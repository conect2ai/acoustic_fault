#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.07417317f, -0.14413099f, -0.22389926f, 0.17720535f, 0.28351748f, 0.09960473f, -0.67636305f, 0.27919146f, 
    0.72875690f, -1.30249238f, -0.66619217f, 0.02865607f, 0.97238797f, -0.92355108f, -1.19123912f, -0.40020493f, 
    -0.32885855f, -0.51663631f, 1.43744338f, -0.25872794f, -0.51664335f, -0.10187568f, 0.01190833f, -0.53598195f, 
    0.22227688f, 0.30077833f, 0.21231279f, 0.60171109f, 1.35661411f, -1.45550835f, -0.39872029f, -0.42781892f, 
    -0.24842367f, -0.28267947f, 0.01298785f, 0.58605701f, -0.55358744f, 0.20728765f, -0.20091692f, -0.41232330f, 
    -0.68217748f, 0.07728288f, 0.59120744f, 0.80651438f, 0.33763734f, -0.47071120f, 0.15589656f, 0.44228283f, 
    -0.32567725f, -0.10819705f, 0.88325578f, 0.93803191f, -0.94978309f, -0.17188367f, 0.22067067f, 0.88707477f, 
    0.56896466f, -0.02626653f, -0.82031697f, -0.87134790f, 0.02104696f, 0.22960865f, 0.65097737f, -1.07266271f, 
    -0.84159261f, 0.16197093f, -0.30398151f, 0.14322388f, 0.47484964f, 0.17584354f, 0.47634000f, 0.66757047f, 
    0.04925096f, 0.16579151f, 0.22343440f, 0.57751125f, 0.94873589f, 0.42625338f, 0.42505702f, -0.04509213f, 
    -0.62598217f, 0.14660533f, 0.81398749f, 0.31178415f, -0.54952508f, 0.33580697f, 0.54851156f, -0.38145337f, 
    -0.72534204f, -0.30665845f, 0.64220846f, -0.33222911f, -0.18647008f, -0.15626298f, 0.60865098f, 1.12223160f, 
    -0.10165349f, 0.48203257f, -0.00325692f, 0.37707379f, -0.68265927f, 0.79930478f, -0.18707314f, 0.48764500f, 
    -0.53893816f, 0.23753461f, 0.56162912f, 0.16100748f, -0.36417529f, 0.66257042f, -0.51670158f, 0.07432614f, 
    0.55599368f, 0.24156238f, 0.80739826f, -0.52902550f, -0.27398071f, 0.22837976f, 0.28720742f, 0.22682807f, 
    -0.78608304f, -0.94224072f, 1.06454945f, -0.07862223f, 0.05169273f, 0.70460743f, 0.19167036f, -0.19233049f, 
    0.00550593f, -1.01644361f, -1.14899290f, -0.95821530f, -0.37956616f, 0.54607779f, -0.75554603f, 0.17427430f, 
    0.45535028f, -0.16120978f, 0.74880695f, -0.55276173f, -0.60041589f, -0.56800795f, -0.75449914f, -0.68543720f, 
    0.67338675f, 0.16396293f, -0.46189111f, 0.50720870f, 0.96627605f, -0.76291955f, 0.23147425f, 0.31536487f, 
    0.52836281f, -0.36570594f, -0.61142200f, -0.48251680f, -0.56765056f, -0.46332866f, -1.16741204f, 0.56508529f, 
    0.36330950f, 0.76113659f, 0.56766045f, 0.42456999f, 0.33132759f, 0.45338112f, -1.06749475f, 0.31578317f, 
    0.13240264f, 0.05675698f, -0.29029399f, -1.22868979f, 1.04748595f, -0.51892668f, -0.25840968f, 0.39910233f, 
    -0.39179194f, 0.42505065f, 0.73103243f, -0.25260416f, -0.04446789f, 0.38337094f, 0.61011189f, 0.01091984f, 
    0.19901218f, -0.65216309f, -0.03503750f, -0.61577874f, 0.86554658f, 1.51883328f, -1.23388851f, -1.06548417f, 
    -0.52767813f, -0.80384922f, 0.82032126f, 0.42112827f, -0.29218021f, -0.14205056f, -1.10781658f, -1.09637320f, 
    -0.96761376f, -0.18711711f, 0.01692072f, 0.30020425f, 0.04258092f, 0.86298031f, -1.19167387f, -1.61556172f, 
    -0.03227454f, 0.29870233f, -0.61358589f, -0.61007744f, 0.65832692f, -0.66360259f, -0.84597552f, 0.34969383f, 
    -0.18888634f, 1.24055707f, -0.80831689f, 0.48917258f, -0.33208600f, -0.47915635f, -0.15066554f, 0.26504987f, 
    0.26571262f, 0.03896538f, 0.17348176f, 0.62345523f, 0.92760271f, -0.63877833f, -0.03996937f, 0.37090829f, 
    0.06386576f, -0.14202003f, -0.71559632f, -1.15128112f, -1.03917837f, 0.31224298f, 0.83331704f, 1.08603108f, 
    -0.31805307f, -0.33533356f, -0.44875619f, -0.93884838f, 1.24070907f, -0.61062503f, 0.79974282f, -0.22926916f, 
    -0.14248008f, -0.09570726f, -0.17685898f, 0.32038486f, 0.49858993f, 0.68338978f, 0.50919539f, 0.45554990f, 
    0.63840270f, 0.43239421f, 0.49721652f, 0.24881673f, -0.15335733f, 0.42702428f, 0.67739511f, -0.03212348f, 
    -0.70544249f, 0.82037538f, -0.37581852f, 0.00037607f, 0.34852585f, 0.57366711f, -0.41170612f, 0.02340650f, 
    -0.14826199f, -1.00935256f, -0.79811430f, -0.76488829f, -0.37536064f, 0.61327958f, 0.82059747f, -1.17762303f, 
    -0.08862792f, 0.63435626f, 1.06642187f, 0.25957942f, -0.19909708f, -0.20583929f, -0.15526178f, -0.43823093f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.45834002f, -0.36581469f, 0.25509432f, -0.07579594f, 0.04942329f, 0.36336035f, -0.11860304f, 0.65134609f, 
    0.01578820f, 0.33438915f, 0.59984171f, -0.16183853f, 0.17438830f, -0.05756237f, 0.33559307f, 0.25481370f, 
    -0.09762067f, 0.02380066f, 0.56126493f, 0.20128563f, 0.41570523f, 0.07802752f, 0.27478445f, 0.39793581f, 
    0.59627020f, 0.61871213f, 0.44370189f, 0.18659531f, -0.12302958f, 0.09440334f, 0.11563168f, 0.20279634f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.18015349f, -0.16373816f, -0.01744355f, 0.00461285f, -0.13146818f, -0.10064733f, 0.24642885f, -0.13444956f, 
    0.06839530f, 0.32139561f, 0.33068201f, -0.24777216f, 0.09475239f, 0.08923817f, 0.08148035f, 0.07585517f, 
    0.11777589f, -0.12893085f, -0.19080339f, -0.08058964f, 0.35628793f, -0.06300322f, 0.05903159f, 0.03231627f, 
    -0.08846725f, 0.07294248f, 0.17687370f, -0.08353000f, -0.07278819f, 0.02024669f, 0.02497886f, 0.32083932f, 
    0.06718177f, -0.00198922f, 0.19954507f, 0.04632711f, 0.08641502f, 0.22462223f, 0.24095912f, 0.05347864f, 
    0.09107691f, 0.06078883f, 0.15278764f, 0.02710082f, 0.08762867f, -0.16993947f, -0.05715028f, 0.10132876f, 
    -0.02984463f, 0.00127040f, 0.18533514f, -0.23544066f, 0.15696952f, -0.13077320f, 0.10892618f, 0.10958559f, 
    -0.03363850f, -0.01463467f, 0.17331953f, 0.10724306f, -0.07478159f, -0.18645427f, -0.14351743f, -0.02736538f, 
    0.11401325f, 0.16666129f, 0.02511814f, -0.29865006f, -0.09439550f, 0.15401866f, 0.03500874f, 0.15533860f, 
    -0.09922263f, -0.02795222f, -0.13618574f, 0.39606288f, -0.03183416f, -0.05824968f, -0.29429191f, -0.07546930f, 
    -0.00652691f, -0.09861392f, -0.21162058f, 0.12254940f, -0.04243404f, -0.01524719f, 0.00219615f, -0.36719051f, 
    -0.22650942f, -0.36515105f, -0.08818004f, -0.26295027f, -0.18460470f, 0.15825689f, -0.11982559f, 0.06728268f, 
    -0.03932170f, 0.08775877f, 0.21044913f, -0.14248070f, 0.01231438f, -0.09186015f, -0.00723295f, 0.10154947f, 
    0.07347953f, -0.01843915f, 0.12282254f, 0.11167418f, -0.08945180f, -0.10766324f, -0.00211529f, 0.20939554f, 
    -0.04413653f, 0.14506197f, -0.16232111f, 0.16264667f, 0.11266399f, -0.05382245f, 0.07208639f, 0.04921967f, 
    0.01278330f, -0.00233433f, 0.07628024f, 0.10129259f, 0.02743256f, 0.19511802f, 0.02065510f, -0.07136680f, 
    0.00753713f, 0.00873323f, 0.07723895f, 0.18103802f, 0.01837597f, 0.00564014f, -0.22975974f, -0.09929235f, 
    -0.24201812f, 0.04450731f, -0.04774683f, 0.04107921f, 0.02349723f, -0.43637922f, -0.38107499f, -0.37281832f, 
    -0.05730205f, -0.17185223f, -0.02803515f, 0.15989533f, -0.02766616f, -0.05643542f, 0.01043416f, -0.12571102f, 
    0.15048197f, 0.28263694f, 0.21058139f, 0.07260137f, -0.10142950f, 0.17070352f, 0.06162163f, 0.11256980f, 
    -0.03389720f, 0.23261261f, -0.17446147f, -0.13143837f, 0.12673870f, -0.11941658f, -0.08599719f, -0.01030166f, 
    -0.07729229f, 0.19276656f, -0.09699532f, 0.02613725f, 0.17816237f, 0.08436815f, 0.02081797f, -0.05879983f, 
    0.02908471f, 0.03689476f, 0.01627356f, 0.07682778f, -0.17824337f, -0.10556734f, 0.04008014f, -0.03307265f, 
    0.04887106f, 0.04658976f, 0.07246891f, 0.04537908f, 0.17752118f, -0.25781775f, -0.21535739f, 0.34040886f, 
    -0.13500077f, -0.24333143f, 0.18092848f, 0.00199957f, -0.06648412f, -0.01851885f, 0.15598601f, -0.02946855f, 
    -0.32678804f, 0.17644672f, 0.02196160f, 0.15025878f, -0.09362020f, 0.07254938f, 0.08272158f, 0.19217660f, 
    0.19691718f, 0.23410377f, 0.18193349f, -0.02030689f, 0.04203844f, 0.01532671f, 0.08183427f, -0.11897384f, 
    -0.14392932f, 0.07378626f, 0.05718537f, 0.06454709f, 0.12094631f, -0.06714826f, 0.15695061f, 0.06340485f, 
    0.15842088f, -0.11468957f, 0.05449399f, 0.11849093f, -0.16377297f, 0.10850394f, 0.09277396f, 0.00151987f, 
    0.09261756f, -0.08368590f, 0.28463155f, -0.15669991f, -0.27490008f, -0.01546198f, -0.25102484f, -0.07424663f, 
    -0.21543142f, -0.06879880f, -0.06043089f, -0.09177773f, 0.06692165f, -0.08301738f, 0.08577267f, 0.11635692f, 
    -0.17304315f, -0.03521721f, 0.07553113f, 0.04858776f, -0.12381618f, -0.07395934f, -0.09229214f, -0.07056975f, 
    0.09475732f, 0.09474697f, -0.09301937f, 0.07710419f, 0.00145352f, -0.06468699f, 0.06955667f, -0.03420490f, 
    -0.04810265f, -0.07913677f, -0.08907831f, 0.30417645f, 0.01486960f, 0.20155120f, 0.32980660f, 0.10661935f, 
    0.12669335f, 0.01830721f, 0.19289291f, 0.05350290f, 0.13837902f, -0.02855338f, 0.11903082f, 0.11924552f, 
    0.20572904f, -0.11452540f, 0.22939432f, 0.01036840f, 0.04470196f, -0.28333452f, -0.09376005f, -0.08179904f, 
    -0.12754476f, 0.06401371f, -0.03959577f, 0.01028464f, 0.11387666f, -0.04260491f, 0.15794621f, 0.16795659f, 
    0.08202863f, -0.77946788f, 0.19246590f, 0.30393761f, 0.01607135f, -0.24932946f, -0.05736631f, -0.05685597f, 
    0.19493072f, 0.03521425f, -0.10433421f, 0.13520104f, -0.23029347f, -0.03482359f, -0.02780558f, -0.21332110f, 
    0.15399474f, -0.18696241f, -0.21588279f, 0.82440686f, -0.10816272f, 0.01312181f, -0.02315138f, 0.10195924f, 
    -0.17394422f, -0.11752921f, -0.16137433f, -0.14128530f, 0.09112069f, -0.37035510f, -0.13130401f, -0.08201224f, 
    -0.10498870f, 0.11785137f, 0.08446167f, 0.00247588f, -0.00902388f, 0.21579403f, -0.15765752f, -0.17685005f, 
    0.24212345f, -0.05771067f, -0.07218561f, 0.13577922f, -0.06472240f, 0.05581525f, -0.42935175f, -0.13373056f, 
    0.36891010f, -0.25496718f, -0.04075366f, -0.23485860f, 0.04079990f, -0.01445558f, 0.15768921f, 0.12884945f, 
    -0.22809477f, -0.01211804f, 0.16479136f, -0.04382298f, -0.03573545f, 0.16280307f, 0.07321982f, 0.08859090f, 
    -0.04693041f, 0.08942242f, -0.07658537f, -0.02177770f, 0.07635365f, -0.23160693f, -0.03072429f, 0.10689879f, 
    0.11172999f, 0.26012978f, 0.01545343f, -0.01864391f, 0.03324547f, 0.07206408f, -0.07583684f, -0.29140157f, 
    -0.02159100f, -0.16743892f, -0.05319719f, 0.04837086f, -0.02242228f, -0.11435816f, -0.03857827f, 0.18791910f, 
    0.08422228f, 0.14412825f, 0.27577558f, 0.09881396f, -0.09842428f, -0.04502361f, 0.00366185f, -0.17584155f, 
    0.38384455f, 0.00269878f, 0.01615433f, 0.04155189f, 0.16813852f, 0.11427117f, -0.17463288f, -0.01009106f, 
    0.25611532f, 0.01926657f, 0.22611740f, 0.13100076f, 0.08937921f, 0.23095697f, -0.46120286f, -0.24899311f, 
    -0.09555264f, -0.07718292f, -0.18452665f, -0.15512823f, 0.24454375f, -0.12886088f, 0.00765813f, -0.15593424f, 
    0.38649917f, -0.06834093f, -0.08404671f, -0.07792616f, 0.02798672f, -0.08366577f, 0.37416768f, 0.17184371f, 
    0.11129099f, 0.10688373f, 0.06102243f, -0.01587475f, 0.13083014f, 0.33968446f, 0.15960670f, 0.13229300f, 
    0.03128895f, 0.07401206f, -0.10489213f, -0.20901240f, 0.08952934f, 0.00698726f, 0.09999866f, 0.16167673f, 
    0.10286407f, -0.18371446f, -0.35961920f, 0.06668318f, -0.00179525f, -0.00842701f, -0.05562885f, -0.00001089f, 
    -0.00373955f, 0.19715607f, 0.02018549f, -0.06176733f, -0.14522380f, -0.01567356f, -0.04143893f, -0.05797372f, 
    0.22804220f, 0.09983650f, 0.09322529f, 0.05388509f, -0.03858129f, -0.00186887f, -0.09529427f, -0.28513366f, 
    0.00505751f, -0.03052723f, -0.01215579f, 0.27279049f, -0.07572258f, -0.16869992f, 0.12635568f, -0.10249843f, 
    0.01284253f, -0.01881711f, 0.02110287f, -0.08618866f, 0.13512358f, 0.02549366f, -0.19815111f, 0.09424754f, 
    -0.06867675f, 0.01727689f, -0.27975443f, -0.14162304f, -0.20581232f, 0.11486233f, -0.35766950f, 0.04319176f, 
    0.01032779f, 0.14841947f, 0.15316620f, 0.23900920f, -0.05702048f, -0.18687692f, 0.10082471f, 0.32508495f, 
    0.05545550f, 0.20140368f, 0.05118353f, -0.10373211f, 0.04859778f, -0.17737226f, 0.09831766f, -0.04380718f, 
    -0.39914456f, 0.01652295f, 0.40151486f, -0.16736256f, -0.07010651f, -0.02534632f, 0.10586891f, -0.12006895f, 
    0.23616080f, -0.02485875f, 0.05306438f, -0.11448023f, -0.16450733f, 0.02397667f, -0.01449693f, 0.24556224f, 
    0.11867910f, 0.07298882f, -0.03984420f, 0.23558208f, 0.02296230f, 0.05577163f, 0.23294319f, 0.02232845f, 
    -0.05476103f, 0.00437540f, -0.02670646f, -0.18951961f, 0.03968961f, 0.10674666f, 0.04975940f, -0.13673311f, 
    0.33516803f, -0.07066052f, 0.05711009f, -0.03990330f, 0.07024734f, 0.03128237f, -0.08758277f, -0.23901631f, 
    -0.55344123f, -0.35384578f, -0.07467411f, 0.19082792f, 0.08416974f, -0.14044017f, -0.08845653f, -0.01804999f, 
    -0.17951876f, -0.09687513f, -0.09100629f, -0.17715998f, 0.23392338f, 0.12388658f, -0.18833947f, -0.14597867f, 
    0.19743717f, -0.07154816f, -0.13185865f, -0.14336576f, 0.05808729f, -0.01441782f, 0.30205142f, -0.36524436f, 
    0.35188803f, -0.09847378f, 0.13777874f, -0.05560179f, -0.14503974f, -0.00412661f, -0.02547929f, 0.01101995f, 
    0.01159357f, -0.06099739f, -0.02993447f, -0.00575852f, -0.05068041f, -0.02922272f, -0.04496028f, 0.00918673f, 
    -0.02478428f, -0.04206683f, -0.02648427f, 0.03488608f, -0.06088685f, 0.04297401f, -0.03314253f, 0.02697177f, 
    0.02632316f, -0.04211212f, 0.01799836f, 0.05051184f, -0.00571854f, -0.02828174f, 0.04562121f, -0.04274093f, 
    -0.02401732f, -0.02082431f, -0.02945100f, -0.03376008f, 0.05951609f, -0.05312878f, 0.01458578f, 0.03065230f, 
    0.01423242f, 0.04209454f, -0.02700053f, 0.02640548f, 0.02064728f, 0.01775834f, 0.00142189f, 0.02811287f, 
    0.05726243f, -0.00035130f, -0.06375048f, 0.03223556f, 0.03073743f, 0.01739147f, -0.01427051f, 0.04734920f, 
    0.00932980f, -0.03377427f, -0.01792374f, 0.00265377f, 0.03378566f, -0.03266548f, -0.02226061f, 0.00117137f, 
    0.02590652f, -0.02725590f, 0.01530549f, 0.00451991f, 0.05113439f, -0.00599029f, -0.00819226f, -0.01370811f, 
    0.02277487f, 0.06082175f, 0.05107224f, -0.04223829f, -0.03913292f, -0.03141836f, -0.02191732f, -0.04240835f, 
    -0.04012004f, -0.06183745f, 0.04461897f, -0.04409046f, -0.02358150f, 0.03719464f, 0.04608501f, 0.02714959f, 
    -0.05691758f, 0.02541244f, 0.00773526f, 0.00870425f, -0.01414758f, 0.01934214f, -0.05060678f, -0.01044090f, 
    -0.03271481f, -0.05794156f, -0.01440142f, 0.05381253f, 0.04810565f, -0.06122233f, 0.00613065f, -0.01748824f, 
    0.00225304f, 0.01257638f, 0.00378059f, 0.02625479f, -0.01647025f, -0.06144573f, -0.02509595f, 0.03344711f, 
    0.00567607f, 0.02105750f, -0.02737598f, 0.03576856f, -0.02193259f, -0.00615772f, 0.04661527f, 0.03482094f, 
    -0.06704988f, 0.02038217f, -0.03836438f, -0.05357154f, 0.00829196f, -0.03186572f, 0.00250188f, -0.03694943f, 
    0.02673768f, -0.02503835f, -0.02243146f, 0.05011762f, -0.04098966f, -0.03049610f, -0.05087909f, -0.01595318f, 
    0.04092110f, -0.06740233f, -0.06499805f, -0.02810280f, -0.02384397f, 0.00353257f, -0.00862631f, -0.00434161f, 
    -0.02400517f, 0.04208703f, -0.01314685f, 0.01311318f, -0.04025234f, -0.05237449f, -0.04644593f, -0.03409299f, 
    -0.04617481f, 0.04837036f, 0.04522407f, 0.02638496f, -0.04813095f, -0.01823248f, -0.00323909f, -0.02847549f, 
    0.04280934f, 0.01679333f, 0.00555841f, -0.03867330f, -0.04724741f, -0.01083106f, -0.04135808f, -0.00117967f, 
    -0.06010116f, 0.01023937f, -0.05312496f, -0.04586469f, 0.00245337f, -0.05217601f, -0.04701446f, -0.02808790f, 
    -0.00700890f, 0.02128964f, -0.04901958f, -0.05959772f, -0.04206458f, -0.04666507f, -0.00874771f, 0.04900449f, 
    0.03721047f, -0.04540472f, 0.02149820f, 0.03992885f, -0.06569172f, -0.06201037f, 0.02715608f, 0.02391236f, 
    0.02620811f, -0.00711526f, -0.06203083f, 0.00851826f, 0.02897080f, 0.03589086f, 0.01483783f, -0.03423926f, 
    -0.02095163f, -0.00987899f, 0.04228022f, -0.04220115f, 0.03373590f, -0.03062491f, -0.00026718f, 0.05885046f, 
    -0.03112342f, -0.03879528f, 0.03367246f, 0.00499642f, -0.04000179f, -0.06526561f, 0.04246909f, -0.05784569f, 
    0.02330972f, 0.03331773f, -0.00263088f, -0.01296875f, 0.01587722f, 0.02196955f, -0.01451398f, 0.02421144f, 
    0.03188156f, 0.03383521f, -0.06565066f, -0.01427584f, 0.05735513f, -0.04687151f, 0.00494939f, 0.04963766f, 
    0.00016497f, 0.00899243f, -0.05245096f, 0.03013130f, 0.00083275f, 0.03456061f, -0.03973160f, 0.03669939f, 
    0.03469803f, 0.01265426f, -0.01726616f, -0.05278268f, -0.05258582f, -0.04618177f, 0.03561953f, 0.04127205f, 
    0.02691370f, 0.01979062f, -0.00686142f, 0.01862249f, -0.06275418f, -0.03301439f, -0.03595980f, -0.02308709f, 
    -0.03440423f, -0.05974028f, -0.04550044f, 0.00491938f, -0.00008669f, 0.01669070f, 0.03640712f, -0.04449090f, 
    0.04889901f, -0.03794804f, -0.05285175f, -0.03654043f, 0.02183266f, -0.04288333f, -0.00330655f, -0.01930409f, 
    0.02217904f, 0.01677322f, 0.05328746f, -0.01912758f, 0.05461949f, 0.04378005f, -0.00811355f, 0.03705792f, 
    -0.03538997f, 0.04939202f, -0.04917425f, 0.03924485f, 0.02171135f, 0.02459263f, -0.03314531f, -0.00151327f, 
    -0.03859386f, -0.04765109f, 0.00420246f, 0.03573357f, 0.00811796f, 0.00762978f, 0.00347643f, 0.03490949f, 
    0.05286914f, 0.20277284f, 0.03192509f, 0.04852867f, -0.01009548f, 0.05843815f, 0.10699501f, 0.13528050f, 
    0.15747686f, -0.00651880f, -0.25323883f, -0.31216592f, -0.00405162f, 0.00817511f, -0.12956326f, -0.10268161f, 
    -0.10781166f, -0.12069849f, 0.34015769f, -0.05609761f, -0.27855983f, -0.00168448f, 0.11715842f, 0.17414297f, 
    0.04110882f, 0.09702849f, 0.24784572f, -0.00265791f, -0.70192963f, -0.00005154f, 0.15906987f, 0.17135742f, 
    0.26658317f, -0.10839585f, 0.20964122f, -0.03246726f, -0.31299827f, 0.09062271f, 0.05134250f, -0.12161661f, 
    -0.05605692f, 0.03669701f, 0.10430182f, -0.02362087f, 0.09467344f, -0.05922984f, 0.22791311f, 0.11050880f, 
    0.05367485f, -0.10111481f, -0.04779211f, 0.20536163f, -0.15144745f, 0.30885905f, -0.06924224f, -0.52781606f, 
    -0.06645513f, -0.03139428f, 0.03988843f, -0.06073460f, 0.05942016f, 0.11584527f, -0.01981431f, -0.13918152f, 
    0.09519553f, 0.10202564f, 0.02534625f, 0.21481499f, 0.18831891f, 0.04722996f, 0.15067320f, 0.12575670f, 
    0.00389174f, 0.04708913f, -0.00835420f, 0.32656991f, -0.00996829f, -0.05739380f, -0.12711801f, -0.21246181f, 
    0.03954668f, -0.00353424f, 0.04832585f, -0.06157620f, -0.04643692f, -0.08519061f, -0.02825779f, -0.02861030f, 
    -0.14409645f, 0.02984495f, 0.21996906f, 0.08116635f, -0.03651518f, 0.00031871f, -0.03838083f, 0.18375137f, 
    -0.01197391f, -0.12739712f, 0.08112935f, 0.01019369f, 0.07801950f, 0.01960905f, 0.12048296f, 0.18048953f, 
    0.20757651f, -0.09326515f, 0.17641912f, 0.20494786f, -0.06114806f, 0.11805481f, 0.05636861f, 0.25081992f, 
    -0.20875975f, 0.25806177f, 0.10429700f, -0.22198448f, 0.11401487f, 0.25936228f, -0.02987822f, 0.28173721f, 
    -0.08600859f, 0.16074400f, 0.07897406f, 0.15995122f, -0.01683053f, 0.06585740f, -0.05525243f, -0.57478595f, 
    -0.65480930f, 0.03871985f, 0.24825880f, 0.06107968f, 0.15055540f, 0.07377759f, 0.20267659f, -0.05415609f, 
    -0.03331071f, 0.02994733f, 0.00180440f, 0.16274630f, 0.00631454f, 0.11231336f, -0.17789000f, -0.30958813f, 
    -0.04093545f, -0.11662146f, -0.11959725f, 0.07816893f, 0.20260456f, 0.06645425f, -0.03875393f, 0.16144550f, 
    0.22970472f, -0.09340627f, 0.14973277f, -0.05797256f, -0.11380198f, 0.11725522f, -0.00756025f, 0.07146862f, 
    0.11400045f, 0.06909081f, 0.22425503f, 0.04321368f, 0.21105611f, 0.02904968f, 0.23829851f, 0.06367009f, 
    0.32738334f, 0.37165201f, 0.10524482f, -0.45847878f, 0.09600960f, 0.32994962f, -0.09101882f, 0.13187100f, 
    0.00889929f, 0.14230648f, 0.19298321f, 0.17132063f, 0.12006228f, -0.00192464f, 0.22375713f, -0.03424147f, 
    0.11245234f, 0.00481610f, 0.33926681f, 0.32640412f, 0.12838574f, 0.11821560f, 0.18929437f, -0.11287331f, 
    -0.04565104f, 0.13520209f, -0.11172909f, -0.04692181f, -0.03674677f, -0.07676948f, -0.28146064f, -0.11414528f, 
    0.21048714f, -0.09353922f, 0.04340009f, -0.04403542f, 0.09669442f, 0.06622555f, 0.07269069f, -0.11389536f, 
    0.08699927f, 0.33957344f, 0.02753884f, 0.07472594f, 0.07216273f, 0.10618176f, 0.00437381f, 0.28450668f, 
    -0.07441202f, -0.00556559f, 0.37396696f, 0.33001298f, 0.21954401f, 0.27389249f, 0.28646639f, 0.31809235f, 
    0.02535866f, 0.12933035f, 0.12790382f, 0.11722178f, 0.21020630f, 0.22311029f, -0.13239537f, 0.15468247f, 
    0.15897648f, 0.16305879f, -0.12794028f, -0.13160032f, -0.25005805f, 0.05923266f, -0.01224735f, -0.36076346f, 
    -0.11352545f, -0.09592845f, -0.05032285f, -0.00001336f, 0.23912045f, 0.33162192f, 0.18828739f, -0.10973641f, 
    -0.08411396f, 0.20109695f, -0.09599081f, -0.17090361f, 0.09091208f, 0.00775375f, 0.04578179f, -0.04592757f, 
    -0.09063601f, -0.10564601f, -0.15630676f, -0.02876194f, 0.04740969f, 0.19262078f, -0.14251545f, -0.01358383f, 
    0.06092196f, 0.15611212f, 0.10528455f, 0.03140987f, 0.06420589f, 0.19381878f, -0.21616244f, -0.23481478f, 
    -0.30262917f, 0.23705626f, 0.07826561f, 0.05976240f, 0.18601803f, 0.08940794f, 0.10743973f, 0.11793907f, 
    -0.09797590f, 0.03718805f, 0.10205314f, 0.12594630f, 0.14756705f, -0.09509356f, -0.11291181f, -0.25260669f, 
    -0.20248009f, -0.32507998f, -0.19209495f, 0.02578080f, 0.06483655f, -0.00719928f, 0.01698308f, 0.10871234f, 
    -0.04418023f, 0.07894580f, 0.47447607f, -0.09886546f, 0.00119373f, -0.04881017f, -0.04505705f, -0.10114134f, 
    -0.04161011f, 0.03173634f, -0.55871952f, 0.12716669f, 0.07082456f, -0.03464680f, -0.14205879f, 0.00933835f, 
    0.01053814f, -0.08125907f, 0.06499635f, 0.40242252f, 0.32496026f, 0.10438602f, -0.29414114f, 0.43250936f, 
    0.03442070f, 0.10539778f, 0.06516237f, -0.25501609f, 0.20060103f, 0.16250932f, 0.04856651f, 0.04890951f, 
    -0.10803313f, 0.09197843f, -0.28566176f, -0.19722039f, -0.21183640f, 0.09613822f, -0.32252309f, 0.10589068f, 
    0.09779151f, -0.15570427f, -0.15139772f, -0.12655720f, 0.02133976f, 0.29005411f, -0.11920317f, -0.23246510f, 
    0.35751897f, -0.32661471f, 0.05703971f, 0.00106098f, 0.16597034f, 0.01485014f, 0.09407446f, 0.10786419f, 
    -0.08062355f, 0.03207597f, 0.25115573f, -0.07742504f, 0.13789228f, 0.12688158f, 0.15962659f, -0.23664458f, 
    -0.21373945f, -0.44545165f, 0.31280130f, 0.12579262f, -0.04006593f, -0.15502866f, -0.07745529f, -0.16987173f, 
    0.07400113f, 0.06170203f, -0.56065154f, -0.16082050f, 0.28717238f, -0.14286318f, -0.11058693f, 0.03181227f, 
    -0.00588123f, -0.10524199f, -0.24938415f, -0.84022093f, -0.35922113f, 0.04028524f, 0.08863905f, 0.00056265f, 
    0.07320923f, 0.31355226f, -0.07828494f, 0.04794402f, 0.30518582f, 0.46642825f, 0.18645339f, 0.04257872f, 
    0.20805831f, 0.01199883f, 0.01326180f, 0.13226686f, -0.09710106f, -0.32727244f, 0.31328705f, 0.08148147f, 
    -0.08399850f, 0.20498191f, 0.22973853f, 0.13005054f, 0.00566096f, -0.23346861f, -0.33951056f, -0.22612756f, 
    0.03740645f, -0.07219908f, -0.05862374f, 0.11059640f, 0.26230302f, 0.04265116f, -0.14022705f, 0.16654755f, 
    0.24765407f, 0.02347367f, -0.08312366f, -0.19103415f, -0.11228259f, -0.02629821f, 0.14340708f, 0.18524627f, 
    0.08350017f, -0.01293093f, -0.15768731f, -0.05203739f, 0.01951014f, -0.17050299f, 0.03133520f, -0.16901529f, 
    -0.18904702f, -0.11001576f, -0.03853881f, 0.01803626f, -0.03174678f, -0.06150325f, -0.02420806f, -0.09234495f, 
    -0.09277805f, 0.30252978f, 0.19426179f, 0.01323082f, 0.11986804f, -0.27107114f, 0.12122826f, -0.07104411f, 
    -0.07095139f, -0.11684796f, -0.69401258f, -0.73857558f, -0.15518795f, -0.10629839f, -0.16350293f, -0.02547557f, 
    0.17531759f, 0.17459524f, -0.12924258f, 0.35526249f, 0.35589695f, -0.07996470f, 0.07070874f, -0.11399093f, 
    0.11438770f, -0.25615504f, 0.16597652f, -0.18978238f, -0.01172047f, -0.39799976f, 0.15746562f, 0.02889370f, 
    -0.22691898f, -0.03718551f, 0.08848555f, -0.03343298f, 0.08175565f, -0.20349564f, 0.19815454f, 0.19929968f, 
    0.06432295f, 0.01246078f, -0.00300802f, -0.11196797f, -0.06477408f, -0.02127603f, -0.00372183f, -0.28561029f, 
    -0.13343589f, 0.24254364f, 0.14706191f, -0.03293541f, 0.06489484f, 0.17957358f, 0.06349129f, 0.40482208f, 
    0.13567144f, 0.00019682f, 0.22824655f, -0.12679130f, -0.01405893f, 0.04008089f, 0.02809792f, -0.04396011f, 
    -0.04486069f, 0.04594612f, 0.06855008f, -0.30215153f, 0.13381431f, -0.13846454f, 0.08235236f, 0.18580920f, 
    -0.12473770f, -0.26817867f, -0.08322585f, -0.11242572f, 0.01516251f, 0.01943419f, 0.08814102f, 0.10273174f, 
    -0.06366937f, 0.28132588f, 0.04923096f, -0.08571541f, -0.11878259f, 0.31245905f, 0.26146773f, 0.03127831f, 
    -0.11176453f, 0.18461096f, 0.05765392f, -0.17244089f, -0.21415652f, -0.26749212f, -0.18255536f, 0.18005750f, 
    0.28433430f, 0.10148196f, 0.33559880f, -0.07951792f, 0.01775206f, -0.51395953f, -0.30456594f, 0.07071044f, 
    -0.13932958f, -0.12986831f, -0.05074641f, 0.11430712f, 0.10184344f, -0.26542974f, -0.43380222f, 0.03463781f, 
    -0.09589089f, -0.10453136f, 0.03928868f, -0.13749637f, -0.11557598f, 0.21078239f, 0.46670368f, 0.25128308f, 
    0.31604716f, 0.03890327f, -0.06976831f, -0.03651205f, -0.00332758f, -0.25466201f, 0.09984127f, 0.08288814f, 
    0.61162972f, -0.19399317f, -0.00194098f, 0.16021448f, 0.04822155f, 0.04288489f, 0.11300697f, -0.03805569f, 
    -0.24602640f, 0.02879273f, 0.14894721f, 0.03067733f, 0.11126035f, 0.02902692f, -0.26449090f, -0.16403830f, 
    -0.04607775f, 0.43332890f, -0.00828938f, -0.04719211f, 0.26430583f, 0.24561617f, 0.13854490f, -0.11853389f, 
    -0.02110895f, 0.02293903f, -0.11970828f, 0.11536613f, -0.16348755f, 0.14409941f, -0.04785129f, -0.02106754f, 
    0.00053265f, -0.01250160f, -0.07976861f, -0.25595054f, 0.18855962f, -0.05903668f, 0.06574226f, -0.04208659f, 
    -0.09534654f, 0.14281529f, 0.00413184f, -0.02135618f, 0.21307454f, -0.01424358f, 0.01397846f, 0.07395779f, 
    0.05118305f, -0.06082461f, -0.26687166f, -0.51868147f, -0.11714964f, 0.21204306f, 0.16155215f, 0.01696556f, 
    0.06058740f, 0.16043998f, -0.09349913f, 0.24544393f, -0.10033120f, -0.11001062f, 0.26240391f, 0.17176747f, 
    -0.28045487f, -0.01678511f, -0.38030326f, -0.23875365f, 0.04680501f, 0.11270914f, 0.13276458f, -0.12513450f, 
    -0.24618295f, -0.04895240f, -0.10232227f, 0.04340312f, 0.17084131f, -0.11639927f, -0.28694123f, -0.00331910f, 
    -0.18532757f, -0.01059754f, 0.09948506f, 0.03673423f, -0.03553534f, 0.09785237f, -0.08665394f, -0.08428521f, 
    -0.23292060f, 0.01210079f, 0.21969646f, -0.17540680f, 0.09132422f, -0.11066536f, 0.12042914f, 0.02436784f, 
    0.23662935f, 0.18172508f, -0.18932812f, 0.09632152f, 0.03658314f, 0.01396051f, 0.08864947f, 0.05459109f, 
    0.03312251f, -0.09298187f, -0.13386151f, 0.08760439f, -0.07320009f, -0.42842206f, 0.03176246f, 0.18105078f, 
    0.24286701f, -0.13589689f, -0.31728807f, -0.32018080f, 0.01158696f, 0.11391056f, -0.06431509f, -0.02694939f, 
    -0.01011255f, -0.00617183f, -0.01445383f, -0.17784372f, -0.23002505f, 0.01942929f, 0.52077496f, 0.03947463f, 
    0.07141605f, 0.04468264f, -0.08654682f, 0.00288886f, -0.02832020f, 0.13808730f, 0.21399321f, 0.30075431f, 
    -0.14590782f, 0.17000698f, -0.00415692f, -0.06690926f, 0.02018565f, -0.04878403f, -0.03451224f, 0.20811218f, 
    0.21715777f, 0.13496266f, 0.04847056f, -0.01622931f, -0.01721716f, 0.03107347f, 0.17712063f, 0.06431586f, 
    -0.09984249f, -0.01452796f, -0.05082386f, 0.15610173f, 0.18680373f, 0.11317820f, -0.05011428f, -0.26225877f, 
    -0.30210328f, 0.30428857f, 0.04907168f, -0.12879698f, 0.15950415f, 0.06286259f, -0.01245830f, -0.20123564f, 
    -0.06655902f, -0.21714051f, 0.24153243f, 0.20187950f, -0.18815233f, 0.07370038f, 0.04687449f, -0.04536359f, 
    0.08079958f, 0.02675809f, -0.08079366f, -0.10072622f, -0.07006862f, -0.35721329f, 0.04950986f, -0.04515312f, 
    -0.07069726f, -0.00221129f, -0.25397074f, -0.37557733f, 0.22550830f, 0.05998068f, -0.19837141f, -0.08339622f, 
    -0.11233445f, 0.12150592f, 0.03995341f, -0.00207710f, 0.06226304f, 0.12005404f, 0.43061209f, -0.27061304f, 
    0.25492111f, 0.02889691f, -0.12623392f, 0.09364374f, 0.19030885f, 0.02393782f, -0.05733955f, -0.18352085f, 
    0.07577879f, 0.23432848f, 0.13174817f, 0.26505297f, 0.14643037f, -0.02239678f, -0.03971356f, -0.09667357f, 
    0.09245577f, 0.00732887f, 0.24393758f, -0.14046369f, 0.21396588f, -0.01758481f, -0.00254301f, 0.07798047f, 
    0.04752761f, 0.10695170f, -0.12174807f, 0.03726019f, -0.04232536f, -0.08751053f, -0.01349444f, -0.01345407f, 
    -0.02942405f, 0.12372788f, 0.00278579f, -0.14536810f, 0.04910621f, -0.03924939f, 0.08977292f, 0.01508453f, 
    -0.00179025f, -0.11778045f, -0.26086497f, -0.16845062f, 0.16899778f, -0.03624468f, 0.13514298f, 0.09006415f, 
    0.29493371f, 0.25510085f, 0.01890979f, -0.12176461f, 0.03566640f, -0.12166280f, 0.03437063f, 0.14905965f, 
    0.04038059f, -0.02949268f, -0.08583853f, -0.01510047f, 0.00160688f, 0.02689888f, 0.14967206f, 0.04628991f, 
    0.02249019f, 0.18548851f, 0.00968416f, -0.04766299f, 0.07785716f, -0.25504914f, 0.13925064f, -0.05440674f, 
    0.06890111f, -0.03817281f, 0.17946224f, 0.07505908f, -0.28033680f, -0.17479318f, 0.13214073f, 0.16499473f, 
    -0.16133283f, 0.00245061f, -0.00230732f, 0.04465324f, -0.19385624f, -0.14186923f, -0.06441034f, -0.08313828f, 
    -0.22540477f, -0.04220174f, -0.11574346f, -0.00853269f, 0.19930553f, 0.26262918f, 0.02393965f, 0.04392353f, 
    0.04075396f, -0.06548683f, -0.03003303f, -0.03247593f, -0.03285655f, 0.02063472f, -0.04543086f, 0.01611151f, 
    -0.01166531f, 0.03383347f, -0.00289059f, -0.02087073f, -0.05004755f, 0.02423148f, -0.04712143f, 0.03836931f, 
    0.00569750f, 0.00243759f, 0.01836404f, -0.00459618f, -0.03854662f, 0.01902248f, -0.02440291f, -0.03964006f, 
    0.02619003f, -0.00165639f, 0.01680267f, 0.00149328f, -0.04332003f, -0.06056049f, 0.02376067f, 0.02568579f, 
    -0.02323617f, 0.04458348f, 0.00017474f, -0.04340847f, -0.05361727f, 0.04568576f, 0.01761717f, -0.03228942f, 
    -0.03338169f, -0.01887526f, -0.00793043f, -0.04262040f, -0.03989226f, 0.01026676f, -0.06550812f, 0.02734994f, 
    0.03453990f, -0.00936721f, 0.00478902f, 0.01435618f, -0.04071004f, 0.03167791f, 0.01897568f, -0.05313390f, 
    0.06383998f, 0.01411529f, -0.04133067f, -0.01432774f, 0.02320750f, -0.05131415f, -0.04320349f, 0.00495005f, 
    -0.01351444f, -0.01325361f, -0.04589136f, -0.03607687f, -0.00913272f, 0.05002432f, 0.01444923f, -0.03267657f, 
    -0.06437895f, 0.02592403f, -0.02085542f, 0.03901200f, -0.03355427f, 0.04621097f, 0.01560821f, 0.03513313f, 
    -0.03975380f, -0.02597439f, -0.05292133f, -0.06729086f, -0.01211464f, -0.02423127f, -0.06208657f, 0.03148782f, 
    0.00092929f, -0.05199948f, 0.01981308f, 0.02472821f, -0.01839716f, -0.06678066f, -0.06030923f, -0.03961134f, 
    -0.05576055f, -0.01596587f, -0.06345709f, 0.00028182f, 0.03537479f, -0.00363594f, -0.05548041f, -0.00881417f, 
    0.05040856f, -0.03334543f, -0.00239943f, -0.05237816f, 0.04598279f, 0.01170153f, -0.02333197f, 0.04502665f, 
    -0.02812419f, 0.03937050f, 0.03689956f, -0.06411678f, 0.03899958f, 0.03246881f, -0.00502294f, -0.03285447f, 
    0.01478769f, -0.02211261f, 0.02724566f, -0.03500017f, 0.04905314f, -0.04422665f, 0.03899394f, 0.02561943f, 
    0.03693664f, -0.02413283f, -0.02632906f, -0.06090957f, 0.01607526f, -0.03063967f, 0.00020253f, 0.01136808f, 
    -0.06938158f, -0.04389587f, -0.04276953f, -0.02357114f, -0.06402602f, -0.05937874f, -0.03585576f, -0.01668271f, 
    -0.01563894f, 0.03705034f, -0.04740097f, 0.01150875f, 0.04249402f, 0.04606903f, -0.01608550f, 0.00801720f, 
    -0.05147521f, -0.04732955f, -0.02007637f, 0.04140427f, -0.02746532f, -0.05251548f, -0.04381492f, 0.00724843f, 
    -0.02385379f, 0.01959626f, -0.02638587f, -0.05831448f, -0.00646730f, 0.00520623f, -0.01607208f, 0.01185874f, 
    0.00593491f, 0.00972583f, -0.00623407f, 0.04527890f, 0.04264973f, -0.03028165f, -0.00051909f, 0.02774159f, 
    0.04113044f, 0.03370261f, 0.01753206f, -0.04075197f, 0.01576521f, 0.04011000f, 0.04034589f, -0.01086781f, 
    -0.01416930f, 0.04456023f, -0.03815801f, -0.00724464f, 0.01288807f, -0.03108509f, -0.01361509f, -0.05117626f, 
    -0.05725274f, -0.00829529f, 0.01286981f, -0.05626138f, -0.01590142f, -0.00524852f, 0.00596310f, 0.00045740f, 
    0.03738993f, -0.03007283f, -0.06491605f, 0.04110867f, -0.00986248f, -0.00833919f, 0.02336404f, 0.03855230f, 
    0.01503429f, -0.01798442f, -0.02983664f, 0.00393707f, -0.03059413f, 0.01424294f, -0.03631229f, -0.04992456f, 
    0.01125105f, -0.03162624f, -0.00764501f, 0.02217022f, -0.02180193f, 0.00466922f, -0.00527236f, 0.01768810f, 
    0.04030889f, 0.03609003f, -0.04273643f, -0.06878000f, -0.05909308f, 0.03462129f, 0.02984605f, -0.01745967f, 
    -0.00459699f, 0.01910414f, -0.00852419f, 0.00505839f, 0.01315791f, -0.00545766f, -0.04603697f, -0.01504734f, 
    0.00052761f, -0.00087339f, -0.02442209f, -0.05373675f, 0.03282148f, 0.01141845f, -0.00507345f, -0.05568627f, 
    -0.01104225f, -0.03474272f, 0.00583139f, 0.02679317f, -0.04936362f, -0.00844981f, 0.01009112f, -0.06133182f, 
    0.03360284f, 0.02009462f, -0.01528448f, -0.00712728f, -0.00336783f, 0.00831591f, -0.05217100f, -0.04297628f, 
    0.01440353f, -0.06508324f, 0.04929389f, -0.02277127f, -0.05671540f, 0.00023283f, 0.01804940f, -0.06498356f, 
    -0.02561508f, 0.00046835f, 0.02082388f, -0.02706847f, -0.00994954f, -0.06161378f, 0.02849892f, -0.03430196f, 
    0.02268836f, -0.06610184f, 0.03502170f, 0.00086121f, -0.06170461f, 0.03447173f, -0.05802728f, 0.00234214f, 
    0.01303883f, 0.03749916f, 0.04627436f, 0.05019241f, -0.02454655f, -0.04328521f, 0.26839563f, 0.10738526f, 
    -0.02216569f, -0.32350957f, -0.45836714f, -0.35072288f, -0.23636363f, -0.18838258f, -0.02417469f, -0.01288923f, 
    0.08078069f, 0.11001979f, 0.33414972f, 0.20072359f, -0.22279009f, -0.04259811f, 0.07453759f, -0.01289151f, 
    0.00876422f, -0.06870147f, 0.00159260f, 0.53266627f, -0.34760895f, -0.51503283f, -0.16983347f, 0.21166493f, 
    -0.19661283f, 0.25640869f, -0.19549678f, -0.09045162f, -0.01430407f, 0.09826797f, -0.10993911f, -0.10506050f, 
    -0.14212096f, -0.29616839f, -0.15787697f, -0.32666710f, -0.22726545f, -0.06652170f, 0.16953140f, 0.09576296f, 
    0.04673330f, 0.03808979f, 0.11308404f, 0.26188096f, 0.18025126f, 0.11718553f, 0.18589178f, -0.37405556f, 
    -0.44480380f, -0.16992123f, 0.18502653f, -0.28528395f, 0.09437905f, -0.00685142f, -0.11849583f, -0.25485924f, 
    0.35264209f, 0.31355387f, 0.01090402f, 0.03590404f, -0.23105058f, -0.08450227f, -0.03407246f, -0.10556734f, 
    0.03097267f, 0.16772372f, 0.13986714f, -0.01460466f, -0.12846100f, -0.10849507f, 0.32629663f, 0.22993039f, 
    0.23622455f, -0.00570931f, -0.01771631f, -0.28727457f, 0.08028600f, -0.00712612f, 0.01307219f, 0.07683726f, 
    0.13147341f, 0.03828392f, 0.04930326f, 0.19781494f, 0.10472157f, -0.01611596f, -0.02052417f, 0.01544038f, 
    0.23078039f, 0.14613719f, 0.04873493f, -0.01564068f, -0.26178503f, -0.18490465f, 0.03688666f, -0.11557069f, 
    0.03756540f, -0.11165820f, -0.09188352f, -0.37516272f, 0.01856225f, 0.05910560f, 0.26866740f, 0.02979186f, 
    -0.06646233f, 0.02997253f, 0.22729386f, 0.02047355f, 0.08123233f, 0.02675512f, -0.15850602f, -0.12363831f, 
    -0.22843120f, 0.17533344f, -0.07228385f, -0.09579343f, -0.05971806f, -0.35333121f, -0.14606093f, -0.38634205f, 
    -0.56526160f, -0.15457699f, 0.12476557f, -0.24481602f, -0.01179202f, 0.04757576f, 0.13098872f, -0.07809597f, 
    -0.18408820f, 0.17543891f, 0.07081053f, 0.10872523f, 0.12580931f, 0.10781997f, 0.14862344f, 0.12670422f, 
    0.09216887f, -0.02978249f, -0.12208032f, 0.09481384f, -0.09669944f, 0.02628827f, 0.03033631f, -0.04434482f, 
    -0.10559025f, -0.44608414f, 0.01697039f, -0.19198036f, -0.10695579f, -0.45306712f, -0.22076412f, -0.01048829f, 
    -0.01574685f, -0.23272464f, 0.21354754f, 0.03274646f, 0.25568709f, 0.10787873f, 0.20465733f, 0.11865331f, 
    0.11908142f, -0.06292924f, -0.09575301f, -0.44328332f, -0.12047204f, 0.16254815f, 0.25948963f, -0.15129113f, 
    -0.16409880f, 0.04642532f, -0.03746935f, -0.20423704f, 0.03019336f, -0.15662619f, -0.12443125f, 0.18066743f, 
    0.09781475f, 0.10985996f, 0.03733511f, 0.02915371f, -0.12780748f, -0.06866038f, -0.04040936f, -0.30889809f, 
    -0.03699274f, -0.24484619f, 0.06233935f, 0.04783799f, 0.10987557f, 0.08090642f, -0.14568521f, 0.04337218f, 
    0.51761204f, 0.31454447f, 0.18256515f, -0.07763699f, -0.00028946f, 0.12514131f, 0.20691201f, -0.11680251f, 
    -0.19213805f, -0.05974763f, -0.01620043f, -0.01733946f, 0.12171156f, -0.14555290f, 0.06564112f, 0.06819021f, 
    0.28465807f, -0.17270964f, -0.07137842f, 0.15360351f, 0.04822383f, -0.11619192f, 0.34643903f, -0.10785718f, 
    0.11559421f, 0.07367437f, -0.11848823f, 0.06933630f, 0.00897618f, 0.11595082f, 0.11241244f, 0.18034959f, 
    -0.07248015f, -0.07082906f, 0.11677326f, 0.54661036f, 0.61763179f, -0.18140528f, -0.01066898f, -0.20044862f, 
    0.16780734f, 0.16485193f, 0.41951782f, -0.30469885f, -0.21650402f, 0.00284949f, 0.03828203f, 0.00498055f, 
    -0.09174222f, 0.39399466f, 0.16628172f, -0.04949971f, -0.03348422f, -0.19026579f, -0.07070339f, 0.06746063f, 
    0.04701338f, 0.05337576f, 0.17309904f, 0.09419498f, -0.12907423f, 0.16770627f, -0.00563118f, -0.17104994f, 
    0.17455658f, 0.11416402f, 0.12483373f, 0.02537086f, -0.20261726f, -0.34030309f, -0.39618397f, -0.29998085f, 
    -0.52833182f, -0.22398561f, -0.34440854f, -0.41770881f, -0.17428106f, -0.13452478f, -0.07477249f, -0.27136648f, 
    0.19193986f, 0.29165450f, -0.16271655f, 0.08907855f, -0.05024011f, 0.13919038f, 0.35065269f, 0.31829897f, 
    0.04724786f, -0.03590701f, 0.04983488f, 0.10780541f, 0.05766099f, -0.42996800f, 0.11945883f, 0.02182624f, 
    0.11252758f, 0.14235710f, 0.25890711f, 0.22264440f, 0.04240139f, -0.12004078f, 0.11155514f, 0.09106536f, 
    -0.18825974f, -0.08572396f, -0.04064158f, -0.16360496f, -0.22412026f, -0.06311332f, 0.15858884f, -0.12184620f, 
    0.02902965f, -0.04126951f, 0.13257866f, -0.05839724f, 0.04254442f, -0.41686326f, 0.02322757f, 0.18863724f, 
    -0.22873421f, -0.06672922f, -0.06177484f, -0.10469560f, 0.02435637f, 0.09672901f, 0.19398570f, -0.14798252f, 
    -0.00213712f, -0.16174354f, 0.06151251f, 0.16777089f, 0.06718923f, -0.06741246f, 0.06019797f, 0.04681035f, 
    0.15023121f, -0.14642200f, 0.04910338f, -0.14713490f, -0.22163101f, 0.08862971f, -0.33568096f, -0.59078699f, 
    -0.28058922f, 0.08492224f, 0.14563699f, -0.08627469f, -0.00274196f, 0.19119854f, -0.11910818f, 0.15836273f, 
    0.05449669f, 0.05342961f, 0.17465861f, -0.08714315f, -0.14467762f, 0.07211817f, 0.05504578f, 0.01105742f, 
    0.05475682f, 0.06826027f, -0.01084311f, 0.06008017f, -0.00456028f, 0.03621620f, -0.12912533f, -0.00465569f, 
    -0.11083771f, 0.11014437f, -0.05126768f, 0.02695344f, 0.06970136f, 0.04075296f, 0.02508034f, -0.30164596f, 
    -0.50395018f, -0.22307053f, -0.06935404f, -0.01114106f, 0.10132421f, -0.02860508f, -0.15959753f, 0.07477336f, 
    0.03909898f, -0.07138234f, 0.04886666f, 0.19894572f, 0.15147363f, -0.18768224f, -0.08720587f, 0.02564783f, 
    0.04504821f, 0.09979407f, -0.04181015f, -0.03174500f, 0.14227214f, 0.05978021f, -0.02866888f, 0.21044256f, 
    0.16406253f, -0.12409553f, 0.00912385f, -0.08097335f, 0.14818557f, -0.04853542f, -0.06224268f, 0.23895194f, 
    -0.08814520f, 0.01045766f, -0.12388295f, -0.22960855f, -0.15739712f, 0.10385394f, 0.33768463f, 0.44818580f, 
    0.04544702f, 0.10444646f, 0.01166082f, 0.11278444f, -0.01239491f, 0.07106797f, -0.16961412f, 0.01436581f, 
    -0.02790461f, 0.16439481f, 0.12014598f, -0.13534728f, 0.07440615f, -0.02319305f, -0.11884764f, -0.49912611f, 
    0.12198097f, 0.15888378f, 0.09369054f, -0.02134079f, -0.04778882f, -0.06236166f, 0.04284767f, -0.06981415f, 
    0.10157856f, 0.17264469f, 0.18858777f, 0.25915247f, -0.10563389f, 0.11575782f, -0.06642722f, 0.16536605f, 
    0.11690401f, 0.07987998f, 0.23916645f, -0.05697064f, 0.03092799f, -0.02865467f, 0.00951834f, -0.01170069f, 
    -0.10356310f, -0.00762268f, -0.13114285f, -0.12537335f, 0.05358363f, 0.13078654f, -0.08394160f, 0.00158659f, 
    0.14692144f, 0.24416998f, 0.27955464f, -0.02306379f, -0.21781543f, -0.14358920f, 0.03199067f, 0.09602890f, 
    0.03179425f, -0.01406948f, -0.19308850f, -0.00141297f, -0.16647777f, 0.29871541f, 0.00234840f, -0.42239985f, 
    0.08986162f, -0.30919820f, -0.00693702f, -0.07134494f, 0.17973754f, 0.19878553f, 0.26223794f, 0.27936435f, 
    -0.08321735f, 0.06025908f, 0.01588388f, 0.03172899f, -0.06064802f, -0.06708358f, -0.04321558f, 0.00692866f, 
    0.15494858f, 0.32424986f, -0.07703846f, 0.08529969f, 0.03607364f, 0.08229986f, -0.11384170f, -0.08696900f, 
    -0.12123986f, -0.11522987f, -0.17915046f, -0.14135934f, 0.05579080f, -0.04772878f, 0.25885594f, 0.11776824f, 
    0.08098226f, 0.01567245f, 0.03767377f, 0.05079227f, -0.03422482f, -0.00678716f, -0.08558760f, 0.05228377f, 
    0.06656174f, -0.15168515f, -0.06243112f, -0.27641937f, -0.33551043f, -0.00380619f, 0.04034201f, 0.17492363f, 
    -0.10329174f, -0.07650580f, -0.10959510f, -0.06597725f, -0.02405185f, -0.07506033f, -0.12203804f, -0.01759926f, 
    0.09735994f, 0.01450826f, -0.14090714f, 0.08558992f, 0.14977123f, 0.17050184f, 0.04021982f, 0.16443649f, 
    -0.01965300f, -0.08834425f, -0.03908586f, 0.02731848f, -0.16402104f, -0.08357303f, 0.01984706f, 0.02196936f, 
    0.15335107f, 0.21280473f, -0.24735329f, 0.18627951f, 0.20876455f, 0.05563066f, 0.13418390f, 0.27032846f, 
    0.41878513f, 0.07059562f, 0.11565854f, -0.06344745f, 0.08127701f, 0.17451340f, 0.01836621f, -0.50949180f, 
    -0.20865984f, -0.00098905f, 0.03449083f, 0.10972945f, 0.22469756f, -0.20164780f, -0.22950208f, -0.20658489f, 
    0.16699873f, 0.10953182f, -0.08315749f, 0.08785875f, 0.02248663f, -0.07288840f, 0.07431850f, -0.04025911f, 
    -0.19312164f, -0.44199234f, -0.39433527f, 0.68829584f, -0.10115245f, -0.00701914f, -0.25150117f, -0.10792553f, 
    0.15427697f, 0.09034265f, 0.54151517f, 0.11748141f, -0.06484930f, 0.05208049f, 0.01763890f, 0.21772827f, 
    -0.05233983f, -0.11940226f, -0.02296101f, 0.31037632f, 0.38423091f, -0.41958266f, -0.04912650f, -0.16219579f, 
    0.56179571f, 0.01046375f, 0.03752781f, -0.17728755f, -0.06358159f, -0.15218773f, 0.10633854f, 0.11192356f, 
    0.04874852f, -0.05214365f, -0.03701507f, -0.10134726f, -0.11827248f, 0.02716500f, 0.38219634f, 0.32635853f, 
    -0.17340945f, -0.06591899f, -0.19623491f, -0.11542945f, 0.02063180f, 0.29139823f, 0.02045890f, 0.19219145f, 
    -0.10574564f, -0.07360331f, -0.00900086f, -0.16660546f, -0.02687218f, 0.13576549f, 0.10270077f, -0.28717756f, 
    0.10651594f, -0.12048686f, 0.08341067f, 0.08342611f, -0.02894678f, 0.07008733f, 0.09024952f, -0.05337057f, 
    0.14084722f, 0.04246680f, -0.06699093f, -0.08836211f, -0.20698430f, -0.18086699f, -0.08430405f, -0.08124296f, 
    0.08554522f, 0.00570159f, 0.06030287f, 0.14166722f, -0.02098258f, -0.00127775f, 0.03745919f, 0.09517128f, 
    0.09115839f, 0.01241670f, 0.01795881f, -0.00973871f, -0.08703682f, -0.14824736f, -0.13141055f, -0.01476164f, 
    -0.04282588f, 0.14980431f, -0.12561394f, 0.09964468f, 0.18725696f, 0.06540185f, -0.20406869f, -0.02328822f, 
    0.12619986f, -0.14361349f, -0.09116776f, -0.09718542f, -0.00583734f, -0.04623332f, 0.04552568f, -0.24206980f, 
    -0.16687222f, 0.21635729f, -0.02550218f, 0.16747898f, 0.17980623f, 0.11752389f, 0.14792319f, -0.26303774f, 
    0.04284909f, -0.05890856f, -0.09428085f, -0.06916949f, 0.05954766f, -0.25790289f, -0.92198825f, -0.52994382f, 
    -0.05901321f, -0.03349385f, -0.05278303f, -0.10105572f, 0.08808804f, 0.05087662f, 0.00638994f, 0.10285764f, 
    -0.13995707f, 0.00072761f, 0.10200708f, 0.14030159f, 0.18133928f, 0.02798302f, 0.15558805f, 0.12343668f, 
    0.16449881f, 0.04395889f, 0.15992130f, -0.05054669f, -0.01567357f, 0.12526472f, 0.02355654f, 0.03456439f, 
    -0.13458176f, -0.60487646f, -0.28917775f, -0.06592996f, -0.08585831f, 0.03561510f, -0.07401758f, 0.03256204f, 
    -0.17829384f, -0.22515666f, 0.13175656f, -0.01487777f, 0.23647456f, -0.04614136f, 0.07612414f, -0.04302713f, 
    0.16398449f, 0.26786250f, 0.02901778f, 0.07609715f, -0.21729851f, 0.32045388f, 0.11690918f, -0.00993491f, 
    -0.06806275f, 0.15633677f, 0.00291776f, 0.09035252f, 0.04011356f, 0.15074490f, -0.11191141f, 0.00596875f, 
    0.09095421f, -0.03687137f, 0.13990186f, 0.12496194f, 0.02349279f, 0.26093528f, 0.09396771f, 0.14740957f, 
    0.00638530f, 0.34958610f, 0.27685338f, 0.04671027f, 0.29658848f, 0.26092592f, -0.17843801f, -0.08323676f, 
    -0.49131748f, -0.04035015f, -0.19363341f, -0.10838603f, -0.04311460f, 0.00905735f, 0.08447658f, -0.35507339f, 
    0.02557345f, -0.28750151f, 0.06586337f, 0.08096489f, -0.02613947f, 0.08646904f, -0.02788693f, 0.06154753f, 
    0.28797463f, 0.32770178f, 0.05889888f, 0.03545568f, -0.11946130f, 0.35933357f, 0.12664923f, 0.30650434f, 
    -0.04082692f, 0.16072142f, 0.06218642f, 0.23280665f, -0.00925133f, 0.12896618f, -0.19541007f, -0.00165648f, 
    0.07266214f, -0.08117771f, -0.48970461f, -0.36957291f, -1.07161319f, -0.12938808f, -0.03143534f, -0.13000672f, 
    -0.01107720f, 0.15240598f, 0.00064963f, 0.08402517f, 0.13929059f, -0.15929556f, -0.09367590f, -0.02223463f, 
    0.26472425f, 0.07285105f, -0.02050755f, -0.15636282f, 0.24229395f, 0.10402622f, 0.01429633f, -0.07123205f, 
    -0.21108341f, -0.16949384f, -0.15068020f, -0.06944288f, -0.10039677f, 0.16583674f, 0.16062388f, 0.03647526f, 
    0.07701506f, 0.07897855f, -0.06252643f, -0.01994829f, 0.06994110f, -0.11534195f, -0.79317468f, -0.41715392f, 
    -0.10848168f, 0.09041906f, -0.06635809f, -0.08330581f, -0.01996273f, -0.14677410f, -0.04130096f, 0.07505168f, 
    0.00820355f, 0.02243438f, -0.09798840f, 0.02247416f, -0.13023776f, -0.27264741f, 0.05166996f, 0.19540639f, 
    0.07881794f, -0.28644237f, 0.26640740f, 0.06723917f, 0.14845128f, 0.19120009f, 0.25243059f, 0.10472603f, 
    0.29070628f, -0.37713501f, -0.10268942f, 0.38597339f, -0.07120062f, 0.24550034f, -0.09180082f, 0.17934188f, 
    0.16112821f, -0.00271060f, 0.09280806f, -0.37134084f, -0.32479906f, 0.01636480f, -0.13274957f, 0.00690739f, 
    0.00335947f, -0.31989288f, 0.24756442f, 0.10373251f, -0.57822621f, -0.92619097f, -0.20344105f, 0.04048843f, 
    0.45914456f, -0.08172805f, -0.13689108f, 0.02302605f, -0.29208702f, 0.11178030f, 0.31354010f, 0.00165277f, 
    0.22444783f, 0.03687990f, -0.12566073f, -0.22291414f, -0.02703501f, -0.33500838f, -0.11178560f, -0.06795425f, 
    -0.02085341f, -0.27298671f, 0.00955507f, -0.10274994f, 0.05427912f, 0.05475832f, -0.42245093f, -0.38486084f, 
    -0.50320882f, -0.26747099f, -0.27063727f, -0.15744798f, -0.02546821f, -0.10785766f, 0.27653152f, 0.06438465f, 
    -0.45932388f, -0.01769333f, 0.10274104f, 0.16531178f, 0.21339758f, -0.03072220f, 0.15387635f, 0.16678466f, 
    -0.41864517f, -0.37793139f, -0.12750655f, -0.24575925f, -0.25697267f, -0.06839412f, 0.12043361f, -0.03916036f, 
    -0.15503007f, -0.18059956f, -0.26799074f, -0.19912219f, 0.08067338f, -0.12195536f, 0.00764324f, 0.06025838f, 
    -0.07222518f, -0.16205020f, 0.16305777f, -0.44813973f, 0.15689000f, 0.27784488f, -0.12306572f, -0.01102123f, 
    0.05323562f, 0.16590844f, -0.13152184f, -0.09950482f, 0.33558375f, -0.22681867f, -0.19154498f, -0.04134422f, 
    -0.06933131f, -0.25801653f, 0.54455036f, 0.00130498f, -0.12522723f, -0.07416954f, -0.21234606f, -0.06095340f, 
    -0.00945979f, 0.01555210f, 0.13553329f, -0.11517381f, -0.03729897f, -0.06577079f, -0.20301056f, -0.21110247f, 
    -0.10220485f, -0.00692923f, -0.12517554f, -0.16844818f, 0.04445744f, 0.22386567f, -0.18754153f, 0.07511830f, 
    0.18791008f, -0.01543345f, -0.04849658f, -0.14515361f, 0.04420586f, 0.04843657f, 0.06341968f, 0.16498712f, 
    0.07486255f, -0.06819511f, 0.02037784f, 0.12968715f, 0.21123576f, 0.22682826f, 0.04132603f, -0.17009555f, 
    -0.39568216f, -0.45159453f, -0.08093856f, -0.07516003f, 0.06709715f, -0.00427156f, 0.12828052f, 0.25674576f, 
    0.37765849f, -0.37086841f, 0.03973251f, 0.35399339f, -0.14077996f, 0.12898023f, -0.02669050f, -0.05186255f, 
    -0.14426826f, 0.01998586f, -0.01396723f, -0.14873938f, -0.39516136f, -0.15139148f, -0.02185536f, 0.24209128f, 
    -0.07597481f, 0.00432085f, 0.25086522f, 0.02996751f, 0.07949439f, 0.23772904f, -0.06350601f, 0.32438228f, 
    0.13825016f, 0.10503846f, -0.17577864f, 0.08221267f, -0.20022848f, 0.04191903f, -0.35769287f, -0.14740802f, 
    0.31449535f, 0.01801661f, 0.05112578f, 0.21233803f, -0.04833570f, 0.18291165f, -0.00319919f, 0.49790651f, 
    -0.19729802f, 0.07866862f, 0.01919991f, 0.13397895f, 0.16929542f, -0.34090060f, -0.24072564f, 0.06454936f, 
    0.08554479f, -0.10648550f, 0.16635878f, -0.00243785f, 0.15243247f, -0.02002850f, -0.13425608f, -0.43219730f, 
    0.03971918f, 0.00096742f, 0.33669159f, 0.12715447f, 0.15014380f, 0.26499018f, 0.26809329f, 0.00343173f, 
    0.28080001f, 0.19452186f, -0.15386207f, 0.21417949f, 0.08476987f, 0.25325975f, 0.02655487f, -0.00189173f, 
    0.27405873f, -0.37365752f, -0.13833576f, -0.33850861f, -0.24021645f, 0.06237675f, 0.09312093f, 0.06940956f, 
    0.18734506f, 0.26582274f, -0.03801950f, 0.17153725f, 0.13289814f, -0.00621711f, -0.05570205f, -0.08834033f, 
    0.18031535f, 0.03043837f, -0.12965916f, 0.00154597f, 0.40087464f, -0.03297191f, 0.08581676f, 0.02386470f, 
    0.03567757f, 0.01733551f, 0.14400189f, -0.09338444f, -0.57602084f, -0.39595377f, -0.26116243f, -0.26341826f, 
    -0.03009295f, -0.16435166f, -0.03248540f, -0.09121005f, 0.13161159f, -0.09726901f, -0.40782866f, -0.22890419f, 
    -0.07853176f, 0.12651990f, -0.07546694f, 0.17193334f, -0.04180533f, 0.02900483f, -0.17374241f, 0.15900092f, 
    0.44661909f, -0.06780806f, 0.01910175f, -0.19056591f, 0.03103166f, 0.00669887f, 0.09560532f, -0.57179624f, 
    -0.06600732f, 0.21387699f, -0.10043887f, -0.05963374f, 0.07216138f, 0.21062835f, -0.00043302f, 0.01890876f, 
    0.04043668f, 0.08112996f, 0.13123839f, 0.11258156f, 0.05146457f, -0.02553192f, 0.23163864f, -0.01999209f, 
    0.12740225f, -0.28307769f, -0.01042103f, 0.19205612f, 0.04872565f, -0.18445352f, -0.11476239f, -0.06858411f, 
    -0.12322184f, -0.16950269f, -0.01968857f, 0.03556975f, 0.05963595f, -0.16408759f, -0.02700129f, 0.07491072f, 
    0.07137749f, 0.20404699f, 0.33790484f, -0.39318737f, -0.51823527f, 0.02484720f, 0.02224244f, 0.00473983f, 
    -0.04225873f, 0.18969685f, 0.04579728f, 0.01676507f, -0.08981917f, -0.18538731f, -0.06858370f, 0.24489269f, 
    -0.11981560f, 0.12471463f, 0.17286164f, 0.11480435f, 0.03631120f, 0.18161011f, 0.09970398f, 0.03454148f, 
    0.02883477f, 0.29193100f, -0.04282197f, 0.04089570f, 0.11269445f, -0.11520229f, 0.00070793f, 0.03211397f, 
    0.22177894f, 0.00882673f, -0.26992857f, -0.08843184f, 0.14111613f, 0.16814052f, 0.07841177f, -0.05859547f, 
    -0.32060003f, -0.19756489f, 0.19190904f, 0.12446709f, 0.04395231f, 0.26811802f, 0.21364562f, -0.11696713f, 
    -0.18064849f, 0.05502742f, -0.07921359f, -0.11588773f, 0.10444873f, -0.00773436f, -0.07028554f, -0.19491830f, 
    0.04804839f, 0.03129749f, -0.01189398f, 0.17410058f, 0.03182150f, 0.00665011f, -0.10917918f, -0.03765338f, 
    -0.00615055f, -0.14687367f, 0.20466885f, 0.02722351f, 0.04843917f, 0.04730594f, 0.12388781f, 0.00897864f, 
    -0.01495459f, -0.00134831f, -0.01398794f, 0.15286206f, 0.03279741f, -0.25838599f, -0.11013670f, 0.05991732f, 
    0.02225479f, -0.06094742f, 0.22479422f, 0.10755245f, 0.07068746f, 0.01929576f, -0.23942862f, -0.03550827f, 
    0.03753873f, 0.00921196f, -0.15899818f, -0.14119887f, 0.19695185f, 0.21401128f, 0.07751899f, 0.08453904f, 
    0.26538226f, -0.05510368f, -0.22994724f, 0.05434203f, 0.21205898f, -0.13052410f, -0.00090110f, -0.47357336f, 
    -0.06372629f, 0.10809389f, 0.00783027f, 0.12042977f, 0.09008429f, 0.18138529f, -0.06765621f, -0.20580091f, 
    -0.18153882f, 0.02837665f, -0.00189540f, 0.08633334f, 0.19390114f, 0.07615993f, -0.08853628f, -0.19315238f, 
    -0.05174912f, -0.04692512f, -0.02594823f, -0.15735276f, 0.04371927f, -0.00106780f, 0.22017550f, 0.20495717f, 
    0.18947122f, 0.20994307f, 0.31342372f, -0.00618610f, -0.19940099f, -0.03616528f, -0.06616846f, 0.04133794f, 
    0.07805227f, 0.07361226f, -0.02257949f, 0.03593083f, 0.30488059f, -0.09640306f, 0.02430985f, -0.03032628f, 
    0.20904432f, 0.15046063f, -0.03502887f, 0.01489133f, -0.29335937f, -0.13807194f, 0.25847000f, -0.33618933f, 
    0.05416239f, 0.11624394f, 0.13099027f, 0.13131800f, 0.16962701f, 0.10037575f, 0.26480204f, 0.09158632f, 
    0.13222523f, -0.12011018f, 0.16951902f, 0.25846329f, 0.19993630f, -0.37678495f, -0.17246094f, 0.03215856f, 
    0.03220832f, 0.10165997f, 0.26378629f, -0.13419557f, 0.26674348f, 0.06821963f, 0.18031903f, -0.04818534f, 
    -0.23753165f, -0.03028848f, -0.33398199f, -0.16169368f, 0.08880360f, -0.01461246f, 0.04959847f, 0.29345617f, 
    0.00675472f, 0.07441261f, 0.25599253f, -0.06895880f, -0.12656051f, 0.18617907f, -0.00881058f, -0.12475683f, 
    -0.02901943f, 0.12261210f, 0.19955140f, 0.00044791f, -0.04996571f, 0.18537576f, 0.37345353f, 0.13405551f, 
    0.01693328f, -0.00151890f, 0.20038192f, 0.11688592f, -0.04024970f, 0.13054064f, -0.06717188f, 0.11689840f, 
    0.29193380f, -0.00007482f, -0.31023431f, -0.60384202f, -0.52700794f, -0.19012290f, -0.15913174f, 0.03113717f, 
    -0.10904799f, -0.23462082f, -0.04325516f, -0.09867633f, 0.11391990f, 0.04547095f, 0.02317116f, -0.11447901f, 
    0.02073238f, 0.18747100f, -0.11711659f, -0.13839155f, 0.04113851f, 0.21098365f, 0.04436520f, -0.13030997f, 
    -0.02776899f, -0.09451424f, -0.10548394f, -0.11357734f, 0.05317218f, 0.17795433f, 0.01608370f, 0.05253397f, 
    0.23262888f, -0.06085191f, -0.05630673f, 0.17865881f, 0.08437052f, 0.19972461f, 0.04842508f, -0.32372701f, 
    0.11099726f, 0.10977202f, -0.01388392f, 0.11518724f, 0.16680159f, 0.05643105f, 0.19590271f, -0.17108485f, 
    -0.09603366f, -0.11233874f, -0.18918155f, 0.07793862f, 0.17831309f, 0.05830148f, -0.12519337f, -0.20912024f, 
    -0.03848981f, -0.13614435f, 0.00988924f, -0.17967042f, -0.01011061f, -0.00541558f, -0.02493901f, 0.22195449f, 
    0.03159396f, 0.24161045f, 0.28678301f, -0.30051535f, 0.15551104f, -0.02197579f, 0.08521703f, 0.02889256f, 
    0.04746905f, -0.02052874f, -0.23534818f, 0.00759078f, -0.27753216f, -0.14688255f, 0.06312244f, 0.18720849f, 
    0.12462255f, -0.06446534f, -0.04412458f, 0.53583938f, -0.55111217f, -0.76632452f, -0.07121938f, 0.07819467f, 
    -0.36202419f, 0.08010741f, -0.07007119f, -0.08064974f, 0.16405830f, 0.05561349f, 0.29054448f, 0.03632693f, 
    0.04542699f, -0.10794236f, -0.08644382f, -0.11435129f, 0.17225412f, -0.23603578f, 0.02880822f, 0.48422071f, 
    0.04332871f, 0.10914436f, -0.37700051f, 0.01541800f, 0.01425580f, 0.15468179f, -0.05359354f, -0.58546525f, 
    -0.01465138f, 0.00553875f, 0.01549197f, -0.37615776f, -0.04881670f, -0.25569990f, -0.01963797f, -0.15107369f, 
    -0.11607718f, 0.42589721f, -0.00071557f, -0.04794384f, 0.02635554f, -0.01474268f, 0.02542012f, -0.02433949f, 
    -0.06459732f, -0.00425121f, 0.30387405f, 0.04505224f, -0.29810917f, -0.26516700f, 0.31538036f, 0.08617609f, 
    0.05686510f, -0.33678907f, -0.42638856f, 0.30007529f, 0.16517302f, -0.05157942f, -0.09559757f, 0.17011070f, 
    -0.05830866f, 0.25121409f, -0.08955025f, -0.05573767f, -0.14077665f, 0.03501214f, -0.16541338f, -0.34595212f, 
    0.11309402f, 0.25923797f, 0.11635245f, -0.44363719f, -0.11795051f, 0.06140220f, 0.01286831f, 0.02228182f, 
    -0.00586847f, -0.06318302f, -0.18810584f, -0.14279605f, 0.05148698f, -0.08407218f, 0.26979208f, 0.05123670f, 
    0.04023654f, -0.29426640f, 0.02175389f, -0.10218571f, 0.01199649f, -0.05079579f, -0.35880229f, 0.51349467f, 
    -0.30130273f, 0.06972929f, -0.44695574f, 0.15873136f, 0.08862881f, -0.12634458f, -0.21893387f, 0.15996887f, 
    0.12309938f, -0.08927731f, 0.11405614f, -0.25259161f, 0.11383156f, 0.05934282f, 0.19350021f, -0.08762936f, 
    0.12886514f, 0.21838123f, -0.07510441f, 0.06125403f, 0.01123257f, 0.08325056f, -0.17743824f, -0.00969702f, 
    -0.12383512f, 0.31314704f, -0.45769477f, -0.00604079f, -0.22704238f, 0.06368021f, -0.12568386f, 0.00911557f, 
    -0.18594585f, 0.02627285f, 0.32520300f, -0.08784437f, -0.00853096f, -0.11768928f, -0.00237765f, -0.17392302f, 
    -0.02963272f, -0.04538839f, -0.28233933f, -0.13366032f, 0.38981891f, 0.07473597f, 0.02420480f, -0.17301860f, 
    0.21124500f, 0.03049335f, 0.11920948f, 0.15638347f, 0.01302217f, -0.26806551f, -0.17442609f, -0.08489948f, 
    0.22444451f, -0.20997795f, 0.06086281f, 0.09079971f, -0.21439214f, 0.21555485f, 0.07486162f, 0.11602367f, 
    -0.28954837f, -0.08728709f, -0.16985184f, 0.09451387f, 0.02345566f, -0.13284400f, 0.11556930f, -0.41150409f, 
    -0.11197341f, -0.27127725f, -0.15937115f, 0.10919014f, -0.03138893f, -0.12045122f, 0.16715895f, 0.37345123f, 
    0.08168451f, -0.03719877f, 0.07759406f, 0.00321397f, -0.04679534f, 0.10095396f, 0.20777063f, 0.41504368f, 
    0.29900026f, 0.48626277f, -0.12183324f, -0.09555896f, -0.13753109f, 0.11929262f, 0.10664452f, -0.16362603f, 
    0.11895651f, -0.08104169f, -0.28368250f, 0.23983853f, 0.08932993f, 0.11977181f, -0.01730148f, -0.01318711f, 
    -0.11602199f, -0.28741512f, -0.00061860f, 0.39302355f, 0.16543053f, 0.05671257f, -0.15195683f, -0.00844077f, 
    0.02093588f, 0.07353801f, 0.23183277f, -0.30216587f, -0.10134415f, 0.01029407f, -0.04754264f, 0.02709852f, 
    0.15249981f, 0.10158227f, 0.20920540f, -0.44173828f, -0.10934957f, -0.07834024f, 0.22083145f, 0.12342588f, 
    -0.09768002f, -0.00893780f, -0.01585489f, -0.17463082f, -0.01980017f, 0.11722686f, 0.14598535f, 0.13413027f, 
    -0.02169778f, -0.14215147f, 0.21338966f, 0.15311714f, 0.15766150f, 0.16769460f, -0.14695360f, -0.13905373f, 
    -0.18422408f, -0.09958486f, 0.17736170f, 0.02706294f, -0.01257174f, -0.08200831f, -0.03874889f, 0.13697511f, 
    0.11162224f, -0.27824223f, 0.04075584f, 0.06326901f, -0.17341341f, -0.14442390f, -0.02727075f, 0.10380636f, 
    0.00941274f, 0.00909074f, 0.11450683f, -0.25578022f, 0.09113017f, 0.17166814f, 0.06830594f, 0.01708574f, 
    -0.07705794f, 0.11386588f, -0.09560037f, -0.01007529f, 0.11560699f, 0.18242915f, 0.14794832f, -0.06049799f, 
    0.22080015f, 0.45428118f, -0.16276135f, -0.08665191f, -0.04213042f, -0.14249116f, -0.24406536f, 0.14115675f, 
    0.26165149f, -0.04745952f, -0.24241029f, -0.14722075f, 0.24257311f, -0.03199420f, -0.06452336f, 0.02783422f, 
    0.16531871f, 0.03180790f, 0.17389275f, -1.09321380f, -0.23988511f, -0.04472987f, -0.22868215f, 0.09879916f, 
    0.21053182f, 0.04280659f, 0.01671849f, 0.34797892f, 0.39829129f, -0.16352610f, -0.20562612f, -0.12569687f, 
    0.15529682f, 0.04137197f, 0.02080186f, -0.08390520f, -0.01059156f, -0.00089777f, 0.31227463f, 0.13735144f, 
    0.10206236f, 0.24570443f, -0.07315791f, 0.28408903f, 0.19140793f, -0.04402925f, -0.32322484f, -0.16181210f, 
    0.38944930f, -0.21901488f, -0.02677933f, -0.08089101f, 0.04650986f, 0.12024429f, 0.02794467f, 0.32160714f, 
    -0.22558089f, -0.51898217f, 0.10159993f, -0.00839777f, 0.14963767f, 0.13143605f, -0.09077700f, -0.09533744f, 
    -0.25583616f, -0.06390020f, 0.08455417f, -0.21067567f, -0.06020908f, -0.14162335f, 0.10201106f, -0.01781511f, 
    -0.03233124f, -0.21440297f, 0.19788401f, 0.07982250f, -0.12159562f, 0.14903018f, 0.03977394f, -0.10264015f, 
    -0.17223132f, 0.07461192f, -0.11093742f, -0.08978846f, -0.04493309f, 0.01946336f, -0.03561667f, -0.12150107f, 
    0.22666787f, -0.05500987f, 0.03827411f, 0.02636923f, 0.06040226f, -0.23751161f, -0.06275995f, -0.13682264f, 
    -0.15303908f, 0.18465474f, 0.13234439f, -0.02324451f, -0.03212455f, 0.05194727f, 0.20997740f, -0.08511098f, 
    0.24819565f, -0.12814718f, 0.04849194f, -0.00122290f, -0.01011937f, -0.52392286f, -0.01223169f, -0.14851835f, 
    0.03014774f, -0.07960375f, -0.11590556f, 0.01828603f, -0.13868186f, -0.10092132f, 0.15497538f, -0.35243872f, 
    0.03474550f, -0.18192704f, -0.06042505f, 0.10309905f, 0.09955040f, 0.20830041f, 0.04778262f, -0.37218079f, 
    -0.34248438f, 0.20917538f, -0.10330351f, -0.12209721f, -0.07762238f, 0.11372467f, 0.16348450f, -0.00286730f, 
    -0.51332402f, 0.15407595f, 0.00047054f, -0.21923320f, -0.21701728f, -0.01051737f, 0.29961631f, 0.14869072f, 
    0.01855563f, 0.09394118f, -0.20036681f, -0.14039445f, -0.07561240f, -0.00176624f, -0.06985816f, -0.10602590f, 
    -0.15179296f, -0.03630273f, -0.33264798f, 0.02075197f, 0.25420377f, -0.07211376f, 0.04589454f, 0.03041797f, 
    0.21464467f, 0.02614536f, -0.04123102f, 0.79415351f, 0.04007060f, -0.47651052f, -0.00426879f, 0.21591187f, 
    0.02111601f, 0.05333036f, -0.01858966f, -0.12803829f, -0.20637925f, 0.00192890f, 0.16351484f, -0.07110824f, 
    0.25281513f, -0.17307067f, -0.08862707f, 0.31349427f, 0.10350382f, 0.37164494f, -0.39745924f, -0.56390291f, 
    0.06525724f, 0.10034078f, 0.10591084f, 0.10507741f, 0.16666864f, -0.02492690f, 0.57384032f, -0.22630002f, 
    -0.36891943f, -0.11164396f, -0.07125864f, 0.02898881f, 0.05201106f, -0.07211080f, -0.17904766f, 0.72995114f, 
    -0.03937638f, -0.53884161f, -0.04077556f, 0.03114684f, -0.05120233f, 0.07864691f, 0.07863786f, 0.14558564f, 
    -0.10243993f, -0.24012595f, 0.13964297f, -0.12682931f, 0.07348303f, 0.04463018f, 0.00035133f, 0.04177689f, 
    0.11150462f, 0.01159140f, 0.03501555f, 0.12637360f, -0.18770520f, 0.18637288f, -0.32759735f, 0.17397723f, 
    0.08733834f, 0.04028040f, 0.45436889f, -0.33817700f, -0.19920431f, -0.01380053f, -0.11029197f, 0.26442254f, 
    0.14318490f, 0.10522956f, -0.16712688f, 0.61055541f, -0.16703506f, -0.33022925f, -0.00381314f, 0.26258457f, 
    0.08512453f, 0.06596004f, 0.05106585f, -0.02335783f, -0.14381556f, 0.18666624f, 0.08796908f, -0.25589210f, 
    -0.19045885f, -0.24976574f, 0.13577619f, -0.07308151f, 0.02704796f, -0.55336148f, 0.33576834f, -0.18533868f, 
    0.00843283f, -0.07459339f, -0.24867554f, 0.17889634f, 0.01552736f, -0.00244446f, 0.06258301f, -0.37204233f, 
    -0.10820708f, -0.29052755f, -0.00294117f, -0.12703122f, 0.07663319f, -0.06720740f, 0.20571955f, 0.48399368f, 
    0.05017095f, -0.25693026f, 0.03174956f, 0.11780071f, -0.23845717f, 0.07043611f, -0.03504370f, -0.03763724f, 
    0.22116940f, 0.06965821f, 0.13827035f, -0.11867589f, 0.04860720f, 0.17373800f, 0.20459111f, -0.00305900f, 
    -0.09431714f, 0.49328193f, 0.29841971f, 0.46097574f, -0.19733429f, 0.12363970f, 0.19488406f, 0.10626467f, 
    0.02820533f, -0.19652866f, 0.05740860f, -0.20059276f, 0.00686629f, 0.00082420f, -0.10542149f, -0.03947088f, 
    -0.06811658f, 0.04555330f, 0.03352226f, -1.22270632f, -0.29785356f, -0.08826862f, 0.03947861f, -0.27805981f, 
    0.01079496f, 0.08284482f, 0.02502756f, -0.20570998f, 0.04425812f, -0.36802953f, 0.16686597f, -0.00821918f, 
    0.13913184f, -0.07088764f, -0.11586753f, -0.13280965f, 0.11138104f, -0.22811486f, -0.33204818f, -0.24339600f, 
    0.08249272f, -0.02697720f, -0.07993501f, -0.00032584f, -0.13661695f, -0.05552587f, -0.49311268f, 0.06926534f, 
    -0.02336839f, -0.14264870f, -0.44317722f, -0.06003507f, 0.00513077f, 0.09588347f, 0.07699099f, 0.41495174f, 
    -0.13525099f, 0.06310996f, 0.09457052f, 0.30332205f, 0.20007968f, -0.01815433f, 0.22342964f, 0.17995614f, 
    -0.25470200f, 0.16917655f, 0.08631402f, 0.08268879f, -0.24460301f, -0.28467649f, 0.00268098f, -0.01684049f, 
    0.20233825f, -0.37367582f, 0.05518320f, 0.06902598f, 0.17428219f, 0.01248641f, -0.20049931f, 0.12663062f, 
    -0.13988373f, -0.05315953f, 0.67968071f, 0.49707982f, 0.03827109f, 0.10529413f, -0.04776545f, -0.27641505f, 
    0.13466397f, -0.09065098f, 0.12266864f, 0.10765075f, -0.47330216f, -0.02192223f, -0.29982576f, -0.10528329f, 
    -0.12185763f, -0.23366994f, 0.02242089f, 0.06605093f, -0.43287137f, 0.02017902f, -0.41529727f, -0.07005654f, 
    -0.16221845f, 0.01776859f, -0.14023738f, -0.03563103f, 0.15252365f, -0.79192072f, 0.06456326f, -0.03154120f, 
    0.07436153f, -0.12105293f, -0.18837388f, 0.07461535f, -0.00631614f, -0.09279153f, -0.41793767f, -0.03122849f, 
    -0.16477951f, 0.00217654f, -0.32806066f, -0.20134783f, -0.01838720f, -0.07166418f, 0.10445489f, -0.11732332f, 
    0.11476592f, -0.07380088f, 0.01533849f, -0.00173070f, -0.06958836f, 0.02275531f, 0.07329158f, 0.14336696f, 
    -0.02713329f, -0.58948916f, -0.06763938f, -0.05485979f, 0.09876285f, -0.11381099f, 0.09503560f, -0.10522489f, 
    -0.02043701f, -0.14744547f, -0.04101546f, 0.14119686f, 0.05654746f, 0.04261310f, -0.00499655f, 0.00574575f, 
    0.11565854f, 0.10291298f, -0.25671875f, 0.11984574f, 0.04946057f, 0.08935992f, -0.01230713f, 0.16236885f, 
    -0.00058407f, 0.09290812f, 0.15718181f, -0.05046960f, -0.39350733f, -0.10351677f, -0.05414265f, 0.03486598f, 
    0.13008101f, 0.00384509f, -0.09926753f, 0.02058493f, 0.12695125f, 0.25015411f, -0.27346596f, -0.12952492f, 
    -0.06749836f, -0.06095403f, 0.21601565f, 0.28633475f, -0.19202536f, 0.72474664f, 0.23913284f, 0.19680528f, 
    0.07856791f, -0.08424950f, -0.09969988f, -0.20184684f, -0.00323477f, -0.00834161f, 0.51284653f, 0.16227758f, 
    0.17002998f, -0.00452795f, -0.01360690f, 0.23192042f, 0.10089842f, -0.05237127f, 0.10749453f, -0.00312324f, 
    -0.14712411f, 0.04731964f, -0.13927978f, 0.21126100f, -0.10242634f, 0.06434587f, 0.13117346f, -0.30086887f, 
    -0.46056274f, -0.12516050f, -0.37586480f, -0.05316547f, -0.25349179f, 0.03494332f, -0.13328905f, 0.16360347f, 
    -0.10644013f, -0.01703271f, 0.03137215f, -0.35952348f, 0.02896865f, 0.02613447f, 0.20498897f, -0.08047881f, 
    0.16555455f, 0.05888705f, 0.56894338f, 0.57460362f, 0.40417179f, 0.04040536f, 0.01342515f, 0.13700053f, 
    0.14217658f, -0.05566161f, -0.04638568f, -0.40592968f, 0.14203510f, -0.23362699f, -0.03288367f, -0.11797608f, 
    0.07697497f, -0.05200787f, 0.07345856f, 0.02052014f, -0.38815016f, -0.31377023f, 0.01589952f, -0.17658874f, 
    -0.18531838f, 0.01585118f, 0.06964111f, 0.00467353f, 0.07500237f, -0.38817888f, -0.42034161f, 0.08689982f, 
    0.15040621f, -0.04216442f, -0.09062751f, -0.04678856f, 0.01761559f, -0.19128565f, -0.30419090f, -0.04064881f, 
    0.15944013f, 0.07764859f, -0.29752791f, -0.05826164f, 0.01573750f, -0.11575917f, 0.02717244f, 0.44279483f, 
    0.42506668f, 0.45958230f, 0.13099352f, -0.25247785f, 0.15928544f, -0.05725769f, 0.04029164f, -0.09347226f, 
    -0.26265138f, -0.08346128f, 0.03685772f, 0.00366063f, 0.02257122f, -0.05998106f, -0.20200399f, 0.01728369f, 
    -0.24389046f, 0.77587610f, 0.29358670f, 0.12712893f, -0.18768522f, 0.11713643f, 0.07260797f, 0.05475825f, 
    0.09737752f, 0.00476944f, -0.07759364f, -0.27804676f, 0.11075361f, -0.18780968f, 0.02691020f, 0.13830873f, 
    -0.01529999f, 0.15534051f, 0.09516191f, -0.53902292f, -0.20611726f, 0.06834152f, 0.08066531f, -0.06961413f, 
    -0.07287199f, -0.05513931f, 0.11868158f, -0.03236122f, 0.12519273f, 0.15664448f, 0.06365126f, 0.08893827f, 
    0.08959103f, 0.34806448f, 0.12929793f, 0.16654573f, 0.11834242f, -0.82949191f, -0.08472562f, 0.00485972f, 
    0.14491828f, -0.03371499f, -0.26249748f, -0.08711396f, -0.31485423f, -0.15328674f, -0.26741728f, -0.01438972f, 
    0.15491951f, -0.27725360f, 0.01268062f, -0.00962357f, 0.09705354f, 0.29292271f, 0.12581596f, 0.04118654f, 
    0.11320567f, -0.14320932f, 0.04805389f, 0.22980194f, 0.20710315f, 0.03766391f, 0.00196813f, 0.06267527f, 
    -0.12048539f, -0.20056181f, 0.20943537f, 0.12249923f, -0.05777287f, -0.02188132f, -0.33194891f, 0.08920287f, 
    0.07456853f, -0.41118282f, -0.20770758f, 0.21343634f, 0.00662437f, -0.05165626f, -0.00552944f, -0.00582622f, 
    0.01573914f, -0.00115260f, -0.20491226f, -0.21852264f, 0.11875845f, 0.05661465f, -0.05504696f, -0.13554178f, 
    -0.04612216f, -0.23656096f, -0.22668996f, -0.09486912f, 0.07534518f, -0.00809111f, -0.04420752f, 0.04310347f, 
    0.19722176f, 0.25910977f, -0.04645270f, 0.20880458f, -0.62998909f, -0.16417991f, 0.13852450f, 0.05089721f, 
    -0.13271867f, 0.01760330f, -0.20560293f, 0.12827571f, -0.28118491f, -0.29378721f, 0.27507004f, 0.12736721f, 
    0.01412493f, 0.08290053f, -0.00228751f, 0.13412371f, 0.08843016f, 0.08663286f, 0.11303100f, -0.01671956f, 
    -0.10915439f, -0.03446062f, -0.29012024f, -0.18937206f, 0.01770999f, -0.14415507f, 0.09144969f, 0.15613899f, 
    -0.11206906f, -0.32489887f, -0.23071201f, -0.07637732f, -0.11881505f, -0.01115676f, -0.02375526f, -0.08342310f, 
    -0.12734725f, -0.15417585f, 0.10554226f, 0.08681097f, 0.07925323f, 0.03765903f, -0.15278298f, -0.12040434f, 
    0.06218890f, 0.45220092f, 0.18433109f, 0.20410648f, -0.16870822f, 0.02302477f, 0.04709935f, -0.01115018f, 
    0.08587766f, 0.17949684f, -0.70566571f, -0.29133832f, -0.23402123f, -0.17317405f, -0.11449749f, 0.02774228f, 
    -0.06184106f, 0.07708642f, -0.07611956f, -0.02554804f, 0.00792214f, -0.08297320f, 0.05247121f, 0.09226982f, 
    0.17087349f, 0.06032721f, -0.03453004f, 0.14095125f, -0.26582089f, -0.08624513f, -0.15850990f, -0.07575890f, 
    -0.07029058f, -0.09695212f, 0.20720935f, 0.10248378f, -0.06022932f, 0.29772601f, 0.05429975f, -0.02588483f, 
    0.01352826f, -0.12255026f, -0.34142601f, -0.08767134f, -0.10754449f, -0.13637124f, 0.36331600f, 0.22081858f, 
    -0.10611238f, 0.31868458f, 0.22956032f, -0.09861986f, -0.02680038f, -0.20765680f, 0.06830031f, -0.04007003f, 
    0.13390036f, 0.04382861f, -0.03626993f, 0.30800876f, -0.04231017f, 0.14580065f, -0.02511209f, -0.20697300f, 
    -0.22707385f, -0.56372905f, -0.09060952f, -0.13299674f, -0.38299409f, -0.08849582f, -0.16780290f, 0.04432822f, 
    -0.04786447f, -0.43355888f, -0.20801607f, -0.12679674f, -0.13367750f, -0.05258159f, 0.04061595f, 0.09414399f, 
    -0.01263693f, -0.27688667f, 0.09307662f, 0.35900679f, 0.23135166f, 0.13314694f, 0.15713501f, 0.03057733f, 
    -0.08244460f, 0.11961424f, -0.19146539f, -0.09745903f, -0.68092293f, -0.08108781f, -0.03707865f, -0.15441191f, 
    0.01181514f, 0.00783463f, -0.04768033f, 0.18979818f, 0.00314988f, -0.04224118f, -0.01369843f, 0.09606068f, 
    -0.05566544f, 0.04356242f, -0.05613519f, 0.07111879f, 0.16314094f, -0.15792833f, -0.07623056f, 0.00784555f, 
    0.07161085f, -0.07169748f, 0.10348716f, 0.11388422f, 0.00841741f, -0.10029265f, 0.31832713f, 0.21877401f, 
    0.19840555f, -0.07890151f, -0.19372699f, 0.10506103f, -0.03011291f, 0.13528918f, 0.01749940f, 0.42666587f, 
    0.20969345f, 0.09542063f, -0.14757901f, -0.04296000f, 0.11756916f, -0.11946224f, 0.11471371f, -0.19705552f, 
    -0.01805487f, -0.02020134f, -0.01324944f, -0.01301427f, 0.03079516f, -0.00588055f, -0.04672573f, -0.04908551f, 
    -0.04976425f, -0.03424880f, -0.00372015f, -0.00337575f, 0.00502995f, -0.04674573f, 0.01683456f, 0.03523589f, 
    0.04278834f, -0.06107866f, -0.06263802f, 0.03417690f, 0.03857775f, -0.00054236f, 0.01443528f, -0.00899320f, 
    -0.06102573f, -0.06542583f, 0.02193672f, -0.04287107f, 0.02560072f, -0.03941891f, 0.01533507f, -0.02425265f, 
    -0.05466883f, 0.00517315f, 0.02564279f, 0.01402359f, 0.00539862f, 0.01364665f, 0.00249045f, 0.03442639f, 
    0.04502274f, -0.01679949f, 0.02429794f, 0.02450522f, 0.03436975f, -0.00715926f, -0.03687559f, 0.02264790f, 
    -0.06152135f, -0.02981427f, -0.04815617f, -0.01597382f, 0.02713517f, -0.02393838f, -0.02058680f, 0.00053982f, 
    -0.04152718f, -0.04653648f, -0.03610232f, 0.02479530f, -0.03895815f, -0.00226598f, -0.00630685f, 0.01327149f, 
    -0.05559452f, -0.05005852f, -0.00026252f, 0.02457128f, -0.02549654f, 0.03426473f, 0.04169224f, -0.04448248f, 
    0.01291731f, 0.02289692f, -0.04175299f, -0.04254153f, 0.00162889f, 0.01515371f, -0.06491295f, 0.01941254f, 
    -0.01187507f, 0.02446319f, -0.00183888f, 0.03345608f, -0.03683163f, -0.02200164f, -0.00255532f, -0.02035920f, 
    0.03194269f, 0.00329876f, 0.02974906f, -0.04917184f, -0.04437378f, -0.05199862f, 0.01126415f, 0.03195132f, 
    -0.06122318f, 0.03781313f, -0.04285573f, -0.01404826f, -0.06070334f, 0.00158995f, -0.03078517f, -0.01672197f, 
    -0.02519602f, -0.02318542f, -0.06306743f, -0.04769889f, -0.00732132f, -0.01186027f, -0.05475203f, -0.03413628f, 
    0.03468809f, -0.05530195f, -0.02376765f, -0.01455580f, -0.00069858f, 0.02617474f, 0.01398600f, 0.02181455f, 
    -0.02989385f, -0.05166948f, -0.02802544f, 0.00977231f, 0.04389409f, 0.01162827f, 0.03315551f, -0.04327331f, 
    0.00437668f, -0.01409121f, -0.06961973f, -0.05564698f, -0.04012831f, 0.02936476f, -0.02376392f, 0.01676920f, 
    0.02020497f, -0.05379800f, 0.02862225f, -0.04978021f, 0.00531559f, 0.03242436f, -0.00430427f, -0.00588971f, 
    -0.05499971f, 0.02735147f, -0.05773070f, -0.01479539f, -0.03434452f, 0.03875754f, 0.03076696f, 0.03947086f, 
    -0.03300529f, -0.03901718f, 0.05285899f, -0.03321648f, -0.04092725f, -0.00438934f, 0.00227842f, 0.00073716f, 
    0.02244625f, -0.01530947f, -0.01351814f, -0.00130651f, -0.02323001f, -0.06180298f, -0.03077788f, -0.03978769f, 
    -0.05867925f, 0.03861128f, 0.02079553f, -0.04601988f, -0.03421128f, 0.02688502f, -0.07207733f, -0.00083731f, 
    0.02784277f, 0.01915707f, 0.02102608f, 0.01693395f, -0.03382746f, -0.06639048f, -0.01652780f, 0.04055136f, 
    -0.01879818f, 0.03404934f, 0.02898236f, -0.06527227f, -0.03320707f, -0.06075315f, -0.00585486f, 0.02285714f, 
    -0.01048523f, 0.03896604f, -0.06772262f, 0.03530875f, 0.01429497f, -0.04878636f, 0.01287098f, 0.02314489f, 
    0.02327508f, -0.03179352f, 0.02304065f, -0.06175996f, 0.03468404f, -0.05539070f, -0.01719550f, 0.02440392f, 
    -0.05559261f, -0.04744178f, 0.03627232f, -0.02005292f, 0.00444330f, 0.04449091f, -0.02089605f, -0.01149864f, 
    -0.00782375f, -0.06344456f, 0.01543409f, 0.02157712f, 0.04834370f, -0.02087843f, 0.04196925f, 0.00480183f, 
    -0.01489060f, -0.00943045f, 0.03437355f, 0.03154524f, 0.01619005f, 0.04512174f, -0.02303336f, 0.02397375f, 
    -0.00300969f, 0.01330940f, -0.04197313f, -0.03089494f, 0.02627721f, 0.01017069f, 0.00955711f, -0.00622872f, 
    0.03570925f, 0.01301751f, 0.01407044f, -0.06000619f, 0.00538396f, -0.04485074f, 0.00032190f, -0.04530243f, 
    -0.04747103f, -0.07089745f, 0.03945496f, -0.04760838f, 0.00465976f, 0.00914994f, -0.06681096f, 0.01193304f, 
    -0.01066313f, -0.06973172f, -0.02662430f, -0.00442317f, 0.00053592f, -0.04572313f, -0.02626411f, -0.06371211f, 
    0.02521564f, 0.02957903f, 0.03981901f, -0.05216245f, 0.04415964f, -0.06351084f, 0.00607516f, 0.03376674f, 
    0.00243367f, -0.00546587f, -0.03219978f, -0.01689934f, 0.03319253f, 0.02360202f, -0.06404837f, -0.02915097f, 
    -0.02198670f, -0.03469894f, -0.00735364f, 0.01221629f, -0.00602268f, -0.05521399f, 0.04360494f, -0.03326720f, 
    -0.00024649f, 0.02740929f, 0.08223001f, -0.07066488f, -0.05449150f, 0.12808433f, 0.24546389f, -0.11273466f, 
    0.31787673f, -0.20764042f, -0.42946765f, 0.33105433f, -0.01563643f, -0.12735501f, 0.00935631f, 0.09396702f, 
    -0.14020503f, 0.04766224f, 0.07345850f, -0.09900516f, -0.24435069f, 0.05558797f, -0.17928004f, 0.04309981f, 
    0.02334775f, -0.01978411f, 0.04247405f, 0.16231196f, -0.00182288f, 0.15672457f, -0.06418022f, 0.12842745f, 
    0.05629765f, 0.04677350f, -0.31548414f, 0.05798357f, -0.16268204f, -0.13591978f, -0.08489897f, -0.11418542f, 
    -0.14035243f, -0.17886601f, 0.17628253f, 0.39198729f, 0.01543155f, -0.05957622f, 0.01849540f, 0.20905115f, 
    -0.02454845f, -0.33103487f, 0.03161149f, 0.06967308f, -0.21333644f, -0.00478622f, 0.16695018f, -0.10423720f, 
    -0.07305979f, 0.07150746f, 0.09462126f, -0.10869172f, 0.00031570f, 0.14177683f, -0.11319748f, -0.08065785f, 
    -0.09830017f, 0.13238259f, -0.01397984f, -0.01331496f, -0.04962207f, 0.19462089f, 0.09593714f, 0.05674062f, 
    -0.06993704f, -0.11843497f, -0.05993969f, 0.31240538f, 0.05663936f, -0.10791379f, -0.16498561f, 0.01571745f, 
    0.12406737f, 0.16053566f, -0.09721269f, -0.03711048f, 0.03893764f, -0.01165156f, -0.10182960f, -0.02507468f, 
    -0.06692068f, -0.10969939f, 0.04948696f, 0.07118035f, 0.06486455f, 0.07076613f, 0.15056476f, 0.19832486f, 
    -0.21495795f, -0.10476029f, 0.24547619f, 0.05835621f, 0.07866120f, 0.08270000f, 0.04098478f, 0.10945268f, 
    0.26680559f, -0.17622714f, 0.32450289f, 0.08667538f, 0.01824256f, 0.02522217f, 0.02298414f, 0.20259757f, 
    -0.00897863f, 0.04912517f, 0.03364680f, 0.24917157f, 0.12465437f, 0.12513869f, 0.14544991f, 0.16062154f, 
    0.14414148f, 0.08962391f, 0.09604479f, -0.10454085f, -0.18787768f, -0.00538290f, 0.20298640f, 0.12679818f, 
    -0.18235189f, 0.08412660f, 0.01629173f, 0.01488828f, -0.08285668f, 0.18838160f, 0.05668368f, 0.20436627f, 
    -0.40488812f, -0.02736446f, -0.00631300f, 0.05523468f, 0.00926308f, 0.08645317f, -0.03251781f, -0.18742250f, 
    -0.03327059f, -0.04260808f, 0.04492352f, 0.01872303f, 0.17456234f, 0.15930712f, 0.08135218f, 0.01134606f, 
    0.10429499f, -0.26134482f, -0.04739352f, -0.21974815f, 0.00846878f, -0.16345631f, -0.05545780f, 0.25635314f, 
    0.15513065f, 0.13218717f, 0.29623252f, 0.00191598f, 0.14904581f, 0.02789038f, 0.01058894f, 0.08056953f, 
    -0.04988360f, -0.12863930f, 0.01194474f, -0.31964156f, 0.02904550f, 0.25049019f, 0.27547735f, -0.16648826f, 
    -0.08415432f, 0.07376058f, 0.40949655f, 0.05681991f, 0.18921398f, 0.01854940f, 0.25420898f, -0.18742052f, 
    0.18099421f, -0.06230788f, -0.01537894f, -0.00554282f, -0.16610536f, 0.17658359f, 0.08319979f, 0.16524374f, 
    0.10605227f, -0.21594305f, 0.06134665f, -0.16049466f, 0.12157513f, 0.08730388f, -0.33819431f, 0.20580721f, 
    0.21403192f, -0.17049888f, -0.20845428f, -0.29736674f, -0.10539868f, -0.03597199f, -0.15414800f, -0.10482445f, 
    0.08953436f, 0.55228150f, 0.16051716f, 0.07512648f, -0.11790012f, -0.21299355f, -0.12891559f, 0.00967551f, 
    0.09550044f, -0.08713018f, 0.39782557f, 0.01795572f, 0.09262734f, 0.19950299f, 0.12802154f, 0.12054473f, 
    0.09839595f, 0.14487909f, -0.01188891f, 0.17111303f, -0.00170631f, -0.08668102f, 0.02386513f, -0.03233973f, 
    0.01975053f, -0.06429527f, -0.45850962f, 0.10489298f, -0.06632426f, 0.06889424f, -0.09039733f, -0.36260697f, 
    -0.22543684f, -0.29439038f, -0.28252101f, 0.09520348f, -0.12553979f, 0.49042588f, 0.31046858f, 0.10978091f, 
    0.12554760f, -0.03594080f, -0.00709909f, -0.01094938f, 0.07188398f, -0.02528437f, 0.11549012f, -0.03743045f, 
    -0.18117201f, -0.04162250f, -0.11216081f, 0.02760125f, 0.08394473f, 0.08994119f, -0.02121587f, 0.10371073f, 
    0.03398875f, -0.03038747f, 0.04663542f, 0.03238686f, 0.07139324f, 0.15491726f, -0.12331583f, 0.14085233f, 
    -0.03661678f, 0.35811654f, 0.22776955f, -0.01807705f, 0.22088803f, 0.15996566f, 0.05627784f, -0.48704323f, 
    -0.28769967f, 0.27073720f, 0.38451138f, 0.02037633f, 0.23035489f, -0.23849104f, -0.05144646f, -0.29758117f, 
    0.16056442f, 0.05476112f, 0.00741743f, -0.08519887f, -0.06597850f, 0.00498193f, -0.00006119f, -0.00411634f, 
    0.24418508f, -0.16368422f, -0.21764177f, 0.46714491f, -0.11824192f, 0.15725994f, -0.22231877f, 0.01086621f, 
    0.05867639f, 0.06910335f, 0.21456800f, -0.15954241f, 0.29407841f, 0.03216590f, 0.15620339f, 0.26942244f, 
    -0.11938246f, -0.08452155f, -0.06919636f, -0.52870154f, 0.35998136f, 0.11073172f, -0.03632643f, 0.21489953f, 
    0.16482949f, 0.16818421f, -0.01765256f, -0.22262210f, -0.17730612f, -0.05746394f, -0.09625878f, 0.11410947f, 
    -0.15622585f, 0.03396936f, -0.09621861f, -0.35567278f, -0.07533149f, -0.15989709f, 0.13971624f, 0.19043437f, 
    0.01126794f, -0.03197671f, 0.02633230f, 0.02672688f, 0.08328237f, 0.04227811f, 0.02499595f, 0.44809756f, 
    0.01641199f, -0.02291569f, -0.05536383f, -0.10847751f, -0.03725914f, -0.16862959f, -0.12403485f, -0.12782489f, 
    0.32463267f, 0.27483642f, 0.04550919f, 0.06405286f, -0.21713273f, 0.20748876f, -0.05584850f, 0.16248120f, 
    -0.03222892f, -0.17069973f, 0.00706738f, -0.05451132f, -0.05410822f, -0.03203563f, 0.12718761f, 0.16992468f, 
    -0.03046629f, -0.27388364f, -0.06620403f, -0.33371550f, 0.06952670f, -0.02205651f, 0.00433263f, 0.15942651f, 
    0.00918256f, 0.02708327f, -0.17599964f, 0.07113071f, 0.05921297f, -0.04154577f, -0.17648521f, 0.11729829f, 
    -0.07852096f, 0.15100794f, -0.03877201f, -0.02977529f, -0.28071356f, -0.15587786f, -0.20459466f, 0.17289098f, 
    0.03347384f, 0.03805269f, -0.21007293f, -0.18390815f, -0.24712272f, -0.29989597f, 0.20551400f, -0.15180428f, 
    0.11723362f, 0.19051421f, -0.00553401f, 0.11653061f, 0.20135662f, -0.31598747f, 0.22154978f, -0.53306663f, 
    -0.09618606f, -0.13049029f, -0.20634896f, 0.06143084f, -0.15461673f, -0.23286216f, -0.13318647f, 0.38515723f, 
    0.58263075f, -0.03876172f, -0.04155504f, -0.12041261f, 0.03046274f, 0.09744760f, 0.02501475f, -0.15291342f, 
    -0.04351118f, 0.18161403f, -0.05519123f, 0.08281684f, 0.10700605f, 0.16074334f, 0.00966608f, 0.05518042f, 
    0.24881352f, 0.08450842f, -0.03000830f, -0.09061881f, -0.12264711f, 0.02321235f, -0.16154082f, -0.22071570f, 
    0.05816910f, -0.14223684f, -0.03675995f, 0.52762395f, -0.01184432f, -0.25155446f, -0.07468008f, -0.05591409f, 
    -0.10730710f, -0.01877793f, -0.13500036f, 0.11609267f, 0.24872780f, 0.03837940f, -0.06645511f, 0.03194565f, 
    -0.06685830f, 0.05208281f, -0.06984057f, -0.11649027f, -0.17938334f, -0.08151819f, 0.17100629f, 0.27454361f, 
    0.21030891f, -0.29036456f, 0.20485026f, -0.03170322f, -0.17267250f, 0.49692336f, -0.01808803f, 0.11767390f, 
    0.00312020f, -0.02185017f, 0.06563529f, 0.01114037f, -0.00931684f, -0.63018161f, 0.10834959f, 0.48504204f, 
    0.26406661f, -0.11120264f, 0.13573548f, -0.08829535f, -0.00011226f, 0.09153115f, -0.10558452f, 0.10953805f, 
    -0.01702487f, 0.15472154f, -0.32158348f, -0.08579963f, 0.12128163f, 0.18900338f, 0.15035199f, -0.13344620f, 
    0.28021011f, -0.24659696f, -0.09990221f, -0.20125189f, 0.11033431f, 0.05392558f, 0.01762846f, 0.13951717f, 
    -0.19075969f, 0.10967700f, 0.03861304f, 0.27692732f, -0.13119599f, 0.26018068f, 0.01685507f, 0.07291788f, 
    -0.08642977f, -0.01229618f, -0.00278676f, 0.13218011f, 0.04936881f, 0.09498173f, -0.16525339f, -0.02589393f, 
    0.03593347f, -0.12270843f, -0.00564549f, 0.04891658f, 0.18703586f, 0.01159988f, -0.37094992f, -0.13411517f, 
    0.14870222f, 0.17247340f, 0.20363410f, -0.67867649f, -0.33999652f, -0.14808303f, 0.09336179f, -0.17412247f, 
    0.17497231f, 0.05744064f, 0.09070518f, -0.18404537f, 0.00000728f, 0.02243365f, 0.07629944f, -0.03866982f, 
    -0.09018761f, 0.07882200f, 0.01769665f, 0.09026635f, -0.06979492f, 0.00805078f, 0.10935090f, 0.12021734f, 
    0.08534012f, -0.00247559f, -0.09534787f, -0.10713939f, -0.10230799f, -0.04717077f, -0.12157889f, 0.02731327f, 
    0.15683344f, -0.25037578f, -0.14600615f, -0.05646142f, 0.10774428f, -0.30640331f, -0.01505092f, 0.01741081f, 
    -0.42148140f, -0.24942386f, -0.01243682f, 0.19361776f, -0.44970769f, 0.05003668f, 0.07481243f, 0.04463446f, 
    0.12188527f, 0.06717832f, 0.22366749f, -0.07937517f, 0.19528729f, -0.01657650f, 0.04063115f, 0.05384208f, 
    0.05449945f, 0.34351525f, 0.32990038f, -0.24938799f, -0.07206996f, 0.04466492f, -0.04151805f, 0.05841696f, 
    -0.01545970f, 0.22295877f, -0.22142044f, -0.06261241f, 0.10100804f, -0.19794649f, 0.06046524f, -0.05249218f, 
    -0.12336629f, 0.05905318f, 0.10643061f, -0.08348188f, -0.04406716f, -0.47880498f, -0.08873995f, 0.05445934f, 
    0.34848502f, 0.02664948f, -0.06667086f, -0.10356767f, -0.00911690f, 0.01713137f, -0.01962325f, 0.01332716f, 
    0.08703432f, 0.04898425f, -0.02592446f, 0.05834460f, 0.01308884f, -0.23734944f, 0.00284760f, 0.28025761f, 
    -0.01063572f, 0.09707578f, -0.06365231f, -0.02159384f, 0.01691579f, -0.18268213f, -0.11027243f, -0.08406831f, 
    -0.31759426f, 0.13173848f, 0.06697022f, -0.02865346f, 0.14464566f, 0.17149548f, -0.02835744f, 0.27074718f, 
    -0.04519650f, -0.00231530f, -0.18003170f, 0.16508564f, 0.06979446f, -0.05567764f, 0.02866631f, -0.03413409f, 
    0.10911909f, 0.14666256f, 0.20660481f, -0.26457259f, -0.31801313f, -0.68035001f, 0.08081783f, 0.09704208f, 
    -0.05760928f, -0.00876255f, -0.03450147f, 0.19921942f, -0.00796496f, -0.01190518f, 0.09406476f, 0.15166771f, 
    -0.13427845f, -0.25167814f, 0.08147779f, 0.12448281f, 0.13070072f, 0.08011144f, -0.07356512f, -0.67350638f, 
    -0.01751107f, -0.04744239f, 0.08584781f, -0.17561193f, 0.08117418f, 0.10685061f, -0.12435254f, -0.26619729f, 
    0.14418101f, 0.04956241f, 0.23106472f, -0.05640928f, 0.09394416f, 0.12626652f, 0.03693093f, -0.40164420f, 
    -0.03664885f, 0.16409157f, -0.03842779f, -0.00213119f, -0.32361704f, -0.69677520f, -0.20153154f, 0.36893144f, 
    -0.07034552f, 0.01340930f, -0.32061014f, -0.17155452f, -0.10486222f, 0.22623885f, -0.08969327f, 0.19605179f, 
    0.04177533f, 0.01762787f, -0.04872913f, -0.07293606f, 0.10763983f, 0.12881641f, 0.22757354f, 0.09998109f, 
    -0.00041901f, -0.42749995f, -0.11724290f, -0.01822624f, -0.04598435f, 0.09386864f, 0.09629729f, -0.19323954f, 
    0.12251684f, 0.03823973f, 0.34744701f, -0.60664296f, -0.04618130f, -0.11667446f, 0.20109035f, -0.08081242f, 
    0.03405587f, 0.01071016f, 0.15112451f, -0.08059563f, -0.06439543f, 0.07317634f, 0.02594728f, 0.05437514f, 
    -0.05934571f, -0.08546461f, -0.02418364f, 0.01584789f, 0.02908218f, -0.11489008f, 0.07061627f, 0.02553517f, 
    -0.06376835f, 0.06603641f, 0.07767772f, 0.48705977f, -0.09832679f, -0.00225458f, -0.12593117f, 0.03880537f, 
    0.34219676f, 0.05151921f, 0.01689796f, 0.07458971f, 0.24973322f, -0.22171134f, 0.22117774f, 0.03558329f, 
    0.07823534f, -0.12264271f, 0.05465239f, -0.04897570f, -0.00961642f, -0.04156386f, 0.11423816f, -0.23061721f, 
    0.03538071f, 0.14799172f, -0.17415033f, 0.10345545f, 0.03038264f, -0.13774534f, 0.09092677f, 0.10313432f, 
    0.24686015f, -0.09559478f, -0.05335740f, -0.20912194f, -0.07449247f, 0.10979253f, 0.03625817f, -0.12385851f, 
    -0.03377511f, 0.43221468f, -0.17194831f, 0.16332109f, -0.19500114f, -0.14653677f, 0.00996104f, -0.07278310f, 
    0.16207057f, -0.36329332f, -0.63548726f, -0.06562620f, 0.24303693f, 0.44405726f, -0.01267024f, -0.11084527f, 
    0.07606505f, 0.00548115f, -0.07586841f, -0.08171105f, -0.27508417f, -0.01060265f, 0.21585199f, 0.04944395f, 
    0.05708417f, -0.11461250f, -0.02116228f, -0.24176854f, -0.09272750f, 0.02019946f, 0.14950193f, -0.13205300f, 
    0.13242561f, 0.12999527f, -0.02932743f, 0.38919717f, -0.20273532f, -0.31827781f, -0.12408300f, 0.08268208f, 
    0.46655694f, 0.02432683f, 0.10033836f, 0.15054886f, 0.01744706f, 0.12747702f, 0.15674675f, -0.05889759f, 
    0.10838547f, -0.10640044f, 0.04378171f, 0.11357288f, -0.02914947f, -0.29153985f, 0.12939902f, 0.26694456f, 
    -0.09364030f, 0.13839738f, -0.03117486f, -0.14575085f, 0.09707335f, -0.04387246f, -0.08288127f, 0.00981087f, 
    0.00137066f, -0.04744424f, 0.02807164f, -0.09509540f, 0.01258570f, -0.03067352f, -0.03487722f, 0.34010643f, 
    0.01910937f, -0.03136330f, -0.03535865f, -0.03933024f, 0.14491075f, 0.14251569f, 0.01950409f, -0.06975587f, 
    -0.01430934f, 0.00801409f, -0.02851834f, 0.01693117f, 0.03308190f, -0.05338216f, -0.03893527f, 0.01480035f, 
    0.04282514f, -0.01628828f, -0.03526738f, 0.03479142f, 0.04438667f, 0.01479721f, -0.05740390f, 0.00912093f, 
    -0.01386887f, -0.02534121f, -0.00007271f, 0.00881715f, 0.01756975f, -0.06155115f, 0.01224327f, 0.04128421f, 
    -0.06218630f, -0.04225063f, 0.02790955f, -0.00698006f, 0.05723323f, 0.03700567f, 0.02973508f, -0.02156250f, 
    0.02235464f, -0.02779177f, 0.03865651f, -0.00644971f, -0.00605985f, 0.00199222f, -0.04160897f, 0.00352428f, 
    -0.04241741f, 0.03548577f, 0.00013033f, 0.00170362f, 0.02341674f, -0.03486645f, 0.00160026f, -0.02041070f, 
    -0.01471602f, 0.03096789f, -0.03795490f, 0.04982958f, -0.03448105f, 0.05208548f, 0.04054748f, 0.02101169f, 
    0.01219932f, -0.05496351f, -0.01294638f, -0.04549897f, -0.01208360f, 0.02301895f, 0.01669014f, -0.00181632f, 
    0.03065544f, -0.04975006f, -0.00784474f, -0.05012641f, -0.02234321f, 0.00333050f, 0.04558325f, -0.04336863f, 
    0.00612484f, -0.00356928f, 0.04318139f, -0.00013522f, -0.04474699f, -0.02126230f, -0.00973674f, 0.01067259f, 
    -0.01394130f, 0.01947259f, 0.00816704f, 0.05050016f, 0.01930984f, -0.02350387f, -0.03899274f, -0.00096689f, 
    0.04682460f, -0.06290543f, -0.00797665f, -0.05520217f, 0.05005146f, -0.03885119f, 0.03501620f, -0.02461322f, 
    0.00439754f, -0.01607842f, 0.00617979f, 0.00957383f, -0.02354323f, 0.01159654f, 0.03515214f, 0.00652026f, 
    -0.01018022f, -0.00496744f, -0.00936423f, -0.05520657f, 0.05210609f, -0.01181494f, 0.01193984f, -0.05312158f, 
    -0.04681555f, -0.01738264f, 0.02910936f, -0.05556244f, -0.00699511f, 0.02578727f, -0.02870628f, -0.01151351f, 
    0.02947400f, -0.04427957f, 0.00038050f, -0.02971984f, 0.03065276f, -0.03840819f, -0.04698734f, -0.04552442f, 
    -0.02152456f, 0.04174029f, 0.03540440f, 0.03399762f, -0.05244936f, 0.01834858f, 0.02634392f, 0.00358222f, 
    -0.01181396f, -0.01633069f, -0.05205870f, -0.05266927f, 0.04824851f, -0.02847330f, 0.00441971f, 0.01501060f, 
    -0.03956050f, -0.01394371f, -0.00385902f, -0.02156218f, -0.01582446f, -0.05215035f, 0.00403265f, 0.04286572f, 
    -0.02082850f, 0.00110840f, 0.01057415f, -0.02252353f, 0.00002180f, -0.01816324f, -0.06119797f, -0.05039052f, 
    0.01211611f, -0.00540405f, -0.00541338f, -0.04762062f, -0.01528989f, 0.04244586f, 0.01336822f, -0.02317165f, 
    0.05141665f, 0.02326292f, 0.03095712f, -0.01333445f, 0.04843687f, -0.00264270f, -0.05767328f, -0.01608433f, 
    -0.05193768f, -0.00045216f, -0.04912687f, -0.04063882f, 0.01208835f, 0.01179884f, 0.04429876f, 0.00574415f, 
    0.01123429f, 0.03926923f, -0.01677194f, -0.02356193f, 0.04319720f, 0.00032355f, 0.04921412f, 0.04563854f, 
    0.04094602f, -0.01196629f, 0.00722522f, -0.00522264f, -0.05580725f, -0.02363150f, -0.02943408f, -0.00788308f, 
    0.01437147f, -0.05047966f, 0.00037757f, 0.00280864f, -0.02523090f, -0.01480036f, 0.06294280f, -0.01700617f, 
    -0.04118098f, 0.04794241f, -0.02100017f, -0.02130540f, 0.01037450f, -0.04394989f, -0.02414903f, 0.00852139f, 
    -0.06507096f, 0.05215455f, -0.02726738f, 0.04440696f, 0.01568693f, 0.04784867f, -0.03570144f, 0.01221371f, 
    -0.04001759f, 0.02887187f, -0.03117757f, 0.02461726f, 0.00013375f, 0.04857781f, 0.00603671f, 0.00317156f, 
    -0.05598766f, 0.02975607f, -0.01243166f, 0.02754725f, -0.00256461f, 0.00178567f, -0.00557182f, -0.05127279f, 
    -0.04610117f, -0.01529482f, 0.00904118f, 0.02476551f, -0.01529530f, -0.05206518f, -0.04499311f, 0.00795550f, 
    -0.00081488f, -0.02727325f, 0.02252334f, 0.00551565f, -0.02473092f, -0.00459381f, -0.03977535f, -0.06008216f, 
    0.00540150f, -0.00921064f, -0.03789556f, -0.03982393f, -0.02836738f, -0.01515463f, -0.04663010f, 0.00935864f, 
    -0.02470452f, 0.04998382f, 0.00395660f, -0.02337933f, -0.05532955f, 0.00691288f, 0.03261745f, -0.03463647f, 
    -0.01991981f, -0.05144589f, 0.02190975f, 0.05068931f, -0.05377956f, -0.05095455f, -0.00217965f, -0.02771853f, 
    0.01304027f, 0.04955541f, 0.02821489f, 0.05067830f, 0.02296410f, -0.02143409f, -0.00596565f, 0.00055003f, 
    -0.04698106f, 0.21358588f, 0.08026256f, 0.02251291f, 0.09226669f, 0.00292347f, -0.16369696f, -0.23383753f, 
    -0.01774916f, 0.07164882f, -0.01087238f, -0.02591766f, -0.14886494f, -0.16467613f, -0.08052541f, -0.05177141f, 
    0.03705374f, 0.23371990f, -0.07317451f, 0.10842900f, 0.20902890f, -0.08766529f, 0.06121408f, -0.00338107f, 
    0.15468884f, 0.06021079f, 0.04577959f, 0.06814064f, -0.04655356f, 0.36476591f, -0.06550795f, -0.09034503f, 
    -0.66900367f, 0.14963382f, -0.10831813f, 0.08393940f, -0.14885171f, 0.00761930f, -0.00235923f, 0.27231026f, 
    0.06852664f, -0.23285054f, -0.05862984f, -0.50398612f, -0.29809812f, 0.17164484f, -0.07075056f, -0.20542616f, 
    0.12234371f, 0.17103450f, 0.18391965f, 0.04261123f, 0.05517272f, 0.00438846f, 0.07640310f, 0.03742364f, 
    -0.10731228f, -0.08499249f, -0.03986675f, 0.02561009f, 0.00916697f, -0.09058799f, -0.16057323f, 0.23764823f, 
    0.13578692f, 0.13555916f, 0.09961251f, 0.13746765f, -0.08725519f, 0.06141290f, -0.00484059f, -0.07053784f, 
    -0.04458134f, -0.02487529f, 0.09268067f, 0.09825695f, 0.16258475f, 0.07080041f, -0.09082521f, -0.15281102f, 
    0.00680615f, -0.20229192f, -0.22695665f, -0.33917165f, -0.04112167f, 0.12792197f, 0.08311841f, 0.12295294f, 
    0.15293470f, -0.02678090f, -0.03262733f, 0.19239378f, 0.08575577f, 0.08022430f, 0.12597725f, 0.11908457f, 
    0.03717010f, -0.12908190f, 0.01597300f, -0.16191044f, -0.08249383f, -0.00509389f, 0.00552884f, -0.05603477f, 
    -0.08155330f, 0.04231814f, -0.00513373f, 0.24493939f, 0.05699104f, -0.07536159f, 0.15969722f, -0.01867949f, 
    0.21533626f, 0.24201725f, -0.13234191f, -0.10648680f, -0.13536431f, 0.06139920f, -0.09671301f, 0.02025155f, 
    -0.23085310f, 0.28375408f, 0.09451077f, 0.08288465f, 0.09672780f, -0.00466622f, 0.22934102f, 0.13243276f, 
    0.23578022f, 0.06138891f, 0.23282482f, 0.04125820f, 0.11842383f, -0.05886402f, 0.18278962f, -0.13676788f, 
    -0.14086427f, 0.12845916f, 0.00586799f, 0.05529745f, 0.04262694f, 0.18324749f, 0.17553891f, 0.19636087f, 
    -0.03543894f, 0.01766550f, 0.08788402f, -0.05771913f, -0.02449011f, 0.12792443f, -0.09239849f, -0.01817497f, 
    0.03567317f, -0.21415533f, -0.20825122f, -0.06556325f, 0.27991492f, 0.31068724f, 0.04092313f, -0.16480546f, 
    -0.15802297f, -0.15899311f, -0.02979699f, -0.02457770f, -0.22307643f, -0.11726785f, -0.05758860f, 0.20811811f, 
    0.08837341f, 0.21073626f, 0.04992599f, 0.17458689f, -0.15989970f, 0.04912227f, 0.21235907f, -0.03633972f, 
    -0.08739640f, -0.03189478f, -0.16250339f, -0.07529359f, 0.14430068f, 0.14679030f, -0.07994040f, -0.01851106f, 
    0.13744105f, 0.18611841f, 0.15070024f, 0.01702757f, 0.00538039f, -0.07279062f, -0.06298629f, 0.34605265f, 
    -0.00649033f, 0.11724523f, 0.14136660f, 0.02925246f, -0.01123267f, 0.20513017f, 0.32334852f, -0.21665466f, 
    -0.15199183f, -0.04889073f, 0.10024286f, 0.13302729f, 0.18567951f, 0.08676203f, 0.28873923f, 0.29579115f, 
    0.05788856f, -0.02289490f, -0.07277542f, 0.20571698f, 0.10494732f, 0.11062656f, -0.04620335f, 0.15985899f, 
    0.15405564f, -0.10603198f, -0.01887788f, 0.09703346f, -0.06562759f, -0.26912245f, 0.07220694f, -0.10406624f, 
    0.15352336f, 0.05528014f, 0.12184406f, -0.22878999f, 0.04151579f, 0.03878819f, 0.17348497f, 0.08319427f, 
    0.04198587f, 0.01088026f, 0.22655907f, 0.12834644f, 0.21279801f, -0.06289716f, 0.26515132f, 0.22617729f, 
    0.12227727f, 0.16195409f, 0.20213231f, 0.26158923f, -0.25936228f, 0.00962146f, -0.08098269f, 0.13973612f, 
    0.08631592f, 0.17174385f, -0.07199258f, 0.04450032f, -0.03782146f, -0.00685534f, 0.00760771f, -0.02673386f, 
    0.09325631f, 0.18848637f, -0.01191427f, 0.06082937f, -0.06290013f, 0.03962432f, 0.13633761f, 0.05360961f, 
    -0.02467061f, 0.16212128f, -0.02384660f, 0.01243531f, 0.02728566f, -0.07529773f, -0.25612247f, 0.00391742f, 
    -0.16227818f, 0.28208175f, 0.22661185f, 0.14373741f, -0.30173358f, -0.23264162f, -0.14306425f, 0.34238282f, 
    0.14702499f, -0.43894097f, 0.22045699f, 0.22501293f, 0.07434976f, 0.09122031f, 0.03651781f, -0.06148326f, 
    0.17115785f, -0.02065811f, -0.11997988f, -0.06665171f, -0.26148137f, 0.12220206f, -0.14731124f, 0.03402163f, 
    -0.09303816f, 0.42350221f, 0.59288204f, -0.09337764f, 0.15800498f, 0.01273369f, 0.35113117f, -0.07700753f, 
    0.11749040f, -0.03641992f, -0.27954799f, 0.43581539f, -0.03417662f, 0.08266138f, 0.02706947f, 0.14570937f, 
    0.24522164f, 0.04061893f, -0.11813737f, 0.41440141f, 0.11003537f, -0.42720324f, 0.02635354f, 0.08434318f, 
    0.14105655f, -0.05162510f, -0.02180366f, -0.07233898f, 0.19858575f, 0.06518625f, 0.23718829f, -0.04881126f, 
    0.06135217f, 0.13347721f, 0.06707259f, 0.02189532f, 0.06796534f, 0.17600305f, 0.24661614f, -0.17694052f, 
    -0.13245521f, -0.00457925f, 0.10301819f, 0.15233608f, 0.08878332f, 0.00929631f, 0.18566802f, 0.40853715f, 
    0.20987107f, 0.03760830f, -0.05815254f, 0.12486066f, -0.16896161f, -0.04049524f, 0.12726262f, 0.11432478f, 
    -0.27200431f, -0.10772585f, 0.00867965f, -0.16189221f, 0.08582278f, 0.01296595f, 0.04718758f, -0.00589571f, 
    0.26014721f, 0.21134982f, 0.15559933f, -0.17414136f, -0.34997860f, -0.13393606f, 0.01886106f, -0.04629115f, 
    -0.00766393f, 0.09650702f, 0.03369147f, 0.24553047f, 0.07299200f, 0.10809842f, -0.04304058f, 0.22444570f, 
    0.20710176f, 0.18519118f, 0.16818370f, -0.06346326f, 0.05485943f, -0.13460107f, -0.03079759f, -0.32385251f, 
    -0.02709806f, -0.03946264f, -0.01688069f, 0.03495590f, 0.14764835f, -0.05848936f, -0.17535068f, -0.02189654f, 
    -0.00517507f, 0.17357391f, 0.02236918f, 0.13058390f, 0.23307668f, 0.16708395f, -0.27754694f, -0.03704396f, 
    -0.28129369f, -0.10830355f, 0.17292133f, 0.02706231f, -0.00505807f, -0.12450791f, -0.14276440f, 0.11433342f, 
    0.15471131f, -0.00773539f, -0.10450859f, -0.00731868f, -0.22823353f, 0.03358321f, -0.15266852f, 0.14404526f, 
    0.51154745f, -0.03353639f, -0.13956442f, -0.13714321f, -0.02271958f, -0.01413945f, -0.15770821f, 0.24785186f, 
    -0.13802931f, -0.06315593f, 0.01242766f, 0.15256837f, -0.13446820f, 0.13074172f, -0.04320566f, 0.06631703f, 
    0.20963857f, 0.37474427f, -0.08446091f, -0.17805852f, -0.22583938f, 0.06015206f, 0.20186949f, 0.06870672f, 
    0.06387742f, 0.20116903f, 0.16032243f, -0.06195709f, -0.04363521f, -0.13006350f, 0.12651922f, -0.04273671f, 
    -0.00087450f, -0.01408229f, -0.01066701f, 0.00147587f, -0.07577685f, 0.08716795f, -0.12091025f, -0.02412291f, 
    -0.01269816f, -0.01190899f, 0.03495070f, 0.27702934f, -0.03246153f, -0.35206071f, -0.00817780f, -0.14483689f, 
    -0.09181663f, -0.00110806f, 0.00637101f, 0.13742632f, 0.03926421f, -0.00060597f, -0.02675190f, -0.02124373f, 
    0.01030806f, -0.02354175f, -0.16156292f, -0.12406348f, 0.00456621f, -0.41669181f, -0.02960898f, -0.41770190f, 
    0.14506873f, 0.28041515f, -0.18710303f, 0.27241498f, 0.09093247f, 0.07840282f, -0.07059019f, -0.31637788f, 
    -0.37561172f, -0.06810623f, -0.14070337f, 0.13739999f, -0.14644715f, -0.17673130f, -0.21134834f, -0.24350518f, 
    -0.08423402f, -0.16010831f, -0.00135229f, -0.19528221f, 0.07428822f, -0.09925952f, -0.18426217f, -0.00685292f, 
    0.25526655f, 0.17964724f, -0.35182214f, -0.11780990f, -0.07459576f, 0.04018003f, -0.18907435f, -0.11616319f, 
    0.03058942f, 0.11549603f, 0.10497919f, -0.07944088f, -0.03313985f, -0.19238630f, -0.10386926f, 0.06007464f, 
    -0.16783106f, 0.14131297f, 0.09276222f, -0.35196981f, -0.10939351f, -0.06707895f, 0.02839196f, 0.30368862f, 
    0.04024682f, 0.07181624f, 0.16326699f, 0.27695024f, 0.10294336f, -0.14102383f, -0.10899251f, 0.00013241f, 
    -0.12971389f, -0.08775800f, 0.06413612f, 0.07489701f, 0.20574954f, 0.18468738f, 0.02005116f, 0.13736299f, 
    -0.03995684f, -0.00044391f, 0.02302543f, 0.00636216f, 0.07660306f, -0.03541601f, 0.10801041f, 0.00623837f, 
    -0.17993782f, 0.07272551f, 0.23512775f, 0.02056021f, -0.08305177f, 0.06140355f, -0.28078884f, 0.15325080f, 
    0.20562005f, -0.14970066f, -0.14768156f, 0.05069606f, -0.14843494f, 0.05321155f, -0.12289912f, 0.34692878f, 
    0.14474972f, 0.14684275f, 0.14750624f, -0.34823433f, 0.18075472f, -0.14283685f, -0.08174954f, 0.00236193f, 
    -0.13684200f, 0.11157226f, -0.14255297f, 0.22706403f, -0.00288285f, -0.17019013f, -0.23988992f, -0.27393547f, 
    -0.36553958f, -0.09262815f, 0.11489394f, 0.34453887f, -0.10698609f, -0.16994372f, 0.00081118f, 0.07500355f, 
    -0.03392136f, 0.00268750f, -0.12368996f, -0.09999927f, 0.17825167f, -0.07374372f, 0.00793220f, -0.10387603f, 
    0.25894701f, -0.06006407f, -0.07427838f, 0.26767117f, 0.41280657f, 0.15038309f, 0.25078756f, 0.12639911f, 
    -0.10677396f, -0.03862862f, -0.16106360f, -0.11191197f, 0.19117691f, 0.12734564f, 0.07048824f, 0.13277178f, 
    -0.04212988f, -0.03147743f, 0.15329978f, -0.27750078f, -0.36152765f, -0.02532378f, -0.13393028f, -0.45826322f, 
    0.02974580f, -0.10808703f, 0.28845873f, 0.17503208f, -0.06799587f, -0.18121617f, 0.05071226f, -0.08139565f, 
    0.05931816f, -0.09965791f, -0.16607317f, -0.24518751f, -0.05029637f, -0.06841989f, -0.26657617f, 0.34942353f, 
    0.07864580f, 0.12488728f, 0.04332693f, 0.12541892f, -0.14857331f, 0.06947252f, -0.15053655f, -0.40130064f, 
    0.15087274f, 0.29245409f, -0.28948367f, -0.06180006f, 0.00015529f, -0.03244282f, -0.23138732f, -0.24982472f, 
    0.10703989f, 0.32730868f, 0.16258094f, -0.08840393f, 0.22724141f, -0.00569662f, -0.04427010f, 0.02482860f, 
    0.10985450f, 0.02253658f, -0.17901427f, 0.10302782f, -0.52780104f, -0.00644211f, -0.03419692f, -0.03812660f, 
    -0.10402206f, 0.15478431f, 0.07339248f, 0.03180012f, 0.18667468f, 0.02547151f, -0.05303473f, -0.10387088f, 
    -0.22340631f, 0.17476034f, -0.08745187f, -0.29336187f, 0.12395354f, 0.04149758f, -0.22534429f, 0.02495308f, 
    0.17538889f, -0.03305372f, -0.12533657f, -0.02454285f, -0.02522352f, 0.07136687f, -0.11663406f, -0.16856723f, 
    0.13464066f, -0.18948060f, -0.11377113f, -0.06978654f, 0.32932341f, -0.20361988f, 0.18015172f, -0.10101572f, 
    0.19985461f, 0.04962665f, 0.05766346f, 0.28019071f, 0.13670272f, -0.08825032f, 0.09254890f, 0.08062351f, 
    0.04547700f, 0.31520244f, -0.03902986f, 0.05770133f, -0.15701823f, -0.10118005f, 0.23251709f, 0.20184144f, 
    0.11209174f, 0.20022222f, 0.03615103f, -0.19516391f, 0.01480483f, -0.05059290f, -0.18258594f, 0.15271387f, 
    -0.36631984f, 0.33021033f, 0.15070324f, 0.20741548f, 0.09782842f, 0.12030984f, -0.26682490f, -0.03059467f, 
    -0.01682587f, -0.06299382f, 0.00071356f, -0.07810033f, -0.36538920f, -0.11114707f, -0.07657371f, 0.07617137f, 
    -0.14692505f, 0.20428431f, -0.18927047f, 0.17362514f, 0.12805109f, -0.06498723f, -0.16006321f, 0.23005439f, 
    -0.08637563f, 0.25021270f, -0.11292594f, -0.13261798f, -0.10296761f, -0.03151699f, -0.13202214f, -0.09450205f, 
    0.14293042f, -0.22000644f, -0.00727039f, -0.02951044f, -0.19187762f, -0.15946655f, 0.16444713f, -0.08203907f, 
    -0.04328633f, 0.07622260f, 0.15973964f, 0.06804490f, 0.22615670f, 0.11597770f, 0.37478793f, -0.25865355f, 
    -0.11371508f, 0.07886821f, -0.07080828f, 0.23449354f, 0.02910156f, 0.03460621f, 0.15460758f, 0.42836609f, 
    -0.10917192f, 0.07678237f, 0.03682088f, -0.28879383f, -0.07739264f, -0.04632138f, 0.13316455f, -0.01129688f, 
    -0.07854037f, 0.06499368f, 0.08912417f, -0.21883090f, 0.01683414f, 0.02699791f, 0.10593460f, 0.00338241f, 
    0.02122251f, -0.10091627f, 0.12361320f, -0.08650547f, -0.18464835f, 0.12415009f, -0.12602721f, -0.02120076f, 
    0.05808437f, -0.12852937f, 0.16778132f, -0.12194088f, -0.17057514f, -0.05257435f, -0.06294470f, 0.18091308f, 
    -0.15757400f, 0.08321673f, 0.09731579f, 0.18378188f, -0.08016113f, -0.07711007f, -0.05770515f, -0.06829548f, 
    -0.00590802f, 0.04199065f, -0.13811763f, 0.15093555f, 0.18195526f, 0.25706333f, -0.06019391f, -0.16283077f, 
    0.18186165f, -0.00927758f, -0.09148449f, 0.04191630f, -0.01125667f, -0.31191203f, -0.15091668f, 0.12335379f, 
    -0.02165045f, -0.07241122f, -0.15597215f, -0.13043922f, 0.00538455f, -0.06677958f, -0.02603899f, 0.25187144f, 
    0.19931510f, 0.03110207f, 0.00450490f, -0.05819330f, 0.05979429f, -0.20375618f, -0.19122250f, -0.20603418f, 
    0.14719680f, -0.06737444f, 0.00038749f, 0.05963749f, -0.06920338f, 0.08787969f, -0.07697526f, 0.20762636f, 
    -0.04850838f, -0.04506291f, -0.01500644f, 0.03164373f, 0.03140773f, -0.00336791f, -0.00464423f, -0.05935718f, 
    0.00389833f, -0.05292583f, -0.01143863f, -0.00930878f, 0.01352927f, -0.03793917f, -0.01988204f, -0.04282481f, 
    -0.03532427f, 0.03889988f, 0.00685262f, 0.00062778f, 0.04395057f, -0.05039068f, 0.02976284f, 0.00683124f, 
    0.00188891f, 0.00001465f, 0.01803221f, -0.03509206f, -0.06945669f, 0.01379293f, -0.05585478f, -0.04051080f, 
    -0.01278799f, -0.00575914f, 0.01886531f, -0.02704965f, 0.04722161f, 0.02103347f, -0.04158523f, -0.05136361f, 
    0.02996657f, 0.01945031f, -0.04011113f, -0.01992332f, 0.04226824f, -0.01005317f, -0.04706000f, 0.03254179f, 
    -0.03504685f, 0.04357994f, -0.02104175f, 0.00612977f, -0.03916984f, 0.00012553f, -0.04000494f, -0.03687394f, 
    -0.01100086f, 0.05145241f, 0.04336742f, 0.01226913f, -0.02701229f, -0.04068999f, 0.02601431f, 0.00904735f, 
    -0.02815881f, -0.00943614f, -0.05799361f, -0.06209042f, -0.00595667f, -0.01431074f, 0.03738252f, -0.01006028f, 
    0.04887713f, -0.01527565f, 0.02553337f, -0.04134381f, 0.00851944f, -0.01835482f, -0.04388337f, -0.03654247f, 
    0.02537129f, 0.04273719f, -0.03509900f, 0.03599387f, 0.04172060f, 0.02583398f, -0.04979081f, 0.01549076f, 
    -0.01149035f, 0.01099633f, 0.05261644f, 0.03158233f, -0.05817891f, -0.03613241f, 0.01733728f, 0.00791527f, 
    -0.05435165f, -0.03158554f, 0.05068379f, -0.00329599f, 0.00821640f, 0.04938112f, -0.02537970f, 0.04716672f, 
    -0.05647114f, 0.04312142f, 0.04579130f, -0.05319204f, 0.05224311f, -0.04552780f, 0.02364651f, -0.01794560f, 
    0.03730335f, -0.05755098f, -0.04928478f, -0.02681839f, 0.02471797f, 0.00664597f, 0.01132154f, 0.01192255f, 
    -0.02828725f, -0.05221764f, -0.01737790f, 0.01089757f, -0.00658008f, -0.03345994f, -0.01090701f, -0.05925594f, 
    -0.04446252f, -0.04862955f, 0.03994601f, 0.04064583f, -0.02193101f, -0.02018049f, 0.02081852f, -0.02220741f, 
    0.00899062f, 0.03391640f, -0.05558193f, -0.05049272f, 0.00360776f, -0.00239180f, -0.06484491f, -0.02454245f, 
    -0.02274844f, 0.00700356f, 0.02688425f, 0.04138503f, -0.02152908f, 0.05464780f, 0.02930933f, 0.02942831f, 
    0.02942714f, -0.00594257f, 0.01830796f, 0.02228325f, -0.03662802f, -0.04194166f, -0.06361623f, -0.01873863f, 
    -0.01912578f, 0.02522576f, -0.00336705f, -0.00412184f, 0.04896563f, -0.03768313f, 0.03388447f, -0.05745421f, 
    -0.04295571f, 0.04432577f, 0.02940669f, -0.03712543f, -0.01910614f, -0.05847175f, 0.02106483f, -0.02311045f, 
    -0.02789064f, 0.01054411f, -0.04255410f, 0.02973184f, -0.04424573f, -0.05905170f, -0.06478363f, -0.03863828f, 
    -0.05383063f, 0.00990564f, 0.04023001f, -0.03414112f, 0.01291538f, -0.02997142f, -0.02989130f, 0.03998198f, 
    0.03408619f, 0.03306217f, -0.02681476f, -0.05005182f, -0.04521593f, 0.02773435f, 0.02434166f, -0.02218803f, 
    0.00823974f, -0.02818766f, 0.00498777f, 0.03680340f, -0.02946977f, -0.05523679f, -0.05244071f, 0.01242493f, 
    0.01892011f, 0.04198743f, -0.01785156f, -0.03490246f, -0.00691281f, 0.00349630f, -0.01486350f, -0.04354974f, 
    0.02972315f, -0.00784853f, 0.00651248f, -0.06299270f, -0.04996841f, 0.00607055f, -0.02420840f, -0.00564705f, 
    -0.00279622f, 0.01172685f, -0.00334722f, -0.03541250f, 0.04353737f, -0.04424445f, -0.01978459f, -0.02367864f, 
    0.03060364f, 0.03033585f, 0.05247648f, 0.00415384f, -0.05234110f, -0.03937120f, -0.00142551f, 0.00520926f, 
    -0.00169892f, -0.05947233f, -0.06794309f, 0.01552821f, 0.03386866f, 0.03208069f, 0.04391562f, 0.01247511f, 
    0.02517909f, -0.01883680f, -0.04690396f, -0.03011759f, -0.04952588f, -0.02745956f, -0.00098261f, 0.00671681f, 
    0.00285234f, -0.00074920f, 0.05037285f, -0.02574676f, -0.02885269f, 0.00510107f, 0.01883432f, 0.02223058f, 
    -0.00693565f, 0.05336624f, -0.01740569f, -0.01744207f, -0.04603904f, 0.01003405f, 0.02581440f, 0.04598350f, 
    0.00726192f, -0.00762921f, 0.05191834f, -0.00091466f, 0.03064052f, -0.01949373f, -0.06591097f, -0.01004139f, 
    0.01140093f, -0.03707653f, 0.05051195f, 0.03277728f, -0.04018809f, -0.05470219f, -0.05908857f, -0.00251908f, 
    -0.06564369f, -0.09672555f, -0.24849331f, -0.13841563f, 0.13270135f, -0.20029594f, 0.10040423f, 0.03281302f, 
    0.06656294f, -0.00824899f, 0.17455836f, 0.12413196f, 0.00445175f, -0.12437548f, -0.09132665f, 0.11518563f, 
    0.09530543f, 0.26663953f, -0.43036461f, -0.42964664f, -0.92556185f, 0.27930909f, -0.11037495f, 0.09461410f, 
    0.06679562f, 0.14713590f, -0.01184550f, -0.28458798f, 0.08418185f, -0.77996522f, 0.12151191f, -0.25730464f, 
    -0.13062036f, -0.05007631f, 0.08155760f, 0.02591219f, 0.47471377f, 0.46988547f, 0.33416921f, -0.00092334f, 
    -0.11210424f, 0.05967680f, 0.12788509f, 0.03364376f, -0.07912052f, -0.30198759f, 0.05417705f, 0.19685103f, 
    -0.31646621f, -0.26619330f, -0.26168382f, 0.25703254f, 0.22287989f, 0.07133133f, -0.34471250f, -0.14934428f, 
    0.48046589f, 0.07018033f, 0.04197098f, 0.07528800f, 0.02131302f, 0.09466323f, -0.02391181f, 0.26463810f, 
    0.37450722f, 0.00977003f, -0.20284151f, 0.18184417f, -0.08449646f, 0.03095827f, 0.19483465f, 0.10320950f, 
    0.30368245f, 0.07350068f, -0.21662542f, -0.23432578f, -0.17114896f, -0.05243156f, 0.13869043f, 0.29631728f, 
    -0.02370618f, -0.04661703f, -0.69946265f, -0.31660914f, 0.15352091f, 0.10944603f, 0.13693939f, 0.09093434f, 
    0.04530531f, 0.30263025f, -0.21161182f, 0.29242638f, 0.01448447f, -0.16983502f, -0.07816818f, -0.21412499f, 
    -0.01652355f, -0.07968005f, 0.15495963f, 0.24757169f, 0.02353224f, -0.40941221f, -0.00366069f, -0.10543555f, 
    -0.24072403f, 0.07963158f, -0.09744272f, 0.05898859f, -0.42040110f, -0.13698402f, -0.04283401f, -0.31291208f, 
    -0.06787193f, -0.01397783f, 0.09977544f, -0.01820994f, 0.09622306f, -0.35575396f, -0.03145245f, -0.24538156f, 
    -0.25466022f, -0.03849400f, -0.01424023f, -0.25525478f, -0.03594509f, 0.00997187f, 0.18372698f, 0.30385521f, 
    0.36810341f, 0.10296714f, 0.18201567f, -0.12172271f, -0.16014661f, -0.16090965f, -0.11778043f, 0.01890553f, 
    -0.12138216f, 0.02606463f, 0.17306726f, 0.02785036f, 0.18796188f, 0.06196799f, 0.08738673f, 0.16337319f, 
    0.00391887f, -0.32721862f, -0.24273656f, 0.13966414f, -0.00474242f, -0.00038744f, 0.11846998f, 0.28886884f, 
    0.21171947f, 0.45974922f, 0.63540125f, 0.33082470f, 0.02112607f, -0.23360902f, -0.26448137f, 0.18636286f, 
    0.21912858f, 0.20672588f, -0.27068272f, -0.84099489f, -0.28966340f, -0.00372590f, 0.01279976f, -0.17779009f, 
    0.05087977f, -0.11503128f, -0.00703835f, 0.26398143f, -0.27714926f, 0.28133008f, 0.01129468f, 0.17482081f, 
    0.02820255f, -0.03461252f, 0.14130177f, 0.00161238f, -0.17904094f, -0.23099564f, 0.35095963f, -0.05042044f, 
    0.17470703f, -0.02443890f, -0.00864643f, -0.33044514f, 0.07822485f, -0.00856876f, 0.21336119f, -0.36060768f, 
    0.03224868f, -0.16191837f, 0.20895378f, -0.06581614f, 0.05597658f, 0.05820826f, 0.23109463f, 0.41013879f, 
    0.13550802f, -0.03440930f, -0.19437288f, -0.17125367f, 0.04646413f, 0.04934392f, 0.07314803f, -0.03697021f, 
    0.12183389f, -0.17258315f, 0.05951348f, 0.18653585f, -0.11423942f, 0.20192845f, 0.18809500f, 0.12928399f, 
    -0.00666119f, -0.48588249f, -0.33170289f, -0.14926995f, -0.08006231f, 0.06238285f, 0.06078674f, 0.18252435f, 
    0.05853434f, -0.71542913f, -0.79105443f, 0.04602812f, 0.01471203f, -0.18582733f, -0.03884299f, 0.11521483f, 
    0.06079819f, -0.20777568f, -0.08490735f, 0.30009899f, 0.03428653f, 0.06713124f, -0.21863297f, -0.05238036f, 
    0.03600230f, -0.07526116f, 0.20062196f, -0.58666945f, -0.62039292f, -0.07101528f, -0.51547903f, -0.21533796f, 
    0.01420037f, -0.00426999f, -0.09070636f, 0.05945681f, 0.36874571f, -0.00809882f, -0.46369514f, 0.24272738f, 
    -0.20392902f, -0.03191758f, 0.01306335f, 0.18582274f, 0.07963118f, 0.10678615f, -0.43500349f, -0.34612432f, 
    0.21214615f, -0.08349013f, -0.06712880f, -0.08414906f, 0.16502501f, -0.08257469f, 0.18111782f, 0.52601832f, 
    0.25582486f, 0.00014447f, 0.13818413f, -0.07922639f, -0.06458915f, 0.09334462f, 0.04985361f, -1.05010104f, 
    -0.67359412f, 0.15075512f, -0.34865019f, 0.05969011f, -0.06935931f, -0.03743041f, 0.04764633f, 0.02090921f, 
    0.02975301f, -0.03303934f, 0.04955255f, -0.02844883f, -0.01579342f, 0.01569549f, -0.05976345f, -0.02231160f, 
    -0.02423038f, -0.05532829f, 0.02798455f, -0.02450610f, -0.05937933f, -0.02218650f, 0.00242732f, -0.02042038f, 
    0.02657484f, 0.05214174f, -0.02291279f, 0.02021656f, -0.03893550f, -0.01414193f, -0.03824010f, -0.02796368f, 
    -0.00476792f, -0.06409392f, -0.06334968f, -0.01173095f, -0.01607715f, 0.00552428f, -0.02718168f, -0.04751848f, 
    -0.01251401f, -0.04131788f, -0.00043755f, -0.00889147f, 0.04474214f, 0.02026952f, 0.00758982f, -0.03816126f, 
    0.04062112f, -0.05801542f, 0.03050453f, -0.04254488f, -0.01048818f, 0.02562843f, -0.05853096f, -0.03130823f, 
    -0.02341164f, -0.03812893f, -0.01111163f, 0.01677987f, -0.00745960f, 0.04391353f, 0.04087208f, 0.05695789f, 
    0.01117899f, -0.01224733f, 0.00336599f, -0.04463144f, -0.01220529f, -0.03646695f, 0.03762046f, -0.02159120f, 
    0.01837866f, 0.04697715f, 0.03197443f, -0.02144793f, 0.02634616f, 0.05145042f, -0.01139841f, -0.06270689f, 
    0.00801815f, -0.06422204f, -0.04672872f, 0.06431571f, -0.04983604f, -0.00303827f, -0.03484581f, -0.02929178f, 
    0.03130500f, -0.05968315f, -0.05355337f, -0.05406120f, -0.02416770f, -0.02693707f, -0.00720606f, 0.03448552f, 
    0.03771465f, -0.02831645f, 0.01955972f, -0.04221256f, 0.02789942f, 0.00131947f, 0.04504248f, 0.00668289f, 
    0.02839952f, 0.02718414f, 0.00627257f, -0.02233705f, 0.01366456f, 0.01156488f, 0.02397810f, 0.06297046f, 
    0.01304060f, 0.03287147f, -0.02736130f, -0.04120660f, 0.05113734f, -0.01098501f, -0.01467163f, -0.05324440f, 
    0.03386505f, 0.02418261f, -0.00229524f, 0.04891401f, -0.06302489f, 0.04490370f, -0.03370941f, 0.00285757f, 
    0.02016355f, 0.05173130f, -0.03275249f, -0.02087420f, 0.02320960f, -0.04729719f, -0.03773341f, -0.06431635f, 
    -0.04804383f, 0.02082634f, -0.01128730f, -0.02276907f, -0.02480322f, 0.00574539f, 0.01924599f, -0.05738198f, 
    0.04499018f, -0.00565717f, -0.03940499f, -0.01620781f, -0.01591483f, 0.05219185f, 0.03371413f, -0.05073734f, 
    -0.04741371f, 0.02348559f, -0.01495885f, 0.01021215f, -0.04728832f, -0.04248492f, -0.00523379f, -0.05890045f, 
    -0.02104581f, -0.04126200f, 0.04726296f, -0.05764114f, -0.05991175f, 0.05105733f, -0.02385426f, -0.01814262f, 
    -0.06291058f, 0.00108138f, 0.04479989f, -0.01844170f, -0.05124146f, 0.01160398f, -0.03869316f, -0.06430390f, 
    0.01273985f, -0.02905296f, -0.03148798f, 0.04704300f, 0.04271247f, -0.04135282f, 0.04328523f, -0.00973405f, 
    -0.05383844f, 0.05141279f, -0.01562095f, 0.00184255f, 0.00078694f, -0.03817800f, 0.02050523f, -0.06319151f, 
    -0.00452558f, 0.04660420f, -0.05922944f, 0.02944130f, 0.02133104f, 0.01515752f, -0.00997844f, -0.02086162f, 
    0.02851103f, 0.01862050f, -0.03807948f, 0.03288966f, 0.01910083f, -0.00754958f, -0.00760812f, -0.01339844f, 
    -0.05923728f, 0.02735652f, -0.00102127f, 0.01327670f, -0.02242157f, -0.03281676f, -0.03704214f, 0.02224884f, 
    0.04441513f, -0.01970504f, -0.04658756f, 0.02459561f, -0.05780722f, 0.01800171f, -0.00632892f, -0.02109980f, 
    -0.06355410f, -0.00988832f, 0.00842559f, 0.00869797f, -0.03813049f, -0.05874607f, 0.01571495f, 0.00995218f, 
    -0.03970105f, 0.02033740f, -0.05231938f, -0.01026378f, 0.03431286f, -0.04564284f, -0.06377840f, -0.03799640f, 
    0.03412737f, -0.02870218f, -0.03915292f, 0.02937924f, 0.05026424f, -0.05861105f, 0.03815593f, -0.05945954f, 
    0.01605602f, -0.06370556f, 0.03592847f, 0.03435422f, -0.00546265f, -0.00425821f, 0.04201558f, -0.02891006f, 
    0.00634723f, -0.05319857f, -0.05293227f, 0.02779882f, -0.04631886f, -0.04714622f, -0.03530549f, 0.02501878f, 
    0.02925381f, -0.06019770f, 0.01527984f, 0.00511255f, 0.04292512f, -0.01533135f, -0.00355884f, 0.03971628f, 
    -0.00074005f, -0.01727895f, -0.03173785f, 0.03753249f, 0.00871213f, 0.01130714f, 0.05413874f, -0.00904426f, 
    -0.04878296f, -0.03712131f, -0.01490350f, -0.03894093f, -0.00714379f, -0.04941737f, -0.01396457f, 0.02579487f, 
    -0.00238354f, 0.01289107f, 0.02655403f, -0.03823686f, 0.00783056f, -0.00322915f, -0.01948471f, 0.03059265f, 
    -0.02710371f, 0.06130438f, -0.17341381f, -0.06950843f, 0.09728237f, 0.16954443f, 0.06014975f, 0.22588345f, 
    0.03328006f, -0.62853920f, -0.62892085f, 0.11100978f, -0.07428399f, -0.14414544f, -0.22478189f, 0.07963914f, 
    0.03712955f, 0.23572887f, -0.05649577f, 0.04193036f, 0.00241458f, 0.26787940f, -0.07235865f, -0.00336161f, 
    -0.04045698f, -0.13213080f, -0.03299435f, 0.19491820f, -0.41942829f, -0.77143747f, 0.03182022f, 0.06202396f, 
    0.20756035f, 0.18631582f, -0.01741192f, -0.32029679f, 0.05292356f, 0.05373989f, -0.00156502f, -0.32891846f, 
    0.07997353f, 0.13592161f, 0.04165530f, 0.06882774f, -0.00499573f, -0.01156207f, -0.14812092f, 0.04839158f, 
    -0.01683493f, 0.04510973f, 0.03777865f, 0.13436569f, 0.09761609f, 0.26194474f, -0.12731396f, -0.97163862f, 
    -0.05889804f, 0.01654241f, 0.13890995f, 0.02207053f, 0.20303075f, -0.18412921f, 0.07699871f, 0.06428625f, 
    0.56342983f, 0.23232310f, 0.00928395f, 0.10043163f, 0.06553954f, -0.00235319f, 0.09942193f, 0.05446244f, 
    0.01994803f, -0.02397443f, 0.05264183f, -0.31481263f, -0.10995424f, -0.15051298f, 0.10373207f, 0.20112447f, 
    0.11811330f, 0.00972801f, 0.03792251f, -0.13345556f, 0.00482213f, 0.11033878f, 0.11302220f, 0.42912421f, 
    0.19073798f, 0.18456987f, 0.01987652f, 0.10702993f, 0.12077659f, -0.28580818f, -0.13178746f, -0.19100899f, 
    0.07213175f, 0.09526882f, -0.01447147f, -0.13719013f, -0.09212299f, 0.00719666f, 0.15791103f, -0.22373924f, 
    0.08428433f, -0.12968251f, 0.08090303f, 0.06042869f, -0.12232705f, 0.01488241f, 0.00904847f, -0.34056705f, 
    0.03389724f, 0.10539024f, 0.09014890f, 0.01264696f, 0.15652293f, -0.19374131f, -0.40607882f, 0.02938039f, 
    -0.22842625f, 0.00604079f, 0.04029172f, 0.01193538f, 0.04530769f, -0.13008656f, -0.44757843f, -0.64262879f, 
    -0.59519339f, -0.05584278f, -0.12868504f, -0.07243919f, -0.02548161f, -0.19284365f, 0.39249390f, -0.06966176f, 
    -0.20622866f, -0.20346707f, 0.07400414f, -0.05667629f, 0.03536946f, 0.30962729f, 0.29020759f, 0.42583239f, 
    -0.13014199f, -0.06963766f, 0.11416440f, -0.24093001f, -0.28983015f, -0.10220611f, -0.19212860f, 0.03336728f, 
    0.07815331f, -0.78986937f, -0.41247520f, -0.10532918f, 0.04732082f, 0.02029269f, -0.06696952f, 0.09633218f, 
    -0.00241223f, -0.17882831f, 0.03651207f, 0.03675108f, 0.06949074f, 0.09574847f, 0.15676758f, 0.11916793f, 
    0.01815520f, -0.02843342f, 0.08301807f, 0.07147431f, -0.07605844f, 0.35625660f, 0.03090552f, 0.14576171f, 
    0.10944817f, -0.07347340f, -0.05651295f, 0.15228549f, 0.07984842f, -0.30886027f, -0.06033791f, 0.04519501f, 
    0.07097188f, 0.02467720f, -0.03551520f, 0.01617498f, 0.16801254f, 0.08644124f, 0.62122190f, -0.48804384f, 
    0.01927948f, -0.07164372f, -0.30269194f, 0.17635269f, -0.12314367f, 0.04709247f, -0.45628706f, 0.58801907f, 
    1.37861705f, -0.05542211f, -0.20473453f, -0.05129899f, -0.08736846f, 0.02760115f, 0.20313372f, -0.14694303f, 
    -0.51367599f, 0.04539002f, -0.09835037f, -0.04997338f, -0.13347618f, -0.09245661f, -0.11082960f, 0.12182736f, 
    -0.08019036f, -0.37079355f, -0.21569507f, 0.07966536f, 0.18536629f, 0.23324624f, 0.02445393f, -0.05562275f, 
    0.17159161f, 0.02228692f, -0.08392327f, 0.11456586f, -0.03141304f, -0.05168901f, -0.04029479f, -0.05328034f, 
    0.07211849f, 0.10765278f, -0.03081536f, 0.46690986f, 0.49227032f, 0.05466407f, -0.13160126f, -0.01909162f, 
    0.17819861f, 0.14555450f, -0.01321447f, 0.08345905f, -0.15380520f, -0.31714550f, -0.27032381f, -0.15981403f, 
    0.11412396f, 0.20337385f, 0.12128367f, 0.03701718f, -0.11930411f, -0.06178863f, -0.03023811f, -0.03963444f, 
    -0.10133257f, -0.16197845f, 0.14689220f, 0.16100989f, 0.10612547f, -0.18194392f, -0.23099138f, -0.01094764f, 
    -0.01133466f, -0.01041500f, 0.05052016f, -0.03558286f, 0.12332700f, -0.07443631f, -0.70342225f, -1.07684040f, 
    -0.39419279f, -0.12646933f, 0.02513225f, -0.10090414f, 0.06881163f, 0.00077359f, -0.20117946f, 0.12962601f, 
    0.06013851f, 0.13052723f, -0.27222371f, -0.07641355f, 0.01424575f, 0.22082976f, 0.20759979f, 0.02727266f, 
    -0.00136221f, 0.04827198f, -0.02777534f, -0.04325829f, 0.01961769f, -0.01204961f, -0.02091150f, -0.01826251f, 
    -0.05843500f, -0.02967125f, -0.00449667f, -0.03569601f, -0.00386414f, 0.01357033f, -0.02519499f, 0.04597914f, 
    -0.06500396f, 0.03496031f, -0.03102917f, -0.03979501f, -0.03133031f, -0.04448374f, -0.06575133f, 0.01815178f, 
    0.00793681f, 0.02717627f, 0.03908595f, -0.00707012f, -0.02127817f, -0.04845518f, -0.00840946f, -0.01368456f, 
    -0.02916235f, 0.02276200f, 0.00481690f, -0.02268653f, 0.02453171f, -0.03540115f, -0.02661083f, -0.05987580f, 
    -0.05674260f, -0.05875694f, 0.03541825f, 0.04231922f, -0.04168319f, 0.02027462f, 0.02513207f, -0.05193854f, 
    -0.06642566f, -0.00410372f, 0.01357377f, -0.01808817f, 0.02657539f, 0.01460677f, -0.06234536f, -0.00565069f, 
    0.03830701f, 0.01742187f, -0.02857165f, -0.00852463f, -0.03313438f, 0.03099239f, 0.02143695f, 0.02194569f, 
    -0.05074079f, -0.00736856f, -0.00746398f, 0.00801057f, -0.04464548f, 0.01781093f, 0.04956182f, -0.00417398f, 
    -0.00846878f, 0.01430068f, 0.02671159f, 0.00685937f, 0.03029935f, 0.00383599f, -0.04876880f, 0.01759538f, 
    -0.02809271f, 0.02233381f, -0.06119208f, -0.04264639f, -0.00765556f, -0.01969080f, -0.01607887f, -0.05176251f, 
    -0.03005678f, 0.01779239f, 0.02553560f, -0.00400885f, -0.02961651f, 0.02402569f, 0.04122580f, 0.04810550f, 
    0.04364643f, 0.03701022f, -0.04686614f, 0.00143246f, 0.02113095f, -0.03286413f, -0.01115701f, -0.03110515f, 
    -0.05439198f, -0.02859956f, 0.04685366f, 0.03379119f, 0.04150008f, -0.00428601f, 0.03891321f, -0.02070342f, 
    0.00146129f, 0.04642648f, 0.01038527f, -0.06722952f, 0.00213036f, -0.05646735f, -0.02795041f, -0.00615354f, 
    -0.01563088f, -0.01195276f, 0.01948035f, 0.02064884f, 0.02307560f, -0.05577572f, 0.01089963f, -0.04459080f, 
    0.01058819f, -0.03427514f, -0.06514631f, 0.00624868f, 0.03200873f, -0.01535537f, 0.01218098f, 0.01407009f, 
    0.02220155f, 0.04275104f, -0.04750102f, 0.01713501f, -0.01607721f, 0.01840455f, 0.04098495f, 0.00545076f, 
    -0.04056369f, 0.04099189f, 0.04534829f, -0.03706592f, 0.03223944f, -0.00755719f, -0.05123127f, -0.04036864f, 
    0.00840793f, -0.04481210f, 0.01060628f, -0.04746339f, -0.04648170f, -0.04603115f, -0.04569629f, -0.03644103f, 
    0.04820012f, -0.05384894f, 0.01176311f, -0.03587334f, 0.03415534f, -0.05855020f, -0.02129484f, -0.00912487f, 
    0.03470539f, 0.04634939f, 0.02188459f, -0.00854992f, -0.00128924f, 0.02588142f, -0.03996237f, -0.05400195f, 
    0.00209208f, 0.03212216f, 0.00255091f, -0.00410601f, 0.00981080f, -0.00133185f, -0.01538107f, -0.04174085f, 
    -0.01983011f, -0.02204025f, -0.00975868f, -0.03931391f, -0.03836365f, -0.02307509f, 0.01447386f, 0.02199103f, 
    -0.03190742f, 0.02666658f, 0.00088364f, 0.04645455f, 0.04314418f, -0.05995979f, 0.04573814f, -0.03418880f, 
    -0.05803306f, -0.01924324f, -0.03476426f, -0.00187855f, -0.06564970f, -0.00024514f, -0.02061627f, 0.00016913f, 
    0.05781472f, 0.03356001f, 0.03416865f, -0.03196828f, 0.03120995f, 0.01702305f, -0.06179387f, 0.03135530f, 
    -0.05225874f, 0.04160172f, -0.03686859f, 0.01317732f, 0.03264245f, -0.00660032f, -0.03124307f, 0.03282445f, 
    -0.05686064f, -0.02379857f, -0.01756159f, -0.00007621f, -0.02477046f, -0.04165057f, -0.03100465f, -0.04498627f, 
    -0.04497755f, -0.02718517f, 0.03625288f, -0.04312592f, -0.04087058f, -0.03303737f, -0.02724876f, -0.05408145f, 
    0.01887236f, 0.00276676f, 0.00028521f, -0.01655407f, -0.04688600f, 0.01766286f, 0.04292882f, -0.01497671f, 
    -0.00568213f, 0.00934931f, -0.05804419f, 0.03440165f, -0.02683874f, 0.01580806f, -0.03960598f, 0.00068627f, 
    0.04337143f, 0.00527796f, 0.00355997f, -0.00414146f, -0.04932173f, -0.05024290f, -0.04882399f, 0.03579956f, 
    0.00580908f, 0.03834759f, -0.05588737f, -0.05368819f, -0.02344677f, -0.05229084f, 0.00123610f, 0.02426135f, 
    0.01029158f, 0.00067475f, 0.02525089f, 0.01573145f, -0.04483693f, -0.03203274f, -0.04238982f, -0.02056948f, 
    -0.04854574f, -0.01030553f, 0.03303199f, 0.01718501f, 0.04531441f, -0.06897417f, -0.02372820f, 0.04352373f, 
    0.04643681f, 0.03421976f, -0.04052785f, -0.05667400f, -0.01437994f, -0.01951796f, 0.03664244f, -0.03976177f, 
    -0.00964941f, -0.04818201f, -0.01355906f, -0.03697567f, -0.00581887f, -0.05401396f, 0.01452873f, -0.01530292f, 
    -0.01089896f, -0.01711109f, -0.03793044f, -0.03400778f, 0.01906287f, -0.00567802f, 0.02688523f, -0.05945512f, 
    -0.04094031f, 0.02884019f, -0.04671996f, 0.04329085f, 0.05941246f, -0.01372007f, -0.03301841f, -0.05819816f, 
    -0.03849440f, -0.03320728f, 0.00259019f, -0.02075976f, -0.03028081f, -0.02513589f, 0.02915739f, -0.06805965f, 
    0.02408630f, 0.04652419f, -0.02450840f, -0.05664258f, -0.04768826f, -0.00266829f, 0.00174787f, -0.06049588f, 
    0.03368474f, 0.03712048f, -0.06449972f, -0.06245820f, -0.03072547f, -0.05619615f, -0.00179479f, 0.04069164f, 
    0.04619908f, -0.05007206f, -0.02709606f, -0.06404218f, 0.01908708f, 0.02477351f, -0.01070937f, -0.04430329f, 
    -0.04806326f, 0.03178478f, 0.02898323f, -0.02328616f, 0.01126593f, -0.04334331f, -0.07107592f, 0.03635443f, 
    -0.04356332f, 0.02952896f, 0.04176798f, 0.01785060f, -0.00463358f, -0.01345163f, -0.02713239f, -0.05385550f, 
    0.01087223f, -0.00047164f, -0.03871382f, 0.03321764f, 0.01445836f, -0.00028770f, 0.03348507f, 0.01178234f, 
    0.00191888f, -0.02790735f, -0.03978218f, 0.04067428f, 0.04942416f, 0.02619279f, -0.04283991f, 0.04237055f, 
    -0.02222676f, -0.07243965f, -0.04440304f, -0.02410629f, 0.03738530f, 0.03538363f, -0.00958329f, -0.04494434f, 
    0.03152330f, -0.06389417f, -0.04830589f, -0.04353026f, -0.06293285f, 0.00108259f, -0.06027535f, -0.01141057f, 
    0.03979420f, -0.06557935f, 0.01548763f, -0.00716505f, 0.03358976f, 0.03342846f, 0.03212889f, 0.04887811f, 
    0.03660576f, -0.00282798f, -0.04848074f, -0.00994505f, -0.03593336f, 0.03800834f, 0.02988641f, 0.02100673f, 
    -0.06736423f, -0.03229411f, 0.04578008f, -0.00213438f, 0.03725493f, 0.00950829f, -0.00467163f, 0.02649927f, 
    -0.03130132f, -0.02978841f, 0.04252598f, 0.01830777f, -0.04460165f, -0.00657777f, 0.02492183f, -0.00231848f, 
    -0.01818539f, -0.03070739f, 0.04459517f, 0.00161748f, 0.04488235f, 0.05015370f, -0.00580566f, 0.01040722f, 
    0.03412283f, -0.04618899f, -0.03616099f, 0.00092906f, -0.02544553f, -0.01074082f, -0.00556636f, -0.04310759f, 
    -0.07116296f, -0.02712242f, -0.06071597f, -0.01997841f, -0.00631905f, -0.06830844f, -0.02207819f, 0.03287137f, 
    -0.03975086f, 0.00918467f, -0.00692605f, -0.02649092f, 0.02078184f, -0.05139258f, -0.00172040f, 0.02283307f, 
    -0.02271248f, -0.00019670f, -0.03803877f, -0.03071992f, 0.00745451f, -0.05727075f, 0.00278536f, 0.03423954f, 
    -0.03350586f, 0.03644770f, 0.03865306f, 0.03523650f, 0.04488622f, -0.00036987f, -0.01009030f, -0.01692757f, 
    0.00828479f, 0.00326965f, 0.03641354f, 0.00282244f, -0.02907038f, -0.01215661f, -0.00673175f, 0.00866557f, 
    -0.00887690f, -0.01531271f, 0.01092106f, 0.00306716f, 0.04018296f, -0.05438522f, -0.06991937f, 0.01672716f, 
    -0.05769921f, 0.00416171f, 0.04300402f, 0.02735105f, 0.01391377f, -0.00746582f, -0.06094869f, -0.04930718f, 
    -0.01708711f, -0.00520952f, 0.02131440f, -0.04480720f, -0.02090611f, -0.04994505f, 0.02953922f, -0.01441994f, 
    0.02973850f, 0.02532572f, -0.06361539f, 0.02073281f, -0.04686312f, -0.00020644f, 0.00331015f, -0.03316445f, 
    -0.01777112f, 0.02903613f, 0.01676045f, -0.03699073f, 0.04330725f, -0.05505224f, 0.02524169f, -0.00635313f, 
    -0.02725129f, -0.00749723f, 0.03649588f, -0.01936841f, -0.04617380f, 0.02771549f, 0.01280260f, 0.03229863f, 
    -0.00827187f, -0.03189478f, -0.02062170f, -0.01302036f, -0.00277230f, -0.04865796f, -0.05427638f, 0.02906268f, 
    -0.03362701f, -0.04975441f, -0.04741954f, -0.05440805f, -0.02187435f, -0.02548835f, 0.01893291f, -0.06038712f, 
    0.02844820f, -0.01271204f, -0.01919871f, -0.04242084f, -0.01268617f, -0.06083561f, -0.03814205f, -0.01797759f, 
    -0.03715294f, 0.01238461f, 0.02077455f, 0.01599202f, -0.05021618f, -0.05388935f, -0.00916543f, 0.02240589f, 
    -0.03230305f, 0.00958711f, -0.04605724f, -0.02793522f, 0.00054539f, -0.07425950f, -0.05237518f, 0.02726118f, 
    -0.03631533f, 0.00426279f, 0.01221535f, 0.03838158f, -0.04461263f, -0.05534739f, 0.01867207f, 0.04660255f, 
    0.00298297f, -0.03364550f, -0.01657747f, -0.05130979f, -0.05107819f, 0.02819820f, -0.05631391f, -0.04034074f, 
    -0.02116357f, -0.04008901f, 0.00771963f, 0.04402401f, 0.01046256f, 0.04942635f, -0.04041032f, 0.04518032f, 
    -0.03465790f, 0.01532221f, 0.00493032f, -0.03738601f, 0.00876450f, -0.04952182f, 0.01353327f, -0.06008762f, 
    0.04659824f, 0.00252048f, 0.04411587f, 0.03013330f, 0.00287667f, -0.00256379f, 0.01979019f, -0.05600104f, 
    -0.04790680f, -0.04355573f, -0.05833893f, -0.02454613f, 0.03290313f, -0.04568776f, -0.02335137f, -0.03183850f, 
    -0.00467318f, 0.04568928f, -0.05790778f, -0.02401247f, -0.05236931f, 0.02243758f, -0.03728985f, -0.04123730f, 
    0.04922788f, 0.04024103f, -0.04906249f, -0.05623032f, -0.01299714f, -0.06092219f, -0.01076604f, 0.00682421f, 
    -0.04777217f, -0.05213312f, -0.01922148f, 0.01411463f, 0.00986512f, 0.03956804f, 0.01084127f, 0.00472130f, 
    0.05097470f, 0.04556247f, 0.02297362f, -0.01124814f, -0.06174564f, -0.00121975f, 0.00607739f, 0.03645433f, 
    0.04071359f, 0.00775962f, 0.01818008f, -0.04170900f, 0.04862037f, 0.03240145f, -0.04564450f, -0.06369638f, 
    0.04621758f, -0.00270618f, -0.03945638f, -0.04835593f, -0.05737947f, -0.06524261f, -0.05144472f, -0.05871070f, 
    0.03765063f, -0.05747120f, -0.00962814f, 0.04383821f, -0.04321064f, -0.02833757f, -0.00200616f, -0.00354922f, 
    -0.05489928f, -0.01781574f, 0.00411234f, -0.06205598f, -0.03716627f, -0.02186377f, -0.02174937f, 0.04914002f, 
    -0.00641105f, 0.03750455f, 0.03626063f, -0.02442202f, -0.03651706f, -0.03567901f, -0.01003891f, -0.04362339f, 
    -0.00960384f, -0.01362096f, 0.04471470f, -0.04230934f, -0.00785098f, -0.04384985f, 0.04679751f, 0.04744867f, 
    -0.02548988f, -0.03546119f, 0.03303815f, -0.01394187f, -0.03560119f, 0.03210102f, -0.06317054f, 0.01286431f, 
    -0.05122676f, 0.02948607f, -0.05081234f, -0.03135369f, 0.04283688f, 0.03985176f, -0.05927567f, 0.03959582f, 
    -0.02999694f, 0.05076437f, 0.05204874f, 0.00582362f, 0.04781030f, 0.00155291f, -0.02202309f, -0.06046275f, 
    -0.03139424f, -0.05733327f, -0.05424763f, 0.00796580f, -0.03630067f, -0.01183717f, 0.05209677f, 0.02078409f, 
    0.02375629f, 0.02921271f, -0.01728894f, -0.01935305f, 0.04597761f, -0.04423214f, -0.04902432f, -0.02911213f, 
    -0.04547792f, -0.03171667f, -0.01532031f, 0.02886023f, -0.04855287f, 0.00327848f, -0.05017598f, -0.06053638f, 
    -0.03574207f, -0.00095957f, -0.01463817f, 0.03173979f, 0.02495561f, 0.00195772f, 0.00085644f, 0.00694481f, 
    -0.06563562f, 0.00871537f, 0.03364804f, 0.00240588f, -0.01240294f, -0.04172837f, 0.03055810f, -0.01219996f, 
    0.04273189f, -0.00796278f, 0.01894724f, -0.05535157f, -0.00577961f, -0.00009587f, -0.05245459f, -0.05732268f, 
    0.04727109f, 0.00891067f, 0.04545401f, -0.02766561f, -0.04011144f, -0.04656565f, -0.02222964f, -0.04099021f, 
    0.02267286f, 0.00839317f, 0.03429735f, 0.02483292f, 0.00706756f, -0.03802482f, 0.00686457f, 0.00318004f, 
    0.01682417f, -0.01480450f, -0.01081011f, -0.03884428f, -0.00292918f, -0.04983834f, -0.03994946f, -0.00496462f, 
    -0.01233587f, -0.05640570f, -0.02979990f, 0.03723459f, 0.03589054f, -0.05242278f, -0.04355778f, -0.00148844f, 
    -0.01118995f, -0.04716876f, 0.03827281f, -0.06199075f, 0.04627509f, -0.05976276f, -0.02807616f, 0.01650445f, 
    -0.06662656f, 0.03986806f, -0.00790589f, -0.04657988f, -0.04031230f, 0.03301655f, 0.03545541f, -0.04236567f, 
    -0.01951677f, 0.04852755f, 0.00049520f, -0.00601703f, 0.00006346f, 0.04922179f, -0.05493401f, -0.03050660f, 
    -0.03272067f, 0.04443742f, -0.04483909f, -0.01116043f, -0.03527712f, 0.02911933f, -0.01914278f, 0.04679832f, 
    0.03591806f, -0.02523163f, 0.01144392f, -0.04844572f, -0.04428774f, 0.03328807f, 0.03662194f, 0.03246215f, 
    0.00464113f, -0.04811838f, -0.06146404f, 0.01497215f, -0.03112437f, -0.04559083f, -0.01226088f, 0.04845285f, 
    0.00138893f, -0.04558679f, 0.03461085f, -0.01405538f, 0.04764716f, -0.06417453f, 0.02838824f, 0.04791366f, 
    -0.02058388f, 0.12276824f, 0.02505652f, -0.18401381f, -0.26463816f, -0.06319897f, 0.06985890f, -0.03932851f, 
    -0.00971211f, -0.35827827f, -0.10711409f, 0.06640666f, -0.03917963f, -0.00727461f, -0.04153837f, 0.20271194f, 
    -0.03484386f, 0.17360678f, -0.14338288f, 0.01772943f, 0.37192574f, 0.08803169f, -0.10326815f, 0.18989943f, 
    0.07138226f, 0.15308236f, 0.04105447f, -0.37768117f, 0.53525484f, -0.05866635f, 0.13292907f, 0.04840648f, 
    -0.03104888f, -0.05085129f, 0.23202586f, -0.01803115f, 0.34889868f, 0.15650599f, 0.06483450f, 0.04267077f, 
    -0.05380334f, 0.11435771f, 0.15295836f, 0.02923378f, 0.04268418f, -0.16392234f, 0.14233010f, 0.07694504f, 
    -0.11539228f, -0.20345660f, 0.06238630f, -0.02669554f, 0.12687699f, 0.02571196f, -0.06633972f, 0.38678855f, 
    -0.18986638f, 0.07052668f, 0.11005078f, -0.07588159f, 0.05302412f, 0.03623629f, -0.04020204f, 0.06865358f, 
    0.05841584f, -0.07153908f, 0.12430330f, -0.12015782f, -0.05750670f, 0.06711069f, -0.01597457f, 0.00139002f, 
    0.06586056f, 0.18912080f, 0.05603521f, -0.52060193f, -0.31912825f, -0.08862913f, 0.15303774f, 0.22366567f, 
    0.04559123f, -0.02753702f, -0.02602972f, -0.21523391f, -0.02532275f, 0.08202763f, -0.06402727f, -0.08984210f, 
    0.04308685f, 0.10157977f, -0.08912174f, 0.10283568f, -0.07672826f, -0.10508870f, -0.33490592f, -0.04590222f, 
    0.08900613f, 0.16054924f, 0.11554061f, 0.10998169f, 0.02321576f, -0.10768433f, -0.31140089f, 0.01664653f, 
    0.03260570f, 0.28553826f, 0.09198420f, 0.06211434f, 0.10365154f, 0.12623098f, 0.09194323f, 0.04504148f, 
    0.07091177f, -0.15644056f, 0.04717275f, 0.16660665f, 0.07091357f, -0.31651181f, -0.10416622f, -0.10755544f, 
    0.05476030f, -0.09782921f, 0.17486782f, -0.08374052f, -0.07462149f, 0.11315235f, 0.00302548f, 0.28176662f, 
    0.12499920f, 0.14925174f, -0.07252819f, -0.09634258f, 0.12937842f, 0.20253582f, -0.11873575f, -0.07279921f, 
    -0.35464755f, 0.04453532f, -0.00509811f, 0.00168010f, -0.04921709f, 0.09306392f, -0.07587922f, 0.05611072f, 
    0.02856306f, 0.18237676f, 0.22607759f, -0.09694852f, -0.27757418f, -0.19304173f, 0.03725023f, 0.14255910f, 
    0.07793166f, 0.15565956f, 0.25981358f, 0.51203704f, 0.10102399f, -0.13573387f, -0.20499463f, 0.08196560f, 
    -0.05705301f, 0.05221220f, -0.20305753f, -0.41305760f, -0.04985493f, -0.04100599f, 0.00430377f, -0.10900270f, 
    -0.02409178f, -0.08157552f, -0.17927003f, 0.40796638f, 0.27522653f, -0.26168278f, 0.04897321f, 0.32799110f, 
    0.08548345f, 0.13904127f, 0.14909488f, -0.04151430f, -0.26740867f, 0.01930573f, 0.16728580f, 0.05201362f, 
    0.05945769f, -0.15131301f, -0.20112179f, -0.16654697f, 0.07262560f, -0.59072018f, -0.29215086f, 0.11231951f, 
    0.17174155f, -0.39567772f, 0.01498168f, 0.00235416f, -0.10577833f, 0.07872890f, 0.03187643f, -0.06599262f, 
    0.10401580f, 0.10222831f, -0.23558527f, 0.02756898f, -0.00937888f, -0.02430435f, -0.03977523f, -0.31694797f, 
    0.08295061f, -0.45653966f, 0.03121214f, -0.09425466f, 0.18881260f, 0.21556702f, 0.06534596f, 0.18669082f, 
    0.04809578f, 0.28288543f, -0.11312952f, -0.03319711f, 0.16851828f, -0.00734376f, -0.05722230f, 0.25746173f, 
    0.07543603f, -0.14873721f, -0.08022290f, 0.11642072f, -0.03112612f, 0.12888081f, -0.12453277f, 0.14716443f, 
    -0.08090613f, -0.14160329f, 0.30230951f, 0.05289046f, 0.16868293f, 0.01337559f, -0.41307059f, -0.34413454f, 
    -0.08465163f, -0.03131508f, 0.05416961f, -0.13058740f, -0.05986499f, -0.03090335f, -0.25935191f, -0.03083422f, 
    0.16992065f, 0.13128814f, -0.07279116f, 0.27504978f, -0.11525792f, 0.02457175f, 0.06558209f, -0.04533441f, 
    -0.04627649f, 0.11167839f, 0.24840836f, 0.13756856f, 0.12251021f, -0.03724142f, 0.22917080f, 0.02000906f, 
    0.05705228f, 0.11729266f, 0.17010014f, 0.13963395f, 0.06448637f, 0.04448902f, -0.06651735f, 0.45758218f, 
    0.01361046f, -0.06463649f, -0.02192994f, -0.02801459f, 0.08673323f, -0.03826237f, -0.08914340f, -0.16697592f, 
    0.08269398f, 0.15171854f, -0.28506583f, 0.03550997f, -0.64859051f, -0.05803931f, -0.13448976f, 0.08533819f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.07858197f, 0.14965583f, -0.05030317f, 0.39246714f, -0.13542441f, 0.02282941f, -0.01411424f, 0.23830527f, 
    0.00431397f, 0.19424176f, 0.27586883f, 0.40530932f, 0.15007815f, 0.04723125f, 0.05642630f, -0.30845946f, 
    -0.01977411f, 0.14828309f, 0.11670513f, -0.00769124f, -0.05883320f, 0.00226524f, -0.10746480f, -0.08420264f, 
    -0.00418160f, 0.03873785f, -0.01677297f, 0.05142169f, -0.02902620f, 0.03142402f, -0.01802826f, 0.01973780f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00665959f, -0.73581678f, -0.09411442f, -0.32814312f, 0.07487645f, 0.19442813f, -0.05908407f, -0.21889290f, 
    0.34191716f, 0.06914017f, -0.48654449f, -0.12968428f, 0.48108545f, 0.21835394f, 0.33476174f, 0.54328722f, 
    0.14494173f, 0.03830565f, -0.59460312f, 0.46108946f, 0.08736740f, -0.21624421f, 0.25218502f, -0.26477388f, 
    -0.00550026f, 0.19192705f, 0.12746184f, 0.13691057f, 0.05225671f, 0.09905947f, -0.10496631f, -0.18161251f, 
    0.02510097f, -0.27356231f, 0.15832087f, 0.23314944f, -0.06214622f, 0.10522912f, 0.00222203f, -0.13620561f, 
    -0.19843832f, 0.30729285f, 0.49250129f, 0.27450380f, -0.09937271f, -0.07751751f, 0.59355068f, 0.38719904f, 
    0.10562784f, 0.13755241f, -0.38508946f, -0.09279844f, -0.08775881f, -0.30695409f, -0.00601606f, -0.73499924f, 
    0.13640833f, -0.07948314f, 0.11360245f, -0.05044561f, 0.06291700f, 0.14141165f, 0.11578599f, -0.45468506f, 
    -0.45610261f, 0.02890605f, 0.04203607f, -0.13163085f, -0.50260723f, 0.19986972f, 0.01947828f, 0.09285543f, 
    -0.20817998f, -0.32932526f, 0.18838440f, -0.09523972f, -0.21705447f, 0.10027724f, 1.19113517f, -0.45133781f, 
    -0.15025742f, 0.12037319f, 0.01385213f, 0.21195446f, 0.13223276f, 0.16904886f, -0.06341198f, -0.41050971f, 
    -0.06254181f, -0.75703871f, -0.16395304f, 0.48062316f, -0.09141629f, -0.16181059f, -0.12136033f, -0.38663962f, 
    0.33898100f, 0.18102933f, 0.13836935f, -0.15874039f, 0.46757320f, -0.08475073f, -0.01548937f, -0.38800806f, 
    -0.42670789f, -1.07894015f, -0.48701480f, -0.05629615f, -0.22687848f, 0.44374719f, -0.03828989f, 0.13548568f, 
    -0.00010902f, -0.58996975f, 0.24159351f, -0.49924496f, 0.10452078f, 0.28136796f, 0.29443505f, 0.34589884f, 
    0.01873854f, -0.23177686f, 0.05080068f, -0.30230436f, 0.15272763f, 0.00873175f, 0.04411720f, 0.14746070f, 
    -0.29812625f, -0.53399968f, -0.02265409f, -0.19566038f, -0.06290548f, -0.08145183f, -0.16407159f, 0.13600250f, 
    0.26703373f, 0.04283627f, 0.11346771f, -0.27485099f, -0.16230118f, -0.55793077f, -0.13894366f, -0.18328187f, 
    -0.10741544f, 0.09280635f, 0.20958860f, -0.13487642f, -0.07876981f, 0.11038189f, 0.18528171f, 0.12068997f, 
    0.04363189f, 0.75015324f, 0.02516443f, -0.05609263f, 0.03125776f, 0.07229853f, 0.13647027f, 0.44632086f, 
    0.15095291f, 0.46239826f, 0.06389566f, 0.03534656f, 0.24359798f, -0.07086572f, -0.08029885f, -0.13221654f, 
    0.37168226f, -0.07601530f, 0.42267963f, 0.09958322f, 0.51339149f, -0.47785541f, -0.34630686f, -0.50158000f, 
    0.00243563f, 0.32646722f, -0.60913259f, -0.24224342f, 0.12362858f, -0.29076418f, 0.04569395f, 0.17617038f, 
    -0.08137501f, -0.00892615f, -0.01241421f, -0.20167378f, 0.15178664f, 0.05403318f, 0.04525765f, -0.14762159f, 
    -0.41766202f, 0.18554229f, 0.04641308f, 0.07802657f, -0.42814657f, 0.24584699f, -0.07401566f, 0.53580087f, 
    -0.09692305f, 0.14659058f, -1.14232802f, -0.27912036f, -0.58942252f, -0.24367920f, -1.05538881f, -0.49646240f, 
    0.02657822f, -0.02258066f, 0.05488385f, -0.36398426f, 0.15236098f, 0.13118647f, -0.37193057f, -0.18623760f, 
    0.10037246f, 0.06171506f, 0.03595292f, 0.73275226f, 0.04988243f, 0.14830109f, -0.01652468f, -0.69986463f, 
    -0.08006130f, 0.08517109f, -0.10158312f, -0.28048974f, -0.27822354f, 0.02216883f, 0.13699122f, -0.43764177f, 
    -0.20179917f, 0.32169166f, -0.59791464f, 0.11728468f, -0.42457783f, 0.74210173f, 0.12942427f, -0.36039212f, 
    0.12487236f, -0.11783899f, -0.30056736f, 0.11275822f, 0.07008166f, -0.01121379f, 0.44331464f, 0.36497730f, 
    -0.12824807f, -0.23407497f, -0.06825054f, -0.09820528f, -0.13333817f, 0.03338492f, -0.07005687f, 0.23649642f, 
    0.20556286f, 0.26525009f, 0.11519069f, 0.10703726f, -0.85818106f, -0.19066270f, -0.16229625f, -0.28233221f, 
    0.41902012f, -0.24354330f, -0.30802569f, 0.30383137f, -0.80571485f, 0.77128017f, -0.38167310f, -0.17482525f, 
    0.02388626f, 0.29226947f, -0.37666059f, -0.43176204f, -0.11918356f, 0.12334486f, -0.47224325f, -0.44389191f, 
    0.11741597f, -0.42402408f, -0.02542852f, -0.47227257f, -0.06929770f, 0.04583104f, -0.08256953f, -0.20952693f, 
    -0.06299320f, -0.19231975f, 0.00382446f, -0.20888895f, -0.95265007f, 0.40463579f, -0.06714947f, 0.42655757f, 
    -0.53981239f, -0.39203873f, -0.01809765f, 0.03265054f, 0.80981445f, -0.44462442f, -0.57114488f, -1.02386296f, 
    0.16506994f, -0.22229153f, 0.20619251f, -0.03263943f, 0.05523435f, 0.18023041f, 0.11015226f, 0.40481806f, 
    0.13572894f, 0.09127792f, -0.12254157f, -0.00264458f, 0.00578423f, 0.08259151f, -0.04988134f, 0.48083070f, 
    0.42947224f, -0.09068013f, 0.01189747f, 0.13155907f, 0.06312476f, -0.89887035f, -0.09342329f, -0.39678362f, 
    -0.14001881f, -0.27246112f, 0.22839877f, -0.36845377f, 0.23334502f, 0.23312595f, -0.36646619f, 0.07469458f, 
    0.06826587f, 0.29803163f, 0.48930809f, 0.70833766f, 0.06630592f, -0.16510436f, -0.59571093f, -0.88336307f, 
    -0.16694039f, -0.71684361f, -0.12857269f, 0.05376116f, 0.06689316f, -0.01932475f, -0.07727424f, 0.49683982f, 
    0.17067832f, 0.18199059f, 0.01398891f, 0.08853633f, -0.26229602f, -0.38698086f, -0.01176214f, 0.03957497f, 
    -0.35108742f, 0.26972768f, -0.54892796f, 0.31239626f, -0.53031397f, -0.52860010f, -0.34388354f, -0.68904948f, 
    -0.15275052f, 0.02661262f, 0.87380677f, -0.93791693f, 0.13791639f, 0.39706704f, -0.59832746f, 0.12357643f, 
    -0.01440088f, -0.14918126f, -0.15866488f, -0.70031559f, -0.11587358f, 0.04134431f, 0.04400433f, -0.23766573f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.46262321f, 0.15936874f, -0.11104343f, -0.07409616f, 0.08208878f, 0.11211477f, 0.11746527f, -0.51227719f, 
    0.35012183f, 0.11915943f, -0.06281382f, -0.00283640f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
