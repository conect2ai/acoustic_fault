#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.24469881f, -0.67340875f, -0.60236919f, -0.31846753f, 0.12524258f, -0.49128935f, -0.42491823f, -0.42500222f, 
    -0.11252099f, -0.43913054f, -0.11875483f, -0.26656884f, 0.10479231f, -0.01028024f, 0.00195111f, 0.04172829f, 
    0.00936299f, 0.33231550f, -0.27396968f, -0.03524769f, 0.10388086f, 0.29264396f, 0.27287164f, 0.29884052f, 
    0.44833621f, 0.12664972f, -0.33580709f, -0.64453137f, -0.42449355f, -0.45383215f, -0.41165054f, -0.31422246f, 
    -0.45201224f, -0.46537691f, -0.53164107f, 0.35957378f, 0.48624665f, 0.23049410f, -0.33050993f, -0.29692879f, 
    0.27468461f, -0.02418396f, 0.11190709f, 0.12201643f, -0.01367693f, -0.06080367f, -0.05811624f, -0.00602961f, 
    -0.02528570f, -0.21831612f, 0.66597956f, 0.04400573f, 0.21361636f, -0.26747045f, 0.61541748f, 0.01081858f, 
    0.23029739f, 0.32530814f, -0.31387907f, 0.00495070f, -0.43618348f, 0.00064613f, 0.59519827f, -0.39922148f, 
    -0.29615998f, 0.09911914f, -0.08474118f, -0.02582838f, 0.01154130f, -0.10983383f, 0.00558902f, 0.17509392f, 
    0.00534763f, 0.18435964f, -0.12640533f, -1.21537423f, -0.02304764f, -0.51968306f, -1.16589701f, -0.23241891f, 
    0.48426706f, 0.03090735f, -0.26587090f, 0.04560536f, 0.14741628f, -0.56265742f, -0.37576771f, -0.15873386f, 
    -0.39843094f, -0.16320217f, 0.11447828f, -0.25200713f, -0.23660184f, 0.12504743f, -0.02382907f, -0.00534590f, 
    0.31025955f, -0.17779981f, -0.22169535f, -0.09042972f, -0.22208725f, -0.04314629f, 0.58927643f, 1.02610493f, 
    0.30258605f, -0.04187012f, -0.67490017f, -0.56564188f, -0.29076558f, -0.26872954f, 0.00143730f, -0.17598258f, 
    0.03061075f, 0.06244784f, 0.00107591f, -0.03767916f, 0.26275757f, -0.31729832f, 0.03214522f, -0.09753023f, 
    -0.12492847f, 0.05412524f, -0.14475025f, 0.05293928f, -0.11584932f, -1.10696089f, -0.46960145f, -0.65188646f, 
    -0.23411036f, 0.00097647f, 0.49640733f, 0.24524160f, -0.12777798f, 0.26949733f, 1.15420866f, 0.14176604f, 
    0.10022792f, -0.04517074f, 0.27793086f, -0.04822664f, -0.12774019f, -0.09918281f, -0.11428482f, 0.06130835f, 
    -0.09829484f, -0.05612697f, -0.09729896f, 0.10316773f, 0.13406980f, -0.05930569f, 0.91597867f, -0.32315439f, 
    -0.28699422f, -0.31291646f, -0.58848923f, 0.18515359f, 0.03295307f, 0.35956529f, 0.15111572f, -0.14677796f, 
    -0.24852943f, -0.02526469f, 0.20214702f, 0.19928381f, -0.02766086f, 0.32056639f, -0.39032513f, -0.27475125f, 
    -0.11949980f, -0.05721352f, 0.03947894f, 0.02410849f, -0.09109177f, -0.42848805f, -0.29818189f, 1.12764287f, 
    -1.21437061f, -0.42835206f, -0.47669229f, 0.24914278f, 0.76220578f, -0.01293748f, -0.30450296f, -0.18117855f, 
    -0.02107166f, 0.25754794f, -0.24251506f, 0.00827778f, -0.42762482f, -0.01849077f, 0.21828598f, -0.13574138f, 
    -0.00036581f, -0.16501115f, -0.32700378f, -0.15960984f, -0.18979184f, -0.24407820f, 0.12453371f, 0.02476420f, 
    0.20032933f, 0.86303180f, 0.41497073f, -0.44889522f, -0.38468227f, -0.39849347f, -0.36288124f, 0.10942962f, 
    -0.04120429f, -0.39437982f, -0.07221730f, -0.16033560f, 0.55989838f, -0.13607121f, -0.10379463f, 0.31399038f, 
    -0.01666422f, -0.15102534f, -0.09051594f, -0.40827703f, 0.18227386f, 0.26634809f, 0.03010272f, 0.09172543f, 
    0.27559245f, -0.39448810f, 0.12021936f, -0.36943474f, 0.56845534f, 0.15774459f, 0.36304370f, 0.21791267f, 
    -0.04976131f, -0.14537926f, 0.07479639f, 0.08136917f, -0.45546749f, -0.13954271f, 0.18833858f, 0.06001144f, 
    0.06140127f, 0.03941671f, -0.07543402f, 0.22441021f, -0.14744301f, -0.11768638f, 0.13922086f, -0.25227073f, 
    -0.47804558f, -0.52677214f, 0.58327383f, -0.42239389f, -0.34371790f, -0.60350162f, -0.83359385f, 0.72306901f, 
    0.11022884f, 0.60909981f, -0.16026406f, 0.09331726f, -0.34981492f, 0.05982062f, -0.11384364f, -0.36152169f, 
    0.23034224f, -0.36696514f, 0.30930474f, 0.11857555f, -0.34397104f, 0.24567576f, -0.02878774f, -0.00299463f, 
    -0.10890951f, 0.05992777f, 0.26140013f, -0.47363916f, 0.13788168f, 0.03233982f, -0.62194705f, -0.36724609f, 
    0.12125652f, -0.04799492f, -0.04217050f, -0.71082300f, -0.67833400f, 0.26528931f, 0.47304359f, 0.21074632f, 
    0.46829072f, 0.14788076f, -0.22398889f, -0.66651279f, -0.48036194f, -0.14775459f, -0.25897619f, -0.05990393f, 
    0.08370953f, 0.24898085f, 0.03455944f, -0.16260107f, 0.28675857f, -0.46223673f, 0.06535453f, 0.07483836f, 
    0.23149978f, -0.27676144f, -0.26796058f, 0.49257487f, -0.07429416f, 0.36413595f, -0.15149035f, -0.27554625f, 
    0.02765944f, 0.21012682f, 0.19128460f, 0.17206059f, -0.40248990f, 0.10208309f, 0.04156641f, -0.50486487f, 
    0.41955760f, -0.22102071f, -0.30628636f, 0.31421581f, -0.05555312f, 0.35166425f, 0.15538540f, -0.07641934f, 
    0.48880789f, -0.30705893f, 0.03552302f, 0.02399310f, 0.05466429f, 0.10032958f, 0.39585695f, 0.04816132f, 
    0.00762997f, -0.09432562f, 0.28190592f, -0.07024775f, -0.49743113f, 0.27156708f, -0.03922414f, -0.24657154f, 
    -0.05291837f, 0.00625733f, 0.15043771f, 0.27943385f, 0.29319257f, 0.19214250f, 0.56330639f, 0.56165433f, 
    0.17437680f, -0.26271439f, -0.00125507f, 0.06567547f, 0.02928234f, 0.38135365f, 0.12460540f, 0.18792818f, 
    -0.11741536f, -0.25259358f, 0.17046115f, -0.39747548f, -0.00867363f, 0.12531467f, 0.42857102f, -0.13309830f, 
    -0.05541500f, -0.04008979f, -0.33575815f, -0.31400037f, 0.04621773f, 0.10112372f, -0.34936798f, -1.11072540f, 
    -0.81741065f, 0.26858103f, 0.70596021f, 0.49755973f, 0.77266032f, 0.58501691f, -0.53764933f, -0.66374177f, 
    -0.00469442f, -0.11637408f, -0.33994859f, -0.05593917f, 0.27586725f, -0.53355491f, -0.21289642f, -0.13203605f, 
    0.15544650f, 0.23769301f, -0.14661492f, -0.06592994f, 0.03427963f, -0.04229042f, 0.15480801f, -0.00471427f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.12927487f, -0.17615387f, 0.35038391f, -0.22873385f, 0.12936866f, 0.26916015f, 0.13045537f, 0.15232028f, 
    0.42858693f, 0.03925686f, 0.33936769f, 0.00095686f, 0.46301705f, 0.06301925f, -0.03270461f, 0.20979443f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.08059993f, -0.14489682f, -0.07485227f, -0.00762883f, 0.04135926f, -0.01076646f, 0.03727211f, -0.00374369f, 
    0.01691893f, -0.04005716f, -0.04559676f, 0.02516930f, -0.05892901f, -0.24724819f, -0.36476964f, -0.05852524f, 
    0.13970336f, 0.15024154f, 0.14333928f, -0.02268703f, -0.10520244f, -0.11680690f, -0.07800996f, -0.03663995f, 
    -0.05436316f, 0.32591593f, 0.08457552f, -0.05444578f, -0.13630100f, 0.07829393f, -0.20627464f, -0.15939122f, 
    -0.09245721f, 0.00090114f, 0.08264909f, 0.09428637f, 0.36392909f, -0.05099516f, -0.09826215f, -0.11323340f, 
    0.25185475f, 0.09182841f, 0.20879568f, 0.00058520f, 0.01039967f, 0.03988526f, 0.05364248f, 0.11983484f, 
    0.23718444f, 0.46873122f, 0.32759726f, -0.12757552f, 0.13327636f, -0.28006363f, 0.13490042f, -0.08013244f, 
    0.08215941f, -0.03413846f, -0.12095089f, 0.03821080f, 0.22098061f, -0.50563979f, -0.29410556f, -0.23533122f, 
    0.09250059f, 0.09641364f, 0.18569736f, 0.05347246f, 0.15402216f, 0.06422447f, 0.05926978f, 0.07405191f, 
    0.03713931f, -0.33591002f, 0.00394472f, 0.24147694f, 0.07158912f, 0.16974373f, -0.03118080f, 0.03006645f, 
    -0.07161692f, 0.03016955f, 0.17865077f, -0.16370699f, -0.08456188f, 0.31623769f, 0.26514694f, 0.08217011f, 
    -0.11233183f, 0.07179425f, 0.24064957f, -0.11618955f, 0.06934946f, 0.05042100f, 0.17177090f, 0.11975181f, 
    -0.18896388f, 0.11586727f, 0.14214185f, 0.19839834f, 0.30438101f, 0.08209366f, -0.07003014f, 0.12635995f, 
    0.05816689f, 0.03887362f, 0.21746160f, 0.22553530f, 0.09082621f, 0.06492322f, -0.00998049f, -0.17273997f, 
    0.02913595f, -0.04303848f, 0.06379502f, -0.01153331f, -0.12234494f, -0.16167381f, 0.08555938f, -0.19611987f, 
    -0.51816666f, -0.13683477f, -0.16764219f, 0.24855474f, 0.06826528f, 0.34120166f, 0.25524819f, 0.08173084f, 
    0.08158776f, -0.02567055f, -0.10779711f, 0.16244023f, -0.44319803f, -0.11315919f, -0.23100825f, 0.05825526f, 
    0.12456729f, 0.03313607f, -0.05898800f, 0.02856435f, 0.00414417f, 0.09132655f, 0.16581295f, -0.02002188f, 
    0.28169289f, -0.10417601f, -0.03476218f, -0.14468300f, 0.24736656f, -0.13001405f, 0.13018072f, 0.11013523f, 
    0.10440996f, 0.22729662f, 0.34299126f, -0.01058814f, -0.13175687f, 0.01333604f, -0.02288233f, -0.20329486f, 
    -0.03914161f, -0.03648316f, -0.07362254f, 0.02074450f, 0.01854597f, -0.03490549f, -0.03461757f, 0.10335817f, 
    -0.19278236f, 0.09746693f, 0.07740345f, 0.04172236f, -0.16114976f, 0.08313512f, -0.11751840f, 0.02666287f, 
    -0.02354756f, -0.03703634f, 0.10018717f, 0.06236339f, -0.06528794f, 0.50539762f, -0.33318898f, -0.09164621f, 
    0.20794432f, -0.02882976f, 0.23397861f, 0.17712212f, -0.04827508f, 0.04140700f, 0.26765999f, 0.25061560f, 
    -0.11705543f, 0.19724771f, -0.05145262f, 0.05420164f, -0.04626650f, 0.27458295f, 0.13722403f, -0.12310088f, 
    -0.00621926f, -0.01300966f, 0.00716687f, -0.05748247f, 0.27814409f, 0.09700786f, 0.10075530f, 0.10460781f, 
    0.21172272f, -0.03088744f, -0.07310705f, -0.07245024f, 0.04017753f, 0.09196188f, 0.02592153f, 0.15770723f, 
    -0.03379562f, -0.29005718f, -0.37687925f, 0.06005300f, -0.10820100f, -0.11325370f, 0.09946647f, 0.01492387f, 
    -0.10367240f, -0.06744226f, -0.07709403f, -0.05945785f, 0.15482311f, 0.32305366f, 0.11125270f, 0.29514763f, 
    0.13623658f, 0.25306326f, -0.03594954f, 0.15333858f, -0.06857401f, 0.05974582f, -0.10703322f, -0.15729590f, 
    -0.45721850f, 0.06456202f, -0.45437235f, -0.08602944f, 0.01701471f, -0.04720423f, -0.05545482f, 0.11037150f, 
    0.03473162f, -0.12065530f, 0.00190474f, 0.05883597f, 0.18365407f, 0.42100713f, 0.04382272f, -0.09283140f, 
    0.05931136f, -0.03364550f, 0.05917359f, 0.12959331f, 0.00490060f, 0.00727522f, -0.03549718f, -0.06590244f, 
    0.28573480f, 0.17375071f, -0.15147151f, 0.04136858f, -0.08867569f, -0.15624459f, 0.02540608f, -0.10243201f, 
    -0.00881287f, -0.09919587f, -0.21094178f, 0.12478853f, 0.24272098f, 0.35148850f, -0.36940861f, 0.19222488f, 
    0.06165039f, 0.01427861f, -0.14531395f, 0.14309761f, 0.07844618f, 0.07772147f, 0.04826702f, 0.06806651f, 
    0.08645277f, -0.24708889f, 0.18204200f, -0.01735151f, -0.19732557f, 0.12743951f, 0.08297966f, -0.13387787f, 
    -0.09744202f, 0.07525270f, -0.07467613f, -0.09342727f, -0.07538312f, -0.04331192f, 0.08956747f, 0.16051579f, 
    0.06787562f, -0.04157526f, -0.07215919f, -0.10480516f, -0.01214334f, 0.07006885f, 0.01139938f, -0.00459378f, 
    0.66942412f, 0.34612149f, 0.18647002f, 0.06021924f, 0.14704995f, 0.29446295f, 0.08670577f, -0.06794189f, 
    0.15132643f, 0.09096313f, 0.03000117f, -0.25200373f, 0.52954167f, 0.04583797f, 0.19948372f, 0.13796389f, 
    0.08142376f, 0.14132315f, 0.03389666f, 0.35577562f, -0.11651295f, 0.00688195f, 0.00713579f, 0.21243066f, 
    -0.39748064f, 0.23469462f, 0.05218864f, 0.15178624f, -0.19541988f, 0.26563928f, -0.25715789f, -0.15339470f, 
    -0.13753875f, -0.18536308f, -0.05139984f, 0.01895297f, 0.01332680f, -0.29185998f, -0.35774368f, -0.27626359f, 
    -0.20107545f, 0.00859486f, 0.03271817f, -0.17357768f, -0.11014744f, -0.08717471f, 0.01907992f, -0.05842237f, 
    0.36169001f, -0.03670636f, -0.01792305f, 0.11740568f, -0.02846371f, -0.12743151f, -0.01201937f, -0.30075112f, 
    -0.02221148f, -0.05984557f, -0.03488786f, -0.13202101f, 0.23811787f, -0.04594154f, 0.39329889f, -0.01529998f, 
    0.13934273f, 0.07172161f, 0.26447317f, 0.02075803f, 0.07624658f, 0.06307420f, -0.07859578f, 0.06231756f, 
    -0.05312687f, -0.00454243f, -0.03120278f, 0.05469022f, -0.01464496f, -0.05529350f, -0.02788356f, -0.07435332f, 
    -0.06842452f, 0.01718589f, 0.01587349f, -0.01841512f, 0.03084111f, -0.03457684f, -0.06762207f, 0.06163173f, 
    0.04882390f, 0.05521984f, -0.07311857f, -0.05889726f, 0.01622728f, -0.05594451f, -0.03268578f, -0.04906301f, 
    0.00381157f, -0.06697608f, 0.01511553f, -0.02814415f, -0.06318984f, -0.03243983f, -0.00088630f, -0.06634761f, 
    -0.07709805f, -0.06890393f, -0.00374658f, -0.00857979f, -0.05919589f, 0.05122929f, -0.04186489f, -0.04764714f, 
    -0.01343190f, -0.00698356f, 0.06243480f, 0.04417835f, 0.06273377f, -0.06771615f, -0.04060624f, 0.02067968f, 
    0.06441504f, 0.06381910f, -0.02747896f, -0.05206752f, -0.03714790f, -0.05252326f, 0.02028294f, 0.06178798f, 
    -0.06030283f, -0.05755560f, -0.04864160f, -0.03355575f, -0.02008655f, -0.00335260f, -0.03233753f, 0.04474311f, 
    0.01055183f, 0.06195796f, -0.02042629f, 0.02250993f, -0.02529181f, -0.02136512f, 0.04083531f, -0.06177665f, 
    -0.04076402f, 0.03046947f, 0.04605622f, -0.01872596f, 0.00089264f, -0.05090341f, -0.02575969f, 0.04816081f, 
    -0.04737406f, 0.02560001f, 0.00833894f, 0.05960990f, -0.06027971f, -0.00215040f, 0.03896973f, -0.05006409f, 
    0.01092363f, -0.03710867f, -0.00222279f, -0.04438280f, 0.01099915f, -0.06099258f, 0.01853126f, -0.05814590f, 
    0.04061256f, -0.02099124f, -0.01612913f, -0.05494070f, -0.02808792f, -0.07130571f, 0.03746264f, -0.04045457f, 
    -0.00170691f, -0.06369396f, 0.05361705f, -0.04280784f, -0.00127693f, 0.03302968f, -0.05662524f, 0.04533722f, 
    -0.04903799f, -0.03179202f, 0.03959070f, -0.05834826f, -0.04697683f, -0.04605676f, 0.01374320f, -0.00712213f, 
    0.03923883f, 0.05647745f, -0.06557956f, -0.07427706f, -0.01659060f, 0.04216570f, -0.05835921f, -0.03792875f, 
    0.03590354f, 0.02963928f, -0.04336539f, -0.04743591f, 0.03480531f, 0.04838771f, 0.02455016f, -0.00181623f, 
    -0.01849014f, -0.04627657f, 0.04841968f, 0.00919887f, 0.04743394f, -0.04553742f, -0.05439670f, 0.04427632f, 
    -0.03135067f, -0.02960899f, 0.06424577f, -0.00161090f, -0.05686617f, -0.05137685f, -0.04409666f, -0.06514867f, 
    0.05557854f, 0.03698840f, 0.06638733f, 0.05716242f, -0.03677563f, -0.02674685f, -0.01386730f, -0.06523535f, 
    -0.01526272f, 0.07208415f, -0.04932063f, 0.01211963f, -0.01719149f, 0.02485899f, -0.02021502f, 0.00066573f, 
    -0.05149053f, -0.05490755f, 0.04194330f, 0.04254847f, 0.00123432f, -0.06307356f, -0.03199484f, 0.03583369f, 
    -0.04783966f, -0.01524309f, 0.06408659f, -0.07285600f, 0.00736387f, -0.06598095f, 0.01143698f, 0.06428987f, 
    0.00367745f, -0.05524783f, -0.05530966f, 0.02329969f, -0.02257085f, 0.05205422f, 0.03529040f, -0.03493510f, 
    -0.01396259f, -0.03078721f, -0.05668816f, 0.05732490f, -0.08334976f, 0.05367936f, -0.00775590f, 0.01558673f, 
    0.04509392f, -0.06707773f, 0.00968443f, -0.02456598f, 0.03570704f, 0.05472130f, -0.06106193f, -0.08291028f, 
    0.04242215f, -0.07304006f, 0.03778078f, 0.01822122f, 0.00433431f, 0.05687263f, 0.00383070f, 0.01351256f, 
    0.03725588f, -0.07790519f, -0.05408236f, -0.00406059f, -0.05139860f, 0.02079815f, -0.00176041f, 0.00812280f, 
    0.05951995f, 0.04134411f, 0.00698683f, -0.03726695f, -0.00934486f, -0.06861359f, 0.06868421f, -0.04982494f, 
    -0.06489505f, 0.06267311f, -0.01237666f, -0.04067184f, 0.00992389f, -0.04919639f, 0.05805691f, -0.06852266f, 
    -0.02754700f, -0.00101690f, 0.03167749f, -0.05026409f, -0.01052355f, 0.01595577f, -0.03390411f, -0.04429888f, 
    0.01213211f, -0.04945847f, 0.05847319f, 0.06681243f, -0.01635544f, -0.06849001f, -0.04619042f, -0.00441261f, 
    -0.06664005f, -0.00704100f, -0.00949500f, -0.07593347f, 0.02200128f, 0.01654826f, -0.01420818f, -0.05604019f, 
    -0.01564174f, -0.04333904f, 0.05336494f, -0.00466851f, 0.05099820f, 0.02780570f, -0.06519668f, -0.04106620f, 
    -0.00281311f, 0.00412305f, -0.04570687f, 0.01533024f, -0.02711588f, 0.02906332f, -0.00219375f, 0.01886905f, 
    0.07486879f, 0.03370795f, -0.00927857f, 0.02766935f, -0.03607772f, 0.03614807f, -0.07451241f, -0.05519234f, 
    -0.00412493f, 0.01525540f, 0.00039285f, 0.06125024f, -0.04568561f, -0.08447696f, 0.04262488f, -0.01840496f, 
    -0.01181522f, 0.07255261f, -0.07914264f, -0.04735479f, -0.03509135f, -0.02208735f, 0.05473441f, 0.03844870f, 
    -0.04673015f, 0.05429810f, 0.00764464f, -0.07296651f, 0.01949370f, -0.05463888f, -0.04350565f, -0.02862918f, 
    0.02868905f, 0.00440961f, -0.06528101f, -0.04832279f, -0.01227935f, 0.06268909f, -0.05301894f, 0.01736604f, 
    -0.02955177f, -0.02357907f, -0.05566627f, -0.08178871f, 0.03832375f, -0.03812972f, -0.03240193f, -0.07980575f, 
    0.01043455f, 0.04753972f, 0.00085401f, 0.05888182f, -0.01858160f, -0.05011009f, -0.02082824f, 0.05348245f, 
    -0.06855588f, 0.02291223f, -0.06563503f, 0.01041080f, 0.06082077f, 0.04119826f, -0.05798889f, -0.03122569f, 
    -0.04125655f, 0.02975389f, -0.07334428f, -0.06104664f, -0.05145302f, -0.01149596f, -0.06633205f, -0.04454791f, 
    -0.01108139f, -0.06616004f, 0.03060528f, -0.07234184f, 0.03382076f, 0.05477726f, -0.04673377f, 0.04564023f, 
    -0.04639572f, 0.02931309f, -0.03032062f, 0.07539676f, -0.03593267f, -0.01129199f, 0.01955192f, 0.02007841f, 
    0.04607242f, -0.07459314f, -0.08859981f, 0.04930412f, -0.06011552f, -0.05401876f, -0.03513904f, 0.05148965f, 
    0.03384966f, 0.05862869f, -0.06083712f, 0.05738594f, -0.00557318f, -0.03117561f, -0.08290035f, 0.02762649f, 
    -0.24154602f, -0.25664911f, 0.03838780f, 0.01821117f, 0.07783529f, 0.06505295f, -0.08481333f, 0.01198228f, 
    -0.15084831f, -0.13727495f, -0.08490308f, -0.09269240f, -0.40307572f, -0.11816290f, 0.28693369f, -0.02696474f, 
    -0.00261954f, -0.02851917f, 0.07734596f, -0.13453205f, 0.06237826f, -0.17974123f, 0.02528108f, -0.00272616f, 
    0.18340637f, 0.13467342f, 0.10477007f, -0.16932011f, 0.03077282f, 0.03528356f, -0.02589517f, 0.05690248f, 
    -0.06070786f, -0.01406311f, 0.01389508f, -0.15960465f, -0.37380168f, -0.31129915f, 0.15296564f, 0.09948206f, 
    0.21176338f, -0.12349635f, -0.01709552f, -0.09158672f, -0.02679393f, -0.21267432f, -0.04841974f, 0.23145504f, 
    -0.02116507f, 0.01988936f, 0.09442108f, 0.27711084f, -0.15430900f, 0.02379219f, -0.21732935f, -0.08524625f, 
    -0.00729238f, 0.05134112f, 0.07249330f, 0.06257679f, -0.01389742f, -0.20614025f, 0.41070974f, 0.13719849f, 
    -0.07312624f, -0.00169120f, -0.07032696f, 0.36473069f, 0.12625225f, -0.02935363f, -0.05091635f, 0.06494658f, 
    0.01669711f, 0.30022445f, -0.10596828f, -0.08994111f, -0.09813423f, -0.00801375f, 0.08675912f, 0.07831531f, 
    0.27159429f, 0.12225326f, 0.16282615f, 0.11597059f, -0.10293323f, 0.24973328f, 0.41636145f, -0.13420036f, 
    0.14825290f, 0.18069440f, 0.00326308f, 0.00170614f, 0.14258519f, 0.01549785f, 0.06154757f, 0.03583872f, 
    0.15729004f, 0.16824009f, -0.14113085f, -0.16189970f, 0.07237228f, -0.00633189f, 0.00774305f, -0.06519157f, 
    -0.12202091f, -0.19814289f, -0.06444873f, -0.19882961f, 0.02287017f, 0.08766437f, 0.05454260f, -0.29092577f, 
    -0.00205734f, 0.10571659f, 0.03761951f, 0.23334368f, 0.27357635f, 0.06769680f, 0.11416576f, 0.07703076f, 
    -0.26089528f, 0.23609994f, 0.11519595f, 0.16761343f, 0.05672744f, -0.21019897f, 0.02289675f, 0.03338724f, 
    -0.05214486f, -0.07042776f, -0.00542497f, 0.12133586f, -0.09999321f, 0.22692527f, 0.21199214f, 0.06783264f, 
    0.10269684f, -0.19068223f, -0.04869184f, -0.16928405f, 0.03189482f, 0.07884749f, 0.09321086f, -0.14582753f, 
    0.18936317f, -0.07756499f, -0.21657547f, -0.18913671f, 0.00325833f, 0.03682964f, 0.24527974f, 0.12066887f, 
    0.05099977f, 0.25513318f, 0.01447308f, 0.27830085f, 0.11122654f, -0.01892191f, 0.08567645f, 0.06934080f, 
    0.00740307f, -0.21208610f, 0.04525231f, 0.01967711f, 0.04205253f, -0.24162394f, -0.26641759f, -0.09713539f, 
    0.19971323f, 0.08292573f, 0.07413724f, -0.05825574f, -0.08397089f, -0.01525423f, -0.04524330f, 0.04933956f, 
    0.31506446f, 0.23954451f, 0.09773450f, 0.11497167f, -0.22363301f, 0.11110852f, 0.16208060f, -0.01693762f, 
    0.00773333f, 0.07684401f, -0.16539420f, -0.09506538f, -0.11263931f, 0.18753403f, 0.02817060f, -0.08849857f, 
    -0.03894162f, -0.06449139f, 0.01518936f, 0.03722318f, -0.01532175f, 0.04308958f, -0.03127919f, 0.11133754f, 
    -0.35643789f, -0.25579917f, -0.28104424f, -0.43180573f, 0.05915470f, 0.01230193f, -0.04056465f, 0.23620129f, 
    0.11727791f, -0.04382763f, 0.12218376f, 0.20439963f, 0.19909018f, 0.16584332f, 0.31565905f, 0.02315678f, 
    0.11056506f, 0.04923169f, -0.09268365f, -0.06061762f, 0.10460379f, -0.17655729f, -0.03559747f, -0.14493570f, 
    -0.04688434f, -0.11950572f, -0.02851986f, -0.13085382f, 0.33979458f, -0.16863903f, -0.00950895f, 0.22595569f, 
    0.12538221f, 0.10698324f, -0.03786737f, 0.16199188f, 0.12426784f, 0.08560926f, 0.10965800f, 0.19735983f, 
    0.23064493f, 0.43772167f, 0.28284863f, 0.22827122f, 0.01175866f, 0.03765795f, 0.07925733f, -0.05402096f, 
    -0.10018398f, 0.13596290f, -0.07386356f, 0.17593566f, 0.54395711f, 0.05543843f, -0.06210350f, 0.15173180f, 
    0.02419904f, 0.06759748f, 0.23594424f, -0.17455249f, -0.00057503f, -0.05037460f, -0.13822900f, -0.02789808f, 
    -0.31718314f, -0.14812374f, 0.14953479f, 0.30615738f, 0.02522095f, 0.06028706f, 0.00985618f, -0.07287636f, 
    0.00814384f, 0.13287233f, 0.05130596f, 0.31836811f, -0.20654459f, -0.03112001f, 0.12139261f, 0.16803290f, 
    0.06420119f, 0.08090419f, 0.24451913f, -0.17671064f, 0.04253946f, 0.23262379f, 0.27300489f, 0.21312951f, 
    -0.10968096f, 0.27410626f, 0.18059184f, 0.05705427f, -0.01994564f, 0.20838356f, -0.02106279f, 0.06241472f, 
    -0.22085065f, -0.27438360f, -0.20185171f, -0.49843052f, 0.18086429f, -0.08181171f, 0.03761979f, 0.28882807f, 
    -0.00979270f, 0.02182664f, -0.05521852f, 0.03413723f, 0.27322474f, 0.15041083f, 0.27783027f, 0.46009576f, 
    -0.34295630f, 0.05733069f, 0.02062351f, 0.03168242f, -0.21583758f, 0.00339241f, -0.04450133f, -0.05226059f, 
    -0.15934508f, -0.12820043f, -0.19285002f, -0.08706629f, 0.11953092f, 0.28528860f, -0.11848856f, 0.35133150f, 
    -0.05606751f, -0.17059544f, 0.08400331f, 0.01116822f, 0.01574346f, 0.01484498f, 0.08966442f, 0.09150880f, 
    -0.12147869f, -0.09782410f, -0.16338322f, -0.03103589f, -0.17815299f, -0.07968445f, -0.01930949f, -0.35122594f, 
    -0.03321538f, 0.13831982f, -0.02901394f, -0.09658775f, 0.07429028f, -0.11374621f, 0.03647932f, -0.28266624f, 
    -0.10582459f, -0.01791781f, -0.08914676f, -0.08075222f, -0.31626382f, -0.37303421f, -0.30950940f, -0.23819709f, 
    -0.16555469f, -0.01274649f, -0.05766397f, 0.05817455f, -0.03205213f, 0.07648639f, -0.03427226f, 0.10140353f, 
    -0.03262418f, 0.32017308f, 0.20293862f, 0.31155831f, -0.13748148f, -0.00327676f, -0.09004664f, -0.15946363f, 
    0.00641751f, 0.21687724f, -0.02251251f, -0.02311852f, -0.26390275f, -0.03158290f, -0.04683949f, -0.15416935f, 
    -0.07202110f, 0.01553988f, -0.00546731f, -0.03203315f, -0.06287660f, -0.00949204f, 0.06448675f, -0.00617087f, 
    -0.00585950f, -0.04623002f, 0.00914126f, 0.02435500f, 0.01920024f, 0.07127684f, 0.03628025f, 0.06312235f, 
    0.01774892f, -0.00091074f, -0.03330328f, -0.01408623f, -0.01931474f, 0.00385744f, 0.01688180f, 0.01935343f, 
    0.01664479f, 0.02965931f, 0.00201728f, -0.06689674f, -0.04143411f, -0.02322810f, 0.04174123f, -0.04445453f, 
    -0.07155707f, -0.02859088f, 0.04488892f, -0.01448373f, 0.03184979f, -0.07814877f, -0.00360616f, -0.02419440f, 
    0.05453089f, -0.05293551f, -0.06743172f, -0.03012745f, -0.03482826f, -0.00540119f, 0.01631787f, -0.04561451f, 
    0.04726113f, -0.02281199f, 0.02621989f, 0.04746420f, 0.04900777f, 0.06384555f, -0.04250368f, -0.07561195f, 
    -0.03099910f, 0.04491606f, -0.03816911f, 0.03454035f, -0.07264035f, 0.01387574f, -0.04896640f, 0.06169864f, 
    -0.03521485f, 0.02374372f, -0.01023280f, -0.03978087f, 0.02202517f, -0.02061346f, 0.02387541f, 0.04172288f, 
    0.04597150f, -0.02983186f, -0.00817579f, -0.04161513f, -0.06760469f, -0.03316290f, 0.04384188f, 0.06049109f, 
    0.00278149f, -0.04818153f, -0.02263690f, 0.02117208f, -0.05362567f, -0.02805454f, 0.02931923f, -0.07250534f, 
    0.05148905f, 0.00505023f, -0.01826775f, 0.06136746f, 0.01414983f, 0.00793185f, 0.04130509f, -0.02946986f, 
    -0.01057994f, -0.06134204f, 0.03220430f, -0.03554770f, -0.00222458f, -0.06265872f, -0.03453280f, -0.04302349f, 
    -0.02667656f, -0.06486816f, 0.05948681f, 0.01501821f, -0.02327682f, -0.00953475f, -0.07681347f, 0.06076897f, 
    0.02363499f, -0.00541233f, -0.00840114f, 0.00430782f, -0.05025090f, 0.03947564f, -0.07154200f, -0.01755228f, 
    -0.01083986f, -0.07250829f, -0.01640036f, -0.03592461f, 0.01881893f, 0.03109460f, 0.05826353f, -0.06391793f, 
    -0.04900297f, -0.00339714f, -0.03497056f, 0.05734069f, 0.06132574f, -0.04578032f, 0.05483595f, -0.04961452f, 
    -0.02668704f, -0.01944319f, -0.06647156f, -0.04506519f, -0.06204930f, 0.02630478f, -0.02284534f, -0.04368173f, 
    -0.05725909f, -0.00503604f, 0.00960697f, 0.05887295f, -0.03967186f, 0.02640773f, 0.03432707f, -0.04243736f, 
    -0.03140273f, -0.04633978f, -0.04003536f, -0.04879046f, -0.04195471f, 0.00682416f, 0.03226432f, -0.06885412f, 
    0.03317587f, 0.01175856f, 0.02881450f, -0.04464919f, 0.03817561f, -0.01080860f, 0.01845840f, 0.05531344f, 
    -0.07514589f, 0.05288197f, -0.07056133f, 0.05467601f, -0.04132012f, -0.01308311f, -0.01285896f, 0.05102430f, 
    0.05797727f, 0.03160459f, -0.03030288f, -0.01197618f, 0.04487338f, -0.04302256f, 0.00218874f, -0.06499255f, 
    0.01579927f, 0.01285374f, -0.03772781f, 0.00605855f, 0.01464215f, 0.00305482f, -0.05791903f, -0.04768948f, 
    0.15476294f, -0.16011527f, -0.19484454f, -0.18656954f, 0.12315331f, -0.08021408f, 0.07857376f, -0.02853700f, 
    -0.03445771f, 0.03780749f, -0.18677367f, -0.06671946f, 0.14876783f, 0.03242759f, -0.39706001f, 0.01857082f, 
    0.22372113f, -0.09764463f, 0.03103137f, 0.19800028f, -0.16301250f, -0.03370559f, 0.06969240f, 0.01763324f, 
    -0.21207543f, 0.06973154f, -0.08559434f, 0.25985968f, 0.38654777f, -0.23727222f, -0.03459738f, -0.24173853f, 
    0.03439558f, 0.06055444f, -0.08041470f, 0.21723095f, 0.51768488f, 0.00134527f, -0.37839952f, 0.03471266f, 
    0.17231297f, 0.22862433f, 0.03183555f, 0.08440626f, -0.10006691f, -0.04385455f, -0.09683396f, 0.11542554f, 
    0.06926407f, -0.12551533f, 0.22425596f, 0.03576995f, -0.06870040f, -0.05897561f, -0.05035982f, 0.04469926f, 
    -0.14993249f, -0.03586063f, -0.04686742f, -0.15081060f, 0.71071243f, -0.18336932f, -0.13390331f, -0.09068791f, 
    0.07198964f, 0.25882781f, 0.08004920f, -0.02929596f, 0.01084312f, 0.06026373f, -0.01577081f, -0.02344897f, 
    -0.19221291f, -0.03675393f, -0.02548339f, 0.22396299f, -0.02012278f, 0.03949272f, 0.04216754f, -0.17511001f, 
    0.04446849f, 0.12499843f, 0.08962787f, 0.22016163f, 0.02362940f, -0.16604713f, -0.08747856f, 0.15884961f, 
    0.08492361f, -0.06849372f, 0.09540852f, -0.09471038f, -0.06171050f, 0.16935198f, 0.10452603f, -0.06504171f, 
    -0.14543894f, 0.12820481f, -0.08863946f, 0.34688419f, -0.01885140f, 0.06197085f, 0.09339211f, 0.01843127f, 
    0.16283472f, 0.00805687f, 0.00925048f, 0.05168319f, 0.32131249f, -0.15107806f, -0.06799361f, 0.02511306f, 
    -0.15977091f, -0.05988653f, 0.02092524f, -0.24438258f, -0.00002401f, -0.01887708f, 0.14090577f, 0.21407677f, 
    -0.25046611f, -0.22558060f, -0.27971530f, 0.16776152f, -0.06048375f, -0.11620001f, 0.05809902f, 0.07875484f, 
    0.05277203f, 0.13743787f, -0.03088509f, 0.14091894f, 0.15280508f, 0.22219832f, -0.40680471f, 0.28469989f, 
    0.13450995f, 0.04895455f, 0.07810774f, 0.13570003f, 0.00510863f, 0.08985876f, 0.02087811f, -0.05112438f, 
    -0.04521827f, 0.13950945f, -0.09344944f, -0.04601625f, -0.02581953f, -0.26605609f, -0.11552148f, -0.29511169f, 
    -0.09398413f, 0.11236563f, -0.11573391f, -0.18858892f, 0.00151673f, 0.00402321f, -0.03287280f, -0.12080984f, 
    0.00562432f, 0.19507475f, -0.19086112f, -0.02616758f, -0.08699913f, 0.01143613f, 0.08004203f, 0.26014638f, 
    -0.38880950f, 0.10039856f, -0.16941299f, 0.06746637f, -0.12364362f, 0.19533373f, 0.07205132f, 0.23505485f, 
    -0.06873646f, 0.05622666f, 0.06685413f, 0.13618387f, 0.53316230f, 0.22768034f, -0.19014244f, -0.45404768f, 
    -0.01593097f, 0.18256323f, -0.17323539f, 0.10618804f, -0.10659663f, 0.00643520f, 0.12992528f, 0.09921873f, 
    -0.32508594f, -0.00573196f, 0.10374967f, 0.14042602f, 0.03348682f, 0.08971786f, 0.22037615f, 0.03185315f, 
    -0.12727518f, -0.18324633f, -0.00409533f, -0.08726700f, -0.29299736f, -0.06315088f, 0.11908212f, 0.06675545f, 
    -0.29872900f, 0.06501183f, -0.07357107f, -0.10382482f, 0.03899087f, -0.17206785f, -0.08785569f, 0.11594440f, 
    0.48603481f, 0.06909205f, 0.09448466f, 0.24955781f, -0.04820928f, -0.21725248f, 0.05223503f, -0.12781195f, 
    -0.06969605f, 0.10204194f, 0.10587874f, 0.01572462f, -0.23093618f, 0.07691006f, 0.10937723f, 0.28198275f, 
    -0.15993135f, -0.18976472f, 0.01359630f, 0.10771665f, -0.28861728f, -0.06692978f, -0.04518539f, 0.02541530f, 
    -0.12598406f, 0.07592161f, -0.33106455f, -0.00470213f, -0.10303041f, -0.24491836f, 0.00450930f, 0.05557568f, 
    -0.21456897f, -0.00511458f, 0.05333265f, -0.05655444f, 0.14352785f, -0.12148858f, 0.17914875f, 0.06287798f, 
    -0.13440964f, -0.06865201f, -0.09694082f, -0.00289954f, 0.03549577f, -0.04506547f, 0.17581879f, 0.17483400f, 
    0.58503234f, 0.44473866f, -0.03370824f, -0.08360343f, -0.05788861f, -0.02477558f, 0.00553233f, -0.11042384f, 
    0.13183928f, 0.13660228f, 0.03623638f, 0.09922905f, 0.38821250f, 0.12514593f, 0.33553267f, -0.08680464f, 
    0.00498113f, -0.06065628f, 0.16101097f, -0.00337394f, 0.36560264f, 0.12145685f, 0.25661010f, 0.20820707f, 
    0.17308885f, 0.29301932f, -0.09291904f, -0.03530844f, 0.04183017f, 0.01403866f, 0.31070438f, -0.19249232f, 
    -0.04806104f, 0.10982649f, -0.00887368f, 0.02784822f, -0.15667871f, 0.24109820f, 0.32373574f, 0.14576253f, 
    0.04959547f, 0.04147752f, -0.08005500f, -0.03506735f, -0.11181469f, -0.00931688f, 0.09042271f, -0.42569119f, 
    0.52160972f, 0.09443086f, 0.02727167f, -0.21416461f, 0.11504147f, 0.16104226f, 0.24642083f, 0.07597340f, 
    0.24232379f, -0.03663545f, -0.00289900f, -0.00878622f, -0.36946690f, -0.14227813f, 0.35906386f, -0.14314149f, 
    -0.07120968f, 0.16518673f, 0.22066991f, 0.32126969f, -0.00868609f, 0.16641746f, 0.18261717f, 0.29122317f, 
    0.30353406f, 0.31422159f, 0.21430945f, 0.29087868f, 0.03664257f, 0.07334535f, 0.06183416f, -0.10480016f, 
    0.17015971f, -0.02919238f, 0.21759975f, 0.26374659f, 0.07714928f, 0.10526057f, 0.12141081f, 0.03285406f, 
    -0.12383294f, -0.08915447f, -0.03394929f, -0.09861714f, 0.12483286f, -0.06016143f, -0.00041752f, 0.07465998f, 
    0.14488156f, 0.01475363f, 0.17630279f, 0.13657752f, -0.09505413f, -0.19596937f, 0.12940639f, -0.24387780f, 
    0.17496531f, 0.43459424f, -0.16956568f, 0.15501836f, -0.19959457f, -0.30208626f, 0.51652348f, 0.27874014f, 
    -0.05462746f, 0.09598459f, 0.07605298f, 0.28829500f, 0.23520498f, 0.16929297f, 0.32749254f, 0.06438679f, 
    -0.25287408f, -0.24612264f, -0.06403822f, -0.12995616f, 0.02640016f, -0.11240482f, -0.09355312f, 0.04981342f, 
    0.04844405f, 0.03995106f, 0.02812111f, -0.13869925f, -0.29697743f, -0.00915203f, 0.15723643f, 0.03007689f, 
    -0.06861927f, 0.01979043f, 0.12005656f, 0.17006437f, 0.10987816f, 0.11597854f, 0.01377090f, -0.08026157f, 
    0.16788945f, 0.07526764f, 0.17050298f, -0.09473191f, 0.12059698f, -0.08216368f, 0.03790911f, -0.09271285f, 
    0.09524564f, -0.04263270f, -0.06786791f, -0.11532895f, -0.23261665f, -0.37264228f, -0.00729085f, -0.09324893f, 
    0.09294017f, -0.02426273f, 0.00347231f, -0.01003274f, 0.08063122f, -0.04621033f, 0.07598411f, 0.07113133f, 
    0.36672479f, -0.14833599f, 0.06454337f, 0.07910690f, -0.07308895f, -0.00994199f, 0.07820383f, 0.13400431f, 
    0.08136109f, -0.01390356f, 0.03752255f, -0.12903202f, 0.37841567f, 0.03182249f, 0.05543224f, 0.10399750f, 
    -0.00664774f, -0.06792784f, -0.04234473f, -0.12718594f, 0.01807087f, -0.07562222f, 0.01546820f, 0.19217893f, 
    0.05393222f, 0.23546621f, 0.18762328f, -0.03721529f, 0.04383028f, -0.11719523f, 0.04827323f, 0.09944969f, 
    0.11308200f, 0.04852963f, 0.12504426f, 0.11923101f, -0.05577728f, -0.20893446f, 0.43258458f, -0.06415260f, 
    0.11488324f, -0.02348517f, 0.11017742f, -0.05345497f, 0.06484229f, 0.14361142f, 0.03460838f, -0.00416826f, 
    0.12620111f, 0.28211540f, -0.10200238f, -0.11706948f, -0.04226587f, -0.06047588f, 0.13247734f, 0.13001211f, 
    0.03767240f, -0.05952935f, 0.02502754f, -0.03708234f, 0.12719122f, -0.05713842f, -0.05356588f, 0.01369547f, 
    0.04935734f, -0.01973379f, -0.05655976f, 0.05249995f, 0.15985063f, -0.06283643f, 0.28570643f, 0.18124919f, 
    -0.25099796f, -0.01260092f, -0.08948395f, -0.21573554f, -0.09213755f, -0.08392852f, 0.12556829f, 0.27012455f, 
    -0.00200969f, -0.11491661f, -0.00314212f, 0.09743277f, -0.31953055f, 0.07963526f, 0.19452566f, 0.03777341f, 
    0.06236419f, -0.08286846f, 0.00810542f, -0.04103205f, 0.14934091f, 0.08756080f, 0.17861506f, 0.09405695f, 
    0.28395182f, -0.00282941f, -0.04888875f, 0.06954582f, -0.01329083f, -0.11092513f, 0.20295060f, 0.00104695f, 
    -0.03046906f, 0.19294173f, -0.00011252f, -0.00288472f, 0.11620328f, 0.02207929f, 0.13609293f, -0.03915984f, 
    -0.05859946f, -0.03132933f, -0.03877200f, 0.00510660f, 0.05337644f, -0.09961942f, -0.10522437f, -0.12690033f, 
    0.20909050f, 0.22276577f, -0.00482898f, -0.05205598f, 0.03005956f, -0.05260101f, 0.05289961f, -0.04410604f, 
    0.11435724f, 0.27033103f, 0.18424946f, 0.11337305f, -0.25032002f, -0.11177537f, -0.04320024f, 0.26281941f, 
    0.26819816f, 0.26034260f, -0.03208857f, 0.04021344f, -0.02606414f, 0.08689968f, 0.11542050f, -0.09293387f, 
    0.06059673f, -0.26789659f, -0.12379818f, -0.19605017f, 0.26682258f, -0.04924383f, 0.12619771f, 0.17533877f, 
    0.11407311f, 0.16649522f, -0.00195218f, 0.28725928f, 0.13859108f, 0.16081329f, 0.01623387f, -0.19489092f, 
    0.00927868f, 0.14466386f, 0.11589090f, 0.05034877f, -0.02927607f, -0.11493573f, -0.01965999f, 0.01187965f, 
    -0.43184981f, 0.03565308f, -0.04309481f, 0.02694558f, 0.02147474f, -0.04657084f, -0.12509818f, -0.15701105f, 
    -0.07713951f, 0.05402226f, 0.13721612f, 0.08027725f, -0.10642565f, 0.06580159f, -0.07318721f, -0.29408142f, 
    0.00891760f, -0.03500713f, 0.08786534f, 0.04615315f, 0.12640879f, 0.03148916f, -0.03564108f, 0.10556410f, 
    0.13687089f, -0.53694636f, 0.23857604f, -0.12390017f, 0.32166809f, 0.37058696f, 0.08327849f, 0.01437983f, 
    0.02366222f, -0.10371061f, -0.01713320f, -0.07621591f, -0.47801247f, -0.60336679f, 0.25833404f, -0.02936563f, 
    -0.11853698f, 0.03023147f, -0.05196043f, 0.04854433f, 0.17663927f, 0.02463431f, 0.05315151f, -0.04698485f, 
    0.14844902f, -0.03992568f, 0.08161053f, -0.08977880f, 0.15928325f, 0.14705656f, 0.02659032f, 0.16454642f, 
    -0.00128782f, 0.17106362f, 0.01505366f, -0.22339815f, 0.28731146f, -0.23130870f, 0.08946535f, -0.04706170f, 
    -0.04032898f, 0.23105463f, 0.07388967f, 0.18150511f, 0.06409654f, -0.16372140f, -0.04675317f, -0.03652158f, 
    -0.29755571f, 0.11469012f, -0.37266183f, 0.33817366f, 0.11123353f, 0.03702540f, 0.00401798f, 0.09327796f, 
    0.10555918f, 0.06362854f, 0.24934664f, 0.17417364f, 0.03886391f, -0.07493626f, 0.17741397f, -0.31230900f, 
    -0.07007034f, 0.08887251f, 0.15180373f, -0.06223565f, -0.07967760f, 0.04148634f, -0.26580545f, -0.30120376f, 
    -0.28007635f, -0.46318445f, 0.04743660f, 0.31659526f, 0.07384042f, 0.00528268f, 0.11041878f, 0.19959339f, 
    0.18857692f, -0.01171967f, 0.24732593f, 0.18596530f, -0.04798970f, 0.21059765f, -0.25865737f, -0.22300304f, 
    -0.01554182f, 0.19189464f, -0.03863484f, -0.03615579f, 0.13607912f, 0.11291432f, 0.07378289f, -0.01301379f, 
    0.28509152f, -0.00566991f, 0.15454166f, -0.20460217f, 0.21351577f, 0.01487291f, 0.02689453f, 0.13126571f, 
    0.12992603f, 0.12393088f, 0.11791299f, 0.03520241f, -0.14466436f, 0.07479277f, -0.05210345f, 0.01769202f, 
    -0.13887224f, 0.00860382f, -0.19317217f, 0.00836737f, 0.18410595f, 0.25220618f, 0.10022966f, 0.12169268f, 
    -0.40380892f, 0.04816215f, -0.19779173f, -0.02425209f, -0.11357117f, -0.01841732f, -0.13717195f, -0.09373557f, 
    -0.29319367f, -0.41926071f, 0.02183163f, -0.03383144f, 0.31519029f, 0.14218771f, 0.13786215f, -0.11834189f, 
    0.02500965f, -0.20028111f, -0.00465868f, 0.28162593f, 0.16992778f, 0.13033584f, -0.00048207f, 0.17066477f, 
    -0.02309262f, -0.03140423f, -0.08053393f, 0.03888931f, -0.04379872f, 0.02181063f, -0.05820835f, -0.06313628f, 
    0.01050591f, 0.00734478f, -0.01501444f, -0.01908019f, 0.05412176f, 0.03240727f, -0.04063248f, 0.00121797f, 
    0.04427517f, -0.09076840f, 0.02899863f, -0.02744952f, -0.10028289f, -0.05275803f, -0.02942858f, -0.01597990f, 
    -0.07249230f, 0.00349355f, -0.06593207f, -0.04667296f, -0.02594990f, -0.03177984f, 0.05100990f, -0.01635548f, 
    -0.08419523f, -0.04973116f, 0.01084024f, 0.02930935f, 0.00375835f, -0.06731455f, 0.00584772f, 0.01859570f, 
    -0.00853669f, -0.01299986f, 0.04008466f, 0.05649565f, -0.01213125f, 0.00560862f, 0.00151040f, 0.02316163f, 
    -0.03514970f, 0.02090696f, -0.01074527f, -0.03910912f, -0.07669269f, -0.08282354f, -0.06314704f, -0.06716850f, 
    -0.01884210f, -0.06097735f, -0.08754773f, -0.06265808f, 0.05520922f, 0.03086402f, -0.01846382f, -0.07596998f, 
    -0.03105826f, 0.01695014f, -0.06110014f, -0.06616935f, -0.04390186f, -0.08418638f, 0.00456680f, 0.05010338f, 
    -0.08008204f, -0.08066438f, -0.06904785f, -0.03604573f, 0.01984794f, 0.00834518f, -0.01283478f, -0.06673915f, 
    0.03062426f, -0.03065554f, 0.00646452f, 0.01558102f, -0.09369855f, -0.05436260f, 0.00496485f, 0.03044295f, 
    -0.01194000f, -0.03367098f, 0.06006534f, -0.06958695f, -0.09559529f, 0.01549678f, -0.00645961f, -0.00680855f, 
    -0.02288071f, -0.03581748f, -0.06962673f, 0.01866180f, -0.02306090f, 0.02398902f, -0.04372788f, -0.03953280f, 
    -0.08208819f, -0.08087187f, -0.07491091f, -0.05227970f, 0.03372929f, -0.06632271f, 0.04454281f, -0.09780119f, 
    -0.08448137f, -0.08473365f, -0.05686697f, 0.04313266f, 0.00303408f, 0.03020279f, -0.02057794f, -0.00617536f, 
    0.03863239f, -0.08547695f, -0.03007171f, -0.04603991f, 0.01205397f, 0.02866842f, -0.07686894f, 0.00632254f, 
    -0.08682689f, -0.02183967f, 0.01222391f, 0.04442318f, 0.01290480f, -0.03985786f, 0.00337759f, 0.00388382f, 
    -0.01737338f, -0.07820023f, -0.05135871f, -0.04070474f, -0.05479095f, -0.09864214f, 0.02852714f, 0.03602980f, 
    0.04659924f, -0.03368379f, -0.08795758f, -0.01701046f, -0.06120626f, 0.01516215f, -0.05843042f, 0.04031160f, 
    -0.04820744f, -0.06570513f, 0.04963902f, -0.03866291f, -0.09769232f, 0.00452942f, -0.01681753f, -0.05118637f, 
    0.02073678f, 0.01428166f, -0.04930276f, 0.05066930f, 0.04204313f, -0.07685200f, -0.01174613f, -0.07107100f, 
    0.00569433f, 0.03884586f, -0.05958118f, -0.04270068f, -0.05185515f, 0.06123643f, 0.00963498f, -0.06111459f, 
    -0.02753798f, 0.04661842f, 0.00715774f, 0.05805350f, -0.02740389f, -0.01431643f, -0.07191132f, -0.05700652f, 
    -0.04922784f, 0.00073858f, -0.02745906f, 0.05076615f, -0.01148746f, 0.01322489f, -0.01178510f, 0.02854499f, 
    0.14710234f, 0.12485886f, -0.02192291f, 0.05076854f, 0.13817814f, 0.19488999f, 0.33251533f, 0.00204026f, 
    0.08530619f, 0.07976290f, 0.02863945f, 0.20434877f, 0.28646845f, 0.29328319f, -0.04619049f, 0.20762473f, 
    0.39245549f, 0.25561804f, -0.01542573f, -0.10680335f, -0.03766894f, -0.07962716f, 0.03886632f, 0.16708849f, 
    -0.15775579f, 0.04708543f, -0.21125200f, 0.07766619f, -0.07429258f, -0.10528468f, -0.02986425f, -0.09415235f, 
    -0.09235021f, 0.05794514f, 0.13757893f, -0.00341050f, 0.37283316f, 0.42920622f, 0.21697086f, 0.27665761f, 
    0.24871074f, 0.15721115f, 0.17639710f, 0.22365671f, -0.01786104f, -0.07194014f, -0.07851262f, 0.09242827f, 
    -0.21033713f, 0.41683587f, 0.43500954f, -0.01467732f, 0.04605275f, -0.03827294f, -0.10398867f, -0.19884329f, 
    -0.05632837f, -0.01386021f, -0.00207583f, 0.01262781f, -0.31539807f, -0.54855114f, 0.21222448f, -0.12887670f, 
    0.07846215f, 0.12558655f, 0.11538362f, 0.19684048f, 0.08715368f, -0.04322332f, 0.09310701f, -0.20287155f, 
    0.09604779f, -0.23154138f, -0.32861093f, 0.19386327f, -0.00600131f, 0.13467766f, 0.00094904f, -0.10211321f, 
    0.13373399f, 0.19554381f, 0.08115989f, -0.06178026f, 0.02209878f, 0.53043020f, 0.03106204f, -0.08754179f, 
    -0.13544995f, 0.05101779f, 0.13288376f, -0.22212699f, 0.10890736f, -0.20044450f, -0.12045257f, 0.10331519f, 
    -0.12192988f, -0.09651975f, 0.11167503f, 0.22074306f, 0.24176428f, 0.28745785f, -0.14189112f, -0.00855076f, 
    -0.02398480f, 0.02556773f, 0.06543349f, 0.07910924f, -0.13656873f, -0.04326078f, 0.07591139f, -0.17561200f, 
    -0.03862180f, -0.04820439f, -0.03101594f, 0.03537000f, 0.04475297f, -0.05881906f, -0.22376335f, -0.29562989f, 
    0.03856012f, 0.08880430f, -0.05669161f, 0.17425524f, 0.16548873f, 0.33274740f, 0.05206260f, -0.10902740f, 
    0.22545479f, 0.21836056f, 0.04467174f, 0.11831362f, 0.22745058f, 0.31240487f, -0.06977694f, 0.18811212f, 
    0.22156201f, 0.19576478f, -0.03965772f, -0.00286322f, -0.07482480f, -0.03520893f, -0.09430881f, -0.13864110f, 
    -0.09335635f, 0.07758436f, 0.00366922f, 0.05515999f, -0.03247715f, 0.05044280f, -0.05122942f, 0.01395099f, 
    -0.06612855f, -0.10320988f, 0.04013047f, 0.07138501f, -0.28948024f, -0.04512722f, -0.09689025f, -0.11353633f, 
    -0.18722917f, -0.08797134f, -0.18784320f, -0.07959925f, -0.04743592f, 0.06201544f, 0.11917113f, 0.08880121f, 
    -0.28158101f, -0.06309952f, 0.03414463f, 0.18511315f, -0.09090396f, 0.08718725f, -0.04882775f, -0.13372304f, 
    -0.10108279f, -0.40122145f, -0.19893555f, -0.12813365f, 0.04632783f, 0.76789916f, 0.21387728f, -0.32131827f, 
    -0.02030518f, -0.34909269f, 0.21781772f, 0.29619679f, 0.14726922f, 0.18504693f, 0.02753230f, 0.15383749f, 
    0.09112025f, 0.24018832f, 0.40351084f, 0.16484347f, -0.09339879f, 0.09340513f, -0.10454474f, 0.12417173f, 
    -0.06420079f, -0.04686378f, -0.04795398f, -0.28139204f, -0.02725645f, 0.24097779f, 0.51799548f, 0.14821926f, 
    -0.23187941f, -0.20162660f, -0.04568455f, 0.11406104f, 0.11095817f, 0.05875801f, 0.09270891f, -0.05170101f, 
    0.33851603f, -0.09862222f, 0.04885535f, -0.20768942f, -0.04782584f, 0.15732896f, 0.08211061f, 0.03637611f, 
    -0.01958651f, -0.08827748f, -0.14190084f, -0.17370531f, -0.36308965f, -0.07423244f, 0.22979072f, 0.01955568f, 
    -0.03196130f, -0.10227773f, 0.04123823f, 0.04016506f, 0.14852861f, 0.02290918f, 0.08045126f, 0.13379741f, 
    0.19792397f, 0.29105926f, 0.07363997f, 0.05788281f, -0.05625054f, -0.22544883f, 0.12303933f, 0.18958466f, 
    0.02632812f, -0.06102958f, -0.04535389f, 0.02250405f, 0.02856991f, 0.44262108f, 0.04525494f, 0.42653447f, 
    0.11114886f, -0.09046021f, 0.04799180f, -0.03141936f, 0.19210191f, -0.10997956f, 0.11757799f, 0.07069319f, 
    -0.10020942f, -0.11150120f, 0.26632395f, 0.00420107f, -0.10255849f, -0.14725874f, -0.14878063f, -0.03186331f, 
    0.13206087f, -0.03682179f, 0.07546242f, 0.06250647f, -0.03343384f, -0.14773975f, 0.55318087f, -0.10013297f, 
    -0.09542314f, -0.02283081f, -0.08527678f, -0.05730260f, -0.05109326f, -0.02431523f, 0.04195545f, 0.09104477f, 
    0.14299357f, 0.25299728f, 0.16842914f, -0.17984599f, 0.12350780f, 0.09350703f, 0.01438774f, 0.19121751f, 
    -0.07678993f, -0.03807761f, -0.00890137f, -0.21925116f, -0.24133159f, 0.04424452f, -0.13609672f, 0.36219463f, 
    0.08145372f, -0.17330095f, -0.29986787f, 0.05164761f, 0.17548917f, 0.04116482f, 0.17595825f, 0.41211250f, 
    0.24416761f, 0.28274912f, 0.18311457f, -0.38805312f, -0.05246104f, 0.27866346f, 0.12136139f, -0.04078328f, 
    -0.05044246f, -0.08773581f, -0.14607368f, -0.14987780f, 0.03593710f, 0.10143863f, 0.25592366f, 0.08486161f, 
    0.09235916f, 0.04412813f, 0.16061395f, 0.06096005f, 0.02578686f, -0.05416459f, 0.04195116f, -0.03133927f, 
    0.00239956f, -0.30341056f, 0.18682167f, 0.17004162f, -0.11254356f, -0.01429064f, 0.09215282f, 0.00837792f, 
    -0.13710970f, 0.07465035f, 0.23894291f, 0.14988613f, 0.12489045f, -0.23730002f, 0.06252115f, -0.05525878f, 
    0.16975193f, -0.06564336f, 0.05262580f, 0.04466844f, -0.11440951f, -0.13726111f, 0.00595538f, -0.14674887f, 
    0.29554409f, -0.29274577f, -0.00291370f, -0.32181436f, 0.08069051f, 0.05041641f, 0.00403283f, -0.16463433f, 
    0.19501503f, 0.09880777f, 0.16343081f, -0.02320927f, -0.50332606f, -0.36216584f, 0.11550254f, 0.67310846f, 
    0.14399239f, 0.28245789f, 0.08120844f, -0.04312217f, 0.05707893f, -0.03255265f, 0.12091704f, -0.14418393f, 
    -0.16729100f, -0.03101318f, -0.22506389f, 0.17661971f, -0.13257219f, 0.14176212f, -0.05880624f, 0.12855673f, 
    -0.07092128f, -0.04775220f, -0.01885613f, 0.12568426f, -0.37137535f, -0.49307927f, 0.04362812f, 0.11088389f, 
    -0.12748724f, -0.04513771f, 0.00796805f, 0.04658905f, -0.00035195f, -0.06000509f, -0.01328267f, 0.04927324f, 
    0.12710796f, -0.00235306f, 0.25640360f, 0.01497901f, -0.27162075f, 0.01869582f, 0.01214796f, 0.01182995f, 
    0.13402186f, -0.02868935f, 0.04724223f, -0.07853190f, 0.04968472f, -0.25362998f, 0.08648416f, 0.11266004f, 
    -0.14710648f, -0.20596990f, 0.14185189f, 0.05936124f, -0.00849029f, 0.15188886f, 0.04139555f, -0.28316286f, 
    -0.22220413f, 0.19140974f, -0.43460986f, 0.23205662f, -0.22936364f, 0.03746110f, -0.08123356f, 0.05295943f, 
    0.02721347f, -0.07058216f, -0.09009597f, -0.06461126f, -0.22000477f, 0.09841272f, 0.03021280f, -0.12386613f, 
    0.05252355f, 0.00995263f, -0.08090341f, 0.03248085f, -0.10267692f, -0.01795298f, -0.09330973f, -0.01732278f, 
    0.10154535f, 0.29942477f, -0.03732660f, 0.12533081f, -0.07982169f, -0.04160257f, -0.15894076f, 0.04345210f, 
    -0.08637175f, -0.07283892f, -0.27127060f, 0.01304655f, -0.00345491f, 0.32960710f, -0.20457809f, 0.26948324f, 
    0.12427083f, 0.04348367f, -0.26088977f, 0.34372038f, 0.15801947f, 0.03448166f, -0.14803749f, 0.03854734f, 
    0.05818482f, -0.25118032f, 0.15164092f, -0.20253763f, 0.05891060f, 0.02864461f, 0.04126671f, -0.17463215f, 
    -0.16995603f, 0.03212928f, 0.04752297f, 0.17731248f, 0.08587628f, 0.34433722f, 0.07360108f, 0.00730108f, 
    -0.08582623f, 0.03126692f, -0.12355791f, -0.17801344f, -0.06643014f, 0.03363342f, -0.42993492f, -0.30246651f, 
    0.12250806f, 0.23776785f, 0.45282507f, 0.26365012f, 0.09700412f, 0.19265652f, -0.12536372f, -0.01530554f, 
    0.14599526f, 0.23224857f, 0.10802375f, -0.05092677f, 0.05720535f, -0.28384569f, 0.25769347f, -0.16930728f, 
    -0.12430581f, 0.12242329f, -0.00822800f, 0.14573018f, 0.04307447f, 0.11407932f, -0.03263827f, 0.03285845f, 
    -0.07048038f, 0.25069275f, 0.22444533f, 0.12683399f, -0.07193001f, 0.22756526f, -0.21357563f, 0.12939152f, 
    0.11526262f, -0.05388054f, 0.06224048f, 0.19541009f, -0.10603638f, 0.22119254f, -0.06824550f, 0.01111084f, 
    -0.07583028f, -0.09973545f, -0.03147802f, -0.23081422f, 0.02646651f, 0.14709063f, 0.11945666f, 0.22261059f, 
    0.04479989f, -0.00407162f, 0.09091797f, -0.14297661f, -0.14940988f, -0.27442911f, -0.19385844f, -0.33228943f, 
    0.14180048f, 0.09956276f, 0.02613953f, -0.05916874f, -0.28702548f, 0.34430671f, 0.13951786f, 0.25671774f, 
    0.08409120f, 0.10705629f, 0.14551884f, 0.06062053f, 0.07595998f, 0.08685257f, 0.07146384f, 0.09406333f, 
    0.34988335f, 0.09979725f, 0.28655314f, -0.21609908f, 0.05862438f, 0.07419564f, 0.15411849f, 0.17751029f, 
    0.06684704f, -0.05426898f, 0.05463831f, -0.12034814f, 0.39858100f, 0.65650892f, 0.43515509f, 0.00873129f, 
    0.26815829f, 0.01190356f, 0.14246322f, 0.24111739f, -0.02519970f, 0.09397274f, 0.18451975f, 0.04198699f, 
    -0.14024408f, -0.25846884f, -0.12174271f, -0.05623753f, 0.18291759f, 0.06076750f, 0.05652459f, -0.12644820f, 
    -0.03621203f, -0.05664282f, 0.02237976f, -0.04405168f, -0.26776832f, 0.28932834f, 0.08746413f, -0.25905761f, 
    0.15306914f, 0.11689702f, 0.10673162f, 0.15531571f, 0.13867977f, -0.04264390f, -0.02784084f, 0.23411074f, 
    0.44651631f, -0.26134491f, 0.51605326f, -0.01233756f, 0.10283466f, 0.00000072f, -0.01889108f, 0.16994745f, 
    0.02367822f, -0.09950851f, -0.01603616f, -0.19735402f, -0.13760981f, -0.06607684f, 0.18036513f, 0.24633232f, 
    0.08572590f, -0.14861862f, -0.08008153f, 0.07694438f, -0.01254343f, -0.08287276f, 0.05180100f, 0.00943217f, 
    -0.16309719f, -0.32634312f, 0.06335612f, 0.01711579f, 0.07848098f, -0.06805325f, 0.02376982f, 0.04464743f, 
    0.27312928f, 0.09474103f, 0.23620437f, -0.05657800f, 0.26458782f, -0.20893095f, 0.36273995f, -0.29605412f, 
    -0.18324973f, 0.13946132f, 0.14876977f, 0.02740379f, 0.01861061f, 0.08249119f, -0.13245149f, 0.08312595f, 
    -0.08733219f, 0.29485938f, -0.36651987f, 0.34259650f, 0.02221409f, 0.02187426f, -0.02471763f, 0.08888930f, 
    0.03181221f, -0.17608565f, -0.09855693f, -0.17455329f, -0.19339333f, -0.22458000f, -0.01867549f, 0.07648157f, 
    -0.00944772f, -0.08345602f, -0.12023638f, -0.00279081f, 0.03783997f, -0.12235485f, 0.11182127f, 0.35401651f, 
    -0.00035252f, -0.11003412f, -0.20064844f, -0.42851469f, 0.05246624f, -0.12563916f, -0.08398819f, -0.02103719f, 
    -0.00617444f, -0.09407956f, -0.01742907f, -0.02244916f, 0.23620106f, 0.57239568f, -0.16388875f, 0.13056843f, 
    0.07293699f, 0.04208094f, 0.06571137f, -0.08041653f, 0.00720783f, 0.01801805f, -0.13320968f, -0.11913759f, 
    -0.04014615f, -0.35886455f, 0.13915467f, 0.06264305f, 0.09971368f, -0.21846217f, 0.09291884f, 0.04416910f, 
    -0.04432855f, -0.00457344f, -0.04365142f, 0.02645817f, 0.16021302f, -0.33748820f, -0.02417427f, 0.15767518f, 
    0.11295865f, -0.03840295f, -0.18374695f, -0.01819785f, -0.01267993f, -0.02920588f, -0.10013370f, -0.16960803f, 
    -0.09436754f, -0.24403253f, -0.43133104f, -0.08798770f, 0.09752660f, 0.16352239f, -0.00823981f, -0.07007188f, 
    0.19677503f, -0.15459269f, 0.06772458f, 0.04676448f, 0.08277094f, -0.21045020f, 0.15868858f, 0.07079289f, 
    0.04634302f, 0.15606870f, 0.01731457f, 0.08993585f, 0.04893768f, 0.01311687f, -0.14175712f, -0.06908556f, 
    0.03371019f, 0.15812181f, -0.07285567f, 0.35848084f, -0.14900729f, 0.06501054f, -0.03394857f, 0.14196135f, 
    0.03959160f, -0.07754372f, -0.00172780f, -0.02864446f, -0.22977015f, -0.26747772f, 0.06189102f, 0.15932158f, 
    -0.12920211f, 0.00911455f, -0.05831794f, -0.05408406f, 0.12647404f, 0.18788575f, 0.04494317f, -0.08120617f, 
    -0.31093147f, -0.33702797f, 0.05504885f, -0.28945938f, -0.08030957f, 0.01734482f, -0.00147022f, 0.02693653f, 
    0.15861459f, -0.03224381f, -0.00320947f, 0.02539870f, 0.18771577f, -0.35077035f, 0.12602207f, 0.39205295f, 
    -0.28487527f, -0.05114507f, -0.06798059f, 0.00339703f, -0.02143679f, 0.06935635f, 0.03996820f, 0.02989575f, 
    -0.47911119f, 0.09874189f, -0.44366458f, 0.41844112f, -0.09066907f, 0.07161480f, -0.11713593f, 0.13316001f, 
    0.05412930f, 0.05340690f, 0.03091889f, 0.05740376f, 0.26548260f, 0.61504823f, 0.43512851f, 0.42000625f, 
    0.03524270f, 0.07593201f, 0.14735436f, -0.12026634f, -0.00290741f, 0.05667667f, -0.04349888f, 0.23185875f, 
    -0.34855393f, 0.31056735f, 0.14803600f, 0.19072752f, -0.02649791f, -0.13794240f, -0.13551129f, 0.00180190f, 
    0.07716516f, 0.06220123f, -0.15893812f, 0.22969677f, -0.23702127f, 0.25668544f, 0.00912783f, 0.28815836f, 
    0.07808829f, 0.04179035f, -0.21260861f, 0.15557893f, -0.09277482f, -0.00829396f, 0.06687666f, -0.01755599f, 
    0.00510516f, -0.21926004f, 0.22022046f, -0.16645865f, -0.06321749f, -0.01358333f, -0.10033103f, 0.05475876f, 
    -0.02610903f, 0.06352113f, 0.03306445f, -0.05487874f, -0.06246670f, 0.12863837f, -0.01094918f, 0.11213960f, 
    0.07305726f, -0.02085473f, -0.10784028f, -0.07070421f, 0.27900070f, 0.28523698f, -0.09606641f, 0.16872659f, 
    0.20385094f, 0.49668327f, 0.64977002f, 0.44954506f, 0.03998976f, 0.21906519f, 0.02429172f, -0.13989750f, 
    -0.11197031f, 0.26740745f, 0.12183888f, 0.04356765f, 0.55208892f, -0.12479223f, 0.20989883f, -0.09132414f, 
    0.02172230f, 0.15673317f, 0.09753051f, 0.28787187f, 0.15936770f, 0.06519692f, 0.09329911f, 0.05722130f, 
    -0.21619083f, 0.09703974f, -0.13039085f, -0.04558825f, -0.15669347f, 0.17727847f, -0.17534618f, -0.06832208f, 
    0.00752297f, -0.14854099f, 0.03334296f, 0.03758904f, -0.24011706f, -0.11202348f, -0.26731896f, -0.21999685f, 
    0.02303677f, -0.10529532f, 0.07653786f, -0.15277255f, -0.13384208f, 0.01467419f, 0.07650260f, 0.22788873f, 
    -0.17805295f, -0.11836084f, -0.07428829f, -0.30266869f, -0.04836290f, -0.04599796f, -0.05672111f, -0.21350645f, 
    0.10218741f, 0.39969367f, 0.23687841f, 0.07648880f, -0.44848686f, 0.30829373f, 0.31640324f, 0.17218757f, 
    0.14289655f, 0.14967258f, -0.11115225f, -0.23263340f, -0.02188126f, -0.02591219f, 0.06690662f, 0.00174413f, 
    0.03531581f, 0.22590232f, 0.04641623f, -0.00203473f, 0.03216773f, 0.20487912f, 0.28586474f, 0.11122540f, 
    0.07573338f, 0.05194588f, 0.09125365f, -0.02688389f, 0.34105891f, 0.13792223f, 0.08970715f, -0.14040159f, 
    -0.02328966f, 0.01919361f, 0.01085294f, 0.19690810f, -0.06928816f, -0.03165529f, 0.11884816f, 0.04801794f, 
    0.41610530f, -0.08110064f, 0.01863621f, 0.26602465f, 0.13350707f, -0.07900735f, 0.27471140f, 0.07518926f, 
    0.13630171f, 0.02735707f, 0.04735776f, 0.00288033f, -0.19199592f, 0.23859826f, -0.09805984f, 0.14517432f, 
    0.00913598f, 0.09748165f, -0.14888528f, 0.19072147f, -0.04450690f, 0.03896127f, -0.06243151f, -0.20339672f, 
    0.14360048f, -0.12009845f, -0.19686732f, -0.11459810f, -0.11433841f, -0.20303568f, 0.22290064f, 0.15383205f, 
    0.12008832f, 0.05067698f, 0.04288161f, 0.01520411f, 0.51492321f, 0.03414550f, -0.10776462f, -0.09193036f, 
    -0.10125722f, -0.05137115f, -0.02802368f, -0.04979093f, -0.03460390f, -0.06455582f, 0.00258907f, 0.07881586f, 
    0.05231363f, -0.07551141f, 0.18948138f, -0.00069400f, 0.05797222f, -0.03783819f, 0.06654498f, -0.13679156f, 
    -0.00327501f, -0.12389084f, -0.01160898f, 0.10719753f, 0.53017479f, -0.63180935f, -0.14760901f, 0.07344370f, 
    0.07523335f, -0.17432661f, -0.11334850f, -0.14766182f, 0.03353320f, -0.05116537f, 0.06064395f, -0.00716630f, 
    -0.19144900f, 0.12445999f, -0.05990404f, 0.31226256f, -0.22573714f, 0.04861579f, 0.11062529f, -0.00056426f, 
    0.03998979f, 0.03222109f, -0.03566547f, -0.10313398f, 0.10652100f, -0.06768239f, 0.21671337f, 0.32819813f, 
    0.06171058f, -0.06007376f, -0.07021275f, -0.19513491f, -0.02271342f, 0.12766862f, -0.08258010f, 0.05860412f, 
    0.47526908f, -0.19785386f, -0.15859458f, -0.47324136f, -0.10480766f, 0.00402335f, -0.20599638f, -0.13546760f, 
    0.08547371f, 0.09738366f, 0.00660630f, -0.26101542f, 0.24600077f, 0.06340740f, -0.20642319f, 0.09284288f, 
    -0.04051220f, 0.02750825f, 0.21409509f, 0.19117312f, -0.05948656f, 0.07143154f, 0.04023808f, 0.05459246f, 
    -0.14726512f, 0.02994130f, 0.28328425f, 0.27031094f, -0.12218062f, 0.18095703f, -0.17817110f, -0.25670850f, 
    -0.02384137f, -0.34390441f, -0.19088461f, -0.21286367f, 0.20347737f, 0.05349008f, 0.00664375f, 0.05053861f, 
    -0.03244474f, 0.20593336f, -0.04159467f, 0.00903818f, -0.01629064f, -0.06361539f, 0.09826069f, -0.05096446f, 
    0.14303991f, 0.06015965f, 0.16527218f, 0.31818935f, 0.13671900f, 0.01124361f, 0.18871601f, -0.15312651f, 
    0.01661829f, 0.06151635f, -0.08943149f, -0.03493997f, 0.55417752f, -0.56674027f, 0.09991027f, -0.02271958f, 
    -0.18041326f, 0.08430574f, 0.17857845f, -0.09370999f, 0.01324375f, -0.00807439f, -0.12448436f, -0.16406497f, 
    0.37367311f, 0.42700756f, 0.05155995f, 0.09158488f, -0.02663828f, 0.14269066f, 0.28959545f, 0.01265763f, 
    0.01713949f, 0.07934862f, 0.15439610f, 0.09309681f, 0.34977806f, 0.06646220f, -0.12277725f, 0.03282770f, 
    0.13667908f, 0.04115141f, -0.07947810f, 0.10466791f, 0.00562475f, 0.02566695f, 0.02817193f, 0.01207418f, 
    -0.17847872f, -0.21726020f, -0.19235015f, -0.14558062f, -0.05056060f, -0.04559488f, 0.09057324f, 0.01082617f, 
    0.02595690f, -0.01476538f, 0.08503032f, 0.02903089f, 0.44191605f, 0.37872687f, 0.03718150f, 0.39268285f, 
    -0.00275168f, 0.09315147f, 0.00351861f, 0.23247357f, -0.04036012f, 0.02879451f, -0.03823012f, -0.18700397f, 
    -0.45448095f, 0.42044699f, -0.22835897f, -0.03980153f, -0.13664187f, -0.24678716f, -0.03181595f, -0.12559700f, 
    0.12255528f, -0.01292473f, 0.00873908f, 0.01154174f, 0.22180220f, 0.30412340f, 0.07658934f, 0.12627645f, 
    0.09131528f, 0.12747957f, 0.06946614f, 0.09516362f, -0.00925778f, -0.03839358f, 0.00717881f, 0.05454256f, 
    -0.37841436f, -0.17607214f, 0.04304041f, 0.25801364f, 0.06477949f, -0.05542546f, -0.04423126f, -0.04725619f, 
    -0.04697785f, 0.07024314f, 0.03680982f, 0.04988515f, 0.08508023f, 0.15412870f, -0.06821212f, 0.18502650f, 
    -0.04906984f, -0.02649902f, -0.13987333f, -0.08685017f, -0.05047993f, -0.07674899f, 0.06099736f, 0.03309235f, 
    -0.13920042f, -0.19741307f, 0.33139291f, 0.01541655f, 0.01580646f, 0.14607716f, -0.16588199f, -0.03409714f, 
    0.01730745f, 0.01728347f, 0.01791497f, 0.08361641f, -0.16292511f, -0.12166995f, -0.00042015f, 0.21126252f, 
    0.15520905f, -0.04694085f, -0.04450279f, -0.13955499f, 0.05258102f, 0.06357974f, -0.09768268f, 0.09991219f, 
    0.31185141f, 0.16348310f, 0.20456627f, 0.16053344f, -0.04247554f, 0.37485594f, -0.15203601f, -0.17009343f, 
    -0.07263589f, 0.21331246f, -0.02726120f, -0.00815162f, 0.45706603f, 0.07269055f, -0.19573593f, 0.19107434f, 
    0.05892789f, -0.03216166f, -0.00971690f, 0.15686257f, -0.13226603f, -0.05033020f, -0.04062330f, -0.03081415f, 
    -0.41418600f, 0.10598566f, -0.05716249f, 0.00219799f, -0.06803051f, 0.11724337f, -0.20800188f, 0.04313109f, 
    0.01725881f, -0.05775497f, 0.00967081f, -0.11942128f, -0.26342389f, -0.07231020f, -0.17621310f, -0.15637851f, 
    0.00187918f, 0.09640061f, 0.08709980f, -0.03457752f, -0.03081165f, 0.05973034f, 0.20512041f, 0.16231821f, 
    -0.38370475f, -0.20397943f, 0.01261284f, -0.09928549f, 0.05581641f, 0.03993768f, -0.07397066f, -0.09461053f, 
    -0.02494792f, 0.03836706f, -0.04285857f, -0.09970724f, 0.20134805f, 0.31597453f, 0.21453463f, 0.02375214f, 
    -0.01229932f, -0.13386011f, 0.23006094f, 0.04419772f, 0.11295282f, -0.19050726f, 0.11977411f, 0.02646910f, 
    -0.07003076f, 0.17698003f, -0.08769486f, -0.04719321f, -0.03167298f, 0.11718754f, 0.04907070f, 0.07550301f, 
    -0.10035072f, -0.01384877f, -0.02827604f, -0.07817149f, 0.21098822f, 0.00339453f, -0.05272995f, 0.03759638f, 
    -0.23175852f, 0.14790186f, -0.02748674f, 0.03940983f, 0.06269035f, 0.12242998f, -0.19304229f, 0.06924801f, 
    0.45353752f, -0.05717950f, 0.09444933f, 0.26360434f, -0.01558355f, -0.13406320f, -0.05302442f, 0.09227771f, 
    -0.13502686f, 0.05145654f, -0.07602207f, 0.15195405f, 0.10511927f, 0.30262303f, -0.02028018f, -0.14173129f, 
    0.01620340f, 0.19638133f, 0.02964714f, -0.07408258f, 0.02529364f, 0.13715844f, 0.11650818f, -0.23431769f, 
    0.04954199f, 0.06698518f, -0.34727225f, -0.39282057f, 0.12420873f, -0.18443893f, -0.01770456f, 0.16526376f, 
    0.00776136f, 0.01156177f, 0.08264589f, -0.01410509f, -0.10346878f, 0.47227708f, -0.27163595f, -0.26959765f, 
    -0.06227436f, 0.04590711f, -0.03267759f, -0.08175246f, -0.09919695f, -0.01520860f, 0.05264087f, -0.10743114f, 
    0.42341915f, -0.01661011f, -0.05235600f, -0.14995684f, -0.00584052f, -0.00585371f, -0.01828263f, -0.04705236f, 
    -0.20496191f, -0.15456504f, -0.15602627f, 0.07570138f, 0.30891147f, -0.24935909f, -0.43095866f, 0.18797746f, 
    0.07235443f, -0.11387993f, 0.10516479f, 0.11906591f, 0.09767974f, 0.15799052f, 0.16115935f, 0.05658521f, 
    0.10984452f, -0.22930719f, 0.12523866f, -0.17484453f, -0.02401271f, 0.05383855f, 0.14849670f, -0.12163521f, 
    -0.03259441f, 0.03409466f, -0.11660173f, 0.08626535f, -0.21470112f, 0.05090158f, 0.06006663f, 0.24947381f, 
    -0.06127379f, 0.12309394f, -0.06332377f, 0.00078895f, -0.16851588f, -0.01112245f, 0.23624380f, -0.10712115f, 
    0.69613451f, -0.03829630f, -0.05574051f, -0.20607734f, 0.06478831f, 0.09983516f, 0.04224722f, 0.02824056f, 
    0.02163405f, -0.03766995f, -0.12608616f, -0.11372206f, -0.01626497f, -0.38259879f, 0.16515857f, -0.16617136f, 
    -0.29918867f, 0.06618616f, -0.00411859f, 0.25475526f, 0.01738411f, -0.07625135f, -0.07754306f, 0.36681646f, 
    -0.10617276f, 0.38973758f, 0.08598968f, 0.24584541f, 0.03431028f, 0.08816059f, -0.14498866f, -0.04744642f, 
    0.12063301f, -0.01516967f, -0.06240284f, -0.03184677f, 0.09320687f, 0.01499697f, -0.00285106f, 0.07384242f, 
    -0.20344757f, -0.05850606f, 0.11183096f, -0.03144041f, -0.07201584f, 0.09509939f, 0.02414309f, -0.03969397f, 
    0.30385077f, -0.00991561f, 0.15967856f, 0.07101261f, -0.04195429f, -0.08014260f, -0.00979040f, -0.04501294f, 
    -0.16398782f, 0.32842276f, -0.16909888f, -0.06764714f, 0.29896313f, -0.51165283f, -0.12134507f, 0.18230543f, 
    -0.12535715f, 0.05448383f, 0.30211326f, 0.07917359f, 0.05772003f, 0.03092400f, 0.25775120f, 0.13724841f, 
    -0.36541113f, -0.09115046f, -0.01607207f, -0.04763276f, 0.05866649f, -0.08489371f, -0.00063673f, -0.16388534f, 
    -0.17547195f, -0.12620187f, -0.11054549f, -0.08903759f, -0.50869685f, -0.30551046f, -0.32234567f, -0.21559413f, 
    -0.18899529f, 0.20177847f, 0.06145531f, -0.38482878f, 0.01897582f, -0.02966092f, -0.21875475f, -0.05373603f, 
    0.14837687f, -0.01805138f, -0.11547724f, -0.03167566f, 0.05927584f, -0.16763055f, 0.05754647f, 0.09160274f, 
    -0.02067671f, 0.10386383f, -0.03635381f, 0.02974958f, -0.04842134f, 0.08498922f, 0.29529834f, 0.25637060f, 
    0.02445509f, -0.00840849f, -0.02929188f, -0.24357927f, -0.09443995f, -0.02809484f, 0.01537439f, 0.02175713f, 
    -0.50688392f, 0.08327419f, -0.34300449f, 0.08133055f, 0.16629489f, 0.11400472f, -0.05744500f, -0.12743154f, 
    -0.01184971f, 0.01614949f, 0.04130151f, -0.00703677f, -0.11654880f, -0.14144704f, 0.49133414f, 0.16950659f, 
    0.03184898f, 0.14681502f, 0.08678351f, 0.01729523f, -0.06176237f, 0.00579672f, 0.13373463f, 0.16640355f, 
    0.50840759f, 0.59034365f, -0.23992775f, -0.07010843f, -0.04404238f, 0.06213638f, 0.09627041f, -0.16290641f, 
    0.11390762f, 0.11875147f, 0.20353976f, 0.18772739f, -0.01554766f, 0.44674793f, -0.08574194f, -0.17261702f, 
    0.16467817f, 0.01526587f, 0.18654701f, -0.00036276f, 0.06850038f, 0.25993001f, 0.33608976f, -0.01966972f, 
    0.13085012f, -0.27426815f, -0.08175918f, -0.36214033f, 0.11053770f, -0.07724649f, 0.18154220f, 0.09000650f, 
    -0.07713072f, -0.04028844f, -0.05193706f, 0.04933282f, 0.08625657f, 0.14580253f, 0.07979195f, -0.06246176f, 
    -0.06659985f, 0.00985942f, 0.09684046f, 0.13021047f, 0.17778686f, 0.07208133f, 0.19726907f, -0.16969448f, 
    0.21497634f, 0.36955607f, -0.01341320f, 0.25131702f, 0.20773554f, -0.04850193f, 0.10467204f, 0.01199545f, 
    0.11952351f, -0.09056900f, -0.01200106f, 0.24750857f, -0.42713073f, -0.36754808f, 0.26636544f, -0.39821947f, 
    -0.12675488f, -0.07473760f, -0.13754581f, -0.28235272f, 0.04745125f, -0.05077789f, -0.00868916f, 0.03980035f, 
    0.22113119f, 0.29664716f, -0.20027341f, 0.03850730f, 0.01897637f, -0.00319680f, 0.22392583f, 0.15898260f, 
    0.23525643f, 0.21807638f, 0.06128733f, 0.09765996f, -0.01311182f, -0.02312835f, -0.04730465f, 0.01174035f, 
    -0.05633381f, -0.13942014f, 0.04556670f, 0.01823044f, -0.03594242f, -0.11657049f, -0.13628337f, 0.05680623f, 
    0.14242342f, 0.07602226f, 0.06956421f, -0.03414572f, -0.05339832f, -0.19977108f, 0.05614273f, 0.05548156f, 
    0.13110003f, 0.34335074f, -0.14492214f, 0.15565373f, 0.10106746f, -0.04081997f, 0.16429052f, -0.08847784f, 
    0.12490035f, -0.02419025f, 0.02403589f, 0.10527600f, 0.02997137f, 0.12722759f, 0.05373709f, 0.03195869f, 
    -0.04580012f, -0.07805352f, -0.10222502f, -0.05859102f, 0.12096147f, 0.01478090f, -0.05585038f, 0.16547179f, 
    -0.08773129f, -0.07939286f, -0.13424625f, -0.02737333f, 0.16944297f, 0.07902709f, 0.00751667f, 0.09678128f, 
    0.09381688f, 0.17849536f, 0.06803300f, -0.08084329f, -0.06212072f, -0.05907794f, -0.05954640f, -0.08664094f, 
    0.13997500f, 0.29136923f, 0.19767886f, 0.17180429f, -0.08221546f, 0.14382686f, -0.16793796f, -0.10925418f, 
    -0.11747896f, -0.13433187f, 0.09951454f, 0.05943108f, 0.03664776f, 0.09206159f, 0.01093913f, -0.52731520f, 
    0.17397599f, 0.08589541f, 0.24686493f, -0.00754823f, -0.07617688f, 0.11110801f, -0.01519250f, -0.06213975f, 
    0.15592086f, 0.04908912f, 0.27107462f, 0.00445716f, 0.22553404f, 0.15150969f, -0.00201274f, -0.18241973f, 
    -0.15751052f, -0.12441195f, -0.05386686f, 0.14103074f, -0.66090548f, 0.07849968f, -0.22876929f, -0.35513502f, 
    -0.11435229f, -0.02409856f, -0.11982067f, 0.09572589f, -0.07178515f, 0.06321807f, -0.00815107f, -0.01575908f, 
    0.24720371f, -0.11131688f, -0.07966433f, -0.19113708f, -0.07421397f, 0.00466981f, 0.08384076f, 0.24819511f, 
    -0.01059758f, -0.12526743f, 0.03775413f, -0.15291511f, 0.04904488f, 0.22848538f, -0.33372331f, 0.13034213f, 
    0.10277960f, 0.14948371f, 0.00523861f, 0.28093129f, 0.03560339f, -0.04006176f, -0.16631441f, 0.02792042f, 
    0.09676731f, -0.33164772f, 0.08840541f, -0.04260313f, 0.24325964f, 0.03680708f, 0.04215178f, 0.06176188f, 
    -0.16181017f, 0.01394514f, 0.04450650f, 0.10779622f, -0.20918539f, 0.30860177f, -0.06854173f, -0.29018837f, 
    -0.16766427f, 0.03681880f, 0.16286249f, 0.03126933f, -0.14428040f, -0.01317012f, -0.07187697f, -0.05731813f, 
    -0.12455640f, -0.19736165f, -0.12444790f, 0.30002281f, 0.12235829f, -0.01096908f, 0.00817643f, 0.38530943f, 
    0.02494167f, 0.11950367f, 0.04558741f, 0.12448385f, -0.11401166f, -0.16777936f, 0.17275082f, -0.03385897f, 
    -0.04966570f, 0.03629022f, -0.07698398f, -0.19158220f, -0.01699170f, 0.00162471f, -0.01324356f, 0.04153736f, 
    0.18340598f, 0.26201418f, 0.29168981f, -0.11749074f, 0.18762194f, -0.07120747f, 0.14477257f, 0.33970398f, 
    0.14420274f, 0.08885439f, 0.16207406f, 0.24830033f, 0.09798950f, 0.10576928f, 0.08290802f, 0.23158169f, 
    -0.06597837f, -0.00183847f, -0.01975564f, -0.05651834f, 0.02519432f, 0.17791648f, -0.09547532f, -0.08136271f, 
    0.21367511f, 0.02612623f, 0.04089586f, 0.01763464f, -0.21334404f, -0.12516803f, -0.16247040f, 0.05540168f, 
    0.08313248f, -0.22535875f, 0.05034611f, 0.00889047f, 0.13714759f, 0.24230398f, -0.21884602f, 0.04621808f, 
    0.04470684f, -0.07004239f, 0.09901977f, -0.13185251f, 0.15831311f, -0.05341482f, -0.05371677f, 0.19777341f, 
    -0.23068492f, -0.21350969f, -0.11447755f, -0.03881194f, -0.07305049f, -0.09451797f, -0.22135742f, -0.03513493f, 
    0.10413218f, -0.01982960f, -0.01011181f, -0.04917759f, -0.52384204f, -0.25514641f, 0.06301097f, -0.05947673f, 
    -0.11187781f, 0.01523603f, 0.04842703f, -0.02288490f, 0.08852077f, 0.09299002f, 0.08396252f, -0.02799005f, 
    0.04710681f, -0.01858711f, -0.00152922f, -0.30573201f, 0.05918671f, 0.00123380f, -0.02021694f, -0.01885945f, 
    -0.05022664f, -0.03948463f, -0.04491409f, -0.15210088f, -0.15132025f, -0.18825175f, 0.18087316f, 0.06291308f, 
    0.17282107f, -0.08468048f, 0.01491923f, -0.04515455f, 0.19873461f, 0.03694374f, 0.16192229f, 0.11800814f, 
    -0.08284291f, 0.16085531f, -0.14953187f, 0.21606119f, 0.05364305f, 0.31315774f, 0.04594726f, 0.13548462f, 
    -0.03610035f, -0.03089768f, 0.01767849f, -0.07658935f, -0.15287922f, -0.06543680f, 0.45065552f, 0.28205305f, 
    0.11260430f, -0.05027846f, -0.07811742f, -0.01547597f, 0.04118414f, 0.09849079f, 0.02281066f, 0.04925871f, 
    0.11347628f, 0.42489055f, -0.07976669f, 0.13459387f, -0.04108647f, 0.00833844f, 0.05784525f, -0.11170019f, 
    0.13859087f, 0.03895574f, 0.28515628f, 0.16850045f, -0.30885112f, 0.27788773f, 0.34424084f, -0.05689602f, 
    0.13766664f, 0.01347283f, 0.13662621f, 0.03200638f, -0.00925530f, 0.12458051f, 0.15412861f, 0.09963594f, 
    0.10656895f, -0.08365101f, -0.09701791f, -0.37172112f, 0.08805618f, -0.01310020f, 0.08789992f, 0.11903416f, 
    -0.05010549f, -0.03623705f, -0.00316835f, -0.07718349f, 0.19302809f, 0.13185646f, -0.05530136f, 0.05120261f, 
    -0.05544576f, 0.00127107f, 0.07742543f, 0.15715060f, 0.25064188f, -0.00557219f, 0.29358745f, 0.16585389f, 
    -0.16600984f, 0.29965788f, 0.08494496f, 0.04927505f, -0.03669114f, 0.01712690f, 0.04936143f, 0.12911341f, 
    0.00095765f, -0.04938855f, -0.06305269f, 0.15803283f, -0.28592697f, -0.03311670f, 0.21470344f, -0.10666740f, 
    -0.09052057f, -0.15709825f, -0.01634938f, -0.27260393f, 0.11112666f, -0.06638750f, -0.03470919f, -0.02997393f, 
    0.03343457f, -0.07360853f, -0.17335980f, 0.00979552f, -0.11557421f, -0.04664003f, 0.09432638f, 0.01970406f, 
    -0.14625792f, 0.25545678f, 0.09316554f, 0.05198267f, -0.07299234f, -0.17663383f, 0.00708791f, -0.07708156f, 
    0.03404436f, -0.13390106f, 0.07140765f, -0.03518043f, -0.08165571f, -0.06584702f, -0.13993128f, -0.21079201f, 
    0.07475440f, 0.06391291f, 0.01559825f, -0.10781766f, 0.00811401f, 0.00777372f, 0.02990628f, -0.00927497f, 
    -0.04109416f, 0.15464430f, 0.05243663f, 0.06780516f, -0.48416495f, 0.28720567f, 0.09961575f, 0.23412216f, 
    0.26955757f, 0.06155178f, -0.05343080f, 0.03783514f, 0.05358859f, 0.11319140f, 0.03677688f, -0.15077482f, 
    -0.02453458f, -0.18805328f, 0.11077862f, -0.09236329f, 0.00108496f, 0.09476201f, 0.22639249f, 0.10406992f, 
    -0.09010523f, -0.19399250f, 0.02919343f, -0.07449292f, 0.14242284f, 0.23940825f, 0.29843646f, -0.08614720f, 
    0.06915722f, -0.13428062f, 0.04764572f, 0.14741407f, 0.11134662f, 0.08259580f, 0.15986775f, 0.02425049f, 
    -0.14987102f, -0.13299271f, 0.01661384f, -0.00576863f, 0.22173399f, -0.23599602f, 0.13833095f, -0.15016402f, 
    0.00513649f, -0.17770234f, 0.18499067f, -0.02308992f, -0.43046507f, -0.05988846f, -0.03819988f, -0.14238970f, 
    -0.01412473f, -0.06862727f, -0.03698773f, 0.09655636f, 0.25275412f, -0.05706231f, -0.06448672f, 0.21683857f, 
    0.20222017f, -0.47879219f, 0.17494626f, 0.12233598f, 0.14709403f, 0.32512367f, 0.02103117f, -0.00365349f, 
    0.00429773f, -0.09874936f, 0.07623749f, 0.01210971f, 0.29517394f, -0.02489800f, 0.39854252f, 0.12028121f, 
    -0.21263482f, 0.00007771f, -0.12943710f, 0.03610897f, 0.11966913f, 0.01722963f, 0.02778882f, -0.07683103f, 
    -0.05453748f, 0.11576276f, 0.00156657f, -0.06717540f, 0.04608995f, -0.25327903f, 0.06656466f, 0.06456817f, 
    0.17261232f, 0.04406328f, 0.03650448f, 0.07998515f, 0.35136181f, -0.36999175f, 0.20178400f, -0.11960775f, 
    -0.04886213f, 0.03112109f, 0.03225808f, 0.01563911f, 0.02397565f, 0.10354058f, -0.03312859f, 0.01353282f, 
    -0.29291949f, 0.32117122f, -0.37910682f, 0.32478803f, 0.03325510f, 0.07223593f, 0.13524257f, 0.12858313f, 
    -0.07986300f, -0.24816425f, -0.04962597f, -0.18492864f, 0.19600026f, -0.04564526f, 0.11440652f, 0.13816562f, 
    -0.06567211f, 0.03041231f, -0.12331297f, 0.01072431f, 0.10337354f, 0.21189363f, -0.02464095f, 0.22106211f, 
    0.00917954f, -0.06215102f, 0.07112505f, -0.21315314f, -0.11011171f, -0.23963401f, -0.06734992f, 0.10435678f, 
    -0.07037481f, -0.02678488f, 0.04872860f, -0.17434768f, 0.22004275f, 0.53859299f, -0.08533607f, 0.07151949f, 
    0.04225527f, -0.08301049f, -0.02791202f, 0.11545235f, 0.13540038f, 0.03295539f, -0.05245776f, 0.01908882f, 
    0.05278981f, -0.19322358f, 0.02365445f, -0.02127763f, -0.13422285f, 0.01416898f, -0.02053847f, -0.28257042f, 
    -0.12236228f, 0.10848524f, -0.10954846f, 0.11262336f, 0.04728560f, -0.13324857f, 0.16214690f, 0.02550788f, 
    -0.11355969f, 0.06388795f, -0.40306002f, -0.15632050f, -0.01710846f, -0.18802293f, -0.08054765f, -0.02978507f, 
    0.00877977f, 0.05052226f, -0.19876947f, 0.11028390f, 0.13416532f, -0.05519047f, 0.19629192f, -0.00772060f, 
    -0.00901208f, 0.03884052f, 0.16960135f, 0.26473111f, 0.20271394f, -0.34093356f, 0.26414752f, -0.01728490f, 
    -0.12676808f, 0.08445578f, -0.25662258f, 0.00786562f, -0.01361379f, 0.08125524f, -0.10253211f, -0.00353189f, 
    0.18460560f, -0.04600387f, 0.18629959f, -0.17570972f, 0.15273996f, -0.00340191f, 0.07032273f, 0.09661487f, 
    0.01638937f, -0.17397706f, -0.02226496f, -0.05327794f, 0.29052165f, 0.47556305f, 0.42446864f, -0.12309346f, 
    0.10978662f, 0.08225425f, 0.05693889f, 0.17175978f, -0.04356621f, 0.06584472f, 0.10806197f, 0.05244984f, 
    -0.22741407f, -0.28035685f, -0.08647710f, -0.06490766f, 0.29024529f, -0.00109586f, -0.02908968f, -0.06854989f, 
    0.03883853f, -0.05277312f, 0.01201038f, 0.07816119f, -0.44556922f, 0.24213104f, 0.13798410f, -0.18505077f, 
    -0.00987319f, 0.10169828f, -0.06324984f, 0.11460631f, 0.07108594f, -0.03866897f, -0.04627485f, 0.22805619f, 
    -0.10738821f, -0.72072411f, 0.22790161f, 0.01532210f, 0.07365047f, 0.29399568f, -0.04372120f, 0.07272388f, 
    0.02168194f, -0.02410672f, 0.14328270f, -0.04766550f, -0.21099405f, 0.13240466f, 0.50344557f, 0.25778276f, 
    -0.06002591f, -0.04895280f, -0.12036178f, 0.12361746f, -0.03604631f, 0.00115399f, 0.09953035f, -0.00725409f, 
    0.15087281f, 0.14377111f, 0.05890922f, -0.22084638f, 0.03546808f, -0.05796132f, -0.02087668f, 0.03128266f, 
    0.33241767f, 0.18431915f, 0.23774680f, -0.06525330f, 0.41548154f, -0.31538251f, 0.14947942f, -0.34735674f, 
    -0.00226004f, 0.14535967f, 0.03958355f, 0.11762816f, 0.05566309f, 0.13145834f, 0.01308097f, 0.01059839f, 
    -0.05573477f, 0.20912106f, -0.62508744f, 0.11548623f, -0.04805789f, -0.01849250f, 0.06284672f, 0.11320926f, 
    0.06683549f, -0.20434572f, -0.20486279f, -0.10522237f, -0.10211678f, -0.24943165f, 0.20869680f, -0.03143912f, 
    -0.02726342f, 0.04462048f, -0.03469373f, 0.05201354f, 0.05518161f, -0.06718080f, 0.19682135f, 0.18709777f, 
    0.26123831f, -0.03829622f, -0.06659203f, -0.22497347f, 0.12440740f, -0.23600249f, -0.10499432f, -0.04057040f, 
    0.00486161f, -0.09816037f, 0.14762683f, 0.00681237f, 0.15536958f, 0.47669670f, -0.00468419f, -0.18906803f, 
    0.13041852f, 0.02593529f, 0.01033122f, -0.09288821f, 0.02439804f, 0.01658639f, -0.01481285f, 0.02427293f, 
    0.14393011f, -0.20466411f, 0.04213815f, -0.00658241f, 0.11468678f, -0.04185809f, 0.19405754f, 0.11804925f, 
    -0.02866976f, 0.10662563f, 0.05009798f, 0.01032039f, 0.14673518f, -0.39069495f, -0.08276715f, 0.21765007f, 
    0.13900064f, 0.00383473f, -0.27239135f, 0.05205838f, 0.10865817f, -0.07511382f, -0.10307359f, -0.11021515f, 
    -0.01137553f, -0.12226372f, -0.55476171f, -0.02430527f, 0.04282956f, 0.03048523f, 0.07440700f, -0.07663503f, 
    0.22038542f, 0.04420343f, 0.13324353f, 0.11312963f, -0.03111503f, -0.29078090f, 0.33626691f, 0.04084983f, 
    -0.10626998f, 0.01780349f, -0.09435192f, 0.03574431f, 0.07892848f, 0.01001677f, -0.24302022f, 0.10914479f, 
    0.01010689f, -0.04911798f, 0.06216219f, 0.01763958f, 0.07545789f, -0.05196145f, -0.02883892f, -0.01526303f, 
    -0.09613363f, -0.01012968f, 0.02601403f, 0.00254675f, -0.02379139f, 0.03115936f, 0.09239998f, 0.04484296f, 
    -0.06581887f, -0.04909574f, 0.03629003f, 0.05643283f, -0.04768677f, -0.03289939f, 0.06307238f, -0.08038826f, 
    0.01763760f, -0.03882378f, -0.04361889f, 0.05443191f, -0.03205496f, -0.00936928f, -0.10020805f, -0.05596488f, 
    -0.06684062f, -0.10501610f, -0.10595302f, -0.06861047f, -0.06020734f, -0.05175908f, -0.05934986f, -0.04781429f, 
    -0.01652810f, 0.05145618f, 0.02421907f, -0.00512976f, 0.02838862f, -0.05973907f, -0.05985472f, 0.01366258f, 
    0.00158444f, 0.00194667f, 0.11555954f, -0.03780065f, -0.11296397f, -0.03812800f, -0.00335140f, -0.00686436f, 
    -0.08209385f, -0.04006481f, -0.05983404f, -0.03157551f, -0.02853381f, -0.09721504f, -0.11501870f, -0.09623872f, 
    -0.03128438f, -0.00091722f, -0.03983936f, 0.08296033f, -0.10653605f, -0.07902818f, -0.05736998f, 0.05379161f, 
    -0.02404607f, -0.06880417f, -0.05827409f, 0.00392612f, 0.00218971f, 0.03203861f, 0.04648935f, 0.02943284f, 
    -0.07777087f, 0.00397364f, -0.08818612f, 0.03082181f, 0.00847163f, -0.05243322f, -0.00743052f, 0.05479636f, 
    -0.02557402f, 0.02282377f, -0.01554898f, -0.07172877f, -0.04372375f, 0.01343637f, -0.05540304f, -0.07935344f, 
    -0.08406241f, 0.00045489f, -0.05132283f, 0.02917897f, 0.02672694f, 0.03994643f, -0.02256522f, -0.05833549f, 
    -0.10390580f, -0.10453866f, -0.06333013f, -0.09576034f, -0.04190509f, 0.05302421f, -0.05138598f, 0.00958945f, 
    -0.08642525f, -0.09259924f, 0.02864267f, 0.00568749f, 0.02476268f, 0.01603230f, 0.01579344f, 0.03716672f, 
    0.03611772f, -0.11321168f, 0.03994564f, -0.08659557f, 0.00189674f, -0.05399945f, 0.02510869f, -0.05534910f, 
    -0.10371260f, 0.01538010f, 0.01424109f, -0.11172836f, -0.05525311f, 0.08051970f, -0.01662681f, -0.04892432f, 
    0.01024018f, -0.02396511f, 0.01067405f, 0.04857359f, -0.02800043f, 0.09555668f, -0.01207358f, -0.03982576f, 
    0.04801247f, -0.03497491f, 0.01035733f, -0.04139721f, -0.04154636f, -0.07303715f, 0.00154870f, -0.11963000f, 
    -0.10301825f, -0.00105999f, -0.07193041f, 0.02776120f, -0.01435704f, -0.05994934f, -0.07310522f, -0.05876881f, 
    -0.04540935f, -0.05301198f, -0.12319684f, -0.07045039f, -0.01498053f, 0.00441368f, -0.06474285f, -0.01446258f, 
    -0.08070671f, 0.04257478f, -0.00907824f, 0.02140410f, -0.04111463f, -0.05779347f, 0.05021008f, -0.05844348f, 
    -0.08274049f, -0.04995525f, -0.10228299f, -0.13127249f, -0.07606743f, 0.00387953f, 0.01919751f, -0.00433192f, 
    -0.09375314f, 0.02112021f, 0.02310026f, 0.04471828f, -0.01683387f, 0.01043088f, 0.00030739f, 0.05132130f, 
    -0.05654050f, -0.11567276f, -0.05917202f, 0.05719936f, 0.09884171f, 0.23709588f, 0.31795901f, 0.16657524f, 
    0.01574775f, -0.06153817f, 0.04844373f, 0.07445890f, 0.19380453f, 0.00984453f, -0.16232261f, -0.01314885f, 
    0.04035103f, 0.10330652f, -0.21491936f, -0.07235358f, -0.08768555f, -0.21329363f, -0.06662571f, 0.16462401f, 
    0.25582254f, 0.12029219f, 0.11617265f, 0.26658985f, -0.18767998f, -0.06769063f, 0.04707879f, -0.08495031f, 
    0.01139286f, -0.00109218f, 0.05937318f, 0.04736163f, -0.02285415f, 0.22761503f, 0.07199695f, 0.53722078f, 
    0.01026572f, -0.14321670f, -0.13204630f, 0.09483323f, -0.10866522f, -0.06722233f, -0.08897119f, -0.34068850f, 
    0.05253898f, 0.39045319f, -0.12827995f, -0.18186371f, 0.00961916f, -0.33194578f, 0.04505303f, -0.15611935f, 
    -0.14643736f, 0.01953482f, -0.06725308f, 0.01390752f, 0.21412577f, -0.56242841f, -0.10908980f, -0.14264421f, 
    -0.26992351f, -0.01617762f, 0.04717813f, -0.03480932f, 0.11121570f, -0.09001446f, -0.12343501f, -0.00249190f, 
    0.24776040f, 0.08161787f, -0.06865177f, 0.09826347f, 0.07127273f, 0.07002697f, -0.09992687f, -0.04966737f, 
    -0.05406330f, -0.00665085f, -0.07055381f, -0.01593876f, 0.50199419f, 0.05852798f, 0.13563311f, 0.07486373f, 
    0.08923651f, 0.04801780f, 0.05536615f, -0.13736857f, 0.36857194f, -0.20358737f, 0.05263077f, -0.01189602f, 
    -0.44514307f, -0.00168567f, 0.09277322f, 0.29988071f, 0.03189916f, 0.12596776f, -0.12093748f, -0.10115949f, 
    -0.04124696f, -0.05386895f, 0.10364984f, 0.07601096f, 0.05693839f, 0.05814090f, 0.19463766f, -0.21095321f, 
    0.06640009f, -0.14654285f, -0.10829756f, -0.07752647f, -0.04691965f, 0.03914184f, -0.34725127f, -0.29220706f, 
    0.04367690f, -0.09607569f, 0.01290053f, 0.12021090f, -0.09584971f, 0.29098099f, -0.07768279f, -0.17712130f, 
    0.04219245f, 0.06609268f, -0.04876439f, -0.12423980f, -0.23014228f, -0.23607105f, -0.19728802f, -0.01341070f, 
    -0.04283861f, -0.11942672f, 0.01699450f, 0.08090819f, 0.11722230f, 0.18763898f, 0.03459486f, 0.04147547f, 
    0.13229810f, 0.01198916f, 0.24739070f, 0.15408944f, 0.08404430f, 0.10049783f, -0.20581771f, 0.03097920f, 
    0.09564687f, -0.05918729f, 0.06565867f, -0.10435067f, -0.04967777f, 0.26013362f, -0.03382898f, 0.02421718f, 
    -0.01972966f, 0.08875493f, -0.07305751f, -0.00236057f, -0.00967052f, 0.05233265f, 0.23281468f, 0.15184127f, 
    -0.08598983f, 0.10756713f, 0.18197067f, 0.19633116f, -0.04075867f, 0.01087357f, 0.00525673f, -0.16748235f, 
    -0.02588155f, -0.21140032f, -0.06944513f, 0.02496609f, 0.71652323f, -0.11641743f, 0.14655520f, -0.08136458f, 
    -0.09058863f, -0.12045600f, 0.31937400f, 0.20225285f, 0.17417781f, 0.04463254f, 0.22766058f, 0.16953799f, 
    0.09799573f, 0.10941492f, 0.00709161f, 0.31675792f, 0.00282974f, -0.12431374f, -0.29847971f, 0.11416859f, 
    0.04497630f, 0.03009929f, -0.12623665f, -0.04779481f, -0.16953388f, -0.20509629f, 0.13808325f, 0.35417879f, 
    0.06854707f, -0.00165805f, 0.00182217f, 0.14012125f, 0.00117204f, 0.06621523f, 0.00047339f, -0.09797676f, 
    -0.28774229f, 0.22883101f, 0.07060295f, -0.44131213f, -0.13476032f, 0.17433934f, -0.19730441f, -0.01000363f, 
    0.05226466f, -0.03211142f, -0.03795836f, -0.02117726f, 0.38822597f, -0.44148159f, -0.03426919f, -0.05340582f, 
    0.08046395f, 0.05024170f, 0.20780958f, 0.02265100f, 0.05626465f, 0.14425099f, 0.10531897f, 0.18612386f, 
    0.30916497f, 0.45946720f, 0.45215210f, 0.45336342f, -0.20121548f, -0.12406096f, -0.18118009f, -0.18174872f, 
    0.01788549f, 0.09222746f, -0.03055293f, 0.22869688f, 0.21252103f, 0.18022789f, -0.38607150f, 0.05318557f, 
    0.21731833f, 0.07943850f, 0.19954461f, -0.12450860f, 0.01067607f, 0.03445403f, -0.07608811f, 0.06284033f, 
    -0.42250708f, -0.26466459f, 0.14395817f, 0.13051000f, -0.06931052f, -0.03736106f, -0.09774602f, 0.10811253f, 
    0.16091907f, 0.09723950f, 0.05950779f, -0.02233494f, -0.58453977f, 0.33433875f, 0.16833766f, 0.39617819f, 
    0.08317737f, 0.17631873f, -0.04730160f, -0.01753255f, -0.07813958f, 0.14112997f, -0.00505730f, 0.16059789f, 
    0.23009825f, 0.08899470f, 0.43825951f, -0.02329035f, 0.20872632f, -0.01190864f, -0.03541337f, 0.11805142f, 
    -0.15141229f, 0.10372555f, 0.04980137f, -0.04244529f, -0.04664901f, 0.35998714f, -0.23375461f, -0.04963933f, 
    0.04554939f, 0.02803063f, -0.05998444f, 0.04167377f, 0.13582309f, 0.03001774f, 0.08277765f, 0.05245275f, 
    -0.53990388f, 0.02880439f, 0.30941364f, 0.45993310f, 0.05436769f, 0.13105947f, 0.13994938f, 0.06763329f, 
    -0.07679982f, 0.13395086f, -0.05116703f, 0.18736610f, 0.09621332f, 0.03985450f, 0.07734412f, 0.12449136f, 
    0.08007381f, 0.03323126f, 0.11194161f, 0.21859753f, -0.05535034f, 0.04512424f, 0.12839088f, 0.08366274f, 
    0.06786878f, -0.15423998f, -0.12729588f, -0.21249433f, 0.13585815f, -0.20679148f, 0.13596734f, 0.05507099f, 
    0.13204467f, 0.10196959f, 0.12024522f, 0.07622500f, -0.07923021f, -0.03553233f, -0.14341724f, -0.13721819f, 
    0.00002408f, -0.10326739f, 0.03871227f, -0.11258634f, -0.20246953f, -0.06038611f, -0.21177606f, 0.01223504f, 
    -0.17785096f, -0.04896307f, 0.01682282f, -0.30868018f, -0.07637780f, 0.08420721f, -0.20685807f, 0.18094778f, 
    0.11042131f, 0.26660809f, 0.17851849f, 0.07560086f, -0.65943217f, 0.57268596f, -0.24970411f, 0.09091476f, 
    0.25976300f, 0.31146625f, -0.25836176f, -0.18622394f, -0.23005283f, -0.09084329f, 0.06422159f, 0.10046072f, 
    0.04639390f, -0.03273041f, -0.01232721f, -0.06042247f, -0.01076594f, -0.06556318f, 0.01506130f, -0.06775369f, 
    0.03953324f, 0.06279399f, -0.04217310f, -0.04091960f, 0.06007348f, -0.04114246f, -0.04271175f, -0.06298707f, 
    -0.07275265f, -0.05185540f, 0.05233498f, 0.02625829f, -0.03227438f, 0.04470461f, 0.03975934f, -0.02309323f, 
    0.01691281f, -0.03458343f, 0.04829068f, -0.06705777f, -0.06050551f, -0.05074740f, -0.03394223f, 0.01452913f, 
    -0.05104321f, 0.05315509f, 0.01213687f, 0.04652134f, -0.03562535f, 0.00032069f, 0.06031296f, -0.00953227f, 
    -0.00810097f, -0.01894275f, -0.05597776f, -0.05500790f, 0.04182291f, -0.00260514f, 0.03710901f, -0.05146243f, 
    0.00437609f, -0.02993198f, -0.06028077f, -0.01057293f, 0.03331979f, 0.05713543f, 0.01219903f, -0.06028802f, 
    -0.04958982f, -0.02139623f, 0.00474701f, 0.01688669f, -0.07669920f, -0.06758015f, 0.05171311f, 0.01398792f, 
    0.01616138f, -0.07567938f, -0.00965803f, 0.00329710f, 0.00068237f, 0.05141260f, 0.05475806f, 0.01523909f, 
    -0.01995319f, -0.03809408f, 0.03474985f, 0.03832467f, -0.00253990f, -0.00465507f, 0.04597056f, -0.03235001f, 
    0.04946380f, -0.05392477f, -0.00112168f, 0.03709006f, -0.07231435f, -0.05247818f, 0.00881232f, 0.03100364f, 
    0.05304819f, -0.00649433f, 0.02068766f, -0.06437880f, 0.01094817f, -0.01544017f, -0.01756163f, -0.07706976f, 
    0.02904264f, -0.01218856f, -0.00484018f, -0.02154152f, 0.05451944f, -0.02662573f, -0.07050681f, -0.06657817f, 
    -0.06223142f, 0.03982256f, -0.03747917f, -0.01632380f, 0.05163653f, -0.04454790f, 0.00223917f, 0.01765153f, 
    -0.00881601f, 0.00924317f, -0.01492072f, -0.07959830f, 0.01135615f, 0.05445370f, 0.01399246f, -0.06566377f, 
    -0.05575741f, -0.00900243f, 0.02809285f, 0.01128915f, -0.06592599f, -0.07818668f, -0.00414310f, 0.04083047f, 
    0.00605140f, 0.05503960f, -0.00093694f, -0.03071589f, -0.05646221f, 0.04708884f, -0.01436570f, 0.00878406f, 
    0.01429276f, 0.05435012f, -0.01226391f, -0.03881987f, -0.06395403f, 0.06281524f, -0.01786738f, -0.03404737f, 
    -0.05381642f, -0.05441869f, -0.05508085f, 0.02352031f, -0.01587525f, -0.02472026f, -0.04230370f, 0.06015308f, 
    0.00886408f, -0.01952975f, -0.06647594f, 0.02831505f, 0.02894751f, -0.05844770f, -0.01248650f, 0.02703363f, 
    -0.06975422f, -0.03924784f, -0.01765744f, -0.04730091f, -0.02689018f, -0.03657119f, -0.06285507f, 0.02430005f, 
    -0.06521433f, 0.05606360f, -0.06732401f, 0.00617999f, -0.05280515f, -0.06464367f, 0.01286978f, 0.04901728f, 
    0.02086370f, 0.05997706f, -0.02838502f, 0.05559883f, -0.00255114f, -0.01824707f, 0.04532805f, -0.02998670f, 
    -0.03876755f, -0.04087932f, -0.00691780f, 0.01119821f, 0.00758758f, -0.06214926f, -0.06674615f, -0.05316079f, 
    0.21611965f, 0.12152974f, 0.05568659f, -0.18201658f, 0.14677745f, -0.00557106f, -0.17314321f, 0.13304493f, 
    -0.07987680f, -0.11219539f, -0.05804942f, -0.00990691f, 0.43935248f, 0.39837289f, 0.35554799f, 0.06078960f, 
    -0.15047216f, 0.13803147f, 0.07677076f, -0.02065779f, -0.03304081f, 0.04246959f, 0.01935143f, -0.14203675f, 
    0.04784995f, 0.13932636f, 0.16746630f, -0.13592847f, 0.02531127f, 0.14917240f, -0.13405286f, -0.03928982f, 
    -0.20396909f, 0.04420040f, -0.01834475f, 0.12947007f, -0.16237539f, 0.05292616f, -0.01037580f, -0.69275963f, 
    -0.02289319f, 0.02570751f, 0.17794508f, -0.13261285f, 0.10892644f, 0.10292540f, 0.17842248f, 0.02653078f, 
    0.46520683f, -0.08879190f, 0.36931357f, -0.17668390f, 0.17209212f, 0.25037390f, 0.09604102f, -0.05410161f, 
    -0.07718223f, -0.07480258f, 0.09673506f, 0.07340208f, -0.78956556f, 0.26006547f, -0.34955990f, -0.02858344f, 
    0.07295817f, 0.01831341f, 0.03098432f, 0.10510373f, 0.13538401f, -0.00561304f, -0.02717953f, -0.04734134f, 
    0.00036033f, -0.38226086f, 0.05624427f, -0.28499445f, -0.00694288f, -0.01140139f, 0.11617968f, 0.13738912f, 
    0.13247511f, -0.04870621f, 0.06666131f, -0.07508627f, 0.00880689f, -0.17856042f, -0.06347532f, -0.05146054f, 
    -0.13146228f, 0.05374410f, 0.07350988f, 0.34706461f, -0.10789666f, 0.19496897f, -0.07903785f, 0.16697235f, 
    0.19990642f, -0.07869010f, -0.02860778f, -0.21209314f, 0.31600514f, -0.04171914f, 0.03272236f, 0.12425263f, 
    -0.08199798f, 0.06292965f, -0.01820325f, 0.04986843f, -0.30797005f, -0.07512230f, -0.11509287f, 0.01371467f, 
    -0.14748913f, 0.12390464f, 0.02850603f, 0.12185890f, 0.03869209f, 0.09895188f, 0.13487674f, 0.30766937f, 
    -0.06382579f, -0.25990313f, -0.06276271f, 0.06026414f, 0.07865391f, -0.18155399f, -0.11658217f, 0.12190365f, 
    -0.10014577f, -0.10313349f, 0.04563075f, 0.09807804f, 0.04353913f, 0.07612267f, 0.13069801f, -0.20825490f, 
    -0.28124061f, -0.00617813f, -0.18870005f, -0.13946287f, 0.14080428f, -0.05097505f, -0.12151027f, 0.05110503f, 
    0.07238171f, -0.07843969f, 0.15682955f, -0.16758952f, 0.15261017f, -0.10329970f, 0.19013005f, 0.26809564f, 
    0.16037008f, 0.22207634f, 0.20387593f, 0.22158755f, 0.09538601f, 0.00370313f, 0.05024862f, 0.25023350f, 
    0.07099783f, -0.07720727f, -0.08527469f, -0.03357306f, 0.02307697f, 0.21518385f, -0.05530293f, -0.03395730f, 
    0.03388273f, -0.16180962f, -0.11990682f, -0.19067484f, -0.07629592f, -0.03533344f, -0.08817998f, 0.10985119f, 
    -0.13921504f, -0.14982451f, 0.17469765f, 0.04397659f, 0.02397221f, -0.34336126f, -0.29008800f, 0.28173926f, 
    -0.19210806f, -0.01243721f, 0.05798681f, -0.08046582f, 0.04740455f, 0.06446062f, -0.01349270f, 0.15020312f, 
    -0.07177082f, -0.04635897f, -0.00832802f, 0.00571428f, 0.01664077f, -0.04131700f, 0.06398756f, -0.05931929f, 
    -0.07029844f, -0.00975131f, 0.01577253f, -0.00948493f, 0.00874980f, 0.02818431f, -0.07674936f, 0.01193594f, 
    -0.00795595f, -0.03439504f, 0.06225730f, -0.02756880f, -0.01523141f, 0.02619918f, -0.04267842f, 0.03332773f, 
    -0.03150993f, -0.05238864f, -0.05056787f, -0.02752857f, 0.00682563f, -0.01199641f, 0.01939808f, 0.06143157f, 
    -0.01934073f, 0.02091954f, -0.05395952f, 0.00957608f, -0.02641035f, -0.06772993f, 0.04017125f, 0.01995187f, 
    0.01752967f, 0.04914559f, -0.02075313f, 0.05007738f, 0.00204899f, -0.01459669f, -0.03267356f, 0.01639167f, 
    -0.06848180f, -0.04937024f, -0.01746328f, 0.04064881f, -0.04806893f, 0.04119479f, -0.02345604f, -0.07120790f, 
    0.05022978f, 0.00266167f, 0.00025873f, -0.00461133f, 0.00292872f, -0.00846422f, -0.06152450f, 0.00906880f, 
    0.01850544f, -0.03249478f, 0.02464199f, 0.04940109f, 0.01194219f, 0.01438365f, -0.07376035f, 0.02188342f, 
    0.01303705f, 0.04080171f, -0.01890260f, -0.02929782f, 0.05510117f, -0.07769698f, 0.00434679f, 0.00965136f, 
    0.05472476f, -0.07014471f, -0.01103269f, -0.04134136f, -0.00983364f, 0.01602223f, -0.02249244f, 0.06258580f, 
    -0.00599568f, -0.07244845f, -0.04643411f, -0.03016121f, 0.03188749f, 0.02140254f, -0.07546566f, -0.01294550f, 
    -0.01976686f, -0.02514304f, 0.03207200f, 0.01329890f, 0.00216023f, -0.05498797f, -0.05342608f, 0.00601179f, 
    -0.05799797f, -0.01770354f, -0.05322931f, -0.07753010f, 0.06060484f, 0.05058880f, -0.06473085f, -0.00937980f, 
    0.05024543f, -0.06246986f, -0.00479994f, -0.07244309f, -0.01828416f, 0.01143645f, 0.03971032f, -0.05874707f, 
    -0.05536206f, -0.07178737f, 0.04409322f, -0.00698366f, 0.03679867f, -0.06691206f, 0.01540337f, -0.04211532f, 
    0.01792510f, 0.04033953f, 0.05045435f, -0.03016114f, -0.00556300f, -0.02199734f, -0.03116436f, 0.03394159f, 
    -0.05827430f, -0.04691148f, -0.05551912f, 0.03997865f, 0.00745371f, -0.03469990f, 0.00358230f, -0.07834762f, 
    -0.04668061f, -0.07281154f, -0.03943697f, 0.02612345f, -0.07814656f, -0.04359761f, -0.01009241f, 0.02213728f, 
    -0.02791463f, -0.06378119f, -0.02557203f, -0.07731342f, 0.03500025f, 0.04287033f, 0.00601642f, -0.07270744f, 
    0.00185219f, -0.02082157f, 0.05471751f, 0.00435569f, 0.02240546f, -0.07720567f, 0.02147415f, 0.06287488f, 
    0.01677588f, -0.07872229f, -0.06962049f, -0.06335019f, 0.04501220f, 0.00041079f, -0.04482103f, 0.01137999f, 
    -0.06376706f, 0.04114332f, 0.01799027f, -0.04898580f, 0.03832132f, 0.00179542f, 0.05958274f, 0.03295076f, 
    0.01635631f, -0.04847559f, -0.06770458f, -0.06798913f, 0.00828951f, 0.03440003f, 0.04537460f, -0.07293681f, 
    -0.05645449f, -0.02916513f, 0.02764601f, -0.07629567f, -0.00186802f, 0.04624445f, 0.04565626f, -0.02662248f, 
    0.01050234f, -0.05135191f, -0.00595140f, 0.00196211f, 0.04515468f, -0.07579109f, -0.06043598f, 0.06925697f, 
    0.01717762f, 0.05843261f, -0.02092598f, -0.07683433f, -0.06230194f, 0.05023698f, 0.00503545f, 0.04636292f, 
    0.04371408f, 0.01783545f, -0.07371732f, -0.08009651f, 0.01652491f, 0.03465191f, -0.01073149f, -0.05655108f, 
    -0.04337032f, -0.01050247f, -0.05739429f, -0.03809393f, -0.01336425f, 0.04384486f, -0.07050295f, -0.01612058f, 
    -0.03670364f, 0.04427918f, -0.04624293f, -0.03452224f, 0.00018769f, 0.01350617f, -0.03116810f, 0.04782633f, 
    -0.06163314f, -0.07740909f, -0.01307765f, 0.04576711f, -0.04248960f, 0.06406397f, 0.00371620f, -0.05332655f, 
    -0.00926514f, -0.00422525f, 0.06158990f, -0.06506521f, 0.04516807f, -0.00397239f, 0.00815799f, -0.00453041f, 
    0.03221468f, -0.06047430f, 0.04803820f, 0.02585958f, -0.05907562f, -0.03591503f, 0.04410801f, -0.06510015f, 
    0.03041838f, 0.01854102f, -0.01608516f, 0.02800484f, 0.02929019f, 0.04475883f, 0.02117749f, 0.06034302f, 
    -0.07159845f, -0.01969084f, -0.03894796f, -0.04259355f, -0.00580791f, -0.02993230f, -0.01295265f, -0.00900383f, 
    -0.01563502f, -0.05459371f, 0.00753446f, -0.06164857f, -0.03635518f, 0.00205254f, -0.07532388f, 0.06005848f, 
    0.06569246f, -0.01539202f, -0.06892440f, -0.03390857f, -0.00116220f, 0.02811616f, 0.03863162f, -0.01370594f, 
    -0.05284486f, -0.00511968f, -0.03401284f, 0.01707256f, 0.00018585f, -0.02006392f, 0.01992366f, -0.02936846f, 
    -0.06995779f, 0.03451296f, 0.01376366f, 0.03890263f, -0.02118624f, 0.05017456f, -0.02169472f, -0.03730580f, 
    -0.02052246f, 0.01681613f, -0.05976702f, 0.00333310f, 0.04761600f, -0.05070686f, -0.01044233f, -0.04537655f, 
    -0.05533255f, 0.01341059f, -0.03859680f, -0.00583695f, -0.01506057f, 0.05981353f, 0.00408007f, 0.01984615f, 
    -0.05049450f, 0.02841424f, -0.02144488f, 0.01295401f, -0.02709393f, 0.05351587f, -0.05634696f, 0.00010008f, 
    -0.03750053f, 0.04063948f, -0.05154403f, -0.04245446f, 0.04299409f, -0.04352545f, -0.03975033f, 0.00920364f, 
    0.01614590f, 0.00672925f, -0.01680841f, 0.03920985f, -0.07367068f, 0.00572292f, 0.04169733f, 0.03880677f, 
    -0.02362076f, -0.06244376f, -0.05472707f, 0.04117999f, 0.01518860f, -0.04866369f, -0.01250695f, 0.03494617f, 
    0.01488795f, -0.02273518f, -0.03936570f, -0.02708290f, -0.00974998f, 0.06282922f, 0.03578497f, -0.04491728f, 
    -0.06186850f, -0.00412388f, 0.04390321f, -0.01217669f, -0.07596020f, -0.04896280f, 0.03378362f, -0.03763499f, 
    0.05826511f, 0.00001868f, 0.01983464f, -0.02799464f, -0.00278959f, -0.05613404f, -0.04776024f, -0.01790787f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.12681288f, -0.00336051f, -0.00761144f, -0.02188205f, 0.12419345f, -0.06624413f, -0.01689100f, -0.09949970f, 
    0.40662634f, 0.07112174f, 0.17515919f, -0.03964430f, 0.08863533f, 0.19138153f, 0.19125463f, 0.14406639f, 
    0.08707494f, -0.15871525f, -0.11650037f, -0.00408856f, 0.21508703f, 0.12830561f, 0.05723608f, 0.09523184f, 
    0.18635997f, -0.01858848f, -0.00033105f, -0.00003023f, -0.06240333f, 0.16705202f, -0.07249444f, 0.02623920f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.08554215f, -0.00375851f, -0.00949491f, -0.06158923f, -0.06601297f, -0.04164269f, -0.13480373f, -0.01813734f, 
    -0.20738795f, 0.04059928f, 0.00461151f, 0.09731469f, 0.05860353f, -0.15857893f, -0.16150407f, -0.04541866f, 
    0.10381116f, 0.03807759f, 0.07010266f, 0.24521331f, 0.17225236f, -0.12677073f, 0.01342419f, -0.22074948f, 
    -0.17714447f, -0.07315272f, 0.03915247f, -0.27676958f, 0.13858345f, -0.33319160f, 0.15107059f, -0.06490667f, 
    0.07544226f, 0.04721038f, 0.12783049f, -0.04216042f, 0.05436955f, 0.32482877f, 0.09235632f, -0.00094373f, 
    0.02709751f, -0.33285645f, -0.22761816f, 0.05187859f, 0.24849971f, 0.09770957f, 0.28286180f, -0.21201016f, 
    0.34073681f, 0.02842985f, 0.25447467f, -0.06869105f, 0.11831869f, -0.00152589f, 0.05479416f, -0.47829419f, 
    -0.44431758f, -0.07173654f, 0.18372925f, 0.31274340f, -0.13607879f, 0.20632589f, -0.12756260f, -0.10799089f, 
    0.01262176f, 0.37550980f, -0.01704319f, -0.04393245f, -0.12187772f, 0.05281875f, 0.15786923f, 0.19511779f, 
    -0.20633537f, -0.25719503f, 0.07063302f, 0.03389405f, 0.37725937f, 0.26255247f, -0.14686745f, 0.56147605f, 
    0.15833244f, -0.00992828f, 0.29171219f, -0.15839697f, -0.48234293f, 0.03373031f, -0.34844574f, 0.28296798f, 
    0.52396238f, 0.14503486f, -0.27134332f, 0.30864877f, 0.15126002f, 0.13124038f, -0.16527881f, -0.04349439f, 
    0.09992806f, -0.09716579f, 0.10837138f, 0.08684325f, 0.17905976f, 0.21210812f, 0.14296988f, 0.00405083f, 
    0.29449922f, 0.26632607f, -0.04054189f, -0.06815436f, 0.00391426f, 0.41813731f, -0.21685781f, 0.37924695f, 
    -0.31513700f, 0.06710023f, 0.12998776f, -0.05659498f, 0.18736266f, -0.42663819f, 0.11036009f, 0.50513828f, 
    0.39665386f, -0.22299764f, 0.00438058f, -0.12786403f, 0.11552564f, -0.17284919f, 0.10250179f, -0.16044433f, 
    -0.04850733f, 0.07849749f, 0.17130251f, -0.06908873f, -0.01515898f, 0.15494628f, -0.10372476f, -0.09443005f, 
    -0.07601953f, -0.06891882f, 0.13974336f, -0.05175424f, -0.15221862f, -0.16672648f, -0.01921243f, -0.07397918f, 
    -0.06698894f, -0.07543717f, -0.07032716f, -0.07012188f, -0.03016640f, 0.14343211f, -0.07204154f, -0.04431581f, 
    -0.04674920f, -0.01598405f, 0.04405208f, 0.00684132f, -0.16314539f, -0.11006154f, 0.11856952f, 0.02488299f, 
    0.36979106f, -0.28895339f, 0.03366761f, -0.00436724f, 0.45841065f, 0.28193265f, 0.05832195f, 0.21683563f, 
    0.24439444f, 0.32780218f, -0.26692933f, -0.12481189f, -0.23497395f, -0.16773827f, -0.01045415f, -0.12188146f, 
    -0.49448404f, -0.16176727f, -0.71689886f, 0.25115851f, 0.27462614f, 0.46983868f, 0.02553191f, 0.04627671f, 
    -0.35556516f, -0.08034609f, -0.11882205f, 0.21188113f, -0.16875035f, 0.24515188f, -0.00379627f, -0.04275231f, 
    -0.27088511f, -0.25338116f, 0.09833112f, -0.08580780f, -0.01786813f, 0.12439051f, -0.02846906f, -0.38972518f, 
    -0.40724728f, -0.03240946f, -0.15389112f, -0.11224656f, -0.05649491f, 0.11598123f, -0.35283086f, -0.24440859f, 
    0.20120414f, 0.14981236f, 0.26017499f, -0.32287049f, 0.13247271f, -0.21696223f, 0.01960205f, -0.19776422f, 
    -0.21635516f, 0.16652696f, -0.12828523f, 0.14184913f, -0.02927377f, 0.12387174f, -0.12960337f, 0.04805588f, 
    -0.08451008f, 0.32285839f, -0.07073232f, -0.17003272f, -0.20944382f, -0.12960422f, 0.10679853f, 0.17137782f, 
    0.19155000f, -0.17941830f, 0.23512033f, -0.00644187f, 0.29423282f, -0.27494437f, 0.26215816f, -0.06653002f, 
    0.04504159f, -0.08873206f, 0.32708937f, 0.24684460f, -0.17887335f, 0.22474486f, -0.09422456f, -0.45174688f, 
    -0.20676342f, -0.04718101f, 0.22465418f, -0.10726621f, -0.05368206f, -0.08654925f, -0.06654896f, 0.14309163f, 
    0.04337260f, -0.37475023f, -0.12841386f, -0.00956795f, -0.30673340f, 0.19808163f, -0.05156479f, -0.25599089f, 
    -0.16377270f, -0.03232134f, 0.42249376f, 0.05356224f, 0.32108665f, -0.01489133f, 0.01448405f, 0.01178802f, 
    -0.09203655f, 0.07805438f, -0.06466620f, -0.02055600f, -0.21760064f, -0.08919148f, 0.02898346f, -0.13292539f, 
    -0.19541188f, -0.00110888f, -0.01493425f, 0.07615384f, -0.01564236f, 0.17157683f, -0.02398135f, -0.05614641f, 
    0.26488754f, -0.00511769f, 0.12915057f, 0.02991368f, -0.10440738f, 0.32156283f, -0.06460857f, 0.62420416f, 
    0.11712946f, -0.18530135f, 0.18204598f, -0.10832516f, 0.19015753f, -0.06689441f, -0.40184420f, 0.38459608f, 
    -0.19805083f, 0.14281034f, 0.02738434f, 0.05125247f, -0.15684646f, 0.08720995f, -0.29455933f, 0.47586617f, 
    0.19941415f, 0.04650754f, 0.46849313f, -0.11270950f, 0.13743645f, 0.17809501f, 0.00391237f, 0.03893089f, 
    -0.04955814f, -0.05510574f, -0.03625141f, -0.11332376f, 0.32815984f, -0.34187201f, 0.14706858f, -0.63440329f, 
    0.13395254f, -0.06411754f, 0.28884226f, 0.12325610f, 0.06635123f, 0.16242489f, -0.00391975f, 0.28150642f, 
    -0.00437342f, -0.50471234f, -0.31277898f, -0.37084943f, -0.00199542f, 0.27335942f, 0.13727711f, 0.20309524f, 
    0.41837591f, 0.06853858f, -0.25718591f, -0.18919329f, -0.14314698f, 0.44853932f, 0.15353179f, 0.13980646f, 
    -0.16512294f, 0.12876232f, 0.03992227f, 0.10528259f, 0.31965068f, -0.47096539f, 0.17156911f, -0.44120786f, 
    0.23553516f, -0.00135052f, -0.10621139f, 0.04946549f, 0.10972270f, 0.05349277f, 0.50439709f, -0.00681336f, 
    0.32237378f, -0.39388087f, -0.10248307f, -0.00742502f, 0.37784570f, 0.32631093f, 0.41573241f, 0.02937731f, 
    0.10944308f, -0.14361683f, -0.23557484f, 0.04683739f, -0.09248239f, -0.17703465f, -0.00911807f, 0.02922607f, 
    -0.14434928f, 0.42294082f, -0.08140782f, 0.16080074f, -0.29915875f, 0.32505429f, -0.03158240f, 0.11724521f, 
    0.27048185f, -0.02441447f, -0.59870875f, 0.07878962f, 0.09431873f, 0.52776974f, -0.08568241f, 0.29320329f, 
    0.20728393f, 0.05828715f, 0.22088826f, 0.21163148f, -0.28337771f, -0.40337497f, -0.20632643f, -0.13784477f, 
    -0.00601136f, -0.07815045f, -0.23012057f, 0.30357003f, 0.07338036f, 0.04434601f, -0.14889598f, -0.06697515f, 
    -0.30836284f, 0.34304917f, -0.15958630f, -0.16173032f, 0.39744863f, -0.30461326f, 0.05359060f, -0.68771714f, 
    0.16225629f, -0.02689488f, -0.23978560f, 0.01592435f, 0.15419875f, 0.16088259f, 0.28573844f, -0.20105515f, 
    -0.00565897f, 0.07027753f, -0.10106106f, -0.00286259f, 0.04885448f, 0.03837804f, 0.39555347f, -0.44437796f, 
    0.12343682f, 0.13174714f, 0.11020255f, -0.02647826f, -0.06096019f, 0.17743357f, 0.04783138f, 0.05545176f, 
    0.34866512f, -0.13320769f, -0.00990197f, -0.14227347f, 0.23017873f, 0.43608066f, -0.13850957f, -0.09267666f, 
    0.15374348f, 0.19348679f, -0.36889628f, 0.04520270f, -0.07494426f, 0.33556843f, 0.08626443f, 0.23310594f, 
    -0.13346338f, -0.01461981f, -0.03277298f, -0.17085630f, -0.23927206f, -0.40052316f, 0.14203945f, 0.22586986f, 
    -0.09143721f, 0.00392779f, 0.16481085f, 0.11147032f, 0.09187846f, -0.30818945f, 0.16296297f, -0.01186321f, 
    0.32014656f, -0.02351398f, 0.03671073f, 0.03941256f, -0.06841764f, -0.27750370f, -0.10128752f, -0.24307248f, 
    -0.09101689f, -0.01800074f, 0.26585844f, 0.02676165f, 0.33196443f, 0.15504846f, 0.41465244f, 0.27847430f, 
    -0.08733151f, -0.00312827f, 0.25569159f, -0.18295923f, -0.35827744f, 0.44135815f, -0.15348467f, 0.17195214f, 
    -0.20542331f, 0.07493629f, 0.38268572f, 0.08304699f, 0.08450849f, 0.06613978f, -0.04515844f, -0.00308844f, 
    -0.00529666f, -0.02023626f, -0.02176931f, 0.06988860f, 0.38678852f, 0.62755662f, -0.07345123f, 0.30881774f, 
    -0.18754090f, 0.22846161f, -0.04137217f, 0.04765159f, 0.10064238f, 0.10032257f, -0.10085405f, 0.20375389f, 
    -0.00819910f, -0.48625797f, 0.10353205f, -0.55577636f, -0.07724416f, 0.15279566f, 0.30963922f, 0.73744518f, 
    0.23855233f, 0.03066934f, -0.42075482f, 0.35362828f, 0.12165249f, 0.14372361f, -0.04453428f, -0.02385964f, 
    -0.14620952f, 0.04812784f, -0.01970386f, -0.01141941f, 0.13775425f, -0.17742266f, 0.04604276f, -0.05829660f, 
    -0.08079436f, -0.21843500f, -0.16833001f, -0.04972808f, 0.03766104f, -0.05536871f, -0.11879078f, 0.11892769f, 
    -0.31163657f, 0.12791042f, 0.04380449f, -0.10827556f, 0.21742314f, -0.01889390f, -0.11842351f, -0.17642978f, 
    0.02917495f, -0.05233981f, -0.14663261f, 0.01746253f, -0.00305664f, 0.07956307f, -0.02695143f, -0.10809606f, 
    0.39751300f, 0.30329764f, -0.13602205f, -0.18782873f, 0.07903808f, -0.69264829f, 0.10959620f, -0.70815909f, 
    0.28599134f, -0.03980054f, -0.18453728f, 0.11568475f, 0.20583285f, 0.25888717f, 0.13475199f, -0.30389380f, 
    -0.07206542f, -0.20129843f, 0.05796791f, 0.42766443f, 0.35708472f, 0.32873300f, 0.04861087f, -0.64589113f, 
    -0.37949294f, 0.14553069f, 0.15610124f, 0.03347769f, -0.07993931f, 0.03763051f, 0.10276113f, -0.03963314f, 
    -0.07410954f, -0.26813257f, -0.03199892f, 0.12811613f, 0.09502403f, -0.38104975f, -0.13738026f, -0.66071510f, 
    0.10217592f, 0.29778543f, 0.26188788f, 0.11418346f, -0.04929644f, 0.38564858f, -0.27335545f, 0.34747604f, 
    -0.10361709f, -0.02633233f, -0.25954151f, 0.10785004f, 0.14023080f, 0.28609988f, 0.33960167f, -0.01517933f, 
    0.40003002f, -0.00116585f, -0.21698120f, 0.06130986f, -0.01403524f, 0.46955690f, -0.17695984f, 0.05056199f, 
    0.32164678f, -0.09244954f, 0.09891463f, -0.04635838f, 0.19983368f, 0.10367477f, 0.17194985f, -0.13718793f, 
    0.14000440f, -0.03184918f, -0.07766612f, -0.04176496f, 0.05128025f, 0.14525434f, 0.53984934f, -0.30094600f, 
    0.33967176f, -0.42786241f, 0.08756566f, -0.41488317f, -0.00649664f, 0.02603561f, -0.03380378f, -0.41186410f, 
    -0.47860217f, 0.13612500f, 0.28363344f, 0.39776564f, -0.14331958f, -0.12396548f, 0.03052741f, 0.02544499f, 
    -0.19350791f, -0.22921912f, -0.12785575f, -0.04689834f, 0.31758159f, 0.05117784f, -0.12404802f, -0.23391651f, 
    -0.08796226f, -0.31798908f, -0.18902934f, 0.16310410f, -0.14575115f, -0.15329494f, -0.09915753f, -0.37535855f, 
    0.07289701f, 0.11018001f, 0.22569001f, -0.32264233f, 0.05293775f, 0.08450773f, 0.11071027f, -0.20694235f, 
    -0.22823727f, -0.09124205f, -0.24017091f, -0.21316616f, 0.11001436f, 0.20879447f, -0.14348848f, 0.06936880f, 
    0.39924967f, -0.31981871f, -0.01093497f, 0.12250436f, 0.10170544f, -0.00093224f, -0.08746806f, 0.42439684f, 
    0.19038419f, 0.08204099f, 0.41980839f, 0.13485037f, 0.35806867f, -0.23584688f, -0.15196452f, 0.08659956f, 
    -0.09496445f, -0.23619793f, -0.12075276f, -0.43884632f, -0.04420371f, -0.15253381f, 0.16643260f, 0.03757484f, 
    -0.06329507f, 0.01260307f, 0.06317080f, 0.29253247f, -0.17214419f, -0.29939038f, 0.10329682f, 0.06026994f, 
    -0.07408767f, 0.02929830f, -0.12818304f, -0.06143449f, 0.00274542f, -0.44560966f, 0.17599362f, -0.30301628f, 
    0.15634678f, -0.20325345f, 0.26975372f, 0.04600902f, 0.18599626f, 0.08426169f, -0.02897451f, 0.33083427f, 
    0.11857770f, -0.29128817f, -0.09238020f, -0.25967225f, -0.05227228f, 0.22005458f, -0.20774588f, -0.22146979f, 
    0.21420354f, -0.04196192f, -0.02781459f, 0.28972247f, -0.01001550f, 0.47030875f, -0.11779975f, 0.02075115f, 
    0.36253583f, -0.02420975f, -0.10332293f, -0.03971171f, 0.36678055f, 0.44839171f, -0.11329648f, 0.15362029f, 
    -0.01811571f, 0.06231309f, -0.24507062f, -0.02687886f, 0.22716950f, -0.07978249f, -0.25103435f, -0.08317651f, 
    0.13160121f, -0.65864658f, 0.08953496f, -0.32414174f, 0.46129221f, -0.25440589f, 0.29160127f, -0.21577062f, 
    -0.08864079f, 0.03801658f, 0.09481671f, -0.05506874f, 0.10019296f, -0.36678216f, -0.15254813f, 0.00953785f, 
    0.13235061f, 0.27975622f, -0.09291918f, -0.05556343f, -0.13010536f, -0.68804687f, -0.06546317f, 0.21461219f, 
    0.20160733f, -0.17356665f, 0.28125262f, 0.12410244f, 0.40590611f, -0.40066797f, 0.27872667f, -0.13379280f, 
    -0.18624379f, 0.01962436f, 0.08755437f, 0.29744047f, 0.24119049f, 0.34814122f, -0.08535799f, -0.24502958f, 
    0.18345800f, -0.06305974f, 0.17499901f, -0.24484646f, 0.09400741f, -0.07864411f, -0.12743540f, 0.14476426f, 
    0.11174161f, -0.36245844f, -0.15550274f, 0.13426040f, 0.05528911f, 0.07545996f, 0.06801719f, -0.38192487f, 
    -0.07426728f, 0.05670690f, -0.24019022f, -0.01254379f, -0.03159822f, 0.00380453f, 0.09815893f, -0.01724311f, 
    -0.08151587f, -0.10150051f, 0.04157186f, 0.08122185f, -0.01271260f, 0.18988049f, 0.15186749f, -0.24264634f, 
    -0.20960523f, -0.09588385f, -0.21898736f, 0.10554139f, -0.02797491f, 0.27563781f, 0.07356378f, 0.06529343f, 
    0.16066346f, -0.19538601f, 0.05192541f, -0.02188160f, 0.20831926f, 0.22120577f, -0.12622860f, 0.07810506f, 
    0.23090540f, 0.27820572f, 0.19211717f, 0.06416340f, -0.33565772f, 0.00746466f, 0.31579718f, -0.31186020f, 
    0.39337793f, -0.23740274f, -0.08312754f, 0.33482441f, 0.18045437f, 0.02397874f, 0.25248709f, -0.28494281f, 
    -0.14093047f, -0.04083377f, -0.13135958f, 0.38284254f, 0.10036317f, 0.33345208f, -0.16713272f, 0.13003485f, 
    -0.02468188f, -0.12753570f, 0.09394296f, 0.07207768f, 0.07708033f, -0.45486048f, -0.08874506f, -0.37702996f, 
    0.31111974f, -0.00802063f, 0.23316818f, 0.09235658f, -0.09497511f, 0.22874036f, 0.17770237f, 0.26983926f, 
    -0.06835787f, 0.02302213f, 0.13357368f, 0.26582459f, 0.02275223f, -0.16914363f, -0.22461163f, 0.15122686f, 
    0.16469888f, 0.11900399f, 0.43390259f, -0.24969685f, -0.16463369f, 0.25044057f, -0.13921134f, 0.00730765f, 
    -0.05400041f, 0.25586092f, -0.09880243f, 0.05613551f, -0.12353425f, -0.33857664f, -0.16749543f, -0.58225811f, 
    0.20973141f, 0.01181266f, -0.05340749f, 0.01831614f, -0.30515715f, -0.11033203f, 0.17078587f, -0.38898572f, 
    -0.12855242f, 0.28938127f, -0.33597246f, 0.28062060f, -0.13903303f, -0.24297394f, -0.10019614f, -0.35021219f, 
    -0.32630160f, 0.14702263f, 0.23073356f, 0.05784554f, 0.14085595f, -0.13098454f, 0.16830888f, 0.06595812f, 
    -0.33628038f, 0.10492603f, 0.15386422f, -0.13448419f, 0.24082838f, -0.16793820f, 0.13234092f, -0.09283692f, 
    0.32958877f, 0.07501820f, 0.19754346f, -0.01251672f, 0.10337523f, 0.00699317f, 0.24598199f, -0.07266659f, 
    0.20212002f, 0.22452708f, -0.03731493f, -0.22868747f, 0.03820198f, -0.39070153f, -0.13098982f, 0.42662987f, 
    0.15198494f, 0.07555882f, 0.23526381f, -0.07728829f, 0.14782637f, -0.40494600f, 0.08931383f, 0.01344490f, 
    -0.35520041f, 0.32144144f, -0.02171686f, 0.09111252f, 0.17198780f, 0.24856155f, 0.10552268f, -0.19119769f, 
    0.21095504f, 0.10507856f, -0.17494006f, -0.00535744f, -0.09362436f, 0.25332469f, -0.04297904f, 0.13401124f, 
    0.17086728f, 0.22041978f, 0.09607820f, 0.18714133f, 0.11359624f, -0.29553321f, 0.13364111f, 0.52802199f, 
    0.27380866f, 0.14309806f, 0.20886911f, -0.19579870f, -0.02273563f, -0.10790896f, 0.03987422f, 0.09339507f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.04915605f, 0.01238526f, 0.05180831f, 0.00139684f, -0.14909464f, 0.28033417f, -0.10847946f, -0.14001352f, 
    -0.19697298f, -0.21100938f, 0.09635668f, 0.32278427f, -0.23919891f, 0.21879798f, -0.01778589f, 0.18830037f, 
    0.08096921f, 0.14674877f, 0.09859942f, 0.08282886f, 0.08837841f, -0.13785359f, 0.19153269f, -0.02311370f, 
    -0.05518958f, 0.18490571f, -0.12728423f, 0.26884234f, 0.08941977f, 0.17991915f, 0.23892577f, 0.00469805f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.10829017f, 0.11775136f, 0.25023785f, -0.09432970f, -0.06661493f, -0.34351218f, 0.28119516f, 0.17317517f, 
    -0.11979910f, 0.34033412f, -0.38887364f, -0.51548707f, 0.25725120f, -0.15825245f, -0.43843693f, 0.05748757f, 
    0.00232098f, -0.32940149f, -0.53412765f, -0.37373099f, -0.70874155f, 0.16535050f, -0.33450806f, -0.01437338f, 
    -0.07782891f, 0.17506348f, 0.18068324f, -0.49591598f, -0.20213650f, -0.66308725f, -0.18446597f, 0.02485257f, 
    -0.13191020f, -0.00203374f, -0.01490188f, -0.01865006f, 0.12270986f, 0.48928314f, 0.08414605f, 0.17833944f, 
    0.08583450f, -0.03209956f, -0.41648692f, 0.02736430f, 0.26542264f, 0.29044035f, -0.14567751f, -0.06496260f, 
    -0.92594916f, 0.27253628f, 0.43040788f, -0.18905963f, -0.18846458f, -0.28109136f, -0.30831456f, -0.06264293f, 
    -0.29604271f, 0.22061080f, -0.09184331f, -0.13344455f, 0.16780283f, -0.09960908f, 0.21866846f, 0.04837840f, 
    -0.10635547f, 0.22685064f, -0.44833907f, 0.08116160f, -0.02436427f, -0.96155745f, 0.07053208f, -0.00174896f, 
    0.26469150f, -0.23006949f, -0.07054431f, 0.16252688f, -0.26568311f, 0.25388956f, 0.36026558f, -0.07623328f, 
    0.00482482f, -0.00703982f, -0.01799063f, -0.20158333f, 0.18986110f, 0.02538989f, 0.01230546f, -0.38266256f, 
    0.67454237f, -0.01154285f, -0.00665599f, -0.19916354f, -0.03363334f, -0.71367341f, 0.37098309f, 0.24389423f, 
    0.10392137f, 0.17547096f, 0.10851710f, -0.16311032f, 0.00779009f, -0.33610108f, -0.62661564f, 0.03113885f, 
    -0.38684416f, -0.17711370f, -0.37090272f, -0.10145128f, 0.19095396f, 0.03004997f, 0.25740921f, -0.09820231f, 
    0.18465966f, 0.02009226f, -0.13416517f, -0.41745424f, 0.36900893f, -0.51079428f, 0.29757246f, -0.02914432f, 
    0.47849250f, -0.20002556f, -0.38897616f, 0.01696833f, -0.84507060f, -0.24786662f, -0.10915475f, -0.28535694f, 
    -0.45617983f, 0.00435742f, 0.21837208f, -0.04296548f, 0.07435285f, -0.02101979f, -0.10385828f, -0.25345927f, 
    0.08584237f, 0.05243301f, -0.01342187f, -0.12977767f, 0.09021282f, 0.22896250f, 0.13981786f, 0.06136166f, 
    0.22458982f, 0.09141582f, -0.59228849f, -0.02532599f, 0.01409716f, -0.59367132f, -0.36507592f, 0.04350271f, 
    -0.25323817f, -0.50823921f, -0.09523273f, -0.22636263f, -0.00803652f, 0.20868941f, 0.20703878f, 0.18334666f, 
    0.11571222f, -0.19023712f, 0.17240708f, -0.01523518f, 0.10023542f, -0.19951236f, -0.24316068f, 0.02211815f, 
    0.05520495f, 0.07220160f, 0.46445704f, 0.06373847f, -0.24527198f, 0.11856171f, -0.10985737f, 0.30745852f, 
    -0.10357967f, -0.27520892f, 0.02593129f, 0.13228050f, -0.17537089f, -0.30972493f, 0.10270593f, 0.23862267f, 
    -0.36992541f, 0.31118223f, -0.06783431f, -0.41876170f, 0.11859803f, -0.18053237f, -0.07853004f, -0.21460927f, 
    0.06429157f, -0.28053439f, -0.85688698f, 0.07061014f, -0.10750984f, -0.02119437f, -0.31221303f, -0.21548574f, 
    0.30872521f, -0.41723624f, 0.38054517f, 0.39472884f, -0.85366666f, 0.30362570f, -0.24025418f, -0.86618018f, 
    0.20139860f, -0.27218208f, -0.02444255f, 0.17302687f, -0.09564076f, -0.63423616f, -0.06479657f, 0.09124727f, 
    0.35312068f, 0.08421086f, -0.31912133f, 0.21074589f, -0.25983754f, 0.03581173f, -0.06715623f, 0.09560946f, 
    -0.15725392f, -0.58043391f, -0.30654493f, 0.19488460f, -0.09215176f, 0.27292669f, -0.22783998f, -0.26432818f, 
    -0.32726356f, 0.30310056f, 0.00140913f, -0.52142942f, -0.35807058f, -0.40097234f, 0.35748631f, -0.02031307f, 
    0.23656453f, -0.14693025f, -0.25552872f, -0.45755774f, -0.19395953f, -0.59901649f, 0.38429508f, -0.51961827f, 
    0.21719314f, -0.12687381f, -0.30270883f, -0.16164289f, -0.07306588f, 0.35569194f, 0.20154929f, 0.06813943f, 
    0.07987303f, 0.21100180f, -0.43005845f, -0.30654621f, 0.11163012f, -0.18863891f, -0.45290646f, 0.13429411f, 
    0.08438470f, 0.24574018f, -0.30673397f, -0.31731170f, -0.76670116f, -0.52667469f, -0.31511760f, 0.17519864f, 
    -0.27567697f, -0.49395135f, -0.02935665f, -0.21439956f, 0.44598085f, -0.05852478f, 0.30051848f, 0.12158152f, 
    0.01812588f, 0.11754242f, -0.03392268f, 0.22956321f, 0.15189017f, -0.21763277f, -0.09671374f, -0.59372526f, 
    0.15375523f, -0.63529581f, -0.05104506f, 0.27594590f, -0.15742476f, -0.17716332f, -0.36503020f, -0.34907651f, 
    -0.20972355f, -0.13828780f, 0.17593481f, 0.10043671f, -0.00360147f, -0.14857964f, 0.23200256f, -0.45886186f, 
    0.15903515f, -0.38685736f, -0.55090123f, 0.20359956f, -0.49374932f, -0.33974078f, -0.10304557f, -0.15749842f, 
    -0.28546879f, -0.51250976f, -0.52343363f, 0.26723894f, 0.18681133f, -0.63537371f, 0.23926170f, 0.15099594f, 
    -0.18687525f, 0.22774376f, -0.15736613f, -0.78257823f, 0.17422247f, -0.71366960f, -0.52092278f, 0.24916559f, 
    -0.43092176f, -0.80195028f, -0.21558464f, 0.38271296f, 0.04765692f, 0.23225200f, -0.54982287f, 0.16880623f, 
    -0.24083842f, -0.52071148f, 0.14652653f, -0.41924700f, 0.35588002f, -0.32144043f, -0.35496092f, -0.13510798f, 
    -0.62819725f, 0.27219573f, 0.06147752f, 0.32202998f, -0.23775469f, 0.00429893f, 0.06971029f, -0.14003578f, 
    -0.23383209f, 0.14451073f, -0.28458360f, -0.03072340f, 0.08990747f, 0.17673583f, -0.72397101f, -0.31716758f, 
    -0.61700648f, -0.35139939f, 0.04274374f, -0.03801831f, 0.29681602f, 0.15339178f, 0.22042681f, -0.01271859f, 
    -0.07918537f, -0.30766404f, 0.43353450f, 0.32929686f, 0.27297971f, -0.21572989f, -0.28148407f, -0.09357820f, 
    -0.16973792f, -0.39141604f, 0.42689943f, 0.26191956f, -0.02667922f, -0.01454463f, -1.11123788f, -0.34809509f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.06247943f, -0.03585643f, 0.16821609f, -0.15736423f, -0.01981221f, 0.16483255f, -0.10310993f, -0.11578932f, 
    0.20750390f, 0.15222819f, 0.06802690f, 0.04896000f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
