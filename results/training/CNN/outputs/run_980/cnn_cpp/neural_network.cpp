#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.06556214f, 0.65916026f, -0.57893014f, -0.02893255f, 0.60245228f, -0.43694746f, -0.31450072f, 0.24228247f, 
    0.23747233f, 0.91642225f, -0.37363833f, 0.02260628f, 0.72131896f, -0.70135510f, -0.53839803f, 0.42175615f, 
    -0.19693966f, 0.15661913f, 0.68131882f, -1.13238871f, -0.23450635f, 0.48846292f, 0.77443701f, -0.15694214f, 
    -0.15325350f, -0.43154943f, 0.06278110f, 0.26208520f, 0.60671049f, -0.23041604f, -0.52536988f, 0.46205416f, 
    0.25769839f, -0.25395200f, -0.34788629f, -0.12000104f, 0.13259459f, 0.98142606f, -1.09523678f, -0.17746778f, 
    -0.33375651f, 0.43146238f, 0.00119595f, -0.49056560f, 0.49499264f, -0.11655639f, -0.59097981f, -0.46121755f, 
    -0.48912749f, 0.14759003f, 0.09548686f, 0.25159821f, 0.45720595f, 0.49844834f, 0.32167634f, 0.09061431f, 
    0.33075041f, 0.58234966f, -0.10931611f, 0.23671830f, -0.36019045f, 0.54008877f, -0.21250911f, -1.15885258f, 
    -0.58514023f, 0.73374093f, 0.41510388f, -0.19320907f, -0.84105045f, 0.14616877f, 0.15407354f, 0.27998990f, 
    0.68703002f, 0.87663269f, -0.78179032f, -0.19364765f, -0.32276145f, -0.35075977f, -0.39487758f, 0.19053765f, 
    -0.25677681f, 1.25797343f, -0.87162727f, -0.17558035f, 0.68771088f, 0.16526560f, -0.31248665f, -0.15112680f, 
    -0.02734119f, -0.40473908f, -0.72392899f, 0.99470973f, -0.24058467f, -0.41453221f, -0.55937946f, -0.91033572f, 
    0.38860384f, 0.26273799f, -0.02738365f, 0.22000831f, -0.81214303f, 0.22335719f, -0.63081318f, -0.44190657f, 
    0.11520335f, -0.44646960f, -0.41233873f, -0.15689963f, 0.66518235f, 0.62958813f, 0.50904286f, -0.60068798f, 
    -0.75258487f, 0.25283232f, -0.27324709f, -0.44368941f, -0.04396177f, -0.43048960f, -0.46616542f, -0.54545003f, 
    -0.57877678f, -0.72849721f, -0.61934263f, 0.27159494f, -0.25851741f, -0.16865939f, 0.73536938f, -0.76219517f, 
    -1.00448799f, 0.03911133f, 0.31184906f, 0.60763687f, 0.15792964f, 0.14429572f, 0.11554579f, -0.77574819f, 
    -0.57237917f, -0.58166045f, 0.22029741f, 0.09513328f, 0.14410874f, -0.37776026f, -0.54360580f, -0.67106611f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.13767670f, 0.05620272f, 0.30314329f, 0.20771815f, 0.13749471f, 0.29228708f, -0.15336910f, 0.06943011f, 
    0.12566449f, 0.12904547f, 0.13404176f, 0.31495267f, -0.01312189f, -0.09935259f, 0.03814483f, -0.16207615f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.04129609f, -0.06619241f, -0.02619848f, 0.02974146f, 0.04551324f, -0.08904170f, -0.04094992f, 0.07320060f, 
    0.03970600f, -0.07447167f, 0.03231020f, -0.02333258f, -0.15662029f, 0.15395688f, -0.10551506f, -0.08169466f, 
    0.02702919f, 0.03702874f, 0.15039518f, 0.08086642f, -0.32777750f, 0.28650269f, -0.03595136f, -0.15209249f, 
    0.22067174f, -0.14222878f, -0.10977449f, -0.26645938f, 0.06187755f, -0.08566374f, 0.07545596f, -0.10496087f, 
    0.01143721f, 0.00620540f, -0.03746662f, -0.01101317f, -0.05569101f, 0.02175620f, 0.28184393f, 0.28627145f, 
    0.35860458f, 0.02741160f, -0.10133662f, 0.01917836f, 0.11114216f, -0.03347977f, -0.01468829f, 0.23384298f, 
    -0.13708678f, -0.03829859f, 0.15686689f, 0.03483547f, -0.02014172f, -0.12788464f, 0.09368742f, -0.01248301f, 
    -0.10912600f, 0.03674013f, 0.02543119f, 0.19205441f, 0.11739202f, -0.15090072f, 0.28094572f, 0.20591819f, 
    0.04817770f, 0.01009005f, 0.04541996f, -0.01524266f, -0.10453485f, -0.07576149f, -0.08205597f, 0.03100548f, 
    0.06000237f, -0.02881332f, 0.06046038f, -0.04220102f, -0.16594905f, -0.17152111f, 0.10778327f, -0.11467908f, 
    0.19034886f, -0.04214190f, 0.10925741f, 0.38936755f, 0.16405895f, 0.23199759f, 0.23527403f, 0.16615647f, 
    -0.06718083f, 0.15569919f, -0.00575861f, -0.05670677f, 0.07720041f, -0.00304776f, -0.00170574f, 0.32059357f, 
    0.01141131f, -0.04580612f, -0.03345758f, 0.09833305f, -0.03665193f, -0.06194607f, -0.08771374f, -0.04125053f, 
    -0.03625286f, -0.04207696f, 0.10655189f, 0.11467530f, 0.02758622f, -0.03877261f, -0.15330039f, 0.06014876f, 
    -0.05073722f, 0.00108920f, -0.06278926f, -0.00587633f, 0.15957646f, 0.05739199f, 0.08863783f, 0.13934509f, 
    -0.05291370f, -0.05943149f, 0.07342481f, 0.14403424f, 0.05652254f, -0.08939669f, -0.06508704f, -0.11689330f, 
    0.06852768f, -0.04675464f, 0.05191734f, -0.00556068f, 0.15565762f, 0.00085768f, 0.15643132f, -0.18552242f, 
    -0.03877150f, 0.06965106f, 0.16175105f, -0.00073659f, 0.12789804f, -0.09627264f, 0.40717107f, -0.28390992f, 
    0.04850708f, 0.05597331f, -0.03512768f, 0.03904072f, 0.35447636f, -0.00527766f, 0.26713952f, 0.09314018f, 
    0.00846759f, -0.02433633f, -0.02720185f, -0.05541553f, 0.06067146f, -0.05254298f, 0.14029461f, 0.03596217f, 
    0.16677433f, 0.09126662f, 0.04626096f, -0.19334666f, -0.22249939f, 0.08915922f, 0.09154459f, -0.15248680f, 
    -0.17650487f, -0.14931865f, -0.00277262f, -0.08117511f, -0.02323231f, 0.02196725f, 0.01805275f, 0.01617855f, 
    -0.00357874f, -0.07823639f, -0.07977067f, -0.17202528f, 0.37939188f, 0.22407921f, -0.06193602f, 0.14362891f, 
    0.09079578f, -0.01275854f, -0.04540152f, 0.01917247f, -0.13669416f, -0.07921382f, 0.10719071f, -0.01017120f, 
    -0.03975889f, 0.10485996f, 0.20751716f, 0.04815124f, -0.06688895f, 0.03888746f, 0.05143130f, 0.09852003f, 
    -0.09615271f, -0.17784071f, 0.21643054f, -0.28482920f, -0.15248454f, 0.02504877f, -0.01724217f, 0.04034366f, 
    -0.01383366f, -0.31383893f, -0.07349177f, 0.08703215f, 0.00050599f, 0.08127233f, 0.00239441f, 0.02726053f, 
    0.06046993f, 0.24347979f, 0.10386269f, 0.13923953f, 0.14985253f, 0.14909524f, 0.02655922f, 0.10454509f, 
    -0.06976132f, 0.10933269f, 0.09339290f, -0.04069636f, 0.00782610f, 0.11427840f, 0.11707730f, 0.00713661f, 
    -0.03322423f, -0.00492644f, -0.14015754f, 0.04656795f, -0.09119177f, -0.16436863f, -0.08284290f, -0.07532412f, 
    -0.27767158f, 0.03114559f, 0.24317931f, -0.02414411f, -0.08842789f, -0.00373872f, 0.05314766f, -0.05234249f, 
    -0.15296598f, 0.03919296f, -0.11596194f, -0.01299389f, 0.00571343f, -0.07083756f, -0.03144794f, -0.00528391f, 
    -0.14508693f, -0.01700569f, 0.06538603f, -0.05714369f, 0.07404566f, 0.13539325f, -0.17124988f, -0.18059944f, 
    -0.14529131f, 0.18730827f, 0.15098086f, 0.03001416f, 0.04379817f, -0.17909072f, -0.02886560f, 0.01688308f, 
    -0.05153031f, -0.10313519f, 0.00797087f, -0.02703848f, 0.06293982f, 0.08934440f, -0.16251341f, 0.13042971f, 
    0.04177565f, -0.02008707f, -0.29859376f, 0.06336705f, 0.08389755f, 0.02924194f, 0.04205506f, 0.08199260f, 
    0.05387506f, 0.01601825f, 0.10155952f, 0.15578708f, 0.03231596f, -0.11291968f, -0.05238464f, -0.06112263f, 
    0.00654022f, 0.08852498f, 0.06626862f, 0.03671548f, 0.07736015f, 0.18654417f, 0.04924051f, -0.18770389f, 
    -0.06736965f, 0.04572462f, 0.01272016f, 0.04418168f, 0.08351990f, 0.01340273f, 0.04588722f, -0.06381493f, 
    -0.07538388f, -0.15872830f, 0.01290386f, 0.01543180f, -0.13758653f, -0.02777470f, -0.22689527f, -0.19606167f, 
    0.24160215f, 0.10761268f, 0.18201922f, -0.07610846f, 0.32425937f, 0.01463950f, 0.04406860f, -0.03908228f, 
    0.07763689f, -0.03216910f, -0.01366110f, 0.24739555f, 0.02965934f, 0.17545034f, 0.22285476f, 0.05946783f, 
    -0.04997522f, -0.10856278f, -0.12997113f, -0.10558044f, 0.14745419f, 0.05066482f, 0.38278523f, -0.11079072f, 
    -0.09495343f, 0.01955133f, 0.04446495f, 0.00104920f, 0.02539677f, -0.00109919f, -0.08969066f, -0.05065879f, 
    0.03847885f, 0.01561734f, 0.01017550f, 0.02571339f, -0.20517653f, 0.10783067f, -0.05314515f, -0.17235960f, 
    -0.05278845f, -0.01714884f, 0.29085451f, -0.06618812f, 0.02619292f, -0.09853551f, 0.09439164f, -0.03526829f, 
    0.12325367f, 0.03108196f, 0.05939024f, 0.13353479f, 0.20413700f, 0.15750983f, 0.17205885f, 0.09638456f, 
    0.07764170f, 0.02593113f, 0.07711839f, 0.18635310f, 0.03565087f, 0.01231497f, -0.15351506f, -0.12866500f, 
    0.13888410f, 0.04781491f, -0.06044803f, -0.00182320f, -0.12386639f, 0.02460985f, 0.06188729f, -0.01569584f, 
    0.00076186f, 0.05918254f, 0.00075797f, 0.14092530f, 0.17792442f, 0.16186477f, 0.07700925f, 0.17765942f, 
    0.25719330f, 0.23119792f, 0.13414428f, -0.30489320f, -0.16332787f, 0.21961533f, -0.04261392f, -0.00485642f, 
    0.19870150f, -0.01695840f, 0.06368682f, 0.10599698f, -0.07560583f, -0.04163167f, 0.08515172f, 0.05699933f, 
    0.18007082f, 0.04788743f, 0.13002558f, 0.07216388f, 0.08599275f, 0.05947933f, 0.28059453f, 0.14683792f, 
    0.05074865f, -0.01658067f, -0.15726319f, -0.02309800f, 0.07155497f, -0.07937226f, -0.01198477f, 0.03070663f, 
    -0.03184552f, -0.15695480f, 0.00524180f, -0.12669927f, -0.16584945f, -0.05385477f, -0.04494617f, -0.18036754f, 
    -0.16942173f, 0.09611877f, -0.16298749f, -0.29474837f, -0.09770515f, -0.02649125f, -0.01452456f, 0.03200379f, 
    -0.01763691f, -0.04213103f, 0.10580503f, -0.01745650f, -0.02775981f, 0.12611762f, -0.09889658f, 0.20489529f, 
    -0.17339742f, -0.02625186f, -0.21329503f, 0.02504538f, 0.13330629f, -0.65130335f, 0.14215539f, 0.65108860f, 
    -0.18060249f, -0.03440212f, 0.08745445f, -0.19529295f, 0.02353938f, 0.02379005f, -0.03652925f, 0.00144663f, 
    -0.06557752f, -0.23427746f, -0.01807696f, 0.01236357f, -0.07795822f, -0.03332927f, 0.10991487f, -0.06681195f, 
    0.25739384f, -0.18020456f, 0.20985506f, -0.02751160f, 0.11240525f, 0.08401591f, 0.05063097f, 0.00241641f, 
    0.03153802f, 0.06805011f, -0.11550529f, 0.08147863f, 0.04613600f, 0.01436978f, 0.06439839f, 0.11859041f, 
    0.11925399f, 0.09907754f, 0.10963736f, 0.04578532f, -0.18763088f, -0.22628547f, 0.22076105f, -0.05171135f, 
    -0.15610763f, -0.05608577f, 0.06332331f, 0.02281759f, 0.03192182f, -0.04394434f, -0.04450953f, -0.02717209f, 
    0.08828808f, 0.03470866f, 0.12921470f, 0.20934720f, 0.21288839f, 0.17104146f, 0.10240044f, 0.02710401f, 
    0.01117155f, -0.19752952f, -0.12264626f, 0.14556237f, -0.05444031f, 0.09758370f, 0.02352252f, -0.11888362f, 
    0.07890105f, 0.13733670f, 0.17696768f, -0.06540316f, -0.09781226f, -0.16141300f, -0.09368644f, 0.04652816f, 
    -0.04687881f, -0.18085352f, 0.20035237f, 0.14280331f, 0.15849783f, -0.14854078f, -0.12576373f, 0.25276431f, 
    -0.08505099f, 0.22644027f, -0.00464217f, 0.13318883f, 0.12016658f, 0.09035879f, -0.03244859f, -0.02516950f, 
    0.02941106f, 0.02010864f, 0.12175668f, 0.10379566f, 0.08539565f, 0.17149331f, 0.32397613f, 0.24220930f, 
    0.17474419f, -0.06981085f, -0.06826332f, 0.12662338f, -0.16853841f, 0.09364454f, 0.02393217f, -0.04912280f, 
    -0.14133751f, 0.06650314f, -0.01060056f, -0.03108777f, 0.00050255f, 0.00088287f, -0.02805148f, -0.02766238f, 
    0.04804020f, -0.02234487f, 0.02298144f, 0.10415238f, -0.27833137f, -0.29373488f, 0.01171669f, 0.10507090f, 
    -0.37236220f, -0.04384543f, -0.16409916f, 0.12145732f, 0.11685341f, 0.05083708f, -0.01572790f, 0.01496163f, 
    -0.06108415f, -0.13012287f, -0.11299985f, -0.04732750f, 0.04594041f, 0.03382135f, 0.16146947f, -0.00029499f, 
    -0.11058440f, 0.13442752f, 0.46194765f, -0.13834810f, 0.00080693f, -0.16033438f, -0.14132495f, 0.04587057f, 
    0.01239234f, -0.08391768f, -0.06067036f, 0.03803125f, -0.00051337f, -0.05572199f, 0.02252002f, -0.20009691f, 
    -0.03505999f, -0.10289600f, -0.11682115f, 0.06349712f, -0.21415535f, -0.28541443f, 0.20616987f, 0.33136019f, 
    -0.18079454f, -0.08989431f, -0.14248623f, -0.15403232f, 0.09444658f, -0.02918895f, -0.05830987f, -0.12156362f, 
    0.03695888f, 0.19301403f, -0.01582403f, 0.04367685f, 0.13282612f, 0.11762722f, 0.17262001f, 0.23267220f, 
    0.03626369f, -0.11160953f, 0.11431536f, 0.06053997f, -0.00777366f, 0.06370464f, 0.01032016f, -0.02928018f, 
    0.02559387f, -0.03357776f, 0.00741148f, 0.16624537f, 0.02247440f, 0.05072395f, 0.07355728f, 0.03091342f, 
    0.01451707f, -0.05597954f, -0.16260123f, -0.11083133f, 0.35581648f, 0.05268333f, -0.20288362f, 0.22586256f, 
    -0.24479502f, 0.19619063f, -0.12317881f, 0.14388822f, 0.26928595f, -0.04222590f, -0.10431615f, 0.11983745f, 
    -0.03802352f, 0.01476675f, 0.05411429f, -0.06158454f, -0.00191261f, -0.02463914f, -0.07731972f, -0.07248847f, 
    -0.02119841f, -0.03076908f, 0.09169353f, 0.17713755f, -0.08633401f, -0.01324611f, -0.04189822f, -0.14491469f, 
    0.13646141f, 0.01309909f, 0.04995585f, 0.04807847f, 0.19201210f, 0.14804462f, 0.00263448f, 0.06505149f, 
    0.09398893f, -0.04762956f, -0.00573765f, -0.01992389f, -0.05342850f, -0.00498887f, -0.05787858f, -0.19928633f, 
    0.11310290f, 0.01174846f, -0.02432450f, -0.00817633f, -0.04715957f, -0.07315087f, -0.00688436f, 0.06812286f, 
    -0.04045316f, -0.04276825f, -0.09428335f, 0.18364531f, 0.15256351f, 0.10554116f, 0.00711188f, 0.18665561f, 
    0.03402180f, -0.09235351f, 0.29312998f, -0.10865642f, 0.04682745f, 0.02504381f, -0.12793936f, 0.16445298f, 
    0.37605339f, -0.05401921f, -0.08381534f, 0.09086709f, -0.10827723f, 0.03353820f, -0.07524510f, -0.14849022f, 
    0.12273322f, 0.11155223f, 0.10246845f, -0.00896556f, -0.13544752f, 0.33223534f, 0.18849473f, 0.01415954f, 
    0.08055913f, -0.09009854f, -0.00090821f, -0.12855525f, -0.16742985f, -0.12400904f, 0.03095315f, 0.03217807f, 
    -0.07918975f, 0.07651910f, 0.07041661f, -0.04967920f, -0.06174126f, -0.00847526f, -0.04014016f, -0.04603622f, 
    -0.03496409f, -0.17033982f, -0.09018929f, -0.00613126f, -0.09297751f, -0.01431856f, -0.03427535f, -0.01461196f, 
    -0.06854677f, 0.03537028f, -0.11245505f, -0.01504751f, -0.15305306f, -0.12625661f, -0.11838666f, 0.06775180f, 
    -0.02724641f, 0.02411989f, -0.06846476f, 0.00348605f, -0.30536091f, 0.05584062f, -0.05440233f, 0.27029154f, 
    0.03862808f, 0.05276509f, -0.05980627f, 0.15459748f, -0.21283875f, 0.16109444f, -0.11860316f, 0.00391896f, 
    0.11122975f, 0.06864031f, -0.00926800f, 0.00613749f, -0.04287187f, -0.03998988f, -0.08590050f, -0.01070583f, 
    0.00399933f, -0.12990600f, -0.33249941f, 0.01489352f, -0.24745236f, 0.13592553f, -0.02687861f, 0.12204005f, 
    0.10567281f, 0.05736011f, -0.00617612f, -0.03812402f, -0.05682725f, 0.03061660f, 0.02556844f, -0.00307680f, 
    0.04702675f, 0.16585928f, 0.01682347f, 0.16127937f, 0.18627968f, -0.08537249f, -0.20413148f, 0.18247803f, 
    -0.34762800f, 0.07999048f, 0.04246467f, -0.08175579f, 0.01890345f, -0.07682066f, -0.06984801f, 0.13251702f, 
    0.02729183f, 0.10263389f, 0.06673910f, 0.01361102f, 0.08767153f, 0.06765053f, -0.04977606f, 0.17256515f, 
    -0.31218272f, -0.10106120f, -0.26710233f, 0.21963471f, -0.07459274f, -0.00614184f, -0.03016573f, 0.10293263f, 
    0.10211476f, 0.02613641f, 0.13575375f, 0.12249294f, 0.07617116f, 0.10218193f, 0.03337878f, -0.03697426f, 
    -0.00381212f, 0.08701633f, 0.00739903f, 0.00759671f, -0.23373728f, -0.01167000f, -0.05506782f, -0.11827028f, 
    0.05964257f, -0.08063773f, 0.13390854f, 0.16252375f, -0.01594437f, -0.16373138f, -0.01920996f, -0.04638179f, 
    0.02217287f, 0.10113392f, 0.06420843f, -0.04133747f, 0.02442885f, -0.00922164f, 0.22540323f, 0.00398888f, 
    0.35266659f, 0.02673734f, -0.24499837f, -0.25072610f, 0.13444944f, -0.10569467f, -0.04141456f, 0.06062166f, 
    0.05578327f, -0.05264742f, -0.04954477f, -0.08784394f, -0.10094652f, -0.01685324f, -0.00888626f, 0.14717360f, 
    0.14250235f, -0.20168893f, 0.17238422f, 0.16910203f, -0.10315088f, 0.22074786f, 0.04163568f, -0.04041195f, 
    -0.05695350f, -0.08670447f, -0.05317768f, -0.05212289f, -0.05434582f, -0.11625250f, 0.00555824f, 0.02758839f, 
    -0.05182916f, -0.02756970f, -0.03792484f, 0.06806280f, -0.04558727f, 0.03986338f, 0.17519620f, -0.06991125f, 
    0.06805234f, 0.26125792f, 0.07690360f, 0.06613346f, 0.00646652f, -0.10179617f, 0.04145262f, -0.11627055f, 
    0.02560709f, -0.04555801f, 0.09616846f, -0.14287923f, 0.01256704f, 0.03759769f, 0.12382293f, 0.07916958f, 
    -0.01459567f, -0.03156567f, -0.00592252f, -0.04256966f, -0.07242508f, -0.13729343f, 0.05038004f, 0.02083483f, 
    -0.05047249f, -0.10866884f, 0.07427695f, 0.18528765f, -0.13246858f, 0.01305220f, -0.03273712f, 0.02913934f, 
    0.07080910f, 0.00779855f, -0.09526687f, 0.15802541f, 0.05203685f, 0.07602874f, 0.21442720f, 0.07337327f, 
    -0.27686831f, 0.08564258f, -0.01720507f, 0.02323011f, 0.06670985f, 0.00499778f, -0.00429231f, -0.09485652f, 
    -0.01586885f, 0.01853656f, -0.07833403f, 0.04510238f, -0.10970334f, 0.03336252f, -0.11135983f, -0.00073780f, 
    -0.16449609f, 0.08892999f, -0.05667045f, -0.07829680f, 0.27534690f, -0.36155090f, -0.05135448f, 0.37908646f, 
    -0.06380913f, -0.00883293f, 0.22906962f, 0.22411710f, -0.15017238f, 0.11073177f, 0.02711360f, -0.08795329f, 
    -0.06399112f, 0.00497770f, 0.08901379f, 0.10296015f, 0.11016323f, 0.30737028f, -0.06594587f, -0.03241953f, 
    -0.47778729f, 0.63887173f, -0.45379698f, -0.11328404f, 0.07603444f, 0.19555569f, 0.09862836f, -0.05864633f, 
    -0.06725461f, 0.02377939f, 0.00860535f, 0.17533922f, -0.04164300f, 0.13626033f, 0.06477769f, 0.01414703f, 
    -0.06980247f, 0.04936241f, -0.07131449f, 0.09114799f, 0.27161551f, -0.10281765f, -0.21338131f, -0.07623141f, 
    0.35438934f, -0.07839459f, -0.01495395f, 0.01466242f, 0.05043711f, -0.11962056f, -0.03703372f, 0.00401910f, 
    0.06971585f, 0.08904780f, -0.06268992f, -0.04551472f, -0.00141860f, -0.07623316f, 0.07607657f, 0.08210234f, 
    0.60354459f, 0.38913167f, -0.14065786f, -0.03431188f, 0.36776486f, -0.06984551f, 0.00373251f, -0.11589640f, 
    0.16616623f, 0.05519265f, 0.13518499f, 0.13568793f, -0.03735122f, 0.03313443f, 0.05958568f, 0.11238096f, 
    0.11451680f, 0.18133783f, 0.07402851f, 0.00955191f, -0.23828927f, 0.09406123f, 0.08128269f, -0.10433370f, 
    0.03650426f, -0.02291095f, -0.03091239f, -0.16279720f, 0.05380269f, 0.06943440f, 0.00052156f, 0.03815057f, 
    -0.13068837f, -0.08668786f, -0.11899697f, -0.04309534f, -0.05935359f, -0.05783682f, 0.01934359f, 0.08704243f, 
    -0.26801348f, -0.21703075f, -0.25805604f, 0.03728462f, -0.04332940f, -0.02577939f, 0.06120027f, -0.11202157f, 
    -0.14764883f, -0.01093430f, -0.03286175f, -0.13335089f, 0.15803196f, 0.09262593f, -0.12733011f, 0.05440500f, 
    -0.02603362f, 0.00401517f, -0.18831439f, 0.03898890f, -0.72427219f, -0.19147514f, 0.07222679f, -0.03985943f, 
    -0.09367773f, 0.00503227f, 0.01281057f, -0.04871690f, -0.15230894f, -0.08336548f, -0.02925671f, -0.04250421f, 
    -0.14448401f, 0.02718612f, 0.06291971f, 0.03105026f, -0.01246353f, -0.05516965f, 0.15646605f, 0.06439287f, 
    0.34635305f, -0.23846686f, 0.18762173f, 0.26870123f, 0.42712727f, 0.06121611f, 0.17716092f, 0.03227100f, 
    0.16223325f, -0.13033739f, 0.04609338f, 0.07022891f, -0.08434112f, -0.03114959f, -0.07544795f, -0.06895180f, 
    0.03227843f, 0.13394181f, 0.05268757f, -0.02123640f, -0.49462727f, 0.08910555f, -0.00419356f, 0.04334610f, 
    0.01621555f, -0.03089578f, 0.02437700f, 0.05239573f, -0.01215763f, -0.10838564f, -0.02121761f, -0.06648888f, 
    0.04147651f, -0.08719439f, 0.00710821f, 0.14216310f, 0.04811865f, 0.12196591f, -0.02918217f, -0.01051582f, 
    -0.25900975f, 0.15513317f, 0.01199797f, -0.15529868f, 0.29010513f, -0.14383778f, 0.08023306f, 0.12088476f, 
    0.02187238f, 0.00017640f, 0.17862716f, -0.09978765f, -0.00568040f, -0.06530175f, 0.06843024f, 0.09242858f, 
    -0.01493248f, 0.13818152f, 0.08297538f, 0.10486040f, 0.14242317f, -0.08250300f, -0.07607778f, 0.05150386f, 
    0.01180545f, -0.06012143f, -0.14380980f, 0.19960810f, 0.16931006f, 0.05381118f, -0.01980085f, 0.04409294f, 
    0.01294696f, 0.13016559f, 0.03416602f, 0.13216279f, 0.06809463f, 0.13133512f, -0.01332366f, 0.03350927f, 
    0.10295799f, -0.46872255f, 0.00656536f, -0.13536997f, 0.14828642f, 0.01448906f, -0.04931507f, 0.10539804f, 
    0.03953623f, -0.08150385f, -0.04221179f, -0.09412944f, 0.03393874f, -0.06529798f, -0.03066165f, -0.02675896f, 
    -0.09721787f, 0.02260507f, -0.00543910f, 0.09527817f, 0.03031273f, -0.17156976f, -0.05467401f, -0.05982554f, 
    0.05582292f, -0.02661281f, -0.00668231f, -0.03194302f, 0.04962847f, -0.02488550f, 0.00356615f, 0.05877886f, 
    0.01392827f, 0.06748099f, 0.06642078f, 0.01831420f, 0.00891825f, 0.05814837f, 0.13720338f, 0.06295529f, 
    -0.29208088f, 0.12698394f, 0.01380805f, -0.12886775f, -0.00085011f, 0.03233401f, -0.03995392f, -0.18425742f, 
    0.09904154f, 0.00221899f, 0.06925943f, 0.09432071f, 0.11706977f, -0.08292458f, -0.01747290f, -0.01638409f, 
    -0.08270264f, 0.04493989f, -0.03690407f, 0.08367922f, 0.10900605f, 0.01074099f, -0.35548437f, -0.06496705f, 
    0.11361198f, 0.10719258f, 0.07312189f, 0.03586507f, 0.12159345f, 0.09679804f, -0.02728639f, -0.06085357f, 
    0.07524451f, 0.22197209f, 0.12507035f, -0.04957068f, 0.08606969f, 0.24294876f, 0.05802651f, 0.08572375f, 
    -0.03537598f, -0.00649057f, 0.07381874f, 0.16503118f, 0.02297054f, -0.09485003f, 0.16618180f, 0.10885872f, 
    0.12335553f, -0.03572114f, 0.09512075f, 0.09883598f, 0.00163559f, 0.11947886f, -0.07098442f, -0.04271559f, 
    0.09481305f, 0.07276226f, -0.00992079f, -0.03593535f, 0.06937898f, 0.18949060f, 0.07215042f, 0.16101256f, 
    -0.04240931f, -0.02476836f, -0.16293463f, -0.09071879f, 0.25897476f, -0.10245165f, 0.02671789f, -0.12001064f, 
    0.04800725f, 0.07054819f, -0.01192771f, 0.01723185f, -0.01288793f, -0.02608669f, 0.19215094f, -0.02281306f, 
    0.06172440f, -0.22561145f, -0.01294597f, 0.24832770f, -0.17413808f, 0.02613643f, 0.11609458f, 0.20937058f, 
    0.07399140f, 0.01749187f, -0.13548842f, -0.22287093f, 0.07372123f, -0.00854981f, 0.04650664f, -0.06177456f, 
    -0.06742392f, 0.00482723f, -0.09459721f, 0.01821975f, 0.19501130f, 0.19957556f, 0.36358523f, 0.28073037f, 
    0.00629857f, -0.06947833f, 0.02702439f, -0.07429606f, -0.07498021f, -0.13252878f, -0.00398670f, -0.02236774f, 
    -0.01339159f, -0.05217782f, 0.00583755f, 0.07844476f, -0.06684956f, 0.00361345f, -0.07159179f, -0.09259535f, 
    -0.00511168f, -0.53410012f, 0.44660512f, 0.01652522f, 0.15906367f, 0.13442458f, 0.23833081f, -0.05055533f, 
    0.30013010f, 0.10618532f, -0.00504631f, 0.04064257f, 0.04737089f, 0.08390824f, -0.10372905f, -0.01803987f, 
    -0.03167692f, 0.02695596f, 0.09261491f, 0.08084263f, -0.11792162f, -0.32319063f, -0.30806518f, 0.07978701f, 
    -0.05441811f, -0.03592352f, 0.11904216f, 0.14135508f, 0.02628994f, 0.03257809f, 0.00048905f, -0.04056530f, 
    0.00581505f, -0.07725307f, -0.01803459f, 0.00164060f, 0.06954592f, 0.01097383f, 0.05547598f, -0.02067664f, 
    0.13078141f, 0.07847937f, 0.19907190f, 0.15129748f, -0.13210176f, -0.02681374f, 0.03211525f, 0.11541320f, 
    0.12548268f, -0.04488171f, -0.13610633f, 0.19664228f, -0.02161364f, 0.09497341f, 0.10884232f, -0.13160333f, 
    0.12253932f, 0.05051428f, 0.03955664f, -0.02636061f, -0.03926385f, 0.18160053f, -0.09447020f, 0.05597116f, 
    0.11855527f, 0.13585831f, -0.13624048f, 0.29921511f, -0.06855410f, 0.16144936f, -0.09106681f, -0.04902713f, 
    0.07892551f, -0.00878572f, 0.01727975f, -0.08343275f, 0.01245026f, 0.07747013f, -0.12094905f, 0.02385507f, 
    -0.13808024f, 0.06932876f, 0.10623661f, 0.23589574f, -0.01994588f, -0.03214644f, -0.08036536f, -0.11719462f, 
    -0.03951382f, -0.08480939f, -0.08259466f, -0.02798764f, 0.08733826f, 0.03539915f, -0.02285826f, -0.05342332f, 
    -0.03926359f, -0.05457490f, 0.01834908f, -0.06644674f, 0.34826553f, 0.13311508f, -0.14681575f, 0.42954665f, 
    0.07042085f, -0.01412324f, -0.02570865f, 0.01757132f, 0.03519522f, 0.00793220f, 0.02922983f, 0.06343973f, 
    -0.00269498f, 0.07617651f, 0.07244936f, -0.13214301f, -0.10551880f, -0.17011428f, -0.01238770f, -0.14056000f, 
    0.03194893f, -0.09000596f, 0.18424681f, 0.34408104f, -0.01015584f, -0.00476694f, -0.14622976f, 0.01695110f, 
    0.01724959f, 0.03518194f, -0.05332794f, 0.06601469f, 0.09747254f, 0.08062727f, 0.04979397f, -0.05223570f, 
    0.04775231f, 0.03311127f, -0.11723968f, 0.08827948f, 0.01476993f, 0.08482534f, 0.16766195f, 0.01050472f, 
    0.15838128f, 0.10253800f, 0.02491053f, -0.15260462f, 0.07474872f, 0.01261178f, 0.01122318f, 0.05848912f, 
    0.04835947f, 0.03405961f, -0.02032007f, 0.30138290f, 0.02534693f, 0.10920236f, -0.06645907f, -0.18347080f, 
    0.52921188f, 0.29849225f, 0.44569051f, 0.17891562f, -0.17757256f, -0.08924152f, -0.10696755f, -0.18131241f, 
    -0.01603248f, -0.08405407f, 0.00256396f, 0.00783527f, 0.02881603f, -0.06648967f, 0.03050777f, 0.05780423f, 
    0.00200909f, -0.01205837f, -0.08150653f, 0.02428154f, 0.08241755f, 0.13174056f, -0.11272141f, 0.15273796f, 
    0.22813907f, -0.14187616f, -0.10236684f, -0.05562678f, -0.03422657f, 0.01380337f, -0.03757880f, -0.00830668f, 
    0.00085765f, 0.04290579f, 0.12356447f, 0.14848179f, -0.03412805f, 0.06575429f, -0.00776004f, -0.04448283f, 
    -0.05198745f, -0.41473940f, -0.31447363f, -0.00952288f, -0.06147370f, -0.06744083f, 0.16511852f, 0.11291254f, 
    0.12407848f, 0.19911930f, 0.00519379f, -0.02223161f, -0.05016373f, -0.02589971f, -0.04189484f, -0.13309143f, 
    0.00585716f, 0.09105226f, 0.04159784f, -0.03426090f, -0.14955409f, -0.10717534f, -0.07377501f, -0.25745395f, 
    -0.02251253f, 0.00675899f, -0.10658793f, -0.02251438f, 0.00595032f, 0.05351640f, 0.03584440f, 0.00753635f, 
    -0.01702082f, 0.00525221f, 0.01855758f, 0.16312626f, -0.06169926f, -0.01664987f, 0.11667811f, 0.10345428f, 
    -0.13465825f, -0.20173506f, -0.24762823f, -0.05047011f, -0.15753560f, 0.10203948f, -0.01338614f, -0.13367029f, 
    -0.00558147f, -0.01460824f, 0.08971085f, -0.02584137f, 0.01725340f, -0.01942864f, 0.12166134f, 0.00718228f, 
    0.03036784f, -0.23203328f, -0.17669268f, -0.14970161f, 0.22910975f, -0.31481665f, -0.08006231f, -0.35235551f, 
    -0.22125795f, -0.22409834f, 0.03031459f, 0.17149645f, -0.04052025f, -0.12872313f, -0.04631946f, -0.09716625f, 
    0.04572878f, 0.15662453f, 0.09194311f, -0.03856581f, -0.11425162f, 0.18736926f, -0.07556576f, -0.20166783f, 
    0.08997440f, -0.27249739f, -0.09440398f, 0.08434331f, -0.06146614f, -0.05774730f, 0.06046598f, 0.10037090f, 
    -0.03513376f, -0.15003592f, -0.01707559f, -0.13994260f, 0.11087237f, 0.10133962f, 0.04222732f, -0.03854381f, 
    0.03730573f, 0.02683605f, -0.12558952f, -0.05704346f, -0.50016040f, -0.22637261f, -0.36596796f, -0.03448041f, 
    -0.31037861f, 0.00606909f, -0.04200894f, -0.03081131f, -0.00135201f, 0.05176852f, 0.03702891f, 0.07031567f, 
    -0.04716116f, 0.06186391f, -0.05857242f, 0.04875506f, -0.07184611f, 0.12430220f, 0.09215099f, 0.13621131f, 
    -0.68427318f, 0.10701052f, 0.10071579f, -0.17428671f, -0.12788254f, 0.22427616f, -0.04955601f, -0.24348594f, 
    -0.15231614f, -0.04781605f, 0.04779928f, 0.08877520f, 0.04450291f, 0.04269594f, -0.01624909f, -0.16457261f, 
    -0.15713055f, -0.06251080f, -0.10878339f, -0.14936486f, 0.04315110f, 0.20859213f, 0.05427120f, 0.09263495f, 
    0.03993777f, 0.04416007f, -0.02090376f, 0.01397237f, 0.00612248f, 0.03268121f, 0.00695935f, 0.03028646f, 
    0.12007291f, 0.04976339f, -0.00843277f, 0.07869070f, -0.08833835f, -0.01919965f, -0.00360253f, -0.20650080f, 
    -0.19381464f, -0.30643409f, -0.29859272f, -0.29906252f, -0.05906203f, 0.10447932f, 0.08854910f, 0.07414798f, 
    0.10990992f, 0.00126785f, -0.12870920f, 0.06699203f, -0.14649478f, 0.01921363f, 0.01331621f, -0.01745197f, 
    0.01471044f, -0.04716903f, -0.12726593f, -0.05720755f, -0.01459956f, 0.51850253f, -0.01418184f, 0.32736820f, 
    0.31745148f, 0.01754319f, 0.22244230f, 0.09772701f, 0.10661791f, -0.04958118f, 0.07249151f, 0.06879354f, 
    0.02713294f, -0.03273718f, -0.09500011f, -0.03671348f, -0.04257311f, 0.03822529f, -0.13173954f, -0.07197502f, 
    -0.27173981f, -0.17615806f, -0.43569541f, -0.22649106f, -0.21045877f, 0.05495909f, -0.01069759f, -0.04801650f, 
    -0.09954659f, 0.15641801f, 0.01429475f, 0.01920322f, -0.02371342f, 0.01576479f, 0.09061614f, -0.04312365f, 
    0.07003545f, 0.09617971f, 0.13799691f, 0.06921142f, 0.40116647f, -0.45602477f, -0.18709658f, -0.16859421f, 
    -0.02255601f, -0.02737926f, 0.05553654f, 0.08721474f, -0.02514301f, 0.06793767f, -0.07289042f, 0.10117793f, 
    0.02816549f, 0.10668952f, 0.02664805f, 0.01118580f, -0.01346573f, 0.20330647f, -0.07060073f, 0.20809443f, 
    0.23996563f, 0.30991334f, 0.00002648f, 0.51632422f, 0.01941315f, 0.02244103f, 0.13132346f, -0.08232389f, 
    0.07051982f, 0.17901854f, -0.02284415f, -0.00313614f, -0.02582050f, 0.02590945f, 0.05607651f, -0.07999184f, 
    -0.01301632f, -0.14721861f, 0.06573238f, -0.07912347f, -0.15198708f, 0.20221809f, 0.03218872f, -0.06068192f, 
    0.21463829f, -0.00287352f, -0.02446151f, 0.01242075f, -0.01584714f, 0.05074972f, -0.03504650f, -0.00361329f, 
    -0.00085046f, -0.04826664f, 0.03630519f, -0.02426500f, -0.03981473f, 0.10109466f, 0.00745552f, 0.21753395f, 
    -0.49818298f, -0.45108384f, -0.58507043f, -0.19813430f, -0.12357667f, 0.09297368f, -0.00399431f, 0.02729075f, 
    -0.04061850f, 0.00985790f, 0.11770000f, 0.02352940f, 0.00251544f, 0.07130212f, 0.03295012f, -0.12214847f, 
    0.27227855f, 0.01751720f, 0.18312156f, 0.01467981f, 0.18462381f, 0.26002517f, 0.38024700f, 0.21334174f, 
    0.36817318f, -0.03774349f, -0.07584386f, 0.03799026f, 0.14985517f, 0.22882891f, 0.06299942f, -0.02200912f, 
    0.02746424f, -0.04613254f, -0.02516374f, 0.01089756f, 0.00706389f, 0.05531932f, 0.04910609f, 0.12173234f, 
    0.10018703f, 0.05650071f, 0.03079221f, 0.06567270f, -0.17634152f, 0.03142715f, 0.04756595f, -0.01775109f, 
    -0.09680401f, -0.00593615f, -0.04157561f, 0.16986926f, 0.00982548f, -0.00684034f, 0.07086544f, 0.03883237f, 
    -0.11224017f, -0.13070326f, -0.13385525f, -0.02122495f, 0.36900231f, 0.25649175f, 0.36931738f, 0.32122770f, 
    0.15230036f, 0.17085870f, 0.06477027f, 0.16161659f, 0.19786075f, 0.12552980f, 0.06142946f, -0.04161192f, 
    -0.00525933f, 0.13552025f, 0.19338879f, 0.15880932f, 0.09095544f, 0.06706266f, 0.17888305f, 0.29298034f, 
    -0.23320034f, -0.11672613f, 0.09308126f, 0.01475467f, -0.24713144f, -0.02431995f, 0.09472410f, -0.02234330f, 
    0.00571672f, 0.08402386f, -0.03618561f, 0.10393068f, 0.08787518f, 0.10858865f, 0.07317028f, -0.02579860f, 
    0.11978705f, 0.11512934f, 0.04491757f, 0.03757897f, -0.20127101f, -0.11010236f, -0.02175372f, 0.29328573f, 
    -0.20455639f, 0.06083251f, -0.12271796f, 0.08414146f, 0.08043640f, -0.10668144f, -0.10793521f, 0.00582400f, 
    -0.05177327f, 0.03166751f, 0.09232250f, 0.03387208f, 0.19798400f, 0.23356375f, -0.02417719f, 0.03557708f, 
    -0.41316330f, 0.43043092f, 0.07418188f, 0.11468563f, 0.00081842f, 0.10853318f, -0.00720424f, -0.03093039f, 
    0.06355087f, 0.09489664f, -0.00591129f, -0.02313050f, 0.12739803f, 0.06952696f, 0.15474042f, -0.03355096f, 
    -0.02082868f, 0.09247488f, -0.01072048f, -0.11555538f, -0.22169250f, -0.14270058f, 0.17832510f, -0.08475326f, 
    -0.02974095f, -0.16989176f, 0.02854197f, 0.03143585f, 0.09211633f, -0.02617303f, -0.11147135f, -0.02581248f, 
    -0.08442357f, -0.05651918f, -0.03182162f, 0.03970253f, 0.02607285f, -0.14320831f, 0.14722688f, 0.04550891f, 
    -0.03952416f, -0.21580054f, -0.13414136f, 0.27930534f, 0.48310801f, 0.03251803f, 0.12727635f, 0.05942081f, 
    0.09874489f, 0.00743014f, -0.01238577f, 0.12277170f, -0.06678440f, -0.07548022f, 0.03788728f, 0.09048562f, 
    -0.08997087f, 0.07759931f, 0.05718897f, 0.01590874f, -0.26532808f, 0.01534681f, -0.07245909f, 0.09180063f, 
    0.13589999f, -0.06423781f, 0.07901608f, -0.06520563f, 0.06458978f, 0.19774899f, 0.11251668f, 0.11844764f, 
    -0.13550594f, -0.07388398f, -0.01279938f, 0.02776478f, -0.01304341f, 0.06916269f, 0.14811182f, -0.00510272f, 
    -0.33259034f, -0.25256118f, -0.10984547f, -0.11732376f, -0.31470940f, -0.14094502f, 0.04798059f, -0.05804360f, 
    -0.01197693f, -0.01403657f, -0.06030338f, -0.06875150f, -0.08775016f, 0.08510609f, 0.05132776f, 0.06979614f, 
    0.15370281f, 0.10925471f, -0.08632016f, 0.00322595f, -0.09474523f, 0.35945308f, -0.41173884f, -0.00435392f, 
    0.32236609f, 0.10149927f, 0.06950279f, -0.00983667f, -0.21109937f, 0.01986244f, -0.09466866f, 0.10765301f, 
    0.00697793f, 0.04933442f, -0.04753983f, 0.08864228f, 0.03139040f, 0.01553804f, 0.11094463f, 0.10797127f, 
    -0.34592512f, -0.19690308f, 0.47302988f, 0.28727740f, 0.26790497f, -0.04140548f, 0.10092134f, -0.07812800f, 
    0.06103471f, -0.06781937f, -0.06720276f, -0.09303764f, -0.08544218f, -0.05101678f, -0.03160215f, 0.01218650f, 
    0.06440937f, 0.18978655f, -0.10619555f, 0.02263412f, -0.50708038f, 0.24399889f, -0.03420683f, 0.37793958f, 
    -0.10527991f, 0.03719735f, -0.01633736f, -0.08871629f, -0.05465170f, -0.03917877f, -0.00363864f, -0.06513657f, 
    -0.04622875f, 0.13632970f, -0.09359150f, 0.05720909f, -0.03363045f, 0.06126524f, -0.16555069f, 0.08220406f, 
    0.37708670f, -0.09746093f, -0.19121873f, -0.13569638f, 0.31678292f, 0.11335334f, -0.00554515f, 0.04646618f, 
    0.06685388f, -0.06568584f, 0.05401417f, 0.16956519f, 0.10862991f, 0.09993417f, 0.01010888f, -0.05293021f, 
    0.02219227f, 0.13702548f, 0.17537579f, 0.19922566f, -0.05565169f, 0.07770594f, -0.13706408f, -0.01553888f, 
    0.19887784f, -0.15646553f, 0.03506491f, 0.00546825f, 0.11973754f, 0.02656979f, -0.01121574f, 0.01541900f, 
    0.00128029f, 0.12122567f, 0.01232740f, 0.12012437f, 0.01841171f, 0.11804335f, -0.00526013f, -0.05465610f, 
    -0.15826398f, -0.18951446f, 0.31578147f, -0.09383705f, 0.08824798f, -0.15087013f, -0.12481821f, -0.01637874f, 
    0.04693427f, -0.12601078f, -0.12925611f, -0.02850803f, -0.09448975f, -0.09140003f, 0.00113468f, 0.06610028f, 
    -0.02490873f, -0.02078210f, -0.13324639f, -0.07836821f, -0.00503273f, -0.19995773f, -0.53654850f, -0.15517248f, 
    0.31690061f, -0.05259010f, -0.04448345f, -0.14935358f, -0.02095309f, -0.14080699f, 0.02313316f, 0.01266676f, 
    0.02601249f, 0.09549537f, 0.03095871f, 0.04400397f, -0.05811211f, 0.19062826f, -0.00000679f, 0.07117482f, 
    -0.21573894f, 0.05760352f, -0.04943127f, 0.04835805f, 0.21763451f, -0.01777740f, 0.08936799f, 0.06456906f, 
    0.12664877f, 0.01686619f, 0.20301269f, 0.10405672f, -0.01710682f, 0.04015875f, 0.07649789f, 0.03639429f, 
    0.01407172f, 0.06788438f, 0.10193801f, -0.09155189f, 0.09628706f, 0.00700222f, -0.40351242f, 0.00271255f, 
    0.38393843f, 0.09599723f, 0.06340971f, 0.09197327f, 0.05465057f, 0.11388242f, -0.00307284f, 0.02432407f, 
    0.02624435f, 0.15484613f, 0.07501928f, 0.20446447f, 0.08515321f, 0.23743959f, 0.13064247f, 0.00605898f, 
    -0.43271962f, -0.08442260f, -0.16800432f, 0.04360253f, -0.04846708f, -0.21196535f, -0.06626640f, 0.11909591f, 
    -0.02128151f, -0.02134819f, 0.02868187f, 0.13790855f, -0.05004747f, 0.04977643f, 0.03273704f, -0.05943941f, 
    0.14773080f, 0.11865870f, 0.12190124f, 0.06604590f, 0.00740586f, -0.25635019f, -0.51528072f, 0.30613199f, 
    -0.08869372f, -0.08607019f, -0.08007313f, 0.09847848f, 0.19480003f, 0.05228921f, 0.05592526f, 0.04393043f, 
    0.01620945f, -0.05756734f, -0.17437504f, 0.01317774f, 0.30491123f, -0.02733065f, 0.13509767f, 0.26702580f, 
    0.31554136f, -0.27068108f, -0.31435210f, 0.12369660f, -0.07231368f, -0.14943165f, -0.17538923f, -0.11484976f, 
    0.00119594f, 0.10616547f, 0.01456155f, 0.18799219f, -0.05713357f, 0.07513037f, 0.05052230f, -0.00369920f, 
    -0.07261195f, 0.06971075f, -0.10559840f, 0.13528427f, -0.12804158f, 0.08309231f, 0.29365724f, 0.14884861f, 
    0.16542830f, -0.09653722f, -0.07191048f, -0.10099888f, -0.17510624f, -0.07399306f, -0.02320872f, 0.00255806f, 
    0.00157368f, 0.05407625f, 0.12453328f, -0.01791431f, 0.08420818f, -0.16901107f, -0.01784245f, -0.13851820f, 
    0.12351722f, -0.06839138f, 0.01790186f, 0.18175548f, 0.02183428f, 0.06467653f, 0.12658454f, 0.26335868f, 
    0.10258619f, 0.26149869f, -0.12321548f, -0.05015172f, -0.14048283f, 0.26101166f, 0.06534184f, -0.01833528f, 
    0.20703308f, 0.04014920f, 0.04908781f, 0.25564566f, -0.15996166f, -0.12716632f, -0.14609805f, -0.17826478f, 
    -0.22219324f, 0.01781995f, 0.07378857f, -0.08207364f, 0.01830469f, 0.04977656f, -0.02348145f, -0.10116214f, 
    -0.07319982f, 0.05887068f, -0.01336070f, -0.07589774f, 0.18355298f, 0.03676403f, 0.02018353f, 0.19059694f, 
    -0.36368775f, -0.21810557f, 0.03851448f, 0.22866535f, 0.05752522f, -0.12093598f, -0.19771260f, -0.26913801f, 
    -0.20455818f, -0.16783196f, -0.00689520f, 0.06771690f, 0.11074588f, -0.12447821f, 0.08147114f, -0.20179649f, 
    0.06305753f, -0.00786373f, 0.18781973f, 0.06592230f, 0.17402066f, 0.15938166f, -0.04367924f, -0.47194076f, 
    -0.23401071f, -0.11822848f, -0.10485364f, 0.28212661f, 0.01219777f, 0.27963117f, 0.00829250f, -0.06205215f, 
    0.15353286f, -0.03535368f, 0.21469907f, 0.17312866f, 0.17142458f, -0.01128035f, 0.07987250f, 0.15049945f, 
    -0.06411880f, 0.17040898f, -0.18797804f, 0.06579775f, -0.24056473f, 0.04768864f, -0.06981696f, 0.08046690f, 
    -0.09774825f, 0.00299479f, 0.05209578f, -0.09308939f, 0.00080016f, -0.07330105f, -0.06567883f, -0.00568914f, 
    0.00077614f, -0.03484318f, 0.05515070f, -0.09765150f, 0.32056364f, -0.13696872f, 0.01254845f, 0.17468816f, 
    0.24901876f, -0.04271195f, -0.23317222f, -0.05510607f, 0.06072089f, 0.05097632f, 0.05440297f, -0.00871581f, 
    -0.02375458f, -0.00197756f, 0.09641785f, -0.12851347f, -0.07204849f, -0.00616578f, -0.04731884f, -0.18932870f, 
    0.04946617f, 0.25813311f, 0.09116546f, -0.29293552f, -0.20984887f, -0.05071483f, -0.04126069f, 0.32152733f, 
    0.14706053f, -0.08511785f, -0.01461515f, 0.08879080f, 0.12336900f, 0.05105975f, 0.04578445f, 0.12494439f, 
    0.17626978f, 0.37805167f, -0.03696397f, 0.10486505f, 0.41989225f, 0.19926009f, 0.24063259f, -0.01395124f, 
    -0.07773780f, 0.21394767f, 0.04308121f, 0.06945332f, 0.00555987f, 0.01002362f, 0.10590326f, 0.08066738f, 
    0.08337446f, -0.03846007f, -0.04673157f, 0.10587051f, -0.00282204f, -0.18539058f, -0.00565878f, -0.07971988f, 
    -0.35666835f, 0.34579286f, 0.09426734f, -0.01479061f, 0.04721821f, 0.13043831f, -0.10871463f, -0.08126913f, 
    -0.02922512f, -0.06189161f, -0.10373963f, -0.07421994f, -0.05592029f, -0.03427314f, -0.00522675f, 0.18695444f, 
    -0.08024020f, -0.06588181f, 0.08514805f, -0.04140783f, 0.24836238f, 0.21660306f, 0.07578760f, -0.21113937f, 
    -0.12674287f, 0.17076586f, 0.08237953f, 0.11547921f, 0.08788852f, -0.07659299f, -0.05452171f, -0.08394226f, 
    0.05674013f, 0.11963186f, -0.03938400f, 0.12734318f, -0.03610089f, 0.00067452f, 0.04364878f, 0.03311136f, 
    -0.25747499f, -0.43594590f, -0.49454340f, -0.08882999f, -0.15118200f, 0.08324268f, 0.02642892f, -0.10949798f, 
    0.18073340f, -0.02402952f, 0.05672697f, 0.10255127f, 0.03889297f, -0.01936541f, -0.02225154f, -0.07837614f, 
    0.07695259f, 0.02433181f, 0.08117848f, 0.10692963f, 0.19108467f, 0.22237520f, -0.06300729f, -0.20180237f, 
    -0.15068956f, 0.01096249f, 0.07570546f, 0.13985310f, -0.08472736f, -0.12903059f, -0.09870499f, -0.05464870f, 
    -0.03632404f, -0.07316706f, -0.13177413f, 0.10631080f, -0.25145796f, -0.05571091f, -0.07166764f, -0.28250033f, 
    0.02994632f, -0.02784137f, 0.01370569f, -0.04705285f, 0.02270425f, 0.00005962f, -0.03909136f, 0.01776195f, 
    0.04903369f, -0.01921304f, 0.02185304f, -0.00926090f, 0.02486785f, 0.01665409f, -0.04243837f, 0.00399811f, 
    0.02760478f, -0.05751270f, -0.02283607f, -0.04254908f, -0.04698543f, 0.03111018f, 0.01240201f, -0.00481962f, 
    0.03693610f, 0.01044894f, 0.03739356f, 0.00451324f, 0.04142541f, -0.03597986f, 0.04449498f, -0.04491260f, 
    -0.04733834f, -0.03278981f, -0.03379449f, 0.05043201f, -0.01721375f, 0.04885308f, -0.05667087f, -0.02691112f, 
    -0.05637814f, -0.02058030f, 0.02409474f, 0.05022825f, -0.03942737f, -0.04266324f, -0.00919952f, 0.04092860f, 
    -0.01445853f, -0.00934833f, 0.03208279f, 0.00314296f, 0.00269564f, 0.04967226f, 0.01191755f, -0.02311740f, 
    -0.03601898f, -0.01291986f, 0.00051834f, -0.04521232f, 0.00272824f, -0.05666599f, 0.00934346f, 0.04057435f, 
    -0.04512269f, -0.05279601f, -0.05851729f, -0.04846266f, -0.00579912f, -0.04553608f, -0.00559764f, -0.05659778f, 
    0.03412525f, 0.04172121f, 0.02353906f, 0.01957721f, -0.00288717f, -0.00895060f, 0.04523517f, -0.05847459f, 
    -0.01769739f, -0.00096307f, 0.02896845f, 0.00743297f, 0.01398815f, -0.01289994f, -0.03396070f, -0.02350831f, 
    0.00443751f, -0.01660660f, -0.01549170f, -0.05816932f, 0.04712813f, 0.04736391f, 0.05046729f, 0.01599099f, 
    -0.03907344f, -0.03133126f, -0.05015808f, -0.04976474f, -0.01414896f, -0.04836196f, 0.00551562f, -0.01901514f, 
    -0.02983277f, 0.02561482f, 0.03186054f, -0.04980249f, -0.03370939f, -0.00392559f, -0.00984253f, 0.00543780f, 
    -0.01827436f, 0.04973033f, 0.02965637f, 0.00343946f, -0.02072251f, 0.00730447f, -0.04233406f, -0.01575972f, 
    -0.04837353f, 0.03043248f, 0.04384365f, -0.03045114f, 0.02583374f, -0.02006644f, 0.00410351f, -0.03108785f, 
    -0.01368914f, 0.01378646f, 0.03084224f, 0.01739403f, -0.02620232f, -0.04934189f, 0.04459120f, -0.01813237f, 
    -0.01757218f, -0.05275135f, 0.01784189f, 0.02573887f, -0.04582155f, 0.04685808f, 0.03417039f, 0.04136212f, 
    -0.04495881f, -0.06122092f, 0.03719655f, -0.03442782f, -0.02855229f, 0.03287510f, 0.00109829f, 0.04583681f, 
    0.03367797f, -0.04209607f, -0.00608550f, 0.02862827f, -0.01996778f, -0.05822539f, 0.00424274f, -0.01366785f, 
    -0.05894013f, -0.01180757f, -0.05915146f, -0.02900752f, -0.04043327f, 0.01241115f, 0.03278964f, -0.06060911f, 
    -0.00308711f, -0.05561909f, -0.03548147f, -0.01280512f, 0.01533928f, 0.03637949f, -0.02336548f, -0.01415049f, 
    -0.03923601f, 0.01267099f, 0.00695975f, 0.02962985f, 0.00223353f, 0.02520025f, 0.00508047f, 0.03124079f, 
    0.02477085f, 0.02247911f, 0.02839234f, -0.02934167f, -0.00409494f, 0.04554426f, -0.02369819f, 0.03663429f, 
    -0.00129917f, -0.01019956f, 0.04446283f, 0.01300890f, 0.04115909f, -0.04517071f, -0.00031854f, -0.00887062f, 
    -0.05393950f, 0.02018002f, 0.02339914f, 0.04237098f, 0.04862373f, -0.01772908f, -0.02868908f, 0.03272293f, 
    0.00714560f, -0.01551642f, -0.05139038f, -0.03019309f, -0.04802114f, -0.03212271f, -0.03997235f, 0.02413699f, 
    -0.02187348f, -0.00985218f, -0.03744292f, -0.01357349f, -0.03279574f, 0.01264895f, 0.04352779f, -0.02423898f, 
    0.00541514f, -0.01702178f, -0.03481701f, -0.05634504f, -0.01500775f, 0.04086683f, -0.01838427f, -0.05255140f, 
    0.01989862f, 0.00100620f, -0.03676981f, -0.03884356f, -0.00282790f, 0.03574292f, -0.02637278f, 0.00386476f, 
    -0.06018614f, 0.00197389f, 0.03537861f, 0.04411533f, -0.01561162f, 0.03114548f, 0.01465768f, -0.01582147f, 
    -0.01904445f, 0.00821052f, 0.05621837f, 0.02651945f, -0.03155814f, -0.03442379f, -0.03230971f, -0.05823273f, 
    0.01731572f, -0.01612749f, -0.03927620f, 0.00728853f, -0.04567698f, 0.03969789f, 0.02109297f, -0.00801321f, 
    -0.03987149f, 0.02868930f, 0.03559593f, -0.01910930f, 0.03415874f, -0.04639677f, -0.04135022f, 0.03030683f, 
    -0.01339352f, -0.05336986f, -0.04434847f, -0.02331807f, 0.01628319f, 0.00101132f, -0.04681359f, 0.01188732f, 
    -0.06068433f, -0.05630945f, -0.03416359f, -0.04961079f, -0.04190373f, 0.02514217f, 0.03575095f, -0.00928894f, 
    0.04459948f, 0.02426268f, 0.01694631f, -0.03443996f, 0.05026552f, -0.04851999f, -0.04245225f, -0.05910441f, 
    -0.01393172f, -0.02191814f, 0.01389366f, -0.04020755f, 0.04301993f, 0.00843780f, -0.02709635f, 0.01117910f, 
    0.04851918f, -0.00161578f, 0.04768062f, 0.01671287f, -0.05978326f, -0.05684632f, 0.00478334f, -0.03082245f, 
    -0.00422200f, -0.00196514f, 0.04179315f, -0.02618900f, 0.01443123f, -0.05694130f, -0.02034197f, 0.03785492f, 
    0.10268447f, 0.26992366f, 0.19081810f, -0.25336611f, -0.20893058f, -0.02226231f, -0.08456585f, 0.06102946f, 
    -0.08281240f, -0.05074020f, 0.04325120f, -0.19694103f, 0.02345961f, -0.01292451f, -0.10987307f, -0.02686854f, 
    -0.22883987f, 0.03412937f, -0.16270775f, -0.17735334f, -0.12578128f, -0.33827063f, 0.24781528f, -0.01176406f, 
    0.00513875f, -0.05313462f, -0.01051564f, -0.02137313f, 0.09308562f, 0.22036943f, -0.06599945f, -0.05277908f, 
    -0.10597681f, -0.13540640f, -0.03598109f, 0.07232101f, -0.29503775f, -0.18318453f, 0.01178298f, -0.05525032f, 
    -0.30302912f, 0.20363085f, 0.24577066f, -0.18844922f, -0.15755357f, -0.12699570f, -0.20238355f, -0.03596410f, 
    0.03956875f, -0.15247415f, 0.00085355f, 0.07235350f, -0.12619759f, 0.03399247f, 0.05027951f, -0.20258991f, 
    -0.08671807f, -0.04319290f, 0.13942838f, -0.00620755f, 0.07097292f, -0.02193416f, -0.24428003f, 0.03468804f, 
    -0.03358790f, 0.07735391f, 0.00083431f, 0.10983995f, -0.03259451f, -0.06338050f, -0.02979042f, 0.01574414f, 
    0.08817845f, 0.07801283f, 0.06226015f, 0.00292398f, 0.11825309f, 0.10425301f, -0.10051468f, 0.10627829f, 
    0.08057356f, 0.36877096f, -0.13911812f, 0.04654920f, -0.23303816f, -0.13585949f, -0.16833121f, 0.33519310f, 
    -0.25169635f, -0.19311276f, -0.06955489f, 0.07375935f, 0.01915848f, -0.11046027f, 0.11650116f, 0.00801087f, 
    -0.04896612f, 0.04494107f, -0.10325136f, -0.06666404f, 0.30707401f, 0.05549666f, 0.38673976f, 0.12499337f, 
    0.09463081f, 0.16066031f, -0.17785764f, -0.02806917f, 0.02699498f, 0.05489019f, -0.09871232f, -0.05485638f, 
    -0.00690450f, -0.19123499f, -0.01995024f, -0.15459533f, -0.17927778f, -0.25018042f, -0.00150934f, 0.05757046f, 
    -0.03639261f, 0.02489649f, 0.13936318f, -0.05087855f, -0.12844908f, -0.01686456f, 0.02580806f, -0.06130191f, 
    -0.14412704f, -0.20810592f, 0.07498002f, -0.04102206f, 0.33840075f, -0.03199070f, -0.08929431f, 0.09469680f, 
    -0.11996483f, -0.06202416f, -0.08180041f, -0.06365927f, 0.56462276f, 0.20250417f, 0.04180842f, 0.09661768f, 
    0.05571249f, -0.17927283f, 0.15480149f, -0.08637802f, -0.14733927f, 0.18179892f, -0.09923155f, 0.08452194f, 
    -0.17884807f, 0.01638267f, -0.00827750f, 0.03422309f, -0.10191675f, -0.07540257f, 0.00290436f, 0.08761663f, 
    -0.09316957f, 0.20025279f, 0.23709601f, 0.07292769f, 0.48996931f, 0.03693101f, 0.10970046f, 0.18100701f, 
    0.10318851f, 0.17920972f, -0.08207414f, 0.16490622f, 0.01757979f, 0.01275595f, -0.03247428f, 0.08083838f, 
    -0.02978387f, 0.08607414f, -0.01824692f, 0.04307109f, -0.39884222f, 0.01975449f, 0.17769977f, -0.15972677f, 
    0.21214870f, -0.02050082f, -0.03845927f, 0.04550263f, 0.23038763f, -0.01029528f, -0.11649781f, 0.09722154f, 
    -0.06967523f, -0.02179805f, -0.05618023f, -0.04463573f, 0.08335914f, -0.13506913f, 0.10382298f, 0.09481030f, 
    0.30753365f, 0.35369059f, 0.20950359f, 0.32059136f, 0.19391161f, -0.01442342f, 0.13300321f, 0.26642051f, 
    -0.00970293f, 0.39204589f, 0.04012339f, -0.06520211f, -0.02283148f, -0.18206418f, -0.13669772f, 0.03332656f, 
    -0.24188375f, -0.07220360f, 0.00399310f, -0.04247278f, -0.16997997f, -0.10962087f, -0.03311708f, 0.17186299f, 
    0.14505476f, -0.05175958f, -0.03234655f, 0.06554328f, 0.19583015f, 0.06876789f, -0.04046430f, 0.04062825f, 
    -0.10855493f, 0.06062202f, 0.04771654f, 0.03140647f, 0.02951327f, -0.05517046f, -0.00849186f, 0.05862437f, 
    -0.07711709f, 0.03518040f, -0.20823018f, 0.27843758f, 0.03198581f, 0.04034578f, 0.15907912f, 0.01783237f, 
    0.04444199f, 0.03743013f, -0.05093755f, 0.02860762f, 0.04590132f, 0.10544514f, 0.13019131f, 0.12963597f, 
    0.08059621f, 0.03360195f, 0.00368227f, 0.12710373f, -0.03114535f, -0.10992142f, 0.12478691f, 0.22817999f, 
    0.19168511f, -0.00541032f, -0.02894860f, 0.00505674f, 0.13804057f, 0.39228037f, -0.01761394f, 0.10798871f, 
    0.07856001f, 0.06250117f, -0.06030393f, 0.02520425f, 0.11791363f, -0.13867228f, 0.05159824f, -0.09837458f, 
    -0.10613450f, -0.19316633f, 0.47775394f, 0.05205620f, -0.04232562f, 0.05513734f, -0.38173413f, 0.01975713f, 
    -0.03149757f, -0.28644255f, -0.09542608f, -0.06510817f, 0.02311970f, -0.06312479f, 0.00711636f, -0.12917177f, 
    -0.16320711f, -0.07905859f, 0.04401563f, -0.01400186f, -0.16656138f, -0.06353445f, -0.15653126f, 0.22160174f, 
    0.00316118f, -0.02939241f, 0.10300633f, -0.12840948f, 0.19909623f, 0.23589756f, 0.00969594f, 0.12575880f, 
    0.20830920f, 0.13200462f, 0.12745564f, -0.08058339f, 0.19918677f, 0.14665945f, 0.03870013f, 0.19033957f, 
    -0.00182832f, -0.00679412f, 0.01503407f, 0.01339872f, -0.02731077f, -0.05197578f, 0.03153416f, -0.02162865f, 
    0.03232848f, 0.04877055f, 0.01660571f, 0.02501041f, 0.02228304f, 0.02533974f, 0.04550795f, -0.03762511f, 
    0.01311946f, 0.02889591f, 0.03965376f, -0.01156583f, -0.03773057f, -0.03941460f, -0.01130902f, -0.00698830f, 
    0.02011684f, -0.03442003f, 0.03291979f, -0.06376631f, 0.02922561f, 0.03304169f, 0.04384119f, 0.01237728f, 
    -0.01094947f, -0.03874636f, -0.01988469f, -0.02851665f, -0.04586356f, -0.05652905f, -0.00184142f, 0.04719107f, 
    -0.00340010f, -0.03299996f, 0.02578643f, -0.02683516f, 0.03925601f, -0.03294116f, 0.03059396f, -0.00091928f, 
    -0.05565231f, -0.06228115f, -0.03197628f, -0.01517535f, 0.02720738f, 0.00095515f, -0.03649025f, 0.01743246f, 
    -0.00137870f, 0.02656276f, -0.04132690f, -0.05165554f, -0.05764911f, -0.00040162f, -0.03477793f, -0.00399914f, 
    -0.05218913f, -0.00296423f, -0.00182360f, -0.04087862f, -0.04690079f, 0.00102968f, 0.00939424f, 0.02859888f, 
    -0.05369509f, -0.00905286f, -0.00606805f, -0.01883991f, -0.03422489f, 0.03976468f, -0.00991497f, -0.04487555f, 
    -0.02686967f, 0.00395449f, -0.06104131f, 0.01929469f, -0.02427351f, 0.02112952f, -0.06174020f, 0.01643011f, 
    0.03621341f, -0.05494614f, -0.05590577f, -0.04362566f, 0.02171773f, -0.02408768f, -0.02969310f, -0.03907022f, 
    0.02628632f, 0.00987987f, 0.00509976f, 0.03969079f, -0.02183913f, -0.04553763f, 0.03291664f, 0.01091919f, 
    -0.03956172f, 0.04316581f, 0.03469517f, -0.00521736f, 0.03615125f, 0.03348761f, -0.03103196f, 0.04070141f, 
    0.02393426f, -0.01008620f, -0.05348416f, 0.00976985f, 0.01536900f, -0.02629454f, -0.03427979f, 0.04154176f, 
    -0.04696470f, -0.02941244f, 0.03232932f, -0.05744656f, -0.04127127f, 0.00851857f, 0.00704220f, 0.04785223f, 
    -0.05507445f, -0.03775945f, 0.03022712f, -0.00030016f, -0.00217458f, 0.05792065f, -0.02348564f, -0.03844889f, 
    -0.03832456f, 0.01351426f, -0.06117024f, -0.01088970f, 0.03515865f, -0.04969488f, -0.00392192f, -0.01583142f, 
    0.03274347f, -0.03074323f, -0.05492091f, -0.01510484f, 0.02681336f, -0.04010666f, -0.04617551f, 0.01990892f, 
    -0.00227505f, 0.02345088f, 0.03553518f, 0.00189125f, -0.03947363f, 0.03383718f, -0.03543605f, 0.01174004f, 
    -0.02340242f, 0.03269554f, -0.06388509f, -0.00336706f, 0.01319571f, 0.00620742f, -0.05989191f, 0.01238401f, 
    -0.03796346f, 0.04081267f, 0.01003217f, 0.02444481f, -0.05778168f, -0.06301700f, 0.01920431f, -0.00005424f, 
    -0.03141245f, 0.02749116f, -0.06329794f, -0.01409549f, -0.03648372f, -0.05793953f, 0.02491594f, 0.00584388f, 
    0.00409888f, 0.00848854f, -0.00336313f, 0.04580602f, 0.02784407f, -0.04872032f, -0.00471824f, 0.02920786f, 
    -0.00677839f, 0.01900827f, -0.00509317f, 0.04887691f, -0.02148840f, -0.05393170f, 0.02352350f, -0.00414073f, 
    -0.03698707f, -0.04391001f, 0.01306644f, -0.03004041f, 0.02544280f, -0.03019683f, -0.03737622f, 0.04094228f, 
    -0.03674137f, -0.03185001f, 0.00617031f, -0.02355774f, -0.01418167f, -0.06186841f, -0.04174823f, 0.02389503f, 
    -0.06240355f, -0.05214681f, -0.02378780f, -0.03993563f, 0.01748203f, -0.05603546f, -0.05638937f, 0.03067038f, 
    -0.01020471f, 0.01259908f, 0.02107243f, 0.03774373f, -0.02920850f, -0.05061514f, 0.00084717f, -0.03548906f, 
    -0.02359015f, 0.00161470f, 0.00986613f, 0.01361189f, 0.03420235f, 0.02190151f, -0.03648572f, -0.00641869f, 
    -0.04872316f, 0.01779620f, 0.00395822f, 0.01989420f, 0.04386941f, 0.04062821f, -0.00056489f, 0.02877783f, 
    -0.03491485f, -0.03886571f, -0.02883174f, -0.03185099f, -0.02143440f, 0.04760486f, -0.04299788f, 0.04288180f, 
    0.02770801f, 0.00977946f, -0.02815169f, 0.04192080f, -0.00621283f, -0.04244602f, 0.02379082f, -0.05533005f, 
    -0.01526955f, -0.00788630f, 0.00171798f, -0.03296583f, -0.01543346f, 0.02057059f, -0.01797991f, -0.03202724f, 
    -0.03170469f, -0.02432110f, -0.00337869f, 0.00151246f, -0.01149214f, -0.03504614f, -0.01598856f, -0.01604311f, 
    -0.06141630f, -0.05687091f, -0.01450259f, -0.01269431f, -0.00258950f, -0.02376064f, -0.01240910f, -0.06425626f, 
    -0.01245681f, -0.02952383f, -0.05507877f, -0.03552761f, -0.00739631f, -0.04073726f, -0.04992997f, -0.01758807f, 
    -0.03925581f, 0.02824117f, -0.05205187f, 0.02142053f, 0.01351452f, -0.04995204f, 0.03215932f, -0.01097796f, 
    0.04302756f, 0.03426362f, 0.02504737f, -0.04467648f, 0.01037680f, 0.02280763f, -0.06324784f, -0.03833514f, 
    -0.02928499f, 0.03234332f, -0.02017519f, 0.02229350f, 0.01216277f, -0.03951156f, -0.02967994f, 0.01095953f, 
    -0.07883190f, 0.02526515f, -0.09508127f, 0.14662676f, 0.18985999f, 0.01844502f, -0.00583021f, -0.08239736f, 
    -0.04379610f, 0.00454281f, -0.03123643f, 0.08777907f, -0.13607134f, 0.09652144f, 0.07717197f, -0.07850055f, 
    0.03979442f, -0.11006813f, 0.04066823f, -0.03231342f, -0.18279137f, 0.20050213f, 0.30819359f, -0.04162356f, 
    -0.02807779f, -0.10026339f, 0.14807107f, 0.05749727f, -0.11943620f, -0.20975195f, 0.04423352f, 0.03505111f, 
    0.12483668f, 0.10816441f, -0.03127901f, 0.07726611f, 0.15132560f, 0.23140538f, 0.08063070f, -0.12192168f, 
    -0.00801689f, 0.10406546f, -0.16083086f, 0.06825568f, -0.04508780f, 0.13133432f, 0.16212574f, 0.15358117f, 
    -0.11810823f, -0.05001181f, 0.01635706f, -0.01289295f, 0.08880487f, 0.01847183f, -0.04966169f, 0.15379846f, 
    0.00438931f, 0.05583608f, 0.00070340f, 0.08947496f, 0.31521010f, -0.12231850f, 0.26364800f, 0.19008607f, 
    0.04114132f, -0.02224899f, -0.01443011f, 0.02330813f, 0.01136903f, -0.05728807f, -0.08717053f, 0.00811597f, 
    -0.00481898f, -0.00639635f, -0.08233366f, 0.04347258f, -0.06259613f, -0.06939825f, 0.21486026f, 0.06092535f, 
    -0.12663393f, -0.05963947f, 0.15769361f, -0.09650621f, 0.24228761f, 0.27913776f, 0.14076643f, -0.18164963f, 
    0.11533487f, 0.14108339f, 0.05222323f, 0.04066766f, -0.02220696f, 0.01255431f, 0.00873452f, 0.05623142f, 
    0.14439806f, -0.01629632f, 0.02814482f, 0.01538799f, -0.03863014f, -0.16341206f, -0.24148153f, 0.00558745f, 
    -0.01188531f, 0.01335292f, -0.01509940f, 0.07850896f, 0.01988667f, -0.09579851f, -0.08528659f, 0.13356368f, 
    0.02659652f, -0.05701755f, -0.05922637f, 0.01384725f, -0.06128949f, 0.02425064f, -0.04937376f, -0.07812814f, 
    0.03835174f, 0.15618686f, 0.00747972f, -0.03872084f, 0.05727288f, -0.02877378f, -0.02958917f, 0.01274986f, 
    0.10074132f, -0.03615732f, -0.07840678f, -0.05440224f, -0.12119979f, -0.03078789f, -0.08811992f, -0.06513883f, 
    0.03716338f, 0.14901966f, -0.03731355f, -0.07810642f, 0.03942531f, -0.05369011f, 0.07658926f, 0.05478474f, 
    0.09100189f, 0.06670342f, 0.05645816f, -0.09434444f, 0.26720208f, -0.09970118f, 0.17686839f, -0.02758739f, 
    0.05752053f, -0.01879040f, -0.16182238f, -0.04904298f, 0.06383315f, 0.13391148f, 0.12275403f, -0.06370315f, 
    0.15948613f, -0.15495549f, 0.19546245f, 0.05326903f, -0.03712811f, 0.08773288f, -0.05245792f, -0.13901754f, 
    0.00399856f, 0.03698670f, 0.01709078f, -0.06019785f, -0.16424426f, -0.00065836f, 0.00035135f, 0.08630652f, 
    0.06898475f, -0.04032375f, 0.03123001f, 0.03359998f, 0.15149446f, 0.04913280f, -0.05289201f, 0.17566539f, 
    0.07870100f, -0.08445835f, 0.02103299f, 0.11638168f, -0.12846118f, -0.00282696f, 0.05704466f, 0.07034939f, 
    0.04866280f, 0.00725574f, 0.03769077f, 0.26227307f, 0.03199955f, 0.24543865f, 0.10583165f, 0.05968193f, 
    0.13535881f, -0.12136696f, 0.12179232f, -0.08655009f, 0.02862413f, 0.07284909f, -0.03618306f, -0.36907229f, 
    -0.02196202f, -0.03280739f, -0.06047935f, -0.05689922f, -0.04885349f, 0.02340937f, 0.02701061f, 0.00677143f, 
    -0.00939537f, -0.11102369f, 0.13420920f, 0.02367400f, 0.11137632f, 0.06638264f, -0.04847341f, -0.04206043f, 
    -0.07212047f, 0.04434334f, -0.17061055f, -0.03086652f, -0.05480972f, 0.02903466f, 0.00395361f, 0.06420133f, 
    0.00425224f, -0.08179091f, -0.00326770f, 0.07827586f, -0.07539545f, 0.09227304f, -0.00834187f, -0.08193895f, 
    0.22414465f, 0.02964663f, 0.59045881f, 0.01960032f, -0.13164067f, 0.01932095f, -0.07557462f, -0.05731089f, 
    -0.05876094f, -0.01537834f, 0.06057646f, -0.07856905f, 0.02076274f, -0.04276980f, -0.06317299f, -0.00295479f, 
    0.11556666f, 0.02596501f, -0.03911671f, -0.04443723f, 0.12622514f, -0.00257426f, -0.14332598f, -0.11588870f, 
    -0.04395396f, 0.04032646f, -0.00508632f, -0.06171422f, -0.01633319f, 0.03562325f, -0.01249464f, -0.08883206f, 
    0.01308670f, -0.07126039f, -0.01805056f, -0.05051681f, -0.04226511f, 0.17579210f, -0.01447864f, 0.15078691f, 
    0.08367461f, -0.10519221f, -0.13215776f, 0.05222183f, -0.08942485f, 0.06383906f, 0.08134758f, 0.11477455f, 
    0.00114468f, -0.01245893f, -0.15974161f, 0.15413202f, -0.01545316f, -0.06091323f, 0.08184438f, -0.00553858f, 
    0.05221902f, 0.02179451f, -0.06142060f, 0.03289201f, 0.32962951f, 0.12805524f, 0.09307459f, -0.17396423f, 
    0.00512684f, 0.25450304f, 0.00467167f, -0.03534470f, 0.10340799f, 0.13293058f, -0.01020973f, -0.09450266f, 
    0.03473252f, 0.08098324f, 0.05601398f, 0.11982612f, 0.01241005f, 0.04071304f, -0.00651931f, 0.09104399f, 
    0.03289569f, 0.03532287f, -0.04585420f, 0.03405844f, 0.02787047f, 0.04607985f, -0.04838574f, -0.05094601f, 
    -0.04432795f, 0.01476877f, -0.01207224f, 0.00411132f, -0.03926421f, -0.00044210f, -0.01699493f, -0.01931610f, 
    -0.04222186f, -0.02997749f, -0.05344866f, 0.04200668f, -0.02956770f, 0.03387223f, -0.02869657f, -0.01380406f, 
    -0.04488475f, -0.05456538f, -0.00830627f, 0.02523836f, 0.03791181f, 0.03627905f, -0.03214594f, -0.04297763f, 
    0.00605505f, 0.00347474f, -0.01752973f, -0.04945458f, 0.03230939f, -0.00005115f, -0.03199314f, -0.01716676f, 
    -0.02164956f, -0.01114182f, -0.03230288f, 0.01795659f, 0.00889334f, -0.02553436f, -0.03767230f, 0.03599922f, 
    0.03910846f, -0.00176493f, 0.00307557f, 0.04954643f, -0.03342238f, -0.01474302f, -0.05052332f, 0.05029837f, 
    0.02588899f, -0.00924683f, -0.01823182f, 0.00509391f, -0.03231405f, -0.01620631f, -0.03557365f, 0.04031584f, 
    -0.01772016f, -0.00159617f, -0.02625622f, 0.04745765f, -0.00499336f, 0.04130667f, -0.04522869f, -0.01428802f, 
    0.02343481f, 0.02455276f, 0.03256062f, -0.04183413f, -0.05156041f, 0.02120531f, -0.04040320f, 0.00442601f, 
    -0.04023179f, -0.01183964f, 0.04243045f, -0.05541645f, 0.04761390f, -0.00065174f, -0.03244836f, -0.01301745f, 
    0.00343265f, 0.03607408f, 0.04284805f, 0.03989227f, 0.03863268f, -0.01588791f, 0.02882737f, 0.02236244f, 
    0.04989298f, 0.04534306f, 0.03574241f, 0.05316871f, -0.00424486f, -0.05589649f, 0.03001850f, -0.00531917f, 
    -0.05173275f, 0.05129280f, -0.04440099f, -0.01870257f, -0.02102184f, -0.02684837f, 0.04718206f, -0.05458780f, 
    0.04490897f, -0.01905837f, -0.04832678f, 0.01391703f, 0.00243678f, -0.01748265f, -0.03693542f, 0.02199267f, 
    -0.01417338f, -0.04746512f, 0.01222880f, -0.02789655f, 0.00925657f, -0.04583392f, 0.03521299f, 0.01604090f, 
    -0.01757214f, 0.05073899f, 0.01589579f, 0.03079678f, 0.01539025f, -0.01626459f, 0.03956213f, -0.02369107f, 
    -0.03596313f, -0.04826338f, 0.02990084f, 0.04186048f, -0.05156830f, 0.02414259f, -0.04803357f, -0.01034028f, 
    -0.00899987f, 0.00166792f, 0.05202408f, -0.02047273f, 0.03068369f, -0.01465912f, -0.00846964f, -0.00482305f, 
    -0.04119279f, 0.05051888f, 0.00478322f, -0.02929866f, -0.00861849f, -0.04410584f, 0.00095115f, 0.00897718f, 
    -0.00803937f, -0.03362031f, -0.00889675f, 0.02958719f, 0.03347136f, -0.02403023f, 0.05225050f, 0.04405711f, 
    0.05434982f, 0.02648274f, -0.03703849f, -0.02578425f, -0.01035655f, -0.04535212f, 0.03177116f, -0.03789629f, 
    -0.05363285f, 0.02543632f, -0.00596823f, -0.03478334f, 0.01199134f, -0.04620614f, 0.03537096f, -0.01956921f, 
    0.00552726f, -0.03585450f, -0.05116330f, 0.04883479f, 0.02829893f, 0.01779515f, -0.01432715f, -0.03041694f, 
    0.01520652f, 0.00460300f, -0.00647866f, 0.00345906f, 0.04449759f, 0.05348552f, 0.00204390f, 0.02803515f, 
    0.02776600f, 0.00796412f, -0.01770504f, 0.02942147f, -0.00579078f, -0.01946269f, -0.04942393f, -0.04801009f, 
    -0.04729098f, -0.00049202f, 0.04462523f, 0.01791428f, 0.02430229f, -0.04416515f, 0.01842227f, 0.01029018f, 
    -0.02921134f, -0.01312769f, -0.01561501f, 0.02355189f, 0.00650079f, -0.04403030f, 0.00514308f, -0.00810348f, 
    0.04877562f, 0.01654597f, 0.00657807f, -0.03904988f, -0.01296272f, -0.02224430f, -0.02047979f, 0.02820208f, 
    0.00618135f, 0.03181918f, -0.02622379f, -0.05579423f, 0.00689410f, -0.00058085f, -0.04948771f, 0.04656198f, 
    0.01493646f, -0.01804240f, -0.00899814f, -0.01650529f, 0.02209263f, -0.05534051f, -0.02550126f, 0.04399373f, 
    -0.02446042f, -0.00215440f, -0.03255572f, 0.01025143f, -0.03896620f, -0.05108783f, -0.03875217f, -0.00625579f, 
    -0.04965766f, -0.04195238f, -0.02140429f, -0.03293876f, 0.01422895f, 0.01490744f, -0.03158668f, -0.02558671f, 
    -0.04936199f, -0.02928867f, -0.00096329f, -0.02780370f, -0.02330746f, -0.02292109f, 0.01442466f, 0.03748224f, 
    -0.04774571f, 0.01332448f, -0.01123711f, 0.00943845f, -0.05495274f, 0.01721520f, 0.02284229f, -0.05448248f, 
    -0.04487365f, 0.05441774f, -0.02887229f, -0.04752695f, -0.00368225f, -0.05331487f, -0.02860903f, 0.03906227f, 
    0.01133220f, -0.05007415f, 0.00064771f, -0.01957557f, 0.02373768f, -0.00609014f, -0.04166628f, -0.00225451f, 
    -0.00632940f, 0.05184556f, -0.00248005f, -0.05515546f, -0.04902158f, -0.00906559f, -0.04808815f, -0.04217405f, 
    -0.02030348f, -0.03443753f, 0.01439423f, -0.03375687f, 0.03040969f, 0.04114950f, 0.04849290f, -0.00020440f, 
    -0.04570863f, -0.04472589f, -0.04219024f, 0.00452176f, -0.03682653f, 0.02184043f, -0.05066280f, -0.05506418f, 
    0.07763789f, -0.00727386f, -0.07233884f, 0.05705164f, 0.09354134f, -0.06996408f, 0.03900402f, 0.09090923f, 
    0.03876039f, 0.01910654f, 0.13632409f, 0.25787506f, 0.04942986f, 0.12300523f, -0.01918858f, 0.09847672f, 
    0.11936419f, 0.07835884f, 0.11947555f, -0.04102454f, 0.48175994f, 0.05768598f, -0.14998689f, 0.25126952f, 
    0.00790216f, 0.18984656f, 0.07767159f, 0.08589958f, 0.04622248f, 0.17402339f, 0.05762397f, -0.10111459f, 
    0.08937173f, -0.02046838f, -0.11086693f, 0.18847308f, 0.19593042f, 0.05577916f, 0.17041329f, 0.15358050f, 
    0.26849845f, -0.21973166f, -0.10513145f, -0.05264478f, -0.06772143f, -0.09549612f, 0.17808595f, -0.08443754f, 
    0.04734677f, -0.01591788f, 0.05654653f, 0.11162679f, 0.03529404f, 0.19207115f, 0.08757651f, 0.02236410f, 
    -0.16472253f, 0.19066453f, 0.05722685f, -0.02303433f, 0.21858658f, 0.27630457f, 0.05861629f, 0.05666121f, 
    0.37511122f, 0.07900277f, -0.06795746f, -0.13344054f, -0.06888021f, -0.04986977f, -0.08288518f, -0.09114375f, 
    0.02854001f, -0.03605308f, -0.00052830f, -0.01374911f, -0.03523254f, 0.00817893f, -0.00857154f, -0.12947290f, 
    0.46194604f, -0.06333186f, 0.24067169f, -0.21679738f, 0.04687423f, -0.01492943f, 0.06927261f, 0.11466300f, 
    0.36378074f, 0.25035056f, -0.04539423f, 0.01854241f, -0.04100762f, 0.06601001f, -0.00508663f, -0.07663216f, 
    0.13521884f, 0.00856724f, 0.21533006f, 0.25653401f, 0.06021464f, -0.11644994f, 0.02044104f, 0.02132505f, 
    -0.01351197f, -0.07927258f, 0.02474303f, -0.07363269f, 0.02440853f, 0.10290210f, 0.21402822f, 0.03678819f, 
    -0.02992510f, -0.07971458f, -0.11175407f, -0.17899252f, 0.08878158f, -0.00990507f, -0.08478501f, 0.03288138f, 
    0.07194668f, 0.04115780f, -0.04336540f, 0.22768028f, 0.20053621f, -0.03605099f, -0.03610767f, -0.13737611f, 
    -0.12149371f, -0.06435549f, 0.13306037f, 0.08262870f, 0.08835055f, 0.02784797f, 0.01775650f, 0.13316782f, 
    0.17793171f, 0.00139607f, -0.02420372f, -0.04823345f, -0.47718030f, -0.39006111f, 0.07797491f, 0.16449480f, 
    -0.30485469f, -0.11940438f, -0.25471044f, 0.24930024f, -0.01823666f, 0.17223230f, -0.03594642f, -0.02341800f, 
    0.11612630f, 0.07212316f, 0.12135286f, -0.05542852f, -0.00184351f, -0.05530319f, 0.00161535f, 0.15504733f, 
    0.36322555f, 0.00609325f, -0.22865140f, 0.10372791f, 0.06780586f, 0.08415768f, 0.05992280f, 0.09792893f, 
    -0.02033818f, 0.01534469f, 0.00337196f, 0.04180845f, 0.05990646f, -0.01131034f, -0.03435928f, 0.02881106f, 
    -0.02761236f, -0.02764597f, 0.07340074f, -0.07573242f, 0.24184166f, 0.01607680f, -0.02293337f, -0.03084441f, 
    -0.00422123f, -0.05238264f, 0.05340129f, -0.17522807f, 0.01712433f, -0.08523045f, -0.00042243f, -0.02068456f, 
    -0.05892050f, -0.02481816f, 0.05956312f, -0.04825071f, -0.00425058f, -0.03399129f, 0.08404987f, -0.12167133f, 
    -0.30387303f, 0.12827535f, 0.20998909f, 0.09178308f, -0.08680621f, -0.01888840f, -0.17622244f, 0.11861508f, 
    -0.00352770f, -0.12029677f, -0.03577917f, 0.01118170f, -0.02641303f, 0.06478041f, 0.00895055f, 0.02423042f, 
    0.05701580f, 0.08336925f, -0.03137560f, 0.01432759f, 0.27943063f, -0.03039472f, 0.22089042f, 0.12018926f, 
    0.00016772f, 0.23687421f, 0.08156180f, -0.00972621f, 0.08463439f, -0.00422867f, 0.03701188f, -0.01749959f, 
    0.08111069f, 0.07974686f, 0.07949473f, 0.03530578f, 0.03143605f, -0.09271464f, -0.08013139f, -0.03522841f, 
    0.44705403f, 0.11058073f, -0.00870694f, 0.14287531f, 0.02595984f, 0.14539059f, -0.07741091f, -0.08608729f, 
    0.05270917f, 0.07240699f, -0.14835723f, -0.08168605f, -0.07089905f, -0.07753932f, -0.03077034f, 0.04291494f, 
    -0.14849657f, 0.06934404f, -0.01653890f, 0.07231241f, 0.00762698f, 0.01948625f, 0.30543411f, 0.19430809f, 
    -0.04833933f, -0.05875395f, -0.11056359f, 0.07304867f, -0.08402489f, -0.13944030f, -0.03911904f, -0.01967742f, 
    -0.01570845f, 0.08391423f, 0.13889486f, 0.03338145f, -0.05872924f, -0.13509201f, 0.10874648f, 0.01261462f, 
    -0.09970132f, -0.39911342f, -0.08085535f, -0.11443938f, -0.04514981f, -0.08709861f, 0.11231662f, -0.03001101f, 
    0.00586176f, 0.00192696f, 0.25766948f, 0.03138115f, 0.26920092f, 0.06592519f, -0.11532872f, -0.24015281f, 
    0.01867457f, -0.04433098f, -0.13454162f, -0.04267261f, -0.31032690f, -0.01283740f, 0.01016292f, -0.01819820f, 
    -0.18253508f, -0.13663800f, -0.14131446f, 0.05571923f, -0.17001365f, -0.13904843f, -0.04865098f, -0.10181917f, 
    -0.02247652f, -0.02601237f, -0.01372898f, -0.06194505f, -0.12561882f, -0.09614918f, 0.03999808f, -0.07375767f, 
    0.18765225f, -0.20800741f, 0.07903054f, 0.01848358f, 0.12503627f, -0.00026980f, -0.00989569f, -0.01813520f, 
    -0.01131379f, 0.06685911f, -0.00311513f, 0.09191411f, 0.05457132f, 0.00477202f, -0.12191883f, 0.01708573f, 
    -0.07950769f, 0.09493188f, 0.07874289f, -0.06489238f, -0.03540790f, 0.23332249f, -0.13516448f, 0.26942191f, 
    -0.10160892f, 0.18747732f, -0.08472163f, 0.09044810f, 0.04370066f, -0.09791593f, -0.07835836f, -0.11958303f, 
    -0.01572726f, 0.07551417f, -0.04000555f, 0.12491406f, 0.12308260f, 0.13038667f, 0.10273094f, 0.09012932f, 
    -0.12403841f, 0.45521739f, 0.05927135f, 0.04554517f, -0.01184941f, 0.12580058f, -0.00339817f, -0.09954181f, 
    0.08263231f, 0.12288108f, -0.08418658f, 0.11101075f, 0.08914702f, 0.07784205f, 0.03309586f, 0.17347734f, 
    -0.17041026f, 0.02721274f, -0.02368668f, -0.00918921f, 0.29046860f, -0.22983927f, -0.05187594f, -0.15373969f, 
    0.22749136f, -0.11015181f, -0.04209214f, -0.13094696f, -0.09567493f, -0.11173064f, -0.11407813f, -0.03518071f, 
    0.02943789f, -0.06289182f, -0.06313445f, 0.01910395f, -0.01864509f, 0.04225551f, 0.12719108f, -0.03277615f, 
    0.79967773f, -0.23708917f, 0.20414758f, 0.04380285f, 0.30412376f, -0.05836063f, 0.07823154f, 0.12596688f, 
    0.35566479f, 0.16453499f, -0.01261067f, 0.08974478f, 0.05451267f, 0.08401193f, -0.08010930f, -0.01060127f, 
    0.10810345f, 0.00831411f, 0.18126340f, 0.15058726f, -0.13043135f, 0.02188058f, 0.09960885f, 0.09623798f, 
    0.09367295f, -0.15854324f, 0.12257598f, -0.05953982f, 0.08557926f, 0.13285482f, 0.03825871f, 0.08628638f, 
    -0.08024871f, -0.02780840f, -0.08697983f, -0.00928086f, 0.02894025f, 0.06082131f, -0.14568532f, 0.04635545f, 
    -0.02112968f, -0.14430542f, -0.27287325f, 0.09936147f, -0.09056563f, -0.20561570f, 0.02308720f, -0.09839247f, 
    -0.06899071f, -0.01650961f, -0.13146353f, -0.02414467f, 0.06381714f, 0.17489237f, 0.08042608f, 0.02730895f, 
    0.14217791f, 0.06255196f, -0.05284194f, -0.06301161f, -0.55625522f, -0.20035383f, 0.19263624f, 0.37851727f, 
    0.07175518f, 0.13953386f, -0.17171863f, 0.15737240f, -0.01771603f, 0.05433583f, -0.00356440f, -0.00563011f, 
    0.02135667f, 0.01276442f, 0.07925586f, -0.14032680f, 0.01648052f, -0.02020844f, 0.03923438f, 0.13462025f, 
    0.59817308f, -0.27668864f, 0.10776148f, 0.11593964f, 0.09512793f, 0.01529206f, 0.11618215f, -0.07296151f, 
    0.09541996f, -0.19997342f, 0.05629747f, -0.00171419f, -0.02054798f, 0.02291491f, -0.06950632f, 0.01218791f, 
    -0.02585980f, 0.09794120f, 0.09140323f, 0.01981849f, -0.18213874f, 0.45472503f, -0.23431531f, 0.15310653f, 
    -0.35631946f, 0.12800893f, 0.08974261f, -0.16898641f, -0.04422699f, -0.09283566f, 0.03278371f, 0.03411955f, 
    -0.02904399f, -0.10570738f, 0.03305653f, 0.22562593f, 0.00384502f, -0.03449752f, 0.10263161f, -0.11144666f, 
    -0.47082931f, -0.15149538f, 0.18534686f, 0.03424737f, 0.34889945f, 0.16702174f, -0.01242638f, 0.18811484f, 
    0.14195739f, -0.09625902f, 0.08033938f, 0.07275585f, -0.08381122f, 0.05930557f, 0.07091046f, 0.07671367f, 
    -0.01066687f, 0.09290441f, 0.10096458f, 0.17466581f, 0.01916975f, 0.02726282f, 0.08256224f, 0.23572572f, 
    -0.04824633f, -0.06726139f, 0.18680908f, 0.00995941f, 0.11395963f, -0.02920917f, -0.05186251f, 0.02408442f, 
    -0.00860333f, 0.07708324f, 0.05112305f, 0.00067604f, 0.10268394f, 0.02524569f, 0.10235465f, 0.01607282f, 
    0.22545880f, -0.48746151f, -0.03716838f, -0.15284598f, 0.09892247f, -0.15235542f, -0.02868000f, -0.21896720f, 
    0.02870672f, -0.05108440f, -0.16074127f, 0.03328762f, -0.07007625f, -0.12358326f, 0.00822993f, 0.01817846f, 
    -0.10797926f, 0.00670746f, -0.04422043f, 0.03797442f, -0.11195129f, 0.02237903f, -0.10584698f, 0.23485914f, 
    0.06448308f, -0.08876580f, -0.02558515f, 0.03111240f, -0.16846062f, -0.25080913f, -0.06077158f, 0.05227774f, 
    -0.06913053f, -0.02266771f, 0.09329800f, 0.03025962f, 0.00229670f, -0.02280992f, -0.00739106f, -0.04982597f, 
    -0.00209407f, 0.20018530f, 0.11784131f, -0.07507141f, 0.22605091f, -0.26102200f, 0.14530414f, -0.13449776f, 
    0.12238868f, 0.13768621f, 0.16786441f, -0.15612037f, 0.05967933f, -0.07314774f, -0.04568755f, -0.16242167f, 
    -0.12423382f, 0.00064715f, -0.09229084f, -0.02121631f, -0.30955237f, 0.02768195f, 0.03026606f, 0.13980356f, 
    0.20714177f, 0.00602899f, -0.01333013f, -0.05611854f, -0.14845838f, -0.04698199f, -0.15929790f, -0.03679684f, 
    -0.03001596f, -0.05172658f, -0.04656931f, -0.02220501f, -0.03845078f, -0.00208918f, -0.01476051f, -0.09290874f, 
    0.05014756f, 0.07566915f, 0.01323912f, -0.10014071f, -0.05773921f, -0.08617503f, -0.05429154f, 0.00978748f, 
    0.01939849f, -0.04241630f, 0.01243238f, -0.01038576f, 0.07428720f, -0.10767427f, 0.09277033f, 0.03238612f, 
    -0.11347636f, 0.04873460f, -0.04206407f, 0.07300954f, 0.03817227f, -0.17721951f, 0.16841654f, -0.21696845f, 
    0.02098080f, 0.08787577f, 0.13060038f, 0.06419607f, -0.09230039f, 0.17288710f, 0.08249874f, -0.02070273f, 
    -0.00441719f, -0.12185834f, 0.00440114f, -0.02046625f, -0.04818835f, -0.02138734f, -0.06781496f, -0.02225811f, 
    -0.32092059f, 0.13593255f, 0.10942398f, -0.23299813f, 0.11450578f, -0.02589342f, -0.06557842f, -0.13645582f, 
    -0.01655584f, 0.04053978f, -0.04476085f, 0.24778588f, 0.01189074f, 0.18379474f, 0.16954522f, 0.02031470f, 
    -0.00629397f, 0.04864742f, 0.07158740f, 0.03078530f, -0.04969444f, 0.20035990f, -0.24725480f, -0.08890882f, 
    0.07347053f, 0.03656445f, -0.01004733f, -0.05653140f, -0.03975377f, -0.01562044f, 0.06319533f, -0.01041239f, 
    0.05155837f, -0.04188128f, 0.03284081f, -0.09647194f, 0.10758286f, 0.16295367f, -0.05008367f, -0.01512319f, 
    0.68151402f, 0.22357997f, -0.21904911f, 0.06900867f, 0.23731405f, -0.14101107f, 0.07886811f, 0.05324121f, 
    0.23453347f, 0.01019147f, 0.08718836f, -0.02456328f, 0.04397672f, -0.05095291f, 0.15560012f, 0.03695972f, 
    0.17362572f, -0.00550019f, 0.09094156f, 0.09505491f, 0.06418571f, 0.06455936f, 0.17022201f, -0.00176942f, 
    0.04123054f, -0.08299977f, -0.04150715f, -0.14617763f, 0.12785715f, 0.05375119f, 0.03766262f, 0.06292909f, 
    -0.01732603f, -0.04473306f, -0.04651631f, -0.04639597f, -0.03617515f, -0.04982558f, -0.05659947f, -0.04613634f, 
    -0.13824645f, -0.03795281f, -0.16935419f, -0.19735114f, -0.16127186f, 0.00637967f, 0.00858416f, -0.07548986f, 
    -0.09705749f, -0.02508188f, 0.03386894f, 0.01449741f, 0.00681888f, 0.03755593f, 0.03159014f, 0.18527842f, 
    0.02207447f, -0.05770066f, -0.04690857f, 0.01442018f, 0.01756539f, -0.42189217f, 0.18429802f, 0.10618725f, 
    -0.25924382f, -0.05635056f, 0.10625985f, -0.07478411f, -0.11197679f, 0.03688226f, -0.02331286f, 0.03284001f, 
    -0.01067999f, -0.07011369f, 0.04150577f, 0.06116268f, -0.04922735f, -0.04961827f, 0.15150134f, 0.14447817f, 
    0.02507191f, 0.09019312f, 0.14205755f, 0.02943289f, 0.39082706f, -0.01531158f, 0.13803425f, 0.18589774f, 
    0.16524939f, 0.01975847f, 0.04404146f, 0.00794246f, 0.00848526f, -0.02390234f, -0.00365443f, 0.15304224f, 
    -0.01833169f, 0.10383360f, 0.05242755f, -0.03265240f, -0.43696111f, 0.06347489f, 0.44491532f, -0.35624751f, 
    0.06945043f, 0.02062450f, 0.04902413f, -0.02677775f, -0.04520974f, -0.06155640f, 0.09467355f, -0.09091622f, 
    0.15505803f, 0.02172917f, 0.03493473f, 0.07990163f, 0.07470768f, 0.00367887f, 0.05177469f, -0.07626274f, 
    -0.00834261f, -0.14914423f, 0.13017640f, 0.09454140f, 0.10975005f, 0.08533221f, 0.16819160f, 0.19645375f, 
    0.04843334f, -0.03550864f, 0.12468903f, -0.07230799f, 0.05006769f, -0.06244871f, -0.00488510f, 0.03857218f, 
    0.01669101f, 0.01559104f, 0.12224869f, 0.17107403f, 0.23858930f, -0.19926752f, 0.02751764f, 0.19986804f, 
    0.05064051f, 0.11806285f, 0.02145880f, 0.11726733f, 0.11770759f, 0.04314860f, 0.08035231f, 0.00419686f, 
    -0.07938050f, 0.10394339f, 0.03585083f, 0.09654120f, 0.14255679f, 0.05723717f, 0.17829482f, 0.15000480f, 
    -0.22193250f, -0.17607294f, -0.15796661f, 0.05257269f, 0.00162225f, -0.04333268f, 0.02641399f, 0.00280975f, 
    -0.03397661f, 0.07003544f, 0.00397627f, -0.07653253f, -0.05220208f, -0.03262653f, 0.00795460f, -0.08739328f, 
    -0.04336040f, 0.19725017f, -0.08453389f, 0.13068694f, -0.17160299f, -0.25515756f, -0.04329157f, 0.21732770f, 
    -0.24956909f, -0.07787316f, 0.09159604f, 0.09197833f, 0.06800134f, -0.11859860f, 0.04779494f, -0.04868649f, 
    0.01373127f, 0.07204637f, -0.08552942f, -0.05663178f, -0.02497390f, -0.01882056f, 0.26059258f, 0.00439838f, 
    -0.17836747f, 0.09953367f, 0.06607406f, -0.13742384f, 0.16651709f, -0.08566154f, -0.09498370f, -0.04763781f, 
    0.00860074f, -0.01063488f, -0.01244433f, -0.02641639f, 0.06034203f, 0.04528796f, 0.01280710f, 0.00551053f, 
    -0.00354223f, -0.06322718f, -0.07514244f, -0.05091968f, -0.39459780f, -0.25028226f, -0.18908425f, 0.07924679f, 
    0.10652126f, -0.04700223f, -0.05846399f, -0.07906650f, 0.01114763f, -0.02379110f, -0.03952106f, -0.00463987f, 
    -0.03630481f, 0.15637521f, -0.04008367f, -0.16415000f, 0.02962055f, 0.17724353f, 0.09598289f, -0.00739402f, 
    0.05940823f, 0.01960990f, -0.01679974f, -0.12852244f, -0.15365444f, 0.10151172f, -0.11525814f, -0.00601425f, 
    -0.02175282f, 0.03874923f, 0.03493109f, -0.04429948f, 0.10617059f, -0.01698273f, 0.01175793f, 0.01842395f, 
    -0.06220280f, 0.09920093f, -0.20320404f, 0.03761836f, 0.19625087f, -0.27735370f, -0.37766746f, -0.01681386f, 
    0.07116888f, 0.16331148f, 0.00854658f, 0.10749431f, 0.12785167f, 0.01473937f, -0.06987383f, -0.11399345f, 
    -0.08803070f, -0.07191864f, 0.11237293f, -0.12507464f, -0.25988668f, -0.10497293f, -0.19370320f, 0.12340045f, 
    0.07333449f, 0.16321409f, 0.15972862f, -0.11499427f, 0.08942003f, -0.09081630f, -0.20486522f, -0.20674303f, 
    0.17685772f, 0.13878185f, 0.01315046f, 0.08807206f, 0.07291216f, 0.03960006f, 0.08610262f, -0.07499259f, 
    0.07800664f, -0.01087217f, 0.00544348f, 0.03190989f, -0.22264408f, 0.09345932f, -0.20241517f, -0.22668298f, 
    0.08009337f, -0.03794264f, -0.03634448f, -0.07467870f, 0.04175287f, 0.03256648f, 0.13984002f, 0.00400130f, 
    0.00322820f, 0.02639874f, 0.04680645f, 0.07018264f, 0.18313596f, 0.13925692f, -0.01621955f, 0.10330039f, 
    0.10646961f, 0.29832006f, -0.09230014f, -0.07377034f, -0.20053242f, -0.14434250f, -0.03282523f, 0.13420591f, 
    0.00427463f, -0.11535906f, 0.05109587f, 0.15076692f, 0.07723346f, 0.05737485f, 0.12972394f, 0.06825017f, 
    -0.00132163f, -0.04123849f, 0.04603837f, -0.15851335f, 0.18008028f, 0.49155825f, 0.41355693f, 0.04920357f, 
    0.12062227f, -0.01656347f, 0.02689941f, -0.04487289f, 0.04318821f, 0.11271265f, 0.06574132f, -0.04463270f, 
    -0.06723441f, -0.01036227f, 0.04640771f, 0.02420679f, -0.10940524f, -0.19462049f, -0.04942473f, -0.07827352f, 
    -0.15170874f, -0.26738074f, -0.38642088f, -0.25733393f, -0.02087323f, 0.02718710f, -0.01875907f, -0.09951349f, 
    -0.22056031f, 0.11839342f, 0.04752090f, 0.00204459f, 0.14048292f, -0.04359634f, -0.01959349f, 0.13928387f, 
    -0.04775273f, -0.19148017f, -0.02577952f, -0.01017495f, -0.06278657f, 0.23782724f, 0.03093345f, 0.18571234f, 
    -0.06057560f, -0.09073036f, 0.05946339f, 0.01758180f, -0.27304262f, 0.05034462f, -0.03056039f, 0.08377722f, 
    -0.14403729f, -0.02166844f, -0.02616559f, 0.08181272f, -0.06467860f, 0.02814092f, 0.09562345f, 0.00577760f, 
    -0.09489650f, 0.20638171f, -0.35891935f, -0.10056403f, -0.01403716f, -0.01188435f, 0.11355954f, 0.14666784f, 
    0.07127063f, 0.09498319f, -0.03607550f, 0.00601684f, 0.01753038f, -0.05473719f, 0.03481031f, 0.09286936f, 
    0.04388229f, 0.15624696f, 0.02868456f, 0.12755404f, -0.05700374f, 0.00406088f, 0.03900877f, -0.28720051f, 
    -0.12948677f, -0.01781437f, -0.10884462f, -0.18073504f, 0.08901938f, -0.00052013f, 0.00183544f, 0.13635407f, 
    0.07024694f, 0.14893691f, -0.01584293f, -0.08265635f, 0.14798914f, 0.00600644f, 0.09502085f, 0.25141418f, 
    -0.11419504f, 0.29619995f, -0.18461859f, 0.22758833f, 0.18899876f, 0.10204892f, 0.17900836f, 0.27627108f, 
    0.10403319f, 0.10585245f, 0.11713558f, 0.01776220f, 0.02571985f, -0.05170670f, 0.08310379f, -0.04713888f, 
    -0.06366792f, 0.16448790f, -0.01194655f, -0.01300673f, -0.11719360f, -0.00512299f, 0.11324716f, -0.11552513f, 
    -0.02093608f, -0.08280149f, 0.09613495f, 0.12889932f, 0.03684733f, -0.06206540f, -0.07737479f, -0.01719902f, 
    0.03319826f, 0.07743505f, 0.10676537f, 0.04879754f, 0.16339129f, 0.03495347f, 0.10347287f, 0.24882714f, 
    -0.17233047f, -0.03259942f, -0.58056712f, 0.02518914f, 0.30521831f, -0.12624890f, 0.14023636f, 0.00512965f, 
    -0.04505973f, 0.07218859f, 0.03871496f, -0.02474685f, 0.02953224f, -0.06043453f, 0.03961159f, 0.03906828f, 
    0.02644776f, -0.02250326f, 0.07377481f, 0.12869672f, -0.02839777f, 0.12712960f, 0.29887792f, 0.03128287f, 
    0.01809436f, 0.03512738f, 0.16273412f, 0.05009408f, -0.06447507f, -0.05380499f, 0.02357816f, 0.00904147f, 
    -0.00850984f, 0.04296762f, 0.00193121f, 0.04151875f, 0.07074918f, -0.07781733f, 0.28218246f, -0.01272013f, 
    0.06670605f, 0.53334218f, 0.51017284f, -0.13113169f, 0.14905289f, -0.15399982f, -0.22386502f, -0.21879850f, 
    0.00375966f, 0.07461395f, -0.02472944f, -0.19704106f, -0.03314984f, -0.07216707f, -0.09815633f, 0.03025152f, 
    -0.07581378f, -0.18901059f, -0.00532389f, -0.08205406f, -0.14025104f, -0.02248026f, 0.05154723f, 0.15920861f, 
    0.10423093f, -0.07162065f, 0.06319794f, 0.02778261f, -0.03876099f, 0.09081444f, -0.07170936f, -0.03527370f, 
    -0.06920731f, 0.00748733f, -0.01572808f, 0.10176883f, 0.16978054f, 0.23146255f, 0.19505528f, 0.22850510f, 
    0.08703090f, -0.09220971f, 0.17733438f, -0.01290379f, 0.01005514f, 0.06397735f, 0.02559939f, 0.00675777f, 
    0.05787870f, -0.07354199f, 0.09195402f, 0.12398714f, -0.01719781f, 0.12717631f, 0.10954717f, -0.00944477f, 
    0.09729822f, -0.03721903f, 0.05665241f, -0.07376689f, 0.04627687f, 0.13625836f, -0.26445273f, 0.23775969f, 
    -0.21698244f, 0.17045936f, -0.11875927f, 0.15469705f, 0.13066648f, 0.00299722f, -0.15426517f, 0.04118944f, 
    -0.13718568f, 0.07653561f, 0.08113947f, 0.07355653f, -0.11350425f, 0.12919284f, 0.07216067f, 0.01636385f, 
    0.21538745f, 0.21735343f, 0.47518483f, 0.25291571f, -0.02024550f, 0.03758265f, 0.06148053f, -0.09303291f, 
    0.10950980f, -0.11640756f, 0.12317552f, -0.09646817f, 0.20857932f, -0.01466202f, 0.06038897f, 0.06059981f, 
    0.07353568f, -0.00531775f, -0.02975490f, -0.01540588f, 0.04282844f, -0.18564807f, -0.05828813f, -0.11573792f, 
    0.21528918f, -0.08947004f, 0.06730463f, 0.09332463f, -0.01196889f, -0.09370764f, -0.03869325f, -0.05222977f, 
    -0.05736595f, 0.04318278f, -0.03007648f, 0.20367922f, -0.01847308f, -0.06228361f, 0.06472966f, 0.03483589f, 
    -0.52778411f, 0.02028320f, 0.12641080f, 0.10676682f, -0.11066213f, 0.21044260f, -0.03903351f, 0.19597858f, 
    -0.09852045f, 0.11889457f, 0.00607244f, 0.19471677f, -0.00743305f, 0.06806187f, 0.02542795f, 0.01899956f, 
    0.02992440f, 0.08123162f, 0.09968811f, 0.13607061f, -0.20977184f, 0.04476467f, 0.11683527f, -0.00999351f, 
    -0.05685275f, -0.07394697f, -0.06603800f, -0.11216462f, 0.02947591f, -0.05231913f, 0.02553507f, 0.04881614f, 
    0.03609464f, 0.02811659f, -0.04200872f, 0.01563388f, -0.06865252f, 0.00553221f, 0.06670693f, -0.07240548f, 
    0.17589906f, 0.07665136f, 0.02555628f, 0.12866396f, 0.05082484f, -0.08269648f, -0.04345015f, 0.01685886f, 
    -0.06140890f, -0.11718673f, -0.04266068f, -0.09831604f, -0.06898786f, 0.11140641f, -0.05633191f, 0.04801888f, 
    0.04309541f, 0.10110468f, -0.05360837f, -0.08483960f, -0.27183205f, -0.04171320f, -0.26175678f, 0.32310548f, 
    0.32999167f, 0.06655214f, 0.02220865f, 0.14135085f, 0.09016505f, 0.03027726f, -0.08680667f, -0.02096957f, 
    0.06751174f, 0.00809159f, -0.07620467f, 0.06987709f, -0.04842372f, 0.07805987f, -0.01066996f, -0.07257115f, 
    -0.00311271f, -0.15072477f, 0.12154193f, -0.09450323f, -0.12484812f, 0.06940454f, -0.01250640f, 0.07516406f, 
    0.04030853f, 0.05555859f, -0.05888177f, -0.03250822f, -0.02701110f, 0.05153795f, 0.05323878f, -0.02390475f, 
    0.09881322f, 0.03141921f, 0.01545898f, 0.12144998f, 0.25002560f, 0.09221175f, -0.19862136f, 0.30178466f, 
    -0.18053624f, 0.03188115f, 0.02202102f, -0.08060048f, 0.04546021f, 0.02999535f, -0.15910082f, 0.13123138f, 
    -0.10342935f, 0.05661694f, 0.05175536f, 0.11361700f, 0.13832450f, 0.04948177f, 0.04718346f, 0.14894648f, 
    -0.16855329f, -0.38751152f, -0.16925885f, -0.01223792f, -0.00888033f, 0.05279512f, -0.06874534f, 0.05347436f, 
    0.03134781f, 0.16600923f, -0.05214113f, -0.00608395f, 0.09496487f, 0.17238216f, -0.04638143f, 0.03427505f, 
    -0.00648109f, 0.00255657f, 0.06440295f, -0.04500898f, -0.35110292f, 0.08765060f, -0.24694525f, 0.05704329f, 
    0.06641805f, 0.00605440f, 0.07331157f, 0.07436957f, 0.18106857f, -0.01653575f, -0.08877247f, 0.05700726f, 
    0.06279345f, -0.02096007f, 0.09851636f, 0.05426646f, -0.01049690f, 0.09380167f, -0.03949448f, 0.04862828f, 
    0.16085778f, -0.27437964f, -0.21109971f, 0.05029620f, 0.17254010f, -0.12444822f, -0.01694245f, 0.06308528f, 
    -0.05795689f, -0.15955594f, -0.06243365f, -0.02557479f, -0.04781768f, -0.05556617f, -0.06320444f, 0.05313012f, 
    0.09019812f, -0.11831512f, 0.01561185f, -0.04405867f, -0.33835584f, 0.00089990f, -0.26471886f, 0.12067135f, 
    0.13259517f, -0.00179476f, -0.27882659f, -0.08129407f, 0.05797327f, 0.01182002f, -0.04909442f, 0.09492974f, 
    0.07074612f, -0.04644075f, -0.05241537f, 0.03781953f, 0.04152237f, 0.09040647f, -0.23235020f, -0.01903234f, 
    0.17795072f, 0.19986497f, 0.33817944f, 0.02192022f, -0.22053291f, -0.08987166f, -0.11161157f, -0.09700592f, 
    -0.00060607f, -0.07842512f, 0.10483587f, -0.00460529f, -0.01774403f, 0.06577282f, 0.06505280f, -0.13019337f, 
    -0.08560363f, -0.08087585f, 0.03317327f, -0.03608074f, -0.14869379f, 0.03808781f, 0.16175924f, 0.47250125f, 
    0.00806293f, 0.00202207f, -0.09163930f, -0.02208503f, 0.04270971f, -0.05855336f, 0.01090053f, -0.00651805f, 
    0.01103413f, -0.18187223f, 0.03420027f, 0.21971047f, 0.01703267f, 0.07110507f, 0.03882225f, 0.09190331f, 
    0.10206043f, -0.06331392f, 0.13145205f, -0.04451557f, -0.02870700f, -0.00151085f, 0.08655389f, 0.01713035f, 
    0.00621396f, -0.04703050f, 0.03480866f, 0.07823266f, 0.08498431f, 0.18905938f, 0.24459337f, -0.05767604f, 
    0.11599100f, -0.11176387f, -0.00415684f, -0.06711200f, -0.02087209f, 0.19268794f, -0.01372817f, 0.10841440f, 
    -0.31524250f, 0.13611650f, -0.25763732f, 0.04018680f, 0.08712417f, 0.03473932f, -0.18231545f, 0.07367593f, 
    -0.11044835f, 0.04585633f, 0.08069115f, -0.00572232f, -0.23121642f, 0.01540797f, 0.13840854f, -0.07135706f, 
    0.04385281f, -0.09340672f, 0.60115206f, 0.31543452f, -0.10487701f, -0.01518329f, 0.11222154f, -0.01079904f, 
    0.06424978f, -0.09813858f, 0.00279365f, -0.13685890f, 0.16594186f, 0.04541047f, 0.05145314f, 0.09990781f, 
    0.03327309f, -0.06023849f, -0.05167207f, -0.09100708f, -0.05230744f, 0.00887363f, -0.02455113f, -0.11231332f, 
    -0.04331067f, 0.02470241f, 0.02534961f, 0.06755923f, 0.03178939f, 0.00103666f, -0.01362614f, -0.02730253f, 
    -0.06748282f, -0.09074204f, -0.01590113f, 0.26514375f, 0.03638720f, 0.04617607f, 0.10038555f, 0.06493347f, 
    -0.42694628f, -0.22065140f, 0.24913883f, 0.02495229f, -0.05170254f, 0.25148752f, 0.03757038f, 0.03846080f, 
    0.04900577f, 0.05145230f, -0.01222751f, 0.15384126f, -0.00764334f, 0.08802038f, 0.07039955f, -0.01271004f, 
    0.00847356f, 0.01915663f, 0.20345834f, 0.05977303f, -0.06831291f, -0.06282608f, 0.02466857f, 0.13909434f, 
    0.05078659f, -0.04959615f, -0.09628086f, -0.10180558f, -0.00308176f, -0.02072302f, 0.07232941f, 0.08863687f, 
    0.06230365f, 0.04604472f, 0.02180204f, 0.03419059f, -0.06276772f, 0.02290146f, 0.00002267f, -0.19615096f, 
    0.06036681f, 0.00266127f, -0.09538398f, -0.09417570f, -0.06320032f, -0.05875820f, -0.02961091f, 0.02669415f, 
    -0.02716086f, -0.06012115f, -0.13606483f, -0.12704609f, -0.34042758f, 0.02487064f, -0.08311737f, 0.09994726f, 
    -0.07156549f, 0.06026199f, -0.09505959f, -0.04722388f, 0.07907159f, -0.02847144f, -0.36236376f, 0.41134492f, 
    0.22534420f, 0.08661033f, 0.00269304f, 0.10375234f, 0.04536625f, 0.05275365f, -0.26189417f, 0.06807016f, 
    0.02707272f, -0.05459201f, -0.07787147f, 0.04437180f, 0.00395965f, 0.08273063f, -0.05370371f, -0.15197982f, 
    -0.17895959f, -0.16696487f, 0.36604887f, 0.09002543f, -0.13202558f, 0.06252470f, -0.04032581f, -0.00672108f, 
    -0.00633148f, 0.16641878f, -0.06901163f, -0.00229963f, 0.00403696f, 0.02875280f, -0.01933558f, 0.05756661f, 
    -0.00332770f, 0.01802596f, 0.06726241f, 0.16475254f, 0.08982451f, -0.06754328f, -0.03644865f, 0.38308150f, 
    -0.09076276f, -0.05334859f, -0.06234644f, -0.01160257f, 0.01987640f, 0.00920049f, -0.04789781f, 0.06699423f, 
    0.00974944f, 0.12264156f, -0.10291906f, 0.08516832f, 0.08955076f, -0.02774709f, 0.02548737f, 0.07095225f, 
    0.18656938f, -0.25429931f, -0.13841899f, 0.14943872f, -0.02564452f, 0.14512549f, -0.13965453f, -0.08318647f, 
    0.07523810f, 0.21031478f, 0.02521883f, 0.09902448f, 0.03064212f, 0.07988892f, -0.02711072f, 0.05389174f, 
    -0.07330200f, -0.14902356f, 0.09528893f, 0.00207606f, -0.12819891f, 0.07771160f, -0.16841422f, 0.08602744f, 
    0.10947339f, 0.06969259f, 0.00438239f, 0.01378304f, 0.15078939f, 0.07646716f, 0.00152925f, 0.04523735f, 
    0.12960453f, -0.00371401f, 0.05179031f, 0.13936077f, 0.11081681f, 0.21960461f, 0.11476627f, 0.04270169f, 
    0.24480067f, -0.10264128f, 0.11281404f, 0.12093245f, -0.07512000f, -0.12292445f, -0.08855289f, -0.03228014f, 
    -0.10367106f, -0.14573851f, -0.06755684f, -0.03679132f, 0.01051360f, -0.00262525f, -0.09090605f, -0.02733986f, 
    0.20887205f, -0.08225504f, -0.02387991f, 0.04752463f, -0.25536788f, -0.11136970f, -0.19440496f, 0.03876222f, 
    0.03751160f, -0.13153361f, -0.31981248f, 0.00303026f, 0.08951610f, 0.11772646f, -0.03399035f, 0.02908188f, 
    -0.04029326f, -0.00228231f, -0.06279979f, 0.06276351f, -0.01476428f, 0.05998602f, -0.06760883f, -0.04765220f, 
    0.01046461f, 0.01521860f, 0.30969977f, 0.09936942f, -0.08188284f, -0.17333268f, -0.05776364f, 0.00673935f, 
    -0.10483789f, -0.10778118f, 0.07748794f, -0.06778166f, 0.01967408f, 0.11889385f, 0.11201081f, -0.09260555f, 
    -0.06020740f, -0.12310383f, 0.03144137f, -0.14318675f, -0.10346802f, -0.18929434f, 0.14904146f, 0.33740225f, 
    0.00560770f, -0.08841438f, -0.01643744f, -0.02475659f, 0.12604141f, 0.00171352f, -0.01059359f, 0.03955864f, 
    -0.02172735f, -0.01736695f, 0.06150435f, 0.11979111f, 0.06926520f, 0.08864386f, 0.00242494f, 0.18918006f, 
    -0.00893884f, -0.02402594f, 0.02841665f, -0.02591981f, -0.02443449f, -0.01848520f, -0.06376060f, 0.03361272f, 
    -0.01204989f, -0.00170424f, -0.01061788f, -0.04065483f, -0.00384705f, 0.00122007f, -0.03834796f, 0.04222270f, 
    -0.02312701f, 0.02225885f, -0.01617609f, 0.00498426f, 0.03951573f, 0.00918083f, 0.03787480f, 0.01125730f, 
    0.01306426f, -0.01637898f, -0.00076754f, -0.05520502f, 0.00678530f, 0.03422268f, 0.00908247f, 0.02403426f, 
    0.04142304f, -0.03088800f, -0.04267318f, -0.04542983f, 0.04188265f, 0.04376465f, 0.02560998f, 0.01761163f, 
    -0.04914498f, -0.02756716f, -0.01293958f, -0.05702664f, -0.06539933f, -0.01121900f, 0.00206067f, 0.03340364f, 
    -0.01094130f, 0.01070320f, 0.01818112f, 0.03036272f, 0.01945021f, -0.02679123f, 0.00377895f, 0.01282016f, 
    -0.05567197f, 0.03997191f, -0.04913349f, -0.01404701f, 0.03638044f, 0.00802292f, 0.01262172f, 0.00979670f, 
    0.02415366f, 0.01371096f, 0.02447073f, -0.04573809f, -0.05802536f, -0.01340716f, 0.02705549f, 0.03239923f, 
    0.04233892f, -0.04167262f, -0.00738588f, 0.01965951f, -0.06399563f, -0.04304754f, -0.06063592f, -0.02126364f, 
    -0.06165290f, 0.02071792f, -0.06501929f, 0.00645697f, -0.02751307f, -0.00553553f, 0.04764855f, -0.01747698f, 
    -0.04259392f, 0.02978905f, -0.01680714f, -0.00339436f, 0.01435919f, -0.01469846f, -0.01965434f, -0.06357424f, 
    -0.04053676f, -0.01799891f, -0.00514739f, -0.01220227f, -0.03142507f, -0.00012063f, 0.03739758f, -0.01011188f, 
    -0.05299651f, 0.01801379f, 0.01548092f, -0.02011101f, 0.00307199f, 0.02468519f, -0.03678596f, 0.02728071f, 
    -0.04859721f, -0.05414702f, -0.00437273f, -0.00001403f, -0.06183008f, 0.01731031f, -0.03202803f, 0.04070020f, 
    -0.04860542f, 0.03305835f, 0.03245555f, 0.01113922f, -0.03543396f, 0.02038839f, 0.03626207f, -0.00861084f, 
    -0.00141078f, -0.00083152f, -0.04583114f, -0.00118697f, 0.03817808f, 0.04106344f, -0.06335945f, 0.02999022f, 
    0.02820242f, -0.04616946f, 0.01704264f, -0.02554129f, 0.01846074f, -0.01605919f, -0.00904536f, 0.01027096f, 
    0.00703095f, 0.03054337f, -0.01124967f, -0.06385943f, -0.03125932f, -0.04917801f, -0.03590342f, 0.01459902f, 
    -0.00864510f, 0.02259603f, 0.00609659f, 0.01726213f, -0.05691078f, 0.00618929f, -0.02333928f, -0.00570035f, 
    -0.00482840f, -0.00149641f, 0.01452477f, -0.05845298f, -0.00796633f, 0.03130776f, 0.01720510f, -0.01922197f, 
    -0.00455972f, -0.01665644f, 0.03594790f, 0.04491502f, 0.01973449f, -0.01475594f, 0.04252065f, -0.05012715f, 
    -0.05389769f, 0.02526584f, 0.00574271f, -0.04635502f, -0.05853596f, -0.01637245f, -0.05600045f, -0.05737990f, 
    -0.05760073f, -0.03608416f, -0.06281164f, 0.03765410f, -0.00576078f, -0.02131452f, -0.00328997f, -0.04243838f, 
    -0.02584695f, 0.00168274f, -0.00130118f, -0.04908136f, 0.01621820f, -0.00443636f, 0.02678538f, -0.05370467f, 
    -0.00446768f, -0.01768568f, -0.02502664f, 0.04462184f, 0.04056581f, 0.00479958f, 0.05086088f, -0.05369052f, 
    -0.04896108f, 0.04456746f, -0.02817122f, 0.02870918f, -0.01723843f, -0.02885204f, 0.00487944f, -0.02448740f, 
    -0.02307365f, 0.03310875f, -0.02674359f, -0.02146316f, -0.00897943f, 0.04351748f, 0.01302283f, -0.02392037f, 
    0.00327357f, -0.06391127f, 0.01602279f, -0.04030536f, -0.02247031f, -0.00571474f, -0.00515926f, 0.01773237f, 
    -0.01971678f, -0.02698758f, -0.03422425f, -0.01702605f, 0.02455426f, -0.05693724f, -0.04362660f, 0.01837796f, 
    0.01594697f, -0.00382629f, 0.04245586f, -0.03459472f, -0.04807026f, -0.01682822f, 0.05139121f, 0.03445652f, 
    -0.00538665f, -0.03734305f, -0.03280658f, -0.01143399f, -0.01948045f, -0.00101727f, -0.00777412f, 0.01924558f, 
    0.01549350f, 0.05186691f, -0.00102192f, 0.01455201f, 0.01208761f, -0.03733202f, -0.02728969f, 0.00923136f, 
    -0.03060218f, 0.04848129f, 0.02794622f, 0.02665727f, 0.01487711f, 0.04046137f, 0.04175158f, 0.02704806f, 
    -0.01300727f, 0.01296992f, 0.00841368f, 0.01916665f, -0.03814954f, -0.04675544f, 0.02956175f, 0.02168833f, 
    -0.05795860f, 0.01263001f, -0.05079325f, 0.01582889f, 0.00629182f, -0.00433993f, 0.02631431f, 0.02080571f, 
    -0.05123089f, -0.05019725f, -0.05721980f, 0.01403825f, -0.02701229f, 0.01116263f, -0.05506657f, 0.00006962f, 
    0.02649144f, -0.03624494f, -0.06332517f, -0.06447762f, -0.06006543f, 0.03369075f, -0.03887316f, -0.02895112f, 
    0.02252977f, -0.00773482f, -0.06200889f, -0.01546843f, 0.04366618f, 0.00962019f, -0.03574193f, 0.00436143f, 
    -0.06370807f, -0.05973816f, 0.01221917f, 0.04070623f, 0.00391827f, 0.03059536f, -0.02192303f, 0.03830317f, 
    0.07191417f, 0.15824722f, 0.22361250f, -0.00904042f, -0.02164069f, -0.01936930f, 0.01255429f, 0.04155912f, 
    0.04840826f, -0.10547477f, 0.06928945f, -0.00000056f, 0.15924436f, 0.06281833f, 0.01604529f, 0.12572962f, 
    0.03550469f, -0.03250112f, -0.20908086f, 0.01415801f, 0.35050073f, -0.06055928f, 0.06888970f, 0.06795854f, 
    -0.15151866f, 0.24479601f, -0.10628604f, 0.03456863f, 0.23170686f, 0.07882050f, 0.02906571f, 0.02811250f, 
    -0.14473818f, -0.13457818f, 0.11278632f, 0.07163137f, -0.12822546f, 0.00138404f, 0.16481480f, 0.02638412f, 
    0.11944488f, -0.12384830f, 0.31791717f, 0.15270157f, -0.14378305f, 0.01130385f, 0.05764296f, -0.07051717f, 
    0.13061711f, -0.09630116f, 0.06512777f, -0.01603900f, 0.08490898f, 0.04057610f, 0.06761274f, 0.13816616f, 
    -0.02586147f, -0.08930005f, 0.05443715f, 0.06894970f, -0.01664448f, 0.13926117f, -0.28227940f, -0.03238348f, 
    0.13361049f, 0.02140033f, -0.00206721f, 0.08033590f, -0.02146319f, -0.03109436f, 0.03407846f, 0.04314590f, 
    -0.03305621f, 0.09399592f, -0.05389801f, 0.13313994f, 0.03323130f, 0.07179128f, -0.03802609f, 0.21566163f, 
    -0.32119021f, 0.14955547f, 0.13332897f, -0.13012406f, -0.25620797f, 0.02604785f, -0.12016816f, 0.08394135f, 
    0.14128838f, -0.07445072f, 0.08216492f, 0.20528470f, -0.00977719f, 0.04172380f, -0.05464890f, -0.13282670f, 
    0.05235673f, 0.13637266f, -0.06762797f, 0.06472708f, -0.12431028f, -0.08796726f, 0.13607627f, -0.01917952f, 
    -0.12062632f, 0.01440929f, -0.03611564f, -0.08765592f, -0.01775513f, 0.06722844f, 0.06996750f, -0.05530126f, 
    0.11835622f, 0.02625275f, 0.07456684f, -0.02939567f, -0.08287995f, -0.01206193f, -0.03569913f, -0.06096398f, 
    0.32685411f, 0.19731030f, 0.17147233f, -0.01970303f, 0.04806699f, -0.05598508f, -0.09712721f, 0.01303915f, 
    -0.05911599f, -0.14427340f, -0.02278769f, 0.02960944f, -0.10541510f, -0.05513280f, -0.14755419f, 0.02806968f, 
    -0.19815351f, 0.03480826f, 0.03776846f, 0.00714078f, -0.23236623f, -0.17322788f, -0.04727451f, 0.32647276f, 
    0.02035451f, -0.02981793f, 0.10913851f, 0.12568310f, -0.10203408f, 0.13150278f, -0.13940489f, -0.02433262f, 
    0.12266522f, 0.04366524f, 0.00194981f, -0.02046787f, -0.04726650f, 0.11987414f, -0.14441843f, -0.09655768f, 
    0.00901953f, 0.09875391f, -0.18897295f, -0.03698498f, 0.03000817f, 0.05303735f, -0.12723337f, 0.22016044f, 
    0.04779143f, -0.02288836f, 0.00030185f, 0.06731525f, 0.08881316f, -0.04075461f, 0.01916449f, -0.00737300f, 
    -0.00926542f, 0.02232709f, -0.00972485f, 0.09998132f, 0.26226509f, -0.15699409f, 0.01050801f, 0.10728110f, 
    0.18626806f, 0.04566418f, 0.07223192f, 0.06850532f, 0.04665988f, -0.02292218f, 0.01407314f, 0.08030475f, 
    0.01379557f, 0.05041099f, -0.04650876f, 0.11351057f, -0.02287577f, -0.00228906f, 0.05704328f, 0.11524811f, 
    -0.23719993f, -0.25025487f, -0.11430418f, 0.36454761f, -0.06832299f, -0.04501283f, -0.02377347f, 0.16940491f, 
    -0.05656588f, 0.29312938f, -0.05507725f, -0.01282599f, 0.12547821f, 0.11147239f, 0.05831987f, 0.08763061f, 
    -0.05407487f, -0.04698554f, -0.07242595f, -0.05263991f, -0.28952205f, -0.07594402f, -0.19322136f, 0.06566920f, 
    0.13479939f, -0.00858699f, 0.09414449f, 0.06609042f, 0.10906448f, 0.00590977f, 0.04559986f, 0.04023148f, 
    0.04498666f, 0.09217916f, 0.06969775f, 0.00379787f, 0.03034864f, 0.09815134f, 0.08523859f, 0.07848710f, 
    0.51650602f, 0.13885304f, -0.49904221f, 0.09359175f, 0.04271646f, -0.07559109f, 0.02043870f, 0.11091634f, 
    -0.06847627f, -0.08864242f, -0.00764299f, -0.01181978f, 0.02158667f, -0.03523250f, 0.01497955f, -0.00832815f, 
    0.11942867f, -0.10316085f, 0.04847931f, 0.14786138f, -0.18856904f, -0.02809071f, 0.07732063f, 0.21813320f, 
    0.11392914f, -0.13073294f, -0.18093993f, -0.05607109f, 0.05371599f, 0.24228913f, 0.04508511f, 0.06462825f, 
    0.02394497f, -0.02895404f, -0.01631196f, 0.07757448f, 0.08091187f, 0.04626061f, 0.06597853f, -0.07848231f, 
    0.08080865f, -0.01315741f, 0.23320796f, -0.06130542f, -0.19877671f, -0.12285991f, -0.13591513f, -0.05188934f, 
    -0.04983186f, -0.05451925f, 0.00117208f, -0.21672510f, 0.02999029f, 0.02953379f, 0.09961163f, -0.00070044f, 
    -0.02973586f, -0.02472811f, -0.04289658f, -0.05569545f, -0.24499716f, -0.19618127f, -0.02163669f, 0.21326280f, 
    -0.15595827f, -0.03996554f, -0.05874710f, -0.02049997f, -0.00764228f, 0.00906110f, 0.06655404f, 0.11307503f, 
    0.06490075f, -0.01528583f, -0.00120609f, 0.15544079f, 0.15767589f, 0.02138825f, 0.18037193f, 0.26108542f, 
    0.05379572f, -0.02285274f, -0.02440477f, -0.01365093f, 0.00000961f, 0.04338517f, -0.02768841f, 0.01410328f, 
    0.03421120f, -0.05616235f, -0.00903277f, -0.03827687f, -0.05210356f, -0.05334326f, 0.03913280f, 0.03685957f, 
    0.03924887f, 0.02110241f, -0.00128391f, -0.00362625f, 0.02866841f, 0.03477119f, -0.02700220f, -0.05273903f, 
    0.02744184f, 0.05827585f, 0.03609855f, -0.05171042f, -0.03184868f, -0.00460662f, 0.03322428f, -0.02595088f, 
    -0.02081818f, -0.02555392f, -0.04558979f, -0.01091730f, -0.03631930f, -0.02345433f, -0.04490545f, -0.02306023f, 
    0.00816750f, 0.03799245f, 0.04167499f, -0.04185324f, 0.00948606f, 0.00657928f, -0.00821936f, 0.01376231f, 
    -0.03472566f, 0.03716136f, -0.01824289f, 0.04373862f, -0.05293743f, -0.04544657f, -0.04165448f, 0.03418669f, 
    -0.02514489f, -0.05466349f, 0.00961563f, -0.02694039f, -0.01988388f, 0.04367143f, 0.00553734f, 0.05051023f, 
    0.01752894f, 0.04658498f, 0.00723286f, -0.05579199f, 0.02807310f, 0.04510800f, -0.05637843f, -0.02839554f, 
    -0.01325010f, 0.01092642f, -0.01513097f, 0.01947012f, -0.00493798f, -0.02264697f, -0.03349059f, 0.01055044f, 
    -0.04322753f, 0.00432529f, -0.01213474f, 0.01817767f, 0.02590794f, 0.01208775f, 0.04895529f, 0.02558437f, 
    -0.01760672f, -0.00274757f, -0.03568980f, -0.01705153f, -0.02411842f, 0.02571215f, -0.04590731f, -0.02331489f, 
    -0.00513747f, 0.03650060f, 0.00907757f, -0.04846456f, -0.05863245f, -0.04869135f, 0.00540709f, -0.04846611f, 
    -0.06241100f, -0.02313137f, 0.01692300f, -0.00538081f, 0.02331539f, -0.04715253f, -0.05170496f, 0.00596163f, 
    0.04520014f, 0.04931928f, -0.03948613f, 0.03155738f, -0.00646418f, 0.03684499f, 0.04543667f, -0.04939733f, 
    -0.00005729f, 0.02871300f, -0.02573992f, -0.01062584f, -0.03131298f, -0.05629404f, -0.04342998f, -0.02306633f, 
    0.00119285f, 0.01414546f, 0.01888003f, -0.02899885f, 0.00107107f, 0.00763869f, 0.01150430f, 0.03255060f, 
    0.05104940f, -0.03311016f, 0.00220998f, 0.05300546f, -0.05848163f, 0.01965455f, -0.02756050f, 0.01954503f, 
    -0.04121976f, -0.05384488f, 0.01294555f, -0.05329860f, 0.01906037f, -0.04704771f, -0.02639126f, -0.04507875f, 
    0.01221390f, -0.02177860f, 0.03171828f, -0.01899759f, -0.03518890f, 0.04599014f, -0.04032842f, 0.02584636f, 
    -0.00497540f, 0.02804789f, 0.02294134f, -0.04748539f, -0.05842867f, 0.00063778f, -0.02041202f, 0.04548612f, 
    0.03977564f, 0.02390216f, -0.01162293f, 0.01336301f, -0.03097131f, -0.06157268f, -0.04705248f, -0.02689695f, 
    -0.02411475f, -0.01702584f, -0.02111263f, -0.04442909f, 0.05014384f, -0.05259962f, 0.01017185f, 0.04514837f, 
    -0.02449239f, -0.04702771f, -0.06098216f, -0.05279794f, 0.04281472f, -0.01239302f, -0.04126087f, -0.06141485f, 
    0.01023746f, -0.04911400f, -0.04138142f, -0.03594742f, 0.02328001f, 0.01155452f, 0.03276048f, -0.04048849f, 
    0.05040706f, -0.00638124f, 0.00110154f, -0.00249866f, 0.01574508f, -0.01964316f, -0.00721265f, 0.00011575f, 
    -0.01175111f, 0.03295648f, -0.03035286f, 0.01577445f, -0.03359637f, 0.00092124f, -0.00161878f, 0.01310570f, 
    0.02943108f, 0.01956405f, -0.04306612f, -0.03488510f, -0.05594097f, -0.00837860f, -0.05448416f, -0.03779425f, 
    0.04318600f, -0.01956577f, -0.01906687f, 0.02734339f, -0.00824601f, -0.02207439f, 0.04831721f, -0.05751618f, 
    -0.05112332f, 0.02167734f, -0.02114844f, 0.01114863f, 0.04235019f, 0.00737036f, -0.01552024f, 0.00515831f, 
    -0.00192444f, -0.03721735f, 0.02007511f, 0.04697983f, 0.01163965f, 0.02230041f, 0.04514212f, -0.04934786f, 
    0.04045953f, -0.02508643f, 0.02581097f, 0.03183869f, -0.05119471f, 0.04687087f, 0.04845385f, 0.02937619f, 
    -0.02303265f, 0.00141181f, 0.02224926f, -0.02242603f, -0.02313923f, -0.05638066f, 0.03077754f, -0.03268360f, 
    0.01952885f, 0.04523676f, 0.04388969f, -0.03900920f, -0.05425685f, 0.02572238f, 0.00445521f, 0.01621513f, 
    0.01334227f, 0.04557029f, -0.04308627f, 0.02594007f, -0.03802758f, -0.00617230f, -0.03004392f, 0.03066890f, 
    -0.03789903f, -0.01659405f, 0.02175403f, 0.04020702f, -0.03004888f, 0.01552080f, -0.01686433f, 0.02631811f, 
    -0.05991704f, -0.00564879f, 0.00742426f, 0.00134997f, -0.01333143f, 0.04827648f, -0.04571901f, 0.04209554f, 
    -0.01280789f, -0.03939857f, -0.02717890f, -0.03562100f, 0.02404869f, 0.01691469f, -0.01569628f, -0.03927407f, 
    -0.04451573f, -0.01016291f, 0.04071080f, -0.01542826f, -0.04535510f, -0.02190926f, -0.05055210f, 0.04408534f, 
    -0.05249493f, 0.03355836f, -0.00925361f, 0.03775966f, 0.03040847f, -0.05829583f, -0.05567570f, -0.03563359f, 
    -0.03356577f, -0.13819893f, -0.23689772f, -0.15718190f, 0.08278122f, 0.07700655f, -0.09764346f, -0.21604812f, 
    -0.02624745f, 0.00941532f, 0.00646041f, 0.01308670f, 0.02703334f, 0.03004873f, 0.01305319f, 0.12347952f, 
    0.20869900f, -0.10471060f, 0.09941589f, -0.03438439f, -0.33456343f, -0.02588848f, -0.27858979f, -0.09096238f, 
    -0.09937976f, -0.10992226f, 0.11328167f, -0.02704608f, -0.11649554f, -0.12870270f, -0.09088308f, 0.04863212f, 
    0.05787417f, 0.00341289f, -0.03244755f, 0.15747190f, 0.13608222f, 0.17699644f, 0.07833938f, -0.00661581f, 
    0.40926278f, -0.16795754f, -0.01456235f, -0.05579846f, -0.22070155f, 0.00492626f, 0.11355724f, -0.00451925f, 
    -0.02361483f, -0.13682590f, 0.09869822f, -0.06971614f, 0.00612001f, -0.00096539f, 0.05224642f, 0.12703079f, 
    0.04178977f, 0.08842677f, 0.05662306f, 0.03346474f, 0.00483932f, -0.24908951f, -0.11237780f, 0.11482912f, 
    0.16485192f, 0.00941434f, -0.05599179f, 0.02891604f, 0.09930769f, 0.02829149f, 0.00471540f, 0.04010498f, 
    -0.09851593f, 0.06749533f, -0.00063122f, 0.06687392f, -0.06153432f, 0.06563127f, 0.05739116f, 0.04592218f, 
    -0.48749375f, 0.10046129f, 0.08434193f, -0.08458324f, -0.28864461f, 0.31164557f, 0.05176055f, -0.18308812f, 
    -0.20694020f, 0.17099096f, 0.00150017f, 0.04902802f, 0.05093945f, 0.16534865f, 0.02325499f, 0.02268825f, 
    0.02328466f, -0.08898965f, -0.00506580f, -0.01180449f, 0.00053922f, -0.06615081f, -0.13395315f, -0.13359389f, 
    -0.14646503f, 0.01791063f, -0.05109761f, 0.04501418f, -0.01404655f, -0.03494995f, 0.02770074f, 0.12692019f, 
    0.15148993f, 0.10291050f, 0.00784777f, 0.13469627f, -0.02829545f, 0.06179930f, -0.01588715f, 0.07564697f, 
    0.01728612f, -0.07163800f, -0.22305886f, -0.10368312f, 0.24628542f, -0.01393623f, -0.11182051f, 0.00638919f, 
    0.08523952f, -0.11244666f, 0.03455238f, 0.10797011f, -0.06770264f, -0.04312719f, -0.08899134f, 0.11095425f, 
    0.10883917f, 0.13381986f, 0.14668562f, 0.00462909f, 0.30724317f, 0.29526076f, -0.09783731f, -0.03360468f, 
    0.08490793f, 0.02746334f, 0.11635432f, 0.04493348f, 0.35333395f, -0.07463370f, 0.11499824f, -0.18090984f, 
    0.00579731f, -0.04504517f, -0.07421135f, 0.03404011f, -0.02306099f, 0.00540858f, -0.06808697f, -0.09041281f, 
    0.06048923f, -0.15985426f, -0.13374953f, -0.15518583f, -0.12717649f, -0.05242693f, -0.00688699f, -0.06479004f, 
    0.06460354f, 0.15864943f, 0.00928623f, -0.08504353f, -0.06116709f, 0.04623754f, 0.05324257f, -0.06711069f, 
    0.06609941f, -0.17756313f, 0.05294582f, 0.16939472f, 0.46122143f, -0.06329684f, -0.04237391f, -0.12922306f, 
    0.05595111f, -0.11612280f, -0.00228247f, -0.03472165f, -0.00150152f, -0.01499894f, -0.02149511f, -0.03533567f, 
    -0.03663659f, -0.09692694f, 0.06741579f, 0.12676181f, 0.13704227f, 0.20010035f, 0.20407964f, 0.14808358f, 
    0.13369276f, 0.17436559f, 0.01061955f, -0.06064636f, -0.19766396f, 0.13803922f, 0.00841335f, -0.18199703f, 
    0.02906853f, 0.05078633f, -0.22781552f, -0.02844840f, -0.06023238f, 0.04011054f, -0.13569440f, -0.02718166f, 
    0.02816812f, -0.22736445f, 0.06006991f, 0.06314503f, -0.07919121f, 0.20535393f, 0.01476577f, -0.01551495f, 
    -0.10658110f, 0.15752095f, -0.00271760f, -0.05157367f, -0.02032915f, 0.16478856f, -0.03848915f, 0.08315763f, 
    0.05051306f, -0.00840120f, -0.02085865f, -0.11150212f, -0.03988178f, -0.00045802f, -0.06191863f, 0.07703202f, 
    -0.27783284f, -0.31106287f, -0.14016272f, 0.12071295f, 0.12411041f, -0.00195443f, -0.04300393f, 0.01897411f, 
    -0.06293277f, 0.01971248f, 0.15138727f, -0.01854297f, -0.06207645f, 0.03310237f, -0.15853827f, -0.06158174f, 
    0.10997809f, 0.06820954f, -0.00935317f, -0.06214656f, 0.09368216f, 0.21526049f, 0.15518069f, -0.08210284f, 
    -0.01779957f, 0.18876392f, -0.02513356f, 0.09706173f, 0.07045392f, 0.25778911f, 0.02052013f, 0.01690312f, 
    0.07999253f, 0.05412768f, -0.03740411f, -0.03684964f, 0.01445236f, 0.11165969f, -0.28007030f, 0.14165457f, 
    0.33356377f, -0.07032683f, 0.14279440f, 0.01022263f, -0.40615982f, 0.11831538f, -0.11794644f, -0.04198635f, 
    -0.11883366f, -0.10323298f, 0.02694139f, 0.15065658f, 0.07161821f, 0.13179967f, 0.05689837f, 0.08385111f, 
    -0.03178338f, 0.01862881f, -0.08817818f, 0.02615068f, 0.27508292f, 0.28801218f, 0.59524715f, 0.26381457f, 
    -0.27294013f, 0.12837917f, -0.07793342f, -0.03167666f, 0.14752974f, 0.03538541f, 0.11604516f, -0.06185839f, 
    -0.04613334f, -0.08566762f, 0.13379888f, 0.17356044f, 0.11810578f, -0.08200297f, -0.05266466f, 0.00381313f, 
    0.01445769f, -0.02047429f, 0.02628277f, 0.02708199f, -0.05636300f, 0.04943701f, -0.03804959f, 0.03159265f, 
    0.00766159f, 0.00812600f, 0.04592773f, -0.01694704f, -0.00921597f, 0.03250802f, -0.04733437f, 0.00706169f, 
    -0.04772447f, -0.02376869f, -0.02102810f, 0.04327685f, -0.03922788f, -0.00105229f, -0.01361225f, 0.02811742f, 
    -0.02459181f, -0.03286053f, -0.01003173f, -0.01668704f, -0.04135202f, -0.01285824f, -0.03252285f, 0.01074717f, 
    -0.04593042f, 0.01630115f, 0.04549540f, 0.02414593f, 0.02692751f, 0.03432265f, 0.01620325f, -0.01670881f, 
    -0.02595786f, -0.06204484f, -0.04090179f, 0.01111735f, -0.02711144f, -0.02330509f, 0.04667862f, -0.00968840f, 
    -0.04828540f, 0.04279575f, -0.03679698f, -0.01436020f, -0.01230280f, -0.05183954f, 0.02155995f, 0.01035205f, 
    -0.03956059f, -0.00551795f, 0.01099190f, -0.03989204f, -0.04120921f, -0.02825333f, 0.01436158f, -0.05544983f, 
    0.00124558f, 0.00700469f, -0.03322235f, -0.01110961f, 0.03831965f, -0.01222563f, -0.05248999f, -0.06070637f, 
    -0.05149052f, 0.03293115f, -0.00570105f, -0.04597007f, 0.01152993f, -0.01494321f, 0.03159910f, -0.00402534f, 
    0.02578393f, 0.03170363f, 0.02213717f, -0.03354208f, -0.03288932f, -0.04297578f, 0.04174202f, -0.00477958f, 
    -0.00181897f, 0.00893170f, -0.02136141f, -0.01371842f, -0.01837846f, 0.02822219f, 0.02470443f, 0.01547759f, 
    -0.05136991f, -0.00060468f, 0.00442576f, -0.04760944f, -0.04507175f, -0.01391239f, -0.03909500f, 0.01537070f, 
    0.00424264f, -0.04551488f, -0.02134989f, 0.03495849f, -0.00340272f, -0.03957365f, 0.03592782f, -0.05716528f, 
    -0.06341393f, 0.00172899f, 0.00072195f, -0.02772244f, -0.04206425f, -0.00898366f, 0.02996143f, 0.02276922f, 
    0.03824263f, -0.04480625f, -0.03971618f, 0.04607004f, -0.02668239f, -0.05431544f, 0.00724393f, 0.02397174f, 
    -0.00740498f, -0.03167293f, 0.01206705f, -0.03694589f, 0.02417073f, -0.01464908f, -0.03862729f, -0.04959391f, 
    -0.02983805f, -0.00624527f, -0.04369698f, -0.05529204f, 0.00196510f, 0.02887388f, 0.03231744f, -0.01701624f, 
    -0.03339113f, -0.05396184f, 0.02833514f, 0.02466134f, 0.02318725f, 0.03777928f, 0.04799512f, 0.03522657f, 
    0.01945535f, -0.01232968f, 0.01312949f, -0.00399531f, -0.00041844f, 0.02452242f, -0.06183650f, 0.02022719f, 
    -0.02407268f, 0.00594804f, -0.06020806f, -0.05418686f, 0.03620688f, -0.04388504f, 0.04814332f, 0.01252260f, 
    -0.03105431f, -0.02927909f, 0.03651454f, -0.01246569f, 0.03738104f, -0.04324739f, -0.02721422f, 0.01787178f, 
    -0.01205444f, 0.00677200f, -0.00867532f, -0.03638797f, -0.02577546f, 0.00852029f, 0.04379404f, 0.02671032f, 
    -0.03285022f, -0.03852986f, -0.00408766f, -0.02136737f, 0.04210101f, -0.02982898f, -0.02102394f, -0.02125059f, 
    0.03908442f, -0.02701348f, 0.00535176f, -0.00595019f, -0.02395468f, -0.05334637f, 0.03524020f, -0.02446103f, 
    -0.02597770f, 0.04164835f, -0.03368531f, -0.01360584f, -0.04478773f, -0.06072395f, -0.04678334f, -0.01834949f, 
    -0.01235535f, -0.01756551f, 0.03880168f, 0.01638551f, -0.03205018f, 0.01061999f, -0.00674026f, -0.04700987f, 
    -0.05893298f, -0.02033194f, -0.03159873f, -0.01844993f, -0.00826562f, -0.00632417f, -0.01696734f, 0.00919441f, 
    -0.00326344f, -0.04457187f, -0.01304797f, 0.02869652f, 0.01671220f, -0.05665782f, 0.03828300f, -0.01094364f, 
    0.04042574f, -0.04585619f, -0.04681157f, -0.05370400f, -0.03574443f, -0.00215958f, -0.00342017f, -0.01850644f, 
    -0.01635179f, -0.02350092f, -0.01311340f, 0.04568364f, 0.02330834f, 0.00268258f, 0.04611263f, 0.00773996f, 
    -0.01748189f, -0.03353863f, 0.03106472f, -0.04314655f, -0.06224353f, 0.02694940f, -0.02657735f, 0.03143562f, 
    -0.04384190f, -0.02225292f, 0.04423292f, -0.05721804f, -0.03937406f, -0.00447079f, -0.06161683f, -0.05614866f, 
    -0.01298829f, -0.01010150f, -0.04552287f, 0.01849224f, -0.01053668f, 0.00060968f, -0.04915537f, 0.04327041f, 
    -0.04418368f, 0.04824040f, -0.06090742f, 0.03303624f, -0.05566944f, 0.01802159f, -0.02341483f, -0.02414635f, 
    -0.05037589f, -0.04577872f, -0.03644982f, -0.01206847f, -0.02120405f, -0.02785456f, 0.01307327f, 0.03846482f, 
    0.04749725f, 0.00412914f, 0.01320352f, -0.04105963f, -0.01934467f, 0.03570747f, 0.00379650f, -0.04357776f, 
    0.02256586f, 0.02091240f, -0.04263982f, 0.00211890f, 0.01312046f, -0.05433053f, -0.03462413f, -0.02156623f, 
    0.01808890f, 0.04028963f, -0.01571882f, -0.04190020f, -0.00431940f, 0.03874854f, 0.02744295f, -0.02497161f, 
    0.01629216f, -0.01160179f, 0.00317585f, -0.00452821f, -0.03312679f, 0.03359925f, -0.02063648f, 0.01706171f, 
    -0.02529280f, -0.05407153f, -0.00924366f, -0.00394591f, 0.00605329f, 0.00189690f, 0.03743618f, -0.03036535f, 
    -0.05520545f, -0.01768838f, -0.02739972f, -0.00639161f, 0.01947418f, 0.01921612f, 0.01290482f, -0.03513354f, 
    -0.04307418f, -0.01138307f, 0.01174311f, 0.01821683f, 0.01935834f, -0.04982882f, 0.02482818f, 0.00004824f, 
    -0.00476642f, 0.02110799f, -0.04562594f, -0.00656104f, 0.02488371f, 0.02160353f, 0.00914155f, 0.04720928f, 
    -0.04806602f, -0.02585033f, -0.03875260f, -0.04856143f, 0.04360006f, -0.01994732f, 0.04152204f, -0.02649516f, 
    -0.03249148f, 0.02982573f, -0.03010692f, -0.02955465f, -0.00249301f, -0.02504825f, -0.03248658f, -0.05757727f, 
    -0.04074214f, -0.02686775f, -0.03620748f, -0.03315196f, -0.00573620f, 0.04835423f, -0.02453848f, 0.03655897f, 
    0.00908117f, 0.02698873f, 0.03360771f, 0.00362777f, -0.03451760f, 0.03828446f, -0.00655897f, 0.02485005f, 
    0.01729095f, -0.04629570f, -0.04076013f, -0.05917589f, -0.04077895f, -0.02072787f, 0.04485247f, 0.02861123f, 
    0.03702154f, -0.04521515f, -0.02994550f, -0.00116553f, 0.00226160f, 0.04562565f, -0.03324404f, 0.02239103f, 
    -0.04635712f, -0.01344228f, -0.02486461f, -0.05651683f, 0.03138883f, -0.02496351f, 0.00154027f, 0.00237977f, 
    0.02127292f, -0.00755070f, -0.00881094f, 0.00246115f, 0.04075423f, -0.04650867f, -0.04977049f, 0.03880979f, 
    -0.01179509f, 0.04645428f, -0.04067181f, -0.02323467f, 0.03406896f, -0.03726288f, 0.00639303f, -0.05900939f, 
    -0.03652472f, 0.02294716f, -0.02513909f, -0.02047744f, -0.03791789f, -0.04500727f, 0.02550033f, -0.01343801f, 
    0.02821329f, 0.02080301f, -0.02537147f, 0.04462751f, -0.06114734f, -0.06038046f, -0.00603248f, -0.06072223f, 
    -0.04762167f, 0.01481392f, 0.05028500f, -0.04544432f, 0.04653854f, -0.03823592f, -0.03361416f, -0.03797663f, 
    0.00047714f, -0.02784932f, -0.03871761f, -0.02589838f, -0.02028929f, 0.04232027f, -0.05743538f, 0.03160518f, 
    -0.04846757f, 0.03202572f, 0.01416866f, 0.01218583f, 0.03694464f, -0.05202359f, 0.01181544f, 0.03773327f, 
    -0.02371732f, -0.02889327f, -0.03884052f, -0.01405641f, 0.03505849f, -0.02524904f, 0.02598459f, -0.01854528f, 
    0.01226616f, -0.02316179f, -0.02496707f, 0.01350437f, 0.02614238f, 0.04188472f, 0.02460987f, 0.00165840f, 
    -0.00255380f, 0.03726301f, -0.05736744f, -0.01372395f, 0.04066833f, 0.02473816f, -0.04543770f, -0.00507591f, 
    -0.01027134f, -0.04509483f, -0.02627351f, 0.00490427f, -0.02205334f, -0.05075795f, -0.04700471f, -0.01977759f, 
    0.00485212f, -0.04299222f, -0.05998293f, -0.02152894f, -0.02007133f, 0.00009259f, -0.01658426f, -0.05541465f, 
    0.00193907f, -0.01468601f, 0.01604555f, 0.00311215f, 0.00021962f, 0.03085758f, -0.03138599f, 0.00115299f, 
    0.02107878f, 0.00845420f, 0.01596172f, -0.01290398f, -0.00634915f, 0.03294035f, 0.01392785f, 0.01760576f, 
    0.02956788f, 0.02224317f, 0.04630223f, 0.02809820f, -0.04987029f, 0.04785727f, 0.02080888f, -0.00287978f, 
    0.02321985f, -0.04277198f, -0.02020161f, -0.02471647f, -0.02158914f, 0.02562664f, 0.01664232f, -0.02661283f, 
    -0.05839223f, -0.02411080f, -0.01453684f, 0.04775862f, 0.00698153f, 0.01291938f, 0.00534810f, -0.04133920f, 
    -0.04454603f, 0.02089765f, 0.00071289f, -0.04918104f, 0.03701077f, -0.02129949f, 0.00139335f, 0.01616771f, 
    -0.00416815f, -0.06039808f, 0.00673414f, 0.04605268f, -0.03347716f, 0.01932546f, 0.04272651f, -0.06000713f, 
    0.04562905f, 0.02301194f, -0.02228581f, -0.03682691f, -0.04069463f, -0.03928144f, -0.04076271f, -0.05466610f, 
    -0.06031825f, -0.02266568f, 0.02925411f, -0.01428344f, 0.01334915f, 0.01198970f, 0.02808207f, 0.01072528f, 
    -0.04502770f, -0.03928112f, 0.04920472f, -0.05701753f, 0.02747828f, 0.02606665f, -0.03256479f, 0.03748128f, 
    0.02610875f, 0.02776091f, -0.05139007f, -0.02702428f, 0.03061080f, -0.01711350f, 0.04910775f, -0.02901304f, 
    -0.05101324f, 0.01924167f, -0.05827581f, -0.02070273f, -0.04697063f, -0.01218947f, 0.00856370f, -0.00144700f, 
    -0.06006058f, 0.02588468f, -0.02949442f, -0.01782977f, -0.02178575f, -0.03750157f, 0.00524838f, -0.03418213f, 
    -0.02002240f, -0.00196742f, 0.03186502f, -0.02115812f, 0.00443597f, 0.02020604f, -0.02773852f, 0.04488640f, 
    -0.01560738f, -0.04695044f, -0.05686736f, 0.04406219f, -0.00916289f, -0.05472945f, -0.05788849f, 0.03038029f, 
    -0.05564389f, 0.03272150f, 0.02700451f, 0.01315921f, 0.03862826f, 0.03988591f, 0.04701689f, 0.04036675f, 
    -0.03004468f, -0.05764257f, 0.02517430f, -0.03731041f, -0.02536159f, -0.05751742f, 0.00284952f, -0.02553618f, 
    -0.03959167f, -0.01260878f, 0.12238212f, -0.04117873f, -0.10076601f, -0.18986045f, -0.00740633f, 0.00329745f, 
    0.03289669f, -0.03448826f, 0.11647837f, 0.02932135f, 0.13084275f, 0.19025700f, 0.04812000f, -0.01969973f, 
    0.10009920f, 0.01765585f, -0.01610031f, -0.02109558f, 0.05796082f, 0.00099293f, 0.05288345f, 0.14974211f, 
    -0.12089624f, -0.00083479f, -0.26107651f, -0.00357148f, 0.11344583f, 0.07738038f, -0.11442566f, -0.09428290f, 
    -0.11905491f, -0.00427309f, 0.02731233f, 0.05893711f, -0.09757243f, 0.03154998f, 0.21202968f, 0.09994529f, 
    0.15517153f, -0.07938791f, 0.21370955f, 0.27427787f, -0.09834646f, -0.03084177f, 0.00708590f, -0.02085355f, 
    0.02786176f, -0.15670484f, -0.03388206f, -0.05774537f, 0.10104275f, -0.01155921f, -0.04928397f, 0.02369447f, 
    -0.04394470f, -0.10730616f, 0.02258492f, 0.08217617f, 0.14380933f, -0.00711211f, -0.00714737f, 0.08023246f, 
    0.07458148f, -0.01823532f, -0.04114449f, 0.01978440f, -0.07205231f, -0.06594760f, -0.03693145f, -0.02108407f, 
    -0.02026430f, -0.03891002f, -0.03460643f, 0.16704713f, -0.05155035f, -0.03760598f, 0.07483796f, 0.02203695f, 
    -0.40236774f, -0.03625999f, 0.17644237f, 0.08361045f, -0.02235868f, 0.16729060f, 0.07984969f, 0.07364791f, 
    0.01658439f, 0.15382269f, 0.07882369f, 0.13959973f, 0.04268485f, -0.01751924f, -0.11205301f, -0.07801587f, 
    -0.05050746f, 0.13438876f, 0.03061334f, 0.07466505f, -0.16925992f, -0.29440895f, -0.11445846f, 0.01105869f, 
    -0.16030061f, 0.01359329f, 0.03848610f, -0.06306157f, -0.01506875f, 0.08303428f, -0.01099805f, 0.01673174f, 
    0.08839503f, -0.00834136f, -0.06285769f, -0.03304764f, -0.00463023f, 0.05345670f, -0.01322059f, -0.07106440f, 
    0.13663529f, 0.10787844f, 0.18680765f, 0.10033876f, -0.13695189f, -0.03861697f, -0.12902488f, -0.01987661f, 
    -0.00252782f, -0.19164050f, -0.17706707f, -0.12317261f, -0.03281037f, -0.05299703f, -0.07988980f, -0.23534404f, 
    -0.05595398f, 0.03403363f, -0.01368843f, 0.01080156f, -0.19543071f, -0.08590869f, -0.10223646f, 0.26189452f, 
    0.27897361f, 0.12309051f, -0.07162382f, 0.24764450f, 0.02685517f, 0.12447014f, -0.02030971f, -0.01038740f, 
    0.05972954f, 0.01964897f, -0.01898219f, 0.02236381f, 0.04803825f, 0.08516109f, -0.17574354f, -0.01522898f, 
    0.10650297f, 0.01092864f, 0.05935614f, 0.05344677f, -0.01520574f, 0.04160891f, -0.00296105f, 0.04627623f, 
    -0.08345824f, 0.02629483f, -0.06726302f, -0.07616857f, -0.00349405f, -0.00426264f, -0.03120251f, -0.01625958f, 
    0.05825419f, -0.03630288f, -0.02054590f, -0.02494944f, 0.38032207f, -0.11240409f, -0.16245285f, 0.38441068f, 
    0.23597789f, -0.00485227f, 0.00968502f, -0.06464478f, -0.04130434f, -0.07563913f, -0.11140988f, 0.09895957f, 
    -0.08843540f, 0.09600895f, -0.01526039f, 0.01842276f, -0.01113564f, -0.09260888f, 0.02750523f, 0.01161201f, 
    -0.17729703f, -0.23520713f, 0.06199773f, 0.31565255f, -0.02767070f, -0.03400517f, -0.12827069f, 0.09160531f, 
    0.05080089f, 0.27048063f, -0.07066001f, 0.03982071f, -0.02614304f, 0.16660449f, 0.06539273f, 0.10766754f, 
    0.00931958f, 0.05182626f, -0.03461011f, -0.05970395f, -0.24412213f, -0.03298161f, -0.18938270f, 0.09642696f, 
    0.09264494f, 0.06403822f, 0.00898855f, -0.03697719f, 0.12266728f, 0.03055410f, 0.07711286f, 0.11805458f, 
    0.06046945f, 0.00752165f, 0.07981893f, 0.20013089f, 0.09156618f, 0.15299383f, -0.11645474f, -0.09091584f, 
    0.49459478f, 0.02316681f, -0.10787243f, 0.15628481f, -0.19670026f, -0.01470236f, -0.08537986f, -0.03049383f, 
    -0.02942789f, -0.16096267f, -0.07856543f, -0.04231758f, -0.04148488f, -0.01784372f, -0.06461113f, 0.08003170f, 
    -0.01466595f, -0.14895596f, 0.01537571f, -0.05699412f, -0.15272072f, 0.01520840f, -0.14708902f, 0.17895697f, 
    0.23258372f, -0.07911096f, -0.21756522f, 0.03305969f, 0.08367918f, 0.16951485f, -0.01327103f, 0.00533891f, 
    -0.05117043f, -0.01661041f, -0.01814475f, 0.13121295f, 0.08054286f, 0.08521543f, -0.14181392f, -0.12790978f, 
    -0.00893058f, -0.30681980f, -0.01860449f, 0.03498062f, -0.28898606f, -0.10418447f, -0.00404098f, -0.06673794f, 
    0.01309493f, 0.04709888f, 0.06597550f, -0.02858729f, 0.07178584f, 0.15147533f, 0.02972568f, -0.07178782f, 
    -0.03023614f, -0.04998215f, -0.05428515f, 0.06066985f, 0.00213099f, -0.04259669f, -0.06252635f, 0.08817048f, 
    -0.09814776f, 0.09241837f, -0.12810712f, -0.10542745f, 0.15627912f, 0.00672032f, 0.06089792f, 0.00155533f, 
    -0.01107963f, -0.08406658f, 0.12679668f, 0.29450789f, 0.13710293f, -0.03628284f, 0.06493580f, 0.12728244f, 
    0.05570995f, 0.00230056f, 0.02922476f, -0.03192845f, 0.20055941f, -0.01173657f, -0.08885947f, -0.05831792f, 
    0.02956144f, -0.07113248f, -0.03492891f, 0.09121066f, -0.09527820f, 0.04264847f, 0.09803741f, -0.02498915f, 
    -0.18554690f, -0.04770596f, -0.00345691f, -0.02865704f, 0.05070835f, -0.00627195f, 0.07042848f, -0.03743034f, 
    -0.07628073f, 0.14460965f, 0.14644381f, 0.18220052f, -0.18943480f, 0.16730116f, -0.00520256f, 0.06034513f, 
    0.00434125f, -0.04075285f, -0.09524019f, -0.08046801f, -0.11817956f, 0.17119421f, -0.11540475f, 0.03969705f, 
    -0.07719500f, 0.16768399f, 0.03687150f, -0.10013124f, 0.14073503f, 0.06207259f, 0.03446439f, -0.05847695f, 
    0.01308968f, -0.01752516f, 0.20770516f, 0.30237284f, 0.02497329f, 0.11652894f, 0.00961252f, 0.05944853f, 
    0.03978302f, 0.06075050f, 0.02251344f, 0.12322885f, 0.16755678f, -0.14742002f, -0.19172683f, -0.19423793f, 
    0.30767679f, 0.10400748f, 0.04713123f, 0.04364108f, 0.00934542f, 0.06030180f, -0.08415356f, -0.09791600f, 
    -0.00129386f, -0.00041695f, -0.07008782f, -0.02865740f, 0.15182832f, 0.12314584f, 0.15696655f, 0.05208183f, 
    0.60453552f, 0.35377425f, -0.10578462f, -0.07271977f, -0.02348918f, 0.04820690f, -0.08172571f, -0.08444756f, 
    0.26602000f, 0.08783835f, 0.16164951f, 0.01930270f, 0.02702305f, -0.01286803f, 0.17105207f, 0.10998498f, 
    0.37950957f, -0.06431358f, 0.20452054f, 0.10257816f, -0.07576679f, 0.08495504f, 0.14730875f, 0.03346325f, 
    0.03291072f, -0.16463783f, -0.15756507f, -0.14904517f, -0.00801809f, -0.14143215f, 0.01128572f, 0.08431429f, 
    -0.05551527f, -0.04274162f, -0.00355256f, -0.04766715f, -0.03242530f, -0.10223481f, -0.01922417f, -0.08849980f, 
    -0.16429895f, -0.02347320f, -0.35459512f, -0.16222854f, 0.08839386f, -0.01258112f, -0.07362378f, -0.14381149f, 
    -0.10273562f, 0.02166351f, -0.00854653f, -0.24406314f, -0.05760691f, -0.00678061f, -0.09498436f, 0.10289651f, 
    -0.12102290f, -0.00210980f, -0.00549701f, 0.04807716f, -0.46482313f, -0.76375431f, 0.26080924f, 0.33392912f, 
    -0.36763784f, -0.06738317f, 0.00032044f, -0.11745678f, 0.01481492f, -0.13681792f, 0.10093270f, 0.08310243f, 
    0.01597860f, -0.06195234f, -0.04571642f, 0.03327713f, 0.00142747f, -0.07231560f, 0.14947130f, -0.06637771f, 
    0.61742502f, -0.26194063f, -0.15266068f, -0.05011520f, 0.04403537f, 0.24048501f, 0.17939781f, 0.16552590f, 
    0.13891417f, -0.00858865f, 0.03932904f, 0.03591341f, -0.02795260f, -0.03850150f, -0.04583216f, 0.11954792f, 
    0.08457764f, -0.03521310f, 0.12991633f, 0.06434939f, -0.30293587f, -0.02881382f, 0.14232871f, -0.30737332f, 
    -0.22456546f, 0.05649303f, 0.06007982f, -0.04348296f, -0.03501114f, -0.04093054f, -0.03814420f, -0.08370189f, 
    0.00440960f, -0.07096696f, 0.11682371f, 0.21780115f, 0.11845458f, 0.31188774f, 0.25355953f, -0.00927954f, 
    -0.39273793f, -0.29061705f, 0.04086284f, -0.18705271f, 0.02571675f, 0.02504822f, -0.00798989f, -0.15898608f, 
    0.01742727f, -0.16246603f, 0.13301468f, -0.04990267f, -0.03106924f, -0.08160954f, -0.02400705f, 0.09523346f, 
    -0.01992501f, -0.00392143f, 0.14743851f, 0.09987581f, 0.36569688f, -0.12795769f, 0.08196316f, 0.11613228f, 
    -0.19364551f, 0.20417546f, 0.00920792f, 0.18083593f, 0.11589243f, -0.02621725f, 0.09173977f, -0.00080477f, 
    0.04886722f, 0.10311701f, 0.08293263f, 0.04303973f, 0.10578331f, 0.11264434f, 0.27576420f, 0.19032294f, 
    0.03763941f, -0.35926044f, -0.17388350f, -0.16070063f, -0.06297183f, -0.00308226f, 0.04616467f, 0.10390882f, 
    -0.04079793f, 0.08972681f, -0.04248737f, -0.03713502f, 0.01140632f, -0.07936028f, -0.05529629f, -0.01682398f, 
    -0.06087103f, 0.02933872f, 0.02080766f, 0.06027337f, -0.15842685f, -0.21611604f, 0.13801412f, 0.01449302f, 
    -0.41959104f, -0.04895295f, -0.01036586f, 0.13290790f, -0.01704690f, -0.25212100f, 0.04947978f, 0.05049822f, 
    0.11922701f, 0.02392310f, -0.03382612f, 0.00894309f, 0.01444304f, 0.00714611f, 0.13597210f, 0.11784480f, 
    -0.14380699f, 0.28474799f, 0.21437499f, -0.15878259f, 0.04682531f, -0.15011719f, -0.04653917f, -0.10352887f, 
    -0.05801292f, -0.23107958f, -0.01893756f, 0.01062030f, 0.10405120f, -0.04878194f, 0.09819430f, -0.01986712f, 
    -0.15108107f, -0.07335497f, -0.04261980f, -0.00053036f, -0.34175825f, -0.23416124f, 0.15843330f, 0.17313302f, 
    -0.11963399f, -0.01018487f, 0.03616985f, -0.03524735f, -0.15217440f, -0.10715517f, 0.02290425f, 0.02506519f, 
    0.16575730f, 0.10351476f, -0.04142394f, -0.09710912f, 0.14373142f, 0.15334649f, 0.10315907f, 0.08686817f, 
    -0.07620297f, 0.09905006f, 0.02628470f, 0.09836438f, 0.07539062f, -0.07987136f, 0.04473741f, -0.08177719f, 
    0.08254194f, 0.05310018f, 0.00026026f, 0.09087709f, 0.07571200f, 0.25938442f, 0.09352285f, -0.02756756f, 
    0.12379812f, 0.01895850f, 0.17040758f, 0.10253294f, -0.17841828f, 0.04143410f, 0.17145918f, 0.01653430f, 
    -0.02787198f, -0.19552547f, -0.18403317f, -0.05399267f, 0.00313975f, 0.04517181f, -0.03920046f, 0.13349769f, 
    0.06763162f, 0.13434273f, -0.03802855f, 0.08912157f, 0.04148456f, 0.09362984f, 0.21852750f, 0.16857739f, 
    0.02623795f, 0.08866595f, 0.02899738f, 0.30958629f, 0.14034520f, -0.00922854f, 0.00144911f, 0.13536111f, 
    -0.06855618f, 0.01340730f, 0.13937961f, -0.08130314f, 0.14912213f, 0.00555513f, -0.00586415f, 0.07778394f, 
    0.10350718f, 0.00904379f, 0.09145896f, 0.00384005f, -0.31624210f, -0.27101415f, 0.20383538f, 0.12519668f, 
    -0.06138813f, -0.09690729f, 0.03227462f, 0.04009189f, 0.03313652f, 0.05429440f, -0.10896606f, -0.00748952f, 
    -0.01033390f, -0.08395915f, -0.01432744f, 0.09693667f, 0.05875587f, -0.18005942f, 0.29180416f, 0.01507985f, 
    -0.49574617f, -0.00201079f, 0.04493929f, 0.14133319f, 0.15006940f, 0.22270454f, 0.06328609f, 0.00862204f, 
    -0.13218683f, 0.09149572f, -0.00181511f, 0.12162933f, 0.08487960f, -0.11524367f, -0.01872493f, 0.17640020f, 
    -0.07282442f, -0.06785125f, -0.06058337f, -0.18904409f, -0.08045740f, -0.01123255f, -0.04683357f, 0.02735358f, 
    0.00826842f, 0.02307359f, 0.09325989f, 0.03056199f, -0.11653805f, -0.00260006f, 0.07977346f, 0.05503330f, 
    0.17534450f, 0.10264589f, -0.02665502f, 0.03233280f, 0.04846150f, -0.02332675f, 0.04624327f, -0.03350145f, 
    -0.19281207f, -0.00904334f, 0.04046843f, -0.01702739f, -0.01898642f, -0.02675225f, -0.01307144f, 0.03311525f, 
    0.02863181f, 0.00518317f, -0.07141230f, -0.07562055f, -0.01637369f, 0.04059663f, 0.06466436f, 0.05791157f, 
    0.11856001f, 0.19993678f, 0.12203344f, 0.07374521f, 0.35623044f, 0.03059447f, -0.27460003f, -0.11888235f, 
    0.21729045f, 0.14773743f, 0.10224240f, -0.04480999f, 0.09156904f, 0.02981591f, 0.09209516f, 0.04888999f, 
    -0.01140582f, -0.02567082f, 0.00755599f, -0.03117722f, 0.10691923f, 0.07546742f, 0.00779729f, -0.02731790f, 
    -0.36559215f, -0.08405874f, 0.29695287f, 0.02872496f, -0.11754657f, 0.04340472f, -0.03299953f, -0.05141899f, 
    0.04974998f, 0.02821809f, 0.00825198f, -0.10843723f, -0.03374168f, -0.01599226f, 0.04716692f, 0.02634158f, 
    0.04376211f, -0.02494041f, -0.03434275f, -0.00485376f, -0.09877577f, -0.15060294f, 0.00714382f, 0.48696718f, 
    0.21268354f, -0.03191518f, -0.01088061f, 0.07945421f, -0.10101123f, 0.13696465f, -0.06275405f, -0.02831593f, 
    -0.04798308f, 0.05794145f, -0.06468622f, 0.03987218f, 0.16581281f, 0.14944147f, 0.02239016f, 0.23163828f, 
    0.23117471f, -0.24649568f, -0.16885717f, -0.34722632f, -0.11461817f, 0.04810406f, 0.06253251f, -0.15201287f, 
    0.09809169f, 0.00374728f, -0.02036652f, 0.13841645f, -0.03063801f, 0.01634959f, -0.03634208f, 0.03470010f, 
    0.00185919f, 0.05629884f, 0.21039297f, 0.09210008f, 0.00486712f, 0.04459080f, -0.14440274f, 0.01920479f, 
    0.10125972f, 0.07443836f, -0.01851423f, 0.02682000f, 0.09215044f, 0.14337462f, 0.01384703f, -0.00158919f, 
    -0.05851460f, -0.01166665f, -0.11031347f, 0.06228108f, -0.06117371f, 0.03224778f, 0.11012542f, -0.04211183f, 
    -0.46718937f, -0.05966161f, 0.16105045f, 0.06281445f, -0.07516772f, -0.01867507f, 0.05457162f, 0.00984391f, 
    -0.11035750f, -0.11302932f, -0.02940807f, -0.02297757f, -0.00842582f, 0.02069013f, -0.08224885f, 0.03079347f, 
    0.11983699f, -0.05834861f, 0.05454012f, 0.00931006f, -0.00663653f, -0.14072974f, -0.32501179f, -0.35345703f, 
    -0.07891472f, 0.12183985f, 0.00694220f, -0.02236333f, 0.13932833f, 0.05174419f, -0.06938561f, -0.05710744f, 
    -0.12340824f, -0.08291209f, -0.07900675f, -0.01794775f, 0.00142564f, -0.03528510f, -0.21913955f, 0.10416491f, 
    -0.04881761f, 0.08430294f, 0.08991247f, 0.05504908f, 0.06794943f, -0.00397961f, 0.03463354f, 0.09077633f, 
    0.11260749f, 0.01565878f, 0.06799918f, 0.30093017f, 0.18265535f, 0.13567476f, 0.18313433f, 0.03781361f, 
    -0.05261059f, 0.01547793f, 0.05580385f, -0.03890197f, 0.34888056f, 0.08952984f, -0.03670634f, -0.10880710f, 
    0.01696311f, 0.13035883f, -0.00423391f, 0.08156022f, 0.18375716f, 0.17314173f, 0.01293956f, -0.04036606f, 
    -0.04519486f, -0.06526431f, 0.03115526f, 0.23137981f, 0.12116502f, -0.00006054f, -0.04727004f, 0.03983446f, 
    -0.03376562f, -0.07591204f, 0.01340510f, 0.15762103f, 0.00988581f, -0.00143159f, 0.03271477f, 0.01584725f, 
    0.05841336f, -0.05821414f, 0.01526082f, 0.17332254f, -0.18543787f, 0.04547702f, -0.04254991f, -0.13059975f, 
    0.00594668f, -0.14555675f, 0.06281102f, -0.03769046f, 0.01442397f, 0.19476454f, -0.10892957f, 0.16896497f, 
    0.09706423f, 0.00569045f, 0.03055303f, 0.00486302f, 0.09503431f, -0.11537088f, -0.02531292f, -0.00665410f, 
    0.05737612f, 0.08187323f, 0.00038521f, -0.04570090f, 0.20845923f, 0.05746544f, 0.06712955f, 0.12369601f, 
    0.40546981f, -0.07206427f, -0.06452277f, 0.09430058f, 0.04988276f, 0.01417216f, -0.02319541f, 0.10657974f, 
    -0.03471668f, 0.00868634f, 0.13532452f, -0.06566372f, 0.15022212f, -0.04528333f, 0.00597053f, 0.07225875f, 
    -0.05815234f, -0.07813955f, -0.04734590f, -0.00225978f, 0.14486043f, 0.00657600f, 0.52016181f, 0.15932590f, 
    0.13218497f, -0.09463651f, -0.10564616f, -0.02717250f, -0.00350802f, 0.00960567f, -0.01743752f, 0.06349684f, 
    0.00862850f, -0.09570344f, -0.02470811f, 0.06919251f, -0.12616627f, -0.18822090f, 0.08928018f, -0.21695076f, 
    -0.09165861f, -0.18258080f, 0.24537958f, 0.23136620f, 0.14322729f, 0.09838438f, 0.04978474f, 0.26873013f, 
    0.10445457f, 0.12005319f, -0.09975014f, 0.02367806f, -0.08838368f, 0.14064357f, -0.10932363f, 0.00897656f, 
    0.00919200f, -0.08256291f, 0.10735974f, 0.05175091f, -0.10376368f, 0.00911742f, -0.25987253f, -0.08044612f, 
    -0.11268499f, -0.20962340f, 0.00226479f, -0.00017878f, -0.08010189f, 0.02553121f, 0.00572163f, 0.03395742f, 
    -0.05212140f, 0.01747134f, -0.08856923f, -0.04238445f, -0.02723159f, -0.01152257f, 0.02816401f, -0.04500182f, 
    0.17542332f, 0.05273840f, 0.17672694f, 0.25301841f, 0.16551509f, -0.02679812f, -0.07266009f, -0.06715882f, 
    -0.01389521f, -0.03860835f, -0.05633605f, 0.08178414f, 0.00888644f, -0.10579471f, -0.00116282f, -0.24195179f, 
    0.03771164f, -0.06101586f, -0.00147895f, -0.13892619f, -0.25124183f, 0.12304416f, 0.15230852f, -0.29571784f, 
    0.12675756f, 0.06434947f, -0.07442283f, 0.15684125f, 0.16402945f, 0.02784326f, 0.08723446f, -0.00972536f, 
    0.06244086f, -0.00230938f, 0.02948703f, -0.07285795f, 0.00817632f, -0.00940936f, 0.02462298f, 0.01219795f, 
    0.16797540f, 0.03116983f, -0.20513834f, -0.08270296f, -0.42025876f, 0.13797081f, 0.06399488f, -0.00238014f, 
    -0.00877571f, -0.08768158f, -0.04921012f, -0.04247578f, -0.06488296f, 0.01005601f, 0.03277279f, -0.03696243f, 
    0.08687932f, -0.07634721f, 0.00272869f, -0.07302234f, 0.58415312f, 0.15716206f, -0.21930362f, 0.30281419f, 
    -0.07111441f, -0.01695471f, 0.00497230f, -0.09324113f, -0.07170220f, -0.03537444f, 0.01469947f, 0.13237193f, 
    0.04297187f, 0.04602430f, 0.09792470f, 0.06948230f, -0.00797538f, 0.00788496f, -0.02359843f, 0.15773569f, 
    -0.28289482f, -0.05072613f, 0.01829750f, -0.14961338f, -0.16513008f, -0.09948018f, -0.09999535f, -0.03680445f, 
    0.05900280f, -0.25868350f, -0.01673809f, 0.04536122f, 0.06034201f, 0.08944491f, 0.09089797f, 0.01309643f, 
    -0.00865775f, 0.25048381f, -0.04615048f, 0.05852619f, 0.01913563f, 0.17025238f, 0.00191911f, -0.15115933f, 
    0.02410782f, 0.02225877f, 0.16522342f, -0.03984269f, -0.06180746f, 0.05472911f, -0.00266035f, 0.02235279f, 
    0.02362181f, -0.02706195f, -0.01893976f, 0.02619377f, -0.04667114f, 0.00016277f, -0.09107120f, -0.08168755f, 
    0.06831626f, 0.14470527f, 0.22918780f, 0.00327465f, 0.18078180f, -0.03101582f, -0.05630782f, 0.02092727f, 
    -0.05506479f, -0.04888817f, -0.04823910f, 0.00551633f, -0.03265829f, -0.08554013f, -0.02388563f, 0.06966133f, 
    -0.13256013f, -0.07194514f, 0.11438387f, -0.08045874f, 0.09936227f, 0.34714293f, -0.01445539f, -0.25831220f, 
    0.07893974f, 0.08650620f, 0.03461419f, -0.03017319f, -0.16017270f, -0.19765194f, -0.07339858f, -0.03318169f, 
    0.06219161f, -0.01602741f, 0.09097404f, 0.04186365f, 0.08240159f, 0.19469501f, -0.07824880f, 0.01241679f, 
    0.19092958f, 0.09799053f, -0.31478491f, 0.06480858f, -0.06101318f, -0.08811913f, 0.08015120f, -0.01954324f, 
    0.01969429f, 0.09604650f, 0.23379458f, 0.08120457f, -0.00878529f, -0.08244350f, -0.07599323f, -0.02922465f, 
    -0.10438924f, -0.06362943f, 0.04078666f, 0.05044451f, 0.28231707f, 0.24695480f, 0.17181416f, -0.22141364f, 
    0.02506351f, 0.10466191f, 0.05880034f, 0.20042568f, 0.01150515f, 0.08165205f, -0.02241345f, -0.04657100f, 
    -0.00936122f, -0.06167509f, -0.06659699f, 0.22673324f, -0.09533802f, -0.08203068f, 0.00380104f, -0.10915007f, 
    -0.01689257f, -0.05233929f, -0.01263648f, 0.01314661f, 0.00384300f, 0.01334875f, 0.04643133f, 0.00984003f, 
    -0.00858019f, -0.00830510f, 0.04114018f, 0.01213333f, -0.04361073f, 0.00744686f, 0.03553618f, -0.01419939f, 
    -0.04816586f, -0.01608165f, 0.04205356f, -0.00714514f, -0.04804504f, 0.01838390f, 0.01822150f, -0.00524268f, 
    -0.01971005f, -0.03265497f, 0.02062249f, 0.01787400f, -0.01219614f, -0.04805481f, -0.03520099f, 0.04588722f, 
    0.02452518f, 0.01969728f, -0.00825932f, -0.05545501f, -0.05384315f, 0.01856838f, 0.01124595f, 0.04492227f, 
    -0.03857485f, -0.02826175f, -0.06096324f, -0.01522417f, 0.02508117f, -0.03438482f, 0.02158691f, -0.04903109f, 
    0.04078577f, -0.01169160f, 0.04071835f, -0.05514739f, 0.02551848f, -0.00830386f, 0.02089307f, -0.03976572f, 
    -0.03828889f, 0.01721300f, -0.00492951f, -0.01294802f, 0.04293861f, 0.03868612f, 0.00953360f, -0.00003090f, 
    -0.04865471f, 0.01251514f, 0.02440083f, -0.01879201f, -0.00586404f, 0.03330855f, 0.03519259f, 0.02723225f, 
    -0.05587711f, 0.03588006f, -0.03828603f, 0.03631769f, -0.04509475f, -0.01523216f, 0.01600355f, 0.04060877f, 
    0.03675192f, -0.01695194f, 0.04310385f, -0.03803184f, -0.03748985f, 0.00990025f, -0.04102529f, 0.04026303f, 
    -0.05364440f, 0.02723114f, -0.04155528f, 0.04965629f, -0.00009968f, -0.02035626f, 0.02439644f, -0.01754162f, 
    0.00464450f, 0.00754665f, -0.04099992f, 0.01898586f, 0.02905840f, -0.06275032f, -0.02431119f, -0.00389784f, 
    0.03907661f, 0.04154546f, -0.00210916f, 0.02914243f, 0.02754319f, -0.02164130f, -0.04144792f, 0.01570679f, 
    -0.03554350f, -0.05472218f, -0.06346476f, -0.03377001f, -0.05237988f, 0.02501642f, -0.06286919f, 0.01589255f, 
    0.04029123f, 0.03932794f, -0.06070070f, -0.04552596f, -0.00557315f, -0.06232499f, -0.00145696f, 0.03763789f, 
    -0.00209147f, -0.02024012f, 0.05140441f, 0.03479673f, -0.03336692f, 0.04101687f, 0.00785257f, 0.03779037f, 
    0.03439099f, 0.03499964f, -0.01738638f, 0.03044246f, -0.04127031f, -0.02965944f, 0.02131395f, -0.02013138f, 
    0.03394866f, -0.01563480f, -0.00662017f, 0.01512921f, -0.06144517f, 0.00532953f, 0.02613040f, -0.03690804f, 
    0.00559330f, -0.06130267f, -0.01591255f, -0.06164685f, -0.03774115f, 0.04735206f, -0.04776688f, 0.04686520f, 
    0.03936850f, -0.01744067f, 0.01872984f, -0.04808787f, 0.04847657f, -0.04161950f, -0.02494548f, -0.05667223f, 
    0.02218756f, -0.00924157f, -0.02548250f, -0.00351718f, 0.03939746f, 0.00901616f, -0.05256319f, 0.02086286f, 
    -0.04468331f, 0.01289212f, -0.01614895f, 0.02053088f, 0.02042739f, -0.01294297f, 0.03613396f, 0.01354539f, 
    0.04321125f, -0.02352016f, -0.05511310f, 0.04296732f, -0.05309818f, -0.05996895f, -0.03454363f, 0.00393568f, 
    0.02374022f, 0.04407386f, -0.02641723f, -0.01634834f, -0.01971932f, -0.05723086f, -0.03577881f, -0.03402906f, 
    0.04017547f, -0.00426576f, -0.01594640f, -0.01393909f, -0.01969391f, -0.04899911f, -0.03067918f, 0.00714997f, 
    -0.04881532f, 0.02196766f, 0.00776798f, 0.04302494f, -0.03391721f, -0.04898935f, -0.03345687f, -0.05646334f, 
    -0.05664757f, -0.00689086f, -0.01376888f, -0.05520223f, 0.00373488f, -0.02223283f, -0.00604946f, 0.01458211f, 
    -0.06545480f, 0.04238367f, -0.04171298f, 0.03401767f, 0.04844474f, 0.00057446f, -0.00854554f, -0.02918428f, 
    -0.02988983f, 0.04528983f, -0.01819514f, 0.04443125f, -0.03082150f, -0.05091318f, -0.01889832f, 0.02186016f, 
    0.05153614f, 0.03957376f, -0.00837851f, -0.01062161f, -0.02511979f, -0.02719419f, 0.00050463f, 0.01520142f, 
    0.03863498f, 0.02969870f, 0.01744363f, 0.00712662f, -0.05008517f, -0.01531141f, -0.02014753f, 0.04626138f, 
    -0.06025321f, 0.04744825f, 0.00882925f, -0.00819244f, 0.02735691f, -0.06144938f, 0.00316988f, -0.05815896f, 
    -0.04249929f, -0.03674942f, -0.02705922f, -0.02081230f, -0.05185671f, 0.02350156f, -0.03469233f, 0.02953528f, 
    0.02768365f, 0.02807149f, 0.03659023f, -0.03407049f, -0.03525214f, -0.01752917f, -0.03663589f, 0.04533789f, 
    -0.03920886f, 0.00040156f, 0.02563723f, 0.00622178f, 0.02855099f, -0.03653734f, 0.04401588f, -0.04108635f, 
    -0.05079163f, 0.00338585f, 0.03412214f, -0.03868860f, -0.03844220f, 0.03017404f, -0.01782401f, -0.05817912f, 
    0.01900028f, 0.03214076f, -0.04189819f, -0.04034187f, 0.03914911f, -0.03850845f, 0.02958950f, -0.00415266f, 
    0.05097576f, 0.00108035f, 0.00944569f, -0.01262303f, -0.05136518f, -0.04591216f, -0.01816194f, 0.02877385f, 
    0.01101109f, 0.00615592f, 0.01211786f, -0.00819302f, -0.01654390f, 0.02077296f, -0.01703668f, -0.00256701f, 
    0.00439844f, -0.00762677f, 0.01431098f, -0.00503406f, 0.02729849f, -0.04492788f, 0.01612937f, -0.06107225f, 
    -0.03460544f, 0.00868996f, 0.00631431f, 0.03113552f, -0.02330031f, 0.02747452f, -0.05896461f, 0.00104728f, 
    -0.05012626f, 0.00167656f, 0.01070943f, 0.00225820f, 0.04731850f, 0.03206898f, -0.05133187f, -0.04666134f, 
    -0.05524894f, -0.04983384f, -0.06003295f, -0.03727534f, -0.04585358f, -0.04603415f, 0.03764561f, -0.03439546f, 
    -0.03731825f, -0.03501958f, -0.04227359f, -0.01079256f, 0.04321868f, -0.02835826f, 0.00892951f, 0.04418972f, 
    0.01354535f, -0.02134778f, -0.03256387f, -0.00775234f, -0.05689818f, 0.03279232f, 0.02788219f, 0.04463533f, 
    0.04342538f, 0.04546975f, -0.06163931f, -0.04196267f, -0.00865273f, -0.05001613f, 0.02487459f, -0.04496132f, 
    -0.03581601f, -0.00437732f, -0.04069018f, 0.03795176f, 0.03027484f, -0.02052329f, -0.01363717f, -0.02592841f, 
    0.01685096f, -0.05434037f, 0.00556594f, -0.00991726f, -0.00583095f, -0.01170528f, -0.04954988f, 0.00115105f, 
    0.04332799f, -0.06118200f, -0.05955472f, 0.03895855f, -0.04407820f, -0.03382074f, -0.05358373f, -0.00584333f, 
    0.03265209f, -0.06161731f, 0.04329665f, -0.02586264f, 0.02335247f, 0.03208337f, 0.00747267f, -0.01495916f, 
    -0.05150036f, -0.01347943f, -0.03286195f, -0.06398968f, 0.00132024f, -0.05266714f, 0.01989356f, 0.02025405f, 
    -0.03781008f, 0.04015820f, -0.01487885f, 0.03301213f, 0.00590805f, -0.02554494f, -0.05980207f, 0.04051469f, 
    0.02298479f, 0.00450470f, 0.02331686f, -0.05586497f, 0.02463818f, -0.02596798f, -0.06374194f, -0.02630211f, 
    -0.04932545f, -0.04313574f, 0.01189701f, 0.02977934f, 0.02182684f, 0.04466357f, -0.02489015f, 0.00358568f, 
    0.00812036f, 0.03132939f, -0.03275382f, 0.03665292f, 0.00134172f, 0.00222392f, 0.00305018f, 0.02181444f, 
    -0.02822088f, -0.05185421f, 0.02544211f, -0.02350096f, 0.04385608f, 0.03545085f, -0.01585328f, -0.03856049f, 
    0.04276603f, -0.01167770f, 0.03567927f, 0.03311196f, -0.01560425f, 0.04618198f, 0.00004430f, -0.05403613f, 
    -0.01051033f, -0.04670414f, -0.05634704f, -0.01869505f, 0.02369294f, 0.00322779f, -0.01948048f, -0.03638330f, 
    -0.01177325f, -0.06357630f, 0.02201574f, 0.00311195f, 0.03091551f, -0.03426221f, -0.01574021f, -0.04757351f, 
    0.00134968f, 0.01855553f, -0.05223295f, 0.04405725f, -0.03355798f, -0.01493245f, 0.03123645f, -0.00129107f, 
    -0.00085962f, -0.03722625f, -0.01371104f, -0.00139504f, 0.04791922f, -0.05242196f, -0.03136192f, -0.00995267f, 
    0.02463381f, 0.01555027f, 0.03371313f, -0.06597456f, -0.04617009f, -0.04034416f, -0.01631482f, 0.02157564f, 
    -0.00915440f, 0.00005124f, -0.04646233f, 0.04799719f, 0.03600955f, 0.00213882f, 0.02485043f, 0.01999275f, 
    -0.00840132f, -0.00980776f, 0.02732760f, 0.03592011f, 0.02270957f, -0.05718331f, 0.04080347f, -0.02567406f, 
    0.02983731f, 0.02257803f, -0.03695893f, -0.04737491f, -0.05382388f, 0.01180914f, 0.01140612f, 0.02729156f, 
    -0.06615653f, -0.04636061f, -0.05073080f, -0.05913438f, -0.03332413f, 0.00550863f, -0.02427350f, 0.03384834f, 
    0.00161925f, -0.05723203f, -0.01071753f, -0.04896956f, 0.03870055f, -0.02681957f, -0.01618266f, 0.03059269f, 
    -0.00479520f, 0.00023795f, 0.01125839f, -0.00004852f, -0.03333747f, 0.04358259f, -0.01080532f, 0.01984702f, 
    0.04437023f, 0.03291547f, -0.03056954f, -0.01190959f, 0.03419938f, 0.03237791f, -0.00343831f, -0.05650459f, 
    0.02934642f, -0.00615170f, 0.01650775f, 0.00798618f, -0.04042307f, -0.00274383f, -0.03563270f, 0.04401213f, 
    0.00791558f, -0.00965993f, -0.00959639f, 0.01821544f, -0.03452435f, 0.03758292f, -0.00722614f, -0.04051710f, 
    0.03625503f, -0.00926964f, 0.01285127f, -0.05409455f, -0.03593639f, -0.00317943f, 0.03270393f, -0.03517536f, 
    0.04251229f, 0.03742967f, -0.03006953f, -0.02698301f, -0.02548357f, -0.05789069f, 0.04535642f, -0.02598283f, 
    0.03026680f, -0.01848981f, 0.04913216f, 0.04741020f, -0.04776906f, -0.02067673f, 0.00269132f, -0.02018297f, 
    0.04688603f, 0.01634672f, 0.03938298f, -0.05789021f, -0.01291753f, -0.03860736f, 0.02011617f, 0.01505425f, 
    -0.02313107f, -0.05772934f, -0.06066419f, 0.00739462f, -0.02481861f, -0.01145703f, 0.03374431f, -0.04534230f, 
    -0.00820810f, 0.04822209f, 0.02277932f, 0.03227397f, 0.03140072f, 0.03893698f, -0.01395301f, -0.03648249f, 
    -0.01832336f, -0.05028776f, 0.04375450f, -0.01143305f, -0.05806071f, 0.01301275f, 0.01470651f, 0.03794182f, 
    0.02829918f, -0.00550223f, 0.01809626f, -0.04535134f, 0.04646075f, -0.04489928f, -0.05368044f, -0.01466279f, 
    0.16584870f, 0.16087769f, -0.06519322f, -0.08140994f, 0.08892972f, 0.15095432f, -0.19179659f, -0.11968790f, 
    -0.05078546f, -0.03147051f, -0.06029718f, 0.02921262f, 0.05824989f, -0.06681055f, -0.10115145f, -0.20139958f, 
    -0.40903735f, -0.12356915f, 0.05919973f, -0.09379068f, -0.44158804f, -0.11430322f, 0.29069164f, -0.01604612f, 
    0.12639564f, 0.02198752f, 0.38041204f, 0.12872855f, -0.04482713f, -0.17486276f, -0.01000688f, -0.20075153f, 
    -0.00965079f, 0.17212903f, -0.00305075f, -0.08852717f, -0.11558267f, -0.04572942f, -0.13683923f, -0.05149983f, 
    -0.18315728f, 0.46308935f, -0.09353187f, -0.05428848f, 0.18238914f, 0.10310248f, -0.15831509f, -0.04356257f, 
    -0.04052088f, 0.03113053f, 0.10523736f, 0.02671999f, 0.01618690f, 0.03756933f, 0.08801614f, -0.08843273f, 
    0.14266813f, 0.03305010f, 0.11254491f, 0.11224841f, -0.09832540f, -0.09103331f, 0.00222281f, -0.00104472f, 
    0.06880416f, -0.00973455f, -0.33442858f, -0.04256976f, 0.19695272f, -0.02141278f, 0.15085270f, -0.03180356f, 
    0.14808202f, -0.05175572f, -0.06966994f, 0.00847040f, 0.18174495f, 0.14654669f, 0.13075724f, 0.11851729f, 
    0.21133283f, 0.33195716f, -0.13532151f, -0.03781628f, -0.06015522f, 0.08221855f, -0.14412019f, 0.12376764f, 
    -0.10567211f, -0.14045793f, 0.03204107f, 0.12551856f, 0.17651156f, -0.14215244f, 0.03138677f, 0.15855460f, 
    -0.04596553f, 0.07594806f, 0.07311881f, -0.23501626f, 0.16387607f, 0.37390649f, 0.25148004f, -0.10717138f, 
    -0.00760944f, 0.00421644f, -0.21299785f, 0.05960549f, 0.01339172f, -0.01498019f, -0.17599514f, -0.06455206f, 
    -0.08975192f, -0.05851684f, 0.01058371f, -0.05324714f, -0.40507975f, -0.36264104f, -0.27890795f, -0.24462989f, 
    -0.33378115f, -0.11985852f, -0.36807209f, -0.16060272f, 0.05258707f, -0.15069719f, 0.09809324f, -0.35137007f, 
    -0.30659685f, -0.16787106f, 0.02141364f, -0.09917157f, 0.09195697f, -0.01311353f, 0.03077301f, 0.14927684f, 
    -0.19255967f, 0.09019355f, 0.03581157f, -0.12546486f, 0.06269298f, 0.05390978f, 0.05553747f, -0.10230215f, 
    -0.12842713f, -0.03556990f, 0.10119098f, -0.13446912f, 0.01320432f, -0.10314929f, 0.12542185f, -0.03990213f, 
    -0.14882754f, 0.06688677f, -0.03864217f, 0.05103625f, -0.09864341f, -0.05707642f, -0.10127779f, -0.17051147f, 
    0.01389676f, -0.04419231f, 0.17895691f, 0.02809331f, 0.27998132f, 0.03388518f, -0.00144933f, -0.03873042f, 
    0.05452363f, -0.13730581f, 0.07930098f, 0.09162556f, -0.20138560f, -0.03815472f, -0.00947501f, 0.14864585f, 
    0.22215308f, 0.12360714f, 0.14312087f, 0.06482532f, -0.39151105f, 0.01011852f, 0.22802870f, -0.03797506f, 
    -0.06253169f, -0.03414367f, -0.14859846f, 0.01489168f, 0.01345824f, -0.04169409f, 0.06449945f, 0.02514221f, 
    0.08738032f, 0.13580203f, -0.00727788f, 0.09598283f, 0.21678026f, 0.23924619f, 0.19424561f, 0.12018075f, 
    0.13996914f, 0.19040808f, -0.14781384f, -0.16686065f, 0.12580355f, 0.06374399f, 0.08367752f, -0.05595702f, 
    0.01700374f, -0.00564049f, 0.08994212f, -0.17641667f, -0.12802109f, -0.05657372f, 0.00550785f, 0.04798806f, 
    -0.05785584f, -0.06210563f, -0.02340832f, -0.00515102f, 0.06213177f, 0.03500182f, -0.05457095f, -0.17546129f, 
    -0.11389390f, 0.03812432f, -0.03422023f, 0.15499814f, 0.04928308f, 0.09539126f, 0.08531899f, -0.03466576f, 
    -0.03288749f, -0.05355136f, 0.11730029f, 0.17990805f, 0.13710298f, 0.19441546f, 0.10236891f, 0.14676294f, 
    -0.49069712f, -0.11135105f, 0.24874111f, 0.11777940f, 0.32633698f, 0.07819925f, -0.09719919f, 0.08233560f, 
    -0.05478764f, 0.11423334f, 0.10275596f, -0.21303947f, -0.03692976f, -0.11363504f, 0.08002701f, -0.03642737f, 
    0.15159003f, 0.12820281f, 0.14677373f, 0.04002200f, 0.03186650f, -0.08973332f, -0.13614851f, -0.35212383f, 
    -0.08355875f, 0.11205219f, 0.13945493f, -0.02289679f, 0.01284356f, 0.02674134f, 0.06635481f, -0.12195877f, 
    -0.00498011f, 0.06665596f, 0.03909308f, 0.07061809f, 0.02931382f, 0.02991673f, 0.06220753f, 0.09148217f, 
    -0.05321068f, 0.81731272f, 0.53087366f, 0.03254383f, 0.33931819f, 0.00673629f, -0.22668578f, -0.07255114f, 
    -0.04443205f, -0.12976255f, -0.24056827f, -0.00994394f, 0.06551069f, -0.16980638f, 0.03979598f, 0.00849678f, 
    -0.28926557f, -0.25846002f, -0.06610425f, -0.14733191f, 0.24536423f, 0.04820460f, -0.01465643f, 0.02067295f, 
    0.12508139f, 0.14482564f, 0.14350571f, -0.06599983f, 0.00836497f, 0.20510256f, 0.03013057f, -0.10254911f, 
    0.10871655f, 0.16062763f, 0.15500626f, 0.11207528f, 0.22505605f, 0.22110753f, 0.16024727f, 0.25263271f, 
    0.02182613f, -0.14701420f, -0.05685848f, -0.03065858f, 0.11670491f, 0.14415301f, -0.01783631f, -0.06965911f, 
    0.06391145f, 0.05575641f, 0.11723682f, -0.07003270f, 0.16544548f, 0.03261190f, -0.05948338f, 0.08337850f, 
    0.02214093f, -0.24177596f, -0.06859571f, -0.13786554f, -0.01524863f, 0.06499459f, -0.28110802f, 0.00426931f, 
    -0.17740877f, 0.05586240f, -0.22697170f, -0.11012135f, 0.14521363f, 0.05410298f, -0.13883080f, 0.12777622f, 
    -0.00930305f, 0.05994397f, 0.05620099f, -0.02366309f, -0.04654135f, -0.11347344f, 0.05940409f, -0.13204454f, 
    0.17179802f, -0.16576217f, 0.17508329f, 0.14625148f, -0.10903447f, 0.09017304f, 0.05347708f, -0.07443028f, 
    0.09748720f, -0.06004630f, -0.03679194f, -0.16981316f, 0.17532197f, -0.10934845f, -0.05682411f, -0.02818682f, 
    0.10142008f, 0.06027829f, 0.06096858f, -0.09866877f, -0.11036855f, -0.14131111f, -0.08598357f, -0.25965750f, 
    0.00841711f, 0.03018379f, -0.02847473f, 0.02628883f, 0.12497516f, 0.12020461f, 0.12482173f, 0.10090592f, 
    -0.02775762f, 0.01682711f, 0.07619072f, 0.09843843f, 0.09836008f, 0.08612573f, 0.15045507f, 0.07706180f, 
    -0.53185409f, -0.09724961f, 0.42573252f, -0.26905572f, -0.34987342f, 0.11836969f, -0.16715850f, 0.09841557f, 
    -0.17460141f, -0.00315352f, -0.20257206f, 0.06594089f, 0.14446096f, -0.20139894f, -0.14765775f, -0.18638031f, 
    -0.05214515f, -0.03066412f, -0.03602920f, -0.19783063f, 0.02571367f, 0.22500890f, 0.21654508f, 0.20805985f, 
    0.14310253f, 0.11887560f, 0.09414314f, 0.11698908f, -0.16027436f, -0.18657701f, -0.02870859f, -0.03413568f, 
    0.13340060f, 0.03165324f, 0.06318155f, -0.03177992f, -0.07377680f, -0.04436098f, -0.07183519f, -0.04096770f, 
    0.03610033f, -0.11198791f, -0.20313954f, -0.07576293f, 0.09359476f, 0.07540587f, 0.07049304f, 0.17552726f, 
    0.12669739f, 0.07140852f, -0.01890532f, 0.03556094f, -0.13382338f, 0.02005137f, 0.00099901f, -0.00463009f, 
    -0.19982417f, 0.09709364f, 0.04555774f, -0.00073856f, 0.16927938f, 0.47964415f, -0.08377892f, 0.36315477f, 
    0.22082451f, 0.10629223f, 0.01548721f, 0.12108891f, -0.03929709f, 0.11716651f, 0.01136474f, -0.13828732f, 
    0.04621658f, 0.08765833f, -0.17738536f, -0.03586257f, -0.08219120f, 0.05251505f, -0.13629143f, -0.06763281f, 
    -0.14560589f, -0.09227034f, -0.19823077f, -0.06766539f, -0.21367769f, 0.00589049f, -0.24965470f, -0.11057424f, 
    0.00698930f, 0.18133450f, -0.02496525f, 0.01571609f, 0.01229104f, 0.08363008f, 0.04003612f, -0.06698664f, 
    0.14253734f, 0.02765246f, 0.11418629f, 0.11734970f, 0.20436811f, -0.02871191f, -0.39202562f, -0.05908804f, 
    -0.34022596f, 0.03004976f, -0.03615761f, 0.00757826f, 0.07487353f, 0.10357822f, -0.18419902f, 0.27008235f, 
    -0.14842536f, 0.09185806f, 0.00057037f, 0.02592861f, 0.02020785f, -0.02607087f, 0.21938838f, 0.22702651f, 
    0.20388998f, 0.09012020f, -0.07545014f, 0.39511809f, -0.13140139f, 0.10469227f, 0.05663954f, -0.16623490f, 
    -0.00181185f, 0.31506693f, -0.03582803f, 0.05643637f, -0.03089809f, 0.14465477f, -0.00036038f, -0.00067826f, 
    -0.04914761f, -0.11298592f, -0.05047535f, 0.00964622f, -0.15960111f, 0.23733257f, 0.02600270f, 0.02109522f, 
    0.09410363f, -0.12648356f, 0.00245250f, -0.01274371f, -0.14334641f, -0.12497606f, -0.13963607f, -0.05851032f, 
    0.05669617f, -0.08635148f, -0.00471748f, -0.18662135f, -0.08794478f, 0.10758927f, 0.08873806f, 0.23740430f, 
    0.12077093f, -0.10323583f, -0.20636880f, -0.02078011f, 0.09066250f, -0.06710035f, -0.10806075f, 0.11344679f, 
    0.12914543f, 0.05242185f, 0.00729266f, -0.02767822f, 0.00275383f, 0.11059512f, 0.00660555f, -0.00189589f, 
    0.22628729f, -0.07174862f, 0.07087628f, -0.13172133f, 0.03297910f, 0.28088641f, 0.23171186f, 0.19398288f, 
    0.08257287f, 0.04417236f, -0.09711798f, -0.03787009f, 0.01364056f, 0.17328459f, -0.04473936f, 0.05256859f, 
    0.00575853f, -0.08008626f, -0.01298786f, -0.06176099f, -0.01959811f, 0.00991175f, 0.03693345f, 0.19790252f, 
    0.16057770f, 0.13209663f, 0.30642560f, 0.26613408f, 0.03786191f, -0.00142850f, -0.01138569f, 0.02963983f, 
    -0.06282461f, -0.09226554f, 0.04449977f, -0.04732455f, -0.14735477f, -0.07047287f, 0.07858518f, -0.05612433f, 
    0.01667791f, -0.03139257f, -0.05476744f, -0.04781954f, 0.10464733f, 0.17668335f, 0.52586490f, 0.28527930f, 
    -0.09771688f, -0.01658826f, 0.07625715f, 0.16698927f, -0.05021840f, -0.08472819f, -0.02485103f, -0.00542931f, 
    0.03387681f, -0.16234019f, -0.04727658f, 0.04789415f, 0.03182280f, -0.01045523f, 0.04224929f, 0.19804913f, 
    -0.10918053f, 0.18226637f, -0.13145609f, 0.09449943f, 0.08480514f, -0.07217373f, 0.10029445f, -0.09316517f, 
    -0.00755463f, 0.00981856f, 0.05627483f, 0.14600062f, -0.01955942f, 0.12146104f, -0.06279153f, 0.00391072f, 
    0.10156219f, -0.01083323f, -0.15983473f, 0.03213038f, 0.46865901f, -0.15908925f, 0.18409887f, -0.04053463f, 
    0.11713394f, -0.09027493f, 0.14550152f, 0.04652811f, 0.05213341f, -0.19337109f, -0.00948899f, -0.02097068f, 
    0.02769113f, 0.09384250f, -0.02253128f, 0.09348741f, 0.01006692f, 0.04718088f, 0.08446002f, -0.11564554f, 
    0.28098398f, -0.43806201f, -0.27071190f, 0.11375180f, -0.06340379f, -0.14218542f, 0.09516826f, 0.10953572f, 
    -0.08611231f, -0.13264403f, 0.04919446f, -0.05462912f, 0.12719204f, 0.14428560f, -0.09059002f, 0.06366759f, 
    0.09242654f, -0.07741047f, -0.12376723f, 0.17104664f, -0.09480429f, 0.29083398f, 0.10132372f, 0.12312242f, 
    -0.00779395f, 0.05484616f, 0.01677158f, -0.02380747f, 0.05762367f, 0.08087911f, 0.01087919f, 0.05580615f, 
    0.07010663f, 0.01065175f, -0.02921183f, 0.02417130f, 0.05288354f, 0.00769445f, -0.09116273f, 0.24654105f, 
    -0.47612903f, 0.07904048f, 0.25072211f, -0.30166763f, -0.10187751f, 0.25402093f, 0.05844448f, -0.24893029f, 
    0.13221104f, -0.04236656f, -0.13523284f, 0.04881639f, -0.06660968f, 0.06486962f, -0.12875816f, -0.04870717f, 
    -0.09259428f, 0.09855596f, -0.16157934f, -0.14872627f, 0.07020697f, 0.01971294f, -0.00274502f, -0.06048806f, 
    -0.16767995f, 0.11398030f, 0.03861672f, 0.16117339f, -0.06491924f, 0.08629441f, 0.05822374f, -0.04952004f, 
    0.05548767f, 0.02726053f, 0.03850031f, -0.02206179f, -0.00575077f, -0.03960660f, -0.03420629f, -0.02710430f, 
    0.09448472f, 0.13215342f, 0.10395154f, 0.01430252f, -0.04259684f, 0.12478215f, 0.02755238f, 0.11174556f, 
    0.04579495f, -0.05152898f, -0.02198134f, 0.11590903f, -0.02974102f, -0.09878315f, -0.05768476f, -0.12129659f, 
    -0.04148277f, -0.01898164f, -0.05288648f, 0.01895868f, 0.15046498f, 0.13051420f, -0.06446882f, -0.01930000f, 
    -0.00989783f, -0.02952882f, 0.02172339f, 0.10118026f, -0.05176660f, 0.04156750f, 0.05941622f, -0.22833812f, 
    0.00846420f, -0.05660940f, 0.02300258f, 0.01836787f, 0.03014620f, 0.10494456f, -0.17983899f, -0.08562423f, 
    -0.08418386f, 0.13164875f, -0.47311950f, -0.02708011f, -0.20293015f, -0.06164087f, -0.00485831f, -0.09535699f, 
    -0.13575067f, 0.02944454f, -0.06797656f, -0.04200210f, -0.08088037f, 0.04745708f, 0.02317987f, 0.06927256f, 
    0.00633053f, 0.02750784f, -0.01588582f, 0.05073604f, 0.63246000f, -0.47322121f, 0.08656278f, -0.09741786f, 
    0.18829316f, -0.05740800f, 0.06749211f, 0.05688732f, -0.00570391f, -0.03552186f, 0.02051675f, 0.04211548f, 
    0.03437751f, 0.15512396f, -0.07410726f, 0.10065499f, 0.02403775f, 0.15933238f, -0.17443354f, 0.04995340f, 
    0.00229321f, 0.34124151f, -0.11762072f, 0.30018973f, -0.11479653f, -0.14161940f, -0.04040549f, -0.21518320f, 
    -0.07805035f, 0.07805128f, -0.03052856f, -0.02638744f, 0.01917555f, -0.03435338f, -0.01134877f, -0.07200962f, 
    0.07331610f, -0.14353730f, 0.01655244f, -0.05403820f, 0.03855884f, 0.02715623f, 0.08579163f, -0.23255886f, 
    0.00019688f, 0.21651851f, -0.07456546f, 0.03103136f, -0.05510082f, -0.00335184f, 0.00885618f, 0.02361639f, 
    -0.03445707f, -0.08902136f, 0.01863929f, 0.00113719f, 0.02265670f, 0.08229483f, 0.05444378f, -0.01444613f, 
    0.30628419f, 0.74335766f, 0.14615586f, 0.13235441f, 0.00517582f, 0.15091188f, -0.10318150f, 0.02492477f, 
    -0.04845186f, 0.04957447f, -0.00358892f, -0.00423053f, -0.02385494f, -0.01556556f, 0.05524388f, 0.06617779f, 
    0.15755349f, -0.11520762f, 0.16033278f, 0.15551057f, 0.18829919f, 0.20945764f, 0.29740086f, -0.18661526f, 
    0.05580254f, -0.02934416f, -0.01866534f, 0.02700312f, 0.02051248f, 0.19162226f, 0.01583786f, -0.08193780f, 
    -0.08401921f, -0.13581976f, 0.06948902f, -0.05681251f, 0.07141756f, 0.06264092f, 0.05015234f, 0.00919829f, 
    0.10858312f, -0.15394177f, -0.05721439f, -0.01612392f, -0.15598351f, 0.10811795f, 0.03885379f, 0.06898057f, 
    0.02390672f, 0.22336611f, -0.13038667f, 0.15694186f, 0.03805846f, 0.14912596f, -0.06323412f, 0.11599913f, 
    0.02123269f, 0.03996563f, -0.04622708f, 0.06030371f, 0.31136519f, 0.14792950f, -0.01196783f, -0.21443586f, 
    -0.16739036f, 0.04730523f, -0.01007178f, 0.02721204f, 0.04477805f, 0.01567825f, 0.09104976f, 0.01030436f, 
    -0.00687533f, 0.04407208f, 0.00174418f, 0.10784671f, 0.04049297f, -0.14443029f, 0.07191224f, 0.14316519f, 
    0.17261080f, 0.07542880f, 0.00500614f, -0.12225838f, -0.07219212f, 0.11630259f, -0.07401522f, 0.06654574f, 
    -0.03514867f, -0.07608486f, 0.00878894f, -0.24462557f, -0.07058485f, -0.19038346f, -0.14619361f, 0.03956630f, 
    -0.12544587f, 0.16551945f, -0.04419629f, 0.03932511f, -0.19859274f, -0.00269731f, 0.05619793f, -0.22993501f, 
    0.40167427f, 0.09535293f, 0.12939782f, -0.04179280f, -0.04371237f, 0.01377660f, 0.24239556f, -0.03447454f, 
    0.03342923f, -0.12362911f, 0.05996944f, -0.05767433f, -0.07838380f, -0.08195649f, 0.02250790f, 0.03645307f, 
    0.15468399f, 0.19420774f, 0.01435419f, -0.26189646f, 0.18260168f, 0.13911048f, -0.14443687f, 0.05404203f, 
    0.08561508f, 0.06816499f, 0.05589374f, 0.19943842f, -0.05664793f, -0.14378826f, 0.07827834f, -0.11232605f, 
    -0.06910279f, -0.17198126f, 0.07909321f, 0.07919387f, 0.15049998f, 0.08522081f, -0.09641880f, 0.02059808f, 
    -0.10402345f, -0.06632268f, 0.00711681f, 0.06573660f, -0.03985084f, 0.07421476f, 0.16650371f, 0.04459291f, 
    0.15730807f, 0.06566791f, -0.01651094f, -0.14240119f, -0.05617709f, 0.11732870f, -0.18991388f, 0.14961337f, 
    0.25246179f, 0.46429840f, -0.31805483f, 0.20376134f, -0.04932052f, -0.22838348f, 0.06820566f, 0.15387583f, 
    -0.14938651f, -0.02383320f, 0.23297286f, -0.15925193f, 0.09276401f, 0.02584578f, 0.02577915f, 0.04603978f, 
    -0.07233687f, -0.04632472f, -0.14613634f, 0.16792995f, 0.07984618f, 0.11060259f, 0.08920034f, -0.15490791f, 
    -0.03023008f, 0.07059780f, 0.04504112f, 0.05964685f, 0.06145215f, 0.02799850f, 0.01683664f, 0.10401783f, 
    -0.04445721f, 0.11292610f, -0.02271567f, 0.13028775f, 0.07518516f, -0.03071716f, -0.00573194f, 0.15582959f, 
    0.23075558f, 0.09425921f, 0.22491135f, -0.01910701f, 0.08133356f, -0.02691713f, -0.02181165f, -0.08721089f, 
    -0.09038598f, -0.00432707f, 0.17851377f, 0.07267974f, 0.17558022f, 0.03400962f, -0.06942212f, -0.01093481f, 
    -0.02721139f, -0.11446910f, 0.03481506f, 0.00539207f, 0.08386151f, -0.09903727f, 0.53809708f, -0.17931326f, 
    -0.01431805f, 0.08448119f, 0.19029985f, -0.07017109f, 0.16036849f, -0.05488523f, 0.01883851f, 0.14943317f, 
    0.10650762f, 0.01548761f, 0.02970385f, -0.03428718f, -0.07214504f, -0.01359230f, 0.06907486f, 0.08483411f, 
    0.33655623f, 0.30775642f, -0.15203388f, -0.29665953f, 0.07229819f, -0.11607426f, 0.05920697f, 0.08731713f, 
    -0.10078180f, -0.19850697f, 0.07167857f, 0.12373401f, 0.08166873f, 0.04473812f, -0.00925214f, -0.03955970f, 
    -0.11888488f, 0.02218483f, -0.01646189f, 0.02961670f, 0.09216942f, 0.36327353f, 0.22140509f, -0.25598228f, 
    0.15187165f, 0.13179313f, 0.04743468f, 0.06529656f, 0.02862957f, 0.02048085f, 0.16700193f, 0.04548665f, 
    0.13724437f, -0.04824759f, 0.08375305f, -0.14945692f, 0.01156369f, -0.05988261f, 0.12622911f, -0.09506037f, 
    -0.37755933f, -0.11113536f, 0.15887395f, 0.07030946f, -0.04047635f, 0.09071307f, 0.21048442f, 0.20058212f, 
    -0.00092309f, -0.05156587f, -0.02210375f, -0.11301685f, 0.00556159f, -0.00215049f, 0.06805524f, 0.01084511f, 
    -0.01507850f, 0.00205018f, 0.11043181f, -0.04130971f, -0.24643619f, -0.00177943f, 0.05920978f, 0.01443500f, 
    -0.05968985f, -0.08974343f, 0.24287315f, -0.02888766f, -0.03123028f, 0.12648468f, -0.04408177f, -0.04257832f, 
    -0.12540996f, -0.00948711f, -0.04495545f, -0.03757447f, -0.04819275f, -0.15253209f, -0.14167343f, 0.09645350f, 
    -0.26717368f, -0.13420451f, -0.32629782f, -0.02212456f, 0.03309908f, -0.10332441f, 0.09536441f, 0.00476105f, 
    -0.09033351f, 0.12749600f, 0.06920954f, 0.07371072f, 0.12263449f, 0.07296181f, 0.04136904f, -0.04773741f, 
    -0.13309820f, -0.01118132f, 0.04448349f, 0.16857125f, -0.18945006f, 0.15014036f, 0.21808065f, 0.30159763f, 
    -0.04426558f, 0.15147816f, 0.33843029f, -0.02536589f, -0.04468656f, 0.05724229f, -0.00376136f, -0.04387206f, 
    -0.03460940f, 0.01772417f, 0.03730877f, -0.09723090f, 0.00345989f, -0.15509947f, 0.11253492f, -0.05214531f, 
    0.16432038f, 0.23856796f, -0.10326780f, -0.15045196f, 0.02695271f, 0.01358695f, -0.09956395f, -0.07537404f, 
    -0.08850765f, 0.06435209f, -0.05851889f, -0.03168147f, 0.00747810f, -0.14468311f, -0.02475093f, 0.10088879f, 
    -0.00250588f, -0.01698409f, -0.00031240f, 0.11610028f, -0.18857589f, 0.07280268f, 0.03640649f, 0.03155161f, 
    0.02898705f, 0.03489995f, 0.06235234f, 0.09933238f, 0.03733128f, 0.05257582f, 0.01944618f, 0.05347250f, 
    -0.04028329f, -0.07822704f, -0.08677433f, -0.28501743f, -0.21814580f, 0.00206511f, -0.02817449f, -0.08063212f, 
    -0.01715770f, 0.13959120f, -0.01839380f, -0.03632415f, 0.00111476f, -0.06171437f, -0.10193639f, -0.00229288f, 
    -0.12383248f, -0.05920250f, 0.06941378f, -0.11389567f, 0.02880814f, 0.03297096f, -0.14198519f, 0.04715266f, 
    0.03422336f, 0.10238233f, -0.08060540f, 0.01159146f, 0.11420365f, -0.29955167f, -0.01565740f, -0.17168532f, 
    0.29107389f, -0.10296125f, 0.11516263f, -0.01220307f, -0.00627871f, -0.05846711f, 0.08305772f, -0.02229410f, 
    -0.03395779f, 0.04122110f, 0.03499829f, 0.06724134f, -0.01112714f, -0.00491953f, 0.07614204f, -0.03597089f, 
    0.42472261f, -0.16826503f, -0.12990238f, -0.14947239f, -0.06902745f, -0.02342766f, -0.04934760f, 0.07986191f, 
    -0.05309040f, -0.05033861f, 0.07976183f, 0.11408386f, -0.00104911f, 0.01081189f, 0.02369785f, -0.00946815f, 
    0.02538583f, -0.07272207f, -0.01489157f, 0.07232201f, 0.01571192f, 0.11199670f, -0.18280812f, 0.13208613f, 
    0.12095980f, -0.02623833f, -0.02058689f, 0.07005690f, -0.10507333f, 0.03753822f, 0.09831351f, 0.02859590f, 
    0.07633636f, 0.05839030f, 0.01646677f, 0.00871809f, 0.02529774f, 0.10166845f, -0.03110018f, 0.09584237f, 
    -0.15385683f, 0.46312431f, -0.20556842f, -0.01799011f, -0.35176480f, 0.06074274f, -0.03431484f, 0.14744525f, 
    -0.25393450f, 0.04581941f, 0.04855388f, -0.01024072f, 0.08849872f, 0.04356705f, -0.01974632f, 0.04562034f, 
    -0.13048539f, 0.15699862f, -0.05128642f, 0.08605509f, 0.05731118f, -0.05548222f, 0.00242721f, -0.15428835f, 
    -0.23886016f, 0.08641039f, -0.02874135f, 0.07908402f, 0.04650195f, 0.11014606f, -0.11058316f, 0.01153078f, 
    0.02106982f, -0.00851399f, -0.04428013f, 0.04180989f, -0.01898531f, 0.00566548f, -0.06766348f, 0.07946790f, 
    0.26472273f, 0.10098414f, 0.23287007f, 0.11814553f, 0.13271712f, 0.00545141f, -0.02131695f, -0.07442125f, 
    -0.03275087f, -0.08612312f, 0.08582290f, 0.10192920f, 0.20406543f, -0.08621215f, -0.16136815f, -0.10907792f, 
    0.00441089f, -0.10461199f, 0.00856234f, -0.00445512f, 0.16816956f, 0.13431181f, 0.25566646f, -0.33216712f, 
    -0.05029172f, -0.12663935f, 0.21954191f, 0.01263111f, 0.22489150f, 0.01874099f, 0.06965465f, -0.08385292f, 
    -0.06476056f, -0.03810908f, 0.07045300f, -0.06196446f, -0.04812846f, -0.00363645f, 0.02763788f, 0.03452464f, 
    0.27933031f, 0.42448989f, -0.27492502f, -0.27544966f, 0.07666370f, 0.01843456f, -0.04549377f, 0.16912952f, 
    -0.06147079f, 0.03401397f, 0.01426668f, 0.02450927f, -0.02088581f, -0.06674941f, -0.02661282f, 0.06395549f, 
    0.01536458f, -0.09608397f, -0.05999259f, -0.04535841f, 0.49625984f, -0.25714165f, 0.11241625f, -0.20333751f, 
    0.35292086f, -0.14236908f, -0.06626875f, 0.03696612f, -0.02674909f, 0.03779915f, 0.08510613f, 0.03441154f, 
    0.04432860f, -0.03456611f, 0.03040021f, -0.03571544f, 0.07204571f, -0.00103424f, 0.13454941f, -0.00131561f, 
    -0.23983239f, 0.47439611f, 0.06743764f, 0.21378000f, -0.19364995f, -0.14018521f, 0.12048782f, 0.13049918f, 
    -0.00140550f, 0.16439685f, -0.05931708f, -0.08742470f, 0.00514402f, -0.07317423f, -0.04936022f, -0.01026055f, 
    -0.02290373f, -0.02304620f, -0.06451792f, -0.13379285f, -0.03455342f, -0.01591416f, 0.12243709f, -0.05625226f, 
    -0.05192946f, 0.10387327f, -0.05103802f, 0.07261663f, -0.01298363f, 0.14888968f, -0.07689030f, 0.01618530f, 
    -0.03004406f, -0.04070658f, -0.02063710f, -0.00934764f, 0.05089340f, -0.04353766f, -0.09056685f, 0.01972743f, 
    -0.05263856f, 0.22356984f, -0.35814071f, 0.20232703f, 0.15634967f, 0.12631679f, -0.02295041f, 0.02874645f, 
    -0.10036381f, 0.05072504f, 0.07008158f, 0.06509177f, 0.04372316f, 0.05109426f, 0.03157659f, 0.06949544f, 
    0.07757033f, 0.03412866f, 0.15202801f, 0.05439492f, 0.18726034f, 0.29420590f, 0.39438376f, 0.10070524f, 
    -0.06083004f, 0.11026490f, 0.04928859f, 0.13771635f, 0.17930926f, 0.37149456f, -0.03303277f, 0.02100188f, 
    -0.00752786f, -0.00239453f, 0.03610720f, -0.08587608f, 0.07813734f, -0.09605707f, 0.02336748f, 0.02860257f, 
    0.16658857f, -0.16217330f, -0.05812955f, -0.15059279f, -0.21443985f, 0.05569743f, -0.13446179f, -0.02674722f, 
    -0.06552679f, 0.01381187f, -0.07509349f, 0.05948631f, 0.12277361f, -0.03786500f, -0.05861309f, 0.00966575f, 
    0.07338616f, 0.02356045f, -0.03840857f, 0.02478173f, 0.23369552f, 0.25689867f, -0.02188956f, -0.03736481f, 
    -0.43490875f, 0.06821790f, -0.00710079f, -0.04180668f, 0.12991069f, 0.07109530f, 0.01649072f, -0.05842987f, 
    -0.09050468f, 0.00592539f, 0.10462516f, -0.03283513f, 0.00358220f, -0.02797572f, -0.06052185f, -0.05227099f, 
    -0.06824447f, -0.04571164f, 0.03011978f, -0.26158869f, -0.23770973f, -0.05632763f, -0.12743965f, -0.03613485f, 
    -0.08536363f, -0.08965304f, 0.08637016f, -0.05591880f, 0.12875687f, -0.05002603f, -0.10652589f, 0.03148041f, 
    -0.03953233f, -0.03298701f, 0.16403084f, 0.00856975f, -0.59183460f, -0.06251622f, 0.22799487f, -0.40934449f, 
    0.07398242f, 0.03065422f, 0.00634851f, -0.34218568f, -0.18431653f, -0.11256073f, 0.05816801f, 0.00072921f, 
    0.02226054f, -0.09228446f, 0.02502497f, 0.05978094f, -0.00501896f, 0.13827017f, 0.13453007f, 0.04788580f, 
    0.01507360f, 0.35535324f, 0.38092139f, -0.24678136f, 0.10725276f, -0.01659832f, -0.00909654f, 0.01221015f, 
    -0.05714408f, 0.00731808f, -0.01423617f, -0.00842811f, 0.00931127f, -0.13067043f, 0.17819874f, -0.05985040f, 
    -0.06540963f, -0.03996736f, 0.09172965f, -0.09251683f, 0.07965164f, 0.25414729f, -0.07107806f, 0.11644620f, 
    -0.08461260f, -0.16671045f, -0.07959758f, 0.02193938f, -0.00337877f, -0.03947470f, 0.02083517f, -0.08891692f, 
    0.07982040f, -0.00917538f, -0.00101269f, 0.01654573f, -0.07581902f, 0.05875159f, 0.00976157f, 0.10023539f, 
    -0.05697125f, 0.00208724f, -0.20361134f, 0.25115144f, 0.41532227f, -0.11403891f, 0.22673038f, 0.01477334f, 
    -0.14767034f, 0.02365783f, 0.10493388f, -0.00277184f, 0.25546715f, -0.13221380f, -0.07534198f, 0.08789513f, 
    -0.05712881f, -0.00571278f, -0.00759208f, 0.13113156f, 0.00076746f, -0.41915807f, -0.15266219f, -0.07336057f, 
    0.17678165f, 0.07649478f, 0.01925259f, 0.13314539f, 0.10835122f, 0.15112200f, 0.14261548f, 0.06558112f, 
    0.03535853f, 0.00160179f, 0.01099899f, 0.06277756f, 0.13873601f, 0.01950804f, 0.05694243f, 0.06427327f, 
    -0.11833131f, -0.01621390f, 0.19951263f, -0.20913494f, -0.24489881f, -0.11612730f, -0.22657341f, -0.25471380f, 
    -0.01480799f, -0.10209392f, 0.11807943f, -0.01460211f, -0.10211816f, 0.14991941f, 0.03136979f, -0.09645235f, 
    0.03513192f, -0.06974025f, -0.07470731f, -0.11514535f, 0.25965706f, 0.12330347f, 0.04968831f, 0.15327694f, 
    0.29382238f, 0.16726325f, 0.19550425f, -0.07733224f, 0.25397575f, -0.01352715f, -0.05308859f, 0.03363556f, 
    -0.03132290f, 0.02127788f, 0.04201161f, -0.03430960f, 0.05571543f, 0.01570808f, -0.01100271f, 0.05926553f, 
    -0.17830770f, 0.11110260f, 0.47870794f, 0.04191758f, 0.39824244f, -0.08319432f, 0.01987406f, -0.05192282f, 
    -0.08786242f, -0.00593089f, 0.05109413f, -0.07632066f, 0.01311891f, -0.05008055f, -0.06329076f, 0.12219920f, 
    -0.06262092f, 0.08930099f, -0.03948471f, -0.01089988f, -0.16043210f, 0.45054704f, 0.28737441f, -0.09785111f, 
    0.07824592f, -0.01079603f, 0.01382816f, -0.06460967f, -0.00357866f, -0.06110300f, 0.09761328f, 0.03396199f, 
    0.05843076f, -0.01306533f, -0.01305824f, -0.01991668f, -0.01002343f, -0.05730167f, 0.02788469f, -0.08492406f, 
    0.29024711f, -0.11718591f, 0.27926788f, 0.18237744f, 0.20977631f, 0.29597262f, 0.12240528f, 0.01158487f, 
    -0.02722429f, -0.00777202f, -0.17604417f, -0.07287662f, 0.01670249f, 0.03092154f, -0.00141267f, -0.00616976f, 
    -0.03686861f, -0.06389315f, 0.16763298f, 0.08108508f, -0.01795241f, -0.01062642f, -0.04487372f, 0.22103515f, 
    0.16373065f, -0.05568368f, 0.08072040f, -0.08592578f, 0.00547467f, 0.14137182f, 0.00720556f, 0.09237914f, 
    0.00403230f, -0.00733038f, -0.04565299f, 0.04736300f, 0.04647316f, 0.11043674f, -0.21234776f, -0.05853952f, 
    -0.21892664f, -0.01145133f, 0.12326144f, 0.15782945f, -0.11943109f, -0.17380033f, -0.09015919f, -0.13386881f, 
    -0.05968107f, -0.01989094f, 0.02698931f, -0.04627499f, 0.00488835f, -0.04155822f, -0.01434319f, -0.05306031f, 
    0.06127712f, 0.21709771f, -0.11176224f, 0.03748289f, -0.12612446f, -0.10534623f, -0.11859880f, 0.36002630f, 
    0.26014507f, 0.02351686f, 0.07132671f, 0.04669025f, -0.00659938f, 0.04269244f, -0.03850871f, 0.03612904f, 
    -0.06338958f, 0.01434851f, -0.01595775f, 0.03218618f, 0.06439434f, 0.13792314f, -0.18080641f, -0.10452547f, 
    0.01421117f, -0.32881102f, -0.07921513f, -0.19996099f, 0.08066559f, -0.04658197f, -0.06583252f, 0.09627908f, 
    -0.20693217f, 0.14222749f, 0.12276959f, 0.09734077f, 0.00664150f, 0.04615442f, 0.00984940f, -0.04649444f, 
    0.01929168f, 0.00467303f, -0.00991778f, -0.09384782f, -0.05306141f, 0.00025342f, -0.06831611f, 0.19976084f, 
    0.32472450f, 0.01452578f, -0.07581355f, -0.08475668f, 0.15912165f, 0.05176485f, 0.02024722f, -0.00989732f, 
    -0.07017707f, -0.07602985f, 0.06492060f, -0.06251787f, 0.03893168f, 0.05586208f, -0.20887168f, -0.09235626f, 
    0.00421268f, -0.00336395f, 0.03518346f, 0.03815964f, 0.04482503f, 0.00606042f, -0.05895499f, 0.00416352f, 
    -0.04974255f, -0.01242534f, 0.01673736f, -0.03144856f, -0.04074556f, -0.04856010f, -0.02695881f, -0.03312503f, 
    -0.04338456f, -0.01249421f, -0.05195306f, -0.04374781f, 0.01619996f, -0.02781504f, 0.02608950f, -0.05049587f, 
    0.00670627f, 0.04009031f, -0.05032750f, 0.04707955f, -0.04799982f, -0.00221259f, 0.01399454f, -0.01992499f, 
    -0.03149879f, 0.02732599f, 0.02343206f, -0.01310477f, -0.04886614f, -0.00305240f, 0.03551787f, -0.05065860f, 
    -0.06033462f, -0.02309201f, 0.02228216f, -0.01187120f, -0.00003484f, 0.00699044f, 0.01990257f, -0.04432408f, 
    0.02558614f, -0.01080247f, 0.01424208f, -0.01690459f, -0.05334483f, 0.02452564f, -0.01814697f, 0.01685344f, 
    -0.02701765f, 0.04330109f, -0.02522937f, 0.00035041f, 0.04314294f, -0.00264299f, -0.03272413f, 0.04369165f, 
    0.03895133f, -0.02256084f, -0.01972948f, -0.06054580f, -0.02771664f, -0.05012622f, 0.01721682f, -0.01460731f, 
    -0.03372778f, -0.01771767f, -0.05446561f, -0.01758952f, 0.00503243f, -0.01936412f, -0.05801926f, -0.03633191f, 
    0.04131550f, -0.05721591f, 0.03850111f, 0.03428555f, 0.00173112f, 0.04629852f, 0.00106950f, -0.06083614f, 
    0.02757063f, 0.03114542f, 0.01737902f, 0.04359765f, -0.04550299f, 0.01160936f, -0.01367831f, 0.02152117f, 
    -0.03273911f, 0.01580966f, -0.06157731f, -0.02889921f, 0.00603565f, -0.01055423f, 0.04633080f, -0.02058556f, 
    0.01251555f, 0.01778352f, 0.04754992f, 0.02655769f, -0.04927367f, -0.01750426f, 0.01813644f, 0.02227136f, 
    -0.05710967f, -0.04330328f, -0.06135967f, 0.02815262f, 0.03912225f, 0.04649669f, 0.00274879f, 0.01791985f, 
    -0.03543774f, -0.05739246f, 0.04576684f, 0.02515162f, -0.00902411f, 0.02550277f, 0.00224649f, -0.01270872f, 
    0.00159442f, -0.00070508f, 0.03748970f, -0.05217406f, -0.01964399f, 0.03327282f, -0.01199440f, -0.03974825f, 
    0.02167616f, -0.01544952f, -0.02488374f, 0.02045089f, -0.02636810f, -0.06184744f, -0.00640683f, -0.00110300f, 
    -0.03434796f, -0.01807004f, 0.03105178f, -0.03606544f, 0.01684534f, -0.00642356f, 0.03886679f, 0.00174276f, 
    0.03989382f, -0.00328189f, -0.01665748f, -0.04860986f, -0.00213446f, -0.05351672f, -0.01523523f, 0.02359223f, 
    0.00347280f, 0.01686060f, -0.01057224f, -0.01879956f, -0.02379794f, -0.01242739f, 0.01632933f, -0.05166527f, 
    0.00255044f, -0.04031891f, -0.03151759f, -0.01227204f, 0.02480820f, -0.03469233f, -0.06148218f, -0.03938396f, 
    -0.02237503f, -0.01925626f, 0.02052382f, 0.03538504f, -0.03315025f, -0.05754997f, -0.03481793f, -0.00707837f, 
    0.01761813f, 0.04644144f, 0.02389102f, -0.00769237f, 0.04213362f, 0.04054722f, 0.00614736f, -0.04060871f, 
    -0.02224218f, -0.00880213f, 0.01067973f, 0.01316042f, 0.04983535f, 0.00008234f, 0.00415068f, -0.01040613f, 
    0.00886519f, 0.02111736f, 0.01739692f, -0.00114224f, -0.03878735f, -0.03347910f, 0.04181793f, -0.05748642f, 
    -0.04029327f, 0.03489318f, -0.00517900f, -0.01694783f, 0.03377655f, -0.06022967f, -0.05234352f, -0.04061431f, 
    0.03823346f, 0.04252471f, -0.05189970f, -0.01532610f, 0.01867020f, -0.02386400f, -0.00931648f, 0.02453705f, 
    0.04622456f, 0.00208342f, -0.01874114f, -0.00602543f, 0.00419621f, 0.00963609f, -0.02727551f, -0.01175924f, 
    -0.05096195f, -0.04201287f, -0.03291621f, -0.02529132f, -0.03089594f, -0.04908576f, 0.02532060f, 0.01988633f, 
    0.01439601f, 0.02142725f, 0.03754056f, -0.04915857f, 0.02195986f, -0.04937023f, 0.04399070f, -0.03537897f, 
    0.04756070f, -0.04555934f, 0.02567672f, -0.01977598f, 0.01096366f, -0.03448941f, -0.02307234f, -0.00200525f, 
    -0.01685346f, -0.05968535f, 0.01898520f, 0.00715696f, -0.01397143f, 0.03841841f, 0.00831904f, -0.01397525f, 
    -0.05037364f, 0.00457973f, -0.01389629f, 0.01495263f, -0.04079259f, -0.02718754f, 0.03135199f, 0.01723750f, 
    -0.03232810f, -0.04865363f, -0.04230058f, 0.02048783f, -0.00267770f, -0.03398300f, -0.02190436f, -0.04345177f, 
    -0.05551509f, -0.04747797f, 0.00248392f, -0.02850642f, -0.06141745f, -0.02905299f, -0.05892392f, 0.00157276f, 
    -0.01481678f, -0.02598543f, -0.00718806f, 0.04269418f, -0.01396309f, 0.03857573f, 0.02637421f, 0.00326851f, 
    -0.05719879f, -0.01880515f, 0.04325784f, 0.00295881f, -0.05026559f, 0.03293716f, 0.04660143f, -0.02872892f, 
    0.02790486f, 0.02200109f, -0.04351654f, 0.03233499f, -0.00459079f, 0.03602294f, -0.06052116f, -0.01470606f, 
    -0.00425585f, 0.03367736f, 0.00788758f, -0.00244059f, -0.04081664f, -0.00278738f, -0.04391636f, 0.05932929f, 
    -0.03080316f, -0.13138218f, 0.12963206f, 0.10291082f, -0.16995874f, -0.11345363f, -0.00904307f, 0.05899056f, 
    0.03808608f, -0.02072379f, -0.01864341f, -0.01749086f, 0.12173755f, -0.05878048f, 0.05554065f, -0.17474660f, 
    -0.02916596f, 0.07552449f, 0.03714987f, 0.02380791f, -0.42022198f, 0.01367523f, 0.14189720f, 0.01485735f, 
    0.00871002f, 0.04647752f, 0.03974682f, -0.07436967f, 0.30944851f, 0.07927015f, 0.03581737f, 0.02911549f, 
    -0.03415440f, -0.03514846f, 0.06452772f, -0.01032907f, 0.03164520f, -0.08427125f, 0.06152641f, 0.09566789f, 
    -0.35811961f, 0.19803354f, 0.04146328f, 0.13135725f, 0.04706912f, -0.01521919f, -0.18591465f, 0.12394281f, 
    0.06692772f, 0.14017302f, -0.12067661f, 0.11316156f, -0.12218174f, 0.04719848f, 0.24063514f, -0.07420359f, 
    -0.02555118f, -0.07033616f, 0.04973584f, -0.06668287f, -0.14853272f, 0.09529943f, 0.21990293f, 0.12208763f, 
    -0.22543214f, -0.21736602f, -0.02594336f, -0.08158008f, 0.01298278f, -0.11445374f, -0.01777380f, -0.00561955f, 
    0.02123276f, -0.06391624f, 0.04416107f, -0.01119540f, 0.13805683f, -0.02057121f, 0.02352287f, 0.02273884f, 
    0.52473295f, -0.24451469f, 0.24852051f, 0.30036750f, 0.36753789f, -0.04930599f, 0.17919026f, 0.28892502f, 
    0.20817356f, -0.06225573f, 0.04932330f, -0.03811923f, 0.09301366f, -0.03482936f, 0.05917370f, 0.00529611f, 
    -0.00224666f, 0.06139498f, 0.03880337f, 0.02833054f, 0.09106603f, -0.15879636f, -0.17312388f, 0.17652591f, 
    0.24361822f, 0.04430681f, 0.00809443f, 0.04659086f, 0.02546246f, 0.12360140f, -0.02914164f, -0.08612972f, 
    -0.06084827f, -0.10186958f, -0.04556508f, 0.02666781f, -0.01600253f, 0.05289653f, 0.04175900f, 0.03735908f, 
    -0.32194477f, -0.20304677f, 0.15379193f, 0.06861280f, -0.39406613f, -0.14991315f, -0.11397468f, -0.15209681f, 
    -0.05478336f, -0.06888621f, -0.14607981f, -0.10010666f, 0.04979226f, -0.15384147f, 0.17102934f, -0.13223991f, 
    -0.03087229f, -0.13417171f, 0.07455312f, 0.02071968f, 0.67108512f, 0.48053610f, -0.02341316f, -0.20343012f, 
    0.17093213f, 0.19187994f, 0.04616283f, 0.09233828f, -0.19509660f, 0.20848969f, -0.00850323f, 0.05897313f, 
    0.05019601f, 0.12048998f, 0.04539035f, 0.10397094f, 0.00581861f, 0.00879107f, 0.04980868f, 0.12773278f, 
    -0.43726930f, 0.17575853f, 0.31546405f, 0.38330713f, 0.14037187f, -0.01400310f, 0.03036295f, -0.00949010f, 
    0.00493389f, 0.06827044f, 0.03163801f, 0.02917863f, 0.09916546f, 0.01434495f, -0.06920656f, 0.00345015f, 
    -0.05649218f, 0.18475571f, -0.02620491f, -0.00657120f, -0.39335468f, 0.26339102f, 0.07355628f, 0.30362451f, 
    0.19227104f, 0.08367852f, -0.15610449f, 0.03253219f, 0.01222350f, -0.00172557f, -0.01110218f, 0.15631616f, 
    -0.03157227f, 0.06019789f, 0.07099671f, -0.06641462f, 0.00845098f, -0.14315999f, -0.02812334f, 0.02034256f, 
    0.66835999f, 0.13619997f, 0.17308211f, 0.01126713f, 0.21269754f, 0.07334913f, 0.21997263f, 0.29156062f, 
    0.01716389f, 0.07966625f, 0.02702366f, 0.11632765f, 0.16092932f, 0.00013783f, 0.01519572f, 0.07885914f, 
    -0.09859205f, 0.13926508f, 0.01527904f, 0.25353360f, 0.15433683f, -0.01068226f, 0.19115934f, 0.05605373f, 
    0.13360958f, -0.22831704f, 0.03734609f, 0.00525191f, -0.07585232f, -0.06326664f, -0.01228592f, -0.10100122f, 
    0.02133187f, -0.03234413f, -0.11020496f, 0.05663309f, 0.01730930f, -0.03853593f, 0.06386791f, -0.05895929f, 
    -0.15654150f, 0.14749748f, 0.54478991f, 0.03461348f, -0.10069419f, -0.14886475f, -0.15539987f, -0.29090792f, 
    0.06914763f, -0.05191742f, -0.00250270f, -0.01842627f, 0.03604539f, -0.08126243f, 0.04983507f, 0.01781712f, 
    -0.01288757f, 0.15971769f, 0.04426706f, 0.11513837f, 0.22692119f, 0.00035997f, -0.19130450f, -0.06161447f, 
    0.17474416f, 0.03984287f, 0.16044854f, -0.10802957f, 0.06093313f, -0.04961757f, -0.07309904f, -0.08189305f, 
    0.00757933f, -0.07051403f, -0.10719025f, 0.03787085f, 0.01371722f, -0.13666475f, 0.16969511f, -0.05461958f, 
    -0.35370472f, -0.28125972f, -0.41799656f, 0.17958331f, 0.41650867f, -0.01682043f, -0.03776725f, 0.02666401f, 
    0.22470328f, 0.07581707f, -0.09113434f, -0.08764028f, 0.03807361f, -0.01466533f, 0.17374167f, -0.04081204f, 
    -0.09172030f, 0.06264406f, 0.09686381f, -0.05621167f, 0.12942721f, -0.06135891f, -0.24632148f, -0.23057938f, 
    0.31628916f, -0.01107807f, 0.17418174f, 0.12676428f, -0.00678340f, 0.03384423f, -0.08396321f, -0.03504093f, 
    -0.06341093f, -0.03512973f, -0.03740965f, -0.04196770f, 0.01834810f, 0.08128128f, -0.07916577f, -0.09167156f, 
    -0.01861712f, -0.11286501f, -0.03860961f, -0.01773312f, -0.00569641f, 0.05217484f, -0.03064144f, -0.02133520f, 
    0.03538439f, 0.13492095f, -0.02051469f, 0.00664388f, 0.16076879f, -0.20709661f, 0.04235639f, 0.06334373f, 
    -0.03906588f, -0.00246917f, 0.17586648f, 0.04928875f, -0.34505972f, 0.06370727f, -0.09112557f, -0.10357730f, 
    -0.01604222f, -0.12823939f, 0.11466309f, -0.15525542f, -0.27517998f, 0.18040502f, -0.02375552f, 0.00097319f, 
    0.09339240f, 0.05145890f, -0.09707215f, -0.00107167f, 0.18051578f, 0.04022478f, -0.17897855f, 0.06323041f, 
    -0.29386893f, 0.08346028f, -0.02532434f, -0.13419083f, 0.03427272f, 0.03895377f, -0.02436436f, -0.08334538f, 
    -0.05908786f, 0.14172639f, -0.08468902f, 0.11634047f, -0.10970617f, -0.01020755f, 0.08180930f, -0.02043833f, 
    0.08701716f, 0.15725850f, 0.02956467f, -0.17818765f, 0.04744115f, -0.02114564f, 0.11657315f, 0.04587805f, 
    -0.01048773f, 0.05527098f, 0.01157627f, -0.05821051f, 0.14337187f, 0.12144363f, -0.00554164f, -0.04010881f, 
    0.00849928f, -0.01533867f, -0.00444480f, -0.11870845f, 0.00123024f, -0.02597187f, 0.08406482f, -0.25345764f, 
    0.35993508f, -0.11227185f, -0.20041078f, 0.21498586f, 0.10523659f, -0.11585315f, 0.05004522f, 0.01177266f, 
    -0.21815354f, 0.05649897f, -0.05457871f, -0.08674334f, 0.06720185f, -0.09904343f, 0.15796997f, 0.12889840f, 
    0.03683480f, -0.16294132f, 0.09372497f, -0.01718681f, 0.19207177f, 0.00558254f, 0.05683158f, 0.10310183f, 
    0.26982364f, 0.07210327f, -0.00388676f, 0.03691428f, 0.05195780f, -0.00914821f, 0.03969077f, -0.00796155f, 
    -0.03211369f, -0.07849479f, -0.00381976f, 0.04178304f, 0.00079228f, -0.00485620f, 0.05927816f, -0.00757022f, 
    -0.22379893f, -0.21338114f, -0.22284372f, -0.10102011f, -0.00012357f, 0.06432381f, 0.04912577f, -0.02780526f, 
    0.03890757f, 0.15665933f, 0.09098255f, 0.08904684f, 0.06295539f, 0.08022500f, 0.13503686f, 0.27339453f, 
    0.07252329f, -0.05612582f, -0.01536892f, 0.01105799f, 0.57048100f, 0.27596372f, -0.07094241f, -0.06365962f, 
    0.03116958f, 0.07353748f, 0.09179053f, -0.17776458f, 0.04270826f, 0.00378811f, 0.01942473f, 0.02183556f, 
    -0.09946159f, 0.00824773f, -0.06990303f, 0.08017699f, 0.04082523f, -0.10274495f, 0.08594966f, 0.06958164f, 
    -0.02941492f, 0.08420768f, 0.33660579f, 0.17227742f, 0.22263005f, -0.10432902f, -0.04244598f, -0.00734705f, 
    0.07590660f, 0.20224184f, 0.03345909f, -0.00087351f, 0.02722163f, 0.02539670f, -0.00416134f, 0.08279059f, 
    -0.01493739f, -0.01870841f, 0.08851743f, 0.04626909f, -0.52922046f, 0.25754613f, 0.14127712f, -0.11931279f, 
    -0.14606978f, 0.02113223f, 0.01748453f, 0.00849383f, -0.01598490f, 0.10008219f, 0.06167648f, -0.04217524f, 
    0.17521961f, -0.07715392f, -0.03548364f, -0.00171297f, 0.04362310f, -0.00467253f, 0.19842505f, -0.00718679f, 
    0.58915800f, 0.31068930f, 0.11388404f, -0.31678605f, 0.16974249f, 0.17732292f, 0.11345673f, 0.02816894f, 
    0.06158343f, -0.10550183f, 0.01514700f, -0.03293516f, -0.02493751f, -0.10612534f, -0.09816522f, -0.05976885f, 
    0.01981161f, 0.02644406f, 0.06186379f, 0.12595361f, 0.37086445f, 0.10993426f, 0.20824163f, 0.12310786f, 
    -0.12643582f, -0.09462975f, -0.01189173f, -0.07945833f, 0.01608803f, 0.16918293f, 0.03522406f, -0.05775653f, 
    -0.00959076f, -0.00867583f, -0.02382151f, -0.04788731f, -0.03244773f, -0.09007367f, 0.04985210f, 0.08082966f, 
    -0.55329227f, -0.22415099f, 0.41599068f, 0.07974463f, 0.05116516f, 0.07269280f, 0.03543999f, -0.03335796f, 
    0.08261933f, 0.18460310f, 0.05876693f, -0.01771087f, 0.00678725f, -0.02290657f, 0.03404330f, -0.13920970f, 
    -0.08599863f, 0.17011099f, -0.13339958f, -0.17391343f, 0.11124939f, -0.11730438f, -0.02356501f, -0.01765390f, 
    -0.10889530f, 0.10183633f, 0.19473277f, 0.11210895f, 0.02800511f, -0.01375082f, 0.05454449f, 0.02488281f, 
    0.02240047f, 0.03961870f, -0.04304523f, -0.10520715f, -0.00166153f, -0.09921482f, 0.04452720f, 0.16999362f, 
    -0.00066131f, 0.04523809f, 0.07686617f, 0.14731435f, 0.17632531f, 0.10037377f, 0.06045188f, 0.12149364f, 
    0.13748592f, -0.06587230f, 0.08538109f, 0.04263525f, 0.05045240f, -0.03177403f, 0.00111520f, -0.03549616f, 
    -0.00893570f, -0.02153325f, -0.04810254f, -0.05183424f, 0.05113874f, 0.03836984f, 0.10838095f, 0.07731871f, 
    0.16272898f, 0.00692029f, 0.08648515f, 0.06810261f, 0.05231613f, 0.03903840f, -0.07206847f, -0.01339046f, 
    0.02003344f, 0.07320616f, 0.06297105f, -0.27828011f, -0.01633304f, 0.02478246f, -0.14017826f, -0.12791753f, 
    -0.15078308f, -0.00776977f, -0.11355632f, 0.01168670f, -0.07466432f, -0.00953690f, -0.04557782f, -0.06187216f, 
    -0.01204794f, -0.04290729f, 0.14118260f, 0.02040220f, -0.07646302f, -0.03470166f, -0.09567209f, 0.06326949f, 
    -0.03701800f, 0.15965642f, 0.09799134f, 0.02123161f, -0.25980487f, -0.20828860f, -0.44384447f, 0.07232645f, 
    0.06003094f, -0.16192764f, 0.12174641f, 0.05337870f, 0.14104533f, 0.05850796f, -0.01924657f, -0.02785830f, 
    0.08257735f, 0.00700905f, -0.00488863f, 0.15259911f, 0.23343076f, 0.16450834f, 0.15642942f, 0.16275965f, 
    0.17723532f, 0.06988994f, -0.44963247f, -0.10088919f, -0.11168049f, 0.08433000f, -0.12641099f, 0.00972096f, 
    -0.05374172f, 0.11076036f, -0.02387333f, 0.22353809f, -0.05520435f, -0.03847899f, 0.01736381f, 0.07905982f, 
    -0.07561051f, 0.07471856f, 0.11094028f, 0.21407789f, 0.18464492f, -0.32313582f, -0.05402004f, 0.12161188f, 
    0.11957742f, -0.10365708f, -0.19118027f, -0.10675192f, -0.09891927f, -0.07787896f, 0.06686151f, 0.06455092f, 
    -0.02162800f, 0.02758497f, -0.03336306f, -0.05997264f, -0.07335690f, -0.07150172f, 0.03586992f, -0.11877421f, 
    0.40398532f, 0.27072352f, -0.00114693f, 0.14985941f, -0.18130477f, 0.03130176f, -0.00040572f, 0.19526465f, 
    -0.03975250f, 0.27171403f, -0.02102568f, -0.04888242f, -0.10835311f, 0.17143841f, 0.07086569f, 0.02836980f, 
    -0.03822125f, 0.10870684f, -0.05176145f, 0.15148230f, -0.21159755f, -0.00091040f, -0.05053418f, -0.06128485f, 
    -0.09489585f, 0.00524824f, 0.05356840f, -0.06175407f, 0.07791057f, 0.15645793f, -0.00318361f, -0.01875567f, 
    -0.10350402f, -0.01843857f, -0.04633917f, -0.02398558f, 0.07507442f, 0.02648175f, -0.08918352f, 0.17798793f, 
    -0.06861266f, -0.26816660f, -0.11698879f, 0.02618145f, -0.08413532f, -0.11666071f, -0.11511704f, -0.14122754f, 
    -0.07798926f, -0.11022792f, 0.02047414f, 0.10651251f, 0.26784721f, -0.06855928f, 0.02760414f, 0.01600947f, 
    0.13461460f, 0.02800828f, 0.27704141f, 0.02490148f, -0.08186360f, 0.15367687f, 0.30234107f, -0.31755385f, 
    -0.09159280f, 0.11430239f, -0.00197016f, 0.17519675f, 0.12895341f, 0.16882288f, 0.24410141f, -0.10958437f, 
    -0.02518430f, -0.03513810f, 0.06942949f, 0.05173856f, 0.05263921f, -0.12907277f, 0.16849191f, 0.07149404f, 
    0.39907634f, 0.20271325f, -0.18248370f, -0.04726127f, -0.20956466f, -0.09307552f, -0.14237402f, 0.07411305f, 
    -0.01558299f, -0.07136335f, 0.03486926f, -0.01468907f, -0.17759866f, -0.02041090f, 0.06487034f, -0.10624183f, 
    -0.09821719f, -0.08770497f, -0.07191010f, -0.15869322f, 0.04981199f, 0.07403916f, -0.24509902f, -0.03415490f, 
    0.20819794f, -0.09441613f, -0.13641648f, -0.04548547f, -0.02129493f, -0.04017014f, -0.00456411f, 0.08463452f, 
    0.11248098f, -0.14801304f, 0.12021239f, -0.02749380f, -0.01990562f, 0.02224593f, 0.14153562f, -0.01837548f, 
    -0.28478897f, 0.22060423f, 0.16556276f, -0.15896717f, -0.12154222f, -0.02249284f, -0.02825545f, 0.14451696f, 
    0.08654825f, -0.03694200f, 0.06831189f, -0.08963192f, 0.00194786f, 0.03447372f, -0.01053002f, 0.07128925f, 
    0.07567959f, 0.18862772f, -0.04566320f, 0.02489194f, 0.12010341f, 0.20100327f, 0.24747406f, 0.03377540f, 
    -0.09981279f, 0.02079216f, -0.02783726f, 0.07557599f, 0.01481163f, 0.11167618f, 0.00659020f, -0.02617170f, 
    -0.02898403f, 0.01909384f, -0.06932435f, -0.04149213f, 0.00311750f, -0.24842301f, -0.00361929f, -0.04170437f, 
    -0.28974697f, -0.30592912f, -0.24913083f, -0.26084247f, -0.21835142f, -0.06820262f, -0.19194162f, -0.14075269f, 
    -0.02130302f, 0.06777263f, -0.08617476f, 0.09734494f, -0.08855762f, -0.01005706f, 0.07600172f, 0.21239889f, 
    -0.13821346f, -0.02454251f, 0.03589278f, 0.01455319f, 0.19783926f, 0.25422329f, 0.20032859f, -0.01728158f, 
    0.01816318f, 0.10552339f, 0.12656325f, 0.07437858f, 0.00611734f, 0.11369414f, -0.06604377f, -0.03410864f, 
    -0.00073185f, -0.00582264f, 0.03336916f, 0.04682523f, 0.03319429f, -0.07705502f, -0.01140176f, -0.00849249f, 
    -0.03085004f, -0.12483757f, -0.42733416f, 0.01136939f, -0.30188614f, 0.05672377f, -0.07639243f, -0.11419918f, 
    0.16905361f, 0.00490711f, 0.03168393f, 0.11249483f, 0.14197993f, -0.09233973f, -0.03795799f, 0.00838637f, 
    -0.07789444f, 0.08777056f, 0.00880532f, 0.17978798f, 0.24065480f, 0.30864704f, 0.10969986f, -0.16555712f, 
    -0.10297824f, 0.19565260f, 0.07852108f, 0.04014236f, 0.01059038f, 0.03949031f, -0.04744848f, 0.01767748f, 
    0.04460461f, -0.00523232f, -0.06795903f, 0.01331472f, -0.12095100f, -0.10594365f, -0.02127845f, -0.14613581f, 
    0.08602601f, 0.04660454f, 0.09853769f, -0.00329833f, -0.07600183f, 0.09925327f, 0.09270504f, 0.08826836f, 
    0.13168062f, 0.10483853f, 0.10015064f, 0.09909915f, 0.06389847f, -0.03010404f, 0.04612573f, 0.01853467f, 
    0.00760600f, -0.03867883f, 0.05537906f, 0.04035156f, 0.10516926f, -0.03141194f, -0.03073090f, -0.05067144f, 
    0.07818295f, 0.22669771f, 0.04384249f, 0.06368593f, 0.00104199f, 0.16808255f, -0.08809756f, 0.18779375f, 
    0.02535342f, 0.11159173f, 0.09735947f, -0.11700843f, -0.00105257f, 0.01087539f, 0.02901480f, -0.09727609f, 
    0.25136557f, 0.20031466f, 0.50949669f, 0.05542590f, 0.02609359f, 0.01929397f, 0.07972191f, 0.07336295f, 
    0.13415158f, 0.22172065f, -0.05057324f, 0.02556346f, 0.16496395f, -0.03405753f, -0.17786157f, -0.14451198f, 
    -0.09307225f, -0.02040970f, -0.18775184f, -0.02779749f, -0.14433683f, 0.21836992f, -0.05122416f, -0.18980202f, 
    -0.09610710f, 0.01639628f, -0.09248006f, 0.00941822f, 0.09955908f, 0.03309517f, 0.09608475f, 0.14599660f, 
    0.01247886f, -0.06150950f, 0.03755604f, 0.12361681f, 0.07993349f, 0.04319313f, -0.14367206f, 0.12748013f, 
    -0.23984107f, -0.14549217f, 0.06475776f, 0.01297148f, -0.16102837f, -0.01045704f, 0.16632155f, 0.18649189f, 
    0.07838895f, 0.03227299f, 0.08318942f, 0.26186806f, 0.01850268f, 0.02791885f, -0.04210328f, -0.20152104f, 
    0.04543486f, 0.04967034f, 0.12406255f, 0.13456503f, 0.03494697f, -0.03617933f, -0.01619217f, 0.05507110f, 
    -0.03168839f, 0.08559641f, 0.20971261f, 0.05267461f, 0.04296384f, 0.28193897f, 0.14804886f, 0.04378062f, 
    -0.03921755f, -0.05794884f, -0.05858282f, 0.05818442f, 0.02573636f, -0.02623861f, -0.01372152f, 0.02120989f, 
    0.10639533f, -0.00927630f, 0.07127991f, 0.00477421f, 0.00897300f, 0.02045863f, 0.04105632f, 0.09725233f, 
    0.03070790f, 0.13411862f, 0.10871288f, 0.16571173f, 0.06036816f, 0.17198461f, 0.14761348f, -0.02850584f, 
    -0.03785827f, 0.04267835f, -0.04635717f, 0.00670040f, -0.01730615f, 0.20463093f, 0.12600456f, 0.09025551f, 
    0.27545178f, 0.09012844f, -0.13160512f, 0.11923093f, 0.08266492f, -0.04067864f, -0.14361449f, -0.09355310f, 
    -0.12216675f, -0.16993786f, -0.17885567f, -0.04582269f, -0.12878448f, -0.10159759f, -0.14967193f, 0.04810068f, 
    -0.25585461f, -0.21696912f, -0.07801612f, 0.14538352f, 0.09393106f, -0.11828180f, -0.29829469f, 0.19862191f, 
    -0.11189145f, -0.06138724f, 0.07290014f, 0.08041918f, 0.01613756f, 0.04860027f, -0.00998591f, 0.01806116f, 
    0.21258256f, -0.04179905f, 0.03607466f, 0.05904038f, 0.22890033f, 0.20923784f, 0.00990260f, -0.10062824f, 
    0.01045803f, 0.05196864f, 0.00607616f, -0.12880139f, 0.12856448f, 0.12119829f, -0.15291052f, 0.30242008f, 
    -0.06278721f, -0.01135003f, -0.17450881f, -0.23809764f, -0.07152998f, -0.13215508f, -0.03070014f, -0.01504946f, 
    -0.10355446f, 0.05023749f, 0.20089625f, 0.17989768f, 0.08187295f, 0.17445734f, -0.00540319f, 0.04754695f, 
    -0.00435193f, 0.11454856f, -0.01669202f, -0.06443079f, -0.04399958f, -0.06304205f, -0.06104746f, -0.15802799f, 
    -0.09964909f, 0.02361777f, -0.20223908f, 0.03699379f, -0.14979969f, -0.03071786f, -0.06446095f, -0.02354836f, 
    0.05598313f, -0.06573595f, -0.05822057f, -0.17904353f, -0.15655783f, -0.13648084f, -0.14543827f, -0.15118869f, 
    -0.09617519f, -0.22356664f, -0.07874934f, 0.07158510f, 0.01200703f, 0.13720264f, 0.00045615f, 0.03388847f, 
    -0.13530008f, -0.07261966f, -0.20998974f, -0.20398439f, 0.03302934f, -0.10558806f, -0.02915276f, -0.02231277f, 
    0.05385129f, -0.00482819f, 0.06809700f, 0.07518161f, 0.03071561f, 0.03454496f, 0.10081474f, 0.13337633f, 
    0.19274436f, 0.12806368f, -0.06865211f, -0.02883895f, -0.11938441f, 0.02950954f, 0.05521975f, 0.23068888f, 
    0.15535039f, -0.10160919f, -0.20125110f, -0.08706404f, -0.30565307f, -0.12286375f, -0.16077583f, -0.15951012f, 
    -0.19559485f, -0.15017550f, -0.10537050f, -0.12894352f, -0.17070006f, -0.03379870f, -0.24953726f, -0.18657655f, 
    0.15507752f, 0.01843906f, 0.06337451f, 0.13750760f, -0.02139943f, -0.02688748f, 0.12742631f, 0.03367813f, 
    -0.12282408f, 0.28725189f, 0.11777215f, -0.05530737f, -0.05481534f, -0.01942419f, -0.06511805f, -0.02077965f, 
    0.07513610f, -0.09268247f, -0.01174252f, -0.05478943f, -0.06336495f, 0.03630013f, 0.12381314f, 0.16694222f, 
    0.05278565f, -0.13963257f, -0.05512004f, -0.09723052f, -0.21413781f, -0.27208188f, -0.09112620f, -0.11692584f, 
    -0.14690094f, -0.16914584f, -0.09519520f, 0.07958741f, -0.13760974f, -0.09869438f, -0.36408538f, -0.23813713f, 
    -0.03511767f, 0.09331305f, 0.07571524f, -0.07383866f, -0.06823659f, -0.07671292f, -0.02201906f, -0.01975953f, 
    -0.00582757f, -0.03623655f, 0.00850303f, 0.05165465f, -0.05423515f, -0.07597227f, 0.13294677f, -0.04557211f, 
    -0.05414952f, 0.19120660f, -0.00239717f, 0.06027843f, -0.15442900f, -0.08213596f, 0.20636992f, 0.02137338f, 
    0.04105169f, 0.02445932f, 0.17918630f, 0.19327851f, -0.17421445f, 0.19677398f, 0.15181255f, 0.00851880f, 
    0.06483398f, -0.01054969f, -0.01989855f, 0.03252865f, 0.01234931f, 0.13786399f, -0.05370762f, 0.15690143f, 
    -0.37597460f, 0.45432296f, -0.02752034f, -0.12849851f, 0.12663704f, 0.04848702f, -0.05423623f, 0.05059524f, 
    -0.01827325f, 0.11860541f, 0.03792193f, 0.26137736f, -0.03968134f, 0.09686520f, 0.12110177f, 0.01085063f, 
    -0.02860555f, 0.05432159f, 0.01319711f, 0.09052368f, 0.01661100f, 0.01454328f, -0.04262588f, 0.17025049f, 
    0.05223536f, -0.06673687f, 0.09803511f, 0.06031602f, -0.05288281f, -0.01420196f, -0.04583422f, -0.05912632f, 
    0.09290586f, -0.06377279f, -0.05161331f, -0.06734319f, 0.01926122f, 0.06704263f, 0.07194912f, -0.00368999f, 
    0.61950904f, 0.20559514f, -0.30321679f, 0.31012985f, 0.50821358f, -0.18260394f, 0.18133703f, -0.05248079f, 
    0.10572147f, 0.12113050f, 0.28226361f, -0.00516887f, -0.02236401f, 0.14138329f, 0.24457528f, 0.15648720f, 
    0.17550150f, -0.03223934f, 0.05564859f, 0.19139771f, -0.06594455f, -0.07015532f, -0.05933349f, -0.05647311f, 
    0.07459977f, -0.02175901f, -0.08034092f, -0.14138614f, 0.09560936f, 0.10374503f, 0.13706572f, 0.08139926f, 
    -0.01476017f, -0.04161170f, 0.00540686f, 0.05012249f, 0.03631711f, -0.02402941f, 0.01357945f, -0.03719379f, 
    -0.15421800f, 0.00994831f, -0.02307645f, -0.06080758f, -0.13712384f, -0.07487515f, 0.02429717f, -0.03356559f, 
    -0.11264279f, 0.02186909f, 0.06763906f, -0.09887480f, 0.08105930f, 0.01453054f, 0.07467315f, 0.09926224f, 
    0.24951370f, -0.02233302f, 0.00930791f, -0.02582049f, -0.15903269f, -0.28912678f, 0.13488030f, -0.14479360f, 
    -0.16768637f, 0.11725772f, 0.10546304f, -0.13279174f, -0.00725840f, 0.08320125f, -0.04954140f, 0.23573430f, 
    0.00205534f, 0.02543871f, 0.07025999f, 0.00646645f, 0.05401120f, -0.11210155f, 0.11384420f, 0.08342292f, 
    0.07791083f, 0.02628473f, 0.40407485f, 0.19553173f, 0.43287861f, -0.08011094f, 0.22456518f, 0.11872276f, 
    0.09524754f, -0.08126112f, 0.07691842f, 0.01850032f, 0.04758868f, -0.02381937f, -0.00089447f, 0.04864945f, 
    -0.09012702f, 0.13500775f, 0.05369763f, -0.01719060f, -0.70407563f, 0.23994401f, 0.40158165f, 0.05718447f, 
    0.24401172f, 0.08088022f, 0.12382907f, 0.04621596f, -0.09159522f, -0.02633355f, 0.06996535f, -0.16181046f, 
    0.12989751f, -0.04263045f, 0.02041841f, 0.04256913f, 0.05264861f, 0.02390531f, 0.08182298f, -0.04229627f, 
    -0.03104454f, -0.22549587f, 0.13316527f, -0.17371526f, 0.28663287f, 0.02832330f, 0.16220783f, 0.26279178f, 
    0.03026050f, -0.11180299f, 0.04345884f, -0.00251970f, 0.05244891f, -0.15791872f, 0.00959434f, 0.03111169f, 
    -0.00158995f, 0.06396946f, 0.15254748f, 0.17708257f, 0.09958863f, -0.21901783f, -0.01650783f, 0.20971580f, 
    0.13351411f, 0.07987222f, -0.02412379f, 0.17010824f, 0.18057323f, 0.10069516f, 0.11742337f, -0.05809720f, 
    -0.01269155f, 0.14146230f, 0.08918855f, 0.17746598f, 0.18446404f, 0.03880651f, 0.09152841f, -0.05766923f, 
    -0.35116684f, -0.27443564f, -0.02840703f, -0.00894285f, -0.04170838f, 0.05265922f, 0.12032486f, 0.05956452f, 
    0.03600710f, -0.08522598f, -0.03253603f, 0.04583814f, -0.06113617f, -0.05974448f, -0.07473574f, -0.01271625f, 
    -0.16641191f, 0.08408266f, -0.02059489f, 0.20391528f, -0.14755301f, -0.38692874f, -0.24604909f, 0.03862227f, 
    -0.03802693f, 0.01859626f, 0.13223642f, 0.07035667f, 0.14228773f, -0.11966115f, -0.02232546f, -0.01566576f, 
    -0.06146049f, 0.03092650f, -0.05757599f, 0.04667787f, 0.04677575f, -0.03281068f, 0.15002304f, 0.04123897f, 
    -0.29933584f, 0.05626676f, -0.06247478f, -0.07385359f, 0.09974134f, 0.01297502f, -0.04626669f, -0.02382712f, 
    0.10817537f, 0.01235145f, 0.05033418f, 0.17094989f, 0.18753920f, 0.04347041f, 0.07194281f, 0.05721124f, 
    -0.03761045f, -0.03569096f, -0.00044041f, -0.02078780f, -0.18008891f, -0.23618221f, -0.41897944f, -0.13711084f, 
    0.24902880f, 0.01117129f, 0.02595485f, -0.04884957f, 0.12823795f, 0.11078031f, 0.02214341f, 0.00913079f, 
    0.02320289f, 0.20337792f, 0.09265865f, -0.14643537f, 0.07267284f, 0.28359461f, 0.12257628f, -0.06958705f, 
    0.00681590f, -0.03253543f, 0.01533844f, -0.03664041f, -0.05443240f, 0.02658778f, 0.00189945f, 0.02256872f, 
    -0.01426141f, 0.03994415f, -0.04311838f, 0.03781254f, -0.02983828f, -0.00507019f, 0.01109082f, -0.04914490f, 
    -0.04932453f, -0.04246541f, -0.03051964f, 0.04310007f, -0.02248371f, -0.01320958f, -0.00838071f, 0.00360576f, 
    -0.04827448f, -0.02542564f, -0.00515073f, 0.01691203f, -0.01768965f, 0.04375190f, 0.02152609f, 0.02841499f, 
    -0.00858480f, -0.04904779f, -0.03139579f, -0.02865274f, 0.02861376f, -0.02658614f, 0.04822475f, -0.04000202f, 
    0.01734484f, 0.04789109f, 0.02276147f, 0.02156147f, -0.00770051f, -0.04311042f, 0.03571767f, -0.05485537f, 
    0.03444103f, -0.05034302f, -0.05818802f, 0.03209969f, 0.03062291f, -0.02816455f, -0.02116162f, 0.03918339f, 
    -0.05592841f, 0.04908831f, 0.04294714f, -0.02526127f, -0.02805933f, -0.02319101f, 0.03280184f, 0.00271203f, 
    0.01782651f, -0.03474381f, -0.05836402f, -0.04204025f, -0.03711541f, -0.06026998f, -0.03260987f, -0.00646966f, 
    -0.01886426f, 0.00206387f, 0.01146098f, -0.05534500f, -0.00686333f, -0.00596219f, -0.03667697f, -0.02973421f, 
    0.04353227f, 0.02767668f, -0.00092002f, -0.00884848f, 0.03251727f, -0.03774703f, -0.03890650f, 0.03481677f, 
    0.01876940f, 0.02160789f, -0.03218311f, -0.00745560f, -0.05601934f, -0.05061474f, -0.06107236f, -0.05094073f, 
    0.03415496f, -0.04719618f, -0.04270960f, -0.01586726f, 0.00066333f, 0.00159455f, -0.04558611f, -0.05562058f, 
    -0.02475111f, -0.02803404f, -0.04962811f, -0.05740609f, -0.01030055f, -0.04156712f, -0.05846321f, -0.01227026f, 
    -0.00301610f, 0.04377091f, -0.02586273f, 0.00750890f, 0.01083514f, -0.03985375f, -0.05550133f, -0.01039264f, 
    0.05064931f, -0.05307271f, 0.02404281f, 0.02764826f, -0.02079145f, -0.04631933f, -0.03332319f, 0.01194919f, 
    0.04414146f, -0.02839033f, -0.02012465f, 0.01352436f, -0.00969414f, 0.04855202f, 0.02471764f, 0.03520134f, 
    -0.04037378f, 0.00433115f, 0.00702810f, -0.00428222f, -0.04912205f, -0.03133877f, 0.03490889f, 0.00112123f, 
    0.00208969f, -0.03470284f, 0.04954614f, -0.02143989f, -0.04105694f, 0.01709268f, -0.02057295f, -0.01375086f, 
    -0.02973795f, 0.04834554f, 0.02870602f, -0.01904945f, 0.00877751f, -0.05502303f, 0.00364858f, 0.00831311f, 
    -0.03435964f, -0.03718108f, -0.02613221f, 0.01583757f, 0.01426968f, -0.03616151f, -0.02802325f, -0.05810503f, 
    0.01310565f, -0.04599351f, -0.03704253f, -0.00823925f, 0.00844564f, -0.00542522f, 0.02101294f, 0.00338588f, 
    0.04164169f, 0.03434808f, -0.03413323f, -0.05204251f, -0.05897808f, 0.02800874f, 0.03792503f, -0.00566135f, 
    -0.02038854f, 0.02445345f, 0.04087903f, 0.00905245f, 0.03115438f, -0.04512026f, -0.01501587f, -0.05029417f, 
    -0.03940459f, 0.01276577f, -0.04522461f, -0.03829443f, -0.02859784f, -0.03796670f, -0.00263642f, 0.00274575f, 
    0.03711246f, 0.01735738f, -0.05368283f, -0.00598778f, -0.04020717f, -0.03507742f, -0.05771261f, 0.04085566f, 
    0.02456153f, 0.04211615f, -0.02947659f, 0.01569602f, 0.04845693f, 0.04943031f, -0.04325879f, 0.01672674f, 
    0.02682110f, -0.05777899f, 0.01015536f, -0.00110573f, -0.04776424f, 0.04221237f, -0.04953960f, 0.03577323f, 
    -0.05332336f, -0.02224954f, -0.01863563f, 0.02681196f, 0.04479769f, -0.02104067f, -0.03450834f, -0.00909199f, 
    0.01502635f, -0.01284465f, 0.04066120f, -0.00962971f, -0.03192388f, 0.02478652f, 0.00851825f, -0.01132999f, 
    -0.03971848f, 0.00518843f, 0.00028546f, -0.03186952f, -0.01859013f, 0.03079338f, 0.04319167f, 0.03490716f, 
    -0.03840644f, -0.04325149f, -0.02420897f, 0.03321864f, -0.02145249f, -0.04762653f, 0.04709627f, -0.04612270f, 
    0.03840278f, 0.04715201f, -0.01751062f, -0.03206139f, -0.03832145f, 0.03767701f, 0.01222501f, 0.03923552f, 
    0.03562149f, 0.01374480f, -0.04915793f, -0.05416998f, 0.02983899f, 0.01254515f, 0.00552299f, -0.01474475f, 
    0.02038925f, -0.05023440f, -0.05022343f, 0.03018886f, 0.03638670f, 0.00293856f, 0.00564885f, 0.03428072f, 
    -0.01638193f, -0.02443461f, 0.03313905f, -0.00552610f, 0.02669904f, 0.03773972f, 0.01836518f, -0.00836270f, 
    -0.02644720f, -0.01888563f, -0.02686708f, 0.02125405f, 0.01525636f, -0.01354529f, 0.03309995f, 0.01334092f, 
    0.04876611f, 0.01897249f, 0.01317606f, 0.04727681f, 0.01456321f, -0.05334128f, -0.02730446f, -0.06061256f, 
    0.00208648f, 0.01651032f, 0.03642887f, -0.02250102f, -0.02335238f, 0.04188541f, 0.02501660f, 0.02227386f, 
    0.00182878f, 0.01115479f, -0.03948734f, -0.05814995f, -0.05864672f, -0.04563804f, 0.02330841f, 0.04794976f, 
    0.04087798f, 0.09640963f, -0.09015173f, 0.25563449f, -0.20214804f, 0.03145331f, -0.01461611f, 0.04593825f, 
    -0.07514327f, 0.00901174f, 0.09091789f, -0.04319667f, 0.11748041f, -0.10954037f, 0.01518999f, -0.03382325f, 
    -0.19989711f, 0.01777207f, -0.41100585f, -0.20558706f, 0.28105217f, -0.10908536f, 0.41551480f, -0.16667688f, 
    0.08294152f, -0.03078253f, 0.14374314f, 0.13991654f, -0.09890679f, -0.16868852f, -0.01945452f, -0.13008741f, 
    -0.16480219f, 0.04312930f, 0.08646194f, -0.12777135f, -0.18405853f, -0.15673894f, -0.34788495f, -0.08843315f, 
    -0.43771449f, -0.22170763f, -0.29237548f, 0.01010797f, 0.04148998f, 0.02411975f, -0.00555615f, 0.31126425f, 
    -0.04260411f, -0.11570746f, -0.00230934f, -0.10351167f, -0.03385639f, 0.15150140f, 0.04132870f, -0.17731884f, 
    0.04883524f, 0.01942743f, -0.13655315f, -0.14047305f, -0.04089681f, 0.11366015f, 0.10845558f, 0.10215656f, 
    -0.28053468f, 0.01203356f, 0.05081245f, -0.02987775f, 0.11645680f, -0.03173243f, 0.05526462f, 0.05099890f, 
    0.04954614f, -0.03603794f, -0.06747158f, 0.13902189f, 0.15146029f, 0.22517698f, 0.03757226f, 0.12383061f, 
    0.19517174f, -0.06291310f, 0.13284427f, -0.12648082f, 0.07523138f, -0.02036742f, 0.10600758f, 0.06975892f, 
    0.23282988f, -0.25603271f, 0.16523746f, -0.06029523f, 0.05640641f, -0.06375013f, -0.02589658f, 0.09128401f, 
    -0.13338037f, -0.06800703f, -0.12179647f, -0.23443778f, 0.23637177f, 0.26843977f, -0.14603366f, 0.01877114f, 
    0.10105876f, -0.15711389f, -0.17568676f, -0.01645559f, -0.14945647f, -0.05640169f, 0.02036155f, 0.01764478f, 
    -0.17372100f, -0.19004993f, 0.09699789f, -0.13710670f, -0.37803212f, -0.12937185f, -0.11413941f, -0.43991190f, 
    0.00132021f, 0.07693778f, 0.19456461f, 0.02434745f, -0.32115543f, 0.06449354f, 0.18196933f, 0.11491866f, 
    -0.07833196f, -0.06596242f, -0.12222917f, -0.08301533f, -0.12653039f, -0.12579767f, -0.03243481f, -0.08947510f, 
    -0.02821356f, -0.09594283f, -0.41879395f, -0.21884392f, 0.30154300f, 0.48290649f, -0.08733956f, -0.13213612f, 
    0.17632352f, 0.07580612f, 0.03969582f, 0.07007927f, -0.25323272f, 0.09598955f, 0.20329031f, 0.15213740f, 
    -0.07620260f, 0.05864574f, -0.13629007f, -0.17590679f, -0.13292912f, 0.01591397f, 0.12902838f, 0.07476922f, 
    -0.23524110f, 0.30004859f, -0.14030544f, 0.39904135f, 0.13361774f, 0.11540616f, 0.06355484f, 0.03500739f, 
    0.05790608f, -0.03038775f, -0.12779655f, -0.09914462f, 0.07464328f, -0.03216655f, -0.03095609f, 0.18539143f, 
    0.06885829f, 0.29025289f, 0.09370504f, 0.26182532f, -0.15560104f, -0.20125459f, -0.03203080f, 0.04969804f, 
    0.12413318f, 0.09990782f, -0.03071622f, 0.28285357f, -0.02802837f, -0.05888776f, 0.06869173f, -0.04273300f, 
    -0.03386374f, 0.11456588f, -0.01138761f, -0.01781867f, 0.09479932f, 0.10188510f, -0.16616613f, 0.27589229f, 
    0.30316612f, 0.14348316f, -0.06003125f, 0.36006242f, 0.22101726f, -0.02927171f, 0.20688224f, 0.06061003f, 
    -0.02917501f, 0.14503166f, 0.08583802f, 0.00267758f, -0.00156836f, -0.04824799f, 0.04874879f, -0.23860693f, 
    -0.16626774f, -0.10865602f, -0.05782872f, -0.02066041f, -0.14608452f, -0.08429518f, 0.10307065f, -0.16109985f, 
    0.32592368f, -0.09401655f, 0.01627086f, -0.00476831f, 0.02394276f, 0.01899982f, -0.00914689f, -0.10431447f, 
    -0.11136586f, 0.02288522f, -0.02053032f, -0.07962865f, 0.11849935f, 0.17565624f, 0.20975818f, 0.10544331f, 
    0.41679654f, 0.35857600f, 0.34855613f, 0.01650916f, 0.07851995f, 0.00611266f, 0.16544619f, 0.03977517f, 
    0.04148664f, -0.17011033f, -0.03376248f, -0.13754836f, -0.01930085f, -0.08470960f, 0.12009799f, 0.14010276f, 
    0.30395362f, 0.04167562f, 0.07487241f, 0.10240322f, 0.31184849f, 0.18393075f, 0.19792153f, 0.06548545f, 
    0.33162367f, 0.02468729f, 0.15364243f, -0.09720591f, 0.03481985f, 0.17847501f, 0.02697020f, 0.00237084f, 
    -0.02216000f, -0.04804373f, 0.01528340f, -0.06784762f, 0.00110585f, -0.08164819f, 0.24153543f, 0.00371576f, 
    -0.00847042f, -0.07973545f, -0.74616897f, 0.10429855f, 0.16978914f, -0.31647706f, -0.10992918f, 0.16532259f, 
    -0.16805114f, -0.23891622f, -0.11486575f, -0.10243268f, -0.07137945f, 0.02753927f, 0.06093488f, 0.13955501f, 
    -0.12174100f, -0.00506870f, -0.09360428f, -0.40885913f, 0.19953328f, -0.04167267f, -0.16453947f, -0.33353320f, 
    0.32273811f, 0.12879807f, 0.16769305f, 0.10883965f, 0.10223675f, 0.26296857f, -0.00219050f, 0.07506967f, 
    -0.00075065f, 0.21665744f, 0.16130899f, -0.07232085f, 0.20915028f, 0.14133188f, 0.18549150f, 0.24283388f, 
    -0.05723476f, -0.10782487f, -0.26884443f, 0.12055890f, 0.22843806f, 0.04768317f, 0.02502362f, -0.10432538f, 
    -0.01148818f, 0.07813434f, 0.00229928f, 0.05037931f, -0.13442774f, -0.06679984f, -0.02648376f, -0.01114468f, 
    -0.01058169f, -0.11336683f, 0.11749799f, -0.07514373f, -0.10605509f, 0.14422403f, -0.11813744f, -0.01345875f, 
    -0.12353475f, -0.21049847f, 0.05712855f, -0.00665754f, -0.16095287f, -0.08644468f, -0.01555634f, -0.06173139f, 
    0.02264497f, 0.06638482f, -0.07262708f, 0.06744809f, 0.09636348f, 0.03528541f, -0.03466401f, -0.18418819f, 
    -0.00403667f, -0.02278558f, -0.39915189f, -0.07980070f, -0.19499972f, -0.03597596f, 0.06060214f, 0.15514372f, 
    -0.05140553f, -0.09869271f, -0.00699830f, -0.17503588f, -0.03624862f, 0.03965738f, 0.00045585f, 0.05567754f, 
    -0.06257099f, 0.01380976f, -0.19617617f, -0.07911967f, 0.50920910f, -0.05548801f, 0.22257106f, 0.10307501f, 
    0.17845500f, 0.02418367f, -0.00582441f, -0.14097169f, 0.05084223f, -0.02898257f, -0.03849806f, 0.04223784f, 
    0.04239869f, 0.00327106f, 0.06704772f, 0.05808531f, -0.03375930f, 0.00930083f, 0.12877211f, -0.07062455f, 
    0.40440971f, -0.33547670f, 0.30190709f, -0.06304132f, 0.04118129f, 0.21512310f, 0.17856300f, -0.17830960f, 
    0.17132629f, 0.00243685f, -0.16084237f, 0.01023128f, -0.04038763f, 0.09307346f, -0.03771912f, 0.10186204f, 
    0.07813986f, 0.03195853f, 0.22185856f, -0.10337161f, 0.13221711f, -0.09989983f, -0.12524262f, 0.10853584f, 
    0.12282870f, 0.05103141f, 0.04800422f, 0.13214496f, 0.12463891f, -0.08037284f, -0.14322822f, -0.04477070f, 
    -0.05428394f, -0.03444028f, -0.00652891f, 0.02457586f, -0.00584296f, 0.04703412f, -0.06486595f, 0.09830292f, 
    0.02657729f, -0.11382425f, -0.33299410f, 0.08220198f, 0.05112273f, 0.05797819f, 0.08831662f, -0.03533995f, 
    0.10883097f, 0.03609862f, -0.04276563f, 0.02896574f, -0.06665573f, 0.06673782f, 0.07320272f, -0.02649918f, 
    -0.04197349f, 0.02854236f, -0.03008550f, 0.01559608f, -0.14467004f, 0.39890215f, 0.14036898f, -0.02119625f, 
    0.00684292f, 0.11797020f, -0.07977911f, 0.09529041f, 0.23453052f, 0.00352578f, 0.06034922f, -0.10154308f, 
    -0.01145065f, 0.00269611f, -0.07361005f, -0.08950606f, 0.04158150f, 0.04731079f, 0.08882561f, 0.04136877f, 
    0.44594562f, -0.17396410f, 0.06380767f, 0.27376947f, 0.02265609f, 0.06796794f, 0.12325421f, -0.30258566f, 
    0.04125717f, 0.01923706f, -0.03796704f, 0.05639613f, -0.06005333f, 0.02307544f, -0.00307374f, -0.01199587f, 
    0.15731911f, -0.15213419f, 0.20293741f, 0.14369635f, 0.05314310f, 0.23901162f, -0.27045795f, 0.14207199f, 
    -0.28401235f, -0.06228505f, 0.05386043f, 0.05452324f, -0.06464423f, 0.00850931f, 0.05247412f, 0.01515263f, 
    0.04243045f, -0.03278912f, 0.15846913f, 0.20315452f, -0.08536718f, 0.11376639f, 0.01655779f, -0.02273791f, 
    0.11672651f, 0.36942500f, 0.36097336f, -0.11530390f, 0.10443491f, 0.00971473f, -0.07160778f, -0.26567608f, 
    0.06754631f, 0.04088883f, 0.00964425f, 0.05531137f, 0.02742480f, 0.03560852f, -0.03049117f, -0.02503002f, 
    0.01597208f, -0.09364612f, -0.07764279f, 0.16253445f, 0.21592924f, 0.17447284f, 0.26107699f, -0.03175175f, 
    -0.10279490f, -0.14415495f, -0.16332054f, -0.16984674f, -0.00628362f, -0.05814737f, 0.02899449f, 0.05724799f, 
    0.05358128f, 0.00728572f, -0.04756660f, -0.00793995f, -0.00085695f, 0.06824207f, 0.03915571f, -0.01500283f, 
    0.44749764f, -0.05120314f, 0.59778452f, -0.05005321f, 0.08154736f, 0.07343596f, -0.00755012f, -0.17556399f, 
    0.10039854f, 0.02094047f, 0.03211555f, 0.00571574f, 0.04265753f, 0.04532854f, 0.01658321f, 0.02239123f, 
    0.11498728f, 0.22373202f, -0.00331817f, -0.04805142f, 0.40080440f, 0.14105639f, 0.15340838f, 0.01308533f, 
    0.03961286f, 0.05659731f, 0.02891230f, 0.01737586f, -0.06655564f, -0.02212651f, 0.08858047f, 0.07968894f, 
    0.11167928f, -0.02483943f, 0.05717955f, 0.06013816f, 0.05930289f, 0.10380030f, -0.02094511f, 0.23652068f, 
    0.04027594f, -0.16871318f, -0.25960582f, 0.05677081f, 0.05221904f, 0.06856894f, 0.04569056f, 0.10239274f, 
    0.05053200f, -0.10539591f, -0.02708009f, -0.01159947f, -0.02896799f, -0.16444483f, -0.03422678f, 0.00758980f, 
    -0.01237501f, -0.00705932f, -0.08346763f, 0.03852192f, 0.16273619f, 0.24632792f, 0.20359793f, -0.16279089f, 
    -0.14571372f, 0.02997214f, 0.01597286f, 0.06700075f, -0.15041552f, -0.03593119f, 0.00508696f, 0.01715911f, 
    0.15462053f, 0.09382693f, 0.02839024f, -0.02098046f, 0.02427642f, 0.02097341f, -0.12139967f, 0.00086659f, 
    -0.22314538f, -0.00543874f, -0.24058251f, -0.11342449f, 0.03391095f, -0.12343692f, 0.06924708f, -0.12839863f, 
    0.00500250f, -0.02421924f, 0.15354446f, 0.09238132f, -0.00193661f, 0.05095091f, 0.03036637f, 0.05175767f, 
    0.04041312f, -0.12564470f, 0.11759221f, 0.03701933f, -0.00297145f, -0.15266840f, -0.09808003f, -0.08594395f, 
    -0.11441900f, -0.08832378f, 0.07350335f, 0.07053389f, -0.29107773f, 0.00782551f, -0.03650391f, -0.06838945f, 
    -0.07510484f, -0.03452940f, -0.11888139f, 0.18951757f, 0.11460263f, 0.21906599f, -0.07583007f, 0.01402002f, 
    0.12669860f, -0.12196113f, -0.14742972f, -0.10307562f, -0.19211365f, -0.11380707f, 0.16328485f, -0.00578547f, 
    -0.16108380f, -0.09776520f, 0.09418055f, -0.11112479f, -0.11318333f, -0.00453568f, 0.09556006f, 0.06190423f, 
    -0.07873854f, 0.12641728f, -0.03734625f, -0.04337079f, 0.37579787f, 0.14562967f, 0.08603920f, 0.09773885f, 
    0.25734133f, 0.02452576f, -0.04784346f, -0.07538871f, 0.02429495f, -0.01798009f, -0.07327956f, -0.05993449f, 
    0.01038334f, 0.02074151f, 0.06247748f, -0.02448534f, -0.05296592f, -0.00007048f, 0.16319193f, -0.05456297f, 
    -0.03869330f, -0.02040274f, 0.00252161f, -0.10687704f, 0.11868943f, 0.18272682f, 0.18847494f, -0.17698304f, 
    -0.08873411f, 0.26482692f, -0.04247211f, 0.06629491f, 0.03592065f, 0.06958556f, 0.08941264f, 0.05703718f, 
    -0.01510565f, -0.03136873f, 0.16072325f, 0.09740119f, 0.04353511f, -0.36188045f, -0.18420313f, -0.03586255f, 
    -0.09896237f, 0.10113557f, -0.06564333f, 0.06593003f, 0.09531891f, 0.04266894f, 0.10102437f, 0.03736493f, 
    0.10601297f, -0.01718748f, -0.05036165f, 0.01445538f, 0.10202815f, 0.06861243f, 0.03490131f, 0.09004164f, 
    -0.00039828f, 0.01554802f, -0.18293661f, 0.03718715f, 0.07317683f, -0.03791592f, -0.03414826f, -0.13990737f, 
    0.01973650f, -0.16614161f, 0.06949897f, -0.01919026f, -0.07241121f, 0.01687081f, -0.06006946f, -0.01245341f, 
    -0.04935307f, -0.09406859f, -0.02787486f, -0.07742239f, -0.22865537f, 0.00446940f, -0.14662682f, 0.02045287f, 
    0.02310551f, -0.01537603f, 0.10314611f, 0.05021954f, 0.28806940f, -0.05135423f, 0.03266423f, -0.01745937f, 
    0.01268938f, -0.05218482f, 0.03185679f, 0.05419524f, 0.05400874f, 0.06088666f, -0.06202783f, -0.00852032f, 
    0.32570589f, -0.03597693f, 0.32113555f, 0.25642309f, 0.38495284f, 0.05887789f, 0.08912116f, -0.08351330f, 
    -0.02262690f, 0.10025749f, -0.03379789f, -0.01850042f, -0.03257518f, 0.00561950f, -0.09892028f, 0.06810579f, 
    0.10581020f, -0.08926306f, 0.07951878f, -0.05587545f, 0.13118534f, 0.09441296f, 0.09662069f, 0.06252030f, 
    0.08755772f, -0.08354415f, 0.02481053f, -0.01372899f, -0.07749899f, -0.06104019f, 0.04145988f, 0.00301489f, 
    0.00853000f, -0.04363948f, -0.00224086f, 0.10779323f, 0.01809184f, 0.02867268f, 0.05618842f, -0.12112156f, 
    0.10046415f, 0.24930918f, 0.30918872f, 0.00063226f, 0.05894379f, 0.13968870f, 0.00671489f, -0.12329406f, 
    0.06904350f, 0.09942834f, -0.11798725f, -0.02406027f, -0.04163925f, 0.05138074f, -0.02136750f, 0.00457253f, 
    0.04372279f, -0.06820104f, 0.00574395f, 0.02520857f, 0.22970080f, 0.04637117f, 0.03713341f, 0.11241073f, 
    0.04626364f, 0.17588235f, -0.18444125f, -0.01626460f, 0.08496288f, 0.14104292f, 0.05821737f, 0.17172016f, 
    0.07139000f, -0.04971572f, 0.09294344f, 0.02836223f, 0.01930096f, 0.12847802f, -0.08127897f, 0.02439378f, 
    0.40773782f, 0.03764128f, 0.29590192f, 0.26991144f, 0.04540922f, 0.16555440f, -0.08639761f, -0.07708667f, 
    0.00659976f, -0.03423632f, -0.02759563f, -0.08983386f, 0.04150422f, -0.02250570f, -0.00651750f, -0.08583915f, 
    -0.01386797f, 0.13529657f, -0.10827138f, -0.18736260f, 0.04349141f, -0.10894730f, 0.10202581f, 0.26293945f, 
    0.10834534f, 0.05538417f, -0.17556942f, 0.12903681f, 0.07363764f, 0.09519512f, 0.05499546f, 0.02270572f, 
    0.04705935f, 0.03485681f, 0.08066297f, 0.01109967f, 0.05471710f, 0.07110765f, -0.14597073f, 0.20511913f, 
    -0.02085163f, -0.47714546f, 0.04000679f, -0.14078230f, -0.14548250f, 0.08269950f, -0.02911918f, 0.01801420f, 
    -0.11710848f, -0.10020246f, 0.11065809f, 0.20246574f, 0.08377374f, 0.04874964f, -0.08379127f, -0.03882230f, 
    -0.01032341f, 0.03917864f, -0.07334916f, -0.00091858f, 0.06426044f, 0.13805509f, -0.00389606f, 0.13762352f, 
    -0.08113117f, 0.02873412f, -0.13274944f, -0.13623810f, 0.05153983f, -0.04605572f, 0.11963011f, -0.02189439f, 
    0.06593731f, 0.06265741f, 0.26216611f, 0.12728024f, 0.08283011f, -0.04262036f, -0.07622726f, 0.01519113f, 
    -0.12299997f, -0.07810866f, -0.07397767f, 0.00540882f, -0.11766723f, -0.13313028f, 0.00336901f, 0.03374591f, 
    0.02019585f, -0.11264788f, 0.05693872f, 0.04181751f, -0.09100840f, -0.01102031f, -0.09773961f, -0.12094664f, 
    0.13360427f, 0.03958301f, 0.22684677f, 0.09299172f, -0.38408279f, 0.18508545f, 0.00081790f, -0.06871758f, 
    0.07097781f, -0.22169673f, -0.05255359f, -0.10368392f, -0.02292658f, -0.10571322f, -0.04326517f, 0.07230751f, 
    0.06394305f, 0.05451443f, -0.13964002f, 0.10095009f, 0.19838375f, 0.19859040f, 0.15728000f, 0.09135596f, 
    0.08327033f, 0.16243316f, -0.02673705f, 0.00317041f, -0.01943332f, 0.05901859f, 0.05009921f, 0.15599561f, 
    -0.12125188f, -0.03638051f, 0.04385825f, -0.01894116f, 0.02845104f, -0.07702275f, 0.13709363f, -0.02163302f, 
    -0.04368626f, 0.07349380f, 0.09096209f, -0.08385870f, 0.25571772f, 0.17201914f, 0.39811718f, 0.37976995f, 
    -0.00533670f, -0.15995096f, -0.04986343f, -0.06595443f, 0.00649778f, -0.02861521f, -0.18311951f, -0.06060759f, 
    -0.01182524f, -0.12080377f, 0.04506211f, -0.03015961f, -0.12312225f, -0.14343770f, 0.02623300f, -0.24052928f, 
    -0.10421385f, -0.24360369f, -0.01062668f, 0.35742426f, 0.43853602f, 0.15490752f, 0.27363142f, 0.11993577f, 
    -0.12731180f, 0.19001581f, 0.00281381f, 0.04677182f, 0.04467005f, 0.06063398f, -0.08360432f, 0.11959057f, 
    -0.06765062f, -0.01298329f, 0.06256095f, 0.13126385f, -0.15769830f, -0.45270896f, -0.45914742f, -0.14647883f, 
    -0.09391467f, 0.03408254f, 0.06907010f, -0.00529134f, 0.02239516f, 0.06231571f, 0.14281248f, 0.06692170f, 
    -0.00630945f, 0.06194128f, -0.00344794f, 0.04559424f, 0.17972329f, 0.08330701f, 0.05876425f, 0.12635775f, 
    -0.01606597f, 0.12937936f, 0.29342532f, 0.12698531f, -0.14006735f, -0.17775881f, -0.15535182f, -0.10727691f, 
    0.03636581f, -0.21594216f, -0.04059037f, -0.01742020f, -0.08709753f, -0.05614067f, 0.01633022f, -0.19402498f, 
    0.20999373f, 0.03425418f, 0.01537739f, -0.04898065f, 0.26421118f, 0.25882763f, -0.00079672f, -0.30001330f, 
    0.29388818f, 0.23055001f, 0.12046082f, 0.09019355f, 0.32691231f, 0.09853222f, 0.06553958f, 0.00257922f, 
    0.04383406f, 0.00694155f, 0.08539265f, -0.03902657f, 0.03349650f, 0.06791045f, 0.08425146f, 0.12411188f, 
    -0.04200056f, 0.16309547f, 0.46060169f, 0.17981775f, 0.06077263f, -0.04909809f, -0.06998286f, -0.04639611f, 
    -0.02121462f, -0.00684222f, -0.07877511f, -0.06856935f, -0.04137899f, 0.03877908f, -0.01946360f, -0.03417098f, 
    -0.10629394f, -0.10908990f, -0.02750906f, -0.13555282f, 0.25348875f, 0.38345453f, 0.11184818f, 0.35156548f, 
    0.24455541f, -0.08585764f, -0.08451281f, -0.03765227f, -0.09817128f, -0.01712560f, 0.03730737f, 0.00909080f, 
    0.00751034f, -0.01506593f, -0.02760832f, -0.02081938f, -0.09527256f, -0.00783680f, 0.03227035f, -0.04805425f, 
    0.27676809f, -0.11224341f, 0.27634242f, -0.23202537f, 0.03195357f, 0.11071348f, -0.00927178f, -0.01933119f, 
    -0.00037087f, -0.12008001f, -0.06353330f, -0.01103633f, 0.06041165f, 0.14420587f, 0.09420004f, 0.02219999f, 
    0.04837503f, 0.09911633f, 0.12557495f, 0.16123246f, 0.12042914f, 0.16036488f, 0.02903300f, 0.07364419f, 
    0.11044033f, 0.13378200f, 0.00152033f, -0.05423775f, -0.00871021f, 0.19515328f, 0.03230618f, 0.07906339f, 
    0.04533411f, -0.03018390f, -0.01823383f, 0.06452576f, -0.09631439f, -0.00978748f, -0.13453616f, -0.20154634f, 
    -0.17274584f, 0.22373998f, 0.53627312f, 0.15029556f, -0.10100073f, -0.04086535f, -0.16176987f, -0.13050662f, 
    -0.00852834f, -0.09705555f, 0.01431499f, 0.00399233f, -0.11523347f, -0.06140734f, -0.02251913f, 0.02029664f, 
    -0.07341978f, 0.03032661f, -0.09212907f, -0.22855073f, 0.12421007f, 0.01616514f, -0.33099556f, -0.03519622f, 
    0.17702200f, 0.11733181f, 0.01221724f, 0.04585304f, 0.08370000f, -0.07271387f, 0.04653124f, -0.04609201f, 
    0.02284485f, 0.03177096f, 0.08061522f, 0.00205369f, 0.02048331f, 0.06868649f, -0.14366548f, 0.11229757f, 
    -0.09946728f, -0.30836722f, -0.48959169f, -0.05235323f, -0.13384658f, 0.04787882f, 0.03965044f, 0.00586518f, 
    0.01467796f, 0.01513517f, 0.19559675f, 0.19986886f, 0.02442417f, 0.07768836f, -0.06918297f, -0.01295330f, 
    0.07854494f, 0.09847808f, 0.11084248f, 0.03840721f, 0.29077855f, 0.28323057f, -0.09732558f, -0.16972007f, 
    0.16206297f, 0.17477760f, 0.02542386f, 0.06290767f, 0.17115791f, 0.19840340f, 0.00980565f, 0.03378067f, 
    -0.04172788f, -0.03061774f, 0.10080840f, 0.08602850f, -0.08768526f, -0.00218412f, -0.06982758f, -0.07699229f, 
    0.09485365f, 0.11584611f, -0.07983695f, 0.01159579f, 0.13537604f, -0.01759979f, 0.14894488f, 0.03691497f, 
    -0.00661011f, -0.03430507f, -0.05146226f, 0.11716035f, 0.06279925f, -0.09160796f, 0.09833155f, 0.13444626f, 
    0.08273575f, 0.06912046f, -0.22564806f, 0.00285210f, 0.40779075f, -0.03568905f, 0.29010725f, -0.00280413f, 
    0.02722112f, 0.08052079f, 0.20974442f, 0.25793707f, -0.04972017f, 0.01261940f, 0.13648529f, 0.03519750f, 
    0.17975436f, -0.00825940f, -0.02919450f, -0.03802069f, 0.00117400f, -0.11128175f, -0.08128900f, -0.22745216f, 
    -0.13127480f, -0.33900669f, -0.11191422f, -0.02422873f, -0.14098127f, -0.04193057f, 0.11558146f, 0.07261605f, 
    -0.01537724f, 0.05671942f, -0.09383991f, 0.14506057f, 0.01380328f, 0.19680685f, 0.00488870f, 0.03285605f, 
    0.05152835f, -0.02366723f, -0.12096027f, 0.08134198f, 0.02755572f, 0.32725930f, -0.06479201f, 0.08300985f, 
    -0.09353130f, 0.07958755f, 0.06089672f, -0.09215104f, -0.04594992f, -0.01468981f, 0.10035221f, 0.04319245f, 
    0.02625293f, -0.04408030f, -0.04276958f, 0.02628529f, 0.03380463f, 0.17843542f, -0.25277233f, 0.06485757f, 
    0.32747567f, -0.03329122f, 0.18189596f, -0.26103100f, -0.07165658f, -0.03912894f, 0.03136710f, -0.21797313f, 
    0.38311461f, 0.01636721f, 0.13665429f, 0.06732358f, -0.05528257f, 0.13361320f, -0.03268455f, -0.21276982f, 
    0.16628952f, -0.01869507f, 0.00780570f, 0.06348073f, 0.09686595f, -0.10312365f, -0.08906620f, -0.01348483f, 
    -0.17375244f, 0.10498467f, -0.02092333f, -0.10591018f, 0.14608184f, -0.04017043f, 0.05547683f, -0.06326286f, 
    -0.03722791f, 0.01916489f, 0.07304265f, -0.00342769f, -0.06009166f, -0.04418319f, -0.19365785f, -0.16754265f, 
    0.15425195f, 0.23641557f, 0.08338124f, -0.04566963f, -0.12943073f, 0.15559912f, 0.11898068f, 0.09607965f, 
    0.03832188f, 0.06323595f, -0.02765693f, 0.13664350f, -0.19002305f, -0.12705044f, -0.07803352f, 0.14021994f, 
    0.05329104f, -0.09622565f, -0.12618585f, -0.04057830f, 0.00920233f, -0.20185620f, 0.09554110f, 0.31654352f, 
    -0.27395564f, -0.04099361f, -0.14097308f, 0.12695497f, -0.20093897f, 0.05449634f, -0.15744989f, -0.07558113f, 
    0.13039362f, -0.05258779f, 0.04101503f, 0.05835238f, -0.04465371f, -0.00354191f, -0.15179078f, -0.02583424f, 
    0.12635255f, 0.14961079f, -0.39666733f, 0.13954186f, -0.03632735f, -0.16811702f, -0.05483211f, 0.03779707f, 
    0.09609247f, 0.16510883f, 0.07954286f, 0.11999466f, 0.05451829f, -0.00820524f, -0.02913323f, 0.05581393f, 
    -0.04826845f, 0.05306788f, 0.11982975f, 0.09331341f, 0.03001031f, -0.26354742f, 0.36341068f, -0.07845629f, 
    0.11129478f, 0.06460974f, 0.09743713f, 0.06022699f, 0.03912980f, -0.04293576f, 0.10529574f, -0.10618442f, 
    0.16653460f, 0.03066218f, -0.11340505f, -0.00903395f, 0.05960334f, 0.02712328f, 0.00418265f, -0.20726582f, 
    -0.05383344f, 0.17681645f, 0.01906854f, 0.49106580f, -0.04292371f, -0.14230397f, -0.07779515f, -0.08197407f, 
    -0.00681044f, 0.08252812f, 0.07540577f, -0.06225596f, 0.02449044f, -0.09546601f, -0.03180117f, -0.12927501f, 
    0.09451877f, -0.20004161f, -0.09157858f, -0.05111566f, 0.13369688f, -0.08406251f, 0.25461820f, -0.04381467f, 
    -0.00909722f, 0.09752246f, -0.03600199f, 0.08309826f, -0.00574824f, -0.06534017f, 0.02117336f, -0.03115270f, 
    -0.02479012f, 0.03088395f, 0.02890338f, 0.13839632f, 0.12507124f, 0.19275238f, 0.11629945f, 0.05982975f, 
    0.43005130f, 0.29571605f, 0.12482965f, 0.02026714f, -0.10916319f, 0.01986158f, 0.00308124f, -0.03208175f, 
    0.02713986f, 0.01973215f, 0.11303135f, 0.07108245f, 0.03287409f, -0.04392812f, -0.00603647f, -0.00350578f, 
    0.04890499f, 0.02295486f, -0.03854017f, 0.26309213f, 0.10997142f, 0.07151844f, 0.43417671f, 0.19277863f, 
    -0.06498310f, -0.09478639f, 0.00198061f, 0.03581018f, -0.00700612f, -0.00522033f, -0.00323068f, 0.02586473f, 
    -0.03316922f, 0.02377379f, 0.04550138f, -0.01362013f, 0.03208514f, -0.09232979f, 0.27155095f, -0.16660081f, 
    -0.17817536f, -0.17314133f, -0.15640534f, -0.06911460f, -0.09501427f, -0.00556914f, -0.01403388f, 0.05504293f, 
    0.16369358f, 0.05387349f, -0.18496244f, -0.12669648f, 0.05619157f, 0.18181017f, -0.02488814f, 0.12033323f, 
    0.04322127f, -0.07621502f, -0.07397445f, -0.04658246f, -0.18272503f, -0.17596953f, 0.06209526f, -0.10780463f, 
    -0.10534044f, -0.07038286f, -0.01997088f, -0.01171636f, -0.04078962f, -0.05181309f, -0.01160158f, 0.05646833f, 
    -0.08167864f, 0.16647223f, -0.04031917f, -0.21085414f, 0.03591696f, 0.08170092f, 0.22810566f, 0.13232136f, 
    -0.36374110f, 0.36557353f, -0.31777003f, -0.00662323f, -0.08970482f, -0.03909942f, -0.14092150f, -0.06178369f, 
    -0.22425871f, -0.01790822f, -0.00174782f, 0.07662968f, 0.00927754f, -0.11136837f, -0.09139316f, -0.13866106f, 
    -0.18505317f, -0.02686843f, -0.02776244f, -0.04400728f, 0.20418875f, -0.47474521f, -0.08628122f, 0.12135280f, 
    0.21357246f, -0.02808865f, 0.22795512f, 0.07250882f, -0.04486107f, -0.18429334f, 0.14355832f, -0.05570363f, 
    -0.00813568f, -0.15288410f, -0.08948439f, -0.09129641f, 0.01758095f, -0.09776440f, -0.14792942f, -0.07014444f, 
    -0.19051518f, -0.01516705f, -0.61021966f, -0.17069362f, 0.00305862f, 0.03266986f, -0.08001648f, -0.06268008f, 
    0.01686843f, -0.04502245f, 0.02591153f, 0.07140479f, -0.16495557f, 0.09592522f, 0.03834563f, -0.18284455f, 
    0.09134457f, 0.08868482f, -0.07033336f, 0.06912634f, -0.02152931f, 0.14767478f, -0.05134923f, 0.12075003f, 
    -0.17769012f, -0.06169125f, -0.23304734f, -0.06376978f, 0.05042594f, 0.03725886f, 0.17908612f, -0.10515766f, 
    0.02710536f, -0.11138647f, -0.05867529f, -0.04564026f, 0.18767048f, 0.06321865f, -0.01205594f, 0.06932262f, 
    0.35698462f, 0.21786846f, -0.12810759f, -0.02148866f, -0.19286731f, -0.05139734f, -0.03519769f, -0.01446455f, 
    -0.07672381f, -0.09856826f, 0.09128097f, 0.03028174f, 0.07620734f, -0.02925220f, 0.00235006f, 0.13231595f, 
    0.08538652f, -0.11871289f, 0.02690300f, -0.19737902f, 0.02872211f, 0.24349013f, 0.21015629f, -0.09949511f, 
    0.09534263f, 0.00661118f, -0.10975958f, 0.00500699f, -0.21930724f, -0.15905607f, -0.00742674f, -0.01398413f, 
    -0.18917845f, -0.16701533f, 0.06130824f, -0.01582741f, -0.29000589f, -0.24128348f, -0.14902490f, -0.22314401f, 
    -0.34041685f, -0.12797187f, -0.21495104f, 0.14324601f, 0.06742825f, 0.24948934f, 0.45792109f, -0.23248959f, 
    -0.49725696f, -0.18265963f, 0.10249498f, -0.00058639f, -0.00437831f, -0.20993142f, -0.15497763f, 0.08940087f, 
    -0.15901788f, 0.01552869f, -0.18016410f, 0.09013399f, 0.00084417f, 0.38843280f, -0.05888085f, -0.31623226f, 
    -0.12974370f, 0.08585282f, 0.00652413f, 0.00219926f, -0.21952930f, -0.04702644f, 0.05281320f, -0.02515280f, 
    -0.03489700f, 0.09970687f, 0.05798540f, -0.08904471f, 0.00970545f, -0.14081728f, -0.06200958f, -0.04538143f, 
    -0.08251947f, 0.29107121f, -0.05562472f, 0.28263387f, 0.43054760f, -0.05313957f, 0.06648135f, 0.06498655f, 
    0.08227201f, 0.05184259f, 0.10459951f, 0.08936609f, 0.04072098f, -0.21537982f, -0.26072839f, 0.06384280f, 
    0.13300383f, 0.06046101f, 0.05387123f, 0.09256452f, -0.17825098f, -0.12861212f, -0.13607872f, -0.16769578f, 
    0.06419845f, 0.04267408f, -0.09409154f, 0.04792054f, 0.21764684f, -0.00160148f, 0.16565822f, 0.00397227f, 
    -0.04885371f, 0.06530646f, -0.12003016f, -0.13774681f, 0.03771913f, 0.12124093f, -0.02943075f, 0.10390150f, 
    0.18427250f, 0.52944762f, -0.00795556f, 0.08401040f, 0.20057420f, -0.08027165f, 0.16909812f, 0.05370626f, 
    0.01012869f, 0.07494264f, 0.11879213f, 0.09620145f, -0.05509801f, -0.06419566f, -0.08666378f, 0.01422483f, 
    -0.21929286f, 0.01497449f, 0.00770409f, 0.02650487f, 0.27103746f, 0.10508157f, 0.27140549f, -0.12615922f, 
    0.16598824f, 0.10843800f, 0.02550210f, 0.19245464f, 0.11035979f, 0.06606213f, 0.01254510f, -0.05922179f, 
    0.04878678f, 0.05893758f, -0.06827708f, -0.00748278f, 0.05618516f, -0.01698261f, 0.11329963f, 0.11857582f, 
    0.06608114f, 0.27127871f, 0.06097106f, 0.22214402f, 0.25297081f, 0.04140124f, -0.08266450f, 0.00223312f, 
    0.12389873f, 0.22680967f, 0.07929647f, -0.25489849f, -0.02261195f, -0.25537509f, -0.12478183f, 0.19267596f, 
    0.18186937f, -0.10043801f, -0.00205991f, 0.12255429f, 0.32773492f, 0.22889353f, 0.28518268f, 0.00348100f, 
    0.24695934f, 0.26547146f, 0.20058867f, 0.07157139f, 0.17348701f, 0.20783287f, 0.08341849f, -0.00611870f, 
    0.17352706f, 0.09915902f, 0.02486739f, -0.05080536f, -0.08835699f, -0.09755524f, 0.10140256f, -0.00119381f, 
    -0.17313641f, -0.27392188f, -0.12693399f, -0.08169638f, 0.15041007f, 0.05250480f, -0.02633230f, -0.23570299f, 
    -0.15267693f, -0.38099003f, -0.10787407f, -0.02473169f, -0.15560059f, -0.16098434f, 0.15836202f, -0.02222700f, 
    -0.16804840f, 0.01343871f, -0.22972813f, -0.16098186f, 0.18621510f, 0.16803968f, -0.14698224f, -0.14050098f, 
    0.13976008f, 0.14342272f, 0.32320455f, 0.17571858f, -0.07642935f, 0.19694698f, -0.12515324f, -0.04889771f, 
    0.26110083f, 0.22435205f, 0.18014118f, -0.07660136f, 0.08310517f, 0.03963157f, 0.21143085f, 0.11388978f, 
    -0.15996358f, 0.16886668f, -0.03677429f, -0.02631706f, 0.11454020f, -0.07287344f, 0.08985223f, -0.04740327f, 
    -0.05999864f, 0.00091162f, 0.01860471f, 0.02479490f, 0.03823663f, 0.05761653f, -0.01518283f, 0.11892417f, 
    -0.10959410f, 0.13140614f, -0.18304579f, -0.12294720f, 0.15773286f, -0.38172811f, -0.02154989f, 0.25690395f, 
    -0.20942496f, 0.01561428f, 0.21487804f, 0.13538015f, 0.05432298f, 0.24459562f, -0.02131129f, -0.07610860f, 
    -0.05095269f, -0.02450211f, -0.12720256f, 0.08643737f, 0.10629673f, -0.02604051f, 0.13309197f, -0.10555179f, 
    -0.48777387f, 0.01192610f, -0.30964828f, -0.01310038f, -0.26166767f, 0.06305129f, 0.05418066f, 0.04401550f, 
    -0.02151758f, -0.01547453f, 0.00342363f, 0.13079019f, -0.09272160f, 0.12888838f, 0.02199665f, -0.03775464f, 
    0.00997810f, 0.10792126f, 0.10563267f, 0.03003092f, 0.29684070f, -0.01407837f, -0.20542952f, 0.04465723f, 
    0.16666174f, 0.06962989f, -0.14939493f, -0.05549059f, -0.01382167f, -0.08320946f, 0.04470067f, -0.00475597f, 
    0.00558146f, 0.10047219f, -0.00388426f, -0.01734565f, 0.06772839f, 0.04674837f, 0.05431647f, -0.01591236f, 
    0.56374276f, 0.15545528f, 0.21506730f, -0.23390235f, -0.25281349f, 0.00394416f, -0.03007744f, -0.01905903f, 
    0.14983937f, 0.15701446f, 0.00695855f, 0.01296415f, -0.08468299f, -0.07676892f, 0.05370582f, -0.00885032f, 
    0.13171287f, 0.09976991f, 0.14923987f, -0.06555068f, 0.24350247f, -0.15596640f, 0.15362002f, 0.16804868f, 
    0.06150477f, 0.12646106f, -0.08372183f, 0.01262236f, 0.05010439f, 0.02519549f, -0.11495615f, 0.00535391f, 
    -0.06414741f, -0.18098286f, -0.06143093f, -0.07467825f, 0.02783705f, -0.02183206f, -0.15417923f, 0.07566101f, 
    -0.11330742f, -0.18301053f, -0.21336922f, 0.15607376f, 0.05620822f, 0.11465690f, 0.05436961f, 0.00881558f, 
    -0.04629329f, 0.01566214f, 0.01909298f, 0.04015796f, 0.28403172f, 0.03091197f, -0.06394020f, 0.12811592f, 
    -0.01679846f, 0.04951567f, 0.03526659f, 0.04824839f, -0.23917653f, 0.15888432f, 0.08574741f, 0.13958375f, 
    -0.27555525f, -0.11940416f, -0.08275065f, 0.14109407f, -0.31672817f, 0.15851791f, -0.09008712f, -0.13233283f, 
    -0.01327727f, 0.05391937f, 0.02277140f, 0.05341802f, -0.01272487f, -0.05481176f, -0.07955767f, -0.04301795f, 
    0.46580279f, 0.04400017f, -0.07059802f, 0.29556653f, 0.36740151f, 0.01950434f, 0.01625181f, 0.02365106f, 
    0.05176547f, 0.11472823f, 0.02603208f, 0.05068100f, 0.01971763f, -0.13064477f, -0.04408311f, -0.01169476f, 
    0.03147322f, -0.04157413f, 0.11254775f, 0.02403983f, -0.42685547f, -0.05257153f, -0.13542473f, -0.00780301f, 
    0.18788511f, -0.10742719f, -0.08771411f, 0.07171043f, 0.14793973f, -0.05277511f, -0.03392572f, 0.03561975f, 
    -0.08551908f, -0.07122149f, -0.07604242f, -0.04882830f, 0.06808461f, -0.12046158f, 0.18358941f, -0.19647497f, 
    -0.00127432f, 0.61369258f, 0.25684518f, 0.27064341f, 0.08813051f, -0.12556811f, -0.05231521f, 0.19231281f, 
    0.03587859f, 0.26398429f, 0.06115120f, 0.00673322f, -0.04042766f, -0.10213972f, -0.10301782f, 0.05829701f, 
    -0.09711747f, -0.06311324f, -0.13532926f, 0.06784164f, 0.17554744f, -0.11033242f, 0.30849046f, 0.11309887f, 
    -0.07341897f, 0.06427509f, -0.22166115f, 0.04900505f, 0.13161409f, -0.03046933f, -0.04032768f, 0.02511991f, 
    0.04945505f, 0.00138381f, 0.06121627f, 0.01374279f, -0.00484366f, -0.10043151f, 0.01425009f, -0.00745656f, 
    0.56476146f, -0.13097063f, 0.01534394f, 0.14391513f, 0.06565713f, 0.11792478f, 0.02448363f, -0.11453648f, 
    0.11514596f, 0.03694121f, -0.04871762f, 0.00704056f, 0.03010431f, -0.09800325f, -0.05999018f, 0.08261786f, 
    -0.05708587f, 0.18223983f, -0.00035246f, 0.16989760f, 0.22395082f, 0.04203501f, 0.36543033f, 0.33902118f, 
    0.13996674f, 0.02001075f, -0.12896566f, 0.14319323f, -0.02583764f, 0.28667802f, 0.01604057f, -0.00167992f, 
    0.06218377f, -0.00494204f, -0.03467372f, 0.02578187f, -0.04161076f, -0.16318524f, 0.14128041f, -0.00646164f, 
    -0.22957711f, -0.43976796f, 0.09247348f, 0.02159454f, -0.12010647f, 0.13219480f, -0.07415480f, -0.10748221f, 
    0.03321261f, -0.09326372f, -0.09947448f, -0.02275672f, 0.15822928f, -0.02864001f, 0.08998008f, -0.02392456f, 
    -0.01001045f, 0.07165160f, -0.14629005f, 0.10876229f, -0.18048237f, 0.01811268f, -0.16336685f, -0.05610131f, 
    -0.30502766f, -0.00128899f, 0.16984507f, -0.01652440f, -0.01592086f, 0.04782984f, -0.08118749f, -0.07624593f, 
    0.18405031f, 0.21000171f, 0.06075562f, -0.05811397f, 0.14555642f, -0.06916655f, 0.03825753f, 0.18792933f, 
    -0.10007385f, 0.06028877f, -0.01793961f, 0.13926831f, -0.07677314f, -0.04624701f, 0.00607217f, 0.04685098f, 
    0.05610640f, 0.03459233f, 0.13251960f, 0.20091203f, 0.09883726f, 0.19693589f, 0.03658418f, 0.07525148f, 
    0.10534635f, -0.15184143f, 0.08336464f, 0.01519528f, 0.30497494f, 0.05172994f, 0.00372772f, -0.10635377f, 
    -0.01110393f, 0.23056845f, -0.11969169f, -0.02606843f, 0.04276753f, -0.20844963f, -0.01795368f, 0.02644635f, 
    -0.01833602f, 0.00298526f, 0.05855902f, 0.09456646f, -0.01920286f, 0.09689143f, -0.08272050f, -0.03770717f, 
    0.49820694f, -0.35611343f, 0.22109649f, 0.17189397f, 0.03869674f, -0.00989870f, 0.11496242f, 0.00212595f, 
    0.00383796f, 0.02025912f, 0.16718106f, -0.13812122f, 0.20174147f, -0.04950156f, 0.03110593f, 0.05902993f, 
    0.14634013f, 0.04688751f, -0.02800254f, -0.06271259f, -0.23875248f, 0.24885851f, 0.27335802f, 0.07473043f, 
    0.04481329f, 0.02546781f, -0.05041283f, 0.00268610f, 0.02061020f, 0.04456340f, 0.00359767f, 0.02799754f, 
    -0.00561373f, -0.01676159f, 0.00938766f, 0.18822022f, -0.03885970f, -0.01749980f, 0.01310958f, 0.06611149f, 
    -0.75714427f, -0.14427875f, 0.06660718f, -0.18209481f, 0.01644371f, 0.17270505f, 0.11450192f, 0.00511757f, 
    0.00402104f, -0.10735709f, -0.22014217f, 0.19690105f, -0.01711524f, -0.08412330f, -0.09213907f, 0.05220676f, 
    -0.13558012f, -0.01108792f, -0.07843158f, -0.06020328f, -0.02838756f, -0.02070811f, -0.09324899f, -0.07354683f, 
    -0.06837607f, -0.11323342f, 0.05304878f, 0.03737089f, -0.11115438f, 0.07353183f, 0.11278841f, 0.00693449f, 
    0.03791915f, 0.08389758f, -0.01704429f, -0.06967510f, 0.03704978f, 0.04695842f, 0.13081211f, -0.07795811f, 
    0.18492477f, 0.17744409f, 0.15183513f, 0.02092178f, 0.05546214f, 0.05135701f, -0.04182966f, 0.04864014f, 
    0.10019208f, -0.01316793f, 0.03819184f, 0.06560032f, -0.27792546f, 0.02645104f, 0.09982925f, -0.06041691f, 
    0.00175910f, 0.02367492f, -0.11438473f, 0.01968873f, 0.05778461f, 0.12353452f, -0.29792225f, 0.00415080f, 
    0.13277988f, -0.03956058f, 0.04661931f, -0.02811449f, 0.08906666f, -0.02409794f, 0.01716412f, -0.01876453f, 
    -0.04206555f, -0.03574925f, -0.04044987f, 0.00916282f, 0.00715135f, 0.12684433f, -0.07192218f, -0.10650959f, 
    -0.40490839f, -0.09805232f, -0.17945194f, 0.01407873f, -0.25088596f, 0.01719510f, -0.18371682f, -0.06602830f, 
    -0.08444306f, -0.00472720f, -0.11774885f, -0.12302696f, -0.01089750f, 0.03786525f, 0.01183626f, 0.17781429f, 
    0.10436124f, 0.02482372f, 0.02567011f, 0.08812507f, 0.63442147f, -0.17614743f, -0.00765593f, -0.00411788f, 
    -0.00747751f, 0.00342348f, -0.03923464f, -0.04805354f, 0.01643834f, 0.05208551f, 0.00666392f, 0.11973517f, 
    -0.04560836f, 0.20020646f, -0.05707356f, 0.07044872f, -0.03648449f, 0.16448085f, -0.23657386f, 0.17676628f, 
    0.11834642f, -0.05055644f, -0.21661206f, 0.08108128f, -0.13652883f, 0.03194872f, 0.03619347f, -0.23912299f, 
    -0.02963400f, -0.01945306f, -0.10110475f, 0.03683990f, -0.03696872f, 0.10292812f, 0.03984909f, -0.12047926f, 
    0.02293584f, 0.00582524f, 0.05010888f, -0.03692174f, -0.04191384f, 0.07230092f, -0.18084034f, -0.21719098f, 
    0.06897689f, 0.10593480f, 0.09369009f, 0.00792989f, -0.15049827f, 0.00972959f, -0.04552203f, 0.02254229f, 
    0.02976690f, -0.09269533f, 0.03154053f, -0.09925465f, -0.01084284f, 0.09589050f, -0.03800794f, 0.06315181f, 
    0.09398204f, 0.53209817f, 0.14962560f, 0.14660960f, 0.15053038f, -0.00106806f, -0.07415069f, 0.10307080f, 
    -0.11166642f, -0.09092977f, -0.01648281f, -0.05359581f, -0.08905278f, 0.03137061f, -0.00945577f, 0.08619026f, 
    0.30104339f, -0.03846431f, -0.00873056f, -0.03313110f, 0.09782951f, 0.14746450f, 0.07426634f, -0.09469910f, 
    0.16192816f, 0.06054280f, -0.11145829f, -0.10116171f, -0.09127055f, -0.01079272f, 0.00274563f, -0.03819705f, 
    -0.07101756f, -0.02041640f, 0.01610093f, -0.05002828f, 0.04024961f, 0.07946467f, -0.09326623f, -0.04015334f, 
    0.33701834f, 0.06157289f, 0.01272889f, -0.06118858f, -0.07244494f, -0.13803184f, -0.02828658f, 0.10084689f, 
    -0.07016084f, 0.13302881f, 0.14018695f, 0.07593703f, -0.09114323f, 0.00733069f, 0.01050285f, 0.01851416f, 
    0.07025419f, -0.04371404f, 0.05787920f, -0.00680728f, 0.34155077f, 0.00105086f, 0.19123918f, -0.01819631f, 
    0.11163031f, 0.00810716f, -0.06744117f, 0.04580670f, -0.01928069f, 0.08500297f, -0.01326788f, -0.02425984f, 
    -0.05980588f, -0.12782408f, 0.02006113f, 0.16451438f, 0.12157487f, -0.06157652f, 0.05801348f, 0.06603827f, 
    0.02959658f, 0.00990839f, -0.03754176f, -0.02864402f, 0.01789137f, -0.01578435f, -0.02258681f, -0.01128818f, 
    -0.03432712f, 0.02518066f, -0.05151459f, 0.03448900f, 0.01348350f, 0.03835887f, 0.01619098f, -0.06703971f, 
    -0.01694554f, -0.03324707f, -0.05583295f, -0.02821629f, 0.02489255f, -0.05571454f, 0.02941118f, 0.06075852f, 
    -0.07141583f, 0.04640364f, 0.02835528f, -0.03421262f, -0.03247475f, 0.01736431f, 0.01218842f, 0.03527543f, 
    -0.02586968f, -0.04871042f, 0.05521236f, -0.02664276f, 0.04165164f, 0.01148168f, 0.02121221f, 0.00866630f, 
    -0.01345034f, 0.02413756f, -0.04782399f, 0.03461313f, -0.06500368f, 0.03954315f, -0.04819531f, 0.03043195f, 
    0.01363545f, -0.02114520f, 0.02246026f, -0.06505868f, 0.04610783f, 0.00382348f, 0.00111860f, -0.03595719f, 
    -0.00140108f, 0.03518475f, 0.00368011f, -0.04353586f, 0.01712906f, 0.01496124f, -0.06434309f, -0.00161264f, 
    0.02978777f, 0.03530543f, -0.01554229f, -0.04551187f, 0.03224601f, -0.03595911f, -0.02084877f, -0.03205153f, 
    0.00071402f, -0.03621387f, -0.03910620f, 0.02064827f, 0.04385778f, -0.03970147f, 0.02763502f, -0.00977217f, 
    0.03564410f, -0.00396494f, 0.02164110f, -0.00568324f, -0.05949753f, 0.02394512f, 0.03964710f, 0.03357337f, 
    -0.04592545f, 0.02959238f, 0.02426031f, -0.04291726f, -0.01254023f, -0.01452656f, -0.00595368f, -0.02660646f, 
    -0.03869829f, -0.05648950f, 0.02467405f, -0.05881708f, -0.02654425f, 0.04463292f, 0.01718900f, -0.05302009f, 
    0.04914404f, -0.03598231f, 0.04764480f, -0.01857610f, -0.04130628f, -0.03951051f, 0.04020066f, -0.05513984f, 
    -0.04280371f, 0.02005416f, -0.03974131f, -0.06230533f, -0.02860816f, -0.01373528f, 0.02668149f, 0.00036503f, 
    0.02939891f, 0.02141853f, 0.01453582f, -0.03778225f, 0.02770586f, -0.02114692f, 0.04278077f, 0.03229980f, 
    0.02226917f, -0.05419053f, -0.02097437f, 0.03021223f, 0.04117744f, -0.01307988f, -0.00741033f, 0.03630805f, 
    0.02106933f, -0.05596174f, -0.01614019f, -0.00089180f, -0.05360065f, -0.02916829f, -0.01646870f, 0.05356566f, 
    0.03868777f, 0.01218759f, 0.04605266f, -0.05780561f, 0.01526029f, 0.00913880f, 0.00987378f, 0.02976860f, 
    -0.04850310f, 0.02001979f, 0.02078520f, 0.05183024f, 0.01204883f, 0.04408123f, -0.03991530f, -0.06393144f, 
    -0.03695443f, -0.00937251f, -0.01264074f, -0.00623187f, 0.03686963f, -0.01088193f, 0.00914347f, -0.04781523f, 
    -0.00758274f, 0.01986726f, -0.04546862f, -0.04525637f, 0.01528680f, 0.04108419f, -0.03675137f, -0.03806824f, 
    -0.05355278f, 0.00315992f, -0.02305679f, -0.02567419f, 0.02171727f, 0.02687757f, -0.00052186f, -0.03954016f, 
    0.02603769f, -0.03460196f, -0.02027620f, 0.00776427f, 0.02048486f, 0.00325796f, -0.00506599f, 0.00346678f, 
    -0.03378985f, -0.01599494f, 0.04408918f, -0.00739907f, -0.06478500f, 0.05403361f, -0.02473350f, -0.00398859f, 
    0.02720855f, -0.04611558f, -0.02107657f, -0.02216907f, -0.01020865f, -0.04875134f, -0.03508449f, 0.02783617f, 
    -0.02893510f, -0.02756389f, -0.02560154f, -0.05148567f, -0.01219721f, 0.03294634f, -0.02479896f, -0.04828400f, 
    -0.01195775f, 0.00142401f, -0.00419242f, 0.03980768f, 0.03995799f, -0.06009018f, 0.03038441f, -0.00353014f, 
    0.03956143f, -0.02467003f, 0.02134210f, 0.00265038f, -0.00544663f, 0.03967952f, -0.01093746f, 0.01427865f, 
    0.00264598f, 0.04787463f, -0.06241762f, -0.05293874f, 0.03833812f, -0.01868852f, 0.00092818f, -0.04960562f, 
    0.03834405f, -0.00981475f, 0.00347225f, 0.02722728f, 0.01123933f, -0.05553822f, -0.03761220f, 0.00764893f, 
    -0.02306649f, -0.02920030f, 0.00520265f, -0.05005799f, 0.01925466f, 0.04311370f, -0.03685662f, -0.05118421f, 
    0.01338391f, 0.00120816f, 0.04070519f, -0.00595903f, 0.05496107f, -0.03576906f, 0.01640473f, 0.01277007f, 
    -0.04763963f, 0.02063350f, 0.00400121f, -0.06796531f, -0.00253247f, 0.00025301f, 0.05699386f, -0.04428978f, 
    -0.00535197f, -0.00227357f, 0.01986331f, -0.02585909f, -0.01449772f, -0.03844967f, -0.04498128f, -0.03759693f, 
    -0.01134732f, -0.01884452f, -0.02961141f, 0.03450222f, 0.04846011f, 0.00050627f, -0.02493239f, -0.04069978f, 
    0.00602550f, -0.05729385f, 0.01139956f, 0.04289507f, -0.03965490f, -0.05197362f, -0.06299409f, 0.03585794f, 
    0.04167383f, 0.02589412f, 0.03007897f, 0.04444290f, -0.00822964f, 0.05070470f, -0.01402931f, 0.01872846f, 
    0.04199854f, 0.00161940f, 0.02499996f, -0.04264762f, -0.00061614f, -0.01612078f, -0.03109889f, -0.02285907f, 
    -0.01274131f, 0.00407894f, -0.03931641f, 0.00446973f, 0.03146603f, 0.01409064f, 0.03000441f, -0.00140195f, 
    -0.01572726f, 0.03407565f, -0.03343463f, 0.00397226f, -0.04805610f, -0.05229268f, 0.00674393f, -0.01190152f, 
    -0.04648192f, 0.01442801f, 0.01616119f, 0.00406737f, 0.04706918f, -0.01949925f, -0.00499759f, -0.00465670f, 
    -0.01594668f, 0.02145782f, 0.04918350f, -0.03700120f, -0.04563780f, 0.02122319f, -0.01557582f, -0.02990622f, 
    -0.05721078f, -0.01450123f, 0.04568474f, 0.01027695f, -0.00210059f, 0.03978757f, 0.03516814f, 0.02221506f, 
    0.04911867f, -0.03541661f, 0.01001647f, 0.01190180f, -0.01015763f, -0.04464990f, -0.06314114f, -0.02096450f, 
    -0.04053471f, 0.00921785f, -0.05886737f, -0.01555965f, -0.05806473f, -0.01814858f, 0.04691815f, -0.03595650f, 
    0.00096839f, -0.00442578f, -0.01898586f, 0.04524434f, 0.01044184f, -0.05586532f, -0.03777495f, -0.05247049f, 
    -0.01937449f, -0.04878987f, -0.02453493f, 0.00661228f, 0.01444353f, 0.02234242f, -0.01528445f, 0.02012452f, 
    0.02957672f, -0.05501123f, 0.04312330f, -0.05614001f, -0.01903760f, -0.04084607f, 0.01747841f, 0.00012010f, 
    -0.01747821f, 0.00990852f, -0.04735097f, 0.03569054f, -0.01545133f, 0.01201012f, -0.04591458f, 0.04877894f, 
    -0.02168457f, 0.01429823f, -0.05455745f, 0.01220698f, 0.01146297f, 0.01023835f, -0.00857401f, 0.00526875f, 
    0.02240470f, 0.03632537f, -0.05270176f, -0.03692378f, -0.05859989f, -0.00411484f, -0.02247392f, -0.00891124f, 
    0.03357523f, 0.04247500f, 0.01633545f, -0.01890660f, -0.03668487f, 0.04898872f, -0.05047946f, -0.03110318f, 
    -0.02678978f, -0.05010592f, 0.02171918f, -0.05286269f, -0.03948529f, -0.01679505f, 0.01628850f, 0.00210139f, 
    -0.03570364f, 0.04188719f, -0.02475341f, -0.00068338f, -0.04911427f, 0.02768474f, -0.04339855f, 0.00388103f, 
    0.03539424f, 0.00317777f, -0.05326929f, -0.04248209f, -0.04915547f, 0.03853397f, 0.04215674f, -0.04683976f, 
    0.03752938f, 0.03742087f, 0.04067620f, -0.06142553f, 0.00705297f, 0.04307136f, 0.00167630f, 0.01846344f, 
    -0.02868326f, 0.03936823f, 0.02426988f, -0.01670531f, 0.04158580f, 0.00217936f, 0.00022535f, -0.04684370f, 
    0.04925373f, -0.01398426f, 0.02445666f, 0.01028368f, -0.03229367f, -0.05173348f, -0.03576737f, -0.03031987f, 
    -0.03996119f, -0.02747307f, 0.01366843f, 0.01836013f, -0.03740676f, -0.05612547f, -0.00924131f, -0.04086687f, 
    0.01965915f, -0.01989689f, 0.00846142f, -0.02658030f, -0.00650232f, 0.01481158f, -0.04137903f, -0.03233770f, 
    -0.04234806f, 0.01767153f, -0.01332660f, 0.03980966f, 0.00228440f, 0.04941187f, -0.04837940f, 0.03453605f, 
    -0.00480759f, 0.02765594f, -0.01157525f, -0.03596739f, -0.04205291f, 0.03731742f, 0.03191168f, 0.04031194f, 
    0.01499050f, 0.00823111f, 0.04634009f, -0.01074561f, -0.01301725f, -0.05211480f, 0.03304372f, 0.01797338f, 
    -0.01744843f, 0.04400982f, 0.04708358f, -0.00523218f, -0.02950890f, -0.01256688f, -0.04449765f, 0.01243467f, 
    -0.05681582f, 0.03354520f, -0.01732017f, -0.00419868f, -0.04630829f, -0.05899887f, 0.02686491f, -0.03721335f, 
    0.02888220f, -0.02959314f, 0.04241660f, 0.00068193f, 0.01756235f, -0.02155479f, 0.01919928f, 0.02683333f, 
    0.00301679f, -0.04068440f, -0.04013716f, 0.00909187f, -0.05509317f, -0.04637749f, -0.03925727f, -0.04687957f, 
    -0.05822134f, -0.03620354f, -0.06213984f, 0.01394599f, -0.05407442f, -0.02961357f, 0.04644820f, -0.05273129f, 
    0.00320723f, 0.02029352f, 0.00724615f, 0.04679397f, -0.05559972f, 0.02079242f, -0.03339657f, -0.06023621f, 
    0.01057249f, -0.02495762f, 0.01875114f, -0.01790118f, 0.02030424f, 0.00757181f, -0.02280689f, 0.03836038f, 
    0.00325383f, 0.04697477f, -0.00177177f, 0.01300610f, -0.00840805f, 0.00525794f, 0.03350556f, -0.01139717f, 
    0.00806844f, 0.00168051f, -0.00984324f, -0.01388394f, -0.04311116f, -0.01619308f, -0.02865166f, 0.05202883f, 
    -0.05093451f, 0.03274733f, 0.02171041f, -0.03318432f, -0.04291938f, 0.05069187f, -0.01713950f, 0.00699752f, 
    -0.03003275f, 0.02891327f, -0.01008208f, 0.00239859f, 0.00328921f, -0.05938271f, -0.00747842f, 0.02530007f, 
    -0.00181904f, 0.00215977f, -0.04131014f, -0.01540820f, -0.01357064f, -0.00064780f, -0.01249419f, 0.02852026f, 
    -0.03295479f, 0.01376625f, 0.04379259f, 0.03609361f, -0.04217125f, -0.05346788f, 0.03017813f, 0.00292731f, 
    -0.02016676f, -0.03342822f, 0.01120301f, -0.04685827f, -0.01875266f, 0.00302230f, -0.03179190f, -0.01525631f, 
    -0.03804595f, 0.02417498f, -0.01681721f, -0.03582168f, -0.03071833f, 0.01004712f, 0.04651071f, -0.05352500f, 
    -0.04915169f, 0.03563765f, 0.00624715f, -0.03531851f, -0.03887979f, -0.05628157f, 0.02004670f, -0.04894599f, 
    0.03519901f, -0.01767723f, -0.03162674f, -0.03724668f, -0.02524269f, 0.03626521f, 0.02884485f, 0.01868726f, 
    -0.05303776f, -0.01608462f, -0.04645395f, 0.03816307f, -0.02709751f, 0.04140316f, 0.03917659f, 0.04315122f, 
    -0.04279053f, -0.05140999f, -0.04353141f, -0.05347556f, -0.01919436f, 0.03035915f, -0.04348950f, -0.04609003f, 
    -0.02203302f, 0.04306576f, 0.04499796f, -0.00550949f, -0.00585333f, -0.05240544f, 0.00138214f, 0.03391990f, 
    0.00430049f, -0.03843326f, 0.02675239f, 0.00312579f, -0.02532561f, 0.03035277f, -0.05578632f, -0.04148753f, 
    -0.01353829f, -0.01210164f, -0.01370532f, -0.05915921f, -0.00163041f, -0.03090537f, -0.02554196f, 0.03495688f, 
    -0.05595939f, 0.04414750f, -0.05256410f, -0.05679043f, -0.04119961f, -0.04893685f, 0.00876642f, 0.01754029f, 
    -0.00711437f, 0.02148366f, 0.00188051f, 0.03491719f, -0.03900803f, 0.00939979f, 0.01375229f, -0.01370356f, 
    -0.04519046f, -0.03158565f, 0.02540081f, 0.03717243f, 0.00794015f, -0.05666954f, 0.03241222f, 0.02079877f, 
    -0.00456717f, 0.04559578f, 0.00718445f, 0.01405000f, 0.03197158f, -0.05881247f, -0.00034864f, -0.01863542f, 
    0.01196539f, 0.04583896f, -0.05525009f, 0.00662730f, -0.04836235f, 0.00175746f, 0.01891961f, -0.01802390f, 
    -0.03501993f, 0.02010795f, 0.02228558f, 0.03277769f, 0.04654554f, -0.04391426f, -0.06341883f, 0.03068086f, 
    0.00562504f, -0.00835963f, -0.02548116f, -0.04457160f, 0.02773882f, 0.00821790f, -0.05566670f, 0.04144578f, 
    0.00693445f, -0.01483482f, 0.00944529f, -0.05848058f, -0.06094607f, -0.04198116f, -0.00130022f, -0.05595887f, 
    0.02911706f, 0.01115275f, 0.02659952f, -0.00754889f, -0.00852049f, 0.01088741f, -0.02311390f, -0.02437150f, 
    -0.02201786f, 0.04445368f, -0.01755707f, 0.01466573f, 0.02686447f, 0.01055753f, -0.02787572f, -0.00583359f, 
    -0.01333830f, 0.04223179f, -0.03743251f, -0.01455375f, 0.04608218f, -0.04510565f, -0.05146819f, -0.04406419f, 
    -0.04760985f, -0.02712769f, 0.00018334f, 0.02929212f, 0.03107311f, -0.04630635f, -0.04813510f, -0.06415381f, 
    0.00485652f, -0.05655001f, 0.02769075f, -0.03529680f, 0.04718347f, -0.04309139f, -0.05396672f, -0.03895661f, 
    0.03883348f, -0.04458972f, 0.04168274f, 0.02678132f, 0.00992591f, 0.00600086f, -0.05144507f, 0.01408958f, 
    -0.02886517f, 0.01318357f, 0.02557079f, 0.00004338f, 0.03177282f, -0.03521863f, -0.03395094f, 0.04104882f, 
    -0.03263346f, -0.05290759f, 0.03025106f, -0.01826676f, 0.00860476f, -0.05875086f, 0.00528947f, -0.05858080f, 
    0.04057568f, -0.04490379f, -0.02584991f, 0.01760573f, -0.04921851f, 0.01901908f, -0.05376013f, -0.03374889f, 
    -0.05764950f, -0.02579742f, -0.01014811f, -0.02979432f, -0.04459455f, -0.00004334f, -0.04220965f, -0.06113141f, 
    -0.03902118f, -0.02238744f, -0.00892837f, -0.01060087f, 0.00035563f, 0.03656381f, 0.01996551f, 0.00031023f, 
    0.02501593f, 0.02769213f, 0.01149670f, 0.00526100f, 0.00708852f, -0.03125798f, 0.01544232f, 0.04078574f, 
    0.01440104f, -0.01421245f, -0.03972148f, 0.01385816f, -0.02074062f, 0.01231512f, -0.04454888f, -0.04220989f, 
    0.01546139f, -0.04851751f, 0.03455561f, -0.01570790f, -0.00305707f, 0.00865254f, 0.02446583f, 0.02984528f, 
    -0.06382750f, 0.00728205f, 0.04514511f, 0.04051284f, -0.01569250f, -0.03292137f, -0.00422365f, -0.01483340f, 
    -0.04753559f, -0.00075122f, 0.02795009f, -0.04669477f, -0.01765716f, -0.03229932f, -0.03572627f, -0.06464370f, 
    -0.02546140f, 0.03591398f, -0.03169955f, 0.04976878f, 0.02852144f, -0.05039320f, -0.01456245f, -0.04414225f, 
    -0.04588254f, -0.06220180f, 0.03419036f, -0.06078826f, -0.03891907f, 0.04013621f, 0.00917944f, 0.06380132f, 
    -0.03049166f, -0.02490469f, -0.01294131f, -0.02858809f, 0.03063145f, -0.03944454f, -0.01190645f, -0.03951695f, 
    0.01857739f, 0.01599601f, 0.02029376f, -0.04041898f, -0.06196081f, -0.01702419f, 0.02465769f, -0.00112076f, 
    0.01182341f, -0.05501099f, 0.02486221f, -0.01582106f, -0.06155915f, -0.02706526f, -0.03899770f, -0.05056581f, 
    0.00519858f, -0.03060128f, 0.00588756f, 0.01634854f, 0.04305414f, -0.01162856f, 0.03814128f, 0.02821070f, 
    0.03478112f, -0.02424455f, -0.00881625f, -0.02954102f, 0.03388805f, -0.06062715f, 0.01185741f, -0.03798816f, 
    0.04401755f, 0.05093566f, -0.00202392f, 0.02263077f, -0.00506603f, 0.00919018f, -0.01871469f, 0.00759000f, 
    0.01744640f, -0.00503273f, 0.01327996f, -0.02228036f, -0.04236760f, 0.02030340f, 0.04137607f, -0.05927889f, 
    -0.04910523f, -0.06470190f, -0.00947315f, -0.00862831f, 0.02051717f, -0.00144301f, -0.05828191f, 0.01514276f, 
    0.01804356f, -0.01738834f, -0.00474945f, -0.05303518f, -0.05780187f, -0.04840123f, -0.05144642f, -0.04106583f, 
    -0.03958414f, 0.02001124f, -0.04423675f, 0.02186145f, -0.00981623f, 0.03115047f, -0.04267756f, 0.04586517f, 
    0.04746446f, -0.03950322f, -0.01906047f, -0.02365527f, 0.00922233f, -0.01340098f, 0.04096023f, -0.02378378f, 
    -0.02961952f, -0.04704022f, 0.02665387f, -0.05168388f, -0.05337378f, -0.02198162f, 0.04888117f, -0.05645588f, 
    0.04349291f, 0.01602608f, -0.05520906f, 0.04822519f, -0.01858401f, -0.03622920f, 0.02317249f, 0.03263021f, 
    -0.05148800f, -0.05339403f, -0.03345498f, -0.00866437f, -0.04676413f, -0.04997304f, -0.05747022f, -0.01359288f, 
    -0.02904593f, -0.03383582f, -0.04063675f, 0.01310198f, -0.01316604f, -0.03873021f, -0.01620296f, 0.03885899f, 
    -0.01366478f, -0.05425603f, -0.04767366f, -0.01680265f, -0.05599703f, 0.01031836f, 0.01202525f, 0.03321743f, 
    -0.05034663f, -0.00533604f, 0.03397620f, -0.02693955f, 0.03361741f, 0.01634810f, 0.00043780f, -0.05654883f, 
    0.00795355f, 0.04381219f, 0.01711852f, -0.03217454f, -0.05541150f, 0.04292299f, -0.02863576f, 0.00199450f, 
    -0.04394587f, 0.03287196f, -0.04110045f, 0.01532459f, -0.00031769f, 0.04954560f, -0.02563424f, -0.02879541f, 
    0.01297137f, -0.02211139f, 0.02862303f, 0.02332981f, -0.05532936f, 0.04180555f, 0.01831827f, -0.02642860f, 
    0.00807831f, -0.04103690f, 0.02596185f, -0.04915510f, -0.04052915f, -0.01335088f, 0.01966197f, 0.03951354f, 
    -0.04752592f, -0.05316536f, -0.00869112f, -0.06105218f, -0.05411562f, -0.03954941f, 0.03607702f, -0.01379280f, 
    -0.04833198f, -0.02634204f, -0.02345109f, -0.04122175f, 0.03358111f, 0.00754121f, 0.02728793f, -0.01279975f, 
    -0.03323285f, 0.02803982f, -0.03938875f, 0.05422735f, 0.04836255f, -0.01639200f, 0.04273695f, -0.03787408f, 
    -0.05049319f, 0.03669112f, -0.01606963f, -0.00470107f, 0.02554427f, 0.01417365f, -0.04329745f, 0.01757379f, 
    -0.04754933f, 0.03902793f, -0.00138085f, 0.01930048f, 0.04379451f, -0.02025209f, -0.00493180f, -0.04309616f, 
    -0.02932432f, 0.05129677f, -0.02507672f, 0.04952630f, 0.03269223f, -0.05933486f, 0.01366214f, -0.02027838f, 
    0.01464227f, 0.02173069f, -0.02722455f, -0.05739702f, 0.02320266f, -0.04007933f, -0.02197423f, -0.05700531f, 
    -0.02586149f, 0.02487015f, 0.02518403f, -0.01788130f, -0.03410157f, -0.03408899f, -0.05292952f, -0.01878425f, 
    -0.02011958f, 0.03870878f, -0.03891569f, 0.04462490f, 0.01168061f, -0.00374078f, -0.05742541f, 0.02963532f, 
    0.04252918f, -0.04454610f, -0.00204619f, -0.01174246f, 0.02390312f, -0.03882462f, -0.00743956f, -0.01516389f, 
    -0.05234059f, 0.00901307f, 0.02334109f, -0.01081750f, 0.00870315f, 0.01778155f, 0.02089715f, 0.03884660f, 
    0.01737284f, -0.04323535f, -0.05438709f, 0.03947573f, -0.04675103f, 0.02061235f, -0.03849619f, -0.00032767f, 
    -0.04990929f, -0.05826131f, 0.03841452f, 0.03286850f, 0.02230030f, 0.00031712f, -0.03562401f, 0.04322939f, 
    -0.03253818f, 0.04251883f, -0.02035191f, -0.02983414f, -0.00994598f, -0.01841056f, -0.03344833f, -0.02547418f, 
    -0.00646681f, -0.00109534f, 0.00637358f, -0.02259950f, -0.02973842f, -0.00532650f, 0.00078848f, -0.01268633f, 
    0.01962653f, 0.03136070f, -0.05026687f, 0.01607353f, 0.00100543f, 0.00161467f, -0.02182126f, 0.01954064f, 
    -0.00137928f, 0.00306407f, -0.01172521f, -0.02375839f, -0.00450205f, -0.02961065f, 0.03903556f, 0.03001200f, 
    -0.01365972f, -0.00769720f, -0.00180935f, 0.00499882f, 0.00427942f, 0.02181531f, 0.03601482f, 0.03105951f, 
    -0.00969273f, 0.04526975f, -0.04209687f, 0.01466742f, 0.02171638f, -0.00166091f, -0.04514644f, -0.04402516f, 
    -0.01474359f, 0.01494354f, 0.01816373f, 0.02267611f, -0.04012747f, 0.01956183f, -0.01022737f, 0.02209929f, 
    0.00289749f, 0.01106397f, 0.04967557f, 0.00958706f, -0.04296375f, 0.01433961f, 0.00692229f, 0.01518302f, 
    0.04216326f, -0.00566475f, -0.01811213f, 0.01190485f, -0.02606533f, 0.02353588f, -0.02685352f, -0.04731335f, 
    -0.03029547f, 0.02484604f, -0.04339116f, 0.03343569f, 0.00493992f, -0.05298626f, -0.01210168f, 0.03551157f, 
    -0.03480466f, -0.02283806f, 0.00931544f, 0.01167542f, -0.04300395f, -0.00414134f, -0.01781945f, 0.04914534f, 
    0.04075908f, -0.02134111f, -0.02642310f, 0.03017872f, 0.04639048f, 0.03196961f, -0.05465587f, 0.04140849f, 
    0.03022156f, -0.03739284f, 0.05010139f, -0.01165367f, -0.03720395f, -0.06068822f, -0.02323003f, -0.04252054f, 
    -0.00359540f, 0.00867828f, 0.02343072f, 0.00752651f, 0.00449415f, 0.03785899f, -0.01852555f, -0.00736432f, 
    0.08801530f, 0.07086805f, -0.02109182f, -0.13804176f, 0.00499137f, -0.02231032f, -0.10659927f, -0.00506717f, 
    -0.08303352f, -0.08281191f, 0.12293222f, 0.00878507f, 0.19060031f, 0.06740533f, -0.07407998f, 0.07256787f, 
    -0.00684446f, 0.08077998f, 0.03060882f, 0.06881759f, 0.39116359f, -0.15911022f, -0.06125761f, -0.23188016f, 
    0.24658380f, 0.17776614f, 0.14198084f, -0.10191081f, 0.04858385f, 0.16677710f, 0.04539467f, -0.05568099f, 
    -0.01328525f, -0.08737543f, -0.06115932f, 0.14805087f, 0.04845395f, 0.04013560f, 0.05549886f, 0.10778015f, 
    0.43169868f, -0.23761535f, 0.26111093f, -0.26419103f, 0.08665252f, -0.11536005f, 0.03038925f, -0.12350699f, 
    -0.03993854f, 0.02091898f, 0.12655549f, 0.20302741f, 0.06947573f, 0.07400440f, 0.01781211f, 0.05714499f, 
    -0.09016953f, 0.09607475f, 0.16049005f, 0.09348015f, 0.10510699f, 0.21143685f, -0.25322828f, 0.03621070f, 
    0.21678159f, 0.08424172f, -0.07814254f, 0.04093685f, -0.11464623f, 0.00612992f, -0.01462997f, -0.04962519f, 
    0.06056058f, 0.07698946f, -0.04985597f, -0.05460950f, -0.06208424f, 0.11487196f, -0.02478552f, -0.03712932f, 
    0.07699388f, 0.42201811f, -0.18869391f, -0.07662489f, -0.12287852f, -0.04773388f, 0.05600226f, 0.17755619f, 
    -0.07738439f, 0.13072214f, 0.07023547f, 0.00709165f, 0.10924035f, -0.12765937f, 0.08080491f, -0.07045060f, 
    0.07020617f, -0.04900469f, 0.06118436f, 0.31207380f, 0.14056644f, -0.05648063f, 0.20900425f, -0.01060354f, 
    -0.13514975f, -0.02372972f, 0.04152291f, -0.02682780f, -0.03013798f, 0.06688958f, 0.13312905f, -0.03616577f, 
    0.01912572f, 0.03875260f, -0.00841092f, -0.13504954f, 0.15101545f, -0.10002081f, -0.02931760f, 0.11678797f, 
    0.14278878f, 0.09072530f, 0.08149148f, -0.03444408f, 0.11330435f, -0.02575191f, -0.15031317f, -0.16552989f, 
    -0.18469538f, -0.10721190f, 0.20799309f, 0.05265023f, 0.20543981f, 0.12262964f, -0.12003490f, 0.06397445f, 
    0.07383340f, -0.13729107f, 0.03437449f, -0.04027659f, -0.09871002f, -0.44877768f, 0.32766625f, 0.14815442f, 
    -0.19230771f, -0.17310548f, 0.00563334f, 0.01236678f, 0.19554156f, -0.02666872f, 0.14553900f, 0.07501283f, 
    -0.02563938f, -0.00873088f, 0.10756428f, -0.03394942f, -0.02338143f, 0.00708333f, -0.02658475f, 0.11583273f, 
    0.26884615f, 0.16329488f, -0.22417198f, -0.28808036f, 0.13853875f, 0.09040357f, 0.08827997f, 0.24891470f, 
    -0.01774067f, 0.00776744f, -0.04908622f, 0.01558774f, 0.00843850f, -0.02982358f, -0.16250144f, 0.05983520f, 
    -0.04835513f, -0.04402099f, -0.04337043f, -0.14455295f, 0.34240600f, -0.04352946f, 0.22746806f, -0.39504179f, 
    0.24540401f, -0.06029347f, 0.08478616f, -0.08742581f, 0.02855584f, -0.07707392f, -0.01498624f, 0.06829330f, 
    0.06284527f, -0.06550349f, 0.03479879f, 0.04236908f, -0.03111879f, -0.02470424f, 0.10556336f, -0.04911058f, 
    -0.34526902f, -0.06137306f, 0.21641319f, 0.11374597f, -0.12568350f, -0.06086865f, 0.02845527f, 0.19985603f, 
    -0.03332889f, -0.03123932f, -0.06174099f, -0.04632867f, -0.03521379f, -0.06027083f, -0.02761098f, 0.05233502f, 
    -0.02276617f, 0.13502684f, 0.08174738f, -0.07698776f, 0.16862004f, -0.04016252f, 0.03783778f, 0.28151485f, 
    -0.04895778f, 0.25260955f, 0.06289628f, 0.10738885f, 0.08211627f, 0.13173290f, 0.06472322f, -0.02510866f, 
    -0.05571871f, -0.03543043f, 0.06791986f, 0.02803687f, 0.09367310f, -0.00360573f, -0.10807969f, 0.13253400f, 
    0.03592653f, 0.08592601f, -0.49105474f, 0.21272960f, 0.06164758f, 0.13265271f, 0.01482859f, 0.00702565f, 
    -0.05322527f, 0.18719479f, -0.04047885f, -0.01133985f, -0.05487163f, -0.08681449f, 0.01072143f, 0.05788128f, 
    -0.12452277f, 0.07481620f, 0.04077058f, 0.00029253f, -0.16616057f, -0.03739726f, 0.17060630f, 0.28026187f, 
    -0.20142323f, 0.04363514f, -0.04130288f, 0.11147708f, 0.04815577f, 0.09208633f, 0.05356426f, 0.02033656f, 
    -0.09200069f, 0.05230285f, 0.07468897f, -0.05285548f, 0.10217904f, -0.06491658f, 0.00972719f, 0.03387660f, 
    0.03088680f, -0.15371992f, 0.15184765f, -0.33806789f, -0.12359811f, 0.00901678f, -0.11807065f, -0.09663349f, 
    -0.10343074f, -0.07597212f, 0.17977573f, 0.03120074f, 0.14601013f, 0.09000570f, -0.15032941f, -0.02230618f, 
    0.00764788f, 0.02219170f, -0.10573995f, 0.03012161f, -0.30635700f, -0.11520888f, 0.06467903f, 0.13900411f, 
    -0.23695934f, -0.05295774f, -0.15495618f, -0.07872037f, 0.03276358f, 0.00304599f, 0.01947927f, -0.07554351f, 
    -0.04160205f, 0.00000705f, 0.07709816f, -0.03216064f, 0.00518728f, -0.02735272f, 0.02467795f, -0.02815075f, 
    0.27771547f, 0.07277831f, -0.10498237f, -0.13132492f, 0.03729982f, 0.03782432f, -0.26922759f, -0.13340344f, 
    -0.09757603f, -0.09661491f, 0.08323339f, -0.05163043f, -0.00138955f, -0.11926112f, 0.01022489f, 0.08034433f, 
    -0.00474710f, -0.13158013f, -0.07801417f, -0.00957457f, -0.37259692f, 0.07677529f, 0.14375529f, -0.38089499f, 
    0.23652500f, -0.06731338f, 0.09327710f, -0.28036889f, -0.05875444f, -0.20206222f, 0.09813749f, 0.08636755f, 
    0.12412319f, -0.18423934f, -0.30907345f, -0.04383560f, -0.07274521f, -0.16002658f, 0.00743991f, -0.06566319f, 
    0.43502903f, -0.54754525f, 0.07176784f, -0.19655132f, -0.11093510f, -0.25222084f, -0.12435806f, 0.10473606f, 
    -0.05153707f, -0.07094780f, 0.20590255f, 0.20288733f, 0.00628627f, 0.01148569f, 0.10499918f, -0.09510864f, 
    0.02925106f, 0.06864604f, 0.14794375f, 0.05011230f, 0.11045593f, 0.29881227f, 0.08742303f, 0.14889729f, 
    -0.17876120f, 0.13211335f, -0.09709068f, -0.03220361f, -0.07162300f, 0.06286340f, 0.08967810f, -0.05243852f, 
    -0.02937395f, 0.11070996f, 0.03064273f, 0.05330499f, 0.05376475f, 0.13403709f, -0.03276172f, 0.08846094f, 
    -0.10825174f, 0.13337091f, 0.20009361f, -0.14320673f, -0.38887724f, 0.10837979f, -0.01114461f, 0.10240874f, 
    -0.12720396f, 0.02598890f, 0.01874349f, -0.09983588f, -0.00527176f, 0.05414296f, 0.10140184f, 0.10200391f, 
    0.04229345f, -0.13854095f, -0.06541090f, -0.03262199f, 0.37091228f, -0.21055013f, 0.01989151f, -0.07901739f, 
    -0.07722601f, 0.04952954f, -0.09756432f, 0.11203725f, -0.05050622f, -0.20404997f, 0.05460116f, 0.03232995f, 
    -0.00610636f, 0.00255175f, 0.06302085f, -0.05687728f, -0.06207761f, -0.03267816f, -0.12106822f, -0.08446176f, 
    0.19311348f, 0.16456047f, 0.15491441f, -0.06100370f, 0.19008088f, -0.00404760f, -0.28359586f, -0.08109345f, 
    0.02931649f, -0.24189065f, 0.05135468f, 0.09015524f, -0.07261722f, -0.20274746f, -0.05463807f, 0.14187849f, 
    -0.05902941f, -0.16909942f, 0.13003442f, -0.07660328f, 0.73083848f, 0.02730138f, 0.28824541f, 0.01998611f, 
    -0.12822482f, -0.01542871f, 0.11095583f, 0.00207556f, 0.23568404f, 0.04784001f, 0.18856379f, 0.00213341f, 
    0.09153466f, -0.05548911f, -0.04216992f, -0.02904543f, -0.12735352f, -0.04944735f, 0.05185273f, 0.00762880f, 
    0.01277697f, 0.42137066f, -0.20907390f, -0.17699900f, -0.23004915f, 0.02661305f, -0.10203442f, 0.02816832f, 
    -0.03131688f, 0.26459977f, -0.01126747f, -0.03357712f, -0.00777848f, 0.03722577f, -0.09970174f, 0.15629183f, 
    0.11139450f, -0.09729754f, 0.02569952f, 0.07608582f, 0.46626768f, -0.08122701f, 0.24884248f, -0.24330615f, 
    0.12430862f, -0.09255836f, 0.02025902f, -0.02949492f, -0.00751742f, -0.00923238f, 0.00398717f, 0.07813917f, 
    0.09236048f, -0.09952824f, -0.05892346f, -0.12951982f, 0.10226012f, 0.05838812f, 0.22036265f, 0.01203144f, 
    0.13754250f, 0.15744886f, 0.26125899f, 0.30569762f, -0.33992559f, 0.10796422f, 0.11724852f, -0.09711214f, 
    0.04843564f, 0.07075745f, -0.02597435f, -0.01783720f, 0.05776078f, -0.00648533f, -0.07375044f, -0.11319788f, 
    -0.03442888f, -0.21904629f, -0.01380714f, 0.01605547f, 0.13210832f, 0.05992042f, 0.28628537f, 0.06842929f, 
    -0.08550263f, 0.19075230f, 0.11287045f, -0.06969687f, -0.09909140f, 0.16326983f, -0.02119448f, -0.04495470f, 
    0.01960012f, 0.05490033f, 0.03098157f, -0.11594522f, 0.04186357f, -0.06703079f, 0.09057445f, 0.16302167f, 
    -0.03515800f, 0.44577155f, -0.02767128f, 0.19540499f, -0.09176309f, 0.05048939f, -0.02677496f, -0.10992773f, 
    -0.02935323f, 0.17770196f, 0.06627501f, 0.01682690f, -0.12315557f, -0.03298572f, -0.10209680f, 0.00863740f, 
    0.13304648f, 0.15659289f, 0.05456191f, 0.07940114f, 0.07912510f, 0.28872764f, 0.36963892f, 0.08778983f, 
    -0.19327019f, 0.04241219f, 0.10047583f, 0.06966085f, 0.06037566f, 0.17873192f, 0.11752330f, -0.00575688f, 
    0.07413927f, 0.08457838f, 0.07362151f, 0.00365605f, 0.13818099f, -0.04209966f, 0.10389896f, 0.14083004f, 
    0.28512031f, -0.43542853f, -0.23230569f, -0.27071047f, -0.37822428f, -0.11991996f, -0.25819254f, 0.18212783f, 
    -0.03719265f, -0.15936050f, 0.04731142f, 0.07951107f, -0.08566418f, -0.09121806f, 0.04510733f, -0.04316936f, 
    0.06397072f, 0.07736950f, -0.03199438f, -0.07743207f, 0.01934095f, 0.05680501f, 0.42557693f, 0.02095059f, 
    -0.15573169f, 0.08787907f, 0.00738933f, 0.06144940f, 0.03170956f, 0.01941846f, 0.24222061f, 0.07138421f, 
    -0.05083703f, 0.04367005f, 0.15291347f, -0.02331614f, 0.05164585f, -0.04862019f, 0.10956037f, 0.12806629f, 
    0.08121199f, -0.01207037f, 0.05788605f, 0.02887428f, -0.06489649f, -0.07862154f, -0.08160304f, 0.11938240f, 
    0.00724957f, -0.03279188f, 0.15380791f, 0.08950400f, 0.06303439f, 0.03995560f, -0.01758922f, 0.03395637f, 
    -0.02843238f, 0.04616572f, -0.07285490f, 0.05141020f, 0.47752160f, -0.04947256f, -0.33486632f, 0.18803550f, 
    0.11099093f, 0.21300161f, 0.03489097f, -0.00101008f, 0.22824818f, 0.08380252f, -0.01024788f, -0.09104652f, 
    0.03288985f, -0.14047749f, 0.06483234f, 0.01662342f, 0.00400051f, -0.05024423f, -0.01367213f, 0.14753522f, 
    0.51799917f, -0.32520011f, 0.15827675f, -0.04116775f, -0.02790060f, -0.09636423f, -0.01293030f, -0.12990007f, 
    0.17088979f, 0.04584782f, 0.03980118f, 0.08583328f, 0.14684138f, 0.07534967f, 0.08043914f, -0.02272646f, 
    -0.04380412f, 0.07925007f, -0.01230672f, 0.07027199f, -0.01823864f, 0.09780519f, -0.16388960f, -0.10606024f, 
    0.17821984f, -0.01109339f, -0.10215265f, 0.04956514f, -0.04689972f, -0.00789806f, 0.00735099f, -0.00425019f, 
    -0.07040217f, 0.03538746f, -0.02901212f, 0.08568370f, -0.01147456f, 0.08905281f, -0.07624120f, -0.03423614f, 
    0.01495982f, 0.17936856f, 0.03449772f, -0.04741806f, -0.21706167f, -0.00268169f, -0.04876331f, 0.23643307f, 
    0.04002915f, 0.08774569f, -0.08488698f, 0.09534045f, -0.05663252f, 0.12069044f, 0.01437320f, -0.02767221f, 
    0.10768716f, 0.05258209f, 0.04608902f, 0.19178016f, 0.02808573f, 0.08874447f, 0.20892508f, -0.04985559f, 
    -0.12982693f, -0.12076465f, 0.07039061f, -0.11437575f, -0.00573839f, 0.05613631f, 0.04883406f, -0.03741231f, 
    -0.06973936f, 0.08337975f, -0.04220194f, -0.11062855f, 0.05460804f, -0.07532725f, -0.01279999f, 0.09686425f, 
    0.15935217f, 0.04596753f, 0.11674276f, 0.13163275f, 0.16290048f, 0.01275559f, -0.05415515f, -0.05367819f, 
    -0.12786356f, -0.02050243f, -0.00783348f, 0.06106511f, 0.18474787f, -0.04765720f, 0.01760656f, -0.03702242f, 
    0.04414113f, -0.13723566f, 0.03908253f, -0.00503135f, -0.23350593f, -0.16688238f, 0.13048692f, 0.14963967f, 
    -0.20144916f, -0.08153581f, -0.08251722f, 0.23307863f, -0.00067359f, 0.05318531f, 0.01794624f, -0.04011302f, 
    0.03670211f, 0.03493220f, 0.07367064f, -0.05481155f, 0.03184005f, -0.03582545f, -0.00303633f, 0.09450176f, 
    0.19055198f, 0.14220110f, -0.41148508f, -0.19190638f, -0.16744438f, 0.04620383f, -0.00318554f, 0.31322601f, 
    -0.04965243f, 0.09177332f, -0.04989229f, -0.00286418f, -0.00816575f, -0.02369317f, -0.04152992f, -0.01831774f, 
    0.05859906f, 0.03903249f, 0.02060725f, 0.03575524f, 0.59633791f, -0.20622285f, -0.07442161f, -0.08326988f, 
    0.06064643f, -0.09816086f, -0.01078236f, -0.12597489f, 0.11024707f, -0.06139326f, 0.03779609f, 0.01538473f, 
    -0.08666726f, -0.05386493f, 0.07101129f, -0.07622993f, -0.01388701f, -0.04572387f, -0.01052304f, -0.00767864f, 
    -0.42679790f, 0.14917152f, 0.05813010f, 0.21812394f, -0.05418446f, -0.04308166f, -0.04808743f, 0.24013002f, 
    -0.01926522f, -0.00224154f, 0.03016705f, 0.04645156f, 0.05418925f, -0.03503913f, 0.00279085f, 0.04979112f, 
    0.10975211f, 0.17065339f, -0.09173778f, -0.06136868f, 0.12504365f, 0.05446085f, 0.10016256f, 0.07245117f, 
    -0.03023888f, 0.13201721f, 0.10123699f, 0.01194358f, 0.10513478f, 0.01026784f, -0.00261774f, 0.02135048f, 
    -0.02411649f, 0.03730243f, 0.00763256f, -0.04916462f, 0.00307510f, -0.15747340f, -0.06209300f, 0.02101174f, 
    0.11703217f, 0.14906378f, -0.49465066f, 0.02063445f, 0.12508218f, -0.03143069f, 0.00277097f, 0.05708728f, 
    -0.01699926f, 0.02814021f, -0.10458484f, 0.01318194f, -0.08632587f, 0.01486693f, 0.06931470f, 0.07041971f, 
    -0.08813434f, -0.04840253f, 0.01653291f, 0.03051186f, -0.08953865f, 0.18725239f, 0.31282398f, 0.23858938f, 
    -0.06495415f, -0.04479095f, -0.01298747f, 0.11851025f, -0.02660016f, 0.03900827f, -0.02468796f, -0.00375803f, 
    -0.05082528f, 0.07728864f, 0.07590971f, 0.03795858f, 0.07386772f, -0.09805740f, -0.02658795f, -0.08617657f, 
    0.11277492f, -0.04141039f, -0.00126475f, -0.17829500f, -0.19874220f, -0.05590935f, -0.04604556f, -0.13973428f, 
    0.08542606f, 0.04277590f, 0.13009502f, -0.01283536f, 0.09730661f, 0.01677086f, -0.12568298f, -0.16096403f, 
    0.00831059f, -0.10413896f, 0.01311231f, 0.01325556f, -0.22273543f, -0.03665691f, 0.11866677f, 0.08934392f, 
    -0.14079116f, -0.08815063f, -0.10627343f, 0.00064650f, -0.12687905f, -0.04407201f, -0.03077492f, 0.02329158f, 
    -0.11721677f, -0.19571212f, -0.01995707f, 0.05666459f, -0.03857615f, -0.18855907f, -0.05224723f, -0.08510941f, 
    0.11826217f, 0.07790649f, 0.23383108f, 0.13705723f, 0.16963589f, 0.06772014f, 0.01893004f, 0.07162526f, 
    0.05403230f, -0.00665999f, -0.05416132f, 0.08129606f, -0.04993322f, 0.06686721f, 0.00371930f, -0.16586788f, 
    -0.10480168f, -0.08181956f, -0.14996284f, -0.17711021f, -0.17039549f, 0.34225151f, 0.26724255f, 0.15698403f, 
    -0.05172008f, -0.03632672f, 0.12560035f, 0.02052350f, 0.11176211f, -0.26728743f, -0.02444335f, 0.00824370f, 
    0.05173633f, 0.17011331f, 0.09591635f, 0.07501549f, 0.04154861f, 0.01702101f, -0.04199481f, -0.23061064f, 
    0.08862729f, 0.29003006f, 0.21084297f, 0.12206838f, 0.11765765f, 0.08546787f, -0.01095890f, 0.04252229f, 
    0.03595408f, 0.02236670f, 0.01732720f, -0.08657698f, 0.28388897f, -0.00263958f, -0.03673776f, 0.10429806f, 
    0.05005935f, -0.14396933f, -0.08677531f, -0.03787965f, 0.41969278f, -0.00508446f, 0.34192953f, 0.02043457f, 
    0.08276765f, -0.19854642f, -0.05231423f, 0.10787092f, 0.00873090f, 0.07856624f, -0.04587382f, -0.00360510f, 
    0.05029352f, 0.06500703f, 0.02584163f, 0.08216280f, 0.04988594f, -0.08897503f, 0.17112774f, 0.25263962f, 
    -0.05474536f, -0.16528215f, 0.18022828f, 0.11471740f, 0.29826000f, -0.11232978f, 0.11739340f, -0.00127325f, 
    0.11009294f, -0.02452468f, 0.02679020f, 0.10881121f, -0.06543420f, 0.15183596f, -0.00740849f, 0.02729748f, 
    0.18123281f, 0.10191087f, 0.06666882f, 0.01637458f, -0.31831366f, 0.07448320f, -0.11864248f, -0.11864788f, 
    0.08573531f, -0.09202971f, -0.04546276f, -0.00553505f, -0.02192696f, -0.05422660f, -0.09994587f, 0.18719120f, 
    -0.02125968f, 0.02774470f, -0.02407730f, 0.02796832f, -0.15510331f, -0.01903781f, -0.11744379f, -0.23467496f, 
    0.38991857f, 0.26832619f, 0.22962888f, 0.04145382f, 0.00802966f, -0.05198826f, 0.01849421f, 0.13708815f, 
    0.11997501f, -0.00515726f, -0.06623895f, -0.05858010f, -0.09742990f, 0.14236403f, 0.00944240f, -0.07996456f, 
    -0.17181370f, -0.03690820f, -0.26587439f, -0.12357036f, -0.28163901f, -0.01176863f, -0.08811306f, 0.00634001f, 
    0.26051837f, 0.21494640f, 0.11776374f, -0.31329283f, 0.08019774f, -0.07716785f, -0.09894358f, -0.15845086f, 
    0.00966205f, -0.14510910f, -0.12891690f, -0.10658387f, -0.05876916f, 0.06320529f, 0.27100608f, -0.15141407f, 
    0.26442602f, -0.00307574f, 0.42993695f, 0.15140727f, 0.01377408f, -0.17537323f, -0.10248999f, -0.18577696f, 
    0.14590824f, -0.03291292f, -0.06721949f, -0.07435738f, -0.03008094f, 0.14945720f, 0.09034836f, 0.11474920f, 
    0.13348363f, 0.03713127f, 0.07314958f, 0.12963060f, -0.04026262f, 0.32549813f, -0.09844412f, 0.38672939f, 
    -0.19875893f, 0.06945299f, 0.11162671f, 0.01337883f, 0.00936943f, -0.04190078f, 0.05101743f, 0.12556572f, 
    0.19424391f, 0.20079684f, 0.00794730f, 0.19379561f, 0.11848975f, 0.22899820f, 0.09794197f, 0.13184850f, 
    -0.19313475f, -0.51625925f, -0.14298598f, -0.11725131f, 0.12235159f, -0.00685565f, 0.08831695f, -0.21591607f, 
    0.02611796f, 0.18321590f, -0.06654727f, -0.13289505f, -0.00330223f, -0.06557577f, -0.08001363f, -0.14108422f, 
    -0.04348575f, -0.05992697f, 0.20349313f, -0.08640191f, -0.29862821f, -0.02565212f, -0.44355482f, -0.09462098f, 
    0.05854595f, -0.11754029f, 0.04988788f, -0.07783530f, 0.02748156f, 0.15965118f, -0.12313945f, -0.01046443f, 
    0.07217406f, 0.08456031f, 0.08281861f, -0.02817842f, 0.10575128f, 0.21121474f, 0.21835850f, 0.16539656f, 
    0.48212817f, 0.16915484f, 0.42108420f, -0.13267934f, -0.00203351f, -0.36751002f, -0.01456349f, 0.04979299f, 
    0.08562686f, 0.01225158f, -0.00653337f, -0.07999864f, 0.12086488f, 0.09306994f, -0.01604249f, 0.00551122f, 
    0.04717899f, -0.14907005f, 0.00764882f, 0.06434184f, -0.07872544f, -0.27150184f, -0.50615507f, -0.18723619f, 
    -0.01973459f, 0.10068716f, 0.04440668f, -0.19026300f, 0.09252643f, 0.08194756f, -0.10545515f, -0.12252019f, 
    0.06694884f, -0.04458043f, -0.02013819f, -0.03695285f, -0.04923219f, 0.18683308f, 0.20468585f, 0.10912074f, 
    0.21304230f, 0.38338462f, 0.02453906f, 0.02239635f, 0.12442271f, -0.07531599f, -0.07465831f, -0.00283973f, 
    0.02382613f, -0.03370911f, -0.01680589f, 0.03638284f, -0.07176507f, -0.11016465f, -0.09416469f, -0.01592324f, 
    -0.16243239f, -0.11584909f, -0.11847440f, -0.10502906f, 0.15482126f, -0.18636358f, -0.23164053f, -0.02238074f, 
    0.15020512f, 0.01630149f, -0.00137754f, -0.06940576f, 0.13202500f, 0.21044648f, -0.16967477f, -0.04869137f, 
    0.01393181f, 0.06344529f, 0.00567621f, 0.10248012f, 0.14403886f, 0.14986968f, 0.28654695f, 0.11035831f, 
    0.02766564f, -0.13516006f, -0.11234099f, -0.12898785f, -0.02461856f, 0.03381251f, -0.05814728f, 0.01994971f, 
    -0.03283596f, -0.07377497f, 0.01234921f, 0.06156113f, 0.05423034f, -0.14462258f, 0.16421948f, 0.09592350f, 
    -0.04095699f, -0.01672548f, 0.05862245f, 0.04047160f, 0.21865249f, -0.19949682f, -0.19597901f, -0.16769594f, 
    -0.06101282f, 0.07501570f, 0.10547540f, -0.02131751f, -0.09046759f, 0.04515978f, 0.02311681f, -0.01523045f, 
    -0.03460652f, -0.16201864f, -0.19143192f, 0.03782405f, 0.01989216f, -0.08831313f, -0.09267566f, 0.01871245f, 
    0.27697596f, -0.45686081f, 0.26619092f, -0.33776367f, 0.07673876f, -0.19390249f, -0.02288506f, -0.19081354f, 
    0.03328437f, 0.03742525f, 0.23008655f, 0.13142812f, 0.03222533f, 0.16428611f, 0.06419460f, 0.04355403f, 
    0.00245084f, 0.09446977f, 0.03090911f, -0.01919198f, -0.21015313f, 0.24621882f, -0.11233568f, -0.12566924f, 
    0.14005952f, 0.10564126f, 0.00543014f, -0.00310919f, 0.04409108f, 0.03636536f, 0.04546418f, -0.07546335f, 
    0.02203049f, 0.08085736f, 0.05801506f, 0.03766704f, 0.09381151f, 0.18298942f, -0.02551424f, -0.13122098f, 
    0.25525272f, 0.17136501f, -0.29314548f, -0.00357248f, -0.21156947f, -0.06199994f, -0.03895828f, 0.03301659f, 
    -0.07233279f, 0.00913041f, -0.08488160f, 0.04263985f, -0.00105872f, 0.09485888f, 0.26977012f, 0.13861641f, 
    0.14131391f, -0.08332358f, 0.15652980f, 0.20263860f, 0.26531801f, 0.12996528f, 0.25776187f, 0.01293659f, 
    -0.04405915f, -0.07039741f, -0.06539252f, -0.08715560f, 0.03972449f, 0.00748118f, 0.00991600f, 0.00655316f, 
    -0.08278378f, -0.04259415f, -0.05532434f, -0.01589990f, 0.09706683f, 0.03794872f, 0.04240366f, 0.06810871f, 
    -0.11115942f, -0.12049686f, -0.29566163f, -0.22787482f, 0.01531155f, -0.02555237f, -0.06243808f, -0.17129894f, 
    -0.12033866f, -0.06758884f, 0.18990706f, -0.04215862f, 0.02383418f, -0.07454925f, 0.02994638f, 0.09696669f, 
    -0.05830876f, -0.20044445f, -0.06035602f, 0.05987146f, 0.10257117f, -0.34206626f, 0.08118587f, -0.03436034f, 
    -0.38917342f, -0.23814130f, -0.01137372f, -0.07279663f, 0.09734336f, 0.06841090f, 0.01736728f, 0.00440982f, 
    0.04270325f, -0.06605649f, 0.05733866f, 0.11915694f, -0.01799307f, -0.04532363f, 0.25416103f, 0.15224932f, 
    -0.02601431f, 0.19126360f, -0.22974718f, -0.10049798f, -0.06244346f, 0.08434691f, 0.09529117f, 0.21803062f, 
    0.06282941f, 0.23349182f, -0.06309018f, -0.02735929f, 0.08318298f, -0.02136611f, -0.05848834f, 0.14559643f, 
    0.00263492f, -0.02009415f, 0.05068213f, -0.00650276f, 0.14457764f, -0.25831863f, 0.24671687f, -0.39235017f, 
    -0.12183279f, -0.13641146f, -0.07844667f, -0.18217371f, 0.00706518f, 0.06030768f, 0.06378838f, -0.02707423f, 
    0.17473869f, -0.02456332f, 0.08745605f, -0.04662851f, 0.07273383f, 0.08013029f, 0.12599634f, -0.02188336f, 
    0.03372490f, 0.17692116f, 0.10289101f, -0.04737720f, -0.20486380f, 0.06591795f, 0.03485766f, 0.15126732f, 
    0.02680806f, -0.09435405f, 0.13338307f, 0.04728936f, 0.17366214f, -0.00092946f, 0.00084905f, 0.11509827f, 
    0.08222485f, 0.14647822f, 0.08368717f, 0.04634418f, 0.36837330f, 0.02086368f, 0.13360405f, 0.10906801f, 
    -0.12268576f, 0.23987907f, 0.00098193f, 0.07928649f, 0.05248052f, 0.09561960f, 0.05003203f, -0.01076994f, 
    0.11833905f, 0.12674901f, 0.08216903f, -0.00060269f, 0.09933824f, 0.00477393f, 0.09172352f, 0.18827362f, 
    -0.23136839f, 0.17103894f, -0.27473685f, 0.18495569f, 0.08820871f, 0.15230423f, -0.02073308f, 0.06308283f, 
    0.03950207f, 0.08548757f, -0.01896940f, 0.01388037f, 0.02382542f, -0.04965327f, 0.00023173f, -0.01484378f, 
    -0.00890016f, 0.14285906f, -0.00752466f, -0.05816260f, -0.04318941f, -0.00150333f, 0.31758139f, 0.08815861f, 
    -0.33330423f, -0.01570402f, -0.02037312f, 0.12513022f, -0.07119573f, -0.06604773f, 0.03519414f, 0.06648181f, 
    0.08864889f, 0.20539723f, 0.05564652f, 0.11683526f, 0.08820152f, -0.01564940f, 0.19741875f, 0.09258356f, 
    -0.04915154f, 0.06195549f, 0.23667181f, -0.14480819f, 0.07269668f, -0.07124792f, -0.10446825f, -0.04253047f, 
    -0.01490182f, -0.10011450f, 0.17088994f, 0.04828438f, -0.03800499f, -0.00285476f, -0.08613684f, -0.00473295f, 
    -0.02729751f, -0.01434485f, 0.03429662f, -0.05048010f, -0.29167101f, -0.11597750f, 0.22996080f, 0.21376795f, 
    -0.16417922f, -0.25647625f, -0.15049450f, 0.00150032f, -0.11022907f, -0.09360687f, 0.06560773f, -0.01619702f, 
    0.02593377f, 0.07128574f, -0.04767978f, -0.05188970f, 0.02874236f, 0.00873992f, 0.10872673f, -0.00193726f, 
    0.39403987f, -0.54694802f, -0.07885366f, -0.24920066f, -0.17871717f, 0.23777784f, -0.01901557f, -0.07667290f, 
    -0.15545619f, 0.07921000f, 0.04642420f, -0.24270886f, 0.04789585f, -0.10364060f, -0.13226180f, -0.05057226f, 
    0.09013914f, -0.09133442f, 0.06469757f, -0.10449466f, -0.78204584f, 0.66530693f, -0.44824034f, -0.00916522f, 
    -0.22027154f, 0.12600337f, -0.28115469f, -0.02197966f, 0.03389199f, -0.19850487f, -0.15264203f, -0.00034403f, 
    0.02732932f, 0.06739169f, -0.19458079f, -0.05566264f, -0.07017136f, -0.04617988f, 0.18796423f, -0.07003882f, 
    0.04457192f, 0.49170765f, 0.19080640f, 0.12305652f, -0.18713140f, 0.11923354f, -0.06119934f, -0.01698549f, 
    0.12227493f, -0.02949326f, 0.03598749f, -0.07096802f, 0.05990431f, -0.13542448f, -0.03069982f, 0.02295576f, 
    0.01583213f, -0.03020413f, 0.13978711f, -0.22828490f, 0.27450052f, -0.25869286f, 0.01993292f, -0.17839618f, 
    0.03693538f, -0.18533564f, 0.12746735f, -0.12105762f, -0.01167472f, -0.04167988f, -0.05772108f, 0.06266748f, 
    0.01698125f, -0.03120827f, -0.02746577f, 0.10102770f, -0.01417537f, 0.12017030f, 0.06667285f, -0.04062482f, 
    -0.04691464f, -0.25429103f, 0.32453415f, 0.28946897f, -0.03079843f, 0.00869158f, 0.10994141f, -0.01080525f, 
    -0.13349856f, 0.12764421f, -0.10266303f, 0.01686482f, 0.12064230f, 0.13268071f, -0.04755441f, 0.03263985f, 
    -0.03023864f, -0.03227283f, 0.11141940f, -0.10227288f, -0.05249361f, 0.11420377f, -0.07463309f, 0.18619220f, 
    0.19015439f, -0.00420112f, 0.12611572f, 0.01253088f, -0.01855022f, -0.03984223f, -0.00698858f, 0.18614179f, 
    0.12614882f, 0.08755075f, 0.09428716f, 0.16011497f, -0.02785149f, -0.08032168f, -0.13895249f, -0.07838523f, 
    0.19386655f, -0.13204996f, -0.37609112f, -0.03217113f, -0.05438549f, -0.26618716f, -0.26354668f, -0.03769077f, 
    -0.05758484f, -0.12880282f, -0.25702825f, -0.11069916f, -0.12640254f, 0.02319446f, 0.12655874f, 0.11014542f, 
    0.04867380f, 0.02841254f, 0.07187637f, -0.31360361f, 0.15342312f, 0.65626508f, 0.16234258f, 0.31377670f, 
    0.58959514f, 0.31251597f, -0.01238431f, 0.15330523f, 0.19890954f, 0.08150271f, -0.05107021f, -0.04864446f, 
    -0.04074964f, 0.05595873f, -0.00240451f, 0.00037986f, -0.12778729f, -0.01013974f, -0.05087119f, 0.04592934f, 
    0.16427149f, -0.04850250f, 0.25769353f, 0.00953115f, 0.03904498f, -0.04960036f, 0.12428297f, -0.17276430f, 
    0.01601307f, 0.07085112f, -0.04349876f, -0.04344912f, -0.06071235f, 0.08392005f, 0.01309688f, 0.00472911f, 
    0.00388803f, 0.01323081f, 0.10525786f, 0.13637818f, -0.01661961f, 0.76299828f, -0.23128638f, 0.14568734f, 
    -0.33157009f, 0.17997324f, -0.04911676f, -0.06981730f, -0.05570124f, -0.06217216f, 0.01942305f, 0.10518834f, 
    0.00364279f, -0.06294839f, -0.11115569f, 0.08755991f, 0.03935553f, -0.11451368f, 0.27302614f, 0.14051078f, 
    0.12970555f, -0.03287937f, 0.22163384f, 0.09206142f, 0.26278305f, 0.36897546f, 0.09267417f, 0.04514278f, 
    0.16866882f, 0.09384086f, 0.02345575f, 0.09490412f, -0.02793860f, 0.12798360f, -0.04013836f, -0.06103879f, 
    -0.09314186f, -0.14795060f, -0.14538293f, 0.16018106f, -0.48850054f, 0.20099020f, 0.01940308f, 0.10799118f, 
    0.08161794f, -0.21498354f, 0.31365165f, -0.04637681f, 0.09277227f, 0.11509186f, -0.04568029f, 0.07665027f, 
    -0.04270832f, 0.01863793f, -0.06625214f, 0.08750649f, 0.10205913f, 0.09996196f, -0.06892478f, 0.06408504f, 
    0.05331596f, -0.54570466f, 0.11508153f, -0.24200124f, 0.02421723f, -0.41528025f, 0.11162738f, -0.38296723f, 
    -0.03425349f, -0.14215092f, -0.10660852f, 0.12672783f, -0.03183184f, -0.09251326f, -0.06547276f, 0.01257601f, 
    0.04282146f, 0.12870049f, 0.04207748f, 0.02006246f, -0.11446379f, 0.27221575f, -0.04568889f, 0.22274853f, 
    0.38932171f, 0.12698083f, 0.06397744f, -0.10663324f, -0.12136260f, -0.01783299f, -0.01903995f, 0.07032146f, 
    0.00202939f, 0.08155608f, 0.03109479f, -0.01711685f, -0.01248414f, -0.02041431f, -0.25592804f, 0.14394216f, 
    0.32596070f, 0.28712702f, 0.08668164f, 0.27599755f, 0.06453460f, -0.14304648f, 0.02324753f, -0.08708421f, 
    -0.04808780f, -0.03779101f, 0.12461075f, -0.07260241f, -0.07524654f, 0.03549000f, 0.00039256f, 0.03466721f, 
    -0.08358474f, -0.04122210f, -0.13424543f, -0.21999806f, -0.17622305f, 0.16908555f, 0.59290779f, 0.30544722f, 
    0.20165248f, 0.14065066f, 0.20685259f, 0.17920659f, 0.01294978f, 0.06286287f, 0.01276333f, 0.12874271f, 
    -0.03625089f, -0.05289371f, 0.08759274f, 0.17690077f, 0.11065139f, 0.08903539f, -0.03414091f, 0.08835395f, 
    0.07521449f, 0.09408467f, 0.00509856f, -0.04226957f, 0.04674615f, 0.01158498f, -0.07030877f, -0.01697552f, 
    -0.01904402f, -0.10913439f, 0.09677067f, 0.00024245f, 0.04831981f, 0.07637816f, -0.02989034f, 0.02728767f, 
    -0.09347775f, -0.10327015f, -0.09783079f, -0.05639967f, 0.21003841f, -0.02161179f, 0.25595534f, -0.12491435f, 
    -0.01606987f, 0.23651507f, -0.01826882f, -0.04154027f, -0.10232169f, 0.00736287f, -0.03044693f, -0.03669661f, 
    -0.09672523f, 0.01514110f, 0.08621725f, -0.02625201f, -0.14251783f, 0.05391385f, 0.05762726f, -0.05386332f, 
    0.17309448f, 0.14379637f, 0.35368437f, -0.06685586f, 0.00873812f, 0.07014522f, 0.07555939f, -0.05252435f, 
    -0.00820548f, -0.04693108f, 0.06669839f, 0.02669150f, 0.07458030f, 0.00700354f, -0.02830607f, 0.00283440f, 
    -0.03386436f, -0.04132436f, 0.02266247f, 0.06595413f, 0.33568308f, 0.11231922f, -0.31444803f, -0.13624743f, 
    0.20992218f, -0.00239461f, 0.00437731f, 0.04851263f, -0.08021218f, 0.05092678f, -0.02444046f, -0.00092914f, 
    0.05826622f, -0.02503913f, -0.08569487f, 0.04714007f, -0.05370612f, 0.14693528f, 0.03274836f, 0.25667444f, 
    -0.03317254f, 0.18031882f, 0.11344235f, -0.23550163f, -0.00833937f, 0.02201790f, 0.12070405f, -0.13385470f, 
    0.05522878f, 0.08279918f, 0.17887700f, 0.11006924f, 0.05940434f, -0.07148133f, -0.08698735f, 0.01220738f, 
    0.02738249f, -0.01902271f, 0.06684011f, 0.06844363f, -0.04611930f, -0.09078888f, 0.08348853f, 0.01160000f, 
    -0.04812589f, -0.04589557f, -0.08101226f, -0.01463328f, -0.03470785f, 0.03403350f, 0.07429679f, 0.07766491f, 
    0.03511469f, 0.02931073f, -0.04488819f, -0.03416058f, -0.02222957f, -0.00922888f, -0.06917412f, -0.05993911f, 
    0.34715143f, 0.18512829f, 0.08360197f, 0.05024720f, 0.05612594f, -0.00040081f, -0.07608349f, -0.06766608f, 
    -0.09482265f, -0.09653286f, -0.01746506f, -0.06211190f, -0.02517277f, 0.05103777f, -0.13052195f, 0.04023971f, 
    -0.16576779f, 0.04934662f, -0.15757537f, -0.05001916f, -0.41917026f, -0.31454530f, 0.18300015f, 0.52570957f, 
    0.10459454f, -0.00889753f, 0.00451484f, -0.05338061f, 0.08343993f, -0.20032482f, -0.02548655f, 0.03670878f, 
    0.08939134f, -0.04676130f, -0.05110575f, -0.07368410f, -0.03946862f, 0.12114490f, -0.05717071f, -0.13296464f, 
    0.40576419f, -0.07971900f, -0.00362435f, -0.11720628f, 0.23234090f, 0.04788298f, 0.07038283f, 0.06222631f, 
    0.03193701f, 0.04116100f, -0.00743572f, 0.01735605f, 0.05465721f, 0.01842671f, -0.06118154f, 0.04550311f, 
    -0.00759056f, 0.00385935f, -0.02122962f, 0.08944935f, 0.19284342f, 0.17762302f, 0.04372157f, -0.11884870f, 
    0.08242720f, 0.03897735f, 0.10830919f, -0.02389857f, -0.02379652f, -0.08166687f, 0.00147540f, 0.04649564f, 
    0.01892622f, -0.05492773f, 0.01671886f, 0.15123598f, 0.07852091f, 0.09557353f, 0.10093863f, -0.01964985f, 
    -0.34526154f, -0.11028150f, 0.11644830f, 0.33449852f, 0.08554488f, 0.08798533f, -0.05746143f, -0.08877368f, 
    0.01779667f, 0.19448827f, 0.00568165f, 0.00385362f, -0.06366916f, -0.01594140f, 0.04444052f, -0.07828850f, 
    -0.09157158f, -0.11254355f, 0.04532345f, -0.12808047f, -0.15273729f, -0.05858595f, -0.12262798f, 0.15603322f, 
    0.01183642f, 0.08160869f, 0.09752091f, 0.03733444f, 0.04189725f, 0.04428434f, 0.03956378f, 0.03654756f, 
    0.03587516f, 0.08821432f, 0.05864487f, 0.00128782f, 0.07203627f, 0.20989937f, -0.04517182f, 0.10190313f, 
    0.61770469f, -0.13580854f, -0.34364367f, -0.00640786f, -0.02042741f, -0.04809194f, 0.09256800f, 0.02656293f, 
    -0.01538279f, 0.02440964f, 0.03547359f, -0.01616094f, -0.03792422f, -0.06051750f, -0.04347911f, -0.11534964f, 
    0.03723178f, 0.05261191f, -0.01038743f, 0.17830160f, -0.16274995f, -0.11084741f, 0.14368010f, 0.44545797f, 
    0.10318208f, -0.04968097f, -0.03126839f, 0.06266950f, -0.08805867f, 0.02774404f, 0.01447553f, 0.04858606f, 
    -0.02099694f, -0.06412052f, 0.05385865f, 0.01415861f, 0.06501009f, 0.01697637f, -0.10897914f, -0.07349337f, 
    0.09142381f, 0.00792973f, 0.11714096f, -0.11458460f, -0.08249958f, -0.07146224f, -0.10110006f, -0.09827132f, 
    -0.27042344f, 0.03074827f, -0.03116923f, -0.08040659f, -0.00013026f, -0.00165387f, -0.01245091f, -0.00855824f, 
    -0.00042079f, -0.05184153f, -0.06606952f, -0.08571905f, -0.15243042f, -0.10533595f, 0.07211956f, 0.17801644f, 
    -0.00646959f, 0.07392033f, -0.13782759f, -0.17350854f, 0.02556204f, -0.00519816f, 0.05474597f, -0.03154038f, 
    -0.01209172f, 0.06070178f, 0.07819317f, -0.03928492f, 0.09569261f, 0.13517965f, 0.15189338f, 0.15687917f, 
    0.02718895f, 0.04113883f, 0.03498910f, -0.02276498f, 0.01266427f, 0.01633320f, -0.02291782f, 0.03807725f, 
    -0.02814863f, 0.03600876f, -0.01604727f, 0.01026612f, -0.03827438f, -0.04895495f, -0.06032833f, -0.01166551f, 
    -0.05860864f, -0.02501794f, 0.04251847f, 0.01889217f, 0.05208531f, -0.03727511f, -0.05222794f, -0.06293096f, 
    -0.04073225f, -0.05078495f, 0.02782521f, 0.05435298f, -0.05710509f, 0.05427428f, -0.05406222f, -0.05124644f, 
    0.01370662f, 0.00179136f, -0.00780460f, 0.03182207f, -0.05938104f, 0.00226632f, 0.01000436f, 0.00164711f, 
    0.04563836f, 0.04616313f, 0.00885706f, 0.00539672f, 0.02530709f, 0.03114682f, 0.04028750f, 0.01640574f, 
    -0.05779200f, -0.01944513f, 0.04821361f, 0.03265500f, -0.00822759f, 0.00674355f, -0.02178923f, -0.02407688f, 
    0.03362579f, 0.00636929f, 0.01289201f, -0.02335940f, -0.03223916f, -0.03384234f, 0.03812109f, -0.04868580f, 
    0.03746570f, -0.00230112f, -0.05351842f, 0.02266372f, -0.00082697f, 0.02670237f, 0.00882088f, 0.01821759f, 
    -0.02841167f, -0.05272786f, -0.03708089f, -0.06094131f, 0.02007097f, 0.02648052f, -0.06161690f, 0.03462138f, 
    0.01721272f, -0.03735964f, -0.05039962f, 0.04079368f, -0.00871296f, -0.03960473f, 0.02781299f, -0.05496233f, 
    0.01824139f, 0.02158501f, 0.04467896f, 0.02395265f, -0.04956189f, -0.05065205f, -0.01123353f, -0.05894707f, 
    -0.03638136f, 0.03250906f, 0.04248089f, 0.03437590f, 0.01606251f, -0.04305853f, -0.03076058f, -0.05061975f, 
    -0.04272936f, 0.04049472f, -0.00288396f, -0.01824816f, 0.03675610f, 0.02388812f, -0.03369493f, -0.01249311f, 
    0.04768413f, -0.01633489f, 0.02375512f, 0.02667365f, -0.04632638f, 0.04047507f, 0.01612728f, 0.04610104f, 
    0.01559077f, -0.03759343f, 0.01773481f, 0.03724368f, 0.01328977f, 0.03285773f, 0.02387687f, 0.01415032f, 
    -0.04998863f, 0.01291813f, -0.00495892f, -0.05908361f, -0.04477026f, 0.01887515f, 0.02199712f, -0.04280794f, 
    0.04272253f, 0.03694635f, -0.03507788f, -0.04141455f, 0.02251350f, 0.03467095f, 0.04697766f, 0.01028205f, 
    0.00605113f, -0.03130903f, -0.05658177f, -0.02579525f, -0.03656395f, -0.01573339f, 0.00024837f, -0.01688850f, 
    0.01762591f, 0.01940189f, -0.05046925f, -0.04568322f, -0.02654552f, 0.05284900f, 0.03029425f, -0.05961895f, 
    0.03825600f, -0.00796442f, -0.03691933f, -0.01312845f, 0.03780630f, 0.01219010f, -0.02224493f, -0.05316320f, 
    -0.01362167f, -0.01722412f, -0.05897009f, -0.02374247f, -0.02646365f, 0.00086686f, 0.00041468f, -0.04716580f, 
    -0.04260810f, -0.05500296f, -0.03974343f, 0.01915991f, -0.01235901f, 0.05296807f, 0.05078389f, -0.01280135f, 
    0.02407663f, 0.05066278f, 0.00079469f, -0.05334672f, -0.02721713f, 0.02907675f, -0.04758752f, -0.00514625f, 
    0.01163449f, -0.00894211f, -0.03804269f, -0.02811932f, 0.04749629f, 0.01116284f, 0.00909388f, -0.02251860f, 
    -0.05880698f, 0.03619091f, -0.05053221f, -0.01173721f, -0.05925396f, 0.00791755f, 0.04727337f, 0.03445558f, 
    -0.04177501f, -0.05045564f, -0.00692702f, 0.01823085f, -0.05254754f, -0.00749872f, -0.02382011f, 0.03423045f, 
    -0.04657473f, 0.02635924f, -0.01275383f, -0.04623457f, -0.00899833f, 0.01771014f, -0.01998070f, 0.04594136f, 
    -0.00131976f, 0.01936494f, 0.04302521f, 0.00060578f, -0.04785332f, 0.03941655f, -0.03900431f, -0.01126804f, 
    0.02570251f, -0.05152927f, -0.04840754f, -0.03887365f, 0.04439748f, 0.00415373f, 0.00483903f, 0.03874300f, 
    -0.02418129f, -0.04027956f, -0.02897712f, -0.02987896f, 0.01466076f, -0.01512840f, 0.00566501f, 0.02210139f, 
    0.05200700f, -0.04346332f, -0.01785535f, -0.03510463f, -0.03638412f, -0.02117732f, -0.01957264f, -0.05116723f, 
    0.00477038f, -0.01841468f, -0.05138149f, 0.00690959f, -0.05707571f, 0.03355873f, -0.01449004f, 0.00122321f, 
    -0.04799950f, -0.01991470f, -0.03929945f, 0.04042553f, -0.04964049f, 0.02272518f, -0.03779610f, -0.03638048f, 
    -0.01270668f, -0.03042311f, -0.04728725f, -0.05684946f, 0.04497923f, 0.01847173f, -0.01302220f, 0.02029916f, 
    0.01332476f, -0.06020645f, 0.01320832f, -0.01150111f, -0.04069682f, 0.04731165f, -0.03662548f, -0.05675582f, 
    -0.02940535f, -0.05706855f, -0.02046809f, -0.02745116f, 0.02323721f, 0.01379717f, -0.02540582f, -0.01712873f, 
    0.01097594f, -0.01742063f, 0.03188145f, -0.04269706f, 0.03535334f, -0.02706962f, -0.04929134f, -0.06117923f, 
    0.01457701f, -0.01344750f, -0.06101882f, -0.02729438f, -0.04877646f, -0.02336349f, 0.01300167f, -0.04342085f, 
    -0.04448777f, -0.01852949f, 0.02837204f, 0.02376083f, -0.04899500f, 0.04040310f, -0.00149538f, 0.00393572f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02602626f, 0.11352313f, 0.09048000f, 0.03622468f, 0.07955989f, -0.03501201f, 0.03650014f, 0.04149356f, 
    -0.04172896f, -0.06589830f, 0.02321704f, 0.04025855f, -0.05131939f, 0.08652682f, 0.10750632f, 0.08405500f, 
    -0.00218331f, 0.20587027f, 0.20143355f, -0.04492958f, 0.05955242f, 0.02011737f, 0.13218027f, 0.00178055f, 
    -0.05184378f, 0.10710942f, 0.16535185f, 0.04039280f, 0.08061177f, -0.00286135f, 0.00949794f, 0.04127516f, 
    -0.02225121f, -0.03346006f, 0.00456632f, 0.00217326f, 0.01031830f, 0.03493056f, -0.08267528f, -0.03523625f, 
    -0.04352831f, 0.16140267f, 0.07510971f, -0.02434675f, -0.15484294f, -0.04995126f, 0.04576037f, 0.08669635f, 
    0.03173972f, -0.08754225f, -0.04256009f, 0.05723314f, 0.01265503f, -0.04022614f, 0.02720183f, -0.04458349f, 
    0.15917701f, 0.01998426f, 0.14683014f, 0.18334363f, 0.12973304f, 0.00015841f, 0.12705785f, 0.03168425f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.02814929f, -0.39289650f, 0.01978330f, -0.26085690f, -0.03946842f, 0.22605726f, -0.15914974f, 0.32121474f, 
    -0.00151220f, -0.11623333f, 0.11526159f, 0.05182207f, -0.06567635f, -0.29356655f, -0.46810889f, -0.26120821f, 
    0.09335427f, -0.31882370f, -0.21671110f, -0.09436201f, -0.36686644f, -0.13206741f, 0.15739620f, 0.01747674f, 
    0.10658985f, -0.37046435f, -0.28030917f, 0.08281638f, 0.17304531f, -0.10106277f, -0.00230821f, 0.21211104f, 
    0.15540902f, 0.25896433f, 0.04026572f, 0.15520513f, -0.32883421f, -0.10772260f, 0.13054323f, 0.10300104f, 
    0.24298711f, -0.66709024f, -0.32479739f, 0.01174536f, 0.35030541f, 0.15441506f, -0.19276148f, -0.02562023f, 
    0.02162844f, 0.28690314f, -0.06198416f, 0.16863430f, -0.02698246f, -0.02740869f, 0.00053578f, 0.11248504f, 
    -0.41838416f, 0.28922224f, -0.11670963f, -0.36592481f, -0.04408529f, 0.01318341f, -0.59065521f, 0.06258008f, 
    0.20447475f, -0.27175987f, 0.02702512f, -0.24944454f, 0.08871782f, 0.41009003f, -0.19987033f, 0.01502755f, 
    0.04763367f, -0.62638962f, -0.00318907f, 0.14043885f, 0.02019174f, 0.14276473f, 0.02157748f, -0.32810429f, 
    -0.19486900f, 0.11750481f, 0.02676312f, 0.06358856f, 0.06976812f, 0.11877998f, 0.25668597f, -0.10673902f, 
    -0.01354084f, 0.08915752f, -0.14612922f, 0.00147541f, 0.23024072f, -0.05292486f, -0.10060490f, -0.71340680f, 
    0.10337114f, 0.10164395f, 0.10428096f, 0.14333351f, -0.01240834f, -0.01792506f, -0.39391312f, -0.16108347f, 
    0.06472214f, 0.05177780f, -0.25760379f, 0.05058980f, -0.42124832f, 0.08172415f, 0.12634188f, 0.16524708f, 
    -0.13961580f, -0.65849727f, -0.32317284f, 0.24079530f, -0.03241866f, -0.06509118f, -0.05281847f, -0.01400897f, 
    0.11271325f, 0.16677655f, 0.18691704f, 0.45186490f, -0.02145416f, 0.25442851f, 0.13986996f, 0.09833263f, 
    0.09690099f, 0.31699297f, 0.02335357f, -0.29671675f, -0.26326686f, -0.27648687f, 0.02306017f, -0.37252435f, 
    -0.07160576f, -0.04458902f, 0.09302332f, 0.04723667f, 0.00376400f, -0.31002873f, 0.14865337f, 0.13937537f, 
    0.00611576f, 0.13247214f, 0.14069632f, 0.08788987f, -0.12401032f, -0.04661446f, 0.16854423f, -0.07203516f, 
    0.04326122f, -0.20731281f, 0.17364460f, 0.14926736f, -0.15352499f, -0.00690769f, 0.04225408f, 0.33806872f, 
    0.13268472f, -0.23932128f, 0.06360765f, -0.34895837f, 0.15233621f, 0.05527290f, 0.00148957f, 0.21412630f, 
    -0.60361737f, -0.15229167f, -0.02454020f, -0.12156941f, -0.61813265f, -0.08862625f, -0.01459412f, -0.03427320f, 
    -0.26803622f, -0.73966271f, -0.58283383f, 0.02189057f, -0.01470544f, -0.05164784f, -0.08536252f, -0.09869029f, 
    -0.09068097f, 0.24159627f, -0.24503091f, 0.26679701f, 0.16877621f, 0.52180934f, -0.04624313f, -0.09006829f, 
    -0.07762062f, -0.36011449f, -0.25331894f, 0.37158605f, -0.06404779f, 0.12128389f, 0.35812327f, -0.32062137f, 
    0.06051068f, 0.14869359f, 0.08494397f, 0.10624021f, 0.00946493f, -0.47914508f, -0.00680840f, -0.03326555f, 
    -0.04450035f, -0.11184124f, -0.10302122f, -0.02842325f, -0.26096386f, 0.05547680f, 0.04040206f, -0.08024068f, 
    -0.05462395f, -0.17003714f, -0.34711662f, 0.06192581f, -0.14517261f, -0.06294295f, 0.00435028f, 0.24643992f, 
    -0.07906079f, -0.20669313f, 0.07812414f, -0.06646591f, 0.29373798f, -0.02453852f, 0.16059223f, 0.14511526f, 
    -0.06447712f, -0.02787636f, 0.21105227f, 0.00997588f, 0.16348565f, 0.15182543f, 0.13176894f, 0.17438990f, 
    -0.43851945f, 0.14272061f, 0.03175849f, -0.09041531f, -0.00839320f, 0.09423770f, -0.09264772f, 0.11083033f, 
    -0.42162746f, -0.24055886f, -0.62665689f, 0.31532219f, -0.41819939f, 0.25852633f, -0.06061677f, 0.00715744f, 
    -0.31306696f, -0.08550680f, 0.05912161f, -0.17199227f, 0.05385377f, 0.19022076f, -0.14451919f, -0.27359813f, 
    -0.01922993f, 0.16437191f, 0.10805580f, -0.30510429f, 0.09054533f, 0.07963680f, -0.03425660f, 0.12023065f, 
    0.28697440f, -0.13754342f, -0.02517620f, 0.08592474f, 0.15007181f, -0.11808443f, -0.09667680f, 0.02589519f, 
    0.02189027f, -0.09005921f, -0.17443909f, -0.33043849f, -0.28454164f, 0.08850972f, 0.07836255f, -0.07428610f, 
    0.06435484f, 0.08103697f, 0.07159699f, 0.08198952f, 0.03401250f, 0.04366783f, 0.03731918f, -0.06459439f, 
    -0.28914541f, 0.30020759f, -0.12479644f, 0.02630395f, 0.33695987f, -0.07489452f, -0.04782958f, -0.33371210f, 
    0.26820907f, 0.18755244f, 0.15653394f, 0.16552809f, 0.11221022f, 0.10524610f, -0.06282783f, -0.01026580f, 
    0.03002729f, 0.16677484f, 0.11971149f, -0.66681343f, 0.11110326f, 0.09835222f, 0.11979375f, 0.04651278f, 
    0.18454932f, -0.11494857f, -0.15720604f, 0.16461816f, -0.02555753f, -0.22021750f, -0.26635879f, 0.19052054f, 
    0.02950052f, -0.09373114f, -0.04070258f, -0.01953821f, 0.02385795f, 0.31700674f, 0.20274696f, 0.18555897f, 
    -0.08172881f, -0.30557683f, -0.34001008f, -0.11472053f, -0.20181569f, -0.11350819f, 0.00943558f, -0.03009856f, 
    -0.01488348f, -0.10272284f, 0.15022266f, -0.21977827f, -0.02130107f, -0.10501362f, -0.03585793f, -0.08613988f, 
    -0.29531395f, -0.03080567f, 0.19963995f, 0.20428476f, 0.01396026f, -0.06816675f, -0.12774235f, 0.05957114f, 
    0.38143617f, -0.25849980f, 0.14965321f, -0.11154781f, -0.62959331f, 0.13806644f, 0.14976895f, 0.00883023f, 
    0.05126348f, -0.03317510f, 0.26350918f, -0.26098964f, 0.02505926f, 0.09168003f, 0.02387966f, 0.02173561f, 
    0.34336272f, 0.15709388f, 0.19247267f, -0.69627786f, 0.17860401f, -0.09250032f, 0.04517309f, -0.08198024f, 
    0.03661156f, 0.14267589f, 0.28933212f, 0.36614192f, -0.29995668f, -0.52900732f, 0.14696611f, -0.38897127f, 
    0.05562676f, -0.43338123f, 0.00093756f, -0.03504205f, -0.12095530f, -0.05177352f, 0.35112777f, 0.26875493f, 
    0.27211520f, 0.07602535f, -0.09215210f, 0.05259791f, 0.11478844f, 0.01048068f, -0.74670196f, -0.02186663f, 
    -0.04609090f, -0.08388735f, 0.35267591f, 0.04041230f, 0.11974008f, 0.04717337f, 0.07423674f, 0.24367484f, 
    -0.15594710f, 0.08565061f, 0.20414567f, -0.23054197f, -0.30680481f, 0.09707855f, -0.24066290f, -0.28240344f, 
    -0.06472615f, -0.32209370f, 0.26618391f, 0.01340555f, 0.13225952f, -0.42478949f, -0.50173312f, -0.39183536f, 
    0.08789313f, -0.31428543f, -0.47570732f, 0.07244998f, 0.06692815f, 0.09447949f, -0.02362582f, -0.10688403f, 
    0.05466795f, -0.76826501f, 0.11743210f, 0.31525669f, 0.08232649f, -0.26866400f, 0.12402102f, -0.07716779f, 
    0.12821178f, 0.13205358f, -0.12748374f, -0.23073937f, 0.10975103f, -0.30764818f, -0.19286276f, -0.26600829f, 
    -0.05778883f, 0.30450609f, -0.10931958f, 0.14619987f, 0.02848226f, -0.29199719f, -0.49208596f, 0.06112012f, 
    -0.45903778f, -0.18995368f, -0.05172131f, 0.06054261f, 0.08450048f, 0.00366999f, -0.23659967f, -0.01186876f, 
    -0.01289710f, 0.13198447f, -0.17002080f, 0.19358836f, -0.20088366f, -0.04382165f, -0.04836669f, -0.17386113f, 
    -0.23578432f, 0.15737343f, 0.18714277f, 0.25496954f, 0.23050874f, -0.06848186f, 0.23815155f, -0.12740633f, 
    -0.33964840f, -0.28530753f, 0.15999405f, 0.02501026f, 0.52157086f, -0.30161476f, -0.15593991f, 0.15449783f, 
    0.20231111f, -0.16718937f, -0.10269170f, -0.05808780f, -0.11086034f, -0.00660270f, -0.03598434f, -0.05869348f, 
    0.08643257f, 0.43536410f, -0.12422234f, 0.01744072f, -0.37688115f, -0.59732682f, 0.07104301f, 0.09218880f, 
    0.14036812f, -0.15069848f, -0.10133690f, -0.03629755f, 0.20090625f, -0.25181070f, 0.30801186f, 0.52703828f, 
    -0.04789315f, -0.59425795f, 0.09218772f, 0.08167432f, 0.10350676f, 0.18245828f, -0.30564579f, 0.11740984f, 
    -0.50064862f, -0.14058696f, 0.05174576f, -0.11067200f, -0.19717726f, 0.08781824f, -0.28324094f, -0.08428996f, 
    0.10203237f, 0.08575379f, -0.19390991f, 0.29767326f, 0.06504310f, 0.04073162f, 0.05040417f, -0.49850422f, 
    -0.41305327f, 0.12717913f, -0.33506796f, -0.21215719f, 0.21737804f, 0.05270526f, 0.31252050f, 0.06338413f, 
    -0.48551378f, -0.08333612f, 0.22008248f, 0.10719448f, -0.32991517f, -0.11248931f, 0.19582945f, 0.33463073f, 
    -0.14186573f, -0.42783350f, -0.27913335f, 0.24755453f, -0.06184009f, -0.07480676f, 0.03208337f, -0.01688348f, 
    0.01214999f, -0.24600892f, -0.03844318f, -0.18669224f, 0.19392605f, -0.84579438f, -0.35964024f, -0.01170498f, 
    -0.33281177f, 0.29056758f, 0.05980793f, 0.18250175f, -0.47224960f, 0.32733512f, -0.18549062f, -0.25406668f, 
    -0.10647949f, 0.29785040f, -0.01791599f, -0.04525876f, -0.08305037f, -0.06667265f, -0.41705582f, 0.03789108f, 
    0.20964453f, 0.30161870f, 0.13283844f, -0.05372222f, 0.25194284f, -0.01610728f, 0.20738856f, -0.07815013f, 
    -0.05007521f, 0.06921741f, 0.12850095f, 0.07710534f, -0.44020584f, -0.09000944f, -0.02272365f, 0.22049581f, 
    0.06099918f, 0.24779397f, -0.11562268f, 0.36334848f, -0.29377440f, -0.09894188f, -0.62603408f, -0.21770221f, 
    -0.22158173f, -0.06300703f, -0.10931218f, -0.03782201f, -0.41140199f, -0.46496621f, 0.14364688f, -0.52434134f, 
    -0.06597054f, 0.18955411f, 0.24352871f, 0.14197785f, -0.05655586f, 0.04064555f, -0.05352558f, -0.06777346f, 
    0.25854793f, -0.06444434f, 0.18970186f, -0.09887177f, 0.21469538f, -0.58647454f, 0.11426831f, 0.01410830f, 
    0.14535947f, -0.39570689f, 0.23465839f, 0.14224975f, 0.16202189f, -0.52096057f, 0.27514711f, 0.31144884f, 
    0.00845729f, 0.18455333f, -0.07328756f, -0.52469134f, -0.00580768f, 0.02865010f, 0.27405465f, -0.08540128f, 
    0.06975225f, 0.32898453f, 0.05074808f, -0.08430974f, 0.13061804f, -0.03082810f, -0.26892880f, 0.07225777f, 
    -0.08595109f, 0.22218314f, -0.31889063f, 0.01438760f, 0.16764495f, -0.09232061f, -0.00434989f, -0.57492918f, 
    -0.03480478f, -0.55651695f, 0.06667599f, -0.05196159f, -0.07949060f, 0.02501423f, 0.27759153f, -0.10254394f, 
    0.32449603f, 0.12743303f, 0.10844179f, -0.07806182f, -0.37119299f, -0.32283589f, -0.23801069f, 0.12600011f, 
    -0.59159732f, -0.34853640f, 0.06629487f, -0.40379113f, -0.06892725f, -0.06264527f, -0.06296336f, -0.02074957f, 
    -0.02631226f, -0.46913138f, 0.27683064f, -0.33233255f, -0.07557747f, 0.33984241f, -0.31944981f, 0.10862086f, 
    -0.13282026f, 0.15513141f, 0.16618063f, 0.31007895f, 0.26112726f, -0.36131653f, 0.07667073f, -0.14995594f, 
    0.10412857f, -0.31393409f, -0.02164070f, 0.27603853f, 0.03519556f, 0.21225022f, 0.32496706f, -0.08073964f, 
    -0.50166410f, 0.02610573f, 0.13023277f, -0.09389833f, 0.06439947f, -0.01818545f, -0.28988263f, -0.00701434f, 
    -0.01281654f, 0.16379242f, 0.19685204f, 0.01417388f, -0.01159034f, 0.07755750f, -0.09421763f, -0.30725017f, 
    0.02903569f, 0.04887727f, -0.57076979f, -0.50436854f, -0.43411493f, 0.04289747f, 0.02171414f, -0.16187488f, 
    -0.19868344f, -0.11894099f, 0.00012982f, -0.03071111f, 0.20090139f, 0.45494571f, 0.08835093f, -0.09021457f, 
    0.30757254f, -0.00502490f, 0.47494194f, -0.20393531f, 0.09336967f, 0.11474952f, 0.09049041f, -0.11142091f, 
    -0.34662849f, -0.49756482f, -0.26583511f, 0.21876778f, -0.35291800f, -0.05295097f, 0.06167442f, -0.10658220f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.14718167f, 0.02004659f, -0.05225134f, -0.00806920f, -0.01794372f, 0.06591161f, 0.05346538f, -0.14377843f, 
    0.07028794f, -0.04797043f, -0.05037115f, -0.13056864f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
