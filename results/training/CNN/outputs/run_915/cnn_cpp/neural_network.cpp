#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.23792598f, -0.27926195f, -0.31624681f, -0.42027548f, -0.44800785f, -0.05878604f, -0.26629034f, 0.51525998f, 
    -0.19618106f, 0.65098447f, 0.44345558f, 0.83537877f, -0.40366837f, -0.10271937f, -0.16236581f, -0.04467726f, 
    -0.09722762f, 0.02732776f, 0.56752479f, 0.35096201f, 0.30326465f, -0.05362077f, 0.41007772f, -0.37068325f, 
    0.34299254f, 0.12589777f, -0.03483706f, 0.35240036f, 0.14534345f, -0.10317708f, 0.30605057f, 0.21552624f, 
    0.23097205f, -0.43354431f, -0.43778402f, 0.40438837f, 0.50340295f, 0.16926527f, -0.20290467f, 0.44986299f, 
    0.41325349f, 0.10947820f, 0.17648268f, 0.10223164f, -0.49682620f, 0.28453520f, 0.18942325f, 0.38384581f, 
    -0.19007595f, 0.17677674f, 0.47345781f, -0.19257870f, 0.30849504f, 0.50050253f, -0.46035799f, -0.41772106f, 
    0.24703145f, -0.26072565f, 0.22114180f, -0.36166427f, -0.10992791f, -0.01340656f, -0.24012680f, -0.12929866f, 
    -0.01401403f, -0.28885332f, 0.31121212f, 0.37839344f, 0.10524109f, -0.08834778f, 0.50702810f, 0.18282287f, 
    -0.40992257f, 0.45139018f, -0.34699032f, -0.22982140f, 0.66370785f, -0.40646556f, 0.10467966f, -0.05391036f, 
    -0.23403700f, 0.56768155f, 0.43485662f, -0.21135166f, -0.39273235f, 0.32968390f, -0.34839293f, 0.17900565f, 
    0.23784062f, 0.33617800f, -0.13027610f, -0.48757830f, -0.28446880f, 0.55073690f, 0.42189866f, 0.34072417f, 
    -0.31042260f, -0.09747943f, -0.20123820f, -0.23270129f, 0.41316092f, -0.10500038f, 0.25818893f, 0.38033995f, 
    0.15233299f, -0.12199654f, -0.34386560f, -0.40475994f, 0.47832584f, -0.76559061f, -0.61029845f, -0.45898843f, 
    0.05910850f, 0.24384031f, -0.24335313f, 0.11019631f, -0.05058065f, 0.15219730f, 0.69928533f, 0.18109947f, 
    0.37680656f, 0.44442317f, -0.02344853f, -0.12712047f, 0.02309209f, 0.06562904f, 0.69988495f, -0.35354909f, 
    -0.36576536f, -0.17507344f, 0.17385294f, 0.02857592f, -0.36793578f, -0.09616712f, 0.44840753f, -0.40453762f, 
    -0.37123728f, -0.17530151f, 0.38469315f, 0.73843396f, -0.13196196f, 0.27852282f, -0.26412216f, 0.11014771f, 
    0.58652073f, 0.10466676f, 0.24156730f, 0.39103758f, -0.57377720f, 0.25899565f, -0.01450415f, 0.37623218f, 
    -0.48167917f, 0.13968088f, -0.81260842f, -0.07946272f, -0.24578592f, -0.63145906f, -0.43709227f, 0.17585976f, 
    0.30347955f, 0.42692176f, -0.69699907f, -0.45498064f, -0.60061324f, 0.30110949f, 0.39729485f, 0.47835127f, 
    0.00483605f, 0.04450759f, -0.29439646f, 0.38540235f, -0.70636141f, 0.61757940f, -0.25170675f, -0.30335411f, 
    0.47530141f, -0.04744622f, -0.08138175f, 0.06883345f, -0.60263956f, 0.25719038f, -0.34179366f, 0.06157756f, 
    -0.47073498f, -0.11757310f, -0.30864847f, 0.17781442f, -0.26698846f, -0.65860832f, 0.25346982f, 0.44496095f, 
    0.57327646f, 0.46614414f, -0.25307986f, 0.15677530f, 0.22920744f, 0.01535960f, -0.28776693f, -0.64156222f, 
    -0.04940175f, 0.49311510f, -0.57031047f, 0.44157454f, 0.20105878f, -0.27034461f, -0.06626713f, 0.40940580f, 
    0.45844689f, 0.25572902f, -0.19633965f, -0.72667599f, -0.12657721f, 0.27428904f, 0.29470491f, 0.17736666f, 
    -0.28827664f, -0.40236956f, 0.13810757f, -0.05225958f, 0.17046352f, -0.31705317f, -0.20020063f, -0.19068936f, 
    -0.51612490f, 0.30085766f, -0.14095870f, 0.54434031f, 0.59534800f, 0.27212584f, 0.29328465f, 0.38283375f, 
    -0.36262590f, 0.20198406f, 0.16650318f, 0.40965688f, -0.50178826f, 0.00307997f, -0.01123970f, 0.43755394f, 
    -0.19066575f, 0.44082290f, -0.36180052f, 0.52140129f, -0.28998971f, -0.44574603f, 0.18213743f, -0.28412679f, 
    -0.31298468f, 0.38881275f, 0.10254033f, -0.16921386f, -0.18231849f, 0.41280818f, -0.00599934f, -0.22982259f, 
    -0.15979688f, -0.81982762f, -0.19154112f, -0.29717571f, 0.39486441f, 0.48726672f, 0.29999489f, 0.39089277f, 
    0.01174676f, 0.06567533f, -0.08099641f, -0.08641572f, -0.06381337f, 0.13622953f, -0.15331693f, 0.37210193f, 
    0.26854050f, -0.53903633f, 0.31470540f, -0.45855528f, 0.10705411f, 0.17490597f, -0.55493695f, 0.42853442f, 
    -0.22884662f, 0.22797666f, -0.36107683f, 0.30545422f, 0.34445438f, -0.28695947f, -0.43122360f, -0.53848273f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.03229203f, -0.31427604f, -0.16762628f, 0.09935337f, 0.00396201f, -0.21913953f, 0.03531004f, -0.19442300f, 
    -0.26630688f, 0.00204399f, 0.05060057f, 0.07799654f, 0.09972090f, -0.37329948f, -0.34984159f, -0.31086355f, 
    -0.09376769f, -0.26079264f, 0.04026668f, 0.18466334f, -0.11790554f, -0.00278105f, -0.12463111f, -0.07224657f, 
    0.02740191f, 0.10134913f, 0.02842239f, 0.03673774f, 0.02605291f, 0.30394393f, -0.24694341f, -0.18489209f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.35589567f, -0.05856852f, -0.15844339f, 0.12127010f, -0.11234289f, 0.09804434f, 0.03972740f, -0.03379755f, 
    0.08231876f, 0.22764035f, 0.19956802f, -0.13687260f, -0.21161626f, -0.00883772f, 0.03114052f, 0.02516213f, 
    -0.08083585f, -0.02465810f, 0.04410612f, 0.12847677f, -0.26961958f, -0.20353946f, -0.13422866f, -0.03884469f, 
    0.16074163f, 0.07741369f, 0.10393821f, 0.08293806f, 0.06695233f, -0.09617899f, -0.13465828f, 0.12608743f, 
    -0.16156171f, 0.10010031f, 0.17451429f, -0.00059312f, 0.14880593f, -0.07207246f, -0.15778705f, -0.12338509f, 
    -0.01115310f, 0.08753912f, 0.07705667f, -0.01602539f, 0.07861622f, -0.02665633f, 0.05422668f, -0.21387133f, 
    0.08133487f, 0.01129486f, -0.10435122f, 0.14952807f, 0.12998714f, 0.03396622f, -0.26200742f, 0.04982809f, 
    0.04138928f, 0.02517936f, 0.14715488f, -0.01178838f, 0.02664122f, 0.00614302f, 0.11319117f, 0.09960838f, 
    0.03569762f, -0.21382834f, -0.03051134f, -0.12356414f, 0.01044239f, 0.03710904f, -0.03743906f, 0.08103337f, 
    0.23839894f, -0.16830097f, -0.03663331f, 0.00662689f, -0.00214821f, 0.04486387f, -0.11497311f, -0.12965125f, 
    -0.05542808f, 0.10101712f, -0.12116668f, 0.13461427f, -0.17646098f, 0.02853607f, -0.07315847f, -0.15565760f, 
    -0.00557245f, 0.12284549f, 0.13214393f, 0.19007590f, -0.14867832f, 0.02306491f, 0.01061434f, 0.09644990f, 
    -0.03327844f, -0.08993191f, -0.01045481f, 0.29858169f, 0.20481190f, 0.17056681f, -0.08711181f, -0.12396662f, 
    -0.07600158f, 0.01010787f, 0.00309493f, -0.02119534f, 0.02445175f, -0.27807727f, -0.05838837f, 0.06845129f, 
    0.01590844f, -0.08458522f, -0.00208567f, -0.03107372f, 0.04391779f, -0.07079798f, 0.03353380f, -0.11815101f, 
    -0.27562582f, 0.00009909f, -0.15941843f, 0.07849922f, -0.00880715f, -0.02028229f, -0.25509092f, -0.45435572f, 
    0.07793648f, -0.16731746f, 0.02715850f, 0.12381607f, -0.11072670f, 0.14192393f, 0.06445891f, 0.10766221f, 
    0.00853827f, 0.12881418f, -0.08940208f, 0.05922545f, -0.00334519f, -0.12707953f, -0.08401773f, -0.20755923f, 
    0.14834565f, 0.13463821f, 0.22777583f, -0.12754738f, -0.05930620f, -0.03944144f, 0.08708491f, 0.11789044f, 
    -0.12556313f, -0.16962172f, -0.54535645f, 0.02435051f, 0.19552658f, 0.16710085f, 0.07372427f, 0.19290464f, 
    0.11386789f, 0.07355136f, 0.24471599f, 0.22857316f, -0.10821301f, -0.03983207f, 0.07524442f, 0.19007576f, 
    0.03095541f, -0.15096727f, -0.00924835f, 0.03945591f, -0.21239099f, -0.05190551f, 0.04958269f, 0.07407555f, 
    -0.10530513f, 0.05881085f, 0.00359898f, 0.19152726f, -0.27178156f, -0.02473924f, -0.08872698f, 0.20553902f, 
    0.02766902f, -0.10857268f, 0.15662235f, 0.01027115f, 0.02141418f, 0.16046976f, -0.21260922f, 0.46564788f, 
    0.02205571f, -0.04823634f, 0.03779555f, -0.03865672f, -0.03373314f, 0.01138313f, 0.06445388f, -0.06635675f, 
    -0.17289938f, 0.08644008f, 0.11091840f, 0.22267005f, -0.00694561f, -0.11747592f, -0.11348452f, -0.02690993f, 
    0.11948548f, 0.06978168f, -0.16931522f, 0.03150199f, -0.10604911f, -0.06632200f, 0.10978888f, 0.03789232f, 
    -0.21133420f, -0.08504359f, -0.02523740f, 0.00458790f, 0.17694880f, 0.01384221f, 0.11085901f, -0.02496747f, 
    0.09745374f, -0.14930481f, 0.05259824f, -0.03481247f, -0.04285218f, 0.17987904f, -0.03303928f, 0.01093547f, 
    0.08607703f, -0.03359935f, 0.10115373f, -0.04243864f, 0.02542236f, -0.11718225f, -0.09347071f, -0.01169052f, 
    -0.00213478f, 0.08571778f, 0.05670689f, 0.17381510f, -0.30164683f, 0.10507472f, 0.01217400f, -0.09821406f, 
    -0.02867272f, 0.01519892f, 0.15527950f, -0.05801874f, -0.15537147f, 0.11133900f, -0.09650989f, 0.04681410f, 
    -0.15281975f, -0.01403548f, 0.09111075f, 0.10559314f, 0.30179378f, 0.19002649f, 0.18723883f, 0.06992184f, 
    -0.12693508f, -0.00677156f, -0.02921574f, 0.14800452f, -0.04769738f, -0.04643749f, -0.28912470f, -0.02484347f, 
    -0.29370987f, 0.02897895f, 0.06028677f, -0.06615193f, -0.06619784f, 0.09468006f, 0.04144338f, 0.06198292f, 
    0.12487693f, -0.06074553f, -0.17613514f, -0.09490423f, -0.13636933f, 0.27166948f, 0.05427268f, 0.12674546f, 
    -0.07829279f, 0.02375657f, -0.00038036f, -0.00424624f, 0.02020750f, 0.00991870f, -0.09129206f, -0.04406895f, 
    -0.06090049f, -0.06783273f, -0.01028644f, 0.00163785f, -0.06417930f, 0.02671387f, 0.02310973f, -0.01870160f, 
    -0.03803500f, -0.01964623f, -0.01046448f, -0.04266798f, 0.06141886f, 0.03600200f, 0.00385134f, -0.01839237f, 
    0.01374175f, -0.05941964f, 0.01789177f, 0.05498840f, -0.06145530f, -0.03879466f, 0.01441485f, -0.05373465f, 
    0.02015244f, -0.07722464f, 0.04096621f, -0.05482615f, 0.00011606f, 0.00136939f, -0.00023688f, -0.08565388f, 
    0.01594799f, -0.06990876f, -0.00378677f, -0.02826254f, 0.06448437f, 0.04966566f, -0.02295912f, -0.01850023f, 
    -0.02258997f, 0.01143998f, 0.03059093f, -0.00046047f, -0.00720242f, 0.02963964f, -0.03935924f, -0.05136020f, 
    0.02573418f, -0.06293130f, 0.00182464f, -0.07097073f, -0.06985847f, -0.06345659f, 0.01664187f, -0.05282601f, 
    0.03280219f, -0.03659581f, 0.00372869f, 0.07202628f, 0.06155862f, -0.01178696f, 0.01061783f, 0.02473838f, 
    0.01540380f, -0.07971399f, -0.06065904f, -0.01673517f, 0.01449875f, 0.01485422f, -0.03733027f, -0.04006858f, 
    -0.00240735f, -0.02413776f, -0.05294613f, -0.03318318f, 0.01329172f, 0.01328977f, -0.02124470f, -0.05529669f, 
    0.03856868f, 0.04088799f, -0.03920984f, -0.05714688f, -0.11684243f, -0.01438623f, 0.03301748f, -0.05271774f, 
    0.00234689f, -0.00736738f, 0.04214011f, 0.02023182f, -0.05375379f, 0.03469694f, -0.07698482f, -0.03192016f, 
    0.02329268f, -0.04588316f, 0.04048301f, -0.04603510f, 0.02184122f, -0.02417465f, -0.05073335f, -0.05115001f, 
    0.00572554f, -0.03310851f, 0.02835748f, -0.05929273f, -0.05309043f, -0.04831085f, -0.04440264f, 0.07451697f, 
    0.01310889f, 0.02347095f, 0.00120107f, -0.05475016f, -0.00317501f, 0.02170713f, 0.03895420f, -0.02657717f, 
    -0.02930136f, 0.02804375f, -0.01585525f, -0.05987872f, -0.06519701f, 0.02277526f, 0.00362194f, -0.02183223f, 
    -0.00974342f, -0.05392624f, -0.01487308f, -0.06035450f, -0.02246340f, -0.07926833f, -0.05076481f, -0.04032157f, 
    0.05830080f, 0.02186381f, -0.04932464f, 0.00488950f, -0.02083518f, -0.02269914f, 0.03043169f, -0.01403729f, 
    -0.05631658f, -0.01338436f, 0.00213442f, 0.01497047f, 0.00756081f, -0.02882036f, 0.06260444f, 0.01001623f, 
    -0.07200387f, -0.07728914f, -0.02819047f, -0.05537901f, -0.08543169f, -0.02892196f, -0.02191929f, -0.02660755f, 
    -0.07437467f, -0.06930953f, -0.00249551f, -0.02861444f, -0.08142211f, 0.01482387f, 0.05414569f, 0.00095602f, 
    -0.01946136f, 0.01784383f, -0.04596071f, 0.04959496f, 0.00163580f, 0.02525436f, -0.06917711f, 0.02859892f, 
    -0.04648513f, -0.06073471f, -0.07348711f, 0.00194520f, 0.02508559f, -0.03209127f, 0.03347658f, 0.01016125f, 
    0.03714534f, -0.02242870f, -0.05550408f, 0.01740385f, 0.03041493f, -0.01745361f, -0.05202549f, -0.05624624f, 
    -0.07428800f, -0.02581897f, -0.04244697f, -0.04250599f, 0.02829502f, -0.03753893f, 0.06412436f, 0.01398733f, 
    -0.00156913f, 0.05754959f, 0.01435834f, -0.03163925f, -0.00325883f, -0.02793277f, -0.08030012f, -0.01026439f, 
    0.00603504f, -0.07142453f, 0.03790933f, -0.03571915f, 0.00822133f, -0.08819987f, 0.00452997f, 0.01535054f, 
    -0.05084991f, -0.04652640f, 0.02879895f, -0.04165182f, -0.03083471f, -0.03583761f, -0.01581892f, 0.00348624f, 
    0.00523683f, 0.02368309f, 0.01699089f, -0.04277984f, -0.02929504f, -0.08298052f, -0.04970147f, -0.03402872f, 
    -0.03033324f, -0.01963302f, -0.02728842f, 0.00280467f, -0.04580820f, -0.04917594f, -0.07874419f, 0.04661265f, 
    -0.07002490f, 0.01898626f, -0.06841431f, -0.08128496f, -0.02633410f, -0.02966373f, -0.04860585f, -0.03233063f, 
    -0.02062676f, 0.05560242f, -0.00443025f, 0.00819183f, 0.03700033f, -0.00614857f, 0.01464665f, -0.00075137f, 
    -0.00985288f, -0.04802355f, -0.03503730f, -0.01419829f, -0.04034719f, 0.04596869f, 0.01586686f, -0.01759366f, 
    0.04291568f, 0.04456902f, -0.05423406f, -0.03527399f, -0.03803470f, -0.05859208f, 0.03559677f, -0.06615048f, 
    0.00806183f, 0.03333364f, -0.01586001f, -0.06149328f, -0.05964382f, -0.00086648f, -0.05325112f, 0.05983996f, 
    -0.05269869f, -0.01585055f, -0.06625499f, -0.04458947f, 0.01459145f, -0.05194408f, -0.05129491f, -0.02273886f, 
    -0.08938024f, -0.02249879f, -0.03000084f, -0.06392004f, -0.03731711f, 0.02336768f, -0.09417623f, -0.01464322f, 
    -0.02642612f, 0.01174574f, 0.00321929f, -0.08636778f, 0.04389665f, -0.06693383f, -0.00902685f, 0.01986285f, 
    -0.03121385f, 0.02954146f, 0.00171767f, -0.04193795f, 0.01190232f, 0.01960433f, -0.01495290f, -0.04750202f, 
    -0.04927327f, -0.09041613f, -0.03322410f, 0.02964257f, 0.01865411f, 0.01172130f, -0.06764850f, -0.06112348f, 
    0.01954939f, -0.04280063f, -0.05918095f, 0.01550937f, -0.06918624f, -0.03303296f, 0.04025259f, -0.06138317f, 
    0.01290580f, -0.01936032f, -0.09279177f, -0.00306054f, 0.01742905f, 0.00332085f, -0.04960832f, -0.03712097f, 
    -0.08999433f, -0.00131183f, -0.08135553f, -0.07621010f, -0.07062599f, 0.01616090f, -0.00785447f, -0.02321990f, 
    -0.03218018f, -0.03138433f, -0.04152900f, -0.03476858f, -0.05539034f, -0.06421202f, -0.03393639f, -0.04742277f, 
    0.00674822f, -0.02070155f, -0.00180100f, -0.01454443f, -0.06585591f, 0.01207757f, -0.03934310f, 0.02491239f, 
    -0.02942335f, 0.01250485f, -0.08467302f, -0.03769972f, -0.01617618f, -0.01308964f, -0.04265552f, -0.02541440f, 
    -0.06508893f, -0.01592126f, -0.09599485f, -0.05478833f, 0.04031397f, -0.06810462f, -0.05766682f, -0.00299092f, 
    -0.07902464f, -0.03676188f, -0.07262244f, 0.00107647f, -0.05522182f, -0.05231057f, -0.01109926f, 0.00077344f, 
    -0.01709366f, -0.04836971f, -0.05201945f, 0.00295491f, -0.09910171f, -0.04735454f, -0.04351830f, 0.01743549f, 
    0.02156105f, 0.02277239f, -0.02907512f, 0.00621596f, -0.01829815f, 0.01083606f, -0.05412477f, -0.05646805f, 
    -0.04282349f, -0.02011107f, 0.02189608f, -0.06256109f, -0.05497423f, -0.02555510f, -0.04495350f, 0.00417052f, 
    -0.02511478f, -0.08266067f, 0.01775311f, -0.04138487f, -0.06887475f, -0.02273390f, -0.01919658f, -0.06107885f, 
    -0.04368627f, -0.03912436f, -0.03242229f, -0.07145941f, -0.04447332f, -0.01543504f, 0.02250393f, -0.04302563f, 
    -0.06097329f, 0.00925535f, -0.04443664f, 0.03563569f, -0.00150481f, -0.01767300f, -0.04638480f, -0.02116992f, 
    -0.00434223f, -0.03249147f, -0.09387516f, 0.01469472f, -0.07214326f, -0.07661289f, -0.01006963f, -0.04700324f, 
    -0.02661519f, -0.01812631f, -0.02397736f, 0.01353560f, -0.06134718f, 0.01449299f, -0.06631785f, -0.08953043f, 
    -0.02990708f, -0.08460818f, -0.03134917f, -0.07054623f, -0.02368287f, -0.08891174f, -0.06886674f, -0.03045850f, 
    0.00518693f, -0.02660049f, -0.09431019f, 0.02189110f, -0.01502496f, -0.02113278f, -0.03321571f, -0.07568680f, 
    -0.05426296f, -0.08907717f, 0.00145104f, -0.01545408f, -0.06978036f, 0.01085873f, -0.02033080f, -0.00069087f, 
    -0.00925677f, -0.00564652f, -0.09552247f, -0.05988949f, -0.03153733f, -0.07343074f, 0.00583484f, -0.04661470f, 
    -0.06873921f, 0.00410148f, -0.08665723f, -0.03505751f, -0.03665025f, -0.04447149f, -0.06503757f, -0.03788618f, 
    -0.08924069f, -0.09289227f, 0.01588944f, -0.02965567f, -0.01664311f, -0.06219777f, 0.02465694f, -0.02133388f, 
    -0.03509494f, 0.01485773f, -0.05673457f, -0.00080857f, -0.05310826f, -0.06516887f, -0.05843194f, -0.03231975f, 
    -0.06821635f, -0.03198693f, -0.03740483f, 0.01479465f, -0.02739794f, 0.01939257f, -0.07180309f, -0.03936286f, 
    0.04277229f, 0.02955002f, -0.02452360f, -0.05026102f, -0.00020914f, -0.07824956f, 0.00213613f, -0.04039876f, 
    0.01782544f, -0.07753650f, -0.04215055f, -0.08779889f, -0.01970951f, -0.08408822f, -0.00925913f, -0.00200050f, 
    -0.02611838f, 0.00217041f, 0.00254390f, -0.02282332f, -0.01278239f, -0.03559960f, -0.07968791f, -0.00364578f, 
    0.01522981f, 0.00747153f, -0.01527589f, -0.03162545f, -0.01037218f, -0.00430681f, -0.04555007f, -0.03568491f, 
    -0.07223325f, -0.03249014f, 0.01319663f, 0.00719514f, -0.04964413f, -0.01052363f, -0.03415922f, -0.07391218f, 
    -0.04916231f, -0.04516023f, -0.04943228f, -0.02206908f, -0.04165516f, 0.01908292f, -0.09524436f, -0.03379213f, 
    -0.05657976f, 0.00609488f, 0.02669609f, -0.02577015f, -0.05347169f, -0.00433255f, 0.01909036f, -0.05339971f, 
    -0.04402904f, 0.13272339f, -0.19837233f, -0.04589210f, 0.04245529f, 0.09133957f, -0.04071496f, 0.13381867f, 
    -0.11347139f, 0.28910604f, 0.20087701f, 0.06346991f, 0.04949792f, -0.10695595f, -0.02852648f, -0.01317857f, 
    -0.01443515f, -0.08222329f, 0.28493708f, 0.19714834f, -0.01520030f, -0.20201439f, -0.09320946f, 0.00009763f, 
    0.00668454f, -0.01779022f, -0.00264765f, -0.14567704f, 0.06040027f, 0.12643820f, 0.03968955f, 0.02774032f, 
    -0.04170480f, 0.03067655f, 0.09120064f, 0.15617321f, 0.00774006f, -0.30652252f, 0.06903256f, -0.00047705f, 
    0.00432673f, -0.05598122f, -0.08596505f, 0.14508517f, -0.00748867f, -0.03905207f, 0.14133449f, 0.00259732f, 
    0.10183731f, -0.16706255f, 0.02555807f, 0.00469077f, 0.04338948f, 0.09100462f, 0.02299394f, -0.18479295f, 
    -0.01792407f, 0.04489989f, 0.07906177f, 0.07704621f, -0.00350452f, 0.07877674f, -0.02029850f, -0.22571217f, 
    -0.24377066f, 0.00704272f, -0.11210870f, 0.04922137f, -0.14241602f, 0.07892846f, -0.06147680f, -0.11825540f, 
    -0.06056647f, -0.25465554f, -0.08512049f, -0.04706255f, 0.17195523f, 0.05342671f, -0.11364112f, -0.04971068f, 
    -0.14191516f, 0.24812335f, -0.03509895f, 0.18551275f, -0.02017268f, 0.03688743f, -0.07553194f, 0.00946649f, 
    -0.06633845f, 0.11182582f, -0.07735837f, -0.30959177f, -0.26071990f, 0.12307594f, 0.04621688f, -0.03626435f, 
    -0.03195881f, -0.04859393f, -0.01772769f, 0.02623031f, -0.24620688f, 0.01727582f, -0.02788941f, -0.03729347f, 
    -0.18396810f, 0.03312285f, 0.06895223f, -0.01738889f, -0.07053620f, -0.09715892f, -0.21480346f, 0.12538828f, 
    0.08654899f, 0.05131676f, -0.04465003f, -0.00086316f, -0.01240496f, 0.14743564f, 0.06926370f, -0.00198742f, 
    -0.15202542f, 0.11129262f, 0.04108913f, -0.04809586f, -0.14238806f, -0.15097357f, -0.19064242f, -0.15788305f, 
    -0.11853445f, 0.22715618f, -0.01855407f, -0.05184836f, -0.24150951f, 0.05652578f, 0.08160321f, 0.02867885f, 
    -0.28954050f, -0.15348479f, 0.04554968f, 0.04233681f, -0.03576924f, 0.01138596f, -0.08944443f, -0.13538456f, 
    0.23356554f, 0.27762374f, 0.14274308f, -0.08263185f, -0.09921155f, 0.09330432f, 0.14528546f, 0.03879794f, 
    -0.00236248f, -0.29005897f, 0.16162507f, -0.12989274f, 0.07169759f, 0.11862965f, 0.01874691f, -0.16527708f, 
    0.01339030f, -0.07606415f, 0.03601868f, -0.23460622f, -0.19344237f, -0.03200944f, -0.04259491f, -0.02688916f, 
    0.08342834f, 0.03488038f, -0.08623774f, 0.15500207f, 0.03806207f, 0.11151559f, -0.12002049f, 0.05537668f, 
    0.09943449f, 0.02028223f, -0.06644103f, -0.01765644f, -0.04949740f, 0.08417741f, -0.02094138f, 0.10516682f, 
    0.13130033f, -0.04074074f, -0.01974255f, 0.05145607f, -0.17073694f, -0.26603442f, -0.20112653f, -0.00839577f, 
    0.10608528f, 0.06865088f, -0.05401986f, -0.10518796f, -0.01802365f, -0.06900757f, -0.21000442f, 0.09130123f, 
    -0.01227961f, 0.00912950f, -0.08400851f, 0.05375547f, 0.03744573f, -0.03951414f, -0.03532929f, 0.25367442f, 
    0.13126379f, 0.08476463f, -0.06102011f, 0.05003650f, 0.16879180f, 0.20672494f, -0.05163121f, 0.14408551f, 
    0.01042506f, -0.22575271f, -0.00657836f, 0.04073811f, 0.11741610f, -0.05180986f, 0.04745951f, 0.07232361f, 
    0.03505919f, -0.11462509f, -0.00062686f, 0.10977762f, -0.07802003f, -0.06019345f, -0.04251982f, -0.04182066f, 
    0.11662181f, -0.19432333f, -0.07000587f, -0.07059649f, 0.14716175f, -0.08159758f, -0.05607016f, 0.00156021f, 
    0.00156284f, 0.04445592f, 0.01138094f, -0.19967449f, -0.10997637f, -0.27886885f, 0.03880979f, -0.07099005f, 
    -0.04697985f, 0.12370299f, -0.00862762f, -0.11782140f, 0.12597947f, 0.03460216f, -0.14131263f, 0.03638682f, 
    0.10952026f, 0.06101077f, 0.00741707f, 0.03254842f, 0.04020273f, 0.12583464f, 0.18838619f, 0.11440969f, 
    -0.07252786f, 0.00424797f, -0.14298657f, -0.07411502f, 0.05392793f, -0.02524463f, 0.01365319f, 0.12491074f, 
    -0.23686257f, 0.00725804f, 0.04631569f, 0.03792777f, 0.12883416f, -0.02993263f, -0.03213643f, 0.17818323f, 
    -0.05682901f, -0.03105949f, 0.00684183f, 0.13429320f, 0.00347150f, 0.02314800f, -0.03921742f, 0.09643158f, 
    -0.10476565f, -0.16235361f, -0.16572173f, 0.02798741f, 0.04621513f, -0.01918115f, 0.05418548f, 0.11472783f, 
    0.11907679f, -0.19887917f, -0.26894897f, -0.03734978f, 0.15667260f, 0.02918720f, 0.06586189f, -0.09467817f, 
    -0.01051033f, -0.16427180f, -0.12431358f, -0.27400503f, -0.02501396f, 0.13191418f, 0.03481079f, 0.00227335f, 
    -0.01006453f, -0.02956645f, 0.01022697f, -0.02441402f, -0.14568375f, 0.01636841f, -0.03253359f, 0.06113765f, 
    0.10074265f, 0.02784101f, 0.12969200f, -0.00941406f, -0.08211961f, -0.23390588f, -0.07831529f, 0.02268033f, 
    -0.06724203f, 0.05373903f, 0.10583921f, 0.13620852f, 0.05952739f, -0.11108100f, -0.09611305f, -0.15672620f, 
    -0.12078480f, -0.05728568f, -0.19227375f, 0.27293396f, 0.04681126f, 0.07844768f, -0.16464657f, 0.03051037f, 
    -0.13303463f, -0.02950946f, 0.03015297f, 0.01722437f, 0.03744754f, 0.16452116f, -0.18249655f, 0.04599866f, 
    -0.08388834f, 0.06376491f, -0.42828333f, -0.21347865f, 0.06328562f, -0.08715443f, -0.01780901f, -0.03028059f, 
    -0.13132407f, -0.32361981f, -0.15865822f, -0.20146938f, -0.03156547f, 0.06852084f, 0.18253411f, 0.18808879f, 
    -0.07117727f, -0.14907250f, -0.08183250f, -0.04984138f, 0.09222309f, -0.05772987f, 0.08701295f, -0.00263475f, 
    0.01984569f, 0.15287945f, 0.16884178f, 0.16283229f, 0.10353637f, -0.04218157f, 0.07087431f, -0.02038638f, 
    -0.01159498f, 0.10371916f, 0.02627656f, 0.05516658f, -0.06020344f, -0.14459971f, 0.02016894f, 0.12399404f, 
    -0.09259990f, 0.18252061f, -0.02132341f, -0.05495573f, 0.13339566f, -0.15061662f, 0.09001068f, 0.04787038f, 
    0.06186701f, 0.01959406f, 0.07719370f, -0.08659486f, 0.07256187f, -0.26829696f, -0.46295175f, -0.18063854f, 
    -0.11221545f, 0.04191543f, -0.05829174f, -0.06429030f, -0.03826085f, -0.09888313f, 0.05343116f, -0.07213683f, 
    0.15037248f, -0.03327939f, -0.03718155f, 0.14160055f, 0.13140932f, 0.10439129f, -0.16791651f, 0.16778156f, 
    -0.01104653f, -0.01137501f, -0.06723144f, 0.03812447f, 0.04080118f, 0.09480262f, -0.03035892f, 0.05795067f, 
    -0.30176222f, -0.18131247f, 0.15317486f, -0.01068284f, 0.08925470f, 0.03197357f, -0.00738067f, -0.01185408f, 
    0.00759886f, 0.23138140f, 0.13796744f, 0.04235440f, -0.07708006f, -0.24211361f, 0.00045130f, 0.00104792f, 
    0.05372273f, 0.15940979f, 0.18550695f, 0.16879281f, 0.07655840f, -0.16620904f, -0.08024646f, 0.01729932f, 
    -0.01052662f, 0.00211985f, -0.05746753f, -0.07322726f, 0.21436039f, 0.16197039f, 0.09363203f, -0.04692845f, 
    0.10929546f, 0.11792797f, 0.01599244f, 0.02813339f, -0.11695920f, -0.26862532f, 0.03617843f, 0.02929992f, 
    0.00016027f, 0.05375389f, -0.18593548f, 0.06110412f, -0.06630257f, -0.25418413f, 0.06024520f, -0.19916487f, 
    -0.00032607f, 0.04417102f, 0.03329610f, -0.01522032f, -0.01372501f, 0.17067836f, 0.02850226f, 0.25551671f, 
    0.06293670f, -0.23540008f, -0.10444744f, -0.06532254f, -0.07369190f, 0.00538404f, -0.00245298f, 0.23030406f, 
    0.12767425f, 0.08159730f, 0.02499794f, -0.06266221f, 0.00937387f, -0.10585015f, -0.04962608f, 0.15378799f, 
    -0.11039428f, -0.06872537f, -0.04786330f, 0.02546783f, 0.08061130f, 0.02637498f, -0.09197199f, 0.00941634f, 
    0.03925143f, 0.08378398f, -0.09417478f, 0.00981902f, 0.08499502f, -0.01347988f, -0.17777464f, -0.03271061f, 
    0.01293851f, -0.07338054f, -0.18591543f, -0.28061253f, 0.15504324f, 0.02610083f, -0.02296255f, 0.11136406f, 
    0.14543033f, -0.11755480f, 0.01733932f, 0.03264536f, 0.05573697f, 0.07715239f, 0.07698761f, -0.08705880f, 
    -0.00714301f, -0.09094022f, -0.07664890f, 0.13257383f, 0.21189727f, -0.14984486f, 0.04945764f, 0.03552013f, 
    0.17627214f, 0.09873518f, 0.03327200f, 0.08537991f, -0.05410187f, -0.24200912f, -0.23000151f, 0.07289676f, 
    0.13099557f, 0.02193433f, 0.03973185f, -0.02458539f, -0.03949419f, 0.02820861f, 0.06916976f, 0.04343522f, 
    0.13188991f, -0.13126640f, -0.01888024f, 0.08207042f, 0.00314206f, 0.15260088f, -0.00710099f, -0.16760767f, 
    -0.15868300f, 0.03364670f, -0.09622214f, 0.00652897f, 0.01544262f, -0.09903761f, 0.01777438f, -0.04980264f, 
    -0.30264178f, -0.02291144f, -0.03059809f, 0.04032514f, -0.06910451f, -0.00115568f, -0.02335642f, -0.08578490f, 
    -0.30797654f, -0.17343691f, 0.15849943f, -0.24212456f, 0.17148159f, 0.05040602f, 0.04902735f, -0.09267236f, 
    0.14292128f, 0.02962458f, 0.08875264f, 0.15386653f, -0.11585722f, -0.02932316f, -0.05409527f, 0.12344858f, 
    -0.08422116f, 0.13589092f, -0.01860546f, 0.05178767f, -0.02365174f, -0.11511996f, -0.04444763f, 0.02635589f, 
    0.03699458f, 0.05278186f, 0.05546239f, -0.01637149f, 0.07215966f, 0.21787037f, 0.03859640f, -0.03420196f, 
    -0.04918402f, -0.18890420f, 0.07120415f, -0.00199135f, 0.17993471f, 0.02848545f, -0.04811165f, -0.04799862f, 
    0.05379691f, -0.03935324f, -0.06218089f, 0.09244936f, 0.05297200f, 0.25971192f, -0.39144072f, -0.09175172f, 
    -0.00151332f, 0.01590566f, 0.13848700f, -0.00190502f, -0.01813291f, -0.15050103f, 0.11880053f, 0.00625210f, 
    -0.18126297f, 0.13957931f, 0.01222398f, -0.10327859f, -0.04021316f, -0.01614165f, -0.10684811f, 0.05214402f, 
    -0.26964974f, -0.09690407f, -0.27196267f, 0.14804310f, -0.01134709f, -0.01957007f, -0.10250866f, -0.07566044f, 
    -0.15076737f, -0.01490587f, 0.04769962f, -0.15835835f, 0.05131496f, -0.07642797f, 0.09407710f, -0.05703225f, 
    -0.02562135f, -0.15874727f, 0.23506923f, -0.05906798f, -0.01017437f, 0.10243346f, 0.12517706f, -0.09638801f, 
    -0.10876953f, 0.04713904f, 0.04713327f, -0.12757653f, 0.06423528f, -0.11644348f, 0.09818456f, -0.01790453f, 
    -0.06690054f, -0.03865760f, 0.08521600f, -0.01927544f, 0.06827157f, -0.16149253f, 0.00387617f, 0.27452385f, 
    0.01682290f, -0.12101726f, 0.01603946f, -0.00145054f, -0.01949100f, -0.15913434f, 0.10560522f, -0.25046539f, 
    0.03298402f, -0.19120099f, -0.09963979f, -0.06778008f, -0.00771978f, 0.10190509f, -0.21658303f, -0.06509568f, 
    0.25927156f, 0.12773691f, -0.08003351f, -0.15857896f, -0.06703806f, 0.08366258f, -0.24598649f, -0.25511828f, 
    -0.23314026f, 0.15215074f, 0.13573791f, -0.12339455f, 0.03182022f, 0.00308368f, -0.04607555f, 0.00977248f, 
    0.19166368f, 0.12881219f, -0.04664503f, 0.07809658f, 0.02980577f, 0.07545703f, -0.12441367f, 0.06513699f, 
    -0.01523109f, -0.00209381f, -0.06719787f, 0.03873980f, 0.09260139f, 0.08626063f, -0.15141267f, 0.03511179f, 
    0.15883575f, -0.05949979f, -0.04340087f, -0.03588537f, 0.29653558f, -0.00477583f, 0.08825582f, -0.06792077f, 
    -0.00147555f, -0.00554098f, -0.02258747f, 0.02547915f, -0.06969514f, -0.16058147f, 0.07984322f, 0.08458864f, 
    0.14809051f, -0.09532086f, 0.04158420f, 0.04227624f, -0.12223899f, -0.09241505f, 0.05214443f, 0.09230993f, 
    0.05362448f, 0.11613932f, -0.11233277f, -0.02323319f, -0.11931187f, -0.27939299f, 0.12561581f, -0.13977899f, 
    0.02308432f, 0.04077052f, 0.04585686f, 0.05102643f, 0.02400423f, 0.00060370f, 0.23129782f, -0.12447321f, 
    -0.04484556f, -0.08164324f, 0.03179946f, 0.06889795f, -0.01757137f, 0.13450427f, 0.07048195f, 0.09752972f, 
    0.30848801f, -0.21046974f, -0.07558158f, 0.17096874f, -0.08751981f, 0.00227713f, 0.10590343f, -0.05070158f, 
    -0.39068034f, -0.19093597f, 0.07344693f, 0.13059884f, -0.00237537f, 0.04475183f, -0.05645071f, -0.03042233f, 
    0.31448421f, -0.03041031f, 0.15295745f, -0.06590318f, 0.00380577f, 0.01382766f, -0.18558201f, 0.07153159f, 
    0.02068613f, 0.05479161f, -0.04148933f, 0.03388363f, -0.01240645f, -0.01339022f, -0.03263984f, 0.00037590f, 
    0.08917922f, 0.05339542f, -0.13267130f, 0.11935543f, 0.09625576f, 0.33303803f, -0.12215873f, 0.02872291f, 
    -0.08838124f, 0.07593855f, 0.02759000f, 0.00323799f, -0.18522257f, -0.19281100f, -0.33561289f, 0.10504021f, 
    -0.04182961f, 0.07820681f, -0.11941218f, 0.07704099f, 0.21459250f, -0.06259219f, 0.11058129f, -0.04976377f, 
    0.14500186f, 0.02813107f, 0.11149137f, -0.06965043f, -0.02580402f, 0.15626708f, -0.27409643f, -0.01600667f, 
    0.09697297f, 0.00843995f, -0.12238503f, 0.12332916f, 0.03168393f, 0.01494265f, -0.30594298f, -0.01962038f, 
    -0.04670522f, 0.02462390f, -0.04373869f, 0.09634530f, -0.04745745f, -0.07535867f, 0.12703790f, 0.17869204f, 
    -0.17374478f, -0.13647473f, -0.01706976f, -0.03251021f, 0.05878326f, 0.02682869f, -0.08332958f, 0.07530549f, 
    0.09240919f, -0.35024908f, 0.17270109f, -0.22538446f, 0.06354479f, 0.09439223f, 0.06929593f, -0.01398409f, 
    0.04527016f, -0.05049497f, -0.06195201f, 0.13965835f, 0.11729719f, 0.04866267f, 0.19762358f, 0.03940877f, 
    -0.05773156f, 0.05377636f, -0.00735550f, -0.04781628f, 0.02831564f, 0.10662073f, -0.04741213f, -0.05745669f, 
    -0.09526408f, 0.00053469f, -0.01218930f, 0.08135335f, 0.08644653f, -0.10135820f, -0.14778233f, -0.06155619f, 
    -0.12175197f, 0.07297117f, 0.03493473f, -0.02137727f, -0.01885568f, -0.14431635f, 0.24203797f, 0.00795562f, 
    -0.02577978f, -0.05627965f, -0.16809393f, 0.00315018f, 0.08628763f, 0.07824900f, 0.16591100f, -0.22347891f, 
    -0.32326561f, 0.04139239f, -0.02198598f, 0.01637094f, 0.04840140f, -0.15731487f, -0.06125030f, 0.28375697f, 
    0.14579619f, 0.13449682f, -0.08572061f, -0.22623646f, 0.08966649f, 0.01569705f, 0.06416596f, -0.09145498f, 
    0.03312781f, -0.04330770f, -0.34973732f, 0.00056930f, 0.03545520f, -0.00402020f, -0.16615367f, -0.00773655f, 
    -0.06933574f, 0.16542369f, 0.16454139f, -0.04203688f, 0.05599814f, 0.09385300f, 0.08776729f, -0.11182129f, 
    -0.11943182f, -0.15727641f, 0.21111371f, 0.01070644f, 0.09776850f, 0.01584543f, -0.02754557f, 0.01704451f, 
    0.10884647f, 0.13522774f, 0.11673620f, 0.12293597f, -0.07446633f, 0.01030176f, 0.03151733f, 0.10862979f, 
    0.07045649f, -0.03985330f, 0.05919831f, -0.00499758f, 0.27954635f, -0.25273129f, -0.02361102f, -0.05457474f, 
    0.00966027f, 0.00237122f, -0.09987745f, -0.06954342f, 0.03452126f, -0.00419821f, -0.05708039f, 0.12159786f, 
    0.02318189f, 0.03399533f, -0.10166409f, -0.17666064f, 0.16716698f, 0.06900620f, 0.04032605f, -0.29358861f, 
    -0.15966770f, -0.09244036f, 0.12420730f, 0.01194075f, 0.07536806f, 0.09262471f, -0.04503925f, 0.19214980f, 
    -0.03286674f, 0.21775842f, 0.07021733f, 0.13505946f, -0.00289671f, 0.10870010f, 0.10309491f, -0.13118632f, 
    -0.35385704f, 0.18728018f, 0.01852225f, -0.03597952f, -0.00157057f, 0.06315266f, 0.07444988f, -0.02426889f, 
    0.04692426f, -0.19517127f, -0.06516123f, 0.01516438f, 0.08732790f, 0.00390472f, 0.01423519f, -0.18881665f, 
    0.09311156f, -0.14861080f, 0.44327554f, 0.09321796f, -0.03164351f, 0.01428291f, -0.07019970f, -0.02947925f, 
    0.08061226f, -0.02233515f, 0.15478699f, -0.18237212f, 0.13587609f, -0.43616760f, 0.02808067f, -0.00895002f, 
    0.04803853f, -0.01040370f, 0.02379972f, 0.14088766f, -0.00748507f, -0.24032742f, -0.13098842f, -0.14964251f, 
    0.03191976f, -0.03705087f, -0.20126638f, 0.10579159f, -0.09459072f, 0.24676569f, -0.01504304f, -0.02571548f, 
    -0.15677585f, -0.09930294f, -0.00790926f, 0.02906899f, -0.06641439f, 0.01202404f, -0.27967417f, 0.33649507f, 
    0.15957582f, 0.05997492f, 0.08967470f, -0.03192260f, 0.07111916f, 0.00826321f, -0.02794904f, -0.27510047f, 
    0.11271318f, -0.01199848f, 0.03097692f, 0.07661778f, 0.09171963f, -0.07474229f, -0.03422448f, 0.02587805f, 
    0.08187809f, -0.24266414f, -0.08443938f, 0.09125622f, 0.11117940f, 0.04906511f, -0.07498992f, -0.03464214f, 
    -0.04531872f, -0.28720424f, 0.04535999f, 0.07315973f, 0.05278929f, 0.06083458f, 0.02554790f, -0.10908407f, 
    0.05360284f, -0.13995893f, -0.11980809f, -0.09963535f, -0.13818654f, -0.01312370f, -0.20583007f, -0.04828414f, 
    0.03963952f, 0.00302389f, 0.09067082f, -0.19416401f, -0.14604606f, 0.13853697f, -0.07288042f, 0.11035968f, 
    0.13029599f, 0.02239024f, -0.02673667f, -0.13396861f, -0.08164408f, -0.12515080f, -0.35333186f, 0.00459094f, 
    0.00263727f, 0.06226462f, 0.02019544f, 0.02286268f, 0.03893703f, -0.20030628f, 0.02596605f, -0.01947533f, 
    -0.04104889f, 0.05218891f, 0.02251592f, -0.11404899f, -0.08507668f, 0.00677720f, 0.11235332f, 0.18061276f, 
    -0.12851024f, 0.13307987f, -0.08539547f, -0.02401952f, 0.05525217f, -0.06753512f, -0.04981039f, -0.19428121f, 
    0.13222906f, -0.28255087f, 0.15889204f, -0.13500203f, 0.10071341f, -0.12577362f, -0.06946546f, 0.03356472f, 
    0.00105919f, -0.02626236f, 0.03133853f, -0.06518927f, -0.04763402f, -0.04432619f, -0.04760740f, -0.01032419f, 
    -0.00895405f, -0.01545649f, 0.04682942f, -0.02707137f, 0.01816163f, -0.06653719f, 0.01911949f, -0.02680307f, 
    0.04967755f, 0.03023666f, 0.03224460f, 0.03962525f, -0.02416471f, -0.01799785f, 0.00829114f, -0.02063238f, 
    -0.00828085f, -0.04895611f, -0.06460962f, -0.05836591f, -0.05907474f, -0.05760377f, -0.05199922f, 0.03041995f, 
    -0.03099309f, -0.05196369f, 0.04624583f, -0.00975570f, 0.03683549f, 0.04668099f, -0.00615454f, 0.01338805f, 
    0.04752300f, -0.05958579f, -0.00443204f, 0.04823576f, 0.02271504f, 0.03589065f, -0.02356546f, 0.02851439f, 
    -0.02878789f, -0.05614201f, 0.00633633f, 0.00617016f, -0.05366625f, 0.02408664f, 0.00219995f, -0.02483742f, 
    -0.05554027f, 0.02017217f, 0.04189407f, -0.06310622f, 0.01699402f, 0.04345805f, -0.01321985f, -0.02306329f, 
    -0.04157617f, 0.00535738f, -0.04617920f, 0.00155079f, -0.00922720f, -0.05362685f, -0.05723175f, 0.03775899f, 
    -0.01211757f, -0.06451891f, 0.00917646f, -0.06563675f, -0.02862409f, 0.05250991f, 0.03324369f, 0.05087403f, 
    -0.04441256f, 0.03565706f, 0.03598541f, -0.00596483f, -0.05805555f, 0.04615513f, -0.01157978f, 0.03825610f, 
    0.02455261f, -0.01179478f, 0.03841630f, -0.00115589f, -0.02794253f, 0.00073914f, -0.01857083f, -0.06336650f, 
    -0.04119426f, -0.05573947f, 0.03249270f, -0.04128582f, 0.04375486f, -0.02780033f, 0.02418364f, 0.04284811f, 
    -0.04988036f, 0.01757436f, -0.02017502f, -0.05481974f, 0.04831135f, -0.01615665f, -0.00640948f, 0.02357574f, 
    0.00954070f, -0.02668681f, -0.03200840f, -0.00271298f, 0.04350544f, 0.04960479f, 0.01333399f, 0.03016317f, 
    -0.03102017f, 0.02448548f, -0.04291172f, 0.03411652f, -0.04933686f, -0.00511558f, 0.00332347f, -0.00843969f, 
    0.04129394f, -0.02169385f, 0.02619695f, -0.04562653f, -0.02190240f, -0.02488351f, -0.00324495f, -0.05789695f, 
    -0.04884709f, -0.05296130f, 0.01479867f, -0.05999541f, 0.00711055f, -0.06453490f, -0.04188561f, 0.02653190f, 
    0.03869783f, 0.04494562f, -0.02130939f, -0.02920863f, 0.02082971f, 0.02439834f, -0.03427901f, -0.05354251f, 
    0.05095161f, -0.03569647f, 0.01298815f, 0.03896102f, -0.02534726f, 0.01511561f, 0.04016103f, 0.00750756f, 
    0.02381959f, 0.03934637f, -0.03956642f, -0.00579587f, -0.05006956f, -0.04494454f, -0.02179630f, -0.04550872f, 
    0.02506794f, 0.03859610f, 0.00303103f, -0.05269119f, -0.03830485f, -0.02546222f, 0.01218270f, -0.03572169f, 
    0.03482572f, -0.00623831f, -0.01630483f, -0.01046672f, -0.04331016f, -0.03459100f, -0.06478854f, 0.04306347f, 
    0.04075861f, -0.02010145f, 0.00903954f, 0.03302705f, 0.04651669f, 0.00332364f, -0.04586190f, -0.01275487f, 
    0.00107577f, -0.02233457f, -0.00938811f, -0.05690502f, 0.02618830f, -0.01038127f, -0.02822983f, -0.03082204f, 
    0.02341650f, -0.00536894f, 0.01872634f, -0.06224386f, -0.03806828f, -0.03888402f, -0.00927844f, 0.01575931f, 
    -0.03632605f, 0.00654310f, 0.04054969f, 0.02439634f, -0.02136277f, -0.00681493f, -0.03457337f, 0.01299263f, 
    -0.03313575f, -0.00648557f, 0.04122399f, -0.04749452f, -0.02627126f, -0.02743548f, -0.02755216f, -0.05140582f, 
    -0.02655702f, -0.04894660f, -0.02129697f, -0.01668960f, -0.04952802f, 0.00243375f, -0.01454246f, 0.02715855f, 
    0.02721459f, 0.00260105f, 0.04380940f, 0.01177421f, -0.02235062f, 0.00981946f, -0.00213107f, -0.04870174f, 
    -0.05337552f, 0.02580776f, -0.05158367f, -0.00714103f, -0.02850621f, -0.06274667f, -0.04989515f, -0.01685137f, 
    -0.06697586f, -0.03428986f, 0.00475004f, -0.00585310f, -0.05899047f, -0.02682716f, -0.03836365f, 0.02712266f, 
    0.00151374f, -0.00515971f, 0.04430133f, -0.03771618f, -0.00498427f, 0.03538620f, 0.03505640f, -0.01081236f, 
    0.01641205f, -0.06503765f, -0.04456889f, -0.02296398f, 0.03854554f, -0.01790893f, -0.02221328f, -0.04718124f, 
    -0.00402199f, -0.04341589f, -0.02556822f, -0.02443030f, 0.02276553f, 0.00178095f, 0.02591298f, -0.04468440f, 
    -0.01690218f, 0.00118060f, 0.03516657f, -0.01264138f, 0.05046922f, -0.05071807f, -0.04127485f, -0.06334506f, 
    -0.03382151f, -0.02109439f, 0.01851356f, -0.05359982f, 0.04910503f, 0.03855024f, 0.00377475f, -0.01175077f, 
    -0.01751542f, -0.06553813f, 0.02886131f, -0.04028763f, 0.00126972f, 0.01219358f, -0.06055110f, 0.04367166f, 
    -0.00755936f, 0.01069424f, 0.01874078f, -0.07083797f, 0.04594267f, 0.01637734f, -0.00598006f, -0.00899816f, 
    -0.02640414f, -0.01521015f, 0.03066157f, 0.02647234f, 0.03262108f, -0.02682361f, 0.04190987f, -0.04151507f, 
    0.00910640f, 0.02444998f, -0.03537440f, 0.04945075f, -0.02366617f, 0.00550770f, 0.02417581f, -0.00866935f, 
    -0.02801017f, 0.04032833f, 0.02190483f, -0.01566311f, -0.03563665f, 0.01210949f, 0.03468335f, 0.01688968f, 
    0.02434807f, 0.02743910f, 0.00723329f, -0.03380707f, -0.04166199f, 0.03393551f, -0.04845866f, 0.03254984f, 
    0.01449349f, -0.05373885f, 0.00370229f, 0.00899512f, 0.00639060f, -0.03320324f, 0.00878657f, -0.05065443f, 
    -0.03783485f, -0.07080511f, -0.00439800f, -0.05735225f, -0.04390100f, 0.00890272f, 0.01866813f, 0.03587508f, 
    0.03155711f, -0.02829980f, 0.01364102f, -0.03700862f, 0.03841209f, -0.00035386f, 0.03148643f, 0.03191295f, 
    0.03006038f, -0.06878605f, -0.00695705f, -0.06482825f, -0.02239579f, 0.01379172f, 0.00439776f, 0.04082451f, 
    -0.05310379f, 0.01081378f, -0.03771224f, -0.06423523f, -0.00785403f, -0.05395165f, -0.03077048f, -0.06974912f, 
    -0.03880230f, -0.02031542f, -0.00192383f, 0.01139019f, -0.03037859f, 0.02225861f, 0.04406802f, -0.03895414f, 
    0.00364601f, -0.03239788f, -0.03754649f, 0.03198298f, 0.00904572f, -0.05652434f, -0.05012006f, 0.04291138f, 
    0.03274061f, 0.04229997f, 0.00985738f, -0.00139604f, -0.03526133f, -0.00053975f, -0.02130870f, -0.00001991f, 
    -0.01206700f, 0.03345616f, -0.04991098f, -0.06833112f, 0.00856985f, -0.02632861f, -0.06805383f, 0.02208906f, 
    0.02786009f, 0.02980676f, 0.02631503f, -0.07199712f, -0.06514481f, -0.00562171f, 0.02469700f, -0.01570930f, 
    -0.05530094f, -0.01478975f, -0.00175973f, 0.04355175f, -0.01888484f, -0.00646538f, 0.04207783f, -0.02483502f, 
    0.03955768f, -0.06937186f, 0.00324804f, -0.00399889f, 0.00834632f, 0.00231653f, 0.03571824f, -0.06572530f, 
    -0.04578851f, 0.03387677f, 0.00088045f, -0.03365220f, 0.03791715f, 0.00362632f, 0.00345943f, -0.03338454f, 
    -0.05065134f, 0.03405339f, 0.01054379f, -0.00699499f, 0.01275513f, -0.00626542f, -0.05940478f, 0.01811388f, 
    0.02487338f, 0.01540858f, 0.03038368f, -0.03346611f, 0.00686266f, -0.01473252f, -0.01538195f, 0.02203909f, 
    -0.01472389f, -0.03308827f, -0.06838726f, 0.02385066f, -0.02749692f, 0.02379434f, 0.01173068f, -0.01030426f, 
    -0.00556882f, -0.05117894f, -0.01652525f, -0.00495082f, -0.04520027f, 0.02794233f, 0.02303527f, -0.05214255f, 
    -0.01946689f, -0.04822202f, 0.01353778f, 0.02587721f, -0.03919914f, 0.03229599f, -0.03893894f, -0.00915027f, 
    -0.03249554f, 0.02593256f, 0.00123985f, -0.05557920f, 0.03336289f, 0.02682324f, 0.04059407f, -0.00612220f, 
    -0.00334818f, 0.04423568f, -0.04560547f, 0.01755894f, -0.03720792f, 0.05075862f, 0.00522960f, -0.05515106f, 
    -0.04254284f, 0.03335546f, -0.02543527f, -0.04193420f, 0.05134649f, 0.01909217f, -0.01887383f, 0.00852066f, 
    -0.04665990f, -0.05684219f, 0.01915508f, 0.02850763f, 0.03546210f, -0.01944657f, 0.03110355f, 0.01568841f, 
    0.03559818f, -0.07180009f, 0.03072044f, 0.04623492f, -0.01169265f, -0.06541123f, -0.04261139f, -0.05235957f, 
    -0.06388353f, 0.03534090f, 0.04771117f, 0.03843647f, -0.07416116f, 0.02735174f, 0.01305674f, -0.00350237f, 
    -0.04458293f, -0.04144435f, -0.01232396f, 0.00129110f, 0.01044290f, 0.02658982f, 0.02823982f, -0.02608802f, 
    0.00762074f, 0.04913460f, -0.02257108f, 0.03764034f, -0.03101238f, 0.00377271f, 0.01814645f, -0.04433084f, 
    -0.03340614f, -0.03859587f, -0.06939045f, -0.04849869f, -0.03264811f, -0.05373634f, 0.05478591f, -0.02283517f, 
    -0.01395571f, -0.06108966f, -0.00190559f, -0.03469252f, -0.03741480f, 0.00878445f, 0.04575416f, 0.01958695f, 
    0.03041049f, -0.05561633f, -0.06121308f, 0.00923170f, -0.01855976f, -0.01678859f, 0.04505330f, 0.00788714f, 
    0.04663409f, 0.03343343f, 0.01561936f, -0.04715764f, 0.03798411f, -0.00461137f, -0.04341803f, -0.02934283f, 
    -0.01352059f, -0.05742506f, 0.00898729f, -0.03375401f, -0.04671146f, 0.00792771f, -0.04743365f, 0.03433273f, 
    0.04504744f, 0.02371618f, -0.02153546f, -0.02327152f, -0.03068104f, -0.01044371f, -0.03124614f, -0.00758151f, 
    -0.04242412f, 0.04994706f, -0.00046163f, -0.03456454f, -0.03189269f, 0.00223998f, -0.01048648f, -0.00126859f, 
    -0.05973574f, -0.06678244f, -0.04366478f, -0.04135496f, -0.01310843f, -0.06139499f, -0.05008738f, -0.03463192f, 
    -0.06081140f, -0.06380080f, 0.00602358f, 0.04911055f, 0.03787451f, 0.04972650f, 0.02955227f, 0.02437094f, 
    -0.02693665f, 0.02586902f, -0.05783362f, 0.04470550f, 0.02208305f, 0.03471190f, 0.00859810f, -0.00263756f, 
    -0.02965385f, -0.06487130f, -0.02177737f, 0.04042877f, -0.05282241f, -0.00804888f, -0.01365032f, 0.03249079f, 
    -0.00854757f, -0.03452644f, 0.02281481f, 0.02569094f, 0.03392093f, 0.05261106f, 0.00043855f, 0.04355847f, 
    -0.06412053f, -0.03981254f, -0.05217259f, 0.01956788f, 0.00655190f, -0.00070672f, -0.00466714f, 0.02520036f, 
    0.01013021f, 0.00039461f, -0.02543125f, 0.00243823f, 0.04568331f, 0.02529341f, -0.03172214f, -0.02918904f, 
    -0.05584243f, -0.03960409f, 0.03405615f, -0.06534868f, 0.00355681f, -0.06279133f, 0.04389887f, 0.00413168f, 
    -0.01329236f, -0.01567501f, 0.04576136f, -0.04442993f, -0.04856497f, 0.01269163f, -0.00057207f, -0.06118052f, 
    0.03370384f, -0.03657476f, 0.02727830f, -0.02277609f, -0.03955989f, 0.00249037f, 0.00149645f, -0.03381565f, 
    -0.05949245f, 0.01676371f, -0.01181321f, -0.02472084f, 0.04114945f, 0.01941580f, 0.04841280f, -0.06305908f, 
    -0.03421840f, 0.01843027f, -0.04175724f, -0.04926877f, -0.04274372f, 0.01430140f, -0.05928678f, -0.01613058f, 
    -0.06212881f, 0.00588678f, 0.03412422f, -0.03649705f, 0.02104722f, -0.04841655f, 0.03401281f, 0.04075044f, 
    -0.01014413f, 0.04285072f, -0.06212639f, 0.03292212f, -0.00536502f, 0.02111323f, -0.02414380f, 0.02516810f, 
    0.00272444f, 0.03114931f, 0.00971779f, -0.03342364f, 0.01869319f, 0.03888394f, 0.01529806f, 0.01943207f, 
    0.03661202f, 0.01855689f, -0.02656922f, 0.04329564f, 0.04069632f, 0.04868524f, -0.00525474f, -0.03107520f, 
    -0.03241564f, -0.06055979f, 0.01613281f, -0.03740588f, 0.02441313f, -0.03728740f, -0.03609917f, 0.00537954f, 
    0.04977526f, 0.02505401f, -0.04174154f, 0.00723348f, -0.03031120f, 0.02269818f, -0.04720019f, 0.02059859f, 
    0.04496354f, -0.04405335f, -0.02214777f, 0.04315249f, -0.01197704f, -0.01370636f, -0.01509417f, -0.03194781f, 
    -0.02086798f, -0.05970849f, 0.03413285f, -0.05335309f, 0.01886325f, -0.04512284f, -0.02332729f, 0.04749677f, 
    0.03273929f, 0.01394945f, -0.06444940f, 0.01823882f, -0.04851869f, -0.05115024f, -0.02092154f, -0.04868164f, 
    0.02016559f, -0.03557208f, -0.04952595f, 0.03267165f, 0.03518264f, 0.05020453f, -0.00337686f, -0.06191699f, 
    0.03456103f, 0.03308528f, -0.03646291f, -0.01853246f, -0.05396030f, -0.05813987f, 0.02985569f, -0.01742974f, 
    -0.05494671f, 0.04588032f, -0.06714164f, 0.02232235f, -0.05253400f, -0.04222506f, 0.00194154f, -0.04960687f, 
    0.01275423f, -0.02281564f, -0.00625249f, -0.01567063f, -0.01248936f, -0.04492147f, -0.05344516f, 0.03451066f, 
    0.02756854f, -0.00647992f, -0.03088417f, -0.06479407f, -0.03008849f, -0.02442273f, 0.03744710f, -0.00518954f, 
    0.03388904f, -0.01739709f, 0.00732453f, -0.05171153f, -0.02142221f, -0.04542879f, -0.01756211f, -0.02551889f, 
    -0.00798066f, -0.05795542f, -0.02250264f, -0.02901492f, -0.05030046f, 0.03112081f, -0.01813725f, 0.03513232f, 
    -0.05886753f, -0.02979339f, -0.04370569f, -0.05466877f, -0.00263420f, -0.04498297f, -0.05814852f, -0.06003838f, 
    0.04410745f, 0.02665555f, 0.02029846f, -0.06129450f, 0.00811622f, -0.02108603f, -0.02750591f, -0.00124787f, 
    0.01235148f, 0.03232100f, 0.02243702f, -0.05820562f, 0.00093321f, 0.00438596f, 0.02872553f, 0.04326721f, 
    -0.06230996f, 0.02535075f, 0.03805611f, 0.01764133f, -0.03877100f, 0.00643712f, -0.06771183f, 0.02109208f, 
    -0.02632204f, 0.01025124f, 0.04586953f, -0.05254986f, -0.02894702f, -0.05605840f, -0.01914665f, -0.04499881f, 
    -0.00540272f, 0.00381880f, -0.00033867f, -0.01457204f, -0.05941667f, -0.04306992f, -0.03361128f, 0.02519248f, 
    -0.06342227f, 0.00317222f, -0.04624341f, 0.00865615f, 0.04705295f, -0.03249430f, -0.05534907f, 0.03172745f, 
    -0.00850510f, 0.02123246f, -0.04960353f, -0.06237473f, -0.03790193f, -0.00413512f, -0.04449634f, -0.01892968f, 
    -0.01007091f, -0.02370871f, 0.01905217f, 0.02725420f, -0.05713392f, -0.02636778f, 0.02832637f, -0.01941097f, 
    -0.02050321f, 0.04103210f, -0.01769917f, -0.04027981f, -0.06132708f, -0.06395064f, -0.01663675f, -0.06353462f, 
    0.00273096f, 0.00998385f, -0.01892075f, 0.03209422f, 0.01490923f, -0.06473827f, 0.01454693f, -0.01068376f, 
    -0.01742544f, 0.04250014f, -0.00817518f, -0.00461722f, -0.01255946f, -0.00595647f, 0.03030646f, 0.04653167f, 
    0.00260630f, 0.00660993f, 0.01046257f, 0.02383740f, 0.04962323f, -0.01969913f, 0.02195202f, 0.02796253f, 
    -0.05938837f, -0.03593439f, -0.00360760f, -0.04760648f, 0.03974878f, -0.04102372f, -0.02782676f, -0.01462581f, 
    -0.00938485f, -0.03368153f, -0.02934085f, -0.03422254f, 0.04091092f, 0.00913757f, -0.05589876f, -0.00850467f, 
    -0.00390501f, -0.05416049f, 0.01196358f, -0.03092834f, -0.05223175f, 0.01898397f, 0.03896715f, -0.06059147f, 
    0.00288911f, 0.02484515f, 0.03641241f, -0.04070469f, 0.03230621f, 0.02857052f, -0.02092942f, 0.03598422f, 
    -0.05040674f, -0.04447000f, -0.00980450f, -0.04695284f, 0.01460636f, -0.00242175f, 0.04271840f, 0.01243589f, 
    -0.03369146f, 0.01978333f, -0.02175649f, -0.05517089f, -0.04220185f, 0.00403897f, 0.05218183f, -0.02138425f, 
    -0.05609446f, -0.00056127f, -0.06332634f, -0.04034168f, -0.02399439f, 0.03415228f, -0.05053718f, -0.04582039f, 
    -0.03824739f, 0.04591038f, -0.02984843f, -0.06165658f, -0.01379371f, -0.05132819f, -0.00834278f, -0.00976136f, 
    -0.04094974f, -0.03665678f, -0.04424191f, 0.03615375f, -0.05948403f, 0.03183221f, 0.02631725f, 0.03145355f, 
    -0.02813081f, -0.01788793f, -0.02819759f, -0.01709260f, -0.00446251f, 0.03501567f, -0.06210980f, 0.03615414f, 
    -0.05156421f, -0.04271429f, 0.02096032f, -0.04386972f, 0.00668233f, 0.03574286f, 0.01769822f, -0.01760717f, 
    0.05025909f, 0.00949809f, 0.00192755f, 0.01388668f, 0.05180023f, -0.00180798f, -0.04533895f, -0.00508287f, 
    0.04541459f, -0.04853687f, 0.02933221f, 0.04078872f, -0.03091554f, -0.03294446f, 0.00225277f, 0.03394111f, 
    -0.03665598f, 0.02646865f, 0.00299777f, 0.01582373f, -0.02058727f, -0.05928843f, -0.06303485f, -0.03477536f, 
    0.04740535f, -0.03983009f, -0.00196575f, -0.01485242f, 0.03560031f, -0.00060607f, -0.04224296f, 0.04801330f, 
    0.03852919f, -0.04047018f, -0.01224534f, 0.02082364f, 0.05421671f, 0.00161319f, -0.02200797f, -0.05320276f, 
    -0.05620009f, 0.05010822f, -0.04254543f, -0.02654605f, 0.03661592f, -0.00895232f, 0.03239087f, -0.05584504f, 
    0.05096192f, 0.00323386f, 0.04858326f, 0.04373640f, 0.01247146f, -0.03206007f, 0.01220220f, -0.00527874f, 
    0.01033645f, -0.06252056f, -0.02232928f, 0.01643285f, -0.01793833f, -0.01882686f, -0.01571888f, -0.00125984f, 
    -0.01784748f, 0.04074455f, 0.04342831f, -0.01327755f, -0.02461078f, -0.05427006f, 0.04450463f, -0.04131156f, 
    -0.06382559f, 0.00807337f, 0.04567288f, 0.02240702f, -0.02137414f, 0.02037680f, 0.05117455f, 0.00963950f, 
    0.03272803f, 0.01416394f, 0.03889905f, -0.03813566f, -0.01544142f, 0.04600562f, -0.00779903f, -0.05480431f, 
    0.00384449f, 0.04110046f, 0.00970163f, 0.00038684f, -0.03866118f, 0.04572639f, -0.00178862f, -0.01020422f, 
    -0.02020926f, -0.02800388f, 0.02436271f, -0.03653567f, -0.03439991f, -0.00022012f, 0.01081900f, -0.00455327f, 
    -0.03700732f, -0.04888237f, -0.05618389f, 0.03175795f, -0.03240939f, -0.01265832f, -0.06217687f, -0.05455584f, 
    -0.03380658f, -0.01859110f, -0.00241265f, -0.06150123f, 0.02460487f, -0.04413565f, -0.01400479f, -0.04578172f, 
    -0.01021977f, -0.02996626f, 0.03841414f, -0.01290559f, 0.02991050f, 0.01660694f, 0.04717375f, -0.00060651f, 
    0.02806485f, 0.05580928f, -0.02928307f, 0.02090707f, 0.02044774f, -0.00545915f, -0.03937483f, 0.01687006f, 
    0.01750768f, 0.02027469f, -0.02591597f, 0.01943642f, -0.00177384f, -0.03321915f, -0.04749987f, 0.01613843f, 
    -0.01414816f, -0.10689267f, -0.06700540f, -0.03850945f, -0.08591556f, -0.01822701f, -0.03103689f, 0.01354684f, 
    0.02791104f, -0.03446348f, 0.02801301f, 0.02017838f, -0.02787115f, -0.06005973f, 0.01049693f, -0.02757935f, 
    -0.07993267f, 0.03306147f, -0.02146656f, -0.04383409f, -0.06229392f, -0.07913886f, 0.01902469f, -0.00167790f, 
    -0.06168856f, -0.10047064f, 0.05902494f, -0.01978935f, -0.05022338f, -0.04979829f, -0.01154779f, -0.05162978f, 
    -0.03618429f, 0.02046829f, 0.02243671f, -0.00574214f, 0.05169818f, 0.01818352f, 0.02715687f, -0.05302115f, 
    -0.08527921f, 0.01237314f, -0.01808128f, -0.03404879f, -0.02152407f, -0.07431056f, -0.00670806f, -0.01964207f, 
    -0.00287871f, -0.00991650f, -0.09021365f, -0.03089646f, -0.10877547f, 0.00004990f, -0.01762768f, -0.05419170f, 
    -0.01509981f, 0.01556533f, -0.00599626f, -0.03814886f, 0.03756974f, 0.00206490f, -0.04061800f, -0.06808567f, 
    -0.03590374f, -0.02941714f, -0.01163994f, -0.02078499f, -0.08064444f, -0.01060884f, -0.04565506f, -0.02024992f, 
    -0.03988693f, 0.00251534f, -0.00008410f, -0.01030202f, 0.01731257f, -0.02915819f, -0.04020504f, -0.10229772f, 
    0.01086475f, -0.01567808f, 0.01559535f, -0.03026719f, -0.01812017f, -0.03825603f, -0.08445688f, 0.01620637f, 
    0.00293041f, -0.02364351f, -0.03016587f, 0.03349596f, -0.05829225f, -0.04165965f, -0.08564799f, -0.00070496f, 
    -0.06714870f, -0.04277435f, 0.02886578f, 0.03184310f, -0.01071057f, -0.05914525f, -0.03690620f, -0.01333419f, 
    -0.07663110f, -0.01490584f, -0.03604247f, 0.04854473f, 0.00340957f, -0.06835870f, -0.01229638f, -0.07420606f, 
    -0.05411158f, -0.03614072f, -0.00230494f, -0.01022118f, -0.08307763f, 0.02516015f, -0.00330629f, -0.00216767f, 
    0.00701207f, -0.01505174f, -0.01875320f, -0.04236972f, -0.01333077f, 0.09599350f, 0.04214566f, 0.01675760f, 
    -0.04624485f, -0.01247200f, -0.07646389f, -0.00133109f, 0.03398924f, -0.01760768f, -0.00329865f, -0.04532459f, 
    -0.04185133f, -0.02083932f, 0.00909029f, -0.01041791f, 0.07598730f, -0.00983118f, 0.02771578f, 0.00379765f, 
    0.00959769f, 0.00291328f, -0.07090472f, -0.00752628f, 0.01360462f, -0.05231223f, -0.05283500f, -0.06757569f, 
    -0.00279618f, -0.05455919f, -0.04470033f, -0.02820694f, -0.01618277f, -0.05903673f, -0.09640025f, -0.00849658f, 
    -0.00817628f, -0.07185818f, -0.03778688f, -0.06069768f, 0.05810643f, -0.04179366f, 0.03068168f, -0.03233086f, 
    -0.03068839f, -0.06668234f, -0.00800273f, -0.00145183f, -0.00594104f, -0.10305408f, 0.00521328f, -0.00620226f, 
    -0.02265930f, 0.04172079f, -0.00249359f, 0.06219319f, -0.04907163f, 0.05556481f, -0.00277812f, 0.04068492f, 
    -0.04996582f, -0.03584776f, -0.06064313f, -0.05315180f, -0.03011576f, -0.03542336f, 0.03377251f, -0.06526356f, 
    -0.09926020f, -0.02504509f, -0.08795784f, 0.02316920f, -0.05243041f, -0.05073791f, -0.02295506f, -0.00386492f, 
    -0.00124029f, -0.04450110f, -0.00178963f, 0.04056804f, 0.01232129f, -0.06609032f, 0.02318340f, 0.01877357f, 
    -0.05841828f, -0.03449097f, -0.05330344f, 0.00710477f, -0.06000627f, -0.04353996f, 0.02240059f, -0.05859470f, 
    -0.02759727f, 0.00098727f, -0.01072722f, 0.00075147f, 0.00629028f, -0.06585354f, -0.06614304f, -0.02894636f, 
    -0.00891862f, -0.02312256f, -0.01841213f, -0.00062139f, -0.01523440f, 0.00114719f, 0.01028608f, -0.01763025f, 
    -0.08937385f, -0.01525025f, -0.06414231f, -0.01550157f, -0.04980977f, -0.08224447f, -0.06459258f, 0.03952350f, 
    0.03370139f, -0.00411748f, -0.06811944f, -0.04633221f, -0.00632724f, -0.00395953f, -0.10782890f, -0.00397877f, 
    -0.01675155f, -0.01393683f, -0.05919083f, -0.06689097f, -0.00992249f, -0.01362130f, -0.11015768f, -0.02406746f, 
    -0.06050639f, -0.04729043f, -0.03283635f, 0.04218240f, -0.03566425f, 0.01866665f, -0.00524221f, -0.00499068f, 
    0.03551418f, -0.07227036f, -0.03137126f, -0.04363644f, -0.01176993f, -0.05962816f, 0.01606195f, -0.00825141f, 
    0.00218423f, 0.03286704f, 0.02379236f, -0.00967087f, -0.04138140f, -0.03344973f, -0.01188777f, -0.06675246f, 
    -0.03977981f, 0.03590584f, 0.02154140f, 0.01495045f, -0.05203807f, -0.00706717f, 0.02034988f, 0.04001933f, 
    0.04576209f, 0.02675252f, 0.04240464f, -0.02269646f, 0.03746502f, -0.02754650f, -0.04257184f, -0.06480680f, 
    -0.04468307f, 0.00443340f, 0.02372282f, -0.01441489f, -0.01737369f, -0.04085166f, -0.02418689f, -0.01699859f, 
    -0.01869312f, -0.05302463f, -0.01937190f, 0.03006426f, 0.02180965f, -0.06314442f, -0.04082656f, -0.04852850f, 
    -0.02008324f, 0.03157383f, -0.04770466f, 0.03538574f, -0.05666188f, -0.00992018f, -0.06693286f, -0.00233043f, 
    -0.06431533f, 0.03254744f, -0.03457104f, -0.03210557f, 0.03639249f, 0.04189501f, -0.02208747f, -0.06171302f, 
    0.04413354f, -0.05499495f, -0.02544777f, -0.01234608f, -0.01069820f, -0.02500211f, -0.03706918f, -0.00249631f, 
    -0.01447272f, 0.03218193f, -0.06195480f, -0.05907292f, 0.03151394f, 0.01478735f, 0.05125235f, 0.01205861f, 
    0.02270873f, -0.02204106f, 0.00531167f, -0.03407149f, -0.03043346f, -0.04192865f, -0.05801987f, 0.04443485f, 
    -0.01107286f, 0.01298812f, -0.04820731f, 0.04697931f, 0.02108630f, -0.06025752f, -0.01162288f, 0.00398904f, 
    -0.06396040f, -0.05711358f, -0.00574003f, -0.02994859f, -0.06997999f, 0.02028054f, 0.01322937f, -0.04626876f, 
    -0.00608175f, -0.05807152f, 0.03960495f, -0.04581081f, -0.01194102f, 0.00775237f, 0.04301805f, 0.04410653f, 
    0.01659430f, -0.00606103f, -0.05633245f, 0.03961651f, 0.00645825f, -0.03896188f, 0.00445802f, -0.01080111f, 
    0.03580087f, -0.00997855f, -0.04770023f, 0.03230548f, -0.05949793f, -0.04379792f, -0.00975797f, 0.01324379f, 
    0.03761032f, -0.04053843f, 0.02040914f, -0.06952386f, 0.04526789f, -0.04668448f, 0.02839861f, -0.04358549f, 
    -0.01974975f, -0.05827582f, -0.00983537f, -0.04463800f, 0.03271215f, 0.01337871f, 0.04834183f, 0.04318913f, 
    -0.01860635f, -0.06139852f, 0.04263934f, -0.03552308f, 0.05003510f, -0.01594181f, 0.02720421f, 0.05715938f, 
    0.02126536f, 0.02232519f, -0.02527425f, 0.01781538f, -0.00890866f, -0.03225075f, 0.01309317f, -0.01716720f, 
    -0.02983656f, 0.01537761f, 0.00970929f, 0.00025769f, 0.02093577f, 0.04214430f, -0.01134466f, 0.03441098f, 
    -0.00487232f, -0.05989215f, -0.06233712f, -0.02217639f, -0.05722216f, -0.05376117f, -0.04866007f, 0.03090373f, 
    0.01372112f, -0.00918114f, -0.01172505f, 0.00710459f, 0.02962344f, -0.03248901f, -0.06661632f, 0.03079847f, 
    -0.02871100f, 0.04193611f, 0.00010553f, 0.02134667f, -0.06312701f, 0.02537605f, -0.00657345f, -0.03250211f, 
    0.00877605f, 0.05536035f, -0.00001345f, 0.00954381f, -0.04706641f, 0.04217450f, -0.05651224f, -0.02122982f, 
    0.02075405f, -0.01626181f, -0.05766828f, 0.00508618f, 0.01019033f, 0.02840518f, 0.03901337f, 0.03259479f, 
    0.01482153f, -0.03023693f, -0.00803847f, 0.01648153f, 0.03181224f, -0.04648330f, -0.05325036f, -0.05155834f, 
    0.04861284f, -0.00015810f, 0.02905906f, -0.01414606f, -0.05469769f, -0.01031360f, -0.02580069f, -0.01976153f, 
    -0.05714418f, -0.03317327f, -0.05929449f, -0.01044533f, 0.00573208f, -0.03733807f, -0.06802166f, 0.00126699f, 
    -0.05809459f, -0.03546735f, -0.00987820f, -0.05249489f, -0.00608981f, 0.01530572f, 0.00454359f, 0.03630603f, 
    0.03904935f, -0.03167040f, 0.01953987f, -0.06830766f, 0.00330541f, 0.04338563f, 0.01626910f, 0.01562279f, 
    0.03594786f, 0.00644111f, -0.03624022f, -0.02352376f, -0.06201916f, 0.04478369f, -0.05815574f, 0.03360004f, 
    0.01941460f, -0.04564981f, -0.01022709f, -0.02481041f, -0.01556670f, 0.03920833f, -0.04009329f, -0.05740660f, 
    0.01356238f, -0.00068290f, -0.05578526f, 0.01886589f, -0.03463408f, -0.02002566f, -0.04028023f, -0.05583201f, 
    0.01960467f, 0.01195525f, 0.03876050f, -0.06276278f, -0.04697885f, 0.00073997f, -0.06726113f, -0.00418630f, 
    0.01040134f, -0.00973558f, 0.03513170f, -0.01436868f, 0.03772303f, -0.04831068f, -0.02907787f, 0.04659077f, 
    -0.06273431f, -0.04782130f, -0.06201026f, 0.03932184f, -0.01692435f, -0.04387955f, -0.05156056f, -0.02937547f, 
    -0.05051073f, -0.01147581f, -0.01620638f, -0.03002671f, 0.04187273f, -0.05898159f, -0.01850347f, -0.00282795f, 
    0.02097441f, 0.02134085f, -0.05831013f, 0.02738888f, 0.01207269f, 0.04691539f, 0.04036060f, 0.04001303f, 
    -0.04756409f, -0.04624152f, -0.05626935f, -0.02944023f, 0.00178017f, -0.01807818f, 0.04723952f, 0.04337967f, 
    0.03578198f, -0.02141760f, 0.03788596f, -0.04028034f, -0.02675403f, -0.04950304f, -0.05496042f, -0.04613380f, 
    -0.01691582f, 0.04108256f, 0.02908977f, 0.02972586f, 0.03666726f, -0.04849201f, -0.01177817f, -0.04846958f, 
    -0.05839938f, -0.06062109f, 0.01239649f, -0.03041568f, 0.03524731f, -0.03190295f, 0.02247008f, 0.01406126f, 
    -0.00009831f, 0.04882267f, 0.05085743f, 0.02823685f, 0.03923474f, -0.06031068f, 0.03705176f, -0.05368199f, 
    -0.04588083f, 0.02410675f, 0.03873361f, -0.05814735f, -0.01700887f, -0.05261491f, 0.02011892f, 0.00696375f, 
    0.02665436f, -0.02558074f, -0.04818451f, 0.02936956f, -0.03481783f, -0.05731557f, -0.02136210f, 0.03295641f, 
    -0.00928465f, -0.04198856f, -0.01634277f, 0.02797326f, -0.04473629f, -0.04011331f, -0.05695553f, -0.04724634f, 
    -0.00301773f, 0.00071288f, -0.03375444f, 0.00158561f, 0.00198271f, -0.00433755f, 0.01852164f, 0.02807202f, 
    -0.00232026f, -0.01551931f, 0.02229867f, 0.04502874f, -0.03241440f, 0.03424109f, -0.06165783f, -0.03902896f, 
    -0.03119884f, -0.05918717f, 0.02601304f, -0.04062298f, -0.01418125f, -0.01313846f, 0.04645234f, -0.04444220f, 
    -0.05615244f, 0.04144115f, 0.02545169f, 0.01209879f, 0.03108410f, -0.03886279f, -0.05358791f, -0.05603337f, 
    -0.01594576f, -0.03261852f, 0.00821413f, 0.01271067f, 0.00058248f, 0.02076382f, -0.02403123f, -0.05647749f, 
    -0.02967984f, 0.00518729f, -0.00884686f, 0.00636018f, 0.01788166f, -0.01307066f, -0.03713824f, 0.03163489f, 
    -0.03461047f, -0.01549257f, 0.02973007f, -0.06497858f, 0.03888776f, 0.05518702f, 0.03894521f, -0.00673553f, 
    -0.01427173f, -0.02766974f, -0.04699601f, -0.06042584f, -0.06035785f, -0.03762389f, -0.05281471f, -0.02204582f, 
    -0.00321766f, 0.04663249f, 0.00887726f, -0.06049903f, 0.01896482f, 0.04436057f, -0.01043128f, -0.03939996f, 
    0.03617592f, -0.06328778f, 0.03110264f, 0.00986089f, -0.05141738f, 0.03564834f, 0.04958095f, -0.05535812f, 
    0.01515184f, -0.01779764f, 0.00129046f, -0.01615705f, -0.02936425f, 0.03066499f, -0.02948095f, -0.06040596f, 
    0.03831467f, 0.04268024f, -0.01552342f, -0.00675173f, 0.05299419f, -0.02280918f, -0.02828831f, -0.05003580f, 
    -0.05645500f, -0.06448017f, -0.00576830f, -0.01703860f, 0.01440965f, 0.04362863f, 0.01060009f, -0.05041461f, 
    -0.02762403f, -0.05166622f, 0.03428669f, 0.00329666f, 0.04310476f, -0.02956127f, -0.03518613f, 0.04455057f, 
    -0.02893682f, 0.02607005f, -0.00663189f, -0.05075996f, 0.01275705f, 0.02023038f, -0.01728592f, -0.03904748f, 
    -0.05098404f, -0.01989742f, 0.04056592f, -0.01759083f, 0.00792970f, 0.04881115f, 0.00917364f, 0.01511132f, 
    0.00020830f, 0.02248290f, -0.02283709f, 0.00335533f, -0.01646090f, -0.02622892f, -0.00617444f, -0.04294688f, 
    0.04654161f, -0.04003646f, -0.02963035f, 0.03572775f, -0.00704225f, -0.01647804f, 0.03953220f, -0.04955374f, 
    0.02201113f, -0.06053945f, -0.03462148f, -0.02491079f, 0.01001149f, -0.02411830f, 0.02783684f, 0.01903844f, 
    -0.02234105f, -0.06257081f, 0.04549415f, -0.01306043f, -0.02841729f, -0.01148920f, -0.06666184f, 0.04145303f, 
    0.03097039f, -0.02562419f, 0.00539874f, -0.05158040f, -0.01872081f, -0.04234064f, -0.00947436f, -0.05675586f, 
    0.02620924f, 0.03270885f, -0.02312619f, -0.01649927f, -0.03038016f, -0.01909395f, 0.00239870f, -0.02837860f, 
    0.02490114f, 0.04636927f, -0.04008215f, 0.01960662f, -0.06117544f, -0.04349322f, 0.03295431f, 0.02303814f, 
    -0.01986202f, 0.05023972f, 0.00887413f, -0.04691920f, -0.00364510f, 0.01516496f, -0.01613050f, -0.02264934f, 
    0.03060997f, 0.03946122f, 0.01482193f, -0.06185171f, 0.00336655f, 0.03871054f, -0.03805873f, 0.05464926f, 
    0.00140814f, 0.01814710f, -0.06636338f, 0.02080212f, -0.02555562f, -0.04438395f, -0.05031962f, -0.01033732f, 
    -0.05404340f, 0.22730842f, 0.05956220f, 0.06192811f, -0.09493658f, -0.08838412f, 0.02867362f, -0.01485799f, 
    0.12226893f, 0.52678400f, 0.20817633f, -0.10528714f, 0.10092734f, 0.14230880f, -0.03036966f, 0.14173386f, 
    0.06600844f, 0.07752451f, 0.47433344f, -0.01183833f, -0.07094738f, 0.08772849f, 0.00355894f, 0.02897503f, 
    0.13925767f, -0.10327837f, 0.06677306f, -0.05589717f, -0.13025801f, -0.00233185f, 0.11097457f, 0.06684083f, 
    0.16162001f, 0.01960283f, -0.17044786f, -0.05296575f, -0.17726386f, -0.19180450f, -0.10893413f, 0.06469930f, 
    -0.08204474f, 0.11066584f, -0.05946814f, 0.14657775f, 0.10964149f, -0.30611500f, 0.18915860f, 0.11252411f, 
    -0.11711438f, -0.02757225f, -0.02245790f, 0.08136886f, 0.09384929f, -0.07513360f, -0.27515703f, 0.00203002f, 
    -0.04819490f, 0.09308401f, -0.17079228f, 0.14435357f, -0.13390285f, 0.08474480f, 0.03210898f, -0.00839642f, 
    -0.15917020f, -0.07445506f, 0.09017525f, 0.07769531f, 0.12663184f, -0.08864394f, -0.16865996f, -0.18086058f, 
    -0.03001492f, -0.00996545f, -0.03156902f, -0.20933560f, -0.10494371f, -0.14150727f, -0.41240764f, 0.07570709f, 
    0.09077851f, 0.04308062f, 0.23373809f, -0.21953824f, 0.03679866f, 0.14604220f, 0.10353865f, -0.15332380f, 
    -0.06814761f, -0.17640574f, -0.40218565f, -0.08276222f, 0.22298490f, -0.14673227f, -0.10821310f, 0.00782959f, 
    -0.11267684f, -0.09675287f, 0.05185121f, -0.06515034f, -0.21657385f, -0.01874614f, -0.01776542f, -0.01359755f, 
    0.09941166f, -0.18652581f, 0.02049539f, 0.02770953f, 0.11774398f, 0.13481188f, 0.00503071f, -0.02332460f, 
    -0.05902245f, 0.01020352f, 0.05670944f, 0.12113842f, 0.03229302f, -0.24168490f, -0.35039264f, -0.24486150f, 
    0.01199641f, 0.15424520f, 0.12618314f, 0.05166409f, -0.12435287f, 0.18226823f, 0.08393793f, 0.07652729f, 
    -0.21275073f, 0.06567107f, 0.15911277f, 0.00078289f, 0.13325503f, 0.08019244f, -0.10712022f, -0.03067168f, 
    -0.20416453f, -0.04398609f, 0.01778929f, -0.02707145f, 0.16945542f, -0.32582584f, 0.14756386f, 0.05332494f, 
    -0.10727271f, -0.17830130f, -0.03167311f, 0.14167468f, -0.05177543f, -0.01294337f, -0.11803672f, 0.04098345f, 
    0.09809794f, -0.04057669f, -0.10793145f, -0.44986373f, 0.24357852f, -0.08177748f, -0.02937348f, 0.06401384f, 
    0.02124495f, -0.24459049f, -0.14022502f, 0.08839796f, 0.07209070f, 0.00280241f, -0.05510713f, 0.00185368f, 
    -0.09658615f, 0.01589097f, 0.08435290f, -0.23700045f, 0.06900712f, 0.01411746f, 0.11266296f, -0.04010452f, 
    0.05711741f, 0.15200721f, 0.05389554f, 0.05309495f, -0.11911266f, 0.05752490f, -0.00038530f, -0.01414796f, 
    0.09423270f, 0.14452051f, 0.03341829f, -0.11800840f, 0.15079425f, 0.24227636f, -0.08569160f, -0.16471897f, 
    0.01083515f, 0.04735328f, -0.01410392f, 0.01339452f, -0.06878131f, 0.05966905f, -0.04249624f, 0.05209540f, 
    -0.08923680f, 0.02047947f, 0.02993315f, 0.11391928f, 0.04883964f, -0.04810290f, 0.03534967f, 0.41321999f, 
    0.04669189f, 0.07732436f, 0.22294000f, 0.02845623f, -0.11197627f, 0.27831474f, 0.10766464f, -0.11553825f, 
    -0.20285991f, 0.02981981f, -0.02947272f, -0.10148454f, -0.09319413f, 0.14088659f, -0.08917884f, -0.01905183f, 
    -0.01032419f, -0.34964982f, -0.12294880f, -0.09332782f, 0.05413451f, -0.03611754f, 0.11220418f, 0.00895854f, 
    0.00820658f, -0.06896076f, -0.08524213f, 0.13196297f, 0.13728000f, 0.06194650f, 0.16244952f, 0.02883646f, 
    0.09028822f, -0.07487263f, 0.05396608f, 0.12625732f, 0.02523282f, -0.13833869f, 0.11350615f, -0.01629007f, 
    -0.10458311f, -0.05014828f, 0.03696669f, -0.05406193f, 0.16549946f, 0.09823769f, -0.32891995f, 0.04897511f, 
    0.05296095f, -0.06152129f, 0.07313193f, -0.08778914f, -0.00098453f, 0.34903356f, 0.13184811f, -0.02353889f, 
    0.03624827f, 0.07081029f, 0.09677840f, 0.12580498f, 0.10402503f, 0.11656316f, 0.58764261f, -0.00784894f, 
    -0.12214593f, 0.06383778f, -0.05351122f, -0.08306925f, 0.01147861f, 0.00616348f, 0.04783326f, -0.42816919f, 
    0.15346672f, -0.25801528f, -0.04747393f, 0.02281271f, 0.25471684f, -0.03518805f, -0.12355925f, -0.15406305f, 
    0.17321923f, -0.00752959f, 0.08059804f, 0.06973675f, -0.14965455f, 0.09651253f, 0.04991714f, -0.18716928f, 
    0.23123108f, -0.05723133f, -0.00924585f, 0.25778899f, 0.07599019f, -0.01111803f, -0.05168845f, -0.06754761f, 
    -0.14628856f, -0.04697791f, -0.19590285f, 0.07406839f, 0.12239230f, -0.04469703f, -0.15904760f, -0.09708204f, 
    -0.03054856f, -0.18726075f, 0.04072820f, -0.06129584f, -0.09846598f, -0.30249372f, 0.08547299f, -0.05911325f, 
    0.05506905f, 0.16728698f, 0.17544754f, -0.22005376f, -0.08299926f, -0.02371832f, -0.05348885f, 0.08816786f, 
    -0.02786568f, 0.11657859f, -0.00441453f, -0.09173916f, -0.07614437f, -0.00756574f, -0.03774191f, -0.08256843f, 
    0.01346154f, 0.20813875f, 0.07023130f, 0.15355432f, -0.00267772f, -0.19284730f, 0.07429186f, -0.06903856f, 
    0.03961429f, 0.09374996f, -0.17919169f, -0.03392251f, 0.05534071f, -0.00104888f, 0.13299419f, 0.03252732f, 
    0.06950066f, -0.08918799f, 0.08357158f, -0.00023032f, -0.17958222f, 0.18942706f, -0.15710904f, -0.28532484f, 
    0.13563502f, 0.31475249f, 0.00139605f, -0.18442447f, -0.29027134f, -0.17774834f, 0.04862657f, 0.01927857f, 
    0.18458553f, -0.20532875f, 0.03276419f, 0.01495228f, 0.08578073f, -0.01145498f, -0.12698193f, -0.04536498f, 
    -0.00278104f, 0.12479070f, -0.05996148f, -0.11569153f, -0.02080272f, 0.00590016f, 0.03194855f, 0.24687499f, 
    0.05906321f, -0.10730010f, -0.07763379f, 0.08133970f, 0.12644777f, -0.04623427f, -0.04179975f, 0.04058741f, 
    0.27575597f, 0.12477948f, 0.06500509f, 0.11231630f, -0.00907775f, 0.01013292f, 0.23973361f, -0.14202805f, 
    0.03721204f, 0.05379121f, -0.07912422f, 0.19720499f, 0.07706868f, -0.16789700f, -0.01671963f, -0.00063111f, 
    0.12075634f, -0.08849371f, 0.17326580f, 0.01893000f, 0.12506361f, -0.32458073f, 0.01650457f, 0.02182793f, 
    0.10751710f, -0.14193082f, 0.14980425f, -0.09093326f, 0.02422172f, 0.20788445f, 0.00483301f, -0.20673421f, 
    -0.21559572f, -0.14692070f, -0.08037426f, -0.12663089f, -0.07916575f, -0.03193762f, 0.15269993f, -0.15524328f, 
    -0.05700876f, 0.00586963f, -0.11427377f, -0.06796639f, 0.13514860f, -0.03944352f, 0.01201142f, 0.02678447f, 
    -0.08263794f, 0.12763768f, -0.13286330f, 0.06730383f, 0.01838170f, -0.01384449f, -0.11269630f, 0.12394675f, 
    -0.05641143f, -0.04693459f, 0.10780978f, -0.19997682f, 0.05633307f, -0.04266629f, -0.01667106f, 0.10542541f, 
    -0.04537812f, -0.07526415f, 0.14557916f, 0.20954956f, 0.04429704f, -0.07830063f, -0.12456688f, 0.11275536f, 
    0.00962892f, 0.09562116f, 0.08509071f, -0.06146357f, 0.14294493f, 0.03676834f, 0.01517870f, -0.28814489f, 
    -0.23035012f, 0.00044668f, 0.05296154f, 0.19871962f, 0.19574925f, 0.14850317f, 0.08554292f, -0.21615949f, 
    0.04779223f, 0.01600517f, 0.09639824f, -0.03576352f, 0.05297646f, -0.22960006f, 0.08552961f, -0.03696008f, 
    0.01853193f, 0.04985039f, 0.14007735f, -0.03653050f, -0.05783285f, -0.00538474f, -0.04670739f, -0.17151016f, 
    0.00319081f, 0.11381246f, -0.02151832f, 0.12213609f, -0.23789169f, 0.01911843f, -0.04001117f, -0.25412571f, 
    0.12465270f, -0.01557937f, 0.02619040f, 0.14631809f, -0.15215676f, -0.04021950f, 0.07077067f, -0.05885889f, 
    0.12774217f, -0.00541442f, -0.20100144f, -0.28567064f, -0.02510121f, 0.10028411f, 0.03256910f, 0.04341156f, 
    -0.00282996f, -0.20485039f, -0.10685316f, -0.01448551f, -0.01841571f, 0.00802064f, 0.03791950f, 0.04043821f, 
    0.04925131f, 0.16655792f, -0.05345128f, 0.10261623f, 0.07665747f, 0.34815380f, -0.07322355f, -0.03647196f, 
    0.06186992f, -0.02766442f, 0.18028891f, 0.14237270f, 0.12481638f, 0.11401749f, 0.05643089f, 0.09423413f, 
    -0.04808799f, -0.31878948f, -0.00749638f, 0.07148892f, 0.17736408f, 0.00653137f, 0.06815398f, -0.01621465f, 
    0.07673433f, -0.00915654f, 0.02835626f, 0.16103356f, 0.18637031f, 0.05014218f, -0.19295010f, 0.25896055f, 
    0.04617376f, 0.14372805f, -0.16921188f, -0.22135860f, 0.06646149f, -0.03200649f, 0.11901935f, -0.09436947f, 
    0.24098507f, -0.19196814f, -0.03373971f, 0.14635865f, 0.20525436f, 0.21283175f, 0.14650327f, -0.01689014f, 
    0.05853503f, 0.07150032f, 0.28356186f, 0.22651225f, 0.08513543f, -0.07872590f, 0.01475607f, -0.06756853f, 
    -0.02113750f, 0.19930820f, -0.11732094f, -0.07935479f, 0.09566810f, -0.03523298f, 0.03052425f, -0.13084815f, 
    -0.02903624f, 0.02580725f, -0.12023596f, -0.11169021f, 0.09641708f, 0.19312546f, -0.22973292f, 0.01395462f, 
    -0.12528841f, -0.09697219f, -0.02224083f, 0.08843172f, -0.06475630f, 0.03812824f, -0.12867549f, -0.03224309f, 
    -0.10242522f, -0.11120950f, 0.02609408f, -0.24559401f, -0.18871830f, 0.12112740f, 0.07634471f, -0.08416036f, 
    -0.26452655f, 0.08537821f, 0.04065456f, -0.12491787f, -0.05502874f, 0.04783691f, 0.00617054f, -0.05784784f, 
    0.05026608f, -0.06967413f, 0.16049711f, -0.03353117f, 0.07742383f, 0.20188747f, -0.00851816f, 0.01766525f, 
    0.17723311f, -0.01426052f, 0.02104480f, 0.02425541f, -0.12129384f, 0.06938965f, 0.07430902f, 0.06843860f, 
    -0.03048337f, 0.01415003f, -0.00246187f, -0.09759293f, 0.02785255f, 0.13831691f, 0.07445414f, 0.16665109f, 
    0.00257069f, 0.17237933f, 0.13190366f, -0.04338558f, 0.01583352f, -0.11901858f, 0.02959015f, -0.17809510f, 
    -0.02817631f, -0.26890975f, 0.09572372f, -0.03046086f, 0.00219292f, -0.01652946f, -0.11392546f, -0.12793764f, 
    0.01845494f, 0.01675097f, -0.00767317f, -0.08412091f, 0.24389730f, -0.06735629f, 0.11277176f, 0.03818400f, 
    -0.05771221f, -0.02859225f, -0.15024543f, -0.03436777f, 0.02969240f, -0.03036813f, -0.03932451f, -0.00636370f, 
    -0.02278347f, 0.19150446f, -0.12468507f, -0.08925434f, 0.06755733f, -0.03237559f, 0.25307396f, -0.18866007f, 
    0.08512023f, 0.01501135f, 0.07009996f, 0.05058023f, -0.05460519f, -0.01870617f, 0.21962148f, 0.21437427f, 
    0.18874183f, -0.09652950f, 0.07807440f, 0.09448300f, 0.20376416f, -0.08660130f, 0.15504643f, -0.00526801f, 
    0.07631070f, -0.13687095f, 0.05397333f, 0.01444083f, -0.03238055f, 0.10999440f, -0.18465103f, -0.13991737f, 
    0.20095706f, 0.37061772f, -0.07377358f, 0.10479367f, -0.09981865f, -0.00400055f, 0.13264968f, 0.10109825f, 
    0.18178482f, 0.01794825f, -0.10666935f, -0.04773149f, -0.00062343f, 0.03770766f, -0.04122574f, -0.08152170f, 
    -0.13726361f, 0.34457186f, 0.05293665f, -0.05014103f, -0.02186783f, -0.07697410f, -0.14097428f, 0.08563336f, 
    0.03439905f, 0.03017553f, 0.09154785f, 0.00673058f, 0.26937127f, 0.01405224f, 0.09495228f, 0.22018814f, 
    0.07514423f, 0.02423983f, 0.01358242f, 0.05827264f, 0.09455775f, -0.23471071f, -0.18408979f, -0.07697307f, 
    -0.03239181f, -0.07086322f, -0.06787204f, -0.00352494f, 0.08966449f, 0.19884944f, -0.02021893f, 0.24380916f, 
    -0.10147300f, 0.09071997f, 0.07204345f, 0.00116133f, 0.04617198f, 0.16605833f, 0.00691930f, -0.12859543f, 
    0.02892531f, -0.07357180f, -0.03351767f, -0.03204961f, 0.03027275f, 0.04738896f, 0.02201877f, 0.06910894f, 
    0.01495530f, 0.14086889f, -0.04665529f, 0.11977404f, 0.13412578f, -0.11205012f, -0.13846698f, -0.20439528f, 
    0.14493319f, -0.08823672f, 0.00740115f, 0.08297470f, -0.04289168f, 0.01714226f, 0.08951455f, 0.09376678f, 
    -0.06987483f, 0.00058317f, 0.20962626f, 0.02206116f, -0.09547275f, 0.00447119f, -0.11470295f, 0.06992895f, 
    0.09501556f, 0.01310885f, -0.06496310f, -0.26673722f, -0.00815899f, -0.08557322f, 0.04608798f, -0.09268376f, 
    -0.01940424f, -0.00229477f, -0.01661141f, 0.02039399f, -0.01790029f, -0.28375807f, -0.05498918f, 0.02357065f, 
    0.07825950f, -0.01941981f, 0.03704719f, -0.17199834f, 0.06256575f, -0.06108795f, -0.05616878f, -0.06362200f, 
    -0.04620441f, -0.02749617f, 0.03336333f, -0.06457858f, -0.34881809f, -0.02803311f, -0.08092967f, 0.14367285f, 
    -0.10576931f, 0.02307419f, -0.08256721f, -0.05054828f, 0.00326157f, -0.09295131f, -0.08126813f, -0.15862113f, 
    0.04050498f, -0.03603931f, -0.00128799f, -0.04259754f, 0.01927887f, -0.02983772f, 0.14882337f, -0.02416188f, 
    0.03494438f, 0.02387159f, 0.10902640f, -0.12884670f, -0.18610689f, 0.00355567f, -0.07679729f, 0.13430166f, 
    0.03620052f, -0.12638384f, -0.10833974f, 0.00192941f, 0.15611790f, -0.01792080f, 0.12513131f, 0.18049134f, 
    0.00405712f, 0.01346633f, -0.03189538f, 0.00083789f, 0.03047934f, -0.03307392f, -0.05758084f, -0.00741281f, 
    -0.01428993f, -0.05505942f, 0.04858239f, -0.04817520f, 0.01931757f, -0.02146874f, 0.00974746f, 0.00935779f, 
    -0.01772358f, 0.01171831f, -0.00122701f, 0.04774800f, 0.04402982f, -0.00728445f, -0.05990157f, -0.01968048f, 
    -0.05203310f, 0.02006574f, 0.01946547f, -0.05597388f, -0.01410828f, 0.02148909f, -0.00345676f, -0.03220370f, 
    -0.05099392f, -0.05160115f, -0.02581383f, 0.01631626f, -0.03841422f, 0.01002486f, -0.02288791f, 0.04472898f, 
    -0.04356892f, -0.03136934f, -0.01250674f, -0.02625361f, -0.05090838f, -0.00046623f, 0.01593665f, -0.02848396f, 
    -0.04335165f, -0.01123628f, 0.03175460f, 0.04267141f, 0.00683256f, -0.01177833f, -0.04689635f, 0.03180281f, 
    0.04391881f, 0.05865915f, -0.01189614f, -0.00887831f, 0.05609072f, -0.03121202f, 0.01328710f, -0.05993676f, 
    -0.01110639f, 0.00731906f, -0.04813531f, -0.04356471f, -0.00501957f, 0.03159148f, 0.03220784f, 0.05789814f, 
    -0.03299041f, -0.03906212f, -0.01072465f, -0.02150987f, 0.01742653f, 0.04634811f, 0.05015970f, -0.00372410f, 
    0.03761113f, -0.04012913f, 0.00462090f, -0.00771968f, 0.01142017f, 0.02990743f, 0.02493427f, -0.05183497f, 
    0.05316743f, 0.00503579f, 0.04862106f, -0.05850630f, 0.00804827f, -0.04752216f, 0.01682832f, 0.01157965f, 
    0.01187991f, -0.00322840f, 0.01506150f, 0.01265506f, 0.03648539f, -0.04603723f, -0.03510005f, 0.00766024f, 
    -0.01274444f, 0.02205358f, 0.05338630f, 0.03882138f, -0.04978941f, 0.04954790f, -0.02720735f, -0.05705566f, 
    0.00635095f, -0.00752021f, 0.01617043f, 0.01135569f, -0.02173794f, -0.05301630f, 0.03000960f, 0.01322910f, 
    -0.02547552f, -0.05944785f, 0.04579766f, -0.02202578f, -0.02145919f, -0.02187495f, 0.02883423f, -0.06105703f, 
    0.03409447f, -0.01237445f, -0.03981676f, 0.02774722f, 0.04420706f, 0.04367113f, -0.05176844f, -0.00646139f, 
    0.03480394f, -0.06309579f, 0.00454737f, -0.00736349f, 0.01199994f, 0.02184922f, -0.01650779f, -0.04301079f, 
    0.05795245f, -0.02548802f, 0.04000341f, -0.05433438f, -0.05045483f, -0.00396557f, -0.04589954f, -0.05938073f, 
    0.01789158f, -0.02794736f, -0.00314144f, -0.04448165f, -0.03537506f, -0.00737547f, -0.02569308f, 0.03966563f, 
    -0.01037159f, 0.00901330f, 0.02359180f, 0.03204297f, -0.00669869f, 0.02422009f, -0.01775984f, 0.03173798f, 
    0.03042906f, -0.05309021f, -0.02645846f, 0.00420728f, -0.04476682f, -0.01789694f, -0.03776271f, -0.04073020f, 
    -0.01261852f, -0.04230471f, -0.02896652f, -0.00817436f, 0.03731084f, 0.00674793f, 0.05277740f, -0.04750161f, 
    -0.05284106f, 0.02640124f, -0.04424126f, -0.04796693f, 0.04039587f, -0.01134375f, -0.00328575f, 0.02632487f, 
    -0.01689125f, 0.05469472f, 0.00481525f, -0.05191582f, 0.02028998f, 0.00557412f, 0.04691908f, -0.04974905f, 
    0.02991119f, -0.00927893f, 0.00085214f, -0.00046405f, -0.02795220f, -0.04535821f, -0.02390087f, 0.00522839f, 
    -0.06151306f, -0.05068582f, 0.02938274f, 0.02036284f, -0.05304886f, 0.05098656f, -0.03930524f, -0.02342475f, 
    -0.00672218f, 0.00636334f, -0.05675138f, 0.00275071f, 0.02344340f, -0.00800284f, 0.01165624f, 0.04779093f, 
    -0.00075196f, 0.00298365f, 0.01705264f, 0.02986533f, -0.04653816f, -0.05190463f, 0.00770155f, -0.04333306f, 
    0.00374516f, -0.05216278f, -0.01007883f, -0.00464149f, -0.04773076f, -0.02647706f, -0.01350980f, 0.01278247f, 
    -0.04302618f, -0.04918577f, -0.00931486f, -0.04801919f, -0.04774374f, 0.04839503f, -0.00637068f, 0.01408625f, 
    -0.04564299f, 0.04022377f, 0.04222030f, 0.03552526f, 0.02543757f, 0.04667085f, -0.01394401f, 0.00041731f, 
    -0.00937215f, -0.01287923f, -0.00225030f, 0.05452462f, -0.01894737f, -0.04828235f, 0.00697685f, -0.03066946f, 
    -0.00255303f, 0.05294276f, 0.00478716f, -0.02760885f, -0.05310361f, 0.01765823f, -0.02149637f, 0.00102962f, 
    -0.00044355f, -0.02900876f, -0.00819034f, -0.02753619f, -0.03689523f, 0.02671247f, -0.05810392f, -0.01481429f, 
    -0.05011937f, 0.00443072f, 0.01791269f, -0.00156278f, -0.05349172f, 0.03368102f, 0.04866587f, 0.03646628f, 
    0.04276998f, 0.01568084f, 0.03344055f, 0.01762370f, -0.04647502f, 0.03441927f, 0.00621998f, -0.06034129f, 
    -0.03932306f, -0.02012322f, -0.04196402f, 0.01335157f, -0.05933673f, -0.01862606f, 0.05816893f, -0.03441424f, 
    0.04100112f, -0.05469586f, 0.00742466f, -0.00816137f, 0.04814290f, 0.05115316f, -0.02968651f, -0.03083468f, 
    -0.00136961f, -0.03944091f, 0.04018322f, -0.04019477f, -0.02769686f, -0.02891903f, -0.05226705f, 0.00287746f, 
    -0.02076504f, 0.03253578f, 0.04169427f, -0.04023803f, -0.03443946f, 0.00421421f, 0.03849636f, 0.04077457f, 
    0.02650889f, 0.02868325f, 0.05077156f, 0.04949784f, -0.03303196f, -0.03284270f, -0.05479723f, -0.05066511f, 
    0.03459032f, 0.00657673f, -0.03249679f, -0.04021248f, -0.04852244f, 0.01460016f, -0.03821929f, 0.03791400f, 
    0.00399155f, 0.02562127f, -0.00949716f, 0.02480358f, -0.02967959f, 0.04286317f, 0.03234509f, -0.00116743f, 
    -0.04024287f, 0.01929218f, -0.03584312f, 0.00784386f, -0.01464927f, 0.03492007f, 0.03084138f, 0.03518905f, 
    0.01591074f, -0.03176689f, -0.01008718f, 0.01950166f, 0.00904614f, 0.04614426f, 0.05228055f, 0.00211627f, 
    -0.05925121f, -0.02876222f, 0.00559964f, -0.02851400f, 0.04651859f, 0.00413092f, -0.00664550f, 0.03912040f, 
    -0.02455870f, -0.05860538f, 0.03049343f, -0.02930735f, 0.03295752f, -0.01400687f, 0.05020123f, 0.03383274f, 
    0.02461071f, -0.04334040f, -0.04886703f, 0.01052435f, -0.01906972f, -0.01533274f, -0.03499310f, -0.04357500f, 
    0.02888209f, -0.05577112f, -0.00300305f, -0.04226045f, -0.05793014f, 0.01940102f, 0.05829449f, -0.02446117f, 
    -0.04864601f, -0.00173516f, 0.00680166f, -0.05945181f, 0.04031312f, -0.03263468f, 0.03067813f, 0.03680672f, 
    0.02602925f, -0.00325748f, -0.05221196f, -0.05044368f, -0.05740233f, -0.03636356f, -0.03857408f, 0.05820132f, 
    -0.00127724f, -0.02454919f, -0.03335407f, 0.01132006f, -0.04904489f, 0.03241514f, 0.02819290f, -0.04937652f, 
    0.06085562f, -0.02138579f, -0.02870906f, 0.02203450f, 0.04711201f, -0.05759311f, -0.02718964f, -0.00272080f, 
    -0.02720287f, -0.00409259f, -0.05526302f, 0.01129451f, -0.04549711f, 0.01300039f, -0.04120190f, 0.02274820f, 
    0.04180524f, -0.01550134f, 0.03400901f, 0.02415845f, 0.01841700f, -0.04132802f, -0.06385641f, 0.02952588f, 
    -0.04064338f, -0.04214015f, -0.01214093f, -0.02713717f, -0.01246228f, -0.04898229f, 0.01082776f, -0.02450672f, 
    -0.03324601f, 0.00964155f, 0.03371549f, -0.05367796f, -0.05973060f, -0.03866477f, -0.02896166f, 0.03722287f, 
    -0.05011201f, -0.01815730f, -0.03614651f, 0.02234968f, -0.01009031f, 0.03761803f, 0.05408634f, 0.05485984f, 
    0.01951578f, 0.03800181f, -0.01718265f, 0.03665487f, -0.01500657f, -0.04176721f, -0.02042579f, 0.03431873f, 
    0.00667606f, 0.04998992f, 0.00545227f, -0.05824805f, 0.01397601f, -0.00935185f, -0.02337105f, 0.06403718f, 
    -0.04825837f, -0.06290532f, 0.03723395f, -0.05269882f, 0.00351085f, 0.01394760f, 0.04165833f, -0.01414385f, 
    -0.02162439f, 0.04779578f, 0.03753596f, 0.03448927f, 0.01083189f, -0.06840559f, -0.05047845f, -0.02003735f, 
    -0.01041202f, -0.05576758f, -0.02227332f, 0.01427533f, 0.03431043f, -0.04368264f, 0.03708006f, -0.01449647f, 
    -0.05996902f, 0.00456166f, -0.02814413f, -0.00457365f, 0.00680121f, -0.03911331f, 0.01884270f, 0.01440790f, 
    0.01123543f, 0.04650236f, -0.02553057f, 0.00950913f, -0.06188504f, -0.03108643f, -0.04220529f, 0.04334816f, 
    0.05352927f, -0.05993038f, 0.04459021f, 0.02060610f, 0.01999627f, -0.03374274f, 0.01606149f, -0.01931929f, 
    0.04786872f, -0.03413280f, -0.04499488f, -0.01454422f, 0.01831500f, -0.04625436f, 0.00328875f, 0.02377738f, 
    -0.01209135f, -0.00089220f, 0.03273827f, -0.04744815f, -0.04687821f, 0.03578875f, -0.03534453f, -0.00351507f, 
    -0.01243122f, 0.02539196f, -0.04160184f, -0.05137310f, -0.00081601f, -0.04441838f, -0.05891647f, -0.02178848f, 
    -0.00155101f, -0.05321903f, -0.06348781f, 0.01736425f, 0.03417181f, 0.00353055f, -0.01548052f, 0.04912249f, 
    0.05677671f, 0.01323163f, 0.01606870f, 0.02211940f, -0.02378632f, -0.02346574f, -0.01677851f, -0.04942412f, 
    0.04947181f, -0.01244816f, 0.01859776f, 0.01682987f, -0.05548029f, 0.01105994f, -0.00978725f, -0.00512811f, 
    -0.01705189f, -0.01342377f, -0.06488783f, 0.03724436f, -0.01219895f, -0.01517367f, 0.05149435f, -0.01833341f, 
    0.01663258f, -0.02353597f, -0.04863878f, -0.06127688f, -0.00123912f, 0.04081214f, -0.05126902f, -0.00827143f, 
    -0.04289868f, 0.00816629f, -0.00393461f, -0.00906575f, 0.02602256f, 0.03010087f, -0.02897805f, -0.04726811f, 
    -0.01395874f, -0.04653238f, 0.04332701f, -0.06316024f, -0.04020336f, 0.00882460f, 0.03577350f, 0.01493558f, 
    -0.06203531f, -0.03713036f, -0.02558246f, -0.06278192f, -0.04505450f, -0.05187034f, -0.03561724f, -0.00482011f, 
    0.02927961f, -0.02731540f, -0.03248657f, 0.01006731f, 0.01821790f, 0.04479698f, 0.00609918f, 0.02541400f, 
    -0.06284074f, -0.04647760f, -0.06041145f, -0.06311921f, -0.02511446f, -0.04181524f, -0.00995898f, -0.01811239f, 
    0.00584088f, -0.01943376f, -0.04721959f, -0.02435043f, 0.04171297f, 0.01481880f, 0.03363783f, 0.01161889f, 
    0.00828152f, 0.01213957f, 0.03387612f, -0.01214080f, -0.01285548f, 0.01550634f, -0.06250393f, -0.00763839f, 
    -0.06007205f, -0.05923782f, 0.04561500f, 0.03268089f, -0.06075547f, -0.02931883f, -0.01744685f, 0.04376868f, 
    0.00922520f, 0.04746620f, -0.04018164f, -0.06259797f, 0.04613360f, -0.04841641f, -0.05905914f, 0.00522631f, 
    0.04227877f, -0.01501542f, 0.03527733f, 0.01301333f, 0.01290438f, 0.05092658f, 0.01392078f, 0.00512096f, 
    -0.00260622f, -0.01075976f, 0.01828897f, 0.02357643f, -0.04470003f, -0.01264570f, -0.02412220f, -0.06483258f, 
    -0.03408545f, -0.04085928f, -0.00148276f, 0.03770686f, 0.00321714f, -0.01632636f, -0.04060051f, 0.03071259f, 
    -0.03387209f, -0.05789166f, 0.00416160f, 0.02964278f, -0.04497834f, -0.04958462f, -0.05798439f, 0.02484239f, 
    -0.03232757f, -0.00866151f, -0.00819478f, -0.00270141f, 0.01444582f, 0.01795666f, -0.04595103f, -0.01682703f, 
    -0.05972619f, 0.00203899f, -0.01541331f, 0.01010040f, -0.00096532f, -0.05000615f, -0.01876644f, -0.05898303f, 
    -0.05529161f, -0.02537761f, -0.03569824f, 0.03658758f, 0.05287160f, 0.01454389f, 0.03298562f, -0.02886998f, 
    -0.05672957f, -0.01149356f, 0.03728229f, 0.00619519f, -0.02975894f, -0.04809346f, 0.04285864f, -0.01358688f, 
    0.00307444f, -0.04774829f, 0.04832200f, 0.05239996f, -0.01369646f, 0.02166613f, -0.05507428f, -0.04665052f, 
    -0.05652588f, -0.02283633f, -0.00946494f, 0.00887022f, -0.01633143f, 0.01400973f, -0.05118721f, -0.01739622f, 
    -0.01084909f, -0.03806369f, -0.05164894f, 0.01396400f, -0.05892189f, 0.04344790f, 0.02059149f, -0.01485344f, 
    -0.02524373f, 0.00058719f, 0.05044343f, -0.02408674f, -0.00037614f, 0.04429906f, -0.04851292f, -0.05415926f, 
    -0.00344640f, -0.00468385f, -0.04076263f, -0.04294995f, 0.05173544f, 0.03168528f, 0.02647872f, 0.00297329f, 
    0.03823001f, -0.06066870f, -0.05094757f, -0.00992253f, -0.04012308f, 0.05228619f, 0.01125439f, -0.04138048f, 
    0.01600577f, -0.06133843f, -0.05888613f, 0.05212217f, -0.03555485f, 0.03704385f, 0.00308857f, 0.05048449f, 
    0.05093186f, 0.04538367f, -0.04262644f, -0.04898451f, 0.02335109f, -0.02352626f, 0.05214847f, -0.02546799f, 
    -0.04221784f, -0.05251832f, -0.03413949f, 0.03456102f, -0.03371205f, -0.00738938f, -0.00803987f, -0.04719324f, 
    0.02370471f, 0.04255600f, 0.04922195f, -0.05735916f, -0.03125608f, -0.01783023f, -0.00931301f, -0.00090822f, 
    -0.01334934f, 0.02169587f, -0.01607337f, 0.02012484f, -0.01630534f, -0.06339791f, 0.03852896f, -0.00293252f, 
    -0.05032278f, -0.00403493f, 0.01651715f, 0.01380394f, -0.05778177f, -0.03847390f, -0.01669087f, -0.01491615f, 
    -0.04706304f, 0.04151480f, 0.01355167f, -0.01378404f, 0.00200041f, -0.02260199f, -0.04797323f, -0.05956197f, 
    0.05005007f, -0.05551510f, 0.04595944f, -0.04625585f, -0.04359402f, -0.02229105f, 0.04854488f, -0.02956219f, 
    -0.02224817f, -0.02677058f, -0.05146125f, 0.02455508f, -0.04193378f, -0.05259707f, -0.00015035f, 0.01058717f, 
    0.00523217f, -0.02820235f, -0.00013167f, 0.04136873f, 0.00888756f, -0.03133305f, -0.03231685f, 0.04442225f, 
    0.04519033f, 0.06415521f, -0.30009031f, 0.22729443f, -0.14939962f, 0.19948074f, 0.07474910f, -0.07328174f, 
    -0.08081243f, -0.13983972f, -0.08737754f, -0.00416973f, 0.17042272f, -0.10909875f, 0.02008088f, -0.05827108f, 
    0.01314061f, -0.00007046f, 0.07279354f, 0.03602356f, 0.07760752f, 0.00323502f, 0.07247005f, 0.00075640f, 
    0.04149257f, -0.09983242f, 0.22540694f, -0.04390169f, 0.16124980f, 0.06261328f, 0.07656655f, -0.04635530f, 
    -0.03245867f, 0.02543762f, 0.07345463f, 0.22808723f, -0.00398380f, -0.15633503f, -0.15398780f, -0.07056981f, 
    -0.09402466f, -0.03100663f, 0.08892594f, 0.13956100f, 0.08523422f, -0.01272037f, 0.01284424f, -0.08238380f, 
    0.16865414f, -0.07521679f, -0.31355980f, 0.08066339f, 0.07199389f, 0.20478523f, 0.05318127f, 0.06367749f, 
    -0.01450759f, 0.02444001f, 0.08681405f, 0.05527791f, 0.06209147f, 0.01084113f, -0.08921196f, 0.07231458f, 
    0.00351081f, 0.13884667f, -0.18456338f, 0.00189870f, 0.02134682f, -0.01969223f, -0.03157847f, -0.03226494f, 
    -0.17830005f, -0.27774566f, -0.04517318f, 0.07671724f, -0.00543601f, -0.02399358f, 0.00807756f, -0.04851454f, 
    -0.17752926f, 0.09151151f, 0.08054367f, 0.07222033f, 0.01304828f, 0.00827881f, 0.12514946f, -0.01121410f, 
    -0.07579748f, 0.08239932f, 0.11363191f, -0.00612291f, -0.13253050f, -0.04721849f, 0.02111230f, -0.07191209f, 
    -0.04038905f, 0.04564948f, -0.03851962f, -0.04863574f, -0.20778094f, -0.08237743f, 0.02838051f, -0.08930404f, 
    -0.07737733f, 0.01186276f, 0.01142709f, -0.11442296f, -0.06953883f, 0.07308248f, 0.00591860f, 0.21748622f, 
    0.06151348f, 0.07986723f, -0.07729775f, -0.08593342f, -0.00986154f, 0.11075047f, -0.10022540f, -0.05425660f, 
    0.04789564f, -0.14147075f, -0.29984164f, -0.03614511f, -0.02369755f, -0.05942671f, -0.00265473f, -0.10215387f, 
    -0.26687708f, 0.06877390f, 0.12963572f, -0.02981965f, -0.03523687f, -0.10698262f, 0.00840763f, 0.08844837f, 
    -0.01602951f, -0.04012839f, -0.14542077f, 0.03725787f, -0.15836404f, 0.10997300f, 0.00717070f, -0.05318743f, 
    -0.09558488f, 0.15213914f, 0.01840988f, 0.02050123f, 0.01858424f, -0.06989337f, 0.09068645f, 0.09298443f, 
    0.20330605f, 0.03853932f, 0.03353935f, 0.01001026f, 0.13079128f, -0.04720147f, 0.21877730f, 0.00701561f, 
    0.06075282f, -0.03571649f, 0.03928050f, 0.13512293f, -0.00039389f, 0.00329520f, -0.00064221f, -0.15764143f, 
    -0.13160285f, 0.04173981f, -0.10927036f, -0.09242723f, 0.17319216f, -0.04925631f, 0.09342297f, 0.02126367f, 
    0.02216064f, -0.05925592f, -0.14856939f, -0.05270248f, -0.06860320f, -0.00203819f, -0.26824334f, -0.04697200f, 
    -0.11899825f, 0.11815492f, 0.02870403f, 0.00014853f, -0.15701972f, -0.40928078f, -0.09395086f, -0.06905900f, 
    0.00609497f, -0.10470887f, -0.02014452f, -0.06458098f, 0.00820116f, 0.11726617f, -0.11753437f, 0.20833769f, 
    0.20034572f, 0.14017366f, -0.06024339f, 0.00514065f, 0.12621267f, -0.01440003f, -0.03780123f, -0.01011398f, 
    -0.14368822f, -0.14545384f, 0.06119445f, -0.02439680f, 0.08607345f, 0.09697628f, -0.08622761f, 0.22939223f, 
    0.12439719f, 0.07369528f, -0.04075217f, 0.01332340f, 0.07031279f, 0.10698736f, 0.01164281f, -0.07159331f, 
    -0.03503560f, 0.05824556f, 0.12522537f, 0.18132810f, -0.03781113f, -0.10290979f, -0.01659237f, 0.12228715f, 
    0.14158642f, 0.16284949f, 0.09487274f, -0.13895696f, -0.17200662f, 0.01506728f, -0.11685726f, -0.06506194f, 
    0.07576684f, -0.01227929f, 0.16022806f, -0.01476754f, 0.08748985f, -0.02676150f, 0.11348044f, 0.03853372f, 
    -0.01182359f, 0.08561288f, 0.14510046f, 0.05839853f, -0.04067485f, -0.12900317f, -0.08758422f, -0.00855581f, 
    0.15484741f, 0.01547491f, -0.00780706f, -0.00929601f, -0.05544816f, -0.10804665f, 0.12715714f, 0.01762983f, 
    0.12060198f, 0.04779743f, 0.02164008f, -0.10024376f, -0.01256606f, 0.04591338f, 0.10302371f, -0.16551301f, 
    -0.04148227f, -0.09744541f, 0.08994675f, 0.07649828f, -0.06644950f, -0.10890695f, -0.05925965f, -0.04321463f, 
    0.05295285f, 0.01317234f, 0.14183336f, -0.05745713f, 0.04557676f, -0.11018678f, 0.04035122f, -0.38911089f, 
    -0.04890067f, 0.00166075f, -0.03857239f, 0.00740426f, 0.03242871f, 0.02739624f, -0.02906828f, -0.00618845f, 
    -0.02116768f, 0.02372016f, 0.03670146f, -0.03678463f, -0.03030996f, 0.01622865f, 0.02136714f, -0.01296585f, 
    0.04679093f, 0.00269363f, 0.04517685f, -0.06279032f, 0.01210099f, 0.02189911f, 0.02370516f, -0.05372660f, 
    -0.04659208f, -0.01786919f, -0.05069528f, 0.00574740f, -0.04426845f, -0.02993663f, -0.06023438f, 0.04498570f, 
    0.02392040f, -0.02427898f, -0.02718839f, 0.00713557f, 0.01462918f, 0.03644774f, -0.02975572f, 0.00162552f, 
    0.01176952f, 0.01163546f, -0.02270972f, -0.05964481f, -0.04444518f, 0.03369355f, -0.04810945f, 0.00499861f, 
    -0.01789687f, 0.03356279f, -0.03520906f, -0.03071338f, 0.04119032f, -0.03670409f, 0.01831333f, 0.00153404f, 
    -0.02044142f, 0.03500084f, 0.04347488f, -0.00065299f, 0.03136288f, 0.04646998f, 0.05412290f, -0.04702964f, 
    0.01293239f, 0.04754684f, -0.01215777f, -0.04217762f, 0.02707358f, -0.00463975f, -0.02439574f, 0.03278356f, 
    0.02395893f, 0.05719244f, 0.05151433f, 0.01387337f, -0.03049854f, -0.00523317f, 0.01499529f, 0.03667015f, 
    0.01626480f, -0.01217470f, -0.03552345f, 0.04973183f, -0.01983158f, -0.04490351f, 0.04646501f, 0.02218033f, 
    0.01738356f, -0.01725511f, 0.04937314f, 0.00827416f, -0.00898775f, -0.06149008f, -0.01852429f, 0.00645807f, 
    -0.05643195f, -0.00212161f, -0.05228179f, 0.02136667f, -0.04174390f, 0.03231288f, -0.02131630f, -0.05858590f, 
    0.04950954f, 0.04179231f, 0.04355378f, -0.05631647f, -0.04592407f, 0.00881050f, 0.02013966f, -0.04918674f, 
    -0.00838751f, -0.00652482f, -0.03468775f, -0.03485831f, 0.01066388f, 0.02870651f, 0.03837826f, 0.02052315f, 
    -0.00865430f, 0.03607439f, 0.02517414f, -0.00457877f, 0.00617189f, 0.01506904f, -0.05780264f, -0.00023562f, 
    -0.02890991f, 0.03882941f, 0.03076899f, 0.02298042f, -0.00880944f, -0.05513123f, 0.03554915f, -0.02947555f, 
    -0.04617926f, -0.04609760f, -0.03978565f, -0.03068443f, -0.06562433f, 0.01257854f, 0.05811665f, 0.00289157f, 
    -0.03302434f, 0.03667586f, 0.01023452f, 0.02883747f, 0.04620443f, -0.06402998f, 0.03199925f, -0.05468938f, 
    0.00883137f, 0.00188145f, 0.01710862f, -0.01691394f, -0.04033080f, 0.05057099f, 0.01044489f, 0.05018079f, 
    0.00462384f, -0.02913642f, 0.03127971f, -0.05902928f, -0.01069261f, -0.05484105f, -0.01622881f, -0.00987848f, 
    -0.05259489f, -0.05022664f, -0.05879659f, 0.00693063f, -0.04972340f, -0.00212517f, 0.01328104f, 0.03060076f, 
    -0.06264364f, 0.00523919f, 0.02432090f, -0.01187626f, 0.03962035f, -0.04705089f, 0.00354492f, 0.02013740f, 
    -0.01568588f, 0.00020012f, 0.00554654f, -0.02809221f, 0.03051285f, 0.02055429f, -0.01684150f, -0.02955231f, 
    0.01677009f, 0.01820175f, -0.03604554f, -0.04218622f, 0.02409198f, -0.06135304f, 0.03011171f, 0.02872822f, 
    0.03507253f, 0.04851696f, 0.03150441f, 0.02456096f, -0.04630615f, 0.04809099f, -0.05009586f, -0.06156287f, 
    -0.04511000f, 0.00072777f, -0.00046133f, -0.03184890f, -0.00435811f, 0.03036686f, -0.00399877f, 0.01917830f, 
    -0.04966794f, -0.02254969f, 0.02931603f, -0.00090328f, -0.02639035f, 0.03722987f, -0.00344279f, -0.05853162f, 
    0.02871248f, 0.00610939f, 0.00928013f, 0.03765227f, -0.05447304f, -0.04555730f, 0.01000754f, 0.01039760f, 
    -0.00963435f, -0.05174422f, 0.01520675f, -0.05074211f, -0.02515144f, -0.05962981f, -0.01404953f, 0.00145973f, 
    -0.04987311f, -0.02929877f, -0.01969474f, -0.03186408f, -0.00442210f, -0.03674107f, -0.04874226f, 0.03860100f, 
    0.04564987f, 0.01101636f, 0.04444337f, 0.02710313f, -0.00294862f, -0.00778582f, -0.04999860f, 0.02145815f, 
    -0.02121707f, 0.03022897f, -0.05369724f, 0.00497888f, -0.02863163f, 0.00482308f, -0.00758571f, 0.00841600f, 
    -0.06553393f, 0.04904763f, -0.05981056f, -0.00507223f, 0.00833613f, -0.03588532f, 0.03678291f, 0.05178864f, 
    -0.02688514f, -0.00271047f, 0.04361707f, 0.04056525f, -0.03470578f, 0.00664817f, -0.00203595f, -0.04079422f, 
    -0.05571508f, 0.01971296f, 0.01796376f, 0.00132963f, 0.01692278f, -0.03525027f, -0.03264564f, -0.04786835f, 
    0.00449934f, 0.10432626f, -0.03109416f, -0.16006264f, 0.12860258f, -0.21457629f, 0.07412243f, -0.08002300f, 
    -0.02283430f, -0.03375763f, -0.32216987f, 0.28848216f, 0.13246851f, 0.13857959f, 0.21081375f, 0.10993328f, 
    -0.04733760f, 0.03013563f, -0.35592735f, -0.30635026f, 0.02009510f, 0.07339359f, 0.02714102f, -0.11221645f, 
    0.07395130f, -0.02869268f, 0.14754696f, -0.00198955f, -0.29533660f, -0.03859339f, -0.06709483f, 0.11833087f, 
    -0.03871370f, -0.02192511f, 0.15972818f, -0.01787169f, 0.03411466f, 0.00100451f, -0.04669860f, -0.00763532f, 
    0.06318209f, -0.15160707f, -0.02620784f, 0.02298969f, -0.01928642f, -0.06814089f, -0.05130696f, -0.04938073f, 
    0.04443361f, -0.07231048f, 0.11966860f, 0.07279272f, 0.06856211f, 0.17915028f, 0.00893429f, 0.12381849f, 
    0.12128060f, -0.00937474f, -0.10864799f, -0.00305110f, -0.03404449f, -0.02400520f, -0.09986897f, -0.02089902f, 
    0.03875733f, -0.05620139f, 0.04203185f, -0.05665151f, -0.18095888f, 0.01505543f, 0.01868745f, 0.06046100f, 
    0.19580127f, 0.02435284f, -0.16506514f, 0.00047648f, -0.08779195f, 0.01096045f, 0.08154215f, -0.06952871f, 
    -0.07694733f, -0.21295086f, -0.30260843f, -0.08833934f, -0.05697799f, -0.06300185f, 0.03392239f, -0.06452881f, 
    -0.00465476f, 0.03111431f, 0.02843885f, 0.00184331f, -0.20722213f, 0.06984872f, 0.07281719f, -0.00312762f, 
    -0.07597663f, 0.13875267f, 0.00106409f, 0.11611075f, -0.17597450f, -0.03141632f, 0.11413848f, 0.11987394f, 
    -0.09831484f, -0.06233616f, -0.01996793f, -0.12985761f, 0.00116122f, 0.12447674f, -0.18027847f, -0.02413261f, 
    -0.08736070f, -0.13455202f, 0.00950511f, 0.01651651f, 0.05836716f, -0.04372061f, 0.14693230f, -0.28049964f, 
    -0.05997293f, 0.05604245f, -0.01189567f, -0.04327999f, 0.05826766f, -0.01870992f, 0.10593423f, 0.11235508f, 
    -0.11645832f, 0.00250638f, -0.13692696f, -0.06150076f, 0.05598113f, 0.02012980f, -0.01524229f, 0.07823358f, 
    0.14047748f, -0.11925569f, -0.03234206f, -0.11678732f, -0.10298097f, 0.06691518f, 0.02952515f, -0.09931435f, 
    -0.19275606f, -0.40559781f, 0.11194656f, 0.01429024f, -0.08197682f, 0.06692051f, -0.00061312f, -0.05456771f, 
    -0.04886777f, 0.29634070f, 0.06383055f, -0.12435232f, -0.12952447f, -0.06046472f, -0.00716647f, 0.04042080f, 
    -0.08779389f, 0.03017538f, 0.25026402f, 0.13868243f, 0.05072622f, 0.11847471f, 0.03604084f, -0.11379007f, 
    0.00180063f, 0.20697688f, 0.07098667f, -0.01925804f, 0.06365548f, 0.13857633f, 0.04958633f, 0.01089196f, 
    0.06710503f, 0.02798590f, 0.12494989f, 0.02199270f, 0.23374413f, -0.08993204f, 0.04010962f, 0.09624726f, 
    -0.01342916f, -0.08832749f, -0.02637246f, -0.03561810f, -0.06005089f, 0.17280309f, 0.11508779f, 0.01462817f, 
    -0.13986742f, -0.12464845f, -0.09732861f, -0.02839591f, -0.02495137f, 0.01753366f, 0.15653533f, -0.02933799f, 
    -0.15932477f, 0.10995214f, 0.05971267f, 0.07027383f, 0.04020475f, 0.17898595f, 0.02612286f, 0.16960511f, 
    -0.50807446f, 0.06697073f, 0.08920406f, 0.07617750f, 0.07098652f, 0.05336542f, 0.03062952f, -0.10731891f, 
    -0.07253181f, -0.03883715f, 0.08857147f, -0.06905636f, 0.08329579f, 0.00845480f, -0.04439545f, 0.02090166f, 
    -0.01492214f, -0.17770594f, -0.22855359f, -0.05986881f, 0.10416958f, 0.02026234f, 0.01684017f, -0.05901574f, 
    0.11126862f, -0.00457069f, 0.01005034f, -0.00987948f, -0.04594921f, 0.01432682f, 0.05211067f, -0.13901880f, 
    -0.09671719f, -0.00994643f, 0.04183977f, 0.05609627f, 0.08752593f, -0.19408651f, -0.08277989f, 0.03419714f, 
    0.04955371f, 0.07127100f, 0.08714504f, -0.09561497f, 0.12567371f, 0.10321105f, 0.13607945f, 0.03039758f, 
    -0.01924697f, 0.12247327f, 0.03436955f, -0.08146381f, 0.05966200f, -0.23597908f, -0.25496644f, 0.08212450f, 
    -0.03254291f, 0.06266595f, 0.06237718f, 0.02495442f, 0.04058110f, -0.02593267f, 0.00254626f, 0.12364612f, 
    0.06418090f, 0.08790088f, -0.03000530f, 0.06575102f, -0.11088342f, -0.11115424f, 0.07095563f, -0.04095567f, 
    0.06156057f, -0.15071179f, 0.12403614f, 0.11452649f, -0.12168810f, 0.03692628f, -0.08818442f, 0.10254817f, 
    -0.09380883f, -0.01537759f, 0.07699487f, 0.06305530f, 0.13587902f, 0.04309491f, 0.14596726f, -0.15891780f, 
    -0.06150602f, -0.19292356f, -0.20325044f, 0.07298477f, 0.11331859f, 0.06659853f, 0.01401135f, 0.13691582f, 
    -0.12203921f, 0.01354926f, 0.13823362f, 0.02641775f, -0.25997978f, 0.05002399f, 0.03854460f, 0.03483347f, 
    0.02407820f, -0.06893930f, 0.01575916f, 0.14940847f, 0.04183208f, -0.04939158f, -0.06095877f, 0.02600332f, 
    -0.05561237f, 0.09324103f, -0.03214640f, -0.01987274f, 0.16422087f, 0.05805057f, -0.18298402f, -0.07488844f, 
    0.08491912f, -0.08586544f, -0.07112075f, 0.04754143f, -0.01128866f, 0.08957923f, 0.06657677f, 0.19187357f, 
    -0.11326148f, -0.13781667f, -0.10151248f, -0.15934499f, 0.04500041f, -0.01283469f, -0.29282841f, -0.18674210f, 
    0.00702479f, 0.13162996f, 0.05811980f, 0.06937800f, -0.00917946f, -0.05875779f, -0.01597389f, -0.05489019f, 
    0.02438677f, 0.06185160f, -0.04582512f, -0.02606300f, 0.01532459f, -0.07368504f, -0.19164155f, 0.14448041f, 
    -0.19589384f, -0.14233316f, -0.31729349f, -0.03239855f, 0.09346664f, 0.11693882f, 0.00532747f, -0.12868935f, 
    0.08668746f, 0.20902275f, 0.12812622f, -0.10222444f, 0.00740786f, -0.06787660f, -0.13884081f, 0.08727736f, 
    0.02174890f, 0.05677440f, 0.05753579f, 0.00043646f, 0.06098340f, 0.02025839f, -0.03660481f, 0.04779884f, 
    -0.05590346f, 0.07880408f, -0.04958623f, -0.08823274f, -0.07256712f, 0.04468569f, -0.04638310f, 0.03472963f, 
    -0.03467817f, -0.03427764f, 0.06505521f, -0.01862569f, 0.07555828f, 0.40365815f, 0.04996440f, -0.04835556f, 
    0.07549627f, -0.00579229f, 0.02054538f, 0.03679971f, 0.02673484f, 0.10823067f, 0.11811856f, -0.11191861f, 
    0.06478833f, -0.11220561f, -0.05106866f, -0.08309066f, 0.01149072f, 0.03995870f, 0.18411236f, 0.17937298f, 
    -0.03587757f, 0.07764844f, -0.15648295f, -0.19516620f, 0.11489493f, -0.08101491f, 0.04443228f, -0.06590680f, 
    -0.09337392f, 0.10630298f, -0.14699182f, 0.05810669f, 0.06998185f, -0.08542256f, -0.13983129f, -0.02945288f, 
    0.08216346f, 0.12254955f, 0.08327236f, 0.13326117f, 0.06564131f, -0.14630027f, -0.00336557f, 0.23543078f, 
    -0.01585456f, 0.02421339f, -0.08276838f, 0.15401153f, 0.08533593f, -0.08495804f, 0.08070021f, -0.11712259f, 
    -0.08482781f, 0.10676331f, -0.19939601f, -0.06414354f, 0.17534170f, -0.05992898f, 0.03162873f, -0.05155014f, 
    -0.06028224f, 0.10966602f, -0.05876285f, -0.04403320f, 0.14385845f, 0.08175846f, 0.15728968f, 0.01201728f, 
    -0.01680776f, 0.07242078f, -0.02045523f, -0.05008210f, -0.20719206f, -0.29469177f, -0.06890128f, 0.04181475f, 
    0.01829071f, 0.11499984f, 0.11864081f, -0.02239104f, -0.00207437f, 0.02234428f, -0.24068205f, -0.15929471f, 
    -0.11388529f, -0.03751791f, 0.07388931f, -0.07919660f, -0.06947314f, 0.07300127f, -0.04731080f, 0.17152832f, 
    0.19277002f, -0.16796044f, -0.18063967f, 0.14401060f, 0.03200684f, 0.08354802f, 0.09634889f, 0.15707485f, 
    -0.04852817f, -0.19491756f, 0.07814162f, -0.01994378f, -0.04045592f, 0.15729134f, -0.01138221f, -0.23944651f, 
    -0.16316439f, -0.07969733f, -0.00314381f, 0.04465169f, 0.05053400f, 0.04324917f, 0.04740123f, 0.08480019f, 
    0.03780037f, 0.17912048f, 0.26082572f, 0.13141650f, 0.01710263f, 0.09349454f, -0.05336487f, 0.09994245f, 
    -0.02335151f, 0.07615908f, 0.03988450f, -0.08463729f, -0.12641194f, 0.14618193f, -0.00859756f, -0.22207063f, 
    0.00368767f, -0.11391644f, -0.16094427f, 0.13713372f, 0.11654852f, 0.05902521f, 0.13174371f, -0.01517621f, 
    -0.14773656f, 0.09506068f, -0.06418021f, 0.01126756f, -0.25255457f, -0.12616847f, -0.44079792f, 0.02411502f, 
    -0.10755364f, 0.03398011f, 0.06932126f, 0.09343424f, 0.12431508f, 0.01471796f, 0.14081341f, 0.02624419f, 
    0.08074179f, 0.04124654f, -0.09119428f, 0.01986133f, -0.00942107f, 0.15461382f, -0.09245565f, -0.09519970f, 
    -0.46017978f, 0.00341105f, 0.13565142f, -0.07260340f, 0.04970210f, -0.09066328f, 0.05555228f, -0.01368530f, 
    -0.06634703f, -0.02295191f, -0.07290421f, 0.09427106f, 0.02116836f, 0.00563202f, 0.03239949f, 0.08371689f, 
    0.03037934f, -0.06963242f, -0.06712511f, -0.06751237f, 0.01378144f, -0.07491107f, -0.05133384f, -0.00152672f, 
    0.02821261f, 0.02962819f, 0.01715011f, 0.04144546f, 0.00219272f, 0.00193142f, 0.00069048f, -0.02690149f, 
    -0.00906030f, -0.05032455f, -0.05965575f, -0.00611407f, 0.00041336f, -0.05843358f, -0.04041592f, 0.00445122f, 
    -0.03735094f, -0.03924920f, -0.02028759f, -0.00065169f, -0.00214175f, 0.00333729f, -0.01518161f, 0.00708485f, 
    -0.06890094f, -0.02648238f, -0.03168735f, 0.00631845f, 0.04181440f, 0.02549642f, -0.00126010f, 0.00512038f, 
    -0.01091872f, 0.04013054f, -0.02089990f, -0.04307894f, -0.06835511f, -0.04180662f, -0.03427633f, 0.00609761f, 
    0.02178846f, -0.03699761f, 0.01809571f, -0.05011855f, 0.00978482f, -0.02102153f, 0.00436352f, -0.02678833f, 
    -0.01210059f, 0.00913933f, 0.01801527f, 0.02950074f, -0.05032781f, -0.06949624f, -0.04936073f, -0.02199473f, 
    -0.03977463f, 0.00092622f, -0.05654867f, 0.04442338f, 0.02673720f, -0.05510356f, 0.01518986f, -0.01514470f, 
    0.02705209f, 0.01240865f, 0.01030968f, -0.02488441f, -0.02265687f, -0.01784568f, -0.02010782f, 0.04269123f, 
    -0.01391320f, 0.04160969f, -0.02747774f, -0.00114400f, 0.01027446f, -0.03541364f, -0.01829104f, -0.03335844f, 
    -0.06267204f, -0.05659590f, -0.03215797f, -0.03136742f, 0.00603365f, -0.00979441f, 0.03702984f, 0.01610280f, 
    0.00273173f, 0.03140117f, 0.00701662f, 0.01225760f, 0.00104723f, 0.03024207f, -0.00350883f, 0.00110768f, 
    -0.00947713f, -0.04720073f, -0.03167507f, -0.03164493f, -0.06086021f, 0.00069723f, -0.05477205f, -0.07381211f, 
    -0.01969828f, -0.03629801f, -0.05146824f, -0.00752730f, -0.00038664f, -0.01449148f, 0.03506549f, -0.02949510f, 
    -0.03889171f, -0.05633531f, -0.05725056f, -0.03327336f, -0.03984085f, -0.06209440f, -0.04358810f, -0.02178981f, 
    0.02953653f, 0.01377864f, 0.00138502f, 0.01632627f, -0.03054702f, -0.01410359f, -0.00827458f, 0.00251739f, 
    0.03344891f, -0.04524390f, -0.02680350f, -0.04697504f, 0.04522185f, 0.01321262f, 0.01375688f, -0.03609244f, 
    -0.00817199f, -0.01609549f, -0.03829317f, -0.05762295f, 0.00636695f, -0.02730932f, -0.04519008f, -0.04469464f, 
    -0.02785848f, 0.01019766f, 0.01919282f, 0.00602067f, 0.02342248f, -0.06268650f, 0.00855276f, 0.02797714f, 
    -0.06791495f, 0.02344071f, -0.06570293f, 0.01095033f, 0.00249990f, -0.01168412f, -0.01761417f, -0.03021938f, 
    -0.07472800f, -0.01675489f, 0.03042993f, 0.00629652f, -0.01232757f, -0.01369208f, 0.03415609f, -0.00790334f, 
    0.00873143f, -0.00505373f, -0.03713756f, -0.06229086f, -0.05619373f, -0.03568784f, -0.07845730f, 0.02998161f, 
    0.00856333f, -0.04450512f, -0.04580990f, -0.06180762f, -0.00094004f, 0.02000825f, -0.06215600f, -0.07027620f, 
    -0.04715704f, 0.02437672f, -0.03894325f, 0.02115173f, -0.00215357f, -0.05575102f, -0.07053786f, 0.02491596f, 
    0.03517234f, 0.02087222f, 0.02020331f, -0.06646344f, -0.01360341f, -0.00705679f, 0.02725919f, 0.01302950f, 
    0.02550649f, 0.02461539f, 0.01375279f, -0.02417902f, 0.03772392f, -0.02928219f, -0.03316365f, 0.00517006f, 
    -0.02937996f, -0.04667636f, -0.04860504f, -0.05064197f, -0.08300344f, -0.03300165f, -0.00272565f, -0.03733691f, 
    0.00775617f, -0.05501022f, -0.05648499f, -0.01760476f, -0.03722905f, -0.00348129f, -0.01284479f, -0.00304105f, 
    0.03811749f, -0.06201132f, 0.04069658f, -0.00737580f, 0.00456434f, -0.04690140f, 0.05156615f, 0.04012356f, 
    -0.01310314f, -0.05635656f, -0.05711026f, -0.04025102f, -0.03884505f, -0.00399513f, -0.00421439f, -0.00013676f, 
    -0.02285641f, -0.00408495f, -0.05051539f, 0.01040475f, -0.03964680f, -0.04495648f, -0.01588007f, 0.01719142f, 
    -0.05875337f, -0.06753533f, 0.00928959f, 0.00324220f, -0.03078808f, -0.02948696f, -0.03996433f, -0.01295932f, 
    -0.03330398f, -0.06619667f, -0.06242580f, -0.00945169f, 0.01377814f, -0.00056330f, -0.00278889f, 0.00876875f, 
    -0.06778342f, -0.00059087f, -0.02992468f, -0.02539420f, -0.04885599f, 0.00348715f, 0.02144827f, -0.07439906f, 
    -0.06399859f, -0.02318245f, -0.06982429f, 0.01287796f, 0.00617258f, 0.00556808f, 0.01552418f, -0.05198308f, 
    0.04363802f, -0.05656467f, -0.08879384f, -0.06262316f, 0.02141308f, 0.01069392f, -0.11220832f, 0.19790447f, 
    0.00431048f, -0.13549910f, -0.01036983f, 0.16704190f, -0.18113612f, 0.06064769f, 0.01246718f, 0.04857985f, 
    -0.08098178f, -0.12474058f, -0.19385229f, 0.01809643f, 0.05642638f, 0.05643035f, 0.00092226f, -0.08077169f, 
    0.01294852f, 0.08563369f, 0.04963554f, 0.05720832f, 0.04042879f, -0.20821922f, 0.06719193f, -0.04479937f, 
    0.05890875f, -0.00072357f, 0.10343745f, -0.09377345f, -0.23611452f, -0.00882703f, -0.16607741f, 0.03219791f, 
    0.03706273f, 0.00608038f, 0.07925580f, -0.12187517f, 0.00691962f, 0.01268919f, -0.03197065f, -0.03441313f, 
    0.00343033f, -0.12874936f, -0.08820991f, 0.09066705f, 0.00375288f, -0.00318389f, 0.08761929f, 0.16191190f, 
    0.16122518f, 0.12819600f, -0.07150812f, -0.04008190f, -0.06813166f, 0.03855641f, 0.07341212f, 0.09878452f, 
    0.04330954f, -0.35802591f, -0.05658006f, -0.00622259f, -0.01882142f, 0.20976348f, 0.11925712f, -0.00103301f, 
    0.06044552f, 0.12290657f, -0.01853577f, -0.03965167f, -0.22224410f, -0.00245488f, -0.07464976f, -0.15052813f, 
    -0.00801728f, -0.42610112f, -0.18237531f, 0.00327279f, 0.06650570f, -0.00381488f, -0.01540199f, -0.01718809f, 
    -0.02337723f, -0.05078017f, 0.19612987f, 0.12730680f, -0.01311773f, 0.12448968f, 0.13936886f, 0.11903232f, 
    -0.01532997f, 0.00086682f, 0.00158464f, -0.01978349f, -0.04452422f, -0.14076385f, -0.00604762f, 0.02488749f, 
    -0.05944449f, -0.02832197f, 0.00105310f, -0.14763305f, -0.11616211f, -0.01829987f, 0.01171488f, 0.10031174f, 
    0.05099767f, -0.09971190f, -0.10618336f, -0.01247516f, 0.11730539f, -0.27483156f, 0.10290606f, -0.39516371f, 
    0.00313787f, -0.00440090f, -0.07153889f, 0.03368255f, -0.08592249f, -0.07080410f, -0.01966515f, 0.15033615f, 
    -0.01161796f, -0.13274224f, -0.01365608f, 0.04520623f, -0.03098265f, 0.14229745f, 0.00574089f, 0.35271990f, 
    0.26718318f, 0.07413724f, -0.11879029f, -0.04016152f, -0.02130303f, 0.17245515f, 0.05614510f, -0.03004226f, 
    0.00699761f, -0.16938493f, -0.15141766f, -0.00803374f, 0.00241458f, -0.04299372f, 0.15304263f, -0.09198730f, 
    -0.01073088f, -0.03486666f, 0.17993176f, -0.01387582f, -0.11567877f, -0.20707189f, -0.04333505f, -0.06832606f, 
    -0.05840533f, 0.03522961f, 0.40037698f, 0.13609654f, 0.14685571f, 0.04343819f, 0.12946241f, 0.16000991f, 
    0.06649049f, -0.03393694f, 0.07701199f, 0.02971243f, 0.03030563f, 0.09407575f, -0.09159822f, -0.02869777f, 
    -0.16047660f, 0.00413914f, 0.10967682f, 0.09988830f, 0.16528171f, 0.01952136f, 0.11950763f, -0.02396012f, 
    -0.03836422f, -0.08670198f, 0.04577611f, 0.05563603f, -0.14134756f, 0.05999624f, 0.11705989f, -0.06716567f, 
    0.01193342f, 0.09031971f, 0.04339836f, 0.01207918f, 0.10531591f, 0.08415306f, 0.21322919f, 0.13987488f, 
    -0.00266779f, 0.03159650f, -0.02827473f, 0.00933422f, 0.07700924f, 0.00166347f, 0.00401818f, -0.06752105f, 
    -0.21303043f, -0.25777695f, -0.16704598f, 0.00154425f, 0.01484623f, 0.02292460f, 0.11727090f, -0.14035617f, 
    0.16872536f, 0.04763972f, 0.18703593f, 0.04145522f, 0.00557188f, 0.04608261f, -0.06459422f, 0.03588017f, 
    0.01011092f, -0.13698287f, 0.09095489f, -0.10255414f, 0.06540298f, 0.07493978f, 0.03039731f, -0.00721610f, 
    0.15984045f, 0.04681494f, -0.05561440f, 0.04892326f, -0.22546870f, 0.00913624f, 0.05384356f, 0.04842953f, 
    0.00003587f, -0.10326259f, 0.16277550f, -0.20525917f, -0.08744679f, 0.10870335f, 0.05858133f, -0.03402895f, 
    0.01838492f, 0.03374851f, -0.04029772f, 0.09241034f, -0.16264603f, -0.10449396f, -0.12289655f, 0.11498708f, 
    -0.01468285f, 0.01102061f, -0.12909983f, -0.16040364f, 0.03983219f, -0.05236542f, 0.05121252f, 0.03216820f, 
    -0.00381584f, 0.04257173f, 0.00086078f, 0.09728756f, 0.05545516f, -0.05402255f, 0.06653169f, 0.04432201f, 
    -0.13490258f, 0.19242758f, -0.28231153f, 0.09683869f, -0.06619607f, 0.04488929f, -0.00840846f, -0.04050714f, 
    -0.21414933f, 0.08786219f, -0.03959197f, 0.11481895f, -0.10649955f, -0.09574194f, -0.12898108f, 0.00722053f, 
    -0.01898398f, -0.06355359f, 0.02455000f, -0.03913802f, -0.02221560f, -0.05535251f, 0.00802767f, -0.02124068f, 
    0.03277902f, 0.00482523f, 0.00071308f, -0.02772424f, 0.02495184f, -0.02108778f, 0.03181457f, -0.02317012f, 
    0.01663451f, 0.00618536f, -0.04104620f, -0.01037381f, -0.05480642f, 0.04430392f, 0.02681693f, 0.02075624f, 
    -0.02556414f, 0.02851046f, -0.04495852f, -0.01487393f, -0.00371797f, -0.04586617f, -0.02235425f, 0.02948114f, 
    -0.01740644f, -0.01497775f, -0.03532479f, 0.02359724f, 0.00242590f, 0.01370797f, -0.06415373f, 0.04115824f, 
    0.04172964f, -0.04638549f, 0.03172492f, -0.00668032f, -0.03990011f, -0.06343436f, 0.05062272f, 0.03789153f, 
    -0.06302798f, -0.04563837f, 0.04582265f, -0.03771555f, -0.01451945f, 0.02836726f, -0.00727842f, 0.01175946f, 
    0.03812834f, 0.00550946f, 0.04119406f, -0.02153243f, -0.06910333f, 0.02256320f, -0.03786183f, 0.04684543f, 
    -0.00924771f, -0.02081603f, 0.02158511f, -0.02311444f, 0.04691805f, 0.01107632f, -0.02548044f, -0.00902335f, 
    -0.04507393f, 0.02989127f, -0.01629623f, -0.02534594f, 0.01819961f, 0.03677129f, 0.04352941f, -0.01772401f, 
    -0.02426184f, 0.03306696f, -0.00334653f, -0.00182727f, 0.02243147f, -0.05298245f, 0.04364900f, 0.01879732f, 
    -0.00054794f, -0.00375243f, -0.02289026f, -0.05226415f, 0.03726967f, -0.05375643f, 0.03610226f, 0.01473075f, 
    0.04097277f, -0.03678813f, -0.03486592f, 0.00460274f, 0.04077110f, 0.02392972f, 0.04530848f, 0.03658425f, 
    -0.06853959f, 0.01975871f, -0.03202677f, -0.05042821f, -0.01298443f, -0.06112254f, -0.02656512f, -0.06442460f, 
    0.02559435f, -0.03103522f, 0.03472935f, -0.02260282f, 0.03961801f, 0.03539771f, -0.06946221f, -0.03696959f, 
    -0.00936734f, -0.00990043f, -0.04090570f, -0.01510094f, -0.00840961f, -0.02796348f, 0.03795805f, -0.00611659f, 
    0.00689435f, -0.00962874f, 0.03568051f, 0.00328700f, 0.03972465f, 0.02323619f, 0.01166510f, 0.03007223f, 
    -0.02493956f, -0.02979273f, -0.01201973f, 0.00817420f, 0.00635933f, -0.04213045f, 0.03369892f, 0.01484481f, 
    -0.03788084f, -0.04842208f, -0.06152794f, 0.02838354f, 0.01575826f, 0.04294476f, 0.01533978f, -0.04833904f, 
    -0.06425235f, 0.02606032f, 0.01551694f, -0.00925584f, -0.06230035f, -0.04505140f, -0.02453082f, -0.04977150f, 
    0.04128252f, 0.00727575f, -0.05181952f, 0.04257972f, 0.02102299f, 0.04109999f, -0.05963168f, 0.00599712f, 
    0.01746763f, 0.00347436f, -0.05720759f, -0.06406759f, 0.03286403f, 0.02379189f, -0.04348657f, -0.05665370f, 
    0.02979523f, 0.01862579f, -0.05245035f, 0.00099067f, 0.04449004f, 0.02904254f, 0.04702864f, -0.03992243f, 
    -0.06312341f, -0.04066103f, -0.04518703f, 0.03549790f, -0.01669154f, -0.00313507f, -0.06919879f, -0.02406441f, 
    0.00581450f, 0.02206711f, 0.03450458f, -0.03649476f, -0.01027750f, 0.00709367f, 0.03073770f, -0.02106850f, 
    -0.04138117f, 0.01644951f, -0.05543131f, 0.02335265f, 0.02158548f, 0.02652745f, 0.00008956f, 0.04604451f, 
    -0.04113515f, -0.05289538f, 0.03808793f, -0.04822167f, 0.03348275f, 0.03145898f, -0.07153761f, 0.02520280f, 
    -0.04743243f, 0.04747406f, -0.02592593f, 0.00729045f, -0.02925849f, 0.03300439f, 0.03919853f, -0.07131413f, 
    -0.01121631f, 0.03927397f, 0.00033382f, -0.03251395f, 0.01194574f, 0.02121432f, -0.01663122f, -0.05108350f, 
    -0.01298693f, 0.02652036f, 0.03729737f, -0.03079102f, -0.03495698f, -0.07258976f, -0.03473594f, 0.00014705f, 
    -0.02093655f, -0.05922689f, -0.01642846f, -0.03173718f, -0.04749169f, 0.01366519f, 0.02339338f, 0.03778296f, 
    -0.05701525f, -0.03153283f, 0.03369400f, -0.00852597f, -0.00162036f, 0.03390099f, 0.00850059f, 0.03018775f, 
    0.04529822f, -0.02839428f, -0.02505383f, -0.05631570f, -0.04529834f, -0.05565490f, 0.02614823f, 0.03930326f, 
    0.03446647f, -0.02137581f, -0.03361355f, -0.07077317f, -0.00283036f, -0.00396659f, -0.00584095f, 0.00654901f, 
    -0.02513994f, -0.03052906f, -0.01978362f, -0.04797355f, -0.04108601f, -0.01953632f, -0.03818382f, -0.01889182f, 
    -0.00419819f, -0.01126376f, -0.04883396f, 0.02189470f, -0.01899548f, -0.01664382f, -0.02219294f, 0.02304550f, 
    0.04289804f, -0.05251395f, -0.07350771f, -0.03017533f, -0.07783888f, -0.07459141f, -0.07648951f, -0.05406679f, 
    -0.03293128f, -0.04411775f, -0.00088743f, -0.03700525f, -0.04191592f, 0.03313494f, -0.01864901f, -0.04892500f, 
    -0.00688463f, -0.03486910f, -0.01521619f, -0.08166336f, -0.02198396f, -0.04934198f, 0.04726096f, 0.01588263f, 
    -0.07648233f, -0.07324578f, -0.05602418f, -0.02365836f, 0.02669586f, 0.03281059f, 0.00529596f, -0.06806290f, 
    0.02233333f, 0.01708825f, -0.07681359f, -0.08935192f, 0.00048843f, -0.01874788f, 0.01347566f, -0.01429404f, 
    -0.03341896f, -0.04074979f, -0.09110440f, -0.04268909f, -0.07746712f, -0.04649199f, -0.03231706f, 0.03333459f, 
    0.01499500f, -0.06000730f, 0.03083267f, 0.00413868f, -0.08422671f, -0.01467870f, -0.00417668f, -0.06076901f, 
    0.00732078f, -0.07643598f, -0.05950370f, -0.06180310f, -0.02343743f, -0.07782377f, 0.00814710f, -0.04201664f, 
    -0.04792599f, 0.02121743f, -0.01340867f, 0.02863952f, -0.05165105f, 0.00949588f, -0.03896405f, -0.06808616f, 
    0.02134658f, 0.01675669f, 0.02976833f, -0.04124595f, -0.02387752f, -0.10085555f, -0.07131360f, -0.05676143f, 
    0.00691418f, 0.01801572f, -0.05613995f, -0.04930283f, -0.05303142f, -0.05328267f, 0.00359172f, -0.06794891f, 
    0.00930380f, 0.02833103f, -0.01335096f, -0.08298413f, -0.05502154f, 0.00710929f, 0.01463198f, -0.05460409f, 
    0.02264502f, -0.02154420f, -0.06857464f, -0.02805252f, 0.02437393f, -0.03086421f, -0.05710284f, -0.04997301f, 
    -0.07950441f, -0.03059012f, -0.07658576f, -0.08281503f, 0.06037335f, -0.07004092f, -0.05582181f, -0.03679312f, 
    -0.04855885f, -0.04967862f, -0.08550099f, -0.08210231f, -0.04367188f, -0.03936232f, 0.00206198f, 0.02638531f, 
    -0.00488572f, -0.05410045f, 0.01906744f, 0.00305569f, -0.06008382f, 0.00334897f, 0.03288720f, -0.02632273f, 
    -0.04085634f, 0.01673940f, -0.06755222f, 0.02866698f, 0.02737305f, -0.01450102f, 0.01967219f, 0.02239329f, 
    -0.00153711f, -0.05299342f, 0.02325490f, -0.05550242f, 0.00966320f, -0.06508767f, -0.03481763f, -0.02621825f, 
    0.02940552f, -0.07965553f, -0.04507369f, 0.01819631f, -0.04835617f, -0.05999134f, -0.00115834f, 0.02127383f, 
    -0.02043063f, -0.04728785f, -0.00583996f, 0.00164882f, -0.08897144f, -0.02816260f, 0.02574038f, -0.07079945f, 
    0.03066135f, -0.02952490f, 0.03514986f, -0.05903853f, -0.02784895f, -0.01963337f, 0.03175202f, -0.06903155f, 
    0.01815379f, -0.03214797f, -0.02402302f, -0.07895139f, -0.03558024f, -0.08486918f, -0.03987188f, -0.05300078f, 
    -0.05713480f, -0.05311665f, -0.02154913f, 0.01240180f, -0.03547839f, -0.07856070f, -0.08120143f, -0.05591182f, 
    -0.04696560f, -0.09944606f, -0.04826130f, -0.01270913f, -0.09373786f, -0.01491969f, 0.00122904f, -0.06891839f, 
    0.03164640f, 0.01439929f, 0.01454703f, 0.00061942f, -0.05381098f, 0.02747050f, 0.00835707f, -0.05249646f, 
    0.00535687f, -0.07575596f, 0.00442775f, -0.04893560f, -0.08828387f, 0.02964053f, -0.01999539f, 0.02057510f, 
    0.02323163f, -0.08232629f, -0.07169822f, 0.00748197f, 0.00620851f, -0.01259659f, 0.00245265f, -0.00984734f, 
    -0.05906556f, 0.00786469f, -0.04261789f, -0.09162453f, 0.02888391f, -0.01269757f, -0.06235855f, -0.07034441f, 
    -0.00205029f, -0.02421993f, -0.03767696f, -0.04027529f, -0.05531826f, 0.00089672f, -0.03619092f, -0.06552232f, 
    0.02057646f, 0.00991901f, -0.03775103f, -0.03552439f, 0.00453942f, -0.07616150f, -0.01149074f, -0.08916603f, 
    -0.00531764f, -0.00478270f, -0.00433650f, -0.02803847f, -0.01450806f, 0.00571594f, -0.01106334f, -0.09102061f, 
    -0.03056446f, -0.06120577f, -0.03505002f, 0.02025478f, -0.02500875f, -0.01734292f, -0.00983535f, -0.07097692f, 
    -0.08802442f, -0.08453379f, 0.00817593f, -0.08979589f, -0.02830182f, -0.08664752f, -0.06262007f, -0.05158979f, 
    0.00641069f, 0.02950316f, -0.04518706f, -0.00343974f, -0.07274748f, 0.01712312f, -0.08402143f, -0.01361248f, 
    -0.06731307f, 0.01449859f, -0.06496754f, -0.00506783f, -0.01310651f, -0.05312263f, -0.04982868f, 0.00325673f, 
    0.02523219f, -0.06999282f, 0.00628173f, 0.02663988f, -0.01452740f, 0.00127929f, -0.01846552f, -0.06448743f, 
    -0.06218220f, -0.21539097f, 0.20877908f, 0.00984753f, 0.15013823f, 0.09843953f, -0.16567636f, 0.02406764f, 
    -0.08343986f, -0.07401204f, -0.02317879f, 0.04215990f, 0.01129349f, -0.00493841f, 0.10904583f, -0.02205782f, 
    -0.13254325f, 0.07153235f, -0.04337488f, -0.15614423f, 0.15819545f, 0.00663636f, 0.03119188f, -0.06723819f, 
    -0.06991526f, 0.14862436f, -0.01008992f, 0.29141739f, 0.19433945f, 0.13344029f, -0.17693536f, -0.11854415f, 
    0.05316548f, -0.01360826f, 0.08291604f, 0.09122720f, -0.00631980f, -0.14821625f, -0.01044976f, -0.04443641f, 
    -0.01928498f, -0.06716744f, -0.07001716f, -0.02022920f, 0.00761318f, -0.03033736f, 0.12541446f, -0.16463785f, 
    0.03516983f, -0.06334342f, -0.04179562f, -0.01120684f, 0.07924741f, -0.01095770f, -0.01473964f, -0.24329266f, 
    -0.18909915f, 0.04966802f, 0.01861813f, 0.09975293f, 0.08690718f, -0.00009856f, -0.04465025f, 0.04046059f, 
    0.06865569f, -0.08494408f, 0.01337981f, 0.08681480f, -0.20141417f, -0.07158035f, 0.10809589f, 0.09240962f, 
    0.04400248f, -0.18460624f, -0.20262970f, -0.05251186f, 0.04494534f, 0.09326725f, 0.13867244f, -0.00016660f, 
    -0.00813110f, 0.08608197f, -0.04376535f, 0.04605291f, -0.09358622f, -0.07349899f, 0.00751276f, 0.03168017f, 
    0.07994982f, 0.22822669f, 0.20558012f, 0.04346482f, 0.03869459f, 0.09208857f, 0.08600277f, -0.17825161f, 
    0.08226081f, 0.06226497f, -0.14911012f, 0.11292797f, 0.16953644f, 0.13939151f, 0.05014190f, -0.06534734f, 
    -0.04933489f, 0.11951990f, 0.06669163f, -0.04615748f, -0.61289442f, -0.33194461f, 0.00863873f, 0.10755564f, 
    0.05367487f, 0.06667128f, 0.10335122f, 0.00173572f, 0.00426191f, -0.29791126f, 0.19972506f, 0.12907836f, 
    0.13780537f, 0.06883565f, -0.09523266f, -0.00775543f, 0.06743210f, -0.11380766f, -0.20503272f, -0.35897756f, 
    -0.30247349f, -0.16325854f, 0.05827347f, -0.07299310f, -0.03391258f, -0.15798177f, 0.18265393f, -0.03315685f, 
    -0.00611623f, -0.04293506f, -0.06276240f, -0.02881739f, 0.01279707f, -0.01908544f, 0.00735886f, -0.22195536f, 
    -0.14334938f, 0.07887930f, -0.01574229f, 0.02089592f, 0.08841208f, 0.04381442f, -0.08340690f, -0.03133539f, 
    -0.09855444f, -0.18632603f, -0.07073046f, 0.30986273f, -0.10830200f, -0.05643595f, 0.20781198f, 0.04845660f, 
    0.02741046f, 0.18899505f, 0.35764149f, 0.08637496f, -0.20342022f, -0.07289557f, 0.11065509f, -0.06886837f, 
    -0.05038867f, 0.08511777f, -0.02786977f, -0.58056176f, -0.01979239f, -0.07365680f, 0.09017207f, 0.15062107f, 
    -0.05431294f, -0.05185934f, -0.04202704f, 0.10770530f, 0.03766689f, -0.25648025f, -0.37605795f, 0.07516115f, 
    0.09353156f, 0.13927656f, 0.08658355f, 0.03749123f, -0.11904369f, -0.24079573f, -0.04590203f, 0.16874622f, 
    0.01413803f, 0.09612211f, -0.02701481f, 0.08655142f, -0.10096073f, 0.08837311f, 0.04468254f, 0.00758096f, 
    -0.08342323f, 0.11059166f, -0.00057934f, -0.10046934f, 0.04707435f, 0.03986584f, -0.09265261f, -0.09791314f, 
    0.10141002f, 0.17725800f, -0.12231728f, -0.04595524f, 0.04793791f, -0.05071486f, -0.13215622f, 0.26673752f, 
    0.07657169f, -0.10079617f, -0.02985589f, 0.06373811f, 0.12295225f, -0.06537599f, 0.05133463f, 0.06676941f, 
    -0.07564586f, -0.26554286f, 0.24329793f, 0.25215864f, 0.03474725f, 0.02299834f, 0.02004201f, 0.06369628f, 
    0.01394521f, -0.09361825f, -0.27735123f, -0.05780580f, -0.05398369f, -0.01354683f, -0.08111748f, 0.00534413f, 
    0.07422817f, 0.11584502f, 0.01644543f, -0.13673538f, -0.21239346f, 0.08478735f, -0.05083619f, -0.01101451f, 
    -0.03248317f, 0.07565875f, 0.07370515f, -0.10208580f, 0.04838923f, -0.02274703f, -0.09531101f, -0.00858142f, 
    -0.05281232f, 0.10421203f, -0.17063576f, 0.03101954f, 0.26736221f, -0.01464605f, 0.03227182f, 0.09649059f, 
    0.15989013f, 0.06311731f, 0.08811648f, 0.02472521f, -0.01421196f, 0.11471018f, 0.06222499f, -0.05939090f, 
    -0.18361840f, -0.16833422f, -0.00355520f, -0.00518572f, -0.02046890f, -0.03259958f, 0.01009611f, -0.14159235f, 
    0.04559299f, -0.02484578f, 0.02972565f, 0.02791583f, -0.13838513f, 0.09329156f, 0.15381376f, -0.08360489f, 
    -0.03140284f, -0.03130955f, -0.06602603f, -0.01337279f, -0.04127538f, 0.04239553f, -0.12672934f, -0.07496054f, 
    -0.06918518f, 0.00386732f, 0.02068501f, 0.06114709f, -0.01795973f, -0.07055280f, -0.09374622f, -0.04984197f, 
    -0.00529996f, -0.08894031f, -0.03763299f, -0.01725125f, -0.03559418f, 0.00404350f, -0.01265257f, 0.00589403f, 
    -0.01865895f, -0.01434454f, -0.03780847f, 0.00299119f, -0.03421336f, 0.00457791f, -0.01216185f, -0.04071882f, 
    -0.08424236f, 0.01721820f, -0.03378241f, -0.02458864f, -0.06680619f, -0.01967568f, -0.05788761f, -0.04998168f, 
    0.00996631f, -0.00552751f, -0.00206874f, -0.01480041f, -0.02853767f, -0.00024597f, 0.00471209f, -0.02468096f, 
    -0.02961655f, -0.03114485f, -0.02274375f, 0.03837197f, 0.01337453f, 0.02758173f, -0.04430450f, -0.01166641f, 
    -0.05931090f, -0.06262774f, -0.10279115f, 0.02404647f, -0.06449058f, -0.03488351f, -0.04232198f, 0.03655173f, 
    -0.00569633f, 0.01275443f, -0.02831160f, -0.06545682f, -0.07788717f, 0.01983691f, -0.01578685f, -0.08449352f, 
    -0.05288646f, -0.05428048f, 0.01988366f, 0.00605566f, 0.02317036f, 0.02764942f, -0.06778373f, -0.06594095f, 
    0.02800655f, -0.06510276f, -0.06136067f, -0.04899851f, 0.01333163f, -0.07476145f, -0.01162145f, -0.03671113f, 
    -0.02730297f, -0.05684765f, -0.03650299f, -0.00797397f, 0.00611651f, -0.04126200f, -0.07012120f, -0.01750060f, 
    -0.02860752f, -0.05614436f, -0.07524382f, -0.07398063f, -0.01425725f, -0.03873347f, -0.04152000f, -0.02516763f, 
    0.00594844f, -0.04793592f, -0.05768023f, 0.01366452f, 0.01106328f, -0.01113710f, 0.03298936f, -0.06600374f, 
    -0.02779100f, -0.00947281f, -0.07627004f, -0.01795347f, 0.01946313f, -0.03905471f, -0.01370740f, -0.05077201f, 
    0.03170528f, 0.02271808f, 0.00763227f, 0.02678181f, -0.01846434f, -0.05521182f, 0.02848793f, -0.02547689f, 
    -0.04889128f, 0.03318489f, -0.03881869f, -0.02031987f, -0.08306788f, 0.05636439f, 0.05602039f, -0.07750790f, 
    -0.09621789f, -0.05050797f, -0.07803100f, 0.03505163f, 0.04609623f, -0.03506395f, -0.01184724f, -0.04806230f, 
    0.00225134f, -0.01904966f, -0.00771389f, -0.02026531f, 0.02532817f, -0.04746300f, -0.09182253f, 0.01773571f, 
    0.01272222f, -0.07185826f, -0.08754268f, -0.07008455f, -0.06740547f, -0.02104624f, -0.01722841f, -0.11406271f, 
    -0.09814053f, 0.00193264f, -0.00107843f, 0.01210089f, -0.04632952f, 0.01346949f, -0.00803214f, -0.06476499f, 
    -0.06032557f, -0.03283789f, -0.02703035f, -0.02971020f, -0.02108505f, -0.08162038f, 0.00940265f, 0.01914705f, 
    -0.06302078f, 0.01870330f, 0.06149086f, 0.00654810f, -0.00659791f, 0.02462896f, 0.03588863f, 0.03370455f, 
    0.00071049f, 0.02030706f, -0.07298528f, 0.03173809f, -0.04751827f, 0.02394545f, 0.00009672f, -0.08000103f, 
    -0.01692958f, -0.04712755f, -0.05096452f, -0.07637636f, -0.02300607f, 0.03618912f, 0.04621868f, -0.08761109f, 
    -0.03949085f, -0.10138410f, 0.02296187f, -0.05635604f, 0.00803615f, -0.05409408f, 0.00952531f, -0.04612042f, 
    -0.08717763f, -0.09329676f, 0.00063603f, -0.05691503f, -0.08943158f, -0.01384313f, -0.06486047f, -0.07287868f, 
    -0.05429364f, -0.00942407f, -0.06021984f, -0.06418775f, -0.07588212f, -0.03157446f, -0.06039130f, 0.05417980f, 
    -0.07579622f, 0.00634630f, -0.01970089f, -0.03065495f, -0.03994780f, -0.00401665f, -0.04429872f, -0.06503237f, 
    -0.06035006f, -0.04055536f, -0.00603467f, 0.00034219f, -0.04568357f, -0.00359035f, 0.02325463f, 0.00493468f, 
    -0.06288385f, -0.00297511f, -0.03593126f, -0.07591611f, -0.03040799f, -0.02302404f, 0.00051076f, 0.06824165f, 
    -0.04479193f, -0.06015987f, 0.01088432f, 0.02025086f, 0.01203368f, -0.04987859f, 0.03033190f, -0.02824707f, 
    -0.00492406f, -0.03756918f, -0.05186885f, 0.00443923f, 0.02213739f, -0.06741788f, 0.02532294f, 0.05232650f, 
    -0.01721800f, -0.05959758f, -0.04583967f, 0.01042018f, -0.05606009f, -0.05162040f, -0.08295720f, -0.04532548f, 
    0.02738334f, 0.02593956f, -0.07538683f, -0.03789751f, -0.00580081f, 0.03563770f, -0.02300716f, -0.09905165f, 
    -0.05074177f, 0.04134524f, 0.01664019f, 0.00055281f, -0.02009674f, -0.02896177f, -0.00684172f, -0.00465413f, 
    -0.03674990f, 0.05089242f, -0.04614715f, 0.05827705f, 0.05357150f, 0.09500119f, 0.05854095f, -0.03144177f, 
    -0.16886412f, -0.16446030f, 0.23028608f, 0.38008559f, 0.02693298f, 0.26857156f, -0.16508727f, 0.03126476f, 
    -0.04673848f, 0.15516770f, -0.05594611f, 0.26758376f, 0.15787074f, -0.05599992f, -0.08375577f, 0.13760178f, 
    -0.09628707f, -0.13824640f, 0.00001355f, 0.08941578f, 0.01260213f, 0.04897583f, 0.14494726f, 0.05012149f, 
    -0.07529216f, 0.06632025f, -0.01415853f, 0.09783900f, -0.12494676f, 0.01025952f, 0.02214780f, 0.05435538f, 
    0.03761492f, -0.02115261f, 0.03407447f, 0.00767195f, 0.13685723f, 0.00280365f, 0.02782750f, -0.09340368f, 
    0.00446340f, 0.00562328f, -0.01648666f, 0.11185577f, -0.01566902f, -0.03181730f, -0.06977221f, -0.11357275f, 
    -0.06093388f, -0.01286130f, 0.09486510f, -0.04467983f, 0.05666573f, 0.10982467f, -0.01447556f, -0.17130771f, 
    -0.00709499f, 0.10255519f, 0.11127176f, 0.04618406f, -0.08954201f, -0.08668405f, 0.11478794f, -0.22092652f, 
    -0.45049036f, -0.24171735f, 0.00058787f, -0.05360648f, 0.00428674f, -0.05735505f, -0.08462647f, -0.02022344f, 
    -0.11341645f, 0.07797531f, 0.08135258f, 0.21318954f, -0.06238753f, -0.13476388f, 0.10077544f, -0.03991919f, 
    -0.03520871f, -0.11493090f, 0.02906047f, -0.06534965f, -0.13719539f, 0.15597735f, -0.07777147f, 0.13935307f, 
    -0.18570490f, -0.00968132f, 0.06334770f, 0.20851465f, 0.09592669f, 0.02444067f, -0.07077608f, 0.05328255f, 
    -0.06187335f, 0.11212189f, -0.00659846f, 0.04521587f, 0.00316883f, -0.01549198f, -0.12747239f, 0.07188869f, 
    0.07367433f, -0.08298703f, -0.06258354f, 0.04580206f, 0.05429557f, 0.04174617f, 0.04019471f, 0.04308961f, 
    0.13211133f, 0.09594858f, 0.10102651f, -0.05275168f, -0.05502488f, -0.15259957f, -0.18960650f, -0.24075156f, 
    -0.07317209f, -0.19421105f, -0.10970247f, -0.11640878f, -0.16666032f, -0.10121527f, 0.06482901f, -0.50125015f, 
    -0.35304514f, -0.25021604f, 0.01103646f, -0.02624089f, 0.03409984f, 0.08548111f, -0.12554668f, 0.05396246f, 
    -0.25259417f, -0.01386184f, 0.14291985f, 0.05425694f, 0.00110718f, 0.09169552f, 0.02246815f, 0.10062744f, 
    -0.18569604f, -0.06015700f, -0.12780547f, -0.11122772f, 0.07053547f, 0.14429241f, 0.01347806f, 0.13129327f, 
    -0.13553117f, 0.11459697f, -0.14586359f, -0.02267244f, -0.16373852f, 0.12626800f, -0.01305311f, 0.09443619f, 
    0.00620401f, -0.06773175f, -0.04375453f, -0.11161951f, -0.03872198f, -0.10190740f, -0.05365709f, -0.11166570f, 
    -0.07912680f, -0.00396269f, -0.01843349f, 0.12604298f, -0.12777184f, -0.15541773f, 0.08609514f, -0.09726483f, 
    0.11514231f, -0.01310241f, 0.06425925f, -0.05006658f, 0.10886694f, -0.16455272f, -0.31728992f, -0.15118037f, 
    0.06274445f, 0.06129524f, 0.03984202f, 0.03286780f, -0.03203995f, -0.10511638f, -0.32574964f, -0.16680336f, 
    -0.35029560f, 0.07182121f, 0.16251905f, 0.19435392f, -0.04957712f, -0.02371836f, -0.14976604f, 0.06976547f, 
    0.13632812f, 0.14669678f, -0.18258739f, 0.05372969f, 0.10893461f, 0.04515066f, 0.08847234f, 0.06502075f, 
    0.12592770f, -0.02016568f, -0.14803942f, 0.00598712f, 0.05909657f, -0.03177862f, -0.01365495f, 0.16949306f, 
    -0.06591287f, 0.16981673f, -0.01338023f, 0.01567446f, -0.02122162f, 0.08885214f, 0.02614459f, 0.05127474f, 
    -0.05435104f, 0.02372998f, -0.04776181f, 0.03185541f, 0.17287970f, 0.02371060f, -0.05925633f, 0.02942035f, 
    -0.11262535f, -0.00396750f, 0.03710592f, 0.04465005f, -0.12616102f, -0.19268502f, -0.06834056f, 0.06859165f, 
    0.02287072f, 0.00790822f, 0.05481091f, 0.00428230f, 0.08925345f, 0.17192841f, -0.09272292f, 0.02088766f, 
    0.07904010f, -0.00793963f, -0.01579072f, 0.10757093f, 0.22424495f, 0.13243100f, 0.26159447f, 0.23840283f, 
    0.05838094f, 0.04397942f, -0.15719798f, 0.11105345f, -0.03612729f, 0.09946901f, 0.14068925f, 0.17889746f, 
    -0.10305097f, -0.00820892f, 0.17184542f, -0.15471715f, 0.07250798f, 0.08029862f, 0.08580572f, 0.22221622f, 
    0.10415963f, 0.12535080f, 0.14337702f, 0.00674678f, 0.06784020f, -0.08868584f, 0.03352021f, 0.05192503f, 
    -0.03098779f, 0.02128441f, 0.02432764f, -0.02877171f, 0.05582589f, -0.05199001f, 0.01884847f, -0.06245548f, 
    -0.04512271f, -0.01706014f, -0.00893537f, -0.03114070f, 0.04456390f, 0.05128986f, -0.04393568f, -0.04063906f, 
    -0.00398574f, 0.05315149f, -0.06310202f, 0.00353718f, -0.03485358f, -0.00062215f, 0.01790847f, 0.02446588f, 
    -0.05589299f, 0.02697789f, -0.00991556f, -0.05739828f, 0.01278943f, -0.04839347f, -0.01604569f, 0.01248523f, 
    -0.04148837f, -0.00684952f, 0.04417524f, -0.01734000f, 0.00052127f, 0.03040569f, 0.02467717f, -0.04013650f, 
    -0.03409708f, -0.01715192f, 0.02466503f, -0.04667592f, -0.04966971f, 0.01492631f, 0.05179607f, -0.00987567f, 
    -0.00117829f, -0.03077510f, 0.03840745f, -0.01634890f, 0.01515622f, -0.03943074f, -0.03256053f, -0.03545941f, 
    -0.00986825f, -0.05767296f, 0.03217740f, -0.04819494f, -0.01518534f, -0.03765407f, 0.01759396f, -0.00007915f, 
    0.01086662f, -0.03771993f, -0.06192368f, -0.02538668f, -0.01002256f, -0.04716944f, 0.04897327f, -0.05697669f, 
    -0.01635670f, -0.05291553f, -0.01175943f, -0.03728668f, 0.03274792f, 0.03296902f, 0.03435546f, -0.02674682f, 
    -0.02220814f, -0.01003490f, 0.00716998f, 0.04015504f, 0.04857213f, -0.01629016f, 0.04671990f, 0.04504833f, 
    -0.02383269f, 0.03928107f, -0.00163071f, -0.04675674f, 0.04140265f, 0.03240456f, 0.02771957f, 0.05198523f, 
    0.04962956f, -0.02223949f, -0.00486958f, -0.01983204f, -0.03877044f, -0.01977574f, 0.01882051f, -0.00994439f, 
    -0.02225839f, -0.03419900f, -0.03681339f, -0.04456051f, 0.02974221f, 0.00219975f, 0.05178754f, -0.01748841f, 
    -0.02569631f, -0.00035937f, 0.00502543f, -0.05836753f, 0.03768042f, -0.02884123f, 0.01466231f, 0.00502087f, 
    -0.05852354f, 0.04999404f, -0.04574272f, 0.01521782f, -0.05157686f, 0.02200812f, 0.01129812f, -0.01890116f, 
    -0.04123700f, -0.00105807f, 0.00209324f, -0.02984655f, -0.06477258f, -0.06584267f, -0.02900015f, 0.03665826f, 
    -0.06191826f, 0.02523811f, 0.03048489f, -0.04936640f, -0.03266605f, -0.05303203f, -0.05893471f, 0.04861998f, 
    -0.02888255f, -0.02928762f, 0.03592231f, -0.00045643f, 0.02824135f, -0.04091470f, 0.00961479f, 0.01271577f, 
    -0.00025676f, 0.00462652f, -0.00057071f, -0.02083901f, 0.04431764f, -0.00965512f, -0.04944948f, -0.01226576f, 
    -0.06334934f, -0.03340079f, 0.02200261f, 0.04645379f, 0.00728563f, -0.02241436f, -0.06010609f, 0.00938477f, 
    0.00235734f, -0.00730922f, -0.00771198f, 0.03209834f, -0.04157803f, -0.01966462f, -0.00127558f, -0.06441936f, 
    -0.02942215f, -0.02848592f, -0.00547981f, 0.03897480f, 0.03448362f, 0.03530955f, -0.04844169f, 0.02751749f, 
    -0.05592337f, 0.05679132f, 0.01853082f, -0.03260285f, 0.01056244f, -0.00818985f, -0.02740591f, 0.02742382f, 
    -0.01317670f, -0.04964753f, 0.02285799f, 0.03093362f, -0.01278868f, 0.00208854f, 0.03625187f, -0.02027382f, 
    -0.04128290f, 0.03331428f, 0.04038894f, 0.04536082f, 0.03242432f, -0.04820845f, -0.01858667f, 0.01815320f, 
    0.00138632f, -0.03658009f, -0.05742458f, -0.05135034f, -0.06474015f, -0.00871787f, -0.00108457f, -0.05194272f, 
    -0.00328597f, 0.04084822f, 0.03654931f, -0.05815880f, 0.03886213f, -0.06031491f, -0.02988366f, 0.03967206f, 
    0.02133066f, -0.05455719f, -0.02808523f, 0.02417333f, 0.02197141f, -0.04240928f, 0.01851756f, -0.04124450f, 
    -0.01394931f, 0.03934207f, 0.04243874f, 0.01465136f, -0.02983790f, -0.05204237f, -0.01665647f, -0.02902750f, 
    0.04722929f, -0.02573851f, 0.05292554f, -0.02772069f, -0.03822073f, -0.05946587f, -0.02089982f, 0.01989662f, 
    -0.00398183f, -0.02521096f, -0.03130010f, -0.00185902f, -0.05681504f, -0.01641319f, 0.04131021f, 0.00178425f, 
    0.00758367f, -0.06077011f, 0.00985271f, -0.01713897f, -0.02186011f, 0.02157570f, -0.05940094f, -0.03071942f, 
    -0.06370961f, -0.05543120f, 0.02983368f, 0.03290969f, 0.01755838f, 0.01234560f, 0.01915281f, -0.04116612f, 
    0.00614055f, -0.00364352f, -0.03690042f, -0.02880633f, 0.03470991f, -0.04924726f, -0.03419909f, 0.02810463f, 
    -0.06110128f, -0.01481857f, 0.02938125f, -0.00860366f, -0.04962022f, 0.04445737f, 0.04580604f, 0.01289889f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.08569273f, -0.03825780f, -0.03569297f, -0.04817764f, 0.17561366f, 0.11523658f, -0.00804259f, 0.04747108f, 
    0.00639305f, -0.02408465f, 0.05184493f, 0.01364667f, -0.01890803f, -0.03031528f, 0.07117000f, 0.21266645f, 
    -0.04618377f, 0.01813785f, 0.02480842f, 0.03534044f, 0.07548694f, 0.04604123f, 0.06251293f, 0.09405107f, 
    0.00695516f, 0.02955124f, 0.00452349f, -0.07964466f, 0.01429716f, -0.01242615f, 0.09184328f, -0.01410406f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.24770552f, -0.08827899f, 0.17468730f, 0.10041043f, 0.36984810f, 0.35748252f, 0.15271889f, 0.05469661f, 
    -0.00855737f, -0.08824982f, 0.04974987f, -0.09445500f, 0.06972596f, -0.05213823f, -0.04942607f, 0.01641487f, 
    -0.28117070f, 0.03982545f, -0.13423768f, 0.11901443f, 0.27269706f, -0.09688615f, -0.16782913f, 0.37931982f, 
    -0.06013071f, -0.09107488f, 0.08582673f, -0.07967725f, -0.11253431f, -0.10814037f, -0.07539065f, 0.00660170f, 
    0.34953204f, 0.07169066f, 0.11031067f, 0.06939976f, 0.17276886f, 0.13815555f, 0.14487572f, 0.14148620f, 
    -0.08301530f, -0.00593663f, 0.03286655f, 0.17347445f, -0.15613900f, 0.16298957f, 0.23299013f, 0.03452140f, 
    0.22856122f, 0.06176273f, 0.13421792f, 0.16752684f, -0.29375154f, 0.07769989f, -0.31344077f, 0.34920767f, 
    -0.09628605f, -0.13778009f, 0.07728166f, -0.07625760f, -0.47891706f, -0.15536423f, -0.11739998f, 0.10040610f, 
    0.18427861f, -0.01483763f, -0.10745569f, -0.31487846f, 0.06639460f, 0.41778967f, -0.28388476f, -0.02838103f, 
    0.00019438f, -0.14886831f, -0.05225438f, -0.13524234f, 0.09049130f, 0.06478569f, -0.08910536f, 0.19993891f, 
    0.26779601f, 0.01310158f, -0.16525675f, -0.15393835f, -0.33680409f, 0.13812511f, 0.20414531f, -0.22098024f, 
    -0.13796803f, 0.20602065f, -0.14092581f, -0.10247453f, -0.18118379f, -0.02979376f, -0.19098449f, -0.03800651f, 
    -0.13350980f, 0.15400712f, -0.01942802f, -0.28342417f, -0.20809968f, -0.05921589f, -0.27473530f, -0.12516040f, 
    -0.02657299f, 0.12820631f, -0.01519282f, 0.13765466f, 0.14823338f, -0.11306816f, 0.23718540f, 0.30449501f, 
    0.34628320f, -0.00721605f, 0.11506235f, -0.07845948f, -0.32121721f, -0.14117990f, 0.18725255f, 0.06002373f, 
    0.00592102f, 0.02795674f, -0.14065938f, 0.14203569f, -0.04186701f, -0.01203572f, -0.08653656f, 0.12770385f, 
    0.30262515f, -0.03039026f, -0.13559003f, 0.32957035f, 0.16073637f, 0.13817212f, -0.21994381f, -0.04329235f, 
    0.00406121f, -0.02667081f, -0.00313208f, 0.20655029f, -0.09186344f, 0.14120571f, 0.26782960f, -0.05229498f, 
    -0.19500294f, 0.10143693f, 0.04667337f, 0.12161066f, -0.01264204f, 0.10761532f, 0.00200859f, 0.12762560f, 
    -0.03333231f, -0.10895284f, 0.13122042f, -0.00199109f, 0.35851508f, -0.13544880f, -0.19097203f, -0.03176006f, 
    0.03430509f, 0.16919923f, -0.04097979f, 0.12262674f, 0.13036245f, 0.09046969f, -0.04545923f, -0.12493847f, 
    -0.01834662f, -0.02810471f, 0.15944982f, -0.02933575f, 0.09794755f, -0.11918919f, -0.14864810f, -0.19280420f, 
    0.04712798f, -0.17432012f, 0.14701983f, 0.03427941f, 0.05778571f, -0.08537315f, 0.00687848f, 0.05183377f, 
    0.12389315f, -0.08323915f, 0.08656459f, -0.02746185f, -0.06587216f, 0.16357039f, -0.04623503f, 0.09722073f, 
    0.04927187f, -0.09471469f, 0.10223301f, -0.37710470f, -0.16623771f, 0.25660405f, -0.13575019f, 0.09142826f, 
    -0.07775538f, 0.07175785f, 0.05999630f, 0.16199648f, 0.07856043f, -0.03762038f, -0.29893175f, -0.00193641f, 
    0.20917441f, -0.05367185f, 0.08796037f, 0.15221213f, 0.27715674f, 0.05173254f, 0.06526128f, 0.60669160f, 
    0.12192594f, -0.07786655f, -0.04862119f, -0.03452120f, 0.25253463f, 0.06571733f, 0.16815497f, -0.10761595f, 
    0.22976652f, -0.03395870f, -0.00454022f, 0.12551337f, 0.23829642f, -0.00644694f, 0.11589432f, -0.06892561f, 
    -0.00125439f, -0.07904413f, -0.10375436f, -0.06297942f, -0.07789683f, -0.15223016f, 0.24922384f, -0.16389613f, 
    -0.36695367f, -0.01517204f, -0.06492367f, 0.00217307f, 0.40130895f, -0.06463900f, 0.02764644f, -0.18956327f, 
    -0.05634527f, 0.16408516f, 0.13908678f, -0.13458703f, 0.36766273f, -0.09514087f, -0.03849274f, 0.08067547f, 
    0.23312549f, 0.01877553f, -0.11387311f, 0.05252212f, -0.36252701f, -0.33118212f, 0.25738066f, -0.04543398f, 
    0.12405451f, 0.01096939f, -0.09195521f, 0.05981333f, 0.13001534f, 0.11074535f, -0.13210431f, 0.15403832f, 
    0.00817156f, 0.12248017f, 0.16397245f, -0.07549509f, -0.14696136f, 0.16588683f, 0.22121379f, -0.13259360f, 
    -0.03014259f, 0.31670418f, 0.08430895f, -0.16755225f, 0.24885029f, -0.05459187f, -0.00653894f, 0.05210356f, 
    -0.05108634f, -0.11201634f, 0.16964087f, -0.33210009f, 0.04087835f, 0.24530682f, 0.29684561f, 0.03581013f, 
    -0.16430709f, -0.07445854f, 0.14471656f, 0.02615290f, -0.05819508f, 0.14947556f, 0.05526792f, -0.24740411f, 
    0.07693870f, -0.04368104f, 0.11483815f, 0.03962693f, 0.30730674f, 0.00475033f, 0.28425124f, -0.39746606f, 
    -0.02858043f, 0.00923290f, 0.12232471f, 0.12650925f, -0.09988064f, 0.08144495f, 0.07070271f, -0.08143114f, 
    0.04367799f, -0.12511325f, 0.07119456f, -0.40825447f, -0.16670680f, 0.00339792f, -0.28773981f, 0.01378692f, 
    -0.10553890f, 0.06217305f, -0.17736542f, 0.07099678f, -0.04249619f, -0.12057909f, 0.14488037f, 0.17308706f, 
    -0.00852047f, 0.00784008f, 0.16679348f, 0.09688758f, -0.03097067f, 0.17581300f, -0.16315106f, 0.23518580f, 
    0.10089144f, 0.01679143f, -0.16255720f, -0.13417956f, -0.17343190f, 0.14637209f, 0.30700213f, 0.10686707f, 
    0.09065813f, -0.08978171f, -0.07331154f, 0.33396149f, 0.33635971f, -0.11590253f, 0.13821860f, -0.06220229f, 
    -0.05242214f, -0.10528921f, 0.09990223f, -0.13704745f, 0.04025087f, 0.12485503f, -0.11296126f, -0.21038762f, 
    -0.16758807f, -0.04246384f, -0.01009866f, 0.16011828f, 0.45833322f, 0.05051505f, -0.12175281f, 0.25013775f, 
    -0.10383847f, 0.13470115f, 0.17760397f, 0.13729557f, -0.20005827f, -0.12569940f, -0.01493549f, -0.15683310f, 
    0.09674236f, 0.02049484f, -0.14455393f, 0.38614115f, 0.05014353f, 0.14344513f, -0.70110387f, 0.04655178f, 
    -0.09774876f, 0.10818486f, 0.12663378f, 0.04755208f, 0.04787684f, -0.14848442f, -0.08542238f, 0.01651683f, 
    0.04289602f, -0.13752438f, 0.16260636f, 0.16843621f, -0.16024184f, 0.11397033f, -0.05142906f, 0.06566339f, 
    0.13237593f, -0.01727940f, 0.11734748f, -0.11049867f, -0.34712461f, 0.01813282f, 0.36820841f, 0.15299816f, 
    0.07309993f, 0.05871467f, 0.01497286f, -0.02877945f, -0.17827052f, 0.04815697f, 0.04290535f, -0.16393796f, 
    -0.10600945f, 0.00743711f, -0.16160065f, -0.14504014f, -0.07925114f, 0.06165351f, -0.15611847f, -0.16561636f, 
    0.02280929f, 0.01533834f, -0.13705406f, -0.12850618f, -0.21734479f, 0.05825860f, 0.00569472f, -0.09158961f, 
    -0.16928214f, -0.10604213f, 0.13119726f, 0.05392532f, 0.06759448f, 0.00506206f, -0.16935992f, 0.00534523f, 
    0.15194991f, 0.07223857f, 0.03374743f, -0.25224644f, -0.16679288f, -0.13498105f, -0.47320560f, 0.07368813f, 
    -0.08741764f, -0.07357363f, -0.15666862f, -0.07888471f, -0.14164086f, 0.04770859f, 0.03399666f, 0.26443213f, 
    -0.13219784f, -0.10403227f, 0.16582556f, -0.12241611f, 0.06685626f, -0.11761026f, 0.40281433f, -0.07041061f, 
    0.07115360f, -0.03890483f, -0.11169749f, 0.06692199f, 0.26795533f, 0.17057382f, 0.15186049f, 0.01534794f, 
    -0.08511664f, 0.10482758f, -0.00030968f, 0.09553675f, -0.24793649f, -0.11649259f, -0.14846270f, -0.10810927f, 
    0.13082410f, 0.12198131f, 0.13933429f, -0.09561492f, 0.15090533f, 0.11003156f, 0.01329395f, 0.24799405f, 
    0.22894043f, -0.01451312f, -0.02631726f, -0.00641296f, -0.20639785f, -0.06989507f, 0.14857808f, -0.19060382f, 
    -0.14394368f, -0.08347853f, 0.02820925f, -0.09162802f, 0.16039814f, 0.13395606f, 0.16494630f, 0.14286438f, 
    -0.17943461f, 0.04406966f, -0.03883555f, 0.22198191f, 0.19119893f, -0.05329517f, 0.22235475f, 0.00439479f, 
    0.07076093f, -0.15314461f, -0.13367367f, 0.11651498f, 0.16852258f, -0.00371943f, 0.35380617f, 0.17285125f, 
    -0.07347545f, 0.14692420f, -0.11927260f, -0.11274138f, 0.02364377f, -0.05444765f, -0.22029190f, 0.43203384f, 
    0.13476267f, -0.03681909f, -0.14489381f, -0.10611355f, -0.09569676f, -0.01898746f, -0.17259285f, -0.11549686f, 
    -0.09261711f, 0.04169569f, -0.08231551f, 0.04879399f, 0.05690407f, 0.66238600f, -0.10042000f, 0.05410363f, 
    0.04155503f, 0.12314985f, -0.15188906f, 0.10947290f, -0.03076990f, -0.14132704f, -0.17615019f, -0.04389296f, 
    0.04270059f, 0.17853341f, 0.11612576f, 0.07368300f, 0.12757398f, -0.01741910f, -0.16375366f, 0.24305157f, 
    0.05086016f, 0.27810341f, 0.03710741f, -0.08276929f, 0.14217454f, -0.07130096f, 0.11671200f, -0.05033176f, 
    -0.12672076f, -0.13520294f, 0.15278494f, 0.18211804f, -0.08095093f, -0.08288471f, -0.18349174f, 0.07522559f, 
    -0.14659874f, 0.06547859f, -0.03785569f, 0.09598665f, -0.08330767f, -0.04771578f, 0.25529635f, -0.30968627f, 
    0.07542746f, -0.09443258f, 0.08080605f, -0.09038944f, 0.58413774f, -0.09816534f, 0.30031174f, 0.21758656f, 
    -0.01954242f, 0.36177221f, -0.13837431f, -0.05631118f, -0.01994078f, -0.01133958f, 0.01568023f, -0.01257308f, 
    0.03552379f, 0.01841016f, 0.06826376f, 0.06770149f, 0.09507119f, -0.01252190f, 0.10703297f, -0.02846342f, 
    -0.15238050f, 0.08058251f, 0.16168897f, 0.08302427f, -0.08836655f, 0.11793534f, 0.01009384f, -0.09296411f, 
    -0.08048506f, -0.00151054f, -0.07809602f, 0.14643674f, 0.05170831f, 0.15230250f, -0.23646186f, 0.00090837f, 
    -0.01196695f, -0.19301181f, 0.07858778f, -0.11782627f, -0.15766037f, 0.11126271f, -0.00874394f, 0.13786487f, 
    0.36106962f, 0.17327058f, -0.04991556f, 0.19275291f, 0.01572997f, 0.34374052f, -0.52703691f, 0.14007464f, 
    0.04280186f, -0.00009510f, 0.12273731f, -0.11347347f, -0.02669662f, -0.07954752f, -0.06143835f, 0.17587967f, 
    -0.17962663f, -0.13288958f, 0.00666456f, -0.04202900f, 0.01574166f, 0.07685297f, -0.34216875f, 0.32697535f, 
    0.03594973f, -0.04230388f, 0.04134050f, 0.02653082f, -0.26570475f, 0.16713488f, -0.11047193f, 0.08840812f, 
    0.08000805f, 0.10960036f, -0.10312851f, -0.01037433f, 0.09064805f, -0.25605074f, -0.16761239f, 0.07429309f, 
    0.10506877f, -0.05002612f, -0.08960803f, 0.05451417f, 0.04486616f, -0.09132718f, 0.14779958f, 0.28026754f, 
    -0.15780178f, 0.16792533f, 0.18189967f, -0.03664658f, -0.07185882f, 0.16968162f, 0.30341142f, -0.30602279f, 
    0.07932688f, 0.34744912f, -0.14892009f, -0.05538702f, 0.38999650f, -0.03818692f, -0.12893465f, 0.04563311f, 
    -0.18876442f, 0.15506281f, 0.07168279f, -0.14598183f, -0.00472936f, -0.19107836f, -0.31689075f, 0.03494165f, 
    -0.10191755f, 0.06518330f, 0.09262233f, -0.10025797f, 0.04234101f, -0.09099582f, 0.41345620f, 0.25023177f, 
    0.07591791f, -0.10060744f, -0.05287769f, 0.04327784f, -0.18950382f, -0.11538159f, 0.30103534f, 0.02876410f, 
    -0.02656102f, -0.15606174f, -0.16775379f, -0.11022325f, -0.20106700f, 0.10470029f, 0.12406353f, 0.07724182f, 
    0.02606483f, 0.06596895f, 0.16966790f, 0.39273515f, -0.38777578f, -0.06654565f, 0.26921606f, 0.13271119f, 
    0.11359398f, -0.00839942f, 0.08784653f, -0.00953172f, -0.15914324f, -0.11860908f, 0.17104952f, 0.13556756f, 
    -0.12018001f, 0.08442298f, -0.05412302f, 0.07749990f, -0.15685038f, -0.13018169f, -0.30145037f, -0.29438746f, 
    -0.12024534f, 0.13965482f, -0.17384072f, 0.09126209f, -0.32883567f, 0.07913963f, 0.42762998f, -0.09554331f, 
    0.26768851f, -0.14210311f, -0.11086039f, 0.45513931f, 0.04152653f, 0.14911841f, 0.23665774f, -0.03714969f, 
    0.11045199f, 0.12503235f, 0.17591213f, 0.00151492f, 0.04045566f, -0.04305747f, -0.14177006f, 0.03717967f, 
    -0.14026007f, 0.12622832f, -0.16535933f, 0.00023754f, 0.04065921f, -0.04811527f, -0.31193945f, 0.29053468f, 
    -0.09586475f, -0.03461156f, 0.10902796f, -0.15256153f, -0.16508722f, -0.15337224f, -0.06035083f, -0.09160551f, 
    0.30299550f, 0.09660783f, -0.20237558f, -0.10232126f, -0.22588621f, -0.28210700f, -0.20551530f, -0.09609965f, 
    -0.11013928f, 0.11225386f, -0.02037243f, 0.08755776f, -0.05828993f, 0.16675797f, 0.19970517f, 0.06350958f, 
    -0.17909577f, 0.08963363f, -0.15181960f, -0.09516891f, 0.05978752f, 0.16236264f, -0.15528290f, -0.11820807f, 
    0.10602368f, -0.05702183f, 0.11197283f, 0.11601567f, -0.00943918f, 0.10192724f, 0.30677745f, -0.11825433f, 
    0.16334468f, 0.13700955f, 0.18394636f, 0.14952186f, 0.00828480f, -0.05604922f, 0.19315869f, 0.07067624f, 
    -0.07068965f, -0.01396034f, 0.05556336f, 0.02859732f, -0.17350990f, 0.12154362f, -0.29812732f, -0.01533863f, 
    0.18568584f, -0.10047223f, -0.17869261f, -0.15542769f, 0.17144850f, 0.04941980f, -0.13086452f, -0.09367143f, 
    0.09503362f, 0.36414805f, 0.14457552f, 0.08265280f, 0.53755331f, -0.07284806f, -0.39885756f, 0.16375074f, 
    -0.05860358f, -0.19082585f, -0.11970823f, -0.19343916f, 0.24916025f, 0.36426353f, -0.24584764f, -0.03028321f, 
    -0.09749993f, 0.15380639f, 0.10318068f, -0.11998266f, -0.04563997f, 0.03027887f, -0.11404016f, 0.20645010f, 
    0.03650785f, 0.02084215f, -0.17389031f, 0.06916419f, 0.08513561f, 0.10017560f, 0.28423676f, -0.21973017f, 
    -0.08790877f, 0.34941807f, 0.01105751f, 0.06136125f, -0.04772651f, 0.07946821f, -0.02292486f, 0.08288820f, 
    -0.07822530f, 0.11527892f, 0.09179534f, -0.30871043f, -0.03543121f, 0.22899964f, 0.37817875f, 0.14230171f, 
    -0.13699795f, -0.14958543f, -0.04988533f, 0.12929140f, -0.08869959f, -0.09562542f, -0.19042885f, 0.06152632f, 
    0.42939085f, 0.03119958f, 0.02535360f, -0.09610590f, -0.22950505f, 0.14098798f, 0.20095789f, -0.00383836f, 
    -0.10708512f, 0.42605278f, 0.15240784f, -0.12069888f, 0.22687316f, -0.12611619f, -0.07891441f, 0.01477143f, 
    -0.22092609f, 0.02256533f, -0.01318515f, -0.23224691f, 0.21455193f, 0.21690078f, 0.07229655f, -0.00882185f, 
    0.06144809f, 0.06366204f, -0.16080566f, 0.03685591f, -0.01608605f, -0.17367981f, -0.14911246f, -0.06154254f, 
    0.29197094f, 0.10636429f, 0.16486344f, -0.06996666f, 0.29428506f, -0.04582325f, 0.22590795f, 0.04488756f, 
    -0.16181789f, 0.39768749f, -0.12048969f, -0.01820599f, 0.31586811f, 0.12548091f, 0.01199520f, -0.01503745f, 
    0.17872229f, -0.17141387f, 0.07033261f, -0.05996010f, 0.10051313f, 0.41029418f, -0.09007977f, 0.04479797f, 
    0.12546079f, 0.12336745f, 0.07049657f, -0.15754044f, 0.10062871f, -0.02322267f, -0.07593151f, 0.20700245f, 
    0.22008817f, -0.07563147f, 0.11685432f, -0.04096314f, -0.37152046f, -0.00972611f, 0.00692126f, -0.16906109f, 
    0.02338913f, 0.12443188f, -0.02175425f, -0.02781667f, -0.43779370f, 0.07751442f, 0.06682820f, -0.01308263f, 
    0.37943718f, -0.09639478f, 0.06907155f, -0.00381102f, -0.27610442f, -0.06274569f, -0.14610794f, -0.05587248f, 
    -0.00274178f, 0.13672377f, -0.12267028f, -0.15745810f, 0.01990751f, 0.05625953f, 0.05183318f, 0.11306775f, 
    -0.01799938f, -0.01142334f, -0.09564740f, 0.05468003f, -0.13646807f, -0.13563369f, 0.05228354f, -0.28603563f, 
    -0.12122259f, 0.12284485f, -0.10623696f, -0.08768132f, 0.32709944f, -0.02612172f, -0.11144076f, -0.05444428f, 
    -0.19663520f, 0.16851494f, 0.20418660f, 0.29767916f, 0.21533570f, -0.10508529f, -0.00245274f, -0.10135522f, 
    -0.04667882f, -0.13158658f, 0.08139043f, 0.10883560f, 0.13337548f, 0.05761923f, -0.05894270f, 0.22302148f, 
    -0.30070612f, 0.04288728f, 0.17425451f, -0.06921432f, 0.40244296f, 0.12720610f, -0.16753830f, -0.00859617f, 
    0.16542648f, 0.05609823f, -0.13985200f, 0.00122052f, -0.10853581f, -0.02842760f, 0.24479415f, -0.11291452f, 
    0.25562835f, 0.00714821f, -0.03759774f, -0.17805913f, 0.18515283f, 0.17508808f, 0.22035402f, -0.03056642f, 
    0.03424281f, -0.04529176f, 0.16029969f, 0.12835105f, -0.07691413f, -0.04303923f, 0.07216777f, 0.35854992f, 
    0.05530329f, -0.06934389f, -0.08081932f, 0.01931262f, -0.54337204f, 0.03810121f, -0.08943783f, -0.21264054f, 
    -0.00565599f, -0.02519666f, -0.03294951f, 0.08749226f, -0.45413685f, 0.02385145f, -0.00310900f, 0.12073061f, 
    -0.23577009f, -0.02468233f, 0.15601127f, 0.17306054f, -0.20130858f, 0.18172120f, 0.28135735f, 0.07153098f, 
    0.03501543f, 0.09746262f, 0.10197797f, 0.08717475f, 0.12975016f, -0.11504526f, -0.27194935f, -0.20650597f, 
    0.08134988f, 0.15502742f, 0.16393033f, -0.01680179f, -0.24446140f, -0.14660189f, 0.04164149f, 0.06413823f, 
    0.01190529f, -0.50907028f, 0.09226608f, -0.09433841f, 0.20271704f, 0.19385555f, 0.23376632f, 0.16337471f, 
    -0.05199010f, -0.05159248f, 0.10270700f, 0.35277331f, -0.10839232f, -0.40237707f, -0.17276368f, 0.03587228f, 
    0.00532298f, 0.09109289f, -0.15665923f, -0.08600532f, 0.17762338f, -0.02093179f, -0.06052041f, 0.17797104f, 
    -0.08414958f, 0.09530566f, 0.11378548f, 0.16288094f, 0.14678280f, 0.04317081f, -0.26014942f, 0.17966685f, 
    0.11585059f, -0.05707127f, -0.15693656f, 0.15169932f, -0.33121914f, -0.05464217f, 0.40549198f, -0.09339882f, 
    0.08152537f, 0.07410920f, -0.11392031f, 0.40218604f, 0.47839299f, 0.20883961f, -0.14325906f, 0.08505481f, 
    0.12832497f, -0.03736418f, 0.11661523f, -0.00982543f, -0.00416082f, -0.07891195f, 0.30169985f, 0.25539324f, 
    -0.39717069f, -0.09550009f, -0.15308997f, 0.16547728f, -0.26779696f, 0.06662612f, 0.12787931f, 0.13004312f, 
    -0.09574993f, 0.08598921f, -0.02508973f, -0.08986942f, -0.55254787f, -0.10570983f, -0.31688887f, 0.02730801f, 
    0.00008859f, -0.15275364f, 0.07330723f, 0.04046514f, -0.14313938f, 0.20581168f, 0.21817814f, -0.00857223f, 
    -0.09149950f, -0.02961720f, 0.12976435f, 0.11857266f, 0.04281218f, -0.12191172f, -0.14826369f, 0.04486975f, 
    -0.05565958f, 0.04506613f, -0.11099786f, -0.12492321f, 0.11852635f, -0.16560626f, -0.09787224f, 0.11185426f, 
    -0.00077447f, -0.07465771f, 0.00099483f, 0.09107938f, -0.01359923f, -0.08012506f, -0.13768813f, -0.09956525f, 
    0.31959036f, -0.16069166f, -0.09148815f, 0.12064946f, -0.10739139f, -0.12941684f, 0.27880070f, -0.16852240f, 
    0.06612360f, 0.10588139f, -0.13844191f, 0.00482946f, 0.06627747f, 0.16459316f, -0.26670283f, 0.25734621f, 
    0.06309476f, 0.17028940f, -0.11389640f, 0.15817049f, -0.07586358f, 0.15584362f, -0.43310389f, -0.10564972f, 
    -0.11233483f, 0.03989431f, 0.10130186f, 0.04924689f, -0.22761466f, 0.04074092f, 0.24871187f, -0.00992526f, 
    -0.06987706f, -0.01664501f, 0.15714920f, -0.13476282f, -0.20959681f, 0.02754770f, 0.02400821f, -0.13990124f, 
    -0.13736956f, 0.11496291f, 0.15642706f, -0.15356854f, 0.11040063f, 0.04701262f, -0.20990419f, -0.21905977f, 
    -0.11152023f, -0.14199904f, 0.10202582f, 0.12501773f, 0.01322250f, 0.16562718f, -0.20339023f, -0.04538975f, 
    -0.04741333f, -0.18749262f, 0.17327772f, 0.05959330f, 0.02367133f, -0.12092767f, -0.01015094f, 0.13755703f, 
    0.09868654f, 0.10818291f, -0.03556426f, -0.47310182f, 0.33794188f, 0.53148025f, -0.22908878f, -0.07748167f, 
    -0.04387359f, 0.03558648f, -0.10680656f, -0.07748193f, 0.00700830f, 0.02261060f, 0.00201358f, 0.13988663f, 
    0.03325451f, -0.02004202f, 0.02319847f, 0.17690717f, -0.31542286f, -0.00239541f, 0.08964781f, -0.09365285f, 
    -0.00511278f, 0.12848832f, -0.15105741f, 0.08282255f, -0.21297888f, -0.03035104f, 0.02933521f, -0.13076986f, 
    -0.07045297f, 0.07194037f, 0.13516350f, 0.11709827f, -0.34436125f, 0.21083795f, -0.25042236f, 0.16024564f, 
    0.03180652f, 0.15691830f, 0.04817921f, -0.09815036f, 0.15006536f, -0.13256755f, -0.14330114f, 0.18706366f, 
    -0.09953282f, 0.05694340f, -0.14676397f, 0.08311816f, 0.09979954f, 0.07748392f, 0.31547347f, -0.10978401f, 
    0.14457753f, 0.20767464f, 0.06009412f, -0.09339443f, -0.32899064f, 0.02666118f, 0.31559259f, 0.13480420f, 
    -0.07705361f, 0.11362141f, 0.12593755f, 0.05770769f, -0.03998516f, -0.09520464f, -0.15808153f, 0.01958686f, 
    0.06701252f, 0.12902731f, 0.16084778f, -0.06055382f, -0.07852291f, -0.07903112f, -0.02142270f, -0.10599808f, 
    -0.03591963f, -0.15913859f, 0.02337822f, 0.10335787f, -0.01024227f, 0.07249459f, -0.15322098f, 0.02842487f, 
    -0.01838583f, -0.15776345f, 0.07991939f, 0.14673978f, -0.14048120f, 0.07881688f, 0.14932010f, 0.03403834f, 
    -0.01928645f, 0.08225245f, 0.07121881f, -0.04606707f, 0.12273271f, 0.36937994f, -0.17429437f, -0.12648092f, 
    -0.11494728f, -0.11207705f, 0.11220188f, -0.05082790f, 0.15552919f, 0.00509598f, -0.06518207f, 0.02737196f, 
    0.19819814f, -0.16943868f, 0.16423519f, 0.12555504f, -0.02063029f, 0.05032932f, 0.28488311f, -0.33688393f, 
    -0.07601793f, 0.33552516f, 0.13243520f, 0.05278567f, -0.05116984f, 0.20746340f, -0.18596630f, 0.09716135f, 
    -0.09195043f, -0.02377348f, 0.02494706f, -0.06962082f, 0.01779172f, -0.16568276f, -0.00837627f, 0.08248165f, 
    0.08810411f, -0.03506057f, 0.17199530f, -0.01699654f, 0.16855504f, -0.02177700f, 0.05553212f, -0.10460561f, 
    0.03346569f, -0.11916840f, -0.15699115f, -0.13523176f, -0.15188549f, 0.09426971f, -0.03638438f, -0.14993651f, 
    -0.13445947f, -0.02252812f, 0.01415668f, 0.05747071f, -0.03296938f, 0.06678535f, 0.02655121f, -0.07118248f, 
    0.02201955f, 0.03898961f, -0.17531395f, 0.42968458f, 0.38644770f, 0.14267632f, -0.14655617f, 0.05748688f, 
    0.10225678f, -0.18064791f, 0.15510996f, 0.09303957f, -0.03975491f, -0.00903652f, 0.30248001f, 0.17876722f, 
    -0.29724815f, 0.06944965f, -0.16058424f, -0.17011921f, 0.20511504f, -0.02920995f, 0.09147980f, -0.11450559f, 
    -0.09568793f, -0.30122694f, 0.07972411f, 0.00717775f, -0.18292530f, 0.00305518f, 0.12889999f, 0.10574145f, 
    0.00648962f, 0.09770149f, 0.06795675f, 0.16440114f, 0.02549233f, -0.27996761f, -0.06143445f, 0.06949891f, 
    -0.03740166f, 0.10392260f, 0.00749742f, -0.11951765f, -0.10208118f, 0.08216673f, -0.27496362f, -0.14166836f, 
    0.08712278f, -0.11133482f, -0.04624559f, -0.11092066f, -0.11561310f, -0.10547594f, -0.05268151f, 0.16585942f, 
    0.01854295f, -0.31956565f, -0.01853296f, -0.15341175f, 0.05865400f, -0.06086934f, 0.10497696f, 0.15033925f, 
    -0.01836538f, 0.07876199f, 0.02280104f, 0.32748097f, 0.05556668f, -0.12962279f, 0.45471460f, -0.13747329f, 
    -0.09577816f, -0.15124226f, 0.06856053f, 0.11675562f, -0.11752425f, 0.00405493f, -0.15133898f, 0.17109236f, 
    0.12637582f, -0.09146832f, 0.03669384f, 0.16597356f, -0.04826548f, 0.15389666f, -0.12808995f, -0.26964426f, 
    0.14292192f, 0.53172314f, -0.00054698f, 0.06790721f, -0.14650747f, -0.13726850f, -0.07484307f, -0.13845168f, 
    -0.25633991f, -0.15010342f, -0.06257138f, -0.32609552f, 0.18637213f, -0.23397887f, -0.14697881f, -0.06824867f, 
    -0.12882964f, -0.14477666f, -0.08558863f, 0.16730331f, -0.05410924f, -0.16033381f, 0.31575280f, 0.13126493f, 
    0.33716747f, -0.07921813f, 0.07242873f, -0.12776206f, -0.19686404f, 0.14050995f, 0.24166721f, -0.04982644f, 
    -0.03190337f, -0.04766838f, -0.01511297f, -0.05376061f, 0.21180798f, 0.10940293f, -0.16473652f, -0.10073554f, 
    -0.11833686f, -0.09497286f, -0.04619906f, 0.15894790f, -0.02037059f, -0.11708140f, 0.52061373f, 0.15747352f, 
    -0.18016542f, 0.09286015f, -0.14440328f, 0.16626653f, 0.07190730f, -0.15344968f, 0.33011630f, 0.06403327f, 
    0.38417819f, -0.11595161f, -0.11806155f, -0.09336846f, 0.22096221f, -0.07683869f, -0.22990857f, 0.26566491f, 
    0.17470096f, -0.22072506f, -0.04424099f, -0.13446267f, -0.01372226f, -0.19735438f, -0.08141674f, 0.16475262f, 
    0.25866163f, 0.09569649f, 0.14790626f, -0.03925523f, 0.01891564f, 0.46074179f, -0.22917436f, -0.17472598f, 
    0.01513372f, 0.13658346f, 0.10314878f, 0.05047591f, 0.12552136f, 0.16373983f, -0.17297857f, 0.40973672f, 
    -0.39367691f, -0.16983654f, 0.04986673f, 0.10499650f, -0.22445247f, 0.15076078f, 0.07467215f, 0.17578550f, 
    -0.02624338f, -0.18515810f, -0.12759921f, 0.14482580f, 0.07652869f, -0.17054671f, 0.22786359f, 0.02631193f, 
    0.19602583f, -0.05568146f, 0.19704494f, 0.38442662f, 0.14042114f, 0.35185084f, 0.20729969f, -0.14738250f, 
    -0.09687652f, 0.08159371f, -0.12356623f, -0.00429726f, 0.01663266f, -0.01731883f, 0.05152569f, 0.06029804f, 
    -0.11381780f, 0.11026334f, 0.07849883f, -0.13563350f, 0.16571587f, -0.10485062f, 0.00391463f, 0.14177077f, 
    0.00463992f, 0.01064164f, 0.17018589f, 0.06685925f, -0.10115687f, 0.12340563f, -0.55654013f, 0.05411344f, 
    0.21899037f, -0.07940553f, -0.12149934f, 0.02047286f, 0.28255171f, 0.14695829f, 0.18240322f, 0.06288214f, 
    -0.14898731f, -0.07562777f, -0.05434474f, -0.07482850f, -0.07405668f, 0.10179511f, 0.08121584f, -0.01011683f, 
    -0.16624574f, 0.00609623f, 0.03109897f, 0.10074266f, 0.37957165f, -0.09881123f, -0.26762748f, 0.43756461f, 
    -0.15593749f, -0.06476326f, -0.00031873f, 0.02821896f, 0.06880684f, -0.17253520f, -0.15202703f, -0.05974030f, 
    -0.11698532f, 0.10625494f, 0.10525177f, -0.04954067f, -0.19420294f, 0.04668237f, -0.11084709f, -0.05506429f, 
    -0.16808558f, -0.08079562f, 0.00039374f, -0.01449483f, 0.01851321f, -0.02824534f, -0.13848053f, -0.02429817f, 
    -0.11354783f, -0.08337152f, 0.02167880f, -0.16630889f, 0.01590745f, -0.07556660f, -0.08268052f, 0.10877855f, 
    0.06649915f, -0.08202401f, 0.11679327f, 0.07232081f, -0.00022313f, -0.16982520f, -0.21404245f, 0.07413396f, 
    -0.16668613f, -0.16432114f, -0.03134068f, 0.49712342f, 0.51296514f, 0.21526131f, 0.01252847f, -0.02480911f, 
    -0.03158072f, 0.09587175f, 0.13811947f, -0.07965884f, 0.05403622f, 0.15171425f, 0.21752922f, 0.06943011f, 
    -0.07735209f, -0.18410879f, -0.03389289f, -0.04755941f, 0.04140531f, -0.08115000f, 0.08171518f, 0.17760310f, 
    -0.03986959f, -0.23929296f, -0.14231284f, 0.05069561f, -0.14449535f, 0.17605136f, -0.18996647f, -0.01181047f, 
    0.30790895f, -0.02146302f, 0.07142409f, 0.06594351f, -0.24678832f, 0.31091142f, -0.50759888f, 0.07981925f, 
    -0.13603732f, 0.10119710f, -0.16920617f, 0.16079183f, 0.01639635f, -0.05821792f, -0.16538815f, -0.10524487f, 
    -0.29373017f, -0.10781958f, 0.00291926f, -0.02999633f, 0.20237538f, -0.05991581f, 0.09769402f, -0.25119352f, 
    0.02103479f, 0.18344720f, 0.01243297f, -0.07505544f, 0.13353659f, 0.02958989f, 0.20989779f, 0.17096893f, 
    -0.19297613f, -0.08835370f, -0.11848523f, -0.22149873f, 0.29095593f, -0.29242671f, 0.23644118f, -0.14701886f, 
    0.12312033f, 0.17297050f, 0.10752262f, -0.07735895f, 0.03437643f, -0.10413355f, 0.13259807f, 0.21451852f, 
    -0.18713440f, -0.06521700f, 0.11813815f, 0.02642026f, -0.06636116f, -0.06671824f, 0.46801955f, 0.21108653f, 
    0.14269614f, 0.08924320f, 0.10704663f, -0.03208548f, 0.42497429f, -0.09837174f, -0.14874493f, 0.14828739f, 
    0.24740803f, -0.15787803f, 0.04499372f, -0.11879993f, -0.42375383f, -0.21498843f, -0.29725304f, 0.01507079f, 
    0.03269094f, -0.00490742f, 0.04594845f, -0.03073403f, 0.01363155f, -0.15837494f, -0.06955346f, 0.26826757f, 
    -0.10129182f, -0.11946220f, -0.10855185f, 0.02081386f, -0.04922261f, 0.00947280f, 0.26198575f, -0.22362423f, 
    0.02675474f, 0.38757327f, 0.07377872f, -0.11550881f, -0.04811278f, -0.13085881f, 0.28430155f, -0.15481903f, 
    -0.17936918f, 0.10492019f, -0.04494650f, -0.16679631f, 0.07811887f, -0.33033428f, 0.13286640f, -0.09588517f, 
    -0.13659030f, 0.01948426f, -0.06225199f, -0.10003109f, -0.00506464f, -0.00323620f, 0.52713990f, -0.04071241f, 
    0.13320726f, -0.17315185f, -0.14443842f, -0.17268761f, 0.06772343f, -0.15871763f, 0.27664718f, 0.09245256f, 
    -0.18185072f, -0.30885273f, -0.13224238f, 0.09069891f, -0.47013670f, -0.14596429f, 0.29556933f, 0.05183582f, 
    -0.19476685f, 0.02176766f, 0.12299495f, -0.28973511f, 0.28145146f, -0.03253857f, -0.25952747f, 0.07066578f, 
    -0.08447501f, -0.01945815f, -0.11511758f, 0.10054815f, -0.06809407f, 0.00213314f, -0.17969067f, 0.08922664f, 
    0.01427357f, 0.06400269f, 0.15182152f, 0.04101986f, 0.33271360f, 0.08904935f, 0.15996464f, 0.28275636f, 
    -0.11528522f, -0.08181845f, 0.00864255f, 0.00688732f, 0.30871195f, -0.03405093f, 0.39308786f, 0.06791279f, 
    -0.08448029f, 0.02305233f, -0.00884333f, -0.28444025f, 0.08416640f, 0.05114029f, 0.40351889f, -0.00649937f, 
    0.00508325f, -0.02966089f, 0.09819502f, -0.14525704f, 0.06684227f, -0.11263562f, 0.18149225f, 0.07701997f, 
    0.20081989f, -0.08326564f, 0.15310970f, -0.08626252f, 0.15062381f, 0.12854135f, 0.20630234f, -0.19044431f, 
    0.02757039f, 0.33107969f, -0.00598683f, 0.14110142f, 0.02172182f, -0.00617810f, -0.28643727f, 0.04665960f, 
    -0.05673141f, 0.04138518f, 0.07180211f, -0.16783099f, -0.29337043f, -0.00589343f, -0.25657594f, -0.09161752f, 
    0.00270577f, -0.12272491f, -0.08125558f, -0.08533175f, -0.00430389f, -0.07388254f, 0.14059627f, 0.19298156f, 
    0.21089922f, -0.05142403f, 0.14866255f, -0.00385252f, -0.17953102f, 0.02048881f, 0.06908742f, -0.04114193f, 
    -0.11100717f, -0.18325011f, 0.15740098f, 0.07859737f, -0.02314555f, -0.14479089f, 0.32812890f, 0.10303189f, 
    0.16270801f, -0.18977384f, 0.09783638f, 0.33125901f, -0.47888416f, -0.39470956f, 0.06368876f, 0.06520383f, 
    0.05393339f, 0.11563713f, -0.09241422f, -0.04908132f, -0.17121020f, -0.05872240f, 0.18094712f, 0.00499318f, 
    0.03238039f, -0.14527681f, 0.12418767f, 0.00669657f, -0.06983330f, -0.06578599f, -0.28420055f, -0.13169393f, 
    -0.16114894f, 0.27501574f, -0.15881036f, -0.04076928f, 0.13071421f, 0.05935737f, 0.36855754f, 0.02295548f, 
    0.10083666f, 0.06559271f, 0.14099444f, -0.37071595f, -0.25649384f, 0.30905008f, 0.25445822f, -0.16570066f, 
    -0.00204318f, 0.17913638f, 0.03510139f, 0.10041178f, -0.15029038f, -0.03980873f, 0.34578338f, 0.06081661f, 
    0.06298161f, -0.11033802f, -0.15714882f, -0.13853753f, 0.18288957f, 0.03077455f, -0.50485253f, -0.17773581f, 
    -0.16556543f, -0.23914433f, 0.16310546f, -0.06268065f, 0.07058957f, 0.07218615f, 0.05139118f, -0.08516208f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03182930f, 0.16522358f, 0.03821155f, 0.14131743f, 0.05858608f, 0.10465707f, -0.07470100f, 0.31308526f, 
    -0.01825468f, 0.07083936f, 0.31882429f, 0.15142901f, 0.08562578f, -0.17840728f, 0.19286798f, 0.25626850f, 
    0.16902322f, -0.06855930f, -0.23494346f, 0.01465945f, 0.18214780f, 0.13230571f, 0.30027404f, 0.12173755f, 
    0.04743724f, 0.36166939f, 0.02550865f, 0.12434776f, 0.09666879f, -0.10955913f, -0.12184943f, 0.23938966f, 
    0.47542182f, 0.29444468f, -0.04954810f, 0.27604461f, 0.07335003f, -0.01323792f, 0.20422782f, -0.23972440f, 
    0.07717910f, -0.06717702f, 0.07927476f, -0.01928898f, -0.04836366f, 0.25120205f, -0.23088355f, 0.20321448f, 
    -0.04163438f, -0.15956986f, 0.40378925f, -0.10052333f, 0.27084970f, -0.17494799f, 0.06376273f, 0.10347281f, 
    -0.09518103f, -0.02601139f, 0.22627102f, -0.06435668f, -0.03052291f, 0.25095659f, 0.22170848f, 0.23033132f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.20720130f, 0.15191704f, 0.31405511f, -0.05073278f, 0.10855239f, -0.03136259f, 0.09949975f, 0.04918023f, 
    -0.31045523f, -0.00184422f, -0.07278646f, -0.05036084f, -0.27722660f, 0.02662751f, 0.03487368f, -0.13953508f, 
    0.13452958f, 0.36999565f, 0.04938927f, 0.12806387f, 0.17148589f, 0.03004954f, 0.10135904f, -0.15866143f, 
    -0.05151894f, -0.24242851f, -0.05196085f, 0.33834779f, 0.19247858f, 0.14924864f, 0.13064152f, -0.25083858f, 
    0.08517298f, 0.11277817f, 0.21040983f, -0.24926814f, 0.28229105f, -0.10107737f, -0.16428463f, 0.14195070f, 
    0.34110716f, -0.02225300f, -0.01668687f, 0.30845568f, 0.08925104f, 0.19251980f, 0.19593798f, -0.13926972f, 
    0.08868841f, -0.17773297f, 0.28203183f, 0.22843367f, 0.05064075f, -0.03150650f, 0.33186150f, 0.01568227f, 
    0.20072992f, -0.19578308f, -0.11643193f, 0.22356187f, 0.10681909f, -0.04557478f, -0.33318940f, -0.42722604f, 
    0.05636630f, 0.00165418f, -0.11306176f, -0.08722971f, 0.19360006f, 0.07638591f, -0.28055352f, 0.34358478f, 
    -0.30841509f, 0.42709380f, 0.06570279f, 0.18293232f, -0.56239641f, -0.04649155f, -0.14489652f, -0.15888788f, 
    0.19986852f, 0.03857715f, 0.19616777f, -0.04593027f, -0.24467094f, 0.13284020f, 0.20240138f, 0.06957635f, 
    -0.07928415f, 0.02632715f, -0.27290243f, 0.03851930f, -0.19700749f, -0.00177699f, -0.06997927f, -0.08510321f, 
    0.10341872f, -0.00766858f, -0.25707290f, -0.17528015f, 0.37821451f, -0.05153361f, -0.47066990f, 0.07035068f, 
    0.02453736f, -0.27099368f, -0.03884424f, -0.04570374f, 0.07788774f, 0.28738490f, -0.02362811f, -0.19317734f, 
    0.14195225f, 0.26883161f, -0.07947690f, 0.21767710f, 0.14215246f, 0.04071458f, 0.39543098f, -0.10617407f, 
    0.26883423f, -0.17836793f, 0.48623914f, 0.04554728f, 0.21883154f, -0.15868092f, -0.10676636f, -0.03444328f, 
    0.24442674f, -0.25446805f, -0.16451111f, -0.10775760f, 0.24738422f, -0.13156705f, 0.01329396f, 0.14878160f, 
    0.04117340f, -0.14150140f, -0.03221215f, 0.21334912f, -0.45140213f, -0.06198513f, 0.20911783f, -0.06315272f, 
    0.00834105f, 0.17379241f, 0.05817994f, -0.07982012f, 0.17558874f, 0.06058261f, 0.09765450f, -0.03730051f, 
    0.20728433f, -0.18435878f, 0.07122112f, 0.14828835f, -0.03568109f, 0.08925392f, -0.35404503f, 0.00198233f, 
    0.32094756f, -0.12596460f, -0.04153968f, 0.04580367f, 0.06954233f, 0.00269773f, -0.17057221f, 0.11913604f, 
    -0.09947380f, 0.17439693f, -0.04044392f, -0.04666731f, -0.09556074f, 0.11762898f, 0.11019816f, 0.05926314f, 
    0.02486446f, -0.05421861f, 0.26054484f, 0.38376555f, 0.25053707f, 0.04566437f, 0.31824172f, 0.06773931f, 
    0.34876949f, -0.04294310f, -0.19848178f, 0.04821945f, 0.05081302f, -0.00840723f, -0.21323973f, -0.31771195f, 
    0.26583546f, 0.24421179f, -0.31059596f, -0.30067909f, 0.34329489f, 0.00483429f, 0.41123939f, 0.23021264f, 
    -0.30039725f, -0.17059888f, 0.08132101f, 0.21731102f, -0.24538073f, -0.01930253f, -0.06555580f, -0.09518716f, 
    0.02157835f, 0.23985206f, 0.06508581f, 0.09658065f, 0.13477913f, -0.02110958f, -0.37543970f, -0.27674934f, 
    0.13621540f, 0.16904978f, 0.15841831f, -0.14907031f, -0.22576679f, 0.12991233f, -0.50702822f, 0.05865165f, 
    0.06900025f, -0.32733724f, -0.19806883f, -0.02241412f, -0.39735761f, 0.04437494f, 0.00722635f, -0.02336727f, 
    0.03738123f, -0.34868795f, -0.05919751f, -0.30438551f, -0.03096253f, 0.05737574f, -0.03879599f, -0.50309038f, 
    -0.24858430f, 0.18343446f, 0.05149285f, 0.00552091f, 0.44829094f, 0.12680154f, 0.06463271f, 0.23090824f, 
    -0.07167391f, -0.07447048f, -0.44150096f, 0.08690248f, -0.08122472f, -0.00875012f, -0.07014346f, 0.17960839f, 
    -0.13573408f, 0.02761841f, -0.13434388f, 0.11527144f, 0.12990847f, -0.07645326f, 0.04693567f, -0.05753445f, 
    0.30293998f, -0.17641643f, 0.19757798f, -0.21842103f, 0.14077027f, 0.03523343f, 0.16128020f, 0.15188000f, 
    0.08776478f, -0.29672301f, -0.11844599f, 0.02993029f, 0.00732211f, 0.21741436f, 0.20021056f, 0.23935902f, 
    0.01421102f, 0.50070465f, -0.12059360f, -0.16956614f, 0.05241490f, -0.33401886f, -0.17890587f, 0.33567294f, 
    -0.02554933f, 0.13002068f, -0.39535511f, 0.26587662f, -0.08675265f, 0.01699600f, 0.42259836f, -0.02621628f, 
    0.04179771f, 0.12227758f, -0.08038192f, -0.23651330f, -0.12040920f, -0.07784604f, -0.12369241f, -0.13492461f, 
    -0.03958648f, 0.12313514f, 0.25653628f, -0.10306048f, 0.05329680f, -0.04458760f, -0.16202521f, 0.05259579f, 
    0.16024524f, 0.30014244f, 0.20995204f, 0.07130823f, -0.06798413f, 0.40185413f, 0.37029901f, 0.81953716f, 
    0.01726471f, -0.10379281f, 0.27137870f, 0.13056597f, -0.04164514f, 0.04986067f, -0.02162483f, -0.13908176f, 
    0.13008797f, -0.07873841f, -0.00313796f, -0.12793773f, -0.02590147f, -0.00520669f, 0.20003358f, 0.33710209f, 
    0.13829066f, 0.07866738f, -0.45676643f, 0.03406106f, -0.02471771f, 0.11808877f, 0.19496536f, 0.19311623f, 
    0.09050892f, 0.08846996f, -0.09519526f, 0.12066332f, 0.19821231f, 0.01221033f, 0.32633933f, 0.30071571f, 
    -0.04592968f, 0.51044101f, 0.00801995f, -0.05399957f, -0.14553891f, 0.14623369f, 0.19529694f, 0.00571381f, 
    0.02964806f, 0.03319553f, -0.00213533f, 0.03092223f, 0.07282536f, -0.07004493f, -0.01523385f, 0.27671278f, 
    0.08869975f, 0.01276646f, 0.27470541f, -0.11062327f, -0.20593584f, -0.07374170f, 0.12275246f, -0.19674399f, 
    0.18781781f, 0.09020390f, -0.19932882f, 0.00880608f, 0.00317574f, 0.33414352f, 0.14980915f, 0.18935318f, 
    -0.24103157f, -0.22760029f, 0.13873377f, 0.18798572f, -0.10655389f, 0.03653705f, 0.06041651f, -0.23066454f, 
    0.11019917f, 0.11960270f, -0.16542260f, -0.03700667f, -0.40211937f, -0.07173725f, 0.01867014f, 0.19948612f, 
    -0.09381886f, -0.26223618f, 0.06594560f, 0.09070467f, -0.15377991f, 0.01191050f, 0.14792719f, -0.59401035f, 
    -0.22511968f, -0.48585090f, 0.22014019f, 0.15001376f, 0.20084612f, 0.30859345f, 0.15989643f, -0.00609989f, 
    -0.39903185f, 0.07932214f, 0.08609425f, -0.62163091f, 0.12767734f, -0.06809843f, -0.41889632f, -0.05429274f, 
    0.07398345f, -0.14621866f, -0.06274360f, 0.37645689f, 0.08228223f, -0.07288890f, -0.04630084f, 0.16352651f, 
    0.40499586f, -0.07433862f, -0.04329851f, 0.05924100f, -0.21192425f, 0.10421096f, 0.22696377f, -0.37442774f, 
    0.27206618f, 0.05499365f, -0.01652069f, 0.09643216f, 0.04886235f, -0.10486636f, -0.48846924f, -0.67340010f, 
    -0.06622376f, 0.11157698f, 0.27598801f, 0.28996283f, -0.05608565f, -0.01716242f, -0.36758357f, -0.00176933f, 
    -0.04713404f, 0.16909084f, 0.01528281f, -0.27685794f, -0.42463997f, -0.08576146f, -0.05084947f, -0.02830741f, 
    0.19106531f, -0.09358236f, 0.12102658f, -0.10605540f, -0.23702641f, 0.21395078f, 0.28204671f, -0.21270469f, 
    -0.40359136f, -0.10722501f, 0.24739076f, 0.07724369f, 0.13128094f, 0.26181740f, 0.01753119f, 0.06573538f, 
    -0.23398159f, 0.06121573f, 0.22960743f, -0.36669031f, 0.35029691f, -0.05218474f, -0.41164976f, -0.03893841f, 
    0.00076972f, -0.27706146f, -0.05787367f, 0.22645685f, 0.12211945f, -0.05357781f, -0.13233443f, 0.01468515f, 
    0.59752142f, 0.19958736f, -0.24971493f, 0.04726342f, 0.04346732f, 0.11316724f, 0.14498709f, -0.39400747f, 
    0.31025812f, -0.01656439f, 0.13324146f, -0.21719632f, 0.23642021f, -0.06565770f, -0.16961962f, 0.10112328f, 
    0.03145555f, 0.47685480f, 0.18548889f, 0.04838660f, 0.16829039f, -0.13780662f, -0.16481939f, -0.23346601f, 
    -0.27920893f, 0.06892231f, -0.01082009f, 0.06702040f, 0.11458963f, 0.06109503f, -0.29946083f, -0.18707496f, 
    0.18564056f, 0.06590141f, -0.39852160f, -0.02628315f, 0.24264055f, -0.36114305f, 0.04050938f, 0.02767777f, 
    0.27068070f, -0.16065344f, -0.31928885f, -0.08464301f, 0.04871958f, -0.34650353f, 0.38870400f, -0.13627851f, 
    -0.16303474f, 0.32745218f, 0.25990251f, 0.04796965f, 0.36669493f, 0.12497842f, 0.04403423f, -0.00902582f, 
    0.14026740f, -0.18716705f, -0.01874110f, 0.14688301f, -0.02503283f, 0.15594713f, -0.32774183f, 0.09059194f, 
    -0.04611278f, 0.23379202f, 0.04453596f, 0.35238153f, 0.08597402f, -0.02676499f, 0.23685472f, -0.24471487f, 
    -0.31895438f, -0.29896724f, -0.01301269f, -0.59207475f, -0.00559357f, -0.15254898f, -0.16661634f, 0.16802640f, 
    0.18067092f, 0.37072232f, 0.03247972f, 0.10769022f, 0.14741904f, -0.04061538f, 0.24612567f, -0.14771649f, 
    -0.20414647f, -0.04690255f, 0.16145545f, -0.10267025f, -0.19284265f, 0.03161074f, -0.24140371f, -0.13614205f, 
    0.12519740f, 0.07696836f, -0.05154280f, 0.02531247f, 0.20246382f, -0.35313961f, -0.07735872f, 0.00442945f, 
    0.16242014f, -0.06553219f, -0.24072625f, -0.11525200f, -0.04031328f, -0.04278675f, 0.15057546f, -0.21565363f, 
    -0.14717057f, 0.13913558f, -0.09275819f, -0.13746905f, 0.06870043f, 0.11938748f, 0.00960423f, 0.02947221f, 
    0.02786787f, -0.57002538f, -0.01755502f, -0.12032999f, 0.07846534f, -0.09961833f, 0.09730659f, -0.21152830f, 
    0.11313208f, 0.31045836f, 0.00980262f, 0.02509638f, 0.32019910f, -0.02817035f, -0.12773333f, -0.20364837f, 
    -0.14884032f, -0.24497688f, 0.20655032f, -0.12545301f, -0.02856893f, 0.07205671f, -0.17060496f, 0.48732385f, 
    -0.09393641f, -0.11274797f, -0.02662968f, -0.07884559f, -0.06351189f, -0.04480562f, 0.06332230f, 0.03318104f, 
    -0.11314396f, 0.06035081f, 0.06002931f, 0.02246511f, -0.13104877f, -0.10354801f, 0.09305104f, -0.07853954f, 
    -0.01123825f, -0.03649871f, -0.00300818f, -0.08276262f, 0.03966049f, 0.02146623f, -0.14303786f, -0.11972717f, 
    0.07517290f, -0.04602567f, -0.09055693f, 0.00684159f, 0.01742144f, -0.08137723f, -0.02907241f, 0.09237884f, 
    0.07506569f, 0.05677236f, 0.04433982f, 0.09370576f, 0.06001341f, -0.00902379f, -0.09479582f, 0.09347495f, 
    -0.03054979f, -0.02268267f, 0.10147098f, -0.08997560f, 0.07976428f, 0.01638579f, 0.01542161f, -0.04486791f, 
    0.07302654f, -0.12195633f, -0.02197179f, -0.00833671f, 0.04207025f, -0.01789679f, -0.02924612f, -0.09584197f, 
    -0.00753970f, -0.08599553f, 0.02568602f, -0.03362400f, -0.01902935f, 0.01021227f, 0.02985283f, -0.01212534f, 
    -0.12377531f, -0.49583551f, 0.14967623f, -0.07895812f, 0.01350547f, 0.08136223f, -0.06072386f, 0.08430513f, 
    0.16749614f, 0.09791203f, -0.00057051f, -0.01110817f, 0.13123192f, -0.12289278f, 0.16103789f, -0.00208850f, 
    -0.21580724f, 0.15297075f, 0.14824876f, -0.01719493f, -0.41880214f, 0.26802024f, 0.00816839f, 0.10694376f, 
    -0.24703930f, 0.02568749f, -0.03624528f, 0.39078832f, 0.05399458f, 0.07240490f, 0.18699628f, 0.14050233f, 
    0.09984891f, -0.01779354f, -0.79111511f, -0.22253920f, -0.27953511f, -0.09969725f, -0.03245243f, -0.08140800f, 
    0.23376058f, 0.32714483f, -0.04568153f, 0.29612666f, -0.00864892f, -0.16094875f, 0.12262247f, 0.24940763f, 
    -0.24099006f, -0.43703452f, -0.08423579f, -0.28280082f, -0.19439247f, 0.12238157f, -0.46219406f, 0.20840430f, 
    0.01921910f, 0.29183063f, 0.05141290f, -0.02624486f, 0.10657597f, -0.05936958f, 0.07853422f, 0.05631027f, 
    0.07441013f, 0.13149114f, -0.32925323f, -0.07461752f, 0.01582697f, 0.06948569f, -0.12876154f, 0.03334071f, 
    -0.14561681f, 0.46947309f, -0.02709400f, 0.21426074f, 0.33644485f, 0.07625037f, -0.01736247f, -0.05161567f, 
    0.05124439f, -0.03049519f, 0.34397960f, 0.13741569f, -0.10437687f, -0.05339334f, 0.22837664f, 0.27228084f, 
    0.07849371f, 0.28630063f, -0.39418310f, -0.02695486f, -0.24257600f, 0.00748427f, 0.01566099f, -0.00312451f, 
    0.10220902f, -0.01862546f, -0.22902372f, 0.14309317f, 0.26228625f, 0.04129832f, -0.18171774f, -0.05855960f, 
    -0.10974012f, 0.17985819f, -0.09624495f, 0.03105191f, -0.12340735f, 0.30561399f, -0.05218885f, 0.04860750f, 
    -0.10523573f, 0.08239267f, 0.04851845f, -0.11251704f, 0.11233266f, 0.06458168f, 0.19673215f, 0.01305341f, 
    -0.05590833f, 0.11945311f, 0.47157666f, -0.15333939f, -0.01629864f, 0.00939709f, 0.14585951f, 0.27481931f, 
    -0.25557029f, 0.32391506f, 0.26193002f, 0.23620726f, -0.23231524f, 0.11054461f, 0.09949017f, -0.27128860f, 
    -0.03970115f, 0.12843968f, -0.08496823f, -0.17656992f, 0.36941317f, 0.09259992f, -0.03323274f, 0.06935930f, 
    0.01697437f, 0.16568460f, 0.34343672f, 0.04190482f, -0.22278267f, -0.02993012f, 0.09610649f, -0.31537530f, 
    -0.07389690f, -0.71960706f, 0.26580659f, -0.02886447f, 0.22863477f, 0.26207682f, 0.35351485f, 0.05615100f, 
    -0.86116689f, -0.06446081f, -0.04838245f, -0.18928832f, -0.15363710f, -0.04641849f, -0.00767216f, 0.13433650f, 
    -0.02329659f, 0.09654027f, -0.08482648f, 0.13389808f, -0.11568937f, -0.68328524f, 0.18401419f, 0.12969384f, 
    0.23358871f, 0.17647645f, -0.48465091f, 0.12761451f, -0.28291020f, 0.10716815f, 0.11333255f, -0.11298954f, 
    -0.14824137f, 0.07396869f, -0.13251722f, -0.22438629f, -0.00869647f, 0.00325482f, -0.20155194f, -0.06999549f, 
    -0.01250861f, 0.07185177f, -0.00567796f, 0.10824487f, -0.13754621f, 0.04328047f, 0.06455214f, -0.13805847f, 
    0.00422615f, 0.08918599f, -0.12013245f, 0.06165845f, 0.10577312f, -0.11855233f, -0.14172064f, -0.03099683f, 
    -0.12939243f, 0.04716914f, -0.10921719f, 0.07341592f, 0.00061898f, -0.04776274f, 0.09836387f, 0.05241727f, 
    -0.01670173f, 0.03745978f, 0.06942727f, -0.07904642f, -0.00821827f, 0.06167097f, -0.12821405f, -0.12835552f, 
    0.02679546f, -0.03802532f, -0.05177745f, -0.08497716f, 0.09612334f, 0.03388491f, -0.03700880f, -0.08901757f, 
    -0.11968472f, -0.02464195f, 0.00512637f, -0.04017014f, 0.11883643f, -0.10575860f, 0.02592544f, -0.05305114f, 
    0.09796630f, -0.03388527f, -0.08404943f, -0.04710445f, -0.05524767f, 0.05339913f, -0.01361275f, -0.10349111f, 
    -0.07618459f, 0.00639489f, -0.00160941f, -0.07732351f, -0.13336711f, -0.07686378f, -0.15274711f, 0.02386944f, 
    -0.08786616f, -0.05266538f, 0.05727337f, -0.09338929f, -0.08426166f, 0.06223134f, -0.15485674f, -0.10428741f, 
    0.05727717f, -0.06007408f, 0.05071099f, -0.02584872f, 0.06426733f, -0.03379525f, -0.15297200f, -0.12654449f, 
    -0.06851745f, 0.03437756f, -0.10312854f, 0.04280511f, -0.03451469f, 0.00976508f, -0.05300299f, 0.05121724f, 
    -0.14729775f, -0.06094693f, -0.05273876f, -0.03403722f, -0.12653944f, 0.09915786f, -0.03376979f, -0.02014102f, 
    0.02142659f, -0.15614115f, -0.06053200f, 0.08971732f, -0.09137522f, -0.12513648f, -0.02435057f, -0.07413445f, 
    -0.06214201f, -0.12333985f, -0.03483489f, 0.05621799f, 0.05013150f, -0.10978767f, -0.02083741f, -0.10274055f, 
    0.09540012f, 0.07181193f, -0.02440031f, 0.04739757f, -0.05546088f, -0.01922549f, -0.01178398f, -0.05544280f, 
    -0.01968857f, 0.01906654f, -0.01896525f, -0.09648560f, -0.12916481f, -0.11846448f, 0.10212841f, -0.08312897f, 
    -0.19315720f, 0.26139218f, -0.00180146f, 0.07946025f, -0.38030767f, -0.10885087f, 0.07194623f, -0.08408182f, 
    -0.10657688f, -0.13113938f, -0.02763463f, 0.11700686f, 0.21208759f, -0.03149335f, -0.30410093f, -0.01701908f, 
    0.15628800f, 0.33808473f, 0.23659527f, 0.06166240f, -0.01032936f, -0.17248544f, 0.07563708f, 0.13423353f, 
    0.12133864f, -0.20067051f, 0.06960442f, 0.05667650f, 0.26110294f, 0.27713677f, 0.19793037f, -0.36933473f, 
    -0.20053360f, -0.06843553f, 0.23529649f, 0.11841656f, -0.13994738f, 0.06812887f, 0.05494953f, 0.06772459f, 
    0.02367660f, 0.09261080f, -0.10037094f, 0.10930640f, -0.03123735f, -0.49934748f, 0.08835834f, 0.06400815f, 
    0.02805170f, 0.32737303f, -0.34279141f, -0.03462006f, -0.32637593f, -0.06174637f, 0.05225416f, -0.00125093f, 
    -0.09567682f, 0.09569228f, 0.05292025f, 0.17539364f, -0.07402848f, 0.14801580f, 0.06551289f, -0.29593638f, 
    -0.17377461f, 0.03474965f, -0.13244297f, -0.07523627f, 0.06648552f, -0.02712311f, -0.11931337f, -0.14747639f, 
    -0.03535266f, -0.12116435f, 0.05148444f, -0.13705945f, -0.07204773f, 0.03041697f, 0.04128951f, -0.08897242f, 
    0.05576656f, 0.02201714f, -0.10188574f, -0.09126677f, -0.04359361f, -0.09235592f, -0.02490889f, 0.07543454f, 
    -0.05330434f, -0.12639268f, -0.12286144f, -0.11543918f, -0.00997567f, 0.04240832f, 0.00245264f, -0.03236525f, 
    -0.11589029f, 0.06681748f, 0.07421586f, 0.05801350f, -0.10630299f, 0.01707543f, 0.00031927f, -0.02203397f, 
    -0.04781742f, -0.00210806f, -0.11130507f, -0.03238114f, 0.10689971f, -0.13777438f, -0.09522484f, -0.06103892f, 
    0.02628955f, 0.02029625f, -0.00677718f, -0.00257440f, -0.01506098f, 0.11026345f, -0.07003585f, -0.04736968f, 
    -0.09594391f, -0.09859087f, 0.03536089f, -0.03236265f, -0.12762049f, -0.08569806f, -0.08698887f, -0.10275566f, 
    -0.10048981f, -0.03137138f, 0.11511081f, 0.05601378f, 0.05297875f, 0.11202475f, -0.09736751f, -0.08806153f, 
    -0.10752302f, -0.02957474f, -0.11009035f, -0.09190515f, -0.11481462f, -0.04207510f, -0.00718240f, 0.00623791f, 
    0.02242108f, 0.02185671f, 0.05668980f, 0.04714406f, -0.08061790f, -0.01414172f, -0.11605234f, -0.01182225f, 
    -0.09940022f, -0.00512162f, -0.06014396f, -0.07447782f, 0.02509949f, -0.02335306f, -0.07018574f, -0.04683545f, 
    -0.05914111f, -0.09750003f, -0.05679053f, -0.05686872f, -0.11753879f, 0.00510232f, -0.10383838f, -0.04520288f, 
    -0.00632542f, 0.07791817f, 0.08474296f, -0.07655944f, -0.01971535f, 0.00128654f, 0.10299876f, 0.01218596f, 
    -0.00062199f, -0.02416362f, -0.08259043f, -0.07668309f, -0.03460653f, 0.06756462f, 0.11252944f, -0.01691662f, 
    0.05059505f, -0.02183478f, 0.03956500f, 0.02434134f, -0.02477700f, -0.03350289f, -0.04224159f, -0.06334127f, 
    0.03184618f, 0.22649243f, 0.36627582f, 0.29700777f, -0.05928222f, -0.04254648f, -0.18594716f, -0.01064904f, 
    -0.08298434f, -0.17309473f, 0.28574884f, -0.31379265f, 0.06911637f, 0.11743881f, 0.38687670f, 0.04958045f, 
    0.02320901f, -0.20013750f, -0.32475495f, -0.08189776f, 0.11308465f, 0.16641700f, 0.44095168f, 0.01811996f, 
    -0.21248761f, 0.17799248f, -0.55753833f, 0.09962443f, 0.01850113f, -0.22907768f, 0.41835684f, 0.11451419f, 
    0.10053521f, 0.56431347f, 0.00923041f, 0.07850575f, 0.17958809f, -0.08967579f, -0.03931277f, -0.11960608f, 
    0.25567573f, 0.04833549f, -0.05519051f, 0.03797068f, 0.02792332f, 0.13077974f, -0.00023499f, -0.16575405f, 
    0.36280787f, -0.27069652f, 0.20693839f, -0.05657350f, -0.18722518f, 0.06557903f, 0.00982550f, -0.17970845f, 
    0.07812030f, 0.30166665f, 0.27897957f, 0.05334665f, 0.06324351f, 0.41908956f, 0.02458658f, 0.35999358f, 
    0.14748725f, 0.06139360f, 0.14705239f, -0.23559290f, -0.05298047f, -0.12924908f, -0.37861744f, 0.16354290f, 
    0.10250118f, 0.19334973f, 0.01537895f, -0.01374912f, 0.24053034f, -0.05924321f, -0.01660650f, -0.02423214f, 
    -0.07547354f, 0.04518145f, -0.34945324f, -0.00775453f, 0.19915690f, -0.04019712f, -0.09761561f, 0.33723876f, 
    0.22823118f, 0.15902480f, -0.07744299f, 0.07942959f, -0.07665699f, -0.37945759f, 0.29719022f, 0.16479219f, 
    -0.03387539f, 0.37750146f, -0.35235575f, 0.25753412f, 0.22522162f, -0.08233738f, 0.26413104f, -0.01749357f, 
    0.19206947f, 0.29679590f, -0.12876384f, 0.07829287f, 0.11758494f, 0.03561111f, 0.07103415f, 0.15487599f, 
    -0.53458577f, -0.32293886f, 0.23280144f, -0.05520068f, 0.04408601f, 0.09031383f, -0.03802647f, 0.24382512f, 
    -0.28125453f, 0.19151293f, -0.12891957f, -0.31186044f, -0.15237683f, -0.03212560f, -0.02478676f, 0.05590418f, 
    0.11752454f, -0.03043131f, 0.07519028f, 0.26741251f, -0.16926326f, 0.08116516f, 0.29108861f, -0.26329562f, 
    -0.42312282f, -0.10520860f, 0.21600163f, 0.14599825f, 0.36816683f, -0.00290043f, -0.02093419f, 0.04240232f, 
    0.15427920f, 0.22077608f, 0.05903573f, -0.02551079f, 0.05241887f, -0.32079864f, 0.26573026f, -0.13825352f, 
    0.00815531f, -0.22668409f, -0.45742735f, 0.28744563f, -0.05239989f, 0.22712483f, 0.27965569f, -0.58445805f, 
    0.25416175f, 0.01711168f, -0.04490124f, 0.28805676f, 0.18743114f, -0.03930866f, -0.11720383f, -0.04341567f, 
    0.30272996f, 0.55285662f, 0.07707811f, 0.07371138f, -0.07956445f, 0.12639326f, 0.28538030f, -0.19157442f, 
    0.05652136f, -0.03438981f, 0.09824806f, -0.13203086f, 0.00566599f, 0.05621830f, 0.27328473f, -0.02690048f, 
    -0.04819437f, -0.18128504f, 0.39038897f, 0.33825877f, -0.05827096f, 0.09072929f, -0.33974436f, -0.28205433f, 
    0.12524351f, 0.03729909f, 0.30221963f, 0.09697247f, 0.20115292f, -0.03830808f, 0.43219391f, 0.13157341f, 
    0.12123263f, -0.07450783f, 0.12048170f, 0.10704023f, -0.16383201f, -0.05181353f, 0.09955584f, -0.05004634f, 
    -0.15141463f, 0.34570265f, 0.12055773f, 0.07829373f, 0.28435627f, 0.00450171f, -0.21026543f, -0.17237855f, 
    0.04131756f, -0.16588609f, 0.49298206f, 0.14256744f, 0.26966223f, 0.29986969f, 0.05177950f, 0.25998825f, 
    -0.21506326f, -0.11055307f, 0.34685957f, -0.29115692f, -0.09123337f, -0.14116484f, 0.06154235f, 0.10238392f, 
    0.18259701f, -0.12601511f, -0.14563687f, 0.36075765f, -0.04852131f, -0.25933549f, -0.04824399f, 0.06040320f, 
    -0.15719150f, -0.28760210f, 0.14895585f, 0.20400980f, 0.11612678f, -0.08185417f, -0.23658882f, 0.39184755f, 
    -0.14074609f, 0.01290845f, -0.59979939f, 0.12336729f, -0.00283256f, -0.08126136f, -0.10752191f, -0.06419616f, 
    -0.22175123f, 0.07422382f, 0.29648760f, 0.38819838f, 0.00483135f, -0.19491076f, -0.06810658f, -0.21852538f, 
    0.03678305f, 0.04456726f, 0.09574432f, -0.35403609f, 0.17225555f, -0.01627777f, 0.34436449f, 0.25391409f, 
    -0.05817369f, -0.17027868f, -0.16876432f, -0.08134535f, 0.29265502f, 0.15461031f, 0.33631879f, 0.09766566f, 
    -0.08657660f, 0.07259154f, -0.32142192f, 0.10188665f, -0.08827517f, -0.31655109f, 0.21871683f, 0.21689397f, 
    -0.06696099f, 0.37075993f, -0.13024703f, 0.15201887f, 0.20282827f, -0.19075371f, 0.12556583f, -0.03361714f, 
    0.10611220f, 0.08065588f, 0.13898350f, -0.04381426f, 0.05176650f, 0.04910661f, -0.03418272f, -0.13170375f, 
    0.25138143f, -0.26399598f, 0.18677743f, 0.04056594f, -0.16996291f, 0.01340217f, 0.05999699f, -0.01125163f, 
    -0.05512901f, 0.05020420f, 0.18542044f, -0.12111865f, -0.08583209f, 0.33965954f, 0.01963199f, 0.13631843f, 
    0.09065574f, -0.11283260f, 0.32993984f, -0.21376257f, 0.27295446f, -0.14702134f, -0.08221515f, 0.08718048f, 
    0.28241143f, 0.07224757f, 0.04241406f, -0.23931158f, 0.01631763f, -0.04303282f, 0.22988485f, 0.12401837f, 
    -0.11358263f, 0.16472295f, -0.28553131f, -0.05298305f, 0.30192870f, 0.30217415f, -0.13620336f, 0.10462701f, 
    -0.02438503f, 0.23671563f, 0.34741017f, 0.25912771f, 0.10888717f, -0.04428083f, 0.03532140f, 0.52605277f, 
    -0.16934653f, 0.11254612f, 0.26347718f, -0.21082640f, 0.00770584f, -0.00580421f, 0.10908289f, -0.10576637f, 
    0.05096198f, 0.15480445f, 0.09177122f, 0.19857264f, 0.00923137f, 0.03657267f, -0.18579096f, -0.27879477f, 
    -0.28970382f, -0.33518204f, 0.26236656f, 0.01789879f, -0.07261208f, 0.08409258f, -0.09116103f, 0.59437752f, 
    -0.17175151f, 0.25200129f, -0.70587689f, -0.06158069f, -0.15150777f, 0.07596581f, 0.05462188f, 0.22973411f, 
    -0.11504942f, -0.04437363f, -0.03982085f, -0.13202536f, 0.13848962f, 0.12173937f, -0.21607985f, -0.05474483f, 
    -0.02475934f, -0.01318068f, -0.01326956f, 0.06480435f, 0.66446722f, 0.00378778f, 0.14606988f, 0.07037386f, 
    -0.06139662f, -0.02116547f, 0.32597226f, 0.06356694f, 0.27851576f, -0.04542923f, 0.03558615f, 0.24038094f, 
    0.04438977f, 0.18671672f, -0.29405835f, 0.11089043f, -0.54855072f, -0.21546294f, -0.11287119f, 0.09958187f, 
    0.16741115f, -0.35739875f, -0.55257833f, 0.36487398f, -0.00160568f, -0.18419117f, 0.05598106f, 0.00807716f, 
    0.03231949f, 0.42409813f, -0.11983008f, 0.26184845f, -0.00934204f, 0.38441783f, -0.17104112f, 0.01570285f, 
    -0.40167838f, -0.36308187f, 0.11050078f, -0.12312067f, -0.16264687f, 0.01163116f, 0.17692424f, 0.50311404f, 
    -0.48830247f, 0.16304348f, 0.00085572f, -0.03574076f, -0.28267175f, 0.13986878f, 0.22412238f, 0.03355434f, 
    -0.13353986f, -0.04030022f, 0.04323664f, -0.44280842f, -0.26458147f, -0.11026828f, 0.10666613f, -0.05667000f, 
    0.07126739f, 0.34207383f, -0.15302512f, 0.11564909f, 0.06678949f, -0.06201024f, -0.03446734f, -0.01835067f, 
    -0.20383193f, 0.09437899f, 0.09583436f, -0.05444009f, -0.08606245f, -0.22999857f, -0.27841589f, 0.08504609f, 
    -0.12694627f, -0.23116665f, -0.09335823f, -0.10610382f, 0.13196781f, 0.01778790f, -0.15862042f, -0.21453810f, 
    0.14629088f, -0.09868673f, 0.17237933f, -0.27417111f, -0.20246670f, -0.01695124f, -0.04616426f, 0.13805531f, 
    -0.06452817f, -0.01662709f, -0.08016717f, -0.03662332f, 0.03671251f, -0.01414734f, 0.09579490f, -0.03998155f, 
    -0.23394305f, -0.06697246f, -0.13441931f, -0.16853932f, 0.02022820f, 0.00157327f, -0.15940978f, 0.10173121f, 
    0.07120273f, -0.33679339f, -0.03824774f, 0.15662177f, 0.07230555f, -0.07310331f, -0.14163046f, -0.15845570f, 
    -0.13029923f, 0.02978480f, 0.01004961f, 0.06152407f, -0.01723396f, -0.06459934f, -0.11157589f, -0.03349696f, 
    -0.02239111f, -0.12065481f, 0.00272770f, 0.06966301f, -0.08920739f, 0.05289700f, 0.01563697f, -0.00815950f, 
    -0.10074247f, 0.01703299f, -0.01457213f, -0.09368689f, 0.02038391f, 0.04068020f, -0.15557967f, -0.09518852f, 
    0.05082480f, -0.10874635f, 0.02373791f, -0.11359855f, 0.01013072f, -0.00792891f, 0.03317952f, -0.11761629f, 
    0.06477815f, -0.01864217f, 0.07467598f, 0.02992064f, -0.12199848f, 0.05105681f, -0.01730754f, 0.03168224f, 
    -0.10126268f, 0.04435881f, 0.04876122f, -0.11289734f, 0.09542358f, -0.02391656f, 0.00493355f, -0.00217797f, 
    0.04079744f, -0.16253968f, -0.12289780f, -0.00722621f, 0.07350043f, -0.00390671f, -0.02096467f, 0.00771844f, 
    0.05742611f, -0.10479198f, 0.02452019f, -0.08849315f, -0.08508173f, -0.09087645f, -0.03433056f, -0.08547506f, 
    0.25249201f, 0.44074029f, 0.03619522f, -0.17070234f, 0.09323633f, 0.02639011f, 0.20378949f, -0.07014109f, 
    -0.46846995f, 0.05083060f, 0.21893156f, 0.01937138f, 0.08119908f, 0.03057596f, -0.26246917f, -0.01806461f, 
    0.06750950f, 0.19492909f, -0.29822978f, 0.16216683f, 0.36895496f, -0.46449062f, 0.00035140f, -0.00337148f, 
    0.08322326f, 0.09395621f, -0.51937139f, -0.35775495f, -0.29094478f, -0.36037889f, 0.09082867f, -0.18686654f, 
    0.02290181f, 0.12495859f, 0.26264095f, 0.08798845f, 0.03653398f, 0.03984070f, 0.27299964f, -0.11420461f, 
    -0.02583401f, -0.27554521f, 0.03680648f, -0.08211506f, 0.01717093f, 0.24596247f, -0.18540229f, -0.31153777f, 
    0.00722452f, 0.22228839f, 0.17448890f, 0.20997669f, 0.24969408f, -0.04510165f, 0.25342903f, -0.04469645f, 
    -0.47877407f, -0.37421095f, 0.11272670f, -0.14056402f, -0.09817911f, 0.06972458f, -0.12204370f, 0.32867154f, 
    0.12430973f, 0.42997211f, 0.24765204f, -0.00999230f, -0.08372737f, 0.06800743f, -0.26247144f, -0.11046865f, 
    -0.02877984f, -0.01945035f, 0.10239042f, 0.10094827f, 0.10016090f, -0.09753819f, -0.09701641f, -0.03075726f, 
    0.15884908f, -0.13967174f, -0.28329211f, -0.09035424f, 0.18256141f, 0.11580963f, 0.24704428f, 0.11122544f, 
    0.24442515f, -0.19630612f, 0.00106145f, 0.11311862f, 0.08584771f, -0.20251115f, 0.39300090f, -0.12060074f, 
    0.05691013f, 0.62801319f, -0.28638592f, 0.02873312f, 0.54386955f, 0.12483086f, 0.28324950f, 0.06036655f, 
    0.14765833f, -0.16312802f, 0.01009829f, 0.05789633f, -0.12423719f, 0.21936703f, 0.01079254f, 0.42513597f, 
    -0.11631111f, -0.01731679f, 0.13791041f, 0.18420255f, 0.03845056f, -0.11452306f, 0.26691625f, -0.10548702f, 
    -0.06169224f, -0.04008795f, 0.10628036f, -0.40897611f, -0.00913436f, -0.20244721f, -0.15581405f, -0.14393599f, 
    0.00449825f, 0.37293851f, 0.01389424f, 0.17440283f, 0.14144836f, 0.08755577f, -0.12480531f, 0.23057635f, 
    0.16491745f, -0.26170114f, 0.05326486f, 0.01006532f, -0.45134771f, -0.10279094f, -0.09112167f, -0.01640879f, 
    0.01764752f, -0.23747383f, 0.14365274f, 0.06081814f, 0.01008677f, 0.04252514f, 0.17892925f, -0.16554974f, 
    0.05996406f, 0.14782108f, 0.36796981f, -0.06724221f, 0.02826403f, 0.09249569f, 0.14277840f, 0.13059315f, 
    -0.41860557f, 0.32013029f, 0.09346391f, -0.23892723f, 0.04128492f, -0.09734298f, -0.05628026f, -0.09096384f, 
    0.16429634f, -0.63685000f, -0.12987602f, -0.06163840f, 0.03845393f, -0.06367024f, -0.10619470f, -0.02377719f, 
    0.37432298f, 0.19147520f, -0.26756704f, 0.04234441f, 0.20306478f, -0.05419771f, -0.04840638f, -0.19348870f, 
    0.14962110f, -0.11992094f, 0.11201301f, -0.21786761f, 0.24749799f, -0.10997222f, -0.03231191f, -0.00604886f, 
    -0.20527627f, -0.04782698f, 0.22436987f, 0.31091431f, -0.46105012f, -0.01035907f, 0.12982997f, -0.35022429f, 
    0.00876197f, 0.07723713f, 0.16411309f, -0.11735224f, -0.06886590f, -0.07031749f, 0.07395780f, 0.07363433f, 
    0.03370950f, 0.02231474f, 0.28258765f, -0.04184572f, -0.13634703f, -0.08768647f, 0.19454555f, -0.09074613f, 
    -0.14630246f, -0.37714022f, 0.03788068f, 0.08321856f, 0.26118225f, 0.13739942f, 0.18402298f, -0.26578152f, 
    -0.12602782f, -0.07684629f, -0.31365731f, -0.01621496f, -0.22835797f, -0.04841307f, -0.23060043f, 0.02087364f, 
    0.00074267f, 0.17641155f, -0.06698170f, 0.23254971f, -0.11113714f, -0.41229546f, -0.14231624f, 0.10646004f, 
    0.50260895f, -0.03702710f, -0.14762892f, -0.09730035f, -0.23059478f, -0.00073588f, -0.04173828f, -0.27177924f, 
    0.18992268f, 0.11332759f, 0.41930908f, -0.10220722f, 0.20478463f, 0.19353919f, -0.26731673f, -0.42847249f, 
    0.16063760f, -0.22038256f, -0.18624339f, -0.05047309f, -0.18444128f, -0.09946954f, 0.24566586f, 0.15226538f, 
    -0.08304084f, 0.05703019f, 0.08074787f, 0.17773819f, 0.01334477f, 0.09369277f, 0.09262156f, 0.10377799f, 
    0.15357654f, 0.24486791f, 0.14983842f, -0.11529344f, 0.06573648f, 0.06618651f, -0.02303473f, -0.02780816f, 
    0.07807957f, 0.07509302f, -0.11862268f, 0.11331417f, -0.06823140f, 0.12117427f, -0.21966240f, -0.06986623f, 
    0.48656434f, -0.35492003f, -0.17709874f, 0.37419385f, -0.17809813f, -0.05018653f, 0.16564003f, -0.05220173f, 
    -0.06265238f, 0.42494306f, 0.07893910f, 0.05473694f, -0.10227366f, 0.14987455f, 0.13600658f, 0.07102495f, 
    -0.11669528f, -0.14997074f, 0.06745939f, -0.00652314f, 0.20504296f, 0.06924788f, 0.15917908f, 0.10389142f, 
    0.03978965f, 0.11814286f, -0.10825182f, 0.21220286f, 0.01483098f, 0.14607309f, -0.01231463f, -0.36016336f, 
    -0.03467568f, 0.11733235f, 0.05595794f, -0.01946265f, -0.14225201f, 0.00020397f, 0.06402257f, -0.08105035f, 
    -0.00252424f, 0.01657979f, -0.05561979f, -0.01324986f, 0.00888846f, 0.07521521f, 0.04550418f, -0.03107568f, 
    -0.11522841f, -0.10092828f, -0.10633646f, -0.03309195f, -0.06811241f, -0.06271624f, 0.01406109f, -0.09960277f, 
    0.07422780f, -0.10092092f, -0.08676066f, 0.01241020f, -0.04836984f, -0.03964118f, -0.15914616f, -0.05901268f, 
    -0.04499963f, -0.15192406f, 0.02683222f, -0.07703146f, 0.00162321f, -0.00910078f, -0.05074272f, 0.09083004f, 
    -0.09106369f, -0.08660516f, 0.03303632f, -0.03886528f, -0.04116966f, -0.01251142f, -0.01163118f, -0.12379065f, 
    0.04530521f, -0.03510057f, -0.00273650f, -0.06822997f, -0.11473931f, 0.07168145f, -0.10861400f, -0.11342891f, 
    0.06809076f, -0.02599440f, -0.09097360f, -0.00343500f, -0.00812452f, -0.14160240f, -0.08938793f, -0.09379526f, 
    0.03710286f, 0.18068430f, 0.44605497f, 0.18092644f, -0.12489121f, 0.06298862f, 0.17289463f, -0.24003752f, 
    0.02613676f, -0.02151814f, -0.02324961f, -0.33830473f, 0.33796337f, -0.08170383f, -0.02822430f, -0.02358324f, 
    -0.20654078f, 0.09618884f, -0.38189980f, -0.13094474f, -0.01972793f, -0.10318092f, 0.12030098f, -0.04244844f, 
    -0.19643515f, -0.00867534f, -0.20049784f, 0.12566844f, 0.19147514f, 0.15582086f, 0.49945331f, 0.06801720f, 
    -0.29671487f, 0.21399379f, 0.07587124f, -0.10107832f, 0.04360344f, 0.03443521f, 0.13641335f, 0.06484198f, 
    0.22612412f, 0.03969394f, -0.04889802f, 0.26416236f, 0.03139898f, -0.10347863f, 0.21916610f, 0.03805369f, 
    0.03203293f, -0.17158619f, 0.22270657f, -0.05256557f, -0.22427422f, -0.09974729f, -0.00569700f, 0.14815862f, 
    0.01791175f, 0.08904521f, -0.05377626f, -0.13523339f, 0.07983693f, 0.22354935f, -0.25324011f, 0.27023953f, 
    -0.03934649f, -0.20118088f, -0.16897286f, 0.25531000f, 0.11072460f, -0.15053935f, -0.06640588f, 0.21630301f, 
    0.09837274f, -0.43054152f, -0.03279081f, -0.08371603f, -0.49632350f, 0.09947884f, 0.33669019f, 0.19480385f, 
    0.17438021f, -0.11349361f, 0.12983990f, -0.06974292f, -0.26535410f, 0.24769792f, 0.24118918f, -0.13091353f, 
    -0.00477730f, -0.10977778f, 0.32320035f, 0.20096898f, -0.09169241f, 0.09057556f, -0.43176648f, 0.08281074f, 
    0.08744016f, -0.21624099f, -0.20320818f, -0.16735326f, 0.01078272f, -0.03549239f, -0.30177426f, 0.03204076f, 
    -0.01540537f, -0.18144503f, 0.07748929f, 0.03743752f, 0.00113305f, 0.14219670f, -0.19215515f, -0.12254550f, 
    0.49855030f, 0.09957895f, 0.10281666f, 0.17373589f, -0.03380347f, 0.14920951f, 0.04538045f, 0.04948146f, 
    0.40032437f, -0.11113133f, 0.05468516f, -0.05344352f, 0.04566205f, -0.10691951f, -0.04451756f, 0.09461300f, 
    -0.10811467f, -0.28397942f, 0.02007861f, 0.05195415f, 0.06107952f, 0.06243800f, -0.11397067f, 0.14987934f, 
    -0.04281862f, -0.08629604f, 0.09027763f, -0.10653266f, -0.02415024f, 0.12700062f, 0.27538043f, 0.23765497f, 
    0.06275043f, 0.09807284f, 0.12679514f, -0.14991438f, 0.18134879f, 0.27341449f, 0.08764475f, -0.19514842f, 
    -0.13456944f, 0.17113943f, 0.05872703f, 0.28590530f, -0.01222047f, 0.06794708f, 0.08255537f, 0.22615400f, 
    0.03966114f, -0.23289450f, 0.31332248f, -0.10393928f, -0.00989140f, -0.02817290f, -0.25363475f, 0.05955093f, 
    -0.03720943f, -0.15905648f, -0.07271972f, 0.16561590f, 0.00383251f, 0.11823191f, 0.04358619f, -0.01648106f, 
    0.13607790f, -0.15666585f, 0.09546175f, 0.03211282f, 0.03400292f, 0.09165984f, -0.05862540f, 0.17743300f, 
    -0.04933079f, 0.15986353f, -0.12209868f, 0.10827063f, 0.08437014f, 0.19312835f, 0.11978797f, 0.06499617f, 
    0.03876331f, -0.07993202f, 0.02771968f, -0.07336116f, 0.06403908f, 0.07312357f, 0.04453238f, -0.07228446f, 
    -0.14455655f, -0.08256373f, 0.08477843f, -0.01617371f, 0.04235686f, -0.08527756f, -0.12691627f, -0.12296589f, 
    -0.07963868f, 0.04373541f, 0.09288572f, -0.04086752f, -0.09512699f, 0.05319146f, -0.01244432f, -0.11160862f, 
    -0.08482455f, -0.11987224f, -0.05005566f, -0.09257721f, -0.02952240f, 0.06684718f, 0.06906052f, 0.06013536f, 
    -0.11235655f, -0.07251361f, 0.01560862f, 0.00231095f, -0.09548177f, -0.05059765f, 0.00532629f, 0.10847256f, 
    -0.11551733f, 0.07974970f, 0.09334548f, -0.04661728f, 0.00832528f, 0.01307635f, -0.06356469f, 0.03327953f, 
    0.09694728f, 0.00902184f, 0.03158811f, -0.08345208f, -0.06482844f, 0.12216799f, -0.03788190f, 0.01320862f, 
    0.02280636f, -0.14239922f, -0.02157379f, -0.06050086f, -0.07922926f, -0.07904916f, -0.14358905f, -0.06557556f, 
    0.12187763f, -0.02208432f, 0.12300356f, -0.24121372f, -0.19356066f, 0.01663044f, 0.11722378f, -0.03375364f, 
    0.08777270f, 0.16408415f, 0.19160196f, -0.02390429f, 0.42518356f, 0.10254387f, 0.13105111f, 0.09272052f, 
    -0.10509583f, 0.00517594f, -0.33696756f, -0.04919084f, 0.48851869f, -0.07217122f, -0.04746629f, 0.16143183f, 
    0.20429508f, 0.44404438f, 0.05334452f, -0.04338849f, -0.09543522f, -0.11380095f, 0.15529366f, 0.12230197f, 
    0.08325308f, 0.17415203f, 0.15291318f, 0.38576612f, -0.00805017f, -0.21085344f, 0.43086159f, -0.14343467f, 
    -0.01207783f, 0.21547629f, -0.05470017f, 0.00368234f, -0.10799964f, -0.05664577f, -0.06450947f, 0.12686637f, 
    -0.53918380f, -0.32923228f, 0.04498679f, -0.13756052f, 0.07343899f, 0.02486918f, -0.37827688f, 0.49214613f, 
    -0.18258801f, 0.34173644f, -0.14425847f, -0.06249041f, -0.08761454f, 0.10837312f, 0.25060153f, 0.24149416f, 
    -0.05679778f, -0.03116981f, 0.11029884f, -0.04732948f, 0.14789315f, -0.01113813f, 0.10426947f, 0.01613335f, 
    -0.11971818f, 0.02168810f, 0.08523631f, 0.11679104f, -0.03607517f, 0.04871197f, 0.00509803f, 0.11272839f, 
    -0.10758579f, -0.06604313f, -0.10450573f, -0.05230816f, 0.09737789f, -0.10541042f, -0.13887820f, -0.08124486f, 
    0.02471988f, 0.11633098f, 0.02682906f, 0.05918419f, -0.02899195f, 0.07665435f, -0.07217064f, -0.00753614f, 
    0.01874584f, 0.09336279f, 0.07791918f, -0.10340858f, -0.12714188f, -0.00347603f, 0.12664387f, -0.10382406f, 
    -0.02449608f, -0.10776238f, -0.03423113f, 0.05158390f, 0.09501767f, -0.03166550f, 0.14883366f, -0.01754362f, 
    0.08259637f, -0.08488787f, -0.01849016f, -0.07308625f, 0.13757418f, 0.03178079f, -0.07345295f, 0.16297454f, 
    -0.12326638f, -0.09995826f, -0.14175227f, 0.07412474f, -0.02837523f, 0.01055552f, -0.02950270f, 0.08666709f, 
    0.19197901f, 0.35699257f, -0.12400428f, 0.17194906f, -0.00270433f, -0.06339771f, 0.22539005f, -0.11292991f, 
    -0.06019523f, -0.50379211f, 0.23315206f, 0.10483816f, 0.13952716f, 0.04658240f, -0.05757161f, -0.06788298f, 
    0.29634187f, 0.05248523f, 0.08692809f, -0.06227112f, 0.15726662f, -0.20727651f, 0.17748916f, 0.25963864f, 
    0.27839214f, 0.15315613f, -0.18454555f, -0.03988200f, -0.01234164f, -0.12575455f, -0.05496441f, -0.04155908f, 
    0.09887662f, 0.11013150f, -0.16895138f, 0.49629280f, -0.15630858f, 0.37155336f, 0.42361245f, -0.06398880f, 
    0.12739101f, 0.23543733f, 0.06637676f, -0.25404611f, 0.06721313f, -0.06181023f, 0.47503468f, 0.11175930f, 
    -0.07126776f, 0.19157153f, 0.03325274f, 0.04841881f, 0.11404900f, -0.13267773f, -0.07837031f, -0.21694818f, 
    -0.07986679f, 0.09086496f, 0.08091249f, 0.00760958f, -0.03470981f, 0.21244776f, 0.17516544f, 0.06822806f, 
    -0.11511060f, -0.03916387f, 0.05510985f, 0.01924841f, -0.19179977f, 0.06993628f, 0.04741460f, -0.16191551f, 
    0.00083201f, 0.13312887f, -0.07504183f, 0.01105405f, -0.07821774f, -0.09403419f, -0.09650594f, 0.00097744f, 
    0.06654218f, -0.00118310f, 0.11502257f, -0.04809041f, -0.13535647f, -0.17449586f, -0.12567754f, -0.07959957f, 
    0.04681562f, 0.05224162f, -0.03280673f, -0.00978914f, 0.01237029f, 0.08732864f, 0.04474998f, 0.02196823f, 
    -0.08519404f, -0.15992084f, 0.00434807f, -0.05082178f, 0.08974297f, -0.02025283f, -0.08797461f, -0.01669787f, 
    0.01449944f, 0.14551455f, 0.12032564f, -0.10164090f, -0.07109347f, 0.06404749f, 0.13656978f, 0.07754599f, 
    0.00690628f, 0.08126716f, -0.01790283f, -0.11484522f, -0.06807553f, -0.00767738f, 0.03471565f, 0.09065051f, 
    -0.02132008f, -0.04716180f, 0.06007462f, -0.11949540f, -0.09392397f, -0.13887516f, -0.10956603f, -0.04826555f, 
    -0.20320436f, -0.25987017f, 0.17888899f, 0.18647981f, 0.13729501f, 0.05743852f, 0.04115652f, 0.11787412f, 
    -0.01831333f, 0.04671077f, 0.08548193f, -0.07433889f, -0.04893881f, -0.03415003f, 0.15178405f, 0.08791357f, 
    0.02850807f, 0.07974923f, 0.32583266f, -0.05444821f, -0.28047535f, 0.14009975f, 0.22914124f, -0.14570017f, 
    -0.09025564f, 0.01541655f, -0.15460560f, 0.10809236f, 0.19534719f, 0.15837255f, -0.05518254f, -0.01177449f, 
    -0.27836040f, -0.15675090f, 0.03353465f, -0.21698722f, -0.13664006f, 0.03567500f, -0.37990919f, -0.05508459f, 
    0.15645802f, 0.20192513f, -0.01293886f, 0.27869853f, 0.04094103f, -0.04916782f, -0.07594848f, -0.12270320f, 
    0.34182683f, -0.11213507f, -0.11726848f, -0.18454494f, -0.09132496f, 0.14101030f, -0.06622108f, 0.20915675f, 
    -0.01955744f, 0.02423510f, 0.28017581f, -0.01233900f, 0.20613511f, 0.11644970f, -0.13809943f, 0.17070241f, 
    0.18983194f, -0.37885875f, -0.14809987f, -0.16728956f, 0.00421395f, 0.06805816f, 0.11633006f, 0.17422269f, 
    -0.02790234f, 0.18356392f, 0.05498789f, 0.04729751f, 0.10491338f, -0.08697947f, 0.19224919f, -0.01417669f, 
    -0.00795166f, 0.21341847f, 0.11816335f, 0.08306546f, 0.15135702f, 0.18357185f, -0.26103055f, 0.01035745f, 
    0.18845543f, -0.03362338f, 0.21016414f, 0.39962205f, -0.03231683f, 0.18158074f, -0.22700144f, 0.12222686f, 
    0.25816900f, -0.22824650f, -0.16317908f, 0.07008870f, -0.33415401f, -0.05675302f, 0.11959760f, 0.11905567f, 
    -0.03196359f, 0.29950911f, -0.02982227f, 0.33520818f, 0.01642020f, 0.03590036f, -0.14540929f, 0.00300877f, 
    -0.24565689f, -0.30004263f, 0.21934626f, 0.04576486f, 0.04959899f, 0.04524554f, -0.02183353f, 0.29596007f, 
    0.00501646f, 0.24072829f, -0.26100981f, 0.08369482f, -0.04846757f, -0.13481237f, 0.12318823f, -0.04048743f, 
    -0.03416842f, 0.08361570f, -0.13234814f, 0.03847736f, -0.12636000f, -0.10546493f, -0.02189996f, -0.10624692f, 
    0.06642396f, -0.08531299f, -0.10158207f, -0.12731166f, -0.03806998f, -0.06221440f, -0.06358933f, 0.03130816f, 
    -0.03643210f, 0.09597989f, 0.01248167f, -0.07384315f, -0.15508604f, -0.08035446f, 0.02590942f, -0.05776187f, 
    0.02265878f, 0.08136501f, 0.01756775f, -0.01228797f, 0.00401792f, -0.06525545f, -0.03032401f, 0.04636789f, 
    -0.08867051f, -0.01931849f, -0.04524541f, 0.05154863f, 0.06979574f, -0.02486544f, -0.04178122f, 0.00920020f, 
    -0.09213963f, 0.11179169f, -0.03491482f, 0.04725967f, 0.05090632f, 0.09800692f, 0.08120934f, 0.00697176f, 
    0.04259432f, 0.03256378f, 0.09031267f, -0.12311748f, 0.06708778f, -0.11059277f, -0.01172451f, -0.09891850f, 
    -0.01581562f, -0.04517319f, -0.10806726f, -0.15202315f, -0.02962293f, -0.09286668f, -0.09146708f, -0.09296825f, 
    -0.03613661f, 0.05558667f, -0.17863706f, 0.06109047f, 0.23047899f, 0.04240090f, -0.16691661f, 0.07375184f, 
    0.25468236f, 0.00723910f, 0.14490031f, 0.03540097f, 0.39499849f, -0.17782238f, -0.03633002f, 0.21496409f, 
    0.04965368f, 0.11786408f, -0.05040657f, -0.03006515f, 0.26822481f, 0.11933926f, -0.05866290f, 0.33783066f, 
    0.13714135f, 0.39853650f, -0.01212451f, -0.00168918f, -0.28695375f, -0.25910723f, -0.01172980f, 0.27332485f, 
    0.16144077f, -0.16183014f, 0.15579601f, 0.37946290f, -0.07490893f, 0.16587433f, 0.22990467f, 0.08380390f, 
    -0.22603175f, 0.37557980f, -0.13644256f, -0.18304962f, -0.11074992f, 0.22815172f, 0.00027509f, 0.11552986f, 
    -0.40498546f, 0.07677453f, 0.26679665f, 0.08919225f, 0.14970601f, -0.01834758f, -0.08795606f, 0.17917474f, 
    -0.30459735f, 0.27831212f, -0.28352851f, -0.37187809f, -0.13687861f, 0.07236370f, 0.36126328f, 0.25408027f, 
    0.04075224f, -0.00650657f, 0.47128841f, 0.13619603f, -0.20784980f, 0.13448054f, 0.11787826f, -0.07157380f, 
    0.04684932f, 0.00893989f, 0.19255428f, -0.17832729f, 0.11633579f, -0.06390727f, 0.03955683f, -0.00753792f, 
    -0.06312607f, 0.08760767f, -0.07293037f, 0.07353538f, 0.09923565f, 0.05372389f, 0.05305015f, -0.11223014f, 
    -0.18598358f, -0.02725764f, 0.03840138f, 0.34249875f, 0.19768459f, 0.16071108f, 0.29931584f, 0.17940395f, 
    -0.31485012f, 0.07770531f, 0.10378913f, -0.13516757f, -0.15921621f, -0.03534239f, -0.00071954f, -0.09328893f, 
    0.37973469f, 0.20628960f, 0.06614590f, 0.37060910f, 0.05814819f, -0.22880472f, -0.14648089f, -0.05603825f, 
    0.01104356f, -0.09175412f, 0.08311242f, -0.17357218f, -0.19087745f, 0.09547278f, -0.33290973f, 0.27443630f, 
    -0.12902544f, 0.17189239f, -0.09545673f, 0.01886017f, 0.20117076f, 0.11638141f, -0.11021669f, 0.19961870f, 
    0.14503844f, 0.27402014f, -0.07766260f, -0.16536167f, 0.18233636f, 0.04912673f, -0.58774215f, 0.29185924f, 
    -0.12531359f, 0.34780735f, -0.02437747f, 0.23310332f, -0.09420846f, -0.03871046f, -0.24832712f, -0.17447813f, 
    0.14015225f, -0.08939888f, -0.07011440f, -0.01212216f, 0.17585519f, 0.14733440f, 0.13821810f, 0.24702272f, 
    0.17807835f, 0.12629281f, -0.13503130f, 0.00403565f, -0.07798871f, -0.24127622f, 0.02634350f, 0.11100286f, 
    0.27146757f, 0.47601497f, -0.12267913f, 0.14653909f, 0.44398478f, 0.17628483f, 0.01422451f, -0.20258559f, 
    0.17162344f, -0.10003705f, 0.04436586f, 0.07557999f, 0.07679166f, 0.21210866f, -0.06963424f, 0.25618246f, 
    -0.14789844f, 0.04921908f, -0.06038028f, 0.24378449f, 0.17562687f, -0.06292694f, 0.21099336f, -0.33858234f, 
    -0.08365144f, -0.07178261f, 0.34859428f, -0.16655912f, 0.11918075f, -0.16405275f, 0.10978422f, -0.08230526f, 
    -0.14317724f, -0.43274030f, 0.24081729f, 0.23582499f, -0.23911500f, -0.05102368f, -0.12389389f, -0.12355514f, 
    0.23343201f, -0.16790065f, 0.13047706f, -0.15599336f, -0.02995468f, -0.03875473f, 0.17860776f, 0.07568208f, 
    -0.06617550f, -0.04185540f, 0.12570825f, 0.02558001f, -0.46646091f, 0.10625454f, 0.33702910f, 0.05539403f, 
    -0.21528360f, 0.00580180f, -0.07335353f, 0.33753985f, 0.31126246f, 0.34132734f, 0.24609187f, 0.08159740f, 
    -0.12128374f, 0.20989591f, -0.05114664f, -0.13562638f, -0.01037236f, 0.14965057f, -0.03485661f, 0.01494300f, 
    0.17638852f, 0.43758494f, 0.10149329f, 0.33239052f, 0.05916391f, 0.04399385f, 0.31699631f, 0.18466693f, 
    0.32547411f, -0.25047100f, -0.04132382f, -0.17590162f, -0.37709898f, 0.09814224f, 0.04684928f, 0.25459787f, 
    0.26773143f, 0.27698964f, 0.12629408f, 0.12223212f, 0.17397796f, 0.11212741f, -0.10053284f, -0.33215681f, 
    0.24450257f, 0.16302930f, 0.02204565f, -0.14491065f, 0.19591548f, 0.01884800f, -0.24370329f, 0.28446370f, 
    -0.18171617f, -0.09292103f, -0.12806384f, 0.11635548f, -0.57343006f, 0.08839252f, -0.16111344f, -0.29508758f, 
    0.20242000f, -0.02244977f, 0.19957101f, -0.08254929f, -0.10146895f, 0.06791155f, 0.15398295f, -0.23224567f, 
    0.11595583f, -0.14700927f, 0.08320258f, -0.01078151f, -0.06942043f, -0.04024721f, -0.23818417f, -0.09394556f, 
    0.08819310f, 0.06404107f, -0.24539475f, -0.17528093f, 0.43597472f, 0.02217854f, -0.36415765f, 0.00355994f, 
    0.04340366f, -0.31943375f, 0.07399480f, 0.11942534f, 0.11850031f, 0.33164215f, -0.02967449f, 0.11960218f, 
    0.23108284f, 0.08552809f, 0.10324769f, 0.36599979f, 0.21757542f, -0.01232936f, 0.23915173f, -0.12534076f, 
    0.33298102f, -0.12138448f, 0.20064706f, -0.05305472f, 0.22031912f, -0.26710513f, -0.13698769f, -0.23550786f, 
    -0.07896637f, -0.09755953f, -0.10840670f, 0.18542802f, 0.17902711f, 0.08317567f, -0.51062882f, 0.06044490f, 
    0.00224508f, -0.01637290f, -0.11573616f, -0.04418156f, 0.19629905f, 0.11653540f, 0.12295744f, 0.20822395f, 
    -0.00046592f, -0.35743785f, 0.09542760f, 0.04904923f, -0.22298190f, 0.29469764f, 0.36799318f, 0.19558778f, 
    -0.13509633f, 0.20380822f, -0.12212241f, 0.04107614f, -0.27932617f, -0.23015796f, 0.07935508f, 0.06534941f, 
    -0.04389193f, 0.08695026f, -0.26269603f, 0.15178283f, 0.12467255f, -0.13237770f, -0.19788894f, 0.04018664f, 
    -0.18665105f, -0.09096004f, -0.00747033f, 0.08363582f, 0.03541111f, 0.33210453f, 0.16917904f, 0.03907338f, 
    0.27115962f, 0.08349755f, -0.18050097f, 0.02191943f, -0.27362534f, 0.00528377f, 0.27879980f, 0.14679109f, 
    0.13312194f, 0.01147266f, 0.32179993f, -0.29581502f, -0.02480838f, 0.19881736f, 0.20066489f, 0.02475430f, 
    0.23032308f, 0.13038962f, 0.10994697f, -0.06571607f, 0.33841419f, -0.11094577f, -0.20137493f, 0.18717305f, 
    0.05350752f, -0.24042012f, -0.14677784f, 0.10004484f, -0.02781610f, -0.08530741f, -0.06453476f, 0.04320852f, 
    0.16710880f, -0.03739315f, -0.13335270f, 0.02186284f, 0.29720712f, -0.00736225f, -0.22665930f, 0.09748878f, 
    0.20673695f, -0.11814654f, 0.43193057f, -0.09620165f, -0.12748054f, -0.21459328f, 0.04307139f, 0.15525320f, 
    -0.07974619f, 0.02498518f, 0.63926476f, -0.20973910f, 0.29528758f, -0.02673157f, 0.15284240f, 0.10231414f, 
    0.01027407f, -0.01849507f, -0.08220785f, 0.12377345f, -0.06895377f, 0.10130572f, 0.34690642f, 0.19875151f, 
    -0.27860859f, -0.14000182f, 0.18429218f, 0.39687812f, 0.01241411f, -0.06566925f, 0.25597239f, 0.09723561f, 
    0.06448624f, 0.02196908f, -0.56270057f, -0.43377367f, 0.04081278f, -0.11606884f, 0.01255212f, -0.13315460f, 
    0.27397931f, 0.31488803f, 0.02444901f, 0.06111842f, 0.26169953f, 0.12981650f, 0.16399683f, 0.12145134f, 
    -0.56957853f, 0.00345719f, 0.18292086f, 0.14574766f, 0.56322312f, 0.06611240f, 0.20549387f, -0.25033984f, 
    0.14602509f, 0.08549505f, 0.25692761f, -0.07375718f, 0.44520116f, -0.20717861f, 0.33382952f, -0.11771485f, 
    -0.02200152f, 0.28844339f, -0.56050438f, -0.08717152f, -0.69409758f, -0.35067889f, -0.04048814f, -0.20001706f, 
    0.09566370f, -0.37272993f, -0.69900513f, 0.24599947f, 0.24694628f, -0.18446912f, -0.31644776f, -0.05590142f, 
    0.23877577f, 0.07845104f, -0.11700055f, -0.06984840f, 0.06218499f, 0.26029032f, 0.08720911f, -0.77860600f, 
    0.09102778f, -0.12692218f, 0.18135171f, -0.00792579f, 0.27306986f, 0.07946187f, 0.20306398f, 0.18250683f, 
    -0.30539018f, -0.20228674f, 0.15619934f, 0.18340077f, -0.32190764f, 0.05508005f, -0.15979843f, 0.13645689f, 
    0.00303652f, -0.09255025f, 0.07380188f, -0.00344741f, 0.04066641f, 0.09277944f, 0.06651383f, -0.11417219f, 
    -0.09129317f, 0.00716008f, -0.09506226f, -0.05395751f, -0.14007585f, 0.05511136f, 0.04796732f, -0.03648834f, 
    -0.04606423f, 0.02957692f, 0.05747407f, 0.03965907f, -0.08252128f, -0.09317592f, -0.05343579f, 0.02489867f, 
    0.00915649f, 0.08619637f, 0.02720126f, 0.00208285f, -0.09332901f, -0.01970614f, -0.00223140f, -0.11288805f, 
    0.02583931f, -0.03247168f, -0.10639678f, -0.06833101f, -0.11679310f, -0.10677046f, -0.04178046f, 0.08884926f, 
    -0.13147573f, 0.04941720f, 0.03900164f, -0.05933616f, 0.11314373f, -0.14266267f, -0.00851698f, 0.09229652f, 
    -0.09291776f, -0.10357457f, -0.09005963f, -0.12389065f, -0.13422726f, -0.02650152f, -0.03675599f, 0.03255960f, 
    -0.04583184f, -0.08959805f, -0.00859705f, -0.09448572f, 0.00923460f, -0.08832915f, -0.09411853f, -0.05961539f, 
    0.13072422f, -0.31910026f, -0.09172630f, 0.00420397f, 0.18841282f, 0.10250710f, -0.18999822f, 0.26400438f, 
    -0.11605052f, -0.10627065f, 0.02888572f, 0.30581719f, -0.29036242f, -0.03042562f, 0.07964045f, -0.09448624f, 
    0.06067861f, -0.09598318f, 0.18720096f, -0.04067401f, 0.18638837f, 0.16926283f, -0.01936751f, -0.15610605f, 
    0.00885307f, -0.05908453f, 0.20095372f, 0.14027333f, -0.10610289f, 0.12815793f, -0.31765532f, -0.02167765f, 
    0.31134841f, -0.32810563f, -0.03302104f, 0.06848212f, 0.35920003f, 0.01999373f, -0.35350966f, -0.02758372f, 
    0.01352763f, 0.00368027f, 0.05172051f, 0.01738901f, 0.00162981f, 0.18612298f, 0.04256992f, -0.03039768f, 
    0.08597624f, -0.30296838f, 0.03386098f, 0.19740039f, 0.12324616f, 0.07835474f, 0.29101214f, 0.11109855f, 
    0.17217803f, -0.08051629f, -0.17090076f, 0.21967806f, -0.11506248f, -0.27705202f, -0.11132776f, -0.50533211f, 
    0.07408242f, 0.25374866f, -0.12486584f, 0.12423201f, 0.13988815f, 0.16579790f, 0.18120773f, 0.08951727f, 
    0.17704460f, -0.52737582f, 0.20387068f, 0.04059113f, -0.41364419f, 0.00209631f, 0.30527824f, -0.00999231f, 
    0.17849770f, -0.15022248f, -0.09504000f, -0.09840225f, 0.08921839f, 0.16554794f, 0.26082894f, -0.19347073f, 
    -0.00607491f, 0.18773328f, 0.09498860f, -0.12857187f, 0.03911665f, -0.18579201f, -0.31617352f, 0.26558024f, 
    -0.14243521f, 0.00917338f, -0.23567641f, 0.21874540f, -0.06047990f, -0.03665766f, -0.02663567f, -0.05839829f, 
    -0.13307597f, -0.25887758f, 0.02602810f, -0.20480070f, 0.10391405f, -0.12041587f, 0.27656668f, -0.13098933f, 
    0.23442236f, 0.24440727f, 0.18563333f, -0.07637219f, 0.08790327f, -0.00097908f, -0.08509143f, -0.13220677f, 
    0.41784093f, 0.15064810f, 0.31204063f, 0.04376772f, 0.09518413f, 0.10734332f, 0.09628021f, 0.13569440f, 
    -0.21674174f, -0.20594718f, -0.16551876f, 0.19847682f, 0.03895363f, 0.10849947f, -0.29505223f, 0.09365697f, 
    -0.04149102f, -0.02612754f, 0.27404982f, -0.10238142f, 0.41640308f, -0.06446830f, 0.32660082f, 0.23256983f, 
    0.04251680f, -0.24579073f, -0.20467319f, -0.13096732f, 0.07383405f, 0.20537412f, 0.37785858f, 0.03673107f, 
    -0.15811293f, 0.28106222f, -0.60899234f, 0.15601359f, -0.35804328f, -0.13407998f, 0.02347666f, 0.01776189f, 
    0.26485327f, 0.15277891f, -0.36665541f, 0.37857178f, -0.01873230f, -0.05532246f, -0.02226452f, 0.10055115f, 
    0.12992637f, 0.21620218f, 0.01195809f, -0.10046863f, -0.05641523f, 0.27916038f, -0.21131244f, -0.03701636f, 
    0.16401954f, -0.18956168f, 0.22700042f, -0.33915725f, -0.04521901f, 0.00869127f, -0.09866176f, 0.14522660f, 
    0.06898987f, 0.26447070f, 0.28631607f, 0.05992451f, -0.11011793f, 0.33000952f, -0.00826382f, 0.26235515f, 
    0.02581417f, -0.03908581f, -0.07534390f, 0.04262967f, 0.08539692f, -0.15268302f, -0.32241443f, 0.13482091f, 
    0.18103410f, -0.18112122f, -0.07480061f, -0.04130591f, -0.31533337f, -0.01400849f, 0.01215226f, 0.06960518f, 
    0.02584824f, -0.20476028f, 0.00864412f, 0.06137312f, -0.18790035f, 0.21262290f, 0.10042539f, 0.14040719f, 
    0.00056767f, 0.10332538f, 0.42339131f, -0.03582757f, 0.12547651f, -0.06548895f, -0.01604355f, 0.32149386f, 
    -0.04226515f, 0.03002273f, -0.08266359f, 0.03110341f, -0.13998929f, 0.05764912f, 0.13385639f, 0.15482984f, 
    -0.06135121f, -0.40200296f, -0.01179615f, -0.03889485f, 0.06191688f, -0.08490101f, -0.00090289f, 0.33357757f, 
    0.35094529f, 0.05011892f, -0.05395664f, 0.10296022f, -0.00033680f, 0.03920665f, -0.00655198f, -0.05398591f, 
    0.03172675f, 0.14306399f, -0.23440668f, -0.40385440f, 0.12346681f, 0.02914612f, 0.31711909f, 0.23908944f, 
    0.13516393f, 0.33318573f, -0.16552374f, -0.03732974f, 0.06744561f, 0.00300181f, -0.21164055f, 0.18063891f, 
    0.09707042f, -0.13309705f, 0.18722725f, 0.42644277f, -0.01763317f, -0.13548939f, -0.09266892f, -0.13412248f, 
    0.24619465f, -0.12135473f, 0.47716653f, -0.04400726f, 0.06818378f, -0.03000661f, 0.04873077f, 0.28331110f, 
    0.15070350f, 0.30371630f, 0.18803796f, -0.30497178f, -0.04859808f, -0.09034194f, -0.43054879f, 0.00520817f, 
    0.17126651f, -0.22868873f, -0.14499369f, 0.36739263f, 0.03311244f, 0.01565085f, 0.23349085f, 0.14329323f, 
    -0.19853401f, -0.02562169f, 0.12601900f, -0.24918929f, -0.12013613f, 0.11790771f, 0.04498735f, 0.13637990f, 
    -0.05664669f, 0.33850548f, -0.10690636f, 0.14953275f, 0.22590081f, -0.03077833f, 0.07232144f, 0.08358893f, 
    0.00929181f, 0.05982591f, 0.17370932f, -0.19570799f, 0.16698353f, -0.16058019f, 0.27624321f, 0.05969555f, 
    -0.03801377f, 0.02256699f, 0.05160953f, -0.09007099f, -0.15115891f, -0.06795765f, -0.08567483f, 0.00545543f, 
    -0.07541145f, -0.01311119f, -0.04534662f, -0.10048690f, -0.05567493f, 0.11283265f, 0.00765030f, -0.04553561f, 
    -0.08385930f, 0.01280255f, 0.08673175f, -0.00175720f, -0.09442880f, -0.10145865f, -0.04311103f, -0.11280078f, 
    -0.03935849f, -0.06872671f, -0.14488524f, -0.11601491f, -0.02078643f, -0.03890505f, 0.08034316f, -0.11819462f, 
    0.08337498f, -0.08935256f, 0.10375650f, 0.04723977f, -0.09103653f, -0.03172834f, 0.02927162f, -0.07802171f, 
    0.02036455f, -0.01774359f, 0.08589821f, -0.13230997f, 0.00332841f, -0.05498940f, 0.11694211f, -0.03685948f, 
    0.05830976f, 0.08204472f, -0.12935157f, 0.03506599f, -0.10560119f, -0.03392935f, -0.10192170f, 0.08469799f, 
    -0.14949274f, -0.01533647f, 0.01182310f, -0.06484884f, -0.06917417f, 0.07857604f, -0.05339456f, 0.03824195f, 
    0.02564744f, 0.08440753f, 0.35396299f, 0.08306180f, -0.09912641f, -0.15846877f, -0.16572359f, -0.12649141f, 
    0.15869538f, -0.02171668f, -0.00450393f, -0.08418672f, 0.13168703f, 0.11946632f, -0.08638440f, 0.16543764f, 
    -0.06677481f, 0.10870376f, -0.45852494f, 0.10256398f, -0.11212006f, -0.03700024f, -0.04982630f, 0.24616340f, 
    -0.08435108f, 0.02548470f, -0.04218910f, 0.06195626f, 0.15059060f, 0.01504675f, 0.57419795f, 0.10532110f, 
    0.06937037f, 0.64123017f, -0.03938057f, -0.01316071f, 0.07076383f, 0.01688105f, 0.27653745f, 0.02169557f, 
    0.27678141f, -0.01139710f, 0.02650919f, 0.07991575f, -0.12153916f, 0.14478099f, -0.16934039f, 0.25599250f, 
    0.07597405f, 0.15252748f, 0.01168240f, -0.07177459f, -0.04337149f, 0.00982539f, 0.07939700f, -0.11724883f, 
    -0.17546505f, -0.01213434f, 0.07299020f, -0.13651210f, -0.01280253f, 0.21142651f, 0.02719370f, 0.32411060f, 
    0.02352084f, -0.02881673f, 0.02840897f, -0.24349615f, -0.20577422f, -0.10866679f, -0.23854306f, 0.24887794f, 
    0.10778202f, 0.02271123f, 0.04284320f, 0.16445433f, -0.49645361f, 0.00175837f, -0.17167880f, -0.06301162f, 
    0.21933576f, 0.18887682f, -0.19362871f, 0.07358740f, -0.22294791f, 0.17119586f, -0.31658703f, 0.27849346f, 
    0.15408434f, 0.06288692f, 0.33685669f, 0.02864826f, 0.27707294f, 0.11380810f, -0.06073724f, 0.03493305f, 
    0.30899051f, 0.12201974f, -0.26267049f, -0.08444408f, -0.26361197f, 0.15923378f, 0.41317299f, -0.00752836f, 
    0.02359156f, -0.00240788f, 0.07899690f, 0.20781216f, 0.08403442f, -0.08553683f, -0.26404735f, 0.54484373f, 
    -0.15751687f, 0.07670518f, 0.01042020f, 0.22992867f, 0.05105297f, -0.00174355f, 0.03686283f, -0.05265721f, 
    -0.06881049f, -0.03723533f, -0.19704677f, -0.14875503f, 0.24502167f, -0.10763641f, 0.15162946f, 0.26748309f, 
    -0.03139567f, 0.11779813f, 0.54325885f, 0.37559894f, 0.12800175f, -0.11438081f, -0.02320121f, 0.05047466f, 
    -0.07515087f, -0.08656365f, 0.08964718f, -0.05622377f, -0.25128263f, 0.01334057f, 0.11948475f, -0.05147652f, 
    -0.03091081f, 0.05071056f, -0.12314264f, -0.12962526f, 0.24392347f, 0.31618747f, 0.08435506f, -0.28354564f, 
    0.00823793f, -0.10408410f, 0.21400268f, 0.19955586f, 0.18190238f, -0.03203018f, 0.17307384f, 0.22970781f, 
    -0.32450849f, 0.39672670f, 0.00323458f, -0.16267611f, 0.29313108f, -0.18739775f, -0.21782839f, 0.01285613f, 
    0.21966361f, -0.42645869f, 0.01143163f, 0.32060593f, -0.02129274f, -0.03007215f, 0.15971784f, -0.10774101f, 
    0.51591384f, -0.15638752f, -0.03594608f, 0.20946790f, 0.01953193f, -0.00384307f, -0.01171920f, -0.01062121f, 
    0.29446253f, 0.17270780f, -0.00598753f, -0.03540631f, 0.11869150f, 0.03457618f, -0.23873658f, -0.16942102f, 
    -0.02441975f, 0.28480488f, 0.44724986f, -0.08200648f, 0.11353512f, -0.08516768f, -0.02086836f, -0.00298497f, 
    0.07100436f, -0.04358401f, -0.15048295f, 0.18857327f, 0.29873765f, -0.06111333f, 0.05532826f, -0.12976763f, 
    -0.23169528f, 0.00328770f, 0.02010349f, -0.19140121f, 0.15414971f, -0.00421150f, -0.14890474f, -0.05992021f, 
    0.17660557f, 0.11427844f, 0.38031787f, 0.12097757f, -0.05262478f, 0.06601810f, 0.46282461f, 0.22831100f, 
    -0.32356998f, 0.13672397f, -0.21440428f, -0.21654499f, 0.17405720f, -0.03476026f, 0.23574482f, 0.04460239f, 
    0.01265359f, 0.04004776f, -0.04880263f, 0.29993051f, -0.03600511f, -0.16175759f, 0.09684773f, 0.21539031f, 
    -0.29055905f, -0.35883769f, -0.10916427f, 0.23631477f, -0.04542657f, 0.04116536f, -0.24078281f, 0.29608485f, 
    -0.22541240f, 0.12311328f, -0.30541003f, -0.30566508f, -0.01378590f, -0.22132994f, 0.08529367f, -0.43304300f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.04767110f, 0.06362247f, 0.28099015f, 0.20003660f, 0.29488340f, 0.19346015f, -0.11743730f, -0.15972994f, 
    -0.00222789f, 0.11103125f, -0.13501208f, -0.11710813f, 0.17744036f, -0.27761829f, 0.05580151f, 0.05819418f, 
    -0.38430008f, -0.08402968f, -0.08058269f, 0.12501892f, 0.13028511f, 0.07725279f, 0.04660528f, 0.05956565f, 
    0.03715681f, 0.05412095f, -0.15508147f, 0.00563280f, 0.07021340f, 0.22206874f, -0.15929382f, -0.16842882f, 
    0.19207115f, -0.07289509f, 0.01443174f, 0.04314638f, 0.17564522f, -0.06442492f, 0.20136476f, 0.10191278f, 
    0.19578230f, -0.11276894f, -0.10115131f, 0.04645335f, 0.02081952f, 0.20448303f, -0.11601035f, 0.14051197f, 
    0.11792260f, 0.04713012f, 0.13091242f, 0.04964104f, 0.12936829f, -0.14019857f, 0.20609133f, 0.18019767f, 
    0.21214080f, -0.02454489f, 0.02468398f, -0.09343216f, 0.04713205f, 0.33013257f, -0.03758443f, -0.20427537f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.10353839f, -0.38736981f, -0.11357457f, -0.36786595f, 0.06739470f, 0.17654827f, -0.19538455f, -0.25795710f, 
    -0.02137937f, -0.28219730f, -0.00500146f, -0.12571561f, -0.30968264f, -0.65543020f, 0.05603157f, -0.14826772f, 
    0.09148026f, 0.01369059f, -0.06722611f, -0.01205594f, 0.24567813f, -0.60001326f, 0.36264318f, 0.16741659f, 
    0.35274178f, -0.19948629f, 0.07787921f, 0.10876451f, -0.41754359f, 0.34729135f, 0.02814998f, -0.68368220f, 
    -0.18432949f, -0.11886029f, 0.00014736f, -0.14199339f, 0.02881438f, 0.02667027f, 0.19201823f, -0.09434700f, 
    -0.12194943f, 0.04781741f, -0.36800858f, -0.05489855f, 0.05393556f, -0.04787287f, 0.07078362f, 0.13492113f, 
    -0.30926916f, -0.09043646f, -0.07576419f, 0.28287858f, -0.86179465f, 0.09548157f, -0.04762924f, -0.02680321f, 
    -0.22264597f, 0.05669362f, -0.09565514f, -0.09808858f, 0.14016154f, 0.05578938f, 0.17453110f, 0.59484798f, 
    -0.03741709f, -0.13661945f, 0.28588322f, 0.16587852f, 0.10005111f, -0.04615750f, 0.26629907f, -0.11358169f, 
    -0.14889817f, -0.26835272f, -0.12099623f, -0.47107404f, -0.12499935f, 0.21560656f, 0.11511559f, -0.04462363f, 
    -0.01819172f, 0.03250305f, -0.04227723f, -0.64803046f, -0.12821549f, -0.17179132f, 0.11098547f, -0.26843366f, 
    0.13781354f, -0.21834344f, -0.18023069f, -0.00490904f, -0.26168594f, -0.47508955f, -0.11203576f, 0.59213960f, 
    0.15510380f, 0.00753680f, -0.62548584f, 0.16426153f, 0.03596731f, 0.09491553f, -0.01994869f, -0.13424540f, 
    0.14491670f, 0.15558797f, -0.09607381f, 0.15204401f, -0.04262226f, 0.30565640f, -0.36796609f, -0.13240372f, 
    0.01191548f, 0.10038833f, -0.43163499f, 0.36979133f, -0.18347955f, -0.03671452f, 0.16014913f, 0.13029243f, 
    -0.46257100f, 0.04668668f, 0.22017720f, -0.03263485f, -0.21712410f, 0.10974748f, -0.02031222f, -0.08486731f, 
    -0.13847417f, 0.12240392f, -0.08631598f, -0.16981663f, 0.04066165f, 0.06211751f, -0.54066747f, -0.19398232f, 
    0.40011489f, 0.24904887f, 0.07910788f, -0.25040624f, 0.09822402f, -0.21839768f, -0.10259388f, -0.07848295f, 
    -0.04575120f, 0.03714084f, -0.05614652f, -0.22792810f, 0.17239772f, -0.13916519f, -0.35338235f, -0.23275425f, 
    -0.35935920f, -0.88087493f, -0.24082284f, -0.04246801f, 0.29313612f, 0.45106235f, 0.21504821f, -0.89057451f, 
    -0.21375926f, -0.14179099f, -0.10480203f, -0.15908575f, -0.59159964f, -0.07834171f, -0.13026188f, 0.00537629f, 
    0.15931930f, 0.04641735f, -0.52687865f, -0.40059674f, -0.06257595f, 0.00686068f, -0.70684940f, 0.26479253f, 
    -0.75747281f, 0.25184801f, -0.03475313f, 0.14468226f, -0.44065565f, -0.02855168f, -0.16531777f, -0.02850701f, 
    -0.48646876f, 0.00397877f, 0.21464105f, -0.13780291f, 0.21506147f, 0.39225829f, -0.31969318f, 0.11286381f, 
    0.11690222f, 0.00672143f, 0.03387219f, -0.13852708f, -0.02462951f, 0.16330534f, 0.24426606f, 0.11882386f, 
    -0.47010481f, -0.42039153f, 0.02390498f, -0.26454887f, -0.23200165f, -0.52681065f, -0.03428697f, 0.02259479f, 
    -0.37402111f, 0.07181790f, -0.02028513f, 0.09144565f, -0.15193106f, 0.08283345f, -0.07001858f, 0.15504707f, 
    0.13954486f, -0.41770518f, -0.09346418f, -0.06123495f, -0.43312413f, 0.04783943f, -0.00654906f, -0.03959681f, 
    -0.11546581f, -0.02524651f, 0.16126551f, 0.18964636f, 0.10810316f, 0.01002239f, -0.35796121f, -0.03908435f, 
    -0.53867626f, -0.08603887f, 0.19260004f, -0.22670409f, -0.01802600f, -0.82192218f, -0.00400012f, -0.23656820f, 
    0.21973115f, 0.00919073f, 0.20453872f, -0.13975044f, -0.71548665f, -0.03686426f, 0.07580625f, 0.10460055f, 
    0.18060501f, -0.10972547f, -0.50022125f, -0.11760751f, 0.03519683f, -0.41030926f, 0.18359119f, -0.19197458f, 
    -0.09136703f, -0.16394641f, -0.12277292f, 0.44600850f, 0.27892339f, 0.19057414f, -0.45206133f, -0.38876414f, 
    -0.54427505f, 0.17890960f, -0.05130034f, -0.07757239f, -0.07458144f, -0.56180203f, 0.04374753f, 0.06402827f, 
    -0.10042433f, 0.06806234f, 0.07200138f, 0.29953486f, -0.15440169f, 0.23850295f, -0.15246244f, 0.19875582f, 
    -0.16407199f, -0.35339874f, -0.25183329f, -0.04806853f, -0.20017242f, 0.03386401f, -0.03782092f, -0.14596789f, 
    0.04874852f, -0.07710405f, 0.18959519f, -0.08942885f, 0.01149818f, 0.01130989f, 0.01957050f, 0.03442169f, 
    0.26503035f, 0.03151075f, 0.06253546f, -0.18241552f, -0.01044479f, -0.14635941f, 0.14784351f, -0.06640464f, 
    0.19244821f, -0.22848326f, -0.01651117f, -0.51104814f, -0.34596145f, -0.12316583f, -0.33444911f, 0.26827651f, 
    0.24883167f, -0.07045889f, -0.11755737f, -0.01740161f, 0.15069738f, -0.07476990f, 0.03762410f, -0.51144862f, 
    -0.43768084f, -0.12676194f, -0.14340940f, 0.23734938f, 0.16698802f, -0.03455222f, 0.07387469f, 0.33815971f, 
    -0.22754216f, -0.09719808f, -0.10209230f, 0.52082008f, 0.08209851f, -0.35231063f, -0.02081321f, -0.14993352f, 
    -0.27259198f, -0.11237113f, 0.07674487f, -0.30508816f, 0.11011884f, -0.40618601f, 0.08739089f, -0.15259965f, 
    0.19103166f, 0.33269128f, -0.05854221f, 0.04208054f, 0.27898431f, -0.66138524f, -0.09837577f, -0.02117455f, 
    0.08159515f, -0.07725261f, -0.36513305f, -0.03228605f, 0.06098982f, 0.00862396f, 0.09607939f, 0.02070821f, 
    -0.12428889f, -0.11975969f, 0.24125111f, 0.21979377f, 0.10965374f, 0.15845925f, 0.15350705f, -0.15177445f, 
    0.20419709f, -0.49448171f, 0.05334376f, -0.26166573f, 0.40559968f, 0.02919075f, -0.03973145f, -0.06532599f, 
    0.17735463f, -0.01689637f, 0.03699169f, 0.02640091f, -0.03921906f, 0.11106833f, -0.36670721f, 0.03658414f, 
    -0.30850729f, 0.02250049f, -0.12294881f, -0.87068766f, 0.15203430f, 0.05566032f, -0.20483342f, -0.38825509f, 
    -0.53174132f, -0.29697898f, 0.03171952f, -0.43551978f, 0.24653332f, -0.19501866f, 0.02354449f, -0.03255685f, 
    0.01298403f, -0.00280244f, -0.03797249f, 0.01096067f, 0.15197244f, 0.12280954f, -0.55195737f, 0.15505575f, 
    -0.06457535f, 0.37829572f, 0.03398100f, -0.12396482f, -0.51638317f, 0.17598997f, -0.44049495f, -0.48215765f, 
    0.12337773f, -0.12280525f, -0.22526774f, -0.25105804f, -0.04925761f, 0.01838644f, 0.13748667f, -0.06563700f, 
    0.09627427f, -0.06924064f, -0.33358094f, -0.03643221f, 0.09736015f, 0.28198159f, -0.34536597f, 0.16013746f, 
    -0.79000556f, -0.05466228f, 0.29699481f, -0.01625948f, 0.00122074f, 0.10287455f, 0.12933539f, -0.14077918f, 
    0.26628461f, -0.09125617f, 0.17735453f, -0.01054325f, 0.11516790f, -0.04664530f, -0.52439952f, -0.01688811f, 
    -0.16237620f, -0.37535569f, -0.61510026f, -0.16205895f, -0.37476417f, 0.05582464f, 0.22843330f, 0.27910027f, 
    -0.10516736f, -0.04798652f, 0.10889816f, -0.03362452f, -0.50837451f, 0.70381939f, 0.05676021f, -0.11174794f, 
    0.40057987f, -0.07526022f, 0.00044505f, -0.11890121f, -0.34893283f, -0.05834617f, 0.19549611f, 0.07939328f, 
    -0.08078228f, 0.14442644f, -0.04155616f, 0.03753139f, -0.13145202f, -0.02664565f, 0.05273158f, 0.19134374f, 
    -0.35754481f, -0.08852223f, 0.25885031f, -0.04773441f, 0.05399784f, 0.06531865f, -0.36912572f, -0.05425413f, 
    -0.02219547f, -0.10322206f, 0.11967114f, -0.31138125f, 0.07850198f, 0.21668579f, 0.20399506f, -0.55910140f, 
    0.15573360f, -0.27912587f, -0.00604765f, -0.22856088f, -0.07082344f, -0.02796711f, -0.55635434f, -0.44427776f, 
    -0.39420772f, 0.06584912f, -0.08059350f, -0.08487791f, 0.14166380f, -0.05182220f, 0.08053689f, 0.31192976f, 
    0.18570206f, 0.09785242f, 0.07408800f, 0.20072633f, -0.46014312f, -0.94200003f, -0.50823838f, 0.04778487f, 
    0.13252619f, 0.11690432f, -0.02112876f, -0.06803233f, 0.16884308f, 0.08932322f, 0.03483648f, -0.09097723f, 
    0.17658870f, -0.03443791f, -0.07775714f, -0.43277723f, -0.08008152f, 0.41749576f, 0.12956163f, -0.63543081f, 
    -0.51986426f, -0.19563363f, 0.11286868f, -0.06193844f, 0.32361448f, -0.00586983f, 0.18141887f, -0.24234417f, 
    0.08320680f, -0.07498908f, -0.27670637f, -0.25990632f, -0.27110356f, 0.09225835f, -0.00242680f, -0.17276782f, 
    0.10104807f, -0.00549064f, -0.01511229f, -0.11139992f, -0.07807487f, -0.20249946f, -0.09787228f, 0.02323918f, 
    -0.05324142f, 0.20224035f, -0.46648055f, -0.08919285f, 0.47761688f, -0.02672162f, 0.18863563f, -0.07948294f, 
    -0.43255457f, -0.62756920f, 0.23032495f, 0.07756754f, -0.59899873f, -0.42072859f, -0.21452157f, 0.26449132f, 
    0.17861784f, -0.13930480f, -0.01332072f, -0.26734847f, 0.03400542f, 0.05010318f, -0.45097694f, -0.76852584f, 
    0.44811460f, 0.11894335f, -0.11316437f, 0.26852360f, 0.02747752f, -0.31798765f, 0.07805972f, -0.10888962f, 
    0.17838112f, -0.04452923f, 0.10902993f, 0.08562642f, 0.24446547f, 0.19983107f, -0.01878929f, 0.13051024f, 
    0.20705001f, 0.04162956f, -0.42931458f, -0.12205865f, 0.52400559f, -0.00244629f, -0.42696708f, -0.38247073f, 
    -0.04561289f, 0.07677243f, 0.20212825f, -0.49410176f, -0.00728960f, 0.10922875f, 0.09822607f, -0.14294061f, 
    -0.00189036f, 0.03067065f, 0.09112024f, -0.04143227f, 0.07413205f, 0.02028922f, 0.22754233f, 0.02584369f, 
    0.07493109f, -0.18423466f, -0.23507248f, 0.10446763f, 0.28981069f, -0.15338445f, -0.17864352f, -0.28488553f, 
    0.00874774f, -0.32575595f, -0.30901363f, 0.01077795f, 0.09714794f, -0.29953608f, 0.05111160f, 0.17960688f, 
    0.32362765f, 0.26680693f, 0.20983520f, -0.04190341f, -0.57843518f, -0.12512055f, 0.00962670f, 0.18187033f, 
    -0.08498482f, -0.53286082f, 0.01024771f, -0.29123443f, -0.10549383f, -0.43515265f, 0.11002451f, -0.02661935f, 
    -0.51712751f, 0.03916980f, 0.05823275f, -0.12504010f, -0.42450428f, 0.19853552f, 0.17518319f, -0.27256986f, 
    -0.11459553f, -0.64822358f, -0.31788161f, 0.05721053f, -0.50497252f, 0.19808738f, -0.03087160f, -0.15570027f, 
    0.12970126f, 0.02080350f, -0.22953330f, 0.14614484f, 0.13897778f, 0.03748276f, -0.32843080f, -0.15019420f, 
    -0.39009440f, 0.07390295f, -0.03290492f, 0.05167203f, -0.03955293f, -0.65116316f, -0.15085469f, 0.17587523f, 
    -0.02957799f, 0.29486769f, -0.07700602f, 0.17267342f, -0.37183854f, 0.02642653f, 0.30731308f, -0.24734665f, 
    -0.18497072f, -0.05284530f, -0.13020010f, -0.01371514f, -0.03091466f, 0.23759268f, 0.12305984f, -0.13291515f, 
    -0.13968652f, 0.32468805f, -0.07834984f, -0.08100854f, 0.11092553f, -0.14042288f, -0.30833346f, 0.22801425f, 
    -0.19128487f, -0.04545251f, -0.03856408f, -0.44827136f, 0.11257298f, 0.10391953f, 0.01630888f, 0.00712791f, 
    -0.18041809f, -0.03226212f, 0.05729066f, 0.24736977f, -0.20689854f, -0.23444925f, -0.46960741f, 0.16502944f, 
    -0.28602436f, 0.12265169f, -0.02763048f, 0.08130442f, -0.23905285f, -0.02927589f, 0.27863678f, -0.21601284f, 
    -0.28793889f, 0.02247445f, -0.22978957f, 0.18653269f, 0.11082632f, -0.04696903f, -0.25898102f, 0.00141944f, 
    -0.11657424f, -0.09732100f, 0.18874310f, -0.54459304f, -0.08173153f, -0.08504413f, -0.35696167f, 0.15611604f, 
    -0.33611515f, 0.18339247f, 0.31404376f, 0.03692498f, 0.02981006f, 0.06368710f, 0.04416673f, 0.26858386f, 
    0.18473862f, 0.10072969f, 0.19157694f, 0.07642735f, -0.09474702f, -0.43783411f, 0.15520595f, 0.04585415f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.14549156f, 0.15813504f, -0.11232911f, -0.08840388f, 0.34402215f, 0.08569145f, 0.08259307f, -0.22714539f, 
    -0.28266957f, -0.04180934f, 0.04754962f, -0.06299879f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
