#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.78607398f, 0.34052148f, -0.46728024f, -0.45792705f, -0.59875470f, -0.04250390f, -0.16930774f, -0.08424601f, 
    0.13690273f, 0.41993159f, 0.37259576f, -0.25920543f, -0.28195068f, 0.29786113f, 0.07940366f, -0.05455464f, 
    -0.14178286f, -0.19339669f, 0.03565814f, -0.04449642f, 0.12577979f, 0.15615162f, 0.00782504f, 0.18475817f, 
    -0.04529046f, -0.94385982f, -0.04668412f, 0.21094359f, 0.11902262f, -0.05780080f, -0.01305225f, -0.06553721f, 
    0.30510551f, 0.32509610f, 0.17970046f, -0.04319769f, -0.01859731f, 0.27820325f, -0.32344854f, -0.04627417f, 
    -0.05515231f, -0.30506894f, -0.43146563f, 0.04718275f, 0.54495233f, 0.14374818f, 0.22494252f, -0.02451130f, 
    -0.24302949f, 0.29435861f, -0.33484113f, -0.39979789f, -0.27720198f, 0.11563146f, 0.12584656f, -0.23549676f, 
    0.42673838f, -0.19722922f, -0.43853974f, -0.05178854f, 0.15346992f, -0.02896686f, 0.11279383f, 0.43975499f, 
    0.05226408f, -0.07036597f, -0.24303272f, -0.13306792f, 0.21140164f, 0.10170224f, -0.13324191f, -0.06334344f, 
    -0.16608930f, 0.02109611f, -0.18388018f, 0.22104937f, 0.42737556f, 0.64385140f, -0.81413287f, -0.74354941f, 
    -0.30947798f, 0.65311998f, -0.52564275f, -0.12123030f, 0.42018190f, 0.13973847f, -0.05452805f, -0.00992403f, 
    -0.11249037f, 0.32195112f, 0.07063521f, -0.20562573f, 0.08014758f, -0.08815793f, -0.04326954f, 0.15468086f, 
    0.17534930f, 0.16237947f, -0.29899794f, 0.21894330f, 0.33012727f, -1.05963326f, -0.32030177f, -0.08695438f, 
    -0.15396594f, 0.90336466f, -0.49549422f, -0.15230466f, 0.33020440f, 0.51149112f, 0.16046360f, 0.13634503f, 
    -0.00318024f, -0.10853752f, -0.06923454f, -0.47046205f, -0.09393790f, 0.34442052f, -0.06984661f, -0.37962022f, 
    0.11365412f, -0.06439002f, -0.04373862f, -0.05572600f, 0.41787103f, -0.29783067f, -0.25372303f, 0.12041167f, 
    -0.18991023f, -0.08106326f, -0.38529417f, -0.29217654f, -0.01287904f, 0.62719959f, -0.48141417f, 0.39003196f, 
    -0.36169848f, 0.03696128f, -0.19529764f, 0.07594237f, -0.26600167f, -0.37030628f, -0.04180339f, -0.24931931f, 
    -0.30419463f, -0.23524176f, 0.07366206f, 0.32594076f, 0.12312566f, 0.16094890f, -0.22325806f, -0.07752182f, 
    -0.03693020f, -0.04215400f, -0.26817390f, -0.60654289f, -0.60309756f, -0.33617586f, -0.31742650f, -0.42006832f, 
    0.07834190f, 0.70862931f, -0.22177291f, -0.19188468f, 0.02682080f, -0.38225454f, 0.15578833f, -0.22581324f, 
    -0.34273800f, -0.36116138f, -0.30056643f, 0.26619703f, 0.03081554f, -0.06115514f, 0.11779381f, 0.35168615f, 
    0.55170971f, 0.35084850f, -0.51782125f, 0.07008936f, -0.31395519f, 0.08696761f, 0.03119203f, -0.15993951f, 
    -0.14782655f, -0.26677123f, 0.48601690f, -0.09252015f, 0.31357497f, -0.05151533f, -0.21163543f, -0.34202725f, 
    -0.10448483f, 0.11186910f, 0.12421019f, -0.01091918f, 0.18901755f, 0.13526380f, -0.25246838f, 0.02087472f, 
    0.32753837f, 0.43320295f, 0.32680875f, 0.04804851f, -0.23921674f, -0.28364041f, -0.24005145f, -0.34011731f, 
    -0.25523901f, -0.34905410f, 0.27271715f, 0.21289657f, 0.10243597f, 0.25559783f, 0.30104110f, 0.19776282f, 
    -0.24793431f, 0.11460476f, -0.31766862f, -0.12508005f, -0.05836893f, 0.13915302f, -0.24429670f, 0.07660779f, 
    -0.17544487f, -0.61501914f, -0.05003211f, -0.47300231f, -0.04920399f, 0.01068146f, -0.00191728f, 0.28019828f, 
    0.33140492f, -0.13913566f, -0.34086359f, 0.15850030f, -0.01605893f, 0.17376098f, 0.37517393f, -0.04971266f, 
    -0.22504745f, -0.20992783f, -0.27418029f, -0.09671759f, 0.00109558f, 0.23860794f, 0.23613386f, 0.28373116f, 
    0.19460890f, 0.22992514f, -0.94901502f, -0.81607372f, -0.31586230f, -0.36863819f, -0.04232857f, 0.52995658f, 
    0.30647868f, -0.41176975f, -0.24682301f, 0.51485175f, 0.06633804f, -0.27478656f, -0.04044000f, 0.11514198f, 
    0.04743946f, -0.08521203f, -0.04006238f, -0.19945081f, -0.51039606f, -0.49147689f, -0.15373293f, -0.03816743f, 
    0.01840109f, 0.15133257f, -0.04782219f, -0.63747138f, -0.49675941f, -0.19312261f, -0.23038450f, 0.13998230f, 
    0.10639926f, 0.17553812f, -0.70937002f, -0.28324166f, 0.05880318f, -0.06840967f, -0.16577359f, -0.19498004f, 
    -0.41120824f, -0.48433453f, 0.09175963f, 0.17123619f, 0.10208319f, 0.20436236f, 0.03561120f, 0.11062811f, 
    0.05493269f, 0.04366407f, 0.16140272f, 0.12925456f, 0.52774674f, -0.16277839f, -0.72186589f, -0.71310759f, 
    0.12419856f, 0.61279762f, 0.25758982f, 0.53725213f, 0.06817616f, -0.13342567f, -0.26941696f, 0.04625963f, 
    -0.37393096f, 0.06923947f, -0.21881768f, 0.08255643f, -0.18907656f, 0.09904413f, 0.14857177f, -0.38974902f, 
    0.09073537f, -0.08781430f, -0.16448154f, -0.46164158f, -0.45720124f, 0.83549857f, -1.22518277f, -1.05692041f, 
    -0.57921171f, 0.33845502f, -0.19023566f, 0.41539830f, -0.16949876f, 0.44566047f, -0.27727184f, 0.13379520f, 
    0.46023390f, 0.33791989f, -0.32619324f, 0.20426539f, -0.11832035f, -0.14205386f, -0.21402290f, 0.09553009f, 
    0.21969263f, 0.07580756f, -0.29608223f, 0.00024089f, -0.07601921f, 0.05734451f, -0.91607916f, -0.13646165f, 
    0.25168672f, 0.45653403f, 0.14598680f, -0.30066043f, -0.34077072f, -0.11324255f, 0.11669190f, 0.22647488f, 
    0.19754526f, -0.05849536f, -0.02815341f, -0.02622036f, 0.07703334f, -0.17910460f, -0.05000168f, 0.01398358f, 
    -0.06003636f, -0.17135398f, 0.17419359f, -0.26323995f, -0.03042360f, 0.27890611f, 0.20696984f, -1.35140002f, 
    0.42947114f, -0.48441741f, -0.01379916f, 0.88674831f, -0.04728566f, 0.43885869f, 0.07993305f, -0.17950407f, 
    0.10259901f, -0.01354661f, -0.35903916f, -0.26939172f, -0.36333916f, 0.10046110f, 0.32189044f, -0.33432251f, 
    -0.32779971f, -0.12639478f, -0.25462145f, -0.01153366f, -0.03041804f, -0.45386943f, -0.42237830f, -0.62829834f, 
    0.10919727f, -0.00768633f, 0.32531708f, 0.12612772f, -0.19620621f, -0.45991269f, -0.55065483f, -0.25281256f, 
    0.00772852f, -0.05636033f, 0.03267095f, 0.05750780f, 0.15121098f, 0.13418132f, 0.32114539f, -0.13336833f, 
    -0.08284739f, 0.26720560f, -0.40511814f, -0.05389599f, -0.06772149f, -0.10179207f, -0.14262497f, 0.11796205f, 
    -0.08894634f, 0.37697169f, 0.40467513f, -0.46920007f, -0.19771554f, 0.04408835f, 0.20779027f, 0.02572902f, 
    -0.16303730f, -0.44787103f, -0.11389540f, 0.06383877f, -0.23854266f, 0.03705259f, 0.24515581f, -0.03486157f, 
    -0.05331644f, 0.15943383f, 0.27080506f, -0.08245835f, -0.31055170f, -0.20634128f, -0.06959499f, 0.16318271f, 
    0.11295298f, 0.25793943f, -0.52610946f, 0.10748491f, 0.07676053f, -0.17363793f, 0.19693308f, -0.16396198f, 
    0.44439909f, 0.54794401f, 0.11227738f, -0.20338693f, -0.19916710f, -0.03879628f, 0.31004968f, -0.16714074f, 
    -0.22501560f, -0.22866072f, 0.04459269f, -0.06849197f, -0.09361140f, -0.08017114f, 0.29056600f, 0.13160962f, 
    0.25953794f, 0.06078230f, -0.33106276f, 0.09973852f, 0.00853808f, 0.12066516f, 0.29507789f, -0.20580734f, 
    0.46504989f, 0.04059035f, 0.09697618f, -0.14905168f, -0.11266933f, 0.27544174f, 0.09490769f, 0.11244942f, 
    -0.15372047f, -0.00927329f, 0.01627828f, 0.10257567f, 0.01831703f, 0.07350656f, -0.13811539f, -0.27527395f, 
    -0.10444975f, 0.08869614f, 0.13528809f, 0.13795184f, -0.22964157f, 0.03789658f, -0.50340593f, -0.58747143f, 
    -0.15495221f, -0.05704644f, 0.21858577f, -0.34411505f, 0.02033455f, 0.65226704f, -0.03454021f, -0.00264278f, 
    -0.11521330f, -0.23679417f, 0.03424776f, 0.26818949f, 0.29928762f, 0.27891648f, -0.01525572f, -0.23981039f, 
    0.03669949f, -0.09643374f, -0.33022171f, -0.29392445f, -0.06529738f, 0.75398147f, 1.08543301f, 0.44800717f, 
    -0.19998552f, -0.68415469f, -0.55660486f, -0.41763225f, 0.00563529f, -0.45710322f, -0.67509770f, -0.32501945f, 
    -0.35854271f, -0.26011434f, -0.20591918f, -0.16364798f, 0.12364274f, 0.19628651f, 0.22450623f, 0.00878614f, 
    0.00178122f, -0.12493677f, -0.01628263f, 0.02421180f, 0.02654531f, -0.13270555f, -0.01162974f, -0.06708479f, 
    -0.27370101f, 0.42413208f, -0.09135293f, 0.55401963f, 0.66758895f, -0.34775221f, -0.37278885f, -0.37114266f, 
    -0.22060229f, -0.15449351f, 0.09141789f, 0.24114239f, -0.03251392f, -0.06889280f, -0.28724065f, 0.02615106f, 
    0.07431152f, -0.15642342f, -0.03903860f, -0.07118177f, 0.21847080f, -0.00899571f, -0.05890430f, 0.24845894f, 
    -0.27531922f, -0.03364237f, 0.42080903f, 0.14662966f, 0.16385867f, -0.01584243f, -0.17540552f, -0.18243222f, 
    -0.03911033f, -0.16039893f, -0.13914528f, -0.43508220f, -0.34077725f, 0.28645116f, -0.13596381f, 0.43061742f, 
    0.20955294f, 0.17390645f, 0.11171910f, -0.03716478f, 0.28872573f, -0.20180258f, -0.35191503f, -0.41263491f, 
    -0.14015947f, -0.68638706f, -0.46040511f, 0.52401638f, 0.17532130f, 0.43026966f, 0.37460336f, 0.26400366f, 
    -0.11659598f, -0.17071366f, -0.05748553f, 0.07758838f, -0.07894846f, -0.27801540f, -0.09816446f, 0.24289988f, 
    -0.13467981f, -0.15339504f, -0.16835991f, -0.17613724f, 0.15620665f, 0.27622503f, 0.14432643f, -0.03239912f, 
    0.13793740f, -0.11304574f, -0.46011227f, -0.75536221f, -0.70676118f, -1.00720966f, 0.43842417f, -0.09788876f, 
    0.16579714f, 0.34736165f, 0.38364217f, -0.12244111f, -0.43342379f, -0.48233777f, -0.36270607f, -0.30132872f, 
    0.33238915f, -0.31881753f, -0.05954928f, 0.08155929f, -0.28939515f, -0.07583463f, -0.15167890f, 0.05328847f, 
    0.00875867f, -0.01863269f, -0.59474248f, -0.92134041f, 0.50606281f, 0.55571204f, 0.38268390f, 0.00082194f, 
    0.59651160f, -0.18221797f, -0.55370188f, -0.92486840f, 0.11473247f, -0.14477205f, -0.25861126f, 0.16267246f, 
    -0.10451258f, -0.25981393f, 0.06009953f, 0.04122000f, 0.01351887f, 0.33823726f, -0.20312122f, -0.32266980f, 
    0.23783301f, 0.08628082f, 0.05927109f, -0.62679386f, -0.53327209f, -0.48553821f, -0.46190098f, -0.26963869f, 
    -0.33727464f, -0.05737823f, -0.61003530f, -0.77449864f, -0.53593212f, -0.00855662f, -0.15040129f, -0.20162749f, 
    0.09247134f, -0.27499846f, -0.12842725f, -0.26398492f, -0.09457579f, 0.09484851f, -0.21405239f, -0.15013941f, 
    -0.34866032f, -0.19738111f, -0.14310750f, -0.31955716f, -0.13556652f, -0.30737185f, -0.45820668f, -0.62049484f, 
    -0.68532008f, 0.55501950f, -0.31556830f, -0.22050768f, 0.00048697f, -0.68433207f, -0.04296118f, -0.08749194f, 
    -0.02383644f, -0.29080412f, -0.27447909f, -0.14944158f, -0.17964274f, -0.24938886f, -0.24047691f, -0.12476827f, 
    -0.15669717f, 0.48694852f, 0.55400789f, -0.31794429f, 0.27723980f, -0.38854340f, -0.42411661f, 0.00438198f, 
    0.04268147f, 0.28427288f, -0.35196418f, -0.38537520f, -0.19984439f, 0.00281397f, 0.11952771f, 0.47442457f, 
    0.27000582f, -0.03945167f, 0.12680483f, 0.18607397f, 0.09260243f, 0.10610994f, 0.04582075f, -0.03794099f, 
    -0.04909221f, -0.11111264f, 0.01429819f, 0.18792340f, -0.06257074f, -0.34303644f, 0.26771078f, -0.04297195f, 
    -0.31375200f, -0.12129966f, -0.44585067f, 0.22480349f, -0.11802222f, 0.30592141f, -0.10330526f, -0.18951330f, 
    0.30227116f, -0.27201268f, 0.19526805f, -0.00842641f, 0.08321575f, 0.25293827f, -0.35635737f, 0.02363401f, 
    0.24103527f, -0.17272288f, -0.22057132f, 0.36208904f, -0.07839420f, -0.36893550f, 0.00194823f, 0.15604863f, 
    0.26577750f, 0.20263287f, -0.17623767f, 0.09960304f, -0.17066705f, -0.05801929f, 0.09894315f, 0.09817491f, 
    -0.13714281f, -0.34709212f, -0.14979979f, 0.13302879f, 0.27610987f, 0.08312561f, 0.10079843f, -0.19625825f, 
    -0.33094740f, 0.30207029f, -0.33521613f, -0.09396666f, 0.17556100f, -0.10789044f, -0.18603760f, 0.19799289f, 
    -0.31137648f, -0.06247033f, 0.04300203f, 0.27707756f, 0.27357736f, 0.05125218f, 0.21309234f, 0.26138428f, 
    0.47609758f, -0.12765449f, -0.02840691f, -0.02344076f, 0.15388457f, 0.01186314f, -0.06529211f, 0.02826390f, 
    -0.19618323f, 0.22324449f, -0.25358638f, 0.18946052f, -0.11831353f, -0.05182943f, 0.03096378f, 0.05478280f, 
    0.06777904f, -0.33649880f, -0.19922157f, 0.03872570f, 0.43873987f, -0.15910856f, 0.03673560f, -0.34736001f, 
    -0.32241702f, 0.19987379f, 0.32274464f, -0.24801567f, 0.18544723f, -0.11912102f, 0.17563683f, 0.02151841f, 
    -0.30788213f, 0.03388103f, 0.06275854f, -0.21811941f, -0.22374345f, 0.27091712f, 0.19157702f, 0.02783842f, 
    -0.08586112f, 0.06587249f, -0.74719501f, -0.40514719f, -0.63910151f, -0.53009504f, -0.60062230f, 0.03023650f, 
    -0.18869065f, -0.15706538f, 0.19487022f, 0.33265895f, 0.02783809f, -0.31995937f, -0.07777517f, -0.13741396f, 
    -0.21396419f, 0.11288079f, -0.06499669f, -0.23193845f, -0.00912700f, -0.26117811f, 0.08848468f, -0.18491629f, 
    -0.16239905f, -0.30203846f, 0.32962751f, 0.06887296f, 0.07005691f, 0.01822444f, -0.28778741f, 0.05543932f, 
    -0.16586353f, 0.29400635f, -0.06677807f, -0.15898304f, 0.16319855f, 0.20414419f, -0.13030535f, 0.10294201f, 
    -0.20248024f, -0.15664952f, 0.04600900f, -0.16348886f, -0.04586681f, 0.25790039f, -0.03469073f, -0.00686118f, 
    0.02436014f, -0.28072870f, -0.30106270f, 0.57569891f, 0.03619863f, 0.48907453f, -0.10279774f, -0.13064213f, 
    -0.05610354f, -0.47367880f, -0.19585349f, -0.27483219f, 0.17519721f, 0.30328479f, 0.02634275f, 0.03454554f, 
    -0.03648240f, -0.12133938f, -0.10648307f, -0.13149393f, 0.10386167f, -0.04807277f, -0.14685534f, -0.14436370f, 
    -0.36626807f, -0.33885810f, -0.59406167f, -0.52784854f, -0.51062161f, -0.69660628f, -0.60646623f, -0.02806935f, 
    0.64461958f, 0.13197447f, 0.06580219f, -0.11691940f, -0.06126584f, 0.38806286f, 0.27971816f, -0.43383601f, 
    -0.42923099f, -0.21986045f, 0.45207620f, -0.29231998f, -0.06667773f, 0.07711137f, 0.08591869f, -0.10047492f, 
    0.13639495f, -0.10076153f, 0.06355251f, -0.16656977f, -0.18160248f, 0.07096094f, -0.22805084f, -1.03464639f, 
    0.45323244f, 0.08900023f, -0.48449981f, 0.37298456f, 0.48684427f, 0.25227958f, -0.40965453f, -0.28450823f, 
    0.15782581f, -0.00043683f, -0.04437355f, 0.33844021f, -0.27565530f, -0.30143005f, 0.03491672f, 0.13454770f, 
    -0.12549175f, 0.31653264f, 0.19383948f, -0.10231742f, -0.13038640f, -0.04237075f, -0.15722528f, -0.25099596f, 
    0.18649310f, -0.03028754f, -0.37064028f, -0.39862797f, -0.01253308f, -0.00815128f, 0.11836018f, 0.04974924f, 
    0.30731326f, -0.23841958f, 0.13094136f, 0.09352668f, 0.05197965f, -0.18107663f, 0.09659737f, -0.30312714f, 
    -0.35470518f, 0.06545003f, -0.43276513f, 0.06958032f, -0.03725746f, 0.31167522f, 0.29296216f, 0.21764253f, 
    -0.19267865f, -1.02017283f, -0.59031737f, 0.16238487f, 0.42170325f, 0.04379752f, 0.47220153f, 0.27545804f, 
    -0.04120294f, 0.25198123f, -0.22010392f, -0.31512007f, 0.09735689f, 0.01079213f, 0.00884467f, -0.14893147f, 
    0.09062443f, 0.07768954f, 0.09839778f, 0.23062927f, -0.03948712f, 0.14606588f, -0.09452581f, -0.21327996f, 
    -0.02874328f, 0.83375382f, -0.26937848f, -0.53166741f, -0.35159844f, -0.65631723f, 0.51497251f, 0.43113935f, 
    0.31055698f, 0.15864512f, -0.25693977f, -0.29829833f, 0.07345314f, -0.03188332f, 0.30726701f, -0.13131583f, 
    -0.14435226f, -0.07567342f, 0.08385090f, -0.25701120f, -0.10451286f, -0.01982813f, -0.39221942f, -0.05741395f, 
    -0.17785263f, -0.06830286f, -0.65932536f, -0.40435731f, 0.15840687f, 0.53907925f, 0.26431954f, 0.70933568f, 
    -0.41279837f, -0.59427112f, 0.14288646f, -0.04080864f, -0.08502872f, 0.28756359f, -0.55093712f, 0.18995641f, 
    0.02351392f, 0.22668102f, -0.28656974f, -0.12410485f, 0.29831871f, 0.24809287f, 0.27500448f, -0.20355704f, 
    -0.28755006f, -0.05865392f, 0.21310540f, -0.93851823f, -0.40976146f, -0.29524234f, -0.45511380f, -0.72835404f, 
    0.47516650f, 0.32999560f, -0.57334971f, -0.07519045f, 0.87764865f, 0.02323039f, 0.14986081f, 0.20679362f, 
    0.10509970f, -0.02166438f, -0.10404601f, 0.04998526f, -0.11127013f, 0.14484939f, 0.25522789f, 0.09338691f, 
    0.17558680f, 0.19076012f, 0.00967484f, -0.15021136f, 0.44377884f, 0.16503018f, -0.15390928f, 0.18258962f, 
    -0.48142827f, 0.33545980f, -0.04145880f, -0.07018451f, -0.16670497f, -0.16806151f, 0.02710734f, -0.13694726f, 
    -0.12929589f, 0.31065249f, -0.10251378f, -0.14947329f, -0.24681824f, 0.07665873f, 0.00439188f, 0.20953651f, 
    0.06441989f, 0.04363842f, -0.16301863f, -0.22188209f, 0.13679244f, 0.32262400f, 0.12553084f, -0.44331282f, 
    -0.76332200f, -0.35398698f, -0.10637664f, -0.04291337f, 0.27538311f, -0.17361967f, -0.04051852f, 0.41540292f, 
    0.24756789f, 0.45245451f, -0.21461344f, -0.12055312f, -0.13326094f, -0.07537720f, -0.09693491f, -0.13943315f, 
    0.05839712f, 0.38723600f, -0.18289705f, -0.28523815f, 0.10776751f, -0.26314512f, 0.18328153f, -0.00307116f, 
    0.29488307f, 0.05523831f, -0.28510374f, -0.58971262f, -0.83318859f, -0.57804215f, -0.06722362f, -0.54385465f, 
    0.41490406f, -0.40553322f, -0.16405617f, 0.32813698f, -0.06150226f, 0.06468081f, -0.00074813f, -0.12410661f, 
    -0.11250070f, -0.25430858f, -0.19327043f, -0.01810521f, -0.22911616f, -0.06894738f, -0.02880493f, 0.58203673f, 
    0.63668644f, 0.30361569f, -0.14667878f, -0.06860406f, -0.04509644f, 0.17412531f, -0.29223993f, -0.55440164f, 
    -0.35170662f, 0.16892102f, 0.00648412f, 0.03135262f, -0.26931176f, -0.17832752f, 0.10126314f, 0.05305559f, 
    -0.13998652f, 0.08667342f, -0.10413833f, 0.16377330f, -0.04219344f, -0.22422868f, -0.18372484f, -0.02923975f, 
    -1.06977069f, -0.44245452f, 0.32751241f, -0.14530748f, -0.29271466f, 0.05230863f, 0.46410415f, 0.20448790f, 
    0.28613651f, 0.25789103f, 0.05940978f, -0.08749881f, 0.18438891f, -0.15832143f, -0.05372018f, 0.10630526f, 
    0.10666730f, -0.43261424f, -0.14382491f, 0.16715266f, -0.12335142f, -0.03081160f, 0.11438847f, 0.04079784f, 
    -0.13608877f, -0.40136114f, -0.75954103f, -0.57830286f, -0.18351772f, 0.70593542f, -0.15288140f, -0.13715583f, 
    0.50528938f, -0.26043510f, -0.32650942f, -0.06727254f, -0.00523982f, 0.28574750f, -0.07338168f, -0.07717156f, 
    0.14391018f, 0.05392037f, 0.11683790f, -0.15133572f, 0.26596615f, 0.10447583f, -0.40679029f, -0.25788167f, 
    0.17833479f, -0.19178337f, -0.14975747f, -0.08882395f, -0.04770358f, 0.07306951f, 0.25145292f, -0.43118209f, 
    -0.09056538f, 0.24441350f, 0.09971377f, 0.09493554f, -0.10740826f, 0.39576203f, -0.31934631f, -0.10246085f, 
    -0.15666966f, 0.35287455f, 0.07579882f, 0.14193524f, -0.51210409f, 0.11967884f, -0.33021498f, 0.08668596f, 
    0.07451406f, 0.05364029f, 0.22008473f, 0.30488461f, -0.47807202f, -0.23961955f, -0.31763297f, -0.31465319f, 
    0.27760544f, -0.00803541f, 0.03577233f, 0.28068265f, 0.37944981f, 0.09701940f, 0.01281655f, 0.06717130f, 
    -0.09320047f, 0.09848428f, -0.21145073f, -0.17967489f, -0.06261448f, 0.07344706f, 0.20979644f, 0.10768930f, 
    -0.12307299f, 0.19133584f, -0.29176572f, 0.14704914f, 0.27821466f, 0.01819957f, 0.05031741f, -0.69896841f, 
    -0.55078465f, 0.39873880f, -0.02025012f, 0.38955817f, -0.43642661f, -0.28220999f, 0.13371524f, 0.25455996f, 
    -0.35110623f, 0.00841295f, 0.21078430f, 0.11195491f, -0.26852316f, 0.19638012f, -0.33200446f, -0.47740805f, 
    0.13362791f, -0.12264327f, 0.23702639f, 0.09653471f, 0.07530043f, -0.28261611f, -0.30255911f, -0.03123219f, 
    0.24435288f, -0.37534067f, -0.27073190f, -0.18448360f, 0.06990395f, -0.08851369f, -0.31887496f, 0.06204289f, 
    -0.12649670f, -0.06316257f, 0.27766335f, -0.26775730f, 0.00153575f, -0.03766855f, 0.12676044f, -0.20387748f, 
    0.07977282f, 0.31977198f, 0.05608657f, -0.09579154f, -0.05037418f, 0.25356564f, 0.28348544f, -0.11099362f, 
    -0.44351369f, -0.41443729f, -0.17624369f, -0.10189247f, -0.51010120f, -0.43231720f, -0.70548439f, -0.66342205f, 
    0.14610629f, 0.59868300f, -0.20662162f, 0.03529723f, 0.40377635f, -0.07330168f, -0.08525437f, 0.06898458f, 
    -0.00868123f, -0.06925754f, -0.05519901f, -0.30321607f, 0.14363146f, 0.36239773f, 0.02521521f, -0.84444416f, 
    0.66356462f, -0.11052684f, -0.88942909f, -0.60228091f, -0.06917807f, 0.35995856f, 0.48489296f, 0.55534160f, 
    -0.07057099f, -0.08663474f, -0.26252529f, -0.22595736f, -0.71030432f, 0.12555532f, -0.03066554f, 0.25591204f, 
    0.02503376f, 0.01516205f, 0.09780923f, -0.18009065f, 0.16357405f, 0.06717207f, -0.05113196f, 0.26229781f, 
    0.55901444f, -0.66729420f, -0.09014975f, 0.35161924f, -0.61191893f, 0.06781223f, 0.41439983f, -0.12360056f, 
    -0.33415651f, -0.24167280f, 0.42424491f, -0.37282750f, -0.32020029f, -0.25917345f, 0.28204605f, -0.31758752f, 
    -0.31659016f, -0.19344862f, 0.27955928f, -0.18432416f, -0.44025436f, 0.02185685f, -0.03910523f, -0.06884964f, 
    -0.52676064f, -1.03819788f, -0.65260506f, -0.47543016f, 0.38589641f, 0.12814891f, -0.27572018f, 0.03407722f, 
    -0.29012033f, 0.30026820f, 0.65917683f, 0.19619402f, 0.06997330f, 0.36105505f, 0.15398796f, 0.22513752f, 
    -0.06378906f, 0.15296057f, -0.06766499f, -0.05464544f, -0.16645132f, -0.18450035f, 0.11147504f, 0.00217397f, 
    0.24684073f, -0.18609414f, 0.53587872f, -0.07905494f, 0.04064753f, -0.42626393f, 0.09363900f, 0.34798473f, 
    -0.23725757f, 0.18047383f, 0.22893891f, -0.13025527f, -0.36978528f, 0.00852445f, 0.07277640f, -0.00037216f, 
    -0.02249952f, -0.15328138f, -0.35571566f, 0.11399946f, 0.04507589f, 0.08054329f, 0.27182263f, -0.21717671f, 
    -0.41624317f, 0.28101093f, 0.01038241f, -0.61227220f, 0.38721192f, 0.97762775f, -0.69415671f, -0.54679960f, 
    -0.34571207f, -0.36611819f, 0.13429688f, 0.32812589f, 0.39747372f, -0.39402539f, -0.40572137f, 0.17885251f, 
    0.11626041f, 0.11644189f, 0.11207325f, 0.04595505f, 0.04090078f, 0.10734897f, -0.02274260f, -0.08631027f, 
    -0.31106392f, -0.42704031f, -0.48292795f, -0.56673926f, -0.04570852f, 0.35909542f, -0.12395249f, -0.04464798f, 
    0.11538818f, -0.55295855f, -0.07626813f, 0.59301615f, 0.26489931f, 0.10763651f, -0.22994991f, -0.06068192f, 
    -0.10758955f, 0.26336932f, -0.21045122f, -0.09166275f, 0.22780566f, -0.10060263f, 0.16919516f, -0.33941036f, 
    -0.33637705f, 0.06059727f, 0.33173504f, -0.09270094f, -0.16583237f, 0.28187126f, 0.12587322f, 0.18511836f, 
    0.19341093f, -0.10653207f, -0.30901471f, -0.27478305f, 0.12635261f, -0.14321975f, 0.13608833f, 0.00183806f, 
    0.30346760f, 0.17210622f, -0.20621502f, -0.20651187f, -0.03988719f, 0.03772148f, -0.09841090f, -0.04791879f, 
    0.13577764f, 0.21780652f, -0.32900324f, -0.22191486f, 0.17184202f, -0.30628580f, 0.18296957f, 0.14615116f, 
    -0.02976672f, -0.12308615f, 0.17354208f, 0.36978957f, -0.49180213f, -0.16640863f, 0.00898776f, 0.03117008f, 
    -0.00161061f, -0.21705873f, -0.00508078f, 0.28837553f, -0.23860057f, 0.34443229f, 0.22939973f, -0.22684866f, 
    0.05975840f, -0.42077431f, -0.47625655f, 0.08234971f, 0.32835793f, 0.02875309f, -0.10847229f, -0.16798249f, 
    0.02295866f, 0.23613399f, -0.20449299f, 0.13956837f, 0.02878116f, -0.47535738f, -0.14502531f, 0.25997579f, 
    0.35002494f, 0.10743526f, -0.29727602f, -0.12239072f, 0.02906202f, -0.00600508f, -0.09177003f, -0.12724414f, 
    0.07340831f, 0.37483492f, 0.02998374f, -0.10626731f, -0.21858142f, 0.00072640f, -0.08561572f, -0.00944362f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.08043875f, 0.14778061f, 0.19272862f, 0.29578418f, 0.26372263f, 0.14036044f, 0.13271034f, 0.15086156f, 
    -0.12427228f, -0.11510002f, 0.11922388f, -0.38945708f, -0.13863669f, 0.25712660f, 0.12929341f, -0.25785309f, 
    0.02400415f, 0.15379965f, 0.19656937f, -0.11750714f, 0.09188486f, 0.06306843f, 0.12261564f, -0.12616073f, 
    0.10198254f, -0.33895528f, 0.18288317f, -0.31528762f, -0.30089635f, -0.06735880f, 0.13882087f, 0.09046644f, 
    -0.09341566f, 0.18089651f, -0.35293368f, 0.23934004f, -0.16105996f, -0.04802863f, 0.32757974f, 0.00161054f, 
    -0.02691497f, 0.04299170f, 0.24535005f, -0.21305206f, 0.28057975f, 0.17346022f, 0.04060054f, 0.14966290f, 
    0.11523082f, 0.07914940f, 0.27658975f, 0.17162451f, 0.17700167f, -0.08216307f, -0.08767407f, 0.00816101f, 
    -0.06860100f, 0.11081266f, 0.21652441f, 0.04291543f, 0.30442899f, -0.11800206f, 0.14483400f, -0.08858766f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.07838641f, -0.03863702f, -0.17160632f, 0.09206666f, -0.12148552f, -0.07885005f, -0.08298466f, -0.11349785f, 
    -0.23148358f, -0.11159455f, -0.11975131f, -0.04512928f, -0.22813162f, 0.00306053f, 0.26713660f, -0.17921163f, 
    -0.00014641f, -0.01462197f, 0.04682842f, 0.01430333f, -0.07650049f, -0.07760111f, 0.05300432f, -0.19977282f, 
    0.23404154f, 0.11982796f, -0.11586875f, -0.06962448f, 0.04601442f, 0.01154312f, -0.08412931f, -0.17579629f, 
    0.02369111f, -0.00428572f, -0.06377313f, 0.02278367f, 0.04733130f, -0.12356514f, 0.04626177f, -0.01966030f, 
    -0.02234092f, -0.09863490f, 0.19213161f, -0.29544708f, -0.23876314f, -0.13994968f, 0.10581222f, -0.08842728f, 
    -0.03479277f, 0.10611415f, -0.08511842f, -0.17992564f, 0.04495198f, 0.11358277f, 0.10282115f, -0.29815263f, 
    0.07333561f, 0.06166839f, -0.00484751f, -0.03796038f, 0.08805809f, 0.01397567f, 0.04473730f, -0.24650949f, 
    -0.00352567f, 0.17779072f, -0.23389116f, -0.19125475f, 0.00857222f, -0.16272439f, -0.09139846f, -0.10439963f, 
    0.18978447f, 0.09633159f, -0.06836043f, -0.20472717f, 0.08841933f, 0.16243096f, -0.04454273f, -0.05372571f, 
    -0.02879423f, 0.00114151f, -0.05027739f, -0.10927702f, -0.29034889f, -0.12740584f, -0.33061060f, 0.06212368f, 
    0.01344686f, -0.01822842f, -0.12607944f, 0.02434743f, -0.02088745f, 0.00515980f, 0.02284095f, -0.11395421f, 
    0.07177944f, -0.02248241f, -0.06591263f, -0.07347905f, -0.16591564f, 0.06582140f, -0.03945636f, -0.01342899f, 
    0.07379777f, 0.12448983f, 0.10942174f, -0.05502314f, 0.10285264f, 0.15292488f, 0.05046250f, -0.00518987f, 
    0.18666852f, 0.06009734f, -0.03971120f, -0.16016163f, -0.10359678f, -0.07163543f, -0.03307875f, -0.04775071f, 
    0.25420344f, 0.11456783f, -0.02225190f, -0.03473892f, -0.01454565f, 0.06774028f, 0.02143821f, -0.24952728f, 
    -0.11886214f, -0.16231957f, -0.15070248f, -0.03264942f, 0.45467994f, 0.21930432f, -0.15315251f, -0.17642732f, 
    0.10884390f, 0.11509734f, 0.07198318f, 0.08561496f, -0.02040756f, 0.00934009f, 0.02411320f, -0.00232283f, 
    0.10364617f, -0.17400414f, -0.27508572f, 0.04339965f, 0.00062535f, 0.07554148f, -0.08760232f, -0.11786549f, 
    0.00288793f, 0.04117322f, -0.05733541f, -0.01100305f, 0.26741678f, 0.12807617f, -0.33837143f, -0.00187869f, 
    0.11896727f, -0.10187806f, -0.02193774f, 0.02094535f, -0.06420656f, -0.06565183f, -0.00537148f, 0.02156395f, 
    0.15254870f, 0.23574710f, 0.47129560f, -0.51744407f, -0.02953522f, -0.01633258f, 0.07375555f, 0.10494396f, 
    -0.02185818f, -0.08232059f, -0.11825768f, -0.09663503f, 0.15179512f, 0.18062279f, -0.01216387f, 0.08390687f, 
    -0.02033150f, 0.04564581f, 0.02036407f, -0.01896252f, -0.17215502f, 0.01955607f, 0.18889332f, 0.21449094f, 
    0.10790975f, 0.05334415f, 0.06674328f, -0.17701025f, -0.11914059f, -0.01375866f, -0.12614986f, -0.00687482f, 
    0.05761739f, 0.02299554f, -0.00263053f, -0.03095398f, 0.13905855f, -0.01338502f, -0.08111377f, -0.00503184f, 
    0.07797931f, -0.25334722f, -0.02255106f, -0.18629587f, -0.07286562f, -0.01400983f, 0.04612989f, 0.01920558f, 
    -0.43653718f, -0.15940037f, -0.09599329f, -0.01692245f, -0.05571722f, 0.01375301f, 0.03733623f, -0.00306715f, 
    -0.16217422f, 0.07255069f, -0.08535688f, 0.04256250f, 0.02201042f, 0.05019411f, -0.02217826f, 0.07378134f, 
    0.00300719f, 0.05830093f, -0.01342921f, 0.04656395f, -0.11697146f, -0.19279195f, 0.02166360f, 0.00746563f, 
    0.00491752f, 0.13337818f, 0.01969848f, 0.05932700f, 0.03835466f, 0.08402217f, 0.00195457f, -0.04742477f, 
    0.03080873f, 0.09882984f, 0.07312832f, -0.00862300f, -0.08287317f, -0.00269793f, -0.06576177f, 0.00322131f, 
    -0.05812239f, -0.03254173f, -0.18512397f, -0.00055211f, -0.02079725f, 0.02875960f, -0.00708965f, 0.07612392f, 
    0.21801771f, -0.45817950f, -0.31542626f, 0.09699654f, 0.06856333f, -0.09654737f, 0.01368109f, -0.01305247f, 
    0.01885693f, -0.11413369f, 0.10492886f, 0.13058577f, 0.01620557f, -0.00205933f, 0.09488125f, -0.13744710f, 
    0.02768549f, -0.05718857f, 0.06089843f, -0.09191635f, 0.00022866f, 0.13737735f, 0.01071295f, 0.04850909f, 
    0.11804362f, 0.00245004f, -0.30927452f, -0.00409335f, 0.03882818f, -0.00681051f, 0.03111803f, -0.05782076f, 
    -0.06617852f, 0.00862051f, -0.14794521f, -0.08811478f, 0.10062649f, 0.13462174f, -0.00112149f, -0.02206647f, 
    0.05856351f, 0.13512278f, 0.04239872f, 0.01795689f, -0.04645183f, -0.00075073f, 0.00606736f, 0.01125456f, 
    0.50464249f, -0.37672764f, -0.11308151f, -0.58925283f, -0.03203022f, -0.21362045f, 0.13914742f, -0.01040528f, 
    -0.07681359f, -0.01021885f, -0.00586739f, 0.04986450f, 0.30333173f, 0.17792426f, -0.06292475f, -0.04721107f, 
    0.12152636f, 0.17473428f, 0.10039726f, 0.10404188f, -0.09579671f, -0.12386406f, -0.00995419f, -0.10630147f, 
    0.25542793f, 0.02354603f, -0.24990547f, -0.14987120f, 0.01090930f, 0.20235220f, -0.13836145f, 0.11253716f, 
    -0.07005655f, -0.03122449f, -0.01571530f, -0.01534692f, 0.11740315f, 0.16939810f, 0.10884801f, -0.07052799f, 
    -0.00141922f, 0.05691511f, 0.01269471f, -0.03149143f, 0.05236235f, -0.04692685f, -0.06430274f, 0.09319317f, 
    0.05654573f, -0.16296232f, -0.08609801f, -0.06869926f, 0.04488448f, -0.02500452f, 0.09685305f, -0.07255022f, 
    -0.12395441f, 0.00665515f, -0.06500760f, 0.00313358f, -0.69553840f, -0.30097732f, 0.01559272f, -0.02634915f, 
    0.07912180f, -0.00380435f, -0.00251834f, 0.02078121f, -0.04074803f, 0.02860114f, -0.06774416f, -0.11576830f, 
    0.03179787f, 0.01125042f, 0.04128426f, 0.01580209f, -0.01945828f, 0.03708904f, 0.04522496f, 0.00613083f, 
    -0.25474319f, -0.33532155f, -0.05337165f, -0.23958926f, -0.16245000f, 0.08652332f, 0.12932779f, -0.23021811f, 
    0.07062897f, -0.00721581f, 0.06485682f, -0.02616159f, -0.05623140f, -0.03619691f, 0.00377020f, 0.00340865f, 
    0.24218562f, 0.18565349f, 0.07834759f, -0.09985855f, 0.18722659f, 0.18616726f, 0.22819741f, 0.08281964f, 
    -0.04244752f, -0.01788077f, 0.02247238f, -0.06471047f, -0.03673276f, -0.02949705f, -0.08332546f, 0.00414517f, 
    -0.03240909f, 0.00640931f, -0.03508914f, -0.09310377f, -0.02525139f, -0.07365351f, -0.14866404f, -0.06826203f, 
    -0.30673078f, 0.05362497f, 0.03123688f, 0.04884685f, 0.00178834f, 0.02141569f, -0.01043454f, 0.05041041f, 
    -0.06474183f, -0.11042257f, 0.02208842f, 0.12205639f, 0.40532705f, 0.12328850f, 0.20243244f, -0.19584171f, 
    0.00515348f, -0.01488676f, 0.08492992f, 0.05722786f, 0.11714454f, 0.07447399f, -0.13273163f, -0.04122890f, 
    0.20901564f, -0.32607755f, -0.29928103f, -0.13506387f, -0.02276831f, -0.05045578f, 0.05120460f, -0.02071601f, 
    -0.04279102f, -0.05886043f, -0.11550147f, 0.01417652f, -0.04810295f, -0.12930621f, 0.07750018f, 0.01716614f, 
    0.02409247f, -0.07372100f, -0.01224197f, -0.00431547f, -0.04762333f, -0.23719937f, -0.12080412f, -0.01562185f, 
    0.33121896f, 0.09683604f, 0.02015572f, -0.01341915f, 0.12498193f, 0.02588353f, 0.12991926f, -0.16891715f, 
    0.02797509f, 0.12331161f, 0.02087966f, -0.02326423f, -0.18828723f, -0.50884235f, -0.14281259f, 0.11635664f, 
    0.03944051f, 0.04220228f, -0.02379709f, 0.03032001f, 0.09919670f, -0.04395520f, -0.07636005f, -0.03382722f, 
    0.14270306f, 0.10884718f, -0.06567523f, -0.20480080f, -0.17790383f, -0.24803115f, 0.11499153f, -0.08940445f, 
    -0.10243261f, 0.00241207f, -0.07130666f, -0.20617509f, 0.22481763f, 0.10218256f, -0.06208573f, -0.14773917f, 
    0.07097660f, 0.14250119f, -0.07917462f, -0.06238978f, 0.03525701f, -0.01716683f, -0.00120313f, 0.01900173f, 
    -0.19920005f, -0.34610197f, -0.18563311f, -0.02280447f, -0.00097352f, -0.00703044f, -0.06366210f, 0.03997048f, 
    -0.07360438f, 0.02656666f, -0.00468217f, 0.00392520f, 0.10638928f, 0.10341174f, -0.14136384f, -0.00376243f, 
    0.02664523f, -0.03534575f, -0.14963749f, -0.09742167f, -0.04126138f, 0.00229009f, 0.01815059f, -0.02631111f, 
    0.12399107f, 0.18825006f, 0.04283081f, -0.24789397f, 0.06241834f, 0.09377486f, -0.08679448f, 0.07697236f, 
    -0.04435650f, -0.00799436f, 0.01836473f, 0.04360376f, -0.40577689f, -0.38802290f, -0.60879058f, 0.21546136f, 
    0.00963307f, 0.03644394f, -0.02972339f, -0.06748094f, -0.03537550f, 0.01920370f, 0.01354342f, 0.06709737f, 
    -0.06660244f, -0.04464119f, 0.12058254f, -0.08729947f, 0.03895105f, 0.00987258f, 0.05089232f, 0.05849135f, 
    -0.22220074f, 0.01372438f, -0.10230091f, -0.02726128f, 0.30999249f, 0.02684967f, -0.16173986f, -0.03645715f, 
    0.17045902f, 0.02957430f, 0.09697660f, -0.03142561f, -0.11752266f, -0.04413995f, 0.09435189f, 0.00532608f, 
    -0.09658011f, 0.08218130f, -0.00433346f, -0.21880628f, -0.20842919f, -0.04345880f, 0.04363114f, -0.01737302f, 
    -0.11392645f, -0.08313361f, -0.09771806f, 0.00174893f, -0.02092075f, 0.02335411f, -0.01829604f, 0.06413271f, 
    -0.00578291f, -0.04179947f, -0.00113319f, 0.07002753f, -0.00051008f, -0.02471053f, -0.03101381f, 0.00950230f, 
    0.12301130f, -0.21888013f, -0.21689430f, 0.00565216f, -0.02205431f, 0.05709142f, -0.20278314f, -0.39887598f, 
    -0.09095720f, -0.04554968f, -0.10931926f, -0.01335737f, 0.17901661f, 0.07192239f, 0.00866853f, -0.26777348f, 
    0.08006082f, 0.01843374f, 0.11452276f, 0.07358896f, -0.05211661f, -0.02749894f, 0.01097330f, -0.03509609f, 
    0.36612681f, 0.11414237f, -0.38153836f, -0.05819038f, 0.02727441f, -0.14613856f, -0.19302672f, 0.02023931f, 
    -0.03379757f, 0.04853176f, 0.00604549f, -0.06541885f, -0.05147059f, 0.05800227f, 0.16800715f, -0.18381019f, 
    -0.05364984f, 0.16853902f, -0.09281217f, 0.00401479f, 0.04811513f, 0.01354190f, 0.09565621f, -0.00549802f, 
    0.24327527f, -0.13551380f, -0.17045856f, -0.04631504f, -0.02772533f, -0.18014207f, -0.06778024f, -0.07162317f, 
    -0.07025890f, 0.11698880f, 0.00425010f, 0.14229664f, 0.23744933f, 0.33063653f, 0.15949023f, -0.08170375f, 
    0.08200263f, 0.03623702f, 0.05539277f, -0.07056969f, 0.03832188f, -0.10029394f, -0.09477460f, 0.00200291f, 
    -0.22238280f, -0.21015656f, -0.37572294f, 0.15464211f, 0.02300131f, 0.04913497f, -0.09140876f, -0.02047370f, 
    0.00302504f, 0.02271859f, -0.02422374f, -0.07366613f, -0.28975737f, 0.07413501f, 0.20254780f, 0.05620654f, 
    0.02767642f, 0.00414032f, -0.03513092f, 0.00098243f, 0.24609520f, -0.11348283f, -0.04737511f, 0.03047315f, 
    -0.62376589f, 0.05405935f, -0.01671680f, -0.07781085f, 0.00963758f, -0.01479438f, 0.02251931f, 0.05132888f, 
    -0.06189001f, -0.02833073f, -0.05983925f, -0.07244101f, -0.06946328f, -0.03884677f, 0.04405457f, 0.05621393f, 
    0.05131881f, -0.00707189f, -0.03801014f, -0.01490977f, -0.02606776f, 0.01936558f, 0.07662272f, 0.03527822f, 
    -0.08452212f, 0.02352794f, -0.13234885f, -0.03715524f, -0.15083870f, -0.10119690f, 0.04149026f, 0.03520796f, 
    -0.12194416f, -0.17259006f, -0.04503391f, 0.04054879f, -0.18433864f, 0.28232160f, 0.02931808f, -0.16866842f, 
    -0.02950626f, 0.04426175f, -0.03021277f, 0.05958306f, 0.12861302f, -0.02967191f, -0.05903194f, -0.04073667f, 
    0.07050976f, -0.11797403f, 0.09801517f, -0.17129646f, 0.03994831f, 0.08295602f, 0.04948671f, 0.16233221f, 
    0.04052249f, -0.02889039f, 0.06075849f, -0.02951626f, -0.12375543f, 0.22781233f, -0.18016177f, 0.04257732f, 
    -0.01409532f, 0.01432372f, -0.00278542f, -0.00706430f, -0.04066555f, 0.16647145f, -0.11273592f, 0.19351754f, 
    -0.05128806f, -0.09648735f, -0.11236166f, -0.01248451f, 0.03653280f, 0.09272669f, 0.08732362f, 0.05381975f, 
    -0.04119758f, -0.10740374f, 0.16563338f, -0.02629517f, 0.35326466f, -0.22039737f, 0.16459817f, -0.20310864f, 
    -0.01196601f, 0.09001631f, -0.25939983f, 0.20753017f, -0.06233298f, 0.13220681f, 0.06350528f, -0.09411284f, 
    0.27542877f, -0.00786099f, -0.37342256f, -0.58784068f, -0.09091643f, 0.04194935f, -0.07700770f, 0.15239961f, 
    0.08043725f, 0.11524901f, 0.06830383f, -0.00681733f, -0.43936798f, -0.10119701f, -0.26703203f, -0.13234326f, 
    -0.06868979f, 0.08160654f, 0.10473721f, 0.03966384f, 0.02394999f, 0.06791068f, -0.13686036f, 0.00140420f, 
    -0.20638615f, -0.03716860f, -0.24023061f, -0.00028362f, -0.02414155f, 0.05857327f, -0.08782652f, 0.10772339f, 
    -0.02923453f, 0.00046210f, -0.12973613f, 0.12467958f, 0.65744776f, -0.05719446f, -0.08399079f, 0.05917840f, 
    0.06039876f, -0.04963804f, -0.06621926f, 0.06756289f, -0.00347650f, 0.03412564f, -0.04916001f, 0.08159415f, 
    0.03971792f, -0.05559098f, 0.02202386f, 0.00802459f, 0.05337321f, 0.02103960f, -0.06155789f, 0.15174824f, 
    -0.05734072f, -0.01522477f, 0.03921188f, 0.11875316f, -0.17318137f, -0.09151497f, 0.10450429f, 0.07748560f, 
    -0.06218388f, -0.00463608f, 0.13257058f, -0.11468898f, -0.11133541f, -0.06724948f, 0.04059440f, -0.01143720f, 
    0.23331034f, -0.17219616f, -0.02293613f, -0.07927954f, 0.04225989f, 0.07289277f, 0.02669874f, 0.11358567f, 
    0.03846115f, -0.01509571f, 0.13128307f, -0.14145029f, 0.38109213f, 0.20672682f, 0.05109258f, 0.08235814f, 
    -0.09680551f, 0.02465674f, 0.13476573f, 0.05605274f, -0.00799741f, -0.06319250f, -0.00204368f, -0.03723592f, 
    0.52000993f, 0.05308528f, -0.13094500f, 0.03162957f, -0.01756259f, 0.04319163f, -0.15295391f, -0.06620166f, 
    -0.19148900f, -0.26318312f, -0.33056810f, -0.11374284f, 0.15617165f, -0.20935436f, -0.43458480f, 0.10906252f, 
    -0.03928946f, 0.18043236f, 0.09720699f, -0.25582141f, 0.16691306f, 0.02669213f, -0.01602351f, -0.00427602f, 
    -0.64698750f, -0.00202213f, -0.05124392f, -0.05842236f, -0.11899748f, 0.03409583f, -0.00188733f, 0.05661250f, 
    0.02183584f, -0.01293448f, 0.07149904f, -0.03091895f, -0.05309341f, -0.50119525f, 0.07296941f, 0.10469072f, 
    -0.01002018f, 0.06356949f, -0.05966736f, 0.01038852f, -0.24959932f, -0.21723956f, -0.34027413f, -0.21217610f, 
    -0.11835013f, 0.01794862f, -0.04107869f, 0.00456632f, 0.03215453f, 0.01054790f, -0.02925972f, 0.17285588f, 
    -0.04629360f, 0.03163574f, 0.03900370f, 0.11023256f, 0.07854108f, -0.05841427f, 0.00414748f, 0.03107285f, 
    0.01161161f, -0.14007783f, 0.19070545f, -0.05685248f, 0.02241499f, 0.14541015f, -0.01232648f, 0.00048198f, 
    -0.24982814f, -0.17923602f, 0.23199360f, 0.06862421f, -0.02846721f, -0.02484900f, 0.04581959f, 0.01845659f, 
    0.06813247f, 0.02637757f, 0.07710804f, -0.00409507f, 0.11305590f, 0.04422359f, 0.06924640f, 0.08552229f, 
    -0.03494439f, 0.02957886f, -0.01370123f, -0.06545883f, 0.00842287f, 0.15478416f, 0.01310066f, -0.01634760f, 
    -0.03361499f, -0.12711780f, 0.01866418f, -0.07520803f, 0.03577744f, -0.07944814f, -0.36291412f, -0.33130327f, 
    0.03899166f, -0.12240592f, -0.11690726f, 0.04495402f, 0.31563663f, -0.26570490f, 0.04288964f, -0.42523980f, 
    0.06168510f, -0.15056914f, -0.05518945f, -0.15881658f, -0.03343656f, -0.00125062f, -0.03826173f, 0.03857446f, 
    0.13358584f, -0.26711035f, 0.38710943f, 0.25121036f, 0.01331304f, -0.10802089f, 0.05618899f, 0.06115819f, 
    -0.07252686f, 0.09082952f, 0.14881267f, 0.01626114f, 0.02533307f, 0.05986867f, -0.05835576f, 0.12709068f, 
    0.01459096f, 0.01468663f, -0.14361979f, 0.05351963f, 0.08883619f, -0.18180539f, -0.15124397f, 0.01227463f, 
    0.12156013f, -0.01896821f, -0.10626072f, 0.17399673f, -0.13759945f, 0.00144156f, 0.01849319f, 0.03264946f, 
    -0.00166720f, -0.10258801f, -0.04391707f, 0.24949449f, 0.27442342f, 0.49828807f, 0.00959043f, -0.10949467f, 
    -0.06493959f, 0.14366262f, 0.10064040f, -0.14326878f, 0.06606962f, -0.01769437f, -0.13790695f, -0.09653644f, 
    -0.05606911f, -0.34634879f, 0.11404743f, -0.39072913f, 0.02252848f, 0.10523610f, 0.07839426f, -0.10499304f, 
    0.17685604f, 0.07928029f, -0.00395328f, -0.04233870f, 0.16836323f, -0.01549174f, 0.26237392f, 0.13217284f, 
    0.04497300f, 0.04633591f, 0.04848465f, 0.02152385f, -0.01202856f, -0.01354581f, -0.05973604f, -0.02404265f, 
    0.02561986f, 0.29345509f, 0.13973816f, 0.05358696f, -0.05211590f, -0.01994308f, 0.04927199f, 0.21047792f, 
    -0.02360230f, 0.04912011f, -0.05118832f, 0.00423232f, -0.16647613f, -0.04093711f, -0.09066877f, -0.00389974f, 
    -0.14549538f, 0.13016567f, 0.08785256f, 0.17952582f, -0.02586346f, -0.04503667f, -0.07935241f, 0.00342994f, 
    -0.00366732f, -0.00577058f, -0.15647295f, 0.00455375f, -0.05540538f, 0.00770927f, -0.06005827f, -0.15577647f, 
    -0.01257825f, 0.08566026f, -0.08383216f, -0.04116805f, 0.33290336f, 0.25730988f, 0.09937761f, 0.10790224f, 
    0.00648247f, -0.00286303f, -0.00024385f, -0.05334204f, -0.03169072f, -0.03340548f, -0.00713985f, 0.01505753f, 
    0.10921723f, 0.06964418f, 0.12370159f, 0.06164899f, -0.00013048f, 0.00229306f, -0.04371854f, -0.07280270f, 
    0.06252634f, 0.09844341f, 0.02307397f, 0.07988223f, -0.40408760f, 0.21684633f, -0.19114777f, 0.04552712f, 
    -0.06036050f, 0.00418652f, -0.01689624f, 0.09229374f, 0.00191960f, -0.06808708f, 0.03253604f, 0.00094338f, 
    0.08606086f, 0.27501673f, 0.13376719f, 0.00957431f, 0.05456662f, 0.14471683f, -0.15470740f, -0.17126271f, 
    0.03764503f, 0.01868985f, 0.00255355f, -0.13904515f, 0.16200767f, 0.08427521f, 0.10554199f, -0.09376488f, 
    -0.05122875f, 0.14817768f, -0.02537079f, -0.00452598f, 0.10242828f, -0.09025079f, -0.04400599f, -0.17421004f, 
    -0.04241497f, 0.03786290f, 0.10211705f, -0.02315139f, 0.04366004f, -0.01549824f, -0.09069355f, 0.05035673f, 
    -0.19199972f, -0.33587772f, -0.33126533f, -0.03418515f, -0.39471787f, 0.07154016f, -0.16402256f, -0.18182531f, 
    -0.04933266f, 0.00629153f, -0.05891263f, 0.01702297f, 0.16357563f, -0.12181737f, -0.09049987f, -0.02365885f, 
    0.11536364f, -0.20318198f, -0.08595435f, -0.32490852f, 0.00097635f, 0.04395444f, 0.14282525f, -0.22845428f, 
    -0.01925331f, -0.14120477f, 0.23805821f, 0.06994162f, -0.03186543f, -0.11838523f, 0.03806328f, -0.03921412f, 
    0.04734831f, 0.00071269f, 0.08822840f, -0.00886680f, 0.06623671f, -0.07574872f, -0.03054076f, -0.14986856f, 
    -0.04718170f, -0.08172911f, -0.06075513f, 0.05993691f, -0.14589269f, 0.11360849f, -0.07964374f, -0.12501742f, 
    0.03824333f, -0.21645111f, 0.07055590f, -0.08696724f, 0.68177974f, -0.19889680f, -0.14077093f, -0.11170104f, 
    0.02290842f, -0.00888493f, 0.03255234f, -0.07097150f, -0.08551532f, -0.13498306f, -0.11965241f, -0.11903942f, 
    -0.13283205f, 0.08173022f, -0.14562142f, 0.03571002f, -0.01229792f, 0.02617249f, 0.13503514f, 0.19619280f, 
    0.22320704f, -0.08636688f, 0.06947978f, 0.02593550f, 0.18933043f, 0.14567068f, 0.04559643f, -0.07191209f, 
    -0.08407784f, 0.06004455f, -0.03155745f, 0.03567351f, -0.11259996f, -0.06424022f, 0.02068453f, 0.02333917f, 
    0.25351846f, 0.10016398f, -0.01917970f, -0.09532122f, -0.00674910f, -0.00241397f, -0.12800911f, 0.04293322f, 
    0.04226457f, 0.05421735f, 0.04716341f, 0.00289626f, 0.02249595f, -0.39556158f, -0.04690908f, -0.04341277f, 
    0.04537917f, 0.10972780f, 0.07235091f, 0.00140610f, 0.17597859f, 0.03859848f, 0.03136425f, 0.12215111f, 
    -0.14267248f, -0.02532874f, -0.30559629f, -0.37959555f, -0.03030129f, -0.18669854f, 0.16606124f, 0.16703551f, 
    -0.01921683f, -0.03447565f, -0.04080229f, -0.05965332f, 0.28648221f, 0.17460018f, 0.28671762f, 0.14839901f, 
    0.00799640f, -0.00994738f, 0.00641071f, -0.00311680f, -0.00078565f, -0.04598463f, 0.02849737f, 0.10065924f, 
    0.16445479f, -0.00861701f, -0.04613137f, -0.07119603f, 0.01100031f, -0.00133323f, 0.07634945f, -0.11186616f, 
    0.00127591f, 0.03742655f, 0.02664495f, 0.01012375f, -0.24287716f, -0.13396485f, 0.03111948f, 0.17947493f, 
    -0.08854613f, -0.02596225f, 0.00426420f, -0.21426983f, 0.05744845f, -0.06501400f, -0.01659421f, -0.01762779f, 
    0.00144561f, -0.08437196f, 0.08038777f, 0.04818858f, 0.07157853f, 0.14378013f, -0.04812964f, -0.06691274f, 
    -0.02488031f, 0.03475790f, -0.07708948f, 0.20389943f, 0.13587184f, 0.06059949f, -0.05179270f, -0.07037602f, 
    -0.01769449f, 0.00824288f, -0.00760263f, -0.01219288f, 0.06852196f, 0.08582259f, 0.01858483f, -0.13386331f, 
    0.15577193f, -0.26087523f, 0.00679957f, -0.20141572f, -0.15168436f, 0.12828983f, 0.05944660f, 0.19307886f, 
    -0.05242991f, 0.09282971f, -0.18598749f, -0.02654003f, -0.20553361f, 0.09455051f, 0.10478812f, -0.09609099f, 
    -0.10531448f, -0.04851241f, -0.00913630f, -0.07716420f, -0.05699805f, -0.04536695f, 0.03341599f, -0.04138825f, 
    0.04482117f, -0.14066383f, -0.03454164f, 0.11043663f, -0.17858511f, -0.02998583f, 0.08158410f, 0.00020301f, 
    -0.01140799f, 0.05595554f, -0.03602837f, 0.02287467f, -0.20918982f, 0.24583870f, 0.04345933f, -0.17394435f, 
    0.00780734f, 0.04724967f, -0.07930959f, -0.40182003f, -0.01960141f, 0.02668474f, -0.15616022f, -0.04723984f, 
    0.09181215f, -0.13994087f, 0.04562082f, -0.23060414f, 0.01547360f, -0.00651033f, -0.00956801f, -0.00539736f, 
    -0.09642871f, -0.24384953f, 0.19297603f, -0.24798334f, -0.44873646f, -0.06653575f, -0.15501058f, -0.06148523f, 
    -0.04761399f, 0.02765573f, 0.07560036f, 0.08142170f, -0.13332132f, -0.07597243f, 0.08245381f, -0.07695299f, 
    0.47324151f, 0.25094494f, 0.19675002f, 0.32693607f, -0.03779376f, 0.04198289f, -0.01464731f, -0.04604444f, 
    0.07671200f, -0.00596486f, 0.13230462f, -0.10857717f, -0.15954691f, 0.03760152f, -0.00634195f, -0.14553869f, 
    0.13862401f, 0.10175721f, -0.20588249f, -0.00333591f, -0.23955564f, 0.03933975f, 0.02160621f, -0.28562650f, 
    -0.06737368f, 0.13596024f, 0.33648780f, 0.08809566f, 0.05911806f, -0.09363752f, 0.02003462f, -0.00866310f, 
    0.09761777f, 0.03374144f, 0.01037865f, 0.10107669f, 0.05461372f, 0.06814606f, 0.14099906f, 0.10042760f, 
    0.05748788f, -0.03124694f, -0.02841329f, -0.06031368f, 0.10451550f, -0.09470040f, 0.05286223f, 0.09786601f, 
    0.00185860f, 0.09763413f, -0.03668328f, 0.12467374f, 0.15409268f, -0.07360130f, 0.08111119f, 0.15752678f, 
    -0.07576303f, 0.30621478f, 0.09138629f, -0.00366317f, -0.15851980f, 0.23004539f, 0.00128526f, -0.10220697f, 
    -0.00221844f, 0.08973257f, -0.03557047f, 0.03155696f, 0.02317618f, -0.02934965f, 0.03195100f, -0.05012146f, 
    -0.29994902f, 0.18287261f, -0.08105657f, -0.01258795f, 0.01737094f, 0.00104617f, -0.11005051f, 0.00012668f, 
    0.04028083f, -0.05422709f, -0.05166457f, 0.15828034f, 0.08660144f, -0.10086104f, -0.34303337f, 0.22777729f, 
    0.07153893f, 0.06269685f, 0.02613147f, 0.03952283f, 0.02400548f, -0.05808042f, 0.01065125f, -0.08328851f, 
    0.09901791f, -0.09341545f, 0.16202837f, -0.05337546f, -0.08260967f, -0.06252715f, -0.04425712f, 0.06777766f, 
    -0.09059162f, -0.01099441f, 0.12456890f, -0.06217464f, 0.12926073f, -0.21387976f, 0.12458619f, -0.00706924f, 
    0.14953546f, -0.16610168f, -0.33988172f, 0.23447184f, 0.02894507f, 0.04306936f, -0.09924120f, 0.06357842f, 
    -0.17981911f, 0.45873427f, 0.03575743f, 0.04340402f, 0.05631393f, 0.09879228f, -0.19231221f, -0.08263412f, 
    -0.23011847f, -0.23696277f, 0.07098533f, -0.03902685f, -0.10098504f, 0.11240166f, -0.19302309f, -0.14536054f, 
    -0.03794494f, 0.01301181f, 0.03669556f, -0.01813232f, -0.00434048f, -0.00736653f, -0.13632801f, 0.10612702f, 
    -0.21268715f, -0.17899360f, -0.26161814f, -0.19379960f, 0.04323818f, 0.18001580f, -0.05783866f, -0.07127150f, 
    0.06666818f, -0.01835593f, -0.13226771f, 0.03347342f, 0.06356181f, -0.32842043f, 0.03947629f, -0.30612227f, 
    -0.02701393f, -0.04284378f, -0.00053572f, -0.05613589f, 0.03302293f, 0.00183933f, 0.00713983f, 0.00149757f, 
    -0.19398138f, -0.07936928f, 0.11940031f, -0.00827929f, -0.10417970f, -0.34458458f, -0.37045953f, 0.04604500f, 
    0.08381705f, -0.02062308f, -0.09253407f, 0.01539645f, -0.04565017f, -0.09098882f, -0.07317871f, 0.00073816f, 
    -0.08587334f, -0.06706191f, -0.01097675f, -0.13794984f, -0.05389365f, -0.11091999f, -0.02936726f, -0.09168138f, 
    -0.01590632f, -0.14677925f, 0.57074261f, 0.40975803f, 0.06414358f, 0.00584430f, -0.08057333f, 0.13245553f, 
    -0.01966926f, -0.14173122f, 0.01624767f, -0.11982390f, -0.49718773f, -0.27209821f, 0.01735578f, 0.01774523f, 
    0.09923550f, -0.02813220f, 0.06376863f, 0.20614652f, 0.00326160f, -0.01055074f, 0.00274468f, -0.04561223f, 
    -0.32337743f, 0.27532655f, 0.20745733f, 0.06528138f, -0.09687977f, -0.07928763f, 0.04745608f, 0.00678005f, 
    0.07165178f, -0.03258944f, -0.00646050f, 0.10328098f, -0.14893338f, 0.28913319f, 0.13042407f, 0.07986362f, 
    -0.06575688f, -0.04584514f, -0.04372011f, 0.11344454f, 0.00672094f, 0.11434998f, 0.02907138f, -0.00987709f, 
    0.14265230f, 0.00790974f, -0.21099468f, 0.01515718f, 0.15309078f, 0.12266681f, -0.06079650f, 0.08474346f, 
    -0.06212743f, -0.00884907f, 0.01649043f, -0.00864331f, 0.04196357f, -0.30471280f, -0.03949725f, 0.01825987f, 
    0.02183186f, -0.03555875f, 0.04468482f, -0.00060643f, 0.04354862f, 0.08373582f, -0.08000634f, -0.02866379f, 
    -0.18606865f, 0.01825024f, 0.05788787f, 0.01375619f, 0.03086253f, -0.07085545f, -0.04452343f, -0.05812162f, 
    0.04350492f, 0.05607579f, 0.03235561f, 0.01730585f, -0.19257928f, -0.09334135f, 0.07436661f, 0.00649886f, 
    0.03127038f, -0.08525717f, 0.05167815f, -0.18659085f, -0.04471188f, -0.10215112f, 0.02128052f, -0.04081747f, 
    0.05290118f, 0.05481154f, -0.08151232f, 0.06215924f, -0.01186477f, 0.00083632f, 0.11322180f, -0.02852063f, 
    -0.07507367f, -0.03813278f, 0.01040363f, -0.15032074f, -0.13829841f, -0.03259144f, -0.07296147f, -0.05912099f, 
    -0.03882666f, -0.12655668f, 0.01434281f, 0.05145750f, -0.13184471f, -0.06437325f, 0.08445736f, -0.05104956f, 
    0.07054766f, -0.02975274f, 0.03750313f, 0.04370242f, 0.16687082f, 0.10874727f, -0.02805649f, 0.06127166f, 
    0.06149772f, 0.04703192f, 0.02999880f, 0.11571961f, -0.45455679f, -0.31001022f, 0.35375345f, -0.50381899f, 
    -0.05964296f, -0.08977182f, -0.07959805f, -0.17959915f, 0.04784530f, -0.03094935f, -0.00358245f, 0.00344084f, 
    -0.01883327f, 0.07103349f, -0.16074923f, -0.36108619f, 0.03750667f, -0.14398713f, 0.04696332f, -0.02703418f, 
    -0.08562919f, 0.01903280f, 0.04004287f, -0.28880543f, -0.07635414f, -0.03787116f, -0.19593196f, -0.07254634f, 
    0.09529991f, -0.00467373f, -0.09115306f, 0.07109526f, 0.07633984f, -0.01555489f, -0.11774313f, 0.04676513f, 
    -0.04214090f, -0.12298410f, 0.17426038f, 0.00085213f, -0.04342956f, -0.00799007f, -0.03988238f, -0.02577101f, 
    0.01018574f, -0.06406361f, -0.18459952f, 0.04532870f, -0.22683172f, 0.52199626f, 0.26835430f, 0.19143431f, 
    -0.08318101f, -0.05884009f, 0.01882857f, -0.10964239f, -0.02141170f, 0.02952615f, -0.02374906f, -0.04161950f, 
    0.07969487f, 0.32020995f, -0.26851144f, 0.05436901f, -0.07595979f, -0.17950563f, 0.01515141f, 0.13351929f, 
    -0.04538281f, 0.09930797f, -0.05143363f, -0.00229155f, -0.63088286f, -0.35489637f, 0.00330870f, -0.44106179f, 
    0.01213970f, -0.00826437f, 0.00014807f, -0.01636602f, -0.03631331f, -0.01063887f, 0.06439421f, -0.04069133f, 
    -0.80867189f, 0.01749406f, 0.01386570f, -0.14674821f, -0.05431370f, 0.06266052f, -0.03389233f, -0.07047118f, 
    0.01484615f, -0.04688386f, -0.12129899f, 0.01205670f, -0.01640877f, -0.04478456f, -0.01894593f, 0.04491131f, 
    -0.00154886f, -0.10785659f, -0.08800888f, -0.12191053f, -0.10030090f, 0.12185824f, -0.05603955f, 0.01525532f, 
    -0.13435397f, 0.03625239f, 0.04086329f, 0.00670239f, 0.08324702f, -0.02902361f, -0.03982399f, 0.02013000f, 
    0.06877269f, 0.03267227f, 0.06962129f, 0.05500629f, -0.14889409f, -0.15165244f, -0.13629417f, 0.08097504f, 
    -0.03710332f, 0.05909889f, -0.02240180f, 0.03660240f, -0.06543569f, -0.07203824f, 0.06734911f, -0.02321909f, 
    -0.08715338f, -0.07459363f, -0.07630000f, 0.05415586f, -0.05305947f, 0.00172618f, 0.03938588f, 0.08264180f, 
    -0.20800915f, 0.01895856f, 0.03672351f, -0.17601973f, 0.05590338f, 0.17424856f, -0.02389614f, 0.07401909f, 
    0.04920809f, 0.00127885f, -0.09936389f, 0.04596493f, 0.00841081f, -0.00840920f, -0.00771522f, -0.00694744f, 
    -0.33516186f, 0.18595909f, 0.16639335f, 0.28752440f, -0.14583886f, 0.02228584f, -0.00680793f, -0.01978584f, 
    -0.02605175f, -0.05227454f, 0.01241864f, 0.04713467f, 0.04111566f, -0.04985037f, 0.00287786f, 0.01969126f, 
    -0.03865976f, 0.04006429f, -0.13690937f, 0.14818574f, 0.06830181f, 0.00085782f, 0.10303780f, -0.11324881f, 
    0.04761282f, 0.01033022f, 0.02292504f, 0.04706273f, -0.00526819f, -0.03226464f, -0.03506403f, -0.03649721f, 
    0.17555639f, 0.12655886f, 0.02927428f, 0.21722066f, -0.23025440f, 0.01377537f, 0.19579799f, 0.18273336f, 
    -0.04060887f, 0.05845181f, -0.11267305f, 0.06730019f, 0.02446760f, -0.02702065f, 0.09623965f, -0.08489060f, 
    0.41051021f, 0.04883875f, 0.32881656f, -0.08392464f, 0.02059036f, -0.15372272f, 0.01608949f, 0.07577716f, 
    0.07556784f, 0.05470717f, 0.14522101f, -0.16139987f, 0.14950858f, -0.08862131f, 0.09815172f, -0.00040743f, 
    0.07009301f, 0.06257688f, -0.06937598f, -0.00351934f, -0.06110441f, -0.14795247f, -0.07104723f, 0.09569956f, 
    0.04828577f, -0.09689415f, 0.25241682f, 0.14366640f, -0.02117784f, 0.06718426f, -0.00226296f, 0.07459487f, 
    0.10761210f, 0.07735097f, 0.12368821f, -0.24514209f, -0.24756101f, 0.24999478f, 0.15693818f, -0.03221482f, 
    -0.00389990f, 0.01740718f, 0.03201947f, -0.05614468f, 0.06931778f, 0.01981492f, 0.07234669f, 0.09033591f, 
    0.01023688f, 0.15218502f, -0.26058349f, 0.09033835f, 0.12440802f, 0.02071890f, -0.06669233f, 0.32847342f, 
    -0.02547899f, 0.02257270f, -0.01460867f, 0.06045396f, 0.23200448f, -0.20503840f, 0.29771826f, 0.41416231f, 
    -0.17087606f, -0.17000145f, 0.04729386f, 0.19133928f, 0.03396853f, 0.02521008f, 0.01199231f, -0.01775865f, 
    -0.22815302f, 0.18190439f, -0.06665633f, -0.33663535f, 0.00592011f, -0.05974262f, -0.06334485f, 0.06894156f, 
    0.00043436f, 0.03307736f, 0.00549547f, 0.01333974f, 0.00456147f, 0.07851256f, 0.09176757f, 0.07378516f, 
    -0.03646036f, -0.04609907f, 0.00925998f, -0.02381077f, 0.09042016f, 0.07441770f, -0.04844265f, 0.07348503f, 
    -0.88171685f, -0.18837810f, 0.16223741f, -0.24879596f, 0.00275715f, -0.08211383f, -0.13634229f, -0.12900424f, 
    0.02092643f, -0.01828597f, 0.00807740f, 0.00825699f, -0.13622962f, -0.11434869f, 0.22832590f, -0.43839172f, 
    0.07619701f, -0.01149988f, -0.06270762f, 0.07895964f, 0.02039001f, -0.05780318f, 0.02205028f, 0.01735774f, 
    0.28129664f, 0.01363396f, 0.05826101f, 0.16341577f, 0.02285465f, 0.04248036f, 0.06413645f, -0.09019046f, 
    -0.00303005f, -0.01072441f, 0.04325499f, 0.14000921f, 0.07379008f, -0.12185763f, 0.03952398f, 0.10236440f, 
    -0.02635031f, -0.19498867f, 0.14973140f, 0.18656030f, 0.08518668f, 0.09574763f, 0.04772568f, -0.07107890f, 
    0.14018278f, -0.00611167f, -0.11112808f, 0.06189374f, 0.01000592f, 0.05545764f, 0.05457027f, 0.01132191f, 
    -0.00167593f, 0.06594049f, -0.09580093f, 0.05982120f, -0.19372785f, 0.24527209f, 0.06897318f, 0.13140400f, 
    -0.01073709f, 0.07889226f, 0.03515081f, -0.04487768f, -0.02271722f, 0.07914099f, 0.01209567f, 0.03601705f, 
    -0.08083269f, 0.02300002f, 0.20393406f, -0.31527874f, 0.00763473f, -0.04528295f, 0.00439351f, -0.09069435f, 
    0.07374812f, -0.02240001f, -0.04315604f, 0.10452257f, -0.15702076f, -0.01844882f, -0.12154764f, -0.20802291f, 
    -0.01811317f, 0.10470817f, 0.04048546f, 0.02499356f, 0.01231321f, -0.01225742f, -0.01544302f, -0.03763940f, 
    -0.60551059f, -0.47091371f, -0.07933366f, -0.27066764f, -0.01355587f, -0.02155201f, 0.01670366f, -0.22313027f, 
    -0.02605833f, 0.01392200f, -0.04174298f, -0.03700353f, -0.00918815f, 0.33553001f, 0.20634368f, 0.00485577f, 
    0.06307379f, 0.07463202f, -0.11098137f, -0.11050980f, -0.03806045f, -0.02813768f, -0.02030659f, 0.02388127f, 
    -0.22252479f, 0.14433210f, 0.21997334f, -0.09965392f, 0.01687594f, -0.06649216f, 0.02687433f, -0.10095135f, 
    0.02139370f, 0.08150227f, -0.02272399f, 0.16336045f, 0.21095167f, -0.06402232f, 0.05955096f, 0.23890696f, 
    -0.03014484f, -0.02188883f, 0.05041384f, -0.04538034f, -0.14484124f, -0.09366012f, 0.07472736f, 0.04820139f, 
    -0.18940413f, 0.08819178f, 0.11283299f, -0.02438164f, -0.01037089f, -0.02434843f, 0.04118140f, 0.02130309f, 
    0.00316455f, 0.05104817f, 0.02483329f, -0.15671113f, 0.17912592f, 0.04725593f, -0.06462128f, 0.07757674f, 
    -0.07124084f, -0.00478604f, -0.06037939f, -0.18388373f, -0.07620990f, 0.11145668f, 0.03465268f, -0.03129708f, 
    0.00559543f, -0.20266381f, -0.02696660f, 0.13398597f, 0.01622295f, 0.02320281f, 0.08642364f, -0.05126259f, 
    -0.03687018f, -0.12286784f, -0.03625555f, 0.14777423f, -0.15485780f, 0.05357480f, -0.08270820f, 0.02809390f, 
    -0.00079382f, -0.02845984f, 0.01073199f, 0.06178566f, -0.02690851f, -0.06970141f, -0.04266677f, 0.07695863f, 
    -0.01887700f, -0.15481660f, -0.07011487f, 0.00007504f, 0.04166951f, 0.04519163f, 0.09338726f, -0.01990476f, 
    0.00240757f, -0.13457109f, 0.03853556f, 0.08100260f, -0.06218927f, -0.02536157f, 0.04166396f, -0.04365837f, 
    -0.00315778f, -0.01030649f, 0.00009432f, 0.02547719f, -0.09086452f, 0.04975567f, -0.01165149f, -0.01781994f, 
    -0.28445131f, 0.02167580f, 0.12950799f, 0.29495463f, -0.14810669f, -0.01174568f, -0.05875513f, -0.13752186f, 
    -0.00202405f, -0.10057718f, 0.00588387f, 0.12139651f, 0.24652320f, 0.00730280f, -0.03044939f, -0.28038162f, 
    0.10570630f, 0.13924974f, -0.07923442f, 0.20747286f, 0.00976907f, 0.02146704f, -0.12247597f, -0.22894926f, 
    -0.13438170f, -0.08454236f, -0.22759975f, 0.00998419f, 0.03350161f, 0.04052275f, 0.11560370f, 0.02973985f, 
    -0.03897851f, -0.11244055f, -0.00917871f, -0.04752527f, 0.17970157f, -0.04102098f, 0.03436869f, 0.21581815f, 
    -0.19929063f, 0.11263994f, -0.20543045f, -0.08859449f, -0.03514848f, -0.30182651f, -0.06711669f, -0.11054456f, 
    -0.49940810f, -0.10101876f, 0.09053554f, -0.06629478f, 0.25751433f, -0.12985736f, -0.02870223f, -0.19645736f, 
    -0.15794408f, 0.11485628f, 0.04060319f, -0.05256600f, 0.27704155f, -0.07558431f, 0.03053394f, -0.01438851f, 
    0.01845434f, 0.06498032f, -0.00219560f, -0.03764739f, -0.17657098f, 0.05733416f, 0.01116266f, -0.14378464f, 
    0.05966232f, -0.08444594f, 0.00238433f, 0.00524636f, 0.06542335f, 0.03359370f, 0.01442771f, 0.08246426f, 
    -0.00392993f, -0.04632209f, -0.08675055f, -0.09857427f, -0.03154696f, 0.14086473f, 0.45368600f, -0.18710311f, 
    -0.07084130f, 0.05973297f, -0.25529751f, -0.06879338f, -0.05161729f, -0.33072433f, 0.07499183f, -0.03775580f, 
    0.08839172f, -0.23314869f, 0.38584575f, 0.17364517f, 0.08564194f, -0.05564035f, -0.02719537f, 0.16887914f, 
    0.09773661f, 0.00290825f, 0.07853428f, 0.09153967f, 0.10258675f, -0.07816104f, -0.01565926f, 0.19663285f, 
    0.09664967f, 0.01811691f, 0.05545975f, 0.01994098f, 0.08705089f, 0.00187608f, 0.16703016f, -0.03230564f, 
    -0.02744449f, -0.06520146f, -0.07014670f, 0.04951360f, 0.09349856f, 0.02782373f, 0.00116696f, -0.07733247f, 
    -0.11952125f, 0.01195686f, -0.08026563f, 0.05981696f, -0.06460368f, -0.00382778f, -0.16403165f, 0.04876373f, 
    0.08143362f, -0.04686154f, 0.00207199f, -0.01111110f, -0.00927927f, 0.09619991f, -0.03983602f, 0.11521430f, 
    0.22763535f, -0.05354653f, -0.05164966f, 0.28715274f, 0.13684458f, 0.06652912f, 0.07139549f, 0.06006137f, 
    0.02843212f, 0.02193992f, 0.15507995f, 0.13048559f, -0.25157359f, 0.22683553f, -0.22818200f, 0.14818986f, 
    0.01002632f, -0.16111651f, 0.15177928f, -0.13962476f, 0.01102987f, 0.03228283f, 0.05162492f, -0.09860218f, 
    0.21674922f, 0.23707362f, -0.06182070f, -0.29706934f, -0.04510795f, -0.14441940f, -0.04421518f, -0.13493553f, 
    -0.07970976f, 0.07424354f, -0.08454072f, 0.09545686f, 0.30411428f, 0.10998149f, -0.26288664f, -0.11952679f, 
    0.05068240f, -0.04790508f, 0.04101636f, -0.05032751f, -0.14511445f, 0.01035362f, -0.02825381f, 0.06033440f, 
    0.04737933f, -0.10025494f, 0.09494556f, 0.07466697f, 0.01882776f, -0.06352407f, 0.09489921f, 0.06394161f, 
    0.04285407f, 0.11844983f, -0.16817245f, -0.04393517f, -0.22892252f, -0.16492423f, -0.02979692f, 0.45437354f, 
    -0.05700330f, -0.08947560f, -0.03397316f, -0.37189189f, -0.05217997f, -0.11736521f, -0.02026146f, -0.06131553f, 
    0.59115446f, 0.11941709f, -0.08455728f, -0.11096321f, 0.09211308f, 0.03396862f, -0.03774466f, 0.07392278f, 
    -0.08411859f, 0.03108142f, 0.05963017f, -0.03930693f, -0.20305020f, -0.26622507f, 0.02145972f, -0.09685749f, 
    0.02703127f, -0.11019595f, -0.04919777f, 0.09412028f, -0.09409387f, -0.02866472f, -0.06921984f, -0.22881347f, 
    0.17167756f, -0.10429660f, -0.15263413f, 0.16323669f, -0.04382797f, -0.00912297f, -0.07065382f, -0.07590918f, 
    -0.19701880f, -0.09655908f, -0.12321381f, 0.03623605f, -0.09838749f, -0.16031152f, 0.38154930f, 0.15383781f, 
    -0.16269514f, -0.08571860f, 0.01914951f, 0.15039180f, -0.00028344f, 0.03364642f, -0.05168709f, 0.02884814f, 
    -0.21645121f, 0.32985348f, -0.35262004f, 0.07910937f, 0.16981487f, 0.11735281f, -0.05229294f, -0.01781488f, 
    -0.11843182f, -0.19625668f, 0.04528724f, -0.24719663f, -0.13861510f, 0.28003696f, -0.00271651f, 0.22264203f, 
    -0.18252711f, 0.08284314f, -0.10076411f, 0.03673412f, 0.11918124f, 0.23911826f, 0.07020282f, -0.01621387f, 
    -0.06632835f, 0.44150287f, -0.07564414f, -0.16873695f, 0.23464550f, 0.09351252f, 0.01092511f, 0.07025786f, 
    -0.22894220f, 0.04170532f, 0.07175744f, -0.01289007f, 0.02063313f, -0.13136187f, 0.05278530f, 0.19782697f, 
    0.02854507f, -0.01773656f, -0.00493926f, -0.01851089f, -0.01606835f, 0.04514067f, 0.14349966f, 0.12501448f, 
    -0.52923381f, 0.49134675f, -0.31664693f, 0.26056427f, -0.00044007f, 0.10835503f, -0.14985280f, -0.10327598f, 
    -0.11061352f, -0.10196856f, 0.06260379f, 0.29188767f, -0.13250698f, -0.14479379f, -0.03432927f, 0.13350415f, 
    0.00276747f, 0.07197337f, 0.11031781f, 0.02981449f, -0.02101470f, 0.00234626f, 0.04754166f, 0.03373456f, 
    0.01336690f, -0.14949691f, 0.04782286f, 0.27573773f, 0.01355814f, 0.02215514f, 0.00257348f, 0.00966786f, 
    0.03623315f, -0.00774342f, -0.04739527f, 0.01108837f, 0.20941208f, -0.06454198f, -0.27299008f, -0.12209729f, 
    0.21416394f, 0.14440949f, 0.12501721f, -0.00690773f, -0.06258927f, -0.08805626f, -0.01097267f, 0.06787195f, 
    -0.25911519f, -0.03764169f, 0.02541400f, 0.12079476f, 0.05698347f, 0.10476283f, -0.31459314f, 0.04398618f, 
    -0.01419778f, -0.13116565f, 0.17927621f, -0.06063689f, -0.17508569f, -0.02375148f, 0.21981394f, -0.20158476f, 
    -0.16719826f, -0.01305349f, -0.16963398f, 0.11106607f, -0.04509196f, -0.20847005f, 0.23332004f, -0.15591636f, 
    -0.35316792f, 0.04280507f, -0.13031080f, -0.46575037f, 0.20748821f, 0.04461952f, 0.10532600f, 0.07478250f, 
    -0.09677740f, 0.03695875f, -0.16075416f, -0.21510239f, 0.18004189f, 0.06572984f, -0.03677807f, -0.18060154f, 
    -0.05731429f, -0.15635790f, -0.03342410f, -0.17581764f, -0.07307331f, 0.11715795f, -0.19425510f, 0.05205621f, 
    0.06193925f, -0.13013473f, -0.00041744f, 0.23890774f, 0.05823867f, -0.03527606f, -0.14637440f, 0.02099331f, 
    0.01121340f, 0.05402197f, 0.08097117f, 0.05061458f, -0.10305079f, -0.06121172f, -0.23359181f, -0.00453530f, 
    0.05191040f, -0.21368349f, -0.20572148f, -0.09826283f, -0.12890360f, -0.21982031f, 0.10659659f, -0.25537318f, 
    -0.06627973f, -0.03092652f, 0.09040748f, -0.15385805f, -0.21337351f, -0.01722292f, -0.08882488f, -0.05523199f, 
    0.05247235f, 0.07095855f, -0.03371805f, -0.02694005f, -0.10588522f, 0.20126657f, -0.16656107f, -0.36249778f, 
    0.11677831f, 0.01139049f, -0.01885815f, 0.00256126f, -0.20820147f, 0.04052489f, 0.15188390f, -0.16543430f, 
    -0.52434373f, 0.17821768f, 0.01485606f, 0.19044276f, 0.02456349f, -0.01041486f, -0.09388007f, -0.08768453f, 
    -0.16748427f, 0.06569529f, -0.06611305f, -0.10375556f, 0.13902704f, 0.11263486f, 0.06183412f, 0.21143821f, 
    -0.02025140f, 0.03103976f, -0.12859172f, -0.14437740f, 0.05913989f, 0.11517347f, 0.15460674f, 0.11950601f, 
    0.01674555f, 0.53230238f, -0.12901236f, -0.21063626f, 0.24144904f, 0.02899625f, -0.02693508f, 0.02306117f, 
    -0.12011184f, -0.04218212f, 0.01947175f, -0.14355752f, -0.16596870f, -0.19128834f, -0.02428520f, 0.29743162f, 
    0.06877689f, 0.23813993f, 0.15854564f, 0.08584426f, 0.00644636f, 0.07021680f, -0.04401449f, 0.00135368f, 
    -0.25525838f, 0.53060055f, -0.39594078f, -0.21429220f, -0.08526351f, -0.08731191f, -0.14444986f, -0.00243957f, 
    -0.15055822f, -0.13790473f, 0.02309639f, 0.04560031f, 0.10913453f, -0.18691847f, -0.02708447f, 0.14817074f, 
    0.07868545f, 0.00373007f, -0.00070376f, -0.16610275f, -0.03238713f, 0.00835006f, -0.03404573f, 0.17410110f, 
    -0.29312330f, -0.18120150f, -0.00929593f, 0.13152345f, 0.07775030f, -0.06098643f, -0.09896211f, -0.15517028f, 
    -0.05252339f, -0.08414207f, 0.00679276f, -0.09573030f, -0.14365882f, -0.02809400f, -0.12813801f, 0.29321986f, 
    -0.06865528f, 0.03904897f, 0.04795460f, 0.01664792f, -0.15924451f, 0.08024885f, 0.14400816f, -0.01230952f, 
    -0.04091704f, -0.18863699f, 0.14499234f, 0.08956214f, -0.05745905f, 0.08491436f, -0.03646293f, 0.06203662f, 
    0.02356067f, -0.01660441f, 0.10031505f, -0.02122800f, -0.39487746f, 0.03007442f, 0.38950318f, 0.15440024f, 
    -0.19844848f, -0.08126129f, -0.09893174f, 0.01829245f, 0.00404444f, 0.13820100f, 0.07997217f, 0.10115957f, 
    0.27885947f, 0.05303332f, 0.18769024f, -0.17418529f, 0.17542140f, 0.06779966f, -0.08603657f, 0.00682327f, 
    -0.06763158f, -0.00374374f, -0.04096601f, -0.08137615f, 0.00236574f, 0.24131058f, -0.20138000f, 0.00673936f, 
    0.01007127f, -0.00763786f, -0.03243114f, -0.04552680f, 0.03543173f, -0.04556452f, -0.10311075f, 0.03671980f, 
    0.25195444f, -0.12549603f, -0.10045733f, -0.35220611f, -0.06272060f, -0.28695309f, -0.10353920f, -0.04461106f, 
    -0.10360140f, 0.14116754f, -0.01404221f, -0.15853144f, -0.19731179f, -0.13053583f, -0.14684136f, 0.04516095f, 
    0.08613140f, 0.08916739f, 0.07260309f, -0.19873938f, -0.09676000f, -0.03842248f, -0.01980584f, 0.01766181f, 
    -0.08648555f, -0.14111434f, -0.04040715f, 0.25925207f, 0.07245191f, -0.00333897f, -0.01863097f, -0.01873893f, 
    -0.02897860f, 0.06089772f, 0.16069606f, -0.07530428f, -0.06642717f, -0.05876209f, 0.05054302f, 0.07030346f, 
    -0.06472865f, -0.05587725f, -0.02157612f, 0.01540099f, 0.04883564f, 0.20950732f, -0.09292038f, -0.16109899f, 
    -0.20226146f, -0.20215645f, 0.03349348f, 0.21167639f, 0.08674705f, 0.03570062f, 0.19280253f, 0.04039821f, 
    0.05241381f, -0.07123514f, 0.09619302f, -0.09646022f, 0.69257939f, -0.29655242f, 0.05136196f, 0.20117342f, 
    0.07278738f, -0.07539514f, -0.15834925f, 0.03656964f, -0.07073066f, -0.09366992f, 0.01753094f, 0.21674871f, 
    -0.48097292f, 0.04264200f, 0.08147276f, 0.14766486f, -0.15742700f, -0.03616699f, 0.00671123f, -0.05136649f, 
    0.06771513f, 0.14011496f, 0.04456334f, 0.02735283f, 0.11131489f, -0.14014868f, -0.08164444f, -0.18192205f, 
    0.17120957f, 0.09561304f, 0.03770996f, -0.11292607f, -0.05109242f, -0.01828450f, -0.03407070f, 0.00147246f, 
    -0.18270166f, 0.08968115f, 0.16392635f, -0.17286836f, 0.00626251f, -0.03075891f, 0.12013767f, -0.06242636f, 
    -0.07907346f, -0.05186907f, 0.09257791f, -0.07173304f, 0.57800674f, -0.01346033f, 0.13177200f, -0.03334571f, 
    -0.14195296f, 0.14583981f, 0.04134729f, -0.02796826f, 0.01922437f, 0.03224042f, 0.02211058f, 0.01097557f, 
    0.38347137f, -0.24547791f, -0.15290040f, -0.16173929f, -0.23851210f, 0.00636741f, -0.21195346f, 0.04188094f, 
    -0.07640208f, -0.01439916f, -0.01486038f, 0.04872014f, -0.12366174f, -0.03308634f, -0.08599925f, -0.37303460f, 
    -0.17051688f, 0.04320631f, -0.09202090f, -0.28184795f, 0.15080307f, 0.24627009f, -0.15206432f, 0.13980021f, 
    -0.24427333f, -0.07281269f, 0.10441072f, -0.14547308f, -0.29282901f, -0.12831773f, -0.19104281f, -0.16698888f, 
    -0.07078122f, 0.05378364f, 0.16042589f, -0.03680361f, 0.20755713f, -0.13519575f, 0.06844717f, -0.14745124f, 
    -0.17053029f, -0.00557201f, 0.04538422f, -0.00740569f, 0.04363796f, -0.02031398f, 0.01433453f, -0.11361609f, 
    -0.13640824f, 0.04476893f, 0.00331508f, -0.04042491f, -0.00817016f, 0.01567273f, 0.01308794f, 0.06694113f, 
    -0.00026446f, 0.03846885f, -0.18808368f, -0.04231689f, 0.18664680f, -0.00140706f, -0.11744082f, -0.17524923f, 
    -0.14068882f, 0.00730630f, 0.00686319f, 0.04139565f, -0.02068424f, -0.08229450f, -0.18525812f, -0.08257504f, 
    -0.05008214f, 0.02759105f, 0.12963292f, 0.11228772f, -0.03919417f, -0.13917160f, 0.00745739f, 0.06838182f, 
    0.01644932f, 0.08813570f, -0.15088284f, 0.08212075f, -0.07384039f, 0.20324607f, -0.30123958f, 0.13615587f, 
    0.02675663f, -0.01276836f, -0.23983863f, -0.09379286f, 0.05634833f, 0.06149175f, -0.01145617f, -0.09597814f, 
    0.21842901f, 0.14108545f, -0.11519071f, 0.15079704f, -0.09357090f, 0.01006952f, -0.07650379f, 0.04352117f, 
    -0.13622442f, -0.16991797f, -0.25160328f, -0.04925461f, -0.14649320f, 0.07036190f, 0.26818821f, 0.15599731f, 
    -0.07147288f, -0.00254844f, -0.00275379f, -0.01048326f, -0.05317187f, -0.12434563f, -0.00858809f, -0.04129947f, 
    0.02283845f, 0.11361755f, 0.20569493f, 0.14876455f, -0.08703994f, -0.09659876f, 0.08162814f, -0.04139908f, 
    -0.06156057f, -0.07601534f, 0.11407366f, -0.18593958f, -0.29457060f, -0.12482952f, -0.44547787f, 0.09511396f, 
    0.09205671f, 0.02024738f, 0.19776773f, -0.10323402f, 0.01915383f, 0.05898577f, -0.03327911f, -0.04958439f, 
    0.01724603f, 0.10930096f, 0.09260576f, 0.13121308f, 0.10013017f, 0.17345040f, 0.03961979f, 0.07668149f, 
    0.07520737f, 0.07836378f, -0.01112025f, -0.03678030f, 0.12313449f, -0.06375331f, -0.00100687f, 0.00042568f, 
    -0.07948683f, 0.03024231f, -0.16433212f, -0.05923016f, 0.12814446f, -0.00023183f, -0.04719547f, 0.02349756f, 
    0.03361587f, 0.17237771f, -0.04873971f, 0.16776727f, -0.07477706f, -0.13127373f, 0.05928526f, -0.16882816f, 
    -0.06406159f, -0.12029842f, 0.06626514f, -0.02244499f, -0.16692248f, -0.06649785f, 0.12878856f, 0.20478573f, 
    -0.04187095f, 0.02394183f, -0.03003141f, -0.17876790f, 0.00962775f, 0.02222149f, 0.04764119f, -0.00264394f, 
    -0.28586528f, 0.03986021f, 0.04435709f, 0.01018420f, 0.05276817f, -0.01561721f, -0.02683842f, 0.00874840f, 
    0.14606063f, 0.00226886f, 0.02961872f, 0.15026100f, 0.03914232f, -0.24242516f, 0.27860457f, -0.04786788f, 
    -0.00584804f, 0.04416403f, -0.16438840f, -0.16968940f, -0.06183410f, 0.03073042f, 0.01901119f, 0.07307494f, 
    -0.08952718f, -0.08096865f, -0.10219724f, 0.28486076f, -0.09092768f, 0.00372569f, -0.02301377f, -0.16128449f, 
    -0.15047531f, -0.10284813f, -0.10714442f, 0.02734971f, -0.07514230f, -0.29116288f, -0.01437505f, 0.09541999f, 
    -0.01154790f, -0.02590715f, -0.00284149f, -0.04145143f, 0.21784073f, 0.12439061f, 0.05319143f, 0.21452583f, 
    -0.13337696f, 0.08431635f, 0.11048788f, 0.12106065f, -0.17586523f, 0.05050453f, -0.05512190f, 0.04521438f, 
    -0.03770433f, -0.04056773f, -0.05150881f, -0.06674396f, -0.00743990f, 0.06486830f, 0.01603792f, 0.07973588f, 
    -0.01668802f, 0.16826239f, -0.14421913f, 0.20723404f, -0.01675170f, 0.00859297f, -0.06332498f, -0.08529256f, 
    -0.12560405f, -0.03772007f, 0.00841866f, -0.17421034f, 0.07992505f, -0.05215025f, -0.00818932f, -0.00168646f, 
    0.00034194f, -0.30016145f, -0.22049837f, -0.14603366f, 0.07836928f, 0.06954074f, 0.03525767f, -0.03235078f, 
    0.15888199f, 0.09678057f, 0.02478809f, 0.05337773f, 0.05081039f, 0.05535391f, -0.03074475f, -0.05913172f, 
    -0.05462785f, -0.06693520f, -0.01418822f, 0.07918962f, -0.08338424f, 0.00190866f, -0.00731120f, -0.04266836f, 
    -0.01385328f, 0.01030047f, -0.01042368f, 0.05619403f, 0.19193718f, 0.48699743f, -0.12729998f, 0.29974642f, 
    0.02571788f, 0.04753864f, -0.04927898f, 0.14836031f, 0.05829422f, -0.00495286f, 0.04388016f, -0.02352072f, 
    -0.10912000f, -0.28784177f, -0.10883179f, 0.00406323f, 0.00526266f, 0.07568364f, -0.05575201f, -0.00844119f, 
    -0.00158777f, 0.03147497f, -0.03499388f, -0.06469698f, 0.14864334f, -0.01416755f, 0.04388482f, 0.11405081f, 
    0.07053997f, 0.02546292f, -0.03910838f, -0.12901723f, -0.00606648f, -0.13831447f, 0.10727877f, 0.06366197f, 
    0.15543452f, -0.27050391f, 0.09438589f, 0.05186344f, -0.10551298f, 0.12162481f, 0.00567266f, 0.02031278f, 
    0.14075898f, -0.12737298f, -0.13993396f, -0.14453605f, -0.17261226f, 0.02527307f, 0.03368919f, 0.14132351f, 
    0.04440847f, 0.00420656f, -0.06773233f, -0.00574124f, 0.02153326f, -0.04612727f, -0.09638815f, 0.07505091f, 
    -0.01411408f, -0.10736334f, 0.25202316f, 0.23539461f, -0.14880452f, -0.15239625f, -0.04063047f, -0.06739748f, 
    -0.25864524f, -0.04753239f, -0.04451701f, -0.13674338f, 0.00670670f, 0.14733565f, 0.10260928f, 0.07905211f, 
    -0.07153074f, -0.07543144f, -0.12183283f, -0.00246045f, 0.05106023f, 0.06692505f, -0.01610037f, 0.12482644f, 
    0.06954706f, 0.01401141f, 0.12808274f, 0.15007718f, 0.12652498f, -0.16725266f, -0.18358332f, -0.07180679f, 
    0.03144008f, 0.01781041f, 0.08953130f, -0.03028214f, 0.01101699f, 0.11090370f, 0.07911123f, 0.12844428f, 
    0.03136287f, -0.06651120f, -0.07079257f, -0.06311650f, 0.06177222f, 0.00296160f, 0.04250025f, 0.01969072f, 
    0.01627676f, 0.02198443f, 0.18738148f, -0.06491793f, -0.13870211f, -0.07839706f, -0.12151495f, -0.17118737f, 
    -0.05869041f, -0.04869146f, 0.01092788f, -0.09726927f, -0.20068884f, -0.21262667f, -0.09512373f, 0.06883094f, 
    0.01743090f, -0.01946995f, 0.00612400f, 0.07725705f, 0.04301798f, 0.04931329f, -0.10527000f, 0.04103870f, 
    0.06777817f, 0.01466421f, 0.00467880f, -0.04750537f, 0.03747704f, 0.00763236f, 0.03180796f, 0.07133535f, 
    -0.20182554f, -0.00396465f, -0.04091742f, 0.00204273f, -0.02542270f, -0.19317909f, -0.15400229f, 0.00462394f, 
    0.06670386f, 0.03847948f, 0.05964408f, -0.00645637f, -0.07832830f, -0.08130094f, -0.00331888f, -0.09895591f, 
    -0.00502384f, 0.03444869f, 0.03372792f, 0.08037136f, -0.11798239f, -0.01568093f, -0.01970968f, -0.03265213f, 
    -0.00163196f, -0.01134179f, 0.02255309f, 0.06298383f, -0.08436823f, -0.03263119f, -0.09356758f, -0.03093410f, 
    -0.07899513f, 0.05536001f, -0.07511465f, 0.11024973f, 0.01403180f, -0.01806402f, -0.11325205f, 0.01405900f, 
    0.12476622f, -0.05340294f, -0.14574291f, 0.09584140f, 0.03544874f, -0.05206872f, 0.08439809f, -0.07848361f, 
    0.13296820f, 0.09567477f, 0.25509903f, 0.27862430f, -0.05188059f, -0.32248837f, 0.16056703f, -0.09535560f, 
    -0.08931438f, 0.02199839f, 0.14487764f, -0.06781181f, -0.18970373f, 0.08326015f, -0.08013465f, 0.09642855f, 
    -0.03180397f, -0.06080490f, 0.08205908f, -0.06399119f, -0.08963908f, -0.17327467f, -0.01977634f, -0.10043434f, 
    -0.06397541f, 0.02514677f, -0.15887947f, -0.03599422f, 0.08133682f, 0.09269161f, -0.24921991f, 0.05641905f, 
    -0.00549999f, -0.04193860f, 0.00834291f, 0.06695221f, -0.12191664f, -0.22815475f, 0.05269137f, -0.18278188f, 
    -0.24025433f, -0.22306341f, 0.06276260f, 0.03770780f, -0.30539283f, -0.00417729f, -0.10467236f, -0.04622469f, 
    -0.00257979f, -0.03996222f, -0.05301183f, 0.08199242f, -0.26355654f, 0.04374931f, 0.11685837f, -0.05402652f, 
    0.03333142f, -0.05563931f, 0.00522288f, 0.07272206f, -0.05346841f, 0.06987088f, 0.03975320f, 0.18900073f, 
    0.15172079f, -0.59311408f, 0.33479938f, 0.12896389f, -0.18126445f, -0.13670652f, -0.27142203f, -0.04256865f, 
    -0.34626806f, 0.01886482f, -0.24827911f, 0.07200904f, 0.14200279f, 0.32324278f, 0.04275728f, 0.15767688f, 
    -0.09524718f, -0.13357839f, 0.03369708f, -0.01456717f, 0.08790474f, 0.05271161f, 0.06430494f, 0.03734388f, 
    -0.20073242f, -0.00425524f, -0.04305678f, -0.00843609f, 0.09570665f, 0.07447463f, 0.02464858f, 0.04788906f, 
    0.07558904f, -0.00103540f, -0.02472372f, 0.03275696f, 0.03309611f, -0.02641866f, 0.05453284f, -0.04673859f, 
    0.06714860f, 0.01663590f, -0.02005349f, -0.19401634f, 0.15893498f, -0.00855987f, -0.12180759f, 0.02919046f, 
    0.08528734f, 0.30190125f, 0.06832720f, 0.16298996f, 0.04456511f, 0.02629234f, -0.10828996f, 0.01690592f, 
    -0.02288035f, -0.00250689f, -0.03769811f, 0.00164670f, 0.25544006f, 0.15105531f, -0.27360991f, 0.03413123f, 
    0.06200383f, 0.06894474f, 0.14348784f, -0.00050097f, 0.09868865f, 0.05883797f, 0.03950417f, 0.03168659f, 
    0.14541911f, -0.07500952f, -0.11394253f, -0.01398128f, -0.07987521f, -0.05737888f, 0.10547611f, 0.00011206f, 
    -0.01022485f, -0.07775736f, 0.03062872f, -0.04422832f, 0.00835573f, -0.15922709f, 0.19578983f, -0.00248932f, 
    -0.24801278f, -0.03462860f, -0.25876817f, -0.18835588f, -0.08034795f, -0.03598372f, -0.00273384f, 0.01365344f, 
    -0.13028020f, -0.06367984f, 0.04485514f, -0.06294788f, -0.11984473f, 0.04394798f, 0.08349434f, 0.07487894f, 
    0.01121567f, -0.02024502f, 0.03398864f, -0.17535466f, 0.02011634f, 0.01903208f, 0.02913507f, 0.01706928f, 
    -0.00943337f, -0.01243388f, -0.00295453f, 0.07775149f, -0.03013675f, -0.16797903f, -0.11797126f, 0.02496423f, 
    0.10422602f, 0.19376262f, -0.00389242f, 0.13878626f, -0.10792775f, -0.16575097f, 0.01971916f, -0.17246340f, 
    -0.15154934f, -0.00359366f, -0.01297211f, -0.11199911f, 0.05879931f, 0.02397097f, 0.05632871f, 0.05803746f, 
    -0.05574822f, -0.02370169f, -0.00353378f, -0.08443180f, 0.06742590f, -0.02504507f, 0.01210118f, 0.05351625f, 
    0.21534550f, 0.26271969f, 0.19252455f, 0.21603948f, -0.08700908f, 0.01900381f, 0.14979975f, 0.02089070f, 
    -0.00461789f, -0.00046744f, -0.01678586f, 0.02911991f, -0.07501877f, -0.10571893f, -0.06477300f, 0.12366273f, 
    0.01679562f, -0.21648623f, -0.01866114f, 0.01130616f, 0.02264525f, -0.00321847f, 0.08408871f, -0.05797262f, 
    -0.02674347f, 0.14649098f, -0.12085683f, -0.19098999f, -0.02953636f, -0.05450679f, 0.00543203f, -0.05806395f, 
    0.01379860f, -0.08335894f, -0.21328104f, 0.12820977f, -0.00243886f, 0.11282224f, -0.13429315f, 0.15600489f, 
    -0.05692881f, -0.06958118f, 0.05474418f, -0.01582619f, -0.01043799f, 0.08395129f, -0.01163498f, 0.00691543f, 
    -0.06025264f, -0.08540670f, -0.20726772f, -0.25546160f, -0.00462498f, 0.07280418f, -0.08393057f, 0.09022599f, 
    -0.08937377f, 0.01913622f, -0.09042136f, 0.00130500f, -0.07109262f, -0.01656653f, -0.04486660f, 0.05555887f, 
    -0.00237161f, -0.06469631f, 0.06588361f, -0.20307000f, -0.01620206f, 0.03610006f, 0.09119643f, 0.37348083f, 
    -0.40508363f, -0.25345391f, -0.32221600f, -0.19192435f, 0.08808877f, 0.03231265f, 0.05729130f, 0.02929353f, 
    0.04204943f, -0.15962410f, -0.02662709f, -0.08402188f, 0.04671592f, -0.03130709f, 0.01919821f, 0.05980393f, 
    -0.03609097f, 0.02627648f, -0.03954430f, 0.02639558f, 0.06691214f, 0.02453922f, -0.01501405f, -0.00189138f, 
    -0.03936899f, 0.03770879f, 0.10696518f, 0.13718243f, 0.00173169f, 0.01449476f, 0.02957793f, -0.19420123f, 
    0.09169096f, -0.07936371f, -0.30073991f, -0.04959275f, 0.00806404f, -0.18856208f, -0.02815038f, 0.18375784f, 
    -0.00029215f, -0.04794379f, -0.02505428f, -0.00689168f, -0.05386899f, 0.02826522f, -0.04274645f, 0.00477839f, 
    0.11230312f, 0.02394685f, -0.08778948f, -0.21349525f, 0.02182024f, 0.03479225f, -0.18817052f, -0.12121653f, 
    0.09532291f, 0.14482392f, 0.08970137f, -0.02203454f, -0.40800878f, -0.35176209f, 0.09690520f, 0.30821711f, 
    0.08401606f, -0.11553891f, -0.01066133f, 0.06437624f, 0.07892572f, -0.11083300f, 0.06131951f, 0.13362201f, 
    0.00861884f, 0.18200186f, 0.11529816f, -0.09740072f, 0.10198631f, -0.04129536f, -0.00749172f, -0.08127584f, 
    -0.00872691f, 0.06455301f, -0.12443160f, 0.02641036f, -0.44480857f, 0.21673074f, -0.26246357f, -0.13679464f, 
    0.04663090f, -0.17083919f, 0.24137066f, 0.07394604f, 0.12711626f, -0.08085326f, 0.00066386f, 0.21094231f, 
    -0.24001081f, -0.41519466f, 0.12797679f, 0.04272687f, -0.17859140f, 0.03041982f, 0.02052485f, -0.07690272f, 
    0.16851829f, -0.18330738f, 0.15017445f, 0.03662457f, 0.29167172f, 0.12693268f, -0.00965643f, 0.09329090f, 
    -0.02431868f, -0.04408811f, 0.01557733f, -0.15251891f, 0.03955221f, -0.03737962f, 0.07790551f, -0.10154625f, 
    0.20798197f, 0.16614664f, 0.20140575f, 0.06930202f, 0.03750626f, 0.01567281f, 0.10823269f, -0.02980440f, 
    0.05583365f, -0.07051244f, 0.07676399f, 0.05948298f, -0.37494248f, -0.09609314f, -0.21035780f, 0.32271546f, 
    -0.01382368f, 0.03687626f, 0.08975518f, -0.01206922f, -0.07413428f, 0.06180921f, -0.03597452f, 0.09411834f, 
    -0.07450603f, 0.02973408f, -0.17126676f, -0.03521848f, -0.02699648f, 0.06434031f, 0.13032262f, -0.16288322f, 
    -0.09218594f, -0.00697014f, -0.04865574f, -0.06728504f, 0.00902245f, 0.05785405f, -0.10399897f, -0.11497767f, 
    -0.03779075f, -0.01376471f, -0.05098632f, -0.09061317f, 0.13209546f, 0.15451555f, -0.03788758f, 0.00634764f, 
    -0.28898102f, 0.02525982f, 0.03684784f, -0.21002305f, -0.01793092f, 0.06988900f, -0.05269030f, -0.05544490f, 
    0.17101951f, 0.03613806f, -0.22412519f, 0.03129793f, -0.18931520f, 0.07411143f, 0.22574574f, -0.09899090f, 
    0.07191212f, 0.02802198f, 0.03985043f, 0.01937521f, 0.04345714f, 0.02623952f, 0.05636605f, 0.13028775f, 
    -0.22865696f, 0.06067173f, -0.11943194f, -0.51791370f, -0.07675611f, -0.01879252f, 0.14430615f, 0.10505524f, 
    -0.01409498f, -0.18767513f, -0.01570709f, -0.47103959f, 0.18238375f, -0.03312478f, -0.03019129f, -0.23286223f, 
    0.02129694f, 0.05104493f, 0.02690990f, 0.14419663f, 0.03423962f, -0.03389151f, -0.03003556f, 0.03597993f, 
    0.10505402f, -0.10537506f, 0.27390447f, 0.05086925f, 0.03296395f, 0.03098783f, -0.00387023f, 0.11816287f, 
    0.07856610f, 0.03044642f, 0.01411865f, 0.08079804f, -0.61687309f, 0.58853996f, 0.18605140f, -0.22014591f, 
    0.00673398f, -0.06791404f, 0.01031443f, 0.13844769f, 0.01816559f, -0.36178640f, -0.32006282f, -0.29037726f, 
    0.08467776f, -0.08786609f, -0.01740162f, 0.04806382f, 0.02118932f, 0.08622675f, 0.01783964f, -0.19497502f, 
    -0.05129872f, -0.03326601f, 0.02746303f, -0.14161046f, 0.04065556f, 0.00636473f, -0.17784232f, -0.23589963f, 
    0.01379687f, 0.35980499f, -0.16888082f, 0.12381147f, -0.01409242f, -0.11523773f, 0.04324284f, 0.08817792f, 
    0.03112835f, 0.03986420f, -0.27095592f, 0.19751047f, -0.00910511f, -0.07015482f, -0.00086530f, -0.05135291f, 
    -0.01269370f, 0.08461543f, 0.17938359f, -0.02712564f, -0.03576473f, 0.01597252f, -0.05411790f, 0.01335382f, 
    0.10223150f, -0.00209557f, -0.02326186f, -0.01459834f, 0.14614411f, -0.16678697f, 0.04356287f, 0.14532635f, 
    -0.11468606f, 0.01888250f, -0.04076609f, -0.13394263f, 0.00411938f, -0.09444150f, 0.15946846f, 0.25675189f, 
    -0.18176419f, -0.12775405f, 0.10861909f, -0.01650981f, 0.09982865f, 0.06508221f, -0.27481160f, 0.09096131f, 
    0.15195484f, 0.19090331f, -0.08598396f, 0.17636023f, 0.02265831f, 0.02857705f, 0.06858154f, -0.08732744f, 
    -0.02491809f, 0.38812405f, -0.51921767f, -0.23772112f, -0.09130799f, -0.01788039f, -0.08376964f, 0.04828001f, 
    0.13541785f, -0.07798892f, -0.18658254f, -0.05234035f, 0.01867262f, -0.08504695f, 0.13900380f, -0.13460252f, 
    -0.07383805f, -0.15023278f, 0.05498379f, 0.28714332f, -0.14660928f, 0.19630417f, 0.06667315f, -0.20961939f, 
    -0.09889625f, 0.12619701f, 0.07296332f, -0.30423424f, 0.05999096f, -0.05444357f, -0.01201006f, -0.05076835f, 
    0.10515136f, 0.04121014f, -0.05606649f, -0.10531036f, 0.08204469f, -0.19388880f, 0.00382975f, -0.31137156f, 
    -0.09578422f, -0.17404722f, -0.19369422f, 0.09218363f, -0.06277612f, -0.07248319f, -0.06648025f, 0.06584889f, 
    0.31290203f, 0.06120407f, -0.04001479f, 0.09456606f, 0.08638676f, -0.00225615f, 0.12389687f, 0.08879872f, 
    0.16682312f, -0.02780339f, -0.09607305f, 0.03907076f, 0.00508174f, 0.21481918f, 0.11613851f, -0.09184505f, 
    0.15333714f, -0.00511643f, -0.06316071f, -0.08318672f, 0.03011614f, 0.03674309f, 0.00444253f, -0.02358868f, 
    0.04172870f, 0.12615983f, -0.01311045f, -0.13434826f, 0.00318087f, 0.12219780f, 0.24357425f, -0.16532370f, 
    0.02346666f, 0.00585160f, 0.11999433f, 0.01526541f, 0.11893710f, -0.01635497f, 0.12403092f, -0.09797592f, 
    0.06488556f, -0.12594216f, -0.03965493f, -0.11850547f, -0.13550901f, -0.00469822f, 0.10670810f, -0.08536323f, 
    0.15314457f, 0.09200321f, -0.24838594f, -0.18259849f, 0.08379638f, -0.01069510f, 0.24984281f, 0.19497943f, 
    0.07574766f, -0.00148165f, -0.01559740f, 0.09225655f, -0.28012717f, -0.26960334f, 0.00031738f, 0.10511336f, 
    -0.03093553f, 0.04945594f, -0.00640009f, 0.07586266f, 0.04682556f, 0.19427288f, 0.01563226f, 0.13424899f, 
    -0.06354582f, -0.11943912f, -0.02684850f, 0.14898773f, -0.07418050f, -0.04102540f, -0.01573035f, 0.03017467f, 
    0.10498292f, -0.15877910f, 0.09023480f, 0.10928489f, 0.20406868f, -0.21679324f, 0.22081195f, 0.00322910f, 
    -0.15344575f, -0.05650380f, -0.07305160f, 0.01849237f, 0.07267463f, 0.05382526f, 0.08294927f, -0.02421879f, 
    -0.14335719f, -0.09740590f, -0.01499605f, -0.12866454f, 0.14984572f, -0.01838480f, 0.01074524f, 0.05103404f, 
    -0.03511378f, -0.06988656f, -0.06640589f, 0.12410815f, -0.18194547f, -0.10452192f, -0.14554982f, 0.08658224f, 
    0.14152637f, -0.04586333f, 0.07679012f, -0.13601714f, -0.11037875f, 0.18608567f, -0.05914312f, 0.49351054f, 
    0.01074071f, -0.10467783f, -0.04428368f, 0.06038009f, 0.05093503f, 0.05504190f, 0.07896537f, 0.08395132f, 
    0.01555099f, -0.14822501f, -0.14551114f, -0.53060144f, -0.01729626f, -0.25189951f, 0.13099875f, 0.20143144f, 
    -0.08679304f, -0.05641271f, 0.00385291f, -0.00170287f, -0.21135302f, -0.03888183f, -0.17853078f, -0.14554828f, 
    0.14296778f, 0.10713103f, -0.31546924f, 0.10249343f, 0.02094173f, 0.10393611f, -0.01045416f, 0.07456771f, 
    0.03317104f, 0.17184353f, -0.07175563f, -0.05272357f, -0.22276230f, 0.02293910f, 0.00236419f, -0.05925918f, 
    0.03172043f, -0.03711228f, -0.11480045f, -0.02520085f, 0.04484333f, 0.15331425f, -0.08109038f, 0.07365927f, 
    -0.00991991f, -0.08089059f, -0.03818415f, -0.12718119f, 0.00359750f, -0.17331207f, -0.06566159f, -0.09415697f, 
    -0.12803447f, 0.11962750f, -0.08127155f, 0.08388768f, -0.16681318f, 0.03595453f, -0.49748239f, -0.13487202f, 
    0.00971042f, 0.09752729f, 0.01642961f, 0.00157771f, 0.12934464f, -0.04235157f, 0.06866150f, -0.27446240f, 
    -0.03084064f, -0.07773595f, 0.28232932f, -0.03789110f, 0.02421995f, 0.16568294f, 0.02957399f, -0.13672283f, 
    0.17427930f, 0.06205985f, -0.01222608f, 0.03247100f, -0.56929588f, -0.31053928f, 0.01897108f, -0.18631504f, 
    0.10261534f, 0.08060973f, 0.00406610f, 0.07766297f, 0.00294889f, 0.05060020f, -0.02317001f, -0.11065751f, 
    0.15845031f, 0.02648194f, -0.24989367f, 0.19198424f, -0.09188341f, 0.08648963f, 0.12782721f, -0.05456706f, 
    -0.00414520f, -0.00530745f, 0.00270254f, 0.04692856f, 0.11605776f, 0.05185964f, -0.19536376f, -0.12091958f, 
    -0.00618012f, -0.02742759f, -0.06860710f, 0.09774213f, -0.11181457f, -0.07407717f, 0.04319902f, -0.09269609f, 
    0.15060894f, 0.05062373f, 0.07371217f, 0.12548894f, -0.00059628f, 0.07472226f, -0.00415578f, -0.16102071f, 
    0.04350800f, -0.00702055f, -0.05223362f, -0.02132441f, -0.03734036f, -0.19033332f, -0.58049965f, -0.06201559f, 
    0.10386109f, 0.06286178f, 0.01797717f, 0.06424057f, 0.03300612f, -0.06012646f, -0.09895368f, -0.09063888f, 
    -0.55852032f, -0.35625675f, -0.22373118f, 0.12211114f, 0.13836801f, -0.05858120f, -0.14216332f, 0.10194135f, 
    0.07344220f, 0.01114308f, -0.03619456f, 0.01948257f, 0.11816087f, 0.13069716f, -0.00211838f, -0.22713599f, 
    0.19065470f, -0.00054064f, 0.08322667f, 0.14906581f, -0.02078726f, -0.00829246f, 0.03202389f, 0.04128848f, 
    -0.04892533f, 0.01676926f, 0.04640665f, 0.14441158f, 0.14454046f, -0.06702451f, -0.00606675f, -0.08156400f, 
    0.08731429f, -0.10355092f, 0.15004799f, 0.03260957f, -0.06597757f, -0.29904622f, 0.02803503f, 0.02662045f, 
    -0.00413244f, -0.00664362f, -0.00330767f, 0.06109635f, 0.02671205f, 0.01900964f, 0.08668776f, 0.03335521f, 
    -0.03870541f, 0.18443033f, -0.12857223f, -0.33697054f, 0.09513640f, -0.01722877f, -0.05848826f, 0.06685679f, 
    0.09922157f, -0.06073768f, 0.17034023f, 0.03425422f, 0.21363294f, 0.06862420f, -0.01409996f, 0.14206167f, 
    0.17764853f, 0.15485770f, 0.07916491f, 0.14738244f, 0.05390889f, 0.07299691f, 0.01690805f, 0.10591602f, 
    0.06879099f, 0.21873851f, -0.03185683f, -0.24342981f, 0.17494227f, 0.12985787f, -0.05593302f, 0.01767753f, 
    0.03555281f, 0.01751967f, 0.06627376f, 0.03152280f, -0.21496616f, 0.06145139f, -0.23328251f, 0.04484724f, 
    -0.00106744f, -0.06985939f, 0.11236112f, 0.13033842f, -0.05814385f, -0.02589561f, 0.05817752f, 0.13771829f, 
    0.31875286f, -0.00062100f, -0.11402404f, -0.09449108f, 0.10306045f, 0.08495279f, 0.00738688f, -0.03006173f, 
    -0.07860563f, 0.17798612f, -0.31884715f, -0.18222830f, -0.25964931f, -0.33231789f, 0.14551955f, 0.04497640f, 
    -0.11747783f, -0.00867046f, -0.06643694f, 0.21957596f, 0.08020198f, -0.09388036f, 0.03006950f, -0.04713609f, 
    -0.14332545f, -0.18251155f, -0.21153390f, -0.29745775f, -0.00460049f, 0.00300292f, 0.03498691f, 0.02619272f, 
    0.02120551f, -0.08559939f, -0.06899155f, 0.18045945f, -0.17837758f, -0.21272774f, 0.03767815f, 0.07006429f, 
    -0.08697182f, -0.05126788f, 0.08715498f, 0.16060080f, -0.14085808f, -0.12278458f, -0.18358453f, -0.36703780f, 
    0.29488349f, -0.10606986f, -0.09018724f, 0.23217757f, -0.01053094f, 0.04146400f, -0.03861377f, 0.03068477f, 
    0.09344405f, 0.18110469f, 0.04661176f, -0.08302920f, 0.03088884f, -0.19811238f, -0.02214573f, 0.10751887f, 
    0.01313056f, -0.03027572f, 0.00790700f, 0.08233169f, -0.08106655f, -0.00929809f, 0.08077277f, -0.22394115f, 
    -0.02266004f, -0.16438389f, 0.02068830f, -0.38634068f, 0.05077301f, 0.21163735f, -0.10591996f, -0.07870438f, 
    0.12364957f, -0.34645209f, 0.18723160f, 0.06286286f, -0.07450762f, -0.13141906f, 0.06618407f, 0.07094663f, 
    0.08035350f, -0.11920080f, 0.04635626f, 0.02611480f, -0.04849523f, -0.01191986f, -0.00587609f, 0.03433177f, 
    0.72206199f, 0.17971481f, -0.24062695f, 0.06798568f, 0.07603726f, -0.07472482f, 0.05696076f, 0.10241681f, 
    0.10235129f, -0.06033900f, 0.04935738f, -0.14703068f, -0.03461589f, -0.02820156f, 0.15107310f, 0.15101072f, 
    0.03154971f, -0.04176627f, 0.02961059f, -0.05590380f, 0.10254481f, -0.02023195f, 0.24153852f, 0.04189050f, 
    -0.30991989f, 0.02555599f, 0.19730271f, 0.03261188f, -0.16528134f, -0.01070625f, 0.00883157f, -0.13778968f, 
    0.11698297f, -0.01381774f, 0.07448817f, 0.07845401f, 0.54648638f, -0.39426753f, -0.08864701f, 0.06919603f, 
    -0.01868198f, -0.19353686f, 0.20995495f, -0.02190041f, 0.05842102f, -0.02931356f, -0.06323754f, -0.08618538f, 
    -0.25391251f, 0.21123432f, 0.35712552f, 0.30620426f, 0.07605543f, -0.09224091f, 0.10654046f, 0.21252936f, 
    0.06609096f, 0.12080879f, -0.06861865f, -0.05984590f, -0.12733583f, -0.27771482f, -0.02341453f, -0.05062062f, 
    -0.07093317f, -0.09544738f, -0.06610837f, 0.03670914f, -0.10252281f, 0.05657288f, 0.08531728f, -0.13898566f, 
    -0.54020214f, -0.50799072f, -0.34938610f, -0.47740206f, -0.03454540f, -0.20456082f, -0.12113727f, -0.22876126f, 
    -0.03184876f, -0.00676701f, -0.01453765f, -0.08897448f, 0.01520483f, -0.06764521f, -0.10840076f, -0.03933866f, 
    0.07777091f, 0.15185571f, 0.09246257f, 0.06289227f, -0.06030093f, -0.03985917f, 0.00808302f, 0.05856159f, 
    0.19926324f, -0.20331901f, -0.19810122f, -0.03151800f, -0.07988302f, 0.01901566f, 0.09836656f, -0.10971905f, 
    -0.02621886f, -0.06438745f, -0.09373370f, -0.03539178f, -0.25083631f, -0.06012770f, 0.09311076f, -0.12723586f, 
    -0.13215508f, -0.23364916f, -0.16716835f, 0.11098290f, -0.04285528f, 0.01292635f, -0.00858584f, -0.01047346f, 
    -0.28969115f, -0.08191831f, 0.28066471f, -0.17913501f, -0.07525297f, -0.06695608f, 0.04500664f, 0.06572870f, 
    -0.18488441f, 0.05181639f, 0.13351758f, -0.01257790f, -0.27678820f, -0.37577206f, -0.47358257f, 0.23186374f, 
    -0.21921110f, -0.26459724f, -0.09757736f, -0.16722682f, -0.06683700f, 0.02635095f, -0.01317263f, -0.12053003f, 
    -0.15431577f, 0.04376889f, 0.07405304f, 0.09942126f, 0.00780246f, 0.04511883f, 0.09145654f, -0.04102799f, 
    0.03322808f, 0.13064884f, 0.08007392f, 0.03480265f, -0.29149348f, 0.57006979f, 0.08155095f, 0.00002962f, 
    -0.14755258f, 0.01435601f, -0.08149956f, -0.02908394f, 0.04207450f, -0.00849771f, -0.04850570f, 0.01806383f, 
    0.01681311f, -0.34556139f, -0.23359898f, 0.15058777f, -0.18604197f, 0.00680100f, 0.02870699f, 0.00105772f, 
    0.00534561f, 0.01063295f, -0.05149899f, -0.06706303f, 0.03451112f, -0.04581049f, 0.01029159f, -0.13872695f, 
    -0.04554075f, -0.05062424f, 0.07486393f, 0.05015042f, 0.06390885f, 0.12024772f, 0.25704634f, -0.04052660f, 
    0.26215675f, -0.11121269f, -0.38489377f, -0.04078089f, -0.16076869f, 0.08568239f, 0.10015418f, 0.05181395f, 
    0.01647476f, -0.09730767f, -0.04277589f, 0.06794043f, 0.01562055f, -0.03044245f, -0.01576436f, -0.09692796f, 
    -0.00836781f, -0.03416367f, 0.04109577f, 0.10280383f, -0.04940462f, -0.05816822f, -0.08943474f, 0.00293188f, 
    0.05184516f, 0.08764964f, -0.00759566f, -0.41025922f, -0.01517101f, 0.12565471f, -0.04248975f, -0.00702880f, 
    0.11170875f, 0.09447652f, 0.01028986f, 0.16945729f, -0.02331483f, -0.06640685f, 0.02611402f, -0.04259679f, 
    -0.02823513f, -0.02907242f, -0.04538081f, -0.03425997f, -0.31310531f, -0.08308080f, -0.26737750f, -0.16170725f, 
    0.06678949f, -0.02730534f, 0.03674257f, 0.10864159f, 0.00196322f, 0.09961780f, 0.17103851f, 0.22121350f, 
    0.10959329f, 0.13485353f, 0.01641182f, -0.11686361f, -0.28201914f, -0.65557986f, -0.05202753f, -0.55291945f, 
    -0.11630588f, 0.13487504f, 0.23531623f, -0.15778485f, -0.00227798f, 0.05649026f, 0.02657056f, 0.10362606f, 
    -0.27494928f, -0.11953699f, 0.07942175f, 0.11151654f, 0.00790999f, 0.01724957f, 0.02890246f, 0.07132215f, 
    0.08577262f, 0.03148966f, -0.11018356f, 0.00950306f, -0.03718157f, -0.12483228f, -0.08022895f, 0.23042639f, 
    0.05857885f, 0.17104226f, 0.02634723f, -0.18812115f, 0.03585456f, -0.03901136f, 0.09979093f, 0.00353957f, 
    -0.09320316f, -0.07299064f, 0.08020748f, -0.07773444f, -0.03033504f, -0.11315040f, -0.04530855f, 0.01585247f, 
    -0.00411420f, 0.07247133f, 0.03410292f, -0.01092078f, -0.57723737f, -0.54909146f, -0.16178444f, 0.40019190f, 
    -0.02120437f, 0.06602882f, 0.05910163f, 0.01335008f, -0.00048017f, 0.04540621f, 0.08367626f, -0.07344117f, 
    -0.37580839f, -0.58731455f, -0.11314832f, 0.31967577f, 0.17494895f, -0.08233407f, -0.21793397f, -0.23716731f, 
    -0.09193154f, -0.08000680f, 0.10516169f, 0.06361122f, -0.51231170f, -0.63426286f, -0.45953521f, 0.02821829f, 
    -0.19022822f, -0.02459932f, 0.03518951f, -0.27767140f, -0.06200897f, 0.02053080f, 0.02810184f, 0.03141216f, 
    -0.33104968f, -0.73934305f, -0.00938703f, -0.41597995f, 0.03911966f, -0.24518614f, -0.12365440f, -0.25248992f, 
    -0.01168180f, -0.00580265f, 0.01621304f, -0.03736036f, -0.02386021f, 0.01824874f, -0.01896341f, -0.05830663f, 
    -0.18857445f, 0.03401112f, -0.20882216f, -0.04770109f, 0.03801222f, -0.07558691f, 0.06084318f, -0.06909551f, 
    0.13714701f, 0.22532940f, 0.18018104f, 0.02909403f, -0.08352162f, -0.00455062f, 0.05791054f, 0.04618737f, 
    0.14067052f, 0.08061390f, 0.00913244f, 0.04564533f, 0.03904626f, 0.02987108f, -0.03801665f, -0.08253236f, 
    0.04858879f, 0.03004579f, 0.05130456f, -0.01508816f, -0.05645839f, -0.07291084f, -0.05019926f, -0.05090887f, 
    -0.13923270f, 0.04335240f, 0.07731837f, -0.01202991f, -0.00763275f, -0.01856530f, -0.02014325f, 0.03576978f, 
    0.01854370f, -0.08692342f, -0.09265493f, -0.04120927f, -0.09534656f, -0.13596176f, -0.32211304f, 0.07462876f, 
    -0.08401500f, 0.04666411f, 0.08370799f, 0.01214540f, 0.05682979f, 0.05631343f, -0.03401746f, 0.01118221f, 
    -0.72928166f, -0.79914862f, -0.18119602f, 0.09311014f, -0.06648580f, -0.19457492f, 0.12679876f, -0.12498009f, 
    -0.01503471f, 0.07048583f, -0.04355975f, 0.03020295f, 0.07070013f, 0.06690381f, 0.10814697f, -0.09348352f, 
    0.11921636f, -0.16395625f, 0.25687462f, -0.04261167f, -0.01396701f, -0.00184682f, -0.01638636f, -0.06168405f, 
    0.09452031f, 0.01004336f, -0.05270738f, -0.01483453f, -0.04382518f, -0.02262539f, 0.08541226f, 0.12512909f, 
    0.05369630f, 0.16352254f, 0.09823780f, 0.02369328f, 0.06098334f, 0.00815877f, -0.19316494f, -0.04828886f, 
    -0.09952913f, 0.01496487f, 0.05598464f, 0.01494814f, -0.03943293f, 0.00476626f, -0.01051297f, 0.17494069f, 
    -0.40441117f, -0.03791552f, 0.42804524f, 0.02033016f, -0.04976874f, 0.05971524f, -0.09868068f, -0.31695455f, 
    -0.05981193f, -0.01591382f, -0.05632455f, 0.16418037f, 0.00163719f, 0.04008670f, -0.07398269f, 0.00955898f, 
    0.06328885f, -0.12519482f, 0.01332993f, 0.07607202f, -0.05609286f, 0.10684094f, -0.06951806f, -0.06259128f, 
    -0.35019010f, 0.18640827f, 0.09853888f, 0.00631809f, -0.17608789f, 0.01781739f, 0.03488496f, 0.20903940f, 
    0.14321771f, 0.02841561f, -0.01840308f, 0.15213311f, 0.00008337f, 0.27847266f, 0.25500748f, 0.01696050f, 
    -0.00901684f, -0.02595786f, -0.00721165f, -0.02634448f, 0.11484064f, 0.18187073f, 0.01287853f, 0.20149969f, 
    -0.03376600f, -0.11347349f, -0.12128123f, 0.24491523f, 0.07404989f, 0.18240364f, 0.19147325f, 0.00236415f, 
    0.08979560f, 0.06235949f, 0.07823137f, -0.07023973f, -0.59792387f, -0.25800213f, 0.26853758f, 0.06553412f, 
    0.08660064f, 0.02297790f, -0.10790566f, 0.01714595f, 0.01775846f, -0.01423079f, -0.00286983f, 0.03342990f, 
    0.08994833f, -0.02822884f, 0.08456021f, -0.00523099f, 0.16835505f, -0.01523573f, 0.15684359f, -0.11099182f, 
    0.04312659f, -0.03630943f, -0.02568352f, 0.05470205f, 0.24433325f, 0.26490572f, 0.03513437f, -0.13491796f, 
    -0.05059000f, -0.04679909f, -0.09182911f, -0.05051697f, 0.01634618f, 0.00907677f, -0.10516950f, 0.05127371f, 
    -0.35336554f, -0.87813050f, -0.35218811f, -0.31387222f, 0.01005987f, 0.09848540f, 0.08617182f, -0.22650018f, 
    0.00551403f, 0.05951349f, 0.00526763f, 0.00731455f, 0.08694306f, -0.23822327f, -0.13797842f, -0.01148713f, 
    0.03679920f, 0.04671378f, 0.21366931f, -0.05454917f, 0.00110769f, 0.03872772f, -0.03677392f, -0.01647888f, 
    -0.15889035f, 0.00458719f, 0.22044094f, 0.19522610f, -0.04609125f, 0.05450615f, -0.07305481f, 0.02596647f, 
    -0.07067924f, -0.01786504f, 0.07942263f, -0.01832405f, -0.23333704f, 0.22859062f, -0.16089480f, -0.05736953f, 
    -0.18815188f, -0.11121114f, 0.05998984f, 0.01978407f, 0.02169804f, 0.04375371f, -0.01073413f, 0.02379697f, 
    0.03974099f, -0.08382402f, -0.08789491f, -0.02262663f, -0.10398033f, -0.03660518f, 0.04513522f, 0.22733669f, 
    0.02081603f, -0.02566262f, 0.01284340f, -0.05905018f, 0.08341800f, 0.18890285f, 0.14017269f, 0.21331544f, 
    -0.04308856f, -0.01156833f, -0.01937256f, 0.08400534f, -0.04547049f, -0.12732884f, -0.04794486f, 0.18722731f, 
    0.26399493f, 0.09989365f, 0.09119919f, -0.16998582f, 0.15029672f, -0.01540046f, 0.01534699f, 0.06170392f, 
    0.11232723f, 0.02057200f, 0.16710749f, 0.05039547f, -0.26718530f, -0.14899746f, -0.14784603f, -0.12821071f, 
    -0.03587331f, -0.34384578f, -0.01918661f, -0.34499252f, 0.00970036f, -0.05263922f, -0.05653744f, -0.05822141f, 
    -0.38346997f, -0.36900887f, -0.07357838f, -0.10452501f, -0.13127658f, -0.17570576f, -0.07282563f, -0.36713222f, 
    0.00204260f, -0.15284285f, -0.00732741f, -0.04143293f, -0.42270696f, -0.36262628f, -0.09279780f, 0.74905753f, 
    -0.19620658f, -0.13142037f, -0.07248209f, 0.00797308f, -0.00227738f, -0.06388580f, 0.09243586f, -0.21731402f, 
    -0.37499043f, 0.14917186f, -0.03216467f, -0.04989779f, -0.01242219f, 0.09213544f, 0.04933549f, -0.07790361f, 
    0.06318447f, -0.13643576f, 0.33533192f, 0.03583213f, -0.44121689f, 0.20450230f, 0.15050852f, -0.05349473f, 
    -0.17337200f, -0.04728565f, -0.11813696f, 0.13396862f, 0.02223489f, 0.23555598f, 0.05714341f, -0.00993631f, 
    -0.00880813f, 0.08842488f, 0.10058183f, -0.22187151f, 0.09086686f, -0.04521500f, 0.06764808f, -0.02025254f, 
    0.00295477f, 0.06685428f, -0.14986356f, 0.15848988f, 0.24086158f, -0.10308969f, -0.12076487f, -0.03399525f, 
    -0.17457919f, 0.06932672f, 0.00699047f, 0.10722107f, 0.02741016f, 0.09186935f, -0.03947809f, 0.16029404f, 
    0.10105652f, 0.20656033f, -0.08047263f, -0.11138011f, -0.01024676f, 0.00966730f, -0.10467051f, 0.13764615f, 
    -0.08167015f, 0.03866440f, -0.06375603f, -0.07368212f, 0.07095692f, -0.01943432f, -0.13239485f, -0.06303959f, 
    -0.04048614f, 0.06635392f, 0.10165473f, 0.04182203f, -0.01403449f, 0.01389081f, -0.02784757f, -0.02320972f, 
    0.13935246f, 0.09088290f, -0.01988403f, -0.13858970f, 0.01558797f, 0.06662570f, -0.06224895f, 0.22159140f, 
    -0.05826175f, 0.11912705f, -0.16674055f, -0.05939976f, 0.02053640f, 0.00542146f, -0.07939272f, 0.17144313f, 
    0.00813318f, 0.09169488f, 0.01354811f, 0.13353270f, -0.00706369f, -0.00035597f, 0.04996136f, 0.10031040f, 
    -0.21453062f, -0.12860985f, 0.15388817f, 0.11866617f, 0.04986409f, -0.09808873f, -0.00811272f, -0.06909202f, 
    -0.02431412f, 0.03807518f, -0.01868140f, -0.00442414f, 0.31260991f, -0.01060278f, -0.14826176f, -0.10433766f, 
    0.11969930f, 0.04488602f, -0.05737165f, -0.04164635f, -0.09332847f, 0.01114648f, -0.10872551f, -0.06398300f, 
    -0.07245515f, -0.07398812f, 0.06539903f, -0.12535937f, 0.04844566f, -0.15230256f, 0.03664143f, 0.08592428f, 
    0.00216478f, 0.06506649f, -0.04825052f, 0.06713423f, -0.32403654f, 0.05366981f, 0.10975563f, 0.11667800f, 
    -0.11175109f, 0.12672250f, 0.02540687f, -0.02523798f, -0.00336353f, -0.01294169f, -0.00037205f, -0.02211588f, 
    0.10295061f, -0.54152477f, 0.28402910f, -0.61365527f, -0.11523172f, 0.06875497f, -0.00587132f, 0.04425174f, 
    -0.06024880f, -0.01371939f, -0.23040310f, -0.07523480f, -0.30980143f, 0.26318198f, -0.09602614f, 0.37535924f, 
    -0.15889743f, 0.12241606f, -0.09533829f, -0.11581376f, -0.11075310f, -0.05120210f, -0.02373673f, -0.00193743f, 
    -0.51153588f, -0.08867488f, 0.19393110f, 0.52717417f, 0.00280154f, -0.07425766f, -0.06639763f, -0.03833554f, 
    0.02244167f, -0.05169939f, 0.06697957f, -0.11865409f, -0.33514577f, 0.23188154f, -0.12427729f, 0.02766375f, 
    -0.06051179f, 0.01333587f, 0.01249810f, 0.00341618f, 0.04579046f, 0.07658348f, 0.00840619f, -0.06615470f, 
    -0.11261924f, 0.07151282f, -0.05772137f, 0.07846670f, -0.01429036f, -0.04077612f, 0.08522532f, 0.09538361f, 
    0.04732081f, -0.01831546f, 0.06627446f, 0.04169211f, 0.13915202f, 0.18140586f, -0.03793480f, 0.01281582f, 
    0.06421836f, -0.21261033f, 0.04545478f, 0.00212781f, 0.00611209f, 0.10917857f, 0.02166890f, 0.07797593f, 
    0.59305614f, -0.54852116f, 0.03275730f, -0.42904156f, -0.16416018f, -0.17535928f, -0.17409076f, 0.17571793f, 
    0.09621808f, 0.10780827f, -0.00474737f, 0.01609770f, -0.26148632f, -0.43012041f, 0.01300198f, -0.26122907f, 
    0.05102385f, -0.05237459f, -0.06363234f, 0.31994614f, 0.04982446f, 0.02515837f, -0.04343845f, -0.06536548f, 
    -0.39209145f, 0.05850593f, -0.27314278f, 0.25716659f, -0.03532765f, -0.21167681f, 0.10696302f, -0.09948899f, 
    0.06235132f, 0.16445473f, 0.16497305f, 0.10926294f, -0.40542361f, -0.17697278f, -0.18860090f, -0.09416385f, 
    -0.04598920f, -0.22488360f, 0.13457377f, 0.00611807f, -0.18764174f, 0.01254657f, -0.06088587f, 0.03204107f, 
    0.33089703f, -0.22738072f, 0.03777209f, 0.22238833f, -0.17478243f, 0.11085620f, -0.01643179f, -0.04495489f, 
    -0.12294392f, 0.06150876f, -0.10881792f, -0.09314142f, 0.39448309f, 0.03211958f, -0.12619579f, 0.04694194f, 
    0.03162149f, -0.12053865f, -0.05062228f, -0.19892479f, 0.11132763f, 0.03697521f, 0.15814567f, -0.05573109f, 
    -0.19205220f, -0.09741187f, -0.00158585f, 0.16561961f, 0.01454623f, -0.01306812f, -0.11027291f, -0.06156227f, 
    0.00831530f, -0.00084428f, 0.01856087f, 0.00673400f, -0.11480180f, 0.17607652f, 0.07752606f, -0.10124877f, 
    -0.08198082f, -0.13873477f, -0.03562903f, 0.09328260f, 0.01050264f, -0.04666922f, 0.02844830f, 0.05160124f, 
    0.10087827f, 0.06990397f, -0.40626958f, -0.07019158f, -0.00633063f, -0.00384109f, -0.00219092f, 0.04236302f, 
    -0.15480666f, 0.00264300f, -0.14772826f, -0.11033458f, -0.03119702f, 0.09511223f, 0.05682981f, -0.15594214f, 
    -0.00008977f, 0.04941101f, 0.04392183f, 0.01872152f, -0.06739558f, -0.04224254f, 0.00636467f, -0.03274958f, 
    -0.10917310f, -0.07951444f, 0.04965108f, -0.08000204f, -0.07611782f, 0.07994446f, 0.06655959f, -0.08995929f, 
    0.02873667f, 0.01737846f, -0.11768051f, -0.13828970f, -0.71760654f, 0.65154743f, -0.49864319f, 0.10170630f, 
    0.10278517f, -0.05254709f, 0.08517275f, 0.01249004f, 0.04604805f, -0.00952881f, 0.04336068f, 0.00989680f, 
    0.15530606f, 0.02914278f, 0.06589789f, -0.10429171f, 0.02096208f, -0.02309933f, 0.08227050f, 0.02303083f, 
    0.08662861f, 0.06684788f, 0.03266215f, -0.07725377f, 0.06036214f, -0.13663328f, 0.09978064f, -0.09393467f, 
    0.02005467f, -0.06413269f, -0.08223417f, -0.08412229f, -0.10467518f, -0.10353086f, 0.15661485f, 0.03950322f, 
    0.23252241f, 0.00288390f, -0.02613303f, -0.30843028f, 0.02053106f, -0.02744997f, 0.14482485f, 0.04841254f, 
    -0.04017592f, -0.01912989f, 0.14927728f, -0.04858230f, -0.26646599f, -0.44266832f, -0.46868461f, -0.37226754f, 
    0.02273780f, 0.02138421f, 0.12824775f, 0.10210993f, 0.05522082f, -0.06293758f, -0.01833059f, 0.07224464f, 
    0.07084230f, -0.19014159f, 0.00026356f, -0.23029785f, -0.39611369f, -0.07913681f, 0.03151660f, 0.07452597f, 
    -0.15138400f, 0.08046371f, 0.08265629f, -0.16100834f, -0.32696316f, -0.21382365f, 0.10730594f, 0.03967958f, 
    0.03574141f, -0.03581323f, 0.12084736f, 0.22989419f, -0.10848388f, -0.14339076f, -0.13234666f, -0.00650346f, 
    -0.45434782f, -0.30047280f, -0.04203067f, -0.04000051f, -0.03598601f, 0.05412135f, 0.11545359f, 0.05577367f, 
    0.06469297f, -0.03864208f, -0.00640638f, 0.00771496f, 0.11516533f, -0.12668531f, 0.00785345f, 0.03660997f, 
    0.17449117f, 0.02673723f, 0.10984948f, 0.01204037f, 0.05906469f, 0.11244246f, 0.11512293f, 0.02633214f, 
    -0.07270621f, 0.11879297f, -0.06103700f, -0.00394519f, 0.03341030f, -0.09256410f, 0.06323132f, -0.01494897f, 
    -0.08025021f, -0.12201731f, -0.02346568f, 0.02961282f, -0.04235862f, 0.02563010f, -0.11324408f, 0.01977591f, 
    -0.02316729f, 0.00669824f, -0.03507377f, -0.07881787f, 0.03616409f, 0.03764027f, -0.08526950f, -0.13297909f, 
    0.12995084f, 0.02832130f, -0.04992824f, -0.13971256f, -0.01093351f, 0.02473072f, 0.07693989f, -0.03583055f, 
    -0.15632814f, -0.07479842f, -0.13883030f, -0.22625123f, 0.26428404f, -0.32732072f, 0.20007457f, -0.15261425f, 
    -0.00812531f, 0.01186743f, -0.02927080f, -0.00231383f, 0.02152063f, 0.05228058f, -0.04231221f, -0.03474182f, 
    0.03002445f, -0.27899411f, -0.32009593f, -0.19316702f, 0.01468491f, -0.04907346f, 0.08047345f, 0.19712150f, 
    0.08676186f, -0.00333678f, -0.11146344f, 0.04572412f, -0.04598626f, 0.06239942f, -0.04204914f, 0.00554756f, 
    0.04526656f, 0.02961347f, -0.01801541f, -0.08902081f, -0.08857016f, -0.01287525f, -0.06789018f, 0.03396796f, 
    0.06005730f, 0.02102270f, 0.00855201f, -0.08961949f, -0.02784009f, 0.01871604f, -0.00934051f, 0.03152013f, 
    0.13469122f, -0.02147252f, 0.10797075f, 0.11189235f, 0.32633820f, -0.06409374f, 0.03707318f, -0.36893553f, 
    0.08801369f, -0.01769812f, -0.06232934f, -0.07290001f, -0.03040528f, 0.07690498f, -0.02100456f, 0.00350685f, 
    -0.39339086f, 0.24372452f, -0.08611105f, -0.11550429f, -0.02580653f, -0.10015785f, -0.25556308f, 0.20276470f, 
    0.00411729f, -0.02152364f, -0.04998967f, -0.03789082f, 0.05029682f, -0.02599204f, -0.04506315f, 0.01569659f, 
    -0.19017309f, 0.15195973f, 0.07947887f, 0.03133551f, -0.00140727f, 0.05341245f, -0.04451505f, 0.05874378f, 
    0.34616271f, -0.20407756f, -0.03047537f, -0.18153858f, 0.13811916f, -0.07328618f, 0.06335175f, 0.03804068f, 
    -0.02103680f, 0.07404231f, -0.02244988f, -0.11057255f, -0.09886578f, -0.05231070f, -0.15258850f, 0.14914918f, 
    -0.04450946f, 0.00482676f, 0.00513253f, 0.09519385f, -0.02567876f, 0.05703118f, -0.04220017f, 0.13164578f, 
    0.18339150f, -0.12892275f, 0.22922161f, -0.39581305f, -0.06249502f, 0.00751462f, -0.07486279f, 0.07571869f, 
    -0.10494670f, 0.10486498f, -0.06110832f, -0.05724409f, 0.54154307f, -0.32369661f, -0.30441454f, -0.27523643f, 
    -0.08843036f, 0.00577111f, -0.08149567f, 0.12731388f, 0.09866682f, 0.00290356f, 0.07653167f, 0.00225729f, 
    0.03668686f, 0.08812922f, 0.00408477f, -0.13047974f, -0.08900992f, -0.00751221f, 0.03593472f, 0.04050348f, 
    -0.02411457f, 0.05920939f, 0.07957053f, -0.01518690f, -0.28237003f, 0.06842244f, -0.25902143f, 0.08943325f, 
    0.06164597f, -0.00946341f, 0.05296139f, 0.00065117f, -0.07811523f, 0.05296123f, 0.08950706f, 0.07424071f, 
    -0.47595343f, -0.05437031f, 0.11517175f, 0.36223316f, -0.04760917f, -0.02235002f, -0.03379929f, -0.00794994f, 
    -0.01049265f, -0.08587445f, 0.02765939f, 0.00458409f, -0.03085124f, 0.14613393f, -0.03234515f, -0.09520756f, 
    -0.00996899f, -0.14079039f, -0.09493365f, 0.01759109f, 0.01054050f, 0.04611318f, 0.05081765f, 0.02557381f, 
    0.26138222f, -0.04781925f, -0.10078896f, -0.12936939f, -0.00247783f, -0.06743994f, -0.12622392f, 0.00717920f, 
    -0.10381867f, -0.05554855f, -0.02023252f, 0.00778652f, 0.07762209f, -0.12086751f, -0.08878435f, -0.05520055f, 
    0.08245704f, -0.03656049f, 0.02511569f, 0.15125465f, 0.05083204f, 0.04631133f, -0.06348273f, 0.02132717f, 
    -0.05397010f, -0.00225714f, 0.01543367f, -0.02047254f, -0.08904752f, -0.01259342f, -0.01633593f, -0.02869346f, 
    -0.05852346f, 0.02382421f, -0.03768653f, -0.04260780f, 0.04901064f, -0.15686093f, -0.09210806f, -0.19318311f, 
    -0.01486517f, -0.00973228f, -0.05541779f, -0.05651992f, -0.11435297f, -0.14835709f, -0.08691869f, -0.04288635f, 
    0.04857278f, 0.54537374f, -0.22199878f, 0.10966635f, -0.00262573f, 0.10984571f, 0.07042612f, -0.01307692f, 
    -0.07319786f, -0.00450365f, 0.00972926f, 0.05477901f, -0.28132555f, -0.26327151f, -0.00863729f, 0.14301002f, 
    0.19234428f, -0.09006528f, -0.01463558f, 0.10156360f, 0.04493034f, 0.04290247f, -0.04321321f, -0.01003352f, 
    -0.46463984f, 0.14751686f, 0.08554336f, 0.12876490f, 0.16097291f, -0.00477299f, 0.11915559f, -0.02330195f, 
    0.00934935f, -0.03887312f, 0.05132005f, 0.02995972f, -0.34530148f, -0.00955771f, -0.52160627f, -0.16490404f, 
    -0.03146975f, 0.03987134f, 0.19274268f, 0.01838773f, 0.07253509f, 0.01522548f, -0.02550382f, -0.04299565f, 
    0.09307928f, -0.01593945f, 0.00485651f, 0.11522814f, -0.03424936f, -0.05398557f, -0.03391376f, 0.07286326f, 
    0.02767351f, 0.02510303f, 0.11417469f, 0.02881829f, 0.63900965f, -0.47047147f, -0.23463380f, -0.46306735f, 
    0.07971974f, 0.00912798f, -0.05137670f, -0.05870269f, 0.00047363f, 0.19069934f, 0.08753037f, -0.02731710f, 
    -0.01168585f, 0.02335694f, -0.06110449f, 0.05676966f, 0.02288311f, 0.05064599f, -0.02213158f, -0.08855068f, 
    -0.07993809f, 0.05656688f, 0.09192000f, -0.11384165f, 0.00033192f, -0.05779800f, -0.12409568f, 0.18943164f, 
    -0.00466628f, 0.16710417f, -0.00602418f, -0.07689540f, 0.09574403f, -0.04185169f, 0.00608929f, 0.11899368f, 
    -0.15581945f, -0.03033680f, 0.10452171f, -0.00059447f, 0.00683101f, 0.08297731f, 0.07333818f, -0.06388853f, 
    -0.00538182f, -0.06489416f, 0.02699964f, -0.11484789f, 0.00293417f, 0.08344620f, 0.02159306f, -0.06181958f, 
    0.02014068f, -0.05412013f, -0.01920262f, -0.07644781f, 0.02528799f, 0.10664643f, 0.02268996f, 0.08123805f, 
    0.01545965f, -0.00431024f, 0.09589559f, -0.03465293f, -0.06282806f, -0.07829090f, -0.05864678f, -0.01056077f, 
    -0.04162236f, -0.12620975f, -0.11022282f, -0.03617231f, 0.05502023f, 0.03695409f, 0.08496594f, -0.05054968f, 
    0.09845315f, 0.04567343f, -0.09244041f, -0.06113812f, -0.03210945f, 0.01351132f, 0.00927016f, 0.05429944f, 
    -0.39735076f, -0.07042514f, 0.07924276f, 0.06618947f, 0.16928628f, 0.03557068f, 0.07491621f, -0.08457913f, 
    -0.05613745f, 0.00719145f, 0.19068430f, 0.15519093f, 0.07278875f, 0.05940626f, -0.16131447f, -0.13440749f, 
    -0.08003287f, -0.08192566f, 0.04367558f, 0.01069127f, 0.06610097f, 0.05736795f, 0.10073447f, -0.03446833f, 
    0.21199657f, -0.04979889f, -0.00458917f, -0.01841312f, -0.05357262f, 0.08733175f, 0.09086632f, 0.08941969f, 
    -0.07679570f, -0.10430685f, 0.02710149f, -0.11648255f, -0.39068660f, -0.00570658f, 0.12008873f, 0.17885809f, 
    0.07349369f, 0.10888226f, -0.12471385f, 0.04337640f, -0.04952852f, 0.11068691f, 0.14858645f, 0.08445928f, 
    0.06918718f, -0.37442115f, -0.43533427f, 0.09440301f, 0.10681937f, -0.06459028f, 0.07416262f, -0.04770184f, 
    0.09816989f, 0.00492999f, 0.06235033f, 0.17803714f, 0.11736515f, -0.05066397f, -0.03594887f, -0.14414822f, 
    0.27362505f, -0.04532494f, 0.04796116f, 0.16953918f, 0.10994216f, 0.10030209f, 0.15500070f, 0.24061523f, 
    -0.00325826f, -0.24238564f, -0.21788125f, -0.04664880f, 0.06210923f, 0.02180471f, -0.02054259f, 0.09812145f, 
    0.05933443f, 0.16201195f, 0.11482119f, 0.13659054f, -0.26506653f, 0.06597897f, 0.03122041f, -0.11951912f, 
    -0.03049700f, 0.03348995f, -0.09989396f, 0.11254867f, -0.07186142f, 0.07286101f, 0.03974552f, 0.04608198f, 
    -0.15606532f, -0.02281515f, 0.11389076f, -0.02132464f, 0.01264236f, -0.02856952f, -0.13229653f, -0.05201120f, 
    0.00325478f, 0.01718963f, 0.05330347f, -0.08740102f, -0.04899804f, -0.21667852f, -0.23442954f, -0.17183761f, 
    -0.01571085f, 0.15426660f, 0.14791539f, 0.14606610f, 0.07501918f, 0.09055565f, 0.05638089f, 0.03505148f, 
    -0.34251454f, -0.38825032f, -0.22871909f, -0.22522603f, -0.01120611f, 0.21705686f, 0.18768959f, 0.10868776f, 
    -0.01674838f, 0.01561917f, 0.01805509f, 0.04963934f, 0.05423464f, -0.15325588f, -0.33455753f, -0.04459711f, 
    0.03678675f, 0.06782097f, 0.03821100f, -0.23004545f, 0.01943906f, -0.02468284f, 0.04282553f, 0.12158763f, 
    -0.06731696f, -0.29787773f, 0.10985032f, 0.09790866f, -0.01795010f, 0.01497036f, 0.05111666f, -0.10563220f, 
    -0.16921028f, -0.02203441f, -0.07877477f, -0.45960185f, 0.27171764f, -0.50653839f, -0.16397725f, 0.01957077f, 
    -0.04568189f, 0.10468353f, 0.05471113f, 0.03901289f, -0.04038130f, -0.06495479f, 0.05077432f, -0.03388117f, 
    0.53328884f, 0.13098088f, -0.23322430f, -0.25740063f, 0.06015044f, -0.14718044f, 0.03079379f, -0.11016596f, 
    0.18330337f, 0.07312530f, 0.19633660f, 0.09867275f, 0.14260480f, -0.07975355f, -0.11683184f, -0.27931467f, 
    -0.01270692f, -0.00710880f, 0.03793792f, 0.05756478f, 0.02108890f, 0.13729309f, -0.10176565f, -0.36776480f, 
    0.14222538f, 0.05272129f, 0.02517961f, -0.00812772f, 0.07206892f, -0.08912820f, 0.01267753f, 0.03284511f, 
    0.01483776f, -0.02633481f, 0.07466213f, -0.01732007f, -0.39198941f, 0.05221279f, 0.13247627f, 0.08301856f, 
    -0.09766411f, -0.08175140f, 0.10358064f, 0.01610016f, 0.15979132f, 0.06020749f, 0.08193206f, 0.09875729f, 
    -0.07406896f, -0.07158118f, -0.10698099f, -0.13819847f, -0.17207126f, 0.01635103f, 0.04073481f, -0.04990485f, 
    0.00709539f, 0.10467960f, -0.01366989f, 0.10344999f, -0.12088313f, -0.06956668f, -0.04443189f, -0.01488828f, 
    -0.11338443f, -0.09584008f, -0.00350341f, 0.05471980f, 0.16532382f, 0.02651117f, 0.04401896f, 0.10160810f, 
    -0.17309688f, -0.21919866f, -0.06481169f, -0.04651740f, 0.07798170f, 0.16303858f, 0.22500657f, 0.01579271f, 
    -0.07409075f, 0.09128596f, -0.21164048f, -0.24128050f, -0.84033173f, 0.06898115f, 0.16425578f, 0.36698553f, 
    0.04480506f, 0.04830756f, -0.13104936f, -0.07074273f, -0.06597041f, -0.08528724f, -0.02288089f, -0.01490037f, 
    -0.14930117f, -0.00002433f, 0.01331154f, -0.14132708f, -0.23960599f, -0.01472268f, -0.07271452f, -0.04666891f, 
    0.07811241f, -0.01177765f, 0.00445021f, 0.22357911f, -0.15733618f, -0.03658042f, 0.12555140f, -0.20856774f, 
    -0.01159630f, 0.02419520f, 0.07139301f, -0.23898447f, -0.14652598f, 0.00448017f, -0.18640956f, -0.09480268f, 
    -0.12190355f, -0.22064464f, -0.01409073f, -0.05012681f, -0.11641175f, -0.03913064f, -0.03746954f, -0.09160013f, 
    0.11242812f, 0.16344747f, 0.11024063f, 0.08660291f, -0.03785887f, -0.53317964f, -0.23718187f, 0.08399740f, 
    0.04561231f, 0.05296499f, 0.06689483f, 0.03542061f, -0.03059412f, -0.00048321f, -0.01129454f, -0.19532305f, 
    0.36618379f, 0.40442541f, -0.20398709f, -0.22784677f, -0.10540711f, -0.16818647f, -0.01720513f, 0.06634688f, 
    0.19594003f, -0.08644013f, 0.06651643f, 0.15994897f, 0.07747730f, -0.14258112f, -0.44211039f, -0.38222757f, 
    -0.25279352f, -0.16756500f, 0.03469084f, -0.20765874f, -0.04224313f, -0.03958796f, -0.00695804f, -0.01051125f, 
    -0.08139899f, -0.68723917f, -0.31360978f, 0.03518019f, 0.03998905f, -0.10662188f, -0.17870483f, -0.21027268f, 
    -0.03072579f, 0.05993798f, 0.01048445f, 0.12723522f, 0.04500658f, -0.09743042f, -0.05457709f, -0.12833108f, 
    -0.10041639f, -0.02175440f, -0.07702489f, 0.02955732f, -0.12781596f, -0.15904151f, 0.00104111f, -0.11393646f, 
    -0.04478209f, -0.10299572f, -0.02479237f, 0.11149075f, -0.02612079f, 0.12694758f, -0.13020521f, 0.11756747f, 
    -0.08433916f, -0.06145792f, -0.17224190f, -0.06424014f, -0.13940439f, 0.12067743f, -0.02674183f, -0.09794980f, 
    0.03853473f, -0.01119243f, 0.05163332f, 0.03074440f, 0.03254788f, -0.07468046f, 0.03635726f, 0.19795319f, 
    0.05396987f, -0.02024165f, -0.13791443f, -0.19068472f, -0.05394253f, -0.00610352f, 0.00942316f, -0.02199179f, 
    0.11587285f, 0.07687435f, 0.00182848f, 0.11109412f, 0.11769506f, 0.05359975f, -0.03938580f, -0.07492001f, 
    0.13762829f, -0.13026969f, -0.01401974f, -0.06878769f, -0.04928905f, 0.07818207f, 0.06646881f, 0.15524803f, 
    -0.06659235f, -0.22834696f, -0.46788833f, -0.14416701f, -0.05121677f, -0.11601637f, 0.04351339f, -0.04741941f, 
    -0.01952889f, -0.01845529f, -0.00358619f, -0.03384755f, 0.09379333f, -0.02849982f, 0.02017740f, 0.04185363f, 
    -0.10286167f, -0.10382815f, 0.04870705f, 0.01160094f, 0.04675417f, 0.13836686f, 0.11021253f, -0.03846892f, 
    -0.08392940f, 0.01362572f, -0.06051331f, -0.08713276f, 0.07314421f, 0.02539076f, 0.02171258f, -0.01640341f, 
    -0.33349255f, -0.04723078f, -0.22909120f, -0.35719121f, 0.15949535f, 0.10901091f, -0.08022285f, -0.31744218f, 
    0.01759099f, -0.02304488f, -0.01080753f, 0.05257177f, 0.09976865f, 0.01063228f, 0.01481030f, 0.08746210f, 
    0.07952134f, -0.12592493f, -0.04672124f, 0.17478244f, -0.01776066f, 0.10888932f, 0.10280771f, 0.26800475f, 
    0.10825567f, -0.17239228f, 0.06497947f, -0.01286094f, -0.12077995f, -0.09408136f, 0.06061193f, 0.07912453f, 
    -0.04143852f, 0.01653360f, -0.05977913f, 0.02086970f, 0.02029109f, 0.06224775f, 0.22381373f, 0.08282132f, 
    0.19960570f, -0.14331944f, -0.23921888f, -0.14751910f, -0.00307717f, -0.02150880f, 0.14424743f, 0.02563552f, 
    0.06369416f, -0.05102132f, -0.08349007f, -0.05577091f, -0.35273790f, -0.20143303f, 0.18019143f, 0.09348704f, 
    -0.00319428f, 0.03729589f, -0.05137715f, -0.02985013f, -0.01180670f, 0.05468605f, -0.14832102f, -0.08232410f, 
    0.35833076f, 0.11994625f, -0.01348021f, -0.36676461f, 0.09348564f, -0.02140163f, 0.06356300f, -0.15955091f, 
    0.01644868f, 0.11310937f, 0.09876022f, -0.16024959f, -0.35865843f, -0.43989292f, -0.44507673f, 0.09895629f, 
    0.00815383f, 0.09917853f, 0.22415031f, 0.06267978f, -0.05334014f, -0.06367336f, 0.00929357f, 0.00846093f, 
    -0.24703346f, 0.01415492f, 0.10208560f, 0.05381104f, -0.03122947f, 0.05127245f, 0.02109372f, -0.04660103f, 
    -0.05309602f, -0.08851406f, 0.10199209f, -0.02911687f, 0.00233697f, -0.11715090f, -0.04702627f, 0.11045752f, 
    -0.05579520f, 0.00931189f, 0.10501312f, 0.09160712f, -0.28612697f, -0.19387415f, -0.02208908f, -0.09834374f, 
    0.21039720f, 0.13740729f, 0.14490432f, -0.15910919f, 0.11599158f, -0.16650158f, -0.06436887f, -0.08194526f, 
    -0.05534093f, 0.00950866f, -0.01518739f, 0.00297124f, -0.49206322f, 0.03259001f, 0.08400863f, 0.03299755f, 
    -0.13321503f, -0.04123028f, -0.07752396f, -0.13656537f, -0.15645173f, -0.01158205f, -0.09086150f, -0.06388921f, 
    -0.11924060f, -0.07169785f, -0.34954008f, -0.07742721f, -0.11742721f, 0.10307592f, 0.03849325f, 0.18835723f, 
    0.17755963f, -0.05534678f, 0.06752604f, -0.11350086f, 0.28939506f, 0.01498197f, -0.43133318f, 0.10082334f, 
    0.00766501f, -0.02932266f, 0.09755781f, -0.10231667f, 0.13818292f, -0.18441091f, -0.08589628f, -0.06296803f, 
    0.14261633f, 0.01639263f, -0.08305778f, 0.03047216f, 0.05859206f, -0.05876133f, -0.01287921f, -0.02116661f, 
    0.20081036f, 0.02548706f, 0.04189232f, 0.06784351f, -0.15063141f, -0.09485639f, -0.07274346f, 0.10532916f, 
    0.00782673f, 0.04891749f, 0.01649982f, 0.05380048f, 0.02443884f, 0.04996802f, 0.05162656f, 0.03005361f, 
    -0.46580982f, -0.19041722f, 0.03065636f, 0.25154278f, 0.16682583f, 0.12278218f, -0.08868441f, 0.16477644f, 
    0.16686916f, 0.06890131f, -0.04575147f, 0.05699227f, -0.03060509f, -0.21791908f, -0.18147238f, 0.13674076f, 
    -0.05291894f, 0.02481285f, -0.07366250f, -0.03247545f, -0.03186474f, -0.01820661f, 0.05493259f, 0.13404737f, 
    -0.44146925f, -0.22558102f, 0.02142902f, 0.10125020f, -0.09653267f, 0.06034454f, 0.04761846f, 0.02051114f, 
    0.07852698f, -0.01122422f, 0.02136698f, 0.08680956f, -0.06979955f, -0.35046738f, -0.02800418f, 0.34295952f, 
    0.02926378f, 0.11467859f, 0.10622859f, 0.11122281f, -0.09617011f, -0.03559357f, 0.01436072f, 0.02936820f, 
    0.08426028f, -0.05859357f, 0.07642809f, -0.00728155f, 0.05926931f, 0.08431628f, 0.06601092f, 0.08006456f, 
    0.01541248f, -0.06269137f, -0.21653853f, -0.30469736f, 0.05062233f, -0.37244621f, -0.31937715f, -0.36023924f, 
    0.10894099f, 0.02603982f, 0.14129022f, 0.04318032f, 0.08949405f, -0.11540437f, -0.06604631f, -0.01453554f, 
    0.03592698f, 0.08798528f, 0.21044333f, -0.02493317f, -0.01041299f, -0.08427902f, -0.05380422f, -0.04228296f, 
    0.07582141f, 0.00791137f, -0.00707192f, 0.03524510f, -0.09241044f, 0.00154942f, -0.04309501f, 0.02655646f, 
    0.13714883f, 0.00082720f, -0.00546066f, 0.19028652f, -0.16955020f, -0.05591980f, -0.02463000f, -0.36696473f, 
    0.08531772f, 0.33335766f, -0.01461261f, -0.08396050f, 0.00808225f, 0.03435454f, -0.02546642f, -0.02912849f, 
    -0.07213401f, 0.02288917f, -0.03340577f, 0.13141240f, -0.06656928f, 0.03867772f, -0.06718436f, 0.01675780f, 
    -0.01236486f, 0.00278009f, 0.05080131f, -0.03501839f, -0.13703893f, -0.05568623f, -0.11171928f, -0.12496544f, 
    -0.18124546f, 0.04104469f, 0.03590518f, -0.05014617f, -0.01801067f, -0.15191628f, -0.00512636f, 0.03057789f, 
    0.12677024f, 0.07019061f, -0.02291756f, 0.03261339f, 0.15315467f, 0.09104982f, 0.03255617f, -0.20668226f, 
    -0.02029694f, -0.07817353f, -0.05763833f, 0.01071753f, -0.03608233f, -0.01197330f, -0.03489316f, -0.05098836f, 
    -0.11687964f, 0.06325950f, 0.00519949f, -0.50032282f, -0.09349540f, -0.07161124f, 0.12220350f, -0.12282784f, 
    -0.00054257f, 0.00198378f, -0.05671986f, -0.06667602f, -0.33009470f, 0.21758163f, 0.07188974f, 0.22922423f, 
    0.02561305f, 0.00223282f, -0.23347488f, 0.04111781f, -0.00054153f, -0.05668413f, -0.15452613f, 0.01060415f, 
    -0.02477103f, 0.04525587f, 0.05166950f, 0.06953638f, 0.03393977f, -0.08703375f, -0.08155317f, 0.02139091f, 
    -0.00802318f, -0.05472731f, 0.01396663f, 0.03991918f, -0.11228346f, 0.49358228f, -0.38256094f, -0.57960516f, 
    -0.08963727f, 0.13918558f, 0.03054124f, -0.08273083f, 0.18364444f, -0.14213689f, -0.05471990f, 0.08988072f, 
    0.48268333f, -0.23468646f, 0.45956334f, -0.34002957f, -0.01153104f, -0.16983365f, -0.18597183f, -0.15080522f, 
    -0.06546088f, 0.15167256f, -0.05896216f, 0.13303730f, -0.13560617f, 0.00184718f, 0.00449001f, -0.15302858f, 
    0.14457135f, -0.25228205f, 0.03919939f, 0.10252219f, 0.08463860f, 0.03203813f, -0.02729793f, -0.04448599f, 
    -0.09602920f, -0.04045132f, -0.10761231f, -0.02812152f, -0.03811679f, -0.17322038f, 0.00468278f, 0.15197247f, 
    0.09204879f, 0.09048900f, -0.05966315f, -0.03457447f, -0.14930543f, 0.22411393f, -0.15035973f, -0.29303092f, 
    0.08056775f, -0.14102979f, 0.10677835f, 0.03402388f, 0.14194570f, -0.07505647f, -0.08791636f, -0.07312164f, 
    0.11477569f, 0.29405448f, -0.27973935f, -0.08683001f, 0.05970819f, 0.07053433f, 0.13632302f, 0.00046587f, 
    0.11173265f, -0.05583147f, -0.20150836f, -0.07823552f, 0.04950876f, 0.07605284f, 0.08379956f, 0.02805325f, 
    0.15745555f, -0.03512849f, -0.23476627f, 0.17128855f, -0.04167319f, -0.19930646f, 0.05174122f, -0.01372078f, 
    0.15175650f, -0.04296101f, -0.09008926f, 0.23472789f, -0.07779530f, 0.06746397f, -0.06075203f, -0.04793401f, 
    -0.02216649f, -0.00441461f, -0.03716034f, -0.02847716f, -0.09139757f, -0.29833990f, 0.20002311f, -0.18797554f, 
    -0.06989840f, 0.02366775f, -0.22163735f, 0.05303595f, 0.10602555f, -0.00863601f, 0.01823227f, 0.03691603f, 
    0.22706769f, -0.08439464f, 0.28036895f, -0.18502732f, 0.10478508f, -0.15851408f, -0.06134837f, 0.01398410f, 
    -0.10631062f, 0.12316849f, 0.01376075f, 0.07004008f, -0.01985232f, -0.04734857f, 0.56755584f, -0.53259563f, 
    0.15857539f, -0.47449201f, -0.05907922f, -0.01306772f, -0.07363404f, -0.06592033f, 0.05278828f, 0.09865522f, 
    -0.35090017f, -0.22166732f, 0.00687648f, 0.13902399f, 0.14615458f, 0.10786827f, -0.03743792f, -0.04177894f, 
    -0.09138938f, -0.04628832f, 0.12939662f, -0.06312998f, -0.31750056f, 0.04316075f, 0.18474786f, 0.34340447f, 
    0.07244148f, 0.04450392f, -0.06654909f, -0.11019656f, 0.02160989f, 0.10126886f, 0.13807036f, 0.08138636f, 
    0.19717272f, 0.24881227f, -0.24644735f, -0.12453821f, -0.02580374f, -0.05079057f, 0.06786821f, 0.03620936f, 
    0.04178947f, -0.04966154f, -0.03637002f, -0.02023637f, 0.12278221f, -0.10956407f, -0.00390585f, -0.23791216f, 
    0.06006442f, 0.00395192f, 0.00017771f, 0.03414710f, -0.02579818f, 0.03509723f, -0.09868766f, -0.07969784f, 
    -0.15846735f, 0.06491943f, 0.28738111f, 0.34825140f, -0.00045647f, -0.06385244f, -0.10829129f, -0.02337143f, 
    0.06720371f, -0.04902727f, 0.04904797f, 0.08308224f, 0.14165023f, -0.23119640f, -0.02091695f, -0.06083594f, 
    0.03982798f, 0.11078197f, 0.04987944f, 0.07707325f, 0.15305489f, 0.12800166f, 0.15569474f, 0.01649796f, 
    0.03765922f, 0.10430647f, 0.17035682f, -0.05267052f, -0.10161392f, -0.04620720f, -0.04160984f, -0.20701833f, 
    0.15568189f, 0.09321211f, 0.02430317f, 0.08536077f, -0.30675012f, 0.14440684f, -0.58681524f, 0.15658221f, 
    0.07819183f, -0.06019744f, 0.14463376f, 0.11441035f, -0.05354289f, 0.04272629f, -0.00067580f, 0.05970171f, 
    0.03271241f, -0.24082664f, 0.15632361f, -0.06539205f, 0.06144430f, 0.06532824f, -0.32788345f, -0.09671885f, 
    -0.09203090f, 0.00489267f, -0.05356528f, 0.02364544f, 0.12866950f, -0.23855284f, 0.00406412f, -0.14258803f, 
    -0.12531549f, 0.10578424f, -0.08438656f, 0.10243696f, 0.11274770f, -0.04233999f, 0.08622348f, 0.12969430f, 
    0.02960080f, 0.14278585f, 0.10740121f, 0.28747994f, 0.07419381f, 0.02591177f, -0.11125965f, 0.10285271f, 
    -0.06580222f, 0.02103844f, 0.04238995f, -0.05123369f, 0.08503937f, -0.12357275f, 0.22063078f, -0.23437525f, 
    -0.07462589f, -0.10720920f, 0.03560613f, -0.02918371f, -0.02397676f, 0.01918568f, 0.08666208f, -0.01522225f, 
    -0.73878455f, -0.40608305f, 0.03502238f, -0.21706276f, 0.08955847f, 0.15316637f, -0.45254520f, 0.25780001f, 
    -0.02205772f, -0.18426836f, -0.01843547f, -0.12729999f, -0.29614457f, 0.03229851f, 0.17367189f, -0.00123316f, 
    -0.09439781f, -0.02252252f, -0.02839608f, 0.15083450f, 0.07620756f, 0.10728546f, 0.09837224f, 0.02977560f, 
    -0.16434862f, -0.01738532f, 0.11658082f, -0.53099751f, -0.22459576f, -0.18661623f, -0.12808344f, 0.15176164f, 
    0.04921502f, -0.02126430f, 0.01044281f, -0.04139863f, 0.15610301f, -0.02262943f, 0.17545545f, 0.10964573f, 
    0.06932975f, 0.01845172f, -0.02964949f, 0.03337981f, 0.10761771f, 0.06611333f, 0.08860403f, -0.03494684f, 
    0.15950154f, 0.00904302f, 0.08379532f, -0.30037776f, -0.00595707f, -0.18861097f, 0.08448720f, 0.00797682f, 
    -0.02604546f, 0.10720119f, -0.02533180f, -0.02713086f, -0.12728266f, -0.00225062f, -0.09805143f, -0.12080228f, 
    0.06747616f, -0.08174562f, 0.03163678f, -0.00261631f, 0.01772889f, -0.06908272f, -0.08179563f, 0.04867578f, 
    -0.13561963f, 0.06753517f, 0.07781421f, 0.20121267f, 0.09961671f, -0.01355176f, -0.09126808f, -0.04646059f, 
    0.12284532f, 0.10997412f, 0.01573738f, 0.17271858f, 0.09716278f, -0.17324741f, 0.00198210f, 0.03795296f, 
    0.01441540f, 0.09438476f, -0.01566961f, -0.06297421f, 0.01800758f, -0.03851422f, -0.08783946f, -0.01546237f, 
    -0.06190620f, 0.09231465f, 0.07662506f, -0.20757659f, -0.13962844f, -0.18680856f, 0.01617662f, 0.02674661f, 
    0.02057810f, 0.05385863f, 0.04563374f, 0.01963232f, -0.04993762f, -0.02913373f, -0.05839060f, -0.16372222f, 
    0.07741041f, -0.15368809f, 0.04207878f, 0.02770283f, -0.04209380f, 0.14213397f, -0.06225356f, 0.11945139f, 
    -0.04158302f, 0.01495215f, 0.05734944f, 0.06755072f, 0.01902443f, 0.03536492f, 0.11108056f, -0.01977791f, 
    0.02070958f, 0.06677229f, 0.09145300f, 0.15941398f, -0.05883782f, 0.02937051f, -0.10549902f, 0.31962645f, 
    0.12759548f, -0.05754682f, -0.14437731f, -0.00232385f, 0.15362726f, -0.01424602f, 0.00986711f, 0.04693593f, 
    -0.28879383f, -0.02946660f, -0.17560558f, 0.12998921f, -0.03578648f, 0.07322516f, -0.17761002f, 0.10001343f, 
    0.18664111f, -0.11040914f, 0.00892893f, 0.05907908f, -0.01549324f, 0.20563056f, 0.09790993f, -0.11329404f, 
    -0.04100457f, -0.01082993f, 0.16117974f, -0.09939133f, 0.01175958f, 0.01396788f, -0.08186138f, -0.09524848f, 
    0.14052051f, -0.17451146f, 0.15600796f, 0.28572813f, 0.10980882f, -0.16274384f, -0.09346697f, 0.02833074f, 
    0.10728224f, -0.03464112f, -0.00194898f, 0.19092776f, 0.22440358f, 0.05213063f, 0.04066421f, -0.02827832f, 
    -0.04029818f, -0.16533782f, -0.10182138f, 0.02497591f, -0.01730768f, 0.06025654f, 0.03799526f, -0.00814008f, 
    -0.16395155f, -0.27756840f, -0.03580916f, -0.10217685f, -0.06813414f, 0.03963193f, -0.21557744f, -0.13069840f, 
    -0.05580619f, -0.02857332f, 0.06703813f, -0.10725521f, -0.25361753f, -0.02108978f, -0.23438303f, -0.43218371f, 
    -0.22906500f, -0.00358922f, -0.18213381f, -0.07637242f, 0.09670147f, -0.12664172f, 0.00851577f, 0.06587990f, 
    -0.06228070f, -0.10827114f, -0.00288864f, -0.23320702f, 0.04458233f, 0.06970726f, 0.05098473f, 0.06835999f, 
    -0.05732927f, -0.05200946f, -0.11708217f, 0.01095207f, -0.19818529f, 0.41094592f, 0.39255658f, -0.31205681f, 
    0.05290897f, -0.13835545f, -0.02769304f, 0.00955474f, -0.01280578f, 0.14454083f, 0.04491345f, 0.05275290f, 
    0.28417119f, 0.02482886f, -0.58872163f, 0.09891418f, -0.09046537f, 0.00615813f, 0.11367936f, 0.18106651f, 
    -0.00005815f, 0.05049697f, 0.04465122f, -0.00854316f, -0.16616653f, -0.17105941f, -0.07523230f, -0.12820989f, 
    0.03603030f, 0.16384287f, 0.15030548f, 0.11032970f, 0.01555502f, 0.06748161f, -0.05927898f, 0.03755488f, 
    -0.16972715f, 0.50260568f, 0.08597376f, 0.26792020f, -0.05357687f, -0.06597459f, -0.25881192f, -0.05065421f, 
    0.08288420f, -0.04895330f, 0.04187285f, 0.02107833f, -0.29476991f, -0.13227709f, 0.04346437f, 0.07582457f, 
    0.04149121f, -0.11285130f, -0.09890682f, 0.05087051f, 0.07170524f, 0.00394893f, -0.03108551f, 0.04481504f, 
    -0.22645113f, -0.06847042f, -0.13488191f, 0.09672958f, 0.17064324f, -0.01590384f, 0.00298255f, -0.00782539f, 
    0.01246959f, -0.09503717f, -0.01448530f, -0.19706894f, 0.19181626f, 0.06721044f, 0.31290254f, -0.26897493f, 
    0.07763738f, -0.12579033f, -0.09309785f, -0.14238952f, 0.01939742f, 0.00430648f, 0.09127150f, 0.06731321f, 
    -0.00441472f, -0.11737819f, 0.03740216f, -0.28003192f, -0.05013797f, -0.05827740f, -0.04276919f, 0.00271690f, 
    0.01784136f, 0.00992621f, -0.11145844f, -0.13068199f, -0.14127949f, -0.03459485f, -0.19212638f, -0.08081532f, 
    -0.17292100f, 0.03366411f, 0.02766668f, -0.00727268f, 0.05540030f, -0.07824715f, -0.02337243f, -0.00832043f, 
    0.21553634f, -0.12557419f, 0.15035151f, -0.49882159f, -0.00291431f, -0.04974486f, 0.04556366f, 0.23424339f, 
    -0.01947272f, 0.01425697f, -0.07175726f, 0.00498794f, -0.29637837f, -0.07924733f, -0.07182624f, -0.54064274f, 
    0.14704354f, -0.22029717f, 0.14870374f, -0.08194660f, 0.02453252f, -0.00008395f, 0.01519112f, 0.02504032f, 
    0.21555702f, -0.32958892f, 0.11438817f, -0.08279973f, -0.03230320f, -0.00062047f, -0.07967031f, 0.06921783f, 
    -0.00753191f, 0.00687069f, 0.05630956f, -0.00281674f, 0.31936705f, -0.00910644f, 0.28726158f, 0.38802767f, 
    -0.07713229f, -0.14734879f, -0.23260598f, -0.25710639f, 0.04636766f, -0.05074534f, 0.04903151f, 0.12323660f, 
    -0.06982271f, -0.14705391f, -0.08350499f, -0.12228076f, 0.11644432f, -0.01511055f, 0.06386916f, -0.03178541f, 
    -0.09499883f, -0.00459874f, -0.03003213f, 0.10215762f, -0.05046095f, 0.24963230f, -0.25735953f, -0.01607293f, 
    -0.02003207f, -0.14323415f, 0.02410979f, -0.03369362f, 0.06256867f, 0.04006447f, 0.07315742f, 0.18814375f, 
    -0.17351401f, -0.08581316f, -0.41663879f, 0.13118771f, 0.07849710f, -0.06893939f, 0.05140078f, -0.12070132f, 
    -0.04297708f, -0.07028646f, -0.02935496f, -0.02278290f, -0.14845239f, -0.16166188f, -0.18086161f, -0.03603341f, 
    0.11328483f, 0.19018155f, 0.13162610f, 0.00846208f, 0.06249459f, -0.07139862f, -0.06272685f, -0.01746000f, 
    0.03438767f, -0.09420264f, -0.19989517f, 0.03104922f, 0.02252972f, -0.07490656f, 0.06607062f, -0.00081648f, 
    0.09333654f, 0.00794009f, -0.10801144f, -0.17473292f, -0.07509046f, -0.22206387f, -0.13121764f, 0.03287907f, 
    -0.01837103f, -0.01793215f, 0.07144149f, -0.23089927f, -0.01121652f, -0.00963042f, -0.03324554f, 0.05282171f, 
    0.12833881f, 0.08973866f, -0.29263490f, 0.08017366f, -0.14955081f, 0.03165091f, 0.16679052f, -0.07766398f, 
    -0.06327956f, -0.01882853f, -0.09690792f, 0.02965503f, 0.17969789f, -0.16886663f, 0.45505145f, -0.39733934f, 
    -0.16701987f, -0.02750327f, -0.00078081f, 0.13134597f, -0.09908152f, -0.06262783f, 0.08321456f, -0.14164203f, 
    -0.10556012f, 0.06936258f, 0.02230529f, 0.06856085f, -0.01446830f, 0.14356315f, -0.06843167f, 0.03359367f, 
    0.06664243f, -0.01590695f, -0.10544976f, -0.23275675f, 0.15423059f, -0.03321014f, 0.39052039f, 0.07163524f, 
    -0.11833819f, -0.24088563f, 0.14286005f, 0.07168199f, -0.09844106f, -0.04358199f, 0.05209702f, 0.22065669f, 
    -0.30393845f, 0.29293904f, -0.39161488f, 0.30038077f, -0.02890050f, 0.06093402f, 0.01173332f, 0.03108163f, 
    -0.05929442f, -0.10195290f, 0.08770096f, -0.00387595f, 0.02649713f, 0.12221270f, 0.12235972f, 0.12324246f, 
    -0.06379651f, -0.07646096f, 0.04042551f, 0.03048818f, 0.05129166f, 0.00708218f, 0.01288268f, 0.22955914f, 
    -0.21175818f, -0.13097367f, 0.17140315f, -0.00816492f, -0.07828651f, -0.01640925f, 0.01856620f, -0.09582368f, 
    -0.01108660f, 0.10436456f, 0.13189827f, 0.07882457f, -0.10244453f, -0.07496505f, 0.43979108f, 0.01329239f, 
    -0.07167111f, -0.03076670f, 0.10571659f, 0.03603202f, -0.08366130f, 0.02233004f, 0.15784897f, 0.00860539f, 
    -0.25060534f, -0.40557134f, -0.01225635f, -0.11648124f, -0.06335379f, -0.00642646f, 0.09585399f, -0.20275314f, 
    -0.17146987f, -0.01580624f, -0.04939282f, 0.03000909f, 0.02936961f, 0.08002836f, 0.05626643f, -0.09816951f, 
    -0.12814105f, 0.08090661f, 0.09906614f, 0.20125152f, 0.11571608f, 0.13988145f, 0.16672488f, 0.09393590f, 
    -0.04230101f, 0.15497904f, -0.25022697f, 0.00977898f, -0.01908834f, -0.03520412f, 0.10808712f, 0.10565381f, 
    -0.02049258f, 0.13144699f, 0.01258469f, -0.02741192f, -0.30560198f, -0.24329074f, -0.07814988f, 0.05021531f, 
    -0.06640477f, -0.09617736f, -0.03147096f, -0.03453717f, -0.05132441f, -0.04339023f, 0.06147990f, 0.00209390f, 
    -0.00584980f, -0.06478007f, 0.08983429f, 0.08647549f, 0.04634881f, -0.00239291f, -0.04579492f, -0.00400843f, 
    -0.06630658f, 0.03710964f, -0.38465539f, -0.23996535f, -0.34684053f, 0.41402707f, 0.14507136f, 0.25546321f, 
    -0.03901329f, 0.12075485f, -0.07290025f, 0.24438286f, 0.06126835f, -0.07693869f, 0.03985044f, -0.06037198f, 
    -0.30203128f, -0.18992969f, 0.13051336f, -0.09081044f, -0.08043617f, 0.03405778f, -0.02024054f, 0.03295802f, 
    0.02092547f, 0.02665741f, 0.03232992f, 0.08126932f, 0.30351681f, -0.08287784f, 0.03405646f, -0.07635053f, 
    -0.01035742f, 0.11069674f, -0.04177332f, 0.03355581f, -0.05252922f, -0.23840389f, -0.35193112f, -0.29737803f, 
    -0.38456619f, -0.07383367f, 0.03655852f, -0.15991026f, -0.03583435f, -0.02529223f, 0.03454990f, -0.03639841f, 
    -0.05511416f, 0.05965888f, 0.02427339f, 0.06162681f, 0.06309688f, -0.17711569f, -0.23199043f, 0.25521305f, 
    -0.02673667f, -0.09364478f, 0.17171571f, 0.01792454f, 0.00577799f, -0.04875489f, 0.08531968f, 0.18711577f, 
    0.19050182f, -0.12518989f, 0.21968460f, -0.15314645f, -0.13374293f, 0.00007479f, -0.10768823f, -0.01626511f, 
    -0.03013985f, 0.00373000f, -0.09504756f, 0.09894089f, -0.01292734f, -0.24887691f, -0.13290723f, 0.15178493f, 
    -0.23798357f, 0.06098150f, -0.17747794f, -0.17127216f, -0.04268955f, 0.04451926f, 0.00036630f, 0.14740981f, 
    -0.08180888f, 0.08243480f, 0.01675263f, 0.07816740f, 0.05065971f, -0.11327063f, -0.08907747f, 0.11734276f, 
    -0.06398532f, -0.09706235f, -0.08148004f, -0.22863361f, 0.05787673f, -0.48213986f, -0.27279273f, -0.12807921f, 
    -0.02488929f, 0.08347475f, 0.03198513f, -0.16758598f, -0.04146810f, -0.01286992f, -0.06450792f, 0.00789100f, 
    0.18030839f, 0.25132766f, 0.32356641f, -0.02242314f, 0.02003003f, 0.21457183f, 0.08734857f, 0.02124238f, 
    0.12495633f, 0.04968451f, -0.10514569f, 0.17794782f, -0.10092346f, 0.16758850f, 0.01074118f, -0.05566503f, 
    -0.03518635f, -0.10962227f, -0.08839025f, -0.00573464f, -0.26148623f, -0.07446011f, 0.03860174f, -0.10266607f, 
    -0.08139367f, 0.02401874f, -0.00746532f, 0.03328932f, -0.15613002f, -0.02128697f, 0.05263991f, -0.03620200f, 
    -0.00551966f, -0.00780508f, 0.02902188f, 0.13515891f, -0.13723585f, -0.28814167f, -0.31899008f, -0.03792724f, 
    0.03759072f, -0.03479075f, -0.00809101f, -0.00870575f, 0.14269504f, -0.13148487f, -0.33712056f, -0.34722832f, 
    -0.27743810f, 0.08876470f, 0.18352790f, 0.10346102f, -0.04028098f, 0.09530590f, -0.00903398f, 0.14933126f, 
    -0.11412922f, 0.02835217f, 0.10850418f, 0.10336887f, -0.02987546f, -0.30945626f, -0.18353455f, -0.01056170f, 
    -0.04663469f, -0.01541754f, -0.16951264f, -0.06341165f, 0.05286279f, 0.04808040f, -0.05774435f, -0.11189967f, 
    0.01417538f, -0.17301166f, -0.08368021f, 0.11104646f, -0.05926496f, -0.05304369f, 0.04578403f, 0.08692992f, 
    0.03837286f, 0.14102136f, -0.01182244f, 0.08051564f, -0.41616052f, -0.01438765f, -0.10690301f, -0.11374184f, 
    0.01141158f, -0.07917764f, 0.14349781f, 0.12409277f, -0.07558562f, -0.05913391f, -0.18567435f, 0.06406319f, 
    0.03415225f, -0.17866230f, 0.00424812f, 0.23525302f, -0.04212820f, -0.03694522f, 0.05894797f, -0.08145943f, 
    -0.05428856f, 0.00192212f, -0.10251662f, 0.07162528f, -0.12787285f, -0.04054809f, -0.02141698f, -0.14594536f, 
    -0.16957112f, -0.01895109f, 0.05210591f, -0.05193333f, -0.00451135f, 0.14578532f, -0.13294317f, -0.00051661f, 
    -0.21384223f, 0.01758679f, -0.04774382f, -0.32616949f, -0.11663345f, -0.05886176f, 0.05217534f, -0.11871327f, 
    0.05172790f, -0.03200970f, 0.17862380f, 0.17377119f, -0.23416391f, 0.08120009f, -0.05023610f, 0.12911266f, 
    0.01791911f, 0.13417533f, -0.01154142f, -0.08920152f, -0.04213171f, 0.09396142f, 0.16129565f, 0.16330759f, 
    -0.07140540f, -0.25509989f, -0.18054028f, -0.16891965f, -0.22920497f, 0.00748944f, 0.10209540f, 0.11484185f, 
    0.02679838f, -0.00122810f, 0.01497786f, -0.10899571f, 0.02262903f, -0.03312663f, 0.18169491f, 0.01234592f, 
    -0.08539271f, 0.06051552f, 0.27277327f, 0.09747688f, 0.00198930f, -0.13139847f, 0.15363014f, 0.05186031f, 
    -0.07904766f, 0.15036194f, -0.13323839f, -0.07323807f, -0.04474217f, -0.00344348f, 0.09050857f, -0.03992635f, 
    -0.04971531f, -0.08598389f, -0.24630800f, -0.30702180f, -0.38746607f, 0.35984293f, -0.02162416f, 0.11466789f, 
    0.03079459f, 0.02278806f, 0.10037836f, -0.09390291f, 0.01026689f, -0.01322548f, -0.05846914f, -0.25351474f, 
    -0.02327298f, 0.10237656f, 0.05268355f, 0.09813600f, 0.08013506f, -0.05427746f, -0.02763353f, 0.14690775f, 
    -0.20049210f, -0.00136061f, -0.04168716f, -0.11241229f, 0.16204560f, 0.06404065f, 0.13987389f, -0.07985300f, 
    -0.10535223f, -0.04072039f, -0.00176793f, 0.01914845f, 0.12019482f, 0.14847293f, 0.15590560f, 0.15774003f, 
    -0.53122944f, 0.10627385f, 0.00396151f, -0.06165839f, -0.00636531f, -0.09425326f, -0.02438959f, -0.02906910f, 
    -0.10312683f, 0.08859914f, -0.00074099f, -0.04600175f, -0.01057601f, 0.11045738f, -0.03853612f, -0.03298114f, 
    0.04585186f, -0.11828935f, -0.05777563f, 0.01826288f, -0.08616232f, -0.25727832f, -0.07574770f, -0.38610408f, 
    -0.25155929f, 0.22809386f, -0.16282280f, 0.18481173f, -0.04085480f, 0.01375897f, -0.10534624f, -0.09514933f, 
    -0.12604293f, 0.01551229f, -0.00404548f, -0.04308243f, -0.14536917f, 0.06242724f, -0.00800340f, -0.13630293f, 
    -0.01462044f, -0.15099472f, -0.09424062f, 0.01894802f, -0.11875188f, 0.06444550f, -0.03931969f, -0.03185238f, 
    0.05255097f, 0.03295311f, -0.12670594f, 0.21371298f, -0.01977459f, 0.00094511f, 0.16748062f, -0.16632654f, 
    0.08885880f, 0.10783292f, -0.13437738f, 0.01512168f, -0.02147668f, -0.23014714f, 0.11471005f, 0.28408921f, 
    -0.14593320f, 0.14604865f, -0.00876312f, -0.02279485f, -0.02760781f, -0.26647478f, -0.08775201f, -0.06794982f, 
    -0.14552620f, -0.08946126f, -0.40107194f, -0.04553222f, -0.04557911f, -0.14861935f, 0.11534084f, 0.03283775f, 
    0.03664052f, 0.08510911f, -0.07026733f, -0.00850565f, 0.05931084f, -0.17945896f, -0.04729611f, 0.01039117f, 
    -0.16433427f, -0.21852203f, 0.08072807f, 0.05596169f, -0.07237347f, -0.10165211f, -0.03996859f, -0.09362070f, 
    0.25368717f, 0.04385508f, 0.24474305f, -0.13073783f, 0.03849705f, -0.02987997f, -0.00520640f, 0.06979298f, 
    -0.15295091f, 0.12481432f, -0.05169854f, -0.00925436f, -0.17985056f, -0.14193171f, 0.04199154f, 0.01455172f, 
    -0.04667229f, 0.26815057f, -0.27356932f, -0.00586967f, -0.08666799f, -0.01859853f, 0.07056812f, 0.00753092f, 
    -0.10580272f, 0.10914624f, 0.16139866f, 0.01003200f, -0.08451155f, 0.07087648f, 0.12250119f, 0.07606593f, 
    -0.08512359f, 0.05685798f, 0.14246140f, 0.04976555f, -0.20636979f, 0.17858882f, -0.07507222f, 0.01688477f, 
    -0.06811743f, -0.12113097f, 0.11845587f, 0.04413752f, -0.00781726f, -0.02492118f, 0.06654286f, -0.04750412f, 
    0.13944192f, -0.05102110f, 0.17803858f, 0.27542141f, -0.01092325f, -0.02639359f, 0.04589198f, 0.13659592f, 
    -0.00418693f, -0.00331934f, 0.00820300f, 0.09938757f, -0.15156774f, 0.24567130f, 0.00687694f, 0.02992773f, 
    -0.15628175f, 0.13966386f, -0.04602579f, 0.08510555f, -0.00470477f, 0.08622384f, 0.05644875f, 0.14417033f, 
    -0.19240600f, 0.05409331f, 0.19894984f, 0.02894284f, 0.00772317f, -0.04872186f, -0.22221233f, 0.01880883f, 
    0.00858611f, 0.06912330f, 0.15635070f, -0.05670482f, 0.37992287f, -0.18053013f, 0.33142588f, 0.12443431f, 
    -0.13245438f, 0.18951288f, 0.15046686f, 0.12582433f, 0.04805434f, 0.09659223f, -0.02868431f, -0.04713654f, 
    -0.15617371f, 0.26935786f, 0.03838110f, 0.37616366f, 0.00945351f, 0.18651350f, -0.10117456f, 0.06675284f, 
    -0.09755214f, -0.07419577f, -0.33313257f, -0.35007781f, -0.58864963f, 0.16270059f, 0.08381202f, -0.17189564f, 
    -0.04211617f, 0.11415925f, -0.04673639f, -0.10147251f, -0.03037043f, 0.05132920f, 0.02376260f, -0.04958589f, 
    -0.05256399f, 0.07557809f, -0.12346098f, 0.31997585f, -0.05106637f, 0.01698653f, -0.11811973f, 0.10604702f, 
    0.14101951f, 0.03651371f, -0.02908508f, -0.09627338f, 0.11126721f, 0.01401231f, 0.14670439f, -0.03920797f, 
    -0.05514507f, -0.22743575f, 0.06747001f, 0.07042220f, -0.03178912f, -0.05676197f, -0.37616187f, -0.18644357f, 
    -0.13203016f, 0.05060096f, 0.06283896f, -0.08168804f, -0.15893932f, -0.08782218f, 0.03177794f, -0.04072190f, 
    0.04407577f, 0.15189256f, 0.05261723f, 0.05055377f, -0.20543201f, -0.03887746f, -0.11563595f, -0.16424303f, 
    -0.08502778f, -0.06097774f, -0.16266239f, 0.02460224f, -0.03486086f, -0.04142065f, -0.01036544f, -0.19493210f, 
    -0.02644319f, 0.22910993f, -0.35719118f, 0.23329382f, -0.13015148f, 0.02805797f, 0.08820366f, 0.00845110f, 
    -0.13238427f, 0.18617928f, -0.15615988f, 0.06163206f, -0.09020318f, 0.04575496f, -0.12518555f, 0.01917929f, 
    -0.04948900f, 0.05160421f, 0.05804575f, -0.06213573f, 0.06409272f, 0.07250713f, -0.22811757f, -0.05989960f, 
    0.04549374f, -0.10645778f, 0.32382396f, 0.24114873f, 0.00346594f, 0.04951172f, -0.03668194f, -0.02613005f, 
    -0.09912209f, 0.03082093f, 0.10511552f, 0.13394354f, -0.02741172f, -0.09902991f, -0.04204856f, -0.26734796f, 
    0.09880594f, 0.03690792f, -0.07881696f, -0.08584015f, 0.09391461f, -0.06024723f, 0.09474409f, -0.05127560f, 
    -0.05621599f, -0.15571783f, -0.15724294f, 0.33868349f, -0.11317249f, 0.04305308f, -0.07406737f, -0.05004380f, 
    0.09404964f, 0.09118605f, 0.01023903f, 0.09153927f, -0.53541452f, 0.19725601f, -0.02493725f, 0.16999048f, 
    0.11414463f, 0.08839832f, 0.28440204f, -0.32551306f, -0.06533275f, -0.03046852f, -0.03363870f, 0.03619653f, 
    -0.41525814f, 0.17105730f, -0.29853472f, 0.53238779f, 0.06207620f, -0.11377772f, 0.10920499f, 0.17070554f, 
    -0.08926187f, -0.01730866f, -0.06363206f, -0.19828920f, 0.19766076f, -0.37547988f, 0.05138073f, 0.05250921f, 
    -0.01469643f, -0.12616910f, 0.00683389f, 0.08245621f, -0.11798984f, -0.07066893f, 0.08869661f, -0.04910764f, 
    -0.10153558f, -0.15106538f, -0.11441837f, -0.02011366f, -0.16714983f, -0.03750062f, -0.04771869f, -0.13171683f, 
    -0.01599468f, 0.04966956f, 0.01583961f, 0.02758208f, 0.45226845f, -0.01803321f, 0.41362128f, 0.08439999f, 
    -0.08861502f, 0.15601659f, -0.16056474f, 0.05313010f, -0.10759251f, 0.00160088f, 0.06421307f, 0.04536145f, 
    0.24407461f, 0.24858321f, 0.19246612f, -0.02618337f, 0.04526315f, -0.06781954f, -0.08061323f, -0.04877168f, 
    -0.10625014f, 0.01809822f, 0.00897087f, 0.11411536f, -0.11917607f, -0.09252672f, -0.09145080f, 0.04711865f, 
    0.00968975f, -0.10509954f, -0.08813107f, 0.13797532f, -0.05020830f, -0.13593689f, -0.25010100f, -0.17690758f, 
    -0.72250473f, 0.30344668f, -0.51440710f, -0.02540705f, -0.07441843f, -0.22906958f, -0.05835138f, -0.09198417f, 
    -0.00056802f, -0.02427959f, 0.03769819f, 0.10511944f, -0.21201678f, -0.01515166f, -0.32231852f, 0.02640011f, 
    -0.05006882f, 0.05752311f, 0.00500548f, -0.19011837f, -0.05831075f, -0.02044540f, -0.03893847f, -0.13483445f, 
    -0.20535976f, 0.12361455f, 0.03548091f, -0.03642486f, 0.06537156f, 0.07877336f, -0.06950425f, 0.11470578f, 
    -0.09791560f, -0.08125421f, 0.16821724f, 0.19365339f, -0.39583379f, -0.50737411f, -0.02181857f, 0.31489578f, 
    0.00115364f, 0.12115020f, -0.04406501f, 0.12947170f, -0.09239457f, 0.10609347f, 0.01887068f, -0.20588437f, 
    -0.12632650f, -0.00524524f, -0.37669677f, -0.05451590f, 0.20921421f, -0.18435410f, 0.08169102f, 0.01767128f, 
    0.00764449f, 0.06310022f, -0.01084547f, -0.09960899f, -0.36419204f, 0.01893806f, -0.31260559f, 0.06336348f, 
    0.03757285f, 0.15988275f, -0.09846234f, 0.05067405f, 0.12336490f, 0.06123280f, 0.23705165f, 0.11824132f, 
    0.24481969f, 0.09213220f, 0.12617142f, -0.02230840f, 0.21837458f, -0.14671235f, -0.03434955f, -0.08095215f, 
    -0.05513949f, 0.00995339f, 0.00183970f, 0.08111195f, 0.20745833f, 0.14043418f, 0.10311387f, -0.04866691f, 
    0.08226141f, 0.05202761f, -0.12650451f, 0.14347476f, -0.18686408f, 0.04869776f, -0.02248723f, -0.07759991f, 
    0.04089794f, -0.08322795f, 0.07029890f, -0.12741885f, 0.04592096f, 0.08830431f, -0.07523162f, -0.04445114f, 
    -0.07362486f, -0.06357051f, -0.02010413f, -0.09948720f, -0.06988682f, 0.11553663f, -0.01038182f, -0.02979165f, 
    -0.01632517f, 0.01460136f, 0.14602275f, 0.01469469f, -0.07231370f, 0.04006549f, 0.08534189f, -0.00713398f, 
    -0.01841030f, 0.24163921f, -0.24367677f, 0.14640227f, -0.09143967f, -0.05229663f, -0.03122524f, -0.02781756f, 
    0.06254549f, 0.01036355f, 0.08617222f, -0.05475207f, 0.48465309f, -0.14355016f, 0.59328270f, -0.28132370f, 
    -0.10996772f, -0.09962317f, -0.16162680f, -0.07868259f, -0.00283234f, 0.01552904f, 0.02036582f, -0.04973539f, 
    -0.31744519f, 0.19088739f, -0.26037851f, 0.12869900f, 0.05224746f, 0.04824840f, 0.12316941f, 0.03651597f, 
    -0.07539235f, 0.02834722f, -0.02266455f, 0.07143980f, 0.02424412f, 0.31687719f, -0.21645546f, 0.14647678f, 
    0.00308736f, -0.05101537f, 0.31670287f, -0.00886571f, 0.03624633f, 0.03315699f, 0.05254235f, 0.06582653f, 
    -0.54819399f, -0.01717126f, -0.31995335f, 0.14879288f, 0.11169107f, -0.01750140f, 0.02102522f, -0.06654597f, 
    -0.12147689f, -0.15598513f, 0.03049552f, -0.17366453f, -0.23365118f, 0.06245934f, -0.14537461f, -0.60287237f, 
    0.02755604f, 0.04452757f, -0.04720640f, -0.01048334f, -0.05445597f, 0.09212961f, 0.15160067f, 0.07326201f, 
    -0.69235790f, 0.22687553f, 0.11411770f, 0.15678690f, 0.12408195f, 0.17958549f, 0.20364566f, -0.22980377f, 
    0.08740230f, 0.04026960f, -0.03402680f, 0.07731549f, -0.06328727f, -0.30892414f, -0.22130549f, 0.06108775f, 
    -0.28359103f, -0.06011426f, -0.08661167f, -0.08984145f, 0.01067539f, 0.04354985f, 0.02793528f, -0.03619275f, 
    -0.20573688f, -0.13417719f, -0.02954656f, -0.11590384f, 0.02911116f, 0.10138772f, -0.06390432f, -0.21208286f, 
    0.05579801f, -0.03226168f, -0.08142380f, -0.12679146f, 0.01734956f, -0.09875149f, -0.11085867f, 0.07966223f, 
    -0.14784326f, 0.02311563f, -0.05206257f, -0.21652283f, 0.11182565f, 0.09422217f, -0.04240645f, -0.05092622f, 
    -0.05361956f, -0.11797870f, 0.21665470f, 0.11463656f, -0.16135617f, 0.03960958f, -0.18654266f, 0.07282574f, 
    0.01583917f, -0.09331208f, 0.22053821f, 0.02185011f, 0.45051825f, -0.03893481f, 0.05448332f, -0.15131983f, 
    0.05955645f, 0.02142928f, -0.00329897f, 0.04428398f, -0.00906244f, 0.00983775f, 0.16325200f, 0.03265562f, 
    -0.12009422f, -0.07583006f, -0.18297696f, -0.05816090f, 0.11670664f, -0.00978814f, -0.04147298f, -0.01590199f, 
    0.08035560f, 0.08633174f, -0.02428495f, -0.05405063f, -0.13901441f, 0.11408217f, 0.00503496f, 0.08852508f, 
    0.18467663f, -0.11526264f, 0.05990095f, -0.05314058f, 0.00256342f, -0.06352208f, -0.11322658f, -0.11391257f, 
    0.03020878f, -0.03081904f, -0.19031478f, -0.76595110f, -0.02367527f, -0.11397519f, 0.15506141f, 0.03658328f, 
    0.06713825f, 0.12416086f, 0.09145626f, -0.05888525f, 0.01969022f, 0.10030033f, 0.07007022f, 0.08899608f, 
    -0.03441330f, 0.01698497f, -0.05699858f, -0.01789390f, -0.05972315f, -0.09797452f, 0.05843385f, -0.14040238f, 
    0.15854999f, 0.02099632f, 0.03240054f, -0.03314922f, -0.01099354f, 0.05689814f, -0.15382251f, -0.03699432f, 
    -0.01618810f, 0.04695284f, 0.12052234f, -0.04082789f, 0.07626332f, -0.32270783f, -0.13020603f, 0.32881790f, 
    0.28639719f, 0.00924595f, 0.07661845f, 0.03702880f, 0.01837354f, 0.13673672f, 0.27320975f, 0.13000678f, 
    -0.33463815f, 0.23639885f, 0.01173888f, 0.36962861f, 0.05203498f, 0.00879771f, 0.16882579f, 0.05287082f, 
    -0.03310210f, -0.03984508f, -0.12701997f, 0.17879549f, -0.03121827f, -0.08212299f, -0.00137624f, -0.13017812f, 
    0.00659903f, 0.01296300f, -0.00936765f, 0.10516308f, -0.15526058f, 0.00543503f, -0.13493875f, -0.10498495f, 
    -0.20862657f, 0.10955762f, -0.47320771f, 0.07000390f, 0.15433323f, 0.10024329f, 0.09603964f, 0.09334537f, 
    -0.16947688f, 0.08023395f, 0.00420673f, 0.01822094f, -0.40708926f, 0.02277994f, 0.05685257f, -0.04456270f, 
    -0.02527565f, -0.04635730f, 0.03258806f, 0.01362921f, -0.28128338f, -0.09882350f, 0.07115871f, 0.05908308f, 
    -0.27357858f, 0.02179811f, 0.03803134f, 0.39821160f, 0.09401180f, 0.00051034f, 0.12716389f, -0.09207262f, 
    0.03411977f, -0.09163169f, 0.06299936f, 0.15160905f, 0.04706587f, 0.46356308f, -0.15900181f, -0.04539690f, 
    0.07743986f, -0.09634381f, 0.05164930f, -0.23283429f, 0.06636063f, 0.06724786f, -0.17283782f, -0.08526412f, 
    -0.01973165f, 0.00698206f, 0.38593674f, 0.12698369f, -0.04724252f, -0.01640666f, -0.05333744f, 0.02996622f, 
    -0.00763442f, -0.02531754f, 0.06951298f, 0.06444220f, -0.14715406f, -0.20342821f, 0.16396080f, -0.13894784f, 
    -0.11716714f, -0.08485436f, 0.00107296f, -0.03026096f, -0.04172777f, 0.14910913f, -0.00755719f, -0.13281432f, 
    0.24379626f, -0.39678296f, 0.25842988f, 0.12660065f, -0.14825200f, -0.02937058f, -0.13017817f, -0.10897725f, 
    0.01310398f, 0.03243465f, 0.05702534f, 0.11133993f, 0.16364789f, 0.25692713f, 0.26285923f, -0.01771782f, 
    -0.10538448f, -0.02769386f, -0.16730940f, 0.01883004f, -0.11435500f, 0.00186375f, 0.07187384f, -0.00088662f, 
    -0.26070741f, -0.20902164f, -0.09231541f, -0.11267762f, 0.03576863f, -0.01909043f, 0.10935970f, -0.16296934f, 
    0.00149562f, 0.02237127f, -0.00391164f, 0.02143571f, -0.26717043f, 0.02013938f, 0.29246068f, -0.13401127f, 
    0.00567335f, -0.05224553f, -0.04456339f, 0.03378528f, -0.08442697f, 0.10523246f, -0.00778636f, -0.11923459f, 
    0.10405835f, 0.02415201f, -0.07103600f, 0.10687874f, -0.06713697f, 0.05530510f, -0.22062099f, -0.02591814f, 
    -0.04773532f, 0.11131536f, 0.01989213f, -0.14883663f, -0.12455441f, -0.08425368f, -0.04995809f, -0.00952413f, 
    0.02553172f, 0.00028979f, 0.08445232f, -0.08220767f, 0.03146060f, 0.01999572f, -0.03741287f, -0.05086887f, 
    -0.48188448f, 0.06619692f, 0.07002155f, -0.08259622f, -0.10113994f, -0.07145514f, 0.12958139f, -0.10857048f, 
    -0.11436550f, 0.00169933f, -0.02630905f, -0.00803488f, 0.11138184f, -0.30772403f, 0.35792530f, 0.15418628f, 
    0.10734882f, -0.21739361f, -0.12085601f, 0.01576068f, 0.00359118f, -0.08192875f, -0.05763941f, -0.19109803f, 
    -0.18388775f, -0.05883527f, -0.18435466f, 0.08314438f, -0.08989080f, -0.07784691f, -0.25319791f, 0.05159465f, 
    -0.09916678f, 0.02857722f, -0.12835389f, 0.00668341f, 0.02423399f, -0.05204934f, 0.28339425f, -0.63776410f, 
    0.02817049f, 0.02684921f, -0.14636797f, 0.11372784f, -0.00595961f, -0.01053939f, -0.00411163f, -0.08230042f, 
    -0.40792891f, -0.08280793f, -0.40780473f, 0.28145754f, -0.01029748f, 0.00975981f, 0.12535276f, 0.11334351f, 
    0.09162673f, 0.02943566f, 0.13318920f, 0.23722880f, -0.20819542f, -0.08807100f, -0.25080487f, 0.16852501f, 
    0.19298433f, -0.03604017f, 0.08542458f, -0.15562409f, 0.00860575f, 0.17222467f, -0.00847923f, -0.03197780f, 
    0.03982780f, -0.30034900f, 0.14716640f, 0.11937482f, -0.03192881f, 0.10888109f, 0.04060321f, 0.00526699f, 
    -0.06499606f, -0.02623098f, -0.02786625f, 0.04430337f, 0.15449208f, -0.13502793f, 0.21138775f, -0.29809615f, 
    0.12965527f, 0.09999087f, 0.18849766f, 0.04874793f, 0.08850227f, 0.05540425f, 0.05238939f, -0.02269404f, 
    0.29292414f, -0.25762904f, 0.16890259f, -0.02257786f, -0.00973691f, 0.11266243f, -0.11208691f, 0.14141747f, 
    -0.15375337f, -0.02509376f, 0.07796936f, -0.10425737f, 0.29319260f, 0.03740336f, 0.14111857f, -0.08289362f, 
    -0.06458748f, -0.03341942f, 0.04260151f, 0.06181928f, -0.19552106f, 0.10254220f, -0.03529423f, 0.03946499f, 
    0.19610903f, -0.10778907f, 0.16298157f, 0.12592322f, 0.00122407f, 0.02281473f, -0.15636592f, 0.01349119f, 
    -0.01175853f, -0.14999372f, 0.20975015f, 0.06579498f, 0.28767216f, -0.07042500f, 0.07293370f, 0.01141850f, 
    -0.03883404f, 0.02924609f, 0.12094880f, -0.01407928f, -0.01393979f, -0.02551870f, 0.06634165f, 0.06862334f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.16912137f, 0.11759131f, 0.03422309f, -0.12894087f, -0.10250222f, 0.06693893f, 0.03748568f, -0.13142262f, 
    0.04749852f, 0.03162411f, 0.03896996f, -0.02213817f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
