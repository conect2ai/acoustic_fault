#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.20445196f, -0.11468423f, 1.04278100f, -0.05875575f, -0.86435056f, -0.59304339f, 0.03400911f, -0.29287314f, 
    -0.25145495f, -0.87068760f, -0.52768213f, -0.39792669f, 0.75315797f, -0.34874213f, -0.12830460f, -0.40347981f, 
    -0.34474793f, -0.51690716f, 1.05775213f, -1.01686764f, -0.21679471f, -0.87741321f, -0.31010136f, 0.06350827f, 
    -0.24043992f, -0.64525855f, 0.15765092f, 0.49770257f, 0.27401376f, 0.47955015f, 0.26681408f, -0.73832411f, 
    0.06773329f, 0.10319492f, -0.51315409f, -0.23622090f, 0.70314878f, 0.59594363f, 0.38071954f, 0.00671388f, 
    -0.02598397f, 0.05407192f, -0.32375890f, -0.00557423f, 0.42833796f, 0.35000354f, 1.05692589f, -1.05798757f, 
    -0.21057180f, -0.06822342f, 0.43078637f, -0.12041011f, 0.00182851f, 0.19340008f, -0.18961400f, 0.58073932f, 
    0.35834399f, -0.99689490f, -0.01166228f, 0.40428492f, 0.17039220f, 0.19436352f, -0.07722644f, -0.48236436f, 
    -0.96736974f, 0.33804992f, 0.82172424f, 0.86156166f, -0.25376937f, -0.05824776f, -0.52428311f, -0.43703336f, 
    1.17038333f, -0.54248297f, -0.82864726f, 0.22367901f, 0.45275438f, 0.49611706f, -0.28067422f, 0.01807197f, 
    -0.58419782f, -0.00127059f, -0.16023976f, -0.45887905f, -0.60752451f, 0.78192461f, -0.32675260f, -0.13490061f, 
    0.54516655f, 0.12011888f, 0.07207773f, 0.31709123f, 0.27094465f, -0.01152082f, 0.31834686f, -0.22471030f, 
    0.36414284f, 0.28978488f, -0.28678820f, -0.23893960f, 0.14995696f, -0.93462867f, 0.33615047f, -0.15306360f, 
    -0.36668882f, -0.60887152f, -0.17953092f, -0.65329969f, -0.33688658f, 0.90284616f, -0.46467450f, 0.24278407f, 
    -0.51003700f, -0.64407188f, 0.39649189f, 0.23093717f, 0.50906557f, -0.09838162f, 0.33074430f, 0.47607949f, 
    0.20203581f, 0.24160972f, 0.57188237f, -0.26556724f, -0.35871205f, -0.01245536f, -0.65499181f, 0.42855003f, 
    0.17003396f, -0.30014917f, -0.56899697f, -0.70968705f, 0.02046249f, -0.50093806f, -0.53813690f, -1.16756415f, 
    -0.51164246f, 0.75402826f, -0.08530678f, 0.33901665f, 0.55305529f, 0.08099172f, -0.04755515f, -0.14366624f, 
    -0.70537466f, -0.32880148f, 0.04537253f, -0.46142730f, -0.44054863f, 0.54233915f, 0.13540013f, -0.07696999f, 
    -0.47901794f, 0.64793462f, -0.62688446f, -0.52116424f, 0.38361311f, 0.33316872f, 0.30691901f, -0.49956319f, 
    -0.22265004f, 0.51497412f, 0.34951523f, 0.40766230f, 0.25428006f, 0.13738085f, 0.49715593f, 0.24559866f, 
    -0.33491081f, -0.34281373f, 0.17476219f, 0.01101203f, 0.26563355f, 0.00354513f, 0.34410566f, 0.75077474f, 
    0.11583250f, -0.49163860f, 0.49704781f, 0.13055971f, -0.82341194f, 0.26498240f, -0.54788643f, 0.27465346f, 
    -0.01805908f, 0.25960910f, 0.34164277f, 0.09791098f, 0.12591934f, -1.18422174f, 0.07765333f, 0.82188696f, 
    -0.57789898f, -0.45857060f, 1.04653990f, -0.44307107f, 0.33016482f, -0.00325864f, 0.54266852f, 0.18741480f, 
    -0.58581549f, 0.29995459f, 0.21789721f, -0.44393370f, 0.49178785f, -0.50984514f, 0.12122771f, -0.70695460f, 
    -0.36329949f, -0.56700379f, 0.19875437f, -0.79793602f, 0.36531955f, -0.24933191f, -0.21244095f, 0.67860317f, 
    0.86464012f, -0.45234600f, -0.73953754f, 0.24475141f, -0.15648057f, 0.32677621f, 0.02796540f, 0.25718507f, 
    0.15564480f, 0.28753835f, -0.04371423f, -0.79095370f, 0.27522615f, -0.33058745f, -0.33128306f, -0.40188220f, 
    -0.31318796f, -0.24106587f, -0.48976922f, -0.24371208f, 0.00392415f, -0.50104308f, -0.83750832f, -0.87375396f, 
    0.26902428f, 0.50260520f, 0.52773321f, 0.41184938f, -0.71874201f, 0.63021642f, -0.05945646f, -0.54677361f, 
    0.60622007f, -0.08151451f, -0.30417874f, 0.28395721f, -0.28397080f, -0.83404559f, -0.99945641f, 0.17789187f, 
    0.51392323f, 0.78372920f, 0.13065310f, -0.08001915f, 0.01386736f, -0.09651254f, -0.68530941f, -0.17178145f, 
    -0.61665636f, -0.40176412f, -0.50825471f, -0.04790000f, -0.47828084f, -0.52596086f, 0.54589170f, 0.05904806f, 
    0.08741197f, -0.08084175f, -0.21741806f, -0.49074212f, -0.70262963f, 0.22860795f, 0.52721471f, -0.91417313f, 
    -0.73443359f, -0.24871674f, -0.44051528f, -0.50629455f, 0.11444266f, 0.54196852f, 0.17257729f, 0.21762525f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.09391803f, -0.27072459f, 0.10206538f, 0.14444394f, -0.36983126f, -0.16804402f, 0.32092869f, -0.17534304f, 
    0.09707977f, 0.16937263f, -0.29597613f, -0.20451747f, -0.19762082f, -0.34245911f, -0.10964466f, 0.05916658f, 
    0.04957783f, 0.29713231f, -0.05407357f, -0.11386677f, 0.17177811f, 0.23919061f, 0.10580567f, -0.28216282f, 
    -0.31798327f, -0.21358451f, -0.17656372f, -0.10384394f, 0.33118534f, -0.32951921f, 0.33947787f, -0.21985313f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02894941f, 0.01884352f, -0.00161073f, 0.00417458f, -0.01374286f, -0.01797984f, -0.01545264f, -0.00586174f, 
    -0.01789649f, 0.00976209f, -0.02757600f, -0.00151327f, -0.02605823f, -0.03848165f, -0.03658701f, 0.02826570f, 
    -0.03353329f, 0.01024093f, -0.01205564f, -0.02197523f, -0.02411291f, -0.01654567f, 0.02703670f, 0.01418495f, 
    -0.02664617f, 0.02640335f, 0.00112778f, -0.01716593f, -0.03686222f, 0.00244352f, -0.03999530f, -0.02679613f, 
    -0.00178617f, -0.02552461f, 0.02079047f, -0.01938182f, -0.03352970f, 0.03126781f, 0.00557096f, -0.03170433f, 
    0.00694771f, 0.00733085f, 0.03198183f, 0.00851227f, 0.00927462f, -0.02838299f, 0.03328460f, 0.03020706f, 
    0.02513067f, 0.03082986f, -0.02011356f, -0.00191172f, -0.03516443f, -0.00321216f, -0.02933093f, -0.00342139f, 
    0.01884900f, 0.02128592f, 0.02289170f, 0.02258835f, 0.00706343f, 0.01404867f, 0.01135266f, 0.01995898f, 
    -0.00093778f, -0.04025446f, -0.02074202f, -0.02937559f, 0.00961935f, 0.03217157f, -0.01884981f, -0.02744579f, 
    -0.01229222f, 0.03235376f, -0.03034377f, -0.02723286f, -0.00735078f, 0.01510980f, -0.04359568f, 0.02149882f, 
    -0.01740323f, 0.00864298f, -0.00183937f, -0.01879006f, 0.02206956f, -0.00142510f, 0.03752870f, 0.02996817f, 
    0.03600001f, 0.03496308f, -0.02219857f, -0.01383651f, -0.01370426f, -0.02832997f, -0.03770384f, 0.02607298f, 
    -0.00811046f, 0.01636474f, -0.04358428f, 0.02491616f, -0.01890014f, -0.03331815f, -0.03365147f, 0.00670883f, 
    0.01268384f, -0.03106687f, -0.02819550f, -0.04050416f, -0.00628294f, -0.03689342f, 0.01832126f, -0.02256125f, 
    -0.03707248f, 0.00915921f, -0.00194822f, -0.02539384f, -0.02342800f, -0.00168038f, -0.02006233f, -0.00995466f, 
    -0.00795917f, 0.02957749f, -0.04389365f, -0.03034273f, 0.01060559f, -0.03772497f, -0.03331295f, 0.00531312f, 
    -0.04225293f, -0.03932837f, -0.03561865f, -0.01611755f, -0.02250455f, -0.01981428f, -0.01091398f, 0.02823330f, 
    -0.00858308f, 0.01261213f, 0.02857169f, 0.00530488f, -0.03629193f, -0.04289540f, 0.01817445f, -0.00703091f, 
    -0.03022052f, -0.00243128f, 0.01773363f, 0.02682728f, 0.02435530f, -0.03573009f, 0.01224000f, 0.01885857f, 
    -0.02808372f, 0.01950022f, -0.00597823f, -0.00074527f, -0.03405442f, -0.01523903f, -0.04458449f, 0.02003852f, 
    -0.03485427f, -0.01331511f, 0.02408595f, -0.04340887f, -0.00979122f, -0.03446744f, -0.02093594f, -0.00226965f, 
    -0.00610201f, -0.02909901f, -0.00292825f, -0.03919665f, -0.04384417f, -0.03843537f, -0.02503520f, -0.02097460f, 
    -0.00784907f, 0.00594322f, -0.02461755f, -0.03959225f, -0.00454467f, 0.00622738f, 0.00700420f, 0.00639674f, 
    0.00152364f, 0.03203821f, -0.00484751f, 0.00660000f, -0.02874425f, 0.03309565f, 0.00664275f, 0.01317563f, 
    0.00160313f, -0.03615119f, -0.01923802f, 0.00632531f, -0.00676479f, -0.04070316f, 0.01458411f, 0.01874535f, 
    -0.02593054f, -0.00326737f, 0.02966277f, 0.01469234f, 0.00887897f, -0.03552893f, 0.00217293f, -0.03823363f, 
    -0.02746295f, 0.00055142f, -0.01342811f, -0.03047201f, -0.02847491f, 0.02829855f, -0.04180893f, -0.04050138f, 
    -0.01844705f, 0.00851479f, -0.02970418f, -0.03435735f, 0.01590323f, -0.02827841f, -0.03317560f, -0.02017046f, 
    0.03215335f, -0.00403442f, 0.00353394f, 0.00647389f, -0.03712780f, 0.00994028f, 0.01441389f, -0.02491991f, 
    0.03791180f, -0.00805629f, -0.01363060f, -0.01035302f, -0.03323882f, 0.01867067f, -0.03127707f, 0.01840959f, 
    -0.02398857f, -0.03526041f, -0.01601133f, -0.01329244f, 0.00621002f, -0.02687116f, 0.00730726f, 0.01936210f, 
    0.00405202f, 0.00551887f, -0.02236767f, -0.00100538f, -0.04078324f, -0.00648079f, -0.02781386f, -0.00822084f, 
    -0.00223777f, 0.02386978f, -0.02220228f, 0.01902588f, 0.01304715f, -0.00197255f, -0.02296741f, -0.02040342f, 
    0.01615228f, -0.03623735f, 0.03070954f, -0.03745181f, -0.03088056f, 0.00967727f, -0.00026113f, 0.02405729f, 
    0.01392655f, -0.03275802f, 0.00498333f, -0.01188337f, 0.03349821f, -0.00263792f, 0.00291845f, 0.01949276f, 
    0.00535182f, -0.04470885f, 0.03291160f, 0.02979310f, -0.02317809f, 0.01702855f, -0.03216049f, -0.04268322f, 
    -0.02371118f, 0.00872138f, 0.02852122f, -0.00838528f, -0.03211474f, -0.00950304f, -0.01922943f, -0.02211165f, 
    0.02644396f, -0.03586975f, 0.02787616f, -0.02825191f, 0.00177673f, -0.02828766f, 0.02463574f, 0.00979283f, 
    0.00594981f, -0.01177915f, 0.00826377f, -0.03933460f, -0.03921683f, 0.02406969f, -0.03780406f, 0.03197272f, 
    -0.01306732f, -0.03679483f, 0.00992737f, 0.02441742f, -0.01905901f, -0.00631131f, -0.04241459f, 0.00882520f, 
    -0.02421433f, -0.02100514f, -0.00140801f, -0.02261095f, -0.03260449f, -0.03511402f, 0.01754080f, -0.02650170f, 
    -0.02606649f, 0.02699337f, 0.01064891f, 0.01284514f, -0.01780514f, -0.04118561f, 0.01661233f, -0.02371580f, 
    0.00040789f, 0.02513756f, 0.00949292f, -0.02441825f, 0.02407024f, -0.00986900f, 0.00041979f, -0.01423317f, 
    0.02908160f, -0.02241655f, 0.03003516f, 0.02216278f, -0.03170034f, -0.00128998f, 0.02782385f, -0.03438307f, 
    0.00330927f, 0.01138442f, 0.02936829f, -0.04294908f, 0.00206021f, 0.03249554f, -0.04399576f, 0.03295949f, 
    0.00304937f, -0.01778650f, 0.00315082f, -0.03638019f, 0.02911715f, 0.01888562f, -0.02794669f, 0.02939062f, 
    0.01027553f, -0.03684964f, -0.00725434f, -0.00640920f, 0.00549661f, -0.00591494f, 0.02637096f, 0.00364134f, 
    -0.02107177f, -0.03800236f, -0.02015619f, -0.00497367f, -0.02474208f, 0.00859134f, -0.02722609f, 0.03095088f, 
    -0.03447311f, 0.03055075f, 0.03281171f, 0.00416272f, 0.00814152f, 0.02687671f, -0.02099475f, -0.02375683f, 
    -0.03270723f, -0.00976918f, -0.00742944f, -0.01039056f, -0.00146373f, -0.01691432f, 0.01559122f, 0.00472708f, 
    0.01409997f, 0.01356105f, -0.04439625f, -0.02704888f, -0.01034399f, -0.02191024f, -0.01085808f, -0.03774584f, 
    0.00706060f, 0.00212992f, -0.02614347f, 0.01130250f, -0.03252126f, -0.02439166f, -0.03701022f, 0.03212364f, 
    -0.01707793f, -0.03287183f, -0.00250011f, -0.02194184f, -0.04192896f, 0.00194348f, 0.01189192f, -0.00475205f, 
    0.00928213f, -0.02087389f, 0.00085247f, -0.03746186f, 0.02920072f, -0.04272360f, -0.02917782f, 0.01523374f, 
    -0.01768060f, -0.02865124f, 0.01559958f, -0.02184217f, -0.04251685f, 0.03102589f, 0.00404278f, 0.02615929f, 
    0.01026491f, 0.00656276f, 0.02826848f, -0.03247341f, -0.03914898f, -0.03603168f, 0.03284694f, -0.00631001f, 
    -0.02611043f, -0.02979487f, -0.03578196f, 0.02181785f, -0.01573223f, 0.03125007f, -0.02464448f, 0.03077833f, 
    0.01329912f, -0.01349167f, -0.03486502f, -0.02947104f, 0.00817343f, -0.01801857f, -0.04378688f, 0.01739999f, 
    -0.01140238f, -0.02479192f, -0.03897214f, -0.00647776f, 0.03293845f, -0.00164460f, 0.00646892f, -0.03205696f, 
    -0.03455345f, 0.03401449f, 0.02178144f, -0.00848600f, 0.02605781f, -0.02788237f, 0.01842534f, -0.03847205f, 
    -0.03325143f, 0.01784024f, 0.02554476f, 0.03752125f, -0.02039072f, 0.03540989f, -0.03791465f, -0.03205317f, 
    0.02249805f, -0.03807930f, -0.00817071f, -0.00988895f, -0.03224361f, -0.02863329f, -0.01649084f, -0.02477430f, 
    0.02996257f, -0.03901131f, 0.01801882f, -0.02675494f, -0.01174990f, 0.01228126f, -0.00136617f, 0.02318747f, 
    -0.02240071f, 0.02230344f, -0.03405851f, 0.02318881f, -0.02614390f, -0.02457511f, 0.02709618f, -0.03080392f, 
    0.00848226f, -0.02300583f, 0.01652660f, 0.02550098f, 0.00533060f, -0.01255210f, -0.00525025f, 0.00528207f, 
    -0.01186273f, -0.02588504f, 0.01375427f, -0.03427885f, -0.00851270f, -0.03846433f, 0.01674975f, 0.02960270f, 
    0.02608688f, 0.00884542f, 0.00161055f, 0.01648827f, 0.00387914f, 0.01510333f, 0.02560038f, 0.00589110f, 
    0.02275894f, -0.00301582f, 0.03248354f, -0.01863273f, -0.02507181f, 0.00816778f, 0.02573665f, 0.02869071f, 
    -0.00103923f, 0.03584297f, 0.01564884f, 0.03542507f, -0.03725501f, -0.01037863f, -0.00014974f, -0.02557765f, 
    0.03080478f, -0.03109059f, -0.02882332f, -0.03226499f, -0.01431794f, 0.01927671f, -0.00920001f, -0.03589446f, 
    0.01431490f, 0.00420162f, 0.02682301f, -0.02241620f, -0.01262772f, 0.01553251f, -0.00632657f, 0.01130441f, 
    -0.02182109f, 0.02717002f, -0.00593063f, 0.01133909f, -0.02806221f, -0.00909719f, -0.03368276f, -0.02648824f, 
    -0.03339322f, -0.02348033f, -0.00670969f, -0.01009484f, -0.03490695f, -0.01987923f, 0.02715312f, -0.02323706f, 
    -0.04407748f, 0.02407480f, -0.04140541f, 0.02438794f, 0.03228069f, -0.02929590f, -0.03539834f, -0.00239021f, 
    0.01621785f, -0.00751202f, 0.00099645f, -0.01962669f, -0.02516398f, -0.03879644f, 0.01208158f, 0.01384390f, 
    -0.04420001f, 0.00764284f, -0.00813204f, -0.01971656f, -0.01615891f, 0.03358762f, 0.00245973f, -0.02093978f, 
    -0.00169804f, 0.02717650f, -0.00814450f, 0.01157730f, -0.02447930f, 0.02998114f, -0.01252936f, -0.02138438f, 
    0.03159422f, -0.03647934f, 0.02008248f, -0.02059473f, -0.02772181f, 0.01990349f, -0.02580895f, -0.01229616f, 
    -0.00668350f, 0.00089000f, 0.00281617f, 0.01239110f, 0.02226736f, -0.02536654f, 0.00324912f, -0.01909036f, 
    -0.01557029f, -0.00570755f, 0.00937594f, 0.02490035f, 0.02629541f, 0.02361031f, 0.00170906f, -0.01579950f, 
    -0.00753328f, -0.00900533f, -0.03768682f, 0.02987270f, -0.00954955f, -0.00240001f, 0.04121791f, 0.00797227f, 
    0.01144207f, 0.01704730f, 0.01492254f, 0.02320790f, -0.01670423f, -0.00251740f, 0.03527022f, -0.03114216f, 
    0.00116343f, -0.00772059f, 0.01117323f, 0.03155291f, 0.00822116f, 0.03220939f, -0.02181285f, 0.02555744f, 
    -0.00247906f, -0.01959207f, -0.03333747f, -0.00524624f, -0.03166978f, -0.02666769f, -0.00952171f, -0.04371876f, 
    -0.04353244f, -0.01469210f, -0.04069979f, -0.02790328f, 0.00375233f, -0.00939820f, 0.01286434f, -0.00280083f, 
    -0.03428108f, -0.02577664f, 0.01120268f, 0.00295455f, 0.02513243f, -0.03611676f, 0.00769954f, 0.02178268f, 
    -0.04418198f, 0.00541021f, 0.02765220f, -0.01979063f, 0.02803564f, -0.03113844f, -0.03633926f, -0.03140557f, 
    0.00913169f, 0.02992404f, -0.02867234f, 0.00417094f, 0.01814337f, -0.02050987f, 0.02291253f, 0.01207389f, 
    0.02383765f, -0.02062739f, 0.00855661f, -0.02601338f, -0.04406099f, -0.02528714f, -0.01403558f, -0.00858466f, 
    0.02185944f, -0.01679798f, -0.01965054f, -0.03457338f, -0.00729673f, -0.04572298f, 0.01385554f, -0.01230335f, 
    0.03487452f, 0.00983339f, 0.00833174f, -0.00711340f, -0.00864127f, 0.03160033f, 0.01360918f, -0.00642688f, 
    0.00151192f, 0.00783796f, 0.02979340f, 0.01904652f, 0.01946013f, -0.04408464f, -0.03949603f, 0.01525911f, 
    -0.03874495f, 0.03155252f, -0.02892180f, 0.01862750f, -0.03148698f, -0.01574476f, 0.03933816f, -0.02117178f, 
    -0.03882922f, -0.00831316f, -0.04231984f, -0.01802306f, -0.03276606f, -0.04324828f, -0.02416172f, -0.02496253f, 
    -0.02321583f, -0.03505528f, 0.02338402f, -0.00034985f, 0.02769803f, -0.01992906f, 0.00607273f, 0.00208158f, 
    -0.02810076f, 0.03819292f, 0.00652823f, -0.03423309f, 0.00525180f, 0.01912777f, -0.03501241f, 0.02739924f, 
    -0.01211467f, 0.01361269f, 0.02159415f, -0.03435892f, -0.02767414f, -0.00051936f, -0.00303055f, -0.03268126f, 
    -0.02269092f, -0.04624438f, -0.03081798f, -0.01082369f, -0.02941888f, -0.04093122f, -0.01439483f, 0.02432951f, 
    0.02847809f, 0.02571598f, 0.01185823f, -0.00902359f, 0.02419269f, -0.03434950f, 0.00014027f, -0.00401455f, 
    0.01784919f, -0.04373409f, 0.02739003f, 0.02040460f, 0.01450640f, -0.03664744f, 0.03122498f, 0.01853645f, 
    -0.03558321f, -0.02274505f, -0.00643998f, -0.03216954f, 0.02793135f, -0.00974099f, -0.00062993f, -0.03632310f, 
    -0.02596918f, -0.02465288f, -0.04262698f, 0.01913000f, 0.01715524f, -0.04150643f, 0.00954122f, 0.01673758f, 
    -0.02523047f, 0.01138809f, -0.03789988f, -0.00915960f, 0.01042494f, 0.02275947f, -0.02636123f, 0.01747568f, 
    0.01985827f, 0.02743053f, -0.02659143f, -0.00802237f, -0.02841881f, -0.03019627f, -0.02041069f, -0.00737957f, 
    -0.02655921f, -0.03976268f, -0.03634826f, 0.02191476f, -0.00533307f, 0.01801509f, -0.00949517f, -0.03774229f, 
    0.01718474f, 0.01557016f, 0.02948809f, -0.00318570f, 0.00221877f, 0.00291371f, 0.02619217f, -0.02527897f, 
    0.02264860f, 0.02329055f, 0.01722907f, -0.01061150f, -0.04083712f, -0.03096966f, -0.00139539f, 0.02788913f, 
    -0.00576412f, -0.03892381f, -0.03765256f, -0.03886883f, -0.02938451f, -0.03821092f, -0.02755514f, 0.02097797f, 
    -0.02991887f, -0.02709365f, -0.02469279f, 0.01830368f, 0.03186306f, 0.03195955f, -0.01733058f, -0.04234000f, 
    0.00369404f, 0.02973538f, 0.02543379f, -0.00409646f, 0.01765416f, -0.01177842f, 0.00635165f, -0.03745452f, 
    0.00462323f, 0.02966335f, 0.00049542f, 0.01242920f, 0.01745588f, -0.04450466f, -0.01371368f, -0.02251319f, 
    0.02393583f, -0.01329891f, -0.01084142f, -0.03138175f, 0.03040838f, -0.00886556f, 0.02727336f, -0.02136169f, 
    -0.02952935f, -0.03306168f, -0.02030189f, -0.02920486f, 0.00741411f, 0.02914305f, -0.01294108f, -0.02604067f, 
    -0.01682913f, 0.01253971f, -0.03024521f, -0.03534564f, 0.01605286f, -0.03634562f, -0.01141094f, -0.01923481f, 
    -0.00096492f, 0.00898717f, -0.03635842f, 0.00033470f, 0.01592350f, 0.00470157f, -0.02226686f, -0.04120096f, 
    -0.04088334f, 0.01878268f, -0.01000026f, 0.00090045f, -0.03987037f, 0.00124013f, -0.00916391f, -0.02391200f, 
    -0.02996920f, 0.02064439f, 0.00371908f, -0.02022415f, 0.03534989f, 0.03595337f, 0.02176959f, 0.01020230f, 
    -0.04541633f, -0.00646602f, 0.02026580f, 0.01370948f, 0.01027960f, -0.01445816f, 0.00439184f, -0.00023215f, 
    0.00855520f, 0.02011704f, -0.01940634f, 0.01649885f, -0.00594383f, -0.02797615f, -0.03927400f, -0.00697153f, 
    0.02997764f, -0.00010040f, -0.03243839f, -0.00429908f, 0.00756068f, -0.00844629f, -0.02441010f, -0.01516639f, 
    -0.02548521f, -0.03549654f, 0.02100176f, -0.04621171f, -0.00879339f, -0.04426980f, 0.00085308f, 0.03154676f, 
    0.00301528f, 0.03212618f, -0.01302105f, -0.03615637f, -0.00560333f, 0.01934576f, 0.03351486f, -0.03041723f, 
    -0.00931244f, -0.01855430f, 0.02568405f, -0.01860674f, 0.01354528f, -0.00517308f, -0.04079023f, -0.01092779f, 
    0.02974872f, -0.02634393f, -0.00848751f, 0.02204669f, 0.03072410f, -0.03364647f, -0.00218616f, -0.03996629f, 
    0.01037392f, -0.04725609f, -0.01142869f, 0.02763787f, 0.00973575f, -0.01970411f, 0.02963335f, 0.01028466f, 
    0.04742033f, 0.00570822f, -0.02062848f, 0.00047041f, -0.00053975f, -0.00376709f, 0.03067944f, -0.03393339f, 
    -0.01516655f, -0.02933311f, -0.02943394f, -0.04485482f, -0.02962629f, -0.00107931f, 0.01842625f, 0.02542785f, 
    0.01545320f, -0.00162552f, 0.01871927f, 0.01651914f, -0.01311237f, 0.03872646f, 0.04033082f, -0.02775486f, 
    -0.03069840f, -0.03188615f, -0.00583292f, -0.00986234f, -0.02378044f, 0.01814684f, -0.01006423f, -0.00608769f, 
    0.02679327f, 0.03093166f, 0.01732390f, -0.00499024f, -0.01728454f, -0.00065285f, 0.02556893f, -0.00360178f, 
    -0.01750245f, 0.00808514f, 0.02124408f, -0.00082419f, -0.03584190f, -0.03156770f, 0.00456088f, 0.00742126f, 
    0.02192073f, -0.04498495f, -0.00900064f, -0.02974406f, -0.00214154f, -0.02009000f, 0.00979031f, -0.04457340f, 
    0.02541006f, -0.01066697f, -0.00418234f, 0.00386660f, -0.00374244f, 0.01811501f, -0.04078655f, -0.00182910f, 
    -0.03535747f, -0.00399212f, 0.02888161f, -0.01452520f, -0.04396330f, 0.02636564f, 0.00997014f, -0.02601933f, 
    -0.01392042f, 0.03105740f, -0.04055034f, 0.01240717f, -0.04212529f, -0.01901557f, -0.02866877f, 0.00364159f, 
    0.01643026f, 0.04771824f, 0.02693837f, -0.00639913f, 0.01363842f, 0.01828865f, -0.02520965f, 0.01912827f, 
    -0.00763834f, 0.02278681f, -0.04618988f, 0.01421378f, -0.02016879f, -0.00867459f, -0.03350791f, 0.01805807f, 
    0.01412327f, -0.03844470f, 0.00008170f, -0.04220322f, 0.01197325f, -0.00264875f, -0.02257938f, -0.04500656f, 
    -0.00428326f, 0.02850281f, -0.01538264f, 0.02122553f, -0.00019871f, 0.00958900f, -0.00881828f, -0.01879092f, 
    -0.02287656f, -0.04126086f, 0.01194837f, 0.01149563f, 0.02560114f, -0.04032788f, -0.00127299f, -0.02078431f, 
    0.03206587f, 0.00429357f, 0.02981787f, 0.01499001f, 0.01088026f, -0.03149404f, 0.01871368f, -0.03761965f, 
    0.01105540f, 0.01409458f, -0.01132326f, 0.01556676f, 0.02769009f, -0.02907496f, -0.00173302f, -0.00715415f, 
    -0.00640726f, -0.03360936f, -0.01283507f, 0.00707081f, -0.03868759f, -0.02789240f, 0.00850653f, -0.02013843f, 
    -0.01330391f, -0.00376568f, -0.01739228f, -0.00739156f, -0.01487815f, -0.02907138f, 0.00270475f, 0.00912516f, 
    -0.03134766f, 0.02325085f, 0.00553790f, 0.02659573f, 0.03215365f, 0.02244468f, -0.01955387f, -0.03650565f, 
    0.01498500f, -0.01293925f, -0.03028593f, 0.00153258f, 0.01016983f, -0.02869742f, -0.01321521f, -0.04171188f, 
    0.03500325f, -0.00446882f, 0.02240245f, 0.02748871f, 0.01651804f, -0.01871937f, -0.00742112f, -0.03270507f, 
    0.02044328f, -0.02722469f, -0.01023654f, 0.00133334f, -0.00612746f, 0.00631390f, -0.04282848f, -0.01490805f, 
    0.02803715f, 0.02906806f, 0.04315007f, -0.04025177f, -0.01343898f, 0.01342466f, -0.03154657f, -0.02204163f, 
    -0.04329294f, -0.01962224f, -0.02581650f, -0.01593751f, -0.02815011f, -0.04450627f, -0.00209842f, -0.00536943f, 
    -0.02117666f, -0.01876626f, -0.01951754f, -0.03943763f, -0.02335780f, -0.04630825f, -0.01935450f, 0.01770376f, 
    0.02155673f, 0.00458611f, -0.04062975f, 0.01317855f, -0.03611129f, -0.00646565f, 0.02609829f, -0.02992403f, 
    0.02803105f, 0.01678357f, -0.03119011f, -0.01967197f, 0.01953037f, 0.01157321f, -0.01122890f, -0.04172210f, 
    0.00188633f, -0.03057484f, 0.02214838f, -0.00905088f, -0.02284039f, 0.02770750f, -0.03278282f, 0.02315952f, 
    0.01357178f, 0.02446062f, -0.02866575f, -0.03019124f, -0.01534681f, -0.00484359f, -0.03333234f, -0.00434537f, 
    -0.01961858f, 0.00940359f, 0.01382263f, 0.01528523f, -0.04242203f, 0.01788081f, -0.04364207f, -0.01321740f, 
    0.00827212f, 0.01982986f, 0.00855298f, -0.00760793f, -0.01509663f, 0.01340993f, 0.02326346f, -0.00032564f, 
    -0.03035004f, -0.00100403f, -0.02855002f, 0.00946653f, -0.03717269f, -0.03625147f, -0.04450574f, 0.02548846f, 
    -0.04394400f, -0.00739666f, -0.02764758f, -0.02402394f, -0.03864474f, 0.00804713f, 0.02754585f, -0.02660920f, 
    -0.00795090f, -0.00277579f, -0.03590062f, 0.00597985f, 0.01567767f, -0.00602262f, -0.00743174f, 0.02534968f, 
    0.03709008f, -0.18108015f, -0.54888177f, -0.11769323f, -0.04313590f, 0.26013893f, 0.14570875f, 0.05141489f, 
    0.15333426f, -0.07688085f, -0.03915090f, -0.03646626f, 0.02212992f, 0.04722222f, 0.02301692f, 0.14099075f, 
    -0.01858220f, -0.09486149f, 0.18680434f, -0.02310075f, 0.38768649f, 0.20317921f, -0.35916293f, -0.02379097f, 
    0.12996398f, -0.01199829f, -0.11638601f, 0.06237518f, 0.29786089f, 0.18745576f, 0.03247323f, 0.03913142f, 
    0.02092295f, -0.19680011f, 0.00039904f, 0.18378365f, 0.10739128f, 0.05937292f, 0.18760602f, -0.05073406f, 
    0.09957773f, -0.03475833f, -0.54322714f, 0.00291589f, -0.07485776f, -0.08373325f, 0.07424528f, 0.09299087f, 
    -0.07329015f, 0.06367116f, 0.05043731f, 0.04976393f, -0.01899616f, 0.03769873f, 0.15024099f, 0.13355027f, 
    0.01906194f, 0.24535352f, -0.17629473f, -0.09049027f, -0.16115409f, 0.09101662f, 0.07766928f, 0.17109419f, 
    0.09921765f, -0.00712431f, -0.07914670f, 0.01570770f, -0.03646066f, -0.02589944f, -0.04319791f, -0.07084029f, 
    -0.00659922f, 0.04212195f, 0.02523926f, 0.00326870f, -0.02776911f, -0.16476591f, -0.02749310f, 0.07710835f, 
    -0.17605032f, -0.05856341f, 0.01117011f, -0.16266344f, -0.21256186f, -0.10912555f, -0.21284656f, -0.07674656f, 
    -0.11051832f, -0.12663989f, -0.12684482f, -0.07422923f, -0.14617369f, 0.06747092f, -0.15284298f, 0.10503501f, 
    0.05685191f, -0.07203703f, 0.03674297f, 0.02126304f, -0.46597919f, -0.04967622f, 0.08244871f, -0.14931382f, 
    -0.09091306f, -0.10516186f, -0.18475644f, 0.04647460f, -0.07815398f, -0.12967546f, -0.13244016f, -0.01469653f, 
    0.03273661f, 0.11709749f, 0.03839567f, -0.16229860f, 0.02118975f, -0.05640331f, 0.07367092f, 0.05664309f, 
    0.18216847f, 0.07424551f, -0.03723473f, -0.17848776f, 0.00023215f, -0.12630947f, 0.10100462f, 0.27080888f, 
    -0.00986745f, -0.06356308f, 0.03313338f, 0.02986942f, -0.00090677f, -0.09326144f, 0.07721084f, 0.10326242f, 
    0.21148981f, -0.00370242f, 0.29112273f, 0.06990671f, 0.48566481f, -0.25034478f, 0.25407073f, 0.17795970f, 
    0.13981083f, -0.10350862f, -0.10278123f, -0.25844613f, 0.14314444f, -0.03275103f, 0.22008379f, 0.01994371f, 
    0.17577696f, 0.03193569f, -0.13524923f, 0.13828951f, 0.03452701f, -0.06339193f, -0.03451199f, -0.19135195f, 
    0.39278612f, 0.10275296f, 0.35642940f, 0.11163776f, 0.06480119f, -0.03183813f, -0.10357266f, -0.08332090f, 
    -0.13555497f, -0.10114792f, 0.35556731f, 0.10615160f, 0.07855099f, -0.00608511f, 0.02191691f, 0.12552159f, 
    0.10502022f, -0.16069663f, -0.02126724f, -0.00470457f, -0.26730138f, 0.07312971f, 0.21328308f, -0.19568071f, 
    -0.14139359f, -0.16703305f, 0.23886655f, -0.23898017f, 0.00683477f, 0.09190770f, 0.15326318f, 0.12682436f, 
    -0.07315704f, 0.07839770f, 0.05343591f, -0.01326617f, 0.15181260f, -0.02693531f, 0.13859770f, -0.06730534f, 
    -0.01508545f, -0.17693207f, -0.02448856f, -0.06753052f, -0.14320613f, -0.23042803f, -0.07829784f, -0.05828413f, 
    -0.07341793f, -0.15257962f, -0.06409329f, 0.01632294f, -0.09256966f, -0.17403844f, -0.06142912f, -0.12073163f, 
    0.04609567f, -0.03369424f, 0.10320832f, 0.02291753f, 0.12215907f, 0.04709255f, -0.20163171f, 0.08061220f, 
    -0.05956612f, 0.01983813f, 0.10340493f, 0.04627042f, 0.13564125f, 0.00577799f, 0.05499842f, 0.01646118f, 
    -0.00084783f, 0.08787035f, 0.08397576f, -0.09524138f, -0.14280736f, 0.12951437f, -0.02886486f, -0.10094339f, 
    -0.15795526f, -0.26941958f, -0.19355328f, 0.01414252f, -0.13541391f, -0.01690113f, -0.22354351f, 0.15584695f, 
    -0.05352800f, -0.14465861f, 0.04962334f, 0.06321804f, 0.10387632f, 0.03332504f, 0.01421019f, -0.07451431f, 
    0.08458821f, 0.21533588f, 0.12258592f, 0.22078654f, -0.22972931f, 0.13635829f, 0.13449527f, -0.12178721f, 
    -0.09001715f, -0.12999710f, -0.08625568f, -0.08761239f, -0.10997709f, -0.06945727f, -0.04334617f, 0.06437701f, 
    0.12602217f, 0.07057399f, 0.03468122f, 0.10110823f, -0.05683838f, -0.16485880f, -0.02506593f, -0.06507685f, 
    -0.12153813f, -0.04168322f, -0.53679407f, -0.25347224f, -0.07330343f, 0.09866890f, 0.17121491f, 0.00537327f, 
    -0.09576042f, -0.18612821f, 0.03422795f, 0.07232303f, 0.04435606f, 0.11486089f, 0.10330410f, 0.03162222f, 
    -0.04551839f, -0.05729938f, 0.05631673f, -0.28163248f, 0.12893470f, 0.12726925f, 0.25703695f, 0.12914874f, 
    0.04023798f, -0.08296392f, -0.01269983f, -0.08352027f, -0.00726487f, 0.03857948f, 0.07872719f, 0.09626834f, 
    0.13551365f, 0.11896353f, 0.01010682f, 0.09323578f, 0.05588616f, -0.12145375f, 0.14810358f, 0.02711233f, 
    -0.22437693f, 0.17285679f, -0.24890523f, 0.00086273f, 0.07650843f, -0.06688938f, 0.02275054f, 0.06854048f, 
    0.03407557f, -0.00543944f, -0.03901263f, 0.05085525f, -0.02327190f, 0.05035497f, 0.01993837f, 0.07917794f, 
    0.03264851f, 0.02803738f, 0.20653808f, -0.02251760f, 0.24827243f, -0.00361052f, 0.20139126f, 0.09464287f, 
    0.10457686f, -0.01074331f, 0.02584868f, 0.01005009f, 0.08381152f, -0.06078081f, 0.09944886f, 0.07502672f, 
    0.07576875f, 0.14851210f, 0.03773521f, 0.04433683f, 0.08538622f, -0.00615496f, 0.07406493f, -0.03442449f, 
    -0.28115314f, 0.06784150f, 0.13364285f, -0.11326353f, -0.12166597f, -0.12383930f, -0.05224118f, -0.02503417f, 
    -0.06809850f, -0.04171607f, -0.04730666f, -0.01968709f, 0.05089185f, 0.00268567f, -0.00503451f, 0.18205938f, 
    0.00380003f, -0.12115290f, -0.07149979f, 0.05352871f, -0.21261571f, -0.19380604f, 0.32117417f, -0.08442047f, 
    -0.08121578f, -0.16709612f, -0.07142465f, 0.00726165f, -0.02273379f, -0.07340995f, 0.09469342f, 0.15363909f, 
    0.00587572f, 0.08104460f, 0.14190204f, -0.07830045f, 0.04592120f, -0.08981181f, -0.01875422f, -0.06847344f, 
    -0.03960613f, -0.12183544f, 0.10348915f, -0.02906802f, -0.03200344f, -0.03738080f, 0.08978844f, 0.07013898f, 
    -0.00931245f, -0.00109378f, -0.00204096f, 0.12174002f, -0.05455188f, 0.08457417f, 0.06863237f, -0.00001109f, 
    0.09409494f, 0.01889356f, 0.07601631f, 0.02490732f, 0.11290399f, 0.51969689f, -0.17064422f, -0.03630183f, 
    0.26196927f, -0.11016075f, -0.10201278f, 0.20247695f, 0.05815327f, 0.07287555f, 0.10811614f, 0.11169851f, 
    0.04650567f, 0.07352106f, 0.01283660f, 0.13320175f, 0.16636710f, -0.10874544f, 0.29073718f, 0.06389476f, 
    -0.03759626f, 0.02668678f, 0.05037890f, 0.12234720f, 0.03482273f, -0.06947052f, -0.09226970f, 0.04530062f, 
    0.05683137f, -0.09129950f, -0.04141514f, 0.14926207f, 0.15422791f, 0.03517801f, 0.11533535f, 0.02362779f, 
    -0.13701272f, 0.05416494f, 0.00464169f, 0.05675353f, -0.40544835f, -0.08925001f, -0.32056570f, -0.02278321f, 
    -0.09844344f, -0.27448159f, 0.08473463f, 0.28568599f, -0.09053794f, 0.10247377f, -0.11804869f, -0.02589157f, 
    -0.02404478f, 0.05180514f, 0.05770441f, -0.01246018f, 0.05387316f, -0.03777054f, 0.03799281f, 0.01135485f, 
    0.06769457f, 0.19434361f, -0.15309902f, -0.09966874f, -0.08587729f, 0.00238387f, -0.04022014f, -0.18367355f, 
    0.00114487f, -0.00852873f, 0.17477475f, 0.06581740f, -0.10235937f, 0.13629560f, 0.06949487f, -0.02471416f, 
    0.00395338f, -0.02925524f, 0.03702779f, 0.07272013f, 0.20168047f, -0.09474260f, -0.39917308f, -0.01224957f, 
    -0.15332587f, 0.02979573f, 0.09649760f, 0.09433217f, -0.00416723f, -0.09272031f, 0.08235878f, -0.02255755f, 
    0.02604100f, 0.12405995f, 0.19248064f, -0.00592496f, -0.07155220f, 0.12426654f, -0.09590334f, -0.10870783f, 
    -0.19810890f, -0.16996801f, -0.38557512f, -0.09192909f, -0.04480362f, -0.22946703f, -0.05612991f, -0.09446450f, 
    0.03086519f, -0.13225549f, -0.15276879f, 0.01018164f, 0.01811323f, 0.04414435f, 0.04024648f, 0.05325548f, 
    0.09738684f, 0.10362250f, 0.10559135f, 0.01286821f, -0.11630505f, 0.31475231f, -0.09618100f, 0.01235362f, 
    0.06111516f, -0.06726211f, -0.06579723f, -0.03346834f, 0.02692499f, 0.02670913f, -0.01946464f, -0.00097834f, 
    -0.03758066f, 0.12219215f, -0.04403453f, -0.07580269f, -0.01052181f, -0.18093552f, 0.03225954f, 0.06119557f, 
    0.04833682f, 0.11940897f, 0.22347799f, 0.16366298f, 0.25941956f, 0.00155891f, 0.07035302f, 0.00869690f, 
    0.02648080f, 0.04130684f, 0.15405868f, -0.00804599f, -0.05379770f, 0.08067888f, 0.07095668f, 0.09261670f, 
    0.01093029f, -0.05548557f, 0.08946928f, -0.03577190f, 0.00051809f, 0.01911928f, -0.32077363f, -0.13721077f, 
    -0.13723524f, -0.21742733f, -0.11082288f, -0.03875639f, -0.09156921f, -0.18305780f, 0.02781695f, 0.03397948f, 
    0.02260369f, 0.09562980f, 0.05080799f, 0.01365194f, -0.00192518f, 0.30865231f, -0.08026846f, -0.10892456f, 
    0.15927698f, -0.21250500f, -0.28241241f, 0.02885915f, -0.25032935f, 0.17294335f, 0.07560576f, 0.08263167f, 
    -0.10780492f, -0.03212814f, 0.00487124f, 0.05022214f, 0.01329224f, 0.11997173f, 0.05586356f, 0.08146844f, 
    0.32028899f, 0.09129156f, 0.07835139f, 0.06650995f, -0.54933006f, -0.12456130f, -0.21848170f, -0.15449171f, 
    0.00519594f, -0.20685847f, -0.01370642f, 0.13509370f, -0.04760410f, 0.21193139f, -0.14938173f, -0.02624946f, 
    0.02854895f, -0.00440085f, 0.02573226f, 0.08476097f, -0.00962414f, -0.01919126f, 0.11420873f, -0.02022191f, 
    -0.10862011f, -0.20618202f, 0.11396018f, -0.11608838f, -0.07493652f, 0.13819601f, 0.03140292f, 0.15048477f, 
    -0.02821625f, -0.15394537f, -0.08537631f, -0.00556521f, -0.00260360f, -0.05487662f, 0.14181828f, 0.00502749f, 
    0.04783202f, 0.10702680f, 0.10494556f, 0.03477267f, -0.34672105f, 0.10909697f, -0.04215266f, 0.07669224f, 
    0.11467174f, 0.04109904f, -0.02527035f, -0.03506193f, -0.12204553f, 0.12084483f, -0.19770229f, -0.00942551f, 
    -0.11409448f, 0.00272700f, -0.07632515f, -0.00023404f, -0.14143805f, -0.02588800f, -0.05650655f, -0.03372091f, 
    0.24424055f, 0.06157032f, -0.10411311f, 0.29106975f, -0.22981249f, -0.09383442f, 0.19809659f, -0.17127478f, 
    0.12586053f, 0.08662312f, 0.09826312f, 0.04410785f, 0.05261512f, 0.11910927f, 0.03703220f, 0.10937876f, 
    -0.06976413f, 0.01779243f, 0.03916313f, 0.08189341f, -0.09965125f, 0.04072385f, 0.27695501f, 0.11747626f, 
    0.03537259f, 0.08783925f, -0.05459705f, -0.04892294f, -0.14147761f, -0.07809976f, -0.07927782f, -0.01015171f, 
    -0.00207698f, -0.06813883f, 0.09271148f, -0.07357236f, -0.19803447f, 0.00487765f, -0.04548644f, 0.03135026f, 
    0.15278848f, -0.21306711f, 0.15007947f, -0.16911817f, 0.06913014f, -0.11203352f, 0.04437417f, -0.01888236f, 
    0.06925437f, -0.12088388f, -0.17079209f, -0.04334622f, -0.13055800f, -0.07549541f, -0.06225995f, 0.03695255f, 
    0.08311549f, 0.05210454f, 0.00420904f, -0.08656101f, 0.64860815f, -0.28918329f, 0.20817891f, -0.16291127f, 
    0.14382003f, -0.05091565f, 0.08210259f, -0.09340209f, 0.17333013f, -0.05959531f, -0.07805113f, -0.01424164f, 
    -0.02337906f, 0.00742265f, 0.02309142f, -0.00527259f, 0.03024728f, 0.06837342f, 0.06785256f, -0.04365028f, 
    0.30262384f, -0.09248178f, -0.01597842f, -0.12340546f, 0.12395324f, 0.11378738f, -0.04132852f, 0.02655912f, 
    0.10421948f, 0.07437192f, -0.16085933f, 0.03357413f, 0.00192611f, 0.05669678f, 0.10559115f, 0.19289562f, 
    -0.01498027f, 0.19267143f, 0.09590823f, 0.01746682f, -0.07225136f, 0.23288128f, 0.09574646f, -0.14680254f, 
    0.10068804f, 0.09229730f, -0.12527633f, 0.01647495f, -0.17228696f, -0.20832555f, -0.16129927f, 0.03133344f, 
    -0.11627799f, 0.07644583f, 0.03700212f, -0.04443973f, -0.16079426f, 0.04755903f, -0.13060606f, -0.19288377f, 
    -0.27941620f, 0.29512903f, 0.02652799f, 0.06935889f, 0.32846057f, -0.06742159f, 0.01243153f, -0.25362310f, 
    -0.12609755f, -0.07993690f, 0.24242312f, 0.04090102f, 0.06519424f, -0.04039127f, 0.05735637f, -0.14603728f, 
    -0.05914089f, 0.04676565f, 0.14757551f, -0.19586633f, -0.07996976f, 0.07915547f, 0.15071489f, 0.41937849f, 
    0.06468938f, -0.03190074f, 0.24505973f, -0.05085180f, 0.22315717f, 0.00579676f, 0.03996602f, 0.05652499f, 
    -0.04735519f, -0.10091629f, -0.05814021f, -0.05149346f, 0.13130589f, 0.05601062f, 0.17986524f, -0.00076359f, 
    0.08022935f, -0.07475375f, 0.08769079f, -0.06062222f, -0.19327617f, 0.12330320f, -0.08855303f, -0.09122781f, 
    -0.08721130f, -0.06028553f, -0.06373023f, -0.01667689f, -0.03156321f, -0.01572530f, -0.00939807f, -0.08796601f, 
    0.01276640f, 0.08231951f, -0.08427136f, 0.00601774f, 0.03564604f, 0.11598518f, -0.10005417f, -0.02686183f, 
    0.13863631f, 0.15450007f, -0.03909734f, 0.10793293f, -0.06790902f, -0.04670368f, -0.03696088f, 0.00853263f, 
    0.02691880f, -0.00501216f, 0.05216347f, -0.12470423f, -0.12359877f, -0.06142626f, -0.04007119f, -0.29541889f, 
    -0.12541912f, -0.30376819f, 0.03054975f, 0.06224884f, -0.03198572f, -0.10176255f, -0.13799858f, 0.02889172f, 
    -0.03249863f, -0.24625012f, 0.11542881f, -0.05791176f, -0.06571737f, -0.03483309f, 0.00852180f, 0.00309258f, 
    0.14858665f, 0.14453676f, 0.09572510f, 0.32076308f, -0.00781939f, -0.03752197f, 0.04508308f, -0.19804925f, 
    -0.05799666f, -0.04154275f, -0.04066431f, -0.10689534f, -0.04574880f, -0.03522959f, -0.17479241f, -0.03638004f, 
    -0.11964600f, 0.07969412f, 0.05153059f, 0.09099381f, 0.06364657f, -0.03205414f, -0.02702493f, -0.20543033f, 
    -0.13732123f, -0.04629698f, 0.24053544f, -0.27992657f, 0.09271706f, 0.01496467f, -0.02691135f, -0.01976515f, 
    0.09956779f, -0.18388000f, -0.01271320f, 0.13352959f, 0.02660480f, -0.03481662f, 0.12654074f, 0.18551931f, 
    -0.16693427f, -0.03838547f, -0.14433064f, -0.10907263f, 0.05946277f, -0.17391163f, 0.16460276f, -0.17897004f, 
    0.06961533f, 0.04090967f, 0.04569811f, 0.01672236f, -0.01475295f, 0.19006144f, -0.02529053f, 0.06382000f, 
    0.11335927f, 0.16256765f, 0.06219562f, -0.06799806f, 0.03051644f, 0.12805490f, 0.00578735f, -0.12995367f, 
    -0.03361707f, -0.00523890f, -0.00969664f, -0.03509589f, 0.18391608f, -0.14998642f, 0.19331427f, 0.02549743f, 
    0.07363869f, 0.04897974f, -0.00464651f, -0.11514232f, 0.08068378f, -0.09829956f, -0.06206734f, 0.11789930f, 
    -0.02460659f, -0.02495485f, -0.01016365f, -0.09146117f, -0.17479098f, 0.20271756f, -0.06390427f, -0.06193127f, 
    0.24819724f, 0.05172506f, -0.05317478f, -0.01993048f, 0.08248814f, 0.09934685f, 0.09344771f, 0.18867953f, 
    0.08268487f, 0.06424081f, 0.16055435f, 0.08001565f, -0.01018046f, 0.07810243f, 0.15524100f, 0.16291672f, 
    -0.02572067f, 0.01641341f, 0.10646447f, -0.11914878f, 0.01964414f, -0.12385077f, -0.05834085f, -0.03994145f, 
    -0.02945424f, -0.03166098f, -0.12731633f, -0.10687112f, -0.10450569f, 0.04610418f, 0.07210837f, 0.06685849f, 
    0.09172563f, 0.03401654f, 0.08161192f, -0.10054377f, -0.14341444f, -0.18564086f, -0.04128895f, -0.09623967f, 
    -0.06871206f, -0.01275187f, 0.00364988f, -0.01125306f, -0.02248464f, -0.05214238f, -0.02269186f, 0.13708864f, 
    -0.00087010f, 0.13906230f, 0.17782199f, -0.01001610f, -0.00241561f, 0.16452454f, 0.10348116f, -0.03930784f, 
    -0.33917752f, 0.18520638f, 0.07594195f, -0.06070253f, 0.08763519f, -0.04847294f, -0.02516630f, 0.16106175f, 
    0.10855241f, 0.15711509f, -0.00065930f, 0.14014091f, 0.08935331f, -0.12587766f, -0.02374277f, -0.06035721f, 
    0.03732316f, 0.08900630f, 0.06273778f, 0.03473715f, 0.56446069f, -0.13276222f, 0.25645837f, 0.00549160f, 
    0.35593581f, 0.10589764f, 0.18288136f, 0.00926832f, 0.16589616f, 0.27382368f, -0.01316646f, -0.07079110f, 
    0.00036664f, 0.13264917f, 0.08259615f, 0.16541529f, 0.22799017f, 0.06420036f, 0.06744247f, -0.07526427f, 
    0.09564976f, 0.10020210f, -0.10945893f, 0.17884128f, 0.05275236f, 0.05378452f, -0.02629034f, 0.01209762f, 
    -0.01670002f, -0.07352341f, -0.00268690f, 0.05848445f, -0.08026018f, 0.17061599f, 0.18502441f, 0.06821229f, 
    0.05485411f, 0.10229362f, -0.00931015f, 0.18737720f, -0.27740687f, -0.12019904f, 0.07770551f, 0.07952478f, 
    -0.06305338f, 0.29010418f, -0.00853897f, 0.15677121f, -0.11809824f, 0.17097390f, -0.24301773f, 0.11434106f, 
    -0.03543146f, -0.02205322f, 0.03911665f, 0.06830557f, 0.07046130f, -0.01606575f, 0.12274604f, 0.32233381f, 
    -0.16175017f, 0.34541124f, -0.41017243f, 0.08637379f, -0.02947211f, -0.13920584f, 0.00664072f, -0.04355245f, 
    0.10103536f, 0.01909170f, 0.05249725f, 0.05756800f, -0.02214513f, 0.00074486f, 0.09178409f, -0.05104388f, 
    -0.05922847f, -0.02647070f, 0.13920188f, -0.02999569f, 0.01277590f, 0.12088291f, -0.25208664f, -0.05980679f, 
    0.01798711f, 0.14493729f, -0.00459245f, 0.03581166f, -0.11993953f, -0.08489037f, 0.03643515f, 0.03669547f, 
    -0.03705822f, -0.07165299f, 0.11564682f, 0.00554046f, 0.02024604f, -0.04731218f, -0.06961545f, -0.18668859f, 
    -0.19518675f, -0.44342190f, -0.17926893f, -0.25364062f, -0.24970429f, -0.02294755f, 0.02212824f, -0.25714025f, 
    -0.19515082f, -0.41706190f, -0.05190425f, -0.01462558f, 0.00094574f, -0.05195263f, 0.06455864f, -0.11784623f, 
    0.04249716f, 0.01256796f, 0.07986496f, 0.19974288f, 0.31077671f, 0.19562878f, 0.32271090f, 0.13602147f, 
    0.08298316f, -0.01628363f, -0.09950816f, 0.12020689f, 0.18760540f, 0.16347572f, -0.07578146f, -0.12425703f, 
    0.03520251f, -0.05209092f, 0.04955805f, 0.16037096f, -0.12539048f, 0.07313193f, 0.34810349f, -0.03761100f, 
    -0.29086384f, 0.28641450f, 0.14764048f, -0.16313361f, 0.56688476f, -0.04880023f, 0.00418000f, 0.01636309f, 
    0.18933970f, 0.11140510f, 0.02395975f, 0.13841715f, 0.08005857f, 0.01314072f, -0.01806956f, -0.19599840f, 
    -0.13497792f, -0.09892380f, 0.01525863f, -0.11563581f, 0.04468193f, -0.02741849f, -0.20835958f, 0.00552851f, 
    -0.17444897f, 0.04731184f, 0.06150744f, -0.05867488f, -0.12818895f, -0.16993101f, -0.00197037f, 0.01596882f, 
    -0.06135987f, 0.00063631f, 0.12869889f, -0.00623825f, -0.16671938f, -0.00880573f, 0.00223386f, -0.19902168f, 
    0.05119555f, -0.04080048f, -0.04840185f, 0.18125035f, 0.03062417f, 0.09151921f, 0.05604299f, 0.05212243f, 
    0.08280378f, -0.09447354f, 0.00679621f, 0.05904428f, 0.02228156f, 0.00255051f, 0.13448833f, -0.05629847f, 
    0.14269772f, 0.02226090f, 0.17294718f, 0.04996983f, -0.27919424f, -0.06351800f, -0.15250416f, -0.12736672f, 
    -0.14073414f, -0.19213234f, 0.14859059f, -0.10684838f, -0.03992197f, -0.08392954f, -0.15490633f, -0.12385608f, 
    -0.11468611f, -0.14818904f, -0.00019246f, -0.01059295f, 0.03948980f, -0.02621565f, -0.01353762f, 0.01582861f, 
    -0.01844574f, 0.01183993f, 0.18539348f, 0.19065684f, 0.30239168f, -0.05151923f, -0.03316174f, 0.10573898f, 
    0.02715462f, -0.04159774f, -0.03626628f, -0.04668405f, 0.03721919f, -0.01584110f, 0.06716074f, -0.04868608f, 
    -0.17705703f, -0.10479967f, -0.00726608f, 0.04933868f, -0.11323002f, -0.07119513f, 0.09001245f, 0.36626777f, 
    0.18849014f, 0.15186803f, 0.00875275f, -0.00076305f, 0.08341984f, 0.01263235f, -0.03154835f, 0.02396343f, 
    0.11862255f, 0.10174128f, 0.05210570f, 0.07715511f, 0.18996425f, 0.11588737f, 0.19146113f, 0.15030183f, 
    -0.31422380f, 0.18188570f, -0.11923131f, 0.25101462f, 0.19087580f, -0.22735645f, 0.07927360f, -0.02793477f, 
    -0.02860265f, -0.12740532f, -0.12456343f, -0.05293452f, 0.01895500f, -0.06193048f, -0.03650463f, 0.02149294f, 
    0.07271171f, 0.04316550f, 0.02668771f, -0.21193798f, 0.69611627f, -0.00866071f, 0.31918323f, -0.05279832f, 
    -0.07181361f, -0.15359300f, -0.07166407f, -0.05874849f, -0.00377273f, -0.03550835f, -0.00311520f, 0.00116814f, 
    0.01384338f, -0.08946688f, -0.00114554f, 0.02637025f, 0.14255440f, 0.14973950f, 0.10048979f, 0.13625565f, 
    0.40183735f, 0.11091618f, 0.07208128f, -0.12881020f, 0.16214404f, -0.13777611f, -0.04101492f, -0.02420336f, 
    -0.11117504f, -0.04822718f, -0.03158084f, 0.04443737f, 0.03830581f, -0.04543940f, -0.03613014f, 0.03075888f, 
    0.22656626f, -0.05147477f, -0.09965125f, 0.01421919f, 0.02849112f, -0.14753050f, 0.16932563f, 0.01731331f, 
    0.08435371f, 0.04713031f, -0.03397195f, -0.15477249f, 0.06904937f, -0.09072271f, 0.02098607f, 0.04433985f, 
    -0.04541649f, 0.08358833f, -0.17946565f, -0.05734139f, 0.04395773f, 0.13418178f, -0.15153906f, -0.02480284f, 
    0.38299632f, -0.17132810f, 0.16297215f, -0.23868552f, 0.04334215f, 0.00145797f, 0.11139774f, -0.05384370f, 
    -0.08526083f, 0.07791232f, 0.08222584f, -0.05049430f, 0.07278145f, 0.03270220f, -0.01404914f, -0.05034074f, 
    -0.02155561f, -0.22044802f, 0.01637580f, 0.08719692f, -0.64430165f, 0.06416116f, 0.11760692f, 0.15187278f, 
    0.22053401f, 0.21482988f, 0.09273606f, 0.03815784f, -0.15493283f, 0.14215767f, 0.06287972f, -0.07616782f, 
    0.34761298f, -0.01461896f, -0.00754298f, 0.08050776f, -0.07873508f, -0.08815402f, 0.09285916f, 0.04253960f, 
    0.47895619f, 0.66743594f, -0.05962805f, 0.21855083f, -0.36034104f, -0.02221438f, 0.08505459f, 0.01266650f, 
    0.05577116f, 0.01005371f, -0.17077471f, -0.04334737f, 0.08681808f, 0.24155989f, -0.00528405f, 0.08703404f, 
    0.00418580f, 0.01392161f, -0.12177088f, 0.05207408f, 0.03381936f, -0.16192693f, -0.22674614f, 0.12745845f, 
    0.30290753f, -0.06306306f, -0.05578588f, 0.16058113f, 0.00072733f, 0.08292966f, 0.09787878f, 0.13614632f, 
    -0.08575672f, 0.04142204f, 0.13105927f, 0.02951419f, -0.15275581f, -0.12405296f, 0.03503359f, 0.02734270f, 
    0.03825056f, -0.08593893f, 0.00735152f, -0.00342104f, -0.07633019f, -0.12455030f, -0.03668396f, -0.06746207f, 
    -0.04889960f, 0.00784355f, 0.04133747f, -0.05095956f, -0.00214987f, -0.01792821f, 0.03827971f, 0.19138117f, 
    0.12172376f, -0.18647094f, -0.00246103f, -0.08404213f, -0.12202565f, -0.07303206f, 0.14092025f, 0.28914648f, 
    -0.01947250f, 0.13835995f, 0.03085044f, -0.19039400f, 0.14378925f, 0.02538433f, 0.05725603f, 0.01458775f, 
    0.07344662f, 0.03739493f, 0.13701317f, 0.01875228f, 0.02930986f, -0.09549258f, 0.25803927f, 0.31864053f, 
    -0.16949527f, -0.11497757f, 0.14906971f, -0.07470344f, 0.09610631f, 0.11291879f, 0.02142326f, -0.13048868f, 
    0.17518850f, 0.05753250f, 0.00777894f, 0.06364910f, -0.05134639f, 0.07620472f, -0.03433757f, -0.07955769f, 
    -0.15209842f, -0.17718165f, -0.01070699f, -0.26419693f, 0.15172744f, -0.25137722f, -0.11133830f, -0.20768817f, 
    0.03798717f, -0.03522764f, -0.04305350f, 0.03742228f, -0.04132825f, -0.02644806f, 0.02441904f, -0.04683844f, 
    0.14431468f, -0.11760207f, 0.01244153f, 0.14751537f, 0.05816066f, -0.14702502f, -0.03075773f, 0.00157366f, 
    0.04835518f, -0.13344975f, -0.07674129f, 0.08282194f, 0.34237534f, 0.12997755f, 0.00988610f, 0.01409423f, 
    -0.03600011f, 0.06046013f, -0.05243735f, -0.03624083f, 0.06277047f, -0.09571017f, 0.02014583f, -0.06385062f, 
    0.07225226f, -0.04794060f, 0.13157345f, 0.09277642f, -0.15937327f, -0.10896122f, 0.11046566f, -0.12609380f, 
    0.17713456f, 0.09779008f, 0.12777153f, 0.06103031f, -0.15793200f, 0.18418410f, -0.10595199f, 0.08749802f, 
    0.02415198f, 0.04737204f, 0.05622245f, 0.00766877f, 0.00490801f, -0.14358006f, 0.00182872f, 0.08333573f, 
    -0.11535067f, -0.04247205f, -0.01841233f, 0.02761383f, 0.31318262f, 0.02789103f, -0.05592252f, -0.03618062f, 
    -0.07126347f, -0.04671559f, -0.05364827f, 0.06510188f, 0.03300817f, 0.03932212f, -0.06255964f, 0.10716271f, 
    0.11777686f, 0.10455363f, 0.10718049f, 0.13863207f, 0.26405129f, 0.09848276f, 0.10375627f, -0.09310431f, 
    -0.19157691f, 0.02944158f, 0.10990469f, 0.07111090f, 0.09632979f, -0.05770834f, -0.05764013f, -0.19110271f, 
    0.06824318f, -0.05933796f, 0.00843468f, -0.04256834f, 0.00872818f, -0.09684622f, -0.09758663f, -0.03756136f, 
    0.29927033f, -0.05563889f, -0.06341250f, -0.17124540f, 0.07423098f, -0.00661191f, 0.00758365f, 0.00310928f, 
    0.01285977f, -0.01221714f, -0.02808246f, 0.03110306f, 0.08278992f, -0.10588843f, -0.05002004f, 0.20125835f, 
    0.07815079f, -0.16500421f, -0.01118710f, 0.01220640f, 0.02583197f, -0.07658222f, -0.19945286f, -0.07490692f, 
    0.02018539f, 0.01195576f, -0.01748506f, 0.05238685f, -0.03000706f, -0.01390412f, 0.02858923f, 0.02076423f, 
    -0.02600375f, 0.05523239f, 0.07112668f, -0.03566648f, -0.10595041f, -0.25829959f, -0.08436830f, -0.18195124f, 
    -0.13153256f, -0.16470994f, -0.03762031f, 0.03371399f, 0.04841879f, 0.04375688f, -0.03702899f, -0.01228324f, 
    0.05867949f, -0.07216297f, -0.06625413f, 0.11344337f, -0.00671298f, 0.08136052f, 0.07448255f, 0.00681812f, 
    -0.13958514f, -0.10144722f, -0.02141119f, -0.00700824f, 0.05098725f, -0.07251335f, -0.10636815f, -0.35514778f, 
    0.19916627f, 0.18035088f, 0.07691228f, 0.01096609f, -0.02568760f, 0.10268018f, 0.04752950f, 0.09779152f, 
    -0.03119035f, 0.15197989f, 0.03903255f, -0.05010784f, 0.19703682f, -0.02815927f, -0.09470337f, 0.14982074f, 
    -0.04541700f, 0.02913877f, 0.02436211f, -0.03769040f, -0.19174436f, -0.01946257f, 0.04705393f, -0.06024825f, 
    0.02715544f, -0.08702902f, 0.02220235f, 0.02013059f, 0.26611426f, -0.01561364f, -0.05231441f, 0.14670599f, 
    -0.02226510f, 0.06352092f, 0.04491957f, -0.12790981f, -0.24594106f, 0.00671939f, 0.02164004f, 0.34617984f, 
    0.42129132f, -0.02674467f, 0.00043838f, -0.14347315f, 0.01239088f, -0.14282289f, 0.06811165f, 0.00997094f, 
    0.02993643f, 0.01275214f, -0.01848618f, -0.08474930f, 0.05990900f, -0.04606349f, -0.15503138f, -0.16211423f, 
    0.09060956f, -0.08783471f, 0.03028283f, -0.03590735f, -0.04572767f, -0.07572417f, 0.01342200f, 0.05085123f, 
    -0.06762683f, -0.10455478f, 0.08101831f, 0.04175640f, -0.08357515f, -0.05466973f, 0.01732426f, -0.01630635f, 
    -0.08477110f, 0.08571939f, -0.13546868f, -0.10493769f, -0.07663891f, -0.01030840f, 0.06088196f, 0.25217554f, 
    0.05763713f, 0.00092443f, -0.00835956f, -0.20135349f, -0.02182299f, 0.04398210f, 0.04745580f, -0.03387026f, 
    0.06423189f, 0.11647698f, 0.09243944f, 0.03505155f, 0.01020061f, -0.02183225f, 0.19747446f, 0.19638067f, 
    -0.25935006f, -0.18514572f, -0.09884091f, 0.26724049f, 0.34768528f, 0.02834666f, -0.10449791f, 0.08291130f, 
    0.00875913f, 0.12653236f, 0.03997075f, 0.05236534f, -0.14476389f, -0.03229805f, -0.03260799f, -0.02020158f, 
    -0.10621455f, -0.01927130f, -0.10950097f, -0.13994858f, -0.23550804f, 0.08247896f, -0.04637823f, -0.13583507f, 
    -0.00505224f, -0.22431773f, -0.00333531f, -0.15868424f, -0.09696067f, -0.06784363f, -0.06369045f, 0.12363002f, 
    -0.00448664f, -0.06583315f, -0.02306565f, 0.04000400f, 0.26315284f, -0.03678089f, -0.22304280f, 0.01519108f, 
    -0.21033935f, 0.25348818f, 0.39918143f, 0.08483825f, 0.00632801f, -0.03624329f, 0.01880626f, 0.01685978f, 
    -0.00007816f, 0.07974631f, 0.04473521f, 0.02437740f, 0.08915662f, -0.03540410f, 0.10075882f, -0.03691167f, 
    -0.01838956f, -0.02749074f, -0.10358502f, 0.03014573f, -0.32008743f, 0.02713567f, -0.07033802f, 0.17766495f, 
    0.24085169f, -0.13568644f, 0.08218071f, -0.06725277f, -0.04826966f, -0.00065020f, -0.03200355f, 0.03030331f, 
    0.12970395f, -0.00979856f, 0.04603386f, 0.04203559f, 0.00454911f, 0.21235886f, -0.12925650f, 0.06068603f, 
    0.29502997f, 0.24337710f, 0.21384458f, -0.06585169f, 0.19910638f, -0.07617985f, 0.05798140f, 0.16096443f, 
    -0.02678243f, 0.05978021f, -0.06232275f, 0.01759881f, -0.06458511f, 0.04889140f, -0.01268462f, -0.07963280f, 
    0.02345637f, 0.17791454f, 0.08913717f, 0.02936254f, -0.11847923f, -0.04055820f, 0.01223173f, 0.40044934f, 
    0.44534615f, 0.00587565f, 0.00777333f, 0.03424812f, -0.08252265f, -0.06335277f, -0.02144948f, 0.10985555f, 
    0.06148837f, -0.01447706f, -0.01773130f, 0.05830365f, -0.05542514f, 0.03597926f, -0.07340785f, -0.05341076f, 
    -0.03427213f, -0.00642085f, -0.00144263f, 0.00040729f, 0.01979462f, 0.02136116f, -0.03632233f, -0.04149546f, 
    0.02320519f, -0.01674881f, -0.01107853f, -0.01958847f, 0.01725186f, 0.02085390f, -0.02114561f, 0.01106222f, 
    0.02602524f, 0.02654978f, -0.00234972f, 0.01222912f, 0.01151877f, 0.02287293f, 0.00108479f, -0.01290717f, 
    -0.03223844f, 0.02446357f, -0.00029096f, -0.03838244f, 0.02845717f, 0.00931521f, 0.02975983f, 0.00529285f, 
    -0.00469571f, 0.00047824f, 0.00922197f, -0.03366013f, -0.02431367f, -0.01522264f, 0.00495202f, 0.00893480f, 
    -0.03264225f, 0.02651394f, -0.00628248f, -0.02106967f, 0.00087946f, -0.00768017f, -0.00637902f, -0.02801301f, 
    -0.02824089f, -0.02613162f, -0.03829068f, 0.01170429f, 0.00768089f, 0.00317464f, 0.03039009f, -0.04047329f, 
    -0.03199553f, 0.02767780f, -0.03918304f, 0.01120551f, 0.02942542f, 0.01119698f, -0.01214946f, 0.01518208f, 
    -0.02149006f, -0.01309252f, -0.04007506f, 0.02587211f, 0.00606097f, -0.00868327f, -0.03394476f, -0.02559357f, 
    -0.02902869f, -0.04458062f, 0.03357845f, -0.03146213f, -0.02691096f, -0.02880079f, 0.01123225f, 0.03127975f, 
    0.00644513f, -0.01853348f, -0.02503971f, 0.00637437f, 0.03488820f, -0.00766731f, 0.00787496f, -0.01105634f, 
    -0.02063059f, -0.01853791f, 0.02605554f, -0.04020577f, 0.03464681f, -0.00767448f, 0.02973467f, -0.00101935f, 
    -0.02190115f, -0.00903929f, 0.02485114f, 0.00746091f, -0.01512974f, -0.01341664f, -0.02977294f, 0.00325057f, 
    0.03144784f, -0.03234728f, 0.02975305f, 0.01926531f, 0.01861501f, 0.02355491f, 0.02250607f, -0.03030116f, 
    -0.02432248f, 0.02376179f, 0.02109534f, -0.00924923f, -0.00306872f, -0.00273908f, 0.02683896f, 0.01048286f, 
    -0.03185923f, -0.00197426f, 0.01934620f, -0.04460844f, -0.03216953f, -0.02364813f, 0.02051123f, -0.02184233f, 
    -0.04435315f, 0.01681700f, 0.02076261f, -0.01529110f, 0.02429846f, -0.02040664f, 0.00918054f, -0.04156255f, 
    0.01512270f, 0.00587320f, -0.00043541f, -0.00812787f, -0.01111607f, -0.02044937f, -0.02017698f, -0.02227133f, 
    -0.00097231f, -0.00231323f, -0.02545584f, -0.00332856f, -0.02576776f, 0.01031367f, -0.02078217f, -0.01183109f, 
    0.02561120f, -0.01073804f, 0.00930844f, -0.01735296f, -0.04246242f, -0.02962051f, 0.01219850f, 0.01171696f, 
    0.01416159f, 0.03438079f, 0.00628101f, -0.03534063f, 0.01944997f, -0.02781831f, -0.04382471f, 0.00135161f, 
    0.02296155f, -0.04291215f, 0.01884471f, -0.01797205f, -0.01262545f, -0.02632761f, -0.01180256f, -0.03232162f, 
    -0.03231542f, -0.02100473f, 0.00645404f, -0.01422022f, 0.02453684f, 0.00870948f, 0.00674626f, 0.00472209f, 
    0.03436878f, 0.03244129f, 0.00609733f, 0.00344706f, -0.01651870f, 0.02042884f, 0.01944972f, -0.00853964f, 
    -0.03887512f, -0.02206101f, 0.00606917f, 0.02298216f, -0.00081343f, 0.00784601f, -0.01110369f, -0.03539883f, 
    -0.04320814f, -0.00723136f, 0.00752376f, 0.01817390f, -0.00708847f, -0.01562624f, -0.00509359f, -0.01284803f, 
    -0.03124849f, 0.03224095f, -0.00620634f, 0.01231948f, -0.02394764f, -0.00882015f, -0.04345722f, -0.02844400f, 
    -0.02686923f, 0.02516848f, 0.00481075f, -0.03567709f, 0.03206437f, 0.01290097f, -0.00965670f, 0.01146674f, 
    0.01663346f, 0.02629952f, -0.01341388f, -0.04325365f, -0.00224116f, 0.01994994f, -0.01005618f, 0.02216595f, 
    -0.01464325f, 0.01470978f, 0.00609017f, -0.03785622f, -0.03663022f, -0.03876581f, 0.01534567f, -0.00003761f, 
    -0.01524837f, 0.00757478f, -0.02708122f, -0.04399940f, -0.01068753f, -0.02528847f, 0.02150738f, -0.02155125f, 
    -0.03303626f, -0.02086842f, -0.01419930f, 0.01968320f, -0.02629273f, -0.01781627f, -0.02774142f, 0.00817858f, 
    -0.00995539f, 0.01771630f, -0.02144018f, -0.03783241f, -0.01031353f, -0.02097403f, 0.00334544f, -0.03498964f, 
    -0.03128584f, -0.03354171f, 0.00235011f, 0.00005712f, 0.00675577f, -0.01415281f, -0.01226851f, -0.00261989f, 
    -0.01459119f, -0.01459402f, 0.00400096f, -0.02328258f, 0.02542823f, -0.03814065f, -0.00678082f, 0.01260027f, 
    -0.01832406f, -0.04280043f, -0.02553456f, -0.03093860f, 0.01226921f, 0.00629484f, -0.00550638f, -0.02604079f, 
    -0.03313576f, 0.01371012f, -0.03562482f, 0.02230985f, -0.02754469f, -0.02978656f, 0.03150092f, -0.00221961f, 
    -0.03084489f, 0.03002762f, -0.00744325f, 0.02347969f, -0.04394032f, -0.00021134f, 0.00525534f, 0.02144390f, 
    -0.00250218f, 0.01445226f, 0.00813343f, 0.01742046f, -0.03147462f, -0.03245647f, 0.00208993f, 0.02206388f, 
    -0.01216889f, -0.03938060f, -0.02655762f, -0.04180763f, 0.03009247f, -0.00571880f, 0.01240587f, 0.00182576f, 
    -0.01913266f, -0.00213174f, 0.00743079f, -0.03664220f, -0.03812872f, -0.02340600f, 0.00600206f, -0.01219436f, 
    0.00188885f, -0.02664456f, 0.03381507f, -0.03278622f, 0.02130065f, -0.00398620f, 0.02826142f, 0.02190729f, 
    0.01975284f, -0.00109622f, -0.02512339f, -0.02834596f, -0.00512230f, -0.02415063f, 0.01610523f, 0.02255209f, 
    0.01440696f, 0.02287112f, 0.01184327f, 0.01746310f, -0.02089107f, -0.00493656f, 0.02178589f, -0.02651654f, 
    0.02462628f, -0.02439031f, -0.04260733f, 0.00290356f, 0.01912987f, -0.00524459f, 0.02551876f, -0.03615508f, 
    0.00475734f, 0.00992880f, 0.02822742f, -0.01252861f, -0.00126745f, 0.00953954f, -0.02314117f, -0.00185319f, 
    -0.01856285f, 0.02721489f, 0.00185276f, 0.02197168f, 0.02836459f, 0.00625755f, -0.00643064f, -0.00060402f, 
    0.00189175f, -0.00621367f, -0.04377189f, -0.00567809f, 0.03150485f, 0.02755992f, -0.03094294f, -0.00957776f, 
    -0.02927456f, -0.03118589f, -0.03652103f, -0.00379504f, 0.00567043f, -0.03931136f, -0.02247942f, 0.00541516f, 
    0.01119180f, -0.04404677f, 0.01603405f, -0.04326294f, 0.02781972f, -0.02517354f, -0.01465271f, 0.01909023f, 
    -0.02008189f, -0.01961766f, -0.00702816f, -0.01686698f, -0.04100429f, 0.00486407f, 0.01372298f, -0.02705756f, 
    0.02448374f, 0.01396782f, -0.03521484f, 0.01266350f, 0.01947499f, -0.00376591f, -0.04195111f, -0.00864678f, 
    -0.00814877f, -0.03302188f, 0.02706959f, -0.01034248f, 0.01108747f, 0.03596689f, -0.00939654f, -0.02562407f, 
    -0.00404040f, 0.02027122f, 0.00503901f, -0.02131396f, -0.01923296f, 0.02289893f, 0.02091697f, -0.00374406f, 
    0.00520645f, -0.02429466f, -0.02049221f, -0.00592409f, 0.01216101f, 0.03636561f, 0.02632811f, -0.01902528f, 
    0.00782084f, 0.03286345f, -0.01148203f, -0.00019888f, -0.02410420f, -0.04316092f, 0.01581100f, 0.02599963f, 
    -0.03618211f, -0.02425674f, -0.02683844f, -0.00482555f, 0.00331281f, 0.00750002f, 0.02372594f, -0.02388737f, 
    -0.01054109f, -0.03062051f, -0.01448858f, 0.01361596f, 0.01500782f, -0.00373805f, 0.03826924f, 0.02880968f, 
    0.01904410f, -0.00037179f, -0.00286475f, -0.02913593f, -0.00100781f, -0.02997425f, -0.01838960f, -0.01954892f, 
    0.00526080f, -0.03873136f, -0.01732861f, -0.00213807f, -0.00813865f, 0.00967905f, -0.02841529f, -0.03477963f, 
    0.02372376f, -0.00115316f, -0.00386724f, -0.00551511f, -0.02666978f, 0.02379888f, -0.04370678f, 0.01754872f, 
    -0.02702121f, 0.03234462f, 0.01696745f, -0.03424153f, 0.02237905f, 0.02818079f, 0.00646745f, -0.03432403f, 
    0.01340890f, -0.00214134f, 0.03291326f, -0.01142098f, -0.04147281f, -0.03858290f, -0.00066721f, -0.01863638f, 
    -0.01841049f, 0.03464965f, 0.03262622f, -0.02624071f, -0.03737902f, -0.01703769f, -0.03345059f, -0.00357016f, 
    0.00299596f, -0.03333684f, 0.03205089f, -0.00354626f, 0.02083313f, -0.01493639f, 0.01722332f, 0.01791793f, 
    -0.00694893f, -0.03211762f, -0.04262808f, -0.01414571f, -0.02057123f, -0.01398329f, 0.00053692f, -0.00034163f, 
    0.01269565f, 0.00583995f, -0.03289624f, 0.00301634f, 0.00213615f, -0.03154015f, 0.02446937f, 0.01979532f, 
    0.01645816f, 0.00073696f, -0.01583647f, -0.04336470f, 0.01204692f, 0.03079676f, 0.00148939f, -0.01941879f, 
    -0.01885612f, 0.01946442f, -0.02524499f, 0.00438062f, 0.01985836f, -0.03525281f, 0.02248469f, 0.00865471f, 
    0.00928883f, 0.02522097f, 0.03271077f, -0.02632551f, -0.02070188f, 0.01373488f, -0.00776830f, 0.00101032f, 
    0.00237119f, 0.01679944f, -0.00303533f, -0.01318298f, 0.01109064f, 0.01405815f, 0.01866421f, -0.04114529f, 
    0.02708077f, -0.01855354f, -0.03934768f, 0.03073246f, -0.03817833f, 0.01067415f, -0.02492887f, -0.00863289f, 
    -0.02257377f, -0.02485992f, -0.03659872f, -0.00208412f, 0.01485751f, 0.01788797f, -0.01258216f, -0.00980642f, 
    0.00525332f, 0.02994966f, -0.01696700f, -0.00014841f, 0.02778208f, -0.02151833f, -0.00690781f, 0.00221345f, 
    -0.00300441f, -0.02321770f, 0.01220319f, 0.02514699f, 0.00130066f, -0.02901278f, -0.01785581f, 0.01634113f, 
    -0.01978118f, 0.03111286f, -0.04325296f, 0.02479319f, -0.00249767f, -0.01834642f, 0.01367154f, 0.00701752f, 
    0.01167436f, 0.01178459f, 0.00309128f, -0.03131079f, -0.03182450f, -0.03022559f, 0.00235156f, 0.03030102f, 
    -0.00555722f, 0.01868088f, 0.00677070f, -0.01452696f, -0.03172771f, 0.04108683f, 0.00153968f, 0.02983168f, 
    -0.01835707f, -0.03453923f, 0.00815192f, 0.01921387f, -0.01881427f, 0.00407012f, 0.00737476f, 0.00226329f, 
    0.00763013f, 0.02120608f, -0.01936844f, -0.04251705f, -0.02467584f, -0.03977048f, -0.00840858f, 0.00933802f, 
    0.46025816f, 0.35293365f, 0.29175562f, 0.09991015f, -0.16982049f, -0.07656931f, -0.08346044f, 0.05867181f, 
    -0.02629122f, 0.20021543f, -0.06471679f, -0.01584233f, -0.08811662f, -0.08319868f, -0.02702052f, 0.02773591f, 
    0.16517144f, 0.03963374f, 0.06516966f, 0.07114403f, 0.05591206f, 0.03927577f, -0.00942483f, -0.14380236f, 
    0.06955624f, -0.00785589f, 0.14870791f, 0.23234288f, -0.18161172f, 0.05691583f, 0.00141229f, -0.07172079f, 
    0.00970953f, 0.17278291f, 0.14109842f, 0.06458554f, -0.10167790f, -0.00895805f, -0.12204074f, 0.03009235f, 
    0.59873933f, -0.04936638f, 0.54864305f, -0.14628099f, 0.37207082f, 0.15147124f, 0.11255975f, -0.03543383f, 
    0.25173834f, 0.06018803f, 0.02273387f, -0.02307646f, 0.04585200f, 0.05236218f, -0.04889431f, 0.00385072f, 
    -0.01310016f, 0.09153591f, -0.11304010f, 0.18506873f, -0.06141431f, 0.09235289f, -0.21519068f, 0.08906898f, 
    0.02787631f, -0.02212771f, -0.10500053f, -0.08324181f, -0.03026663f, 0.00008860f, 0.02454184f, -0.06920741f, 
    -0.00685703f, -0.05608150f, -0.00370599f, -0.07086342f, -0.07059937f, -0.12875886f, -0.02775273f, 0.09457362f, 
    -0.14751276f, -0.25155678f, -0.13866392f, 0.14505406f, -0.11861342f, 0.06681118f, 0.08969730f, 0.00030857f, 
    0.04737876f, -0.01512418f, 0.06393674f, -0.03368224f, -0.04459956f, -0.00777064f, 0.09859228f, 0.14784862f, 
    0.07620817f, 0.09329009f, -0.05301491f, 0.02161515f, 0.11316069f, -0.15015879f, -0.15632850f, -0.04998676f, 
    -0.06703092f, -0.03223477f, 0.18498486f, -0.08757362f, -0.08813924f, 0.02780832f, 0.09151869f, -0.06379296f, 
    0.16483761f, -0.13279018f, 0.08079449f, 0.29594591f, 0.07855057f, -0.12311990f, -0.10555715f, 0.06065898f, 
    -0.18935828f, 0.13648804f, -0.10083945f, 0.15133736f, -0.03060046f, 0.03111920f, -0.23597229f, -0.03187302f, 
    0.00567706f, -0.05008892f, -0.07242418f, 0.05382387f, 0.00351343f, 0.00880772f, 0.11206184f, 0.01917932f, 
    0.03840495f, 0.00540845f, -0.09639731f, 0.02307491f, 0.02353062f, 0.14642285f, -0.49285766f, -0.26128986f, 
    -0.40531057f, -0.05421456f, 0.02055079f, 0.22194383f, -0.20327210f, 0.07956470f, -0.08511455f, -0.02339666f, 
    -0.17313027f, 0.17265193f, 0.07710899f, -0.13839051f, -0.10963276f, 0.05112568f, -0.05152800f, -0.03516119f, 
    -0.51482934f, -0.57596016f, -0.24095419f, -0.30364442f, 0.05523853f, -0.03485767f, 0.10525160f, -0.15841383f, 
    -0.03571189f, -0.09735423f, -0.03886738f, -0.02025970f, 0.07133349f, -0.00441563f, 0.08682042f, -0.12002778f, 
    -0.09296068f, 0.16497460f, -0.08696140f, -0.08023722f, 0.16285491f, -0.08153395f, 0.02875803f, 0.17853139f, 
    -0.00363744f, 0.18305303f, 0.00445855f, 0.05658419f, 0.05797496f, 0.01453249f, -0.00172673f, -0.04884822f, 
    -0.09718826f, -0.08437342f, -0.13924967f, 0.05447264f, 0.07896899f, 0.03288484f, -0.06266353f, -0.02014333f, 
    -0.10019454f, 0.05501391f, -0.13184214f, -0.03558888f, -0.07743233f, 0.14589640f, -0.02031608f, -0.00406062f, 
    -0.03815572f, -0.08176827f, 0.04734157f, 0.07866965f, 0.07096934f, 0.07683857f, 0.16941002f, 0.15769382f, 
    0.24173974f, 0.03275912f, -0.04851612f, 0.01574083f, 0.08100532f, 0.18549086f, 0.11216837f, -0.07579532f, 
    0.31081566f, 0.00040931f, 0.09381270f, 0.20753723f, 0.11447029f, 0.20203669f, -0.00203064f, -0.03667637f, 
    0.06056969f, 0.01411610f, -0.02668791f, 0.19544517f, 0.09516997f, 0.02913255f, -0.18329285f, -0.20291485f, 
    0.12559402f, 0.23717266f, -0.04369381f, -0.06725546f, -0.02959761f, -0.11885838f, 0.21011530f, 0.19399713f, 
    -0.06630421f, -0.01520144f, 0.09626703f, 0.07823295f, -0.00159943f, -0.12998372f, 0.00901143f, 0.06562578f, 
    0.08485474f, 0.05632490f, 0.01456151f, 0.01571517f, -0.21827714f, -0.10547340f, -0.03689088f, -0.08964628f, 
    -0.09650636f, 0.02148072f, -0.01109800f, -0.04864144f, -0.02921183f, 0.02913606f, 0.08368847f, 0.01937992f, 
    -0.04939293f, -0.01421201f, 0.06854826f, 0.01048853f, 0.17663364f, -0.08114539f, -0.00013138f, 0.01261508f, 
    0.27243638f, 0.27921951f, 0.44266185f, 0.25190413f, -0.06539188f, -0.08434428f, -0.04951470f, 0.15172517f, 
    0.04061344f, 0.00628038f, 0.04779787f, 0.05025978f, -0.06431226f, 0.01782490f, -0.04173684f, 0.11494967f, 
    0.15073209f, -0.00194367f, -0.00360684f, -0.07186639f, -0.28799599f, -0.10767327f, -0.25799030f, -0.13550594f, 
    -0.24132277f, 0.03891454f, -0.05097460f, 0.19091547f, 0.12564346f, 0.05702763f, 0.09525184f, -0.06258817f, 
    0.07416759f, 0.04911714f, 0.12638216f, -0.02666846f, -0.04730212f, 0.02304698f, -0.01483705f, -0.09732445f, 
    0.23484977f, -0.05445370f, 0.24397352f, 0.04790349f, -0.01912074f, 0.02743728f, 0.06382142f, 0.08105772f, 
    0.01594394f, 0.01955988f, 0.02660347f, -0.01887190f, 0.02747411f, 0.07435120f, 0.02295285f, 0.02608535f, 
    -0.00011028f, -0.05336443f, 0.11397997f, 0.16855553f, -0.33477294f, -0.31449479f, -0.30225947f, -0.17768835f, 
    -0.05843465f, 0.00806758f, 0.07606911f, -0.08384676f, -0.07463083f, 0.09400888f, 0.07169941f, 0.07990512f, 
    -0.08214876f, 0.11388543f, 0.14531438f, 0.01834588f, -0.10861602f, -0.03351203f, -0.11799686f, 0.09369169f, 
    -0.25800619f, -0.08698784f, -0.06178215f, 0.02094143f, -0.05556458f, -0.03428168f, -0.03303642f, -0.06619045f, 
    -0.00184464f, 0.02511850f, 0.09333106f, -0.04697073f, -0.08726691f, -0.01971830f, 0.08227669f, -0.00802895f, 
    0.10092059f, 0.05599936f, -0.07051033f, -0.06034318f, -0.15807170f, -0.22535269f, -0.17696381f, -0.06592328f, 
    -0.13770036f, -0.01042202f, 0.00136334f, -0.04370825f, -0.01287260f, -0.00387778f, 0.15103455f, 0.00337392f, 
    0.17364927f, 0.04010059f, 0.13801180f, -0.00347514f, 0.04390305f, 0.07742344f, 0.01756120f, 0.00234683f, 
    -0.10371871f, -0.04039476f, -0.20742331f, -0.06913295f, -0.04215359f, -0.00198525f, 0.06243256f, 0.02348236f, 
    0.02943273f, 0.17304511f, 0.19523534f, -0.04174517f, 0.05146981f, -0.19016108f, -0.10209866f, 0.05306411f, 
    0.13621795f, 0.07999643f, 0.00643745f, -0.01794238f, -0.00907969f, -0.29704693f, 0.47689036f, 0.14869285f, 
    -0.09142277f, 0.22917975f, -0.04171390f, 0.05850700f, 0.14023343f, 0.08669570f, -0.00705104f, -0.03539186f, 
    0.03702621f, -0.00248262f, 0.16200782f, 0.02754234f, -0.18216069f, -0.19066915f, 0.18635850f, 0.03796337f, 
    -0.11735445f, -0.10507277f, -0.16967714f, -0.01488384f, -0.01264952f, 0.07235967f, 0.07810416f, -0.02953492f, 
    -0.02355327f, 0.12209404f, 0.09710136f, -0.01774884f, -0.00456981f, -0.00135257f, 0.19872169f, -0.08865675f, 
    0.15052545f, 0.10763498f, -0.08854301f, 0.01491023f, 0.41755971f, 0.06501582f, 0.31621346f, -0.17939687f, 
    0.09431977f, 0.02711004f, -0.02396664f, 0.05421007f, 0.20649965f, 0.27098736f, -0.01803807f, -0.02464378f, 
    -0.16183537f, -0.00914651f, -0.02929856f, 0.08839298f, 0.03253403f, -0.03895724f, 0.14251560f, 0.11910094f, 
    -0.05323428f, -0.32793292f, -0.07352712f, -0.02413880f, -0.02562647f, 0.09516568f, 0.01833828f, -0.02337117f, 
    -0.03907005f, 0.03884168f, 0.16351485f, 0.05876467f, 0.16645569f, 0.01050222f, -0.12086177f, 0.07382336f, 
    0.06356540f, 0.01510665f, -0.03023167f, 0.09550335f, 0.05730740f, 0.11897937f, 0.22431289f, -0.02384394f, 
    0.40559232f, -0.04423230f, 0.15725404f, 0.10347037f, 0.24556436f, 0.12477688f, 0.01385413f, 0.03221685f, 
    -0.00117429f, 0.00913450f, -0.02097406f, 0.21706145f, 0.09238998f, -0.01086972f, -0.09786253f, -0.13895385f, 
    0.51487744f, 0.36165318f, 0.46519631f, 0.02363208f, 0.08887361f, -0.04111475f, -0.06813978f, 0.03770939f, 
    0.00554669f, 0.23540871f, 0.02038568f, -0.03690322f, -0.04668472f, -0.10199247f, 0.01081403f, 0.02222069f, 
    0.03875925f, -0.03123874f, 0.18701778f, 0.16604662f, 0.20956644f, -0.41311571f, 0.09578133f, -0.16535240f, 
    -0.05501224f, 0.06220658f, 0.01889957f, -0.02929151f, 0.06502955f, 0.03075518f, 0.06165909f, 0.06196816f, 
    -0.09397414f, -0.04011882f, 0.10150701f, 0.22050352f, -0.00512007f, -0.08732584f, -0.00469182f, 0.03051026f, 
    0.13990298f, -0.40601647f, -0.49071661f, -0.17646298f, -0.05042683f, 0.14132448f, 0.18970813f, 0.04129051f, 
    0.18423192f, 0.14677620f, -0.04435140f, -0.13309532f, -0.03718143f, 0.15258920f, -0.13242078f, -0.01401028f, 
    -0.04673300f, -0.03282892f, -0.00496220f, -0.03943433f, 0.33700269f, 0.06468912f, 0.38404116f, 0.12745059f, 
    0.17375095f, -0.00482097f, 0.09565973f, 0.11213750f, 0.12516822f, 0.02834792f, 0.02597594f, -0.02804467f, 
    0.01287618f, 0.17278410f, 0.02083025f, 0.07740413f, 0.11491013f, -0.07702520f, 0.07856381f, -0.04570159f, 
    0.30122128f, 0.05107637f, 0.14852883f, 0.14741547f, 0.09386513f, -0.08156049f, 0.09059155f, 0.12636155f, 
    0.20649843f, 0.06185936f, 0.05268261f, -0.01686310f, -0.01081442f, -0.03302719f, 0.02959183f, 0.07000848f, 
    -0.11396179f, -0.02800070f, 0.11341166f, 0.17918137f, 0.45397931f, 0.13675794f, 0.24798143f, 0.10478102f, 
    -0.08565355f, 0.15398641f, -0.02328105f, -0.05438703f, -0.00207603f, 0.12607147f, -0.01276444f, -0.03016819f, 
    -0.07160083f, -0.02871505f, -0.07859829f, -0.00416202f, 0.07899018f, -0.03121695f, 0.05419566f, 0.03597646f, 
    0.11439797f, -0.05505772f, 0.08356474f, 0.19615185f, -0.00707669f, 0.03720591f, 0.03207139f, 0.35242704f, 
    0.03340559f, 0.23639581f, -0.05747799f, 0.00687097f, -0.12542096f, -0.08868072f, -0.09268361f, -0.00540705f, 
    0.05398557f, 0.12642916f, 0.08457919f, 0.23937812f, -0.26226014f, -0.33327809f, -0.10974236f, 0.33035657f, 
    -0.20704256f, -0.01763263f, 0.08010283f, 0.04160074f, -0.30343032f, -0.03413046f, -0.06751761f, -0.09250095f, 
    -0.00397865f, 0.14979561f, 0.04586499f, 0.03308015f, 0.06010119f, 0.16387443f, 0.06276069f, 0.20820774f, 
    0.05239965f, -0.02452284f, 0.19791637f, -0.09230302f, -0.05589533f, 0.09690844f, 0.00305132f, -0.05170248f, 
    0.20360827f, -0.11444691f, -0.03722239f, -0.06410392f, 0.08980694f, -0.01307957f, 0.05618956f, 0.08997611f, 
    0.01114522f, -0.08642045f, 0.19588526f, 0.14739178f, 0.41038787f, -0.10602657f, -0.15257958f, 0.16382933f, 
    0.05228970f, -0.02978941f, 0.00083848f, 0.13047554f, 0.02041336f, -0.01447769f, -0.06573260f, -0.00708297f, 
    -0.04419053f, -0.07773671f, -0.02467007f, 0.07170182f, 0.07323956f, 0.11784133f, 0.08949632f, 0.16905090f, 
    0.06282866f, -0.15260673f, 0.00340792f, -0.18361224f, 0.08085239f, -0.00381558f, 0.12955138f, 0.04221419f, 
    0.12772962f, 0.01144425f, -0.05971519f, -0.01856762f, 0.04614078f, -0.12242410f, 0.00361457f, 0.00340314f, 
    0.15342359f, 0.09040048f, -0.04213614f, -0.11437549f, 0.39518717f, -0.18354647f, -0.12487630f, -0.03239581f, 
    -0.02146704f, -0.06153716f, 0.09662148f, -0.07286326f, 0.06380338f, 0.05483787f, -0.00543360f, 0.04259902f, 
    -0.01841951f, -0.18211210f, -0.06930670f, 0.07124980f, 0.22292994f, 0.00824050f, -0.02535829f, -0.07221916f, 
    -0.17139684f, -0.06448146f, -0.07653362f, 0.09280397f, 0.24484833f, 0.06816728f, 0.09653009f, 0.02490334f, 
    0.01707849f, -0.00783020f, -0.03217386f, -0.05846512f, 0.00384627f, -0.04119546f, -0.13388219f, 0.02329057f, 
    -0.07854940f, 0.00119196f, -0.25345415f, -0.04047497f, -0.58895016f, 0.19327432f, 0.06196005f, 0.26262254f, 
    0.08505712f, 0.13947222f, 0.06159240f, 0.01259932f, -0.32041782f, -0.11194462f, -0.14264904f, -0.09052780f, 
    -0.03022563f, 0.03113678f, 0.07271434f, -0.08230528f, -0.01413985f, 0.13763601f, 0.11808544f, 0.15028442f, 
    -0.60572493f, -0.07564631f, -0.23534887f, -0.23499236f, -0.01747954f, 0.00742090f, 0.01479963f, -0.19453675f, 
    0.09355884f, -0.03263322f, -0.19760019f, 0.11106221f, 0.10844896f, 0.10190062f, 0.21355142f, -0.03805432f, 
    0.09392911f, 0.19860773f, 0.06161115f, 0.04801558f, 0.14805312f, 0.13297197f, 0.17758499f, 0.29351193f, 
    0.19712047f, 0.09529100f, 0.00824744f, -0.02919307f, 0.06205783f, -0.08592311f, -0.17234586f, 0.00181784f, 
    0.01856590f, -0.05705014f, -0.06047868f, -0.00523685f, -0.10719233f, 0.09403985f, -0.11671560f, -0.05376929f, 
    -0.05396985f, -0.06942674f, -0.08652571f, -0.06524786f, 0.13328193f, 0.07619070f, 0.12367900f, 0.05166912f, 
    -0.04217377f, 0.04413558f, 0.01790933f, 0.08579022f, 0.01217595f, 0.07096058f, -0.01505977f, 0.29430479f, 
    0.14836378f, 0.01698779f, -0.14803335f, -0.05051386f, -0.14226444f, -0.05666701f, -0.02450888f, 0.05495361f, 
    -0.04708765f, -0.03106589f, -0.03268409f, 0.12584911f, -0.03507276f, 0.15361004f, 0.00150087f, 0.01720456f, 
    0.02669260f, 0.06452747f, 0.08995802f, 0.34666437f, 0.27552053f, 0.11676326f, 0.12596837f, 0.23242982f, 
    -0.00546027f, 0.22953178f, -0.00978113f, 0.07781259f, 0.00177129f, -0.06041453f, 0.06983868f, -0.01170694f, 
    -0.04734119f, 0.08083627f, 0.11068761f, 0.02583956f, -0.08993049f, -0.09845527f, -0.02682950f, 0.00336544f, 
    -0.11853713f, -0.16721985f, -0.18782525f, -0.22497046f, -0.03345419f, -0.23053542f, -0.13091496f, -0.11118614f, 
    0.18618107f, -0.00385710f, -0.01215043f, -0.00679354f, -0.01738838f, 0.02268556f, 0.04983395f, -0.00814319f, 
    -0.08336410f, -0.06182227f, -0.04416750f, 0.03015995f, 0.17435555f, 0.11034106f, 0.03919159f, 0.01601375f, 
    -0.00068993f, -0.14653021f, -0.03390849f, 0.15574846f, -0.00130123f, -0.08208531f, -0.11433701f, 0.10730134f, 
    0.00163600f, -0.00401908f, 0.03561476f, 0.04221058f, -0.04116060f, -0.02149109f, -0.05009134f, 0.26230073f, 
    0.07304132f, 0.05846555f, 0.09481873f, 0.27434462f, -0.02410414f, -0.04676009f, 0.09658732f, 0.21583959f, 
    0.16366687f, 0.07641324f, 0.05571517f, 0.16524224f, -0.04415015f, 0.08348455f, -0.01730097f, -0.05647621f, 
    0.04723115f, 0.01983360f, -0.01358651f, -0.07196073f, -0.04335659f, 0.04958868f, -0.03679384f, 0.07516094f, 
    -0.07582037f, -0.08751129f, 0.28309423f, 0.15681878f, -0.11049603f, -0.02031608f, -0.11893281f, 0.00053390f, 
    -0.01962313f, 0.12984215f, -0.00768128f, -0.04943463f, 0.06020165f, 0.04019115f, -0.03150762f, 0.08379102f, 
    0.09933517f, -0.00484325f, 0.12374863f, 0.18423715f, -0.26757303f, 0.04440692f, -0.06938022f, -0.10602680f, 
    -0.09693472f, -0.04903007f, -0.06018486f, -0.14339669f, -0.03671055f, 0.05089492f, -0.02860155f, 0.02619014f, 
    0.03655303f, 0.10854621f, 0.09143658f, -0.07395481f, -0.12893200f, 0.00602706f, -0.08342353f, -0.07871489f, 
    0.05550055f, -0.12322515f, -0.04548346f, -0.10901181f, 0.09946417f, -0.02985115f, -0.04612515f, 0.04550792f, 
    0.01530585f, 0.01378723f, 0.03362237f, 0.05182812f, -0.04552102f, -0.02361627f, -0.00930383f, 0.01503390f, 
    0.13698585f, 0.14963709f, 0.05712785f, -0.03758005f, -0.08190220f, -0.04948947f, -0.19445485f, -0.09610604f, 
    0.13398330f, 0.02392009f, -0.07269919f, -0.03217626f, -0.00602865f, -0.00863806f, -0.01459491f, 0.07993673f, 
    0.11056980f, 0.15801001f, 0.12714486f, 0.01254282f, -0.10344815f, 0.08258531f, -0.02078525f, -0.07386956f, 
    -0.19971628f, 0.25514367f, 0.23125447f, 0.20027691f, 0.09312007f, -0.05695854f, -0.05823248f, -0.07524974f, 
    0.06147974f, 0.05280813f, 0.06288392f, -0.03223136f, 0.03740140f, -0.11447265f, -0.00103907f, -0.01588308f, 
    -0.09185404f, 0.00969106f, -0.05532014f, -0.03145495f, -0.05654369f, -0.39841455f, 0.31386733f, 0.18553536f, 
    0.08492675f, 0.06825914f, 0.18344712f, 0.05950700f, 0.00306147f, 0.03134528f, 0.02221153f, -0.08960647f, 
    0.01053368f, 0.01843150f, 0.02359185f, 0.05045022f, 0.08151791f, 0.04392993f, -0.03769199f, 0.12656941f, 
    0.12116007f, -0.09379775f, -0.01084242f, 0.00187654f, -0.05021258f, 0.00942081f, 0.08991197f, 0.01069614f, 
    -0.06727683f, 0.17808104f, -0.01120216f, -0.00280455f, -0.04803883f, 0.14848529f, 0.07727484f, 0.01186766f, 
    0.12062415f, 0.05175996f, -0.01855876f, -0.04331151f, -0.02243051f, 0.03271855f, 0.38995224f, 0.23852001f, 
    -0.06743003f, 0.00798423f, -0.23876555f, -0.09426524f, 0.13867348f, 0.11313577f, 0.02245604f, 0.00755836f, 
    -0.04309607f, -0.08394958f, -0.03269275f, 0.05935535f, 0.00616105f, -0.05842881f, 0.10617527f, -0.05092284f, 
    -0.14677300f, -0.11404697f, 0.17208128f, 0.12150835f, 0.00801503f, -0.02733949f, 0.00528466f, -0.07416671f, 
    0.04474168f, -0.07193946f, -0.07805381f, -0.10120813f, 0.12325140f, -0.00525093f, 0.00680436f, 0.04270000f, 
    -0.10909937f, -0.07382235f, -0.07359761f, -0.14776060f, -0.20227122f, -0.04049232f, 0.02912497f, 0.01827472f, 
    -0.03165604f, -0.03145305f, -0.00513621f, 0.09157160f, 0.04333914f, 0.07719953f, -0.04119704f, 0.05417714f, 
    0.06146586f, 0.04028662f, -0.04828655f, 0.19971089f, 0.21145950f, 0.08735313f, 0.05240634f, 0.22979489f, 
    -0.03882000f, 0.01824093f, 0.26591194f, 0.05108390f, 0.03465911f, -0.02322127f, -0.05646123f, 0.16417754f, 
    -0.21173653f, -0.02052835f, 0.00342302f, 0.09228262f, -0.09397896f, -0.10052359f, -0.06970911f, -0.03368021f, 
    -0.10301952f, -0.09071504f, -0.16181035f, -0.22859098f, -0.19883078f, -0.32700416f, 0.13513364f, -0.02181638f, 
    -0.14528534f, -0.01000688f, -0.03903915f, 0.10234120f, 0.11834449f, -0.11293790f, -0.19286872f, -0.08396713f, 
    0.03560058f, -0.14404672f, 0.01890369f, 0.15804040f, -0.01132019f, 0.04104470f, 0.04834772f, -0.02999204f, 
    -0.09197900f, 0.12117576f, 0.45149538f, 0.19094479f, -0.13860762f, 0.01885671f, 0.00673765f, -0.21341524f, 
    0.18492280f, -0.00426528f, -0.11027540f, 0.08093955f, 0.04818039f, -0.01590334f, 0.01381985f, -0.11253750f, 
    -0.03136847f, 0.02632293f, -0.05556143f, 0.05735285f, -0.19062324f, -0.13899572f, 0.01817954f, 0.13304673f, 
    -0.10984065f, 0.12308918f, 0.02160085f, 0.06960529f, 0.02500093f, -0.01476002f, 0.03391613f, 0.03034369f, 
    0.05862159f, 0.09789545f, 0.00341603f, 0.12565029f, 0.02298735f, -0.24772644f, 0.17366846f, 0.15624675f, 
    0.15652259f, 0.27406257f, 0.22504668f, 0.00905967f, 0.26440424f, 0.10491168f, 0.06590614f, 0.24494010f, 
    0.29187223f, 0.10196970f, -0.09564966f, -0.10371487f, 0.04331902f, -0.12794745f, 0.00264133f, -0.10514572f, 
    -0.18025821f, 0.04102627f, 0.13534096f, 0.01153512f, -0.06701083f, 0.13425618f, 0.34802738f, 0.38280618f, 
    -0.01963391f, 0.01928129f, -0.20285957f, -0.20156486f, -0.12241564f, -0.12983330f, 0.03662274f, -0.02691819f, 
    -0.08293453f, -0.09761389f, -0.02645296f, 0.03902478f, 0.02076742f, -0.07686462f, -0.04176090f, -0.02343054f, 
    -0.11425379f, 0.06795697f, -0.18530534f, -0.25082237f, -0.21812183f, 0.00573824f, 0.07417279f, -0.31418321f, 
    -0.11248869f, 0.01109594f, 0.02687419f, 0.01139562f, -0.01421218f, 0.05749902f, 0.05142071f, -0.02924110f, 
    0.17162962f, 0.10053183f, 0.05366607f, 0.00083620f, 0.04123408f, 0.14299494f, 0.32344210f, -0.28740934f, 
    -0.13831255f, -0.04440489f, 0.06300554f, 0.00110144f, 0.00175328f, 0.00246937f, 0.04472446f, 0.00535016f, 
    0.00644060f, -0.10733278f, 0.02583863f, -0.09291489f, -0.12752028f, -0.17434794f, -0.11358409f, -0.10905049f, 
    0.39131179f, -0.02199205f, 0.26667312f, -0.15528554f, -0.33440694f, 0.17419471f, 0.04891682f, 0.09009136f, 
    -0.07194567f, 0.21666418f, 0.04121706f, -0.02613275f, -0.07878797f, 0.06207487f, 0.01290675f, -0.17662758f, 
    -0.18850261f, 0.23217240f, 0.03909736f, 0.36444944f, 0.03001168f, 0.34143174f, -0.27598163f, -0.18708475f, 
    0.09074272f, 0.08515713f, 0.10936578f, -0.10607870f, -0.01208972f, 0.10682082f, -0.03255773f, -0.02446021f, 
    0.05167790f, 0.11129066f, -0.02093043f, -0.05603110f, -0.04534240f, 0.05250862f, 0.16900443f, -0.05769661f, 
    0.04385163f, -0.17757295f, -0.11106890f, 0.14473915f, 0.20783256f, 0.09482792f, 0.06089760f, -0.01225183f, 
    -0.07509169f, 0.01743035f, -0.07452474f, -0.06621827f, -0.03065183f, 0.02615827f, 0.00940413f, -0.00208842f, 
    -0.09073636f, -0.12505393f, -0.12523934f, 0.09514076f, 0.39710876f, 0.02789658f, -0.11599726f, -0.01246591f, 
    0.14956357f, 0.04606205f, 0.02310534f, -0.02048061f, -0.15731512f, 0.03571907f, -0.10786476f, -0.04731862f, 
    -0.03671571f, -0.01997469f, -0.05128758f, 0.09336634f, -0.08569979f, -0.36131683f, -0.06382184f, 0.08552580f, 
    -0.17610317f, -0.06674359f, -0.12797470f, 0.26382309f, 0.14084345f, -0.00432835f, -0.30793595f, -0.00595740f, 
    0.14138232f, 0.23021977f, -0.09259557f, 0.13081031f, -0.04297364f, -0.03280943f, 0.00955063f, 0.06058566f, 
    0.10051931f, -0.04800430f, -0.07728641f, 0.07414096f, 0.54292762f, -0.20051774f, -0.12410665f, -0.16801529f, 
    -0.17200492f, -0.19430722f, 0.02086715f, 0.15238695f, 0.04673610f, -0.03589062f, 0.09084564f, 0.14141165f, 
    0.02211588f, 0.20272565f, 0.07542672f, -0.00988958f, -0.02941518f, -0.00513545f, -0.01383145f, -0.00490869f, 
    0.57214421f, -0.19394431f, -0.05777565f, -0.09222146f, 0.12579179f, -0.01979237f, -0.00208176f, 0.05487895f, 
    -0.08885333f, -0.05184586f, 0.18108453f, 0.04519813f, 0.06701718f, -0.18041281f, 0.10321689f, 0.04789895f, 
    -0.09745539f, 0.21028972f, 0.15663245f, -0.05089140f, 0.06910923f, 0.11840656f, 0.04130919f, -0.00264045f, 
    -0.08123326f, 0.03577584f, -0.02154034f, 0.11970013f, -0.09536732f, -0.03649830f, 0.09000441f, 0.14367387f, 
    -0.15123630f, 0.08648051f, -0.06903707f, 0.01393914f, -0.08749066f, 0.04034262f, 0.01206716f, 0.09708665f, 
    0.03478952f, -0.01372536f, -0.13184337f, 0.07697476f, 0.07466466f, 0.12686872f, -0.01501170f, -0.10577987f, 
    0.07264144f, 0.06275797f, 0.06826814f, 0.00652519f, -0.01235619f, 0.04617346f, 0.05743993f, -0.14921300f, 
    0.00125098f, -0.00935141f, -0.03575451f, -0.10114845f, 0.12355314f, 0.24215437f, 0.21023133f, -0.16191176f, 
    0.01925354f, 0.04830751f, -0.07056600f, 0.09931799f, -0.04837038f, -0.11996285f, -0.02055363f, -0.03713812f, 
    0.08338234f, -0.12222794f, -0.12509787f, 0.11029424f, 0.01964807f, 0.10198779f, -0.05068661f, -0.14866759f, 
    0.14025658f, 0.10031519f, -0.08948719f, -0.09885447f, 0.01919772f, -0.13131036f, -0.02728946f, 0.07395159f, 
    0.09668756f, -0.30040094f, 0.06873295f, -0.03323637f, -0.00246133f, -0.07388837f, 0.00606127f, 0.02835632f, 
    0.02589255f, -0.08536686f, 0.08502693f, -0.05052708f, -0.01969643f, 0.02833290f, 0.01947055f, 0.08495779f, 
    0.17961469f, -0.01478563f, 0.02106571f, -0.04407785f, -0.05844384f, 0.03015938f, 0.03889835f, -0.01701256f, 
    0.00937667f, 0.14266147f, 0.10714044f, -0.18581802f, -0.13495678f, -0.04044744f, -0.01356032f, 0.06831542f, 
    -0.07446631f, 0.16914898f, 0.22575633f, -0.03227706f, -0.24633296f, 0.02234629f, 0.06776572f, 0.06227602f, 
    0.20359607f, 0.02804496f, 0.07239354f, -0.04748400f, 0.06513803f, 0.02032562f, 0.04099537f, -0.13760473f, 
    -0.07780806f, 0.15034766f, -0.00064350f, 0.00256937f, -0.64046091f, -0.30499095f, -0.14811860f, 0.11579045f, 
    0.04526762f, -0.04319470f, 0.00476458f, 0.03652048f, 0.20633474f, 0.09582791f, 0.08441606f, 0.13144384f, 
    -0.10215614f, 0.08395698f, 0.06219939f, 0.01268733f, 0.08872860f, 0.05087838f, 0.09094781f, -0.05243716f, 
    0.02945713f, 0.09740923f, 0.18164071f, 0.18335545f, -0.10941055f, -0.04090570f, 0.09114407f, 0.04061670f, 
    -0.05892919f, 0.09478278f, -0.02070673f, -0.05293864f, -0.00192520f, -0.07457060f, -0.03638282f, -0.08609682f, 
    -0.01361732f, -0.09807698f, 0.22715759f, -0.00830313f, 0.11087870f, -0.12504254f, -0.08702191f, -0.06113131f, 
    0.26345554f, 0.03118137f, -0.08491882f, -0.11604650f, -0.04837697f, -0.01679055f, 0.08766345f, 0.21417627f, 
    -0.06501020f, -0.06648051f, 0.06823413f, 0.06512164f, -0.07796633f, 0.07990700f, -0.10146656f, 0.23173207f, 
    0.02444372f, 0.01387099f, -0.01438937f, 0.09084357f, 0.20533136f, 0.02176743f, -0.00636574f, -0.02390990f, 
    -0.03740079f, 0.08203434f, 0.04538092f, 0.00433548f, -0.01260909f, 0.11509924f, 0.06384555f, -0.18423030f, 
    -0.22323343f, 0.00639973f, -0.00694775f, 0.01865083f, -0.01232253f, -0.21819533f, -0.09608461f, 0.11190673f, 
    0.13997100f, 0.00123233f, -0.04552722f, -0.07976699f, -0.06006453f, 0.03488387f, 0.19132909f, 0.19414809f, 
    0.22370492f, 0.01187665f, 0.02498111f, 0.03223056f, -0.07018355f, 0.10476858f, 0.02923012f, 0.07442722f, 
    -0.29164022f, 0.17199664f, 0.01587168f, -0.00641364f, -0.00578852f, 0.02506923f, 0.07858699f, 0.05725297f, 
    -0.02641352f, 0.03253520f, 0.02949767f, -0.01456699f, -0.02621122f, -0.01853686f, 0.01573237f, -0.08916306f, 
    0.07538547f, 0.04726234f, -0.03963860f, -0.05464349f, -1.06947577f, -0.12034721f, 0.05300817f, 0.54003197f, 
    -0.09535242f, 0.10352671f, 0.02452975f, -0.02199440f, 0.26462662f, 0.18853597f, 0.03512223f, 0.08322138f, 
    -0.07946364f, 0.17968912f, 0.06744682f, -0.07698010f, 0.13939081f, -0.15314062f, 0.32270154f, 0.13860250f, 
    0.17968658f, 0.03128943f, -0.21058811f, -0.21041642f, 0.06506383f, 0.04876478f, 0.04488684f, 0.01341306f, 
    -0.01500871f, -0.03064789f, 0.01331831f, 0.04555478f, -0.05663133f, -0.00031634f, 0.21300305f, 0.07432554f, 
    -0.02054816f, -0.08818048f, -0.15461729f, -0.01606211f, 0.16203967f, 0.22325975f, 0.20760497f, -0.13268511f, 
    -0.43578795f, 0.08567223f, 0.14520019f, 0.11227878f, -0.09822880f, 0.06963272f, 0.00114437f, -0.04764844f, 
    -0.05757391f, 0.01106424f, 0.01662384f, 0.03660144f, -0.01387406f, 0.07297026f, 0.14084855f, 0.19911507f, 
    0.25312278f, 0.16599487f, -0.10665108f, -0.15868549f, 0.08250987f, 0.02489897f, -0.00028509f, 0.03574938f, 
    -0.09009202f, -0.06647432f, 0.04075923f, 0.12517796f, 0.06241925f, -0.21032222f, 0.04320081f, 0.00503618f, 
    0.01008046f, -0.00714241f, -0.05737341f, 0.05094803f, 0.20814368f, 0.17518295f, 0.20465754f, -0.18082157f, 
    -0.06206984f, 0.17222252f, 0.01756672f, 0.20712166f, 0.08642646f, -0.18174189f, -0.03126244f, -0.03663801f, 
    0.06106079f, -0.07312575f, -0.03781732f, 0.04844956f, 0.11011293f, 0.13980380f, -0.03609797f, -0.04852007f, 
    0.23310675f, 0.22336274f, 0.27133656f, -0.06152635f, -0.21209037f, -0.08099657f, 0.09291711f, -0.12528932f, 
    0.00430933f, -0.23709311f, -0.00977355f, -0.06400226f, -0.01003808f, -0.04335434f, 0.03003789f, -0.04016161f, 
    0.00041252f, 0.02005601f, 0.15507224f, 0.17161156f, 0.18038663f, 0.14578208f, 0.07952225f, -0.03564047f, 
    0.17520605f, -0.10611763f, 0.10591815f, -0.15240689f, -0.09107010f, 0.17151807f, -0.01502889f, -0.00093160f, 
    -0.17347486f, 0.12469216f, -0.02516638f, 0.03677776f, 0.01733523f, -0.10024823f, 0.09076098f, 0.05593824f, 
    -0.15991324f, 0.10705049f, -0.28489190f, -0.04115222f, 0.05751726f, 0.18644308f, 0.06680568f, 0.09494776f, 
    -0.17378896f, 0.08566049f, 0.00833247f, 0.08865417f, -0.11240155f, -0.04991662f, -0.00832305f, 0.01704632f, 
    0.00278546f, -0.03411756f, 0.03311785f, 0.06945368f, 0.39270690f, 0.11373447f, 0.41426960f, -0.05369087f, 
    -0.09381420f, 0.16304402f, -0.00459709f, 0.17762136f, -0.02288362f, -0.11136768f, 0.01199064f, -0.01986099f, 
    0.02064655f, -0.03531881f, -0.06417983f, -0.15474588f, -0.04442044f, -0.00433525f, 0.12078063f, 0.01366770f, 
    0.10985573f, -0.10001071f, -0.23921600f, 0.19762756f, 0.01286754f, 0.16705160f, 0.03688443f, -0.09899142f, 
    -0.03468326f, -0.23170887f, -0.00481478f, -0.01358974f, -0.03396899f, 0.03484878f, 0.07434381f, 0.15925762f, 
    0.07569523f, -0.01599160f, -0.07573759f, 0.08383849f, 0.03470562f, 0.14899693f, 0.06745161f, -0.07338715f, 
    -0.41592434f, -0.06524345f, 0.03206926f, 0.12662919f, -0.04170037f, -0.00236883f, -0.02496392f, -0.02666094f, 
    -0.06102440f, -0.04970098f, -0.02272899f, -0.06056203f, 0.02076661f, -0.01306492f, 0.10267080f, -0.02021138f, 
    0.20600830f, -0.05588310f, -0.08608744f, 0.01983869f, -0.27319682f, 0.13519204f, -0.21463473f, 0.14282449f, 
    0.10957845f, 0.12265075f, -0.11762602f, 0.06336980f, -0.02507064f, -0.05007926f, -0.14214355f, -0.09960779f, 
    0.03600915f, -0.12745681f, 0.09579141f, 0.11884069f, -0.26712260f, -0.24659705f, 0.05253987f, 0.45139387f, 
    -0.17026372f, -0.02526452f, -0.00906982f, 0.15120338f, -0.06560072f, -0.01647788f, -0.04367279f, -0.19567576f, 
    -0.00659495f, 0.00049179f, -0.02913699f, 0.05716268f, -0.05973196f, -0.11934251f, 0.02612669f, -0.00012563f, 
    0.30120644f, -0.07811127f, 0.03901178f, 0.05488224f, -0.01888863f, 0.12153440f, 0.13263355f, -0.01718700f, 
    0.07526421f, 0.05872026f, -0.04592811f, -0.09240195f, 0.10988943f, 0.07627821f, 0.05559338f, 0.04018055f, 
    -0.01267700f, -0.02256281f, 0.03614825f, -0.06730337f, 0.42419749f, 0.08585858f, -0.08521112f, 0.17799176f, 
    -0.03681508f, 0.04180327f, -0.15319456f, 0.00783223f, -0.08030982f, -0.08065781f, -0.00964652f, 0.02789579f, 
    -0.00955195f, -0.10510147f, -0.08064718f, -0.05093780f, -0.01135016f, -0.01763582f, 0.13200542f, 0.04617690f, 
    -0.08138119f, -0.04602240f, 0.24101874f, -0.16659850f, -0.05233972f, -0.01671972f, 0.09634712f, -0.02005379f, 
    -0.03089635f, 0.02118862f, -0.06749301f, 0.01339074f, 0.08935742f, -0.06262912f, -0.04459221f, -0.01617954f, 
    0.05036357f, 0.05015350f, 0.04055908f, -0.04509659f, 0.03193570f, -0.29300687f, 0.27613464f, 0.05187677f, 
    -0.11034693f, 0.05459492f, 0.12972640f, -0.24618118f, 0.00978411f, 0.01936272f, -0.10020779f, -0.00094262f, 
    -0.07215500f, 0.04392684f, -0.00020305f, -0.18107593f, 0.08148748f, -0.14322302f, 0.05354518f, 0.03898163f, 
    0.17317228f, 0.21737313f, 0.01311117f, 0.02789384f, 0.16338308f, 0.24931988f, 0.20932631f, -0.02101536f, 
    0.07013181f, 0.10542402f, -0.02124622f, -0.09540727f, 0.12001491f, 0.02806115f, -0.07356841f, 0.06112686f, 
    0.01156929f, 0.08413114f, -0.03571315f, 0.10846149f, -0.28505769f, -0.36884651f, 0.32235718f, 0.30129334f, 
    0.07656816f, 0.01969259f, -0.01353082f, -0.06826839f, -0.06018852f, -0.11286221f, 0.08480556f, -0.06153557f, 
    0.01894390f, 0.04632714f, 0.01066151f, 0.08773383f, -0.11860835f, 0.02322727f, -0.15715449f, -0.14484268f, 
    -0.06639052f, -0.21819748f, 0.14201607f, -0.15555578f, -0.11842652f, -0.09912854f, 0.10496734f, -0.26537722f, 
    -0.00105429f, -0.01452914f, 0.01949210f, 0.04919181f, 0.03948819f, 0.02473169f, 0.13659556f, 0.06811333f, 
    -0.00072915f, -0.02373524f, -0.04832369f, 0.00001594f, 0.26726404f, -0.24687530f, -0.03500628f, 0.22625475f, 
    0.17862903f, 0.03822275f, 0.21437296f, 0.01262443f, 0.18162018f, -0.10165670f, 0.04624633f, -0.04448201f, 
    0.06862962f, -0.04725976f, 0.03015837f, 0.08274494f, 0.04209441f, -0.02919661f, 0.10317285f, 0.03742769f, 
    -0.04843650f, 0.08827306f, 0.04301665f, -0.04953748f, 0.07878022f, 0.10566229f, 0.03931985f, -0.03696766f, 
    -0.01923863f, 0.02925883f, -0.00502119f, 0.01002816f, 0.06496743f, 0.09960688f, 0.08551357f, 0.08736134f, 
    0.11134491f, -0.02462588f, -0.06849401f, -0.07220980f, -0.19518803f, -0.04222034f, 0.16313899f, 0.16168557f, 
    -0.07869566f, 0.05993185f, 0.00639640f, 0.12349053f, -0.03880371f, -0.06375455f, 0.07107284f, -0.06029391f, 
    0.01999157f, 0.02249763f, 0.04094587f, 0.07345198f, 0.00916654f, 0.04537230f, 0.00614588f, 0.00539566f, 
    0.06326777f, -0.01032546f, -0.17578578f, 0.12155643f, -0.14272419f, 0.08217273f, -0.16832073f, -0.01449724f, 
    0.10035673f, -0.09492724f, -0.04685263f, 0.10773063f, 0.02177886f, -0.17089917f, -0.06816013f, 0.03109566f, 
    -0.08939811f, -0.17102376f, 0.09023925f, 0.09427368f, -0.04279835f, -0.18032028f, -0.02194118f, -0.25474897f, 
    0.13522601f, -0.09541563f, -0.08404592f, -0.05355209f, -0.05808716f, -0.08111336f, -0.04269342f, -0.01933053f, 
    -0.06250229f, 0.00495956f, 0.01540320f, 0.07010412f, 0.01594764f, 0.00309257f, 0.03307130f, -0.02601024f, 
    -0.08836962f, -0.21693319f, -0.12616536f, 0.03443191f, -0.13282590f, 0.05003270f, -0.20883763f, -0.01396132f, 
    0.03346722f, -0.01079365f, 0.00450971f, 0.11850660f, 0.02753858f, 0.03957361f, -0.07485831f, 0.11317991f, 
    0.12155199f, -0.09681176f, -0.04979261f, 0.05824329f, 0.07690468f, -0.36636865f, -0.08108167f, 0.19486903f, 
    0.11198987f, -0.00860739f, 0.03954910f, 0.07801367f, -0.05760247f, 0.17129415f, 0.10784815f, 0.05308484f, 
    0.05614533f, 0.05636889f, 0.04864874f, -0.02045775f, -0.04014448f, -0.03145018f, -0.05433446f, -0.01780780f, 
    -0.15432605f, 0.03584889f, 0.04137302f, 0.20677610f, 0.07474783f, -0.00593601f, 0.01024731f, 0.01567932f, 
    -0.05560634f, 0.20720753f, -0.02030452f, 0.03977451f, 0.02966095f, 0.10297243f, -0.02873389f, 0.19311441f, 
    0.13776556f, -0.00667938f, 0.09538765f, 0.07115839f, 0.03044515f, -0.27104142f, 0.22644515f, -0.02484265f, 
    -0.02051832f, -0.13267706f, 0.00117974f, 0.01803412f, 0.05807817f, 0.04376877f, 0.01160567f, 0.07046165f, 
    0.01861971f, 0.07498575f, 0.00208912f, 0.13293274f, -0.01157927f, 0.09368034f, 0.02620783f, -0.03062243f, 
    -0.02529567f, -0.04391676f, 0.12215013f, -0.21959719f, 0.16681483f, -0.10453160f, 0.00157153f, -0.03473599f, 
    -0.03316195f, -0.02700479f, -0.12212718f, -0.01531812f, -0.00161213f, -0.03388555f, 0.02625150f, 0.08244421f, 
    0.02714617f, 0.07681310f, -0.00508174f, -0.02613484f, -0.09678222f, -0.13923065f, -0.20850170f, -0.13303071f, 
    0.16432089f, 0.00085348f, 0.00597714f, -0.01824328f, 0.10335080f, -0.02475386f, 0.11420777f, 0.15571730f, 
    0.08195747f, 0.06432334f, 0.12625040f, 0.19785722f, 0.00391196f, -0.04410133f, 0.02377496f, 0.04958079f, 
    -0.09929574f, 0.12780406f, 0.07926990f, 0.14259413f, 0.01733472f, -0.01842896f, 0.02531294f, -0.01982263f, 
    0.18531607f, 0.12089543f, 0.04550949f, 0.10268132f, 0.03037051f, 0.02530465f, 0.00249845f, 0.04040262f, 
    -0.01196782f, -0.01813200f, 0.04996921f, 0.09324690f, 0.08209447f, -0.37670401f, 0.03042755f, 0.27316552f, 
    0.07882185f, 0.18476830f, 0.20213200f, 0.07471220f, -0.00965517f, 0.17640972f, 0.07423488f, -0.08959980f, 
    0.10276844f, 0.09251153f, 0.00594396f, -0.01978265f, 0.03722444f, -0.00940775f, 0.00724766f, 0.07019491f, 
    0.07004524f, -0.07362387f, 0.02034052f, 0.02278533f, -0.06264406f, 0.14896642f, 0.10680323f, -0.00874219f, 
    0.05836835f, 0.09477131f, 0.05868206f, -0.05520179f, 0.15366489f, 0.18867356f, 0.14134547f, 0.11507941f, 
    -0.03213212f, -0.09535229f, 0.02108181f, -0.00640887f, -0.12181464f, -0.08577528f, 0.19691078f, 0.34215033f, 
    -0.21452485f, -0.13192309f, -0.20942819f, 0.11485449f, 0.16490825f, 0.21764810f, -0.01847369f, -0.02094208f, 
    0.06262311f, -0.12474294f, -0.10383982f, 0.10272290f, -0.04595421f, -0.21729574f, -0.11251918f, -0.01818009f, 
    -0.13488662f, -0.06454680f, 0.03702933f, -0.00629738f, -0.09094591f, 0.05797317f, 0.04396853f, -0.05730667f, 
    0.08403780f, -0.06245336f, 0.06577025f, 0.05483865f, -0.06485997f, 0.01571335f, 0.07584365f, -0.22479829f, 
    0.00924359f, -0.11541706f, -0.09489845f, -0.03078289f, -0.15400136f, -0.02431780f, 0.11771578f, 0.13428830f, 
    -0.09514955f, 0.03398038f, 0.00322881f, 0.04638191f, -0.00767315f, -0.02626630f, 0.02638661f, 0.01016786f, 
    0.04640500f, 0.10974154f, 0.05061923f, 0.05161204f, 0.01496480f, 0.02286942f, -0.04110297f, 0.00146261f, 
    -0.10417048f, -0.19779833f, 0.07949641f, 0.11626882f, -0.16227287f, -0.06433158f, -0.05459057f, 0.00008783f, 
    -0.14762248f, -0.14657602f, -0.16064411f, 0.18013364f, -0.09885478f, -0.06989869f, -0.11518805f, -0.01953245f, 
    -0.02322562f, -0.12158288f, 0.01357768f, -0.08463950f, 0.14675497f, -0.02826273f, -0.01595312f, 0.14703162f, 
    -0.07696816f, -0.18640527f, -0.16232702f, -0.02542324f, -0.14368314f, 0.01896373f, -0.17939386f, -0.06741554f, 
    -0.06664876f, -0.00919286f, -0.09834588f, -0.03567011f, -0.14754014f, -0.01018041f, 0.13127601f, 0.13161767f, 
    -0.13231295f, -0.14765127f, 0.40312132f, 0.08365165f, -0.01281186f, -0.05748400f, 0.09412196f, 0.05029486f, 
    0.22765826f, 0.14812015f, 0.09527180f, -0.03835518f, 0.07882041f, -0.01501155f, -0.07396154f, -0.06424790f, 
    0.01371217f, -0.04072341f, -0.03367205f, -0.02929299f, -0.08113284f, -0.12169978f, -0.05590006f, 0.10367063f, 
    -0.09363396f, -0.06119041f, -0.12056795f, -0.02715176f, 0.07842769f, -0.05456467f, 0.03307026f, -0.01083863f, 
    0.06802135f, 0.14443208f, 0.12027152f, 0.05390646f, 0.02726181f, -0.15015735f, -0.07560167f, 0.02352932f, 
    0.36018440f, 0.27460387f, 0.20157294f, 0.05871323f, 0.08082154f, 0.23978026f, 0.09793336f, 0.11013013f, 
    0.14543045f, 0.12154101f, -0.09097711f, 0.09314850f, 0.02291378f, -0.02571403f, 0.01001860f, 0.13207516f, 
    -0.08629411f, 0.09153064f, 0.23011385f, 0.11035631f, -0.16185381f, 0.02373759f, -0.01517918f, 0.41210929f, 
    -0.06216595f, -0.11401238f, -0.11364990f, -0.06006316f, -0.06479315f, 0.07128625f, -0.07763223f, -0.02657342f, 
    -0.04395353f, -0.03183338f, -0.15708834f, 0.06447798f, 0.06542581f, -0.04227068f, -0.13783059f, -0.03121885f, 
    0.01174969f, 0.01234720f, -0.00064545f, 0.00072643f, -0.03499940f, 0.00503558f, -0.01558035f, -0.00026659f, 
    -0.00083844f, -0.00776439f, 0.00389758f, 0.02439879f, 0.01792003f, 0.01518325f, -0.01009424f, -0.02999145f, 
    0.02841444f, -0.01960819f, -0.01207273f, 0.02744051f, -0.00884929f, -0.02558257f, -0.03845046f, -0.01805774f, 
    -0.02200079f, -0.04015617f, 0.01041171f, -0.03621818f, -0.02659008f, 0.02005031f, -0.04245801f, -0.00913308f, 
    0.02630208f, -0.00221190f, -0.01495509f, 0.01055876f, 0.02099799f, -0.01200281f, 0.02530653f, 0.01668442f, 
    -0.02491536f, -0.03530572f, -0.00920624f, -0.01232447f, -0.04272650f, -0.02742619f, -0.03752726f, 0.02152605f, 
    0.02004089f, -0.00342822f, 0.01333163f, -0.00118526f, 0.00707889f, -0.03494921f, -0.04685848f, -0.00624122f, 
    0.02626063f, 0.02816003f, 0.03188484f, -0.03296573f, -0.00559544f, -0.00395248f, -0.02665375f, 0.02672991f, 
    0.02060190f, -0.03351963f, 0.01845843f, -0.03951171f, -0.04615988f, 0.02636013f, -0.01194245f, -0.02097422f, 
    -0.01819743f, -0.00371968f, 0.02112075f, 0.01871084f, 0.02747766f, -0.02787029f, -0.03105086f, 0.03067047f, 
    0.02578851f, 0.03044291f, -0.01437737f, 0.00835443f, -0.04317272f, 0.03084603f, -0.01137108f, 0.01063970f, 
    -0.00781330f, -0.04387390f, -0.02758555f, 0.02199515f, 0.02159625f, -0.02810322f, -0.02734688f, 0.01229663f, 
    -0.02925966f, -0.01177831f, 0.00097849f, -0.04265037f, 0.00743315f, -0.04273841f, -0.04114291f, -0.01430737f, 
    0.00138939f, 0.02070994f, 0.00986557f, -0.02014724f, 0.01477651f, -0.03457537f, 0.03204646f, 0.02848002f, 
    0.00661245f, -0.03047959f, 0.00939758f, 0.01858482f, 0.00241317f, -0.02414238f, 0.02219177f, 0.01025006f, 
    0.00292793f, -0.04092893f, 0.01554550f, 0.00970884f, -0.01799193f, 0.01093606f, 0.01710149f, 0.01124580f, 
    -0.03749375f, 0.01969899f, -0.01541273f, -0.02121246f, -0.02105735f, -0.01438752f, -0.03589997f, -0.00687517f, 
    0.01213414f, 0.01979386f, -0.02370526f, -0.03592684f, 0.00117539f, -0.02568399f, 0.00078508f, -0.01247675f, 
    -0.03111237f, 0.00658349f, -0.00618843f, 0.01064633f, -0.00031176f, -0.02228818f, -0.01698761f, 0.00846628f, 
    -0.02103500f, -0.04343000f, 0.00427164f, -0.03053395f, 0.00278870f, -0.02454566f, 0.01280764f, 0.00537856f, 
    0.04036810f, -0.00607194f, 0.00636283f, 0.01714731f, 0.00115915f, 0.00275829f, -0.03108179f, 0.02246921f, 
    -0.00862368f, -0.02899273f, -0.00039533f, 0.04479568f, -0.01067941f, 0.01477681f, -0.02804103f, -0.00394096f, 
    0.00804003f, 0.00440907f, -0.02020278f, -0.04092611f, -0.02621688f, -0.00316259f, -0.02214680f, 0.00716149f, 
    -0.00678919f, 0.02998517f, 0.01801657f, 0.00855251f, 0.03049701f, -0.01158915f, 0.00667941f, 0.00626859f, 
    0.01616091f, -0.01128953f, 0.02995278f, -0.01822426f, 0.02463360f, -0.00513184f, -0.01378586f, -0.00939910f, 
    -0.01079802f, -0.00334654f, -0.00657850f, 0.00334189f, -0.00732223f, 0.01088518f, -0.03015794f, -0.03696792f, 
    0.01226120f, 0.00813572f, 0.01254295f, -0.02625791f, 0.02423242f, -0.04529620f, -0.03545237f, -0.00737963f, 
    -0.02154629f, -0.04240610f, 0.02216141f, 0.00757070f, -0.01920510f, -0.00839033f, 0.02422475f, 0.01254113f, 
    -0.03525606f, -0.04455796f, -0.04451413f, -0.01228769f, -0.03570743f, 0.02023086f, 0.02884933f, 0.03058987f, 
    -0.04540765f, -0.01617043f, -0.02629907f, -0.00712882f, 0.00621437f, 0.02468332f, 0.00916686f, 0.02547730f, 
    -0.00458893f, -0.00482157f, 0.00621169f, -0.03032783f, -0.00709036f, 0.01851264f, -0.03858371f, -0.00289738f, 
    0.02261189f, 0.01014692f, -0.03207218f, -0.00869186f, -0.03407326f, 0.01952654f, 0.01894793f, 0.01024387f, 
    -0.01608602f, -0.00577172f, -0.01483682f, -0.00188822f, 0.03205441f, 0.02954854f, -0.00940988f, 0.03196065f, 
    -0.03886950f, -0.02293351f, 0.02765596f, 0.03022337f, 0.02715635f, 0.03029842f, -0.04512388f, -0.03423827f, 
    -0.00646160f, 0.00907481f, 0.01433784f, -0.03735318f, -0.03721435f, -0.04500605f, -0.03082144f, -0.01460092f, 
    -0.02093197f, -0.03074113f, 0.01673042f, 0.01708128f, 0.00488942f, -0.02031552f, -0.04244472f, 0.02085620f, 
    0.00416017f, 0.02193401f, -0.01891861f, -0.01526284f, 0.01455577f, -0.02607599f, -0.03852335f, -0.01664179f, 
    -0.02656147f, 0.00850879f, -0.03565238f, 0.03027077f, 0.00097149f, 0.01487129f, -0.00579676f, -0.03815881f, 
    -0.00166752f, -0.01437120f, -0.01008236f, -0.01129188f, -0.02624313f, -0.03855690f, -0.00088443f, 0.00344494f, 
    -0.00118202f, 0.01907572f, 0.00432330f, -0.01774956f, 0.00394165f, -0.01949004f, -0.04364031f, -0.04344323f, 
    -0.00490678f, -0.04447142f, -0.01649184f, -0.00541148f, -0.03620440f, 0.03146617f, -0.02855040f, -0.01470141f, 
    -0.01482224f, -0.01703200f, -0.00716988f, 0.00058915f, -0.04034418f, -0.02033808f, -0.03194088f, -0.03009663f, 
    0.03261686f, -0.00427405f, -0.01341351f, 0.02824633f, -0.03010227f, 0.02195997f, 0.00587882f, 0.02015771f, 
    0.02589827f, -0.04162535f, 0.01256899f, -0.03118204f, -0.02927311f, -0.00535594f, -0.02951549f, -0.03471771f, 
    0.02511599f, 0.01483741f, 0.02779387f, 0.00004328f, -0.03068674f, -0.03839993f, 0.00710496f, -0.02938581f, 
    -0.01874339f, -0.04289231f, -0.01810901f, -0.03282517f, -0.01728138f, 0.01982037f, -0.02087312f, 0.02826958f, 
    -0.02171249f, -0.01400462f, 0.01550236f, -0.01747655f, -0.02898718f, -0.00284711f, -0.00779252f, -0.00481831f, 
    -0.01480460f, 0.00738470f, 0.00318453f, -0.03152471f, 0.00306422f, -0.02716189f, 0.00525526f, -0.00739094f, 
    -0.03321966f, -0.03792378f, -0.00371923f, -0.03788941f, -0.00756769f, -0.01131141f, -0.01483935f, -0.00355906f, 
    -0.00102535f, -0.01297711f, -0.01128636f, 0.01226159f, -0.00177223f, -0.01737645f, -0.00684576f, -0.01269496f, 
    -0.00474016f, 0.01523007f, 0.02653436f, 0.02022490f, -0.02638349f, -0.01390010f, -0.00355311f, -0.01309468f, 
    -0.03272730f, 0.02297802f, 0.02061861f, -0.00665241f, 0.02147484f, -0.00391776f, 0.00670144f, 0.00275900f, 
    -0.02729958f, -0.03231676f, 0.02588471f, -0.03807403f, -0.00832415f, -0.02361126f, 0.01756463f, 0.04624876f, 
    -0.00709984f, -0.00329461f, 0.01788604f, -0.02236483f, -0.01387852f, -0.03330573f, 0.02883134f, 0.01589518f, 
    0.03109614f, -0.00453174f, 0.00229079f, -0.02708459f, -0.04197204f, 0.02912539f, 0.00797457f, -0.02430793f, 
    -0.00206170f, 0.01119188f, 0.01838060f, -0.02733646f, -0.01571595f, 0.00862409f, -0.00508956f, -0.03616470f, 
    -0.00842654f, 0.00465693f, 0.01676362f, -0.02935731f, 0.02918622f, 0.01417175f, -0.01018290f, -0.02196584f, 
    0.01629400f, -0.00194216f, -0.04353224f, 0.00591918f, -0.02179773f, -0.00493829f, -0.00953283f, -0.02771035f, 
    -0.03995042f, -0.02823711f, -0.01011269f, 0.02278800f, 0.01372193f, 0.03186056f, 0.01401476f, -0.00005090f, 
    0.01118232f, -0.01180484f, -0.02335068f, 0.01211501f, -0.00529788f, 0.02514412f, 0.00724106f, -0.01894028f, 
    0.01209694f, 0.00852246f, -0.01267857f, 0.03110815f, -0.00887788f, 0.02893869f, -0.03574657f, 0.00583585f, 
    0.01822109f, 0.00584686f, -0.04238078f, 0.02201910f, -0.04390446f, 0.02735327f, -0.01536591f, 0.01834396f, 
    0.01269130f, -0.04561340f, 0.02211734f, 0.02283728f, 0.00389952f, -0.00509968f, 0.00023663f, 0.00432688f, 
    0.00915166f, -0.02228318f, -0.00585569f, -0.03725932f, 0.00115261f, -0.02418846f, -0.00121969f, -0.01092332f, 
    -0.04110742f, -0.01676181f, -0.04058905f, 0.01495946f, 0.01900978f, -0.02404467f, -0.03843369f, -0.01150387f, 
    0.01555094f, -0.03215897f, -0.01465386f, -0.04169542f, 0.00749491f, -0.03221032f, 0.02692558f, 0.00538617f, 
    -0.02500121f, -0.03561644f, -0.02073403f, -0.01223333f, -0.00538891f, 0.02309080f, 0.00540778f, -0.01829533f, 
    -0.04479373f, 0.00370101f, 0.02394252f, -0.02673435f, -0.03986697f, 0.00737429f, -0.03098959f, 0.01688917f, 
    -0.03743662f, 0.02471136f, 0.00573967f, -0.04298927f, -0.01869189f, -0.01330907f, -0.00822295f, -0.00217649f, 
    -0.00606531f, -0.01706651f, -0.04306009f, 0.00809399f, -0.02525561f, 0.01576475f, 0.02721496f, -0.01008218f, 
    0.01980021f, -0.02636300f, -0.00201261f, 0.01948013f, 0.01643286f, 0.01667416f, -0.00559504f, -0.02430668f, 
    0.00549222f, -0.00624034f, -0.00906491f, 0.00107264f, 0.01735642f, -0.01459219f, -0.03252077f, 0.00870602f, 
    -0.03104872f, -0.03152397f, 0.02397707f, 0.00515502f, -0.04024479f, 0.03176168f, -0.03028629f, -0.02105080f, 
    -0.02295381f, -0.03909109f, 0.01917963f, -0.03106029f, -0.00520652f, 0.03148314f, 0.01611070f, 0.00659035f, 
    -0.04590182f, 0.02832723f, -0.01121888f, 0.00794425f, -0.01347772f, 0.00462958f, 0.01839722f, -0.01110130f, 
    -0.02011551f, 0.01342272f, 0.02966773f, 0.02163528f, -0.03243201f, -0.03013535f, -0.01369206f, -0.01234449f, 
    -0.00184302f, 0.00553810f, 0.01641675f, -0.02821629f, 0.02218973f, -0.02832624f, -0.02694309f, -0.02825849f, 
    -0.00027597f, 0.02848453f, -0.00609193f, -0.03292557f, 0.00661723f, -0.04246202f, 0.02822064f, 0.01898735f, 
    -0.02702750f, 0.00796938f, 0.03276155f, 0.02017406f, -0.04671405f, -0.01269204f, 0.01362363f, -0.01018307f, 
    0.02243914f, -0.03210054f, -0.04286842f, -0.01926258f, 0.02986306f, 0.01523988f, -0.04152599f, 0.01003727f, 
    0.03601154f, -0.23638111f, 0.28444684f, 0.60166776f, 0.26482421f, 0.03466363f, 0.36856180f, 0.27861902f, 
    -0.05808018f, 0.09308621f, 0.01420946f, 0.03651984f, -0.18516120f, -0.03760911f, -0.04816964f, 0.03575780f, 
    0.09166241f, 0.17339315f, -0.06908950f, -0.01265589f, -0.26348382f, -0.31861538f, -0.40456998f, 0.07013226f, 
    0.08258455f, 0.09627727f, 0.02863844f, -0.02207878f, -0.05107958f, 0.12264882f, -0.00077701f, -0.04315528f, 
    -0.07518506f, 0.18938199f, -0.04048290f, 0.02526731f, 0.05780583f, 0.22962496f, 0.02566084f, 0.02045226f, 
    -0.10080292f, -0.18126249f, -0.18826374f, 0.14941859f, 0.39620316f, 0.08281461f, 0.09781142f, 0.11630497f, 
    0.28612971f, -0.05241191f, 0.02304214f, -0.01120613f, 0.05135944f, 0.07280762f, 0.05319120f, 0.02272406f, 
    0.06352019f, 0.02400756f, 0.00541896f, 0.09467535f, -0.07677400f, -0.19270419f, 0.13317965f, 0.09051825f, 
    0.15000387f, 0.05484814f, 0.08069395f, 0.12178900f, -0.04748967f, 0.02373652f, -0.06411579f, -0.10084903f, 
    0.01302873f, -0.10875887f, -0.05126924f, 0.03359966f, -0.01314016f, -0.10044324f, -0.16624063f, 0.14743122f, 
    -0.28578734f, -0.18481497f, -0.10872316f, -0.10379638f, -0.19980578f, 0.03003308f, 0.03961232f, 0.03416038f, 
    0.09546832f, 0.01380805f, -0.10696632f, -0.08673286f, -0.04053520f, -0.01055582f, -0.01533799f, 0.10201868f, 
    0.06716903f, 0.14496087f, -0.03123779f, -0.06561794f, 0.35202307f, 0.03481161f, -0.15554249f, -0.11498085f, 
    0.02471585f, 0.00384636f, 0.00906672f, 0.04800578f, 0.02771493f, -0.05272403f, 0.05656498f, 0.04636980f, 
    0.13631567f, -0.17075580f, -0.00603159f, 0.15434238f, 0.04123659f, 0.17352474f, -0.10418810f, 0.02568684f, 
    0.04288727f, 0.11477917f, -0.34878719f, -0.01246857f, 0.06068382f, -0.00995676f, 0.04428520f, 0.21318537f, 
    0.07424236f, 0.06944905f, 0.00638219f, 0.03619063f, 0.01755855f, -0.06590445f, 0.03465194f, -0.08846281f, 
    -0.03985746f, 0.03412689f, -0.00792960f, 0.01954322f, -0.39794010f, 0.50245035f, 0.07370890f, 0.00544273f, 
    0.12302582f, 0.03144908f, 0.09293650f, -0.06461869f, -0.12057772f, -0.00876579f, -0.12234597f, -0.04920340f, 
    -0.14613694f, -0.02406597f, 0.08348681f, -0.17876120f, 0.04780651f, 0.02273373f, 0.07725925f, 0.13166642f, 
    -0.72409731f, 0.17603403f, -0.01442783f, -0.35101256f, 0.45343491f, 0.04746976f, -0.02691861f, -0.06142529f, 
    0.03095780f, -0.17535201f, -0.00564904f, 0.15078953f, 0.32074720f, 0.11712337f, 0.13653387f, -0.09089743f, 
    0.08269845f, 0.01106540f, -0.01634042f, 0.02621116f, -0.12565756f, 0.11134672f, 0.44621864f, 0.17422608f, 
    0.22884773f, 0.14465828f, 0.00578211f, -0.05178344f, 0.00386746f, 0.08016213f, -0.04515600f, -0.01202894f, 
    0.03947162f, -0.06958793f, -0.16172516f, -0.04283442f, -0.03734199f, 0.17412215f, -0.04281135f, -0.04320665f, 
    -0.02180311f, -0.11738994f, -0.09391689f, -0.12878717f, -0.06419583f, 0.04198940f, 0.11378051f, 0.09534106f, 
    0.00378761f, -0.01079880f, 0.02717476f, 0.03925795f, -0.00586552f, -0.09904596f, 0.03737221f, 0.11477561f, 
    0.04216107f, 0.08250085f, 0.00454453f, 0.05668204f, -0.00160932f, -0.23859376f, -0.28518200f, -0.06266295f, 
    0.27553239f, -0.00393756f, 0.02572057f, 0.12274870f, 0.16815370f, 0.09900964f, -0.04512640f, 0.03931312f, 
    0.00108623f, 0.09745678f, 0.02694046f, 0.19480060f, 0.28313708f, 0.19222499f, 0.03899088f, -0.08636695f, 
    -0.01823299f, 0.07975292f, 0.12900677f, 0.07503917f, 0.20634909f, -0.08795635f, 0.11254223f, 0.26804301f, 
    -0.08689424f, -0.11268224f, 0.24403277f, -0.07217151f, -0.02148006f, -0.20034523f, 0.04420189f, 0.04143356f, 
    -0.01783320f, 0.25420794f, 0.06361566f, 0.06303422f, -0.12472585f, 0.08581105f, 0.05220230f, 0.02972810f, 
    -0.14654215f, -0.00796421f, 0.02514471f, -0.06926060f, -0.07284205f, 0.02679062f, -0.06621563f, 0.09606063f, 
    0.01656178f, -0.00848707f, -0.07432310f, 0.01340969f, 0.13722759f, -0.04763238f, 0.03061817f, -0.01275795f, 
    0.02114259f, -0.15359589f, 0.05182437f, 0.30189815f, 0.21482411f, -0.07453269f, 0.17666322f, 0.18358609f, 
    -0.03998740f, -0.10165198f, 0.07279331f, -0.00429387f, -0.05167270f, -0.06012028f, -0.01848874f, 0.22168212f, 
    0.15400320f, -0.01930954f, 0.23361188f, -0.00570334f, -0.00073236f, 0.61158288f, 0.03860183f, 0.18775220f, 
    -0.10342339f, 0.04224686f, 0.02097527f, -0.05682063f, -0.02085464f, 0.08476023f, 0.10146065f, 0.09149373f, 
    0.17246842f, 0.00818212f, 0.08796385f, -0.09861372f, 0.01172438f, -0.02064855f, 0.02404061f, -0.01634061f, 
    -0.14231662f, -0.25833341f, -0.07181245f, 0.03766116f, -0.09192138f, -0.06997134f, -0.06177778f, -0.00874606f, 
    0.02489225f, 0.08240379f, 0.04749362f, -0.01557429f, 0.06440992f, 0.02570424f, 0.05656946f, -0.02820364f, 
    0.05547051f, -0.06382558f, 0.19040093f, 0.07812728f, -0.41254383f, 0.36478922f, -0.07662056f, -0.17027923f, 
    0.10206925f, 0.06018647f, -0.06692266f, -0.02076152f, -0.01030418f, 0.10896938f, 0.07499854f, 0.23336555f, 
    0.04615598f, 0.23040618f, 0.11480003f, -0.11361201f, -0.19264710f, 0.08068141f, -0.03967883f, 0.11879165f, 
    -0.21304956f, 0.00098618f, 0.03019042f, -0.00815518f, -0.15303503f, -0.00847679f, -0.04425268f, 0.03012021f, 
    -0.03915095f, 0.00124309f, -0.03206626f, 0.00688615f, 0.02173019f, 0.02006601f, -0.02057244f, 0.02911091f, 
    0.08242944f, 0.10638984f, -0.02329561f, 0.00533955f, -0.04666982f, 0.05899722f, 0.09988680f, -0.09036009f, 
    -0.05667126f, 0.03674437f, -0.03860832f, -0.07836105f, -0.01596516f, 0.01457490f, 0.06505743f, 0.08629462f, 
    0.13629590f, 0.08773154f, 0.02835100f, -0.03020682f, -0.06149692f, 0.10897157f, 0.01112837f, 0.01520822f, 
    0.05243978f, 0.22805209f, 0.28988522f, 0.09979325f, 0.03766988f, -0.04150712f, -0.02270332f, -0.03211596f, 
    0.02620954f, 0.05681321f, 0.17569751f, -0.02202352f, 0.08050826f, -0.14962830f, -0.10008483f, 0.03312951f, 
    -0.02471432f, 0.01167046f, 0.08876980f, -0.01065677f, 0.71213818f, 0.19589834f, -0.32530671f, 0.22575551f, 
    0.07190160f, 0.02322893f, 0.00935112f, 0.15088151f, -0.02716997f, 0.18008088f, -0.03165836f, -0.02354862f, 
    -0.00109006f, 0.10649063f, 0.01510207f, 0.13830990f, -0.02882811f, -0.05484242f, 0.21550299f, -0.00115405f, 
    0.17159955f, -0.01996575f, 0.09182294f, -0.04364759f, 0.07010179f, 0.13755959f, -0.02661504f, 0.04408580f, 
    -0.04944411f, 0.14242153f, 0.06801071f, -0.07577620f, -0.05734796f, 0.06928990f, 0.11580057f, -0.09085796f, 
    0.14137116f, 0.17801179f, -0.03299183f, 0.09268602f, -0.18478344f, -0.29793686f, -0.01802942f, -0.01460666f, 
    0.21115142f, 0.19081004f, -0.11133522f, 0.02069774f, 0.21363145f, 0.07814906f, -0.05992183f, 0.01537461f, 
    -0.13134530f, 0.10698872f, -0.05224418f, -0.00275411f, 0.06314591f, 0.04852112f, 0.15338099f, 0.06304906f, 
    -0.29018652f, 0.09766021f, 0.09261133f, 0.00759832f, 0.08898962f, 0.00223577f, -0.09917182f, -0.11945080f, 
    -0.00226629f, 0.00389405f, 0.00831612f, -0.01573766f, 0.06905499f, 0.00083379f, 0.01123276f, 0.11257511f, 
    -0.04325623f, -0.02404201f, 0.04001046f, -0.00564323f, -0.12211097f, -0.18549997f, -0.21082933f, -0.01689642f, 
    0.30427694f, -0.03299116f, 0.03716346f, 0.07658070f, 0.13191617f, 0.03500679f, 0.03369720f, 0.04533082f, 
    -0.03110179f, 0.06410872f, -0.04573767f, 0.17303395f, 0.15967911f, 0.02112278f, -0.01162780f, 0.00410695f, 
    -0.09394132f, -0.24793276f, 0.00523858f, 0.03339997f, 0.15956727f, 0.04490006f, 0.06354282f, 0.10937589f, 
    -0.15409212f, -0.02887978f, -0.00940134f, 0.02267022f, -0.10426631f, -0.06905676f, 0.00544872f, -0.05760430f, 
    -0.01785839f, -0.00913610f, 0.25476196f, -0.00139166f, 0.00949735f, -0.10678251f, -0.10374374f, -0.02657961f, 
    -0.05120531f, 0.07001019f, 0.01497077f, 0.00015925f, 0.24871117f, 0.02888089f, -0.11269531f, -0.00409695f, 
    -0.03385834f, 0.01353011f, 0.11898072f, 0.14026208f, -0.05232510f, -0.05360095f, 0.08291506f, 0.12594935f, 
    -0.16735354f, 0.26095161f, 0.22836822f, 0.08863756f, 0.32793203f, 0.03790710f, 0.04398155f, -0.14887179f, 
    0.20082627f, 0.13604052f, -0.00448957f, 0.10737718f, 0.01825649f, 0.08968795f, -0.04917394f, -0.19963475f, 
    -0.08939717f, 0.06757043f, -0.04004948f, -0.01864319f, -0.29936704f, -0.20374230f, -0.21985465f, 0.22327749f, 
    0.01093952f, -0.09379855f, 0.01086714f, -0.09038339f, 0.09665667f, -0.08618163f, -0.01053461f, 0.04645075f, 
    -0.08180823f, 0.08401424f, 0.03631634f, 0.09489988f, 0.11210679f, 0.04059754f, 0.05392092f, -0.02901236f, 
    -0.01960542f, -0.02337198f, 0.13568345f, 0.13359275f, 0.29964742f, 0.16556780f, 0.10364520f, 0.26785582f, 
    0.25241682f, -0.01564481f, 0.05917654f, -0.09739929f, -0.06258272f, -0.09318330f, 0.00494770f, 0.03199192f, 
    -0.06511557f, 0.21923472f, 0.01251042f, 0.03409713f, -0.17457190f, -0.26644191f, 0.09751675f, 0.17078391f, 
    -0.07168421f, 0.06276646f, -0.06537686f, -0.13761701f, 0.06628169f, -0.00569904f, -0.02083258f, -0.00235135f, 
    -0.04027106f, -0.13134456f, -0.03929265f, -0.06229537f, 0.02953039f, 0.01898097f, 0.16738288f, -0.02692571f, 
    0.03134360f, 0.01478469f, 0.01273343f, 0.00607152f, -0.00054130f, -0.04014582f, -0.03928353f, -0.02209792f, 
    -0.02916604f, -0.01920274f, -0.02476672f, -0.01804466f, -0.02657637f, -0.03808677f, 0.00621948f, 0.02410228f, 
    -0.04065117f, -0.04527044f, -0.02436956f, 0.00992479f, -0.03144893f, -0.02691446f, -0.00488988f, -0.01578724f, 
    0.01394948f, 0.00176231f, 0.01109059f, -0.02316981f, 0.01657506f, -0.00485289f, -0.00620578f, 0.02191892f, 
    0.00928085f, 0.01806798f, -0.01716961f, 0.00826800f, 0.02446974f, 0.00839432f, 0.02199501f, -0.03661907f, 
    0.00115195f, -0.04132204f, 0.02402168f, 0.00220256f, -0.03545222f, -0.00171769f, 0.00821685f, 0.03200309f, 
    0.00899212f, 0.03049731f, -0.03228907f, -0.02977974f, 0.00279864f, 0.01218313f, -0.03694222f, 0.02157893f, 
    0.00427131f, 0.00557365f, 0.01500857f, 0.00813983f, -0.04448348f, -0.02159590f, -0.04249972f, 0.00091677f, 
    -0.00752486f, -0.02414707f, 0.02219505f, -0.01954435f, -0.01299406f, -0.01915371f, -0.01852545f, 0.00002096f, 
    -0.03924488f, 0.00128090f, 0.02050938f, -0.00036347f, 0.01659431f, 0.01143490f, 0.00052011f, -0.04530020f, 
    -0.04516715f, -0.04056896f, -0.04385049f, -0.02776748f, -0.04275121f, -0.01971490f, -0.01008914f, -0.01022672f, 
    0.03032699f, -0.01714103f, -0.01691518f, -0.02895124f, 0.02188713f, -0.01949118f, -0.01001151f, -0.00662665f, 
    0.02592192f, -0.00616678f, -0.00313981f, -0.03086696f, -0.02556690f, 0.01616966f, -0.00136487f, -0.03071723f, 
    -0.00850457f, 0.02488522f, -0.02537625f, 0.01619902f, 0.02017235f, 0.02031708f, -0.04596876f, -0.01361750f, 
    0.00107008f, -0.03015465f, -0.02070449f, -0.01935585f, 0.01005991f, 0.00220261f, 0.03214981f, -0.02748388f, 
    -0.01152149f, -0.02410104f, 0.02305737f, -0.02777521f, 0.00958503f, -0.03133244f, -0.03614863f, -0.02812021f, 
    -0.00349784f, 0.00859390f, -0.01777691f, 0.00128926f, -0.00305100f, 0.03120676f, -0.02062049f, 0.00589580f, 
    -0.02881156f, 0.03179617f, -0.03003617f, 0.01580216f, -0.02136233f, -0.02770052f, 0.02738347f, 0.01483116f, 
    -0.03479936f, -0.03251067f, 0.00338242f, 0.00650000f, 0.00261011f, -0.02567351f, 0.01677206f, -0.01985926f, 
    -0.00419880f, 0.00949864f, -0.02352848f, -0.01157938f, 0.00988823f, 0.00587963f, 0.01744088f, -0.00346546f, 
    -0.01095505f, 0.00522946f, 0.01711353f, -0.01080228f, -0.03473575f, -0.04309524f, 0.02084323f, -0.02429967f, 
    -0.03774184f, 0.00340388f, -0.03848049f, -0.01261757f, -0.00958263f, -0.02581502f, 0.02932252f, 0.02834085f, 
    -0.01808259f, -0.00712685f, -0.01549465f, 0.01280868f, -0.04154369f, -0.00821587f, -0.03249247f, 0.01519730f, 
    -0.01709989f, 0.00983490f, -0.00508889f, 0.01823059f, -0.00554379f, -0.02682100f, 0.00260843f, 0.00839230f, 
    0.00506455f, -0.01859537f, -0.02464360f, -0.03347731f, -0.02007960f, 0.00731112f, -0.02631337f, 0.00543886f, 
    0.01355590f, -0.01710767f, -0.03338518f, -0.01136294f, 0.01659906f, 0.00722506f, 0.02770647f, -0.01659552f, 
    0.03506649f, -0.03217368f, -0.01950068f, -0.02222194f, 0.00616348f, 0.02309061f, -0.02717492f, -0.04403707f, 
    -0.00704509f, -0.03212236f, -0.00761073f, -0.02018937f, 0.02610081f, -0.04126712f, 0.02788473f, -0.03977540f, 
    0.00397922f, 0.01513953f, -0.00390686f, 0.02739846f, 0.02676933f, 0.02163918f, -0.02142769f, -0.00333600f, 
    -0.01902348f, 0.02745033f, 0.01217198f, 0.00474876f, -0.00626828f, 0.00792461f, 0.00718982f, -0.00532889f, 
    0.00260061f, -0.01507292f, 0.00344583f, 0.02458861f, 0.02805656f, 0.02106603f, 0.01389477f, -0.02609866f, 
    0.01743789f, -0.03196873f, 0.03298630f, 0.02759672f, 0.00459845f, -0.04298185f, -0.03825325f, -0.02781580f, 
    -0.01310366f, -0.02616034f, 0.01741278f, 0.00200648f, 0.00623441f, -0.01785468f, -0.01785104f, -0.01839627f, 
    0.00366095f, 0.01591629f, 0.01427097f, -0.01830720f, 0.00524259f, -0.02559456f, 0.02010693f, 0.02416334f, 
    0.02477003f, -0.02146749f, 0.02194692f, -0.00973558f, 0.00678080f, -0.02442542f, 0.02429754f, -0.00628459f, 
    -0.02191479f, 0.01124209f, 0.00266904f, 0.00195169f, -0.01220077f, 0.02448587f, 0.01209700f, -0.03329239f, 
    -0.00925833f, 0.02456303f, 0.02567604f, -0.04016412f, -0.01881168f, -0.04342028f, 0.00886121f, -0.03016040f, 
    0.01109346f, -0.03884028f, 0.00988933f, -0.01076709f, -0.00986849f, -0.00823047f, 0.02818016f, 0.02046760f, 
    0.01629817f, 0.00295030f, 0.02240703f, -0.03876693f, -0.01305308f, -0.01764936f, -0.02085688f, 0.00499462f, 
    0.02283687f, 0.03119342f, 0.00524222f, -0.04097369f, -0.03759159f, 0.00773386f, -0.00548386f, 0.00205653f, 
    -0.01312018f, -0.00029329f, -0.04282226f, -0.01214655f, -0.02038355f, -0.03002342f, -0.04431478f, -0.01460526f, 
    0.00161402f, 0.01965115f, -0.01319610f, -0.03406173f, -0.00633201f, 0.03159051f, -0.02886413f, -0.01435593f, 
    -0.01480816f, 0.02840148f, -0.04422778f, -0.03041033f, -0.03729751f, -0.03202860f, 0.01807094f, 0.03177606f, 
    0.01979176f, -0.03278032f, 0.02987102f, -0.02673045f, 0.02239772f, -0.01299875f, 0.00260722f, 0.00521727f, 
    0.01153737f, -0.00086193f, -0.00391559f, -0.01079856f, -0.02935611f, -0.02239104f, 0.02218033f, -0.03507903f, 
    -0.04466704f, 0.02273424f, 0.00569168f, 0.02620214f, 0.00121184f, 0.01124852f, -0.02528253f, -0.04111864f, 
    -0.00259926f, -0.03289921f, 0.00246437f, -0.03701999f, 0.00617421f, -0.01177351f, 0.00453346f, -0.01877761f, 
    -0.02364461f, 0.01755488f, 0.02941399f, -0.04022740f, -0.01978779f, 0.01754826f, -0.04259904f, 0.01829888f, 
    -0.03456772f, -0.02582409f, -0.00468224f, -0.03089407f, -0.04120208f, 0.03156697f, -0.02456135f, 0.03738571f, 
    0.03837930f, 0.00328702f, 0.02527542f, -0.03858724f, -0.00178359f, -0.00333526f, 0.01470305f, 0.01065225f, 
    0.02983377f, 0.00850868f, -0.02600318f, -0.03704904f, -0.00988866f, 0.02712289f, 0.01601578f, 0.02589033f, 
    0.00109381f, -0.01980189f, -0.01709948f, -0.03205307f, 0.01981277f, -0.01304000f, 0.02280100f, 0.00504366f, 
    0.00173767f, -0.00155383f, -0.03161255f, 0.01130156f, -0.00285723f, -0.01124038f, 0.01458587f, -0.02671319f, 
    -0.02621663f, -0.02868631f, -0.04694409f, 0.01412654f, -0.03239176f, -0.04115034f, 0.01856393f, 0.00068096f, 
    -0.03398509f, 0.03153034f, -0.01311780f, -0.04074742f, 0.03222205f, -0.02753337f, 0.01559579f, -0.02882482f, 
    -0.04664331f, 0.02031677f, -0.02306730f, -0.02361393f, 0.00382250f, -0.01085560f, -0.00671938f, -0.04578085f, 
    -0.03345644f, -0.00773974f, 0.00197920f, 0.03250170f, -0.01174990f, 0.00187063f, 0.02901361f, -0.01827706f, 
    -0.00171655f, -0.04435502f, -0.03997194f, -0.02722938f, -0.01209909f, 0.00035627f, -0.00787612f, -0.00198462f, 
    0.02496461f, 0.01770797f, 0.03232183f, -0.01575898f, -0.03649963f, 0.02443295f, 0.00067436f, 0.03299470f, 
    0.03223190f, -0.01444927f, 0.00410262f, -0.00847342f, -0.00741689f, -0.01071671f, -0.02947639f, -0.01112140f, 
    0.01683038f, 0.03204157f, -0.01622006f, -0.01798344f, 0.02879547f, 0.01922993f, -0.01150225f, -0.04335228f, 
    -0.01114570f, 0.01408777f, 0.01010023f, -0.03945300f, -0.01049365f, 0.02220474f, -0.00327796f, 0.02842837f, 
    0.02317774f, -0.03927289f, 0.02544679f, -0.00133243f, -0.03847285f, 0.02106040f, 0.00744518f, -0.02134287f, 
    0.02844119f, -0.03513156f, 0.00661920f, -0.02406786f, 0.03209341f, 0.00242432f, 0.01750207f, 0.01890302f, 
    0.02363226f, 0.02677086f, 0.00468650f, 0.02704655f, -0.02273306f, 0.01455016f, 0.01768930f, -0.03216182f, 
    0.00874065f, 0.02173258f, 0.01727643f, 0.03306897f, -0.03600119f, 0.02217581f, 0.00440078f, -0.03355875f, 
    -0.01588853f, -0.02474694f, -0.00587837f, 0.02898470f, -0.03060014f, -0.04531847f, 0.03217925f, -0.01857355f, 
    -0.03380707f, 0.01868016f, -0.00592714f, 0.01381384f, 0.00878479f, -0.02639949f, -0.00160042f, 0.02820365f, 
    -0.02745189f, -0.04045302f, -0.00882307f, -0.00974655f, -0.03279984f, -0.02381010f, -0.02036028f, 0.03111466f, 
    -0.00089871f, 0.03450667f, -0.00220001f, 0.00007678f, 0.03228543f, 0.00957486f, -0.02138781f, -0.01528140f, 
    0.01323420f, -0.02345799f, -0.02598304f, -0.03117160f, -0.02759660f, 0.01245964f, -0.03511075f, 0.02960305f, 
    0.00741638f, -0.01850650f, -0.02959827f, 0.01814998f, -0.02508161f, 0.01032390f, -0.00949244f, -0.02888452f, 
    0.02066338f, 0.02768996f, -0.03537252f, -0.03705570f, 0.01714211f, -0.00934029f, -0.01556181f, 0.01235070f, 
    -0.03626085f, 0.01957166f, -0.03794439f, -0.00929726f, 0.01009739f, 0.01907755f, 0.01768549f, -0.03755910f, 
    -0.04302685f, 0.00596479f, 0.01708801f, -0.00064506f, 0.02518141f, 0.00846817f, -0.02660310f, 0.01627761f, 
    -0.01665602f, 0.01905543f, 0.03220583f, -0.03817058f, 0.00141590f, 0.01653159f, 0.01989876f, -0.00973627f, 
    0.00311167f, 0.01288527f, 0.01038478f, -0.02109507f, -0.01761189f, -0.02427498f, -0.03893571f, 0.02146301f, 
    -0.02123295f, -0.04438718f, -0.01839123f, -0.02221423f, 0.00575613f, -0.00723419f, -0.00573321f, 0.00590066f, 
    -0.01562676f, -0.00337688f, -0.01323068f, 0.00784404f, 0.02555993f, 0.00928249f, -0.00263110f, -0.01880781f, 
    -0.03851409f, 0.01370599f, 0.02940097f, -0.00852739f, -0.01964296f, -0.04250289f, 0.01636363f, -0.01562420f, 
    -0.10994195f, -0.16689378f, -0.57486069f, 0.10778845f, 0.09392187f, 0.08568645f, 0.29255012f, 0.04055215f, 
    0.23624170f, 0.20936181f, -0.12470521f, 0.01516061f, -0.14687207f, -0.03326142f, -0.02654818f, 0.01708421f, 
    -0.03553707f, 0.04896497f, 0.01143879f, 0.09862226f, -0.13430236f, 0.07709642f, -0.04692130f, 0.24127099f, 
    0.06338068f, 0.08730299f, 0.09411643f, -0.06539701f, -0.17725588f, -0.02784881f, 0.07765855f, -0.02230722f, 
    0.01760710f, -0.11701402f, 0.05165938f, 0.08547943f, 0.08068087f, 0.01394732f, -0.07563127f, 0.05761931f, 
    -0.11029737f, 0.27308139f, -0.12244117f, 0.00628355f, -0.01743514f, 0.03851145f, 0.08665978f, 0.06410083f, 
    -0.04871931f, 0.25677899f, -0.02120147f, 0.01363445f, 0.02440757f, -0.13487676f, 0.11090325f, -0.03118081f, 
    0.01812503f, -0.02375015f, -0.13356192f, 0.00526329f, 0.00942092f, -0.20786253f, -0.53479809f, 0.00438938f, 
    0.22553499f, -0.11647229f, 0.05625270f, 0.02801040f, 0.07518358f, -0.02771124f, -0.02533533f, -0.05319653f, 
    -0.05722019f, 0.03563768f, -0.00827889f, 0.00991391f, 0.00235036f, 0.07529066f, 0.02690209f, -0.00795261f, 
    -0.19048683f, -0.34235957f, -0.46986434f, -0.14218700f, 0.14953390f, -0.02528477f, -0.06749194f, 0.00229958f, 
    -0.09747557f, -0.01554100f, 0.02927912f, -0.07290764f, -0.04487309f, -0.08092497f, 0.04223057f, 0.04691730f, 
    0.08979344f, 0.05984780f, 0.14035280f, 0.01045307f, -0.35319516f, 0.14398654f, -0.25522152f, -0.16894612f, 
    -0.16789243f, -0.18399936f, -0.03451098f, -0.03268184f, -0.33290029f, -0.01640994f, 0.06502515f, 0.01199430f, 
    0.09330393f, -0.01008926f, -0.05154172f, -0.02878096f, 0.14397936f, 0.00877096f, 0.09049796f, 0.03286383f, 
    -0.45916590f, -0.15257023f, -0.31125695f, -0.04484239f, 0.02982686f, 0.12587108f, 0.08689395f, 0.08303710f, 
    -0.03099568f, 0.02563021f, 0.18771690f, -0.01218104f, -0.05432656f, 0.02400918f, 0.07135540f, 0.07448778f, 
    0.09045295f, 0.03604819f, 0.06373469f, -0.05369336f, -0.04241166f, 0.39548069f, 0.38909853f, 0.17709808f, 
    0.11816444f, 0.01261969f, 0.03613408f, -0.24538802f, -0.08111947f, -0.12129526f, 0.08896857f, -0.08582315f, 
    -0.00980027f, -0.18251146f, -0.02535363f, 0.08592567f, 0.02857568f, 0.00411806f, 0.15932801f, -0.00833434f, 
    0.72637308f, 0.26304197f, 0.05687898f, -0.46062139f, -0.17088313f, -0.07107186f, -0.18809406f, -0.12775105f, 
    -0.03611746f, -0.06452382f, -0.07581920f, 0.09048411f, 0.07118716f, -0.14815143f, 0.09871688f, 0.09727340f, 
    0.08190195f, 0.13853079f, -0.00645097f, 0.03585205f, 0.08897945f, 0.10203201f, 0.28181389f, -0.21494862f, 
    -0.05299419f, 0.05405879f, 0.00626304f, -0.05240773f, 0.13920552f, 0.13321863f, 0.07449973f, -0.07522461f, 
    0.08719391f, 0.05216772f, -0.04775845f, 0.04324626f, 0.01478400f, 0.07627919f, -0.04870140f, 0.06555158f, 
    -0.18774720f, -0.26131508f, -0.31291384f, -0.05427614f, 0.23584945f, -0.00615746f, -0.02371670f, -0.06480934f, 
    -0.10181469f, -0.01646676f, 0.12817667f, 0.08736311f, -0.09028555f, 0.06098896f, 0.08698919f, 0.15641744f, 
    0.14202850f, 0.05125763f, -0.04328251f, -0.04322345f, 0.05434478f, 0.08251927f, 0.11798261f, 0.16490002f, 
    -0.10921439f, 0.08483391f, -0.02874877f, 0.02638235f, 0.03696395f, 0.02582534f, -0.00176548f, -0.01300055f, 
    -0.02873589f, 0.04905243f, -0.02392953f, 0.02009011f, 0.14432539f, 0.04759029f, -0.01085495f, 0.09612522f, 
    -0.22977890f, 0.20602265f, -0.16770500f, -0.08428214f, -0.03290214f, 0.12770037f, 0.15822339f, 0.10643246f, 
    -0.16782238f, 0.13095246f, 0.05511276f, -0.13291575f, 0.09542407f, 0.03222557f, -0.04161825f, 0.14878690f, 
    -0.00869884f, -0.06136418f, -0.07136829f, -0.04594655f, -0.11184166f, -0.07312296f, -0.07401351f, 0.13275170f, 
    0.05284848f, -0.03141887f, -0.10078196f, -0.01133632f, -0.12519172f, -0.03278684f, 0.08605298f, -0.07844607f, 
    -0.03181193f, 0.02862548f, -0.02548667f, 0.04785442f, 0.14403369f, 0.22162849f, 0.04275562f, 0.05433360f, 
    -0.00316919f, -0.04458780f, -0.23719463f, 0.09810856f, 0.06738820f, 0.10845228f, 0.11022730f, 0.15781164f, 
    -0.02538399f, 0.06821628f, -0.03712725f, 0.05541813f, -0.06995472f, -0.01231063f, -0.01893887f, -0.09069659f, 
    0.01235229f, 0.09738538f, 0.04911340f, 0.03055050f, 0.06478655f, 0.40060160f, 0.18223266f, 0.47677669f, 
    -0.04113312f, 0.06518462f, -0.06473812f, -0.14634413f, -0.18040632f, -0.09730982f, 0.13328049f, -0.10781772f, 
    0.01912049f, 0.01712353f, 0.16864289f, 0.21128373f, -0.00623194f, 0.05101437f, 0.04477129f, -0.04510602f, 
    -0.41992858f, 0.18192914f, 0.14097938f, 0.24415548f, -0.11175209f, 0.07309868f, -0.02204432f, 0.11237291f, 
    -0.02032452f, -0.01551291f, 0.02223521f, 0.00556926f, -0.01044791f, -0.14187780f, 0.13836749f, -0.09365649f, 
    0.12495170f, 0.06381320f, -0.14069600f, 0.13196389f, 0.50123674f, 0.15217005f, 0.08505323f, -0.07693461f, 
    -0.09805521f, 0.05394252f, -0.19193746f, -0.14202863f, -0.09672051f, 0.07205731f, 0.02489744f, 0.03697221f, 
    0.12749030f, 0.02594460f, 0.02505716f, 0.01082466f, 0.06885333f, 0.08200963f, 0.10850780f, 0.05531621f, 
    -0.12091196f, -0.16853262f, -0.15914465f, -0.03749759f, 0.08499596f, -0.02592354f, -0.07715946f, 0.03757408f, 
    -0.06402205f, 0.00335630f, 0.05515806f, 0.00801482f, -0.04746589f, -0.07645679f, 0.03062018f, 0.02444515f, 
    0.15004593f, 0.14397919f, 0.06381781f, 0.05736724f, 0.16044037f, -0.08256258f, 0.17375502f, -0.07556668f, 
    0.02774399f, -0.01060153f, -0.16257097f, -0.16187996f, -0.09863644f, -0.03722170f, 0.20435970f, 0.07194573f, 
    -0.06956386f, 0.05065467f, -0.03817078f, 0.08420108f, 0.09543188f, -0.07694585f, 0.05386362f, -0.01174763f, 
    -0.11887082f, 0.14617543f, 0.29982311f, 0.15159126f, -0.03982602f, 0.01565123f, -0.03898600f, -0.11649711f, 
    -0.07930797f, -0.01064198f, 0.04837285f, 0.03520292f, 0.18876795f, 0.16314822f, 0.00133616f, 0.09836172f, 
    0.05639214f, 0.04331860f, 0.04373731f, 0.07463597f, -0.73995626f, 0.19881974f, -0.22863477f, 0.17588025f, 
    -0.10950254f, -0.04009508f, 0.03623443f, -0.05904550f, -0.05727120f, 0.06672605f, 0.16422978f, 0.00841475f, 
    -0.08857404f, -0.17912082f, 0.03538233f, 0.12722726f, -0.00199893f, 0.07838205f, -0.03738872f, 0.12456346f, 
    0.19704632f, -0.07733525f, -0.29582369f, -0.15926309f, -0.06796063f, -0.10964540f, -0.01234627f, -0.00484870f, 
    -0.12633671f, 0.09438375f, 0.09511290f, -0.02248129f, 0.01159079f, 0.03801881f, -0.01656748f, 0.23894471f, 
    0.21170269f, 0.13826738f, 0.08577365f, 0.04639458f, -0.56033677f, 0.14222880f, 0.20300515f, 0.53424662f, 
    0.32156670f, -0.04550114f, 0.09057418f, -0.05316484f, -0.06602923f, -0.07665887f, 0.06761792f, -0.05063577f, 
    -0.01200442f, -0.06343138f, 0.00091276f, 0.00739007f, 0.10082202f, -0.00337469f, -0.14199869f, -0.05924273f, 
    0.26069728f, 0.01797938f, 0.22651854f, -0.21825191f, -0.17469679f, -0.00644645f, -0.17363471f, -0.28525981f, 
    -0.10453819f, 0.08007415f, 0.13161464f, 0.01146712f, 0.07866858f, 0.05568629f, -0.17543550f, 0.11113590f, 
    0.01853082f, -0.13525087f, 0.07339730f, 0.05752183f, 0.12161823f, 0.14842208f, 0.05678445f, 0.11969524f, 
    0.01016227f, 0.10187176f, 0.04063388f, -0.09175050f, -0.06135909f, 0.06865207f, -0.01950313f, -0.00617246f, 
    -0.02116123f, 0.02314739f, -0.02842047f, -0.06695231f, 0.05783107f, -0.13490143f, -0.08652816f, 0.06647488f, 
    -0.07555134f, 0.25507522f, 0.08124755f, 0.24327950f, 0.14313079f, 0.09768367f, 0.07375540f, 0.16766568f, 
    0.21941254f, 0.18164031f, -0.08302870f, -0.00595216f, -0.02954790f, 0.01137241f, -0.05063026f, 0.07588063f, 
    -0.08298212f, -0.09248842f, -0.10171312f, 0.07651340f, -0.55912757f, -0.16975057f, -0.33890471f, -0.32730106f, 
    -0.08487875f, -0.13458879f, -0.05283207f, -0.15315634f, -0.01373818f, -0.01730920f, -0.09147029f, -0.07883015f, 
    -0.01823706f, -0.12549213f, 0.17494184f, -0.07120480f, 0.23408566f, 0.05440274f, 0.08757157f, 0.12563191f, 
    0.34125021f, 0.38650033f, 0.42416814f, 0.29767144f, -0.18967611f, 0.15835014f, -0.13541976f, -0.19359934f, 
    -0.05662422f, 0.03171548f, -0.02548529f, -0.04107869f, 0.05968365f, 0.07850487f, -0.02173167f, 0.01203594f, 
    0.06811207f, 0.11293207f, -0.00931721f, 0.04736051f, -0.36394799f, 0.09648491f, 0.25930598f, 0.31338659f, 
    0.11254295f, 0.04475731f, -0.01080497f, -0.06910052f, 0.06830592f, 0.20730750f, 0.04341710f, 0.04327004f, 
    0.05179434f, 0.03899665f, 0.06842105f, 0.01774139f, 0.09686543f, -0.11503410f, -0.08564118f, 0.02065185f, 
    0.16848999f, 0.07109974f, -0.30421057f, -0.05963462f, 0.23645377f, 0.21668740f, 0.05209697f, 0.17986548f, 
    0.07655226f, 0.16075221f, 0.00787772f, -0.16624126f, 0.03210574f, 0.01325538f, -0.09846573f, 0.06088921f, 
    -0.12394960f, -0.07714893f, -0.01987191f, 0.03904819f, -0.51558268f, 0.18687777f, 0.28346223f, 0.56514859f, 
    0.14530675f, 0.14363018f, 0.03444461f, 0.05759491f, -0.03085805f, -0.06952723f, 0.02388492f, -0.07535833f, 
    -0.00637333f, 0.03523875f, 0.03285835f, 0.08816393f, 0.04161897f, -0.03847097f, -0.12319249f, 0.02063303f, 
    -0.28603131f, 0.16053519f, 0.11950390f, -0.15378456f, 0.07956430f, 0.02793338f, -0.32215452f, -0.28919366f, 
    0.00450854f, -0.13644288f, -0.04387160f, 0.03856100f, 0.02622468f, -0.01389684f, 0.01323427f, -0.06651030f, 
    -0.12790945f, -0.09855302f, -0.04154288f, 0.05528289f, 0.10536937f, 0.37553725f, 0.17969215f, 0.07158124f, 
    0.17958058f, 0.02081671f, 0.06563115f, 0.12849414f, 0.26181051f, 0.09400664f, -0.06059868f, 0.02015548f, 
    -0.07516685f, -0.12615407f, 0.01070131f, 0.02390619f, 0.07549448f, -0.05905032f, -0.16376713f, -0.08442962f, 
    -0.35772499f, 0.40054858f, -0.07124726f, 0.43695742f, -0.04674504f, -0.15747075f, 0.17546491f, -0.00436191f, 
    0.11682902f, 0.16560146f, -0.10748632f, 0.11527229f, 0.08403958f, -0.02993757f, -0.11313102f, 0.11752851f, 
    -0.07111532f, -0.16927283f, -0.05886628f, -0.21868153f, -0.32738525f, -0.12127774f, 0.12135665f, 0.17255588f, 
    0.14028609f, -0.06691173f, -0.11905986f, -0.14764987f, -0.02594108f, 0.00253069f, -0.01278489f, 0.01864096f, 
    0.01099744f, 0.01017784f, 0.04139138f, -0.00554695f, -0.14756021f, 0.03132747f, 0.17940539f, -0.07976014f, 
    0.01513178f, 0.02551621f, -0.04701308f, -0.03407863f, -0.06605175f, -0.07670501f, -0.09497071f, -0.16178308f, 
    -0.00652268f, -0.01654570f, -0.03661956f, 0.02967550f, 0.15717055f, 0.04217899f, -0.01556867f, -0.05260081f, 
    -0.01976913f, -0.11813173f, 0.17238821f, 0.03233245f, -0.25463229f, -0.05871843f, 0.05371213f, 0.07845251f, 
    0.00978534f, -0.01408182f, 0.04543585f, 0.09434981f, -0.12337663f, -0.01282556f, 0.01074011f, 0.07158554f, 
    0.02061577f, 0.17915317f, -0.05102342f, -0.12150955f, -0.06394882f, 0.25030151f, 0.10926162f, -0.00447445f, 
    0.01752174f, -0.18683180f, 0.31658795f, -0.08610630f, -0.19482258f, -0.02346442f, -0.02286995f, 0.03732540f, 
    0.02036979f, 0.03196077f, 0.02700263f, -0.03044693f, 0.01048187f, 0.15326495f, 0.06901342f, -0.04154153f, 
    -0.02885520f, 0.22020520f, 0.07248882f, -0.05901881f, 0.29068196f, -0.00889701f, 0.24872226f, -0.13907194f, 
    0.15400125f, 0.03371504f, -0.20806444f, 0.18464677f, 0.04278264f, -0.06370198f, 0.04164116f, -0.13035949f, 
    -0.03253580f, -0.04221477f, 0.03701100f, 0.01500075f, -0.07296959f, -0.11079102f, -0.01215608f, -0.11349534f, 
    0.78385472f, 0.41550571f, 0.00206856f, 0.45216596f, -0.23505673f, 0.01088126f, -0.06224036f, 0.07822577f, 
    -0.09873090f, 0.05256297f, 0.23439805f, 0.10582706f, -0.11146947f, 0.06660771f, -0.09233589f, 0.03690853f, 
    -0.02388472f, 0.10176174f, 0.08547541f, 0.09283023f, 0.03295774f, -0.14540546f, -0.20220016f, 0.00429048f, 
    0.10861330f, -0.05597029f, 0.25248888f, 0.12634045f, -0.03267759f, 0.14003457f, -0.00695988f, -0.10435145f, 
    -0.05506904f, 0.01793854f, 0.03654032f, -0.06698546f, 0.08456067f, -0.07453022f, 0.10733536f, 0.09803181f, 
    0.00327510f, -0.00507259f, 0.06139565f, -0.03373826f, -0.08853466f, -0.06638729f, -0.16827074f, 0.04416554f, 
    -0.01905109f, -0.00519046f, -0.02012146f, -0.09743027f, 0.11194530f, 0.09717463f, 0.07700881f, -0.05383107f, 
    0.01632162f, 0.05283333f, 0.07189191f, -0.04641685f, 0.10216354f, 0.14268878f, 0.02333036f, 0.17487749f, 
    -0.08466496f, -0.07114141f, 0.05063077f, -0.00571417f, -0.01566066f, -0.07404700f, 0.02335530f, -0.04432780f, 
    -0.02537947f, -0.09705888f, 0.01497290f, -0.18037079f, -0.19580917f, -0.16011021f, 0.06220714f, 0.00715033f, 
    -0.11997180f, -0.18402457f, 0.05772693f, 0.04816904f, 0.02108734f, 0.12202874f, 0.05957578f, 0.20218086f, 
    0.04305564f, 0.11922127f, -0.15522505f, 0.12162515f, 0.01276518f, 0.21859513f, 0.01464090f, -0.03926528f, 
    0.04108213f, 0.10252476f, 0.06189717f, 0.28387243f, -0.01347052f, -0.23380001f, -0.04550376f, 0.06089260f, 
    -0.12173567f, -0.05499373f, -0.02661451f, 0.02133026f, -0.00686317f, -0.04329574f, -0.05613211f, 0.10205998f, 
    0.11841226f, 0.05756357f, 0.12598199f, 0.12416513f, -0.17823669f, 0.01933429f, 0.09335981f, -0.07258118f, 
    0.03838753f, 0.16218302f, 0.06342667f, -0.14643788f, 0.17984562f, 0.16107546f, 0.13790044f, 0.01290606f, 
    0.11014044f, 0.21166296f, -0.06479241f, 0.07155335f, -0.00676195f, -0.07888369f, 0.03981778f, -0.01066646f, 
    -0.15164727f, -0.11796185f, -0.22474331f, -0.07040124f, 0.41584310f, 0.01526098f, 0.29035327f, -0.13546690f, 
    -0.04928742f, 0.14513728f, 0.00663965f, 0.11769126f, 0.00562012f, -0.01431697f, -0.13123071f, -0.06099561f, 
    -0.06164154f, 0.14214434f, -0.12836376f, -0.02524026f, -0.01649906f, 0.03884069f, 0.00569392f, -0.06225561f, 
    0.08982637f, 0.26973912f, 0.05103213f, -0.08125219f, 0.28059247f, 0.09230804f, 0.19472113f, 0.08282682f, 
    0.23073392f, -0.00458937f, -0.07952242f, 0.04640347f, -0.04565423f, -0.11884769f, -0.15050334f, 0.05353518f, 
    -0.05026601f, 0.10701283f, -0.28220251f, -0.11116881f, 0.31527787f, -0.09003922f, 0.06660953f, 0.20259693f, 
    -0.04127315f, 0.01348753f, 0.06952126f, 0.11510023f, 0.11262656f, -0.08201559f, 0.04666393f, -0.14609720f, 
    0.16390985f, -0.15478009f, 0.05539164f, -0.03320684f, 0.06203115f, 0.04415653f, 0.20076281f, 0.00241917f, 
    0.01980160f, -0.17673694f, -0.09784050f, 0.00769056f, -0.06407636f, -0.06955732f, -0.07573886f, -0.03313588f, 
    -0.04087259f, -0.05655977f, -0.07547553f, 0.04639435f, 0.11104236f, 0.02287979f, 0.12958473f, 0.09760094f, 
    -0.02354609f, -0.20885140f, 0.11137465f, 0.01881277f, 0.03881862f, -0.06687906f, -0.02954651f, 0.07691970f, 
    -0.02111715f, -0.05308928f, -0.04727847f, -0.01950191f, 0.00582919f, 0.02836367f, -0.08959147f, -0.10573751f, 
    -0.24575059f, -0.04858191f, -0.07291090f, -0.11415611f, 0.01773708f, -0.12643567f, 0.04922026f, -0.03843419f, 
    0.24918415f, -0.22429869f, -0.12135433f, 0.00805109f, 0.01406865f, 0.05403281f, 0.01586810f, 0.17953683f, 
    0.14044489f, -0.03963515f, -0.31782243f, 0.08382878f, -0.09598424f, 0.01489518f, -0.06289098f, -0.12798719f, 
    0.01093507f, 0.07855304f, 0.06389679f, 0.04109231f, 0.33437598f, 0.23643853f, 0.61223125f, -0.19799261f, 
    0.13184384f, -0.09764502f, 0.04960190f, 0.19239761f, 0.08789580f, -0.04692609f, 0.07981706f, 0.16843903f, 
    -0.04007350f, 0.05580713f, -0.06766915f, -0.02260561f, -0.03037204f, 0.25206259f, -0.01036932f, -0.18109912f, 
    -0.11319661f, 0.07471186f, 0.07705889f, 0.20168340f, -0.08005749f, -0.16623078f, 0.04630130f, -0.12491044f, 
    0.02654633f, -0.09506291f, -0.01547388f, -0.05948296f, 0.03958846f, 0.08905435f, 0.06243505f, 0.02540202f, 
    -0.11420194f, 0.01210937f, 0.23850259f, 0.15964310f, 0.00756733f, 0.13249101f, -0.06014571f, 0.14902557f, 
    0.45072308f, 0.08278181f, 0.14727639f, -0.02800321f, -0.01680686f, -0.05213714f, -0.13834926f, -0.03520136f, 
    0.01247927f, -0.10464296f, -0.05898496f, 0.05407667f, 0.11537090f, -0.01233459f, -0.22691920f, 0.05391051f, 
    -0.02244462f, -0.13947114f, -0.10019845f, 0.07226834f, -0.00789030f, -0.05461119f, -0.02933965f, 0.11141017f, 
    0.11643463f, 0.05670510f, 0.05959066f, -0.02507873f, -0.10854221f, -0.04555089f, 0.06504147f, -0.11654635f, 
    -0.01389429f, -0.06282825f, 0.18437922f, 0.09978764f, 0.10818613f, 0.24475755f, -0.08645825f, 0.24092495f, 
    0.06905687f, 0.03682187f, -0.02450203f, 0.10002209f, -0.12226724f, 0.09764260f, 0.01078401f, -0.05912676f, 
    0.00666485f, -0.18343656f, -0.08350587f, -0.03743600f, -0.17509691f, -0.12203974f, 0.03243600f, -0.04761834f, 
    0.06507035f, 0.13699742f, -0.01071739f, 0.24334361f, 0.39135486f, 0.28737688f, 0.17065918f, -0.08280711f, 
    0.17097057f, 0.14636721f, 0.11365435f, 0.05846567f, 0.00568713f, 0.07114025f, 0.02326489f, -0.04418742f, 
    0.03298230f, 0.02394826f, -0.09035219f, 0.18400349f, -0.09323232f, -0.08282232f, 0.19665563f, 0.03156050f, 
    0.02229460f, 0.00232686f, -0.10363372f, -0.01116640f, 0.05608825f, 0.00857335f, 0.08875379f, 0.02992460f, 
    0.02809918f, 0.05662303f, -0.07644758f, -0.00353835f, 0.07788729f, 0.33279154f, -0.00529312f, -0.06032602f, 
    0.32780418f, -0.01474175f, 0.05529440f, -0.00776510f, 0.05281867f, 0.16040240f, 0.14612909f, 0.22271398f, 
    -0.11307343f, -0.09325442f, -0.15813234f, -0.16308472f, -0.00239603f, -0.22555062f, -0.02161269f, 0.01061140f, 
    0.04680432f, -0.05352001f, -0.01981759f, 0.00962867f, -0.02695722f, 0.24505520f, -0.11613006f, -0.00579691f, 
    0.08522998f, 0.11831065f, 0.12377630f, 0.03913414f, 0.03932710f, 0.22958291f, -0.04470870f, 0.02261794f, 
    -0.00300529f, -0.29847792f, -0.15842384f, -0.02832041f, -0.09941684f, 0.19811781f, -0.19722886f, -0.10173473f, 
    -0.14284328f, 0.10994135f, 0.24909081f, 0.03066282f, -0.09337578f, -0.12414524f, -0.00189281f, -0.28536570f, 
    -0.06816810f, 0.14757110f, -0.04289455f, 0.01594470f, 0.17370941f, 0.08923394f, -0.09562145f, -0.03400228f, 
    0.16713755f, -0.02989062f, 0.07208121f, 0.10841274f, 0.25210068f, 0.26624289f, -0.07805567f, -0.14658903f, 
    0.52760994f, -0.00537232f, 0.22000034f, 0.02721721f, 0.15567428f, -0.02977353f, -0.09287231f, -0.00126234f, 
    -0.04657254f, 0.00400310f, -0.02900223f, 0.00871160f, 0.00082758f, 0.06849647f, -0.12135141f, 0.11051519f, 
    0.01134497f, 0.02012083f, -0.04437760f, 0.01639171f, -0.02756014f, -0.02421541f, -0.00058194f, 0.00801493f, 
    0.02712402f, -0.02440456f, -0.01330827f, 0.02470081f, 0.03322538f, -0.02422662f, -0.02422718f, 0.00594798f, 
    -0.03566094f, 0.01358426f, -0.00107632f, -0.00906969f, 0.01599246f, 0.03870638f, 0.01140708f, -0.01830493f, 
    0.02689912f, -0.00762815f, -0.01070753f, -0.01288986f, -0.02028286f, -0.03464530f, 0.01556671f, 0.01498272f, 
    -0.04155573f, 0.02831117f, 0.02493808f, 0.02080091f, -0.00516766f, 0.00213600f, -0.00327654f, 0.02510443f, 
    0.01849263f, -0.01982113f, 0.03234390f, -0.01308127f, 0.02747783f, -0.00103074f, 0.02789709f, 0.01678849f, 
    -0.00914472f, -0.02956426f, -0.03114509f, -0.02894796f, -0.02331089f, -0.02592264f, -0.01029559f, 0.01187778f, 
    0.02084948f, 0.02402297f, -0.01460468f, -0.01371863f, -0.04145272f, 0.00769077f, -0.00905641f, 0.01228089f, 
    0.03322836f, 0.01761155f, 0.01685941f, -0.01383231f, -0.04343033f, -0.01897296f, -0.00194589f, -0.00360403f, 
    -0.02461964f, -0.01638997f, -0.00172179f, -0.04336082f, 0.02639968f, -0.01191904f, 0.02519788f, -0.02224789f, 
    -0.04034473f, 0.00204541f, -0.00438712f, 0.02720727f, 0.00866528f, -0.03946633f, -0.02435157f, -0.00315535f, 
    0.02742332f, 0.00671369f, -0.00479778f, -0.04284923f, 0.02029353f, -0.01606007f, 0.01262960f, -0.02656709f, 
    -0.00224787f, -0.03009062f, 0.02599638f, 0.00079146f, -0.03453087f, 0.01890453f, 0.02186674f, 0.01909798f, 
    0.01574231f, 0.00555285f, 0.02157175f, -0.03525627f, 0.00027968f, 0.00007438f, -0.03583638f, 0.03341345f, 
    -0.02198783f, -0.02586542f, 0.02256854f, 0.02168795f, 0.01056108f, 0.01886499f, -0.03363388f, 0.01729653f, 
    -0.02797189f, 0.01800550f, -0.00859499f, 0.01625475f, 0.02757709f, -0.03248632f, 0.03288385f, -0.00538358f, 
    0.00696762f, -0.02115142f, 0.03183606f, 0.02609350f, 0.02884446f, 0.02195148f, -0.01031629f, 0.01465182f, 
    -0.02505316f, 0.00499465f, 0.01273553f, 0.02566774f, 0.01182769f, 0.02767554f, 0.02300976f, -0.01378455f, 
    -0.01780378f, -0.01025152f, -0.02397241f, 0.02736389f, 0.00539633f, 0.03004541f, -0.00945685f, -0.04221754f, 
    0.00339701f, -0.04143015f, -0.02834307f, 0.03191885f, 0.01390372f, 0.02021749f, -0.03959828f, -0.03368458f, 
    0.02358899f, -0.03390390f, -0.02725707f, -0.02702496f, -0.01779923f, 0.02232725f, 0.01908119f, -0.04053515f, 
    0.02692976f, -0.01085111f, 0.03235828f, 0.01101284f, -0.03904950f, 0.03241281f, -0.02354980f, 0.02807548f, 
    -0.00447920f, 0.00013683f, -0.01287327f, 0.02207261f, -0.00111933f, -0.00285172f, 0.00277323f, -0.00704163f, 
    -0.00476578f, -0.04070665f, 0.01562576f, -0.00561060f, -0.00999202f, -0.02702923f, -0.04479420f, -0.04307543f, 
    0.02370513f, -0.04461180f, -0.01085042f, 0.00091306f, 0.01383507f, -0.01252666f, -0.02833442f, -0.00197518f, 
    -0.04454430f, -0.04319920f, -0.02509282f, -0.00752160f, -0.00126327f, -0.02665275f, -0.01838285f, 0.00498519f, 
    -0.03246741f, -0.03895856f, -0.03243599f, 0.01895737f, -0.00591012f, -0.01789217f, -0.01906787f, -0.04084859f, 
    0.03167595f, 0.03854758f, 0.00203777f, 0.02109507f, -0.03340989f, -0.00966171f, -0.01210170f, -0.00909243f, 
    0.00060558f, -0.00578223f, -0.04441062f, 0.00679595f, 0.01333816f, -0.03133450f, -0.01619626f, 0.02951271f, 
    0.02237959f, 0.00323255f, -0.00687757f, 0.02213799f, -0.03178034f, -0.04269474f, -0.02368007f, -0.00755141f, 
    0.02311328f, -0.01488076f, -0.01564771f, 0.02610313f, 0.00547353f, 0.01353840f, 0.03016294f, -0.04076286f, 
    0.03246992f, -0.02705137f, -0.01116944f, 0.00030702f, -0.02925872f, 0.00016138f, -0.01056272f, -0.01331488f, 
    -0.01811869f, -0.00886242f, -0.03075257f, -0.00893640f, -0.00646668f, 0.02924498f, -0.04379988f, -0.00016290f, 
    -0.03360164f, 0.01243714f, -0.04111867f, 0.00015456f, 0.00766620f, -0.01719531f, -0.02038121f, -0.01334927f, 
    0.00362248f, 0.03177013f, -0.00162403f, -0.00212452f, -0.00193776f, -0.02232299f, 0.01261061f, -0.03137177f, 
    -0.03171885f, -0.01511960f, 0.00823091f, -0.01646452f, -0.01439943f, -0.04461584f, -0.03926873f, -0.04152875f, 
    -0.01303761f, 0.01332155f, -0.00964805f, 0.01072488f, 0.01449193f, 0.02994857f, 0.01283424f, -0.03361073f, 
    0.02579364f, 0.02893058f, -0.03993413f, -0.02918639f, 0.01056563f, 0.02244221f, -0.02121221f, 0.01897051f, 
    -0.02775184f, 0.01572988f, -0.03580090f, -0.03193080f, 0.00642241f, 0.01546383f, -0.03932558f, -0.01725974f, 
    -0.02676972f, -0.04436363f, -0.03462231f, -0.01199220f, 0.01604946f, 0.01147660f, 0.02722325f, -0.04548544f, 
    0.01687012f, -0.02892512f, -0.00130158f, -0.00192496f, -0.00707878f, 0.02566127f, -0.03992919f, 0.00874426f, 
    -0.00803453f, -0.04415987f, -0.00700827f, 0.00683040f, -0.01997367f, 0.00632931f, -0.04397406f, 0.03279500f, 
    0.00138295f, -0.02014791f, -0.02508818f, -0.04081351f, 0.00936921f, -0.01577803f, 0.00788892f, -0.01507994f, 
    -0.00926657f, 0.02216034f, -0.04053985f, 0.02015813f, 0.00254088f, -0.04373996f, -0.02118682f, -0.00054958f, 
    -0.02514329f, -0.00529702f, -0.01475326f, 0.01414402f, -0.03245778f, 0.00339943f, -0.02628788f, 0.02240622f, 
    0.02478826f, 0.02334364f, -0.01903349f, 0.01518837f, 0.02472603f, -0.00081963f, -0.02021802f, -0.03981335f, 
    0.01207411f, -0.04084117f, 0.01918022f, -0.02446037f, -0.01856356f, 0.02443166f, 0.02346430f, -0.02479759f, 
    -0.01218398f, -0.01804016f, 0.02788589f, -0.03168358f, 0.01115177f, 0.02362056f, 0.02922169f, 0.02106827f, 
    0.03283853f, -0.03566371f, -0.00590626f, -0.02799848f, 0.02122838f, 0.01481228f, -0.01160158f, -0.00427684f, 
    -0.04344779f, 0.00907254f, -0.02802550f, -0.04402183f, 0.01484364f, -0.00189300f, -0.00893506f, -0.01584833f, 
    -0.01757527f, 0.01868908f, 0.02318572f, -0.02258919f, 0.00079462f, 0.01842411f, 0.01714700f, 0.03203790f, 
    -0.01559488f, -0.03549659f, -0.02321425f, -0.00788627f, -0.04433086f, 0.00310799f, 0.00585321f, -0.01809662f, 
    -0.04066781f, -0.02724023f, -0.04322715f, 0.02129539f, 0.02688251f, -0.00982143f, 0.00608836f, -0.00779557f, 
    -0.03033968f, 0.01689485f, -0.01051523f, -0.01282178f, 0.02440383f, -0.01045337f, 0.01223498f, 0.02443911f, 
    -0.03029942f, 0.02553166f, -0.04366995f, -0.02949674f, -0.00151658f, -0.02043016f, 0.01055269f, -0.01171646f, 
    0.01478043f, -0.03866348f, 0.00723302f, 0.00331949f, 0.01295892f, -0.04292144f, -0.02581598f, 0.01440892f, 
    -0.00196428f, 0.00132119f, -0.01482338f, -0.00582910f, -0.00313346f, -0.04557043f, 0.01122493f, -0.00478120f, 
    0.00589272f, -0.00045742f, 0.03105964f, -0.01477252f, -0.00211444f, -0.01914390f, -0.04244728f, 0.02870476f, 
    0.03390549f, -0.00842768f, -0.01159901f, -0.01417780f, 0.00617604f, -0.03217704f, -0.00443512f, 0.01633898f, 
    -0.02880707f, 0.01661449f, 0.01817809f, 0.01433888f, 0.02938189f, 0.03139134f, -0.04393761f, 0.03073745f, 
    -0.03398005f, 0.02324416f, -0.02436678f, -0.03294330f, -0.01302627f, -0.04504708f, -0.02341160f, -0.02481931f, 
    -0.04351751f, -0.00125168f, 0.02496946f, 0.00824811f, -0.03794874f, -0.00189399f, -0.02740810f, -0.00953048f, 
    -0.02188485f, -0.01912173f, 0.01069114f, -0.01926444f, 0.00312633f, 0.02538372f, -0.00180898f, -0.04128413f, 
    -0.03570088f, 0.03158985f, -0.00543850f, 0.02278120f, 0.00517116f, 0.00897083f, -0.03972760f, 0.02421477f, 
    -0.03515033f, 0.02503150f, -0.01247464f, 0.02368151f, -0.00654892f, -0.02166346f, -0.02766198f, 0.00056593f, 
    -0.00507158f, 0.00264685f, 0.02047122f, 0.00788214f, -0.00400493f, -0.01830438f, -0.01921028f, -0.03962956f, 
    0.00845075f, -0.00836436f, 0.01627264f, 0.02214251f, -0.01024552f, -0.01816104f, 0.02358286f, -0.02858127f, 
    -0.04344133f, -0.02777347f, -0.01566135f, -0.03545897f, 0.01789428f, 0.03136269f, 0.02315529f, -0.03901299f, 
    -0.00499370f, 0.00756643f, -0.02334477f, 0.03085318f, -0.01118270f, -0.00773145f, 0.01238935f, -0.00975962f, 
    -0.00877756f, -0.04324962f, -0.02336031f, 0.01683465f, -0.00299915f, 0.02322063f, 0.00334795f, -0.02449987f, 
    -0.03176477f, 0.02513670f, 0.00342030f, -0.02667378f, -0.01021683f, -0.03359567f, 0.00838058f, 0.01695071f, 
    0.01510325f, -0.02500332f, 0.01761944f, -0.01883817f, -0.03168824f, -0.04363067f, -0.01955425f, 0.01698278f, 
    -0.04131350f, 0.03037268f, -0.04542028f, -0.03278279f, 0.00781005f, -0.00586464f, 0.00660046f, 0.00882662f, 
    -0.01411443f, 0.00153273f, -0.03840620f, 0.01090094f, -0.01441007f, -0.00851387f, -0.02816483f, -0.04467715f, 
    -0.03538667f, -0.01910986f, -0.02373870f, -0.04355851f, 0.02815084f, -0.03494069f, -0.00393240f, -0.02448538f, 
    -0.02616379f, -0.02402076f, -0.01473171f, -0.01340649f, -0.02436620f, 0.01924700f, 0.01624997f, -0.02138675f, 
    0.00757498f, -0.03507655f, -0.04481091f, -0.00354895f, 0.02312639f, -0.02898033f, -0.01954229f, 0.00424209f, 
    0.02850286f, -0.01812529f, 0.02967797f, -0.01771958f, 0.00354692f, 0.02248848f, -0.02813293f, 0.01822198f, 
    0.04029845f, 0.02255090f, -0.02597848f, 0.00323703f, -0.00226199f, -0.04149951f, 0.00598107f, -0.03180324f, 
    -0.03850213f, -0.02328674f, 0.00007086f, -0.04010087f, -0.03949265f, -0.00265668f, -0.01928198f, -0.01358857f, 
    -0.07442109f, 0.08287024f, 0.03699460f, 0.01019209f, 0.12129494f, 0.15225044f, 0.09851520f, -0.14014111f, 
    0.05269769f, -0.08242691f, -0.03145928f, 0.03677321f, 0.02396991f, -0.11017073f, -0.08159980f, -0.04161157f, 
    0.17629325f, 0.06854316f, 0.15355398f, 0.00057912f, -0.24602355f, -0.36002693f, 0.18857685f, 0.16300923f, 
    0.11194857f, -0.04351427f, -0.03659936f, -0.02738857f, -0.00999997f, -0.06922351f, 0.06421069f, -0.04268966f, 
    -0.18051620f, 0.11684072f, -0.01270154f, 0.07213871f, 0.14327522f, 0.16453420f, -0.03110367f, -0.01991357f, 
    0.20459895f, -0.03528280f, 0.17259490f, 0.03628542f, 0.02956270f, 0.07493220f, 0.30432069f, -0.04487581f, 
    -0.08973343f, 0.08018230f, 0.10064378f, -0.08812695f, 0.08691876f, 0.11047711f, -0.08950153f, -0.11149195f, 
    0.15555431f, 0.07392969f, -0.01008009f, 0.17916763f, -0.31121600f, 0.32077622f, 0.05784786f, -0.08613299f, 
    0.03374246f, 0.06851114f, -0.04505417f, -0.15246367f, -0.02027183f, -0.07151488f, 0.02930967f, -0.08616858f, 
    0.02148039f, -0.12103495f, -0.01598693f, 0.00031424f, 0.05788984f, 0.10445704f, 0.07931457f, 0.07910939f, 
    -0.86622590f, -0.41549367f, 0.03794086f, -0.21293527f, 0.24736343f, -0.17535208f, -0.07277570f, -0.15049802f, 
    -0.09963814f, -0.05804108f, -0.06067031f, -0.20401001f, -0.22030829f, -0.03472062f, 0.19107383f, -0.00396318f, 
    0.02296490f, -0.00993531f, -0.19650237f, -0.06172655f, 0.37146488f, -0.00387405f, 0.21338417f, -0.29368347f, 
    -0.11283120f, -0.20932207f, -0.11241306f, -0.10020483f, -0.15296006f, -0.17235795f, 0.12235238f, -0.14042380f, 
    0.22082113f, -0.13874339f, -0.03271421f, 0.02714234f, -0.03699339f, -0.09711391f, -0.18851514f, -0.00261364f, 
    -0.13581993f, -0.13493721f, -0.27287948f, 0.04703055f, 0.01309098f, 0.14598842f, -0.05553622f, -0.07585130f, 
    -0.07649637f, 0.14617988f, 0.21644396f, -0.04387148f, 0.03350557f, -0.00105314f, 0.03282595f, -0.02528640f, 
    -0.10289968f, 0.01560005f, -0.06318107f, -0.04162740f, -0.14217226f, -0.25991073f, 0.32046607f, -0.01814153f, 
    0.27867845f, -0.11671941f, -0.14648651f, 0.12327430f, -0.07939467f, 0.13449670f, 0.10585531f, 0.07834389f, 
    -0.06385051f, -0.03135765f, 0.06361780f, 0.06272128f, 0.06066339f, 0.04018573f, -0.05187692f, 0.12251368f, 
    -0.48999894f, 0.22524446f, 0.32073334f, -0.33567908f, 0.02324610f, -0.03522516f, 0.01259604f, -0.21072286f, 
    -0.07124872f, 0.15483862f, 0.14359674f, -0.03027955f, 0.04849052f, 0.14574768f, 0.06064629f, 0.08145455f, 
    0.16112560f, -0.01073133f, 0.18446903f, -0.09201792f, 0.31590384f, -0.02494893f, 0.13239622f, 0.15733983f, 
    0.13546380f, 0.11796184f, -0.05800353f, 0.27251706f, 0.17349648f, -0.04637527f, 0.09814030f, 0.12564152f, 
    0.03207434f, -0.07541017f, 0.04955408f, 0.08928087f, -0.07851003f, -0.02458992f, 0.04907729f, -0.22423109f, 
    -0.27750123f, -0.22077793f, 0.00151724f, -0.09439515f, 0.07654431f, 0.53566504f, -0.23467980f, -0.06697281f, 
    -0.18623039f, 0.00174259f, 0.07022947f, -0.12147179f, 0.03911902f, 0.07455838f, 0.10658236f, -0.02599354f, 
    0.14405915f, -0.23498286f, -0.18148470f, -0.13127248f, -0.21264122f, -0.13294168f, 0.11618180f, 0.07347398f, 
    0.15979344f, 0.04095869f, -0.05664968f, -0.08106761f, 0.04461948f, -0.02259398f, 0.03862634f, -0.00108660f, 
    0.03843582f, 0.07272664f, -0.03156266f, 0.13882883f, 0.22234988f, 0.09894838f, 0.11688291f, 0.06309648f, 
    0.35307676f, -0.01281238f, -0.26538453f, -0.18314326f, -0.06203441f, 0.22849126f, -0.18533541f, -0.04889653f, 
    0.04981655f, -0.15326242f, 0.13745461f, 0.07668514f, 0.13020258f, -0.04668247f, -0.11620790f, 0.02618149f, 
    -0.21761863f, -0.28256708f, -0.03640787f, -0.07125316f, 0.05796574f, 0.26498088f, -0.10302617f, -0.31092784f, 
    -0.28897551f, -0.12296248f, -0.25550538f, -0.28020963f, -0.02780820f, 0.39613754f, -0.04892390f, -0.02956211f, 
    0.05365444f, -0.01919476f, 0.10201158f, -0.06858616f, 0.11106452f, -0.05518357f, -0.00162052f, 0.21629442f, 
    0.03941156f, -0.10573812f, 0.17457362f, 0.08408175f, -0.08078679f, 0.06294021f, 0.07479575f, 0.01723922f, 
    0.15184517f, -0.11495035f, -0.00589926f, 0.04933989f, -0.09081198f, -0.06100678f, -0.04795490f, 0.09642615f, 
    0.28241694f, 0.08393545f, 0.12562053f, 0.24358600f, 0.20698215f, -0.15101044f, -0.03971810f, -0.20371523f, 
    0.07730774f, -0.13542163f, -0.17039055f, 0.12512183f, -0.05454996f, 0.26966622f, -0.05506226f, 0.03628912f, 
    0.08728050f, -0.03543536f, 0.04912942f, -0.16385415f, 0.00947520f, -0.04155926f, -0.13100614f, 0.14518617f, 
    0.03945418f, -0.09460907f, -0.19694953f, 0.04247061f, 0.08165168f, -0.05377828f, 0.11382969f, 0.04846197f, 
    0.01420817f, 0.10223185f, 0.01879244f, -0.10077550f, -0.00290558f, 0.07828885f, 0.03446596f, 0.02751939f, 
    0.15761925f, 0.02598050f, 0.04760066f, 0.12963308f, -0.22349998f, 0.14982601f, 0.29468173f, -0.13242720f, 
    0.14721073f, -0.18759339f, -0.05109403f, 0.04246208f, -0.06179144f, 0.10860807f, 0.10204931f, 0.15325402f, 
    0.01141074f, 0.04362602f, 0.00014541f, -0.17367722f, -0.07131451f, 0.06141065f, 0.02474845f, -0.08063224f, 
    -0.11432101f, 0.11836955f, 0.10917399f, -0.09600203f, -0.18724079f, -0.17509274f, -0.24351521f, -0.20320332f, 
    -0.05907198f, 0.27705953f, -0.03565437f, -0.06228334f, -0.01429128f, -0.00417527f, 0.13923047f, -0.07951394f, 
    0.05291452f, 0.02467076f, 0.03768718f, 0.05008710f, 0.16754730f, -0.06911927f, -0.06847336f, -0.17785926f, 
    -0.36190224f, 0.00007801f, -0.16743258f, 0.16033058f, 0.12388740f, 0.15571204f, 0.01035237f, 0.00669627f, 
    0.13364480f, -0.08158179f, 0.08055162f, -0.04301633f, -0.06008277f, -0.03140168f, 0.01529906f, 0.02098074f, 
    0.12542869f, 0.42672074f, 0.25523037f, 0.19112164f, 0.21614991f, -0.14438386f, -0.25148693f, -0.02287656f, 
    0.18800259f, 0.12451274f, 0.12659150f, -0.09709136f, -0.00735268f, -0.00356913f, 0.03806296f, 0.01409753f, 
    0.00463223f, -0.15401186f, -0.11863380f, -0.03104149f, 0.44957981f, -0.16813359f, -0.24389526f, 0.06577030f, 
    -0.03009617f, 0.04323479f, 0.08653468f, 0.15703461f, -0.11006607f, 0.28627038f, 0.00980240f, -0.10331218f, 
    -0.02746700f, 0.01247506f, -0.01769769f, -0.10597289f, -0.11776892f, -0.04324494f, 0.08472478f, 0.02239213f, 
    -0.14299460f, -0.09841588f, 0.00094870f, -0.15988134f, -0.07041407f, 0.35791117f, -0.12535913f, -0.11957654f, 
    -0.06395398f, -0.07297936f, 0.10277156f, -0.11477917f, 0.00493772f, 0.04288637f, -0.04099653f, -0.11361516f, 
    0.04209488f, -0.18013351f, -0.02887769f, -0.07971149f, 0.15505661f, -0.02836018f, 0.00288702f, 0.22148387f, 
    0.05757449f, 0.04551651f, -0.06399663f, 0.09510790f, 0.10928514f, -0.03492847f, 0.06023527f, -0.04669920f, 
    -0.12524059f, 0.10991545f, 0.05001860f, 0.04716141f, -0.04370021f, -0.05798928f, 0.04712058f, 0.02091526f, 
    -0.45080620f, 0.78799152f, -0.10118877f, -0.26228258f, 0.06237980f, -0.08314326f, 0.02382915f, 0.14896442f, 
    -0.02915928f, -0.03961068f, 0.01420289f, -0.02202985f, 0.02007411f, 0.07272974f, -0.03864014f, 0.05996089f, 
    -0.11266073f, -0.09379097f, -0.30707669f, -0.15568522f, -0.19625384f, -0.03051423f, 0.22386685f, 0.02028868f, 
    0.08776098f, 0.00544261f, 0.03598158f, -0.16078307f, 0.09511514f, -0.05796579f, -0.02445956f, -0.03206699f, 
    0.12143246f, 0.17670387f, -0.05050655f, 0.00214441f, 0.20453210f, -0.03975775f, 0.11385699f, 0.10959155f, 
    0.08473095f, -0.11532334f, 0.07214362f, -0.05801785f, -0.06073448f, 0.10984227f, 0.13173650f, -0.05134477f, 
    -0.04495021f, 0.08730383f, 0.03139314f, 0.04030187f, -0.01681092f, -0.05199265f, 0.05945989f, -0.13374540f, 
    -0.18072064f, -0.02073190f, -0.10165424f, -0.03685691f, 0.02220669f, 0.27670389f, -0.29316261f, -0.20833549f, 
    0.09458489f, -0.30596682f, -0.00802480f, -0.05282956f, -0.29977259f, 0.25873178f, -0.10484018f, 0.05088941f, 
    0.01500377f, -0.07079227f, 0.06643865f, -0.23186904f, 0.00725203f, 0.06620847f, 0.02829031f, 0.07703070f, 
    0.02788669f, 0.26061988f, 0.36275992f, 0.00739820f, 0.56474495f, -0.21498287f, 0.03373301f, 0.16652979f, 
    0.05207140f, 0.15962581f, 0.05653920f, -0.03021715f, -0.07803069f, -0.02357361f, 0.03776325f, -0.04341926f, 
    0.02628114f, -0.02695837f, 0.08824679f, -0.07444760f, -0.04977855f, -0.15473244f, 0.07971700f, 0.03624410f, 
    0.06471927f, -0.01400922f, 0.21053413f, -0.09454620f, -0.03149036f, 0.01397782f, -0.02196034f, -0.11266071f, 
    -0.03866768f, 0.22881263f, 0.15172763f, 0.06353107f, 0.16627011f, -0.08067785f, 0.04540415f, 0.10660408f, 
    -0.18658721f, -0.06675183f, 0.14752764f, -0.09686705f, 0.27752960f, 0.09790961f, 0.02107310f, 0.05968940f, 
    0.12305079f, -0.03769864f, 0.01669523f, -0.00375064f, -0.11068112f, -0.01609216f, 0.08030398f, 0.12761603f, 
    -0.07491811f, 0.12529874f, 0.00740111f, -0.00464158f, 0.26218390f, 0.19960251f, 0.03551208f, 0.12783122f, 
    -0.02325668f, -0.02729688f, 0.03281356f, -0.03463396f, 0.11222930f, 0.03711727f, -0.06886126f, -0.03140281f, 
    -0.04973748f, -0.09645119f, -0.00109018f, 0.02992259f, 0.16092275f, -0.00018419f, 0.04953456f, 0.09100500f, 
    0.05126752f, 0.03128898f, 0.43269166f, 0.05639847f, -0.22434099f, 0.19175145f, -0.11191393f, -0.12383123f, 
    0.11409289f, -0.05613760f, -0.00367165f, 0.04438177f, 0.00446365f, -0.03044651f, 0.05661285f, -0.12479027f, 
    0.03672161f, 0.26803330f, -0.13666531f, -0.11502719f, -0.24614686f, 0.12184696f, 0.13516432f, 0.04939833f, 
    -0.03430997f, 0.19594505f, -0.07292594f, -0.01685681f, 0.05280775f, -0.05441712f, 0.07452513f, -0.05666258f, 
    0.06867388f, 0.14278039f, 0.15348557f, 0.02296226f, -0.16517860f, -0.04669252f, 0.00135210f, -0.02369508f, 
    0.24351075f, 0.05292561f, -0.15109587f, 0.47939652f, -0.01552909f, 0.11318639f, -0.08209936f, -0.18429428f, 
    -0.14700386f, 0.22052604f, 0.13591839f, 0.06742354f, 0.08998694f, 0.07187523f, 0.01782923f, -0.04965649f, 
    -0.08278439f, -0.02494135f, 0.00439901f, 0.00040137f, -0.06701918f, -0.19117932f, 0.24781686f, -0.14626619f, 
    -0.08742253f, -0.01253808f, -0.05211042f, -0.09888133f, -0.10319620f, -0.07812763f, -0.03657588f, -0.01385422f, 
    -0.00500360f, 0.05177286f, -0.07076497f, -0.11582400f, -0.03128599f, 0.22185093f, -0.04805932f, -0.24692073f, 
    -0.05405489f, -0.10920697f, 0.19179155f, -0.02291251f, -0.17952660f, -0.10452798f, -0.03484327f, -0.10157862f, 
    -0.10652913f, -0.08060949f, -0.11826586f, -0.16394192f, -0.08827385f, -0.07272069f, -0.13646699f, -0.04546313f, 
    0.02726606f, 0.00449677f, -0.10866811f, -0.09223311f, 0.24927790f, -0.41878349f, 0.32001504f, -0.00289034f, 
    -0.00171905f, -0.09403723f, 0.05770791f, -0.33506238f, -0.19670564f, 0.01478213f, -0.25653771f, 0.01121593f, 
    -0.13456652f, -0.02542570f, -0.13825604f, 0.07501823f, -0.00636516f, -0.04000672f, 0.14621788f, 0.01116103f, 
    0.18527636f, 0.20823698f, -0.00166107f, 0.03372113f, 0.04924230f, 0.20056398f, -0.16226166f, -0.24922426f, 
    0.03995506f, 0.03720443f, -0.06077885f, 0.01205652f, -0.05988146f, 0.06207858f, -0.04219921f, 0.07740228f, 
    0.00033355f, 0.28270689f, 0.14431673f, 0.02682583f, -0.37324843f, 0.41296244f, 0.01336257f, 0.08531373f, 
    0.01065463f, -0.00440323f, 0.00553454f, -0.10500795f, -0.10296678f, -0.18236671f, 0.16999078f, -0.13036054f, 
    0.07963095f, 0.09742396f, 0.17496361f, 0.01844924f, -0.16779397f, -0.04768363f, -0.01290358f, -0.19015166f, 
    0.19107386f, 0.16046724f, 0.38916391f, 0.06769542f, 0.27782130f, -0.13138925f, -0.01803854f, -0.14665852f, 
    -0.06915241f, -0.07347867f, 0.06011930f, -0.00587684f, 0.23492169f, -0.01254523f, 0.08801062f, 0.00025387f, 
    -0.10930207f, -0.01591114f, 0.21900538f, -0.21080999f, 0.03028537f, -0.28091007f, -0.24273662f, 0.00030811f, 
    -0.00587404f, -0.03521724f, 0.17888312f, 0.01143041f, 0.25151548f, 0.11229122f, 0.09066141f, -0.18242601f, 
    0.04170258f, 0.08302861f, -0.07516903f, 0.08574299f, 0.12905501f, -0.02189594f, 0.23351687f, 0.11640544f, 
    -0.14274155f, 0.11666838f, -0.00245676f, -0.06966490f, -0.07855517f, -0.10676095f, -0.09504073f, -0.21454164f, 
    -0.06029909f, -0.12524357f, -0.03107454f, -0.11721651f, -0.03267876f, -0.00582865f, -0.02344206f, -0.13417122f, 
    -0.02274955f, 0.06639230f, -0.04441557f, -0.07384372f, 0.11756530f, 0.11638665f, 0.09447598f, 0.02072095f, 
    0.09676204f, 0.09219962f, -0.14433648f, 0.05136118f, -0.01422696f, -0.04212157f, 0.01921360f, -0.01496361f, 
    0.07320525f, 0.05283464f, 0.09649083f, 0.07264660f, -0.14725685f, -0.07445563f, 0.05931779f, -0.27432480f, 
    -0.08659595f, -0.15373948f, 0.05965162f, -0.15956782f, -0.00106861f, -0.16500129f, -0.09208243f, -0.11090395f, 
    0.02846431f, -0.02369927f, -0.00803141f, -0.01959801f, -0.12923019f, -0.05444510f, -0.07684449f, 0.14656092f, 
    0.09189135f, 0.09363336f, 0.17469639f, 0.49979660f, -0.16233560f, -0.10238815f, 0.02690193f, 0.02659392f, 
    -0.00348739f, -0.03723430f, -0.03790052f, -0.07600875f, -0.08406112f, -0.16521734f, -0.25648502f, -0.14761858f, 
    -0.03331590f, 0.02024590f, -0.04946076f, 0.09420903f, 0.09877791f, -0.01821051f, -0.09806806f, -0.21203031f, 
    -0.10267216f, -0.06903145f, 0.38857049f, -0.07342435f, 0.06656839f, -0.05113075f, -0.09223586f, -0.02258277f, 
    0.08670165f, -0.03312299f, 0.07394806f, 0.14001180f, 0.00678232f, 0.01512466f, 0.08815140f, 0.01251423f, 
    -0.07584407f, -0.06003105f, -0.10387586f, -0.22973618f, -0.18261081f, 0.18046035f, -0.28440303f, 0.09711321f, 
    -0.07799489f, 0.22170538f, 0.10496945f, -0.15899293f, 0.00916103f, -0.02248238f, 0.13634720f, 0.01365606f, 
    0.08290619f, 0.01328748f, 0.21464469f, 0.05437086f, 0.09021190f, 0.02218054f, -0.11688534f, -0.12020246f, 
    -0.03186650f, 0.03593477f, -0.01161183f, 0.17247154f, 0.06112796f, 0.12978265f, 0.14695171f, 0.07292885f, 
    0.10677139f, 0.08484032f, 0.03099776f, 0.03762012f, 0.05570010f, -0.01605227f, 0.05391109f, -0.09091441f, 
    0.07629974f, 0.09053187f, -0.06836313f, 0.08196752f, 0.11647383f, -0.03904219f, 0.05177205f, -0.05400848f, 
    -0.00455041f, -0.01069687f, -0.00194335f, 0.05309439f, -0.07166007f, 0.09997697f, 0.09059978f, 0.20126271f, 
    0.05014452f, 0.00833311f, 0.09724353f, 0.06055104f, -0.07294622f, 0.08362900f, 0.09128444f, 0.15575930f, 
    -0.10179937f, 0.02587800f, 0.16558751f, 0.04195965f, 0.10383962f, -0.04177082f, -0.04675520f, -0.13547359f, 
    -0.10534861f, -0.06680547f, -0.20250799f, -0.05289689f, -0.02170656f, -0.03786720f, -0.03504819f, 0.07436164f, 
    -0.03209282f, -0.01372628f, -0.02184209f, -0.15201174f, -0.20816238f, -0.16456147f, -0.26267546f, -0.05340463f, 
    -0.08911719f, -0.11428060f, -0.02681769f, -0.07117707f, -0.15295538f, -0.19386680f, 0.13499489f, -0.04255785f, 
    0.11129571f, 0.24664909f, 0.02572521f, 0.00792195f, -0.01932700f, 0.03579548f, 0.02559771f, 0.00618279f, 
    -0.34734946f, -0.06585836f, -0.33684349f, -0.13909416f, -0.10645466f, -0.01158955f, -0.01087046f, -0.01217293f, 
    -0.00363519f, 0.02508736f, 0.04226494f, 0.12254545f, 0.11794659f, -0.01444194f, -0.14225999f, -0.04844048f, 
    0.05602316f, 0.07125735f, 0.09097582f, 0.01581264f, 0.28596994f, 0.03026002f, -0.32434329f, 0.07747918f, 
    -0.04143876f, 0.49574956f, 0.20028187f, -0.07044978f, 0.11374564f, 0.18886857f, -0.03772568f, 0.11574952f, 
    -0.09743340f, 0.01669568f, 0.09900610f, 0.24610221f, 0.23319596f, 0.11103995f, -0.08203959f, 0.17898259f, 
    -0.03424368f, 0.05737494f, -0.08295665f, -0.19983593f, 0.09630290f, -0.05501838f, 0.06822173f, -0.03676039f, 
    -0.08322587f, -0.02539510f, -0.05831420f, -0.03090912f, -0.04890148f, 0.16647902f, 0.09775383f, 0.08264102f, 
    -0.07005090f, 0.12640668f, 0.08534704f, 0.05104711f, -0.28086331f, -0.25499931f, -0.19777344f, 0.18519640f, 
    -0.03623702f, 0.34744099f, 0.00103293f, 0.07735764f, -0.13015319f, 0.12445518f, -0.01022736f, 0.08304544f, 
    0.00762437f, -0.09813078f, -0.07754844f, 0.02571164f, 0.07294624f, 0.06473286f, -0.05514589f, 0.21777178f, 
    -0.20749582f, -0.17474097f, -0.06638912f, -0.12474386f, -0.09046447f, -0.07923587f, -0.02343887f, -0.09330299f, 
    -0.09482004f, -0.05635712f, 0.04282692f, 0.27166656f, -0.01853676f, -0.05422116f, -0.06618345f, -0.05908850f, 
    0.01202570f, 0.03668156f, -0.06348541f, -0.06255644f, 0.15499187f, 0.13403423f, -0.04595061f, 0.07971061f, 
    0.03373654f, 0.16926810f, -0.09311561f, 0.06512285f, 0.01186407f, -0.01846532f, 0.04876460f, -0.00871351f, 
    0.04611535f, -0.04399844f, 0.04586902f, 0.05084402f, -0.06167403f, 0.01234278f, -0.03620209f, -0.20605455f, 
    -0.01680730f, -0.33724868f, -0.15542871f, 0.06209658f, -0.18902783f, 0.11475793f, -0.01745999f, -0.03076113f, 
    -0.01635030f, -0.24635029f, -0.09353703f, -0.04316828f, -0.00391318f, -0.04034330f, 0.02876914f, 0.00581612f, 
    0.16717085f, 0.11532371f, -0.10600448f, 0.37066934f, 0.57133931f, -0.06718609f, -0.21527177f, 0.03148913f, 
    -0.30810559f, 0.13883348f, -0.11217071f, -0.11614519f, -0.18412942f, -0.13534459f, -0.02518341f, -0.09795471f, 
    0.01792174f, -0.08457498f, -0.05089485f, 0.13244258f, -0.14948957f, -0.00370334f, 0.05548485f, -0.08762750f, 
    -0.11189625f, 0.04797791f, -0.01802974f, -0.07335509f, 0.00119397f, 0.12268122f, 0.03872553f, 0.01100265f, 
    0.00368181f, 0.12689354f, 0.13211635f, 0.13311076f, 0.16731665f, 0.02888881f, 0.05532829f, -0.11036874f, 
    -0.02131501f, 0.00303982f, -0.04203256f, 0.02856086f, -0.04653155f, -0.03219578f, 0.04474081f, 0.24821456f, 
    -0.04247902f, -0.07133222f, -0.08305204f, -0.05658621f, 0.02200219f, -0.09937744f, 0.03511177f, 0.01279743f, 
    0.02441518f, 0.00257127f, 0.10495742f, -0.07656577f, -0.01921700f, 0.10607853f, -0.14694835f, -0.28512812f, 
    0.14119823f, 0.11255398f, 0.12260990f, 0.14574763f, -0.05154737f, -0.05083727f, 0.04221731f, 0.07972432f, 
    -0.04740074f, 0.16664988f, 0.03588412f, 0.06260759f, 0.08686121f, 0.01018377f, 0.11666155f, 0.12545341f, 
    0.10145449f, 0.07033700f, 0.12725651f, 0.27110472f, -0.22681233f, -0.25449106f, -0.25909913f, 0.13107531f, 
    -0.01770654f, 0.10335973f, 0.13108557f, 0.06402090f, 0.05384284f, -0.01292416f, -0.01141912f, -0.10485876f, 
    -0.04425956f, -0.06966649f, -0.02700064f, -0.05179674f, 0.11184449f, 0.08216140f, -0.05427298f, 0.06943348f, 
    0.02732542f, -0.03907312f, -0.02267773f, -0.03913002f, -0.02497310f, 0.01453221f, -0.03507916f, 0.01383293f, 
    -0.02714058f, -0.02444130f, 0.02660122f, 0.02972290f, 0.03452271f, 0.01839484f, 0.02798447f, -0.00332176f, 
    0.03718875f, 0.03299042f, -0.04097242f, -0.02812211f, 0.01433258f, 0.00890884f, -0.01263181f, -0.03386696f, 
    -0.00612109f, -0.01458291f, 0.01228625f, -0.03075542f, -0.04288473f, -0.03128163f, 0.03472573f, -0.00796344f, 
    0.00730785f, -0.02869522f, 0.02361063f, -0.00010313f, 0.00482846f, -0.01553455f, -0.00180153f, 0.01905430f, 
    0.02245552f, -0.03320903f, -0.01115946f, -0.04058031f, -0.01841611f, -0.01484394f, 0.00651229f, 0.01895300f, 
    -0.03847245f, -0.02794422f, -0.01623855f, -0.00477835f, -0.01817488f, -0.03558084f, -0.01429180f, -0.02361247f, 
    -0.02484263f, -0.01453389f, 0.01047069f, -0.01748949f, -0.00061228f, -0.02768372f, -0.01812988f, -0.02133431f, 
    0.00323670f, 0.00924890f, -0.02792379f, -0.00098593f, 0.02746913f, -0.01445279f, -0.02974468f, -0.00957643f, 
    -0.03520634f, 0.03651213f, 0.03458434f, 0.03206984f, -0.00180721f, -0.01504363f, -0.03007649f, 0.02351420f, 
    0.02229591f, 0.02449763f, -0.00166400f, -0.02059143f, -0.00072187f, 0.01776079f, -0.04531824f, 0.02095210f, 
    -0.04632893f, -0.00277241f, -0.03313407f, 0.02091135f, -0.03701176f, 0.03257066f, 0.02234802f, 0.01169620f, 
    -0.01839851f, 0.00882183f, 0.01467562f, -0.00493435f, -0.03355829f, 0.00549361f, 0.02391396f, 0.01363387f, 
    -0.00755554f, -0.02545474f, -0.02864287f, 0.00697290f, -0.01691462f, -0.01403920f, -0.02693039f, -0.01479250f, 
    0.02562475f, -0.00086005f, -0.01161088f, 0.00645812f, -0.03226279f, 0.00641914f, 0.00221348f, -0.04336416f, 
    -0.02887190f, -0.03070997f, 0.02810049f, -0.03904200f, 0.00129719f, 0.01147320f, -0.02986459f, 0.00914986f, 
    0.01081404f, 0.01991517f, -0.00284588f, -0.01716180f, 0.01105911f, -0.04051170f, -0.03685810f, 0.01989436f, 
    -0.00492355f, -0.01898959f, 0.03390498f, 0.02101010f, 0.01381349f, 0.02284075f, -0.03748532f, -0.02721441f, 
    -0.03623115f, 0.02432503f, 0.01465025f, 0.02991775f, 0.02954358f, 0.01285281f, 0.02307524f, 0.02319572f, 
    -0.03497217f, 0.02894679f, 0.02096435f, 0.00177410f, -0.01917207f, -0.03914208f, -0.01374174f, -0.01434616f, 
    0.01045298f, -0.00091240f, 0.01581943f, 0.02953711f, 0.00540668f, 0.01536441f, 0.03199998f, -0.00966279f, 
    0.02265451f, 0.03792284f, 0.01673092f, 0.00285136f, 0.02308571f, -0.00672602f, -0.04082997f, -0.00197295f, 
    0.01581466f, 0.01728491f, -0.01395495f, 0.02850011f, -0.03079016f, 0.00817405f, -0.02211799f, -0.04713972f, 
    -0.00174364f, -0.02384516f, -0.02516170f, 0.02698987f, 0.00619746f, -0.04067736f, -0.02807576f, -0.02605759f, 
    0.03310818f, 0.01235514f, 0.02204450f, 0.02874889f, -0.03270299f, -0.00802159f, 0.02777844f, -0.04183813f, 
    -0.03260577f, -0.02224541f, 0.00259351f, 0.01389643f, -0.00460984f, 0.00452093f, -0.01961074f, 0.01231535f, 
    -0.01244659f, -0.00279600f, -0.02510921f, -0.04048192f, 0.00041830f, -0.00878197f, -0.01676743f, -0.02995878f, 
    -0.03201781f, 0.02423538f, 0.02594795f, -0.00075806f, -0.00201622f, -0.03902313f, -0.03720399f, -0.01224431f, 
    0.01548917f, 0.01314495f, -0.01135690f, -0.00476449f, -0.01250959f, -0.04158445f, -0.00735177f, 0.02659214f, 
    -0.01298099f, -0.03630847f, -0.01412576f, -0.00982052f, 0.03044747f, 0.00359674f, -0.00616153f, -0.04715818f, 
    -0.04313068f, 0.02971491f, 0.02584573f, -0.04703784f, -0.02155308f, 0.02568966f, -0.04350992f, 0.00076925f, 
    0.00006147f, -0.02918933f, -0.03209559f, -0.00601777f, 0.01053445f, 0.01431477f, 0.01154147f, 0.02781720f, 
    0.01232963f, -0.02521823f, 0.02812686f, -0.00614373f, 0.02942617f, 0.01449936f, 0.00709463f, -0.04680712f, 
    -0.01798428f, -0.02682852f, -0.01740469f, 0.01387273f, -0.04146224f, -0.03075777f, 0.03112399f, -0.03079520f, 
    0.00137167f, 0.03488704f, -0.01597391f, -0.04119230f, 0.02107576f, -0.02000348f, 0.02376165f, 0.02589575f, 
    -0.03440702f, 0.01710247f, 0.01198507f, 0.02829159f, 0.01429571f, 0.02536098f, -0.03166002f, 0.00006239f, 
    0.01576728f, 0.00459782f, -0.01051652f, -0.02838159f, 0.01127778f, 0.00373412f, 0.03582306f, 0.00618189f, 
    0.01003733f, 0.02220817f, 0.01408448f, -0.00160280f, -0.04789057f, 0.01096189f, 0.01173723f, 0.02976265f, 
    -0.00658571f, -0.01999030f, -0.03205157f, -0.00302806f, -0.03595734f, -0.01362083f, -0.04468953f, 0.02573674f, 
    -0.03607499f, 0.02918205f, 0.01058888f, -0.03977117f, 0.02161918f, 0.02684890f, -0.00780523f, -0.02888192f, 
    -0.01615275f, -0.04167655f, 0.00296375f, -0.02209168f, -0.03952374f, -0.01259445f, 0.02241837f, -0.00018689f, 
    0.02866194f, 0.00753955f, 0.02245958f, 0.01781525f, 0.02724111f, -0.02216085f, -0.04305370f, 0.02884445f, 
    -0.02089258f, -0.02187438f, -0.03176361f, 0.00150107f, -0.03838336f, -0.03854213f, -0.02560324f, -0.02884628f, 
    0.01369213f, 0.01427273f, -0.04017363f, -0.04128413f, -0.02155734f, -0.02520994f, 0.01334032f, -0.01541098f, 
    -0.03462936f, -0.02376056f, -0.00111789f, -0.01745017f, -0.01807848f, -0.01977195f, -0.02827602f, 0.03670190f, 
    -0.03973049f, 0.00141433f, 0.02041059f, -0.02156791f, -0.03082007f, -0.02496013f, 0.00319885f, 0.00265632f, 
    0.03083774f, -0.00239193f, -0.02580007f, 0.01684296f, 0.01367014f, -0.02947912f, 0.01064520f, -0.01159823f, 
    -0.03974872f, 0.02275994f, -0.02889761f, 0.03011184f, -0.02942913f, -0.00970147f, -0.02182507f, -0.01141007f, 
    0.01030288f, -0.02106050f, -0.00621557f, -0.02371500f, -0.00163000f, -0.01678096f, -0.00675159f, -0.01977572f, 
    -0.02067151f, 0.00211601f, 0.00285653f, -0.02359683f, 0.00423841f, 0.00928862f, -0.03550009f, -0.04114480f, 
    -0.01988671f, -0.02680987f, 0.00457986f, -0.01935815f, -0.04077759f, 0.01677506f, -0.02651738f, 0.03069024f, 
    -0.01440717f, -0.02016615f, -0.02721882f, 0.02598223f, 0.01333138f, 0.02936552f, -0.00717872f, -0.00676730f, 
    -0.00314116f, -0.01236598f, -0.02487414f, -0.00792357f, -0.01429405f, -0.03167034f, 0.01627982f, 0.00160720f, 
    0.01879155f, -0.01487717f, 0.02335958f, -0.02105243f, 0.03017351f, 0.02029708f, 0.00227106f, -0.00422546f, 
    -0.02738885f, -0.03846676f, -0.00998538f, 0.00925393f, 0.01647916f, -0.01297124f, -0.03568355f, 0.00532801f, 
    -0.03683696f, 0.00791168f, -0.02285043f, 0.02461255f, -0.00000097f, 0.03004180f, 0.02456340f, -0.01052145f, 
    0.01601852f, 0.00993268f, 0.02541327f, 0.00085524f, -0.03231146f, 0.01907220f, 0.00062925f, 0.02336008f, 
    0.01160604f, 0.00583393f, 0.00154485f, -0.02343095f, -0.03538454f, -0.01697274f, -0.00030556f, 0.02193019f, 
    -0.03188119f, -0.03388390f, -0.00545569f, -0.00506581f, 0.01718486f, 0.03234427f, 0.00770892f, 0.00807742f, 
    0.03832498f, 0.03292964f, -0.00814697f, -0.03192854f, 0.00781792f, -0.03139222f, -0.00089846f, -0.00447927f, 
    -0.02006340f, -0.02458186f, 0.01717755f, -0.00536924f, 0.01972454f, -0.00030991f, -0.00982376f, -0.00806376f, 
    0.00474954f, -0.00520829f, -0.03667597f, -0.00884758f, -0.02104744f, 0.02387656f, 0.00951157f, -0.02466165f, 
    -0.02632326f, 0.01592666f, -0.03886695f, -0.03067345f, 0.00786603f, 0.00617925f, 0.00541541f, 0.02760793f, 
    -0.00004297f, -0.02662610f, -0.02351105f, 0.02858943f, -0.04561625f, 0.01670571f, 0.00841026f, -0.02081283f, 
    0.00939783f, 0.02924920f, 0.02892088f, 0.00191786f, 0.00724478f, -0.00085162f, 0.02624011f, -0.02867787f, 
    0.02084979f, 0.00562927f, -0.00567296f, -0.02225296f, 0.00201884f, 0.03330920f, 0.02787904f, -0.02926505f, 
    -0.04104602f, -0.01934556f, 0.00050070f, -0.02613470f, 0.04360722f, -0.02783641f, 0.03637290f, -0.02887271f, 
    -0.02848562f, 0.02929810f, -0.01907211f, 0.02329041f, 0.00810026f, 0.02727312f, 0.00451237f, 0.00956429f, 
    0.01349119f, -0.02665566f, 0.01809714f, -0.03983026f, -0.04459355f, -0.03479806f, -0.00250710f, -0.04278295f, 
    -0.03088309f, -0.00556362f, -0.00488127f, -0.04288610f, -0.04212774f, 0.00540122f, -0.02862313f, -0.01454912f, 
    0.02215162f, -0.00341461f, -0.00803276f, -0.02313917f, -0.00725828f, 0.00879238f, 0.03151724f, -0.03263740f, 
    -0.02953566f, 0.03334062f, -0.00766983f, -0.00430414f, 0.00659331f, -0.00658523f, -0.00427106f, 0.00242460f, 
    -0.02598376f, -0.00612934f, -0.00664144f, -0.02314372f, -0.01222540f, -0.00957932f, -0.01259368f, -0.03348608f, 
    0.00374119f, -0.00249823f, -0.00947405f, -0.00426931f, -0.04393244f, -0.00374462f, 0.00320010f, 0.03521621f, 
    0.01422288f, 0.01728346f, 0.02212450f, 0.01571341f, -0.00545280f, -0.02297475f, -0.02180115f, -0.00388617f, 
    -0.00821430f, -0.03411781f, 0.00550920f, -0.02815374f, -0.02327849f, -0.00448140f, -0.04075786f, -0.02135287f, 
    -0.00166322f, -0.00518715f, 0.02234706f, 0.02777942f, 0.00672134f, -0.00773317f, 0.00308350f, -0.03832183f, 
    0.02326907f, 0.02149850f, 0.01879304f, 0.03788980f, -0.01416242f, 0.03352853f, -0.00053636f, -0.00881077f, 
    -0.01506267f, -0.04499625f, 0.00555801f, 0.00075285f, -0.02229182f, -0.01217679f, 0.00713869f, -0.00853585f, 
    -0.03937003f, -0.02193917f, -0.01737092f, -0.01603266f, 0.01584339f, 0.01294340f, -0.01902578f, 0.03516950f, 
    0.07483143f, 0.13314578f, 0.33022431f, 0.10358332f, 0.26346156f, -0.03910119f, 0.12988006f, 0.15584455f, 
    -0.20718472f, -0.02339312f, 0.10655826f, -0.08147584f, -0.02579571f, 0.07231161f, 0.09627979f, 0.15538779f, 
    -0.05106518f, 0.22597955f, -0.00508003f, 0.02976288f, 0.23098722f, 0.13322586f, -0.22230703f, -0.21214248f, 
    0.16554259f, 0.02696868f, 0.10453192f, -0.01472371f, 0.04289145f, 0.15488763f, -0.17554943f, 0.11264215f, 
    0.05034850f, 0.13085546f, 0.14344570f, 0.06285073f, 0.19351859f, 0.34949827f, 0.16633400f, 0.19321641f, 
    -0.34840769f, 0.00358769f, -0.05505769f, -0.00623855f, 0.07629795f, -0.06135957f, -0.13188630f, 0.07085188f, 
    0.18775497f, -0.12362218f, -0.11796812f, 0.06370199f, -0.10119481f, -0.08866465f, -0.05523369f, 0.12252034f, 
    0.08394442f, 0.02725855f, 0.22256963f, 0.08958229f, -0.12214712f, -0.18899800f, 0.46136269f, 0.04116550f, 
    0.02402479f, -0.14239226f, 0.00309729f, 0.00152998f, -0.13204707f, 0.04374843f, 0.02218278f, -0.12015216f, 
    -0.08377077f, -0.01956216f, 0.01459206f, 0.10085811f, 0.11654532f, 0.03618351f, -0.17154953f, 0.00710583f, 
    0.20865811f, 0.05744990f, -0.06350078f, -0.13713685f, -0.22160147f, 0.05564168f, -0.18720664f, -0.08940336f, 
    0.17942750f, -0.04516415f, -0.11198746f, 0.11838917f, -0.05833712f, 0.03302899f, -0.04009921f, 0.01872669f, 
    0.10622391f, -0.15222871f, -0.23018643f, -0.09205896f, 0.05534661f, -0.01712434f, -0.23459379f, 0.03797859f, 
    0.05912332f, 0.09052722f, -0.12485893f, 0.12713489f, 0.48841932f, -0.16801305f, 0.06104826f, 0.11840421f, 
    -0.04615868f, 0.08357587f, 0.16558757f, 0.06376050f, 0.00745967f, 0.16318706f, -0.10965013f, -0.19327198f, 
    0.19460799f, -0.02976671f, 0.09918349f, -0.15224530f, -0.15964541f, -0.19532087f, -0.02011340f, -0.01913317f, 
    0.01413324f, -0.13176695f, -0.06200188f, 0.02441473f, -0.02799197f, -0.02856701f, 0.13192441f, -0.04545631f, 
    0.04644514f, -0.19141856f, 0.04540731f, -0.06237386f, 0.00108159f, 0.54649132f, -0.34694475f, -0.07346145f, 
    0.05144948f, 0.09968445f, 0.05369484f, 0.10622299f, 0.00709358f, 0.16237873f, -0.13769889f, 0.05596061f, 
    0.06354836f, 0.17770243f, 0.15055826f, 0.04581438f, 0.25269982f, 0.10502444f, 0.18674950f, 0.19384359f, 
    -0.40065297f, 0.04886337f, -0.31068391f, 0.47628418f, 0.22111984f, 0.02519181f, -0.10595205f, 0.18825023f, 
    0.06682935f, -0.08660536f, -0.05780257f, 0.08375866f, 0.11686777f, 0.16251242f, 0.04285620f, 0.12874018f, 
    0.02820617f, 0.07770858f, -0.00707155f, 0.21370399f, -0.31720060f, 0.30572197f, -0.04787854f, 0.01181243f, 
    0.08074142f, 0.08386520f, -0.14124821f, 0.04503446f, -0.08344340f, 0.19953890f, -0.20271814f, 0.07726277f, 
    -0.07135139f, -0.10228747f, 0.01253625f, -0.08205458f, -0.07066084f, -0.08655006f, -0.05492275f, 0.06315000f, 
    0.08054957f, -0.05535735f, 0.00470203f, -0.15110491f, -0.29316440f, -0.32906920f, 0.06791419f, 0.06279712f, 
    -0.08771662f, -0.06485224f, -0.13917349f, -0.04500281f, 0.01094423f, -0.06860667f, -0.02147524f, 0.03025851f, 
    -0.14029993f, -0.03434789f, -0.15881181f, 0.13283792f, 0.24063566f, -0.10303579f, -0.26068389f, -0.00548800f, 
    0.08817490f, -0.03226290f, 0.06531365f, -0.02510113f, 0.02361803f, 0.03935780f, -0.10696906f, -0.01460392f, 
    0.01329863f, 0.01342489f, 0.06484289f, 0.17137721f, 0.13449579f, 0.12288346f, 0.17741044f, 0.12268993f, 
    -0.02410349f, -0.15878244f, 0.23533171f, -0.06779318f, 0.26491070f, -0.17234188f, 0.21180353f, 0.10755921f, 
    0.06512664f, 0.09819630f, 0.12442868f, 0.02998973f, -0.20456834f, 0.06021143f, 0.14213361f, -0.09508443f, 
    -0.08832961f, 0.18484987f, -0.07589978f, -0.04064516f, -0.02815885f, -0.07876385f, 0.04650566f, -0.06334636f, 
    -0.17452037f, -0.05839261f, 0.08486527f, -0.04596094f, 0.06559345f, -0.02732874f, 0.05694900f, 0.12684099f, 
    0.08790285f, 0.06599039f, 0.01293124f, 0.02985340f, -0.05725450f, -0.21079049f, -0.10259904f, -0.05826184f, 
    0.21227659f, 0.20815994f, 0.02494827f, -0.09692344f, 0.24723522f, -0.08931917f, 0.17771861f, 0.11021730f, 
    -0.01821864f, 0.07487211f, 0.01280497f, -0.09430346f, -0.02503407f, -0.10226084f, -0.03953937f, 0.09121066f, 
    -0.10727733f, 0.14301389f, 0.14104456f, 0.11568035f, -0.00098635f, 0.47380492f, 0.22089031f, -0.20891908f, 
    0.07745655f, 0.13035043f, 0.21693093f, 0.01927868f, 0.11269057f, -0.05909686f, -0.10936919f, -0.01137189f, 
    0.07991223f, 0.09426504f, 0.00071989f, -0.07399008f, 0.11840036f, -0.08689496f, 0.12674734f, 0.08829732f, 
    0.20515336f, 0.02265598f, 0.01066625f, -0.27755123f, -0.01185388f, 0.13906269f, 0.01748646f, 0.01845035f, 
    0.06597915f, -0.08097401f, -0.05641988f, -0.10919383f, 0.01810997f, 0.06458008f, -0.05139530f, 0.03867383f, 
    -0.09127008f, -0.02009633f, 0.09300701f, -0.03140538f, -0.42254111f, 0.30122569f, -0.30806589f, 0.03431593f, 
    -0.07981714f, 0.15573809f, 0.07230117f, -0.01379712f, -0.00555864f, -0.03373143f, 0.01148926f, -0.03368488f, 
    -0.05760365f, 0.07522012f, 0.09518401f, -0.06633537f, -0.08847244f, -0.12921384f, -0.09517353f, -0.06536739f, 
    0.01508126f, -0.00609087f, -0.01271301f, 0.02584556f, -0.19262443f, -0.03067747f, -0.14153683f, -0.09060425f, 
    0.04367322f, -0.05800909f, -0.00408627f, -0.00510430f, 0.02725756f, 0.02182120f, -0.02761831f, -0.01087300f, 
    0.01119156f, -0.21013990f, -0.02788149f, -0.02526176f, -0.08645859f, 0.18473519f, -0.01918407f, -0.02622637f, 
    -0.17991364f, 0.02116610f, 0.02509912f, -0.10482084f, -0.03049434f, 0.08928590f, -0.12336184f, -0.06234883f, 
    -0.11954772f, -0.04179046f, 0.02683148f, -0.31256607f, -0.06423472f, -0.12385218f, -0.12642257f, -0.11447236f, 
    0.16900605f, -0.20618215f, -0.05011500f, -0.08344544f, 0.03826277f, 0.04510953f, -0.00065320f, -0.01153461f, 
    -0.14137834f, -0.02634553f, -0.08713396f, -0.10349626f, -0.06612830f, -0.16643246f, -0.04115203f, -0.03401336f, 
    -0.08480832f, -0.01224853f, -0.08751169f, -0.11203294f, 0.36920118f, 0.40563425f, 0.26436859f, -0.23258062f, 
    0.16933167f, 0.02504183f, -0.00430832f, 0.06297355f, 0.15389073f, -0.09534641f, -0.02252393f, -0.00548574f, 
    -0.04097139f, 0.18493842f, 0.09143551f, 0.13480273f, 0.10486281f, 0.04178698f, 0.11204764f, -0.01608562f, 
    -0.12962843f, 0.04799071f, 0.17805730f, 0.27184987f, -0.07495299f, -0.17960048f, -0.10727284f, -0.03218335f, 
    0.01422818f, -0.02295163f, -0.12790611f, 0.08877020f, -0.08523829f, -0.11454942f, 0.00916295f, -0.10419428f, 
    0.05005250f, 0.20751359f, -0.07796160f, -0.07310513f, 0.22339158f, -0.00898310f, -0.10103866f, -0.31517634f, 
    0.26063368f, 0.21520600f, 0.15025209f, -0.09732915f, -0.04563903f, -0.05963768f, -0.06375583f, -0.08766266f, 
    -0.19056308f, 0.13807051f, -0.04499983f, -0.04550280f, -0.00419049f, 0.01582160f, 0.17448401f, -0.10845844f, 
    -0.34960082f, -0.26840416f, -0.12110958f, 0.35025516f, 0.20425519f, -0.14206102f, -0.10284772f, 0.07929306f, 
    0.02434714f, -0.07861998f, -0.17023352f, -0.02784535f, 0.05591594f, -0.18019798f, -0.02808161f, 0.01442508f, 
    -0.13105389f, 0.24697268f, 0.11027826f, -0.02830821f, 0.12246094f, -0.09240379f, -0.15890065f, 0.01706317f, 
    0.09517030f, -0.06042448f, 0.04522850f, 0.07160232f, 0.02383016f, 0.07159632f, -0.06386938f, -0.08776011f, 
    -0.01422469f, -0.11609437f, 0.01726410f, 0.21863826f, 0.06615433f, 0.20747770f, 0.16012014f, 0.09415250f, 
    0.00061321f, -0.01892459f, -0.22726639f, -0.15473759f, 0.23333709f, 0.16702619f, 0.03422069f, 0.15131611f, 
    0.06815826f, 0.08652129f, 0.22844803f, -0.07754453f, -0.12076685f, -0.05155531f, 0.01820659f, -0.11081581f, 
    -0.22594912f, 0.10982277f, 0.21937986f, 0.03121634f, -0.15929812f, -0.16130804f, 0.38736808f, -0.00936438f, 
    -0.05226266f, 0.21444260f, -0.00861908f, 0.03629130f, 0.32273591f, -0.26080585f, 0.11364170f, 0.02461342f, 
    0.09101973f, 0.04665021f, 0.09788335f, 0.21811645f, 0.13879028f, -0.09276725f, -0.20293923f, -0.24492058f, 
    0.11500920f, 0.18728325f, -0.11745818f, 0.01976038f, 0.03470897f, 0.14901114f, 0.01892933f, -0.07211299f, 
    -0.00005706f, -0.11476067f, -0.11645114f, 0.00434414f, 0.03038680f, 0.09016817f, 0.05912488f, -0.00023770f, 
    -0.11505324f, -0.04005561f, -0.00264324f, 0.05776428f, 0.07201612f, 0.09392625f, -0.12444334f, -0.15043138f, 
    0.05676200f, 0.08772264f, 0.09440126f, 0.12585105f, 0.00466404f, 0.03666682f, -0.11868504f, -0.06223594f, 
    -0.06884592f, -0.16863696f, -0.12104976f, 0.10740850f, -0.09246729f, 0.18906526f, 0.13765094f, 0.11467992f, 
    -0.22114518f, -0.11961396f, 0.11784285f, 0.01834345f, 0.04998924f, 0.00038342f, 0.00901514f, 0.04949595f, 
    0.04127203f, -0.03157496f, -0.01128458f, 0.00099202f, -0.10900932f, 0.05464234f, 0.10216697f, -0.09290197f, 
    0.02830835f, 0.11970547f, -0.01225439f, -0.12040281f, 0.22090168f, -0.04390029f, 0.03810964f, -0.29408702f, 
    0.07222744f, 0.17274031f, 0.06694024f, 0.02870520f, 0.07776754f, -0.04869883f, 0.05091968f, -0.01810667f, 
    -0.03398174f, -0.07649634f, 0.00459300f, -0.04798126f, -0.23264256f, -0.01599656f, 0.16835490f, 0.02573187f, 
    -0.11435506f, 0.37262562f, 0.23026469f, 0.03053930f, 0.01233508f, 0.01791715f, 0.03204615f, -0.12776594f, 
    0.05991020f, 0.18983281f, 0.13587198f, 0.07961454f, -0.08192591f, -0.04409323f, -0.22441822f, 0.06679120f, 
    0.10064170f, 0.10133982f, -0.08967290f, 0.07817111f, -0.14060639f, -0.03341153f, 0.43464753f, -0.11655455f, 
    -0.10410076f, 0.01739226f, 0.20684472f, -0.03204060f, 0.09051828f, -0.01898009f, 0.11003507f, -0.03139330f, 
    0.04155594f, 0.14746128f, 0.21340753f, 0.05024954f, -0.05956947f, 0.00263423f, -0.05969994f, 0.09965409f, 
    0.04443438f, 0.10061975f, 0.49115255f, 0.17034544f, 0.04914575f, 0.24866883f, 0.08612534f, 0.04091907f, 
    0.01059784f, 0.28052929f, 0.06177966f, 0.06244718f, 0.06547637f, 0.01326901f, -0.11766076f, -0.00419536f, 
    0.15678149f, -0.19817770f, 0.06618259f, 0.20259933f, -0.18586834f, 0.04250663f, -0.13204913f, -0.11853644f, 
    -0.02330137f, 0.01343310f, 0.00450606f, -0.05916610f, -0.01137238f, 0.08413043f, 0.01495848f, -0.02455300f, 
    -0.10403571f, 0.03320763f, -0.14418705f, 0.07726534f, 0.01968377f, 0.15445980f, 0.07127964f, -0.04189801f, 
    -0.43972483f, -0.00856659f, -0.26903903f, 0.25985384f, 0.03745732f, 0.17410488f, -0.10296543f, -0.13850774f, 
    -0.04753541f, -0.06651913f, 0.14710900f, -0.12047918f, -0.02672186f, -0.11936006f, 0.11054897f, -0.00489196f, 
    -0.05049416f, 0.08479601f, -0.13101631f, -0.14351240f, 0.05721961f, 0.35293514f, -0.45506451f, 0.20916532f, 
    -0.21350111f, -0.04343260f, -0.23029499f, 0.22933996f, -0.55909175f, 0.10215230f, 0.14046524f, 0.04897782f, 
    0.05566258f, -0.10258751f, 0.15325649f, 0.27768511f, 0.03968814f, -0.05385718f, -0.14079231f, 0.05206733f, 
    -0.70399648f, -0.02456271f, -0.08409792f, 0.53181624f, -0.18289572f, -0.00161035f, -0.18913484f, -0.16371667f, 
    -0.15530907f, -0.05149968f, 0.01031665f, 0.08580951f, -0.05698755f, 0.08658834f, -0.09295991f, 0.10411150f, 
    0.02488681f, 0.18436782f, -0.14103000f, -0.08840910f, 0.13727340f, -0.02489543f, 0.09438849f, -0.12343323f, 
    -0.10261809f, -0.16019459f, -0.07685433f, 0.00103222f, 0.11107875f, -0.15660569f, -0.00487198f, 0.16035044f, 
    -0.05561789f, -0.05998161f, 0.23413286f, -0.07952321f, 0.07827873f, -0.03434457f, 0.19971628f, 0.23012918f, 
    -0.16183497f, -0.04196550f, 0.15983827f, -0.15466380f, -0.01504847f, -0.04988737f, -0.39633420f, 0.13885091f, 
    0.05736502f, 0.13596140f, 0.01547886f, 0.11593343f, -0.06347563f, 0.04580301f, 0.09459439f, 0.05350163f, 
    -0.10519131f, 0.14102103f, 0.20388204f, 0.06979237f, 0.31311619f, -0.12457646f, 0.07579716f, -0.24167156f, 
    -0.05703048f, 0.12728009f, -0.22212528f, 0.24426027f, 0.14844780f, -0.03255484f, -0.12027252f, -0.04712489f, 
    0.02549001f, -0.03243162f, -0.13435617f, -0.06709945f, -0.06063143f, -0.00442361f, -0.15622538f, 0.06840602f, 
    -0.19296037f, 0.13231920f, 0.10560167f, -0.11348733f, 0.11660837f, 0.08864097f, -0.13707437f, -0.01228163f, 
    0.06567449f, 0.06343365f, 0.17904553f, -0.01769715f, -0.01437845f, 0.02774894f, -0.07062988f, 0.15286632f, 
    -0.01358965f, -0.04152847f, -0.19935669f, -0.09800468f, 0.06769469f, 0.00534251f, 0.19640912f, -0.06365480f, 
    -0.05919046f, 0.04891532f, 0.04089366f, 0.17763159f, 0.06208188f, 0.24913284f, 0.03707265f, -0.01656515f, 
    0.09099580f, 0.02809347f, 0.03904454f, 0.13984467f, 0.14936130f, -0.02769079f, -0.02769189f, 0.02747554f, 
    0.40025055f, 0.39480805f, 0.21556963f, -0.15808521f, -0.10980488f, 0.04804059f, 0.00921914f, -0.14288858f, 
    -0.07819849f, 0.03436524f, 0.11639507f, 0.04726712f, 0.03042853f, -0.10028079f, -0.07746227f, 0.17682584f, 
    -0.21153435f, -0.26424196f, 0.03209740f, -0.14517623f, 0.06959593f, -0.05233431f, -0.19631901f, 0.33827695f, 
    -0.06126455f, 0.03952647f, -0.09850760f, -0.02813631f, -0.05434782f, -0.14920874f, -0.01312796f, -0.08850776f, 
    -0.10703120f, 0.00693711f, -0.00287700f, -0.11589421f, 0.14792126f, 0.25687382f, 0.07329270f, 0.18199115f, 
    0.04005557f, 0.21260951f, 0.53703004f, 0.31163085f, -0.18783987f, 0.03701942f, 0.13099711f, 0.03831339f, 
    0.11891534f, 0.28537434f, 0.06010853f, 0.06125905f, -0.05682057f, 0.01940848f, -0.13714559f, 0.11260108f, 
    0.07754564f, -0.01742890f, 0.00157926f, 0.14328268f, 0.28727686f, 0.21761340f, -0.15664373f, -0.03889599f, 
    0.04514275f, -0.07828256f, -0.10775733f, -0.01537244f, 0.37988979f, -0.24838828f, 0.07656165f, 0.06296003f, 
    -0.02447653f, -0.06097650f, 0.05535891f, -0.05082039f, 0.03269823f, 0.10148903f, -0.12919219f, 0.09069030f, 
    0.36951041f, 0.08702413f, 0.09647769f, 0.20262319f, -0.19483040f, 0.24077915f, 0.10865185f, 0.00309259f, 
    0.13660522f, 0.09267581f, 0.12179503f, -0.00941986f, 0.01967205f, 0.05744985f, 0.08559410f, -0.08676628f, 
    0.01385796f, -0.00799477f, -0.04843396f, 0.19011752f, -0.15808745f, -0.09646901f, -0.06465539f, -0.02441546f, 
    -0.14160022f, -0.13123956f, -0.18680601f, 0.02758197f, -0.13692872f, -0.13188122f, 0.11471886f, 0.10105456f, 
    -0.12979728f, -0.01721864f, 0.13085274f, -0.08920474f, -0.09332970f, 0.14098006f, 0.11563541f, 0.03942390f, 
    0.02570643f, -0.05486523f, -0.17646994f, 0.25172192f, 0.03158000f, 0.08055317f, -0.10884988f, -0.06343232f, 
    -0.09359795f, -0.09711143f, 0.13856642f, -0.05239658f, -0.04089252f, 0.04359908f, -0.00964650f, -0.10525543f, 
    0.05304981f, 0.16122158f, 0.06892532f, -0.00514520f, 0.21102265f, 0.14436333f, -0.27058303f, -0.02127188f, 
    -0.06546681f, -0.19474342f, -0.32264236f, -0.13723165f, -0.10118903f, -0.32584912f, 0.15713109f, -0.01344210f, 
    0.11666785f, 0.05556265f, -0.03634233f, 0.03339448f, -0.07340678f, 0.20657629f, -0.01907674f, 0.03023847f, 
    0.63472831f, 0.18592285f, -0.21463202f, 0.03723636f, -0.06964584f, 0.05998214f, -0.03544222f, -0.02280563f, 
    -0.06568400f, -0.20629378f, 0.18477699f, -0.07004289f, 0.09556197f, -0.05182006f, -0.02119549f, -0.14017382f, 
    -0.06099673f, -0.02131421f, 0.05592549f, -0.06875299f, 0.23416929f, 0.16799262f, -0.06727251f, 0.37994033f, 
    -0.34453464f, 0.10130265f, 0.11349115f, -0.03334764f, -0.07482001f, -0.04507061f, -0.03007941f, 0.08766621f, 
    -0.16200386f, -0.04947827f, -0.05094285f, -0.04913094f, -0.11457472f, 0.14846122f, -0.01823620f, 0.11809934f, 
    -0.12122536f, 0.02246705f, 0.05241031f, -0.24366923f, 0.02522837f, -0.01081820f, -0.08355387f, -0.14595784f, 
    -0.15112364f, 0.07263514f, 0.08509209f, -0.03590161f, -0.18239132f, 0.08608360f, 0.07096469f, -0.12368219f, 
    0.02680673f, -0.01517760f, 0.10339627f, -0.03663054f, 0.54649848f, 0.08995659f, 0.13937752f, 0.13079441f, 
    0.15376507f, 0.25101024f, 0.09316671f, -0.04834349f, 0.16489960f, -0.14198089f, 0.19579406f, 0.07843021f, 
    -0.09806218f, -0.00782677f, 0.04006479f, 0.00401467f, -0.10802798f, 0.24574456f, 0.00706304f, 0.05370403f, 
    -0.35820228f, -0.36095959f, 0.39629656f, -0.16740860f, 0.05648507f, -0.08081192f, -0.10732995f, 0.12360129f, 
    -0.06934808f, -0.26712951f, 0.02081288f, 0.14999487f, 0.15956090f, -0.03826854f, -0.07481875f, 0.03857195f, 
    -0.23253790f, 0.01924683f, -0.11006711f, -0.09787770f, 0.04385487f, 0.16735891f, 0.27636775f, -0.05306610f, 
    0.13734986f, 0.01975472f, 0.10516886f, 0.16458675f, 0.17769836f, 0.27342859f, 0.00377303f, -0.00270065f, 
    0.05793626f, 0.02664519f, -0.07333017f, 0.07952216f, 0.11597033f, -0.06613136f, 0.04986849f, 0.03151647f, 
    0.55685288f, 0.23387155f, 0.43958384f, 0.06670722f, -0.25632972f, 0.22173573f, 0.24393938f, 0.11537979f, 
    0.16182865f, 0.34191781f, 0.12448470f, 0.03550996f, 0.09070805f, -0.01698480f, -0.00319316f, 0.01694019f, 
    -0.17733142f, -0.17143576f, -0.13700949f, 0.02047119f, 0.08192725f, -0.44587484f, -0.29679963f, 0.14619291f, 
    -0.05093118f, -0.10698710f, -0.18340456f, -0.13657793f, -0.35124293f, -0.47929037f, 0.13226187f, 0.02662542f, 
    -0.07689093f, -0.02140565f, -0.04694268f, 0.01072142f, 0.03428001f, 0.14360821f, -0.02552371f, -0.13519560f, 
    0.30622044f, -0.08288226f, -0.17748544f, -0.01378450f, -0.12033030f, 0.05260786f, -0.00137928f, 0.22434558f, 
    0.04876420f, -0.08156691f, 0.00209694f, 0.15705760f, -0.04403398f, 0.01294256f, 0.12889715f, -0.07527916f, 
    -0.02403440f, 0.06068166f, 0.05740256f, 0.04331022f, 0.18193576f, 0.00547958f, 0.32060704f, 0.18070209f, 
    -0.07576914f, 0.27353933f, 0.15742992f, 0.03634612f, 0.17052937f, 0.27976546f, 0.05147875f, -0.06413095f, 
    0.02821327f, 0.07786015f, -0.00889010f, 0.09040566f, 0.09049074f, -0.17867506f, 0.12364207f, 0.10950066f, 
    -0.41964135f, 0.12625265f, 0.27089962f, -0.03754227f, 0.16121511f, -0.13003644f, 0.05156412f, -0.11361546f, 
    0.04110767f, 0.09225809f, 0.05735863f, -0.14301065f, 0.02436974f, -0.14616948f, -0.06979608f, 0.09638236f, 
    -0.09635837f, -0.05329916f, -0.11720303f, 0.07513449f, 0.71698147f, 0.20774053f, 0.07208291f, 0.00850924f, 
    0.02826063f, 0.30285409f, 0.12905544f, -0.09940764f, 0.23252428f, -0.04349761f, 0.15708306f, 0.04430491f, 
    -0.00427223f, 0.05012745f, -0.00822788f, -0.06757806f, 0.11872331f, 0.04621867f, 0.09186808f, 0.13077509f, 
    0.08320737f, -0.08339443f, -0.15824334f, 0.14843580f, 0.07376845f, -0.20473760f, 0.35775536f, 0.37204847f, 
    0.20147128f, 0.20172098f, 0.02053942f, -0.04978960f, -0.01096150f, 0.03651503f, -0.09798539f, -0.03152151f, 
    0.16314718f, -0.07154955f, 0.23960340f, 0.12565707f, 0.03477402f, -0.41448563f, 0.20440103f, 0.19163680f, 
    -0.16437869f, -0.08174631f, -0.05472946f, -0.17236084f, -0.08664444f, -0.14192511f, 0.00770550f, -0.02912418f, 
    0.06120474f, 0.10856220f, -0.32569805f, -0.03253318f, 0.09627425f, 0.23138747f, 0.08889706f, -0.01042782f, 
    -0.04080429f, -0.17707990f, 0.09981514f, -0.26907149f, 0.04071543f, 0.08779045f, -0.01952893f, 0.16195606f, 
    -0.15479504f, -0.29648405f, 0.03120338f, -0.04400076f, -0.05602329f, -0.06260106f, 0.04979489f, -0.04934486f, 
    0.29122698f, 0.07295901f, 0.20950961f, 0.15805808f, 0.35344020f, 0.05297999f, -0.11963008f, -0.08958410f, 
    -0.12844756f, 0.01698738f, 0.13886090f, 0.20169184f, 0.02493726f, 0.05916654f, 0.02348481f, -0.03529436f, 
    -0.00128490f, -0.04092020f, -0.07771489f, 0.08631859f, 0.30064923f, 0.03849388f, 0.03935121f, 0.12988116f, 
    0.02807531f, 0.14943297f, 0.06609593f, -0.10675764f, 0.06730343f, 0.01549508f, -0.04545232f, 0.09795167f, 
    0.03593378f, 0.01868382f, 0.07885220f, 0.04342347f, -0.07071242f, -0.01003117f, -0.02119905f, -0.18977971f, 
    -0.05699965f, 0.11471805f, -0.00390216f, 0.04743178f, 0.01632683f, 0.03791941f, 0.09667282f, -0.11303952f, 
    -0.03157770f, -0.04036258f, -0.20922109f, -0.11181591f, 0.15146717f, 0.02401592f, 0.18731587f, -0.06550348f, 
    -0.08378541f, -0.09358743f, 0.05054500f, -0.05151177f, 0.01769034f, -0.00460534f, -0.07245297f, 0.00192059f, 
    0.08835036f, 0.15551341f, -0.10791668f, -0.06177323f, 0.13900667f, 0.09849998f, 0.31350601f, 0.01131544f, 
    -0.01545400f, 0.01419397f, 0.19522089f, -0.00888498f, -0.02248866f, -0.01294530f, -0.08495487f, 0.07575211f, 
    -0.08947111f, -0.11079261f, -0.02561259f, 0.01404667f, -0.26319489f, -0.42174906f, 0.10068600f, 0.35578269f, 
    0.36734936f, 0.01446795f, 0.10875723f, -0.20887980f, 0.00520628f, 0.08665190f, 0.07206665f, 0.03980355f, 
    0.30219302f, 0.15418971f, 0.05246255f, 0.06254863f, 0.15517023f, 0.13671231f, 0.05683333f, 0.21500799f, 
    -0.49856672f, -0.05452367f, -0.02462887f, -0.11522267f, -0.02847335f, 0.09401888f, -0.01873655f, 0.05859122f, 
    0.11963852f, 0.04328479f, -0.19269258f, 0.04300537f, 0.05895808f, 0.16774358f, 0.01861575f, 0.06543019f, 
    0.21877992f, -0.06069441f, 0.04579183f, 0.12613836f, 0.00342322f, 0.08230208f, 0.16765469f, 0.03212539f, 
    0.10788450f, 0.04941545f, -0.25090176f, -0.11955596f, -0.00718610f, -0.13596912f, 0.03916643f, 0.18593346f, 
    0.13643388f, 0.00164122f, 0.14054914f, 0.03869980f, -0.16943067f, -0.00791530f, -0.12587760f, -0.20875783f, 
    0.05058115f, -0.00443960f, 0.05572516f, -0.01837299f, 0.09037891f, -0.02258838f, 0.12057847f, 0.02833768f, 
    0.03365446f, 0.10995062f, -0.00037416f, -0.00080474f, -0.04709722f, 0.04176432f, -0.15145636f, 0.17386447f, 
    -0.00820926f, -0.04055076f, -0.04202905f, 0.02469928f, -0.27065486f, -0.22688319f, 0.20669803f, 0.07213441f, 
    -0.11941117f, 0.01724612f, 0.06324618f, -0.11236437f, -0.00426074f, 0.03736000f, -0.07303238f, 0.02339870f, 
    -0.00649526f, 0.06875002f, 0.10705405f, -0.01583637f, 0.16910575f, 0.15563139f, 0.08039182f, 0.23842835f, 
    0.04546302f, -0.02841857f, 0.06525503f, 0.11110774f, -0.04187182f, 0.13141167f, -0.18235019f, -0.46546707f, 
    -0.00859421f, 0.06779016f, 0.16758560f, -0.05098027f, -0.00682579f, 0.01172503f, 0.00373317f, -0.03196613f, 
    -0.14365649f, -0.14324464f, -0.08359651f, -0.33095217f, 0.09518582f, 0.10813794f, -0.10545806f, -0.06790451f, 
    0.03375906f, 0.04725577f, 0.02640325f, -0.00548152f, 0.03354073f, 0.00931597f, 0.08741339f, -0.06571455f, 
    -0.11369430f, -0.16878797f, -0.16718206f, -0.03763904f, 0.22134535f, 0.18240376f, 0.05599821f, 0.13891675f, 
    -0.04324352f, -0.20476466f, -0.23259316f, 0.20910148f, -0.04978354f, 0.03496133f, -0.01410231f, -0.05203649f, 
    -0.00143652f, 0.04582398f, -0.04067896f, -0.10608556f, -0.01643342f, 0.03073300f, -0.10143112f, -0.03850242f, 
    0.26740947f, 0.13933590f, 0.39162761f, 0.40892676f, 0.08746910f, -0.12993719f, -0.11295639f, 0.27738538f, 
    0.16056710f, -0.17868838f, 0.07118237f, -0.08044241f, -0.18668771f, 0.04198479f, 0.09492488f, -0.07733648f, 
    0.24668317f, -0.04017070f, 0.05448668f, 0.07614867f, 0.03620736f, -0.02834939f, -0.04839190f, 0.10541999f, 
    -0.02614106f, -0.22470994f, -0.10897639f, 0.11007877f, -0.09389662f, -0.02184586f, -0.10868501f, -0.02096092f, 
    -0.06781111f, 0.13075463f, 0.07426041f, -0.06550290f, 0.04544970f, 0.06638768f, -0.00359198f, -0.00505060f, 
    -0.00894388f, 0.01179170f, -0.04964040f, -0.04811224f, -0.15431136f, 0.17181234f, 0.10485291f, 0.00505748f, 
    -0.02725159f, -0.08049215f, -0.06535346f, 0.00302779f, 0.00472326f, -0.02410902f, -0.01629119f, -0.10536509f, 
    0.15851858f, 0.22984523f, -0.05973119f, 0.03030443f, 0.07980789f, 0.08673260f, -0.04934203f, -0.03636289f, 
    0.07946076f, 0.11162803f, -0.00774780f, -0.07180898f, 0.01653028f, 0.05164371f, 0.03704250f, 0.07989857f, 
    -0.01047218f, 0.02852571f, 0.04445026f, 0.01042103f, -0.02098466f, -0.07272848f, -0.11539634f, -0.03799811f, 
    0.14694037f, 0.26208004f, 0.04173672f, 0.07208586f, -0.02225040f, 0.19446263f, 0.08019828f, -0.05318746f, 
    0.08954097f, 0.04733575f, -0.04008746f, 0.03639949f, 0.02935363f, -0.02898567f, -0.13544245f, -0.12053147f, 
    0.06211310f, 0.01270708f, -0.00076729f, 0.09985876f, -0.01122124f, -0.01213073f, -0.10156005f, 0.06047888f, 
    0.01951309f, 0.14024286f, 0.20972903f, 0.09815802f, 0.08047362f, -0.00110564f, -0.06235960f, -0.15208921f, 
    -0.07517585f, -0.09511251f, 0.22283290f, 0.03076706f, 0.16087598f, 0.15445466f, 0.15735871f, 0.09988364f, 
    -0.07331213f, -0.15148410f, -0.06532981f, -0.13073599f, 0.03338627f, -0.20970067f, -0.48506021f, -0.18159764f, 
    0.18922724f, 0.06939118f, 0.12246845f, -0.00273183f, -0.23576838f, 0.16863793f, 0.13688521f, -0.13981371f, 
    0.18657045f, -0.06660382f, -0.14619368f, -0.04878759f, -0.05331368f, -0.03257731f, -0.27369985f, 0.07142707f, 
    0.12750103f, 0.00289162f, 0.11253977f, -0.23880363f, -0.03858222f, 0.14020912f, -0.06048145f, 0.01146346f, 
    0.05586880f, 0.02271469f, 0.07063472f, 0.17981096f, 0.08164804f, -0.03894012f, -0.17200200f, 0.01123529f, 
    0.18480405f, -0.07742264f, -0.06037005f, -0.09972090f, 0.19150329f, 0.00195616f, 0.09564091f, 0.15088351f, 
    -0.22392865f, -0.23106776f, -0.10681842f, -0.01731553f, 0.15927246f, 0.00821005f, 0.14357227f, -0.00556965f, 
    0.01691030f, 0.04434989f, 0.03896778f, -0.10686448f, -0.13798462f, 0.00314553f, -0.07728989f, -0.24471267f, 
    -0.03313871f, 0.06672999f, 0.24919634f, -0.07709794f, -0.05317772f, 0.01143292f, -0.05906931f, -0.09864018f, 
    0.03155516f, -0.14386399f, -0.19181480f, -0.07576254f, 0.01765875f, 0.09914991f, 0.02296654f, 0.08386095f, 
    -0.01210732f, 0.08357885f, -0.19566923f, -0.09243830f, -0.21132217f, -0.23145168f, 0.36060578f, -0.00317393f, 
    -0.21512970f, -0.02156434f, -0.02686161f, -0.13997699f, -0.05464267f, -0.07790679f, -0.02338167f, 0.05002002f, 
    -0.01099123f, 0.04662659f, 0.10216935f, -0.15670104f, 0.13554236f, 0.23917058f, 0.09985061f, 0.24885137f, 
    -0.22189358f, -0.08541533f, -0.13733557f, 0.18225370f, -0.00678319f, -0.21668832f, -0.14309549f, 0.04637112f, 
    -0.18647298f, -0.03490805f, 0.04298390f, -0.03198978f, -0.06899378f, -0.00703971f, -0.02866737f, -0.03196304f, 
    -0.06342142f, -0.01953414f, -0.28439686f, -0.44182095f, -0.05331626f, 0.13550286f, -0.24584284f, -0.09031947f, 
    -0.02491493f, -0.02315905f, 0.00311326f, 0.13848497f, -0.07182906f, -0.03703205f, -0.06905458f, -0.00043537f, 
    0.04558007f, -0.09634799f, -0.03717083f, -0.22369991f, 0.09686708f, -0.09641219f, -0.04938802f, 0.00591857f, 
    -0.01614795f, 0.32823592f, 0.47462994f, 0.20776443f, -0.00587424f, -0.30469692f, -0.06986804f, -0.01864484f, 
    0.10518398f, 0.06656513f, 0.12363524f, 0.02934695f, 0.21490300f, 0.08928638f, 0.18572417f, 0.01234046f, 
    0.05978412f, 0.09875897f, 0.02406634f, 0.06750355f, -0.13054796f, -0.13818683f, 0.03039406f, -0.07852139f, 
    -0.03173711f, -0.05801257f, -0.03444171f, 0.12382583f, 0.04079242f, 0.04275584f, -0.05064492f, -0.02767810f, 
    0.05158586f, -0.00471568f, 0.02882290f, 0.01000085f, 0.06371956f, -0.09475422f, 0.14948162f, 0.23440568f, 
    -0.02007034f, 0.17701124f, 0.04814576f, -0.25361291f, 0.12960972f, -0.00690613f, 0.05603651f, 0.26570317f, 
    0.16303596f, 0.06528693f, 0.07599614f, 0.00499641f, -0.06298076f, -0.03313525f, -0.02335316f, -0.06600849f, 
    -0.08644240f, 0.12670159f, -0.07664029f, -0.12231541f, 0.08517797f, -0.06555911f, 0.13547583f, 0.28541839f, 
    -0.04487720f, -0.01913399f, -0.16017072f, -0.01970039f, -0.06757930f, 0.06913967f, 0.11870954f, 0.03188121f, 
    0.09555576f, -0.01872678f, -0.00696859f, 0.02901220f, -0.04385033f, -0.00420531f, -0.10091719f, -0.17437394f, 
    -0.04996568f, -0.10055158f, -0.56811684f, -0.15697193f, -0.30829093f, 0.14842658f, -0.12513967f, 0.14637920f, 
    0.16821988f, 0.09039766f, -0.04895014f, -0.02048695f, 0.05068256f, 0.06680377f, -0.01162175f, 0.01706546f, 
    -0.02468218f, -0.28802413f, 0.21528804f, 0.11636975f, -0.00126816f, 0.09221980f, 0.15952887f, 0.27267963f, 
    -0.13724317f, -0.07281986f, -0.02652747f, 0.05943473f, 0.03525967f, 0.02342543f, 0.04024190f, -0.09687372f, 
    0.00837306f, -0.17366235f, -0.06872623f, 0.21065794f, 0.04862640f, -0.23273714f, 0.05806471f, 0.04195242f, 
    0.22195035f, 0.07076415f, 0.04914730f, -0.13417618f, -0.22859778f, -0.01655231f, 0.05546176f, 0.00970711f, 
    0.08995555f, 0.04517934f, 0.01725347f, 0.00730608f, 0.06417756f, 0.06169426f, 0.12687181f, 0.12179028f, 
    0.03404433f, 0.10800476f, -0.12010805f, -0.12489107f, 0.50081861f, 0.22996338f, -0.27981877f, 0.19644555f, 
    -0.00041232f, -0.04916717f, -0.10149553f, -0.01801520f, -0.04378318f, -0.05827672f, -0.05225904f, 0.05166215f, 
    -0.00762255f, 0.09626872f, 0.08249775f, 0.03924425f, -0.08939584f, -0.09603144f, 0.23719788f, 0.10574687f, 
    0.25161719f, -0.01431195f, 0.08330932f, 0.02456337f, 0.14919627f, -0.05573749f, -0.03570724f, -0.00046357f, 
    -0.00601939f, -0.07796972f, -0.03966427f, 0.02457911f, 0.05077440f, 0.02285925f, -0.00760503f, -0.01310783f, 
    0.05734107f, -0.14201204f, 0.03730242f, 0.02386272f, 0.06800312f, -0.00114667f, 0.05822865f, -0.00045136f, 
    -0.06629110f, -0.02213482f, -0.08561362f, 0.15171152f, -0.03061655f, 0.00354449f, -0.09065157f, 0.08343945f, 
    -0.08326020f, 0.10728754f, -0.00868109f, -0.24184063f, -0.04138646f, -0.11081026f, 0.05276331f, 0.03500460f, 
    0.07298075f, -0.13247645f, 0.18589452f, 0.05764879f, 0.19003424f, 0.09069677f, 0.17069258f, 0.14964713f, 
    0.04461120f, 0.07168348f, -0.00351901f, 0.02591810f, 0.04222766f, 0.07493951f, 0.03969214f, 0.16435060f, 
    0.09442782f, -0.00280659f, 0.03459667f, 0.05681233f, 0.32630885f, -0.56732601f, 0.24169110f, 0.10986814f, 
    -0.03523297f, -0.03795548f, -0.04376803f, -0.04197013f, -0.03971878f, -0.12734835f, 0.19688250f, -0.01588990f, 
    0.08087160f, 0.00719259f, -0.08244558f, 0.10176223f, -0.15697488f, -0.03574388f, -0.07366707f, -0.13209799f, 
    0.74442923f, -0.01076199f, 0.05638634f, 0.03127353f, -0.24648358f, -0.00694328f, -0.01711185f, -0.10672668f, 
    0.04031232f, -0.04115228f, 0.16838224f, -0.00068166f, -0.00379138f, -0.10682055f, 0.12539884f, 0.02532251f, 
    -0.04223017f, -0.02149666f, 0.02927459f, -0.00176936f, -0.04167145f, -0.15110488f, 0.13081004f, 0.10056570f, 
    -0.08120809f, -0.06825345f, 0.19672801f, -0.07970265f, 0.03956731f, -0.06623971f, 0.21192186f, 0.06507435f, 
    -0.15454084f, 0.02466778f, 0.01574193f, -0.05796407f, 0.02854769f, -0.08224534f, 0.06212888f, 0.03152742f, 
    0.06330740f, -0.06331933f, 0.02259983f, 0.02940099f, 0.05047501f, -0.00643298f, -0.01286342f, -0.08536217f, 
    -0.03175247f, 0.01506190f, -0.02099271f, 0.03174087f, -0.00003935f, 0.04784991f, 0.09145444f, -0.01578613f, 
    0.02382611f, -0.15914360f, -0.09582553f, -0.11909422f, -0.15363906f, 0.25341371f, 0.16175772f, 0.05471072f, 
    -0.12775162f, 0.07691421f, 0.05181950f, 0.13219477f, -0.07465224f, 0.00516319f, 0.00252789f, -0.04519513f, 
    0.01814259f, 0.05155396f, 0.11292520f, -0.00215560f, -0.03179168f, -0.08776718f, -0.04316779f, 0.09126676f, 
    -0.18726783f, -0.17049435f, -0.11823272f, 0.03145828f, -0.31478724f, 0.10874441f, -0.10309919f, 0.06713095f, 
    0.02882847f, -0.06545808f, -0.13987584f, 0.05607887f, 0.06084735f, 0.03405897f, -0.03259124f, -0.07701635f, 
    -0.01088643f, -0.03165083f, 0.05004058f, 0.02795741f, 0.05966526f, -0.05539929f, 0.11885796f, -0.06100532f, 
    0.20810652f, -0.06793021f, -0.08483317f, 0.00642331f, -0.07239003f, -0.02022399f, 0.08566778f, 0.03534677f, 
    -0.05273721f, 0.01889488f, 0.08655172f, 0.04976748f, -0.05167947f, -0.09817535f, -0.01977076f, -0.18457533f, 
    -0.18775214f, -0.06207949f, -0.36129934f, -0.00756967f, -0.18514161f, 0.13323905f, -0.19999665f, -0.09939866f, 
    -0.01131213f, 0.03107397f, 0.03171374f, 0.03427276f, 0.07763858f, 0.04257217f, 0.12407234f, 0.11065444f, 
    0.00263608f, -0.04532764f, -0.20872346f, -0.12264041f, -0.10744008f, -0.56176358f, 0.11099477f, 0.16944063f, 
    0.07101249f, -0.08277494f, -0.05504389f, 0.23364198f, 0.01463013f, 0.12909380f, 0.09098914f, 0.07243734f, 
    -0.04619985f, 0.13578185f, -0.01214222f, -0.04467278f, -0.06247808f, 0.02936261f, 0.06972451f, -0.00999385f, 
    -0.21631435f, 0.18754917f, 0.19799949f, 0.24429138f, 0.12755741f, -0.14603068f, -0.03777045f, -0.00464426f, 
    -0.04455614f, 0.06806789f, -0.08355904f, 0.07191091f, 0.00993202f, -0.00874355f, -0.02246718f, 0.14864743f, 
    0.11819363f, 0.03165221f, 0.17829743f, 0.01745925f, 0.40462601f, -0.09168600f, 0.23479839f, 0.11599821f, 
    0.03729282f, -0.02375811f, -0.04482019f, -0.00000292f, 0.13789727f, 0.05881740f, -0.00123592f, -0.02997198f, 
    0.07463147f, 0.06571892f, 0.03748958f, 0.06067633f, 0.02510059f, -0.01589208f, 0.02835418f, -0.04059669f, 
    0.21313769f, 0.00956250f, 0.10836301f, -0.00665431f, 0.20923686f, -0.04336856f, -0.00756678f, -0.01092995f, 
    -0.03384513f, -0.00859447f, -0.01633503f, 0.09489845f, -0.03920087f, 0.00917304f, 0.02524296f, 0.11751362f, 
    0.02988261f, -0.02176626f, -0.07313992f, -0.05514121f, 0.02572837f, -0.03269922f, 0.11255390f, 0.06176317f, 
    0.13256703f, -0.02701155f, -0.06759718f, -0.01429746f, 0.00585914f, 0.02268128f, 0.15895817f, 0.22458307f, 
    -0.00396381f, 0.08547800f, 0.08874357f, -0.00264604f, -0.10335623f, -0.11438286f, -0.08438590f, -0.06552632f, 
    -0.24916668f, -0.03114484f, 0.07608318f, -0.00601268f, -0.10393512f, -0.06265246f, -0.02567703f, 0.03215376f, 
    0.12507512f, 0.05418319f, -0.02843618f, 0.13950250f, -0.01398353f, 0.10550589f, 0.06099273f, -0.13218936f, 
    -0.03018152f, -0.00649794f, -0.01243327f, 0.00574061f, -0.80792522f, -0.32477653f, 0.41722998f, 0.27480137f, 
    0.20201488f, 0.01801057f, 0.13309965f, 0.10644820f, 0.17730488f, 0.10238598f, 0.06774709f, 0.06240784f, 
    0.09475213f, 0.09379750f, -0.00076790f, 0.06413448f, 0.15846023f, 0.05625885f, 0.21287142f, 0.03124743f, 
    0.17395504f, -0.06950634f, -0.00108803f, 0.11294400f, -0.03274073f, -0.04197966f, 0.02395139f, 0.05739607f, 
    0.10257690f, -0.01250914f, -0.02318157f, 0.14105834f, 0.10334146f, 0.13330895f, 0.15333498f, 0.17087924f, 
    -0.03743989f, -0.05368396f, -0.07467888f, 0.02561644f, -0.18203931f, 0.19900699f, 0.34560871f, 0.26147288f, 
    -0.33270061f, -0.23885754f, -0.03619316f, 0.05211042f, 0.03760215f, 0.17693953f, -0.08266634f, -0.07573999f, 
    0.02197686f, -0.12269627f, -0.06204263f, 0.07014211f, 0.05787045f, -0.15527758f, -0.00903349f, 0.02227441f, 
    0.23578194f, 0.05696338f, -0.15866160f, -0.04730966f, -0.17279799f, -0.11027019f, -0.03444735f, -0.06896465f, 
    0.07687863f, 0.04373146f, 0.17543258f, 0.05663093f, -0.08441619f, 0.01564687f, 0.09601375f, -0.19611871f, 
    -0.11610345f, -0.20314138f, -0.02406989f, -0.02784995f, 0.01220908f, 0.18412849f, 0.07742614f, 0.09349839f, 
    -0.20727158f, 0.11435556f, -0.00749863f, 0.06982558f, -0.15793347f, 0.02282538f, -0.06464707f, -0.05335318f, 
    0.02167987f, 0.12711802f, 0.14486353f, 0.08128040f, 0.08206917f, 0.00254036f, -0.06866171f, 0.05106344f, 
    -0.23144147f, 0.09904587f, 0.24707547f, 0.07494397f, -0.12660697f, -0.13516526f, -0.04137978f, -0.13617256f, 
    -0.10108779f, -0.17147200f, -0.22726935f, 0.13405746f, -0.10453286f, -0.01207186f, -0.03433651f, -0.04235302f, 
    -0.00827279f, -0.05016733f, -0.03273556f, -0.04683334f, 0.02182993f, 0.17418730f, 0.27756765f, 0.05665525f, 
    0.10999772f, -0.15145789f, -0.11895453f, -0.02654040f, -0.01125523f, 0.05054566f, -0.07972057f, -0.05359007f, 
    -0.05527726f, 0.08165237f, 0.00960790f, -0.02487019f, 0.04378434f, -0.06925797f, 0.07740828f, 0.07559625f, 
    -0.12947081f, -0.02828591f, 0.17718838f, 0.05350544f, -0.21010913f, -0.02467172f, 0.00191255f, 0.02706284f, 
    0.07857338f, 0.11311629f, 0.12318794f, -0.08352542f, 0.01925165f, -0.07708215f, -0.02564817f, 0.02517640f, 
    -0.03314169f, -0.06015255f, 0.00500658f, -0.01444756f, 0.12115654f, 0.13823162f, 0.08002689f, 0.08537990f, 
    -0.01585891f, -0.01531609f, -0.13349910f, -0.00538487f, -0.04140807f, -0.01825351f, 0.03364088f, 0.01710458f, 
    0.09352359f, 0.09137527f, 0.16141687f, -0.02993312f, 0.01260586f, 0.07592365f, -0.05986458f, -0.05464504f, 
    0.36086902f, 0.13083327f, -0.07007383f, 0.07114270f, -0.07680221f, 0.25530130f, 0.13234445f, 0.04862062f, 
    0.13123868f, -0.00081839f, -0.09078830f, -0.01958303f, 0.11809181f, 0.14402524f, 0.02593241f, 0.10675846f, 
    0.15676476f, 0.07073900f, 0.26112664f, 0.20986773f, -0.32971749f, 0.19156270f, 0.03700193f, 0.25587061f, 
    -0.06653591f, -0.23105490f, -0.02153749f, -0.01528122f, -0.09218702f, 0.12891254f, -0.05615505f, 0.00980294f, 
    -0.07136887f, -0.05770914f, -0.06975392f, -0.02849708f, 0.01022169f, -0.08060101f, -0.05290839f, -0.05120129f, 
    0.02643456f, 0.00584759f, 0.01193435f, 0.01305034f, -0.00884078f, 0.01167234f, -0.00200026f, -0.00469613f, 
    -0.01876852f, -0.04196467f, -0.01380073f, -0.01230336f, 0.01004695f, 0.01893441f, -0.03122390f, -0.02112509f, 
    -0.00810305f, -0.00594962f, 0.02107561f, 0.02173909f, 0.03099699f, 0.02171337f, 0.03372753f, -0.02272085f, 
    -0.04382388f, -0.03140699f, -0.02915992f, 0.00224370f, -0.00103982f, -0.03068142f, -0.03387656f, 0.00573894f, 
    -0.04003823f, 0.04341979f, 0.00384732f, -0.03474659f, 0.00875727f, 0.02859299f, -0.00741365f, 0.02465030f, 
    -0.02772265f, -0.04099825f, -0.02267213f, -0.00946079f, -0.02371895f, 0.00533916f, -0.01331251f, 0.00500869f, 
    0.01566265f, -0.02539448f, 0.02878318f, 0.02280129f, -0.00368164f, 0.03406110f, -0.04697801f, 0.01277037f, 
    0.00903076f, -0.03072023f, 0.02605228f, 0.02781071f, -0.01679266f, -0.04553176f, 0.00635452f, -0.02803334f, 
    0.01239620f, 0.00834635f, -0.03826955f, 0.00937006f, 0.00960126f, 0.02184705f, -0.03411223f, -0.04895284f, 
    0.00942877f, -0.03636325f, -0.03067956f, -0.01489304f, 0.00135363f, -0.03862245f, 0.00590021f, -0.03763132f, 
    0.01742275f, 0.02450408f, 0.01292325f, -0.03564697f, -0.00824258f, -0.02517135f, -0.03814470f, 0.03410121f, 
    -0.00114281f, 0.00631239f, 0.03197017f, -0.02402833f, -0.01479197f, -0.03147119f, -0.01773147f, -0.01579079f, 
    -0.00930335f, 0.02113314f, -0.03579044f, 0.00842931f, 0.01951467f, 0.00485275f, 0.00064997f, -0.03822678f, 
    -0.01454545f, -0.01032794f, 0.00013448f, 0.03052548f, 0.00841526f, 0.02782564f, 0.03148107f, -0.03042098f, 
    0.01434416f, -0.02908633f, 0.02278913f, 0.02225695f, -0.01524602f, 0.02844288f, -0.02485371f, -0.02157528f, 
    0.00397118f, 0.01017718f, -0.02980315f, -0.04634052f, 0.00928372f, -0.03083758f, 0.03331301f, -0.03918208f, 
    -0.00717065f, -0.03783761f, -0.03851489f, 0.02935934f, -0.02694121f, 0.01514096f, -0.00996399f, 0.00475969f, 
    -0.03494188f, -0.01330223f, 0.01504094f, 0.01240451f, -0.00648451f, -0.01665288f, 0.02923969f, 0.02514884f, 
    -0.04572217f, -0.04455705f, -0.01419221f, 0.00700880f, 0.00583513f, -0.03574361f, -0.02460526f, -0.03797491f, 
    -0.01234720f, 0.02220875f, 0.00178457f, -0.01079719f, 0.01496870f, -0.04590856f, -0.03774182f, -0.04594629f, 
    -0.03358051f, 0.02304535f, -0.01308621f, 0.01237354f, -0.00609078f, -0.00051819f, -0.02521304f, -0.01236852f, 
    -0.02457267f, -0.00222893f, -0.01881347f, -0.02930880f, -0.02856359f, 0.02021804f, 0.02802977f, -0.04737033f, 
    -0.00256877f, 0.03171438f, 0.01497462f, 0.01617387f, -0.02591323f, -0.01873960f, -0.00548141f, 0.02801987f, 
    -0.03045201f, -0.00416531f, -0.01766429f, -0.00129159f, -0.01984816f, -0.03590439f, 0.00311939f, -0.04527564f, 
    0.00234850f, -0.03809535f, 0.01891379f, -0.03991196f, -0.02339595f, 0.01072487f, -0.03925219f, -0.03147074f, 
    -0.04397391f, 0.00894101f, -0.04216181f, 0.02008085f, 0.02247101f, -0.02467734f, 0.00214950f, -0.03151629f, 
    0.02682951f, 0.00253193f, -0.03008712f, 0.03395557f, 0.01579770f, 0.03229833f, 0.01739506f, -0.01493634f, 
    0.02670379f, -0.01775134f, 0.00497838f, 0.01060956f, -0.02359957f, 0.02547692f, -0.02378543f, -0.04360826f, 
    -0.00734450f, 0.01669184f, 0.01033157f, -0.01598129f, -0.04758189f, -0.04556588f, -0.01578958f, -0.03297343f, 
    0.01091675f, -0.03533707f, 0.02035878f, -0.00192880f, 0.00848140f, -0.01910941f, -0.02192809f, -0.01705224f, 
    -0.03642196f, 0.00080275f, -0.03169552f, 0.01997807f, -0.00542437f, 0.01150087f, -0.02227551f, 0.02444559f, 
    -0.04721685f, 0.00917593f, 0.00717975f, -0.01167794f, 0.00188310f, -0.01381482f, -0.03332990f, -0.03388866f, 
    -0.02122685f, 0.02801057f, 0.02998713f, -0.02147979f, 0.01145244f, 0.00596620f, -0.02175142f, -0.00323585f, 
    0.01259370f, -0.01495728f, -0.02599800f, -0.00908691f, -0.00074117f, -0.04041974f, -0.00334602f, 0.00589991f, 
    -0.03834966f, -0.03800334f, 0.01205822f, 0.01285994f, -0.02136866f, -0.01586424f, -0.02082299f, 0.01498073f, 
    -0.02155992f, 0.01759243f, -0.02844685f, -0.02679440f, -0.04545078f, -0.00997043f, 0.00665640f, -0.01972677f, 
    -0.01147431f, 0.00621440f, -0.00588301f, -0.03381725f, -0.00447829f, -0.04954625f, -0.04888262f, 0.03399227f, 
    0.02014797f, -0.00183998f, 0.00294528f, 0.03561366f, -0.01759633f, 0.00960791f, -0.02989233f, -0.02142929f, 
    0.00670618f, -0.01648396f, -0.01124638f, 0.02540667f, 0.00705145f, 0.01751275f, -0.02020217f, 0.02214965f, 
    -0.03074655f, -0.01708936f, 0.01140836f, -0.04057860f, -0.02382521f, 0.00274445f, 0.00172169f, -0.00463166f, 
    -0.02180241f, -0.04039799f, 0.02949532f, -0.00937760f, 0.00323065f, 0.02848685f, -0.00586161f, 0.01381707f, 
    -0.01416132f, 0.01388760f, 0.00571061f, -0.03018935f, 0.00649788f, -0.03387327f, -0.01634306f, -0.00357916f, 
    -0.03190171f, -0.01338894f, -0.03386533f, -0.00466699f, -0.01164658f, -0.01660054f, 0.00961574f, -0.00318637f, 
    0.01065500f, 0.02516689f, -0.04447180f, -0.00518685f, -0.01326985f, 0.02718074f, -0.02338743f, 0.01478566f, 
    0.02679620f, -0.01384500f, -0.03409965f, 0.01409908f, -0.00662362f, 0.00024295f, 0.02185760f, -0.03121704f, 
    0.01226037f, 0.00436264f, -0.02554067f, -0.03691129f, -0.00538218f, 0.00295317f, -0.01562196f, -0.00385079f, 
    -0.02725171f, 0.00326576f, 0.00936157f, -0.03812326f, -0.01634301f, 0.01652711f, -0.00039421f, 0.03109496f, 
    -0.00787051f, -0.00272014f, -0.00596010f, 0.02507812f, 0.02797478f, -0.01601830f, 0.00242059f, 0.01893606f, 
    0.01446748f, -0.04301244f, -0.02927139f, 0.01338204f, 0.02476277f, 0.02937159f, 0.00767967f, 0.00678805f, 
    0.00305044f, -0.00633373f, 0.03918477f, 0.03056437f, -0.02008040f, -0.02161481f, 0.03449402f, -0.03224123f, 
    0.01043068f, -0.01823373f, -0.02458714f, 0.01299935f, 0.00141856f, -0.00410743f, -0.00319360f, 0.00922801f, 
    -0.00359145f, 0.01346640f, -0.01090464f, 0.01146149f, 0.03404240f, -0.01430479f, 0.01216727f, -0.01814012f, 
    0.01792593f, 0.00738414f, 0.00974891f, 0.02742575f, -0.01275294f, 0.02788766f, -0.00462420f, 0.02219323f, 
    -0.02565833f, -0.01206964f, -0.02979326f, -0.00135376f, -0.01430800f, -0.02638946f, 0.02628790f, 0.01282157f, 
    0.02595585f, -0.02404134f, -0.04377534f, -0.01598261f, -0.03886254f, 0.00628626f, -0.01432039f, -0.00884587f, 
    0.02457066f, -0.02106894f, -0.03730719f, -0.03599670f, -0.02494437f, -0.02900507f, 0.01525356f, -0.03570500f, 
    -0.00236432f, -0.00851084f, -0.04044116f, -0.00172929f, -0.00360594f, -0.00103071f, -0.02611132f, -0.01299028f, 
    0.03775574f, -0.00233306f, 0.03375923f, -0.03147779f, 0.02052983f, 0.01328345f, -0.00982887f, 0.00957273f, 
    0.01063224f, 0.03349024f, -0.03086260f, 0.00144368f, 0.03667481f, 0.01304057f, 0.02482088f, 0.02600081f, 
    0.01783559f, -0.03906760f, -0.01558067f, -0.03869827f, 0.03294742f, -0.02739995f, 0.00788167f, 0.01345918f, 
    -0.02165706f, -0.00619804f, -0.01796549f, -0.04001281f, 0.01020875f, -0.02118573f, -0.01892044f, 0.02629759f, 
    0.01842509f, -0.01637908f, -0.02584510f, -0.03564311f, -0.00893679f, 0.02309167f, 0.00323857f, -0.01517516f, 
    -0.01841899f, 0.02744886f, 0.02595825f, -0.02310452f, -0.00654253f, 0.02447188f, 0.03413252f, 0.00248436f, 
    -0.03078772f, 0.00976988f, -0.00457161f, -0.03202989f, -0.04046817f, -0.03292369f, -0.01579090f, -0.03901478f, 
    0.02501356f, 0.01180663f, 0.02304745f, -0.03785652f, -0.00916867f, -0.04043246f, 0.01234400f, 0.00114975f, 
    -0.01836712f, 0.00672096f, 0.00702287f, -0.03217508f, -0.03129411f, -0.01477036f, 0.00902988f, -0.04125170f, 
    -0.02089714f, -0.02976372f, -0.03716281f, -0.03712419f, 0.02367652f, -0.00714120f, -0.02839598f, -0.01569828f, 
    -0.03081034f, 0.00218046f, -0.03804563f, -0.03801344f, 0.01525274f, 0.02069261f, 0.00655058f, 0.00298337f, 
    0.00538366f, 0.01190773f, 0.00821698f, 0.00429225f, -0.03192412f, -0.02048374f, 0.03546991f, 0.02497436f, 
    0.03519833f, -0.01144033f, -0.01447528f, 0.03528544f, -0.02310372f, -0.03896312f, 0.00092855f, -0.03591976f, 
    -0.02524923f, -0.02609558f, -0.01345490f, -0.00838159f, 0.02543797f, -0.00004822f, -0.04425833f, 0.01402181f, 
    -0.02292924f, 0.01182451f, -0.04461563f, 0.01314995f, -0.02117727f, -0.00799451f, 0.02868223f, 0.02693769f, 
    0.02343086f, 0.01914546f, -0.04624412f, -0.04507817f, -0.03510230f, -0.01946850f, -0.02326041f, -0.01856282f, 
    -0.02669818f, -0.02571185f, 0.01545862f, -0.03949682f, -0.03404479f, 0.01138563f, 0.01778283f, 0.01016679f, 
    -0.01970300f, 0.02570889f, 0.01389442f, 0.02497843f, -0.01821699f, -0.03075854f, 0.01903831f, -0.04518291f, 
    -0.03698610f, 0.00648165f, -0.01300350f, 0.02354964f, -0.03895173f, -0.03970831f, -0.04572929f, -0.00596881f, 
    -0.04469907f, 0.02205953f, 0.02675212f, 0.00235335f, -0.02727432f, -0.03113762f, -0.03854243f, 0.00182605f, 
    0.00914111f, -0.03299351f, 0.01396215f, 0.00722438f, -0.03066062f, 0.01714043f, 0.02304453f, -0.00242768f, 
    0.00069868f, -0.00712254f, -0.02743405f, 0.02052462f, -0.02011531f, -0.00853078f, -0.01516018f, 0.01663967f, 
    0.01458152f, 0.01466977f, -0.02335768f, -0.00451737f, -0.04416449f, -0.01788375f, 0.03121414f, -0.04667167f, 
    -0.02471333f, 0.03343140f, -0.00671183f, 0.00118111f, -0.03832626f, 0.00162755f, -0.02760517f, 0.02645126f, 
    -0.01132918f, 0.00002560f, 0.02144919f, -0.04575862f, -0.00248506f, 0.00177554f, 0.01410518f, -0.02682487f, 
    0.02006762f, -0.03386959f, -0.03921623f, -0.00452051f, -0.01292752f, -0.02250899f, -0.03430717f, -0.00091548f, 
    0.03155002f, -0.04687370f, -0.03894213f, -0.03597077f, 0.02455051f, 0.01380943f, 0.03070252f, -0.01586585f, 
    0.02301243f, -0.00588748f, -0.00957895f, 0.01503293f, 0.03160623f, -0.03554736f, -0.01420218f, -0.02742728f, 
    -0.03022113f, -0.02505748f, -0.01045819f, 0.00625546f, 0.01523354f, 0.02889166f, -0.02705015f, -0.02645255f, 
    -0.00977156f, 0.03160831f, -0.00854788f, -0.02375002f, 0.02168352f, -0.03310218f, 0.00482863f, 0.00415478f, 
    0.00348492f, 0.02209255f, -0.01437824f, 0.02490986f, -0.00985168f, 0.00333619f, -0.02835890f, -0.00811154f, 
    -0.00338199f, -0.04719147f, 0.00432816f, 0.02250105f, -0.00941963f, 0.01825771f, 0.00560581f, -0.02782205f, 
    -0.02664642f, -0.02013211f, -0.00641164f, -0.04554793f, -0.01573303f, 0.00591221f, 0.01738331f, 0.01236537f, 
    0.03066202f, 0.00993325f, 0.03258113f, -0.03145460f, -0.03828484f, -0.01895035f, 0.02959548f, -0.02707612f, 
    0.00003587f, -0.01411695f, -0.02952321f, 0.01421849f, -0.03350484f, -0.02995503f, 0.02515782f, -0.03241518f, 
    0.02766353f, 0.01381877f, 0.01007427f, -0.00827987f, -0.02335869f, 0.02741906f, -0.02496296f, -0.04542601f, 
    0.02986597f, -0.01757816f, -0.00542825f, -0.03057065f, 0.00701387f, -0.03882842f, 0.01779395f, -0.02403162f, 
    0.03118639f, -0.03685101f, 0.02293531f, 0.02809426f, 0.00683877f, -0.02000785f, -0.01961246f, -0.01307818f, 
    0.00942847f, 0.00028867f, 0.00251695f, -0.04629585f, 0.00123352f, -0.02957180f, -0.03209176f, 0.01219717f, 
    0.00883801f, 0.03021374f, -0.02279652f, -0.03509122f, -0.00769977f, -0.00611715f, 0.01212071f, -0.02822614f, 
    0.01236112f, -0.04454078f, -0.01172009f, -0.03883000f, 0.00095316f, -0.03160079f, 0.03274900f, 0.02641294f, 
    0.00879727f, -0.02421629f, 0.02002732f, 0.02218123f, 0.02098492f, -0.00533550f, 0.00557328f, 0.01796627f, 
    -0.04332363f, -0.02332325f, -0.02371621f, -0.03811744f, -0.04181409f, -0.02132599f, 0.01539835f, -0.03753478f, 
    0.02663865f, -0.03711159f, -0.00708325f, -0.01804674f, -0.03115852f, -0.00136591f, -0.03427638f, 0.00428089f, 
    0.02253255f, -0.03529213f, 0.00417617f, -0.01338703f, -0.02726679f, 0.03398022f, 0.00417518f, -0.00362401f, 
    -0.02112308f, -0.01667163f, -0.02874805f, -0.03887108f, -0.01718980f, -0.01207049f, 0.02480355f, -0.02961728f, 
    -0.01107670f, -0.02387531f, 0.00177188f, -0.04257012f, 0.03074028f, -0.00348811f, -0.03753863f, -0.03044571f, 
    -0.02635708f, -0.04774815f, -0.03366126f, 0.02209143f, -0.02045687f, -0.01727509f, -0.01988464f, 0.02465171f, 
    -0.01836154f, -0.03796971f, -0.01294638f, -0.01670985f, -0.00517125f, 0.00537041f, 0.00101781f, 0.01139732f, 
    -0.02062370f, -0.02676611f, 0.00587347f, -0.03807635f, 0.02009935f, 0.03432408f, 0.02860240f, -0.00206124f, 
    0.01321894f, -0.00375571f, -0.01031602f, 0.02730264f, 0.00987269f, 0.00497216f, 0.00491687f, 0.02669219f, 
    -0.00051692f, -0.01199634f, -0.01008963f, -0.04517486f, -0.03716444f, -0.04014743f, 0.01436170f, -0.02181123f, 
    -0.03687697f, -0.03764429f, 0.00587438f, 0.01403610f, -0.01545578f, -0.03083316f, -0.03471860f, 0.02438318f, 
    -0.03463065f, -0.03487676f, 0.00552545f, -0.00475890f, -0.04640769f, -0.04057270f, 0.01398679f, -0.00114062f, 
    0.01406100f, -0.02734433f, 0.02553033f, 0.01844569f, 0.00021837f, 0.02546661f, -0.02261832f, 0.02436344f, 
    -0.00507175f, -0.03144347f, 0.00115090f, -0.03577578f, -0.01198977f, 0.01566271f, 0.00979076f, -0.03473756f, 
    -0.00372353f, 0.02612770f, 0.03140345f, -0.04329612f, -0.03873995f, -0.01869666f, -0.01892265f, 0.02288643f, 
    -0.00926784f, -0.01323360f, 0.03310928f, 0.02363217f, 0.01214249f, 0.01798267f, 0.02061107f, 0.02179476f, 
    0.02214939f, -0.00455518f, 0.01088723f, 0.00741406f, -0.02503999f, -0.04725552f, -0.02201968f, -0.01451485f, 
    -0.01784404f, -0.02698860f, -0.02136762f, 0.02630068f, 0.01531489f, -0.00288450f, 0.01908598f, -0.04084158f, 
    -0.03636810f, -0.03886532f, -0.02248997f, -0.01215857f, -0.03544316f, -0.04049006f, 0.02004616f, -0.03026976f, 
    0.02500225f, -0.00440963f, 0.02620008f, 0.02775799f, 0.02041485f, 0.01317365f, -0.02222421f, -0.04447783f, 
    -0.01452167f, -0.02675332f, 0.00749804f, -0.04190130f, -0.04391978f, -0.03293178f, -0.00956203f, 0.00535300f, 
    -0.03574242f, -0.01558483f, -0.00484292f, 0.01831556f, -0.03548338f, 0.02301087f, -0.01152983f, 0.01098880f, 
    0.01607274f, -0.02837228f, -0.00153503f, 0.02089844f, -0.02768364f, -0.00052083f, -0.01809446f, 0.02764360f, 
    -0.04091436f, 0.01611380f, 0.02971190f, -0.04530881f, -0.01151578f, -0.02057367f, 0.02593318f, 0.03013684f, 
    0.01803942f, 0.00959652f, -0.01886271f, 0.01302514f, 0.01104018f, 0.01152911f, 0.00331630f, -0.02776278f, 
    -0.01404863f, 0.00233270f, 0.00597497f, 0.01576612f, -0.04225506f, 0.02443569f, -0.02051143f, -0.00309323f, 
    0.02192503f, 0.01509967f, -0.01158022f, 0.00123076f, -0.03651669f, 0.01438605f, 0.00744819f, -0.00540086f, 
    -0.00392941f, -0.02699047f, 0.01223851f, 0.01009746f, -0.03763976f, 0.00593222f, -0.04250104f, -0.04307899f, 
    -0.02464428f, 0.02799291f, 0.01438193f, 0.00037757f, -0.03379251f, -0.04384724f, -0.01239476f, -0.04360699f, 
    0.00138689f, 0.02188286f, 0.01319410f, 0.03154780f, -0.00705674f, 0.02010908f, 0.00791236f, 0.01400208f, 
    0.03161965f, -0.01709894f, -0.02975750f, -0.00910072f, 0.00796822f, -0.00958109f, 0.00101608f, -0.00831733f, 
    -0.00267011f, -0.04419057f, -0.00280012f, -0.04574483f, 0.00941340f, 0.03049043f, -0.01380569f, 0.00012569f, 
    0.01095258f, -0.03760028f, 0.02673258f, -0.02907708f, -0.03708443f, -0.03159488f, 0.02757515f, -0.02094349f, 
    0.02021931f, -0.01097507f, -0.02576952f, 0.02033386f, -0.03261909f, 0.02777399f, -0.00172311f, 0.00819806f, 
    0.03095609f, -0.01444056f, 0.00768749f, 0.00807021f, 0.00400855f, 0.01727602f, -0.01786941f, 0.02631336f, 
    -0.00652416f, 0.00867659f, 0.01783973f, 0.03180924f, 0.02664782f, -0.01165948f, 0.01270852f, 0.02198614f, 
    0.02617395f, 0.00421569f, 0.02497819f, -0.00092724f, -0.02360538f, -0.04276611f, -0.04157831f, 0.00405606f, 
    -0.00709728f, 0.00144706f, 0.00693965f, 0.02808528f, 0.01505670f, -0.00090749f, -0.02570969f, 0.03150665f, 
    -0.00469883f, 0.01521192f, 0.03216002f, -0.03089361f, -0.04399470f, 0.00647128f, -0.02055404f, 0.01336492f, 
    0.02010548f, -0.03203337f, -0.00810283f, -0.03746345f, 0.00147708f, 0.01861958f, 0.02821708f, 0.00242726f, 
    0.00989153f, -0.03191132f, 0.01858662f, -0.00731128f, -0.00320164f, -0.00895459f, -0.03239561f, 0.01560574f, 
    -0.00253331f, 0.01607408f, -0.03858171f, -0.01626450f, -0.02910171f, -0.03931999f, -0.02889720f, -0.04381447f, 
    -0.04063496f, -0.00761421f, 0.02801424f, 0.00540604f, 0.01993090f, -0.03379558f, -0.00149181f, 0.03011976f, 
    -0.02052167f, 0.01078990f, -0.00608340f, 0.02477791f, -0.00240917f, -0.02042162f, 0.02941909f, 0.00037743f, 
    0.02239847f, -0.04256042f, 0.01826981f, 0.00054962f, -0.00736075f, 0.02628919f, 0.02617009f, -0.02183754f, 
    0.00818355f, 0.03457645f, -0.02151539f, -0.03757328f, -0.01609449f, -0.03261575f, -0.04319493f, -0.03969753f, 
    -0.04424776f, 0.03103303f, -0.00952256f, 0.01892610f, 0.02326792f, -0.02218440f, -0.01044740f, -0.04519838f, 
    0.00558639f, 0.04202182f, -0.02082848f, -0.01279570f, 0.01607253f, 0.00366365f, -0.04496892f, 0.01953181f, 
    0.01157335f, -0.03828498f, 0.01502961f, -0.00434749f, -0.03231339f, -0.02791714f, 0.00463729f, -0.04150518f, 
    -0.03515367f, -0.02683694f, -0.03090351f, 0.02872025f, 0.03371003f, -0.00849091f, 0.02745791f, 0.02299797f, 
    0.02634476f, 0.00571776f, -0.02876302f, -0.00087762f, -0.00349763f, -0.03679661f, 0.00499483f, -0.01944125f, 
    -0.03999013f, -0.00778457f, 0.00008243f, 0.01965464f, -0.00581612f, 0.03436203f, -0.00860518f, 0.01258366f, 
    -0.04420380f, 0.03180806f, -0.03469704f, 0.02365110f, -0.03240520f, 0.00371953f, -0.00260614f, -0.01552050f, 
    0.03071211f, -0.03277576f, -0.01225349f, -0.03307483f, 0.00207751f, 0.00839574f, 0.01747301f, 0.03085972f, 
    -0.02012880f, 0.00285059f, -0.01498539f, -0.00692876f, -0.00941527f, 0.02129865f, -0.01411852f, -0.04402291f, 
    -0.03894041f, 0.01411020f, -0.03337890f, 0.00989284f, -0.02984262f, 0.02123929f, 0.01802231f, 0.03155261f, 
    -0.03806816f, -0.03774886f, 0.00239448f, -0.03422813f, 0.00065188f, -0.01194882f, 0.00486750f, -0.00155052f, 
    0.03421174f, 0.00275006f, 0.01163039f, 0.00419076f, -0.01659362f, 0.00102001f, -0.01837810f, -0.03150690f, 
    -0.02103702f, -0.03970901f, -0.02127536f, 0.01402518f, -0.03329130f, 0.02407233f, 0.00266539f, 0.00405651f, 
    -0.00124417f, 0.00808336f, -0.02754102f, -0.02406149f, -0.03506044f, -0.01726016f, -0.01726893f, 0.01589351f, 
    0.02737265f, -0.01143673f, -0.02385356f, 0.00993386f, -0.01115943f, -0.02753858f, -0.03371377f, -0.04161577f, 
    -0.02521673f, 0.25782359f, 0.27765542f, -0.37791902f, -0.09653392f, -0.00659900f, -0.20250197f, 0.04072521f, 
    -0.00539522f, -0.02537634f, -0.00295464f, -0.01848472f, 0.11827607f, -0.01423292f, 0.08521942f, 0.04743604f, 
    0.09531654f, 0.14726244f, -0.01844480f, 0.09209608f, 0.14077500f, 0.36561117f, 0.34604582f, -0.08528651f, 
    0.00952945f, 0.05773446f, 0.07883550f, 0.06179658f, -0.00683963f, 0.03460348f, -0.04168963f, -0.01427120f, 
    0.08110069f, 0.07429850f, 0.16495104f, 0.06579293f, 0.05529476f, 0.07384174f, 0.15343432f, 0.19242078f, 
    -0.05690462f, 0.25743163f, 0.19534808f, 0.01304443f, -0.35705388f, -0.19338731f, -0.08049127f, -0.18608171f, 
    -0.06087002f, -0.03531751f, -0.03847250f, 0.02811932f, -0.00617514f, -0.02939896f, -0.07534171f, 0.03726468f, 
    0.02495837f, 0.07252621f, 0.12806714f, 0.00517640f, 0.27730784f, 0.12726349f, 0.27628565f, -0.00490156f, 
    -0.07862815f, -0.08130733f, -0.11802047f, -0.08179197f, -0.02205330f, -0.00975465f, -0.00157443f, 0.04406994f, 
    -0.00683494f, -0.05971358f, -0.02805869f, -0.09206835f, 0.03103205f, 0.22455269f, 0.18759361f, -0.06194433f, 
    0.34586310f, 0.05436376f, 0.23090993f, 0.06700611f, 0.14836919f, -0.08652844f, -0.02614266f, -0.09842087f, 
    -0.08410107f, -0.06117578f, -0.04093805f, 0.03547024f, 0.01647442f, -0.05033295f, -0.04277013f, -0.01753807f, 
    0.12448972f, -0.11890152f, -0.04652750f, -0.03903309f, 0.19732571f, -0.20455204f, 0.30674946f, 0.10838302f, 
    0.16369615f, 0.03800166f, 0.06812560f, -0.19626470f, 0.15968393f, 0.01038468f, -0.08642881f, 0.07152272f, 
    -0.18985192f, 0.12862155f, -0.02957872f, -0.08066990f, 0.05032522f, -0.05763128f, 0.05171607f, -0.15143247f, 
    0.20001410f, -0.12024890f, 0.44973269f, 0.02277811f, 0.04707123f, -0.01406039f, 0.03643664f, -0.21608554f, 
    -0.00218089f, 0.04773748f, -0.08745952f, -0.00475965f, -0.05769083f, 0.10258649f, 0.03359050f, 0.00946293f, 
    -0.01507124f, -0.03094401f, -0.05547869f, 0.00466997f, -0.00720790f, 0.14459123f, -0.35780358f, -0.16047233f, 
    -0.08392770f, 0.13357592f, -0.00972649f, 0.14034396f, -0.14999996f, 0.04949925f, 0.01284759f, 0.02926962f, 
    0.16090986f, 0.13466342f, 0.11887422f, 0.13634655f, 0.01693388f, 0.11964130f, 0.12541060f, -0.05602054f, 
    0.57202178f, 0.15613037f, -0.17978173f, 0.51413631f, -0.16188824f, -0.01589133f, 0.00589356f, -0.12527642f, 
    0.03390926f, 0.00603632f, 0.07040554f, -0.03024235f, -0.11008140f, 0.07093491f, -0.05968956f, 0.11128025f, 
    -0.05662615f, 0.21344000f, 0.20046110f, 0.07681166f, 0.09059153f, -0.00556292f, -0.45688057f, 0.15641834f, 
    -0.01425271f, -0.06382515f, -0.01069353f, 0.14685848f, 0.01927196f, 0.14391162f, 0.10932980f, 0.03673956f, 
    -0.11658273f, -0.00437413f, 0.03654547f, -0.00635954f, -0.09484141f, -0.14449582f, 0.00249206f, 0.07540758f, 
    0.09378818f, 0.12811136f, 0.05264369f, 0.17001976f, -0.03174334f, -0.00789961f, -0.03625146f, -0.15802974f, 
    -0.02399846f, -0.02892123f, -0.12577218f, -0.02125058f, -0.04462066f, 0.12809503f, -0.07434132f, 0.05839988f, 
    0.00368150f, -0.15498957f, -0.10121310f, -0.11301456f, 0.15574577f, 0.23123801f, 0.12844907f, -0.00002546f, 
    -0.11587711f, 0.15378459f, 0.07326841f, -0.00771237f, -0.01947389f, 0.01869409f, -0.01756691f, 0.02961497f, 
    0.06784215f, 0.04579471f, 0.17625307f, 0.09605335f, -0.08409374f, -0.09666967f, 0.16007788f, 0.05993538f, 
    -0.08908021f, -0.20248127f, 0.01900083f, -0.05074482f, -0.07455835f, -0.01610775f, -0.00056061f, -0.22794218f, 
    0.14091741f, 0.02760316f, 0.00482443f, 0.10460318f, -0.15515837f, 0.12760139f, -0.09287599f, -0.05332159f, 
    -0.00226713f, -0.18905628f, -0.00571331f, 0.08128317f, 0.12759586f, -0.15283829f, 0.05796767f, -0.12228779f, 
    0.17976026f, -0.01515002f, -0.03199475f, -0.03120159f, 0.01056349f, -0.07079352f, -0.06203824f, -0.00146699f, 
    0.05540624f, -0.02747278f, 0.06275639f, 0.13347051f, -0.01130777f, -0.04671225f, -0.03011104f, -0.19430447f, 
    0.01849842f, 0.17631677f, 0.21254803f, -0.32815042f, 0.07705358f, 0.01415770f, -0.11920185f, -0.07374372f, 
    0.16545397f, 0.04303592f, 0.04939145f, -0.00185937f, 0.07857905f, -0.04263873f, 0.06855590f, -0.02637927f, 
    -0.06777450f, 0.08723351f, -0.21956785f, 0.07328415f, -0.17158470f, -0.46428680f, 0.06410366f, -0.33480352f, 
    0.19945237f, 0.15024747f, 0.15705736f, 0.19476926f, 0.04312703f, 0.09264208f, 0.00782254f, -0.02792273f, 
    0.02963544f, 0.19191261f, 0.10794034f, -0.01103059f, 0.11056513f, 0.05964012f, -0.00981667f, -0.03804842f, 
    0.23593058f, 0.21447054f, 0.21684605f, -0.22396943f, 0.12713531f, 0.02713003f, 0.08081542f, 0.01379039f, 
    -0.05217880f, -0.09278468f, -0.03895137f, 0.01496253f, 0.02439567f, -0.01297339f, -0.03271179f, 0.09997213f, 
    0.06605827f, 0.13516836f, -0.01877009f, 0.04477349f, 0.19582990f, -0.00239452f, -0.06271712f, 0.06501687f, 
    -0.06610982f, 0.04206207f, 0.01356551f, -0.01107006f, 0.05524950f, 0.00542097f, -0.04377157f, -0.12942752f, 
    0.03312739f, -0.06281631f, 0.07037108f, 0.07314844f, 0.05775957f, -0.02804866f, -0.01921744f, 0.02814734f, 
    0.29392552f, -0.04339217f, 0.04953186f, 0.02304638f, 0.16321264f, -0.05538090f, -0.05287196f, -0.12610541f, 
    -0.03751460f, -0.04808414f, -0.11052004f, -0.05078345f, 0.03924922f, -0.04412590f, -0.01300678f, 0.13107386f, 
    0.04964933f, -0.13283667f, 0.03869146f, -0.16209404f, 0.00832930f, -0.04366717f, -0.19138658f, 0.04083074f, 
    0.08226202f, 0.00242664f, -0.02340880f, -0.02701198f, -0.00351923f, -0.08179411f, -0.06531537f, 0.03378494f, 
    -0.00922001f, 0.17792879f, 0.11719490f, -0.11305602f, -0.10720060f, -0.12483225f, -0.08271635f, -0.08000667f, 
    -0.38176459f, -0.17675719f, -0.34293976f, -0.10784850f, -0.03898353f, -0.02520679f, -0.05530896f, 0.06140458f, 
    0.04944642f, -0.00580284f, -0.10415387f, 0.12236358f, -0.04426001f, -0.02435226f, 0.01347660f, -0.09139377f, 
    -0.06257206f, -0.04994814f, -0.07363423f, -0.08978850f, -0.33911049f, -0.21811652f, 0.60428822f, -0.36412328f, 
    0.19845754f, 0.27060458f, 0.19054545f, -0.03253990f, 0.17754725f, 0.09537143f, 0.10159364f, 0.01557312f, 
    -0.03194430f, 0.01766584f, 0.15003662f, 0.05565920f, 0.27715877f, 0.11428776f, -0.07959088f, 0.10146732f, 
    -0.04241969f, 0.08183918f, -0.06124760f, 0.17399895f, -0.09810831f, -0.06706820f, 0.08147778f, -0.06383012f, 
    0.11511146f, -0.04854782f, -0.11025281f, 0.13944371f, 0.07215238f, 0.02538940f, 0.02205029f, 0.09784935f, 
    -0.06260396f, 0.02361954f, 0.05364932f, -0.09605622f, 0.14430104f, 0.25801465f, 0.13030836f, -0.12715416f, 
    -0.02035972f, 0.14149116f, 0.09571144f, -0.12781347f, -0.30767593f, -0.01508855f, -0.01682463f, -0.02410310f, 
    0.06784185f, -0.04238863f, 0.00358395f, 0.02368386f, 0.01923535f, 0.06064454f, -0.07446891f, 0.01271687f, 
    0.13300832f, -0.16580129f, -0.16526662f, 0.03191939f, -0.04035795f, -0.14588751f, 0.00514567f, 0.05650327f, 
    0.05360370f, -0.10002042f, -0.05709130f, 0.02535091f, -0.03977954f, -0.17245321f, -0.03974687f, -0.15174319f, 
    -0.08649555f, 0.02853398f, -0.09840605f, -0.09516153f, 0.16040422f, 0.23386207f, 0.10432421f, 0.03368690f, 
    -0.12955205f, 0.16189599f, 0.05164941f, 0.04131054f, -0.04012180f, 0.06488814f, -0.03567582f, -0.02725930f, 
    0.07740964f, -0.03408319f, 0.15257841f, 0.16623792f, -0.00283724f, 0.03284196f, 0.16410854f, 0.04230724f, 
    0.13578676f, 0.05389785f, -0.09155550f, -0.15935218f, -0.05506649f, 0.01965726f, -0.07514109f, -0.16211273f, 
    0.07016537f, -0.15881774f, 0.08813793f, 0.00094377f, -0.02410293f, 0.03610232f, -0.02868449f, -0.07619023f, 
    -0.09573267f, -0.01247019f, -0.17362770f, 0.09336517f, 0.11367746f, 0.07261253f, 0.34586301f, -0.04925585f, 
    0.03000472f, -0.01278603f, 0.00629830f, -0.04477620f, -0.12201121f, -0.02295219f, 0.06908036f, -0.01904506f, 
    -0.01841607f, -0.02186852f, -0.01406607f, 0.18371852f, 0.08991043f, 0.10432933f, -0.07482202f, -0.17712663f, 
    -0.09590703f, 0.03951836f, -0.21784738f, -0.18572009f, -0.12382241f, 0.04010734f, -0.02343948f, 0.11596306f, 
    -0.09493557f, -0.02220370f, -0.02282404f, -0.00068839f, 0.10227554f, -0.10288680f, 0.10583858f, 0.06761524f, 
    0.04771112f, -0.01116680f, -0.02931861f, 0.03873454f, 0.23240887f, 0.23788656f, 0.15515375f, -0.19069548f, 
    0.04264643f, 0.07824410f, 0.01752537f, 0.09760791f, -0.12755850f, -0.03322890f, -0.01235932f, -0.01479421f, 
    0.07871238f, -0.10550404f, 0.02758863f, 0.03123127f, -0.08946148f, 0.22707711f, -0.05432542f, -0.00887773f, 
    0.16388144f, 0.15979712f, 0.16257560f, 0.13506985f, -0.04784773f, -0.00366494f, 0.00333325f, -0.01872656f, 
    0.00383265f, 0.03519070f, -0.02026155f, 0.06046551f, 0.07705302f, 0.08071411f, 0.11931428f, -0.08930101f, 
    0.12303460f, 0.01959187f, 0.15753265f, 0.11759201f, 0.16675740f, 0.21961007f, -0.08162252f, -0.20470089f, 
    0.09872033f, -0.02111114f, 0.10656763f, 0.07251383f, -0.13264818f, -0.13592762f, 0.02772231f, 0.00206434f, 
    0.00551559f, -0.04820887f, -0.03197699f, -0.05233724f, -0.04176985f, -0.03933560f, -0.09263689f, -0.04043934f, 
    0.12056957f, 0.21212938f, -0.07266049f, -0.05893042f, 0.04423232f, -0.03640044f, -0.10936105f, -0.21082170f, 
    0.06631516f, 0.04545569f, -0.02218584f, -0.06318127f, 0.05345646f, -0.01609188f, -0.02447363f, 0.10636207f, 
    -0.08298656f, -0.07940229f, -0.05093320f, -0.12601219f, 0.33432668f, 0.28608817f, 0.05428585f, -0.12043227f, 
    -0.00627779f, 0.11338519f, 0.00030557f, -0.01082267f, 0.24386218f, 0.01547243f, 0.03778813f, -0.01937819f, 
    -0.00042837f, 0.01406335f, 0.09266978f, 0.09844881f, 0.07429627f, 0.02032910f, 0.04480205f, 0.04182607f, 
    -0.17124273f, 0.15053593f, -0.26923591f, 0.08382088f, -0.01796137f, 0.14080529f, -0.17473957f, 0.08266674f, 
    -0.24187061f, 0.21218970f, -0.01935256f, 0.03950817f, -0.01805922f, -0.16762830f, -0.01248782f, 0.05975344f, 
    0.10469685f, 0.14292121f, -0.03850120f, -0.12914528f, -0.00501905f, 0.11286834f, 0.14588548f, -0.02419321f, 
    0.05299575f, -0.12438945f, -0.01070013f, -0.05062856f, 0.01381745f, 0.01620460f, -0.02850405f, 0.00324613f, 
    -0.02550363f, 0.05790457f, -0.01494066f, 0.02538576f, 0.14470555f, 0.07533836f, -0.01971141f, -0.06501399f, 
    -0.08999208f, 0.28802848f, 0.08621004f, 0.12214147f, -0.03718192f, -0.07124793f, -0.23497242f, -0.05295629f, 
    -0.12204566f, -0.07949011f, 0.11575501f, 0.05951300f, 0.05284490f, 0.06696160f, -0.07047472f, 0.12654148f, 
    0.16507331f, -0.07935764f, -0.03923465f, -0.01253254f, -0.78394973f, 0.33163217f, 0.16321434f, 0.09873310f, 
    -0.03315292f, -0.02515671f, -0.12629136f, 0.01904645f, -0.03863853f, 0.03004221f, 0.03650299f, -0.02860470f, 
    0.03626185f, 0.26932946f, 0.01505310f, -0.09329623f, 0.06812351f, -0.00818218f, -0.01118467f, -0.00709157f, 
    0.05910875f, 0.13567311f, 0.13033409f, 0.00230795f, -0.05995662f, -0.01810781f, 0.14311400f, 0.08243538f, 
    -0.06920817f, -0.06999188f, 0.14122944f, -0.05813062f, 0.00186767f, 0.02217551f, -0.04944282f, 0.00290416f, 
    0.15047184f, -0.10461030f, 0.15811521f, 0.01719643f, 0.25212187f, -0.02554420f, 0.13092792f, 0.25828156f, 
    0.07681217f, -0.12666035f, -0.00854186f, -0.12868841f, 0.20323265f, -0.07546669f, 0.11579556f, -0.14213786f, 
    0.23345789f, -0.00125202f, 0.05527031f, 0.06352289f, -0.04661875f, -0.22773938f, 0.03265274f, -0.10944611f, 
    0.80252850f, -0.05318233f, 0.38548541f, 0.22121538f, -0.20647788f, -0.07428975f, -0.08358949f, 0.09901519f, 
    -0.06715664f, -0.00933913f, -0.01594220f, 0.05027055f, 0.03029162f, -0.00569141f, -0.03438733f, 0.02771955f, 
    -0.01576711f, -0.02685526f, 0.00857573f, 0.13592672f, -0.03326530f, -0.09438570f, -0.16842166f, -0.36581570f, 
    -0.18414494f, -0.05699430f, -0.04441324f, 0.12146027f, -0.02948015f, 0.12369662f, 0.09615277f, -0.00853097f, 
    -0.11371732f, 0.05711911f, 0.07979917f, -0.03371953f, 0.08986089f, -0.21903440f, 0.14498417f, 0.03363091f, 
    0.02316197f, 0.03532492f, -0.02047421f, 0.09391122f, 0.07179648f, -0.25167280f, -0.02221636f, -0.04661994f, 
    0.02315012f, -0.06035991f, 0.05891740f, 0.00469278f, 0.02750999f, 0.00932723f, -0.01494998f, 0.00994659f, 
    0.04041549f, -0.18594611f, 0.06673126f, -0.05799275f, 0.19478415f, 0.00391354f, 0.06067609f, 0.12372385f, 
    -0.17094365f, 0.02055339f, 0.02261466f, -0.03258748f, 0.10647719f, 0.01615430f, 0.03074315f, -0.04090698f, 
    0.00282618f, 0.01972634f, 0.12588458f, -0.04033937f, 0.02574201f, 0.04346503f, 0.06451161f, 0.17702335f, 
    -0.07344771f, -0.10830126f, -0.01934104f, -0.11243281f, -0.06665006f, 0.14776732f, 0.06090731f, -0.05921337f, 
    -0.05606037f, 0.07496531f, -0.09649542f, 0.14889461f, -0.07163346f, 0.05519316f, -0.01708116f, -0.15818571f, 
    -0.02258565f, -0.08790436f, 0.06663106f, 0.07643494f, -0.01341011f, 0.14694524f, 0.07343441f, 0.14740974f, 
    0.03807923f, -0.08467570f, -0.05610741f, 0.06437556f, -0.00142196f, -0.13881762f, 0.09817562f, 0.02679707f, 
    0.17574634f, 0.00565670f, 0.02543883f, 0.08195813f, -0.00600431f, -0.04184088f, -0.11561576f, 0.02227233f, 
    0.07361785f, 0.09202299f, -0.11773748f, -0.03500252f, 0.00087442f, 0.09916876f, 0.07065937f, -0.02023620f, 
    -0.07946690f, 0.21517530f, -0.09501135f, -0.07779534f, 0.02068326f, -0.02033940f, -0.02166114f, -0.12225010f, 
    -0.01354779f, 0.09290744f, 0.08926313f, -0.08988357f, 0.11096182f, 0.27706304f, 0.03175497f, 0.19852673f, 
    0.07017858f, 0.07010348f, 0.07965235f, -0.16566791f, 0.13142945f, -0.12203217f, 0.05504966f, 0.00753730f, 
    0.07507914f, -0.01373096f, 0.02619520f, 0.14795032f, -0.09708119f, -0.18687819f, 0.04065558f, -0.03055430f, 
    0.05997323f, 0.22156979f, -0.12905338f, 0.00253821f, -0.01927114f, 0.26962537f, -0.09581945f, 0.04982372f, 
    0.05081648f, -0.00598033f, -0.04164246f, 0.02633889f, -0.03163573f, 0.01714135f, 0.06997161f, 0.03737402f, 
    0.02810170f, 0.11836246f, -0.03677204f, 0.01286928f, 0.53635776f, -0.03363841f, 0.24357815f, 0.28198496f, 
    -0.03321778f, 0.08692592f, 0.10544179f, 0.08716737f, -0.03583112f, -0.15782878f, 0.13143593f, -0.10861756f, 
    0.02969417f, 0.00793512f, -0.00407302f, -0.00571461f, 0.11027697f, -0.05666449f, -0.05383608f, -0.07135312f, 
    -0.00729754f, 0.11013029f, 0.03938705f, 0.08491234f, 0.04982098f, -0.03986335f, -0.07241338f, 0.05298583f, 
    0.02150853f, -0.08738258f, 0.09595761f, 0.05828262f, 0.07176005f, -0.03749999f, -0.01989009f, 0.14643531f, 
    0.00391970f, -0.04772295f, -0.05784153f, 0.00925047f, 0.01206479f, 0.07311308f, 0.12711090f, 0.06528079f, 
    0.06356012f, -0.11373982f, -0.01880556f, -0.00209044f, -0.00803931f, -0.11289991f, 0.20962195f, -0.00825619f, 
    0.05409467f, 0.11675284f, 0.04346027f, -0.08681098f, -0.00783754f, -0.20329060f, -0.02683051f, -0.04019817f, 
    0.19483973f, -0.27268675f, -0.15259232f, -0.01515677f, -0.03220210f, 0.12254895f, 0.05210873f, 0.07107127f, 
    -0.09011294f, -0.08961112f, -0.06945319f, 0.04697292f, -0.01419432f, 0.09432811f, -0.02007876f, -0.04246159f, 
    -0.03427389f, -0.09636408f, -0.03015413f, -0.01843537f, -0.21548325f, 0.52475119f, -0.39310291f, -0.08860032f, 
    -0.01392904f, 0.09192487f, -0.01531797f, 0.03737075f, -0.01759782f, -0.13138419f, 0.15876931f, -0.01349245f, 
    0.00341640f, -0.01953322f, -0.04827400f, 0.06496345f, 0.05115723f, 0.00655575f, 0.00452802f, 0.16048288f, 
    -0.16901013f, 0.16073446f, 0.10430793f, -0.02881095f, 0.04836781f, -0.14005440f, -0.00157341f, -0.00371125f, 
    0.09605672f, -0.07360913f, 0.08258624f, 0.16215667f, 0.14233452f, -0.10084394f, 0.06243865f, 0.06301514f, 
    -0.01083349f, 0.09668984f, 0.14683107f, -0.05809670f, -0.05996766f, 0.05072372f, -0.34937900f, 0.00959013f, 
    0.08396131f, -0.11619854f, 0.22953492f, 0.05468504f, -0.13285364f, -0.13812029f, -0.02090924f, -0.09850898f, 
    0.01955676f, -0.05508555f, -0.01290551f, -0.07259290f, -0.01286721f, 0.04968638f, -0.22820018f, -0.06829512f, 
    0.04398344f, -0.11347267f, 0.24799983f, -0.13606918f, -0.08681283f, 0.01596411f, -0.05537793f, -0.01223806f, 
    -0.06790037f, -0.03300882f, 0.11397606f, 0.20376931f, -0.06189498f, 0.07175028f, 0.04389669f, -0.14119998f, 
    0.05940426f, 0.05197085f, -0.01397612f, 0.00355280f, 0.19324416f, -0.07800194f, 0.03680510f, 0.09493127f, 
    -0.12296765f, 0.00122301f, -0.03270737f, -0.00660678f, 0.04322379f, 0.11463763f, -0.03448116f, -0.06123718f, 
    0.02126380f, -0.00745784f, 0.10807018f, -0.05068411f, -0.04464274f, 0.10627431f, 0.00679665f, 0.06902682f, 
    0.10270780f, 0.08936251f, -0.30707484f, 0.17278376f, 0.03781387f, -0.03360589f, -0.08247172f, 0.08291426f, 
    0.24184395f, 0.10926519f, -0.06083218f, -0.04171193f, -0.04164401f, -0.01297962f, -0.05060212f, -0.01628478f, 
    -0.03136659f, 0.04687553f, 0.19392014f, 0.01543953f, -0.00017137f, 0.20287719f, -0.27926731f, 0.01054226f, 
    -0.02052488f, -0.06468122f, -0.01617560f, -0.05598323f, -0.30942556f, -0.10065394f, 0.09557364f, 0.10543524f, 
    0.05964659f, 0.03822955f, -0.14933454f, 0.01484291f, 0.23588517f, 0.06594303f, -0.31124750f, -0.05163487f, 
    0.35810256f, -0.14304450f, -0.06353274f, 0.24224877f, -0.19393903f, 0.10321348f, 0.00850691f, 0.18353365f, 
    -0.01120444f, -0.14160189f, -0.01956335f, -0.06875867f, -0.01441401f, -0.00307910f, 0.03528283f, 0.01935304f, 
    -0.01072892f, -0.08396959f, -0.00264068f, -0.01998090f, 0.01000156f, 0.09691847f, 0.03415467f, -0.06232924f, 
    0.06517859f, -0.06304224f, -0.11208606f, 0.05615329f, 0.13025048f, 0.21253085f, -0.07245073f, 0.02419575f, 
    0.04325358f, -0.04120985f, -0.03804593f, 0.00777709f, 0.08189604f, 0.27410462f, -0.06237007f, 0.05422429f, 
    -0.00505905f, 0.05435649f, -0.00080539f, -0.09429727f, -0.10066308f, 0.05289532f, -0.04540825f, -0.05313827f, 
    -0.17748034f, 0.16124801f, 0.04521445f, 0.03601116f, 0.00850255f, -0.00874781f, -0.09161443f, -0.02535047f, 
    0.16318196f, 0.04720662f, -0.03293826f, -0.08252683f, -0.00983755f, -0.04746750f, -0.13681696f, 0.05301329f, 
    0.23691882f, 0.16998954f, 0.01711896f, 0.21078841f, 0.08460174f, 0.05299098f, -0.12311145f, -0.07996231f, 
    0.02972364f, -0.02222100f, -0.10224534f, -0.00983296f, -0.15291880f, 0.01166823f, -0.07599144f, 0.05541896f, 
    -0.08618981f, 0.06820355f, -0.40892377f, -0.13983551f, 0.07543248f, -0.03054590f, -0.01838567f, 0.07212616f, 
    0.11415797f, 0.01083983f, 0.01522663f, -0.03023954f, 0.03585830f, 0.04399406f, -0.00909180f, 0.12630445f, 
    -0.08760596f, -0.07359348f, 0.20832904f, 0.22930071f, 0.38583824f, 0.17505875f, 0.10028149f, 0.15091367f, 
    0.23557851f, -0.01200627f, 0.08557678f, 0.22090293f, -0.02613355f, 0.01645617f, 0.01135057f, 0.01875951f, 
    -0.02915839f, -0.04446025f, 0.09350659f, -0.00792164f, 0.11211585f, -0.00905453f, 0.18061289f, 0.09038047f, 
    -0.03106313f, 0.17481223f, 0.20517145f, -0.18515609f, 0.09533697f, -0.04843566f, 0.01749024f, 0.09901074f, 
    0.13764580f, -0.11240092f, -0.02299768f, 0.05913028f, -0.03247065f, -0.02678939f, 0.05537255f, 0.02848756f, 
    -0.05958953f, 0.04399055f, 0.07503748f, -0.10914996f, -0.15032144f, -0.24672839f, -0.25163624f, 0.11767910f, 
    -0.13194540f, -0.02138481f, -0.09208969f, -0.05432378f, -0.00743709f, -0.06993675f, 0.00941539f, -0.03647409f, 
    -0.08763336f, 0.01893223f, -0.02099244f, 0.02428312f, 0.07581735f, -0.11224486f, 0.08813032f, 0.18681121f, 
    -0.07374612f, -0.28267643f, -0.47757509f, -0.13390426f, -0.22910921f, -0.01474671f, 0.02848881f, -0.02636804f, 
    -0.02395024f, -0.03578766f, -0.05120152f, 0.05747674f, 0.07113796f, -0.02992949f, -0.00194193f, 0.02306456f, 
    0.09932145f, 0.01496033f, 0.04789543f, -0.05948576f, -0.99646366f, -0.15235431f, -0.33789617f, -0.05022188f, 
    -0.16042331f, -0.00411817f, -0.00021889f, 0.15254369f, -0.01584728f, -0.03828368f, 0.03309730f, -0.01644412f, 
    0.05158615f, 0.04934774f, 0.04074683f, -0.12840220f, -0.01921493f, 0.12940261f, -0.05288733f, 0.00023777f, 
    -0.09175371f, -0.32269078f, 0.18484566f, -0.23813893f, -0.11750273f, -0.07109585f, 0.11982048f, 0.07256695f, 
    -0.04217553f, -0.17800833f, 0.00870645f, -0.03010229f, 0.11652186f, -0.05689590f, -0.01446153f, -0.12955692f, 
    0.01297263f, -0.19307579f, -0.02702688f, -0.04600028f, 0.55331653f, -0.10681757f, 0.24525569f, 0.02409896f, 
    0.21713811f, 0.05206472f, -0.03423450f, 0.07406931f, 0.05763272f, 0.13656697f, 0.00946660f, 0.03656550f, 
    0.05881878f, -0.03789021f, -0.12863187f, -0.04277974f, 0.06091699f, 0.00326197f, -0.07630622f, 0.02147406f, 
    0.34043199f, -0.10052287f, -0.26274681f, 0.23807541f, -0.33042502f, 0.05553295f, 0.12454227f, 0.02410715f, 
    0.01589636f, 0.06358556f, -0.06410699f, 0.04942359f, -0.14649062f, 0.13636102f, -0.02555324f, -0.03406673f, 
    -0.04703456f, 0.03679264f, -0.18486899f, 0.08612902f, 0.14669627f, 0.14529860f, -0.03336639f, 0.01758658f, 
    -0.01648954f, -0.05386940f, 0.05134461f, -0.07898448f, -0.08352405f, -0.00932940f, 0.06882002f, 0.01787441f, 
    -0.08083471f, -0.05644502f, 0.09013123f, -0.09209671f, -0.09668408f, -0.08262376f, -0.13855897f, -0.04371819f, 
    -0.09644882f, -0.21539158f, -0.09615546f, -0.17784752f, -0.19643372f, -0.04888183f, 0.06067804f, 0.08095991f, 
    -0.05102960f, -0.06747334f, -0.08381980f, -0.07033575f, 0.02797629f, -0.00561224f, 0.05195806f, 0.00043048f, 
    0.08877152f, -0.10709593f, 0.00266302f, -0.00058350f, -0.04244507f, 0.14697640f, 0.14838447f, 0.17254834f, 
    0.00426121f, -0.02167291f, 0.21107957f, -0.01167847f, -0.03529794f, 0.08328952f, -0.01437849f, 0.05048575f, 
    -0.04733799f, 0.07972020f, 0.04281589f, -0.13224116f, 0.12136329f, 0.04063242f, 0.06208895f, 0.32122454f, 
    -0.02513374f, 0.09126517f, -0.03806016f, 0.07172136f, -0.09271859f, 0.02406466f, 0.02049931f, 0.17857370f, 
    0.00053297f, 0.11077657f, -0.12381277f, 0.13829301f, 0.16058528f, 0.16351767f, 0.05407126f, -0.21880496f, 
    -0.12082221f, 0.07324062f, -0.09598826f, -0.06619460f, -0.12307942f, -0.26971334f, -0.15623252f, -0.30356058f, 
    -0.16802068f, -0.03558363f, -0.04222152f, 0.00006835f, 0.03714252f, -0.03444876f, 0.05635381f, -0.03369183f, 
    0.06098221f, 0.01043622f, -0.04299512f, -0.00953142f, -0.02177405f, -0.02546943f, -0.02562942f, -0.01968854f, 
    0.21560742f, 0.15378411f, -0.25458831f, 0.07839412f, 0.06620677f, 0.16752000f, -0.04528855f, 0.00422374f, 
    -0.05105014f, 0.03701747f, -0.00453837f, 0.00798209f, -0.02252774f, 0.05541309f, 0.05718005f, -0.06106359f, 
    0.06616180f, 0.12390850f, -0.06401909f, 0.15259087f, 0.04960887f, -0.24986617f, 0.23032901f, -0.20448165f, 
    0.01799593f, -0.14106838f, -0.12717168f, 0.14055753f, -0.01834122f, 0.03932227f, -0.01759130f, 0.08323400f, 
    0.07867737f, 0.03269518f, -0.14913158f, 0.03431804f, -0.06741929f, -0.06443455f, 0.07727071f, 0.01825745f, 
    0.01586553f, 0.20544866f, 0.18383747f, 0.07171314f, 0.19866835f, -0.04597673f, -0.04763327f, -0.03887488f, 
    -0.04026990f, -0.07791910f, -0.05036621f, 0.05932895f, -0.07168287f, -0.01569627f, 0.01355164f, 0.14323440f, 
    -0.06467956f, 0.01370067f, 0.07928772f, 0.00617812f, 0.14489797f, -0.24478178f, -0.17292440f, 0.05495096f, 
    -0.13107243f, 0.02951650f, 0.03640058f, -0.00924153f, 0.10043809f, -0.13550104f, 0.02119640f, -0.18783243f, 
    -0.04787738f, -0.02768568f, -0.12817781f, -0.02182078f, 0.07101071f, -0.05126455f, -0.03733310f, -0.19516340f, 
    -0.15769237f, -0.28761283f, -0.34744367f, -0.29629529f, -0.32407638f, 0.01163363f, -0.03220347f, -0.05217617f, 
    0.03951509f, -0.02593643f, -0.08779619f, -0.06137781f, -0.06560271f, 0.00036530f, -0.02042759f, -0.01686602f, 
    0.00601751f, -0.01628164f, -0.06841636f, -0.00762837f, -0.05369531f, -0.16186069f, 0.10745859f, -0.12887317f, 
    -0.13493609f, -0.01185621f, -0.01764371f, -0.05569302f, 0.01586531f, 0.03222964f, -0.08324269f, -0.01549509f, 
    -0.04184725f, -0.12230034f, 0.02639078f, -0.03182219f, 0.12956142f, -0.13552240f, -0.04352932f, -0.14024551f, 
    0.11282187f, -0.29915330f, 0.00428508f, -0.05524812f, -0.03537250f, -0.08866034f, 0.00408597f, -0.00178375f, 
    0.04159331f, -0.01815852f, -0.15964983f, 0.11832774f, -0.03842594f, -0.04593262f, 0.05029619f, 0.04258730f, 
    -0.00408739f, 0.03137474f, -0.05184023f, 0.01316390f, -0.30623844f, 0.03127282f, 0.39997664f, -0.04146363f, 
    0.20546815f, -0.13595989f, -0.05787890f, 0.10991417f, 0.06958517f, -0.20855527f, 0.08616623f, 0.01034972f, 
    0.14539924f, -0.10864034f, -0.06042243f, 0.00468856f, -0.11017568f, -0.01209613f, 0.00706760f, -0.19071589f, 
    -0.28223321f, -0.27890277f, -0.19005120f, 0.14757767f, -0.29109535f, -0.15608308f, -0.07862815f, -0.03086704f, 
    0.08578981f, -0.09351847f, -0.05142427f, -0.01859044f, 0.10231543f, 0.02611651f, -0.13526760f, -0.12435147f, 
    -0.07424122f, -0.00570426f, -0.08058293f, -0.03721276f, 0.23145241f, 0.40354848f, 0.27963161f, 0.09350809f, 
    0.31769219f, -0.23633739f, 0.09808136f, 0.04736325f, 0.14796777f, -0.09851468f, 0.08378052f, 0.04525115f, 
    0.04397423f, -0.03357667f, -0.00601868f, 0.08669006f, 0.05160723f, -0.08795068f, 0.01621607f, -0.12940463f, 
    0.22336257f, -0.20426549f, -0.14426856f, 0.11433019f, -0.04966922f, -0.04494174f, -0.03942637f, 0.01525672f, 
    -0.03592271f, 0.00299864f, -0.00912304f, -0.14131136f, 0.03145456f, 0.11167432f, 0.08792342f, -0.06865048f, 
    -0.02354135f, -0.11129902f, 0.13770612f, -0.04013418f, 0.02942844f, 0.06977098f, 0.20085883f, 0.17573000f, 
    0.00281464f, -0.02713603f, 0.18240833f, 0.10812566f, -0.12545910f, 0.04646660f, 0.03071079f, -0.01001570f, 
    -0.05524034f, 0.15044954f, 0.04737579f, 0.00645385f, 0.03615533f, -0.09034095f, 0.08258136f, 0.10643885f, 
    0.05182159f, 0.47988907f, 0.20377415f, 0.11266381f, 0.23558736f, -0.03005918f, -0.03293739f, 0.10539148f, 
    0.16631311f, 0.28283408f, 0.07380321f, 0.15043172f, 0.09510642f, 0.09910516f, 0.05756484f, -0.07191522f, 
    -0.06337768f, -0.12269136f, 0.25806916f, 0.01850393f, -1.11579502f, -0.39447382f, 0.20874055f, -0.15005063f, 
    -0.07983632f, -0.06795114f, 0.04874294f, -0.06004803f, 0.09454449f, -0.04671606f, -0.07297856f, 0.06988890f, 
    -0.05876424f, 0.02300244f, -0.16129771f, -0.15429929f, 0.16583554f, -0.05827715f, -0.02913270f, 0.02934203f, 
    0.21444993f, 0.06485365f, 0.08737683f, 0.15194680f, 0.01930004f, -0.06338154f, 0.03137694f, 0.05691352f, 
    0.04736547f, -0.00642299f, 0.09587976f, -0.04436618f, -0.07777058f, -0.08160000f, -0.09042127f, 0.07077545f, 
    0.01738843f, -0.00272386f, -0.02218311f, -0.05688251f, 0.06917315f, 0.26143569f, 0.12465055f, -0.07550117f, 
    0.21621084f, -0.01017767f, 0.05423826f, 0.01362341f, -0.07340067f, 0.15509464f, 0.00142573f, 0.05073514f, 
    0.04363658f, 0.11777334f, 0.06763859f, 0.03796108f, 0.03598628f, 0.08316153f, -0.00634393f, 0.09473839f, 
    0.07635429f, -0.13003299f, -0.10850956f, -0.10465390f, -0.12417568f, 0.10737310f, -0.03544247f, 0.03659339f, 
    0.00538038f, -0.01796599f, -0.14942108f, 0.07806744f, 0.00421334f, -0.03457883f, -0.06336021f, -0.16396326f, 
    -0.16619444f, -0.08879816f, 0.13027605f, -0.14365965f, 0.14894326f, 0.32878017f, 0.18664004f, 0.14464307f, 
    0.27988127f, -0.00322793f, 0.04749579f, 0.08595631f, 0.00375285f, 0.08045960f, 0.05840299f, 0.09842899f, 
    0.10181841f, 0.03764136f, 0.08289961f, 0.08218966f, -0.10483726f, -0.08861759f, 0.09822012f, -0.01785077f, 
    0.15932004f, 0.13947205f, -0.16282636f, -0.25606632f, -0.31166372f, 0.14854504f, -0.12140657f, -0.07608832f, 
    0.13587043f, 0.13269116f, -0.04956392f, -0.05107789f, 0.04359204f, -0.01705879f, -0.05745759f, 0.07577161f, 
    0.17738776f, -0.06336271f, 0.10193703f, 0.03147406f, 0.11008936f, 0.19771895f, 0.14496031f, -0.13162681f, 
    -0.09932774f, -0.04725203f, -0.05676210f, 0.04455980f, 0.10469396f, 0.13243794f, 0.01115380f, -0.04700526f, 
    -0.06254423f, 0.05390935f, 0.14471619f, 0.09688697f, -0.15710285f, -0.24824497f, 0.04039417f, 0.03346280f, 
    0.46743640f, -0.03265905f, 0.30063337f, -0.06504548f, -0.08094055f, 0.18007620f, 0.10771752f, -0.01006590f, 
    0.00943785f, 0.10654085f, 0.12407601f, -0.00122666f, -0.01650542f, 0.07670144f, 0.06838742f, 0.08410001f, 
    -0.03387670f, 0.05948554f, -0.09494096f, -0.03304636f, 0.11553939f, 0.40802312f, -0.09569719f, 0.23818411f, 
    0.01396403f, 0.04255306f, -0.13365719f, -0.16094567f, -0.03593481f, -0.10390528f, -0.04746241f, 0.02142908f, 
    -0.02186471f, 0.02073997f, -0.04628348f, -0.01536082f, -0.15201600f, -0.07077981f, 0.10263687f, -0.13722077f, 
    0.12937331f, 0.16271150f, 0.14385110f, 0.31799221f, 0.03153437f, -0.09063743f, 0.02136185f, -0.10636360f, 
    -0.03216511f, -0.13821401f, -0.03753079f, -0.08924495f, -0.11193597f, -0.11726906f, -0.06016921f, 0.03045656f, 
    -0.04184420f, 0.05699689f, 0.06915941f, 0.02148430f, 0.16958015f, 0.08220652f, -0.09473770f, 0.02246485f, 
    -0.15427822f, -0.12972163f, 0.04052082f, 0.06795322f, -0.15731731f, -0.01114789f, -0.03065876f, -0.02964995f, 
    -0.01615401f, 0.03935967f, -0.00796592f, 0.02899026f, 0.02115415f, -0.16074122f, 0.08632363f, 0.04479983f, 
    -0.02980526f, 0.09241975f, 0.17821027f, 0.10507050f, -0.03317700f, 0.09032526f, -0.09215841f, -0.02981483f, 
    -0.01753000f, -0.11725340f, -0.09673459f, 0.05580253f, 0.05120190f, -0.03666469f, 0.00254904f, 0.17680003f, 
    0.10863645f, 0.23851883f, -0.04485194f, -0.00816016f, 0.66823715f, -0.40723971f, -0.23041350f, -0.14342447f, 
    -0.18086879f, -0.17961210f, -0.15405458f, 0.01337052f, 0.02987194f, -0.08814728f, 0.18655439f, 0.06121932f, 
    -0.10195278f, 0.21522450f, -0.03915897f, -0.01684344f, -0.14863089f, -0.02705592f, -0.11414071f, -0.06659385f, 
    0.19047192f, -0.34759718f, 0.03794215f, 0.15563791f, 0.06603206f, -0.05284469f, 0.02477918f, -0.05270932f, 
    -0.10704272f, 0.02792337f, 0.18536407f, 0.01381437f, -0.07237271f, -0.02622185f, 0.00825534f, -0.08025207f, 
    -0.11928334f, 0.04803657f, 0.09491119f, -0.13193339f, -0.00110255f, -0.21926032f, -0.14244406f, 0.05675254f, 
    -0.26844820f, -0.03192919f, 0.23393211f, -0.01913261f, 0.11853152f, -0.04292798f, 0.22615673f, 0.05528754f, 
    -0.07688242f, 0.00492016f, -0.10342585f, -0.06116397f, 0.15366830f, -0.01970564f, -0.08263577f, -0.00368709f, 
    0.05140435f, 0.17590316f, 0.10995938f, 0.05301796f, -0.07199479f, 0.06433303f, -0.10392805f, -0.12668632f, 
    -0.07623400f, -0.14504100f, -0.04040603f, 0.02196463f, -0.03908564f, -0.02034888f, 0.02817324f, -0.10656392f, 
    0.07554797f, 0.09704107f, -0.06341109f, -0.09508974f, 0.01227803f, 0.24566752f, 0.11510761f, -0.11994633f, 
    -0.00542142f, 0.11003859f, 0.04888790f, 0.21023954f, -0.01552393f, 0.06488726f, 0.04178735f, 0.01290412f, 
    -0.05070077f, 0.08297999f, 0.07371578f, -0.06894974f, -0.07013404f, -0.11255407f, -0.11999087f, -0.12398046f, 
    -0.04130477f, -0.13212116f, -0.13182238f, 0.00965929f, -0.29066864f, 0.02236327f, -0.16660506f, 0.02789880f, 
    -0.05464330f, -0.08172640f, -0.14709409f, 0.09090858f, 0.11760635f, -0.04668047f, -0.05227641f, -0.02336548f, 
    0.15859467f, 0.13659064f, 0.10916953f, 0.30348477f, 0.09329206f, 0.14547604f, 0.20475730f, 0.09302598f, 
    0.02349377f, -0.05030983f, -0.07061450f, -0.12804711f, -0.13174647f, -0.19172110f, -0.10170899f, -0.08011681f, 
    -0.15287472f, -0.01534014f, 0.05665405f, 0.12472585f, 0.01370288f, 0.00769474f, -0.04273955f, -0.15336964f, 
    -0.04676992f, 0.10765461f, 0.07685072f, -0.00416364f, -0.23131831f, 0.09766483f, -0.20181862f, -0.11226597f, 
    0.08803161f, -0.02740312f, 0.03302546f, 0.00815033f, 0.02895253f, 0.03395233f, 0.12561665f, 0.12648781f, 
    0.06169281f, -0.04802185f, -0.29089037f, -0.17892888f, 0.00730596f, -0.42134756f, -0.22054498f, -0.27264816f, 
    -0.25773698f, -0.14269644f, -0.17670579f, 0.08888465f, 0.05695979f, 0.06024899f, 0.28766125f, 0.05760803f, 
    -0.04389571f, 0.03267759f, -0.01861054f, -0.00975132f, -0.10710757f, 0.08739224f, -0.01183673f, -0.09713710f, 
    0.05553770f, 0.09257279f, 0.09559248f, 0.10626268f, 0.06506784f, -0.08100581f, 0.12586914f, 0.01051719f, 
    0.06204738f, 0.08698850f, 0.02841093f, -0.00664260f, -0.01978658f, -0.03496630f, 0.00021098f, 0.01378580f, 
    -0.05008098f, 0.04291052f, 0.05452086f, 0.11780344f, 0.18850595f, -0.41043091f, -0.06020332f, 0.00114377f, 
    -0.09587544f, -0.06450313f, -0.03614596f, -0.07146358f, 0.00217557f, 0.01032476f, 0.08303431f, 0.10784546f, 
    0.03065779f, 0.14303322f, 0.08604083f, 0.10090858f, 0.00119167f, 0.07730510f, 0.05622483f, 0.04483347f, 
    0.14790650f, 0.18383166f, 0.13581030f, 0.18314430f, 0.06466594f, -0.04179859f, -0.01350401f, -0.13990629f, 
    -0.13199905f, -0.18308420f, -0.12154455f, -0.07342783f, -0.16205300f, 0.00353370f, 0.00116447f, 0.02034238f, 
    0.05694343f, 0.11959691f, -0.05393568f, -0.11584019f, -0.03576107f, -0.10942456f, -0.07467999f, 0.06782106f, 
    -0.19999158f, -0.15728797f, -0.09331749f, -0.07080300f, -0.11341980f, -0.16089533f, 0.09793556f, 0.20568831f, 
    0.11861476f, 0.05813822f, 0.16343589f, 0.04653268f, 0.04565127f, 0.06416696f, -0.04041997f, 0.05305869f, 
    -0.11568109f, -0.13990806f, -0.34020281f, -0.24998775f, -0.23171350f, -0.12907882f, 0.06120305f, 0.02355380f, 
    -0.00083341f, 0.11815547f, 0.22590014f, 0.11389356f, 0.02732478f, -0.01743050f, -0.07081456f, -0.14441349f, 
    0.03067562f, 0.05396694f, -0.00238617f, -0.01822340f, -0.25302085f, -0.30142769f, 0.42518893f, 0.17251906f, 
    0.02340898f, 0.19961610f, 0.17555787f, 0.01276085f, 0.21080919f, 0.04027360f, 0.13698876f, -0.00854215f, 
    0.12664221f, -0.07834559f, 0.04859635f, 0.03914340f, 0.03164310f, -0.02201297f, 0.02798167f, -0.04108468f, 
    0.03822059f, -0.07951999f, -0.02852265f, 0.07522660f, 0.08190506f, -0.03459752f, 0.02714935f, 0.04952373f, 
    0.01213988f, -0.05397998f, 0.01846478f, 0.14312670f, -0.09636192f, 0.17312670f, 0.11550168f, 0.05939412f, 
    -0.03172734f, -0.00880131f, 0.00310173f, 0.12836397f, 0.18268472f, 0.15894888f, 0.24577424f, -0.09870793f, 
    -0.32458583f, 0.01510670f, 0.07679600f, 0.12766613f, 0.02069953f, 0.24120699f, -0.07076804f, -0.04548178f, 
    0.02251726f, -0.16824098f, -0.00195487f, 0.07490153f, 0.03588701f, -0.03430802f, 0.01836447f, 0.21068758f, 
    0.09808927f, -0.23389634f, -0.44183517f, -0.14455768f, -0.17260355f, -0.05067594f, -0.02023095f, -0.04550047f, 
    0.04252779f, -0.03530837f, 0.15739135f, 0.12681885f, 0.03740938f, 0.04262074f, -0.05706560f, -0.10830155f, 
    0.02489598f, -0.13246234f, 0.04231093f, 0.01858441f, 0.09773053f, 0.15963101f, 0.16293782f, -0.15852886f, 
    -0.02493193f, 0.22858956f, 0.05900173f, 0.21646471f, 0.04020170f, 0.07818831f, 0.04464047f, -0.04622794f, 
    -0.04517689f, 0.09881334f, 0.14091773f, -0.04089041f, 0.01281398f, 0.01270318f, -0.07667851f, -0.11187453f, 
    0.05776882f, 0.08643194f, 0.27403498f, 0.02091688f, -0.23944488f, 0.00476042f, 0.03450888f, -0.11432143f, 
    -0.01851702f, -0.12675950f, -0.16399182f, 0.09120366f, 0.05988623f, -0.03009003f, 0.01370098f, -0.09166568f, 
    0.06381258f, -0.03071577f, 0.08496372f, 0.30239627f, 0.60531861f, 0.06199544f, 0.30880073f, 0.18703793f, 
    0.10510749f, 0.02589450f, -0.10800390f, -0.03725080f, -0.07369667f, -0.00892611f, 0.05674361f, -0.16035807f, 
    -0.11653909f, 0.05264973f, -0.07528780f, 0.05922435f, -0.11786744f, 0.05288096f, 0.09783936f, -0.08200801f, 
    0.01204786f, -0.39082584f, -0.50443655f, -0.26900682f, -0.14650439f, -0.04839904f, 0.00466275f, 0.14120871f, 
    0.12041164f, 0.21535297f, 0.12171278f, -0.02252312f, -0.05702741f, -0.03806805f, -0.09360416f, 0.00831256f, 
    -0.02476159f, -0.05973443f, 0.05001028f, -0.01740341f, 0.33170557f, 0.12342424f, 0.18278919f, -0.10081574f, 
    -0.03997945f, 0.09441821f, -0.07941912f, 0.02650994f, -0.04079894f, -0.05751197f, 0.03700129f, -0.01677597f, 
    -0.00975546f, 0.08525144f, 0.10120538f, -0.06890764f, 0.02469281f, -0.02323324f, 0.07515154f, -0.02844915f, 
    0.20580241f, 0.10269568f, 0.00882716f, 0.18282153f, -0.13626949f, 0.04010280f, 0.04848638f, -0.05444372f, 
    0.06450157f, 0.04807710f, -0.02899038f, 0.04284460f, 0.06730855f, 0.00327129f, -0.04135441f, 0.14367697f, 
    0.17505407f, -0.03100295f, 0.20300168f, 0.27363876f, 0.05216286f, 0.03687093f, -0.18010661f, -0.11662070f, 
    -0.19211121f, -0.02762932f, 0.15580937f, 0.06255221f, -0.02299011f, 0.20169936f, 0.05966466f, -0.03597176f, 
    -0.10374698f, -0.03883503f, -0.00931417f, -0.06461246f, 0.04202980f, -0.08053242f, -0.02485587f, 0.05245931f, 
    -0.04379120f, -0.06075329f, 0.01159736f, 0.22557840f, 0.37445888f, 0.07670937f, 0.12231512f, -0.14947368f, 
    0.17329173f, 0.14247757f, -0.00314934f, -0.00784018f, 0.05655411f, -0.01025921f, 0.07362356f, 0.13140619f, 
    -0.02906772f, -0.03821201f, 0.00047999f, -0.07345806f, 0.21370739f, -0.40177837f, -0.23927753f, -0.61778188f, 
    0.03146617f, 0.04549488f, -0.17246619f, -0.17499799f, 0.29250655f, 0.06403334f, -0.14461751f, -0.03242046f, 
    -0.07035797f, -0.14262830f, -0.05048223f, -0.14288236f, -0.12946846f, -0.12166718f, 0.13236716f, -0.01964806f, 
    -0.11510498f, -0.43406343f, -0.32037669f, -0.01990435f, 0.21818942f, 0.09379254f, 0.32905695f, 0.33049119f, 
    -0.02096468f, 0.16421981f, 0.01689690f, -0.07359430f, -0.04441346f, -0.01228001f, 0.01712088f, 0.08526558f, 
    0.14295384f, 0.13742045f, -0.03210593f, 0.02798324f, 0.05475496f, 0.27819267f, 0.25728011f, 0.06894372f, 
    0.26474607f, 0.03329942f, 0.05663644f, 0.01596801f, 0.00176198f, 0.01734589f, 0.01720259f, 0.04800538f, 
    0.08260053f, 0.05719527f, 0.02940699f, 0.09105791f, 0.01291948f, -0.00502389f, 0.00035853f, -0.16293687f, 
    0.23501793f, 0.22367969f, 0.04897780f, 0.21321900f, 0.17502461f, -0.07648384f, -0.01763928f, -0.01895669f, 
    0.00103814f, -0.02479831f, 0.11334043f, 0.04089892f, -0.01675699f, -0.01932042f, -0.05389838f, -0.20283462f, 
    -0.20720340f, 0.10523874f, 0.00140088f, -0.01740165f, 0.30102044f, 0.32690239f, -0.09507348f, 0.00741879f, 
    0.06379679f, -0.01235900f, -0.03483638f, 0.05859407f, -0.05281151f, -0.02296473f, 0.22724372f, -0.03639317f, 
    0.17866123f, -0.00407072f, -0.02189219f, 0.06088648f, -0.13879962f, 0.20910871f, -0.07417475f, 0.11212179f, 
    0.17349845f, 0.01178038f, -0.03740494f, 0.03456421f, 0.01455248f, 0.06132970f, -0.00338696f, -0.00886126f, 
    0.00798586f, 0.08519509f, 0.06113247f, 0.08517299f, 0.07788290f, -0.05243805f, 0.01721448f, -0.09436934f, 
    0.08355432f, 0.05880664f, 0.00500047f, -0.04416063f, 0.55058479f, -0.29362833f, -0.11817050f, -0.29726183f, 
    -0.20648544f, -0.00447899f, -0.01320975f, 0.09335605f, 0.15616579f, 0.14991841f, -0.20125662f, 0.04711147f, 
    -0.04163926f, 0.11454853f, -0.14529081f, -0.10068410f, 0.02203747f, -0.06188479f, 0.11810780f, 0.14463133f, 
    -0.05262280f, 0.16854900f, 0.06921410f, -0.01625917f, 0.01825131f, 0.10763111f, 0.06970108f, 0.15265210f, 
    -0.05422878f, -0.00359493f, 0.22983234f, 0.14293918f, 0.11981633f, 0.06714683f, -0.13633920f, -0.08959181f, 
    0.09869144f, 0.12642691f, 0.14032495f, 0.07348180f, -0.28167269f, -0.18170364f, 0.07207258f, -0.12501839f, 
    -0.23955137f, -0.00382208f, 0.20401327f, -0.03923987f, 0.00698801f, 0.08263690f, 0.13242427f, 0.20815289f, 
    0.03509358f, 0.04114502f, -0.06037997f, -0.04774009f, 0.04089814f, 0.09974281f, -0.16222934f, -0.02871671f, 
    0.17317708f, 0.05147669f, 0.13357763f, 0.08863160f, -0.00081842f, 0.11441781f, -0.01107094f, 0.05175101f, 
    0.00210570f, -0.07441386f, 0.07589944f, 0.06842199f, -0.00338730f, 0.00083212f, -0.01054006f, -0.06233858f, 
    -0.04065247f, 0.06869327f, 0.06305147f, -0.13438538f, -0.11451922f, -0.16280404f, -0.18044424f, -0.34330627f, 
    0.21253780f, 0.04753228f, -0.02764310f, -0.01922968f, 0.09867892f, 0.02639901f, -0.13084961f, -0.08724064f, 
    -0.12247717f, 0.02653810f, -0.06222621f, -0.22323631f, -0.04876436f, -0.02820001f, -0.05360003f, -0.07529000f, 
    -0.08977807f, -0.10271447f, -0.01022620f, -0.08395714f, 0.01194529f, 0.27775928f, 0.21913110f, 0.28474584f, 
    0.08229443f, -0.04869715f, -0.13915718f, -0.01099024f, 0.14584355f, -0.03689676f, -0.01375466f, -0.03994697f, 
    0.01950477f, 0.12526631f, -0.04776207f, 0.01035139f, 0.20027353f, 0.32835203f, 0.18426001f, 0.14449702f, 
    -0.11084845f, -0.04478668f, 0.04813475f, -0.07452770f, -0.08195426f, -0.02624840f, 0.03320532f, 0.10606084f, 
    -0.00335469f, 0.03348104f, 0.05022563f, -0.03226907f, -0.08266398f, -0.06366874f, -0.06010220f, 0.02310576f, 
    -0.27590969f, -0.15292653f, -0.07169737f, 0.21987709f, 0.11279463f, 0.17932348f, 0.31984261f, -0.01355912f, 
    0.13717571f, 0.05591596f, -0.08072805f, -0.09620594f, -0.03461099f, 0.00062008f, 0.04775096f, -0.04060535f, 
    0.01557698f, -0.08085224f, 0.12135996f, 0.03143678f, 0.32349700f, 0.11923093f, -0.07458916f, -0.14375471f, 
    -0.36685845f, -0.06932044f, -0.19413833f, -0.04875925f, -0.02218443f, 0.23862463f, -0.02709789f, -0.02783086f, 
    0.09075047f, -0.08383261f, 0.17677371f, -0.01723103f, 0.00420027f, 0.05759710f, 0.07207908f, -0.10251306f, 
    -0.19342618f, -0.60506666f, -0.34960350f, 0.04654687f, -0.08568028f, -0.15993859f, 0.23348382f, 0.01156241f, 
    0.10486351f, 0.12185995f, -0.03240485f, -0.04120991f, -0.07423705f, -0.13354926f, 0.02917147f, -0.12151379f, 
    -0.09318740f, 0.03237114f, -0.15987070f, -0.00264238f, 0.12949950f, 0.08693036f, -0.01730687f, -0.03586350f, 
    0.01167452f, 0.04160187f, -0.00431733f, 0.01578088f, 0.00401256f, 0.05960893f, 0.02311881f, 0.06137617f, 
    0.10256149f, -0.02236681f, 0.07266038f, -0.05342003f, 0.04236021f, -0.07498978f, 0.04051025f, 0.13328369f, 
    0.22631022f, 0.23472433f, 0.14767498f, 0.21938173f, -0.01646660f, -0.03667063f, 0.00079043f, 0.00409532f, 
    -0.04020739f, -0.04115013f, 0.15139017f, 0.08501475f, 0.02589122f, 0.01553954f, 0.03061019f, -0.08165946f, 
    -0.08011774f, 0.03506722f, -0.05606056f, 0.00990557f, 0.14827974f, 0.12826854f, 0.17190982f, 0.00418092f, 
    -0.09901753f, 0.01538026f, -0.02211756f, 0.00405720f, -0.04520014f, -0.02319868f, -0.02773316f, -0.10022764f, 
    -0.05423934f, -0.18578489f, -0.06852299f, -0.04538492f, 0.00109693f, -0.02591632f, -0.00601326f, -0.05147462f, 
    0.14037172f, -0.00042105f, -0.10744858f, -0.14182067f, -0.16949916f, -0.02123933f, 0.01624677f, -0.01213403f, 
    -0.06234040f, 0.12984559f, 0.11037347f, -0.03956959f, 0.07244155f, 0.05155330f, -0.05633333f, 0.00001235f, 
    -0.02863079f, 0.02845970f, -0.03110203f, -0.00646103f, 0.23976140f, 0.00524129f, -0.09310927f, 0.08066055f, 
    -0.09520783f, -0.22524896f, -0.03952935f, 0.02067869f, 0.06397545f, 0.11866405f, 0.09507305f, -0.03744153f, 
    0.19763252f, -0.08636039f, 0.08086053f, -0.01306176f, -0.16794497f, 0.00571222f, -0.04261373f, -0.25311863f, 
    0.19644493f, 0.10359927f, 0.15109207f, 0.01798494f, 0.15752418f, 0.14899698f, -0.03944811f, 0.04525477f, 
    0.00371842f, -0.00935318f, 0.26969594f, 0.05813819f, 0.05392391f, 0.09397232f, -0.10917038f, 0.02458872f, 
    -0.01470505f, -0.01771728f, 0.02733798f, 0.00384448f, -0.06640320f, -0.03143582f, -0.09956761f, -0.39525494f, 
    -0.13751264f, 0.06117647f, 0.25801092f, 0.08498254f, -0.00336073f, 0.03051050f, -0.08936737f, -0.10069100f, 
    -0.03114643f, -0.07587250f, -0.00739529f, -0.07157807f, -0.07917225f, -0.02312235f, -0.01949369f, 0.18467875f, 
    0.16557284f, 0.11043546f, -0.11088786f, -0.07899998f, -0.02784943f, 0.07571402f, -0.00314136f, -0.00593238f, 
    -0.06156055f, 0.11695645f, -0.00355203f, -0.03733102f, -0.06330825f, 0.07818728f, -0.14009562f, -0.00984390f, 
    0.05484564f, 0.05900147f, 0.01854582f, -0.00304045f, -0.08472700f, -0.19977489f, -0.00586767f, -0.25243250f, 
    0.12252862f, 0.11569007f, 0.00295124f, 0.01504784f, 0.14447834f, -0.01773377f, -0.05707813f, -0.01630971f, 
    -0.04451122f, 0.03225103f, 0.00348140f, -0.19899969f, 0.02460442f, -0.05412116f, -0.02729549f, -0.03114591f, 
    -0.49751231f, -0.26157752f, -0.29351911f, -0.23771101f, -0.19180109f, 0.10153318f, 0.26326057f, -0.25235894f, 
    -0.22500798f, -0.11638597f, -0.06460667f, -0.09320585f, 0.05715695f, -0.02163628f, -0.01299718f, -0.05949472f, 
    0.03222618f, -0.07747911f, -0.15250431f, 0.12511407f, 0.34329432f, 0.18627340f, 0.05027917f, 0.09604434f, 
    0.25010839f, -0.01004250f, 0.03146800f, -0.02082215f, -0.06061780f, 0.21361682f, 0.03546548f, -0.01580530f, 
    0.10905487f, -0.01218478f, 0.09033537f, -0.25251454f, -0.22238792f, 0.17673488f, -0.06342249f, 0.07424466f, 
    -0.00960138f, -0.17339663f, -0.52469641f, -0.38001296f, -0.09201749f, -0.18518120f, -0.16627605f, -0.03671550f, 
    0.00963968f, 0.22808526f, -0.06089627f, 0.01851692f, -0.13625513f, 0.00928964f, -0.08297899f, -0.04053555f, 
    0.06062097f, 0.14625515f, 0.09108961f, -0.00295217f, -0.27172729f, -0.21961971f, -0.34220794f, -0.00052732f, 
    0.25191778f, 0.01434025f, 0.14623916f, 0.00526611f, 0.02129770f, 0.05455236f, -0.05590037f, -0.07683422f, 
    -0.09972894f, -0.10411750f, 0.00051528f, -0.12128790f, -0.05307288f, -0.13032325f, 0.03270509f, 0.02784887f, 
    -0.00483770f, -0.04399055f, 0.00239051f, 0.09969679f, 0.01212822f, -0.03521141f, -0.03319261f, -0.08209538f, 
    0.16928466f, 0.08538412f, 0.02853420f, 0.04774466f, 0.09959462f, 0.03370620f, -0.10433588f, -0.06740368f, 
    0.13647902f, 0.05292017f, -0.00287689f, 0.12860022f, -0.01967571f, -0.42720643f, -0.06640630f, -0.27838105f, 
    -0.25860065f, 0.10213728f, 0.32296330f, -0.00168237f, -0.04801010f, 0.05486342f, -0.08595376f, -0.04503714f, 
    -0.01210876f, -0.05834733f, -0.02631528f, -0.10028558f, -0.06794581f, 0.03523371f, -0.04021705f, -0.03260246f, 
    0.12507771f, 0.32062307f, 0.57296491f, -0.14755107f, 0.07535704f, 0.02914363f, -0.25848350f, -0.03363314f, 
    0.08816886f, -0.12589255f, -0.04956897f, -0.00125670f, 0.04686971f, -0.10009738f, -0.04233854f, -0.04157789f, 
    0.19971788f, 0.19300014f, -0.04650127f, -0.09551385f, 0.04890672f, 0.14878541f, 0.05851597f, -0.06211251f, 
    0.16130185f, 0.15249088f, 0.02881673f, 0.18126936f, 0.12821279f, 0.07751362f, -0.08146456f, -0.01374542f, 
    -0.06333084f, 0.14257607f, 0.22381596f, -0.09586275f, 0.08421231f, 0.20281480f, -0.02953503f, -0.07905215f, 
    -0.08118103f, 0.07425310f, -0.04130352f, 0.29770535f, 0.00013775f, -0.00414228f, 0.03523961f, -0.13656411f, 
    -0.09059407f, 0.14130619f, -0.05781477f, -0.02200564f, 0.02878919f, -0.08471327f, -0.10963115f, -0.06591525f, 
    0.04326899f, -0.06494855f, 0.14976172f, 0.00583478f, -0.36751342f, 0.06790960f, 0.50341338f, 0.04823051f, 
    -0.06370413f, -0.02606571f, -0.08046702f, -0.01530073f, 0.01880924f, -0.01885164f, -0.03486211f, 0.02104290f, 
    -0.02196899f, -0.02844953f, -0.02879113f, -0.07939630f, 0.02380783f, 0.15585740f, -0.08432347f, -0.12628679f, 
    -0.18620500f, 0.04237277f, 0.33001891f, -0.05921904f, -0.06616891f, 0.00522525f, 0.00131046f, -0.05116761f, 
    0.08128303f, 0.00749446f, 0.02348522f, 0.05998152f, 0.05751782f, 0.05776434f, 0.03902779f, 0.10695445f, 
    0.11255240f, -0.03009334f, -0.01670696f, -0.07901413f, -0.39920950f, -0.27077973f, 0.42899230f, 0.17747188f, 
    0.09369668f, 0.05540115f, 0.13457987f, -0.15871647f, 0.20764363f, 0.08930538f, -0.07310174f, 0.00209787f, 
    0.02354619f, 0.16141774f, 0.13703728f, 0.06171106f, 0.10174687f, 0.10533125f, 0.16175038f, -0.19436379f, 
    0.20184314f, 0.21177642f, 0.33714390f, -0.06853879f, 0.00208241f, -0.07091353f, 0.03478315f, -0.13125740f, 
    0.03534540f, 0.00046894f, 0.04860960f, -0.04025993f, -0.00585179f, 0.15167007f, 0.04522753f, -0.07622690f, 
    0.01557104f, 0.09710084f, -0.00504297f, -0.03201235f, -0.32886109f, 0.29758978f, -0.13804169f, 0.08062667f, 
    0.19204052f, 0.01179024f, -0.11730251f, -0.05211078f, -0.17298168f, -0.12824011f, 0.01410653f, -0.04073070f, 
    0.07616910f, 0.04610576f, 0.16394140f, -0.02928767f, 0.03828114f, 0.06515189f, -0.07801769f, -0.19291779f, 
    -0.27262539f, 0.08325338f, 0.20454051f, 0.49829274f, 0.15498754f, -0.08958941f, 0.00390175f, -0.08390084f, 
    -0.11565638f, 0.05752374f, -0.09335008f, -0.02281724f, -0.06372362f, 0.13947587f, -0.06451413f, 0.10418948f, 
    0.10155845f, 0.01780759f, 0.06418899f, -0.11629234f, 0.17324825f, -0.03036477f, -0.39570996f, 0.15832277f, 
    0.20208727f, -0.05072216f, 0.06553070f, 0.11765438f, 0.02115060f, 0.07863080f, 0.00112975f, -0.15530393f, 
    -0.06597835f, -0.06268091f, 0.04647030f, 0.00283927f, 0.10173398f, -0.11745592f, 0.21653901f, -0.01388508f, 
    -0.09695184f, 0.19548847f, 0.08372057f, 0.05981992f, -0.01120105f, -0.09740665f, -0.02734301f, 0.00436264f, 
    0.02539714f, 0.05735040f, -0.05419945f, 0.05594578f, 0.08796971f, 0.11450171f, 0.05309801f, -0.06850127f, 
    0.03236796f, -0.04525859f, 0.03047223f, 0.00025401f, 0.15308346f, -0.11851376f, -0.08278430f, 0.04520444f, 
    -0.02649392f, 0.08078732f, 0.11786953f, 0.05802682f, 0.13791671f, 0.09397215f, -0.02509894f, -0.00632747f, 
    -0.04072500f, 0.06585898f, 0.02497743f, 0.16245613f, 0.01561999f, -0.05078968f, 0.12177789f, 0.00535482f, 
    0.12794977f, -0.08855078f, 0.04958940f, -0.01178702f, 0.11444607f, -0.07340741f, -0.11397826f, -0.37622333f, 
    -0.06920467f, -0.03538764f, 0.03331852f, 0.25682831f, -0.04986285f, -0.03144704f, -0.07790291f, -0.07723171f, 
    0.05529471f, 0.00038657f, 0.16869351f, 0.34379709f, -0.14249611f, -0.07021148f, 0.01418756f, -0.10249636f, 
    -0.01457591f, 0.01460748f, 0.02766448f, -0.00391034f, 0.09794740f, -0.05063282f, -0.05749422f, 0.03756779f, 
    0.24790779f, 0.02676656f, 0.15682131f, 0.11943482f, 0.02568713f, -0.01919638f, -0.04221266f, -0.06541931f, 
    0.11656403f, 0.16390708f, 0.29804659f, -0.37146771f, 0.11819568f, 0.07413696f, 0.03550134f, 0.03151862f, 
    0.13304566f, 0.04622907f, -0.01174343f, 0.01880267f, -0.01766809f, -0.06893993f, -0.03621597f, -0.02931094f, 
    -0.05552540f, 0.08850327f, -0.02825213f, 0.00716388f, 0.03825887f, -0.10530481f, 0.02247823f, -0.25603387f, 
    0.23214073f, 0.17477474f, 0.21731578f, 0.08127087f, 0.00856257f, -0.09457238f, 0.02764016f, -0.03684167f, 
    0.01410847f, 0.15243703f, 0.01092371f, -0.02660565f, 0.02510901f, -0.01366570f, -0.03576991f, 0.00779156f, 
    0.32183772f, 0.11546943f, -0.16598344f, -0.38327649f, 0.14934041f, 0.18326387f, 0.12727006f, 0.07467683f, 
    0.12253612f, 0.02669357f, -0.04063990f, -0.03276705f, -0.04765322f, 0.13983190f, -0.01181657f, 0.01232276f, 
    0.00149427f, 0.05716188f, -0.21512528f, 0.08159572f, -0.15514506f, -0.06898566f, 0.13273743f, 0.16872618f, 
    0.05863602f, 0.07410350f, 0.17235695f, 0.14364266f, -0.02668888f, -0.01769425f, 0.09971604f, -0.00055198f, 
    0.09230115f, -0.05750010f, 0.02503309f, 0.03215746f, 0.09442727f, 0.03819033f, 0.07528652f, -0.10855632f, 
    -0.15391581f, 0.04215516f, 0.10784049f, 0.02626443f, -0.00876688f, 0.00110960f, 0.01716133f, -0.04797767f, 
    0.09119016f, 0.04325958f, -0.08736117f, 0.02225799f, 0.11171956f, 0.00822804f, 0.10310342f, 0.14088671f, 
    0.04166477f, -0.02728260f, 0.04817022f, -0.09932881f, -0.23079807f, -0.12156766f, -0.14228758f, 0.01560007f, 
    0.01028670f, -0.01723071f, 0.12012832f, 0.16646293f, 0.14173388f, 0.03381379f, -0.02301423f, -0.09004103f, 
    0.07476329f, 0.11051913f, 0.08193419f, -0.04115636f, 0.08618601f, -0.04011732f, 0.10597288f, 0.00842813f, 
    0.03822976f, -0.18323980f, -0.20050068f, 0.04621309f, 0.15965717f, 0.06303495f, 0.06194628f, 0.08900011f, 
    0.04139252f, 0.00181224f, 0.02292147f, 0.06012358f, -0.07444934f, -0.02550332f, -0.04625216f, -0.07253320f, 
    0.03294303f, -0.01426284f, -0.01616206f, -0.02810222f, 0.83240348f, 0.29663846f, 0.07704056f, -0.57125616f, 
    0.08654746f, 0.26056078f, 0.08593766f, 0.04704961f, 0.02195332f, 0.00965541f, -0.05393288f, -0.05152735f, 
    -0.12786390f, 0.07325307f, 0.08625536f, 0.10500745f, 0.18054871f, 0.06280257f, -0.18825050f, 0.09689011f, 
    -0.35469306f, 0.06718052f, 0.06199126f, 0.14259301f, 0.04284145f, -0.08293591f, 0.08047985f, -0.10638966f, 
    0.09221485f, 0.06474543f, -0.09876021f, 0.11973337f, 0.13388309f, 0.07582932f, 0.13562582f, 0.01251797f, 
    0.00061966f, -0.01846674f, 0.15709350f, -0.00886014f, 0.09154449f, -0.17880289f, -0.53306353f, -0.20314327f, 
    0.20653121f, 0.19916512f, 0.03822117f, 0.10953424f, -0.17176367f, -0.03946079f, -0.07768857f, -0.01322190f, 
    -0.00601051f, -0.03133353f, -0.00760219f, -0.04233320f, -0.06999812f, 0.01933776f, -0.05310216f, -0.10296533f, 
    -0.25849900f, -0.13358700f, 0.00936487f, 0.21901485f, 0.10000581f, 0.05321000f, 0.09582981f, 0.08382580f, 
    0.09852502f, -0.03679302f, -0.01300251f, 0.09895152f, 0.02499474f, 0.06001468f, -0.01984353f, -0.06857664f, 
    -0.00699879f, 0.07195482f, -0.04065414f, -0.02266489f, 0.07194537f, -0.09906983f, -0.13132580f, 0.10658394f, 
    -0.02280415f, 0.01089294f, 0.06443886f, 0.07907796f, 0.10258993f, 0.13432646f, -0.02796796f, -0.02133718f, 
    0.00442302f, -0.11282643f, -0.08050568f, 0.26174957f, -0.08110257f, 0.02046167f, 0.12022579f, 0.00861342f, 
    0.35676470f, -0.07646730f, -0.26355824f, -0.10149861f, 0.07555038f, 0.05172826f, -0.07943185f, -0.07954483f, 
    0.05744550f, -0.04632490f, 0.00208536f, -0.01945641f, -0.00847887f, 0.00600954f, -0.01456546f, -0.06063703f, 
    0.01256786f, 0.06441467f, -0.04157594f, 0.22418395f, 0.08394450f, 0.00817222f, 0.03205541f, 0.04534489f, 
    -0.13424976f, 0.14913575f, -0.00715711f, 0.06724477f, -0.05179966f, -0.00000220f, 0.13721806f, 0.08272786f, 
    0.00407473f, 0.03005565f, -0.09159812f, 0.10452002f, 0.03685052f, 0.19425802f, -0.03614153f, -0.18340497f, 
    0.05751129f, -0.16357209f, -0.01804739f, -0.00289644f, 0.38034680f, 0.07010292f, 0.20921780f, 0.22419336f, 
    0.02843595f, -0.08348341f, 0.02893468f, -0.02886954f, 0.08225385f, -0.02360550f, 0.06673728f, 0.00280460f, 
    0.02826211f, -0.08779903f, -0.00954256f, -0.10197806f, 0.11955085f, -0.10117617f, -0.14490576f, -0.27082914f, 
    0.00954513f, 0.00894241f, 0.06892285f, 0.09578435f, -0.01826431f, 0.03672986f, -0.05865750f, -0.03542985f, 
    -0.05450120f, -0.05753956f, -0.10243193f, -0.01709115f, -0.06794614f, 0.14406075f, -0.10335826f, 0.03258356f, 
    -0.13815098f, 0.07732523f, 0.28477317f, 0.00035090f, -0.05367570f, -0.13155803f, -0.11321241f, -0.05193766f, 
    -0.15412290f, 0.09226959f, 0.04711425f, 0.14763150f, 0.06924641f, -0.02123807f, 0.11214622f, -0.03408317f, 
    0.21049121f, 0.03355130f, 0.11500504f, -0.11317527f, 0.27906898f, -0.11392540f, -0.39613369f, -0.48264328f, 
    0.22140734f, 0.06494320f, 0.07660916f, 0.08189002f, 0.00348064f, -0.11499342f, -0.10303578f, -0.07701281f, 
    -0.03772897f, 0.03902850f, -0.04019278f, -0.04875302f, -0.02266046f, 0.05296499f, -0.10376146f, 0.09422182f, 
    0.17529500f, -0.23780917f, 0.14364779f, 0.28199089f, -0.14323081f, 0.03172527f, 0.26090187f, 0.12927611f, 
    -0.00300653f, 0.09969946f, 0.00100034f, 0.01689723f, -0.08976468f, -0.00192511f, -0.00416037f, 0.02433319f, 
    -0.03935010f, 0.00210404f, -0.12455944f, 0.04703198f, -0.07753444f, -0.03258691f, -0.25351977f, -0.20512582f, 
    -0.10055325f, 0.15922363f, 0.04999046f, -0.14239123f, 0.22169532f, 0.15776527f, 0.04051795f, 0.03671084f, 
    0.00919793f, 0.06106444f, 0.06980808f, 0.16450764f, 0.08342986f, 0.09567203f, 0.10768009f, 0.02123545f, 
    -0.05267840f, -0.18791908f, -0.36906111f, 0.27043867f, 0.22712938f, 0.05708638f, -0.15139262f, 0.13121316f, 
    0.08079333f, 0.16029061f, 0.03562238f, 0.05712878f, -0.04528686f, 0.04721570f, 0.02191439f, 0.11749660f, 
    0.08066742f, 0.12326109f, -0.05627548f, 0.00335846f, 0.08279683f, -0.15662864f, 0.03174388f, -0.10354311f, 
    -0.08325748f, -0.03629120f, 0.05537364f, 0.02635303f, -0.05416070f, -0.06987691f, -0.09448411f, -0.07117949f, 
    -0.01786018f, 0.01762499f, -0.04371671f, -0.03979856f, -0.03636487f, -0.13536571f, -0.02626310f, 0.08681652f, 
    -0.00515302f, 0.06219543f, 0.02276450f, 0.00749780f, -0.23925443f, -0.03292787f, -0.15910311f, -0.02048747f, 
    -0.02164384f, -0.05254138f, -0.10546919f, -0.12465052f, -0.10081256f, -0.02139411f, -0.16803937f, 0.07906920f, 
    0.02321539f, 0.24933784f, 0.04490396f, 0.11343371f, 0.10385094f, 0.23225099f, -0.11024181f, -0.08576073f, 
    -0.15987705f, -0.03134859f, -0.12455376f, 0.09851807f, -0.05497567f, -0.07355069f, 0.05052244f, 0.04015848f, 
    0.03145482f, 0.03297285f, -0.03895272f, 0.12020525f, 0.05868299f, 0.14143477f, -0.00694297f, 0.13646053f, 
    0.08927653f, 0.13885197f, -0.22183006f, 0.03032938f, -0.09534669f, 0.03813026f, 0.03156782f, 0.25146121f, 
    -0.00272528f, -0.03453439f, -0.12000038f, 0.04050499f, -0.00111924f, -0.07707769f, -0.02795362f, 0.14445786f, 
    0.14076078f, 0.14345974f, 0.14000119f, 0.13427171f, -0.01056403f, 0.16625442f, -0.15881287f, 0.08572198f, 
    -0.19661997f, 0.07269134f, 0.09773024f, -0.22802629f, 0.04812782f, -0.20167084f, -0.02467906f, -0.06518767f, 
    0.04546930f, 0.09205068f, 0.03304080f, 0.02540687f, 0.04005611f, -0.17339790f, 0.12481046f, -0.01481219f, 
    0.02605258f, -0.07874681f, 0.01055143f, 0.08808598f, 0.22505055f, 0.05544808f, -0.06692051f, 0.11230739f, 
    -0.09671066f, -0.23491938f, -0.03443913f, 0.07962191f, 0.24408330f, -0.08368712f, 0.14970496f, 0.04527536f, 
    -0.05773739f, 0.01989474f, 0.05285440f, 0.11485956f, -0.42129648f, -0.14618964f, 0.28321046f, -0.16840799f, 
    -0.09400016f, -0.07411141f, 0.05114146f, -0.16263224f, 0.08790849f, 0.18031973f, -0.08505058f, 0.01662578f, 
    0.13136072f, 0.05995959f, -0.12409060f, 0.04992480f, 0.05585884f, 0.20681691f, -0.03797814f, 0.05255894f, 
    0.04542388f, -0.03147906f, 0.01811856f, -0.05053889f, -0.14696750f, -0.08156752f, 0.01576068f, 0.09969214f, 
    -0.02263137f, -0.13793790f, 0.00015951f, -0.03036378f, -0.05536734f, -0.19982257f, -0.06932819f, 0.01692523f, 
    -0.00325084f, 0.17883411f, 0.06218746f, 0.01982329f, 0.11055934f, -0.09604615f, -0.18954109f, -0.06989346f, 
    0.10225568f, 0.05409550f, -0.01501946f, 0.08884378f, 0.24365330f, 0.09442681f, 0.01959788f, -0.01486447f, 
    -0.07075105f, 0.05239438f, 0.05467103f, -0.03999952f, 0.09381950f, 0.06017505f, -0.02761750f, -0.15376109f, 
    -0.20378129f, -0.25302160f, 0.09024588f, 0.02262095f, -0.02219350f, -0.11630578f, 0.17683095f, 0.15984325f, 
    -0.06272517f, -0.12475615f, 0.01871594f, -0.13796870f, 0.07273566f, -0.09111689f, 0.08290957f, 0.10428035f, 
    0.09478290f, 0.20988984f, 0.10426432f, 0.14565885f, -0.04251112f, 0.14092377f, 0.09841095f, 0.13536765f, 
    -0.16804963f, -0.08731939f, -0.04446379f, -0.06905498f, -0.13344474f, -0.11863472f, -0.14462258f, 0.02736149f, 
    -0.03189908f, -0.00326570f, -0.11369012f, 0.05044125f, 0.09655391f, 0.03774954f, -0.01731638f, -0.04380378f, 
    -0.19362389f, -0.14643082f, 0.03164392f, 0.24425881f, 0.00686431f, -0.09093517f, 0.06101789f, 0.04322590f, 
    -0.02925493f, 0.15794264f, 0.00409760f, -0.00661878f, 0.00854487f, 0.04176258f, 0.05262476f, 0.06374072f, 
    -0.00814935f, -0.07161246f, 0.01632682f, -0.17825781f, 0.01846594f, 0.66822660f, -0.01554345f, 0.30855295f, 
    -0.34928629f, 0.10576655f, 0.06068973f, -0.24248458f, -0.11525213f, -0.06000242f, 0.19721296f, 0.11831154f, 
    0.10206185f, -0.02238404f, 0.11052080f, 0.07360727f, -0.01457298f, -0.00223124f, 0.03416842f, -0.03966665f, 
    -0.11867377f, -0.16665399f, -0.10923716f, 0.21455613f, -0.13197583f, 0.14453138f, -0.09582599f, -0.01224307f, 
    0.14923458f, 0.09092930f, 0.01005963f, 0.03115789f, 0.02715873f, -0.06212125f, 0.06567074f, -0.03933394f, 
    -0.01129130f, 0.03071848f, 0.17311706f, -0.04862720f, 0.02518519f, 0.17722568f, -0.08112112f, -0.01778682f, 
    -0.03100698f, 0.07285800f, -0.02255251f, 0.02841407f, -0.01310578f, -0.07349890f, 0.02300056f, 0.10676959f, 
    0.06200413f, 0.10454576f, 0.13332148f, 0.03701367f, -0.07786074f, 0.01445998f, -0.00607932f, 0.18804172f, 
    -0.00178728f, 0.08395860f, 0.02474480f, 0.06223329f, -0.11229467f, -0.08164942f, -0.04529942f, -0.03435947f, 
    -0.13656841f, -0.12095585f, -0.04240857f, -0.03485393f, -0.00134928f, -0.02845920f, -0.07869803f, 0.10441069f, 
    0.02996982f, 0.18949449f, -0.01611467f, 0.00213451f, -0.01103563f, 0.14571992f, 0.17264752f, 0.02194223f, 
    -0.12741591f, -0.07541621f, -0.08326199f, -0.06898048f, -0.14174891f, -0.17526674f, 0.14162228f, 0.10780016f, 
    0.05000819f, 0.19938140f, 0.09605211f, 0.02866179f, -0.03881628f, 0.08597799f, -0.00323196f, 0.04196131f, 
    0.08516558f, -0.03251581f, -0.01494921f, -0.07304470f, -0.22913814f, -0.01077028f, -0.06048817f, -0.06877194f, 
    -0.12733687f, 0.03220979f, 0.04225944f, 0.01099939f, 0.17232826f, 0.06412922f, 0.01045298f, 0.01516508f, 
    -0.01721294f, 0.01940216f, 0.07272365f, -0.01754559f, 0.19380638f, 0.29248789f, -0.34804654f, 0.28702906f, 
    -0.00856232f, 0.20824106f, 0.10727964f, 0.06425861f, 0.04587835f, 0.13106287f, 0.04872585f, 0.15345953f, 
    0.04390515f, -0.03058114f, 0.03521269f, 0.25466973f, 0.26367912f, 0.16746327f, 0.07024997f, 0.09632196f, 
    0.18247502f, 0.15901242f, 0.09104031f, -0.01872775f, 0.08442394f, -0.07039811f, -0.08063208f, 0.08478874f, 
    0.00105559f, -0.01684131f, 0.12211242f, 0.08319811f, -0.05079063f, 0.05232672f, 0.07370098f, 0.11792763f, 
    0.12670377f, 0.33157334f, 0.08340953f, 0.06851314f, -0.36177307f, -0.28588992f, -0.14741756f, -0.22571653f, 
    -0.07675419f, 0.13064790f, 0.05078162f, -0.02215257f, 0.02746636f, 0.08126142f, -0.05091783f, 0.00447814f, 
    -0.02687397f, -0.03753262f, -0.09160410f, 0.05203253f, 0.05721079f, 0.12101529f, -0.05087258f, 0.05606000f, 
    -0.13878858f, -0.13694687f, 0.03245379f, -0.12127460f, -0.12850834f, -0.08048303f, -0.10980397f, -0.17118007f, 
    0.03888359f, 0.02462781f, 0.06725920f, 0.22486745f, 0.11282559f, 0.17724445f, 0.05128454f, -0.00968002f, 
    0.02034472f, 0.07346415f, 0.05209745f, 0.02540549f, 0.11822455f, -0.10452855f, -0.20439650f, -0.03766067f, 
    0.19367827f, 0.04144644f, -0.07875590f, 0.15569147f, 0.25463274f, 0.04103495f, 0.04001348f, 0.03539847f, 
    -0.10863704f, -0.02778740f, 0.07180129f, 0.06841563f, 0.12023336f, 0.10320705f, -0.08361664f, -0.17678079f, 
    -0.33365366f, -0.43924624f, -0.20526125f, 0.06481200f, -0.14139666f, -0.00195365f, -0.02533616f, 0.01128499f, 
    -0.00063025f, -0.14631575f, -0.03003126f, -0.04250319f, 0.01541624f, -0.03124928f, 0.02865745f, 0.02442087f, 
    0.07920942f, 0.02200600f, 0.18808135f, 0.11753381f, 0.24448642f, -0.00652296f, -0.14017695f, 0.08335518f, 
    -0.10957193f, 0.03453465f, -0.07777033f, -0.03052254f, -0.06137852f, -0.08269064f, 0.00114608f, -0.09027116f, 
    -0.00767283f, 0.01429683f, 0.06857682f, 0.16869619f, -0.07794947f, -0.00022804f, -0.03127744f, 0.13019995f, 
    0.00785703f, 0.06785536f, -0.17156674f, -0.03663976f, -0.33906570f, 0.06254644f, -0.20412984f, -0.11959727f, 
    0.19811797f, -0.00098670f, 0.00378929f, 0.11446121f, 0.08527026f, 0.13807549f, -0.05862817f, -0.03043258f, 
    -0.07041216f, 0.08168623f, 0.00794320f, 0.03443022f, -0.12406845f, -0.09731486f, -0.09536548f, 0.23386255f, 
    0.00326430f, -0.05444036f, -0.20418099f, -0.01567072f, 0.09896015f, 0.01947043f, -0.02122458f, 0.02079320f, 
    -0.11752570f, 0.03742969f, -0.00046412f, -0.00032196f, 0.06178324f, 0.04867011f, 0.19440448f, -0.16787121f, 
    0.09392250f, 0.04147847f, 0.00851129f, 0.09899499f, -0.14280787f, 0.03841488f, 0.04703941f, 0.18222369f, 
    0.05892048f, 0.09101743f, 0.04926163f, -0.06893746f, -0.00161828f, -0.02416317f, -0.02354944f, 0.01193925f, 
    0.07007346f, 0.09016799f, 0.06891229f, 0.31045312f, -0.30148622f, -0.43439141f, -0.13444698f, -0.01939462f, 
    -0.22570632f, 0.07049622f, -0.00554927f, -0.00741201f, 0.04694450f, 0.12233263f, -0.06521104f, -0.01651975f, 
    0.00456530f, -0.06534315f, -0.03968249f, -0.05393564f, 0.05413103f, 0.03865341f, 0.04382789f, -0.15315880f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01760144f, 0.01660136f, 0.18715996f, 0.11923560f, 0.03494000f, -0.00765721f, 0.06837165f, 0.07379459f, 
    0.05720961f, 0.15909499f, 0.00975736f, 0.05619119f, -0.03755862f, 0.11445569f, -0.00068330f, -0.00245980f, 
    0.02168722f, 0.15160871f, -0.02164367f, -0.10973009f, -0.07336350f, 0.03021060f, 0.20643872f, 0.01509870f, 
    -0.04505610f, 0.04209046f, 0.05541530f, -0.05184218f, 0.13952890f, 0.02170618f, 0.02287753f, 0.09520160f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.04296038f, 0.11456921f, -0.27292839f, -0.21973023f, -0.33241656f, 0.17199077f, 0.10817423f, -0.16787718f, 
    0.12213683f, -0.53916359f, 0.08336557f, -0.63967752f, -0.03447581f, -0.09920513f, 0.16760586f, -0.09600972f, 
    -0.01731156f, -0.74404711f, -0.13222194f, 0.32226941f, 0.27369207f, -0.05638560f, -0.11489457f, 0.08307764f, 
    0.01336270f, 0.31792453f, 0.09752806f, 0.24019811f, 0.15681651f, -0.47775120f, 0.17475213f, -0.52651560f, 
    -0.15632513f, 0.05062529f, 0.01943668f, -0.03862133f, 0.23779100f, -0.17057961f, -0.20824337f, -0.30286697f, 
    0.13228881f, 0.07631791f, 0.09644665f, -0.54926610f, 0.04675246f, 0.19465086f, 0.22435153f, 0.08941003f, 
    -0.44556978f, 0.05567904f, 0.13443154f, -0.55957288f, -0.21384805f, -0.06699128f, 0.37076256f, 0.00673646f, 
    -0.12561689f, 0.23624444f, 0.33502433f, 0.26185361f, 0.24040748f, 0.13762172f, -0.05871068f, -0.11927945f, 
    -0.04905288f, 0.15425716f, -0.05171801f, 0.15531234f, 0.16838431f, 0.04183179f, -0.62547463f, 0.00545413f, 
    -0.10829291f, 0.34036124f, -0.03675640f, -0.10471981f, 0.05661250f, -0.01237313f, 0.05805856f, -0.16620182f, 
    0.53598791f, 0.13856438f, 0.16962264f, -0.29447857f, 0.19565864f, 0.17836186f, -0.09057999f, 0.12970695f, 
    -0.03116971f, -0.11537062f, 0.10020950f, -0.50127685f, -0.42311794f, -0.52533704f, 0.20072055f, -0.21839090f, 
    -0.15794633f, -0.06281016f, -0.25806984f, -0.12585105f, 0.34688002f, -0.08494627f, -0.03093165f, -0.11677393f, 
    -0.46026102f, -0.58444238f, -0.12924947f, 0.15835357f, -0.06089159f, 0.12510499f, 0.16533862f, 0.10177890f, 
    -0.06045309f, 0.04427576f, -0.06231976f, 0.40414310f, 0.11028799f, -0.21410738f, -0.79423743f, -0.01462073f, 
    -0.02742129f, 0.09293066f, 0.19884716f, -0.01369130f, -0.60041398f, -0.38666549f, 0.29649389f, -0.07776285f, 
    -0.16017208f, 0.12219263f, -0.55652851f, -0.42636961f, 0.15346690f, -0.00440386f, 0.22971229f, 0.19712162f, 
    -0.00582997f, 0.13564414f, -0.08868074f, 0.08207906f, 0.08472753f, 0.15821238f, -0.18183804f, 0.11857445f, 
    0.40846330f, -0.46939418f, 0.10304863f, -0.25786245f, 0.12645116f, 0.19681066f, -0.12015067f, 0.02126801f, 
    0.07858353f, -0.18293543f, -0.26653600f, 0.21115088f, -0.11533111f, 0.25278413f, -0.17702964f, -0.41500875f, 
    0.15179022f, -0.15850295f, -0.44072592f, 0.20719683f, -0.35627958f, 0.04537577f, 0.22875690f, 0.04895880f, 
    0.35367167f, 0.02040841f, 0.14579782f, 0.05600244f, 0.03373230f, 0.10448573f, -0.15740758f, -0.00901159f, 
    0.01470797f, 0.20516925f, 0.17043279f, -0.35225078f, 0.27148619f, -0.24733388f, -0.03928309f, 0.11913063f, 
    -0.05012573f, 0.07158242f, -0.34157902f, -0.34447968f, 0.25986314f, 0.06031678f, -0.13665083f, -0.03038263f, 
    0.01483667f, 0.08590589f, 0.22781622f, 0.40493006f, 0.03019314f, -0.15313581f, -0.74673843f, -0.02545392f, 
    0.13940713f, -0.05856827f, -0.02580442f, 0.38450283f, 0.11852673f, -0.05224956f, -0.45073539f, -0.05498299f, 
    0.18732032f, -0.15222059f, 0.10684831f, 0.15389211f, -0.81232089f, 0.23735598f, 0.08067714f, 0.12682179f, 
    -0.14585635f, -0.18216461f, -0.21063124f, -0.44391784f, -0.19822888f, -0.00342966f, -0.37191182f, 0.10257882f, 
    0.05867385f, 0.04652536f, -0.21738715f, -0.55511701f, -0.07503236f, 0.16400963f, -0.15733278f, -0.37617111f, 
    -0.21082419f, -0.34190527f, 0.11561997f, 0.12646715f, -0.11955944f, -0.59042603f, 0.09141406f, 0.00665895f, 
    -0.18412232f, -0.12730230f, 0.15692809f, 0.25502375f, 0.52758610f, 0.07497817f, -0.25216392f, -0.00768844f, 
    -0.06804848f, -0.28810802f, 0.12483049f, -0.49059689f, 0.13118635f, 0.30942169f, -0.07861457f, 0.20658749f, 
    0.02330536f, -0.15896259f, 0.42779377f, 0.30061853f, -0.48277357f, -0.09711757f, 0.17918536f, -0.65838289f, 
    -0.30263343f, 0.14395224f, -0.11211234f, 0.06895272f, 0.14242804f, -0.79453820f, -0.06748480f, 0.03405914f, 
    -0.01387996f, 0.27083755f, -0.07476626f, -0.08358973f, -0.31642750f, -0.16552040f, -0.14739025f, 0.16796128f, 
    -0.03337654f, -0.12573020f, 0.24236660f, -0.32263759f, 0.36492509f, -0.03620053f, 0.31287992f, 0.03994266f, 
    0.06463566f, -0.05141398f, 0.04438334f, -0.74231970f, -0.08691676f, -0.16599041f, -0.06010000f, 0.22590308f, 
    -0.17659858f, 0.16382572f, -0.14769047f, 0.18760037f, -0.07724347f, 0.47491246f, -0.51682204f, 0.10211632f, 
    -0.40808284f, -0.11258572f, -0.07528254f, -0.02355087f, 0.04820730f, 0.25821781f, 0.07779187f, 0.07506344f, 
    -0.09351502f, -0.38692090f, 0.47057328f, -0.10817497f, -0.29340151f, -0.24287286f, -0.43256652f, 0.10998876f, 
    -0.18088993f, -0.11376746f, 0.19121678f, 0.45475677f, -0.16228911f, 0.01105454f, -0.18192096f, 0.08403280f, 
    -0.79480946f, 0.09822826f, 0.14397122f, 0.28562158f, 0.00423995f, 0.12103060f, 0.32754591f, 0.10435319f, 
    -0.58270794f, -0.16085301f, -0.00797162f, 0.09148066f, -0.26450464f, -0.50490868f, 0.22920588f, -0.06000509f, 
    0.10147206f, -0.22577666f, -0.43879238f, 0.23956597f, 0.08494155f, -0.17767349f, -0.28434947f, 0.10913667f, 
    0.15169391f, -0.00645689f, -0.32589701f, 0.27551645f, 0.35158321f, 0.05776774f, -0.05968178f, 0.33999175f, 
    -0.35621360f, 0.38854000f, -0.02825738f, -0.00425521f, -0.08928680f, -0.67046922f, -0.24134506f, -0.12534718f, 
    -0.76482213f, 0.13363129f, -0.11761238f, 0.28314799f, -0.42013624f, 0.16828035f, 0.12057623f, -0.06638891f, 
    -0.06416514f, 0.46018904f, -0.32752478f, -0.38176587f, -0.00127389f, -0.25462914f, 0.17461057f, -0.02062807f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.30833101f, 0.14059833f, 0.04391126f, -0.03141184f, 0.07696518f, -0.14771964f, 0.10560559f, -0.16420797f, 
    -0.07055620f, 0.14677465f, 0.12345103f, -0.08810762f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
