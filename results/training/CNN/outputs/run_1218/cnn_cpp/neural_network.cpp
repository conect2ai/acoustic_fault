#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.27585271f, -0.00179158f, 0.10443019f, 0.56609619f, -0.01244706f, -0.12178868f, -0.37521216f, -0.41638297f, 
    -0.07166438f, -0.06021026f, 0.43788853f, -0.31924191f, 0.06928279f, 0.15798895f, -0.31484380f, 0.15281437f, 
    0.25743222f, 0.29536140f, -0.07372016f, -0.28703010f, -0.03432326f, 0.14264038f, 0.39711952f, 0.06012329f, 
    0.27224141f, 0.07317748f, 0.16691451f, 0.31580606f, 0.54015273f, 0.34341037f, 0.01704770f, -0.04721020f, 
    0.01828505f, -0.08545750f, 0.33459920f, 0.45158377f, 0.25873688f, -0.15459888f, -0.34437242f, 0.03681659f, 
    0.07045311f, 0.13982563f, -0.01982021f, 0.21426755f, -0.31052217f, -0.24937254f, -0.21665040f, -0.17496769f, 
    0.02352478f, -0.35562545f, 0.37702608f, 1.24878693f, 0.37257630f, 0.25549701f, -0.29683241f, -0.60825396f, 
    -0.76210469f, -0.19692974f, 0.16008349f, 0.01305906f, 0.04161994f, -0.31500149f, -0.22477193f, 0.22677507f, 
    -0.33861333f, 0.18278298f, 0.03542314f, -0.17774938f, 0.21017526f, -0.15083176f, -0.05888001f, -0.04978384f, 
    -0.08598137f, -0.09002623f, 0.04482567f, 0.71130532f, 0.00048785f, -0.21846023f, -0.42220092f, -1.10066938f, 
    -0.13202606f, 0.02554219f, 0.13791509f, 0.35471860f, 0.00184310f, 0.05559790f, -0.20760059f, 0.51499969f, 
    -0.18534909f, 0.09570764f, -0.43114963f, -0.13379830f, 0.10818376f, -0.02557435f, 0.04474369f, -0.16147910f, 
    -0.04885448f, 0.31283930f, -0.01315108f, 0.00453355f, -0.69964141f, -0.35110402f, -0.49060613f, -0.66993618f, 
    -0.52194703f, 0.19836567f, -0.02758496f, -0.28525677f, -0.05941224f, 0.25583202f, -0.13535577f, -0.31217855f, 
    -0.38202992f, -0.43889767f, -0.22164805f, -0.04840708f, 0.22272950f, -0.06018146f, 0.15566042f, -0.39704895f, 
    0.12444814f, -0.04603335f, -0.20950115f, 0.01146293f, 0.37964335f, 0.48326468f, 0.29742685f, -0.63640881f, 
    -0.11795791f, 0.10877344f, 0.33465621f, 0.10363705f, -0.12381047f, -0.18338536f, -0.24692845f, 0.82834750f, 
    -0.44809300f, -0.07532921f, -0.03048779f, -0.06283601f, 0.15057330f, 0.24061930f, -0.08384582f, -0.36709329f, 
    0.06002446f, -0.28025696f, 0.05196449f, 0.03445367f, 0.15616795f, 0.28134173f, 1.02546024f, -0.27414829f, 
    -0.07828920f, -0.26346895f, -1.01665759f, 0.46946514f, 0.15273601f, 0.01108686f, -0.01469349f, 0.33881670f, 
    -0.04642631f, -0.25170824f, -0.34546095f, 0.32338065f, -0.14796354f, -0.12570626f, 0.08062156f, 0.05654660f, 
    -0.08431618f, -0.27959052f, -0.20144683f, -0.17810982f, -0.18797281f, 0.26322320f, -0.24345303f, -0.52002770f, 
    -0.12525114f, 0.34155622f, 0.47745031f, 0.22260901f, -0.57328773f, -0.12672210f, -0.82155699f, -0.40554827f, 
    0.11154202f, 0.01084722f, -0.57188946f, -0.24433060f, -0.17367004f, 0.39042518f, -0.02445865f, 0.46443149f, 
    0.02242107f, 0.20727405f, 0.35644928f, 0.10591632f, 0.06960810f, -0.07459385f, -0.24762653f, -0.36017033f, 
    0.07923841f, -0.34365720f, -0.50499576f, -0.27167112f, -0.58473212f, -0.65438098f, -0.22357485f, -0.51261210f, 
    -0.22606468f, -0.75253743f, 0.19689344f, 0.32584208f, 0.21111786f, -0.16094570f, 0.19250013f, -0.18338889f, 
    -0.20955011f, 0.14146154f, 0.09494810f, 0.02941057f, 0.08565225f, 0.15878183f, -0.20304598f, -0.16702725f, 
    0.29575241f, 0.64635748f, 0.33693287f, 0.04420302f, 0.08323670f, -0.05995923f, 0.00820313f, -0.02129874f, 
    -0.03885596f, 0.04303837f, 0.08104546f, -0.02664496f, -0.06402001f, 0.07949435f, -0.28573155f, -0.09104301f, 
    -0.27529696f, -0.20269577f, -0.07138847f, 0.10238236f, -0.08243322f, 0.06576809f, 0.26888981f, -0.27621135f, 
    0.26998562f, 0.47127801f, 0.18266816f, -1.27564466f, -0.44530833f, 0.61414498f, 0.68071759f, -0.00119373f, 
    0.51846415f, 0.05755647f, 0.12712756f, -0.19981268f, -0.22154371f, -0.39740145f, -0.45468688f, 0.11591045f, 
    -0.07014085f, 0.10873354f, 0.18352149f, -0.01064953f, 0.13410218f, -0.33297136f, -0.23078696f, -0.08205609f, 
    -0.30730429f, -0.23925386f, -0.55547416f, -1.15054667f, 0.00627387f, -0.53419888f, -0.62715274f, -0.12771478f, 
    0.44919732f, -0.00963515f, 0.21143396f, 0.14396909f, 0.39553973f, 0.15089063f, -0.03852527f, -0.03691654f, 
    0.02927724f, 0.02479359f, 0.02663361f, -0.03051380f, 0.10595853f, 0.16282667f, -0.13073258f, -0.29054412f, 
    -0.02907101f, 0.17844835f, -0.38468084f, -0.31494898f, 0.07384817f, -0.65009749f, -0.78128016f, -0.50532067f, 
    0.25506222f, 0.52387440f, 0.41924620f, 0.42038137f, 0.44358984f, 0.04671825f, -0.24916506f, -0.05560194f, 
    0.39576662f, -0.05690019f, 0.24223377f, -0.22236958f, -0.19442138f, -0.13181509f, -0.06584781f, -0.49157473f, 
    0.11473025f, -0.12669514f, 0.34466910f, 0.15571721f, 0.25203601f, -0.80813187f, 0.70095795f, -0.06910462f, 
    -0.22710863f, 0.19556010f, -0.33284646f, -0.13825746f, 0.82274264f, -0.03441013f, -0.31867975f, 0.06524473f, 
    0.07529208f, -0.01062726f, -0.10288698f, 0.25588936f, -0.08823667f, -0.25388032f, 0.25703079f, 0.03380695f, 
    -0.03697938f, -0.10540863f, 0.04909895f, -0.04313297f, 0.26258835f, 0.29302558f, 0.36068049f, 0.42997187f, 
    0.37649822f, -0.17645027f, -0.61841279f, -0.03243584f, -0.08218057f, -0.23953503f, -0.35538271f, -0.02283366f, 
    0.18555671f, 0.27483895f, 0.36803687f, 0.48716453f, 0.20081945f, 0.09703969f, -0.03738301f, 0.50144815f, 
    -0.29058713f, 0.25401103f, 0.23343976f, -0.08660273f, 0.02013955f, 0.41953710f, -0.13528611f, 0.51375407f, 
    -0.06714361f, 0.06644399f, 0.00383463f, 0.38661274f, -0.23774804f, -0.36663303f, 0.39438662f, 0.12997442f, 
    0.42785197f, -0.05073024f, 0.35192332f, -0.31786254f, -0.27915391f, 0.31926459f, -0.23249151f, 0.03927937f, 
    -0.34478438f, 0.06649505f, 0.11725338f, -0.16626656f, 0.49062145f, 0.19331855f, -0.28030860f, -0.15343879f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.24441767f, -0.19530226f, 0.28962266f, 0.29132304f, 0.08663260f, 0.19378275f, 0.21057735f, 0.16038278f, 
    0.00126166f, 0.22770557f, 0.06437443f, 0.09381077f, -0.09766769f, 0.32199928f, -0.05325191f, 0.36563417f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.11878038f, -0.12456547f, 0.00837962f, -0.07304657f, 0.00209927f, 0.19076920f, 0.13797286f, 0.22007516f, 
    -0.02795100f, 0.02266937f, -0.08977172f, -0.04746995f, 0.18541120f, 0.08957522f, -0.03310684f, -0.08816825f, 
    -0.04803358f, 0.01760018f, 0.02378895f, 0.06995702f, -0.16087045f, -0.02680216f, -0.04509600f, -0.12140278f, 
    0.25632423f, -0.12850109f, -0.04514219f, -0.04640961f, 0.20681232f, 0.30476943f, 0.20488651f, -0.05096524f, 
    -0.07481165f, -0.07587845f, -0.06844923f, -0.03974067f, 0.20910081f, 0.23025119f, -0.38928097f, 0.08977789f, 
    0.03219503f, 0.07184339f, -0.01736599f, -0.14208977f, 0.11644844f, 0.08818763f, 0.02623751f, -0.00416994f, 
    -0.30933931f, -0.25599232f, 0.06075745f, -0.01255800f, -0.03590790f, -0.04265403f, -0.03825322f, -0.11738314f, 
    0.09207756f, 0.07344373f, -0.03277263f, 0.08551954f, -0.08721993f, 0.06391469f, 0.14505313f, -0.03417374f, 
    -0.11914258f, -0.19084439f, -0.07614748f, 0.21608396f, -0.04942762f, 0.03316255f, 0.03796017f, -0.00946744f, 
    -0.07770523f, 0.30219740f, 0.08573586f, -0.02972354f, -0.06748790f, -0.01734667f, 0.15945686f, 0.02297075f, 
    -0.04841750f, 0.08062322f, -0.07103972f, -0.08775582f, -0.09920261f, -0.28217724f, 0.02545650f, -0.08274724f, 
    0.17626399f, 0.04458208f, 0.26182693f, 0.08548070f, 0.04331062f, -0.01445535f, -0.02677221f, 0.08035249f, 
    -0.23509407f, -0.21182552f, -0.17907631f, -0.15887868f, 0.19811565f, 0.07993978f, 0.06669518f, -0.25400749f, 
    -0.04863426f, 0.08369467f, -0.01963048f, 0.03420201f, -0.03358478f, -0.08505157f, -0.15688546f, -0.25775623f, 
    0.09740408f, -0.05344459f, 0.04484930f, 0.07275438f, 0.00399609f, 0.01038359f, 0.00965581f, -0.08301014f, 
    0.17571336f, -0.09289739f, -0.13942726f, 0.14652103f, 0.10025144f, -0.15514901f, 0.14386402f, 0.12262537f, 
    0.18804216f, 0.17759684f, 0.23537138f, -0.09895933f, -0.18436965f, -0.07112724f, 0.02555287f, -0.10440923f, 
    -0.02841236f, -0.13808689f, 0.06658905f, -0.01778837f, 0.12492763f, 0.03455242f, 0.03453514f, -0.01691193f, 
    -0.36251771f, -0.11781960f, 0.25240538f, 0.11451125f, 0.03696152f, -0.10565840f, 0.10495439f, -0.04156879f, 
    -0.05579736f, -0.00240783f, -0.02227148f, 0.15709546f, 0.04548066f, 0.16365983f, -0.03947236f, 0.10239042f, 
    0.13197397f, 0.09632377f, 0.23890100f, 0.12257951f, 0.23227236f, -0.02411994f, 0.16831276f, 0.12025656f, 
    -0.02482298f, -0.23721340f, 0.02185616f, -0.04191088f, -0.24332032f, -0.15730923f, 0.10252815f, 0.08017508f, 
    0.04773467f, -0.00024581f, 0.02620862f, 0.08488720f, 0.23177260f, 0.18881112f, 0.08894052f, 0.26354167f, 
    -0.09349900f, 0.00697989f, -0.01849638f, -0.03583741f, 0.05910112f, -0.01684217f, 0.12214231f, 0.17374682f, 
    -0.22146735f, -0.25719258f, 0.12537603f, 0.21817036f, 0.09441547f, 0.18159533f, -0.07278664f, -0.16342247f, 
    0.00382722f, -0.07556327f, 0.02031324f, 0.14180355f, 0.05620598f, 0.01974480f, 0.11856262f, -0.30246317f, 
    -0.00514874f, 0.03391321f, 0.03884105f, -0.03967034f, -0.03023662f, -0.07626534f, -0.08950497f, 0.05067619f, 
    -0.09559262f, 0.13934053f, 0.12725322f, -0.01169818f, -0.16288532f, 0.03161652f, 0.17554936f, -0.00371310f, 
    -0.05498822f, 0.08044710f, -0.08358453f, -0.02870247f, -0.09790186f, 0.24809454f, -0.04267636f, 0.55578578f, 
    0.10332655f, 0.03895486f, 0.05050619f, 0.03027349f, -0.20014530f, 0.07869638f, 0.10810088f, 0.07079712f, 
    -0.27228481f, -0.42803428f, -0.13698657f, 0.36101955f, 0.03486736f, -0.03673503f, 0.00283610f, 0.02970586f, 
    -0.00734438f, -0.07680979f, -0.07871785f, 0.15865432f, 0.04760965f, 0.20209830f, 0.20627275f, 0.14013301f, 
    -0.04681705f, -0.13478169f, -0.02109737f, 0.02490793f, -0.00767614f, -0.02570731f, 0.11656404f, 0.00626252f, 
    -0.42393240f, 0.24444690f, 0.29594943f, 0.27577692f, -0.12157210f, 0.13576695f, -0.17667565f, 0.03178739f, 
    0.12777488f, -0.06515289f, 0.09993701f, 0.07556525f, -0.12416994f, -0.12677953f, 0.14396538f, 0.27726060f, 
    0.17191544f, 0.12891671f, 0.01194948f, -0.04671536f, -0.07383088f, -0.01247543f, -0.04264373f, 0.01342625f, 
    -0.25802049f, -0.36550277f, -0.05719525f, 0.16950797f, 0.04957677f, 0.08536594f, 0.13135722f, 0.00053041f, 
    -0.12193313f, 0.03625628f, 0.03864426f, 0.02830639f, -0.28629237f, 0.13030200f, 0.03603477f, -0.16609573f, 
    0.22341812f, -0.18069342f, -0.01880466f, -0.00069859f, 0.02614390f, 0.05721730f, 0.04416319f, 0.08582919f, 
    0.04836552f, 0.39587998f, -0.11335121f, -0.21069399f, -0.09067942f, 0.03970416f, 0.13031027f, -0.16316827f, 
    0.03377058f, 0.01279537f, 0.05074696f, -0.08691014f, 0.49397933f, -0.30111554f, -0.06293578f, -0.02367895f, 
    0.19700386f, 0.02025882f, 0.20401877f, 0.11557601f, 0.07576992f, -0.05894948f, 0.03352703f, -0.03623292f, 
    0.03083798f, -0.01778500f, 0.01865429f, -0.07116850f, -0.02736332f, 0.04495129f, 0.05865097f, -0.02130209f, 
    0.26376298f, 0.22777845f, -0.05425278f, 0.26065528f, 0.52401215f, 0.11982205f, -0.23191798f, 0.10464400f, 
    -0.04408694f, 0.00903622f, 0.21901940f, -0.02667364f, 0.15301801f, 0.01751131f, 0.11544681f, 0.17056070f, 
    -0.46567136f, -0.30430424f, -0.10512060f, -0.03436656f, -0.18098104f, -0.00636121f, -0.11309509f, 0.11855967f, 
    0.01190234f, -0.07160205f, -0.01820567f, -0.10340510f, -0.20615411f, 0.08798970f, 0.12831694f, -0.13646463f, 
    -0.09222797f, -0.10610045f, -0.00839855f, -0.23157591f, -0.02038865f, 0.06712978f, 0.06756008f, 0.11636027f, 
    0.00346283f, -0.02736784f, -0.03380954f, 0.02308746f, 0.05132714f, 0.06074369f, 0.00625245f, -0.05356922f, 
    0.06600886f, -0.02736570f, 0.05709140f, 0.02225472f, -0.03259954f, -0.02530074f, -0.04385531f, 0.04318863f, 
    -0.02985578f, -0.02846000f, 0.01691935f, -0.02429517f, -0.04268463f, 0.04472698f, 0.05316889f, 0.02378351f, 
    -0.01590729f, 0.05129787f, -0.01060422f, 0.01458998f, -0.05416456f, 0.03312103f, -0.05618067f, -0.04506518f, 
    -0.05686625f, -0.04523491f, 0.04971767f, -0.06190189f, -0.07427271f, 0.05112920f, 0.06264466f, 0.01314667f, 
    0.02426664f, 0.05959895f, -0.05000574f, -0.05512041f, 0.05516214f, -0.04768502f, 0.01928709f, 0.00851017f, 
    -0.07680925f, 0.05077118f, -0.00159415f, -0.04348530f, 0.02170756f, 0.02670968f, -0.07572705f, 0.02445595f, 
    -0.03069141f, 0.03208983f, -0.02256320f, -0.02441310f, 0.05919627f, -0.01113307f, -0.03086645f, -0.01106777f, 
    -0.04651973f, 0.02347972f, -0.02825951f, 0.05731929f, 0.02006456f, -0.05585133f, -0.07638411f, -0.05054691f, 
    0.06190319f, -0.01004169f, -0.00068672f, -0.01218155f, 0.06391318f, 0.05827203f, -0.00910630f, 0.01769343f, 
    -0.04630686f, 0.04146532f, -0.04586417f, -0.03084748f, -0.06204537f, -0.02541004f, 0.05250198f, -0.01515067f, 
    -0.02867576f, -0.04663888f, -0.05289467f, -0.00449852f, -0.07286217f, -0.02999059f, 0.06631895f, -0.05400366f, 
    0.04002646f, 0.03571293f, -0.00091425f, -0.01229978f, -0.07808819f, 0.01914842f, 0.05007820f, -0.02326979f, 
    -0.06622145f, -0.02625080f, 0.01467497f, -0.06490234f, 0.00549199f, -0.01725863f, -0.07265712f, -0.05839310f, 
    0.01666296f, -0.03424323f, -0.06086026f, -0.04581087f, 0.04918786f, -0.03774457f, -0.00097908f, 0.00653163f, 
    0.03943538f, 0.05377772f, 0.00207598f, 0.06268059f, 0.00117146f, 0.00676971f, -0.06387476f, 0.04677809f, 
    -0.01121749f, -0.01936652f, -0.06889730f, -0.02126910f, -0.05429608f, 0.01192836f, -0.05758409f, -0.04401545f, 
    0.02824846f, 0.04306563f, -0.06823412f, -0.00841399f, -0.04293617f, -0.06850461f, -0.04849108f, -0.05255483f, 
    0.03865180f, 0.04640633f, 0.00013831f, 0.04352329f, -0.02828760f, -0.05297571f, -0.06221931f, 0.03727665f, 
    0.06551516f, -0.02243506f, -0.06380534f, -0.06697883f, -0.05905283f, -0.03303576f, -0.07326055f, -0.03261577f, 
    -0.05153359f, 0.03434094f, -0.01533288f, -0.07447913f, -0.01550102f, -0.07159792f, -0.03592158f, 0.04141231f, 
    -0.04181695f, -0.03205909f, -0.04976640f, -0.01526337f, -0.05609099f, 0.02820004f, 0.03755856f, 0.02895609f, 
    -0.06468493f, 0.06021291f, 0.05149513f, 0.03217439f, -0.00632348f, 0.06307104f, -0.05508712f, 0.03925763f, 
    0.03989429f, 0.03707627f, 0.01050751f, 0.03039145f, -0.01487640f, -0.01728862f, -0.04354227f, -0.02252809f, 
    -0.13936703f, 0.05987769f, -0.02516856f, -0.03648724f, 0.05985126f, 0.01100346f, 0.08714978f, -0.03510715f, 
    -0.05058176f, 0.23947565f, 0.08723217f, 0.15335153f, -0.20787892f, -0.19964352f, -0.02439072f, -0.15972923f, 
    -0.19168878f, -0.01875778f, -0.10833097f, -0.17799814f, -0.03757649f, 0.09699556f, -0.13713047f, 0.13472442f, 
    -0.48884305f, 0.08812456f, 0.18934542f, -0.25948623f, -0.31881267f, -0.15006456f, -0.17174992f, -0.06552462f, 
    0.04513268f, 0.01706763f, 0.01042781f, -0.10435560f, -0.24269699f, -0.06424193f, 0.31128854f, 0.29689199f, 
    -0.13480102f, -0.03181701f, -0.13055325f, 0.07603192f, 0.02369593f, 0.09389827f, 0.14346564f, 0.15722424f, 
    0.31417972f, 0.01589522f, 0.16031966f, 0.32511541f, 0.10580910f, 0.02503375f, 0.01730495f, -0.11305407f, 
    -0.02868672f, 0.11738861f, -0.05261214f, -0.03778908f, -0.14434935f, -0.00539515f, -0.09758060f, 0.40455502f, 
    -0.05959594f, -0.08912076f, 0.14177297f, -0.11824603f, -0.11319859f, 0.17758656f, -0.12199114f, -0.02626536f, 
    -0.26286739f, -0.00395088f, 0.36031362f, 0.32688433f, 0.01611288f, -0.07601333f, -0.24628073f, -0.08925246f, 
    0.07789446f, 0.12612593f, 0.04330521f, 0.04426988f, 0.05350680f, 0.12234114f, -0.04685228f, -0.05329249f, 
    0.02773857f, 0.13088506f, -0.16344279f, -0.22621267f, -0.14816616f, 0.01318343f, 0.03899940f, -0.02792699f, 
    -0.06114734f, -0.13435145f, -0.06470460f, 0.16679919f, -0.02041537f, 0.20939015f, -0.05316600f, 0.18850918f, 
    -0.03637249f, -0.07161337f, 0.03994416f, -0.09012648f, -0.24825060f, 0.11637332f, 0.15694828f, 0.16502480f, 
    -0.04148651f, -0.06476509f, -0.05422167f, -0.06934971f, -0.04138490f, 0.03827647f, 0.08448964f, 0.18477233f, 
    -0.17940399f, 0.56401467f, -0.01773270f, -0.05329728f, -0.05346055f, 0.13126168f, -0.15666270f, -0.06259102f, 
    -0.11842462f, 0.07235292f, -0.13521846f, 0.02368600f, 0.40335676f, 0.04974224f, 0.05093342f, 0.23842759f, 
    0.15327010f, 0.08819058f, 0.05903201f, -0.01384563f, -0.23774233f, 0.16623151f, 0.00206360f, -0.10689750f, 
    0.27573818f, 0.60977602f, -0.13106206f, 0.26577753f, 0.05964587f, 0.11857881f, 0.12597546f, 0.05022537f, 
    -0.01014886f, 0.17681506f, -0.00747256f, 0.06851513f, 0.39589435f, -0.47311604f, 0.20171425f, -0.26887864f, 
    -0.02645290f, -0.04517055f, 0.27006432f, 0.05498661f, 0.09048241f, 0.13616276f, 0.12473585f, 0.07152410f, 
    -0.19546670f, -0.14290901f, 0.12119903f, 0.03809614f, 0.26036903f, 0.07081206f, 0.08111975f, 0.00387371f, 
    0.09439520f, 0.07846726f, 0.05187411f, 0.19639687f, -0.32142830f, 0.05036631f, 0.05855661f, -0.16758838f, 
    -0.15222287f, -0.09433336f, -0.09707955f, -0.15567145f, -0.14414847f, 0.13131885f, -0.04482841f, -0.03303183f, 
    0.09373672f, -0.07339284f, -0.25250965f, -0.10140514f, 0.02506945f, 0.06982562f, 0.16277125f, 0.15500829f, 
    0.11460867f, 0.02063536f, -0.18439476f, -0.16715373f, -0.31693757f, -0.04498113f, -0.28824681f, -0.09874298f, 
    -0.07638304f, 0.03299826f, -0.04002210f, -0.14705305f, 0.14730185f, 0.09925795f, 0.10459454f, -0.08146919f, 
    0.19221146f, -0.07631323f, -0.53420174f, 0.10138768f, -0.03076842f, -0.07741395f, 0.05253292f, -0.13470913f, 
    -0.05695621f, 0.03712982f, -0.08835182f, -0.01149816f, 0.34873441f, 0.15465361f, 0.03524166f, -0.24012925f, 
    -0.01886873f, -0.13175929f, 0.21527755f, 0.12297855f, 0.14713737f, -0.07027872f, 0.01635486f, -0.11184163f, 
    -0.13943405f, 0.02155714f, 0.12349548f, -0.22580843f, -0.11217428f, -0.03265541f, 0.12657246f, 0.07406580f, 
    0.05814358f, 0.06751648f, -0.00871587f, -0.06274310f, 0.26813993f, -0.19443266f, 0.01144213f, 0.10295702f, 
    -0.01275495f, 0.12324423f, 0.24650553f, 0.28049257f, 0.25333914f, -0.09097008f, 0.15528041f, 0.12034670f, 
    0.53778470f, 0.14373833f, -0.14624524f, -0.10472120f, 0.07721677f, -0.12209556f, 0.18585593f, 0.18828416f, 
    0.02207897f, 0.11173126f, 0.04104682f, 0.01873300f, -0.00068770f, -0.12548965f, -0.09721762f, 0.09943319f, 
    -0.04276681f, 0.05743143f, 0.14876036f, 0.08953883f, 0.13600844f, 0.06434864f, -0.10139805f, 0.08865595f, 
    -0.08561023f, 0.21125926f, 0.12641472f, -0.12911418f, -0.20592526f, -0.14661013f, 0.13382077f, -0.05041573f, 
    -0.01994513f, 0.04582469f, -0.12025187f, 0.00167015f, 0.32009754f, -0.19829762f, -0.00741393f, 0.01516256f, 
    -0.13169804f, 0.03052451f, 0.00027598f, -0.22060303f, 0.02036476f, -0.10653381f, -0.10557798f, -0.06493288f, 
    -0.11881497f, -0.22083248f, 0.23261184f, 0.12488818f, -0.08903164f, 0.11864728f, -0.21505615f, 0.16731687f, 
    0.17586446f, 0.05268376f, 0.13273656f, 0.20207192f, -0.52708203f, 0.22778219f, 0.24132986f, 0.00976612f, 
    -0.22657281f, -0.16743036f, -0.04472471f, -0.00531064f, 0.12185889f, -0.02605664f, 0.11384976f, 0.14686126f, 
    -0.12052534f, 0.16352023f, 0.19020361f, -0.13153912f, -0.11513978f, -0.03972989f, -0.26472643f, 0.12855008f, 
    0.00771802f, -0.01176945f, 0.20001210f, -0.04147177f, -0.52277231f, 0.01135665f, 0.04078453f, 0.09774039f, 
    0.12754038f, 0.31473115f, -0.11297724f, 0.06679447f, -0.05232240f, 0.09114192f, -0.10416970f, -0.04912549f, 
    0.31453806f, 0.14238335f, -0.12260532f, -0.01750857f, 0.09196907f, 0.18033254f, 0.15875934f, 0.03358008f, 
    0.13201183f, 0.02159267f, 0.01348350f, -0.05907295f, 0.23838542f, 0.03599006f, -0.18967831f, 0.07938235f, 
    0.03245527f, 0.03438104f, 0.14498636f, 0.08906847f, 0.05584699f, -0.02560954f, 0.22549693f, -0.02308082f, 
    0.13100328f, 0.04639198f, 0.02575024f, 0.13664615f, 0.03286612f, -0.12074075f, -0.10786859f, -0.00083959f, 
    0.02974960f, -0.00614943f, 0.07301021f, 0.11199453f, 0.09844159f, -0.17526194f, 0.09578259f, 0.12006660f, 
    -0.08597215f, 0.07123330f, 0.01792720f, -0.03831468f, 0.25065848f, 0.10973964f, 0.09106116f, -0.06037614f, 
    0.14000563f, 0.56059396f, -0.21356319f, 0.40726665f, 0.02255906f, -0.05363310f, 0.00741917f, -0.01923629f, 
    0.08212514f, -0.00014333f, 0.10777885f, 0.13994622f, -0.52245218f, -0.12649119f, -0.27283150f, -0.91579074f, 
    0.24493219f, -0.22643352f, 0.12530062f, 0.20523967f, -0.13291347f, -0.04068891f, 0.25095552f, -0.24792705f, 
    -0.22368753f, -0.33350876f, -0.27245185f, -0.64555776f, 0.04569320f, 0.19941112f, -0.00646172f, 0.23865266f, 
    0.06578630f, -0.09630991f, -0.07571883f, -0.01000144f, 0.21412218f, 0.19114688f, -0.05925623f, -0.15416208f, 
    0.17596591f, 0.20465739f, 0.06257563f, -0.03824090f, 0.06455292f, 0.29857084f, -0.20331351f, 0.09941811f, 
    0.25634521f, 0.10546133f, 0.07256095f, -0.19552484f, -0.03145506f, 0.13805848f, -0.10034472f, 0.12702481f, 
    0.18464760f, 0.11039645f, -0.18341613f, -0.05320730f, -0.08078443f, 0.11757614f, 0.09445039f, -0.57872266f, 
    0.19950753f, -0.07429168f, -0.16802140f, 0.19733620f, -0.13729681f, 0.04264486f, 0.00681279f, 0.06273327f, 
    -0.37824538f, 0.13854808f, -0.13730600f, -0.36083937f, 0.04623314f, -0.08833015f, 0.16608259f, 0.29569748f, 
    -0.17471856f, -0.03485053f, -0.02327172f, -0.01815390f, 0.22822784f, 0.09475929f, 0.08274417f, 0.22953272f, 
    -0.01513392f, 0.07583825f, -0.02168536f, -0.08742536f, 0.06158121f, 0.00111404f, -0.01474111f, 0.14235479f, 
    0.16259807f, -0.04074884f, 0.25058699f, -0.10934622f, -0.06739311f, 0.00905804f, -0.21294087f, -0.32319590f, 
    -0.02323924f, -0.17830281f, -0.06952125f, -0.15243427f, 0.13857588f, -0.05109594f, 0.15910980f, -0.12639162f, 
    0.00012525f, -0.05269567f, -0.34688720f, -0.10705502f, 0.18536973f, -0.10405437f, 0.02512700f, 0.05919805f, 
    0.56269807f, -0.10109903f, 0.28178722f, 0.01941260f, 0.10582565f, -0.08647601f, -0.02949991f, -0.24312364f, 
    -0.06479381f, -0.06848201f, 0.15169482f, -0.14856328f, -0.16277486f, 0.02231237f, -0.08574556f, 0.25830671f, 
    -0.02687947f, -0.02684111f, 0.30218396f, -0.16958246f, 0.00896875f, 0.03703542f, 0.15378632f, -0.04247351f, 
    -0.11801585f, 0.19233207f, -0.03071818f, -0.12384685f, -0.01550868f, 0.14051989f, -0.01226035f, 0.18350406f, 
    -0.06517407f, -0.06119639f, 0.06269743f, -0.06038815f, -0.11836423f, 0.04629518f, 0.15498042f, -0.14541358f, 
    0.08428850f, 0.03224770f, 0.01610710f, -0.10308047f, 0.14596897f, 0.11351163f, -0.17192337f, -0.07228243f, 
    0.06436982f, -0.05529432f, 0.34027269f, 0.18843076f, 0.00571609f, 0.12231573f, 0.03439784f, -0.04054451f, 
    -0.00285604f, -0.09387355f, -0.02115185f, -0.21461892f, 0.05291553f, 0.14373732f, -0.19498357f, -0.07670455f, 
    -0.12211177f, -0.01095738f, 0.10821046f, -0.04033667f, -0.00710933f, 0.16892782f, -0.02727188f, 0.35536757f, 
    0.29477420f, -0.14064662f, 0.45064065f, 0.07371309f, -0.04063822f, -0.05904843f, -0.03953814f, 0.17107283f, 
    0.07971530f, -0.09506559f, 0.01318120f, -0.15514903f, -0.14525276f, -0.12411559f, 0.11397615f, 0.19868609f, 
    0.06129884f, 0.03084178f, 0.05282573f, 0.05887514f, -0.26622054f, 0.11968585f, -0.05983632f, -0.03631898f, 
    0.04088132f, -0.05018727f, -0.03844375f, 0.07708714f, 0.04394493f, -0.05119364f, 0.03843017f, 0.02557764f, 
    -0.03868008f, 0.07603080f, 0.06920612f, 0.23599401f, -0.31990358f, -0.12899050f, -0.04134011f, 0.20163548f, 
    -0.00655154f, 0.17742260f, -0.04637300f, 0.04030971f, 0.11503989f, -0.05020746f, 0.07405660f, -0.31389990f, 
    -0.80425662f, -0.23703699f, 0.03854664f, 0.12823246f, -0.12169234f, -0.05929144f, 0.14202750f, -0.03951344f, 
    0.01611428f, 0.04283712f, 0.17450891f, 0.20755067f, 0.10177098f, 0.18110763f, 0.05351612f, 0.15904033f, 
    -0.09281028f, -0.02029275f, 0.16247177f, -0.12305211f, 0.24008679f, 0.13127783f, -0.08102521f, 0.11981939f, 
    0.09307573f, -0.19627215f, -0.02472205f, 0.02345387f, 0.06695388f, -0.05242754f, 0.00263141f, 0.17922227f, 
    -0.04414619f, -0.01433935f, 0.02718037f, -0.08146882f, -0.07347199f, 0.08217220f, 0.02068394f, -0.34536105f, 
    0.09835693f, 0.03411307f, -0.04664654f, 0.06874911f, -0.07668558f, 0.01844511f, -0.14362434f, -0.38947961f, 
    -0.10063799f, 0.15625833f, -0.37286919f, 0.14689320f, 0.22392188f, -0.08089681f, 0.18708895f, 0.19517796f, 
    0.05819177f, 0.26605552f, 0.10217692f, 0.23007642f, 0.32419252f, -0.29968375f, -0.11226200f, 0.22364108f, 
    0.08345805f, -0.00187112f, 0.02044046f, 0.05015099f, -0.02799433f, -0.05732645f, 0.16716726f, 0.22476265f, 
    -0.33530456f, -0.33837026f, -0.10791492f, -0.02487984f, 0.14730625f, 0.12005684f, 0.07048824f, -0.12993297f, 
    -0.07092117f, -0.15751794f, -0.00324333f, 0.02958924f, 0.51398218f, 0.26470545f, -0.12823597f, -0.23315406f, 
    0.18991856f, -0.17129397f, -0.15368380f, -0.06995936f, -0.00320632f, -0.04976922f, -0.09451619f, -0.11842169f, 
    -0.02508533f, 0.11431344f, 0.26749748f, 0.25214070f, 0.08461295f, -0.15744823f, 0.00491605f, -0.05342130f, 
    0.16870837f, 0.25801814f, -0.08356648f, -0.12760709f, -0.06554103f, 0.03660056f, -0.01217215f, -0.11819165f, 
    0.07233458f, 0.23737647f, -0.04408162f, -0.02523955f, 0.07723528f, -0.03684683f, -0.14470865f, 0.05428850f, 
    -0.16132842f, 0.12602760f, -0.21356952f, -0.19415599f, -0.04202767f, 0.04952203f, 0.16427539f, -0.09900548f, 
    -0.11985324f, 0.27585009f, -0.10763808f, 0.20839779f, -0.18217193f, -0.13270956f, 0.20672418f, 0.09081690f, 
    -0.15345579f, 0.03388914f, -0.27017063f, -0.33422580f, -0.23489125f, -0.22110446f, -0.06771004f, -0.21724062f, 
    -0.43125972f, 0.16191024f, -0.28076994f, -0.14573246f, -0.11828437f, -0.05543461f, 0.03179582f, -0.08439283f, 
    -0.00075153f, 0.03755879f, -0.15523854f, 0.15570918f, -0.11178455f, -0.10802008f, 0.26307774f, -0.24019527f, 
    -0.05165156f, -0.08792075f, 0.04888538f, 0.28217453f, 0.05645915f, 0.06550296f, 0.10430019f, 0.09651943f, 
    0.23543243f, 0.17919800f, -0.01349472f, 0.00291087f, 0.09731495f, 0.24224971f, 0.12798667f, 0.08349416f, 
    0.18733895f, 0.07121684f, -0.08444491f, -0.22572760f, 0.14897500f, -0.05206919f, -0.00495619f, 0.53145272f, 
    0.00313579f, -0.06674882f, 0.39046198f, -0.08537742f, -0.09206416f, 0.03919632f, -0.06965293f, 0.13883378f, 
    0.67453110f, -0.01525348f, 0.10469685f, 0.24695583f, 0.02254889f, -0.12730423f, -0.16380818f, 0.10776576f, 
    0.06567891f, -0.00219709f, -0.02625831f, -0.20987704f, 0.06043371f, 0.02836600f, -0.15524723f, -0.30568206f, 
    0.03871983f, -0.03575742f, -0.06411386f, -0.05116034f, -0.09970319f, -0.07809159f, -0.05728803f, -0.06346533f, 
    0.12932837f, 0.17938805f, -0.02687937f, 0.03418756f, -0.17142622f, -0.02416226f, 0.12059886f, 0.06027479f, 
    -0.04356305f, -0.02048368f, -0.14309938f, -0.04623425f, 0.05694847f, -0.10468249f, 0.00455737f, 0.29386514f, 
    -0.17494014f, 0.16873088f, 0.09185064f, -0.09047123f, -0.04113191f, -0.04862667f, 0.24843702f, 0.13450502f, 
    -0.04384638f, -0.09484528f, 0.28694308f, 0.15026924f, -0.00811673f, 0.13435586f, -0.26221880f, -0.10388107f, 
    0.16626914f, 0.04458576f, -0.07504939f, -0.03523155f, 0.07733476f, 0.08403264f, -0.07023157f, -0.03508321f, 
    -0.06404563f, 0.08181898f, -0.16863264f, 0.05984129f, 0.06285244f, 0.19665377f, -0.19849068f, -0.08636788f, 
    0.38907239f, 0.37894389f, -0.09312523f, 0.17245410f, -0.22966659f, 0.03820849f, 0.03360062f, 0.03450914f, 
    0.04425915f, 0.08036312f, 0.06092323f, 0.00561626f, -0.29927504f, -0.44406924f, 0.34259078f, 0.09422507f, 
    -0.04955719f, 0.09681246f, 0.24486318f, 0.05034629f, 0.12378459f, 0.15983218f, -0.01206508f, 0.06812313f, 
    0.02423786f, -0.01142049f, -0.07917079f, -0.32357919f, 0.08970092f, -0.16785720f, -0.03739312f, -0.01248986f, 
    -0.04545163f, -0.11964063f, 0.13631310f, 0.11383090f, 0.02052501f, 0.05950465f, 0.17026611f, -0.04001486f, 
    0.08491242f, -0.14451623f, 0.15984552f, -0.09740282f, -0.22143343f, 0.04705177f, 0.04655998f, -0.16382800f, 
    -0.00881116f, -0.16107127f, -0.23265813f, 0.00963836f, -0.11476340f, 0.04673295f, 0.03257862f, 0.17356336f, 
    0.09192658f, 0.03040671f, -0.10556079f, 0.04502968f, -0.00289021f, -0.04483836f, 0.09156168f, -0.04087621f, 
    0.04391738f, 0.02216102f, 0.04222248f, 0.09825666f, 0.19105974f, 0.04321437f, 0.00738459f, -0.02902503f, 
    0.08381166f, -0.00075273f, -0.45267203f, 0.03577740f, -0.20992194f, 0.18538326f, 0.19260718f, -0.05545669f, 
    0.07274431f, 0.09700608f, 0.01271308f, 0.04422941f, 0.30519205f, 0.60455412f, -0.11832543f, 0.18185624f, 
    -0.10690290f, -0.04770213f, 0.00301193f, -0.07630906f, 0.17812791f, -0.00876103f, 0.03360267f, -0.07395019f, 
    -0.28419194f, -0.18643057f, 0.13463062f, 0.19863638f, -0.09145708f, -0.01295085f, 0.10387684f, -0.03748774f, 
    -0.10064600f, -0.08874226f, -0.14535560f, -0.17040862f, 0.24375999f, 0.07237180f, 0.10914073f, -0.04430222f, 
    0.30660337f, 0.02092413f, 0.18764685f, 0.07628442f, 0.35889319f, 0.03769646f, -0.04146862f, 0.23633364f, 
    0.27153969f, 0.49609485f, 0.17253545f, -0.14032596f, 0.11466356f, 0.05519030f, 0.10304278f, -0.00342174f, 
    0.15039399f, -0.06248880f, 0.05278579f, -0.08351395f, -0.26726389f, -0.33202100f, -0.22842880f, 0.38368487f, 
    -0.04955210f, 0.01496155f, -0.06409208f, -0.01894047f, -0.15654209f, -0.09470960f, 0.18152782f, 0.01057392f, 
    -0.42094335f, -0.00378201f, 0.15448143f, 0.06765706f, -0.07069663f, 0.04862235f, 0.08984575f, -0.20604838f, 
    -0.04251396f, -0.03839296f, -0.04378337f, 0.06201051f, 0.07799425f, 0.01150527f, 0.04580077f, -0.07214091f, 
    -0.00578797f, -0.10192327f, 0.08042659f, -0.05481017f, 0.13100225f, -0.05670636f, -0.08629983f, 0.09532760f, 
    -0.14118719f, 0.24389054f, 0.20542656f, -0.07439560f, -0.03702040f, 0.07584244f, -0.10537217f, 0.06707319f, 
    -0.18574226f, -0.04946247f, 0.04296494f, -0.13052988f, -0.06047749f, 0.14709742f, 0.38260570f, 0.12221632f, 
    -0.11136433f, -0.17684443f, 0.00222034f, 0.03807060f, 0.02202127f, -0.05462935f, 0.15078697f, 0.12360562f, 
    0.08092868f, 0.32506907f, 0.36479545f, -0.10201324f, 0.05783265f, -0.07764956f, 0.01191649f, 0.05933791f, 
    0.09151109f, 0.05038642f, 0.14647710f, 0.13307568f, -0.22167645f, -0.12747698f, -0.12328369f, 0.13704322f, 
    -0.04181031f, 0.20327002f, 0.15083009f, -0.11268106f, -0.05030132f, 0.02739769f, -0.01518087f, 0.07568244f, 
    0.10407203f, -0.15635568f, -0.03401658f, -0.03757099f, 0.12016609f, 0.11801714f, 0.02020842f, 0.06148893f, 
    0.02228656f, -0.14249201f, 0.12396087f, 0.05549655f, 0.24082829f, 0.04863640f, 0.04270802f, 0.13968018f, 
    -0.07329964f, -0.01905485f, 0.01888120f, 0.13827151f, 0.10500149f, 0.05928634f, 0.21270339f, -0.00131715f, 
    0.06829433f, 0.00899165f, 0.06160620f, -0.05809304f, 0.10638576f, -0.00863427f, 0.15114759f, 0.19417310f, 
    -0.12915491f, -0.02931396f, -0.12142259f, -0.11565470f, 0.03126575f, -0.05099168f, -0.04248747f, 0.14294791f, 
    -0.02870502f, -0.02010951f, 0.07270418f, 0.05676452f, 0.12018289f, 0.06702249f, 0.18606205f, 0.04771345f, 
    0.26056391f, -0.03879390f, -0.23910862f, 0.08549775f, 0.09349405f, -0.06347206f, 0.12681283f, 0.05760774f, 
    0.05323111f, -0.06173470f, 0.04388068f, 0.05373832f, 0.10473011f, 0.04247449f, -0.16265629f, -0.26113817f, 
    0.07770485f, 0.08654967f, 0.03834906f, -0.01646854f, 0.00058042f, 0.05735767f, -0.09427924f, -0.05877439f, 
    0.02645022f, 0.18349415f, 0.03968925f, -0.24078217f, -0.08793885f, 0.00548855f, 0.10515325f, 0.04380820f, 
    -0.08541565f, 0.10298073f, -0.03998669f, -0.19415937f, 0.26910806f, -0.14165443f, 0.03340394f, -0.33689630f, 
    0.05807745f, 0.11084355f, 0.00872351f, 0.15790071f, -0.06911206f, 0.23061551f, 0.08621579f, -0.07026916f, 
    0.47036728f, -0.05020326f, -0.13266422f, -0.23407716f, 0.10605436f, -0.17072441f, 0.02304910f, 0.07828519f, 
    -0.06807237f, 0.02658064f, 0.14509688f, 0.05174612f, 0.07815439f, -0.07237570f, -0.20347458f, 0.03285407f, 
    -0.07655701f, -0.02764339f, 0.00159873f, -0.03522457f, 0.14316586f, -0.10549423f, 0.02338764f, 0.03829871f, 
    0.00889492f, 0.23613344f, 0.16810831f, -0.19151479f, -0.11355079f, -0.12435941f, -0.05980002f, -0.16380188f, 
    -0.01467006f, -0.02622523f, -0.04466869f, 0.01049938f, 0.24332573f, 0.01837255f, -0.03141456f, -0.05042409f, 
    0.06729434f, 0.02503135f, 0.07928371f, 0.00023870f, -0.02385435f, -0.09103473f, -0.05292835f, -0.11962602f, 
    -0.06959879f, -0.33462259f, 0.22878966f, 0.25917754f, -0.01989615f, 0.23351510f, 0.03154253f, 0.10919474f, 
    0.31783885f, 0.11320776f, 0.11512824f, 0.14572179f, -0.30492353f, 0.10691391f, 0.14821032f, 0.11122097f, 
    -0.24678878f, -0.06180397f, -0.09230813f, -0.05619192f, 0.18791109f, 0.08897808f, 0.17681074f, 0.27096900f, 
    -0.12703411f, -0.16111831f, 0.29627290f, 0.05445633f, -0.09539314f, -0.05316742f, -0.09190089f, 0.03164035f, 
    -0.13199960f, -0.00463963f, 0.03341718f, -0.07331987f, -0.44606689f, 0.13246335f, 0.06960259f, 0.06675762f, 
    0.06840283f, 0.13879170f, -0.05882615f, 0.16263224f, -0.11635695f, 0.00443605f, 0.01672710f, -0.02590145f, 
    0.22430871f, 0.10607457f, -0.10752342f, 0.09497703f, -0.00089963f, -0.04733909f, -0.08332851f, 0.08923066f, 
    0.09642797f, -0.12462324f, -0.09298450f, 0.04722629f, 0.39828604f, 0.01587203f, -0.19501299f, 0.17728741f, 
    0.01417114f, 0.07290781f, 0.01002896f, 0.19042104f, 0.09249663f, -0.14448175f, -0.03443785f, 0.08955814f, 
    0.08669371f, -0.19141895f, -0.33715239f, -0.07939658f, 0.04481319f, 0.15679118f, 0.06152820f, 0.02104172f, 
    0.04709676f, 0.08699029f, -0.08607926f, -0.04711806f, -0.39783219f, -0.28432348f, -0.16905287f, -0.12036803f, 
    0.07488875f, -0.07673826f, -0.15947255f, -0.04391314f, 0.04711178f, 0.08096965f, 0.07772496f, 0.04521624f, 
    -0.14899687f, 0.05486061f, -0.39193025f, 0.11137275f, -0.16817151f, 0.00785075f, 0.23996791f, -0.06798909f, 
    0.05631144f, 0.01196770f, -0.10716578f, -0.16800644f, 0.46075484f, -0.04799446f, 0.18638860f, 0.13022539f, 
    0.12844470f, -0.09034766f, -0.02465443f, 0.28403756f, 0.02058316f, -0.00133361f, 0.04573894f, 0.05637297f, 
    0.22606051f, 0.10137777f, -0.04251911f, 0.02962843f, 0.11686226f, 0.03835962f, 0.11576786f, 0.08692838f, 
    0.01607370f, 0.01375045f, 0.20316739f, 0.04608289f, 0.20026803f, -0.04521080f, -0.29115966f, 0.38526142f, 
    -0.00270653f, 0.11711843f, 0.05719266f, -0.20369670f, -0.01568324f, -0.01410593f, 0.12393824f, -0.01475664f, 
    0.18147182f, -0.27781904f, -0.23778325f, 0.22692713f, 0.01277400f, -0.13395892f, -0.00028966f, 0.19832444f, 
    -0.04747656f, 0.02534114f, -0.03131823f, 0.05848726f, 0.36964771f, 0.22943680f, 0.29428673f, 0.44350320f, 
    0.03834274f, 0.04524863f, 0.17619435f, 0.15531796f, 0.01213310f, -0.08529861f, 0.03355711f, 0.09038860f, 
    0.40156764f, 0.52185750f, 0.40652415f, 0.32877979f, 0.10321245f, 0.04417499f, 0.21818101f, 0.12085119f, 
    0.16382752f, 0.02945795f, 0.03032474f, 0.02321695f, -0.13071054f, -0.42668772f, -0.24978650f, 0.27272716f, 
    -0.11482505f, 0.00266911f, 0.07027277f, -0.16439861f, 0.05878382f, -0.05566934f, -0.15723036f, 0.04627728f, 
    0.13076672f, 0.13936099f, 0.24460487f, -0.29420915f, -0.17339493f, 0.16024269f, 0.10628790f, 0.28963196f, 
    -0.00996540f, 0.01357253f, -0.01360365f, 0.06681877f, -0.11162172f, 0.01482196f, 0.00896516f, 0.01967352f, 
    0.21070707f, 0.22521330f, 0.05013715f, 0.21279925f, 0.01046067f, 0.13608180f, 0.03972946f, -0.08000311f, 
    0.30548364f, 0.54306740f, -0.25895914f, 0.24528770f, 0.14959620f, 0.02391461f, -0.09858021f, 0.08976607f, 
    0.04285022f, -0.00105285f, 0.10729291f, 0.20303890f, -0.32604745f, -0.40648362f, 0.21233974f, 0.02640868f, 
    -0.08150312f, 0.15394387f, 0.16697335f, 0.08965286f, 0.07345621f, 0.07760118f, 0.03445888f, -0.13752462f, 
    0.22257906f, 0.05753896f, -0.21582027f, 0.07104439f, -0.02613918f, 0.07022221f, 0.00833902f, 0.08878203f, 
    -0.02181672f, 0.02272039f, -0.04577632f, -0.05432548f, -0.33542967f, -0.24630842f, -0.13125643f, -0.15622766f, 
    -0.01970668f, -0.21487071f, 0.08061565f, 0.00584748f, -0.12566215f, -0.11310529f, 0.13640441f, -0.08201530f, 
    -0.23198767f, 0.21313046f, 0.10538303f, -0.39097553f, -0.02523132f, -0.02859054f, -0.01244218f, 0.08899295f, 
    0.16968234f, 0.09328189f, 0.29545090f, 0.20998392f, -0.22373599f, -0.33491808f, -0.14652544f, 0.15053985f, 
    0.07280158f, -0.05288278f, -0.16160277f, 0.02243770f, -0.13379742f, -0.09477711f, 0.17281777f, -0.09764820f, 
    -0.65421498f, -0.22178492f, 0.23965053f, -0.07454484f, 0.10925631f, -0.14251186f, -0.16513596f, -0.05396870f, 
    -0.10396542f, -0.10509660f, 0.05669471f, 0.03701412f, 0.27116764f, 0.09941164f, -0.19704524f, -0.04891956f, 
    0.05303181f, 0.10719768f, -0.00355260f, -0.03616535f, 0.18675935f, 0.12110533f, 0.05794200f, -0.06455997f, 
    0.20886418f, 0.33976409f, 0.15452124f, -0.14598098f, 0.25886518f, 0.22011398f, -0.00465313f, 0.01490398f, 
    0.01765715f, -0.12933888f, -0.02264121f, -0.02244313f, -0.16542846f, 0.03574944f, -0.03843309f, -0.66696042f, 
    -0.12595753f, 0.08359983f, 0.16823205f, -0.17693436f, 0.04758012f, 0.00639331f, 0.08619162f, 0.10009596f, 
    0.46516064f, -0.04599144f, 0.20187506f, -0.27999684f, -0.00241824f, -0.08477542f, 0.02038653f, -0.16913997f, 
    0.09433360f, 0.13861218f, 0.13210388f, -0.09082223f, 0.07742833f, 0.01948245f, 0.21119176f, -0.30697271f, 
    0.22934972f, -0.15782195f, -0.03939595f, 0.27011853f, 0.00579171f, -0.02684138f, 0.04455156f, 0.08335380f, 
    0.13485914f, 0.15472879f, -0.02222349f, -0.16230789f, 0.16944557f, 0.24308096f, 0.06640155f, -0.02576420f, 
    -0.08859013f, -0.03449928f, -0.05917478f, 0.02763408f, -0.24386421f, -0.16582029f, -0.37486094f, 0.04191216f, 
    -0.26342958f, -0.01065090f, -0.08211496f, -0.03802106f, -0.01470600f, 0.03671874f, 0.09985523f, 0.21136446f, 
    0.33805367f, -0.12981179f, 0.13215743f, 0.04848506f, 0.01676923f, -0.09695935f, 0.18966216f, -0.12922411f, 
    0.19865319f, 0.04353061f, 0.06069761f, -0.07788568f, -0.15228185f, 0.23920354f, -0.03888451f, 0.04760548f, 
    0.15233299f, 0.15675859f, -0.05643741f, 0.01639744f, 0.03125684f, 0.02670174f, -0.00758260f, -0.18643226f, 
    0.11985466f, -0.10832123f, -0.13446978f, 0.07751447f, -0.05263368f, 0.01442793f, 0.17254657f, -0.14024493f, 
    0.02423937f, 0.09220465f, 0.09966812f, -0.06542967f, -0.24319986f, 0.20042332f, -0.09161299f, 0.17182469f, 
    0.13053823f, 0.15543707f, 0.23691517f, 0.03891882f, 0.03578292f, 0.28047258f, 0.09730124f, 0.35761994f, 
    -0.27706715f, -0.05013992f, -0.41026857f, -0.30754739f, -0.05169921f, 0.03698838f, 0.07556247f, 0.23195446f, 
    0.10973597f, 0.20542109f, 0.10434506f, 0.24219923f, 0.05586161f, -0.10753930f, -0.09095944f, 0.35693857f, 
    -0.02158616f, -0.17066456f, -0.16932420f, 0.09760230f, 0.06715039f, -0.05104411f, -0.19735257f, 0.10078615f, 
    -0.04350771f, 0.20058590f, 0.03923025f, 0.15436620f, 0.09756626f, -0.11157096f, 0.19199006f, -0.00314808f, 
    0.02128467f, 0.14586924f, 0.07723677f, 0.06140990f, -0.15125367f, 0.19586842f, -0.33870155f, 0.03356833f, 
    -0.17365021f, -0.04214849f, -0.01226255f, 0.01514589f, 0.08499008f, -0.04805367f, -0.08064124f, 0.09852416f, 
    0.48893934f, -0.26074275f, 0.44553494f, -0.20051499f, -0.01326973f, -0.03900840f, -0.15110064f, 0.03317666f, 
    -0.04650513f, -0.15370268f, -0.07510587f, 0.07839235f, 0.05015933f, -0.02919605f, 0.26032439f, 0.17294447f, 
    0.11587813f, 0.12947533f, 0.10624326f, 0.11289584f, 0.06200011f, 0.17099446f, 0.04850996f, -0.17239550f, 
    -0.15305509f, 0.11031928f, 0.19223252f, 0.14053380f, -0.09625784f, -0.05591072f, 0.07981981f, -0.13366313f, 
    -0.02612921f, -0.02174733f, 0.05199239f, 0.03407154f, -0.04564397f, 0.01542766f, 0.03007258f, 0.22618495f, 
    -0.14606808f, -0.01991151f, -0.02613777f, 0.21139808f, 0.17735985f, -0.10111132f, 0.08830176f, 0.30870631f, 
    0.15537845f, 0.31533983f, 0.17628556f, 0.01884569f, -0.00455063f, -0.14372562f, 0.02239392f, -0.02060137f, 
    0.12744927f, -0.05178039f, 0.07002269f, -0.17753591f, -0.18848161f, 0.18773040f, 0.03699613f, 0.13507441f, 
    -0.03243273f, -0.21657562f, 0.04393218f, 0.07908738f, -0.16105527f, -0.00933605f, -0.13739647f, -0.13802859f, 
    -0.20819919f, -0.10974884f, 0.07732689f, 0.10077703f, -0.19257292f, 0.06964792f, -0.14410818f, -0.12460802f, 
    -0.13621819f, -0.16089281f, -0.07801547f, -0.17445198f, -0.00566903f, 0.21203114f, 0.09974149f, -0.01929772f, 
    -0.06437554f, -0.09511113f, -0.04768982f, 0.05942886f, -0.13401948f, 0.03175332f, -0.05226206f, 0.13955656f, 
    -0.33885700f, 0.24462683f, -0.14648256f, 0.09331995f, -0.05929294f, 0.06410340f, -0.15083002f, 0.08592102f, 
    -0.06105061f, -0.15756890f, 0.06969668f, -0.01997605f, -0.39800963f, 0.26627320f, -0.03592562f, -0.00170472f, 
    0.07505535f, -0.10451647f, 0.00633418f, -0.06003251f, -0.19483931f, 0.03400881f, 0.07535511f, -0.11203439f, 
    -0.65185791f, -0.23321518f, 0.23720750f, -0.11641029f, 0.01010507f, 0.10763511f, 0.05906433f, 0.09576724f, 
    0.07714886f, -0.03080961f, -0.05944128f, 0.02730359f, 0.31468573f, -0.13580598f, 0.19983962f, -0.14865905f, 
    0.16636890f, 0.19793232f, -0.06649963f, 0.42047885f, 0.14182106f, 0.13880700f, 0.05454743f, 0.05638161f, 
    0.03880357f, -0.22034048f, 0.07139330f, -0.01214608f, 0.14872454f, -0.09332772f, 0.05123891f, 0.02433052f, 
    0.07211676f, 0.04670737f, -0.13168386f, -0.15019412f, 0.35286698f, 0.55088794f, -0.04789102f, 0.24531759f, 
    -0.02649003f, 0.17175277f, -0.19037166f, 0.20876542f, 0.06106063f, 0.15208830f, 0.05708950f, 0.30409703f, 
    0.05952005f, -0.02484624f, -0.01273435f, -0.01018570f, -0.06820222f, -0.05667893f, -0.01933538f, -0.05407559f, 
    -0.04858293f, 0.01441840f, -0.02812928f, -0.02805446f, -0.03369676f, 0.02867420f, -0.03189636f, 0.00280672f, 
    0.02995396f, -0.00217020f, 0.03295685f, -0.07944208f, 0.01161920f, -0.05252394f, 0.02005851f, -0.02008900f, 
    0.03313289f, 0.00091966f, 0.05252879f, -0.01402571f, 0.01928348f, -0.00570642f, -0.04298414f, -0.03480726f, 
    -0.00812569f, -0.03923402f, -0.01996141f, 0.05161147f, 0.02199264f, -0.02178735f, -0.01643649f, 0.01221538f, 
    -0.04592941f, -0.06039542f, 0.04318483f, -0.02908021f, 0.01531974f, -0.01465681f, -0.04942948f, 0.05385352f, 
    0.03309763f, -0.00715200f, -0.03315607f, 0.05581104f, 0.04554646f, -0.04057765f, -0.06127013f, -0.04247031f, 
    0.05545116f, -0.06845058f, -0.07934914f, -0.00948308f, -0.03473673f, -0.06775124f, -0.06842701f, -0.04194551f, 
    0.05242462f, -0.04495121f, -0.06993776f, -0.00627480f, -0.01850898f, -0.07226365f, 0.02062624f, -0.03480848f, 
    -0.00897094f, 0.01046728f, 0.02849956f, -0.00528976f, 0.05170875f, -0.05755430f, -0.05494642f, -0.07616168f, 
    0.01840945f, -0.02272112f, -0.02658845f, -0.00559321f, 0.03314652f, 0.05364467f, -0.05633730f, -0.00397880f, 
    -0.06122530f, -0.04554289f, 0.00298366f, -0.05927839f, -0.05054268f, -0.08398053f, 0.05714196f, -0.07671603f, 
    0.05262478f, 0.04451123f, 0.04179420f, 0.04818217f, 0.03570166f, 0.00673883f, 0.02081220f, -0.00308814f, 
    0.05472610f, -0.03886065f, -0.07090321f, -0.01351597f, -0.05669631f, -0.01756840f, -0.06548150f, -0.00553790f, 
    -0.04995764f, 0.01768151f, 0.05176214f, 0.02881415f, -0.03951037f, 0.04606642f, 0.01275324f, -0.00023062f, 
    -0.00233671f, -0.08288470f, 0.04142890f, -0.07443622f, -0.03802847f, -0.07419394f, -0.02188143f, -0.02559261f, 
    -0.07979393f, 0.01402087f, 0.03833367f, -0.03574878f, -0.07525939f, 0.04271012f, 0.04377193f, 0.02353941f, 
    -0.08631512f, 0.01346599f, -0.01684519f, 0.00746122f, 0.04947017f, -0.01774323f, 0.01733548f, -0.07381734f, 
    0.00443386f, -0.04030681f, 0.05613684f, 0.00248508f, -0.00597393f, -0.07413053f, 0.04971650f, 0.01502939f, 
    0.02355932f, -0.04473853f, -0.04904965f, -0.01844908f, 0.00587566f, 0.01085360f, -0.00832350f, 0.04826452f, 
    -0.02324365f, -0.07052552f, 0.05185654f, 0.00547898f, -0.01853679f, -0.00389404f, -0.05755314f, -0.04277731f, 
    -0.05011186f, 0.00195303f, 0.04232607f, 0.01234309f, -0.05249849f, 0.00937148f, -0.01652254f, 0.01363678f, 
    -0.04944015f, 0.05866451f, -0.03359652f, 0.04986628f, 0.02867172f, -0.06566259f, -0.05174952f, 0.06198902f, 
    -0.05168165f, 0.02518524f, 0.05367588f, 0.03352157f, -0.08509024f, -0.02369841f, 0.02661302f, -0.07854314f, 
    -0.22187027f, 0.21495281f, 0.00123769f, 0.03455321f, 0.09990670f, -0.02719419f, 0.00333368f, 0.12268534f, 
    0.04526261f, -0.04631410f, 0.21095365f, -0.00449980f, -0.12472747f, -0.01760615f, -0.09306983f, 0.22789009f, 
    -0.01723784f, -0.04923286f, -0.08115682f, -0.22546741f, -0.17407072f, -0.21185689f, 0.01786546f, 0.03581981f, 
    -0.07146844f, 0.16446324f, 0.37942538f, 0.38305449f, 0.27914456f, 0.09409109f, -0.13951826f, 0.01375156f, 
    -0.05811558f, -0.09466597f, -0.09192813f, -0.02865199f, -0.06752338f, 0.29367346f, 0.15048130f, -0.08197010f, 
    0.10608463f, 0.29543898f, 0.21370156f, -0.05589261f, 0.06275645f, 0.18552892f, -0.00102318f, -0.12970811f, 
    0.16421472f, 0.54679698f, 0.46211499f, 0.10470315f, 0.01229683f, 0.02650538f, -0.01621064f, 0.01047045f, 
    -0.00546266f, -0.07679436f, -0.00781359f, -0.09236512f, -0.24624671f, 0.16191189f, 0.00953221f, 0.00154745f, 
    -0.06213831f, 0.22401878f, 0.00098257f, -0.02347741f, 0.24543977f, -0.09181538f, -0.03171986f, 0.35763240f, 
    -0.14780621f, 0.57072473f, -0.02238303f, -0.27209345f, -0.01999090f, 0.19387394f, 0.03325193f, -0.08568487f, 
    0.01762893f, 0.11118051f, -0.17658754f, 0.02502165f, -0.03836573f, 0.24376601f, 0.10943556f, -0.13288192f, 
    0.25397226f, -0.18398383f, 0.04953420f, 0.23805095f, -0.01016632f, 0.14884844f, 0.06766226f, -0.10821509f, 
    0.06784032f, 0.36972988f, 0.16385625f, -0.09594650f, -0.00670939f, 0.15094368f, -0.10925786f, -0.10747664f, 
    0.03791839f, 0.00896026f, -0.05190596f, 0.04195131f, -0.22804469f, -0.15702175f, 0.15464593f, 0.01910024f, 
    -0.14834782f, 0.13010834f, -0.11522852f, 0.08299082f, -0.14897223f, -0.14449680f, -0.13837951f, -0.23183726f, 
    -0.02903858f, -0.13104606f, 0.27110249f, 0.00309809f, 0.04926225f, -0.02816664f, -0.18993984f, 0.15077566f, 
    0.03356992f, 0.02289165f, 0.03906409f, 0.08369518f, -0.35507011f, 0.50122797f, 0.14682989f, 0.28385079f, 
    -0.05436795f, -0.17958647f, 0.10315733f, 0.06293110f, 0.10202149f, -0.03493682f, 0.03797369f, -0.05772118f, 
    -0.31547537f, -0.08162581f, 0.46694216f, 0.12570539f, -0.29212743f, 0.08010557f, -0.12108692f, -0.04936432f, 
    0.09059978f, -0.11088867f, 0.03875951f, -0.18547478f, 0.14330980f, -0.04542261f, 0.16434096f, 0.00414410f, 
    0.15547343f, 0.11166487f, 0.09996704f, 0.31166741f, -0.03365009f, 0.12253524f, -0.09269552f, 0.12026495f, 
    -0.17644978f, -0.09486536f, -0.04794686f, -0.24056864f, -0.28228536f, -0.08868370f, -0.00309588f, -0.03063701f, 
    -0.00583825f, 0.22742292f, 0.05740844f, -0.13979159f, 0.15615351f, 0.18440714f, 0.11556566f, 0.35975125f, 
    -0.01093489f, 0.09606199f, 0.06164424f, -0.14936565f, 0.02703446f, 0.07508191f, -0.12146344f, 0.22560936f, 
    -0.08143172f, -0.19068882f, -0.01287449f, 0.05932571f, 0.17440158f, 0.00162875f, -0.06996644f, 0.16242374f, 
    -0.06416347f, -0.28835741f, -0.03358123f, -0.22329171f, -0.05386585f, -0.25918150f, -0.24544300f, -0.02295489f, 
    0.09920563f, -0.07562699f, -0.19255714f, 0.05854963f, 0.12484851f, 0.20246236f, 0.10264992f, 0.12845752f, 
    -0.03734957f, -0.09007545f, -0.25480789f, 0.39273316f, 0.14901651f, 0.13613059f, -0.14208026f, -0.07012855f, 
    0.07170679f, -0.06812120f, 0.09095275f, 0.02027669f, -0.16123986f, 0.34779164f, 0.11514079f, 0.11409948f, 
    -0.06592568f, -0.00147116f, 0.15461707f, -0.08191414f, -0.01978369f, -0.02152712f, 0.01034380f, -0.18638088f, 
    -0.14381883f, 0.09848773f, 0.19011459f, 0.24486676f, -0.17878094f, -0.08920754f, -0.00245210f, -0.08042076f, 
    -0.08413583f, 0.15272705f, 0.08494579f, 0.00618571f, -0.05865267f, 0.05338582f, -0.01010098f, -0.32779226f, 
    0.13016036f, 0.09412474f, -0.15056990f, 0.13863271f, 0.17059211f, -0.16271299f, 0.04267332f, -0.15196434f, 
    -0.26130384f, 0.43949008f, 0.05729577f, -0.24965774f, 0.14999057f, 0.12542911f, 0.16276261f, -0.05420725f, 
    -0.00427832f, 0.27081206f, -0.01383356f, 0.17897332f, -0.09251244f, -0.14986496f, -0.21025178f, 0.23296919f, 
    -0.10705469f, -0.03659429f, -0.10093383f, -0.06468511f, 0.04156840f, 0.08913804f, -0.03860193f, 0.18153492f, 
    -0.21971977f, 0.07558607f, 0.24048799f, 0.13037550f, -0.09278505f, 0.03044086f, 0.03947631f, 0.02550954f, 
    0.18033901f, 0.15717976f, 0.04722724f, -0.02771567f, -0.06230336f, -0.16047299f, 0.28849509f, -0.10115093f, 
    0.00191268f, -0.00720708f, -0.06476051f, 0.02724660f, -0.11016338f, -0.01391184f, -0.15944162f, -0.23612912f, 
    -0.34648243f, -0.13831659f, 0.23403428f, -0.09367529f, 0.03760167f, 0.19898701f, -0.25740367f, 0.27249449f, 
    0.13535450f, 0.15693729f, 0.02211965f, 0.18233831f, 0.03130822f, 0.18300718f, 0.32590410f, 0.42494392f, 
    -0.13025135f, -0.15910040f, 0.06259621f, 0.07080796f, 0.12580363f, 0.00752469f, 0.13078417f, 0.22184040f, 
    -0.01423887f, 0.38707569f, 0.48214018f, 0.11923431f, -0.14751324f, 0.04471856f, -0.07738701f, -0.00459573f, 
    -0.07136353f, -0.06947450f, 0.06990246f, -0.12316035f, -0.18620831f, 0.09628157f, -0.23146106f, 0.01661200f, 
    0.18501426f, -0.15291317f, -0.08291598f, 0.03123170f, -0.18672253f, -0.15565965f, -0.21076511f, -0.28457144f, 
    0.09514835f, 0.27164829f, -0.01563777f, 0.04234740f, 0.10730933f, 0.09396260f, -0.02290219f, -0.15586796f, 
    0.02457792f, -0.10245007f, -0.26679313f, -0.20753647f, 0.14135982f, -0.29818383f, -0.20371951f, -0.07040484f, 
    0.02406235f, 0.17290875f, 0.02013982f, -0.27780735f, 0.14515443f, 0.03461350f, -0.07178497f, 0.28743801f, 
    0.08394235f, -0.19290426f, 0.01008773f, 0.25453943f, 0.07211936f, 0.12980023f, -0.10403385f, -0.13817614f, 
    0.05198255f, 0.03070996f, 0.13168587f, 0.04513587f, 0.10476364f, 0.14182205f, -0.10584085f, -0.23514278f, 
    0.06926887f, -0.07892764f, -0.05769806f, 0.01282936f, -0.02812109f, -0.12414686f, -0.02402925f, -0.04208540f, 
    0.28165910f, -0.14424042f, 0.15378274f, 0.04499684f, -0.08333748f, 0.08905800f, 0.11763653f, -0.05088446f, 
    -0.30673513f, -0.01387861f, -0.02645814f, -0.08560707f, 0.25991333f, 0.13503547f, -0.25687873f, 0.40034863f, 
    0.09745966f, 0.08251040f, 0.00800384f, 0.02421070f, -0.05274381f, 0.14575203f, 0.03680211f, -0.03671904f, 
    -0.34051678f, -0.28563511f, -0.06038193f, 0.15031998f, 0.04405452f, -0.13022318f, 0.09409636f, 0.04381564f, 
    0.01118219f, -0.10456284f, 0.01774381f, 0.07522839f, 0.00761595f, 0.03739680f, 0.15014249f, 0.02210032f, 
    0.00696436f, -0.04422314f, -0.04119818f, 0.01238401f, 0.18173203f, 0.01696186f, 0.09000008f, 0.03360244f, 
    -0.12880476f, 0.06539001f, 0.04243141f, 0.04993486f, -0.08820219f, 0.08869844f, 0.04057529f, 0.07432201f, 
    0.18661653f, -0.03869136f, 0.10723802f, -0.00628341f, -0.01111882f, -0.05672056f, 0.14944257f, 0.22481880f, 
    0.08213253f, 0.09027591f, 0.25426275f, 0.22217128f, -0.04289389f, 0.04748551f, 0.11766816f, -0.14264381f, 
    -0.06350335f, -0.13797085f, -0.04621306f, 0.12196661f, 0.15921181f, 0.01032929f, -0.01314778f, -0.08355772f, 
    -0.06633523f, 0.07075563f, 0.02731248f, 0.00943868f, -0.19315632f, 0.16984682f, -0.05122126f, -0.19069985f, 
    0.14117044f, -0.16358393f, -0.09614446f, -0.06899381f, 0.09839214f, 0.14377344f, -0.09687911f, 0.04765847f, 
    0.09344334f, 0.36841553f, -0.23552419f, -0.16864589f, 0.01184694f, -0.15819781f, 0.04982242f, -0.02894427f, 
    -0.18692522f, 0.01690498f, 0.03915996f, -0.01508013f, 0.01768660f, -0.18170543f, -0.00838610f, -0.24344143f, 
    0.07889874f, -0.01811106f, 0.10818568f, 0.00389998f, 0.02134140f, -0.06505591f, 0.03788617f, -0.05418400f, 
    -0.39019039f, -0.33917034f, 0.07788202f, -0.16684856f, 0.06319942f, -0.10718056f, 0.01965204f, -0.14858612f, 
    0.11345437f, 0.19253601f, -0.02637603f, 0.17954098f, 0.35176629f, 0.22366078f, -0.13529374f, -0.04281332f, 
    -0.02069594f, 0.12616049f, -0.07753227f, 0.03659740f, 0.20149678f, -0.10251890f, 0.12736759f, 0.23693994f, 
    -0.02009732f, -0.29208356f, -0.22213416f, -0.13127188f, -0.15577555f, 0.02544205f, -0.00241783f, 0.03204285f, 
    -0.02947556f, 0.02808229f, -0.09112954f, -0.10545553f, -0.03674477f, 0.22404313f, -0.05221087f, 0.12071498f, 
    -0.08034758f, -0.02648600f, -0.03689346f, 0.03592891f, -0.05829668f, -0.00361524f, 0.12819567f, 0.09656261f, 
    0.09307846f, 0.08646082f, 0.27870741f, 0.05722127f, -0.03415147f, 0.04272830f, -0.03205060f, -0.07255530f, 
    -0.17318033f, -0.05287886f, -0.05733413f, -0.15928549f, -0.06269354f, -0.16793819f, 0.13681085f, -0.00367700f, 
    -0.10858308f, 0.14377107f, -0.07230843f, -0.10832286f, 0.22072166f, 0.09023400f, 0.18093404f, 0.12263561f, 
    0.03064800f, 0.03833052f, 0.35621828f, 0.15907668f, 0.02323512f, -0.09695975f, -0.16581522f, -0.04797085f, 
    0.07963623f, -0.10537464f, 0.03844613f, 0.08034026f, -0.14471731f, -0.01264033f, 0.18918163f, -0.29072398f, 
    0.10232211f, 0.16488400f, 0.14543003f, 0.11099949f, -0.07787876f, 0.18564893f, -0.10383486f, -0.03275515f, 
    0.40830335f, 0.33937493f, 0.22739033f, -0.02944158f, 0.21407813f, 0.06967540f, 0.15446451f, 0.23080656f, 
    0.07775990f, 0.09596452f, -0.03376801f, 0.14172611f, -0.13434429f, 0.01604783f, 0.10581717f, -0.09797080f, 
    -0.03755467f, 0.08485763f, 0.15060446f, -0.10518669f, -0.08459366f, 0.29677916f, -0.07256611f, -0.16830222f, 
    0.07513523f, -0.36719170f, 0.06519922f, -0.27052233f, -0.33726668f, 0.00533080f, 0.07366554f, -0.07131182f, 
    0.12300169f, 0.06694963f, 0.07887892f, 0.05876144f, 0.16286096f, 0.11636776f, 0.19335380f, -0.06136380f, 
    -0.00493424f, -0.05365288f, -0.06566286f, 0.12086990f, 0.10825886f, -0.04577525f, -0.06762467f, -0.05321941f, 
    0.24105926f, 0.25060099f, 0.01266379f, 0.19997720f, -0.05758861f, -0.04299034f, 0.02405978f, 0.31854451f, 
    -0.17022076f, -0.06949937f, -0.07999045f, -0.05734439f, 0.21706104f, 0.16428290f, 0.06832533f, -0.00280921f, 
    -0.15296081f, -0.07027280f, -0.20770435f, -0.19739681f, -0.04177970f, 0.00647809f, -0.03923857f, -0.10359275f, 
    -0.01652404f, 0.20874868f, -0.24506076f, 0.50850683f, 0.22782950f, -0.00330868f, 0.05513595f, 0.07635484f, 
    -0.03376625f, 0.08932526f, 0.18714079f, 0.06598818f, 0.51253211f, -0.31720832f, -0.15546320f, 0.09242016f, 
    0.12087442f, 0.02130978f, -0.07573342f, -0.01944411f, 0.04016365f, 0.04114135f, 0.04545590f, 0.10815312f, 
    0.25869459f, -0.12325459f, 0.00045746f, 0.16135623f, 0.14968389f, -0.05264838f, 0.25510156f, -0.16671604f, 
    -0.09749836f, 0.15335627f, -0.04314889f, -0.02101020f, 0.09400622f, 0.19530882f, -0.11031787f, -0.06730981f, 
    0.20713770f, -0.00038490f, 0.16525130f, -0.09504594f, -0.00865766f, 0.13708141f, -0.03733731f, -0.00652582f, 
    -0.21769083f, 0.32375813f, 0.17705673f, -0.06894709f, 0.15571894f, -0.02458111f, 0.16612709f, 0.04525096f, 
    0.10488160f, 0.10285268f, -0.16585368f, 0.01574145f, -0.05838887f, -0.17895465f, -0.01880681f, 0.18840699f, 
    0.08066808f, 0.23530622f, -0.17288545f, -0.12234291f, 0.14328666f, 0.02019244f, -0.27827835f, -0.04270638f, 
    -0.01116217f, -0.10433346f, -0.01653121f, -0.15262696f, 0.15179990f, 0.19460194f, 0.10036935f, 0.10140618f, 
    -0.10025269f, -0.13536660f, -0.08973739f, -0.19378577f, -0.10666611f, -0.36970773f, 0.01626625f, 0.05473420f, 
    -0.01812469f, 0.11589713f, -0.13806300f, -0.08861742f, 0.10857228f, 0.17766398f, 0.23836787f, 0.10862561f, 
    -0.20333353f, -0.04838762f, -0.09847841f, 0.39794546f, 0.22725183f, 0.08049004f, 0.00282891f, -0.07261716f, 
    -0.04539015f, -0.15638417f, -0.07578345f, -0.12393894f, -0.06975874f, 0.23325771f, 0.17682962f, -0.30848813f, 
    -0.00450404f, -0.01789250f, 0.19977812f, 0.12330845f, -0.07328903f, 0.02519367f, -0.01804932f, -0.05046295f, 
    0.30353513f, 0.39675030f, 0.19308053f, -0.02786654f, -0.05223637f, 0.16171485f, 0.11569810f, 0.12324663f, 
    -0.04538712f, 0.08653301f, 0.00252795f, 0.02208835f, 0.02740877f, -0.01799506f, -0.10643048f, -0.28335747f, 
    0.00443208f, 0.25686249f, -0.08319673f, -0.11544620f, -0.00821265f, 0.12271442f, -0.07994498f, -0.05286605f, 
    -0.14728424f, -0.12699269f, -0.04830163f, -0.37189424f, -0.14101902f, 0.06507851f, 0.12941475f, -0.04090546f, 
    -0.04497192f, 0.30212247f, -0.00366239f, 0.34165940f, 0.24169333f, 0.13394034f, -0.02653661f, -0.04269490f, 
    0.10082795f, 0.06069511f, 0.04166635f, 0.12227025f, 0.08985625f, 0.01741281f, -0.06356562f, 0.22556995f, 
    0.28846860f, 0.32501537f, 0.28760415f, 0.02339529f, 0.09522584f, -0.00924523f, 0.03558400f, 0.28824836f, 
    0.01968990f, 0.05432194f, -0.03668530f, -0.04718704f, -0.00506045f, -0.31794000f, -0.09125148f, 0.02870124f, 
    -0.19064714f, 0.09424581f, -0.13240819f, -0.01369863f, -0.19045357f, -0.18927121f, -0.03170867f, -0.38574493f, 
    0.05063071f, -0.31092599f, 0.17702809f, 0.27512598f, 0.08067533f, -0.06811740f, 0.02078598f, 0.19361542f, 
    0.22789820f, 0.19777818f, 0.02007395f, 0.18774806f, 0.04003890f, 0.08899351f, 0.21013138f, 0.34839699f, 
    -0.09540792f, -0.03519057f, -0.07004806f, 0.13175157f, 0.12488346f, 0.04266891f, 0.06991097f, 0.17705537f, 
    0.17698017f, 0.09850270f, 0.29171744f, 0.35326296f, -0.11065970f, -0.08987853f, -0.04017746f, -0.20714906f, 
    -0.22332737f, -0.02815235f, 0.06342922f, -0.09527026f, -0.30860379f, 0.10935307f, -0.11776165f, 0.08436123f, 
    0.13078606f, -0.02133007f, -0.00676822f, 0.04822355f, -0.04949410f, -0.04519909f, -0.10504033f, -0.08189395f, 
    -0.05717298f, 0.54464781f, -0.11354506f, -0.18545866f, 0.00711687f, 0.16105908f, 0.01085892f, 0.07167917f, 
    0.05490433f, 0.02612429f, -0.10768855f, 0.08618812f, -0.13633887f, -0.30377603f, -0.10854680f, 0.01587568f, 
    0.11540106f, 0.05389065f, 0.14134549f, -0.26807109f, 0.07872027f, -0.12705649f, -0.15026492f, 0.13469413f, 
    -0.05356284f, 0.09798408f, 0.01436969f, 0.07163299f, 0.14099592f, 0.18341294f, -0.13541171f, 0.03544359f, 
    -0.06437656f, 0.06894201f, -0.04694685f, 0.04457680f, 0.02261243f, 0.13522673f, 0.01631670f, -0.25205341f, 
    -0.04275271f, 0.09440939f, -0.02014778f, -0.09052909f, -0.04257385f, 0.01843455f, -0.13119030f, -0.16921410f, 
    0.35821432f, -0.05368637f, -0.06530763f, 0.05518861f, 0.01219902f, -0.06851033f, 0.01457772f, -0.03014297f, 
    -0.11373423f, 0.12290355f, -0.04148098f, -0.13446189f, -0.12418880f, 0.05536766f, 0.14555910f, 0.04763983f, 
    0.13550732f, 0.07990365f, 0.30151650f, 0.15120003f, -0.17214884f, 0.05834063f, 0.09655409f, 0.01976626f, 
    -0.22442338f, -0.11008500f, 0.00414454f, 0.05955786f, -0.06115256f, -0.10324746f, 0.00345745f, 0.12428024f, 
    0.04174145f, 0.02515404f, -0.03936328f, -0.00521465f, -0.16171254f, 0.19278386f, 0.22328852f, 0.45135918f, 
    -0.15665518f, -0.01043636f, 0.07663860f, 0.23244575f, 0.17293505f, -0.27164850f, 0.01955448f, 0.19844054f, 
    -0.13462722f, 0.13152970f, 0.12917559f, 0.15899165f, -0.01943638f, 0.23864485f, 0.05318215f, 0.17124808f, 
    -0.04280946f, -0.05068130f, -0.06130588f, -0.03356838f, -0.06640606f, 0.01898663f, 0.17059462f, 0.16205005f, 
    -0.03895677f, -0.07593837f, 0.24143739f, -0.01347248f, -0.10948253f, 0.14123799f, -0.03098300f, -0.07983921f, 
    -0.06894730f, -0.03425703f, 0.11350773f, 0.32710215f, -0.14541125f, -0.12135709f, -0.00339438f, 0.12009178f, 
    -0.02715578f, 0.13767295f, 0.02638672f, 0.06734015f, 0.04753708f, 0.14621219f, 0.25917038f, 0.01249805f, 
    -0.06628945f, 0.02800911f, -0.05757558f, -0.09608926f, -0.01166218f, 0.08692895f, 0.09084677f, 0.10385580f, 
    -0.12547947f, 0.23179525f, -0.15103462f, 0.14554054f, 0.12310857f, -0.06434429f, 0.03928398f, 0.11340211f, 
    -0.22294649f, -0.14514932f, 0.07818408f, 0.06019986f, 0.07856226f, -0.26475912f, -0.14042099f, -0.24077480f, 
    -0.03591570f, -0.09494073f, 0.07062248f, 0.20437333f, -0.11577128f, -0.14884092f, 0.04079822f, -0.14417474f, 
    -0.08666017f, -0.25332433f, 0.09388212f, -0.25537881f, -0.13845196f, -0.10872971f, 0.03066631f, 0.25109303f, 
    0.08541093f, 0.12714867f, -0.08807310f, -0.05622162f, 0.51713657f, 0.11471386f, -0.06649417f, 0.02417540f, 
    0.14613940f, 0.13334137f, 0.07254267f, -0.03523795f, 0.03510092f, 0.05573272f, 0.00073901f, 0.11041539f, 
    -0.24658677f, -0.08792731f, 0.01443554f, -0.15016162f, -0.07858021f, 0.16054641f, 0.20277929f, 0.04878009f, 
    0.03618484f, 0.09064231f, 0.05821897f, -0.08052374f, 0.07818106f, 0.13275953f, 0.09584190f, 0.11415130f, 
    0.03587751f, 0.10184773f, -0.15031281f, -0.14100263f, 0.04450834f, 0.20416963f, 0.21939664f, 0.03613205f, 
    0.16742279f, -0.19540685f, 0.23230295f, 0.37465906f, 0.07904249f, 0.08314522f, -0.01583758f, 0.06050530f, 
    -0.06061811f, -0.20498575f, -0.15999527f, -0.41407591f, -0.15557225f, -0.00196144f, -0.25467157f, -0.17056942f, 
    0.08007515f, -0.37153834f, -0.01886928f, -0.12263841f, 0.12508833f, 0.35031122f, 0.00364019f, 0.22843765f, 
    0.46661824f, -0.00219783f, 0.24518199f, 0.34948304f, 0.02013738f, 0.11696162f, -0.22243515f, 0.05666589f, 
    0.03442892f, 0.05707467f, -0.01019288f, -0.18177231f, -0.06482044f, 0.11588688f, 0.18763043f, 0.20717567f, 
    0.03024951f, 0.08870034f, 0.13873474f, -0.01241461f, -0.13102204f, -0.15170611f, 0.03249887f, -0.10212517f, 
    -0.05589052f, 0.09868346f, 0.05895549f, 0.24793278f, -0.10786615f, 0.02650332f, 0.02648231f, 0.03709757f, 
    -0.14014372f, 0.08574447f, 0.11652655f, 0.10758264f, -0.00646697f, 0.04287149f, 0.03819699f, 0.13024525f, 
    0.05595648f, 0.05485263f, -0.10170322f, 0.16609088f, 0.01673477f, -0.07705305f, 0.05595369f, 0.00736381f, 
    -0.53236759f, 0.20690954f, -0.11014020f, 0.04633690f, 0.03100147f, 0.16460469f, 0.13245952f, 0.06019893f, 
    -0.10486251f, 0.04361245f, -0.03694138f, 0.31864494f, 0.05575332f, 0.19390392f, 0.11948761f, 0.58766550f, 
    -0.04768987f, 0.01608369f, 0.06563748f, -0.03633817f, 0.11520018f, -0.04785749f, -0.08164138f, -0.01624696f, 
    0.11593280f, 0.07839546f, 0.33645123f, 0.29301453f, 0.13858373f, 0.15554236f, 0.06158851f, 0.15561299f, 
    0.14480351f, 0.04957914f, -0.07947962f, -0.05033048f, -0.01293953f, -0.11671610f, 0.26708001f, -0.17655538f, 
    0.14138594f, -0.12485690f, -0.22521590f, 0.00027869f, -0.22118768f, -0.11906515f, -0.23142213f, -0.32536334f, 
    -0.27779198f, 0.11034353f, 0.06966297f, -0.23398323f, -0.00893851f, 0.14014235f, -0.00644412f, 0.16105735f, 
    -0.14318630f, 0.21813986f, -0.01078736f, 0.28630692f, 0.07882313f, 0.07305770f, 0.13845637f, 0.19083589f, 
    0.07411905f, -0.16083676f, 0.03753510f, 0.13167030f, 0.01178982f, -0.02291841f, 0.10375751f, 0.11871659f, 
    0.03402032f, 0.40740010f, 0.06922897f, 0.04711867f, 0.08634032f, 0.11750803f, -0.27352956f, 0.08891718f, 
    0.01007834f, -0.14480951f, 0.01101712f, -0.10363012f, 0.22877671f, 0.19328116f, 0.00559329f, -0.15114512f, 
    -0.06983315f, -0.06365409f, -0.04438519f, 0.05696315f, -0.12156279f, -0.16889186f, -0.13965315f, -0.32424769f, 
    0.11200138f, 0.18816486f, 0.00486276f, 0.25905859f, 0.18075357f, 0.17463271f, 0.00035404f, -0.09761699f, 
    0.03235248f, -0.07744981f, -0.28917697f, -0.26403752f, -0.06423863f, -0.30407304f, -0.04645831f, -0.16499364f, 
    -0.04713595f, 0.05554415f, -0.03466099f, -0.17438261f, 0.17212369f, -0.08921830f, 0.04826364f, 0.15738626f, 
    0.09832617f, -0.03430134f, -0.09161238f, 0.11095799f, 0.10097396f, 0.06304575f, -0.16857034f, -0.05645076f, 
    0.21375178f, 0.01063369f, 0.02671179f, -0.06922852f, 0.15899542f, 0.07793548f, 0.18602847f, 0.22504288f, 
    0.16128844f, -0.07600369f, 0.02395762f, 0.09475148f, 0.04944498f, -0.13785142f, 0.21014325f, 0.04510417f, 
    0.33024848f, 0.40851799f, -0.03645099f, 0.34162262f, 0.14147170f, -0.03093777f, 0.16021883f, 0.06846546f, 
    -0.12989751f, 0.05454916f, -0.01945465f, 0.06493138f, 0.32188860f, -0.03722497f, -0.50368315f, 0.03208170f, 
    0.14744192f, 0.13246605f, -0.00851001f, -0.07468564f, 0.13068029f, -0.12410599f, -0.04493951f, -0.04513165f, 
    -0.21207069f, -0.13219111f, -0.12583867f, -0.28253454f, 0.17036508f, 0.08796751f, 0.02963821f, 0.14547496f, 
    -0.02989690f, -0.21617988f, 0.13821320f, 0.17690343f, 0.31552768f, 0.06285318f, 0.04762344f, -0.15199620f, 
    0.16443302f, 0.08436450f, -0.21728562f, 0.03404062f, 0.09893936f, -0.14103197f, 0.06016073f, 0.26965541f, 
    0.21816529f, 0.10408469f, -0.52010757f, -0.23572685f, 0.00839962f, 0.12452271f, -0.11211539f, 0.24440822f, 
    0.05358656f, 0.01028530f, -0.08360383f, -0.08212779f, 0.07388093f, 0.10300626f, 0.37949178f, 0.09085756f, 
    0.24226928f, 0.07157265f, 0.20899056f, 0.32097355f, -0.08474761f, 0.06967061f, 0.24084309f, -0.05634085f, 
    0.28238913f, 0.12148250f, 0.15427485f, -0.02491722f, 0.28366593f, 0.12251053f, 0.12954876f, -0.20171726f, 
    0.01644632f, 0.01087176f, 0.13063382f, 0.12018065f, 0.09747700f, 0.14171872f, -0.09898724f, 0.28258187f, 
    0.04222089f, -0.14299683f, -0.12361046f, -0.02469732f, 0.19058686f, -0.15586410f, -0.07912536f, 0.15278305f, 
    0.53293598f, -0.22462463f, 0.24526393f, -0.49370900f, -0.19168018f, -0.05668081f, 0.10102081f, -0.13806298f, 
    -0.07485056f, -0.17417672f, -0.01792596f, -0.24058573f, -0.52460819f, 0.06719068f, -0.09228262f, -0.39496195f, 
    -0.06191375f, 0.02703686f, 0.03499711f, 0.02815934f, 0.16513945f, -0.20170556f, 0.03660568f, -0.03065569f, 
    -0.29012832f, -0.52935648f, -0.16489890f, -0.25168386f, -0.10151432f, -0.16281280f, -0.20176591f, -0.19949076f, 
    0.28008699f, -0.00232207f, -0.07480657f, 0.01188816f, -0.31285366f, 0.22520861f, 0.05055641f, 0.27967522f, 
    -0.12109817f, 0.15813655f, -0.10887462f, 0.01132528f, 0.09886011f, -0.06742358f, -0.06483714f, 0.11901104f, 
    -0.10229997f, -0.17037736f, -0.46124521f, 0.01886002f, -0.10462976f, 0.17893466f, -0.09844095f, 0.31247374f, 
    -0.11778695f, 0.02446398f, 0.04825864f, -0.21050037f, -0.10200012f, 0.36198947f, 0.20405623f, 0.24214965f, 
    -0.03729269f, -0.18888859f, 0.08297806f, 0.11519821f, 0.08335154f, -0.09016365f, 0.19750625f, -0.08396609f, 
    0.03543311f, -0.02524468f, 0.03406087f, -0.06888545f, -0.07180265f, 0.01460504f, -0.07059661f, -0.05623300f, 
    -0.03014939f, 0.05675346f, 0.00874670f, 0.03735020f, 0.03827025f, -0.07233340f, -0.01317626f, 0.02304383f, 
    -0.01867614f, -0.01080933f, -0.04921169f, -0.01659765f, 0.03850221f, -0.02901147f, -0.01517156f, 0.05690348f, 
    -0.02403174f, 0.04754129f, -0.00367898f, 0.01121766f, 0.06503949f, 0.03988098f, 0.05447822f, 0.03238368f, 
    -0.04708153f, 0.05314261f, -0.06005239f, 0.02083507f, -0.00769883f, -0.04389100f, -0.02564280f, 0.05000455f, 
    -0.03627544f, -0.04326338f, 0.01340618f, -0.02301065f, -0.07196531f, -0.05753691f, 0.06283848f, -0.03540451f, 
    0.00675283f, -0.06022941f, 0.01100951f, 0.02948172f, 0.01184088f, -0.05199543f, 0.03155372f, 0.04663816f, 
    0.00528742f, -0.04876027f, -0.07607803f, -0.06968550f, -0.05198189f, -0.06402413f, 0.04954301f, -0.00409748f, 
    -0.02469623f, -0.01430964f, -0.00664610f, -0.01859873f, -0.05515466f, -0.04828159f, -0.02213044f, -0.03138603f, 
    0.03524429f, -0.01007491f, -0.00740434f, 0.03431850f, -0.06461315f, 0.01231107f, -0.04963248f, -0.04485938f, 
    -0.02328456f, -0.07280747f, 0.03522602f, 0.03875695f, -0.00102449f, -0.07825295f, 0.03675348f, 0.01169027f, 
    -0.04890138f, -0.01696488f, -0.06506693f, 0.04587143f, 0.02268301f, -0.07696313f, -0.03295411f, -0.00588726f, 
    -0.03370564f, -0.06627373f, 0.02354893f, 0.03665150f, -0.06667676f, 0.05871163f, 0.02145637f, 0.04701138f, 
    0.00193369f, 0.06054187f, 0.00898293f, -0.06842524f, -0.02029561f, 0.01480792f, -0.01488157f, 0.05117542f, 
    -0.06135004f, 0.05162384f, 0.05583708f, -0.04700159f, 0.05875006f, 0.01490174f, 0.04224518f, 0.00846897f, 
    -0.02601237f, -0.02852843f, 0.02546661f, -0.07205213f, -0.01142207f, -0.01612966f, 0.05367639f, -0.02886085f, 
    0.01537889f, 0.02130469f, -0.06848397f, -0.02792899f, -0.00988197f, -0.06252734f, 0.01713156f, 0.02446530f, 
    0.03755556f, -0.07499088f, 0.04055896f, -0.04583742f, 0.05432484f, 0.01488443f, 0.05761296f, -0.06062393f, 
    -0.06600778f, 0.02121448f, -0.02852323f, 0.05129794f, -0.03480349f, 0.01992335f, -0.02291433f, 0.02981394f, 
    -0.05880299f, -0.07647784f, 0.04119986f, -0.03760793f, -0.04606535f, 0.03039780f, -0.03092515f, -0.04357477f, 
    -0.07094088f, 0.03724852f, -0.01829714f, 0.01625906f, 0.04425716f, -0.00530605f, -0.04013290f, -0.06311127f, 
    0.02185407f, -0.02223682f, -0.01206137f, -0.07916957f, 0.02453575f, -0.00484098f, -0.05350383f, -0.07081395f, 
    0.00353482f, -0.01173928f, -0.05209237f, -0.07620512f, -0.00231216f, -0.08046634f, 0.02122696f, 0.04207247f, 
    -0.04028322f, -0.03753652f, -0.07321247f, -0.06656787f, -0.04999717f, 0.01522033f, 0.04574928f, 0.04468496f, 
    0.03804335f, 0.01005344f, -0.04194980f, 0.01735521f, 0.01678407f, 0.04822215f, -0.04070182f, -0.01243345f, 
    -0.00810768f, -0.00490580f, 0.00630412f, -0.05252504f, 0.00366181f, -0.03860899f, -0.00182835f, -0.05134772f, 
    -0.06630284f, 0.01789694f, -0.03723881f, 0.03692956f, 0.02074331f, -0.05725596f, -0.00437815f, 0.01778531f, 
    -0.03477057f, 0.00635447f, -0.02123115f, 0.02459192f, -0.04439154f, -0.05037526f, -0.02100641f, 0.05470733f, 
    -0.02482994f, -0.03991893f, -0.04905546f, 0.04671775f, -0.00347987f, 0.00243892f, -0.02623866f, -0.06390952f, 
    0.01118253f, 0.02012341f, -0.00733292f, 0.03551714f, 0.03656572f, 0.01021454f, 0.05047505f, -0.05975758f, 
    -0.07360081f, 0.05862826f, -0.04057861f, 0.00777432f, 0.04436292f, 0.02881236f, 0.04858387f, -0.03161424f, 
    0.00800198f, 0.04553097f, -0.07477980f, -0.04801222f, 0.00188418f, 0.02815881f, 0.01617201f, -0.04765853f, 
    -0.05571935f, -0.07200959f, -0.05073669f, -0.05806163f, -0.06262238f, -0.04761621f, -0.06590527f, 0.05443320f, 
    -0.06692088f, 0.05153440f, 0.00924057f, -0.03050689f, 0.03427128f, 0.06375821f, 0.01976344f, 0.06590654f, 
    -0.00787530f, -0.05256310f, -0.07007486f, 0.00062514f, -0.03298728f, -0.03800027f, -0.02928156f, -0.05967248f, 
    0.01698988f, 0.05177428f, -0.02434726f, -0.01158341f, 0.00589899f, -0.03266781f, 0.02344386f, -0.01779934f, 
    0.02600595f, -0.03373809f, 0.03889730f, -0.07019580f, 0.01395246f, -0.04788546f, 0.06096891f, -0.00367738f, 
    -0.01331992f, 0.04476453f, 0.00920060f, -0.06060594f, -0.00176677f, -0.01776784f, 0.04854342f, -0.06342573f, 
    0.00018592f, -0.03373636f, 0.05961362f, -0.02366798f, -0.06378397f, -0.00095045f, -0.02733117f, 0.04467263f, 
    0.02078537f, -0.04988219f, 0.03189249f, 0.01689497f, -0.04497731f, -0.07099539f, -0.02429147f, -0.03372885f, 
    0.04250465f, 0.06184268f, 0.04998391f, 0.00755173f, -0.07548353f, -0.01340955f, -0.05470473f, -0.07726714f, 
    0.02165595f, -0.06692576f, 0.04530961f, -0.06001430f, 0.02145734f, -0.04010094f, -0.03181885f, -0.06011444f, 
    -0.00713650f, 0.05512462f, -0.03768154f, -0.01001840f, 0.02983432f, 0.01539690f, -0.03430643f, -0.00152375f, 
    -0.03641243f, 0.04050077f, 0.01351034f, -0.00921080f, 0.03093145f, -0.03919736f, -0.01827295f, 0.05098533f, 
    -0.04408070f, 0.00157515f, -0.06551305f, 0.03372914f, -0.05575677f, 0.04205144f, -0.03752819f, -0.05020292f, 
    -0.00374412f, -0.06157362f, -0.02839576f, -0.01792598f, -0.02826548f, 0.05742000f, 0.06534832f, -0.06502401f, 
    0.05647929f, 0.00971397f, -0.04091099f, -0.00740754f, -0.02152609f, 0.03580311f, -0.01492392f, -0.01266327f, 
    0.02771649f, -0.06338044f, 0.04460913f, 0.00565464f, -0.05295165f, 0.02485834f, -0.07453336f, -0.00124148f, 
    -0.27322894f, -0.16595925f, -0.19869068f, -0.08091994f, -0.02051035f, -0.09217833f, 0.06474028f, 0.06580617f, 
    0.10242334f, -0.02901175f, -0.00795719f, 0.26679033f, 0.03761209f, 0.13916610f, -0.13356562f, -0.19426285f, 
    -0.08355818f, -0.09075288f, -0.01514778f, 0.07774363f, -0.04413725f, -0.19105369f, -0.16051836f, -0.14779404f, 
    0.16162357f, -0.31168112f, 0.36368605f, -0.21536379f, -0.09198769f, 0.12174630f, -0.06295092f, 0.05653487f, 
    -0.13579553f, 0.05319991f, -0.01043158f, -0.05302570f, 0.14885376f, 0.21293272f, -0.16994569f, 0.32287300f, 
    0.07484175f, 0.18354125f, 0.07975715f, -0.14491978f, 0.14991336f, 0.04443767f, 0.08426578f, 0.09014695f, 
    -0.23447229f, -0.16713543f, 0.04348088f, 0.18178338f, 0.05210870f, -0.09736195f, -0.00837148f, -0.08546451f, 
    0.05869110f, 0.00992868f, -0.06804273f, -0.03478790f, 0.01298083f, 0.08651880f, 0.03496163f, -0.21632709f, 
    -0.05028935f, -0.13107698f, 0.05747333f, 0.07804764f, 0.24729151f, -0.10684723f, 0.08038608f, 0.33187687f, 
    0.16575637f, 0.43146536f, 0.27666375f, 0.04104206f, -0.00874447f, 0.12511061f, 0.01905345f, -0.01801494f, 
    0.04425791f, -0.02242017f, 0.18112066f, -0.04077874f, -0.33139291f, -0.23560232f, -0.06257471f, 0.18957800f, 
    0.07110554f, -0.00480042f, 0.11365707f, 0.15004714f, 0.04439859f, 0.12192668f, 0.07125919f, 0.00490381f, 
    -0.35439229f, -0.22161491f, -0.19773728f, 0.00426189f, 0.09037434f, 0.16834560f, -0.04277364f, -0.18312807f, 
    0.04282964f, 0.07075485f, -0.01970371f, 0.15735930f, -0.09274992f, 0.00836044f, -0.03525033f, -0.23409162f, 
    -0.01861558f, -0.08146893f, -0.03004404f, 0.01504839f, 0.03848059f, 0.07783116f, -0.06849010f, 0.14127108f, 
    -0.10434911f, 0.40808326f, -0.18408950f, 0.08685715f, 0.02194180f, 0.00974395f, 0.06651761f, -0.06697697f, 
    -0.09463677f, 0.02023115f, 0.10870188f, -0.09839257f, -0.20629263f, 0.02937043f, 0.12493555f, -0.04004085f, 
    -0.02633670f, 0.01472540f, 0.16782610f, 0.12102609f, -0.04669251f, -0.02659787f, 0.05484097f, -0.15207005f, 
    -0.26143467f, 0.23078233f, 0.22799724f, -0.03080546f, -0.15125880f, -0.12315697f, 0.11310519f, 0.15181576f, 
    0.18283208f, 0.17273510f, -0.05399008f, 0.03753133f, 0.08052690f, -0.08953364f, -0.14646897f, 0.06798512f, 
    -0.01268081f, 0.18672708f, 0.13969037f, -0.00297826f, 0.00848514f, 0.05637350f, 0.13055192f, 0.22417150f, 
    -0.10028295f, -0.53393281f, -0.12018326f, -0.13354295f, -0.16771726f, -0.10838127f, -0.02624110f, -0.11218453f, 
    0.00121882f, 0.00094753f, -0.00224344f, 0.04397619f, 0.33866999f, 0.31565821f, 0.02068625f, 0.29250157f, 
    -0.10221113f, -0.01384374f, -0.16687986f, 0.16016933f, 0.01494947f, 0.11685387f, 0.06260102f, 0.01919749f, 
    0.11768940f, 0.08396792f, 0.09067807f, -0.03656707f, -0.04267615f, -0.04407475f, 0.01456749f, 0.18790548f, 
    0.26227689f, 0.09685119f, 0.08601042f, 0.10655241f, 0.00615687f, -0.09651161f, 0.01452893f, 0.07703039f, 
    0.20242244f, 0.00124811f, -0.00409272f, 0.02839945f, -0.17993581f, -0.27013874f, 0.17292722f, -0.02479806f, 
    -0.31245697f, 0.09917431f, -0.01720043f, 0.08120114f, 0.16640577f, 0.01963892f, -0.00249490f, 0.02634996f, 
    0.04453624f, 0.09233969f, -0.07463267f, 0.09072706f, 0.17362367f, -0.13651371f, -0.35424203f, 0.11051878f, 
    0.07748952f, 0.01171472f, -0.11184218f, -0.00056332f, 0.02842651f, -0.16170532f, -0.02378589f, 0.07461658f, 
    0.10086365f, 0.15456161f, -0.03252343f, -0.23277338f, 0.08224396f, 0.11177697f, -0.05861968f, 0.08994045f, 
    -0.05560396f, -0.16444689f, 0.04500224f, 0.07468303f, 0.02294947f, 0.13658476f, 0.06259709f, -0.18328582f, 
    0.02683611f, 0.10771421f, -0.08134022f, -0.04832708f, 0.00581976f, 0.02572628f, 0.10586269f, 0.03246149f, 
    0.05393401f, -0.27665964f, -0.31568021f, -0.00143166f, 0.00366564f, 0.08613116f, -0.04182547f, -0.13609381f, 
    -0.04665807f, 0.02322760f, -0.03217672f, -0.02282905f, 0.17760731f, 0.05667149f, 0.23942885f, -0.07054263f, 
    0.15089163f, 0.03972960f, 0.13453296f, 0.22439641f, -0.03740688f, 0.07381577f, -0.01332174f, -0.01206053f, 
    0.38328606f, 0.22794747f, 0.12403869f, -0.05657401f, 0.21997531f, 0.09228519f, 0.15489912f, -0.03507347f, 
    -0.05824626f, -0.08918677f, 0.05079804f, 0.01057872f, -0.17762789f, -0.18471287f, -0.30730626f, 0.06779395f, 
    -0.00582356f, 0.04170180f, -0.04419667f, -0.01755342f, 0.11324779f, 0.07807797f, 0.06304232f, 0.06900387f, 
    0.50078011f, -0.40528801f, 0.31121761f, -0.40301576f, -0.07212181f, -0.15385985f, 0.12576218f, -0.02924845f, 
    -0.00948902f, -0.06971538f, -0.18749681f, -0.05559156f, -0.30463633f, 0.11551222f, -0.06837489f, -0.08710503f, 
    0.08283979f, 0.19984013f, 0.11954837f, 0.09870409f, 0.13134071f, -0.10911617f, -0.02709928f, -0.05409879f, 
    0.15295289f, -0.25796425f, -0.37352467f, -0.10456419f, 0.00966870f, 0.04148769f, 0.01158154f, -0.03713648f, 
    0.09281505f, -0.05766902f, 0.18498617f, 0.14073901f, -0.06182178f, 0.28431913f, 0.01434653f, 0.11943568f, 
    -0.12280834f, 0.02291162f, -0.05547922f, 0.02619891f, 0.06330046f, 0.05007834f, -0.01735835f, 0.15559180f, 
    0.05501627f, 0.06517420f, -0.12783910f, 0.06489585f, -0.15331295f, 0.07102056f, -0.00372632f, 0.21128665f, 
    -0.02628334f, 0.13505748f, 0.17707188f, -0.01944212f, -0.35330078f, -0.42153525f, 0.07228788f, -0.10112167f, 
    -0.01310739f, -0.18863468f, 0.06262851f, -0.03861995f, 0.04150245f, -0.00361236f, 0.16721180f, -0.07410257f, 
    -0.21974747f, 0.23630530f, 0.07939129f, 0.05315929f, 0.02554923f, -0.15481260f, 0.09174722f, -0.09886956f, 
    -0.13457362f, 0.19912669f, 0.08483662f, 0.20990483f, -0.09240159f, 0.17357682f, -0.09542860f, -0.04124343f, 
    -0.05115408f, -0.00062803f, -0.02427930f, -0.07058145f, -0.07434588f, -0.05005438f, -0.05707322f, -0.00798380f, 
    0.12324446f, -0.20706572f, 0.35289532f, -0.32906839f, -0.07512860f, -0.05793867f, -0.16020320f, -0.00749950f, 
    -0.04048626f, -0.02456192f, 0.03110658f, 0.08563368f, -0.07794398f, -0.17345619f, 0.29269427f, 0.08897469f, 
    0.06107624f, 0.12382987f, 0.09974623f, -0.01157729f, 0.05468355f, 0.10998312f, 0.11438160f, 0.08072855f, 
    0.12629981f, 0.18918936f, 0.11205202f, 0.13675992f, 0.12081236f, 0.15651494f, -0.05834093f, -0.10531174f, 
    -0.03422021f, -0.06289766f, -0.05933100f, -0.09046102f, -0.30189535f, 0.14351824f, 0.00065324f, 0.30477330f, 
    -0.13348107f, -0.07396783f, 0.23276019f, 0.08261294f, 0.05283152f, 0.10824889f, 0.05482604f, 0.29825601f, 
    0.37303743f, 0.15490083f, 0.29067791f, 0.22541997f, 0.02393257f, -0.11019614f, 0.00492050f, -0.01187907f, 
    0.04794868f, -0.13453633f, 0.06809890f, -0.10638091f, -0.22552204f, 0.17384601f, -0.16019553f, -0.17425770f, 
    -0.03898999f, -0.05239945f, -0.06635857f, 0.02137850f, -0.07442083f, 0.05740121f, -0.12267425f, -0.11123477f, 
    -0.11852384f, -0.08835851f, -0.06319958f, 0.03761310f, -0.29501268f, 0.08552305f, -0.12383458f, -0.11003935f, 
    -0.07379433f, -0.13504019f, -0.09305278f, -0.01676803f, -0.00641892f, 0.26015356f, 0.03672710f, 0.02891856f, 
    -0.22171234f, 0.16318540f, -0.00690403f, -0.03540138f, -0.06677200f, 0.03355853f, 0.15521480f, 0.20674154f, 
    -0.21782149f, 0.19157539f, -0.13287996f, 0.04532823f, -0.06498173f, 0.05858278f, -0.08270162f, -0.02742339f, 
    -0.01722348f, -0.07310135f, 0.13267909f, -0.00266864f, -0.22887926f, 0.08784225f, -0.09574874f, -0.00799360f, 
    0.14766645f, 0.09258377f, 0.10699805f, 0.14053339f, -0.24373318f, 0.14278613f, -0.02144836f, -0.18796360f, 
    -0.10986025f, 0.00385537f, -0.05728314f, -0.21485713f, -0.07448487f, 0.10983612f, 0.06884915f, 0.27344134f, 
    -0.01922943f, 0.01288938f, -0.01678728f, -0.02927986f, 0.26581079f, -0.15157942f, 0.18106529f, -0.06034661f, 
    0.02234226f, 0.12068365f, 0.06338300f, 0.01970888f, 0.11919957f, 0.27722380f, 0.10953566f, 0.08526447f, 
    -0.03304290f, -0.31402043f, 0.17266868f, -0.15702364f, 0.13210782f, -0.10314204f, 0.15987335f, 0.07649316f, 
    -0.17939177f, 0.05686240f, 0.03042826f, -0.09003956f, 0.25693160f, 0.32991910f, 0.15962076f, 0.27192602f, 
    -0.08357647f, 0.15142703f, -0.22080638f, 0.21817686f, -0.02766298f, 0.13232891f, -0.10856667f, 0.05497785f, 
    0.24758169f, -0.46824756f, -0.10450670f, 0.03049247f, -0.10474896f, 0.14489195f, 0.02649818f, -0.04286712f, 
    0.01924494f, -0.10491878f, -0.10375348f, -0.06610643f, 0.09752943f, 0.00126163f, 0.01044424f, -0.12190430f, 
    -0.03127493f, 0.08443768f, -0.01084423f, 0.07452957f, 0.00111267f, -0.04211341f, 0.05972452f, -0.10959548f, 
    0.51137316f, -0.25314707f, -0.51346749f, 0.11553556f, -0.03228565f, 0.22665522f, 0.29657400f, -0.08682683f, 
    -0.02786280f, 0.07641244f, -0.05860680f, -0.04592562f, 0.45491341f, 0.23052724f, -0.16348340f, -0.01172692f, 
    -0.03456286f, -0.09191155f, 0.20651165f, 0.16115041f, 0.00569921f, 0.05810504f, -0.01717076f, -0.23624608f, 
    -0.29729441f, -0.19725120f, 0.06434218f, 0.02486378f, -0.04714647f, -0.12934680f, 0.18088995f, -0.03553434f, 
    -0.10593184f, 0.01485614f, 0.04628464f, 0.23968968f, 0.09125665f, 0.01019887f, 0.14085986f, -0.15176067f, 
    -0.19937421f, 0.04373091f, -0.02481897f, 0.10207012f, 0.20966016f, 0.05439568f, 0.03594660f, -0.02326765f, 
    0.16537586f, 0.06896734f, -0.14658448f, -0.12255351f, -0.01208358f, 0.04377297f, 0.17553060f, 0.19681682f, 
    0.02827358f, 0.10367462f, 0.09621139f, -0.11503160f, 0.00590996f, -0.23239395f, -0.03999099f, 0.38241303f, 
    0.11356544f, 0.10166262f, 0.15613258f, 0.15385453f, 0.06048929f, -0.03163996f, 0.09542678f, 0.14878346f, 
    -0.05997555f, 0.06053705f, 0.21944502f, 0.30268744f, 0.06342766f, -0.10954966f, 0.22331880f, -0.03398818f, 
    -0.04206199f, -0.09292518f, -0.10299728f, 0.04732242f, 0.14756225f, -0.08339481f, -0.07841635f, -0.05142987f, 
    0.02034685f, -0.17437015f, -0.09424285f, -0.02427698f, 0.08358797f, -0.05305479f, -0.17884120f, 0.00625766f, 
    -0.11726973f, 0.05583712f, -0.05779969f, -0.00255179f, 0.05347057f, 0.00471984f, 0.10088571f, 0.15106693f, 
    0.07409532f, 0.15779912f, 0.19103511f, 0.00582901f, 0.04030663f, -0.16361356f, 0.10514244f, -0.13814369f, 
    -0.01900873f, -0.15390937f, 0.00931692f, 0.02388395f, 0.13569011f, -0.23927958f, 0.05775236f, 0.01164325f, 
    -0.13571548f, -0.16506058f, 0.07428966f, -0.17561500f, 0.13605240f, -0.26802135f, -0.13411398f, -0.05241993f, 
    -0.11615926f, 0.10821475f, 0.11453044f, 0.10082275f, -0.15603319f, 0.29109713f, -0.35276809f, 0.08736464f, 
    -0.06669956f, 0.03591020f, -0.18144920f, -0.09926644f, -0.00644188f, -0.07932648f, 0.07707408f, -0.15013494f, 
    0.07744045f, 0.02070545f, -0.16431613f, 0.07378283f, -0.11737140f, 0.06998140f, -0.09304856f, -0.07187721f, 
    -0.03281879f, -0.13194472f, -0.04525388f, -0.13852499f, 0.11973731f, -0.06907044f, -0.14860943f, -0.07523923f, 
    0.07210837f, 0.01482745f, 0.05041443f, 0.02707832f, 0.03710104f, -0.00792257f, 0.19547363f, -0.10688096f, 
    0.06346614f, 0.24000724f, -0.09749726f, 0.07712038f, 0.07458037f, 0.00642628f, -0.12775624f, -0.14552549f, 
    0.17975219f, 0.11380944f, 0.08032503f, 0.12869452f, 0.03058497f, 0.12128296f, -0.02490240f, -0.10523380f, 
    -0.09120281f, -0.08474004f, -0.13887927f, -0.08703725f, -0.00958006f, -0.16282982f, -0.00357071f, -0.08939692f, 
    0.20653532f, -0.09766465f, 0.17758134f, -0.01418902f, 0.10274065f, -0.19870123f, -0.09134956f, 0.04363510f, 
    0.03877775f, 0.11076748f, -0.12613159f, 0.00699393f, 0.08767799f, -0.22123550f, 0.04841218f, 0.18179993f, 
    0.18783449f, 0.20487480f, 0.02283244f, 0.26115525f, 0.12159847f, 0.04405022f, 0.14211552f, 0.17626362f, 
    0.07786522f, 0.07023723f, -0.04013905f, -0.00786887f, 0.10079218f, -0.11683693f, 0.08694035f, 0.02658154f, 
    0.07707086f, -0.03673425f, 0.22400580f, 0.25014174f, -0.27117407f, 0.24181697f, -0.13802855f, 0.20231918f, 
    -0.06399884f, 0.15400171f, 0.11786705f, -0.03318646f, 0.13221425f, -0.26743990f, 0.16776745f, 0.07625429f, 
    -0.01198514f, -0.22090212f, 0.05331073f, 0.02714232f, -0.05457535f, 0.18807141f, -0.04140639f, -0.00066829f, 
    0.01407818f, -0.11558725f, -0.18133278f, -0.30717883f, 0.05543598f, 0.16872625f, 0.22212447f, 0.01382860f, 
    0.12624966f, -0.13480745f, 0.18582276f, 0.09613322f, -0.19494243f, 0.06766479f, 0.08536752f, -0.09656300f, 
    0.12606128f, 0.02283885f, 0.00061309f, 0.13849279f, 0.01004634f, 0.08745479f, 0.05355421f, 0.01299985f, 
    -0.04528714f, -0.04041411f, 0.11169764f, 0.04063125f, 0.02874240f, 0.15779714f, 0.18959567f, 0.19554433f, 
    -0.07174113f, 0.00954917f, -0.15785290f, -0.14413929f, 0.14438981f, 0.17504629f, 0.04036891f, 0.17422962f, 
    0.02487817f, 0.34680048f, -0.15429133f, 0.00589355f, -0.00847177f, -0.15056166f, 0.08921264f, 0.03246656f, 
    -0.28382996f, -0.15884210f, -0.02134208f, -0.25653315f, -0.31254971f, -0.22238839f, -0.33189169f, -0.35505337f, 
    0.09419946f, -0.00110901f, 0.15007016f, 0.02704130f, -0.25765768f, -0.10185043f, -0.06776952f, -0.28363025f, 
    -0.14518149f, -0.43443739f, -0.21555470f, -0.29894480f, 0.04883839f, -0.01445176f, -0.00124177f, -0.02612722f, 
    0.11854276f, 0.03609834f, 0.07689080f, 0.19407572f, 0.54093558f, -0.11066770f, -0.04291196f, -0.03623979f, 
    0.08878083f, -0.09061009f, -0.11704647f, 0.11474356f, 0.30686405f, 0.12865527f, 0.03115450f, 0.12949942f, 
    -0.21854386f, -0.11613759f, -0.06214519f, -0.18278186f, 0.07222950f, 0.04514342f, 0.14945589f, 0.19829282f, 
    0.09504627f, 0.07036824f, 0.06619371f, -0.09032020f, -0.13030899f, 0.37475768f, 0.03505042f, 0.18306212f, 
    0.01771959f, -0.12084103f, -0.16163109f, -0.04787793f, 0.03655271f, 0.21931902f, 0.13196097f, -0.11046603f, 
    0.01922528f, 0.24107884f, -0.02503400f, 0.12514243f, 0.07204974f, -0.03175547f, 0.09303278f, -0.01231691f, 
    -0.06454188f, 0.13151991f, 0.07035414f, 0.08810008f, -0.06312291f, 0.01990988f, -0.10467831f, 0.15511832f, 
    0.01277508f, -0.04577447f, 0.06849916f, 0.12408997f, -0.15068008f, -0.07810833f, -0.05773935f, -0.21442880f, 
    0.11395186f, 0.08675202f, 0.08084760f, 0.08552091f, 0.19697756f, -0.03493240f, -0.02315799f, 0.07236887f, 
    0.02242228f, -0.11108391f, 0.01765803f, 0.07197381f, -0.31362683f, -0.19526161f, 0.41004434f, -0.31860006f, 
    0.14000387f, -0.00025280f, -0.05890299f, 0.01724575f, 0.13188578f, 0.11173253f, -0.12735482f, -0.05912554f, 
    0.07604021f, 0.32453477f, 0.13079724f, -0.23323187f, -0.05168137f, 0.01622974f, 0.09220628f, -0.05385055f, 
    -0.01397590f, 0.14882667f, 0.21660125f, -0.18702710f, 0.05470212f, -0.00799414f, -0.01881563f, -0.01873774f, 
    -0.23839991f, -0.12693593f, -0.07899442f, 0.09098175f, -0.29502127f, 0.11716488f, -0.04412050f, 0.01335902f, 
    0.35559094f, -0.03524818f, 0.10763987f, 0.00537588f, 0.18378688f, -0.13192342f, -0.02986084f, -0.01987260f, 
    -0.12673540f, -0.04671196f, -0.13854994f, -0.10166313f, -0.13947150f, 0.22687802f, -0.06705585f, -0.07332861f, 
    -0.11823665f, -0.15749714f, 0.06961928f, 0.06753723f, -0.01791962f, 0.04784236f, -0.16356206f, -0.08824441f, 
    -0.01829815f, 0.26095438f, 0.14787708f, -0.19694613f, -0.22462979f, -0.06113041f, -0.11257604f, 0.04993432f, 
    0.08257794f, 0.09376818f, 0.04284662f, -0.03665718f, 0.06278528f, 0.06210679f, 0.01165087f, 0.08803097f, 
    -0.00488968f, -0.01988405f, 0.07509896f, 0.07660262f, -0.05321132f, -0.06309099f, 0.14621867f, 0.11018683f, 
    -0.34990525f, -0.18274140f, 0.06757247f, 0.24665615f, 0.04087120f, 0.23815058f, -0.11994389f, 0.08733318f, 
    0.04714303f, -0.05278331f, 0.04175286f, 0.10634857f, -0.52948284f, 0.24907064f, -0.00496665f, 0.17808945f, 
    -0.02631949f, 0.12555657f, 0.04454517f, -0.02665229f, -0.11972901f, 0.24085678f, 0.11648576f, -0.18366395f, 
    -0.36334983f, -0.21499208f, 0.14806460f, -0.04779545f, -0.02969240f, 0.09267183f, -0.07457693f, 0.06719241f, 
    -0.22880279f, -0.03337055f, -0.05241039f, -0.18770184f, -0.23338552f, -0.20458615f, 0.30711767f, 0.01006832f, 
    0.06702984f, 0.28661036f, -0.13850023f, 0.32605109f, 0.07489434f, 0.12389063f, -0.08010215f, -0.02310885f, 
    0.17134258f, -0.01750628f, -0.04080799f, -0.03270757f, -0.02044575f, -0.10665362f, -0.30708292f, -0.19397761f, 
    -0.08450189f, -0.00566120f, -0.08119258f, 0.06188725f, 0.09944174f, 0.35534152f, -0.06357478f, 0.19488485f, 
    0.06479664f, 0.10392284f, 0.04523256f, 0.08792226f, -0.11872043f, -0.00490411f, 0.06396239f, 0.16493168f, 
    -0.03881010f, 0.24531719f, 0.24064694f, -0.23655482f, -0.10762577f, -0.14134961f, -0.01222497f, -0.05330392f, 
    -0.17437902f, 0.06908861f, 0.03196909f, -0.03261343f, 0.08457271f, -0.03588925f, 0.28204277f, 0.07328033f, 
    -0.27968234f, -0.05834005f, -0.03707162f, -0.21325465f, -0.03006050f, -0.06778914f, -0.07134828f, 0.04043287f, 
    -0.07467176f, 0.12571950f, 0.66122311f, -0.04651353f, 0.05227672f, -0.22274134f, -0.29198235f, 0.14654297f, 
    -0.00537844f, -0.09980187f, 0.10434164f, 0.12680164f, -0.12044494f, -0.19239850f, 0.04802835f, -0.07337310f, 
    0.00486553f, 0.16504490f, -0.05961381f, 0.09012511f, 0.10106089f, 0.13572595f, 0.08985971f, 0.13188219f, 
    0.40168342f, 0.24342844f, 0.02615491f, -0.06347515f, 0.34194759f, 0.15482090f, -0.00987119f, 0.22326858f, 
    0.00880309f, 0.08529860f, -0.16231491f, 0.09028780f, -0.14171405f, 0.01700728f, 0.03580929f, -0.29187101f, 
    -0.00978814f, 0.04144001f, 0.14149410f, -0.12176216f, -0.08883017f, 0.15573791f, -0.08237240f, 0.03197412f, 
    0.25557905f, -0.25375929f, 0.17086026f, -0.05934034f, -0.21167013f, 0.00045662f, -0.04870101f, -0.14059757f, 
    0.13299073f, -0.02971908f, 0.27643707f, 0.04164148f, 0.12585968f, 0.11384848f, 0.14703989f, -0.28219205f, 
    0.17830713f, 0.02250344f, -0.13875130f, 0.07179852f, 0.23184867f, 0.02202610f, -0.01028168f, 0.00381339f, 
    0.19408084f, 0.10868109f, -0.26787645f, 0.00515816f, 0.03556394f, 0.09026828f, -0.06562374f, 0.14075063f, 
    -0.11490528f, -0.14383404f, 0.04747174f, 0.05117492f, 0.21165952f, 0.29081869f, -0.00122949f, 0.02592298f, 
    -0.13180940f, 0.04946318f, -0.15762645f, -0.12666404f, -0.09472287f, 0.05898928f, 0.06281100f, -0.09762701f, 
    0.29306802f, 0.03380045f, -0.25178823f, 0.54716349f, 0.02215407f, -0.09227452f, 0.21705765f, -0.07303762f, 
    0.07952821f, 0.08997780f, 0.21033438f, 0.10225485f, 0.45568532f, -0.15935631f, -0.22320230f, -0.05974358f, 
    0.24772233f, 0.17337862f, 0.01835599f, 0.00801154f, -0.05467596f, 0.10712704f, 0.02754904f, -0.01424283f, 
    0.25202143f, -0.18662387f, -0.28908882f, 0.14440125f, 0.04724492f, -0.04978855f, 0.37616882f, -0.17784086f, 
    0.02686748f, 0.16488288f, -0.14437877f, 0.02118772f, -0.04335614f, 0.17532925f, -0.08032786f, -0.09266809f, 
    0.08235907f, -0.03041915f, 0.18987422f, -0.12590268f, -0.08600799f, 0.13986814f, 0.10481603f, 0.02940902f, 
    -0.34767812f, -0.01973452f, 0.07862195f, -0.25679559f, 0.03302533f, -0.16467769f, -0.03261634f, 0.05995049f, 
    0.16201934f, 0.11590064f, 0.04219488f, 0.10560385f, 0.16249669f, 0.07880192f, 0.15889892f, 0.20378014f, 
    0.03262518f, 0.09872879f, -0.33834279f, 0.01055410f, 0.04843933f, -0.02607136f, -0.40863210f, -0.14129153f, 
    0.07657935f, -0.04518624f, 0.07959542f, -0.00096959f, 0.01691752f, 0.11119349f, -0.14435898f, -0.13958286f, 
    -0.28241134f, 0.01677831f, -0.09982869f, -0.23483652f, 0.10798232f, 0.05047121f, 0.02082025f, -0.02659062f, 
    -0.10586545f, 0.13327190f, 0.03920429f, 0.04909242f, 0.28512967f, 0.19983757f, 0.08530824f, -0.00839890f, 
    0.47988290f, 0.09041187f, 0.21975279f, 0.08951046f, -0.05886201f, -0.09138708f, -0.02997167f, 0.00152869f, 
    -0.07432653f, -0.03561690f, 0.08505953f, -0.00945331f, 0.13097100f, 0.03870098f, 0.06875553f, -0.39496529f, 
    -0.03413773f, -0.02489267f, 0.21979076f, 0.05903521f, 0.09642992f, 0.19798613f, -0.16494480f, -0.06413718f, 
    -0.12271287f, -0.15880834f, -0.20543139f, -0.46416724f, 0.20803761f, -0.02037645f, 0.12446143f, 0.09911320f, 
    -0.13034786f, -0.01824443f, -0.08188201f, 0.02553486f, 0.08340535f, -0.01085643f, 0.19146551f, 0.06525798f, 
    -0.09591255f, 0.09407540f, 0.07914256f, 0.21745197f, -0.07029520f, 0.17408751f, -0.04951512f, -0.12379939f, 
    0.22161447f, -0.09314036f, 0.01895804f, 0.08055615f, -0.14843176f, -0.05262341f, 0.02776529f, 0.15254830f, 
    0.25326961f, 0.09943343f, 0.10217398f, 0.05432566f, 0.17125249f, -0.00448515f, -0.00799782f, -0.13073739f, 
    -0.21522145f, 0.12947389f, 0.10338137f, 0.04370391f, 0.04102685f, -0.05080825f, 0.02255423f, -0.03462643f, 
    -0.26514664f, -0.21452862f, -0.37917596f, -0.37739244f, -0.19190843f, -0.43898499f, -0.03722211f, 0.17922677f, 
    -0.12482467f, 0.03579532f, -0.08321074f, -0.07218734f, 0.39394790f, 0.29460546f, 0.18214417f, 0.07743134f, 
    0.02255831f, -0.05762685f, 0.02886205f, -0.05532540f, -0.11715395f, -0.01803806f, -0.19600101f, -0.15301779f, 
    0.19618936f, 0.18431149f, -0.25690857f, 0.54618132f, 0.25190052f, -0.04385788f, 0.10603549f, 0.13763537f, 
    -0.00168276f, 0.21135777f, 0.23777075f, 0.31491461f, 0.34226635f, -0.21820590f, 0.01583072f, -0.10794558f, 
    -0.07582911f, -0.09549182f, -0.12927920f, 0.00343881f, -0.02035528f, -0.06867620f, 0.17782073f, 0.08086530f, 
    0.03718311f, -0.30398196f, 0.42115873f, 0.08667316f, -0.03488715f, -0.24822046f, -0.00018570f, -0.05285994f, 
    -0.18301681f, 0.20363358f, -0.06518774f, -0.01984696f, -0.02143408f, 0.22790861f, -0.03416349f, -0.06302390f, 
    0.28497359f, -0.02182470f, -0.08673912f, 0.00677085f, 0.00547197f, -0.03423797f, -0.01925177f, -0.01344825f, 
    0.08891872f, 0.14640690f, 0.14086449f, -0.08697948f, -0.00628795f, -0.01246936f, -0.04124964f, -0.09602404f, 
    -0.03989151f, -0.01283969f, -0.27334765f, -0.13717163f, 0.27936482f, 0.28644213f, 0.15353811f, 0.12204406f, 
    0.06970517f, 0.26435453f, -0.06715802f, 0.12527837f, 0.04294086f, 0.00265113f, 0.12487861f, -0.01337347f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.10242488f, 0.00384318f, 0.01520087f, -0.12307114f, 0.14760734f, 0.09551325f, -0.14870749f, -0.01613049f, 
    0.17748192f, 0.15697029f, -0.02086912f, 0.16237327f, 0.30595988f, -0.03389400f, 0.26087204f, 0.12982726f, 
    0.04046179f, -0.01100279f, 0.03066835f, 0.19759631f, -0.12084854f, 0.15270875f, -0.06765481f, -0.04669286f, 
    0.29982561f, -0.13643906f, 0.12264630f, 0.09282973f, 0.09251171f, 0.15019871f, -0.00351272f, 0.09699468f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.03959967f, 0.67779243f, 0.15811233f, 0.13181736f, -0.21526794f, -0.20502147f, 0.09699205f, 0.07881013f, 
    0.08119547f, -0.30096000f, 0.15474167f, -0.17808591f, -0.01012614f, -0.10745762f, 0.17537996f, -0.22620711f, 
    0.04546287f, -0.08506913f, -0.01531358f, 0.20508216f, 0.13643532f, 0.44445282f, -0.06209853f, 0.13329455f, 
    -0.12617388f, 0.17404234f, 0.04126500f, -0.01560769f, 0.33067411f, -0.01450335f, -0.01514304f, -0.24708186f, 
    -0.01784110f, -0.32957861f, 0.12682562f, -0.11477567f, 0.47016436f, 0.13636208f, -0.43599325f, 0.12811370f, 
    0.14101072f, 0.03061555f, 0.29641834f, 0.14115639f, -0.30598480f, -0.00239466f, -0.02168537f, 0.04799962f, 
    0.04142198f, 0.16334087f, 0.27386603f, -0.10981836f, 0.10833712f, 0.57897580f, 0.16220163f, 0.14611359f, 
    -0.07570539f, 0.15157619f, -0.20580526f, 0.32175341f, 0.14256923f, 0.11037477f, -0.14941241f, -0.10809029f, 
    -0.21341956f, -0.55869681f, -0.09975219f, -0.20804264f, 0.38584107f, -0.23933184f, 0.06868149f, -0.13769414f, 
    -0.23646006f, 0.16380577f, 0.29527959f, -0.18208884f, 0.40941173f, -0.02271010f, 0.12330259f, 0.12971324f, 
    0.06748310f, 0.23043479f, 0.26561981f, 0.26418281f, 0.29060858f, 0.30006361f, -0.08020920f, -0.00620437f, 
    -0.12780888f, -0.07434379f, 0.06884616f, 0.09643041f, 0.13053620f, 0.22329211f, -0.15423456f, -0.11116525f, 
    -0.30700058f, -0.26109278f, 0.08704169f, 0.40974885f, -0.16893125f, -0.00733595f, -0.10011758f, 0.22054867f, 
    0.15152566f, -0.11749178f, 0.36680037f, 0.18678001f, -0.06575080f, 0.16189301f, -0.04030886f, 0.13318570f, 
    -0.27967063f, 0.22578886f, 0.24857886f, -0.21573332f, 0.06250154f, -0.33278954f, 0.01405992f, -0.02053409f, 
    0.20759411f, -0.15636745f, 0.06753076f, -0.11490696f, 0.19235736f, 0.00583621f, 0.21337976f, 0.12776427f, 
    0.00594002f, 0.08850778f, -0.13430694f, 0.06673230f, -0.00938460f, -0.11903282f, 0.68016553f, -0.48025951f, 
    -0.18600082f, -0.07110816f, -0.25436395f, -0.22803612f, -0.02691527f, -0.14129424f, 0.05842188f, 0.23215733f, 
    0.01602298f, 0.31565800f, 0.24919039f, 0.13735428f, 0.38659474f, -0.38678125f, 0.11807688f, 0.00415496f, 
    0.03610367f, -0.47640932f, -0.13039458f, 0.09040861f, -0.13482565f, -0.14494431f, 0.22260354f, 0.31477007f, 
    0.14336526f, 0.29673159f, -0.00436268f, -0.06199543f, 0.16642484f, -0.27190253f, 0.51508051f, -0.28079298f, 
    -0.25007027f, 0.06912727f, -0.20136453f, -0.63551593f, 0.40708128f, -0.02799460f, 0.01724605f, -0.36615834f, 
    0.41865045f, -0.04858509f, -0.31163201f, 0.18939209f, -0.11152231f, 0.21888152f, -0.00928292f, 0.01189587f, 
    0.18568408f, -0.11117868f, 0.13015108f, 0.08760893f, 0.20758851f, -0.04174820f, -0.06868294f, 0.44001883f, 
    0.20878918f, 0.00253875f, 0.02244229f, -0.07657598f, 0.60613495f, -0.21912511f, -0.87382466f, 0.59341699f, 
    0.31119350f, 0.11212181f, 0.23363484f, -0.00918660f, 0.08120522f, -0.12197521f, 0.27569255f, 0.12246724f, 
    0.01160386f, -0.13440664f, 0.08304558f, 0.31637201f, -0.24302503f, 0.05031004f, 0.15179728f, -0.07805418f, 
    0.36311641f, -0.21529774f, 0.20908082f, 0.08535339f, -0.13310131f, 0.25685576f, -0.14772834f, -0.06490934f, 
    -0.00516727f, -0.06283987f, 0.12354135f, 0.01657453f, 0.05854230f, 0.27332595f, 0.19790511f, 0.06030544f, 
    -0.02401901f, 0.30889529f, 0.10651054f, -0.09697284f, -0.45641050f, 0.12126470f, 0.15205599f, 0.51533037f, 
    0.09283903f, 0.04481119f, 0.42287770f, -0.03359996f, 0.17435735f, -0.00662978f, 0.15604316f, -0.03953123f, 
    -0.13646454f, -0.06494362f, -0.62125695f, -0.02021516f, -0.50185996f, -0.24234891f, -0.15948187f, 0.16415699f, 
    -0.23895322f, -0.15048376f, 0.04647166f, -0.10236099f, 0.11194579f, 0.49210697f, 0.53019345f, 0.19154488f, 
    -0.40006888f, -0.03235680f, 0.23064601f, -0.07465754f, -0.51952517f, 0.05108421f, 0.09126668f, 0.16878268f, 
    -0.02504239f, 0.19961432f, 0.35018516f, -0.12588727f, 0.24494644f, 0.13035764f, 0.07346883f, 0.05875907f, 
    -0.46024704f, -0.01599553f, -0.63306344f, 0.07637122f, -0.44129536f, -0.11587503f, 0.23458892f, 0.34810546f, 
    -0.23620041f, 0.02524737f, 0.16243689f, 0.38995561f, -0.03887751f, -0.04555990f, 0.12521519f, 0.20102090f, 
    -0.07280064f, 0.13673851f, 0.14578535f, -0.00613654f, -0.23127665f, -0.05485621f, 0.22572206f, 0.48367196f, 
    -0.36013153f, 0.11791928f, 0.28726721f, -0.18203039f, 0.32019329f, -0.06963126f, 0.04715545f, -0.11276221f, 
    -0.16003117f, -0.26085475f, 0.02855183f, -0.50285995f, -0.62257230f, -0.23358321f, 0.24499837f, -0.26711053f, 
    -0.13212258f, 0.04892482f, -0.08159718f, 0.41889068f, -0.33765209f, 0.12717074f, 0.29677176f, 0.30460677f, 
    -0.30520764f, -0.14344208f, 0.02377956f, -0.17527142f, 0.29213104f, -0.01693315f, 0.12995134f, -0.15536900f, 
    0.11765922f, 0.20926549f, -0.13946408f, 0.20568338f, 0.03277709f, -0.29592085f, 0.08574608f, -0.07333484f, 
    -0.01313468f, -0.47017488f, 0.37476188f, -0.31580263f, 0.11893479f, 0.12359771f, 0.38733980f, 0.27668217f, 
    -0.00528755f, 0.49252513f, 0.07975071f, 0.00343916f, -0.13385156f, -0.17807797f, 0.36291674f, -0.38282564f, 
    0.19896409f, 0.11134757f, -0.16172330f, -0.14431570f, -0.33732969f, 0.14543331f, 0.05586136f, 0.19003093f, 
    0.17676619f, 0.29169092f, 0.28354236f, 0.02121740f, -0.00077736f, -0.30448282f, -0.13155966f, 0.03421506f, 
    0.19620776f, -0.36501440f, -0.19218029f, -0.07474736f, -0.52761531f, -0.40440625f, 0.34898290f, 0.17010634f, 
    -0.37501189f, -0.09573688f, -0.14189444f, 0.04825486f, -0.02557571f, 0.16168649f, -0.43843940f, 0.37619755f, 
    -0.19557983f, 0.02486463f, 0.08506624f, 0.33466712f, -0.14942262f, -0.04437916f, -0.07654037f, 0.15841304f, 
    -0.24552274f, 0.18045765f, 0.20659046f, -0.11483724f, -0.06425597f, -0.46264005f, 0.10733734f, -0.00644402f, 
    -0.19586430f, 0.20375815f, 0.19196759f, -0.44769272f, -0.05818545f, -0.04351182f, 0.36445063f, -0.15291385f, 
    0.16426077f, 0.51292282f, -0.01656228f, 0.15477654f, -0.09711867f, -0.43517077f, 0.17536782f, -0.34947109f, 
    0.32160735f, -0.12688538f, 0.17467111f, -0.38613716f, 0.22854209f, -0.02783635f, -0.03337140f, 0.45330885f, 
    0.26323316f, 0.06970499f, -0.11329377f, 0.30394599f, 0.39395967f, -0.31083700f, -0.15114275f, -0.07916936f, 
    0.06391085f, -0.12651934f, -0.05112047f, 0.46112362f, 0.16008344f, -0.23146947f, -0.21977502f, 0.02005131f, 
    0.30382255f, -0.62292707f, -0.00281116f, -0.32810861f, 0.54475236f, -0.07233283f, -0.18178953f, -0.00761398f, 
    0.22906527f, 0.41469949f, -0.32938123f, 0.40647927f, 0.11414007f, 0.07102933f, 0.22850485f, 0.13784142f, 
    -0.05218181f, 0.27074969f, 0.27061787f, 0.12952319f, -0.39407536f, -0.01773101f, 0.13079643f, 0.12931037f, 
    0.29949856f, 0.10662284f, 0.04954594f, 0.22279434f, -0.19824624f, 0.01101565f, 0.31069788f, 0.33542553f, 
    -0.12331855f, 0.08649194f, -0.07468784f, 0.14460105f, 0.11446697f, 0.12630509f, -0.17257883f, 0.08610927f, 
    0.19609559f, 0.15234683f, -0.07456680f, -0.34603885f, 0.26852080f, -0.13464130f, -0.09669178f, -0.24719347f, 
    0.16201095f, 0.05426975f, -0.42139274f, 0.03292948f, -0.35499942f, 0.26198682f, -0.06249101f, 0.06447022f, 
    -0.01278701f, -0.26675045f, -0.06509281f, 0.04950764f, -0.04310180f, -0.16790453f, 0.13547736f, 0.45570123f, 
    -0.02424246f, -0.36562657f, -0.01807680f, 0.29057106f, 0.00518292f, -0.03142587f, -0.16444659f, 0.18115580f, 
    -0.09449507f, -0.14539959f, 0.08555922f, 0.41977996f, 0.40480080f, -0.02878674f, 0.35702771f, -0.20569538f, 
    0.10227688f, 0.18919697f, 0.04365394f, -0.05616401f, -0.26094139f, -0.09369244f, -0.16985494f, -0.15085007f, 
    0.26625997f, -0.41278976f, 0.21651752f, -0.33776057f, 0.06394760f, 0.05825849f, 0.31869778f, 0.27630258f, 
    0.16944981f, 0.50203753f, -0.05440783f, 0.17160127f, -0.51652223f, 0.05983061f, 0.22327854f, -0.28518566f, 
    -0.22705185f, -0.38101199f, 0.11181547f, 0.29137671f, -0.01643200f, -0.15127030f, 0.03196811f, -0.40956944f, 
    0.42865068f, 0.15615441f, -0.04234166f, 0.08322901f, -0.15331434f, 0.25743452f, -0.11675151f, 0.05088884f, 
    0.15378752f, 0.15650253f, -0.12733474f, 0.16531396f, 0.29064760f, -0.38149998f, 0.21863627f, 0.01705188f, 
    -0.14995870f, -0.06010554f, 0.13302700f, -0.11232244f, -0.05215284f, 0.09715581f, 0.24203503f, -0.01963995f, 
    0.20926432f, 0.01309190f, 0.03390231f, -0.28852385f, -0.00239875f, 0.09454476f, -0.13571836f, -0.20716548f, 
    -0.23300542f, 0.14012887f, -0.66073734f, -0.09762044f, -0.40594131f, 0.24624856f, 0.16656435f, 0.02370895f, 
    -0.22048575f, 0.14066467f, 0.34470937f, 0.13860171f, -0.05123030f, 0.17253390f, 0.22831465f, -0.07258905f, 
    0.31613719f, 0.05050834f, -0.01811440f, -0.16620302f, -0.10701321f, -0.14475454f, 0.31414691f, -0.52077818f, 
    -0.03447703f, 0.18577255f, -0.17379470f, 0.37988153f, 0.35788906f, 0.05733780f, 0.21277016f, 0.08357879f, 
    0.37883708f, 0.10613682f, -0.23624709f, -0.03561413f, 0.08203508f, -0.06038496f, -0.14192104f, 0.11415450f, 
    0.32314008f, 0.01984333f, -0.03995865f, -0.00532898f, 0.09554601f, 0.08038408f, 0.23669383f, 0.18502784f, 
    -0.02987309f, 0.42917392f, 0.03526977f, 0.38467118f, -0.52791911f, 0.09877580f, 0.04538817f, 0.09036499f, 
    0.16458079f, 0.06307496f, 0.19486840f, -0.20813780f, 0.08099628f, 0.13681720f, -0.16515796f, -0.20462552f, 
    0.14734687f, -0.09820164f, -0.02603806f, 0.00245044f, 0.03220772f, 0.01093250f, 0.05548964f, -0.07844458f, 
    -0.04161834f, 0.13091265f, 0.03282703f, 0.11465655f, 0.23316643f, -0.07681515f, -0.14790171f, -0.45056397f, 
    -0.45066473f, -0.27488244f, 0.10935137f, 0.12630589f, 0.11260054f, -0.10852428f, -0.05680849f, 0.50622362f, 
    -0.21760568f, 0.11287467f, 0.43464872f, 0.03364894f, -0.23035106f, -0.15399697f, 0.23142974f, -0.07621527f, 
    -0.02875114f, 0.21103752f, 0.01066842f, 0.01400325f, 0.25212738f, 0.07047825f, 0.11302040f, -0.16503040f, 
    -0.25780812f, 0.21573478f, -0.05341838f, -0.12292909f, -0.02295316f, -0.10904986f, 0.18550937f, -0.49487752f, 
    0.01480879f, -0.07656006f, -0.15550238f, -0.13964584f, 0.33287156f, -0.56459975f, 0.21800695f, -0.12306400f, 
    0.22110969f, 0.16711581f, 0.22468753f, -0.63695353f, 0.09261572f, -0.08471001f, -0.24430472f, -0.09500173f, 
    0.37094966f, -0.18872216f, -0.20185067f, 0.00419349f, 0.17009188f, 0.14519691f, 0.08449882f, 0.09115449f, 
    0.30345652f, -0.47840321f, 0.09764145f, 0.29391384f, -0.06427742f, -0.18945757f, -0.01169090f, 0.28360161f, 
    0.10703669f, -0.03517957f, 0.06567402f, -0.05967112f, 0.30231312f, 0.19893120f, -0.33462155f, 0.12917176f, 
    0.35884461f, 0.29657495f, 0.17941482f, -0.06477984f, -0.09206070f, -0.08415426f, -0.12136028f, 0.30328968f, 
    0.05792902f, -0.01054331f, 0.15258792f, -0.01546038f, -0.21074930f, -0.05331661f, 0.00072199f, -0.03202086f, 
    0.08763381f, -0.17897762f, -0.26874945f, 0.22763537f, -0.25624233f, 0.02784542f, -0.12308476f, 0.10888375f, 
    -0.17199448f, 0.79280531f, -0.06256447f, 0.32753855f, -0.21391137f, 0.09754997f, -0.14183357f, 0.04672510f, 
    0.13053767f, -0.45990294f, -0.06177321f, -0.11185875f, 0.10434372f, 0.01208454f, 0.09517207f, 0.25000641f, 
    0.31265646f, 0.07797462f, -0.13855484f, 0.21326469f, 0.11485080f, 0.05968137f, 0.15283351f, 0.08616230f, 
    0.24836205f, -0.13237378f, 0.14587757f, 0.10820881f, 0.13328169f, -0.25556764f, -0.00247035f, -0.36898065f, 
    -0.18765695f, 0.25759906f, -0.14707823f, -0.09571835f, -0.25877810f, 0.26548439f, -0.16365160f, 0.12604800f, 
    0.19388363f, -0.01877065f, -0.27070859f, -0.13157247f, -0.11507712f, 0.06819486f, -0.31814688f, -0.39804390f, 
    -0.06582029f, 0.01728652f, -0.36915225f, 0.39678130f, -0.15684503f, 0.39066243f, -0.02674512f, -0.14049245f, 
    -0.03990182f, -0.15072665f, 0.19734538f, -0.11780310f, 0.30706856f, -0.15889780f, 0.24223310f, 0.13410756f, 
    0.12347206f, 0.28040078f, 0.04610568f, -0.32173982f, 0.36483654f, 0.26945883f, -0.17911828f, 0.17944430f, 
    0.15261528f, 0.04468838f, 0.14323400f, -0.29728174f, -0.42981213f, -0.01977326f, -0.21423909f, -0.23298523f, 
    0.03958832f, 0.18904673f, -0.11660748f, 0.09561664f, -0.04434179f, 0.12640297f, 0.15951565f, -0.04693861f, 
    0.01386341f, -0.17264421f, -0.34261551f, 0.48901424f, -0.15623192f, -0.54669887f, 0.15797426f, 0.24331869f, 
    -0.09967062f, -0.18735833f, -0.00309209f, -0.09867305f, 0.03547953f, 0.10883713f, -0.22667390f, -0.45257211f, 
    0.02390677f, 0.29468048f, 0.28245452f, 0.36531886f, -0.12958777f, -0.12234493f, 0.12773602f, 0.05432713f, 
    0.14415464f, -0.11626966f, 0.13413057f, -0.32704914f, 0.23032287f, 0.68850046f, 0.04917612f, 0.16365318f, 
    0.18569590f, 0.16661307f, -0.16767833f, 0.15063097f, -0.16196176f, -0.38020229f, 0.20592734f, -0.21100594f, 
    0.20839693f, 0.13912755f, 0.16975349f, -0.13139680f, 0.26768720f, -0.58354706f, -0.15438382f, -0.04334011f, 
    0.43425557f, -0.06242480f, -0.04246508f, -0.01527525f, 0.45208985f, -0.15308855f, 0.34490958f, 0.56976187f, 
    0.03466980f, -0.11206058f, -0.03969146f, 0.04568029f, 0.31913343f, 0.15572523f, 0.15397175f, 0.06516875f, 
    0.42403656f, -0.38608071f, 0.00961172f, 0.13191190f, -0.09984002f, -0.06150069f, -0.25119957f, 0.00929444f, 
    0.05142679f, -0.22422990f, 0.08295379f, -0.33393142f, -0.05350634f, 0.10444374f, 0.24840181f, -0.08813462f, 
    -0.19992135f, -0.08041331f, -0.26639459f, 0.33959818f, 0.18545814f, -0.15999457f, 0.21531284f, -0.08624937f, 
    0.03948280f, 0.22874849f, 0.15084440f, 0.23616841f, -0.09512737f, 0.35661209f, 0.05733083f, -0.11677901f, 
    -0.08528467f, 0.03804806f, -0.00300902f, 0.22090231f, 0.17198597f, -0.10810622f, 0.31425488f, 0.09115392f, 
    -0.01220235f, 0.46555075f, 0.14872470f, 0.19583945f, -0.11411372f, -0.02229544f, -0.26531696f, 0.39057183f, 
    -0.01027013f, -0.34447396f, 0.09272056f, 0.21268854f, -0.30620444f, -0.11070965f, -0.02059650f, -0.51292074f, 
    0.21385098f, 0.21979928f, -0.05228759f, 0.23542315f, -0.15781036f, 0.13972138f, -0.15558966f, 0.09027832f, 
    0.04283003f, 0.01796218f, 0.05959188f, -0.15719168f, 0.03933649f, -0.10094113f, 0.27242178f, 0.00807289f, 
    -0.00276192f, 0.06451778f, 0.12530625f, 0.04381751f, 0.11200637f, -0.05879169f, 0.07278101f, -0.01385169f, 
    -0.13262476f, -0.07632558f, -0.11323630f, -0.04296506f, -0.02156399f, 0.10540485f, -0.09658561f, -0.01314852f, 
    -0.15282059f, -0.18023373f, 0.01061304f, -0.05201484f, 0.14693359f, 0.07348632f, -0.06957847f, -0.07963699f, 
    -0.18369265f, 0.05436506f, -0.02775236f, 0.05250948f, -0.05330328f, -0.05145543f, -0.16889693f, 0.11367795f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.06908823f, 0.04671295f, -0.01215031f, 0.00485704f, -0.26339597f, 0.15123735f, 0.19068521f, 0.03748785f, 
    -0.23178628f, -0.06523447f, 0.09907665f, -0.13499330f, -0.25490093f, 0.12950552f, 0.10937889f, 0.16639596f, 
    0.10092695f, -0.01521348f, -0.16233528f, 0.09453423f, -0.04169386f, -0.04654527f, -0.18662097f, 0.28334516f, 
    0.06700146f, 0.16561496f, -0.06020562f, 0.18762043f, 0.21960361f, 0.23068634f, 0.14227562f, -0.03530145f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.06279545f, 0.14236368f, -0.08306042f, -0.06990787f, -0.26557317f, -0.20198756f, -0.38589281f, 0.17981258f, 
    0.35157233f, 0.27317581f, -0.01287908f, -0.12173868f, 0.25605634f, -0.92656720f, -0.22790711f, -0.33767810f, 
    0.03484695f, 0.00577521f, 0.32234469f, -0.13187040f, 0.01150171f, 0.31770131f, -0.19805548f, -0.38960856f, 
    -0.35002404f, -0.35490170f, -0.26393834f, 0.17304845f, -0.69931382f, -0.11501433f, 0.07753375f, 0.11684177f, 
    -0.17000966f, -0.01778317f, 0.03830545f, 0.15485880f, -0.57443625f, 0.23875934f, 0.06225207f, -0.83082289f, 
    -0.91280752f, 0.01293931f, 0.26129326f, -0.53755450f, 0.48974285f, -0.84126681f, 0.14032009f, 0.44979629f, 
    0.34354314f, -0.14267951f, 0.07722640f, 0.05015924f, -0.29177386f, 0.20326559f, -0.10704162f, 0.07547633f, 
    -0.17143616f, 0.25770316f, 0.23514347f, 0.01815956f, -0.12726824f, 0.02725714f, 0.05507419f, -0.05145964f, 
    -0.21361886f, -0.12616870f, -0.17304687f, -0.06625271f, 0.16739887f, -0.23771451f, -0.01201615f, 0.15628025f, 
    -0.72163117f, 0.39005530f, -0.19429196f, 0.42536393f, -0.04658451f, 0.00119673f, 0.14985567f, -0.61689943f, 
    0.29568389f, -0.28238475f, 0.08711389f, 0.22402515f, 0.12158707f, -1.13297856f, -0.50263685f, -0.13999489f, 
    0.30164078f, -0.33217302f, -0.60712242f, 0.03315797f, 0.47389236f, 0.03504792f, -0.39014819f, -0.03554609f, 
    -0.00374261f, -0.04178205f, -0.10299494f, 0.28853592f, 0.33877012f, -0.63006341f, -0.52433801f, -0.04209765f, 
    -0.06746437f, 0.11661735f, 0.26607421f, 0.18556195f, -0.13311386f, 0.34063599f, -0.47584042f, 0.04435773f, 
    -0.01107426f, 0.31497118f, -0.28573895f, -0.00915632f, 0.26214188f, -0.16079138f, -0.00849540f, -0.28960800f, 
    0.25107500f, 0.00990151f, 0.18944426f, -0.04945668f, -0.20516479f, -0.23402233f, -0.13222304f, 0.04861860f, 
    0.08008205f, 0.20567955f, 0.29804334f, -0.05162024f, 0.10370892f, 0.03854619f, -0.16984220f, 0.32935107f, 
    0.17589560f, 0.21905266f, -0.13287388f, -0.15476011f, -0.12272232f, 0.14629033f, -0.31481713f, 0.18472452f, 
    -0.37579039f, -0.43757722f, 0.05977326f, -0.13280232f, -0.02309542f, 0.18691386f, -0.55138040f, 0.10105479f, 
    0.03286776f, 0.28475073f, -0.31483167f, 0.03765874f, 0.10039423f, -0.12144486f, -0.63980067f, 0.02022222f, 
    0.12615645f, 0.31549925f, 0.17051388f, -0.17029433f, -0.81861734f, -0.19728343f, 0.05381879f, -0.02149000f, 
    -0.19093542f, -0.22459862f, -0.40353057f, -0.56812286f, -0.40709051f, -0.20983800f, -0.01214973f, -0.59427190f, 
    0.06274765f, 0.27724519f, -0.17338428f, 0.06749433f, -0.17606595f, 0.02880638f, -0.40611833f, 0.00025682f, 
    0.11485621f, -0.16591583f, -0.11035443f, 0.34572890f, 0.01545112f, 0.16903791f, 0.09658168f, -0.04397637f, 
    -0.37361491f, 0.09480583f, -0.27587780f, -0.55813283f, -0.12412850f, 0.12677075f, 0.26405448f, -0.09282925f, 
    -0.78252643f, -0.57380307f, -0.74677163f, 0.03856727f, -0.45479560f, 0.24968316f, 0.11486223f, 0.04342878f, 
    -0.22219066f, -0.63846022f, -0.10743206f, 0.01702671f, -0.03966006f, -0.88331908f, 0.60500896f, 0.30766654f, 
    -0.17650712f, -0.28592324f, 0.17777839f, 0.02734911f, 0.32615006f, -0.37839538f, -0.36710450f, 0.08401934f, 
    0.02001732f, -0.17918274f, -0.45626312f, -0.71294820f, 0.31858781f, -0.02452261f, -0.14022553f, -0.13129842f, 
    0.00411129f, -0.41854274f, -0.13031763f, 0.45690984f, -0.14206158f, 0.05366513f, -0.03212171f, -0.03769482f, 
    -0.44641671f, 0.23608913f, 0.00985499f, -0.08577265f, 0.14122376f, -0.67753828f, 0.06770455f, -0.33163893f, 
    0.21111116f, 0.45351872f, 0.46204007f, -0.19196267f, -0.33374432f, 0.15156482f, 0.34670269f, 0.01292758f, 
    0.22904257f, -0.54777700f, -0.24557753f, -0.52853960f, -0.20604533f, 0.36473995f, -0.06030394f, 0.01519597f, 
    -1.05858481f, -0.59644353f, 0.36568052f, -0.17415701f, -0.59191930f, -0.07428343f, -0.15398003f, 0.03148032f, 
    0.15206257f, 0.47992647f, -0.27627996f, 0.24275966f, 0.12146544f, -0.73784703f, -0.65783489f, -0.56511092f, 
    0.19033405f, 0.05521702f, -0.43397614f, -0.54302686f, -0.31709009f, -0.00313764f, 0.31684610f, -0.11472623f, 
    -0.72710800f, 0.37802875f, 0.01089115f, -0.07621096f, 0.13761906f, -0.33725247f, 0.07687084f, 0.36601332f, 
    0.32843262f, -0.07892956f, -0.62603253f, 0.11234698f, -0.39251125f, -0.02872588f, 0.23881024f, -0.03612034f, 
    0.00435482f, -0.48947340f, -0.24375401f, -0.03719359f, -0.07979003f, -0.39803129f, -0.24339324f, 0.43547133f, 
    -0.49771369f, -0.19461210f, 0.24013670f, -0.13475347f, -0.18041003f, 0.02606211f, -0.42848185f, -0.03583940f, 
    0.19580446f, -0.10434052f, -0.07286832f, 0.07069091f, -0.65545171f, -0.02469159f, 0.49258259f, -0.62662911f, 
    -0.30828843f, -0.00393145f, 0.32346770f, -0.44879198f, -0.17587872f, 0.15566745f, -0.41344872f, 0.09199065f, 
    0.20321421f, -0.35732424f, -0.56778818f, -0.31144997f, 0.17241760f, 0.04893721f, 0.39914128f, -0.05067419f, 
    0.28555205f, -0.52342910f, 0.22057171f, -0.72727013f, 0.12529016f, -0.54469979f, 0.34530309f, 0.08521408f, 
    -0.42047191f, -0.40500179f, 0.40111578f, -0.29581049f, 0.39542264f, 0.38226730f, -0.18590835f, -0.39194626f, 
    -0.02591136f, -0.32434070f, 0.43228787f, -0.19853680f, -0.45777932f, 0.06833085f, 0.13086076f, -0.06070599f, 
    0.28344530f, -0.31975025f, -0.45096835f, 0.16982277f, -0.31514499f, -0.32973865f, 0.38466898f, -0.52475715f, 
    -0.21357632f, -0.10877008f, -0.34911439f, -0.53887731f, 0.05102877f, 0.22417116f, -0.49959281f, 0.00966209f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.18161513f, 0.17179289f, 0.21486087f, -0.03940558f, 0.02308797f, 0.11078368f, 0.04350245f, -0.13353741f, 
    -0.00160683f, 0.17012256f, -0.10755523f, -0.21064675f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
