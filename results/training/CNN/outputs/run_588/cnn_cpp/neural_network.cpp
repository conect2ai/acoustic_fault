#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.31046349f, 0.49144998f, 0.75799811f, 0.12294990f, -0.45831868f, -0.26460177f, 0.08934301f, -0.18669991f, 
    -0.07594325f, 0.48993263f, 0.67566657f, 0.46457592f, -0.09020905f, 0.57019258f, 0.10376758f, 0.56613421f, 
    -0.13107990f, -0.49141288f, 0.56816173f, 0.62148952f, 0.13219771f, -0.36026496f, 0.05802464f, 0.04775387f, 
    -0.46383908f, -0.04583059f, -0.06833415f, 0.29088843f, 0.18094403f, -0.80464566f, -0.64267141f, 0.72191316f, 
    -0.31287259f, 0.14972588f, -0.08389205f, 0.21958666f, 0.54379213f, -0.80196494f, 0.05268966f, -0.32470059f, 
    0.00159385f, 0.56276101f, -0.10422550f, -0.02821866f, 0.34605211f, 0.34931731f, 0.45329484f, 0.44127837f, 
    -0.32515648f, -0.84528875f, 0.52686661f, 0.11138674f, 0.27189857f, 0.10173180f, 0.22418419f, 0.39765424f, 
    0.43015495f, -0.39975226f, -0.53729099f, -0.31066474f, -0.44048330f, 0.31188855f, 0.35518107f, -0.54672819f, 
    0.69472605f, -0.17077124f, -0.66036797f, -0.02202229f, -0.32900491f, 0.40298951f, -0.20845756f, -0.22698532f, 
    0.60513574f, 0.65977532f, 0.07018087f, -0.37560570f, -0.25901058f, -0.51491803f, 0.38753760f, 0.45810723f, 
    0.15652007f, 0.61365908f, -0.33365652f, -0.70576578f, -0.46682900f, -0.63816589f, -0.26717421f, -0.50240308f, 
    -0.11146270f, 0.24894759f, -0.50217181f, -0.76018119f, -0.06421605f, -0.75396472f, -0.54418492f, 0.45798326f, 
    0.12258800f, 0.46999243f, 0.25381190f, -0.25062013f, -0.42665115f, -0.63369739f, -0.56961787f, 0.36972189f, 
    0.69969410f, 0.09158471f, 0.01640799f, -0.04445609f, 0.61849391f, -0.05683595f, 0.59545946f, 0.08418783f, 
    0.34858313f, -0.17909835f, -0.16136396f, -0.22729294f, 0.11087149f, 0.62105244f, -0.65672946f, -0.59546548f, 
    0.54230297f, 0.15558326f, -0.63059878f, -0.30988050f, 0.31577355f, 0.17958176f, -0.50555867f, -0.55556595f, 
    -0.34065703f, 0.53478211f, 0.64949495f, 0.38561866f, -0.09019174f, -0.14315714f, -0.08176504f, 0.42828777f, 
    0.33652911f, 0.22592464f, -0.76118195f, 0.40116745f, -0.62252599f, -0.29993531f, -0.05189315f, 0.24522749f, 
    0.64430177f, -0.11673931f, 0.52631485f, 0.41168556f, -0.00970318f, 0.06858732f, -0.04435065f, 0.46042681f, 
    0.13245985f, 0.67923266f, -0.68689555f, 0.12677565f, -0.59606373f, -0.10521873f, -0.56578678f, -0.28470513f, 
    0.00251132f, -0.40019676f, -0.01685851f, 0.05876730f, -0.17979479f, -0.74986827f, -0.14349036f, -0.71306020f, 
    0.18643294f, 0.45116374f, -0.20989862f, 0.54066014f, -0.70648402f, 0.49446681f, 0.73382580f, 0.11115094f, 
    0.19446857f, -0.09708037f, -0.48775926f, -0.12699737f, 0.38979730f, 0.19021769f, -0.00726984f, 0.36761409f, 
    -0.90253985f, -0.00202132f, -0.53687644f, 0.05363363f, -0.46589658f, -0.33995417f, -0.50627762f, -0.50839186f, 
    0.62144661f, -0.38183641f, 0.50408006f, -0.00588749f, -0.15002599f, -0.18859574f, -0.68730623f, -0.71250123f, 
    -0.70700210f, 0.18904760f, -0.52078193f, -0.20490094f, -0.17289841f, -0.06958317f, -0.20844184f, 0.38087118f, 
    0.44577739f, 0.59451187f, 0.45684782f, 0.06043559f, 0.16449101f, 0.02205750f, 0.15663141f, 0.08721815f, 
    -0.63799918f, 0.79134130f, -0.60555279f, 0.08791533f, -0.12554444f, -0.68992037f, -0.31758741f, 0.30025318f, 
    0.12681910f, 0.12465229f, -0.24406517f, 0.76284838f, -0.68352109f, -0.12805498f, 0.29350573f, -0.11608036f, 
    -0.04463363f, 0.04290241f, 0.51622117f, 0.85720122f, -0.32410601f, 0.16142589f, -0.64753962f, 0.05672520f, 
    0.37869453f, -0.19413461f, 0.21016480f, -0.87468332f, 0.12521473f, -0.03362280f, 0.09603734f, 0.77345300f, 
    0.41005701f, 0.04177290f, -0.55304617f, 0.45994592f, -0.72683525f, -0.05987407f, -0.49688187f, 0.05968701f, 
    0.64500403f, 0.13979815f, -0.04101057f, -0.08312462f, -0.33424094f, -0.59349138f, 0.25292596f, 0.26151893f, 
    0.59134454f, 0.80743963f, 0.22806861f, 0.25725883f, 0.16357316f, -0.05989426f, -0.67459369f, -0.25980291f, 
    0.63648146f, -0.27944887f, -0.41066217f, -0.37129354f, 0.18733262f, 0.15299891f, -0.27219895f, -0.87536544f, 
    -0.51205498f, 0.34785840f, 0.50316322f, -0.27027166f, 0.35500821f, 0.22605234f, -0.00510455f, 0.16523054f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.06951529f, -0.12619299f, 0.12797551f, 0.01455600f, -0.15182891f, -0.28466043f, 0.06711663f, 0.16584370f, 
    -0.19166131f, -0.22141527f, 0.14962597f, -0.06821603f, 0.02663277f, -0.05557804f, 0.23570588f, -0.01363717f, 
    0.12651917f, -0.44265029f, 0.16660076f, 0.11528013f, -0.12047113f, -0.07874240f, 0.16202444f, 0.14082897f, 
    0.13070410f, -0.10142397f, 0.08672477f, -0.21711399f, 0.01616788f, -0.07555044f, -0.08232429f, 0.05065813f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.01679540f, -0.02552984f, 0.05489789f, -0.00432783f, 0.02951008f, -0.03030311f, -0.04911437f, 0.05023199f, 
    -0.05127643f, -0.05821192f, -0.02555758f, -0.03452361f, -0.02748762f, 0.05493184f, 0.03448956f, -0.00190366f, 
    -0.04632025f, -0.01835628f, -0.04830452f, 0.01759521f, 0.01723394f, -0.02468321f, -0.06030305f, -0.06575725f, 
    0.00378690f, 0.01819281f, -0.06091014f, -0.05877846f, -0.05785231f, 0.03206721f, -0.00314915f, 0.01865871f, 
    -0.04479081f, -0.00107670f, 0.02301805f, 0.02974843f, -0.03653043f, -0.06153419f, -0.04532992f, -0.01204155f, 
    -0.03938357f, -0.05003147f, -0.01080827f, -0.01272191f, -0.02559171f, -0.03773323f, -0.04263784f, 0.04106202f, 
    -0.03699042f, -0.03570736f, -0.00032608f, 0.02973195f, -0.05051479f, -0.05841957f, -0.06023903f, 0.02170388f, 
    -0.05332145f, -0.03633500f, 0.00441354f, 0.02921814f, -0.00896798f, 0.02381337f, -0.02324358f, -0.02985220f, 
    -0.00350749f, -0.00522439f, -0.03605624f, -0.03531220f, -0.02807201f, 0.04397004f, 0.01754989f, -0.02081750f, 
    0.00075728f, 0.00324393f, -0.03740132f, -0.03273554f, -0.05189519f, -0.07173225f, -0.00576649f, -0.05602292f, 
    -0.04658835f, -0.00262645f, 0.01724249f, -0.05917082f, 0.02286921f, -0.02067056f, -0.03017620f, 0.00089318f, 
    0.00532656f, -0.02097242f, -0.03081747f, -0.03552791f, 0.03753984f, 0.04830297f, 0.03631850f, 0.00111223f, 
    0.02059754f, 0.00414882f, -0.00023421f, 0.03457013f, 0.01287458f, -0.03441943f, -0.01721976f, -0.01574096f, 
    0.04083277f, -0.01240394f, -0.05214639f, -0.03905632f, 0.01209849f, 0.01699832f, -0.02209547f, -0.01202832f, 
    -0.03022374f, 0.00752720f, 0.01972306f, 0.04244139f, 0.04040157f, -0.02416324f, 0.02992115f, 0.02109443f, 
    -0.01909112f, 0.00597231f, -0.05431826f, 0.04090931f, 0.00541956f, -0.01458245f, 0.00034410f, -0.05533583f, 
    0.02714968f, 0.02668748f, -0.02605601f, 0.02400623f, -0.00981421f, 0.03575571f, 0.01531002f, -0.03290664f, 
    0.04679835f, 0.00229039f, 0.02667962f, -0.01209243f, 0.03346748f, 0.01920016f, -0.06700780f, -0.00922402f, 
    -0.00912907f, -0.00423989f, 0.02781725f, -0.01815271f, -0.01158243f, 0.01925685f, -0.02727167f, 0.02458034f, 
    0.00841295f, -0.04698476f, -0.01582530f, -0.01514135f, 0.00011381f, 0.01004993f, 0.00034202f, 0.02773239f, 
    -0.04997665f, -0.02626651f, -0.02992988f, 0.03677084f, 0.02497348f, 0.01468044f, -0.06316496f, -0.04285027f, 
    -0.04795104f, -0.04221799f, 0.01058152f, 0.05471931f, -0.00228711f, -0.06096170f, -0.01346229f, 0.01164191f, 
    0.00723415f, -0.01973694f, -0.00336949f, 0.02363465f, -0.02907508f, 0.01836393f, -0.04406144f, -0.02480327f, 
    -0.02427992f, -0.00393889f, -0.05701853f, 0.03215431f, -0.03432707f, 0.01909858f, 0.00839380f, 0.00034345f, 
    -0.02236480f, -0.05586425f, -0.02039653f, 0.04641161f, -0.05167329f, -0.03101219f, -0.01412856f, -0.02902876f, 
    -0.00516273f, -0.00731256f, -0.04662775f, -0.03556425f, 0.02999807f, 0.00028988f, -0.05036550f, 0.04209316f, 
    0.01217449f, -0.02611610f, -0.04411428f, -0.03522151f, -0.01541846f, 0.05619508f, 0.03195814f, -0.01867576f, 
    0.02409636f, 0.04719986f, -0.06092544f, -0.01497576f, 0.00360437f, -0.01186133f, 0.01630002f, -0.00205311f, 
    -0.00610175f, -0.03944721f, 0.04519754f, -0.04351640f, -0.02864864f, -0.05512176f, -0.00854572f, -0.05071168f, 
    -0.05360645f, 0.02932942f, 0.04222596f, 0.04629597f, 0.03387200f, 0.04693194f, 0.01164324f, 0.00914209f, 
    0.04710219f, -0.04770252f, 0.00201893f, -0.02840403f, 0.03920220f, -0.00949537f, -0.03409880f, 0.05366598f, 
    -0.04987446f, 0.03696122f, 0.00743118f, 0.01335571f, 0.01794886f, -0.00701164f, -0.02910056f, -0.00934702f, 
    -0.04483272f, 0.03793902f, 0.03248028f, -0.01530544f, 0.01586135f, -0.03475291f, -0.05595152f, -0.04226555f, 
    -0.05281711f, -0.03311241f, -0.00109957f, -0.04276499f, 0.03580585f, -0.05319870f, 0.01253034f, -0.00897763f, 
    0.00872844f, 0.00872821f, -0.06205088f, -0.04572870f, 0.02485121f, -0.00596878f, 0.05175694f, -0.05225218f, 
    0.02155134f, -0.05371301f, -0.00178403f, 0.01369754f, 0.01013085f, 0.02642130f, -0.01499425f, -0.00870665f, 
    -0.05254225f, -0.42246073f, -0.01463913f, 0.12190342f, 0.02830458f, 0.16285218f, 0.06267119f, 0.03131329f, 
    0.07482318f, -0.28701824f, -0.12876423f, -0.18248551f, 0.14151864f, 0.17458117f, 0.07066481f, 0.15395436f, 
    -0.11951295f, -0.02045311f, -0.13381761f, -0.24469118f, -0.09472268f, 0.00199718f, 0.09842395f, -0.10182896f, 
    -0.01073656f, -0.00950693f, 0.23332269f, -0.11137098f, -0.02026698f, -0.27587467f, 0.06026165f, -0.17027414f, 
    -0.03786560f, -0.12102876f, 0.13677241f, -0.15324192f, -0.02932300f, -0.11890788f, -0.20258236f, 0.12983221f, 
    0.00468117f, 0.07501572f, 0.11521579f, 0.07742335f, 0.12194481f, -0.25421536f, -0.43952000f, -0.16791439f, 
    -0.15983663f, 0.03404717f, -0.05184716f, -0.03668390f, 0.08323718f, 0.03663964f, -0.05203731f, -0.14862311f, 
    0.11548627f, 0.07229590f, -0.07949284f, -0.02337776f, 0.12135189f, 0.02182371f, 0.15174402f, 0.05508429f, 
    0.09504402f, -0.08609270f, 0.19283234f, 0.06471039f, 0.16242337f, -0.00256989f, -0.07100081f, -0.09539052f, 
    -0.09278566f, -0.39967260f, -0.10334828f, -0.03490374f, 0.00634917f, 0.05207653f, 0.00642767f, 0.07601923f, 
    0.14449657f, 0.23922530f, 0.20963553f, -0.19345975f, 0.06136185f, -0.07277048f, -0.01054073f, 0.03817564f, 
    -0.00059200f, 0.00450797f, -0.15529472f, 0.21414450f, -0.08115539f, -0.03673723f, -0.17850152f, -0.05928370f, 
    -0.03254761f, 0.12238322f, 0.06241758f, -0.08207164f, -0.01933080f, -0.12448521f, 0.05134525f, -0.12708855f, 
    -0.20937765f, 0.16537912f, 0.07000682f, 0.08457292f, -0.42901036f, -0.22667862f, 0.02482228f, -0.05898008f, 
    0.12005448f, 0.09271033f, 0.08873941f, 0.02848944f, 0.12527597f, 0.25921437f, 0.04483159f, -0.44151616f, 
    -0.03678048f, -0.06426233f, 0.02010890f, 0.04229629f, 0.10687962f, 0.18885888f, 0.19625883f, 0.30052921f, 
    -0.05711812f, 0.03935610f, -0.05843246f, -0.08774313f, -0.00095233f, 0.11517981f, 0.19370806f, -0.35716829f, 
    0.00357636f, 0.11395397f, 0.03820201f, -0.05002102f, 0.04508859f, -0.00227099f, -0.08948339f, 0.01597101f, 
    -0.38911423f, -0.45884579f, -0.16031666f, 0.08690044f, 0.06158072f, 0.04872006f, 0.09328703f, 0.03663098f, 
    0.08561341f, 0.12522304f, 0.45195505f, 0.28579229f, 0.05396011f, 0.09381443f, -0.05266615f, 0.13190591f, 
    0.02123564f, -0.04034583f, 0.05022205f, 0.21185546f, 0.08043395f, -0.05333924f, 0.07759615f, 0.00064157f, 
    0.02855055f, -0.07214444f, -0.00673809f, -0.23069562f, 0.07436044f, -0.24956018f, 0.00571806f, 0.08675678f, 
    -0.04423531f, 0.10718218f, 0.02662935f, 0.13417059f, -0.01695427f, -0.23111276f, 0.21023706f, -0.03785302f, 
    0.00228684f, 0.16783458f, -0.10318872f, -0.06699034f, 0.00720672f, 0.27097008f, 0.13486725f, -0.07565352f, 
    0.19419068f, 0.11132593f, -0.00699461f, -0.11693976f, 0.07027306f, 0.07082400f, 0.05625507f, -0.08747722f, 
    -0.24177431f, 0.13899913f, 0.02941025f, 0.00300197f, 0.10946297f, 0.08192755f, 0.05607155f, -0.50138021f, 
    -0.03917418f, -0.12912628f, 0.00134858f, 0.03321522f, 0.07902121f, 0.05329572f, 0.00687071f, 0.09825364f, 
    0.27914524f, -0.17315148f, 0.19905640f, -0.03582243f, 0.03532854f, 0.10902784f, -0.03581513f, 0.05545947f, 
    0.01313375f, 0.24785092f, 0.13741317f, 0.06249775f, -0.07665145f, 0.01923282f, 0.07097279f, -0.15710948f, 
    0.27820510f, 0.05218636f, 0.20050921f, -0.25850254f, -0.10526312f, 0.06204107f, 0.04607353f, 0.04355797f, 
    -0.10746128f, 0.10152452f, 0.03471090f, 0.10391581f, 0.11102952f, -0.08300281f, 0.02752092f, -0.00242876f, 
    -0.20547746f, 0.05558062f, 0.07413495f, 0.05195170f, -0.06117435f, 0.15221992f, 0.01794440f, 0.21793903f, 
    0.01462405f, -0.01096986f, 0.01867135f, 0.03882596f, 0.15676461f, -0.19171146f, 0.16709781f, -0.06966619f, 
    0.10229409f, -0.01733613f, 0.09307045f, -0.02181558f, 0.07126169f, 0.07731145f, -0.02928540f, 0.24695361f, 
    0.06469821f, -0.13834627f, -0.03054681f, 0.01485581f, -0.09945026f, 0.07458731f, -0.03348913f, -0.05059572f, 
    0.10103773f, -0.07480247f, -0.08573280f, 0.10652169f, 0.15666951f, -0.07462199f, 0.06515931f, 0.00071608f, 
    0.01264519f, 0.03547711f, -0.05506117f, -0.02823829f, -0.06602386f, -0.04711209f, -0.02093513f, -0.02694422f, 
    0.01775417f, -0.01709650f, -0.01803491f, 0.01643896f, -0.04622297f, -0.01924633f, 0.04080141f, 0.00495134f, 
    0.01796550f, 0.02177252f, -0.03312352f, 0.00049644f, -0.00626623f, -0.04313967f, -0.01472158f, -0.00096319f, 
    -0.00558177f, 0.04518975f, 0.01595757f, -0.02018134f, -0.01628613f, -0.00203486f, -0.03513752f, 0.03217124f, 
    0.01060540f, 0.03261872f, 0.02914006f, -0.02125817f, 0.05241029f, -0.01253261f, 0.03307306f, -0.02316312f, 
    0.02737235f, -0.00728173f, -0.00331799f, -0.01248019f, 0.01035774f, 0.05491019f, 0.00217423f, -0.03960506f, 
    -0.02272198f, 0.04955902f, -0.03584513f, 0.02598856f, -0.05286385f, -0.01997216f, 0.04373403f, -0.05087816f, 
    -0.00632926f, -0.01911919f, 0.03671546f, 0.00691593f, 0.04350161f, -0.04536957f, -0.05646463f, -0.00595375f, 
    0.04717878f, -0.03492530f, -0.02947846f, -0.00843879f, -0.04781662f, 0.01867285f, -0.02708269f, 0.00733541f, 
    0.00357865f, -0.04850693f, 0.01664620f, 0.02711674f, -0.00256736f, -0.05026608f, -0.01489043f, 0.00652182f, 
    -0.03734388f, -0.06043728f, -0.03922936f, 0.02125436f, 0.01773453f, -0.02692620f, -0.00356359f, -0.01299372f, 
    0.03082044f, -0.01212010f, 0.02889682f, -0.05536868f, -0.01541705f, 0.04335279f, 0.03090048f, -0.02787993f, 
    -0.06327342f, 0.02089032f, -0.04734954f, -0.00918646f, 0.03598727f, 0.04942452f, -0.05251560f, 0.02934547f, 
    -0.06473941f, 0.00309146f, 0.02384495f, -0.02949120f, -0.01790650f, -0.00302112f, -0.04004446f, -0.01811844f, 
    -0.03010427f, 0.02171255f, -0.02434776f, 0.02932501f, -0.05838804f, 0.02126632f, -0.01814820f, 0.01688736f, 
    0.04034385f, -0.00538588f, 0.02551649f, 0.03482668f, -0.00154784f, 0.01331236f, -0.01332435f, 0.01772695f, 
    -0.03079566f, -0.04453531f, -0.00314530f, 0.02600978f, -0.00163015f, -0.00159189f, 0.03290707f, -0.02094121f, 
    -0.01467134f, -0.03926443f, -0.06172626f, 0.02964274f, 0.00856739f, -0.02778764f, -0.04378191f, 0.03892114f, 
    -0.05062935f, 0.01903347f, -0.06346866f, 0.00057715f, 0.00234394f, -0.00277987f, 0.02096362f, 0.01804954f, 
    -0.03115953f, -0.04477056f, -0.01506200f, -0.04648272f, -0.03480553f, -0.03388790f, 0.02869840f, -0.05874805f, 
    0.01832502f, -0.01067242f, -0.04253055f, 0.01436548f, -0.03881206f, 0.00792069f, 0.01286025f, 0.03671953f, 
    0.01037060f, -0.05361208f, -0.00153405f, -0.04633595f, 0.01909686f, -0.05359587f, 0.03859706f, 0.00816103f, 
    -0.03589237f, -0.06503594f, 0.03536515f, -0.02211117f, -0.00410460f, 0.01881683f, -0.04218087f, 0.01240945f, 
    -0.02358279f, 0.02576925f, 0.03469900f, -0.02399849f, -0.01401719f, -0.06322861f, -0.04123105f, 0.04209608f, 
    -0.06030642f, -0.05864648f, 0.04976977f, -0.00588686f, 0.05085975f, -0.00030279f, 0.04214156f, 0.03949441f, 
    0.02591577f, -0.06051772f, -0.05714311f, 0.01919065f, -0.03840259f, -0.02369195f, 0.00815302f, 0.05401361f, 
    -0.01945820f, -0.03918887f, -0.06031734f, 0.03924801f, 0.03256065f, 0.00655095f, -0.05076998f, 0.01349683f, 
    -0.02516988f, -0.04582161f, -0.03744826f, -0.01475865f, -0.03234383f, 0.00264899f, -0.04929251f, 0.01924327f, 
    -0.01256569f, -0.05061268f, 0.00926907f, -0.04298443f, 0.01735694f, 0.04020534f, 0.04707470f, 0.00601643f, 
    -0.02343987f, -0.02767714f, -0.02734991f, 0.00515915f, 0.05334796f, 0.02999299f, 0.00869873f, -0.04930785f, 
    0.05096200f, -0.02941009f, -0.01776093f, 0.01233554f, -0.01900663f, -0.03979671f, 0.04966010f, -0.04585333f, 
    -0.06619712f, -0.05163328f, -0.02748745f, 0.05185386f, -0.02279759f, -0.00074264f, 0.02307544f, 0.02882638f, 
    0.04074404f, 0.00790888f, -0.01972373f, -0.06064989f, 0.00291047f, -0.02942304f, 0.03121263f, -0.01643035f, 
    0.04048171f, 0.00507520f, 0.04131909f, 0.00051977f, -0.01070335f, -0.00487297f, 0.02462767f, 0.05165240f, 
    0.05784788f, -0.06263754f, -0.04541285f, -0.01895261f, 0.03183205f, 0.00314377f, -0.01957402f, -0.04613930f, 
    -0.00386035f, 0.02234756f, -0.00959019f, 0.05487727f, -0.00574683f, 0.00412782f, -0.05946478f, -0.00885566f, 
    0.04652083f, 0.00476923f, -0.03045001f, 0.00518032f, 0.00682934f, -0.02807475f, -0.01632491f, -0.03520732f, 
    -0.01424861f, 0.04552971f, 0.03983445f, 0.03440731f, 0.04888068f, 0.05090455f, -0.05320121f, 0.05754579f, 
    -0.01795645f, -0.05329775f, -0.00660324f, 0.02174644f, 0.00908173f, 0.02248790f, -0.00350913f, -0.06292725f, 
    -0.04993452f, -0.02019480f, 0.00494996f, 0.02337324f, -0.03104467f, -0.00207764f, 0.01046831f, 0.02797833f, 
    -0.03919063f, -0.03529702f, -0.04106964f, 0.00376783f, 0.03980818f, -0.05242921f, 0.01654426f, -0.06159598f, 
    -0.03336429f, -0.03519423f, -0.01960279f, -0.03708844f, 0.03464679f, 0.01488005f, -0.01184600f, 0.01771090f, 
    -0.01349323f, 0.01826405f, -0.05849851f, -0.01150288f, 0.05129854f, 0.03179882f, -0.05422016f, -0.04805601f, 
    0.04946307f, -0.05309653f, -0.05692278f, -0.01978484f, 0.03987627f, 0.02816267f, 0.02896944f, -0.00029460f, 
    0.04734492f, -0.04411408f, -0.06596763f, 0.03262624f, -0.03765532f, -0.05113729f, 0.01883666f, 0.02699241f, 
    0.04432705f, -0.02365471f, 0.03848502f, -0.01545917f, 0.04530776f, -0.05003623f, -0.05175456f, -0.00863585f, 
    -0.00278340f, 0.04316770f, 0.05596917f, 0.01530949f, 0.05143645f, -0.02140847f, 0.00898580f, 0.00734087f, 
    -0.05816867f, 0.01002755f, -0.02872324f, 0.01968555f, 0.02394210f, -0.05081675f, 0.01464228f, -0.06043763f, 
    -0.04668992f, 0.03833303f, 0.00015536f, -0.00834153f, 0.02930754f, 0.02344176f, -0.04846518f, -0.01519160f, 
    -0.01698624f, 0.00744904f, -0.00800220f, -0.04343732f, -0.01639047f, 0.00299594f, -0.04967524f, -0.00474479f, 
    0.04707992f, -0.03593538f, 0.03314725f, 0.02040933f, -0.01439910f, 0.02430879f, -0.02526503f, 0.01622071f, 
    0.04212159f, -0.05856536f, -0.05017276f, 0.01238227f, 0.04093001f, 0.01973472f, 0.01307231f, -0.00220513f, 
    -0.06158063f, 0.02365218f, -0.00082286f, -0.00028214f, -0.06319862f, -0.05927278f, 0.02147386f, -0.04107622f, 
    0.04683424f, -0.02925712f, -0.01563653f, -0.02372819f, 0.03191931f, -0.02952574f, 0.04334772f, -0.04035736f, 
    0.01878024f, 0.04611794f, -0.03151579f, -0.04975072f, 0.03272710f, -0.02255674f, -0.06143755f, -0.00315555f, 
    -0.01156782f, 0.05399917f, -0.04909655f, -0.01831615f, -0.00588451f, 0.00039801f, -0.05082100f, -0.02244430f, 
    0.04088095f, 0.04996742f, 0.00094803f, -0.04417387f, -0.05157514f, -0.00092278f, -0.02090772f, -0.03554417f, 
    0.04719163f, -0.02103641f, -0.00063416f, 0.02214954f, 0.00099673f, 0.00012699f, -0.01837979f, 0.01307011f, 
    0.01512813f, 0.05056884f, 0.02675553f, -0.04541353f, 0.04667220f, -0.04926342f, -0.05292732f, -0.02110500f, 
    -0.05564306f, -0.03223771f, -0.03438937f, 0.00826879f, -0.05212966f, 0.03970022f, 0.03771769f, -0.02971252f, 
    0.01862954f, -0.02966863f, -0.02001851f, -0.01259782f, 0.03395715f, 0.04008595f, -0.03242767f, 0.04998377f, 
    0.03323546f, -0.05549892f, -0.00110135f, 0.01584838f, -0.03899252f, -0.01260689f, 0.03496153f, -0.03497764f, 
    0.00254911f, -0.00187268f, 0.03768390f, -0.02208449f, -0.00626223f, 0.03069084f, 0.03989536f, 0.03141989f, 
    -0.01550414f, -0.02489222f, -0.00384343f, -0.00451816f, -0.04867357f, -0.06569015f, -0.00873661f, 0.03552537f, 
    -0.01763909f, -0.01579361f, -0.03484367f, -0.01685075f, -0.02298595f, -0.02390116f, 0.04537482f, 0.01204117f, 
    0.02245020f, 0.00615884f, -0.00903057f, 0.00640373f, 0.00711428f, -0.05593126f, -0.03727549f, 0.03048731f, 
    -0.04377514f, 0.00770385f, -0.05992641f, 0.03046085f, -0.06451624f, -0.05364420f, 0.01161710f, -0.04366021f, 
    -0.03880582f, -0.03357776f, 0.01055793f, -0.06022937f, 0.03782780f, -0.04845028f, -0.05886128f, -0.06482019f, 
    -0.01460583f, -0.05328675f, 0.00941663f, -0.01919047f, 0.01978587f, -0.05058149f, 0.00990874f, -0.02194732f, 
    -0.03366329f, 0.02403849f, 0.02845967f, 0.00205790f, -0.04767302f, -0.02456089f, -0.05014699f, -0.04791157f, 
    0.03571596f, -0.01254776f, 0.00332380f, 0.02479038f, -0.00051771f, -0.03373995f, -0.00573999f, -0.04388174f, 
    -0.00888437f, -0.06871936f, 0.02470896f, 0.04405986f, -0.02186799f, -0.00829362f, 0.02944141f, 0.04045173f, 
    -0.04554297f, -0.22628257f, -0.18729894f, -0.05217436f, 0.03066536f, 0.02941450f, 0.13565849f, -0.06371492f, 
    -0.02615101f, -0.18054685f, -0.21595827f, -0.01582138f, 0.07938919f, 0.16557547f, 0.15687554f, 0.00355643f, 
    -0.10955529f, -0.36234441f, -0.06013899f, 0.14351228f, -0.15931602f, 0.03234026f, 0.18687135f, 0.03403728f, 
    0.00038110f, -0.00772015f, -0.15270178f, -0.07149626f, 0.15460481f, 0.03839017f, -0.06927705f, -0.00393038f, 
    -0.32066071f, 0.02158488f, 0.09603657f, 0.10099094f, 0.02238410f, 0.01986266f, -0.04733061f, -0.15204649f, 
    0.00407481f, 0.06750885f, 0.01460809f, -0.00703409f, -0.11268392f, -0.15492526f, -0.30406183f, -0.17039317f, 
    0.09860817f, 0.09371461f, -0.02009061f, 0.02359878f, -0.12393577f, -0.22288045f, -0.15828584f, 0.02723076f, 
    0.01242561f, 0.08080877f, -0.05439981f, -0.08120817f, -0.04109794f, -0.02328826f, -0.10390218f, 0.05162498f, 
    0.19408935f, 0.08309348f, -0.13423434f, 0.12254505f, 0.02793019f, 0.07376943f, 0.03349597f, 0.06447615f, 
    -0.14553489f, -0.03643532f, 0.01228733f, 0.09090696f, 0.02541142f, -0.28208828f, 0.12569176f, 0.03489198f, 
    -0.18553573f, 0.21107256f, 0.35854816f, -0.08474924f, -0.14811961f, -0.14799349f, 0.03997160f, 0.20094185f, 
    0.20972101f, -0.04005937f, 0.06875403f, -0.01315160f, -0.17779256f, 0.12879215f, 0.05255638f, -0.17785366f, 
    0.07374384f, -0.03217399f, 0.15543860f, -0.22105014f, 0.14067438f, 0.23136450f, -0.07833939f, -0.11702309f, 
    -0.11874194f, -0.06117684f, 0.11338144f, 0.06332534f, 0.19116142f, 0.08066262f, -0.41624045f, 0.12618348f, 
    0.16924153f, 0.29389727f, 0.09293365f, 0.00515925f, 0.00966712f, -0.01495493f, -0.03225561f, 0.07747243f, 
    0.01854042f, 0.05583602f, -0.06951720f, -0.06333129f, -0.01083006f, 0.14702399f, -0.17626196f, -0.04199350f, 
    0.15733053f, 0.01015716f, -0.03433720f, 0.16683459f, -0.04962172f, 0.03296553f, 0.08493976f, -0.04521282f, 
    0.15061361f, 0.02804918f, -0.05469747f, 0.02068046f, 0.00924452f, 0.00070991f, -0.00121567f, 0.00815575f, 
    -0.13572201f, -0.09555451f, -0.20033281f, 0.04388742f, 0.09977335f, 0.16255523f, -0.02827364f, 0.01750123f, 
    -0.21112162f, 0.07718004f, 0.16457674f, -0.07715046f, -0.08833665f, 0.08656207f, -0.00195966f, -0.01419098f, 
    0.10246158f, 0.31486496f, 0.06426436f, 0.16402225f, -0.12451942f, -0.04613481f, 0.20762417f, -0.10576538f, 
    0.02131844f, 0.06380758f, 0.12533346f, -0.21813476f, -0.01165615f, -0.10765167f, -0.05560937f, 0.06950265f, 
    0.21851791f, 0.04736437f, -0.02774963f, -0.08684280f, -0.09630680f, 0.24822038f, -0.14069983f, 0.01735989f, 
    0.01546951f, 0.15653762f, 0.04377469f, 0.04425072f, 0.16820012f, -0.15922894f, 0.01586355f, 0.25199553f, 
    0.00927393f, -0.03132429f, 0.11187927f, -0.12524992f, -0.08562898f, 0.13115184f, 0.00186589f, -0.00913044f, 
    0.12179475f, -0.04315713f, -0.10901922f, 0.02091568f, 0.12160902f, 0.04542740f, 0.27993813f, 0.03170501f, 
    -0.17916620f, -0.12461731f, 0.06841559f, 0.23482664f, 0.18915120f, -0.04802981f, 0.00566458f, -0.23166199f, 
    -0.01890591f, 0.14022250f, 0.28064293f, -0.02165393f, 0.08136215f, -0.02565935f, 0.11043844f, 0.00398378f, 
    0.06490790f, 0.33705455f, 0.06922985f, -0.19850212f, -0.12274934f, 0.12925290f, 0.07696576f, 0.06075384f, 
    -0.20802504f, 0.14957823f, 0.06070865f, 0.04940023f, -0.08695094f, 0.01702981f, 0.05987553f, 0.13140506f, 
    0.04652071f, 0.09961142f, -0.08930021f, -0.44231591f, 0.04147638f, 0.09954937f, 0.05962969f, -0.09645373f, 
    0.14508674f, 0.04708770f, -0.05227681f, -0.07883462f, -0.37187919f, 0.05370755f, 0.12372507f, -0.23072515f, 
    -0.08540702f, 0.16445927f, -0.06536137f, 0.13968396f, 0.15893592f, -0.03277880f, 0.03132404f, 0.05471822f, 
    0.05031760f, 0.04180413f, 0.28678912f, 0.00785545f, 0.05500343f, -0.33442858f, 0.13258794f, -0.02221329f, 
    -0.15313803f, 0.06853593f, -0.20632209f, 0.03031007f, 0.09085346f, 0.05476455f, 0.16040729f, 0.13380276f, 
    0.11868796f, 0.01259759f, 0.09803535f, -0.00349276f, -0.08499139f, 0.03687334f, -0.07469662f, -0.08129694f, 
    -0.04679835f, -0.04549455f, 0.03740252f, -0.05832881f, -0.02050261f, 0.03750330f, 0.01876624f, -0.03704285f, 
    0.01400099f, -0.03650975f, 0.03747679f, 0.05157924f, 0.04942083f, 0.02790323f, 0.03845961f, 0.02160196f, 
    -0.02896845f, -0.06451866f, -0.01745153f, -0.00518164f, 0.01835987f, 0.03421882f, 0.04511607f, -0.05093507f, 
    0.01272495f, 0.01187499f, -0.00703636f, 0.02095752f, 0.03404456f, 0.00892616f, 0.04667189f, 0.03175206f, 
    -0.00469976f, -0.00201681f, 0.04726252f, -0.03768760f, 0.02797488f, 0.01485237f, -0.02050926f, 0.05311096f, 
    0.00029554f, -0.01592956f, 0.00081413f, -0.04200362f, -0.06592290f, 0.04967897f, -0.06674654f, -0.02101752f, 
    -0.04236722f, -0.06313709f, -0.02098432f, 0.05014946f, -0.05693320f, -0.05912325f, 0.01409999f, 0.01214711f, 
    -0.01869529f, 0.04588779f, -0.01548077f, 0.03678429f, 0.00539277f, 0.04348620f, 0.02894460f, 0.02774679f, 
    -0.00481359f, 0.05074141f, -0.01333211f, -0.02368667f, -0.00054232f, 0.02624678f, -0.05195696f, 0.04332843f, 
    -0.05394930f, -0.03881254f, -0.05015954f, -0.01700299f, -0.03001290f, 0.00642868f, -0.03587564f, 0.00804412f, 
    -0.02420897f, -0.03132506f, -0.07170352f, 0.02913767f, -0.00241095f, 0.05267366f, -0.01647553f, 0.01228984f, 
    0.03383389f, -0.04895488f, 0.00566456f, 0.00073572f, -0.00368781f, -0.04743097f, -0.02047654f, -0.05270283f, 
    -0.00305937f, -0.01437942f, -0.02895987f, -0.00035442f, -0.04580436f, 0.02874900f, -0.03721526f, -0.01952646f, 
    -0.03685838f, -0.05062140f, -0.05517326f, -0.01128451f, -0.04377529f, -0.04013075f, -0.03690088f, 0.05197227f, 
    -0.05177829f, 0.00913935f, -0.04050749f, 0.04039133f, 0.02672360f, -0.02787847f, 0.03907579f, -0.02892376f, 
    0.02457150f, -0.02267307f, -0.02610707f, -0.02463517f, -0.04154475f, 0.01367336f, 0.02275421f, 0.03335039f, 
    -0.01762235f, 0.00962066f, 0.05003503f, -0.01541322f, -0.06276209f, 0.01341209f, -0.03782673f, 0.03387932f, 
    0.03803879f, -0.02288388f, 0.00317837f, 0.03240397f, 0.00115857f, -0.00238507f, 0.02441509f, -0.05403762f, 
    -0.04414377f, 0.02778536f, 0.00726444f, -0.02159867f, -0.03171669f, -0.01569516f, -0.04294442f, -0.04145562f, 
    0.01437456f, 0.03906387f, -0.03027041f, 0.02208621f, 0.04169137f, -0.04007392f, 0.03356805f, 0.00515220f, 
    0.04272969f, -0.04944471f, -0.00254849f, -0.06664827f, -0.00691682f, -0.03380460f, -0.00014569f, -0.05098243f, 
    -0.06294934f, 0.04395682f, -0.03855910f, 0.05416959f, 0.00789455f, -0.04493921f, -0.00910818f, 0.02484522f, 
    0.03804188f, 0.00096239f, 0.01454876f, -0.03348166f, 0.04528130f, -0.03291138f, -0.02474896f, 0.02205951f, 
    0.00009428f, -0.00026755f, -0.00505129f, 0.00702538f, -0.05535026f, 0.04557864f, -0.04599408f, -0.05834487f, 
    -0.03353729f, -0.03709717f, -0.07047550f, -0.02244137f, -0.05757993f, -0.02713715f, -0.06428309f, -0.05481398f, 
    -0.04338448f, 0.02135724f, -0.03800059f, -0.04905177f, -0.05407916f, 0.00514831f, 0.02070710f, -0.02138843f, 
    -0.00063082f, 0.02721737f, -0.02730211f, 0.04464968f, 0.04053100f, 0.00360029f, -0.06033266f, -0.04259736f, 
    0.01230342f, 0.00753703f, 0.01696210f, -0.00235386f, 0.02254291f, -0.02560587f, -0.02128383f, 0.03250453f, 
    -0.01550406f, 0.04820993f, 0.02458546f, 0.00239922f, -0.03985425f, -0.05535358f, 0.03292416f, 0.00655012f, 
    -0.03731057f, -0.04845027f, 0.03281433f, -0.04446495f, 0.01864188f, 0.01581172f, 0.01333483f, -0.05471619f, 
    0.00897907f, -0.05968514f, -0.04633412f, 0.05229634f, -0.05290596f, 0.02342545f, -0.03132582f, -0.06784727f, 
    -0.04296775f, -0.06456288f, -0.01688409f, -0.03902416f, -0.00606470f, -0.04536071f, 0.00860642f, -0.05309774f, 
    0.02613599f, -0.03981569f, -0.00810188f, -0.02449178f, -0.04493193f, 0.05270411f, 0.04205662f, 0.04219685f, 
    -0.01368644f, -0.01166783f, -0.04093010f, 0.02678799f, -0.04527846f, -0.00034686f, -0.04592754f, 0.02344625f, 
    -0.01357120f, 0.00243609f, -0.02406387f, -0.04561974f, -0.03097506f, 0.03148079f, 0.02009279f, -0.02036841f, 
    -0.06234498f, 0.03474998f, 0.05815705f, 0.02451290f, 0.03174247f, -0.04115192f, 0.03092955f, -0.02995981f, 
    -0.14514677f, 0.11149172f, -0.13627261f, 0.02499236f, 0.15550385f, 0.03164463f, -0.13530032f, -0.12914550f, 
    0.02236030f, -0.08473127f, -0.12200916f, -0.03044874f, 0.02046323f, -0.18321157f, -0.03658438f, 0.05386328f, 
    0.26648286f, -0.07988031f, 0.16354409f, 0.04344176f, 0.15244892f, -0.01655624f, -0.01913225f, 0.01295268f, 
    -0.05109970f, -0.07359508f, 0.11844529f, 0.09932816f, -0.11838721f, 0.04164752f, -0.00674236f, 0.02281369f, 
    0.13955553f, -0.03084482f, 0.00765817f, -0.13875809f, -0.02049961f, -0.12357045f, -0.13421313f, 0.01102347f, 
    -0.16368113f, -0.05127648f, 0.16287464f, -0.06944393f, 0.07040812f, -0.38843998f, 0.03252706f, -0.27541935f, 
    0.05544724f, -0.03025356f, 0.04509451f, -0.05802453f, 0.00611008f, 0.08043895f, -0.04436148f, 0.06124258f, 
    0.00310555f, 0.03500174f, 0.16921589f, -0.16015878f, -0.21468273f, 0.08516037f, 0.12281923f, 0.05936028f, 
    0.06003477f, -0.06808149f, 0.00491612f, -0.05857443f, 0.04986083f, 0.05454298f, -0.00068476f, -0.05295018f, 
    0.01682849f, -0.15515584f, 0.06677338f, -0.11650452f, 0.02797240f, 0.03893161f, -0.07920821f, -0.12907989f, 
    0.00294302f, -0.23372617f, -0.26609564f, 0.06623214f, 0.02109943f, 0.08670551f, -0.01615967f, -0.09210009f, 
    -0.06471777f, -0.11506336f, 0.13867803f, 0.00772638f, -0.11672086f, 0.15445925f, 0.06610377f, 0.05748836f, 
    0.11616889f, 0.03941270f, 0.09893904f, 0.41772261f, -0.04984943f, -0.15636955f, 0.11518745f, -0.12643489f, 
    -0.16188392f, -0.02275078f, 0.10943994f, 0.24706845f, -0.19410376f, -0.17668058f, -0.08606082f, 0.08421663f, 
    0.05066345f, 0.02673527f, 0.08987197f, -0.04964992f, 0.03149539f, -0.20407692f, -0.09097812f, -0.09612967f, 
    -0.13086392f, -0.02329451f, 0.09144104f, 0.10519177f, -0.05039751f, -0.05594395f, 0.32212192f, 0.19998030f, 
    0.03851052f, 0.00854461f, 0.10725255f, -0.06972282f, 0.01507719f, 0.11808298f, -0.02941972f, -0.17196584f, 
    0.12918851f, 0.14363658f, 0.00772923f, 0.08546324f, 0.11763313f, -0.02488707f, 0.07692441f, -0.11634713f, 
    -0.60089970f, -0.08228780f, -0.00746293f, 0.06543742f, -0.09232844f, -0.22113904f, 0.08288882f, 0.02278956f, 
    0.22836523f, -0.27376312f, 0.11220112f, -0.13360128f, 0.00796310f, 0.16271874f, -0.00572717f, -0.06063691f, 
    -0.03418622f, -0.05694392f, 0.10943109f, 0.09260660f, -0.03170985f, 0.01223222f, -0.05001454f, 0.20681022f, 
    0.14120980f, 0.08517892f, -0.11203541f, -0.32954302f, 0.15774001f, 0.05704392f, -0.01158397f, 0.03365402f, 
    -0.07714386f, 0.08028105f, -0.01449319f, -0.02831979f, -0.16648276f, -0.13530707f, -0.00032952f, 0.21162936f, 
    0.07334650f, -0.00807150f, -0.01928847f, 0.09464410f, 0.08263100f, -0.05085383f, 0.16174749f, 0.06063401f, 
    0.13962752f, 0.04861115f, -0.11253316f, 0.01663834f, 0.08405313f, -0.14683688f, 0.08225501f, 0.16771959f, 
    0.18738993f, 0.05467265f, -0.02595073f, -0.08259347f, 0.03495751f, 0.19689777f, -0.08896371f, -0.35580149f, 
    -0.21888332f, -0.16479206f, 0.11300818f, 0.11087186f, -0.04172624f, -0.05646460f, 0.03336988f, 0.11816698f, 
    -0.02814026f, -0.11207484f, -0.17326911f, 0.14221182f, -0.07200292f, -0.00454723f, 0.03937694f, -0.05597021f, 
    -0.01112792f, -0.14701332f, -0.07547896f, -0.24304962f, 0.09767757f, 0.02402028f, -0.12175472f, -0.05909447f, 
    0.07668899f, -0.03988130f, -0.12630671f, -0.18852121f, -0.04465766f, 0.15676317f, -0.21181273f, 0.15370937f, 
    -0.05779308f, -0.08983695f, -0.02574910f, 0.14899160f, 0.26095599f, -0.16802853f, 0.02355283f, 0.00980911f, 
    0.06649988f, 0.05497154f, -0.01845505f, -0.05048695f, 0.19953053f, 0.00617558f, -0.06982715f, 0.05708311f, 
    0.01640492f, 0.04559713f, 0.08209474f, 0.06285384f, -0.00265797f, 0.02977839f, 0.08198598f, 0.01936036f, 
    0.09687131f, 0.14568360f, -0.11984574f, 0.17400889f, 0.04814608f, 0.06535150f, -0.06693944f, 0.18527159f, 
    -0.15569401f, -0.14937854f, -0.07849578f, -0.01651735f, 0.02237575f, -0.11425391f, -0.03509024f, 0.03598046f, 
    0.07892166f, 0.01228043f, -0.14682311f, -0.04234282f, 0.04000530f, 0.08027617f, 0.02881214f, 0.01678516f, 
    0.07444213f, 0.04566060f, 0.14072575f, 0.07893024f, 0.08713943f, 0.04858118f, 0.01633527f, -0.02915337f, 
    0.04002453f, 0.10617941f, 0.00183314f, 0.05958168f, 0.04293784f, 0.08222491f, -0.20697810f, -0.14181139f, 
    0.07281131f, 0.05384155f, -0.09893751f, 0.00667044f, 0.06277896f, -0.03004423f, 0.08790460f, 0.14178270f, 
    0.05715890f, -0.02213938f, -0.00168346f, -0.13710853f, -0.18871732f, 0.13598607f, 0.04254739f, -0.16094810f, 
    -0.14049169f, 0.09915511f, -0.12002406f, -0.04916089f, -0.17997549f, -0.00767365f, -0.23568416f, -0.04615196f, 
    0.00620116f, 0.01808894f, -0.02915350f, -0.12497192f, -0.01414207f, -0.05465323f, 0.26796469f, -0.03013297f, 
    -0.08015224f, 0.03058991f, 0.10014444f, 0.13478324f, -0.13932183f, -0.01103852f, 0.20614655f, 0.19439985f, 
    0.03350687f, -0.04876684f, -0.00885819f, 0.16648933f, -0.05235816f, 0.15210095f, 0.15730159f, 0.11052428f, 
    -0.12688082f, 0.06629144f, 0.02105488f, -0.10053909f, 0.03592728f, 0.10395876f, -0.09538575f, 0.10666617f, 
    0.13626750f, 0.15653230f, 0.07969457f, -0.18881559f, 0.01452588f, 0.00070971f, -0.18905061f, 0.00548084f, 
    -0.02948712f, 0.11159154f, -0.04726518f, -0.11046720f, -0.03540163f, -0.10128254f, 0.02599234f, -0.00996148f, 
    -0.03102329f, 0.18059613f, -0.12944105f, -0.02666911f, -0.10474067f, 0.12802237f, 0.04674643f, 0.14086889f, 
    0.23823276f, 0.04562576f, -0.02252277f, -0.18006068f, -0.03756571f, -0.28630465f, 0.09894933f, -0.00623712f, 
    0.06599658f, 0.11729617f, 0.08555248f, -0.13379087f, 0.05235742f, 0.08728782f, 0.20500906f, 0.11819908f, 
    0.17147249f, -0.00019453f, -0.17752460f, 0.05186275f, 0.01739156f, -0.02824301f, -0.35146320f, -0.26266676f, 
    -0.07238329f, 0.05469219f, -0.10126816f, -0.00696539f, 0.02554261f, -0.06108533f, 0.01427797f, 0.14375824f, 
    -0.40149328f, 0.02247893f, -0.07642130f, 0.12524435f, -0.19033645f, -0.05374113f, 0.06515897f, 0.19084416f, 
    0.04515946f, 0.07996171f, -0.05253622f, 0.02899821f, 0.06967283f, -0.11965341f, -0.05618870f, -0.03028359f, 
    -0.13269137f, -0.00445909f, 0.12482949f, 0.05665008f, 0.05785049f, 0.00282050f, -0.00297092f, -0.02363115f, 
    -0.03088087f, 0.00258559f, 0.16458634f, -0.00568446f, -0.04474138f, 0.01750619f, 0.11497467f, -0.09752166f, 
    -0.15720218f, 0.08053936f, 0.12845512f, 0.11281213f, 0.00651292f, 0.00130068f, -0.11487167f, -0.10736982f, 
    0.05717772f, 0.01280083f, -0.04224471f, -0.29107755f, 0.00119413f, -0.11946376f, -0.09160088f, 0.05681296f, 
    0.00253362f, -0.01037274f, 0.05992989f, -0.13172692f, -0.16109596f, -0.03594621f, 0.16333823f, 0.07717174f, 
    0.02680426f, 0.02140060f, 0.10522492f, -0.13430713f, 0.24676275f, -0.16937174f, 0.05902341f, -0.14231242f, 
    0.03492187f, 0.00393203f, 0.00315229f, -0.06161875f, -0.11598875f, -0.10220637f, -0.31032410f, 0.10699528f, 
    -0.18023022f, 0.12597206f, 0.00834299f, 0.08258675f, 0.04882351f, 0.03112346f, 0.00040716f, 0.12618755f, 
    0.03583558f, 0.14402254f, 0.10917118f, -0.00351563f, -0.05776826f, 0.22528757f, 0.08341911f, 0.08328775f, 
    -0.18488117f, -0.14273886f, -0.03702269f, -0.02321509f, 0.08655615f, 0.01659585f, -0.05105004f, 0.05969460f, 
    -0.10325301f, -0.04721903f, -0.02395167f, 0.02057205f, -0.05641773f, -0.01464468f, 0.22989197f, 0.00157627f, 
    -0.13370243f, 0.11906859f, -0.05389781f, -0.01219051f, -0.00065692f, -0.07770173f, 0.06619062f, 0.13792512f, 
    0.10665154f, -0.03096218f, -0.12336438f, -0.45334417f, -0.02613993f, -0.14790621f, -0.02695253f, -0.06896137f, 
    0.05325491f, 0.07686923f, -0.05440828f, 0.09079468f, -0.03186697f, 0.34846324f, -0.36021772f, 0.01149721f, 
    0.05734028f, 0.04029167f, 0.06989051f, -0.11836671f, -0.01098294f, -0.11988286f, 0.09126171f, 0.04462260f, 
    -0.09002938f, -0.06230668f, 0.04401108f, -0.08350550f, -0.01104021f, 0.06504435f, 0.10691918f, -0.21901320f, 
    -0.14614497f, -0.08106562f, -0.04078821f, -0.08339493f, -0.03689576f, 0.05180587f, 0.07840172f, -0.40975693f, 
    -0.31253329f, -0.10821190f, 0.09038056f, -0.00627266f, 0.04200118f, 0.10674126f, -0.06064915f, 0.11048350f, 
    -0.06535348f, -0.06357534f, -0.11394339f, 0.01330173f, 0.18804877f, 0.06610266f, 0.08211903f, -0.15818931f, 
    -0.17338836f, -0.03095742f, 0.06867840f, -0.09332738f, 0.06147898f, 0.05324537f, 0.08605237f, 0.03479818f, 
    -0.15180804f, 0.04334730f, -0.08666310f, -0.04745751f, 0.04443761f, 0.11759926f, 0.05893426f, 0.19561169f, 
    0.01456378f, 0.08829998f, -0.13353570f, 0.07677845f, 0.06066740f, 0.04538762f, -0.09473080f, -0.00447644f, 
    -0.02733853f, 0.04785167f, 0.02155571f, -0.04167218f, 0.08100761f, 0.09207633f, 0.05407031f, 0.03987058f, 
    -0.02336466f, -0.20133370f, 0.02839218f, 0.05601222f, 0.13588253f, -0.21142253f, -0.00560990f, -0.33264148f, 
    0.01833714f, -0.00972916f, -0.04941029f, 0.11680902f, -0.02961851f, -0.08441233f, -0.02643406f, 0.00647887f, 
    -0.09534734f, -0.02219932f, -0.03850218f, 0.03566390f, 0.02552466f, 0.03933578f, -0.17740506f, 0.01772052f, 
    0.14956452f, 0.03839159f, -0.07885204f, -0.02294112f, -0.03180126f, -0.08573084f, 0.11082380f, -0.08683743f, 
    0.03350529f, 0.06559557f, 0.12681341f, 0.09400785f, -0.06032877f, -0.01829467f, -0.02570987f, -0.12482183f, 
    -0.10112714f, -0.12671424f, 0.08630757f, -0.07537469f, 0.00662031f, -0.12109018f, -0.00027074f, -0.03501647f, 
    0.07953182f, -0.06516863f, 0.09302866f, -0.03346219f, -0.06148692f, 0.00512561f, -0.12875521f, -0.12043369f, 
    0.05179018f, -0.06638087f, 0.16053998f, 0.02335649f, -0.17349979f, -0.00838462f, -0.04497175f, -0.19399700f, 
    0.03098836f, 0.04582447f, 0.07619756f, 0.03880932f, 0.01352588f, 0.02666146f, -0.15916710f, 0.03679691f, 
    0.13278940f, 0.19515923f, 0.06326687f, 0.00148955f, -0.01909786f, -0.11758869f, -0.10638113f, 0.14041159f, 
    0.00487972f, -0.01822104f, -0.13260598f, 0.08095637f, -0.11854842f, 0.00450725f, 0.08253648f, -0.02064423f, 
    0.07914154f, 0.05637081f, -0.05473212f, -0.12309399f, 0.02915581f, 0.04424855f, 0.02961318f, -0.16864768f, 
    0.01810938f, 0.12433845f, -0.01249436f, -0.01013958f, -0.00184700f, 0.07466491f, 0.09612291f, -0.03742117f, 
    -0.11798490f, 0.10938091f, -0.01416253f, 0.12108126f, -0.05109357f, 0.01157288f, 0.02004957f, 0.10904194f, 
    0.10157586f, 0.07323059f, 0.23320454f, 0.00644859f, 0.00441407f, -0.03736889f, -0.03169013f, 0.02482442f, 
    -0.11844435f, -0.05254997f, 0.08534109f, 0.07272721f, 0.01296948f, 0.04022001f, -0.00336505f, 0.03510066f, 
    -0.00767315f, -0.05843566f, 0.00931445f, 0.02534453f, 0.03140306f, 0.07544196f, -0.11547152f, 0.11592305f, 
    0.14347062f, -0.02279005f, -0.13400847f, -0.02109131f, 0.00068557f, -0.17595275f, -0.13366760f, -0.11945476f, 
    0.15960875f, 0.05573580f, 0.10737804f, 0.01922892f, -0.02897049f, -0.00581867f, 0.02278893f, 0.15160295f, 
    0.03863726f, -0.09690564f, 0.02359317f, -0.02385773f, 0.02011858f, -0.03643299f, 0.04223829f, 0.01356014f, 
    0.05023502f, -0.14921582f, -0.24231419f, 0.03165054f, 0.03922633f, 0.12653993f, 0.05266120f, -0.22596136f, 
    -0.13598077f, -0.19218330f, 0.03886002f, 0.07355568f, 0.16212101f, 0.05703449f, -0.03593381f, 0.04002512f, 
    -0.04065415f, -0.15070878f, 0.04559017f, 0.06717235f, -0.14200498f, 0.03112338f, -0.01284070f, 0.03949199f, 
    -0.16208643f, 0.04351707f, 0.09078164f, -0.10274142f, 0.07632928f, 0.03283687f, 0.15253009f, -0.08827409f, 
    -0.06476089f, 0.00214173f, 0.04296019f, -0.18692471f, -0.03973519f, 0.05489462f, -0.00717203f, 0.12798317f, 
    0.05973932f, 0.05742891f, -0.01534971f, 0.12542677f, 0.21835990f, -0.15010560f, -0.04497106f, -0.07052310f, 
    -0.12244876f, 0.10149878f, -0.10621867f, 0.00786383f, 0.08469392f, -0.07710318f, -0.02323950f, -0.00118967f, 
    -0.10290801f, -0.11257078f, 0.05308436f, 0.02944076f, 0.06288852f, 0.29504123f, 0.15256751f, 0.08029256f, 
    0.11320782f, -0.03192142f, 0.01175514f, 0.10887092f, 0.04013051f, 0.16518043f, 0.17180794f, 0.08541577f, 
    0.06219473f, -0.13942292f, -0.11600277f, 0.05615634f, -0.00315899f, -0.09300938f, -0.01578355f, 0.02507989f, 
    0.12596379f, 0.09992936f, -0.04305360f, -0.19162688f, -0.07192939f, 0.08771059f, 0.01091562f, -0.04804962f, 
    0.06214839f, -0.06418011f, 0.19987597f, 0.06727821f, 0.04961899f, -0.07298138f, 0.04779786f, 0.10661774f, 
    0.13340402f, -0.20814584f, 0.04870268f, -0.09033753f, 0.16884302f, -0.02254973f, 0.16745758f, 0.16624162f, 
    0.00144255f, 0.19803755f, -0.00101302f, 0.00524166f, 0.11865513f, 0.03653573f, 0.18943577f, 0.04260886f, 
    0.18894261f, 0.08610091f, -0.04454555f, -0.23887323f, -0.05430374f, 0.02269277f, -0.07675134f, -0.00083122f, 
    0.02274213f, -0.03437238f, -0.10901482f, -0.01447676f, -0.10544769f, -0.07719845f, -0.22704597f, -0.07258414f, 
    -0.09228212f, -0.01782327f, -0.12401421f, -0.03392896f, 0.11247915f, -0.37053564f, -0.19429864f, -0.00719662f, 
    -0.04620021f, 0.09047225f, -0.20877451f, 0.03593362f, 0.03703253f, -0.09133048f, 0.01085231f, -0.00037689f, 
    0.29011926f, -0.10988998f, 0.04652335f, -0.16802604f, 0.10305844f, 0.13596967f, 0.07932558f, -0.13221529f, 
    0.02521611f, 0.20558001f, -0.00067826f, -0.12450255f, -0.19144502f, -0.02003729f, -0.06134153f, 0.19265176f, 
    -0.12981376f, 0.15288095f, -0.01539270f, -0.06236790f, 0.11376196f, -0.10970951f, -0.05242125f, -0.06987705f, 
    0.03350438f, 0.07403891f, -0.20389682f, 0.07562935f, -0.09777318f, 0.00745250f, -0.15592121f, 0.21575458f, 
    0.07852715f, -0.07805999f, 0.00544822f, -0.18844728f, -0.00485324f, 0.11243572f, 0.01638332f, 0.07904462f, 
    0.07910019f, 0.17629167f, 0.04771924f, -0.47198057f, 0.09763981f, -0.11672024f, 0.09095103f, -0.00820838f, 
    -0.02714087f, -0.10345562f, -0.07142839f, 0.16084790f, 0.05748539f, 0.32653680f, 0.01946099f, 0.01722670f, 
    -0.14891678f, 0.22432861f, 0.14722225f, 0.11367028f, 0.00950166f, 0.13075070f, -0.01969329f, 0.16038749f, 
    0.07523865f, 0.02653237f, 0.09145149f, 0.08012162f, 0.09272948f, -0.01682721f, 0.02072329f, 0.05803061f, 
    0.08710811f, 0.16851479f, 0.08093691f, 0.12668809f, 0.07338317f, 0.02229681f, 0.05149519f, -0.04041442f, 
    0.26298320f, 0.14194897f, -0.10172040f, 0.01284096f, 0.16700222f, -0.01230944f, 0.02527989f, 0.08346771f, 
    0.09128351f, -0.05452006f, 0.13461004f, 0.09241582f, 0.06047641f, 0.13299778f, -0.05586394f, -0.02916000f, 
    -0.04920724f, 0.21857092f, 0.17481337f, 0.00755443f, -0.32031494f, 0.01841381f, -0.13891269f, 0.21319546f, 
    0.05769804f, -0.02178408f, -0.00885941f, 0.23000981f, 0.07602895f, -0.08819992f, -0.00453649f, -0.17255510f, 
    -0.01665451f, 0.06389495f, 0.09097214f, 0.03050733f, -0.03149942f, -0.26503786f, 0.00422476f, 0.04622601f, 
    0.03812945f, 0.19201699f, 0.01828232f, -0.13213885f, -0.26700801f, -0.11294656f, 0.20558991f, 0.02785279f, 
    0.07649975f, 0.05004206f, 0.15022868f, -0.05211325f, -0.06568194f, -0.27175647f, 0.00960770f, -0.02928378f, 
    -0.00466927f, 0.25937402f, 0.18821792f, -0.09237772f, -0.16717812f, -0.12046106f, -0.23409623f, -0.02645434f, 
    0.10642688f, 0.03396961f, 0.22783276f, 0.07573888f, 0.04780901f, -0.00277371f, 0.06022278f, 0.05187526f, 
    0.01125354f, 0.12346196f, 0.20624217f, 0.05693025f, 0.19884129f, 0.09737635f, 0.00081310f, -0.05075185f, 
    0.10626020f, 0.21558112f, 0.10505133f, -0.13339934f, 0.08215528f, -0.03356315f, 0.01651502f, 0.11959062f, 
    -0.11252337f, 0.03334415f, -0.23435237f, 0.07671160f, -0.12602293f, 0.17698877f, -0.20909424f, 0.20524213f, 
    -0.04350987f, -0.01787360f, -0.19817421f, 0.03840357f, -0.00501516f, -0.04846473f, 0.03409820f, 0.06029297f, 
    -0.17117192f, 0.02294661f, -0.01752351f, -0.17105168f, -0.07890517f, -0.01493684f, 0.18093029f, 0.03173821f, 
    0.05527135f, -0.16035357f, -0.09341338f, -0.02848491f, 0.00041628f, 0.16025355f, 0.01121892f, 0.13168243f, 
    0.06125217f, 0.05266470f, -0.04369227f, -0.12978287f, 0.09096350f, 0.08688021f, -0.02624321f, -0.00238135f, 
    0.15949057f, -0.04113180f, 0.17451802f, -0.01613451f, -0.16810414f, 0.07593564f, -0.01422638f, -0.08285479f, 
    -0.08536360f, 0.23976116f, -0.21784373f, -0.08320531f, -0.05603316f, 0.04394676f, -0.06493059f, -0.14523751f, 
    -0.26640975f, -0.09005152f, 0.13705298f, 0.01025928f, 0.12274857f, -0.15196045f, -0.05087127f, -0.11713170f, 
    -0.05273650f, -0.12855406f, 0.01611051f, 0.06218313f, 0.02801825f, 0.09178536f, -0.12525709f, -0.09410749f, 
    -0.01223223f, -0.40982017f, 0.08393698f, 0.13978353f, -0.03146406f, 0.13475463f, 0.00138140f, -0.00895459f, 
    -0.06926346f, -0.09791144f, -0.17849182f, -0.35280162f, 0.02825963f, 0.12499733f, 0.05420261f, 0.05840642f, 
    -0.15654913f, -0.06309998f, 0.02781775f, 0.03762322f, -0.09443996f, -0.17849937f, 0.01571685f, -0.11404517f, 
    -0.03008883f, -0.00906254f, 0.01401696f, 0.01033466f, 0.02292963f, 0.11057933f, -0.09722891f, -0.00194602f, 
    0.00411715f, -0.01112734f, 0.16829175f, 0.07059344f, -0.03033447f, -0.02206246f, -0.35446215f, -0.01713892f, 
    -0.01435505f, 0.05644821f, 0.01442690f, 0.01136418f, -0.14702025f, -0.10341492f, 0.20248955f, -0.10740642f, 
    0.06061308f, -0.02687631f, -0.02603146f, 0.08611791f, -0.00081198f, -0.09248427f, -0.08823618f, -0.12565358f, 
    0.12866122f, -0.02048085f, 0.03341097f, -0.03901406f, 0.13395666f, -0.05534494f, -0.06635500f, -0.07250314f, 
    0.09712697f, -0.17902055f, 0.10405372f, -0.01787455f, 0.09070171f, 0.12060741f, 0.01875350f, -0.06024658f, 
    -0.03441001f, 0.31546080f, 0.18755852f, -0.06423292f, 0.07601549f, -0.00103352f, 0.03155619f, -0.03799558f, 
    -0.15497915f, -0.00979779f, -0.04810880f, 0.20272391f, 0.00948876f, -0.14377896f, -0.08732281f, -0.10091625f, 
    0.01994750f, -0.01661957f, -0.01407431f, -0.08614282f, 0.09857508f, -0.11942673f, 0.11002413f, -0.06588630f, 
    -0.05247662f, 0.10093212f, 0.02008393f, -0.02632621f, -0.25337929f, -0.20234300f, 0.18195635f, -0.06958998f, 
    0.10475657f, -0.07207747f, -0.17936131f, -0.02841210f, 0.02003123f, 0.06276970f, 0.10921499f, -0.22186308f, 
    -0.11277341f, 0.00869344f, -0.07330327f, 0.09858172f, 0.08108407f, -0.03824015f, 0.26661867f, 0.26049039f, 
    0.13883148f, 0.01982749f, 0.05935775f, -0.04241373f, 0.09332023f, 0.11975570f, -0.06599519f, -0.07891502f, 
    -0.09708143f, 0.06493717f, 0.00069043f, 0.02447071f, 0.20656054f, 0.06352026f, -0.21076611f, -0.13305554f, 
    -0.13416275f, -0.29578251f, 0.00160145f, -0.09201927f, -0.01820264f, 0.05752039f, -0.03355761f, -0.04980676f, 
    0.02542549f, 0.11263466f, 0.29435834f, 0.20403884f, -0.05744710f, 0.22841388f, 0.00507233f, 0.09926581f, 
    -0.12809893f, -0.01916696f, 0.00653559f, 0.12801926f, 0.03675755f, -0.08080103f, -0.00724580f, -0.00566608f, 
    0.09866434f, -0.06137384f, -0.02754205f, -0.18089969f, -0.00940060f, -0.18584947f, -0.12980883f, 0.04972137f, 
    -0.15335496f, -0.01302175f, 0.01196548f, 0.08572234f, 0.20119582f, -0.23848875f, 0.08718998f, 0.01189543f, 
    -0.03696459f, 0.02618175f, -0.08449636f, -0.24032174f, 0.06253806f, 0.37552571f, 0.18357964f, 0.11749408f, 
    -0.05234917f, 0.04293451f, 0.00043427f, -0.07262515f, 0.14471196f, -0.02662088f, 0.08900765f, 0.10404401f, 
    -0.03026029f, -0.01009219f, 0.00509495f, -0.01685364f, -0.01771419f, 0.04184448f, 0.00944326f, -0.28189564f, 
    0.05007041f, -0.09205332f, 0.01078306f, 0.09713681f, 0.06369750f, -0.04743332f, -0.03813972f, -0.04525892f, 
    0.32723555f, 0.01143388f, -0.02747223f, -0.19283059f, -0.01623003f, 0.01585917f, -0.11976128f, 0.00226664f, 
    0.04706221f, 0.29044670f, 0.12605406f, 0.16240768f, -0.06647561f, 0.04968273f, 0.00529503f, -0.00519137f, 
    -0.02917086f, 0.00357748f, 0.33777121f, -0.02123905f, -0.06779032f, 0.13034186f, -0.00886439f, 0.11043008f, 
    -0.13289410f, -0.02156802f, -0.03549645f, 0.24053261f, 0.18280242f, 0.08976300f, 0.02316723f, -0.01983416f, 
    -0.00227405f, -0.10038976f, 0.16313696f, -0.01742309f, 0.16878965f, 0.32266119f, 0.06941371f, -0.01978204f, 
    0.03685613f, -0.09112277f, 0.18705222f, 0.00327769f, 0.05102354f, 0.15061520f, 0.06825115f, 0.16077517f, 
    -0.08681882f, -0.09271488f, -0.09990100f, 0.01250460f, 0.07639411f, -0.04294883f, -0.11003591f, 0.19758222f, 
    0.18299700f, 0.01524067f, -0.02714171f, -0.04074958f, -0.13284308f, 0.07204279f, 0.12853996f, -0.05142505f, 
    -0.06652425f, 0.14876984f, -0.12960222f, 0.06850041f, 0.10835240f, -0.07947273f, 0.06760897f, 0.00281712f, 
    -0.03810538f, 0.02186013f, 0.06931794f, 0.01955860f, 0.07439338f, 0.06551272f, -0.13911071f, -0.03875176f, 
    0.19371951f, 0.13106792f, 0.14757259f, 0.04488111f, -0.05431420f, -0.04280497f, 0.07015907f, 0.12912351f, 
    0.05841210f, 0.12499920f, 0.14003199f, 0.08487467f, -0.07615133f, 0.04639702f, -0.04089592f, 0.14285937f, 
    0.00977480f, 0.05173593f, -0.04297797f, 0.21564139f, 0.10125107f, -0.33370060f, -0.03352480f, 0.06197331f, 
    -0.02688434f, -0.22968785f, -0.06946079f, -0.05422145f, 0.15234756f, 0.03107098f, -0.09746338f, 0.00693046f, 
    -0.10460684f, -0.03667499f, -0.00562422f, 0.08646373f, -0.01213241f, -0.28577733f, 0.15158454f, -0.29236999f, 
    -0.01581781f, 0.10888091f, 0.07557194f, 0.07104704f, -0.04241270f, 0.10378910f, -0.00931213f, -0.12507354f, 
    -0.01544518f, -0.01591286f, 0.11097126f, 0.05765283f, 0.04024525f, -0.01674169f, -0.05824662f, -0.13446534f, 
    -0.18425576f, -0.29988921f, 0.27500600f, 0.07972531f, -0.05780758f, 0.00393205f, 0.07398801f, -0.00777753f, 
    0.16342294f, 0.05389493f, -0.05109835f, 0.04768845f, 0.11765774f, 0.06973675f, -0.06224071f, 0.03844058f, 
    -0.06167981f, -0.27717179f, 0.02614466f, -0.06736941f, 0.10361016f, 0.05676735f, -0.06614351f, -0.04019481f, 
    0.14087082f, -0.13880096f, 0.06762744f, -0.04758025f, 0.18914886f, -0.10553575f, -0.03959924f, 0.03253013f, 
    -0.00914111f, -0.06769067f, 0.06119814f, 0.11632665f, -0.05636353f, 0.07824060f, -0.14260525f, 0.11696893f, 
    -0.09079856f, -0.04921480f, 0.09428973f, 0.15388329f, 0.00980811f, 0.02678012f, 0.01870409f, 0.04818098f, 
    -0.11989841f, 0.08135881f, 0.04955526f, 0.04418483f, -0.04239983f, -0.12456530f, -0.19814011f, 0.04615821f, 
    -0.06296836f, -0.08674034f, 0.02017692f, -0.29894266f, -0.00363672f, -0.14882761f, 0.15391622f, 0.07409830f, 
    0.12022052f, -0.15108654f, -0.04192861f, -0.02348247f, 0.06210971f, 0.03958884f, 0.07212934f, 0.16209765f, 
    0.15729007f, -0.14926785f, 0.06883284f, -0.03385580f, 0.04538664f, -0.00295906f, -0.06825303f, -0.07158949f, 
    -0.07591341f, -0.00543654f, 0.09797817f, 0.08292829f, -0.05878612f, -0.03441956f, -0.04271032f, 0.03683857f, 
    0.13814417f, 0.12916861f, -0.10877355f, -0.18561664f, 0.02804389f, 0.05294158f, 0.10312429f, -0.01893284f, 
    -0.05021298f, 0.02966318f, 0.01429467f, 0.07230635f, -0.29119554f, 0.01849622f, 0.02190687f, 0.02786875f, 
    0.15849039f, -0.01378221f, -0.16377911f, 0.07007797f, 0.17981291f, 0.16869661f, -0.26637170f, -0.06814403f, 
    0.12834649f, 0.07330115f, 0.05898818f, -0.18799216f, -0.07346167f, -0.13489589f, -0.15649621f, -0.06424268f, 
    -0.02505780f, 0.03231132f, 0.01086910f, 0.15634766f, 0.09996967f, -0.14528687f, 0.10130302f, 0.07571272f, 
    -0.16681464f, 0.08269816f, -0.03193967f, -0.05631945f, -0.05057215f, 0.01164219f, -0.21625486f, -0.14549126f, 
    0.04185757f, -0.03055779f, -0.10330447f, -0.03073801f, 0.04683125f, 0.00220200f, 0.05766299f, -0.12433334f, 
    0.03685519f, 0.01171881f, 0.05994282f, 0.05150722f, 0.09215318f, -0.09558299f, 0.02726768f, 0.19667006f, 
    -0.10901172f, -0.10475712f, -0.35979888f, 0.04250492f, -0.07279692f, -0.07643158f, -0.08680761f, 0.01836050f, 
    0.05003137f, -0.04861924f, -0.11180408f, -0.27507666f, 0.13103798f, 0.06170731f, 0.12770411f, -0.08578890f, 
    -0.00716182f, -0.17769891f, 0.11955718f, -0.02770248f, -0.04941101f, 0.12064967f, 0.11287196f, 0.00978563f, 
    -0.03372800f, 0.04348379f, 0.13726455f, 0.27562323f, 0.21169245f, 0.14428639f, -0.10931519f, -0.10418225f, 
    0.14318080f, -0.00181872f, 0.01010027f, 0.03834578f, 0.06023858f, -0.00039875f, 0.01187389f, -0.03978153f, 
    0.01434404f, -0.13441730f, 0.06963865f, -0.11196770f, -0.02541554f, 0.34014770f, 0.16958420f, 0.15373592f, 
    -0.26270992f, -0.14856413f, 0.00258233f, -0.01986642f, 0.09430747f, 0.04243657f, 0.01027601f, -0.20669088f, 
    -0.12779507f, 0.10174898f, 0.00954761f, 0.05042216f, -0.00420984f, -0.07591475f, 0.01654354f, 0.17653309f, 
    0.08432115f, 0.09781555f, -0.17532952f, -0.23110540f, 0.02887124f, -0.04456274f, 0.04942791f, 0.02728745f, 
    -0.03301622f, -0.04058102f, -0.13365574f, 0.04323933f, -0.02093371f, -0.15518861f, -0.04852575f, -0.05432002f, 
    -0.06014577f, -0.20528392f, 0.02525984f, -0.02523547f, -0.04380533f, 0.07212929f, -0.03646498f, -0.08230373f, 
    -0.09558110f, -0.15845594f, -0.21719795f, 0.16663687f, -0.05948007f, -0.07845826f, -0.03674450f, -0.00088439f, 
    0.08074503f, 0.05413913f, -0.23130748f, -0.09464331f, 0.09930424f, 0.01083829f, 0.20173934f, 0.05936201f, 
    0.02335293f, 0.07691342f, 0.14938828f, -0.12667276f, 0.08984176f, 0.09929629f, -0.11037362f, -0.13273257f, 
    -0.11261892f, 0.10492412f, 0.03276023f, 0.17164581f, -0.15089656f, -0.26339227f, 0.11256776f, -0.25245905f, 
    0.03243391f, 0.16746946f, -0.15122803f, 0.00365962f, 0.05127583f, -0.26990697f, -0.10448607f, 0.11473724f, 
    -0.08445902f, 0.03999954f, -0.00852497f, -0.17928854f, -0.18559480f, 0.02844066f, -0.00548429f, 0.02850318f, 
    0.05300565f, 0.03536240f, -0.01216143f, 0.13995656f, -0.13577750f, 0.09811559f, -0.07553366f, 0.24613146f, 
    -0.33026254f, 0.20126869f, -0.11734661f, 0.08459018f, -0.01954314f, -0.45933995f, -0.00426183f, 0.03571324f, 
    0.05314111f, 0.01236361f, 0.28002945f, -0.14840341f, 0.08569293f, 0.07179160f, -0.14059246f, 0.05513851f, 
    0.09637746f, 0.03875884f, 0.25121480f, 0.09422230f, -0.05089307f, 0.09582348f, -0.03931580f, -0.07434807f, 
    0.00090817f, 0.11593659f, 0.00327488f, 0.14541908f, -0.10125663f, 0.21308935f, -0.01985388f, 0.09050179f, 
    -0.13212968f, 0.04790761f, 0.01498809f, -0.04503181f, 0.18237114f, 0.13052757f, -0.26873446f, -0.00214642f, 
    0.16267535f, 0.04260994f, 0.13575713f, -0.11683173f, -0.11881268f, -0.16569854f, 0.18937124f, -0.16505164f, 
    -0.06880136f, 0.13366090f, 0.02991123f, 0.14861764f, 0.10698484f, 0.02852059f, 0.06964792f, -0.05021899f, 
    0.10547909f, 0.08955634f, -0.03110276f, 0.14047967f, 0.12970714f, 0.09405728f, 0.04284233f, -0.18194267f, 
    0.02769276f, 0.08033152f, 0.12994722f, 0.07784205f, -0.11965929f, -0.05935105f, -0.02724115f, -0.04384981f, 
    -0.05256465f, -0.10090426f, -0.04589172f, -0.03795831f, 0.06460465f, -0.02265985f, -0.01249558f, 0.11167283f, 
    0.00906225f, 0.25762796f, -0.09711967f, 0.17863861f, -0.10439952f, -0.01232664f, 0.04400209f, -0.28801727f, 
    0.00850650f, 0.13761151f, 0.17943224f, 0.06458231f, 0.00348499f, 0.12571624f, 0.17658560f, -0.13879402f, 
    -0.13947910f, 0.02722663f, 0.05270050f, 0.12611651f, -0.09757704f, -0.19058785f, -0.12049439f, -0.00483212f, 
    0.04171961f, 0.06040457f, 0.01288899f, -0.07712517f, 0.34330776f, 0.29635137f, 0.00140917f, 0.02652647f, 
    -0.06736893f, 0.15012354f, -0.13479599f, -0.19222099f, 0.00966688f, 0.21040392f, 0.03374794f, 0.22065063f, 
    0.14794387f, 0.00211613f, 0.23028646f, 0.05778378f, -0.07981487f, -0.02459139f, 0.11498847f, 0.09445728f, 
    0.27833068f, 0.14099348f, 0.03564191f, 0.00596660f, -0.03801990f, -0.03741164f, 0.08245337f, 0.09209231f, 
    -0.04911066f, -0.04447836f, -0.09977509f, 0.02274133f, 0.05054495f, 0.04878080f, -0.03303665f, -0.25832376f, 
    0.01058935f, 0.07055200f, 0.07649302f, 0.03001375f, 0.02704187f, 0.00518266f, 0.12640694f, 0.25911033f, 
    0.16340284f, 0.43112552f, -0.01700910f, -0.00696286f, 0.01603715f, 0.06561919f, -0.03686300f, -0.02537386f, 
    -0.17337415f, -0.16369364f, -0.15294896f, 0.07726838f, 0.07746093f, -0.07389482f, 0.14424352f, -0.10238174f, 
    0.04388481f, 0.16233233f, -0.03546649f, -0.00314745f, -0.11558819f, 0.03290159f, 0.02836448f, 0.04772513f, 
    0.15812303f, 0.15478909f, -0.03177900f, 0.10156403f, 0.05392321f, -0.04314787f, 0.04680868f, 0.04949786f, 
    -0.03299382f, 0.22085772f, -0.01215390f, 0.10511795f, 0.13555826f, 0.15191971f, -0.03402644f, -0.08525163f, 
    -0.12998389f, -0.06083547f, 0.13580394f, 0.20916465f, 0.04987470f, -0.17200918f, 0.32139608f, -0.08694737f, 
    -0.09005830f, 0.27334145f, -0.00817882f, -0.09388942f, -0.04058984f, 0.15727183f, 0.07367992f, 0.13955583f, 
    -0.01234782f, -0.11946814f, -0.02578074f, -0.03226575f, -0.01171414f, 0.05929852f, 0.10569001f, -0.06436934f, 
    0.01682052f, 0.00488329f, -0.04707347f, -0.00341682f, -0.01912542f, -0.03268510f, 0.01958088f, 0.00173582f, 
    0.04562652f, -0.04382470f, 0.04596700f, 0.04191031f, 0.01179909f, -0.06009868f, 0.05164273f, -0.04096072f, 
    -0.01153976f, -0.03404653f, -0.04134439f, -0.02375563f, -0.01673250f, 0.02995241f, -0.01689636f, 0.04281926f, 
    0.03578269f, 0.00856994f, -0.05634854f, -0.00040371f, 0.03280130f, -0.01430019f, 0.00986781f, -0.03457019f, 
    0.01421259f, 0.02294397f, 0.03001135f, 0.02974516f, -0.02666263f, -0.00525457f, 0.00774836f, 0.04328644f, 
    0.00248886f, 0.00702374f, -0.00076405f, -0.02782550f, 0.00210007f, -0.06096864f, -0.01450722f, 0.02730652f, 
    -0.03826011f, -0.06309312f, 0.05178546f, -0.04775260f, 0.03589456f, -0.05680991f, -0.01030942f, -0.07811591f, 
    -0.04803450f, -0.03634930f, -0.03590505f, 0.01840870f, 0.04103413f, -0.04857814f, -0.03457411f, -0.05562446f, 
    0.03163390f, -0.03707780f, -0.03150074f, 0.00023453f, -0.00682292f, -0.00778116f, -0.02191265f, 0.00887183f, 
    0.04019052f, 0.02844282f, 0.03783580f, -0.06897680f, -0.04495345f, -0.06158609f, -0.00446298f, 0.01901341f, 
    0.04128439f, -0.05525289f, -0.03897978f, 0.01447370f, 0.00009895f, 0.00920344f, 0.00801094f, -0.07618665f, 
    -0.01112393f, -0.00350477f, 0.03677516f, -0.00645174f, 0.04788962f, 0.04613919f, -0.03933528f, -0.02144594f, 
    -0.04358648f, 0.01916665f, 0.02736698f, 0.01632686f, 0.04852946f, 0.02151480f, 0.03819739f, 0.05352058f, 
    0.02481928f, -0.01785741f, 0.04891155f, -0.04379116f, 0.04746002f, -0.01949471f, 0.01670831f, -0.05426882f, 
    0.01723325f, 0.01338569f, -0.06196388f, 0.01072611f, -0.05072786f, -0.00229991f, -0.00502579f, 0.02781986f, 
    0.03340565f, 0.00701402f, 0.03352464f, -0.00164290f, 0.04411550f, 0.01362785f, -0.04031603f, 0.01469081f, 
    -0.06898674f, -0.02555152f, -0.02377072f, -0.02803515f, -0.01318007f, -0.02119487f, 0.00636992f, -0.05264900f, 
    -0.07496436f, -0.04030618f, 0.02585009f, 0.04407649f, -0.02399970f, -0.03276846f, 0.00817771f, 0.03475136f, 
    -0.06160064f, 0.00612378f, -0.03432183f, -0.05084847f, -0.06460972f, -0.03291807f, 0.03616756f, 0.03982751f, 
    0.03007642f, -0.03518831f, 0.01164550f, 0.05079203f, 0.04241521f, 0.01704011f, -0.07305066f, 0.01742989f, 
    0.02084299f, 0.02722686f, -0.01644582f, -0.00552945f, -0.05853996f, 0.02171530f, -0.01753447f, 0.04065804f, 
    -0.03195085f, -0.04395274f, -0.04343548f, 0.04333898f, -0.00219806f, -0.03632294f, -0.03570047f, -0.03093763f, 
    -0.05380449f, -0.06974555f, -0.00779195f, -0.04704740f, 0.04905625f, 0.01064330f, 0.01238689f, -0.04720000f, 
    0.03064916f, -0.00588636f, -0.02384085f, -0.03512372f, -0.04549250f, 0.02962052f, 0.00821350f, -0.04386849f, 
    0.03605875f, 0.03725995f, -0.04343197f, 0.02619541f, -0.01402789f, -0.04568944f, -0.05539329f, 0.03714833f, 
    0.00801249f, 0.02541609f, -0.00702466f, -0.02934458f, -0.07418773f, 0.01258250f, -0.05405223f, 0.01025216f, 
    -0.04616681f, -0.01270514f, -0.01308554f, -0.05016392f, -0.05049635f, -0.00293115f, 0.00215975f, 0.03158485f, 
    0.03847265f, -0.01880521f, 0.04451025f, -0.03980179f, 0.04689459f, -0.02255565f, 0.02646300f, -0.05422490f, 
    -0.04672610f, 0.00321284f, -0.03362831f, -0.02999922f, 0.02289430f, -0.02501981f, -0.03692615f, 0.01207392f, 
    -0.04923061f, 0.00135574f, -0.02044154f, 0.03412829f, -0.03997789f, -0.03735832f, 0.04882618f, -0.01172973f, 
    0.04483865f, -0.01041490f, -0.03197058f, -0.01083528f, -0.04067965f, 0.03796064f, -0.00533572f, 0.03638554f, 
    -0.02791296f, -0.02835635f, 0.02668059f, -0.00732403f, -0.04698101f, 0.01222401f, -0.00531287f, 0.03098001f, 
    -0.03398140f, 0.04075392f, -0.01812495f, -0.01398724f, -0.00815160f, 0.00760504f, -0.00895346f, -0.01970138f, 
    -0.05570126f, 0.02406529f, 0.05412543f, -0.04146351f, 0.05043940f, -0.05047252f, 0.00090546f, -0.01219471f, 
    -0.05306581f, -0.01058150f, -0.00301340f, 0.03590491f, -0.01717139f, -0.00695355f, 0.03812795f, -0.01660010f, 
    0.00061976f, 0.02681500f, 0.04004562f, 0.00403399f, -0.04615121f, 0.01851145f, -0.04912738f, 0.00465258f, 
    -0.04524134f, -0.05767179f, -0.04930724f, -0.04199757f, -0.02477002f, -0.05846839f, -0.03944305f, 0.00233537f, 
    0.02919044f, 0.04317009f, 0.00990196f, -0.04813122f, -0.01123013f, 0.03452905f, -0.04540043f, 0.01195488f, 
    -0.03014981f, 0.03073514f, -0.04830822f, 0.00552868f, -0.04388278f, -0.05724378f, 0.04430030f, -0.04124168f, 
    0.02283550f, -0.05436363f, -0.01484044f, -0.04033935f, -0.06475902f, -0.01647878f, 0.02870579f, -0.04367494f, 
    0.00146225f, 0.04815695f, -0.04925919f, 0.05141371f, -0.03245921f, 0.03383956f, 0.00740520f, -0.03097831f, 
    0.03139180f, -0.07021228f, 0.02816498f, 0.01877478f, 0.02352551f, -0.01543094f, 0.01188469f, 0.02370054f, 
    -0.04347682f, -0.01408420f, -0.03057216f, -0.03143854f, -0.03811656f, -0.02804585f, -0.06540187f, -0.05414184f, 
    -0.05086781f, -0.00497916f, 0.00452483f, -0.04099835f, -0.01910836f, 0.01818201f, 0.03819473f, -0.00605303f, 
    -0.03531464f, -0.01869388f, 0.00759607f, 0.03088789f, 0.00647004f, 0.03611913f, -0.06157846f, 0.04299702f, 
    0.01174570f, 0.00763983f, -0.00095550f, 0.04631177f, -0.05449916f, 0.04778358f, 0.03333291f, -0.05686193f, 
    -0.02266407f, 0.04845610f, -0.02521900f, -0.00564471f, -0.05309333f, 0.03850607f, -0.00024123f, 0.00772164f, 
    0.01032508f, 0.02577851f, 0.01009540f, 0.04706578f, 0.00653383f, -0.02760296f, 0.02709643f, -0.06421314f, 
    -0.02441852f, -0.06192795f, -0.05796737f, -0.04465372f, -0.00549048f, 0.00789139f, -0.01030114f, -0.01191315f, 
    -0.01197910f, -0.00809358f, 0.01431985f, 0.01225226f, 0.01517518f, 0.00587587f, -0.02999520f, -0.00664961f, 
    -0.01968603f, 0.03419800f, -0.05795560f, -0.00412849f, 0.00998821f, -0.00756582f, 0.01013635f, -0.01229674f, 
    0.03296509f, -0.02691642f, -0.02958733f, 0.02587982f, -0.04335524f, 0.03928707f, 0.02935194f, 0.04357053f, 
    -0.05129457f, -0.04519775f, 0.01536168f, -0.06113974f, 0.02719251f, -0.06150156f, 0.01175938f, 0.04950370f, 
    0.02225963f, -0.00447968f, -0.04863901f, -0.00983404f, -0.00979397f, -0.04521550f, -0.05953155f, -0.05549554f, 
    0.03852528f, -0.02387369f, -0.01546572f, 0.05012779f, 0.03011413f, -0.02885526f, 0.00114675f, -0.00680722f, 
    0.04667624f, 0.00482652f, -0.01339802f, -0.01570760f, 0.04894868f, -0.00299918f, 0.01038920f, 0.01630663f, 
    0.04669971f, 0.04156385f, -0.03503391f, -0.00222564f, -0.02016154f, 0.00566555f, -0.04531567f, 0.00758870f, 
    0.03090971f, 0.04136372f, -0.05824027f, -0.02184191f, -0.00048640f, -0.01806995f, -0.04342160f, -0.05925288f, 
    -0.00433508f, 0.02049971f, 0.00591571f, -0.00731634f, -0.05008256f, 0.02908758f, 0.00692771f, 0.01686899f, 
    0.04554456f, 0.03935114f, -0.03498424f, -0.00361243f, 0.00504853f, 0.00356327f, 0.02279333f, -0.03008167f, 
    -0.04443805f, -0.00129387f, -0.01152551f, 0.00270639f, 0.00094034f, 0.00341084f, -0.06189141f, -0.06006614f, 
    0.00800318f, 0.05247315f, -0.04078301f, -0.00576008f, 0.01814290f, 0.01968196f, 0.05007683f, -0.05846606f, 
    0.04105681f, -0.04570656f, 0.02397382f, 0.04725050f, 0.03966419f, -0.04986887f, 0.04999417f, -0.04070654f, 
    -0.00079797f, -0.04311309f, -0.05078480f, 0.03852490f, -0.06092378f, 0.01282319f, 0.03326399f, -0.00966578f, 
    -0.03889607f, -0.00714010f, -0.00831554f, 0.05881463f, 0.01701469f, -0.02315482f, -0.01996850f, -0.02896343f, 
    -0.06229318f, 0.01586687f, -0.05771394f, -0.04408640f, -0.05319964f, 0.04968261f, -0.03571720f, 0.02403867f, 
    -0.00305066f, 0.02774130f, -0.02369146f, 0.02002132f, 0.04229497f, -0.00165860f, 0.01157358f, 0.02632236f, 
    -0.06182338f, -0.03343914f, -0.02073917f, -0.02149741f, 0.00554354f, -0.03569663f, 0.00024180f, -0.00677299f, 
    -0.01268464f, -0.03438858f, 0.05202959f, 0.03769080f, -0.05147403f, -0.00992309f, 0.03078998f, -0.01580710f, 
    -0.02244981f, 0.03820223f, -0.04150496f, -0.04560435f, -0.04405328f, 0.03497980f, -0.01964066f, -0.05272432f, 
    -0.03549147f, -0.01034372f, 0.03378770f, -0.00698889f, -0.03370991f, 0.03598183f, -0.01574076f, -0.04714743f, 
    -0.01038528f, -0.02988174f, 0.03295980f, -0.05335368f, -0.04979921f, 0.00540534f, -0.03511216f, -0.03111259f, 
    0.01730984f, 0.01478073f, -0.03946282f, -0.05032919f, -0.06440386f, 0.04907112f, 0.04181516f, 0.03703463f, 
    -0.02063496f, 0.01296983f, -0.01609445f, -0.06295903f, -0.03280467f, -0.00077343f, 0.04024575f, -0.05524539f, 
    0.03457282f, -0.04072772f, -0.05373094f, 0.01582746f, 0.04782473f, 0.02970729f, 0.00783866f, -0.01445460f, 
    -0.05244363f, -0.06238333f, 0.04039415f, 0.03327036f, -0.02120294f, -0.04695969f, 0.01322366f, -0.04252520f, 
    0.01780251f, 0.00945703f, 0.01162375f, 0.03061770f, -0.02810383f, -0.01268670f, -0.03765347f, 0.01282082f, 
    0.02572087f, -0.03761074f, -0.02956115f, -0.01919260f, -0.05185314f, 0.03006406f, 0.01838183f, 0.03138674f, 
    0.02568740f, 0.00218385f, 0.02370409f, -0.05496645f, 0.05780126f, -0.05035336f, 0.03648481f, -0.03152190f, 
    -0.03849208f, -0.04875725f, -0.01456665f, 0.04238166f, 0.04356239f, 0.03750065f, -0.05381049f, -0.04500378f, 
    -0.01172176f, -0.03139748f, -0.00576053f, -0.05153934f, -0.04246665f, -0.00830298f, 0.02328730f, -0.01903962f, 
    -0.03116926f, 0.02620983f, -0.04708339f, 0.03304651f, 0.04690557f, -0.03453616f, 0.03993708f, -0.00623617f, 
    -0.02222217f, 0.04737119f, -0.05504584f, 0.04497730f, -0.05965459f, -0.00051186f, 0.02617881f, 0.04990200f, 
    -0.00786671f, -0.01392276f, 0.00203608f, -0.05304678f, -0.02017178f, -0.03365180f, -0.05692177f, 0.00841611f, 
    -0.03931863f, 0.01275541f, -0.04250069f, 0.02355339f, 0.02262941f, 0.04875228f, -0.04598258f, -0.01230618f, 
    0.05188251f, 0.00434297f, 0.00804125f, -0.03437420f, -0.00678378f, 0.01185098f, -0.00704589f, 0.03689136f, 
    0.04671511f, 0.03659476f, 0.01288804f, -0.05710250f, -0.04987763f, -0.05764300f, -0.01487823f, 0.04098042f, 
    -0.01412740f, 0.00818875f, 0.00743408f, 0.02375802f, 0.00755085f, -0.01503216f, -0.04005736f, 0.01307730f, 
    -0.02711653f, -0.03719177f, -0.03556499f, -0.03989184f, -0.04562455f, -0.01729191f, 0.04852990f, -0.00950071f, 
    0.02409859f, -0.03689272f, -0.02071033f, -0.04823992f, -0.03814789f, -0.06247269f, -0.03839421f, 0.00233301f, 
    0.01304184f, 0.03476019f, -0.05928724f, -0.03659378f, 0.03878184f, 0.01758465f, -0.03532311f, -0.06437716f, 
    0.02642360f, 0.03070438f, -0.03030724f, 0.02397934f, 0.01929375f, -0.02778623f, 0.02670292f, -0.01981469f, 
    0.01307933f, -0.00378700f, -0.00844879f, -0.00926810f, 0.01823090f, 0.05066348f, -0.05661097f, -0.04211504f, 
    0.04392165f, -0.03214022f, -0.03634864f, -0.04274692f, -0.01285337f, -0.02770215f, -0.05631210f, -0.02545626f, 
    -0.04132980f, 0.01200222f, -0.01731155f, -0.05948518f, -0.01257210f, 0.03998497f, -0.00274049f, -0.00707836f, 
    0.00950808f, 0.04757974f, 0.05046377f, -0.06074218f, 0.04731683f, 0.05047175f, 0.03100969f, -0.05236518f, 
    -0.03048222f, -0.02321523f, -0.01788547f, -0.01114181f, -0.02648721f, -0.02845715f, 0.00918095f, -0.01879733f, 
    0.00316775f, -0.04697379f, -0.03929913f, 0.02046847f, -0.03826578f, -0.03562820f, 0.02515669f, -0.02101410f, 
    -0.00735210f, -0.00006077f, 0.01868758f, -0.05053905f, 0.00241261f, -0.02860614f, -0.02141371f, 0.01705245f, 
    -0.04169425f, 0.02750635f, 0.02712208f, -0.00249090f, 0.00050215f, 0.03143845f, -0.03212274f, -0.02652014f, 
    0.00907950f, -0.00366408f, -0.00081280f, -0.03197144f, 0.01267471f, -0.00852895f, 0.00141086f, 0.03013450f, 
    0.00229032f, -0.01151564f, -0.01227444f, -0.03955939f, 0.00934105f, -0.03488538f, 0.04343548f, 0.01162158f, 
    0.04160674f, 0.01030943f, -0.02741196f, 0.05019060f, 0.03015572f, -0.04785559f, -0.02118569f, -0.04630558f, 
    0.01191862f, 0.01583580f, -0.00306098f, 0.05220692f, -0.01117294f, -0.01566252f, -0.04474987f, 0.04507803f, 
    -0.05527322f, 0.01279744f, 0.04746918f, 0.03238970f, -0.05402463f, -0.04406792f, 0.02855396f, -0.05641001f, 
    -0.01079648f, -0.02324503f, 0.01683558f, -0.03093052f, -0.05098130f, 0.00037117f, -0.04980173f, 0.05095292f, 
    -0.00574790f, -0.05280259f, -0.03865799f, -0.00516087f, -0.04654431f, -0.04445698f, -0.01083004f, 0.02262818f, 
    0.00866135f, -0.03288625f, 0.00933113f, 0.00522689f, 0.00549561f, -0.00719294f, 0.00447039f, -0.03193998f, 
    -0.00354344f, 0.11394969f, 0.24046277f, 0.01047493f, 0.04125660f, -0.19135779f, -0.02928401f, 0.00939494f, 
    0.17193788f, -0.15957999f, 0.11990220f, -0.01984351f, -0.09088720f, -0.01971199f, 0.07914323f, -0.04253007f, 
    0.05386733f, 0.08160975f, 0.05095597f, 0.23083991f, 0.25339767f, -0.14286445f, 0.00871170f, -0.11476712f, 
    0.02023001f, 0.02995628f, 0.05798906f, -0.20827144f, 0.02118874f, -0.02334073f, -0.02799136f, 0.14037959f, 
    0.02719751f, 0.06795339f, 0.05938620f, 0.09631886f, -0.13231818f, -0.48768502f, -0.05701165f, 0.06881790f, 
    0.07335509f, -0.10760993f, 0.00394982f, -0.20450391f, -0.01044108f, -0.28479484f, -0.16416699f, 0.04461474f, 
    0.03643645f, -0.02454421f, -0.22741815f, 0.13783473f, 0.15299010f, 0.07137061f, -0.13595815f, 0.14688943f, 
    0.16866994f, 0.00279152f, 0.03192598f, -0.01703564f, -0.02214723f, 0.04604064f, 0.05974568f, 0.00966676f, 
    -0.03729761f, 0.01435434f, -0.00777652f, 0.13259216f, -0.03513595f, 0.03184687f, 0.16458431f, 0.18599433f, 
    -0.23943138f, -0.08345067f, 0.13338795f, -0.24226119f, -0.15921974f, -0.07267614f, -0.01803391f, -0.02708845f, 
    0.00412473f, -0.10876860f, -0.19436409f, 0.09742930f, 0.05313058f, 0.13688442f, -0.00810275f, -0.19257680f, 
    -0.00643644f, 0.05253394f, -0.04788104f, -0.29332095f, -0.03783542f, 0.36850050f, 0.16909012f, 0.17076588f, 
    0.08856059f, 0.07589735f, 0.07266917f, -0.17191841f, -0.13963202f, -0.15270640f, -0.03265977f, 0.08813162f, 
    0.00387238f, 0.02038647f, -0.08435126f, 0.07815244f, -0.09352484f, 0.18973485f, 0.06731378f, 0.16922975f, 
    0.04283277f, 0.01892403f, 0.18818422f, -0.02658236f, -0.01277242f, -0.06447949f, -0.05069201f, -0.02333310f, 
    0.15011153f, -0.09341806f, 0.00116786f, -0.09222244f, 0.06469657f, 0.03235647f, 0.12938745f, -0.05820032f, 
    -0.08451600f, 0.10352506f, -0.02052107f, 0.15529589f, 0.26375985f, 0.02730599f, 0.01211018f, -0.17643902f, 
    0.17420618f, 0.03374950f, -0.11256305f, 0.11317008f, -0.00125750f, -0.08869576f, 0.08105515f, 0.17125145f, 
    -0.18619689f, 0.05200442f, 0.08025876f, 0.15762283f, -0.03361251f, -0.09909394f, 0.00766949f, 0.09709364f, 
    0.01338441f, -0.03745418f, -0.05471346f, 0.13618861f, -0.09695761f, 0.06677028f, -0.02267687f, -0.23615557f, 
    0.10404547f, -0.00072667f, -0.03705884f, -0.01145128f, 0.12853874f, 0.07822362f, 0.12630802f, 0.05297812f, 
    -0.07008952f, 0.07371258f, 0.22041120f, -0.07283056f, 0.06315594f, -0.11212625f, 0.04864489f, 0.06714955f, 
    -0.02162179f, 0.09383597f, 0.08709472f, 0.14314671f, -0.09546286f, 0.15454836f, 0.25686678f, -0.06651524f, 
    0.14010972f, 0.05788716f, 0.09745049f, -0.05170107f, 0.07228139f, -0.10507382f, -0.04870493f, -0.09187289f, 
    0.17029232f, -0.04698296f, 0.13258795f, 0.02646302f, -0.09835406f, 0.00578219f, -0.06559862f, 0.08448423f, 
    -0.00138064f, 0.22478716f, -0.02886559f, -0.01414026f, -0.03913602f, 0.03941996f, 0.19275342f, 0.06590055f, 
    0.17666100f, 0.29850915f, 0.06206272f, -0.06716531f, 0.02964388f, 0.03641555f, 0.02077743f, 0.01030202f, 
    -0.18580969f, -0.08292425f, 0.01355338f, 0.17192459f, 0.25836951f, 0.11496419f, 0.15542077f, -0.00672487f, 
    -0.04401339f, -0.15939976f, -0.05256827f, 0.09799167f, -0.06868671f, -0.06025653f, -0.07419908f, 0.03323872f, 
    -0.00741088f, 0.07566991f, -0.21377608f, -0.03067968f, 0.10303886f, -0.09996318f, 0.14949185f, -0.12701717f, 
    -0.00562266f, 0.05637218f, 0.05789917f, -0.02423705f, -0.12441956f, 0.00162394f, -0.06948908f, 0.03179608f, 
    0.03314546f, 0.21972135f, 0.00208911f, -0.03529130f, 0.03061154f, -0.01975564f, -0.07242172f, 0.13332699f, 
    0.03184412f, 0.05921283f, 0.15902650f, -0.12174059f, 0.10513220f, 0.04803168f, 0.02477521f, 0.13446808f, 
    -0.06038986f, 0.13833904f, 0.08108697f, 0.17530344f, -0.08902679f, 0.04031393f, -0.10278075f, -0.02286012f, 
    0.01307082f, 0.06124729f, -0.06995825f, -0.14244038f, 0.04122271f, 0.06455017f, 0.02625245f, -0.03220998f, 
    -0.15422711f, -0.14423664f, 0.13652121f, -0.09043519f, 0.00733061f, -0.00846172f, 0.02835487f, -0.09182330f, 
    0.04451568f, -0.06392276f, 0.19644293f, -0.26102984f, -0.00469692f, 0.02127208f, 0.15130156f, -0.03929285f, 
    0.03141531f, 0.21304604f, 0.03979108f, 0.15771407f, -0.13538325f, -0.00097322f, 0.02153488f, -0.05043648f, 
    0.32895073f, -0.07912056f, 0.04856819f, 0.23482606f, -0.06300310f, -0.01707644f, -0.05426582f, 0.13613424f, 
    0.05282168f, 0.00423363f, 0.13663524f, 0.33315489f, -0.25493425f, 0.11879677f, 0.02205659f, 0.01099787f, 
    0.10655302f, 0.07190664f, 0.06891687f, -0.04455801f, -0.45162526f, -0.16730632f, -0.00657034f, 0.17126882f, 
    -0.01135254f, -0.23542349f, 0.02278227f, -0.06601514f, 0.06213573f, 0.07648969f, 0.13263468f, -0.13185990f, 
    0.10706179f, 0.05827726f, 0.05478588f, 0.10620915f, -0.17070910f, 0.07055596f, -0.05371125f, -0.04725186f, 
    -0.09768289f, 0.09496535f, -0.02836680f, 0.04333574f, 0.05950293f, -0.08223352f, 0.04376154f, 0.07721394f, 
    0.13298768f, -0.16759942f, 0.13612522f, 0.04293411f, 0.17138822f, 0.05585456f, 0.14687751f, -0.00652571f, 
    -0.02536202f, -0.31437835f, -0.10042485f, -0.10404588f, -0.02348547f, -0.12930770f, -0.08292113f, -0.06854944f, 
    0.00370841f, -0.20784445f, -0.00850999f, -0.22756621f, 0.18844809f, 0.32841143f, 0.10493927f, -0.25747389f, 
    -0.15205471f, 0.14147304f, 0.18605775f, -0.04433586f, 0.03715628f, 0.15147930f, 0.09272859f, 0.09174278f, 
    -0.03731056f, 0.04693140f, 0.13091905f, 0.39022937f, -0.12890466f, 0.12713364f, -0.00328916f, 0.03304158f, 
    0.01237235f, -0.00604170f, 0.08666453f, 0.09511576f, -0.07295609f, -0.06640524f, 0.07331685f, 0.03352418f, 
    -0.03803064f, -0.09106494f, -0.10882936f, 0.09216882f, 0.07264052f, 0.09962153f, -0.02629522f, -0.11174002f, 
    0.19144471f, -0.06863888f, 0.11893228f, -0.07817748f, 0.07028323f, 0.25936109f, 0.12430311f, -0.26147899f, 
    -0.12879445f, 0.03526777f, -0.00699506f, -0.08930705f, -0.00315319f, 0.10697515f, -0.00793225f, 0.14254546f, 
    0.01379836f, -0.23617394f, 0.00573106f, 0.08939466f, 0.12763272f, 0.17533638f, 0.09151800f, 0.22898464f, 
    -0.01471115f, 0.12628058f, 0.14201720f, 0.02335003f, -0.08807603f, 0.01839011f, 0.01570556f, -0.09217692f, 
    0.18894981f, 0.00826179f, 0.01891563f, -0.13277246f, 0.15129599f, 0.04629378f, 0.16297197f, -0.10490720f, 
    0.09934264f, -0.05526714f, 0.05185710f, -0.04372989f, -0.27771994f, 0.00442314f, 0.02695707f, 0.28535610f, 
    -0.00437704f, 0.05374215f, -0.06439456f, -0.06212273f, 0.02038298f, 0.29349831f, 0.22826993f, 0.23923685f, 
    -0.02381577f, -0.05679613f, 0.05331131f, -0.03838724f, -0.17821711f, 0.22586530f, -0.10694884f, 0.06794618f, 
    0.04396260f, 0.17247605f, 0.02102432f, -0.00019002f, -0.18935467f, 0.17605333f, 0.21153569f, -0.04850989f, 
    0.06997789f, -0.06017604f, -0.08110662f, -0.05487525f, 0.04781555f, 0.03290001f, 0.20984520f, 0.19639178f, 
    -0.10917283f, 0.06798302f, 0.08811057f, 0.02697514f, 0.06498704f, 0.27343810f, 0.15772964f, 0.09007677f, 
    0.01877872f, 0.14511570f, -0.09268151f, 0.04082170f, -0.02614271f, -0.02860664f, 0.05805980f, 0.03748768f, 
    -0.13206644f, 0.00523909f, -0.16909033f, -0.07240804f, 0.07011730f, 0.28852317f, 0.11985045f, 0.02597678f, 
    0.05220491f, -0.16010621f, -0.05226060f, -0.46891189f, 0.15843055f, 0.01651212f, -0.23139028f, 0.02834390f, 
    0.20983151f, -0.17783585f, 0.06443337f, -0.21469465f, -0.10656524f, 0.00807861f, -0.04719283f, 0.05028286f, 
    -0.04560775f, -0.03443855f, 0.03114906f, 0.04958172f, 0.02732895f, 0.00252601f, -0.03447148f, 0.19791257f, 
    -0.26274031f, 0.01842003f, 0.00675609f, -0.01838944f, 0.07827605f, -0.21096542f, -0.04026382f, 0.03199044f, 
    -0.03579455f, -0.10854185f, 0.06748328f, 0.10646006f, -0.13912092f, -0.35931242f, -0.21191356f, 0.06079548f, 
    0.01127528f, 0.06659307f, -0.13577825f, 0.02582157f, -0.03778342f, 0.02758265f, 0.03128224f, -0.08014510f, 
    -0.11419901f, 0.08973711f, 0.07640480f, 0.09252930f, -0.12340832f, 0.17792578f, 0.13796383f, -0.05537489f, 
    0.16644596f, 0.12404102f, 0.12292883f, -0.03342046f, 0.15609339f, -0.02436703f, -0.10749064f, 0.00774234f, 
    0.02455837f, 0.00457532f, 0.00682363f, -0.06079882f, 0.02063171f, 0.04985731f, -0.05601690f, -0.02719560f, 
    -0.04157033f, -0.00752440f, -0.00999551f, -0.05098737f, 0.02939586f, 0.00224739f, -0.02305794f, -0.04021306f, 
    -0.01478343f, -0.02807685f, -0.05403168f, -0.05893410f, 0.03914935f, -0.01765252f, -0.04991092f, -0.02234801f, 
    -0.04558550f, -0.05945354f, -0.03902694f, 0.03795390f, -0.06271391f, 0.03587805f, -0.02622896f, -0.06207565f, 
    -0.00497678f, 0.00979932f, -0.02310792f, -0.05834859f, -0.06336232f, 0.05858016f, 0.04091812f, 0.02131788f, 
    0.00840755f, -0.04115872f, -0.02136467f, 0.04444031f, -0.00541779f, -0.04959124f, 0.00994527f, 0.01786127f, 
    -0.03628785f, 0.02126334f, 0.02625540f, -0.04299407f, 0.02517714f, -0.02152674f, 0.02821055f, 0.03299657f, 
    -0.03409959f, -0.05225171f, 0.03453702f, 0.02098762f, -0.04156962f, -0.01405444f, -0.06069357f, -0.06292717f, 
    -0.05454659f, -0.03637435f, -0.00151761f, -0.02839163f, 0.03819504f, -0.04261467f, -0.02029050f, 0.01961675f, 
    0.01023894f, -0.01244847f, 0.03225235f, -0.05717982f, 0.02871869f, 0.00679772f, -0.00321830f, -0.00162523f, 
    -0.05027352f, -0.02201555f, -0.01153184f, -0.04433140f, -0.02590602f, 0.03014040f, -0.03774874f, 0.01012548f, 
    0.04920554f, -0.04743639f, 0.04193513f, 0.02771653f, 0.04442160f, 0.05326848f, -0.02647277f, -0.04389957f, 
    -0.06145698f, 0.02963870f, -0.00822215f, -0.00106597f, 0.00012370f, 0.01648425f, -0.03154759f, 0.03792397f, 
    0.00148230f, -0.04928012f, -0.03034041f, -0.04266854f, -0.05290662f, -0.02317830f, -0.02657481f, -0.00734621f, 
    -0.03904219f, 0.01232722f, -0.01344557f, 0.02273898f, -0.05288858f, 0.02159414f, -0.00058833f, -0.03868670f, 
    -0.03351909f, 0.01057368f, -0.03511564f, -0.05133445f, 0.01646137f, 0.03197351f, -0.03299404f, 0.01047539f, 
    0.04985586f, -0.05513861f, 0.03954035f, -0.00337251f, 0.03815307f, -0.02947229f, 0.02238971f, 0.03891426f, 
    -0.03453803f, -0.03098548f, 0.00026871f, 0.00132047f, -0.06146152f, 0.01192783f, 0.03059339f, -0.03314920f, 
    0.01696251f, 0.02108175f, -0.06001781f, 0.03736272f, -0.02082890f, 0.03929691f, 0.00839144f, 0.01632833f, 
    -0.03201247f, -0.05866375f, -0.00142797f, -0.04076437f, -0.03623888f, 0.02993682f, -0.02982583f, -0.00213116f, 
    -0.05779691f, -0.02764869f, -0.02837666f, 0.03163984f, -0.01939416f, -0.00995216f, 0.01277609f, 0.04189411f, 
    -0.02056746f, -0.04756423f, -0.00410942f, 0.01032453f, 0.03147978f, 0.02691564f, -0.02995127f, -0.04482431f, 
    -0.03878965f, 0.03085902f, 0.05362400f, -0.04650148f, 0.04945258f, 0.02310457f, -0.04544430f, -0.05184465f, 
    0.01030726f, -0.03437917f, -0.05388710f, 0.04037082f, -0.00251503f, 0.03343739f, -0.01523728f, 0.03886156f, 
    0.04867171f, 0.03901028f, 0.00771993f, -0.04971253f, 0.03780904f, -0.06388720f, -0.05046599f, 0.04509826f, 
    -0.01908905f, -0.02865936f, -0.06201756f, 0.03428254f, -0.05770817f, -0.03463733f, -0.01804339f, -0.01742497f, 
    -0.00769925f, 0.00155320f, -0.05253439f, -0.02141779f, -0.02875677f, 0.01100160f, -0.04419370f, 0.05078900f, 
    -0.04590708f, -0.01461701f, 0.05095052f, -0.02001706f, 0.02179013f, -0.01301207f, -0.00115073f, 0.02322439f, 
    0.03739239f, 0.00814389f, -0.02786150f, -0.01098552f, -0.02340156f, -0.05871182f, -0.01048376f, -0.01373537f, 
    0.03704069f, 0.03670399f, -0.02386386f, -0.02404133f, -0.02850196f, 0.03720352f, -0.04664646f, -0.05297451f, 
    -0.05812546f, -0.05457781f, -0.00718020f, 0.03959925f, 0.04194180f, -0.03618995f, -0.01117171f, 0.00332790f, 
    0.00402444f, 0.00281992f, -0.03823330f, 0.02079686f, -0.03972435f, 0.03130997f, 0.03051223f, -0.04938449f, 
    0.02400912f, 0.00846762f, 0.03322625f, 0.05054910f, -0.05219166f, -0.03574529f, 0.00936470f, -0.01235538f, 
    -0.05705167f, 0.01267382f, 0.00313453f, -0.02082589f, -0.04224084f, 0.02836872f, 0.00593142f, -0.01809158f, 
    0.01334638f, 0.01870235f, 0.03473267f, -0.03158079f, -0.02609194f, -0.01568034f, 0.02055324f, 0.04949465f, 
    -0.05736353f, -0.00300264f, 0.04742025f, 0.05139197f, -0.00822024f, 0.00772991f, -0.00393002f, -0.00449011f, 
    0.37570384f, 0.15488662f, -0.02038015f, 0.01631382f, 0.02130038f, -0.10784206f, 0.01351550f, 0.03398976f, 
    0.08903021f, 0.40949985f, -0.21804182f, 0.00694157f, 0.07639948f, 0.00634187f, -0.10311698f, 0.01918940f, 
    0.11093860f, 0.07623041f, 0.21972492f, 0.01813461f, 0.00381750f, 0.07960167f, 0.01887836f, 0.02418561f, 
    -0.08448058f, -0.02629592f, 0.04205773f, -0.10511712f, -0.00082483f, 0.01306158f, 0.06431558f, -0.10449349f, 
    -0.01518344f, -0.02620884f, 0.05659813f, -0.04138676f, -0.15185824f, 0.03766522f, 0.14530818f, 0.10951817f, 
    -0.07819173f, -0.08517007f, 0.03365701f, 0.12060061f, 0.11564332f, 0.36760017f, 0.02597411f, -0.07009194f, 
    0.04958466f, -0.03544246f, -0.05266951f, 0.22902584f, -0.20161854f, 0.12098280f, 0.18635486f, 0.00632912f, 
    -0.06508096f, 0.15710941f, -0.06496643f, 0.02842787f, 0.08702842f, -0.03254868f, 0.01183694f, 0.06606273f, 
    -0.16474089f, 0.02470793f, 0.11642396f, 0.19615375f, 0.00134874f, -0.06319306f, -0.03968008f, 0.08962766f, 
    0.17285755f, 0.12265879f, -0.13822921f, 0.12885307f, -0.11185919f, 0.09069020f, 0.09909719f, -0.11426579f, 
    -0.02342997f, -0.17032091f, 0.14676373f, -0.28176686f, -0.09611415f, -0.03426471f, 0.15774986f, 0.02896707f, 
    -0.11801868f, -0.25937727f, 0.15794611f, 0.02162829f, -0.16538319f, 0.00691243f, 0.02226739f, 0.18462530f, 
    -0.01439485f, 0.03678558f, -0.00170893f, -0.24679682f, 0.14931040f, -0.09149799f, 0.01764073f, 0.05713120f, 
    0.09212627f, -0.05469289f, 0.08920121f, 0.03304645f, -0.09204839f, 0.07156319f, -0.11914466f, 0.16408017f, 
    -0.07893264f, -0.08342349f, 0.02065814f, 0.03205122f, 0.03118990f, 0.02451957f, 0.01952631f, -0.14508760f, 
    0.10947295f, 0.08828782f, -0.05752813f, -0.05345418f, -0.12409047f, -0.04170924f, -0.36667126f, -0.07544429f, 
    0.02786131f, -0.05808059f, 0.13673140f, 0.01694648f, -0.04926106f, -0.09755760f, -0.09570392f, 0.09027441f, 
    0.32479179f, -0.10945204f, 0.09357620f, -0.05940597f, 0.09916332f, 0.07593900f, -0.04507032f, 0.02474112f, 
    0.05504750f, 0.03443503f, 0.18432577f, 0.16611011f, 0.04129849f, -0.05007356f, -0.00128356f, 0.09282023f, 
    0.11832470f, -0.03991823f, 0.06569321f, -0.29654688f, 0.03317308f, 0.07839748f, 0.08699185f, -0.18514749f, 
    -0.00905680f, -0.05938511f, -0.00806903f, 0.04349856f, -0.20450078f, -0.07496666f, -0.08898275f, 0.08910085f, 
    0.06722527f, 0.03280701f, -0.12143497f, -0.10717485f, -0.04841170f, 0.19301806f, 0.00500037f, 0.06174176f, 
    0.02990089f, -0.13974835f, 0.12177182f, 0.06934252f, 0.11062694f, -0.00777966f, -0.26742262f, 0.03839080f, 
    0.02615776f, -0.00652457f, -0.04608709f, 0.08551752f, -0.08731069f, -0.20438693f, 0.34557998f, 0.01313270f, 
    -0.10455333f, -0.07545804f, 0.05715157f, 0.00555781f, 0.05365930f, -0.03301144f, 0.08061152f, 0.14878887f, 
    -0.16510123f, -0.12442808f, 0.02241110f, -0.04174905f, -0.01407018f, 0.08489304f, 0.00999864f, 0.21785815f, 
    0.11156441f, -0.02452676f, 0.01751125f, 0.01908951f, -0.07733873f, -0.03615909f, 0.04046154f, 0.05108150f, 
    -0.10098060f, 0.05883327f, -0.06791007f, -0.12872379f, 0.04573582f, 0.08563428f, 0.05718582f, -0.12650369f, 
    0.06177152f, 0.13883941f, 0.00253920f, 0.00335297f, -0.02275891f, -0.11059215f, -0.08660308f, -0.04475528f, 
    -0.06487966f, -0.01346483f, 0.19599430f, -0.06335848f, 0.00088740f, 0.14074920f, -0.09905506f, -0.01527022f, 
    0.10584006f, 0.02777482f, 0.06767660f, -0.34765700f, 0.03677006f, 0.06394114f, 0.05474880f, -0.02283063f, 
    0.00813329f, -0.12119428f, 0.14626375f, -0.15805182f, -0.39425337f, 0.04042446f, 0.17486246f, -0.06249933f, 
    -0.00069927f, -0.12902141f, -0.16651884f, 0.07917417f, -0.07025881f, -0.31519538f, -0.12979281f, 0.03884177f, 
    -0.18609031f, 0.02935716f, 0.00788099f, -0.08998329f, 0.19859594f, -0.08484567f, -0.12858629f, 0.04793685f, 
    -0.07420772f, -0.11876532f, -0.09415103f, 0.13283050f, -0.01225918f, 0.03508095f, -0.19320136f, -0.11510589f, 
    0.00672767f, 0.04043059f, -0.14811200f, 0.02057102f, 0.03858802f, 0.00005645f, 0.06406316f, 0.01757970f, 
    0.03319266f, 0.00341987f, 0.04613826f, -0.00923713f, 0.04656497f, -0.03217761f, -0.01717753f, -0.00355866f, 
    0.00306854f, -0.04297031f, -0.06422502f, 0.00496782f, -0.01752526f, -0.03675151f, -0.00876893f, -0.04095264f, 
    -0.02870138f, -0.04627447f, -0.00771995f, -0.01547062f, -0.03350654f, -0.00140727f, -0.05320580f, 0.04818874f, 
    0.02442774f, 0.04747885f, 0.01490173f, -0.02170876f, 0.04354747f, 0.02150819f, -0.04152714f, -0.02972913f, 
    -0.01237026f, 0.02343037f, -0.04095334f, 0.03816281f, 0.00380912f, -0.03551270f, -0.00132778f, -0.05338163f, 
    -0.01094280f, 0.01400778f, 0.03986136f, 0.00970033f, 0.00260960f, -0.06024544f, 0.02758466f, -0.03415836f, 
    -0.04944998f, -0.05313646f, -0.01564514f, -0.06569350f, -0.03434176f, -0.00353370f, 0.01269863f, -0.05497521f, 
    -0.01186121f, 0.02432150f, -0.03458512f, -0.05480048f, 0.04694427f, 0.03433203f, 0.02506919f, 0.03326391f, 
    0.02316866f, 0.03862938f, -0.05389983f, -0.05979545f, -0.01451481f, -0.05249193f, 0.02993705f, -0.05247322f, 
    -0.05432485f, -0.00112212f, -0.03234588f, -0.01347451f, 0.01851675f, -0.01769497f, -0.04231910f, -0.04180326f, 
    -0.00572932f, -0.03324711f, -0.05131934f, -0.00298951f, 0.01948775f, -0.00400411f, 0.04277889f, 0.00385556f, 
    0.02820031f, 0.02024265f, -0.05601123f, 0.03826991f, -0.00641032f, -0.06045113f, 0.02950681f, -0.00933005f, 
    0.03106813f, -0.00391398f, 0.04860589f, -0.01829354f, -0.05716562f, 0.02416118f, 0.04508447f, -0.03690929f, 
    0.02314183f, -0.02236601f, 0.01385913f, 0.02806502f, 0.01474927f, -0.02473414f, -0.00673921f, -0.00032110f, 
    0.01894622f, -0.00947540f, -0.00273569f, 0.03170692f, 0.00711279f, -0.01542279f, -0.06753420f, -0.03540917f, 
    0.04036987f, 0.03351167f, 0.00217154f, 0.01142338f, 0.04757305f, 0.00305832f, -0.06220522f, -0.00539792f, 
    0.00768876f, -0.05053214f, 0.03304192f, -0.06529247f, -0.03988243f, -0.04392762f, -0.01346266f, 0.04540877f, 
    0.01694826f, -0.05481480f, -0.04710845f, -0.04070745f, 0.04500243f, 0.01171103f, 0.00039751f, -0.05942047f, 
    -0.05586689f, -0.06115370f, 0.02224748f, 0.01117905f, -0.05677691f, -0.03737816f, 0.01280218f, -0.04427984f, 
    -0.02363379f, -0.01889259f, -0.04913469f, -0.03459404f, -0.04170194f, 0.02052922f, -0.06284896f, -0.00427853f, 
    -0.00434887f, -0.06279449f, 0.04975443f, -0.02789776f, -0.02175364f, -0.05684773f, -0.03120224f, -0.02462288f, 
    -0.02162175f, -0.01508571f, 0.00119199f, -0.03042409f, 0.01741362f, 0.04234929f, -0.00349992f, -0.01983958f, 
    0.00248582f, -0.06778118f, -0.05378430f, 0.00744229f, -0.03409725f, 0.02196828f, -0.05167657f, 0.01598267f, 
    -0.00886270f, 0.03998953f, -0.06163100f, 0.04867103f, 0.02905347f, 0.02086854f, 0.05130025f, 0.02667044f, 
    0.00591288f, 0.04477365f, 0.03626367f, 0.00931532f, 0.04092173f, 0.00335652f, 0.05677703f, -0.03966175f, 
    -0.03073022f, 0.01119426f, -0.00685908f, -0.05171057f, -0.02441563f, -0.04088682f, -0.00193308f, -0.04417901f, 
    0.02877772f, -0.03053156f, 0.00130666f, -0.01796487f, 0.02290446f, -0.05456140f, 0.02979252f, -0.02321290f, 
    0.01262592f, 0.04305857f, 0.03719622f, -0.00850128f, -0.04118076f, 0.02168164f, 0.05043705f, -0.03658266f, 
    -0.01354320f, 0.01442760f, -0.03857768f, 0.00480882f, -0.04647712f, -0.01514663f, -0.03374263f, 0.03018568f, 
    -0.06187614f, -0.05469660f, 0.00711034f, 0.03939478f, 0.01666811f, 0.04092301f, -0.05638393f, 0.00807012f, 
    -0.00412292f, -0.06684483f, -0.01062002f, -0.03045340f, 0.03443639f, 0.01452732f, -0.04844039f, 0.00594566f, 
    -0.02408484f, -0.06123733f, -0.06600355f, -0.04982185f, 0.02544901f, -0.04978554f, -0.04779128f, -0.02444334f, 
    0.04568867f, 0.01711726f, -0.05373676f, 0.03621696f, 0.03071096f, 0.03887861f, -0.01742042f, 0.00237147f, 
    -0.01305389f, -0.03668021f, 0.01566523f, -0.05225754f, -0.02384873f, 0.03754601f, -0.06260604f, -0.01660364f, 
    0.01274875f, -0.02568376f, 0.03485156f, -0.01378669f, 0.00656593f, -0.03050861f, -0.02195876f, -0.00290780f, 
    -0.00706733f, -0.03345550f, 0.01253692f, -0.03150241f, -0.04779981f, 0.03537942f, -0.04992278f, 0.00275704f, 
    0.07513198f, 0.15146950f, 0.09642028f, -0.07731506f, -0.07128708f, -0.03264049f, -0.06915379f, -0.02004125f, 
    0.03019702f, -0.12519167f, -0.04782618f, 0.11165503f, 0.07693972f, 0.11788709f, 0.09150102f, -0.02594755f, 
    -0.20529693f, 0.07442475f, 0.17430262f, 0.11297478f, 0.14730375f, 0.02249889f, -0.14137551f, -0.08689123f, 
    0.09927974f, -0.15937868f, -0.08195385f, -0.18476197f, -0.05449443f, 0.08579485f, 0.04182943f, -0.07295555f, 
    -0.11253431f, -0.25969025f, -0.06395380f, 0.01734204f, 0.56989825f, -0.25232542f, -0.25758642f, -0.19203606f, 
    0.00029622f, -0.09459546f, 0.19066527f, -0.08044261f, 0.04089083f, -0.09013228f, 0.02806404f, 0.15984835f, 
    -0.19123413f, 0.30674753f, 0.05927930f, -0.08618291f, -0.08803445f, 0.02869993f, 0.12959267f, 0.27483958f, 
    0.04655051f, -0.15813224f, -0.06358138f, -0.18828115f, -0.06475810f, 0.07964740f, -0.02071442f, -0.03244269f, 
    -0.18282722f, 0.03616170f, -0.09841790f, -0.08062662f, -0.06031923f, 0.05601386f, -0.05530037f, 0.14176331f, 
    -0.09055556f, 0.32759047f, 0.06331605f, -0.22626446f, -0.19149800f, -0.15349218f, -0.18701272f, -0.05643900f, 
    0.05417745f, 0.24501875f, 0.13645649f, -0.09805629f, 0.08283500f, -0.09635805f, -0.11492700f, -0.04136456f, 
    0.24446069f, 0.13095488f, 0.07889887f, -0.05245222f, -0.27689871f, 0.09650120f, 0.06288536f, 0.01216120f, 
    0.18634574f, -0.08351295f, 0.01215312f, -0.13099521f, -0.09413280f, -0.22612908f, 0.15026860f, 0.01389085f, 
    -0.06365824f, 0.09622005f, -0.16033113f, 0.08934354f, -0.08930902f, 0.13542801f, 0.15815543f, -0.10743286f, 
    -0.11025704f, 0.11308310f, -0.07686711f, -0.10563007f, -0.11671190f, -0.01531810f, -0.06330961f, -0.00386792f, 
    0.20488039f, 0.04566908f, -0.10470109f, 0.01186139f, -0.13957824f, 0.11985730f, 0.13096957f, 0.10252993f, 
    -0.07438932f, 0.20628858f, 0.12377913f, 0.17790218f, -0.08772399f, -0.00871431f, 0.10566384f, 0.01092877f, 
    0.07289255f, 0.03288215f, -0.18053687f, -0.08892104f, -0.06931031f, -0.04424763f, -0.03128230f, -0.08713463f, 
    0.13306405f, 0.11074162f, -0.13470335f, -0.10109910f, -0.06479011f, 0.06445391f, -0.24733002f, -0.04079089f, 
    -0.09395058f, 0.33876950f, 0.12936354f, -0.43559402f, -0.17047648f, -0.00710212f, 0.13702041f, -0.15866007f, 
    0.04106177f, -0.00421297f, -0.00195264f, 0.08020265f, -0.21478702f, 0.11109800f, 0.13404667f, 0.00034131f, 
    -0.05639135f, 0.08254700f, 0.07635204f, 0.49093214f, 0.04909478f, -0.38749295f, -0.10888746f, -0.03849884f, 
    0.19076896f, 0.08717782f, -0.02971005f, -0.16454145f, 0.12643158f, 0.20809214f, 0.03020772f, -0.21677893f, 
    -0.15966660f, -0.03543605f, -0.00090763f, 0.21747471f, 0.04092256f, 0.00372149f, -0.10813484f, -0.17077386f, 
    0.11727226f, 0.18454623f, 0.04393715f, -0.02773412f, -0.03781185f, -0.00160071f, -0.11933083f, 0.12077071f, 
    -0.14297728f, 0.26578560f, 0.09237916f, -0.01049657f, 0.10605329f, -0.18342252f, 0.11197314f, -0.05352446f, 
    0.13744947f, 0.18841012f, 0.00686186f, 0.03087429f, -0.06716543f, -0.00192521f, -0.04446209f, -0.07118332f, 
    0.11236653f, -0.18624087f, 0.09702784f, -0.01977255f, -0.11524269f, -0.10243093f, 0.17236559f, 0.06195753f, 
    0.25657612f, 0.16249186f, -0.26191899f, 0.13360082f, -0.20547856f, 0.03152950f, -0.11374654f, 0.12484281f, 
    0.00660126f, 0.13701504f, -0.11014489f, -0.07940549f, 0.28379735f, -0.12323119f, 0.04205993f, -0.06300166f, 
    0.02338382f, -0.08342361f, 0.14598800f, 0.33764693f, -0.23224014f, 0.01804948f, 0.00681977f, 0.21957445f, 
    0.11950097f, -0.00676738f, -0.00565437f, -0.16113389f, 0.43162391f, 0.01671186f, -0.13643509f, 0.06767610f, 
    0.05647751f, 0.12362903f, -0.15618373f, 0.00515370f, 0.04643007f, 0.31674477f, -0.26495403f, 0.03306818f, 
    0.04683649f, 0.07617505f, 0.11565001f, -0.18107419f, -0.13190186f, -0.09339482f, 0.16626810f, -0.06550279f, 
    -0.13170703f, 0.29002145f, -0.10073877f, 0.08495747f, 0.10600235f, 0.02520103f, -0.03724333f, 0.15014887f, 
    -0.13367626f, -0.16020080f, 0.17941517f, 0.00630982f, 0.00461411f, -0.06358720f, -0.01721821f, -0.15659036f, 
    0.49031645f, -0.06068671f, -0.09314959f, -0.02233689f, -0.06776445f, -0.14798887f, -0.01955838f, 0.13770550f, 
    0.00165102f, 0.39498010f, -0.25732112f, -0.22990711f, 0.02000712f, 0.01570572f, 0.03360194f, 0.21013968f, 
    0.14770496f, 0.14277676f, 0.02349213f, 0.24758624f, -0.15310109f, 0.03336315f, 0.00859883f, -0.02491585f, 
    0.15398863f, -0.06570117f, 0.26787010f, -0.01208511f, 0.20058833f, -0.22428511f, -0.04004506f, 0.11178655f, 
    0.20318407f, -0.19022530f, -0.00055172f, -0.00294014f, -0.05833776f, -0.07259877f, 0.00474000f, 0.17988363f, 
    -0.06702106f, 0.14481626f, 0.13073139f, -0.02564020f, 0.03484960f, 0.03051574f, -0.04494444f, -0.27622283f, 
    -0.04073669f, 0.06248458f, -0.05480605f, 0.13381204f, -0.01702345f, -0.10559511f, 0.27894369f, 0.12023795f, 
    -0.13540584f, -0.13427913f, -0.06318051f, -0.06539048f, 0.25332615f, -0.09563592f, -0.06094167f, -0.05586061f, 
    -0.10626319f, -0.07192463f, -0.14086020f, 0.06796306f, 0.03308148f, -0.05982495f, -0.03083681f, -0.03197047f, 
    0.55669886f, -0.01398216f, -0.05673421f, 0.06171143f, 0.06836110f, 0.12527703f, 0.17046811f, -0.11021602f, 
    0.05657140f, 0.21627055f, 0.39564046f, -0.00617338f, -0.05935989f, -0.30620664f, -0.10662492f, 0.07452153f, 
    0.19019119f, 0.14570765f, -0.39440683f, 0.26425245f, -0.09985845f, 0.02219201f, 0.02137339f, -0.09751971f, 
    0.10380096f, 0.13758196f, 0.09561380f, -0.37930775f, 0.10258278f, 0.13264695f, 0.07454920f, -0.09551010f, 
    -0.12111215f, 0.06543241f, 0.08828308f, 0.03417142f, -0.09870762f, -0.09427961f, -0.17628966f, 0.02302053f, 
    0.14553814f, 0.04978231f, -0.01416096f, -0.05244655f, 0.14937641f, 0.24937995f, -0.28773424f, 0.13095501f, 
    0.04882840f, -0.03074144f, -0.06802220f, 0.26718172f, 0.01230154f, -0.01132124f, 0.02981988f, 0.06875256f, 
    0.10411406f, 0.07686912f, 0.09013485f, -0.05243526f, -0.11378873f, -0.01995128f, 0.22387895f, 0.09382394f, 
    0.15605395f, -0.26856121f, 0.05980472f, -0.01068856f, 0.12752041f, 0.03188135f, -0.14142355f, 0.13972594f, 
    -0.04177038f, -0.26640561f, -0.15631719f, 0.06123123f, 0.03980764f, 0.05539833f, -0.01408270f, -0.11130365f, 
    -0.20838888f, -0.29988876f, -0.00231881f, -0.21048890f, 0.14190361f, 0.03546351f, -0.04611015f, -0.05767952f, 
    0.08727084f, -0.05541918f, 0.12558725f, 0.12713456f, -0.22227217f, 0.05198518f, 0.00582007f, 0.04365570f, 
    0.06360713f, 0.01365095f, -0.01811732f, -0.34543389f, -0.38048434f, -0.16136503f, 0.15803179f, 0.11637664f, 
    0.04603202f, -0.08987171f, -0.02437349f, -0.07124386f, 0.24154128f, -0.05772875f, -0.14104640f, 0.08438671f, 
    -0.04156588f, -0.03030844f, 0.04019801f, 0.09543376f, 0.01311509f, 0.42058742f, 0.08235790f, 0.04571490f, 
    0.10344644f, 0.18701696f, 0.15285523f, 0.02265548f, 0.24715799f, 0.07794547f, 0.54699069f, 0.20887259f, 
    0.20126274f, -0.02784986f, 0.05579198f, 0.01620091f, 0.02499704f, 0.07013880f, 0.17485479f, 0.25539902f, 
    -0.21536961f, -0.21094725f, 0.17851341f, -0.03160726f, 0.00858765f, 0.00676055f, -0.03894277f, 0.04589614f, 
    -0.02357890f, -0.11739648f, -0.02096191f, -0.09275245f, 0.07523368f, -0.12253641f, 0.05363996f, -0.33173713f, 
    0.21436383f, -0.29655114f, 0.27762538f, -0.26902828f, 0.12379897f, 0.09298661f, -0.08666765f, 0.14528392f, 
    0.10594100f, 0.18617746f, 0.37515026f, 0.47720262f, -0.17153236f, 0.20726295f, -0.00339576f, 0.00644128f, 
    0.00778339f, 0.10975574f, -0.06870434f, -0.19875088f, 0.15038523f, 0.21492946f, 0.03252259f, 0.09390080f, 
    -0.05097853f, -0.10238053f, 0.10486359f, 0.16166550f, 0.04044315f, 0.08482429f, -0.00136956f, -0.05116227f, 
    0.06895137f, 0.05746386f, -0.15899809f, -0.09634812f, 0.15263361f, -0.20720546f, -0.08973164f, -0.27013335f, 
    0.13075282f, 0.06521392f, 0.23970844f, -0.03498873f, -0.02165698f, 0.25579622f, -0.13960703f, 0.04007985f, 
    -0.22619547f, -0.09191179f, 0.04010743f, 0.07248324f, -0.01459080f, 0.09320836f, 0.05348875f, -0.19255686f, 
    -0.06669793f, 0.05337893f, 0.08490393f, 0.24689278f, 0.23951730f, 0.08556287f, 0.23573178f, 0.08950442f, 
    0.11623909f, -0.10849535f, 0.15400219f, 0.09381080f, 0.00389304f, -0.01811549f, 0.02309001f, -0.13619970f, 
    0.06599861f, 0.02273797f, -0.25416258f, 0.10807871f, 0.07918415f, -0.13987754f, 0.01879359f, 0.05184726f, 
    0.01986730f, 0.15270139f, -0.17484644f, -0.12040197f, 0.03405233f, -0.00284961f, -0.11853228f, -0.16785993f, 
    0.09734198f, -0.08059388f, -0.05120248f, 0.22858983f, -0.38961220f, -0.06623762f, -0.08676673f, -0.10179763f, 
    -0.04983729f, 0.04009714f, 0.12651385f, 0.01470746f, 0.11115886f, -0.09555778f, -0.03175023f, 0.09103765f, 
    -0.02137579f, 0.11286496f, -0.02332830f, 0.07383946f, 0.25263792f, -0.37328690f, -0.16882449f, 0.04326898f, 
    0.23146711f, -0.08373027f, -0.07684024f, -0.10845302f, -0.09796687f, 0.06250436f, -0.20574376f, -0.14702451f, 
    0.06495179f, 0.08338951f, -0.00452518f, -0.00919580f, 0.07721511f, 0.03182762f, -0.04417120f, -0.11559032f, 
    -0.20530903f, -0.14279598f, -0.15324876f, 0.00297192f, 0.09449088f, 0.03132519f, 0.04138911f, 0.07875530f, 
    0.25688019f, -0.38020930f, 0.05144426f, 0.02748924f, 0.03967967f, -0.00203967f, -0.06599443f, -0.03434213f, 
    0.14304885f, 0.20793632f, -0.14016877f, -0.31668434f, 0.07024322f, 0.02014786f, 0.11872489f, 0.04981089f, 
    -0.12005667f, -0.05710833f, -0.15744907f, 0.27341598f, -0.19450875f, 0.04120311f, -0.02649067f, -0.11674821f, 
    -0.12944147f, -0.04169034f, 0.10910639f, 0.00717162f, 0.13958088f, 0.05361694f, 0.04931052f, -0.00551421f, 
    -0.10039333f, -0.05387639f, -0.08932820f, 0.16558611f, -0.10679723f, -0.06545450f, -0.02213872f, 0.01863497f, 
    -0.08770881f, -0.15385261f, -0.12149519f, 0.10396891f, -0.05084290f, 0.32557350f, -0.04300374f, 0.17531244f, 
    -0.01523216f, -0.03064339f, -0.02990401f, -0.03381418f, 0.00524707f, 0.13050105f, -0.11315700f, 0.06795103f, 
    0.02729671f, -0.03402579f, 0.03983159f, -0.01568258f, -0.11916441f, -0.06791691f, -0.15069462f, -0.09025218f, 
    -0.40654084f, -0.03583128f, 0.04159214f, -0.04510197f, 0.07260154f, 0.04923807f, -0.02200167f, 0.08385427f, 
    0.08665407f, 0.13336551f, 0.00570415f, 0.01119296f, -0.00742547f, 0.06601002f, 0.01529020f, 0.07079936f, 
    -0.06819668f, 0.25336942f, 0.08555009f, -0.18145443f, 0.10591278f, 0.09468158f, 0.04194712f, -0.03989131f, 
    -0.04549457f, 0.07212714f, 0.08420787f, -0.13622445f, -0.20738102f, 0.05055664f, -0.05474064f, 0.12099207f, 
    0.00731639f, 0.11248960f, 0.01851331f, 0.33723754f, 0.11556124f, 0.08448307f, -0.06073384f, -0.00441176f, 
    -0.11593922f, 0.06759012f, 0.05243675f, -0.09256390f, -0.29655612f, 0.02868736f, -0.09649637f, 0.08671536f, 
    -0.07111857f, -0.01125072f, 0.16644715f, -0.19684942f, -0.06909908f, -0.11469120f, 0.25723150f, 0.07647212f, 
    -0.11023928f, 0.05681697f, -0.05688367f, 0.03257762f, -0.05908566f, 0.00739796f, -0.29261079f, 0.29745945f, 
    -0.04851984f, 0.17737107f, 0.02262957f, 0.03799210f, 0.03949663f, 0.01021863f, -0.02273852f, 0.14487363f, 
    0.06412376f, -0.03074854f, 0.14688839f, 0.07325367f, -0.10910701f, 0.00689018f, 0.00557904f, 0.03085607f, 
    -0.24665946f, -0.21149221f, -0.22232388f, 0.07763428f, -0.03935763f, 0.07857038f, -0.04744877f, -0.01962077f, 
    0.04026939f, -0.45842156f, 0.13687488f, -0.16559683f, -0.04251118f, -0.17625366f, 0.02923904f, 0.06588816f, 
    0.01346822f, -0.00749015f, 0.35551158f, -0.17396957f, 0.09670497f, 0.06971946f, 0.09024525f, -0.25764680f, 
    0.04804850f, 0.06756442f, -0.04418693f, 0.00270844f, 0.15577507f, 0.10729595f, -0.09244644f, 0.07857665f, 
    -0.04468481f, 0.02488884f, 0.05375841f, -0.07623453f, -0.21849659f, -0.01626905f, 0.10941821f, -0.03360319f, 
    -0.07910158f, -0.04330945f, -0.01352743f, -0.01559574f, -0.03994713f, -0.15007307f, -0.06665940f, 0.16878584f, 
    -0.12083163f, -0.04797089f, -0.02937518f, 0.07843397f, 0.10352807f, -0.02410369f, -0.35592753f, 0.02064577f, 
    -0.19198878f, 0.04840536f, -0.15887527f, 0.01559866f, -0.15184176f, 0.16942886f, 0.04350977f, -0.25654492f, 
    0.21108235f, 0.02729552f, -0.07484310f, 0.00805547f, -0.06222057f, -0.03396881f, 0.07981962f, -0.01685957f, 
    0.31530920f, 0.09877859f, 0.19397609f, 0.12092745f, 0.04755254f, 0.00389421f, -0.03218152f, 0.18534845f, 
    -0.01601149f, 0.08573982f, 0.11143407f, 0.09299920f, 0.05693784f, 0.09989024f, -0.04334522f, 0.00806772f, 
    0.23334837f, 0.02058135f, 0.22195965f, 0.06797933f, 0.18834662f, 0.04769984f, 0.13968134f, -0.06040923f, 
    -0.22955775f, 0.03376766f, 0.03432940f, -0.12888590f, -0.25532928f, 0.29432508f, 0.03562685f, 0.04351047f, 
    0.00221403f, 0.12026383f, -0.02217326f, -0.00383559f, 0.07218096f, 0.10345297f, -0.07608825f, 0.00034617f, 
    -0.06788717f, -0.08952179f, 0.01553782f, -0.06236627f, -0.00685314f, 0.23901592f, 0.17956010f, -0.00598446f, 
    0.00607207f, 0.10726084f, -0.10237878f, 0.12510800f, 0.03303662f, -0.01051212f, 0.29909053f, 0.04849932f, 
    -0.03616881f, 0.04768509f, 0.06064206f, 0.04370327f, 0.08822492f, 0.04251426f, 0.03308914f, -0.17797369f, 
    -0.02433906f, 0.14822680f, 0.02229107f, -0.07976032f, -0.05003263f, 0.23103473f, 0.00871668f, 0.11776290f, 
    0.27261919f, -0.07842495f, 0.01266808f, -0.06117676f, -0.12262642f, -0.04076240f, 0.09509111f, -0.05973631f, 
    0.00128239f, -0.16552512f, 0.00566721f, -0.17044623f, 0.03088198f, -0.12118872f, -0.10745316f, -0.08374164f, 
    -0.00878600f, -0.01404852f, -0.15963168f, 0.01918937f, -0.26535165f, 0.06348053f, 0.04274265f, -0.11721151f, 
    -0.10361034f, 0.15263478f, 0.06939980f, 0.02066335f, -0.02077140f, -0.07586123f, -0.00012970f, 0.08346277f, 
    -0.05772855f, 0.02581774f, 0.08451103f, -0.16368467f, 0.07669811f, 0.09284804f, 0.10544076f, 0.06129451f, 
    0.04020831f, -0.05450493f, 0.01444476f, 0.00168756f, 0.07641692f, -0.13046654f, -0.05936311f, -0.07006413f, 
    -0.03897976f, 0.05830860f, 0.00224213f, -0.04924231f, -0.10629109f, 0.06156445f, -0.14701827f, -0.21048702f, 
    -0.11981640f, 0.02355138f, 0.02069188f, 0.06853910f, 0.00821625f, 0.00350824f, 0.03504826f, 0.11604410f, 
    0.12253764f, 0.05604090f, 0.04873197f, 0.18939006f, -0.07112189f, 0.01127912f, -0.07534459f, 0.02591747f, 
    -0.06348812f, -0.03559624f, 0.17940643f, -0.06096310f, -0.09359200f, 0.08742432f, 0.04952989f, -0.06675608f, 
    0.03286491f, 0.18029658f, -0.07569911f, -0.07960338f, -0.14560124f, -0.00352300f, 0.07161070f, -0.06120081f, 
    -0.04864767f, -0.05495177f, -0.07027383f, -0.20648272f, -0.16189288f, -0.02551594f, 0.14941204f, -0.04863262f, 
    -0.13083124f, -0.01539201f, -0.03591397f, -0.02874295f, -0.13438316f, -0.13916087f, -0.09352481f, 0.07322025f, 
    0.10975358f, -0.02024646f, -0.03077922f, 0.07452434f, 0.11664676f, 0.14134218f, -0.07289021f, 0.01781803f, 
    0.08032330f, -0.03992140f, -0.04836613f, 0.07209683f, 0.03747891f, -0.28802913f, 0.10259377f, -0.11891152f, 
    -0.00758164f, 0.09136320f, 0.05509631f, 0.06646185f, 0.01290886f, -0.05283254f, 0.05129019f, 0.03995226f, 
    -0.14366060f, -0.04780268f, 0.02602012f, -0.05272601f, -0.00706624f, 0.12107605f, 0.01206932f, 0.26678964f, 
    0.00478602f, 0.27505717f, 0.13768046f, 0.08356651f, 0.00641370f, 0.03303953f, 0.04082988f, -0.02117489f, 
    -0.20597953f, 0.26883674f, 0.06187114f, -0.03436712f, -0.01358749f, -0.05043552f, 0.04964361f, -0.09346816f, 
    0.01903222f, -0.15788452f, 0.04985294f, 0.07441725f, 0.03399185f, -0.07085812f, -0.01049173f, -0.04473782f, 
    0.00261299f, 0.03610767f, -0.02599375f, -0.18306071f, -0.00894964f, -0.05280265f, 0.08655870f, -0.01500855f, 
    -0.03154566f, -0.03272402f, -0.06867780f, -0.60013676f, -0.10629354f, -0.03497721f, 0.01994270f, 0.11921546f, 
    -0.05492655f, -0.03522388f, -0.16286409f, -0.01610382f, -0.18864670f, -0.05306505f, 0.11537034f, 0.05559978f, 
    -0.11236576f, 0.08284619f, -0.01650869f, 0.14941870f, -0.06222865f, -0.41703507f, -0.22571607f, 0.01986739f, 
    0.07468653f, -0.03698738f, 0.01266482f, 0.12233064f, -0.02675862f, -0.07881629f, -0.16084050f, 0.11601023f, 
    -0.31141719f, 0.04218671f, -0.04307523f, -0.00715817f, 0.06794658f, 0.10160932f, -0.10627818f, -0.22400641f, 
    -0.13624148f, 0.04208278f, 0.06328306f, -0.02452632f, 0.09186849f, -0.02532696f, -0.03232815f, -0.08826779f, 
    -0.01839706f, 0.07101454f, -0.03910816f, -0.01414472f, 0.04398443f, 0.02247997f, -0.05097998f, 0.05986272f, 
    -0.08242670f, 0.03635469f, 0.10154164f, 0.10476798f, -0.14060324f, 0.01353200f, 0.13554837f, -0.03466096f, 
    -0.07860938f, -0.08529828f, -0.32534322f, 0.07425264f, -0.00367337f, 0.02041268f, -0.01048305f, 0.12712310f, 
    0.06991011f, -0.06397717f, 0.05632922f, 0.08977968f, 0.01366097f, -0.12929958f, -0.05621347f, 0.03274934f, 
    0.00082773f, -0.08482673f, -0.12317559f, 0.04073836f, 0.30959681f, 0.12554190f, -0.08662401f, -0.09748866f, 
    -0.04862504f, -0.06174982f, -0.02774675f, -0.04577406f, -0.01218007f, -0.55858970f, 0.03875706f, -0.09768506f, 
    -0.14581400f, 0.03424975f, -0.00714993f, -0.11440987f, 0.02619449f, 0.00391125f, -0.28562245f, 0.27338439f, 
    -0.06595644f, -0.02604263f, -0.08177272f, -0.00167761f, -0.12414404f, 0.11160216f, -0.03366468f, 0.08398651f, 
    0.08444306f, 0.07123572f, 0.02021926f, 0.12498061f, -0.01591370f, -0.18179138f, 0.07332261f, -0.06315871f, 
    0.01251553f, 0.15939513f, 0.14238404f, 0.13056546f, -0.07462198f, 0.03064531f, -0.11416554f, -0.00352963f, 
    -0.01928600f, 0.03645993f, 0.02940238f, 0.03552370f, -0.03767431f, 0.22760183f, -0.15106824f, 0.02315791f, 
    0.13115804f, -0.01982461f, 0.22512053f, -0.03015936f, 0.01806166f, -0.16499448f, -0.03033374f, -0.13097337f, 
    -0.08830371f, 0.06428598f, -0.02268557f, 0.08785123f, -0.17370228f, 0.19082718f, 0.08715728f, 0.03425805f, 
    0.09379186f, -0.05645676f, 0.14802839f, 0.00836101f, -0.16390952f, -0.03406883f, 0.02203467f, 0.09265975f, 
    0.07338364f, 0.05704329f, 0.02295893f, 0.02749052f, 0.03731532f, -0.11058760f, -0.12681946f, 0.07474469f, 
    -0.13425560f, -0.01308219f, -0.14319682f, -0.00033215f, -0.01373631f, -0.01485522f, 0.23761109f, 0.17469291f, 
    0.23940650f, 0.08875521f, -0.04465548f, 0.06743062f, -0.02041728f, 0.05768863f, -0.08222902f, -0.12681614f, 
    0.27925023f, -0.07789329f, 0.02857943f, -0.02051644f, 0.03615877f, 0.03375533f, -0.10268686f, 0.03671906f, 
    -0.33124679f, -0.06493659f, -0.06940908f, 0.05781545f, -0.09645018f, 0.02398138f, 0.01412193f, 0.09457973f, 
    0.01032489f, -0.12127914f, -0.00487027f, -0.00949726f, -0.05202754f, 0.05837401f, -0.04234974f, 0.00566463f, 
    -0.07380378f, -0.09544410f, 0.03601750f, 0.02657480f, -0.03735222f, 0.05682001f, 0.08502799f, -0.17101391f, 
    -0.23412094f, 0.09718759f, 0.02098880f, -0.08885298f, 0.05392686f, -0.04586395f, -0.01126167f, -0.13124725f, 
    -0.00185179f, 0.02551601f, -0.04301978f, -0.07283317f, -0.14278738f, 0.12955867f, -0.20473021f, -0.01734645f, 
    -0.02035859f, 0.07694729f, -0.09555045f, 0.01264622f, 0.09007913f, 0.03700291f, 0.25417569f, 0.25098592f, 
    0.09921499f, 0.01481794f, 0.12456473f, 0.05616587f, -0.11222436f, 0.05276671f, 0.03744784f, 0.11956584f, 
    0.23960641f, -0.03983640f, -0.09257188f, -0.09563430f, -0.00420425f, -0.05328981f, 0.15020329f, -0.21133590f, 
    -0.12045521f, -0.02125206f, 0.01654398f, 0.06037922f, 0.15775447f, -0.05322035f, 0.04003558f, -0.00736492f, 
    -0.09660928f, -0.06475636f, 0.05381919f, -0.02265098f, 0.00537622f, -0.13565816f, -0.02775884f, 0.04076580f, 
    0.09744515f, 0.00907286f, 0.16433279f, 0.02759879f, -0.00355561f, 0.05266157f, -0.04616271f, -0.12233187f, 
    0.04584524f, 0.02666036f, -0.19989814f, -0.01659201f, -0.04685665f, 0.01552945f, 0.09146111f, 0.03167840f, 
    -0.12373848f, 0.07059475f, 0.00140263f, 0.28652024f, 0.13553965f, 0.06634069f, 0.08231220f, -0.29487044f, 
    0.06023053f, -0.01717073f, -0.02927659f, -0.01521915f, 0.31722373f, 0.13235454f, 0.16346765f, 0.04681400f, 
    0.05889590f, 0.14948320f, -0.00916228f, 0.08144882f, 0.12299696f, 0.46158880f, 0.08536536f, 0.02677213f, 
    -0.03840872f, -0.07694159f, 0.09153708f, 0.04880448f, 0.04037562f, -0.15470931f, 0.19887714f, 0.06550854f, 
    0.07255636f, -0.04476367f, -0.03840368f, -0.19917074f, -0.11153144f, 0.03549635f, -0.08968541f, 0.10358935f, 
    -0.13196757f, -0.01445220f, -0.09355316f, -0.04889557f, 0.03432792f, 0.01029979f, -0.08448036f, -0.13762133f, 
    -0.12018298f, 0.05199320f, -0.10982875f, -0.10931562f, 0.05428557f, 0.07416812f, -0.02031092f, -0.00871926f, 
    -0.14958075f, -0.04976203f, 0.27700186f, -0.32208043f, -0.05429775f, -0.06192905f, 0.00508179f, 0.11383295f, 
    -0.04801708f, 0.07220381f, 0.18678559f, 0.00112051f, -0.11842931f, -0.18231530f, -0.01730466f, -0.04843384f, 
    0.08453248f, 0.07549305f, -0.02377453f, -0.23967123f, -0.09108852f, 0.12689400f, 0.04082635f, -0.04391338f, 
    0.03482583f, -0.20025793f, -0.12081788f, -0.14437851f, 0.05397546f, -0.05044889f, -0.11382920f, -0.02654653f, 
    0.08049390f, -0.23258232f, 0.12149335f, -0.02319097f, -0.06708792f, -0.05653330f, -0.04809593f, -0.34615707f, 
    0.04099855f, -0.06139838f, 0.03699400f, -0.08526385f, 0.02753524f, 0.08727629f, -0.10908343f, 0.04798904f, 
    -0.12132055f, -0.14200731f, -0.07394056f, -0.05424245f, -0.14330822f, 0.08513989f, -0.08837721f, -0.27117360f, 
    -0.13913989f, 0.21458597f, -0.09767768f, -0.02788532f, 0.10699459f, 0.02315797f, -0.07170470f, -0.03297165f, 
    -0.22242709f, -0.00807170f, -0.03140772f, -0.06779152f, -0.02686697f, -0.07117147f, -0.00456974f, 0.04778707f, 
    -0.03724207f, 0.21612483f, -0.16331702f, 0.27465349f, -0.07342292f, 0.08368716f, -0.20291092f, -0.04212071f, 
    0.18011703f, 0.08749043f, -0.16265328f, -0.23455290f, -0.11900237f, -0.05233627f, 0.05650050f, -0.05025066f, 
    0.05596931f, 0.01281317f, -0.08760553f, -0.46586871f, 0.25286752f, -0.15917535f, -0.08545551f, 0.03340143f, 
    -0.01854458f, 0.10652348f, -0.01470560f, 0.14776580f, 0.11945231f, 0.07788149f, -0.01484791f, -0.21827437f, 
    0.08268043f, 0.04297107f, 0.00659378f, -0.06458790f, 0.25119248f, 0.22616647f, -0.06704884f, -0.04877036f, 
    -0.11845891f, 0.03905554f, -0.08016004f, 0.08372647f, 0.12674828f, 0.10039710f, 0.12150932f, 0.27228105f, 
    -0.03557992f, 0.02889916f, 0.01541667f, -0.04126368f, 0.14166375f, -0.02832079f, 0.11776605f, -0.09214242f, 
    -0.16477586f, -0.35293928f, -0.10928829f, -0.10534118f, -0.05844640f, 0.04271810f, -0.03882773f, 0.09591497f, 
    0.20107572f, 0.02940289f, -0.07600491f, 0.04251756f, 0.00466596f, -0.05583192f, -0.06036318f, 0.10944616f, 
    0.00026864f, 0.16660191f, -0.17551978f, 0.09081773f, -0.10630266f, 0.12952997f, -0.06214330f, -0.02506332f, 
    -0.05987134f, -0.05619540f, -0.35073015f, -0.19944568f, 0.06137906f, -0.11532243f, 0.11026503f, 0.01270292f, 
    0.04328440f, 0.05974843f, -0.25311804f, 0.06782515f, -0.12945732f, -0.16726109f, 0.01122841f, 0.18211463f, 
    0.00634366f, -0.01100100f, 0.08576966f, 0.09486797f, 0.16766374f, -0.06492961f, 0.02125962f, -0.03113245f, 
    -0.00049751f, -0.03994430f, 0.16036171f, 0.12134258f, -0.09875753f, 0.11903609f, 0.22342701f, -0.14826325f, 
    0.11373560f, 0.06586644f, 0.17861030f, -0.02039716f, -0.04260021f, -0.09643596f, 0.36314079f, 0.35045150f, 
    0.16890751f, 0.17035939f, 0.02691224f, 0.03092542f, -0.00829719f, -0.04197092f, -0.06007157f, -0.08535329f, 
    0.05097196f, 0.06419845f, -0.11878352f, -0.05923183f, -0.01759677f, -0.02904145f, 0.08962060f, -0.09218327f, 
    0.12785921f, -0.03335771f, -0.01491765f, 0.08155838f, 0.06688185f, -0.15727106f, 0.05744430f, -0.19398734f, 
    -0.02089798f, -0.04756553f, -0.10899551f, -0.24748808f, -0.16313112f, 0.10947905f, -0.21849659f, 0.04952457f, 
    0.12965074f, 0.09700168f, -0.01371406f, -0.01762870f, 0.23052643f, -0.07601495f, -0.08935972f, 0.04097827f, 
    0.02879425f, -0.02012584f, -0.04346517f, 0.38835829f, 0.25024185f, 0.19077799f, 0.10419906f, -0.10009324f, 
    -0.08488509f, 0.18780810f, -0.03448953f, 0.04799340f, 0.50950015f, 0.31412497f, -0.00508274f, -0.00205244f, 
    0.09259515f, -0.04335708f, 0.12357998f, -0.01854895f, -0.03598447f, 0.32307160f, 0.16781464f, 0.22696695f, 
    -0.06214617f, 0.03579295f, 0.00389906f, -0.00450237f, -0.02854379f, 0.12397269f, -0.29333067f, -0.09129240f, 
    -0.08918996f, -0.17485456f, 0.03037968f, -0.17428815f, -0.06481552f, 0.06934281f, 0.05313796f, -0.17267263f, 
    0.03005824f, 0.25903428f, 0.02247499f, 0.07886338f, 0.12009010f, -0.13569158f, 0.04680325f, 0.02727298f, 
    -0.04684562f, -0.03554353f, 0.04425292f, 0.03136303f, -0.00283109f, 0.02442506f, -0.06214083f, 0.00561198f, 
    -0.05408799f, 0.04871035f, -0.02274381f, -0.02101165f, -0.03339991f, -0.02402286f, 0.02284671f, 0.01866345f, 
    0.03353340f, -0.05958795f, 0.04105753f, -0.05655628f, -0.01122482f, -0.01076829f, -0.04301417f, -0.05672713f, 
    0.01944776f, -0.00234863f, -0.00576478f, 0.00100417f, -0.05836897f, -0.06069701f, -0.01677601f, -0.03204795f, 
    0.02622928f, -0.04049165f, 0.01067526f, -0.06459679f, 0.01716348f, 0.04048465f, 0.04351667f, 0.04733362f, 
    0.01275957f, 0.02605527f, 0.00057170f, 0.01345298f, -0.02123377f, 0.00460610f, -0.03925965f, -0.06037672f, 
    -0.02447289f, -0.03906417f, -0.02719689f, -0.02458052f, -0.04263585f, 0.04071658f, 0.02109890f, 0.00143008f, 
    0.04251345f, 0.00182664f, 0.03934712f, 0.00819989f, 0.02113630f, 0.03464007f, -0.06276264f, 0.04117081f, 
    0.00948186f, 0.02578858f, -0.02410245f, 0.01792427f, 0.02916625f, -0.04122015f, 0.01215443f, -0.01248920f, 
    -0.04363104f, -0.01715087f, -0.05530200f, 0.01235203f, -0.02739303f, -0.05971351f, 0.03773375f, 0.02446978f, 
    -0.00929369f, -0.06729580f, -0.02263621f, -0.00222810f, -0.00748715f, -0.01132688f, -0.03355458f, 0.00580291f, 
    0.02933937f, -0.00855135f, -0.01643279f, 0.00162128f, -0.05444641f, 0.01706189f, -0.04437089f, -0.02366465f, 
    -0.05803521f, -0.03267736f, -0.05445337f, -0.00246837f, -0.03607311f, -0.01224732f, -0.05292474f, 0.00829841f, 
    -0.00032133f, 0.00175611f, 0.00013780f, 0.00638726f, 0.00861242f, -0.03729620f, 0.04921955f, 0.02726687f, 
    -0.05175812f, 0.00883984f, -0.01994023f, -0.06468657f, -0.00006443f, -0.03930009f, 0.01390187f, 0.02452554f, 
    -0.02133110f, 0.01068195f, 0.01231609f, 0.04268816f, 0.03482428f, 0.02688882f, 0.04715279f, -0.00990424f, 
    0.01203739f, -0.00245042f, 0.00364916f, -0.00566344f, -0.01175402f, -0.00991848f, 0.03476908f, 0.01170841f, 
    -0.03023252f, 0.04759414f, 0.03116693f, -0.01597546f, -0.05237076f, -0.03669322f, -0.02236825f, 0.04605455f, 
    -0.06693646f, -0.02848637f, -0.00330892f, 0.01257446f, -0.05895061f, -0.06488570f, 0.03000686f, 0.03101369f, 
    0.01124719f, -0.04350056f, -0.03836972f, -0.04699533f, -0.01671343f, 0.02849093f, 0.03672443f, 0.00304471f, 
    -0.00346391f, -0.00886110f, -0.05635459f, -0.01127434f, 0.04863664f, -0.00238788f, -0.05902952f, -0.01002496f, 
    0.03682075f, 0.04749926f, -0.06207351f, 0.02795031f, 0.03609920f, 0.04019542f, 0.00177578f, 0.02100175f, 
    -0.01612595f, -0.00137298f, 0.04308574f, 0.04837333f, 0.04238570f, -0.00249678f, -0.01931164f, 0.03528295f, 
    -0.01298556f, 0.02131192f, -0.03943315f, -0.05925648f, 0.03650161f, 0.02202943f, 0.02981729f, 0.03742923f, 
    -0.02924805f, -0.00113040f, -0.02565318f, 0.04374171f, 0.02192970f, -0.02135767f, -0.04703679f, -0.05946555f, 
    -0.05605238f, -0.01524094f, -0.02967653f, -0.05512272f, 0.03700066f, -0.01496536f, -0.03586263f, 0.04893561f, 
    0.00564842f, -0.04836473f, -0.03325862f, 0.00522050f, 0.02305330f, 0.03710631f, 0.00832427f, -0.06025339f, 
    0.00628832f, 0.04707891f, -0.06475513f, -0.06477766f, -0.05588500f, -0.00368126f, -0.01972890f, -0.05816112f, 
    -0.04693750f, -0.04122644f, -0.00712827f, 0.00280639f, 0.03998353f, 0.00848971f, 0.05463668f, -0.03232506f, 
    -0.05378442f, 0.01158282f, -0.03402194f, 0.00357866f, -0.04478936f, 0.00396863f, -0.02530207f, 0.02477539f, 
    0.00247344f, 0.02249922f, -0.06673910f, -0.04266327f, -0.02283274f, -0.05438094f, 0.00455102f, -0.01890444f, 
    0.02885899f, 0.01825074f, 0.04528442f, -0.03456324f, -0.03225206f, 0.01319447f, -0.03103132f, 0.04539380f, 
    -0.05393639f, -0.03397068f, -0.06429756f, -0.05404349f, -0.04473426f, -0.06202127f, -0.05772623f, 0.05179396f, 
    -0.01277311f, 0.01560840f, 0.02887255f, 0.04790555f, -0.02763446f, -0.02833702f, -0.05133696f, 0.03187463f, 
    -0.02684940f, -0.05395640f, -0.06279281f, 0.04731989f, 0.02062597f, -0.05675653f, -0.01066530f, -0.05164994f, 
    0.01500497f, 0.02822198f, -0.02275268f, -0.00737295f, 0.04495426f, -0.02291489f, -0.01288803f, -0.00661973f, 
    0.00320445f, -0.10758664f, 0.11118118f, -0.14474025f, 0.10803566f, -0.04332647f, 0.10287972f, 0.02224467f, 
    0.09941574f, -0.28668815f, -0.11135786f, 0.10450483f, -0.09866909f, 0.00873240f, -0.06913578f, 0.07991573f, 
    -0.03565192f, 0.04616416f, -0.00235276f, 0.02262407f, -0.08356951f, 0.06634336f, 0.03782856f, -0.02702951f, 
    -0.03459444f, 0.01502582f, -0.10600056f, 0.11496779f, 0.03231355f, -0.01978249f, 0.00395584f, 0.01751298f, 
    -0.09068616f, -0.04348895f, -0.15721244f, -0.02832054f, 0.18990028f, -0.01187398f, 0.07367919f, 0.10665166f, 
    -0.08001831f, 0.01466785f, -0.22894381f, 0.05653612f, -0.21780014f, 0.01398473f, 0.10859498f, 0.06976470f, 
    0.06634267f, -0.00745779f, 0.07591967f, -0.18390386f, -0.08286691f, -0.16855061f, 0.08306555f, 0.07928424f, 
    0.03814689f, -0.06750526f, -0.03193948f, 0.14696108f, 0.10586550f, -0.15484636f, 0.07240839f, -0.08060871f, 
    0.00344388f, 0.03662809f, -0.10015910f, 0.12548108f, -0.08506977f, -0.04405294f, -0.03661119f, -0.04010038f, 
    0.08209103f, 0.04087080f, 0.04673586f, 0.03851141f, 0.02378163f, -0.02783735f, -0.01083364f, -0.04491674f, 
    -0.00709427f, 0.18688400f, -0.05074584f, -0.09219928f, -0.02110525f, 0.12179998f, -0.10701939f, -0.06172490f, 
    0.00356833f, 0.06325843f, 0.06329581f, 0.14695817f, -0.04956358f, 0.10850514f, -0.01412040f, -0.03843968f, 
    -0.10051309f, -0.07734033f, 0.04268910f, 0.07287469f, 0.15840997f, -0.02554642f, -0.14497961f, -0.04969287f, 
    -0.07344536f, -0.16024072f, -0.11391556f, -0.21291478f, -0.25077268f, -0.16416004f, 0.03342285f, 0.05419213f, 
    -0.11706332f, -0.00725220f, 0.17689022f, -0.00327337f, 0.01314539f, 0.37812918f, 0.18571453f, -0.04499971f, 
    -0.03436044f, -0.11714253f, -0.04867732f, -0.09120663f, -0.05426838f, 0.14778674f, 0.03846502f, 0.16058265f, 
    -0.16542472f, -0.02287087f, -0.01543495f, -0.04101083f, -0.06466113f, -0.06503853f, -0.00712929f, 0.22814453f, 
    0.13384554f, -0.09135100f, -0.03128812f, 0.04828222f, 0.10640241f, 0.07780746f, -0.04648497f, 0.14861789f, 
    0.06458168f, 0.06562866f, 0.05722241f, 0.06504174f, 0.02529874f, -0.04951791f, 0.08496320f, -0.06988875f, 
    -0.00658784f, 0.33124629f, -0.01618922f, -0.10010722f, 0.03112178f, 0.04075204f, 0.05798485f, 0.13176213f, 
    0.06490480f, 0.02340658f, 0.14076698f, 0.07818023f, -0.09789877f, -0.02264988f, -0.00751697f, -0.09181351f, 
    0.07156910f, 0.01717618f, 0.03760216f, 0.21527156f, -0.05928969f, -0.02210553f, -0.04955136f, 0.02645054f, 
    -0.02176560f, 0.07585932f, -0.04752375f, -0.00281654f, -0.17255133f, 0.08748200f, 0.06676228f, 0.04032885f, 
    0.11318680f, -0.06163954f, 0.01123543f, 0.04193781f, 0.11036098f, 0.15342377f, 0.05636640f, -0.20178619f, 
    -0.06712380f, 0.01592711f, -0.04860565f, 0.02909844f, -0.28765926f, 0.14065950f, 0.02501604f, 0.08065896f, 
    -0.14396919f, 0.06002589f, 0.05845856f, 0.01326496f, 0.11697328f, -0.13090421f, 0.02139545f, -0.11071954f, 
    0.12476568f, 0.19570990f, -0.03517272f, 0.06554563f, -0.10564636f, 0.11270864f, -0.04636672f, 0.01226798f, 
    -0.01250826f, 0.11916180f, 0.02595079f, 0.15595059f, -0.03790157f, -0.02516236f, 0.07124496f, -0.06551713f, 
    0.06593549f, -0.11328592f, 0.02118664f, -0.15751870f, 0.03708922f, -0.17285746f, 0.10382931f, 0.07731806f, 
    -0.04796944f, -0.19954839f, 0.12553144f, -0.08916235f, 0.01766183f, 0.01564269f, 0.02045174f, -0.13869743f, 
    -0.12076401f, -0.13890128f, -0.04706174f, 0.12695795f, -0.03035396f, 0.00892696f, -0.10584699f, 0.01727208f, 
    0.05860172f, -0.02562706f, -0.07244613f, -0.07992509f, 0.13877054f, 0.07737376f, -0.00778049f, -0.07016580f, 
    -0.07306208f, -0.03401812f, 0.07986104f, -0.08124112f, -0.02582916f, -0.28392506f, -0.05172998f, 0.09117740f, 
    0.05745924f, -0.16304077f, 0.06478725f, 0.08574888f, -0.07770517f, 0.04397138f, -0.02890028f, 0.18665826f, 
    -0.14445741f, -0.00263886f, 0.02196418f, -0.06938159f, 0.06702973f, -0.00880315f, -0.05641080f, -0.11932457f, 
    0.12021862f, -0.11629082f, -0.00132719f, 0.03322362f, 0.03541926f, -0.06491298f, -0.09554359f, 0.08265219f, 
    -0.24109846f, -0.01838902f, 0.15516211f, -0.00972403f, 0.12754774f, -0.06194035f, -0.09266853f, 0.00198534f, 
    0.00816163f, -0.02974226f, -0.01074223f, -0.12325593f, -0.07947695f, -0.01215352f, 0.04231144f, -0.14179924f, 
    0.13836935f, 0.03156464f, -0.00511341f, 0.00197078f, 0.02150654f, -0.03258684f, 0.04449262f, 0.05308314f, 
    -0.08933771f, -0.01015741f, 0.00031963f, 0.03830523f, -0.34926379f, 0.09134474f, -0.10844910f, 0.06163859f, 
    -0.04425357f, -0.14971693f, 0.00517885f, -0.02251431f, -0.41363060f, -0.32372618f, 0.04605388f, 0.04102140f, 
    0.08128566f, 0.02279851f, -0.02084358f, -0.15256362f, 0.09520305f, -0.02507998f, 0.19057049f, -0.03595352f, 
    -0.02561170f, -0.27210480f, -0.03511813f, 0.01299136f, 0.01097065f, 0.08910926f, 0.13342103f, 0.11921314f, 
    -0.02445127f, -0.13614286f, -0.15227580f, 0.05380001f, -0.17782679f, 0.05114416f, 0.18191366f, 0.12015652f, 
    -0.01288801f, -0.12764433f, -0.01370130f, 0.12246123f, 0.08472980f, -0.06943218f, 0.00407127f, -0.09326911f, 
    -0.01777187f, -0.08776823f, 0.04923020f, -0.19321194f, -0.04379522f, -0.09488480f, -0.07342300f, 0.01400007f, 
    0.17739312f, 0.03846169f, -0.06253471f, 0.03675112f, -0.03944283f, 0.01711541f, -0.11124805f, -0.09388731f, 
    -0.15371627f, 0.04644759f, -0.34818345f, -0.28793606f, 0.02018853f, 0.04617044f, -0.00173720f, 0.13027620f, 
    -0.02649560f, 0.10705181f, -0.04397903f, 0.03903162f, 0.08137310f, -0.05536359f, 0.14728925f, -0.02464692f, 
    -0.00595914f, -0.05321407f, 0.01820869f, -0.08371327f, -0.04291267f, 0.01720885f, 0.07715999f, -0.04483550f, 
    0.01696673f, 0.06760322f, 0.03879392f, 0.05699981f, 0.04553019f, 0.00303197f, -0.44777256f, -0.14049499f, 
    -0.03971539f, 0.11730155f, -0.02280823f, 0.09308466f, -0.13870761f, 0.10594990f, 0.20714574f, 0.10577631f, 
    -0.13739140f, 0.08598100f, 0.07748345f, -0.14790621f, 0.12748414f, -0.06022520f, 0.04787887f, 0.23209380f, 
    -0.17824771f, -0.08871894f, -0.19634053f, 0.04213532f, 0.08042255f, -0.22271693f, 0.03560551f, 0.09809940f, 
    0.03667619f, 0.04286754f, 0.26133043f, 0.01087859f, 0.05119097f, -0.00092898f, 0.08515726f, 0.05925791f, 
    -0.04798792f, 0.18454255f, -0.07945067f, 0.31382385f, 0.05591324f, 0.03341286f, 0.08564163f, -0.15206704f, 
    0.04244933f, -0.10588729f, -0.13481979f, -0.07040766f, 0.01419925f, 0.00568500f, -0.01979163f, 0.13936442f, 
    -0.00535757f, -0.09337360f, -0.06343662f, 0.06502336f, 0.15549226f, 0.13773015f, 0.11315671f, 0.15679438f, 
    -0.12898540f, 0.19159389f, -0.02123191f, -0.05597218f, 0.05261906f, 0.11346812f, 0.20031883f, -0.00719748f, 
    -0.06822970f, 0.06413957f, -0.02367383f, 0.15808859f, 0.06549277f, 0.11444714f, 0.15158944f, -0.21053268f, 
    0.16449481f, 0.05936169f, 0.07497308f, 0.03022879f, -0.00446075f, -0.12346235f, -0.05463229f, 0.03606105f, 
    0.02809713f, 0.20598702f, 0.07486410f, -0.06618518f, 0.01203446f, 0.08634736f, -0.18708147f, -0.13074037f, 
    0.06272179f, 0.16283238f, 0.08212773f, 0.02034424f, -0.12004273f, 0.00028179f, 0.12208823f, -0.06057958f, 
    -0.03144992f, -0.26083884f, -0.18680581f, 0.17131440f, 0.11075081f, -0.02627800f, -0.11300690f, 0.05018559f, 
    0.07322709f, -0.20476219f, -0.07067454f, -0.12228607f, -0.10526093f, -0.02244994f, -0.20356607f, 0.03577522f, 
    -0.00073903f, 0.03726685f, -0.17767662f, -0.04453593f, 0.02360865f, -0.08908020f, -0.02927658f, 0.04735851f, 
    -0.07011539f, -0.14160895f, -0.02167015f, 0.11677361f, 0.41324601f, -0.09780348f, 0.01316049f, -0.00857552f, 
    -0.13387877f, 0.08063404f, -0.07810294f, -0.09647927f, 0.36539382f, 0.12833852f, -0.06711470f, 0.11131585f, 
    0.07576022f, -0.03131556f, 0.23608674f, -0.04582989f, -0.11391763f, 0.06351069f, 0.20125861f, 0.18936753f, 
    0.00403403f, -0.08257285f, -0.08652675f, 0.01849244f, -0.06715520f, 0.15449804f, -0.18202749f, -0.07109269f, 
    -0.00081507f, -0.01005248f, 0.10401110f, 0.04169629f, 0.04828966f, -0.01354248f, -0.08651240f, -0.48197874f, 
    0.06385095f, 0.09200514f, 0.05469471f, 0.10134195f, 0.17201945f, -0.03948199f, 0.10534570f, -0.03385979f, 
    0.15406977f, 0.04932752f, 0.03522759f, 0.05522558f, 0.05455799f, 0.07309953f, 0.00898251f, 0.07352033f, 
    0.06111052f, -0.03165593f, 0.08682264f, -0.04842935f, 0.05217272f, -0.03245464f, -0.04507772f, -0.03705136f, 
    0.16366489f, 0.05493218f, 0.06173422f, 0.05341821f, 0.01388324f, -0.04653738f, 0.08373375f, -0.01179379f, 
    -0.08927690f, 0.08510352f, 0.01022670f, -0.08976908f, -0.16863069f, 0.07663506f, -0.04758490f, -0.04414854f, 
    0.00734351f, 0.01708161f, -0.02587711f, -0.15576789f, 0.21781911f, -0.25336531f, 0.02143067f, -0.07562229f, 
    0.16200514f, -0.00241323f, 0.06023476f, -0.08923464f, -0.03969216f, 0.17590311f, 0.15176520f, 0.18356337f, 
    -0.02732056f, -0.11322163f, -0.11931016f, 0.04797983f, 0.24018696f, 0.12757894f, 0.14802729f, 0.15869522f, 
    -0.05558581f, -0.03897769f, 0.02044076f, 0.14287820f, -0.03329351f, 0.12549910f, 0.00081914f, -0.04760456f, 
    -0.17590882f, 0.05070599f, -0.16200911f, 0.08144473f, 0.01099793f, -0.03030049f, 0.03146170f, -0.02142743f, 
    0.32537565f, 0.12650177f, 0.02383299f, 0.00028313f, -0.10254523f, 0.02119845f, -0.00801629f, -0.02222856f, 
    -0.08761710f, -0.22429061f, 0.18902425f, -0.09626278f, -0.00673911f, -0.05961523f, 0.08894078f, -0.21091272f, 
    0.14770345f, 0.04183000f, -0.19355005f, -0.00949545f, -0.11375276f, 0.13147555f, 0.16068338f, 0.08201508f, 
    -0.00474991f, 0.11684214f, -0.14111216f, -0.17802663f, -0.28729904f, -0.26719162f, -0.11922830f, 0.08181738f, 
    0.09291439f, -0.19877082f, 0.04908841f, -0.07892220f, -0.04172931f, -0.07320030f, 0.19354251f, 0.00678602f, 
    0.04306751f, -0.26352593f, 0.04436330f, 0.10987275f, 0.12471966f, -0.30728683f, -0.00913787f, 0.09667215f, 
    0.03230068f, -0.00283644f, 0.08251937f, 0.00751095f, 0.17432912f, -0.11706252f, 0.11279984f, -0.24308436f, 
    -0.35426730f, 0.14511906f, -0.00753600f, 0.00332901f, 0.05899515f, -0.02875640f, -0.06727776f, -0.05431504f, 
    0.02065050f, -0.14927097f, -0.00479044f, -0.03826202f, 0.19773637f, -0.12514032f, 0.05726453f, 0.01123729f, 
    0.15814602f, 0.14609680f, 0.10115319f, -0.08329137f, 0.06140829f, -0.10742408f, 0.02215650f, -0.01656322f, 
    0.02083825f, 0.05024910f, 0.07707006f, -0.08873022f, -0.11967537f, 0.08844084f, 0.08569141f, -0.15011358f, 
    0.03757183f, 0.13788067f, -0.19904923f, -0.05682926f, -0.12047853f, 0.07045820f, 0.14976887f, 0.04526791f, 
    -0.03794280f, 0.02780186f, -0.00134081f, 0.20532089f, -0.15461475f, -0.01892940f, 0.07223722f, 0.10873589f, 
    -0.04515337f, 0.10366114f, 0.12491098f, 0.09293677f, -0.09960163f, 0.11041687f, 0.03661863f, 0.03274830f, 
    -0.14895126f, -0.11740109f, 0.12937678f, 0.10819117f, 0.18238677f, 0.06211172f, 0.09350277f, -0.05303212f, 
    0.00756236f, 0.02201334f, 0.13235818f, -0.07376562f, -0.16836715f, -0.02741842f, -0.17821039f, 0.06258096f, 
    -0.10851851f, -0.03463306f, 0.05469947f, 0.01552280f, -0.04442517f, 0.16984388f, -0.02404879f, 0.06673464f, 
    0.15489769f, 0.17122942f, 0.02148484f, 0.06391296f, -0.06702632f, 0.14687476f, 0.00971049f, 0.05177138f, 
    0.02755742f, -0.19141518f, -0.08878618f, 0.07514361f, 0.02307416f, 0.08549874f, 0.08694531f, -0.03816387f, 
    -0.00177727f, -0.12083774f, -0.03140927f, 0.07765056f, -0.00143400f, 0.03352596f, 0.03337034f, 0.01035831f, 
    -0.06566218f, 0.20797013f, -0.07661654f, 0.07337669f, 0.21520987f, 0.03039287f, -0.04383437f, 0.11044032f, 
    0.04450808f, -0.07512921f, -0.14033331f, 0.29098004f, -0.35402995f, 0.00454273f, -0.04965845f, -0.19838174f, 
    0.04790262f, 0.13315256f, 0.06049101f, -0.17963134f, 0.11844461f, -0.35579401f, -0.14631066f, 0.04537749f, 
    0.04793356f, -0.04146409f, 0.06636739f, 0.02262706f, -0.22977790f, 0.05169170f, -0.30499798f, -0.12275615f, 
    -0.02408930f, 0.06202349f, -0.06401713f, 0.01488441f, -0.13060904f, 0.00838439f, -0.28245556f, 0.05883266f, 
    -0.06504905f, 0.03068996f, 0.17130956f, 0.00604340f, 0.01767049f, 0.16058363f, -0.02706953f, -0.07825898f, 
    -0.05413533f, -0.10514690f, 0.01039867f, 0.03241025f, 0.02327078f, -0.00917371f, -0.05374397f, 0.10378651f, 
    -0.06469903f, 0.03101958f, -0.05502437f, 0.02032196f, 0.04029655f, 0.02679062f, -0.04343529f, 0.03938876f, 
    -0.05450118f, -0.02493363f, -0.05902298f, -0.02607276f, -0.00246012f, -0.04780006f, -0.06008930f, -0.05666203f, 
    -0.06268185f, -0.00335311f, -0.02928393f, 0.03286345f, 0.01786470f, 0.04536426f, -0.02032631f, -0.03981795f, 
    -0.03931876f, -0.01030518f, 0.04595511f, -0.00406608f, -0.02890052f, -0.00832188f, -0.05522019f, -0.06255350f, 
    0.02492082f, -0.03981319f, 0.04592843f, 0.04347475f, -0.00082742f, 0.00271218f, 0.04021776f, -0.01211980f, 
    0.03528942f, 0.05072464f, 0.00095008f, -0.03125279f, -0.03346571f, -0.02089304f, -0.01780562f, 0.02926375f, 
    0.00706082f, -0.00845170f, -0.01066729f, 0.01072366f, 0.01660696f, 0.02015191f, 0.00539213f, 0.04170570f, 
    -0.03288619f, -0.04708673f, -0.02845743f, -0.06112703f, 0.01369166f, -0.03273674f, -0.03627753f, -0.04972938f, 
    -0.01845507f, 0.01615969f, 0.00025737f, 0.03577967f, 0.03486322f, 0.05243469f, -0.01346493f, -0.03812324f, 
    0.02634210f, 0.02402257f, 0.02395280f, 0.01769772f, -0.04502951f, -0.03134748f, -0.01501485f, 0.01370440f, 
    -0.04765210f, -0.01172823f, 0.03685341f, 0.04704340f, -0.00732836f, -0.04531118f, 0.02564910f, -0.00068081f, 
    0.05160661f, 0.00863980f, -0.00332441f, -0.02345099f, -0.01082731f, -0.01740545f, 0.05247037f, -0.03426855f, 
    0.02566533f, 0.02141308f, -0.04986416f, 0.05303248f, 0.00564042f, 0.03177640f, 0.01241774f, -0.00111446f, 
    -0.02267986f, 0.00650883f, -0.05617475f, 0.02890595f, -0.02012804f, -0.04144937f, -0.03866069f, 0.04326119f, 
    -0.05993218f, -0.00278172f, 0.02211880f, 0.01415357f, 0.03520460f, -0.03756222f, 0.05428880f, -0.02015818f, 
    0.03537758f, -0.02637744f, 0.02286251f, 0.02382140f, -0.05733226f, 0.04580258f, 0.02292212f, -0.00627573f, 
    0.02929411f, 0.04628931f, 0.03846977f, -0.04703644f, -0.05703716f, 0.02601212f, 0.02179118f, 0.02428140f, 
    0.03316198f, -0.05482056f, -0.06017070f, -0.01570929f, -0.05184767f, 0.04208836f, -0.05875184f, -0.01845609f, 
    -0.03913068f, 0.01652073f, -0.00580518f, 0.02398258f, 0.02201519f, -0.01636225f, 0.01743270f, -0.05630228f, 
    -0.02082948f, -0.03187484f, 0.02965089f, 0.02817127f, -0.01559564f, -0.01663053f, 0.04091398f, -0.05670603f, 
    0.01044977f, 0.00879929f, -0.00365023f, -0.01681234f, 0.01641180f, -0.02124465f, 0.02483976f, -0.05544803f, 
    -0.05602532f, -0.04398999f, 0.01724924f, -0.01478521f, -0.05802900f, -0.03391493f, -0.02397827f, -0.05357455f, 
    -0.01291435f, 0.00728968f, 0.03903290f, -0.06407537f, -0.03638108f, -0.01993120f, 0.01556430f, 0.03990414f, 
    -0.05069643f, -0.02407456f, 0.02260168f, 0.03603761f, 0.01152426f, 0.01378776f, -0.05155464f, -0.05070298f, 
    0.00265683f, -0.02922217f, -0.05499392f, 0.00168489f, 0.03461595f, 0.01199330f, 0.02302267f, -0.01349858f, 
    -0.05727226f, -0.03656753f, -0.02604136f, 0.01418277f, 0.03326784f, 0.01202782f, 0.00441135f, -0.00606665f, 
    -0.04439726f, -0.01966088f, -0.00458656f, 0.03472709f, 0.01335357f, 0.01689863f, 0.00042043f, -0.00592367f, 
    0.00046682f, -0.05129277f, 0.00922759f, -0.00972994f, 0.04049929f, -0.00690165f, -0.02289388f, -0.02876140f, 
    -0.05863822f, -0.00376148f, -0.05857107f, -0.02584347f, -0.02783489f, -0.02856102f, -0.06406347f, -0.03045489f, 
    0.03049927f, 0.01906519f, 0.02276779f, 0.03015225f, -0.04675317f, 0.05233150f, -0.00683987f, -0.02756849f, 
    -0.03790680f, -0.00090236f, 0.00698595f, 0.02081811f, -0.00032937f, 0.04775620f, -0.03927402f, -0.05733056f, 
    -0.01855285f, 0.05279726f, 0.04986101f, -0.04305813f, -0.03287853f, 0.04316545f, 0.03157247f, 0.04500029f, 
    0.04975430f, -0.02593242f, -0.06293479f, -0.06040061f, -0.04223305f, -0.05387626f, -0.04977563f, -0.04787941f, 
    -0.04920296f, -0.01470573f, -0.00059842f, -0.04335624f, -0.00311668f, 0.04581906f, -0.04146939f, 0.04247943f, 
    -0.01622760f, -0.01544616f, -0.02436739f, 0.02058239f, -0.04498154f, 0.04961073f, -0.03319064f, 0.05187808f, 
    -0.02983830f, -0.00416512f, -0.01106665f, -0.02789336f, -0.01880200f, 0.00944071f, 0.03385671f, 0.03318489f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.00807383f, 0.00701132f, -0.03631284f, -0.03794644f, 0.07656635f, 0.04894280f, 0.14789818f, -0.05529438f, 
    0.07899992f, 0.07291572f, -0.10472973f, 0.05322957f, 0.11334784f, -0.06454541f, -0.02331546f, -0.06408822f, 
    0.13064271f, 0.19105862f, -0.06210444f, 0.07919761f, -0.04181999f, 0.05246313f, 0.06871890f, 0.03270017f, 
    0.04688870f, -0.01224897f, 0.00089959f, 0.00347284f, 0.00830968f, 0.04952415f, 0.12130240f, 0.04967887f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00265120f, -0.08558907f, -0.00518914f, 0.12522654f, -0.22277603f, 0.17517842f, 0.32983780f, 0.28666934f, 
    0.04765162f, -0.00477180f, -0.05031753f, 0.14186276f, -0.06969795f, 0.03088147f, -0.15954998f, 0.04383097f, 
    0.10507689f, 0.13894407f, -0.01896581f, -0.14309984f, 0.16631097f, -0.14720595f, 0.02054228f, 0.17116088f, 
    -0.28093848f, -0.13692856f, 0.38079593f, 0.00351285f, -0.13992041f, 0.41881561f, 0.05919971f, -0.18112533f, 
    -0.10918791f, -0.05560810f, -0.07172409f, -0.07125305f, 0.37416857f, 0.14083080f, 0.07202845f, -0.67912835f, 
    0.11813540f, -0.26240867f, 0.11063289f, 0.18744290f, 0.23242249f, -0.04619455f, 0.11826494f, 0.16360360f, 
    -0.29738185f, 0.25939324f, -0.10877530f, 0.23523889f, 0.04395657f, 0.39702088f, 0.37703115f, -0.16048498f, 
    -0.38975504f, 0.17692693f, 0.27544340f, 0.00387323f, -0.16076060f, -0.21004036f, 0.27534926f, -0.12681091f, 
    0.09079790f, 0.08112559f, -0.10366347f, 0.05682596f, 0.02666765f, -0.16822873f, -0.29134068f, -0.16978458f, 
    -0.27835032f, 0.17945866f, 0.15882318f, -0.41685766f, -0.14632733f, 0.01662642f, -0.16592878f, -0.04988686f, 
    0.04756278f, -0.20014344f, 0.14977841f, 0.28454912f, -0.00712911f, 0.47091135f, 0.25214589f, -0.26439473f, 
    0.47602206f, -0.17846784f, -0.24178168f, 0.16449685f, 0.26750180f, -0.34874809f, 0.31818107f, 0.08540042f, 
    -0.11715405f, 0.09722378f, 0.11512614f, 0.00738920f, 0.15428233f, -0.11496553f, 0.09914310f, 0.09528608f, 
    0.20422938f, -0.21895358f, 0.26636136f, -0.15090224f, 0.10819917f, 0.08208460f, 0.04024154f, -0.00755638f, 
    0.06228203f, 0.11355018f, 0.13487177f, -0.41373667f, 0.12174827f, -0.02073180f, 0.25278556f, -0.62633735f, 
    -0.45590305f, 0.23651862f, 0.56487006f, 0.14224690f, -0.23328951f, 0.05860258f, -0.30477914f, 0.05779007f, 
    -0.16308796f, 0.10160349f, 0.16797480f, -0.04422581f, 0.06241653f, -0.13695891f, -0.14957289f, 0.71866840f, 
    -0.28550464f, 0.14734557f, 0.35221955f, -0.26580873f, -0.06462341f, 0.12414934f, 0.10643142f, 0.08744711f, 
    -0.18760723f, 0.04417411f, -0.13815463f, 0.26059419f, 0.01509247f, -0.02303277f, 0.25121707f, 0.53283143f, 
    0.41501805f, -0.04482046f, -0.26179221f, -0.07908233f, 0.06760877f, 0.29632849f, -0.15905041f, 0.07452413f, 
    0.00963713f, 0.23774160f, 0.00135293f, 0.09533481f, 0.02186829f, -0.12601714f, 0.38083693f, 0.09825204f, 
    0.06127135f, 0.07294825f, 0.18940336f, 0.11154400f, -0.11573339f, -0.04056845f, -0.13144110f, 0.02743079f, 
    0.11773613f, 0.30609748f, -0.04896954f, 0.27356720f, 0.13715467f, -0.51822376f, 0.00424981f, 0.62623763f, 
    -0.33092201f, -0.26931024f, -0.36319777f, 0.13339241f, 0.08087867f, 0.19716801f, -0.07744765f, -0.02183215f, 
    0.02650666f, 0.26007414f, 0.00706729f, -0.04791219f, 0.02404440f, 0.04936336f, 0.32182974f, 0.50167990f, 
    0.09631493f, 0.37937042f, -0.11096016f, -0.21501721f, -0.10295846f, 0.01087579f, -0.15194306f, -0.08371677f, 
    0.26102757f, 0.28944829f, 0.16160291f, 0.34206232f, -0.16649278f, -0.43124321f, -0.10729080f, 0.28576067f, 
    0.10892828f, -0.21628447f, -0.41449985f, -0.02108688f, 0.24018987f, 0.20497903f, -0.08865842f, 0.16423768f, 
    0.00233679f, -0.03775090f, 0.03980991f, -0.01333672f, -0.01745788f, -0.06591362f, 0.43948451f, 0.01953193f, 
    0.14962739f, -0.10723548f, 0.08039374f, 0.21734101f, 0.17408793f, 0.17280090f, 0.10561133f, -0.12317061f, 
    0.01585428f, -0.01838645f, 0.14305660f, 0.39485571f, 0.16895969f, 0.09790814f, 0.31198364f, 0.49185377f, 
    0.46548855f, 0.40842757f, -0.63672602f, 0.10190820f, 0.12557732f, -0.26025918f, -0.22646472f, 0.07416829f, 
    0.08354997f, 0.00838041f, -0.02606354f, -0.11111888f, -0.14036839f, 0.16636737f, -0.12499500f, -0.00342260f, 
    0.04808860f, -0.10637783f, -0.02009111f, -0.16164829f, -0.17477840f, 0.03472910f, -0.16542812f, -0.02378784f, 
    0.02707976f, -0.01865926f, -0.02780908f, 0.01849339f, 0.13218483f, -0.16771995f, -0.08069509f, 0.14233509f, 
    0.04769386f, -0.17842272f, -0.00495108f, 0.12831205f, 0.14637657f, -0.02318663f, 0.14988479f, 0.04955686f, 
    0.00578725f, 0.20517895f, 0.08761030f, 0.03963492f, 0.30766422f, 0.10774829f, 0.04125531f, -0.42380518f, 
    0.37131476f, -0.01433618f, 0.10500471f, 0.25439864f, 0.05172192f, -0.15712674f, 0.09734585f, 0.03774405f, 
    -0.04027300f, -0.04309236f, 0.08363245f, -0.17852128f, 0.16357222f, -0.06145298f, 0.34682480f, -0.18702543f, 
    -0.38581055f, 0.11714595f, 0.00026242f, -0.03128144f, -0.18316871f, -0.16664287f, -0.28676385f, -0.00432246f, 
    -0.16921046f, -0.17243487f, -0.07961877f, 0.06895911f, 0.09003672f, 0.07096404f, -0.25049073f, 0.24165277f, 
    -0.13868798f, 0.30309263f, 0.12413355f, -0.07273593f, 0.07202643f, 0.17235328f, 0.13099509f, 0.06383149f, 
    0.33647847f, 0.04146351f, -0.04021564f, -0.46697947f, -0.02544205f, -0.01482512f, -0.19046225f, -0.31696555f, 
    -0.10009487f, 0.27829924f, 0.56874204f, -0.08739109f, 0.19277559f, 0.48491287f, 0.21211007f, -0.04117450f, 
    -0.10860394f, -0.19498056f, 0.12503400f, 0.06858041f, -0.18311088f, -0.09925838f, -0.04339274f, 0.08323278f, 
    -0.20692804f, 0.38577583f, -0.41682890f, -0.31820253f, 0.09661722f, 0.12597123f, 0.02258859f, 0.06803071f, 
    0.39057678f, 0.11459075f, 0.03819708f, -0.11637161f, -0.08071740f, -0.04207711f, 0.18440999f, -0.05608753f, 
    0.01488348f, -0.47330716f, 0.41004595f, -0.16314419f, 0.13311954f, 0.35471678f, 0.20827129f, 0.08621825f, 
    0.02699724f, -0.40570751f, -0.01378817f, -0.07873993f, 0.04996710f, 0.15060051f, 0.00792160f, -0.12381446f, 
    -0.05906264f, 0.12537894f, -0.54088813f, 0.13663846f, 0.09269246f, -0.11876140f, -0.10689130f, 0.00367473f, 
    0.16461346f, 0.10478656f, 0.09252925f, -0.06628974f, -0.15360768f, 0.25490707f, 0.24456158f, -0.48584750f, 
    0.12812680f, 0.01714162f, 0.23862559f, 0.11472269f, 0.02082931f, 0.00885323f, 0.33567548f, -0.14928770f, 
    0.17703478f, -0.18552631f, 0.04617285f, 0.10703879f, -0.12627129f, 0.01426263f, -0.01257984f, -0.00530922f, 
    0.13072589f, 0.10178580f, 0.10290898f, -0.06856434f, 0.11398675f, -0.01522098f, -0.11187668f, -0.11613805f, 
    -0.04671777f, -0.10187417f, 0.09356220f, 0.09776077f, 0.02050344f, -0.09919598f, -0.17977755f, 0.08218525f, 
    -0.11870729f, 0.05955877f, -0.07649586f, 0.10823245f, 0.14872067f, -0.13085027f, -0.19492488f, -0.00620403f, 
    0.00605483f, -0.04310857f, 0.04509168f, -0.04859149f, 0.22699647f, -0.02126069f, -0.27232280f, -0.03402254f, 
    0.06137078f, 0.07120927f, 0.17902224f, 0.07213212f, -0.26816121f, 0.08783079f, 0.03548677f, -0.12939671f, 
    -0.06824136f, 0.08192030f, -0.15347120f, 0.31644869f, 0.09344413f, 0.04087020f, 0.23993075f, 0.98206061f, 
    -0.05633146f, -0.30273098f, -0.15941994f, 0.00049205f, 0.18171218f, 0.05036616f, 0.05248343f, 0.11378831f, 
    0.00325870f, 0.00697119f, 0.03131153f, -0.10792119f, -0.18803445f, -0.16088761f, -0.01655755f, -0.20276669f, 
    -0.03715724f, -0.20891045f, -0.05815062f, 0.21927495f, -0.22126685f, 0.02440393f, 0.04726060f, 0.04389773f, 
    0.16966867f, 0.47461057f, -0.13570657f, -0.08684352f, 0.15929472f, 0.20137869f, 0.26624414f, 0.40876698f, 
    -0.27690551f, -0.34455496f, 0.43288511f, -0.14522482f, 0.24195732f, 0.52589703f, 0.44831410f, 0.05229526f, 
    -0.08619434f, 0.48255429f, -0.08638883f, 0.00313874f, -0.16022320f, -0.12125597f, -0.08650729f, 0.51671249f, 
    -0.25361043f, 0.00295091f, 0.44709697f, -0.41648036f, 0.11595317f, -0.01135660f, 0.03002770f, -0.14177978f, 
    0.11556394f, -0.01222883f, 0.11621334f, -0.00034087f, 0.17439178f, 0.08721138f, 0.00617369f, -0.38404006f, 
    0.07653382f, 0.02987746f, 0.43447551f, 0.05069096f, -0.00154211f, 0.33828846f, 0.10082065f, -0.07363234f, 
    -0.00502810f, -0.40201092f, 0.12733045f, -0.04327384f, 0.04743033f, 0.06231878f, 0.51856214f, -0.48995116f, 
    -0.10618803f, -0.05981853f, -0.32486203f, 0.19508539f, 0.05597806f, -0.05359865f, -0.07952788f, 0.12806851f, 
    0.14366522f, 0.44650456f, 0.11839087f, 0.50155985f, -0.04526794f, 0.20620339f, 0.30818361f, 0.11171150f, 
    0.22979262f, -0.08713949f, -0.51510727f, 0.04672512f, 0.25886828f, -0.21735275f, 0.33493328f, 0.10012984f, 
    -0.13359806f, 0.02443426f, 0.09931466f, 0.02991971f, 0.33872080f, 0.08335458f, -0.39847544f, 0.03824265f, 
    -0.01210892f, 0.45667008f, -0.26614323f, -0.25540653f, 0.37506300f, -0.14014450f, 0.04801703f, -0.08945460f, 
    0.46113461f, -0.07954534f, 0.05623076f, -0.31884894f, -0.02208936f, 0.29267207f, -0.17925550f, -0.74969798f, 
    0.21601251f, 0.30691376f, 0.05815797f, -0.12101380f, 0.18814538f, -0.34599024f, -0.08755192f, -0.08701313f, 
    -0.09879012f, 0.16317642f, -0.01113422f, -0.02753017f, 0.30679446f, 0.13165015f, -0.52285296f, 0.04505644f, 
    -0.27681863f, 0.49539480f, -0.00160039f, -0.35384947f, 0.03500135f, 0.12453125f, -0.06131900f, 0.10984597f, 
    0.30203664f, -0.08078486f, 0.01155612f, -0.12884787f, 0.10826048f, 0.28350013f, -0.02949229f, 0.05381329f, 
    0.21035565f, -0.34406796f, -0.16134568f, -0.03587603f, 0.34761894f, -0.38600916f, 0.21814689f, 0.14713970f, 
    -0.16700840f, 0.10305032f, 0.09067591f, -0.07022949f, -0.15374185f, -0.09979976f, 0.41830060f, -0.39083794f, 
    -0.08325236f, -0.27576327f, -0.05758952f, 0.12157877f, 0.11070052f, -0.11833901f, -0.14771347f, -0.09327669f, 
    -0.01655281f, 0.25898799f, -0.08045085f, 0.02803678f, -0.09135289f, 0.22094460f, -0.15851310f, 0.00419377f, 
    -0.28071353f, -0.05618905f, -0.21959531f, 0.02976033f, 0.02024324f, 0.37087810f, 0.06787078f, -0.17198643f, 
    -0.10343268f, 0.06974112f, -0.14920405f, 0.06433761f, -0.17274055f, 0.04585009f, -0.15095346f, -0.09407352f, 
    0.11136552f, 0.04073400f, 0.11708660f, 0.04122496f, -0.09503203f, -0.07585435f, -0.13002835f, -0.14864251f, 
    -0.01019212f, -0.04414878f, 0.13869318f, 0.01396446f, 0.06509530f, -0.09944230f, -0.11548408f, 0.06761750f, 
    -0.20288412f, -0.03539899f, -0.02026473f, -0.14044988f, -0.07502019f, 0.00479746f, -0.05879987f, 0.13850302f, 
    0.00029220f, -0.09916938f, 0.03979649f, 0.05764144f, -0.01851404f, -0.08728507f, 0.05249814f, 0.07172087f, 
    -0.07804127f, 0.09266581f, 0.16132075f, -0.04081385f, -0.17664450f, -0.17188077f, 0.10285985f, 0.04040131f, 
    -0.14583217f, -0.07464759f, 0.12193926f, -0.03787826f, 0.06123305f, 0.05950351f, -0.08844955f, 0.02727925f, 
    -0.01080799f, 0.06252626f, 0.05338735f, 0.02537415f, -0.00710960f, -0.09952162f, -0.10089241f, 0.17452790f, 
    0.11378103f, 0.29508191f, 0.13046749f, -0.09333886f, -0.18357456f, 0.07976929f, 0.04951027f, 0.36073372f, 
    -0.25899217f, -0.07882354f, 0.36161864f, -0.15116662f, -0.01681120f, 0.15499337f, -0.09502418f, 0.13497964f, 
    0.02815855f, 0.20171794f, 0.10798799f, 0.35453480f, -0.16686642f, -0.07371631f, -0.18298648f, 0.73131412f, 
    0.45754579f, -0.10598893f, -0.25295365f, -0.00722993f, 0.24149610f, 0.10675786f, 0.08973981f, -0.10193584f, 
    0.17074302f, 0.44556496f, 0.09628835f, 0.16751759f, 0.06070457f, -0.13550308f, 0.22973868f, -0.08634723f, 
    0.23460540f, 0.04699254f, 0.11569458f, 0.00278660f, 0.11257933f, 0.10089678f, -0.12777972f, 0.15587057f, 
    0.05957801f, -0.24074271f, 0.00560621f, 0.12330683f, -0.04441068f, -0.28502840f, 0.26027212f, -0.59503824f, 
    -0.29712984f, 0.21628617f, -0.09333754f, -0.02402063f, -0.23593517f, -0.12102558f, -0.33092669f, 0.13688721f, 
    0.16964936f, -0.05122488f, -0.03121838f, -0.16704847f, -0.09915947f, -0.08533546f, -0.00913663f, 0.09797313f, 
    -0.00594303f, -0.00254843f, -0.03538603f, -0.10725566f, -0.03153170f, -0.08249040f, -0.00608050f, -0.16914731f, 
    0.11849077f, -0.10750096f, 0.06780785f, -0.14141625f, 0.07147107f, -0.03567943f, -0.16368356f, 0.08143441f, 
    0.12009963f, -0.10858125f, 0.13036078f, 0.05958568f, -0.12897329f, -0.12169057f, 0.08909155f, -0.04711236f, 
    -0.00203544f, -0.19065970f, 0.14208372f, -0.13201192f, 0.02561729f, 0.06353575f, 0.61089277f, -0.04980932f, 
    0.33399528f, 0.06587834f, -0.07935461f, 0.40815878f, 0.15625799f, 0.00009878f, -0.03971541f, -0.17642416f, 
    0.22581117f, 0.04228310f, -0.07894819f, -0.00492775f, 0.08597320f, -0.05172137f, -0.20143685f, -0.25062138f, 
    -0.04453189f, 0.50341004f, -0.14549924f, 0.14036541f, -0.23743315f, 0.08220126f, -0.29731104f, 0.07674341f, 
    -0.14319874f, 0.13857104f, 0.16145504f, 0.11627129f, -0.03093038f, -0.06568360f, -0.14850834f, -0.31794387f, 
    -0.22105135f, 0.26179007f, 0.07866643f, -0.18906999f, 0.25820315f, -0.08955217f, -0.04471811f, -0.16481437f, 
    -0.13311568f, 0.15566726f, -0.02276575f, -0.32609800f, -0.13464931f, 0.08813438f, 0.21777517f, -0.15648712f, 
    -0.33870772f, 0.05585440f, -0.06260448f, -0.04159527f, -0.11776181f, -0.68205935f, -0.58076489f, -0.07248865f, 
    -0.02542774f, 0.12705193f, -0.00918038f, 0.14417918f, -0.11666427f, -0.16136155f, 0.10653353f, 0.59055531f, 
    -0.00941955f, 0.28230298f, 0.01310896f, -0.27052870f, -0.12783371f, 0.04486902f, -0.15791345f, -0.10829251f, 
    0.05946259f, -0.13994165f, 0.05380268f, -0.56097829f, 0.09801544f, 0.29679945f, 0.15922807f, -0.27639219f, 
    -0.21059398f, -0.07077775f, 0.16467185f, -0.05314545f, 0.17281967f, 0.27021977f, -0.31651875f, -0.15163432f, 
    0.08138438f, 0.08223783f, 0.04996702f, 0.09185564f, 0.02576489f, 0.04263272f, -0.16738583f, 0.04142756f, 
    0.11009712f, 0.07693586f, 0.02263031f, -0.19373702f, -0.16007331f, -0.02351508f, -0.08591136f, -0.06014317f, 
    0.02430012f, -0.08105574f, 0.09833822f, -0.11832397f, 0.17299455f, 0.05282198f, -0.13370745f, -0.14081647f, 
    -0.10037132f, -0.05264342f, -0.11631083f, -0.11470668f, 0.14433843f, 0.07200260f, -0.00965517f, 0.07763298f, 
    -0.01020278f, 0.09456617f, -0.16301581f, 0.09608560f, -0.10980088f, 0.00470924f, -0.10733241f, -0.18062554f, 
    -0.07837045f, -0.18390407f, -0.10224991f, -0.09300436f, 0.01808660f, -0.17781447f, 0.12483644f, -0.16390403f, 
    -0.18960090f, 0.14739609f, -0.11766690f, -0.05656698f, 0.07522519f, -0.18768135f, -0.04003870f, 0.02974292f, 
    -0.09020448f, 0.02408758f, -0.14716075f, 0.07792255f, 0.10110613f, 0.15922320f, -0.01130167f, -0.02839433f, 
    0.12248028f, -0.08754158f, 0.15091917f, 0.03755085f, -0.08581615f, 0.06855652f, 0.10166952f, -0.18469891f, 
    -0.09969439f, 0.01860981f, -0.02287553f, 0.02709591f, -0.08166740f, 0.15195517f, 0.14164072f, -0.16751477f, 
    -0.02544256f, -0.18309808f, 0.06936558f, 0.00924456f, 0.09491642f, -0.05809466f, -0.15402539f, 0.08735934f, 
    0.00780899f, 0.05646238f, 0.10017747f, -0.05059433f, -0.18742876f, -0.04474443f, 0.09168283f, 0.05261897f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.23644444f, -0.06843966f, 0.16972685f, 0.03581244f, 0.01482353f, 0.10593259f, 0.37398466f, 0.11915070f, 
    0.11764412f, 0.20694534f, -0.09689011f, 0.25960958f, 0.10151622f, -0.13573140f, -0.06889506f, 0.05506733f, 
    -0.00012654f, 0.28246289f, 0.20716685f, 0.17381285f, 0.01529538f, -0.16289586f, -0.01559562f, 0.02852991f, 
    0.17217058f, 0.00975884f, -0.00418721f, 0.02340146f, -0.27365744f, 0.09348643f, -0.03913305f, -0.14399661f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.20012641f, -0.08783508f, 0.11129850f, 0.43040270f, 0.13219611f, 0.04392757f, 0.28288072f, -0.14450240f, 
    0.11348952f, -0.04588001f, 0.57547104f, 0.52772838f, 0.09631694f, -0.18638773f, -0.50902575f, -0.03244071f, 
    0.48677501f, -0.23837025f, 0.63004893f, 0.43334621f, -0.42308792f, 0.06276008f, -0.08106430f, -0.07474693f, 
    0.30650058f, -0.09118354f, 0.04556313f, 0.34253681f, 0.98633599f, 0.20020020f, 0.16192050f, -0.00293006f, 
    -0.01044112f, 0.01511655f, 0.08406220f, -0.08881295f, -0.18281795f, 0.09409630f, 0.02943267f, -0.12778710f, 
    0.00177811f, -0.04136479f, -0.06573804f, -0.11407857f, -0.09288386f, 0.07395978f, -0.05311039f, -0.16598859f, 
    -0.05684622f, 0.15629373f, 0.06921513f, -0.04503631f, 0.01444495f, -0.11646660f, 0.08727500f, 0.11344804f, 
    -0.03635041f, -0.04089127f, -0.14532578f, -0.13832760f, -0.07145418f, 0.12441318f, -0.00860259f, 0.09792135f, 
    0.28297102f, 0.22896191f, 0.01595533f, -0.15321517f, 0.21217397f, 0.52931362f, 0.19849972f, 0.09930744f, 
    0.08047144f, 0.21771869f, -0.37559459f, -0.15063252f, -0.01579626f, -0.14068724f, 0.79312742f, 0.34668884f, 
    -0.40402249f, 0.30844539f, -0.56884050f, 0.06883316f, 0.24401991f, 0.14142708f, -0.12101001f, 0.01015608f, 
    0.07232554f, 0.09611025f, -0.01724689f, 0.09088264f, 0.16897780f, 0.12505919f, -0.17025322f, -0.03796538f, 
    0.71866059f, 0.10778358f, -0.56897891f, 0.14842242f, -0.14542311f, 0.52750772f, 0.43449822f, 0.22337706f, 
    0.13883643f, 0.18985985f, -0.26660705f, 0.41253161f, 0.18650441f, -0.16624112f, 0.31679446f, 0.32164475f, 
    -0.38076302f, 0.30161175f, -0.43615788f, -0.52827245f, 0.19623242f, 0.09440312f, -0.07291523f, -0.25852165f, 
    0.23981482f, 0.11890966f, 0.16384980f, -0.26818499f, 0.04399209f, 0.05892900f, -0.07884167f, -0.04945675f, 
    -0.12750621f, -0.13350427f, -0.09795860f, -0.18968178f, -0.19131464f, 0.11898130f, 0.06723556f, -0.20763469f, 
    -0.13746616f, 0.15555225f, -0.06527892f, -0.15097292f, 0.05334055f, 0.08313570f, -0.07624229f, 0.11733752f, 
    0.00264718f, -0.16560240f, 0.08675872f, -0.12898967f, 0.13256587f, 0.06662644f, -0.11482112f, -0.07993739f, 
    -0.05759869f, -0.12420418f, -0.07879075f, 0.05011119f, -0.13137159f, 0.14987028f, 0.07206978f, -0.00516917f, 
    0.17550787f, 0.30447587f, 0.21432872f, 0.28649580f, -0.29734975f, 0.03551888f, -0.41936484f, -0.18628198f, 
    -0.02990463f, 0.44899505f, -0.01481368f, 0.25379685f, -0.06761698f, 0.00676795f, 0.27533469f, 0.17021371f, 
    0.12718649f, 0.01408185f, 0.05496761f, 0.07644817f, 0.33956334f, -0.06306136f, 0.16630132f, -0.45582831f, 
    0.14072983f, -0.00038602f, -0.46030885f, 0.41244307f, 0.08556563f, -0.03626557f, -0.00645996f, 0.14608026f, 
    0.17940241f, 0.17612800f, -0.00789406f, 0.05165181f, -0.33968547f, 0.05136784f, -0.13284329f, -0.02950736f, 
    0.13796315f, -0.18184669f, -0.04267858f, 0.19776025f, -0.06290410f, -0.04639137f, -0.01248725f, 0.30925983f, 
    0.07963462f, 0.18353868f, 0.02821934f, -0.11853307f, 0.53285110f, -0.12554604f, 0.13809814f, 0.30356443f, 
    -0.17525153f, 0.11537363f, 0.10449246f, -0.40877408f, -0.31220660f, 0.06016944f, -0.17731883f, 0.07828761f, 
    0.15603638f, -0.21604945f, 0.27290919f, -0.01466251f, 0.11646051f, -0.13508172f, 0.24432698f, -0.12724029f, 
    -0.05745114f, 0.17257755f, 0.32009906f, 0.34035596f, 0.17115942f, 0.03521382f, 0.42241293f, 0.34783274f, 
    -0.01530735f, 0.03896231f, 0.16116840f, 0.62220204f, -0.28122550f, 0.07096250f, -0.12241495f, -0.39856124f, 
    -0.15277267f, -0.10463944f, -0.29174131f, -0.27991757f, 0.73271710f, -0.09899733f, 0.07740297f, 0.06827711f, 
    0.03165178f, -0.08679117f, -0.02349229f, -0.09494974f, 0.04081170f, 0.00751173f, -0.14085129f, -0.17870036f, 
    -0.08347777f, -0.16601157f, 0.13942029f, 0.09484246f, -0.01991882f, -0.14584114f, -0.17341869f, 0.07699408f, 
    -0.15538076f, -0.03547817f, -0.09081715f, -0.19592096f, -0.17335844f, -0.07883359f, -0.14049090f, -0.14598089f, 
    -0.19367801f, -0.17488746f, -0.01732464f, 0.13590898f, 0.07598373f, 0.16603872f, -0.17653799f, -0.15674247f, 
    -0.02319031f, -0.06218722f, -0.12960897f, -0.16588828f, -0.19168240f, 0.05009429f, 0.05297651f, -0.08426336f, 
    0.00562652f, -0.10475388f, -0.13669285f, 0.03711296f, -0.07613514f, 0.00784892f, -0.16499463f, -0.16361703f, 
    0.00201078f, 0.13926065f, 0.13400194f, -0.04547918f, 0.07836422f, 0.09724614f, -0.07627829f, 0.04496310f, 
    -0.04821743f, 0.14784347f, 0.01414381f, -0.00959100f, 0.16981053f, 0.12678269f, -0.12051903f, 0.06005641f, 
    0.10967702f, -0.07941298f, -0.06192780f, 0.03493498f, 0.08053512f, -0.07037411f, -0.02465774f, 0.03796462f, 
    0.08631533f, 0.02487117f, -0.15826514f, -0.07137634f, -0.10684820f, 0.09175052f, 0.07059513f, -0.12606867f, 
    0.09098202f, -0.09404909f, 0.00970326f, 0.00082907f, 0.15128635f, 0.08585951f, 0.07164638f, -0.05261492f, 
    -0.16489640f, -0.04502965f, -0.13360195f, -0.12201614f, 0.12246197f, 0.09267303f, 0.04527402f, -0.07157485f, 
    -0.05125623f, 0.15508890f, 0.44742018f, -0.10462055f, 0.38914558f, 0.09703773f, 0.01677231f, 0.33870953f, 
    0.00622079f, -0.18158583f, -0.18390888f, -0.38063294f, -0.00733333f, 0.15074205f, 0.04481810f, 0.23488690f, 
    0.04081132f, 0.39081100f, -0.18368284f, -0.24153177f, 0.36858803f, 0.18022232f, -0.16133602f, 0.35120860f, 
    -0.40178654f, -0.11276801f, 0.21009903f, -0.45937204f, -0.11036006f, 0.03472883f, -0.07929861f, -0.12090405f, 
    -0.19791149f, 0.17338838f, 0.45613092f, -0.14107274f, -0.27202377f, 0.35219330f, 0.21795762f, 0.11454120f, 
    -0.13578291f, 0.07092635f, -0.37454304f, 0.06268954f, 0.17702734f, 0.01528398f, 0.10155305f, -0.05783916f, 
    -0.24515916f, 0.46729702f, 0.14677300f, 0.34295619f, 0.14714427f, -0.00425264f, 0.07413112f, -0.13673908f, 
    0.14096460f, -0.01574682f, -0.04448118f, -0.39936936f, -0.55443776f, -0.14308728f, -0.12666404f, 0.08976377f, 
    -0.38916680f, -0.24335897f, 0.38809115f, -0.14848228f, 0.36991459f, 0.11933650f, 0.31165290f, -0.11982352f, 
    0.15909009f, -0.32021216f, 0.05039036f, 0.56531292f, 0.20391785f, 0.12248847f, 0.18202071f, 0.15433006f, 
    0.26683077f, 0.22708921f, 0.35690877f, 0.54289824f, -0.43392396f, 0.16862461f, 0.12381663f, 0.42609388f, 
    -0.36890480f, 0.06092457f, -0.33783534f, -0.16045296f, 0.40302584f, -0.11199012f, 0.13966221f, 0.03203895f, 
    -0.42155251f, -0.11617148f, 0.39599767f, -0.26491302f, 0.46454921f, 0.27581191f, 0.34964988f, 0.25642380f, 
    0.09296470f, -0.28951845f, 0.02541245f, 0.24175771f, -0.12422740f, 0.10570461f, 0.54269254f, -0.21430762f, 
    -0.03935473f, 0.03240005f, 0.28870505f, 0.54084659f, -0.57595527f, 0.07560343f, -0.15773821f, 0.45846125f, 
    -0.15918066f, 0.12878001f, -0.17656521f, -0.08052931f, 0.41900349f, 0.14817692f, 0.05857248f, -0.13211970f, 
    -0.11067896f, 0.26686910f, 0.61799556f, -0.00381572f, -0.04583501f, -0.41587284f, -0.29459736f, -0.09064487f, 
    0.02161323f, -0.21924521f, 0.29665148f, 0.43378043f, 0.36923617f, 0.02521064f, 0.16096380f, 0.49816582f, 
    -0.00871537f, 0.31380075f, 0.07631002f, 0.15844500f, -0.05389478f, 0.12599467f, 0.17412592f, -0.09428307f, 
    -0.25813684f, 0.15018143f, -0.31833535f, -0.66687304f, -0.14160089f, 0.07127173f, -0.14388585f, -0.18329290f, 
    0.05287115f, 0.30382195f, 0.29044101f, 0.51401275f, 0.16957811f, 0.05570752f, -0.23501696f, -0.10508451f, 
    0.09108564f, 0.46849382f, -0.14481281f, -0.16596383f, -0.17695856f, 0.10734659f, 0.19284840f, 0.04633944f, 
    -0.02841984f, -0.14648816f, 0.08344241f, 0.06140424f, 0.32948276f, 0.07502481f, 0.16864227f, -0.21053967f, 
    0.39142051f, 0.06156369f, -0.36264256f, 0.56776202f, -0.22107278f, -0.07935945f, 0.02312095f, -0.13181752f, 
    -0.58705944f, 0.23775123f, 0.65514922f, -0.11229436f, 0.16723743f, -0.57085681f, -0.42138577f, 0.40604144f, 
    -0.14067580f, 0.16117552f, -0.24468367f, -0.13718301f, 0.42595124f, 0.03585229f, 0.29371434f, -0.13294508f, 
    -0.35275200f, 0.24171059f, 0.35299015f, 0.25648218f, -0.37366441f, 0.03977099f, -0.16726917f, -0.27731517f, 
    -0.10926671f, 0.03772951f, 0.00594592f, -0.04373820f, -0.34836408f, 0.04145972f, 0.14047067f, 0.11092938f, 
    -0.07733993f, -0.13838790f, -0.04970570f, -0.02953137f, 0.07219280f, -0.05612663f, -0.16768543f, 0.05969298f, 
    -0.03789749f, -0.15825848f, -0.07365654f, 0.12846123f, -0.17437768f, -0.04523668f, 0.10816167f, 0.02717519f, 
    -0.08776876f, -0.14567970f, -0.03424414f, 0.05684128f, -0.07233351f, 0.06496236f, -0.11667004f, 0.06203263f, 
    0.03900770f, -0.12614393f, 0.08872517f, 0.05592355f, 0.11357604f, -0.11731480f, -0.10120967f, 0.13195300f, 
    -0.07770053f, -0.05504812f, -0.34853882f, -0.02774046f, -0.34934023f, 0.23711452f, 0.45461705f, 0.16970749f, 
    -0.12448963f, 0.08841155f, 0.20339744f, -0.07131326f, -0.07486381f, -0.02122746f, -0.55993044f, -0.03739426f, 
    -0.07110413f, 0.16282150f, 0.40673381f, 0.14459461f, 0.48732334f, 0.05768932f, -0.11887455f, 0.05512043f, 
    0.08640962f, -0.10568511f, 0.56487089f, 0.12418030f, -0.00184111f, -0.02201635f, -0.03034696f, -0.06341054f, 
    0.23795630f, -0.20227058f, -0.50088811f, -0.00476050f, 0.22762100f, 0.42106539f, 0.36587527f, 0.34061691f, 
    0.18121314f, 0.22337674f, -0.12208746f, 0.04007032f, 0.01722202f, -0.06505357f, -0.00977262f, -0.00271234f, 
    -0.03816665f, 0.30636454f, -0.14009850f, -0.48951867f, -0.11291440f, -0.09804630f, 0.13554102f, 0.00185406f, 
    0.29577029f, 0.15439296f, 0.51393592f, 0.23803876f, -0.03849662f, -0.11271990f, 0.06260132f, -0.00483341f, 
    0.25834608f, 0.33955306f, -0.35621133f, 0.19358027f, -0.31155562f, -0.13718817f, -0.26286080f, -0.16595645f, 
    0.11560689f, 0.29160839f, 0.14940424f, 0.39344057f, 0.38209900f, -0.19381508f, 0.01412663f, 0.39407983f, 
    0.07384188f, 0.05399249f, 0.09431403f, -0.07339644f, 0.19566597f, 0.17450076f, -0.10521828f, -0.43677351f, 
    -0.16394159f, -0.03078560f, 0.12746601f, -0.14664167f, 0.10427903f, -0.04117047f, -0.19009216f, -0.14800754f, 
    0.03550311f, -0.14346287f, 0.07372332f, -0.04243768f, -0.19640328f, -0.04918308f, 0.00286470f, -0.16508855f, 
    0.02692246f, -0.02780070f, 0.09465262f, -0.14473671f, -0.13354833f, -0.05947309f, 0.13503371f, -0.08977562f, 
    -0.04852296f, -0.09600230f, 0.03729810f, 0.01752524f, -0.06930179f, -0.12227457f, 0.06685632f, 0.10070488f, 
    -0.10632072f, 0.15202980f, -0.16621801f, -0.16543250f, 0.04811406f, 0.11952443f, 0.00714794f, -0.07721498f, 
    0.50081843f, 0.31668085f, -0.39516345f, 0.57352537f, 0.23805538f, 0.03910168f, -0.28837585f, 0.23572028f, 
    -0.05536684f, 0.31886256f, 0.31449383f, -0.27200890f, -0.02225447f, -0.05652355f, -0.25779930f, 0.07298142f, 
    0.33007440f, -0.11995143f, -0.14360668f, -0.37396282f, 0.00753514f, 0.09543969f, -0.04555326f, 0.05138070f, 
    0.27251753f, 0.09396020f, 0.22204293f, 0.61320132f, 0.64180332f, -0.12965438f, 0.08136357f, 0.12236813f, 
    -0.16224575f, -0.19791429f, -0.07815884f, 0.03539731f, -0.04020586f, 0.13892592f, -0.11625671f, -0.14073041f, 
    0.09094818f, 0.12222096f, 0.12375149f, -0.08950945f, -0.09467758f, -0.05703636f, -0.03131152f, -0.04930862f, 
    -0.03340736f, 0.05034633f, -0.19987647f, -0.04959618f, -0.16514231f, -0.10734069f, 0.00204400f, 0.06109150f, 
    0.12469140f, 0.08929788f, -0.12908787f, -0.10061612f, 0.05276284f, -0.08670831f, -0.10284334f, 0.00556945f, 
    -0.20528215f, 0.16205950f, 0.19989066f, 0.05632807f, 0.54580045f, 0.43279055f, 0.39992601f, 0.25272062f, 
    0.15165168f, 0.18227060f, -0.50906920f, -0.38960916f, -0.43264097f, 0.03408511f, 0.59030682f, 0.16293193f, 
    0.37490681f, -0.07191647f, -0.37786889f, 0.05187031f, 0.30239472f, 0.11231623f, 0.09611447f, 0.65254480f, 
    0.34912673f, -0.16823930f, -0.29974300f, 0.49340555f, -0.67931384f, -0.06312507f, 0.06315548f, -0.05434645f, 
    -0.00151375f, 0.08124234f, -0.25634998f, -0.22704758f, -0.01154666f, 0.07191438f, 0.04714364f, -0.05513356f, 
    -0.06268401f, -0.14012751f, 0.04535776f, -0.19633473f, -0.05875520f, 0.02070671f, 0.13638616f, 0.03225370f, 
    -0.06289952f, -0.18757996f, -0.20581895f, -0.04346483f, 0.07250687f, 0.05678361f, 0.17541023f, -0.15973130f, 
    -0.23087563f, -0.01485917f, 0.16727595f, 0.03954757f, -0.09149303f, 0.05437961f, 0.04826090f, 0.07482950f, 
    -0.16364546f, -0.04803360f, 0.01066297f, 0.04255353f, -0.03898789f, 0.10605327f, 0.02188448f, -0.11809881f, 
    -0.15125702f, -0.16134098f, -0.04206775f, -0.08052050f, -0.12377836f, 0.07950610f, -0.02613787f, 0.09678163f, 
    0.09790590f, -0.01210331f, 0.14162603f, -0.05500982f, -0.05489605f, -0.13420554f, -0.07796071f, -0.12999852f, 
    -0.05447638f, 0.07149874f, -0.12739368f, -0.16245040f, -0.02123086f, -0.03098689f, 0.15444365f, -0.00892274f, 
    -0.10095174f, 0.11469965f, 0.44761139f, -0.36917126f, 0.28602582f, -0.06344341f, 0.29208967f, 0.07378436f, 
    0.08580305f, -0.51248622f, 0.06730369f, 0.41262862f, 0.00102423f, -0.13378699f, 0.20376253f, 0.41773349f, 
    0.14155269f, 0.22540730f, -0.32253674f, 0.05784436f, 0.43064362f, -0.06785598f, -0.09046977f, 0.31292030f, 
    -0.63685125f, 0.12812936f, -0.41634423f, -0.84974968f, 0.25385189f, 0.02508749f, 0.14525811f, 0.12989031f, 
    0.21378785f, 0.06135577f, -0.81597388f, 0.15640239f, -0.20810616f, 0.14943013f, -0.05054232f, -0.00672917f, 
    -0.13424693f, 0.09535861f, 0.41559279f, -0.01223167f, -0.07220965f, 0.15242775f, 0.31045312f, 0.34480613f, 
    -0.02810151f, -0.03627433f, 0.04532886f, -0.21469153f, 0.42960024f, -0.03129653f, -0.11535458f, 0.22917964f, 
    -0.51677656f, -0.14102444f, 0.37435246f, -0.09451757f, -0.50434136f, 0.09755013f, 0.10784903f, -0.00807529f, 
    -0.51096344f, 0.32610264f, 0.29554781f, 0.03209429f, -0.16257104f, -0.16722977f, 0.05624614f, 0.41459894f, 
    0.04849302f, 0.43410748f, -0.22775599f, -0.27153334f, -0.08147878f, 0.12358599f, -0.20045695f, -0.41607833f, 
    -0.15214340f, 0.22552666f, 0.48646355f, 0.15638529f, -0.02599247f, -0.08653922f, -0.16650827f, -0.17644267f, 
    0.57538509f, 0.14425762f, 0.41416436f, 0.61764961f, -0.29458007f, -0.11728022f, -0.06420369f, -0.17394930f, 
    0.04293438f, 0.23594229f, -0.48769659f, 0.21835259f, -0.21805048f, 0.09433965f, -0.03972301f, 0.04401451f, 
    0.15814006f, 0.00711003f, 0.13114664f, 0.24815984f, 0.32037038f, 0.10815045f, -0.46841827f, 0.31770957f, 
    -0.19795547f, 0.28226912f, 0.09091803f, -0.28207228f, 0.50417441f, 0.10636593f, 0.13087867f, -0.17212130f, 
    -0.12441754f, 0.06823169f, 0.38881773f, -0.14390860f, -0.19294277f, -0.13584644f, -0.08374830f, -0.09159466f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.03430157f, -0.17175707f, 0.02201461f, 0.22435573f, 0.06483574f, 0.22568822f, 0.19453010f, 0.20781641f, 
    -0.00074661f, -0.15740614f, -0.15665263f, -0.02043990f, 0.36349645f, -0.00567868f, 0.05527424f, 0.03935014f, 
    0.07666758f, 0.00312554f, -0.04620302f, 0.34330449f, 0.09601992f, -0.02110068f, 0.10212228f, -0.05395830f, 
    -0.06517994f, 0.03915840f, -0.05655726f, -0.12225416f, 0.22772479f, 0.02299266f, 0.13157797f, 0.32037690f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.24357884f, -0.18075091f, -0.48827836f, 0.15633988f, 0.13138232f, 0.38462409f, 0.18798155f, 0.19670956f, 
    -0.04775298f, 0.01615394f, 0.08038158f, -0.57126129f, -0.35679135f, -0.07798133f, -0.45685840f, 0.32348213f, 
    -0.07175683f, -0.48543876f, -0.03850143f, -0.02753568f, -0.21624166f, 0.49184093f, 0.12480158f, -0.02062437f, 
    -0.01380878f, -0.49130571f, -0.02712476f, -0.14203122f, -0.37816253f, 0.32227603f, -0.31529558f, 0.22680111f, 
    -0.24783000f, -0.17926806f, 0.05672242f, 0.30719006f, 0.11868048f, -0.23873462f, 0.36935362f, -0.04430459f, 
    -0.09439861f, 0.00408890f, -0.06332378f, 0.17367223f, -0.05310217f, 0.03256793f, -0.14450403f, 0.01600072f, 
    -0.21522880f, -0.70845127f, 0.05012742f, 0.12219305f, -0.00771414f, 0.26656377f, 0.14109182f, -0.09212724f, 
    -0.05263153f, 0.00806726f, 0.01637376f, -0.12530369f, 0.22871998f, 0.41130704f, -0.52470726f, 0.39259517f, 
    -0.65848362f, 0.06105604f, 0.01987269f, 0.22331253f, -0.03467039f, -0.46564865f, 0.08989269f, -0.28206089f, 
    -0.09559005f, 0.03803676f, -0.16789012f, 0.46733838f, 0.04055780f, -0.51300991f, -0.47306532f, 0.01899644f, 
    -0.37522575f, 0.59703082f, 0.07634713f, 0.30125681f, 0.30123934f, 0.15184286f, 0.09277709f, 0.15082344f, 
    0.10502635f, -0.81861955f, -0.13981530f, -0.11448070f, -0.37475353f, 0.15240814f, 0.36018541f, 0.44483191f, 
    0.02627690f, -0.01865542f, 0.07415220f, -0.40115947f, -0.10480243f, 0.18706362f, -0.52816844f, 0.09134056f, 
    0.04456055f, -0.05547324f, -0.05876577f, 0.05827931f, -0.24642248f, -0.04715470f, 0.22157918f, -0.76618296f, 
    0.33773747f, -0.50998789f, 0.14453697f, 0.14887223f, -0.17025341f, -0.60395330f, 0.10890269f, 0.11905347f, 
    -0.01312846f, 0.46013430f, -0.06291967f, 0.12015429f, -0.43362561f, -0.20452678f, 0.11558095f, -0.81820160f, 
    0.18044882f, 0.02685893f, -0.32753634f, 0.00329859f, 0.14808899f, -0.11495552f, -0.37031040f, 0.26327133f, 
    -0.10284085f, 0.03354784f, -0.09178197f, -0.59403104f, 0.08893034f, 0.11073997f, 0.35474283f, -0.25263670f, 
    -0.17106622f, 0.08062713f, -0.03116674f, 0.32135946f, 0.07735954f, 0.02931708f, -0.07701793f, -0.29869089f, 
    -0.05638400f, -0.49566302f, 0.11821014f, -0.10948257f, -1.19631386f, 0.12566790f, 0.28291339f, 0.01940548f, 
    0.26403490f, -0.13160838f, -0.05927729f, 0.21030067f, 0.10730682f, -0.51647615f, 0.00487227f, 0.20566681f, 
    -0.09373908f, -0.17689183f, -0.02613244f, 0.08695714f, -0.23455024f, 0.28518346f, 0.27618960f, 0.09270592f, 
    -0.38085377f, -0.47967428f, 0.10145768f, -0.07124161f, -0.03265214f, -0.18714714f, -0.07623912f, -0.03824506f, 
    0.02382154f, -0.22599132f, 0.07203459f, -0.11988011f, 0.35074991f, -0.77902603f, -0.58560807f, -0.16823748f, 
    -0.01343085f, -0.01890977f, -0.41077560f, -1.03211141f, 0.12139851f, -0.56818134f, 0.13566451f, -0.07686845f, 
    -0.13657723f, 0.15205704f, 0.13139826f, 0.30363640f, 0.02183810f, 0.33186895f, 0.40521523f, 0.21895857f, 
    -0.65948087f, 0.30562195f, -0.00306335f, -0.05760159f, -0.65162748f, -0.47536001f, 0.03008434f, -0.78701043f, 
    -0.04192669f, 0.24997196f, -0.12615502f, -0.12211217f, 0.22315755f, -0.27570799f, 0.04038783f, -0.27781874f, 
    0.13090685f, 0.09292576f, -0.63863117f, -0.35541609f, 0.00569121f, 0.29500887f, 0.12619422f, -0.48527122f, 
    0.00183194f, -0.18658374f, -0.07273052f, 0.01549218f, -0.98774886f, -0.60735583f, -0.52624214f, -0.22092286f, 
    0.33008915f, 0.11054841f, 0.12045700f, -0.27644929f, -0.05477709f, 0.10877132f, 0.05631764f, 0.56345898f, 
    -0.14032747f, 0.10228474f, 0.09978046f, -0.16247597f, -0.19865628f, 0.45783469f, 0.24792728f, -0.22356156f, 
    -0.82514662f, -0.03279297f, 0.53853071f, 0.30397984f, 0.15401088f, -0.16781400f, 0.15233938f, -0.08872691f, 
    0.14156644f, -0.16348638f, -0.17203285f, 0.25356218f, -0.11172264f, -0.08471009f, 0.24349661f, -0.05854713f, 
    -0.39547759f, -0.18998647f, 0.03385649f, -0.56686312f, 0.02703817f, -0.28589031f, 0.07619697f, -0.19837318f, 
    -0.08900715f, 0.35671735f, -0.13845883f, 0.07420121f, 0.36914563f, 0.28945944f, -0.47069439f, -0.20565760f, 
    -0.09229790f, -0.06982212f, -0.07455198f, -0.34166184f, -0.14847562f, 0.25583431f, 0.17027983f, 0.22867398f, 
    0.15192057f, 0.00847287f, 0.15627046f, -0.14602076f, 0.36881632f, -0.02937459f, -0.03595294f, 0.32023582f, 
    -0.04340211f, 0.21747075f, -0.15973832f, -0.10272516f, -1.14771223f, 0.25817981f, 0.08085892f, -0.43528599f, 
    0.01546018f, -0.31410101f, -0.08186833f, -0.16086325f, -0.23736145f, -1.07249343f, 0.14055482f, 0.02387743f, 
    -0.19826192f, -0.13219376f, -0.05484940f, 0.41622233f, -0.10822995f, -0.21487615f, 0.25151643f, -0.53402901f, 
    -0.02648643f, -0.14977939f, -0.14308596f, 0.15727843f, 0.24026264f, -0.38458961f, -0.29903996f, -0.88733685f, 
    -0.01622748f, -0.62594336f, 0.14263873f, 0.35101777f, 0.43549177f, -0.37666789f, 0.00922221f, 0.00048713f, 
    0.04854838f, 0.34362006f, 0.01199160f, 0.09449695f, -0.18032192f, -0.31682739f, 0.35876054f, 0.06168884f, 
    -0.50964314f, 0.10950804f, 0.39976680f, 0.20444810f, 0.07556198f, 0.20272380f, -0.39881909f, 0.12678523f, 
    -0.09164034f, 0.14031540f, 0.14138114f, 0.14849727f, 0.11960422f, -0.19963756f, -0.06992988f, 0.00428090f, 
    0.25756374f, 0.36283922f, 0.07722025f, -0.64995927f, 0.04466007f, 0.00008207f, 0.03083978f, -0.04012841f, 
    -0.05450914f, 0.21178453f, 0.01140890f, 0.02271480f, -0.28356111f, -0.37813112f, 0.05224016f, -0.24908535f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.09447069f, -0.09488979f, -0.11621770f, 0.09968852f, 0.26317495f, -0.02501969f, -0.11851169f, -0.13955387f, 
    -0.11150837f, 0.15495221f, 0.13616839f, -0.15732820f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
