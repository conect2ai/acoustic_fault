#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.44908184f, 0.27814326f, 0.45865616f, 0.17088261f, 0.29657382f, 0.26506227f, 0.15157408f, -0.00732415f, 
    -0.27991033f, -0.28847501f, -0.43686467f, -0.37406343f, -0.05277669f, 0.47120383f, 0.79068851f, -0.13155298f, 
    -0.30079094f, 0.11982919f, -0.04245692f, -0.29634005f, -0.40335125f, 0.23254248f, 0.52138621f, 0.34850764f, 
    0.41741875f, 0.20160340f, 0.19670591f, -0.16177523f, 0.62842411f, 0.36397210f, 0.34778941f, 0.17022996f, 
    0.15063064f, 0.44098082f, -0.11672172f, 0.38265771f, -0.24406420f, -0.34145457f, -0.19520882f, 0.04305182f, 
    0.62285835f, -0.55197752f, -0.19489704f, -0.21323179f, -0.19260155f, 0.61826235f, -0.19394465f, -0.40469164f, 
    0.17410660f, -0.18083450f, 0.22003585f, -0.03274137f, -0.23330881f, 0.27806520f, -0.57508582f, -0.93309516f, 
    -0.62630844f, -0.63045132f, -0.09295225f, -0.01540156f, 0.09594273f, 0.15851584f, -0.04006600f, -0.43010578f, 
    0.66808122f, -0.16016443f, 0.24844790f, -0.13586134f, -0.25333095f, 0.00323024f, -0.11240488f, -0.26902199f, 
    0.58996582f, 0.23198596f, 0.41892937f, 0.38312411f, 0.12572239f, 0.07520749f, -0.47881740f, 0.12805685f, 
    0.06448846f, 0.41560689f, 0.43212944f, -0.05784467f, 0.06708140f, -0.25999960f, 0.13785495f, 0.41248924f, 
    0.44809508f, -0.06547320f, 0.37812656f, 0.27454501f, -0.57105243f, 0.60144824f, 0.49342975f, -0.23115429f, 
    0.19659168f, 0.22300217f, -0.19801661f, 0.77831590f, 0.37141284f, -0.07310412f, -0.22881418f, 0.13583988f, 
    -0.31105179f, -0.07150447f, 0.13771147f, -0.03065971f, -0.67476034f, 0.22377290f, 0.15347545f, -0.46869361f, 
    -0.47124019f, -0.18349180f, 0.23573273f, 0.11206202f, 0.02633670f, 0.01105034f, 0.45115340f, 0.10692184f, 
    0.25970009f, -0.46257567f, -0.48052374f, -0.31536621f, -0.05687534f, 0.22081667f, 0.25447205f, -0.43574631f, 
    -0.55671400f, 0.27387381f, 0.20012331f, -0.07183322f, -0.39432782f, 0.19164786f, 0.24951652f, -0.40932497f, 
    0.14649762f, -0.34358597f, 0.37603566f, -0.32000309f, 0.09793311f, -0.32607782f, 0.11308584f, -0.28981608f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.18350355f, -0.13978578f, -0.45984465f, -0.33657297f, -0.13241637f, -0.31161880f, 0.10647485f, -0.16873713f, 
    -0.03764093f, -0.15282029f, -0.11535656f, 0.06881398f, 0.14802077f, -0.27145532f, -0.29580370f, -0.45878547f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.15968525f, -0.30664644f, 0.01941988f, 0.13862349f, 0.10487708f, -0.02613553f, 0.03381257f, -0.05684005f, 
    0.17334104f, 0.26467252f, 0.20042919f, 0.07557138f, 0.07550983f, 0.07249594f, 0.02696451f, 0.01205487f, 
    0.08526827f, 0.13183814f, 0.04828384f, 0.00614206f, 0.10583807f, -0.13224080f, -0.16255088f, -0.07796844f, 
    0.00865544f, 0.16922480f, 0.05564654f, -0.16346732f, 0.03796547f, 0.01422109f, -0.01606978f, -0.10135455f, 
    -0.12014709f, -0.07143709f, -0.07444291f, -0.07967166f, -0.07124177f, 0.13773540f, -0.03335073f, 0.03715250f, 
    0.22464162f, 0.06723830f, 0.03314332f, -0.02448581f, -0.12044394f, -0.03310246f, -0.06991567f, 0.12461617f, 
    0.01570371f, 0.04242466f, -0.07412002f, 0.06366458f, 0.00788896f, -0.13497888f, -0.09257935f, 0.33903810f, 
    -0.18738776f, 0.00558987f, 0.00849054f, -0.04579990f, -0.03509125f, 0.03670372f, -0.14691101f, 0.41189489f, 
    -0.25855014f, 0.00116542f, 0.03459690f, -0.12560335f, 0.22006878f, -0.05005529f, 0.05896654f, -0.06957265f, 
    -0.56427950f, -0.14902757f, -0.00555061f, 0.06628203f, -0.00395088f, 0.02658691f, -0.03659483f, 0.07119012f, 
    0.03906757f, -0.01070137f, -0.30517444f, -0.18237452f, -0.02137632f, -0.10479929f, 0.06580706f, 0.03883510f, 
    0.09264547f, -0.03918979f, 0.03989093f, -0.02298804f, -0.08812432f, -0.11445619f, 0.03236442f, -0.07587631f, 
    0.04332330f, 0.11557415f, 0.00900737f, -0.06315219f, -0.02708426f, -0.19199830f, 0.06528848f, 0.10550901f, 
    0.00878741f, 0.03393258f, -0.12974963f, 0.06623995f, 0.01136164f, 0.20513995f, 0.07947326f, -0.01046042f, 
    -0.06232119f, 0.07817726f, -0.01895040f, -0.05752616f, 0.11504422f, 0.27123457f, -0.41713682f, 0.06472955f, 
    -0.00259917f, 0.06252161f, 0.14396696f, 0.03399779f, -0.02035365f, 0.01765860f, 0.19982742f, 0.12755391f, 
    -0.22343937f, -0.10187942f, -0.07993105f, 0.00068111f, -0.01274166f, -0.00790715f, -0.02842327f, -0.08056349f, 
    -0.05893958f, -0.02686103f, -0.01116514f, -0.00729648f, -0.08599528f, -0.13299736f, 0.02247312f, -0.00974773f, 
    -0.20710029f, -0.18798523f, -0.06027737f, -0.06447824f, 0.04556605f, 0.09650788f, 0.05291025f, 0.14724606f, 
    0.04847821f, 0.17506860f, 0.13824973f, -0.04544008f, -0.22290960f, 0.03445903f, -0.03344246f, 0.05292505f, 
    0.09679962f, -0.02724273f, 0.15344836f, 0.07864562f, 0.18252309f, -0.08666369f, -0.12645271f, -0.01471885f, 
    0.11624570f, -0.13300624f, 0.03172054f, 0.23958473f, 0.12064502f, -0.17612343f, -0.04922150f, 0.03671030f, 
    -0.04424929f, 0.09815326f, -0.06632614f, -0.12303665f, 0.01524402f, 0.05596192f, -0.00922584f, -0.08931793f, 
    -0.04581832f, -0.03295171f, 0.10513553f, -0.08891751f, -0.17804495f, 0.11578524f, -0.13112928f, -0.01989144f, 
    -0.05532258f, -0.16057791f, 0.25654215f, -0.19444062f, 0.04793815f, 0.00660866f, 0.23410420f, -0.15661937f, 
    0.08636548f, -0.26059198f, 0.03850930f, -0.01913916f, -0.10342576f, 0.16369303f, 0.00548287f, 0.45522064f, 
    -0.07579313f, -0.01921852f, -0.10446633f, 0.12375148f, -0.13238293f, 0.00350158f, 0.07554215f, -0.07306416f, 
    -0.34689456f, -0.19622748f, -0.14017199f, 0.02259624f, 0.10846801f, 0.08713223f, -0.01109128f, 0.01380059f, 
    -0.00470719f, -0.00625720f, -0.01648210f, 0.27307728f, 0.10662535f, -0.02735371f, 0.06978491f, 0.05572429f, 
    0.03309085f, -0.18464445f, 0.16868405f, -0.14896004f, 0.02810765f, -0.23848210f, -0.01723563f, 0.07855633f, 
    -0.09859022f, 0.07760020f, 0.07620910f, 0.08587319f, 0.06179557f, -0.03231756f, 0.04399352f, -0.02990923f, 
    0.16295414f, -0.09849769f, 0.06931752f, -0.03731966f, 0.11651592f, 0.00276254f, -0.14279319f, 0.14120448f, 
    -0.05125942f, -0.15403317f, -0.07698860f, -0.10587177f, 0.00214029f, 0.00847926f, -0.18572022f, -0.00362476f, 
    0.12971142f, 0.04840572f, -0.03023068f, -0.11426035f, 0.07289935f, -0.12367566f, 0.17055894f, -0.13701096f, 
    0.18531476f, -0.07099271f, 0.06599584f, -0.16733383f, 0.07879964f, -0.03515668f, -0.03647028f, 0.02888513f, 
    -0.18249966f, 0.10380629f, -0.20729707f, 0.07287277f, 0.11897842f, -0.09803596f, -0.08938217f, 0.18434660f, 
    0.08366945f, 0.00659929f, 0.23280971f, -0.10815793f, -0.09949704f, 0.15476094f, -0.01967991f, 0.10501922f, 
    -0.11982971f, 0.48451003f, -0.14773299f, -0.10804682f, -0.02625613f, -0.10821569f, 0.13333154f, 0.08832317f, 
    0.00559667f, 0.04502163f, 0.09791882f, -0.09763636f, 0.06307144f, 0.12272295f, 0.06468654f, -0.16115749f, 
    -0.02295974f, -0.22856691f, -0.12185635f, 0.19737238f, 0.13190795f, 0.03486857f, -0.14260432f, 0.01060819f, 
    -0.17525835f, -0.15177603f, -0.06026546f, -0.10125789f, 0.02422756f, -0.05800483f, -0.29653823f, 0.15051085f, 
    0.14617433f, 0.12565364f, -0.02521838f, -0.07899778f, 0.00096728f, -0.32965070f, -0.23863865f, 0.00700542f, 
    0.04180579f, -0.02584006f, -0.02814474f, 0.05951483f, 0.08495737f, -0.14053389f, 0.34620661f, -0.14485300f, 
    0.11131020f, -0.09884377f, -0.03584601f, 0.02453887f, 0.00498033f, -0.07869779f, -0.03588130f, 0.16643710f, 
    -0.00675236f, -0.26955956f, -0.08122508f, 0.14579232f, 0.06415128f, 0.13519560f, 0.04668849f, 0.04872552f, 
    -0.06354456f, 0.26924083f, 0.12096361f, -0.13590507f, -0.07295579f, 0.06768737f, 0.03106146f, 0.08293497f, 
    0.00607765f, -0.13718918f, 0.03477138f, -0.00986802f, -0.01738157f, 0.03876371f, -0.10059581f, -0.08622497f, 
    0.02681654f, -0.09344649f, -0.09838404f, -0.29539260f, 0.08256436f, 0.01596207f, 0.00322061f, -0.01732378f, 
    0.04632678f, -0.10625397f, 0.08765082f, 0.31056726f, 0.06847241f, -0.13673867f, -0.06739201f, -0.29137453f, 
    0.00379817f, -0.01344845f, 0.08983997f, 0.02982693f, -0.18056594f, -0.08627576f, 0.20318629f, 0.02566789f, 
    -0.00150349f, 0.00482321f, -0.07028338f, 0.13938338f, 0.01408929f, -0.14023089f, -0.04186791f, -0.05412688f, 
    -0.12850560f, 0.00325193f, -0.06856400f, 0.01799626f, 0.10021973f, 0.24915452f, -0.13290837f, 0.00827717f, 
    -0.03508914f, 0.03133235f, 0.06169822f, -0.04050696f, 0.07404996f, 0.05508585f, -0.02595019f, 0.00262157f, 
    -0.15878782f, -0.08594520f, -0.01207801f, -0.20101240f, 0.08773068f, 0.03249181f, 0.09601466f, -0.10994680f, 
    -0.01078797f, 0.12068958f, 0.12411471f, 0.12850645f, 0.06492537f, 0.05035451f, 0.11703435f, 0.11268304f, 
    -0.07732309f, 0.16202405f, -0.07406847f, 0.29451919f, -0.07695885f, -0.10659223f, 0.05905347f, -0.08300772f, 
    0.06916323f, 0.00427521f, -0.09965558f, 0.08091811f, -0.03933891f, -0.20780316f, -0.02865639f, 0.07123023f, 
    0.06018853f, -0.01018237f, 0.07515062f, 0.14935155f, 0.23150483f, -0.21160015f, 0.14385962f, -0.08311018f, 
    -0.20328866f, 0.02621289f, -0.04152159f, -0.00614450f, 0.06033062f, -0.12676395f, -0.20051312f, -0.07093500f, 
    0.05029875f, 0.17595728f, 0.04032245f, 0.02260581f, 0.11397181f, -0.06558926f, 0.01797123f, 0.03111276f, 
    -0.10878125f, 0.05127653f, 0.03521045f, 0.02067255f, 0.09268741f, -0.07588065f, -0.44766295f, 0.21042554f, 
    0.20839317f, 0.09187245f, -0.03334164f, 0.08524770f, 0.02657248f, 0.03872391f, -0.07326113f, -0.42849988f, 
    -0.14271021f, -0.45009014f, 0.03452921f, -0.04024756f, -0.17468528f, 0.08999056f, 0.10283118f, -0.01062483f, 
    0.08225361f, -0.02132391f, 0.00023801f, 0.01362874f, -0.00020384f, 0.07229716f, 0.07465752f, 0.03363458f, 
    0.18731582f, -0.05213718f, 0.15358344f, -0.07297441f, -0.00670215f, -0.07960407f, -0.06452900f, 0.03003538f, 
    -0.06562987f, -0.05528605f, 0.06637949f, -0.00362921f, -0.07532309f, -0.01840625f, -0.18069500f, -0.13041137f, 
    -0.07234734f, 0.07043771f, 0.16290750f, 0.18226069f, 0.01084180f, -0.09463114f, 0.06991408f, 0.15572883f, 
    0.02363279f, -0.06584311f, 0.03411790f, -0.08921883f, -0.00984476f, -0.21031299f, -0.09707615f, 0.00766713f, 
    0.06261241f, -0.19440328f, 0.06904480f, 0.09477844f, 0.10283779f, -0.43302965f, -0.20859319f, -0.40055531f, 
    0.06919321f, -0.01611536f, -0.09365092f, 0.21957259f, -0.08626290f, 0.19530097f, -0.07511901f, 0.31673279f, 
    -0.01899541f, 0.00279126f, -0.15017189f, 0.05325369f, 0.04471438f, -0.08766631f, 0.03165483f, -0.10666458f, 
    -0.28501040f, -0.26005214f, -0.20143802f, -0.01000420f, -0.02958507f, 0.09255409f, 0.01151689f, 0.03841570f, 
    -0.03052686f, 0.16211066f, 0.01996277f, 0.12006706f, -0.11914711f, -0.00780296f, 0.01377568f, 0.00911134f, 
    0.03768530f, -0.32247862f, -0.36464968f, 0.16042534f, 0.03631768f, 0.02361029f, -0.02524708f, -0.00120630f, 
    0.04729770f, -0.00755941f, -0.28437063f, 0.04186227f, 0.11307232f, -0.01595529f, -0.08578076f, 0.03186978f, 
    -0.04233396f, 0.03500826f, -0.06005232f, 0.09617821f, 0.00450645f, -0.24631432f, -0.08824876f, -0.08872680f, 
    0.01332303f, -0.17270134f, -0.02212961f, 0.08016536f, -0.20629090f, -0.24185571f, -0.16590993f, 0.08913668f, 
    0.10278305f, -0.10182585f, 0.13097671f, 0.03188420f, 0.08834179f, 0.08233768f, -0.09398615f, 0.08736348f, 
    0.06911949f, 0.01588008f, 0.09599554f, 0.00888928f, -0.01921698f, 0.10065338f, -0.29353261f, -0.03078845f, 
    0.12896746f, 0.09739448f, 0.08126836f, 0.01309582f, -0.10531171f, -0.10402058f, 0.05190364f, -0.41444525f, 
    -0.10814379f, 0.01159860f, 0.04579207f, 0.09590630f, 0.05182145f, -0.00741675f, 0.05435271f, -0.00027276f, 
    0.22254407f, 0.23637964f, 0.05727964f, -0.05337657f, -0.10141637f, 0.01760182f, -0.05717066f, 0.08320843f, 
    0.04538174f, 0.08726247f, 0.11986425f, -0.09640744f, -0.09486894f, 0.05018847f, -0.15762134f, 0.01061397f, 
    0.07967404f, -0.18777686f, 0.15004462f, 0.09399384f, -0.03569888f, -0.13691229f, 0.02320449f, 0.00771858f, 
    0.09348056f, 0.17831342f, -0.04482394f, 0.13470325f, 0.05209398f, 0.25107837f, -0.07892309f, -0.04090996f, 
    0.01324196f, 0.04237897f, -0.04733865f, 0.11149020f, -0.32312572f, 0.11078849f, -0.01697728f, 0.06174372f, 
    0.14272644f, 0.03568461f, 0.02804310f, 0.08036534f, -0.10466879f, -0.17616996f, 0.17259675f, -0.27793762f, 
    -0.02167846f, -0.11520382f, 0.01746419f, -0.03353233f, 0.08952047f, -0.03879003f, 0.02726783f, -0.06619764f, 
    0.25329435f, 0.09058727f, -0.05397869f, -0.00217480f, -0.06869758f, -0.07443208f, -0.06963301f, -0.14831848f, 
    0.06880847f, 0.26195073f, -0.07152681f, -0.05100965f, 0.08971643f, 0.09354021f, -0.13364951f, -0.00046515f, 
    0.11285602f, 0.12318872f, 0.35078901f, 0.25442123f, 0.12525517f, -0.13301250f, 0.06337405f, 0.04821278f, 
    -0.10667410f, -0.24410453f, -0.30278698f, -0.15488183f, 0.03032091f, 0.03872814f, 0.03031782f, 0.02108178f, 
    -0.06097528f, 0.04074449f, 0.05313834f, 0.01722893f, -0.33936030f, 0.07177159f, -0.24362649f, 0.02047475f, 
    0.03141842f, -0.10330932f, 0.09491568f, 0.07102748f, 0.03211118f, 0.08222486f, 0.02313075f, 0.08034455f, 
    -0.08182220f, 0.03534941f, 0.04620654f, 0.17864969f, -0.10071031f, -0.02762657f, -0.32960021f, -0.21833581f, 
    -0.01978585f, -0.10500167f, -0.07009646f, -0.05577306f, -0.18917923f, -0.02870563f, -0.10872016f, -0.30738637f, 
    -0.05295287f, -0.05789831f, 0.11699407f, 0.11687411f, -0.00135660f, -0.02673216f, -0.30649903f, 0.07826683f, 
    0.00629702f, 0.09735056f, 0.01312388f, -0.01263059f, 0.06884528f, -0.03625952f, -0.01536624f, -0.08190592f, 
    0.06377459f, 0.24227814f, 0.07111153f, 0.15357628f, -0.24199419f, 0.24853277f, 0.01910962f, 0.08842532f, 
    -0.21722914f, 0.23522191f, 0.22262885f, 0.04873717f, 0.21028292f, 0.16851994f, 0.09185455f, 0.04248570f, 
    0.06747364f, -0.09552430f, 0.07949385f, 0.09601046f, -0.15028246f, 0.00242579f, -0.06013317f, 0.15257521f, 
    0.01080928f, -0.09920701f, -0.18901353f, -0.14930420f, -0.06740748f, 0.11556689f, 0.07455607f, -0.16431284f, 
    -0.03293981f, -0.06157970f, 0.05485263f, -0.00395831f, -0.06894021f, 0.13768457f, -0.07557289f, 0.00850198f, 
    0.12030801f, 0.00656463f, -0.16180286f, 0.06817044f, 0.27447706f, -0.04898995f, -0.07484458f, -0.06847911f, 
    0.02146986f, 0.02360536f, -0.02321858f, 0.08220386f, 0.07616188f, 0.10378119f, -0.12118147f, 0.15640163f, 
    0.15305449f, 0.04506220f, 0.03083645f, -0.04615249f, 0.11142593f, 0.13363607f, -0.03698557f, -0.25106838f, 
    0.05844395f, -0.04775313f, -0.04896117f, -0.21137351f, -0.07760704f, 0.03366875f, 0.01292703f, 0.03177933f, 
    -0.30846393f, -0.33417061f, -0.22442509f, 0.00307035f, -0.03190094f, 0.00812840f, 0.15028352f, -0.00249159f, 
    -0.17944172f, -0.04734002f, -0.22082548f, 0.15268996f, 0.09993467f, 0.13832442f, 0.20377395f, 0.05274127f, 
    -0.09700307f, -0.00854174f, 0.11949885f, -0.08915959f, -0.20241657f, -0.01153421f, 0.16135390f, -0.07101619f, 
    0.03842426f, -0.19429298f, 0.01054056f, 0.05994970f, -0.20006038f, -0.09639081f, 0.12873812f, -0.07143389f, 
    -0.17996265f, 0.09531667f, 0.08060158f, -0.30761355f, 0.10470098f, -0.03912332f, 0.08387978f, -0.11312394f, 
    0.09841441f, 0.14868934f, -0.25620946f, -0.03295399f, -0.06459120f, -0.05500169f, 0.14153691f, 0.02509533f, 
    -0.10524878f, 0.12114087f, 0.10526358f, 0.04386625f, 0.01704288f, -0.06083402f, 0.00630607f, -0.24561253f, 
    -0.01675708f, 0.09990092f, -0.19234124f, 0.01510016f, 0.09164393f, -0.13969854f, -0.06783061f, 0.20757948f, 
    0.13097513f, -0.13641596f, -0.10176821f, -0.23903084f, -0.04542228f, 0.06876487f, 0.11801953f, 0.27825734f, 
    -0.20900986f, 0.08271914f, 0.12407954f, -0.11162345f, -0.13489547f, -0.02385868f, 0.10283701f, -0.10870215f, 
    -0.29419512f, -0.11430991f, -0.25411344f, 0.07926963f, 0.18146636f, 0.05861390f, -0.01752004f, -0.05378108f, 
    0.11382733f, 0.13862248f, -0.38408178f, 0.00802871f, 0.10079590f, 0.08798289f, -0.03181101f, -0.02983390f, 
    -0.06844385f, 0.01763074f, -0.01193753f, 0.06457354f, -0.12426776f, 0.05733741f, 0.02562090f, -0.20189686f, 
    -0.01980053f, 0.03742665f, 0.14566681f, 0.04286932f, -0.13494146f, 0.03631721f, 0.12256949f, -0.02993244f, 
    -0.10462075f, 0.06183486f, 0.03293393f, -0.00027308f, -0.03302492f, 0.00486098f, 0.11531276f, 0.02686895f, 
    -0.05445142f, 0.00693917f, 0.13582432f, -0.04304778f, -0.01478313f, 0.23135947f, -0.23488750f, 0.15340689f, 
    0.06764228f, -0.03161874f, 0.16678430f, 0.09674678f, 0.05429770f, 0.00135017f, -0.05888384f, -0.03655782f, 
    -0.01848427f, 0.03097944f, -0.01671720f, -0.06281795f, 0.08601162f, 0.00499579f, 0.07281838f, 0.07485824f, 
    -0.12685338f, 0.10327195f, -0.01981015f, 0.04756973f, -0.11864182f, -0.03583832f, 0.11984134f, -0.09198983f, 
    0.09066311f, -0.04019355f, 0.06200152f, 0.09620084f, -0.05526467f, -0.20907432f, 0.00636082f, -0.05436197f, 
    0.05085103f, 0.20939909f, 0.23577957f, 0.12566999f, -0.10353719f, 0.09490419f, -0.16782157f, 0.01641842f, 
    0.01704291f, -0.02442233f, 0.25203606f, 0.17674607f, 0.11591768f, -0.29270041f, -0.02082045f, 0.01605881f, 
    0.11341351f, 0.17896339f, -0.13904233f, 0.05351122f, 0.02222059f, 0.03296275f, 0.08086019f, -0.12139427f, 
    -0.10834647f, 0.00777800f, 0.09902763f, 0.17863514f, -0.09455369f, -0.34321520f, -0.24894160f, 0.04489911f, 
    0.03083459f, -0.04428048f, 0.14490096f, -0.09252635f, -0.26811922f, 0.03497726f, -0.00741137f, 0.06419161f, 
    -0.12675297f, -0.06718871f, 0.08072644f, -0.02447555f, -0.16465542f, 0.00061679f, 0.37376446f, 0.00019607f, 
    0.01578534f, 0.17032400f, -0.01070639f, 0.01275185f, -0.10464714f, 0.04487227f, 0.08919517f, -0.27957028f, 
    -0.16321601f, -0.32133341f, 0.03387358f, 0.07438579f, 0.00729545f, -0.00823174f, -0.06868576f, -0.07381438f, 
    0.12111026f, -0.01748561f, 0.00926520f, 0.18094462f, 0.01774951f, -0.13497914f, -0.08626746f, 0.15386733f, 
    0.05335730f, 0.05570848f, -0.14502400f, 0.04292241f, 0.04862756f, -0.05032578f, 0.05640642f, 0.20246641f, 
    0.13069946f, 0.12635569f, 0.28331068f, -0.19445746f, -0.09952541f, -0.10982338f, -0.02307488f, -0.07644455f, 
    0.11647353f, -0.16002044f, 0.11907944f, -0.09363501f, -0.04053178f, -0.13673781f, 0.15332212f, 0.05165663f, 
    0.14057603f, -0.14591029f, 0.01726174f, -0.19449489f, 0.05506567f, -0.03183561f, -0.49721953f, 0.04059257f, 
    0.00674914f, 0.12118634f, -0.02717847f, 0.01569749f, 0.01416764f, -0.12082282f, -0.11294872f, 0.02064586f, 
    0.12713014f, 0.18501297f, 0.01978847f, -0.19384561f, 0.04672699f, 0.08463118f, -0.08528503f, -0.03158439f, 
    0.01340867f, -0.06872328f, -0.05556617f, 0.07574540f, 0.03422280f, 0.04512421f, -0.08802437f, -0.01590358f, 
    0.02826587f, 0.03907391f, 0.07934397f, -0.05825760f, 0.03106831f, -0.15783551f, 0.13227980f, -0.11161717f, 
    0.11229602f, -0.13242556f, 0.24193081f, 0.07188303f, 0.08121614f, -0.02320966f, -0.05650136f, 0.05763218f, 
    0.06235282f, 0.23459792f, 0.02793028f, 0.09800070f, 0.08389705f, 0.09943051f, 0.04543223f, -0.12179700f, 
    0.02706804f, 0.04198827f, 0.20694180f, -0.31357634f, -0.04966167f, 0.16996071f, 0.17580613f, 0.00877602f, 
    -0.03081716f, -0.09027008f, 0.11757056f, 0.19639595f, -0.00169512f, 0.22694919f, -0.03948940f, 0.14477021f, 
    -0.05130023f, -0.02788091f, -0.03637429f, -0.13207646f, -0.10662422f, 0.12413347f, 0.22323006f, 0.11303350f, 
    0.02985881f, 0.05173310f, -0.02641462f, 0.01952901f, -0.06461889f, 0.22951588f, 0.09795567f, -0.14668950f, 
    -0.02013923f, -0.15373480f, -0.02607130f, 0.06274699f, 0.00942566f, -0.05622645f, 0.23549919f, -0.04102291f, 
    0.35724846f, 0.03339797f, 0.09577316f, -0.01698124f, -0.04437796f, 0.00460305f, -0.03941260f, -0.25407621f, 
    0.02759114f, -0.08142041f, 0.08602808f, 0.01357619f, -0.04325125f, -0.05429406f, -0.08746396f, 0.11916538f, 
    0.20743272f, -0.03075839f, 0.03514857f, -0.02844061f, 0.11055048f, 0.01645273f, -0.12690008f, -0.04135142f, 
    -0.07617761f, -0.19959013f, 0.18915619f, 0.02842471f, -0.01864717f, -0.09818976f, -0.14571342f, -0.03054019f, 
    0.03417966f, -0.07118919f, -0.00173131f, 0.14243987f, 0.08092180f, -0.03447602f, -0.09374017f, -0.12496161f, 
    0.14869823f, -0.08027397f, -0.09235412f, -0.11761975f, -0.06872088f, -0.18827239f, -0.12693958f, -0.24315420f, 
    -0.16503754f, -0.15592600f, -0.10582963f, -0.05091221f, -0.01272081f, -0.31977552f, -0.04038452f, -0.01616108f, 
    -0.18750748f, -0.08529770f, 0.04707604f, -0.05546310f, -0.02298696f, -0.00846813f, 0.05835238f, -0.12416006f, 
    -0.15014338f, -0.14216030f, 0.00416242f, 0.00501136f, 0.08445042f, 0.10275510f, 0.03785946f, 0.02151095f, 
    0.21065125f, 0.12407544f, 0.09939041f, 0.05520730f, -0.12323867f, 0.01711473f, 0.00323324f, 0.23927364f, 
    0.14981614f, -0.00240707f, -0.03085656f, 0.06274656f, 0.13937208f, -0.07195050f, -0.08019128f, -0.07532991f, 
    0.20424734f, -0.08716103f, -0.04339525f, -0.03354981f, -0.06749358f, -0.04667343f, 0.04428040f, 0.09363717f, 
    0.10197024f, -0.03580985f, 0.26302338f, -0.11913494f, 0.14387210f, -0.05629005f, -0.18131585f, -0.01864243f, 
    -0.07671835f, 0.10556568f, -0.13839360f, 0.20461275f, -0.26537240f, -0.03221030f, 0.06587007f, -0.01630197f, 
    0.03484761f, -0.15514074f, 0.01822962f, 0.04296369f, -0.20678844f, 0.17563081f, -0.08297122f, 0.12130725f, 
    0.05718022f, 0.02737033f, -0.08646987f, 0.09143084f, 0.05816805f, -0.00214231f, -0.19397748f, -0.13100311f, 
    0.10455522f, 0.10643862f, 0.12951273f, -0.02740313f, -0.28888375f, -0.05839747f, 0.12914486f, 0.04252446f, 
    0.16818137f, -0.01338544f, 0.00280028f, 0.04274717f, 0.10198997f, 0.05334817f, 0.04665865f, 0.22270508f, 
    -0.25848660f, 0.00980763f, 0.15792237f, -0.00934258f, 0.02676892f, 0.15330459f, -0.05311157f, -0.16455552f, 
    -0.19835094f, 0.18672208f, -0.12004171f, -0.10686494f, -0.07028393f, -0.06005314f, 0.04528655f, 0.01655363f, 
    0.17886610f, 0.15990898f, -0.04085771f, -0.14122033f, -0.04162335f, -0.13438609f, 0.03747096f, 0.09441662f, 
    -0.00744184f, 0.40368789f, 0.18105294f, 0.03392811f, 0.07710214f, -0.24559195f, -0.03691882f, 0.10272705f, 
    -0.16530815f, 0.17256327f, 0.11683612f, -0.05330715f, 0.13309422f, -0.02956286f, 0.10421785f, -0.17069387f, 
    -0.08799237f, 0.09452549f, 0.03611362f, 0.27793559f, 0.21111582f, -0.05339409f, -0.01572969f, -0.04356943f, 
    0.01608358f, -0.08112873f, 0.00803793f, 0.10889586f, -0.20018883f, -0.21399869f, -0.00227202f, -0.12657572f, 
    -0.00027009f, -0.02349793f, -0.09650300f, -0.13594888f, -0.00042912f, -0.10352600f, -0.04987130f, -0.00033013f, 
    0.04038188f, 0.05067492f, 0.01613705f, -0.02511014f, 0.02539063f, 0.07796904f, 0.15951464f, -0.15148938f, 
    -0.24737795f, 0.15448935f, -0.14178111f, 0.08744908f, 0.14082171f, 0.07275526f, -0.04414610f, 0.01792731f, 
    -0.18006968f, 0.16032287f, 0.12146045f, 0.17278199f, -0.00708168f, 0.11913184f, 0.04984156f, -0.03145466f, 
    -0.06290987f, 0.08809929f, 0.02312267f, 0.10241659f, 0.14907689f, 0.23806478f, 0.12055743f, -0.08129713f, 
    -0.20928502f, -0.12216537f, -0.01097260f, 0.05088405f, 0.20023552f, 0.05243939f, 0.04034718f, 0.01693230f, 
    -0.16978580f, 0.06327426f, -0.26158553f, -0.06892661f, -0.03840864f, 0.23353465f, 0.13273580f, 0.23248619f, 
    -0.06677712f, 0.00139335f, -0.29444826f, -0.10740938f, -0.12132487f, -0.24942309f, -0.01535459f, 0.10543507f, 
    -0.00997629f, -0.08527121f, 0.19722523f, -0.06577127f, -0.07295136f, 0.02686651f, 0.04020480f, 0.10215641f, 
    -0.17428437f, -0.08456865f, -0.12792794f, -0.06797253f, 0.20899291f, 0.09692679f, 0.02419689f, 0.03290328f, 
    0.07510577f, -0.10008822f, 0.08546851f, -0.20067237f, 0.10033364f, -0.25999600f, 0.03874493f, 0.19116190f, 
    -0.01128374f, 0.06898609f, 0.21365455f, -0.08930485f, 0.04884206f, 0.03370275f, 0.04074813f, 0.24784046f, 
    0.08466220f, -0.06034213f, -0.08061370f, -0.14244182f, 0.02405713f, -0.08229136f, 0.00993157f, 0.02529854f, 
    -0.18912116f, 0.17683966f, 0.00007913f, 0.13495325f, 0.01106241f, 0.07250636f, 0.15492857f, -0.09709866f, 
    -0.21356571f, -0.21224748f, 0.01619410f, -0.01737339f, 0.08428711f, 0.02758731f, -0.03912099f, -0.02519665f, 
    0.18352753f, -0.03847018f, -0.31915897f, -0.00003837f, 0.00645592f, 0.23982643f, 0.09518530f, 0.17973071f, 
    -0.17054223f, -0.06053310f, -0.00225108f, 0.27894494f, 0.26658016f, -0.02244729f, -0.20613417f, -0.01264739f, 
    -0.18897171f, 0.09844397f, 0.01973381f, 0.13728085f, -0.14978826f, 0.06414957f, 0.02735373f, 0.11367771f, 
    0.10896479f, 0.00727677f, -0.04074569f, 0.03317393f, -0.06644627f, 0.21634267f, -0.17055117f, 0.16634715f, 
    -0.03134850f, 0.04367717f, -0.04638858f, 0.09708027f, -0.05241950f, -0.01460976f, -0.02741100f, -0.07415955f, 
    -0.11584507f, 0.09382768f, -0.00643677f, -0.05390370f, -0.07308022f, -0.07419389f, -0.12447599f, -0.08835183f, 
    -0.04555352f, -0.00034695f, -0.11559291f, -0.02933500f, -0.03242929f, 0.12772484f, 0.03989043f, 0.01839001f, 
    -0.12906660f, 0.07992525f, -0.09698705f, 0.00769578f, 0.01860754f, 0.20710239f, -0.14534838f, -0.17061661f, 
    -0.14962220f, -0.07266782f, -0.09603469f, 0.09865080f, -0.06626939f, -0.02687791f, 0.16298053f, 0.02528880f, 
    -0.03600071f, 0.00422258f, 0.11896812f, -0.06221179f, 0.08659730f, 0.01205110f, -0.09037340f, 0.12776223f, 
    -0.07490003f, -0.09503272f, 0.18107449f, -0.03009849f, 0.16178206f, -0.33758044f, -0.03502711f, -0.09672851f, 
    0.17270084f, -0.17096502f, 0.07094738f, -0.05189539f, -0.03875840f, 0.01370754f, 0.05136905f, -0.04442606f, 
    -0.06660313f, 0.13593309f, 0.04098189f, 0.25656196f, 0.26622790f, 0.21255860f, 0.10777137f, 0.05302845f, 
    -0.12385972f, 0.23184618f, -0.04453551f, -0.16725482f, -0.04871362f, -0.19735122f, 0.12069053f, -0.27936035f, 
    0.01798091f, 0.01274249f, 0.16192889f, -0.06426863f, -0.04068764f, -0.01146731f, 0.04796225f, 0.36629522f, 
    0.01282160f, -0.11917172f, -0.05517182f, -0.00044949f, 0.13107914f, 0.01109721f, 0.01633440f, -0.05823817f, 
    -0.31025448f, 0.07104401f, -0.13280144f, 0.13312566f, 0.13768740f, 0.13336307f, -0.01034504f, 0.04836942f, 
    -0.22420658f, -0.07082719f, 0.03481274f, -0.11982473f, 0.05484422f, -0.12378306f, -0.11542670f, -0.14071228f, 
    0.12465437f, -0.06338541f, 0.08965567f, -0.04910044f, 0.16295463f, 0.19010900f, -0.05518688f, -0.00777227f, 
    -0.14870682f, 0.11051212f, -0.04023899f, -0.15942813f, 0.11841481f, 0.00869964f, 0.21284534f, 0.01757867f, 
    -0.03053997f, 0.03644605f, -0.26056448f, 0.06824525f, 0.15607648f, 0.20137413f, -0.15372837f, -0.03607531f, 
    -0.02248679f, -0.08880576f, 0.08164251f, 0.24782009f, 0.04010725f, 0.10984404f, 0.23078772f, -0.00028098f, 
    0.01308989f, 0.04919678f, 0.02413131f, -0.16806257f, -0.06761029f, 0.03410270f, -0.11108760f, -0.13593791f, 
    0.26618320f, -0.18876818f, -0.04673617f, 0.03023240f, 0.00506488f, 0.00653308f, -0.09927367f, -0.01287848f, 
    -0.15257588f, 0.10760020f, 0.02155991f, -0.01637341f, 0.22893524f, -0.08470519f, -0.22563961f, 0.06137261f, 
    -0.05207541f, 0.13625535f, 0.00211818f, -0.11539972f, -0.03536314f, -0.03243932f, 0.03137274f, 0.18701451f, 
    0.01669448f, 0.11030459f, 0.32470742f, -0.20489092f, -0.03708791f, -0.14034301f, 0.09461369f, 0.04259657f, 
    0.08168249f, 0.14646901f, -0.02882903f, 0.01350521f, -0.04458462f, -0.02064728f, -0.00442563f, -0.10431848f, 
    0.10941049f, -0.09569461f, -0.10195974f, 0.05233819f, 0.14448981f, 0.17109571f, -0.17309715f, 0.00287987f, 
    -0.14166695f, -0.10442910f, -0.18623932f, -0.14022733f, 0.08068781f, -0.00893888f, -0.21860205f, 0.02837670f, 
    0.12184305f, 0.16795440f, 0.04876632f, 0.05131235f, -0.11142532f, -0.28119248f, -0.40920931f, -0.12759253f, 
    -0.12535040f, 0.17460527f, 0.01283992f, 0.02588277f, -0.02789124f, -0.02188253f, -0.20814627f, -0.35129973f, 
    0.30397132f, 0.09526338f, 0.06260329f, 0.15835465f, -0.03129250f, -0.00341936f, -0.07242249f, 0.25734398f, 
    -0.08661353f, -0.22623783f, 0.21268494f, 0.22745983f, 0.06237780f, 0.01350279f, -0.03051292f, -0.09295137f, 
    0.17085576f, 0.04489109f, 0.13052218f, -0.08995795f, -0.01208914f, 0.02151361f, 0.26472056f, -0.01573257f, 
    0.19923790f, -0.21228971f, -0.00253802f, 0.12577766f, 0.08028732f, -0.27454895f, 0.02407024f, -0.08074840f, 
    0.03702489f, 0.24817045f, 0.07181769f, -0.55302680f, -0.07364774f, -0.03241522f, 0.10621350f, -0.09586336f, 
    0.02377506f, 0.01601318f, -0.11802996f, 0.14261222f, -0.15607992f, 0.10986215f, -0.05686112f, -0.08160815f, 
    0.04912971f, -0.11632600f, 0.06739742f, 0.08346053f, -0.20138270f, -0.03529122f, -0.26107830f, -0.01870238f, 
    0.07185121f, 0.03474380f, 0.04602435f, 0.07390176f, -0.03116362f, -0.09782159f, -0.13720942f, 0.19295907f, 
    -0.04434331f, 0.03522643f, 0.09663946f, -0.08255621f, 0.01293134f, 0.16758151f, 0.09349135f, -0.24704041f, 
    -0.23254846f, -0.03318673f, 0.06817398f, -0.16697422f, -0.04792846f, -0.08243318f, 0.03691265f, -0.08336887f, 
    -0.09098639f, -0.20906833f, 0.02589133f, -0.06086768f, 0.15126075f, 0.00259042f, -0.16778854f, 0.02075874f, 
    0.11972534f, -0.04687448f, 0.21314317f, -0.05654710f, -0.04980752f, 0.19425382f, 0.21131395f, -0.07496817f, 
    0.07906971f, 0.14972633f, 0.04699765f, -0.36871436f, 0.05895546f, 0.05150545f, -0.03199454f, -0.10100000f, 
    -0.11233350f, 0.02931847f, -0.11601183f, -0.23484206f, -0.17381987f, -0.02723548f, 0.05071324f, -0.03729205f, 
    -0.01704644f, -0.01126121f, -0.19684893f, -0.00597692f, -0.22153877f, -0.14130384f, 0.11287007f, -0.05567003f, 
    -0.05741586f, -0.04609200f, 0.02324041f, -0.26483706f, -0.03010669f, -0.17357144f, -0.34192717f, 0.14855565f, 
    0.01300383f, 0.09255546f, -0.00271678f, -0.02932747f, -0.10142212f, -0.37852591f, -0.03443841f, -0.00042257f, 
    -0.10803851f, -0.01338951f, -0.19240105f, -0.04513597f, -0.12198088f, -0.05748229f, -0.51550037f, 0.02963367f, 
    -0.07383894f, 0.08708031f, 0.08552959f, -0.01171455f, 0.00084320f, -0.03394912f, -0.01689221f, 0.02049335f, 
    -0.27202845f, 0.10206862f, 0.04110264f, -0.03037577f, -0.10601367f, 0.01101102f, -0.04389605f, -0.03325752f, 
    -0.02160043f, 0.09867365f, 0.07328665f, 0.06080581f, 0.09162687f, -0.08585083f, 0.06746724f, 0.09468453f, 
    -0.07858111f, 0.24298725f, 0.14679471f, 0.10319570f, -0.09787268f, 0.01402637f, -0.01919436f, -0.04599437f, 
    -0.10109112f, 0.17070210f, -0.45923877f, 0.13587201f, 0.19966435f, 0.08381127f, 0.03964026f, -0.18410008f, 
    0.17727560f, 0.02103104f, 0.01723347f, -0.09073607f, 0.08048186f, 0.04706947f, -0.00808175f, -0.08464350f, 
    0.07639532f, -0.08817965f, -0.01161267f, 0.14008707f, 0.15908417f, 0.02380417f, -0.04983771f, 0.05777723f, 
    0.06322150f, 0.02533787f, 0.11758711f, 0.11230239f, 0.08248415f, 0.20903622f, -0.02818002f, -0.08856533f, 
    0.02594621f, -0.00840970f, -0.04355348f, 0.16725677f, 0.19764738f, 0.13220979f, -0.57649130f, 0.00106926f, 
    0.00386855f, 0.03189671f, 0.03132341f, 0.12292482f, -0.02359103f, 0.01298277f, 0.04698833f, -0.41961139f, 
    0.01283001f, 0.17393255f, 0.09689623f, 0.09168737f, 0.01890468f, -0.15201268f, 0.00789539f, -0.03524553f, 
    0.03703778f, 0.00638987f, -0.00657592f, 0.00648202f, 0.04784762f, -0.05464640f, -0.08769041f, -0.02847780f, 
    -0.05131980f, -0.04647670f, -0.04272939f, 0.02477644f, 0.00322983f, 0.02211467f, 0.01412990f, -0.08160862f, 
    -0.08987974f, 0.04446642f, 0.03515738f, -0.05567790f, 0.04041966f, -0.06753837f, -0.08113758f, -0.00371570f, 
    -0.00472715f, 0.02234912f, -0.01422313f, 0.06834776f, -0.03842791f, -0.07372823f, -0.03803593f, -0.05255225f, 
    0.03888046f, -0.08801603f, -0.03067623f, 0.05572132f, 0.05529822f, 0.03882472f, -0.05999306f, -0.02780848f, 
    -0.00565757f, -0.02083021f, -0.08824145f, 0.03119790f, -0.08932186f, -0.07402340f, -0.08137915f, 0.05147718f, 
    0.06973476f, 0.04977961f, -0.04670073f, -0.06372447f, -0.05728009f, -0.05540965f, -0.00448408f, 0.02380957f, 
    -0.01387140f, -0.02061764f, -0.08283664f, 0.01917658f, 0.05585475f, 0.03993938f, -0.01092883f, -0.04479548f, 
    0.02661288f, -0.00546536f, -0.04834451f, -0.00311224f, 0.03641157f, 0.00978896f, -0.05017653f, -0.06032976f, 
    -0.08043829f, -0.05082101f, 0.04863255f, -0.08432321f, -0.01917769f, -0.03914234f, 0.04525010f, -0.00176932f, 
    -0.08961955f, -0.02098875f, 0.06271122f, -0.01889086f, 0.00078589f, -0.07927199f, -0.00896133f, -0.00718312f, 
    -0.06243882f, -0.00578275f, -0.04361977f, -0.00288611f, -0.03791192f, 0.01323816f, -0.08967709f, 0.02566317f, 
    0.07357766f, 0.04121668f, 0.01791953f, -0.07143040f, -0.07465016f, -0.05232444f, -0.02943338f, 0.04543090f, 
    -0.07774892f, 0.06172666f, -0.07026635f, 0.02674416f, 0.00501226f, 0.05043379f, 0.03445614f, -0.00987286f, 
    0.03612687f, 0.06046905f, -0.00814688f, -0.08833924f, -0.02549326f, -0.08667044f, 0.04078774f, -0.02957108f, 
    -0.04422919f, 0.07174364f, -0.07963090f, -0.02330074f, -0.02906366f, -0.02321954f, -0.07537727f, -0.05711404f, 
    -0.07656260f, -0.05868855f, 0.03320778f, 0.03881783f, -0.07986063f, -0.05388264f, 0.01134439f, -0.02134128f, 
    -0.09059793f, -0.00403384f, -0.05854933f, 0.01435002f, -0.05254363f, -0.07513548f, 0.03184953f, 0.07032799f, 
    0.05718020f, 0.10221514f, -0.08778778f, 0.03331689f, 0.06902970f, -0.06984483f, 0.08072255f, 0.10865641f, 
    0.16372313f, 0.14173016f, 0.21632102f, -0.00536760f, 0.18139178f, 0.03148323f, -0.08264407f, 0.05323803f, 
    -0.01794499f, 0.06722975f, 0.13270195f, 0.07054325f, -0.04707678f, -0.23219433f, 0.04293620f, 0.07839957f, 
    0.13673259f, -0.01381925f, 0.08645307f, -0.15645982f, 0.04800614f, -0.19156732f, -0.05668177f, -0.13871419f, 
    0.03293767f, 0.05533012f, 0.11213308f, -0.03254615f, 0.20750101f, 0.16702834f, 0.07322463f, -0.01293601f, 
    -0.02086194f, 0.08190992f, -0.15457334f, 0.04262909f, -0.12901947f, 0.04708270f, -0.21479337f, -0.27244905f, 
    0.07974022f, 0.11127036f, -0.13435899f, 0.02547641f, -0.05895133f, -0.05451237f, -0.21316098f, 0.21164493f, 
    0.20255689f, 0.11077249f, 0.07197526f, 0.01736706f, 0.02577688f, 0.12993129f, -0.10029543f, -0.09167278f, 
    0.09309050f, -0.04264153f, -0.11769356f, 0.13735548f, -0.00757041f, 0.04451130f, 0.07636067f, -0.12723070f, 
    0.04894316f, -0.12133136f, -0.13284886f, -0.10250016f, -0.08963844f, -0.25478548f, 0.14902626f, -0.04088338f, 
    0.13429219f, -0.18040594f, -0.14050134f, -0.09320372f, -0.16781396f, -0.01999817f, 0.00665098f, 0.16390502f, 
    -0.03624211f, 0.11660428f, -0.27006552f, 0.05430055f, 0.09141078f, 0.08827758f, -0.07959849f, 0.00892229f, 
    0.14088084f, 0.13407794f, 0.12736470f, -0.48471937f, -0.21433035f, 0.26529500f, -0.06150516f, 0.05917083f, 
    0.16186342f, 0.00173808f, 0.01397686f, 0.08921782f, 0.06839385f, -0.08262635f, -0.12799779f, -0.12676468f, 
    -0.16651961f, 0.06404016f, -0.05083764f, 0.00360125f, -0.02171345f, 0.03879254f, -0.03281014f, -0.00528213f, 
    -0.09738126f, -0.13071817f, -0.00503696f, 0.01922744f, 0.02518866f, -0.09131681f, 0.06689836f, 0.11344657f, 
    0.05544532f, 0.03043809f, -0.25323635f, 0.13864714f, 0.00786348f, 0.04206381f, 0.03241698f, 0.16850510f, 
    -0.20725954f, 0.07527965f, 0.04191332f, 0.01613275f, -0.14433709f, 0.00066943f, 0.18713979f, 0.05082572f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.05261579f, -0.02432267f, 0.03473343f, -0.03581110f, 0.07758723f, 0.00810805f, 0.06118785f, 0.00680727f, 
    -0.21664861f, 0.04361252f, 0.11580034f, 0.05261757f, 0.04435356f, 0.05229554f, -0.06556500f, 0.06958941f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.36488602f, 0.12617429f, 0.17550547f, -0.21628071f, 0.01730819f, 0.46736270f, 0.19359396f, -0.13755418f, 
    -0.27794027f, -0.36176658f, -0.00212014f, 0.25273651f, 0.02246949f, -0.23860300f, -0.18206292f, 0.05847816f, 
    -0.19229500f, 0.20060797f, 0.29428387f, 0.51498741f, -0.00406519f, -0.47379100f, -0.02055261f, 0.26346684f, 
    0.03645124f, -0.00345195f, 0.12443661f, -0.14623684f, 0.05312621f, -0.13233918f, -0.07159880f, 0.26914039f, 
    0.22970952f, 0.07273765f, -0.07009066f, 0.41678104f, -0.02668476f, -0.41740623f, 0.32238397f, 0.31441942f, 
    -0.31770861f, -0.07415477f, -0.35356912f, 0.09544724f, -0.17823344f, 0.19097115f, -0.08369879f, 0.30981272f, 
    -0.25130707f, 0.09697697f, 0.49514624f, 0.01822921f, 0.45576108f, -0.19651675f, 0.41798955f, -0.23690063f, 
    0.05414519f, -0.20703022f, 0.14345902f, 0.00272732f, -0.01496200f, 0.37756640f, 0.07731244f, -0.17286944f, 
    -0.22013706f, 0.21891180f, 0.04302489f, 0.19356988f, 0.30045557f, -0.38322809f, 0.20244657f, -0.18822975f, 
    0.32731736f, 0.13629885f, -0.08924647f, 0.01828236f, 0.10367137f, -0.40339625f, -0.02215574f, 0.35625985f, 
    0.25588521f, -0.34874338f, -0.43371865f, 0.62891698f, 0.21430738f, -0.02333699f, -0.01449671f, -0.25248891f, 
    0.57920182f, 0.04690480f, -0.05414581f, 0.04899054f, 0.25937331f, -0.03629550f, 0.09899861f, -0.10734787f, 
    0.26293766f, -0.15690240f, -0.20640625f, 0.54248959f, 0.23565957f, 0.26599285f, -0.05005661f, -0.00653155f, 
    0.16544881f, 0.21132024f, -0.33663926f, -0.27800688f, -0.20939344f, -0.14976041f, -0.12128642f, -0.05044791f, 
    0.01206176f, -0.14639606f, -0.30074045f, 0.41613412f, 0.27340597f, -0.25242132f, -0.16446017f, -0.11965099f, 
    0.31775740f, 0.28378549f, 0.08136660f, -0.19692196f, -0.17616664f, 0.23645060f, 0.07212029f, 0.29858994f, 
    0.52026957f, 0.30096275f, 0.22622120f, 0.11495630f, 0.11971478f, -0.29318765f, -0.06449678f, -0.39419764f, 
    0.28716522f, 0.09899168f, -0.16374442f, 0.33224240f, -0.30902919f, -0.05446251f, 0.07246044f, -0.30130076f, 
    0.11240602f, -0.04525392f, -0.06028025f, 0.27115768f, 0.02314279f, -0.20746087f, -0.09105085f, 0.15564097f, 
    -0.20419753f, 0.35760278f, -0.28542730f, -0.21934833f, 0.38057649f, -0.01526069f, 0.11759077f, 0.37391934f, 
    0.09622032f, -0.11719778f, 0.53447014f, 0.36434537f, -0.17768569f, -0.45618027f, 0.19247635f, -0.28105745f, 
    -0.37991410f, 0.24063215f, 0.05991689f, -0.07615484f, 0.45117575f, 0.08294774f, -0.11923149f, -0.21521871f, 
    -0.24360391f, 0.34988952f, 0.25293425f, 0.27172571f, 0.07539532f, -0.15480119f, -0.23139395f, -0.15999950f, 
    -0.47114074f, 0.18567660f, 0.01357198f, 0.24309440f, 0.25690687f, 0.19567706f, 0.01622899f, -0.16493316f, 
    -0.29755595f, 0.42710268f, 0.00440463f, 0.00834606f, -0.31714350f, -0.22956344f, 0.11246590f, 0.00553676f, 
    0.16267541f, 0.10417277f, 0.03075014f, 0.23062824f, 0.31421086f, -0.45150983f, 0.07217740f, 0.05989807f, 
    -0.23029959f, 0.25206876f, 0.18348192f, 0.10801875f, 0.19423160f, -0.34121272f, 0.40024289f, 0.29963329f, 
    -0.14577858f, -0.12940399f, 0.17929517f, 0.09292676f, 0.05440170f, -0.36502507f, -0.07706790f, 0.10234298f, 
    0.01455481f, 0.04875756f, -0.30742598f, -0.00464760f, 0.33146793f, -0.10872435f, 0.48575982f, 0.08890702f, 
    0.15885374f, -0.17724070f, 0.11524298f, 0.27152923f, -0.42658654f, 0.04957924f, 0.07154231f, -0.17239593f, 
    0.03708290f, -0.16098195f, 0.24974765f, -0.18383762f, -0.19256556f, -0.04889679f, -0.11985993f, 0.08267305f, 
    -0.39797914f, 0.34198549f, -0.20189643f, 0.21503550f, 0.17334355f, -0.07272387f, -0.16734657f, 0.38898316f, 
    -0.14876066f, 0.25355145f, 0.24783960f, 0.32714391f, 0.04357368f, 0.06183631f, -0.14355271f, 0.36686757f, 
    0.10192254f, 0.32551512f, 0.09484738f, -0.16672266f, -0.08180290f, -0.43646038f, 0.25571099f, -0.30395913f, 
    0.39892936f, -0.02217025f, -0.18828580f, 0.07923471f, 0.12378781f, -0.25128984f, 0.23167261f, 0.36668620f, 
    -0.18275627f, -0.16817378f, 0.09237136f, 0.17473568f, -0.56467623f, 0.44889441f, 0.21773088f, -0.22753076f, 
    0.09003886f, -0.05256610f, 0.24235609f, -0.26594248f, 0.36148465f, 0.22412577f, 0.06129491f, 0.00489829f, 
    -0.34775892f, -0.12995422f, -0.03363795f, 0.18741339f, 0.11173278f, 0.39483321f, -0.24139997f, -0.04716108f, 
    0.46990523f, 0.16197225f, 0.25669336f, 0.43386427f, -0.15302479f, 0.05118166f, 0.37219504f, -0.03951463f, 
    -0.05312982f, -0.18227664f, -0.25672814f, -0.15359208f, -0.03718710f, -0.26696151f, 0.05401528f, -0.43612874f, 
    0.05010383f, -0.12600347f, 0.01823705f, 0.52804786f, 0.03625396f, 0.13886218f, -0.59927845f, 0.11167748f, 
    -0.60049498f, -0.10548645f, 0.07496846f, -0.47639751f, 0.31311283f, -0.00513058f, -0.17677894f, 0.27067697f, 
    0.31709263f, 0.14089520f, -0.10440446f, 0.12248728f, -0.08875953f, -0.02380590f, -0.06290826f, -0.07949614f, 
    -0.35903910f, 0.30310866f, 0.21373044f, 0.03782824f, -0.39365983f, 0.17853487f, 0.13434795f, -0.33451936f, 
    0.32264411f, 0.29587325f, 0.08175055f, 0.15411831f, 0.14746661f, -0.08850855f, -0.27815834f, 0.22024398f, 
    0.53587621f, -0.25174397f, -0.05828359f, 0.24980925f, -0.15094420f, -0.18915614f, 0.11332046f, -0.01244516f, 
    -0.15106761f, -0.26195300f, 0.06666497f, -0.20600255f, -0.05765118f, 0.12591475f, 0.00362246f, 0.04779226f, 
    -0.11524092f, -0.24805963f, -0.08351895f, -0.21214093f, -0.19391558f, 0.05025949f, 0.13730910f, -0.03469047f, 
    -0.08026700f, -0.38819137f, 0.19475690f, -0.16242857f, 0.35490707f, 0.15886132f, 0.49804190f, 0.00042269f, 
    0.23821008f, -0.35212418f, -0.13115631f, 0.26314953f, -0.25710684f, 0.21851599f, -0.11108833f, 0.31928787f, 
    0.05058461f, -0.45472682f, -0.25887614f, 0.17273903f, -0.19092889f, 0.40920228f, 0.17652874f, -0.06740539f, 
    -0.21270566f, 0.42063591f, 0.26334894f, -0.09953686f, 0.05469783f, -0.05548942f, -0.08072174f, -0.14367969f, 
    -0.23831956f, 0.16041948f, -0.14925398f, 0.03468848f, -0.06551035f, -0.20062935f, -0.01124631f, -0.14811529f, 
    -0.51585364f, -0.02543354f, 0.34689394f, -0.23273347f, -0.14695825f, -0.06558226f, -0.11835274f, 0.12434245f, 
    0.27065718f, 0.20962402f, 0.01199802f, 0.42286226f, 0.25788790f, -0.35126844f, 0.34632236f, 0.09069645f, 
    0.29521433f, 0.08810747f, -0.19346702f, 0.11868297f, -0.21037062f, -0.24855010f, -0.17153773f, -0.07751505f, 
    -0.23805888f, -0.53234917f, -0.02773273f, 0.58915466f, 0.38064575f, 0.12919785f, -0.49737191f, 0.00178425f, 
    -0.44569594f, -0.02256945f, 0.07478272f, -0.31985492f, -0.02781336f, 0.06380733f, -0.09480688f, -0.34854040f, 
    0.09020777f, -0.18361989f, -0.11824487f, -0.34264764f, 0.24917181f, -0.15535766f, 0.32944691f, 0.25114575f, 
    0.29342380f, -0.33110565f, -0.01397376f, 0.28592098f, -0.15838344f, 0.40344274f, 0.06189252f, 0.20935857f, 
    -0.01012562f, -0.46021551f, -0.02127765f, -0.08905897f, 0.04979267f, 0.32818952f, -0.02807429f, 0.02957055f, 
    -0.35499075f, 0.30194685f, -0.19698903f, -0.02311035f, 0.33946392f, 0.37309438f, -0.07560331f, -0.21962276f, 
    0.46969470f, 0.14624476f, -0.00471469f, 0.02189654f, -0.28062400f, 0.27823874f, -0.05138695f, -0.02649311f, 
    -0.49232656f, -0.21108186f, 0.11887062f, 0.13065132f, -0.51026231f, -0.63070941f, 0.05861254f, 0.24358657f, 
    -0.01269916f, -0.11613421f, 0.39562955f, -0.34930128f, -0.01296915f, 0.05409252f, 0.11192159f, 0.33079457f, 
    -0.22971483f, 0.01023290f, 0.12479372f, 0.29240707f, -0.02283386f, -0.34957200f, -0.18223816f, -0.13589221f, 
    -0.13945001f, 0.21459138f, 0.46482629f, 0.03090754f, -0.13811059f, 0.29844451f, 0.05596812f, -0.13929839f, 
    0.07799055f, 0.00272225f, 0.39949253f, 0.12400635f, -0.30569151f, -0.00404081f, -0.24254078f, -0.35546067f, 
    -0.11123256f, 0.00869695f, -0.02821986f, 0.25318804f, 0.24346437f, -0.06347468f, -0.04663084f, -0.04412220f, 
    0.43784305f, -0.25756690f, 0.07137989f, 0.12906140f, -0.18599734f, 0.31019887f, 0.19957164f, -0.08152828f, 
    -0.15048470f, -0.14639847f, -0.06302781f, -0.09791652f, -0.07150739f, -0.24596620f, -0.06269409f, 0.15449257f, 
    0.17405641f, 0.09793764f, -0.29756701f, -0.30075341f, -0.06253850f, -0.04500981f, 0.17571741f, -0.14882854f, 
    0.14852175f, -0.19369932f, -0.00509271f, 0.38834658f, 0.38992798f, -0.12940018f, 0.07942018f, -0.11311655f, 
    -0.30941820f, 0.18381220f, 0.23736443f, 0.21096627f, -0.22612931f, -0.15878193f, -0.00445753f, -0.29437506f, 
    0.51178616f, 0.35531971f, 0.10535394f, 0.26091728f, -0.02949475f, -0.36364293f, 0.07827216f, -0.36914021f, 
    0.45914549f, -0.43059871f, -0.08206038f, 0.03560430f, -0.37355801f, 0.15516403f, 0.04715974f, 0.13607347f, 
    -0.18048032f, -0.30522242f, 0.15012795f, 0.15639722f, -0.27547970f, 0.10004014f, 0.06129427f, -0.00428484f, 
    -0.26440242f, -0.27939636f, 0.05420806f, -0.23707126f, 0.07970522f, -0.22947992f, 0.09356683f, -0.12353696f, 
    -0.10476332f, 0.21647939f, -0.31821856f, -0.40742666f, -0.19030532f, 0.27618894f, -0.23836198f, 0.28810900f, 
    0.07260196f, 0.13653281f, -0.20691250f, 0.01039812f, -0.25215584f, -0.33471414f, 0.22101179f, 0.31635371f, 
    0.30161834f, 0.01354334f, -0.18118964f, -0.18072557f, -0.14045873f, 0.21769677f, 0.22671923f, -0.12333941f, 
    0.30898979f, -0.24902454f, 0.34038594f, 0.32502431f, -0.11924083f, 0.17185162f, -0.25196749f, -0.14951108f, 
    0.03542746f, 0.36657590f, -0.06225444f, -0.38914782f, -0.10161867f, -0.07288020f, 0.07804111f, 0.46600264f, 
    0.29307920f, -0.10001188f, -0.08738315f, -0.07380368f, -0.68723500f, 0.00858505f, -0.14466867f, 0.26347312f, 
    0.26546741f, -0.39599079f, -0.11186969f, -0.34346727f, 0.39568177f, 0.14959970f, 0.13729055f, -0.07989040f, 
    -0.06271692f, 0.17414860f, 0.06374562f, 0.07840699f, -0.23584378f, 0.26569915f, 0.01198497f, -0.06002329f, 
    0.09180461f, 0.25286889f, -0.59089017f, 0.37743485f, 0.01859426f, 0.44078276f, 0.28506202f, 0.22870006f, 
    0.00236125f, -0.17075543f, -0.24501467f, -0.15263584f, -0.40725079f, -0.15913831f, -0.16543552f, -0.34335655f, 
    0.13314073f, -0.19808078f, -0.47608557f, 0.43281144f, 0.03475984f, -0.03538131f, 0.41730943f, 0.20628244f, 
    -0.00920715f, 0.26280746f, -0.10409360f, -0.05657969f, 0.14231265f, 0.15246004f, -0.22926041f, -0.21249633f, 
    -0.01015201f, 0.01098312f, 0.12928510f, -0.08992375f, -0.51089782f, 0.11523270f, 0.10036843f, -0.44404727f, 
    0.02464863f, -0.04593829f, -0.12364229f, 0.07902817f, 0.62816572f, 0.54220021f, 0.20382570f, 0.16103750f, 
    0.16997690f, 0.19378902f, 0.32336158f, -0.05907688f, 0.00663006f, 0.15976842f, 0.09632938f, -0.51004171f, 
    -0.45031381f, -0.26577649f, 0.28556329f, -0.29078245f, 0.47729489f, 0.35379374f, 0.13017729f, 0.06418469f, 
    0.33908227f, 0.19342558f, -0.12021758f, 0.12366857f, -0.23656364f, 0.18999536f, 0.30901492f, -0.13612285f, 
    0.33372343f, -0.11369329f, -0.12280692f, 0.24726743f, 0.04033215f, -0.30685681f, -0.09587502f, 0.33859324f, 
    -0.25671962f, -0.09703273f, -0.01169484f, 0.18598965f, 0.29386875f, -0.10162091f, -0.17846325f, 0.51109910f, 
    -0.33619827f, 0.16025069f, -0.17542745f, 0.19322598f, 0.21242255f, 0.29110584f, 0.08979510f, 0.11386021f, 
    -0.37715414f, -0.41365030f, -0.06098576f, -0.18468930f, 0.42308164f, 0.22710644f, -0.15955496f, -0.41923752f, 
    0.04449134f, 0.16914262f, 0.12805550f, 0.18422394f, -0.20189047f, 0.04884025f, -0.05290890f, 0.02908582f, 
    -0.11102549f, -0.17262746f, 0.43525472f, 0.13739961f, -0.19349763f, -0.40578529f, -0.19299977f, 0.15151489f, 
    0.35635144f, 0.10766550f, 0.17574073f, 0.02630945f, 0.35242778f, -0.22993311f, -0.07284417f, 0.24129300f, 
    0.04199053f, -0.27136022f, 0.37735361f, 0.00630540f, -0.36022246f, 0.03551316f, -0.01983398f, -0.37421843f, 
    -0.39695683f, 0.35381576f, 0.17507763f, 0.01626597f, 0.13181594f, 0.03176750f, -0.06931967f, -0.05782679f, 
    0.19363354f, 0.07176787f, 0.03738353f, -0.35754713f, -0.16817953f, 0.08375105f, 0.07061065f, 0.17024173f, 
    -0.34695765f, 0.10596215f, 0.00133168f, -0.15819068f, 0.34419236f, 0.04342060f, -0.22366163f, 0.29586375f, 
    -0.29804856f, 0.27623394f, 0.32260460f, 0.21967417f, -0.18301448f, -0.15649523f, 0.09991964f, 0.09394120f, 
    -0.16804808f, 0.14979449f, 0.30692402f, 0.28868452f, -0.24601629f, -0.19918855f, 0.11747818f, -0.24631330f, 
    0.08156350f, 0.45409170f, -0.78470534f, 0.08909240f, -0.08651664f, 0.26275393f, -0.02943700f, 0.05995055f, 
    -0.24843210f, -0.11552041f, -0.36001486f, 0.33259562f, 0.36184299f, 0.22309293f, 0.10776687f, 0.13335426f, 
    -0.17291839f, 0.29902968f, -0.00037893f, 0.15870279f, 0.06333733f, -0.38181683f, -0.27735978f, 0.19036698f, 
    0.44087586f, 0.19336931f, -0.05493869f, -0.06616807f, 0.08992926f, 0.02623422f, -0.08539105f, 0.27144766f, 
    -0.02826685f, -0.00795925f, 0.21155402f, -0.16612625f, -0.05491191f, -0.22180864f, 0.20913684f, -0.22258601f, 
    -0.18777931f, -0.12777779f, -0.13481882f, 0.04678437f, -0.20892379f, 0.11211973f, 0.15624082f, -0.15495494f, 
    -0.04575878f, -0.11845258f, -0.00958191f, -0.04859238f, -0.06520212f, 0.20722614f, -0.04764855f, -0.33146307f, 
    0.10849512f, -0.33508337f, 0.25418380f, 0.35988113f, -0.30460855f, -0.39644253f, 0.16469732f, 0.23262405f, 
    0.32066071f, -0.10541382f, 0.11020368f, 0.34936467f, 0.21137090f, -0.23978010f, 0.07763308f, -0.03778148f, 
    -0.65052247f, -0.29193881f, -0.07697999f, -0.19075708f, 0.22306110f, -0.21978517f, 0.06192350f, 0.10755134f, 
    0.05094473f, -0.29951134f, 0.27421337f, 0.32254276f, -0.06031543f, 0.02478280f, 0.24044503f, -0.43716377f, 
    0.02404543f, 0.12903786f, 0.04178789f, -0.04738095f, 0.26990023f, 0.36219862f, -0.07514277f, -0.36521879f, 
    -0.07952316f, 0.21281323f, -0.24324386f, 0.06135745f, 0.26818514f, -0.01083687f, -0.04481529f, 0.10400271f, 
    0.13037932f, -0.53399116f, -0.10899564f, 0.39102694f, 0.34368414f, -0.34349167f, -0.16641633f, -0.12662366f, 
    0.32679105f, 0.14160630f, 0.40354899f, 0.39801040f, 0.25166550f, -0.44781321f, 0.09312706f, 0.19318813f, 
    -0.35453492f, -0.13172777f, -0.16740747f, 0.09906982f, -0.08578600f, -0.03387222f, -0.11500224f, -0.12573621f, 
    0.19168031f, -0.39503357f, -0.06709794f, -0.22831553f, -0.38790691f, 0.16226093f, 0.18215956f, 0.28402534f, 
    -0.18414688f, -0.02363379f, 0.04931299f, 0.11448713f, 0.21026932f, 0.25518245f, -0.03091579f, 0.24987619f, 
    -0.29317936f, 0.08977585f, 0.22301488f, -0.05108520f, 0.41209108f, -0.06798849f, -0.29864556f, 0.24743629f, 
    -0.10308937f, 0.04723147f, 0.19480202f, -0.08088714f, 0.02779863f, 0.39884898f, 0.03225058f, 0.33956271f, 
    -0.06039330f, 0.02554090f, -0.36735833f, 0.27422899f, 0.28879407f, -0.18174383f, -0.18803243f, 0.06911587f, 
    -0.17997999f, -0.04139316f, 0.35393670f, -0.01499175f, -0.38775837f, 0.21413921f, 0.13307509f, 0.14279926f, 
    0.03301911f, -0.29989624f, -0.06454436f, -0.45964050f, 0.31663123f, 0.08252960f, -0.14417528f, -0.25160414f, 
    -0.19720371f, -0.16058929f, 0.33237961f, 0.19534266f, 0.02643977f, 0.59263557f, -0.00971958f, -0.02481985f, 
    -0.26621106f, -0.13600509f, 0.11948009f, 0.13094616f, 0.35608193f, 0.05512314f, 0.21702988f, 0.35013816f, 
    -0.14585312f, -0.11392516f, 0.01898359f, 0.03564134f, -0.06498613f, -0.21696004f, -0.10938555f, 0.28662726f, 
    0.07964980f, 0.00478087f, -0.23106615f, 0.41713700f, 0.33677143f, -0.03402428f, 0.03830478f, 0.09002873f, 
    -0.23000103f, 0.20815283f, -0.26199910f, 0.17719673f, -0.24918085f, -0.07959084f, -0.14031935f, 0.11772448f, 
    -0.17975907f, 0.15234111f, -0.24414332f, 0.44703144f, -0.20477459f, -0.12586521f, 0.39480758f, 0.19170652f, 
    -0.21713696f, -0.15303940f, 0.20032352f, -0.28842217f, -0.36165571f, -0.70018530f, -0.21761578f, 0.13721067f, 
    -0.28178543f, -0.40632790f, -0.19070390f, 0.62195688f, 0.31397524f, 0.31950045f, -0.04115522f, -0.47381970f, 
    -0.58485615f, -0.03279461f, -0.02658035f, 0.26270798f, 0.12389579f, 0.08493640f, 0.15607938f, -0.41329172f, 
    0.12708266f, 0.10627217f, 0.14729266f, 0.21017282f, -0.11895993f, -0.35649025f, 0.30132076f, -0.28810185f, 
    0.03873928f, 0.34221461f, -0.32967171f, -0.26907140f, 0.40143383f, -0.28336513f, 0.14525840f, 0.06829856f, 
    0.13234219f, -0.23580079f, -0.23162062f, 0.15177301f, -0.15108527f, -0.03600456f, -0.26834348f, -0.19586466f, 
    0.21208924f, -0.19325309f, -0.05775756f, -0.19129634f, 0.19886898f, -0.02030662f, 0.03496376f, -0.17608383f, 
    0.29185316f, -0.07022492f, -0.12182741f, 0.11894624f, -0.33182326f, -0.34040359f, 0.13131574f, -0.30131772f, 
    0.06579986f, -0.20413519f, 0.09429482f, 0.17783374f, -0.40658990f, -0.35901439f, -0.11955836f, 0.34366637f, 
    -0.15589678f, -0.17015350f, -0.14398420f, -0.24955520f, -0.03278390f, -0.07341743f, 0.24390545f, -0.12791130f, 
    -0.18901998f, -0.22676677f, -0.10717893f, -0.09955880f, -0.12057218f, -0.16350782f, -0.04655042f, -0.02812132f, 
    0.00394393f, 0.34404835f, 0.43396363f, -0.28556472f, 0.03443145f, -0.39837870f, -0.04383244f, 0.30700961f, 
    -0.08997361f, -0.02951717f, 0.20863788f, 0.19392852f, -0.11408453f, -0.09108439f, -0.17426392f, -0.42856929f, 
    0.43250495f, -0.05441459f, -0.29740557f, -0.18331107f, -0.12590411f, 0.27438214f, 0.19422546f, 0.03778154f, 
    0.33902028f, -0.17036843f, -0.01141672f, 0.04278437f, -0.07263971f, 0.10897626f, -0.15171394f, 0.10487688f, 
    -0.19800256f, -0.15160450f, 0.17592031f, 0.40557504f, -0.01611994f, -0.41309324f, 0.03077032f, -0.26257491f, 
    0.36127666f, 0.07340278f, -0.06470022f, 0.24398296f, -0.12189797f, 0.56033152f, 0.11706793f, 0.36045587f, 
    -0.70110965f, 0.32887286f, -0.06335472f, 0.20141792f, -0.14310017f, 0.44604090f, -0.39617640f, 0.37470862f, 
    0.36203128f, -0.00467542f, -0.10852523f, 0.25155964f, -0.13235806f, -0.31354144f, -0.21169332f, 0.21018222f, 
    -0.15351726f, 0.09358495f, 0.30359152f, 0.18015870f, 0.15104035f, -0.56428701f, -0.29976246f, 0.02950038f, 
    -0.24362282f, 0.06724151f, 0.11675282f, 0.24355870f, 0.42662510f, -0.30074146f, -0.03902714f, -0.07590328f, 
    0.13710161f, 0.28427371f, -0.27239993f, -0.10798909f, -0.13241848f, 0.19677925f, -0.19093890f, 0.44251835f, 
    0.05108868f, -0.13692744f, -0.30534887f, 0.09962477f, 0.40519941f, 0.09625130f, 0.09615044f, 0.07415026f, 
    0.12906401f, -0.12647451f, -0.13475539f, -0.01928772f, -0.08729503f, 0.12914404f, -0.06145464f, 0.27514857f, 
    -0.19494417f, 0.33253440f, -0.18353306f, -0.25498274f, 0.19713557f, 0.24791719f, 0.13647288f, 0.20665707f, 
    0.03565894f, -0.10654637f, -0.14390706f, 0.20692538f, 0.32312846f, 0.31429774f, 0.20716740f, -0.10735270f, 
    0.47359413f, -0.02181977f, -0.25684100f, 0.09446394f, 0.14891034f, 0.04576221f, 0.08231485f, 0.02194400f, 
    -0.16029833f, -0.21397685f, 0.05665004f, 0.35959479f, 0.23429462f, 0.46932453f, -0.51903391f, 0.34841096f, 
    0.12790808f, -0.02068243f, -0.12557617f, 0.27715096f, -0.39921379f, -0.18916623f, 0.05231810f, -0.50533766f, 
    0.00047216f, 0.30136347f, 0.24086019f, -0.18073572f, -0.00789502f, 0.16595131f, -0.02990519f, -0.51369041f, 
    -0.12907682f, 0.12086914f, 0.20294918f, 0.14035664f, 0.02486078f, -0.13925581f, -0.17277552f, -0.07903975f, 
    -0.21982752f, 0.34388998f, -0.12122401f, 0.14148059f, 0.01586685f, -0.38283071f, -0.17785189f, 0.31862894f, 
    -0.22154973f, 0.27645037f, 0.13788141f, 0.26811302f, -0.55659693f, -0.03980442f, 0.05153472f, 0.10578442f, 
    0.22911267f, -0.26362774f, 0.31912664f, -0.11555177f, -0.29823720f, 0.14658254f, 0.31961119f, -0.53447270f, 
    -0.23765627f, 0.10085835f, 0.20454833f, 0.17642130f, 0.18288513f, -0.40250510f, -0.19404975f, -0.03500618f, 
    0.39043763f, 0.26034597f, -0.06290397f, 0.07983927f, 0.20559420f, -0.06418061f, -0.12293541f, 0.27388287f, 
    -0.36856127f, -0.01564629f, -0.11504091f, -0.08560780f, 0.00453755f, -0.27613059f, 0.14253706f, -0.00613323f, 
    0.21922798f, 0.23670830f, 0.27485725f, 0.02285014f, 0.05717418f, 0.01015374f, -0.39671355f, 0.17635313f, 
    -0.34184358f, 0.23550750f, -0.11395019f, 0.11913748f, 0.28105992f, -0.31334734f, -0.15756002f, -0.08584030f, 
    -0.03638826f, -0.01340783f, 0.05032907f, 0.19276084f, 0.08929726f, -0.20999877f, -0.33950195f, 0.37829193f, 
    -0.10736001f, 0.25776842f, 0.02342501f, 0.07334112f, 0.35466287f, 0.04586469f, 0.02110708f, -0.16946335f, 
    -0.00386281f, -0.10301626f, 0.09129666f, -0.18012515f, -0.30941185f, -0.13092059f, 0.32184321f, 0.16757376f, 
    0.72482765f, 0.13543129f, 0.18921474f, -0.23236252f, 0.14239037f, 0.16853431f, -0.06094509f, -0.15558766f, 
    -0.03944550f, -0.10234869f, 0.12393772f, 0.46075428f, -0.06022874f, -0.29411060f, -0.14782934f, -0.21410568f, 
    -0.41540432f, 0.20456736f, 0.22643924f, 0.14845084f, 0.00766751f, -0.04050720f, -0.06675379f, 0.18837923f, 
    0.11637193f, -0.16352749f, 0.08034700f, 0.02874136f, -0.14937216f, -0.13107240f, -0.00803283f, -0.23107061f, 
    -0.19228163f, -0.12757277f, -0.14937127f, -0.17941508f, -0.15387347f, 0.00193232f, -0.17727581f, -0.18230262f, 
    -0.19252740f, -0.25389859f, 0.14678214f, -0.23130664f, -0.06482606f, -0.13629355f, -0.23484087f, -0.04252252f, 
    0.08765024f, -0.31327996f, 0.05816930f, -0.25128716f, -0.05050154f, 0.07759339f, 0.23601383f, -0.07728401f, 
    0.10921201f, 0.19792856f, -0.15549918f, -0.29822120f, -0.19057924f, -0.01560739f, 0.36195824f, -0.23023736f, 
    -0.28162885f, 0.19346261f, 0.17131750f, 0.08377182f, 0.23538001f, -0.27676308f, -0.05151454f, -0.18491790f, 
    -0.13855372f, 0.32144609f, 0.37640437f, 0.46234345f, 0.20531040f, -0.37545940f, -0.18890582f, 0.26863128f, 
    0.50906837f, -0.17673649f, 0.26113278f, -0.27296862f, 0.08687846f, -0.17758569f, 0.16983423f, 0.04759632f, 
    -0.30730215f, 0.09100708f, 0.55066150f, 0.12952714f, -0.14814058f, 0.35996392f, 0.33383003f, 0.05161505f, 
    -0.11468367f, -0.17874254f, 0.01503027f, 0.23843001f, 0.41171679f, -0.35854277f, 0.15162177f, -0.06920651f, 
    -0.28007668f, -0.17350559f, 0.12718374f, -0.17404063f, -0.01588763f, 0.39105746f, -0.07995231f, -0.22936569f, 
    0.15269105f, -0.23447059f, 0.33212510f, 0.16191100f, -0.10928458f, 0.43768045f, -0.13165396f, 0.41771153f, 
    -0.02157304f, -0.04674642f, 0.01946144f, -0.01492267f, 0.02281012f, -0.09344218f, -0.07878107f, 0.03404894f, 
    -0.22903681f, -0.25738272f, -0.14891902f, -0.12571117f, -0.19477734f, 0.08780079f, -0.00300536f, 0.11782166f, 
    0.35443169f, -0.07504877f, -0.00902932f, 0.06101729f, -0.34903273f, -0.03144245f, -0.11240815f, -0.22901925f, 
    0.49526146f, 0.34939539f, -0.09627609f, -0.01146681f, 0.28786534f, -0.12570021f, 0.19884714f, 0.30492714f, 
    0.22509541f, -0.14040272f, -0.17080702f, -0.14326996f, -0.36864537f, 0.19651251f, -0.24143201f, -0.02905021f, 
    0.16812325f, -0.36236364f, 0.27685547f, 0.02464976f, 0.47659221f, 0.11496496f, 0.04348605f, 0.23215610f, 
    0.29904258f, 0.22681372f, -0.00515189f, -0.12853082f, -0.18378247f, -0.03578629f, 0.11572431f, -0.05429023f, 
    0.16541703f, 0.20854814f, 0.22871761f, 0.12172670f, -0.16357782f, -0.21485464f, -0.04444694f, -0.07778599f, 
    -0.03048635f, -0.21696150f, 0.01286052f, -0.24720596f, -0.00441895f, 0.15350603f, 0.41723472f, -0.38112551f, 
    0.20539650f, 0.13597129f, 0.32963595f, 0.05581678f, -0.34998533f, -0.02527250f, 0.12667932f, 0.12533905f, 
    0.11734374f, 0.31503743f, 0.28331953f, 0.22033291f, -0.11981989f, 0.18873002f, -0.08570249f, -0.25285304f, 
    -0.11328420f, 0.26471385f, 0.17662375f, 0.11862033f, 0.03157799f, -0.35247314f, -0.22054490f, -0.35434434f, 
    0.05332959f, -0.21791509f, 0.09029131f, -0.18719773f, 0.24778983f, -0.07559863f, 0.30090818f, 0.30146402f, 
    -0.27020732f, -0.34648824f, -0.22797167f, 0.22684555f, 0.03731241f, 0.24950542f, 0.18577982f, 0.26414365f, 
    -0.18505099f, 0.13703212f, 0.14596802f, 0.08247760f, -0.22533754f, -0.08239619f, 0.25493351f, -0.25456619f, 
    0.26334038f, -0.46172327f, 0.28430527f, 0.12042899f, -0.25388658f, -0.31905463f, -0.13947536f, 0.39767841f, 
    -0.09811950f, -0.13939179f, 0.15363632f, -0.30088443f, -0.13778958f, -0.02723166f, 0.00892387f, -0.35065222f, 
    0.42618951f, 0.13196377f, 0.34941342f, 0.02572727f, -0.39958185f, 0.36877015f, 0.02212778f, 0.21345478f, 
    0.39106560f, -0.11593360f, 0.03375519f, 0.21232361f, -0.14826956f, 0.05141870f, 0.26951128f, 0.17300126f, 
    0.25665954f, -0.38579458f, -0.01310345f, -0.01907396f, 0.42856047f, -0.14827691f, 0.12311623f, 0.31532419f, 
    -0.19062875f, 0.12111308f, -0.02713192f, -0.25831380f, -0.21022144f, -0.21456820f, 0.02263023f, 0.13501380f, 
    0.09549387f, -0.16038078f, -0.10579025f, -0.00331453f, -0.10889338f, -0.09169984f, -0.06482977f, -0.08102900f, 
    -0.17924710f, 0.30678251f, -0.03525664f, 0.20201792f, -0.30979824f, -0.23865120f, -0.26934621f, 0.17377624f, 
    -0.05295422f, -0.08474430f, -0.00042980f, 0.05299928f, 0.12975626f, -0.02456701f, 0.16467083f, -0.10939285f, 
    -0.13447702f, 0.29095271f, 0.24732105f, -0.08446303f, 0.24433824f, -0.08930293f, -0.35904539f, -0.27404475f, 
    -0.48342341f, 0.28760400f, 0.08337735f, -0.21044894f, 0.01295146f, 0.34293410f, 0.08916456f, 0.32108697f, 
    -0.09805618f, -0.02831731f, 0.41824749f, -0.27572736f, -0.23072699f, 0.17982283f, -0.10685555f, 0.16796544f, 
    0.34341270f, -0.03482550f, -0.04362810f, 0.13892166f, 0.01949257f, 0.07456418f, -0.06591151f, 0.20471750f, 
    -0.08944123f, 0.20910038f, 0.15120205f, -0.28350243f, 0.35905156f, 0.32791832f, 0.12866241f, -0.17939042f, 
    -0.00339215f, -0.32919925f, 0.13625301f, 0.23827508f, 0.24432312f, -0.31043208f, -0.13460527f, -0.12230552f, 
    0.30374303f, 0.25159323f, 0.16500777f, -0.00145130f, 0.31458384f, -0.43371198f, -0.00017789f, 0.03912574f, 
    -0.31756034f, -0.27371866f, -0.04704175f, 0.34011039f, 0.04659225f, -0.21643937f, 0.14270023f, -0.20066294f, 
    0.02288068f, -0.18164429f, -0.24100301f, 0.07812116f, -0.13244632f, 0.01450710f, -0.04859723f, -0.08263443f, 
    -0.22038849f, -0.09428303f, -0.26553315f, -0.25733808f, 0.22686297f, -0.05239991f, -0.00256985f, -0.08299314f, 
    0.03116118f, 0.01491938f, 0.02247729f, 0.09168647f, 0.08226578f, 0.20749833f, -0.26788449f, 0.56300992f, 
    -0.16053322f, -0.14618181f, -0.27552328f, 0.21837464f, 0.30718631f, 0.07623962f, -0.02461727f, -0.26828134f, 
    0.12959342f, -0.07393233f, 0.19263241f, 0.15114655f, 0.26691970f, 0.02156116f, -0.36338416f, -0.08910735f, 
    0.21213260f, -0.24640310f, 0.17600362f, -0.22378129f, 0.18732138f, 0.46754819f, -0.16990948f, 0.33744830f, 
    -0.06617831f, -0.07752055f, 0.02819093f, 0.14435849f, -0.25497872f, 0.07063895f, -0.15163644f, -0.09898932f, 
    -0.02991753f, 0.01990442f, -0.00774172f, -0.14391616f, -0.22333631f, -0.29388726f, -0.17714816f, -0.20961931f, 
    -0.06977996f, 0.02863262f, 0.27476817f, 0.17945617f, -0.20787722f, 0.15323523f, -0.20134108f, 0.02114417f, 
    0.08315971f, 0.18060707f, -0.24070722f, -0.17649479f, 0.45362106f, 0.15244624f, -0.07092383f, 0.19099160f, 
    0.32128304f, 0.28460228f, -0.12673520f, -0.20779164f, -0.03966816f, 0.16117409f, 0.20967884f, -0.19193423f, 
    -0.53936940f, 0.17231604f, -0.03394514f, 0.18992703f, -0.06284166f, 0.02026498f, 0.10903463f, -0.26865971f, 
    -0.21280491f, 0.36341307f, 0.09110349f, -0.11884079f, 0.07150565f, -0.26501259f, -0.35682645f, -0.23204416f, 
    -0.33883700f, 0.12988476f, 0.20291153f, 0.19863506f, 0.05517448f, 0.59723514f, -0.18791285f, 0.03707822f, 
    0.04553809f, -0.05760619f, -0.00980574f, 0.07165962f, -0.32344428f, -0.18358478f, 0.54633921f, -0.43131480f, 
    -0.04884769f, -0.35447508f, 0.04057451f, 0.00323571f, -0.10194322f, -0.22365971f, 0.02001724f, 0.32673338f, 
    0.28204939f, -0.01697811f, -0.10177321f, -0.04006033f, 0.00437835f, -0.02828958f, 0.04582988f, -0.39129201f, 
    -0.17734076f, -0.39527139f, 0.37415558f, 0.12088849f, 0.02106846f, -0.16980278f, 0.04261798f, 0.06714958f, 
    0.16563505f, 0.00631810f, 0.40674058f, 0.11698269f, 0.23283154f, 0.15745321f, -0.04222902f, -0.35705048f, 
    -0.21654518f, -0.36682597f, -0.25513849f, -0.10241946f, 0.37952828f, 0.25496265f, 0.04451263f, 0.06984169f, 
    -0.24079169f, 0.08064403f, -0.30754453f, 0.17368384f, -0.21321595f, -0.21907179f, 0.48310757f, 0.36200780f, 
    -0.07593507f, -0.14968710f, -0.03835595f, -0.09715996f, 0.33636653f, 0.01763527f, 0.07920972f, -0.16723138f, 
    -0.14319144f, -0.33547175f, -0.14738859f, -0.33761796f, 0.33883232f, 0.40303394f, -0.03696686f, -0.24518634f, 
    0.14842556f, 0.31428638f, 0.10318205f, -0.21789090f, 0.32468039f, 0.31188950f, -0.05535460f, 0.12139234f, 
    -0.03589861f, -0.02700581f, 0.13181970f, -0.36342639f, 0.03219447f, 0.04208574f, -0.21029678f, 0.35235921f, 
    -0.28599173f, -0.01270487f, 0.11831704f, 0.11719142f, -0.01808662f, 0.29544139f, -0.22594777f, -0.05767824f, 
    0.06842335f, -0.02046373f, -0.32689768f, -0.25255585f, -0.24479848f, 0.25768012f, 0.14455277f, 0.45554012f, 
    0.28700089f, 0.21975635f, 0.02542994f, 0.18787059f, -0.09339365f, -0.50901967f, -0.03652564f, -0.14576416f, 
    0.41485214f, 0.07951782f, 0.00595465f, 0.21517731f, -0.13396455f, -0.06592196f, 0.41424540f, 0.02658196f, 
    -0.39579496f, 0.16775621f, 0.01339318f, -0.00003109f, -0.22587305f, -0.29583243f, 0.01143953f, -0.06634580f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.34112903f, -0.06732202f, 0.08475442f, 0.12980181f, -0.33952937f, -0.30564976f, -0.17465159f, -0.14276323f, 
    -0.30805275f, 0.30212954f, -0.03661883f, -0.00939456f, 0.07433385f, 0.07984073f, 0.05929672f, 0.48337308f, 
    0.02743211f, 0.07287394f, 0.43008178f, -0.05147207f, 0.12173781f, 0.45235205f, -0.41424218f, 0.21892735f, 
    -0.00089348f, -0.01499519f, 0.07244022f, -0.05244348f, 0.23341544f, -0.07367457f, 0.25408956f, 0.40424189f, 
    0.07699098f, -0.00945336f, -0.18625550f, -0.20027430f, 0.19762386f, -0.17669007f, 0.01522655f, 0.04512684f, 
    -0.00892464f, -0.19376217f, 0.11241768f, -0.23470369f, -0.27915692f, 0.20397641f, 0.01020596f, -0.25345078f, 
    0.14927025f, 0.24418986f, -0.12764379f, 0.00503158f, 0.27528882f, 0.37760767f, -0.04976875f, -0.19390397f, 
    -0.20391229f, 0.42730111f, -0.07204058f, 0.21016423f, 0.25046876f, 0.33800909f, -0.09768413f, -0.16758075f, 
    0.37339431f, 0.05340466f, 0.08984403f, -0.21676683f, -0.12902765f, 0.19592181f, -0.05394255f, -0.10681772f, 
    -0.08808100f, 0.10793412f, 0.14117454f, 0.33104700f, 0.06193967f, -0.32634804f, 0.27919504f, 0.31241021f, 
    0.17503835f, -0.44848391f, -0.05251129f, -0.03570583f, -0.06148226f, 0.05061629f, 0.51030517f, -0.21998513f, 
    -0.11751144f, -0.48936540f, 0.42149827f, -0.09075877f, 0.05130114f, 0.35401446f, -0.27223754f, -0.05375933f, 
    0.08554260f, 0.12643579f, 0.03094421f, 0.18663915f, -0.08482894f, 0.18364835f, 0.05713027f, 0.43829834f, 
    0.23029511f, 0.22773039f, -0.21799748f, -0.19668674f, -0.06389958f, 0.34862933f, -0.26172942f, 0.02032395f, 
    -0.24735318f, 0.20541739f, 0.13064384f, -0.28013831f, -0.09890620f, -0.06848705f, 0.33394384f, 0.09204865f, 
    0.19667122f, 0.17388994f, -0.33951291f, -0.00005740f, 0.32303175f, 0.27340445f, -0.14169925f, 0.33531442f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.04135591f, 0.05367921f, 0.25062317f, 0.21736187f, -0.00851759f, 0.06314028f, 0.19495288f, 0.12093738f, 
    -0.41235450f, -0.07707610f, -0.16967957f, -0.05259704f, -0.01965013f, 0.11449495f, 0.31668124f, 0.01786177f, 
    0.04705237f, 0.38976216f, 0.07896286f, -0.19284661f, 0.10791583f, 0.23742831f, -0.13243738f, 0.02396611f, 
    0.15565573f, 0.15366465f, 0.26163003f, 0.28791440f, 0.32151797f, 0.15736271f, 0.09497903f, 0.16639766f, 
    0.06075487f, 0.15103213f, 0.13646902f, -0.07940605f, 0.24866241f, -0.16125931f, -0.01093973f, -0.14880787f, 
    0.15042399f, -0.26639616f, 0.30313393f, 0.17886347f, 0.53348404f, -0.52282023f, -0.14298688f, 0.01433288f, 
    -0.08458319f, 0.18865569f, -0.03676493f, -0.04259608f, -0.08570167f, 0.22243518f, -0.41593149f, -0.15896235f, 
    0.04973419f, 0.05790360f, -0.23687805f, -0.11813909f, 0.22578371f, 0.24857868f, 0.02292627f, 0.01718568f, 
    0.18918850f, 0.13561112f, 0.09512976f, 0.19503167f, 0.61032766f, -0.04414441f, -0.45859557f, -0.10144158f, 
    0.05620345f, 0.03746766f, 0.03344244f, 0.21469845f, -0.03968346f, -0.22475538f, -0.10330608f, -0.17021166f, 
    -0.03913225f, 0.09080900f, -0.22413516f, -0.05318254f, 0.05250920f, 0.01436717f, 0.04771630f, -0.15396480f, 
    -0.05135497f, 0.06807048f, 0.04154216f, -0.00357949f, 0.02868614f, 0.14895478f, 0.00921008f, 0.00896924f, 
    -0.03787657f, 0.03231032f, -0.08496290f, -0.06915218f, 0.14075926f, 0.18426323f, 0.06122135f, 0.13121684f, 
    0.00127914f, 0.08035836f, 0.02357011f, -0.02375942f, 0.13056791f, -0.09590181f, -0.24265465f, 0.09601068f, 
    -0.24965574f, 0.06771992f, 0.01269604f, -0.19710475f, -0.02691871f, -0.34821159f, 0.07161072f, -0.16435477f, 
    -0.04480067f, -0.00697168f, 0.09718080f, 0.25038928f, -0.02946518f, -0.09484690f, 0.14335062f, 0.39690995f, 
    0.15036322f, -0.03243583f, -0.12761502f, 0.34802225f, 0.05762276f, -0.12149380f, -0.15171678f, -0.10728869f, 
    -0.34796596f, -0.23233789f, 0.00996800f, -0.01034566f, 0.04653439f, 0.02287116f, 0.16545103f, -0.05367501f, 
    -0.10080595f, 0.12511382f, 0.24494894f, 0.21947379f, -0.35779306f, -0.09075871f, -0.07457183f, 0.03388825f, 
    0.17483021f, -0.15049714f, -0.33134493f, -0.11129740f, 0.03331953f, 0.23010403f, -0.07625397f, -0.13845094f, 
    0.13955197f, 0.20937665f, 0.03084944f, 0.03463155f, 0.01033849f, 0.00412869f, -0.03648852f, 0.15434568f, 
    0.16605821f, 0.02290349f, 0.09129836f, 0.58366716f, 0.05719019f, 0.14090000f, -0.07101788f, 0.15240921f, 
    0.09181867f, 0.20723952f, 0.06348673f, -0.05764277f, -0.03458394f, 0.12552729f, 0.19747883f, -0.06796330f, 
    -0.06969510f, 0.16862692f, -0.08639447f, 0.16589369f, 0.33297670f, -0.10830861f, -0.01689545f, 0.12005734f, 
    0.13740396f, 0.32991275f, 0.17349423f, -0.02532237f, -0.31443328f, 0.45677534f, 0.21406469f, 0.04265639f, 
    -0.44386679f, 0.04007928f, 0.14748779f, 0.02142132f, 0.17265962f, 0.11542712f, 0.14968295f, -0.00602439f, 
    -0.12122182f, -0.12327483f, 0.08890674f, 0.19835393f, 0.03012349f, 0.11698087f, -0.13119943f, -0.02657944f, 
    -0.07775450f, -0.18967040f, -0.02176076f, -0.02955402f, -0.07915317f, 0.08423214f, -0.01246778f, 0.09644745f, 
    0.29396600f, 0.03756171f, -0.17191477f, 0.06567395f, -0.14019813f, 0.15409717f, -0.01650393f, 0.19633308f, 
    0.14753273f, -0.00706869f, -0.02695706f, -0.04117598f, 0.13522650f, 0.10490175f, -0.04622318f, 0.31190503f, 
    -0.12187245f, -0.00782756f, -0.02106351f, 0.11176166f, -0.07356158f, -0.09423077f, 0.06293128f, 0.21007156f, 
    -0.34031519f, 0.15941149f, -0.54383093f, 0.32235757f, 0.16973917f, 0.06607664f, -0.06144629f, -0.19654894f, 
    0.23105964f, 0.13464728f, 0.04466385f, 0.14398956f, -0.10787003f, 0.05937430f, -0.00939485f, -0.15689655f, 
    -0.47842556f, -0.26512951f, -0.39760154f, -0.37974942f, -0.16094917f, 0.18181410f, 0.14178783f, -0.29938132f, 
    -0.21453953f, 0.07110759f, 0.06532226f, 0.11160625f, -0.10793552f, -0.12031060f, 0.11608998f, -0.08844343f, 
    0.27299884f, -0.09353308f, -0.19891404f, -0.12980248f, 0.34679782f, 0.18296686f, -0.05878862f, 0.29681987f, 
    -0.05266724f, -0.07929161f, 0.18698557f, -0.00188235f, -0.12495933f, 0.26213804f, -0.01204703f, -0.24069656f, 
    0.30058861f, -0.18411298f, -0.09442535f, 0.12800555f, 0.12830409f, 0.29603642f, 0.13484569f, 0.20617360f, 
    -0.04603043f, -0.19934063f, -0.07831022f, -0.16581929f, -0.04352127f, -0.08660776f, 0.69244885f, -0.25867796f, 
    0.00571992f, 0.33789864f, -0.04001987f, -0.02162305f, 0.40373939f, -0.13455778f, 0.14574462f, -0.13326862f, 
    0.14950818f, 0.03898097f, -0.01110805f, -0.06879456f, -0.28817791f, 0.26129642f, -0.27820638f, -0.08225271f, 
    0.05526733f, -0.02763988f, 0.01187214f, 0.24763894f, 0.06484106f, -0.14483772f, -0.06223359f, 0.20189534f, 
    -0.19698294f, 0.11318983f, 0.37251735f, -0.06418261f, -0.26111910f, -0.03619888f, -0.17648400f, -0.42561483f, 
    -0.30530426f, -0.27315193f, -0.10850228f, 0.06632879f, -0.04580970f, 0.09742781f, 0.21139909f, 0.29905155f, 
    0.21662202f, 0.08199429f, -0.09171560f, 0.31916335f, -0.01613720f, 0.11603430f, -0.27383471f, 0.23912601f, 
    0.34693289f, 0.06376691f, 0.27993369f, 0.07905737f, -0.11472050f, -0.29069126f, -0.03040827f, 0.20309335f, 
    -0.03625633f, 0.08268172f, 0.24105217f, 0.06746358f, -0.11116461f, -0.30048725f, -0.13122474f, -0.08992250f, 
    0.56056482f, 0.32132256f, -0.02349891f, -0.25333023f, -0.05698700f, 0.02377284f, -0.04380277f, 0.04882824f, 
    0.09018332f, 0.01075418f, 0.01669784f, -0.12676123f, -0.04449511f, 0.13685043f, 0.08311364f, 0.04962013f, 
    0.45634809f, 0.07870858f, 0.34318858f, 0.15771067f, 0.01525618f, -0.14356889f, -0.24985009f, -0.02290525f, 
    -0.05820500f, -0.01572660f, -0.04202347f, 0.43503055f, 0.07826841f, 0.02619409f, 0.20720653f, 0.05702618f, 
    -0.25482312f, -0.24393691f, -0.10870983f, -0.17381091f, -0.35670853f, -0.14189276f, -0.17727135f, -0.03157730f, 
    -0.08098290f, 0.08338252f, -0.10131159f, -0.01078814f, -0.10480282f, 0.36252457f, 0.09297167f, 0.56187433f, 
    0.06220936f, 0.10491214f, -0.13453493f, 0.29081714f, -0.45771050f, 0.27428809f, 0.34106371f, 0.17167822f, 
    -0.14271790f, -0.11664915f, 0.07086214f, 0.01446867f, -0.06483307f, -0.15902562f, 0.24037687f, 0.12532321f, 
    -0.04612903f, -0.12348393f, -0.01994578f, 0.15805119f, -0.09678951f, -0.01616913f, 0.16523376f, 0.07783901f, 
    -0.11891426f, 0.07270882f, -0.23969041f, -0.07735380f, -0.38650221f, -0.38248652f, 0.40124977f, -0.09736985f, 
    -0.04177086f, 0.05858799f, -0.12384521f, 0.05982359f, 0.15451552f, 0.51389962f, 0.07647003f, 0.20934923f, 
    0.04928434f, 0.10054757f, 0.22033134f, 0.18975501f, -0.08477893f, 0.02521488f, 0.11631471f, 0.13563502f, 
    0.05455010f, -0.13615566f, 0.00413317f, 0.03269842f, 0.05793304f, -0.08854590f, 0.18949629f, 0.07566165f, 
    0.05747168f, -0.03654875f, 0.14859468f, 0.13415278f, -0.02631296f, -0.12387574f, 0.08516601f, -0.26438913f, 
    -0.00278580f, -0.09133966f, 0.13358709f, 0.07132076f, 0.25268894f, -0.01855795f, 0.08519489f, 0.02982031f, 
    0.36173266f, -0.05527683f, -0.04842319f, 0.29189268f, 0.04149568f, 0.24492317f, -0.11749990f, 0.16006450f, 
    0.00613952f, 0.27739629f, 0.08526853f, -0.41594359f, -0.03737986f, -0.05255758f, -0.09133908f, -0.10548157f, 
    0.02569434f, -0.04498105f, -0.02440682f, -0.15183052f, 0.13383050f, 0.29711044f, 0.25813776f, 0.03658574f, 
    -0.01698070f, 0.19227292f, 0.15896510f, -0.03717165f, 0.08704340f, 0.04760142f, -0.12856506f, 0.08044922f, 
    0.05005149f, -0.30874026f, -0.15902907f, -0.14636773f, -0.27090168f, -0.04886661f, -0.03497248f, 0.06694641f, 
    -0.10217294f, 0.20927840f, 0.31681541f, 0.11695301f, -0.34365138f, -0.01447170f, 0.03226896f, -0.14711842f, 
    0.01497287f, -0.02711570f, -0.11916406f, 0.07402375f, -0.09207539f, 0.17328343f, 0.09071949f, -0.19823837f, 
    0.08716228f, -0.09938858f, -0.10675915f, -0.25236320f, 0.35683456f, 0.24729875f, 0.25113335f, 0.11795080f, 
    -0.03540875f, -0.06606679f, 0.09583968f, 0.18901378f, -0.04173026f, 0.04980748f, 0.12589458f, 0.10097353f, 
    0.06621548f, 0.18984631f, -0.18082754f, 0.10557570f, 0.03119632f, -0.15479504f, 0.09352887f, -0.12894125f, 
    -0.17488280f, 0.10117522f, -0.08347950f, 0.09661455f, 0.16180179f, -0.20017414f, 0.39407521f, 0.02667385f, 
    0.15258315f, 0.03313779f, -0.04736886f, -0.01388749f, 0.04669026f, -0.04814356f, -0.06122631f, 0.04102016f, 
    0.06174068f, 0.15050296f, -0.15764983f, 0.16574241f, -0.16213670f, 0.10406110f, -0.08138144f, 0.07764413f, 
    0.06540129f, 0.66199654f, 0.00603186f, 0.06410637f, -0.00178423f, 0.13967094f, -0.03342783f, 0.11726931f, 
    0.11095193f, -0.03605719f, 0.28891453f, 0.04807959f, 0.19581775f, 0.11158035f, 0.17905021f, -0.14587253f, 
    0.27347904f, 0.19014233f, 0.21844026f, 0.00430388f, -0.41484097f, -0.03156474f, 0.06936450f, 0.04419717f, 
    -0.13191833f, 0.05593399f, -0.19010887f, 0.11107138f, -0.00036143f, 0.18739256f, -0.02360154f, -0.04715583f, 
    0.15397075f, 0.16890824f, 0.13919431f, 0.21354288f, 0.12195025f, -0.10003631f, 0.20262821f, 0.10596580f, 
    -0.10996664f, 0.40391204f, 0.02686977f, 0.18013331f, 0.17209189f, 0.20049316f, 0.12629442f, 0.12413083f, 
    0.33184433f, 0.08626606f, 0.33860534f, 0.10931338f, 0.18355620f, 0.05517636f, -0.06477554f, -0.01651354f, 
    -0.02696856f, -0.19078110f, -0.09987857f, -0.43587106f, 0.58879042f, -0.07177933f, 0.03664737f, 0.06981072f, 
    0.04286611f, -0.12678249f, 0.08243921f, 0.13153341f, 0.49231815f, -0.06016878f, -0.11811501f, -0.56193459f, 
    -0.26066446f, 0.01023863f, 0.08084536f, 0.03460153f, 0.02339744f, 0.05675262f, 0.06531369f, 0.22381988f, 
    -0.09284330f, 0.23303235f, -0.32150173f, -0.22269610f, -0.31616476f, 0.03317193f, 0.30596870f, 0.06739420f, 
    -0.04717150f, -0.27086782f, 0.11868596f, -0.07409259f, -0.01596627f, -0.09364458f, -0.10108612f, 0.10768458f, 
    -0.05786824f, -0.11998798f, 0.01223973f, 0.24653129f, -0.05335007f, 0.20660494f, -0.01009177f, 0.11908622f, 
    -0.04107095f, -0.16857396f, -0.02977283f, 0.01742093f, -0.12990116f, 0.10161527f, 0.07629737f, -0.07575890f, 
    -0.34907427f, 0.06172794f, -0.00523995f, -0.11575537f, 0.10836293f, 0.17866251f, 0.20040236f, -0.09421352f, 
    0.07031679f, 0.10752506f, 0.03009865f, -0.07365314f, -0.03141385f, 0.11901577f, -0.06793073f, 0.13036382f, 
    0.11305378f, 0.00282730f, 0.05494560f, 0.00711249f, -0.03438380f, -0.07194876f, 0.31961924f, 0.00667197f, 
    -0.07354093f, -0.05108039f, 0.11952284f, 0.09737709f, -0.10208128f, -0.10938112f, 0.08085077f, -0.14389989f, 
    0.01558721f, -0.11002484f, 0.22864743f, -0.04882838f, -0.12941125f, -0.07036913f, -0.08796602f, -0.04354687f, 
    0.25608426f, 0.04465116f, -0.10906409f, 0.14867634f, 0.14102511f, 0.12508701f, -0.20514424f, -0.04341893f, 
    -0.58197016f, 0.04052893f, 0.42428723f, -0.26431459f, -0.13722289f, -0.14263920f, -0.26463178f, -0.10215952f, 
    0.04789282f, 0.24500163f, -0.12019391f, 0.00071070f, -0.09971805f, 0.18506254f, -0.05451192f, 0.04950248f, 
    -0.43927702f, -0.13556419f, 0.14491303f, 0.02463805f, 0.12055606f, 0.16342103f, 0.15884449f, -0.12368959f, 
    0.28312144f, 0.14955325f, -0.00441098f, 0.47056380f, 0.09901386f, 0.08725841f, 0.02753460f, 0.05607535f, 
    -0.15305980f, 0.09025215f, -0.06304289f, 0.10152684f, -0.11781073f, -0.17851371f, -0.25331435f, 0.08582089f, 
    0.19550151f, 0.29200232f, 0.14803557f, 0.05398889f, 0.22373807f, -0.45787111f, -0.05002161f, -0.02937756f, 
    0.03392065f, -0.13765655f, -0.26405558f, 0.05520562f, -0.07245959f, -0.10675334f, 0.00587530f, -0.17179929f, 
    0.15502299f, 0.00514422f, 0.11376280f, 0.03585822f, -0.14284484f, 0.22781125f, -0.24934170f, 0.01079915f, 
    -0.02813741f, 0.09947436f, -0.18199152f, -0.02348983f, 0.09684394f, 0.22421849f, -0.06804486f, 0.13992579f, 
    0.31607392f, -0.09756830f, 0.16913886f, -0.00114848f, -0.15906021f, -0.43863699f, -0.23158139f, -0.08613723f, 
    -0.41649079f, -0.01714419f, 0.12633124f, 0.00866069f, -0.10749501f, 0.26719880f, 0.26479617f, -0.02164366f, 
    0.01992026f, -0.20611233f, -0.03302877f, -0.01242525f, 0.31012139f, 0.07265471f, 0.09146166f, -0.00157594f, 
    0.22913574f, -0.16214800f, 0.10271852f, -0.07890417f, 0.03814366f, -0.04998587f, 0.37756139f, 0.27937317f, 
    0.09023944f, -0.03119327f, -0.14794229f, 0.00842647f, -0.06723184f, 0.01417104f, 0.22105731f, -0.14965969f, 
    -0.31253442f, -0.20715007f, 0.05518367f, 0.07051913f, 0.50637442f, -0.11325325f, 0.04056935f, 0.16696782f, 
    -0.14062551f, -0.06197401f, 0.29873869f, 0.12116598f, 0.08296418f, -0.19182563f, -0.10119799f, -0.06457302f, 
    -0.44048440f, -0.18740807f, 0.21292043f, -0.29010475f, -0.11395923f, 0.05723599f, 0.14810312f, 0.09969252f, 
    0.07742666f, 0.00932706f, 0.34189489f, 0.12226058f, 0.01196366f, -0.10374397f, -0.34414083f, -0.00146013f, 
    0.52219361f, -0.03500534f, -0.62528229f, -0.00982425f, -0.03877053f, 0.09546173f, 0.16415086f, 0.06979654f, 
    -0.40018931f, 0.17625996f, 0.13755946f, 0.14111230f, 0.42468449f, -0.01177502f, 0.26239261f, 0.07522380f, 
    0.19586025f, -0.29820579f, 0.16836740f, 0.08594992f, 0.23189439f, 0.18165711f, 0.00486968f, 0.17202614f, 
    -0.17120680f, -0.19153294f, 0.15179528f, 0.03188166f, -0.12137262f, 0.62653172f, 0.00372291f, 0.44704896f, 
    0.05477722f, 0.39509878f, 0.01023564f, -0.19953489f, -0.01925244f, 0.15512238f, 0.07281104f, 0.21287988f, 
    -0.00310541f, -0.04050012f, -0.11087089f, -0.22149175f, 0.12439571f, -0.22699653f, 0.57743603f, 0.09049293f, 
    -0.02320858f, -0.03672969f, 0.31295943f, -0.25271881f, -0.18314840f, 0.06032535f, 0.19776331f, 0.09192119f, 
    0.01030668f, 0.20568021f, -0.05426177f, 0.06563557f, 0.20753609f, 0.08649840f, -0.24018589f, -0.04623174f, 
    0.30660924f, -0.05881850f, -0.03256642f, 0.27279770f, 0.09871943f, -0.31863832f, -0.41408440f, 0.21097499f, 
    0.09928261f, 0.17110029f, -0.71457416f, 0.06402814f, 0.17066181f, -0.12777472f, 0.09198692f, -0.16284730f, 
    -0.10986933f, -0.14777386f, -0.08794698f, 0.08398260f, 0.06176387f, -0.06275266f, 0.02702059f, -0.19442511f, 
    0.13769355f, -0.04373085f, 0.04896919f, 0.10489524f, 0.01904314f, -0.05114608f, -0.16543184f, 0.29961666f, 
    0.01339328f, -0.08349801f, 0.17804904f, 0.07124350f, 0.09826494f, 0.02812882f, 0.10892097f, 0.10537249f, 
    0.46022859f, 0.01419682f, -0.26991361f, 0.18659079f, -0.00478995f, -0.05959650f, 0.22245523f, 0.10201547f, 
    0.44739729f, -0.09893324f, 0.28733015f, 0.33998922f, -0.22200280f, 0.01403388f, 0.06219681f, -0.04961287f, 
    0.00514978f, -0.06949117f, -0.01572546f, 0.05800109f, 0.04916404f, 0.06540760f, 0.10325677f, -0.11196005f, 
    0.02839953f, -0.06229836f, 0.01630996f, 0.01360002f, 0.05341722f, -0.06352874f, 0.01036664f, -0.10791333f, 
    -0.04806431f, 0.04070903f, 0.02289859f, 0.00013600f, 0.02319862f, -0.01191443f, 0.00594105f, 0.00756651f, 
    -0.03057210f, -0.05489838f, -0.03737353f, 0.05782123f, 0.02666359f, -0.14002106f, -0.02938755f, -0.05885329f, 
    -0.05652800f, 0.03405193f, -0.06034077f, -0.04269257f, -0.05699478f, 0.05039175f, 0.05514407f, -0.01943607f, 
    -0.12182928f, -0.05438697f, -0.09650340f, 0.12615690f, -0.03227907f, 0.05491479f, 0.03817415f, -0.03323758f, 
    0.02158473f, -0.07531528f, -0.09620524f, -0.05473584f, -0.04983864f, -0.10753307f, 0.02975960f, -0.08005229f, 
    0.07562248f, -0.13321623f, -0.03541109f, 0.06470821f, -0.01013548f, -0.07413382f, -0.01900482f, 0.01193643f, 
    -0.03780039f, -0.03406960f, -0.12266322f, -0.02699672f, -0.01764307f, -0.10890029f, 0.03561267f, -0.04727519f, 
    -0.07546131f, -0.04998771f, -0.07037713f, 0.01970956f, 0.02330937f, -0.12279827f, -0.01272221f, -0.02353942f, 
    -0.07072162f, 0.06446397f, -0.01348445f, 0.03102273f, -0.00229681f, 0.02733687f, 0.05197550f, -0.05102777f, 
    0.05033760f, 0.01277264f, -0.01723764f, -0.06208206f, -0.08280235f, 0.07756816f, -0.00369122f, -0.06385957f, 
    -0.10710698f, 0.07148042f, -0.01119237f, -0.11946467f, 0.00868069f, -0.01282179f, 0.00577633f, -0.09332636f, 
    -0.04839998f, -0.15495409f, 0.02709288f, -0.07998356f, 0.06546407f, -0.11092750f, -0.00321042f, -0.09292097f, 
    -0.01994063f, 0.00834722f, 0.00467899f, -0.14939740f, 0.02790550f, -0.03387668f, -0.05251135f, -0.04901119f, 
    -0.02619767f, -0.01172849f, 0.03675878f, -0.01224106f, -0.02445756f, -0.03536044f, 0.06062379f, -0.00498790f, 
    0.04992007f, -0.00048650f, -0.03577872f, -0.04024960f, -0.03295788f, -0.07221476f, -0.00829137f, 0.07695284f, 
    -0.09718961f, 0.03688844f, -0.09420250f, -0.03743495f, -0.09845151f, -0.01180064f, 0.00761804f, -0.08289836f, 
    0.03871180f, 0.01500876f, -0.10232303f, 0.05092918f, 0.07387907f, -0.10329369f, -0.06035881f, 0.04368473f, 
    0.03251278f, -0.03824690f, 0.06182311f, -0.11726829f, -0.06706077f, -0.05810320f, -0.03255276f, -0.01705509f, 
    -0.01643822f, 0.03236425f, -0.07025095f, 0.04327732f, -0.05512068f, 0.00463467f, 0.01938774f, -0.01375579f, 
    -0.08558035f, 0.04174455f, 0.04672760f, 0.04340031f, -0.08002349f, -0.02180614f, 0.04380953f, -0.02011625f, 
    -0.06097656f, -0.00966441f, -0.10238143f, -0.07839318f, -0.04166709f, -0.02467840f, 0.04698871f, 0.01898374f, 
    -0.00750361f, -0.09188931f, 0.05655930f, -0.07998428f, -0.00453452f, -0.09967601f, -0.08718068f, -0.11096892f, 
    -0.06786293f, 0.00688911f, -0.05822413f, 0.00218458f, -0.01845417f, 0.03372034f, 0.05301767f, -0.01787333f, 
    -0.05920170f, -0.02481347f, 0.03349071f, -0.11570129f, -0.06888680f, -0.11450251f, 0.04288110f, -0.04866844f, 
    -0.01217057f, -0.05498385f, -0.07761933f, -0.07767124f, -0.05834385f, 0.02189941f, -0.01426143f, 0.04842336f, 
    -0.11585543f, 0.04277528f, -0.02028070f, 0.02842941f, 0.08494775f, -0.08817707f, -0.10506966f, -0.03743252f, 
    0.00144420f, -0.06393942f, -0.10422002f, -0.06782386f, -0.09435332f, -0.01336134f, 0.04186980f, -0.08480339f, 
    0.03109854f, -0.08716083f, 0.05194001f, 0.06845372f, -0.02357282f, -0.00395257f, -0.09049017f, -0.09267890f, 
    0.01034743f, -0.06526735f, -0.07764367f, -0.00956518f, -0.07484324f, 0.00671478f, -0.06958755f, 0.00106756f, 
    -0.05045318f, 0.03123233f, -0.08205327f, -0.02489918f, 0.04088306f, -0.02620017f, -0.06707014f, -0.03435967f, 
    0.20427282f, -0.46287259f, 0.03608758f, -0.19115391f, -0.21332113f, -0.17054385f, -0.07861596f, 0.00486469f, 
    0.02264934f, 0.06614056f, -0.12192667f, -0.05710480f, -0.02379452f, -0.15149227f, -0.13163400f, 0.17497471f, 
    -0.06337824f, 0.09652381f, 0.17832920f, -0.13784924f, -0.32184115f, 0.31781209f, -0.00483937f, 0.01614737f, 
    -0.03147735f, 0.11745104f, 0.08305115f, -0.05022584f, -0.28461766f, 0.03333586f, 0.04298572f, 0.39209688f, 
    0.08962159f, -0.04364203f, -0.21644108f, -0.04414975f, -0.00608837f, -0.09892989f, 0.03732134f, -0.17168006f, 
    0.14511396f, -0.13195409f, 0.41783178f, -0.16989116f, 0.15256967f, 0.19939934f, -0.02890164f, 0.01127109f, 
    -0.02221643f, 0.19720775f, -0.01636092f, 0.20776878f, 0.18303037f, -0.02376840f, 0.18443200f, -0.07334127f, 
    0.08236176f, 0.14614184f, -0.09272598f, -0.01840545f, -0.16661458f, 0.04372353f, 0.07107856f, -0.02668595f, 
    0.17075185f, 0.31843999f, -0.20624609f, -0.16457148f, 0.62906754f, 0.01740940f, 0.15150031f, -0.02060691f, 
    0.09408344f, -0.07572717f, 0.05642127f, 0.34892684f, -0.06786565f, -0.53908163f, -0.07922781f, 0.06674078f, 
    0.10009272f, -0.30710593f, -0.05843352f, 0.08663046f, -0.26765996f, 0.04525936f, 0.13722946f, -0.06474304f, 
    -0.14397748f, -0.08991469f, 0.04365511f, -0.00552338f, 0.02248351f, 0.28711459f, -0.26718268f, -0.24548876f, 
    0.05648234f, -0.03479629f, 0.20719300f, 0.19573694f, 0.16757695f, 0.22001667f, 0.15564547f, 0.24865699f, 
    -0.08762503f, 0.33671239f, -0.05306392f, 0.07571934f, -0.07915658f, 0.25420150f, -0.01681005f, -0.03837149f, 
    -0.27033347f, 0.01815161f, -0.16608395f, 0.02103597f, -0.02558151f, -0.01153787f, 0.37410289f, 0.08779527f, 
    -0.07650963f, -0.14769031f, -0.59051013f, 0.35030338f, 0.18824396f, 0.25387800f, -0.08277581f, 0.11576668f, 
    0.02559613f, 0.33981845f, 0.09541770f, -0.14367026f, 0.05040303f, -0.32913038f, -0.19343813f, -0.06977431f, 
    -0.35937488f, 0.24275556f, 0.22553079f, 0.14120580f, 0.21433999f, 0.17132577f, 0.10958727f, 0.31840393f, 
    0.20615070f, -0.17518392f, 0.02991947f, -0.58664209f, 0.07744911f, -0.08409111f, 0.04991953f, 0.07763485f, 
    0.04581698f, -0.07373943f, 0.00940198f, 0.15510936f, -0.42843461f, -0.00963819f, 0.11214244f, -0.00953895f, 
    0.36613566f, -0.04563132f, -0.17042315f, 0.07808287f, 0.07167922f, -0.20693250f, 0.05043766f, -0.13234118f, 
    -0.14745189f, -0.08841290f, -0.19430713f, -0.08408581f, -0.11947205f, -0.01905981f, 0.00907805f, -0.16129653f, 
    0.12532946f, -0.35585853f, 0.21966989f, 0.09802168f, 0.14674215f, 0.23418291f, -0.16422909f, 0.06727467f, 
    0.06748863f, 0.09473342f, 0.22864339f, -0.21315248f, 0.30981490f, 0.21701495f, -0.16010074f, -0.03805681f, 
    -0.00476457f, -0.46200281f, 0.13674508f, 0.02092545f, -0.18710251f, -0.29916859f, -0.06263565f, 0.04808731f, 
    -0.12571242f, 0.05364382f, 0.14007080f, -0.07790965f, -0.09379894f, -0.07767677f, 0.32696760f, 0.20894997f, 
    0.10739058f, -0.07213565f, -0.16525243f, -0.03579567f, 0.04298588f, 0.03445581f, 0.24515589f, 0.01684992f, 
    0.08441689f, 0.01673946f, 0.12342599f, -0.03287584f, -0.04919453f, 0.17907870f, 0.17803816f, 0.14756180f, 
    -0.03441911f, 0.01254055f, 0.02204384f, -0.00527602f, -0.06347021f, 0.00997762f, -0.06266766f, 0.23161367f, 
    0.09728721f, -0.05858877f, 0.09344442f, 0.04925848f, -0.12914529f, 0.02014234f, 0.04492800f, -0.00025921f, 
    0.01580466f, -0.02777312f, 0.30079800f, -0.19761056f, -0.02105142f, 0.17439257f, -0.04631465f, 0.04339749f, 
    -0.25594652f, 0.11450329f, 0.20030351f, 0.03198784f, -0.04174210f, 0.15720613f, 0.14791635f, 0.03533411f, 
    0.03823178f, -0.02684713f, 0.04333263f, -0.08570579f, -0.04043038f, -0.02531979f, 0.02681215f, 0.05073131f, 
    -0.03910746f, -0.00958304f, -0.08880138f, 0.06272998f, 0.00118098f, -0.02476759f, -0.02933775f, -0.06996996f, 
    -0.08020183f, -0.04322942f, 0.06037222f, -0.04172466f, -0.08608622f, -0.00985869f, -0.10360614f, -0.05670570f, 
    -0.09301531f, -0.05503142f, 0.00542152f, -0.04794169f, 0.07918333f, 0.02167279f, 0.02201323f, -0.06721599f, 
    -0.06802777f, -0.09583933f, 0.03306262f, -0.01056695f, -0.03590464f, -0.08094730f, -0.07762591f, -0.11040741f, 
    0.03089013f, 0.02841005f, 0.04104890f, -0.15816030f, -0.09088067f, 0.01342434f, -0.05908408f, -0.03701679f, 
    -0.05574286f, -0.00923926f, -0.03629694f, -0.05356327f, -0.07423587f, 0.04697535f, 0.06131484f, -0.01023439f, 
    -0.05688762f, 0.01948578f, 0.02529178f, -0.06291691f, 0.05776507f, -0.03816221f, -0.02617627f, -0.08672491f, 
    -0.03074836f, -0.03346900f, 0.04377123f, -0.09411178f, 0.06735042f, 0.05427454f, 0.05280567f, 0.02704386f, 
    -0.10107391f, 0.05757749f, 0.00821738f, 0.04984355f, -0.08527079f, 0.05955479f, 0.03293431f, -0.05704553f, 
    -0.08548360f, 0.05996327f, -0.00569667f, -0.07306154f, -0.02013741f, -0.08589721f, -0.00795799f, -0.01645961f, 
    0.01897679f, -0.04306091f, -0.09625962f, 0.07901298f, -0.08289682f, 0.07913727f, -0.06078800f, 0.06454223f, 
    -0.00446661f, 0.00612139f, 0.06950026f, -0.08265723f, 0.00550913f, -0.03171892f, -0.02847658f, 0.07557590f, 
    -0.03256988f, -0.05112780f, 0.06216571f, -0.00997836f, -0.08263051f, -0.06570508f, 0.06532747f, -0.00676486f, 
    -0.00053245f, 0.01492831f, 0.05853901f, -0.05347343f, -0.03472256f, 0.01587642f, -0.01912206f, 0.03484746f, 
    -0.03371120f, -0.06039446f, -0.07854179f, -0.00340089f, -0.07520293f, 0.04176102f, -0.03209738f, 0.05910958f, 
    0.05978146f, 0.01540870f, 0.00732330f, -0.00174986f, 0.06453136f, 0.04198583f, 0.05051951f, -0.03294398f, 
    0.07975298f, 0.04276643f, -0.07056245f, 0.01322557f, -0.09238457f, -0.04282666f, -0.08745341f, -0.08826125f, 
    -0.02346704f, -0.00148509f, -0.05819724f, 0.00950150f, 0.03796396f, -0.02970337f, -0.08764251f, -0.08265282f, 
    0.00314081f, 0.01982793f, -0.00931958f, -0.01887961f, 0.00966548f, 0.06444860f, -0.00986115f, 0.04540723f, 
    0.05689960f, 0.02400176f, -0.07191262f, 0.05315287f, -0.04273728f, -0.07666485f, 0.07721575f, -0.06010947f, 
    -0.02946245f, 0.03821226f, -0.07713403f, -0.03188204f, 0.04006167f, 0.00771233f, 0.00284822f, -0.06674436f, 
    0.05497054f, 0.02456848f, -0.09995294f, -0.00161781f, 0.05073778f, 0.01655944f, 0.03722705f, 0.02826154f, 
    0.04636661f, 0.03310164f, -0.05068865f, 0.02624526f, 0.00967455f, 0.01272591f, 0.02644108f, -0.02584587f, 
    -0.00258214f, -0.12322006f, -0.04726359f, -0.05148381f, -0.00297693f, -0.02053310f, -0.08355936f, 0.04373632f, 
    0.00635272f, 0.06973428f, 0.06470978f, -0.00048429f, 0.01561372f, 0.04805118f, 0.00242189f, -0.01420220f, 
    -0.06160397f, 0.00085017f, -0.03221454f, 0.02070920f, -0.04049060f, -0.04478040f, -0.06577601f, 0.03612156f, 
    -0.03926904f, 0.00732441f, -0.09111435f, -0.02499138f, 0.05410997f, -0.01033133f, 0.00014374f, 0.04556972f, 
    -0.04704198f, 0.08003668f, -0.00184844f, -0.10080037f, -0.06992303f, 0.04116677f, 0.00116289f, 0.04011654f, 
    0.01054291f, 0.05590614f, -0.00480698f, -0.00403203f, -0.02057672f, 0.01121770f, -0.04871935f, -0.07935875f, 
    -0.05336077f, -0.06607918f, -0.10739950f, -0.05988185f, -0.03638731f, -0.05712136f, -0.08921176f, 0.01378165f, 
    -0.03223382f, 0.03608799f, -0.08366731f, 0.01056973f, -0.05783584f, -0.04941494f, -0.10773768f, -0.05594261f, 
    -0.09525810f, -0.04184198f, 0.01528461f, 0.02440121f, -0.10340940f, -0.02907508f, -0.05103953f, -0.04669221f, 
    -0.06940190f, -0.01072978f, 0.04260338f, -0.09963796f, 0.01341473f, -0.01651214f, 0.00670093f, 0.00670798f, 
    -0.06285226f, -0.04126857f, -0.02295165f, 0.06587151f, 0.00460210f, -0.07677355f, -0.04382003f, -0.04409694f, 
    -0.03605365f, 0.06689951f, 0.00427805f, -0.01925060f, -0.00061992f, -0.01675178f, 0.01049514f, 0.00674606f, 
    -0.06657684f, 0.00852516f, 0.01564010f, -0.00546551f, -0.07913297f, 0.07679905f, -0.01325877f, -0.02288107f, 
    -0.02852355f, -0.08062812f, 0.02987445f, 0.07955416f, 0.06055453f, -0.01573539f, 0.06811114f, -0.00443009f, 
    0.06261297f, -0.03470084f, -0.05564180f, -0.01545380f, -0.09792739f, -0.09331003f, 0.00753589f, -0.08923092f, 
    -0.05082502f, 0.07270928f, 0.05788177f, 0.06516015f, -0.01394338f, 0.00527991f, -0.03173507f, 0.07032726f, 
    0.00530825f, -0.03590230f, 0.04136225f, -0.08622098f, -0.01862330f, -0.03490458f, -0.08029801f, 0.04629224f, 
    -0.05820573f, -0.04402949f, 0.04307969f, -0.00202718f, 0.02582091f, 0.02342610f, -0.08791628f, -0.01824709f, 
    -0.02773768f, 0.02460943f, 0.04797222f, -0.05260433f, 0.03724451f, -0.00877929f, 0.04019279f, 0.05434067f, 
    0.00849269f, 0.03809271f, -0.02064258f, 0.05741504f, -0.08725682f, 0.07057433f, -0.03565832f, 0.05662616f, 
    0.04725533f, 0.02034730f, -0.04499416f, -0.02542217f, -0.00715852f, -0.04295488f, 0.00425215f, 0.06334805f, 
    -0.03153785f, -0.03869671f, 0.00219095f, 0.08381086f, -0.05157701f, -0.08156389f, -0.02238112f, -0.06254645f, 
    -0.00982244f, 0.09180939f, -0.00820872f, -0.02279506f, -0.01617672f, -0.07607898f, -0.06116116f, -0.10660493f, 
    -0.01198529f, 0.03428577f, -0.05752230f, 0.06799888f, 0.04413640f, -0.03294486f, -0.02563661f, 0.00198284f, 
    0.21777610f, 0.31109747f, 0.17225817f, 0.15958126f, 0.10240102f, 0.01681572f, -0.31706309f, -0.09942926f, 
    0.02153159f, 0.14956687f, 0.35072619f, 0.11731119f, 0.04966632f, 0.22539468f, 0.07980959f, 0.22012936f, 
    -0.05569761f, -0.07192797f, 0.14728901f, -0.08781613f, -0.09526452f, -0.03788102f, -0.09246570f, 0.08250007f, 
    0.07913144f, -0.30542612f, -0.18490644f, -0.01187336f, -0.37604982f, -0.10049832f, -0.01205415f, 0.00312154f, 
    0.21949777f, 0.00480560f, -0.10865282f, 0.06193816f, 0.13469733f, 0.16923703f, -0.00716053f, -0.19353771f, 
    -0.15238449f, -0.34387550f, -0.16090743f, -0.10967321f, -0.15040968f, 0.05490739f, 0.10787295f, -0.01555198f, 
    0.06456290f, -0.02928774f, 0.20145243f, -0.01968143f, 0.02960538f, 0.16374592f, 0.03668490f, -0.05379802f, 
    0.08259418f, 0.19747901f, 0.14057188f, -0.01985383f, 0.69723052f, 0.44949913f, -0.12952980f, 0.02364874f, 
    -0.12854572f, -0.15922488f, 0.25473216f, -0.05633818f, -0.46680152f, -0.32474396f, -0.02069960f, 0.04170350f, 
    0.07424427f, 0.06958070f, 0.02058490f, -0.21826218f, 0.05567438f, 0.04403412f, 0.38461819f, -0.00254525f, 
    -0.21491925f, 0.05899567f, 0.06846026f, 0.07022355f, -0.00548229f, 0.23627417f, 0.20253521f, 0.19508548f, 
    0.13932717f, -0.50023794f, 0.10275535f, 0.04760443f, -0.03820470f, 0.14041975f, 0.03859490f, 0.30092096f, 
    -0.05523952f, 0.07082206f, -0.06834672f, -0.04996996f, -0.03623413f, 0.00672023f, 0.09063924f, 0.23444223f, 
    0.18197209f, -0.24018918f, 0.07496787f, -0.06809823f, -0.10657986f, -0.02149423f, -0.00641662f, 0.17809118f, 
    0.53296107f, -0.03333945f, 0.17836282f, -0.05577345f, 0.00110627f, 0.04174969f, 0.05430412f, 0.07629533f, 
    -0.05512188f, 0.47168121f, -0.19649643f, 0.31034082f, -0.15561707f, 0.04321401f, -0.28165120f, 0.03116295f, 
    0.13697720f, 0.01269517f, -0.34659129f, 0.23661940f, -0.02776643f, 0.08376359f, -0.37527835f, -0.22777887f, 
    -0.00764984f, 0.02238967f, 0.23726130f, 0.14144708f, 0.07325260f, 0.03141762f, -0.03080718f, 0.00042824f, 
    0.02692853f, -0.35287988f, 0.28148854f, 0.07683311f, -0.00409782f, -0.19869775f, 0.02033680f, -0.04972064f, 
    0.07003798f, 0.03489432f, -0.37525430f, -0.16034468f, -0.26357645f, -0.05365371f, 0.20970875f, 0.13536921f, 
    0.18844889f, 0.12292706f, 0.07553718f, -0.03806892f, 0.13892366f, 0.37626085f, 0.10536571f, -0.23789790f, 
    0.02870033f, -0.06799111f, -0.05185363f, -0.35697433f, -0.23600633f, 0.08061790f, 0.49232045f, -0.13049884f, 
    0.04793489f, 0.24545564f, 0.12826496f, 0.04792127f, 0.04695241f, 0.04055031f, -0.14479138f, -0.00517538f, 
    0.08785049f, 0.17117104f, 0.25999647f, 0.24957968f, 0.31226438f, 0.00524261f, -0.09859038f, 0.09112260f, 
    -0.08560390f, -0.06989440f, 0.17062438f, -0.15030174f, -0.55258554f, -0.18126264f, -0.13808808f, 0.07751903f, 
    0.01000554f, -0.07604652f, 0.10043087f, -0.15819632f, -0.06405723f, -0.01510466f, 0.27439940f, -0.04838885f, 
    0.00463569f, -0.01431185f, -0.00759826f, 0.15480444f, -0.11252589f, 0.16709924f, 0.00078749f, 0.00219903f, 
    0.03051413f, -0.20865858f, 0.04278006f, -0.04810519f, 0.07703187f, 0.02886668f, 0.10158730f, 0.28973442f, 
    0.10619839f, -0.07853594f, -0.12485071f, -0.00667720f, -0.12406827f, -0.01620322f, 0.19258058f, 0.04209728f, 
    -0.03807136f, -0.18816912f, 0.05683808f, 0.08400743f, -0.00311014f, 0.04304219f, 0.08359261f, 0.29772732f, 
    0.40570047f, 0.02874565f, 0.07811360f, 0.08485691f, -0.06090142f, 0.12441846f, 0.01540137f, 0.07512078f, 
    0.08889020f, 0.35590595f, 0.05116229f, 0.09129426f, 0.17322628f, 0.10159244f, -0.09916615f, -0.08168436f, 
    -0.04561973f, -0.39150688f, -0.25872439f, 0.09337386f, -0.28709689f, 0.00121498f, -0.03359203f, 0.09643708f, 
    0.37614405f, 0.20951770f, -0.03725384f, 0.27376425f, -0.39738569f, -0.22579806f, -0.33423775f, 0.09796956f, 
    -0.23159337f, -0.16501561f, 0.31470543f, 0.49916533f, 0.45341638f, 0.20823614f, -0.42719689f, 0.03039020f, 
    0.03581413f, 0.19607711f, 0.17536952f, -0.41961834f, 0.29936978f, -0.09181819f, 0.46919301f, -0.47924784f, 
    -0.24722669f, 0.01723052f, 0.08736073f, 0.01883591f, 0.02700978f, 0.09207352f, 0.04257856f, -0.13595811f, 
    -0.13907722f, 0.09461052f, 0.08671516f, -0.33114815f, -0.06678306f, 0.30814686f, 0.50497890f, -0.31916618f, 
    0.11917165f, 0.27916437f, -0.10962622f, 0.21197425f, 0.00138325f, -0.04980963f, -0.04383326f, -0.09364041f, 
    0.01801790f, -0.34133643f, 0.39762023f, 0.32298222f, -0.42186013f, -0.19579729f, 0.03666306f, 0.12828623f, 
    0.27769485f, 0.47203210f, -0.07316888f, -0.15281484f, 0.19868959f, 0.38946608f, -0.07758606f, 0.02254137f, 
    -0.34989932f, -0.04319815f, -0.15178314f, -0.14810766f, 0.22434869f, -0.56630719f, -0.09705213f, 0.09316543f, 
    0.21469173f, -0.08401544f, -0.11669482f, 0.15082385f, -0.13343336f, 0.10609082f, -0.00040854f, 0.02959044f, 
    0.14514887f, -0.30040035f, 0.18328692f, -0.06494511f, 0.01386735f, -0.05394180f, -0.45855954f, -0.12197174f, 
    0.24873778f, 0.06112925f, -0.05275753f, 0.07383656f, -0.32477972f, 0.01690408f, -0.06217614f, 0.07504653f, 
    -0.41210324f, 0.11434574f, -0.17378487f, 0.06181257f, 0.09026553f, 0.42503768f, -0.12050152f, 0.07695191f, 
    0.26284209f, -0.01956579f, 0.06745162f, 0.28070298f, 0.08900342f, 0.28879973f, 0.22649394f, 0.42945832f, 
    -0.05040759f, -0.08183577f, 0.52460349f, -0.08628969f, 0.37100652f, 0.19196451f, -0.27653363f, -0.31425878f, 
    -0.10781989f, 0.17625512f, 0.27562222f, -0.08363894f, 0.09193610f, -0.58757710f, -0.15719832f, 0.09321932f, 
    -0.15594380f, 0.27658188f, -0.26064870f, -0.23046066f, -0.05940569f, 0.00658292f, 0.03462140f, 0.22008751f, 
    -0.39087367f, -0.07256160f, -0.09421333f, -0.62441647f, 0.42728826f, -0.18204805f, -0.14170225f, 0.08254549f, 
    0.15153693f, -0.10469380f, 0.11399198f, -0.16029580f, 0.30925700f, -0.01811261f, 0.00420231f, 0.11729559f, 
    -0.14162365f, -0.50445998f, -0.11271656f, 0.03051349f, -0.12778634f, 0.03354966f, -0.02002941f, 0.25104663f, 
    -0.19318961f, 0.08440550f, -0.08731087f, -0.07016689f, -0.01560532f, 0.21713471f, -0.23188846f, -0.01512874f, 
    0.21451417f, 0.07663739f, -0.02429973f, 0.16448875f, 0.07565112f, -0.10518457f, 0.14470300f, 0.02239711f, 
    -0.01382398f, 0.24493700f, 0.27846798f, -0.33254808f, -0.24370801f, 0.04374982f, 0.16137195f, 0.03103018f, 
    0.17753966f, -0.19514796f, 0.15832016f, 0.24143539f, 0.28558213f, 0.45274252f, 0.13413996f, 0.01139295f, 
    0.31053099f, -0.02123401f, -0.29445437f, 0.07927503f, 0.32483146f, -0.22718269f, -0.26780498f, -0.00434851f, 
    0.18171267f, -0.23111770f, 0.21485882f, -0.10679153f, 0.09631430f, -0.09975175f, -0.04587023f, -0.44631186f, 
    -0.09816267f, -0.23911022f, 0.26022393f, -0.06552786f, 0.06841079f, 0.04552956f, -0.07472735f, -0.33805650f, 
    0.22150560f, 0.03525342f, -0.02013290f, -0.02433910f, -0.04492237f, 0.12957583f, -0.53873295f, 0.20155369f, 
    0.12925684f, 0.09381766f, 0.00188572f, -0.04577237f, 0.05326299f, 0.20008342f, 0.10012203f, -0.41152444f, 
    -0.26974526f, -0.03542522f, -0.09131155f, -0.01571102f, 0.00882067f, 0.04602573f, -0.12421358f, 0.11982027f, 
    0.39333901f, -0.01508734f, -0.23365901f, 0.03069730f, 0.03972581f, -0.03406366f, -0.10132943f, -0.04194480f, 
    -0.00555524f, -0.09516203f, 0.05559397f, -0.03475963f, -0.02984483f, -0.11269539f, 0.04560376f, 0.04008807f, 
    0.02635214f, -0.10720260f, 0.00604842f, -0.08429807f, 0.03366645f, -0.05144584f, -0.08668051f, -0.01802589f, 
    -0.08526230f, -0.06900506f, -0.03663364f, 0.05022571f, -0.08609282f, 0.02529978f, 0.02975071f, -0.00729402f, 
    0.03723779f, -0.07004973f, -0.02680142f, -0.05312111f, 0.03390197f, -0.08259980f, 0.00159925f, -0.09041151f, 
    0.06609507f, 0.05292162f, -0.02302179f, -0.03052814f, 0.01960894f, -0.01193403f, -0.06134762f, -0.02055472f, 
    0.00926358f, -0.06815123f, 0.04425709f, 0.07593469f, 0.05292665f, -0.02598017f, 0.02699245f, -0.07052738f, 
    0.02008415f, -0.02726324f, -0.02508597f, 0.01067454f, -0.09463939f, 0.04964372f, -0.11051098f, -0.08843105f, 
    0.03634884f, 0.06003504f, -0.02007611f, 0.01513645f, -0.02456663f, -0.01128961f, 0.05378051f, -0.09905764f, 
    -0.08146742f, -0.06790587f, -0.10481064f, 0.02113691f, 0.07593071f, -0.02123577f, 0.04008097f, -0.00660004f, 
    -0.07289838f, 0.07684191f, -0.06329019f, -0.06837264f, -0.00534899f, -0.10583847f, 0.03715556f, -0.02575372f, 
    -0.00230581f, 0.04659713f, 0.06380251f, 0.05924945f, 0.04264284f, -0.02655740f, -0.00273345f, -0.04818037f, 
    -0.07066417f, 0.00056902f, -0.06769652f, -0.02022912f, 0.03511921f, -0.02392424f, -0.05237692f, 0.06555991f, 
    -0.00811005f, -0.04341296f, -0.10066546f, -0.06560592f, 0.00025809f, -0.11048243f, -0.04561953f, -0.05017022f, 
    -0.02047380f, 0.04622069f, -0.07373694f, 0.03222261f, 0.04577580f, -0.03217637f, 0.02616608f, -0.02767850f, 
    0.08211820f, -0.04948207f, 0.05773099f, 0.05946608f, 0.02084950f, -0.09399780f, -0.00404130f, -0.06385066f, 
    0.03149932f, -0.04758373f, -0.07684734f, 0.05108248f, -0.01151663f, -0.04916042f, 0.04334803f, -0.05918013f, 
    -0.06709193f, 0.24722476f, 0.33813179f, -0.30794534f, 0.16244571f, 0.04339091f, 0.19116406f, 0.14567623f, 
    -0.24488787f, 0.24545451f, -0.07237975f, -0.01536816f, 0.10038428f, 0.13802218f, 0.13270938f, 0.17070428f, 
    0.15219645f, 0.18279637f, -0.17536414f, -0.43190706f, 0.11865358f, 0.25626490f, 0.13099422f, -0.00717439f, 
    -0.22405748f, -0.07457569f, 0.29212293f, 0.17450050f, 0.18879916f, -0.09235328f, -0.06831584f, 0.16997644f, 
    0.09663010f, -0.09629267f, -0.14994062f, -0.07897188f, 0.08068868f, -0.32052577f, -0.09892849f, -0.44567063f, 
    0.06291369f, -0.64923817f, -0.03621377f, 0.03525364f, 0.32200822f, -0.14537567f, -0.28140613f, -0.02354748f, 
    0.01965094f, -0.38146833f, 0.10545415f, 0.05681221f, 0.02425232f, 0.08007741f, -0.01047276f, 0.14046507f, 
    0.06902546f, 0.13251923f, -0.21816188f, -0.20965551f, 0.38444126f, 0.15838209f, -0.08943412f, -0.07076541f, 
    0.14966397f, -0.31789273f, 0.00824249f, 0.07170856f, 0.23626012f, -0.43667847f, 0.10242780f, 0.03287393f, 
    0.35548422f, -0.08621488f, 0.19040386f, 0.15499954f, -0.12698050f, -0.35661924f, 0.16905962f, 0.13702361f, 
    0.17390269f, -0.08232918f, -0.16497311f, -0.13527057f, 0.07517415f, 0.05051729f, 0.30230778f, 0.09950699f, 
    0.12124426f, 0.01758900f, 0.14529844f, 0.07688727f, 0.08105539f, 0.30466452f, 0.08215424f, -0.12921867f, 
    -0.18622856f, 0.03339123f, 0.28171450f, 0.11993542f, 0.19166441f, -0.08425944f, 0.10736597f, -0.02196509f, 
    0.19214216f, -0.06758886f, 0.21980132f, 0.07968476f, 0.10154826f, -0.07749207f, -0.14031927f, -0.06480457f, 
    0.05093539f, -0.06320667f, 0.08487246f, -0.06764574f, 0.08812568f, 0.02054561f, 0.17204091f, -0.01616448f, 
    0.15704104f, 0.06649378f, -0.12132286f, 0.03160135f, -0.16172522f, -0.05695421f, 0.21770175f, 0.25965592f, 
    -0.00983021f, 0.34429213f, 0.27032062f, 0.01532237f, 0.38502392f, 0.27329698f, 0.29718605f, 0.12029585f, 
    0.54843128f, 0.30018380f, 0.56792158f, 0.26783627f, 0.12361812f, 0.07841440f, -0.23741505f, 0.07821267f, 
    0.15707202f, -0.37429348f, -0.17582133f, 0.24316648f, 0.18509366f, 0.00362493f, 0.10115733f, 0.08286804f, 
    -0.17481348f, -0.15221789f, -0.12748080f, 0.30206552f, 0.04393410f, -0.20467013f, -0.24983543f, -0.78525376f, 
    -0.17931148f, -0.05407953f, -0.11199182f, -0.05631058f, 0.10737314f, 0.02490724f, -0.02109817f, -0.00846445f, 
    -0.28969711f, -0.40025270f, -0.25585279f, -0.00408968f, -0.14376979f, 0.28121319f, 0.16560730f, 0.13971803f, 
    0.01971673f, -0.48866814f, 0.23164365f, 0.21115334f, -0.12646604f, 0.11668620f, -0.08801991f, 0.23288304f, 
    -0.04033026f, -0.13068447f, -0.38050678f, 0.20649216f, 0.09606265f, 0.25711274f, -0.06119082f, -0.08390807f, 
    -0.16461363f, -0.37393808f, -0.02730224f, 0.18561319f, -0.12615609f, -0.43558154f, 0.64914942f, -0.05070059f, 
    -0.38212267f, -0.05150430f, -0.18765616f, -0.33306107f, 0.25390467f, 0.25399727f, 0.24788953f, -0.06781299f, 
    -0.07330336f, 0.08624683f, -0.01856133f, 0.01871576f, -0.04094179f, 0.19257015f, -0.00358899f, 0.12374828f, 
    0.11312971f, 0.07896449f, 0.22306350f, 0.01032898f, 0.00887430f, -0.04280788f, 0.28421128f, 0.10211514f, 
    -0.04358568f, 0.02159554f, 0.27607340f, 0.08530524f, -0.04221155f, -0.17842513f, 0.10354440f, -0.10472623f, 
    -0.02466024f, -0.13721533f, 0.17290837f, -0.00885847f, -0.20668598f, 0.05360216f, 0.00750139f, -0.10276052f, 
    0.31515843f, -0.01068482f, -0.17089613f, 0.16417375f, 0.04167160f, 0.27091491f, -0.22279811f, -0.06767873f, 
    -0.32542595f, 0.15460935f, -0.09627540f, -0.27491429f, -0.09714290f, -0.27548110f, -0.41488934f, 0.13858455f, 
    0.09070087f, 0.16569301f, 0.33188817f, -0.09231833f, 0.01680629f, -0.09120139f, 0.02312619f, -0.00193770f, 
    -0.53117645f, 0.03578018f, -0.22992189f, -0.04266011f, 0.02942518f, 0.10724666f, 0.14234442f, 0.02673410f, 
    0.11923934f, 0.16205356f, -0.08136599f, -0.54029769f, 0.21458915f, 0.03059697f, 0.03310580f, -0.08518028f, 
    0.03940919f, 0.00191277f, 0.07977913f, 0.10723796f, 0.33916453f, 0.09692410f, 0.09973297f, 0.29601586f, 
    -0.06404981f, -0.00407182f, 0.06066286f, -0.00893760f, 0.11740895f, -0.12845454f, -0.01175077f, -0.02765664f, 
    0.11098433f, -0.63976026f, -0.06677101f, 0.03392595f, 0.24656576f, -0.05088996f, -0.40147662f, 0.19945212f, 
    0.04741750f, -0.01794422f, 0.00475168f, -0.11295145f, -0.03715249f, 0.10726538f, 0.22521770f, 0.06089889f, 
    0.08626675f, 0.27119735f, -0.38184568f, -0.21421410f, 0.28235850f, 0.22184364f, -0.07402148f, -0.01478126f, 
    0.15971816f, -0.12083863f, 0.08098198f, 0.03375006f, 0.02677136f, -0.16388382f, -0.26951206f, 0.00866656f, 
    0.36903784f, -0.03886240f, -0.06082428f, 0.27947438f, -0.00689741f, -0.03927380f, 0.08148331f, 0.12589423f, 
    0.05663150f, -0.02039523f, -0.10022666f, -0.04956065f, 0.13192599f, 0.00374756f, 0.15643723f, 0.06657508f, 
    0.05090710f, -0.17662831f, 0.06289873f, -0.06809599f, 0.03393736f, 0.13456282f, 0.01313007f, 0.15849912f, 
    -0.06194768f, -0.08287387f, -0.10169736f, -0.02026092f, 0.04450854f, -0.04476633f, -0.01711896f, 0.07922585f, 
    0.23475920f, -0.15330751f, 0.04914522f, -0.01760399f, 0.29634774f, -0.11043309f, 0.01686031f, 0.09141738f, 
    0.03520028f, -0.04758307f, 0.10404518f, -0.07944863f, 0.00143091f, -0.01407965f, 0.12168051f, -0.11206847f, 
    0.40222052f, 0.08409606f, -0.47917998f, -0.16023450f, -0.12664811f, -0.02059327f, -0.00753189f, 0.10310357f, 
    0.01060912f, 0.03002777f, -0.28952700f, 0.39857054f, 0.00621890f, 0.10328305f, -0.25125936f, 0.16814251f, 
    0.30865961f, -0.14567922f, 0.22496554f, 0.08894172f, -0.01617580f, 0.09137044f, 0.17366728f, -0.02876791f, 
    0.00746548f, -0.04805927f, 0.02287810f, 0.61316842f, -0.26549605f, 0.23045930f, -0.04764496f, 0.04504019f, 
    0.07505555f, 0.24994408f, -0.21836588f, -0.10321746f, -0.40474430f, 0.07298808f, -0.06672420f, -0.29530960f, 
    0.05142485f, 0.37133560f, 0.07878027f, 0.04848287f, 0.16063799f, -0.04520465f, -0.06681389f, 0.06758183f, 
    0.21376468f, 0.24771088f, 0.18481708f, 0.01080920f, -0.12861648f, -0.12494944f, 0.41414908f, -0.08907831f, 
    -0.02469677f, 0.19903307f, 0.12577321f, 0.07426206f, -0.03913634f, 0.18742190f, -0.72254044f, -0.01174028f, 
    0.07627686f, 0.00165942f, -0.11678991f, 0.44396162f, -0.11379139f, -0.09069743f, -0.07757237f, 0.24819720f, 
    0.09790421f, 0.38074002f, 0.06054178f, -0.22128887f, -0.08202882f, -0.05414686f, 0.15022425f, 0.02692809f, 
    -0.49348146f, 0.05575596f, 0.10274529f, -0.15683708f, 0.24749388f, 0.05830768f, 0.17106795f, -0.44053611f, 
    -0.03797557f, -0.09375640f, -0.12033825f, 0.31405133f, 0.13380231f, 0.17655168f, -0.19459945f, -0.05471805f, 
    0.01127353f, 0.62562329f, 0.03273149f, 0.06453378f, 0.01964370f, 0.11595757f, 0.13375305f, 0.08128269f, 
    0.14676580f, 0.07403035f, -0.00228994f, 0.06186053f, 0.12755398f, 0.25541130f, 0.27066103f, -0.14957857f, 
    -0.04619176f, 0.37595776f, -0.15126556f, -0.06512833f, 0.12706184f, 0.20692347f, 0.10515715f, 0.04818765f, 
    -0.10946811f, 0.05174029f, -0.26925355f, 0.16959010f, -0.03591482f, -0.14592363f, 0.03077779f, 0.34215370f, 
    -0.60522974f, 0.11493100f, 0.04173187f, 0.12930663f, 0.17240518f, 0.07040400f, -0.14507836f, -0.08230764f, 
    0.07261344f, -0.04208021f, -0.07399534f, -0.02238606f, -0.06945125f, -0.10641851f, -0.05278728f, -0.09139692f, 
    0.00138642f, 0.01207527f, 0.01132259f, 0.03066015f, -0.10800481f, 0.01527678f, 0.05273007f, -0.03879648f, 
    0.06572410f, 0.03599185f, -0.02416887f, 0.00514814f, 0.06284346f, 0.04790738f, -0.07279116f, 0.00631056f, 
    0.05314247f, 0.05643685f, -0.01805011f, -0.08659318f, -0.00957799f, -0.07925417f, 0.00977995f, 0.02980999f, 
    -0.04021227f, -0.08158060f, -0.06785387f, -0.05083805f, -0.01498697f, 0.06365634f, -0.02921616f, 0.06535698f, 
    0.04376096f, -0.04611650f, -0.07937244f, 0.07602246f, 0.00270543f, 0.00630909f, -0.02511837f, 0.01969324f, 
    -0.00667389f, -0.04348165f, 0.01027566f, 0.02566091f, -0.00867581f, -0.03309868f, -0.02376381f, -0.03895002f, 
    0.03846095f, -0.07458325f, -0.06948831f, 0.01197908f, 0.02978580f, -0.00198969f, -0.02303081f, -0.01240769f, 
    -0.03838763f, -0.07274684f, 0.07148287f, 0.04146664f, 0.03461895f, 0.00300064f, 0.07718177f, -0.06854889f, 
    -0.08794911f, -0.01118793f, -0.08136696f, -0.06043737f, -0.00622934f, -0.03054864f, 0.06377019f, -0.08015892f, 
    0.05089308f, 0.02023484f, -0.06455606f, -0.07827387f, -0.07440733f, -0.07899743f, -0.00733726f, -0.03034222f, 
    -0.05041301f, -0.03357537f, 0.04365806f, -0.02824216f, 0.00294746f, -0.03622133f, 0.05538195f, 0.02704253f, 
    -0.02323451f, -0.06793359f, -0.00121728f, -0.03240997f, -0.04302357f, 0.01718233f, -0.04338834f, -0.06525548f, 
    0.06114498f, 0.04996800f, -0.08266277f, 0.05007803f, 0.03338909f, 0.06777580f, 0.03632690f, -0.02058952f, 
    -0.08721366f, 0.07081474f, -0.08216120f, -0.04477572f, -0.07501616f, 0.02426024f, 0.00432893f, -0.00541647f, 
    -0.02498250f, 0.01244840f, -0.04642992f, 0.06391373f, -0.02329662f, -0.03862695f, 0.06661807f, -0.07446147f, 
    0.01961774f, -0.02698987f, -0.00373624f, -0.00937105f, 0.02984950f, -0.04573109f, -0.00383149f, -0.00910249f, 
    0.07462025f, -0.02412614f, -0.05483134f, 0.02298707f, 0.00113014f, -0.06054342f, -0.03596091f, 0.02495709f, 
    -0.01486263f, -0.02305743f, 0.00792298f, 0.00572854f, 0.02886642f, -0.05106114f, -0.10031667f, -0.07165050f, 
    -0.03097847f, -0.01349269f, 0.00201323f, 0.03397818f, -0.06931928f, -0.02937153f, 0.02846561f, -0.01061083f, 
    -0.07902416f, -0.01238715f, 0.01112417f, -0.08799244f, -0.02456570f, 0.06898012f, -0.05955017f, -0.08597228f, 
    -0.05599431f, -0.05331285f, -0.09715689f, 0.07943195f, -0.01542625f, -0.08072817f, -0.08249615f, -0.08659517f, 
    -0.00109670f, -0.03296388f, -0.09919707f, -0.10076709f, -0.06846800f, -0.08092847f, -0.06450765f, -0.03344196f, 
    0.02352063f, 0.01731515f, 0.08495940f, 0.03002892f, -0.07263273f, -0.04828847f, -0.02726769f, -0.11648665f, 
    -0.04058939f, 0.02513910f, -0.12017040f, 0.00642245f, -0.07835178f, -0.07080313f, 0.04304332f, 0.08343887f, 
    -0.01250962f, 0.07344883f, 0.02556874f, -0.05286789f, -0.11327688f, -0.08202156f, -0.00306069f, -0.09297235f, 
    -0.04139682f, 0.04949129f, 0.04781938f, 0.00902350f, -0.04463082f, 0.02279964f, 0.00740293f, 0.00447392f, 
    -0.02321821f, 0.04182791f, -0.08734359f, -0.04660825f, 0.05360447f, 0.00850756f, 0.01919638f, -0.03377324f, 
    -0.11866081f, 0.06349850f, 0.03315793f, -0.05120252f, 0.03923757f, -0.06710245f, 0.01092841f, -0.05702267f, 
    -0.01838070f, -0.03979912f, -0.12276017f, 0.08601133f, -0.04721857f, -0.05850614f, -0.03924866f, 0.01317414f, 
    -0.07661129f, -0.03169823f, 0.00894788f, -0.04780235f, 0.04037086f, 0.00163149f, 0.01652322f, -0.02570072f, 
    0.07498491f, -0.02639990f, -0.10886445f, 0.01678003f, 0.03093424f, 0.03558455f, -0.12046009f, 0.01867074f, 
    0.05284616f, -0.19560914f, -0.06270880f, -0.13755663f, -0.39612728f, -0.30090487f, -0.16026540f, -0.14218435f, 
    -0.16045745f, 0.00475524f, 0.04510227f, 0.03632877f, -0.06780633f, 0.06314909f, -0.19602130f, 0.09519277f, 
    0.02327382f, -0.18253753f, 0.18867488f, 0.32041973f, -0.19247848f, 0.13321553f, -0.00666602f, -0.04418293f, 
    -0.15994832f, 0.17721146f, -0.06943886f, -0.27747700f, -0.21388897f, -0.04801699f, 0.21610348f, 0.34408280f, 
    0.07683073f, 0.04448595f, -0.11428203f, 0.06777573f, 0.01762374f, -0.13582610f, -0.06210393f, -0.47375256f, 
    -0.02044187f, 0.49834299f, 0.09667320f, -0.53485519f, 0.08248310f, 0.31962872f, 0.22132233f, -0.36565858f, 
    -0.03575876f, 0.12597650f, -0.06769194f, 0.13621160f, 0.12403513f, -0.03938570f, -0.43872076f, -0.05759256f, 
    -0.03278064f, -0.15210922f, 0.25751740f, 0.06361838f, -0.49864566f, -0.06870791f, 0.13767874f, 0.07612382f, 
    -0.04690378f, 0.10240122f, 0.05138265f, -0.25618166f, 0.37996343f, -0.20480311f, 0.07076390f, -0.08138392f, 
    0.12682521f, 0.06222551f, 0.07853561f, 0.00245783f, -0.24297017f, -0.29599997f, -0.01196250f, 0.08843898f, 
    0.17262141f, -0.30693930f, -0.08777208f, 0.06753141f, -0.13901992f, 0.04864182f, 0.26345691f, 0.07584565f, 
    0.03592732f, 0.00849301f, 0.03245821f, 0.06035998f, 0.09481201f, 0.17960578f, -0.12889726f, 0.02917932f, 
    0.12599769f, 0.02217033f, 0.10789341f, 0.14882767f, 0.14305979f, 0.12055557f, 0.03644711f, 0.12141944f, 
    -0.28392559f, 0.06967258f, 0.01051460f, -0.01050726f, -0.02277939f, 0.23185672f, 0.03635137f, -0.06046043f, 
    -0.07777888f, -0.02084262f, -0.03381041f, 0.01738003f, -0.02879099f, 0.19544995f, 0.15414909f, 0.03700702f, 
    0.24286851f, -0.24722654f, -0.13305146f, 0.19440295f, 0.20951200f, 0.21596093f, 0.06892269f, 0.16393255f, 
    -0.33345446f, 0.40017503f, 0.24369262f, 0.06129955f, 0.12448420f, -0.07681980f, 0.42143700f, 0.20768476f, 
    -0.33358407f, 0.10036518f, 0.31184524f, 0.21122454f, 0.21890284f, 0.13669541f, -0.02815937f, 0.01360826f, 
    0.06856974f, 0.12821645f, -0.12644807f, -0.30987662f, -0.01148908f, 0.17740680f, -0.35050246f, -0.01760808f, 
    -0.10326513f, 0.15297893f, 0.44922420f, 0.10180111f, 0.27187011f, -0.08994088f, -0.19856745f, -0.39113581f, 
    -0.01926460f, 0.02333839f, -0.05085824f, 0.05653572f, 0.10706870f, -0.63473344f, 0.08751658f, 0.21207179f, 
    0.01235421f, -0.18739788f, -0.09805363f, 0.09770133f, 0.23457047f, -0.08730783f, -0.09000229f, -0.06055059f, 
    0.07671601f, -0.35281062f, 0.24455293f, 0.23001680f, -0.08463201f, 0.17478164f, -0.43582767f, 0.21690024f, 
    -0.07664642f, 0.02450278f, -0.36345056f, 0.21648686f, -0.02915486f, 0.04153204f, 0.08519025f, -0.05569301f, 
    0.06842255f, -0.03580019f, -0.05475884f, 0.04887541f, 0.11092159f, -0.29967895f, 0.22848278f, 0.00489691f, 
    -0.32623959f, -0.07889542f, 0.06314448f, -0.25704852f, 0.19919796f, -0.01544445f, 0.26857433f, -0.21310893f, 
    0.04924240f, -0.03768988f, -0.44912416f, -0.01465265f, 0.14457245f, 0.08042365f, -0.28361818f, -0.14449486f, 
    0.11743539f, 0.27302784f, 0.14428076f, 0.06113294f, -0.09983487f, 0.04507997f, 0.24242443f, -0.01514207f, 
    -0.01786423f, -0.09095573f, 0.07792255f, 0.08362895f, 0.08133677f, 0.01339175f, 0.12852085f, -0.14741981f, 
    0.20837097f, 0.18211091f, -0.01982364f, -0.08610065f, 0.23417526f, -0.08177596f, -0.10164361f, -0.30441713f, 
    -0.15948465f, -0.06303016f, -0.14571449f, -0.01801286f, 0.09662814f, -0.04640912f, -0.02766491f, -0.02536705f, 
    -0.63705611f, 0.07539795f, -0.07690745f, 0.32631111f, -0.25584012f, 0.02118417f, -0.14348669f, -0.03361346f, 
    -0.09340563f, 0.29563859f, 0.00987340f, 0.30691069f, 0.01203429f, 0.06011477f, -0.02363728f, 0.22401747f, 
    0.13150714f, -0.07006607f, -0.15920220f, 0.09998305f, -0.06380214f, 0.03693304f, 0.06290600f, -0.17340496f, 
    0.14999601f, 0.14943092f, 0.11204366f, 0.07419567f, 0.55206698f, 0.11395306f, 0.20461194f, 0.01608970f, 
    0.05448269f, -0.22206229f, -0.32875094f, 0.12351387f, 1.07373822f, 0.00797188f, -0.26411244f, 0.01863864f, 
    -0.06882195f, 0.07265135f, 0.43360195f, -0.02025730f, 0.11944583f, 0.21133678f, -0.03647724f, 0.38461599f, 
    -0.09772977f, 0.17711031f, -0.12924226f, 0.22342519f, -0.34351370f, -0.38324475f, -0.19980414f, -0.04025982f, 
    0.18719830f, 0.17824194f, -0.06280408f, -0.21908706f, -0.16438232f, 0.10268882f, 0.24872598f, 0.25007048f, 
    0.02453908f, -0.19529030f, 0.01875750f, 0.05053998f, 0.05211031f, 0.23220427f, -0.18288621f, 0.19476695f, 
    0.30045193f, 0.00557607f, 0.21049242f, 0.15497048f, -0.44174320f, 0.54792160f, -0.45911056f, -0.04722872f, 
    -0.31316394f, 0.06106281f, 0.23180467f, -0.04958016f, 0.22680476f, 0.23432589f, 0.16710968f, 0.12371753f, 
    0.08174477f, -0.07434080f, 0.53314382f, -0.13075811f, 0.26952624f, -0.25782660f, 0.23110145f, 0.17967403f, 
    0.25721499f, -0.21527380f, -0.04922921f, -0.05277544f, -0.05557903f, -0.30391058f, 0.22882243f, 0.02426181f, 
    -0.08187415f, -0.01215426f, -0.31100333f, -0.01474768f, -0.03209751f, -0.22788404f, -0.00322532f, 0.01357019f, 
    -0.32575145f, -0.15683350f, -0.05291199f, -0.01711251f, 0.23942536f, -0.12728822f, -0.08029418f, 0.04680797f, 
    0.26933688f, 0.00207492f, 0.29401818f, 0.34439546f, -0.01804584f, -0.12270016f, -0.08014929f, 0.12461349f, 
    -0.43874586f, -0.24302474f, 0.31089523f, -0.45573550f, 0.02070004f, 0.11683801f, -0.01562001f, -0.16216201f, 
    -0.13026668f, 0.19418338f, 0.07822983f, 0.03289013f, 0.12031528f, -0.29619956f, 0.18726893f, 0.23325041f, 
    -0.22213289f, 0.26168987f, -0.17852367f, 0.04125373f, 0.13296302f, 0.16863407f, 0.06794529f, 0.08969758f, 
    0.12450766f, 0.09124678f, 0.09692586f, -0.32949173f, 0.44524387f, -0.00538147f, -0.01490149f, -0.02737837f, 
    0.00793491f, -0.14409322f, 0.12200186f, 0.07971831f, 0.84668297f, 0.19650252f, -0.18832609f, -0.09838013f, 
    -0.11129916f, -0.15775204f, 0.20453495f, 0.06339566f, -0.00997413f, -0.17507103f, -0.07268780f, 0.18527187f, 
    -0.11582597f, 0.11996470f, 0.08198188f, 0.40489781f, -0.23426287f, 0.03917114f, -0.27265009f, -0.08138023f, 
    0.26758608f, -0.20713264f, 0.08690795f, -0.14655848f, 0.06549147f, 0.14716686f, 0.29414290f, 0.19864529f, 
    -0.06119389f, 0.07582377f, -0.08854207f, -0.15364110f, 0.10365216f, -0.06079191f, 0.00034648f, 0.10963304f, 
    0.35783195f, 0.01371901f, 0.15247408f, 0.20358348f, -0.08827807f, 0.61098683f, -0.10402949f, -0.06103628f, 
    -0.14489235f, -0.03326882f, 0.10283630f, 0.07398759f, 0.31396380f, -0.05113635f, 0.16688281f, 0.21990973f, 
    0.06206534f, -0.29068491f, 0.21863861f, -0.16903970f, 0.27094498f, -0.11841647f, 0.17491846f, 0.02419846f, 
    0.22498259f, -0.16456723f, 0.02083334f, -0.02946107f, 0.02213843f, -0.03906133f, 0.13281259f, -0.20435397f, 
    0.10903277f, -0.06746339f, -0.03997701f, 0.03949418f, -0.03020909f, -0.01249226f, -0.26174787f, 0.16214785f, 
    -0.01292389f, 0.00836912f, -0.01688663f, -0.01516323f, 0.32422197f, 0.15530708f, -0.02253408f, -0.10977472f, 
    -0.19693112f, 0.02827855f, 0.23902638f, -0.00260689f, -0.00559145f, -0.13637775f, -0.10846940f, 0.24237068f, 
    0.07958607f, -0.16166008f, 0.18804550f, -0.32256034f, -0.08459503f, 0.11207454f, -0.05240012f, -0.10220187f, 
    0.16916968f, 0.00761467f, 0.30018428f, -0.13410111f, -0.06215095f, 0.12113882f, -0.39725202f, -0.17797114f, 
    0.26498082f, 0.00546857f, -0.38375908f, -0.26184374f, 0.10303106f, 0.00356804f, 0.07883034f, 0.15503016f, 
    -0.08346626f, 0.10466142f, -0.03733459f, -0.22827271f, -0.13770004f, -0.16924326f, 0.23267072f, 0.07877044f, 
    0.21586938f, 0.03612190f, 0.15074331f, 0.20889960f, -0.12662999f, 0.25109696f, 0.17176670f, 0.34964809f, 
    0.29809302f, -0.00411453f, 0.09712719f, 0.08971243f, -0.22208115f, 0.53602767f, 0.05364687f, 0.02197810f, 
    0.12308667f, 0.33308637f, -0.03127538f, -0.35285378f, 0.23613542f, 0.02217612f, -0.00103493f, 0.31353638f, 
    -0.16122016f, -0.30954573f, 0.12217464f, -0.06498700f, 0.18332823f, -0.17661241f, 0.32246622f, -0.06047331f, 
    -0.07676360f, 0.11105725f, 0.51718318f, -0.21745683f, -0.11209172f, 0.02826330f, 0.21839595f, -0.16214506f, 
    -0.39208594f, -0.03510409f, -0.07154375f, -0.06907928f, 0.22985761f, -0.56612927f, -0.29805088f, 0.02967143f, 
    0.42702258f, -0.00612327f, 0.19925351f, 0.31682691f, -0.13009404f, -0.39877471f, -0.51422489f, 0.16011046f, 
    0.07377786f, 0.20212331f, -0.25611576f, -0.07021543f, -0.18308963f, 0.11724208f, 0.13413939f, -0.00180875f, 
    -0.18088514f, 0.04181545f, -0.14797784f, -0.08601808f, 0.02655226f, 0.03525191f, 0.16810441f, 0.22589093f, 
    0.10409908f, -0.04358977f, 0.15508568f, 0.06946433f, 0.08696810f, 0.00865311f, -0.07186463f, 0.13923432f, 
    0.19275834f, -0.08178712f, 0.17894796f, 0.01959487f, -0.30474550f, -0.19252919f, 0.28730646f, 0.12506667f, 
    0.20622532f, -0.01581663f, -0.08956034f, -0.02137768f, -0.04181997f, -0.00167679f, 0.00683229f, -0.11829052f, 
    0.52844691f, -0.19338819f, 0.15992698f, 0.04130581f, -0.23572209f, 0.12286350f, 0.39365435f, 0.16847926f, 
    0.06435459f, 0.01958959f, -0.07347142f, -0.04199301f, -0.03990049f, 0.06811175f, -0.00078652f, -0.08410338f, 
    -0.05973087f, -0.04981598f, -0.08298409f, -0.03651262f, -0.09693109f, -0.07437998f, 0.06049681f, -0.08971567f, 
    -0.07690737f, -0.06557411f, 0.03023089f, 0.00122009f, -0.05384373f, -0.04866647f, 0.05830769f, -0.02576141f, 
    0.00614989f, 0.03992207f, 0.00923514f, 0.00088205f, -0.01553020f, 0.00458343f, -0.03905052f, 0.04669518f, 
    -0.04080044f, 0.05266451f, 0.01216908f, 0.06264249f, 0.02925755f, -0.05583495f, 0.03913797f, 0.03833447f, 
    -0.06272527f, 0.06794807f, 0.02833901f, 0.05515522f, -0.02508435f, -0.08540674f, -0.01064395f, 0.01755661f, 
    -0.05214762f, -0.08664308f, 0.06783093f, -0.02267730f, -0.08691191f, -0.01911085f, 0.01589577f, -0.04921056f, 
    -0.03962094f, -0.04329228f, 0.04247745f, 0.04930868f, -0.09212025f, -0.10993223f, -0.07910506f, -0.08885380f, 
    -0.06894267f, 0.01250205f, -0.10199696f, -0.08781552f, -0.03191399f, -0.02640785f, 0.01916119f, 0.05889067f, 
    0.00009566f, 0.01227288f, -0.00808191f, -0.01408635f, -0.09585550f, -0.03774601f, -0.07513050f, -0.05941670f, 
    -0.11350880f, -0.07009924f, 0.00589994f, -0.06028770f, 0.01972070f, 0.04634074f, 0.04307347f, -0.02380059f, 
    0.02812950f, -0.00498653f, -0.00604760f, 0.06744184f, 0.03362248f, 0.06285302f, -0.06072623f, 0.05633519f, 
    0.05107916f, 0.05411063f, 0.05502295f, -0.08038618f, -0.06028031f, -0.01358617f, -0.05435315f, -0.04332681f, 
    0.04742862f, -0.01980163f, 0.07033144f, -0.07456225f, 0.01207736f, 0.07767709f, 0.06313259f, -0.08224943f, 
    -0.07813998f, -0.01636656f, 0.06928059f, -0.05109066f, 0.04266667f, -0.07057513f, -0.01998760f, -0.03765464f, 
    -0.05228016f, -0.04111243f, 0.00962148f, 0.01047084f, -0.01502284f, -0.03480259f, -0.00921581f, -0.00235316f, 
    0.18005210f, -0.13933821f, 0.01519674f, 0.04826858f, -0.07055347f, 0.23530343f, -0.17770724f, 0.01214522f, 
    -0.07181384f, 0.03720667f, -0.13482447f, -0.07021558f, -0.11555575f, -0.04450463f, -0.02834155f, 0.04924711f, 
    -0.22187115f, -0.06212857f, 0.15676068f, 0.30499384f, -0.14147632f, -0.03186230f, -0.11207204f, -0.03430713f, 
    0.20482039f, 0.23923591f, -0.32995763f, -0.08373371f, 0.23296385f, 0.11284456f, 0.22004700f, 0.06333727f, 
    0.14476886f, -0.04836431f, 0.09283663f, -0.04315864f, 0.16511360f, 0.14681180f, -0.04350771f, -0.29388618f, 
    0.21098046f, 0.01260030f, 0.19909310f, -0.34145114f, 0.33683264f, 0.28738081f, 0.22146228f, 0.06103496f, 
    0.02707951f, 0.36851946f, -0.11873513f, -0.08966541f, 0.09742536f, -0.01161434f, 0.11238552f, -0.14471360f, 
    0.06191100f, 0.14442314f, 0.01241072f, 0.20845072f, -0.00923674f, -0.12645073f, 0.18808486f, -0.05070908f, 
    0.07512298f, 0.39376375f, 0.01189327f, -0.03233479f, -0.42402712f, 0.64135295f, 0.07355566f, -0.07775868f, 
    -0.13434274f, 0.08075790f, -0.12844962f, 0.23786752f, 0.00040324f, -0.04808601f, -0.13925990f, 0.01679553f, 
    0.04078639f, -0.06372930f, 0.09112933f, 0.00585004f, -0.05343866f, 0.06200549f, -0.08731447f, -0.05446290f, 
    -0.02520394f, -0.08454149f, 0.08348051f, 0.05069374f, -0.00561157f, -0.05155651f, -0.28064764f, -0.00462804f, 
    0.16883540f, 0.04223618f, -0.01330315f, 0.18963231f, -0.02403946f, 0.21565634f, 0.02430001f, 0.23812634f, 
    0.00400821f, 0.17812467f, 0.12094041f, 0.01357533f, 0.06289439f, 0.05951989f, -0.09585632f, -0.06355130f, 
    -0.26906988f, -0.06973366f, -0.02418339f, 0.05694104f, -0.05965922f, -0.16024992f, 0.09439389f, 0.02798730f, 
    -0.10541970f, 0.15885612f, -0.28921795f, -0.20087872f, 0.17193940f, 0.16283071f, -0.05375916f, -0.04006010f, 
    0.10193021f, -0.01756137f, 0.08494031f, -0.19700237f, -0.05713658f, 0.14782271f, -0.23463044f, 0.04679177f, 
    0.15201017f, 0.08673281f, 0.34309727f, -0.02439531f, -0.02287560f, -0.08694067f, -0.06889862f, 0.21025461f, 
    -0.01497101f, -0.13157228f, -0.05410577f, 0.23020175f, -0.19674395f, 0.20178762f, -0.14282015f, -0.05284613f, 
    -0.15634838f, 0.28810871f, 0.19124587f, -0.04707773f, -0.51227057f, -0.18255459f, 0.14286096f, 0.18588620f, 
    0.03949435f, 0.20705301f, -0.25230005f, 0.07542139f, 0.08961529f, -0.07051247f, 0.00683754f, -0.47015885f, 
    0.07650948f, -0.10622409f, 0.02504263f, -0.53288180f, 0.37051225f, 0.17327711f, 0.23888880f, 0.06351015f, 
    -0.00851805f, 0.07063874f, 0.11921456f, 0.30692443f, 0.14412719f, 0.19463205f, -0.53964752f, -0.06711712f, 
    0.00368337f, 0.14837272f, -0.11923405f, 0.24926841f, -0.28528762f, 0.04821673f, 0.15523228f, -0.14916083f, 
    0.00305104f, 0.04010550f, -0.06950533f, -0.07555127f, 0.45340118f, -0.25801775f, 0.37174869f, 0.07261107f, 
    0.26805398f, 0.05194221f, 0.02670647f, 0.05835063f, -0.01961424f, -0.25697538f, -0.05865345f, -0.21718693f, 
    0.08799093f, -0.07450987f, -0.42657205f, 0.07312901f, -0.07726861f, 0.22656150f, -0.02991487f, -0.00072652f, 
    -0.00950905f, 0.26379466f, 0.23356016f, 0.00283505f, 0.09955771f, 0.19947782f, -0.16287984f, 0.10691179f, 
    -0.03157102f, 0.01780220f, 0.37835753f, 0.11593386f, 0.21093489f, 0.07224257f, 0.17168058f, -0.09018710f, 
    0.04246637f, 0.24324358f, 0.14815702f, 0.04922933f, -0.18941456f, -0.00856448f, 0.13486546f, -0.12133817f, 
    -0.18509348f, 0.00255448f, -0.26326919f, -0.00131500f, 0.04137002f, 0.18977377f, 0.16088043f, -0.01721589f, 
    0.05598357f, 0.11423793f, 0.13852084f, 0.36384696f, 0.04511652f, 0.08582338f, 0.09634416f, 0.27979714f, 
    0.00731574f, 0.26589605f, 0.22695459f, -0.15519817f, 0.25213677f, -0.02035725f, 0.11932366f, 0.13019741f, 
    -0.19456117f, 0.41882864f, -0.03654583f, 0.12560223f, 0.07052110f, 0.04282712f, -0.05054966f, 0.09542423f, 
    0.14295915f, -0.27836707f, 0.04214626f, -0.52632725f, 0.48038954f, -0.17652556f, 0.18514559f, 0.00848704f, 
    -0.11805687f, -0.10507884f, 0.09469127f, 0.21954906f, 0.29560149f, -0.06770115f, 0.03978667f, -0.10245312f, 
    -0.09099156f, -0.27610415f, -0.05785633f, 0.04830076f, 0.02947946f, 0.12766981f, 0.07666381f, -0.01256387f, 
    -0.23313108f, -0.12684435f, -0.20685111f, -0.17672572f, -0.27936202f, 0.18053776f, 0.03814711f, 0.04243087f, 
    0.18178482f, -0.20314163f, 0.15942441f, 0.10121766f, 0.08867273f, 0.01938446f, 0.24881960f, 0.16281262f, 
    0.06854869f, -0.06126881f, -0.01901975f, -0.08656552f, 0.32150918f, 0.19686812f, 0.09658659f, 0.13073742f, 
    0.18158919f, -0.26087877f, 0.17854394f, 0.24153200f, -0.38549799f, 0.09472898f, 0.18801646f, 0.07448922f, 
    0.05551880f, 0.03952038f, -0.22957379f, -0.15378900f, 0.03229020f, -0.03421585f, 0.16871326f, 0.26522794f, 
    0.05460898f, -0.04093449f, 0.20615435f, -0.07920684f, 0.21104571f, -0.11273921f, 0.24620095f, 0.05099641f, 
    0.10361698f, -0.27251607f, 0.19275472f, 0.06279068f, 0.02426918f, -0.12710872f, 0.28312641f, 0.00960329f, 
    -0.13639778f, 0.03352948f, 0.06477115f, 0.12807253f, -0.05415348f, -0.25403464f, -0.09246334f, 0.18269069f, 
    0.07248235f, -0.24812035f, 0.30814996f, 0.00183419f, -0.17409605f, -0.02785705f, -0.02449943f, -0.05152332f, 
    0.18243565f, -0.04777468f, 0.21122001f, 0.18046294f, 0.05594897f, 0.13945501f, -0.21658157f, 0.02565504f, 
    0.32824272f, 0.15883306f, 0.10690612f, -0.56014282f, -0.03062031f, -0.03439750f, -0.04215738f, -0.09280021f, 
    -0.04828355f, -0.03086564f, -0.06563588f, 0.04488100f, -0.01100098f, -0.09450889f, -0.03419283f, 0.01841438f, 
    0.00612654f, -0.10278757f, -0.03944919f, -0.03645253f, 0.01326067f, -0.00629846f, -0.03200457f, -0.08496933f, 
    -0.07512253f, -0.05965338f, -0.02893570f, 0.02171672f, -0.05490517f, -0.06048546f, -0.01164464f, -0.02294046f, 
    -0.11858638f, -0.09280147f, 0.08291180f, -0.01801879f, -0.05841637f, -0.09963357f, 0.05037095f, -0.08469949f, 
    -0.07810852f, 0.02473767f, -0.09384540f, -0.07862353f, 0.03805321f, 0.00765703f, -0.07455637f, 0.05795029f, 
    0.05061921f, -0.04554838f, -0.03418948f, 0.05566486f, -0.10952038f, -0.09138659f, 0.05028227f, 0.01762337f, 
    -0.00233979f, 0.02188827f, -0.07662731f, -0.03095048f, 0.04023632f, 0.01570118f, -0.04055629f, -0.01865897f, 
    -0.03020733f, 0.03335267f, 0.08754048f, -0.08592751f, -0.05660393f, -0.02106020f, -0.07964358f, 0.00870937f, 
    -0.07422954f, -0.06451159f, -0.10181969f, -0.03174731f, 0.05236770f, -0.02170318f, 0.08648364f, 0.08823239f, 
    -0.08491058f, 0.03927135f, -0.04106572f, 0.00741998f, 0.05176057f, -0.02820650f, -0.03608084f, 0.01199611f, 
    -0.03328768f, -0.03398149f, -0.04507181f, -0.09480226f, 0.05847572f, -0.02705382f, 0.00606965f, -0.03832620f, 
    -0.03745793f, 0.02485827f, -0.07456365f, -0.01885160f, -0.04721350f, 0.02411032f, 0.04570634f, 0.04770502f, 
    0.01300071f, 0.01316473f, -0.01793877f, -0.10443013f, -0.10881052f, 0.05457226f, -0.10860766f, -0.00901166f, 
    0.00564997f, -0.03178801f, 0.01818626f, 0.08830728f, 0.03240325f, 0.05104787f, -0.08846951f, -0.02632089f, 
    0.08262975f, 0.03437729f, 0.05153850f, -0.04986746f, -0.01160386f, -0.04945431f, 0.05223999f, 0.07163759f, 
    -0.03511950f, -0.04830665f, -0.06708577f, 0.06199541f, -0.05030106f, 0.02395120f, 0.05791068f, -0.01066986f, 
    0.00767441f, 0.14839511f, 0.15783294f, 0.01447059f, -0.03002714f, -0.23619755f, -0.26731095f, 0.02291886f, 
    -0.01811568f, 0.13518596f, 0.04220560f, 0.10456884f, 0.17140836f, 0.10686892f, 0.14281486f, 0.12064616f, 
    -0.05592600f, 0.13970068f, 0.04282063f, -0.28274608f, 0.02625633f, 0.20072939f, 0.10746201f, 0.00445356f, 
    -0.20335799f, -0.28134561f, 0.09020538f, 0.06269147f, 0.00114981f, 0.16182300f, -0.46998951f, -0.06718356f, 
    -0.01907077f, -0.23789290f, 0.08038794f, -0.08172073f, -0.11019330f, -0.24762124f, -0.07663164f, -0.03349586f, 
    -0.03235904f, -0.20057912f, 0.06065914f, 0.22782831f, -0.42960641f, 0.19336148f, -0.38086033f, -0.04609889f, 
    0.15060005f, -0.37034160f, 0.12989587f, -0.05348673f, 0.10732906f, 0.14127751f, 0.13436657f, 0.16277109f, 
    0.06636413f, 0.17934562f, -0.04749180f, -0.21219563f, 0.20308726f, 0.08723568f, 0.05194965f, -0.04121057f, 
    0.22054249f, -0.09582143f, 0.02938540f, 0.07438619f, 0.02831270f, -0.04818381f, 0.23182605f, -0.08139529f, 
    -0.28394929f, 0.03408819f, 0.28804898f, 0.07875602f, 0.14025448f, -0.21245253f, 0.18512388f, 0.30075681f, 
    -0.00256408f, -0.35195079f, -0.28431073f, -0.02556740f, 0.19580948f, -0.09282193f, 0.24644403f, -0.02144494f, 
    0.09944246f, -0.17596132f, 0.13375597f, -0.05484548f, -0.09657369f, 0.17372099f, 0.00204039f, -0.18483381f, 
    0.02809861f, -0.01121235f, 0.08530597f, 0.21079762f, -0.02647681f, 0.02558116f, -0.02636485f, 0.22242410f, 
    -0.02224284f, 0.03644100f, -0.10319802f, 0.07182566f, 0.35755011f, 0.07004205f, -0.15830019f, -0.07817892f, 
    0.12299515f, 0.00479319f, -0.07908407f, -0.04874183f, 0.11913692f, -0.07762777f, 0.20265305f, 0.34894589f, 
    -0.16336444f, -0.18182975f, -0.54441941f, -0.00312726f, -0.14450841f, 0.18019755f, -0.07759009f, 0.02939830f, 
    0.18245484f, -0.16127251f, -0.12785412f, 0.42627242f, -0.07472729f, -0.11552630f, -0.18252154f, -0.15004472f, 
    -0.07661659f, -0.03815477f, 0.24759799f, 0.07549481f, -0.07354669f, 0.16317312f, 0.09448695f, 0.06432137f, 
    -0.11484613f, 0.13098413f, 0.41331160f, 0.25931966f, -0.26428097f, 0.04610188f, -0.00185733f, -0.06781466f, 
    0.30342269f, -0.11360433f, -0.42051235f, -0.08706590f, -0.21074855f, -0.00649668f, -0.03807747f, 0.21860214f, 
    0.23593144f, 0.14525165f, -0.05986248f, -0.07987124f, 0.11433702f, 0.03300453f, 0.11424481f, 0.01735075f, 
    0.10012414f, -0.08833268f, 0.10249194f, 0.12443322f, -0.07600486f, 0.08589933f, 0.20973773f, -0.12022693f, 
    0.06316964f, 0.33495986f, -0.02149818f, 0.13097788f, -0.01298461f, 0.13745940f, -0.09390068f, -0.05857311f, 
    0.01712628f, 0.10258946f, 0.33403683f, 0.15999423f, 0.37065759f, 0.23875110f, -0.10119213f, 0.10477781f, 
    0.00116316f, 0.27340618f, 0.08304461f, -0.11401293f, -0.55598062f, -0.03494436f, 0.25544730f, 0.01248315f, 
    -0.13099848f, -0.07293171f, 0.18156230f, 0.05923728f, -0.01364103f, 0.22572210f, 0.27100298f, 0.10534436f, 
    -0.01538364f, -0.00703048f, 0.03709719f, 0.10878889f, -0.13946755f, 0.18655586f, -0.01725963f, 0.06797595f, 
    -0.03683405f, -0.41861635f, 0.02520169f, -0.06127062f, 0.02224233f, 0.01729069f, -0.05393329f, 0.15832065f, 
    0.23377234f, 0.00795245f, -0.20365480f, -0.02637718f, -0.02378713f, 0.09288055f, 0.10945658f, 0.28607455f, 
    0.03155353f, 0.03142221f, -0.03533603f, 0.08366179f, 0.10691733f, 0.21269727f, 0.06921268f, 0.33519945f, 
    0.37948945f, 0.04598089f, 0.02015331f, -0.04814874f, -0.04635987f, -0.08929209f, 0.30296943f, 0.23013179f, 
    -0.24989991f, 0.28025049f, -0.53868729f, 0.34419143f, 0.22697257f, 0.25203872f, -0.13752359f, 0.00896039f, 
    0.13007331f, -0.03754921f, -0.17793123f, 0.14529547f, -0.15188766f, 0.00476897f, -0.36188039f, -0.21093237f, 
    0.10949709f, -0.03779094f, 0.15625618f, 0.16777968f, 0.12913212f, 0.17867103f, -0.04409318f, 0.04688442f, 
    0.04772131f, 0.05037208f, 0.21893364f, -0.14310949f, 0.09423926f, -0.01181623f, 0.03423818f, -0.07856876f, 
    -0.01153525f, -0.04251857f, 0.11067970f, -0.10022736f, -0.43452007f, -0.15986362f, 0.09406287f, 0.29568654f, 
    0.28285718f, 0.18635976f, -0.03541254f, -0.07280268f, -0.01068021f, 0.25207251f, -0.04165395f, -0.22883470f, 
    -0.03357040f, 0.01676102f, -0.03193128f, -0.38495037f, 0.00707614f, -0.22668323f, 0.14014643f, -0.08825637f, 
    0.09982537f, -0.05517723f, -0.00267852f, -0.05504028f, -0.03351700f, 0.10832750f, -0.21968229f, -0.09218536f, 
    -0.08808775f, 0.03273318f, 0.26153132f, -0.05483758f, 0.16245233f, 0.11992580f, -0.01909636f, 0.05441081f, 
    -0.00847172f, -0.13397790f, 0.15344222f, -0.22543304f, -0.12623322f, -0.34210601f, -0.31478700f, -0.02918277f, 
    0.12186565f, -0.02022672f, 0.25981811f, -0.01993637f, -0.21909553f, 0.00546345f, 0.16213064f, 0.00914366f, 
    0.05419971f, -0.02055344f, -0.11712971f, 0.00063912f, 0.02148365f, 0.13488059f, 0.01825456f, 0.12706701f, 
    0.14211497f, 0.08707515f, -0.00696987f, 0.07712731f, -0.02426245f, 0.18393460f, 0.14484650f, 0.29433796f, 
    0.01605935f, 0.04735912f, -0.12456034f, 0.01037107f, 0.04675898f, -0.02681205f, 0.16729055f, -0.01256441f, 
    0.01346803f, -0.17300759f, 0.06114500f, 0.07023121f, 0.14217068f, -0.00695714f, 0.10085209f, 0.13950230f, 
    0.34265214f, 0.07152320f, 0.13270946f, 0.01335497f, -0.12889399f, 0.06474505f, 0.09772609f, 0.17100282f, 
    0.07106313f, 0.23116203f, 0.13187678f, 0.30375427f, 0.06643171f, 0.20029750f, 0.11423852f, -0.03762914f, 
    0.13513534f, 0.25169763f, 0.03370603f, 0.14752807f, 0.19798076f, -0.01663175f, -0.08214316f, -0.02288995f, 
    -0.03669956f, -0.04100801f, -0.37778839f, -0.25908399f, 0.01950169f, 0.18589754f, 0.15875199f, -0.10976951f, 
    -0.10864095f, 0.09000818f, -0.09855227f, -0.21326591f, 0.31679162f, -0.28043443f, 0.21196797f, -0.02627464f, 
    0.19997737f, -0.41648573f, 0.24282749f, 0.02298426f, 0.00006234f, 0.20689891f, -0.14473149f, -0.04226476f, 
    0.14379366f, -0.21441798f, 0.08582939f, 0.06409411f, -0.34639299f, 0.28698593f, 0.03841635f, -0.01396028f, 
    0.18447381f, 0.38996783f, -0.09346282f, 0.02033979f, -0.60057598f, 0.18981391f, 0.10671828f, 0.20284805f, 
    -0.10001414f, -0.29292700f, 0.12223280f, -0.04605654f, 0.12728846f, -0.23935249f, 0.27738950f, 0.16376390f, 
    0.08702282f, 0.05217072f, 0.04838482f, -0.06995174f, 0.14550123f, -0.22682668f, 0.18657200f, 0.13617657f, 
    -0.10449167f, 0.08005771f, 0.04838705f, -0.12710232f, -0.16540910f, -0.18113692f, -0.43730283f, -0.01163685f, 
    0.07915910f, 0.07529399f, 0.17051221f, 0.30261672f, -0.11799061f, -0.52073270f, -0.37133798f, 0.09948310f, 
    0.00135284f, 0.07211767f, -0.54708546f, -0.10635333f, 0.04502997f, -0.02465854f, -0.04129206f, -0.02038737f, 
    -0.05370212f, 0.39436167f, -0.21955562f, -0.05800737f, 0.05308921f, 0.07750263f, 0.40973574f, 0.00537234f, 
    0.09503219f, 0.05082198f, 0.06092909f, 0.26113799f, 0.07894139f, -0.04863587f, -0.29524040f, 0.15979511f, 
    0.27484307f, 0.04799207f, 0.27849495f, -0.00596752f, -0.06331905f, -0.14928174f, 0.21537369f, 0.14934821f, 
    0.04624183f, 0.04244494f, 0.05326695f, 0.24757242f, -0.06434538f, 0.01027671f, -0.32130465f, -0.05768230f, 
    0.30153230f, 0.02951141f, 0.28098354f, -0.25564632f, -0.08953024f, 0.04497534f, 0.14451307f, -0.11367216f, 
    0.05388903f, 0.01713569f, -0.08624579f, -0.04044177f, 0.03152707f, 0.05245313f, -0.04495808f, 0.03651561f, 
    -0.08437553f, -0.00322217f, -0.04634879f, 0.02266756f, -0.07495325f, -0.09955831f, -0.00123955f, -0.00018297f, 
    -0.01688489f, -0.00097875f, 0.01943524f, -0.02963674f, 0.05773124f, 0.02160487f, -0.06417908f, 0.03017012f, 
    -0.06386175f, -0.11254507f, -0.00216590f, 0.01191984f, 0.01241384f, 0.04596752f, -0.03839219f, 0.05275494f, 
    -0.00722216f, 0.03367291f, -0.10483833f, 0.05215134f, 0.00521671f, 0.02881533f, -0.04464231f, 0.01824307f, 
    -0.00836062f, -0.06547248f, -0.04227764f, 0.05773807f, -0.08121946f, -0.05469161f, -0.03088149f, -0.04501847f, 
    -0.08867645f, -0.09735576f, 0.01824082f, 0.00186999f, -0.07311527f, -0.08242793f, 0.08140236f, -0.08834739f, 
    -0.00444623f, 0.06301547f, -0.04363636f, -0.07343200f, -0.00954864f, 0.07133044f, -0.01380293f, -0.10604572f, 
    0.04058778f, -0.02358400f, -0.02845311f, -0.12434668f, 0.01825618f, -0.09660725f, 0.06019405f, 0.03316854f, 
    0.01863884f, -0.03357376f, 0.02397869f, -0.09025383f, 0.04240228f, -0.07509156f, 0.00001180f, 0.00918663f, 
    -0.03332416f, -0.00906868f, 0.02453858f, -0.10062187f, 0.05684222f, -0.06654298f, 0.00257400f, 0.01849502f, 
    0.02654741f, 0.06962893f, 0.01930662f, 0.04204120f, -0.07197283f, -0.08592065f, -0.10894349f, -0.07380746f, 
    0.04349859f, 0.03535405f, -0.00582831f, -0.04972004f, -0.03017414f, -0.07039753f, -0.14425066f, 0.03209847f, 
    -0.02152047f, 0.01670291f, -0.04719927f, 0.07265866f, 0.05335839f, -0.07555593f, -0.09988248f, 0.01286994f, 
    -0.06423377f, -0.02296976f, 0.00613573f, 0.02173352f, -0.05076806f, -0.08825660f, -0.07591712f, -0.03207199f, 
    -0.02082069f, -0.01993408f, -0.00105970f, -0.07679258f, -0.03979082f, -0.02443449f, -0.02663024f, -0.03423585f, 
    0.23448147f, -0.22174187f, 0.44070560f, 0.12439879f, -0.00405517f, -0.17185681f, -0.26684526f, -0.07721160f, 
    -0.05353978f, 0.15054710f, -0.52760774f, -0.12784123f, -0.26029870f, 0.05169086f, 0.26715887f, 0.14086294f, 
    -0.56291223f, 0.23914889f, 0.09755372f, 0.04802738f, 0.32682493f, -0.10099669f, 0.02072870f, -0.02623231f, 
    0.38577622f, -0.39651483f, -0.07983132f, 0.18812871f, 0.16914284f, 0.29109478f, 0.05405559f, 0.21984485f, 
    0.01719008f, -0.38536605f, -0.02932076f, -0.00911356f, -0.09543280f, 0.33760032f, 0.08665346f, -0.47263983f, 
    0.08240312f, 0.27831790f, 0.24840975f, 0.74216574f, -0.11299747f, 0.17577982f, -0.13721570f, 0.17436372f, 
    0.17946076f, 0.16355066f, -0.16188245f, -0.18975550f, 0.12420554f, -0.30887008f, 0.49405518f, -0.27704453f, 
    0.00923907f, 0.10273672f, 0.38585678f, -0.28858715f, 0.09479295f, 0.08190147f, 0.27474749f, 0.06153936f, 
    0.09038636f, 0.17920958f, 0.11134689f, 0.18896878f, 0.29338217f, 0.35194939f, -0.13209996f, -0.00622628f, 
    0.38932353f, 0.00223192f, -0.07209595f, 0.26249054f, 0.11273611f, -0.76483244f, -0.18086863f, 0.18294750f, 
    0.01452422f, 0.25288028f, -0.42445377f, -0.19114706f, -0.11567148f, 0.03246722f, 0.22170003f, -0.14181481f, 
    -0.24052308f, -0.47709906f, -0.07382645f, 0.05837187f, 0.00108872f, -0.05858775f, -0.30155411f, -0.24313127f, 
    0.09364536f, -0.05479571f, -0.07039642f, -0.04512443f, -0.10083355f, 0.07059516f, -0.50233710f, 0.43122843f, 
    -0.04308643f, -0.06429596f, 0.21186271f, 0.03166362f, 0.01680289f, -0.10013350f, 0.08408570f, -0.00705480f, 
    0.26021659f, -0.07497235f, -0.05262218f, 0.05167800f, -0.01922020f, -0.10289499f, 0.23182379f, -0.05061859f, 
    0.66232389f, -0.13315900f, -0.06915999f, 0.16032644f, -0.02063363f, 0.13738903f, -0.09773763f, 0.17464387f, 
    -0.01801505f, 0.00170558f, -0.02288752f, -0.00009604f, 0.00097220f, -0.06388414f, -0.06827548f, -0.08100610f, 
    -0.07383922f, -0.07877802f, -0.04572269f, -0.05392016f, 0.07694004f, -0.08348413f, 0.06493340f, -0.06469564f, 
    0.00311728f, -0.05371381f, 0.06645253f, 0.01868237f, 0.03511072f, 0.06814314f, 0.05119471f, 0.05534612f, 
    -0.04850481f, 0.02719177f, -0.03278298f, 0.06674424f, 0.02698046f, 0.01123728f, 0.06132874f, -0.03592227f, 
    0.07558464f, -0.01408492f, -0.00049657f, -0.00618064f, -0.00703852f, -0.04949984f, 0.02992898f, 0.07143094f, 
    -0.04104387f, -0.01657069f, -0.03817035f, -0.04635652f, -0.08546864f, -0.05082584f, -0.01509576f, -0.00072950f, 
    -0.08136007f, 0.03253463f, 0.01172036f, -0.03894147f, -0.07181345f, 0.04022260f, 0.06213403f, -0.06563215f, 
    -0.07107072f, 0.00816124f, -0.02455102f, -0.03864272f, -0.01993928f, -0.00233451f, 0.04107128f, 0.04930638f, 
    -0.01602825f, -0.04842200f, -0.07576296f, 0.08774050f, 0.07189824f, 0.00731692f, 0.01206776f, 0.03712570f, 
    -0.01607887f, 0.01768829f, -0.01104240f, -0.08272119f, -0.02622706f, -0.03664163f, -0.05453701f, -0.05560835f, 
    0.04821894f, 0.00062349f, 0.00627688f, -0.01632648f, 0.07479765f, 0.06460368f, 0.01145415f, -0.07218547f, 
    0.06201613f, -0.04605005f, -0.06595571f, 0.04595377f, -0.05126999f, 0.01346673f, 0.02499694f, 0.06512611f, 
    -0.02337369f, -0.00226808f, -0.04716665f, -0.08668497f, -0.01095879f, -0.07480808f, -0.01008154f, -0.02097768f, 
    -0.06996033f, -0.05058842f, 0.03113627f, 0.00733096f, 0.03038499f, -0.02855670f, 0.04278748f, -0.04845946f, 
    -0.01879484f, 0.03876263f, 0.02954069f, -0.00867316f, 0.07854875f, 0.02707354f, -0.06794985f, -0.04437011f, 
    -0.04171050f, -0.04154256f, 0.01111103f, -0.06729446f, 0.03519367f, -0.08672452f, -0.07641494f, -0.03585773f, 
    0.06665770f, 0.10659109f, -0.03135639f, 0.25466061f, 0.02061629f, 0.00829261f, -0.09928171f, 0.10178529f, 
    -0.58002222f, 0.00555234f, 0.09374918f, -0.19510771f, -0.07809229f, 0.17483932f, 0.07964513f, 0.11115844f, 
    0.20741984f, 0.05467649f, 0.17229810f, 0.22701162f, -0.35842246f, 0.04241712f, -0.15141571f, -0.00668104f, 
    0.22829534f, 0.23345111f, -0.54672688f, 0.08264738f, -0.45560730f, -0.06033931f, -0.25093704f, 0.01002700f, 
    0.17410016f, 0.07830784f, -0.01868665f, -0.07890013f, 0.25151622f, -0.28495276f, 0.04892857f, 0.07914213f, 
    0.03069257f, -0.10750261f, 0.21170597f, -0.02503128f, -0.19517645f, -0.06870617f, 0.19036700f, -0.05510181f, 
    0.03846729f, 0.41788644f, -0.08320946f, 0.10810722f, 0.09715605f, 0.17304248f, -0.38807473f, -0.09542631f, 
    0.07047187f, 0.18426229f, -0.09916417f, 0.01406769f, 0.27278298f, 0.18893512f, -0.07882607f, 0.13424945f, 
    0.15186912f, 0.20316015f, 0.39976913f, -0.09869716f, -0.12682268f, -0.31829181f, 0.35878506f, 0.07870714f, 
    -0.45634472f, -0.06484961f, -0.31109640f, 0.02419263f, -0.02597591f, 0.32468957f, 0.00357110f, -0.15625830f, 
    -0.00027831f, -0.08051626f, 0.05012028f, 0.04736710f, 0.08813941f, 0.08454718f, -0.03786772f, -0.07113089f, 
    -0.23896696f, -0.16528675f, 0.12079654f, 0.01843430f, -0.06372409f, -0.07004939f, 0.02647810f, 0.18778861f, 
    0.19975087f, -0.04631957f, -0.04838903f, -0.07378887f, 0.00510072f, 0.30942109f, -0.03834532f, 0.22965322f, 
    -0.04653469f, 0.05517381f, -0.01652385f, -0.06830742f, -0.21184437f, 0.13105831f, -0.09308314f, 0.19157226f, 
    -0.36706167f, 0.03420934f, -0.15184061f, 0.03216121f, -0.01450640f, -0.19244561f, -0.06612474f, -0.28079900f, 
    -0.32390627f, 0.07390031f, -0.40017280f, -0.26279807f, 0.06289616f, 0.07516699f, -0.01048090f, 0.20386961f, 
    0.05022836f, -0.00079203f, 0.13323089f, 0.11722039f, -0.11091752f, -0.37097806f, -0.24221888f, 0.00564656f, 
    0.21538901f, -0.11727481f, 0.12472160f, 0.09704325f, 0.16613770f, 0.04253874f, 0.09326441f, 0.03882696f, 
    0.06439874f, 0.33109474f, 0.22394878f, -0.04832290f, -0.26643306f, 0.25601006f, 0.01275467f, 0.06553086f, 
    -0.05460960f, -0.27015603f, 0.05226040f, 0.11693570f, -0.26383296f, 0.14487602f, -0.33397859f, 0.04084380f, 
    0.09483720f, 0.15889689f, -0.11939717f, -0.08809504f, -0.03970226f, -0.11876629f, -0.04685154f, 0.09839074f, 
    0.06376609f, -0.08716004f, 0.18304408f, 0.34733915f, -0.21622902f, -0.10515359f, -0.12547061f, -0.06369653f, 
    0.00323579f, -0.24593090f, 0.05314025f, 0.09061626f, -0.03265413f, 0.26133117f, -0.29129258f, 0.04598140f, 
    -0.08571933f, 0.08757792f, -0.00901956f, -0.06526167f, 0.26690438f, 0.29408884f, -0.08834298f, 0.04928314f, 
    0.19856171f, 0.01144952f, -0.04629684f, -0.15072554f, 0.17711252f, -0.44462764f, 0.26732007f, 0.08571558f, 
    -0.11749972f, -0.06717028f, 0.22623713f, -0.03420797f, -0.01555621f, -0.00073547f, 0.20409502f, 0.06248335f, 
    -0.08715139f, -0.37864032f, -0.18589319f, 0.14214920f, 0.12152639f, 0.01500574f, 0.17782478f, 0.05139435f, 
    0.04827270f, -0.09701911f, -0.04827415f, -0.06576052f, 0.05681402f, 0.19473173f, 0.06880427f, -0.14321050f, 
    -0.00492298f, -0.01204826f, -0.12731944f, -0.07527234f, 0.09908305f, 0.00619578f, 0.03886811f, 0.05213907f, 
    0.00577055f, 0.19993553f, -0.22267841f, 0.02553695f, 0.24871600f, 0.18769258f, 0.07053093f, 0.06443003f, 
    0.20546067f, -0.04159696f, -0.06372138f, -0.16478990f, -0.10184301f, -0.01845770f, 0.27879953f, 0.29135993f, 
    -0.36366594f, 0.08026981f, -0.45018688f, 0.31587461f, -0.21495067f, 0.14368697f, -0.01917347f, -0.03044029f, 
    0.18856421f, -0.02578428f, 0.20988522f, -0.07187346f, 0.01213259f, -0.04490660f, -0.16264756f, 0.00519240f, 
    -0.17282660f, -0.01859098f, -0.00844299f, -0.06712873f, 0.07701864f, -0.02129635f, 0.01227328f, 0.13012071f, 
    -0.13769010f, 0.13574946f, 0.13774428f, -0.20032451f, -0.47479424f, 0.17070808f, 0.08036777f, -0.07494944f, 
    0.05876333f, -0.03182659f, -0.23219365f, -0.08234054f, -0.25547364f, 0.14386658f, -0.07819057f, 0.11053636f, 
    -0.01596283f, -0.09621722f, 0.02546868f, 0.05735524f, -0.05374566f, -0.29633608f, -0.01107827f, -0.21055795f, 
    0.10008612f, -0.27373192f, 0.19713345f, 0.28549004f, 0.23516905f, 0.29760146f, -0.22567771f, 0.21648653f, 
    -0.12755218f, 0.10663001f, -0.01061185f, -0.01690714f, 0.05340610f, 0.07961845f, 0.38166541f, -0.08416513f, 
    0.07453129f, 0.30429271f, -0.10801347f, -0.00027005f, 0.39307362f, 0.09845826f, 0.10763089f, 0.01494911f, 
    0.01951273f, 0.06127967f, -0.10674739f, 0.04670967f, 0.48141205f, 0.14771245f, 0.19186901f, 0.02349268f, 
    0.19427402f, -0.00771311f, -0.02824024f, 0.20631909f, 0.11469316f, -0.12295233f, -0.09914736f, 0.07096015f, 
    0.07936418f, 0.05747830f, -0.10607215f, 0.16744782f, -0.13649151f, 0.11424567f, 0.05295323f, -0.08111356f, 
    -0.02045779f, -0.02676529f, 0.00573938f, 0.02305857f, -0.02794579f, 0.21374871f, -0.10858666f, 0.08577486f, 
    0.03798925f, 0.04271193f, 0.15917221f, 0.16454536f, 0.15444180f, 0.19967295f, -0.11763749f, 0.21119744f, 
    0.34631833f, 0.09645770f, 0.17237569f, 0.01986076f, -0.12220389f, -0.07479002f, -0.00322759f, 0.08441354f, 
    -0.15538231f, -0.07612619f, -0.08807267f, -0.14175881f, 0.09699794f, 0.00334618f, 0.28475603f, -0.00168564f, 
    0.32335335f, -0.00085199f, -0.48731330f, 0.33340269f, 0.08876857f, 0.00342114f, 0.04415384f, 0.08884460f, 
    0.16181408f, -0.12944920f, 0.11241966f, -0.21235597f, -0.18290095f, 0.45976126f, -0.43098661f, -0.24156030f, 
    0.52956390f, -0.25743735f, -0.22489680f, -0.01684597f, 0.20294809f, 0.01607843f, 0.18338102f, -0.13256250f, 
    -0.06907380f, 0.19027968f, -0.14018048f, 0.46772519f, -0.09540112f, 0.41660693f, 0.32321069f, -0.00967129f, 
    -0.25611734f, -0.06116566f, 0.01640049f, 0.23196791f, -0.10358402f, -0.11778519f, -0.40937370f, 0.37676185f, 
    0.21911758f, 0.27465287f, 0.09212338f, 0.05922636f, 0.16833434f, 0.16346855f, 0.00802758f, 0.16018772f, 
    0.30532864f, 0.13047516f, -0.12346318f, -0.45800409f, 0.19362274f, -0.07320280f, 0.09159670f, 0.24023612f, 
    -0.49786264f, -0.34195167f, -0.21152082f, -0.08540157f, -0.07498883f, 0.20478845f, 0.24254745f, -0.07570803f, 
    0.02854025f, 0.25506672f, -0.09957501f, -0.12696970f, 0.12080487f, 0.05571890f, -0.12774011f, -0.46542358f, 
    -0.11350871f, -0.38515162f, -0.39505228f, -0.01334078f, 0.17404848f, -0.46474510f, 0.03699967f, 0.05130488f, 
    0.41142273f, -0.05871013f, 0.21598274f, 0.20178027f, -0.24073622f, -0.26565129f, -0.16500907f, 0.00770319f, 
    -0.24562940f, -0.14991747f, -0.40116733f, 0.32527250f, 0.13327904f, -0.00573654f, 0.13283531f, 0.13022871f, 
    -0.08853472f, -0.23932526f, 0.02220307f, -0.02573485f, 0.05717725f, 0.28954750f, -0.13122937f, -0.12114996f, 
    -0.18063395f, 0.00349878f, 0.04316035f, 0.03469516f, 0.24965426f, 0.09416685f, 0.43486303f, -0.20376986f, 
    0.19587396f, -0.07754113f, 0.06329401f, 0.02398502f, 0.01981486f, -0.10938567f, -0.03456479f, 0.00018550f, 
    0.26140717f, 0.02643025f, -0.49870062f, -0.38079390f, 0.02842782f, -0.23647711f, 0.38057011f, 0.06037546f, 
    0.32592788f, 0.09469090f, -0.43340403f, 0.55455613f, -0.53127742f, -0.06222995f, 0.17462495f, 0.23132278f, 
    0.26676962f, -0.17034680f, -0.08945198f, 0.00488422f, -0.27498695f, -0.11397317f, -0.22519124f, -0.21283002f, 
    -0.36355340f, -0.09867729f, -0.09700183f, -0.02400612f, 0.00129268f, 0.21512401f, 0.10446245f, 0.12207972f, 
    0.06986491f, -0.15852073f, 0.20147489f, -0.03298011f, -0.20114496f, 0.06137400f, -0.02377611f, 0.04981567f, 
    0.10352003f, 0.24948902f, -0.09635193f, -0.15532269f, -0.19489889f, 0.05598061f, 0.25470543f, 0.65197361f, 
    0.25440374f, 0.21095620f, 0.00590570f, 0.01644522f, 0.00780757f, 0.00343162f, 0.05377452f, -0.46314850f, 
    0.11405445f, 0.37019089f, 0.04800719f, -0.38917395f, 0.20859306f, 0.08323827f, 0.07894416f, -0.09070258f, 
    0.10009453f, 0.04505597f, -0.06114651f, 0.07537793f, 0.06022017f, 0.02196320f, -0.12965944f, -0.09804789f, 
    -0.02005738f, 0.06487161f, 0.39362711f, -0.11870397f, 0.00923530f, 0.11606715f, -0.00132406f, -0.04564183f, 
    -0.01204096f, -0.14948323f, 0.20933554f, -0.04950542f, 0.10969961f, -0.13431969f, -0.27325955f, -0.01608068f, 
    0.27657610f, 0.04807686f, 0.06341711f, 0.10266133f, -0.26986390f, -0.19886054f, -0.08147904f, 0.06618420f, 
    0.08880413f, -0.01408875f, -0.11014428f, 0.00020346f, -0.06027163f, 0.12408964f, 0.09825528f, -0.03518599f, 
    -0.00142703f, 0.00347461f, -0.08816971f, -0.01525066f, -0.04515728f, 0.19610415f, -0.08435754f, 0.26941887f, 
    0.13253464f, 0.01825949f, -0.12257947f, -0.01619741f, 0.09517992f, 0.06162117f, 0.05866070f, 0.09849974f, 
    0.10217483f, 0.07719488f, 0.11492843f, -0.08640826f, -0.32604164f, -0.04101113f, 0.22310680f, 0.16177522f, 
    -0.13279659f, -0.07584773f, 0.12475482f, -0.19155702f, -0.09843390f, -0.08531071f, 0.03111089f, 0.01709983f, 
    0.49143478f, -0.09803678f, 0.02611641f, 0.27178961f, 0.07364637f, 0.15314718f, 0.28310603f, 0.09623322f, 
    0.11681829f, -0.27173591f, 0.01992522f, -0.02756818f, -0.01555864f, 0.24285984f, 0.07901441f, -0.01558497f, 
    0.17146344f, 0.06296866f, 0.10553052f, -0.06373356f, -0.01261012f, -0.17465487f, -0.13262069f, -0.01973728f, 
    -0.20648678f, -0.41725180f, 0.11200458f, 0.42604491f, -0.08544552f, -0.11652801f, 0.36251205f, 0.01241271f, 
    0.03702690f, -0.15169297f, 0.08730614f, -0.06761909f, -0.28930950f, 0.11150450f, 0.15607862f, -0.23708704f, 
    -0.20645897f, -0.22496852f, -0.01513781f, -0.02337739f, -0.33701620f, 0.22709887f, 0.04964027f, -0.17148791f, 
    0.17707272f, 0.24460721f, -0.08691233f, -0.17994724f, -0.21683314f, 0.62429303f, 0.56178641f, 0.10414887f, 
    -0.00660060f, -0.05014567f, 0.11969643f, 0.21502599f, 0.13670540f, -0.39036834f, 0.28572834f, 0.11459108f, 
    0.07523780f, 0.01082022f, 0.44181877f, 0.27721670f, 0.04889029f, -0.26854226f, 0.08753429f, 0.03198331f, 
    -0.41062659f, 0.21055260f, -0.18008849f, -0.16766492f, -0.70685345f, 0.04886623f, 0.36465609f, -0.01326640f, 
    0.11637165f, -0.04230415f, -0.10499647f, 0.13639380f, 0.12455319f, 0.04397201f, -0.05023835f, 0.23921244f, 
    0.04610800f, 0.29530305f, 0.24927408f, 0.06351749f, -0.34479046f, 0.19616766f, 0.05460977f, 0.15293737f, 
    0.01269266f, 0.28541574f, -0.09499200f, -0.04196762f, -0.03302153f, -0.04694111f, -0.02902997f, 0.02379717f, 
    0.17114261f, 0.03263840f, 0.22236201f, 0.22892819f, 0.10131733f, 0.07609438f, -0.18062070f, 0.16098103f, 
    0.07668637f, 0.22026221f, 0.28867361f, 0.05776490f, -0.01987095f, 0.09326266f, 0.18697095f, 0.03548635f, 
    0.14688843f, -0.04974712f, 0.05827386f, 0.26222667f, -0.00534613f, 0.24934496f, -0.01626438f, 0.02464293f, 
    0.35674414f, 0.28506374f, 0.32709977f, -0.41674975f, 0.29691601f, 0.02966532f, 0.09109632f, -0.16671416f, 
    0.18684359f, -0.05428299f, 0.16370642f, -0.22109504f, -0.14846152f, 0.07742566f, 0.07605855f, -0.13680325f, 
    -0.40382510f, 0.12917104f, -0.13033572f, -0.29971156f, -0.03762828f, 0.06014987f, -0.12869678f, 0.12334078f, 
    0.05074287f, -0.03746178f, -0.01850408f, -0.01324814f, -0.07316701f, 0.03479962f, 0.10449853f, -0.08005592f, 
    0.17139292f, 0.24458326f, -0.13280201f, -0.07263532f, -0.05265032f, 0.16771442f, 0.24554133f, 0.36530828f, 
    0.09495544f, 0.01401048f, 0.02852579f, 0.02408453f, -0.13819692f, 0.09084301f, 0.05174728f, -0.44297636f, 
    0.19630237f, -0.35281223f, 0.03036350f, -0.13058250f, 0.19048193f, 0.25990412f, -0.03471285f, 0.12570384f, 
    -0.13745102f, -0.10262565f, 0.07058361f, 0.09076940f, 0.11446800f, -0.03255489f, 0.13246720f, -0.09341633f, 
    -0.06230771f, 0.18530896f, -0.07873391f, -0.07166901f, 0.08988166f, -0.00947160f, 0.27734989f, -0.06645554f, 
    -0.14455195f, -0.01548720f, -0.01396105f, 0.00375081f, 0.14417543f, -0.00714186f, 0.35023937f, 0.07414573f, 
    0.16073011f, -0.02462305f, 0.01348198f, 0.26718959f, -0.08469433f, -0.25003830f, -0.23162249f, 0.33415809f, 
    0.06141659f, -0.03449744f, 0.20873865f, -0.21672195f, -0.35718411f, 0.01710935f, 0.22974218f, -0.02435516f, 
    0.03025775f, -0.00318429f, -0.05134574f, -0.03334178f, -0.03855969f, -0.05283385f, -0.08327556f, 0.15849873f, 
    0.03690793f, -0.06493843f, 0.10945660f, 0.19108598f, -0.00230884f, 0.13980830f, -0.02011533f, 0.26980940f, 
    0.21231666f, 0.06093780f, 0.37354937f, 0.01817852f, -0.36589971f, -0.09045587f, 0.17942122f, 0.03921873f, 
    -0.25174826f, 0.01491657f, 0.20617293f, 0.09766115f, 0.03626254f, 0.16039960f, -0.07578736f, -0.22105457f, 
    0.78945488f, 0.01518325f, -0.19334501f, -0.18040672f, 0.10543743f, 0.05697120f, 0.06541018f, 0.21371272f, 
    -0.00814125f, 0.40746409f, 0.23639610f, -0.07850996f, 0.13835035f, -0.04344441f, 0.12813504f, 0.11242751f, 
    -0.05025684f, 0.38498682f, 0.27429831f, 0.30971691f, 0.09315242f, 0.09476941f, -0.16184452f, 0.16460539f, 
    0.10960369f, -0.17306802f, -0.05372347f, -0.64904171f, 0.36325556f, -0.13389935f, 0.06941552f, 0.07383540f, 
    -0.16726699f, -0.25859931f, 0.19545086f, 0.11188266f, 0.03979208f, 0.00400077f, -0.03767818f, -0.15739200f, 
    -0.06747333f, -0.26591623f, -0.06210576f, 0.05257783f, -0.06949773f, 0.00173244f, -0.00461729f, 0.13282642f, 
    -0.15380447f, -0.10521107f, -0.23807903f, -0.01288056f, -0.32760826f, 0.08387777f, 0.11740008f, 0.06907897f, 
    0.14173441f, -0.45192504f, 0.07013567f, 0.08276575f, 0.12013782f, 0.06213406f, 0.06008358f, 0.25418913f, 
    0.01643746f, -0.10587600f, 0.07116857f, -0.10750917f, 0.31423217f, 0.24966080f, -0.01888296f, 0.08859182f, 
    -0.03854749f, -0.31637695f, 0.10649958f, 0.15174578f, -0.47781318f, -0.18634392f, 0.17986512f, -0.00207114f, 
    0.20940071f, 0.01331591f, -0.04951790f, -0.06912281f, 0.09861889f, -0.10281541f, 0.23177177f, 0.14825603f, 
    0.12416152f, -0.03555665f, 0.07236950f, -0.03620318f, 0.19052410f, 0.02690087f, 0.20288526f, 0.10057606f, 
    0.14629290f, -0.00803238f, 0.10914826f, 0.01931878f, 0.00964279f, -0.10116899f, 0.22845739f, 0.11606479f, 
    -0.17249350f, -0.07951836f, 0.09218467f, 0.03099547f, -0.00339513f, -0.30323145f, -0.07208586f, 0.07274102f, 
    0.11729809f, -0.24201171f, 0.15529577f, -0.01600194f, 0.07449637f, 0.12815313f, 0.02543174f, -0.10389829f, 
    0.13132091f, 0.02424833f, 0.22740479f, 0.10102263f, -0.01473678f, 0.35334241f, -0.17101368f, 0.12283830f, 
    0.20737289f, 0.10126641f, 0.42325121f, -0.47061709f, -0.23293726f, 0.01514130f, -0.13204408f, 0.05818668f, 
    -0.05279983f, -0.02579509f, -0.08951701f, -0.06574491f, -0.06721538f, -0.08543781f, -0.05531022f, -0.06017342f, 
    -0.08335783f, 0.03194297f, 0.08473588f, 0.04132234f, 0.07535058f, -0.08558328f, 0.04623467f, 0.05419393f, 
    0.01547536f, -0.01746143f, -0.03152332f, -0.00989147f, 0.05801561f, 0.07485647f, -0.07794441f, -0.06534286f, 
    0.05151774f, -0.04726648f, 0.07228244f, 0.06859184f, -0.02313242f, 0.03658308f, -0.00258025f, 0.05470112f, 
    -0.08074926f, -0.05827139f, 0.04095185f, -0.05247990f, 0.07955319f, 0.04450623f, 0.06483419f, 0.05714578f, 
    -0.05451178f, 0.00955821f, -0.03222530f, 0.07378185f, 0.02282674f, 0.02149475f, 0.08046301f, 0.07306191f, 
    -0.09432191f, 0.07622841f, -0.06480418f, -0.01183923f, -0.08181525f, -0.04154189f, -0.05234698f, -0.04594645f, 
    -0.08565887f, -0.01985371f, 0.08652996f, -0.08566896f, -0.06938412f, 0.00070944f, 0.01103320f, 0.06030463f, 
    -0.02290910f, 0.07380372f, -0.05002328f, 0.01750010f, -0.03416202f, -0.06921778f, 0.02920059f, -0.04840805f, 
    -0.08193374f, -0.01855263f, 0.02848959f, 0.01907263f, -0.06049865f, -0.04416590f, -0.08398928f, -0.07262840f, 
    -0.08033293f, -0.04654623f, -0.04926484f, -0.04643365f, -0.04322866f, -0.08336935f, 0.02301636f, 0.07157974f, 
    0.08043356f, 0.04654337f, -0.09175825f, -0.06297042f, -0.03328704f, 0.07713307f, -0.05939052f, 0.05074383f, 
    0.02164690f, -0.05760382f, -0.05838968f, 0.03979117f, -0.07175417f, -0.08586027f, -0.08772629f, 0.02544724f, 
    0.00836921f, 0.06265935f, 0.03720454f, 0.04898648f, -0.06256746f, -0.09292222f, 0.05737448f, -0.08626520f, 
    -0.06645876f, -0.03138131f, -0.05821329f, -0.00009940f, 0.05472112f, 0.07087836f, 0.03967364f, -0.08945957f, 
    -0.08400303f, -0.01250771f, -0.07414690f, -0.03506709f, -0.08481339f, -0.04215640f, 0.02722225f, -0.00291817f, 
    0.03273673f, -0.20919596f, -0.28479525f, 0.18381429f, 0.02739220f, 0.39931878f, 0.07115336f, 0.15577307f, 
    0.19404487f, -0.29673648f, -0.32135472f, -0.12555438f, -0.24229996f, -0.12806065f, 0.12404098f, -0.18047443f, 
    -0.23313248f, -0.06688996f, 0.05522845f, 0.57236546f, -0.00184665f, -0.21142505f, 0.12554145f, -0.06726266f, 
    0.31967327f, 0.15099680f, 0.03923097f, -0.06435025f, 0.29226133f, 0.21892741f, 0.22545406f, -0.08543945f, 
    -0.10832904f, 0.09200724f, 0.32470697f, -0.00417474f, -0.02750058f, 0.35682109f, -0.01002963f, -0.36019632f, 
    0.22934049f, 0.26064807f, 0.07371401f, -0.23820907f, -0.06625478f, 0.30246022f, 0.26487932f, 0.11534155f, 
    -0.04619467f, 0.41712144f, 0.06452028f, 0.02724940f, -0.18198712f, -0.20568413f, -0.06850539f, -0.06252751f, 
    0.00823201f, 0.16356249f, 0.11938893f, 0.16875523f, 0.04756445f, -0.24373563f, 0.15194596f, -0.03866231f, 
    0.06109760f, 0.44420719f, 0.00713830f, 0.03310557f, -0.68910843f, 0.78827149f, 0.02613125f, -0.00473147f, 
    -0.05206246f, 0.05214152f, -0.06126430f, 0.13444276f, 0.23468165f, -0.14462921f, -0.16375110f, -0.20916484f, 
    -0.07806665f, 0.29027745f, 0.39230326f, -0.00349422f, -0.07541379f, 0.09132928f, -0.31490645f, -0.23474093f, 
    -0.14737697f, 0.26018807f, -0.03319766f, 0.04756022f, -0.07634397f, -0.24812146f, 0.07226523f, 0.03124571f, 
    0.28801289f, -0.07638361f, 0.06772814f, 0.16160107f, 0.05288378f, 0.17041326f, -0.18124156f, 0.01438687f, 
    -0.00168526f, 0.23517425f, 0.14318672f, 0.05859494f, 0.02816835f, -0.14212063f, 0.10198797f, 0.13769913f, 
    -0.19497424f, -0.06558747f, 0.08472270f, 0.33853778f, -0.04492548f, -0.21393082f, -0.29563516f, 0.07722854f, 
    0.13688172f, 0.09386245f, 0.14172035f, -0.49358478f, 0.19995816f, -0.08220930f, -0.07776722f, -0.23576604f, 
    -0.04902861f, -0.03757317f, 0.04151503f, 0.04578409f, -0.02677640f, -0.09621992f, -0.06633067f, -0.10232884f, 
    0.08815747f, -0.05157169f, 0.04972972f, -0.07464986f, 0.08047362f, -0.05429156f, -0.07278170f, 0.03516273f, 
    0.05041786f, 0.00083945f, -0.08598815f, -0.01880918f, -0.04209858f, -0.03055887f, 0.00475210f, -0.07115530f, 
    0.04030893f, -0.04850226f, 0.00768017f, -0.08565608f, -0.08644083f, 0.05491866f, -0.02198624f, 0.03582805f, 
    -0.10187459f, 0.01910037f, -0.11425340f, -0.07497421f, -0.05690254f, -0.06880640f, 0.06753765f, -0.01446735f, 
    0.03015330f, 0.05873384f, -0.08944243f, 0.02198509f, -0.06611694f, -0.01341223f, 0.07777936f, -0.07361858f, 
    -0.01630104f, -0.05889872f, 0.03859543f, 0.05481738f, 0.02411763f, -0.10172246f, 0.07316362f, 0.02476404f, 
    0.08078746f, -0.04834776f, 0.08415249f, -0.00984805f, -0.00386617f, -0.06699609f, -0.06250546f, -0.09364918f, 
    -0.06643894f, -0.01129653f, 0.03030860f, 0.02405158f, 0.04682108f, -0.11722877f, 0.10934614f, 0.05176551f, 
    0.03709903f, -0.05329052f, -0.05830785f, -0.08166520f, -0.00666639f, -0.00295776f, 0.06141797f, -0.11914808f, 
    0.01605990f, 0.05833553f, -0.04339194f, -0.12192999f, -0.01630527f, -0.05831755f, -0.06204098f, 0.04850845f, 
    -0.10000038f, -0.06483855f, 0.04354953f, 0.05920099f, 0.03444532f, 0.03630026f, 0.01520135f, 0.00739021f, 
    -0.01890388f, -0.00343849f, -0.03356043f, -0.05153236f, 0.01038689f, -0.06509835f, -0.03685389f, -0.01666672f, 
    -0.00402089f, 0.07981230f, -0.05261916f, -0.06342147f, 0.00899945f, -0.06550304f, 0.02902718f, -0.11500762f, 
    -0.08170758f, -0.08456033f, 0.01410707f, 0.05639836f, 0.07592518f, -0.02089132f, 0.10621043f, 0.01925812f, 
    -0.08117722f, -0.09226316f, -0.04363054f, 0.01255046f, -0.01032611f, -0.03645848f, 0.01427114f, -0.02419319f, 
    0.25247529f, -0.05464380f, -0.06114501f, 0.37112901f, -0.11213826f, -0.10736754f, -0.22415149f, -0.12559070f, 
    -0.29119360f, -0.21796314f, -0.13573244f, -0.02516495f, -0.11204527f, 0.10318611f, 0.17749754f, 0.07028218f, 
    0.01411321f, 0.29556656f, 0.28239793f, 0.27019867f, -0.26138356f, 0.04632180f, -0.06270651f, -0.05259490f, 
    0.29827520f, 0.17481184f, -0.36787355f, -0.06897958f, -0.21528795f, 0.02390834f, -0.02224369f, 0.16197640f, 
    0.31668705f, 0.19884248f, 0.12846333f, -0.01366108f, 0.09690882f, -0.14586729f, -0.08490299f, -0.05206719f, 
    0.14016929f, -0.02622518f, 0.23201151f, 0.13586570f, 0.07820518f, -0.08619720f, 0.02518858f, -0.02107789f, 
    0.11596322f, 0.41491824f, -0.13674168f, 0.06342939f, -0.03707932f, 0.12504119f, -0.26141599f, 0.01484584f, 
    0.08048265f, 0.19177005f, 0.16236579f, -0.03175039f, 0.20155956f, 0.18884094f, -0.02744605f, 0.21387161f, 
    0.07397936f, 0.24519475f, 0.22331111f, -0.12477753f, -0.10146394f, -0.09163325f, -0.17618997f, 0.07545269f, 
    -0.32823649f, -0.07351153f, 0.04285344f, 0.01143357f, -0.14662290f, 0.19389935f, 0.11281066f, -0.09267899f, 
    0.03445655f, -0.02840492f, 0.04833623f, 0.06518611f, 0.01492674f, 0.00477482f, 0.00830529f, -0.06255719f, 
    -0.04680907f, -0.29220626f, -0.02217818f, -0.08622956f, 0.00187696f, -0.10042382f, -0.15033375f, 0.16706267f, 
    0.23189339f, -0.07709388f, -0.17441382f, -0.09301449f, -0.04204303f, 0.22223428f, 0.04286009f, 0.25953475f, 
    -0.25494558f, 0.15093745f, -0.23433514f, 0.03356978f, 0.17928421f, 0.14491545f, -0.04188450f, 0.31265023f, 
    -0.01694112f, -0.03034199f, 0.17867337f, -0.00381735f, -0.01719024f, -0.22248538f, 0.14266977f, 0.04515319f, 
    -0.35484087f, -0.00781967f, -0.41667184f, 0.26528564f, 0.10170871f, 0.27769774f, 0.07943251f, 0.01238820f, 
    -0.07522449f, -0.08209870f, 0.05546445f, -0.00783852f, -0.06526110f, 0.00504664f, -0.08205103f, 0.00241556f, 
    0.00553561f, 0.02217065f, 0.00484433f, 0.05643319f, -0.07304364f, 0.04278598f, 0.03900957f, 0.04730322f, 
    -0.05864452f, -0.05221491f, -0.08893684f, -0.04630176f, -0.07735606f, 0.04707995f, 0.06988281f, -0.07984091f, 
    0.03372157f, -0.03832221f, 0.05810266f, -0.00191516f, -0.07734395f, -0.08155178f, 0.01723871f, -0.00334552f, 
    0.04588479f, -0.05455619f, 0.00791656f, 0.04305449f, -0.05496340f, -0.02171987f, -0.04701460f, -0.03529334f, 
    0.03044802f, -0.00097068f, -0.00757713f, 0.00398613f, -0.00192144f, -0.08075667f, -0.06718035f, 0.03929030f, 
    0.04568706f, 0.04639077f, -0.07572567f, 0.03540167f, -0.02058805f, -0.07743952f, 0.07059989f, 0.02938316f, 
    -0.05779867f, 0.04131414f, 0.03345959f, -0.04594243f, 0.02604750f, -0.01772038f, -0.01834990f, 0.00795711f, 
    -0.04384860f, 0.01279128f, -0.09527054f, 0.04516217f, 0.00664628f, 0.01212514f, -0.03975579f, 0.02059492f, 
    -0.03887799f, 0.07168393f, -0.07012535f, -0.06693202f, -0.03959817f, 0.02037801f, -0.05618014f, -0.02758177f, 
    0.05475098f, -0.02637034f, -0.05129370f, -0.08679315f, -0.07473020f, 0.04954641f, -0.09597025f, 0.03158489f, 
    -0.02133751f, -0.04691998f, 0.00741761f, -0.01003052f, 0.08344331f, 0.00839609f, -0.01145965f, -0.05756172f, 
    -0.03201462f, 0.01701116f, 0.02162598f, 0.00756709f, 0.00173584f, -0.09380946f, 0.02403961f, -0.00408681f, 
    -0.03248074f, 0.07973479f, 0.05896370f, -0.01261480f, -0.04657135f, 0.06611796f, -0.02870733f, -0.07789197f, 
    0.00581136f, -0.02684600f, -0.00784522f, 0.05956007f, 0.05433246f, -0.06251857f, -0.09182337f, -0.06031119f, 
    -0.03085369f, -0.07933777f, 0.05970790f, -0.05314853f, 0.02731266f, 0.05856396f, -0.00083591f, 0.01244523f, 
    -0.07963378f, 0.00621524f, 0.04134635f, 0.03567962f, -0.00258079f, -0.06411109f, -0.09535899f, -0.08380184f, 
    -0.04661211f, -0.00596129f, 0.01417880f, 0.00663284f, -0.11635423f, 0.03882689f, -0.05265881f, 0.03147412f, 
    -0.06215451f, -0.04545172f, -0.04692822f, 0.05217848f, -0.05692041f, -0.06088057f, 0.05370416f, -0.03441973f, 
    -0.08584646f, -0.07584821f, 0.06552400f, -0.08204846f, 0.04366770f, 0.02497419f, -0.03830668f, -0.00622812f, 
    -0.02865903f, 0.01838835f, -0.05494225f, 0.01649105f, 0.03870881f, -0.02455526f, -0.03556556f, 0.03151948f, 
    -0.11536505f, -0.08270828f, -0.04557883f, -0.04477001f, -0.01667568f, -0.08398167f, -0.02565716f, -0.00402757f, 
    -0.04445200f, 0.00138234f, -0.00251562f, -0.10227217f, -0.09168272f, 0.02688019f, -0.04910736f, -0.02918287f, 
    0.00725323f, -0.00515486f, 0.03124273f, 0.06737971f, 0.02801785f, 0.04650928f, 0.00923118f, -0.12206797f, 
    -0.02151374f, -0.09566851f, 0.04575638f, -0.00789475f, 0.07926689f, -0.01503292f, -0.07852623f, -0.05299794f, 
    -0.09091295f, -0.06266657f, -0.00819161f, -0.07694133f, 0.03831099f, 0.01500866f, 0.02551791f, -0.01625139f, 
    -0.03976266f, -0.09268570f, -0.01077413f, -0.09027015f, -0.04279183f, -0.05037599f, 0.05661257f, -0.10647600f, 
    -0.05988060f, 0.04187731f, -0.09048191f, 0.02106442f, -0.08151662f, -0.01194930f, -0.07888684f, -0.00637412f, 
    0.03850212f, -0.00459845f, -0.03600305f, -0.10116216f, 0.03267162f, -0.03627435f, -0.05781177f, -0.03641002f, 
    -0.04389967f, 0.03043949f, 0.05987453f, -0.06418134f, 0.02399236f, -0.09141784f, -0.08957600f, 0.02003199f, 
    -0.11341915f, -0.01021474f, 0.03251918f, -0.01656825f, 0.01187330f, 0.04672515f, -0.11443748f, 0.03491295f, 
    0.00148066f, 0.00563739f, -0.04168929f, 0.06601236f, -0.00361251f, -0.10184383f, 0.01306064f, -0.05085623f, 
    -0.03403912f, -0.01094422f, -0.01523074f, -0.04747927f, -0.01303643f, -0.08456985f, -0.02180121f, -0.02523877f, 
    0.04711485f, 0.04278270f, -0.09374813f, -0.00629218f, -0.06579055f, -0.00197591f, 0.05419581f, -0.02491597f, 
    -0.03616375f, -0.05192209f, 0.01608221f, -0.06029820f, -0.05677839f, -0.05149163f, -0.07839122f, -0.05698387f, 
    0.01310114f, -0.09652611f, 0.00193734f, 0.04759522f, -0.01734659f, -0.06608482f, 0.01535054f, -0.05005967f, 
    -0.06136924f, -0.08512445f, -0.02324086f, -0.00944022f, 0.03091037f, 0.04528213f, 0.07648861f, -0.00100938f, 
    0.05783458f, 0.08393277f, -0.03425270f, 0.00619867f, -0.04619218f, 0.05516480f, 0.01752777f, -0.06869690f, 
    -0.09709863f, -0.04925478f, -0.08049797f, 0.03140149f, 0.01575871f, 0.03902730f, 0.07619502f, 0.01885979f, 
    0.06763943f, -0.00352080f, 0.00093797f, -0.05859799f, -0.07537329f, 0.04247189f, 0.06005323f, -0.00419093f, 
    0.05716281f, -0.03632905f, -0.08509330f, -0.04264749f, -0.01114575f, -0.06773941f, 0.01733199f, 0.05223340f, 
    0.06304114f, 0.03587077f, -0.06403050f, -0.01131130f, -0.05856101f, 0.01461057f, 0.03942101f, 0.00749838f, 
    0.00317159f, -0.02488415f, 0.08025949f, 0.06417337f, -0.00103917f, -0.03340602f, -0.00805331f, -0.02974525f, 
    -0.05016192f, -0.07632889f, -0.08952998f, -0.00261715f, 0.03506598f, -0.02904840f, -0.01182418f, -0.00647185f, 
    -0.00515141f, -0.00824249f, 0.02081232f, -0.02510088f, 0.05288465f, 0.02861128f, 0.07337914f, -0.01936050f, 
    -0.03901577f, 0.05239022f, 0.03355468f, 0.00014719f, -0.01173900f, -0.04055937f, 0.01059302f, -0.08349326f, 
    0.00379122f, 0.00901239f, -0.06627070f, 0.01089838f, -0.03967430f, -0.08970971f, -0.05678476f, -0.06314029f, 
    -0.08050769f, -0.04337638f, -0.06223927f, -0.06312769f, 0.06273947f, 0.01413320f, -0.07355095f, -0.10327002f, 
    -0.13516477f, 0.18357220f, 0.13739862f, 0.25428066f, 0.30791363f, -0.17902435f, -0.19482350f, 0.29752931f, 
    -0.05040623f, 0.19984269f, 0.15811263f, -0.03558587f, 0.00683717f, 0.04533381f, 0.13174172f, 0.02964337f, 
    -0.24438508f, 0.03224324f, -0.02456099f, -0.13095732f, -0.50990450f, 0.13199346f, -0.10051903f, 0.00013229f, 
    0.08851939f, -0.16095112f, -0.01672688f, -0.06033790f, -0.06497449f, 0.13831754f, -0.42721245f, -0.18179715f, 
    -0.16190936f, -0.07350182f, 0.03427475f, 0.04936131f, 0.01850286f, -0.13531339f, 0.05985667f, 0.12485533f, 
    0.07377476f, 0.16110663f, 0.23236331f, -0.11918339f, -0.17385639f, 0.13495494f, 0.01926462f, -0.04032122f, 
    0.01718778f, 0.05795275f, 0.08738355f, 0.17326610f, 0.01520731f, 0.12275714f, -0.15035340f, 0.15623088f, 
    -0.01831112f, -0.00727955f, -0.02350896f, 0.08661898f, -0.10390008f, -0.03693072f, 0.12011503f, 0.06369622f, 
    0.18282208f, 0.23698972f, 0.02276696f, -0.12040796f, 0.16818601f, -0.11255047f, 0.40713441f, 0.06482826f, 
    -0.27763769f, -0.06422432f, -0.18903033f, -0.03695313f, 0.34278396f, 0.07835897f, -0.07877583f, -0.31974304f, 
    0.07262864f, -0.23283891f, -0.27513906f, 0.26694238f, 0.04673144f, 0.02467893f, -0.24159679f, -0.28385851f, 
    -0.08640450f, 0.12235328f, 0.15692939f, 0.02113854f, 0.02883360f, 0.05117730f, -0.06031330f, -0.16683479f, 
    0.22787541f, 0.00451735f, 0.16923273f, -0.04614090f, 0.09315684f, 0.20004325f, -0.25328293f, 0.05788998f, 
    0.03855227f, 0.37918910f, -0.00735800f, -0.04726764f, 0.04426640f, 0.26819536f, -0.07673934f, -0.11498683f, 
    -0.24936251f, 0.02024248f, -0.41105831f, 0.15518320f, -0.00455205f, -0.17730038f, 0.06565345f, 0.17611726f, 
    -0.10018557f, -0.04862935f, -0.31135812f, -0.11752712f, 0.04736017f, -0.13183297f, -0.42340875f, -0.02128582f, 
    0.12298814f, -0.03406669f, 0.12087623f, -0.08906791f, 0.02820811f, 0.02046194f, 0.03272894f, 0.01206882f, 
    -0.10306053f, 0.40264443f, 0.04986978f, -0.12202218f, -0.14689717f, -0.03573327f, -0.18039560f, 0.20848058f, 
    0.00818265f, -0.36169365f, 0.07923650f, 0.34952232f, 0.49427852f, -0.06462601f, -0.23924306f, 0.04565671f, 
    0.19001642f, 0.18931660f, 0.02932484f, -0.16126367f, 0.21770550f, -0.08614805f, 0.10362185f, -0.01362720f, 
    0.00291932f, -0.21889651f, -0.20204075f, 0.02855076f, 0.01814507f, -0.11580855f, -0.07705750f, 0.06898972f, 
    -0.19033132f, 0.06675921f, 0.05612112f, -0.08045448f, -0.09079491f, 0.48406187f, 0.30104354f, -0.18956141f, 
    0.02243953f, 0.02074111f, 0.06308608f, 0.10918820f, 0.15408435f, -0.13550659f, -0.25090775f, -0.00714584f, 
    -0.07305979f, -0.18418784f, 0.51559913f, 0.08856155f, -0.46424371f, -0.13574077f, 0.23673786f, 0.16177392f, 
    0.10184019f, 0.17613530f, 0.21197656f, 0.02332387f, 0.23710179f, 0.12043602f, 0.56479836f, 0.04538947f, 
    -0.07557135f, -0.07213195f, -0.36010274f, -0.05418227f, 0.03805040f, 0.01259335f, -0.08824526f, 0.04399506f, 
    0.19570553f, -0.11246315f, 0.32395774f, -0.08979916f, -0.09002474f, 0.14431153f, 0.24650517f, -0.02707626f, 
    -0.02822347f, -0.13734441f, 0.08022526f, -0.06133790f, -0.08031677f, -0.05278478f, -0.16645026f, 0.07419164f, 
    0.12280230f, 0.08973205f, 0.07297225f, 0.10211314f, -0.09369428f, -0.04283172f, -0.17467783f, 0.24158309f, 
    -0.23171695f, -0.00239649f, 0.11305070f, 0.00486950f, -0.22723147f, 0.25341606f, -0.05469327f, -0.12873417f, 
    -0.22729518f, -0.00845181f, -0.04578438f, 0.04542007f, 0.08606384f, 0.11920951f, -0.12143681f, -0.11844583f, 
    0.20474100f, -0.14009964f, 0.26389268f, -0.24566187f, 0.18347305f, 0.09291726f, -0.04328480f, 0.11538786f, 
    -0.07604797f, 0.05260623f, 0.19486785f, 0.26417553f, -0.00606862f, 0.12669107f, 0.36080861f, -0.01081625f, 
    -0.06804502f, -0.06489144f, 0.20066352f, 0.21654806f, -0.09644965f, -0.06099264f, 0.11859977f, -0.28756887f, 
    0.10422689f, 0.10983013f, 0.09807778f, 0.21464741f, 0.14343643f, 0.06700959f, -0.21414213f, -0.02421873f, 
    -0.15580626f, 0.06770795f, 0.16088478f, 0.17216721f, 0.37439823f, -0.39428005f, 0.12048420f, -0.43384704f, 
    -0.23562671f, 0.19318338f, 0.11274378f, -0.04895635f, 0.02074927f, -0.36090586f, 0.06124151f, 0.09009866f, 
    -0.10453691f, -0.04111990f, -0.03816432f, 0.82651359f, 0.32528648f, -0.30602476f, 0.17755480f, -0.08708274f, 
    0.01865237f, 0.10065959f, -0.21932450f, 0.00514560f, -0.07725909f, 0.08718421f, -0.06297793f, -0.16675223f, 
    0.07600035f, -0.19867866f, -0.51457053f, 0.36414808f, 0.01941224f, 0.03492882f, -0.34668243f, -0.01428223f, 
    -0.04204206f, 0.06636027f, 0.08979061f, 0.15423100f, 0.74071091f, 0.41027749f, -0.12534437f, -0.06103626f, 
    0.09966057f, -0.06202588f, -0.04992475f, -0.10093360f, -0.01708222f, 0.05175877f, -0.08039498f, 0.03415519f, 
    0.05380023f, 0.19636376f, 0.24597532f, 0.22393899f, -0.16521150f, -0.13772425f, -0.05694555f, 0.02025701f, 
    0.04179904f, -0.04296686f, 0.00854293f, 0.02593826f, -0.01949091f, 0.00949515f, 0.00849128f, 0.11630299f, 
    -0.06353328f, -0.07924628f, -0.28735650f, -0.36491159f, -0.07188275f, -0.08904048f, 0.04379275f, -0.23571849f, 
    -0.11234418f, -0.24115676f, -0.19815230f, -0.01624590f, 0.59317034f, -0.02214515f, -0.34671599f, 0.23160653f, 
    -0.35016486f, 0.02848893f, 0.09190004f, -0.04818543f, 0.08518055f, -0.01909899f, 0.22008298f, -0.02827465f, 
    -0.15157618f, -0.37654349f, -0.13785324f, 0.74505883f, 0.04895522f, -0.14394125f, -0.04128556f, 0.05923079f, 
    -0.04855309f, -0.04269713f, -0.04648728f, -0.15748091f, -0.08881859f, -0.03325379f, -0.01546455f, -0.16088705f, 
    -0.09351375f, -0.05208706f, -0.08507839f, -0.01155904f, -0.11333209f, -0.02256894f, -0.03879351f, -0.09436168f, 
    -0.05906773f, -0.04089554f, 0.02986290f, 0.09179297f, -0.07865785f, -0.11714544f, -0.06162409f, -0.07464879f, 
    -0.01453099f, 0.03524086f, -0.07596124f, -0.03928736f, -0.12563375f, -0.12193785f, 0.01301684f, -0.06455402f, 
    -0.00068766f, -0.01670717f, 0.02072591f, -0.07100359f, -0.08471575f, 0.01045006f, 0.00085445f, 0.14992554f, 
    0.02884951f, -0.13693367f, 0.03422234f, 0.02884871f, 0.05245995f, 0.06740072f, -0.02963901f, -0.03776964f, 
    -0.11334500f, -0.01679572f, -0.07072353f, 0.07647317f, -0.05983993f, -0.01749586f, 0.08227096f, -0.04589686f, 
    -0.01928723f, -0.11637333f, -0.03620787f, 0.02763376f, -0.07454988f, -0.03992217f, 0.02685705f, -0.06981079f, 
    -0.14799167f, 0.02849317f, -0.03918144f, -0.15463153f, 0.02107264f, 0.01496272f, 0.06087062f, -0.00510226f, 
    -0.10403386f, 0.05801494f, -0.12453352f, 0.01563985f, -0.02538881f, 0.08641034f, -0.05425753f, 0.07065123f, 
    -0.01479154f, 0.03924624f, -0.08063353f, 0.04663626f, -0.01852945f, 0.00612403f, -0.10539546f, -0.03009688f, 
    0.06207554f, -0.01264585f, -0.04338212f, -0.05477235f, 0.01841073f, 0.01240981f, -0.01345273f, -0.02029573f, 
    -0.00135749f, -0.08049929f, 0.03518643f, -0.06044213f, -0.05914050f, 0.00724275f, 0.04788460f, -0.03070496f, 
    -0.12854941f, -0.11007030f, -0.07252733f, -0.04853907f, -0.03127326f, -0.08296427f, 0.06928640f, -0.05144850f, 
    -0.10039447f, -0.06083407f, 0.02477194f, -0.08875663f, 0.08513138f, -0.03685215f, 0.03650580f, 0.02685988f, 
    0.00068670f, -0.16439782f, 0.05285565f, -0.00758141f, -0.08944670f, -0.02940930f, -0.06161976f, -0.07777171f, 
    -0.02023140f, -0.06146280f, -0.06797945f, 0.19207084f, -0.09077881f, -0.14956944f, -0.12440819f, 0.10480796f, 
    -0.35196522f, 0.06344082f, -0.11222398f, -0.15424481f, 0.04049959f, 0.20226304f, 0.15973777f, 0.08111154f, 
    0.02101343f, -0.18238726f, 0.19043104f, 0.00173116f, 0.00739585f, 0.07437880f, -0.22192372f, -0.02990823f, 
    0.14025913f, 0.36166188f, -0.05197899f, -0.10416242f, 0.27712321f, 0.12408172f, -0.02649506f, -0.22581083f, 
    0.16662751f, 0.00402793f, 0.12757988f, 0.02452352f, 0.07365941f, -0.20357724f, -0.04122443f, 0.05564174f, 
    -0.05056529f, 0.06323498f, 0.12605684f, 0.00800833f, -0.03161429f, 0.07475597f, 0.08773278f, -0.14736855f, 
    0.03313074f, -0.01314649f, 0.01103070f, 0.10016234f, 0.12248352f, 0.12764797f, -0.15158494f, 0.04416496f, 
    -0.00453015f, 0.02412177f, 0.28475684f, 0.13908969f, -0.00206526f, -0.20069055f, 0.15791154f, 0.10364749f, 
    0.12193242f, 0.03764368f, 0.23138148f, -0.05888440f, 0.24844731f, 0.71461493f, 0.18491204f, 0.05318582f, 
    -0.47189996f, 0.07375118f, 0.02692352f, 0.01211511f, 0.04389023f, -0.17657547f, -0.17595591f, 0.00497289f, 
    0.20271875f, -0.04028328f, -0.21495782f, -0.11992884f, 0.00500650f, 0.01771009f, -0.14720933f, -0.13277406f, 
    0.03228158f, 0.21190202f, -0.06649102f, 0.08267142f, -0.09884262f, 0.00747393f, -0.04909909f, 0.07936687f, 
    0.07572001f, 0.08097532f, -0.13186595f, 0.08670015f, 0.02774267f, 0.17676094f, -0.14091951f, 0.13151227f, 
    0.01324487f, 0.19752419f, -0.02580047f, -0.00259836f, -0.38703460f, 0.19888335f, 0.04618026f, -0.00061537f, 
    -0.39384964f, 0.07430016f, -0.02239526f, -0.00313605f, -0.01815458f, -0.01463822f, -0.04289483f, 0.00201773f, 
    -0.36850289f, -0.16532338f, 0.25633261f, 0.01534205f, 0.30939099f, 0.12571666f, 0.01303016f, 0.00821952f, 
    0.01173686f, -0.00739609f, -0.07301774f, 0.01625872f, 0.07390923f, 0.02099745f, -0.10939220f, -0.06630211f, 
    0.06209752f, -0.03419404f, 0.07293006f, 0.02601167f, -0.12527631f, 0.07540217f, 0.03314527f, 0.03821697f, 
    -0.03530211f, 0.05208991f, 0.04060435f, 0.00029926f, -0.09100956f, -0.10095175f, -0.02586002f, -0.08274852f, 
    0.06604302f, -0.00008589f, -0.02892346f, 0.05704633f, -0.06468560f, -0.00480524f, 0.01879549f, -0.09336590f, 
    -0.09323224f, -0.03273757f, 0.03294810f, 0.01360201f, 0.00594077f, -0.00406334f, -0.00551732f, 0.00226505f, 
    -0.09839311f, -0.10145222f, 0.02395078f, -0.09485264f, -0.01800296f, -0.10453096f, 0.04312060f, -0.01953887f, 
    -0.10421195f, 0.02092528f, -0.07194164f, -0.11042854f, -0.01229336f, -0.04762547f, -0.04909601f, -0.07894967f, 
    -0.01439856f, -0.06101710f, 0.02838867f, 0.01834052f, -0.00376183f, -0.04216976f, 0.02410774f, -0.09256028f, 
    -0.05725341f, -0.08773659f, -0.06786722f, -0.00355408f, 0.01724429f, 0.01519597f, 0.05236173f, -0.00860988f, 
    0.07227068f, -0.03718238f, 0.03610154f, -0.01320864f, -0.02064469f, -0.03696266f, -0.01184994f, -0.07205910f, 
    -0.12319635f, 0.02502746f, -0.00862624f, -0.09451949f, -0.06985507f, -0.08710805f, -0.03884255f, 0.00258820f, 
    -0.08646527f, -0.02010405f, -0.11285238f, 0.03890761f, 0.04036028f, -0.01410979f, 0.05221226f, -0.02526981f, 
    -0.03544683f, -0.00068202f, 0.02107479f, 0.05147382f, 0.04984902f, 0.01658912f, -0.06129196f, 0.00778252f, 
    0.02127490f, 0.04849580f, 0.03977748f, 0.00332936f, -0.02790239f, 0.02706542f, -0.00104665f, -0.11178748f, 
    0.01454694f, -0.07024898f, -0.07168796f, -0.07741003f, 0.06336314f, -0.09215260f, 0.01843880f, 0.01427433f, 
    -0.05825387f, 0.03305006f, -0.08578753f, -0.05368252f, -0.05088563f, -0.07822070f, 0.01973369f, -0.02862269f, 
    0.04193601f, -0.08127555f, 0.00243849f, 0.00884124f, 0.04669448f, -0.08065096f, -0.00997820f, 0.03752452f, 
    -0.02961623f, -0.05722470f, -0.00375291f, 0.01259443f, -0.10422941f, -0.03049641f, -0.02180150f, -0.07378471f, 
    0.06001443f, -0.04471568f, -0.02270638f, 0.05910831f, -0.09146616f, -0.09219620f, -0.02322964f, -0.05886270f, 
    -0.01332936f, 0.04685786f, 0.02911030f, 0.04819536f, 0.00660348f, -0.00623835f, 0.05600339f, -0.03736374f, 
    0.02801455f, 0.04427956f, -0.06294087f, -0.04686106f, -0.05447197f, -0.00379565f, 0.02204264f, -0.07451521f, 
    -0.03748640f, -0.00118532f, -0.00696378f, -0.04778820f, 0.02310454f, 0.05559722f, -0.02348692f, -0.08546819f, 
    -0.12189254f, -0.09367432f, -0.09639591f, -0.01502870f, -0.02939611f, -0.01083870f, -0.08959983f, -0.10406037f, 
    -0.02835011f, -0.02692020f, -0.02588124f, -0.07388411f, 0.02042281f, 0.03985285f, -0.00062818f, -0.07402901f, 
    0.01261338f, 0.04891264f, -0.03156101f, -0.01692711f, 0.05875048f, 0.03742032f, -0.06554501f, 0.08098478f, 
    -0.01202723f, -0.02515408f, -0.01321312f, -0.07015630f, -0.07297698f, -0.06283524f, -0.04574610f, 0.01451648f, 
    -0.07143315f, -0.08156396f, -0.08953144f, -0.09273343f, 0.01589393f, 0.03672012f, -0.10977388f, -0.05526319f, 
    -0.05397006f, 0.02404410f, -0.01260878f, -0.03132113f, -0.06163182f, -0.02190902f, -0.02205369f, -0.05809220f, 
    -0.08697773f, 0.07777492f, 0.01712644f, -0.07512101f, 0.02456009f, -0.06700428f, -0.08329949f, 0.05497940f, 
    0.01718301f, -0.02579440f, -0.09341688f, -0.01681882f, -0.03134929f, -0.02102994f, -0.09828536f, 0.01145255f, 
    -0.07587054f, -0.00879486f, 0.03121623f, -0.06070769f, 0.02621760f, 0.00065729f, -0.05356284f, -0.00808021f, 
    0.06356969f, -0.00628650f, 0.03960427f, -0.02520970f, -0.06829222f, -0.04688606f, 0.04727926f, -0.09531257f, 
    -0.19907582f, 0.15006231f, -0.12248007f, -0.18740764f, 0.32824093f, 0.26887780f, 0.38469768f, 0.24010369f, 
    0.06222853f, 0.36067098f, 0.32345551f, 0.00932227f, 0.06278548f, -0.14482784f, -0.24697198f, 0.11353269f, 
    0.10806328f, -0.49650881f, -0.18820857f, -0.00090443f, 0.08206277f, -0.15373327f, 0.21533832f, -0.04268724f, 
    -0.14501850f, 0.02389047f, 0.30339861f, 0.13596088f, -0.13429919f, -0.08169196f, 0.05240885f, -0.55229318f, 
    -0.17277816f, -0.10440651f, -0.04037642f, -0.03035277f, -0.21132311f, 0.03467255f, 0.03146735f, 0.01487663f, 
    -0.11463098f, 0.13144647f, -0.21564013f, -0.04530218f, -0.06515076f, 0.28861168f, 0.21022765f, 0.12011348f, 
    -0.00287617f, -0.26519066f, 0.19246465f, 0.08241288f, -0.02603358f, -0.10455968f, 0.01792608f, 0.23079365f, 
    -0.05911642f, -0.07465819f, 0.01976655f, 0.10160092f, -0.01041472f, -0.20182861f, 0.01939808f, 0.07367733f, 
    -0.16593204f, -0.09477653f, -0.07273825f, 0.12385415f, -0.29630670f, 0.03312452f, 0.50196213f, -0.08184059f, 
    -0.03535690f, 0.07750450f, -0.24148224f, -0.01304372f, 0.24147768f, -0.07227133f, -0.09545958f, 0.16021192f, 
    0.12972778f, 0.13721271f, 0.02985879f, 0.03490434f, -0.02096638f, 0.03877670f, -0.02433509f, 0.10435215f, 
    0.09495590f, 0.58135635f, 0.10469779f, 0.03080391f, -0.11006859f, -0.10476789f, 0.25538209f, -0.01219371f, 
    0.01917916f, -0.06278223f, 0.30487332f, 0.23647384f, -0.02819206f, -0.05960316f, 0.00613182f, -0.13211720f, 
    0.01478440f, 0.18084916f, 0.14402655f, -0.08470156f, -0.30640593f, 0.15256570f, 0.13505025f, -0.07607370f, 
    -0.12825628f, 0.05892890f, 0.02951284f, 0.07431170f, 0.00630039f, 0.28814802f, -0.17494810f, 0.07606387f, 
    0.00130731f, 0.00410845f, 0.47208968f, -0.31599075f, 0.17902330f, -0.14724332f, 0.14240746f, -0.14001092f, 
    -0.32060409f, 0.04906281f, -0.39634296f, 0.05449312f, -0.20002976f, 0.20076855f, -0.02411963f, -0.23302156f, 
    -0.03662271f, -0.13464381f, -0.03919060f, 0.10683727f, 0.29429817f, 0.06287189f, -0.07113032f, -0.05845730f, 
    0.20226799f, -0.10874046f, -0.14812222f, -0.80600268f, -0.13896872f, 0.12958166f, -0.24689789f, 0.06041707f, 
    -0.11655685f, 0.23680840f, 0.14703175f, 0.06484593f, 0.09916857f, -0.22252645f, 0.30983284f, -0.20720452f, 
    0.35982195f, 0.19021288f, 0.18644854f, 0.02560987f, 0.09651103f, -0.19707583f, 0.08416612f, 0.05574208f, 
    0.10792439f, -0.06461838f, -0.18959552f, -0.31742558f, 0.31578669f, -0.63852495f, -0.04465235f, -0.13876045f, 
    0.13311639f, -0.10836453f, 0.04935891f, -0.00120053f, -0.05222519f, 0.35208830f, 0.21904236f, -0.08175609f, 
    -0.05788701f, -0.32636070f, -0.20673811f, 0.17011282f, -0.28389499f, -0.19149311f, 0.09882855f, -0.01837122f, 
    -0.18175814f, -0.06251138f, -0.12021349f, -0.02113512f, 0.02585487f, 0.19391604f, -0.32090309f, -0.02828293f, 
    0.04102310f, 0.02104914f, 0.36099711f, -0.18387952f, -0.02445652f, 0.21934521f, 0.05634782f, -0.08982182f, 
    -0.00808904f, 0.06260775f, 0.34641489f, -0.07466809f, 0.12487459f, -0.08946627f, -0.32715222f, 0.08676413f, 
    0.21990058f, 0.20684311f, -0.03599749f, 0.08045547f, 0.02621957f, 0.15564944f, -0.01881173f, 0.09970906f, 
    -0.13393348f, -0.00875006f, -0.07390652f, -0.34752336f, 0.14362113f, 0.09507298f, 0.11995021f, -0.35636100f, 
    0.25015223f, -0.02606303f, -0.37772012f, 0.02595281f, -0.36004835f, -0.32699358f, 0.15282524f, -0.30395293f, 
    -0.14869043f, 0.08182461f, 0.19180788f, -0.34479439f, -0.04958486f, -0.15259433f, 0.10835865f, 0.14116296f, 
    -0.14981715f, -0.16302057f, 0.19531512f, -0.21558921f, 0.01098714f, 0.13883349f, 0.29161140f, -0.02948782f, 
    -0.02326694f, 0.19998993f, 0.22251481f, -0.27298224f, 0.07660756f, -0.14150704f, 0.20614523f, 0.06396426f, 
    -0.26990163f, 0.53255212f, 0.02948781f, 0.02863910f, 0.09082133f, 0.09406223f, -0.17067316f, 0.19553752f, 
    0.09441341f, -0.23730665f, 0.10195637f, -0.17364348f, 0.26079965f, -0.01191688f, -0.04134445f, 0.01304804f, 
    -0.04909676f, 0.02792509f, 0.18963508f, -0.07038298f, 0.15265644f, 0.08730131f, 0.01158558f, -0.09154348f, 
    -0.02559998f, -0.32881397f, -0.16297720f, -0.00037846f, -0.08129343f, -0.16761802f, 0.10181525f, -0.07970315f, 
    -0.18854149f, 0.04867953f, -0.17529787f, -0.05619586f, -0.13533379f, 0.33914819f, 0.09351384f, -0.06768887f, 
    0.19167757f, -0.32590201f, 0.09104159f, 0.09082609f, 0.19125377f, -0.08371644f, 0.18309288f, 0.04579611f, 
    0.00910785f, -0.11150622f, 0.39884046f, -0.10797560f, -0.06177012f, -0.09488431f, 0.11904921f, 0.06705549f, 
    0.14802642f, -0.16684517f, 0.10409959f, 0.16618693f, -0.10344166f, 0.04079396f, 0.27438161f, 0.00616139f, 
    -0.00432255f, -0.03094243f, -0.23946653f, -0.09567002f, 0.09567925f, -0.34183761f, 0.00967502f, 0.18762048f, 
    0.30482593f, -0.04827465f, 0.09737267f, -0.22952569f, 0.04038842f, 0.02478202f, 0.15828265f, 0.00536799f, 
    0.14480799f, -0.04345182f, 0.16402124f, 0.08270604f, 0.02473858f, -0.05736292f, -0.05585732f, -0.02623655f, 
    -0.07305912f, -0.03390015f, 0.16565202f, 0.16591313f, -0.13323282f, 0.03797678f, -0.30793309f, 0.26638705f, 
    0.04659555f, -0.07139777f, 0.10450357f, 0.07804582f, -0.33125994f, 0.07770614f, 0.00382487f, -0.14049473f, 
    -0.18058257f, 0.02851576f, 0.10302523f, 0.08925702f, 0.00862850f, 0.26545766f, -0.13045809f, 0.07020406f, 
    0.17520584f, -0.04749729f, 0.30244136f, -0.42944100f, 0.16249877f, 0.07477080f, -0.02047832f, 0.00613873f, 
    -0.09108976f, -0.05353704f, 0.20432131f, 0.38233408f, -0.14046186f, -0.03705242f, 0.33206466f, 0.11363818f, 
    0.28876135f, -0.00830214f, -0.20699427f, 0.26905683f, -0.29253384f, 0.07082613f, 0.24519375f, -0.09196393f, 
    0.03892569f, 0.34427655f, 0.15862013f, -0.02505242f, 0.48968938f, 0.18625924f, 0.05454904f, -0.03603373f, 
    -0.16978900f, -0.20157360f, 0.34552377f, 0.19709177f, 0.78707755f, 0.15089971f, 0.13950960f, -0.02001270f, 
    -0.09153578f, 0.01377895f, 0.13680162f, 0.03636222f, 0.07368860f, -0.25013247f, 0.02930982f, 0.15318924f, 
    -0.08301166f, -0.07509205f, 0.15262906f, 0.40287668f, 0.15130311f, -0.26948670f, -0.23259862f, -0.24028562f, 
    0.12615083f, 0.09033827f, -0.12649031f, -0.17326215f, -0.05299335f, 0.12836841f, 0.14658719f, 0.08680765f, 
    0.04487468f, -0.45458299f, -0.24837993f, 0.12161561f, 0.10374793f, 0.22795101f, -0.04441408f, 0.01304930f, 
    0.23986271f, 0.07015778f, -0.02315829f, 0.19715080f, -0.24296810f, 0.44946185f, -0.48453334f, -0.07892392f, 
    -0.32671189f, 0.07511779f, 0.20682293f, -0.00581669f, 0.12234446f, -0.19304423f, 0.01760028f, 0.05304578f, 
    0.12954637f, -0.02155657f, 0.15981959f, -0.03408846f, 0.13479713f, -0.30246145f, 0.18785688f, 0.12174658f, 
    0.14766508f, -0.09701007f, -0.03786663f, 0.05249881f, 0.01346019f, -0.03825833f, 0.06957319f, -0.12334165f, 
    -0.03134150f, -0.07930830f, -0.28405437f, -0.16381839f, -0.02788286f, -0.25012422f, 0.03722450f, -0.00374881f, 
    -0.47014755f, -0.23090187f, -0.20670146f, 0.00791210f, 0.33156174f, 0.08007413f, -0.28156617f, -0.06529717f, 
    0.33764648f, -0.02058974f, 0.19469859f, 0.05001820f, -0.04535005f, -0.01091533f, 0.26534778f, 0.23613174f, 
    -0.64703596f, -0.40597755f, -0.32855439f, -0.28198016f, 0.01834632f, 0.00732864f, -0.10207780f, 0.01994880f, 
    -0.02638742f, 0.02664288f, -0.02680989f, -0.10841438f, 0.02524101f, -0.06964128f, -0.01875985f, -0.05901333f, 
    -0.01792653f, -0.12375939f, -0.09863193f, 0.04557883f, -0.10355150f, -0.07497887f, -0.10848252f, -0.01657006f, 
    0.05879794f, 0.02866199f, -0.01029941f, 0.00555797f, 0.03210125f, -0.00285172f, -0.08391283f, -0.08488056f, 
    0.00271092f, -0.06005024f, 0.02736329f, -0.00475317f, 0.06535797f, -0.03272353f, 0.05126943f, -0.01032189f, 
    0.01375281f, -0.07124902f, -0.08801375f, -0.00370412f, -0.07264115f, 0.08059638f, 0.06429573f, -0.07612059f, 
    -0.01776215f, -0.05583869f, 0.00459944f, 0.06920678f, 0.08525890f, -0.05460808f, -0.01274417f, 0.00767783f, 
    -0.12252226f, -0.02112786f, -0.13429193f, -0.00959580f, -0.09541362f, -0.10150720f, 0.00583726f, -0.12763757f, 
    0.01069830f, -0.04517634f, 0.01486313f, 0.00305834f, 0.01572239f, -0.12446443f, -0.09324687f, -0.04921233f, 
    -0.09961488f, -0.10875796f, 0.06054506f, -0.01887985f, -0.03043492f, -0.00076742f, -0.08124695f, 0.01266770f, 
    -0.05078330f, 0.06432567f, -0.11712850f, -0.05275181f, -0.17386310f, 0.05781922f, -0.01186573f, 0.01750443f, 
    -0.03747372f, -0.05712629f, 0.08334450f, -0.04286177f, -0.11456420f, -0.01390907f, -0.01044392f, -0.04429338f, 
    0.01144529f, 0.07296040f, 0.00991363f, -0.02078314f, -0.05835840f, -0.07118590f, -0.04816480f, 0.01017255f, 
    -0.05058915f, 0.02407560f, 0.01059504f, -0.10818888f, -0.06648119f, -0.03568432f, 0.00057695f, -0.13133164f, 
    -0.03630771f, -0.13651012f, -0.13637047f, 0.05119817f, -0.00519054f, -0.04708853f, -0.05473974f, 0.06750108f, 
    -0.06271218f, 0.00186130f, 0.01385470f, -0.03195310f, -0.02018381f, 0.05412490f, 0.01833850f, -0.09096115f, 
    0.04091510f, -0.07376108f, 0.00479701f, 0.01818115f, 0.01862395f, -0.01950041f, 0.11535984f, -0.07473056f, 
    0.03492246f, -0.10546989f, -0.14437573f, -0.39527613f, -0.12438592f, -0.22651665f, 0.17615743f, 0.08641960f, 
    -0.04717066f, 0.25323626f, -0.28458950f, -0.46717423f, 0.00554455f, -0.11296350f, -0.32391116f, 0.20190518f, 
    0.03396304f, -0.42298013f, -0.01906734f, -0.00678288f, 0.04490864f, 0.14741534f, -0.06334239f, 0.07711044f, 
    -0.04630211f, 0.06079884f, 0.32741114f, -0.26146856f, 0.17014393f, -0.13505556f, 0.08566610f, 0.12225328f, 
    0.05546459f, 0.00625506f, -0.05082504f, -0.02963105f, -0.09320305f, -0.17165537f, 0.06987904f, 0.11172169f, 
    -0.07445241f, -0.27487195f, 0.01118478f, -0.18369651f, -0.00025727f, 0.07902834f, -0.20076494f, -0.10849794f, 
    -0.03395423f, 0.05197565f, 0.08485572f, 0.06981251f, -0.00598110f, 0.07403723f, -0.30727509f, 0.00289159f, 
    0.08167430f, 0.12788269f, 0.09933779f, -0.02820395f, -0.24245733f, -0.50998896f, 0.03490751f, 0.01373172f, 
    0.14079466f, -0.20820640f, 0.00337572f, 0.07269020f, 0.27494463f, -0.10122787f, -0.17546414f, -0.08510242f, 
    -0.06762078f, -0.06220448f, -0.20888151f, 0.14285202f, -0.01398348f, 0.07301138f, -0.37018052f, -0.03990573f, 
    0.08347430f, -0.15045893f, 0.25975460f, -0.17399804f, -0.06191002f, -0.11545295f, 0.08970739f, -0.16479966f, 
    -0.13154638f, 0.18202649f, 0.11442553f, -0.03318875f, 0.05979837f, -0.01657824f, 0.05338765f, -0.13679412f, 
    0.08685879f, 0.02170960f, 0.20470352f, 0.04625873f, 0.08148243f, 0.00109858f, 0.09034101f, -0.07016707f, 
    0.19457489f, 0.13195515f, 0.00675438f, 0.06526643f, -0.08912627f, 0.05300422f, 0.02909482f, -0.16970588f, 
    -0.21358481f, -0.04920348f, -0.06356970f, 0.00341451f, 0.03113606f, 0.10120382f, -0.10721107f, -0.22763419f, 
    -0.02705803f, 0.00844501f, -0.27621913f, 0.17113373f, 0.14544603f, 0.03455281f, 0.05851974f, 0.12571447f, 
    0.18365903f, -0.25394750f, -0.09057413f, -0.12238031f, -0.07826428f, 0.21783537f, 0.10411333f, -0.00693781f, 
    -0.03867854f, -0.23928612f, 0.03297625f, -0.17466906f, -0.03765165f, -0.16913386f, 0.07520327f, 0.10586529f, 
    -0.03749890f, 0.34817630f, 0.10125031f, 0.22716533f, -0.31922162f, 0.11498351f, 0.06662878f, 0.01730265f, 
    0.03410392f, 0.15233181f, -0.40283912f, -0.03685661f, 0.10840873f, 0.02105596f, 0.12405087f, 0.21792617f, 
    -0.02585064f, 0.08522685f, -0.02832911f, 0.05821407f, 0.03196055f, -0.11135376f, 0.02754762f, -0.13332810f, 
    0.26483807f, -0.16653572f, 0.30479443f, 0.30397654f, 0.46617872f, 0.20514730f, -0.11448795f, 0.02023932f, 
    -0.08713451f, 0.42135036f, -0.06742429f, 0.11347149f, -0.01513660f, 0.07393160f, 0.11821757f, -0.06388331f, 
    0.08262540f, 0.33759892f, -0.38804618f, 0.02868558f, 0.10783694f, -0.01369845f, 0.14498547f, -0.11405809f, 
    0.14729092f, 0.29200065f, -0.03928401f, 0.10582251f, 0.60736203f, 0.28081211f, 0.16951522f, 0.02690038f, 
    0.02869015f, -0.04546549f, 0.15930265f, 0.30733454f, -0.08369976f, 0.08755887f, -0.02492365f, 0.13354254f, 
    0.06007291f, -0.04788258f, -0.11992320f, 0.12044580f, -0.17712659f, 0.17699958f, -0.02176085f, -0.00103094f, 
    -0.08641743f, 0.03643541f, -0.11153610f, 0.08328655f, -0.00496707f, 0.34488922f, -0.21742274f, 0.02067155f, 
    0.17556217f, 0.08239131f, 0.02297526f, 0.15631464f, 0.12459106f, 0.23803958f, 0.10019340f, 0.03375769f, 
    0.23016080f, 0.10190462f, 0.04459184f, -0.02434355f, -0.01759441f, -0.11507297f, 0.01918633f, 0.15747933f, 
    -0.31513843f, 0.00444190f, -0.07621682f, -0.04153444f, -0.03526845f, -0.15989354f, 0.26884568f, 0.01548966f, 
    -0.02338432f, 0.17577295f, -0.56112677f, 0.13526711f, 0.09242725f, -0.05364774f, 0.08074246f, 0.00933774f, 
    -0.09447660f, -0.31710494f, -0.09411778f, 0.19401152f, -0.07165986f, 0.17041226f, 0.17998365f, 0.24338245f, 
    0.05854136f, 0.11108045f, -0.20878968f, 0.08194423f, -0.28672323f, -0.12981017f, -0.00592253f, 0.07601984f, 
    -0.11659867f, 0.22971365f, 0.12169950f, 0.59094846f, 0.24379919f, 0.23157597f, -0.27564332f, 0.02931788f, 
    0.14048930f, 0.34161165f, 0.44578049f, 0.01866131f, 0.31342083f, 0.04764020f, 0.43477008f, -0.45353764f, 
    -0.13812742f, 0.10669111f, 0.08315202f, 0.00603609f, 0.22533058f, 0.04332102f, -0.02160456f, -0.34759542f, 
    -0.08733717f, 0.14807172f, 0.40745735f, -0.40552536f, 0.63591444f, -0.03122437f, 0.02850091f, -0.30035859f, 
    0.06364008f, 0.44877198f, -0.15994136f, -0.00913284f, -0.09615387f, 0.04670677f, -0.45135218f, 0.00435195f, 
    0.06446082f, -0.32101843f, -0.09023561f, 0.13444670f, -0.17567120f, -0.05385753f, 0.03914008f, 0.16536555f, 
    0.12977903f, 0.36951813f, 0.03594535f, -0.07647921f, 0.02406870f, 0.41019583f, -0.05721340f, 0.02796040f, 
    -0.79680353f, 0.01488223f, 0.04847928f, 0.09703603f, -0.04171677f, -0.48694545f, -0.06256630f, 0.03981678f, 
    0.21925262f, 0.12949906f, -0.18866231f, -0.04421771f, -0.05298867f, -0.15941761f, 0.08072869f, -0.00406291f, 
    0.05328199f, 0.13092202f, -0.05710627f, 0.07043099f, -0.02503506f, 0.01978491f, -0.31149754f, -0.06623949f, 
    0.09333847f, -0.02807591f, -0.06315058f, -0.08266247f, -0.15803471f, 0.01007658f, 0.07808683f, 0.17774574f, 
    -0.66757452f, 0.16806360f, -0.22663181f, -0.04992094f, 0.10039246f, 0.12382241f, -0.12526329f, -0.02540852f, 
    -0.22936819f, -0.07180928f, 0.01320594f, 0.06209710f, -0.03798651f, -0.01242171f, 0.17745326f, 0.17800348f, 
    -0.79235661f, -0.53240407f, 0.18100330f, 0.13680278f, 0.33824673f, 0.24818134f, -0.05771544f, -0.07955825f, 
    0.25068760f, -0.20419262f, 0.33074325f, -0.00872302f, 0.00937599f, 0.01979411f, 0.01733751f, 0.10363265f, 
    -0.15260740f, -0.02028017f, 0.00324395f, -0.03981995f, 0.01610928f, 0.00253137f, 0.24522197f, 0.07780617f, 
    -0.07573623f, 0.31875688f, 0.00108704f, -0.03387851f, -0.56325930f, 0.04278813f, 0.01992016f, 0.00632132f, 
    0.28254899f, 0.02136073f, -0.58935428f, 0.03378779f, -0.42187941f, 0.17621288f, 0.11590599f, 0.32518715f, 
    -0.06579652f, 0.08500481f, 0.05121559f, -0.02987139f, -0.01830753f, -0.11160814f, 0.03055034f, -0.14451414f, 
    0.16727744f, -0.29421249f, 0.27319503f, 0.27183989f, 0.47843200f, 0.14824983f, -0.13029340f, 0.14727211f, 
    -0.04834530f, 0.33007815f, -0.10875701f, -0.02407707f, 0.11523359f, 0.06857082f, 0.21488152f, -0.16246682f, 
    0.03445109f, 0.49258196f, -0.39171302f, -0.03223904f, 0.35572463f, 0.11873326f, 0.13798200f, -0.05407976f, 
    0.10158347f, 0.18068582f, -0.03665514f, 0.04872104f, 0.57104504f, -0.11311479f, 0.10962399f, -0.07425141f, 
    0.38986123f, -0.06154546f, -0.03852963f, 0.26612672f, -0.00869410f, 0.05233973f, 0.09003025f, 0.05634041f, 
    -0.04876343f, 0.04876319f, 0.08947869f, 0.14646854f, -0.16804847f, 0.18512709f, 0.15675314f, 0.02780486f, 
    -0.01151062f, -0.20719747f, -0.08050080f, -0.03264441f, -0.00817418f, 0.15181701f, -0.23865163f, 0.01955949f, 
    0.10245575f, -0.02239807f, 0.10915732f, 0.16025938f, 0.17389457f, 0.20339721f, -0.02510218f, 0.14424528f, 
    0.24602722f, 0.06911799f, 0.14024055f, -0.04599556f, 0.08010885f, -0.12889731f, -0.09886837f, 0.07809012f, 
    -0.22840714f, 0.06582227f, -0.01588930f, -0.05038740f, -0.02437910f, -0.14659643f, 0.20362212f, -0.07967380f, 
    0.36774543f, 0.22351751f, -0.55491644f, 0.25392699f, -0.03257325f, -0.04487020f, 0.01912810f, 0.28389433f, 
    0.09508557f, 0.23077196f, -0.04366383f, 0.02409759f, -0.04853870f, -0.10628901f, -0.07312071f, -0.11710555f, 
    0.02696063f, 0.19186893f, 0.13667358f, 0.21191840f, -0.03185447f, 0.09058022f, 0.04321872f, -0.00964639f, 
    0.24209008f, -0.07209271f, 0.14067671f, 0.09371254f, 0.25948626f, -0.04022396f, 0.17512964f, -0.07574319f, 
    0.02773554f, -0.22214983f, -0.46113959f, 0.04317744f, -0.31587300f, -0.07957676f, 0.08459505f, -0.11019652f, 
    0.19279395f, -0.06976910f, 0.02308080f, 0.00437047f, -0.07250973f, -0.01427566f, 0.04500422f, 0.07292096f, 
    -0.19976032f, 0.21588361f, -0.19697548f, 0.10876185f, -0.40993142f, 0.18693672f, 0.25335905f, -0.05121225f, 
    0.17956559f, -0.16905154f, 0.14182316f, 0.03117628f, 0.09777728f, -0.06038306f, 0.08158651f, 0.22297543f, 
    0.04186869f, -0.50191349f, 0.39348283f, 0.11547168f, 0.06517994f, 0.12497135f, -0.03943053f, 0.19945773f, 
    -0.10177374f, -0.15161501f, 0.05823160f, 0.00594880f, -0.64918160f, -0.18844491f, -0.02235757f, -0.07151294f, 
    -0.68861049f, -0.01881559f, 0.23641808f, -0.09104295f, 0.05169957f, -0.11381362f, 0.19799235f, 0.30218253f, 
    0.12043749f, 0.09566431f, 0.20895088f, -0.12705281f, 0.15129614f, -0.10402589f, 0.35554010f, 0.19768167f, 
    0.13396671f, 0.02103608f, -0.07756940f, -0.07936630f, 0.06801298f, -0.16110034f, 0.25521609f, 0.12608638f, 
    -0.06803438f, -0.00569904f, -0.11218794f, 0.10761937f, -0.11762694f, -0.29807931f, 0.04120426f, 0.01936913f, 
    -0.25783679f, -0.22047101f, 0.20366278f, 0.04736013f, -0.06102791f, 0.06787897f, 0.12992820f, 0.12004143f, 
    0.44776085f, 0.05694203f, 0.32622287f, 0.09144068f, 0.00934739f, 0.19699661f, -0.07965568f, 0.16949052f, 
    -0.59448844f, -0.33415154f, 0.45203876f, -0.18663935f, 0.04632948f, 0.06928104f, 0.10748327f, -0.06336874f, 
    0.01203369f, 0.24397922f, -0.12560174f, 0.39632303f, -0.11484348f, 0.22119553f, -0.09848566f, 0.14364339f, 
    0.02050326f, -0.16047873f, 0.11056101f, 0.06354374f, -0.01123225f, 0.03334110f, 0.27557155f, -0.16001937f, 
    -0.04397880f, 0.34373653f, 0.01514575f, -0.05731545f, -0.08704580f, 0.22540535f, 0.01236518f, 0.00253080f, 
    -0.00220770f, -0.07560296f, -0.00511628f, 0.06257691f, 0.28066003f, 0.13334179f, -0.30425239f, -0.05108947f, 
    -0.15049154f, 0.24326585f, 0.19082431f, 0.08388147f, 0.22878860f, -0.16473031f, -0.05733028f, 0.07671180f, 
    0.24556887f, -0.56757617f, 0.12905298f, -0.04333466f, 0.04233892f, -0.33554396f, -0.07100886f, -0.14224285f, 
    0.07210647f, 0.08078772f, -0.06029956f, -0.10248078f, -0.11903128f, 0.18371753f, -0.56044185f, 0.00972989f, 
    -0.04087802f, 0.26067883f, -0.56206179f, 0.19665004f, 0.36654201f, 0.24836478f, -0.14290698f, 0.00790990f, 
    0.34005812f, 0.31996304f, -0.03114100f, -0.11738337f, -0.24938676f, -0.11197073f, -0.63838154f, 0.03742706f, 
    0.01010969f, -0.07470673f, 0.22346583f, -0.02816956f, 0.02306578f, -0.00767810f, 0.13771078f, -0.27841792f, 
    -0.28552485f, -0.30534393f, 0.02274781f, 0.13003223f, 0.16833860f, 0.04843089f, 0.04568184f, -0.10267904f, 
    -0.00005404f, -0.22058783f, 0.11379473f, -0.02470211f, 0.02343331f, 0.17898539f, 0.30071363f, -0.06788514f, 
    -0.02067714f, 0.06426337f, -0.26393354f, 0.09198163f, 0.11614028f, 0.09414655f, 0.10129692f, 0.02434903f, 
    0.04477778f, 0.08613954f, -0.10582048f, -0.07233663f, 0.58565223f, -0.10664353f, -0.35227844f, 0.12353279f, 
    0.22697243f, 0.00337550f, 0.05775971f, 0.17668788f, 0.08938034f, -0.42760447f, 0.09956451f, 0.17388205f, 
    -0.23095568f, 0.56874555f, 0.14413366f, 0.29194945f, -0.17301294f, 0.09464938f, -0.31680131f, -0.06152906f, 
    0.02461320f, -0.02515604f, -0.05181215f, -0.01813067f, -0.04327082f, -0.05453405f, -0.10755036f, 0.00311962f, 
    -0.12792276f, -0.02712293f, -0.01682353f, -0.00075952f, 0.05201469f, -0.00600672f, -0.08077509f, -0.09616116f, 
    -0.07169476f, 0.00289640f, -0.08909968f, -0.05097574f, 0.00268997f, 0.04611829f, 0.00829898f, -0.03831298f, 
    -0.05129559f, -0.11037144f, 0.05974799f, 0.06165861f, -0.00186165f, 0.04828930f, 0.00221145f, 0.03437519f, 
    0.05104199f, -0.08333317f, -0.02862515f, -0.04691888f, -0.05657101f, -0.04020962f, -0.06609724f, 0.02998723f, 
    -0.01927795f, -0.04235752f, -0.04536965f, -0.10143217f, -0.01974503f, -0.09190865f, -0.08631700f, 0.04992032f, 
    -0.02267514f, 0.06134188f, 0.04856413f, -0.00805242f, -0.05242993f, -0.07973327f, -0.00357697f, 0.01487173f, 
    -0.07916737f, -0.01493752f, -0.00479307f, -0.04619616f, -0.00197648f, -0.03972783f, -0.06011578f, -0.09979943f, 
    0.04934157f, -0.01729024f, -0.03294913f, -0.01564087f, 0.03673943f, -0.06870508f, -0.12930574f, 0.05565374f, 
    -0.05495141f, 0.05376306f, 0.01482990f, -0.02105051f, 0.01831643f, -0.05618273f, -0.00965787f, -0.09200878f, 
    0.03829338f, -0.07353009f, 0.09555144f, -0.07826994f, 0.00268278f, 0.02664410f, 0.05757462f, 0.00737314f, 
    -0.00883912f, -0.05010298f, -0.04598569f, 0.08266200f, -0.08789765f, -0.05316954f, -0.06175019f, 0.03575354f, 
    -0.09387112f, -0.02785759f, 0.00885913f, -0.06949464f, 0.02231690f, -0.04949056f, 0.01169852f, -0.06403453f, 
    -0.03404776f, -0.10954902f, -0.05976978f, -0.04940521f, 0.03693794f, -0.09452051f, -0.10306754f, -0.08304282f, 
    -0.05107798f, -0.03089812f, 0.05968919f, -0.01366821f, -0.00176312f, -0.03708669f, 0.00703174f, 0.02075827f, 
    0.06989582f, -0.03404589f, -0.03342542f, 0.09915914f, 0.01579053f, -0.05855458f, 0.02833091f, -0.04463750f, 
    0.08243627f, 0.07578973f, -0.21953720f, 0.39551297f, -0.02822131f, 0.22163655f, -0.19831289f, -0.14891660f, 
    0.27969718f, -0.28378779f, 0.26020437f, 0.09514732f, 0.02954019f, 0.09017380f, 0.17012368f, -0.08791488f, 
    -0.10354009f, 0.10361747f, 0.15570036f, 0.31427878f, -0.30767432f, 0.02687400f, -0.03842749f, 0.06303656f, 
    -0.02689792f, -0.10135875f, -0.18369858f, 0.05231755f, 0.01046164f, -0.08721051f, -0.14276730f, -0.04459661f, 
    0.09022035f, 0.26207164f, 0.01299089f, -0.01423738f, 0.20161462f, 0.20185842f, 0.02352106f, -0.42521483f, 
    0.10871648f, -0.30260685f, 0.00320280f, 0.24535942f, -0.15800509f, -0.11997309f, 0.27322751f, 0.02910509f, 
    -0.23919716f, 0.23049158f, -0.01272988f, -0.01456614f, -0.04263990f, 0.18851665f, -0.13882646f, -0.28241369f, 
    0.03816534f, 0.08256251f, -0.06682292f, 0.24829398f, 0.27258846f, 0.18086323f, -0.16952255f, -0.10920992f, 
    -0.03016565f, 0.28173146f, -0.12806089f, -0.26987091f, -0.30180049f, 0.09047607f, 0.25870574f, -0.00318122f, 
    -0.06874140f, 0.00668346f, 0.29117250f, -0.01875710f, 0.00099252f, -0.09915885f, 0.18879430f, -0.26008934f, 
    -0.34653923f, -0.01537065f, 0.26658669f, 0.29187441f, -0.10127962f, 0.21603803f, -0.01778925f, 0.05803763f, 
    -0.14413868f, -0.10872837f, 0.08302489f, -0.08832049f, 0.07349149f, 0.16011611f, 0.05823558f, 0.16062765f, 
    -0.08331036f, -0.02830330f, -0.06716917f, -0.01978376f, 0.03783623f, 0.10859337f, 0.19605421f, -0.07233749f, 
    0.05406948f, 0.04531061f, 0.06981365f, -0.00698323f, 0.03164540f, 0.05037807f, -0.16931255f, 0.16580032f, 
    0.32725793f, -0.03196763f, -0.13463382f, -0.01747344f, -0.04218491f, -0.22098768f, 0.15328036f, 0.06247235f, 
    -0.00488275f, 0.36041334f, -0.27902338f, 0.20811023f, -0.10761585f, 0.03944408f, -0.18717438f, 0.01586307f, 
    -0.02134931f, -0.01880153f, -0.00691892f, -0.03767709f, 0.00089809f, -0.02982579f, -0.07609130f, 0.00352448f, 
    0.00574200f, -0.00048251f, 0.04201024f, 0.03685192f, -0.03487583f, -0.02593980f, 0.04580480f, -0.04448970f, 
    0.01773190f, -0.11794461f, -0.11748958f, -0.06831824f, 0.04798654f, -0.10834405f, -0.10785090f, -0.08223277f, 
    -0.11761172f, 0.02646299f, -0.00302638f, -0.00841052f, 0.06497829f, -0.05088441f, 0.11645089f, -0.01609497f, 
    -0.07256680f, 0.03777846f, 0.06220651f, -0.05730783f, -0.02682952f, 0.01395858f, 0.03388603f, 0.02906238f, 
    -0.09656377f, 0.01373465f, 0.03541078f, -0.06239290f, 0.06163477f, 0.04950278f, 0.03356062f, -0.04911486f, 
    -0.09688233f, -0.06264687f, -0.02832499f, 0.03854991f, -0.08543547f, -0.00635879f, -0.10360766f, -0.00106971f, 
    -0.03791491f, -0.05286766f, 0.01426039f, 0.01989082f, -0.09226397f, -0.02262429f, -0.01005264f, -0.06648532f, 
    0.03917232f, 0.00258757f, 0.00791939f, 0.04870951f, 0.07895529f, -0.04239758f, 0.00656536f, -0.01537757f, 
    0.03971295f, -0.00339788f, -0.10050821f, 0.07083026f, -0.02651064f, 0.07734215f, -0.13655090f, -0.07080469f, 
    -0.09827045f, -0.01304105f, -0.05273398f, -0.04964048f, -0.00996069f, -0.03692089f, 0.01424070f, -0.02449052f, 
    -0.01776369f, 0.02860094f, -0.01342208f, -0.00677071f, 0.01149597f, -0.09651221f, -0.11722282f, -0.05628739f, 
    0.05792725f, -0.02828523f, 0.00003302f, 0.05173074f, 0.05302737f, -0.05042493f, -0.07519310f, -0.10614792f, 
    -0.06106785f, -0.01528506f, -0.07426409f, -0.00139195f, -0.01783090f, 0.01778780f, 0.04763304f, -0.10504852f, 
    -0.00650244f, -0.06489392f, 0.02443609f, -0.01295206f, -0.08433136f, -0.03264626f, -0.10190900f, -0.09185280f, 
    0.07717776f, -0.09440229f, -0.01848105f, 0.00598660f, 0.08759834f, -0.04500886f, -0.05774315f, -0.12529233f, 
    -0.11976635f, -0.13029784f, -0.05817908f, -0.01496495f, -0.02072396f, -0.09849212f, -0.06334841f, -0.03290702f, 
    -0.05052289f, -0.03465571f, 0.02085088f, -0.06515062f, -0.02144192f, 0.00436481f, -0.01630294f, -0.06337246f, 
    -0.02108941f, 0.02738467f, -0.00708031f, -0.04109547f, -0.01221281f, 0.02586124f, 0.05978975f, 0.05057416f, 
    -0.04276474f, 0.09597968f, 0.04611080f, -0.08734813f, 0.09286713f, -0.03427330f, 0.01624981f, -0.11204256f, 
    -0.04305832f, 0.01145141f, 0.09795085f, 0.04913804f, -0.07683507f, -0.11059578f, 0.06847110f, -0.08696382f, 
    -0.05071203f, -0.04243587f, -0.04071400f, 0.00133865f, -0.00448496f, -0.08694566f, -0.04677702f, -0.07488346f, 
    -0.05106126f, -0.00812863f, -0.10828059f, 0.03655086f, 0.00529704f, -0.02664983f, -0.03540625f, 0.00019257f, 
    0.07718741f, -0.06946052f, 0.00049545f, -0.05663549f, 0.02532708f, 0.01576697f, 0.01466795f, -0.05153707f, 
    -0.05349539f, -0.06975510f, -0.03878416f, -0.04544640f, -0.02722874f, -0.01518236f, -0.08668500f, 0.06702361f, 
    -0.02780708f, -0.03570576f, -0.02985030f, 0.03857028f, 0.05591759f, 0.08280182f, -0.00218259f, -0.04090400f, 
    0.02568296f, -0.08253424f, -0.04637749f, 0.04353765f, -0.05585589f, -0.04352837f, -0.04522472f, 0.01288376f, 
    -0.09511410f, 0.01508727f, -0.12658647f, -0.06797700f, -0.04579106f, -0.12112709f, -0.08328339f, -0.08376755f, 
    0.05477279f, 0.01114262f, -0.01846824f, 0.02915276f, 0.01041687f, 0.03169851f, 0.04284646f, -0.09509660f, 
    0.02114068f, 0.05047735f, -0.00771821f, -0.04828308f, 0.02552152f, 0.03749461f, -0.03445706f, -0.02919878f, 
    -0.02240375f, 0.06277017f, 0.02014758f, 0.00983274f, 0.07881702f, -0.04725841f, -0.09946474f, -0.08981296f, 
    -0.04125967f, -0.10474504f, -0.04969699f, 0.00417761f, 0.03175727f, 0.02150264f, 0.05589307f, 0.02899675f, 
    0.10565102f, -0.20417124f, 0.12162166f, -0.05780329f, 0.10859262f, 0.03029216f, 0.19011167f, -0.12779498f, 
    0.12274659f, -0.16300119f, -0.09322545f, 0.07227711f, 0.17744105f, -0.01924768f, 0.21644594f, 0.00675520f, 
    0.04926257f, 0.18759970f, -0.02522164f, -0.28000745f, -0.54026419f, 0.01256801f, -0.03473397f, -0.06420100f, 
    0.01212873f, 0.11153401f, 0.42243603f, 0.04195753f, -1.20088100f, 0.09363984f, 0.22208147f, 0.19508830f, 
    0.10826911f, 0.10367351f, -0.02136948f, 0.06465583f, 0.01435610f, 0.12057310f, -0.02641713f, -0.23912108f, 
    0.06410646f, -0.22731414f, 0.13814810f, 0.08016646f, 0.56490755f, -0.30339700f, -0.18786637f, 0.16339907f, 
    -0.17726120f, 0.01581513f, 0.06579416f, 0.10082747f, 0.07307161f, 0.05045609f, 0.27003568f, -0.02914395f, 
    -0.07259647f, 0.19098891f, -0.22352619f, -0.00452982f, 0.16889653f, 0.12514551f, -0.02787173f, -0.09140309f, 
    -0.19662784f, -0.15855964f, -0.10475623f, 0.13392933f, 0.74398917f, -0.25667831f, -0.37555125f, -0.05659569f, 
    0.42209840f, 0.07495409f, 0.19435982f, 0.05669365f, -0.10885751f, -0.28822294f, -0.03140178f, -0.01684297f, 
    -0.08247349f, 0.30205205f, -0.57473540f, 0.29022166f, -0.01929142f, 0.20653953f, -0.16222809f, -0.02488456f, 
    0.01058974f, 0.13304767f, -0.04268073f, 0.05036328f, 0.01771701f, 0.31079027f, -0.15475109f, 0.06671270f, 
    -0.06018575f, -0.05625033f, 0.06683955f, -0.05693022f, 0.26774013f, 0.21335724f, 0.23230731f, -0.09839173f, 
    0.29147676f, 0.02288117f, 0.04902276f, -0.02244738f, -0.03211900f, -0.16808976f, 0.03357470f, 0.17627126f, 
    -0.03829951f, -0.03771027f, -0.00171986f, -0.22796683f, -0.04334276f, -0.08079157f, 0.27789980f, -0.02451414f, 
    0.28113207f, 0.09288177f, -0.16425166f, 0.70533621f, -0.04139160f, -0.08668353f, 0.23810270f, 0.18491119f, 
    0.06453054f, 0.27705464f, -0.15336396f, 0.34007505f, 0.25462183f, -0.20301576f, -0.13196357f, 0.12362073f, 
    0.04553121f, 0.02701071f, 0.27258095f, 0.10632476f, 0.00779022f, 0.06723342f, -0.03907326f, -0.05583367f, 
    0.14420824f, -0.18071964f, -0.00352234f, -0.07124618f, -0.23596925f, 0.01942809f, -0.00171398f, -0.00901068f, 
    0.10734868f, -0.19891518f, -0.33076963f, -0.14368114f, -0.57185429f, 0.01259115f, -0.36402822f, -0.30964649f, 
    0.02462459f, 0.17376420f, -0.01051421f, -0.09698259f, -0.03028039f, -0.03116200f, 0.09242301f, 0.48841819f, 
    -0.03906363f, 0.19989848f, 0.07157346f, 0.20389767f, -0.71629095f, 0.12495639f, 0.28869182f, -0.11513854f, 
    0.12806401f, 0.09482541f, 0.04550959f, 0.11906861f, 0.07911077f, 0.13982101f, -0.32469317f, 0.12931910f, 
    -0.03695294f, -0.02244950f, 0.03057723f, 0.24808216f, 0.11312824f, -0.06273568f, 0.00896626f, 0.20540161f, 
    0.06726055f, 0.10782150f, 0.16148102f, -0.01065514f, -0.46419823f, -0.46460673f, 0.05379815f, 0.00579942f, 
    -0.47296336f, -0.01145822f, -0.00356603f, -0.20012666f, 0.13606644f, 0.53448999f, 0.24091883f, -0.21292818f, 
    -0.07414041f, -0.12169897f, 0.06796329f, 0.09335151f, 0.13949464f, 0.05243351f, -0.07791639f, 0.00918695f, 
    0.05546048f, -0.08505043f, 0.10254087f, -0.02161306f, 0.02598326f, -0.02340351f, 0.31260213f, -0.04438834f, 
    0.22764938f, 0.07425945f, -0.07636125f, 0.06682913f, -0.00126712f, 0.02875305f, 0.04493277f, -0.15902609f, 
    -0.02824848f, 0.15942460f, -0.09568448f, 0.06103100f, 0.01881650f, 0.23942813f, 0.14320956f, 0.25318155f, 
    0.11191018f, -0.06252965f, -0.11750624f, 0.32368201f, -0.02787309f, -0.00417093f, -0.15755861f, 0.19792666f, 
    -0.31947979f, 0.23268038f, 0.04861512f, -0.26475182f, 0.11788521f, 0.09887200f, -0.09747486f, -0.05873413f, 
    0.02480724f, -0.01978626f, 0.00296058f, -0.09344998f, -0.13853700f, -0.07531075f, -0.00564031f, -0.00851998f, 
    0.04571805f, 0.00186639f, -0.12259125f, -0.03355955f, -0.07248481f, -0.06100895f, -0.06273865f, -0.00882511f, 
    -0.07311196f, -0.03124217f, -0.04185418f, 0.01137783f, -0.01942212f, 0.04979277f, -0.05620570f, -0.00679145f, 
    0.02679076f, -0.09058521f, 0.06171275f, -0.07372388f, -0.07134049f, -0.06359913f, -0.04312133f, -0.07930829f, 
    -0.11535846f, -0.06471253f, -0.06153962f, -0.03526777f, -0.09461430f, 0.02415134f, 0.04176836f, 0.04587880f, 
    0.01075454f, 0.06060475f, -0.04568408f, 0.01528945f, -0.04738567f, 0.03807616f, 0.02501776f, 0.01985725f, 
    -0.04297321f, -0.05311015f, -0.12542774f, -0.06430431f, 0.04542460f, 0.02786203f, 0.05216356f, -0.10492034f, 
    0.00390335f, -0.01186024f, -0.06814870f, -0.11613743f, 0.04742089f, 0.01644319f, 0.03702782f, 0.01959928f, 
    0.06391081f, -0.10196914f, -0.12287170f, -0.03461292f, -0.07153226f, 0.01076341f, -0.06789719f, 0.06273755f, 
    0.06192375f, -0.06222364f, 0.03316469f, -0.05677101f, 0.00638480f, -0.08257401f, -0.15328135f, -0.00544668f, 
    0.04942387f, -0.13136995f, -0.01898071f, -0.09926505f, -0.01177885f, -0.10524847f, -0.04980349f, -0.14371750f, 
    -0.04496184f, 0.06270228f, -0.02848629f, -0.01794084f, 0.05860607f, -0.01173938f, 0.05230200f, -0.11808991f, 
    -0.10136479f, -0.02801576f, -0.06623269f, 0.05698993f, 0.01647566f, -0.11746688f, -0.11157465f, -0.00277491f, 
    0.01056407f, 0.03072229f, 0.01810890f, 0.00962968f, -0.00240768f, -0.03309254f, 0.04985209f, -0.07762999f, 
    -0.04061326f, -0.00016317f, -0.06323229f, -0.01548027f, 0.01981207f, -0.06226935f, -0.10103548f, -0.06065854f, 
    -0.05456299f, -0.08217316f, -0.07226533f, -0.05209542f, -0.06682105f, -0.02584308f, -0.05746565f, 0.00483408f, 
    0.00285319f, -0.12986805f, -0.12371056f, 0.05687821f, 0.00313744f, 0.04785515f, 0.06578207f, 0.04988033f, 
    -0.07222392f, -0.06680177f, -0.02709898f, -0.05755069f, -0.09257311f, -0.13242160f, 0.00740708f, -0.10618889f, 
    0.01563980f, 0.04288583f, -0.06667823f, -0.08106705f, -0.09639128f, -0.05465398f, -0.09238783f, -0.04334329f, 
    -0.10887904f, -0.06044273f, 0.04547958f, -0.09049417f, -0.04770595f, -0.01573449f, -0.02101094f, -0.07983387f, 
    0.00848883f, -0.09072009f, -0.11063166f, -0.05589964f, -0.12112985f, 0.01532396f, -0.05074009f, 0.01376834f, 
    -0.01577594f, -0.01097420f, 0.05057906f, -0.05165559f, -0.03375035f, 0.00332990f, 0.01097159f, -0.08048978f, 
    -0.00076965f, 0.05928101f, -0.06642997f, -0.06420611f, -0.11773118f, -0.04679452f, -0.14658281f, -0.06154482f, 
    -0.04811519f, 0.04480227f, -0.05169444f, -0.04747938f, -0.04914524f, -0.05011228f, -0.11783037f, -0.05742235f, 
    -0.10092957f, 0.06718469f, -0.01410954f, -0.11454286f, 0.08801988f, -0.08202469f, -0.08161815f, -0.01282058f, 
    -0.02092530f, 0.04282966f, -0.04346122f, -0.01710613f, -0.02651587f, 0.06897593f, -0.04719425f, -0.05048996f, 
    -0.03897868f, 0.03585225f, 0.01210309f, 0.03191251f, 0.04207894f, 0.01477928f, -0.09377308f, -0.01441860f, 
    -0.01388540f, 0.01381144f, -0.07578152f, 0.04363043f, -0.02218429f, -0.06249067f, -0.03948118f, 0.04239451f, 
    -0.01845223f, -0.03995677f, -0.13012947f, -0.07509452f, -0.08912832f, -0.07350919f, -0.02692550f, -0.04266806f, 
    -0.12527944f, -0.05155383f, 0.01441267f, -0.08832687f, 0.03484677f, -0.12198140f, -0.01050730f, 0.03795732f, 
    -0.01777055f, -0.08487803f, 0.05551276f, 0.03777707f, -0.07564794f, -0.04188621f, -0.03296445f, -0.07096302f, 
    0.06796125f, -0.05034871f, -0.03868757f, 0.00396779f, 0.00851505f, 0.02071576f, 0.04365809f, 0.02589555f, 
    -0.08864357f, -0.09480414f, -0.03463305f, -0.10061380f, 0.01606448f, -0.01617025f, -0.00364959f, -0.08015841f, 
    0.01278635f, -0.04526969f, -0.00648968f, -0.07044673f, 0.04780866f, 0.00300996f, -0.09726704f, -0.04906613f, 
    -0.07664541f, 0.05986859f, -0.10431977f, -0.06665184f, -0.09906714f, 0.03708933f, 0.04308333f, 0.02717492f, 
    -0.03380573f, -0.02040896f, -0.06683643f, -0.10207886f, 0.04673908f, -0.05885061f, -0.05792525f, -0.00584266f, 
    0.00204023f, 0.05945168f, -0.05688320f, -0.04305227f, 0.03427959f, -0.06965569f, 0.03559288f, -0.04085788f, 
    0.04549444f, -0.03205879f, -0.10878499f, -0.00629551f, -0.02218681f, 0.01850042f, -0.03408085f, -0.06645349f, 
    -0.09948823f, 0.06556965f, -0.08812090f, -0.03404748f, -0.11262191f, 0.05084956f, -0.00174060f, -0.05885865f, 
    0.05569435f, -0.10470480f, 0.00904068f, 0.01685632f, -0.07528630f, -0.09004287f, -0.08442838f, -0.05756816f, 
    0.02358760f, 0.00491335f, 0.03315514f, -0.05521326f, -0.05772955f, 0.07939865f, -0.04559345f, 0.01313639f, 
    -0.10461790f, 0.01964337f, 0.02558658f, -0.08805373f, -0.00181440f, -0.05853168f, 0.04710237f, 0.06113847f, 
    -0.09319045f, -0.10928717f, -0.06579003f, -0.09014179f, -0.09611529f, -0.09562875f, 0.04275294f, 0.04265422f, 
    -0.07801819f, 0.03962342f, -0.08677097f, -0.02992295f, -0.07134955f, 0.05295488f, 0.01879916f, -0.04951709f, 
    -0.11097110f, -0.04676296f, 0.05933394f, -0.06291314f, -0.00973555f, -0.02954977f, 0.02126148f, -0.00941198f, 
    -0.02837427f, -0.01214978f, -0.00292193f, 0.05155764f, 0.08824917f, -0.07325010f, 0.02944650f, -0.04457233f, 
    -0.10020912f, 0.03548834f, -0.07458749f, -0.10763381f, -0.02986003f, -0.00431901f, 0.02237922f, -0.01964975f, 
    0.00197651f, 0.04352435f, 0.03724213f, 0.06728829f, -0.04584148f, -0.02123818f, -0.04125938f, 0.03870154f, 
    0.00122586f, 0.24546495f, 0.42529571f, -0.42897189f, -0.03829990f, 0.14480960f, 0.35546407f, 0.08406870f, 
    -0.19151382f, 0.34883419f, -0.06511051f, -0.40234721f, -0.12498503f, 0.19339719f, 0.07093179f, 0.07805736f, 
    0.16561304f, 0.17778216f, -0.12762317f, -0.37723911f, 0.07606135f, 0.25841743f, 0.07583842f, -0.00495315f, 
    -0.10706574f, 0.08430533f, 0.29007477f, 0.14131267f, 0.35176691f, 0.08273259f, -0.01523047f, 0.40460542f, 
    0.03702571f, -0.28627178f, -0.14005980f, -0.06739242f, 0.03595266f, -0.12292942f, -0.02931003f, -0.18750149f, 
    -0.04845521f, -0.27856693f, 0.06228523f, -0.06427962f, 0.25494379f, 0.05340334f, -0.24549349f, 0.08465923f, 
    0.00783029f, -0.22573785f, 0.03960979f, 0.10897789f, 0.20397095f, -0.07496484f, 0.34360048f, 0.04960254f, 
    -0.06682274f, 0.13923216f, 0.09698399f, -0.32814124f, 0.13306998f, 0.15679546f, 0.16375476f, -0.19636472f, 
    0.19356436f, -0.25505224f, 0.06418303f, 0.04731423f, 0.05872641f, -0.32037464f, 0.50780976f, 0.04220237f, 
    0.41871706f, 0.08820304f, -0.09517764f, 0.31685629f, -0.15036713f, -0.40555412f, 0.01404614f, 0.16943280f, 
    0.25471610f, -0.08683421f, 0.30625460f, -0.32371911f, -0.02235325f, -0.00177260f, 0.28071386f, -0.00356658f, 
    0.09369490f, -0.21928944f, 0.22198196f, -0.01770479f, 0.04566602f, 0.09829879f, 0.06386289f, -0.08160621f, 
    -0.08933226f, -0.00294330f, 0.17036003f, 0.18967761f, 0.14860524f, 0.00419549f, 0.03036156f, 0.23165271f, 
    0.10812943f, -0.15267700f, 0.17236428f, 0.04494875f, -0.26112720f, -0.14213844f, -0.15325424f, -0.16965808f, 
    0.01995740f, 0.07483399f, -0.01645494f, -0.08744160f, 0.10356114f, -0.03967911f, 0.03161551f, -0.26052400f, 
    0.57233131f, 0.27365085f, -0.44763115f, -0.43576497f, 0.02035519f, -0.05750940f, 0.22673196f, 0.37295926f, 
    -0.13368532f, 0.38671196f, 0.22753215f, 0.01305104f, 0.26581326f, -0.19785206f, 0.26689166f, 0.11479774f, 
    -0.21969904f, 0.26186898f, 0.19367230f, -0.01982005f, 0.05980442f, -0.00632866f, -0.09658751f, 0.14469755f, 
    -0.04296595f, 0.09982281f, -0.02019810f, -0.38807550f, 0.38943604f, 0.01531536f, -0.22792533f, -0.03891748f, 
    0.01373521f, -0.09084532f, 0.36931512f, 0.13622509f, 0.55234182f, 0.02314018f, -0.25664458f, -0.12664507f, 
    -0.07494758f, -0.15632454f, -0.10176928f, 0.01065777f, 0.04438655f, -0.26016653f, 0.14476441f, 0.21135280f, 
    -0.17728953f, 0.23498876f, -0.00134726f, -0.28333402f, -0.16475490f, 0.01928523f, -0.09114633f, -0.03327342f, 
    0.02778825f, -0.14745374f, 0.31125328f, 0.19053076f, 0.14290887f, -0.04813657f, -0.24544899f, 0.07327353f, 
    -0.08128872f, 0.19264783f, 0.09576913f, 0.09773833f, -0.14304595f, 0.21857750f, 0.14348210f, 0.09680241f, 
    0.12139788f, 0.03924137f, 0.08211188f, -0.01110531f, 0.17548865f, 0.07547489f, 0.30871642f, -0.00657407f, 
    -0.08388168f, 0.02010617f, -0.06258190f, -0.04121554f, 0.31877244f, -0.31698102f, 0.16825345f, 0.04371352f, 
    0.15333958f, -0.21998669f, -0.18924731f, -0.24159472f, 0.05419037f, 0.12519558f, -0.01039736f, -0.15833418f, 
    0.15792701f, 0.13775811f, 0.18550360f, 0.07055950f, 0.00005767f, -0.15034935f, 0.11219777f, -0.15155010f, 
    0.12920256f, -0.03867548f, 0.11485320f, 0.14180911f, 0.07062316f, -0.01138343f, -0.23596630f, 0.24080579f, 
    0.09213404f, 0.21845010f, 0.12291149f, -0.04875934f, -0.19319603f, 0.01045509f, 0.01208032f, -0.43193176f, 
    -0.13712822f, -0.06237486f, -0.10933462f, 0.11682510f, 0.10137765f, 0.08030554f, -0.19900717f, -0.00797007f, 
    -0.06150636f, 0.04389654f, 0.26271862f, -0.11600105f, -0.01935894f, 0.06706506f, -0.22215062f, 0.06697755f, 
    -0.12031725f, 0.05771872f, -0.08252510f, 0.03888867f, 0.06607665f, -0.09615555f, 0.01725605f, -0.07553022f, 
    0.04388930f, -0.03729248f, -0.07406148f, -0.09849297f, 0.03679872f, 0.03317681f, -0.03767971f, -0.09715511f, 
    -0.08045839f, -0.01387730f, -0.10401243f, -0.07336991f, -0.01763551f, 0.02170373f, 0.00227297f, -0.04528890f, 
    -0.11029611f, -0.08944201f, -0.01230839f, -0.01698315f, 0.10602245f, -0.07577275f, -0.00709779f, 0.02424286f, 
    -0.11312736f, -0.06712001f, 0.07644206f, 0.05316303f, -0.02937445f, 0.03639476f, 0.00831127f, 0.02505391f, 
    0.02840191f, 0.10079228f, -0.02700082f, -0.01927073f, 0.00426506f, 0.05758045f, 0.03549586f, -0.03364937f, 
    -0.01023277f, -0.02005978f, -0.04635996f, -0.12189184f, -0.10527153f, -0.01614261f, 0.07346968f, -0.10962459f, 
    0.03453365f, -0.07503628f, -0.06191856f, 0.04987821f, -0.00325815f, -0.01543634f, 0.02392782f, 0.04423389f, 
    -0.01828189f, 0.05518509f, -0.05990608f, 0.08601541f, 0.04507051f, 0.14026886f, 0.04999602f, 0.06841175f, 
    -0.07864085f, -0.01117216f, -0.11446305f, -0.07001474f, -0.01093502f, -0.00836239f, 0.03997698f, -0.05018295f, 
    -0.02086009f, 0.00364337f, 0.06119157f, -0.02528297f, 0.00209965f, -0.03315771f, -0.04352358f, -0.01743638f, 
    0.00686218f, -0.04912044f, -0.06337604f, -0.01669906f, 0.00754654f, 0.04618026f, 0.04021627f, -0.07038839f, 
    -0.04345859f, -0.03860443f, -0.01726880f, -0.09587292f, -0.00812867f, -0.02531385f, 0.01502200f, -0.02598275f, 
    0.02446543f, 0.00520669f, -0.10111178f, -0.01936966f, -0.01160277f, -0.10847425f, -0.13334794f, -0.10520610f, 
    0.03949752f, 0.04414897f, 0.03774685f, 0.04282995f, -0.06177349f, -0.00997884f, -0.02426776f, -0.07485913f, 
    0.00699944f, -0.08051495f, -0.05954424f, 0.09530227f, 0.00036175f, 0.03889192f, -0.03978360f, -0.09452987f, 
    0.12859118f, 0.09030419f, 0.05151177f, 0.11267532f, 0.12417096f, -0.12156045f, -0.26165181f, -0.19033165f, 
    -0.35831186f, -0.13421147f, 0.15503405f, 0.03884467f, 0.05921208f, 0.06725377f, 0.17920309f, -0.00956261f, 
    -0.05492625f, 0.15013155f, 0.02102782f, -0.13775292f, -0.37694457f, -0.07484490f, 0.09220905f, 0.03416688f, 
    0.26219115f, -0.04832359f, -0.25446987f, 0.04530443f, -0.61098862f, 0.07642083f, -0.11387204f, 0.28946200f, 
    0.20701115f, 0.29860559f, -0.09552793f, 0.00442034f, 0.10247638f, 0.06590263f, -0.02606688f, 0.02030767f, 
    0.15415697f, -0.23146304f, 0.09719063f, 0.21013859f, -0.10337904f, -0.10743257f, 0.04886737f, 0.09578196f, 
    -0.06950536f, 0.27962813f, 0.09737526f, 0.02800845f, 0.04640995f, -0.01795210f, 0.03098604f, -0.04814562f, 
    0.06165552f, 0.35765460f, 0.07033875f, -0.03142874f, 0.31832752f, 0.24609143f, -0.08062564f, -0.03837077f, 
    -0.02153117f, -0.00708095f, 0.09344699f, -0.03674120f, 0.03062476f, -0.23865108f, -0.31515145f, -0.08740244f, 
    0.32324940f, -0.07056436f, 0.07500996f, 0.01375107f, -0.07489630f, 0.16560502f, 0.25194070f, -0.04847708f, 
    -0.17334320f, 0.15648226f, -0.03119116f, 0.09824985f, -0.03340812f, 0.12856376f, -0.00166576f, 0.08452523f, 
    -0.16210027f, -0.20582469f, 0.01260637f, -0.06369614f, 0.01560843f, 0.16263431f, 0.10196449f, 0.30702823f, 
    0.09169527f, -0.02249281f, -0.15019169f, 0.00054391f, 0.11539634f, 0.08940600f, 0.09470828f, -0.00510324f, 
    0.20963180f, -0.12384184f, 0.06850483f, 0.05482677f, 0.00345291f, 0.01684186f, 0.09446899f, 0.37708455f, 
    0.33002406f, -0.07710039f, 0.03836030f, 0.00588255f, -0.08210074f, -0.10150719f, 0.09562096f, -0.13467851f, 
    0.26876763f, 0.56096989f, -0.25053194f, 0.29860494f, 0.02004308f, -0.00657115f, 0.01370233f, 0.10903236f, 
    0.14811249f, -0.01633914f, 0.09296907f, -0.13003421f, -0.27264348f, -0.13963173f, -0.32931975f, -0.14867570f, 
    -0.08012748f, 0.23393536f, 0.13252804f, -0.01187354f, -0.05089308f, 0.01611966f, -0.00168362f, 0.08616769f, 
    0.26532927f, -0.12092373f, 0.15710263f, 0.05325724f, -0.16378666f, 0.11384801f, -0.01583751f, -0.05460285f, 
    -0.05650554f, 0.10729045f, -0.02362857f, -0.15021449f, -0.46002343f, -0.12795001f, 0.23015009f, 0.47732556f, 
    0.17836449f, -0.02520676f, -0.20031101f, -0.00449805f, -0.03833599f, -0.03931620f, -0.04208847f, -0.08804202f, 
    -0.07020856f, 0.08458530f, -0.02019374f, -0.14880031f, -0.09509110f, 0.14835872f, 0.09611610f, -0.23005305f, 
    0.12560512f, 0.04846627f, -0.05382156f, 0.10791013f, 0.17737103f, 0.12736054f, -0.23974307f, -0.01027293f, 
    0.07285778f, -0.00517310f, 0.41320336f, 0.04979428f, -0.32151684f, 0.08416549f, -0.01895428f, 0.10154150f, 
    -0.02059583f, 0.00196305f, 0.03605851f, -0.21751554f, 0.24999844f, -0.32090479f, 0.11900264f, -0.06084148f, 
    0.11580363f, 0.05776815f, 0.10569284f, 0.10326707f, -0.21043429f, -0.05598589f, -0.03761363f, 0.17957583f, 
    0.22136922f, -0.11746693f, 0.03847581f, -0.14575276f, 0.01758247f, 0.09856459f, 0.42951888f, 0.08917758f, 
    0.07648645f, -0.18924731f, 0.00960468f, 0.06572155f, 0.02165552f, 0.12564510f, -0.12097699f, 0.01741802f, 
    0.05602918f, 0.04519198f, 0.06683202f, -0.05498048f, -0.04607309f, 0.11737648f, 0.11472050f, 0.12612410f, 
    -0.14222065f, 0.09624541f, 0.02501365f, 0.07801811f, -0.22188275f, 0.15100916f, 0.07396357f, 0.02537570f, 
    0.08906981f, 0.03681897f, 0.12964693f, -0.14211255f, 0.01013781f, 0.06029335f, 0.14603189f, 0.04897433f, 
    0.05760122f, -0.17644025f, -0.04854611f, 0.22025876f, 0.12597950f, 0.24163164f, 0.16263963f, 0.24411836f, 
    -0.11605422f, -0.07725649f, -0.21611778f, 0.12272334f, -0.13331239f, 0.26603130f, -0.09764851f, 0.08784407f, 
    -0.15215510f, 0.05996668f, -0.12318858f, -0.04017963f, -0.08375103f, -0.00774628f, 0.07492000f, -0.11207521f, 
    0.13909940f, 0.28406534f, 0.20326719f, 0.58751953f, 0.34946781f, 0.03290680f, -0.33211541f, -0.00178416f, 
    0.00134060f, 0.34970534f, 0.27501500f, -0.07908264f, 0.31053635f, -0.14806150f, 0.34064612f, 0.00275312f, 
    0.12809741f, 0.10643731f, 0.11811943f, 0.08339115f, 0.27887294f, -0.17694394f, -0.14648856f, -0.45696506f, 
    0.02041025f, -0.34970763f, 0.33212104f, -0.24239083f, 0.58599764f, -0.24240939f, 0.08329827f, -0.45552137f, 
    0.14483705f, 0.57758760f, -0.00896708f, -0.03824779f, -0.08774481f, 0.01171120f, -0.56788611f, -0.05706876f, 
    0.01248680f, -0.38099903f, 0.33249682f, 0.10123608f, -0.27231306f, 0.03798570f, -0.04281963f, 0.11479744f, 
    0.21811086f, 0.31077746f, 0.25697550f, -0.08104324f, 0.40325436f, 0.20192777f, -0.19277346f, 0.01674364f, 
    -0.54471505f, 0.07136682f, -0.00006199f, -0.09005992f, -0.20542708f, -0.24694113f, 0.06153597f, -0.09217387f, 
    0.11892876f, 0.05160549f, -0.13368338f, -0.04365075f, -0.17504799f, 0.04197491f, 0.19143030f, -0.01272689f, 
    0.15687089f, 0.03478026f, 0.02716293f, -0.03728616f, 0.09186606f, -0.00067784f, -0.01799875f, -0.01655995f, 
    0.08939035f, 0.04360174f, -0.19748443f, -0.16246179f, -0.17560273f, 0.01811309f, -0.03743367f, 0.03346436f, 
    -0.66157228f, -0.01523536f, -0.10388406f, 0.07216025f, 0.15377028f, -0.00929123f, -0.22151479f, 0.13990432f, 
    0.11750031f, -0.04486603f, 0.10102023f, -0.08234034f, 0.12175010f, -0.04202345f, -0.02145891f, -0.05419170f, 
    -0.26982513f, -0.26393643f, 0.28043428f, 0.08973557f, 0.26517248f, 0.17025676f, 0.09641664f, 0.15276271f, 
    -0.01228584f, -0.10275407f, -0.07689127f, -0.04904531f, -0.08700515f, 0.01325959f, -0.08626388f, -0.08641347f, 
    -0.01175742f, 0.04600487f, 0.01102572f, -0.00899815f, 0.04986252f, -0.00273921f, -0.06237651f, -0.06802657f, 
    -0.03080754f, -0.08035190f, 0.00200258f, 0.05885103f, -0.02340788f, 0.00192998f, 0.01864938f, 0.01849308f, 
    -0.07512816f, -0.00980997f, 0.08178563f, 0.00471760f, 0.00121648f, -0.03232953f, 0.08674760f, -0.09770492f, 
    -0.01336942f, -0.05344464f, -0.03241612f, -0.02864944f, -0.08076147f, -0.07198572f, 0.05536849f, 0.03857688f, 
    0.00340375f, -0.06244570f, -0.03475807f, 0.05744015f, -0.04788469f, 0.03284097f, -0.00182144f, -0.09950061f, 
    0.02866117f, 0.02201299f, 0.00342810f, -0.01660595f, -0.05602178f, -0.06606259f, 0.04035598f, -0.04767793f, 
    0.01328072f, -0.01518929f, -0.05831594f, -0.06689772f, -0.04129684f, -0.08207003f, -0.01755588f, -0.01129862f, 
    0.01906606f, 0.00769432f, 0.01439204f, -0.07454068f, -0.00055479f, -0.00201918f, -0.00480899f, 0.00289572f, 
    0.03363578f, -0.02443468f, 0.07155666f, -0.01087825f, 0.06911008f, -0.03837458f, -0.02795972f, -0.07286359f, 
    -0.02362332f, -0.00350242f, 0.01325634f, -0.09731854f, -0.00974520f, 0.06370904f, -0.03298631f, 0.02008786f, 
    0.03254172f, 0.06542139f, -0.09468651f, -0.05320700f, -0.06223662f, -0.07417727f, -0.04901370f, -0.08946366f, 
    -0.03786653f, -0.06110651f, 0.00051703f, 0.00561678f, 0.01560021f, 0.03264030f, -0.01979931f, -0.04885012f, 
    -0.02793895f, -0.06839091f, -0.01389548f, 0.03973961f, -0.00558311f, -0.02860672f, -0.10014006f, -0.04526919f, 
    -0.05243603f, -0.00927824f, -0.03511509f, 0.02361022f, 0.05231835f, -0.05503030f, 0.00071024f, -0.07917872f, 
    0.00051048f, -0.09500795f, -0.05662669f, 0.08552649f, 0.03817501f, 0.02592970f, -0.04781417f, -0.02275350f, 
    0.03866647f, -0.01967284f, 0.09742898f, -0.05718824f, -0.05873556f, -0.12093038f, -0.02388270f, 0.03646240f, 
    0.03981444f, -0.03418681f, -0.00919606f, 0.01495877f, -0.06524928f, 0.04197666f, -0.01864042f, -0.10375226f, 
    -0.05102318f, -0.09128252f, 0.01117209f, 0.02633568f, 0.00133788f, -0.07605199f, -0.02750677f, -0.03151017f, 
    0.05235518f, 0.03875018f, 0.04466588f, -0.08122769f, -0.01666499f, 0.01010246f, -0.05494465f, 0.09989538f, 
    -0.04996224f, 0.04584781f, -0.04571545f, -0.03617450f, -0.11060165f, 0.05984221f, -0.03870296f, -0.05223018f, 
    -0.06852029f, -0.00897164f, 0.02836407f, -0.04594056f, -0.08482862f, -0.07580076f, 0.06256356f, -0.08816238f, 
    -0.01547949f, -0.02067069f, -0.01485122f, -0.14772801f, -0.02284887f, -0.11847968f, 0.02862552f, 0.01635256f, 
    0.05308707f, 0.00634095f, -0.03653476f, -0.05376086f, -0.00660495f, -0.03896465f, -0.09231869f, 0.05855666f, 
    -0.03580560f, -0.00919371f, -0.05992733f, 0.06166933f, 0.07481856f, 0.02925083f, 0.03155658f, 0.06293212f, 
    0.08750252f, 0.05263826f, -0.09338010f, -0.07486412f, -0.02492747f, -0.05919698f, -0.01340735f, 0.04930199f, 
    0.00479753f, 0.02247111f, -0.08886600f, 0.03467512f, -0.00809631f, -0.11438062f, 0.00132927f, -0.01048340f, 
    -0.10450209f, -0.00735820f, 0.00715921f, 0.08258785f, -0.01082756f, 0.01689235f, 0.06251381f, -0.08146229f, 
    -0.05269699f, -0.06588906f, -0.01294507f, 0.00655450f, 0.04135006f, -0.10703178f, -0.04033777f, -0.01085007f, 
    0.01578593f, -0.04458335f, -0.03965924f, -0.06689393f, 0.11207725f, -0.05300111f, 0.05331736f, 0.05291404f, 
    0.05770485f, -0.01382296f, 0.00854809f, 0.06075691f, 0.00941515f, -0.07837286f, 0.05685014f, 0.07104516f, 
    0.10410684f, -0.03321040f, 0.03892110f, -0.04184541f, -0.05470923f, 0.03214595f, -0.02368564f, -0.10696977f, 
    0.08444653f, -0.02894275f, -0.02653466f, -0.01680010f, -0.01968651f, 0.07491607f, -0.02456043f, -0.09236324f, 
    0.04128977f, 0.05432710f, -0.05051505f, -0.09190421f, -0.02185381f, -0.06980292f, -0.03510051f, -0.01589625f, 
    -0.05659881f, 0.08085331f, -0.03007862f, 0.01163504f, -0.06223269f, -0.01360274f, 0.00266253f, -0.08480415f, 
    0.01056649f, 0.04845774f, -0.02368695f, -0.05218102f, -0.06295621f, -0.00000545f, -0.02811099f, -0.00893063f, 
    0.03670450f, -0.05104120f, -0.01289236f, 0.08244436f, -0.08033049f, -0.00661926f, -0.08136568f, 0.00174177f, 
    0.07975845f, -0.05817886f, 0.04093745f, -0.05791894f, -0.00236023f, -0.01803280f, -0.02887054f, -0.04970263f, 
    0.05889381f, 0.00277591f, -0.08922119f, 0.06072119f, 0.03897441f, -0.01381815f, -0.08628833f, 0.05929096f, 
    -0.06730846f, -0.00884753f, 0.02232893f, 0.08437161f, -0.07054543f, -0.06453163f, -0.03960799f, -0.00816852f, 
    -0.02342785f, -0.01668416f, -0.06665134f, 0.05214206f, 0.00527283f, 0.05844497f, 0.00154655f, 0.05752152f, 
    -0.03093118f, 0.08011285f, 0.06579416f, -0.05711095f, 0.00682396f, 0.02994208f, -0.01522149f, 0.02049457f, 
    -0.04731086f, -0.04895059f, 0.04105756f, 0.01808361f, -0.02409242f, -0.07481489f, -0.06936695f, -0.11544649f, 
    0.04742269f, -0.04925577f, -0.06410108f, 0.08699872f, -0.05229897f, -0.02029744f, -0.01543485f, -0.07425588f, 
    -0.01420095f, -0.05909076f, -0.00681359f, -0.04929511f, -0.10939320f, -0.08508706f, -0.08585586f, 0.04917100f, 
    -0.00798359f, 0.00591796f, 0.02969340f, 0.08102241f, 0.00024771f, -0.00124004f, 0.01283302f, -0.02892706f, 
    -0.00605756f, 0.01872132f, -0.08106627f, 0.00726311f, -0.06809673f, 0.00907144f, -0.08483536f, 0.00123850f, 
    -0.07895517f, 0.00612408f, 0.00456212f, -0.02366687f, -0.09622095f, 0.02072785f, -0.03617566f, 0.04686871f, 
    -0.12551178f, -0.04725029f, 0.15125383f, 0.23752283f, 0.12877466f, -0.07463332f, 0.01103013f, 0.32122597f, 
    -0.22586159f, 0.08878841f, -0.18536271f, -0.12672950f, -0.11651838f, -0.05657739f, 0.16233316f, 0.08137549f, 
    -0.22149363f, 0.19143751f, 0.07148335f, -0.60272747f, -0.20826769f, 0.09606341f, -0.06553941f, 0.05535084f, 
    0.29776457f, -0.03835414f, -0.22772042f, 0.03217213f, 0.30085656f, 0.25310558f, -0.10518032f, -0.05513649f, 
    -0.07860792f, -0.07378566f, 0.10976474f, 0.02346080f, 0.14586876f, -0.27432442f, -0.05299437f, 0.17819609f, 
    -0.02711863f, 0.11006838f, 0.37563279f, 0.56266284f, 0.11136802f, 0.13295157f, -0.35708502f, 0.06565626f, 
    0.22481503f, 0.16252281f, -0.00615368f, -0.08373731f, -0.01091302f, -0.05636250f, 0.14409435f, 0.01771926f, 
    0.05021405f, 0.14171714f, 0.02669748f, -0.04202743f, 0.26093712f, -0.10357618f, 0.17920391f, 0.08910397f, 
    0.18323302f, 0.22123852f, 0.21468329f, 0.25021043f, 0.16245322f, 0.39832333f, 0.07779537f, -0.04632708f, 
    -0.18741250f, 0.01194850f, -0.07309566f, 0.12759532f, 0.31613418f, -0.09321521f, 0.01481678f, -0.12203224f, 
    0.14323547f, -0.00998827f, -0.07981420f, -0.02393597f, 0.18185189f, -0.16789961f, -0.06735327f, -0.13789181f, 
    -0.07450999f, -0.12186813f, 0.10491051f, -0.08790620f, -0.05298309f, -0.09427804f, -0.13911191f, -0.22085950f, 
    0.18673326f, 0.07313123f, 0.03565209f, -0.09643047f, -0.01769279f, 0.16688345f, -0.25771156f, 0.31631812f, 
    -0.16030481f, 0.33913633f, -0.18472585f, 0.08114539f, 0.01522798f, 0.01750236f, 0.01168268f, -0.07140414f, 
    -0.33636743f, 0.02990801f, -0.07892296f, 0.05322007f, 0.01728291f, -0.29297575f, -0.05937795f, 0.09811547f, 
    -0.11953977f, -0.30436870f, -0.00810134f, -0.08339582f, 0.22178468f, 0.00301949f, 0.00316392f, -0.09551687f, 
    -0.05450158f, 0.06920339f, 0.04449326f, 0.05909758f, -0.05523312f, -0.06091759f, 0.00340905f, -0.09014498f, 
    0.06360544f, -0.08898096f, -0.00418365f, -0.06760442f, -0.01177169f, -0.03199211f, -0.05160775f, 0.02791918f, 
    -0.00116410f, 0.02188222f, 0.07191993f, 0.01786543f, -0.04027946f, -0.06572878f, 0.01158985f, 0.02701639f, 
    0.05543953f, -0.10037134f, -0.05936307f, -0.04148825f, -0.05888046f, -0.04292550f, 0.03134656f, 0.03323716f, 
    0.02799638f, 0.00623816f, -0.07217543f, -0.07136741f, 0.04563162f, -0.01765987f, -0.03146047f, 0.05260883f, 
    -0.03314130f, -0.03395778f, 0.02146741f, 0.04129704f, -0.00495027f, -0.04871999f, -0.08470218f, -0.07031371f, 
    0.05009737f, -0.00192442f, -0.08533717f, -0.03428607f, 0.00228209f, -0.02379084f, 0.06078104f, 0.02679986f, 
    0.03263893f, 0.00895591f, -0.03867606f, -0.03244697f, -0.07788040f, -0.05398378f, 0.05393603f, -0.07805717f, 
    0.06555572f, -0.05538080f, 0.01451442f, 0.02419245f, 0.04112441f, -0.00177221f, 0.00243839f, 0.03821054f, 
    0.01532499f, -0.04946466f, -0.01339221f, -0.04407348f, -0.01807502f, -0.02759942f, -0.02914007f, 0.04677569f, 
    0.00777655f, -0.05991034f, -0.05559553f, 0.02545417f, 0.03331205f, -0.08927196f, 0.05496332f, -0.10971723f, 
    0.06781881f, -0.01816888f, -0.05583999f, 0.05892334f, -0.04001456f, 0.02847679f, -0.06210263f, -0.05259588f, 
    -0.05165255f, 0.02981033f, -0.04964778f, 0.05060390f, -0.12125222f, 0.00945584f, 0.01407525f, -0.02274579f, 
    0.07846757f, -0.02628686f, 0.04077628f, -0.03895651f, 0.08402287f, 0.07027332f, -0.02879936f, -0.05537826f, 
    -0.02332826f, 0.06246700f, -0.01281308f, 0.06138429f, -0.07549569f, -0.00933677f, -0.07350844f, 0.07155801f, 
    0.05440454f, 0.01453572f, 0.07137461f, 0.03368913f, -0.00650966f, -0.02991857f, -0.06951345f, 0.07271300f, 
    -0.03691238f, -0.09369451f, -0.38150907f, 0.45793536f, 0.10597523f, -0.13370508f, -0.33726335f, 0.11698858f, 
    -0.11870122f, -0.08601919f, -0.12276015f, 0.17454387f, 0.16059262f, 0.12726399f, 0.17279650f, -0.01854846f, 
    -0.01300105f, -0.09006672f, 0.25938851f, -0.20842278f, -0.09354938f, -0.02605520f, -0.07302050f, 0.00246021f, 
    0.17779899f, 0.01193912f, -0.34849513f, -0.17576011f, 0.00512285f, 0.16166595f, -0.03768077f, -0.10847143f, 
    -0.02998496f, 0.28346351f, 0.20417874f, 0.00167217f, 0.07709944f, 0.12455823f, 0.02562626f, -0.04798077f, 
    0.10687521f, 0.14600581f, 0.17361212f, -0.32625201f, -0.29500392f, -0.11239563f, 0.22649477f, -0.09782867f, 
    0.10687850f, 0.57088482f, 0.10376357f, -0.13623542f, -0.03596514f, 0.12131334f, -0.37340596f, 0.18077838f, 
    -0.01984418f, 0.03783244f, -0.22337463f, 0.05077285f, -0.03996811f, -0.07800240f, -0.07962763f, 0.21104196f, 
    0.32181084f, 0.38610947f, 0.18487890f, -0.05947705f, -0.39481163f, 0.14493576f, -0.21019949f, -0.07387117f, 
    -0.30274847f, -0.06012196f, 0.18802109f, -0.03865104f, 0.02819326f, 0.07166258f, 0.08007978f, -0.12361978f, 
    -0.09757801f, -0.10429712f, 0.06848211f, 0.16514573f, 0.21823637f, -0.03403441f, 0.04982049f, -0.05256090f, 
    -0.00618553f, -0.03797282f, 0.10541617f, 0.04319558f, -0.07106124f, 0.02973412f, -0.02693309f, 0.07100682f, 
    0.20186044f, -0.08852470f, -0.12946777f, -0.07800505f, -0.10555819f, 0.21185255f, 0.06003860f, 0.09467009f, 
    -0.14906743f, 0.21850292f, -0.30091548f, 0.06896821f, 0.37594777f, 0.31986225f, -0.03368434f, 0.24980702f, 
    -0.02382766f, 0.01369674f, -0.11754514f, 0.07020184f, -0.08589205f, -0.13637327f, -0.00107622f, 0.23839575f, 
    -0.21287972f, 0.01983526f, -0.22124477f, 0.22000228f, 0.42101204f, 0.10135105f, 0.00181484f, -0.10716854f, 
    -0.00410909f, -0.02520876f, -0.02864723f, 0.01993027f, -0.01246726f, -0.00218742f, -0.02250974f, -0.00321273f, 
    -0.03945184f, 0.00831948f, -0.09307203f, 0.00376058f, 0.04518519f, -0.09959575f, -0.02034481f, -0.02697389f, 
    -0.05035099f, -0.04754112f, 0.06378344f, 0.06632715f, -0.09338326f, -0.02256068f, -0.01612114f, -0.07239021f, 
    -0.02435465f, -0.13267608f, 0.05681062f, 0.04863923f, -0.05668006f, -0.03688923f, -0.09692974f, -0.02945608f, 
    -0.07014901f, -0.05533570f, -0.03834537f, -0.04130683f, -0.00970884f, -0.07532439f, -0.04656152f, -0.01213645f, 
    -0.04928079f, 0.00433596f, -0.11438938f, 0.08583219f, 0.03770364f, 0.03202045f, -0.08715945f, -0.02281350f, 
    0.03152662f, -0.02820105f, -0.10189533f, -0.01894030f, -0.00373096f, -0.08350243f, 0.00507005f, -0.02250396f, 
    0.00865452f, -0.07070184f, -0.04960628f, 0.02018584f, -0.05589955f, -0.05250352f, -0.03611143f, 0.06414178f, 
    -0.07233206f, -0.04212588f, 0.03845861f, -0.08447924f, 0.04320269f, -0.03780386f, 0.05349684f, -0.06641082f, 
    -0.06423921f, -0.07947777f, -0.04718474f, 0.00426149f, -0.02105537f, -0.03020722f, -0.01208669f, -0.04261937f, 
    0.00578425f, 0.00166374f, 0.03894864f, -0.05961210f, -0.07143613f, 0.00472202f, -0.09636540f, -0.05908583f, 
    -0.12149964f, -0.03605743f, -0.01902865f, 0.00734728f, -0.06603143f, -0.00447496f, -0.02209648f, 0.06890564f, 
    -0.10111993f, 0.02574070f, 0.03685197f, 0.04175006f, -0.09436084f, -0.00583045f, 0.01326149f, -0.00240799f, 
    -0.07978242f, 0.02886845f, 0.02953224f, 0.03073752f, -0.03889834f, 0.01696896f, 0.00697683f, 0.03426383f, 
    -0.04944912f, -0.01878962f, 0.03999086f, -0.02523077f, 0.03406222f, -0.09644242f, -0.02718203f, 0.05010608f, 
    0.01544936f, 0.07993652f, 0.03685709f, -0.00198609f, -0.05674402f, -0.09690785f, -0.09098732f, -0.07127487f, 
    0.07711246f, -0.10241233f, -0.05266368f, 0.04019178f, -0.07651158f, -0.01854080f, 0.05532392f, 0.02181346f, 
    -0.08487727f, -0.10791814f, -0.02718247f, -0.07373034f, 0.02916275f, 0.02224451f, -0.03589204f, -0.08523701f, 
    -0.08630884f, 0.02823812f, 0.00924767f, -0.00082571f, 0.06207789f, 0.06328382f, 0.08071547f, 0.08205391f, 
    -0.02355234f, 0.00331106f, 0.06810592f, 0.04489127f, 0.01677309f, 0.08188567f, -0.01849796f, 0.00488710f, 
    0.05856993f, 0.00258808f, -0.07912931f, -0.05491058f, 0.05154810f, -0.03750449f, -0.08439171f, 0.04358990f, 
    -0.06795599f, -0.06573004f, -0.07434257f, 0.05399815f, -0.09567598f, 0.03195561f, -0.07695399f, -0.05449229f, 
    -0.06134688f, -0.08176396f, 0.05250925f, 0.05710953f, -0.04623082f, -0.08341370f, -0.04987616f, 0.06737601f, 
    -0.02777430f, -0.01602548f, 0.01478436f, 0.04741067f, -0.00417295f, -0.05581238f, -0.08182451f, -0.09221385f, 
    -0.11138400f, -0.04734618f, -0.09420119f, 0.04027492f, 0.06776260f, 0.04748206f, -0.02377636f, -0.08817940f, 
    0.07603121f, -0.04200530f, 0.01749031f, -0.01103470f, 0.05843220f, 0.02150530f, 0.01336244f, 0.04249449f, 
    0.00017866f, -0.02739562f, -0.03125309f, 0.02948351f, -0.02698611f, -0.06868532f, -0.02516341f, -0.08055186f, 
    0.02451957f, 0.09331148f, -0.09040257f, -0.01937633f, -0.01350865f, -0.08774737f, -0.07539902f, -0.10537881f, 
    0.03237914f, 0.02844491f, -0.06455114f, 0.03414715f, -0.05139290f, 0.04751818f, -0.08159674f, -0.08147025f, 
    -0.01359366f, 0.05442866f, -0.06373596f, -0.08046450f, 0.08058070f, -0.05517460f, 0.02343441f, -0.05970286f, 
    0.00933636f, 0.00241137f, 0.02783889f, -0.05723016f, 0.06647924f, -0.03156989f, -0.09320256f, 0.01131310f, 
    -0.02210511f, -0.05748631f, 0.08616702f, 0.07952039f, -0.07586184f, -0.01548403f, 0.00477167f, -0.08607223f, 
    -0.05682492f, 0.00331905f, -0.10551747f, 0.01494364f, 0.23170790f, 0.09657655f, 0.23674947f, 0.28762788f, 
    0.03624475f, 0.34894454f, 0.11881871f, -0.06603616f, 0.02756184f, 0.10362884f, -0.02620975f, 0.13853049f, 
    0.04656443f, -0.38311562f, -0.01960057f, 0.35546964f, 0.00256622f, -0.03856427f, 0.00544373f, 0.08530359f, 
    0.17840114f, 0.19766293f, -0.16711615f, -0.11656177f, 0.05205987f, 0.06798985f, 0.04122609f, -0.33580768f, 
    -0.07900006f, -0.10602920f, -0.04285661f, -0.06258903f, -0.02154224f, 0.04610677f, 0.02108110f, -0.05344776f, 
    0.01233834f, 0.45791706f, -0.01669059f, -0.21070109f, -0.18572152f, 0.44317722f, 0.27579632f, -0.04947165f, 
    0.06981509f, -0.03960818f, 0.09705988f, 0.19480449f, 0.07033942f, -0.11100725f, -0.13532671f, 0.16294028f, 
    0.07854801f, -0.05014018f, 0.06960212f, 0.18388146f, -0.14376523f, -0.23983800f, 0.20343548f, 0.16156596f, 
    -0.01215050f, 0.15646471f, 0.06215341f, 0.13810864f, -0.20491754f, 0.21534677f, 0.54766512f, -0.05155722f, 
    -0.32622623f, 0.08798531f, -0.17124449f, -0.08139677f, 0.11523655f, -0.04986534f, -0.19219127f, 0.12815027f, 
    0.21414922f, 0.14604813f, 0.10630769f, -0.10561390f, 0.12437354f, -0.01820303f, -0.04661675f, -0.00161567f, 
    0.00404771f, 0.53330296f, 0.05652477f, 0.00690000f, -0.03539431f, -0.04306283f, 0.01350640f, -0.05447923f, 
    0.10684805f, 0.03833954f, 0.21001713f, 0.17896976f, -0.03427934f, 0.08119339f, -0.07277296f, 0.00699913f, 
    0.02284626f, 0.26603413f, 0.15235701f, -0.02737261f, -0.23498960f, 0.15827350f, 0.13413627f, -0.11498924f, 
    -0.36305305f, -0.06199122f, -0.03828281f, 0.20827582f, -0.03516833f, 0.10057635f, -0.22371329f, 0.13149635f, 
    -0.16355000f, -0.13565497f, 0.52810442f, -0.40747261f, 0.33983818f, -0.08495737f, -0.05492137f, -0.13478452f, 
    -0.04121920f, -0.03490771f, 0.02958023f, 0.00791819f, 0.06696577f, -0.04449731f, -0.03991916f, -0.05274090f, 
    0.04188418f, -0.04278177f, -0.03006701f, 0.04307325f, -0.05576776f, 0.03242319f, -0.01262417f, 0.00798277f, 
    -0.00519434f, 0.01997510f, -0.01133331f, 0.01623641f, -0.08620655f, -0.05148391f, 0.00183310f, -0.01675019f, 
    -0.08401287f, -0.00934778f, -0.07486173f, -0.04186968f, 0.00228095f, -0.07436480f, 0.07189740f, 0.03743836f, 
    0.04009637f, 0.06150973f, -0.09038850f, -0.04283603f, 0.06051617f, -0.01442628f, 0.07813726f, -0.04888514f, 
    0.04545696f, -0.06433979f, 0.00664983f, -0.00496865f, 0.06710193f, -0.09010770f, 0.02722450f, -0.06308103f, 
    -0.03690706f, -0.00539779f, -0.03428762f, 0.06051847f, -0.03502246f, -0.00294430f, 0.03683976f, -0.06643777f, 
    -0.08640051f, 0.01136578f, -0.07585478f, 0.04494585f, 0.01762212f, -0.08358767f, -0.04141906f, -0.06273878f, 
    -0.10003434f, -0.01747203f, 0.03651158f, -0.05669735f, 0.01904904f, 0.01020717f, -0.02789387f, 0.03930604f, 
    -0.05011441f, -0.01904060f, 0.02024787f, -0.06471080f, -0.06254305f, 0.06588847f, -0.00960827f, -0.06962427f, 
    0.02465881f, 0.04940407f, -0.08748557f, 0.02192071f, 0.06585559f, -0.06141543f, 0.08911386f, -0.07584266f, 
    0.04652426f, -0.01759217f, -0.03015283f, -0.01637092f, 0.00120483f, -0.03771789f, 0.00606951f, 0.07634833f, 
    -0.02263758f, -0.02012434f, 0.02877697f, -0.06299324f, -0.00514056f, 0.00426279f, -0.02534979f, -0.05552887f, 
    0.05241733f, 0.02053758f, 0.07635748f, 0.08366837f, -0.07301313f, 0.03028446f, 0.00189493f, -0.09437647f, 
    0.06079197f, -0.06720567f, -0.07280163f, 0.05426489f, 0.00456901f, -0.07526884f, -0.07183426f, 0.06569634f, 
    -0.07211236f, 0.04753186f, -0.06400712f, -0.01692089f, -0.08676622f, -0.06300004f, -0.08936619f, -0.06317350f, 
    -0.11924747f, 0.03100948f, -0.24498470f, 0.11030858f, 0.22449316f, 0.30479854f, 0.19833870f, 0.27404359f, 
    0.10928822f, -0.03786581f, 0.06824852f, 0.04148992f, 0.03726399f, 0.01265317f, -0.08887018f, -0.12916510f, 
    0.11189456f, -0.22120070f, -0.11063534f, 0.47330004f, 0.21800314f, -0.18113302f, 0.13219030f, -0.05963323f, 
    0.02075822f, 0.11004815f, 0.09139935f, -0.12101259f, 0.28365591f, 0.13393864f, -0.00061351f, -0.43436491f, 
    -0.00152817f, 0.15491956f, 0.13625263f, 0.10532510f, -0.11824753f, 0.07437073f, -0.00228591f, -0.01365540f, 
    -0.01862221f, 0.28668064f, 0.06988747f, -0.14269596f, -0.01732989f, 0.13451885f, 0.20199265f, 0.07368588f, 
    0.06122758f, 0.07147006f, 0.22364870f, 0.08589754f, 0.10421477f, -0.05523736f, -0.16403018f, 0.34165817f, 
    -0.03991573f, -0.23159957f, -0.17292972f, 0.43286082f, -0.19691709f, -0.34615844f, 0.01807663f, 0.26957434f, 
    0.09219263f, 0.24158753f, 0.07784026f, 0.18338652f, -0.06253976f, 0.57667810f, 0.10737170f, 0.09576495f, 
    -0.06860324f, 0.00382668f, 0.11642753f, -0.00174504f, 0.25742412f, 0.09361743f, -0.11251957f, -0.11006255f, 
    0.01551341f, 0.22541502f, -0.11115779f, -0.01551364f, 0.18693916f, 0.00915403f, -0.24164015f, 0.06918232f, 
    0.19336715f, 0.78592515f, -0.09280017f, -0.04751677f, 0.06188400f, -0.03689922f, 0.34593236f, -0.11355603f, 
    0.11538775f, -0.07169153f, 0.10272730f, 0.12340206f, -0.03258231f, 0.10406537f, -0.00662172f, -0.13892935f, 
    0.07151774f, 0.23082332f, 0.12037478f, 0.04401027f, 0.04350926f, 0.16459915f, 0.19022565f, -0.05064629f, 
    -0.22349046f, 0.03455361f, -0.03699139f, 0.14830194f, 0.00440585f, 0.01585145f, -0.26483503f, 0.17674738f, 
    -0.09466928f, -0.08204601f, 0.57498211f, -0.03546959f, 0.31165648f, 0.02407463f, 0.10238599f, -0.16185908f, 
    -0.00985342f, -0.02135790f, 0.01742806f, 0.07126625f, 0.07913613f, 0.12034798f, 0.02641308f, 0.17192741f, 
    -0.28589076f, -0.12407196f, 0.08247146f, -0.16111125f, 0.02031119f, 0.07164542f, 0.13871741f, -0.03554906f, 
    -0.05352207f, 0.00700011f, -0.06872555f, -0.01641444f, -0.47829232f, 0.09775170f, 0.00063234f, 0.04236342f, 
    0.15830448f, 0.18562098f, -0.03282899f, 0.05453216f, -0.21106553f, 0.21798119f, -0.10822849f, -0.16232531f, 
    -0.02494526f, 0.13691360f, 0.07358529f, -0.03106098f, 0.01136135f, -0.21989579f, 0.07092731f, -0.29837093f, 
    0.25915766f, -0.13630141f, 0.13832662f, 0.10788456f, 0.36244470f, 0.02952655f, -0.15183958f, 0.15391777f, 
    -0.09048051f, 0.29348311f, -0.00174034f, 0.24807699f, -0.05250287f, 0.08601595f, -0.09287586f, 0.02970387f, 
    0.07392058f, 0.39200357f, -0.33846292f, 0.18891732f, 0.12037273f, -0.04865757f, 0.12257729f, 0.01173379f, 
    -0.03903360f, 0.27346599f, 0.05002479f, 0.08274999f, 0.46119577f, 0.36905122f, 0.17469412f, -0.02739462f, 
    -0.03749591f, -0.05404387f, -0.02275112f, 0.12668437f, 0.17205153f, -0.09348866f, -0.12243944f, -0.08358245f, 
    -0.01069094f, 0.07666764f, -0.15394256f, 0.22791611f, -0.06380218f, 0.24806595f, -0.21155709f, -0.13622108f, 
    -0.12738609f, 0.40332505f, 0.09169388f, 0.00851285f, 0.01837384f, 0.05174952f, -0.01328568f, 0.00326437f, 
    0.20560171f, -0.02129003f, 0.25745219f, 0.00618873f, 0.16323633f, 0.31250417f, 0.02960357f, 0.11927591f, 
    0.33387765f, 0.43330824f, 0.01898438f, 0.07947423f, -0.08826464f, -0.02703074f, 0.09724632f, -0.00571649f, 
    -0.42075554f, -0.02663114f, -0.18475714f, -0.07992025f, 0.11230464f, -0.14628673f, -0.09801877f, -0.04791566f, 
    -0.23788890f, 0.05416652f, -0.44250295f, 0.45764968f, 0.12313660f, 0.01328790f, 0.11103296f, 0.07761146f, 
    -0.01168668f, 0.25350800f, -0.32313854f, 0.12605393f, 0.04491516f, -0.15625447f, -0.38348532f, -0.10827787f, 
    -0.51307756f, -0.14028008f, 0.11261255f, 0.21603009f, 0.14057261f, 0.25089675f, -0.05565216f, -0.04023502f, 
    0.17295271f, -0.28879249f, -0.03392879f, -0.47755134f, 0.24742320f, -0.37906629f, 0.08661326f, 0.00862521f, 
    0.04721880f, -0.02055087f, -0.44495431f, -0.12677613f, -0.23157570f, 0.04715366f, 0.01499825f, 0.01146633f, 
    0.18732585f, 0.13231301f, 0.11721691f, -0.05341936f, -0.10974701f, -0.06852733f, 0.06865553f, 0.09737683f, 
    -0.00390489f, 0.24043117f, -0.37441328f, -0.32392269f, -0.60394108f, -0.07706431f, 0.06829524f, -0.02855123f, 
    0.23443836f, -0.11890274f, 0.14514337f, -0.03635277f, 0.02155633f, 0.11321755f, -0.12546155f, 0.07571320f, 
    -0.02371654f, 0.06468188f, -0.18193735f, 0.05996862f, 0.14945763f, -0.12552671f, -0.08558001f, 0.29432461f, 
    0.00411712f, -0.13373487f, 0.25200361f, 0.04580936f, -0.62688506f, -0.07303541f, -0.54585886f, 0.01100418f, 
    -0.00166161f, -0.04200773f, 0.07312047f, -0.10433295f, -0.04034109f, 0.17039758f, 0.19950882f, 0.02712229f, 
    -0.05138964f, 0.00770856f, 0.13939181f, -0.06789379f, 0.23692380f, -0.02471308f, -0.18958655f, 0.16672389f, 
    0.28884748f, 0.14891413f, -0.00376801f, -0.02790730f, 0.06505159f, -0.06994531f, 0.37514350f, 0.36834371f, 
    0.15643108f, -0.05669584f, -0.10570119f, -0.02615660f, -0.02587326f, -0.11426117f, -0.07150165f, -0.02795982f, 
    0.22096293f, -0.04650235f, 0.08533750f, 0.00076507f, 0.02035283f, 0.07434469f, 0.24369580f, 0.13405360f, 
    -0.12203665f, 0.01384097f, 0.27796188f, 0.20768993f, -0.09038636f, 0.13181674f, -0.44227558f, 0.13251461f, 
    0.14610095f, 0.28665829f, 0.22314356f, -0.07101451f, -0.08720188f, 0.08673359f, 0.14242478f, -0.28580415f, 
    0.17229269f, 0.10879316f, 0.15985744f, -0.05860714f, 0.14320798f, -0.05364190f, -0.12388916f, -0.06203778f, 
    -0.62532479f, -0.11023638f, -0.20195691f, -0.15728477f, 0.14129932f, 0.25620511f, 0.20543528f, 0.09777962f, 
    -0.09579844f, 0.06144591f, -0.04981350f, -0.62483793f, -0.48746267f, -0.04792586f, -0.03345466f, -0.03062053f, 
    0.29315782f, -0.10695375f, 0.30943704f, 0.16486593f, -0.49336922f, 0.18688190f, -0.06070706f, 0.26947862f, 
    0.24911024f, 0.09649690f, 0.09869820f, 0.11490223f, -0.00034702f, -0.04031613f, 0.02774249f, -0.32020712f, 
    0.17371859f, -0.37232098f, 0.00009714f, 0.11061039f, 0.11530909f, 0.11202449f, -0.19639856f, 0.30396315f, 
    -0.08655605f, 0.05981038f, 0.08983724f, -0.07815923f, -0.01039130f, 0.11921920f, 0.37115321f, -0.10257072f, 
    -0.08014368f, 0.46211669f, -0.09026362f, -0.27937755f, 0.57245100f, 0.14371030f, -0.00928890f, -0.16835427f, 
    -0.01555469f, -0.14896579f, 0.09576879f, 0.04679364f, 0.23343328f, 0.09366298f, -0.22541876f, -0.02907113f, 
    0.31174767f, 0.06871322f, 0.05625064f, 0.23996061f, -0.11759007f, -0.02012127f, 0.19902097f, 0.11627416f, 
    -0.09365302f, 0.20747837f, -0.15905544f, 0.09699684f, -0.05472282f, 0.10254427f, -0.08084929f, -0.13161919f, 
    -0.10122346f, -0.18133771f, 0.01806423f, -0.08221386f, 0.08109664f, 0.28129545f, -0.04596629f, 0.18758956f, 
    0.10242616f, -0.04354693f, 0.04486566f, 0.10985694f, -0.02002620f, 0.09276399f, -0.11433842f, 0.30447868f, 
    0.53445631f, -0.00343964f, 0.17451812f, 0.00220158f, -0.08258876f, -0.23685454f, 0.04151648f, 0.20293854f, 
    -0.05586840f, -0.00240024f, 0.12470069f, -0.16048478f, -0.06891846f, -0.12551920f, -0.03798083f, -0.18036568f, 
    0.43505573f, 0.34740406f, -0.18702269f, 0.36488095f, -0.04868882f, -0.10652641f, 0.18341787f, 0.06627486f, 
    -0.11623113f, 0.20818263f, -0.22595674f, 0.17654268f, 0.06419796f, 0.03937905f, -0.08230732f, 0.06657002f, 
    0.06441076f, 0.04937603f, 0.28139332f, 0.26475102f, 0.15900347f, 0.09822422f, -0.02526454f, -0.00115597f, 
    0.28823760f, -0.12525910f, 0.15302828f, 0.30639106f, 0.29227960f, 0.00376929f, -0.06749362f, -0.06586732f, 
    -0.09143093f, -0.04747916f, 0.10007799f, -0.03171078f, -0.38378599f, -0.13354032f, -0.19742870f, -0.17348847f, 
    0.05574893f, 0.03717538f, -0.05042985f, -0.05553472f, 0.04233855f, -0.28760248f, 0.00725172f, 0.14176287f, 
    0.00485278f, 0.00161616f, -0.04062041f, 0.01758762f, -0.30312225f, -0.02492866f, 0.19498909f, -0.16605642f, 
    0.21949795f, -0.09212243f, 0.17615145f, 0.19878484f, 0.10694126f, 0.24726188f, -0.45260748f, 0.24969326f, 
    0.01529846f, -0.07303599f, 0.22354533f, 0.24333188f, 0.00768833f, -0.08738139f, -0.03913566f, 0.25355574f, 
    0.13226654f, -0.12129956f, -0.00430505f, -0.05833503f, 0.05376183f, -0.39769971f, 0.06656376f, 0.08765759f, 
    -0.21768346f, 0.07704204f, 0.20764099f, -0.24072804f, 0.02127665f, 0.07003982f, 0.21425878f, -0.02032982f, 
    0.06706182f, -0.16560704f, -0.13012180f, 0.04302662f, 0.22960696f, 0.09071738f, 0.08890134f, 0.04353127f, 
    0.20833199f, 0.26037630f, 0.11111827f, -0.03099143f, -0.08676789f, 0.03791316f, 0.22191966f, -0.00100040f, 
    0.00990628f, 0.00479413f, 0.10780746f, 0.05008430f, -0.02431832f, 0.08532392f, 0.05886790f, -0.15758513f, 
    -0.04066613f, 0.07337859f, -0.00381215f, 0.00233590f, 0.22262134f, 0.29197475f, -0.03222781f, 0.07733739f, 
    0.09663976f, -0.02691032f, 0.04085418f, 0.03636226f, -0.04217963f, 0.06430354f, -0.03720047f, 0.18875335f, 
    -0.28427750f, -0.07859537f, 0.37139001f, 0.15667278f, 0.19740900f, 0.11614478f, -0.01850171f, 0.01176529f, 
    -0.07916774f, 0.01732296f, 0.06508435f, 0.01462359f, 0.13743682f, -0.22181569f, 0.00827013f, -0.04967322f, 
    -0.16784185f, 0.13260365f, 0.50603610f, 0.07670005f, 0.21769129f, 0.04632315f, 0.05843997f, 0.16207582f, 
    0.06806328f, 0.09136513f, 0.07110506f, -0.18055932f, -0.48165831f, 0.30128595f, -0.26764712f, 0.02950670f, 
    0.00863654f, 0.22567067f, 0.10069650f, 0.11503801f, -1.26446748f, -0.15716211f, -0.05217950f, 0.03510690f, 
    0.11178291f, 0.26042980f, -0.36018369f, -0.09472225f, 0.11989182f, -0.81260061f, -0.09954771f, -0.17661752f, 
    0.02579473f, -0.17270207f, 0.11709990f, -0.20567897f, 0.23724075f, 0.02252598f, -0.06585703f, -0.03885669f, 
    -0.04362536f, -0.06693471f, 0.06402522f, 0.28921196f, 0.05213079f, 0.35383499f, -0.76033586f, -0.09971099f, 
    0.03947311f, 0.14818045f, 0.06894479f, 0.16377786f, -0.16193019f, 0.08772407f, 0.08281213f, -0.11145961f, 
    0.06544548f, -0.07252528f, 0.02742281f, 0.00417183f, 0.51260138f, -0.28049147f, 0.15582292f, -0.03142951f, 
    -0.15490721f, -0.03792373f, 0.03649754f, -0.16092525f, 0.09956679f, -0.24564265f, 0.11152543f, -0.34938517f, 
    -0.04754167f, -0.29408833f, -0.82691908f, 0.21087664f, 0.13469282f, 0.25841594f, -0.04797867f, -0.15136930f, 
    -0.08466950f, 0.10170206f, 0.16728668f, -0.02260324f, -0.08950076f, 0.17412467f, -0.13365833f, 0.07436193f, 
    0.04656368f, -0.05836761f, 0.08923863f, -0.13459331f, 0.08904193f, 0.25567874f, 0.15716958f, -0.09764522f, 
    0.15346934f, 0.27772006f, -0.20323960f, 0.07047880f, -0.24342482f, 0.12301838f, 0.03158860f, -0.25651804f, 
    -0.36099628f, 0.00048490f, -0.30340505f, -0.19732459f, -0.06088092f, 0.00630694f, 0.12752979f, 0.07464103f, 
    -0.56138557f, -0.03659349f, -0.33048457f, 0.46317914f, 0.03292339f, -0.02604325f, -0.05930876f, 0.12674043f, 
    -0.05118266f, 0.23608461f, -0.04158986f, 0.24060197f, 0.24887790f, 0.37431774f, 0.16076507f, 0.24384423f, 
    -0.15310834f, -0.33534431f, -0.12354548f, -0.05456734f, -0.11200868f, 0.14104685f, 0.19904168f, -0.31134668f, 
    -0.17146070f, 0.11545116f, -0.16992101f, -0.07554083f, -0.04279845f, -0.07967684f, -0.04702453f, -0.07519570f, 
    0.30485240f, 0.01815724f, 0.10592537f, 0.24053603f, 0.20071058f, 0.13961560f, -0.08701941f, -0.18533985f, 
    -0.20082358f, 0.15712297f, 0.28868872f, -0.02692764f, 0.08598518f, 0.17474706f, 0.07522247f, -0.37096140f, 
    0.16616194f, -0.04442229f, -0.07167236f, -0.13777199f, 0.33358103f, -0.21616009f, -0.06799396f, 0.05686364f, 
    -0.08389569f, 0.20130841f, 0.10512537f, -0.09826348f, -0.18299444f, -0.04886184f, -0.18606885f, 0.04922849f, 
    -0.02281307f, 0.03509847f, -0.17423469f, 0.22895139f, -0.06071262f, -0.12345899f, -0.00902642f, -0.04003054f, 
    -0.09008386f, 0.09062029f, 0.06772644f, 0.03353327f, -0.15695117f, 0.44527671f, -0.29577762f, 0.04021591f, 
    0.03401841f, 0.08823422f, -0.05332303f, -0.03625929f, 0.36260244f, -0.05527862f, -0.07684293f, -0.44817451f, 
    -0.28881982f, 0.31809029f, 0.03911392f, 0.11255734f, -0.02915259f, 0.10468122f, -0.41584492f, -0.37686485f, 
    -0.06076971f, 0.22742964f, 0.05516449f, -0.08256211f, -0.01067376f, -0.06409419f, 0.23519112f, 0.05448468f, 
    0.15165584f, -0.09339418f, 0.00825175f, 0.01038662f, 0.00402001f, 0.12550253f, -0.06058881f, -0.06070511f, 
    0.23074697f, 0.10840826f, 0.04503539f, -0.02883274f, 0.01878165f, -0.28768477f, 0.07683141f, -0.02965727f, 
    -0.42433858f, -0.01307680f, -0.03612161f, 0.13249376f, 0.05389395f, -0.34609210f, -0.39029047f, -0.15359576f, 
    0.17844860f, 0.25284654f, -0.09860084f, 0.13583396f, 0.06743618f, -0.23175864f, -0.19068883f, 0.00162780f, 
    -0.07131829f, 0.01021915f, -0.01651284f, 0.03359712f, 0.11748160f, 0.05812580f, 0.21230787f, -0.04493788f, 
    0.26152578f, 0.10687600f, 0.10943453f, -0.19144532f, -0.01128447f, -0.14514802f, 0.00174744f, 0.06764861f, 
    -0.00969369f, -0.16103305f, -0.14948684f, 0.25382146f, 0.02469500f, 0.00544736f, 0.08453617f, -0.06199890f, 
    0.08047859f, -0.02439957f, -0.01209673f, 0.08114081f, -0.08603800f, -0.02376648f, -0.12337574f, 0.04970939f, 
    -0.14906429f, -0.09447985f, -0.22789350f, -0.02440372f, 0.01965328f, 0.10612564f, 0.03965972f, 0.02849263f, 
    0.00190975f, 0.27974230f, 0.05606523f, 0.06266985f, 0.21484084f, 0.07685009f, -0.08022270f, 0.16199346f, 
    -0.18618280f, -0.00686437f, -0.06899039f, -0.04609654f, -0.01795944f, -0.09925409f, -0.17175265f, -0.05859658f, 
    0.01718215f, -0.11844605f, -0.07007307f, -0.00878484f, -0.18157157f, -0.13086739f, 0.01435272f, -0.00889661f, 
    -0.12306365f, 0.07189051f, -0.07076188f, 0.01089298f, 0.07909031f, -0.05828949f, 0.24599111f, -0.00964121f, 
    0.06119349f, -0.05603671f, -0.19804813f, 0.06060640f, -0.12060416f, -0.02124440f, -0.13369876f, -0.14940888f, 
    0.10299701f, 0.06637399f, -0.04100160f, -0.03770847f, -0.17558360f, 0.12760051f, -0.01476585f, -0.03559721f, 
    -0.19304930f, 0.14265844f, -0.05926586f, -0.01991109f, -0.01925359f, -0.01012188f, -0.06320627f, -0.00343606f, 
    0.01234312f, 0.04922356f, 0.12662177f, -0.11531515f, 0.04601432f, 0.03577046f, -0.06570607f, -0.00409068f, 
    -0.06620438f, 0.10368762f, 0.14750063f, -0.00592077f, -0.14540489f, -0.18102483f, 0.10683534f, -0.18308601f, 
    -0.19233677f, -0.04013079f, -0.22603726f, -0.05430286f, -0.06133290f, -0.11017147f, -0.03911264f, -0.24117465f, 
    0.09698030f, 0.04523342f, 0.00471917f, -0.02669985f, -0.06703357f, -0.33159423f, 0.10434908f, -0.02015496f, 
    -0.20746903f, 0.31081581f, -0.00319483f, 0.09534835f, 0.22096147f, 0.06045483f, 0.33979991f, 0.16418871f, 
    0.16144793f, 0.21467763f, 0.30051285f, 0.25850177f, 0.12151908f, 0.08731901f, -0.09162895f, -0.05295554f, 
    0.02653760f, -0.16432150f, -0.01437270f, -0.04963998f, 0.41695011f, 0.11354835f, 0.06230256f, 0.05089290f, 
    -0.15836667f, -0.22182460f, 0.14659463f, 0.09314909f, 0.86032081f, 0.04895744f, -0.26586178f, -0.67957151f, 
    -0.30566373f, -0.12829815f, 0.12984003f, -0.07826783f, -0.06478494f, 0.02729413f, -0.07759615f, 0.43051994f, 
    -0.09014475f, -0.19955455f, -0.07099449f, 0.37809044f, -0.24451980f, 0.20090200f, -0.00997121f, 0.05583831f, 
    0.08287692f, -0.13216256f, 0.18917128f, -0.01024727f, -0.07492686f, 0.02302206f, 0.20922340f, 0.17041104f, 
    0.03783912f, 0.04638509f, -0.60096371f, 0.23751138f, 0.14849487f, -0.03095528f, 0.01936054f, 0.12547120f, 
    0.27840185f, 0.13061129f, 0.02487152f, 0.23439759f, -0.17705007f, 0.47677565f, 0.30093703f, 0.00824255f, 
    -0.47332424f, -0.00861529f, 0.11173444f, -0.17257990f, 0.43489501f, -0.00094596f, 0.20418669f, 0.05208677f, 
    -0.07752252f, -0.20851839f, 0.09902079f, 0.14584112f, 0.23894954f, -0.09293623f, -0.12016313f, -0.09115396f, 
    0.07250255f, 0.10162856f, 0.23544550f, -0.06395761f, -0.08238355f, -0.06019174f, 0.15696807f, -0.09064819f, 
    -0.02051507f, 0.05392801f, -0.02703866f, 0.14371724f, 0.01675403f, -0.13282393f, -0.08502619f, -0.04608792f, 
    0.20324896f, 0.09613748f, -0.04524898f, 0.02751211f, 0.31712678f, 0.10133699f, -0.09863804f, -0.13186650f, 
    0.13665551f, -0.08616565f, -0.11442862f, 0.15792947f, 0.00011425f, 0.14142407f, -0.18301585f, 0.25355747f, 
    -0.30914590f, 0.21542282f, 0.20554934f, -0.38434467f, -0.13164759f, -0.03656714f, -0.34964630f, -0.33051491f, 
    0.12143811f, 0.04900269f, 0.32956135f, 0.24072568f, -0.03926910f, -0.09321217f, -0.25629383f, -0.02841008f, 
    -0.02656654f, -0.09240783f, 0.15123218f, -0.00826146f, -0.06144248f, 0.05265269f, 0.12449929f, -0.06521637f, 
    -0.10824989f, 0.63978660f, 0.17400865f, -0.21842071f, -0.19397342f, 0.13903274f, -0.06630487f, -0.07883196f, 
    0.10227057f, -0.19119705f, -0.03250178f, 0.07707255f, -0.00147295f, 0.12836783f, -0.12736182f, 0.23955332f, 
    0.00627034f, 0.03686409f, 0.05804365f, -0.04587940f, 0.14684081f, -0.12882149f, -0.05467683f, 0.19041821f, 
    0.10091781f, -0.38281193f, 0.15016319f, 0.60463595f, 0.07771711f, -0.13937272f, -0.23859164f, 0.17128941f, 
    0.01400664f, 0.03291041f, 0.01219589f, 0.02794407f, -0.00164096f, 0.06690539f, 0.10342736f, -0.13918242f, 
    0.04849092f, 0.13431293f, -0.32348797f, -0.00432675f, 0.27414554f, 0.50446981f, -0.07796802f, -0.02724266f, 
    0.17705402f, 0.06546775f, -0.07040311f, 0.03631860f, 0.53192729f, -0.03242752f, -0.00782767f, -0.01698977f, 
    0.16984026f, -0.07948522f, 0.22974433f, 0.12226020f, 0.04711961f, -0.04094793f, 0.21073432f, -0.04340255f, 
    -0.15321404f, 0.02739722f, -0.08603017f, 0.11574897f, 0.06038834f, 0.12541766f, 0.09105015f, 0.02623397f, 
    -0.06688946f, -0.44662711f, 0.05387552f, -0.06835023f, 0.06171177f, 0.07335554f, -0.03994965f, -0.07490112f, 
    -0.02299618f, -0.06485012f, -0.05344925f, -0.10749315f, 0.09496915f, -0.00985188f, 0.07972001f, 0.10604717f, 
    0.03477881f, -0.08045463f, -0.02483119f, -0.02226382f, 0.36990902f, 0.04489236f, -0.07117952f, 0.12509497f, 
    0.39517453f, 0.04966954f, 0.04153726f, -0.01198407f, 0.01625636f, -0.18887942f, 0.34165159f, 0.08760874f, 
    -0.00508044f, 0.26109847f, -0.31570494f, 0.61395395f, -0.16797194f, 0.00597066f, -0.03113599f, 0.09714907f, 
    0.07079203f, -0.03610023f, -0.01269015f, 0.07737913f, -0.07668052f, -0.09575558f, -0.00449423f, 0.01024382f, 
    -0.07170719f, 0.04142332f, -0.08439212f, 0.02995109f, -0.03376957f, -0.07060297f, 0.04849120f, -0.00153329f, 
    0.05263682f, -0.03708928f, -0.07583842f, 0.05017187f, -0.04102283f, -0.08333880f, -0.04325494f, -0.01258896f, 
    -0.08081263f, -0.03892432f, 0.08151597f, -0.06873956f, -0.00911995f, 0.00222525f, -0.05415004f, -0.05522690f, 
    -0.02635455f, -0.01147063f, 0.00754110f, 0.01268743f, -0.01751278f, 0.06228574f, 0.01590074f, 0.04666422f, 
    0.04439387f, -0.05102012f, -0.01985552f, -0.00807878f, 0.05284380f, -0.09315165f, 0.03710053f, 0.02268290f, 
    0.01572268f, 0.02590955f, -0.05776959f, -0.10897886f, -0.05283479f, -0.02475125f, -0.02784966f, -0.05667629f, 
    0.07526367f, 0.05730807f, -0.00449055f, -0.07140893f, -0.09156795f, 0.01338666f, -0.02070986f, -0.02026071f, 
    -0.04732317f, 0.06924652f, -0.11140421f, 0.04229630f, -0.03016997f, 0.04976390f, -0.04631502f, -0.01506688f, 
    -0.07424667f, 0.07043251f, 0.03892043f, -0.01095721f, 0.00742409f, 0.03316613f, 0.08623560f, -0.00466948f, 
    -0.03425869f, -0.02465655f, -0.08373650f, -0.08250885f, 0.00990340f, -0.09570021f, -0.06850170f, -0.02883106f, 
    0.04672192f, -0.08727890f, -0.05081245f, 0.06665026f, 0.03458273f, 0.05669690f, -0.06821790f, 0.05262687f, 
    -0.03443420f, -0.08645421f, -0.00530545f, 0.04136680f, 0.02233749f, 0.00859470f, -0.07977104f, -0.04021828f, 
    0.03674968f, -0.00713474f, -0.00639774f, -0.07276567f, -0.00384548f, -0.03030405f, 0.00057525f, -0.06495316f, 
    0.06682097f, -0.06773754f, 0.04414973f, 0.06911801f, -0.01558685f, 0.01113855f, -0.06254146f, -0.03010408f, 
    0.05435409f, -0.01636030f, 0.05628798f, 0.08283508f, -0.05028638f, -0.06490215f, 0.03443658f, 0.08172093f, 
    -0.26288030f, 0.01600825f, 0.11313684f, -0.27307585f, -0.02047813f, 0.65604812f, 0.45232701f, 0.42045638f, 
    -0.18714604f, 0.26262200f, -0.41820693f, -0.09209681f, -0.18421331f, -0.12316167f, 0.13138621f, -0.23772216f, 
    0.12806463f, 0.25589097f, -0.20786424f, -0.16655253f, 0.53712869f, 0.19925137f, 0.13927661f, -0.06182997f, 
    -0.13862561f, 0.37468028f, 0.10087239f, 0.22982353f, 0.55650038f, -0.05976412f, 0.47842056f, -0.07308928f, 
    -0.43117842f, -0.10886171f, 0.11421434f, -0.00157724f, 0.24246363f, 0.21734819f, -0.05320315f, -0.25233918f, 
    -0.07577059f, -0.52803129f, 0.12129697f, -0.46568272f, 0.76214063f, -0.27115691f, 0.04050982f, -0.00411983f, 
    0.08805671f, -0.04739302f, -0.08060453f, -0.16965652f, -0.15866719f, -0.02190349f, -0.09626405f, 0.05473366f, 
    -0.01943737f, -0.21816444f, -0.21176858f, 0.01578721f, -0.46202058f, -0.17822754f, 0.11536431f, -0.06343790f, 
    0.30258700f, 0.10413665f, 0.05774593f, 0.25537792f, 0.44697019f, 0.21169050f, -0.31282225f, 0.06066801f, 
    0.45372248f, -0.04486283f, -0.30463162f, 0.10120856f, 0.07728349f, -0.08229513f, -0.23353961f, 0.06598415f, 
    0.17552213f, 0.35836115f, -0.03290830f, -0.25834310f, 0.00089277f, -0.15247694f, 0.13395625f, 0.06661420f, 
    0.23319966f, 0.32620054f, 0.06259442f, 0.01979381f, -0.08809039f, -0.21690466f, 0.05383663f, -0.11215345f, 
    -0.10129644f, -0.03202401f, 0.10537536f, 0.10938805f, 0.03696273f, -0.05419292f, 0.06189103f, -0.42294380f, 
    -0.10216166f, -0.27262112f, 0.17741881f, 0.07127166f, 0.17473401f, -0.08355902f, -0.31861413f, -0.55431294f, 
    -0.24211116f, 0.07064497f, 0.14700040f, 0.14424002f, -0.07338592f, 0.04766804f, -0.10896173f, -0.21937300f, 
    0.18122353f, 0.11902823f, 0.03457316f, 0.17004852f, 0.06598729f, -0.20218481f, 0.04439284f, 0.02802869f, 
    0.06703439f, -0.24564239f, -0.33092120f, -0.16708893f, -0.37218168f, -0.12035143f, -0.32091433f, -0.08252206f, 
    0.22891548f, -0.03892567f, -0.07227181f, 0.10974742f, 0.11185395f, -0.02316486f, -0.05474385f, 0.05958815f, 
    0.18666422f, 0.05102308f, 0.03687932f, 0.26074880f, -0.13519989f, 0.20518541f, -0.05551425f, -0.08245155f, 
    -0.36606589f, 0.08609795f, 0.11050238f, -0.30863360f, -0.10900677f, -0.10056657f, 0.18197431f, 0.31630987f, 
    0.02486779f, 0.28930297f, -0.18974899f, 0.06123398f, -0.05446906f, -0.02658535f, -0.04623640f, -0.46456051f, 
    0.09132113f, 0.53245950f, -0.04004190f, -0.52851832f, -0.01129351f, 0.13476528f, 0.35848004f, -0.30221599f, 
    -0.00227320f, 0.06354050f, -0.09268366f, 0.01276843f, 0.11211365f, 0.17288588f, -0.38460106f, -0.01405316f, 
    0.07946263f, -0.05928970f, 0.05847725f, 0.23113742f, -0.54680860f, -0.24863383f, -0.09068845f, 0.17103650f, 
    0.14216168f, 0.18129821f, -0.32676700f, -0.17264426f, 0.46273232f, -0.24821001f, -0.15737092f, 0.03205805f, 
    0.08775202f, 0.05130705f, 0.14159785f, -0.05565800f, -0.12017564f, -0.14943601f, -0.07913991f, 0.10077094f, 
    -0.02118049f, -0.45620611f, -0.27009752f, 0.20385198f, 0.08482236f, -0.08862925f, 0.20821168f, 0.01632251f, 
    0.00550566f, 0.19368732f, 0.03464626f, -0.01465494f, 0.11215949f, 0.18843874f, -0.05199249f, -0.05681212f, 
    -0.01121257f, -0.06063801f, 0.07522444f, 0.17741916f, 0.11029194f, 0.02629468f, 0.15329459f, -0.29068646f, 
    -0.11511518f, 0.23846336f, -0.29015383f, -0.01744224f, 0.10223515f, 0.33614638f, 0.03967174f, 0.00674895f, 
    0.01201885f, 0.06047924f, -0.06257657f, -0.05821626f, -0.00562902f, 0.04652045f, 0.32177159f, 0.38873342f, 
    -0.22672541f, 0.05960097f, -0.05709833f, 0.09567089f, 0.20590171f, 0.13321674f, 0.04143696f, 0.08074149f, 
    0.04168752f, -0.05312423f, -0.02674010f, 0.01526651f, 0.05925400f, -0.06410523f, 0.07834098f, 0.03257457f, 
    -0.01664480f, 0.07653245f, 0.01711614f, -0.01078380f, 0.02140811f, 0.02522168f, -0.09420116f, 0.02302500f, 
    -0.10071571f, 0.03137741f, -0.01485931f, 0.04128320f, -0.06140455f, -0.00431806f, -0.04226594f, 0.04785070f, 
    0.01836008f, -0.06693961f, -0.03666079f, -0.02221035f, 0.08475205f, 0.01874817f, 0.06774195f, 0.00808106f, 
    -0.00763711f, 0.01731274f, -0.08233535f, -0.05846343f, 0.04398055f, -0.06486207f, -0.05806451f, -0.06140222f, 
    -0.01985332f, -0.01861351f, -0.08392350f, 0.04388216f, -0.04847128f, 0.02435984f, -0.05682193f, 0.05195855f, 
    -0.02794565f, -0.04669410f, 0.00555904f, -0.04500565f, -0.07894177f, 0.07012136f, -0.06186836f, -0.03777630f, 
    -0.04557751f, -0.07455671f, -0.06819186f, -0.03624226f, -0.05957803f, -0.02753487f, -0.06155407f, -0.05536148f, 
    -0.05459496f, -0.05321621f, -0.04926260f, -0.08735141f, 0.01741108f, -0.07642184f, -0.03651513f, -0.01479291f, 
    0.04786398f, 0.04481732f, 0.03539880f, -0.02684222f, 0.03080718f, -0.09003116f, 0.03856879f, -0.04524845f, 
    0.02435558f, 0.01441097f, 0.07316031f, -0.06416140f, 0.05568556f, 0.00771606f, -0.07649801f, -0.00594892f, 
    0.05788868f, -0.03496040f, -0.05040346f, -0.05987808f, 0.03773891f, -0.08769307f, -0.08802229f, -0.03531932f, 
    -0.01658911f, -0.04340092f, 0.04761237f, -0.04497161f, -0.01358344f, -0.00636342f, 0.01632899f, 0.03501765f, 
    0.06766036f, -0.07614236f, -0.05306488f, -0.01577247f, -0.03452023f, -0.05713232f, 0.06094326f, -0.05942622f, 
    0.05885456f, -0.04360747f, -0.00109363f, 0.00826516f, -0.06324136f, -0.02922436f, -0.07494454f, 0.00262009f, 
    0.06366076f, 0.04122074f, -0.02513191f, -0.08393700f, -0.02711473f, -0.05327240f, -0.06649105f, 0.01193767f, 
    0.06616431f, 0.16317631f, 0.14693168f, -0.25425163f, -0.07062557f, -0.05243606f, 0.19075470f, 0.02206472f, 
    -0.08964089f, 0.40172714f, -0.11824626f, -0.06693026f, -0.08020075f, 0.07120402f, -0.05601627f, 0.17550957f, 
    0.21993375f, -0.01498945f, 0.04359371f, 0.19780600f, 0.53966695f, 0.15576975f, -0.08318240f, 0.04459670f, 
    -0.25478196f, 0.39756048f, 0.11461079f, -0.02689394f, 0.21067350f, -0.24060048f, 0.36295605f, 0.52493989f, 
    -0.01680754f, -0.27522394f, -0.26898292f, -0.04946408f, 0.23871374f, 0.16249701f, 0.03473864f, -0.00270058f, 
    -0.25333789f, 0.25985721f, -0.10118876f, -0.51549494f, 0.14586835f, 0.00648023f, 0.14859098f, -0.05006442f, 
    0.01495892f, -0.01039029f, -0.00627494f, 0.17422409f, 0.16750208f, -0.03521617f, -0.00043298f, -0.15646766f, 
    0.05435412f, -0.07664709f, 0.39379406f, -0.24273391f, -0.39407542f, 0.15085046f, 0.17926265f, 0.04238787f, 
    0.21631464f, -0.26690209f, 0.18233953f, 0.07303822f, 0.06461703f, 0.02867378f, 0.13343354f, 0.06999379f, 
    0.11275040f, -0.02975172f, -0.15596797f, -0.08074281f, -0.37206581f, -0.21773694f, 0.00016206f, 0.09999312f, 
    0.26732683f, -0.15817028f, 0.10783839f, -0.14845034f, 0.11053070f, -0.04115920f, 0.41234446f, 0.07814395f, 
    -0.02491515f, -0.15699768f, 0.18186179f, 0.02174478f, -0.07926533f, 0.10399225f, -0.02525186f, 0.04581349f, 
    -0.18917477f, 0.10078769f, -0.07190876f, 0.04368934f, 0.00472931f, -0.00176355f, 0.02607086f, 0.00038003f, 
    0.10865600f, -0.24070638f, 0.08529121f, 0.08257111f, -0.11192565f, 0.01996129f, -0.18628252f, -0.24531260f, 
    0.16638413f, 0.06810282f, 0.00367934f, -0.10546350f, 0.00796683f, 0.10500362f, 0.23419063f, -0.27297181f, 
    0.28241822f, -0.04651477f, 0.09960466f, -0.24534746f, -0.03200737f, 0.00778935f, 0.04933228f, 0.36971790f, 
    0.13788822f, -0.19383837f, 0.24732225f, -0.14590099f, -0.00204962f, -0.25082871f, -0.02042718f, -0.16043961f, 
    -0.54856831f, 0.09516266f, 0.00164989f, -0.08998808f, 0.12152709f, 0.04891713f, 0.09678205f, 0.11446309f, 
    -0.08147712f, 0.12752597f, 0.00560230f, -0.47363269f, -0.27667201f, 0.10330970f, -0.04201322f, -0.03242116f, 
    0.05754412f, 0.07139318f, -0.10845052f, -0.10689462f, 0.04053475f, 0.11975080f, 0.09054097f, 0.41995254f, 
    0.20041400f, -0.11089027f, -0.12756865f, -0.06942706f, -0.13909215f, -0.44942477f, -0.01250013f, -0.25352564f, 
    0.18604338f, -0.31464976f, 0.06127260f, 0.27649143f, 0.24196802f, 0.24781556f, -0.15780027f, -0.00573817f, 
    0.05344338f, 0.05527519f, -0.02137635f, 0.09194823f, 0.13633974f, 0.09771024f, 0.14548501f, 0.00448895f, 
    -0.05945722f, 0.35738021f, -0.03823015f, -0.10334329f, 0.33077538f, -0.06072557f, 0.14231089f, -0.13474885f, 
    -0.05500683f, -0.06869295f, -0.02053723f, 0.01184291f, 0.45980883f, 0.17202759f, -0.08227986f, -0.06054261f, 
    0.20134380f, 0.00641097f, 0.12064057f, 0.31061089f, -0.09627838f, -0.16376527f, -0.05991422f, 0.27729377f, 
    0.15239264f, -0.03516354f, -0.00137441f, -0.07755169f, -0.20270002f, 0.10023821f, 0.12169217f, 0.02516281f, 
    0.01548954f, 0.06203307f, 0.00754195f, 0.02985442f, 0.06754322f, 0.30925354f, -0.17388189f, 0.09166560f, 
    0.12451017f, -0.06937523f, 0.11429767f, 0.17780140f, 0.13270529f, 0.16690347f, -0.02388242f, 0.19498415f, 
    0.35933936f, 0.18877134f, 0.11633722f, -0.04879116f, -0.06949188f, -0.02822560f, 0.13800675f, 0.09445869f, 
    -0.29996100f, 0.03825729f, 0.09073912f, -0.15395015f, 0.08993966f, -0.05807167f, 0.14664939f, -0.16667682f, 
    0.30527657f, -0.04646369f, -0.58460408f, 0.45277056f, -0.01508926f, 0.00788738f, 0.15119225f, 0.17904550f, 
    0.23015623f, -0.31060275f, -0.48215988f, -0.00967073f, -0.35739979f, -0.03247852f, -0.01677396f, -0.02754369f, 
    0.14374939f, 0.06715360f, 0.18864393f, -0.00822257f, -0.18390898f, -0.19829127f, -0.59747589f, 0.20166053f, 
    -0.21868218f, -0.70171314f, 0.29625484f, 0.43413934f, 0.32124203f, -0.14332777f, -0.17047249f, 0.03892019f, 
    0.11579303f, 0.22315417f, 0.04351567f, -0.77710009f, -0.01378974f, -0.13265358f, 0.38505083f, 0.23600155f, 
    -0.17027165f, -0.01224480f, 0.03255257f, -0.00394751f, -0.18659472f, -0.15919285f, 0.03913642f, -0.20782050f, 
    -0.00728484f, -0.19490351f, 0.08486935f, -0.44860488f, -0.31507251f, 0.60500640f, 0.59674829f, -0.23414627f, 
    0.03629818f, 0.08466084f, -0.04525873f, 0.19914120f, 0.15789276f, -0.22152969f, -0.24490780f, -0.10886966f, 
    0.07582422f, -0.13567583f, -0.08643465f, 0.44300875f, -0.45047092f, -0.27554226f, 0.11513029f, 0.08082853f, 
    -0.17699790f, 0.34515172f, 0.05820075f, -0.43259400f, 0.05652615f, 0.15740381f, 0.15449384f, 0.03803406f, 
    0.29577193f, -0.02038242f, -0.51342040f, 0.05320358f, -0.05615497f, 0.09635493f, -0.07993912f, 0.08089594f, 
    0.18019673f, -0.09899327f, 0.17866197f, 0.12504454f, -0.56687397f, 0.21401358f, -0.09805556f, 0.05493654f, 
    -0.13186470f, -0.15645006f, 0.03025997f, 0.06070028f, -0.06436087f, -0.17132905f, -0.24294575f, 0.26317260f, 
    0.34890264f, -0.02704570f, 0.12479768f, 0.17680682f, -0.30186850f, -0.03456236f, -0.08885168f, 0.16515672f, 
    -0.27000389f, 0.15226251f, 0.10313988f, 0.07389808f, 0.22669780f, 0.18921021f, 0.11579277f, 0.13679668f, 
    -0.32424811f, -0.02162820f, 0.15929633f, 0.34732682f, -0.00159117f, 0.34830850f, -0.11211637f, 0.19351159f, 
    0.28468442f, -0.03602892f, 0.24073981f, -0.11536320f, 0.35208699f, 0.14785622f, -0.19924599f, -0.21182235f, 
    0.04781691f, -0.09832027f, -0.07784308f, -0.12293319f, -0.11995973f, 0.06330867f, -0.22215277f, 0.03742057f, 
    0.27769995f, 0.12179972f, 0.34695980f, 0.22374319f, 0.07571108f, -0.02047489f, -0.19739723f, 0.19782789f, 
    -0.09449204f, -0.10485473f, 0.12811306f, 0.44601151f, -0.17913432f, 0.41017297f, -0.10799999f, 0.07808286f, 
    -0.36763352f, 0.01211838f, 0.16681777f, -0.14310831f, -0.30770749f, -0.08187892f, -0.00256382f, 0.05284787f, 
    0.01030663f, 0.08004840f, -0.18441060f, 0.06924788f, -0.02370922f, 0.03068755f, 0.07520130f, 0.21023655f, 
    -0.02521057f, 0.06457116f, -0.09628374f, -0.45638451f, -0.25326085f, 0.22152567f, 0.29268196f, -0.02257787f, 
    -0.03586048f, -0.16806854f, 0.02747265f, 0.05315729f, 0.12509400f, 0.06655461f, -0.13007931f, -0.03412465f, 
    -0.07500923f, -0.06235810f, 0.09257618f, 0.14217344f, -0.23620987f, -0.01937733f, 0.02813988f, -0.04711981f, 
    0.11895210f, 0.22397780f, -0.24436730f, -0.12161343f, 0.19125928f, 0.14482729f, 0.54831356f, 0.06373378f, 
    -0.17819542f, -0.04212242f, 0.09278558f, -0.01176228f, -0.04797697f, -0.11388923f, -0.03183462f, 0.02364526f, 
    0.13457198f, -0.33544564f, -0.35883576f, 0.23894238f, 0.03283207f, 0.14495498f, 0.12671959f, 0.11860762f, 
    0.08090255f, 0.09480088f, 0.28253105f, -0.04641348f, -0.04006583f, 0.27143630f, -0.06537983f, -0.02659849f, 
    -0.00284987f, 0.06606214f, 0.10248070f, 0.29156038f, 0.01082664f, -0.04629010f, 0.26244178f, -0.07849733f, 
    0.02019988f, 0.07594549f, 0.03313965f, 0.02593225f, -0.07651728f, 0.34113955f, -0.02487350f, -0.27004635f, 
    0.30008048f, -0.07261648f, -0.29317191f, -0.00329524f, -0.07812947f, 0.24537528f, 0.32789454f, 0.45195651f, 
    -0.12668319f, 0.14930291f, 0.06360560f, 0.15125160f, 0.09185117f, 0.24879760f, -0.15549159f, 0.14000811f, 
    0.08782900f, -0.02642765f, 0.16362233f, 0.16335207f, 0.07070343f, -0.09226822f, -0.05104690f, 0.05435776f, 
    -0.68348843f, 0.03151160f, 0.00931004f, -0.15473336f, 0.05435618f, 0.14157295f, 0.05952604f, -0.01712082f, 
    -0.07232706f, -0.15618140f, 0.04607853f, -0.78500402f, -0.49484763f, 0.09636241f, -0.15972070f, -0.02184787f, 
    0.45360181f, 0.20205750f, -0.24485022f, -0.11979130f, -0.15464389f, 0.13369584f, -0.20247419f, -0.24053347f, 
    -0.02504902f, 0.01292752f, -0.00008505f, 0.01747105f, 0.12542777f, -0.26770601f, -0.08211480f, -0.09207642f, 
    0.19479601f, -0.26693869f, -0.06205586f, -0.01392508f, 0.07520229f, 0.31829923f, -0.04676400f, 0.07666413f, 
    0.09442545f, 0.21248749f, 0.12929569f, 0.00366362f, 0.02787986f, 0.09392326f, 0.19216751f, -0.03781579f, 
    0.03783744f, 0.39780894f, -0.25558096f, 0.14857484f, 0.37565434f, -0.07158829f, 0.22621885f, -0.03551519f, 
    0.19148137f, 0.27182233f, 0.08975108f, 0.03623981f, 0.14290923f, 0.65457708f, 0.02073405f, -0.04227712f, 
    -0.37122333f, 0.02642268f, -0.24752647f, 0.24989249f, 0.32379109f, -0.03467096f, 0.06609540f, -0.06321193f, 
    -0.10511240f, 0.00000993f, 0.22813569f, 0.05959671f, -0.03872110f, -0.01686453f, -0.18604434f, -0.21417244f, 
    -0.07126388f, -0.00254812f, 0.16880254f, 0.02596958f, -0.05484538f, -0.11268604f, -0.13349648f, 0.02651241f, 
    0.14201373f, 0.04337483f, 0.13010907f, 0.21451871f, -0.07884224f, 0.18170382f, -0.22050160f, 0.37748301f, 
    0.31433168f, 0.17911628f, 0.12736005f, 0.02448061f, -0.05099796f, -0.15386228f, -0.05146747f, -0.04064732f, 
    -0.49862722f, -0.03163797f, -0.02390887f, -0.09760609f, 0.00731165f, -0.18555173f, -0.24449815f, -0.01736821f, 
    0.07260747f, 0.15670888f, -0.24975887f, 0.10175188f, 0.07722435f, -0.05875481f, -0.12339470f, 0.00402836f, 
    -0.07519338f, -0.03441940f, 0.06937058f, -0.07019448f, 0.05236867f, -0.00576916f, 0.01773009f, -0.00142666f, 
    -0.07406891f, -0.02536645f, -0.03747196f, -0.04378858f, -0.07301348f, 0.04911374f, -0.00687022f, 0.06971981f, 
    -0.00359482f, -0.01535504f, 0.02115116f, 0.00861043f, 0.02791226f, -0.03404706f, 0.07642956f, 0.06650912f, 
    0.06227399f, -0.12072944f, 0.06827752f, -0.08399968f, 0.00179346f, -0.01348167f, -0.03094350f, -0.06117764f, 
    -0.04799660f, -0.03616473f, 0.02009181f, 0.01169572f, -0.09209945f, 0.03881083f, -0.09208071f, 0.05394558f, 
    -0.06791820f, -0.05403123f, -0.08856100f, 0.04876900f, 0.01965494f, 0.02213918f, -0.01827271f, -0.07572468f, 
    0.04783878f, 0.02998898f, -0.05273661f, -0.06467444f, -0.06213002f, 0.07141302f, -0.08967409f, -0.09346810f, 
    -0.00487748f, 0.00840743f, 0.05834658f, 0.05462241f, -0.03134356f, 0.07493889f, -0.06798784f, 0.06182931f, 
    -0.04615830f, -0.06775265f, -0.04358780f, 0.01490839f, 0.05287034f, -0.05527927f, 0.00982392f, 0.03557694f, 
    0.01421952f, 0.00144192f, -0.03242968f, -0.03269040f, -0.07535776f, -0.08012217f, 0.00443767f, 0.05154734f, 
    -0.08310588f, -0.07515116f, -0.01184405f, -0.00870356f, -0.00502378f, -0.08661872f, -0.03124410f, -0.05436154f, 
    -0.00769582f, -0.08653931f, -0.10268022f, 0.02881756f, -0.04950445f, 0.06965731f, -0.02893232f, -0.07714753f, 
    0.05994775f, 0.04248371f, -0.07764238f, -0.08169880f, -0.06602588f, -0.06866791f, 0.02595649f, 0.04943152f, 
    0.00290216f, 0.02200605f, 0.01507438f, -0.07769755f, -0.07135838f, -0.04487837f, -0.06612691f, 0.07270763f, 
    0.07113455f, 0.05876764f, 0.01856934f, -0.06161480f, -0.00648184f, 0.05233660f, -0.02775318f, 0.05824893f, 
    0.06243790f, -0.06560658f, -0.07300144f, 0.07611821f, 0.05357799f, -0.01001025f, -0.02570229f, 0.07498021f, 
    -0.07935501f, -0.00088864f, -0.05760221f, 0.05086289f, 0.07995330f, -0.09580293f, 0.00000771f, 0.00622170f, 
    -0.00367841f, -0.01194812f, 0.03738606f, -0.02287262f, 0.07140895f, -0.06931102f, -0.09358487f, 0.03523316f, 
    0.05498781f, -0.03978866f, -0.04181636f, 0.01792845f, 0.04326329f, 0.02710625f, 0.02510751f, 0.03351275f, 
    -0.08727500f, -0.00985061f, -0.01770716f, 0.06581160f, 0.00161960f, 0.05263917f, 0.00207700f, -0.04325975f, 
    0.06859884f, -0.05421757f, 0.04085088f, -0.07816079f, 0.05506629f, -0.06189035f, -0.00906938f, 0.07496193f, 
    -0.05073790f, 0.01481818f, -0.06718791f, -0.01985170f, -0.00006494f, -0.01721070f, -0.02341709f, 0.08692149f, 
    -0.06209072f, -0.01585225f, 0.04484502f, -0.07052153f, 0.01272753f, -0.06503984f, -0.00143095f, -0.00192712f, 
    -0.05756676f, 0.06772561f, -0.00252553f, -0.09501682f, -0.02957242f, -0.05220491f, -0.02412052f, 0.03204637f, 
    0.05601662f, 0.07409773f, -0.07882384f, -0.09608673f, 0.02407689f, -0.01659428f, -0.06963395f, -0.07379204f, 
    0.07900386f, 0.00252863f, 0.04552610f, -0.01987200f, 0.02279313f, -0.05009072f, 0.06945002f, -0.08235775f, 
    -0.04350582f, -0.04144854f, -0.04040173f, -0.04121935f, -0.09484964f, -0.06093066f, 0.04857460f, 0.06303506f, 
    -0.07466402f, -0.05781239f, 0.02820629f, -0.05955304f, -0.01194686f, 0.06070559f, -0.06993780f, 0.06840430f, 
    0.07126100f, -0.02326834f, -0.08513343f, -0.07754359f, -0.07285734f, -0.06767927f, 0.03938757f, -0.01929067f, 
    -0.00563688f, -0.06421058f, -0.01666088f, -0.01885867f, 0.08236872f, -0.05498553f, 0.02965365f, -0.10152753f, 
    -0.07949606f, 0.01932590f, -0.01950308f, 0.02583386f, -0.03841565f, 0.00351528f, -0.05456129f, -0.03092018f, 
    0.00883021f, 0.03431473f, -0.01600209f, 0.04049483f, -0.06766984f, 0.04997958f, -0.04778965f, -0.04594892f, 
    -0.00056834f, 0.32276362f, 0.10818184f, -0.04501765f, 0.15004000f, -0.08989458f, 0.02430642f, 0.04484014f, 
    -0.29635778f, 0.36353892f, -0.18034092f, 0.01572363f, 0.04352934f, 0.16499150f, -0.00768779f, 0.14367715f, 
    -0.07792748f, -0.08224416f, 0.07385162f, -0.47258633f, 0.60818982f, -0.20381697f, 0.03159340f, -0.05179277f, 
    0.07048112f, -0.20776151f, 0.20664105f, 0.07614089f, 0.80777514f, -0.02158918f, -0.03198617f, -0.01381868f, 
    0.01367093f, -0.20867306f, 0.13376760f, -0.09054894f, 0.00953043f, 0.13869230f, -0.03256236f, 0.01039551f, 
    -0.15140276f, 0.08660331f, -0.12678334f, 0.00609061f, -0.29436082f, 0.11773667f, 0.03606320f, 0.03777472f, 
    0.27520359f, -0.13373756f, 0.04818485f, -0.00539257f, 0.02978328f, -0.11985677f, 0.48844773f, 0.16401577f, 
    -0.05400404f, -0.13257226f, 0.21197519f, -0.11908258f, 0.17500252f, 0.02978604f, 0.11968373f, 0.01800536f, 
    0.05167421f, -0.07881508f, 0.12032454f, 0.08431935f, -0.37177926f, 0.67248535f, -0.01578517f, 0.04641520f, 
    -0.03050334f, -0.07916678f, -0.18145007f, 0.12126295f, 0.08829281f, -0.12991084f, 0.11780527f, 0.21483591f, 
    0.09409667f, 0.04524055f, 0.35198519f, -0.21811913f, 0.23518445f, -0.09106653f, 0.10684698f, 0.09712388f, 
    0.22149831f, -0.25275552f, 0.08072864f, 0.01904160f, -0.07308184f, -0.03340643f, 0.13992730f, 0.02815629f, 
    0.05731164f, 0.02216264f, 0.00771243f, 0.16863713f, -0.09341166f, -0.23051654f, -0.25640100f, 0.29255825f, 
    0.12604223f, -0.26006305f, 0.14882644f, 0.06351406f, -0.14792703f, -0.05610213f, 0.07131832f, -0.13678364f, 
    0.07246018f, 0.08064854f, 0.26525918f, 0.13652247f, -0.10170883f, 0.19794373f, -0.18550362f, -0.07747091f, 
    0.33431646f, -0.04111995f, 0.33605000f, -0.45969597f, 0.00859564f, 0.05221319f, -0.01651902f, -0.08286855f, 
    0.10908835f, 0.10722158f, 0.01314524f, -0.02765608f, -0.17749527f, -0.00457143f, -0.36785638f, -0.21299399f, 
    0.22855714f, -0.11176923f, 0.15830919f, 0.28508052f, 0.17978068f, 0.13051812f, 0.04564358f, 0.02347410f, 
    0.12786819f, 0.15646324f, 0.08947943f, -0.08779293f, 0.28694215f, 0.19978748f, 0.00483736f, 0.04421955f, 
    -0.29672843f, -0.04802372f, 0.23740898f, 0.19039690f, -0.16814996f, -0.07772215f, -0.04151310f, 0.21581052f, 
    0.28989917f, 0.22033595f, 0.03437334f, -0.02275947f, 0.05579878f, 0.13850002f, -0.00563353f, -0.02700021f, 
    0.04054230f, -0.12502126f, -0.04232885f, -0.00988256f, -0.08535004f, -0.21250924f, -0.00072341f, -0.07508030f, 
    0.13772976f, -0.33945826f, 0.10257587f, 0.07275801f, 0.09234577f, 0.23891579f, -0.18094546f, 0.07691359f, 
    0.07940404f, 0.10120700f, 0.25220749f, -0.11511404f, 0.06975070f, 0.32000211f, -0.16773027f, -0.01250718f, 
    0.07862882f, -0.23975283f, -0.01729998f, -0.15962891f, 0.17831044f, -0.49637896f, -0.33866957f, -0.01465413f, 
    0.07601344f, -0.01718011f, 0.34256780f, -0.12280519f, -0.24066681f, 0.00388293f, 0.30360141f, 0.03760884f, 
    -0.05466464f, -0.04665015f, -0.24086784f, -0.00685791f, 0.20904189f, -0.06352416f, 0.13388339f, 0.13209197f, 
    0.16225962f, -0.07942111f, 0.03414639f, -0.01581166f, 0.00115106f, 0.23681599f, 0.06995137f, 0.00571676f, 
    -0.13464724f, -0.02782018f, -0.18184908f, 0.01394581f, 0.11394678f, -0.07041924f, 0.25073045f, -0.06405177f, 
    -0.06526083f, -0.13811386f, -0.12377522f, 0.03434272f, 0.30005112f, 0.03189668f, 0.07145713f, 0.10336924f, 
    0.57234073f, -0.09467087f, 0.21043476f, -0.14313860f, -0.05336536f, 0.06512623f, 0.14178136f, 0.21227215f, 
    -0.13073200f, 0.13335384f, 0.33809388f, 0.39818689f, -0.20258735f, 0.17898570f, 0.03583580f, 0.13289253f, 
    -0.28100204f, -0.02922444f, -0.12490498f, -0.07240051f, 0.17983139f, 0.30373448f, 0.05773819f, 0.30071330f, 
    0.16563064f, -0.07388547f, -0.63141418f, -0.26210281f, 0.10720842f, 0.04519683f, 0.14717363f, 0.09461313f, 
    0.05526036f, -0.03195424f, -0.24955928f, -0.56846803f, -0.10634115f, -0.33866122f, 0.27527592f, 0.05679274f, 
    0.11617336f, -0.22637527f, 0.07720168f, 0.05648161f, -0.47458851f, 0.30568397f, -0.09396050f, -0.16368333f, 
    0.05425956f, -0.00249769f, 0.31918293f, 0.05408613f, -0.39478692f, 0.15505613f, 0.00341642f, 0.03957335f, 
    0.10644504f, 0.48505330f, 0.07245416f, -0.34057435f, 0.13334844f, -0.03317184f, -0.16074584f, 0.03388749f, 
    0.09442696f, -0.19397224f, 0.28818855f, 0.00414550f, 0.10560025f, -0.10555722f, -0.03646740f, 0.39774185f, 
    -0.02649165f, -0.12372159f, -0.17712693f, -0.04522687f, -0.27625430f, -0.49856898f, 0.24614920f, 0.08445605f, 
    -0.19859117f, -0.18710247f, -0.06934487f, 0.01496961f, 0.27267796f, -0.42136973f, -0.61001939f, 0.07572830f, 
    0.11609484f, 0.02045899f, 0.20060703f, 0.20105664f, 0.21048681f, 0.03627660f, -0.57220471f, 0.05948978f, 
    0.06998836f, 0.14735740f, 0.13783357f, -0.33152330f, 0.21337947f, -0.13994917f, -0.37185857f, -0.00932943f, 
    0.24950001f, 0.73298496f, -0.37158602f, -0.07031994f, -0.08132678f, -0.21845403f, 0.40098348f, -0.10803261f, 
    -0.00685883f, -0.00440257f, 0.28658181f, 0.08222933f, 0.17761835f, 0.14984845f, -0.26508594f, -0.22627029f, 
    0.02462229f, 0.33457822f, 0.12148150f, -0.06982395f, -0.23136953f, -0.11711372f, 0.38149738f, -0.12892273f, 
    -0.30631015f, 0.01502766f, 0.08088268f, 0.07011418f, -0.06809613f, 0.07181730f, -0.38826254f, 0.12521756f, 
    0.06079571f, -0.51776010f, 0.40865692f, 0.23520564f, -0.07984196f, -0.03569514f, 0.38591349f, -0.25151563f, 
    -0.06029049f, 0.36286432f, -0.25046781f, 0.52437538f, 0.30091262f, -0.20720226f, -0.46564183f, 0.07814500f, 
    -0.18222775f, -0.13272849f, 0.22816728f, 0.24770012f, 0.06272870f, 0.17274930f, 0.04996990f, -0.04798803f, 
    0.19090562f, -0.16488862f, 0.13482641f, -0.32030946f, 0.03716661f, -0.12212570f, -0.02935121f, 0.09286032f, 
    0.15623909f, -0.10762808f, -0.39882910f, -0.22926570f, -0.15340105f, -0.01715259f, -0.30758697f, -0.24689274f, 
    0.03846166f, 0.27613452f, 0.20119363f, -0.06567974f, 0.11086056f, 0.05828066f, -0.01303392f, 0.33582753f, 
    -0.04280594f, 0.40913743f, -0.05317203f, 0.04991070f, -0.65026015f, 0.13070877f, 0.23632123f, -0.03737561f, 
    0.10040946f, 0.36617726f, 0.15906207f, 0.08121074f, 0.05481496f, 0.19445536f, -0.28673077f, 0.24501784f, 
    0.01312518f, 0.04609323f, 0.03631646f, 0.16137369f, 0.03216441f, -0.05648034f, -0.06064849f, 0.34575328f, 
    0.14699261f, 0.19501264f, 0.28804174f, -0.07471234f, -0.42731059f, -0.04884392f, -0.16896191f, 0.07163909f, 
    -0.38974056f, -0.01048068f, 0.04125857f, -0.17852607f, 0.12182903f, 0.38981101f, 0.22682029f, -0.10000374f, 
    -0.04781193f, -0.04557778f, 0.31707710f, 0.13471448f, 0.12166843f, 0.08276622f, -0.06067299f, 0.05874139f, 
    0.05254426f, -0.01160783f, 0.03625589f, 0.07721476f, -0.01892222f, -0.14867997f, 0.37781966f, 0.15962963f, 
    0.15811580f, 0.07894745f, -0.18579561f, 0.02133350f, -0.05773103f, -0.01227431f, -0.03534079f, -0.00194534f, 
    -0.00486960f, 0.20216377f, -0.05318606f, -0.03533616f, 0.05074981f, 0.27014264f, 0.00714946f, 0.12667361f, 
    -0.05877425f, 0.04689629f, 0.02275389f, 0.34667695f, 0.05828780f, 0.04660336f, -0.26597428f, 0.22553430f, 
    -0.10686958f, 0.18025687f, 0.11580241f, -0.14145643f, 0.14521797f, 0.18954071f, -0.09535930f, -0.27170649f, 
    0.04400240f, 0.02853111f, -0.05742759f, -0.00832084f, -0.08400510f, -0.07976696f, 0.01339477f, -0.05103050f, 
    -0.04789321f, -0.01774762f, -0.07940397f, 0.01362196f, -0.01547023f, -0.05741020f, 0.00931759f, -0.00935508f, 
    -0.09612165f, -0.08628353f, -0.11396582f, -0.01093525f, 0.06497546f, 0.00748929f, -0.05422029f, -0.06055396f, 
    -0.09326752f, 0.00428864f, 0.08124952f, -0.00777886f, -0.00802901f, 0.05351868f, 0.02236451f, -0.02183237f, 
    -0.09205400f, 0.04170969f, -0.04850652f, -0.03344104f, -0.02237793f, -0.04690306f, -0.02806577f, -0.01247606f, 
    -0.08259104f, 0.02819475f, -0.05416112f, -0.10252915f, -0.00056536f, -0.01024596f, -0.06521619f, 0.01215414f, 
    -0.05879994f, 0.00432640f, -0.05302882f, 0.07511631f, -0.03947949f, -0.05384995f, -0.09686032f, -0.03764448f, 
    0.00037540f, -0.09433619f, 0.04762315f, 0.00034245f, -0.01159353f, 0.04594428f, 0.03102231f, -0.09262598f, 
    -0.10221023f, -0.08408728f, 0.04387332f, -0.08886330f, -0.03026052f, 0.00342248f, -0.06956707f, -0.00810979f, 
    -0.03255743f, -0.01573537f, -0.01887679f, 0.02349237f, 0.06434180f, -0.00356832f, -0.02394451f, -0.11027869f, 
    -0.10803153f, -0.08461069f, 0.00001943f, 0.01791555f, -0.06958994f, -0.09408755f, -0.07847107f, 0.02110948f, 
    0.03689369f, -0.06441075f, -0.10439902f, 0.02524176f, 0.01869224f, -0.05140721f, -0.06720202f, -0.06393684f, 
    -0.05995579f, -0.02145653f, -0.08225060f, 0.02979332f, -0.03468212f, -0.05360610f, -0.02389025f, -0.09418722f, 
    -0.09499734f, -0.06006917f, 0.05058626f, -0.07696556f, 0.07433489f, 0.03403411f, -0.08384627f, -0.10503857f, 
    0.02482314f, 0.04590950f, 0.03875348f, -0.00971846f, 0.07840315f, 0.01516368f, 0.02675626f, -0.07398847f, 
    -0.03251539f, 0.04339758f, -0.04788188f, -0.05631072f, -0.08231246f, -0.01755880f, 0.01710883f, -0.11655425f, 
    -0.03453916f, 0.00024814f, -0.04063656f, -0.05787460f, -0.05994587f, 0.00018260f, -0.10991355f, 0.03245978f, 
    0.00537997f, -0.08883391f, 0.03154650f, -0.08754724f, -0.09247073f, -0.07057542f, 0.02544037f, -0.08814689f, 
    -0.07266078f, 0.05688982f, -0.02903963f, -0.03259792f, -0.04435644f, -0.06651009f, -0.09572203f, 0.06029295f, 
    -0.07221408f, -0.11287867f, -0.06053658f, -0.08210769f, 0.00470319f, -0.06311937f, 0.06302104f, 0.03996791f, 
    -0.00585214f, -0.04197732f, 0.01370313f, -0.00214227f, 0.03657024f, -0.03937739f, 0.07564397f, -0.02060917f, 
    0.01264707f, -0.04353650f, 0.08391031f, 0.01418736f, -0.04514514f, 0.06321696f, 0.03606008f, 0.00445819f, 
    -0.03768450f, -0.08958914f, 0.00786062f, 0.03844447f, -0.06846351f, 0.05380707f, 0.04584737f, 0.04630477f, 
    -0.08201230f, -0.04422836f, 0.01203293f, -0.01029001f, -0.07585609f, -0.07430421f, -0.06893989f, -0.02233908f, 
    -0.01397914f, -0.08015413f, -0.11889377f, -0.01963843f, 0.05799865f, -0.02975444f, 0.00521912f, 0.08279514f, 
    -0.08625577f, 0.03508080f, 0.00026329f, -0.08241623f, 0.02904742f, 0.04987404f, -0.06005001f, -0.04056124f, 
    0.07131346f, -0.09110132f, 0.02958112f, 0.02761522f, -0.10299168f, -0.06708783f, 0.05690612f, 0.02762765f, 
    -0.02191612f, -0.04264492f, -0.03922870f, -0.04190557f, -0.00030326f, -0.09963837f, -0.09934658f, -0.01750134f, 
    -0.04919247f, 0.03761769f, 0.05280487f, -0.07378890f, -0.00830276f, 0.04897229f, -0.10849887f, 0.03969846f, 
    -0.02128966f, -0.07806049f, -0.10227675f, -0.00172903f, 0.04651892f, -0.03237071f, -0.04087628f, 0.02469972f, 
    -0.07019202f, 0.08346266f, -0.09308253f, -0.11065362f, 0.05787065f, 0.05105937f, -0.01883359f, -0.11832543f, 
    -0.01113700f, 0.08082476f, 0.01255615f, 0.06378606f, -0.02747124f, 0.01612470f, -0.03648858f, -0.09593826f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.09749885f, 0.09134711f, 0.09280684f, -0.24900746f, -0.02736083f, -0.03449230f, 0.08697546f, -0.15265669f, 
    -0.02475306f, -0.06204685f, 0.33249050f, 0.27567282f, 0.00106191f, -0.09837881f, -0.05515917f, 0.05119775f, 
    0.10855366f, 0.19640918f, 0.11025682f, -0.09371861f, 0.19059682f, -0.11301128f, 0.00860152f, -0.00931758f, 
    -0.05227021f, -0.10485628f, 0.17092536f, -0.02269058f, -0.00598292f, 0.25488839f, -0.08505017f, -0.03067187f, 
    0.16348656f, 0.13770507f, 0.12509365f, -0.05935090f, 0.29396588f, 0.13048914f, 0.07802684f, -0.07188094f, 
    -0.07035187f, -0.02728330f, 0.07488117f, 0.19057313f, 0.22205645f, 0.18428834f, 0.08939996f, 0.18302600f, 
    -0.14096925f, 0.13655539f, 0.03794130f, 0.04709617f, -0.17667370f, -0.05134908f, 0.25896475f, 0.01182479f, 
    -0.00152793f, 0.02750650f, -0.01884820f, 0.18383665f, -0.07605150f, -0.08080643f, 0.29055190f, -0.07532618f, 
    -0.07153099f, -0.06384753f, -0.03200136f, 0.20621097f, 0.13466243f, 0.02374750f, 0.24134344f, -0.03163635f, 
    0.04053416f, 0.13388188f, 0.10299370f, 0.11367539f, -0.10444300f, 0.06885903f, 0.02627343f, -0.10294464f, 
    -0.00998064f, -0.01853761f, -0.10892771f, 0.01896115f, -0.05628705f, 0.27963346f, 0.09188331f, 0.06401772f, 
    -0.00198221f, 0.26510397f, 0.25918645f, 0.00521386f, -0.02101267f, 0.06329785f, 0.19257350f, -0.07145812f, 
    0.19700101f, 0.07409398f, -0.05769661f, 0.02303451f, -0.05653158f, -0.11295561f, 0.10769506f, -0.14990070f, 
    0.15014882f, 0.09035905f, 0.27104530f, -0.07332500f, -0.16096099f, 0.09233844f, -0.03713898f, 0.00711207f, 
    -0.13023473f, 0.07396744f, 0.06116685f, 0.19605951f, 0.31119564f, 0.20195457f, 0.20428202f, 0.25339207f, 
    0.04280580f, -0.08768765f, 0.15122075f, 0.12051443f, -0.30323550f, 0.04310476f, -0.06199646f, -0.11471493f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.42123988f, 0.11355044f, -0.02531169f, 0.20048860f, 0.10642666f, 0.08875877f, -0.09056558f, -0.47741160f, 
    -0.11978692f, 0.01150167f, -0.00113982f, 0.05277801f, 0.04944896f, -0.06396353f, -0.08185248f, 0.09660629f, 
    -0.05675391f, -0.17773493f, -0.34587145f, -0.01549625f, -0.03335840f, 0.42958108f, -0.17585723f, 0.15419354f, 
    -0.01984900f, -0.06300129f, -0.03090755f, 0.29474604f, -0.15154003f, 0.05475195f, -0.44791010f, 0.05684659f, 
    -0.02724917f, 0.10922735f, 0.07610640f, -0.03618230f, 0.15269372f, 0.07878894f, -0.14531621f, -0.07978287f, 
    -0.07003208f, -0.27464303f, 0.07255968f, 0.04355852f, 0.05293949f, 0.06637428f, -0.68678916f, -0.18007906f, 
    0.06969532f, -0.04577657f, 0.12988523f, -0.02871781f, -0.21087460f, 0.09611839f, -0.10498035f, -0.00231715f, 
    0.00024690f, -0.08572937f, 0.25643027f, 0.00352720f, 0.35999519f, -0.03116741f, -0.00028417f, -0.07949524f, 
    0.04247578f, 0.21333127f, -0.64165354f, 0.11380212f, -0.08609240f, -0.01424928f, 0.12779498f, 0.01676630f, 
    -0.33834031f, 0.04828856f, 0.00417456f, -0.20259410f, -0.11133935f, 0.00194479f, 0.07709863f, -0.03133026f, 
    -0.18444186f, 0.22157784f, 0.02301816f, -0.09131959f, -0.00461091f, -0.15464240f, 0.21582071f, -0.02074519f, 
    0.00851185f, -0.10720039f, -0.75964403f, -0.03015783f, 0.02779008f, -0.01491543f, 0.08434874f, -0.08148315f, 
    -0.07841595f, 0.04073283f, -0.01922895f, 0.10710204f, 0.03714008f, 0.11868812f, 0.09651715f, 0.01571976f, 
    -0.01024087f, 0.07882407f, 0.27448088f, -0.10865664f, 0.08752619f, 0.22739655f, -0.01342440f, 0.07183150f, 
    -0.73033899f, 0.10528013f, 0.05988199f, -0.31750318f, 0.02790034f, -0.10697673f, 0.16737200f, 0.22955699f, 
    -0.06532002f, 0.01083552f, 0.04138139f, -0.13694513f, -0.36096054f, 0.10369598f, 0.06078505f, -0.05738613f, 
    -0.20708780f, -0.25368261f, -0.40084150f, 0.17753428f, -0.00031961f, 0.19980581f, 0.00313109f, 0.20982622f, 
    -0.10233685f, -0.03407842f, -0.49714056f, 0.13285473f, 0.00190923f, -0.02748676f, -0.07946297f, 0.06093291f, 
    0.16183473f, 0.23022495f, -0.25575307f, -0.00971052f, -0.04095330f, 0.19522592f, -0.18777238f, 0.01858638f, 
    -0.02586565f, 0.03886774f, -0.00867971f, -0.03587025f, 0.03919614f, -0.03488505f, 0.04096642f, -0.02037167f, 
    -0.18525968f, 0.05323644f, 0.15632147f, -0.08744451f, -0.17077936f, -0.01434628f, 0.14001344f, 0.27709317f, 
    0.03921285f, 0.05946171f, 0.00684327f, -0.01745077f, -0.20816228f, -0.34060514f, -0.42910969f, 0.04283755f, 
    0.07734271f, -0.09305251f, 0.17900042f, 0.07682440f, 0.03106413f, -0.00264726f, -0.09334920f, -0.02054624f, 
    -0.05646463f, -0.09570294f, -0.37053114f, 0.14776774f, -0.26785439f, -0.08620884f, 0.00997522f, -0.08058769f, 
    0.02208242f, 0.15327694f, 0.42598727f, 0.19599566f, -0.15422662f, -0.08126843f, -0.01779701f, -0.60832918f, 
    -0.06572995f, -0.47190234f, 0.30374590f, -0.24411990f, -0.07698360f, -0.02400655f, 0.01637475f, -0.06438155f, 
    -0.34901905f, 0.12924390f, -0.02794312f, -0.02163098f, -0.07082642f, -0.03796307f, 0.07424406f, -0.04143772f, 
    -0.04849824f, 0.07441435f, -0.07272804f, -0.05868436f, -0.03468947f, -0.07133684f, -0.43503642f, -0.07023416f, 
    -0.03569331f, -0.02516274f, 0.02776127f, 0.07957374f, 0.04004194f, 0.12060265f, -0.31352732f, 0.16184691f, 
    -0.29084057f, 0.12802060f, -0.01821868f, -0.09727274f, -0.05460010f, 0.02653938f, -0.26929262f, -0.01433228f, 
    -0.06577216f, -0.10744670f, 0.05889853f, 0.16396964f, -0.25345102f, 0.42205635f, 0.06339964f, -0.33204356f, 
    -0.04550497f, 0.01517098f, 0.19590935f, 0.06157470f, 0.18738246f, 0.11182872f, 0.04177120f, -0.02058095f, 
    -0.15786786f, 0.09340654f, -0.13566081f, 0.14358783f, -0.49159175f, 0.06355821f, 0.19120319f, -0.17826135f, 
    -0.04972000f, 0.04505597f, -0.45456457f, 0.11154481f, 0.01889036f, 0.01844284f, -0.06518981f, 0.15022343f, 
    0.23300932f, -0.79394817f, 0.19127564f, 0.03643187f, -0.01824076f, 0.03240595f, 0.09989531f, -0.02584282f, 
    0.02113602f, -0.05201985f, -0.49653396f, 0.04172660f, 0.20226847f, 0.14033164f, -0.35138041f, 0.01754111f, 
    -0.65137684f, -0.57666045f, 0.02494328f, 0.02249850f, 0.18633710f, 0.15226482f, 0.25205946f, -0.48275471f, 
    0.07244257f, -0.35723364f, -0.00555272f, -0.12941274f, 0.15267564f, -0.21173102f, 0.12610514f, -0.05055207f, 
    -0.45962110f, -0.49520141f, 0.11444692f, 0.05146922f, -0.32180166f, -0.04803783f, 0.05731535f, -0.06739695f, 
    0.00801781f, -0.05743196f, -0.06391291f, 0.02660469f, 0.08240530f, -0.06058438f, -0.10124733f, -0.05330440f, 
    -0.09067045f, -0.21129526f, -0.13382515f, -0.12879328f, 0.23042062f, 0.07327286f, 0.12157799f, -0.04847736f, 
    -0.63579333f, -0.18256710f, 0.20984407f, 0.27930775f, -0.01712815f, 0.19223303f, -0.04238454f, -0.04004147f, 
    -0.06286968f, 0.16370524f, -0.01695795f, 0.00831986f, -0.10357392f, -0.44630742f, -0.12838727f, -0.02110578f, 
    0.10677655f, -0.01938854f, -0.08706204f, -0.03067800f, 0.03697936f, -0.05387490f, -0.15731038f, -0.09462263f, 
    0.14022572f, 0.06853275f, 0.01299273f, -0.23004344f, -0.05430564f, -0.01146869f, -0.56908435f, 0.26576525f, 
    -0.12705964f, 0.14037777f, -0.52346236f, -0.27685785f, -0.08424314f, 0.15397412f, 0.07880019f, 0.01979138f, 
    -0.33872059f, -0.24125881f, -0.04988579f, -0.13350131f, -0.18000472f, -0.54404455f, 0.00529995f, -0.71527070f, 
    0.02761904f, 0.01517211f, 0.07952537f, 0.25176176f, -0.33692333f, 0.17827496f, 0.05764028f, -0.08324178f, 
    -0.07455371f, 0.02290676f, 0.17127317f, 0.24988784f, 0.13367616f, -0.10159007f, -0.68608487f, 0.27015239f, 
    -0.06573528f, 0.04242752f, 0.21508373f, -0.23234105f, 0.04226021f, -0.04882026f, -0.02951622f, 0.16107467f, 
    0.02779332f, -0.39968485f, -0.43678844f, 0.01825589f, 0.01936360f, 0.18415704f, 0.03501774f, -0.37514144f, 
    -0.06226245f, -0.07024655f, 0.10025044f, -0.30580714f, -0.76126635f, -0.58983153f, 0.23244271f, -0.06209556f, 
    0.13030416f, 0.12962306f, -0.26192874f, -0.02685861f, -0.11914153f, 0.10970184f, 0.11716446f, -0.08881571f, 
    0.00160943f, 0.17118479f, 0.06603600f, -0.20199153f, -0.08151437f, 0.14776407f, 0.34229988f, 0.06400198f, 
    -0.09649006f, 0.13769199f, -0.23483500f, -0.06606032f, -0.05426538f, 0.02625552f, -0.08003052f, -0.05864042f, 
    -0.03345874f, 0.03102947f, -0.51373041f, -0.48258799f, 0.10845091f, -0.07857005f, -0.42335486f, 0.00198071f, 
    -0.09690446f, -0.25994751f, 0.16965121f, -0.45699611f, -0.22189887f, 0.00941444f, -0.08639285f, 0.12251306f, 
    0.12773018f, 0.19406056f, -0.54874337f, 0.05315857f, -0.09316571f, 0.19603363f, 0.06803690f, 0.04815164f, 
    0.16211331f, -0.37348056f, -0.00949547f, -0.00750310f, 0.06406359f, 0.10804388f, -0.33158448f, 0.02922877f, 
    0.18295255f, 0.01095955f, -0.15070517f, -0.01366951f, 0.02046378f, 0.04636690f, -0.52826476f, -0.08128889f, 
    -0.38156134f, -0.06123917f, 0.05435588f, -0.51072437f, -0.07182226f, -0.48935711f, 0.02000744f, -0.57495111f, 
    0.09949176f, -0.65550244f, -0.26948294f, 0.01303746f, -0.06873203f, -0.21470656f, 0.16795900f, -0.03246943f, 
    0.14129525f, 0.13339119f, 0.04724421f, 0.06539658f, 0.08703377f, -0.22452801f, 0.14889424f, -0.05706677f, 
    -0.02877040f, -0.05057529f, -0.20259951f, 0.03194216f, -0.36663517f, -0.55946857f, 0.02157882f, -0.07805415f, 
    0.04652473f, 0.18152733f, 0.43210310f, -0.18282162f, 0.04084232f, -0.13859671f, 0.19312921f, -0.22530684f, 
    -0.04123305f, -0.00584158f, -0.15803483f, 0.11515152f, -0.06964297f, -0.07607776f, 0.02730306f, 0.15985586f, 
    0.17128091f, -0.60681236f, -0.19453119f, 0.01088867f, -0.09045775f, -0.25027820f, 0.08271400f, 0.00357010f, 
    0.01878744f, -0.10780021f, -0.05447882f, -0.13323061f, -0.05622867f, -0.07137357f, -0.01442261f, 0.06683667f, 
    0.17037278f, -0.11814886f, 0.15657002f, -0.01500137f, -0.14471701f, 0.14570951f, 0.07800753f, -0.03611389f, 
    0.00162257f, -0.12866640f, 0.05582558f, 0.21786979f, -0.11056054f, 0.02039253f, -0.66976285f, 0.17866288f, 
    -0.05049173f, 0.11667342f, 0.03336078f, -0.03729263f, 0.19552974f, 0.03407946f, 0.15614417f, -0.01815002f, 
    -0.01280804f, -0.06370103f, -0.05698607f, -0.07193654f, -0.65515387f, 0.02278256f, 0.04610625f, -0.08719676f, 
    0.04442013f, -0.27954805f, -0.31288508f, -0.06848937f, -0.52083170f, 0.04596031f, -0.19067945f, 0.02421552f, 
    -0.21854427f, 0.11778790f, -0.18246497f, 0.08709808f, 0.00271863f, 0.11642986f, 0.00887216f, -0.13987918f, 
    -0.08915586f, 0.07775609f, 0.06899989f, -0.05164114f, -0.04114771f, -0.01112325f, -0.15764634f, -0.10212785f, 
    0.19518605f, -0.05073217f, -0.17016008f, -0.05427139f, 0.05191668f, -0.03947108f, 0.02681712f, 0.05134029f, 
    0.10406283f, -0.08303237f, 0.03101762f, -0.05894554f, 0.00239084f, -0.03275822f, 0.08042914f, 0.24755749f, 
    0.23702319f, -0.10072758f, -0.15522447f, 0.20670693f, -0.11206985f, -0.02122439f, -0.05964459f, -0.02786674f, 
    0.08905039f, -0.35271212f, 0.01911442f, -0.00535832f, 0.06370539f, -0.23543999f, -0.13596486f, 0.26889205f, 
    -0.06298034f, 0.03222504f, 0.13983846f, -0.11637864f, -0.44281071f, 0.11427951f, 0.08547010f, -0.09939356f, 
    -0.22249681f, 0.00544967f, 0.10656974f, -0.14719805f, 0.02523690f, -0.23274133f, -0.28049707f, 0.15626520f, 
    -0.09853210f, 0.07460055f, 0.10410850f, -0.13048938f, 0.00675311f, -0.01803387f, 0.01922909f, -0.43974218f, 
    -0.06274199f, 0.39628029f, 0.19096479f, 0.04324008f, -0.01091866f, -0.55917454f, -0.18653573f, 0.01291522f, 
    0.05480038f, 0.00556630f, 0.14967783f, -0.40818623f, -0.05564836f, 0.11211549f, 0.29623055f, 0.02752610f, 
    0.12172772f, -0.03958340f, -0.14627156f, 0.03343941f, 0.05711364f, -0.03217049f, -0.07064515f, 0.35140291f, 
    -0.10153792f, -0.16309272f, -0.02700126f, -0.13320151f, -0.15966327f, -0.03933685f, 0.26541916f, 0.07049315f, 
    0.10304692f, 0.09810608f, -0.25328138f, -0.00673967f, 0.17483251f, -0.08041836f, -0.07981157f, -0.05009812f, 
    -0.01133388f, 0.05051909f, -0.00939114f, 0.18686432f, -0.06970122f, 0.02884666f, 0.12466566f, -0.09351248f, 
    0.01138914f, 0.08477764f, 0.01195750f, 0.18060966f, 0.15283486f, -0.02350145f, 0.26715586f, -0.03797550f, 
    0.17294045f, -0.15375002f, 0.01830237f, -0.48601902f, -0.03024586f, -0.20443882f, 0.06505213f, 0.02726457f, 
    -0.09432142f, -0.10050794f, -0.06543516f, 0.00986325f, -0.11309733f, -0.01345431f, -0.18921334f, 0.02428818f, 
    -0.37036520f, 0.05098047f, 0.03519863f, -0.02692013f, -0.02590522f, -0.05940399f, 0.14130443f, 0.07301143f, 
    0.04937194f, -0.03587588f, -0.07034243f, 0.15348376f, -0.04285410f, 0.18322474f, -0.01964054f, -0.13698031f, 
    -0.20679024f, 0.00995126f, -0.46568188f, -0.15588421f, -0.25428370f, 0.09953402f, -0.43562403f, -0.01441147f, 
    0.14569907f, 0.25998154f, -0.07771445f, 0.13940276f, 0.03615174f, 0.29028776f, 0.16390570f, 0.06502973f, 
    -0.07862058f, -0.02622397f, 0.05474689f, -0.19635978f, 0.41476336f, -0.08975372f, -0.04932571f, 0.00836545f, 
    -0.00196217f, 0.05011488f, -0.51238763f, 0.05740159f, -0.11480609f, -0.38743851f, 0.12356538f, -0.36819652f, 
    0.05560532f, -0.06523541f, 0.15617870f, -0.20042837f, 0.00066010f, 0.04675024f, 0.07028655f, -0.07542691f, 
    0.06310201f, 0.13352713f, -0.68991137f, 0.03547333f, -0.04435243f, -0.10982423f, -0.25303543f, 0.19841844f, 
    0.01438732f, -0.05952596f, 0.18950093f, -0.26523927f, 0.01453888f, -0.08974222f, -0.33440500f, 0.05590493f, 
    0.08252126f, 0.08855887f, -0.41606483f, -0.10544842f, -0.10259551f, 0.20141694f, -0.00162375f, -0.79418516f, 
    0.06901560f, -0.61852342f, -0.06395888f, 0.19674790f, 0.02129542f, -0.03004850f, 0.46635026f, 0.10560615f, 
    0.06788991f, 0.00045795f, -0.32473588f, -0.05432269f, 0.04943165f, -0.08592936f, 0.21272105f, 0.05362853f, 
    0.06118215f, 0.04046041f, 0.08438870f, 0.14512070f, -0.46103725f, 0.01549985f, 0.02676171f, 0.02257508f, 
    0.01774309f, -0.16995221f, -0.39257899f, -0.16715391f, -0.27810091f, 0.10607040f, 0.00591867f, 0.08185268f, 
    0.20985720f, 0.09351584f, -0.14818558f, 0.05332887f, -0.04487085f, 0.04880824f, -0.06251466f, -0.01935160f, 
    -0.29630777f, 0.14969048f, -0.05812560f, 0.05807081f, 0.01681489f, -0.03653857f, -0.39002210f, -0.10600611f, 
    -0.01029406f, 0.17559387f, 0.21201377f, -0.04569316f, -0.01151103f, 0.03678193f, 0.13113688f, -0.06290478f, 
    0.20530441f, 0.05966952f, -0.00927644f, 0.01764075f, -0.02894607f, 0.00569131f, 0.01891433f, -0.22593841f, 
    -0.34091806f, 0.03650470f, 0.08558284f, -0.30297628f, 0.19922709f, -0.29257122f, -0.02004664f, -0.01633944f, 
    -0.45443055f, 0.23719993f, -0.08020183f, 0.07252195f, -0.04041913f, 0.34449038f, 0.12532035f, -0.05821873f, 
    0.02320849f, -0.01970408f, -0.37194493f, -0.03981629f, 0.01794221f, 0.08380091f, -0.02905931f, 0.03731918f, 
    -0.14800274f, -0.16249637f, 0.20905669f, 0.04290635f, 0.15267283f, -0.12356231f, -0.41273439f, 0.08020619f, 
    -0.10955125f, -0.03301937f, -0.15719472f, -0.48318821f, -0.02627205f, -0.04016488f, 0.07530493f, -0.60086393f, 
    -0.26804605f, -0.35189936f, 0.27781892f, -0.02279968f, -0.05672736f, -0.02379434f, -0.04654890f, -0.02568992f, 
    0.07783291f, 0.00666827f, -0.17251083f, -0.06489421f, 0.22858781f, -0.14860576f, 0.18043919f, 0.07866265f, 
    -0.10003314f, 0.04365801f, 0.01093187f, -0.04197372f, -0.62047219f, -0.39552182f, -0.20207810f, 0.26843971f, 
    -0.04800357f, 0.19052054f, -0.08667056f, -0.67537916f, -0.63662630f, 0.04487751f, 0.02581998f, 0.04017481f, 
    0.19865870f, 0.07089400f, -0.07442166f, -0.01738215f, 0.28524983f, 0.01389040f, -0.61314154f, -0.07298999f, 
    -0.05386735f, -0.05805499f, -0.02363178f, -0.32341149f, -0.31626546f, 0.07086264f, -0.39788660f, -0.02815122f, 
    0.05418088f, 0.21589674f, -0.08379008f, -0.10442597f, -0.22407493f, 0.07465395f, -0.23309287f, 0.02640893f, 
    0.19232082f, 0.09785330f, -0.00913455f, -0.31157961f, 0.03270958f, -0.39041319f, -0.05548247f, -0.09526644f, 
    0.14511639f, -0.13186407f, -0.03202789f, -0.06908379f, -0.08378551f, 0.02460709f, -0.00207274f, -0.00612267f, 
    0.01733780f, -0.41792542f, -0.18955244f, -0.01881862f, -0.00993615f, -0.00076934f, -0.04532476f, 0.02063367f, 
    -0.30086541f, 0.06234749f, -0.04562032f, -0.01595249f, -0.05835714f, 0.26260072f, 0.12330136f, 0.19479454f, 
    0.04220768f, -0.24772204f, -0.21697806f, 0.33997688f, 0.08068497f, -0.11023647f, -0.21191023f, -0.07143189f, 
    0.30473319f, -0.56553912f, 0.02462697f, -0.29807082f, 0.00562472f, -0.36391920f, -0.78515816f, 0.01912620f, 
    0.03201021f, -0.05070859f, 0.10729003f, -0.55152714f, 0.40439057f, -0.10347707f, 0.04395763f, -0.02165054f, 
    0.16994907f, -0.58125967f, -0.64485294f, 0.28820962f, 0.10831846f, 0.20222725f, 0.15959392f, 0.00114921f, 
    0.04527567f, -0.05845907f, -0.08001686f, -0.09975839f, -0.06036680f, -0.01291507f, 0.05013925f, -0.28741568f, 
    -0.75053144f, -0.53488880f, 0.06335654f, 0.02173566f, 0.25541633f, 0.37039685f, 0.20052320f, -0.19599950f, 
    -0.07815010f, -0.03139790f, -0.45625621f, 0.21041709f, 0.06184433f, 0.12051883f, -0.18338214f, -0.04760269f, 
    -0.20789844f, -0.01893480f, 0.25124660f, -0.09044496f, 0.02922015f, -0.59749037f, -0.33121687f, -0.53340167f, 
    -0.08086613f, -0.07540616f, -0.08610027f, -0.04390409f, -0.17489290f, -0.20461977f, 0.23827955f, -0.50020772f, 
    -0.20053975f, 0.06071873f, 0.19066614f, -0.02792604f, -0.13268827f, 0.04058805f, -0.49785388f, -0.04367279f, 
    -0.01584073f, 0.06954941f, 0.17055845f, 0.08018980f, 0.02517882f, -0.03256604f, -0.08946157f, 0.09195767f, 
    0.01850239f, 0.19277401f, 0.04633404f, 0.13710722f, 0.22994994f, 0.03727535f, 0.04960951f, -0.25501215f, 
    0.15322891f, -0.12623587f, -0.13907863f, 0.11969449f, 0.00632208f, -0.26020855f, 0.01406381f, 0.01255942f, 
    -0.15877262f, -0.12482888f, 0.01979786f, 0.00824899f, -0.09343901f, 0.18036507f, 0.13807647f, 0.04525689f, 
    -0.27202609f, -0.17168617f, 0.06871563f, 0.04124573f, -0.05773940f, -0.08329213f, -0.07092594f, -0.08984914f, 
    -0.28275147f, -0.04269084f, -0.04886435f, 0.01844025f, 0.01164763f, 0.01815575f, -0.11693837f, -0.17028762f, 
    -0.42423236f, 0.00000552f, -0.27278271f, -0.06977518f, -0.14912821f, 0.21034226f, -0.10909003f, -0.06919912f, 
    0.45190215f, -0.55671287f, 0.05575415f, 0.21070117f, -0.24369140f, -0.41575989f, -0.00826734f, -0.18814461f, 
    -0.05999384f, -0.08864336f, 0.16108984f, -0.03493756f, -0.30030206f, -0.16549882f, -0.00119711f, 0.06896994f, 
    0.15008830f, 0.15396562f, -0.30263984f, -0.26167968f, -0.25245672f, 0.15336926f, 0.03552125f, 0.31716079f, 
    -0.02790070f, -0.06663461f, -0.08380061f, -0.35112104f, 0.01100776f, -0.03409662f, 0.03539038f, -0.17919111f, 
    -0.09513755f, 0.13122520f, -0.16934359f, 0.07295733f, -0.66061270f, -0.19370584f, -0.14377928f, 0.22845504f, 
    -0.02537416f, -0.06849498f, -0.40514746f, 0.17707886f, 0.19697258f, 0.09111037f, -0.04741117f, 0.02454114f, 
    0.08568481f, -0.39189565f, -0.23680273f, 0.04968135f, -0.01183472f, 0.07112741f, -0.14392751f, 0.03895578f, 
    0.06870501f, 0.41930726f, 0.03878368f, 0.06930593f, 0.07832187f, -0.08666585f, -0.24543338f, -0.23053563f, 
    -0.32701910f, -0.38226426f, -0.30024672f, 0.07417940f, 0.17153199f, -0.06641004f, 0.09869694f, -0.02814651f, 
    0.02016341f, -0.05492285f, 0.22506636f, 0.01494672f, 0.16895749f, 0.07975262f, 0.12655109f, 0.03520444f, 
    -0.04898475f, -0.21450163f, 0.29483739f, -0.15390565f, 0.07383697f, 0.02419288f, -0.49171472f, -0.05889351f, 
    0.27498943f, -0.03879398f, -0.31428745f, 0.21795753f, -0.08006839f, 0.21954517f, 0.00762969f, -0.01397130f, 
    0.07915383f, 0.03453312f, 0.00689212f, 0.01590681f, 0.03827389f, -0.70261651f, 0.21781075f, -0.02458066f, 
    -0.01349827f, -0.35801598f, 0.13160697f, -0.03177045f, -0.02522211f, -0.09144903f, 0.27425736f, 0.03931380f, 
    0.17164417f, -0.05893866f, -0.00739525f, -0.04986524f, 0.05395212f, 0.13183829f, 0.07128963f, -0.07406571f, 
    -0.11301803f, -0.00327557f, 0.00839230f, 0.29517251f, -0.09388007f, 0.16799606f, 0.10231915f, 0.03612027f, 
    -0.04831670f, -0.29728422f, -0.02750934f, -0.38372675f, -0.24868003f, -0.38944873f, -0.01639619f, 0.07330538f, 
    0.02548980f, -0.05284398f, 0.04906519f, -0.10515824f, 0.22600408f, 0.10058287f, 0.05571163f, -0.04780903f, 
    0.11014755f, -0.10142495f, 0.17876531f, -0.18896481f, -0.16274220f, -0.08993091f, 0.05341648f, 0.07950947f, 
    -0.11979406f, -0.02530633f, 0.17148925f, 0.17029247f, 0.04909223f, -0.03493786f, 0.04073492f, 0.02942764f, 
    -0.27268320f, -0.66167498f, 0.42913169f, -0.06295345f, 0.12502977f, -0.33272809f, 0.17900644f, -0.83245021f, 
    0.00513862f, -0.06578806f, -0.00272490f, -0.10748817f, -0.00979673f, 0.09235640f, 0.10266848f, 0.04015062f, 
    -0.07165472f, -0.09623504f, 0.14251892f, 0.02049452f, 0.22407259f, -0.01325839f, -0.07069616f, -0.02929180f, 
    -0.00052256f, 0.32871959f, 0.04945973f, 0.02384799f, -0.00455695f, 0.12918122f, 0.02405172f, 0.09541932f, 
    -0.19246446f, 0.14804314f, 0.12144458f, 0.03119083f, -0.33734554f, -0.00642249f, 0.00609402f, -0.00304095f, 
    0.07899669f, 0.05843590f, -0.01871152f, 0.07889375f, -0.12339991f, -0.04600594f, -0.06508800f, -0.00189851f, 
    0.05827380f, -0.29225025f, -0.16533767f, 0.21765715f, 0.29144174f, -0.01584814f, -0.03565787f, -0.05011632f, 
    -0.27707747f, 0.14936441f, 0.23565316f, -0.34274504f, -0.07130330f, -0.45950165f, 0.03539846f, 0.05813354f, 
    0.01963008f, -0.50908405f, -0.01258557f, 0.00899369f, 0.04329645f, 0.22591212f, 0.31775051f, -0.03791642f, 
    0.02990998f, 0.14205407f, -0.02115541f, -0.08605525f, -0.06597541f, -0.00317113f, 0.15749647f, -0.03111934f, 
    -0.45412257f, 0.03791825f, 0.00889447f, -0.30308151f, 0.06885286f, -0.65722793f, -0.05361167f, -0.44659910f, 
    0.15512721f, -0.20847724f, 0.06556583f, -0.37161437f, -0.04296317f, -0.17432302f, 0.13329576f, -0.08603082f, 
    -0.43938458f, -0.53673035f, 0.06384822f, 0.13534978f, 0.20504548f, -0.19626050f, -0.08916770f, 0.14431489f, 
    -0.04010148f, -0.07408474f, 0.26004934f, -0.02605499f, -0.36741161f, -0.44756973f, 0.07035822f, -0.03175766f, 
    0.21702634f, -0.06477253f, -0.51663262f, -0.58263361f, 0.14973255f, -0.27011415f, 0.04070899f, -0.40818858f, 
    -0.10033464f, -0.03308867f, 0.17538328f, 0.14891060f, 0.02966926f, -0.02214490f, -0.03167320f, 0.07519194f, 
    0.01222379f, -0.01830152f, -0.30643597f, 0.02832910f, 0.16893010f, -0.52813947f, 0.01225187f, 0.12697679f, 
    -0.04125515f, 0.00065396f, 0.08074321f, 0.22717288f, -0.60793787f, -0.19420020f, -0.10111511f, -0.00472729f, 
    -0.10315403f, 0.25732711f, -0.35023686f, 0.03840054f, -0.05309311f, 0.07242877f, 0.16737665f, -0.44824457f, 
    0.06832822f, -0.60275435f, -0.01668176f, 0.02645361f, 0.09901699f, 0.05902183f, 0.01186434f, 0.18060127f, 
    -0.55356669f, -0.03227729f, -0.17143185f, 0.01503773f, -0.57117856f, 0.01450312f, 0.07256209f, 0.04476924f, 
    0.05894171f, 0.01833005f, -0.06738855f, -0.31839070f, 0.30143920f, -0.05819833f, 0.02631655f, -0.09066714f, 
    -0.03929760f, -0.16988550f, -0.06091157f, -0.23710255f, -0.26212734f, -0.00724895f, 0.08413108f, 0.05881480f, 
    0.24040613f, 0.06979424f, -0.33243620f, 0.17646299f, 0.09750719f, 0.08128804f, 0.06554375f, 0.00685933f, 
    0.23798750f, -0.15716447f, 0.01194234f, -0.02987196f, 0.00279800f, -0.10082349f, -0.00147198f, -0.04066605f, 
    0.11290283f, 0.10928328f, 0.14720982f, 0.05065151f, 0.02379854f, 0.07218532f, -0.01861359f, -0.04880640f, 
    0.02566494f, 0.04326330f, 0.00558260f, -0.20507933f, 0.03830108f, -0.05713291f, 0.11440063f, -0.28914350f, 
    0.10176297f, 0.04385205f, 0.42754921f, -0.13305382f, -0.11973382f, -0.27636105f, 0.08784147f, -0.06491335f, 
    0.42505518f, 0.29075450f, -0.08406986f, -0.06523477f, 0.15040129f, -0.85194570f, 0.12032359f, -0.08831172f, 
    -0.05744516f, -0.04588111f, -0.49545413f, 0.16736545f, 0.25057825f, -0.24690561f, -0.08038522f, -0.06035711f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.02954925f, -0.12258203f, -0.11390933f, -0.19265050f, -0.01888968f, 0.03363331f, 0.02120094f, -0.32312918f, 
    -0.07386986f, -0.03013756f, 0.28336573f, 0.08872928f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
