#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.79579210f, 0.82537854f, 0.50965756f, -0.93113983f, -0.59447849f, -0.66831934f, -0.11898279f, 0.10831857f, 
    0.11365068f, -0.17121044f, -0.34906623f, -0.57163543f, -0.38939497f, 0.68467379f, 0.50684083f, 0.42125887f, 
    0.39040914f, 0.51983756f, -0.37777570f, -0.56528795f, -0.74422264f, 0.38299662f, -0.12844624f, -0.12229041f, 
    0.09354124f, 0.52019221f, 0.68251973f, 1.00042689f, 0.33615342f, 0.63074213f, -0.79538351f, 0.65214366f, 
    -0.43535554f, -0.00324826f, 0.11279090f, 0.29373083f, 0.83403707f, -0.18549325f, 0.54861736f, 0.54886281f, 
    -0.61242646f, 1.01236081f, 0.12835598f, 0.25498313f, 0.34512550f, -0.47406429f, 0.63222462f, 1.20862567f, 
    0.17386118f, -0.02157353f, 0.54922312f, 0.00496176f, 0.22354896f, 0.53041404f, 0.81833142f, -0.10023984f, 
    0.47492293f, 0.99297315f, 0.54224259f, -0.29058895f, -0.33982840f, 0.21367405f, 0.09357236f, 0.54679769f, 
    0.93730456f, 0.36828089f, 0.58626539f, 0.54855138f, 0.46187451f, 0.27448747f, -0.16334720f, 0.11562553f, 
    0.49339566f, -0.70533115f, -0.13357519f, -0.48884326f, -0.40137526f, -0.31049061f, -0.75223780f, 0.68827540f, 
    -0.30253026f, 0.43027955f, -0.36036116f, 1.00768185f, 0.79072332f, -0.82601058f, -0.57695818f, 0.41065440f, 
    -0.43645352f, 0.14506322f, -0.72418284f, -0.86554986f, -0.40864357f, -0.41141585f, 0.04658840f, -0.32056341f, 
    0.42843440f, 0.22573723f, 0.27731833f, 0.06797852f, 0.22941040f, -0.25056031f, -0.94159842f, 0.44979766f, 
    -0.28414091f, 0.14276505f, 0.40524083f, 0.53958410f, -0.84533858f, -0.85318136f, 0.03951705f, 0.17895794f, 
    -0.43225539f, 0.55225986f, -0.02755575f, 0.15659243f, 0.40191182f, 0.50202495f, -0.45185921f, 0.74140787f, 
    -0.72791344f, -0.48034412f, -0.35113442f, -0.13111919f, -0.39269799f, -0.57674479f, 1.14212751f, -0.62283039f, 
    -0.72068131f, -0.11611542f, 0.49468556f, -0.25489646f, -0.11406804f, -0.13415767f, -0.01117889f, -0.57399064f, 
    -0.04089491f, 0.81286258f, -0.87561846f, 0.14077513f, 0.31764373f, 0.42967525f, 0.27714878f, -0.29814953f, 
    0.05985403f, -0.87052935f, -0.50370497f, 0.53304297f, -0.45394146f, -0.46827859f, -0.17750902f, -0.12620138f, 
    -0.09111035f, -0.75693262f, -0.28083596f, -0.67846400f, 0.45331606f, 0.52822900f, -0.25633189f, -0.63840073f, 
    -0.60923821f, -0.00389186f, -0.87353712f, -0.53449881f, -0.88506895f, -0.35274357f, -0.37429956f, 0.67563927f, 
    -0.01784960f, 0.00642270f, -0.33194816f, -0.65978742f, -0.26078010f, -0.84519476f, -0.24066544f, 0.48892933f, 
    0.84917068f, -0.43026775f, 0.03222178f, 0.12835421f, -0.72379488f, -0.88927776f, -0.68351406f, -0.85885280f, 
    -0.44578838f, -0.20592368f, -0.45851424f, 0.27208763f, -0.48613772f, 0.80603379f, 0.85047460f, 0.92111605f, 
    -0.09401306f, -0.13788249f, 0.24386197f, 0.59668714f, -0.04521814f, -0.53774703f, -0.51117450f, 0.96682543f, 
    -0.85251880f, 0.41254932f, -0.39020413f, -0.89757854f, 0.19604023f, -0.25018272f, -0.23353606f, 0.49872974f, 
    -1.25973654f, -0.33391693f, -0.82340705f, 0.11984825f, 0.08647958f, 0.23725690f, 0.24463917f, 0.10203319f, 
    -1.35005140f, -0.08974149f, 0.41375554f, 0.51758599f, 0.85637450f, 0.57911199f, 0.15227599f, -0.49836269f, 
    -0.19792227f, -0.80214375f, -0.28129882f, 0.46450460f, 0.23325761f, -0.85787958f, -0.52427459f, 0.17403272f, 
    0.09549443f, 0.52050179f, -0.55708295f, -0.38544810f, -0.34752759f, 0.02361644f, -0.53253961f, -0.61267155f, 
    0.40878120f, -0.16540815f, -0.51727122f, -0.70826095f, -0.73620069f, -0.66273481f, 0.64119595f, 1.13300967f, 
    0.00289538f, 0.14016049f, -0.06069887f, -0.45987475f, 0.33986297f, 0.74479389f, 0.87938696f, -0.10314321f, 
    0.65194505f, 0.11020840f, -0.51163709f, -0.36567715f, 0.37421638f, -0.40669629f, 0.09915583f, 0.18359676f, 
    0.26366469f, 0.50670588f, -0.81479609f, 0.66174161f, 0.59991050f, -0.61753827f, -0.47491822f, 0.38818017f, 
    0.59914482f, 0.05834781f, -0.31743035f, -1.26688361f, -0.29543328f, 0.15914159f, 0.51345807f, 0.69415271f, 
    0.55931520f, 0.75453156f, 0.00979051f, -0.66701084f, 0.53620923f, -0.44800296f, 0.01105566f, -0.32089216f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.12724680f, 0.10382414f, -0.05372406f, -0.17984842f, 0.19314297f, -0.07987579f, 0.09183044f, 0.03895685f, 
    -0.01451603f, -0.06822047f, 0.26239491f, 0.11486145f, 0.08381349f, 0.37205109f, 0.04459817f, 0.15889342f, 
    0.14860131f, -0.29858956f, -0.14082651f, -0.22191581f, -0.30731204f, 0.27710637f, -0.16520616f, -0.10557509f, 
    -0.18148871f, -0.00521270f, 0.13692489f, 0.07193119f, 0.28269029f, 0.10549616f, -0.07572822f, 0.18714954f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.04102982f, 0.00676845f, 0.08430631f, -0.17219220f, -0.07758966f, 0.15589842f, 0.04467916f, -0.08560528f, 
    0.08418742f, 0.12181097f, 0.12067083f, 0.11564989f, 0.03034321f, -0.14402987f, 0.09593555f, 0.21213999f, 
    0.00914049f, 0.06103405f, -0.10131049f, -0.17596294f, -0.14287893f, 0.07638431f, 0.15749376f, -0.07035842f, 
    -0.01853582f, 0.08256580f, 0.09819038f, -0.09943037f, 0.01810232f, 0.07091646f, 0.05124550f, 0.21377680f, 
    0.21948595f, -0.13497473f, -0.07415487f, -0.08291665f, -0.34209615f, 0.06359136f, 0.04772704f, 0.03573803f, 
    0.16205126f, 0.02856041f, 0.17091945f, -0.18418531f, -0.03641292f, -0.05252495f, -0.02267729f, -0.15894994f, 
    0.05652082f, 0.08100268f, 0.02804176f, -0.07695822f, -0.13571067f, -0.12179030f, 0.14017907f, 0.06756020f, 
    0.24104494f, 0.18659069f, 0.14946488f, -0.17228250f, -0.04672680f, 0.01655632f, -0.09104853f, 0.15724635f, 
    0.24024957f, 0.24043272f, 0.06146215f, 0.03940500f, -0.01700424f, 0.06591014f, -0.05996375f, -0.02569020f, 
    -0.23528993f, -0.12258051f, 0.10118724f, 0.09643919f, -0.24272721f, 0.11170416f, 0.04657620f, -0.03488581f, 
    0.04814311f, -0.32557499f, 0.14828482f, 0.22470190f, -0.07460179f, -0.01218600f, 0.13051015f, 0.06696015f, 
    -0.04244512f, -0.03587751f, 0.07991683f, -0.09883915f, -0.41374651f, 0.10329708f, -0.03875786f, 0.04648670f, 
    0.21628897f, -0.08788175f, 0.18551587f, 0.22128400f, 0.25005543f, 0.12203167f, -0.04995022f, -0.10498946f, 
    0.08929310f, 0.20666593f, -0.00383147f, 0.33920598f, -0.55418330f, -0.29633173f, 0.07934855f, 0.22197893f, 
    0.13851194f, 0.07110988f, -0.06710956f, -0.06859775f, 0.03450825f, -0.16496213f, 0.11902049f, 0.05644885f, 
    0.09411625f, 0.06750555f, 0.05148190f, 0.01597804f, -0.04036041f, 0.00015083f, -0.55060130f, -0.96165442f, 
    -0.30647808f, -0.00128018f, 0.03319278f, 0.13288423f, 0.04402377f, -0.04465568f, -0.00293351f, 0.21396038f, 
    -0.05236426f, -0.17948022f, -0.02471127f, 0.15809342f, 0.07778230f, 0.10042185f, 0.04712777f, 0.18937625f, 
    -0.31085873f, -0.27017507f, -0.34411919f, -0.05882979f, 0.18450518f, -0.10091616f, 0.02513301f, 0.05101233f, 
    0.00596588f, -0.42728600f, -0.01828978f, -0.25419736f, -0.25107616f, -0.17065488f, -0.21637766f, 0.13011697f, 
    0.18114634f, -0.13841371f, -0.16829689f, -0.41631901f, -0.27766064f, 0.22184958f, 0.19627894f, -0.02232401f, 
    0.08899885f, -0.08594191f, -0.11994733f, -0.24198103f, -0.28451696f, -0.13351905f, 0.03238873f, 0.02676266f, 
    -0.06557958f, 0.09045289f, -0.09326170f, -0.02088541f, -0.11376769f, -0.41160566f, -0.03560397f, 0.07311314f, 
    0.11105054f, 0.01728489f, 0.09526916f, -0.01757044f, -0.23678379f, -0.17753610f, 0.05476697f, 0.08012550f, 
    -0.00907578f, 0.18473445f, 0.10055601f, 0.02603191f, 0.18842465f, -0.08937405f, -0.03139371f, 0.04122062f, 
    -0.34578729f, -0.02806508f, 0.10170437f, 0.01520415f, 0.08946665f, 0.05653564f, 0.00598747f, -0.62442529f, 
    -0.23878419f, -0.34904560f, 0.01838886f, -0.07437544f, 0.12684110f, 0.11505980f, -0.07182179f, 0.02507303f, 
    -0.22752604f, 0.32507592f, -0.48102218f, -0.03955115f, -0.04683957f, -0.05008405f, 0.03067230f, -0.20077324f, 
    0.02930022f, 0.25713229f, -0.09058800f, 0.00046599f, -0.15955630f, -0.03031044f, 0.02624546f, -0.00324010f, 
    0.00564082f, 0.10294656f, 0.28815913f, -0.09543107f, -0.60007179f, 0.08478325f, 0.00225314f, -0.00508120f, 
    0.08792098f, 0.06057646f, 0.07767320f, -0.07822489f, -0.27236670f, -0.20206270f, -0.11019798f, 0.03550643f, 
    0.07311047f, -0.21059740f, -0.14001565f, -0.06171318f, 0.07636846f, 0.14374648f, 0.08056315f, -0.07941729f, 
    0.20826067f, -0.03509191f, 0.00584157f, 0.19136204f, 0.12176746f, -0.04139770f, -0.18819323f, 0.08287162f, 
    -0.04640779f, -0.00246454f, -0.01982713f, 0.02199372f, 0.22617666f, 0.05996670f, 0.15739202f, -0.10333175f, 
    0.04696928f, -0.12959106f, -0.04660837f, 0.09893414f, 0.05624171f, 0.22434978f, 0.37210703f, -0.23792864f, 
    0.15900916f, 0.02314140f, -0.14054777f, 0.16290689f, 0.14173539f, 0.25722235f, 0.08517553f, -0.01235112f, 
    0.06047321f, -0.15034135f, -0.16369097f, 0.02739862f, 0.08612528f, 0.02537723f, -0.11485979f, 0.01449974f, 
    0.16071567f, -0.16475163f, 0.10760421f, 0.02991666f, 0.01171130f, -0.05468193f, -0.08193152f, 0.07172034f, 
    0.03930218f, 0.05560563f, 0.02632613f, 0.01193131f, 0.03466313f, 0.01477822f, 0.02526442f, 0.08237131f, 
    0.00020299f, 0.20310552f, 0.05398116f, -0.27791661f, -0.00748639f, 0.08150219f, -0.06050042f, 0.03448012f, 
    0.00203169f, -0.14100577f, -0.09349755f, 0.09984311f, 0.31794843f, 0.02913837f, -0.28450295f, -0.06094069f, 
    0.02519518f, 0.08106480f, 0.08212362f, -0.07532232f, 0.01309366f, -0.09982181f, -0.24173918f, -0.17062901f, 
    -0.01635974f, 0.02854866f, 0.13629265f, 0.24683098f, 0.07066899f, -0.17684144f, -0.29548004f, -0.07680966f, 
    -0.24231523f, -0.05953284f, 0.11954337f, -0.10130578f, -0.01064883f, 0.11242618f, 0.00316506f, -0.53064674f, 
    0.25232297f, -0.00818108f, 0.00780731f, -0.07785486f, -0.07003941f, 0.01513931f, 0.15063179f, 0.05670118f, 
    -0.01003369f, 0.14443420f, 0.22779611f, 0.00503975f, 0.05112805f, -0.03220767f, 0.23508157f, -0.12637532f, 
    -0.00987417f, 0.02963621f, -0.22589737f, -0.05933998f, 0.17646979f, 0.04477507f, 0.03935201f, -0.03390380f, 
    0.09518378f, 0.12920436f, -0.19091287f, -0.01500858f, 0.07870918f, -0.01997496f, 0.02631081f, 0.03331440f, 
    -0.02760355f, -0.08150223f, -0.06313343f, -0.10482760f, 0.18212336f, -0.00018244f, 0.04852813f, -0.03515902f, 
    -0.08052378f, -0.07295094f, -0.01183319f, 0.04386482f, 0.19482049f, -0.02415806f, -0.03514877f, -0.12822545f, 
    -0.03087080f, 0.01962369f, -0.19962269f, 0.04564636f, -0.01692302f, -0.12245760f, 0.18630965f, 0.27155024f, 
    -0.02856838f, 0.17713957f, 0.09129760f, 0.01956874f, -0.02018525f, 0.02739538f, 0.24174459f, 0.19896132f, 
    0.07688738f, 0.03450747f, 0.02284401f, 0.04006414f, -0.18348521f, -0.02341003f, -0.03258942f, -0.19397530f, 
    0.25585774f, 0.22404385f, -0.00080914f, -0.03268877f, 0.09503470f, -0.07276090f, -0.08599646f, 0.01621287f, 
    0.02931247f, -0.01486877f, -0.19398129f, -0.06717660f, 0.07552511f, 0.08378411f, 0.08616253f, 0.08726013f, 
    -0.04383263f, 0.09217288f, 0.10714786f, 0.03506234f, 0.19890815f, -0.02526811f, 0.14045139f, 0.02703983f, 
    0.00680656f, -0.07569416f, -0.02641172f, 0.06832880f, -0.02300629f, -0.04448496f, 0.07670056f, -0.03407624f, 
    -0.18356672f, 0.03221801f, 0.09328490f, -0.08940174f, 0.10858617f, -0.14257394f, 0.09948484f, -0.04252480f, 
    0.18712343f, 0.10985971f, -0.06123818f, 0.00861847f, -0.24285659f, 0.11363836f, 0.10859747f, -0.01752011f, 
    -0.10258375f, -0.03404684f, -0.07190572f, -0.11109710f, -0.14738846f, -0.75164974f, -0.18160190f, -0.18487579f, 
    0.07320125f, 0.06322695f, 0.04897652f, 0.05145385f, -0.05969157f, -0.07050009f, 0.67579263f, 0.04681684f, 
    -0.04820346f, -0.00668526f, -0.01689727f, 0.09255425f, 0.05181890f, 0.08438455f, -0.01817532f, -0.26354608f, 
    0.12800595f, -0.04693627f, -0.07067071f, 0.02761260f, -0.04726326f, 0.07560635f, -0.00815861f, -0.05543482f, 
    -0.05927499f, 0.20267034f, 0.06006176f, 0.05488504f, -0.22429252f, -0.11489987f, -0.14238448f, -0.01801131f, 
    0.15077011f, 0.20375504f, 0.03339950f, 0.03310166f, 0.15516017f, -0.05595971f, 0.08701973f, -0.03390970f, 
    -0.05958011f, 0.01668617f, 0.09981005f, 0.12888497f, 0.03257251f, 0.00151219f, -0.12422945f, 0.02534870f, 
    0.01484719f, -0.11871528f, 0.05265274f, -0.00386418f, 0.21355121f, 0.00674688f, -0.02711325f, 0.02569066f, 
    0.15341426f, -0.05017035f, 0.06069907f, 0.14556341f, -0.11403525f, 0.12920417f, 0.03698434f, -0.06296588f, 
    0.09380031f, 0.04866116f, 0.02965310f, 0.14723562f, -0.05747164f, 0.06148940f, 0.13957754f, 0.02373406f, 
    -0.07325094f, 0.10768684f, -0.06477901f, 0.05177584f, -0.03344763f, -0.06124483f, 0.46576703f, -0.10976691f, 
    -0.03679578f, 0.12922293f, -0.04451081f, -0.01992644f, 0.08314116f, -0.10237660f, 0.00791650f, -0.19229428f, 
    -0.63728714f, -0.14482896f, -0.05132564f, 0.06860819f, -0.01951686f, 0.02013195f, -0.06557121f, -0.04905316f, 
    -0.19617583f, -0.01863258f, 0.14491966f, -0.14366406f, -0.02505371f, 0.21320716f, 0.00840845f, 0.03766737f, 
    0.06617106f, -0.04630550f, -0.05995107f, 0.07641901f, 0.21443062f, 0.20708972f, 0.07554188f, 0.07835285f, 
    -0.16723201f, 0.01735491f, 0.20552452f, 0.37063521f, -0.00063268f, 0.09239414f, 0.29109159f, 0.12635876f, 
    0.06288533f, -0.05418346f, -0.12267251f, -0.06278387f, -0.04941187f, -0.14048918f, 0.11940083f, -0.22595260f, 
    -0.01095988f, 0.09738689f, -0.03366162f, -0.10971419f, 0.05521629f, 0.04838807f, -0.04128616f, 0.03040542f, 
    -0.07922936f, -0.19388714f, 0.22080675f, 0.11631664f, -0.04859590f, -0.08809378f, -0.12821117f, -0.20877452f, 
    0.08938391f, -0.15046000f, -0.40392944f, 0.13947542f, -0.02526806f, 0.15827224f, 0.36273685f, -0.04129691f, 
    -0.23734628f, 0.22070472f, 0.07029444f, -0.15236862f, 0.21102178f, -0.11024909f, 0.06578539f, -0.01035140f, 
    -0.07322237f, -0.21845339f, 0.02590091f, -0.06014030f, -0.23949957f, 0.10407905f, -0.01286399f, 0.13518503f, 
    0.21955064f, 0.09279738f, -0.00970555f, -0.28486744f, -0.09985402f, 0.09555042f, -0.10132235f, 0.07198423f, 
    -0.14195621f, -0.06357709f, 0.12899473f, -0.25207689f, -0.15256526f, 0.17339005f, 0.05873324f, -0.03036902f, 
    0.12674467f, -0.06948164f, 0.37184459f, 0.11913307f, 0.13483867f, 0.11378374f, 0.18769084f, 0.12056611f, 
    -0.04508834f, -0.05526259f, 0.06554605f, -0.16533747f, -0.16779025f, 0.04403898f, 0.08496398f, 0.07524796f, 
    0.14831689f, 0.04166498f, -0.22624515f, -0.08049656f, 0.19592100f, 0.17400864f, 0.15739356f, 0.27476215f, 
    0.09430980f, 0.00073716f, 0.32583541f, -0.01859479f, 0.10540178f, 0.02695155f, -0.01295977f, -0.03262416f, 
    0.04171796f, 0.04611394f, 0.07468887f, -0.04621998f, 0.08193663f, 0.00879406f, 0.37752157f, -0.01459224f, 
    -0.01711619f, 0.21089666f, -0.15507817f, 0.06979796f, 0.01667705f, -0.19181184f, 0.02441006f, 0.04081105f, 
    0.00723473f, -0.06597869f, 0.07568012f, 0.02810675f, -0.03974398f, -0.01750887f, 0.07491453f, 0.04711127f, 
    0.19117932f, 0.32311487f, 0.03842306f, 0.02171400f, 0.15660201f, 0.14154696f, -0.01830834f, 0.23015667f, 
    0.02593427f, 0.29941681f, 0.06972699f, 0.30436534f, 0.12038609f, 0.10439259f, -0.18113804f, 0.14773370f, 
    0.24643877f, -0.03855912f, 0.13761017f, 0.30042300f, 0.05963803f, 0.16061176f, -0.03991691f, 0.20351152f, 
    0.08357357f, 0.05394218f, 0.12148749f, 0.02480733f, 0.04916853f, 0.07079948f, 0.21088509f, 0.22037925f, 
    0.06202728f, -0.07057245f, -0.00137888f, 0.14586985f, 0.22201432f, 0.22329666f, 0.00827606f, 0.24747621f, 
    -0.01933040f, 0.18320526f, -0.05075100f, 0.09098418f, 0.07451274f, 0.06230294f, 0.02954274f, -0.02777313f, 
    0.08028125f, -0.01639764f, -0.00099858f, 0.09407802f, 0.03845231f, 0.15202831f, -0.29587084f, 0.04727828f, 
    -0.05838787f, 0.20966391f, 0.06199392f, 0.21305954f, -0.11182049f, 0.09891216f, -0.09279817f, 0.09777343f, 
    0.09100028f, 0.08312236f, 0.17247632f, 0.09689049f, 0.02497810f, -0.02576849f, 0.02254801f, -0.07382942f, 
    0.18303207f, -0.13974178f, -0.07968740f, 0.18815815f, 0.04797715f, 0.06409220f, 0.08137476f, 0.02538499f, 
    0.15536132f, -0.01012726f, 0.08479136f, -0.09860491f, 0.04962416f, 0.03919257f, 0.13382612f, 0.00877483f, 
    0.05699176f, -0.15507242f, 0.09129728f, 0.11725640f, 0.06058143f, 0.05858001f, 0.13307634f, 0.13177967f, 
    -0.12860842f, 0.32788047f, 0.10763313f, 0.32024178f, 0.07035699f, -0.02368210f, 0.17756611f, -0.11896849f, 
    0.08345804f, 0.23071383f, -0.01525528f, 0.05152832f, -0.14376330f, -0.17083287f, -0.21599953f, 0.05713480f, 
    -0.19241357f, 0.02819159f, 0.08858142f, 0.07452418f, 0.06852718f, -0.12117389f, -0.20701827f, -0.04458105f, 
    0.04895596f, 0.12936376f, 0.05377659f, 0.18216507f, 0.07894465f, 0.20103581f, -0.18459940f, 0.19535561f, 
    -0.27342847f, 0.02316661f, 0.05748916f, 0.11820307f, -0.06184008f, -0.06299680f, -0.06373672f, 0.04415786f, 
    0.23664041f, 0.11721489f, -0.08816967f, 0.00565695f, -0.03372242f, 0.11799242f, 0.10860293f, 0.09438011f, 
    0.41174346f, 0.22065455f, -0.00056533f, 0.03698739f, -0.04884889f, 0.10198155f, 0.08005515f, 0.00737156f, 
    0.02067815f, -0.00738671f, 0.01783613f, 0.01993869f, -0.11238202f, -0.16394205f, 0.04578610f, 0.15554973f, 
    -0.08748552f, -0.05455695f, 0.16902100f, 0.08516487f, -0.21013512f, -0.11542137f, -0.19276240f, 0.19468348f, 
    0.01106174f, 0.08648057f, -0.23168044f, -0.11169557f, -0.02601856f, -0.08932171f, -0.06055026f, 0.07620322f, 
    0.13201244f, 0.13837890f, -0.07865912f, 0.04906746f, -0.36622658f, -0.13832849f, 0.15041427f, 0.14601937f, 
    0.15545915f, -0.14197877f, -0.14226867f, 0.05764174f, 0.13668640f, -0.21029074f, -0.14638926f, -0.16636021f, 
    0.18236977f, -0.08086378f, -0.05953901f, 0.09358764f, -0.16612305f, 0.18444391f, -0.15997611f, -0.04458227f, 
    -0.03614543f, -0.03250003f, 0.11678214f, -0.11395325f, -0.13206957f, 0.07632017f, 0.09204546f, -0.47023135f, 
    -0.10431490f, -0.11550806f, 0.13362913f, -0.05370431f, -0.13474290f, -0.02135182f, -0.00695288f, 0.07999620f, 
    0.08587898f, -0.14859286f, -0.22577445f, 0.16549811f, 0.19145814f, 0.02564067f, 0.08419246f, -0.12961335f, 
    -0.13610354f, -0.43147528f, 0.07122970f, 0.24454594f, 0.12131342f, 0.12215673f, 0.08446831f, 0.10588669f, 
    0.06085857f, -0.03859513f, 0.04991495f, 0.04667129f, -0.19170560f, -0.01720309f, 0.04818042f, 0.31283337f, 
    0.03814559f, 0.07045247f, -0.13023290f, 0.04813775f, 0.09021988f, 0.21256612f, 0.11359075f, -0.13934997f, 
    -0.06070424f, 0.16308884f, -0.05354221f, 0.10099625f, 0.04133765f, 0.21277818f, 0.01295108f, -0.04781780f, 
    -0.04133034f, 0.14789121f, -0.02614826f, 0.23435953f, -0.10535824f, 0.27656525f, 0.07142857f, -0.00208969f, 
    0.00370270f, 0.05311690f, 0.12252938f, -0.00393086f, -0.00288514f, -0.11927129f, -0.08980668f, -0.16300297f, 
    -0.02525605f, 0.22113554f, 0.13498382f, 0.07958308f, 0.01836333f, -0.04966516f, -0.08516558f, 0.36216095f, 
    0.05691612f, 0.03351530f, 0.06001104f, 0.01752266f, 0.12496284f, 0.13431308f, -0.01128977f, 0.00322304f, 
    0.00120894f, 0.15310088f, 0.00575676f, 0.06340760f, 0.20018265f, 0.16175115f, 0.03594388f, 0.09468504f, 
    -0.05464971f, 0.12409309f, -0.02920651f, -0.01575270f, -0.15332130f, 0.02457008f, 0.01818242f, -0.04337931f, 
    0.06768324f, -0.10481015f, 0.02409495f, 0.01989389f, 0.02003731f, -0.05553297f, 0.17229694f, 0.04362794f, 
    -0.06973981f, 0.14320225f, 0.00362230f, -0.07025910f, -0.02345496f, -0.03986894f, -0.15872745f, -0.04366689f, 
    -0.01546384f, -0.19342758f, 0.14709835f, 0.13824651f, 0.05267299f, -0.09635895f, -0.05150957f, 0.11765837f, 
    0.17317493f, 0.32230958f, -0.01668943f, 0.13955988f, 0.03788931f, -0.11276329f, 0.05027291f, -0.10937639f, 
    0.08249918f, -0.00522473f, 0.10298665f, -0.03516183f, 0.05203714f, 0.10459238f, 0.01083457f, -0.26381567f, 
    0.03831038f, 0.10204510f, 0.22817439f, 0.06138034f, 0.09439375f, 0.03059520f, 0.02571316f, -0.03007778f, 
    -0.03893599f, -0.05589057f, 0.18459402f, -0.09234218f, 0.09487127f, 0.14028272f, -0.11517707f, -0.07880992f, 
    0.06187597f, -0.06046022f, 0.05336930f, 0.05459765f, 0.12252567f, -0.16070923f, -0.07370976f, -0.17058624f, 
    -0.06888700f, 0.24209033f, 0.03808138f, 0.03962495f, -0.26247630f, 0.09140939f, 0.04435539f, -0.04138615f, 
    0.03441066f, 0.03592397f, 0.04698849f, -0.08143729f, 0.00612135f, -0.05670614f, 0.07529193f, 0.13746214f, 
    0.05012245f, -0.04596679f, 0.16111870f, 0.32917595f, 0.05171079f, -0.10424469f, -0.25565031f, -0.12087494f, 
    0.04326793f, 0.10827639f, 0.12037877f, -0.04034338f, -0.18891345f, -0.31761470f, -0.03545255f, -0.02784234f, 
    0.01709385f, -0.08549605f, -0.08414402f, -0.03461794f, -0.05584275f, 0.10143545f, -0.01759689f, 0.06393474f, 
    -0.04161028f, -0.11934815f, 0.33846858f, 0.08264948f, 0.16884325f, -0.17018679f, 0.24425355f, -0.04456711f, 
    -0.12034368f, -0.12796569f, -0.03739037f, 0.07101921f, -0.01903340f, -0.01981997f, -0.06979188f, -0.30163702f, 
    -0.06102852f, -0.02992994f, 0.12614885f, -0.02618719f, 0.06274866f, -0.22237539f, 0.02244519f, 0.04852577f, 
    -0.15043806f, -0.15323408f, 0.09810285f, 0.05836237f, 0.04702559f, 0.07176010f, -0.09448538f, -0.14358912f, 
    -0.08742504f, -0.14321758f, -0.02364059f, -0.02934973f, -0.03667022f, -0.00776404f, -0.12676388f, 0.03088805f, 
    0.12624738f, 0.11685861f, 0.08549545f, 0.16803546f, 0.06033977f, -0.11535463f, 0.00396527f, 0.00865268f, 
    0.03228020f, 0.21029496f, 0.15388893f, -0.36271113f, -0.31480941f, 0.05821942f, 0.08228404f, 0.10670899f, 
    0.04264700f, -0.05392117f, 0.01358398f, 0.08158737f, -0.13988160f, 0.02488992f, 0.03119541f, 0.06631030f, 
    -0.05275603f, 0.10004397f, 0.07257126f, -0.06672045f, 0.10351619f, -0.43866169f, -0.02918360f, -0.29211253f, 
    -0.03673944f, 0.12315172f, -0.22406054f, 0.17272188f, 0.08148969f, 0.03809399f, -0.04368216f, -0.28144780f, 
    -0.15582885f, -0.00022467f, -0.03806945f, -0.12097077f, 0.23793228f, -0.13467592f, 0.26158637f, -0.33513597f, 
    0.04734080f, -0.11263988f, -0.02305896f, -0.07236305f, -0.13511327f, 0.19771376f, -0.13043493f, 0.12908790f, 
    0.10532653f, 0.18748820f, 0.25630569f, -0.07054019f, -0.11696377f, 0.00607039f, -0.01292779f, -0.14366496f, 
    -0.04678015f, -0.21009451f, -0.09913488f, -0.06156627f, 0.06412181f, -0.06144586f, -0.01175276f, 0.01913408f, 
    0.00554590f, -0.10809359f, 0.04346390f, 0.20711568f, 0.01818477f, -0.00878955f, -0.06114913f, 0.07931829f, 
    -0.02823968f, 0.02693453f, -0.00909080f, -0.15257466f, -0.05968277f, -0.06120738f, 0.09441393f, 0.05374490f, 
    -0.01475683f, -0.11677913f, -0.09743964f, 0.04820519f, 0.04795575f, 0.26942042f, -0.00081044f, 0.10398927f, 
    0.04440564f, -0.12478629f, -0.06398626f, 0.12808716f, 0.07297299f, -0.02160197f, 0.23946188f, 0.19288881f, 
    -0.10969900f, 0.04020840f, -0.15768829f, -0.24646546f, 0.07259333f, 0.03661242f, -0.01809502f, 0.11934511f, 
    0.10101332f, 0.02921953f, 0.16229950f, -0.05800359f, -0.13387270f, -0.14996883f, 0.04719117f, -0.06187493f, 
    0.22738588f, -0.00558819f, 0.04780615f, -0.06059502f, -0.14830175f, -0.24564211f, -0.04853858f, 0.08645468f, 
    0.14875270f, 0.13623582f, -0.19669913f, 0.02075141f, -0.02600061f, -0.04876305f, -0.03830143f, 0.02605405f, 
    -0.05650210f, 0.18651104f, 0.04616388f, -0.03383838f, 0.24187934f, 0.15566087f, -0.00734599f, 0.01476428f, 
    0.16156200f, -0.08350039f, 0.01156391f, 0.13685155f, 0.15726735f, 0.07201187f, -0.00209546f, -0.01816973f, 
    0.09398624f, 0.04061511f, -0.10056305f, -0.04462602f, 0.03333237f, -0.00569705f, 0.15966029f, 0.09114788f, 
    0.06499215f, 0.12322370f, 0.04071680f, 0.03216494f, -0.00804675f, 0.33102825f, 0.12664329f, 0.02331019f, 
    -0.19119616f, -0.01624486f, -0.14799251f, -0.09292857f, -0.31392181f, -0.49659833f, -0.00603955f, -0.09936637f, 
    -0.02197968f, 0.00775022f, -0.09829125f, -0.08940210f, -0.01278735f, 0.00261719f, 0.35767427f, -0.03133667f, 
    -0.00060880f, -0.00217000f, 0.03871384f, 0.06029986f, -0.09390382f, -0.05410376f, -0.22037402f, -0.10786626f, 
    0.18477249f, 0.08876369f, -0.00843166f, -0.04820088f, -0.10396869f, 0.18640937f, -0.08074846f, 0.07028271f, 
    0.21336728f, 0.12522662f, -0.06241339f, 0.10825779f, 0.04344459f, -0.16520359f, 0.17596219f, 0.13003959f, 
    0.08513365f, 0.03502130f, 0.04250606f, -0.02264151f, -0.05714519f, -0.01740137f, -0.13165064f, -0.11110207f, 
    0.03959822f, 0.12099139f, 0.19552569f, 0.14643615f, 0.03664944f, -0.15660068f, -0.14739703f, 0.07546581f, 
    -0.03626784f, 0.01591258f, 0.03725419f, 0.28916064f, 0.22645764f, -0.09207680f, 0.09997439f, 0.06351351f, 
    -0.14386748f, 0.21130775f, 0.03527706f, 0.10653892f, -0.20197918f, -0.09768523f, -0.26807767f, -0.07365526f, 
    0.09179877f, 0.23710161f, -0.11080346f, 0.01428686f, -0.06702196f, -0.02705041f, 0.03188169f, -0.18678132f, 
    0.02243827f, -0.06093878f, -0.11241787f, 0.09215284f, -0.06280220f, 0.13887982f, 0.06712281f, -0.11086554f, 
    -0.03406857f, 0.08662570f, -0.07412174f, 0.01298301f, -0.17323373f, 0.08406065f, -0.10482217f, -0.18645561f, 
    -0.20099948f, 0.03525228f, -0.09240298f, 0.04396063f, -0.05074318f, -0.14310837f, -0.08502851f, 0.05723432f, 
    -0.09785194f, -0.33526421f, -0.07598107f, 0.20751423f, 0.09140064f, 0.04789473f, 0.11151795f, -0.06342116f, 
    -0.08436433f, 0.07180788f, 0.04434804f, 0.06447726f, -0.11260033f, 0.05407768f, 0.05618921f, -0.01479360f, 
    0.03825722f, 0.10123955f, 0.05389843f, 0.03436092f, 0.02748820f, -0.16918811f, 0.06684794f, -0.06515257f, 
    0.01820502f, 0.11949079f, 0.02927759f, -0.07164399f, -0.27775648f, -0.30208659f, 0.03127206f, 0.16573097f, 
    0.02912146f, 0.17214677f, -0.14565271f, 0.06236309f, -0.13287699f, 0.07223789f, 0.07326505f, 0.11918644f, 
    0.09730130f, 0.05560113f, 0.18078707f, 0.01762487f, 0.08207110f, 0.21044865f, -0.08528942f, 0.25211543f, 
    0.03654606f, -0.13156191f, -0.09761496f, 0.04821389f, 0.11258613f, 0.00519189f, 0.19019632f, 0.26974604f, 
    0.03173545f, -0.13487065f, -0.18021499f, -0.02676149f, -0.01278148f, -0.04753968f, 0.15131001f, -0.05391691f, 
    0.25889343f, 0.12554382f, 0.06220832f, -0.04566826f, -0.02868649f, -0.03311367f, 0.03339055f, 0.10904095f, 
    -0.23406176f, 0.16117041f, -0.03475368f, 0.12849353f, -0.00184804f, -0.08169576f, 0.04323683f, -0.08585827f, 
    -0.20183043f, -0.05714765f, 0.10884781f, 0.06753837f, 0.03712256f, -0.04691079f, -0.16042989f, -0.10056406f, 
    -0.14685141f, 0.09626325f, -0.15185863f, -0.08274148f, 0.26708519f, 0.27429989f, -0.01601979f, 0.10519538f, 
    -0.01752905f, 0.01250792f, 0.09654355f, 0.24634475f, -0.06544772f, -0.21153735f, -0.13708742f, -0.08193125f, 
    0.01763898f, 0.10518038f, -0.00120133f, 0.20136783f, 0.03847280f, -0.08877029f, 0.20077460f, -0.07592655f, 
    -0.12016793f, -0.12258889f, -0.10940222f, 0.11910675f, 0.23004997f, -0.17308939f, 0.01272579f, 0.01602291f, 
    0.08497156f, -0.01073718f, 0.04222446f, -0.04153847f, -0.18009193f, 0.03788182f, -0.31256813f, 0.29930720f, 
    -0.18226482f, -0.08773187f, -0.02451104f, -0.33966139f, -0.11445798f, -0.09174197f, 0.03015998f, -0.03233019f, 
    -0.20315097f, 0.05086769f, -0.02336993f, 0.01867885f, -0.04086813f, 0.08619858f, 0.00326977f, -0.05191373f, 
    -0.16008079f, 0.06247308f, 0.30330890f, -0.04749864f, -0.07111223f, -0.12832566f, 0.14581729f, 0.00593483f, 
    0.12199797f, 0.18103407f, -0.47195750f, 0.13594145f, -0.08865651f, -0.03900478f, 0.11690035f, -0.05059268f, 
    0.01276291f, -0.06727805f, -0.31086183f, -0.16544499f, 0.20497365f, -0.01953905f, -0.07042355f, -0.03051903f, 
    -0.01765298f, 0.00829861f, -0.05192624f, -0.02425516f, 0.01189871f, 0.40229806f, 0.05689782f, 0.19488563f, 
    -0.18404673f, 0.04148064f, 0.33342025f, 0.06428015f, -0.12373034f, -0.22944224f, -0.09240108f, 0.22607614f, 
    -0.28715336f, 0.00738281f, 0.05329739f, -0.06521507f, 0.16317885f, -0.10149753f, 0.11003223f, 0.16132049f, 
    0.24254136f, 0.02291716f, -0.08141118f, -0.02346863f, -0.05443507f, 0.08107297f, -0.03088756f, -0.23308650f, 
    -0.56375265f, 0.12597269f, 0.15545894f, -0.00828154f, 0.05827432f, -0.10339870f, 0.14261429f, -0.21978994f, 
    0.18858956f, -0.02397710f, 0.02118314f, 0.01874676f, -0.00219220f, -0.08786304f, -0.01258038f, 0.10359050f, 
    0.31222922f, -0.08515571f, 0.37382761f, -0.26293069f, -0.08377275f, -0.10609576f, 0.12250214f, -0.12452765f, 
    -0.05639854f, 0.10251705f, -0.23010951f, -0.11042343f, 0.01438587f, 0.14939816f, 0.11401952f, 0.04700106f, 
    -0.02934792f, 0.19797778f, -0.15367338f, -0.30550835f, 0.12674266f, -0.01710295f, 0.07028267f, 0.13306791f, 
    -0.03424704f, -0.13131228f, -0.06239111f, 0.02940261f, -0.07332165f, 0.21189439f, -0.16321373f, 0.10889643f, 
    0.01665373f, 0.05108283f, -0.05082908f, -0.08941218f, 0.08276792f, -0.03324699f, -0.01264417f, 0.05941678f, 
    -0.07246094f, 0.07894439f, -0.00465468f, 0.00376387f, -0.01515725f, 0.07248529f, -0.05059313f, -0.25847259f, 
    -0.10198306f, 0.02793622f, 0.02290859f, 0.08189027f, 0.09355928f, -0.04828491f, -0.27902389f, -0.23824397f, 
    -0.09578121f, 0.08112554f, 0.14319026f, 0.05414429f, 0.08771981f, -0.03949594f, -0.19144888f, -0.26197183f, 
    0.06059967f, 0.18550117f, 0.18393268f, 0.05014455f, -0.01723542f, -0.03931197f, -0.03661185f, -0.03721607f, 
    0.18616222f, 0.40916193f, 0.34551245f, -0.19144106f, 0.02902526f, -0.05394705f, -0.10272203f, 0.03780077f, 
    0.04914017f, -0.26110309f, -0.21463755f, -0.20903377f, 0.04851970f, 0.13659024f, 0.13537197f, 0.08104777f, 
    -0.06256078f, -0.18424456f, -0.24488614f, 0.14107826f, 0.17455813f, 0.27780521f, -0.05630625f, -0.08795283f, 
    0.06827820f, -0.12124295f, -0.18734951f, -0.00463536f, 0.19812734f, 0.29000935f, -0.10347930f, -0.11854025f, 
    0.06921864f, -0.30170700f, 0.01367715f, 0.01519337f, 0.08821356f, 0.22028176f, -0.04904778f, -0.01023871f, 
    -0.04542901f, 0.21568015f, -0.01302578f, -0.03107782f, -0.09427083f, 0.28538162f, -0.34004200f, 0.02973119f, 
    -0.22167072f, -0.18172158f, 0.09879515f, -0.04269665f, 0.04857510f, -0.14769873f, -0.17207788f, 0.06592449f, 
    0.01605866f, 0.17732269f, -0.05395197f, 0.06551524f, 0.19780792f, 0.02681967f, 0.25885054f, -0.13762774f, 
    0.04264216f, 0.16633813f, 0.12923288f, 0.08092037f, 0.29332119f, 0.06555508f, -0.00760243f, -0.07405394f, 
    0.00340447f, 0.10850979f, -0.32426107f, -0.08001808f, 0.06268740f, 0.15612172f, -0.00919205f, -0.03539034f, 
    0.04216151f, 0.13421865f, 0.10097534f, -0.22466473f, 0.00268081f, -0.03244891f, 0.07309533f, 0.05822521f, 
    -0.07976832f, 0.06040809f, -0.11152413f, 0.12708037f, -0.24212964f, 0.16742839f, 0.04137129f, 0.07444111f, 
    0.19624257f, -0.11503606f, -0.00243614f, 0.06673238f, -0.16884781f, 0.02015393f, -0.11977261f, -0.01315716f, 
    0.07997406f, 0.14222531f, -0.05423504f, -0.22237706f, 0.04836799f, 0.09825700f, -0.36458141f, 0.15789236f, 
    -0.06504675f, 0.01763031f, -0.14584835f, 0.02753543f, -0.07180626f, 0.26060387f, 0.09056709f, 0.16341370f, 
    -0.16551340f, -0.04279218f, 0.15743572f, -0.13716717f, 0.23461613f, 0.08597920f, -0.32609203f, -0.34839103f, 
    -0.28884387f, 0.04180881f, 0.07722520f, 0.13538061f, -0.29161623f, 0.07314758f, 0.08698746f, -0.20648040f, 
    -0.00583341f, -0.03381492f, -0.06083620f, -0.12291309f, -0.03393064f, 0.00383396f, 0.09773781f, 0.13097106f, 
    0.00621072f, -0.01578623f, -0.40475595f, 0.14627567f, 0.06474131f, 0.10099346f, 0.03888496f, -0.01782132f, 
    -0.08455420f, 0.33796093f, -0.42493525f, -0.16454244f, 0.07465946f, 0.02800201f, 0.13586468f, -0.05627598f, 
    0.08350235f, -0.01140738f, -0.27148288f, -0.16828461f, -0.35319108f, 0.04923974f, 0.04800498f, 0.08465675f, 
    -0.00048474f, -0.02805087f, 0.00893365f, 0.01528947f, -0.50078368f, 0.00175160f, 0.10232691f, 0.08448531f, 
    0.04974119f, -0.18206108f, -0.12752604f, -0.04024396f, -0.23102798f, 0.20300975f, -0.17554179f, 0.05968423f, 
    -0.01103428f, 0.14318298f, -0.07935245f, 0.05036763f, -0.04500112f, 0.16672342f, 0.34388390f, 0.37547541f, 
    -0.03977180f, 0.00209188f, 0.08212890f, 0.18850626f, 0.02430050f, 0.00532032f, -0.17509539f, -0.00810963f, 
    0.02334703f, 0.01387051f, 0.01300285f, -0.04129278f, 0.11581726f, -0.02476247f, 0.19991873f, 0.30860654f, 
    0.08590532f, -0.20950378f, -0.10263525f, -0.00174779f, -0.09059412f, 0.11764386f, -0.02026221f, 0.00623461f, 
    0.20445317f, -0.51783305f, -0.15681760f, -0.05814357f, 0.28075919f, 0.00204141f, -0.03062915f, -0.03872996f, 
    -0.03953959f, 0.06455404f, -0.11055917f, -0.47149804f, -0.01204120f, 0.01230986f, 0.07235307f, 0.12761971f, 
    -0.13460825f, 0.02452289f, 0.07583303f, 0.07516409f, -0.00931391f, 0.08707508f, 0.09962232f, 0.13266870f, 
    0.28815845f, 0.08928507f, 0.00221413f, -0.14110605f, -0.65909094f, -0.38830805f, 0.23830178f, 0.16351570f, 
    0.03232056f, 0.13380295f, 0.01788547f, -0.17706580f, 0.21687792f, 0.09521406f, 0.23645012f, 0.22331418f, 
    0.04357019f, 0.05402314f, 0.13340285f, -0.06686928f, 0.11203532f, -0.23041373f, -0.15986787f, -0.35921562f, 
    0.17168644f, 0.08981065f, -0.12056004f, -0.02600761f, 0.09743138f, -0.07116296f, 0.14933036f, 0.03334815f, 
    -0.08653760f, 0.06538885f, 0.00404429f, 0.04291130f, 0.14439029f, -0.10038171f, 0.19995575f, 0.10289114f, 
    0.41972834f, 0.36160415f, 0.17814097f, 0.05081441f, 0.05888402f, 0.12430214f, 0.10817913f, 0.11655698f, 
    -0.21473117f, -0.05334328f, -0.04523253f, -0.31436962f, 0.06200675f, -0.06616049f, -0.09257814f, 0.04811105f, 
    -0.09830377f, 0.12845211f, -0.07283685f, 0.15958054f, -0.11045680f, -0.01758198f, 0.04919228f, -0.08737639f, 
    0.01623972f, 0.05372154f, 0.07821004f, 0.25408676f, 0.13669285f, -0.04786291f, 0.17798276f, 0.04322144f, 
    -0.04718526f, 0.05017496f, -0.06537738f, 0.08394486f, -0.30382073f, 0.11922379f, 0.04029407f, -0.04298308f, 
    -0.01168303f, -0.15485156f, 0.09925604f, -0.16435263f, -0.06892190f, 0.06776851f, -0.10538104f, -0.06817515f, 
    -0.32726213f, -0.04406748f, -0.16076967f, 0.00461929f, -0.13413878f, 0.35728300f, -0.09523027f, -0.02561415f, 
    -0.05652734f, -0.03505606f, -0.27320650f, 0.03730620f, 0.03691437f, 0.01571328f, 0.09846838f, -0.04362147f, 
    0.09633228f, 0.05607105f, -0.10639509f, 0.05771815f, 0.08634455f, 0.02105642f, -0.11895837f, -0.09063926f, 
    0.03352504f, 0.09665833f, 0.15334754f, -0.01226475f, -0.03293049f, 0.15790829f, 0.04493351f, -0.01494963f, 
    0.05416805f, 0.14245345f, -0.01200217f, -0.15516567f, 0.13866371f, 0.04790122f, -0.07318295f, 0.06811111f, 
    -0.09351013f, 0.07896215f, 0.27906674f, -0.43617412f, -0.11887997f, -0.12771979f, -0.16381204f, -0.10851169f, 
    -0.04914996f, -0.08016855f, 0.23360780f, 0.14290600f, 0.27113140f, 0.07071263f, -0.05427883f, 0.08591190f, 
    -0.13440058f, -0.11707890f, -0.01911198f, -0.03895054f, -0.13281478f, -0.04379311f, -0.03409239f, -0.01738682f, 
    -0.03389263f, -0.19225994f, -0.01855116f, -0.10087582f, -0.01414532f, 0.04625304f, 0.04178417f, 0.18687019f, 
    -0.08172861f, 0.06498276f, -0.02095436f, -0.01271851f, 0.17733368f, 0.30159569f, -0.23707671f, -0.25560778f, 
    -0.17939673f, -0.15802899f, 0.02710566f, -0.03930219f, -0.14756142f, -0.03739662f, 0.07902592f, 0.03911605f, 
    -0.09916880f, 0.01276009f, -0.15355587f, -0.04963933f, -0.14342441f, 0.16957396f, 0.02385192f, 0.01073774f, 
    -0.45063916f, -0.18154220f, -0.13998312f, -0.06803702f, 0.02608910f, 0.01303168f, -0.07543207f, -0.01735530f, 
    0.07663230f, 0.06675211f, -0.03211652f, -0.03281450f, -0.00840333f, -0.02954615f, -0.12727821f, -0.06968080f, 
    -0.07527908f, -0.03713038f, 0.15058215f, 0.34067598f, 0.09789360f, 0.11757909f, 0.17767274f, -0.09084921f, 
    0.09805411f, -0.20170139f, 0.21222380f, -0.09102737f, 0.34247306f, 0.07177636f, -0.05954950f, 0.05510945f, 
    0.08387411f, 0.08791132f, 0.05041484f, 0.30140647f, -0.10645905f, 0.07718279f, 0.21281123f, -0.03980482f, 
    0.04588772f, -0.13034260f, 0.12600768f, 0.27709493f, 0.14021996f, 0.01871645f, 0.27493846f, 0.24813351f, 
    -0.04251948f, 0.22995733f, -0.08989783f, -0.04470089f, -0.06176770f, -0.12405518f, -0.03492302f, 0.03532221f, 
    0.03864228f, -0.02525170f, 0.05798076f, 0.03406998f, 0.03882834f, 0.09540311f, -0.44231644f, 0.05496703f, 
    0.05643472f, 0.01250640f, -0.20814951f, 0.05138151f, -0.14688911f, 0.12860015f, 0.07130720f, 0.30643186f, 
    0.07070036f, 0.23944822f, -0.09517744f, -0.02046389f, 0.15694328f, -0.18194139f, 0.11570577f, -0.02344701f, 
    0.20467190f, 0.26131162f, -0.09230356f, 0.23411380f, 0.10861325f, -0.14346455f, -0.23263003f, -0.09235070f, 
    0.14908616f, 0.04326063f, -0.16016442f, -0.21147417f, 0.11378146f, -0.08956889f, 0.11840297f, -0.03542178f, 
    -0.18003014f, -0.03693990f, -0.03525290f, -0.02540098f, 0.06424470f, 0.03694157f, 0.05595110f, 0.11944783f, 
    0.01785005f, -0.14196774f, 0.04701627f, -0.12520088f, 0.21120074f, 0.16625862f, 0.05238041f, 0.06034947f, 
    -0.15191233f, 0.04086016f, 0.11858361f, -0.00647699f, -0.01067434f, -0.24163738f, 0.03849426f, -0.22793408f, 
    0.03159764f, 0.05207330f, -0.01588138f, 0.00482812f, -0.19635437f, -0.08166304f, 0.00085173f, 0.01637415f, 
    -0.03901614f, -0.05658273f, 0.06627358f, 0.03708896f, -0.01150414f, -0.03749083f, 0.16301163f, -0.12240735f, 
    -0.41229415f, -0.08747043f, 0.14437874f, -0.07258882f, -0.06701434f, 0.11303032f, -0.06070586f, 0.21737100f, 
    0.25314626f, -0.01363356f, -0.14131941f, 0.04494323f, 0.02599375f, -0.22301334f, -0.00548321f, 0.06633957f, 
    0.04276790f, -0.01866124f, -0.04108740f, 0.03694456f, -0.00636376f, 0.04598534f, -0.00525417f, 0.05067078f, 
    0.04307834f, -0.05315919f, -0.04060121f, 0.01542309f, -0.06560759f, -0.01938035f, -0.03894766f, -0.00951540f, 
    -0.00437017f, 0.04875818f, 0.02357519f, -0.02809874f, 0.01742288f, -0.01980012f, -0.06679460f, 0.01882034f, 
    -0.03664832f, -0.03236217f, 0.03079815f, 0.02765477f, 0.00287382f, 0.01608389f, 0.02528629f, -0.00055113f, 
    0.04431123f, 0.00421456f, -0.04814229f, 0.03773356f, 0.00566501f, -0.06641164f, 0.01938603f, 0.01682913f, 
    0.01791562f, -0.06006783f, 0.05953821f, -0.06130705f, -0.05386906f, -0.03126165f, 0.03195740f, -0.01250565f, 
    -0.06578948f, 0.04478283f, -0.01321005f, 0.02115197f, -0.03745123f, -0.06605481f, -0.03655256f, -0.01282642f, 
    -0.04814675f, -0.06038937f, 0.02512054f, -0.04244675f, -0.01624806f, -0.05991230f, -0.06135708f, 0.03170669f, 
    -0.01764474f, -0.05360620f, -0.02899918f, 0.01859443f, -0.06143962f, -0.01884466f, 0.02024418f, -0.04637452f, 
    -0.02444123f, -0.00157396f, -0.01685518f, -0.00480805f, -0.02257716f, -0.02254797f, 0.02979059f, 0.01531419f, 
    0.00947612f, -0.04662733f, -0.03498860f, 0.01499873f, 0.00042008f, 0.04915569f, 0.01919190f, -0.01535719f, 
    -0.02702886f, -0.04161974f, -0.01839807f, 0.01163645f, -0.02093405f, -0.03988894f, -0.05244310f, -0.00070515f, 
    0.03376263f, -0.04540246f, -0.04503863f, 0.01432958f, -0.04072386f, -0.05779784f, -0.04004336f, -0.05296579f, 
    0.03009632f, -0.01611933f, 0.03334203f, -0.03706794f, 0.02595986f, 0.03937204f, -0.05285009f, -0.04426643f, 
    -0.04448308f, -0.00345014f, -0.02498116f, -0.03953770f, -0.06659722f, 0.03380363f, 0.01078395f, -0.05037567f, 
    0.03719604f, -0.06215508f, -0.04016890f, -0.06103192f, -0.03950568f, 0.03221496f, -0.01799358f, -0.05643790f, 
    0.03612971f, 0.02975718f, -0.04869495f, 0.03814096f, 0.05891911f, 0.03284168f, -0.01098845f, -0.03775285f, 
    0.04087427f, -0.03537838f, -0.03249658f, 0.00310528f, -0.01074427f, -0.04750440f, -0.01044317f, -0.02465401f, 
    -0.03138072f, -0.02575319f, 0.02424016f, -0.00574615f, 0.02269258f, -0.04433038f, -0.01089028f, -0.01948607f, 
    -0.03290839f, 0.00166183f, 0.00647627f, 0.03423132f, -0.05253576f, 0.02838456f, 0.00169954f, 0.04441206f, 
    -0.00958874f, 0.01046863f, -0.03150943f, -0.02424433f, 0.04127102f, -0.00180380f, 0.02088610f, 0.04235851f, 
    -0.01444225f, -0.05306600f, -0.02233224f, -0.01866357f, -0.03735029f, -0.02080986f, 0.03026227f, 0.01054845f, 
    -0.04211538f, -0.01393279f, 0.05988280f, 0.03641665f, 0.04291076f, -0.01585368f, 0.02226981f, -0.05936119f, 
    0.03762265f, -0.00895607f, -0.06721659f, 0.04559306f, 0.00259977f, 0.01795438f, 0.03402903f, -0.02901924f, 
    -0.00451941f, 0.02581558f, -0.05424990f, 0.04178165f, -0.01384880f, -0.06258227f, -0.02920018f, 0.02007168f, 
    -0.06418895f, -0.01375502f, -0.00636480f, -0.03203788f, 0.05354958f, -0.04484753f, -0.06200968f, 0.01189091f, 
    0.02655845f, 0.03301326f, -0.04567767f, 0.00636119f, 0.00078167f, -0.01640581f, 0.02875981f, -0.02194316f, 
    -0.03650564f, 0.00299824f, -0.01674074f, -0.01207210f, 0.00204221f, -0.05104581f, 0.01475037f, -0.03460718f, 
    0.03418094f, -0.01129469f, -0.04699965f, -0.05153302f, 0.03502781f, -0.06496626f, 0.04317369f, -0.03132438f, 
    0.03832788f, -0.04365889f, -0.04489858f, 0.02792943f, 0.00546004f, 0.03835168f, -0.05163192f, 0.00495202f, 
    -0.01111887f, -0.05598003f, -0.01034084f, -0.04985815f, -0.01253357f, -0.02619638f, -0.01772095f, -0.05288135f, 
    0.04871240f, 0.04822571f, -0.02751885f, 0.01746108f, 0.01193022f, 0.02008718f, 0.01774912f, 0.02899631f, 
    0.02715697f, 0.04877894f, 0.04922867f, -0.04806015f, 0.00188766f, -0.05748889f, 0.00155693f, 0.04868671f, 
    -0.03834042f, 0.03652593f, -0.04917302f, 0.04369553f, 0.01543169f, 0.02302333f, 0.01034374f, 0.02979002f, 
    -0.02181016f, 0.03606579f, -0.04842287f, 0.04447161f, 0.03336839f, -0.05026025f, -0.00030951f, 0.01067931f, 
    -0.00256587f, -0.06565436f, 0.02097642f, -0.05535914f, 0.03997853f, 0.01265081f, 0.04812807f, -0.00449380f, 
    -0.00795257f, -0.00844532f, -0.02537510f, -0.05216977f, -0.04421296f, 0.02102078f, 0.04546678f, 0.02334455f, 
    0.04008340f, -0.00805777f, -0.00211769f, -0.06489678f, 0.04604427f, -0.03180191f, -0.06257723f, 0.02985484f, 
    0.00283631f, -0.00783975f, 0.02324261f, -0.01542275f, 0.01771218f, -0.06088521f, -0.02287412f, 0.01125423f, 
    -0.01534868f, -0.01135647f, 0.01467472f, 0.01888439f, 0.00707583f, -0.03701534f, 0.01868317f, -0.05386994f, 
    -0.02544951f, -0.05250222f, 0.00162145f, -0.04996417f, -0.02055122f, -0.05215933f, 0.03456761f, -0.06076976f, 
    0.03169474f, -0.01786890f, -0.01865686f, -0.03721583f, 0.00666630f, -0.03865925f, -0.01315909f, -0.01059155f, 
    -0.04948326f, 0.04304888f, 0.01708862f, -0.04616109f, -0.00309546f, -0.05374935f, 0.02402636f, 0.05263500f, 
    0.05222277f, 0.03652762f, -0.00806092f, -0.02606058f, 0.00980745f, -0.03083349f, -0.04516567f, 0.05137327f, 
    -0.03349158f, 0.02403123f, 0.00217534f, 0.00831276f, 0.04522756f, 0.01825423f, -0.04305612f, -0.03560717f, 
    0.01869705f, 0.03281923f, -0.00514516f, 0.05013536f, -0.05737838f, 0.04124735f, 0.04886282f, -0.05842719f, 
    0.00587175f, -0.00897783f, -0.01028400f, 0.02676008f, -0.01070746f, 0.00734474f, -0.03452865f, -0.05751967f, 
    0.02176607f, -0.05906239f, -0.02206617f, -0.01966621f, -0.01607088f, -0.01704907f, -0.05140516f, 0.00989009f, 
    0.01950125f, 0.04247537f, -0.05995972f, 0.00294620f, 0.03803666f, -0.01709275f, 0.00429765f, -0.03662834f, 
    -0.05728299f, 0.01092761f, 0.01700516f, 0.03693774f, 0.02733809f, -0.05669670f, -0.03503566f, 0.01120236f, 
    0.04176834f, 0.00794791f, -0.02078248f, 0.02546880f, 0.03971456f, -0.05448590f, -0.00138604f, 0.00051904f, 
    -0.01842449f, -0.03611872f, 0.04069302f, 0.04746603f, -0.01551243f, -0.02021460f, -0.05580916f, 0.02934094f, 
    -0.01697285f, 0.01441799f, 0.04620386f, -0.04490073f, -0.06574490f, 0.00984672f, 0.03860031f, -0.01071830f, 
    -0.03592470f, 0.01174397f, -0.03967772f, 0.00703353f, 0.01950582f, 0.00020860f, -0.02372289f, -0.06527730f, 
    -0.04013699f, -0.02743156f, 0.02945387f, 0.04837246f, -0.00772834f, 0.01429461f, 0.01389651f, 0.04296028f, 
    0.00592328f, -0.01102751f, 0.01264463f, 0.02576719f, 0.01877302f, -0.01010993f, -0.03095843f, 0.02406406f, 
    -0.00693351f, 0.01200723f, -0.03374957f, -0.01264475f, 0.02211672f, 0.01857005f, -0.03880613f, -0.05450755f, 
    0.01152059f, 0.01196353f, 0.04667219f, -0.06341167f, -0.02287436f, -0.02242342f, -0.00537079f, 0.01460517f, 
    0.03303123f, -0.04016653f, 0.01632839f, 0.02701105f, 0.01939961f, -0.06473249f, -0.05205487f, 0.05457716f, 
    -0.05397399f, -0.05936025f, -0.01133768f, 0.05206161f, -0.05377114f, -0.04108853f, 0.02951930f, -0.03551913f, 
    0.02410938f, -0.00425052f, -0.05840881f, 0.00505796f, -0.02062162f, -0.05507724f, 0.03263841f, -0.06154099f, 
    -0.05695596f, 0.02802595f, -0.02533208f, -0.03449894f, -0.02351573f, 0.00912476f, -0.00390135f, -0.05141056f, 
    0.02339672f, -0.01784500f, 0.02205690f, 0.04140273f, 0.02603399f, 0.04827474f, -0.05979086f, -0.05542405f, 
    -0.04747006f, -0.01467820f, -0.05374411f, -0.03614075f, -0.04977432f, -0.00304196f, 0.03682393f, 0.05221748f, 
    -0.00115589f, 0.02133385f, -0.04108981f, 0.00025557f, -0.05511509f, -0.04368734f, -0.06328072f, -0.00830594f, 
    -0.01772309f, -0.00086721f, 0.01975689f, -0.03294347f, -0.06112958f, -0.03930048f, -0.06098108f, 0.03833199f, 
    0.00892372f, -0.06201376f, 0.04133598f, -0.00136300f, 0.04806198f, -0.00353256f, -0.02309760f, -0.03741954f, 
    -0.05879610f, -0.05113186f, 0.04053223f, -0.05207022f, -0.00535649f, -0.03623057f, 0.04246440f, -0.01148026f, 
    0.02470886f, 0.04380795f, -0.00893889f, -0.05583822f, 0.02654892f, 0.04516506f, 0.03929244f, 0.00448087f, 
    -0.00006873f, 0.04723074f, -0.01715509f, -0.03786692f, -0.04034838f, -0.03351819f, -0.02686484f, -0.00682243f, 
    0.04745382f, -0.01239653f, 0.00709008f, 0.02077793f, 0.04170395f, -0.04442238f, -0.03196717f, 0.03564945f, 
    -0.03958763f, 0.02691179f, 0.00728792f, 0.04614472f, -0.01291763f, -0.04781454f, 0.00116642f, -0.04214669f, 
    0.33168620f, -0.02457614f, 0.03255789f, 0.12668140f, -0.01894367f, -0.04396770f, 0.02853747f, -0.06791733f, 
    0.02512375f, -0.08744016f, 0.02986027f, -0.00265743f, 0.03063873f, -0.02118318f, -0.06615004f, -0.02083644f, 
    -0.00959069f, 0.14942122f, 0.01044894f, -0.00429190f, 0.01756308f, 0.09556615f, -0.01678738f, 0.14029093f, 
    0.16668682f, 0.08238626f, 0.10980017f, 0.21198450f, 0.04911770f, 0.16220233f, 0.19574662f, -0.08201084f, 
    0.24029925f, 0.05054847f, -0.23115605f, -0.02619716f, 0.02719327f, -0.13921946f, -0.18122877f, 0.11150467f, 
    0.14430413f, 0.23027067f, -0.17493598f, 0.04995906f, -0.09757754f, 0.10761513f, -0.03072356f, -0.16393378f, 
    0.03013865f, 0.14089972f, 0.18327050f, -0.13215642f, 0.14730301f, 0.14877594f, -0.16269074f, -0.18681334f, 
    -0.19832262f, 0.15406498f, -0.05453683f, 0.20808688f, 0.09391233f, -0.09502315f, -0.16657767f, 0.19879587f, 
    -0.18526945f, 0.00652993f, 0.04964609f, 0.03508041f, 0.20411660f, 0.05663574f, -0.03941506f, -0.03237677f, 
    0.17707005f, -0.01570076f, 0.09158974f, -0.16026825f, -0.10425680f, 0.13353565f, 0.04006036f, 0.06798682f, 
    -0.24140976f, 0.18623017f, -0.35827011f, -0.14802760f, 0.12035973f, -0.03023155f, 0.09260437f, -0.07793700f, 
    0.05082489f, -0.21448740f, -0.04758394f, 0.01293115f, -0.01175801f, -0.14355077f, -0.09028709f, -0.07579771f, 
    0.06805011f, -0.10836659f, -0.06475012f, -0.06735840f, 0.12386777f, -0.09761976f, -0.01371035f, -0.00812657f, 
    -0.09464020f, 0.08911122f, -0.29154947f, 0.04605510f, -0.06350090f, 0.02304210f, -0.10868595f, 0.08341984f, 
    -0.36521143f, 0.21187392f, -0.00223219f, -0.08512542f, 0.02050784f, 0.16461515f, 0.20480952f, 0.03865472f, 
    0.03224076f, 0.08363057f, 0.15215380f, 0.06221419f, -0.05192953f, 0.06248670f, -0.03588047f, 0.23366761f, 
    0.12149168f, 0.04241193f, -0.11830347f, -0.09023544f, -0.01017953f, 0.04845073f, -0.23391213f, 0.13984270f, 
    0.21585464f, -0.18574901f, 0.00160823f, 0.00637760f, -0.00244529f, 0.16735956f, 0.08073237f, 0.11057937f, 
    0.09999329f, -0.08594319f, 0.12074495f, -0.15018280f, -0.10764783f, -0.20853578f, -0.03431886f, 0.04125128f, 
    -0.13774487f, -0.07327916f, 0.05456152f, 0.04715144f, 0.12094098f, 0.01984422f, 0.10548704f, -0.16483632f, 
    0.07143924f, -0.07970988f, 0.14531273f, -0.06689721f, 0.10645026f, 0.06335859f, -0.10074330f, -0.06270025f, 
    0.04399826f, 0.01605796f, -0.05102906f, -0.07622842f, 0.08836156f, 0.18319844f, -0.11664584f, -0.12812549f, 
    0.00404968f, -0.06800354f, 0.00928024f, 0.03401964f, -0.01150019f, 0.05103544f, 0.13319455f, -0.00090787f, 
    -0.03564182f, -0.15802866f, 0.00336421f, 0.00831722f, -0.19621322f, 0.17614225f, -0.00979290f, -0.24124078f, 
    0.00446101f, 0.10816772f, 0.02142439f, 0.16304757f, 0.09093870f, 0.00565568f, 0.29520643f, -0.15636328f, 
    0.17051730f, 0.00911330f, -0.01199668f, -0.00910984f, -0.09173626f, 0.08247883f, -0.09964187f, -0.00698947f, 
    0.04087448f, -0.12039275f, -0.09804094f, -0.00088012f, 0.03159864f, -0.01104966f, 0.12994152f, 0.01317241f, 
    -0.01673659f, 0.21491228f, -0.18488748f, 0.14316756f, -0.11315159f, -0.05413511f, -0.08921629f, 0.02181944f, 
    -0.05029667f, -0.05496835f, -0.06315509f, 0.21052161f, -0.13158487f, -0.12059759f, -0.04050115f, -0.04546365f, 
    -0.00195048f, -0.12961367f, -0.28088635f, -0.05728629f, 0.06176909f, -0.14451170f, 0.05423315f, -0.04043534f, 
    0.01265975f, 0.08769797f, -0.13932888f, -0.05258820f, 0.08941542f, 0.13236780f, 0.05496421f, -0.17001273f, 
    -0.01802781f, -0.11430293f, 0.08002191f, 0.03989507f, -0.06734527f, -0.07810788f, -0.06531731f, 0.04046667f, 
    0.10676099f, 0.26108655f, -0.23005180f, -0.13564911f, -0.00389497f, 0.29766941f, 0.14597970f, -0.02041628f, 
    0.10328344f, -0.13231835f, 0.00075463f, 0.04786226f, -0.02229821f, -0.16213055f, 0.26904881f, -0.27244842f, 
    0.27729625f, -0.06927053f, -0.06574830f, -0.09710056f, -0.06244798f, -0.01859307f, -0.04882807f, 0.16269013f, 
    -0.18868347f, -0.28092718f, 0.14027770f, 0.09768752f, 0.14064454f, -0.08487421f, -0.01582591f, 0.11247990f, 
    0.43639517f, 0.35654750f, -0.19994457f, 0.12818934f, -0.18024004f, -0.03384090f, 0.14672841f, 0.12105789f, 
    -0.10304492f, -0.02530765f, 0.03289772f, -0.05405081f, -0.08646619f, 0.09517562f, 0.09475262f, -0.03300875f, 
    0.02554173f, -0.02703479f, 0.28771544f, -0.01051417f, -0.09167808f, 0.05418102f, 0.09577896f, -0.11443959f, 
    -0.08191480f, 0.15912758f, -0.19860382f, 0.39377290f, 0.40457663f, -0.20087388f, 0.04178650f, 0.06050004f, 
    0.09237284f, 0.00341030f, -0.02708335f, 0.08118035f, -0.22226600f, -0.16321103f, 0.01999725f, 0.19143233f, 
    -0.10741587f, 0.01170740f, -0.08972532f, 0.15047249f, -0.09859852f, 0.42757642f, -0.19299226f, 0.02150514f, 
    -0.21936169f, 0.11378897f, 0.10141085f, -0.02421241f, 0.00502745f, -0.05033563f, -0.22083385f, -0.25621921f, 
    0.10481845f, 0.28655037f, 0.12740757f, 0.02172432f, -0.06111473f, -0.03109969f, -0.05639937f, 0.36194783f, 
    -0.12285946f, 0.03803898f, 0.12355299f, 0.05927109f, 0.01454930f, 0.00293027f, -0.00957455f, -0.04642222f, 
    -0.13250387f, 0.25058758f, -0.14756951f, 0.05232709f, -0.22700670f, -0.13600251f, -0.01617892f, 0.07512197f, 
    -0.05248893f, 0.08887538f, -0.02482688f, -0.00655721f, 0.02636747f, 0.05582915f, -0.03898885f, -0.00933763f, 
    0.10129399f, -0.02740492f, 0.05104763f, 0.06850865f, 0.00209265f, -0.24888954f, -0.01836615f, 0.02470331f, 
    0.06606997f, -0.04008115f, 0.03193907f, -0.22246079f, 0.05319038f, -0.13817976f, 0.03156186f, 0.19297662f, 
    -0.00941617f, -0.04041878f, 0.14979653f, -0.21329041f, -0.13747029f, 0.18079433f, 0.09378491f, -0.24063177f, 
    -0.01148421f, 0.02245691f, 0.04358419f, -0.12334830f, -0.22124903f, -0.00488920f, 0.03083018f, -0.09166164f, 
    -0.03289726f, -0.06267559f, -0.11122043f, 0.10542863f, -0.20830438f, -0.03489179f, -0.08415791f, -0.22057453f, 
    -0.24831970f, 0.24909125f, -0.06778928f, 0.07733807f, 0.03252463f, 0.06172726f, 0.03024179f, 0.03407080f, 
    -0.02291020f, 0.01258895f, -0.02711394f, 0.04325586f, -0.00841178f, -0.05585413f, 0.00223881f, 0.21655838f, 
    0.33772027f, -0.21088754f, -0.06247718f, 0.06572003f, -0.10614737f, -0.03961205f, 0.04378682f, -0.02909684f, 
    0.03926749f, 0.06909841f, -0.38167664f, 0.01001055f, -0.12218583f, 0.02765177f, 0.07790286f, 0.07055984f, 
    -0.05977077f, 0.09867147f, -0.15802573f, 0.24739791f, -0.02324365f, 0.04579080f, 0.10114571f, -0.13847362f, 
    -0.18325937f, 0.02909452f, 0.10692564f, -0.24358128f, 0.01202432f, 0.06613123f, -0.16082227f, 0.12124623f, 
    0.07743309f, -0.15672277f, -0.18482536f, 0.02596705f, -0.03023246f, 0.31982583f, 0.12003110f, -0.04547504f, 
    -0.00167706f, -0.09765562f, -0.02491559f, -0.15484238f, 0.15285331f, 0.53882492f, 0.07646605f, 0.00942970f, 
    0.15607865f, -0.04632853f, -0.04123734f, 0.18625927f, 0.05665696f, 0.14644404f, 0.16204952f, -0.23683448f, 
    -0.28562111f, -0.01234426f, -0.03326029f, -0.11825835f, 0.01825348f, -0.04074176f, 0.02916464f, 0.11824052f, 
    -0.07645185f, -0.07164223f, 0.03536655f, -0.03761225f, 0.08106929f, 0.12552546f, 0.13317712f, -0.05479288f, 
    -0.47798291f, -0.12068162f, 0.00712105f, 0.03224543f, 0.21605551f, 0.25350818f, -0.12006871f, 0.04778832f, 
    -0.28867191f, -0.24545574f, 0.05407579f, -0.01280077f, -0.02362208f, 0.08296945f, 0.06977942f, 0.02526662f, 
    0.01212925f, -0.13159460f, -0.04501683f, 0.06453472f, -0.13759211f, 0.00257769f, -0.27505594f, 0.01503058f, 
    0.02403138f, 0.05115193f, 0.14065370f, 0.08404507f, -0.26880223f, 0.10237221f, -0.04395963f, 0.11050542f, 
    0.11450668f, -0.22668287f, 0.14777832f, -0.00978803f, 0.15548307f, 0.27545914f, -0.09540966f, -0.17637861f, 
    0.08594786f, -0.03192554f, -0.05767982f, -0.13074471f, -0.00597424f, 0.26563284f, -0.06413729f, -0.19911717f, 
    -0.06060571f, 0.07464927f, -0.01398211f, -0.18234146f, -0.00563886f, 0.08538958f, -0.03838452f, -0.12432074f, 
    -0.23461352f, -0.17769945f, 0.00270616f, -0.16248575f, 0.17391315f, -0.00941709f, -0.07290890f, 0.30443904f, 
    0.08974220f, 0.02813266f, -0.03536827f, -0.04824304f, 0.04293891f, 0.06368519f, -0.03100770f, 0.09888452f, 
    0.50100261f, 0.13940315f, -0.09311395f, 0.05958309f, -0.09406690f, 0.29736865f, -0.14877859f, 0.02477475f, 
    0.04598258f, -0.11767862f, -0.03461325f, -0.02127758f, -0.02425822f, 0.06193860f, 0.04624904f, 0.05280777f, 
    -0.13917385f, 0.06248636f, -0.36954182f, -0.12113938f, 0.00825527f, -0.16045718f, 0.04642341f, -0.11282452f, 
    0.01849284f, 0.15189068f, 0.00838591f, 0.53138059f, 0.07358281f, -0.02437455f, -0.07570337f, 0.26118898f, 
    -0.10813005f, -0.01791445f, 0.10971383f, 0.10628316f, 0.24436449f, 0.13837515f, 0.33718294f, 0.26745611f, 
    -0.07155932f, -0.14216052f, -0.03214886f, 0.03398677f, 0.08405764f, -0.13752867f, 0.02812089f, 0.18917012f, 
    0.09450819f, -0.06603658f, -0.09894735f, 0.11147624f, -0.12365643f, 0.10903192f, 0.17822373f, 0.05341712f, 
    0.06787089f, -0.10598262f, -0.01587659f, 0.13845935f, 0.07215791f, 0.05666134f, 0.07052801f, 0.24396642f, 
    0.14163063f, -0.03301540f, -0.08696227f, 0.28662360f, 0.03834349f, -0.14050342f, 0.09032886f, 0.10729086f, 
    -0.30876121f, -0.07173252f, -0.06265607f, -0.23076007f, 0.12556161f, 0.03016454f, -0.05746626f, -0.00975196f, 
    -0.06101408f, -0.12562449f, -0.07010800f, 0.14973792f, 0.07195705f, -0.16101055f, 0.07606085f, -0.05375868f, 
    0.17345199f, -0.07255308f, -0.20017514f, -0.13750422f, -0.08258783f, -0.06151050f, 0.03564002f, 0.09146158f, 
    0.12390394f, -0.02730503f, -0.09937004f, 0.32752502f, 0.05018149f, 0.08244763f, 0.00832972f, -0.11034397f, 
    -0.09183197f, 0.05406108f, -0.03019061f, 0.24323736f, -0.54990816f, -0.11135575f, 0.05478510f, 0.01424456f, 
    0.05789254f, -0.07013864f, 0.15889288f, 0.22418194f, 0.30864573f, -0.08788729f, 0.01051918f, -0.08434151f, 
    -0.12151492f, -0.05786270f, 0.24296854f, -0.04004076f, -0.09771589f, -0.02151697f, -0.19911233f, -0.18124638f, 
    -0.07100770f, -0.04712124f, -0.00774739f, -0.15196404f, 0.03245108f, 0.04719969f, -0.05391676f, -0.13246991f, 
    -0.13963637f, -0.03565057f, 0.14952809f, 0.04304548f, 0.01927965f, -0.01499753f, -0.12920606f, 0.18745054f, 
    -0.15427123f, -0.18820550f, -0.21544373f, -0.09823625f, 0.23794626f, -0.01585068f, -0.00828158f, 0.32361621f, 
    -0.07644329f, 0.24485064f, 0.08759659f, -0.15112002f, -0.01856271f, -0.04259459f, -0.03355055f, 0.07451078f, 
    -0.11445236f, -0.41645169f, -0.14824429f, 0.22462253f, -0.17864671f, 0.07744494f, -0.00308775f, -0.11735918f, 
    0.10163181f, -0.04880939f, -0.04340581f, -0.02842866f, 0.06873900f, -0.40998995f, 0.15600018f, 0.00625820f, 
    -0.06326815f, 0.09227762f, -0.22106840f, 0.02053862f, -0.32907251f, 0.07745499f, -0.04671588f, -0.14018196f, 
    0.13274331f, 0.01421649f, -0.13264571f, -0.04910384f, -0.12881222f, 0.30866522f, 0.02261761f, 0.05643843f, 
    0.06437329f, -0.00812487f, 0.22668505f, -0.04315845f, 0.04746797f, 0.01433939f, -0.12257772f, 0.00407581f, 
    0.34257999f, -0.02499577f, -0.00740251f, 0.01499369f, 0.15346582f, -0.07704332f, -0.21739344f, -0.03810096f, 
    0.16654421f, 0.25213972f, -0.03598835f, 0.01217124f, -0.16841120f, 0.10193987f, -0.05059186f, -0.08565939f, 
    -0.09727386f, 0.11963722f, 0.10327754f, 0.02999014f, 0.04748212f, -0.10105106f, -0.05601634f, -0.10912416f, 
    0.11992805f, -0.00919895f, -0.15989064f, -0.25256461f, 0.08641158f, -0.01977415f, 0.01180429f, -0.08994143f, 
    0.25839561f, -0.02265661f, -0.20015208f, -0.08904114f, -0.10873154f, -0.05594543f, 0.14069805f, 0.10736746f, 
    0.04723314f, 0.01428942f, -0.17966372f, 0.20810710f, -0.08849232f, -0.32613218f, 0.01219398f, 0.02470218f, 
    -0.00022827f, 0.12814043f, -0.16642098f, -0.15455770f, 0.00523570f, 0.08858724f, 0.02060148f, 0.03958060f, 
    0.02716858f, 0.10833613f, -0.07747480f, 0.16144930f, 0.08435415f, -0.31506750f, -0.01489794f, 0.13615160f, 
    -0.10404210f, 0.20787036f, -0.02010322f, -0.11595298f, -0.03214712f, 0.17463034f, 0.32955328f, 0.07870261f, 
    0.05212542f, 0.06567241f, -0.04676047f, -0.00895827f, -0.14133841f, 0.27234250f, -0.07935859f, 0.02258873f, 
    0.18242228f, 0.14268979f, 0.17030901f, -0.03698329f, -0.06573709f, 0.05492429f, 0.03169605f, 0.21389630f, 
    0.14945897f, 0.07154696f, 0.07376597f, 0.31292883f, 0.03744684f, -0.24691416f, 0.17639956f, 0.02649707f, 
    0.12992008f, 0.07515527f, 0.09868905f, 0.03618377f, -0.09002775f, 0.07143776f, 0.05588556f, -0.02534163f, 
    0.14900015f, -0.08990812f, 0.43693906f, -0.00931706f, -0.04729870f, 0.25510719f, 0.04047194f, -0.01459232f, 
    -0.08756027f, 0.00822709f, -0.06614279f, 0.04335662f, 0.01145113f, 0.23299137f, 0.28391120f, 0.08814482f, 
    -0.04893107f, -0.10369533f, 0.12182750f, 0.13288729f, -0.06406360f, -0.25089937f, 0.05165097f, 0.14695780f, 
    0.13297760f, 0.11278219f, -0.00689557f, -0.06467950f, -0.22989142f, 0.18179643f, -0.00552914f, -0.08146837f, 
    -0.08628114f, 0.04162431f, 0.02556979f, -0.02322338f, -0.17219315f, -0.14082846f, 0.09613539f, -0.10149837f, 
    0.06919676f, 0.23346889f, -0.09249979f, 0.16040035f, 0.01484424f, 0.17765671f, -0.09602699f, 0.11795864f, 
    -0.12587537f, -0.02612116f, 0.18137403f, 0.02328370f, 0.21553700f, -0.07196545f, 0.10230715f, -0.05395723f, 
    -0.10267375f, 0.19408870f, -0.12854560f, -0.03489731f, -0.09407680f, -0.13791117f, 0.01343792f, 0.08077219f, 
    0.17938432f, 0.12692113f, -0.09390351f, 0.03718059f, 0.07340233f, -0.11327502f, -0.08283411f, 0.02700003f, 
    0.01831955f, 0.10015334f, 0.18327168f, 0.28450003f, -0.03083112f, 0.04037831f, -0.06587575f, -0.12024394f, 
    0.12630214f, 0.05967231f, 0.05444271f, 0.25733632f, 0.08366168f, 0.19594708f, -0.09747081f, 0.13214466f, 
    -0.06196529f, 0.16857591f, 0.00035574f, -0.06929226f, -0.01310184f, -0.07558822f, -0.03614060f, -0.04277750f, 
    0.01195091f, 0.01231724f, -0.17602767f, -0.17340565f, 0.02846774f, 0.17228569f, 0.11735509f, 0.05824806f, 
    0.20234808f, 0.05254085f, -0.20737970f, 0.19572502f, 0.05081732f, 0.21785577f, 0.03902402f, 0.24764185f, 
    -0.25602916f, 0.01337749f, 0.03801931f, 0.14365283f, 0.00385923f, 0.18624242f, 0.07964252f, 0.04500706f, 
    0.14721851f, 0.11630230f, -0.00679041f, 0.07429870f, -0.08392948f, 0.14776504f, -0.01454840f, 0.02945117f, 
    -0.02202673f, 0.13650110f, -0.03241052f, 0.06933720f, -0.09727816f, -0.07033223f, -0.01266812f, 0.00620900f, 
    0.01151353f, -0.20222464f, -0.16952206f, -0.10724609f, 0.00886620f, -0.17933463f, 0.11599252f, -0.02612626f, 
    -0.11137051f, 0.02495216f, -0.10035378f, -0.01336154f, 0.04510634f, -0.11751530f, 0.02453202f, 0.21166757f, 
    -0.05820482f, 0.04291163f, 0.09162884f, -0.08726809f, -0.12438052f, 0.17930499f, -0.31718862f, 0.04308183f, 
    0.00515089f, -0.01303264f, -0.11015224f, 0.03222532f, -0.15511701f, 0.35752496f, 0.00308514f, 0.22826290f, 
    -0.07877320f, -0.04150108f, 0.07289620f, -0.05272596f, 0.21405526f, -0.02026008f, -0.00520956f, 0.19740714f, 
    0.32385615f, 0.29707628f, -0.06700752f, 0.22757800f, -0.00278407f, 0.02767959f, 0.27955875f, 0.01392821f, 
    -0.09489568f, 0.01527491f, -0.00322092f, -0.07232890f, 0.13836420f, 0.09110884f, 0.01642334f, 0.19595453f, 
    0.17326263f, 0.04051456f, -0.00332488f, 0.11578396f, 0.06010662f, 0.11156867f, 0.04389276f, -0.11746188f, 
    0.12770022f, -0.12859990f, -0.09694422f, -0.31084374f, -0.04410687f, 0.21542734f, -0.01894337f, 0.18423985f, 
    -0.13842797f, 0.27959654f, 0.29957074f, -0.10722645f, 0.05554854f, -0.18809740f, 0.03160569f, -0.01106326f, 
    -0.01840096f, -0.22481734f, 0.01124595f, 0.19371518f, -0.01355132f, 0.08360843f, -0.02328779f, -0.22117427f, 
    0.05404785f, -0.07418850f, -0.03598906f, -0.06871554f, -0.14733054f, 0.08777826f, -0.02838379f, -0.09634285f, 
    0.04898350f, -0.18814559f, 0.14962812f, -0.10736451f, 0.06757329f, 0.00539569f, 0.21984227f, 0.22840938f, 
    0.12251264f, 0.01506497f, -0.25292671f, 0.07094884f, 0.03083432f, 0.25774515f, 0.07057437f, 0.07288273f, 
    -0.06189693f, 0.05307788f, -0.09139656f, -0.11511911f, -0.11948355f, -0.03082975f, 0.19642000f, 0.12496600f, 
    0.03115019f, 0.09127351f, -0.32863474f, -0.03681667f, 0.12294270f, -0.18225862f, -0.07171935f, -0.10133868f, 
    -0.09706008f, 0.06199594f, 0.24015641f, 0.09775557f, 0.10256532f, 0.12122916f, -0.07111221f, -0.07486150f, 
    -0.03091509f, -0.02038077f, -0.02681038f, -0.03523441f, -0.05381214f, 0.03844464f, -0.03890726f, -0.04094256f, 
    -0.06025599f, 0.03000782f, -0.03930847f, -0.01953934f, 0.04591277f, -0.04299355f, 0.01168370f, 0.04637155f, 
    -0.06174005f, 0.00500804f, 0.03221144f, 0.05201746f, 0.04436754f, -0.05263944f, -0.00120469f, -0.01312816f, 
    0.04821785f, -0.04025365f, -0.04524362f, -0.04293193f, -0.03154559f, -0.02465583f, 0.00788286f, 0.05483355f, 
    0.01018032f, 0.02381977f, 0.02488797f, -0.00475598f, -0.05555166f, -0.03638203f, 0.02869341f, 0.01177474f, 
    0.01164451f, -0.00601497f, 0.01087434f, -0.03884271f, -0.06423022f, 0.05213559f, 0.04617584f, 0.01398955f, 
    0.00244981f, -0.02821652f, 0.01298300f, 0.01934357f, 0.00914609f, 0.00960497f, -0.04121767f, -0.05034558f, 
    0.03310061f, -0.02199065f, -0.02319601f, -0.02304089f, 0.00744255f, 0.01954078f, -0.05349046f, -0.05828036f, 
    -0.04056240f, 0.00092614f, 0.03182575f, 0.04337906f, 0.03855565f, 0.02106732f, 0.03860626f, 0.03415164f, 
    -0.00764720f, 0.02677575f, 0.04573810f, 0.03535566f, -0.05500410f, -0.04060985f, -0.05080027f, -0.01616642f, 
    -0.00181895f, -0.05852687f, 0.02347879f, 0.03890912f, 0.01169152f, 0.03966022f, 0.04208422f, 0.03198754f, 
    0.00260353f, -0.04497521f, 0.03966678f, -0.01135970f, -0.05547747f, -0.01195818f, 0.03914821f, -0.04840551f, 
    0.02791128f, -0.03553130f, 0.00187240f, -0.01792276f, -0.03155867f, 0.02590030f, -0.01807459f, 0.03145584f, 
    -0.06634931f, -0.03343838f, -0.04478249f, -0.01096854f, -0.02903732f, -0.04005159f, -0.05909060f, 0.02798295f, 
    0.02693054f, -0.05926670f, 0.00308427f, 0.02886534f, -0.03387482f, -0.05684409f, -0.03954055f, -0.03342513f, 
    0.04495918f, -0.04386861f, 0.00483306f, 0.02651811f, -0.05729645f, -0.03785724f, 0.03343326f, 0.03296906f, 
    -0.01417006f, -0.01799374f, -0.01001861f, -0.05088283f, -0.01333918f, -0.00712593f, 0.04776292f, -0.02308308f, 
    -0.03249244f, 0.01388138f, 0.01022425f, 0.01266317f, -0.01439728f, -0.05174921f, 0.01053812f, -0.06333104f, 
    -0.01936392f, -0.04601195f, -0.00321578f, -0.05119193f, 0.04638082f, 0.04842360f, 0.02475782f, 0.00190512f, 
    0.03500604f, -0.01405678f, 0.02664401f, 0.03077371f, -0.00542026f, -0.01823371f, 0.04650684f, -0.06283668f, 
    -0.04615340f, -0.02669862f, -0.04389925f, 0.01343655f, -0.03565015f, -0.02330110f, -0.03873523f, 0.03317105f, 
    -0.01745751f, 0.02465238f, 0.00834092f, -0.05395858f, 0.05784450f, -0.02073777f, -0.03934072f, -0.05223069f, 
    0.01719140f, -0.03083201f, -0.00911052f, 0.03039660f, -0.04616602f, 0.01062293f, -0.00691289f, 0.03111169f, 
    0.02550068f, -0.03926565f, -0.03384070f, -0.04153093f, 0.05228512f, -0.03573248f, -0.00503471f, 0.03309074f, 
    -0.02024163f, 0.01404232f, -0.04338551f, -0.06532227f, 0.02268852f, 0.03046672f, 0.02712697f, -0.01875340f, 
    -0.05206487f, -0.01630608f, -0.02223701f, -0.04572988f, -0.03603915f, -0.02412235f, -0.03177492f, 0.02683538f, 
    0.02766413f, -0.03304891f, 0.01039214f, -0.04816156f, -0.06804456f, 0.03427215f, -0.06380022f, -0.04491429f, 
    0.01679756f, 0.02969199f, -0.00638508f, -0.04043591f, -0.00368532f, 0.03671432f, -0.04770963f, -0.05104236f, 
    -0.03882606f, 0.00430998f, 0.03948050f, 0.04220901f, 0.03747628f, -0.03583872f, 0.03459977f, -0.02138500f, 
    -0.04266888f, -0.04533826f, -0.01715523f, 0.02416153f, -0.02650349f, 0.04431000f, 0.03390334f, -0.00330594f, 
    -0.01940727f, -0.04897731f, 0.04327616f, -0.04834640f, -0.03398233f, -0.01144648f, 0.04791394f, 0.01531236f, 
    0.04212565f, 0.00498990f, -0.01417273f, 0.02504962f, 0.01575926f, -0.01858897f, 0.04124129f, -0.06882076f, 
    -0.05665671f, 0.02356462f, -0.06208510f, 0.02728975f, -0.06305021f, 0.01724301f, 0.03577617f, -0.02736724f, 
    -0.05122184f, -0.03046784f, -0.06162687f, -0.05139627f, -0.02720860f, -0.00691357f, 0.03657540f, 0.02003259f, 
    -0.06286834f, 0.00346739f, -0.05207373f, 0.03127791f, -0.01984541f, 0.00553177f, 0.05055528f, -0.01930357f, 
    -0.02097079f, -0.04938933f, 0.04199649f, 0.02351610f, 0.03339215f, 0.00125773f, 0.04496905f, -0.02226207f, 
    0.11071438f, 0.07008915f, 0.13636410f, 0.38261300f, 0.09862810f, 0.03831768f, -0.00982197f, -0.02497505f, 
    0.18306401f, 0.08681493f, -0.00275766f, -0.01896716f, -0.15607187f, -0.00305268f, 0.01281090f, -0.10757641f, 
    0.24402405f, 0.09394484f, 0.09690992f, 0.09436864f, -0.02207341f, -0.06338138f, -0.26918507f, 0.04303093f, 
    -0.01181039f, 0.22491683f, 0.12381428f, -0.61667699f, -0.26973763f, 0.06313783f, 0.29859385f, 0.16597104f, 
    0.08109163f, 0.03245414f, 0.14155607f, -0.17575800f, -0.47555491f, -0.29079393f, 0.01881636f, 0.16759339f, 
    0.06874029f, 0.17523561f, 0.05307941f, 0.22108644f, 0.06441952f, -0.31582165f, -0.07326894f, -0.14042617f, 
    -0.04168862f, 0.08853258f, 0.00289250f, 0.24062546f, -0.13370547f, 0.10094111f, -0.24397795f, -0.07167596f, 
    -0.18243824f, 0.01900845f, 0.00692586f, 0.10551752f, 0.10699834f, 0.21927403f, -0.01763543f, -0.32058951f, 
    -0.38274112f, -0.14653622f, 0.07369916f, 0.00175461f, 0.07580159f, 0.22804032f, 0.12664402f, -0.03343498f, 
    -0.08183411f, -0.13734031f, 0.05504748f, 0.08386873f, -0.05528970f, 0.05459314f, 0.18179360f, 0.05651833f, 
    0.04537885f, -0.35716665f, -0.19554941f, 0.00797461f, 0.09384686f, -0.04103442f, 0.03499193f, -0.09751403f, 
    -0.15502664f, 0.19105874f, 0.00973970f, 0.08174710f, -0.00818321f, -0.04757644f, -0.15086783f, -0.05515156f, 
    -0.06289853f, 0.00850125f, 0.10554673f, 0.10610672f, 0.05010052f, 0.07460202f, 0.05771611f, -0.00928626f, 
    0.02468695f, -0.05897141f, 0.13323717f, 0.17259589f, -0.19978592f, 0.20142449f, -0.11193774f, 0.01381612f, 
    -0.12536648f, -0.14914076f, 0.17627166f, 0.10830226f, 0.19228549f, -0.07483786f, 0.26069734f, 0.03157593f, 
    0.16801925f, 0.08868363f, 0.03128871f, 0.04566856f, -0.01253824f, -0.04232820f, 0.02383289f, 0.00653746f, 
    0.07618980f, -0.03496525f, 0.01752076f, -0.08876896f, 0.18120095f, -0.08420064f, -0.17175059f, 0.07524266f, 
    0.01586128f, -0.01109264f, 0.13069467f, -0.09951964f, -0.11798751f, 0.02347467f, 0.03585621f, 0.03503357f, 
    -0.19166529f, 0.12649359f, 0.04808988f, 0.06899832f, 0.00738155f, -0.12924290f, 0.08168174f, -0.15219788f, 
    -0.04871282f, 0.06144907f, -0.02136250f, -0.23860347f, 0.05456268f, -0.03126096f, 0.14183724f, -0.05566290f, 
    -0.08325107f, 0.06589641f, -0.17162810f, 0.08516833f, 0.05638701f, -0.05008176f, -0.06720958f, 0.01877656f, 
    -0.11559863f, 0.06026656f, -0.03370444f, -0.00229380f, -0.05930289f, 0.30337039f, -0.27568668f, 0.01717146f, 
    -0.08112863f, -0.05968704f, 0.04941165f, -0.03805392f, -0.21487807f, -0.14746113f, 0.08060396f, -0.03437228f, 
    0.04909346f, -0.01439324f, -0.03386919f, -0.03463209f, -0.02360886f, -0.34805954f, -0.22132125f, -0.13355969f, 
    0.20204051f, 0.07126110f, 0.01630511f, 0.03002488f, -0.14145179f, -0.19834286f, -0.06924796f, -0.25633523f, 
    -0.04642762f, 0.07222944f, -0.06641531f, 0.11291461f, -0.06941120f, -0.18027838f, 0.08732624f, 0.19057840f, 
    0.01536092f, -0.05305421f, -0.04855795f, -0.05797505f, -0.09127037f, -0.04907276f, 0.08798235f, 0.07986192f, 
    0.34746194f, -0.00859461f, -0.02881814f, -0.16013704f, 0.00140169f, 0.03987964f, 0.20269327f, -0.04725053f, 
    -0.02821770f, 0.08874284f, 0.15595046f, -0.08864286f, -0.02008049f, -0.07659079f, -0.17710979f, 0.10434243f, 
    0.00304916f, 0.13213979f, -0.14444317f, -0.09737492f, -0.01903127f, 0.14083008f, -0.04153206f, 0.10866477f, 
    -0.14419004f, -0.10978641f, 0.02509026f, 0.24000801f, 0.21372722f, -0.08889939f, -0.07393067f, 0.07965644f, 
    0.07960881f, 0.08566346f, 0.01001275f, -0.03608681f, -0.58816260f, -0.30212265f, -0.12890476f, 0.17308521f, 
    0.06871036f, 0.07288476f, 0.06930292f, 0.01925710f, -0.04960145f, 0.03533902f, -0.07289197f, -0.01736487f, 
    -0.07205845f, -0.07551368f, 0.18602014f, 0.00615756f, 0.03801427f, 0.15179443f, 0.04276583f, 0.07731913f, 
    -0.30705479f, 0.03534327f, -0.15903287f, -0.12565939f, 0.10488274f, 0.15403549f, -0.02909939f, -0.63882846f, 
    -0.21184902f, -0.10462180f, 0.30141518f, 0.01720147f, 0.00216099f, -0.01976448f, -0.02032634f, -0.04255166f, 
    -0.14568844f, 0.33346277f, -0.08336831f, 0.03174690f, 0.03125166f, 0.06661621f, -0.11174849f, 0.08155747f, 
    -0.11246779f, 0.35010627f, 0.12095125f, -0.02109192f, 0.00918431f, -0.04507571f, -0.02355011f, -0.06248722f, 
    -0.00763593f, -0.02807978f, 0.03275775f, 0.07696367f, 0.14788498f, -0.15395649f, -0.06816600f, -0.09612125f, 
    -0.00400505f, 0.11729074f, -0.18988307f, -0.07726739f, 0.36209741f, -0.04110527f, 0.03651127f, 0.14036231f, 
    0.04792605f, 0.16104840f, 0.04841250f, -0.14334053f, -0.31874701f, 0.08738282f, 0.17871688f, 0.06021758f, 
    -0.11925682f, 0.07650960f, -0.15062428f, 0.12094876f, 0.04451784f, 0.40721884f, -0.04387381f, -0.19131458f, 
    -0.17842543f, -0.01386175f, 0.10186663f, 0.02592576f, 0.15285368f, 0.18135148f, -0.17691128f, -0.08078127f, 
    0.17358585f, 0.10862419f, 0.00779485f, -0.05449238f, -0.02931964f, 0.01700574f, 0.04292349f, 0.22392862f, 
    -0.08394714f, -0.06337065f, -0.05610849f, -0.11304039f, -0.01659599f, 0.16127978f, -0.03373466f, 0.31200847f, 
    -0.08991773f, 0.04895441f, -0.13546100f, 0.07677665f, -0.02232572f, 0.01397170f, -0.13187875f, -0.04561896f, 
    0.07792534f, -0.31123900f, 0.06676790f, 0.10589021f, 0.00648743f, 0.22788079f, 0.01820970f, -0.07490182f, 
    -0.02438833f, 0.12629054f, 0.28460133f, -0.21759945f, 0.01453555f, 0.02702525f, 0.06933977f, -0.08819350f, 
    -0.09238826f, -0.13848926f, -0.03619983f, 0.26867345f, 0.29145297f, -0.09992935f, 0.20214182f, 0.09740923f, 
    0.13573167f, -0.20297690f, -0.04826307f, -0.11648986f, -0.02125669f, 0.09971414f, -0.04338645f, -0.08069227f, 
    -0.08321907f, 0.08617487f, 0.05837577f, 0.02427621f, -0.04746807f, -0.33182964f, 0.10292358f, -0.09723395f, 
    0.03168172f, -0.05008057f, -0.11834032f, -0.16242069f, -0.07519768f, -0.17757188f, 0.11946028f, -0.17939904f, 
    -0.25139764f, -0.06107481f, 0.01654536f, 0.09903344f, -0.05114387f, -0.10807213f, -0.06914898f, 0.18497774f, 
    -0.24079496f, -0.08059453f, -0.00011713f, -0.01050088f, 0.05282122f, -0.11899792f, -0.01951194f, 0.15821470f, 
    -0.43237567f, -0.26904461f, -0.06065152f, -0.06954144f, 0.28671619f, -0.15940674f, 0.05975332f, -0.10327370f, 
    0.19260159f, -0.07778015f, 0.08664476f, 0.03050616f, 0.18129881f, 0.03344413f, 0.01143823f, -0.00135846f, 
    -0.00687598f, -0.10058805f, 0.07291634f, -0.01113772f, 0.17326906f, 0.01878465f, 0.08018440f, 0.00878287f, 
    0.02847826f, -0.08603982f, -0.11642408f, 0.20973115f, 0.28618389f, 0.00640872f, -0.14976923f, -0.12011003f, 
    -0.00048857f, 0.03729459f, -0.13390230f, 0.06482090f, -0.08657768f, -0.14744394f, -0.22514094f, 0.00395159f, 
    0.27304366f, 0.14474060f, -0.14452825f, -0.19172406f, 0.13864334f, 0.05297231f, 0.08641949f, -0.08980885f, 
    -0.04035870f, -0.03880687f, 0.09025005f, 0.05024367f, 0.06002628f, 0.16274184f, -0.14037554f, -0.13479729f, 
    -0.12200125f, 0.04088394f, -0.01887509f, 0.04838812f, -0.26061589f, 0.00487570f, -0.12841105f, 0.56387132f, 
    -0.14015402f, -0.06435116f, -0.00207143f, -0.07590793f, 0.13723052f, -0.34345052f, -0.02372042f, -0.04691816f, 
    0.37848437f, 0.03522984f, -0.21231961f, 0.04222475f, -0.09517661f, 0.16497123f, -0.19617684f, -0.06441310f, 
    -0.01120833f, 0.21213087f, 0.26742285f, 0.00066685f, -0.06176553f, 0.05689539f, 0.01753826f, 0.08155470f, 
    0.07239305f, 0.04104238f, -0.04997392f, -0.08062451f, 0.14175732f, -0.14467750f, -0.02145851f, -0.10034220f, 
    -0.10621286f, -0.11834943f, 0.02174625f, 0.28732294f, -0.14112070f, 0.08143780f, -0.10347036f, 0.04374222f, 
    -0.10059983f, 0.02312231f, 0.05818991f, -0.01315990f, 0.01470568f, 0.07126909f, 0.02892017f, 0.00882582f, 
    0.01569696f, -0.04102822f, 0.06262633f, -0.02516607f, 0.07931542f, 0.17897782f, -0.24631435f, -0.08591258f, 
    -0.25333154f, 0.04565492f, 0.07339253f, 0.15999122f, 0.09278291f, 0.09960557f, 0.27356219f, 0.00736749f, 
    -0.15842488f, -0.03915926f, 0.05026974f, -0.00155411f, 0.07208522f, 0.08045600f, 0.08359431f, -0.18149340f, 
    0.21878585f, -0.00312864f, -0.04323164f, 0.11134294f, 0.01259033f, -0.15826963f, -0.01048119f, 0.16662917f, 
    -0.24432772f, 0.24934718f, -0.14792393f, 0.09045700f, 0.06311988f, -0.13339382f, -0.06812990f, 0.13226013f, 
    -0.20521417f, -0.06024652f, -0.12628132f, 0.17370611f, -0.08479299f, -0.10711058f, -0.04405906f, -0.00908681f, 
    -0.00866683f, 0.00221749f, -0.35040274f, 0.07309732f, 0.41596174f, 0.15304102f, -0.07903025f, 0.05379578f, 
    -0.10477631f, -0.10007630f, -0.05108131f, -0.21875669f, 0.14122412f, -0.22984391f, 0.13457675f, 0.08185402f, 
    0.10424052f, -0.11379548f, -0.00748678f, -0.00269762f, -0.00284931f, 0.03227626f, -0.11929350f, 0.07385717f, 
    0.00141642f, 0.09765089f, -0.11837149f, -0.08947620f, -0.04528003f, -0.01181581f, 0.33188874f, -0.19917716f, 
    0.09128646f, 0.09727520f, 0.13987581f, 0.00761858f, -0.07556623f, 0.12518288f, 0.49245492f, 0.03031153f, 
    -0.28746441f, -0.26670194f, -0.33911723f, 0.10531740f, 0.09464758f, 0.24556336f, 0.15461525f, -0.10046798f, 
    0.22254428f, -0.03628260f, 0.11734227f, -0.08037660f, 0.16901807f, -0.07381313f, -0.00533439f, 0.13165177f, 
    -0.00729596f, -0.06782532f, 0.11341626f, 0.07790307f, -0.04956790f, -0.14129139f, -0.14636756f, 0.05029882f, 
    0.03490261f, 0.20477866f, -0.00052068f, -0.49980968f, 0.03697124f, 0.02445666f, -0.15083493f, -0.07541537f, 
    0.03021955f, -0.02656939f, -0.50825834f, -0.23162828f, 0.17653351f, 0.13385391f, 0.02822495f, -0.11553796f, 
    -0.10778315f, -0.11709537f, 0.04797505f, -0.17963229f, -0.01630585f, 0.02833947f, -0.09628108f, 0.00044655f, 
    -0.02719042f, 0.08588991f, -0.14347635f, 0.05740075f, -0.09200889f, -0.21100321f, 0.11349921f, 0.12908167f, 
    0.06988977f, 0.04582199f, -0.00288600f, 0.25517678f, 0.03245179f, -0.11030577f, 0.08470719f, -0.05954140f, 
    0.05197116f, 0.01030770f, 0.12241150f, 0.11810318f, 0.18560116f, 0.02005384f, 0.45915112f, 0.09612908f, 
    0.36840665f, -0.02249807f, -0.05520196f, -0.04836312f, -0.11562847f, -0.02813008f, 0.17427619f, -0.19101392f, 
    0.23687167f, -0.37035397f, 0.00163057f, -0.05215590f, 0.05995949f, -0.14188449f, 0.03117312f, -0.29904711f, 
    -0.08856560f, -0.03680806f, 0.22460252f, 0.13348076f, -0.04713155f, -0.03366131f, 0.03934059f, 0.02551442f, 
    0.03881769f, -0.24576108f, -0.21290033f, 0.23220451f, 0.11080375f, 0.07572621f, 0.06708518f, 0.19751298f, 
    0.02584587f, 0.20983383f, -0.56552982f, -0.31999013f, 0.26443979f, 0.14918464f, -0.04675809f, 0.20710780f, 
    -0.11923423f, 0.13937132f, 0.09244794f, -0.07535490f, -0.35752240f, 0.36525998f, 0.03570874f, -0.08090837f, 
    0.18727984f, 0.09854595f, 0.11162388f, 0.07763009f, -0.12155305f, -0.15030921f, 0.22348669f, 0.33266941f, 
    -0.12650938f, -0.06591443f, -0.11959558f, -0.12135971f, -0.04258941f, -0.05898618f, 0.11165875f, 0.07266835f, 
    -0.04675893f, -0.13413180f, 0.10614396f, -0.09492915f, 0.05886654f, -0.10636856f, -0.40593418f, 0.20694043f, 
    -0.23061864f, 0.17294721f, 0.19276047f, 0.07645383f, -0.07671342f, -0.03058840f, -0.13438137f, -0.21412425f, 
    -0.26604891f, 0.20735872f, 0.13807130f, -0.09189279f, -0.02398274f, -0.06952754f, -0.07914550f, 0.02534564f, 
    0.03339928f, 0.01175633f, -0.01045620f, 0.06994325f, -0.18044159f, 0.08964068f, -0.06100739f, -0.07132432f, 
    -0.03356714f, -0.03158591f, -0.27586338f, 0.00017532f, -0.06078054f, 0.02928293f, -0.05728576f, -0.01183139f, 
    0.06266662f, 0.27338198f, -0.01524651f, -0.13040358f, 0.04230561f, 0.17291574f, 0.11887651f, 0.01809911f, 
    0.12449852f, 0.02620852f, 0.03865655f, -0.15161708f, -0.18186058f, 0.37704426f, 0.05252465f, -0.15226287f, 
    -0.02967316f, -0.16221920f, 0.14256759f, 0.15356289f, -0.16617171f, 0.14901899f, -0.06235521f, 0.28779626f, 
    -0.15073498f, 0.05761699f, 0.21703541f, 0.15968052f, 0.28686565f, -0.24624714f, -0.07900408f, -0.20767924f, 
    0.02574715f, -0.00966005f, 0.03332067f, -0.01725538f, 0.11362124f, -0.24931104f, -0.25860801f, -0.09563418f, 
    -0.39333829f, 0.08317958f, -0.02370346f, 0.10766993f, -0.02489869f, 0.11839203f, 0.14224927f, 0.04586150f, 
    0.07364848f, 0.18909968f, 0.11796982f, 0.23639572f, 0.00786715f, 0.09631598f, 0.08691949f, -0.06702039f, 
    0.10805805f, 0.11099084f, 0.03815199f, -0.04323634f, 0.02641340f, 0.01582299f, -0.06490606f, 0.11390110f, 
    -0.00274142f, -0.28756574f, 0.13881426f, -0.14314693f, 0.19578138f, -0.05331387f, -0.07201291f, -0.02225743f, 
    -0.09210050f, -0.08488614f, -0.09255359f, -0.01975957f, -0.03977146f, -0.03084032f, 0.09085651f, -0.12532154f, 
    0.12398596f, -0.06352507f, 0.00270642f, 0.03859201f, -0.06096805f, -0.15483323f, 0.11269589f, -0.02899109f, 
    -0.08946817f, 0.02469810f, -0.16539419f, -0.06994335f, 0.27633622f, -0.02372154f, -0.22569032f, 0.19978088f, 
    0.07848985f, 0.12829997f, -0.00923587f, 0.05261375f, 0.01380799f, -0.22496472f, -0.07768129f, 0.11761794f, 
    -0.20685951f, 0.21383950f, 0.01518859f, -0.12450845f, 0.01141447f, -0.13644744f, 0.14087225f, 0.04770319f, 
    -0.04118506f, -0.14253257f, -0.25560978f, 0.12394752f, 0.34058622f, 0.15136349f, 0.22443119f, -0.23042740f, 
    0.10522491f, -0.05712513f, -0.05751985f, 0.12675853f, 0.20580770f, 0.18614924f, 0.05962448f, -0.02159750f, 
    0.12443182f, -0.23181732f, -0.14460301f, -0.15380806f, -0.11695319f, -0.08733105f, 0.04140776f, 0.07299758f, 
    0.02630788f, 0.05170363f, -0.09415098f, -0.08272881f, -0.00267078f, -0.00191051f, 0.10790280f, -0.20028619f, 
    0.21835302f, -0.04562932f, -0.43059620f, 0.12406117f, 0.00570480f, 0.07986683f, 0.01242685f, 0.08244267f, 
    -0.05249717f, -0.03741643f, -0.09200250f, -0.33787546f, -0.12539014f, -0.00913019f, 0.07408372f, -0.04471345f, 
    -0.18219751f, -0.05688908f, 0.02221683f, 0.01567440f, 0.08391973f, 0.28554443f, -0.21874242f, 0.03821263f, 
    0.01897613f, 0.00279413f, -0.05178406f, 0.05002490f, -0.01631393f, 0.19042648f, 0.00019030f, -0.13128103f, 
    -0.21306922f, 0.02446346f, -0.04204907f, 0.12661096f, 0.18119958f, 0.13735297f, 0.16588756f, -0.19890361f, 
    0.02844854f, -0.19736554f, 0.12069199f, -0.13948019f, -0.22175643f, -0.08786720f, -0.19006553f, -0.14433853f, 
    -0.13297816f, -0.44724765f, -0.22819120f, -0.08873304f, -0.04642577f, -0.02485365f, 0.19758031f, 0.13801733f, 
    0.24888000f, -0.05550691f, 0.11657654f, 0.07273094f, 0.03477902f, 0.06723069f, -0.07960861f, -0.05557011f, 
    -0.04081326f, 0.56664032f, 0.15593989f, -0.00626366f, 0.03419635f, -0.05718251f, 0.05017119f, 0.19385359f, 
    0.13816579f, -0.08145314f, -0.07427293f, 0.11301542f, -0.39084983f, -0.15221170f, 0.11898082f, 0.10334520f, 
    -0.06179395f, -0.00011587f, 0.12177721f, 0.06129416f, 0.17100060f, -0.47440434f, 0.13829431f, -0.01760347f, 
    -0.12949021f, -0.00117868f, -0.00823569f, 0.13634782f, -0.46648350f, -0.19526057f, 0.09869963f, -0.17854673f, 
    -0.03814999f, 0.08175302f, 0.09631854f, 0.07809088f, 0.03517744f, 0.05950668f, 0.22265404f, 0.04641263f, 
    -0.09677370f, -0.07957278f, -0.00367142f, 0.15022929f, -0.06917212f, 0.17495115f, 0.25403002f, -0.11787911f, 
    0.15572366f, 0.03730498f, -0.14777552f, -0.14284927f, 0.09769177f, 0.11443391f, 0.11672091f, 0.03873955f, 
    -0.03110797f, 0.06809693f, 0.03030005f, 0.17328027f, -0.07863183f, 0.09731036f, -0.07433605f, 0.02727601f, 
    0.28602612f, 0.28584170f, 0.34968773f, -0.06714865f, 0.07618596f, 0.15354803f, -0.08737135f, -0.14882343f, 
    0.10790659f, -0.53726149f, -0.04029011f, -0.07207733f, 0.12283844f, 0.03806976f, -0.07285536f, 0.03550088f, 
    -0.09081437f, 0.01498278f, -0.16003439f, 0.01221931f, 0.05236755f, -0.05011079f, -0.04648689f, 0.12491263f, 
    -0.10847834f, 0.07449955f, 0.05018306f, 0.26438019f, 0.27973038f, -0.10598596f, 0.07058845f, 0.10494230f, 
    0.11510335f, -0.01973897f, -0.08791301f, -0.07380636f, -0.01566374f, 0.11333673f, 0.08992872f, -0.03896667f, 
    0.04940923f, -0.13097444f, 0.11483873f, 0.02605645f, 0.02224230f, -0.01262750f, -0.22579104f, 0.11767218f, 
    -0.02405935f, -0.00466564f, -0.03955463f, -0.07657124f, 0.03146066f, 0.07831854f, -0.35412273f, 0.20454596f, 
    0.18933448f, -0.11292388f, -0.08772439f, -0.22813682f, -0.12906766f, 0.18778180f, -0.12264634f, 0.08817893f, 
    0.25964743f, 0.04389789f, -0.00043136f, -0.14211375f, -0.05123345f, -0.06421756f, 0.12641998f, 0.01818176f, 
    -0.47336438f, -0.43089941f, 0.27352738f, -0.10515358f, 0.01360918f, 0.14450690f, -0.01655415f, -0.13241953f, 
    -0.01956248f, 0.11370131f, 0.17020249f, 0.01039512f, 0.00984080f, -0.18524675f, -0.05498778f, 0.20310344f, 
    0.01113016f, 0.11767404f, 0.24750149f, 0.30339167f, 0.10889515f, -0.10590193f, 0.02837976f, 0.20833787f, 
    0.19543739f, 0.23354681f, 0.04571963f, -0.38738918f, -0.23648541f, 0.47454849f, -0.01965258f, 0.07012409f, 
    -0.08654965f, 0.02406924f, -0.02032086f, -0.09166710f, 0.10981952f, -0.06811169f, -0.04162567f, 0.03226177f, 
    0.09507401f, -0.06593819f, -0.12085274f, 0.13409939f, 0.06739607f, -0.08496380f, -0.06300550f, 0.07407282f, 
    0.07450318f, -0.11435385f, 0.12988010f, 0.00059616f, 0.03938646f, -0.12101135f, -0.05763615f, 0.09212362f, 
    -0.29375616f, 0.01685605f, -0.21764377f, -0.08671059f, 0.13626985f, -0.01736220f, 0.06176650f, 0.04343639f, 
    -0.02938124f, 0.21005277f, -0.10060012f, 0.03174308f, 0.11372616f, -0.13941020f, -0.02647931f, -0.15869102f, 
    0.24254824f, 0.01727168f, -0.00893834f, 0.04354354f, 0.02832993f, 0.10696381f, -0.20709126f, -0.00331592f, 
    -0.05900086f, -0.09786861f, -0.08361981f, -0.06317434f, 0.09826490f, 0.02976329f, -0.03835001f, -0.14331196f, 
    -0.15341182f, 0.14716235f, 0.07241850f, 0.16656059f, 0.11114285f, -0.03977278f, -0.18431164f, -0.02794462f, 
    -0.09611051f, 0.11554044f, 0.15562454f, -0.03551081f, -0.14176473f, 0.09058604f, -0.08367182f, -0.05936413f, 
    -0.04264303f, -0.06415534f, -0.05364867f, 0.05326553f, 0.23576330f, 0.13685057f, 0.04629907f, -0.20974198f, 
    0.10210378f, -0.20589754f, -0.01363458f, 0.11481714f, -0.03020647f, 0.08004602f, -0.07641163f, 0.18987918f, 
    0.12005759f, -0.13223188f, -0.04605803f, -0.14383020f, 0.19255403f, 0.05399759f, 0.25431013f, -0.12066497f, 
    -0.10830210f, 0.08320695f, 0.04390176f, 0.06727008f, -0.05836459f, -0.00474591f, -0.09705197f, -0.20104513f, 
    0.05133095f, 0.00141504f, -0.04366868f, -0.03488182f, -0.13537174f, -0.22144985f, 0.05397813f, -0.03724331f, 
    0.10495360f, 0.08142082f, -0.29121414f, 0.13168237f, -0.04306260f, 0.02036822f, 0.10975790f, 0.03066194f, 
    -0.10021804f, 0.07408512f, 0.05535319f, -0.01859216f, 0.12142216f, 0.08926140f, 0.19742617f, -0.01078629f, 
    -0.02756427f, -0.19875225f, -0.01796834f, 0.06847177f, 0.29472581f, 0.09771474f, -0.06516008f, -0.13289131f, 
    0.14945194f, -0.00481737f, 0.02866730f, -0.06574713f, 0.09316773f, 0.22424649f, 0.11299592f, 0.00506367f, 
    -0.00266109f, 0.19899471f, -0.04711176f, -0.06397556f, -0.02635663f, 0.10861915f, 0.18175998f, 0.15740664f, 
    -0.06520459f, 0.10358577f, -0.12568083f, -0.08005635f, -0.05584422f, -0.40143746f, -0.05488377f, 0.17296526f, 
    -0.03885445f, 0.03940490f, 0.04276777f, -0.04782909f, -0.08306435f, -0.02677400f, 0.30307907f, 0.07824246f, 
    0.10470615f, -0.02326871f, 0.08966943f, -0.06364355f, 0.05184002f, 0.15453739f, 0.06361076f, 0.03949431f, 
    0.07456035f, -0.08203597f, -0.06950662f, -0.06675829f, -0.06021115f, -0.09044064f, 0.19118197f, 0.18885803f, 
    0.13713785f, 0.09996738f, 0.22836851f, 0.04962183f, -0.00824637f, 0.05298731f, -0.03821535f, 0.05950410f, 
    0.01510278f, 0.00866488f, -0.01496332f, -0.06604659f, -0.07133210f, 0.05031697f, -0.16499342f, 0.10610764f, 
    -0.11160108f, -0.06850788f, 0.09644058f, 0.16459225f, 0.00846174f, -0.00483014f, 0.05258375f, -0.10524857f, 
    0.00241649f, -0.09578677f, 0.11092188f, 0.12455545f, 0.15354960f, 0.20253922f, 0.03932698f, -0.10752629f, 
    0.19112849f, 0.11508553f, 0.00057927f, -0.06712853f, -0.12075100f, 0.09613205f, 0.24663909f, 0.10526707f, 
    0.01551872f, 0.06492754f, 0.04132391f, 0.08463430f, -0.04096099f, -0.15959843f, 0.27855134f, -0.02832220f, 
    0.03693703f, 0.01811313f, -0.16116998f, 0.01422531f, 0.01069923f, 0.01374995f, 0.05264223f, -0.14387493f, 
    0.11678243f, -0.01018367f, -0.07220304f, -0.04636627f, 0.06054865f, 0.08219645f, -0.06161396f, -0.12148590f, 
    -0.14176403f, 0.15862098f, -0.09723957f, -0.14091219f, 0.05010910f, -0.14274389f, 0.14912109f, 0.09162012f, 
    0.02417782f, -0.19289386f, -0.04900646f, 0.05031170f, -0.01827272f, -0.15945202f, 0.04511987f, -0.04222347f, 
    0.08236315f, 0.20627397f, -0.04954280f, 0.01376197f, 0.00044935f, -0.01903164f, 0.05305669f, 0.02984349f, 
    0.06680690f, 0.01088672f, -0.08810107f, -0.20108916f, 0.00380667f, 0.10116401f, 0.08337618f, 0.11697885f, 
    -0.03640133f, 0.11016322f, 0.12448811f, -0.23545353f, -0.03752395f, 0.10088445f, -0.09069181f, -0.13544871f, 
    -0.00564832f, 0.04202568f, -0.02375927f, 0.27590400f, -0.11644130f, 0.14586571f, -0.11354218f, -0.06596038f, 
    0.18874313f, 0.17285012f, 0.00625623f, -0.05385838f, -0.12653917f, -0.14849661f, 0.12940371f, -0.01914497f, 
    0.05928199f, -0.21564431f, 0.19383803f, -0.04250210f, -0.00763272f, -0.01873411f, -0.27067956f, -0.05228625f, 
    -0.17934901f, 0.19702040f, -0.04229119f, 0.24700201f, 0.02825463f, 0.00284273f, -0.26647627f, -0.31628507f, 
    0.26531193f, -0.06014714f, 0.10860050f, -0.11672284f, 0.23268652f, 0.03577506f, -0.07865161f, 0.02589469f, 
    0.15747853f, -0.17752267f, 0.09232011f, 0.03628070f, 0.13161427f, -0.06433440f, 0.03469600f, -0.24447504f, 
    0.13414137f, -0.37058184f, 0.02106873f, -0.00187371f, 0.12400142f, -0.15844239f, 0.06339759f, -0.00313196f, 
    -0.05538240f, 0.07869500f, 0.05853705f, -0.18059227f, -0.13129249f, 0.10269643f, 0.13693513f, 0.05723726f, 
    0.07969043f, -0.05696957f, 0.08880419f, -0.03442963f, -0.05361522f, 0.01846120f, -0.05984724f, 0.08728991f, 
    0.05565010f, 0.16771398f, -0.03495757f, -0.04629045f, 0.07237129f, -0.21617031f, -0.12389713f, 0.01418506f, 
    0.04270960f, -0.06926537f, 0.08192754f, -0.11804934f, -0.11487851f, 0.21294373f, -0.02693032f, 0.09340923f, 
    0.04863670f, 0.06428088f, 0.09689007f, 0.16361393f, -0.08900605f, 0.15633968f, -0.05823811f, -0.09821735f, 
    0.33849332f, -0.16495872f, 0.01871644f, -0.20254444f, 0.00848909f, 0.09712883f, -0.00104788f, 0.30678010f, 
    -0.00039137f, -0.09058753f, -0.02062909f, 0.06274541f, 0.22135772f, 0.08704511f, 0.07657424f, -0.04670676f, 
    0.04369467f, -0.19832994f, 0.07162954f, 0.05317931f, 0.00781516f, -0.16617642f, 0.02332410f, 0.04110582f, 
    0.15579210f, -0.14701080f, 0.07024430f, -0.08575452f, 0.02210298f, -0.03937444f, 0.04922036f, 0.04847040f, 
    0.04368983f, 0.06552468f, 0.15755786f, -0.17996518f, -0.09746376f, 0.05525391f, 0.20760100f, -0.00850910f, 
    -0.03835591f, 0.00607147f, 0.15689489f, 0.11885368f, -0.15081106f, 0.01369759f, 0.01886407f, -0.07363294f, 
    -0.10705620f, 0.05849938f, 0.07574536f, -0.17633608f, 0.32821980f, -0.08376580f, 0.15544152f, 0.10971797f, 
    0.04436503f, 0.01556465f, 0.04022468f, -0.16107361f, 0.10944755f, -0.38154250f, 0.03238107f, -0.13488734f, 
    0.01425981f, 0.02874868f, 0.13706796f, 0.18026267f, -0.14917314f, 0.02941071f, 0.05562877f, -0.02072599f, 
    0.23194784f, -0.22121409f, -0.02671002f, 0.11237670f, 0.05340109f, 0.02420441f, 0.18199770f, 0.16106266f, 
    -0.21156733f, 0.06116809f, -0.13647063f, 0.12637505f, 0.08966503f, 0.09735498f, 0.13728786f, 0.00556144f, 
    0.32643670f, -0.16087224f, -0.21490446f, -0.15661983f, 0.04436343f, 0.10985000f, 0.13328777f, -0.02713938f, 
    -0.24176393f, 0.07372797f, -0.22750810f, 0.18383229f, -0.04945125f, -0.06537977f, -0.14224030f, 0.10175811f, 
    0.08288813f, -0.05251565f, 0.03860186f, -0.08402269f, 0.17366298f, -0.07216746f, 0.04704286f, 0.10626115f, 
    0.26246491f, -0.10090008f, 0.19463326f, -0.09000480f, 0.06003485f, 0.08214033f, 0.02943185f, -0.03491251f, 
    -0.00802385f, -0.00756542f, 0.24944246f, 0.13793974f, -0.06826887f, 0.19992988f, 0.05859418f, 0.08494733f, 
    -0.15699536f, 0.27522987f, 0.04249541f, -0.06306372f, -0.03089864f, -0.01209347f, 0.06744132f, 0.05583179f, 
    0.03318778f, -0.06239128f, -0.08732859f, -0.06845488f, 0.05550665f, -0.01675845f, 0.06735125f, -0.07096673f, 
    0.20800148f, 0.05093282f, -0.13413833f, -0.00040109f, -0.05299782f, 0.09595933f, -0.21422863f, -0.10999456f, 
    -0.02382106f, -0.14841269f, 0.08819275f, 0.04793778f, 0.05962995f, 0.04854418f, -0.14656796f, -0.04871793f, 
    0.09744920f, -0.02494779f, 0.04832485f, -0.07524692f, -0.08449888f, 0.09061287f, -0.06481270f, -0.03396652f, 
    0.01392331f, 0.05254839f, 0.07206758f, -0.28128639f, 0.02066826f, -0.01905257f, 0.08114535f, 0.09130283f, 
    0.00780462f, -0.09549242f, -0.09158429f, 0.13950503f, -0.19708407f, -0.02111677f, 0.04923653f, 0.02477822f, 
    0.06721804f, -0.02180097f, -0.03173776f, 0.14369702f, -0.01622898f, -0.12479857f, 0.12373530f, 0.00762274f, 
    0.09240030f, -0.14254279f, 0.10041358f, -0.04376016f, -0.06187550f, -0.05511928f, -0.00553237f, 0.13257973f, 
    -0.01559871f, -0.07702127f, 0.03422806f, 0.06338365f, 0.03749719f, -0.28641236f, 0.07600544f, -0.15165322f, 
    0.07530921f, -0.01603901f, -0.21197173f, -0.11850655f, 0.10080419f, 0.00126655f, 0.24412104f, 0.04922645f, 
    0.05569160f, -0.16756015f, 0.05697717f, -0.01388067f, 0.17983170f, 0.11196066f, 0.18689257f, 0.03197457f, 
    0.06359013f, -0.05354110f, -0.19343610f, -0.04727881f, -0.05397047f, 0.10950895f, 0.12684020f, 0.01380049f, 
    0.00935954f, -0.10492316f, 0.20439325f, -0.15261689f, 0.17697297f, -0.04099543f, -0.06687847f, -0.07366870f, 
    -0.13786101f, -0.28440359f, -0.05704973f, 0.22373420f, -0.09124751f, 0.19534215f, 0.01994363f, 0.09951159f, 
    -0.05774911f, 0.10729112f, -0.02655699f, -0.00070654f, 0.12531427f, -0.01572799f, 0.00251504f, 0.05205772f, 
    0.04382581f, -0.03217378f, -0.12340847f, 0.01708378f, -0.13756874f, -0.20275570f, 0.02354859f, 0.03554984f, 
    0.08086378f, 0.13118251f, 0.01389862f, 0.08026991f, -0.39034298f, 0.44129294f, 0.11409903f, 0.18519002f, 
    -0.04527714f, -0.05039797f, -0.09086994f, 0.10946063f, 0.03296068f, 0.04680601f, -0.05875111f, -0.05836909f, 
    -0.01271751f, 0.10393088f, 0.00362424f, 0.12869434f, 0.05835333f, 0.00902279f, -0.11348910f, -0.64576656f, 
    -0.10053079f, -0.00074547f, -0.08900331f, -0.00558645f, 0.14245023f, -0.13926941f, -0.14185396f, -0.30959129f, 
    -0.16991967f, -0.41591513f, 0.11403963f, -0.13019463f, 0.15139350f, 0.02711043f, 0.09268714f, 0.03340171f, 
    0.24222299f, 0.14606291f, 0.11627161f, 0.12877230f, 0.02150511f, -0.10983133f, 0.03055412f, 0.04895405f, 
    -0.03499306f, 0.08333169f, 0.16587758f, -0.07175855f, 0.02751169f, 0.05991229f, -0.35184878f, 0.13964611f, 
    -0.03147617f, -0.24359664f, -0.07707424f, 0.21119535f, -0.03191590f, 0.08542454f, -0.09214766f, 0.10465258f, 
    0.16085644f, -0.02546409f, 0.12081582f, 0.17503889f, 0.11080408f, -0.36464006f, 0.16749164f, -0.15960474f, 
    -0.10095885f, 0.10482240f, -0.03993453f, 0.24504764f, -0.48176792f, -0.46378884f, 0.03053178f, -0.00916384f, 
    -0.11553684f, 0.11821325f, 0.01793904f, 0.04764313f, -0.18891461f, 0.01495560f, 0.14497192f, -0.00508812f, 
    0.05998002f, -0.23163666f, 0.12573318f, -0.10464311f, 0.08526378f, -0.02949396f, 0.13316540f, -0.19110590f, 
    -0.23057428f, 0.05551090f, 0.07707939f, 0.06325478f, 0.07423121f, -0.10075369f, -0.05805852f, -0.24618508f, 
    -0.28936759f, 0.14141224f, 0.05281592f, 0.02183153f, 0.02847337f, 0.20501789f, 0.11783295f, -0.11262736f, 
    -0.12971337f, 0.38723314f, -0.00098575f, 0.04073671f, -0.04507139f, -0.16552526f, 0.06982265f, -0.03358458f, 
    0.03098336f, -0.30829212f, -0.09541907f, -0.10518404f, 0.05854500f, 0.02927957f, 0.04153498f, -0.07067237f, 
    -0.03042407f, 0.18949573f, -0.22244813f, -0.10048114f, -0.12717173f, 0.03145842f, 0.06918851f, 0.20861609f, 
    0.00149431f, -0.06643502f, -0.03660287f, 0.28997353f, 0.22165619f, -0.10920006f, 0.01157078f, 0.12976101f, 
    -0.22360098f, 0.06457893f, -0.05270248f, -0.18792014f, -0.04166207f, 0.19249819f, 0.00106847f, -0.07206229f, 
    -0.05289531f, -0.13523008f, 0.22840726f, 0.11293456f, 0.21762338f, -0.40138891f, -0.30267945f, 0.30626324f, 
    -0.12732719f, -0.01533589f, 0.05814572f, -0.03645456f, -0.05387687f, 0.04534971f, -0.20521659f, -0.03060619f, 
    0.13438982f, -0.08326906f, 0.01448794f, 0.04884674f, 0.01813587f, 0.06379554f, 0.22659223f, 0.12174965f, 
    0.19063070f, 0.04514311f, 0.03801474f, -0.06908639f, -0.04115014f, -0.14018571f, -0.07096866f, -0.06495530f, 
    0.04164106f, -0.11001721f, -0.12884322f, 0.14293033f, 0.03855963f, 0.06608482f, 0.01302544f, 0.01419363f, 
    0.00030150f, 0.15489161f, 0.10433552f, 0.10236515f, 0.04009495f, -0.01576287f, 0.02219225f, -0.03546510f, 
    -0.05863504f, -0.01324901f, -0.21436618f, 0.24026306f, 0.05766688f, 0.01731201f, 0.08086906f, -0.04144618f, 
    -0.13833141f, -0.14430259f, 0.06449097f, -0.03574279f, -0.31144401f, -0.26108396f, 0.05184771f, -0.11972601f, 
    0.04609467f, 0.23722060f, 0.05296410f, 0.13020279f, 0.00109965f, 0.08010890f, 0.09219201f, 0.08342910f, 
    0.10166051f, 0.10827428f, 0.08000356f, 0.03136511f, 0.20874843f, 0.10847842f, -0.01638004f, 0.21938214f, 
    0.01843633f, -0.07387093f, -0.04087697f, -0.01620341f, -0.01172900f, -0.02068208f, 0.03585643f, 0.07452656f, 
    -0.09611594f, -0.06733906f, -0.01129211f, -0.07094540f, -0.00308358f, 0.15255691f, 0.12128180f, 0.03275501f, 
    0.01683587f, -0.02716227f, 0.14521849f, 0.05155497f, -0.17469038f, -0.10170271f, -0.01539130f, 0.05403081f, 
    0.13854888f, 0.28842893f, -0.18714304f, -0.01444385f, -0.05193287f, 0.18483894f, 0.06730393f, 0.08187709f, 
    -0.16371213f, 0.01026325f, 0.05103425f, -0.08467996f, 0.05393003f, -0.04586060f, 0.18485442f, 0.02026490f, 
    -0.01607098f, 0.06649511f, -0.28243098f, 0.13267481f, 0.18970254f, 0.10788050f, 0.10359889f, 0.08909885f, 
    -0.00758941f, -0.11799027f, -0.06313633f, 0.07105783f, 0.01978459f, -0.08520043f, 0.04627614f, -0.16728418f, 
    0.02307834f, 0.16986158f, 0.03212056f, 0.20097651f, 0.02824910f, -0.00812499f, 0.24221437f, 0.00535791f, 
    0.08691395f, 0.05704595f, -0.10553786f, 0.13865264f, 0.12387168f, -0.13034534f, -0.18528262f, -0.04434074f, 
    0.03727720f, 0.01392639f, 0.01481922f, 0.13555284f, -0.01320845f, 0.16487463f, -0.05694772f, 0.19061486f, 
    -0.13772634f, 0.09153225f, -0.11390395f, -0.05109783f, 0.18407071f, -0.03028481f, -0.03174603f, -0.21296655f, 
    -0.30977345f, 0.33774504f, -0.05125569f, 0.01270651f, -0.06599396f, 0.15316087f, 0.06615894f, 0.08949909f, 
    -0.28094840f, 0.06939475f, 0.08217596f, 0.15379024f, -0.02802580f, 0.09781639f, -0.17931893f, 0.08627748f, 
    -0.11832321f, -0.19811368f, -0.07061960f, -0.08049711f, 0.10532401f, -0.02400542f, -0.19648378f, 0.13834265f, 
    0.00470368f, 0.01132875f, -0.55994678f, -0.11592948f, 0.08652469f, -0.14631045f, 0.04077491f, -0.13912681f, 
    0.00719830f, -0.06685770f, -0.15852222f, -0.27332556f, 0.10370284f, 0.02613127f, 0.02645504f, 0.04621080f, 
    -0.01745381f, -0.14000285f, -0.20498359f, 0.01001104f, -0.49363855f, 0.18668412f, -0.15729669f, 0.26635832f, 
    0.16357717f, 0.11332778f, -0.10848043f, -0.07239190f, -0.04901950f, 0.06476847f, 0.18419100f, 0.10011727f, 
    0.05564882f, 0.07192389f, -0.12448874f, 0.10656399f, -0.04012519f, -0.00848868f, -0.41311377f, 0.15068091f, 
    0.03490749f, -0.01454180f, -0.12663211f, -0.06575329f, 0.16985153f, 0.07073846f, -0.05862913f, 0.13898997f, 
    0.32863143f, 0.04635767f, -0.00486930f, 0.00881656f, -0.15655574f, 0.02109626f, -0.04629749f, 0.06935586f, 
    0.01513453f, -0.44878942f, 0.36867324f, -0.26657906f, -0.03744304f, -0.10805637f, 0.04671071f, 0.00841994f, 
    -0.10303906f, -0.25500339f, -0.24124986f, -0.06517507f, 0.07894722f, 0.06734382f, 0.16304858f, 0.04333693f, 
    -0.04911757f, 0.07283898f, -0.30099118f, -0.13007942f, 0.29026911f, 0.16083610f, 0.10052137f, -0.01888958f, 
    -0.00800768f, 0.18117155f, -0.10805210f, -0.10306612f, -0.33022150f, -0.06247391f, 0.17837939f, -0.04771588f, 
    -0.24603291f, -0.07718681f, -0.13004722f, -0.06078337f, 0.04082625f, -0.06181725f, -0.08220676f, 0.16504589f, 
    -0.06906359f, -0.11831514f, 0.04467337f, 0.12957583f, 0.03212778f, -0.10336230f, -0.10861861f, 0.22370727f, 
    0.01106369f, 0.07078787f, -0.05287834f, 0.03761725f, -0.03384140f, -0.03523374f, -0.26623344f, 0.01091207f, 
    -0.38122547f, 0.12441485f, -0.00017842f, 0.01830825f, 0.08609942f, 0.03770129f, -0.06639276f, -0.06431175f, 
    0.13742706f, 0.11045654f, 0.00561972f, 0.04622567f, 0.07424691f, 0.15067968f, 0.17462753f, 0.11930996f, 
    0.04199471f, 0.00009813f, -0.01917717f, 0.04181150f, 0.03005679f, -0.05918591f, -0.03616627f, -0.00174490f, 
    -0.01930502f, 0.00840256f, -0.02481566f, -0.02094009f, 0.03995202f, 0.01146456f, -0.01211582f, 0.01117375f, 
    0.02625929f, -0.00154322f, 0.00333751f, -0.01322222f, 0.05231705f, 0.04566303f, -0.00900414f, 0.01788662f, 
    -0.04617060f, -0.04466464f, -0.05040241f, -0.03558794f, -0.06016354f, -0.04392545f, 0.05269557f, 0.03850912f, 
    -0.02091070f, 0.03879571f, -0.05834981f, -0.03611452f, -0.05455899f, 0.00085964f, 0.01211946f, 0.00584125f, 
    -0.00592146f, -0.01407820f, 0.01790286f, 0.02440054f, -0.05609061f, 0.03043170f, -0.00507472f, -0.01386492f, 
    0.04194798f, 0.02621646f, -0.05539287f, -0.02019155f, -0.00546274f, -0.02900597f, 0.03269830f, -0.05873235f, 
    0.04731919f, -0.00441062f, -0.04653339f, 0.02787815f, -0.04735425f, 0.04016202f, -0.01286647f, -0.03593192f, 
    -0.01801926f, -0.01045361f, -0.04424493f, 0.04390584f, 0.01609735f, 0.04132471f, -0.01412336f, -0.04668920f, 
    -0.03233443f, 0.03902055f, -0.03745547f, -0.02993809f, -0.05894677f, -0.00133607f, -0.04317091f, -0.01489963f, 
    -0.05871972f, -0.03777985f, 0.01708184f, 0.00436060f, -0.01948299f, -0.02968160f, -0.03902237f, -0.03385851f, 
    0.05193953f, 0.04779549f, -0.05593180f, 0.04198544f, -0.03895659f, -0.00836462f, 0.01259271f, -0.06270197f, 
    0.03595933f, 0.01114767f, -0.00608536f, 0.00889411f, 0.02933158f, -0.04087866f, 0.03653076f, -0.01414375f, 
    -0.03604446f, -0.06564318f, 0.03660312f, -0.04221291f, 0.00560928f, 0.00831001f, -0.00871777f, -0.03234475f, 
    -0.03459999f, 0.01135527f, 0.01291252f, -0.01979993f, -0.06523197f, -0.02425107f, 0.02876842f, -0.03845587f, 
    -0.01847984f, 0.03810016f, 0.00040230f, -0.02835410f, 0.03580935f, 0.04811948f, 0.00152091f, -0.00833620f, 
    -0.00691508f, 0.01310002f, -0.04483972f, -0.05646691f, -0.03272404f, 0.01494545f, -0.04591924f, 0.00016032f, 
    -0.03215709f, -0.00134150f, 0.00214969f, 0.02251942f, 0.02921617f, -0.01963858f, -0.02455743f, -0.04784440f, 
    -0.04518639f, -0.00938180f, -0.01465689f, 0.02145075f, 0.02986719f, -0.02483685f, 0.03019810f, 0.04613663f, 
    0.01360002f, 0.04981397f, 0.03894383f, -0.02235436f, -0.02102399f, -0.01148621f, 0.02352490f, -0.00602383f, 
    0.03888990f, 0.01844104f, -0.01367814f, -0.05091202f, 0.02954243f, 0.04643366f, -0.03729462f, -0.03437198f, 
    0.04043896f, -0.02785611f, 0.01089301f, -0.02017959f, -0.04853410f, 0.03161709f, -0.04138676f, -0.01917540f, 
    -0.00660913f, -0.03513528f, -0.02776976f, 0.00462581f, -0.03113876f, 0.01537184f, -0.00955679f, -0.00832992f, 
    -0.02182126f, 0.04494847f, 0.03266411f, 0.04307952f, 0.02155264f, 0.01658172f, -0.07187869f, -0.06484682f, 
    -0.05724844f, -0.05912141f, -0.02599722f, -0.03312246f, -0.06641801f, 0.02298659f, 0.04008199f, 0.03008598f, 
    -0.03838221f, -0.03506649f, -0.00429470f, -0.01127857f, -0.05352403f, -0.03578664f, 0.03989276f, -0.04255367f, 
    0.02732278f, 0.04898046f, 0.03237362f, 0.01153697f, -0.04634240f, 0.03576808f, 0.02460519f, -0.03238836f, 
    -0.03210428f, -0.00332166f, -0.02633227f, 0.01879046f, -0.05012684f, -0.01201365f, -0.02822244f, -0.05861400f, 
    -0.01214582f, -0.00092827f, 0.04411797f, 0.01419637f, -0.00916342f, 0.01995127f, 0.01352786f, 0.03548238f, 
    -0.06923958f, 0.04040625f, -0.00291140f, 0.03496704f, 0.00454509f, -0.00353972f, 0.04839130f, 0.00032407f, 
    0.01785097f, 0.04810852f, -0.03179188f, 0.03548254f, -0.01795258f, -0.02376984f, -0.05063834f, 0.02496813f, 
    -0.02427505f, 0.01459456f, -0.02145621f, -0.02663974f, -0.01739292f, 0.00066114f, -0.00050897f, -0.06191060f, 
    -0.04125405f, -0.00106788f, -0.01021033f, -0.04287310f, 0.00903516f, -0.01611022f, -0.02561536f, 0.00432510f, 
    -0.03907942f, -0.04343152f, -0.03502094f, -0.00480540f, -0.00735218f, -0.00335107f, 0.01292820f, 0.00398604f, 
    -0.05198563f, -0.01829797f, -0.00541378f, -0.03194114f, -0.00403327f, -0.05792359f, 0.00435396f, 0.04732872f, 
    0.02037108f, -0.04868164f, -0.03390229f, -0.04203586f, -0.02659583f, -0.01352238f, 0.02365389f, -0.00033614f, 
    -0.03805809f, 0.01408091f, -0.00566542f, -0.00979884f, -0.04223262f, 0.02634411f, -0.00960942f, -0.00812530f, 
    0.02628556f, -0.02444748f, 0.01425995f, 0.02420100f, -0.04949552f, -0.05584595f, 0.01158964f, -0.00577241f, 
    -0.04815801f, 0.03204356f, 0.00632038f, -0.01798327f, 0.01849112f, -0.05505485f, -0.00043686f, 0.00364236f, 
    -0.02440153f, -0.03273609f, -0.04749652f, -0.04664139f, -0.03233702f, 0.00311646f, -0.06360856f, 0.03478258f, 
    0.03737497f, -0.01345893f, -0.06324694f, -0.00004402f, 0.01566032f, -0.05053518f, -0.03889727f, 0.00356943f, 
    0.00463592f, -0.06012475f, -0.01755130f, -0.05845344f, 0.00954249f, 0.04513821f, 0.04118779f, -0.00436487f, 
    -0.02883694f, 0.00111519f, 0.01847121f, -0.02813330f, 0.02835099f, 0.02215934f, -0.04460964f, -0.03486436f, 
    -0.00973517f, 0.02970595f, -0.01072484f, 0.01968605f, -0.00791778f, 0.03956993f, 0.00274757f, -0.02065514f, 
    0.02747470f, -0.04620824f, -0.00616603f, -0.01602166f, 0.05389297f, -0.00808282f, -0.04419230f, -0.00999625f, 
    0.00452922f, 0.01042452f, 0.00883472f, 0.04705793f, -0.04606922f, -0.06235762f, 0.01855748f, -0.01406249f, 
    -0.04509630f, -0.02705033f, -0.03461451f, -0.03429827f, -0.05253980f, 0.01344643f, -0.04273534f, 0.01455761f, 
    -0.03728839f, 0.05153655f, -0.01587052f, -0.03446754f, -0.04834425f, 0.05268380f, -0.00164715f, 0.00943274f, 
    0.02818522f, 0.03141416f, -0.05625126f, 0.02703519f, -0.02315868f, -0.02417478f, 0.00931964f, -0.04226080f, 
    -0.01935244f, -0.01738947f, -0.03415105f, 0.00515335f, -0.01379719f, 0.01049681f, 0.03578934f, -0.00143873f, 
    0.00924046f, 0.03854787f, 0.05201691f, 0.03639443f, 0.02875022f, -0.03747800f, -0.02977062f, -0.00021216f, 
    -0.04573452f, -0.01649326f, -0.03103143f, -0.04287924f, -0.01352912f, -0.01031387f, -0.00650753f, 0.00587560f, 
    -0.05582623f, -0.04441056f, 0.03482617f, -0.02207173f, -0.06252860f, -0.01800295f, -0.00729748f, 0.01320772f, 
    0.01166841f, -0.03259913f, 0.03905045f, -0.01758933f, 0.01153182f, -0.03959458f, 0.05344431f, -0.02620211f, 
    0.04500213f, 0.03298748f, -0.05432828f, -0.03072136f, -0.03760028f, 0.00067430f, 0.00951715f, -0.03533249f, 
    0.02484933f, -0.00078295f, 0.04425026f, -0.03064464f, -0.03192149f, 0.03286532f, 0.05140948f, 0.02846380f, 
    0.01829427f, -0.06094921f, 0.01083051f, 0.03945872f, 0.01663371f, -0.02438900f, 0.04300049f, -0.05661058f, 
    -0.04936767f, -0.06394795f, 0.03743651f, 0.03026823f, 0.04552732f, -0.03563001f, -0.01204187f, 0.03127680f, 
    0.03811915f, -0.02394107f, 0.04454346f, -0.03717430f, 0.02334207f, 0.03260014f, -0.04507365f, 0.00844264f, 
    0.00627097f, -0.01296138f, -0.04568613f, -0.00269242f, -0.06092733f, 0.00189915f, -0.01423479f, -0.03872259f, 
    -0.06332564f, -0.04167986f, 0.01619452f, -0.05443003f, -0.04780106f, 0.01346252f, 0.02445281f, 0.04601207f, 
    -0.01097843f, 0.02708054f, 0.04422338f, -0.01946783f, 0.02900414f, -0.03425094f, -0.05406731f, 0.00886043f, 
    0.00865445f, -0.03834054f, -0.01080302f, 0.00310355f, 0.03298923f, -0.02957430f, 0.02328716f, -0.05102612f, 
    -0.06116730f, -0.05219053f, 0.02235209f, 0.04076391f, 0.05135282f, -0.05401872f, -0.04187005f, 0.02849387f, 
    -0.05074751f, 0.03506437f, -0.00555849f, -0.05779759f, -0.02516690f, 0.02445895f, -0.00922360f, -0.04459722f, 
    -0.03123853f, -0.05204920f, -0.01061217f, -0.00650291f, -0.03578579f, -0.03214625f, -0.00307338f, 0.01196514f, 
    -0.01045624f, 0.02146535f, 0.01145277f, -0.05278787f, -0.06040684f, 0.00105281f, 0.03981998f, 0.01983946f, 
    -0.06268293f, -0.03737736f, -0.01981422f, -0.01370572f, -0.00358636f, -0.01188301f, 0.04224238f, 0.00477416f, 
    0.00467273f, 0.02350985f, 0.05054286f, 0.01159438f, -0.01563944f, 0.03148665f, -0.00924732f, -0.00966059f, 
    -0.01267292f, 0.02723527f, -0.03390869f, 0.01367159f, 0.01559553f, -0.06310007f, 0.04554766f, 0.01679788f, 
    0.01031712f, 0.00028878f, -0.03508064f, 0.02780268f, 0.00993411f, 0.00363519f, 0.01636256f, -0.05688019f, 
    -0.00492594f, -0.05797699f, -0.00990117f, -0.01600985f, 0.00495657f, -0.05826687f, 0.04521333f, -0.05802507f, 
    0.52525187f, -0.03993444f, 0.12683348f, -0.03615720f, -0.10080643f, -0.03755493f, 0.07381792f, -0.04497379f, 
    0.11746616f, -0.20439672f, 0.02675785f, -0.08132820f, 0.07100234f, -0.05131464f, -0.00721817f, 0.06496137f, 
    0.14353210f, -0.09892857f, 0.04732634f, -0.18974197f, -0.03109888f, 0.05189759f, 0.11875868f, 0.11872552f, 
    0.11812261f, 0.05468311f, -0.11587868f, 0.37716773f, -0.11246657f, 0.16397750f, -0.10066853f, 0.08156879f, 
    0.10092987f, 0.07048642f, -0.01116942f, 0.03844061f, -0.36149806f, -0.09428033f, 0.07413656f, 0.00938539f, 
    0.20806247f, 0.00365049f, 0.07676645f, 0.00562722f, 0.03304126f, -0.29091445f, -0.21456373f, 0.18255098f, 
    0.14763157f, 0.02076123f, -0.07743705f, -0.02657513f, -0.02262164f, 0.01495040f, -0.33711162f, -0.41049477f, 
    -0.07059704f, -0.09857319f, 0.08030714f, 0.01712027f, 0.01869612f, -0.01551839f, -0.00690591f, -0.40301526f, 
    0.00318964f, 0.05580579f, 0.05571002f, 0.12523648f, 0.04095776f, 0.23788030f, -0.03909582f, 0.10376774f, 
    0.19991851f, 0.20148808f, 0.00196178f, -0.08111203f, -0.30276260f, -0.12842974f, -0.08629636f, -0.01646143f, 
    -0.08361792f, -0.22785334f, -0.31823781f, 0.03897833f, -0.01441238f, -0.09164791f, 0.10100029f, 0.10187219f, 
    0.19598545f, 0.06492075f, -0.14257349f, 0.13225187f, -0.08373526f, 0.08488344f, -0.03719297f, -0.00951440f, 
    -0.09705892f, 0.05269893f, -0.12061247f, 0.06099417f, 0.14028849f, 0.12380509f, 0.11369141f, 0.07236721f, 
    0.04286755f, 0.02438958f, -0.07561130f, -0.13317733f, -0.08473505f, -0.06168738f, -0.26530319f, -0.01277736f, 
    0.04993777f, -0.02801303f, -0.18871479f, -0.03683350f, 0.02029763f, 0.35054338f, -0.05203900f, 0.07945953f, 
    -0.11818876f, -0.04715496f, 0.05313592f, -0.05438132f, -0.06983251f, -0.05053344f, 0.13530950f, -0.12352126f, 
    -0.06600911f, -0.00745932f, 0.08822509f, -0.20343773f, -0.17027068f, 0.07641193f, 0.01244999f, 0.18603757f, 
    -0.11378980f, 0.16867991f, -0.06676890f, -0.04987644f, -0.03179334f, -0.17283447f, 0.09872294f, -0.01286396f, 
    -0.07689017f, -0.08144090f, -0.14332514f, -0.13675311f, 0.11748315f, -0.08030166f, 0.05888836f, -0.02455948f, 
    -0.01128675f, -0.17300878f, -0.03155952f, -0.07164674f, -0.25419441f, 0.07810582f, -0.04032815f, -0.15040872f, 
    0.16299035f, -0.02151199f, 0.00173029f, 0.03018774f, -0.17641567f, 0.02082216f, 0.05319579f, -0.37113246f, 
    0.15217678f, 0.08211849f, 0.18236229f, 0.06173450f, -0.09376545f, -0.10854118f, -0.10153185f, -0.15060964f, 
    -0.23730604f, 0.05117278f, 0.12567125f, 0.10893921f, -0.09135630f, 0.25083765f, 0.01915929f, -0.16755553f, 
    -0.17986941f, -0.09227338f, 0.19680470f, -0.00964481f, 0.17584525f, -0.03529209f, -0.10634457f, 0.04993388f, 
    -0.04194831f, 0.01341237f, -0.02763270f, 0.32797256f, 0.09266799f, 0.17754428f, 0.20685017f, -0.20649354f, 
    0.16984458f, -0.09941787f, -0.11130540f, -0.06300580f, 0.13582781f, -0.00165236f, 0.07812057f, -0.08402301f, 
    0.15624523f, -0.18926409f, 0.04403668f, -0.15090309f, -0.10895010f, -0.10472007f, 0.13362570f, 0.03109761f, 
    -0.06796306f, 0.06603806f, 0.14761342f, -0.02835395f, -0.03123865f, -0.02120627f, -0.20846312f, 0.24338759f, 
    0.01969555f, 0.05123130f, -0.04218516f, -0.00876485f, 0.06187540f, 0.11320610f, 0.03297744f, -0.06178923f, 
    -0.06075384f, 0.02889316f, -0.00042980f, 0.11807503f, -0.14320537f, 0.08770518f, -0.13759084f, -0.03413113f, 
    0.00831298f, -0.05926251f, 0.04725362f, -0.04383790f, 0.09418280f, -0.03430085f, 0.01841529f, 0.10346995f, 
    -0.16840939f, -0.03640063f, 0.17212562f, 0.09483700f, 0.11681122f, 0.11204490f, 0.18426161f, 0.01645283f, 
    0.03541705f, 0.00923930f, -0.10722552f, -0.09939723f, 0.10942065f, 0.24787660f, 0.07447685f, -0.09560827f, 
    0.04002920f, -0.03111866f, -0.04079655f, -0.18500409f, 0.18307953f, -0.30194485f, 0.07033776f, -0.20983672f, 
    0.27323234f, -0.06204642f, 0.02141917f, 0.09329608f, 0.09694571f, -0.24467078f, 0.03064964f, -0.21666677f, 
    -0.29440665f, 0.20024499f, 0.13517319f, 0.11569612f, 0.06232603f, 0.06081355f, -0.03306695f, 0.06472719f, 
    -0.06047789f, 0.12723492f, -0.01289748f, -0.01510660f, -0.00086478f, 0.00450268f, -0.06265866f, -0.00422250f, 
    -0.04654570f, 0.49430323f, 0.04248039f, 0.08188694f, 0.07248037f, -0.04371622f, 0.04311684f, 0.03249981f, 
    -0.07326940f, 0.01589420f, -0.01424161f, -0.01912583f, 0.08053409f, -0.04167068f, -0.04702733f, 0.00807433f, 
    -0.03812907f, 0.15364942f, -0.12216102f, 0.25702161f, 0.15990691f, -0.19170383f, -0.16885774f, 0.04371832f, 
    0.07447621f, -0.05579823f, -0.03966062f, -0.12451766f, -0.34401560f, 0.15417473f, 0.06908482f, 0.11264168f, 
    0.04028159f, 0.04204703f, -0.10563832f, -0.03498795f, 0.01420022f, 0.34033176f, 0.23589647f, -0.26825401f, 
    -0.17800324f, 0.18797073f, 0.00637044f, -0.01586531f, 0.08023530f, -0.12903392f, -0.17862473f, -0.33474779f, 
    0.11148240f, -0.01187878f, 0.11091983f, 0.05480376f, -0.09329169f, 0.08080704f, -0.02583880f, -0.11703743f, 
    -0.10085879f, 0.05904358f, -0.26550290f, 0.09800714f, 0.09873994f, 0.00178446f, 0.08973872f, -0.07974405f, 
    -0.14049874f, 0.14928330f, 0.04119270f, 0.25687370f, 0.26238227f, 0.08186723f, 0.04776663f, 0.22680682f, 
    0.09013133f, -0.23141511f, 0.06230081f, 0.35020769f, -0.03228902f, 0.31892028f, 0.01534814f, 0.03614854f, 
    0.04281261f, 0.03059343f, 0.21258593f, -0.37564781f, 0.18386024f, 0.03338579f, 0.04651151f, 0.05786115f, 
    0.10655123f, 0.01346229f, -0.03544727f, 0.37058258f, 0.11831588f, -0.30933553f, -0.05800777f, 0.14720406f, 
    0.00534297f, -0.01644666f, -0.04366610f, -0.05206000f, 0.01578208f, 0.19441791f, 0.06929545f, -0.00879785f, 
    -0.21593395f, -0.06301554f, 0.06781653f, -0.17660476f, 0.12537876f, -0.27112830f, 0.12637942f, -0.16577642f, 
    0.23927318f, 0.07461859f, -0.08076278f, 0.04615290f, -0.02319577f, -0.08228114f, -0.04841550f, -0.76843864f, 
    -0.30434215f, -0.08707475f, 0.17120038f, 0.11679252f, 0.05737278f, -0.07477236f, 0.04183855f, -0.24342600f, 
    -0.07035018f, -0.17903283f, 0.13434573f, 0.04655280f, 0.00317000f, -0.06907122f, 0.02286867f, -0.03808942f, 
    -0.28938925f, -0.31449643f, 0.21902220f, -0.15021582f, 0.10563137f, -0.12274873f, -0.04959133f, -0.01410195f, 
    0.03256522f, -0.06912806f, -0.34670281f, -0.07580938f, 0.09127630f, 0.02483741f, -0.14955233f, 0.14561653f, 
    0.19990849f, 0.12343952f, 0.30732507f, -0.32333004f, 0.12987068f, -0.00961731f, -0.13256492f, -0.02586003f, 
    -0.15717077f, -0.00926005f, 0.20190856f, 0.36078572f, 0.02910964f, -0.03873511f, -0.03319111f, -0.13601631f, 
    -0.05309644f, -0.09895241f, -0.11152874f, 0.33678719f, -0.25523397f, -0.30852801f, -0.07105051f, -0.06220415f, 
    0.03839029f, 0.13089897f, -0.12637176f, 0.13686572f, 0.25816566f, -0.10704679f, -0.05430950f, 0.12754737f, 
    -0.14068092f, -0.15277892f, 0.06085968f, 0.10935851f, 0.06917812f, 0.02202190f, 0.05228494f, -0.31376889f, 
    -0.59411067f, 0.19834600f, 0.22055335f, -0.03984784f, -0.11693316f, 0.05531268f, 0.11466507f, 0.20546842f, 
    -0.29391474f, 0.05644574f, 0.07785359f, 0.27204055f, 0.03255501f, 0.07698028f, -0.11655386f, 0.16332154f, 
    0.20589419f, 0.22029313f, -0.22311844f, -0.15179422f, 0.07312323f, 0.00410192f, 0.04325796f, -0.00363522f, 
    -0.07455102f, -0.03657809f, 0.37889275f, -0.15233359f, 0.12234369f, 0.02012201f, -0.11477220f, 0.22871844f, 
    0.02577138f, -0.19030294f, 0.04008969f, -0.16613899f, -0.06676956f, -0.03429943f, -0.09047263f, -0.08517431f, 
    -0.04700622f, 0.01239377f, -0.13797738f, 0.28235322f, -0.23962113f, 0.11428583f, -0.00121623f, 0.00609365f, 
    -0.21274734f, 0.10672268f, -0.00422237f, 0.10284930f, -0.12656622f, 0.16189282f, 0.06300036f, -0.11265969f, 
    0.01408320f, 0.08924951f, -0.17274743f, -0.00314720f, 0.00315908f, 0.03762608f, -0.27791166f, -0.06864402f, 
    0.07070312f, -0.08087285f, -0.09906070f, 0.00173322f, -0.01683060f, 0.01303650f, -0.07197937f, 0.06301751f, 
    -0.37714529f, -0.19019707f, -0.00413109f, 0.00234410f, 0.19069409f, 0.07693254f, -0.07934339f, -0.20693561f, 
    0.11322148f, -0.01086476f, -0.05880300f, -0.02733602f, -0.00991830f, -0.05153457f, -0.05809082f, -0.06274716f, 
    0.03662094f, 0.00170776f, -0.08844955f, -0.00462133f, 0.05633287f, -0.20294620f, -0.00369160f, 0.13679174f, 
    -0.05504132f, -0.00388619f, 0.13537216f, -0.00665383f, 0.30695876f, 0.04246026f, -0.07951058f, -0.17118880f, 
    -0.02389061f, -0.09498742f, 0.09966805f, -0.05114615f, -0.02664690f, 0.19154318f, -0.04051090f, 0.03449391f, 
    -0.11077895f, -0.06636175f, -0.09561931f, -0.04377274f, 0.04852774f, -0.15135950f, -0.24217431f, -0.11585376f, 
    -0.03375616f, 0.03658659f, 0.16549978f, 0.00557258f, -0.11475873f, -0.01276920f, -0.16698828f, -0.13967910f, 
    0.16511935f, -0.10874035f, -0.08766119f, 0.02628499f, -0.37924483f, 0.14033706f, 0.27060837f, -0.12496391f, 
    0.08252176f, 0.10995706f, 0.10121011f, 0.07415720f, -0.06247603f, -0.31646281f, -0.10747375f, -0.06331543f, 
    -0.20584996f, 0.16825952f, 0.06468435f, 0.20221813f, 0.01993993f, 0.20931727f, -0.13937280f, -0.27817753f, 
    -0.04165368f, 0.04402431f, 0.03396409f, 0.18504627f, 0.08368721f, 0.09839301f, 0.10880428f, -0.15469390f, 
    -0.01421176f, 0.07682464f, 0.18437938f, -0.04619462f, -0.00002501f, -0.04255792f, 0.06186912f, 0.11984200f, 
    0.23868006f, -0.03576509f, 0.11848360f, -0.20315483f, -0.11938169f, 0.09287390f, 0.01112756f, -0.11638927f, 
    0.09583649f, -0.25946292f, -0.12346137f, 0.02249028f, 0.09504268f, 0.11112210f, 0.08098256f, -0.03629981f, 
    0.00476317f, -0.05836337f, 0.15856516f, -0.11460607f, 0.22323446f, 0.03749214f, -0.08154387f, -0.01941000f, 
    -0.20864095f, -0.13227557f, 0.12977083f, 0.12504402f, 0.21162149f, -0.15825450f, -0.05966904f, -0.01026671f, 
    0.02449291f, -0.02501647f, 0.02529850f, -0.19205944f, -0.07365274f, 0.14105090f, -0.08009715f, 0.02861083f, 
    0.06844071f, 0.08087768f, -0.03525217f, 0.17375615f, 0.06445343f, 0.09269638f, 0.01038894f, 0.23685195f, 
    0.17623509f, -0.23294726f, -0.01777397f, 0.08963355f, -0.04482744f, 0.21041381f, 0.15583320f, 0.08231777f, 
    0.19617620f, -0.08593003f, 0.09948196f, -0.04988722f, 0.11385094f, 0.10587664f, 0.06139280f, -0.00373999f, 
    0.10577689f, 0.02052476f, 0.00675822f, -0.05907195f, -0.17492160f, 0.15860258f, 0.00746965f, 0.11404829f, 
    -0.05074862f, -0.14234726f, -0.04994408f, 0.14071795f, 0.11572222f, -0.12580296f, 0.31667334f, -0.17942749f, 
    0.08803885f, 0.18675166f, 0.05511429f, 0.06110188f, 0.01991528f, -0.08314554f, 0.19550110f, 0.08355404f, 
    -0.14402105f, -0.00459011f, 0.10467268f, -0.11582788f, 0.10201257f, 0.13138695f, 0.04238387f, 0.16661666f, 
    -0.14269555f, -0.01013093f, -0.11272331f, -0.08651020f, 0.00786271f, 0.12969802f, 0.23870824f, -0.05613276f, 
    0.02277033f, 0.12868676f, 0.02348320f, -0.07333036f, 0.19209459f, -0.05948880f, -0.08887198f, -0.18140960f, 
    0.00571264f, 0.09941519f, 0.00798587f, 0.07386144f, -0.07693381f, -0.13252896f, 0.24821176f, 0.20725998f, 
    0.12612656f, -0.26130632f, 0.18415985f, 0.09622404f, 0.19622858f, 0.08400181f, 0.08454525f, -0.08365156f, 
    0.04808705f, -0.01676107f, -0.00519018f, 0.10266872f, 0.04985309f, -0.13788593f, 0.02598610f, 0.01405737f, 
    -0.10350247f, 0.06530914f, -0.04466489f, 0.24006435f, 0.03099571f, 0.05760998f, 0.07518405f, 0.06336816f, 
    -0.21338212f, -0.11027902f, 0.11707185f, 0.04960340f, -0.05050237f, 0.04161133f, -0.08429351f, 0.14239058f, 
    -0.06019358f, -0.00009302f, -0.06246899f, 0.14844710f, 0.03354943f, 0.06494837f, 0.21861577f, 0.09191728f, 
    0.08067250f, -0.03796633f, 0.09030344f, -0.27851209f, 0.09669891f, 0.16563322f, 0.13567248f, -0.05492110f, 
    0.18787387f, -0.13933861f, 0.12383220f, 0.20895366f, 0.04643608f, 0.26094693f, -0.00140683f, 0.16406664f, 
    0.16320691f, 0.08833328f, 0.09324601f, 0.05877249f, -0.17714937f, 0.12294786f, 0.34858730f, -0.06947013f, 
    0.16950148f, 0.09974623f, 0.06998562f, -0.02439140f, 0.06174187f, -0.08308954f, -0.11300594f, 0.12369534f, 
    0.26111618f, 0.10213222f, -0.14054339f, -0.18263297f, 0.21182701f, -0.12379965f, -0.05818274f, 0.02002964f, 
    0.02001435f, -0.25646186f, -0.08361749f, 0.33718285f, -0.02944349f, 0.11837240f, -0.02754338f, -0.30461144f, 
    -0.03593661f, 0.04158673f, 0.00852260f, 0.03807523f, -0.02333688f, -0.00108343f, 0.01042925f, -0.01116946f, 
    0.02159229f, -0.03319896f, -0.00593559f, -0.02437507f, -0.00276961f, -0.05084379f, 0.01887305f, 0.04998819f, 
    -0.05416971f, -0.01067626f, -0.00656645f, -0.02299589f, 0.00324144f, -0.03241613f, -0.01295295f, -0.06233811f, 
    -0.02112991f, -0.05829659f, 0.00234011f, 0.02694700f, -0.02035008f, 0.02209713f, -0.02796047f, 0.02358329f, 
    0.04283451f, -0.00070052f, -0.03692551f, 0.01220708f, -0.02118243f, 0.00430113f, 0.01623721f, 0.02874204f, 
    -0.03790457f, -0.05104879f, -0.05569594f, -0.00126543f, 0.02376691f, -0.01128061f, -0.00480683f, -0.00697089f, 
    0.00519641f, -0.02599161f, 0.03738245f, -0.03020096f, -0.03511632f, 0.00931709f, -0.02912412f, 0.00652443f, 
    0.03103423f, -0.00774271f, -0.03008735f, 0.04631636f, -0.04913080f, -0.05560524f, 0.04458476f, -0.04618252f, 
    0.00631279f, 0.04063394f, -0.05492677f, 0.02293402f, -0.01104421f, -0.02931897f, 0.05646072f, -0.05580144f, 
    -0.05405639f, -0.01012589f, -0.01216758f, 0.01588081f, -0.00360498f, 0.03523558f, -0.03184260f, 0.02977831f, 
    -0.04440957f, 0.01248822f, -0.04358648f, -0.05277066f, 0.03347221f, -0.00229599f, -0.02313993f, -0.03933219f, 
    -0.03843655f, -0.04621235f, -0.01302611f, -0.05132446f, 0.00533092f, -0.05410601f, -0.03329847f, 0.02877604f, 
    -0.03670271f, 0.02140259f, 0.04557852f, 0.03265376f, 0.00351691f, -0.00617343f, 0.04490318f, 0.02752394f, 
    -0.00216807f, -0.01332431f, 0.01147774f, 0.00557268f, -0.05844859f, -0.00929282f, -0.05626788f, -0.02992537f, 
    0.01899925f, -0.04145849f, -0.03300737f, 0.03502943f, -0.00561568f, 0.05021511f, 0.01109737f, -0.00258027f, 
    -0.02364135f, 0.03963831f, -0.01256159f, -0.04541104f, -0.04950620f, -0.04880995f, 0.01731608f, 0.01728530f, 
    -0.04278775f, -0.04380626f, 0.02073678f, -0.04033926f, -0.02616340f, 0.05007103f, 0.01218337f, -0.00535723f, 
    -0.05723143f, -0.06461513f, -0.03143810f, 0.02748220f, -0.02187025f, 0.03512140f, -0.05256538f, -0.03203725f, 
    0.01757761f, 0.04115134f, -0.01980015f, 0.05048344f, -0.03029394f, 0.03471445f, 0.01593769f, -0.01105377f, 
    0.03349845f, 0.02926628f, -0.06460868f, -0.02949576f, 0.03526437f, -0.01376509f, 0.00949715f, 0.02339454f, 
    -0.03665701f, -0.02710551f, -0.03462071f, 0.02730846f, -0.03544745f, -0.00809803f, 0.04350635f, 0.00243647f, 
    -0.06345345f, 0.01062571f, 0.04566320f, 0.04677172f, 0.02656910f, -0.05236027f, -0.05440515f, -0.04154015f, 
    -0.02986231f, 0.00952815f, -0.03316317f, 0.05121873f, 0.05591688f, -0.01653825f, 0.02424153f, 0.03669604f, 
    -0.01868729f, 0.03932343f, -0.01234315f, -0.01040915f, 0.03424958f, 0.05026139f, -0.04347587f, -0.02245964f, 
    0.02132909f, 0.01114930f, -0.01256164f, -0.02375924f, -0.06041903f, 0.04232340f, -0.00181723f, -0.00594030f, 
    -0.01289558f, 0.00362133f, -0.05397534f, -0.00352155f, -0.02685167f, -0.00911409f, -0.03478698f, 0.00396004f, 
    -0.05118133f, -0.00442248f, -0.03375622f, -0.04974995f, 0.02888538f, -0.06019127f, 0.00159488f, 0.02129668f, 
    -0.04291861f, -0.04775264f, -0.03791455f, 0.04441421f, -0.04392044f, -0.05200441f, -0.00641144f, 0.02761048f, 
    -0.03999846f, -0.05751655f, -0.04700226f, -0.03943206f, -0.01323303f, -0.00061381f, -0.03462872f, 0.01209481f, 
    -0.04828201f, 0.03196907f, -0.05420807f, -0.05132621f, -0.04711900f, -0.04944367f, -0.05957016f, -0.05498820f, 
    0.01733026f, -0.04071860f, -0.00274354f, -0.00443224f, -0.06038912f, 0.00370589f, -0.02949254f, -0.01323388f, 
    -0.02832490f, -0.04688884f, -0.06450430f, -0.03963616f, -0.03212531f, 0.04862342f, 0.04951598f, -0.05811318f, 
    -0.00959978f, 0.01947278f, 0.00447447f, -0.03372218f, 0.03730656f, -0.06043526f, -0.05241811f, -0.00955672f, 
    0.01009132f, 0.00358753f, -0.04269304f, 0.02258918f, -0.04366233f, -0.03382610f, -0.05006408f, -0.01748315f, 
    -0.00796062f, 0.02960814f, 0.00162116f, 0.03499664f, -0.00369653f, 0.01628929f, -0.05460276f, 0.03845780f, 
    0.00730214f, 0.03915223f, 0.03089705f, -0.05629559f, 0.04016216f, -0.05885045f, -0.06380983f, -0.01467176f, 
    -0.03233583f, -0.06643087f, -0.02416231f, -0.04266345f, 0.01798647f, -0.00070500f, -0.00073207f, -0.02946367f, 
    -0.04443132f, 0.02172328f, 0.03419421f, -0.01966061f, 0.05220665f, 0.04682172f, 0.04264799f, 0.02351347f, 
    -0.05612800f, 0.01929664f, 0.03396275f, 0.02490092f, 0.04078976f, 0.02217278f, 0.04823125f, 0.00123311f, 
    -0.05305770f, -0.05227964f, 0.00601960f, -0.06405567f, -0.04734363f, 0.00337698f, 0.04843923f, 0.00063843f, 
    -0.01197871f, -0.03636462f, -0.02647902f, 0.06340666f, -0.06398664f, 0.05190982f, -0.05910140f, 0.05522435f, 
    -0.02591512f, 0.02611610f, -0.05718472f, 0.03437527f, 0.03030491f, 0.05535892f, -0.04191662f, -0.02467330f, 
    -0.04503094f, 0.05350324f, 0.03798731f, -0.02683937f, -0.01012992f, -0.02421580f, -0.01111565f, -0.01306228f, 
    -0.00068730f, 0.00623172f, -0.05074292f, -0.01407515f, 0.00657026f, 0.05220757f, 0.02010985f, 0.05335393f, 
    -0.02972291f, -0.03640592f, 0.01665642f, 0.03970824f, -0.01668492f, -0.03663569f, -0.04189080f, -0.02554957f, 
    -0.03301693f, 0.01154030f, 0.03120664f, 0.04452992f, -0.05983140f, -0.02682388f, 0.01619225f, -0.02032183f, 
    -0.04157481f, 0.04737927f, 0.01679533f, -0.03021951f, -0.06282394f, 0.05030065f, 0.04838451f, -0.03543315f, 
    -0.03856445f, 0.03078311f, -0.01877438f, -0.05949454f, 0.05133915f, 0.03381386f, -0.01328694f, 0.00940932f, 
    -0.01047193f, -0.04922913f, 0.01532413f, 0.01486232f, -0.02030269f, 0.02238709f, -0.03285768f, -0.05580779f, 
    -0.01962320f, -0.04799404f, -0.05528912f, -0.01646085f, 0.03466200f, 0.01830490f, -0.06431619f, 0.01770055f, 
    -0.03118964f, -0.00545720f, -0.00069462f, -0.04182095f, 0.03250542f, -0.02655285f, 0.02626446f, 0.04381746f, 
    -0.02285076f, -0.00505920f, 0.02023810f, -0.03142444f, 0.01830228f, 0.05226187f, -0.05288466f, -0.03985771f, 
    -0.00065224f, -0.01472219f, -0.06918158f, -0.02506105f, -0.05376870f, 0.03273019f, 0.01043521f, 0.01435091f, 
    -0.02542645f, -0.03497902f, -0.04324716f, -0.00678107f, -0.03894131f, -0.01679388f, -0.00362566f, -0.03876296f, 
    -0.03940784f, -0.00280890f, 0.00929395f, -0.03325479f, 0.02993808f, 0.02901109f, 0.03987526f, 0.02758145f, 
    0.01399503f, -0.03403384f, -0.02063056f, -0.04683405f, -0.04179921f, 0.00704901f, -0.02987488f, -0.06349979f, 
    -0.05020752f, -0.01284484f, -0.04929648f, 0.04347001f, 0.01631219f, -0.03842819f, -0.03715178f, 0.00826391f, 
    -0.03507762f, -0.06044896f, -0.00524337f, -0.04133446f, -0.04230097f, 0.00762254f, -0.02117387f, -0.04062406f, 
    0.01341435f, -0.02779046f, -0.02125379f, -0.06776353f, 0.03878345f, 0.05282933f, -0.05051640f, -0.02168938f, 
    0.05209394f, -0.04185469f, 0.02156667f, 0.04133861f, 0.04257483f, 0.00143021f, 0.01941962f, 0.03153693f, 
    0.04232135f, 0.03354191f, 0.02488399f, 0.00239003f, 0.00943298f, -0.01807743f, -0.05019176f, 0.02407886f, 
    0.04379052f, 0.01328235f, 0.02424521f, 0.00205639f, -0.04068773f, -0.04065530f, -0.06801843f, -0.05136381f, 
    0.01578579f, -0.05878422f, 0.03736406f, 0.02701740f, -0.00219356f, -0.03051331f, -0.01218273f, -0.04082962f, 
    0.00692456f, -0.05989508f, 0.01473736f, 0.04184920f, 0.02990635f, -0.02856669f, 0.01936189f, -0.04203956f, 
    0.04380964f, 0.04919369f, 0.00626746f, -0.01071633f, 0.00244701f, -0.02859191f, 0.03489718f, 0.04577225f, 
    0.01759877f, 0.02837186f, 0.02409421f, 0.04156243f, 0.00767889f, -0.00337337f, 0.01741979f, -0.05984329f, 
    0.01400302f, 0.00578323f, -0.00317497f, -0.05163347f, -0.03333680f, -0.00994403f, 0.00105547f, 0.02659818f, 
    -0.05187953f, 0.03107128f, 0.01294842f, -0.06059540f, 0.03289297f, 0.01421826f, -0.03381265f, -0.00782286f, 
    -0.01487583f, -0.02985640f, -0.05932795f, -0.04584219f, -0.00815464f, 0.05381663f, -0.06424591f, 0.00665141f, 
    -0.05350742f, 0.02838472f, -0.01044457f, 0.00101518f, 0.04416468f, -0.04867996f, -0.02693000f, 0.03866794f, 
    -0.02951298f, 0.03232644f, 0.01910556f, -0.05264072f, -0.03490516f, -0.00140634f, 0.04736301f, 0.03720543f, 
    -0.03844105f, -0.03289332f, 0.02776664f, -0.03117072f, -0.00485364f, -0.05908771f, -0.03525559f, 0.01530057f, 
    -0.26353320f, -0.23503044f, -0.25141767f, -0.02175506f, 0.18259135f, 0.08132587f, -0.01382838f, 0.09467597f, 
    0.07944340f, 0.19168285f, 0.00038884f, 0.01066783f, 0.02908356f, 0.03563394f, 0.13520736f, 0.01631141f, 
    -0.13162023f, 0.16772901f, -0.08830892f, 0.10981107f, 0.06403968f, 0.00514725f, 0.11735251f, 0.02209050f, 
    0.11951277f, 0.05904460f, 0.07953220f, -0.10883321f, -0.14418884f, -0.40883294f, 0.21002974f, 0.18096803f, 
    0.02573437f, -0.11249207f, 0.06777871f, 0.01024361f, 0.01364112f, 0.10143011f, -0.09075476f, 0.04513870f, 
    -0.03295879f, 0.06173700f, 0.10411658f, -0.01609447f, 0.04634345f, 0.21364884f, 0.19684531f, 0.36025244f, 
    -0.01841793f, 0.06558958f, 0.01715525f, 0.19862548f, -0.04503713f, 0.12320187f, 0.12604575f, 0.17528164f, 
    -0.02828840f, 0.07989707f, 0.05067087f, -0.00359885f, 0.02191073f, 0.01185090f, 0.20684527f, 0.26427907f, 
    0.18170384f, -0.00877376f, 0.26250598f, -0.04214487f, 0.00296736f, 0.06885150f, -0.00029186f, 0.03528763f, 
    -0.33744422f, -0.00166471f, -0.09427493f, -0.22128361f, -0.01885132f, -0.09363275f, 0.09665152f, -0.07260868f, 
    -0.36307555f, -0.11767223f, 0.01783774f, -0.08915100f, -0.00992953f, -0.09892297f, -0.14866485f, 0.06817999f, 
    -0.00862933f, -0.23853286f, -0.05964550f, -0.13682920f, 0.15543465f, 0.02320980f, -0.01997765f, -0.05180747f, 
    -0.01289717f, -0.03688479f, 0.05556858f, -0.15263012f, 0.05557802f, -0.09544542f, 0.02627032f, -0.10924882f, 
    0.12778690f, -0.00527585f, 0.03233977f, -0.00054324f, 0.03138967f, -0.09122638f, 0.14365654f, 0.11177340f, 
    0.03029465f, 0.06578527f, -0.09260725f, -0.02929327f, 0.11563684f, -0.42629343f, -0.21103440f, -0.18206951f, 
    0.08569111f, 0.07307100f, 0.01678898f, -0.05904299f, 0.12955418f, -0.01600986f, -0.12329086f, 0.19216697f, 
    -0.13908993f, 0.12325471f, 0.14552730f, 0.08476649f, -0.15451446f, -0.20037916f, -0.30648392f, -0.15125082f, 
    -0.10888476f, -0.19119474f, -0.01824631f, -0.00078927f, 0.09835028f, 0.12544873f, -0.12945633f, 0.06926744f, 
    0.09089239f, 0.06995742f, 0.16067092f, -0.03857410f, -0.10534436f, -0.09602464f, 0.09358955f, -0.13670102f, 
    -0.11853866f, 0.34917504f, 0.13868600f, 0.27229863f, 0.02823824f, -0.01406686f, 0.04565441f, -0.03645366f, 
    0.02672253f, -0.12747295f, 0.09190455f, 0.05695245f, 0.15308413f, -0.24234231f, 0.12082712f, -0.18973300f, 
    -0.10163092f, 0.04937603f, 0.01693174f, 0.20935556f, -0.05867852f, 0.21176215f, -0.13570485f, 0.14748400f, 
    -0.09380724f, -0.06930714f, 0.10687662f, 0.18896464f, 0.41934285f, 0.15194017f, 0.00449125f, -0.20545617f, 
    -0.09665831f, -0.20689216f, -0.09606761f, -0.07932504f, -0.08565035f, 0.12348986f, 0.19690903f, 0.10522724f, 
    0.15342975f, 0.01712591f, -0.05742790f, -0.00860301f, 0.02578876f, 0.10806118f, -0.21950264f, -0.22377245f, 
    -0.13777138f, 0.04688784f, -0.05621541f, -0.08354433f, 0.08428155f, 0.00136210f, 0.05879608f, -0.17220476f, 
    0.22427581f, -0.06238610f, 0.09358085f, -0.07045093f, -0.07485469f, 0.14122559f, -0.05215393f, 0.11143938f, 
    0.21322413f, 0.06177232f, 0.16513096f, -0.02205152f, -0.03858654f, -0.06445200f, 0.05352866f, -0.06388210f, 
    0.00621415f, -0.03437531f, -0.46659559f, -0.26269159f, 0.09903651f, -0.08088198f, -0.16616295f, 0.09836280f, 
    -0.09005686f, 0.07724054f, -0.02701888f, -0.09996936f, 0.20849808f, -0.12399602f, 0.01243033f, 0.04076098f, 
    0.08482699f, 0.03685380f, 0.00813061f, 0.14764716f, 0.19526520f, 0.16538174f, -0.07583067f, -0.07606616f, 
    -0.03333978f, -0.03842364f, -0.02361456f, -0.07885315f, -0.02424631f, -0.17725898f, -0.04907805f, 0.22954634f, 
    0.11924824f, -0.00897598f, -0.03435912f, 0.18123059f, 0.07554176f, 0.14952138f, -0.10020632f, -0.00067283f, 
    0.10784399f, 0.12100799f, 0.06084703f, 0.26922044f, -0.00419864f, 0.00019159f, -0.18269439f, -0.45037943f, 
    -0.23681255f, 0.02477323f, -0.07617767f, -0.11184291f, 0.03189055f, -0.01289548f, 0.24141157f, -0.10891489f, 
    -0.05372935f, 0.00364378f, 0.30716866f, 0.05800090f, 0.00589969f, 0.20552658f, 0.01497701f, 0.10385647f, 
    -0.00209610f, -0.03718268f, -0.01188994f, -0.01518996f, -0.04764929f, -0.04532722f, -0.01964064f, 0.01161480f, 
    0.01274252f, -0.01210419f, -0.03180958f, -0.05576030f, 0.01333505f, -0.05849806f, 0.03579598f, -0.02931558f, 
    -0.00054170f, 0.02176779f, -0.05013482f, -0.02795897f, -0.01522925f, -0.05535209f, 0.00533647f, -0.00031691f, 
    0.00957823f, -0.03935036f, -0.02125845f, 0.00080224f, -0.06512056f, -0.00079821f, -0.04846187f, 0.03150559f, 
    0.03083591f, 0.00252088f, -0.04647195f, 0.02305938f, 0.04046440f, -0.03354023f, -0.05909210f, -0.04996713f, 
    0.00682857f, 0.04359506f, 0.03446956f, -0.04194341f, -0.05306004f, 0.04855853f, 0.02788445f, -0.01099840f, 
    -0.00647979f, 0.04697286f, -0.03972870f, 0.01506322f, 0.01317746f, -0.04948534f, 0.03911622f, 0.00247273f, 
    -0.03937256f, -0.06442492f, -0.02499264f, 0.01620076f, -0.06565886f, -0.05237047f, 0.00797332f, 0.04747991f, 
    -0.01186599f, -0.02709526f, -0.04885808f, 0.03768414f, 0.03036759f, -0.03613393f, -0.01871799f, -0.05508314f, 
    0.01206707f, -0.00035775f, -0.02851432f, 0.02428643f, 0.03484024f, 0.00421463f, 0.01597232f, -0.05605622f, 
    0.03798611f, -0.00674611f, 0.01794952f, 0.03550211f, 0.04486859f, 0.04424516f, -0.03198650f, 0.05306854f, 
    -0.01483320f, -0.07262443f, -0.00127798f, -0.03445285f, -0.00984014f, -0.01241405f, 0.01279828f, 0.00358754f, 
    -0.05921450f, -0.06866245f, 0.03425377f, -0.00424603f, -0.02940032f, 0.04298600f, -0.03555875f, -0.03278604f, 
    0.02069744f, 0.03720286f, 0.04373781f, 0.03326096f, -0.06398967f, -0.06578057f, -0.00102449f, -0.05611441f, 
    0.01942100f, 0.03084313f, 0.00031705f, -0.03921365f, -0.03508405f, -0.05098606f, 0.00479813f, 0.01982368f, 
    0.03798808f, 0.04716965f, -0.01868668f, -0.02127068f, -0.06500648f, 0.04193864f, -0.03764054f, 0.03153637f, 
    -0.02662356f, -0.05176992f, -0.03262513f, -0.05465036f, 0.03271219f, 0.05566848f, -0.04403692f, 0.02550574f, 
    0.02110407f, -0.04202817f, -0.00017059f, -0.03771256f, -0.02725593f, 0.02252367f, -0.04282331f, -0.03257379f, 
    -0.03661530f, -0.01889223f, -0.05254098f, 0.01115928f, 0.02459452f, -0.05918595f, -0.04921069f, 0.04333406f, 
    -0.00493600f, 0.01811508f, -0.02569121f, 0.03507673f, -0.04648117f, 0.01109171f, -0.02001951f, -0.04343078f, 
    -0.00707308f, -0.00721654f, 0.01552463f, -0.05652597f, -0.05806031f, 0.01703556f, 0.00508481f, -0.04316963f, 
    0.04068019f, 0.03828567f, -0.00721154f, 0.05024721f, -0.00217701f, -0.01992772f, 0.02431648f, -0.05310817f, 
    0.04113102f, 0.02569774f, -0.06728215f, -0.01144042f, 0.03874796f, -0.04594643f, 0.00305796f, 0.03305898f, 
    0.03130518f, -0.00294497f, 0.01909384f, -0.04640611f, -0.01319706f, -0.04626264f, 0.00304262f, -0.01159582f, 
    -0.01774645f, 0.03089012f, -0.06010114f, 0.00447686f, 0.03893337f, 0.03058629f, -0.02835564f, 0.04327004f, 
    -0.02300304f, 0.00840655f, -0.05416078f, -0.05875359f, -0.03122890f, 0.02168021f, 0.03486668f, -0.04965313f, 
    -0.00252995f, -0.00700248f, -0.01404599f, -0.04842356f, 0.00637057f, -0.01317847f, -0.06511498f, 0.02890600f, 
    0.01474443f, 0.02480352f, -0.00572730f, 0.00262673f, -0.03220731f, 0.03949247f, -0.04841146f, 0.01169684f, 
    -0.05956828f, 0.03230744f, 0.02389683f, -0.03144122f, 0.03192879f, 0.00501069f, 0.00166918f, -0.02407631f, 
    0.02424480f, -0.06359236f, -0.03386394f, -0.00216005f, -0.04981212f, -0.03746228f, 0.00085195f, 0.01523407f, 
    -0.05694129f, 0.04841577f, -0.01070164f, 0.01205425f, -0.04524440f, 0.01269065f, 0.00189646f, -0.00946081f, 
    0.03870799f, 0.00430575f, -0.00580820f, -0.01437240f, -0.03861496f, 0.00720788f, -0.04686171f, 0.02312391f, 
    -0.02424031f, -0.00285383f, 0.03475081f, -0.00692866f, 0.03019207f, -0.00343001f, -0.01396488f, -0.03457798f, 
    0.03116083f, -0.04090989f, 0.02217735f, -0.05090657f, 0.05352385f, 0.03324284f, -0.06515751f, 0.04609259f, 
    0.03386285f, -0.04995953f, 0.04083490f, -0.03280971f, 0.05154293f, -0.00443523f, 0.04409572f, -0.05689686f, 
    -0.05106379f, 0.01731353f, 0.00968078f, -0.03442129f, 0.00254664f, 0.02361947f, -0.02638184f, 0.00645674f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.28233272f, 0.03004413f, 0.12404931f, 0.15784879f, -0.04118594f, 0.08036651f, 0.05253582f, -0.15693863f, 
    0.04674803f, 0.03720258f, -0.04999832f, 0.02822487f, -0.02026016f, 0.08491729f, -0.04210763f, 0.07732897f, 
    0.03767378f, 0.11221059f, -0.01303736f, 0.00128079f, 0.05662414f, 0.17560655f, 0.12314887f, -0.03039690f, 
    -0.04605865f, 0.07272002f, -0.04345457f, 0.05368670f, -0.05334634f, -0.03436150f, -0.00120465f, 0.01117355f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.25217018f, 0.08019510f, 0.09164551f, -0.23097983f, -0.49061784f, -0.73092610f, 0.62469399f, 0.28071740f, 
    -0.01881083f, -0.08748759f, -0.24957952f, 0.30267310f, 0.25209588f, 0.20665754f, 0.08869854f, -0.57135910f, 
    0.44192511f, 0.12605809f, 0.42196530f, -0.37464321f, 0.32838893f, -0.09754932f, -0.04583744f, 0.04305536f, 
    -0.16184722f, -0.18118498f, 0.32820475f, 0.37724215f, -0.10603230f, 0.09856429f, -0.36002293f, 0.17695498f, 
    -0.13374917f, -0.24786179f, 0.17427349f, 0.27516750f, 0.06130986f, 0.14634401f, 0.24591470f, 0.28256637f, 
    -0.04299395f, 0.14381909f, -0.22755644f, -0.15193245f, 0.08367471f, -0.09544694f, -0.14031231f, 0.22860964f, 
    0.18305281f, 0.30641878f, -0.26799083f, -0.17615668f, -0.05698195f, 0.22091040f, 0.36390334f, -0.17540708f, 
    -0.15230809f, -0.47510576f, -0.03362451f, -0.23380378f, -0.03559385f, 0.16059923f, 0.30918330f, 0.13338055f, 
    0.03358788f, -0.01237064f, -0.09876325f, 0.07549676f, -0.05422172f, -0.17626126f, 0.05862155f, -0.05034917f, 
    0.03865622f, -0.01435614f, -0.08830727f, -0.16418989f, 0.00947539f, -0.10630636f, -0.11073769f, 0.03864688f, 
    0.05975292f, -0.04042340f, 0.16032605f, 0.13194907f, -0.14271034f, -0.04423636f, 0.07880092f, -0.11813843f, 
    -0.07859018f, -0.10349480f, 0.10018802f, -0.04011457f, 0.14098452f, 0.01036528f, -0.08256552f, -0.07628361f, 
    -0.31396112f, -0.10344714f, 0.12016542f, 0.21080115f, -0.00915590f, 0.24712016f, 0.49810666f, -0.69370508f, 
    0.15124112f, -0.01185532f, -0.52565515f, -0.15553297f, 0.39377734f, 0.24619210f, -0.00020426f, 0.39616382f, 
    0.31186274f, 0.13031368f, -0.35881290f, 0.11426292f, -0.31454763f, -0.37623078f, 0.30614612f, -0.12911165f, 
    0.13370840f, -0.21362874f, -0.11263267f, -0.00484404f, 0.08453577f, -0.04484299f, -0.18360159f, 0.10646113f, 
    -0.13374242f, -0.17768846f, -0.13663419f, -0.09981751f, -0.14423122f, 0.10701915f, 0.02049465f, 0.09934667f, 
    -0.11919606f, 0.09431664f, 0.03611292f, -0.00300954f, -0.04922449f, 0.09325423f, 0.15181015f, -0.07010208f, 
    -0.11255325f, 0.09983105f, 0.05092277f, -0.05070509f, 0.09562922f, -0.11335721f, -0.09011105f, 0.14780085f, 
    -0.10538242f, 0.06298488f, -0.11831060f, -0.12627125f, -0.08077633f, 0.15273978f, -0.04696779f, 0.12022354f, 
    0.32572886f, -0.02339695f, 0.21955658f, 0.15880010f, 0.12163498f, 0.39376953f, -0.07367693f, 0.39283830f, 
    -0.12988749f, 0.02765830f, 0.15666221f, 0.31356090f, -0.41064093f, 0.01194120f, -0.00426520f, 0.34519115f, 
    0.03095022f, -0.21773943f, -0.66915780f, 0.21913692f, -0.06350500f, 0.15245001f, -0.26175290f, 0.14310685f, 
    0.04943347f, -0.12536764f, 0.47589782f, -0.06147307f, -0.04110462f, 0.07493961f, -0.16721238f, -0.08413586f, 
    -0.19976319f, 0.06855683f, 0.08278082f, -0.15374997f, -0.22803003f, 0.45914450f, -0.53061658f, 0.31660339f, 
    -0.03256542f, -0.00553320f, 0.47996899f, 0.14909574f, -0.17096028f, -0.03428407f, 0.14930335f, 0.31912640f, 
    0.09211948f, -0.07658623f, 0.19378111f, 0.30935621f, 0.31109309f, 0.58353806f, -0.29457575f, 0.14106597f, 
    -0.03561146f, -0.29419529f, 0.54084551f, 0.18478522f, 0.15794064f, 0.05607499f, 0.57053638f, 0.02392670f, 
    0.27838638f, -0.26928484f, 0.30253515f, 0.22475162f, 0.20176291f, 0.35694745f, 0.07120918f, -0.10028690f, 
    -0.11493679f, 0.12842353f, -0.09197400f, -0.10400169f, 0.09680203f, -0.15154189f, -0.10640991f, 0.42974338f, 
    0.27859277f, 0.22718474f, -0.46287709f, -0.22156365f, -0.20388374f, -0.08513664f, 0.25880054f, -0.00676246f, 
    -0.05880870f, -0.40291041f, -0.14970025f, -0.10772115f, -0.08678594f, -0.18264559f, 0.01232396f, 0.08549659f, 
    -0.09761917f, 0.12471266f, -0.08970109f, -0.15412836f, -0.09177756f, -0.14545655f, 0.07188481f, 0.05385218f, 
    0.06972041f, 0.04061810f, -0.18320890f, -0.04412543f, 0.14142197f, -0.01345923f, -0.18098803f, 0.07296331f, 
    -0.06872206f, 0.02820737f, -0.04526276f, -0.06461819f, -0.09488820f, -0.16999820f, -0.07509160f, 0.02710663f, 
    -0.10014062f, -0.15752761f, -0.15441236f, 0.00898308f, -0.06885349f, -0.00869815f, 0.09188247f, -0.08217789f, 
    -0.08320973f, 0.01845519f, -0.12880866f, -0.09737250f, 0.04226528f, 0.05420096f, 0.08585204f, -0.05309498f, 
    0.12317415f, -0.17256184f, -0.17591816f, -0.07241986f, -0.02800292f, -0.13763608f, 0.15685621f, 0.11712383f, 
    -0.06056256f, 0.11732348f, -0.10280858f, 0.11786973f, -0.13477786f, 0.04869398f, -0.19804057f, 0.00174780f, 
    0.13007924f, -0.02384221f, 0.03739893f, -0.04187817f, -0.05320814f, -0.08967414f, -0.01414514f, 0.01531416f, 
    0.32757756f, -0.26353297f, 0.31890133f, -0.28196588f, 0.28593269f, 0.01563961f, 0.13970676f, 0.92868483f, 
    -0.01632400f, -0.08494354f, -0.25730902f, -0.30626374f, 0.01840149f, -0.02642698f, -0.16778281f, -0.40768880f, 
    0.29097614f, 0.32033271f, 0.16191435f, 0.07476748f, -0.34622028f, 0.43840051f, 0.38290581f, -0.12636684f, 
    0.10287167f, -0.53996617f, 0.21607587f, -0.09731336f, -0.03368774f, 0.02613675f, 0.34043652f, -0.11944970f, 
    -0.51114476f, -0.39501995f, 0.10253435f, 0.08127309f, -0.32931384f, 0.47507346f, -0.02324087f, -0.16746788f, 
    -0.03978346f, 0.14908554f, -0.35168132f, -0.00057097f, -0.13643977f, 0.09205462f, 0.10272085f, 0.24189369f, 
    -0.26042929f, -0.26263601f, 0.61942661f, -0.05562228f, -0.08262781f, 0.64741838f, 0.39735866f, -0.00617498f, 
    0.05507360f, -0.24519455f, 0.51247770f, 0.06034451f, -0.03138277f, 0.15589999f, 0.03760207f, 0.12973814f, 
    -0.69580203f, -0.65580660f, 0.23786899f, 0.17042583f, -0.27248424f, 0.15725110f, 0.26107374f, -0.11785022f, 
    0.13563056f, 0.00320464f, 0.23570991f, 0.51688230f, 0.09356596f, 0.19273378f, 0.16546105f, 0.32481688f, 
    0.19558538f, -0.06714387f, -0.04142807f, -0.32362947f, -0.21891104f, -0.56685382f, 0.44982192f, -0.16549227f, 
    -0.14607243f, -0.24856050f, -0.18255955f, -0.01820980f, -0.15092593f, -0.13703111f, 0.23864721f, 0.14574268f, 
    -0.07227870f, -0.15381578f, 0.03969930f, 0.04395995f, -0.13596837f, -0.05054393f, 0.02703950f, -0.03376542f, 
    0.03607637f, 0.05182826f, -0.07514669f, -0.19339922f, 0.06383187f, -0.05872773f, -0.05950412f, -0.04448004f, 
    -0.13700224f, -0.04159952f, -0.17581663f, 0.03428749f, -0.00429844f, -0.02385140f, -0.19767471f, -0.16562319f, 
    0.04441852f, -0.10278438f, -0.13834424f, -0.05334833f, 0.05355775f, -0.00691395f, 0.09487417f, 0.08868868f, 
    -0.01969016f, 0.10383201f, -0.02907266f, -0.00135703f, 0.01083756f, 0.08084244f, -0.12183209f, -0.13349059f, 
    0.02028975f, -0.12953247f, -0.18415415f, -0.19842412f, 0.01624823f, 0.07624879f, 0.07930329f, 0.10258866f, 
    -0.18475874f, 0.01103021f, -0.14581969f, -0.09139458f, -0.06586731f, 0.13024777f, 0.06592722f, -0.12967838f, 
    0.00294014f, -0.04936366f, -0.01312419f, -0.16634144f, 0.06007057f, -0.18218414f, 0.00443408f, 0.04339058f, 
    0.23289348f, 0.19881402f, 0.21605487f, 0.20116404f, 0.71703738f, 0.30523011f, -0.39565307f, 0.65496171f, 
    -0.17965172f, -0.16537584f, 0.02910932f, -0.31405836f, 0.23250696f, -0.11331803f, 0.04161827f, -0.22111481f, 
    -0.13142511f, 0.13841972f, 0.31571746f, 0.13418259f, -0.30293840f, 0.66233468f, 0.09044922f, -0.05354943f, 
    0.02975234f, -0.20057361f, 0.28123119f, -0.33239061f, 0.14846861f, 0.06247258f, 0.38275823f, -0.13109300f, 
    0.85752505f, -0.30736822f, 0.18342850f, -0.18093179f, 0.08743963f, 0.09023724f, 0.17637148f, 0.66405511f, 
    -0.09697270f, 0.05464371f, 0.28037465f, 0.04052739f, -0.22803192f, 0.13587700f, -0.06798563f, -0.25355685f, 
    -0.43281576f, -0.18243885f, -0.11113747f, 0.30896196f, -0.02155811f, 0.04030436f, -0.00591554f, -0.10666636f, 
    -0.09314891f, 0.33755958f, -0.50211465f, 0.09081495f, -0.13123026f, 0.10771687f, 0.28893635f, 0.09845462f, 
    0.35443905f, -0.10216765f, 0.06283664f, 0.19878192f, 0.10404378f, 0.15709133f, 0.01258778f, 0.00890554f, 
    -0.00831314f, 0.09306442f, -0.09028688f, 0.24842925f, -0.21992685f, -0.00411288f, 0.09445219f, 0.10055213f, 
    -0.02934298f, -0.21229409f, -0.15554608f, 0.14587766f, 0.16422355f, 0.31610525f, -0.00792999f, 0.15204503f, 
    -0.07238177f, 0.00514415f, 0.13917187f, -0.15623957f, -0.02267239f, 0.06329016f, -0.10573391f, -0.00813498f, 
    0.14752933f, -0.21525566f, 0.23366003f, 0.27376691f, -0.03409893f, -0.46322644f, 0.01819817f, -0.28871506f, 
    -0.14048964f, 0.09935213f, 0.08326916f, -0.23638809f, 0.08155900f, -0.20898791f, 0.10273103f, -0.17368567f, 
    -0.04763470f, 0.11323795f, 0.27004308f, 0.10002575f, 0.21606022f, 0.15015928f, -0.46495172f, 0.15698637f, 
    0.05555939f, -0.00270109f, -0.46968663f, 0.04489236f, -0.12646301f, -0.15412661f, 0.15394084f, -0.02665948f, 
    0.11091238f, 0.01962996f, -0.09015592f, -0.10846648f, 0.01273474f, 0.03898317f, 0.07630894f, -0.02510935f, 
    -0.16255401f, -0.09243590f, -0.01242767f, -0.10265798f, -0.01882312f, -0.18910941f, 0.09679470f, 0.02113149f, 
    0.04394738f, 0.10339216f, 0.11851110f, 0.07284705f, -0.11368246f, 0.02920227f, -0.03692603f, -0.04368592f, 
    -0.13847992f, -0.13241227f, -0.02467430f, -0.16584232f, 0.13707229f, -0.16407934f, -0.05251013f, -0.14401910f, 
    -0.52011496f, -0.00126853f, -0.00453349f, -0.49003187f, -0.16610403f, 0.09383812f, 0.26682547f, 0.08627730f, 
    -0.16603462f, -0.02837003f, -0.05790406f, -0.14078331f, -0.48843172f, 0.24126527f, 0.10710275f, 0.01128838f, 
    -0.20139298f, 0.86725408f, 0.29800034f, 0.08963028f, 0.15226282f, -0.35672095f, 0.13120650f, -0.02204063f, 
    0.13592786f, -0.23890840f, 0.39155784f, 0.39620560f, 0.13979539f, 0.09563848f, -0.10408933f, -0.02352623f, 
    -0.16933388f, -0.09137458f, -0.17006819f, 0.00061419f, -0.06587879f, 0.08304588f, -0.10993042f, 0.00122972f, 
    0.05256606f, 0.05976366f, 0.09896802f, -0.15842776f, 0.05003309f, -0.17943469f, 0.03469726f, -0.15642720f, 
    -0.04527327f, 0.00571243f, 0.10706110f, -0.08977800f, 0.06740306f, 0.01470775f, -0.12900984f, -0.03468820f, 
    0.02760920f, -0.21185787f, -0.05031324f, -0.03607325f, -0.01235094f, -0.00391997f, 0.12157068f, 0.11399611f, 
    -0.04836117f, -0.16476713f, -0.16197775f, -0.02503251f, 0.16658013f, -0.17630436f, -0.04648764f, -0.12603408f, 
    0.02117685f, 0.11682594f, -0.10206310f, -0.06549681f, -0.14295316f, 0.04130914f, 0.00515435f, -0.07186754f, 
    -0.09434186f, -0.15669501f, 0.11145846f, -0.17045601f, -0.14376427f, 0.11358799f, -0.09291743f, -0.01183336f, 
    -0.10700694f, -0.02370195f, -0.01504904f, 0.11828955f, -0.14650023f, -0.17463186f, -0.13629872f, 0.11888579f, 
    -0.10943972f, -0.19820693f, 0.11495320f, 0.46329105f, -0.37100527f, -0.09395543f, 0.11338735f, -0.50273955f, 
    0.04496289f, -0.01357779f, 0.30519202f, 0.73775071f, 0.25631404f, 0.14752859f, 0.17349237f, -0.08747207f, 
    0.37804329f, -0.18854156f, -0.27940094f, -0.32640183f, -0.09846836f, -0.17733912f, 0.16472600f, -0.11692883f, 
    0.12101657f, 0.35550663f, 0.03997722f, 0.13732569f, 0.09036788f, -0.12591809f, -0.14085114f, 0.13540281f, 
    -0.01910270f, 0.04745779f, -0.03078817f, 0.13341260f, -0.05578641f, -0.15255316f, 0.07656245f, 0.07415318f, 
    -0.03791503f, -0.08690786f, 0.06671189f, 0.03292581f, -0.13612631f, -0.05374749f, 0.12794136f, 0.11093149f, 
    -0.09497617f, -0.10762657f, -0.15412661f, -0.14656392f, 0.00397674f, -0.13574618f, 0.02772064f, 0.11192439f, 
    -0.00446563f, -0.12939177f, -0.10562973f, -0.16385630f, 0.14788420f, 0.13148558f, 0.01925850f, 0.00147588f, 
    0.14664847f, -0.03665530f, -0.04878078f, -0.02492480f, 0.08878775f, -0.14014284f, -0.14349860f, -0.06894422f, 
    -0.11128481f, 0.14529356f, -0.13088210f, 0.02488761f, -0.05834946f, -0.12208939f, -0.09237988f, 0.05687588f, 
    -0.10401376f, 0.08751021f, -0.13303989f, -0.06437982f, 0.02431190f, 0.06980216f, 0.02829206f, 0.15704001f, 
    0.10558913f, -0.01783878f, -0.13305788f, -0.10068342f, 0.17081599f, -0.10036570f, 0.06529389f, -0.04077398f, 
    0.07529533f, 0.04572198f, -0.05276061f, -0.10567507f, 0.09133761f, -0.00917914f, 0.06426224f, 0.01023468f, 
    0.05183881f, -0.13468607f, -0.02691894f, -0.12327617f, -0.10934973f, -0.17021964f, 0.01645726f, 0.13670902f, 
    -0.16721880f, -0.09168367f, -0.21868545f, 0.01596590f, 0.02876918f, -0.05882866f, -0.12981698f, 0.12018846f, 
    -0.06152586f, -0.06024644f, -0.08612528f, -0.10778476f, 0.05905203f, -0.07773357f, -0.03818226f, 0.13449743f, 
    -0.14091100f, 0.58514470f, 0.11928762f, 0.29047912f, 0.01595696f, -0.29510358f, -0.23362471f, -0.43403390f, 
    -0.04244620f, -0.11025827f, 0.38696486f, 0.03907800f, -0.02431030f, 0.12138088f, 0.08788443f, 0.26975268f, 
    -0.36846122f, 0.12702137f, 0.33038449f, 0.13288678f, 0.61802834f, 0.00508558f, -0.09167757f, 0.04020915f, 
    0.04630998f, 0.36487141f, -0.44948149f, 0.36983061f, -0.11366840f, 0.03807201f, -0.25679618f, 0.05579898f, 
    0.27017975f, 0.41412544f, 0.14809950f, 0.14835089f, 0.53718823f, 0.22352614f, 0.32585821f, -0.33188370f, 
    0.18105721f, 0.10560557f, -0.52900833f, -0.12129601f, 0.41562948f, -0.14726828f, -0.07437751f, -0.13618456f, 
    -0.08121560f, -0.32844537f, 0.27842319f, 0.32592297f, -0.26747847f, 0.60504013f, 0.36997548f, -0.08953859f, 
    -0.02973045f, 0.10756433f, 0.03697479f, -0.24606605f, 0.04758080f, -0.08941625f, -0.35053715f, -0.09589760f, 
    0.49692938f, -0.21809849f, 0.27761209f, 0.07074983f, -0.30900002f, -0.19996329f, 0.07512978f, 0.24702135f, 
    -0.07462444f, -0.16829216f, -0.13223943f, 0.15078378f, 0.37998912f, 0.01966668f, -0.11796573f, -0.55787468f, 
    -0.39066720f, -0.55472344f, 0.46502799f, 0.20527105f, 0.04374958f, 0.59246445f, 0.08456515f, 0.09468400f, 
    -0.12385330f, 0.35361147f, -0.35494849f, -0.14764296f, 0.08549009f, 0.09258749f, 0.05642927f, -0.08311077f, 
    0.36915487f, 0.41639164f, -0.00867928f, 0.46893820f, 0.22188678f, 0.32047579f, -0.57916707f, -0.33969089f, 
    0.16441897f, -0.13561042f, 0.43568459f, 0.33145079f, -0.09959655f, 0.25117829f, -0.07441700f, 0.48092562f, 
    0.49096560f, -0.46599200f, -0.76589036f, 0.25652716f, 0.24510795f, -0.15768544f, -0.28738105f, -0.06417751f, 
    0.16313766f, 0.67916834f, 0.64510250f, -0.09286701f, -0.16850626f, 0.11240752f, -0.22259647f, 0.15037006f, 
    0.15964910f, 0.34000713f, 0.06065660f, -0.30023745f, 0.11933833f, 0.23926367f, 0.10221313f, -0.04066212f, 
    -0.06863412f, -0.14071338f, 0.21535252f, -0.34057102f, -0.13458611f, 0.22137615f, 0.00877186f, -0.14255622f, 
    -0.47879148f, 0.51836401f, 0.13097383f, 0.21658288f, 0.26478279f, -0.31269795f, -0.20543614f, -0.14543408f, 
    -0.05782592f, 0.14673625f, -0.78890538f, 0.22226773f, 0.16576101f, -0.12019681f, 0.35616958f, -0.08769570f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.28295827f, 0.16138788f, -0.18437088f, 0.19280921f, 0.11450358f, 0.14572883f, -0.08720200f, 0.03823242f, 
    0.03539856f, 0.02866882f, -0.08415179f, 0.10994311f, -0.19686045f, -0.08030860f, -0.14263825f, 0.05211621f, 
    -0.15519100f, -0.10816532f, 0.04657159f, -0.02883489f, 0.14206237f, -0.13672207f, 0.05879306f, -0.05398944f, 
    -0.03291816f, -0.05370164f, -0.07301818f, 0.11464478f, 0.11456664f, 0.01839465f, 0.24152100f, 0.03001880f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.12766688f, -0.07906892f, 0.09253044f, -0.21081418f, -0.01072226f, -0.70740360f, 0.33318588f, -0.71278977f, 
    -0.12259580f, -0.10486636f, -0.04033592f, 0.43785256f, -0.47732413f, 0.15670991f, -0.18638881f, 0.19505987f, 
    -0.32831404f, -0.26217565f, 0.36242279f, 0.03763978f, 0.09749834f, -0.12743559f, -0.11172518f, -0.36239150f, 
    -0.16077906f, 0.13820361f, 0.11727661f, 0.26698101f, 0.20952499f, 0.32250139f, -0.41874930f, 0.04682766f, 
    0.06474273f, 0.17957392f, 0.03255956f, -0.18407182f, -0.11182291f, 0.31754452f, -0.01158853f, -0.01363181f, 
    -0.08845505f, 0.13205081f, 0.40460867f, 0.24755816f, -0.21048962f, 0.10492045f, 0.02088063f, 0.41353467f, 
    0.04624114f, 0.22458234f, -0.50577617f, 0.07191775f, -0.06989301f, 0.09105802f, 0.02318323f, -0.12270170f, 
    0.11417973f, -0.08464693f, -0.11826888f, -0.39233628f, 0.33536577f, 0.21308458f, -0.09480887f, -0.56352460f, 
    0.36649209f, 0.11286262f, 0.13191001f, 0.10479560f, -0.11406457f, -0.07121480f, 0.35477763f, -0.01719346f, 
    -0.08275110f, 0.11119855f, 0.30616879f, -0.12777850f, 0.25776905f, 0.11817253f, -0.05042238f, -0.14989667f, 
    -0.74600077f, -0.23093365f, -0.49708688f, -0.04061859f, 0.07330495f, -0.03643999f, 0.13732666f, 0.26615003f, 
    0.13355936f, 0.05533268f, 0.13032609f, -0.45106342f, -0.42648008f, -0.68159711f, 0.33529758f, -0.79928339f, 
    -0.34141713f, -0.58158177f, -0.05136469f, -0.12865944f, -0.13251401f, -0.05994660f, -0.01182900f, -0.59000772f, 
    -0.04157454f, 0.05944572f, -0.89614207f, -0.56678897f, -0.80208826f, -0.16346061f, -0.00329846f, 0.07367542f, 
    -0.11218596f, 0.05851977f, -0.24128820f, -0.02062452f, 0.17801343f, -0.12469024f, -0.06441149f, -0.02919597f, 
    0.06689527f, 0.11533506f, 0.06997357f, 0.41818115f, 0.20921028f, -0.38335869f, 0.56659418f, 0.35741359f, 
    0.11960404f, -0.06658091f, -0.02017133f, -0.07149763f, 0.03351776f, 0.31991717f, 0.17841594f, -0.09846300f, 
    -0.15935631f, -0.12733874f, -0.06202983f, -0.12482303f, -0.28549877f, -0.15147072f, 0.06501001f, -0.50753421f, 
    0.29051778f, 0.00831545f, 0.06419174f, -0.08168154f, 0.47726542f, -0.12026393f, -0.07040281f, -0.15207122f, 
    -0.11746704f, -0.15482527f, -0.12231039f, -0.03435633f, -0.39983597f, -0.14191420f, 0.06437078f, 0.30977982f, 
    0.05314210f, 0.11558174f, -0.18447962f, -0.14149059f, 0.04119003f, -0.41458130f, -0.46283871f, 0.11431157f, 
    -0.10490498f, -0.11081736f, 0.26709759f, -0.71458387f, -0.25646609f, 0.13087201f, -0.12661906f, 0.30090207f, 
    0.28659883f, -0.02843063f, 0.44095024f, -0.00583697f, -0.84713650f, -0.14550693f, 0.04590024f, -0.03411781f, 
    -0.12232031f, -0.06333832f, 0.07961173f, -0.05698942f, 0.20302081f, 0.51643169f, -0.09669396f, 0.14018419f, 
    0.48612368f, -0.09207805f, -0.13109724f, 0.47564420f, -0.07960928f, -0.14788596f, -0.97655118f, -0.15146792f, 
    0.13151348f, -0.02661159f, -0.37676173f, -0.12131210f, 0.06845430f, 0.04718071f, -0.16123100f, -0.96227914f, 
    -0.06040200f, -0.07447520f, -0.31565112f, -0.13503417f, -0.08495291f, -0.07842745f, -0.15372689f, 0.19065315f, 
    -0.16082659f, 0.16196148f, -0.05243561f, -0.01292140f, 0.49273843f, 0.24986246f, -0.17378372f, -0.21170753f, 
    -0.26407394f, -0.24276127f, -0.09784954f, -0.61236435f, 0.11631896f, 0.16274253f, 0.42713556f, -0.40315589f, 
    -0.03143539f, 0.05219747f, 0.24935116f, -0.43092892f, -0.44479716f, -0.06596340f, -0.04620279f, 0.31839871f, 
    0.44873223f, -0.14923100f, -0.16824339f, -0.13737470f, 0.03266108f, 0.10716844f, -0.15573277f, -0.84364456f, 
    0.16953142f, -0.15622544f, 0.02244544f, 0.04735570f, -0.17034824f, -0.05936768f, -0.11103254f, 0.37177235f, 
    -0.95171201f, 0.27318078f, -0.11428796f, 0.24840455f, 0.16508104f, -0.05769831f, 0.10240139f, 0.37530589f, 
    0.00017456f, -0.05639496f, 0.26429209f, 0.30517128f, 0.34161258f, -0.06820630f, -0.11227611f, 0.17089918f, 
    0.18533096f, 0.11709967f, -0.34046263f, -0.04116943f, -0.03361828f, -0.02992150f, 0.15890856f, -0.17155959f, 
    -0.16857861f, 0.12815595f, 0.02643550f, -0.56883478f, 0.18439308f, 0.00663084f, -0.36088893f, 0.11836787f, 
    0.31532046f, 0.30338794f, 0.01557293f, 0.07797629f, -0.06089374f, -0.65067953f, -0.46296990f, 0.16265324f, 
    -0.10208289f, 0.07756698f, 0.15485258f, -0.10792800f, 0.15859151f, 0.12163731f, -0.11309192f, -0.17185943f, 
    -0.08660825f, -0.64344072f, 0.13662317f, -0.01631641f, 0.56595898f, -0.02194072f, 0.09179708f, -0.09026129f, 
    -0.08079074f, 0.03846220f, 0.04447074f, 0.05862627f, -0.31601146f, -0.33077615f, -0.93220890f, 0.25975278f, 
    -0.61697716f, 0.32298526f, -0.10212681f, 0.22621302f, -0.07652313f, 0.35962614f, 0.16578504f, 0.65883201f, 
    -0.20065659f, 0.01215931f, -0.62449831f, -0.11036471f, -0.09267421f, 0.06473643f, -0.14983478f, 0.16801932f, 
    -0.32964739f, 0.10079810f, 0.23728287f, -0.10997947f, -0.58986366f, -0.17111221f, 0.06277965f, -0.02172368f, 
    0.16525006f, -0.11257178f, 0.04674148f, 0.11767917f, 0.04321365f, -0.46590632f, 0.40727517f, -0.30365169f, 
    0.01862238f, -0.30231911f, -0.17716336f, -0.43604496f, -0.02714170f, 0.06554873f, 0.25907102f, -0.43006814f, 
    -0.05919445f, 0.02269989f, -0.98098290f, -0.08157731f, 0.25841317f, 0.00688613f, 0.09028240f, -0.43579882f, 
    0.21916178f, 0.05367931f, 0.16157272f, 0.09439479f, -0.40079209f, -0.06528563f, 0.07108647f, 0.41692269f, 
    0.16255443f, -0.12773074f, -0.04134351f, 0.21658710f, -0.58393645f, 0.33119029f, 0.28406912f, -0.14951243f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.19656399f, 0.00005046f, -0.15697199f, 0.12641212f, 0.33657527f, 0.05455246f, 0.12775862f, -0.14892964f, 
    -0.32457173f, 0.17954896f, 0.12746046f, -0.11214074f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
