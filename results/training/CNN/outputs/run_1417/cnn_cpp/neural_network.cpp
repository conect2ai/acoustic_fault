#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.84590679f, -0.01650620f, 0.80465800f, -0.11372828f, -0.31662244f, -0.27302355f, -0.23565549f, 0.57475585f, 
    -0.21801284f, 0.58379912f, -0.71464819f, -0.47137943f, 0.17911945f, 0.35733065f, 0.36320174f, 0.17064270f, 
    -0.35713473f, -0.36667341f, -0.19389820f, -0.59931725f, -0.73383665f, 0.77975643f, 0.50422382f, 0.22338445f, 
    -0.31290770f, -0.06730427f, -0.14833666f, -0.16681719f, 0.62850791f, 0.73041701f, -0.23550320f, 0.24894972f, 
    0.32383445f, 0.01974966f, -0.46881804f, -0.00444515f, -0.27297398f, -0.45274639f, -0.16248198f, -0.42068890f, 
    -0.30796492f, -0.41034472f, -0.39352253f, -0.31225589f, -0.21583885f, 0.49967259f, -0.05792129f, 0.49455366f, 
    0.07498144f, -0.18377247f, 0.73971373f, 0.47840899f, -0.15336476f, -0.25025609f, -0.04602109f, 0.13459422f, 
    0.64876986f, -0.12887217f, -0.46890494f, -0.73048556f, 0.43046197f, 0.09200612f, 0.37358406f, 0.66925281f, 
    0.60943246f, -0.17914490f, -0.25336105f, -0.11949464f, -0.41004157f, -0.07806127f, -0.16683938f, 0.26433325f, 
    -0.88804483f, 0.02480582f, -0.09267465f, 0.97763360f, -0.69230092f, 0.05338982f, 0.12898968f, 0.07666019f, 
    0.03736712f, -0.25055727f, 0.05458700f, 0.00906965f, -0.54167640f, -0.76418823f, 0.17889480f, 0.48612678f, 
    0.30130124f, 0.49952257f, 0.56767964f, 0.37477922f, -0.09391413f, 0.67254132f, -0.29254001f, -0.30702099f, 
    0.20929764f, 0.30736294f, -0.29718107f, -0.31267181f, -0.19473989f, -0.62134987f, -0.61296910f, -0.37379861f, 
    -0.75106764f, 0.23220795f, 0.03056509f, 0.32678717f, -0.42915860f, 0.03167376f, 0.37648359f, 0.06337985f, 
    0.08697505f, 0.27896467f, 0.40566629f, 0.37378222f, 0.31542411f, -0.77269328f, 0.14996353f, 0.19047788f, 
    0.34216222f, 0.34050637f, 0.82571346f, 0.03272164f, 0.13255203f, -0.05441112f, 0.21477434f, -0.59521848f, 
    0.11538091f, -0.48487467f, -0.09363668f, -0.49727437f, -0.35680860f, -0.38134941f, -0.54365790f, -0.05057596f, 
    1.29331529f, -1.06303740f, -0.17269491f, -0.14835832f, 0.11074953f, -0.04189412f, 0.01984047f, 0.25185260f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.11551591f, 0.22191553f, -0.01961033f, 0.29879293f, -0.46998277f, 0.15288095f, 0.07683179f, 0.33519381f, 
    0.16051413f, -0.07539679f, 0.56597555f, -0.17691056f, 0.37655208f, -0.47367650f, 0.53016049f, -0.12026358f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.47453058f, -0.07775144f, -0.15134181f, -0.28880167f, -0.10792732f, 0.05230442f, 0.07988345f, 0.03416350f, 
    0.06720712f, 0.02239823f, -0.26633653f, 0.28636274f, 0.13572137f, -0.09512041f, 0.00702877f, -0.09009028f, 
    -0.00834741f, 0.13258564f, -0.28457299f, -0.21108735f, 0.03840017f, 0.02562858f, 0.18462594f, 0.22666134f, 
    -0.04830650f, -0.07521658f, 0.20880969f, -0.08761919f, 0.30452827f, -0.15661903f, -0.11901065f, 0.03618095f, 
    -0.04678204f, -0.03405025f, 0.21095634f, 0.00450900f, -0.07258271f, -0.29190606f, 0.03144494f, -0.04513642f, 
    0.22660987f, 0.14406224f, -0.09869207f, 0.01179922f, -0.00475287f, 0.09405117f, 0.14939013f, 0.18799238f, 
    -0.01747132f, 0.08481542f, -0.00080827f, -0.04125614f, -0.01276281f, 0.08596455f, -0.08302052f, -0.35698366f, 
    -0.10360657f, -0.10382832f, 0.01345759f, -0.31114718f, 0.10081992f, -0.11723308f, 0.00195767f, 0.61281669f, 
    0.08678459f, -0.05990974f, -0.06802381f, 0.07675797f, -0.35546559f, -0.00675964f, 0.03189259f, 0.20758986f, 
    -0.32974404f, -0.09145049f, 0.27684864f, 0.02001440f, -0.06785619f, -0.14733794f, -0.03804506f, -0.06393396f, 
    -0.07736938f, -0.46925557f, 0.11077654f, 0.05774208f, -0.11414788f, 0.05414980f, 0.03018725f, 0.04190741f, 
    0.02729682f, -0.24207839f, 0.30998167f, 0.15415758f, -0.01940505f, 0.14843842f, 0.00143364f, 0.08259117f, 
    0.01000535f, 0.18906377f, -0.02319292f, -0.05406758f, 0.03045319f, 0.09331948f, -0.07874489f, -0.02785641f, 
    -0.43350244f, 0.10115376f, -0.08637787f, -0.03693148f, -0.01925405f, 0.04861495f, -0.11673152f, -0.04749960f, 
    0.09955937f, 0.11096306f, -0.00815484f, 0.11950992f, -0.00968121f, 0.15506926f, 0.35832620f, -0.23274831f, 
    -0.04600496f, 0.09892142f, -0.05973101f, 0.03809828f, -0.34609270f, -0.07693457f, 0.08359519f, -0.02430180f, 
    0.09438930f, 0.13263318f, 0.16399205f, 0.08873918f, 0.13244510f, 0.08842637f, 0.19788665f, 0.33009782f, 
    0.05279653f, -0.65823710f, 0.08686758f, 0.06812942f, 0.44301996f, 0.01140185f, -0.10291118f, -0.08385864f, 
    -0.62678337f, -0.11723778f, -0.24600291f, -0.02506705f, 0.29452282f, -0.33331475f, -0.11901683f, -0.08658409f, 
    0.32520005f, -0.09422939f, -0.16344325f, 0.30050296f, -0.04885625f, -0.04953819f, 0.03117702f, 0.07443699f, 
    0.22540267f, 0.04570155f, -0.02581732f, -0.21458533f, 0.00387472f, 0.03903704f, -0.07848004f, 0.09979457f, 
    -0.29628575f, -0.08178139f, 0.11145794f, -0.28529310f, 0.07582442f, 0.05345941f, -0.01996569f, -0.12926908f, 
    0.23963326f, -0.02474999f, 0.06243315f, -0.11522818f, -0.15963647f, -0.25450781f, -0.10171270f, -0.07511605f, 
    -0.37189573f, 0.02128762f, 0.09704502f, 0.03444440f, -0.14860049f, -0.16425058f, 0.08982164f, 0.46053049f, 
    -0.14875628f, -0.04266830f, 0.05986099f, 0.01310573f, 0.04509800f, -0.09930447f, 0.06903530f, 0.08552631f, 
    -0.00249638f, 0.02821097f, 0.18044557f, -0.36540955f, 0.20495194f, 0.08971345f, -0.07910555f, 0.25456598f, 
    0.39772838f, 0.11192815f, 0.38979837f, 0.09096297f, 0.02712786f, 0.16597855f, 0.12976354f, -0.06513914f, 
    -0.60483235f, 0.04105332f, 0.60152000f, 0.03305754f, 0.01988973f, -0.26606280f, -0.03758479f, 0.00265345f, 
    -0.05109806f, -0.60046351f, 0.33340269f, -0.13073321f, -0.13058056f, -0.24816373f, 0.00694752f, 0.18689719f, 
    -0.00480456f, -0.09201511f, 0.19708107f, 0.10204966f, 0.21056503f, 0.03086760f, 0.22592245f, -0.24709539f, 
    0.08835741f, 0.22914360f, 0.01378833f, 0.03410015f, 0.03418067f, -0.18152370f, 0.02072729f, 0.05938513f, 
    -0.12992142f, -0.10270297f, -0.02815762f, -0.08878799f, -0.12589419f, 0.09089985f, -0.06219960f, -0.00124460f, 
    0.06578978f, -0.09094292f, 0.04742933f, 0.12272985f, -0.07276122f, -0.42574611f, -0.27589491f, -0.18056372f, 
    -0.00786926f, -0.27003846f, -0.01981247f, -0.00280393f, 0.00002496f, 0.20537987f, 0.03884568f, -0.12637302f, 
    0.23403159f, -0.18341903f, 0.10438366f, 0.07149117f, -0.00339802f, 0.04947254f, 0.02998158f, -0.64969951f, 
    0.27791426f, -0.02754773f, 0.10690398f, -0.12339206f, 0.36503744f, 0.01179540f, 0.02184620f, -0.09249211f, 
    0.21129574f, -0.20185930f, 0.22739218f, -0.03362558f, -0.17005384f, -0.06622496f, 0.23057832f, 0.07174299f, 
    0.05651310f, -0.06310563f, 0.25750732f, -0.09885965f, -0.22046311f, 0.17444867f, -0.13412103f, 0.00123763f, 
    0.17029938f, 0.15729354f, -0.31351423f, 0.01602216f, -0.04908052f, -0.04650662f, -0.02300924f, -0.05308030f, 
    -0.08843408f, 0.00761183f, 0.11019628f, -0.08102661f, 0.25974128f, 0.25667268f, -0.03145937f, -0.02830831f, 
    0.13992435f, -0.04256684f, 0.06749446f, -0.01469008f, 0.26945439f, -0.07180456f, 0.05930906f, 0.01085539f, 
    -0.19153772f, -0.02440723f, 0.08498276f, 0.17002475f, -0.05076624f, 0.12473941f, 0.21779878f, -0.15120050f, 
    -0.19594023f, -0.22574009f, -0.08079136f, -0.09471335f, 0.07532444f, 0.15035088f, 0.44291934f, -0.35924578f, 
    -0.09299425f, -0.08535634f, 0.09708162f, -0.21943569f, -0.08902128f, -0.08641868f, -0.12988374f, 0.39100006f, 
    0.01820990f, -0.06529254f, 0.06882443f, 0.07033762f, 0.16282886f, 0.04963071f, -0.04012606f, -0.10292261f, 
    -0.53209406f, -0.34189525f, 0.14740331f, 0.16905488f, -0.03821105f, 0.01276668f, -0.01137895f, -0.00580963f, 
    -0.05345826f, 0.15446880f, -0.17718744f, -0.03314224f, -0.10879258f, 0.01952716f, -0.07535511f, 0.04560038f, 
    0.03944703f, -0.16139716f, 0.03357326f, -0.03957209f, -0.14622365f, -0.04459315f, 0.04933798f, -0.09223177f, 
    0.10783659f, 0.03547117f, 0.13315919f, 0.00488055f, 0.01831097f, 0.04061690f, 0.21850243f, 0.14512864f, 
    0.04795172f, -0.04921424f, 0.08675519f, 0.01458554f, 0.09019241f, -0.13930754f, -0.02683292f, 0.01633526f, 
    -0.07724380f, 0.05430233f, 0.07882791f, -0.01435654f, -0.13312703f, -0.23737428f, 0.22567602f, -0.04192379f, 
    0.03178282f, 0.12544091f, -0.15638022f, 0.11077724f, -0.07276545f, 0.10925666f, 0.14506024f, -0.07944799f, 
    0.09688160f, -0.06867585f, -0.15118857f, -0.06695671f, 0.05581574f, -0.01217048f, 0.08778986f, 0.77403581f, 
    -0.06626629f, -0.37347397f, -0.18803842f, -0.19609259f, -0.01049950f, -0.02160930f, -0.05639697f, -0.06717819f, 
    -0.05612154f, 0.09974899f, -0.64024049f, -0.04316401f, -0.08134815f, -0.23204426f, -0.01178352f, 0.01077755f, 
    0.09450596f, -0.25890246f, 0.15151693f, -0.16349354f, 0.12788220f, -0.16616505f, 0.02502804f, -0.06256435f, 
    0.05600630f, 0.20432071f, -0.17523682f, -0.40455127f, -0.29190585f, -0.15953533f, 0.14545162f, 0.06340181f, 
    -0.03265130f, -0.18254462f, 0.01369807f, 0.36582690f, -0.02349190f, 0.23477355f, 0.03569391f, 0.00776259f, 
    0.03123509f, -0.02751217f, 0.04470979f, 0.18203664f, -0.19687791f, -0.30664042f, -0.60353822f, -0.48445717f, 
    -0.11702506f, 0.03736094f, 0.13580547f, 0.02789488f, -0.11308140f, 0.19150758f, 0.35852581f, 0.28308657f, 
    -0.12342790f, 0.11207003f, -0.11032657f, 0.06615459f, 0.09097356f, 0.10878417f, 0.14432801f, 0.00343305f, 
    0.11772822f, -0.06518422f, -0.12208302f, -0.16183937f, 0.11575050f, -0.05330294f, -0.01567387f, 0.10568251f, 
    0.24392527f, 0.28484082f, 0.08811896f, 0.10159505f, -0.11683368f, -0.01985653f, 0.07622543f, 0.08327325f, 
    -0.35683653f, -0.67403030f, 0.04799128f, -0.24713777f, 0.12118448f, -0.03133585f, 0.05195678f, 0.13910948f, 
    -0.17959040f, -0.29341161f, -0.13256979f, -0.08011379f, 0.06566638f, -0.01861223f, -0.21703634f, 0.05110770f, 
    -0.01770652f, 0.02666250f, 0.03216942f, 0.21997441f, 0.06081963f, -0.00110964f, -0.11320858f, 0.10910597f, 
    0.13594733f, 0.07621993f, 0.07585621f, -0.00234218f, -0.26870313f, -0.03497903f, 0.12909909f, 0.20599827f, 
    -0.13719223f, -0.07829253f, 0.00229813f, -0.00711089f, -0.19031318f, -0.04938109f, -0.11914485f, -0.01568171f, 
    -0.16157691f, 0.20978136f, 0.22986875f, -0.08192059f, -0.05291047f, -0.31033370f, -0.02970986f, -0.49329099f, 
    -0.06127908f, -0.03176983f, -0.09212247f, -0.11094665f, -0.13963217f, -0.02033693f, 0.19223717f, 0.10558711f, 
    -0.23238431f, 0.00507631f, 0.07707692f, 0.15168190f, 0.08762771f, -0.04360486f, 0.01106486f, -0.22111720f, 
    -0.28001577f, -0.67191702f, 0.02189808f, 0.15183429f, 0.25666422f, -0.09256036f, -0.14577758f, -0.09703036f, 
    0.56747407f, -0.10980074f, -0.42208266f, -0.07908809f, 0.03104699f, 0.08479634f, 0.07341170f, 0.03983901f, 
    0.03080514f, -0.01763885f, 0.15422644f, 0.34442392f, -0.09506077f, 0.03558535f, -0.04923317f, 0.11925865f, 
    -0.04737379f, 0.15789627f, 0.09305231f, -0.00534893f, 0.35528421f, -0.06774639f, 0.05322899f, 0.21602008f, 
    -0.06870057f, 0.07026423f, 0.14522064f, 0.34464467f, 0.29143447f, 0.00607517f, 0.06648142f, -0.04752830f, 
    -0.22215910f, -0.05410440f, -0.07976988f, 0.10243177f, -0.22629671f, -0.00737365f, -0.19173403f, -0.19576757f, 
    -0.10256873f, 0.01556414f, -0.10418157f, 0.03890559f, -0.09837521f, 0.09704693f, 0.14576596f, 0.18836565f, 
    -0.07393151f, -0.00714379f, 0.02317150f, 0.01624870f, 0.07751143f, 0.14359313f, 0.15759173f, -0.88561100f, 
    -0.34870672f, 0.00295499f, -0.05577843f, -0.29473373f, 0.12525399f, 0.13630451f, -0.13805324f, 0.00115288f, 
    -0.13465358f, 0.14462698f, 0.13145861f, 0.07108700f, 0.15700108f, 0.06436218f, 0.02124102f, 0.03304709f, 
    -0.17331286f, -0.18161204f, 0.12066304f, 0.03615126f, -0.13570753f, 0.03069268f, 0.06386910f, 0.09017193f, 
    -0.02194539f, -0.56894845f, -0.01360447f, -0.35080597f, -0.15524629f, -0.05340430f, -0.07739629f, 0.08251646f, 
    -0.13479790f, -0.06359018f, -0.19699484f, 0.16078666f, 0.12665117f, 0.18958598f, 0.14600794f, -0.04823867f, 
    -0.01212284f, 0.06596876f, 0.16785747f, -0.27856931f, -0.17547038f, -0.29758942f, 0.10727870f, 0.19361000f, 
    -0.19861698f, -0.15135455f, -0.03383859f, 0.00990918f, 0.07492403f, -0.07670134f, -0.01996766f, -0.14684008f, 
    -0.05865182f, 0.05423313f, 0.01983240f, -0.02285624f, -0.08003955f, -0.68077010f, -0.34155282f, -0.09679922f, 
    -0.18952696f, 0.01867229f, -0.03079616f, 0.03099331f, -0.11737516f, 0.13446054f, -0.00673263f, -0.01632784f, 
    -0.51567054f, 0.00149545f, -0.00723446f, -0.13086204f, 0.20235024f, 0.01374434f, 0.18529379f, 0.26407421f, 
    -0.56139863f, -0.30781144f, -0.07320976f, -0.32718736f, 0.12989606f, 0.15526657f, -0.02791750f, -0.15617558f, 
    -0.16414630f, -0.28238204f, 0.08301964f, 0.02343778f, -0.12553515f, -0.17525440f, 0.05831680f, -0.00612600f, 
    0.13368016f, 0.05329491f, 0.17441474f, 0.18246147f, 0.11880033f, 0.06532749f, -0.04760465f, 0.15160598f, 
    -0.01627515f, 0.24512887f, -0.04973320f, 0.24112396f, 0.13101876f, 0.09219456f, 0.15790434f, 0.00216272f, 
    0.02506592f, 0.07738480f, 0.14528912f, -0.18007529f, -0.13946581f, -0.05674956f, 0.02799351f, 0.11603755f, 
    -0.04304582f, -0.18214387f, 0.13805495f, -0.03549866f, 0.03208009f, -0.07559805f, 0.12093280f, -0.01508559f, 
    0.00266447f, -0.09538641f, -0.19099656f, 0.13060550f, 0.01271266f, 0.01232877f, -0.22948678f, 0.17484295f, 
    -0.01777248f, -0.01934150f, 0.05548541f, -0.02049009f, 0.02866135f, 0.15807493f, 0.03954503f, -0.23757324f, 
    -0.19810499f, -0.07037681f, -0.18678308f, -0.15815620f, 0.04538237f, 0.13443567f, -0.08213855f, 0.32525596f, 
    -0.06775533f, -0.08302413f, -0.05883989f, 0.05525251f, 0.06909177f, 0.01060355f, 0.06971070f, 0.05684377f, 
    -0.07805694f, -0.15905829f, -0.01011220f, -0.03436474f, 0.08265579f, 0.01330550f, 0.08785451f, 0.23819695f, 
    0.01074959f, -0.16217957f, -0.47247529f, -0.09517392f, -0.09928408f, 0.05375056f, -0.01684411f, -0.03899647f, 
    0.04623010f, -0.28697619f, 0.10134074f, -0.00091671f, -0.31626639f, 0.09034623f, 0.05551049f, -0.08843607f, 
    0.23499876f, 0.12608404f, 0.23146045f, -0.09047923f, -0.10176253f, 0.13962328f, 0.14005104f, -0.08822820f, 
    0.11227570f, -0.03750946f, -0.07691760f, 0.19723915f, -0.12821256f, 0.00601086f, -0.28635332f, -0.07309544f, 
    -0.00290696f, 0.06245378f, 0.00742724f, 0.10771450f, -0.07508356f, -0.73882163f, -0.67934710f, -0.74364156f, 
    0.32122406f, -0.23683934f, -0.34534627f, -0.25615624f, -0.06519741f, -0.06529889f, 0.22972344f, 0.10256103f, 
    0.08734987f, 0.04497604f, 0.06358394f, 0.03121426f, 0.05981352f, 0.06080782f, 0.04760083f, 0.58439070f, 
    -0.31905106f, -0.19961053f, -0.23842858f, -0.31847939f, -0.11656851f, -0.10718292f, 0.04769288f, -0.21977507f, 
    0.04333663f, 0.12741348f, 0.08491133f, -0.13699012f, 0.07714653f, 0.07612360f, 0.07869855f, -0.03929297f, 
    -0.04289161f, 0.44096553f, -0.14215039f, -0.33912298f, 0.04900822f, -0.09801450f, 0.28158426f, 0.21068676f, 
    0.08586796f, -0.12123753f, 0.55510306f, -0.00881514f, -0.44446942f, 0.06170205f, 0.04587039f, 0.13453859f, 
    -0.07513691f, 0.09449006f, -0.02764262f, 0.07794601f, -0.49327922f, 0.13617140f, 0.03635360f, -0.19638656f, 
    -0.17457268f, -0.03492982f, 0.06241785f, -0.05352674f, 0.28984800f, 0.21446322f, 0.01981050f, -0.01922151f, 
    -0.01142871f, 0.13288069f, 0.11555560f, -0.07426190f, -0.02015016f, -0.35451713f, -0.26988295f, -0.30538288f, 
    -0.15541400f, 0.11730297f, 0.05956072f, -0.13250479f, 0.00219707f, -0.02605522f, -0.10134015f, 0.29236898f, 
    0.06518734f, -0.20954016f, -0.03006358f, -0.10186105f, -0.02039366f, 0.07800721f, 0.21832132f, -0.13395230f, 
    -0.06384511f, -0.17780781f, -0.05959387f, -0.20251948f, 0.02768264f, -0.00039089f, 0.11444502f, 0.12487954f, 
    0.21914405f, 0.50688666f, 0.00539584f, -0.16629110f, 0.03672465f, 0.30868804f, -0.12462024f, 0.17624520f, 
    0.07140984f, 0.02515123f, 0.27728879f, 0.39696011f, -0.01178371f, 0.00332008f, -0.17647976f, -0.12140261f, 
    0.02624749f, 0.07187206f, 0.09115426f, -0.24054393f, 0.06858246f, 0.06018310f, 0.12823720f, -0.07331904f, 
    0.12025625f, 0.13697705f, 0.11609630f, 0.04096284f, 0.25649461f, 0.04554736f, -0.03803828f, 0.12729682f, 
    0.23525585f, 0.08175523f, -0.05425842f, 0.03846709f, -0.09480298f, -0.24239036f, 0.17264299f, -0.01218155f, 
    -0.00124235f, 0.07439054f, 0.09902328f, 0.11593809f, 0.10719544f, -0.03252152f, -0.26975816f, 0.08038472f, 
    0.09052505f, -0.28886360f, -0.25672838f, -0.10979410f, 0.01125191f, -0.05745178f, 0.20400986f, 0.11798060f, 
    0.05835342f, -0.05017898f, 0.13160957f, 0.03009128f, 0.03032009f, 0.11889015f, -0.13532487f, -0.10882767f, 
    -0.10835750f, -0.65704817f, -0.10263108f, 0.03739655f, -0.05244802f, 0.03761161f, 0.03903471f, -0.00938890f, 
    -0.05800209f, -0.11206915f, 0.15997039f, 0.13543445f, 0.08714683f, -0.07741288f, 0.12818038f, 0.10547632f, 
    -0.00671504f, -0.05887363f, -0.16506012f, -0.19831981f, -0.08766019f, -0.19079565f, 0.00837279f, -0.20354049f, 
    0.16975921f, -0.06773122f, 0.03782330f, -0.39179909f, -0.25764346f, -0.04272295f, 0.02827675f, 0.07052445f, 
    0.01946257f, -0.26556367f, 0.02728650f, -0.11198329f, -0.02279399f, 0.20487379f, -0.03956085f, -0.19342048f, 
    -0.04860706f, -0.18736713f, 0.08129343f, -0.04931804f, -0.02945689f, 0.21212000f, -0.00292782f, -0.07658760f, 
    -0.03909282f, 0.02869437f, -0.11875665f, 0.20407957f, 0.12904297f, 0.01388997f, 0.05046942f, 0.25144500f, 
    -0.12256891f, -0.01902724f, -0.12462185f, -0.29895985f, 0.01062580f, 0.05090784f, -0.20296986f, 0.00001414f, 
    0.01979929f, -0.08928438f, 0.08955280f, 0.20091236f, 0.10932750f, 0.33473307f, 0.21604286f, 0.08254676f, 
    0.17403124f, 0.18534036f, 0.12868525f, 0.03872382f, -0.06037856f, 0.11639803f, -0.07504715f, -0.01693687f, 
    0.41524094f, -0.48929203f, 0.03255565f, 0.04627674f, 0.37890628f, -0.09719843f, 0.16783562f, 0.16058600f, 
    -0.03079143f, 0.08416931f, -0.49185264f, -0.07814741f, 0.26051727f, -0.17980364f, -0.10216554f, 0.00971804f, 
    -0.02617305f, -0.04525797f, 0.20174295f, -0.02727271f, 0.23650040f, -0.07473540f, 0.01569574f, -0.03056563f, 
    0.14664552f, 0.02219133f, 0.24667263f, -0.14704569f, -0.13250798f, -0.07506309f, -0.13749129f, -0.01334454f, 
    0.06572919f, -0.05477606f, -0.21988688f, -0.08788697f, 0.31344777f, 0.27997449f, -0.19079491f, 0.14320888f, 
    -0.07068084f, 0.13066131f, -0.08145509f, 0.05028709f, -0.05984343f, 0.17962924f, 0.13827150f, -0.31462276f, 
    -0.15464570f, -0.19571678f, -0.20420772f, -0.14142068f, -0.14996241f, -0.14994958f, -0.01181695f, -0.09783606f, 
    -0.19299607f, 0.07268525f, 0.01676108f, 0.04483218f, -0.05879379f, -0.08188356f, -0.25352836f, 0.31600294f, 
    0.77382892f, -0.18706228f, -0.04745049f, -0.20696594f, 0.38202277f, 0.09046479f, 0.28909400f, -0.26443541f, 
    -0.24689186f, 0.02308385f, 0.56021786f, 0.20789102f, 0.19499566f, -0.01567263f, -0.08261146f, 0.11293792f, 
    0.07396527f, 0.09231874f, 0.09029233f, -0.24242897f, 0.12401871f, -0.06712112f, 0.14547797f, 0.13527212f, 
    0.14320411f, 0.17717214f, -0.39768541f, -0.02328569f, 0.05122253f, 0.08321676f, 0.01129805f, 0.12236872f, 
    0.05694042f, 0.01602115f, -0.01197396f, 0.07490424f, -0.41498664f, -0.26625398f, 0.28057763f, -0.16176301f, 
    0.10689513f, 0.10647073f, 0.01886618f, -0.07619435f, 0.12835756f, 0.17059845f, 0.29297736f, -0.05878066f, 
    -0.11072563f, 0.21665691f, 0.09379859f, -0.09157952f, -0.04248275f, 0.00042772f, -0.49138501f, -0.49350220f, 
    0.02703782f, -0.10142477f, 0.01692044f, 0.05197543f, 0.05250772f, 0.26449746f, 0.01307549f, -0.39683101f, 
    -0.39233297f, -0.05499876f, -0.06386608f, -0.24846317f, 0.04376301f, -0.03313062f, -0.00311955f, 0.02615413f, 
    -0.32211238f, -0.16523498f, 0.23120193f, -0.01268998f, -0.06944063f, -0.09185237f, -0.06463298f, -0.00021071f, 
    -0.14474909f, -0.00440655f, 0.21378036f, -0.20631370f, 0.17187020f, 0.25377595f, 0.14399259f, -0.07157851f, 
    0.07827457f, 0.27172279f, 0.31421131f, 0.25869346f, 0.08849832f, 0.09409518f, -0.16873889f, -0.10125783f, 
    0.02663778f, -0.02288226f, 0.06029664f, -0.40664753f, -0.29563475f, 0.07263661f, 0.37842169f, -0.03557381f, 
    0.14141861f, -0.11848168f, 0.14620928f, 0.18483423f, 0.39505798f, 0.29053646f, -0.03671705f, 0.04592538f, 
    0.03821675f, 0.14541936f, -0.03056620f, -0.06745409f, -0.05691997f, -0.19310510f, 0.00862211f, 0.00124203f, 
    0.00744749f, -0.08650514f, 0.02527039f, 0.02298748f, 0.00704689f, -0.36758813f, -0.69480419f, -0.36884922f, 
    -0.36838672f, -0.31865400f, 0.17595765f, 0.07002648f, 0.02647403f, 0.23621625f, 0.22892651f, 0.17460179f, 
    0.18877769f, 0.02844304f, 0.06672578f, 0.11217985f, 0.21704851f, -0.04289639f, -0.00048817f, 0.23582479f, 
    0.18925552f, -1.12032485f, -0.09609403f, -0.11635491f, -0.13175800f, 0.29958680f, 0.01113626f, 0.02563372f, 
    0.06697179f, -0.38065857f, -0.07459617f, 0.11547520f, -0.15378465f, 0.07651982f, 0.03103894f, 0.06275500f, 
    -0.01820744f, 0.27476829f, 0.18166615f, 0.24342066f, -0.00030124f, -0.22364897f, 0.10057946f, -0.10906342f, 
    -0.04246248f, -0.00404013f, 0.15665065f, 0.23129143f, 0.26511776f, 0.06982904f, -0.17608784f, -0.10978282f, 
    0.05991470f, -0.28070217f, -0.09473311f, -0.07911493f, -0.31977519f, 0.02951192f, 0.10274336f, -0.21340810f, 
    -0.09830361f, 0.01715095f, 0.02412296f, -0.08826096f, 0.16658321f, -0.25005350f, 0.02061893f, 0.01578316f, 
    -0.00309091f, -0.23929116f, 0.17661880f, 0.28348061f, -0.41210574f, -0.23731561f, 0.07068720f, 0.05152057f, 
    0.00140363f, -0.20557097f, 0.03642638f, -0.07552880f, -0.00590901f, 0.26749048f, -0.05634161f, -0.07793353f, 
    0.07286644f, 0.14809588f, 0.02309857f, 0.11072718f, -0.13414012f, 0.34397084f, 0.23358831f, -0.05294236f, 
    -0.04181420f, 0.06463379f, 0.10063020f, 0.19640395f, 0.27114871f, 0.09136885f, 0.18032266f, 0.02624034f, 
    0.46058929f, 0.41203409f, 0.12840161f, -0.05430062f, 0.08284993f, 0.03262841f, 0.03429280f, 0.13264850f, 
    0.00346180f, 0.06403289f, -0.31163430f, 0.18819420f, 0.12002093f, -0.06838005f, -0.08277857f, 0.06868538f, 
    0.08818363f, 0.12557428f, -0.19932967f, 0.35497323f, 0.16300713f, 0.06448460f, 0.16131854f, 0.18909253f, 
    0.16114619f, 0.36912453f, 0.17244168f, 0.03922038f, -0.34271425f, 0.08679317f, 0.00641926f, 0.00433627f, 
    -0.00770595f, 0.11189461f, 0.21974769f, 0.14043242f, 0.14988151f, 0.03900910f, 0.03230775f, 0.07123149f, 
    0.29487923f, 0.00028379f, 0.09865604f, 0.22226055f, 0.24165820f, -0.31758493f, -0.22647737f, -0.49967316f, 
    0.26486325f, -0.03371463f, -0.13932881f, 0.03941695f, -0.16264527f, -0.10616329f, -0.01024922f, -0.00317085f, 
    0.11848617f, 0.16507575f, 0.13855593f, 0.16086268f, 0.08297434f, -0.08199058f, -0.17580868f, -0.14455800f, 
    -0.31747597f, 0.35937831f, 0.16105421f, -0.00533923f, -0.17248732f, 0.14868678f, 0.20368868f, 0.27424708f, 
    -0.00195603f, 0.24290001f, 0.53738773f, -0.23695421f, 0.00230425f, 0.05246827f, 0.01231559f, 0.05830848f, 
    -0.15301600f, -0.20398691f, -0.18209089f, 0.02441685f, 0.06489509f, -0.09015793f, 0.17565975f, 0.17762764f, 
    0.03916631f, 0.05507088f, -0.14103340f, 0.01194438f, 0.37705073f, -0.04329678f, 0.01060093f, 0.05827330f, 
    0.08872306f, -0.23677583f, -0.00329983f, -0.34242988f, -0.16473615f, -0.26007393f, 0.03173253f, -0.04905489f, 
    0.04884931f, 0.03194905f, -0.21260744f, 0.21611926f, 0.13746652f, 0.17088024f, 0.16847281f, 0.04103752f, 
    -0.04195440f, 0.09337478f, 0.13712858f, 0.07200113f, 0.05873384f, -0.31260681f, 0.15510081f, 0.04968776f, 
    -0.03547344f, 0.12548837f, -0.06312129f, 0.05149464f, 0.02686808f, 0.04381171f, -0.30303288f, -0.15334450f, 
    -0.14786121f, 0.00363269f, 0.12594950f, -0.21523599f, 0.17947273f, -0.03966166f, 0.24175718f, -0.20807983f, 
    -0.29223511f, 0.02554231f, 0.02875653f, 0.08057804f, -0.16612668f, -0.06959252f, -0.03830301f, 0.12988891f, 
    0.40549299f, -0.11379004f, 0.29667732f, -0.33411467f, -0.02614530f, -0.05892599f, 0.01791081f, 0.15316361f, 
    -0.06083567f, -0.04790652f, 0.14202881f, 0.36092380f, 0.25195006f, 0.02779641f, 0.16258672f, 0.05319788f, 
    0.06554729f, -0.10226072f, -0.26180163f, -0.12024318f, 0.48099920f, 0.09692834f, -0.09676810f, -0.02433043f, 
    -0.02668369f, 0.15874590f, -0.01029762f, -0.04294459f, 0.17467055f, 0.26654786f, -0.15924439f, -0.02123968f, 
    0.09298657f, 0.02922796f, 0.20380858f, -0.02434232f, 0.13116971f, 0.18527636f, -0.11194292f, 0.14828125f, 
    -0.03124009f, -0.04353669f, 0.10001424f, 0.05710979f, -0.10129917f, 0.25758681f, 0.47570366f, -0.07775726f, 
    -0.42534912f, -0.17105633f, 0.06183714f, 0.01272446f, -0.06347603f, -0.13305424f, 0.12759213f, 0.00959346f, 
    -0.11405324f, 0.05991156f, 0.05263932f, 0.11017971f, 0.11408355f, 0.02303152f, -0.16943251f, -0.57815552f, 
    -0.25437683f, -0.16919889f, -0.12919407f, 0.15599559f, 0.05963518f, -0.13025868f, -0.05686775f, -0.10050397f, 
    0.20880771f, 0.34711102f, -0.21037795f, -0.11239121f, 0.13674302f, -0.17284691f, 0.03462849f, -0.00997283f, 
    0.14810061f, -0.12352148f, 0.01356050f, 0.25291759f, 0.03025250f, 0.27946118f, 0.29156804f, 0.16297436f, 
    0.17633492f, 0.08957497f, 0.03297182f, -0.24970508f, 0.34234813f, 0.11511173f, -0.04952368f, 0.21188398f, 
    -0.12523569f, 0.23077151f, 0.18244053f, 0.03460150f, 0.11598238f, -0.07968079f, 0.05381467f, 0.41152695f, 
    0.09853629f, 0.14250487f, 0.05416182f, 0.16693948f, 0.13466433f, 0.21780117f, 0.16389576f, 0.02926767f, 
    0.00705492f, -0.12367655f, -0.13842250f, -0.01665041f, -0.01578827f, 0.25907606f, 0.02304070f, -0.06909773f, 
    0.10680481f, 0.09447335f, 0.07892880f, 0.20575294f, 0.09614854f, -0.06425311f, 0.26865822f, -0.08161010f, 
    -0.10990471f, 0.00150139f, -0.15386990f, -0.10549671f, -0.25004235f, -0.20377927f, -0.26691118f, 0.20287728f, 
    0.55407172f, 0.24039844f, 0.10932183f, 0.00003814f, -0.06891494f, 0.06740049f, -0.01025379f, 0.07109853f, 
    0.30642071f, -0.08817079f, 0.12149840f, 0.07209659f, -0.13732524f, 0.14113297f, 0.07759221f, 0.30685684f, 
    0.25955647f, -0.00394160f, -0.15731508f, -0.33367440f, 0.04254052f, 0.29384160f, 0.24706747f, 0.14655387f, 
    -0.25061074f, -0.04199760f, 0.09875790f, 0.20113282f, -0.02030739f, 0.01575103f, -0.07799724f, 0.14424776f, 
    0.00040009f, -0.08161736f, 0.13563664f, 0.10076138f, 0.10645759f, 0.18389773f, 0.29639626f, 0.11986570f, 
    -0.09690481f, 0.07033543f, 0.07635865f, -0.06656326f, -0.02753904f, -0.20271054f, -0.09952310f, 0.06071957f, 
    0.10028221f, 0.14120175f, -0.08767955f, -0.08214635f, -0.26323536f, -0.29347441f, -0.03651986f, 0.22595295f, 
    -0.02866158f, 0.21041195f, 0.00251010f, -0.29517543f, -0.40885851f, -0.13609931f, 0.08107699f, 0.29112872f, 
    0.33702865f, 0.21562304f, 0.02057944f, 0.06902397f, 0.24385329f, 0.34827456f, 0.06716368f, 0.02645793f, 
    0.45902714f, 0.09365042f, 0.09545369f, 0.09362907f, -0.20843898f, 0.23611321f, 0.09196614f, 0.08175539f, 
    -0.51950479f, -0.33169472f, -0.49933302f, -0.08936769f, -0.32862663f, -0.06590577f, 0.15066990f, -0.20373386f, 
    -0.10791920f, 0.08067057f, -0.12140333f, 0.03469668f, 0.10555627f, -0.15574895f, 0.03208436f, -0.02279570f, 
    0.01689051f, 0.17680451f, 0.28899103f, 0.21129888f, 0.11309271f, -0.16327693f, -0.18365616f, -0.21641533f, 
    0.08773687f, 0.07415583f, 0.11797847f, -0.08565213f, 0.04979396f, -0.24492727f, -0.00295443f, 0.13702627f, 
    0.17825584f, 0.04311864f, 0.02245277f, 0.06309931f, -0.26280847f, 0.03235267f, -0.19302335f, -0.12990819f, 
    0.00432567f, -0.14070857f, -0.00390777f, -0.08109023f, 0.11079087f, -0.07595292f, -0.24344938f, -0.36862096f, 
    -0.09284759f, 0.19099876f, 0.04944903f, 0.16491631f, 0.19024262f, 0.14405560f, 0.33832729f, -0.03361417f, 
    -0.18694609f, 0.29591772f, 0.09154335f, 0.06141713f, -0.11214035f, -0.19506480f, -0.19087784f, -0.09317853f, 
    -0.05843710f, -0.04530231f, 0.32330045f, 0.04436955f, 0.07226860f, 0.09473110f, 0.05875209f, -0.12183934f, 
    -0.16170509f, -0.10955811f, -0.00389045f, -0.19402985f, -0.08674951f, -0.11264817f, 0.18661034f, -0.13837565f, 
    0.08384734f, -0.15591283f, 0.12623546f, -0.13517642f, 0.06740655f, -0.16281830f, 0.09139658f, 0.15390913f, 
    0.11289558f, -0.21023986f, 0.25242442f, -0.28343645f, -0.02616097f, -0.03416007f, 0.15055104f, 0.15721370f, 
    0.07630445f, -0.01471890f, -0.04754321f, -0.02030325f, 0.26085210f, 0.11870930f, -0.00772049f, -0.27439675f, 
    -0.14649597f, -0.02147281f, -0.00648938f, -0.01281888f, -0.01874342f, 0.16262329f, 0.04111601f, 0.22651169f, 
    0.07703663f, -0.10188107f, 0.33916593f, -0.01860324f, -0.11599123f, -0.13301727f, 0.29355875f, 0.16656747f, 
    0.00445664f, -0.02225031f, -0.09111316f, 0.21856305f, -0.06408874f, -0.03554069f, -0.25718725f, -0.13743703f, 
    -0.02563909f, 0.10773374f, 0.01878089f, -0.20104736f, 0.24848403f, 0.23882054f, 0.08552223f, -0.20537607f, 
    0.07931251f, -0.48898935f, 0.00963476f, -0.13165440f, 0.07962180f, -0.01217077f, 0.03993357f, -0.03035340f, 
    0.05549944f, -0.02430872f, -0.04380153f, 0.03742905f, 0.05541532f, -0.07621538f, 0.01327255f, 0.01090518f, 
    -0.01333963f, -0.08727495f, -0.03424504f, 0.06251797f, -0.09865034f, -0.06699228f, 0.07063940f, -0.00503471f, 
    -0.04178738f, -0.09519465f, -0.00608637f, 0.04569371f, 0.02011055f, 0.04827935f, -0.07828185f, -0.00679000f, 
    0.04773739f, 0.05782396f, 0.03936599f, -0.00640671f, -0.06232321f, -0.08083405f, 0.03420911f, -0.04536569f, 
    -0.01074707f, -0.06057068f, 0.03316019f, -0.08441056f, 0.00778219f, -0.03229794f, -0.02705043f, 0.00854314f, 
    -0.05148231f, 0.05241146f, -0.05555413f, 0.04678939f, -0.01042877f, 0.04000042f, -0.01342639f, 0.00369890f, 
    -0.00772023f, 0.07091402f, 0.01444138f, 0.06805880f, -0.09430384f, 0.02087662f, -0.02793033f, 0.07802465f, 
    0.03143381f, 0.05010801f, 0.04792009f, 0.03099367f, 0.02993799f, -0.03979905f, -0.02491327f, 0.04268359f, 
    -0.04030233f, 0.02150646f, 0.00499697f, -0.04370851f, -0.04736710f, -0.03939111f, 0.04624391f, -0.06380433f, 
    -0.05567443f, -0.03039241f, -0.01706749f, -0.07288706f, -0.06542524f, -0.07318971f, -0.02336662f, -0.04223101f, 
    -0.04437271f, 0.02904767f, -0.02365312f, 0.05734173f, -0.03750904f, 0.06630456f, -0.00902561f, 0.06348560f, 
    -0.04394286f, 0.06216168f, 0.00443916f, -0.05969446f, 0.03719723f, -0.06224497f, 0.02281336f, 0.03985002f, 
    0.06122161f, 0.03991664f, 0.02551639f, -0.00542729f, -0.00235183f, -0.09346780f, -0.03743380f, 0.05142659f, 
    -0.02555117f, -0.00592225f, -0.04007588f, -0.00012478f, 0.02241841f, 0.02241081f, -0.09252455f, -0.08405083f, 
    -0.03816398f, 0.00024650f, -0.01683973f, 0.03745679f, -0.06421487f, -0.04245501f, 0.02995143f, -0.01059557f, 
    -0.06589554f, 0.02641367f, 0.00065951f, -0.03372027f, -0.07441545f, 0.03098916f, 0.03283570f, -0.00089226f, 
    0.01935950f, -0.01668439f, 0.03781455f, -0.09089603f, 0.05144091f, 0.00355208f, -0.01031377f, 0.01102242f, 
    -0.07810842f, -0.05129668f, -0.01108161f, -0.03027130f, -0.04315521f, -0.03086746f, -0.06412343f, 0.02143641f, 
    -1.51044095f, -0.38510942f, 0.25676081f, 0.16044930f, -0.24182710f, 0.04749259f, -0.08639137f, 0.11555102f, 
    0.11826739f, 0.21940966f, -0.14504570f, -0.15105581f, 0.05114558f, 0.04322214f, -0.04961348f, -0.17754820f, 
    -0.09924199f, -0.07586360f, -0.02541428f, -0.66913140f, -0.75577068f, 0.33598107f, -0.04617380f, 0.04907110f, 
    0.18970011f, -0.06195434f, 0.04584544f, 0.26310387f, 0.29872000f, 0.40209028f, 0.12399824f, 0.11636931f, 
    -0.06479985f, 0.15886904f, 0.06619334f, 0.16127770f, 0.24010511f, -0.35008958f, -0.14508535f, -0.03287896f, 
    -0.14324522f, 0.15812826f, -0.03763132f, -0.03220955f, 0.30254734f, 0.43288857f, 0.20444225f, 0.25037608f, 
    0.13586131f, 0.16798393f, -0.06761500f, -0.05215751f, -0.07687788f, -0.08801114f, -0.36871752f, -0.18976125f, 
    0.13387063f, 0.34634084f, -0.14549606f, 0.15478060f, -0.17934307f, 0.09289374f, 0.05709982f, 0.24491106f, 
    -0.09042258f, -0.27985772f, 0.08009366f, 0.12376298f, 0.13021971f, 0.21469985f, -0.12435361f, 0.06223973f, 
    -0.39541742f, -0.02329559f, -0.25048006f, 0.19197500f, 0.24045166f, -0.11443706f, 0.25099877f, 0.05858821f, 
    -0.14089784f, -0.36820114f, -0.10221776f, -0.04068614f, 0.10547351f, -0.20823780f, 0.13432851f, 0.18539749f, 
    -0.03875945f, 0.17263667f, 0.42663234f, 0.09595423f, 0.08975998f, 0.09640843f, -0.02258453f, 0.08836000f, 
    -0.08134927f, 0.12596810f, 0.06762243f, -0.01490514f, 0.18939899f, -0.03617897f, -0.06862130f, -0.01418821f, 
    -0.07507868f, 0.18808873f, -0.07201385f, 0.14429063f, 0.06431316f, 0.24078169f, 0.07617861f, 0.03499144f, 
    -0.15946645f, 0.09435415f, 0.06878927f, 0.10563004f, -0.02703979f, 0.36522689f, 0.43253767f, 0.34316614f, 
    -0.27891198f, 0.04320805f, -0.32512921f, 0.08643615f, -0.06087076f, -0.06619863f, -0.01868818f, -0.44091237f, 
    -0.38809472f, 0.12799419f, 0.03966613f, -0.00661707f, -0.12013496f, -0.15590331f, 0.06277895f, 0.25342816f, 
    -0.02654142f, -0.52748841f, -0.21941091f, 0.00732913f, -0.01763371f, -0.17687617f, -0.16309728f, -0.15066192f, 
    -0.52363050f, 0.00852610f, 0.34616381f, -0.04259989f, 0.25605914f, -0.07992148f, 0.00401858f, 0.03272055f, 
    -0.03898688f, -0.16372889f, 0.02284023f, -0.01717067f, -0.00342058f, -0.02232355f, -0.02781586f, -0.15008616f, 
    -0.10784307f, -0.34915727f, -0.36275640f, -0.16118377f, -0.00463294f, 0.12498703f, -0.02981384f, -0.08638228f, 
    -0.20684862f, -0.31245860f, -0.28444952f, -0.17368893f, -0.06021583f, 0.15839759f, 0.17291385f, -0.07853592f, 
    -0.06398936f, 0.05021731f, 0.16374815f, -0.15004681f, -0.43320683f, -0.15809178f, -0.07920498f, 0.03398808f, 
    0.00716458f, 0.10239651f, -0.06581228f, -0.02822728f, -0.06473154f, -0.08522780f, 0.21453103f, 0.24399170f, 
    -0.16731973f, -0.01244880f, 0.20632970f, 0.01485349f, 0.00839002f, -0.07266235f, 0.11433928f, 0.37857410f, 
    -0.07383714f, 0.05634827f, 0.05676493f, 0.02424624f, 0.02889174f, 0.22128171f, 0.23588401f, 0.25435665f, 
    0.08904921f, 0.12772508f, 0.05971839f, 0.03714921f, 0.03901082f, 0.02714236f, 0.10728747f, 0.00292755f, 
    -0.15211308f, 0.08261745f, 0.01889387f, 0.14061850f, -0.16772133f, -0.02480145f, 0.08454870f, -0.15877342f, 
    -0.06042125f, 0.10992357f, 0.02720213f, -0.09089326f, -0.08652583f, 0.09293023f, 0.02508800f, 0.19675416f, 
    0.07600179f, 0.11804525f, 0.08218794f, -0.07997659f, 0.14321601f, 0.14185250f, 0.02794475f, -0.02662605f, 
    -0.01090645f, 0.02748898f, 0.14663738f, -0.31015351f, 0.18640183f, 0.09996151f, -0.18667167f, 0.03379726f, 
    0.01192077f, 0.28930545f, 0.18015319f, 0.13464199f, 0.09261066f, 0.21194331f, 0.02250073f, -0.10326159f, 
    0.07674307f, 0.16401011f, 0.12604512f, 0.30136845f, 0.25899732f, -0.51776308f, -0.09669539f, -0.33566201f, 
    0.23371398f, 0.07300927f, 0.04549628f, -0.06189541f, 0.12506914f, 0.01095943f, 0.04138234f, -0.05399495f, 
    -0.18403715f, 0.17395033f, 0.07977125f, 0.20203798f, -0.13962291f, -0.05579849f, -0.14128895f, 0.47386110f, 
    0.21330762f, 0.08828943f, 0.21214423f, 0.17572089f, 0.16441733f, 0.09121629f, 0.24340214f, -0.17680980f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.20892327f, 0.21683528f, 0.09592712f, 0.16210054f, 0.11312146f, 0.20361340f, -0.09615586f, 0.02515662f, 
    0.02779019f, 0.33708921f, 0.04650493f, 0.21656239f, 0.14238170f, -0.04514389f, -0.08175541f, 0.16082294f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.15431029f, -0.04291160f, -0.53244382f, 0.59835631f, 0.16514029f, 0.22213177f, -0.06700429f, -0.22050238f, 
    -0.40485853f, 0.48461956f, 0.24076679f, -0.08435122f, -0.53382576f, 0.12725388f, -0.27537996f, 0.45418042f, 
    0.63211292f, 0.49750206f, -0.13132049f, -0.04876353f, -1.00437725f, 0.36481357f, -0.40613958f, 0.17630324f, 
    0.34624469f, -0.17951593f, -0.08842015f, -0.00763435f, 0.46335241f, 0.10130695f, -0.06438122f, 0.27307963f, 
    0.11669514f, 0.29570758f, 0.56142575f, -0.00561051f, 0.91464001f, 0.43335339f, -0.49403790f, -0.41656727f, 
    -0.12487175f, 0.23497874f, -0.03318856f, 0.14908138f, 0.03240658f, 0.21948443f, -0.46983859f, 0.18258555f, 
    0.05954275f, 0.12255801f, -0.12990713f, -0.00065814f, -0.23941666f, 0.05381625f, 0.38080549f, -0.26874828f, 
    -0.30121085f, -0.25105846f, -0.38339418f, 0.05708475f, 0.12930153f, 0.23809804f, 0.42478403f, 0.36813465f, 
    0.19864488f, 0.61608261f, -0.18668593f, -0.08908039f, -0.76380932f, -0.11843733f, 0.13639532f, 0.14511877f, 
    0.09220267f, -0.16930082f, -0.40710250f, -0.12987538f, 0.21183822f, -0.17169143f, 0.38311452f, 0.12265590f, 
    0.36648503f, 0.29069337f, 0.23207019f, 0.46265587f, -1.26193857f, -0.13478643f, 0.36023846f, 0.16771717f, 
    0.06183001f, -0.01931670f, -0.33290473f, 0.09711409f, -0.07828181f, -0.09486626f, 0.26146519f, -0.07179083f, 
    0.01240018f, 0.06395642f, 0.57468200f, -0.12504785f, 0.46275914f, 0.40826300f, -0.01904449f, -0.31785133f, 
    0.41343370f, 0.45385194f, -0.39118049f, 0.11448268f, 0.01410896f, -0.21950871f, -0.16513951f, -0.21540609f, 
    0.11968382f, 0.22716670f, 0.14511913f, 0.63967007f, -0.73668134f, 0.27582082f, 0.22800808f, 0.21265259f, 
    -0.04913293f, 0.22553375f, 0.19942248f, -0.32419538f, 0.01313279f, 0.20336653f, 0.02521563f, 0.22850581f, 
    0.56346405f, 0.75273103f, 0.19638827f, 0.53368574f, 0.36995754f, 0.31781083f, -0.30814737f, 0.38797081f, 
    0.01109062f, -0.28598845f, 0.29693699f, 0.08823467f, -0.74261916f, 0.05419328f, -0.44975790f, 0.16543356f, 
    -0.19193377f, 0.07270946f, -0.32299846f, -0.77490067f, -0.35811129f, -0.29712629f, -0.05373029f, -0.24950698f, 
    0.40749785f, 0.08540250f, 0.30621588f, 0.35472447f, 0.33248755f, -0.13820259f, -0.55999625f, -0.34423569f, 
    0.19790260f, 0.00044329f, -0.16308920f, 0.00186781f, -0.18006009f, -0.12790790f, 0.02609418f, -0.03526178f, 
    0.15149827f, -0.24966338f, -0.10796856f, -0.19526099f, -0.17223346f, 0.16508661f, 0.10140501f, -0.09869663f, 
    -0.15617985f, -0.16797447f, 0.02083349f, 0.02596414f, -0.23688480f, -0.20599884f, 0.04327387f, -0.19599631f, 
    -0.07490596f, -0.23691738f, -0.17630115f, -0.20717388f, 0.15168864f, 0.07668537f, 0.02420026f, -0.01053587f, 
    -0.32450715f, 0.26102778f, 0.28650057f, -0.17284907f, 0.14091219f, 0.23344032f, -0.04527805f, -0.51287621f, 
    0.31014803f, -0.10846316f, 0.17674018f, 0.18457933f, 0.43844324f, -0.12188821f, -0.05837996f, -0.32500347f, 
    0.21694311f, 0.17711975f, 0.25434092f, -0.04883979f, 0.59223348f, 0.23898897f, -0.04956967f, -0.48298529f, 
    -0.23465866f, 0.33584967f, -0.55826408f, 0.25082800f, -0.00214535f, -0.20840627f, -0.72100526f, -0.11086642f, 
    -0.33896697f, 0.09202353f, -0.35691088f, 0.62796503f, 0.08659586f, 0.20225288f, -0.15920639f, -0.07053409f, 
    -0.29730758f, 0.17387256f, 0.03809213f, -0.06816222f, 0.29158661f, -0.07598799f, -0.21107964f, 0.18984954f, 
    0.13771854f, -0.16324918f, -0.29186800f, -0.13864042f, 0.33562672f, 0.08035861f, -0.22083472f, -0.23618233f, 
    0.17705975f, 0.35443509f, 0.32528436f, -0.22391586f, 0.07379183f, 0.25097138f, -0.53100216f, 0.32172641f, 
    0.00469871f, -0.09307968f, 0.48437357f, 0.81995529f, 0.24436122f, 0.14902455f, -0.28659925f, 0.25342625f, 
    0.35551828f, 0.24493410f, 0.02903607f, -0.24557176f, -0.56859475f, 0.05821913f, -0.14984912f, 0.43076369f, 
    0.44057685f, -0.29178473f, -0.26599064f, 0.99437094f, 0.53549731f, -0.02901992f, -0.12385365f, 0.26081792f, 
    0.18168509f, -0.08353740f, 0.15544258f, -0.03994946f, -0.42994413f, -0.18557046f, 0.41949588f, 0.16692530f, 
    -0.69981802f, -0.03636312f, 0.03283239f, 0.50848091f, 0.30728874f, 0.30132249f, 0.54834002f, 0.01565932f, 
    0.22170427f, 0.27601731f, 0.07872642f, -0.14029662f, 0.14101242f, -0.09914786f, -0.19340898f, 0.28090179f, 
    0.09206733f, 0.07109699f, -0.70038128f, -0.42186177f, -0.42206299f, -0.14145996f, 0.35637575f, 0.17364484f, 
    0.00231795f, 0.18930417f, 0.52754724f, 0.22057076f, -0.06711997f, 0.00085212f, -0.54402745f, 0.02875008f, 
    0.56570953f, 0.60923827f, 0.31096655f, 0.89552861f, 1.31839156f, 0.41705781f, -0.05765188f, 0.22140266f, 
    -0.05382765f, -0.34089860f, 0.25980046f, 0.06614082f, -0.11736073f, -0.10604598f, -0.14070630f, -0.14468937f, 
    0.10237408f, -0.42783287f, -0.19629793f, 0.06548434f, -0.23929970f, -0.05121301f, 0.27594987f, 0.53876698f, 
    0.44412866f, -0.19941643f, 0.26189438f, 0.14367853f, 0.01614735f, -0.17275642f, 0.22848411f, -0.18932638f, 
    -0.42121518f, -0.32934779f, -0.13500038f, -0.61124295f, -0.92467386f, 0.28758535f, 0.66036415f, -0.08368997f, 
    0.31891903f, -0.04612139f, -0.07595527f, 0.01242197f, 0.13490158f, 0.10819817f, 0.05149202f, -0.00197168f, 
    0.06264147f, 0.35244423f, 0.01136899f, -0.21910694f, -0.71750683f, 0.35427642f, -0.20320193f, 0.52418143f, 
    0.22655176f, 0.30759987f, 0.15778476f, 0.21299088f, -0.36632049f, -0.09954037f, -0.41044244f, 0.12838157f, 
    0.15363954f, 0.42128620f, 0.83962780f, 0.63449395f, 0.44113782f, 0.28978521f, -0.05161858f, -0.33602750f, 
    0.14981709f, -0.00177861f, -0.12693284f, -0.14767534f, -0.41200915f, -0.20660278f, 0.05534572f, 0.31209138f, 
    -0.07192150f, -0.16165347f, -0.16421379f, -0.08290614f, -0.05203518f, -0.04518855f, 0.02891880f, 0.01075346f, 
    -0.04032500f, 0.01903350f, 0.13842337f, -0.28812841f, 0.16888410f, -0.01490590f, -0.10140967f, -0.01839950f, 
    0.13405001f, 0.30961215f, 0.16734892f, 0.48864621f, -0.57694083f, 0.34451860f, 0.47926763f, 0.17795107f, 
    0.09798032f, 0.12751198f, -0.11398894f, -0.33378237f, -0.46931759f, -0.01300799f, -0.01839210f, 0.26029655f, 
    0.15041590f, -0.23764779f, -0.53868246f, -0.21432211f, -0.29739472f, -0.27498895f, -0.05572638f, 0.50684434f, 
    -0.02661923f, -0.02170568f, 0.58066148f, 0.04125221f, 0.10923248f, 0.14479348f, 0.01664658f, 0.23766813f, 
    0.48095027f, 0.63568974f, 0.05622579f, -0.43501213f, -0.04052766f, 0.08633602f, -0.33164668f, -0.03031323f, 
    -0.34544429f, 0.20493424f, 0.03521354f, 0.31273448f, 0.42351174f, -0.01190463f, -0.13476676f, -0.00690105f, 
    0.10944086f, -0.27934211f, -0.03351729f, -0.23555550f, 0.60365456f, 0.20503500f, -0.42801437f, -0.22249036f, 
    -0.10262363f, 0.31333461f, -0.35231516f, 0.38558793f, 0.24847370f, 0.00815984f, 0.05287315f, -0.21872999f, 
    0.42532849f, 0.35917997f, 0.14336453f, -0.42822093f, -0.26672840f, -0.17988198f, -0.46316463f, 0.25660497f, 
    0.32033476f, -0.31361645f, -0.03903199f, 0.40705040f, 0.47731239f, 0.14575104f, -0.06988535f, -0.15529291f, 
    -0.35483873f, 0.38028598f, -0.23553103f, 0.05181589f, -0.05070869f, -0.32020718f, 0.44187072f, 0.07748158f, 
    0.18215540f, 0.13808325f, 0.06819977f, 0.08806884f, -0.17543943f, -0.25474438f, -0.67775500f, 0.37418848f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.32575214f, 0.14517508f, 0.37659025f, -0.01551881f, -0.13157839f, -0.24204084f, 0.32825696f, -0.15288274f, 
    0.32723078f, 0.34513324f, -0.22035660f, 0.08663329f, 0.23890290f, 0.31709725f, -0.07929377f, 0.27607983f, 
    -0.08733977f, -0.03198671f, 0.51853812f, 0.20686732f, 0.01701529f, -0.13469811f, 0.09919507f, 0.53000659f, 
    0.07334155f, -0.28878000f, 0.33284962f, -0.05323223f, -0.00836155f, 0.20247509f, 0.09327284f, 0.04107238f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.45633420f, 0.22452527f, 0.00221461f, -0.37164897f, -0.07822646f, -0.06760756f, 0.02031626f, -0.01335064f, 
    0.08712696f, 0.39326665f, 0.15822686f, -0.05908278f, -0.21156070f, -0.34870055f, -0.28760597f, -0.09674571f, 
    0.02052224f, -0.06793315f, 0.13138822f, 0.08298393f, 0.05396199f, 0.50881863f, 0.02693622f, 0.26660949f, 
    -0.28159228f, -0.10961492f, -0.21648002f, 0.44062072f, 0.03962574f, -0.12483504f, 0.31170842f, 0.32681060f, 
    0.44702351f, 0.25838229f, -0.04108513f, -0.02350830f, 0.10801370f, 0.22281663f, -0.13349524f, 0.40540099f, 
    -0.00269262f, -0.18988505f, -0.08599386f, 0.16271876f, 0.01158648f, -0.37654784f, 0.05927222f, 0.32351452f, 
    0.49677584f, 0.22723430f, 0.17334338f, -0.03667388f, -0.09318350f, 0.15524694f, 0.16204187f, 0.12432759f, 
    0.27893007f, -0.07644148f, 0.71082562f, 0.31087509f, -0.18797033f, -0.28888702f, -0.20516145f, 0.27769539f, 
    0.53727007f, -0.24852166f, -0.15346044f, -0.30554378f, 0.02225017f, 0.03407279f, 0.17971294f, 0.19426587f, 
    0.12380224f, 0.13605648f, -0.12965287f, -0.02921828f, -0.24166492f, -0.16135597f, 0.74299157f, 0.02949933f, 
    0.44878769f, 0.16207896f, 0.30876219f, 0.11373296f, -0.09831487f, 0.12146733f, -0.01746108f, 0.29992923f, 
    -0.01803250f, 0.00013422f, 0.49796799f, -0.07516076f, -0.20479600f, -0.22418807f, -0.17233354f, 0.28343013f, 
    -0.22554027f, 0.37805814f, -0.01671479f, -0.35991615f, -0.12911262f, -0.36272871f, 0.09333189f, 0.08532938f, 
    -0.10735056f, 0.22300465f, -0.01137493f, 0.08698639f, 0.15589292f, -0.57552379f, -0.10260510f, 0.57043779f, 
    0.32770059f, 0.21292555f, 0.26646039f, -0.01147691f, 0.03160655f, 0.42581847f, 0.05357072f, 0.06084052f, 
    -0.05473588f, -0.11050406f, 0.06550221f, 0.40800625f, -0.20798573f, -0.12728511f, 0.14018546f, 0.22544044f, 
    -0.30411658f, 0.34645471f, 0.54271120f, 0.08810179f, 0.10660299f, -0.05904677f, 0.38344049f, -0.04965553f, 
    0.19896826f, -0.04754651f, 0.07780807f, -0.14116485f, 0.51400387f, 0.44749600f, -0.39502147f, 0.05415069f, 
    -0.12668847f, -0.27930486f, 0.04867816f, -0.16468987f, 0.10053442f, -0.58322173f, -0.03205860f, 0.15365329f, 
    0.45117563f, -0.09222530f, 0.19551337f, -0.54414082f, 0.30864695f, -0.03526878f, 0.11354424f, -0.13718298f, 
    0.77276278f, -0.60333681f, 0.52031970f, -0.29946855f, -0.75038916f, -1.03189886f, 0.26649800f, -0.74044013f, 
    0.14251539f, -0.04665820f, 0.01502176f, -0.14329351f, 0.12114126f, 0.56105340f, 0.50950849f, 0.07391728f, 
    -0.07150342f, -0.06645861f, 0.22694512f, 0.19862826f, 0.19274449f, -0.25559470f, -0.11485012f, 0.13902234f, 
    -0.06899516f, 0.10962306f, -0.79620326f, 0.10239808f, 0.10032572f, 0.54737800f, -0.22426756f, 0.08925138f, 
    0.14250310f, 0.14157523f, -0.10541853f, -0.12550996f, -0.13905917f, -0.01427923f, 0.08667073f, 0.34728646f, 
    0.07338196f, -0.19915935f, -0.01743977f, -0.12555219f, 0.05633383f, -0.50008684f, 0.34060538f, 0.44502410f, 
    0.39547837f, 0.13620587f, 0.38115111f, 0.01997726f, 0.42802113f, -0.00579274f, -0.09084807f, -0.07849239f, 
    0.06677105f, -0.15797579f, 0.63457257f, 0.02360194f, -0.05564659f, -0.37789991f, -0.25227186f, 0.09777475f, 
    -0.50110406f, 0.25151569f, -0.13910614f, -0.11758025f, 0.17165655f, 0.32366601f, 0.42025563f, -0.38748202f, 
    -0.23894840f, 0.24592885f, 0.02155424f, -0.15887424f, 0.26540172f, 0.21008380f, -0.36279520f, -0.21424170f, 
    0.30520067f, -0.11826069f, -0.14123471f, -0.10983066f, -0.35896772f, 0.25638840f, 0.36498559f, 0.26759130f, 
    0.21939711f, -0.09002528f, -0.04162838f, -0.23750596f, -0.15264830f, 0.41142070f, 0.56814033f, 0.13396616f, 
    -0.19224903f, 0.10631648f, -0.12529755f, -0.20979339f, 0.21110074f, -0.15178092f, -0.12912667f, 0.14878650f, 
    0.42026865f, 0.60828912f, -0.17446041f, -0.03145409f, 0.00417747f, 0.12660293f, -0.33277741f, 0.15889056f, 
    0.08082563f, -0.26711836f, -0.18549612f, 0.29590672f, 0.01473023f, -0.13968253f, -0.16214989f, 0.31830803f, 
    -0.23941895f, 0.01985522f, 0.25517988f, 0.18195899f, 0.23166761f, -0.33144251f, 0.34681287f, 0.38030258f, 
    0.22265193f, 0.13739343f, 0.46702802f, -0.04316353f, 0.15786657f, 0.04036950f, 0.32306379f, 0.48584211f, 
    0.04961307f, -0.35179737f, 0.02500089f, -0.07022177f, -0.08450256f, 0.49297616f, -0.23140128f, -0.07089799f, 
    0.31473544f, -0.18547933f, 0.17572266f, -0.10261877f, -0.12446211f, -0.49380007f, 0.13522513f, 0.16443412f, 
    0.40553689f, -0.07561667f, 0.43572614f, -0.43019882f, -0.02756082f, 0.11386143f, -0.09785361f, -0.14271313f, 
    -0.34467411f, 0.06009050f, -0.12815952f, 0.01900419f, 0.17460422f, 0.02217699f, -0.05406828f, 0.01817394f, 
    -0.13651554f, 0.50335139f, 0.15187278f, 0.00928082f, 0.49817726f, -0.08193449f, 0.43285495f, -0.19564159f, 
    -0.83661032f, -0.32175606f, 0.24703909f, 0.39056242f, -0.14646135f, 0.36605942f, 0.41288558f, 0.19586629f, 
    -0.59937435f, 0.18903251f, -0.38077253f, 0.31129417f, 0.08980732f, 0.04937861f, 0.27099249f, 0.21201369f, 
    0.42378351f, 0.19402200f, -0.36696884f, -0.32583675f, -0.00703342f, -0.00870000f, 0.17296797f, 0.30189720f, 
    -0.44126454f, 0.03730221f, -0.14477596f, -0.06868539f, 0.08044412f, -0.32875401f, 0.33159855f, 0.22567239f, 
    -0.32057956f, -0.23525441f, 0.08392704f, 0.38432837f, -0.71550554f, 0.07731187f, 0.53162980f, 0.28828874f, 
    -0.45873013f, -0.10596761f, 0.31414813f, 0.47697958f, -0.15145296f, -0.19012642f, -0.32511240f, 0.15133902f, 
    -0.52969325f, -0.31145373f, -0.11931485f, -0.45484105f, -0.10569583f, -0.31590655f, 0.09563205f, -0.23496437f, 
    0.52467161f, 0.15012318f, 0.02430210f, 0.12803680f, 0.23484798f, -0.48856542f, 0.40961191f, -0.11495463f, 
    0.13300747f, -0.26602998f, 0.12107076f, 0.23181851f, 0.74717236f, 0.28124088f, 0.07160140f, 0.01030955f, 
    0.28728586f, 0.00698603f, -0.14836331f, -0.02536741f, -0.49216896f, -0.67550755f, 0.33126348f, 0.03753091f, 
    -0.55920833f, -0.34897071f, -0.90043348f, 0.51097512f, -0.04192652f, 0.42486548f, 0.11982826f, 0.08982965f, 
    -1.08841991f, 0.02189018f, 0.17635706f, 0.09668712f, 0.06713919f, -0.01660382f, 0.26998690f, -0.30032694f, 
    -0.24618575f, -0.59083354f, 0.24136446f, 0.00647469f, -0.52461195f, 0.27725506f, 0.37919563f, -0.06984094f, 
    -0.04764133f, 0.01704069f, 0.45006475f, -0.12343536f, -0.49854210f, -0.55041176f, -0.40143058f, 0.31675208f, 
    -0.49762374f, -0.48846531f, -0.40663087f, -0.12280904f, -0.11462639f, 0.60322636f, 0.05327713f, -0.70055383f, 
    0.01218052f, 0.25377548f, -0.02636713f, 0.14143997f, 0.22169755f, 0.23626147f, 0.31330934f, -0.19100744f, 
    -0.37653077f, -0.04781260f, 0.15221757f, 0.10344684f, 0.39745751f, 0.31429771f, 0.13932505f, 0.15944311f, 
    -0.32892281f, -0.10129140f, -0.28894791f, -0.16440827f, -0.16098914f, 0.13713780f, 0.25542581f, -0.01667977f, 
    0.68417466f, 0.11734101f, -0.05836348f, -0.37428242f, -0.26824766f, 0.07045451f, -0.03607520f, 0.02053640f, 
    0.50939411f, -0.24468464f, -0.16989060f, -0.04501372f, -0.38063735f, 0.08625744f, 0.31500700f, -0.11498535f, 
    -0.12602468f, 0.02178802f, 0.06143662f, 0.24452022f, 0.50611544f, -0.27337858f, -0.21705033f, 0.18735974f, 
    0.16341813f, -0.11075129f, 0.61489159f, -0.01502931f, 0.09886750f, -0.36890745f, -0.25050697f, 0.19253340f, 
    -0.29769236f, 0.40956691f, 0.18172304f, -0.26299238f, 0.01918773f, -0.32194275f, 0.31120774f, -0.44795004f, 
    0.24035162f, 0.23362346f, -0.05629440f, 0.12783712f, -0.02075026f, 0.33408001f, -0.49457371f, 0.36703396f, 
    0.18308926f, -0.36214936f, -0.17178220f, 0.16689070f, 0.04091641f, -0.11040980f, -0.31319612f, 0.27177396f, 
    0.04792045f, -0.04897463f, -0.28729698f, -0.08719040f, -0.04092682f, 0.17740037f, 0.47417551f, -0.19742814f, 
    -0.17313787f, -0.12073089f, -0.02787352f, 0.05602225f, 0.08570877f, 0.02692659f, -0.14729919f, 0.07690521f, 
    -0.07341764f, -0.14595984f, 0.00185849f, -0.12909035f, 0.11679528f, -0.13793825f, 0.08507706f, -0.04182794f, 
    -0.12019940f, 0.04284469f, -0.04707056f, -0.10791542f, -0.14128336f, -0.03192188f, -0.16069473f, -0.21947344f, 
    0.01606848f, -0.12954691f, 0.13561749f, -0.05831118f, -0.16003188f, -0.18747534f, 0.00592433f, -0.10341353f, 
    0.02889959f, -0.05340459f, -0.11903985f, -0.03458410f, -0.01481146f, -0.12514916f, -0.14966623f, -0.12913755f, 
    0.07731308f, -0.12279459f, 0.05881160f, -0.16903716f, -0.04865453f, -0.06759489f, -0.03294177f, -0.14430493f, 
    -0.12715030f, 0.11460038f, 0.10501218f, -0.15297152f, 0.03473043f, -0.01003795f, -0.13636006f, -0.11270288f, 
    -0.12913950f, 0.03787552f, 0.06024567f, -0.01748167f, -0.15048791f, 0.02337226f, 0.11396659f, 0.09023353f, 
    0.17954935f, -0.00928625f, -0.06896549f, -0.39637834f, -0.44520813f, 0.04283557f, -0.03091464f, 0.31987458f, 
    0.14872152f, -0.41564518f, -0.17047805f, 0.00607433f, -0.55402571f, -0.41826588f, 0.25303650f, 0.05178167f, 
    0.20275572f, 0.09860783f, 0.11689720f, 0.17182432f, -0.20937628f, 0.32926753f, 0.03657146f, 0.29412714f, 
    -0.00696872f, 0.05459182f, 0.09268893f, 0.50558311f, 0.14449361f, -0.21789396f, -0.04284434f, 0.21354303f, 
    -0.03523216f, -0.01117157f, -0.05493782f, -0.22985743f, -0.15273428f, 0.12487312f, 0.42945996f, 0.05248123f, 
    -0.26054913f, -0.16889316f, 0.08823496f, 0.15427968f, -0.00407386f, 0.00378883f, 0.27676743f, -0.40047500f, 
    0.01793997f, 0.12615399f, 0.30339026f, -0.28262430f, 0.06492082f, 0.18108119f, 0.44728842f, 0.14535795f, 
    0.05247244f, 0.17906523f, 0.11859220f, -0.28276715f, -0.04702695f, 0.44964755f, -0.01063329f, -0.22609638f, 
    0.07250732f, -0.06919293f, 0.32361555f, 0.31941614f, 0.35911646f, 0.10648228f, 0.07329600f, -0.19460647f, 
    0.18503842f, 0.30831692f, -0.13714705f, 0.00418487f, 0.38116679f, 0.51253211f, 0.53100538f, 0.30533379f, 
    -0.36746114f, 0.08157218f, 0.29722154f, -0.02020857f, 0.13131784f, -0.23726453f, 0.01698435f, -0.03066577f, 
    -0.04987714f, -0.07121298f, -0.06100346f, -0.06304971f, -0.13106504f, 0.05292637f, -0.31045491f, 0.18607502f, 
    -0.14944275f, 0.11503936f, 0.17388812f, 0.10418991f, -0.05107966f, 0.10927713f, 0.26458669f, 0.02641597f, 
    -0.25398806f, 0.09968778f, 0.16490766f, -0.02328192f, 0.21027127f, 0.51337934f, -0.47619671f, -0.10292007f, 
    -0.07341279f, -0.42002374f, 0.14321893f, 0.20263357f, -0.36525100f, -0.19911540f, 0.11363532f, 0.11402012f, 
    -0.02810676f, 0.03075296f, 0.25613782f, -0.29218510f, 0.18580087f, 0.04772281f, 0.18009053f, 0.35286793f, 
    0.07714820f, 0.16915090f, 0.47971433f, -0.20982979f, 0.00456465f, -0.23583592f, -0.03084072f, -0.10931361f, 
    0.47141674f, 0.04386115f, 0.07420780f, -0.06446792f, 0.05021042f, 0.44605201f, 0.11441010f, -0.16450150f, 
    -0.39410314f, 0.07455728f, -0.26107565f, -0.00434837f, 0.19609277f, -0.28878012f, -0.51255435f, 0.21636476f, 
    0.01194841f, -0.02457597f, -0.37113541f, 0.17906363f, 0.51323867f, 0.33488435f, 0.30071968f, -0.14232752f, 
    0.46911848f, 0.02154167f, 0.06002748f, -0.39469323f, 0.15123086f, -0.44584563f, 0.09890503f, -0.11872277f, 
    -0.15066463f, 0.19855595f, -0.03077597f, 0.10525895f, -0.00501869f, 0.29596063f, -0.00289892f, 1.10763216f, 
    0.19081677f, -0.35976937f, 0.34404331f, 0.37522388f, -0.15243530f, -0.16659801f, -0.08612941f, 0.33392546f, 
    0.04425277f, -0.03091360f, 0.21516889f, 0.14720038f, -0.27628383f, -0.03740245f, -0.17399782f, 0.53588986f, 
    -0.81095129f, 0.31309742f, -0.01869424f, -0.32915440f, -0.21529233f, -0.17283575f, 0.07765483f, 0.11294449f, 
    0.25872317f, -0.02067171f, -0.00914708f, 0.10985009f, 0.06477299f, 0.00860340f, -0.06943554f, -0.38775322f, 
    0.11961042f, 0.34579360f, -0.18348601f, -0.03764634f, 0.61402190f, 0.36093506f, -0.05085031f, 0.10773534f, 
    0.19225432f, -0.15996014f, 0.04815866f, 0.03104178f, 0.10475887f, -0.06254212f, 0.19394018f, -0.38297552f, 
    0.04305167f, -0.05299804f, 0.12716646f, 0.09412122f, -0.15762444f, 0.12511638f, -0.14771964f, -0.19212724f, 
    -0.06599133f, -0.15488192f, -0.14456694f, -0.10825706f, 0.07883478f, -0.05531570f, 0.03715993f, -0.03053275f, 
    0.09366071f, -0.12138820f, -0.10518058f, -0.03141954f, 0.01980563f, -0.10097315f, -0.00556052f, -0.15840147f, 
    -0.00360743f, -0.06534011f, 0.13952726f, 0.10957681f, -0.18659437f, 0.12144928f, -0.15342194f, 0.06465053f, 
    0.38683593f, -0.44912508f, 0.45735204f, -0.33572412f, -0.66603559f, -0.43883470f, 0.30812266f, 0.07247092f, 
    -0.09410472f, -0.30267203f, 0.01104930f, -0.15703472f, -0.17872648f, 0.37756741f, 0.22205119f, 0.28039464f, 
    0.59783709f, 0.03421211f, 0.21987300f, -0.10499985f, 0.00845451f, -0.22465402f, 0.06820434f, 0.11236987f, 
    0.28814068f, 0.14625928f, 0.30248868f, -0.40173021f, -0.11127789f, 0.04514043f, -0.56388575f, 0.18450879f, 
    -0.08730669f, -0.19924322f, -0.37680969f, -0.63554335f, 0.21920688f, 0.01771596f, 0.30990458f, -0.04960178f, 
    -0.94942456f, 0.38391632f, 0.00205434f, -0.08154020f, 0.22468294f, -0.10074759f, 0.35966194f, 0.10696234f, 
    -0.16762882f, -0.03025367f, 0.23341157f, 0.30405274f, -0.85422790f, 0.23503962f, 0.65409988f, 0.15732929f, 
    -0.61084646f, -0.07919747f, 0.03675371f, 0.07739194f, -0.34230384f, -0.17279153f, -0.37751356f, -0.02219108f, 
    -0.22243111f, -0.17701706f, -0.18642418f, -0.12765571f, 0.12152790f, 0.03698101f, 0.06601556f, 0.01595772f, 
    -0.13432056f, -0.12941483f, -0.17567326f, 0.13974424f, 0.01305232f, -0.12266891f, 0.06170394f, 0.11604463f, 
    0.01706847f, -0.12326980f, 0.06879915f, 0.05880755f, -0.17289767f, -0.15210448f, -0.13264777f, -0.06946509f, 
    -0.02997648f, -0.01062800f, 0.04896453f, 0.00729791f, -0.01124710f, -0.04983272f, 0.12816933f, -0.07263772f, 
    -0.13270678f, -0.02890413f, 0.04578755f, -0.02899692f, -0.07954383f, -0.09905982f, -0.08525035f, -0.08268373f, 
    -0.00605292f, -0.09211101f, 0.13538818f, -0.09059606f, -0.18104777f, 0.14488725f, 0.15709347f, -0.12183554f, 
    -0.08034689f, -0.02531006f, -0.10022195f, -0.11840878f, -0.16461559f, 0.07717115f, 0.10032526f, 0.09553105f, 
    -0.08091298f, -0.17086874f, 0.12639739f, 0.08267400f, -0.18528689f, -0.13478895f, -0.18492763f, -0.16003063f, 
    0.45752376f, 0.25185400f, 0.01787837f, -0.13309218f, -0.21442458f, 0.07910896f, -0.14234760f, 0.48842722f, 
    0.30468026f, -0.08798628f, 0.19827935f, -0.04854533f, -0.18440877f, -0.31091145f, 0.03933841f, 0.31861743f, 
    0.57254112f, 0.17986801f, 0.15765050f, 0.04985738f, -0.03935359f, -0.07108995f, 0.12182718f, 0.13155250f, 
    0.25781202f, 0.05832880f, 0.77119857f, 0.02024320f, -0.11043842f, -0.46763128f, -0.23545621f, 0.11356755f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.24305068f, -0.24099159f, 0.33173561f, 0.37470934f, -0.08522031f, 0.38837203f, 0.16647065f, -0.13990273f, 
    0.03527727f, -0.09093077f, 0.11851048f, 0.36046699f, -0.43830892f, -0.33135509f, -0.16591275f, 0.14230052f, 
    0.02946650f, -0.05593020f, -0.04897257f, 0.04807990f, 0.57552171f, 0.36874256f, 0.04508166f, 0.22341113f, 
    0.07079212f, 0.11066224f, 0.04615648f, -0.06580178f, 0.23655415f, -0.08976640f, -0.01889730f, 0.18308628f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.11733172f, 0.13408087f, 0.16816694f, -0.05518036f, -0.51758456f, -0.77173835f, 0.03998832f, -0.05740468f, 
    0.09095979f, -0.35986790f, 0.23908088f, 0.01794710f, 0.38535473f, 0.71707642f, 0.32074007f, 0.23415843f, 
    -0.37494957f, -0.24936682f, 0.13862498f, -0.03646516f, -0.19483341f, 0.11822182f, 0.09044247f, 0.02374643f, 
    -0.03169179f, -0.00610002f, 0.02165370f, -0.58075649f, -0.09650108f, -0.00407079f, -0.07352166f, -0.04338139f, 
    -0.15869781f, 0.22091375f, 0.10469274f, 0.14488037f, -0.23485972f, -0.40433797f, 0.34558415f, -0.22198404f, 
    -0.43965474f, 0.05397862f, 0.11135342f, 0.44517097f, -1.59285676f, -1.05810738f, -0.88714147f, 0.09462603f, 
    -0.32348847f, -0.12819551f, -0.07468188f, 0.00547832f, 0.28278732f, 0.03605168f, -0.21931845f, -0.23557100f, 
    0.06321198f, 0.07164155f, -0.03011153f, -0.07509699f, 0.54236615f, -0.14502378f, -0.10334905f, 0.22735864f, 
    -0.22220178f, -0.19359152f, -0.23149242f, -0.04687548f, -0.01194231f, 0.56039345f, -0.38609535f, 0.19941723f, 
    -0.02734640f, 0.01992036f, -0.68660569f, -1.14823365f, -0.11540104f, -0.51180959f, -0.28367856f, -0.25020841f, 
    0.28697154f, 0.07744524f, -0.13436711f, -0.84389764f, -0.05160874f, 0.44353980f, 0.14501165f, 0.01150535f, 
    0.31788319f, -0.34919497f, 0.12387379f, 0.42515293f, -0.38199821f, -0.11038311f, 0.12474632f, -0.64086467f, 
    0.13514473f, -0.32053682f, 0.13535862f, -0.13044192f, -0.18982679f, 0.33617908f, -0.57342672f, 0.24044390f, 
    0.08048233f, -0.24262968f, 0.24596778f, 0.06422624f, -0.25361663f, 0.01254648f, 0.38788295f, 0.27715552f, 
    0.01177257f, -0.14865711f, -0.14937302f, -0.23106444f, 0.08746436f, 0.15056828f, 0.10701444f, -0.15877460f, 
    0.09542485f, -0.51980126f, 0.04290914f, -0.28865093f, 0.08252025f, 0.06032833f, -0.17939350f, -0.48687360f, 
    0.24347633f, 0.15570584f, -0.03639283f, 0.36610809f, -0.23791173f, -0.25221515f, 0.05905082f, 0.11693641f, 
    0.17981960f, -0.46917054f, 0.28951523f, 0.06581000f, 0.35898003f, -1.30378127f, -0.10914563f, -0.93504500f, 
    0.12132377f, 0.10333962f, 0.12535802f, -0.07416299f, -0.17542283f, 0.01807359f, -0.13534015f, -0.33144420f, 
    0.15307137f, 0.26511556f, 0.11770989f, -0.82783496f, 0.03976329f, -0.03932188f, -0.02295973f, -0.14603992f, 
    -0.01575491f, 0.23878163f, -0.02202422f, -0.01130469f, 0.13102576f, -0.63001168f, 0.15449095f, 0.23233505f, 
    -0.10162227f, 0.29908103f, -0.27820903f, -0.09732647f, -0.12575302f, 0.27319947f, -0.54535514f, -0.22404744f, 
    0.01290101f, -0.12861884f, 0.06036326f, 0.04820039f, 0.08592377f, -0.01893496f, 0.22109932f, -0.23862043f, 
    0.12030396f, -0.43800935f, 0.12615547f, 0.23542945f, -0.01592740f, 0.02235047f, -0.03838928f, 0.18835962f, 
    -0.42794910f, -0.25775829f, -1.34127426f, -0.99071121f, 0.37789929f, 0.58926612f, -0.64428443f, 0.12864703f, 
    -0.46894047f, 0.26966634f, -0.99976385f, -0.33332536f, -0.64917749f, -0.08918083f, -0.01272024f, 0.08148291f, 
    0.11666846f, -0.14940837f, 0.09666656f, 0.02340351f, 0.21671705f, -0.10081675f, -0.07677071f, 0.33632019f, 
    -1.44211435f, 0.17140730f, 0.09860364f, -0.03597681f, -0.24992810f, -0.17871679f, -0.12667510f, -0.55771947f, 
    0.29704693f, 0.14382912f, -0.01054894f, 0.19497572f, -0.83111548f, -0.07785080f, -0.01029969f, 0.22662859f, 
    0.25095460f, -0.09618167f, -0.84728825f, -1.10591352f, 0.49874365f, -0.08309946f, 0.14454842f, -0.11781105f, 
    0.38796085f, -0.15539180f, 0.02461846f, 0.55301648f, 0.04691874f, -0.60567307f, -1.23334503f, 0.03203194f, 
    -1.01415908f, 0.31742698f, -0.10407610f, -1.06373346f, -0.37619737f, -0.13583209f, -0.15711805f, 0.05935108f, 
    -0.64654189f, 0.24001582f, 0.09041300f, -0.33109960f, -0.18382220f, 0.46115378f, 0.28029832f, -0.75924712f, 
    -0.58721828f, 0.18788254f, -1.13486111f, -0.48788330f, -0.35424164f, -0.27595443f, -0.28416181f, -0.00278416f, 
    -0.40932971f, 0.10077851f, -0.10946675f, 0.29800463f, 0.01060571f, 0.13489954f, -0.18582171f, 0.05173095f, 
    0.10137751f, -0.43222100f, 0.02837663f, 0.53496695f, -0.26318440f, 0.08720303f, -0.18038137f, 0.21844400f, 
    0.25394410f, -0.64160967f, -0.90049553f, 0.03405593f, 0.17777795f, -0.15432285f, 0.01793304f, 0.05594475f, 
    0.17670003f, -0.01192812f, 0.32997778f, -0.46098274f, -0.92447793f, -0.69742537f, -0.26409495f, -0.35983917f, 
    0.27184606f, 0.05865738f, -0.01358262f, -0.47260588f, 0.30905715f, -0.04214865f, 0.26176521f, 0.31450313f, 
    -0.17643625f, 0.32427838f, 0.12303438f, -1.21663499f, -0.62792367f, -0.09425332f, 0.06835924f, -0.75761724f, 
    0.23468968f, 0.16651972f, 0.13184646f, 0.16260503f, -0.53126585f, -0.01821201f, 0.05443373f, -1.08031440f, 
    0.32209355f, -0.22005856f, -0.28886524f, 0.13046795f, -0.64353061f, -0.90207613f, -0.76686347f, 0.27579379f, 
    0.08632108f, -0.15444507f, -0.15909071f, 0.39746296f, -0.88849062f, -0.21255182f, -0.18357062f, 0.01671841f, 
    0.29854706f, -0.66617471f, 0.09625490f, -0.10647292f, -0.69973868f, 0.00378952f, -0.20031798f, 0.28459981f, 
    -0.64655805f, -0.00119434f, -0.23410338f, -0.67325687f, 0.48625362f, -0.29041731f, 0.00587152f, -0.44604948f, 
    0.31905058f, 0.34262657f, 0.06095913f, 0.26080212f, -0.25196314f, -0.89755327f, -1.40558183f, 0.34962794f, 
    0.04390530f, -0.04702082f, 0.00944406f, -0.38582066f, -0.33505017f, 0.14701714f, 0.03827560f, 0.24968214f, 
    -0.14634675f, -0.09879941f, -0.10950910f, -0.34491324f, -0.28028032f, 0.10676757f, -0.15340383f, 0.12128501f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.23978612f, 0.35984844f, 0.08871983f, 0.11640946f, -0.15185493f, -0.17184900f, 0.03482946f, -0.25617537f, 
    -0.07431928f, 0.45232946f, 0.12671904f, -0.15978754f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
