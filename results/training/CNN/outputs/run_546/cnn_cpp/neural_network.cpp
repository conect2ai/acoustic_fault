#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.05605698f, 0.91992360f, 0.76648647f, -0.13133529f, -0.30152270f, -0.23473874f, -0.36766931f, 0.12630333f, 
    0.25212747f, -0.04690926f, 0.50119507f, -0.52799392f, 0.15141404f, -0.35581017f, -0.02816620f, 0.77774262f, 
    0.13734293f, 0.48537487f, 1.13997769f, -0.59015661f, -0.69811726f, 0.36485964f, -0.47703928f, 0.06689757f, 
    -0.42623329f, -0.24436781f, 0.10763565f, 0.64772725f, 0.54308569f, 0.67227548f, -0.63322592f, 0.47671285f, 
    -0.53027296f, 0.47915781f, -0.05604974f, 0.00148412f, 0.77015138f, 0.45053238f, -0.57047927f, 0.14435329f, 
    0.62291646f, 0.88486564f, 0.51436979f, -0.01629100f, -0.17136048f, -1.02314651f, -1.03832102f, -0.55660230f, 
    -0.46810654f, -0.48631215f, -0.30032668f, 0.28009859f, 0.27614710f, 0.16045146f, -0.17868303f, 0.81341797f, 
    -0.27046859f, 0.70656431f, -0.37902528f, -0.34058809f, -0.42120084f, 0.00952663f, -0.43097055f, -0.39527819f, 
    -0.43608686f, -0.03233742f, 0.51623189f, -0.32499301f, -0.54960150f, -0.49750981f, -0.50253725f, -0.40221146f, 
    -0.04546708f, 0.50702488f, 0.90614045f, 0.26223725f, 0.45013276f, 0.57835013f, 0.12853226f, -0.03749931f, 
    -0.12990034f, -0.79138201f, -0.66630954f, -0.73383433f, 0.50746989f, 0.41325828f, 0.89006174f, 0.04983613f, 
    -0.24610199f, -0.22472680f, 0.26778328f, 0.00279386f, -0.00868039f, -0.95930958f, -1.25065112f, -0.60381252f, 
    -0.04471936f, 0.03563087f, 0.18136488f, 0.05008920f, 1.12652981f, -0.49233773f, -0.27017215f, -0.06243415f, 
    -0.78232896f, 0.09131298f, -0.01303084f, 0.02684323f, 0.34015334f, 0.31693235f, 0.37278971f, 0.13795865f, 
    0.37015200f, 0.07000579f, -0.70080054f, -0.08288867f, -0.62024707f, -0.37731957f, 0.52005363f, 0.33688956f, 
    0.32558921f, -0.07263194f, -1.25230443f, 0.09261981f, 0.03693583f, 0.38478702f, 0.06906238f, 0.12844069f, 
    0.11003006f, -0.78423262f, 0.52426052f, -0.51887614f, -0.80172914f, -0.49476466f, -0.26339987f, 0.87462097f, 
    0.37157974f, 0.68024206f, 0.74399215f, 0.68383354f, -0.28537545f, 0.10305129f, 0.42335391f, 0.42484891f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.25181210f, 0.19534962f, 0.06962901f, -0.15007359f, -0.52127743f, 0.21276563f, -0.10809575f, 0.08597032f, 
    0.64672345f, 0.04915608f, 0.71240103f, 0.09363910f, 0.28853974f, 0.16539563f, 0.14396054f, 0.45417440f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.00264620f, -0.04854541f, -0.07381293f, -0.03732518f, 0.04625870f, 0.06115275f, -0.08096404f, 0.00015660f, 
    0.05666860f, -0.04905618f, 0.06453190f, -0.08687840f, -0.08092159f, -0.01411625f, 0.02866090f, 0.04287878f, 
    -0.05800446f, -0.07532280f, 0.05465793f, -0.00906748f, 0.02778869f, 0.04179645f, -0.00479918f, -0.07668291f, 
    -0.02831291f, 0.04341193f, -0.04221022f, 0.00328058f, 0.01438981f, 0.06745467f, -0.08542599f, 0.01753362f, 
    -0.07606365f, -0.06845623f, -0.03398410f, -0.07497227f, -0.01525688f, 0.05290456f, 0.04722281f, -0.05110489f, 
    -0.06291771f, -0.02668414f, -0.04522079f, 0.04469895f, -0.06663925f, -0.00294337f, 0.07572586f, -0.06369409f, 
    0.06435844f, 0.07592136f, -0.03962412f, 0.00276205f, 0.00666733f, -0.02436522f, 0.04619953f, -0.03569027f, 
    0.02155938f, 0.04204324f, -0.04650271f, -0.07247158f, 0.07173710f, -0.03887489f, -0.02796920f, -0.04107513f, 
    0.02386054f, -0.07621144f, 0.03302772f, -0.00023969f, 0.07427998f, 0.06042911f, -0.06333369f, 0.06364758f, 
    0.00704435f, 0.02924959f, -0.01009974f, 0.02158088f, 0.00295630f, -0.06063339f, -0.03760427f, -0.07465122f, 
    0.03038284f, 0.04760421f, 0.04097890f, -0.04102005f, -0.00902052f, -0.04540017f, 0.05159729f, 0.06752706f, 
    -0.05252506f, -0.04099729f, 0.00124245f, -0.08456651f, 0.04138963f, -0.07096077f, 0.00901966f, -0.06669290f, 
    -0.06372682f, -0.00361627f, -0.04846182f, -0.08749839f, 0.00262633f, -0.01470636f, -0.02457060f, -0.04891380f, 
    0.01273395f, 0.00410442f, -0.07007653f, 0.05886263f, -0.00928627f, 0.05864846f, -0.06427855f, -0.01175921f, 
    0.03140712f, -0.03701235f, 0.06488535f, 0.00174141f, 0.07226793f, 0.03242671f, -0.03258698f, -0.05009875f, 
    0.02044392f, 0.04902856f, 0.01348507f, -0.08134950f, -0.07618232f, -0.06971869f, 0.05324518f, -0.05227728f, 
    -0.04653163f, -0.09210953f, -0.03102379f, -0.06832385f, 0.00213047f, -0.02400387f, -0.04220042f, 0.05379471f, 
    -0.03821928f, 0.02213341f, 0.00192642f, -0.02660036f, 0.00755300f, 0.06291376f, -0.05522682f, -0.04465453f, 
    0.10302296f, 0.09655937f, 0.34362939f, 0.04300505f, 0.02579237f, 0.22485439f, -0.14383659f, -0.02849418f, 
    0.02712624f, 0.02289027f, -0.28377864f, -0.09582199f, -0.08842226f, 0.19020191f, -0.07828677f, 0.15186785f, 
    -0.16834240f, -0.24956179f, -0.41858426f, -0.07659639f, 0.10212462f, 0.27198148f, -0.12786980f, 0.21641307f, 
    0.01751124f, 0.10269482f, 0.07219000f, -0.26506206f, -0.04674407f, 0.30683574f, -0.06364082f, -0.13794005f, 
    0.08704841f, -0.05458537f, -0.07664878f, 0.02694380f, -0.01380092f, -0.02029799f, -0.35978943f, -0.43005869f, 
    -0.04388104f, -0.13595943f, 0.09956952f, 0.16381110f, 0.13797805f, -0.38526276f, -0.50324392f, 0.18728349f, 
    0.27952147f, 0.12546135f, 0.09697255f, 0.01372652f, 0.21881193f, -0.05422224f, -0.01133265f, -0.12273908f, 
    0.06429918f, 0.39932826f, 0.07343446f, 0.04803826f, 0.06256989f, -0.27565581f, -0.08091746f, -0.06582397f, 
    -0.11364537f, 0.06817676f, -0.19457492f, -0.08227155f, 0.01796558f, 0.02044266f, 0.43922806f, 0.03721642f, 
    0.56218189f, -0.02920669f, 0.01331736f, -0.18812163f, 0.09038170f, 0.06613228f, 0.15579581f, 0.17344509f, 
    0.26565957f, -1.07224619f, -0.12672231f, 0.17832260f, 0.37583324f, 0.15121751f, 0.06403641f, 0.04158371f, 
    -0.04856549f, 0.00698683f, 0.03178752f, 0.05888471f, 0.13281903f, -0.07552925f, -0.04603108f, -0.00980049f, 
    0.12195975f, -0.07825814f, 0.23306052f, -0.00823884f, -0.08617368f, 0.06613243f, 0.03658131f, -0.16251591f, 
    0.09097001f, 0.08866449f, -0.24900711f, -0.18728592f, 0.18212196f, 0.13970527f, -0.03979900f, 0.10657235f, 
    0.04661965f, -0.08415309f, -0.05599349f, 0.24349737f, 0.15895258f, 0.07355973f, 0.09145340f, 0.00807315f, 
    0.18329908f, 0.15574542f, 0.11205150f, 0.27902579f, 0.14421235f, -0.08506441f, 0.01970830f, -0.00871147f, 
    0.02865541f, -0.19507810f, 0.26603284f, 0.12183271f, 0.10768525f, 0.18603417f, -0.03206271f, 0.09290678f, 
    -0.18362989f, -0.09920602f, -0.15487421f, 0.22500311f, -0.11989421f, 0.25129256f, -0.02962190f, 0.12067333f, 
    -0.04241987f, -0.07100904f, -0.06827243f, -0.02895604f, -0.04615579f, -0.01753003f, -0.04569569f, -0.07794981f, 
    -0.05362461f, 0.04228494f, 0.05490631f, -0.06951941f, -0.07669425f, 0.01013445f, -0.01411339f, 0.02272237f, 
    0.03941946f, 0.04188485f, -0.01050054f, 0.01424216f, 0.01658846f, -0.02409138f, 0.05886260f, 0.05208794f, 
    0.01902313f, 0.05268224f, 0.00690003f, 0.01090346f, 0.01027383f, 0.07002988f, -0.04463239f, -0.09093199f, 
    -0.02914550f, -0.05499089f, -0.07732046f, 0.02425985f, 0.03377854f, -0.03777374f, 0.06063095f, 0.02247579f, 
    0.02457807f, -0.08343618f, -0.07036690f, 0.03955122f, -0.03971284f, -0.03443939f, -0.03530066f, -0.03252714f, 
    -0.03365258f, -0.03441004f, -0.06108413f, -0.02672530f, -0.00394149f, 0.04800790f, -0.02307875f, 0.02237240f, 
    -0.07544538f, 0.06097869f, -0.08801151f, 0.06930905f, 0.06773681f, 0.02291322f, -0.07050405f, 0.05058841f, 
    -0.05986078f, 0.06978104f, -0.06385003f, -0.03055608f, 0.02799234f, -0.05179564f, -0.02451761f, 0.01190177f, 
    -0.04709979f, 0.05297929f, -0.02105485f, -0.03169607f, -0.08535276f, -0.07181635f, 0.00800247f, 0.04856205f, 
    -0.06047908f, 0.01609978f, -0.05735355f, -0.03558160f, -0.02107894f, -0.07157690f, 0.00655893f, -0.07244448f, 
    0.04412313f, 0.01877052f, -0.03737816f, -0.05120165f, 0.02597701f, -0.03619041f, -0.00648221f, -0.02514979f, 
    0.05119948f, -0.05843357f, 0.03463844f, -0.00227183f, 0.02801824f, -0.07484791f, -0.06840892f, 0.05257132f, 
    -0.02346456f, -0.02330286f, 0.03394597f, -0.07569584f, -0.05967270f, -0.08756497f, -0.01002826f, 0.01338899f, 
    -0.04306694f, -0.00342172f, 0.04803007f, -0.07368610f, -0.07660523f, -0.04681139f, -0.04788522f, -0.02761736f, 
    0.04811908f, -0.08063611f, -0.08769170f, 0.02493791f, -0.03639774f, -0.05984744f, 0.03492893f, 0.06940284f, 
    0.04980268f, 0.00707057f, -0.01019643f, 0.08050642f, 0.02676087f, 0.06936387f, -0.02854681f, 0.04148862f, 
    0.01358308f, -0.08810801f, 0.04473949f, -0.07856800f, 0.03062779f, -0.06957639f, -0.04862418f, 0.01324624f, 
    -0.06598478f, -0.07809877f, 0.05158019f, 0.04687352f, -0.02924046f, -0.00497316f, 0.01272113f, 0.03232540f, 
    -0.01828295f, -0.07021277f, 0.02432644f, -0.10114846f, -0.04755611f, -0.10550499f, -0.02888224f, -0.09355678f, 
    0.04697597f, 0.05875714f, -0.04845189f, -0.04313123f, -0.04142274f, -0.09326413f, -0.00189578f, 0.04329639f, 
    0.00323541f, -0.00302610f, -0.00482039f, -0.10831956f, 0.01883793f, -0.08995093f, 0.05033378f, -0.00666667f, 
    -0.01451890f, -0.00756647f, -0.05868740f, -0.06015792f, -0.08096594f, 0.04566481f, -0.09910350f, -0.02084044f, 
    0.03436599f, 0.03870116f, 0.04484800f, 0.04891015f, -0.05620675f, 0.01844065f, 0.05565858f, -0.01577564f, 
    0.02111762f, -0.01923411f, -0.09667142f, -0.05856742f, -0.04490377f, 0.01485948f, -0.00331322f, -0.02170954f, 
    0.03807210f, 0.00506762f, 0.04812726f, -0.10021035f, 0.04214746f, 0.00768895f, -0.08155294f, -0.05488157f, 
    -0.09073390f, -0.08215131f, -0.03186934f, 0.06520834f, 0.01773771f, -0.02763902f, -0.06744725f, -0.03027106f, 
    0.00159353f, 0.06240375f, 0.00409912f, -0.02961113f, -0.05986441f, -0.05621420f, -0.03395188f, 0.00804402f, 
    0.03336005f, -0.05758061f, 0.05954518f, -0.00601173f, -0.06659760f, -0.07605996f, -0.07332882f, -0.01015474f, 
    0.04765525f, 0.04660939f, 0.04075423f, -0.02020606f, 0.03320603f, -0.08118249f, -0.03005768f, -0.01195457f, 
    0.05574981f, -0.01419629f, 0.02416712f, -0.02157435f, -0.03370879f, -0.04298732f, 0.01946463f, 0.03059543f, 
    0.04455792f, -0.08302461f, 0.02277227f, -0.00324730f, 0.03276513f, 0.04605600f, -0.05655373f, -0.03743024f, 
    -0.05529436f, 0.03029306f, 0.04944209f, -0.07525354f, 0.03286077f, -0.04840565f, 0.00447584f, -0.09440257f, 
    0.02655835f, -0.00890728f, -0.06473656f, -0.04183990f, -0.09818838f, 0.00321951f, 0.00658591f, 0.03776687f, 
    -0.01163354f, 0.02486656f, 0.01989796f, 0.00489803f, -0.00383614f, -0.05462077f, 0.04333953f, -0.04569626f, 
    -0.02654154f, -0.03022904f, -0.00313648f, 0.01249710f, -0.02898871f, -0.05844201f, 0.06536554f, -0.05291198f, 
    -0.03724197f, -0.00888165f, 0.00733538f, -0.07377916f, -0.01183850f, -0.06524905f, -0.08384495f, -0.05780471f, 
    -0.05404471f, -0.04351286f, -0.08357337f, 0.06898937f, -0.03709797f, 0.07251474f, 0.01600444f, -0.04528755f, 
    0.00012982f, -0.06251983f, -0.01881127f, -0.08683717f, 0.02943624f, -0.01579284f, -0.04446144f, 0.06659821f, 
    -0.05980280f, 0.07350828f, 0.07612125f, -0.07721044f, 0.05697902f, 0.06920387f, -0.07176808f, -0.07987162f, 
    -0.04724055f, 0.05278017f, 0.02500249f, 0.02192683f, -0.01784640f, 0.02893175f, 0.01107803f, -0.03016949f, 
    0.04202961f, -0.07697256f, 0.02536975f, 0.04249167f, 0.05565531f, -0.08534458f, 0.02032226f, 0.04247708f, 
    -0.03324253f, -0.07001671f, 0.06032447f, 0.02182751f, -0.06471398f, 0.04131797f, -0.07200330f, -0.07044730f, 
    0.07637235f, -0.08228204f, -0.02248159f, -0.02142118f, -0.05190498f, -0.08374812f, -0.05953382f, -0.08783583f, 
    0.07171220f, -0.07112154f, 0.07367427f, -0.01743509f, 0.02327131f, -0.04984773f, -0.01814707f, 0.06914297f, 
    -0.00955183f, -0.05079168f, -0.01087114f, 0.00769475f, 0.00526326f, -0.01938456f, 0.02723418f, -0.06424690f, 
    -0.01633888f, -0.04758873f, 0.03606246f, -0.04794253f, -0.00854487f, -0.08641665f, -0.02829031f, 0.01601839f, 
    -0.08214673f, 0.02715203f, -0.04643751f, -0.05689687f, 0.00021569f, -0.05521828f, -0.07063456f, -0.05655549f, 
    -0.01530767f, 0.05949258f, 0.05207204f, 0.05450809f, 0.04633562f, 0.01498704f, -0.08517398f, 0.03594521f, 
    -0.04113692f, -0.03539100f, 0.03140580f, 0.07724949f, -0.03260332f, -0.07296831f, -0.01986146f, 0.00045465f, 
    -0.06599894f, 0.00382742f, 0.06512376f, 0.04579170f, -0.04626392f, -0.02242815f, -0.01380836f, -0.00008717f, 
    -0.01414394f, 0.04419183f, 0.01719238f, 0.02054893f, -0.00312510f, -0.07774429f, 0.02530065f, 0.03950231f, 
    0.07651397f, -0.01274233f, -0.00098396f, -0.08682664f, -0.02596858f, -0.03401972f, 0.05334817f, 0.05985995f, 
    -0.07702576f, 0.04796759f, -0.03806568f, -0.07646384f, -0.07425354f, 0.06300880f, -0.07839867f, 0.04796011f, 
    0.08653366f, -0.16279620f, 0.08780461f, 0.06845539f, 0.09484379f, 0.02038992f, -0.04906439f, 0.20606838f, 
    0.04324048f, 0.10867767f, 0.23166038f, 0.06627646f, 0.10268398f, 0.01058614f, -0.01014913f, -0.14327197f, 
    -0.08249936f, -0.13432458f, 0.16740587f, -0.11952845f, -0.30811360f, 0.14105682f, -0.23105669f, -0.19725509f, 
    0.11681539f, 0.08263766f, 0.03945001f, -0.29841015f, -0.05269499f, 0.33611116f, 0.11983969f, 0.11709797f, 
    -0.05723479f, -0.09870879f, 0.09510560f, 0.05197050f, -0.41472408f, 0.08548007f, -0.48605400f, 0.27571264f, 
    -0.06685714f, -0.12174118f, -0.04195667f, 0.07297003f, -0.11211278f, -0.01298090f, 0.62042201f, 0.14398152f, 
    -0.07965701f, 0.16840948f, -0.14248943f, -0.00547095f, 0.06511927f, -0.14177138f, 0.48116490f, 0.20257197f, 
    0.03662083f, -0.14178509f, -0.11272367f, -0.18287593f, 0.10797071f, 0.20891316f, -0.00447194f, 0.31191084f, 
    -0.07149284f, 0.21728086f, 0.02969399f, -0.03801110f, 0.07742700f, -0.06943148f, -0.05165125f, 0.05853441f, 
    -0.29418024f, 0.21700500f, -0.09794503f, 0.07060473f, 0.10106976f, 0.04073942f, 0.01251221f, 0.04368468f, 
    0.05405908f, 0.23654675f, 0.30111647f, 0.11764758f, 0.30721319f, 0.18084335f, -0.10201019f, -0.06902748f, 
    0.16376814f, 0.05275060f, 0.32993358f, -0.23511502f, -0.12733042f, -0.32286307f, -0.03347404f, -0.06769294f, 
    0.16404071f, -0.13017209f, -0.12936594f, 0.39050278f, 0.12970725f, -0.06743570f, 0.00859598f, -0.39282295f, 
    -0.20740160f, 0.08713024f, -0.05381161f, -0.05248115f, -0.01723589f, 0.16062438f, -0.21075681f, 0.14700323f, 
    0.26109308f, 0.02979159f, 0.05322655f, -0.26446554f, 0.18783100f, -0.05586653f, -0.17587699f, 0.27521071f, 
    -0.24449290f, 0.00347784f, 0.05669330f, 0.02464007f, -0.03820997f, 0.07478645f, -0.35878086f, -0.14611885f, 
    0.06646517f, 0.05773196f, 0.25013182f, 0.19314772f, 0.12512739f, -0.14667247f, -0.28255582f, -0.03668345f, 
    -0.26044565f, -0.10613152f, 0.10134538f, -0.01011841f, 0.20034589f, 0.22485709f, 0.07408808f, -0.15251602f, 
    0.02922734f, 0.03369386f, 0.03936733f, 0.06091513f, 0.00608871f, 0.01375313f, -0.05019358f, -0.01015904f, 
    0.07096647f, 0.00055041f, 0.00352331f, 0.04525950f, 0.03290431f, -0.00492518f, 0.04904347f, -0.08172317f, 
    -0.07107217f, 0.00424892f, -0.02763984f, 0.02741143f, -0.08654282f, -0.02359523f, -0.01630478f, 0.03797821f, 
    -0.00178382f, 0.01837054f, -0.07576503f, 0.03806410f, 0.07015769f, -0.06149217f, -0.05574792f, -0.05938924f, 
    -0.03501307f, -0.00875332f, -0.05523371f, 0.01207290f, 0.01018792f, 0.07009885f, 0.04723983f, -0.05490361f, 
    0.02538577f, -0.03565559f, -0.08222157f, -0.07852247f, 0.01154855f, -0.06991651f, 0.03599066f, 0.05808649f, 
    -0.03779761f, 0.01915216f, -0.07856591f, 0.04340493f, -0.02199478f, 0.07891279f, 0.00480699f, 0.05143817f, 
    -0.07036000f, -0.05327044f, -0.08446255f, 0.06075488f, 0.00943660f, -0.04979749f, 0.03238754f, -0.01958852f, 
    -0.07475707f, 0.03514977f, -0.03937913f, -0.07098007f, -0.03122743f, 0.01499477f, -0.01256807f, 0.03733470f, 
    -0.02504247f, 0.04975920f, 0.00082969f, -0.01979032f, 0.00935861f, 0.06315033f, -0.05603550f, -0.00576286f, 
    -0.03989839f, 0.02486699f, -0.07819314f, -0.01215316f, -0.00891982f, -0.04199925f, -0.00183559f, 0.03187940f, 
    -0.06503057f, -0.01169720f, -0.05914214f, -0.03874390f, -0.07656886f, -0.06415432f, -0.08129486f, 0.05432574f, 
    -0.08181643f, 0.06976526f, -0.07147460f, -0.08994399f, -0.00946124f, -0.02624207f, -0.08181677f, 0.04822677f, 
    0.04861780f, -0.03276212f, -0.04398253f, 0.07162356f, -0.02336537f, 0.02304312f, 0.00682047f, -0.07217798f, 
    0.05059734f, 0.04688698f, -0.01797658f, -0.02553895f, -0.03492808f, -0.02456297f, -0.06335667f, 0.05252593f, 
    -0.04230501f, 0.03182132f, -0.08607756f, -0.02478588f, -0.07156429f, 0.00529483f, -0.09151454f, 0.04459905f, 
    -0.04423782f, -0.08359120f, 0.02417854f, 0.02196190f, 0.03429111f, -0.06325427f, -0.04245691f, -0.04678579f, 
    -0.06151167f, 0.04131427f, 0.01363482f, 0.04114769f, -0.09126102f, -0.05063820f, 0.05443748f, -0.06914082f, 
    0.38018364f, 0.27012286f, 0.01612317f, 0.12197155f, 0.04734423f, 0.07704245f, -0.01173414f, -0.00803320f, 
    -0.03943666f, 0.05709084f, 0.09388657f, -0.00179966f, -0.06920981f, 0.16448292f, -0.25853336f, 0.12405884f, 
    0.04230539f, 0.05897290f, -0.61388278f, -0.04033604f, -0.02830482f, 0.26420179f, -0.04275964f, 0.09019332f, 
    0.02154260f, -0.07484084f, 0.08709762f, 0.61988652f, 0.21044441f, -0.09194490f, -0.12519674f, -0.11888345f, 
    -0.00072836f, 0.22734849f, -0.06424619f, -0.02693246f, 0.04175987f, -0.23085523f, 0.13241772f, -0.14615265f, 
    0.06956869f, 0.16007909f, 0.02284708f, -0.09646378f, -0.13599060f, -0.05105625f, 0.29483691f, 0.03567691f, 
    0.13515349f, 0.12827446f, 0.30822730f, 0.09362540f, -0.13137178f, -0.13836825f, -0.22303721f, -0.31697688f, 
    -0.22226357f, 0.11621060f, 0.09935764f, 0.12985362f, 0.20329784f, -0.08214109f, -0.05552456f, 0.09237793f, 
    -0.07715212f, -0.15719241f, -0.13832109f, 0.24514905f, -0.14241207f, 0.22344150f, 0.06224399f, -0.08591943f, 
    0.26296985f, 0.32942104f, 0.26686561f, -0.02446924f, 0.13709427f, 0.09517598f, 0.15860535f, 0.18257509f, 
    -0.10098508f, 0.04463868f, 0.05440971f, -0.14014395f, 0.05784703f, -0.25114727f, -0.07130957f, -0.11536482f, 
    0.08104832f, -0.13710435f, -0.08656251f, -0.05853302f, -0.14806464f, 0.20057823f, -0.01535179f, 0.29855442f, 
    0.07346950f, 0.18749279f, -0.05179659f, 0.39827436f, -0.60964704f, -0.52829653f, 0.05164863f, 0.18311481f, 
    -0.10629109f, -0.00690695f, 0.02577974f, 0.20769219f, 0.23020616f, 0.15117350f, 0.19795601f, -0.14149618f, 
    0.06083247f, -0.03059562f, 0.06162394f, 0.43656886f, -0.06928336f, -0.11886548f, -0.08452332f, -0.19900264f, 
    0.01273251f, -0.07378598f, -0.09214631f, -0.03386015f, 0.11670042f, 0.21102677f, -0.16653536f, -0.07526197f, 
    -0.17980711f, 0.39121032f, 0.21460561f, 0.16364577f, -0.04341332f, -0.11786526f, 0.01225396f, 0.26802406f, 
    0.13534221f, 0.22938757f, -0.11646997f, 0.03278310f, -0.12769943f, 0.08041240f, -0.00525657f, 0.13133901f, 
    0.53751898f, -0.08208023f, 0.10132401f, -0.26606962f, -0.20635010f, -0.07563493f, -0.09636578f, 0.01284133f, 
    -0.15403885f, -0.66764247f, 0.12178996f, 0.00301949f, 0.15088476f, 0.04227734f, -0.08736047f, -0.20741019f, 
    -0.25260028f, -0.21654725f, 0.26983950f, -0.27363044f, 0.18301122f, -0.22655240f, 0.04069063f, 0.17760509f, 
    0.01317302f, 0.03658623f, 0.04411209f, -0.12607315f, -0.41250691f, -0.17156099f, 0.00059558f, -0.23852919f, 
    0.00166364f, 0.04451883f, -0.02215907f, 0.05760922f, -0.56941664f, -0.13814278f, -0.36347619f, 0.16533370f, 
    0.06352484f, -0.15044339f, 0.02405562f, -0.08614448f, -0.06375059f, -0.37017444f, -0.29871920f, 0.15711148f, 
    0.28311011f, 0.02773646f, 0.02399883f, 0.12624151f, -0.06952354f, 0.13769130f, 0.11813776f, -0.09966177f, 
    -0.05346229f, -0.21130624f, -0.24256162f, 0.04756729f, 0.00648649f, -0.01990901f, 0.09395779f, 0.02989205f, 
    0.16148680f, 0.04673045f, -0.05019614f, 0.04103342f, -0.09190301f, 0.03750851f, -0.11551587f, -0.03493591f, 
    0.19009241f, 0.12330193f, 0.16013032f, -0.09227742f, 0.03909010f, -0.02744520f, -0.05876053f, 0.06756257f, 
    0.04885904f, 0.72409058f, 0.39205211f, -0.51291364f, 0.44009691f, 0.45294768f, 0.20194636f, 0.14399347f, 
    -0.20706554f, 0.13967501f, -0.03218830f, 0.01522785f, 0.16915572f, -0.30010131f, 0.00968424f, 0.11166487f, 
    0.06924991f, 0.28134745f, 0.26380959f, -0.31770101f, 0.23264420f, 0.15250725f, -0.04926157f, -0.11224400f, 
    0.13515890f, -0.24372625f, -0.22544792f, 0.09614608f, 0.54744393f, 0.00490797f, 0.10050815f, 0.15052597f, 
    -0.12208671f, -0.14219502f, 0.01386227f, 0.22847529f, 0.08268082f, -0.21844646f, -0.13992044f, 0.04916109f, 
    -0.01276195f, -0.06348124f, -0.13445707f, -0.01186448f, 0.20454882f, 0.03524326f, -0.03210558f, -0.18173417f, 
    -0.28308430f, -0.11627172f, 0.02655230f, 0.21530631f, 0.06087572f, -0.01543062f, -0.10742997f, 0.19077320f, 
    0.27700430f, -0.00647417f, -0.03207510f, -0.17895189f, -0.00390969f, 0.25467998f, 0.10984127f, 0.09300653f, 
    -0.03158211f, 0.04585352f, -0.07434290f, -0.08395630f, -0.07032142f, 0.00730171f, 0.05853450f, -0.07840139f, 
    0.02297701f, 0.04379800f, -0.07175102f, 0.06133433f, -0.08048384f, -0.08893563f, -0.02458245f, 0.07433470f, 
    -0.01337587f, 0.02447860f, -0.05858255f, 0.00428053f, 0.06463414f, -0.03378759f, 0.02713704f, 0.07130749f, 
    -0.04940790f, 0.04369747f, -0.03434631f, -0.01108389f, 0.01390827f, 0.03813851f, -0.04489077f, -0.06133116f, 
    0.05397525f, 0.07142118f, -0.00975612f, -0.04422705f, -0.00513945f, 0.07291615f, 0.04066909f, 0.02733687f, 
    -0.07995969f, -0.07453001f, -0.04031657f, 0.02827856f, 0.00062951f, -0.08872834f, -0.03586340f, -0.04665956f, 
    0.04764637f, 0.00095152f, 0.00505624f, 0.02305356f, 0.07344176f, -0.07873402f, -0.03277862f, 0.01390193f, 
    0.01189811f, -0.01544375f, -0.04208964f, 0.00404636f, -0.01628152f, 0.03182024f, 0.04835894f, -0.02274255f, 
    -0.02706879f, 0.04808607f, -0.07098544f, -0.08106852f, -0.07227994f, 0.00419329f, -0.04122026f, -0.02977145f, 
    -0.03581482f, -0.03267432f, -0.08420610f, -0.06990677f, -0.03152578f, -0.06682115f, -0.07483318f, 0.04910166f, 
    0.01602916f, 0.00654415f, 0.02385660f, -0.03826023f, -0.03798402f, -0.02150463f, 0.07354702f, -0.03112222f, 
    -0.04374187f, 0.02631800f, -0.04476499f, 0.06140256f, -0.08482513f, -0.04810438f, 0.02523351f, -0.04323726f, 
    -0.07759645f, 0.01030782f, 0.06131558f, -0.04856307f, -0.08933298f, 0.01245197f, 0.02787652f, 0.07423437f, 
    0.03685674f, -0.01281341f, 0.00686017f, -0.05700427f, -0.00473113f, 0.07510675f, 0.00183560f, 0.01371373f, 
    0.06833479f, 0.01428230f, 0.04440790f, -0.04502131f, -0.08650295f, -0.02416342f, -0.04910863f, 0.03922291f, 
    -0.04444968f, 0.02170655f, -0.01093386f, 0.06821687f, -0.07576076f, 0.00338163f, -0.07026000f, 0.01448757f, 
    0.00252450f, 0.04089445f, -0.04011009f, -0.00614264f, -0.08673449f, 0.00682013f, 0.00385789f, -0.06120301f, 
    -0.07481701f, -0.02858415f, -0.07279968f, -0.06918505f, -0.01894938f, -0.00620400f, 0.00794378f, -0.05884438f, 
    0.05896841f, -0.04508391f, 0.00335426f, -0.05433178f, 0.00237777f, 0.05218704f, -0.00710352f, 0.03329394f, 
    0.02733407f, 0.04765588f, -0.08758537f, -0.01086729f, 0.02442960f, 0.00763960f, -0.06952792f, 0.07047780f, 
    0.01636009f, -0.07548000f, -0.05203902f, 0.02354789f, 0.00111189f, -0.00263355f, 0.05766525f, -0.01887721f, 
    -0.05006671f, 0.05118930f, -0.06569997f, 0.00544745f, -0.03849125f, 0.06601643f, -0.01906233f, 0.06706141f, 
    0.06277480f, 0.03574434f, 0.03095799f, -0.03655674f, -0.03915796f, 0.06103499f, 0.04729567f, -0.07127146f, 
    0.05370449f, -0.04952620f, 0.03127577f, -0.05641160f, -0.03138994f, -0.05019764f, 0.00882092f, 0.03575296f, 
    -0.02377762f, -0.07416733f, 0.01348198f, -0.09116025f, -0.03757095f, -0.04401320f, -0.08396638f, -0.06703178f, 
    -0.01961319f, -0.03616261f, -0.02710486f, -0.03395358f, 0.04882248f, 0.05094371f, -0.09286548f, 0.00145149f, 
    0.03032263f, 0.03450349f, 0.05221171f, 0.01202345f, -0.08285101f, -0.03865743f, -0.00214032f, 0.02281901f, 
    -0.03981583f, -0.07895624f, 0.01641959f, 0.03753524f, -0.04900982f, -0.05218847f, -0.05227451f, -0.08993021f, 
    0.03885466f, 0.06347098f, -0.08078298f, 0.01237922f, -0.01555747f, -0.04870477f, -0.05355795f, 0.05521835f, 
    0.00433831f, 0.00927342f, -0.05686806f, 0.00023829f, -0.08189657f, -0.03174481f, 0.02464136f, 0.06408250f, 
    -0.00226924f, 0.06106920f, 0.04891368f, -0.04582112f, -0.07017375f, 0.02549727f, -0.09520333f, 0.01096961f, 
    -0.06669242f, -0.01200971f, -0.07788222f, -0.07403780f, 0.02329849f, -0.06297877f, -0.08228001f, 0.05799272f, 
    -0.01550802f, -0.03461164f, 0.06067313f, 0.00192920f, -0.03256550f, -0.07985940f, -0.02014739f, -0.03316794f, 
    -0.06423447f, 0.04958777f, -0.01281121f, 0.02575838f, 0.00660023f, -0.05262097f, 0.00887217f, 0.02102893f, 
    -0.06228711f, 0.01416400f, -0.00142932f, -0.08046949f, -0.03413864f, -0.08746367f, -0.06232441f, 0.02457693f, 
    -0.08652046f, -0.02843783f, 0.01674795f, -0.04916392f, 0.00683287f, -0.01470901f, 0.05710790f, -0.04785249f, 
    -0.55486196f, -0.46809772f, -0.01073278f, 0.07877143f, -0.13171905f, 0.03015610f, 0.06255907f, -0.08526121f, 
    -0.27047497f, -0.07098706f, 0.11288831f, -0.07854415f, -0.12692600f, 0.05041894f, 0.08720390f, -0.14101952f, 
    0.20434771f, 0.04424271f, 0.15267147f, 0.46960378f, 0.08774788f, -0.12469111f, 0.17607647f, 0.01066980f, 
    -0.00894167f, 0.00109001f, -0.05401296f, -0.44700542f, -0.01653567f, 0.07701147f, 0.07820372f, -0.12872158f, 
    -0.01479829f, -0.13940971f, -0.19817747f, -0.25305897f, -0.24859974f, 0.11594870f, 0.00867031f, -0.04836272f, 
    0.30227026f, -0.15963775f, -0.05480277f, -0.10888076f, -0.05725000f, -0.21639203f, -0.17717761f, 0.16091183f, 
    -0.27861542f, -0.04183818f, -0.24884102f, -0.06416783f, 0.09786496f, 0.07840358f, 0.37125286f, 0.09341574f, 
    -0.03212703f, -0.09363037f, 0.04562260f, -0.10571599f, -0.08221230f, -0.09246145f, 0.13571611f, 0.12659289f, 
    -0.31800199f, 0.19243072f, -0.03320524f, -0.15471008f, 0.01838209f, -0.02355570f, 0.10016610f, 0.27750838f, 
    -0.39546663f, -0.05975481f, 0.35398197f, -0.06559654f, -0.07224142f, 0.23074242f, 0.19860736f, 0.09185825f, 
    -0.08314591f, 0.22522426f, -0.12683822f, 0.04517720f, -0.13910714f, 0.08122173f, 0.08661816f, -0.01083041f, 
    0.18740657f, 0.25704849f, 0.35963792f, -0.13037471f, 0.25260600f, 0.01078846f, 0.27598244f, -0.02495123f, 
    0.07166320f, -0.05290254f, 0.01742699f, 0.29263341f, -0.15085015f, -0.09673271f, 0.15923455f, -0.01693268f, 
    0.00470658f, -0.18894288f, 0.16741219f, -0.00958068f, -0.00498815f, 0.01429742f, 0.01352541f, -0.06614239f, 
    -0.08815222f, 0.24156898f, -0.08269585f, -0.07145280f, 0.30106080f, 0.18894537f, -0.37210101f, 0.05668737f, 
    0.13118283f, -0.26597947f, 0.14587736f, 0.05198689f, 0.14391685f, 0.02269501f, -0.25068453f, 0.04978400f, 
    0.17309561f, 0.26249969f, 0.10274594f, -0.03828884f, 0.21222286f, -0.00838663f, -0.11780325f, -0.36522061f, 
    -0.03016622f, -0.09962559f, 0.04860443f, 0.03790389f, 0.00659015f, 0.01510218f, 0.01758079f, 0.00443830f, 
    -0.21649165f, -0.09915385f, 0.34686738f, 0.19445437f, -0.09865458f, -0.01202208f, -0.10093507f, -0.14344802f, 
    0.04714796f, -0.13377757f, 0.31980684f, -0.17651351f, 0.14289282f, 0.01412536f, -0.11400685f, 0.12988991f, 
    0.08449214f, 0.15364751f, -0.05153253f, 0.33941302f, 0.00431987f, -0.15540971f, 0.07400165f, 0.05891203f, 
    -0.12385407f, -0.03284333f, -0.04703733f, 0.06620138f, -0.13801679f, -0.20441410f, 0.08229462f, 0.19740288f, 
    0.02063175f, 0.24842882f, 0.04790984f, 0.05904665f, -0.44861603f, 0.25467309f, -0.08781908f, 0.14845465f, 
    -0.00484286f, -0.23903401f, -0.00080808f, -0.03874977f, 0.01939281f, -0.41850555f, -0.05347625f, 0.59577888f, 
    0.28754827f, -0.00065926f, -0.08680648f, -0.01478539f, 0.08395261f, -0.13924250f, -0.46783805f, -0.24210073f, 
    -0.45274100f, -0.05306983f, -0.21476632f, -0.12379491f, 0.05591931f, -0.02683249f, -0.22284716f, -0.03774987f, 
    -0.30132720f, 0.21945558f, -0.10452844f, -0.00862154f, -0.18707600f, -0.04821169f, -0.06198722f, 0.29597506f, 
    0.03981859f, 0.25634059f, 0.42386508f, 0.06758267f, -0.10181849f, -0.13387924f, 0.00507279f, 0.01482623f, 
    0.04215707f, 0.26385602f, -0.02517171f, 0.26950020f, -0.18920641f, 0.16471000f, 0.04647331f, -0.08198869f, 
    0.10281336f, -0.12517788f, -0.31454191f, -0.03395705f, -0.38356906f, 0.03977506f, 0.02314635f, 0.03707783f, 
    0.19745639f, 0.06972584f, -0.01631816f, 0.08278315f, -0.12759884f, -0.36324149f, 0.12509046f, -0.11040729f, 
    -0.06374000f, -0.11628444f, 0.08181973f, -0.09076422f, 0.20637563f, 0.07388026f, -0.04393813f, -0.07059859f, 
    -0.10102755f, 0.14354764f, 0.12315196f, 0.29636490f, 0.00777466f, -0.02909571f, -0.35628653f, -0.38975859f, 
    0.09790324f, 0.11197638f, -0.03219563f, 0.03840701f, 0.06000887f, 0.23542529f, -0.15464462f, -0.38176781f, 
    -0.14521948f, 0.14729843f, 0.21113826f, 0.28636429f, 0.01824840f, -0.09704938f, -0.06062239f, 0.44515973f, 
    0.22258267f, -0.16180159f, -0.08287526f, -0.10198447f, 0.01356576f, -0.08385427f, 0.03744012f, 0.12237306f, 
    -0.67911333f, -0.03696910f, -0.12558332f, 0.36341289f, 0.22800969f, 0.08848058f, -0.17675747f, -0.07531061f, 
    -0.14059637f, 0.10810657f, -0.06020352f, -0.19643082f, 0.02574650f, 0.09526657f, -0.00257519f, 0.22041257f, 
    -0.09766912f, 0.00799954f, -0.11342426f, -0.21148160f, 0.34694490f, -0.04639274f, -0.19700710f, -0.11443973f, 
    0.00805406f, -0.18225780f, -0.07418055f, -0.16069254f, -0.00317164f, 0.21400018f, 0.26474065f, 0.04156420f, 
    0.15099123f, 0.00780396f, -0.03852181f, -0.29711682f, -0.00546369f, -0.45032018f, -0.16181460f, -0.07213275f, 
    -0.44939682f, 0.00090750f, 0.07575309f, 0.20064126f, -0.00762967f, 0.19747452f, -0.07702031f, -0.25780979f, 
    -0.11109059f, -0.02373127f, 0.20654513f, -0.02324513f, 0.11153869f, -0.03761293f, 0.09255554f, -0.33365059f, 
    -0.24242802f, -0.01164246f, -0.06618417f, -0.11079702f, -0.25012568f, -0.15776798f, -0.22083227f, -0.40268603f, 
    -0.18345666f, -0.05714544f, -0.15968983f, -0.02258525f, 0.10314484f, -0.00468197f, -0.07390682f, -0.01391070f, 
    0.27918810f, -0.08946295f, -0.16159494f, 0.22459787f, 0.12703539f, 0.15397847f, 0.14495835f, 0.03248399f, 
    0.07479616f, 0.35375994f, 0.12076745f, 0.05231162f, -0.22467630f, 0.10419247f, -0.22248550f, -0.06675231f, 
    0.18503308f, -0.09331344f, 0.48003295f, 0.33262858f, 0.29218125f, 0.26081237f, 0.05432944f, 0.25626189f, 
    0.04271510f, 0.18123379f, 0.18814589f, 0.35572660f, -0.51709801f, -0.00713187f, -0.11158293f, -0.10022546f, 
    -0.00548129f, -0.07243507f, -0.09631527f, 0.13448605f, 0.09810410f, -0.14471877f, -0.10251016f, 0.08287982f, 
    -0.07803872f, 0.12760840f, -0.19464117f, -0.00711005f, -0.19509915f, 0.31701100f, 0.10146295f, -0.30098268f, 
    -0.07107380f, 0.00909971f, -0.18905042f, -0.00977564f, 0.09520227f, 0.25127521f, -0.31930727f, 0.01641501f, 
    0.03852369f, 0.15968697f, 0.07365078f, 0.18870927f, -0.07890818f, -0.06557675f, -0.06699363f, -0.76694608f, 
    -0.24092059f, 0.06217263f, 0.14042012f, 0.19953087f, 0.08572563f, 0.20864470f, -0.02228493f, 0.25706756f, 
    0.37184465f, 0.39361334f, -0.00054452f, 0.13197008f, -0.07795931f, 0.01936624f, 0.07345810f, -0.01715863f, 
    -0.18476522f, 0.29350907f, 0.08734126f, -0.17637634f, 0.03179616f, 0.05869577f, 0.14255273f, -0.08280869f, 
    -0.05609908f, -0.24960402f, 0.29904675f, 0.23506786f, 0.24695654f, -0.14869921f, -0.01543334f, 0.21851778f, 
    0.00574401f, 0.13868944f, 0.14075793f, 0.23054285f, 0.43620631f, -0.22203055f, 0.17805165f, -0.15304783f, 
    -0.10066081f, -0.00289658f, 0.00905087f, -0.17657168f, -0.28307900f, 0.17552680f, 0.34013250f, -0.06250581f, 
    0.12137294f, 0.10224985f, 0.01493219f, -0.08782897f, -0.20504214f, -0.16866478f, -0.11979911f, 0.30569059f, 
    0.31037998f, 0.07913088f, -0.13400124f, -0.05219733f, 0.05800590f, -0.11320836f, 0.04610173f, 0.11703485f, 
    -0.17202269f, -0.02129636f, -0.17030461f, -0.05998793f, 0.01582082f, -0.00942621f, 0.15927693f, -0.01290291f, 
    -0.26754475f, -0.07120287f, -0.17811355f, -0.01445024f, -0.15201321f, -0.03648790f, 0.11530289f, 0.18693738f, 
    0.02516584f, 0.04390653f, -0.22145946f, -0.06080819f, 0.08107582f, 0.05719444f, 0.01290884f, -0.02302664f, 
    0.02370961f, -0.59869063f, -0.38304669f, 0.50780100f, -0.20843908f, 0.13597645f, 0.22318147f, -0.28145921f, 
    0.00433972f, 0.22893180f, -0.03603344f, 0.08389511f, -0.48520255f, 0.27886465f, -0.12114332f, -0.08634632f, 
    0.33298349f, 0.03953882f, -0.06913033f, 0.15701909f, 0.07506302f, -0.25793967f, -0.01273223f, 0.13696299f, 
    -0.06644128f, -0.22948067f, 0.03626632f, -0.04407204f, -0.15872304f, -0.16298786f, 0.18006977f, 0.18212429f, 
    0.09805877f, 0.03460848f, -0.00823616f, -0.14854664f, 0.34313843f, -0.02899398f, -0.10240170f, -0.62504590f, 
    0.10855974f, -0.00575297f, 0.07966557f, 0.00531230f, -0.00161312f, 0.08806380f, -0.40667614f, 0.02357060f, 
    -0.27815557f, 0.01211534f, 0.11645643f, 0.04661763f, -0.06830824f, 0.00593732f, 0.38586372f, 0.37422067f, 
    -0.26376146f, -0.11881138f, 0.23117568f, -0.07505538f, -0.04177342f, -0.00846399f, -0.02975335f, 0.06827278f, 
    -0.14876565f, 0.17646241f, 0.31531227f, 0.07078731f, -0.01884321f, -0.13726071f, 0.17112748f, -0.15467477f, 
    0.12811726f, -0.08027629f, 0.02784223f, -0.09579492f, -0.13478342f, 0.22668350f, -0.02763753f, 0.04040849f, 
    0.17405191f, -0.16196944f, -0.40665615f, -0.52887577f, -0.33693182f, 0.02252538f, 0.17708182f, -0.06505190f, 
    -0.06280775f, -0.03447735f, -0.10576609f, -0.08659174f, 0.32413468f, 0.25695142f, -0.11246648f, 0.28557411f, 
    -0.00002921f, -0.06600988f, 0.03484599f, -0.03537048f, -0.59812814f, 0.08843295f, -0.17446862f, -0.04144885f, 
    0.08289342f, -0.18051296f, -0.02157693f, -0.09054384f, -0.12063930f, -0.73927855f, 0.03751108f, 0.02490956f, 
    0.19763635f, 0.11097221f, 0.05792284f, -0.03922638f, -0.07646913f, -0.01393862f, -0.31410173f, -0.32998255f, 
    0.01876830f, -0.01117668f, -0.00892297f, -0.05262399f, 0.13719989f, -0.27617326f, -0.01609489f, 0.17093875f, 
    -0.08150796f, -0.08042556f, -0.04877477f, -0.20669469f, -0.18723564f, 0.12745418f, 0.07826497f, -0.05627837f, 
    0.37024713f, 0.11643197f, 0.22520860f, -0.03210469f, 0.01643108f, 0.06621662f, 0.04542371f, 0.05749248f, 
    -0.04295079f, -0.07807022f, -0.45417774f, -0.67852151f, 0.03158123f, 0.00747941f, 0.14201961f, 0.00986217f, 
    -0.15463175f, -0.13684912f, 0.18540041f, 0.23342001f, -0.09827232f, -0.20380332f, -0.01622781f, 0.04048687f, 
    0.06329289f, 0.15296015f, 0.21688645f, -0.09133965f, -0.13405444f, -0.06917981f, 0.01791944f, -0.06756887f, 
    -0.17522635f, -0.21434824f, -0.00537556f, 0.15118350f, -0.04874108f, 0.20585822f, 0.11283589f, 0.22034597f, 
    -0.01892610f, 0.02147814f, 0.13491005f, 0.16466951f, -0.03423315f, 0.31650773f, -0.04948917f, -0.10972670f, 
    0.16245843f, 0.02227064f, -0.03735963f, 0.02680622f, 0.31678566f, 0.24716249f, -0.06977570f, 0.04820451f, 
    -0.08614971f, 0.16442758f, 0.07072727f, 0.23985973f, -0.09134564f, 0.00704023f, 0.03731603f, -0.15623489f, 
    0.11955051f, 0.17388757f, 0.15910271f, -0.00315528f, -0.01284313f, 0.15184240f, -0.13106842f, 0.05643114f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.05379935f, 0.17636983f, 0.07520149f, -0.07249220f, -0.06351487f, -0.07866015f, -0.01733098f, 0.16863714f, 
    -0.02450058f, -0.02786428f, -0.07568847f, 0.11117647f, -0.06260356f, 0.28878465f, 0.14196825f, 0.08555554f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.12601134f, 0.30923328f, -0.07438254f, -0.00343269f, 0.20440474f, -0.03509994f, 0.06166691f, 0.47022280f, 
    -0.12120422f, -0.06457233f, -0.09013648f, -0.55792516f, -0.22417466f, 0.35696045f, -0.30360767f, -0.29243052f, 
    -0.19049588f, -0.17004448f, -0.16055447f, 0.12705848f, 0.15662202f, 0.51730758f, -0.11209375f, -0.03218782f, 
    -0.17897597f, 0.19831744f, 0.25263107f, 0.42219970f, 0.03335325f, 0.17057942f, 0.00731238f, -0.45795593f, 
    0.13610080f, 0.02238056f, -0.11741221f, -0.15697050f, 0.07032946f, -0.18163338f, -0.20125231f, -0.09854493f, 
    0.06389236f, -0.04320720f, -0.05995163f, -0.10971045f, -0.06511763f, -0.16159093f, 0.14678389f, -0.16452631f, 
    -0.11002302f, -0.14625415f, 0.00461197f, 0.14445254f, -0.15413305f, -0.12681994f, -0.17656845f, -0.22363621f, 
    0.16302451f, -0.24674764f, 0.06329519f, 0.02800217f, 0.03228679f, -0.01560542f, -0.14049646f, 0.23712146f, 
    -0.07695878f, 0.12037022f, 0.09646794f, -0.04404585f, 0.19465810f, -0.03962963f, 0.03994800f, -0.16793655f, 
    -0.33505192f, 0.21574408f, -0.14046046f, 0.60877651f, 0.58811349f, 0.59393471f, -0.08500659f, -0.15515378f, 
    0.13718149f, 0.19059895f, -0.17923144f, -0.19870509f, 0.22591946f, -0.57092732f, 0.05014968f, 0.27576172f, 
    -0.33419964f, 0.13326269f, 0.05323352f, -0.37776935f, 0.35017860f, -0.06092622f, 0.11164147f, -0.00330535f, 
    -0.06635379f, 0.21236692f, -0.07960862f, -0.15142812f, 0.03754289f, -0.10852024f, -0.12712899f, 0.34501675f, 
    0.54793328f, 0.19524802f, -0.08098374f, -0.38762769f, -0.48355252f, -0.49871582f, 0.41968617f, 0.97052234f, 
    0.18843322f, 0.13101369f, 0.17102268f, 0.12812570f, 0.09106089f, -0.21162319f, -0.15572993f, -0.12059819f, 
    0.33352360f, 0.20216703f, -0.22057769f, -0.51281530f, 0.47369295f, 0.16686913f, 0.69768214f, -0.63443613f, 
    0.15204172f, -0.24610382f, 0.04606763f, 0.03387263f, -0.22168583f, 0.04500606f, -0.15087248f, -0.09371825f, 
    -0.05461305f, -0.09353960f, 0.11669883f, 0.18601356f, 0.02715146f, -0.22211735f, -0.19157164f, 0.13300768f, 
    0.00799069f, -0.22758733f, 0.10989702f, -0.07726533f, 0.14795339f, 0.13400576f, -0.02437878f, 0.52304447f, 
    0.13862194f, -0.01448822f, -0.21547997f, -0.33105406f, -0.69344580f, 0.38440195f, -0.08288965f, 0.12710704f, 
    -0.22432685f, 0.34282756f, 0.18011746f, 0.08523889f, -0.15772030f, 0.67302477f, 0.10375836f, -0.42210415f, 
    -0.13628593f, -0.04354962f, -0.10438078f, 0.69400167f, -0.41102195f, -0.05307484f, -0.03159604f, 0.23847041f, 
    0.02129027f, -0.24481387f, -0.02630305f, -0.04479468f, -0.03645942f, 0.17178960f, 0.18072045f, -0.12380346f, 
    -0.12101279f, 0.19112533f, -0.16701213f, -0.23180382f, 0.15673377f, -0.02477143f, -0.24736145f, -0.13818690f, 
    -0.18951851f, -0.18591538f, -0.03349209f, 0.00056443f, -0.04532132f, -0.14372832f, 0.08813718f, -0.06868970f, 
    -0.03787583f, 0.20077905f, 0.09531638f, -0.04321840f, 0.10010776f, -0.23786014f, 0.10600376f, -0.12190041f, 
    -0.17717752f, 0.41917351f, -0.19238017f, -0.12282310f, 0.10369578f, -0.25144148f, 0.18310848f, -0.00569391f, 
    -0.48576394f, -0.07451120f, -0.05842321f, 0.02555571f, -0.79640299f, 0.64058799f, 0.50821412f, -0.15288727f, 
    0.11370541f, 0.22501493f, -0.04444905f, 0.07149798f, -0.24725327f, -0.28215683f, 0.06656300f, 0.09321360f, 
    -0.18071640f, -0.18678932f, -0.16386834f, -0.12092312f, 0.33886060f, 0.42871535f, -0.67434859f, 0.39118451f, 
    -0.13649309f, 0.07294637f, 0.09792516f, -0.02310906f, 0.13446556f, 0.05348586f, 0.04031191f, -0.18558152f, 
    -0.25206289f, -0.01767758f, -0.20324695f, 0.34786186f, 0.61846274f, -0.47491279f, 0.14506206f, 0.17686239f, 
    0.19289616f, -0.12780537f, -0.14739805f, -0.08783093f, -0.20929718f, -0.24345271f, 0.24147278f, -0.03681992f, 
    -0.22218570f, -0.24241564f, -0.16286275f, -0.22236076f, 0.01805071f, -0.09652879f, 0.18027426f, 0.09552558f, 
    0.13627067f, -0.16895586f, -0.20538977f, 0.24006277f, 0.11309236f, -0.04222361f, -0.04804298f, -0.06680702f, 
    -0.07110033f, 0.16802302f, 0.19961622f, -0.16625607f, -0.10048424f, 0.05783220f, 0.07469981f, 0.07784014f, 
    -0.00863996f, -0.18505500f, 0.07365358f, 0.13577120f, -0.22405162f, -0.04967111f, 0.07598642f, 0.04094898f, 
    -0.18964569f, 0.00572410f, -0.08577609f, 0.03161085f, 0.01640085f, 0.01033224f, -0.26696604f, -0.07218573f, 
    -0.22891153f, 0.05123689f, -0.07915885f, 0.01879357f, -0.04023497f, 0.20652619f, 0.21792878f, 0.11330506f, 
    -0.67983925f, 0.07739001f, 0.09719602f, 0.34761462f, 0.15120602f, 0.30921987f, 0.68445086f, 0.10482196f, 
    0.03321090f, -0.19449255f, -0.05254892f, -0.09838882f, -0.14027712f, -0.16905735f, 0.00244826f, -0.20845011f, 
    0.12803538f, -0.19968563f, -0.21554083f, -0.13788842f, -0.12611251f, -0.20193861f, 0.06032723f, 0.17695615f, 
    -0.12156924f, -0.12672797f, -0.23221791f, -0.21786046f, -0.20776698f, 0.49386454f, 0.23157568f, 0.05887415f, 
    0.28841498f, -0.00446226f, -0.18323725f, 0.32232264f, -0.41438949f, -0.19125043f, 0.19988127f, -0.01553541f, 
    0.17838588f, 0.37691161f, 0.07308462f, -0.11431154f, -0.01885197f, 0.51171339f, -0.14751893f, -0.34367770f, 
    0.51853698f, 0.03658047f, 0.22464189f, -0.16818613f, 0.05325227f, -0.25629124f, -0.07705854f, 0.33895025f, 
    0.25403976f, 0.40488985f, 0.15965548f, 0.13704622f, -0.05376169f, -0.22314872f, -0.14244121f, 0.23184602f, 
    0.32551324f, 0.24857645f, 0.14945076f, -0.25337243f, 0.05863799f, 0.18524857f, -0.62814486f, 0.15531942f, 
    -0.20783296f, -0.05901322f, 0.04952804f, -0.02122921f, -0.12539376f, 0.01582801f, 0.14396510f, -0.00157163f, 
    0.38909775f, 0.10889043f, 0.03226836f, 0.39962918f, 0.76195276f, -0.17390722f, -0.05448386f, -0.27312547f, 
    0.17795129f, -0.02681828f, 0.05625332f, -0.04692219f, 0.15438306f, 0.48690647f, 0.02242973f, 0.19804585f, 
    -0.23412190f, 0.21895109f, -0.09238829f, -0.11697993f, 0.71670485f, -0.27489704f, -0.24338603f, -0.27939609f, 
    -0.10116155f, -0.07979695f, 0.19757140f, -0.15362158f, -0.10001001f, 0.51100397f, -0.20776926f, -0.00070006f, 
    0.50950670f, -0.02846784f, -0.19738162f, 0.64914662f, -0.27050093f, -0.28943437f, -0.16255142f, 0.07585183f, 
    -0.02693071f, -0.24760954f, -0.07974942f, 0.00136442f, 0.10991305f, 0.02876468f, -0.06836490f, 0.33965731f, 
    -0.10332897f, -0.03048315f, 0.20647204f, 0.31742197f, -0.24096587f, 0.69934690f, 0.16353239f, -0.95717871f, 
    -0.21344189f, 0.09083910f, -0.24289572f, 0.21781389f, 0.18029703f, -0.43390486f, 0.07527228f, 0.48635781f, 
    0.59473693f, -0.14989452f, 0.01625521f, -0.07746337f, 0.00570492f, -0.22694169f, 0.05109707f, -0.08542423f, 
    0.00883636f, 0.12876436f, 0.23000340f, -0.03680567f, 0.08876121f, 0.13374025f, -0.00487748f, -0.01221022f, 
    -0.21814878f, -0.15162805f, -0.17820904f, -0.42125970f, 0.20016882f, 0.42423564f, 0.61476135f, -0.49491084f, 
    0.10673549f, 0.15797015f, 0.23339283f, -0.27675432f, 0.08620453f, -0.24611714f, -0.07078370f, 0.46049431f, 
    -0.10275338f, -0.22558784f, 0.03497268f, -0.40113834f, 0.31433758f, 0.31734326f, -0.34822518f, -0.19749090f, 
    0.03078169f, -0.22988266f, 0.19985476f, 0.14148432f, 0.21689352f, -0.10436460f, -0.06664494f, 0.06020159f, 
    -0.04206711f, -0.04679257f, 0.03658640f, -0.24316964f, -0.16028622f, 0.04341283f, 0.15527421f, -0.21551770f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.13900475f, -0.30677223f, -0.19049156f, -0.10668486f, -0.11547006f, 0.01864255f, 0.08867379f, 0.19530943f, 
    0.04858366f, 0.17801507f, 0.24120767f, -0.18928452f, -0.14607927f, 0.45873857f, 0.06880818f, 0.23548573f, 
    -0.16107915f, -0.06999536f, -0.10827953f, -0.23305659f, 0.07706942f, 0.36217785f, -0.32428774f, -0.03071652f, 
    0.15885019f, -0.52675635f, 0.54775757f, 0.48103821f, 0.38973546f, 0.13193955f, 0.42352819f, -0.09439439f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.29691425f, -0.41780597f, -0.02633169f, 0.08037482f, 0.05198073f, -0.87627643f, 0.11541447f, 0.00098542f, 
    0.11045025f, -0.12753539f, -0.24342918f, 0.13013481f, -0.01649364f, -0.62535822f, -0.29852685f, -0.32920527f, 
    0.09542681f, -0.08461705f, 0.09769747f, -0.41908717f, -0.05352183f, 0.18697333f, -0.10550782f, 0.09554017f, 
    0.60369730f, -0.24753648f, 0.28732476f, 0.02010008f, 0.38004398f, -0.60917687f, -0.09258748f, -0.07207166f, 
    0.16095738f, 0.01527188f, -0.06762464f, 0.07915701f, 0.14215499f, 0.16593802f, 0.21892671f, -0.53976220f, 
    -0.05904025f, 0.11532855f, -0.41353160f, -0.15430857f, 0.13819307f, -0.82138568f, 0.47695097f, -0.58179003f, 
    -0.00108786f, -0.17537607f, -0.03011509f, -0.21965751f, -0.08688860f, -0.01531116f, -0.33521628f, 0.20542431f, 
    0.16481939f, 0.09606551f, 0.01297848f, -0.13989483f, 0.23420149f, -0.51589358f, 0.26670584f, -0.01486751f, 
    0.47100177f, -0.58559752f, 0.13243869f, -0.04126979f, -0.33045116f, -0.20409483f, -0.10564850f, 0.37391096f, 
    -0.16728382f, 0.21530110f, -1.03744245f, -0.14043462f, -0.08153510f, 0.43546426f, -0.25667506f, -0.21729910f, 
    -0.15338843f, 0.13398433f, 0.01012743f, -0.25875574f, 0.06938338f, -0.28660840f, -1.22814798f, 0.06571097f, 
    -0.15102212f, -0.26257712f, -0.53102827f, 0.53234369f, 0.39217517f, 0.29638535f, 0.21435811f, 0.02451914f, 
    -0.58372301f, 0.32367995f, -0.01634490f, 0.05436748f, 0.52103502f, -3.03894997f, -0.48395595f, -0.30523312f, 
    -0.01388789f, -0.05997410f, 0.34841436f, 0.13240746f, 0.15545568f, 0.42296937f, 0.40558329f, 0.17799953f, 
    -0.18683517f, -0.00972216f, -0.09747867f, 0.32974476f, -0.09395260f, 0.08527786f, -0.62833285f, -0.34754556f, 
    -0.06367401f, -0.03900892f, 0.01015422f, 0.32310516f, -0.49360803f, -0.07178181f, -0.64932668f, -0.00403522f, 
    -0.00599380f, -0.17737183f, 0.09639239f, 0.08207536f, -0.06874315f, 0.08414761f, 0.01568031f, -0.01762620f, 
    0.08193852f, -0.53027272f, 0.26472950f, -0.06658573f, 0.13977322f, 0.42168969f, -0.54688042f, 0.43940184f, 
    -0.13330150f, -0.11842991f, -0.07733375f, -0.13764423f, 0.00331807f, 0.04438936f, 0.38782632f, 0.08097882f, 
    -0.09766544f, -0.03786951f, 0.06648448f, -0.50905269f, -0.11436254f, 0.12223273f, -0.13272862f, -0.09634689f, 
    0.27437440f, 0.15488943f, -0.16806144f, -0.13960269f, -0.64272654f, 0.61869794f, 0.16700654f, -0.38877860f, 
    -0.14371608f, 0.28366494f, 0.03682901f, -0.00316099f, -0.06884316f, -0.03738517f, 0.28155068f, -0.01836962f, 
    -0.14048636f, 0.06352396f, 0.08756793f, -0.49025956f, -0.06850694f, -0.06593645f, 0.50295138f, 0.31915459f, 
    -0.42827168f, -0.18138008f, -0.01131111f, -0.74796790f, -0.16168049f, -0.18945597f, -0.03869418f, 0.14337932f, 
    0.22926018f, -0.62749249f, 0.01528276f, -0.04718257f, -0.28676137f, -0.72759366f, 0.45143124f, -0.55982858f, 
    0.08339070f, 0.28624144f, 0.06487037f, 0.05679557f, 0.06748515f, 0.30506009f, -0.48363507f, 0.01675761f, 
    0.08173911f, 0.04786086f, -0.06398212f, 0.14362174f, -0.11889830f, 0.00125437f, -0.15860522f, 0.01986250f, 
    -0.53284931f, -0.27797323f, -0.13204895f, -0.50122333f, 0.06565616f, -0.55558848f, -0.02170747f, 0.04355506f, 
    -0.70116889f, 0.39581597f, -0.05622337f, 0.08658101f, -0.22183414f, 0.67520231f, -0.56204534f, -0.04779989f, 
    -0.02303468f, -0.43873698f, 0.30377489f, -0.15665281f, 0.05340010f, -1.17496264f, 0.07743316f, 0.54465783f, 
    -0.01880805f, -0.17114316f, -0.17069818f, -0.27279273f, 0.13244244f, 0.32511446f, 0.66348177f, -0.41226503f, 
    0.27461073f, 0.51717228f, 0.31379774f, 0.16879995f, -0.38428578f, -0.33031362f, -0.63852036f, -0.04217799f, 
    0.10268788f, -0.04743927f, -0.14368293f, 0.01301455f, 0.18658383f, -0.17953260f, -0.28570133f, 0.48291436f, 
    -0.09121531f, -1.07556880f, -0.09948796f, -0.02593205f, 0.13889308f, -0.10324520f, 0.53817999f, -0.08777165f, 
    -0.07710977f, -0.09185228f, -0.18876480f, 0.08792333f, -0.07434925f, -0.66381949f, 0.24427557f, 0.15242653f, 
    0.23711321f, 0.57853991f, -0.76472926f, -0.30798152f, -0.17541379f, 0.36122921f, 0.23555636f, -0.01423973f, 
    -0.45066401f, 0.12936020f, 0.11240720f, -0.15737577f, 0.06040763f, 0.20803395f, 0.33706248f, 0.44220835f, 
    0.03483061f, -0.28392962f, 0.20508383f, -0.12478877f, -0.07312544f, -0.10277947f, -1.11695373f, 0.07307843f, 
    -0.08312200f, -0.00920686f, 0.07625531f, -0.01010135f, -0.17846535f, 0.02265389f, 0.31846780f, -0.30906579f, 
    -0.09534121f, -0.49412620f, -0.06775773f, -0.52429610f, 0.09665590f, 0.15734045f, -0.28384209f, 0.07189919f, 
    0.25191057f, 0.16542146f, 0.05396898f, 0.09244595f, 0.51367199f, -0.12881014f, -0.88460922f, -0.20650920f, 
    0.10045086f, 0.04480345f, 0.05542313f, 0.03706644f, 0.07616056f, 0.39037126f, 0.88527340f, -0.07613951f, 
    0.09973931f, -0.08814546f, -0.08613876f, 0.01835767f, -0.10994335f, -0.08180898f, -0.99738067f, -0.12564814f, 
    -0.12960987f, -0.08114322f, -0.20609970f, 0.51314950f, -0.39927557f, 0.13213383f, 0.21239723f, -0.16145130f, 
    0.04664727f, 0.18510140f, 0.05109669f, -0.10309446f, -0.55324388f, -1.12737143f, 0.03921770f, 0.15172181f, 
    0.00294080f, 0.28607461f, -0.13701127f, 0.01080965f, 0.04474122f, 0.14022551f, -0.39159265f, -0.30061808f, 
    -0.08927842f, 0.12399487f, -0.21540678f, 0.08249502f, -0.04642152f, 0.34141770f, -0.44111910f, -0.57330906f, 
    -0.14799476f, 0.25950444f, -0.05016112f, 0.17770714f, -0.01250542f, 0.14343074f, -0.02777975f, 0.09730287f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.21337463f, -0.01153063f, 0.00255860f, -0.21881253f, 0.40849227f, -0.06884480f, 0.24516423f, -0.53331298f, 
    -0.59381950f, -0.04833198f, 0.35870630f, 0.11851194f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
