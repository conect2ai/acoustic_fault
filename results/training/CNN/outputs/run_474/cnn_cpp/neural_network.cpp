#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.01694537f, -0.38233134f, 0.45543218f, 0.80321878f, -0.46365750f, -1.05707467f, -0.45460916f, -0.09835906f, 
    0.07313225f, -0.85872573f, -0.26216331f, -0.25519589f, 0.38801768f, 0.78017962f, -0.44070497f, 0.13835984f, 
    -0.40005007f, -0.29487032f, -0.75268602f, -0.62466872f, -0.78956461f, 0.25643116f, 0.48670116f, 0.59068537f, 
    -0.24635650f, -0.34315360f, 0.09286297f, 0.65173155f, 0.69472182f, 0.75819731f, -0.31398973f, -0.39385438f, 
    0.28011164f, -0.55312353f, 0.16713628f, 0.19799583f, -0.10048433f, 0.29021573f, -0.69111967f, -0.80855376f, 
    0.27071747f, -0.49690720f, 0.66251898f, -0.45799121f, 0.42452502f, -0.20245427f, -0.62230128f, -0.74335051f, 
    -0.80987179f, 0.48057738f, 0.45234278f, 0.13946040f, -0.22888489f, 0.08164770f, 0.10201515f, 0.63662565f, 
    -0.69808328f, 0.84637588f, 0.74644417f, -0.40063190f, 0.24788038f, 0.07271043f, -0.15700738f, -0.89344692f, 
    0.57512033f, 0.22562672f, 0.85957789f, -0.19025923f, 0.41262326f, 0.03219359f, -0.77172732f, -0.20288056f, 
    -0.22010003f, -0.76870525f, 0.10326783f, -0.09480370f, 0.86635947f, -0.85428882f, 0.51854563f, 0.37924814f, 
    -0.22532476f, 0.51974189f, 0.84476793f, 0.25197148f, -0.52921575f, -0.79093617f, -0.76620448f, 0.45142096f, 
    0.29560959f, 0.32337677f, -0.64102691f, 0.17769611f, 0.35184669f, -0.73678851f, 0.23476806f, -1.03870499f, 
    -0.27663776f, 0.30349776f, 0.48199239f, 0.76443183f, -0.26091111f, -0.53760964f, 0.42570457f, -0.09276209f, 
    -0.58867049f, 0.14074168f, 0.47829694f, -0.67714339f, -0.12909704f, 0.67143613f, 0.31198478f, 0.55516899f, 
    0.75755185f, -0.07272606f, -0.24218149f, 0.84096766f, 0.37431648f, -0.18775360f, -0.55470026f, 0.33643678f, 
    0.48039094f, -0.32431036f, 0.75241441f, 0.47989747f, -0.75405788f, 0.53085667f, 0.60876042f, -1.02834094f, 
    -0.01075528f, -1.18136394f, -0.10512134f, 0.54121876f, 0.27816290f, 0.65278047f, 0.43338156f, 0.67964017f, 
    0.22021995f, -0.48196658f, -0.84492624f, 0.80176437f, -0.57101470f, -0.02774786f, 0.21206188f, 0.33531883f, 
    -0.57275093f, 0.75712591f, -0.30001560f, 0.31296429f, -0.01947324f, -0.67944771f, -0.29251549f, -0.14406775f, 
    -0.54874438f, 0.07801150f, 0.41867182f, 0.55304790f, 0.45971209f, -0.17401761f, -0.97858411f, 0.10461710f, 
    0.57979786f, -0.16794457f, -0.82488692f, -0.52919835f, -0.60502571f, -0.27204823f, 0.05495292f, 0.79584700f, 
    0.06051452f, 0.24382654f, 0.67982429f, -0.83727002f, 0.17465539f, -0.78516024f, -0.21904299f, 0.87478107f, 
    0.12727799f, -0.03179583f, -0.06809072f, -0.25415146f, 0.87512910f, 0.73266923f, 0.82555467f, 0.49303189f, 
    0.11986747f, -0.01132125f, 0.55238777f, 0.42112529f, -0.15368091f, 0.90392691f, 0.47739479f, 0.94710565f, 
    0.02113074f, 0.51738489f, 0.36447647f, 0.07722528f, -0.10287631f, 0.24254063f, -0.12516537f, 0.52661830f, 
    -0.22975186f, 0.41498956f, -1.10599172f, -0.33827376f, -0.40622121f, 0.10947367f, 0.09248547f, 1.17882633f, 
    -0.99653625f, -0.02540583f, -0.45816869f, -0.65201205f, 0.32779336f, -0.28579116f, -0.08080381f, 0.01370173f, 
    -0.36289746f, -0.59068793f, -0.73981458f, -0.15265778f, -0.30039260f, -0.54165822f, 0.43683183f, 0.21158373f, 
    0.22662848f, 0.51915103f, -0.46373975f, 0.65027666f, 0.82364684f, 0.58333635f, 0.42771214f, -0.57247746f, 
    -0.23273292f, -0.25936085f, -0.94284481f, -0.80866617f, -0.63229656f, -0.21707655f, -0.58223450f, 0.11850957f, 
    0.08278186f, -0.11942812f, -0.27492177f, -0.78462738f, -0.56114876f, -0.36740685f, 0.95513159f, 0.18799214f, 
    0.26462439f, 0.57444394f, 0.31676421f, 0.05242958f, 0.69204992f, -0.14853403f, -0.66557872f, 0.65772277f, 
    -0.88512051f, -0.51135689f, -0.11295677f, 0.23668920f, 0.26673546f, -0.84717035f, -0.03605291f, -0.06825338f, 
    -0.29863286f, -0.46711236f, -0.52108353f, 0.43013045f, 0.14470954f, -0.81221074f, -0.14594015f, -0.91032523f, 
    -0.54119992f, 0.67481250f, -0.05328720f, 0.38748497f, -0.51877987f, 0.01308257f, -0.17347951f, 0.55873621f, 
    0.71596813f, 0.79850185f, -0.94537407f, -0.65350550f, -0.67596960f, -0.25101367f, -0.52321011f, -0.43510571f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.25619295f, -0.08192755f, -0.22463556f, 0.19470498f, 0.07707103f, 0.02400469f, 0.08058956f, 0.08449655f, 
    -0.01459393f, 0.00385654f, 0.22825693f, 0.25862700f, -0.04505612f, -0.33210289f, -0.06362923f, 0.10805918f, 
    0.05741122f, -0.09495188f, 0.05222159f, 0.12626891f, 0.39868516f, 0.22334585f, 0.04343584f, -0.22878978f, 
    0.45545501f, 0.22032803f, -0.21506901f, 0.11286639f, -0.17308155f, -0.01655647f, -0.20823184f, -0.11044317f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.22525175f, -0.12178238f, 0.02566030f, 0.23412621f, 0.07460704f, -0.00450375f, -0.00655221f, -0.30749366f, 
    -0.09895509f, 0.14124976f, -0.09510636f, 0.05622530f, -0.09384838f, -0.10072906f, 0.01642819f, -0.06016549f, 
    0.17214814f, -0.11479720f, 0.19387870f, -0.08200380f, 0.09278245f, -0.12347741f, 0.08693319f, -0.11512375f, 
    -0.01472928f, -0.02608837f, 0.08383728f, -0.39708096f, -0.19326161f, -0.16453676f, 0.16556013f, 0.11907358f, 
    0.09442771f, 0.03391360f, 0.05520468f, 0.20875375f, 0.15090249f, -0.29755205f, -0.12278933f, 0.00739650f, 
    0.06249150f, -0.03843578f, 0.08923897f, -0.04513898f, -0.06337859f, 0.26859555f, -0.25656056f, 0.05720168f, 
    -0.14504470f, 0.00328869f, 0.06904194f, 0.04408183f, 0.01189244f, 0.13241471f, 0.15801209f, -0.04937828f, 
    0.04766310f, 0.07826587f, 0.05909064f, 0.10252366f, 0.07918934f, 0.09345885f, 0.06050697f, -0.01164967f, 
    -0.09763931f, -0.24314985f, 0.06795275f, 0.07000738f, 0.00010790f, -0.08619461f, -0.10624197f, 0.19639808f, 
    0.04980093f, -0.07088151f, 0.03041497f, 0.00311781f, -0.16143662f, 0.09002796f, 0.12547377f, 0.10401532f, 
    -0.26168531f, 0.31931952f, 0.01671511f, -0.02402968f, 0.09490541f, 0.11194445f, -0.03985754f, -0.00018041f, 
    0.01747875f, -0.06621927f, 0.03021816f, 0.12386518f, -0.14973769f, 0.04664854f, -0.13428782f, -0.00823951f, 
    -0.04501537f, -0.14464721f, 0.03788081f, -0.06486928f, -0.05932471f, 0.35702586f, -0.00141607f, 0.18580648f, 
    0.10987764f, 0.15188196f, 0.14623705f, -0.05354787f, -0.03541012f, 0.00349215f, -0.10519797f, 0.06349625f, 
    0.00768685f, 0.08345693f, 0.07366535f, -0.19645709f, 0.17277139f, 0.07617021f, 0.11969430f, -0.09197354f, 
    0.14702904f, -0.15557021f, -0.12495195f, 0.06282537f, -0.01282421f, 0.12478809f, 0.46982521f, 0.07254519f, 
    -0.06827464f, 0.00092827f, -0.03479917f, 0.15453702f, 0.00932036f, 0.00432299f, 0.00115819f, 0.08850780f, 
    0.13419302f, 0.20845842f, 0.11903233f, 0.14049898f, 0.09746929f, -0.19332705f, -0.13010992f, 0.03848717f, 
    0.02593791f, -0.07689219f, -0.08554488f, -0.00564466f, 0.02829428f, -0.12743813f, -0.15648817f, 0.11853510f, 
    -0.10426397f, -0.00454109f, -0.25505361f, 0.09664541f, -0.02669896f, -0.05808385f, 0.01351176f, 0.12095962f, 
    0.05388948f, -0.01519225f, 0.27741644f, -0.03647626f, 0.10672227f, -0.04696978f, 0.01193570f, 0.09926551f, 
    -0.02944740f, 0.04517302f, 0.14227164f, -0.01927450f, -0.11814095f, 0.18410994f, 0.01139466f, 0.21180321f, 
    -0.04051483f, -0.01493605f, -0.07154807f, -0.02741128f, -0.28493762f, -0.10047109f, -0.16971803f, 0.16776441f, 
    0.10069213f, 0.03909074f, 0.02637130f, 0.13762511f, 0.04736175f, -0.27872890f, -0.24465513f, -0.15638484f, 
    0.30055973f, -0.00101141f, -0.01388853f, -0.10631417f, -0.07740462f, 0.11468069f, 0.12759411f, -0.11971776f, 
    0.04499184f, 0.21332186f, -0.01327687f, -0.00205467f, -0.03783072f, 0.02238862f, -0.08563889f, -0.35534805f, 
    -0.10712539f, -0.15086354f, 0.16048685f, -0.11750405f, 0.08751959f, -0.17270190f, 0.03161371f, -0.25522572f, 
    0.04268510f, -0.10906661f, 0.00214303f, -0.11094455f, -0.02025959f, 0.11351599f, 0.01102382f, 0.13294694f, 
    -0.20605722f, -0.04160806f, 0.28858164f, 0.10765681f, -0.00029904f, -0.14808363f, -0.04687284f, -0.10115508f, 
    0.13907534f, 0.10090695f, -0.27154309f, -0.19748580f, -0.12876819f, 0.26079053f, -0.03824532f, -0.07066913f, 
    -0.07147718f, -0.05320128f, -0.03248065f, 0.18559977f, 0.28975701f, 0.16353644f, -0.08995716f, 0.01348284f, 
    0.17530683f, -0.02404412f, 0.14218381f, -0.11534882f, -0.33528018f, -0.50573069f, 0.17017224f, 0.24066573f, 
    -0.01137842f, -0.07736375f, -0.04506882f, 0.00907267f, -0.11480594f, -0.08739904f, 0.03665689f, 0.08903388f, 
    -0.10771894f, -0.05580769f, -0.22074768f, 0.07605727f, 0.06731305f, -0.07129913f, -0.07269572f, 0.29191342f, 
    0.13925730f, -0.16978879f, 0.04731454f, -0.10872397f, -0.10885212f, 0.07002399f, -0.01263739f, 0.24397320f, 
    0.07278305f, -0.02399731f, 0.00559377f, 0.08252703f, 0.02795410f, -0.17758319f, -0.20318931f, -0.02540341f, 
    0.05387999f, -0.03524500f, 0.00641140f, -0.01812682f, -0.02350338f, -0.02718687f, -0.02326171f, -0.02108150f, 
    -0.05909434f, -0.02842182f, -0.02334818f, -0.00631402f, -0.06194561f, -0.04605027f, 0.00789432f, 0.03297534f, 
    0.02285345f, -0.00644977f, 0.04703575f, -0.03716101f, -0.01347564f, -0.02671731f, 0.01172080f, -0.02172245f, 
    -0.00191961f, -0.02860683f, -0.05511712f, 0.00457939f, 0.01373103f, 0.04311490f, 0.04786345f, -0.04990759f, 
    0.03796943f, -0.02009755f, -0.00887474f, 0.00311561f, 0.04343259f, -0.01560889f, 0.02890925f, -0.04396226f, 
    0.00107495f, -0.04442802f, -0.04609958f, 0.01054152f, -0.00623556f, 0.04055531f, -0.03954886f, 0.01609479f, 
    -0.05288741f, 0.01591173f, -0.05368211f, 0.04607981f, -0.03267726f, 0.04912218f, 0.03747122f, 0.00932183f, 
    -0.06127273f, -0.03320450f, 0.04809533f, 0.01399395f, 0.02788026f, 0.03610530f, -0.06148949f, -0.02737757f, 
    -0.02161663f, -0.00791893f, -0.06273016f, 0.03445674f, 0.04389419f, -0.02264570f, 0.04828486f, -0.01613293f, 
    -0.05251434f, 0.01377339f, -0.00594568f, 0.00161351f, -0.03345022f, 0.04161069f, 0.01281144f, 0.03803725f, 
    -0.02137740f, 0.04005696f, -0.03875863f, -0.02104860f, 0.00646152f, -0.02965195f, -0.00967740f, 0.05245719f, 
    0.01312146f, -0.03422499f, -0.01226480f, 0.01549150f, -0.01869324f, 0.02153769f, -0.02101146f, -0.00872740f, 
    0.00972078f, -0.03630716f, -0.04360159f, 0.02080476f, 0.03163775f, 0.00304512f, -0.01764021f, 0.01086512f, 
    -0.03411800f, 0.00445333f, -0.00775041f, 0.01964002f, -0.03802696f, 0.00042531f, -0.00235384f, -0.03845380f, 
    -0.04780423f, -0.01635408f, -0.02158436f, -0.01383786f, 0.00807182f, -0.04539585f, 0.00559848f, -0.01690065f, 
    0.01917386f, 0.04084628f, 0.03751735f, 0.04305761f, -0.04856812f, -0.05011538f, -0.01311667f, -0.03301189f, 
    0.04221389f, -0.02073181f, -0.04498069f, -0.04301873f, 0.02277191f, -0.00988626f, -0.00611772f, -0.05613914f, 
    -0.01616743f, -0.01984201f, 0.01416912f, -0.04153549f, 0.01572000f, -0.00595617f, -0.05901470f, 0.02071813f, 
    -0.01168561f, 0.04352350f, 0.02493863f, -0.06237816f, -0.05250443f, 0.03911243f, -0.01997626f, 0.04360534f, 
    -0.02333681f, 0.01208434f, 0.04272903f, -0.00438790f, 0.04670760f, 0.00143275f, -0.00435407f, -0.01406957f, 
    0.04961041f, -0.01162280f, -0.02707284f, 0.02887715f, -0.01758099f, 0.04125531f, -0.06107019f, -0.02968029f, 
    -0.03275110f, 0.02624548f, 0.01853362f, 0.00019470f, 0.05095245f, -0.02753143f, 0.02608605f, -0.01367168f, 
    -0.02073832f, 0.02632808f, -0.05546565f, -0.03554541f, 0.03204154f, -0.03469300f, -0.00527520f, -0.00600968f, 
    0.02140899f, -0.04280415f, -0.01084893f, 0.01494304f, -0.03134322f, 0.01638557f, -0.03635698f, -0.00164452f, 
    0.03878658f, 0.02315576f, 0.01592040f, 0.03718852f, 0.03676161f, 0.04333992f, -0.00811541f, -0.06289089f, 
    -0.03039096f, 0.02367038f, -0.04226420f, 0.02431145f, 0.01572115f, 0.04588100f, -0.01456163f, -0.05875856f, 
    -0.04914597f, -0.03396489f, -0.05235289f, -0.05463215f, 0.04029384f, -0.05136140f, -0.03847618f, -0.01757947f, 
    -0.01025255f, -0.03097882f, -0.02753730f, -0.02374991f, 0.05123131f, -0.02816547f, -0.04645109f, -0.02888679f, 
    0.01458900f, 0.03929412f, -0.03102754f, -0.00591396f, -0.05833462f, -0.05693361f, 0.04257647f, 0.03437542f, 
    0.00254124f, -0.04293215f, 0.02788572f, -0.01625043f, 0.03898822f, -0.00318789f, 0.01307754f, 0.00671728f, 
    -0.06307468f, -0.05058571f, 0.01373601f, 0.02093942f, -0.04110697f, -0.00676110f, -0.00148293f, -0.04282646f, 
    0.00833032f, -0.05617929f, -0.01871898f, 0.02626420f, 0.01122112f, -0.05335395f, -0.02876762f, -0.03391276f, 
    0.02406818f, -0.00477706f, -0.03342663f, 0.03576126f, -0.04890694f, -0.00963754f, 0.00098541f, 0.00210104f, 
    -0.04487610f, 0.05050633f, 0.03686282f, 0.04646046f, 0.02638553f, 0.03964904f, 0.01360594f, 0.01002361f, 
    0.02764815f, 0.00250659f, 0.04394793f, -0.00478209f, -0.04729440f, -0.05732751f, -0.05498533f, -0.04852255f, 
    0.05494075f, -0.05385033f, -0.03122371f, -0.03246916f, 0.03353595f, -0.04241620f, -0.05933914f, -0.03548568f, 
    0.11269969f, -0.10142165f, -0.13966630f, -0.01177223f, -0.01093524f, 0.08605994f, 0.25737810f, -0.04746196f, 
    -0.02767876f, -0.14531194f, -0.03603067f, -0.04121980f, 0.13418601f, 0.08895829f, 0.16106798f, 0.18657298f, 
    -0.21659993f, 0.17018412f, -0.08087066f, -0.12117735f, 0.17337653f, 0.11371483f, 0.09185337f, 0.19342427f, 
    -0.02780806f, -0.10704674f, 0.11732191f, -0.00143993f, -0.00241636f, 0.16244753f, -0.06984922f, 0.18699184f, 
    0.04265977f, 0.01524363f, 0.01188535f, -0.24649677f, -0.19177949f, 0.16447155f, 0.11795319f, -0.24011847f, 
    -0.01412806f, -0.05461222f, -0.05697585f, -0.02833312f, -0.15271695f, -0.29263207f, 0.14455175f, 0.08825821f, 
    0.29743913f, -0.06468204f, 0.10230943f, -0.27038306f, -0.04672518f, 0.19190927f, -0.05908493f, 0.10429017f, 
    0.35401273f, 0.17973259f, 0.03273162f, 0.12064175f, 0.12612952f, -0.00119902f, -0.05338474f, 0.22349343f, 
    0.17463940f, -0.09498326f, -0.00856641f, 0.03012007f, 0.20836638f, -0.04908616f, 0.07755556f, -0.20450611f, 
    -0.20969309f, -0.06789660f, -0.01762412f, 0.32544407f, -0.05454500f, 0.02092015f, -0.07263283f, -0.17177370f, 
    0.08551094f, -0.12413059f, 0.05511820f, 0.09960052f, -0.09471485f, -0.16889094f, -0.23368576f, -0.05766980f, 
    0.14516582f, 0.05131427f, 0.13121817f, 0.13733999f, 0.15927534f, -0.05591482f, 0.00228372f, -0.09219479f, 
    0.17296876f, -0.08185212f, 0.00200247f, 0.09312961f, 0.13255244f, 0.07649817f, -0.01008324f, 0.17691974f, 
    -0.05089835f, -0.07012688f, -0.00293577f, 0.12988000f, 0.00058990f, 0.11151133f, 0.22634713f, 0.12804849f, 
    0.04236089f, -0.10819226f, 0.11842684f, 0.08859825f, -0.17525791f, 0.01207669f, -0.10809743f, -0.44857645f, 
    0.08329459f, -0.04316077f, 0.11448271f, -0.08083624f, -0.07358541f, -0.01229903f, 0.13564321f, -0.15652655f, 
    0.04759297f, 0.00054091f, 0.02876943f, -0.14178620f, 0.08474063f, -0.01429939f, 0.00110834f, -0.32019982f, 
    0.17414159f, -0.03566139f, -0.20630060f, -0.02388327f, 0.04547541f, 0.02345510f, 0.03791707f, -0.01835620f, 
    0.37530753f, 0.23338608f, 0.22521375f, -0.16916320f, 0.08075327f, -0.06432640f, 0.20555918f, -0.02049346f, 
    0.20600134f, 0.02563726f, 0.08963903f, -0.05244759f, 0.06865285f, 0.18470059f, 0.08615623f, 0.02040247f, 
    0.03160277f, -0.00128553f, -0.00700124f, -0.07833791f, 0.08388571f, 0.19713338f, 0.09274376f, 0.20030244f, 
    -0.14763908f, -0.10934908f, -0.03216546f, -0.12804206f, 0.20622529f, 0.12449686f, -0.01777407f, -0.06697907f, 
    0.20861104f, 0.09128221f, 0.02814741f, 0.23355401f, -0.27364665f, 0.06123703f, 0.12898566f, 0.06838442f, 
    0.09530436f, 0.01403846f, 0.02473273f, 0.05413100f, -0.00942663f, -0.16435018f, 0.22457932f, 0.05189035f, 
    0.19811611f, 0.00088767f, 0.12274417f, -0.04280071f, 0.17148229f, -0.32956332f, 0.09452796f, 0.13713670f, 
    0.02322000f, -0.16739164f, 0.08164656f, 0.07319976f, 0.06447996f, 0.08918674f, 0.03082245f, 0.21487868f, 
    0.09965569f, 0.17559233f, -0.25197196f, 0.02798944f, -0.04557463f, 0.15091018f, -0.04307507f, -0.02715694f, 
    0.00351229f, 0.18596187f, 0.18258338f, 0.15487455f, 0.21110141f, -0.05617134f, -0.13720794f, -0.02034255f, 
    0.20216285f, 0.21381287f, 0.05286251f, -0.23504780f, 0.14480795f, 0.01741281f, 0.10453521f, 0.13539924f, 
    0.13969311f, -0.19032581f, 0.19460453f, -0.06951905f, 0.19086330f, 0.00159901f, 0.18249452f, 0.10466766f, 
    -0.24748205f, 0.15404519f, 0.14852184f, -0.01414937f, -0.08845033f, 0.15129292f, 0.23310778f, 0.14721394f, 
    0.06969672f, -0.23847693f, -0.19453260f, -0.05315458f, 0.24522971f, 0.10846122f, 0.20556436f, -0.13882396f, 
    -0.06710652f, 0.05503761f, -0.03675155f, 0.19561686f, 0.10300460f, 0.12892133f, 0.35919902f, 0.08326507f, 
    0.30485386f, -0.12574065f, 0.00347033f, 0.06845247f, 0.13158414f, 0.13057612f, -0.08866493f, -0.24565551f, 
    0.24871762f, 0.18442568f, 0.09516657f, 0.18796992f, -0.04994312f, -0.12357216f, 0.10576517f, 0.00308672f, 
    -0.04208815f, 0.41780606f, -0.09758903f, 0.02557164f, 0.08167969f, 0.16103396f, 0.15515622f, -0.03697273f, 
    -0.13534464f, -0.17598242f, -0.01947150f, 0.06521890f, 0.13205610f, -0.04047823f, 0.03234323f, 0.12126856f, 
    0.15090898f, 0.05481040f, -0.13852911f, -0.22240907f, 0.01834085f, -0.05265419f, 0.00627111f, 0.01847315f, 
    0.01871551f, -0.10157845f, 0.16885543f, 0.23812658f, -0.19313836f, 0.00915294f, -0.10640918f, -0.07428964f, 
    -0.03270935f, -0.01158534f, 0.05488525f, -0.17526926f, 0.16350152f, -0.27895445f, -0.09551489f, 0.00975119f, 
    0.06258819f, -0.20135385f, 0.02649610f, 0.07733088f, 0.28097150f, -0.19148193f, -0.09393819f, 0.05793406f, 
    -0.06175034f, 0.27934358f, -0.07937812f, -0.11149313f, 0.12022607f, 0.42652482f, 0.07643516f, 0.13322486f, 
    0.19197033f, -0.00003954f, -0.12487970f, -0.00022934f, 0.04013792f, -0.01887711f, 0.17638195f, -0.28474474f, 
    -0.06473129f, -0.10056841f, -0.02706582f, -0.04423498f, -0.05018523f, -0.01138184f, 0.10721041f, 0.10084374f, 
    0.18788515f, -0.30665600f, -0.08402634f, 0.06468602f, -0.02410938f, 0.07364750f, -0.01591827f, -0.07116217f, 
    0.25686789f, -0.40746108f, -0.24391334f, -0.06501275f, -0.00398619f, 0.16271314f, -0.01318280f, 0.00921732f, 
    0.06320463f, -0.19270217f, 0.08652856f, -0.05420815f, 0.07210097f, 0.00233855f, -0.03902202f, -0.01616744f, 
    -0.02913690f, -0.00598117f, -0.11357861f, 0.11516058f, -0.44510162f, 0.10884745f, 0.01137504f, 0.12135337f, 
    -0.08625060f, -0.02932075f, 0.12011234f, 0.04586352f, -0.07057498f, -0.08627654f, 0.03175713f, 0.06538901f, 
    0.06182720f, -0.01277668f, 0.07571264f, -0.01128494f, 0.07705592f, 0.06790435f, -0.01728225f, -0.16458061f, 
    0.03687980f, -0.00773435f, -0.13133162f, -0.00848877f, 0.13437107f, -0.46203050f, 0.29598850f, 0.04108735f, 
    -0.06588432f, 0.02201131f, 0.02590884f, 0.24177998f, 0.05416203f, 0.08319068f, 0.22721621f, -0.15616913f, 
    -0.02248201f, 0.05974681f, 0.05806097f, 0.14059301f, -0.12603302f, -0.23195796f, 0.13117634f, 0.34083942f, 
    0.04439216f, -0.01356537f, 0.04493136f, 0.04754032f, 0.21941692f, -0.10143675f, -0.06144310f, -0.04283176f, 
    -0.17828965f, -0.14736219f, -0.32895786f, -0.10293624f, 0.11377481f, -0.02336549f, -0.17457351f, -0.11145072f, 
    -0.06285126f, -0.01271114f, -0.02542008f, -0.13250807f, -0.16092332f, 0.05977042f, -0.13539669f, 0.08861028f, 
    -0.05240592f, 0.09086554f, 0.16231838f, 0.13698494f, 0.07299150f, -0.00233119f, -0.00103308f, -0.09719988f, 
    -0.06337321f, -0.07236506f, 0.13515563f, 0.05049345f, 0.01452581f, -0.25671363f, 0.14914027f, 0.14712049f, 
    -0.08937669f, 0.04950184f, 0.05203773f, -0.05179781f, -0.05179550f, -0.01884250f, 0.07121464f, -0.01915076f, 
    -0.08651783f, 0.02587435f, 0.05832918f, 0.12866220f, 0.10312364f, -0.14490916f, -0.08195276f, -0.12962522f, 
    0.02988954f, -0.08741905f, -0.02752198f, 0.01940818f, 0.08957223f, 0.08768241f, -0.09648277f, 0.07836355f, 
    -0.11853714f, -0.00269459f, 0.03085018f, -0.01697182f, -0.03133646f, -0.06864689f, 0.02437225f, -0.64807796f, 
    0.08410212f, -0.25561023f, 0.12334936f, 0.04821673f, 0.18366051f, 0.00313110f, 0.01521987f, 0.01440686f, 
    0.16104528f, -0.03110299f, -0.01761796f, 0.04694537f, -0.00146279f, 0.02432278f, -0.04415076f, 0.11755959f, 
    -0.16072290f, 0.16834934f, 0.03966611f, 0.05157510f, 0.12194205f, 0.01385245f, -0.20305169f, -0.04174457f, 
    0.12318239f, 0.14918531f, -0.09593032f, 0.16964586f, 0.00892092f, -0.01816019f, -0.13775916f, -0.02581444f, 
    -0.07844397f, 0.07598138f, 0.12192417f, 0.07692561f, 0.19388770f, 0.16527405f, -0.02016515f, -0.07338558f, 
    0.04588318f, 0.19096787f, 0.08365981f, -0.07575620f, -0.41017348f, -0.30680627f, 0.21941225f, 0.04895147f, 
    0.05844418f, -0.09591288f, 0.07558711f, -0.09221935f, -0.07895651f, -0.23566635f, -0.28678301f, -0.31340495f, 
    0.17094184f, -0.06985202f, 0.19600405f, -0.00699199f, 0.16345835f, 0.08928400f, 0.10130174f, 0.05523394f, 
    0.11761444f, 0.11576317f, -0.05588220f, -0.10888720f, 0.07520438f, 0.04746760f, -0.03135920f, -0.14697111f, 
    0.10390073f, -0.09923595f, -0.11408498f, 0.01066046f, 0.05519889f, -0.24440865f, -0.04463762f, -0.06066672f, 
    -0.20787373f, -0.05916003f, -0.12147713f, -0.00770842f, -0.08608402f, -0.01099656f, 0.03155126f, 0.22612387f, 
    -0.08861251f, -0.11498746f, 0.00330946f, -0.14515764f, -0.02824550f, 0.23664851f, -0.04889703f, 0.06357292f, 
    -0.18564793f, -0.06587683f, 0.16707394f, 0.05267060f, -0.23770534f, 0.13631600f, 0.18867804f, -0.05178820f, 
    0.04933576f, 0.10294830f, -0.09435701f, -0.03308563f, -0.05775620f, 0.01440586f, -0.08074457f, 0.05402306f, 
    0.03072446f, 0.01250180f, 0.25875899f, 0.16031882f, -0.05467285f, 0.01422398f, -0.02797710f, -0.18910518f, 
    0.19152518f, 0.01366453f, -0.10815955f, -0.16181497f, 0.06696112f, -0.27589414f, -0.28526402f, -0.16673319f, 
    0.01238819f, 0.05316636f, -0.00561609f, 0.04612087f, -0.21224205f, -0.20037061f, -0.09567606f, 0.09298395f, 
    -0.24623166f, 0.14020617f, 0.03526592f, -0.00041026f, 0.04105903f, 0.06031591f, 0.04715808f, 0.03882332f, 
    0.22177024f, 0.11496752f, -0.13860610f, -0.13208266f, -0.13554680f, 0.05168239f, 0.09898544f, 0.03752361f, 
    -0.49705884f, -0.18542786f, 0.02749889f, -0.06697970f, 0.32457435f, 0.15187332f, 0.02649202f, -0.09356646f, 
    -0.14279889f, -0.09317157f, 0.16892174f, 0.22968508f, -0.12619984f, -0.03729294f, -0.04922746f, -0.17387618f, 
    0.05464435f, 0.13197944f, 0.07443585f, -0.00336132f, 0.15375526f, 0.17033598f, 0.03662869f, 0.15010078f, 
    0.01084666f, 0.00734102f, 0.07846832f, -0.13144282f, 0.09616851f, 0.30876246f, -0.24604250f, -0.01964915f, 
    0.09900269f, 0.14090662f, 0.01710785f, 0.15754393f, 0.13025248f, 0.01814345f, -0.14034201f, 0.12279414f, 
    0.05840736f, 0.04662390f, 0.11389861f, 0.11440762f, 0.18932663f, 0.24484541f, -0.32678470f, -0.09761173f, 
    0.10903682f, 0.00017873f, -0.06130901f, -0.07881546f, 0.12272967f, 0.25160509f, -0.45004547f, -0.30546844f, 
    -0.00221740f, -0.24388042f, 0.42634556f, 0.01793850f, -0.00731357f, -0.09298191f, 0.03134968f, -0.29323307f, 
    -0.03614982f, -0.02283918f, -0.12409750f, -0.04443159f, 0.08447578f, -0.00379140f, -0.09027034f, -0.00976782f, 
    -0.08316422f, -0.02495535f, 0.19615754f, 0.11434279f, -0.01782723f, -0.11889055f, 0.01457490f, 0.00595844f, 
    -0.06310039f, -0.04689473f, -0.00185679f, 0.10766501f, -0.06185436f, -0.04269763f, -0.14825718f, -0.03214330f, 
    0.20682043f, 0.23652266f, -0.03281484f, -0.22816291f, -0.20510097f, 0.01642985f, -0.02545203f, -0.01160076f, 
    0.15456370f, 0.04109664f, 0.18024912f, 0.48173732f, -0.12893447f, -0.26796639f, 0.20812057f, 0.09613235f, 
    0.02480703f, -0.08327555f, -0.08237318f, -0.08374810f, -0.08630411f, 0.09249520f, -0.00021769f, 0.15103009f, 
    -0.03842591f, 0.11456122f, 0.05294931f, 0.05154007f, 0.11650632f, -0.06914969f, -0.00983885f, -0.15396094f, 
    -0.09345414f, 0.07115283f, 0.02980687f, 0.09356469f, 0.18591942f, 0.15901835f, -0.27017584f, 0.16280419f, 
    0.05339913f, -0.03348458f, -0.03799115f, -0.22957550f, -0.16026038f, 0.12809047f, 0.10581338f, -0.20219198f, 
    -0.41489202f, 0.02976568f, 0.00590565f, 0.06373420f, -0.07369985f, -0.12360569f, -0.13816266f, -0.00493480f, 
    -0.38434675f, -0.07581915f, 0.12496855f, 0.12724555f, 0.06018608f, -0.02080333f, -0.03345248f, 0.03172141f, 
    -0.06376177f, 0.42440608f, 0.16373228f, -0.10305636f, -0.02015273f, -0.13121699f, -0.01362907f, 0.20910895f, 
    0.31831801f, 0.22071241f, -0.48812044f, -0.47613853f, 0.03226038f, 0.04412902f, 0.00438025f, -0.00129104f, 
    0.12013864f, 0.11689124f, 0.02948249f, -0.07376605f, 0.03829547f, -0.20592348f, 0.04184733f, 0.06874831f, 
    0.09806504f, 0.01166198f, 0.05731514f, 0.16085985f, -0.49718103f, 0.16376056f, 0.21138607f, 0.15204540f, 
    0.02209612f, -0.19698368f, 0.05937160f, -0.11360625f, 0.01948042f, -0.22967669f, -0.32328621f, 0.03357282f, 
    -0.00874584f, 0.09793571f, -0.08026879f, -0.05727123f, 0.18672994f, 0.00965159f, 0.24078614f, 0.00043032f, 
    0.01083939f, 0.17778532f, 0.04290717f, -0.09349047f, -0.02357418f, 0.04216097f, -0.14155822f, 0.01240373f, 
    -0.04990178f, 0.17127101f, -0.03453637f, -0.01356542f, 0.12685464f, 0.16965859f, 0.15285175f, 0.08979115f, 
    -0.02606061f, 0.00778345f, -0.01593195f, 0.03987364f, 0.01049021f, 0.01968879f, -0.01542190f, -0.00677915f, 
    -0.00872654f, -0.00822014f, 0.02117177f, -0.01791965f, -0.02299496f, -0.01524488f, -0.04572295f, -0.00839712f, 
    -0.06498925f, 0.01740757f, -0.02260536f, -0.06182776f, 0.02916662f, -0.01859173f, 0.01018746f, -0.02032992f, 
    -0.03419220f, 0.02997326f, 0.01041095f, -0.04040065f, -0.01763603f, 0.01973146f, 0.02339833f, 0.02615710f, 
    -0.03416903f, -0.03670674f, 0.01977440f, -0.06384425f, -0.00736423f, -0.06314484f, 0.00183428f, 0.02103271f, 
    -0.06556333f, -0.01026932f, 0.02826267f, 0.01926512f, -0.04065025f, -0.06665916f, -0.05871818f, 0.00893059f, 
    0.04318361f, 0.04415095f, 0.01906473f, 0.03944324f, -0.06207915f, -0.01778743f, -0.05073979f, 0.03990075f, 
    -0.01230455f, 0.03811030f, -0.01275238f, -0.01765874f, -0.01630374f, -0.03625824f, 0.02568197f, -0.00303959f, 
    0.00017457f, 0.00710728f, 0.03847578f, 0.01856416f, -0.03706380f, 0.00781580f, -0.02857855f, 0.02390114f, 
    -0.06655700f, 0.03709816f, 0.02583672f, -0.05968073f, -0.02177086f, 0.00042325f, -0.04566693f, -0.03288301f, 
    -0.01332358f, -0.06515859f, -0.04473459f, -0.02798156f, 0.01807082f, -0.01879693f, 0.01560596f, -0.04582796f, 
    -0.03373508f, -0.04740512f, -0.02141080f, -0.03340957f, -0.05794123f, 0.04244994f, 0.03713683f, 0.02368385f, 
    -0.03427968f, 0.03584389f, -0.06199033f, -0.01678523f, -0.04807558f, -0.07223432f, 0.01356220f, -0.02895081f, 
    -0.00467070f, -0.04776778f, 0.04692385f, -0.05542001f, 0.00912046f, 0.04213528f, -0.04127596f, -0.02514572f, 
    -0.01222314f, 0.01553043f, 0.01715168f, -0.03687527f, -0.01196126f, 0.03045188f, -0.03021510f, -0.06643709f, 
    -0.00171973f, -0.02302638f, -0.06446952f, -0.05766760f, 0.03787670f, 0.00416464f, -0.02754322f, -0.05811670f, 
    -0.05994181f, 0.01186116f, -0.00968633f, -0.04910252f, -0.02904029f, -0.05590953f, 0.02778441f, -0.04385202f, 
    0.01795731f, 0.03916506f, -0.04030602f, 0.01731344f, 0.04580216f, 0.03176496f, 0.00375182f, -0.02228713f, 
    -0.03595082f, -0.01751835f, -0.03302846f, -0.00505091f, -0.06263033f, 0.03037798f, -0.06454750f, -0.00658660f, 
    -0.02467160f, 0.03148127f, -0.04565345f, 0.02144322f, -0.06920731f, -0.04671272f, -0.06997082f, -0.06167020f, 
    0.02932747f, 0.02821353f, 0.01052567f, 0.02701835f, 0.00249673f, -0.03089631f, 0.03902778f, 0.02916973f, 
    -0.00667298f, 0.01163628f, -0.01820552f, 0.00839039f, -0.03314296f, 0.01829036f, -0.07072566f, 0.01946550f, 
    0.02466968f, 0.01280595f, 0.04286858f, 0.04418669f, 0.01177832f, -0.01323209f, 0.02491300f, -0.03142754f, 
    0.04359621f, 0.02871336f, 0.02938216f, 0.03396712f, -0.05229457f, -0.00677788f, -0.02593350f, 0.01647251f, 
    -0.03138739f, 0.02429954f, 0.02022624f, 0.00999198f, -0.07274577f, 0.03575757f, 0.02244717f, 0.01912986f, 
    -0.01159447f, 0.02131683f, -0.05369588f, 0.00886988f, 0.03178755f, 0.03164586f, -0.06827789f, -0.02635514f, 
    -0.01849950f, -0.02543281f, -0.03025652f, 0.03348696f, -0.02671484f, 0.00867312f, -0.04499372f, 0.04130306f, 
    -0.00567297f, 0.03182869f, -0.02858758f, 0.01533487f, -0.02737897f, -0.00506874f, 0.01309110f, -0.04111653f, 
    -0.02348182f, -0.02425568f, -0.02043219f, -0.00440930f, -0.05204162f, -0.00058375f, -0.01466173f, 0.03234441f, 
    -0.05737096f, 0.01074071f, -0.06210774f, -0.01966477f, -0.05174920f, -0.02895047f, 0.03157930f, -0.06208809f, 
    0.01209659f, -0.02717361f, -0.04029147f, -0.02861121f, -0.05535354f, 0.00825395f, 0.02792326f, -0.07029958f, 
    -0.03121693f, -0.00490572f, 0.01198890f, 0.02982674f, 0.00224498f, -0.02447059f, 0.00842171f, 0.04764555f, 
    0.03864963f, -0.03458212f, 0.02912858f, 0.02007026f, 0.02035207f, 0.01117985f, -0.03890437f, -0.05293256f, 
    0.02638184f, 0.00433579f, 0.00697456f, -0.00605777f, -0.05538743f, -0.06648755f, 0.01543233f, -0.04575510f, 
    -0.01596527f, 0.04594705f, 0.03219447f, 0.01392009f, 0.00213559f, -0.02837507f, -0.06257403f, 0.02895134f, 
    -0.03726860f, -0.04134513f, 0.01075094f, 0.03676535f, 0.04503100f, 0.03389236f, -0.04583332f, -0.00497476f, 
    0.03851913f, -0.06009571f, 0.04839945f, -0.06492598f, -0.02632295f, -0.01495926f, 0.05650485f, 0.04845310f, 
    -0.05931115f, 0.01485986f, -0.06559812f, -0.01135652f, 0.03168344f, -0.06118332f, 0.00395419f, -0.02961523f, 
    0.00184710f, 0.04976121f, -0.00156531f, 0.01361963f, -0.03405343f, -0.04780471f, 0.00353130f, 0.00042324f, 
    0.00965258f, 0.02301628f, -0.07159676f, 0.03405207f, 0.00578677f, 0.01686546f, 0.00581537f, -0.02857647f, 
    0.00038772f, -0.05424028f, 0.01030825f, -0.02830789f, -0.04273127f, 0.02353626f, -0.00521189f, -0.06127962f, 
    -0.04653639f, 0.01987509f, -0.03464927f, 0.03299670f, -0.02626715f, -0.04608887f, -0.02101363f, 0.03360566f, 
    0.01243069f, 0.00011702f, 0.01363020f, -0.00803183f, -0.06307217f, 0.04136235f, 0.05199707f, 0.00802457f, 
    -0.03528427f, 0.01098006f, -0.00761912f, -0.00364203f, 0.03753213f, 0.00264599f, -0.00901294f, -0.02822704f, 
    -0.01174239f, -0.03684735f, -0.02207679f, -0.02613829f, -0.05510017f, -0.05164080f, 0.03106254f, -0.02365480f, 
    0.02977589f, -0.01425494f, -0.02592054f, -0.04993154f, 0.03038115f, 0.04375349f, 0.02517559f, 0.00313473f, 
    -0.00214097f, 0.02177254f, -0.02725156f, -0.05440433f, -0.04301743f, -0.04100020f, 0.04136519f, 0.02068830f, 
    0.03997637f, -0.05924464f, 0.02135707f, 0.04274193f, -0.01433662f, -0.02185186f, -0.00827253f, -0.00802339f, 
    -0.02995609f, 0.03029668f, 0.02286860f, -0.04751040f, -0.01364617f, -0.04440019f, -0.02894164f, 0.01772334f, 
    0.02620536f, 0.00801899f, 0.00085125f, 0.03899211f, 0.03216055f, 0.05630687f, 0.05083090f, -0.01578018f, 
    0.04105893f, -0.04192708f, -0.00527011f, -0.06259944f, 0.02772644f, -0.04234818f, 0.02431223f, -0.02636261f, 
    0.04046519f, -0.01242973f, -0.05025470f, -0.00245057f, 0.01385625f, -0.04256723f, -0.03278533f, -0.00266221f, 
    0.04158681f, -0.00473182f, -0.05640307f, -0.01076775f, -0.07222182f, 0.00401443f, -0.01330209f, 0.04837126f, 
    0.03207541f, -0.01956446f, -0.05026344f, 0.01280090f, -0.02314576f, -0.01201914f, 0.01257868f, 0.05506063f, 
    0.00841529f, 0.03522319f, -0.03460961f, -0.03537656f, -0.01236771f, 0.02985512f, -0.02820974f, -0.03814421f, 
    0.04864510f, -0.04074547f, 0.04703314f, -0.02066600f, 0.04292528f, -0.05271614f, 0.01545418f, 0.01273336f, 
    0.01045694f, -0.05307197f, 0.00477437f, 0.01669241f, 0.02257413f, -0.05594048f, 0.04964121f, -0.06410929f, 
    0.00863974f, 0.01446252f, 0.05565915f, 0.01673890f, 0.03395250f, 0.04429371f, -0.04076564f, 0.02683335f, 
    -0.05541294f, -0.01492923f, 0.04576387f, -0.06864917f, 0.05419244f, -0.02428136f, -0.04706074f, -0.02590780f, 
    -0.02148270f, 0.02928901f, -0.04167987f, -0.06438682f, 0.04949438f, -0.05877975f, -0.05780156f, 0.03313000f, 
    -0.00706858f, 0.04732112f, -0.04171829f, -0.04103926f, 0.03022149f, 0.04330931f, -0.01478185f, -0.00140520f, 
    0.00196305f, 0.00808231f, -0.03697733f, -0.06360872f, -0.04796663f, 0.03671840f, -0.00067354f, -0.01363929f, 
    -0.02177814f, -0.00481453f, -0.01312830f, -0.00028898f, -0.02536642f, -0.05932829f, 0.04040253f, -0.04216909f, 
    0.02353304f, 0.05209826f, 0.02703988f, -0.02299872f, 0.01025186f, 0.03653595f, 0.02897541f, -0.03846648f, 
    -0.04234098f, -0.02305127f, 0.04729784f, 0.03453060f, -0.04786842f, -0.02164017f, 0.01206490f, 0.00864952f, 
    -0.00207524f, -0.00518939f, -0.04595171f, -0.02337687f, -0.01179217f, 0.03599118f, -0.01338016f, -0.00839213f, 
    0.00805295f, -0.05323379f, 0.02119004f, -0.05530599f, 0.01934052f, -0.05666200f, 0.01076978f, -0.05035871f, 
    -0.04077422f, -0.06585599f, -0.01799614f, -0.06380003f, -0.02261039f, 0.03377982f, 0.01927087f, 0.02956923f, 
    0.02954427f, -0.02092187f, -0.00306853f, -0.02528654f, -0.02908712f, 0.00691027f, -0.00909869f, 0.01453691f, 
    0.04899355f, 0.00704505f, -0.04119891f, 0.02699140f, -0.00339868f, -0.04216483f, -0.07090026f, 0.00570300f, 
    -0.05632139f, -0.07112280f, -0.02602858f, -0.05278677f, 0.00310979f, -0.02944345f, -0.01952595f, -0.04455476f, 
    -0.00396273f, -0.00776744f, 0.00051676f, 0.04989739f, -0.01695559f, 0.02142332f, 0.02091727f, 0.04044972f, 
    -0.30394945f, -0.40627196f, 0.23046970f, -0.09518614f, 0.19693951f, -0.07826687f, 0.06174504f, 0.10115768f, 
    0.12433808f, 0.35226482f, -0.37105620f, -0.04727964f, 0.00212926f, -0.19509502f, 0.05572683f, -0.10029315f, 
    -0.04585815f, 0.00530602f, 0.07926308f, 0.14126517f, -0.29708484f, -0.01548850f, -0.04483113f, 0.13036038f, 
    0.05170609f, -0.04559721f, 0.00809620f, 0.05491148f, 0.24160241f, -0.18851931f, -0.06748232f, 0.09619571f, 
    0.00844555f, 0.03767688f, 0.03510816f, -0.03869960f, 0.03819884f, -0.05930727f, -0.00169197f, 0.09699276f, 
    0.19416633f, 0.05842646f, -0.11715794f, 0.17258640f, 0.00261668f, 0.28678900f, 0.15803503f, -0.16339467f, 
    0.06011175f, 0.08934043f, 0.31875941f, 0.10892589f, -0.01573193f, -0.11756170f, 0.21261416f, -0.15121336f, 
    -0.15599924f, -0.09346575f, -0.17721356f, 0.10013182f, -0.19942604f, 0.06514030f, 0.12172653f, 0.02380695f, 
    0.17959617f, -0.02732242f, 0.00393560f, 0.08602710f, -0.02328402f, -0.03335833f, 0.03632336f, 0.14697625f, 
    0.29246193f, -0.41362357f, -0.01197411f, -0.21859029f, 0.05072095f, 0.14826998f, -0.13031998f, 0.14181846f, 
    -0.02570316f, 0.31723309f, 0.55460143f, -0.09388448f, 0.26574257f, 0.00726826f, 0.14003861f, -0.08875363f, 
    0.02628857f, -0.13164201f, 0.10978331f, 0.20878254f, -0.26690406f, 0.07705839f, 0.10676499f, 0.04257181f, 
    0.09125445f, 0.10630885f, -0.16884536f, -0.25728977f, 0.01036680f, 0.00337224f, 0.04935533f, 0.01390168f, 
    0.08860479f, 0.08074891f, -0.10737851f, 0.00500077f, 0.17827858f, -0.08138008f, -0.13096315f, -0.21440959f, 
    -0.02765637f, -0.00767040f, -0.18667099f, -0.11703600f, -0.06268965f, -0.23766729f, 0.13613379f, -0.04947947f, 
    -0.09422047f, -0.02976719f, 0.08500182f, -0.01344488f, 0.11350164f, 0.06355298f, 0.74436098f, 0.00924205f, 
    -0.05601330f, 0.02010962f, -0.07999941f, -0.07023192f, -0.08565541f, 0.14819534f, 0.08741497f, 0.23531719f, 
    0.33787301f, -0.06486342f, 0.07050661f, 0.19867095f, 0.08479284f, -0.22977181f, -0.07931387f, -0.00563887f, 
    0.02098488f, -0.13258897f, 0.09399696f, -0.14228803f, 0.17578323f, -0.13784593f, 0.03875519f, 0.03292202f, 
    0.05240240f, -0.06176173f, 0.07740569f, -0.08787907f, -0.06474338f, 0.01667989f, -0.02695700f, 0.05755658f, 
    0.14115968f, -0.00590077f, 0.09066740f, 0.16821547f, -0.05153612f, -0.04205588f, 0.09418414f, 0.10877446f, 
    -0.10272523f, -0.04771464f, -0.05185875f, -0.00883226f, 0.14958078f, -0.26373890f, 0.03185077f, 0.02539144f, 
    0.18297698f, -0.02770340f, -0.19631308f, -0.14666601f, 0.03966212f, 0.15459058f, 0.06592558f, 0.08037551f, 
    0.09093236f, 0.08746529f, -0.00011017f, -0.04411757f, 0.01974050f, -0.27092677f, 0.00461588f, 0.00938070f, 
    0.07980659f, 0.02678146f, 0.07836131f, -0.11368247f, -0.10165811f, 0.15689807f, -0.19364147f, 0.43292516f, 
    0.06026618f, -0.04066848f, 0.11577778f, -0.08639196f, 0.11258906f, 0.16001052f, 0.12936519f, 0.10453829f, 
    0.03570722f, -0.01618050f, 0.07180348f, -0.10500319f, 0.28137240f, -0.04357117f, 0.00849457f, -0.02487080f, 
    -0.00391420f, -0.05096481f, 0.00599215f, 0.01495590f, 0.07108414f, -0.02254193f, 0.03305182f, -0.00664529f, 
    -0.18174000f, -0.03816296f, 0.05426041f, 0.19880417f, 0.02474294f, -0.16452548f, -0.16869392f, 0.00369842f, 
    0.07060653f, 0.23610859f, -0.38531744f, 0.06377402f, -0.16535001f, -0.01151121f, 0.23101646f, -0.03884957f, 
    0.01523662f, -0.06227949f, -0.07200257f, 0.10720761f, 0.02217233f, 0.31914818f, -0.18384810f, 0.02368005f, 
    -0.02542916f, -0.03920199f, 0.05406921f, -0.05620996f, -0.29963034f, -0.33171472f, -0.26089549f, 0.03949320f, 
    0.00126982f, 0.02190400f, -0.09878448f, -0.01429736f, -0.02551698f, -0.18654370f, -0.34777209f, 0.14386828f, 
    0.02483809f, 0.01797663f, 0.20062451f, 0.09272405f, -0.17567460f, 0.01233980f, -0.02926985f, 0.08299400f, 
    -0.42880189f, -0.22850361f, 0.16865012f, 0.04740117f, 0.00271956f, -0.19596411f, -0.02375778f, 0.14400817f, 
    0.23322923f, -0.14771308f, -0.10660875f, 0.08339574f, 0.06224072f, -0.11820453f, -0.01952521f, -0.11584815f, 
    0.01434217f, -0.15315092f, -0.37033173f, 0.03633547f, -0.09647338f, 0.08154237f, -0.00044529f, 0.12687978f, 
    0.20362331f, 0.08677962f, 0.30475891f, -0.20288141f, 0.07450113f, -0.05557073f, 0.20954940f, 0.10797933f, 
    0.25147825f, 0.09017363f, 0.12478571f, 0.05390975f, 0.22049826f, -0.13560119f, -0.07519204f, 0.08737782f, 
    -0.03707763f, 0.10089470f, 0.07031234f, -0.53167278f, -0.03436342f, -0.00737651f, 0.12316570f, 0.05819052f, 
    0.03880656f, -0.00454579f, -0.05027413f, -0.03957779f, -0.04469841f, 0.19303897f, -0.03585993f, 0.22893061f, 
    -0.18931243f, -0.11346106f, -0.08441539f, 0.09911230f, 0.10445122f, 0.07322763f, 0.02071176f, 0.11676032f, 
    0.19476976f, -0.14185832f, -0.04382890f, 0.05114799f, 0.12218481f, -0.01621156f, 0.03623187f, 0.08814184f, 
    -0.09906214f, 0.01469840f, -0.13505636f, -0.07642279f, 0.04891404f, -0.03151318f, 0.09099078f, -0.01142973f, 
    -0.07237349f, -0.23017657f, 0.00104621f, 0.12601542f, 0.14183567f, 0.03741969f, -0.05355673f, -0.17895572f, 
    -0.10257997f, 0.22574808f, 0.03371888f, -0.03505341f, -0.10017335f, -0.04796860f, -0.08852623f, -0.02353043f, 
    0.00777108f, -0.16824295f, 0.16117181f, -0.15636146f, 0.09031702f, 0.00711810f, -0.20348679f, -0.22794668f, 
    0.08844052f, 0.18533228f, 0.09629754f, 0.02570292f, -0.12888514f, 0.04124018f, -0.16722813f, -0.15016678f, 
    0.01218230f, -0.11692065f, 0.06521448f, -0.08504694f, -0.07401201f, 0.11984736f, 0.07740065f, 0.10331550f, 
    0.01426129f, -0.08556613f, -0.07354500f, -0.17254008f, -0.46284771f, 0.31747776f, -0.07119880f, 0.10196453f, 
    -0.22278808f, -0.04043923f, 0.06993209f, -0.04074395f, 0.09419653f, 0.33131340f, -0.15517592f, -0.16225831f, 
    -0.00427484f, -0.09932000f, 0.11407698f, -0.29996571f, -0.08669168f, -0.26363298f, -0.07491954f, 0.04412448f, 
    0.01715469f, -0.07938880f, 0.10395858f, 0.14666219f, 0.05860381f, 0.05391554f, -0.11384507f, -0.41587183f, 
    -0.13965334f, 0.24425358f, 0.07877472f, 0.06282649f, -0.02718637f, 0.24885568f, 0.02389687f, 0.13425273f, 
    -0.02873883f, 0.01107493f, -0.06951710f, 0.03608471f, 0.02518995f, 0.01415639f, -0.00796510f, 0.11156701f, 
    0.07348169f, 0.02030872f, 0.03600330f, -0.39988756f, 0.16260177f, -0.00061542f, 0.11836867f, -0.12124883f, 
    0.03016292f, 0.10842641f, 0.06277470f, -0.07863344f, 0.11200631f, 0.04448717f, -0.04354614f, -0.00470978f, 
    0.09035259f, 0.04911600f, -0.07192850f, 0.10903894f, -0.03878955f, 0.07021994f, -0.08551280f, -0.02604534f, 
    0.14658238f, 0.16023634f, 0.08779676f, 0.09961511f, -0.57063007f, -0.10971054f, -0.00133850f, 0.00556309f, 
    0.02414344f, 0.07689704f, -0.07631263f, -0.02428317f, -0.02459142f, -0.36540174f, -0.04572459f, 0.02340134f, 
    -0.14179014f, 0.10602219f, 0.06746320f, -0.01994086f, -0.09904897f, -0.08081999f, 0.12455965f, 0.11453807f, 
    -0.24116386f, 0.10820535f, -0.07852257f, 0.02783842f, -0.11360072f, 0.10232332f, 0.07813109f, -0.02649648f, 
    -0.13591126f, 0.05491651f, -0.27614531f, -0.00622978f, 0.00321223f, 0.01162107f, 0.00236164f, 0.03579725f, 
    0.00456541f, 0.09711794f, 0.07561768f, -0.08772035f, -0.09525017f, 0.07490274f, -0.13750544f, -0.08893704f, 
    0.08026128f, 0.21686772f, 0.02358867f, -0.00047531f, 0.05501714f, 0.03009050f, 0.10608327f, 0.09828269f, 
    0.14543211f, -0.16286169f, 0.01968099f, -0.09507535f, 0.16088888f, 0.21345523f, -0.28656638f, -0.12036442f, 
    0.00292970f, 0.00337761f, 0.00770446f, 0.18961769f, 0.19109213f, -0.13176692f, -0.17003956f, 0.08623842f, 
    0.13948898f, -0.01213475f, 0.12412227f, 0.08205114f, 0.07619260f, -0.07343770f, -0.05659035f, -0.06262879f, 
    -0.19564533f, 0.02980374f, -0.09016157f, 0.05219743f, 0.24057794f, 0.39103669f, 0.25750446f, -0.06351554f, 
    -0.10913100f, 0.10041656f, -0.14546345f, 0.08793698f, 0.14539337f, -0.11398034f, 0.13322529f, 0.15014705f, 
    0.45274553f, -0.08955511f, 0.09714642f, 0.05753651f, 0.00500846f, 0.09249058f, -0.01073518f, -0.28399315f, 
    0.08104576f, 0.13295008f, 0.21906260f, 0.06615113f, 0.08172847f, 0.00352258f, -0.14958479f, -0.16994132f, 
    -0.05060433f, -0.04710441f, 0.05237668f, 0.03641739f, -0.03725146f, 0.04192599f, 0.03941319f, -0.05001055f, 
    -0.04711680f, -0.05099003f, -0.02012793f, -0.05167208f, -0.02615840f, -0.04915110f, 0.01256464f, -0.01326538f, 
    0.02405090f, 0.00549999f, 0.00017816f, 0.00262832f, -0.03519757f, -0.02513212f, 0.01624045f, 0.01985898f, 
    0.03295434f, 0.00064191f, -0.05277373f, -0.05471366f, -0.03793257f, -0.02506438f, 0.03299024f, 0.04933646f, 
    -0.04285307f, -0.02050592f, -0.00072263f, -0.03887607f, 0.00986787f, 0.03532864f, 0.02576501f, -0.04797288f, 
    0.00451070f, 0.02640524f, -0.05860581f, -0.05787562f, 0.05202210f, -0.02058276f, -0.03368907f, -0.03136290f, 
    0.03505408f, -0.02751411f, -0.01750004f, 0.01479028f, -0.00310160f, -0.04975997f, -0.06252920f, -0.05229739f, 
    0.01247600f, 0.04744051f, 0.05208035f, -0.03534391f, 0.02579151f, 0.01628663f, 0.01685039f, 0.02394954f, 
    0.03690498f, 0.03283115f, -0.01877674f, 0.05347347f, -0.03219664f, -0.03002685f, -0.02083671f, -0.02613654f, 
    0.02154918f, 0.03797304f, -0.04874191f, -0.00645406f, -0.02276480f, 0.05255542f, -0.05431421f, -0.03691547f, 
    -0.00978907f, -0.01260292f, 0.04245928f, -0.03043344f, -0.00310244f, -0.02248718f, -0.04885693f, 0.01054232f, 
    -0.06357870f, -0.05613853f, 0.03763267f, -0.02877704f, 0.01861476f, -0.02049136f, -0.01442546f, 0.00277166f, 
    0.01930150f, 0.00929706f, 0.00782317f, -0.05978915f, 0.02946006f, 0.01962517f, 0.01014435f, 0.02698397f, 
    -0.00074372f, 0.05200229f, -0.01431095f, -0.01218144f, 0.04124833f, -0.01227724f, -0.00193447f, 0.01732991f, 
    -0.05216664f, -0.03288339f, -0.05297936f, -0.05430502f, -0.00945705f, -0.01774078f, 0.05810329f, -0.00734927f, 
    0.04954442f, -0.00595861f, 0.03953439f, -0.00927195f, -0.00355555f, 0.01042679f, -0.05189031f, -0.05600890f, 
    -0.05173761f, -0.00400636f, 0.03163105f, -0.04258390f, 0.00086863f, 0.02569060f, -0.01515860f, 0.00226966f, 
    -0.04267063f, -0.02244025f, 0.01270085f, -0.01343605f, -0.02689715f, -0.06069887f, 0.00179804f, -0.04153819f, 
    0.02496372f, 0.05079713f, -0.02149083f, -0.04943965f, -0.05652649f, -0.02963255f, 0.00704642f, 0.00287581f, 
    0.01965530f, -0.06016044f, 0.03264160f, -0.03463215f, 0.01074571f, -0.01401129f, -0.05675035f, -0.01225708f, 
    -0.00178051f, -0.04584347f, -0.05348526f, -0.02445941f, 0.03121799f, -0.00441400f, -0.05208175f, 0.00977529f, 
    0.04446688f, 0.00030713f, 0.03842947f, 0.05329156f, 0.01550095f, 0.05107649f, 0.00260521f, -0.06342990f, 
    -0.02076050f, 0.02227297f, -0.04994752f, -0.03412174f, -0.01890228f, 0.04163101f, 0.04063414f, 0.03543898f, 
    -0.06054572f, 0.00632459f, 0.00626560f, -0.02860629f, -0.05776745f, -0.03741485f, -0.05955182f, -0.02621744f, 
    -0.00036315f, -0.06258182f, -0.01764138f, -0.01817974f, -0.01732557f, -0.05646497f, 0.01814000f, -0.05425469f, 
    -0.00546880f, 0.00038099f, -0.06243992f, -0.02050280f, -0.03147344f, -0.00071310f, -0.06015487f, 0.00814761f, 
    0.05075331f, -0.00127197f, 0.03714786f, 0.01804332f, -0.01337906f, -0.02809237f, 0.04776199f, 0.03265356f, 
    -0.02208433f, -0.01230632f, 0.05286915f, -0.04162165f, -0.03073669f, 0.01083906f, 0.02321613f, -0.02394006f, 
    -0.03404561f, -0.04848418f, -0.01411222f, 0.03614997f, 0.02412820f, 0.04971759f, -0.04631836f, 0.02817338f, 
    0.01059815f, 0.02883177f, -0.02879753f, -0.01782867f, -0.04238794f, 0.00147256f, -0.05027047f, 0.01804433f, 
    0.00559110f, 0.03241915f, 0.01870864f, -0.04919034f, 0.03476190f, 0.01627889f, -0.00463383f, -0.03185833f, 
    -0.02573320f, 0.00712323f, -0.05257635f, 0.00194603f, -0.01550774f, 0.00805252f, -0.04842416f, -0.05045838f, 
    -0.02453094f, -0.03912900f, -0.05761884f, -0.05639261f, -0.04982604f, -0.05942126f, -0.03762793f, -0.05147597f, 
    -0.00948569f, 0.05250527f, 0.04497481f, 0.00440888f, -0.02914695f, -0.03911446f, 0.00368027f, -0.05616213f, 
    0.01186443f, 0.00463127f, 0.00295978f, -0.02170990f, -0.04668150f, -0.00732320f, -0.02834158f, 0.02522056f, 
    0.01673907f, -0.00605753f, -0.01295149f, -0.02166553f, -0.04332609f, 0.03488354f, -0.00025699f, -0.01500674f, 
    -0.04138855f, -0.02878767f, -0.04040420f, -0.06018100f, 0.04519417f, -0.04785369f, -0.01352757f, 0.02096207f, 
    -0.02090993f, -0.03090820f, -0.01893253f, -0.00485007f, -0.01826227f, -0.04583035f, 0.02370622f, -0.05405335f, 
    -0.06205919f, 0.03106766f, 0.03200964f, -0.03362443f, -0.01230999f, 0.04887287f, -0.04179006f, -0.02741821f, 
    -0.02945408f, -0.03024941f, -0.00286868f, 0.01626617f, 0.01567501f, 0.01344482f, 0.05042450f, -0.03236753f, 
    0.04255142f, -0.00420324f, 0.01338783f, -0.01368476f, 0.02416514f, 0.01200289f, -0.05825547f, 0.04374674f, 
    0.02165145f, -0.01652103f, 0.02688928f, 0.03815575f, 0.01920220f, 0.03748213f, -0.01607307f, 0.04464407f, 
    0.04526972f, -0.02407901f, -0.02966889f, 0.02719085f, 0.05287713f, -0.05621738f, -0.03033322f, 0.04127341f, 
    0.02740367f, -0.01849345f, 0.04194527f, 0.05337869f, 0.01684878f, 0.04409292f, -0.00469402f, -0.01282110f, 
    0.02092254f, 0.01077393f, -0.06211738f, 0.00166466f, -0.06397261f, -0.03669785f, -0.02625172f, -0.01091888f, 
    0.03197327f, 0.04534699f, -0.05488722f, 0.04994261f, -0.01640822f, 0.00964916f, 0.03984321f, -0.05597609f, 
    0.05524291f, -0.02739345f, 0.00135025f, -0.04903428f, 0.01415798f, -0.01888615f, -0.00548317f, 0.04508134f, 
    -0.04507595f, 0.01677842f, 0.03205556f, -0.05270691f, -0.01959333f, 0.00404430f, -0.03023223f, 0.00257461f, 
    0.05321372f, -0.04511657f, -0.01243907f, -0.03057570f, 0.00706527f, 0.04134738f, 0.02018985f, -0.06130758f, 
    -0.02105611f, 0.01984790f, 0.01290926f, -0.00225048f, -0.02211424f, -0.05916749f, 0.02093396f, -0.03902427f, 
    0.02421665f, -0.01688443f, 0.01192712f, -0.02864447f, -0.05733782f, -0.00723392f, -0.00813522f, -0.04135074f, 
    -0.05478380f, -0.03696857f, -0.00179579f, 0.03982885f, 0.00261559f, 0.01630159f, 0.01714935f, -0.05033483f, 
    -0.00854740f, -0.05047608f, -0.05304671f, -0.04134944f, -0.04316853f, 0.04813096f, 0.01688435f, -0.01482843f, 
    -0.03390379f, 0.04027698f, -0.04337212f, -0.06192101f, -0.04837021f, 0.02292348f, 0.00967174f, 0.03892393f, 
    0.00855574f, -0.02108954f, 0.01937005f, -0.02235583f, -0.01725089f, 0.04582432f, -0.03898039f, 0.04989370f, 
    0.00605628f, 0.03538971f, -0.05060665f, 0.04195393f, -0.06484034f, 0.04730891f, -0.03651864f, -0.02831566f, 
    0.02077327f, -0.02844230f, -0.04648643f, -0.01409890f, 0.03685186f, -0.03100658f, -0.06084688f, -0.00153939f, 
    -0.04293936f, 0.05227950f, 0.00975384f, 0.03656896f, -0.03008794f, 0.05077405f, -0.00347657f, -0.05318099f, 
    0.02636581f, 0.01948519f, -0.04803053f, 0.02421015f, -0.01910470f, -0.00287384f, 0.03111102f, -0.04407213f, 
    -0.03691761f, -0.02420255f, 0.05972131f, -0.00794633f, 0.03427527f, -0.02731497f, -0.03925256f, -0.00080837f, 
    0.00313527f, -0.02876667f, -0.00686862f, 0.00262831f, 0.03012129f, 0.02951162f, 0.03874705f, 0.01037686f, 
    -0.05428160f, 0.02987469f, -0.06430388f, -0.04159744f, 0.00071006f, -0.03808875f, -0.00579603f, 0.02312986f, 
    -0.04166616f, -0.01148989f, -0.02800105f, -0.05391600f, 0.01542201f, 0.01952335f, -0.03562099f, 0.04073206f, 
    -0.05596618f, -0.05459872f, -0.05563089f, -0.01239874f, -0.04433382f, 0.05036644f, -0.00123756f, 0.03209623f, 
    0.00995980f, -0.04387344f, -0.02640768f, 0.04994255f, 0.04672030f, -0.00439352f, -0.01916513f, -0.05250179f, 
    -0.01288561f, 0.03866847f, 0.03848818f, -0.05907792f, 0.00811352f, 0.00573287f, -0.05934848f, -0.02424111f, 
    0.04506579f, 0.03468692f, -0.05632873f, -0.03269687f, 0.01639834f, -0.06105442f, -0.04632271f, 0.01312888f, 
    -0.04026445f, 0.01631209f, -0.00676787f, 0.02877232f, 0.01467601f, -0.01270576f, 0.04938418f, -0.04803190f, 
    -0.02273058f, -0.00340063f, -0.00769339f, 0.04289096f, 0.00993815f, 0.02274691f, -0.00725591f, -0.06087905f, 
    -0.04878408f, -0.05026220f, 0.05269105f, 0.04797437f, -0.01700956f, 0.06205739f, 0.01515431f, -0.04298884f, 
    -0.01688858f, -0.06383119f, -0.05511508f, 0.03597643f, -0.05355330f, -0.00493288f, -0.05112442f, -0.00224633f, 
    -0.03582864f, -0.04384171f, 0.03043249f, -0.04442659f, -0.03628873f, 0.05179907f, -0.00152936f, -0.04256160f, 
    -0.06186387f, -0.03635937f, 0.00820742f, -0.07094186f, -0.01269650f, -0.00850977f, -0.04230693f, -0.04197434f, 
    -0.04529633f, -0.01298477f, -0.01007236f, -0.06984463f, -0.07017074f, 0.02112071f, 0.04446394f, 0.01203550f, 
    -0.01725950f, -0.09543805f, 0.03225866f, 0.04292267f, -0.04857568f, -0.07151029f, -0.06934994f, -0.03991226f, 
    -0.05645556f, -0.04944601f, 0.03764082f, 0.01754307f, -0.04339509f, 0.02272896f, -0.00537979f, -0.06608067f, 
    -0.04231921f, -0.04277530f, -0.01032000f, -0.07891955f, -0.04386852f, -0.02981704f, 0.00154174f, -0.05817000f, 
    -0.06251555f, 0.03879450f, -0.03134753f, -0.01363087f, -0.09494487f, -0.01383114f, -0.03037436f, -0.05882191f, 
    -0.01785107f, 0.02035888f, -0.03814813f, -0.03230780f, 0.02652976f, 0.02689949f, 0.04580182f, -0.06017280f, 
    -0.06748340f, -0.06561039f, 0.01009550f, 0.01253733f, 0.03344594f, 0.01722771f, -0.06155809f, -0.04522835f, 
    0.02731375f, -0.01130570f, -0.06070624f, -0.06705925f, -0.07974102f, -0.03493231f, -0.04714141f, -0.05314415f, 
    -0.01638262f, -0.00565779f, -0.03484094f, -0.00911249f, -0.04415151f, -0.04295170f, -0.00623206f, -0.04582021f, 
    0.02881083f, -0.01444425f, -0.03522576f, 0.04807135f, 0.01535002f, -0.09758683f, -0.08539002f, -0.01874330f, 
    -0.02041596f, -0.04093525f, 0.04237291f, -0.03387142f, -0.00380913f, -0.02315939f, -0.04076746f, -0.00708943f, 
    0.00574628f, 0.02225218f, -0.07236843f, -0.01972567f, -0.03323719f, -0.05078189f, -0.01854499f, -0.07296894f, 
    0.04744178f, 0.02494488f, -0.03392057f, -0.07656430f, -0.06841077f, -0.04980649f, 0.00153093f, -0.05535964f, 
    -0.02530093f, -0.00890519f, 0.00731534f, -0.06180074f, -0.03086581f, 0.04126693f, -0.06916197f, -0.04283864f, 
    0.03848654f, -0.06913739f, 0.02005361f, -0.00494949f, -0.02924412f, -0.03209940f, -0.01151678f, -0.07885029f, 
    -0.01653015f, -0.07898312f, 0.02232005f, -0.03402952f, -0.05005886f, -0.07140921f, 0.02148487f, -0.05201216f, 
    -0.06272011f, -0.00294088f, 0.01153946f, -0.02492459f, 0.01711851f, -0.01086214f, -0.06752506f, -0.06533774f, 
    0.00065701f, 0.00621149f, -0.03652554f, -0.05959509f, -0.08132070f, 0.02276605f, 0.01695851f, 0.00130386f, 
    0.02194738f, 0.02735399f, 0.00299790f, 0.01463582f, -0.05895142f, -0.08204584f, -0.05634665f, 0.03607401f, 
    -0.02013142f, -0.04600071f, 0.02834556f, -0.01258270f, -0.02963926f, -0.01391667f, -0.02511450f, -0.07223064f, 
    -0.05359111f, 0.02979604f, -0.03947020f, 0.00823268f, 0.01355643f, -0.04152211f, -0.03188126f, 0.00188898f, 
    -0.08625621f, -0.08929675f, 0.02617675f, 0.00900501f, -0.05326079f, -0.07044394f, -0.02564619f, 0.01196651f, 
    -0.06776704f, -0.08646849f, -0.00760718f, -0.01432847f, -0.03092542f, 0.03226716f, 0.00836786f, -0.05618723f, 
    -0.00764496f, 0.00021827f, -0.12141329f, -0.08004463f, -0.00221308f, -0.06514459f, 0.03079448f, 0.00542260f, 
    -0.00819704f, -0.04079635f, -0.04365185f, -0.03424539f, -0.07132354f, 0.01062089f, 0.02431343f, -0.04318850f, 
    0.03610723f, 0.00801205f, -0.01521094f, 0.00784276f, 0.01469389f, -0.00933829f, 0.00282069f, -0.04957934f, 
    -0.06565926f, 0.01859451f, -0.05293283f, -0.07666900f, -0.08151585f, -0.00810515f, -0.03950641f, -0.04607795f, 
    -0.03231144f, -0.03031502f, -0.08700917f, -0.04012399f, 0.02668842f, 0.01067440f, -0.01701791f, -0.08493358f, 
    -0.00889712f, 0.01607594f, -0.02230705f, 0.03026892f, 0.03501281f, -0.01208057f, -0.02297745f, -0.02467616f, 
    -0.07833828f, 0.00468214f, -0.02057714f, -0.02322063f, 0.00541118f, -0.05966707f, -0.07213172f, -0.08435456f, 
    0.00907260f, 0.01765919f, -0.06779469f, 0.03443323f, -0.03282301f, 0.03363116f, -0.08712988f, -0.08837977f, 
    0.04243036f, 0.03244790f, 0.02291019f, -0.02127434f, 0.03745476f, -0.07801958f, -0.06102723f, 0.03545885f, 
    -0.05908781f, -0.12153009f, 0.02132046f, -0.04077218f, -0.01090620f, 0.02044912f, -0.03737349f, 0.05799466f, 
    -0.02326112f, -0.03078755f, -0.04529563f, -0.07795974f, -0.02383267f, -0.05449189f, -0.03927093f, -0.05246917f, 
    -0.01755936f, 0.03800630f, -0.00925587f, -0.09143908f, -0.04233144f, -0.02251091f, -0.04377190f, -0.00902444f, 
    -0.08159529f, -0.03583927f, -0.39999515f, -0.17649193f, -0.02436262f, -0.04551759f, 0.02041275f, -0.12288882f, 
    0.14266524f, -0.28938052f, -0.30768788f, 0.03559266f, -0.17961900f, -0.06462250f, 0.20130146f, -0.02281495f, 
    -0.02554269f, 0.07703333f, 0.15320805f, -0.45467058f, 0.51597744f, 0.13319419f, -0.07114860f, 0.04864810f, 
    -0.02487497f, -0.08082856f, 0.04898544f, -0.05718433f, 0.15858048f, -0.06417304f, 0.16961633f, 0.08720796f, 
    -0.02796102f, 0.01418036f, -0.01501666f, -0.11741073f, -0.06653321f, 0.14824188f, -0.24132420f, 0.05753265f, 
    -0.00981520f, 0.12960100f, 0.04534959f, 0.02999674f, -0.07422616f, -0.20000237f, 0.05154604f, 0.21620417f, 
    0.05734485f, -0.08654512f, 0.10490542f, 0.07905838f, -0.02416281f, 0.13500823f, 0.31064585f, 0.07782723f, 
    0.09728698f, -0.08748183f, -0.17119977f, -0.04192572f, -0.05473164f, 0.01798023f, 0.08372480f, -0.13319880f, 
    -0.17434202f, -0.30507547f, 0.13906538f, -0.13455468f, 0.17791778f, -0.13024658f, -0.04378566f, 0.02053628f, 
    -0.40501922f, -0.12665363f, -0.20428953f, 0.09781247f, -0.12865546f, -0.10126132f, -0.05838428f, 0.07757552f, 
    0.02362385f, 0.40643871f, 0.11882553f, -0.37314489f, 0.03199543f, 0.05407215f, -0.20590250f, 0.08160783f, 
    0.06231645f, -0.15520808f, -0.30215582f, 0.09340186f, -0.28964928f, 0.21990934f, -0.05668589f, 0.10529397f, 
    0.08082954f, 0.02773548f, 0.08947227f, 0.44365829f, -0.01030581f, 0.04805247f, 0.08182998f, 0.00722737f, 
    0.06136158f, 0.07448491f, 0.01919745f, 0.00807368f, -0.04291955f, -0.10478210f, -0.22831109f, -0.08737455f, 
    0.03538880f, -0.00959286f, 0.09389257f, -0.12889835f, -0.12540315f, 0.30246529f, 0.01198439f, -0.03858462f, 
    -0.13984495f, -0.16013813f, -0.02812551f, -0.05366581f, 0.01181386f, -0.13420536f, -0.29855731f, -0.05967227f, 
    0.01874494f, -0.00344184f, -0.03458855f, -0.02211007f, -0.00142593f, -0.05439716f, -0.19001055f, 0.26630306f, 
    0.10312464f, -0.05355175f, -0.01313582f, 0.02197074f, -0.06718713f, 0.05099583f, 0.00745817f, -0.00955504f, 
    -0.04042548f, 0.14548662f, -0.24576408f, 0.04836402f, -0.07723483f, 0.00271768f, -0.03324347f, 0.10003147f, 
    0.01932820f, 0.23295841f, 0.11417355f, -0.38833162f, -0.15829355f, -0.03718673f, -0.02833979f, 0.12043360f, 
    0.02362363f, 0.10696933f, -0.01108841f, -0.11415368f, 0.23026520f, -0.12358208f, -0.13779120f, 0.26291594f, 
    -0.16692615f, -0.12048308f, 0.02427882f, -0.30245909f, 0.21219975f, 0.17467022f, 0.17554556f, 0.02066880f, 
    0.05220425f, 0.00157321f, 0.10223337f, 0.00596105f, 0.19667356f, 0.18947668f, -0.12770984f, -0.04916624f, 
    0.08930085f, 0.03272749f, 0.04470211f, -0.01070426f, 0.04440797f, -0.12757200f, 0.05971804f, -0.05109266f, 
    0.12736602f, 0.16955748f, 0.03429093f, -0.16847038f, 0.03032230f, -0.07001914f, 0.08944744f, 0.14116564f, 
    -0.35992426f, 0.05447592f, 0.20013060f, 0.05494634f, -0.00109131f, -0.13704532f, 0.13664424f, -0.03212626f, 
    -0.25373673f, 0.12813957f, 0.16845630f, 0.03994119f, -0.02242091f, 0.09891524f, 0.17604282f, 0.02974590f, 
    -0.10776938f, -0.05932573f, 0.14017400f, 0.22156157f, 0.15509111f, -0.16058055f, 0.00508228f, -0.05098062f, 
    -0.11059850f, 0.11764032f, 0.11735690f, -0.06205785f, -0.08005785f, -0.01977374f, -0.07737286f, 0.01374154f, 
    0.18595530f, 0.10949239f, -0.04756943f, -0.33174571f, 0.17629772f, 0.10992789f, -0.09982927f, -0.11003581f, 
    -0.15179287f, 0.15895911f, 0.11369298f, 0.13682561f, -0.03986813f, 0.25589854f, -0.06011839f, -0.06894410f, 
    0.13201386f, 0.00654518f, 0.04403499f, -0.09443580f, -0.02889075f, 0.08166873f, -0.24416791f, -0.03687004f, 
    -0.04404858f, 0.05888887f, -0.10513802f, 0.03364800f, -0.07959887f, -0.35325766f, -0.09792961f, 0.26989719f, 
    0.03062734f, 0.11930882f, 0.01199410f, 0.19044481f, 0.13990901f, -0.11686788f, 0.17878568f, -0.01816880f, 
    0.17432430f, -0.00088401f, 0.02318979f, 0.08391244f, -0.08640105f, -0.04059092f, 0.28601140f, -0.11602232f, 
    0.22264183f, -0.40229928f, 0.17604308f, -0.04470414f, -0.01680114f, 0.02577100f, 0.17471664f, 0.10607778f, 
    0.03552551f, 0.02326961f, -0.22790366f, -0.02098428f, 0.11265007f, 0.09610237f, 0.05648616f, 0.07636240f, 
    0.03022657f, 0.03803223f, -0.05720329f, -0.13086462f, -0.03149662f, -0.08260650f, 0.08700573f, 0.14058445f, 
    0.03038552f, -0.05357335f, 0.32992068f, -0.03154203f, -0.11876040f, -0.00215465f, -0.08403984f, 0.08516203f, 
    0.00501508f, -0.06463863f, 0.15105592f, 0.11491884f, 0.13039786f, -0.07180467f, 0.11485881f, -0.03069384f, 
    0.07428677f, -0.00910719f, -0.13461939f, -0.07274767f, 0.34772280f, -0.02283259f, -0.15471737f, 0.09539665f, 
    0.05031496f, 0.03893441f, 0.09621817f, -0.10542238f, -0.05595820f, 0.14512108f, -0.23248191f, 0.18551499f, 
    0.13485566f, 0.07583757f, 0.01380919f, 0.09349339f, -0.10781024f, 0.01275942f, -0.04417813f, -0.34672982f, 
    0.11725219f, -0.08630327f, -0.13367003f, -0.10646727f, -0.06364857f, -0.09921820f, 0.09281904f, 0.21112815f, 
    0.36721990f, -0.04390391f, 0.01927375f, 0.16330785f, -0.09423860f, 0.05088708f, 0.12757725f, -0.05866263f, 
    -0.21613105f, -0.49393079f, -0.04797950f, -0.20226313f, 0.01330831f, 0.11066106f, -0.00538152f, 0.07218315f, 
    -0.06788784f, -0.19870812f, -0.07537894f, 0.05346700f, -0.10877967f, -0.05452703f, 0.01420647f, -0.00898890f, 
    0.21056749f, 0.15160266f, -0.27553454f, 0.25870305f, -0.34821740f, 0.01214448f, 0.14789157f, 0.04366827f, 
    0.06325499f, -0.02858048f, 0.19259709f, 0.08476183f, -0.32527316f, 0.11187869f, 0.00885743f, 0.19072975f, 
    -0.09733797f, -0.13233653f, 0.06893259f, -0.01035119f, -0.36358792f, 0.24699919f, -0.04423863f, 0.02307119f, 
    0.04747344f, -0.05600465f, 0.16301006f, -0.00236602f, -0.06091933f, -0.28143537f, 0.21180914f, -0.10154928f, 
    0.13411209f, 0.10059304f, -0.12604770f, 0.01657451f, -0.05623091f, -0.20836337f, -0.86975628f, -0.07629981f, 
    0.10432593f, 0.01361078f, -0.03108736f, -0.06421859f, -0.01834440f, -0.04306264f, -0.12730096f, 0.25028566f, 
    -0.34830827f, -0.17806254f, -0.00328799f, 0.08781409f, 0.08678903f, 0.10661205f, 0.07241821f, 0.02175122f, 
    0.04199286f, -0.29446194f, -0.26455894f, 0.06699748f, -0.00200403f, 0.09588645f, 0.26857224f, 0.12371661f, 
    0.11202862f, -0.06124809f, -0.05721299f, 0.06068122f, -0.17638975f, -0.10297313f, -0.04851397f, -0.05336751f, 
    0.03026052f, -0.19008970f, 0.41527563f, -0.03446494f, -0.07908022f, -0.02071759f, -0.01255653f, 0.09061060f, 
    -0.01458912f, -0.08280008f, 0.11368125f, 0.24806018f, -0.19706385f, -0.17399220f, 0.07567899f, 0.07151946f, 
    0.17598425f, -0.05415123f, 0.09440092f, 0.07443481f, -0.21865503f, 0.00204813f, 0.20035796f, -0.11495582f, 
    0.03701624f, -0.03381569f, 0.10989209f, 0.00516483f, -0.07733388f, -0.00590118f, 0.06862690f, 0.01634675f, 
    -0.07300800f, 0.01559465f, 0.00035162f, 0.09410477f, 0.08148349f, -0.13877676f, 0.11505479f, 0.01554746f, 
    0.00035680f, -0.19658515f, 0.03686008f, 0.09660834f, -0.04006283f, 0.05375931f, 0.14868118f, -0.80811262f, 
    -0.20282097f, -0.11931091f, 0.19512671f, 0.06132934f, -0.07475370f, -0.04123612f, -0.10586081f, -0.02515756f, 
    0.42467940f, -0.02754290f, 0.06020579f, 0.04108929f, 0.03903478f, 0.10766931f, -0.03006131f, 0.06318057f, 
    0.04597064f, 0.04450756f, 0.14957057f, 0.27209425f, 0.23374902f, 0.08030403f, -0.01301228f, 0.07035012f, 
    0.02089357f, -0.14483988f, 0.24054845f, -0.43385157f, 0.14150578f, 0.02051740f, -0.01522289f, -0.00037338f, 
    -0.00922509f, 0.10297975f, 0.10583584f, 0.23051935f, -0.00353625f, -0.03109313f, 0.09996213f, -0.09049363f, 
    0.01803445f, 0.04335768f, 0.02927309f, -0.07806728f, -0.29444239f, 0.03924797f, 0.01330283f, -0.15450561f, 
    0.11705432f, 0.26271841f, -0.06662104f, -0.13604692f, 0.02306247f, -0.09907618f, -0.30686641f, -0.32628596f, 
    -0.01257624f, 0.09628263f, 0.00594892f, 0.08678367f, 0.09830631f, -0.18734823f, -0.07663651f, -0.28763652f, 
    0.08712237f, -0.00867171f, -0.07044937f, 0.03733098f, 0.18530726f, 0.05201592f, -0.02413085f, 0.07960179f, 
    0.02636160f, -0.02579055f, 0.04196884f, -0.01828896f, 0.17788182f, -0.02000335f, 0.06848124f, -0.02170187f, 
    -0.01326844f, 0.02727951f, 0.04107196f, -0.01492013f, 0.00218526f, 0.03478759f, -0.05713397f, -0.02016593f, 
    0.02717158f, 0.00437012f, -0.02590075f, 0.03397558f, 0.00769861f, 0.04514898f, 0.00847856f, -0.04302951f, 
    -0.05533025f, -0.04881441f, -0.04901787f, -0.01161276f, 0.00610530f, 0.05763548f, 0.05250039f, -0.03950839f, 
    0.02573728f, -0.05070578f, -0.00022042f, -0.06817088f, 0.01227125f, 0.00478419f, 0.03052779f, 0.03895441f, 
    -0.03376739f, 0.00439441f, 0.04316141f, 0.04624090f, -0.03031405f, 0.04345829f, 0.03938496f, -0.03198767f, 
    0.02235089f, -0.03071659f, -0.05968556f, 0.04011296f, 0.03895224f, 0.00320877f, 0.02952153f, -0.01368011f, 
    -0.05887387f, -0.00719673f, -0.01610929f, -0.03562804f, 0.00678443f, -0.04334148f, 0.03707789f, -0.06392720f, 
    -0.02209415f, -0.03985786f, -0.01011455f, 0.00366674f, 0.04475147f, -0.00951031f, -0.02519540f, 0.04603330f, 
    0.00016226f, -0.05991646f, -0.03831830f, -0.04445585f, -0.01109051f, 0.02966440f, -0.00612619f, -0.03130789f, 
    0.03283565f, -0.05668744f, 0.02688660f, -0.06565430f, -0.04064846f, -0.00592434f, 0.02549398f, 0.02545735f, 
    0.03456168f, -0.05744589f, 0.00014139f, 0.02516532f, -0.02235924f, -0.02233684f, 0.05339105f, 0.02163387f, 
    0.04055209f, -0.02497205f, -0.00817901f, -0.05351735f, -0.04370020f, 0.01959456f, -0.05645101f, 0.00347461f, 
    0.00452141f, -0.01752174f, -0.03541230f, -0.06246597f, 0.00445639f, 0.05134021f, -0.03923465f, -0.02116855f, 
    0.04401292f, 0.02418402f, 0.00099372f, 0.03880609f, -0.02447863f, 0.00390702f, -0.01299510f, 0.01914611f, 
    -0.03567073f, 0.03001845f, -0.05585724f, -0.01487925f, -0.02879130f, 0.02598730f, -0.03914861f, -0.06161126f, 
    -0.01109518f, -0.01494076f, 0.02544823f, -0.00915463f, 0.03372537f, -0.02550315f, 0.03688804f, -0.02178029f, 
    -0.05740551f, 0.04561988f, 0.00790351f, 0.01458582f, 0.05266114f, -0.01878392f, -0.03728767f, 0.00395882f, 
    -0.05334833f, 0.02748286f, -0.03269391f, -0.03632925f, -0.00940259f, 0.01038145f, -0.02862721f, -0.03085218f, 
    -0.00792565f, 0.05376335f, 0.00736406f, -0.03703933f, -0.02198765f, -0.00228653f, 0.03048824f, -0.02529889f, 
    -0.00970547f, -0.02129528f, 0.04074499f, 0.02484863f, -0.01693868f, -0.03096209f, -0.04280665f, 0.01476098f, 
    -0.01803404f, 0.03336898f, -0.01870535f, -0.06489319f, 0.02557857f, 0.02373079f, -0.01044860f, -0.00216821f, 
    -0.02010999f, 0.01468986f, 0.04727219f, 0.03537847f, 0.02935281f, -0.01901422f, 0.00539605f, -0.03855478f, 
    0.01199560f, 0.04534227f, -0.01329625f, 0.04595750f, -0.04604405f, -0.03303034f, -0.02596867f, -0.06404001f, 
    -0.04608258f, 0.04405713f, -0.02698128f, 0.04625723f, -0.03959027f, -0.01878904f, -0.04938957f, 0.00773962f, 
    -0.02357936f, 0.04905538f, -0.05552583f, -0.03200433f, -0.03938469f, 0.05048461f, -0.02259884f, -0.01485409f, 
    0.02869180f, -0.06370405f, 0.00867879f, 0.02047597f, 0.00428156f, 0.00365761f, 0.01476165f, 0.02340817f, 
    -0.01212427f, 0.04078663f, -0.03180617f, -0.04443605f, 0.04134513f, -0.04350790f, 0.03409270f, -0.00866445f, 
    0.04914707f, -0.04631372f, 0.01779643f, -0.06281236f, 0.00115097f, -0.05233912f, 0.01467289f, -0.00135918f, 
    -0.05852175f, 0.02491147f, -0.03227919f, -0.04280808f, -0.06078146f, 0.00612806f, 0.03679779f, -0.00890734f, 
    0.04804242f, -0.04855978f, -0.03422592f, 0.00658885f, 0.03148092f, -0.01194701f, -0.05030315f, -0.01963612f, 
    -0.01745675f, 0.04436372f, 0.02870254f, -0.02192565f, 0.04978560f, 0.04100093f, 0.01620654f, -0.02811605f, 
    -0.03336639f, 0.04359607f, 0.03909493f, -0.04175503f, -0.00904344f, 0.02787509f, -0.01955699f, 0.01158591f, 
    0.02749071f, -0.01546200f, -0.03264981f, -0.05731960f, -0.04078113f, -0.03222679f, 0.05078124f, -0.02619293f, 
    -0.02639400f, -0.04330846f, 0.02776902f, 0.00076196f, -0.03168332f, 0.02702112f, 0.05356737f, -0.04537181f, 
    0.02632593f, 0.01197925f, -0.03404715f, 0.02668264f, -0.06613749f, -0.02635415f, -0.01207897f, -0.05332235f, 
    -0.00680666f, 0.00124673f, -0.00579855f, 0.00314133f, 0.02576443f, -0.04990346f, 0.01467427f, -0.04389244f, 
    -0.05691915f, 0.10323983f, -0.08519089f, -0.00217803f, 0.12632065f, -0.11326949f, -0.03434934f, -0.01876369f, 
    0.08987010f, -0.05494561f, 0.16069280f, -0.21635969f, 0.13127729f, -0.01342927f, -0.15416619f, 0.10649542f, 
    -0.06817771f, 0.14183936f, -0.35668153f, 0.15446435f, 0.04687906f, 0.09991032f, 0.03312930f, -0.09501984f, 
    0.28539044f, -0.01100540f, 0.11557933f, 0.07220548f, -0.10040064f, 0.13130155f, 0.02325713f, 0.17000166f, 
    -0.08140628f, -0.12826478f, 0.05343689f, 0.31150454f, -0.03700974f, 0.00111112f, 0.12734169f, -0.12979475f, 
    0.23239213f, 0.08438329f, -0.00950888f, 0.18739919f, -0.17490596f, -0.30152953f, -0.01785994f, 0.19736511f, 
    0.14371313f, 0.10737630f, 0.05698954f, -0.09679151f, -0.22341418f, -0.11030620f, -0.14934836f, -0.16170265f, 
    -0.14628862f, 0.09407913f, 0.01557964f, -0.01321924f, 0.20803338f, -0.00703919f, 0.00857364f, -0.03832896f, 
    0.03371363f, 0.21488006f, -0.02862972f, 0.01093886f, -0.18738922f, 0.20319036f, 0.09675414f, -0.23531730f, 
    0.14622664f, 0.03442107f, 0.20707291f, -0.02679066f, 0.08538177f, 0.09848948f, 0.02898420f, -0.10601565f, 
    0.07462874f, -0.02940365f, 0.01419128f, 0.16949603f, -0.26587087f, -0.06809857f, 0.10524783f, -0.02735862f, 
    -0.01326691f, -0.09571464f, 0.09166228f, 0.04010870f, 0.09546230f, 0.07474365f, 0.13051853f, 0.19451678f, 
    0.00252607f, -0.15848744f, 0.08897812f, 0.06376152f, 0.01642940f, -0.04428722f, 0.03465085f, -0.01392225f, 
    -0.22588046f, -0.07274079f, -0.33179513f, -0.01766599f, -0.26878482f, -0.22379252f, -0.02311477f, 0.03622143f, 
    0.16188516f, -0.24576837f, -0.00500095f, 0.07539875f, 0.19200216f, -0.10747653f, -0.06793404f, 0.15330054f, 
    -0.14085566f, -0.04827847f, 0.11098202f, 0.23258665f, 0.16484982f, -0.02154612f, -0.11091982f, 0.16928104f, 
    -0.02344765f, 0.00922113f, -0.09934492f, -0.04705453f, 0.03138989f, -0.02274795f, 0.15834321f, -0.05107132f, 
    -0.07444114f, 0.20077814f, -0.12094956f, -0.04024445f, -0.02550726f, -0.07394803f, 0.05690359f, -0.10627441f, 
    -0.05151162f, 0.10020709f, 0.06595928f, 0.22305150f, 0.21260962f, -0.00116724f, -0.03702696f, -0.06562629f, 
    -0.29860556f, -0.19886173f, -0.06680814f, 0.04282265f, -0.05037209f, 0.07616640f, -0.07123962f, 0.02308580f, 
    -0.02153930f, 0.24171558f, -0.11734498f, 0.18994172f, 0.05682082f, 0.10198743f, 0.10224783f, 0.06675921f, 
    -0.01230848f, -0.15039645f, -0.02652719f, -0.17427059f, 0.01412289f, -0.09643900f, -0.00115965f, 0.10551586f, 
    -0.03084856f, 0.09331344f, -0.13678071f, -0.07460319f, 0.02383680f, -0.02241137f, 0.12039340f, 0.01318550f, 
    0.09158322f, -0.33488706f, 0.00664925f, -0.18124045f, 0.20672038f, 0.29372823f, -0.19606343f, 0.02600054f, 
    0.02126703f, -0.14210238f, -0.30103719f, -0.06817982f, 0.03105967f, 0.20362259f, 0.03040246f, -0.00176821f, 
    0.10010450f, 0.06751257f, -0.15533191f, 0.03319343f, -0.02187815f, 0.05823655f, 0.02952593f, 0.01629470f, 
    -0.33110514f, -0.07882379f, -0.01449154f, -0.11704289f, 0.05393114f, -0.19547163f, 0.14601168f, -0.22456557f, 
    0.09817238f, -0.04331052f, 0.15868899f, 0.14846726f, 0.09214032f, 0.06723528f, 0.00991034f, 0.01150697f, 
    0.06106762f, 0.08686553f, 0.10544267f, 0.04146672f, -0.16173102f, -0.03213795f, -0.21254124f, -0.00811934f, 
    0.11795343f, 0.00368008f, -0.24743903f, 0.17237759f, 0.19452570f, 0.26836950f, 0.04364657f, -0.02182616f, 
    -0.01656788f, 0.15485294f, -0.05051968f, -0.23292138f, 0.17444085f, 0.08083836f, -0.02668025f, -0.03689925f, 
    -0.05774168f, 0.11360775f, 0.14521551f, 0.19925530f, 0.14578807f, -0.23407374f, -0.08579411f, 0.19935931f, 
    0.13405393f, -0.04910719f, 0.02163840f, -0.23431008f, -0.12221354f, -0.09214494f, 0.01914653f, -0.13092983f, 
    0.15716833f, 0.08798063f, 0.10848113f, -0.05449336f, -0.07647707f, -0.18585777f, -0.00661873f, 0.11452251f, 
    0.07164956f, 0.12815692f, -0.09197972f, -0.18001148f, -0.02398565f, 0.19641949f, 0.04117434f, 0.04165374f, 
    0.02936729f, 0.24272498f, -0.18987207f, 0.09363256f, 0.10267472f, 0.05073324f, 0.07355747f, 0.03799310f, 
    0.02932042f, -0.01339826f, -0.04323667f, 0.00678974f, 0.00423898f, 0.03609156f, -0.01227330f, 0.00585207f, 
    0.03667474f, -0.01444013f, -0.05374637f, -0.03875478f, -0.01183148f, -0.00982437f, 0.04900957f, -0.01351450f, 
    -0.05365722f, -0.02471880f, 0.03599626f, 0.00349684f, 0.03066104f, 0.03284461f, -0.04793195f, -0.02061877f, 
    -0.02104859f, -0.04287247f, -0.05084211f, 0.00170669f, -0.00616486f, -0.06875276f, 0.03412773f, 0.00336547f, 
    -0.01963469f, -0.04230641f, 0.02808687f, -0.05858406f, 0.02014057f, -0.00175116f, -0.02295521f, 0.03942167f, 
    -0.04319663f, 0.00993714f, 0.00068344f, 0.00054503f, -0.01006498f, -0.06836134f, -0.00550235f, 0.00375690f, 
    -0.03993501f, -0.01883492f, -0.00286466f, 0.03079484f, -0.05016791f, 0.03056174f, -0.02439958f, 0.02711407f, 
    0.03069952f, 0.02336432f, 0.03285366f, 0.02266556f, -0.06192931f, -0.05005576f, 0.02279546f, -0.01690003f, 
    -0.05233080f, -0.04620446f, 0.03179621f, 0.04640977f, 0.03496705f, 0.04246205f, 0.04629485f, -0.00097330f, 
    -0.06635679f, 0.01489524f, 0.04127631f, -0.02124152f, 0.02237823f, -0.03145161f, 0.00094830f, -0.01018783f, 
    0.04981295f, -0.01556786f, -0.04837685f, -0.00855266f, 0.04067407f, 0.03750319f, -0.01835706f, -0.01029949f, 
    -0.00598743f, 0.05295712f, -0.01839470f, -0.04217969f, -0.03479328f, 0.03510313f, -0.00868503f, -0.06748234f, 
    0.00654346f, -0.02381300f, -0.01638902f, -0.02194389f, -0.00005681f, 0.02778523f, 0.01650113f, 0.03168530f, 
    -0.05318173f, -0.00497822f, -0.04352564f, -0.05394058f, 0.04744853f, -0.03824179f, -0.06297823f, 0.04429467f, 
    -0.05071060f, -0.05312904f, -0.00183265f, -0.05882253f, 0.02479680f, -0.01540702f, 0.05445013f, -0.05914361f, 
    -0.04549261f, -0.05681313f, 0.01240956f, 0.04139047f, 0.02241069f, 0.04228471f, -0.00949166f, -0.00457554f, 
    0.00114251f, -0.00049530f, -0.04173700f, 0.01566095f, -0.05711024f, 0.01215663f, -0.03561104f, -0.05446585f, 
    0.01162086f, 0.03924445f, 0.02322408f, -0.01901882f, 0.03701594f, 0.01828580f, -0.04151272f, -0.03625137f, 
    -0.02506514f, 0.04636606f, 0.04448808f, 0.00064780f, -0.06663644f, 0.01229714f, -0.03760247f, 0.01353027f, 
    -0.02147758f, -0.01273943f, 0.04920744f, -0.02097902f, -0.04108584f, -0.01620632f, -0.01113768f, 0.01460602f, 
    -0.02388934f, 0.02265898f, -0.00740078f, 0.01826320f, -0.00172949f, 0.02750321f, -0.03519674f, -0.00829622f, 
    -0.06802498f, 0.05159459f, 0.04055332f, 0.03146654f, 0.02725796f, 0.02970042f, -0.05757867f, -0.04718946f, 
    -0.06707805f, -0.03093140f, 0.03525154f, 0.00737770f, -0.05221544f, -0.06002281f, 0.03832428f, 0.01466625f, 
    0.05790986f, 0.03102395f, 0.01382889f, 0.02240157f, -0.02435067f, 0.02584472f, -0.01870025f, -0.00477927f, 
    0.04017794f, -0.05122748f, 0.02244322f, -0.01788857f, 0.02576145f, -0.05618457f, 0.00028793f, -0.01394829f, 
    -0.05007301f, 0.02918932f, -0.04930863f, 0.01889811f, 0.04678192f, -0.04171702f, -0.06136606f, -0.02883910f, 
    -0.01157118f, 0.02247403f, -0.01310350f, -0.04516349f, 0.04591972f, -0.06221950f, -0.02788362f, -0.05030140f, 
    0.02267063f, -0.05264400f, 0.03365695f, 0.00233712f, 0.01137178f, 0.03664814f, -0.04439030f, -0.03100704f, 
    -0.00537269f, -0.05880995f, 0.04128672f, -0.02086997f, 0.00408862f, 0.02947646f, 0.00801511f, -0.00109069f, 
    -0.00016900f, 0.04701586f, -0.06829194f, 0.03529536f, -0.01096987f, 0.02277228f, 0.00430925f, 0.00590229f, 
    -0.06146232f, 0.01452905f, -0.04310906f, -0.01760034f, 0.01630512f, -0.05617137f, 0.01378886f, 0.01176316f, 
    -0.06201975f, -0.04468550f, -0.02268763f, -0.05899394f, -0.00948295f, -0.01541863f, -0.05675516f, -0.03804491f, 
    -0.03123103f, 0.02934115f, -0.01918541f, 0.04039070f, 0.00438984f, 0.04228484f, 0.02568321f, -0.03074365f, 
    -0.03185273f, 0.00732731f, -0.00444621f, -0.02437818f, 0.03031179f, -0.04250867f, -0.04483473f, -0.03608797f, 
    0.00140538f, 0.02627431f, -0.06330343f, 0.04869604f, 0.04469617f, -0.05711001f, 0.02834931f, -0.06853635f, 
    0.02706598f, -0.06504846f, -0.05276103f, -0.04598984f, -0.01567329f, 0.04096933f, -0.03108636f, -0.00300980f, 
    -0.07845698f, -0.16232255f, -0.55217254f, 0.05338547f, -0.12630764f, 0.10014929f, 0.01812887f, -0.00778702f, 
    0.17606676f, -0.20568843f, -0.04965142f, -0.02856247f, 0.10232267f, 0.00413754f, 0.07723434f, 0.05780530f, 
    -0.01244319f, -0.11693307f, -0.49524662f, -0.08583263f, 0.04370174f, 0.13512754f, 0.03576670f, 0.02727165f, 
    -0.05093301f, -0.04874752f, 0.18020633f, -0.10284009f, 0.08758050f, 0.37697697f, 0.15817718f, 0.21235651f, 
    0.05527356f, 0.14560233f, 0.03240092f, -0.03630845f, 0.01937726f, -0.00385656f, -0.09486763f, 0.24525519f, 
    0.00441465f, 0.04203707f, -0.03564409f, 0.06966218f, -0.21900648f, -0.03034004f, -0.25472024f, 0.03924548f, 
    0.03697683f, 0.05146318f, 0.10735226f, -0.09339475f, -0.04262591f, -0.12003472f, -0.09009305f, 0.00500432f, 
    0.03548315f, 0.18980145f, -0.02460379f, 0.00851681f, -0.02742689f, 0.02553568f, -0.06687834f, 0.20169356f, 
    -0.00365039f, 0.06926407f, 0.12060557f, 0.15710334f, 0.08229823f, 0.04130147f, -0.05721609f, 0.04280979f, 
    0.07171814f, 0.03722201f, -0.06344482f, 0.07711586f, -0.12057862f, 0.07389110f, 0.06113289f, 0.03613931f, 
    -0.06518352f, -0.32388005f, 0.08009130f, 0.24383064f, -0.30022520f, -0.01032908f, -0.24415955f, 0.02926487f, 
    -0.15095338f, 0.07249735f, 0.13378911f, 0.02025349f, -0.00426082f, 0.05209358f, 0.08256101f, 0.09967511f, 
    -0.04375875f, 0.07969107f, -0.06817152f, 0.09523997f, 0.06763110f, 0.00130490f, -0.01760625f, -0.07740398f, 
    0.23866673f, 0.11224906f, -0.06817871f, -0.01274415f, -0.21425317f, -0.10522614f, -0.09348693f, 0.05868372f, 
    0.03586125f, 0.10527385f, -0.01649006f, 0.13701096f, 0.08010741f, -0.00760050f, -0.23859248f, -0.38776490f, 
    0.16931440f, -0.18729152f, -0.06920423f, -0.15481715f, -0.15087470f, 0.10469797f, -0.19266996f, -0.12295743f, 
    -0.28482071f, -0.03282391f, -0.03335495f, -0.15709779f, 0.11959790f, 0.08267266f, 0.02992812f, -0.13056011f, 
    0.09199786f, 0.01523192f, -0.08696715f, -0.03918696f, 0.13438916f, -0.05187542f, 0.06357473f, -0.23811907f, 
    0.27369356f, 0.19218230f, 0.00828292f, 0.15318917f, 0.09749684f, 0.07602019f, 0.06596998f, 0.00854485f, 
    0.01130484f, -0.06855372f, -0.03833634f, 0.03381566f, -0.04256533f, -0.12399279f, 0.05601437f, -0.12694028f, 
    -0.04207965f, 0.37512773f, 0.13436919f, -0.11471887f, 0.03339716f, 0.09924301f, 0.09351237f, -0.08255994f, 
    0.01201961f, 0.01918727f, -0.02280457f, -0.40424973f, 0.03394679f, 0.14581610f, -0.02848312f, 0.08625714f, 
    0.18982214f, -0.07579949f, 0.05467681f, 0.02248127f, -0.10972705f, -0.01927222f, 0.18912582f, 0.24503405f, 
    0.02364381f, -0.03408686f, 0.24168682f, -0.04022936f, 0.01824521f, 0.29271555f, 0.22121190f, 0.08010234f, 
    0.29993221f, 0.19739424f, -0.09338495f, 0.14489876f, -0.13037969f, -0.03372983f, -0.16494128f, 0.03667936f, 
    -0.01702351f, 0.22483128f, 0.06505372f, 0.05668375f, -0.13038544f, 0.14778610f, 0.10747208f, -0.71757597f, 
    -0.51638889f, -0.20447804f, 0.00845559f, 0.03138269f, -0.21028635f, -0.00328757f, 0.08059920f, -0.05410677f, 
    0.23534991f, -0.00960151f, 0.32575408f, 0.21470596f, 0.12426091f, 0.04249289f, 0.22997166f, 0.22462468f, 
    0.10275227f, 0.11918075f, 0.10658418f, -0.17620619f, 0.06344648f, 0.07200406f, -0.02191314f, 0.06907818f, 
    0.01882908f, 0.07283340f, -0.36565089f, -0.25279725f, -0.01723274f, 0.17317811f, -0.00962186f, 0.08297840f, 
    0.17964922f, -0.06331260f, 0.09942827f, -0.05455187f, 0.29730567f, -0.13557285f, 0.16100331f, -0.09876122f, 
    -0.05818786f, 0.12782006f, -0.18393219f, -0.12407964f, -0.06176108f, -0.13773449f, -0.03395472f, 0.14845754f, 
    0.11367527f, 0.05353488f, 0.03763256f, 0.02794799f, 0.06214514f, 0.19164062f, 0.05088878f, -0.07126518f, 
    -0.08096907f, 0.17976539f, -0.02966692f, 0.07762847f, -0.15503225f, 0.21024354f, -0.27910224f, -0.04751057f, 
    0.19252826f, 0.10806710f, 0.06207669f, 0.09039091f, 0.00007369f, -0.05299597f, -0.02859197f, -0.19168796f, 
    0.17969608f, 0.24395742f, -0.06322163f, -0.09431511f, -0.39941970f, 0.12573339f, 0.14637960f, 0.09102196f, 
    -0.00507005f, -0.17104097f, -0.07326051f, 0.04354465f, 0.00499182f, 0.05235964f, -0.04336482f, 0.01337809f, 
    0.04640951f, 0.20230210f, 0.13249348f, 0.02901052f, 0.07691614f, -0.00602170f, -0.01774217f, 0.05256064f, 
    0.01055661f, -0.10813456f, 0.32445678f, 0.40253597f, 0.13116656f, 0.03446984f, -0.06947721f, -0.05456150f, 
    -0.06456558f, 0.22918381f, 0.05255136f, -0.26783493f, -0.34121627f, -0.11336771f, 0.00536966f, -0.04801450f, 
    -0.03086743f, 0.00100755f, -0.00873245f, 0.03901141f, -0.12050201f, -0.10676111f, -0.10753597f, 0.01773163f, 
    -0.00739864f, 0.23521683f, -0.15699372f, 0.02391523f, -0.14956707f, -0.14070126f, 0.14855082f, -0.10066102f, 
    -0.05037367f, -0.00875235f, -0.12617946f, 0.10239889f, -0.00049822f, -0.10081159f, 0.24444807f, -0.08996617f, 
    -0.25570285f, 0.00639903f, -0.01921687f, -0.13730133f, -0.01345320f, 0.10900595f, 0.10155743f, 0.04029960f, 
    -0.20225072f, 0.00747586f, 0.18832360f, -0.03727484f, -0.01824577f, -0.05736259f, 0.18433253f, -0.06804559f, 
    -0.03530699f, 0.18976690f, -0.07188323f, -0.01263739f, 0.07062184f, -0.01127051f, 0.18519649f, 0.02633744f, 
    -0.08890727f, 0.37783870f, -0.18361680f, 0.07348057f, 0.07949139f, -0.18811832f, 0.13607949f, -0.02739018f, 
    0.11707004f, 0.07313842f, 0.08821061f, -0.08785352f, 0.20321386f, 0.08170407f, 0.07796964f, 0.07895530f, 
    -0.01411758f, -0.05724254f, 0.10673539f, -0.11488652f, -0.08998515f, -0.06466812f, -0.04738868f, -0.02150107f, 
    -0.12020844f, 0.11914553f, -0.14264397f, 0.00267626f, 0.00352155f, 0.02783293f, -0.22420245f, -0.09772401f, 
    -0.01769196f, -0.10354141f, 0.13123907f, -0.04659891f, -0.04899839f, 0.28415221f, -0.06405167f, 0.05048840f, 
    -0.08261414f, 0.04730485f, 0.21795058f, -0.08658208f, 0.08676226f, 0.14099777f, -0.21672857f, 0.07873253f, 
    -0.07702286f, -0.27835679f, -0.25978959f, -0.00162404f, 0.17948352f, 0.03635887f, 0.09357546f, -0.46158794f, 
    -0.19540305f, -0.07204498f, 0.11253218f, 0.02828562f, -0.01173731f, -0.02503044f, -0.01863362f, 0.08064961f, 
    0.36790285f, 0.01203240f, 0.07089945f, 0.01722172f, 0.06981259f, 0.05057929f, -0.00905281f, -0.08780351f, 
    0.00004760f, 0.11832246f, -0.49619401f, 0.03392123f, 0.14136891f, 0.16352770f, 0.04662114f, 0.03420450f, 
    0.03649887f, 0.06181575f, -0.03009259f, 0.15420231f, -0.17043625f, 0.10403765f, 0.03330540f, -0.02336515f, 
    0.01927112f, 0.03689492f, 0.19958925f, 0.13322768f, 0.10160965f, 0.01281070f, 0.07952487f, 0.00285447f, 
    -0.13552043f, 0.16627313f, 0.01537471f, -0.23859780f, -0.62428284f, -0.24513969f, -0.17689022f, -0.06200415f, 
    0.11765198f, 0.07764325f, 0.08548573f, 0.00612749f, 0.16216560f, -0.64743221f, -0.11775823f, -0.17319530f, 
    0.05847241f, 0.14796722f, -0.04981363f, 0.05254991f, 0.11637587f, -0.04546310f, 0.44101575f, -0.18596563f, 
    -0.02496723f, 0.02022723f, 0.06582430f, -0.06910340f, 0.12731408f, -0.06341251f, -0.03238317f, -0.10376484f, 
    -0.10585994f, 0.26196390f, -0.13175528f, -0.11849823f, 0.09215864f, -0.06968461f, -0.00514920f, -0.06573500f, 
    -0.02329353f, 0.13590120f, -0.13082565f, -0.00546604f, -0.09502146f, 0.04986705f, -0.09079611f, 0.08750059f, 
    0.00460870f, -0.24771161f, -0.17334540f, -0.25729892f, -0.03986864f, 0.00790055f, -0.12450518f, 0.00761613f, 
    0.12418520f, 0.11752004f, -0.09545664f, 0.25347847f, -0.05264107f, 0.02395763f, -0.07641898f, -0.08675038f, 
    -0.09182525f, 0.20208764f, 0.06259600f, 0.14476278f, 0.08483358f, -0.03093964f, 0.08841886f, -0.00668658f, 
    0.07853087f, 0.09715780f, -0.00681674f, 0.10214998f, 0.29373679f, 0.02718735f, -0.23615833f, 0.02641502f, 
    -0.07662731f, -0.00024928f, 0.10785241f, -0.06888331f, 0.05543984f, 0.12559806f, 0.19998845f, 0.22137754f, 
    0.07427303f, 0.01524052f, 0.07128958f, 0.02781553f, -0.04506403f, -0.06481880f, 0.45276761f, 0.16692510f, 
    0.06574882f, 0.06573556f, 0.11442310f, -0.03143856f, -0.08976278f, 0.22101842f, 0.04914029f, -0.02865692f, 
    -0.00527616f, 0.07936746f, -0.02989846f, 0.10866260f, 0.18180904f, -0.15385664f, -0.10493102f, 0.02562163f, 
    -0.04448823f, -0.00868317f, 0.03995703f, -0.06477436f, -0.00855063f, -0.02334841f, 0.01972064f, -0.06278099f, 
    0.03821019f, 0.03563211f, -0.05535793f, 0.03557983f, -0.01262553f, 0.02859862f, 0.03902591f, -0.05528808f, 
    -0.00517903f, -0.05182571f, -0.06357224f, 0.00428011f, -0.01089625f, -0.03834899f, -0.03712543f, 0.01683384f, 
    0.01723897f, -0.00680249f, 0.02132262f, -0.01964699f, 0.03208817f, -0.05300897f, 0.01018102f, 0.04121930f, 
    -0.04202504f, 0.04013949f, 0.00463431f, -0.01743011f, 0.00639488f, -0.03580723f, -0.06535171f, -0.01803051f, 
    0.01988927f, 0.04072502f, -0.04657088f, -0.03441206f, -0.01827360f, 0.00295830f, 0.02556238f, -0.02467177f, 
    -0.00900209f, 0.03623082f, -0.04671810f, -0.03810151f, -0.02162929f, -0.06876256f, 0.03238784f, -0.01723007f, 
    -0.00930991f, 0.04397528f, -0.01822947f, -0.06050904f, -0.03904791f, 0.00993643f, -0.02666903f, -0.00607685f, 
    -0.05350729f, 0.00382769f, -0.05200922f, -0.03015684f, -0.06238789f, -0.01901826f, 0.00631405f, -0.02253854f, 
    0.03239860f, 0.00440630f, -0.04066806f, -0.00797369f, -0.04913939f, 0.00907611f, -0.01677655f, -0.00434679f, 
    0.04735236f, -0.04508520f, -0.04428225f, -0.00971911f, -0.03058229f, 0.04198732f, -0.01807208f, -0.04934154f, 
    -0.00454619f, -0.06020571f, 0.00950986f, -0.06988639f, -0.02940267f, 0.01913266f, -0.00878826f, -0.04020781f, 
    0.04224145f, 0.02588956f, -0.06290496f, 0.00105522f, -0.04829986f, 0.04481336f, -0.02742909f, 0.00528835f, 
    0.00104917f, -0.02373941f, -0.04993228f, -0.03661175f, -0.04807735f, 0.04293820f, -0.04674292f, -0.01388562f, 
    -0.03870454f, -0.05606160f, 0.01648716f, -0.00094025f, -0.00895034f, 0.02736604f, -0.05416130f, 0.01143572f, 
    0.01675623f, -0.01658554f, -0.05287755f, 0.02527927f, 0.01894999f, 0.02980539f, 0.01347770f, 0.02782665f, 
    -0.06314732f, -0.02302190f, -0.00209843f, -0.02119329f, -0.00205094f, 0.04813500f, 0.02990303f, -0.03716368f, 
    -0.00638884f, -0.00695456f, -0.06068323f, -0.00692356f, 0.01466348f, 0.00216579f, -0.05429539f, -0.00179808f, 
    0.03694391f, 0.01392377f, 0.02566796f, -0.02048523f, -0.01833268f, 0.03458623f, 0.03348409f, -0.01152682f, 
    0.01680811f, 0.02305034f, 0.00946417f, -0.06501397f, 0.03522985f, 0.02164440f, 0.01780304f, -0.02624005f, 
    -0.04173782f, -0.00881794f, -0.03520939f, 0.04632591f, -0.03225030f, -0.05654228f, -0.01815041f, -0.05166672f, 
    -0.03441559f, -0.02293270f, 0.02688178f, -0.06436484f, -0.04505705f, 0.05269815f, 0.00709854f, 0.02751327f, 
    -0.05391405f, -0.02606844f, -0.03051219f, 0.01899636f, -0.03743250f, -0.03305698f, 0.01397497f, -0.00727412f, 
    0.03342814f, -0.00011989f, -0.04252059f, -0.02239561f, -0.01703079f, -0.01364483f, -0.00513046f, -0.02560949f, 
    -0.05790812f, -0.05716704f, 0.02207365f, -0.03596516f, -0.03416789f, -0.04609674f, 0.04731416f, -0.03399492f, 
    0.00213357f, -0.04171777f, 0.01530289f, 0.03903081f, 0.04247053f, -0.01320383f, -0.05714438f, -0.05329143f, 
    -0.04325807f, 0.04789075f, 0.00790276f, -0.00620433f, -0.03728288f, -0.01802556f, 0.04199723f, 0.00072913f, 
    0.04077192f, 0.01227489f, 0.00771105f, -0.02738052f, -0.02055558f, 0.04902399f, 0.03647473f, 0.00925803f, 
    -0.05550057f, 0.02313315f, -0.04171890f, -0.00310707f, 0.00062412f, -0.03869469f, 0.03209965f, 0.04420726f, 
    0.00048518f, 0.03549857f, 0.04243699f, 0.04382903f, -0.02527924f, 0.02081425f, -0.02344385f, -0.00499265f, 
    -0.01485959f, 0.02760760f, 0.04083311f, -0.00592932f, -0.04824029f, -0.05102506f, -0.01073519f, -0.01007142f, 
    -0.05226449f, -0.01432747f, 0.00801509f, 0.02038057f, -0.03382573f, -0.03652073f, 0.05045369f, -0.04534449f, 
    0.00455068f, -0.06226327f, -0.01151910f, 0.04114203f, -0.06459168f, -0.06217396f, -0.00704019f, -0.06160942f, 
    0.00406139f, -0.05259386f, 0.00602083f, 0.01626890f, -0.02184132f, -0.00181550f, -0.04588037f, -0.05821186f, 
    0.01535322f, 0.00863690f, 0.00506775f, -0.04419874f, 0.03582648f, -0.03744961f, -0.05353275f, -0.03430909f, 
    0.04657825f, 0.04075743f, -0.04678588f, 0.00149986f, 0.03713250f, 0.02221021f, -0.05290414f, -0.03211590f, 
    -0.28805834f, -0.36087552f, -0.02457736f, -0.22575989f, 0.09098509f, -0.15668397f, 0.10433820f, 0.06037913f, 
    0.12116549f, -0.24938267f, -0.18907063f, 0.13581648f, 0.06014861f, 0.02966164f, -0.16430613f, -0.18173867f, 
    0.18492277f, 0.03059365f, -0.15211651f, 0.14599603f, 0.00708202f, -0.01163762f, -0.07735454f, -0.10248839f, 
    0.09744079f, 0.10308349f, 0.22722395f, 0.52494305f, 0.04343447f, 0.14704624f, 0.04605538f, 0.00319564f, 
    -0.02942061f, 0.15275823f, 0.09387905f, 0.26961833f, 0.11371932f, -0.10518836f, 0.03729700f, 0.18152374f, 
    -0.02176499f, 0.10365864f, -0.15381354f, -0.02619856f, -0.01005976f, -0.18827842f, 0.11943860f, -0.00552475f, 
    -0.03514927f, -0.17289953f, 0.05679660f, -0.04791125f, 0.07468001f, 0.11119738f, 0.17534825f, -0.49144700f, 
    0.23659173f, 0.14831544f, 0.18475816f, 0.05236320f, 0.02377912f, -0.00276113f, 0.06275833f, -0.28744179f, 
    -0.42857185f, -0.12242912f, -0.08485330f, 0.20028897f, 0.06353301f, -0.06719059f, 0.05689673f, -0.03893320f, 
    0.14057453f, 0.09196279f, -0.37749508f, 0.17709100f, -0.10284706f, 0.13079172f, -0.00350226f, 0.11972489f, 
    -0.03359688f, 0.55111265f, 0.14415707f, -0.24728072f, 0.03981386f, -0.13237582f, 0.11154769f, 0.18303710f, 
    0.17716886f, 0.07130804f, -0.17667274f, 0.36118972f, -0.25888652f, -0.09564357f, -0.06386096f, 0.01381534f, 
    0.03311789f, 0.07179433f, -0.19402765f, -0.16595194f, 0.03855502f, -0.08136778f, 0.16311115f, -0.17650609f, 
    -0.18384236f, -0.10350099f, 0.07926107f, -0.03141098f, -0.12900387f, -0.03268467f, -0.02834178f, 0.09111626f, 
    0.20019321f, 0.15753271f, 0.20663062f, -0.04448931f, -0.11348484f, -0.32941344f, -0.15800969f, 0.07394283f, 
    0.04939655f, -0.03447479f, 0.15132569f, 0.13389270f, 0.01956117f, 0.07474466f, -0.20913669f, -0.01125441f, 
    -0.03248188f, 0.00928576f, -0.22631627f, 0.01466208f, 0.13420181f, 0.26621178f, -0.03376258f, 0.02915461f, 
    0.36067474f, -0.06078180f, 0.12455083f, 0.17182136f, 0.15537636f, -0.00098091f, 0.06482699f, -0.05569995f, 
    0.14255081f, -0.12036653f, 0.07518148f, -0.01055743f, 0.13829055f, -0.19169319f, -0.04080623f, 0.01464729f, 
    0.09828502f, 0.23863998f, -0.23795420f, -0.06092145f, 0.02616186f, -0.06293255f, 0.17272595f, 0.06416940f, 
    -0.02695188f, 0.14527656f, -0.12644581f, 0.17107055f, -0.06559262f, 0.02547319f, 0.17670651f, 0.02870816f, 
    0.15898584f, 0.01015919f, 0.10164794f, -0.47590703f, 0.21526809f, 0.09243811f, -0.12929307f, 0.08369407f, 
    0.16322683f, -0.24834573f, 0.09318483f, -0.02958145f, 0.52717716f, -0.05363463f, -0.03669107f, 0.03382896f, 
    0.03137665f, 0.11001371f, 0.18487191f, 0.30670041f, 0.02904643f, 0.37930688f, 0.13397473f, 0.01694728f, 
    0.10490601f, 0.04614379f, 0.10148472f, 0.11501205f, 0.15079832f, 0.29754752f, 0.04946049f, -0.22899848f, 
    -0.01562488f, 0.11972982f, -0.00375572f, 0.02038503f, 0.11652038f, 0.04158539f, 0.05564363f, -0.12620988f, 
    0.20359409f, -0.10612207f, 0.03274912f, -0.17511469f, -0.05927930f, 0.02423630f, 0.10266373f, 0.16490160f, 
    0.19087622f, -0.03867445f, -0.16356423f, -0.04456009f, -0.00973276f, -0.00316968f, -0.01553006f, 0.10368232f, 
    0.16697718f, -0.86131924f, -0.32653081f, -0.10505240f, 0.15528257f, 0.27472061f, 0.19679596f, -0.04034404f, 
    -0.09587689f, 0.07705875f, -0.03392195f, 0.05167852f, -0.23480372f, -0.28985962f, 0.00864956f, -0.07337763f, 
    -0.14946161f, 0.05926782f, 0.13056736f, -0.06643812f, -0.15614477f, -0.00183852f, -0.00665119f, 0.18003681f, 
    0.19446839f, -0.00284218f, 0.29673746f, -0.14128222f, 0.10140308f, 0.15319940f, -0.15378243f, 0.15158339f, 
    -0.03489738f, -0.14971203f, 0.05454934f, -0.06324956f, -0.06227070f, -0.03618635f, 0.04116130f, -0.02531408f, 
    0.00971487f, -0.16458230f, 0.06309077f, 0.08204232f, -0.01207342f, -0.14637341f, 0.02134426f, -0.02213397f, 
    -0.18839772f, -0.00671700f, 0.02729925f, 0.14922254f, -0.02174899f, -0.08188414f, -0.01924873f, 0.73158711f, 
    0.26046801f, -0.22976647f, 0.01602971f, 0.00524681f, -0.22036485f, 0.12328199f, 0.09834407f, 0.19578695f, 
    -0.02852876f, -0.01819604f, -0.00812776f, 0.00341512f, -0.01201615f, -0.05166085f, -0.04126557f, 0.00510360f, 
    -0.00327057f, -0.00964554f, 0.01831345f, -0.03889675f, 0.02406182f, 0.03163051f, -0.01813463f, 0.02612264f, 
    0.02384554f, -0.05790444f, -0.05603175f, -0.04730143f, 0.04717636f, -0.03091635f, 0.00509639f, 0.03580296f, 
    0.03004945f, 0.02025382f, -0.03042437f, -0.04478909f, 0.02182467f, 0.02683625f, 0.00189990f, 0.03943724f, 
    -0.04983446f, -0.04631151f, -0.06201354f, -0.03943414f, 0.01966948f, -0.04806378f, -0.05482267f, -0.04428402f, 
    -0.00567514f, -0.06435476f, -0.06700331f, 0.02902923f, -0.05318576f, 0.03936799f, -0.03750548f, 0.01555587f, 
    -0.02896431f, -0.00372014f, 0.00362016f, -0.06452420f, 0.03368570f, 0.01082298f, -0.00136987f, 0.02296926f, 
    -0.06374355f, -0.00532708f, 0.00822928f, 0.04817903f, -0.05427733f, -0.04422334f, 0.00423102f, -0.04475836f, 
    -0.00397202f, -0.04403206f, -0.06243754f, -0.03796830f, -0.03943068f, -0.04361190f, -0.04625809f, 0.04552382f, 
    -0.02833994f, 0.02212163f, -0.05369502f, -0.00204037f, -0.06470769f, -0.05992891f, -0.04184164f, 0.01934997f, 
    0.02474506f, 0.03442105f, 0.00830762f, 0.04400406f, -0.00136884f, 0.03966140f, -0.01901412f, -0.02919035f, 
    -0.06858548f, -0.04129054f, 0.00588863f, 0.03126397f, -0.03868287f, -0.01456844f, 0.03774718f, 0.00478711f, 
    -0.02943460f, -0.04814447f, -0.01691110f, -0.03168951f, -0.04068438f, -0.06361397f, -0.01723274f, -0.03224857f, 
    -0.06491757f, -0.06539981f, 0.04188063f, -0.03111193f, 0.01975052f, 0.00875096f, -0.02103944f, -0.03192333f, 
    -0.05533372f, 0.03276937f, 0.03678192f, -0.05191377f, 0.01074268f, -0.01533911f, -0.00595183f, -0.04289063f, 
    -0.04105260f, -0.01418197f, 0.02530277f, -0.01137519f, -0.04037118f, -0.01677009f, 0.02783680f, -0.01547874f, 
    0.01275494f, 0.04289956f, 0.04250456f, -0.00767275f, -0.02568487f, 0.04393484f, 0.00317299f, -0.01641132f, 
    -0.05347876f, 0.03205037f, -0.00110607f, 0.02733070f, 0.04573556f, -0.01199227f, -0.06428138f, 0.02530360f, 
    0.02088898f, -0.03551210f, 0.02064052f, 0.01995358f, 0.04912192f, 0.04386640f, -0.06252117f, 0.01740621f, 
    -0.05637390f, -0.00584686f, 0.01155766f, -0.03085337f, -0.01647250f, -0.04964152f, -0.02315604f, 0.03432990f, 
    -0.02247559f, -0.00535691f, -0.00094508f, 0.00312305f, 0.04646024f, 0.04824588f, -0.04349186f, -0.06843803f, 
    0.02156009f, 0.02310400f, 0.03873763f, -0.06445605f, 0.02034704f, 0.03754236f, 0.02673514f, -0.00668979f, 
    0.03184849f, 0.00301593f, 0.02588960f, -0.04343662f, -0.00451703f, 0.01690040f, -0.00925010f, -0.04744321f, 
    0.03697197f, -0.03214508f, -0.02353823f, 0.04173553f, -0.06180583f, -0.03432647f, 0.02162511f, 0.00136157f, 
    -0.05917410f, 0.02738373f, -0.01993273f, -0.03623427f, -0.00033010f, 0.00192572f, -0.06468912f, -0.04079762f, 
    -0.04986807f, 0.03959314f, -0.04519896f, -0.01358199f, -0.03763561f, -0.01984785f, 0.00160078f, -0.01005224f, 
    -0.01400398f, -0.00158701f, -0.04378478f, 0.01222893f, 0.01745738f, 0.01181173f, -0.05233329f, 0.02323198f, 
    -0.06318140f, -0.03130859f, 0.03878390f, -0.04554650f, -0.04687590f, 0.03837901f, -0.06876506f, 0.01317197f, 
    0.04142072f, 0.04418938f, 0.00673362f, -0.02407299f, 0.03818467f, 0.04716854f, -0.04943042f, -0.01376512f, 
    0.04245656f, 0.03074015f, -0.04580944f, 0.01623648f, 0.01340114f, 0.01022884f, -0.04770466f, 0.03026067f, 
    -0.05583665f, -0.02599388f, 0.00812897f, -0.02774254f, 0.02264754f, -0.03414145f, 0.01808244f, -0.04698701f, 
    0.02194895f, -0.02460856f, -0.02645309f, -0.03633151f, -0.03060651f, 0.01975365f, -0.01213887f, -0.06503036f, 
    -0.01707949f, 0.03058833f, -0.02798526f, 0.04721101f, -0.02321008f, -0.01612581f, 0.05123933f, 0.01824362f, 
    -0.00409879f, 0.00799953f, -0.04986725f, -0.05568822f, -0.00281105f, 0.04455712f, -0.03254433f, -0.04616271f, 
    0.03164740f, 0.01909400f, -0.05237193f, 0.02112806f, 0.01868140f, 0.01072372f, -0.02419917f, -0.03359435f, 
    0.02753641f, -0.05445636f, -0.02612173f, -0.04367519f, 0.00560081f, 0.00919106f, -0.01861553f, -0.03965005f, 
    0.23428610f, -0.11625091f, -0.20527416f, -0.05891111f, -0.02830629f, 0.10781590f, -0.04623055f, -0.00347236f, 
    0.25218436f, -0.73595548f, -0.21847501f, 0.03470128f, 0.02966964f, -0.08959004f, -0.11513780f, 0.14780724f, 
    -0.14094526f, 0.11885431f, 0.00300358f, -0.17790937f, 0.10175062f, -0.03374410f, 0.02754551f, 0.01275344f, 
    0.00776541f, -0.00751883f, -0.05595602f, -0.09857881f, 0.03032402f, 0.12213873f, 0.06900796f, 0.16904196f, 
    -0.35716850f, 0.14821853f, 0.09688664f, 0.12383992f, -0.20935668f, -0.13139090f, -0.11922634f, -0.03424157f, 
    0.10601547f, 0.06477696f, 0.26327389f, 0.19881117f, -0.00998294f, -0.11676601f, -0.24387164f, 0.08904865f, 
    -0.02020875f, 0.17017081f, -0.03362289f, 0.06730304f, -0.00923456f, -0.09325867f, -0.09366083f, 0.21860336f, 
    0.03420652f, 0.07118168f, -0.17153627f, 0.00540811f, 0.01894778f, -0.02922022f, 0.06879444f, -0.33203709f, 
    -0.04404465f, -0.36365899f, 0.13771392f, -0.10185673f, 0.06295788f, 0.13840537f, -0.00322545f, 0.04538000f, 
    -0.18767831f, -0.23164006f, -0.03469363f, -0.06031394f, 0.15650010f, -0.06390599f, -0.06495576f, 0.14416486f, 
    0.22461636f, 0.24482736f, 0.18576130f, -0.23581198f, 0.04963964f, -0.09560046f, 0.03181945f, -0.00262262f, 
    -0.08210593f, -0.12960228f, -0.02288601f, -0.06316125f, -0.21562426f, 0.04419511f, 0.10393216f, 0.11613429f, 
    0.02307948f, 0.13762443f, 0.04092856f, 0.62615448f, 0.00450433f, 0.04481402f, 0.11232153f, 0.03775544f, 
    0.01531162f, -0.04531230f, 0.11730454f, -0.09323660f, 0.19103467f, 0.03318972f, -0.14512765f, -0.02550870f, 
    0.02687294f, 0.07193173f, -0.15939216f, 0.01367402f, 0.11007103f, 0.17260343f, 0.13059008f, 0.13420925f, 
    0.00011439f, 0.12692942f, 0.11683404f, 0.02291078f, -0.01227376f, 0.08185648f, 0.31152871f, 0.06655313f, 
    0.09036051f, 0.03672425f, 0.06209482f, 0.05630035f, 0.02725841f, 0.08007784f, 0.02517595f, 0.03009314f, 
    0.02628389f, -0.03435642f, -0.00938705f, 0.05519478f, 0.28725219f, -0.00762877f, -0.07782758f, 0.12191992f, 
    -0.47451970f, -0.22678900f, -0.05765256f, -0.08567668f, 0.01301713f, -0.04587021f, -0.07313211f, -0.06353342f, 
    -0.08850759f, 0.15027921f, 0.21109718f, -0.28069803f, -0.03164872f, -0.03933224f, 0.11254117f, -0.08969821f, 
    0.10390890f, 0.09837532f, 0.16343574f, -0.19647634f, 0.03847694f, -0.13667350f, -0.16077317f, 0.12922521f, 
    -0.09747692f, 0.09131406f, 0.05463797f, -0.38201085f, -0.45506027f, -0.08429818f, 0.02740332f, 0.12716015f, 
    -0.13168383f, -0.03504391f, 0.06300087f, -0.13431360f, 0.16912188f, 0.17938270f, -0.02184839f, -0.05430853f, 
    -0.00677428f, -0.10922071f, 0.07466332f, 0.18375351f, 0.11930309f, -0.09739766f, 0.03255260f, 0.08837711f, 
    -0.00666366f, 0.06253874f, -0.07907166f, 0.02576987f, -0.05520230f, -0.01349480f, -0.10714428f, -0.18116397f, 
    -0.19812527f, 0.03067478f, 0.00415609f, -0.11993746f, -0.14709125f, 0.21713704f, 0.06423316f, 0.49897254f, 
    0.11618005f, 0.10453857f, 0.01713578f, 0.06829639f, 0.28992406f, 0.10769264f, 0.00890626f, 0.00420926f, 
    -0.11259246f, -0.00884495f, -0.00595728f, 0.03591943f, 0.12477551f, 0.08980336f, -0.08099880f, -0.12289658f, 
    -0.07150360f, 0.07836801f, -0.03994235f, 0.02312869f, 0.06610979f, -0.03193317f, -0.08309214f, -0.02062527f, 
    0.08826520f, 0.08989465f, 0.03510958f, 0.11844605f, -0.01185079f, 0.10684083f, -0.21622373f, -0.11740952f, 
    -0.09422953f, 0.08346511f, 0.04112667f, -0.17432757f, -0.12546530f, 0.03967589f, 0.04441204f, -0.11782072f, 
    0.10858086f, 0.00639468f, -0.06640953f, 0.17517391f, 0.35710075f, 0.08068651f, 0.00019775f, -0.00707179f, 
    -0.05070299f, -0.07282354f, -0.19977413f, 0.26186106f, -0.13852938f, -0.06952708f, -0.11131966f, 0.18036970f, 
    0.02111443f, -0.08999504f, 0.10635089f, -0.01138975f, -0.07198671f, -0.13048328f, 0.00259192f, 0.16137451f, 
    0.01367960f, 0.02144898f, 0.00910902f, -0.14436582f, 0.02724059f, -0.02410232f, 0.08318581f, -0.05310912f, 
    -0.05040791f, -0.09454616f, 0.01427690f, -0.22203860f, 0.11783490f, -0.06380374f, -0.11454211f, -0.12226337f, 
    -0.24386768f, 0.02136361f, -0.12572394f, 0.09888631f, -0.00859526f, 0.16836333f, -0.21215656f, 0.07855456f, 
    0.17571543f, 0.04878662f, -0.32612556f, -0.12742576f, -0.01468556f, 0.00312662f, -0.05418650f, 0.04805488f, 
    -0.00885144f, -0.14105101f, 0.23236524f, -0.25276762f, -0.05179355f, 0.20741740f, -0.08148606f, 0.21301857f, 
    0.10677502f, -0.18107763f, 0.01613150f, 0.16001225f, 0.27169514f, 0.21549045f, -0.20267756f, -0.11132155f, 
    -0.02957502f, 0.18266644f, 0.05512812f, -0.10080392f, 0.05831749f, -0.12585874f, -0.03833421f, 0.10342199f, 
    -0.13918151f, 0.04944973f, 0.18650240f, -0.01254044f, 0.00774017f, 0.26140589f, -0.17280537f, -0.02255398f, 
    -0.05595966f, 0.10141709f, 0.17500599f, -0.01559168f, -0.23978737f, -0.13307291f, -0.14718141f, -0.15527748f, 
    0.19558057f, 0.14436121f, 0.11660888f, -0.07011004f, -0.14093013f, 0.01404449f, 0.03078604f, -0.11151712f, 
    0.07180987f, -0.01161543f, 0.15647124f, 0.15542085f, -0.00196374f, 0.15211970f, -0.09869877f, -0.12688297f, 
    0.13859683f, -0.20420453f, -0.04069829f, -0.01446514f, 0.06754799f, 0.20751695f, -0.07997955f, 0.02773785f, 
    0.02255332f, 0.17985612f, 0.07081676f, 0.01678380f, -0.04652629f, 0.05308176f, 0.03644175f, -0.09843170f, 
    -0.07242312f, -0.03707725f, -0.00305615f, 0.11826305f, -0.00067931f, 0.03053655f, -0.05574295f, 0.11800596f, 
    0.14698277f, -0.15189180f, -0.09143332f, 0.22184284f, -0.14087947f, -0.23106699f, -0.09708183f, 0.10486589f, 
    0.10973144f, 0.23022330f, -0.05024396f, -0.04639938f, -0.11935039f, -0.10069836f, -0.17116940f, -0.10656811f, 
    0.07769201f, -0.11528260f, -0.08277854f, 0.03230688f, -0.08959027f, -0.24993910f, 0.23593006f, -0.00467715f, 
    0.08889567f, 0.08777364f, 0.05455317f, 0.09545733f, 0.00139067f, -0.16789733f, 0.01181595f, 0.02826885f, 
    0.01992432f, 0.07452749f, 0.05707293f, -0.11572435f, -0.06913088f, 0.17923786f, -0.12254481f, 0.20177621f, 
    0.03275529f, 0.02162003f, -0.07486784f, -0.20400362f, -0.14035504f, -0.07828987f, 0.08308877f, -0.00059484f, 
    -0.00797037f, -0.10596216f, -0.00425973f, -0.05414306f, 0.06168457f, -0.00998183f, -0.08743428f, 0.09262029f, 
    -0.02116565f, -0.06370907f, -0.13776755f, 0.05425961f, -0.10804939f, -0.07729310f, 0.24678187f, -0.04548992f, 
    -0.01869936f, 0.00131135f, 0.32560748f, 0.09739906f, -0.06571942f, -0.01114891f, 0.05300215f, 0.07503008f, 
    -0.15802863f, -0.20086448f, 0.01512537f, -0.02313968f, -0.12643747f, -0.14453614f, -0.02117217f, 0.02697782f, 
    0.24954690f, -0.18308055f, -0.03603783f, -0.19862403f, 0.21254058f, 0.06800301f, 0.22438852f, -0.23447923f, 
    -0.12737051f, -0.08148997f, 0.12488035f, 0.02535761f, -0.08109059f, 0.05388766f, 0.17854752f, 0.22232620f, 
    -0.18645896f, 0.01395745f, -0.09074222f, 0.04813416f, 0.04757350f, -0.06449509f, -0.07223690f, 0.18070795f, 
    0.20003039f, 0.03994799f, -0.25509292f, 0.11341397f, 0.04171062f, -0.09777556f, 0.08902200f, 0.04390263f, 
    0.04577509f, -0.19024797f, 0.01855936f, -0.00691324f, -0.04888553f, -0.05661749f, 0.06904302f, -0.02457442f, 
    0.24190931f, 0.12534314f, -0.18303871f, 0.23448411f, 0.12535289f, -0.03683667f, -0.12874967f, -0.00492519f, 
    0.02062037f, 0.10154106f, -0.07624578f, 0.20085183f, 0.13389507f, -0.03797378f, 0.06265364f, 0.21979296f, 
    -0.03936960f, -0.08169671f, 0.07614317f, 0.18709686f, -0.04506407f, 0.01414366f, -0.02716262f, 0.15117607f, 
    -0.19833700f, -0.01774833f, 0.23081426f, 0.00626611f, 0.02434947f, 0.00888582f, 0.09583901f, -0.09650651f, 
    0.13240407f, 0.01221595f, 0.02218765f, -0.13233003f, -0.02876397f, 0.01488424f, -0.08683974f, 0.19378203f, 
    -0.04994401f, -0.09949487f, -0.02443514f, -0.11949204f, 0.14419830f, -0.11715338f, 0.00340224f, -0.10013629f, 
    0.02815251f, 0.18977518f, 0.17214300f, -0.01545867f, 0.08982255f, 0.00620564f, -0.11466644f, -0.17832817f, 
    0.03495517f, 0.06449418f, 0.00944465f, 0.10758337f, -0.00490864f, -0.01799011f, -0.11901558f, 0.16802184f, 
    0.24925199f, -0.04797910f, -0.15938509f, 0.08856440f, -0.03000442f, 0.05569015f, 0.09170470f, 0.02142980f, 
    -0.13773693f, -0.29478577f, 0.02374512f, 0.01080266f, -0.02899600f, -0.19822375f, -0.07616421f, 0.10386266f, 
    0.03393311f, 0.57855284f, -0.09173667f, 0.25171933f, -0.01189207f, 0.04134446f, 0.08202597f, -0.10142883f, 
    -0.14216708f, 0.03806100f, 0.05669926f, 0.38802189f, -0.39537424f, 0.00662428f, 0.03152229f, 0.08057891f, 
    0.09657044f, 0.04798109f, -0.01139970f, 0.07298692f, 0.19323003f, 0.01872129f, 0.01679398f, -0.07471063f, 
    -0.00174393f, -0.04214883f, 0.02033324f, -0.16482152f, -0.04441426f, 0.06466644f, 0.20223977f, -0.04288063f, 
    -0.05234976f, -0.02997905f, -0.04434032f, -0.13423872f, -0.06195558f, -0.66423738f, 0.47679067f, -0.31328952f, 
    -0.07268031f, 0.11680467f, -0.03551166f, -0.03092816f, 0.04474685f, 0.02368503f, 0.28778717f, -0.07720301f, 
    -0.14671731f, 0.04057333f, 0.13744228f, 0.13173909f, 0.01127911f, 0.09408092f, -0.01495117f, 0.20199125f, 
    0.01440859f, 0.14206699f, 0.09579764f, 0.01574927f, -0.01635082f, 0.08633067f, 0.00187886f, 0.04736198f, 
    -0.37228632f, -0.21828963f, -0.01561949f, -0.09639648f, 0.12785868f, 0.10828727f, -0.22098435f, 0.12417394f, 
    -0.00872677f, 0.13061932f, 0.30020726f, 0.12651101f, -0.12388200f, -0.14612909f, -0.06971142f, -0.12552744f, 
    -0.01290627f, 0.11997158f, -0.13317697f, -0.20268999f, -0.07469556f, -0.04313509f, -0.07401358f, -0.04701229f, 
    0.01617295f, 0.05926491f, 0.22764704f, 0.07706230f, -0.42423147f, 0.11603518f, -0.04198861f, -0.02561998f, 
    -0.07783262f, 0.10059460f, 0.10160495f, -0.03104436f, 0.15188310f, 0.04979812f, 0.10946255f, 0.01207418f, 
    0.10462426f, 0.09312332f, -0.07360245f, 0.10155018f, -0.08116461f, -0.44844815f, 0.00209846f, -0.28946304f, 
    0.25202003f, 0.09115189f, 0.04928610f, -0.17780945f, -0.02686801f, 0.04527790f, -0.11610300f, -0.18914682f, 
    -0.33622110f, -0.04842097f, -0.07648265f, -0.07824164f, 0.18190187f, 0.05677127f, -0.11003767f, -0.17543098f, 
    -0.24686988f, 0.05237179f, -0.10279407f, 0.09237179f, 0.05647037f, -0.09116644f, -0.14312676f, -0.13667186f, 
    0.36825687f, 0.01377953f, 0.11242645f, -0.03782401f, 0.03649583f, 0.01860141f, 0.10080562f, 0.17307359f, 
    -0.11043764f, -0.27869770f, -0.08884883f, 0.18224654f, 0.08577691f, -0.03092820f, -0.11503098f, -0.08606526f, 
    0.06895813f, -0.06679447f, -0.20760936f, 0.13328303f, -0.38844061f, 0.03579014f, 0.14470917f, -0.03215683f, 
    0.04878338f, 0.25890058f, 0.05098914f, 0.42666876f, 0.58306050f, 0.02083137f, 0.09153125f, 0.08807065f, 
    0.05602210f, -0.03790825f, -0.13766730f, -0.11973841f, 0.17390358f, 0.13639949f, 0.03598120f, 0.13875817f, 
    0.14376561f, 0.09545910f, 0.10796966f, -0.00007483f, -0.16542955f, 0.16657755f, 0.15075234f, -0.06952067f, 
    0.15118374f, -0.08184228f, 0.16665553f, 0.16913475f, -0.07178446f, 0.01988864f, -0.09647644f, 0.12529351f, 
    0.18337193f, 0.01347195f, -0.03794449f, -0.06050731f, 0.04443850f, 0.02729164f, 0.07090365f, 0.36312971f, 
    -0.46883839f, 0.10542317f, -0.16087872f, -0.14297588f, -0.17396250f, -0.02691366f, -0.01399040f, 0.19796640f, 
    -0.23699148f, -0.01209409f, 0.06238296f, 0.01547366f, -0.00579336f, -0.17566782f, 0.09846772f, 0.08688886f, 
    -0.09233894f, 0.10100591f, 0.19602333f, 0.02529195f, 0.02725935f, -0.02584480f, 0.00017917f, 0.28077966f, 
    -0.00680937f, -0.00752990f, -0.52229935f, 0.11684719f, -0.13667165f, -0.22583130f, 0.22795573f, 0.00734409f, 
    0.04241705f, -0.03416722f, -0.02839594f, 0.04417189f, 0.08895671f, -0.15576132f, 0.15958512f, 0.21446754f, 
    0.00468399f, 0.02878428f, -0.07198853f, 0.11337893f, 0.03767464f, -0.43097889f, 0.06963725f, -0.05674937f, 
    0.02573529f, 0.00452122f, 0.03417720f, 0.01851652f, 0.09185421f, -0.35407764f, -0.16207810f, -0.18584970f, 
    -0.12282988f, -0.14565605f, 0.12690784f, 0.11753250f, 0.20802991f, 0.02150791f, 0.43350902f, 0.06929017f, 
    -0.66434938f, 0.12324746f, -0.02866650f, 0.10816389f, 0.00418050f, 0.08014940f, 0.01207763f, 0.17540023f, 
    0.06145510f, -0.03560824f, 0.07797695f, 0.03317308f, -0.06962682f, 0.09848865f, 0.15075219f, -0.01220183f, 
    -0.03472504f, 0.04206310f, 0.03836043f, -0.03281923f, 0.03257110f, -0.00627114f, -0.00418220f, 0.03577481f, 
    0.00701060f, 0.03594530f, -0.00677947f, 0.03196471f, -0.02424285f, -0.00515282f, 0.03140072f, -0.00737171f, 
    -0.03208585f, -0.00604393f, -0.03881923f, 0.00439135f, -0.05379932f, 0.02039168f, -0.03666087f, -0.03111555f, 
    0.02938053f, 0.01674280f, -0.00961163f, 0.02532512f, 0.00163756f, -0.01408974f, 0.02788927f, -0.05328364f, 
    -0.03523859f, 0.05011827f, -0.04928286f, 0.05196863f, -0.02345579f, -0.02466226f, -0.00456244f, 0.03721856f, 
    -0.04927008f, 0.02705805f, -0.02454397f, -0.02368044f, 0.03333625f, -0.01985804f, 0.04545626f, 0.02313221f, 
    -0.02749621f, 0.00843994f, 0.05446775f, -0.01674175f, 0.01965860f, -0.05165423f, 0.02518650f, 0.00864366f, 
    0.04298124f, 0.01514592f, 0.03779775f, 0.00388718f, -0.01787785f, -0.03335361f, -0.06341211f, -0.05749844f, 
    -0.01170752f, -0.05655310f, -0.03950210f, -0.01437342f, 0.02714032f, -0.02692507f, -0.02880825f, -0.02706173f, 
    -0.00382155f, 0.03217321f, -0.03166258f, -0.01985136f, 0.05366717f, -0.05755689f, -0.05132915f, 0.00352371f, 
    0.00872620f, -0.05310798f, -0.02237068f, -0.04103595f, -0.00628720f, -0.01100132f, 0.04668607f, -0.00744935f, 
    -0.06679957f, 0.03157609f, -0.04467274f, -0.03248592f, 0.02374125f, -0.04890743f, 0.04426655f, -0.04020667f, 
    -0.01961630f, -0.00096399f, 0.02887050f, -0.02670871f, 0.03314772f, -0.03551189f, -0.01036929f, -0.03870350f, 
    0.03117545f, 0.04608116f, -0.03568372f, 0.04021519f, -0.05276470f, 0.00134565f, -0.06434870f, -0.02781849f, 
    -0.05335952f, 0.05483200f, 0.05411229f, -0.05189737f, 0.05091630f, -0.00766495f, -0.02536732f, -0.03044071f, 
    0.01010214f, 0.05072908f, -0.00238163f, -0.02103341f, -0.01385534f, -0.06359485f, -0.05061822f, 0.04983799f, 
    0.04341262f, 0.01609117f, -0.05640574f, -0.00895870f, -0.06192101f, -0.03788137f, 0.00245043f, -0.04963565f, 
    0.04573072f, 0.04285824f, 0.01250493f, 0.00182579f, -0.04801174f, -0.02676885f, -0.03847745f, -0.01342704f, 
    0.03393002f, -0.00951087f, -0.05053725f, 0.00726308f, -0.05960786f, 0.03588526f, 0.05206022f, -0.05608809f, 
    0.04748174f, -0.06312716f, 0.03062529f, -0.05041717f, 0.04928014f, 0.01226329f, -0.00055755f, -0.03500170f, 
    0.00574910f, -0.05280932f, -0.03396403f, 0.04381843f, 0.01279711f, 0.00290169f, -0.06106172f, 0.04455535f, 
    -0.01410036f, 0.00498206f, 0.02566483f, -0.00647423f, -0.03479320f, 0.02898682f, 0.03268475f, -0.06003811f, 
    0.05351476f, -0.03095473f, -0.02867809f, -0.06279582f, -0.03443615f, 0.01292922f, -0.05592541f, -0.00649293f, 
    0.03295041f, 0.04320054f, 0.01758575f, -0.01203914f, -0.03916097f, 0.03275310f, 0.02802915f, -0.01395314f, 
    -0.05008859f, -0.04749272f, 0.00717460f, 0.03133128f, -0.02772696f, -0.03356350f, 0.03525275f, 0.00628886f, 
    -0.02801698f, 0.04542716f, -0.03720706f, -0.03600996f, 0.05219659f, -0.01503100f, -0.04238611f, 0.05171057f, 
    0.00358769f, -0.05531420f, 0.00458867f, 0.04071593f, 0.01102177f, 0.00183508f, -0.01928514f, -0.03244251f, 
    -0.03869756f, 0.01043826f, 0.00182008f, -0.02498610f, -0.02236947f, 0.04907509f, 0.02012720f, 0.03192457f, 
    -0.05170755f, -0.02587353f, -0.00118963f, -0.04506644f, 0.01191171f, 0.04817639f, 0.03319781f, -0.06174619f, 
    0.04504806f, -0.00226282f, 0.05332409f, 0.04033368f, 0.02754885f, 0.05298125f, 0.00500452f, 0.04021071f, 
    0.03520500f, -0.05341425f, 0.01839318f, 0.05181441f, -0.05903368f, -0.05823688f, -0.04889196f, -0.05858006f, 
    -0.04063910f, 0.02652874f, 0.04665644f, 0.03809214f, -0.05290301f, 0.00022200f, -0.02469867f, 0.05367789f, 
    -0.00344297f, -0.02958316f, 0.02673014f, -0.02458079f, 0.04739409f, -0.03389883f, 0.05682990f, -0.03233710f, 
    -0.03058884f, -0.01280188f, 0.00988667f, -0.02122071f, 0.04958490f, 0.04821051f, -0.00311497f, 0.03105222f, 
    -0.03347124f, 0.00943588f, -0.04961560f, -0.03002648f, 0.01175801f, -0.06030208f, -0.05264428f, 0.05233062f, 
    -0.05328475f, -0.06037170f, -0.00945820f, -0.01461659f, 0.04426725f, 0.00258567f, -0.05199843f, 0.03889298f, 
    -0.02703636f, 0.02530287f, 0.05854495f, -0.04169251f, -0.00635459f, -0.05969341f, 0.00712358f, 0.01025862f, 
    0.01502265f, 0.02093524f, -0.02485401f, 0.02330798f, 0.02562601f, 0.00392605f, 0.04306297f, -0.01258179f, 
    -0.01577211f, -0.05212987f, 0.05868992f, -0.03003522f, 0.00178982f, 0.01212186f, -0.00140373f, -0.01879999f, 
    -0.03863487f, -0.00708481f, -0.04470600f, -0.06131908f, -0.00185950f, 0.00718405f, -0.01109345f, -0.00942663f, 
    0.02063536f, 0.03167964f, -0.01948231f, -0.01280421f, -0.02290603f, 0.04659725f, 0.04152035f, -0.03320919f, 
    -0.06126964f, 0.00128874f, 0.03363976f, -0.04729481f, 0.03611148f, 0.03878526f, 0.00541065f, -0.02681290f, 
    0.05092973f, -0.05930695f, 0.03292831f, -0.03210328f, 0.01891109f, 0.05668019f, -0.06319471f, -0.04417558f, 
    -0.06052856f, -0.01055478f, 0.00819476f, 0.03583219f, -0.02499579f, 0.02506090f, 0.03924972f, -0.00668405f, 
    -0.01347878f, 0.02131235f, -0.05756149f, 0.01857921f, 0.00288324f, 0.04888177f, 0.02685834f, 0.03742034f, 
    0.02719187f, -0.03196459f, -0.03952304f, 0.04970207f, -0.03622720f, 0.03025528f, 0.01152834f, -0.01828624f, 
    0.00318258f, -0.04005049f, -0.01574492f, -0.00444388f, 0.00061720f, -0.04596682f, -0.00102758f, -0.03563732f, 
    -0.04393806f, 0.01254885f, 0.04499229f, -0.01397751f, 0.04914160f, -0.04062365f, -0.04261663f, -0.04218702f, 
    -0.04413989f, 0.03141328f, 0.04837918f, 0.00723522f, -0.02740064f, -0.05103876f, -0.03348820f, -0.01949770f, 
    0.01636937f, 0.03209678f, -0.03772944f, -0.02573535f, -0.02923986f, 0.04276063f, -0.00486853f, -0.02049109f, 
    -0.04543981f, -0.00390095f, -0.03874713f, -0.01003724f, -0.05734913f, -0.03559169f, -0.02925804f, -0.03413461f, 
    0.04671263f, -0.04960231f, -0.00021132f, -0.01800210f, -0.06307611f, -0.01945901f, -0.03936398f, -0.04972003f, 
    0.01572706f, 0.01989962f, -0.01778201f, 0.03606572f, -0.03177325f, 0.03318504f, 0.02620123f, 0.04649283f, 
    0.00175534f, 0.01283260f, 0.02954185f, -0.01834137f, 0.04526182f, 0.04975465f, -0.00044537f, -0.05973666f, 
    -0.05494269f, 0.03441935f, 0.04653186f, -0.02198381f, -0.03014156f, -0.05892080f, -0.03897688f, -0.06440073f, 
    0.03317478f, -0.00120273f, -0.02438846f, -0.01183756f, -0.04660549f, -0.03311983f, -0.06029648f, -0.00964472f, 
    0.02819936f, -0.05810120f, 0.02433978f, -0.03078131f, 0.01162142f, 0.03538841f, -0.02724164f, -0.00780446f, 
    -0.03211148f, -0.00126205f, -0.05332885f, -0.02678529f, -0.03315803f, -0.01501798f, 0.02005547f, 0.02410277f, 
    -0.03782239f, -0.04316594f, -0.02131314f, -0.02410729f, 0.03088934f, -0.01968772f, 0.00175408f, -0.02285337f, 
    -0.06371065f, -0.05190290f, -0.00236346f, -0.01646645f, -0.01112551f, -0.02810240f, -0.01482276f, 0.03582770f, 
    -0.05181729f, -0.02881641f, 0.03105732f, -0.05410659f, -0.04262174f, -0.03770406f, 0.05161102f, 0.03202520f, 
    -0.04904230f, -0.04618230f, -0.04449577f, -0.05866693f, -0.03951947f, -0.02699064f, 0.04534503f, -0.03987616f, 
    0.02728030f, -0.00678196f, 0.01767802f, -0.03553194f, 0.03416012f, 0.06481871f, 0.05167862f, 0.03487051f, 
    0.02804085f, 0.01755785f, 0.04790462f, -0.00645202f, -0.06587222f, -0.03905250f, -0.05831247f, 0.01363487f, 
    0.01026625f, 0.03579023f, -0.05914777f, 0.01046909f, -0.03568433f, 0.00503840f, -0.04067402f, 0.04821569f, 
    0.02343347f, 0.01448890f, 0.01821540f, -0.00403385f, -0.01885299f, -0.01353088f, 0.02784227f, -0.03896011f, 
    -0.03678356f, -0.04546389f, -0.03183889f, 0.04409075f, 0.02439565f, -0.01858493f, 0.04137532f, -0.02049062f, 
    0.03787529f, 0.00780085f, -0.03858309f, 0.03092588f, -0.05124945f, 0.05393785f, 0.01182686f, 0.03538210f, 
    -0.05302304f, 0.01621120f, -0.04194383f, -0.03529164f, -0.05691022f, -0.01043998f, -0.00373506f, -0.02870076f, 
    -0.05712654f, -0.06578542f, 0.01400786f, 0.03623944f, -0.02387187f, -0.04021578f, 0.00279840f, 0.06125845f, 
    -0.05929517f, -0.00095416f, 0.03112092f, 0.03859811f, 0.00798288f, -0.04639094f, -0.06592531f, 0.00282601f, 
    -0.06086930f, 0.00632019f, -0.02172378f, 0.00589290f, 0.04929945f, -0.04099932f, 0.00791063f, 0.01030004f, 
    -0.25291231f, -0.27592546f, -0.10108357f, -0.01328967f, -0.16258097f, -0.07383131f, 0.05746017f, -0.10830100f, 
    0.20284078f, 0.11913153f, -0.03132002f, 0.32224399f, -0.03562400f, 0.23203667f, 0.33313015f, 0.07740011f, 
    -0.01368212f, 0.01161894f, 0.26091892f, 0.22618718f, 0.35400558f, -0.02259443f, 0.09510265f, 0.01666934f, 
    -0.04999297f, 0.08824522f, -0.06305781f, -0.08418250f, -0.10749754f, 0.17664798f, 0.19172867f, 0.07746238f, 
    -0.09275759f, 0.02568696f, 0.00743307f, 0.11900185f, -0.29091379f, -0.06617874f, -0.28829503f, 0.08722673f, 
    -0.07753381f, 0.01150531f, 0.00720887f, 0.04141031f, -0.02316047f, -0.16670538f, 0.19306234f, 0.13790356f, 
    0.04874761f, -0.02206481f, 0.00670830f, -0.08617868f, 0.00697268f, 0.09914161f, 0.00218314f, 0.05588155f, 
    -0.43362993f, 0.14867112f, -0.11286613f, 0.02765317f, 0.04818085f, 0.03726527f, 0.08172785f, 0.15803798f, 
    -0.19437985f, 0.07968447f, 0.05112229f, -0.09578040f, -0.03284980f, 0.00200958f, -0.00120508f, -0.00034925f, 
    0.06367930f, 0.06087607f, 0.05169587f, 0.12368360f, 0.11783341f, -0.00008895f, 0.15263610f, -0.04603232f, 
    0.12179351f, -0.29130453f, -0.08075906f, -0.30328205f, 0.07605123f, 0.05406862f, -0.14812654f, 0.01643826f, 
    0.10722619f, -0.10277144f, -0.17558989f, -0.40487596f, -0.30077034f, 0.00164411f, 0.00147797f, 0.07899906f, 
    0.10084485f, -0.13696074f, 0.09987535f, -0.16427246f, 0.12910382f, 0.13718069f, -0.12448815f, 0.11614031f, 
    -0.03471779f, -0.07489094f, -0.10808824f, 0.08112457f, 0.35191059f, 0.02332002f, -0.24934009f, 0.00413680f, 
    -0.04238923f, 0.08268786f, 0.12975000f, -0.01716519f, 0.04597330f, 0.27342227f, -0.03480969f, 0.12051449f, 
    0.04900817f, -0.10528901f, 0.05428608f, 0.05036673f, 0.03237882f, -0.10208566f, -0.21207666f, 0.28807387f, 
    -0.03775156f, -0.06525479f, 0.03237158f, 0.17785044f, -0.00626538f, 0.02022469f, 0.08256721f, -0.36700401f, 
    0.09612204f, -0.23952100f, -0.02025327f, 0.01203540f, 0.01770101f, -0.15494424f, 0.03678227f, -0.18671620f, 
    -0.10826921f, -0.08951401f, -0.19781822f, 0.20824768f, 0.06446806f, 0.01469096f, -0.07833966f, -0.04845752f, 
    -0.02848102f, 0.08531895f, -0.31370905f, 0.00011763f, 0.08215033f, -0.05507219f, -0.02068798f, -0.00464770f, 
    -0.20366196f, 0.19233733f, 0.20038547f, 0.01980776f, 0.23465721f, -0.01883760f, 0.07673214f, -0.09033082f, 
    -0.04592744f, -0.04152731f, 0.06938664f, 0.11434671f, 0.07328527f, -0.14446130f, -0.07040025f, 0.19961673f, 
    -0.04799310f, 0.01874595f, -0.02215403f, -0.12036809f, 0.25711486f, 0.19656259f, 0.19749080f, 0.11056349f, 
    -0.00801316f, -0.08786590f, -0.05312055f, -0.09949272f, 0.04077592f, 0.14349611f, 0.06426200f, 0.06026775f, 
    0.08655209f, -0.04838511f, -0.20514029f, -0.02435512f, 0.01563852f, 0.09182883f, -0.27760386f, -0.15466490f, 
    -0.41972023f, -0.05219523f, -0.06732805f, -0.15307015f, 0.22704396f, -0.00636507f, 0.17491214f, -0.48408666f, 
    0.11036487f, -0.21998300f, 0.03224320f, 0.00083890f, 0.00019300f, 0.15765326f, 0.00374539f, -0.09861295f, 
    -0.04756168f, 0.13112950f, 0.14453563f, -0.00625362f, -0.02504092f, 0.05877919f, -0.03861425f, 0.14607348f, 
    0.06757934f, 0.07831600f, 0.15634340f, 0.24434102f, -0.06725741f, -0.08994920f, -0.08769750f, 0.04154248f, 
    -0.00003220f, -0.07522129f, 0.40449232f, 0.09146758f, 0.43216449f, 0.13972458f, 0.02798842f, -0.09968584f, 
    0.00598082f, 0.09265865f, 0.14050099f, 0.02584307f, 0.03791069f, 0.17511322f, 0.13945788f, -0.01656692f, 
    0.15823510f, 0.06506016f, 0.03301927f, 0.15652847f, -0.29303044f, 0.14826430f, -0.29289189f, -0.29124221f, 
    0.09564225f, -0.07996234f, -0.04738587f, 0.05202197f, -0.13810202f, -0.10453790f, -0.41780201f, 0.15854479f, 
    -0.13023056f, 0.03828293f, -0.06242419f, -0.00236167f, -0.00784239f, 0.13089524f, 0.14344172f, 0.18258710f, 
    0.15818118f, 0.02758267f, 0.02052075f, 0.10366200f, 0.00634940f, 0.10366704f, -0.07282279f, -0.49693605f, 
    -0.34287116f, -0.10893185f, 0.11899240f, -0.03568698f, -0.08402483f, -0.01861408f, 0.01956615f, 0.01849690f, 
    -0.10854206f, -0.09552295f, -0.05626554f, -0.24861747f, -0.10517284f, -0.03272786f, 0.06877494f, -0.04565963f, 
    0.09124229f, -0.05078422f, 0.02285887f, 0.03021951f, -0.19947392f, 0.11053504f, -0.12866767f, -0.00424152f, 
    -0.14103521f, -0.15437412f, 0.04016204f, 0.27053690f, -0.01417628f, -0.02059652f, -0.06705818f, -0.12499077f, 
    -0.00979884f, 0.13535786f, -0.06018688f, -0.19949874f, -0.35360229f, 0.05164098f, 0.11651561f, 0.05331326f, 
    0.06650290f, 0.05510701f, -0.10871391f, -0.03707787f, 0.06931900f, -0.34081918f, -0.29041058f, -0.13959953f, 
    0.09287176f, 0.06714276f, 0.21524574f, 0.14079972f, -0.03778111f, -0.06825458f, 0.14879972f, -0.00812687f, 
    -0.07937887f, 0.00137211f, -0.04138361f, -0.04866969f, 0.19025315f, 0.01421858f, 0.16908832f, -0.19095004f, 
    -0.06890748f, -0.03876998f, -0.02489392f, 0.02525950f, -0.09683066f, 0.07098265f, 0.04157959f, -0.17763099f, 
    -0.11032049f, 0.00586539f, -0.02914735f, 0.10581169f, 0.00940719f, 0.04873215f, -0.17563942f, -0.06201005f, 
    0.10144550f, -0.04957579f, -0.23390909f, -0.08163451f, 0.00148469f, -0.02623022f, -0.01844132f, 0.00000838f, 
    0.01287171f, 0.45806152f, -0.06945387f, 0.09953980f, 0.19020632f, 0.07788514f, 0.05632018f, -0.00337861f, 
    -0.22765121f, 0.04683167f, -0.12179106f, -0.04562799f, -0.11310570f, -0.02547687f, -0.13913339f, 0.02437501f, 
    0.12093411f, 0.07801186f, -0.03216357f, 0.10329360f, 0.20721239f, -0.15784489f, 0.14167194f, -0.17631342f, 
    0.01774971f, -0.03060616f, 0.03907967f, 0.08930535f, 0.10159783f, -0.03603454f, 0.06877308f, -0.03358288f, 
    -0.08470114f, 0.09481775f, 0.00911924f, 0.18768504f, 0.03510230f, 0.20501004f, 0.17442152f, 0.24669564f, 
    -0.13585074f, -0.22059657f, -0.16092959f, 0.03104287f, 0.08626693f, 0.05323160f, -0.05421749f, 0.17231351f, 
    -0.03486682f, 0.08824240f, -0.09858110f, 0.02888940f, 0.06242291f, 0.04486430f, 0.15909640f, -0.17396227f, 
    -0.05936484f, -0.00778305f, 0.12530023f, 0.10533308f, 0.15513362f, 0.10641633f, 0.03542070f, -0.04540359f, 
    -0.20390768f, -0.31575656f, -0.27916172f, -0.29737154f, -0.04195308f, -0.04811895f, 0.10430160f, 0.04890165f, 
    0.00596431f, -0.07012058f, -0.17725891f, 0.05629112f, -0.25065953f, 0.07195558f, -0.01258549f, 0.03804245f, 
    0.09422297f, 0.04248853f, -0.07082760f, 0.32195213f, 0.08851571f, -0.19079614f, -0.07234980f, -0.19289647f, 
    -0.07101625f, 0.15985017f, 0.10007714f, -0.11626688f, -0.14244749f, 0.20177977f, -0.25741917f, -0.01603603f, 
    -0.04213081f, 0.09834621f, 0.02006206f, -0.10691516f, 0.06128248f, -0.42447051f, -0.06933746f, 0.12556045f, 
    0.10148638f, 0.02435695f, 0.08052336f, -0.02358967f, -0.05035628f, -0.23129016f, -0.33484074f, 0.02821570f, 
    0.16765325f, 0.14974886f, -0.00647374f, -0.12452314f, -0.03543231f, -0.23462376f, 0.09374192f, -0.16912141f, 
    0.14239857f, 0.02168479f, 0.09066594f, -0.08800460f, 0.04314867f, -0.00631585f, 0.02318278f, -0.33842522f, 
    0.18027109f, 0.04117073f, 0.23864129f, -0.07076463f, 0.18234956f, 0.13421185f, -0.11824423f, -0.15771414f, 
    0.09770400f, 0.10796257f, -0.20459704f, -0.17505142f, -0.18427274f, 0.13654196f, 0.10607503f, 0.08502372f, 
    0.06975296f, -0.07963272f, 0.21152414f, 0.05038571f, -0.09020618f, 0.08076959f, -0.12495150f, -0.04529339f, 
    0.09904835f, -0.05283514f, -0.21487534f, 0.25186566f, -0.19661415f, -0.06307618f, 0.03683586f, -0.03620896f, 
    -0.06592229f, 0.17581868f, 0.00175304f, -0.00095192f, 0.19933125f, 0.02637243f, 0.08314376f, 0.10814956f, 
    0.11694743f, 0.06789310f, 0.08410370f, 0.14693409f, 0.17631890f, 0.15881047f, 0.07632792f, 0.12905687f, 
    -0.13703409f, -0.12379440f, 0.01419411f, -0.00575965f, -0.07121113f, -0.10512815f, 0.13129883f, -0.07796057f, 
    0.01593079f, -0.05218047f, 0.07281869f, 0.09240302f, 0.07674550f, 0.12866515f, 0.26400489f, -0.03951820f, 
    0.03636264f, -0.15687482f, 0.05015799f, 0.02084983f, 0.01374762f, 0.00300719f, -0.17059807f, 0.29097140f, 
    -0.00982527f, 0.08559614f, 0.21163313f, 0.05374800f, 0.14628923f, 0.03354441f, -0.12383601f, -0.06802375f, 
    0.12806578f, -0.01293356f, -0.00518198f, 0.08215310f, 0.01724620f, 0.21392886f, 0.00044462f, 0.07577804f, 
    -0.13938549f, 0.05815171f, 0.48530507f, 0.18720950f, -0.00237897f, -0.02918254f, 0.08851776f, 0.04523901f, 
    0.13953640f, 0.07497677f, 0.26084545f, 0.20976104f, 0.03126995f, 0.18428659f, 0.20238607f, 0.26526278f, 
    0.01513360f, 0.15657350f, 0.02516420f, 0.09136794f, -0.59712374f, 0.32174531f, -0.09132116f, -0.04371820f, 
    0.17071158f, -0.01841261f, 0.13852015f, 0.05568884f, 0.00579416f, 0.04577889f, 0.07987282f, 0.05758072f, 
    -0.00029841f, 0.08719323f, -0.12942417f, -0.05899366f, -0.14308593f, 0.06741559f, 0.00725643f, 0.08811074f, 
    0.23988381f, -0.20791446f, 0.03082233f, -0.06651048f, 0.07666480f, -0.06325781f, 0.05896381f, 0.05191029f, 
    -0.07732482f, -0.16366223f, -0.08899313f, -0.08187722f, 0.18560201f, -0.02701201f, 0.21386121f, 0.25440657f, 
    0.03847717f, 0.09016047f, 0.05034533f, 0.13059391f, 0.05936617f, 0.13015777f, -0.17658693f, 0.23055775f, 
    0.12005487f, 0.26887348f, 0.29288903f, -0.12951320f, -0.02768643f, 0.13079970f, -0.04036627f, 0.16357259f, 
    -0.23635627f, -0.34420887f, -0.43732864f, -0.00243792f, -0.09327058f, -0.00696377f, 0.02069966f, -0.26955789f, 
    -0.12959225f, -0.09112960f, -0.04221106f, 0.03544129f, -0.05236345f, 0.11624593f, 0.00171455f, 0.17469853f, 
    -0.18065852f, -0.11481898f, 0.05884827f, 0.01382846f, -0.18339363f, -0.12886234f, -0.04835732f, 0.09361093f, 
    -0.24305007f, -0.09923859f, 0.02062633f, 0.00543053f, 0.21844691f, 0.05646048f, 0.11682463f, 0.01591420f, 
    0.01544782f, 0.12525807f, 0.00724029f, -0.02842234f, 0.11303792f, -0.02729965f, -0.19436617f, -0.23443201f, 
    0.01130386f, 0.22656369f, -0.01001558f, 0.14616711f, -0.20752656f, 0.02762518f, 0.21542238f, 0.04016263f, 
    0.26682881f, -0.16243236f, -0.08532429f, -0.18894209f, 0.04524209f, -0.04517144f, 0.07695403f, 0.06161867f, 
    -0.12057185f, -0.10277277f, 0.09831369f, -0.02330916f, 0.01025296f, -0.15584406f, 0.06971119f, -0.06218183f, 
    0.22351138f, -0.02269393f, -0.04774794f, -0.02866382f, 0.13043374f, -0.05427146f, -0.01482944f, -0.01136129f, 
    0.05336488f, 0.00814599f, -0.23789893f, -0.09439171f, -0.10611024f, 0.01113901f, 0.10668862f, -0.19450948f, 
    0.04724168f, 0.02971732f, 0.11526973f, 0.00726365f, 0.01976918f, 0.04728943f, -0.18705122f, -0.07023990f, 
    0.02310693f, 0.14090788f, -0.01865613f, 0.15523922f, 0.14155921f, 0.00820385f, 0.10800106f, 0.00511043f, 
    0.14207099f, -0.07250526f, 0.10133736f, 0.05021690f, -0.15270022f, -0.28463945f, 0.06167999f, -0.22210993f, 
    -0.06885324f, 0.08049812f, -0.03589984f, 0.01376497f, -0.08682450f, -0.13327087f, -0.25016776f, 0.13481848f, 
    -0.14337999f, -0.07833071f, 0.13369955f, 0.06813563f, 0.09893594f, 0.10724853f, 0.31526905f, -0.09323467f, 
    0.01013596f, 0.03913084f, -0.02998360f, 0.17344579f, -0.11108517f, 0.01431492f, -0.09420478f, 0.54782015f, 
    0.30986187f, 0.05501371f, 0.00955393f, -0.03350120f, -0.21124800f, -0.21243593f, -0.13905661f, 0.05999542f, 
    -0.00171039f, 0.08433967f, 0.13562378f, 0.00095176f, 0.19462661f, -0.00321323f, 0.00457778f, 0.06707386f, 
    -0.10479639f, -0.16734964f, -0.17406590f, -0.23074639f, -0.00674316f, 0.12607943f, 0.06653294f, 0.07533278f, 
    0.22698350f, 0.06363138f, -0.01698375f, 0.07600292f, 0.28631884f, 0.20636407f, -0.14976908f, 0.15074831f, 
    -0.03816452f, 0.25828201f, 0.07125799f, 0.07070670f, 0.00731022f, 0.06628519f, 0.03778357f, 0.03902084f, 
    0.19460814f, 0.11411615f, 0.13151954f, -0.00306278f, 0.33145291f, 0.04501113f, 0.10314559f, -0.08961241f, 
    0.09341079f, 0.15651271f, -0.16207857f, -0.04155590f, -0.13647458f, 0.14536156f, 0.11520728f, 0.15927231f, 
    0.08665703f, 0.03930334f, -0.17239588f, 0.03193518f, 0.12671375f, -0.05763850f, 0.25412831f, 0.13733223f, 
    0.10138587f, 0.16638349f, 0.23728070f, 0.06837185f, -0.08803061f, 0.05032402f, -0.17897427f, 0.14133455f, 
    -0.53706920f, 0.26368797f, -0.07288168f, 0.07663421f, 0.12084763f, -0.14084293f, -0.08546327f, -0.27846774f, 
    0.00680073f, -0.03518804f, 0.00874495f, -0.00339264f, 0.01047503f, -0.03899807f, -0.01164567f, -0.03041502f, 
    -0.05064520f, 0.04175515f, 0.02545359f, -0.03163214f, 0.03718601f, -0.04788232f, 0.04779727f, 0.00919835f, 
    -0.04800817f, 0.02363140f, -0.03240563f, -0.06399602f, 0.05223804f, -0.04467071f, -0.04402821f, -0.06478567f, 
    -0.02444470f, 0.01240398f, -0.03205069f, -0.00392925f, -0.04570355f, -0.00323151f, -0.01603204f, 0.05788639f, 
    0.02505355f, -0.04962342f, 0.05091389f, -0.00489526f, -0.01991899f, -0.02904496f, -0.02438539f, -0.02243083f, 
    0.02134023f, 0.00189699f, 0.02949924f, -0.00250167f, 0.04652777f, 0.01987860f, -0.04245257f, -0.03805288f, 
    -0.04315455f, 0.04861058f, 0.02475332f, -0.04130819f, -0.03983903f, 0.02263166f, -0.00579072f, -0.05083721f, 
    -0.03682277f, 0.02242479f, -0.03568998f, 0.05098594f, -0.01487112f, -0.00863372f, -0.00483704f, -0.06388504f, 
    0.02869904f, -0.02561960f, -0.05320135f, -0.01927189f, -0.04114345f, -0.05691743f, -0.05181795f, -0.03255771f, 
    -0.01705607f, 0.01058299f, -0.04510138f, -0.02092354f, -0.03462117f, 0.05135674f, -0.05811106f, -0.02178523f, 
    0.03389902f, 0.01504259f, -0.01935993f, 0.05593322f, -0.01897365f, -0.05743922f, 0.01044390f, -0.01659969f, 
    0.03686229f, -0.01143834f, -0.00705258f, -0.05466375f, -0.02937311f, -0.03063506f, 0.04013636f, 0.01891478f, 
    -0.00872793f, 0.01867026f, 0.04939734f, -0.03660452f, -0.05227321f, 0.00210935f, -0.05838930f, -0.06385502f, 
    0.02969779f, 0.02310559f, 0.00508869f, -0.05840713f, -0.01473948f, -0.04320007f, 0.00488076f, -0.00185136f, 
    -0.01762046f, 0.00095379f, -0.00324820f, -0.03489269f, 0.00493804f, 0.01936457f, 0.00721830f, 0.00747906f, 
    0.04826790f, -0.01497033f, -0.04755989f, 0.02414317f, -0.05329637f, 0.02941358f, 0.05151010f, -0.03989758f, 
    -0.04869049f, -0.02928093f, -0.01662954f, 0.02275073f, -0.02299624f, -0.02657779f, -0.00313976f, -0.00032870f, 
    0.02931269f, -0.03749926f, -0.01825168f, 0.00579994f, -0.06394450f, 0.01504163f, 0.00529138f, 0.01838315f, 
    -0.03284176f, 0.01482941f, -0.02874426f, 0.04658540f, -0.03858447f, -0.04355655f, 0.00976145f, -0.05595448f, 
    0.02564205f, 0.04955378f, -0.05213456f, 0.04470091f, -0.04436329f, -0.03581237f, -0.04957626f, 0.00537784f, 
    0.03200951f, -0.03368789f, 0.00592009f, 0.01762245f, -0.02352095f, 0.02969244f, -0.05979262f, -0.03086863f, 
    -0.05742117f, -0.04788725f, -0.03087506f, 0.04083406f, -0.02465588f, 0.04165287f, -0.05423402f, 0.02407021f, 
    0.03209957f, -0.02142882f, 0.04382623f, 0.02152120f, -0.03233889f, -0.03212988f, 0.01827586f, -0.01046630f, 
    0.02615689f, -0.02887719f, 0.00218152f, -0.02563716f, -0.04071569f, 0.05877953f, -0.01017315f, -0.05571657f, 
    0.00588928f, -0.03329698f, 0.03240350f, 0.03500355f, -0.01364687f, 0.05197208f, 0.00338983f, 0.00311126f, 
    -0.06429137f, 0.00280219f, -0.03993190f, 0.00677571f, -0.03424200f, 0.00758029f, -0.00141478f, -0.04662583f, 
    0.01032797f, 0.00739207f, -0.00492773f, -0.02136081f, 0.03850188f, 0.04378946f, 0.02395012f, -0.04554053f, 
    -0.05905976f, 0.02628752f, 0.02119010f, -0.05788311f, -0.00410454f, 0.01692227f, 0.04116986f, -0.00850969f, 
    0.04916835f, 0.03132965f, -0.05395264f, -0.05858977f, 0.03425424f, -0.03710077f, 0.04616430f, -0.03777356f, 
    -0.03393187f, -0.00588761f, 0.02608999f, -0.01467897f, -0.02165526f, 0.02367189f, 0.04259017f, -0.05780203f, 
    -0.04713292f, -0.06200269f, -0.02523442f, -0.00828009f, -0.00560346f, -0.00332492f, -0.01821712f, -0.05708532f, 
    0.00023738f, 0.03737118f, 0.00781757f, 0.02228097f, 0.00756848f, 0.04312921f, -0.00954882f, 0.01753023f, 
    -0.05665454f, -0.05106316f, -0.04123090f, -0.01608439f, -0.04081126f, 0.02925595f, 0.02065748f, -0.06392381f, 
    0.03899978f, -0.05211212f, 0.03857762f, -0.02588929f, -0.01785920f, 0.02096665f, 0.01783579f, 0.04464590f, 
    0.02428863f, -0.04267498f, 0.04714809f, -0.02227443f, -0.04331099f, 0.03179701f, -0.04187419f, 0.00537974f, 
    0.03934024f, -0.04740904f, -0.03360679f, -0.00587578f, -0.00628978f, 0.01660432f, -0.01242328f, 0.05077842f, 
    -0.08123828f, -0.13396598f, -0.62691593f, 0.06234579f, 0.06164152f, -0.11773440f, 0.21341631f, 0.08663333f, 
    0.09050147f, -0.43838295f, -0.26919886f, -0.19451590f, -0.07687531f, 0.01232081f, 0.11592701f, 0.01758517f, 
    -0.04683960f, -0.09199973f, -0.17153825f, -0.20585972f, -0.33626005f, 0.03887429f, 0.00072077f, -0.00109331f, 
    -0.05533167f, -0.06375704f, 0.06419348f, 0.08140737f, 0.22506860f, 0.10376807f, 0.10405953f, -0.04098281f, 
    0.10140909f, 0.00889971f, 0.02911841f, 0.10694733f, -0.09291578f, 0.05022994f, 0.49910292f, -0.04028511f, 
    -0.03843185f, 0.04295138f, 0.25905356f, 0.09818877f, 0.04741662f, -0.29124293f, -0.15972722f, -0.34078380f, 
    0.06267096f, 0.08502666f, 0.00952999f, 0.09266992f, 0.10366737f, -0.06649016f, -0.45783177f, 0.13886517f, 
    0.49144262f, 0.14727543f, 0.06138072f, -0.03057044f, -0.03910933f, -0.04769274f, -0.18011811f, -0.37275779f, 
    -0.20191060f, 0.07401262f, -0.05891474f, 0.15803666f, 0.11110732f, 0.20445792f, -0.04122066f, 0.02246331f, 
    0.05832492f, -0.22228792f, -0.23976003f, 0.07550893f, 0.15487806f, 0.03581842f, -0.31365383f, -0.12655760f, 
    -0.08256191f, 0.41162419f, 0.14483941f, -0.26423666f, 0.04673686f, -0.10447466f, -0.04681878f, -0.01934743f, 
    0.06459587f, 0.10260772f, 0.21988024f, -0.13238309f, -0.06730115f, 0.00181216f, 0.15921687f, 0.10729159f, 
    0.02658899f, -0.07807102f, 0.28338450f, 0.18645819f, -0.08949933f, -0.22635743f, -0.03581981f, 0.07688168f, 
    0.11689428f, 0.23242819f, 0.11174972f, 0.05373878f, -0.20467989f, -0.26772022f, 0.13520773f, 0.00799936f, 
    -0.01716695f, -0.17313872f, -0.07320511f, -0.23005795f, -0.20084102f, -0.40196633f, -0.44065467f, -0.05591597f, 
    0.04795509f, -0.00239577f, 0.10416641f, 0.04573318f, -0.13212560f, 0.13628700f, -0.00201402f, 0.16065595f, 
    -0.06595745f, -0.08795130f, -0.19307655f, 0.03230236f, 0.13862899f, -0.19938077f, -0.01243312f, -0.01052852f, 
    0.00616032f, 0.19177513f, 0.06811763f, 0.02332040f, -0.00703573f, 0.07699858f, -0.06236447f, -0.10247258f, 
    -0.34084159f, -0.02078604f, 0.30924928f, -0.00814933f, -0.09395918f, -0.09194368f, -0.01991169f, 0.07925658f, 
    0.15381406f, 0.13209903f, 0.02762537f, -0.25387588f, 0.00053184f, -0.00188520f, 0.04582864f, 0.19211093f, 
    -0.02559091f, 0.07646566f, -0.68286628f, -0.24572828f, -0.19232538f, -0.02812435f, 0.06349870f, 0.15490434f, 
    0.02704514f, -0.13272148f, -0.08461011f, -0.22460242f, -0.15728065f, 0.12337648f, 0.09285382f, 0.10532075f, 
    -0.00931127f, -0.00609212f, -0.07251792f, -0.00513679f, 0.33098474f, 0.26411623f, 0.27257681f, 0.08404887f, 
    -0.02592079f, 0.03968696f, 0.03844367f, -0.02828887f, -0.08452378f, 0.16879679f, 0.33287966f, 0.16542713f, 
    0.00495976f, 0.10228445f, -0.09337477f, 0.02294457f, 0.02258098f, -0.16671327f, 0.08471754f, 0.10332023f, 
    -0.01891854f, -0.04030448f, 0.10416735f, 0.04414084f, -0.11350711f, 0.18576646f, -0.09079323f, -0.04181941f, 
    -0.12316150f, -0.06509798f, -0.19895962f, -0.04056807f, 0.11778715f, -0.00966391f, -0.04812503f, 0.03692137f, 
    -0.12938046f, -0.04714471f, 0.01014846f, 0.07467795f, 0.03174438f, -0.14985894f, -0.05207860f, -0.05458770f, 
    0.00433598f, 0.12943090f, -0.06960055f, -0.07850401f, 0.04734880f, 0.03114324f, 0.12708952f, -0.09644868f, 
    0.04196762f, 0.10088799f, -0.47565430f, -0.05923284f, -0.18792458f, 0.02740978f, 0.03192410f, -0.17039064f, 
    0.17054877f, -0.07021260f, -0.12004068f, -0.42719615f, -0.22441812f, -0.00395587f, -0.00791422f, 0.06542715f, 
    -0.02595881f, 0.14362668f, 0.10730341f, -0.08550125f, -0.04701523f, -0.33529004f, -0.11378807f, 0.08129117f, 
    0.01925883f, -0.14556071f, 0.04897232f, -0.10862283f, 0.11189510f, 0.08631025f, -0.02779239f, -0.13317700f, 
    0.11166392f, -0.07470585f, -0.10808355f, 0.29734889f, 0.11471780f, 0.02623123f, -0.00368099f, 0.23589048f, 
    -0.26941386f, 0.02270596f, -0.03591967f, -0.02138214f, -0.03308417f, 0.01211866f, 0.03853472f, 0.11571089f, 
    0.12934436f, -0.08016542f, -0.05012033f, 0.11652095f, -0.11494985f, 0.05980656f, 0.22802593f, -0.00303190f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.13811623f, -0.03037875f, -0.00055842f, 0.14553507f, 0.02361659f, -0.03133034f, 0.03733831f, 0.07579318f, 
    0.00887056f, 0.01316833f, -0.04483002f, -0.01780681f, 0.07187782f, 0.17719755f, -0.00667137f, 0.09721074f, 
    -0.06253467f, 0.28792548f, -0.02517144f, 0.00527418f, 0.10937244f, 0.00452549f, -0.02465066f, 0.14721793f, 
    0.03121356f, 0.02716634f, -0.01159870f, -0.05570249f, 0.02114161f, -0.06334315f, -0.05259026f, 0.14081834f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.35955390f, 0.11561666f, -0.06647616f, 0.18549845f, -0.08410188f, -0.05545450f, 0.10649602f, 0.27057841f, 
    -0.33054006f, 0.13819359f, 0.07632178f, 0.03671186f, 0.70123184f, -0.58964539f, 0.13103019f, -0.02574424f, 
    0.05558607f, 0.06540271f, 0.27022502f, 0.15576375f, 0.11058199f, 0.07531758f, 0.20184501f, 0.01551148f, 
    -0.19072129f, -0.17353305f, 0.14157538f, 0.15246232f, 0.57057017f, -0.08208908f, 0.05096637f, -0.24592809f, 
    0.45588827f, 0.02286270f, 0.27554107f, -0.21647635f, -0.14591008f, -0.13042364f, -0.13293600f, 0.18711619f, 
    0.65287703f, 0.07008818f, -0.00311406f, -0.10977200f, 0.79314375f, -0.04360286f, 0.11870909f, -0.42501900f, 
    0.13478665f, 0.29982784f, -0.08741387f, 0.06496869f, -0.07678606f, 0.04292911f, -0.14049341f, 0.05243756f, 
    0.11546336f, 0.08945561f, 0.11575086f, -0.45033517f, -0.11334674f, -0.28035882f, 0.04379146f, -0.65330517f, 
    -0.09830950f, -0.07095651f, -0.01108661f, 0.63764995f, 0.49161890f, -0.09751280f, 0.05016364f, 0.29097745f, 
    -0.00856519f, 0.16861193f, 0.13947065f, 0.13966495f, -0.01846970f, 0.60132164f, -0.09826539f, 0.31187195f, 
    0.08637209f, 0.37487954f, -0.43011305f, -0.08571199f, -0.50837296f, -0.14815983f, 0.00596832f, 0.35862201f, 
    0.29179144f, -0.01304121f, -0.12580657f, 0.09080815f, -0.44169989f, 0.09415608f, 0.12619296f, -0.16811682f, 
    0.27237651f, -0.09505402f, 0.12203296f, -0.46158823f, -0.03741824f, -0.03638619f, -0.14375590f, 0.02550898f, 
    0.45731393f, 0.05298583f, 0.14536552f, 0.02309434f, 0.22417548f, -0.00820503f, -0.17306156f, -0.27714252f, 
    0.10288741f, -0.21317360f, 0.55549896f, -0.05679974f, 0.21977538f, -0.03373168f, 0.04281836f, -0.39290914f, 
    0.16931649f, 0.11352404f, -0.10166010f, -0.20534517f, 0.33897230f, 0.21640159f, -0.09605213f, -0.59391916f, 
    -0.17701669f, -0.04665508f, -0.08575718f, 0.11299132f, -0.00628367f, 0.08615935f, -0.07932725f, -0.15505460f, 
    0.14640549f, 0.01911939f, -0.03944362f, 0.07132498f, 0.05139286f, -0.15097313f, 0.13818876f, -0.00563828f, 
    0.15921657f, 0.16126156f, -0.12987702f, 0.08070106f, 0.10325917f, 0.11303265f, -0.07777216f, -0.17075878f, 
    -0.05137399f, 0.11631554f, 0.14453472f, -0.00175974f, 0.05651714f, -0.13615835f, 0.15275225f, -0.13685127f, 
    0.25474924f, 0.09709997f, 0.27206171f, -0.36802045f, -0.07323543f, 0.09251211f, 0.17662559f, -0.42469957f, 
    0.03167316f, -0.06842837f, 0.15637854f, -0.08007993f, -0.41232851f, 0.00372936f, -0.03275279f, 0.11614079f, 
    0.08823647f, 0.30485451f, 0.34353080f, 0.07522133f, 0.19424202f, -0.00497005f, -0.49651343f, -0.18790399f, 
    -0.30401555f, 0.03319451f, 0.15350825f, 0.16014901f, -0.11500185f, 0.40604925f, -0.08681499f, -0.16700615f, 
    -0.43807808f, 0.01145288f, 0.17432977f, -0.25768626f, 0.32836324f, 0.14311910f, -0.14486206f, -0.20126089f, 
    0.44972080f, 0.06742857f, 0.13951150f, -0.08730700f, -0.36789936f, 0.54233104f, 0.12086941f, -0.05361594f, 
    0.08695906f, -0.26133174f, 0.38560697f, -0.07528730f, 0.00999238f, 0.00372159f, 0.44545564f, -0.04238567f, 
    0.27157891f, 0.11379261f, -0.15775022f, -0.00353923f, -0.25333145f, 0.24654153f, -0.10379411f, 0.18241312f, 
    0.32268488f, -0.04021437f, 0.01717085f, 0.30049694f, 0.02091438f, 0.00976666f, -0.07826627f, -0.13339283f, 
    -0.01155768f, 0.14754054f, 0.13725646f, 0.08454269f, 0.52260649f, 0.57477850f, -0.14078207f, -0.04705859f, 
    0.08940079f, 0.22063501f, -0.26354972f, 0.11995591f, 0.07386017f, -0.16850571f, 0.05207380f, 0.21455808f, 
    -0.17596358f, -0.14577551f, -0.09126712f, 0.04105041f, 0.32069102f, -0.02110010f, 0.05220562f, -0.61803854f, 
    -0.16213107f, 0.09907207f, -0.16971044f, 0.02048744f, -0.01844438f, 0.03390759f, 0.04175957f, -0.17409594f, 
    -0.08273961f, 0.10384130f, 0.06572384f, -0.01526217f, -0.06939388f, -0.16856170f, -0.00770142f, 0.04980537f, 
    -0.07000774f, -0.02934663f, 0.03684193f, -0.07877855f, -0.06829822f, -0.05738976f, 0.06965677f, -0.11506759f, 
    -0.11782347f, -0.16035995f, -0.06267984f, -0.11781275f, 0.01531314f, -0.14940059f, 0.11100243f, -0.01476760f, 
    0.33519006f, 0.01767811f, 0.10349228f, 0.18502931f, -0.24439047f, -0.13570960f, 0.11446650f, 0.12595044f, 
    0.30085346f, -0.14922626f, 0.05830169f, 0.11773367f, -0.43424875f, -0.02914192f, -0.15177399f, -0.23934831f, 
    0.07985801f, -0.03171623f, 0.52346218f, 0.09026024f, -0.20370154f, -0.02776683f, 0.03391805f, -0.35862887f, 
    -0.12578748f, 0.10293910f, 0.06710564f, 0.31770366f, -0.19034636f, 0.35523313f, 0.13460538f, -0.36206442f, 
    0.05603944f, 0.05539326f, -0.15225585f, -0.00968025f, -0.08366227f, -0.00780652f, 0.00275710f, -0.02871813f, 
    0.12938772f, -0.06293783f, -0.14044055f, 0.09995525f, 0.05220254f, 0.13424325f, -0.10652000f, -0.07194840f, 
    -0.00505130f, -0.07952470f, 0.06554743f, -0.09324307f, -0.06039989f, 0.11745568f, 0.03860270f, -0.04040882f, 
    -0.11313230f, -0.16871816f, -0.17590119f, -0.17491326f, -0.01970070f, 0.01241016f, -0.04976103f, -0.03220006f, 
    -0.23431325f, 0.11035097f, 0.21937570f, -0.70921081f, -0.73947120f, 0.15643214f, -0.04888581f, 0.31888106f, 
    0.26929191f, 0.00311534f, 0.06274458f, -0.07882336f, 0.35233539f, -0.23378828f, -0.12579615f, -0.66583419f, 
    0.08273882f, -0.24754235f, 0.03731021f, -0.05337341f, 0.45021462f, -0.16592589f, 0.50512552f, 0.16218963f, 
    -0.03588110f, 0.10819923f, 0.09959799f, -0.59378260f, 0.51156062f, 0.26990700f, 0.05836441f, 0.00409065f, 
    0.50090688f, -0.06810340f, -0.02537817f, -0.00572770f, -0.26050651f, 0.05863187f, -0.11939327f, 0.28260326f, 
    -0.25413191f, -0.06905746f, 0.11973161f, -0.02222577f, 0.20424746f, -0.07014120f, 0.09500506f, -0.01793390f, 
    -0.16486935f, 0.33310032f, 0.22975722f, 0.09847929f, 0.49264863f, 0.15022767f, -0.18776356f, 0.14409479f, 
    -0.27658170f, -0.14428855f, -0.09498703f, -0.61378527f, 0.05987228f, -0.20724234f, 0.14231996f, 0.56658107f, 
    0.26030824f, 0.01561184f, -0.24318492f, 0.26285359f, -0.22376293f, 0.08698346f, -0.03165556f, 0.32315388f, 
    -0.26540697f, -0.04009385f, 0.04949711f, -0.15133578f, -0.56650388f, 0.55328274f, -0.06751932f, 0.02743753f, 
    0.10754817f, 0.11307426f, -0.04921978f, 0.09912414f, 0.52287751f, -0.09185813f, -0.50835043f, 0.10602225f, 
    0.10473041f, -0.02948682f, 0.08014025f, 0.01496913f, 0.24038303f, 0.24598114f, 0.05232509f, 0.12388530f, 
    -0.14126955f, -0.17463712f, -0.04394442f, 0.14155112f, -0.00064943f, 0.03940612f, 0.00555379f, -0.11502956f, 
    -0.05029467f, 0.17170689f, 0.15323837f, 0.06844421f, -0.05453768f, -0.17043681f, 0.10996956f, 0.15297817f, 
    -0.14931619f, 0.05290542f, -0.12644398f, -0.09643885f, 0.01964056f, 0.09583605f, -0.11966669f, -0.16674776f, 
    -0.14057566f, 0.08258934f, 0.11271323f, -0.09018060f, -0.13579632f, -0.09828529f, -0.10773036f, -0.13365954f, 
    0.05387039f, -0.14793350f, -0.17203502f, 0.12934008f, -0.03598656f, 0.17265849f, 0.16836572f, -0.04629926f, 
    0.07493316f, 0.05179584f, 0.15408930f, 0.17135501f, -0.07107423f, 0.03320777f, -0.11418924f, 0.05488689f, 
    -0.13940972f, 0.01675055f, -0.03478830f, 0.09054359f, -0.15938015f, -0.00768936f, -0.05738797f, -0.09128124f, 
    -0.00995764f, 0.01149642f, -0.12890445f, -0.13506760f, 0.04168627f, -0.11230847f, 0.08424965f, -0.17131926f, 
    -0.11504743f, 0.00514215f, -0.13365330f, 0.03024347f, 0.01508120f, 0.01557465f, -0.07152799f, -0.08115002f, 
    -0.08365612f, -0.14413929f, -0.04901107f, -0.11192608f, 0.05489716f, -0.00006916f, -0.06966029f, -0.16746174f, 
    0.06397253f, -0.12623104f, 0.07264182f, 0.17378971f, 0.03407556f, -0.03564011f, -0.00266693f, -0.06397977f, 
    0.05833182f, 0.06440061f, -0.03888540f, 0.11485724f, 0.00571345f, -0.15129453f, 0.08891221f, -0.09887163f, 
    0.08136226f, -0.07686643f, -0.15692322f, -0.15633635f, 0.10983565f, 0.04057382f, 0.05354454f, 0.10617375f, 
    -0.16442272f, -0.12880471f, 0.17140418f, 0.05547718f, -0.01195304f, -0.02233020f, -0.18117605f, 0.04352735f, 
    0.16085809f, 0.04525339f, 0.12785138f, -0.05283719f, 0.08816869f, -0.10314189f, -0.10884742f, -0.16945542f, 
    -0.17296961f, 0.00623311f, -0.17766564f, -0.14761025f, -0.16007482f, -0.13447303f, 0.05189648f, 0.14538035f, 
    0.01178731f, 0.09551772f, -0.05701637f, -0.07389940f, -0.19556555f, 0.13471201f, 0.10499953f, 0.11126791f, 
    -0.00587011f, 0.04676526f, 0.08608866f, 0.01409517f, -0.15747774f, -0.06175911f, 0.04100942f, 0.03514404f, 
    -0.09002081f, -0.04662542f, -0.18507919f, -0.16947013f, -0.13701494f, 0.10411189f, -0.13159925f, -0.16867383f, 
    -0.13837174f, -0.06760141f, 0.09073448f, -0.09477902f, 0.02179152f, 0.09351718f, 0.17269106f, 0.05652291f, 
    -0.18273307f, -0.13710688f, 0.07325921f, 0.15983768f, 0.15587801f, 0.15458593f, 0.04584211f, -0.15903662f, 
    -0.61940944f, 0.14826457f, -0.00254432f, 0.01950423f, 0.83319736f, -0.13126282f, -0.09759305f, -0.03256210f, 
    0.01781665f, -0.33566132f, 0.16538151f, -0.13942686f, -0.05763856f, -0.16107830f, 0.43744478f, -0.03519093f, 
    0.21151602f, 0.14844337f, -0.11815309f, 0.53515452f, 0.44457307f, 0.33402726f, 0.17928761f, 0.02140979f, 
    0.00721889f, 0.16768543f, -0.04208429f, 0.04822011f, 0.14737356f, 0.16549720f, -0.16756356f, -0.14543097f, 
    -0.17714064f, 0.08388864f, 0.13497742f, -0.03289265f, -0.04741924f, -0.08805787f, 0.07526723f, -0.13119292f, 
    0.13383697f, 0.01171905f, 0.04016245f, -0.12480135f, -0.06990591f, -0.03522283f, -0.13254780f, -0.16447459f, 
    -0.11153730f, 0.10916023f, -0.08866203f, 0.02154314f, -0.06294396f, 0.11927257f, -0.04897931f, -0.04129529f, 
    -0.36235681f, -0.09289453f, 0.43136451f, -0.66736621f, 0.30355975f, 0.16585997f, 0.12298225f, -0.03280913f, 
    -0.07955018f, 0.11020809f, 0.13474807f, 0.04387642f, 0.52835828f, -0.30868679f, -0.16546923f, -0.01526190f, 
    0.04292328f, 0.43678477f, -0.30039933f, 0.02330663f, 0.18253170f, -0.03924536f, -0.25590596f, 0.32351860f, 
    0.28576320f, 0.04382956f, -0.12155050f, -0.63308620f, -0.46490112f, -0.17711394f, -0.16491100f, 0.59470588f, 
    0.35513338f, 0.10362194f, -0.05683760f, 0.60873646f, 0.07793398f, -0.10953614f, -0.14990106f, 0.61363047f, 
    -0.28319708f, -0.09600968f, 0.02284080f, 0.02794437f, 0.03265243f, -0.43535745f, -0.11143558f, 0.22679593f, 
    -0.04657147f, -0.21262212f, 0.00452726f, 0.06919429f, 0.05168761f, -0.08430345f, 0.30562088f, 0.35830212f, 
    0.25786927f, -0.01280570f, -0.04220416f, 0.19223712f, 0.02669594f, -0.28040391f, -0.12837471f, 0.20131339f, 
    -0.29943028f, 0.10604402f, 0.10343824f, -0.41570887f, 0.19159494f, 0.11871585f, 0.01977668f, 0.26894474f, 
    -0.34021652f, 0.03027686f, 0.01457245f, -0.06353783f, -0.46877304f, 0.45429659f, 0.00450831f, 0.01983688f, 
    0.11035693f, -0.03241340f, -0.11065072f, 0.15740789f, 0.22604442f, -0.00432553f, -0.67665887f, 0.22664185f, 
    0.69776702f, -0.13311230f, 0.08603938f, -0.61173600f, -0.22239891f, 0.37260774f, -0.06660897f, 0.33123973f, 
    0.02901166f, 0.07622797f, -0.06646052f, 0.51920545f, 0.04202174f, 0.14788286f, 0.12109125f, -0.18711573f, 
    -0.52146077f, 0.11055288f, 0.10827345f, -0.14737478f, 0.46667013f, 0.47437945f, 0.04298001f, 0.23187007f, 
    0.12361656f, 0.19992566f, -0.30761769f, 0.08637827f, 0.14000024f, 0.02577868f, 0.46054187f, 0.39826140f, 
    -0.09911136f, 0.01869046f, -0.10895681f, 0.45384130f, 0.18848185f, -0.09859214f, -0.00890916f, -0.19669515f, 
    0.05317759f, 0.03816731f, 0.25431532f, -0.02569687f, -0.12200757f, 0.01410482f, 0.09296499f, 0.36742976f, 
    0.00893388f, 0.01531574f, 0.14366886f, -0.01970255f, 0.12586248f, -0.39480248f, 0.01397287f, 0.41433588f, 
    0.11394338f, 0.43824965f, -0.74579126f, 0.11128116f, 0.16892006f, 0.11634456f, -0.36211646f, 0.28749925f, 
    -0.09173329f, -0.04659172f, 0.15707791f, 0.22153077f, -0.50296724f, -0.17955980f, -0.17063946f, 0.31131062f, 
    0.36746004f, 0.16386658f, -0.04238258f, 0.30258843f, 0.06398701f, -0.02053970f, 0.04803062f, -0.11823349f, 
    0.53992581f, -0.01129983f, 0.18787229f, -0.10885262f, 0.16020229f, -0.15741773f, -0.08370981f, 0.36429679f, 
    0.08104251f, 0.44119191f, -0.02034362f, 0.05508188f, 0.22648501f, -0.13264003f, 0.58298147f, 0.07452239f, 
    -0.76352173f, 0.13479413f, 0.14522497f, 0.25038451f, 0.33901009f, -0.19637492f, 0.01574713f, 0.36032715f, 
    0.33311129f, -0.16288301f, -0.20432277f, 0.72265267f, -0.23223539f, 0.11889867f, -0.02116026f, 0.24002972f, 
    -0.00625979f, 0.12311443f, -0.05919416f, 0.09916476f, 0.04686210f, 0.55199540f, 0.10921545f, -0.08835453f, 
    0.01294670f, 0.04355147f, -0.20382024f, 0.10164727f, 0.03947192f, 0.15135321f, 0.24043347f, 0.31408253f, 
    -0.17726445f, 0.11323874f, 0.06778318f, 0.28072694f, 0.20368075f, 0.15916160f, -0.14885563f, -0.64633888f, 
    0.21103331f, -0.05848976f, -0.03628010f, 0.60006398f, 0.36837569f, -0.09984598f, -0.06612276f, 0.50729764f, 
    -0.23121549f, 0.12024523f, -0.04717433f, 0.14153919f, -0.00715007f, -0.05087107f, 0.02191104f, 0.16497061f, 
    -0.06306254f, -0.23301426f, 0.40393704f, 0.17197739f, -0.21677750f, 0.07316581f, 0.16046697f, 0.00225887f, 
    0.42233622f, 0.07204168f, 0.02001372f, -0.09880044f, -0.38637838f, -0.17911012f, 0.17207047f, 0.37958580f, 
    -0.02087732f, 0.11411682f, 0.22953260f, -0.48882934f, 0.35328490f, 0.07188708f, 0.03602124f, -0.49858108f, 
    0.18009380f, -0.03966020f, -0.08460766f, -0.08006611f, 0.05018071f, 0.13771993f, 0.11256573f, -0.24223249f, 
    -0.10862046f, 0.26943290f, 0.35498819f, 0.06003731f, -0.11769359f, 0.11962202f, -0.28085420f, -0.42250839f, 
    0.48639059f, -0.09984703f, 0.01336227f, 0.35693759f, -0.11782479f, 0.39004308f, 0.02033285f, -0.25774419f, 
    -0.17716879f, -0.00528829f, 0.10234991f, -0.05317705f, 0.03441600f, -0.14197360f, -0.17973246f, -0.01973728f, 
    -0.11469014f, -0.16063645f, -0.16554679f, -0.11230193f, -0.01783121f, -0.11477190f, -0.16685052f, 0.03156280f, 
    0.09616874f, -0.15276265f, -0.14108230f, 0.09013135f, -0.05837186f, 0.12444080f, 0.02595520f, -0.01103549f, 
    0.06401467f, 0.09267759f, 0.10369307f, -0.17114183f, 0.12864935f, -0.15251254f, -0.09034231f, 0.03688345f, 
    -0.14145422f, 0.05083964f, 0.23070104f, 0.17173061f, 0.07270014f, -0.12057202f, 0.12092993f, -0.06466948f, 
    -0.17613047f, -0.01869290f, -0.03948785f, 0.02294129f, 0.33810365f, 0.40583065f, 0.13051268f, -0.28867292f, 
    -0.11956125f, 0.09279983f, 0.16650118f, 0.16644098f, -0.37626120f, -0.00886921f, 0.46412399f, 0.29274702f, 
    -0.07213561f, -0.05953153f, -0.09025197f, -0.29168636f, -0.42205736f, 0.27057648f, 0.16353691f, 0.67258328f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.05548174f, 0.08484507f, 0.10322539f, 0.17972818f, -0.17275906f, 0.05145935f, 0.09431839f, 0.23660301f, 
    0.10598329f, -0.05891556f, -0.13138694f, 0.12826975f, 0.32419860f, -0.00190170f, 0.01169557f, -0.00014079f, 
    -0.04916096f, 0.00490182f, -0.06230569f, -0.01385812f, 0.02888436f, 0.22085351f, 0.18938521f, 0.19441612f, 
    0.14148729f, -0.11316951f, 0.21866633f, 0.15778027f, -0.06909873f, 0.01153172f, -0.20141421f, 0.20647058f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.35033217f, 0.43903017f, 0.36205876f, 0.20434161f, -0.14121099f, -0.35464293f, 0.28249827f, 0.01884406f, 
    -0.02588804f, -0.24548253f, 0.13046525f, -0.40078092f, -0.82602149f, -0.17701635f, 0.02762878f, -0.09195127f, 
    -0.04138728f, -0.02605981f, 0.16333480f, -0.02324639f, 0.14461344f, 0.16535215f, 0.07482284f, 0.41936105f, 
    -0.24317792f, -0.02110298f, -0.90020633f, -0.24172530f, 0.34946778f, 0.40006992f, -0.01282340f, -0.23061705f, 
    -0.39782420f, -0.67043507f, 0.42748266f, -0.43709192f, -0.04016173f, -0.33035138f, 0.22245051f, 0.33965871f, 
    -0.16009948f, -0.07505286f, 0.16731334f, -0.47767422f, -0.21863820f, 0.28268510f, 0.08614012f, -0.04900368f, 
    0.04192134f, 0.00674232f, -0.00601486f, 0.09426955f, -0.02192250f, -0.35597429f, -0.06719360f, 0.10211828f, 
    0.32841060f, -0.25685325f, -0.18840638f, 0.60073322f, -0.02707393f, -0.28174680f, -0.07870945f, 0.44055131f, 
    0.33270016f, 0.40445575f, 0.34046817f, -0.39369196f, 0.03056537f, -0.67537373f, -0.76975691f, 0.08573990f, 
    -0.13739647f, -0.26238444f, 0.10180166f, -0.17478602f, 0.10052817f, -0.06812501f, 0.00449540f, 0.17269146f, 
    0.06894696f, 0.06155551f, -0.05365032f, -0.16114084f, 0.15931372f, -0.24839652f, 0.39680010f, -0.31937289f, 
    -0.11583999f, 0.33446032f, -0.01425201f, 0.45313233f, 0.38999265f, -0.85716438f, 0.00329848f, -0.02624857f, 
    0.14169221f, 0.20385239f, -0.63136011f, 0.37878212f, 0.12088505f, 0.22906698f, -0.10235170f, 0.02623955f, 
    -0.07673779f, 0.00186286f, -0.15497608f, 0.34975460f, 0.08930568f, -0.07210505f, -0.10105196f, 0.04961632f, 
    0.04411277f, 0.07122168f, 0.04343550f, 0.23499389f, 0.01699241f, -0.14500448f, -0.55896276f, 0.25022155f, 
    -0.61701185f, -0.92946595f, -0.23953684f, -0.38000938f, -0.16106036f, 0.30732140f, -0.13061981f, 0.32973835f, 
    -0.45658597f, 0.41331291f, 0.22185872f, -0.22234702f, -0.17360772f, 0.43104106f, -0.07298724f, 0.35095963f, 
    -0.15171064f, -0.37396869f, 0.14710046f, -0.55341929f, -0.13056117f, -0.14852445f, 0.13498056f, -0.05276646f, 
    -0.12720668f, 0.12836714f, 0.00164828f, -0.51282781f, 0.02472621f, 0.23892164f, -0.52631420f, -0.14213224f, 
    0.03310168f, 0.42444894f, 0.37372881f, -0.02374494f, -0.98667943f, 0.24306768f, 0.11034249f, -0.12144163f, 
    -0.14832036f, -1.13256168f, 0.13458568f, -0.44640589f, -0.13085325f, 0.16772261f, 0.03271876f, -0.39323649f, 
    -0.11196131f, 0.37387794f, -0.03912351f, -1.11423385f, 0.22775692f, 0.20376670f, 0.11216521f, 0.03031031f, 
    -0.05911034f, -0.10245499f, 0.01603072f, -0.05567199f, 0.12423114f, 0.22545362f, 0.08574931f, 0.40000245f, 
    -0.11763592f, 0.21286981f, -0.27462927f, -0.55663371f, 0.40646854f, 0.10305389f, -0.08607218f, 0.27198562f, 
    -0.40687764f, -0.25623849f, -0.17376976f, -0.23792914f, 0.06184708f, -0.22005363f, 0.14810222f, -0.32048064f, 
    0.13668798f, -1.35533595f, -0.08157700f, 0.56779230f, 0.12714875f, 0.21098235f, 0.15572055f, 0.02674808f, 
    -0.04231543f, -0.12213495f, 0.07710046f, -0.58284843f, -0.08087935f, 0.45435536f, 0.08404474f, 0.42845780f, 
    -0.29034731f, 0.36839545f, 0.07417451f, -0.58174545f, -0.28478104f, -0.56692421f, -0.06791080f, 0.11396127f, 
    -0.27085653f, -0.63165873f, -0.41206646f, 0.32820186f, 0.05344168f, 0.35181224f, 0.39290282f, -0.70870394f, 
    0.12291924f, 0.64432728f, -0.13750666f, 0.33191857f, -1.26904988f, -0.26740134f, -0.04993325f, -0.07428736f, 
    -0.00840857f, -0.13735422f, -0.09164055f, 0.31727815f, -0.09012701f, -1.03778064f, -0.34610835f, -0.18218213f, 
    -0.36717042f, -0.17825639f, -0.10740445f, -0.10136379f, -0.21781781f, 0.43847385f, 0.01138357f, 0.04237218f, 
    0.53244108f, -0.74398816f, -0.14271854f, -0.30622816f, 0.03314754f, -0.25683999f, -0.46082819f, 0.22136515f, 
    -0.10707771f, -0.36366802f, 0.08847051f, -0.23345493f, -0.20295864f, -0.13014384f, -0.15976723f, -0.10677234f, 
    -0.02176875f, 0.09740359f, 0.12873414f, 0.62303507f, 0.00497151f, -0.28008163f, 0.33117652f, -0.73100746f, 
    0.40768850f, 0.14538239f, 0.41436893f, 0.02649955f, -0.26451769f, -0.15819180f, -0.18155006f, -0.61038625f, 
    0.19652456f, 0.20436087f, -0.07846802f, -0.18416245f, 0.09874088f, -0.43057141f, 0.12307030f, -0.02104091f, 
    0.15534285f, -0.47320247f, 0.16702799f, 0.23350722f, -0.10782975f, -1.31506145f, -0.07196214f, -0.17417823f, 
    0.12754264f, 0.08745760f, -0.08094212f, 0.36000839f, -0.05130776f, 0.42425579f, 0.02792104f, -0.39860830f, 
    0.07203012f, 0.08364628f, 0.02852578f, -0.55320001f, 0.03803512f, -0.03211824f, 0.00091690f, 0.51754713f, 
    0.20836197f, 0.18523270f, -0.44565988f, 0.28047597f, -0.17208020f, -0.01364602f, 0.09193701f, 0.07095758f, 
    -0.05796190f, 0.28679582f, 0.08419054f, -0.03535104f, 0.33323139f, 0.02463114f, -0.01170289f, 0.16694140f, 
    -0.07166673f, -0.03970463f, 0.07873430f, -0.57570708f, -0.08511238f, -0.63824254f, 0.12135886f, -0.66932136f, 
    -0.17711934f, -0.33194861f, 0.61758894f, 0.15950248f, 0.14450368f, -0.22093607f, 0.00157612f, -0.52056134f, 
    0.23027954f, 0.00980071f, -0.80357760f, 0.10501423f, -0.15228091f, -0.01634318f, -0.27207288f, 0.15405044f, 
    0.08179209f, -0.74689603f, -0.09768379f, 0.54026628f, 0.29573914f, 0.58268273f, 0.14553402f, -0.10187820f, 
    0.05399140f, 0.13479547f, 0.16274974f, 0.01068036f, 0.14318393f, -0.14665607f, 0.04729244f, 0.21279295f, 
    0.10522337f, 0.09675695f, -0.35268873f, 0.27165976f, -0.62312931f, -0.19457845f, -0.02999328f, -0.82810938f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.06116851f, -0.00667576f, -0.36164513f, 0.07875853f, 0.13314264f, 0.27559090f, -0.06349090f, -0.31059542f, 
    -0.16644709f, 0.06881210f, 0.32632625f, 0.07714544f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
