#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.11338580f, 0.57357919f, 0.49867800f, 0.16530170f, 0.29631999f, 0.00827032f, -0.37809074f, 0.12543961f, 
    -0.22345318f, 0.35593900f, 0.13434750f, -0.15009250f, 0.31723440f, 0.19742583f, -0.14273572f, -0.09601853f, 
    0.11751146f, -0.41783535f, 0.09694796f, -0.20782524f, 0.37967548f, 0.33318424f, 0.41570842f, 0.34476420f, 
    -0.10628013f, 0.82240069f, 0.51568019f, 0.49421921f, 1.05865824f, 0.32556823f, 0.08109101f, -0.11998346f, 
    -0.16677929f, -0.00663727f, -0.07869767f, -0.08666534f, -0.08077534f, 0.25886938f, -0.09650864f, -0.26622877f, 
    -0.05133962f, 0.09562337f, 0.36368641f, -0.45188838f, 0.02535783f, -0.13129289f, 0.01599571f, -0.03671095f, 
    -0.25690860f, -0.19753921f, 0.87908852f, 0.00288640f, 0.39640558f, -0.74559510f, 0.30374447f, 0.04356214f, 
    -0.37987500f, 0.44333202f, 0.52600467f, 0.18529990f, -0.09453763f, 0.26316106f, -0.21786684f, -0.03386892f, 
    0.25286877f, -0.00784113f, 0.03900181f, -0.23817341f, -0.35675785f, -0.24281816f, -0.28813046f, -0.01589054f, 
    -0.17304939f, -0.06576044f, 0.01755897f, 0.23665214f, -0.40071052f, -0.49761829f, -0.64976180f, -0.37131742f, 
    -0.04818328f, 0.62247372f, 0.47414243f, 0.33495530f, 0.34480506f, -0.06041551f, -0.21189362f, -0.23676777f, 
    -0.25642160f, -0.21814355f, 0.12441488f, -0.11151963f, -0.33369777f, -0.02849630f, -0.18342371f, -0.00937208f, 
    0.26213238f, -0.16848099f, 0.09341687f, 0.13391116f, 0.40474248f, 0.45806858f, 0.13419752f, -0.02190195f, 
    0.21671806f, -0.09197214f, 0.25870046f, 0.05733475f, 0.38122863f, 0.52929878f, 0.12136322f, 0.22180606f, 
    0.05920218f, -0.27088928f, -0.06155901f, -0.21528868f, -0.53554857f, -0.31208920f, 0.04525671f, -0.18593276f, 
    -0.05397832f, -0.24050795f, 0.35306618f, 0.22018152f, -0.37216824f, 0.53869390f, -0.21139111f, -0.02508737f, 
    -0.40292308f, -0.24744755f, -0.04187461f, -0.36431429f, 0.04650296f, -0.16003861f, -0.15278327f, -0.42093101f, 
    -0.06362224f, 0.41864958f, 0.09865391f, -0.16006164f, -0.26767614f, 0.34680596f, -0.10081826f, 0.35576883f, 
    -0.67428750f, 0.15114301f, 0.19845110f, 0.23489544f, 0.05904013f, 0.30577749f, -0.89041263f, 0.41957170f, 
    0.25181749f, -0.87046415f, -0.37147874f, -0.05463097f, 0.15928747f, 0.28829959f, 0.35221216f, 0.38836417f, 
    0.22542243f, 0.41944996f, 0.09079713f, 0.10491036f, -0.06085712f, 0.32957417f, 0.21411823f, 0.31909028f, 
    0.25626913f, 0.25432295f, 0.12565944f, -0.10780058f, -0.11249621f, -0.32779828f, 0.37738615f, -0.52954322f, 
    -0.59301412f, 0.15108092f, -0.03285942f, -0.47298351f, 0.50197285f, 0.43359545f, 0.51356250f, 0.27534369f, 
    -0.16506653f, -0.44283277f, 0.10969917f, -0.02513022f, -0.12463661f, -0.20995468f, -0.20744829f, 0.36460268f, 
    -0.18373936f, -0.03978487f, -0.06755509f, 0.34899503f, -0.02403023f, 0.07338542f, -0.19074763f, 0.12253688f, 
    0.56329387f, 0.40156350f, -0.68857998f, 0.10895236f, -0.17246206f, -0.40647990f, -0.60514563f, 0.16959636f, 
    0.10493895f, 0.11698592f, -0.29528195f, 0.22625095f, 0.41992679f, 0.14910282f, 0.17338833f, 0.04123402f, 
    -0.18852265f, -0.47073817f, 0.19986898f, 0.23108169f, -0.20136856f, 0.26906848f, 0.05643537f, -0.15588069f, 
    -0.17467088f, -0.45196995f, -0.44409946f, 0.19502059f, 0.37863722f, 0.41751069f, -0.91740614f, 0.04791231f, 
    -0.48977429f, -0.86481416f, -0.16190101f, -0.02615529f, 0.19100296f, 0.24006486f, 0.23736663f, -0.35337317f, 
    -0.30027676f, 0.16190492f, 0.16406102f, -0.19506827f, -0.20601612f, 0.07329482f, -0.02802156f, -0.02395538f, 
    0.08953660f, -0.24114461f, -0.09379697f, -0.92901915f, 0.58483094f, 0.52204585f, 0.18065959f, 0.69268847f, 
    0.52087688f, 0.12170893f, -0.06756261f, 0.03908834f, -0.11570270f, -0.15552023f, 0.16963010f, 0.15174262f, 
    -0.15929897f, -0.14306207f, 0.13357216f, -0.00112623f, -0.06782369f, -0.16112453f, -0.10347522f, -0.09594887f, 
    -0.05029140f, -0.20816955f, 0.13316797f, 0.73770529f, 0.48783484f, 0.57275081f, 0.46120679f, 0.73468572f, 
    0.28453043f, -0.08952360f, -0.74554288f, 0.17208506f, -0.29929423f, -0.03012905f, 0.30446333f, 0.14756927f, 
    0.19212054f, -0.07634765f, 0.15184373f, 0.12151871f, 0.00417325f, 0.11697668f, 0.07037807f, 0.03231113f, 
    0.04274072f, 0.13739011f, 0.08841300f, 0.17077984f, -0.86211908f, 0.14672814f, 0.11153418f, 0.29236147f, 
    0.63129318f, -0.65308481f, 0.85133964f, 0.19294600f, -0.66076088f, -0.33216810f, -0.07815808f, -0.14783648f, 
    0.45048511f, -0.17001943f, 0.25039896f, 0.18450412f, 0.10501364f, 0.04461585f, 0.38653576f, 0.18218905f, 
    0.14982121f, 0.09941415f, -0.17163777f, 0.10892504f, 0.19575667f, 0.80112875f, -0.45463994f, -0.85450065f, 
    -0.24670182f, 0.19846110f, 0.18612432f, -0.50729138f, 0.02766438f, -0.04109732f, -0.30935919f, -0.41577965f, 
    -0.15725911f, -0.00917762f, -0.27339879f, -0.15376432f, -0.20019613f, -0.19737661f, 0.05876685f, -0.20217977f, 
    -0.20641582f, 0.15159468f, 0.09192266f, 0.13453028f, -0.02883819f, -0.36331522f, 0.34938046f, 0.88687074f, 
    0.42723805f, 0.00043361f, -0.24628536f, -0.48612449f, 0.41286263f, -0.18445697f, -0.33747587f, 0.47883135f, 
    0.22511798f, 0.05314986f, 0.18680009f, 0.11884868f, -0.07881005f, -0.31938615f, -0.03010065f, 0.47390574f, 
    0.13731162f, -0.38188839f, 0.10385307f, 0.02984119f, -0.13903636f, 0.22077489f, 0.36621672f, -0.43882033f, 
    -0.41508245f, -0.39011931f, 0.16463177f, -0.12566392f, -0.19970880f, 0.46946505f, -0.20362602f, 0.41201040f, 
    0.12213797f, 0.41521600f, 0.35275576f, -0.14543299f, 0.19548905f, -0.53568947f, -0.38146225f, 0.18773894f, 
    0.19874808f, 0.10593445f, -0.32274336f, -0.07029960f, -0.16169116f, 0.05105845f, -0.33506343f, 0.00427294f, 
    -0.58172917f, 0.11009821f, 0.27975082f, 0.01974688f, 0.09824742f, -0.49015972f, 0.22174934f, -0.30097151f, 
    -0.38611537f, 0.07397635f, 0.53341633f, -0.26064232f, -0.32596380f, 0.16134314f, -0.28299159f, 0.15351957f, 
    -0.13709408f, -0.19484681f, -0.19506551f, 0.15078574f, 0.24205342f, 0.30644664f, 0.33057106f, -0.01282663f, 
    0.06799278f, -0.32546592f, 0.85649443f, -0.35200953f, -0.47257322f, -0.47074732f, 0.66709107f, -0.57562894f, 
    0.01051205f, 0.13747784f, -0.00252238f, 0.43151760f, -0.11013060f, 0.04350859f, 0.10069186f, 0.11420361f, 
    0.34251946f, -0.12071989f, 0.11317572f, 0.02720308f, 0.15053242f, 0.11994145f, 0.16984296f, 0.13186820f, 
    -0.12872295f, 0.08354887f, -0.44197750f, -1.19392633f, -0.58393008f, 0.50567824f, 0.45903879f, -0.35381582f, 
    0.54428351f, 0.56298095f, -0.38975605f, -0.27207479f, 0.25435495f, -0.03243399f, -0.19028614f, 0.01680496f, 
    0.20472658f, -0.21278930f, -0.01476770f, -0.23922069f, -0.10086463f, -0.09422665f, 0.02993112f, 0.05808058f, 
    0.10862192f, -0.00348147f, -0.04546141f, -0.48139256f, -0.35007170f, -0.63318437f, -0.38111529f, -0.51774353f, 
    0.59354097f, 0.90782225f, -0.41282460f, 0.28264460f, 0.52742332f, -0.00295747f, -0.12378334f, 0.12005351f, 
    0.00344867f, 0.13549252f, -0.02204071f, 0.03028329f, -0.02921952f, -0.07344616f, -0.00136496f, 0.06893490f, 
    -0.15423964f, 0.28579298f, 0.18892911f, 0.13539861f, 0.06377728f, -0.53316444f, -0.17873743f, 0.03589299f, 
    0.13022287f, -0.63211697f, -0.68131477f, 0.10439519f, -0.35578495f, -0.14520302f, -0.13522263f, 0.17768666f, 
    -0.01949548f, -0.19268577f, -0.16013019f, 0.40184113f, -0.44389567f, -0.09140898f, -0.42122462f, 0.05275247f, 
    -0.34970915f, -0.06169424f, -0.10333382f, 0.31948215f, -0.05665812f, 0.62848401f, -0.82200176f, -0.53959137f, 
    0.58539438f, -0.44377059f, -0.67810035f, 0.69888765f, 0.21914785f, 0.24667545f, 0.42520884f, 0.12433078f, 
    0.52250630f, 0.23475845f, -0.07320348f, 0.09886452f, -0.25731683f, -0.03319129f, 0.04142912f, 0.02824454f, 
    -0.08408055f, -0.08200774f, 0.07020112f, 0.07155556f, -0.01989187f, 0.02421475f, 0.48200566f, 0.50049305f, 
    0.30921116f, 0.12132149f, 0.52685905f, -0.14465272f, -0.44808814f, -0.30080456f, 0.17361577f, 0.37674284f, 
    -0.34807557f, -0.33716962f, -0.16894080f, -0.42120597f, -0.26388317f, -0.22469255f, -0.21589659f, -0.11789471f, 
    0.19508447f, 0.14116712f, 0.37019610f, -0.04108474f, -0.20162928f, -0.21600115f, 0.14434421f, 0.50994581f, 
    -0.03014026f, -0.18388808f, 0.86016566f, 0.59712291f, 0.30208731f, 0.42426836f, 0.13394915f, 0.44368818f, 
    0.01348472f, -0.08877794f, -0.05651422f, -0.48190549f, -0.05132866f, -0.39137825f, 0.20263800f, -0.33125234f, 
    -0.15120310f, 0.01982563f, 0.02073055f, 0.09750465f, -0.00557913f, 0.30770898f, -0.11483114f, -0.08058202f, 
    -0.60928047f, -0.21973282f, -0.56425470f, 0.44417712f, -0.26988494f, 0.54139072f, 0.02933240f, -0.04690034f, 
    0.00751842f, -0.44391957f, -0.22068176f, 0.14686829f, -0.22282189f, 0.13591366f, -0.10993865f, 0.03635219f, 
    0.27002802f, -0.01187874f, -0.23644561f, 0.23723124f, -0.04789744f, -0.07519378f, -0.10833767f, 0.11200222f, 
    -0.12457679f, 0.83146966f, 0.52837658f, -0.24931246f, -0.92711771f, -1.04552436f, 0.28462952f, 0.04260006f, 
    0.00804763f, -0.22934242f, 0.15561447f, 0.45796666f, 0.34070730f, 0.17628239f, -0.00043350f, -0.04902558f, 
    -0.04771946f, 0.10663711f, 0.11265935f, 0.16328257f, 0.32518154f, 0.18820579f, 0.09188238f, 0.00283514f, 
    0.04363862f, -0.07985815f, 0.32003465f, -0.23952097f, 0.48380661f, 0.58207250f, 0.38785511f, 0.51208174f, 
    -0.03483730f, 0.34416384f, 0.01470868f, -0.16775459f, -0.07885909f, -0.21876399f, -0.26349568f, 0.29484040f, 
    0.16691183f, 0.13432200f, 0.21175817f, 0.18966039f, 0.16575739f, -0.13205619f, -0.18385649f, -0.05262780f, 
    -0.06182222f, -0.06164777f, 0.31759849f, -0.02311842f, 0.54861826f, -0.61346078f, -0.00649146f, 0.31788871f, 
    -0.73879868f, -0.88751358f, -0.45649025f, -0.34383520f, 0.05150342f, 0.08414948f, 0.03214333f, 0.05594350f, 
    -0.09811071f, -0.22878407f, -0.13194245f, 0.20764701f, 0.05621954f, 0.12380572f, 0.23473363f, 0.09973475f, 
    -0.02687443f, -0.26702592f, 0.11364108f, -0.18979649f, -0.46522713f, -0.71713406f, -0.35303348f, -0.30642703f, 
    -0.53372300f, -0.08402842f, -0.34682232f, -0.09243373f, -0.29738560f, 0.28421584f, -0.14928722f, -0.14108339f, 
    0.22385621f, 0.26746553f, 0.28686419f, 0.20843259f, -0.12095597f, -0.02056564f, 0.24700497f, -0.15289205f, 
    0.14015861f, -0.10312982f, 0.11150698f, -0.01120945f, 0.06424105f, -0.11326434f, 0.53435445f, 0.74719864f, 
    0.80374032f, 0.19616419f, 0.44812435f, 0.28804466f, -0.42764914f, 0.04860137f, 0.02583175f, 0.04285157f, 
    0.19377363f, -0.10989716f, -0.01877562f, -0.31162533f, 0.12142413f, 0.00839905f, 0.13249870f, -0.02123502f, 
    -0.06862653f, 0.23733467f, -0.09969467f, -0.23118563f, -0.04907989f, 0.05479622f, -0.29234076f, -0.23979713f, 
    -0.47434366f, -0.26936790f, 0.06071398f, -0.27124467f, -0.47091860f, -0.02293436f, 0.19291136f, -0.02908937f, 
    -0.18383408f, -0.12425722f, 0.44378087f, -0.25722146f, -0.37306994f, 0.01458637f, 0.09969085f, 0.55247098f, 
    -0.00586946f, -0.36007619f, -0.25332549f, 0.09048069f, 0.18844973f, -0.05831480f, 0.27488220f, 0.23924428f, 
    0.95826751f, -0.32788259f, -0.30556610f, -0.37639308f, 0.45577660f, -0.43073350f, -0.65469319f, -0.57412249f, 
    -0.40384105f, 0.03870922f, -0.07640161f, -0.19244179f, 0.12623973f, -0.19602059f, -0.00218285f, -0.24044223f, 
    -0.08028553f, -0.32231566f, -0.14307390f, -0.07354901f, 0.28817296f, 0.11133207f, -0.30478293f, -0.02228762f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.04366524f, 0.14516030f, 0.13255048f, 0.14923778f, -0.04371125f, 0.19674073f, 0.31696016f, -0.10425184f, 
    0.12640160f, 0.16013050f, 0.13210833f, 0.19549641f, 0.22154650f, 0.21450134f, 0.19425060f, 0.15830716f, 
    0.13349053f, 0.35060242f, 0.26208508f, 0.19169402f, 0.14804704f, -0.08336176f, 0.05586078f, 0.01266654f, 
    -0.09086810f, 0.06040493f, 0.04185824f, 0.16498367f, 0.15256245f, 0.08294166f, -0.09370326f, 0.14193265f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.22182697f, 0.01305253f, -0.09346463f, -0.20258540f, -0.08504352f, -0.04200316f, -0.00936675f, 0.00958278f, 
    -0.09305170f, 0.12658378f, 0.05431407f, 0.12099322f, -0.31875065f, 0.01655291f, 0.19024774f, -0.46559864f, 
    -0.02043762f, -0.14353271f, -0.08345915f, -0.03638995f, -0.09462862f, 0.01293152f, -0.00502181f, 0.03525991f, 
    -0.03533773f, 0.07390777f, 0.09182711f, 0.27357829f, 0.07474724f, 0.14819901f, -0.01157020f, -0.03761104f, 
    0.07798246f, 0.03239402f, 0.05649105f, -0.02730519f, 0.09512842f, -0.04277556f, 0.09724869f, 0.08029511f, 
    0.01339406f, 0.15206286f, 0.09266724f, -0.02550054f, 0.01899452f, -0.08033018f, 0.00222515f, 0.03161451f, 
    -0.12117986f, -0.08002437f, 0.07277837f, -0.10034241f, 0.03707293f, 0.00443524f, -0.10743704f, 0.02463162f, 
    0.00128173f, 0.04107726f, -0.00865787f, 0.06891831f, 0.18324637f, 0.19625379f, 0.06350596f, 0.32908762f, 
    0.08384738f, 0.09589137f, 0.00621801f, 0.18368231f, 0.05054370f, -0.01050019f, 0.12238741f, 0.02320227f, 
    0.04174553f, 0.07812711f, 0.05852256f, 0.07318435f, 0.21892062f, 0.05761480f, 0.03749250f, -0.07203799f, 
    -0.06896035f, 0.08689917f, -0.04783141f, 0.05223695f, 0.11216465f, -0.01490328f, -0.01199136f, 0.05204073f, 
    0.09840409f, 0.09264435f, -0.05139858f, -0.00245742f, -0.11911780f, 0.03846215f, 0.07096282f, -0.00348958f, 
    -0.01997957f, 0.07470353f, 0.12273012f, 0.15215889f, -0.06171002f, 0.10283415f, 0.08581298f, -0.02233078f, 
    0.04892152f, 0.05495735f, 0.07068633f, -0.00177123f, 0.25164166f, 0.05048929f, 0.19209169f, -0.00153251f, 
    0.02415735f, 0.12306845f, -0.02675373f, 0.09903695f, 0.02974287f, -0.03511867f, 0.06042654f, 0.09028854f, 
    0.05233805f, -0.05933970f, -0.01029066f, -0.07050410f, 0.10667746f, -0.10891120f, -0.02643942f, -0.03116582f, 
    -0.03386004f, 0.07431480f, -0.00157666f, 0.00351488f, -0.34097159f, 0.20264636f, -0.15723039f, -0.35372967f, 
    -0.04810354f, -0.02495952f, 0.05542494f, -0.00651084f, 0.04833285f, 0.07533803f, 0.13770097f, 0.07889836f, 
    0.14591517f, -0.16353767f, -0.08984103f, 0.04192676f, 0.01208219f, 0.06906238f, 0.06560009f, 0.11181433f, 
    0.00816826f, 0.02109269f, 0.08453321f, 0.04272604f, 0.17004448f, 0.08504272f, -0.20079295f, 0.30791187f, 
    0.01427268f, 0.05587272f, -0.02983922f, 0.07290479f, 0.06380551f, 0.00794324f, 0.03531023f, 0.01813265f, 
    -0.10995276f, -0.15508069f, 0.08564416f, 0.04400520f, 0.05956652f, -0.06025389f, 0.07438669f, 0.02465068f, 
    0.13904662f, 0.05963251f, 0.03021517f, 0.06064951f, 0.02020329f, 0.23740156f, 0.20267381f, 0.04551720f, 
    0.18708305f, 0.17473841f, 0.01660121f, -0.04796132f, -0.06924281f, 0.13527079f, 0.09490975f, -0.02743969f, 
    0.29810381f, 0.16108832f, 0.10617322f, 0.16634125f, 0.02592488f, 0.11800428f, 0.05879863f, 0.03834326f, 
    0.05957803f, 0.08604419f, -0.06716035f, 0.07985467f, -0.09855401f, -0.06840708f, 0.18325746f, 0.30302879f, 
    0.15104777f, 0.05079846f, 0.07958297f, -0.01144901f, -0.07634624f, 0.06692052f, 0.05230432f, 0.03551663f, 
    0.20623146f, -0.16479059f, 0.07719177f, -0.00926068f, 0.09086736f, 0.04399989f, 0.02066017f, 0.19916853f, 
    0.05775163f, 0.10476844f, -0.02271210f, 0.07692689f, -0.33081651f, 0.14256300f, -0.02148386f, 0.16211346f, 
    0.10247172f, 0.09693986f, 0.11324176f, -0.01582700f, 0.14185813f, 0.00918699f, 0.00024271f, -0.14016533f, 
    0.14456823f, 0.25875571f, 0.15775345f, 0.09151346f, -0.02165091f, 0.09394521f, 0.07833359f, -0.04546966f, 
    -0.02824237f, -0.05838648f, -0.00648653f, -0.06010784f, -0.00851942f, 0.33756465f, 0.21170184f, -0.32550475f, 
    0.02028061f, 0.08133273f, 0.08650359f, 0.06954709f, 0.01068813f, -0.04053682f, 0.00127769f, 0.04585471f, 
    -0.14479496f, 0.19206868f, 0.02420854f, -0.14131089f, 0.01488848f, -0.00423501f, 0.01080710f, 0.00646504f, 
    0.02999584f, -0.01411340f, 0.12729126f, 0.10258794f, -0.32887036f, 0.06217234f, 0.13400328f, -0.36119747f, 
    0.02565809f, -0.00387713f, 0.07886001f, -0.03231709f, 0.09016698f, -0.08146869f, 0.02599605f, 0.13231707f, 
    0.21672517f, 0.27492225f, 0.19509745f, 0.29152805f, -0.06328805f, 0.13687427f, 0.18562701f, 0.08839694f, 
    0.08025680f, 0.05100711f, 0.06827780f, 0.10088421f, -0.09734913f, 0.04735110f, -0.06517940f, 0.38620597f, 
    0.13794304f, -0.05464699f, -0.05973671f, 0.12089977f, 0.17829600f, 0.12559326f, -0.03547799f, -0.06232715f, 
    -0.05369834f, 0.01905762f, 0.05350317f, -0.24019653f, 0.05570335f, -0.05060095f, 0.08477381f, 0.00170659f, 
    -0.00177266f, 0.06670137f, -0.02345851f, 0.04798435f, -0.00536076f, 0.07009108f, -0.02699849f, 0.35669097f, 
    0.13123354f, 0.02076995f, -0.08497477f, 0.03337635f, -0.02929973f, 0.07088055f, 0.01429835f, 0.02380473f, 
    0.10437768f, 0.15076891f, 0.03662889f, 0.32377517f, 0.18158236f, 0.16331217f, 0.03643409f, -0.02417413f, 
    0.01606088f, 0.00108996f, 0.10678513f, 0.05324361f, -0.19922948f, 0.00658809f, -0.01990041f, -0.30373168f, 
    0.10536779f, 0.03581695f, -0.05669519f, -0.04912983f, -0.00909650f, 0.01394840f, 0.05380507f, 0.07973816f, 
    0.17277730f, 0.44010213f, 0.00730418f, 0.15756315f, 0.04020027f, 0.13819443f, 0.08224359f, -0.03098987f, 
    -0.07904494f, 0.06319390f, -0.04479652f, 0.01191976f, -0.19642879f, 0.05580994f, 0.15236950f, 0.56110728f, 
    0.03272308f, -0.02397881f, -0.02915833f, 0.01821301f, -0.07596637f, 0.03838089f, 0.00278660f, 0.09792501f, 
    0.00453602f, 0.02193562f, 0.01111381f, -0.01333194f, 0.01646940f, 0.00984713f, -0.00599375f, 0.01020411f, 
    0.04370503f, -0.04774680f, -0.00295244f, 0.01395347f, 0.00549317f, 0.02153226f, -0.04207313f, -0.01770202f, 
    -0.05338246f, -0.01208344f, -0.05197057f, 0.01188313f, 0.00829683f, 0.00562174f, 0.03104198f, -0.01788064f, 
    -0.02390068f, 0.03868457f, 0.00395044f, 0.03923412f, -0.03000439f, 0.01950795f, 0.02050401f, 0.00611544f, 
    0.03775464f, -0.05576888f, -0.03393884f, -0.00225245f, -0.01637209f, 0.02774850f, -0.05613218f, -0.01931040f, 
    0.04033616f, 0.00038109f, 0.01525971f, -0.00773106f, 0.01586717f, -0.02441564f, 0.03100145f, -0.03082644f, 
    -0.05080287f, -0.05034568f, -0.03385168f, 0.00372225f, -0.00892590f, -0.00777050f, 0.02760520f, -0.00041617f, 
    -0.01184115f, 0.03843626f, 0.02803413f, -0.05156886f, 0.04104181f, 0.01001123f, 0.00481253f, -0.04653120f, 
    -0.02430934f, 0.00156769f, -0.03125327f, 0.03115503f, -0.03379775f, -0.02255389f, 0.02202162f, 0.01984680f, 
    -0.02027988f, 0.01696857f, -0.01143766f, -0.02979814f, -0.04922083f, 0.01907014f, -0.00903318f, -0.00207913f, 
    -0.04928447f, 0.01101103f, 0.03298157f, 0.00682169f, -0.01731737f, 0.00616576f, -0.00481671f, 0.03511772f, 
    -0.05496197f, 0.02122265f, 0.01379209f, -0.05247508f, -0.06232072f, 0.00696157f, 0.03900185f, -0.04527655f, 
    -0.00470529f, 0.04005317f, 0.03034508f, -0.01130601f, 0.01260796f, -0.03178914f, 0.02659621f, -0.02369130f, 
    0.02270813f, 0.02795498f, -0.03784033f, -0.00124895f, -0.02426310f, 0.05195649f, 0.03593837f, 0.04306684f, 
    0.02718002f, -0.05086813f, -0.02823070f, 0.03806713f, -0.05464658f, 0.01177478f, 0.01799987f, 0.03989138f, 
    0.02693375f, 0.03426088f, -0.02017570f, -0.04988951f, 0.01695586f, 0.01436988f, 0.01248369f, 0.02499748f, 
    0.01909376f, -0.01860576f, -0.04691738f, -0.04468684f, 0.03329038f, 0.03164906f, 0.03116706f, 0.01630467f, 
    0.04055992f, -0.01729834f, -0.04880621f, -0.03713569f, 0.00629961f, 0.02711171f, -0.02404950f, -0.04616425f, 
    0.02844911f, 0.02420475f, -0.01865283f, -0.01267271f, -0.01039696f, -0.01474352f, -0.04987673f, 0.01837212f, 
    -0.05944261f, 0.03283677f, 0.01920505f, 0.03881953f, 0.02902016f, 0.03826755f, 0.02393677f, 0.00369053f, 
    0.00694939f, 0.02154816f, 0.01097241f, -0.04716971f, 0.00298363f, -0.00451915f, -0.03735928f, -0.02044473f, 
    -0.00790872f, 0.00356212f, -0.01684111f, 0.02482257f, -0.00368333f, 0.01055093f, 0.00387682f, 0.02822608f, 
    -0.03949580f, -0.01942556f, 0.00928031f, -0.00201612f, -0.01176789f, 0.01389991f, -0.03876468f, -0.01226570f, 
    0.04170366f, 0.03962523f, 0.00592127f, 0.00323718f, -0.03600520f, 0.03305321f, -0.02523591f, -0.04674561f, 
    -0.00217116f, -0.03403217f, -0.03970535f, -0.02291770f, -0.05349213f, -0.04018293f, 0.02178716f, 0.00724733f, 
    -0.04468874f, 0.00517964f, -0.05757660f, -0.04510842f, -0.03939054f, 0.00795629f, -0.01802789f, 0.00513444f, 
    0.03525058f, 0.03534495f, 0.03805789f, -0.01808462f, -0.01908195f, -0.01324383f, -0.05185765f, 0.01398054f, 
    0.03263069f, -0.00890492f, -0.00172486f, -0.04400890f, -0.02177505f, 0.02409654f, -0.03767976f, -0.03362444f, 
    -0.02658517f, 0.02286849f, -0.03981237f, -0.00068827f, 0.02083749f, -0.02957033f, 0.01321101f, 0.03273729f, 
    -0.05209763f, -0.00025152f, -0.00795890f, -0.04808899f, -0.02080103f, 0.01705148f, -0.01295812f, -0.01409163f, 
    -0.02436314f, 0.00591257f, -0.03584976f, -0.04708791f, -0.04709598f, -0.03390927f, 0.02955667f, -0.03074873f, 
    -0.00561104f, -0.01973053f, -0.04260809f, -0.00314961f, -0.01367951f, -0.00359694f, 0.04156239f, 0.02505125f, 
    -0.03981374f, 0.00890975f, -0.04243013f, 0.00005700f, -0.04220993f, -0.00146978f, 0.01853454f, 0.03601652f, 
    -0.03795817f, 0.01954814f, -0.03201949f, -0.01083956f, -0.06004844f, 0.02870337f, -0.03763887f, 0.01417053f, 
    -0.04932188f, -0.01999141f, -0.05165192f, 0.03963014f, -0.02088479f, 0.03512512f, 0.02929328f, 0.03523276f, 
    -0.02142442f, 0.02773678f, 0.03244186f, -0.02711609f, 0.01533659f, -0.02021996f, 0.02275286f, -0.03438371f, 
    0.02434725f, 0.04668263f, -0.05633655f, -0.01561228f, 0.00179383f, 0.02052084f, -0.01401532f, -0.00457877f, 
    0.01569959f, -0.02922223f, -0.00962088f, -0.00415719f, 0.03075177f, -0.04815344f, 0.03275963f, -0.00326827f, 
    0.00322487f, -0.00835100f, -0.00322318f, -0.03935047f, 0.02845414f, 0.02862125f, 0.02707525f, 0.02590929f, 
    -0.02151624f, -0.04152064f, -0.03348145f, 0.03162965f, -0.01151635f, 0.00591590f, -0.03750573f, -0.02020011f, 
    -0.00768783f, 0.00263253f, 0.03527860f, -0.04715410f, -0.00922205f, 0.04102017f, -0.03548495f, -0.03195465f, 
    -0.05644339f, 0.01196463f, 0.01538458f, 0.03607744f, -0.03837772f, -0.04699404f, -0.05725573f, -0.03284975f, 
    -0.02613169f, -0.03386465f, -0.01767299f, -0.01619341f, -0.03635389f, 0.03428913f, 0.01225998f, -0.03153895f, 
    -0.02520516f, 0.00004428f, 0.01026367f, 0.01133442f, -0.03035685f, -0.04195383f, -0.02378302f, -0.05308694f, 
    0.02812603f, 0.00656603f, 0.04115104f, -0.05570635f, -0.00878405f, -0.00714782f, 0.02955547f, -0.01136921f, 
    0.00454042f, 0.03996348f, -0.02453444f, 0.03300382f, -0.04800647f, 0.04085465f, -0.05547595f, 0.03839974f, 
    -0.00871478f, -0.00152121f, -0.01430809f, -0.02073074f, -0.05076603f, -0.05010666f, -0.02958163f, -0.00015092f, 
    -0.00700699f, -0.02167450f, -0.00333715f, -0.03201868f, -0.00876155f, -0.00731335f, -0.03272232f, -0.01992488f, 
    0.14820948f, 0.07079940f, 0.03403283f, 0.12222683f, 0.06936541f, -0.03538470f, 0.12683514f, 0.05338914f, 
    0.00750718f, 0.18505783f, 0.12777953f, 0.00565992f, 0.00832660f, 0.08792066f, 0.16473310f, 0.02660767f, 
    0.10960132f, -0.04346892f, -0.08948354f, -0.03268444f, 0.02759052f, 0.05640472f, 0.10132374f, -0.01757342f, 
    -0.28438833f, 0.19111353f, 0.14956899f, 0.15193518f, 0.01686141f, 0.02816595f, -0.02345054f, 0.01536516f, 
    0.02541278f, -0.06116235f, 0.02938207f, 0.04795210f, 0.09341183f, -0.11273032f, -0.06538868f, 0.04282152f, 
    0.04211526f, -0.13431057f, 0.05580405f, -0.05154229f, 0.06823087f, -0.08233661f, 0.02037576f, 0.01741905f, 
    0.19147035f, 0.10499918f, 0.09640592f, 0.11102656f, -0.13707697f, -0.01471778f, 0.00595171f, 0.03498072f, 
    0.01433857f, 0.05650983f, -0.01369980f, -0.01891564f, -0.05999541f, 0.05735342f, -0.04342733f, 0.06678043f, 
    0.00935132f, -0.00536809f, -0.03969814f, 0.07841107f, 0.03190865f, -0.10895664f, 0.10347231f, -0.09392060f, 
    -0.18167925f, 0.04021100f, -0.07992259f, 0.11341452f, -0.13020991f, 0.00592909f, 0.16550383f, 0.12336423f, 
    -0.01786277f, 0.01963590f, -0.01144967f, -0.09690557f, -0.10670299f, -0.10227984f, -0.08669423f, -0.02084492f, 
    -0.14987156f, -0.07991436f, 0.09117960f, -0.11017592f, 0.13819681f, 0.00982834f, -0.10363328f, 0.04884490f, 
    -0.10885324f, -0.01777305f, 0.04583216f, 0.06210060f, 0.10417359f, -0.01710483f, 0.01182021f, 0.11296037f, 
    -0.00820759f, -0.02326525f, 0.00259125f, 0.01180993f, 0.24273360f, 0.18912768f, -0.18737844f, -0.07934827f, 
    0.07878369f, 0.01259898f, -0.01318212f, 0.08363472f, -0.03314718f, -0.01207058f, 0.20201035f, -0.09408636f, 
    0.11254401f, -0.26277694f, 0.01575193f, 0.04967494f, -0.06142722f, 0.10451871f, 0.00270783f, 0.08510023f, 
    0.07343299f, -0.02255523f, 0.06637995f, -0.01975889f, 0.18274064f, -0.02872612f, 0.21473151f, 0.13233504f, 
    -0.02717672f, 0.06872022f, 0.01488644f, -0.02360076f, 0.15518737f, 0.08866849f, 0.04600467f, -0.02726925f, 
    0.15568501f, 0.12179181f, -0.06555289f, -0.02248283f, 0.02832586f, 0.14065564f, -0.07925721f, -0.07230179f, 
    0.00337827f, 0.10165887f, 0.02095740f, 0.14648806f, -0.17190504f, -0.20642740f, 0.14565936f, -0.23316692f, 
    -0.01091457f, -0.11939230f, 0.07184184f, -0.02355988f, 0.11821031f, 0.02631490f, -0.06582993f, 0.05739366f, 
    0.23007470f, 0.30798438f, -0.03584027f, 0.02858048f, -0.03188941f, 0.10912133f, 0.08210820f, 0.12752733f, 
    0.05921473f, 0.01504810f, 0.06322449f, 0.11514143f, 0.07105955f, -0.15007803f, -0.10845362f, 0.12423007f, 
    0.00046377f, -0.08288894f, -0.07656714f, 0.06814945f, 0.06975149f, -0.16572928f, 0.05206305f, 0.10736221f, 
    0.07180883f, -0.02496348f, -0.26859149f, -0.13307206f, 0.11454695f, 0.06343858f, 0.14729895f, -0.01179320f, 
    0.02273676f, -0.08630165f, 0.07718767f, 0.07852722f, -0.04098822f, -0.07807167f, -0.07794669f, -0.02418230f, 
    0.00271687f, 0.07362735f, -0.03939745f, -0.03318458f, 0.05966148f, 0.09427138f, 0.06594444f, 0.10411812f, 
    0.38037413f, 0.02458835f, 0.14965859f, 0.03758099f, -0.01106028f, -0.02794691f, 0.08353762f, -0.13220412f, 
    0.11779942f, 0.02466371f, 0.04961203f, -0.05109131f, 0.33190709f, -0.16746251f, -0.09926786f, -0.13354044f, 
    0.04945908f, -0.00901838f, -0.05675413f, 0.01900631f, -0.01484163f, 0.12233349f, 0.07093515f, 0.01281719f, 
    -0.16367584f, 0.12789074f, -0.09643810f, -0.26417676f, 0.08444136f, 0.05765151f, 0.02260114f, -0.04106997f, 
    0.10329715f, 0.10432614f, -0.03425970f, 0.07587741f, 0.35538369f, -0.30161172f, 0.02128973f, 0.07535072f, 
    -0.04480097f, -0.04816527f, 0.14697562f, 0.12792425f, -0.00994217f, -0.08922425f, 0.02699203f, 0.05301052f, 
    0.05918093f, 0.00832124f, 0.13841659f, -0.04193420f, 0.03173265f, 0.02906224f, 0.03725667f, 0.10806584f, 
    0.13257009f, -0.09370796f, 0.01796171f, -0.02706602f, 0.30031532f, -0.23387644f, 0.11334328f, 0.10999350f, 
    0.06002635f, 0.03194207f, -0.06529275f, 0.17766634f, -0.01372417f, 0.09561769f, -0.02506224f, 0.07836978f, 
    0.02450511f, 0.02759028f, 0.03249192f, -0.03456806f, -0.02174016f, 0.04843248f, -0.06725755f, -0.08304074f, 
    0.15843472f, -0.03529013f, -0.03587801f, -0.00540165f, 0.24900672f, -0.00841867f, 0.01119121f, -0.08195288f, 
    0.00066446f, -0.01587087f, 0.11826915f, -0.03131252f, 0.00090914f, 0.04514636f, 0.19373958f, 0.08070558f, 
    0.02497071f, 0.02282202f, 0.09615287f, 0.08255254f, 0.00338349f, 0.13951927f, -0.06402657f, 0.02775792f, 
    0.10062682f, 0.07214318f, -0.00472617f, 0.00699397f, -0.12599631f, 0.06500625f, -0.04939241f, -0.09648866f, 
    0.01643815f, -0.02069684f, 0.11299313f, 0.01133312f, -0.00505957f, -0.07797763f, 0.05298521f, 0.00848283f, 
    -0.16613652f, 0.17245938f, -0.02525910f, 0.00099839f, -0.05723900f, 0.13085844f, 0.03219842f, 0.03513620f, 
    -0.02060781f, 0.02891414f, 0.12473474f, 0.04996434f, 0.38681111f, -0.16702662f, 0.13280591f, -0.06888320f, 
    -0.00719882f, 0.08732233f, -0.03729092f, 0.00351425f, 0.11492030f, -0.01031510f, 0.14257950f, -0.04095286f, 
    -0.03057688f, -0.07781301f, -0.09043781f, -0.09879546f, 0.04860633f, -0.05466284f, 0.02320592f, -0.01071738f, 
    0.00226532f, -0.15514345f, 0.00838833f, 0.08755299f, 0.04003910f, -0.14885524f, -0.08588146f, -0.16062425f, 
    0.01678937f, -0.00312606f, 0.05553691f, 0.06908114f, 0.07837976f, 0.07301997f, -0.02333437f, -0.08351750f, 
    0.02764749f, -0.01090929f, -0.04035307f, 0.03777472f, 0.01149937f, 0.02202396f, 0.02596144f, 0.04185328f, 
    0.02171335f, 0.01898901f, -0.05087332f, -0.04485545f, -0.04590117f, 0.01516398f, 0.01966598f, -0.03667202f, 
    -0.00818095f, 0.00081141f, -0.00319427f, 0.03160495f, 0.03198595f, -0.03042418f, -0.02112089f, 0.00176895f, 
    -0.02202514f, 0.04262676f, -0.05345815f, -0.02673610f, -0.04877617f, 0.01016443f, -0.01030683f, -0.00309912f, 
    -0.03132011f, 0.00479527f, 0.03053918f, 0.01688246f, 0.02392987f, 0.03928564f, -0.01409989f, -0.01171310f, 
    -0.00326047f, 0.01867805f, -0.02405250f, 0.01051043f, 0.03951827f, 0.00223072f, -0.01334125f, -0.05362889f, 
    -0.04675436f, 0.02048628f, -0.00344278f, 0.03353806f, 0.00620838f, 0.03978927f, 0.01910583f, 0.00113829f, 
    -0.04039526f, 0.03504498f, 0.02753717f, -0.03153959f, -0.03574863f, -0.04432473f, -0.03089232f, -0.02498890f, 
    -0.02458968f, -0.05284235f, -0.04184583f, -0.00852157f, -0.02484293f, -0.04097876f, 0.02649471f, -0.02149847f, 
    0.00955967f, -0.03358170f, -0.03541129f, 0.03898289f, 0.01202296f, 0.01977318f, -0.00887526f, 0.03627859f, 
    0.00981072f, 0.02106084f, -0.03442635f, 0.01717223f, -0.00167622f, -0.00392155f, 0.01296484f, -0.01233142f, 
    0.04623608f, -0.04939187f, 0.02118030f, 0.01589526f, -0.03256783f, 0.03283272f, 0.03221930f, 0.01790731f, 
    0.03234972f, -0.02621833f, 0.03120673f, 0.02649722f, -0.00185906f, 0.03887257f, -0.02886074f, -0.03108838f, 
    0.04352716f, -0.04396756f, 0.04426655f, -0.01464883f, -0.04226134f, -0.02355856f, -0.03421666f, -0.04300053f, 
    0.03869025f, -0.03453645f, -0.03187155f, -0.05198172f, -0.01171885f, 0.01480439f, 0.04199482f, 0.01132625f, 
    -0.01027931f, 0.02007793f, -0.01555647f, -0.04041495f, -0.03519114f, -0.01035567f, 0.02144995f, -0.04937781f, 
    -0.00873828f, 0.04184058f, -0.00695635f, -0.05399603f, 0.02184155f, -0.01287225f, -0.01988316f, -0.04383815f, 
    -0.02939206f, 0.04242304f, 0.02234347f, -0.05417086f, 0.02354583f, 0.04034829f, 0.03961135f, -0.01105973f, 
    0.00621195f, 0.00740312f, -0.03119974f, 0.04006834f, -0.03091680f, -0.02009801f, 0.00558587f, -0.03846297f, 
    -0.05076664f, 0.02169402f, -0.05333746f, -0.00747957f, 0.01762180f, -0.04776670f, 0.02907778f, -0.03359448f, 
    0.02909369f, -0.00172505f, 0.01219701f, 0.03852326f, -0.03584960f, -0.00350649f, -0.04820191f, 0.01297535f, 
    -0.05464834f, -0.00230544f, 0.00433381f, 0.00470987f, 0.01777208f, -0.02777893f, 0.00202255f, 0.03222724f, 
    0.01180790f, -0.02050969f, -0.03795571f, 0.04449799f, -0.05142244f, -0.03868627f, 0.00660015f, -0.00178960f, 
    0.01731762f, 0.00860912f, -0.05444848f, -0.03504283f, -0.02250456f, -0.00998743f, 0.00545346f, -0.01258741f, 
    -0.05275952f, 0.00009842f, -0.05116868f, -0.01588936f, 0.02529434f, 0.02242140f, -0.01429364f, 0.00641790f, 
    -0.01918633f, -0.00775454f, -0.02721880f, -0.00455430f, 0.01983368f, 0.00370547f, -0.02515335f, 0.03585428f, 
    -0.03126509f, -0.00314893f, -0.01002044f, -0.01183322f, -0.01017952f, -0.04301995f, 0.04161527f, -0.00024662f, 
    -0.01926071f, -0.02907210f, 0.00585949f, 0.04185555f, 0.04454521f, -0.03654184f, -0.01026258f, -0.03837816f, 
    -0.02141807f, -0.01635012f, -0.01002240f, 0.02724425f, -0.03225157f, -0.02645803f, 0.01763165f, -0.05757183f, 
    -0.05106817f, -0.01964195f, -0.01553512f, 0.01399053f, 0.03279887f, -0.03450334f, 0.04597123f, -0.03106200f, 
    -0.05318673f, -0.03611862f, 0.03595925f, -0.02305949f, -0.02455984f, -0.04166229f, -0.02131926f, 0.04494874f, 
    -0.01899297f, 0.04333761f, 0.03173021f, -0.04785258f, 0.02984454f, -0.02458053f, 0.01364514f, 0.02684322f, 
    0.02922023f, 0.00890829f, -0.05089269f, -0.05430856f, -0.04942399f, 0.03782089f, -0.03168142f, 0.03309314f, 
    -0.03046629f, 0.03777229f, -0.03390384f, -0.00482756f, 0.04513541f, 0.02441262f, 0.01051032f, -0.04330837f, 
    -0.02804620f, -0.00751743f, -0.05222039f, 0.00441043f, 0.03696760f, -0.02317835f, 0.02006738f, -0.04660740f, 
    -0.00573163f, -0.05205054f, -0.03440517f, -0.05029770f, 0.03094795f, -0.04016928f, -0.00352169f, 0.03525099f, 
    0.03357410f, 0.03300945f, 0.01621385f, 0.01806810f, -0.00764767f, -0.00470602f, -0.03442485f, 0.00933929f, 
    0.03141811f, -0.05507218f, -0.04660710f, -0.00981290f, -0.02431639f, -0.01949527f, -0.05081995f, 0.00234436f, 
    -0.01782062f, 0.03680378f, -0.02512096f, -0.02681899f, 0.01932813f, 0.01288269f, 0.02482711f, -0.04962688f, 
    -0.02955743f, 0.02402302f, -0.03533056f, -0.01557585f, 0.04086370f, 0.02118232f, -0.01062984f, -0.02350875f, 
    -0.04015975f, 0.03848442f, -0.02723128f, -0.00875007f, -0.02831243f, -0.03418888f, -0.01348308f, -0.00141888f, 
    0.04273537f, 0.03448417f, -0.04174386f, -0.03410406f, -0.05603605f, 0.01760668f, 0.01096402f, -0.02117431f, 
    -0.02540895f, -0.03651836f, 0.02688542f, -0.02779323f, -0.05025483f, -0.02525453f, 0.00705832f, 0.01871617f, 
    -0.01199476f, 0.00130534f, -0.01266612f, 0.00430275f, -0.01669846f, 0.03392925f, -0.01244221f, 0.03199205f, 
    0.02035190f, 0.02834529f, -0.04797733f, -0.00529420f, -0.03665621f, -0.00302052f, -0.01925681f, 0.03430130f, 
    0.03574975f, -0.05120162f, -0.05535249f, -0.05060313f, -0.01820931f, 0.02968771f, -0.01522777f, 0.00149752f, 
    0.02778818f, 0.03229887f, -0.03739523f, -0.02486511f, -0.00697493f, 0.00842359f, 0.01404174f, 0.00363747f, 
    0.01498763f, -0.04292898f, 0.01385840f, 0.03111815f, -0.05460509f, 0.02445780f, 0.00046719f, 0.01115236f, 
    0.11235639f, 0.20297535f, 0.04132284f, 0.15287474f, 0.02503913f, 0.10544994f, 0.04511422f, -0.14348249f, 
    -0.04675458f, 0.04131873f, 0.21673585f, 0.00256885f, -0.00755001f, 0.25954962f, 0.00982845f, 0.12431330f, 
    -0.04203261f, 0.12848668f, 0.01721579f, 0.02538912f, 0.04054610f, 0.01480283f, -0.10330997f, -0.02815652f, 
    0.04639041f, 0.29834446f, 0.03639901f, -0.00495958f, -0.04744162f, -0.00842957f, 0.01316387f, 0.17394894f, 
    0.01142843f, -0.06293901f, 0.11099257f, -0.03602192f, 0.19832109f, 0.04709678f, -0.05069620f, 0.10438049f, 
    0.09593491f, -0.14116971f, 0.07035524f, -0.00741817f, 0.08365048f, -0.02161443f, 0.04997186f, 0.10689769f, 
    0.19183154f, 0.14996931f, 0.23844615f, 0.20104060f, -0.17129864f, 0.02177070f, 0.09371533f, 0.03123859f, 
    0.08620235f, 0.02663253f, 0.03760131f, -0.04704978f, -0.08543136f, -0.03680208f, -0.06315068f, -0.07116927f, 
    0.02255876f, -0.03903705f, -0.04633716f, -0.07914391f, -0.21367417f, 0.01462195f, -0.03376130f, 0.04996464f, 
    -0.01736612f, -0.15051767f, -0.23438890f, 0.20252100f, -0.05602793f, -0.02097796f, 0.13028885f, 0.22330846f, 
    0.00314168f, 0.00053721f, -0.05899377f, -0.19163154f, 0.20517682f, 0.03564946f, -0.05226267f, 0.15637818f, 
    -0.02609078f, -0.10682897f, 0.19135951f, -0.02976304f, 0.03481515f, 0.07898824f, -0.01437948f, 0.25793579f, 
    -0.17603001f, -0.12958780f, 0.08231021f, -0.04076888f, -0.04582237f, -0.00938276f, 0.13388248f, 0.16438825f, 
    -0.11582068f, -0.17247443f, 0.05173094f, 0.00367004f, 0.23514937f, -0.05225676f, -0.20497178f, -0.15896195f, 
    0.00693531f, 0.05153565f, -0.05822928f, 0.07993206f, 0.01483697f, -0.02298900f, 0.04284758f, -0.14500399f, 
    0.29295096f, -0.16347013f, 0.05574986f, 0.11978586f, -0.05363121f, 0.18382582f, 0.01897480f, 0.12144241f, 
    -0.02872000f, -0.01910741f, 0.11045888f, 0.08676579f, 0.01961526f, 0.19968870f, 0.15202242f, -0.00116287f, 
    -0.07929192f, -0.00495088f, -0.00918412f, -0.06058456f, 0.00524539f, -0.05243850f, -0.04519538f, -0.14310889f, 
    0.38259709f, -0.03457556f, -0.13040446f, -0.09534070f, 0.09778817f, 0.15156700f, -0.04494866f, -0.04676859f, 
    0.05351725f, -0.04346737f, -0.14079155f, -0.04516053f, -0.13412902f, -0.16136692f, 0.07726524f, -0.25984147f, 
    -0.04399075f, 0.16166377f, -0.01468786f, -0.06218218f, -0.00852757f, 0.10582951f, -0.05888936f, 0.11377735f, 
    0.12061863f, 0.20701547f, 0.12720601f, -0.11120901f, -0.03737443f, -0.01882162f, 0.07749674f, -0.05270547f, 
    -0.00842830f, -0.02800782f, -0.17157578f, -0.06094340f, 0.01489561f, -0.19486588f, -0.01130735f, 0.14129175f, 
    0.06886270f, -0.11726105f, -0.06463575f, 0.17203248f, 0.08499151f, -0.07273998f, -0.02495330f, -0.02734829f, 
    0.07466530f, -0.18691050f, -0.19439761f, -0.17493986f, 0.05646631f, 0.08309834f, -0.11615827f, -0.05477977f, 
    -0.01265282f, -0.13702647f, 0.07287517f, -0.05000585f, -0.07287432f, 0.01666889f, 0.08976667f, -0.13379364f, 
    -0.16435432f, -0.04630321f, 0.03472268f, -0.01039135f, -0.08858275f, -0.08514068f, 0.02869239f, -0.00454311f, 
    0.54971349f, -0.00089621f, 0.06956512f, 0.20072602f, -0.16485369f, 0.00810700f, -0.04267994f, -0.06802575f, 
    0.06270027f, 0.04233333f, 0.09852620f, -0.07870307f, 0.46859077f, -0.11510098f, 0.11605771f, -0.20970392f, 
    0.15304570f, -0.09215616f, -0.13922614f, 0.13723077f, -0.01628048f, 0.18461223f, 0.04989149f, 0.07202753f, 
    -0.16663450f, -0.07768544f, -0.09213152f, -0.24657649f, 0.03885120f, 0.04299680f, -0.19126371f, 0.02479933f, 
    0.15728872f, 0.07798906f, 0.09436838f, 0.00971136f, 0.53432429f, -0.29128671f, 0.03734005f, 0.03343869f, 
    -0.18030496f, 0.06019901f, 0.10087547f, -0.03659565f, -0.16553767f, 0.02701347f, -0.05978630f, 0.09715251f, 
    0.00238525f, 0.08632360f, 0.27793777f, -0.02309817f, -0.09868935f, 0.04387502f, 0.08907227f, 0.01670798f, 
    -0.00228348f, -0.17044157f, -0.04661884f, 0.05666427f, 0.25528735f, -0.07640680f, 0.06237376f, 0.28307500f, 
    -0.05803179f, 0.17506111f, 0.04325014f, 0.12987952f, -0.04192940f, 0.00751709f, 0.15035155f, 0.09620833f, 
    -0.08033317f, 0.05074344f, -0.15954569f, 0.25759169f, 0.15319660f, 0.05933303f, -0.13828720f, 0.09655787f, 
    0.06035955f, 0.02906009f, -0.04235617f, -0.07678249f, 0.03969204f, -0.02746213f, 0.11862840f, -0.14021662f, 
    -0.06779251f, 0.05733256f, 0.22909953f, 0.02247268f, -0.06291831f, 0.04281456f, 0.09725670f, -0.10628571f, 
    0.16602892f, 0.12330773f, -0.06293684f, 0.00864923f, 0.07457780f, 0.13867050f, -0.11021953f, 0.10358891f, 
    0.07828242f, 0.02491906f, -0.04942364f, -0.02904329f, -0.23593040f, -0.22736332f, 0.10377119f, -0.36507571f, 
    -0.00736903f, 0.03593011f, 0.06500724f, -0.02526048f, -0.06893711f, 0.02352175f, 0.01283639f, -0.06097000f, 
    -0.03380684f, 0.21058445f, -0.11443572f, -0.10704058f, -0.14513399f, 0.02750456f, -0.01188272f, -0.01568005f, 
    -0.08851508f, 0.03908794f, -0.12501521f, 0.07350022f, 0.19945781f, -0.01555782f, 0.11943541f, 0.16547956f, 
    -0.03794704f, 0.09836704f, 0.04787917f, -0.13990141f, -0.07291343f, -0.10040604f, 0.06192803f, -0.14545749f, 
    -0.12730779f, -0.20399140f, 0.02898901f, -0.02744513f, 0.11537977f, -0.08982664f, -0.02058584f, 0.01301683f, 
    0.04403646f, 0.01492807f, 0.00799118f, 0.07471650f, -0.15545265f, -0.18476157f, 0.07882779f, -0.44340515f, 
    -0.03914338f, 0.04099409f, 0.06881306f, 0.01474598f, -0.09451663f, 0.03451441f, 0.02386263f, 0.05070332f, 
    -0.18044062f, 0.08159783f, 0.16665801f, 0.25371343f, 0.08572090f, -0.20925361f, 0.13317147f, 0.16583174f, 
    0.07363096f, 0.23966928f, -0.03115025f, -0.09678525f, 0.04831067f, -0.02214206f, 0.14517738f, 0.03326122f, 
    0.07569589f, -0.09468976f, 0.04497547f, -0.04134577f, -0.06128698f, 0.06566447f, 0.16663158f, 0.14810054f, 
    -0.14616290f, -0.03036053f, 0.27933541f, 0.24381103f, 0.08942682f, 0.03461147f, 0.08656834f, -0.14813717f, 
    0.04900282f, -0.00630912f, 0.03656660f, 0.09698635f, 0.09266635f, -0.30864662f, -0.08752172f, -0.16788089f, 
    -0.00090037f, 0.06228068f, -0.04938588f, -0.12332482f, 0.08016486f, -0.15572990f, -0.14019835f, -0.04621504f, 
    -0.02179033f, 0.02125114f, 0.01785137f, -0.04291840f, -0.09751534f, -0.02717687f, -0.04756197f, 0.04843608f, 
    -0.05793581f, 0.03410364f, -0.17015816f, 0.15194911f, 0.16187596f, -0.04044094f, 0.12379292f, 0.19962904f, 
    -0.00002813f, 0.04737794f, -0.02383610f, 0.20380603f, 0.15548946f, -0.11174364f, 0.16422062f, -0.18462570f, 
    -0.20788965f, 0.10683215f, -0.13135327f, -0.15758520f, 0.06722342f, -0.08002491f, 0.03297327f, 0.01973246f, 
    0.03150294f, 0.17847480f, 0.19176270f, 0.15017356f, -0.29153883f, -0.08532733f, -0.18112870f, -0.06769218f, 
    -0.16026686f, 0.00030327f, -0.07706460f, -0.01396230f, -0.02505285f, 0.08856507f, -0.00528098f, -0.05506758f, 
    0.24107251f, -0.28525969f, 0.12754981f, 0.18170129f, 0.07095917f, 0.05500633f, 0.00478897f, 0.00526027f, 
    0.00962280f, 0.10008921f, -0.03952075f, 0.06419160f, 0.01291758f, 0.28456101f, 0.02187072f, 0.06594848f, 
    0.05131483f, 0.01989124f, -0.16164197f, 0.03629913f, 0.00444213f, 0.07222952f, 0.24447507f, 0.09714846f, 
    -0.31800306f, 0.23336494f, -0.04465023f, 0.14087494f, 0.01061761f, 0.04036365f, -0.14837016f, 0.02289885f, 
    0.06330647f, 0.02611093f, 0.11321224f, -0.14398101f, 0.20021701f, -0.04821379f, 0.32364511f, 0.12110110f, 
    -0.00140770f, 0.11362921f, 0.04509423f, 0.05264263f, 0.08823791f, 0.06766685f, 0.05012305f, 0.17213388f, 
    -0.34581035f, 0.27373958f, -0.05334348f, -0.11225498f, 0.04599548f, 0.10788374f, -0.06162533f, 0.10805088f, 
    0.04232313f, 0.10314079f, 0.26101944f, 0.11641578f, 0.11836231f, -0.42216420f, 0.07898865f, -0.15806210f, 
    -0.05931880f, -0.08957013f, 0.10717698f, 0.15950534f, 0.25482059f, -0.09592403f, 0.01764866f, -0.04625412f, 
    -0.34305501f, 0.15546672f, -0.05916979f, 0.11665054f, -0.15312123f, 0.07925343f, -0.10234156f, 0.11975899f, 
    0.22898656f, -0.01346921f, 0.12254753f, 0.13881288f, 0.03222598f, 0.06424943f, -0.29186043f, 0.03788142f, 
    0.04976964f, 0.01657317f, -0.08379874f, 0.02360317f, 0.01553955f, -0.04929700f, 0.10625786f, 0.10940552f, 
    -0.23537852f, 0.02943380f, -0.22268859f, 0.04122756f, 0.06224519f, 0.07896078f, 0.19964954f, 0.08202687f, 
    -0.03506422f, 0.04461735f, 0.02169861f, 0.09522277f, 0.07933225f, -0.16631758f, -0.16999453f, 0.12949696f, 
    0.13896476f, 0.04189581f, 0.10804293f, -0.01039046f, 0.08994432f, 0.20478721f, 0.07517192f, 0.09804563f, 
    -0.23209858f, 0.20043446f, -0.19216546f, 0.01000209f, 0.14662442f, -0.04601188f, 0.14095378f, 0.01891560f, 
    -0.03281417f, 0.02136127f, -0.09319004f, 0.06634899f, -0.12176686f, -0.11259286f, -0.23619375f, -0.14974669f, 
    -0.07157491f, 0.02667225f, -0.03073881f, -0.02041729f, 0.06158553f, 0.05264481f, 0.08721481f, 0.01333246f, 
    -0.00828807f, -0.03047000f, 0.04279863f, -0.04385781f, 0.14223348f, -0.01778041f, 0.15675095f, -0.08744246f, 
    0.09447893f, -0.09347526f, 0.01355763f, 0.07672806f, -0.01058366f, -0.24798422f, -0.00802606f, 0.07189951f, 
    -0.01344818f, -0.04959339f, -0.01807375f, 0.00005444f, -0.04131348f, -0.19160475f, -0.01421380f, -0.09162065f, 
    0.00738288f, -0.15654707f, 0.07606782f, 0.06211791f, 0.01369303f, 0.05678220f, 0.05623151f, 0.10955015f, 
    0.08610913f, -0.01770227f, 0.07705494f, 0.00790973f, 0.17433226f, -0.05583814f, 0.15777855f, -0.02310809f, 
    0.02002703f, -0.09579076f, 0.04907556f, 0.10838039f, 0.14923817f, 0.07660829f, -0.09320956f, 0.16514693f, 
    0.03434735f, 0.09455536f, -0.02038461f, -0.16529134f, -0.10445677f, -0.04760056f, 0.07233167f, -0.04639190f, 
    0.17946404f, 0.01434406f, 0.05539485f, 0.08933357f, 0.22923712f, -0.33057559f, -0.08401401f, 0.05266109f, 
    0.12811248f, -0.00754090f, 0.09386921f, 0.06189398f, 0.13957082f, -0.04055697f, 0.16016200f, -0.00622197f, 
    -0.18926822f, 0.09924047f, 0.15115488f, 0.11245960f, -0.02302094f, 0.10218673f, 0.02266499f, 0.07380638f, 
    0.14004734f, 0.04408723f, 0.06478389f, -0.00944237f, 0.18520118f, -0.12852700f, -0.02577043f, 0.28358227f, 
    -0.05373226f, 0.15052702f, 0.10241518f, 0.01901068f, 0.15449013f, 0.04405107f, 0.02692904f, 0.22613552f, 
    0.05528465f, 0.04565123f, -0.03427636f, 0.03711109f, -0.11595559f, 0.13995694f, 0.00126839f, 0.13650559f, 
    0.01352420f, 0.17252730f, 0.25775424f, 0.10989123f, 0.05944118f, -0.03261200f, 0.10260975f, -0.16643304f, 
    0.01583154f, 0.10052625f, -0.02094107f, 0.14358887f, 0.08079726f, -0.05792543f, 0.18651600f, 0.05634569f, 
    0.08265055f, 0.11681228f, -0.19016340f, -0.21971737f, 0.03050455f, 0.10690098f, 0.01866124f, -0.12280097f, 
    -0.09371822f, -0.30015564f, 0.06059463f, -0.02497849f, -0.02049885f, -0.11160100f, 0.00069114f, 0.26466647f, 
    0.03430363f, 0.06866288f, 0.08303211f, 0.11153151f, 0.03771905f, 0.06605611f, 0.09110056f, 0.02034093f, 
    0.03757852f, 0.04052403f, 0.00418176f, -0.04224588f, 0.02120054f, -0.01269755f, 0.03989283f, 0.01071032f, 
    0.01008811f, 0.00664398f, -0.01244210f, -0.03841152f, 0.03067839f, 0.03210559f, -0.01848388f, 0.00641516f, 
    0.01938154f, 0.00826419f, 0.02232256f, -0.02906608f, -0.04398776f, -0.05142384f, 0.03071537f, 0.01034998f, 
    -0.02238432f, -0.04528950f, -0.02870193f, -0.03342735f, -0.03687391f, -0.05330948f, 0.03607042f, -0.03138786f, 
    0.02330215f, -0.01139852f, -0.03206725f, -0.04934124f, -0.02980296f, -0.05280090f, -0.04177145f, 0.01954923f, 
    0.01372307f, -0.04320474f, 0.00144812f, 0.02175429f, -0.04913722f, 0.04397605f, 0.03676773f, -0.03381952f, 
    0.03540766f, 0.02282904f, 0.01373411f, -0.02660852f, 0.04398743f, -0.02206124f, 0.04323497f, -0.02631913f, 
    0.05105962f, -0.00056039f, 0.04114985f, -0.03427215f, 0.01421581f, 0.01671715f, -0.01892454f, 0.00214362f, 
    -0.03844573f, 0.01069689f, -0.02458187f, 0.00121608f, 0.02612674f, 0.04711762f, 0.04358482f, -0.02422358f, 
    0.01854830f, -0.01479316f, 0.01115238f, -0.04938770f, -0.00904008f, -0.05407711f, -0.05607622f, -0.00837401f, 
    0.01869366f, -0.00130585f, -0.01944339f, -0.05080085f, 0.02921135f, -0.02356634f, 0.03608925f, -0.03105321f, 
    0.03673103f, -0.02918035f, 0.00417865f, 0.01479307f, -0.02225136f, 0.03086079f, -0.04069298f, -0.00430118f, 
    -0.00157532f, -0.02449308f, -0.00692643f, 0.03034691f, 0.00783262f, -0.03955742f, -0.04355673f, -0.03343111f, 
    -0.00753831f, 0.01996737f, -0.04283135f, 0.01937045f, -0.04653133f, 0.01745789f, -0.04526262f, 0.05073477f, 
    -0.01741103f, -0.02345996f, 0.02171166f, -0.02719791f, 0.03552549f, 0.01474156f, 0.02213717f, -0.02428649f, 
    0.03823843f, -0.04481007f, -0.02019336f, 0.04283690f, 0.02198678f, -0.02891977f, -0.04432843f, -0.03160199f, 
    -0.01585222f, -0.04046168f, -0.02721186f, -0.01255882f, -0.01916823f, 0.03572093f, 0.04060321f, 0.04701862f, 
    -0.05128836f, 0.04148876f, -0.04715600f, 0.02858763f, -0.01857626f, 0.03177199f, 0.02797683f, -0.03162494f, 
    -0.00689100f, -0.01071551f, -0.00125432f, -0.00824112f, 0.01695924f, -0.01471181f, -0.03307663f, 0.01222070f, 
    0.03449598f, 0.01335054f, 0.02834009f, -0.00989268f, 0.02580762f, -0.03372131f, 0.01638182f, -0.01143692f, 
    -0.00209670f, 0.01054358f, -0.02366654f, 0.02513559f, 0.00780238f, -0.00439657f, 0.03554720f, -0.00151796f, 
    -0.00185537f, -0.01092131f, 0.00840525f, -0.03863395f, -0.04316660f, 0.03903010f, -0.03976124f, -0.01942306f, 
    -0.00085452f, -0.02147704f, -0.03484075f, 0.04372583f, 0.02156749f, -0.02889328f, 0.00683949f, 0.00286209f, 
    -0.05021634f, 0.00393523f, -0.00109716f, -0.04124609f, -0.03966249f, -0.02857022f, -0.00602800f, 0.01559074f, 
    0.04464365f, -0.05122314f, -0.00382404f, 0.00139640f, 0.02500148f, -0.05134064f, -0.05195036f, -0.00602938f, 
    -0.02741032f, -0.04020939f, 0.03407170f, -0.03752512f, 0.00445341f, 0.01232228f, -0.00140704f, 0.00978684f, 
    -0.05022946f, 0.03941756f, 0.00500376f, 0.01728883f, 0.01344977f, 0.01997700f, -0.03367598f, 0.03473600f, 
    -0.03475624f, -0.02649443f, -0.04277036f, 0.00526929f, -0.02359174f, -0.02961043f, 0.03604843f, -0.03447548f, 
    0.02212105f, -0.05545357f, 0.03133869f, 0.03473184f, 0.03524912f, -0.00755033f, -0.05121232f, -0.02432669f, 
    0.00942341f, 0.04342117f, 0.00136395f, -0.01056498f, -0.00688983f, 0.02527304f, -0.00753193f, -0.02224411f, 
    -0.04410175f, 0.04260897f, -0.03286241f, 0.04020051f, 0.04134758f, -0.00707545f, 0.01880354f, -0.04675191f, 
    0.00789433f, -0.02036287f, -0.01367870f, -0.04233206f, -0.00584848f, 0.04069137f, -0.02683394f, 0.01928182f, 
    0.04280068f, -0.00978857f, -0.00505684f, -0.01771864f, -0.03312367f, -0.01369752f, 0.03327375f, -0.03894044f, 
    -0.05476197f, -0.04842322f, 0.04591688f, 0.01263127f, -0.02800330f, -0.04904673f, -0.03104504f, -0.05763034f, 
    -0.00027053f, -0.01195267f, -0.02607695f, -0.02851094f, -0.04270466f, 0.02350926f, 0.00362627f, -0.04176922f, 
    -0.03212253f, 0.01667546f, 0.03486940f, 0.04066581f, 0.04777763f, -0.00562592f, -0.04828393f, -0.02500719f, 
    -0.02426202f, -0.00510230f, -0.05349064f, -0.03437145f, -0.03030127f, 0.03382137f, 0.02506790f, 0.02868435f, 
    0.01958483f, 0.01486402f, -0.01666770f, -0.03765339f, 0.04497536f, -0.05279886f, -0.04406244f, 0.04150036f, 
    0.02544707f, -0.04015985f, 0.03159217f, 0.02650470f, -0.05312670f, -0.02688314f, 0.02477434f, 0.00735763f, 
    -0.02463132f, 0.01462228f, -0.02468605f, -0.00863577f, -0.02526017f, 0.01670377f, -0.05556113f, 0.00814712f, 
    0.01746323f, -0.00708702f, 0.03914866f, -0.00738491f, 0.03461458f, -0.01097595f, 0.01633332f, -0.02979622f, 
    0.00482497f, 0.03445010f, 0.04249470f, 0.01413944f, -0.00187212f, 0.01311991f, -0.06130416f, -0.00215252f, 
    0.01372258f, -0.03078208f, 0.02438360f, 0.00616698f, 0.02977455f, -0.01863627f, 0.03990920f, 0.03408280f, 
    0.00516606f, -0.00272142f, -0.00697831f, 0.02175230f, -0.03800964f, -0.03011415f, 0.00873356f, -0.02296753f, 
    -0.01490260f, -0.05412466f, -0.02520508f, -0.03452918f, 0.02298826f, 0.00417924f, -0.02575148f, -0.02012103f, 
    -0.04908092f, -0.02537292f, -0.02058160f, -0.03610351f, -0.01113812f, 0.03712382f, -0.05497910f, -0.01484555f, 
    0.01308876f, -0.01061109f, 0.03260093f, -0.00952697f, -0.01133007f, -0.03100128f, -0.03168781f, 0.03719470f, 
    0.02950121f, -0.02695662f, 0.02139917f, 0.00249853f, -0.04007237f, -0.02633658f, 0.03919138f, 0.01753710f, 
    0.00860693f, -0.05906224f, -0.05020668f, -0.09433950f, 0.13704127f, 0.04166517f, 0.26997793f, 0.06651121f, 
    -0.05251544f, 0.05484961f, 0.10014061f, 0.07523707f, -0.23733145f, 0.06169015f, 0.18631303f, -0.05143922f, 
    0.21153329f, -0.04743170f, 0.00304139f, -0.05482526f, -0.08461089f, 0.08055396f, 0.06174574f, -0.04437430f, 
    -0.25824469f, 0.41055757f, 0.11820684f, 0.36646184f, 0.09658775f, 0.13935001f, -0.02895622f, -0.04542696f, 
    -0.10055786f, 0.02222660f, -0.00470585f, -0.08042816f, 0.28840098f, -0.15812548f, -0.23138483f, -0.05593852f, 
    0.04242125f, -0.01679613f, 0.03178617f, -0.10378819f, -0.00286494f, 0.02311573f, -0.05632284f, 0.07675858f, 
    0.05666720f, 0.03845937f, 0.11246028f, -0.12892403f, -0.00614429f, -0.13296221f, -0.00399274f, -0.05734225f, 
    0.08622406f, -0.03748117f, -0.12200036f, -0.05006911f, 0.07151951f, 0.08338508f, -0.13157168f, 0.30742621f, 
    0.08705579f, -0.03859212f, -0.02938443f, 0.21879409f, 0.07824540f, -0.07184409f, 0.10593947f, -0.00892984f, 
    -0.36885193f, -0.33784884f, -0.02246345f, 0.11407502f, 0.02515204f, -0.04972460f, 0.03953647f, -0.06804888f, 
    0.05469335f, 0.02087213f, -0.00060404f, 0.05146267f, 0.15937133f, -0.36653304f, -0.10175427f, -0.02495418f, 
    0.09669411f, -0.13383456f, 0.09182487f, -0.11167476f, -0.06976662f, 0.04443010f, -0.00256013f, 0.06049058f, 
    -0.06337269f, 0.14936005f, 0.22750166f, 0.10702886f, -0.05263384f, 0.13851039f, 0.03715022f, 0.07701531f, 
    0.03336692f, -0.04169170f, 0.06619536f, -0.00096709f, 0.29058748f, 0.16063502f, -0.11699399f, -0.15224774f, 
    0.13159773f, 0.14822488f, 0.19035427f, 0.06268690f, 0.03461034f, -0.04052679f, 0.12436756f, -0.03176081f, 
    0.51588255f, -0.40525028f, 0.04537397f, 0.12642165f, 0.09543532f, 0.04052697f, -0.07272485f, -0.12881681f, 
    -0.01737324f, -0.04457656f, 0.18189175f, 0.00752907f, -0.02472590f, 0.06180343f, 0.02938805f, -0.09177680f, 
    0.04849709f, 0.11351053f, 0.14488095f, -0.08548542f, -0.05522015f, -0.01346243f, 0.07552182f, 0.07936157f, 
    0.28398195f, -0.17089169f, 0.00228698f, 0.00393752f, 0.09414752f, 0.11402011f, 0.04283112f, -0.11175696f, 
    0.00963512f, 0.09116810f, 0.06269121f, 0.04952467f, -0.22883610f, -0.05138924f, 0.02377681f, -0.02870421f, 
    0.02738222f, -0.04463566f, -0.03378309f, 0.11946026f, 0.22334191f, 0.06330553f, -0.00327765f, 0.08886161f, 
    0.31131801f, 0.16851111f, -0.11021543f, 0.27601668f, 0.13742286f, 0.00336155f, -0.00616644f, 0.06168077f, 
    -0.07866572f, 0.02413583f, 0.11481080f, 0.20008691f, -0.23527764f, -0.20366125f, -0.02502901f, -0.01604438f, 
    0.13306688f, -0.10772178f, -0.02807570f, -0.04400727f, 0.07380861f, -0.07874957f, 0.03420968f, 0.10047725f, 
    0.02332352f, 0.01071371f, -0.06045906f, -0.08098788f, -0.05172496f, -0.04657655f, 0.03393409f, 0.02210100f, 
    0.06331416f, -0.02296289f, 0.02545869f, 0.06594070f, -0.16216932f, 0.01230620f, 0.09258079f, 0.10943162f, 
    -0.00720414f, 0.10822718f, -0.02582442f, 0.05754713f, -0.03557959f, 0.05064850f, 0.02033379f, 0.00444287f, 
    0.34127355f, -0.12263275f, 0.27828223f, 0.05979373f, 0.03753594f, -0.03096908f, 0.16782165f, -0.05038066f, 
    0.05292322f, 0.09454899f, 0.02419617f, -0.09672058f, -0.01066968f, 0.01275885f, -0.17304893f, -0.29726860f, 
    -0.05591210f, 0.18107843f, 0.08452199f, -0.05359986f, 0.11605111f, 0.02703254f, 0.03841871f, -0.14903744f, 
    -0.03449757f, 0.27977744f, -0.05951920f, -0.27976614f, -0.00261092f, 0.01484924f, 0.04458974f, -0.10690592f, 
    0.13877524f, 0.04378939f, -0.05986961f, 0.02410777f, 0.39119157f, -0.16625026f, 0.11741447f, -0.11724018f, 
    -0.11559770f, -0.02807014f, 0.06035888f, 0.08683523f, 0.06563867f, -0.15408759f, 0.02963628f, -0.00863460f, 
    -0.25982425f, 0.09856971f, -0.01603216f, -0.11713470f, 0.00789455f, -0.02882312f, 0.05646363f, -0.04032756f, 
    0.00153175f, 0.07490370f, 0.05358390f, -0.08202814f, -0.16331552f, -0.00247759f, 0.11150744f, -0.12191908f, 
    0.00323257f, -0.08589672f, -0.05279475f, -0.03763922f, -0.00138042f, -0.00363255f, -0.04067117f, 0.08062229f, 
    -0.07117574f, 0.19265237f, 0.14590280f, 0.22123703f, -0.05190292f, -0.01779898f, 0.04049313f, -0.03294261f, 
    0.14500096f, 0.11685874f, -0.03132193f, -0.06547898f, 0.35890689f, 0.31897649f, -0.33106500f, 0.27861214f, 
    -0.01497550f, -0.06204394f, -0.02220631f, 0.14323100f, -0.03351121f, 0.04246394f, 0.05179171f, 0.04819031f, 
    0.13234879f, 0.02485262f, 0.16461101f, 0.09654687f, 0.10189869f, 0.11921784f, -0.10867203f, -0.03024757f, 
    -0.02885128f, -0.10453001f, 0.00834104f, 0.13786632f, -0.07902512f, 0.22441559f, 0.00555369f, 0.01278003f, 
    0.07856078f, -0.08449183f, 0.01847208f, 0.02779466f, -0.07618078f, -0.02857546f, 0.03259656f, 0.04906175f, 
    -0.43382922f, 0.01272983f, -0.09115988f, -0.25860769f, -0.01962108f, 0.02312152f, 0.00536167f, -0.09310286f, 
    0.02342180f, 0.04801350f, 0.24544901f, 0.03738092f, 0.24672100f, -0.26968214f, 0.21238019f, -0.04227088f, 
    0.22625926f, -0.03307464f, -0.02118026f, -0.03425330f, -0.01639637f, -0.10558452f, 0.03621222f, -0.05618718f, 
    -0.03358655f, -0.02427669f, 0.03374929f, -0.15905601f, 0.00729395f, 0.06690913f, -0.08666891f, -0.03942989f, 
    -0.06143909f, -0.16302390f, 0.06329096f, 0.08597061f, 0.12133270f, -0.11895046f, -0.05371366f, 0.35250676f, 
    -0.04175365f, 0.10039068f, -0.12955223f, 0.19556163f, -0.07712711f, 0.05700578f, -0.04455186f, -0.00646461f, 
    -0.02854199f, -0.18251173f, 0.02451832f, 0.15531419f, 0.07661593f, 0.06181555f, 0.00328861f, 0.02147627f, 
    0.02199315f, -0.00014987f, -0.09843523f, 0.04266598f, -0.05439304f, -0.25111070f, 0.04543998f, 0.14379022f, 
    0.35296929f, -0.04223935f, -0.04523397f, -0.08666255f, -0.10784749f, -0.14844711f, 0.19460870f, -0.01107620f, 
    0.03086780f, -0.08998254f, -0.11093325f, 0.03402439f, 0.06702963f, -0.04180337f, 0.01700960f, -0.05508411f, 
    0.06713624f, -0.05648962f, -0.05990970f, 0.01392679f, 0.10450273f, -0.04084751f, 0.11252833f, 0.25814420f, 
    -0.08217582f, -0.02347545f, -0.07642407f, 0.11333422f, 0.03327699f, 0.02603269f, -0.28856608f, -0.05541043f, 
    0.23022148f, -0.05447425f, -0.03781611f, 0.12856397f, -0.08891749f, 0.07456928f, 0.04699680f, -0.04893800f, 
    0.01895057f, -0.04553462f, -0.04986276f, -0.18317276f, 0.00206994f, 0.12898859f, -0.13392641f, 0.14247803f, 
    0.00792364f, -0.09364069f, 0.03721323f, 0.16573088f, 0.12625685f, -0.10112182f, 0.03883790f, 0.07723946f, 
    -0.05398517f, 0.27702808f, 0.26466185f, -0.05233763f, -0.01205229f, -0.00238765f, 0.02397352f, 0.10105870f, 
    0.01651725f, 0.06970830f, 0.04756005f, 0.10510341f, 0.01104829f, -0.07782896f, 0.05129045f, 0.19710636f, 
    -0.08069013f, -0.24552068f, -0.03873346f, 0.04870338f, 0.05822441f, -0.10244751f, -0.13126291f, -0.19247101f, 
    0.21308577f, -0.00246277f, -0.09489156f, -0.02823646f, 0.11796720f, -0.10364353f, -0.07316370f, -0.00172988f, 
    0.01385278f, 0.23034824f, -0.19928549f, -0.10490284f, -0.18199585f, -0.07242564f, 0.01322144f, 0.08073398f, 
    -0.01111296f, -0.01568318f, -0.05126245f, 0.15310933f, -0.13093334f, 0.04137230f, 0.19439162f, -0.11427309f, 
    -0.05595523f, 0.06390715f, 0.03589232f, -0.08561584f, -0.06030124f, -0.13992284f, -0.17276426f, 0.07712483f, 
    -0.06749738f, -0.02571546f, 0.12531798f, -0.10353917f, 0.03125591f, -0.23600577f, 0.06104598f, 0.22837748f, 
    0.19162339f, 0.09466295f, -0.06148640f, -0.04073474f, -0.12536065f, 0.08514639f, 0.02851688f, -0.00706261f, 
    -0.06548610f, -0.13023075f, -0.03068972f, -0.14020365f, 0.01435696f, -0.05579041f, -0.10628752f, -0.17623532f, 
    -0.05067878f, 0.26034454f, 0.09100670f, 0.04698918f, -0.05067333f, 0.06945658f, 0.12095917f, 0.21130507f, 
    -0.15093741f, -0.08428627f, -0.07360189f, 0.04835364f, 0.09438346f, 0.03844806f, 0.00300005f, -0.12372924f, 
    0.17991322f, -0.10318489f, -0.13375954f, -0.00776473f, 0.04475958f, 0.11303227f, -0.04017736f, 0.09562156f, 
    0.10149380f, -0.09625979f, 0.31379801f, 0.06899735f, 0.11277578f, -0.01058014f, -0.00931844f, 0.15607682f, 
    -0.10697965f, -0.02964910f, -0.12929724f, 0.01880128f, -0.13584295f, -0.20362045f, 0.20460185f, 0.05661932f, 
    -0.04937325f, 0.15680289f, -0.03417376f, -0.03661053f, 0.01268496f, 0.13461500f, 0.13634078f, -0.13220963f, 
    0.03373635f, 0.01229244f, 0.05203627f, 0.21148442f, -0.30032286f, 0.35056391f, 0.02701247f, -0.11633250f, 
    0.31458101f, -0.01488944f, 0.04979626f, 0.11515177f, 0.17665021f, 0.15718909f, -0.09197340f, 0.20094503f, 
    0.16182831f, -0.14077272f, 0.05308831f, -0.06769451f, 0.03552168f, -0.13743818f, 0.01648484f, 0.03863076f, 
    -0.13635962f, -0.00987375f, -0.12127878f, 0.10542062f, -0.26680759f, -0.00336685f, 0.13194045f, 0.27351415f, 
    0.03021937f, -0.14128299f, 0.10718638f, 0.09003213f, -0.09885324f, -0.05632247f, 0.10483080f, -0.01717108f, 
    -0.13035665f, 0.26468873f, -0.01629825f, -0.00241240f, 0.14733851f, 0.06234673f, 0.12511873f, -0.02212532f, 
    -0.02830871f, 0.09375416f, -0.05482015f, 0.07556042f, 0.45857456f, 0.23020598f, -0.13087085f, 0.07525283f, 
    -0.08570606f, 0.07570552f, -0.04167217f, 0.28428021f, -0.08157821f, 0.01130018f, -0.12481609f, -0.04136701f, 
    -0.00160329f, -0.26480487f, -0.22963673f, 0.19169058f, 0.15558012f, -0.05783236f, -0.04370131f, 0.06027090f, 
    0.04354300f, 0.08230948f, -0.07669780f, -0.04975700f, 0.29279158f, -0.17004852f, -0.00149799f, 0.06070498f, 
    -0.04239108f, -0.13060686f, 0.02529071f, -0.14577779f, 0.03204139f, 0.13014098f, -0.10086070f, 0.11505466f, 
    -0.10770410f, -0.09265962f, 0.22336257f, -0.06423856f, 0.05108185f, -0.27847493f, 0.23203343f, -0.03368859f, 
    -0.27583566f, 0.08868206f, -0.04906268f, 0.05529722f, 0.48447534f, 0.22217947f, 0.02971210f, -0.31482235f, 
    -0.11677996f, 0.02049952f, 0.05319434f, -0.04728259f, 0.24140415f, 0.11627843f, 0.14530757f, 0.13789085f, 
    -0.00879336f, 0.06237782f, 0.15926211f, 0.06507097f, 0.00592701f, 0.02887829f, -0.16533059f, -0.08022694f, 
    -0.04033010f, 0.00726688f, 0.16997431f, 0.15466772f, -0.20592515f, -0.06828407f, -0.45555469f, -0.00558542f, 
    0.07300775f, -0.11550017f, -0.06502603f, 0.06310805f, 0.14530537f, 0.06575976f, 0.02950697f, 0.13041684f, 
    0.23986793f, 0.04865619f, 0.29644758f, 0.30419731f, -0.05936437f, 0.07243793f, 0.08945820f, 0.04087773f, 
    0.04864206f, -0.07440228f, 0.19581118f, 0.10357928f, 0.05147085f, -0.10312834f, -0.05183088f, -0.05781744f, 
    0.08984013f, -0.10217803f, -0.24077566f, -0.06579052f, -0.05917050f, -0.09451011f, 0.11720959f, 0.00237870f, 
    -0.05576849f, 0.06484759f, -0.11611325f, 0.06677540f, -0.02724805f, 0.04727328f, -0.05436716f, 0.06507249f, 
    0.07875855f, -0.26396620f, 0.19176960f, 0.00603397f, -0.03919641f, 0.06579292f, -0.09546692f, -0.02048732f, 
    0.14801945f, -0.20789024f, -0.07182057f, -0.04194756f, 0.19499354f, 0.06380725f, 0.09834865f, -0.13968383f, 
    -0.08649287f, 0.02578552f, -0.04244028f, 0.01243998f, -0.10227101f, -0.08074006f, -0.14633802f, -0.03011324f, 
    -0.03395281f, -0.01756993f, -0.09944039f, -0.00891551f, -0.04748803f, 0.10376182f, 0.12732254f, -0.08336260f, 
    0.03663249f, 0.10577197f, -0.00318532f, 0.08155075f, 0.00807141f, -0.04923308f, 0.02645863f, 0.02367406f, 
    -0.03870367f, -0.25328782f, -0.11299762f, 0.11120584f, 0.01944880f, 0.06456538f, 0.05633887f, 0.00781193f, 
    0.09493177f, 0.07277630f, 0.01487687f, 0.08085242f, -0.21985978f, 0.10990553f, 0.15884629f, 0.16340020f, 
    -0.13230011f, 0.10874216f, 0.04533203f, 0.01899897f, -0.05692979f, -0.04560195f, 0.15737984f, 0.07188813f, 
    -0.23253073f, -0.04371240f, 0.02172380f, 0.01018268f, 0.11473538f, 0.00501313f, -0.06376903f, -0.01619304f, 
    -0.03428531f, 0.05906187f, 0.12232838f, 0.16168603f, 0.05317290f, -0.02109079f, -0.03154239f, -0.11978629f, 
    -0.01883529f, 0.08975230f, -0.01817122f, -0.02427150f, -0.03701022f, 0.07266740f, 0.05522475f, 0.08567651f, 
    0.24657862f, 0.21002066f, 0.11222526f, 0.17632528f, 0.05454049f, -0.00155966f, -0.06787905f, -0.13969614f, 
    -0.00893028f, 0.09148315f, 0.07179999f, 0.01816707f, 0.00944739f, 0.04085522f, 0.15693514f, 0.07592709f, 
    0.05213573f, 0.09017708f, -0.13767302f, 0.13580447f, -0.06492827f, 0.01027510f, 0.04452128f, -0.00723274f, 
    0.05265826f, 0.08163476f, -0.02596030f, 0.18503976f, -0.06980525f, 0.14557774f, 0.00183626f, -0.10688002f, 
    0.09141047f, 0.09961423f, 0.08944115f, 0.03131529f, -0.01261997f, -0.25365660f, 0.23183832f, 0.04493476f, 
    0.05149546f, -0.00678828f, 0.01092603f, -0.11076408f, 0.08571813f, 0.05261784f, -0.09256447f, 0.08070225f, 
    -0.18087159f, 0.13413933f, -0.03896321f, -0.20495342f, 0.01571714f, -0.19175692f, 0.06076205f, 0.04238248f, 
    -0.01378941f, 0.02261449f, -0.12731321f, 0.02672664f, -0.27884260f, 0.25958750f, -0.05656326f, -0.00973533f, 
    0.01606874f, 0.05519817f, -0.02527869f, 0.02356608f, -0.04161950f, -0.05490986f, -0.02154082f, 0.00604775f, 
    -0.18919834f, -0.20172323f, 0.11224634f, 0.19601697f, 0.02242785f, -0.17180297f, 0.13359515f, 0.10993405f, 
    0.01387686f, -0.01899919f, 0.00484420f, -0.04853066f, 0.17539261f, 0.14297843f, -0.29060650f, 0.20124991f, 
    0.03292776f, 0.06894720f, -0.02580732f, 0.03419318f, -0.14015307f, 0.00691483f, -0.02849046f, -0.05313707f, 
    -0.33436465f, -0.17939721f, 0.11103027f, 0.01717797f, 0.11705347f, -0.09346533f, 0.05755071f, 0.01226986f, 
    0.05020755f, 0.08281661f, -0.07857561f, -0.05627040f, 0.08355024f, 0.21394804f, 0.26673245f, -0.02429422f, 
    0.05480728f, 0.18807840f, 0.06401877f, -0.11265455f, -0.04788128f, 0.19084077f, 0.07434659f, -0.04048241f, 
    0.17450458f, 0.10483885f, 0.16956767f, 0.04983647f, -0.00014206f, -0.05439409f, -0.02645108f, -0.04807227f, 
    -0.03337956f, 0.09301212f, -0.06976641f, -0.02902667f, 0.03444577f, 0.19404627f, -0.11569861f, 0.32863638f, 
    0.12733980f, -0.04178417f, -0.03095526f, 0.03251064f, -0.09015502f, -0.01768137f, 0.05463213f, -0.06896162f, 
    -0.16445342f, -0.10586920f, -0.00979627f, -0.24003635f, 0.05242162f, -0.02080333f, 0.01847523f, 0.11872012f, 
    0.06218543f, 0.02267025f, -0.08702730f, 0.09626273f, -0.35211688f, 0.18938142f, 0.19397505f, 0.27746695f, 
    -0.00940040f, 0.05825295f, 0.09597296f, 0.09874280f, -0.03450551f, -0.09358182f, 0.04515940f, 0.00589900f, 
    0.11913320f, 0.02774088f, 0.05231733f, 0.22623131f, -0.00212224f, 0.00185971f, 0.11829920f, 0.02426004f, 
    -0.10137556f, -0.01215560f, -0.01100542f, -0.10719312f, -0.14399850f, 0.45553428f, 0.20727812f, -0.11384696f, 
    -0.04154685f, 0.09766466f, -0.04091632f, -0.07708866f, -0.02397965f, 0.10811462f, 0.04859597f, 0.00442008f, 
    -0.10636880f, 0.15073392f, -0.10580982f, 0.08831412f, -0.00308778f, 0.12860461f, 0.00247287f, 0.01890217f, 
    0.01967181f, 0.03969426f, 0.12150480f, 0.03028786f, -0.13409634f, 0.21915272f, 0.07842212f, -0.16881931f, 
    0.05430443f, -0.03223079f, 0.12855639f, -0.03966840f, -0.00865506f, -0.09147628f, 0.05487050f, -0.02290520f, 
    0.09213769f, -0.03660035f, 0.13715136f, -0.11160818f, -0.10616649f, 0.10698303f, 0.13574329f, 0.05502248f, 
    -0.02861190f, -0.05580484f, 0.05959339f, 0.19652918f, -0.27541971f, 0.08393694f, -0.10010328f, 0.25622207f, 
    -0.02622822f, 0.05720639f, -0.09217039f, -0.06266595f, 0.16034253f, -0.01336806f, -0.06879640f, -0.08232136f, 
    -0.09905901f, 0.07725923f, 0.04784449f, -0.16731882f, 0.01626563f, -0.13054854f, 0.07416880f, 0.07201000f, 
    -0.06609695f, 0.04317504f, -0.01569818f, 0.00254545f, -0.05606627f, -0.04282471f, -0.16504660f, 0.23855542f, 
    0.05310472f, 0.01452441f, -0.04728258f, -0.01037337f, -0.07264122f, -0.00257666f, -0.05069242f, 0.02272812f, 
    0.13700420f, -0.06538911f, 0.17753182f, 0.15187770f, 0.10567991f, -0.06586772f, 0.00376186f, 0.03829025f, 
    -0.01053360f, -0.05992709f, 0.00542992f, -0.01307278f, -0.20938015f, 0.24861892f, -0.10579401f, -0.10214590f, 
    0.00890438f, 0.03635098f, 0.02107961f, 0.07154636f, 0.02006748f, 0.07920274f, -0.06614920f, 0.02603521f, 
    0.14233112f, 0.12846656f, 0.06532955f, 0.18163317f, -0.07920323f, 0.10132740f, 0.09308422f, 0.00688675f, 
    -0.03846805f, 0.21644905f, -0.03141836f, 0.08136566f, -0.21642280f, 0.21267344f, -0.05405977f, 0.34234464f, 
    0.03757561f, -0.04248115f, 0.01730700f, -0.01754115f, -0.00273834f, -0.03869563f, 0.09666330f, 0.10987606f, 
    -0.11160392f, -0.04772888f, 0.14611031f, 0.19708282f, 0.04446951f, -0.01988425f, -0.08190078f, -0.06306224f, 
    0.14098708f, -0.11797792f, -0.09393532f, -0.04954075f, 0.53547406f, -0.14086100f, -0.14162447f, 0.45229125f, 
    -0.15335785f, 0.04383480f, 0.08236767f, 0.08771557f, 0.09293067f, 0.02843376f, -0.05129136f, 0.01313553f, 
    0.29308966f, -0.32697877f, -0.03501755f, -0.25722879f, -0.01737926f, -0.05314315f, 0.13435285f, 0.10672998f, 
    0.02682303f, 0.08133593f, 0.09525987f, 0.04300842f, -0.01231755f, 0.09172795f, 0.01848856f, -0.25015911f, 
    -0.02276210f, 0.07262858f, -0.00517049f, -0.06101252f, -0.00796249f, 0.08391612f, 0.06096725f, -0.02845951f, 
    -0.06478263f, 0.06085463f, -0.06894109f, 0.13802053f, 0.03678042f, 0.08878769f, 0.15682267f, 0.07804198f, 
    0.01371671f, -0.00451470f, 0.08478210f, 0.17121965f, 0.04979432f, -0.30142444f, 0.21879360f, -0.20180282f, 
    -0.09171350f, 0.00735589f, 0.05651071f, -0.08764475f, 0.01544959f, 0.09714252f, -0.13761340f, 0.08297201f, 
    0.08993175f, 0.10876472f, 0.03496281f, -0.26272124f, 0.07113993f, -0.03347550f, -0.03412483f, 0.01470898f, 
    0.11386571f, -0.04334816f, 0.08557043f, 0.07996573f, -0.03449874f, 0.26601586f, 0.13340072f, 0.02991233f, 
    -0.11297495f, 0.11988488f, 0.05119215f, 0.19153953f, 0.06889064f, -0.04119562f, -0.03036150f, 0.02843300f, 
    0.50854886f, -0.21289459f, -0.10257620f, -0.10298176f, 0.04891495f, -0.04854051f, -0.05129109f, 0.04412794f, 
    0.05142181f, 0.00933915f, -0.00990049f, 0.03245034f, -0.50056249f, -0.00131007f, 0.34151986f, 0.21698126f, 
    0.01643501f, 0.03075217f, -0.00391127f, -0.04118181f, -0.03129669f, 0.12753858f, -0.11146633f, 0.02234469f, 
    -0.34532899f, 0.39990821f, 0.04869856f, 0.14189370f, 0.00727821f, 0.00706998f, 0.13141163f, 0.21569404f, 
    0.00953871f, 0.15617482f, -0.08635665f, 0.04667916f, 0.35465580f, -0.33929750f, 0.10928111f, 0.28776217f, 
    -0.06812175f, -0.11094435f, -0.01435657f, 0.06346471f, 0.06073889f, -0.06560697f, -0.06618310f, 0.04611904f, 
    -0.53756303f, 0.25650457f, 0.33678487f, 0.03116995f, 0.05843661f, -0.07420406f, 0.07707601f, 0.10842535f, 
    -0.00154032f, -0.03178800f, -0.05334228f, -0.02074193f, 0.37903592f, -0.06424742f, 0.27234501f, -0.01045970f, 
    0.03360151f, 0.17198181f, 0.03797002f, -0.02612953f, -0.13040723f, 0.04510649f, -0.00822408f, 0.02506055f, 
    -0.38444564f, -0.07379867f, -0.07304700f, -0.08997691f, -0.08329627f, -0.00134381f, -0.06437579f, 0.00252947f, 
    0.05585304f, 0.04374444f, -0.02140367f, -0.11098269f, 0.20373245f, 0.21452570f, -0.14505121f, -0.04585927f, 
    -0.06371524f, 0.04173114f, 0.08457172f, 0.16879526f, 0.02683381f, 0.13063221f, -0.00865102f, 0.06290822f, 
    -0.38777938f, 0.04786041f, 0.14285913f, 0.12950896f, 0.10628201f, -0.02283545f, -0.05667491f, 0.06041238f, 
    -0.03063360f, -0.06253376f, 0.05686620f, 0.00228674f, 0.20050032f, 0.17500596f, -0.09647715f, -0.16717774f, 
    -0.05995490f, -0.03436837f, 0.05526156f, 0.07560997f, 0.05509995f, -0.03272242f, -0.10444174f, 0.00722023f, 
    -0.40926018f, 0.26533371f, -0.07726996f, 0.07809341f, -0.01121637f, 0.06229452f, 0.02304877f, 0.00354795f, 
    -0.03796552f, -0.07238418f, 0.00874879f, 0.08014729f, 0.25650331f, 0.21975620f, 0.04892034f, -0.05661040f, 
    -0.02772871f, -0.07236913f, -0.04212604f, 0.04661155f, -0.03281482f, -0.03677722f, 0.01928338f, 0.18099871f, 
    0.22680265f, -0.15590277f, 0.23993857f, 0.19938298f, 0.05222654f, -0.01223274f, -0.03823437f, 0.03904997f, 
    0.12335823f, 0.07436751f, 0.04833389f, 0.00735935f, -0.02235950f, -0.30263847f, -0.27461302f, 0.33386225f, 
    -0.09067533f, -0.09417717f, -0.16245198f, -0.13109599f, 0.02321706f, 0.10116914f, 0.05147982f, 0.03541948f, 
    0.16736649f, -0.11730684f, -0.05009727f, 0.22100130f, 0.01303749f, -0.01234708f, 0.08911933f, 0.08989549f, 
    -0.02959646f, 0.10821710f, -0.01418451f, 0.06672089f, 0.27255881f, -0.03269424f, 0.03122226f, 0.33716658f, 
    -0.16861747f, 0.05339889f, -0.06386599f, -0.02437387f, 0.07182166f, 0.14375591f, 0.13280053f, -0.08674693f, 
    0.01783310f, 0.06237619f, -0.26753742f, -0.09785417f, 0.14429449f, -0.09529781f, 0.08658990f, 0.20177509f, 
    -0.11216198f, 0.00144439f, 0.17379059f, 0.04556120f, -0.13752559f, -0.20928606f, 0.04187621f, -0.31885213f, 
    -0.06622581f, 0.15862089f, 0.07054834f, -0.02671736f, -0.07719381f, 0.04356323f, -0.00072191f, 0.11230148f, 
    -0.10253893f, -0.03260852f, -0.09760701f, 0.28094858f, -0.15383428f, -0.00920284f, 0.20954889f, -0.06209181f, 
    0.02607877f, -0.02747585f, 0.07051817f, -0.16316307f, 0.39387855f, -0.03614007f, 0.16539757f, -0.01552506f, 
    0.02445454f, 0.16087961f, 0.04494710f, 0.10145854f, 0.13408867f, 0.04134760f, 0.07695952f, 0.02913220f, 
    0.31237492f, -0.17385098f, 0.15879689f, -0.16675229f, -0.04698168f, -0.03236220f, 0.00884940f, 0.09090510f, 
    0.01829399f, 0.01758406f, -0.07641170f, 0.03866656f, -0.12293261f, 0.17792438f, 0.02215297f, 0.40066662f, 
    -0.12958825f, -0.08458505f, 0.11558201f, 0.12353902f, 0.01034272f, 0.05420147f, 0.02136062f, 0.04321611f, 
    0.08285641f, -0.05186500f, 0.11674891f, -0.05954003f, -0.00343225f, -0.05305954f, 0.05303938f, 0.11411110f, 
    0.10149914f, 0.05272011f, 0.00315190f, 0.02822552f, 0.31979784f, 0.16749427f, -0.06540205f, -0.21893385f, 
    -0.00231090f, 0.00737560f, 0.03348213f, 0.05031058f, -0.04649672f, 0.02644067f, -0.00374130f, 0.03493397f, 
    0.40377316f, 0.05562790f, 0.13985136f, 0.02132537f, -0.01970169f, -0.03577921f, 0.04279766f, 0.10876849f, 
    0.08885944f, 0.03948943f, 0.09195814f, -0.00097559f, 0.10291447f, 0.05023107f, -0.08616844f, -0.09008602f, 
    0.14227568f, -0.05223159f, -0.04988021f, -0.04673844f, 0.08593650f, 0.09416790f, 0.12268701f, 0.02413915f, 
    0.40436447f, 0.15907080f, 0.08482227f, -0.23642315f, 0.03328277f, -0.13654974f, 0.03035086f, 0.07124420f, 
    0.08559612f, -0.12651338f, 0.01815590f, 0.14660989f, -0.03873071f, -0.02230881f, -0.10161581f, -0.00263988f, 
    0.17507198f, -0.08146807f, -0.06236791f, 0.23050120f, -0.01718715f, 0.14558245f, -0.14804764f, 0.00338718f, 
    0.32903591f, 0.04537276f, 0.03784741f, -0.02085848f, -0.01759690f, -0.07153828f, 0.03840186f, -0.02967988f, 
    0.00970755f, 0.04387571f, 0.00806085f, -0.22802633f, -0.05278333f, 0.17114960f, 0.02220936f, 0.12909384f, 
    0.21759604f, -0.04524733f, 0.05727186f, 0.07199268f, 0.13611351f, -0.11162034f, 0.02906076f, 0.02090871f, 
    0.08951265f, -0.14034873f, 0.10138433f, -0.12072542f, -0.13049921f, 0.21049885f, -0.06233896f, 0.11018560f, 
    0.05621007f, -0.01931641f, -0.02071707f, 0.09230182f, -0.11648790f, 0.02506735f, -0.04279155f, -0.07464041f, 
    0.22348246f, 0.00206449f, -0.04589006f, -0.10704597f, 0.19140077f, -0.06412203f, -0.03877755f, -0.04482910f, 
    -0.24333467f, 0.11483411f, 0.03437912f, -0.03426179f, 0.14345033f, -0.15679958f, 0.02987740f, -0.11057035f, 
    0.05470794f, 0.11940452f, -0.13646379f, 0.09748853f, -0.06093181f, 0.14579818f, -0.35578883f, 0.01119371f, 
    -0.03795898f, -0.07753955f, 0.01361417f, 0.12029111f, -0.10311648f, -0.07082947f, 0.21612771f, 0.10279080f, 
    0.00142797f, 0.36967283f, 0.04284005f, 0.04195389f, 0.08719943f, 0.06611407f, -0.04438180f, -0.00795690f, 
    -0.08413627f, 0.01275561f, 0.04171825f, 0.06846105f, 0.38987088f, 0.02578660f, -0.05141778f, -0.02648783f, 
    0.14966558f, 0.04992070f, -0.02232970f, 0.02624315f, 0.00454294f, 0.12476180f, 0.01244026f, 0.08242338f, 
    0.29219455f, 0.21970798f, -0.21157019f, -0.10919582f, -0.02906421f, 0.09412631f, 0.05778180f, 0.04179161f, 
    0.00500701f, 0.08861079f, 0.20180468f, 0.03901153f, -0.20716929f, 0.07982103f, 0.10723779f, 0.06177540f, 
    0.11261633f, -0.14266989f, 0.03828690f, 0.02478732f, 0.20704748f, 0.01621850f, 0.23009537f, 0.02412122f, 
    0.67650044f, 0.11400726f, 0.00684319f, 0.07773622f, -0.06327540f, 0.10658907f, 0.03317045f, 0.02447782f, 
    -0.06382877f, -0.01721518f, 0.18847662f, -0.00445988f, -0.18114881f, -0.26741382f, -0.13014378f, 0.17565194f, 
    -0.01307059f, 0.04399340f, 0.02172277f, 0.04454497f, 0.06939283f, -0.13340522f, -0.04102999f, -0.02251738f, 
    -0.06451546f, -0.12358381f, -0.06212023f, -0.09471276f, -0.10600507f, 0.11058570f, 0.01067006f, 0.06817646f, 
    0.19794945f, 0.09000556f, 0.03400514f, 0.15069382f, 0.03295881f, -0.31140530f, 0.31244573f, -0.24452360f, 
    0.09949615f, 0.08047561f, 0.06987644f, 0.07376501f, 0.17536019f, 0.05943439f, 0.03246761f, 0.06163532f, 
    -0.43745551f, 0.35381821f, -0.22081247f, 0.02754768f, 0.15490122f, -0.03803324f, -0.06902880f, 0.03139284f, 
    0.03812551f, 0.08445904f, 0.07194111f, 0.04408109f, 0.01053535f, -0.24661233f, 0.02488230f, -0.03072095f, 
    0.16548017f, 0.06508730f, 0.09694826f, 0.00514093f, 0.02711569f, 0.02246389f, -0.02413564f, -0.05767344f, 
    -0.25994870f, -0.00637814f, -0.17818113f, -0.02045409f, 0.06628441f, -0.05839247f, 0.07606401f, 0.13566183f, 
    -0.04530698f, -0.04148590f, 0.08900429f, 0.18330476f, -0.41650721f, -0.06131132f, -0.20032944f, 0.12669872f, 
    0.33537334f, -0.16896740f, 0.09610941f, 0.12243449f, 0.10861830f, 0.03278995f, 0.07042138f, -0.06338532f, 
    0.38574332f, -0.06503960f, 0.02047099f, -0.02614032f, 0.05504094f, -0.06931435f, -0.08309689f, -0.04885461f, 
    0.08161138f, 0.10289038f, -0.00156458f, -0.03078882f, 0.06443144f, 0.03906961f, -0.12189738f, 0.11348818f, 
    0.20010059f, -0.07522126f, 0.09747165f, -0.03327713f, 0.11712832f, 0.19097570f, -0.05460086f, 0.17423853f, 
    -0.23972569f, -0.03061604f, 0.04683426f, -0.07622658f, 0.05515185f, 0.09954495f, -0.16104491f, -0.20359798f, 
    -0.06606772f, 0.12622724f, -0.09074074f, -0.06892637f, 0.46448934f, 0.09668059f, 0.44356945f, -0.18335100f, 
    0.05179065f, 0.05117551f, 0.08274516f, -0.01609079f, 0.01354129f, -0.01932380f, 0.07783119f, 0.10771417f, 
    0.21053888f, 0.03400469f, -0.19020469f, 0.03405030f, 0.17700914f, -0.06427655f, -0.10890544f, -0.05211792f, 
    0.00508219f, 0.02561339f, 0.06480553f, 0.10982632f, 0.10686709f, 0.01944261f, 0.13399024f, -0.07336305f, 
    0.01388235f, -0.05395582f, 0.11427506f, 0.04684142f, 0.17883413f, 0.08402078f, 0.11485639f, 0.11679304f, 
    -0.21750118f, -0.05161524f, -0.16021198f, 0.01352446f, 0.08946504f, 0.05464129f, 0.15890490f, 0.10765324f, 
    0.13681336f, 0.02323499f, 0.00680336f, -0.00867460f, 0.14421588f, 0.06563438f, 0.05505131f, 0.08915465f, 
    0.05854273f, -0.00148505f, -0.09253401f, -0.02799607f, 0.10642344f, 0.04866256f, -0.01027713f, 0.10134332f, 
    -0.17211533f, -0.20510864f, 0.03168843f, 0.13605057f, 0.02273881f, 0.08533423f, -0.00082250f, 0.09774666f, 
    0.05328075f, -0.03022348f, 0.09822314f, -0.02365262f, 0.07188580f, -0.10729124f, 0.21566510f, -0.22072127f, 
    0.08743190f, 0.09122805f, 0.09800065f, -0.15446372f, 0.16138060f, -0.04535471f, 0.03640816f, -0.05268833f, 
    -0.03496473f, -0.03884109f, 0.00979972f, -0.04217014f, -0.02325331f, 0.04182681f, 0.02137206f, 0.00252943f, 
    0.02682167f, 0.00984385f, 0.03769566f, -0.00619961f, 0.02904510f, -0.04973512f, 0.01581036f, 0.00331945f, 
    -0.03593755f, 0.03294672f, -0.03253036f, 0.00467710f, -0.01797778f, -0.04248019f, -0.04397925f, 0.02631620f, 
    0.00432621f, -0.01568282f, -0.00276074f, -0.04289014f, -0.02460263f, -0.01179540f, 0.00243963f, -0.04872385f, 
    0.00127007f, 0.00116019f, 0.04098160f, 0.00888385f, 0.00069872f, -0.03452167f, 0.03062962f, 0.01023067f, 
    -0.02746413f, -0.02361611f, -0.03580033f, -0.04962581f, -0.03034596f, 0.04289545f, -0.00834257f, -0.03341198f, 
    0.02957808f, 0.02128184f, -0.04463805f, -0.02789811f, -0.05733992f, 0.01600297f, -0.00004423f, 0.02082011f, 
    0.02886033f, -0.01089860f, -0.00132572f, -0.05106210f, 0.00186342f, -0.02969304f, -0.00861018f, 0.02707669f, 
    -0.01628510f, -0.04399931f, -0.03246097f, -0.03775380f, -0.04011909f, -0.03921209f, -0.00407494f, -0.04826954f, 
    -0.01770964f, 0.03709609f, 0.01417535f, 0.00737403f, 0.01287396f, -0.01126433f, -0.00986081f, -0.03144152f, 
    0.01865288f, -0.05051472f, -0.02878219f, -0.04207741f, -0.05276829f, -0.03679377f, -0.02684878f, 0.03726137f, 
    -0.04025470f, -0.00073941f, -0.01186355f, -0.02402610f, 0.00929043f, -0.05756765f, -0.01527216f, 0.00963186f, 
    0.00268584f, 0.02774527f, 0.00247641f, 0.03769664f, -0.04371355f, -0.02898321f, 0.00904825f, -0.04554468f, 
    0.03158522f, 0.00714401f, 0.01069634f, 0.02681229f, 0.03002425f, -0.01590069f, -0.01586205f, -0.00458404f, 
    0.03796281f, 0.00224323f, 0.03024777f, 0.02875337f, -0.05731312f, 0.02802254f, 0.04066903f, -0.02488640f, 
    -0.00545366f, -0.03047428f, -0.05561894f, -0.02281251f, 0.02962784f, 0.02016845f, -0.02331859f, -0.02246802f, 
    0.02028871f, -0.00708765f, -0.03623379f, 0.01288128f, 0.02334063f, -0.05711554f, -0.05730853f, 0.01267886f, 
    -0.03401246f, 0.01750606f, -0.03402350f, -0.02695622f, -0.05834520f, 0.02427379f, -0.01298628f, -0.02035443f, 
    0.00651855f, 0.03251287f, -0.01271305f, 0.02509840f, 0.01900416f, 0.01079112f, 0.03993214f, 0.01907362f, 
    -0.05713135f, 0.02750801f, -0.05337550f, -0.04262571f, 0.00616535f, -0.02684762f, 0.03663746f, -0.01454288f, 
    -0.04468598f, -0.00436090f, -0.02067321f, 0.03304068f, -0.05755112f, -0.01524304f, 0.03035710f, -0.02910780f, 
    0.03906706f, -0.01474663f, 0.01966666f, 0.03543756f, 0.03354137f, -0.04105055f, 0.00588648f, -0.00729957f, 
    -0.01926873f, 0.01094932f, -0.02706452f, -0.02934387f, -0.04872064f, -0.03155017f, -0.03489940f, 0.00814978f, 
    -0.00995870f, 0.02947951f, 0.03624858f, -0.01657083f, 0.02388025f, 0.04281421f, -0.05480788f, -0.05449956f, 
    0.03452429f, -0.02308640f, 0.00576141f, -0.05782978f, -0.01771891f, 0.02265563f, -0.04037695f, -0.01908418f, 
    -0.01050316f, -0.01702943f, -0.05402587f, 0.04327298f, -0.04355259f, -0.03861227f, 0.03298743f, -0.02463559f, 
    -0.05548118f, -0.03838559f, 0.03735949f, -0.02901071f, -0.04870398f, 0.00414139f, -0.03415636f, -0.04496086f, 
    -0.02927776f, -0.01036751f, 0.02222332f, 0.01491112f, -0.02703532f, 0.04234166f, -0.02249243f, -0.04487196f, 
    0.04282970f, 0.01940700f, -0.04778137f, 0.03964626f, 0.01581902f, 0.02124755f, -0.03795536f, -0.03928113f, 
    -0.03502869f, -0.04075480f, 0.02768508f, -0.00019818f, 0.00575326f, 0.03502872f, 0.04213259f, 0.02349563f, 
    0.00940782f, -0.04354556f, -0.03314142f, -0.04018089f, -0.05487826f, -0.01686564f, -0.02099080f, 0.00774503f, 
    0.00997469f, -0.03513958f, -0.04496524f, -0.01280145f, -0.02061024f, -0.03444595f, 0.00105489f, -0.05803216f, 
    0.01467218f, -0.01268550f, -0.05376156f, -0.05045113f, 0.03329972f, 0.01104449f, 0.00049866f, 0.00543944f, 
    -0.01882892f, -0.02308342f, -0.03736128f, -0.02213572f, 0.02252349f, -0.02385625f, -0.03195739f, -0.04837391f, 
    0.03637318f, -0.04461185f, -0.01116558f, 0.02387391f, -0.04305568f, -0.00182512f, 0.00931081f, -0.03551816f, 
    0.01065801f, -0.03489131f, 0.03407463f, 0.04143159f, 0.04261256f, -0.01057948f, 0.01895432f, -0.02463833f, 
    0.01498554f, -0.05564208f, -0.03402936f, -0.05561733f, -0.00567716f, -0.00776900f, -0.03181814f, 0.02865754f, 
    -0.00070102f, -0.02127247f, -0.04815518f, -0.04210024f, 0.02248948f, 0.01580945f, -0.01745700f, -0.05110837f, 
    -0.02313241f, -0.05506426f, 0.02784672f, -0.00747224f, 0.02029391f, -0.05542510f, -0.05653229f, 0.00414970f, 
    -0.01312653f, 0.01940355f, -0.00117686f, 0.02500306f, 0.00928017f, 0.03483244f, 0.01304823f, -0.02341359f, 
    -0.03593916f, -0.03317513f, -0.04356926f, -0.01722804f, -0.01857873f, 0.02171013f, -0.01228470f, -0.02941608f, 
    -0.02486240f, 0.03536366f, -0.02093259f, 0.00128217f, -0.00554780f, 0.03895201f, 0.01120609f, 0.00019122f, 
    0.01342354f, -0.04884736f, -0.01346632f, -0.01636335f, -0.03317006f, 0.03994991f, -0.01734651f, -0.02625669f, 
    0.03996020f, -0.01766847f, 0.00580877f, 0.00021124f, -0.03969903f, -0.03064619f, -0.01493242f, 0.00704406f, 
    0.03120893f, 0.02735904f, 0.04205242f, 0.03322683f, -0.02738719f, 0.02124364f, -0.02385220f, 0.02963899f, 
    -0.02104233f, -0.03612651f, -0.03685428f, 0.04128620f, -0.01076818f, -0.02764327f, -0.05356991f, -0.04872739f, 
    -0.01366752f, -0.03081975f, -0.00242381f, -0.01696062f, -0.02366462f, 0.02750976f, 0.02673509f, -0.04164948f, 
    0.00195297f, -0.05511294f, -0.01961353f, 0.02701349f, 0.01290120f, -0.00288452f, -0.00351545f, -0.03082548f, 
    0.01104720f, -0.01296907f, -0.02093536f, -0.02244166f, 0.04772307f, -0.04568729f, 0.02134222f, 0.02368117f, 
    -0.05365971f, -0.03666889f, -0.03718360f, 0.03151566f, 0.01207871f, 0.03992185f, 0.04586646f, 0.00322670f, 
    -0.04477431f, 0.00593441f, -0.04161179f, -0.04280657f, 0.05429080f, -0.05882205f, 0.04041092f, 0.03620585f, 
    -0.00074623f, -0.00388798f, -0.00514870f, 0.04339270f, -0.02969016f, 0.00631101f, -0.04802902f, -0.03867517f, 
    -0.01508758f, 0.00768977f, 0.03396667f, -0.05562143f, -0.03824267f, -0.02204705f, 0.02382708f, -0.03700486f, 
    0.03001160f, -0.00323364f, 0.03637635f, 0.01133386f, 0.01104170f, -0.04272167f, -0.04586021f, 0.00133864f, 
    -0.03846477f, -0.01359566f, 0.00568165f, -0.00209512f, -0.03467127f, 0.02955212f, -0.03419767f, -0.02399535f, 
    -0.00807329f, -0.01505900f, 0.01601117f, 0.00525041f, 0.04103531f, 0.02252378f, -0.02062538f, -0.02738702f, 
    -0.03672801f, -0.00955248f, -0.02766867f, -0.03738969f, 0.02471403f, 0.04398297f, 0.00532833f, -0.05995955f, 
    0.01740477f, 0.00051303f, 0.04349181f, -0.01936256f, -0.02213885f, -0.05122931f, 0.01987299f, -0.04332781f, 
    0.01308716f, 0.01880825f, -0.00010450f, -0.03376238f, 0.00164362f, -0.00342138f, -0.02331343f, -0.01461203f, 
    0.01401589f, -0.01680216f, 0.00553295f, -0.02321764f, 0.02768965f, -0.00232626f, 0.00854900f, -0.05570329f, 
    -0.03020674f, -0.01424985f, 0.02182703f, 0.03613032f, 0.01773709f, 0.03608285f, 0.03748577f, 0.01586681f, 
    -0.05535081f, -0.04189428f, 0.02597085f, 0.01375588f, 0.00091407f, 0.01251951f, 0.01028369f, -0.03016775f, 
    0.05115255f, -0.05547001f, -0.05784563f, 0.03888763f, 0.02469311f, -0.03925076f, 0.00971178f, -0.01142480f, 
    0.01810790f, 0.00802795f, -0.04595152f, 0.02002669f, -0.04161159f, 0.03875168f, -0.05455444f, -0.03909235f, 
    0.01936500f, -0.04230350f, -0.02602073f, 0.03153237f, 0.02540195f, 0.01484334f, 0.01119190f, -0.03947825f, 
    -0.04039479f, 0.04043789f, -0.02976592f, -0.03903430f, -0.01842942f, -0.04245855f, 0.01451479f, -0.02429384f, 
    0.00010138f, -0.00608896f, 0.02854711f, -0.05271447f, -0.00112876f, 0.01433530f, 0.03534349f, 0.03514372f, 
    0.04430311f, -0.04962383f, -0.05085438f, 0.00955899f, -0.01793827f, 0.02260568f, 0.02531769f, 0.04180076f, 
    -0.03223058f, -0.02322607f, -0.01603999f, 0.01437005f, -0.05833156f, -0.01739365f, -0.03715137f, -0.02667958f, 
    -0.03162820f, -0.04588954f, 0.01026919f, -0.03367576f, 0.01372703f, -0.03728006f, -0.06030490f, -0.01314518f, 
    -0.05737857f, 0.04108992f, -0.04601541f, -0.05014242f, -0.03805911f, -0.01926770f, 0.04091902f, 0.03623729f, 
    -0.03208416f, 0.03263620f, -0.01229055f, 0.02412643f, 0.03464507f, -0.03658934f, 0.03117240f, -0.00185357f, 
    -0.01480923f, -0.02303241f, -0.02956233f, -0.03142890f, 0.03505386f, -0.02093071f, 0.01417754f, 0.00189423f, 
    -0.01336346f, -0.03836390f, -0.01814697f, 0.00834604f, 0.05059422f, -0.02825442f, 0.03628084f, -0.02621724f, 
    -0.04494123f, 0.04013278f, 0.00249654f, -0.01002239f, 0.02194140f, -0.05222980f, -0.02696797f, -0.02189538f, 
    0.01596854f, 0.00764925f, -0.04809749f, 0.02604646f, -0.02436952f, 0.00284632f, 0.01442731f, 0.01253110f, 
    -0.04037912f, -0.05804444f, 0.02704300f, -0.02928346f, 0.03569937f, -0.00267798f, -0.00054996f, -0.05459722f, 
    -0.02177229f, 0.05193785f, 0.00307103f, -0.03922397f, -0.04447801f, -0.04337661f, -0.02079285f, 0.03587247f, 
    -0.02667287f, -0.03995492f, -0.02594823f, -0.00762796f, -0.04069179f, -0.03845927f, -0.04180415f, 0.03051775f, 
    0.00441630f, 0.03938401f, 0.03172918f, 0.01265781f, 0.00535625f, -0.05423686f, 0.01444403f, 0.03316294f, 
    -0.00066999f, -0.00882109f, 0.00591098f, -0.04709512f, -0.02872158f, -0.01727916f, 0.00993063f, -0.04400652f, 
    -0.01696365f, 0.01646885f, -0.01674785f, -0.03318533f, 0.03936507f, -0.03374178f, 0.00263080f, 0.01628022f, 
    0.02265267f, -0.02497405f, -0.03399299f, -0.05433900f, 0.01037057f, -0.01919531f, 0.03057474f, 0.03848840f, 
    -0.04541616f, 0.03037993f, 0.02665903f, 0.02310351f, 0.01374599f, 0.01892848f, 0.01515920f, 0.03605518f, 
    0.04184151f, 0.02894096f, -0.01895405f, -0.04958313f, -0.01190648f, -0.00900421f, -0.00722812f, 0.02158812f, 
    0.04241696f, -0.02275168f, -0.00649918f, 0.00777522f, 0.04437890f, 0.02841431f, -0.01282106f, -0.04559581f, 
    0.01881702f, -0.03677540f, -0.05132371f, 0.03658367f, -0.01161352f, 0.04056110f, 0.01389312f, -0.00519319f, 
    -0.01879207f, -0.00869284f, -0.02868646f, 0.02165245f, -0.05016310f, 0.02143274f, -0.00523342f, 0.03210416f, 
    0.03892283f, 0.01723696f, 0.00874886f, 0.03934040f, -0.01823700f, -0.00138517f, -0.04189070f, -0.00790513f, 
    0.04207209f, -0.04071941f, 0.00646486f, 0.01237050f, -0.02955066f, 0.01010822f, -0.03118234f, -0.03123752f, 
    0.04333987f, 0.02112759f, 0.00157737f, 0.04020471f, -0.05447809f, 0.01409562f, -0.01084642f, -0.02226022f, 
    0.03687125f, 0.01245783f, 0.04438825f, -0.01821642f, -0.04272003f, 0.03896289f, -0.05751437f, -0.04110789f, 
    0.00767578f, 0.02602013f, -0.04935358f, 0.00797454f, -0.03267010f, -0.03723803f, 0.00378626f, -0.01871636f, 
    0.04354713f, 0.02256347f, 0.03046473f, -0.03171618f, 0.05015635f, -0.04227703f, -0.00366122f, 0.01501996f, 
    -0.04553605f, -0.00729609f, -0.04596763f, -0.01162130f, 0.03310523f, 0.04171482f, -0.04159947f, 0.01459167f, 
    -0.00162874f, -0.01781167f, -0.03057166f, 0.00764289f, -0.00071476f, 0.05381400f, 0.02960475f, -0.02081221f, 
    0.00287411f, -0.05174437f, 0.08728079f, 0.06638903f, 0.03053514f, -0.14649607f, -0.00011339f, 0.12935257f, 
    0.02714729f, -0.03676069f, -0.13598441f, -0.20443410f, 0.45315257f, 0.01027430f, 0.05120715f, 0.14129953f, 
    0.09387420f, 0.00206632f, 0.05199071f, -0.08449873f, -0.04260863f, 0.07153133f, 0.17711577f, 0.08268077f, 
    0.00527166f, -0.02061071f, -0.01985536f, 0.02875870f, 0.03381032f, 0.05229524f, 0.06752503f, -0.14999470f, 
    -0.04134024f, 0.03003336f, -0.06689834f, 0.01201249f, -0.05517095f, 0.08977421f, -0.13896431f, -0.26569200f, 
    0.01778556f, 0.15225005f, 0.00768581f, -0.12940226f, 0.00966065f, -0.05568312f, -0.13782518f, -0.11652091f, 
    0.08197453f, -0.04275078f, -0.16514143f, -0.12470589f, 0.03647680f, -0.06210782f, -0.01687108f, 0.09443246f, 
    -0.08050841f, -0.03402082f, -0.13165191f, 0.15317938f, 0.06931473f, 0.08722954f, -0.03464817f, 0.06468832f, 
    -0.03330846f, 0.00084837f, 0.10158231f, 0.12132169f, 0.10182556f, -0.09267197f, 0.14739266f, -0.09793947f, 
    -0.02231347f, 0.14533325f, -0.00748724f, -0.08861601f, -0.02132408f, 0.05456815f, -0.10047605f, -0.13935165f, 
    0.15414675f, -0.04559656f, 0.13210995f, 0.08892391f, -0.38962489f, -0.00149357f, -0.13051638f, -0.12724131f, 
    -0.09035509f, 0.15188384f, -0.07026137f, 0.01369268f, 0.06586917f, -0.09338937f, -0.08499689f, -0.15645467f, 
    0.31760654f, 0.33819559f, -0.03918444f, 0.02818204f, 0.12700790f, -0.01310098f, -0.12301210f, 0.00656435f, 
    0.08790138f, 0.04572715f, 0.04614626f, -0.03588051f, -0.20186721f, -0.05180881f, -0.09394137f, 0.26802975f, 
    0.03097918f, 0.05868224f, 0.02910926f, -0.13863502f, -0.07748648f, 0.00129589f, 0.09818917f, 0.11113240f, 
    -0.38634670f, 0.10054392f, 0.13857372f, 0.14375447f, -0.03808333f, -0.05993585f, 0.01767584f, -0.08491261f, 
    0.01975437f, -0.04802917f, -0.00946843f, -0.12193931f, 0.39523053f, -0.17848428f, 0.11042910f, 0.27716404f, 
    0.05084603f, 0.10657353f, 0.10810826f, -0.04602271f, 0.02477124f, 0.04040118f, -0.04252831f, 0.18940987f, 
    -0.43701020f, 0.04948139f, 0.22039698f, 0.10408834f, 0.06945968f, -0.00122562f, 0.01199616f, -0.05084250f, 
    -0.00940227f, 0.05619375f, 0.20642281f, 0.12323941f, -0.02198597f, -0.12961996f, 0.00578413f, -0.08635986f, 
    0.01446655f, -0.12655191f, -0.00351266f, 0.07399565f, 0.09912979f, -0.08020133f, 0.08540361f, -0.18665701f, 
    0.18458997f, 0.18168114f, -0.14637950f, 0.13760926f, 0.02288969f, 0.02531136f, 0.00210252f, 0.04771122f, 
    -0.00111162f, -0.04172605f, 0.18311647f, 0.10562235f, -0.01591130f, 0.09709895f, -0.14535895f, -0.18347731f, 
    -0.08187512f, 0.11944341f, -0.01541021f, -0.16447568f, 0.04804042f, -0.11935943f, 0.00748426f, 0.08225633f, 
    -0.09435556f, -0.06453754f, 0.08768110f, 0.22176950f, 0.06581555f, -0.06290592f, 0.08792055f, -0.02017619f, 
    0.01620601f, 0.01718713f, 0.05406804f, 0.13844267f, 0.05665446f, 0.07815243f, -0.09281891f, 0.10397622f, 
    0.17065381f, 0.05919113f, -0.10448921f, -0.03604199f, 0.10742139f, 0.05657636f, -0.12534392f, 0.04661496f, 
    -0.55689025f, 0.17297143f, 0.15718725f, -0.29387155f, 0.17723742f, 0.00835058f, 0.17967883f, -0.09432773f, 
    -0.06545722f, -0.01758908f, -0.13563657f, -0.00521799f, -0.00944691f, 0.01695846f, -0.16433719f, -0.05156955f, 
    -0.15941849f, 0.20311476f, 0.09665339f, -0.04743579f, -0.02300762f, -0.08128607f, -0.01598388f, 0.01116506f, 
    -0.10006773f, 0.02790668f, -0.05056485f, -0.00061307f, 0.12039746f, -0.00512085f, 0.23720671f, -0.12646690f, 
    -0.15225017f, 0.01097426f, -0.08511393f, 0.03345876f, -0.00138114f, 0.00206631f, 0.11342295f, 0.09262564f, 
    -0.04096834f, -0.12562728f, -0.03967810f, 0.09237238f, 0.09414810f, -0.07775136f, 0.07704885f, -0.09068047f, 
    0.27757326f, -0.00658739f, -0.14034601f, 0.13660495f, 0.11009786f, -0.02994176f, -0.04603671f, 0.10676042f, 
    0.03514312f, 0.13045262f, 0.07545137f, -0.01860546f, 0.20162681f, -0.07714692f, 0.12148842f, -0.09976980f, 
    -0.06422431f, -0.11125778f, -0.04705923f, -0.05916851f, 0.12616718f, 0.03506250f, -0.16092438f, -0.05495030f, 
    -0.01303823f, -0.00813321f, 0.23466612f, -0.43165424f, -0.18529296f, 0.00785732f, -0.00697962f, -0.02470670f, 
    0.09510286f, 0.03475150f, -0.04642095f, -0.03683108f, 0.15007627f, 0.10459413f, -0.18861391f, -0.00860469f, 
    0.07697861f, 0.02677677f, -0.02493836f, 0.00670964f, -0.02866344f, -0.05901921f, 0.05819747f, 0.08565205f, 
    -0.10912528f, -0.06279719f, 0.16153409f, 0.21084547f, -0.04663637f, 0.09303293f, 0.08757357f, -0.09268421f, 
    0.03740801f, -0.06284785f, 0.04711058f, 0.07983347f, 0.19423109f, 0.18098123f, -0.18514216f, 0.23362145f, 
    -0.04625364f, -0.01895989f, -0.01307328f, 0.06462967f, 0.03865593f, 0.00827029f, 0.00544731f, 0.14541382f, 
    -0.23300587f, -0.07566977f, 0.10184464f, -0.00442236f, -0.04777459f, 0.06101189f, -0.04997863f, 0.10828353f, 
    0.20755926f, 0.00447992f, 0.29746559f, 0.01934093f, 0.27203611f, -0.06254204f, 0.10308729f, 0.04937793f, 
    0.03194188f, -0.05200038f, 0.04406578f, 0.10534526f, 0.11378329f, 0.03094684f, 0.02976294f, 0.07351050f, 
    -0.00050839f, 0.04006613f, -0.16779271f, -0.20065825f, -0.10371722f, 0.08130108f, -0.11632735f, -0.04419201f, 
    -0.02908972f, -0.19509861f, 0.01576789f, -0.10610695f, 0.40798110f, 0.23322794f, -0.19432305f, 0.32851663f, 
    -0.03480851f, -0.04094695f, 0.02795123f, 0.00554877f, 0.07127236f, 0.05986601f, -0.02517355f, -0.06375494f, 
    0.23603368f, 0.04758094f, 0.23850101f, 0.17518058f, -0.17421927f, 0.03133633f, -0.08883280f, 0.00127250f, 
    -0.12258808f, -0.10421813f, -0.09386678f, -0.03054889f, 0.21337359f, 0.26121104f, 0.08515546f, 0.30512112f, 
    -0.00273246f, 0.20350827f, 0.14210792f, 0.11758930f, -0.04363590f, 0.04652422f, -0.11250140f, -0.10362170f, 
    0.60562521f, 0.16568440f, -0.07123237f, -0.15248406f, 0.02019166f, -0.03769594f, 0.01492070f, 0.15178557f, 
    0.03446808f, 0.06476224f, 0.12632684f, 0.12625764f, -0.28369042f, 0.05273098f, 0.06479122f, 0.19319655f, 
    0.16925974f, 0.09617754f, -0.11967118f, 0.27165309f, -0.01545571f, 0.14330609f, 0.00858633f, 0.13963978f, 
    0.07442421f, -0.03582573f, 0.13142370f, 0.07793202f, -0.03705056f, 0.04577910f, 0.04645569f, 0.04173911f, 
    -0.00743334f, -0.04722951f, 0.10614373f, 0.00880116f, 0.06354475f, 0.00369783f, -0.10771729f, -0.09253568f, 
    -0.01646881f, 0.01413876f, 0.03578875f, 0.05503530f, -0.07690845f, -0.03252746f, -0.10767124f, 0.10808986f, 
    0.22257359f, -0.23285711f, 0.15071987f, 0.11360960f, 0.09343328f, 0.06272342f, -0.14213477f, -0.00189035f, 
    0.04076000f, -0.03376913f, -0.02942505f, -0.02716009f, -0.00164584f, -0.16139585f, 0.09510089f, 0.22735152f, 
    0.32284811f, 0.03347137f, -0.10675534f, 0.00294117f, 0.00139323f, 0.00352263f, -0.00478681f, 0.21300478f, 
    0.00868332f, 0.22332335f, 0.07304639f, 0.04252300f, -0.00989709f, -0.07636455f, 0.01683491f, -0.00644738f, 
    0.01379517f, 0.01106756f, -0.13154837f, 0.09673880f, -0.37582198f, -0.34161952f, 0.17931926f, -0.07534093f, 
    -0.01721499f, 0.00801034f, -0.10151648f, 0.01931617f, 0.06719358f, 0.09144330f, 0.01364080f, 0.16138217f, 
    0.02451665f, 0.02198330f, -0.02643256f, -0.25831693f, 0.15005085f, -0.07669832f, 0.07669374f, -0.03018180f, 
    -0.12638026f, 0.04635116f, 0.01647813f, 0.06578677f, 0.10913398f, 0.46165165f, -0.02212912f, 0.15368362f, 
    0.13105205f, -0.01960079f, 0.04214492f, 0.00678300f, -0.11037584f, -0.07322916f, -0.07998488f, -0.03317263f, 
    0.18496133f, -0.22369525f, -0.05200931f, -0.14812769f, 0.09507908f, -0.08500101f, 0.12210313f, -0.04477819f, 
    -0.10247810f, -0.08150520f, -0.07759243f, -0.15502140f, 0.22968632f, 0.31765410f, -0.24195533f, 0.11692979f, 
    -0.04452935f, 0.11325879f, -0.06821107f, -0.04678750f, 0.00553220f, 0.12328734f, 0.03631558f, 0.08475264f, 
    0.30476919f, -0.19572122f, 0.11457425f, -0.11172131f, -0.00684870f, -0.09043235f, 0.04138834f, -0.00069364f, 
    0.04595495f, -0.05693008f, 0.04123839f, -0.07466546f, -0.22534195f, -0.24093407f, 0.14237438f, 0.20372632f, 
    0.16040370f, 0.15539660f, 0.00558422f, -0.04422786f, 0.12795240f, 0.13963053f, 0.13108684f, 0.02407215f, 
    -0.11094147f, -0.20970310f, 0.15635732f, -0.03348981f, -0.13032871f, -0.01798039f, 0.03881149f, -0.04707023f, 
    -0.12926389f, 0.00715672f, -0.06322788f, -0.07097574f, -0.05561655f, 0.17640065f, 0.13198200f, -0.06552918f, 
    0.06545895f, -0.07135013f, -0.04865889f, 0.06677259f, -0.03680327f, -0.17562972f, 0.00153100f, -0.05137422f, 
    -0.22606181f, 0.07729682f, -0.05999583f, -0.15211768f, 0.00531964f, 0.14522274f, -0.09081661f, 0.12534998f, 
    -0.08006009f, -0.04483036f, 0.14570336f, 0.09764227f, -0.45809442f, -0.11549733f, 0.21476266f, 0.09123544f, 
    0.17666750f, 0.00545162f, -0.02565606f, 0.11634959f, -0.03800732f, 0.03817803f, -0.00642466f, 0.08598779f, 
    -0.31117347f, -0.11392381f, 0.11575425f, 0.13289802f, -0.12376440f, 0.16083944f, 0.03009169f, 0.14993569f, 
    -0.13705406f, 0.15223560f, 0.07991326f, -0.05302999f, 0.08862121f, 0.29657555f, 0.08284424f, 0.03229250f, 
    -0.06262799f, 0.13001543f, 0.06183277f, 0.10906669f, -0.20529751f, 0.11889376f, -0.01948009f, -0.02746065f, 
    0.17228472f, 0.07144800f, 0.01391938f, 0.31996927f, -0.00364070f, 0.06634646f, 0.04930317f, 0.00440671f, 
    -0.12133544f, 0.03058277f, 0.01917343f, -0.15132718f, 0.08383971f, 0.28741720f, 0.08890604f, 0.24982458f, 
    0.01915110f, 0.01016179f, 0.12874834f, -0.12089617f, 0.04300063f, -0.02385561f, 0.05236118f, 0.12277665f, 
    -0.39479282f, 0.00644330f, 0.00832962f, -0.15841568f, 0.23793891f, 0.16236775f, 0.05513373f, -0.00044753f, 
    -0.14178790f, 0.21684837f, 0.01385732f, 0.11261102f, 0.48012453f, 0.35468727f, 0.13585809f, -0.09814211f, 
    -0.02821621f, 0.12724708f, 0.04228599f, 0.02019150f, 0.04595172f, 0.02630969f, -0.00265481f, -0.07007907f, 
    0.39998910f, 0.28793362f, -0.09901786f, -0.04381658f, 0.11497808f, -0.04536236f, 0.00719064f, -0.07876152f, 
    -0.02525041f, -0.10027326f, 0.00723157f, 0.00370805f, -0.30280158f, -0.12273698f, -0.05287671f, -0.14911595f, 
    -0.04633119f, -0.06223989f, -0.06438523f, 0.01383017f, -0.00607243f, 0.13661228f, 0.01301901f, 0.05100472f, 
    -0.08772641f, -0.05923422f, 0.31368646f, 0.14154787f, 0.22739059f, -0.07970064f, 0.07500958f, 0.07177425f, 
    0.11431348f, -0.10998922f, -0.03808285f, 0.05745909f, 0.05926616f, 0.27812529f, 0.08883437f, 0.32213649f, 
    -0.01217591f, 0.04008377f, 0.04300390f, 0.02637208f, -0.00507857f, 0.09377027f, -0.11761335f, 0.05189622f, 
    -0.05910247f, -0.35850829f, 0.19605976f, 0.02916384f, -0.03382448f, 0.05479753f, -0.05754091f, 0.19442528f, 
    0.09665040f, 0.13387010f, -0.03385691f, 0.07372908f, -0.00428446f, 0.15722294f, -0.00891356f, -0.00714355f, 
    0.00183137f, 0.10227256f, -0.02127412f, 0.02171531f, -0.03608765f, -0.00953010f, 0.16908462f, 0.23301296f, 
    -0.05605648f, 0.14809024f, -0.01524256f, 0.03642991f, 0.07993297f, 0.04514276f, -0.05030544f, -0.09491549f, 
    0.11792773f, 0.07418861f, 0.18811050f, 0.08483606f, -0.20643644f, -0.16919810f, -0.16593154f, 0.17469938f, 
    0.04464144f, -0.06658949f, -0.12600465f, -0.07092959f, 0.01857044f, -0.03939985f, -0.02786453f, 0.00213436f, 
    0.04860308f, -0.08528619f, 0.03394076f, -0.19894229f, 0.00668998f, -0.02717792f, -0.07874544f, -0.00263604f, 
    -0.05184734f, -0.19242616f, 0.02159486f, -0.10097047f, 0.19176027f, 0.15951912f, 0.03371988f, 0.00973813f, 
    -0.04035198f, -0.03942402f, 0.04800021f, 0.00386548f, 0.03848063f, -0.01304261f, -0.02094563f, -0.10010338f, 
    0.26502970f, 0.02037400f, -0.04037091f, 0.20083025f, -0.03262744f, 0.00401432f, 0.10242354f, -0.02710051f, 
    0.06492545f, -0.00234034f, -0.03844022f, -0.12305988f, -0.26819950f, 0.07114113f, 0.14020966f, -0.15384682f, 
    0.02325068f, -0.03403423f, -0.01637994f, -0.05658337f, 0.02396555f, 0.09374458f, 0.07696989f, 0.04787342f, 
    0.26509348f, 0.20709045f, -0.01558524f, -0.00854890f, 0.01521067f, 0.06465970f, 0.02929454f, 0.21126550f, 
    0.00481046f, 0.01975514f, 0.13736331f, 0.05406813f, 0.30904785f, 0.32050908f, 0.11519803f, 0.04310494f, 
    -0.14049071f, -0.04893466f, 0.17297122f, 0.00438803f, 0.10300866f, -0.07109071f, -0.05865662f, -0.07287289f, 
    -0.20935586f, -0.18854496f, -0.11154718f, -0.18459369f, 0.14326924f, 0.02243644f, 0.08455651f, 0.08783052f, 
    -0.06817302f, 0.10015141f, 0.03054585f, -0.10100822f, 0.33145458f, 0.13102740f, -0.16485697f, -0.10931157f, 
    -0.07473561f, -0.05423884f, -0.04301429f, -0.04699857f, -0.01449572f, -0.04223897f, 0.02335343f, -0.18158711f, 
    0.15190864f, 0.19344386f, 0.12801099f, 0.09583470f, -0.20896478f, 0.09833995f, 0.05457398f, 0.03756310f, 
    0.06519646f, -0.02463731f, -0.02717769f, 0.03786492f, 0.00254636f, -0.25458622f, 0.00461741f, -0.01329833f, 
    -0.03309988f, 0.00466198f, -0.06019481f, 0.00912764f, 0.08895798f, 0.07102200f, 0.11693839f, 0.00699163f, 
    0.30688292f, 0.13411902f, -0.08042827f, 0.11163792f, -0.01976612f, 0.14257392f, -0.03331756f, -0.03054387f, 
    0.03097436f, 0.05266273f, 0.04154393f, 0.14850271f, -0.22156465f, -0.05978859f, 0.34346771f, -0.13534576f, 
    -0.03024189f, 0.14893909f, 0.02537754f, -0.09460757f, -0.01497537f, -0.08991576f, -0.10670155f, -0.08508068f, 
    -0.07114947f, 0.18631980f, 0.01345839f, -0.04277625f, -0.03865524f, 0.16312721f, 0.00635040f, -0.08769095f, 
    -0.06360830f, 0.10052104f, -0.00773873f, 0.06059701f, 0.15272869f, 0.08203265f, 0.01915679f, -0.01234642f, 
    -0.07035994f, -0.05872218f, 0.02097126f, 0.11240888f, -0.03864083f, -0.16589221f, -0.06703938f, 0.03660227f, 
    0.15057139f, 0.00142484f, -0.01671605f, -0.09872169f, 0.20734720f, 0.12816849f, -0.01453631f, 0.02107386f, 
    0.11704848f, -0.07570884f, 0.12586674f, 0.15812522f, -0.02957464f, 0.14351802f, -0.03737023f, -0.34585163f, 
    -0.03528136f, 0.03678260f, 0.15150231f, -0.02676686f, 0.09948542f, 0.11191468f, 0.02194807f, 0.10577560f, 
    0.38986474f, 0.00064070f, 0.12786850f, 0.18254045f, -0.11236511f, 0.03162090f, -0.07784513f, -0.01370089f, 
    0.06537797f, 0.02464144f, -0.01866760f, 0.07549167f, 0.60168344f, 0.18166551f, 0.20380530f, -0.01479107f, 
    0.09133418f, -0.07188866f, 0.05800176f, 0.01999567f, 0.02955257f, 0.18977250f, 0.08656047f, 0.14509866f, 
    0.24037214f, -0.01342321f, -0.02647876f, -0.18866812f, 0.03164965f, 0.00049355f, -0.14571300f, -0.00848272f, 
    0.05278051f, 0.01429244f, 0.07324585f, 0.14402112f, 0.21173503f, -0.23113504f, -0.18312754f, 0.18022379f, 
    -0.01733046f, 0.05137721f, 0.04911169f, 0.02281867f, 0.10972403f, 0.18156113f, 0.01060415f, 0.14597745f, 
    -0.04554516f, -0.13732071f, 0.15968533f, -0.09402218f, 0.01968969f, -0.04791347f, 0.02119604f, -0.07389747f, 
    0.02731882f, -0.03669928f, -0.08606558f, 0.06453953f, 0.23081784f, -0.14100848f, -0.09359685f, 0.35068908f, 
    0.04964700f, 0.01233637f, -0.04642387f, 0.02133002f, -0.11542653f, 0.10147468f, 0.05438982f, 0.04789484f, 
    0.07947442f, -0.02036397f, 0.01890566f, 0.19902419f, 0.13294058f, -0.17851599f, -0.04615300f, -0.05084172f, 
    -0.06656897f, -0.12661660f, -0.04214566f, -0.04511957f, -0.19184282f, 0.00145030f, 0.14374085f, -0.34654152f, 
    -0.08506262f, -0.11258111f, 0.12749931f, -0.25951138f, -0.00218395f, 0.01135886f, 0.15670821f, 0.09626027f, 
    -0.08496103f, -0.01896833f, -0.11650147f, 0.19170395f, -0.01142421f, 0.11599138f, -0.15440780f, -0.00320965f, 
    0.00503161f, 0.05352293f, 0.03333946f, 0.05146305f, 0.06747129f, -0.00315732f, 0.22280726f, -0.35108715f, 
    0.04208999f, -0.01296326f, 0.09044261f, 0.02057490f, 0.05950839f, 0.07971757f, 0.12775110f, 0.02879901f, 
    0.20206153f, 0.16461244f, -0.10435772f, 0.00916574f, -0.03114242f, 0.10382275f, 0.04688273f, 0.04201607f, 
    -0.06938357f, 0.13217670f, -0.12937620f, 0.02804501f, -0.12009877f, 0.01625923f, 0.04292158f, 0.17614383f, 
    -0.00700010f, -0.00624011f, -0.09427203f, -0.08869473f, 0.05633032f, -0.09050962f, 0.10513209f, 0.03748878f, 
    -0.10193428f, 0.12520224f, 0.05949642f, 0.07612851f, 0.21331483f, -0.05327708f, 0.01785437f, 0.09004543f, 
    0.02687419f, -0.03135569f, 0.24779969f, -0.05886166f, -0.31544214f, 0.01646279f, 0.12575208f, -0.55718672f, 
    0.08964328f, -0.05524148f, 0.11625384f, -0.13198601f, 0.04033027f, -0.00281259f, -0.05768028f, -0.11023387f, 
    -0.12218826f, -0.03982973f, -0.06381413f, -0.18864788f, 0.06700351f, 0.15280452f, -0.00638006f, -0.05846511f, 
    0.10738588f, 0.00026596f, 0.13846709f, 0.22101551f, -0.43761769f, -0.23479550f, -0.11289451f, -0.21189219f, 
    0.09147623f, 0.01388113f, -0.02164012f, -0.02697449f, 0.00357092f, 0.04749941f, -0.07318424f, -0.00049320f, 
    -0.06726425f, -0.05153138f, 0.04136131f, -0.02996870f, 0.10808595f, 0.11248200f, 0.03397114f, 0.02255823f, 
    0.07714742f, -0.02426423f, -0.06118463f, 0.03265264f, 0.07552388f, 0.09367229f, -0.01084497f, 0.03576633f, 
    -0.00239789f, -0.07918458f, 0.07152363f, 0.13791294f, -0.05654591f, 0.15084699f, -0.01650354f, -0.01869773f, 
    -0.04355137f, -0.01967463f, -0.02309838f, -0.05588450f, 0.24004833f, 0.08536732f, 0.01960425f, -0.02344435f, 
    0.07268118f, -0.05132598f, 0.12679699f, -0.10249446f, -0.12352229f, 0.01950721f, 0.11048673f, 0.15020542f, 
    0.03109211f, 0.00311884f, 0.05373202f, -0.09701074f, 0.10860131f, 0.20942895f, -0.00306261f, 0.25839880f, 
    0.27584073f, 0.00321905f, 0.14012457f, -0.06235732f, 0.08322418f, -0.00571057f, 0.03021724f, 0.02435091f, 
    -0.02504471f, 0.02384149f, -0.02109314f, 0.10117681f, 0.44657713f, 0.17775397f, 0.12649527f, -0.00846118f, 
    0.08863364f, -0.11604621f, -0.07968450f, 0.03786821f, 0.02319466f, -0.03683557f, 0.05976788f, -0.01603441f, 
    -0.18093972f, -0.14616516f, -0.10029188f, 0.02614221f, -0.04098319f, 0.10972060f, 0.08807202f, -0.07096246f, 
    0.07711247f, 0.03116246f, 0.04477642f, 0.01444298f, 0.21635805f, 0.14567666f, 0.02145836f, 0.00888619f, 
    -0.02846182f, -0.06154190f, 0.10445080f, 0.00661816f, -0.02834040f, 0.00923908f, -0.08621564f, 0.09105914f, 
    0.34932411f, 0.15418762f, 0.01654295f, 0.06681948f, 0.06310926f, -0.12495414f, 0.05058759f, -0.05074375f, 
    0.09384751f, 0.07207557f, -0.02123886f, 0.09440120f, -0.36772388f, 0.02056456f, -0.38741669f, -0.35597491f, 
    0.12687804f, 0.02829714f, -0.02165895f, 0.08883554f, -0.01746127f, -0.00293188f, 0.08359814f, 0.04543119f, 
    0.38599062f, 0.04812188f, -0.06650092f, 0.26007065f, 0.02477326f, -0.10298384f, 0.06670032f, 0.09899175f, 
    0.10014611f, -0.00048355f, 0.01897519f, -0.01890922f, -0.22437665f, 0.28034770f, 0.08362602f, 0.30845895f, 
    0.04003948f, 0.10245872f, -0.01931962f, 0.08906455f, 0.00811796f, 0.07315622f, 0.10995931f, 0.07647514f, 
    -0.11186735f, -0.19644885f, 0.12238470f, 0.10152687f, 0.14470461f, 0.08997983f, -0.01812641f, -0.10251340f, 
    -0.01872421f, 0.08893587f, 0.00919071f, -0.07547080f, 0.00031768f, 0.07112149f, 0.15346777f, -0.05618619f, 
    -0.01712761f, -0.01068431f, 0.07886294f, 0.11121887f, -0.06910389f, 0.13673805f, -0.05249263f, -0.05636280f, 
    0.05736873f, 0.03876537f, 0.20562284f, -0.08565325f, -0.06075259f, 0.02883311f, -0.10228832f, 0.10587157f, 
    0.18625984f, 0.10601752f, 0.03619977f, 0.09274519f, 0.04906004f, -0.00587724f, 0.26617187f, -0.10588325f, 
    -0.01873300f, 0.09771469f, 0.07053942f, 0.03801590f, -0.02995538f, 0.00789133f, 0.09190132f, -0.04317681f, 
    0.12730721f, 0.02278133f, -0.05349270f, 0.16875795f, -0.03655642f, -0.13785936f, -0.15064126f, 0.07915163f, 
    0.07899819f, 0.01953961f, 0.01661024f, 0.11176760f, 0.03291517f, 0.13335794f, 0.10929383f, 0.15184930f, 
    -0.00853561f, -0.03590297f, 0.07675104f, 0.02371911f, 0.14590654f, -0.05902321f, 0.00790967f, -0.05909346f, 
    0.24594389f, 0.17978257f, 0.00223385f, 0.20615885f, -0.06512372f, -0.06550504f, 0.00978895f, 0.10694091f, 
    0.04076156f, -0.07825660f, 0.10825447f, 0.09193096f, -0.44097391f, 0.17406510f, -0.06793595f, -0.09119438f, 
    0.16821599f, 0.01016409f, 0.02890103f, -0.08109155f, 0.17221181f, 0.18281476f, 0.04394967f, 0.04866401f, 
    -0.28288096f, -0.08445670f, -0.01582306f, -0.14374797f, 0.01393451f, 0.13048090f, 0.01610788f, -0.18331881f, 
    -0.02697028f, 0.06380098f, 0.06120386f, 0.12581977f, -0.44227296f, 0.11442336f, -0.19256838f, -0.10852268f, 
    0.18274787f, -0.05108889f, 0.03032100f, -0.07946114f, -0.01978298f, -0.04689007f, 0.05869010f, -0.06362428f, 
    0.06555829f, -0.03768644f, 0.02059900f, 0.27278405f, -0.03117995f, -0.05160787f, 0.00866585f, 0.11944855f, 
    -0.08712032f, -0.08221426f, 0.01708883f, -0.00287728f, -0.27119094f, 0.03079636f, 0.11892780f, 0.18209337f, 
    0.01473939f, 0.04201991f, -0.07791723f, -0.01625429f, 0.11458214f, 0.05111296f, -0.04384176f, 0.06217455f, 
    -0.02673630f, -0.07134291f, -0.08942663f, -0.12086716f, 0.22508615f, -0.12491988f, 0.03565370f, 0.05708415f, 
    -0.07652716f, 0.04517829f, -0.05021276f, 0.04990703f, 0.03570965f, 0.03253261f, 0.25229701f, -0.00814154f, 
    0.06836035f, 0.07280654f, 0.05564712f, -0.07476777f, 0.03158183f, 0.04171642f, 0.06460329f, -0.04544849f, 
    0.12356737f, -0.18744840f, -0.16049103f, -0.11712626f, 0.00653332f, -0.08501860f, 0.09933618f, -0.09571749f, 
    -0.03427301f, 0.03376811f, -0.14638332f, -0.11248870f, -0.36195609f, 0.08867296f, -0.08975710f, -0.07254873f, 
    0.18154585f, -0.01438519f, -0.08644293f, 0.01742174f, 0.00791245f, 0.01542349f, -0.12001815f, 0.09427319f, 
    0.03365811f, 0.07838298f, 0.14235239f, 0.21914603f, -0.03564510f, -0.03564191f, 0.10620380f, 0.01184257f, 
    -0.00077156f, 0.19509844f, 0.03125782f, 0.04568372f, -0.25648740f, 0.01171130f, 0.26656741f, -0.11404265f, 
    0.05189851f, 0.14926156f, -0.04525467f, 0.03599986f, 0.06027673f, -0.08243052f, -0.02653086f, 0.03406934f, 
    -0.00151823f, 0.00270880f, -0.04279707f, 0.02602877f, 0.03703681f, -0.03651312f, -0.00358193f, -0.01479558f, 
    -0.04604300f, 0.04000777f, 0.00564436f, 0.01599461f, 0.01163490f, 0.03485310f, 0.00004335f, 0.03641696f, 
    -0.04789785f, 0.02347090f, -0.02046199f, -0.02960061f, 0.03264853f, -0.03213871f, -0.03974501f, 0.01595966f, 
    -0.05331794f, -0.02606518f, 0.00223643f, -0.01723274f, 0.03423319f, -0.01501065f, -0.02744967f, 0.04097126f, 
    0.03818081f, -0.04755284f, -0.04281266f, 0.03926819f, 0.01121649f, -0.03003223f, 0.01771830f, 0.03756585f, 
    -0.05386889f, -0.01910924f, 0.02283914f, -0.04319902f, 0.01777834f, -0.03351863f, -0.02339293f, 0.02515668f, 
    -0.04731434f, 0.02476494f, -0.05629129f, 0.03319326f, -0.01638268f, -0.02594064f, 0.03047847f, 0.00208682f, 
    0.04377433f, -0.03489260f, -0.05064629f, -0.01681280f, -0.05278461f, -0.00250359f, -0.04214083f, -0.05307879f, 
    -0.02260485f, -0.02517216f, 0.03429620f, 0.01293787f, -0.05592452f, -0.03827930f, 0.03960474f, -0.00162774f, 
    0.00099098f, -0.03394203f, -0.00390069f, -0.03590141f, 0.00549224f, -0.02606232f, 0.00214567f, 0.02250882f, 
    0.00972788f, -0.01002552f, -0.00686503f, 0.01359849f, 0.03273217f, 0.02189553f, -0.01928120f, 0.00122218f, 
    0.00748336f, -0.05325910f, 0.00381080f, 0.04008265f, 0.04181400f, -0.04562593f, -0.01512596f, 0.03671865f, 
    -0.04140876f, -0.03305228f, -0.00586438f, 0.00086295f, 0.03349533f, -0.02478121f, 0.04450388f, 0.00433866f, 
    0.01998720f, -0.04238437f, 0.03774050f, 0.03953512f, 0.00817232f, -0.02958214f, 0.03478099f, -0.01902218f, 
    -0.00248975f, 0.02466919f, 0.01807830f, -0.04482193f, 0.00276806f, -0.03846997f, -0.04145887f, -0.00508169f, 
    -0.01124936f, 0.03185528f, 0.02428108f, -0.00677869f, -0.04954139f, 0.03880624f, 0.00016259f, -0.03571984f, 
    0.00782058f, -0.02728956f, 0.01457974f, 0.01752883f, -0.04961025f, 0.04201072f, -0.02938554f, 0.01260333f, 
    -0.02884112f, -0.01661075f, -0.04811367f, -0.03960276f, -0.01697441f, -0.00261163f, -0.01987416f, -0.03427952f, 
    -0.02294819f, -0.05019299f, -0.03948025f, -0.03074885f, 0.04316691f, 0.04156389f, -0.03510667f, -0.04669445f, 
    -0.03184050f, 0.01501269f, 0.00551686f, -0.00938346f, -0.05291265f, -0.05568616f, -0.00417614f, 0.00460207f, 
    -0.02113102f, 0.00132409f, 0.04476966f, -0.00517475f, -0.02713650f, -0.04479779f, -0.01319624f, 0.04250007f, 
    0.01293768f, -0.05352268f, 0.02788010f, -0.04339826f, -0.01656909f, -0.05532049f, 0.01486896f, 0.02462872f, 
    -0.03457328f, -0.00916296f, 0.00926518f, 0.00350262f, 0.04403375f, -0.05531346f, -0.05182274f, -0.04370572f, 
    0.01414677f, 0.00363089f, 0.01480650f, 0.00105623f, 0.02302304f, -0.02848548f, 0.03556430f, 0.02976097f, 
    0.03077969f, -0.05616275f, 0.01027598f, 0.03290695f, -0.00935846f, 0.04554786f, -0.04044152f, -0.03615374f, 
    -0.01190249f, 0.00900043f, -0.00759887f, -0.01991444f, -0.03076372f, 0.02330660f, 0.03896721f, -0.02151933f, 
    0.02254730f, 0.00410346f, -0.03355784f, -0.03487971f, 0.00955138f, 0.00498186f, 0.00026697f, -0.03608977f, 
    -0.02880148f, -0.03553115f, -0.01497995f, 0.00038836f, -0.05282634f, -0.01814536f, 0.00474624f, 0.04325977f, 
    -0.00994604f, 0.02892631f, -0.03361269f, 0.01378885f, 0.03357480f, 0.00210412f, -0.04688156f, -0.00509789f, 
    0.00250426f, -0.04035551f, -0.01339956f, 0.01392842f, -0.04221916f, -0.01532261f, -0.02873524f, -0.02003948f, 
    0.00807173f, -0.03062970f, -0.02773161f, -0.00836449f, -0.05459083f, -0.01916700f, 0.01608476f, 0.04192841f, 
    -0.00863807f, 0.00933609f, -0.05370668f, -0.01578544f, 0.00582409f, -0.03754208f, 0.00013213f, 0.03111231f, 
    0.00550332f, 0.02273987f, -0.04619144f, -0.05039177f, -0.00968225f, -0.04589550f, -0.03702849f, -0.00482589f, 
    0.03362956f, -0.04408617f, 0.03131881f, -0.03208319f, -0.02272663f, 0.01103603f, 0.04274922f, -0.04438588f, 
    -0.05602342f, -0.03286871f, -0.01137590f, 0.01749514f, -0.02686495f, -0.02210379f, -0.01012727f, -0.03561126f, 
    -0.04918854f, -0.00504111f, 0.02919851f, -0.00484877f, 0.00873571f, 0.01247942f, -0.00628884f, -0.02511931f, 
    -0.01327029f, 0.03968679f, -0.00560794f, 0.03198283f, -0.02441544f, 0.02140491f, 0.03712576f, -0.04534820f, 
    -0.01755777f, -0.04542652f, -0.04549411f, 0.00862684f, 0.03309777f, -0.00195734f, 0.00638476f, 0.03461668f, 
    0.04233954f, -0.01887025f, -0.04725244f, -0.04345982f, 0.01603662f, 0.00806204f, 0.00927339f, 0.03409657f, 
    -0.05504233f, -0.03063964f, 0.02415026f, -0.04385549f, -0.03887458f, -0.05355245f, -0.01420585f, 0.03177578f, 
    -0.02108148f, 0.02477176f, 0.03305221f, -0.03973003f, -0.00415867f, -0.05192139f, -0.04978353f, -0.05484465f, 
    0.04567220f, 0.04181204f, 0.02767086f, -0.02036202f, -0.03469283f, 0.00764794f, -0.00682295f, 0.03175253f, 
    -0.02117236f, -0.00167247f, -0.01118481f, -0.04377885f, 0.02673821f, -0.05418506f, -0.04571536f, 0.01539035f, 
    -0.00084544f, 0.01563055f, -0.01123752f, 0.01080547f, 0.02073350f, -0.04187915f, 0.02147108f, -0.04537917f, 
    -0.02169792f, -0.01075725f, 0.00716478f, -0.01804458f, -0.03021201f, 0.00216877f, 0.04241798f, -0.00753009f, 
    -0.00201288f, 0.00360980f, 0.00334387f, -0.04245017f, -0.05325904f, 0.02354059f, -0.01996942f, 0.00848245f, 
    0.03236530f, -0.04386366f, 0.02427292f, -0.02792133f, 0.00824714f, -0.02654769f, 0.01515873f, -0.04700059f, 
    -0.01530625f, -0.00268861f, -0.05495305f, -0.02789370f, -0.01971193f, 0.02904858f, -0.04362104f, -0.04308533f, 
    -0.10710001f, -0.02631103f, -0.12671565f, -0.11786043f, 0.07482081f, 0.11847434f, 0.06538173f, -0.07855502f, 
    0.09484544f, -0.06562658f, 0.03660640f, 0.11223504f, 0.03048248f, -0.09272887f, -0.19866924f, -0.05268270f, 
    -0.11054768f, 0.00410933f, 0.10817130f, 0.03619872f, 0.08002248f, 0.03230225f, -0.13612700f, 0.10745300f, 
    -0.05555193f, -0.02891602f, 0.03894544f, 0.04378185f, 0.09199198f, 0.14340451f, 0.12956381f, 0.06898299f, 
    -0.00905502f, 0.17853443f, 0.06848545f, -0.01022781f, 0.09947088f, -0.02309510f, -0.02135649f, -0.12531728f, 
    -0.03968628f, 0.03214680f, 0.13077724f, -0.01185181f, -0.04702055f, 0.12716943f, 0.17239554f, -0.02412204f, 
    -0.28551525f, -0.03644161f, 0.06252132f, -0.20731026f, 0.18165511f, 0.07839523f, 0.01844944f, 0.02783898f, 
    0.13825950f, -0.02747526f, 0.08067257f, 0.24896570f, 0.16706909f, -0.19095707f, 0.19593994f, 0.11959475f, 
    -0.01049083f, -0.00791893f, 0.00055297f, -0.04936109f, 0.01053141f, 0.24084146f, -0.06029479f, 0.13545170f, 
    -0.12991089f, -0.13089778f, -0.01084344f, -0.16837405f, 0.16053239f, -0.05699724f, 0.19683930f, 0.01565356f, 
    -0.00785494f, 0.01412372f, -0.08515482f, 0.04900184f, 0.25761586f, 0.13369368f, -0.02164476f, -0.11640384f, 
    -0.04432098f, 0.09058803f, 0.04007437f, 0.17261562f, -0.10413981f, 0.06995030f, 0.09341983f, 0.02701825f, 
    0.19076997f, -0.09121665f, 0.01760472f, 0.06513239f, -0.08672532f, 0.15336163f, 0.13950236f, 0.07519247f, 
    0.09189874f, -0.14917913f, 0.09552752f, 0.10732110f, 0.02232886f, 0.14384085f, 0.21943207f, 0.16525622f, 
    0.00027506f, 0.12422835f, 0.06750312f, 0.00852923f, 0.00804250f, 0.07918520f, -0.13350873f, 0.12563492f, 
    0.25593355f, 0.01065706f, -0.05532585f, 0.08411687f, 0.17045456f, 0.10908486f, 0.13667516f, 0.10655346f, 
    0.14635526f, 0.18843997f, 0.01990483f, 0.04926527f, 0.06622154f, -0.07431660f, -0.07145163f, -0.18626124f, 
    -0.01091206f, -0.04467420f, -0.00788142f, 0.07142704f, 0.07712631f, -0.02684674f, -0.02673292f, -0.00877359f, 
    -0.12344857f, 0.20625535f, 0.20107983f, 0.09232820f, 0.06173128f, 0.05221553f, 0.07494617f, 0.24689901f, 
    0.02623989f, -0.09229136f, -0.15415438f, 0.01439148f, 0.21064664f, 0.11059631f, 0.20445341f, 0.21345586f, 
    0.12071917f, 0.23881461f, 0.10666785f, 0.08564703f, -0.03981353f, 0.10750125f, 0.05707919f, 0.18157719f, 
    -0.31672218f, -0.13442121f, 0.11496937f, 0.00371132f, 0.00519146f, 0.01328919f, -0.00980142f, -0.02851791f, 
    -0.06518524f, 0.12949650f, -0.11893627f, -0.08149893f, 0.09331746f, 0.19991039f, 0.07452103f, -0.08255025f, 
    -0.03135568f, -0.02082722f, 0.06802183f, 0.17925389f, 0.04702838f, 0.32610157f, -0.06146044f, -0.00747618f, 
    -0.05698580f, 0.20117332f, 0.26486585f, 0.18567030f, 0.01554093f, -0.10321551f, -0.17234567f, 0.08084762f, 
    0.09301785f, -0.01859031f, 0.03636805f, -0.11913755f, 0.20517369f, 0.02919271f, 0.13394924f, 0.15015058f, 
    -0.15819478f, 0.01097242f, 0.11293071f, 0.06067439f, 0.00740940f, -0.03368976f, -0.00386888f, -0.08742513f, 
    0.23367684f, -0.00801090f, 0.02406096f, 0.26041618f, -0.07713173f, 0.08452285f, -0.01600382f, 0.07369815f, 
    0.03295594f, 0.07874038f, 0.12556517f, -0.05438130f, 0.21591485f, 0.20194770f, -0.11497723f, -0.18313274f, 
    -0.02816165f, -0.00024114f, -0.05257921f, 0.03290306f, 0.17890821f, -0.04217262f, 0.00550496f, -0.01889617f, 
    0.38158062f, 0.00548600f, 0.18044789f, 0.34617051f, 0.05943964f, -0.12272350f, -0.14831021f, 0.10273567f, 
    0.13886508f, 0.07717896f, 0.14704311f, 0.04518193f, -0.20040946f, -0.15523690f, -0.07041553f, -0.11604022f, 
    0.07659367f, -0.00399639f, 0.00731617f, -0.13068601f, 0.07662483f, 0.05680234f, -0.01121064f, 0.02545075f, 
    -0.05470363f, 0.14495139f, -0.06369444f, -0.05941913f, -0.01631677f, 0.12072194f, 0.07221273f, -0.06397627f, 
    -0.03311847f, 0.05586279f, 0.04038673f, 0.18771669f, -0.36993891f, 0.09566032f, -0.07604833f, -0.15326162f, 
    0.04472720f, 0.13680016f, -0.01437997f, 0.01454576f, 0.06770428f, 0.00807465f, 0.15506874f, -0.04290799f, 
    0.26572508f, 0.20325685f, -0.20956202f, 0.42553788f, 0.12475017f, 0.06786393f, 0.04969689f, 0.21920797f, 
    -0.03753936f, 0.02108857f, 0.16276565f, -0.07975664f, -0.42338994f, -0.17729527f, 0.10770417f, 0.25992140f, 
    0.03894894f, -0.02014067f, -0.00394259f, 0.24432950f, -0.09019017f, -0.00159121f, -0.10140237f, -0.04053662f, 
    -0.14379527f, -0.16941924f, -0.09106832f, -0.15042734f, 0.13705927f, 0.01893523f, 0.12519093f, 0.04862795f, 
    0.02652557f, -0.03659581f, -0.03404479f, -0.06358230f, 0.34518546f, 0.11115411f, 0.32779112f, 0.22872642f, 
    0.10036933f, 0.27537042f, 0.02427707f, -0.03908112f, -0.04114734f, -0.02613909f, 0.01894187f, -0.05426925f, 
    0.26405936f, -0.04992296f, -0.10661872f, -0.18722567f, -0.05455275f, -0.09320255f, -0.03816886f, -0.10590201f, 
    -0.11910367f, 0.09281128f, -0.13775395f, 0.02288437f, -0.18551578f, -0.01721861f, -0.10037699f, -0.05041978f, 
    0.08786823f, 0.06290086f, 0.10078906f, 0.03863724f, -0.10056736f, 0.08711738f, -0.01306354f, 0.01330071f, 
    0.20103866f, 0.12510824f, 0.10408440f, -0.00880746f, -0.05225563f, -0.05389839f, 0.12849714f, -0.03958132f, 
    -0.00853223f, 0.21904027f, -0.11973185f, 0.07775382f, 0.31073895f, -0.06511755f, 0.17385103f, 0.19768849f, 
    -0.05238576f, 0.11585478f, 0.00963812f, 0.24000238f, -0.05417506f, 0.06740569f, 0.00782267f, 0.08955476f, 
    0.00279023f, -0.02968706f, -0.01828409f, 0.04799878f, -0.04314253f, -0.02921296f, 0.03038287f, -0.02355221f, 
    0.00374113f, -0.04550419f, 0.02047180f, -0.05099525f, 0.00593275f, 0.00606492f, -0.04730874f, 0.01762017f, 
    -0.03387057f, 0.01232526f, -0.01245556f, -0.02947955f, -0.04422791f, 0.02318062f, 0.04506973f, 0.00679298f, 
    0.01005376f, 0.03081317f, 0.00803482f, 0.04161206f, -0.02366683f, -0.02171120f, -0.05238554f, -0.04027437f, 
    -0.01166993f, -0.03601333f, 0.04517944f, -0.02885341f, -0.01905015f, -0.01463322f, -0.04393973f, 0.04111103f, 
    -0.04328224f, -0.05369055f, -0.02231748f, 0.04104095f, -0.03407724f, -0.01756053f, 0.01651960f, 0.01481856f, 
    -0.04703531f, -0.02991593f, -0.03488408f, 0.00507959f, 0.00138328f, -0.05542322f, 0.01740731f, -0.01344230f, 
    0.02942945f, -0.03979579f, 0.00250344f, -0.04137551f, -0.00176092f, -0.05006244f, -0.00326261f, -0.02502516f, 
    -0.01257092f, -0.01974353f, 0.05012074f, -0.02440490f, 0.04224058f, -0.00283321f, 0.02416777f, -0.00419453f, 
    -0.03189812f, -0.01584843f, 0.02659180f, -0.01168047f, 0.00544980f, -0.02398650f, -0.01526723f, 0.02234747f, 
    0.01093599f, 0.03824050f, -0.04104321f, -0.01813423f, 0.01931455f, 0.01138542f, -0.03922856f, -0.04181170f, 
    -0.00164063f, -0.00343572f, -0.02744462f, -0.02762154f, 0.02521321f, -0.03656299f, 0.00828851f, -0.04743280f, 
    0.00854533f, 0.02504702f, -0.00363339f, -0.03559452f, -0.00697875f, -0.05252586f, 0.01591065f, 0.01946932f, 
    -0.01340199f, 0.00583052f, 0.03432541f, -0.02732584f, 0.00082047f, -0.02988482f, -0.03087136f, -0.05872232f, 
    0.04513989f, 0.01177132f, -0.01431881f, 0.04050621f, 0.00435434f, -0.00081862f, 0.03128549f, -0.03226889f, 
    0.03285675f, -0.01868848f, -0.03742663f, -0.01526656f, 0.04143743f, -0.04243265f, -0.04068310f, -0.05595636f, 
    -0.02338336f, -0.02755088f, -0.00902655f, -0.03385249f, 0.00455606f, 0.02691310f, 0.01836731f, 0.02091247f, 
    0.03532419f, -0.01428966f, -0.01113385f, 0.01419086f, -0.04323669f, 0.01506639f, -0.01741380f, -0.04745019f, 
    0.01040111f, -0.03489750f, -0.00647731f, 0.02073548f, 0.03029415f, -0.03900328f, -0.01959457f, -0.04239674f, 
    0.00807295f, -0.05887278f, -0.01748337f, 0.01248221f, -0.03954400f, -0.02639734f, -0.00431197f, 0.00603941f, 
    -0.01244089f, -0.01615146f, 0.04013184f, -0.01893204f, 0.01872227f, -0.02902838f, -0.03617113f, 0.01753946f, 
    0.02550607f, -0.00087110f, 0.02634533f, -0.02708151f, -0.02631159f, 0.02601865f, -0.04856363f, 0.03290517f, 
    0.03581333f, -0.03458915f, 0.02896470f, -0.02345021f, 0.01543365f, 0.02008012f, -0.02925169f, 0.02966575f, 
    -0.03436980f, 0.03119986f, -0.03198639f, -0.03494524f, 0.03918464f, -0.01144952f, -0.00849294f, -0.02097580f, 
    0.01691714f, -0.03288528f, -0.03887776f, 0.01050417f, -0.04570949f, -0.03643043f, 0.04194165f, -0.01129529f, 
    -0.05775473f, 0.00215119f, 0.03810414f, 0.03257231f, -0.05132871f, 0.04125608f, 0.02863336f, -0.00489566f, 
    -0.02855167f, 0.00264272f, 0.03584877f, 0.01898360f, -0.02043131f, 0.00156205f, -0.03198195f, -0.04575716f, 
    -0.05265658f, 0.01275570f, -0.03775883f, -0.02485701f, -0.03920339f, -0.06104004f, 0.03905737f, -0.04188059f, 
    -0.05736114f, 0.01845766f, 0.02365466f, 0.03397164f, 0.02626494f, 0.00941230f, -0.04781039f, 0.01514500f, 
    0.00949048f, 0.00677196f, 0.02662056f, 0.00040784f, -0.03086467f, 0.03579735f, -0.00021366f, 0.00224027f, 
    -0.04454791f, -0.03113273f, 0.00877788f, 0.01598726f, -0.04358035f, -0.00683262f, 0.01611523f, -0.04635662f, 
    -0.03608422f, 0.02830827f, 0.02383814f, -0.01580288f, -0.01009250f, 0.01004778f, 0.00498640f, -0.05211388f, 
    0.00597759f, -0.03724413f, 0.03293601f, -0.02224306f, -0.00913374f, -0.03846217f, 0.00766018f, -0.03069525f, 
    -0.03096883f, -0.00446581f, 0.00905548f, -0.02361828f, 0.00767253f, -0.01779335f, 0.04192134f, -0.05790630f, 
    -0.01084870f, 0.04781080f, 0.04141448f, 0.01909979f, -0.03870254f, 0.03925467f, -0.00827562f, 0.00136099f, 
    -0.00908604f, 0.05014749f, -0.03338561f, -0.04088155f, -0.04716606f, 0.00258685f, 0.01778642f, 0.00398835f, 
    -0.03693729f, 0.00222818f, -0.01932455f, 0.04002464f, 0.04960454f, -0.02826455f, 0.02991763f, -0.00028067f, 
    -0.04019181f, 0.02496204f, -0.03983212f, -0.00745846f, -0.01181671f, 0.01274357f, 0.00133160f, -0.05462842f, 
    0.01791090f, -0.01607189f, -0.00433681f, 0.02752086f, 0.02997421f, -0.05114564f, -0.03419366f, 0.03318414f, 
    0.02553763f, -0.01942560f, -0.03116965f, 0.04629653f, -0.00777825f, 0.03421077f, -0.01374922f, 0.02488581f, 
    0.03063359f, -0.03144706f, -0.02018003f, -0.04594100f, -0.03799722f, -0.02527239f, 0.03739773f, 0.01394536f, 
    0.00578314f, -0.00163777f, -0.01727963f, 0.01692434f, -0.00591844f, -0.04969677f, -0.03087706f, 0.02754020f, 
    0.02710433f, -0.05776056f, -0.02743843f, 0.01689109f, -0.01656806f, -0.04462143f, -0.05580816f, -0.04549139f, 
    0.02738185f, -0.02972332f, 0.00677205f, -0.00216862f, -0.02614005f, 0.00156242f, 0.04474751f, 0.01727004f, 
    0.02255430f, 0.01155955f, 0.03555308f, 0.00956625f, -0.00989525f, -0.03484509f, 0.02009692f, 0.02814098f, 
    0.03512305f, 0.03626828f, 0.03242728f, -0.06104371f, -0.04267321f, 0.03807180f, -0.04681579f, 0.01544941f, 
    0.04741061f, -0.02009198f, -0.05093070f, -0.03136240f, -0.00438620f, 0.00903256f, 0.01031811f, 0.01155447f, 
    -0.00399432f, 0.02996252f, -0.05130932f, 0.03459533f, 0.01163132f, -0.01393033f, -0.01586073f, 0.05023253f, 
    -0.00574882f, -0.05164685f, -0.02735328f, 0.03991742f, -0.04760791f, -0.00316141f, -0.01731866f, -0.03028951f, 
    -0.00402680f, 0.01863076f, 0.05642218f, 0.03791279f, 0.00458886f, -0.00779714f, 0.01005831f, -0.00377548f, 
    0.00659906f, -0.04566995f, 0.03366771f, 0.00674544f, -0.01007660f, -0.05137689f, 0.03476468f, 0.00155743f, 
    -0.01200735f, -0.00306608f, 0.02785493f, -0.02563374f, 0.00066248f, -0.04068179f, -0.04290316f, 0.00942212f, 
    0.02426797f, -0.02673483f, 0.00689688f, -0.03576589f, 0.00581868f, 0.03684983f, -0.05345837f, 0.02234174f, 
    -0.04345794f, -0.05501014f, 0.03232464f, -0.04869743f, 0.00352173f, 0.03867162f, -0.04314386f, 0.03733465f, 
    -0.00631011f, -0.00705871f, 0.01524606f, 0.03837526f, -0.03560042f, -0.05232415f, -0.04116590f, -0.04784941f, 
    -0.04860990f, -0.05839783f, 0.00626348f, 0.00860863f, 0.03295807f, 0.02607572f, 0.03091088f, -0.04246290f, 
    -0.01398710f, 0.00893176f, -0.02287958f, -0.00211627f, 0.03896157f, 0.01058801f, 0.03474497f, 0.00645944f, 
    -0.03374601f, 0.02675031f, 0.00810065f, -0.04650899f, -0.05416790f, -0.02941217f, -0.05305599f, -0.04697097f, 
    -0.04643934f, -0.02661553f, -0.00755437f, 0.00004543f, 0.03677318f, 0.00792505f, 0.02171089f, 0.02005081f, 
    -0.00752782f, -0.00758891f, 0.03364110f, 0.01559347f, -0.02098608f, -0.03734195f, -0.04132938f, 0.02673499f, 
    0.02692048f, -0.02584106f, -0.03846121f, 0.01945136f, -0.04389191f, -0.00955058f, -0.05004722f, -0.02643512f, 
    0.00297163f, -0.04842308f, 0.01038080f, -0.00895805f, 0.03957673f, 0.00928900f, 0.02181829f, 0.02257957f, 
    0.05761495f, 0.03676905f, -0.03379794f, 0.03980507f, -0.02282749f, -0.03689811f, 0.00051640f, 0.01229340f, 
    -0.00246222f, 0.03521840f, -0.01864623f, -0.01083794f, -0.01289607f, 0.01747572f, -0.01920210f, 0.04602136f, 
    0.01247123f, -0.03399210f, -0.03522636f, 0.03262872f, -0.03222955f, -0.02005327f, 0.02501748f, -0.05414743f, 
    0.02470241f, 0.00742599f, -0.02039015f, 0.00559984f, 0.02110683f, -0.05731183f, -0.03413603f, 0.03506755f, 
    -0.01392605f, -0.03749577f, 0.02687592f, -0.02894554f, -0.01389692f, -0.03514985f, -0.02333333f, -0.03062111f, 
    0.03209665f, -0.00499774f, -0.05520521f, 0.00184121f, 0.04671352f, -0.04861830f, -0.00937849f, -0.02212749f, 
    -0.04936358f, -0.01215420f, 0.04184575f, -0.00028642f, 0.05008899f, -0.02639841f, 0.04138337f, -0.04220260f, 
    -0.01845746f, -0.05496726f, 0.02661817f, -0.01219283f, 0.00664678f, -0.00608912f, -0.01832966f, -0.00831422f, 
    0.03313283f, 0.01179599f, -0.05803868f, 0.00795411f, 0.03034328f, 0.01151414f, 0.03988227f, -0.00890680f, 
    0.03065697f, 0.02784260f, 0.00535769f, 0.04618275f, -0.01011355f, -0.00639362f, 0.00568840f, -0.04335021f, 
    -0.03749155f, -0.04137674f, -0.01620237f, -0.02384745f, 0.01522562f, -0.04079822f, 0.00816811f, 0.00040348f, 
    -0.02585134f, -0.00088700f, -0.00281870f, 0.04000527f, -0.00572480f, -0.04743888f, -0.05420173f, 0.00207244f, 
    0.00949723f, 0.03162311f, -0.05196291f, 0.00034455f, 0.02441315f, 0.00234784f, -0.01030179f, -0.05553009f, 
    -0.03698485f, 0.01666158f, -0.03053084f, -0.01829961f, -0.00983268f, 0.01008247f, -0.04841862f, 0.03877760f, 
    -0.01248680f, 0.01662666f, 0.02330632f, -0.03667253f, -0.00407199f, 0.00872351f, -0.01715371f, -0.05057601f, 
    0.00271729f, -0.04936794f, 0.02148092f, -0.03192005f, 0.00681606f, 0.01553137f, 0.04596018f, -0.02405635f, 
    0.00725976f, -0.03021588f, 0.00725149f, 0.04995041f, -0.03424385f, -0.04000192f, -0.01428281f, 0.01349066f, 
    0.03700564f, 0.03439875f, -0.03467902f, -0.01806964f, -0.04681180f, -0.02993332f, 0.02555514f, 0.04154090f, 
    -0.00559456f, 0.03901350f, -0.04353281f, 0.04431228f, -0.03136549f, 0.02563005f, -0.01609896f, -0.04114144f, 
    -0.01591952f, -0.03782563f, 0.01188951f, -0.04569940f, 0.01090509f, 0.00069792f, -0.01288642f, -0.00133957f, 
    -0.01014590f, 0.01734428f, 0.03067451f, -0.04204538f, -0.03189098f, -0.02771681f, -0.05623544f, 0.00923816f, 
    -0.00185043f, -0.00371006f, -0.00689251f, 0.04045542f, -0.02245746f, -0.04146787f, 0.03204283f, -0.04247997f, 
    0.00075719f, -0.00382532f, 0.03374212f, 0.02472886f, 0.03165639f, -0.00680839f, 0.01159377f, 0.03602511f, 
    -0.01811666f, 0.03124803f, 0.03570946f, 0.02176797f, -0.05618052f, -0.03054900f, -0.00925867f, -0.03033689f, 
    -0.03414409f, -0.00481291f, 0.01816296f, -0.01470959f, -0.01717900f, -0.03427341f, -0.03771519f, -0.03933476f, 
    -0.03186741f, 0.02208719f, 0.03618070f, 0.01754909f, -0.01709135f, 0.01045487f, -0.02785823f, 0.00253537f, 
    0.03288878f, 0.02986660f, -0.02940381f, 0.03283246f, -0.04105589f, -0.04324222f, 0.02213793f, -0.03756151f, 
    -0.05106869f, 0.03865035f, 0.04371284f, 0.03559362f, -0.02974289f, -0.02784957f, -0.05740071f, 0.01393769f, 
    -0.03521900f, -0.01965894f, -0.02409275f, -0.05422063f, -0.01536383f, -0.05300578f, -0.00832140f, 0.01338108f, 
    0.01616556f, 0.00589235f, 0.00639958f, -0.06034883f, -0.03703153f, -0.04097426f, 0.02498769f, 0.00674392f, 
    -0.00573516f, 0.04046115f, 0.04136141f, -0.03136606f, -0.04770480f, 0.02182827f, -0.02116533f, 0.04681370f, 
    0.01201322f, -0.02502060f, -0.00139627f, -0.02168035f, -0.00742900f, -0.02115181f, 0.02373802f, -0.00275561f, 
    -0.05318345f, -0.04576708f, 0.04630778f, -0.00910105f, 0.01457326f, 0.04485767f, -0.02289372f, 0.01502834f, 
    0.00527456f, 0.03480789f, -0.03494494f, 0.05449146f, -0.00876091f, 0.02097576f, 0.00427920f, -0.04049636f, 
    0.29181972f, -0.11943069f, -0.11999903f, 0.10239527f, 0.05481073f, 0.13242657f, -0.10397299f, 0.04543903f, 
    0.07623627f, -0.02325864f, -0.05686058f, 0.04753141f, 0.10892339f, 0.07747140f, 0.05813940f, -0.03626894f, 
    0.20604135f, 0.11905268f, -0.13791294f, -0.01945909f, 0.21273161f, 0.02670986f, 0.11754222f, -0.08401120f, 
    -0.52534670f, -0.04275287f, -0.17358063f, 0.07512181f, -0.02703442f, 0.04214436f, 0.02857144f, 0.06346533f, 
    0.16073777f, 0.14247987f, 0.04615048f, 0.14736015f, -0.20759133f, 0.15977581f, 0.16126777f, 0.35827684f, 
    -0.07769351f, -0.11869929f, 0.04844746f, 0.09775512f, -0.04168690f, -0.08160146f, 0.20722726f, 0.05058202f, 
    -0.04645199f, 0.06481680f, -0.10604105f, 0.20671551f, 0.09532831f, 0.07107735f, -0.08083621f, 0.06849942f, 
    -0.00598689f, 0.11855564f, 0.16412798f, -0.01557206f, -0.18230632f, 0.07431782f, -0.30814311f, -0.18763831f, 
    -0.10998905f, 0.01820208f, 0.01511547f, -0.07724056f, -0.05643555f, 0.13057970f, -0.01554385f, 0.01750382f, 
    -0.07233382f, 0.31818515f, 0.09153929f, 0.10709649f, -0.23884425f, 0.12222766f, 0.14530081f, -0.00221581f, 
    -0.00726494f, 0.02546132f, -0.04118139f, -0.14880133f, -0.19424056f, -0.01348072f, 0.13586608f, -0.15470521f, 
    -0.30793360f, -0.02744961f, -0.03549879f, 0.11820906f, 0.06096591f, 0.07829963f, 0.04136444f, -0.07924508f, 
    -0.16137068f, 0.18709543f, -0.19119951f, 0.19726771f, 0.12483259f, 0.07296710f, -0.01857435f, 0.19376163f, 
    0.21321677f, 0.07007940f, -0.07149599f, -0.02557806f, 0.05652262f, 0.14740652f, -0.24039535f, -0.01987662f, 
    0.00964848f, 0.08298057f, 0.13287275f, 0.07963008f, 0.04196487f, 0.03758618f, -0.14179224f, 0.01575854f, 
    0.08802906f, -0.35109770f, -0.02696013f, -0.12970264f, -0.07976705f, -0.03496533f, 0.01323498f, 0.15627164f, 
    0.05916749f, -0.02091092f, -0.05440011f, 0.05245004f, 0.10972386f, -0.21380438f, -0.08741142f, 0.33137172f, 
    0.03768929f, 0.09815784f, -0.02630129f, -0.06017868f, 0.14098123f, 0.03972059f, -0.06590194f, -0.10101402f, 
    -0.04630982f, 0.07300123f, 0.11815199f, 0.20229161f, -0.00319129f, -0.06431726f, -0.00708707f, -0.02544530f, 
    -0.01618633f, -0.06329951f, -0.01040398f, 0.05754734f, -0.37080324f, 0.18763685f, -0.06743596f, 0.04982705f, 
    0.09644096f, -0.19218637f, 0.08029387f, 0.02836095f, -0.03459800f, 0.07001760f, 0.08618049f, 0.15707786f, 
    0.37743351f, 0.01992767f, -0.09170959f, 0.09132453f, 0.08305688f, 0.00823463f, 0.03902672f, 0.11554574f, 
    0.04639209f, 0.08900440f, -0.01321185f, 0.04202608f, 0.17702585f, 0.10882648f, 0.19434179f, -0.08509311f, 
    -0.24682270f, -0.01865353f, 0.14367135f, -0.04132031f, -0.00114928f, -0.05959707f, 0.12367347f, 0.08417201f, 
    0.24719155f, 0.17042442f, -0.10674801f, -0.11986125f, 0.01517373f, 0.12963018f, 0.00017319f, -0.05347783f, 
    -0.10876714f, -0.00692738f, 0.11271854f, -0.04066671f, 0.08430056f, 0.06170350f, -0.12775980f, 0.09280960f, 
    0.14324914f, 0.08149644f, -0.05947895f, 0.03772217f, 0.06315238f, -0.06393149f, 0.03494045f, 0.08236802f, 
    0.30852452f, 0.06270367f, 0.16886437f, -0.02895405f, 0.05537905f, -0.14237711f, 0.10963266f, -0.06795640f, 
    0.11163458f, 0.01098234f, 0.05749236f, -0.02987561f, 0.28151309f, -0.21364367f, 0.10168570f, 0.26754603f, 
    -0.04038623f, -0.05050514f, -0.04265047f, 0.08341913f, -0.08641179f, -0.08863128f, -0.02321904f, 0.02850190f, 
    -0.27333900f, 0.30151466f, -0.16731139f, -0.15557198f, 0.20937909f, 0.00730250f, 0.12666684f, 0.15992396f, 
    -0.07427645f, 0.21798268f, 0.05658128f, -0.02052573f, 0.07816783f, 0.25188363f, 0.04514926f, 0.05717563f, 
    0.23885204f, 0.04244915f, 0.08836233f, 0.10556150f, 0.07999793f, 0.09833987f, 0.02964261f, -0.02871427f, 
    0.13017668f, 0.11411044f, -0.18072073f, 0.09363905f, 0.13539860f, 0.14126262f, 0.05611446f, -0.01469747f, 
    0.13674301f, -0.00371775f, 0.15459985f, 0.03762045f, 0.23746482f, -0.26798820f, -0.08921994f, -0.12305402f, 
    0.16387938f, -0.01342404f, 0.02559248f, 0.10075745f, -0.04103860f, -0.00898137f, 0.08548804f, -0.04978167f, 
    0.23005359f, -0.33524364f, 0.13419271f, -0.42429003f, -0.19472259f, -0.09810703f, -0.04662839f, 0.10109197f, 
    -0.12575328f, -0.17393295f, 0.05652285f, 0.15104222f, 0.08236187f, -0.06959087f, 0.07034443f, -0.17312615f, 
    -0.01129495f, -0.00747691f, -0.00657288f, -0.08137725f, 0.08619595f, 0.03939984f, -0.02662243f, -0.04620608f, 
    -0.10777237f, -0.23131175f, 0.12335771f, -0.16328649f, 0.04302975f, 0.00319710f, -0.07301293f, 0.10307633f, 
    0.03122299f, 0.06333709f, 0.01982479f, 0.01394283f, -0.08257404f, 0.19815090f, -0.38074100f, 0.04444259f, 
    0.16471930f, 0.04423618f, -0.02594177f, 0.01731238f, 0.02208978f, -0.03148337f, 0.02439992f, -0.12748294f, 
    0.09476151f, 0.07662053f, -0.03046996f, -0.17495006f, -0.07628565f, -0.05772184f, -0.03440480f, 0.02720384f, 
    0.01480411f, -0.04526526f, 0.00342123f, -0.00805442f, 0.43989292f, -0.13456985f, -0.03459600f, -0.07258489f, 
    -0.07895035f, 0.00245230f, 0.00456918f, -0.02296261f, 0.09567387f, 0.03290346f, 0.04303737f, 0.00417180f, 
    -0.04753906f, 0.07312657f, -0.07459212f, 0.12311458f, -0.34591866f, -0.12340400f, 0.04959830f, -0.06748349f, 
    0.10590057f, 0.09321305f, -0.08341332f, -0.00617660f, 0.38797501f, -0.11209100f, -0.15711486f, -0.11762124f, 
    0.04582040f, -0.08391825f, -0.05229959f, -0.04201563f, 0.18627231f, 0.04837437f, 0.09674897f, 0.04521468f, 
    0.25807902f, -0.07758771f, -0.13084070f, -0.06382362f, 0.01010476f, 0.02882799f, -0.18081030f, 0.03551661f, 
    -0.06259011f, -0.06361206f, 0.01235572f, -0.00626338f, 0.14253399f, 0.32254878f, 0.14237978f, -0.33378449f, 
    -0.07871114f, 0.02835509f, -0.10266072f, 0.01586890f, 0.14109804f, 0.05928250f, -0.08002014f, -0.05205155f, 
    -0.17853026f, -0.12229908f, -0.04060885f, 0.16698445f, -0.05053944f, 0.00250995f, -0.08459759f, 0.10917367f, 
    0.14884786f, 0.14670256f, 0.05172517f, 0.13940339f, -0.31777629f, 0.06222957f, 0.14984083f, 0.14488073f, 
    -0.01132489f, 0.00865204f, 0.11804312f, 0.04992135f, -0.08893406f, -0.04603587f, 0.44704008f, 0.06606076f, 
    -0.28803679f, -0.09073049f, -0.05228323f, 0.00805483f, 0.14781767f, 0.16682196f, -0.08189422f, 0.10350600f, 
    0.05870976f, 0.08955837f, 0.19103850f, 0.18679814f, 0.08148231f, 0.00882626f, -0.23339415f, -0.15112835f, 
    -0.06107248f, 0.05563014f, -0.03386194f, -0.21764076f, -0.07455304f, 0.16604580f, -0.13059288f, -0.06357882f, 
    0.05350797f, 0.08807884f, -0.05720379f, 0.21486406f, -0.06854256f, 0.04411595f, 0.14306140f, -0.05135280f, 
    -0.02987735f, -0.01360109f, -0.09416429f, -0.21993205f, -0.07712292f, 0.03752084f, -0.01434136f, -0.12068317f, 
    -0.07233344f, 0.15044986f, -0.09876814f, 0.04230899f, -0.06070882f, 0.09152482f, 0.14855032f, 0.09686178f, 
    -0.06282889f, 0.23306514f, -0.04004611f, 0.20769554f, 0.04970873f, 0.09486136f, -0.08282626f, 0.11427765f, 
    0.16747905f, -0.05094323f, 0.02913097f, 0.02593260f, -0.18103245f, -0.14327122f, -0.01621961f, 0.02244605f, 
    0.09754440f, 0.03695050f, 0.02269004f, -0.02164553f, 0.09963422f, -0.01088469f, -0.18106923f, 0.07259965f, 
    0.02451229f, -0.25690663f, -0.21165232f, -0.25070462f, 0.03625117f, -0.03242235f, 0.10532976f, 0.15237831f, 
    0.08418157f, 0.13764538f, -0.14614286f, 0.16592324f, -0.07238466f, 0.24793532f, -0.13227049f, -0.00399095f, 
    -0.06244578f, 0.01675726f, -0.01831466f, 0.02737201f, 0.09061012f, -0.07619416f, -0.08047590f, -0.06296535f, 
    -0.13024703f, -0.00571181f, 0.09765397f, 0.25641072f, -0.06553375f, -0.07475024f, 0.06509316f, 0.04548237f, 
    -0.00429626f, -0.15797867f, -0.10764902f, 0.02996456f, 0.04752327f, 0.15508480f, -0.24743432f, 0.08985045f, 
    0.10975432f, -0.09235656f, 0.07144208f, -0.03523690f, -0.11734032f, 0.05470472f, 0.04204287f, 0.23936248f, 
    0.08500086f, 0.02905136f, 0.09397949f, 0.00323055f, 0.05427084f, -0.15292808f, -0.03294122f, -0.05126420f, 
    0.13494509f, 0.17690915f, -0.27038664f, -0.09149849f, 0.06671412f, 0.21828258f, 0.18196291f, -0.10582776f, 
    0.09988271f, 0.01114215f, 0.15438376f, -0.05581333f, 0.10136753f, 0.26307613f, 0.00163836f, 0.04684559f, 
    0.33799332f, 0.03146650f, -0.01762638f, -0.00425206f, 0.02021250f, 0.05519682f, -0.17498650f, 0.03961530f, 
    -0.10327949f, 0.03833922f, 0.10946400f, -0.29830155f, 0.23873109f, -0.20831984f, -0.06832068f, 0.27806675f, 
    0.02180257f, 0.08385509f, -0.06683538f, 0.04040408f, -0.09395695f, -0.06918576f, 0.09095468f, -0.05881023f, 
    0.11477477f, -0.07005031f, 0.07410439f, -0.07388707f, 0.02980346f, -0.08592060f, 0.06178371f, -0.06220561f, 
    0.05302026f, -0.02313042f, 0.12429952f, 0.08278289f, 0.06818022f, -0.07153736f, 0.03871504f, 0.13357323f, 
    -0.01875531f, 0.02473987f, -0.02524657f, 0.06946611f, -0.02441568f, -0.01834154f, -0.12110338f, 0.01274165f, 
    -0.07137808f, 0.08267560f, -0.03802327f, 0.02969129f, 0.04686028f, -0.05712369f, 0.00103982f, 0.13366312f, 
    -0.11053177f, 0.11201935f, 0.07927482f, -0.05533161f, -0.20797196f, 0.39496320f, 0.21915522f, -0.13134538f, 
    0.15513758f, 0.12841848f, 0.03547873f, -0.10696770f, 0.04093284f, 0.05987457f, 0.06271029f, -0.02741778f, 
    0.11897670f, 0.34063345f, -0.00840449f, 0.06074779f, 0.06144556f, 0.08579926f, 0.01585286f, -0.04311361f, 
    -0.01286018f, -0.10014988f, 0.09473532f, 0.01190573f, -0.07753620f, 0.00466246f, 0.03147371f, -0.21306260f, 
    0.17279650f, 0.11616749f, -0.03347124f, 0.07324982f, -0.05140102f, -0.12628222f, 0.21910056f, -0.02509468f, 
    0.28095070f, 0.02902412f, 0.02347809f, -0.11453956f, -0.08453739f, 0.20170921f, -0.00863429f, 0.20276706f, 
    0.12210899f, -0.17851469f, 0.02376341f, 0.12731047f, -0.23562931f, -0.08348355f, -0.02814296f, 0.18359821f, 
    0.11215716f, 0.10211857f, -0.13876925f, 0.02495466f, -0.03373467f, 0.06282809f, -0.17964946f, -0.12225192f, 
    0.10118242f, -0.14814968f, 0.02020803f, -0.33826116f, 0.07524130f, -0.09336840f, 0.02257918f, 0.14919357f, 
    0.00781233f, 0.01732602f, -0.11338278f, -0.05864668f, -0.00043934f, 0.05520717f, -0.18713905f, 0.17600350f, 
    0.03736572f, 0.08125278f, -0.00794672f, -0.06785139f, -0.04121281f, -0.03593985f, -0.10141197f, -0.13713902f, 
    0.14838013f, 0.02751832f, -0.10987850f, -0.03500589f, 0.07215901f, -0.14934756f, -0.07000275f, -0.09661975f, 
    -0.00903915f, -0.07570316f, -0.17794450f, -0.09236303f, 0.25100100f, 0.21388836f, -0.13844723f, -0.21746911f, 
    -0.07674010f, 0.08814566f, 0.04293324f, -0.04810904f, 0.00010345f, 0.13672771f, -0.12521379f, 0.09154135f, 
    0.15717606f, 0.12816551f, -0.06410778f, 0.13673860f, -0.18132924f, -0.17882760f, 0.06356497f, 0.00971634f, 
    0.06146509f, 0.40195957f, -0.23438528f, 0.00847954f, 0.21485104f, -0.06809741f, 0.03549163f, 0.24826263f, 
    -0.06932180f, 0.00719258f, -0.06317830f, -0.01400151f, 0.02737002f, 0.01847923f, 0.14506748f, 0.19742306f, 
    -0.02755872f, 0.02880430f, -0.04510634f, 0.01504415f, 0.01457435f, -0.00281981f, -0.02677649f, 0.00227964f, 
    0.02771149f, 0.01240300f, -0.04933014f, -0.01760429f, -0.05111444f, -0.02063296f, -0.00197617f, 0.03182427f, 
    0.02543596f, -0.03667105f, -0.05351276f, -0.05162755f, 0.02189176f, -0.04501155f, 0.03304525f, -0.05191943f, 
    -0.05667139f, -0.02703122f, 0.02030272f, 0.04282705f, 0.02073285f, -0.04830136f, 0.02149191f, -0.01796220f, 
    -0.01996479f, -0.00068981f, -0.05719211f, 0.00142116f, -0.04537228f, -0.01974227f, -0.04174156f, 0.03878658f, 
    -0.00612516f, -0.03647774f, 0.00889665f, -0.02341876f, 0.03415560f, 0.00399637f, -0.00347311f, -0.04705156f, 
    -0.02619042f, -0.00824628f, 0.02779845f, 0.02484077f, -0.03844909f, 0.02741742f, 0.04225953f, -0.05775615f, 
    -0.04693395f, -0.05604773f, -0.00806989f, 0.00567568f, -0.02535036f, 0.00503288f, 0.03916648f, -0.03654456f, 
    -0.00809688f, 0.00751941f, -0.01777984f, 0.03407045f, 0.02463198f, 0.00354357f, 0.01439879f, -0.03122567f, 
    -0.05507007f, 0.04120294f, 0.01171010f, -0.04036513f, 0.02078717f, 0.02290871f, -0.04409457f, 0.00092003f, 
    0.03922080f, 0.03765606f, -0.01528147f, 0.03726928f, -0.01373953f, -0.04472298f, -0.00756672f, 0.03067181f, 
    -0.00644554f, -0.04810533f, -0.05374165f, 0.02297862f, 0.03458472f, -0.05502199f, 0.03991790f, -0.00802295f, 
    -0.04492828f, -0.04683296f, -0.04111532f, 0.03456818f, -0.04538166f, 0.00115939f, -0.03131003f, -0.00684844f, 
    -0.01717540f, 0.00631902f, 0.01589272f, -0.03810694f, -0.04741117f, 0.02582456f, 0.01849878f, -0.00009826f, 
    0.00706051f, -0.02874108f, -0.00170853f, -0.01397535f, 0.02246191f, 0.00676388f, -0.00980558f, 0.01825816f, 
    -0.00320884f, -0.01480093f, 0.01839543f, -0.01409326f, -0.03357029f, -0.01708294f, 0.03521926f, -0.02186726f, 
    -0.00259555f, 0.02764384f, -0.02450464f, -0.02994191f, 0.04152689f, 0.01537610f, 0.02114215f, 0.03029213f, 
    -0.04958411f, 0.02953471f, 0.02970520f, 0.00418272f, 0.02190979f, 0.00389278f, 0.03980158f, -0.02579486f, 
    0.01127703f, -0.03418181f, -0.00607628f, 0.01792343f, 0.01974284f, 0.02997816f, 0.01778190f, -0.02934763f, 
    -0.03046408f, -0.03070613f, -0.01184791f, 0.02061632f, -0.04495800f, -0.04040680f, -0.03718845f, -0.03313878f, 
    0.01921050f, 0.01797837f, 0.03981704f, 0.01245831f, -0.05327646f, 0.00536588f, -0.01998250f, 0.02915525f, 
    0.03172812f, -0.05304882f, -0.02870459f, 0.00279348f, 0.04240872f, -0.00717277f, -0.02037019f, 0.01421732f, 
    0.00331329f, -0.01569710f, -0.04435912f, 0.03921779f, -0.05741899f, -0.01557552f, -0.00658416f, 0.00449404f, 
    -0.02705218f, -0.03090855f, -0.03726229f, -0.00907808f, 0.01709364f, 0.02809359f, 0.00250457f, -0.00671247f, 
    0.00753091f, -0.04947435f, -0.00485232f, -0.02924174f, -0.03120758f, 0.02124454f, -0.02959868f, -0.05670834f, 
    0.01312489f, 0.03834240f, 0.02397918f, 0.03014336f, -0.03857807f, 0.00535842f, -0.00763628f, 0.03261749f, 
    -0.04797817f, 0.00050294f, -0.02899289f, -0.03110951f, 0.02668408f, -0.05642341f, -0.02822891f, 0.02571721f, 
    0.03083166f, -0.00587421f, -0.05097376f, 0.00305107f, 0.00707558f, 0.00961023f, -0.01792042f, -0.03546609f, 
    -0.03935639f, -0.02798396f, -0.05240938f, -0.03713845f, -0.02253850f, 0.03004209f, 0.02258856f, -0.03595530f, 
    -0.04054036f, 0.00607231f, 0.00713353f, -0.03790482f, 0.04435823f, 0.00921233f, -0.01060951f, -0.01793327f, 
    0.00174964f, -0.01207929f, 0.04081555f, -0.01475281f, 0.00539540f, 0.02396083f, -0.05386660f, -0.04763573f, 
    0.03988447f, -0.01543470f, -0.00312356f, -0.01585835f, -0.02914319f, 0.02545834f, 0.01966820f, -0.04344393f, 
    0.04181937f, -0.04003506f, -0.03667421f, -0.03412736f, -0.00953349f, -0.01554970f, -0.00229852f, 0.03061858f, 
    -0.02086696f, 0.01460964f, -0.05005302f, -0.00976936f, 0.02389902f, 0.01156365f, 0.00514632f, 0.03463589f, 
    -0.00635593f, 0.01029206f, -0.00337873f, -0.03688259f, -0.05188115f, -0.02224265f, 0.01890497f, 0.04169878f, 
    -0.02124736f, 0.02034004f, -0.05068574f, 0.04366483f, 0.01669311f, 0.02160676f, 0.00955722f, 0.02001021f, 
    -0.03165373f, -0.05611100f, -0.04766550f, -0.03572464f, 0.03739083f, 0.01191952f, -0.01333956f, -0.00719962f, 
    0.01078644f, -0.04959913f, -0.00154325f, 0.03685664f, -0.04684838f, -0.02665904f, -0.00692009f, -0.00639991f, 
    0.00276698f, -0.02687905f, 0.03726356f, 0.02997423f, 0.02945304f, 0.00737273f, 0.01623918f, -0.01271812f, 
    0.00779855f, -0.05699326f, -0.03596118f, -0.00576073f, -0.03371284f, -0.02054694f, 0.03690445f, -0.03865539f, 
    -0.01752333f, -0.01653496f, -0.02248603f, -0.00702890f, -0.03044629f, 0.04135729f, -0.00651731f, -0.04052802f, 
    -0.03617163f, -0.05368524f, -0.01534692f, -0.01008905f, -0.03648349f, 0.03262151f, 0.01223661f, 0.00804861f, 
    0.01969544f, -0.05643081f, -0.00861261f, -0.04828522f, -0.00500468f, -0.02065276f, 0.01787131f, -0.01273091f, 
    0.01306232f, 0.00228208f, -0.05416410f, 0.03269975f, -0.04374979f, 0.00997700f, -0.00238690f, 0.00568854f, 
    0.00482121f, -0.03668879f, -0.05026557f, 0.02063980f, 0.01681777f, -0.02765849f, -0.04156772f, -0.00840798f, 
    -0.03162615f, 0.03931051f, 0.04052510f, -0.00208020f, -0.03468312f, -0.05103464f, -0.05623923f, -0.00729631f, 
    -0.04371203f, -0.05000900f, -0.04653867f, -0.04081132f, 0.02645492f, -0.00577669f, 0.01888900f, -0.03172645f, 
    0.03033236f, 0.00054321f, 0.02300144f, -0.02657129f, 0.03347046f, -0.02394469f, 0.00975324f, -0.00611078f, 
    -0.00287214f, -0.04017403f, 0.00319454f, -0.01987870f, -0.01297293f, 0.01576826f, 0.04088205f, -0.01915809f, 
    -0.04216420f, -0.03042354f, -0.03984407f, -0.04344907f, 0.01789030f, 0.04237653f, -0.01478122f, -0.02968350f, 
    -0.04897169f, -0.04786476f, 0.04302394f, -0.02704800f, -0.04779735f, -0.03686599f, -0.04200936f, -0.02582193f, 
    -0.00753303f, 0.03747668f, 0.02287045f, -0.03088453f, -0.00096326f, 0.02740782f, -0.04909071f, -0.04419173f, 
    -0.00289290f, -0.03575533f, 0.02708823f, -0.05607804f, -0.04445475f, -0.03889172f, -0.03530020f, 0.00087852f, 
    -0.03969226f, 0.00849508f, -0.02257370f, -0.01616377f, 0.01037827f, -0.01702392f, 0.02741292f, -0.02095785f, 
    -0.04364242f, -0.04894198f, 0.01611232f, 0.00221942f, 0.02495579f, -0.00252216f, 0.03222229f, 0.04495031f, 
    -0.04961981f, -0.03075154f, -0.05415491f, -0.03799023f, 0.03306841f, -0.05086850f, 0.01142917f, -0.04410419f, 
    0.01378632f, -0.03568354f, 0.02207962f, -0.03331589f, -0.02610873f, 0.01734595f, -0.02583969f, -0.05628554f, 
    0.03336776f, -0.03789095f, -0.01114555f, 0.02526710f, -0.03478309f, -0.00050141f, 0.01844262f, -0.02432017f, 
    -0.03994909f, -0.00345511f, 0.00728291f, 0.00111444f, -0.01752435f, -0.04501707f, -0.04184370f, -0.01832274f, 
    -0.00125817f, -0.03836155f, 0.01223053f, 0.00236185f, 0.02770243f, -0.04402674f, 0.03887157f, 0.02083080f, 
    -0.05657589f, 0.04141659f, -0.01328299f, -0.03119732f, -0.01113328f, -0.05291487f, 0.03129726f, -0.00594504f, 
    0.03766380f, -0.04799118f, -0.00513790f, -0.00532148f, 0.02779095f, 0.03996624f, 0.04337526f, 0.00652610f, 
    0.02683237f, 0.01410378f, -0.00311962f, 0.01295370f, -0.03148279f, -0.04531283f, -0.04795056f, 0.00872101f, 
    -0.05656590f, 0.03388201f, -0.05658608f, -0.04935112f, 0.02745735f, -0.00659220f, -0.02005563f, -0.01682804f, 
    0.02213494f, 0.00689518f, 0.01284857f, 0.01754121f, 0.02752046f, 0.03358310f, -0.03449396f, 0.04323651f, 
    -0.01510055f, -0.00553363f, -0.04279199f, -0.03647202f, 0.00253337f, -0.05300460f, -0.05493287f, 0.04438264f, 
    0.00596646f, 0.02078092f, 0.01356565f, 0.01501212f, -0.04772989f, -0.01600618f, -0.02367897f, -0.03089542f, 
    0.03014683f, -0.00666108f, -0.00853775f, -0.02700026f, -0.04966439f, -0.00283085f, -0.05405081f, -0.00680091f, 
    -0.04540017f, 0.00215230f, -0.05100692f, 0.03419701f, 0.02471083f, -0.00844047f, -0.01685365f, -0.05193105f, 
    0.00123331f, 0.01644044f, -0.05572870f, 0.02797468f, 0.02804899f, 0.02289637f, 0.01306759f, -0.03255560f, 
    -0.03213886f, -0.04495244f, -0.05573646f, -0.05140768f, 0.02871574f, -0.00108839f, 0.03654248f, -0.04774550f, 
    0.03321358f, -0.04442061f, 0.01317642f, -0.05538423f, -0.03627499f, -0.02692295f, 0.01249162f, 0.01330113f, 
    0.03995603f, 0.02588991f, 0.01731485f, 0.00320091f, 0.01030133f, -0.03355348f, -0.05202184f, 0.03049871f, 
    0.00402511f, 0.02645981f, 0.02912381f, 0.02436043f, 0.02717849f, -0.05173647f, 0.01335182f, -0.00844777f, 
    0.03000723f, -0.04422794f, 0.01997972f, -0.00346841f, -0.04248759f, 0.02312312f, -0.02656639f, -0.02117510f, 
    0.00331116f, 0.00917404f, 0.03445826f, -0.00264568f, 0.01690615f, -0.04623272f, -0.01606298f, 0.02430794f, 
    -0.04851433f, -0.04899308f, -0.03078666f, 0.00296048f, -0.04147294f, -0.00269922f, -0.00631465f, -0.02046037f, 
    -0.03555838f, -0.03573315f, 0.04192250f, 0.00552262f, -0.03329291f, -0.00733612f, -0.03067831f, 0.02118416f, 
    -0.05147661f, 0.01278753f, 0.03888899f, -0.01904939f, -0.00750986f, -0.01704716f, 0.03012094f, -0.02928605f, 
    -0.04301511f, -0.00205199f, -0.04466488f, -0.05419581f, -0.04175846f, -0.01679353f, 0.02770460f, 0.02733381f, 
    0.00892532f, 0.01572306f, -0.02113137f, -0.04735341f, 0.02623774f, -0.03590612f, 0.01727155f, 0.02288943f, 
    -0.00454570f, -0.02856095f, 0.01177728f, -0.03171971f, 0.04315896f, -0.02608771f, -0.04548988f, -0.04392963f, 
    -0.00797676f, -0.04667100f, 0.04501630f, 0.01766189f, -0.01961833f, 0.02079220f, 0.04437537f, -0.00601155f, 
    0.01422909f, 0.00848790f, 0.03168488f, 0.04170807f, -0.02703696f, -0.00051743f, -0.01702436f, 0.00334934f, 
    -0.02617155f, 0.03044157f, -0.04818277f, 0.02835944f, -0.04169179f, -0.03448687f, -0.00742454f, 0.03197888f, 
    0.02784402f, -0.01920681f, 0.02016215f, -0.04850599f, 0.00769182f, 0.02408550f, 0.03652851f, 0.00469889f, 
    0.02656904f, -0.04408729f, 0.02547562f, -0.02130153f, 0.01427975f, -0.01599157f, 0.00666535f, 0.03452129f, 
    0.03105980f, 0.00042756f, -0.03598896f, 0.03755315f, 0.04263981f, -0.03675778f, 0.04025276f, 0.01478463f, 
    -0.05322602f, -0.01536247f, 0.03581235f, -0.00536342f, 0.01607508f, -0.01618160f, 0.03255055f, 0.01050722f, 
    -0.03720447f, -0.03832955f, -0.00686395f, -0.00237937f, 0.00950847f, 0.04317651f, 0.02666433f, 0.01377524f, 
    0.04339259f, -0.03298877f, -0.04792711f, 0.01008766f, -0.00888678f, -0.01674278f, 0.00329438f, 0.02794215f, 
    0.00903162f, -0.01022174f, 0.02353407f, -0.04575989f, -0.00330538f, 0.02429952f, 0.01180445f, -0.00030599f, 
    -0.03572749f, -0.01083928f, -0.04587004f, 0.04474247f, -0.04626716f, 0.00608656f, 0.04086308f, -0.05203463f, 
    0.01072234f, -0.01114769f, -0.05008180f, -0.00967621f, -0.00982291f, 0.00346450f, -0.03638968f, -0.03387127f, 
    0.00579056f, -0.05293025f, -0.00107660f, -0.04455491f, 0.00887228f, -0.04982979f, 0.03894488f, -0.02667327f, 
    -0.03309464f, 0.02654188f, 0.02020617f, -0.04745453f, -0.02888254f, -0.04070246f, -0.00635830f, 0.00194555f, 
    0.00584629f, -0.00987395f, 0.02367908f, -0.00046809f, -0.04017883f, 0.03784618f, 0.01102629f, -0.03200369f, 
    -0.05290760f, 0.01953107f, 0.01407153f, -0.03019640f, 0.02332650f, 0.02347897f, 0.03956761f, 0.01728639f, 
    -0.02942998f, 0.00735573f, -0.01879187f, -0.04763232f, -0.02933740f, -0.05589814f, -0.04614386f, 0.00359739f, 
    -0.00240911f, -0.05730093f, -0.05942934f, -0.02781398f, 0.01782322f, -0.03024822f, -0.05201910f, 0.03164419f, 
    0.02962890f, -0.04724543f, 0.01466287f, -0.00553863f, 0.01395259f, -0.00768549f, -0.00561043f, -0.00255656f, 
    0.04157019f, 0.03254704f, -0.05723556f, -0.03007172f, -0.01452656f, -0.01579575f, -0.04090566f, 0.02280843f, 
    0.00413907f, 0.01597380f, -0.02145179f, -0.04492211f, 0.02932709f, 0.03077902f, -0.04470306f, 0.01814285f, 
    0.00186444f, 0.03891917f, -0.03556743f, -0.05594667f, -0.03206328f, -0.03983290f, -0.02713311f, 0.04136476f, 
    0.02118183f, 0.00083927f, -0.04148076f, 0.00838182f, -0.05614301f, 0.01969251f, -0.01848467f, -0.04040349f, 
    -0.05342480f, -0.04989940f, 0.03702920f, -0.00856677f, -0.04595950f, 0.04137061f, -0.01425607f, 0.02632484f, 
    0.03995028f, 0.03540800f, -0.00629214f, 0.03340027f, 0.03502584f, -0.05138499f, -0.01232958f, 0.04290614f, 
    0.02351801f, -0.03916226f, -0.02744124f, -0.03908202f, -0.01570173f, 0.03758268f, -0.03854703f, 0.00293895f, 
    -0.01798752f, 0.01301373f, -0.01970954f, -0.01685340f, -0.02243595f, 0.02162297f, 0.00508572f, -0.03475334f, 
    -0.00425951f, -0.04391969f, 0.01162655f, -0.00163348f, -0.02256881f, -0.01502364f, -0.05280738f, 0.03132974f, 
    -0.00483269f, -0.00677729f, -0.01177970f, 0.01382434f, -0.04986275f, -0.04777529f, -0.04747005f, 0.02950515f, 
    -0.04686811f, -0.03237411f, 0.01117966f, -0.01129386f, -0.02188271f, -0.00817734f, 0.00907436f, 0.03550080f, 
    0.02573497f, 0.00732372f, -0.01033333f, 0.02421040f, -0.03708517f, 0.03152180f, 0.04073379f, 0.01052355f, 
    -0.05157724f, 0.00718864f, -0.02169607f, -0.05714552f, -0.03669348f, -0.03298273f, -0.03149277f, 0.03260259f, 
    -0.01090717f, 0.01763614f, -0.04665568f, 0.02494879f, -0.00662104f, -0.01678007f, -0.05616905f, -0.04122430f, 
    -0.04682077f, -0.02507670f, -0.04951679f, 0.00034564f, 0.03853992f, -0.04985133f, 0.00468066f, -0.00950539f, 
    0.00503233f, 0.02326237f, 0.01421804f, 0.01554110f, -0.04521766f, 0.01222979f, 0.03828657f, 0.00225550f, 
    0.02811344f, -0.02917041f, -0.01150987f, 0.03491332f, 0.02047860f, 0.01116499f, -0.02117611f, 0.02406973f, 
    0.01655413f, 0.03104166f, 0.02662590f, 0.03976470f, -0.04170499f, -0.04187949f, -0.02617103f, -0.01750791f, 
    -0.04194758f, -0.01290274f, -0.05360279f, -0.05585248f, -0.01038672f, -0.00201044f, 0.03272374f, 0.02217215f, 
    0.00785958f, -0.00907925f, 0.02890178f, -0.00561251f, 0.01815790f, -0.03236523f, -0.01310309f, -0.03313093f, 
    0.01443577f, 0.01054002f, -0.01361119f, -0.04525595f, -0.04650054f, -0.01751785f, -0.00087272f, -0.05078369f, 
    0.01577075f, -0.03078344f, -0.05691886f, -0.05497272f, -0.04699846f, 0.04066088f, 0.03886429f, -0.03981923f, 
    -0.02697339f, -0.01681181f, 0.02420414f, -0.00503954f, -0.04476035f, 0.03449726f, 0.02566882f, 0.03324513f, 
    -0.02145433f, 0.02763195f, 0.02212270f, -0.01433005f, -0.04164929f, -0.00577933f, -0.02855738f, 0.03056758f, 
    -0.02601151f, -0.05355402f, -0.01726920f, -0.03614962f, -0.04753497f, -0.04116243f, 0.02412096f, 0.01954098f, 
    0.00660158f, 0.00390444f, -0.03942350f, 0.04093042f, -0.00632004f, -0.01073362f, -0.02112874f, -0.05535270f, 
    -0.05638408f, -0.04719150f, -0.05321286f, -0.01355599f, -0.05314406f, 0.00750190f, 0.03186071f, 0.00299580f, 
    -0.04846090f, -0.01989019f, -0.02153950f, 0.03491500f, 0.03561101f, 0.02043811f, -0.04784636f, -0.03459341f, 
    -0.00708199f, 0.03023528f, -0.01411415f, 0.00983734f, -0.05404935f, -0.03055289f, 0.01203720f, 0.01298246f, 
    -0.00719601f, -0.04660457f, 0.04142290f, 0.01894957f, 0.03396448f, 0.00199279f, -0.04481374f, -0.01636446f, 
    -0.00465015f, 0.04091752f, -0.03839514f, 0.01007023f, 0.01610702f, 0.00974748f, 0.02048509f, -0.01556410f, 
    0.02251918f, -0.02356060f, 0.03550914f, -0.00865830f, 0.01004380f, 0.02992479f, -0.00227362f, 0.01774907f, 
    -0.00324611f, -0.02305817f, 0.02914020f, 0.01316101f, -0.02883853f, -0.00258770f, 0.02771648f, 0.03543966f, 
    -0.00225231f, 0.02879467f, 0.00521098f, 0.03585799f, -0.01813451f, -0.00226532f, 0.01421703f, -0.01525850f, 
    -0.04993923f, -0.04830602f, -0.01062138f, 0.03925722f, -0.05217655f, 0.03849204f, -0.05598975f, 0.01167353f, 
    0.01301575f, -0.02197037f, -0.02372333f, 0.02536841f, -0.02095839f, -0.02759706f, -0.00086330f, 0.04016620f, 
    0.03388064f, -0.04905970f, -0.00564223f, 0.01278573f, 0.02789699f, 0.04146284f, -0.05393391f, 0.01681056f, 
    0.02748139f, -0.05198534f, -0.04246811f, -0.00219732f, -0.01678126f, -0.02714899f, 0.00353369f, -0.03747984f, 
    -0.02694846f, -0.03556855f, -0.05135717f, -0.04002662f, 0.04003059f, -0.04283349f, 0.03541940f, 0.04269104f, 
    0.03484515f, -0.00020806f, -0.04196153f, -0.00463057f, 0.02894621f, -0.01397029f, 0.03833185f, 0.03740129f, 
    -0.02971167f, -0.00474423f, -0.03491263f, -0.02096123f, -0.02129563f, -0.03520749f, -0.03701799f, 0.00042222f, 
    -0.03093516f, -0.00480152f, 0.01245657f, -0.00041096f, 0.00023553f, -0.02476272f, -0.01662634f, -0.03019338f, 
    -0.03186866f, -0.04444913f, 0.01591060f, -0.03186813f, 0.00202653f, -0.04115474f, 0.01251023f, 0.00145762f, 
    -0.00823774f, 0.00388652f, 0.01537472f, 0.03218111f, 0.03683563f, -0.01456347f, 0.00524459f, -0.03788657f, 
    0.00318073f, 0.00162934f, 0.03597559f, -0.01641408f, -0.01034014f, -0.04837110f, -0.03475580f, 0.02604209f, 
    -0.05188579f, -0.04591372f, 0.03940574f, 0.03353250f, -0.02749596f, -0.02694957f, 0.00880799f, -0.05019775f, 
    0.03279699f, 0.01199289f, 0.02608687f, -0.04615387f, -0.05534421f, 0.00334892f, -0.04673051f, -0.04704326f, 
    -0.03117273f, -0.00331798f, 0.00256475f, 0.00410275f, -0.02426451f, 0.03007855f, -0.04843906f, -0.04703939f, 
    0.01700739f, -0.02992973f, 0.01677834f, 0.02746331f, 0.02402788f, 0.01269023f, 0.03438952f, -0.03390121f, 
    -0.05433896f, 0.00087630f, -0.01953335f, -0.04769787f, 0.00727996f, -0.04157597f, 0.02868427f, 0.04008003f, 
    -0.02359241f, 0.04202940f, -0.03075091f, 0.00499820f, 0.03054289f, -0.01221582f, -0.05015347f, -0.00164422f, 
    0.02074203f, -0.02652663f, 0.01946277f, -0.02463270f, -0.04752320f, 0.00713905f, -0.03886414f, -0.01808833f, 
    0.01108540f, -0.04325492f, 0.02726555f, -0.00783601f, -0.04992352f, -0.04426469f, -0.05027447f, 0.00067510f, 
    -0.03954297f, -0.05588221f, -0.04394845f, -0.05402326f, 0.04040824f, -0.01880230f, -0.00501771f, -0.04534696f, 
    -0.01019898f, 0.03368695f, -0.01776955f, -0.00664901f, -0.01728724f, 0.01123838f, 0.04131396f, -0.02546347f, 
    -0.04349448f, -0.03618265f, 0.00687610f, 0.02991338f, 0.01186739f, 0.02258019f, 0.02210953f, 0.02083833f, 
    -0.03718708f, 0.02099155f, -0.03948047f, 0.02691406f, -0.02183095f, -0.05007503f, -0.03140007f, -0.04605125f, 
    -0.05527555f, -0.01690711f, -0.03695475f, -0.00678789f, 0.04972580f, -0.04672933f, -0.04619415f, 0.04075345f, 
    -0.01661578f, -0.01919969f, 0.00334419f, -0.01246839f, -0.00278067f, -0.05627906f, 0.01780603f, -0.02492794f, 
    0.04095834f, 0.03084940f, 0.01388888f, -0.01265386f, -0.04208429f, -0.00356280f, -0.02520935f, -0.05541134f, 
    -0.02573876f, -0.04070478f, -0.02141443f, -0.00358810f, -0.05251131f, -0.03466909f, 0.02061651f, -0.03624582f, 
    0.02873667f, -0.04829570f, -0.04814263f, 0.03038012f, -0.00925811f, -0.05539235f, 0.02737480f, 0.04429046f, 
    0.03742664f, 0.04387983f, -0.04729806f, 0.00931489f, 0.04536884f, 0.01429124f, 0.04665272f, -0.03195476f, 
    -0.02356013f, -0.03401263f, 0.02001717f, -0.03348579f, 0.03489047f, -0.04675353f, -0.05609876f, 0.04545583f, 
    -0.02336562f, 0.04077177f, -0.04696744f, 0.00759161f, 0.01983186f, 0.02594933f, -0.02510501f, -0.05593219f, 
    -0.02453222f, -0.04819597f, -0.04759239f, 0.04250010f, -0.00394930f, -0.03755035f, -0.02471059f, -0.02790065f, 
    0.01697494f, -0.01143847f, 0.01107918f, -0.01606710f, -0.04169238f, -0.05526831f, -0.02109745f, 0.01423702f, 
    -0.02892121f, -0.00219620f, -0.03128234f, -0.01720819f, 0.02108665f, 0.03664951f, -0.04706979f, -0.04037018f, 
    0.02566030f, 0.00674293f, -0.02799474f, 0.02969952f, -0.02227230f, 0.02593551f, 0.04515627f, -0.05555362f, 
    -0.05548228f, 0.03051592f, 0.03371910f, -0.01729229f, -0.02277371f, 0.01961306f, 0.02849539f, -0.02828940f, 
    0.01767880f, -0.00223526f, -0.00722499f, 0.02373437f, 0.03021370f, 0.03659774f, 0.02646633f, -0.01893364f, 
    0.02766034f, -0.04645391f, -0.01894757f, -0.01999640f, 0.00238867f, 0.01200366f, -0.01223544f, 0.04214120f, 
    0.02463412f, -0.00081557f, 0.02986538f, 0.04197748f, -0.00453617f, -0.02636280f, 0.03727469f, -0.04128636f, 
    0.04008694f, 0.04334179f, 0.00322851f, -0.03162941f, -0.01684677f, -0.00809699f, 0.02443301f, -0.04896408f, 
    0.04293346f, 0.01269075f, -0.03482244f, -0.01501083f, -0.00912248f, -0.04646713f, -0.04855160f, -0.01501919f, 
    0.01605923f, -0.03723919f, -0.00853880f, -0.02946131f, -0.03017904f, 0.00447718f, -0.01647148f, 0.01399908f, 
    0.02838952f, -0.04264736f, -0.04681154f, -0.02387279f, 0.00713822f, -0.05091067f, -0.00874359f, -0.02969471f, 
    -0.04942632f, -0.00298813f, -0.02458222f, 0.04181196f, 0.02532097f, -0.02084288f, 0.01611781f, -0.02543152f, 
    0.03397005f, -0.04081866f, 0.04048501f, -0.05575608f, 0.02231633f, 0.03768603f, -0.03979591f, 0.00080307f, 
    0.01825924f, 0.03507804f, -0.00459247f, -0.04762947f, -0.04838771f, -0.03485835f, 0.02561710f, -0.04902037f, 
    -0.01453521f, 0.03566791f, -0.00964386f, -0.00929748f, -0.01240113f, 0.00826972f, -0.00731607f, 0.03079717f, 
    0.03612341f, -0.00817476f, 0.03989985f, 0.02001010f, 0.03851769f, 0.00284286f, -0.01354708f, -0.01807643f, 
    -0.02327694f, -0.04025868f, -0.03049224f, -0.04588221f, -0.00458077f, -0.02081534f, -0.03969025f, 0.01761462f, 
    0.00166800f, 0.01889863f, -0.02809831f, -0.02144946f, -0.03573090f, 0.02865944f, -0.01023633f, -0.02012937f, 
    0.00631306f, 0.01208666f, 0.00696081f, 0.02641422f, -0.04288983f, -0.04835185f, 0.02663320f, -0.05312398f, 
    0.01186087f, -0.03810949f, 0.03949086f, -0.01062608f, -0.01938040f, -0.05169573f, 0.01728941f, -0.05584189f, 
    0.03149618f, 0.00961506f, -0.00296526f, 0.04537748f, -0.00734369f, 0.02162672f, 0.04022872f, 0.00667007f, 
    0.03707948f, -0.01582914f, -0.04732977f, -0.01944223f, -0.04545243f, 0.02003579f, 0.02244999f, 0.01719661f, 
    -0.03711472f, -0.00689505f, 0.02006342f, -0.00093687f, 0.04254806f, 0.01297494f, -0.04257908f, -0.02904959f, 
    -0.02923349f, -0.01071690f, 0.03380491f, -0.01783696f, -0.02254827f, -0.04938473f, -0.05437668f, 0.03161636f, 
    -0.05192253f, -0.05108044f, -0.03502387f, -0.01530544f, 0.00240991f, 0.04189959f, -0.01721425f, 0.00322752f, 
    -0.07767050f, 0.32339090f, 0.33136067f, 0.11038686f, -0.11083402f, -0.12502855f, -0.00456260f, 0.06445427f, 
    0.08946797f, 0.05165523f, 0.05135896f, -0.00837379f, 0.03798390f, 0.22828028f, 0.10680333f, 0.06291615f, 
    -0.31245944f, 0.02044180f, 0.02376348f, 0.07406721f, -0.11950222f, 0.14354828f, -0.00658749f, 0.13683403f, 
    0.32911655f, 0.09967249f, 0.29679197f, -0.00509163f, 0.05628105f, -0.02103300f, -0.00703170f, -0.02128825f, 
    0.07912116f, 0.01538368f, 0.08570398f, 0.00105329f, -0.10034011f, -0.19053638f, -0.11916017f, -0.20103616f, 
    0.09428117f, 0.07616229f, 0.01685731f, 0.08910961f, 0.00332563f, 0.02708240f, -0.04138806f, 0.08948172f, 
    0.04146762f, -0.02912588f, 0.04391014f, -0.16121694f, -0.07698786f, -0.08377918f, 0.05371512f, 0.00326376f, 
    -0.00158508f, 0.03453191f, -0.09915070f, 0.04722735f, 0.01673325f, 0.03656800f, 0.19011466f, 0.16204464f, 
    0.10427154f, 0.03581911f, 0.01043251f, 0.09077258f, 0.06492651f, 0.00666738f, 0.07634458f, -0.03141149f, 
    0.12935081f, -0.21887727f, -0.11219323f, -0.09227778f, 0.13735469f, -0.03228355f, -0.07354988f, -0.01772799f, 
    0.02185655f, 0.09416771f, 0.09706069f, -0.02437996f, -0.11891440f, 0.09163809f, -0.15697041f, 0.01644968f, 
    0.21151333f, 0.15237509f, -0.01259713f, -0.08375286f, -0.10976059f, 0.04420003f, 0.01708055f, 0.11161797f, 
    -0.16801718f, -0.18558788f, 0.14760934f, 0.02515986f, -0.11539716f, 0.01202984f, 0.08206127f, -0.14225358f, 
    -0.06862140f, -0.10696303f, 0.08174760f, 0.02883359f, 0.00279444f, -0.03572591f, -0.01012877f, -0.06687003f, 
    -0.04592450f, -0.08320657f, -0.11450122f, -0.06801603f, -0.06936581f, 0.06095686f, 0.12751149f, 0.22382751f, 
    -0.07438316f, 0.39872435f, -0.04158109f, 0.03970103f, 0.13530995f, 0.10066780f, -0.01493207f, -0.02601858f, 
    0.02777526f, 0.08551773f, 0.00891706f, 0.00035264f, 0.16572279f, 0.42588636f, 0.27556857f, -0.11578438f, 
    0.01527496f, -0.09588904f, 0.03555590f, 0.09994213f, 0.03737237f, 0.03280981f, 0.10560763f, 0.16136424f, 
    0.17143860f, 0.05905648f, -0.18446693f, -0.00498468f, 0.06518512f, 0.03498744f, 0.00770662f, 0.11540704f, 
    0.09621790f, 0.00194709f, 0.12691316f, 0.01400430f, 0.00949750f, -0.14478302f, -0.04435529f, -0.12161294f, 
    -0.01969999f, -0.09999082f, 0.06919511f, -0.03887850f, 0.08561065f, -0.03983651f, -0.00390451f, -0.08192120f, 
    -0.19223225f, 0.12661248f, 0.15271357f, 0.00183783f, -0.08823071f, 0.01142741f, 0.07292780f, 0.00904207f, 
    -0.02606173f, -0.01230902f, -0.03579088f, -0.04480869f, -0.37541851f, -0.23376814f, -0.17875749f, 0.10030989f, 
    0.14641419f, 0.08802541f, -0.00551652f, -0.01888704f, 0.05638688f, 0.11318596f, -0.03991229f, -0.10101863f, 
    -0.24825460f, -0.22290972f, 0.04800271f, 0.12137569f, 0.01188560f, 0.04350350f, 0.04622715f, 0.09875909f, 
    0.11144809f, 0.13029997f, -0.09986183f, 0.02627843f, 0.10474090f, -0.26000896f, 0.17048746f, -0.06097878f, 
    -0.05034798f, -0.02890933f, 0.17226136f, -0.12110069f, 0.00032680f, -0.03425894f, 0.02387738f, -0.09713697f, 
    -0.58230096f, 0.07615102f, -0.29403549f, -0.09586592f, 0.07099465f, 0.17258652f, -0.07616909f, 0.15510562f, 
    -0.05101231f, 0.03206186f, -0.00324941f, 0.08634669f, -0.30595073f, -0.10935376f, -0.05924665f, -0.17557906f, 
    0.06187900f, 0.08142900f, 0.04463040f, 0.06638653f, 0.10542673f, 0.08501990f, -0.01926306f, -0.03050256f, 
    -0.08136906f, -0.30292383f, -0.02456171f, 0.04858337f, -0.10248104f, 0.01390292f, -0.01081865f, -0.08912092f, 
    -0.05711704f, -0.02351693f, 0.09091920f, 0.12766577f, -0.49343830f, -0.18445681f, -0.01368617f, -0.05042794f, 
    -0.00774733f, 0.06717816f, 0.09865174f, -0.01253384f, -0.02069593f, 0.01272568f, 0.05059820f, -0.01091175f, 
    0.10826255f, -0.00257831f, 0.38047138f, 0.01462872f, -0.13862254f, -0.02914983f, 0.01266960f, -0.06270778f, 
    -0.01122488f, 0.04109704f, 0.10473079f, 0.01198170f, -0.11615544f, 0.32325456f, 0.12226058f, 0.02542681f, 
    0.02690903f, -0.01143516f, 0.13529144f, 0.03337315f, 0.10663411f, -0.04532683f, -0.06836660f, 0.16156679f, 
    -0.33128452f, -0.05221909f, -0.13124165f, 0.02851886f, 0.04920659f, 0.14925143f, -0.02639583f, -0.08606897f, 
    0.22743167f, 0.12132206f, -0.10225792f, -0.03623847f, -0.09210240f, -0.02191632f, 0.15898891f, 0.05519967f, 
    -0.02721880f, -0.01999330f, 0.12538642f, 0.10183913f, -0.02254694f, -0.10288916f, -0.01638598f, -0.05783201f, 
    0.31833994f, 0.38894290f, -0.09065179f, 0.04685580f, 0.07601763f, 0.00626999f, 0.06470309f, 0.04535485f, 
    0.09853704f, -0.02669524f, -0.06304558f, 0.09956034f, -0.04058324f, -0.18539591f, 0.44942021f, 0.14833874f, 
    -0.23759107f, -0.04036454f, 0.06103171f, -0.15431750f, 0.07732856f, 0.02137293f, 0.00316963f, 0.15847608f, 
    -0.36021015f, -0.20079584f, -0.19169047f, -0.05907646f, 0.13351509f, 0.03581084f, -0.02281328f, 0.15526009f, 
    0.12377810f, -0.00529340f, -0.09368033f, -0.01668436f, -0.11252138f, 0.30751687f, 0.15126200f, 0.09976155f, 
    -0.02356477f, 0.02979676f, 0.02579032f, 0.06933408f, 0.05800449f, 0.02469153f, -0.03574114f, -0.00064752f, 
    -0.13231730f, -0.17143723f, 0.04246793f, 0.00822638f, 0.16079319f, 0.14104591f, -0.09763994f, 0.09068821f, 
    -0.08831128f, 0.08044155f, -0.12916218f, 0.03394751f, -0.37573162f, 0.04522358f, 0.19980954f, 0.04605322f, 
    -0.02246015f, 0.11575513f, 0.06739809f, -0.02679241f, 0.00731592f, 0.02621893f, -0.03498955f, -0.01458245f, 
    -0.03891907f, -0.04610637f, 0.04109152f, -0.03365756f, -0.02534844f, 0.00468906f, 0.02249615f, 0.02776011f, 
    -0.03594450f, -0.05531605f, -0.01637424f, 0.00928520f, -0.04230189f, 0.02141696f, 0.04261384f, -0.04975691f, 
    -0.04355124f, -0.00034762f, -0.03306674f, -0.01415679f, 0.03184407f, -0.02920604f, -0.02092842f, -0.01065563f, 
    0.03256287f, -0.01833252f, -0.04454549f, 0.02607961f, -0.00888741f, 0.04163952f, 0.00100997f, 0.02063624f, 
    0.00751693f, -0.00656105f, 0.03458983f, -0.04728048f, -0.03889593f, -0.01481708f, -0.01629138f, -0.03441148f, 
    0.03247984f, -0.03284211f, -0.03062827f, -0.01476029f, -0.03737106f, -0.00734310f, -0.05177407f, -0.03574625f, 
    -0.01445518f, -0.04630896f, -0.05393803f, 0.04229024f, -0.03321832f, -0.03216980f, -0.00952159f, 0.00869413f, 
    0.00734717f, -0.05432165f, -0.02524387f, -0.02395923f, -0.03611571f, -0.01816756f, -0.04727330f, 0.03135281f, 
    -0.03026786f, -0.02322303f, -0.01689150f, -0.03342749f, 0.03018677f, -0.02854013f, -0.01824789f, 0.01690616f, 
    -0.05520800f, 0.04177959f, -0.05454816f, 0.03303169f, 0.00913906f, -0.03742924f, -0.02678841f, 0.01735425f, 
    0.02039271f, 0.02637388f, 0.00454800f, -0.02295816f, -0.03446331f, -0.04868102f, -0.03662229f, -0.00713711f, 
    -0.05278349f, 0.00666152f, -0.00286142f, 0.00574351f, -0.00100889f, -0.05014768f, -0.02959052f, 0.04022071f, 
    -0.04378253f, -0.00418741f, -0.01431984f, -0.01264236f, -0.00743922f, 0.03100063f, 0.00919506f, -0.02696954f, 
    0.01254024f, -0.03811851f, -0.00786243f, -0.01627565f, -0.00950912f, 0.00448659f, 0.01541315f, 0.01110650f, 
    0.04038273f, 0.03212864f, 0.04098533f, 0.01573263f, 0.02384403f, -0.04904807f, -0.00149933f, -0.03317597f, 
    -0.02105807f, -0.04478280f, 0.00196669f, 0.02381632f, -0.03427992f, -0.01244348f, 0.01175418f, -0.04966731f, 
    0.02675069f, 0.04496964f, -0.05220321f, -0.01946682f, -0.01273809f, -0.01119061f, -0.05306230f, -0.04932902f, 
    0.03382097f, 0.02046500f, -0.04177221f, -0.02956991f, 0.01869281f, 0.03163602f, -0.03220019f, 0.02645691f, 
    -0.05323368f, 0.00553847f, -0.04956466f, -0.01131347f, -0.05815759f, 0.04201113f, 0.04070598f, -0.05618083f, 
    0.02242827f, 0.01356728f, 0.03848676f, 0.01961460f, -0.05228010f, 0.00760711f, -0.00206683f, -0.03461943f, 
    -0.05542248f, -0.04031324f, -0.00181587f, -0.02796252f, -0.03587749f, -0.03389513f, -0.00436753f, -0.01772828f, 
    0.03673846f, -0.04259564f, -0.03868056f, -0.01109226f, -0.03269996f, -0.05246620f, -0.04466690f, -0.04911089f, 
    0.00775939f, -0.01110621f, 0.00855901f, -0.03679459f, -0.01713991f, -0.01562726f, -0.04667350f, -0.03210656f, 
    -0.02554947f, 0.01969567f, -0.05343864f, 0.02082308f, 0.02824491f, -0.03898533f, 0.01591086f, -0.05184915f, 
    -0.05747374f, 0.03098763f, -0.01043891f, -0.05102383f, -0.01535632f, -0.01753956f, -0.05540597f, 0.03629939f, 
    -0.00632358f, 0.01621849f, -0.02884325f, 0.02980333f, 0.04028864f, -0.01958492f, 0.03607719f, -0.04017494f, 
    0.04278751f, -0.04468665f, 0.00863289f, -0.01096460f, 0.02565262f, -0.02651747f, -0.00721992f, -0.03961751f, 
    -0.03784106f, 0.02412741f, -0.04220167f, 0.03825739f, -0.03547002f, -0.02642330f, -0.03058046f, -0.04286176f, 
    0.02787560f, -0.00179618f, -0.05325477f, -0.03620912f, -0.00158940f, 0.00579717f, -0.00080430f, 0.02619141f, 
    -0.00968290f, -0.00240385f, 0.00546950f, -0.00037656f, 0.03152801f, -0.00879581f, -0.01479770f, -0.01044913f, 
    0.01240022f, -0.00599131f, -0.04430512f, 0.03341342f, 0.00790683f, -0.01967617f, -0.03454389f, -0.01748261f, 
    -0.00110798f, -0.02017706f, 0.02232329f, 0.02509579f, -0.01422776f, -0.02226716f, 0.01750638f, 0.00764323f, 
    -0.01179490f, 0.02336647f, 0.02957645f, 0.02531375f, -0.00845043f, -0.01537486f, 0.02051233f, -0.03663509f, 
    -0.03719994f, -0.01253678f, 0.03781115f, -0.00210465f, 0.00098211f, 0.02056201f, -0.02963902f, 0.01672952f, 
    0.04278147f, 0.02942177f, -0.04625497f, 0.03587624f, -0.01469381f, 0.03009008f, -0.01104852f, -0.02473587f, 
    0.02763988f, -0.02765223f, 0.02441850f, -0.04217988f, -0.05323889f, 0.01200388f, -0.00085145f, -0.02747578f, 
    -0.03609106f, 0.03549588f, -0.00224575f, 0.01898549f, -0.03299731f, 0.02975158f, 0.01040877f, 0.01734630f, 
    -0.05163480f, -0.02730592f, -0.05063044f, -0.00570476f, 0.03686485f, -0.02260268f, -0.00666829f, 0.00978686f, 
    -0.02960162f, -0.00032518f, -0.03619421f, -0.02330152f, -0.02517975f, 0.01260189f, -0.03780957f, 0.03441456f, 
    -0.05316104f, 0.02421958f, -0.00148029f, -0.00548030f, -0.05411078f, 0.02701198f, -0.02697381f, -0.00528700f, 
    -0.00309856f, 0.02967670f, -0.04418825f, -0.04782482f, 0.03657490f, 0.01710836f, -0.02585686f, 0.01934339f, 
    -0.01239709f, -0.05943770f, 0.03535197f, 0.00290850f, -0.00731384f, -0.03679363f, 0.00887361f, -0.04873358f, 
    0.03981857f, -0.03682510f, 0.02231275f, 0.02954607f, -0.03537174f, 0.02264873f, 0.01537832f, -0.00733225f, 
    -0.01826845f, -0.05156750f, 0.01547602f, -0.02083932f, -0.04536190f, -0.03421233f, -0.04320679f, 0.00699287f, 
    0.03798912f, 0.00271336f, 0.01012259f, 0.03922113f, 0.01469851f, -0.03400379f, 0.04172098f, 0.01100815f, 
    -0.01448319f, -0.02057873f, -0.00471949f, -0.02147576f, -0.05768350f, -0.03745387f, -0.02469024f, 0.02473796f, 
    0.00719184f, -0.02575773f, -0.01205445f, -0.05875455f, 0.00035525f, 0.03993308f, 0.01373948f, -0.02606749f, 
    -0.04537077f, -0.01640349f, 0.03889759f, -0.04884373f, -0.01507179f, -0.00397357f, 0.03488722f, 0.00416051f, 
    -0.00542158f, 0.04509552f, 0.00929178f, -0.03960559f, 0.02103740f, -0.00417783f, -0.03334408f, 0.03868391f, 
    -0.00433360f, 0.01743176f, -0.01093920f, 0.00506368f, -0.03705104f, -0.02662910f, 0.03870692f, -0.05617434f, 
    0.03283959f, -0.04287904f, 0.01397732f, -0.03240598f, -0.05002111f, 0.04219320f, -0.04715615f, -0.04964923f, 
    -0.04540300f, 0.01196688f, -0.04983006f, 0.04435781f, 0.04307241f, 0.02119951f, 0.01976592f, 0.02727384f, 
    -0.03380343f, -0.00928124f, -0.04218389f, -0.04664633f, -0.04107229f, -0.05403936f, 0.01390085f, 0.02891275f, 
    0.03752261f, -0.03112235f, -0.03383809f, 0.00995613f, 0.02716659f, -0.02410348f, -0.00483382f, -0.03048027f, 
    -0.03342742f, -0.03558166f, 0.03989653f, 0.01740276f, -0.03299928f, -0.03761402f, -0.01703901f, -0.01645834f, 
    0.00157042f, -0.03468388f, 0.03897904f, 0.04334345f, 0.00690526f, 0.03587984f, 0.00594310f, -0.03032462f, 
    0.01383380f, 0.05576881f, 0.01056980f, 0.03871180f, 0.01844473f, -0.01371406f, 0.00134521f, 0.01996679f, 
    -0.03074252f, 0.04160894f, 0.01699757f, -0.05091285f, -0.05492438f, 0.03194755f, 0.04687836f, -0.04306494f, 
    -0.05722122f, 0.04578947f, 0.02725799f, 0.02355096f, -0.03586583f, 0.03882925f, -0.04398740f, -0.02069467f, 
    -0.00416293f, 0.01678851f, -0.03115879f, -0.04648818f, 0.00241094f, -0.04417800f, -0.02917290f, -0.00254548f, 
    -0.04786057f, -0.01941900f, 0.02615023f, -0.03067882f, 0.02391999f, -0.03702306f, 0.04058339f, -0.00108744f, 
    0.01419003f, 0.01750547f, -0.02683645f, -0.02975406f, -0.01220509f, -0.06004432f, 0.03214648f, -0.01966706f, 
    -0.01355612f, 0.04415358f, 0.01806042f, -0.02732019f, -0.01616247f, -0.02238974f, -0.01808458f, -0.00175448f, 
    -0.03649567f, 0.03077320f, 0.02610216f, -0.06086842f, -0.04739661f, -0.01603889f, -0.02009299f, 0.01857606f, 
    -0.05010783f, -0.00085207f, -0.01459878f, 0.04374697f, 0.04246298f, 0.05140629f, 0.02984421f, -0.01394335f, 
    0.02269447f, -0.02968487f, 0.00022351f, -0.04821856f, 0.01510514f, 0.00463789f, 0.02128982f, 0.02043607f, 
    0.03720390f, 0.02987555f, -0.04363327f, -0.00974348f, 0.03793877f, 0.03161401f, -0.04832691f, -0.03490297f, 
    0.00759500f, -0.03033828f, -0.00348776f, -0.03725012f, -0.03468628f, 0.03301363f, -0.02113097f, -0.00319207f, 
    -0.01804063f, -0.00421777f, 0.01341507f, 0.01724504f, -0.01339563f, -0.04255845f, -0.03210928f, -0.04780620f, 
    -0.05849902f, 0.04686470f, -0.03268538f, -0.01798372f, 0.01965491f, -0.04134356f, -0.02656506f, -0.04685433f, 
    0.00749813f, -0.04001786f, 0.00012783f, -0.01115675f, -0.05637069f, -0.00640209f, 0.00046224f, 0.01890163f, 
    -0.05694661f, 0.01727617f, 0.01343016f, -0.01380333f, -0.00610476f, 0.01193898f, -0.03420328f, -0.05383237f, 
    -0.03710707f, -0.02717916f, -0.05633097f, 0.00388491f, 0.00963301f, -0.05700244f, -0.02014636f, 0.04118917f, 
    0.02643670f, -0.03107652f, 0.01246690f, -0.03750988f, -0.03636596f, -0.02074635f, -0.05101781f, 0.01648903f, 
    -0.02851867f, 0.02728259f, 0.04439491f, -0.04250182f, 0.02593490f, 0.01776599f, 0.04117801f, 0.02356547f, 
    0.04490290f, -0.05310419f, -0.03359847f, 0.01796957f, 0.02727701f, 0.02438615f, 0.03090085f, 0.04226017f, 
    0.00007378f, -0.02463016f, -0.00055170f, -0.03059795f, 0.00866598f, -0.04623003f, -0.04165218f, 0.00852861f, 
    0.00945605f, -0.03657144f, -0.02181712f, -0.03479664f, -0.03166250f, -0.03495163f, 0.02493763f, 0.00451292f, 
    0.01622149f, 0.00229005f, -0.01852200f, 0.03327086f, 0.00201215f, 0.01002567f, -0.04668014f, 0.00867258f, 
    -0.03066959f, -0.03170710f, 0.02729798f, 0.00607601f, 0.01623868f, 0.01530617f, 0.01153375f, -0.00872938f, 
    0.02185651f, 0.01165475f, -0.00007145f, 0.05201596f, 0.02100490f, -0.04278835f, -0.00787011f, -0.01104135f, 
    -0.03831573f, 0.01504695f, 0.04837644f, -0.04038225f, 0.03088269f, -0.04604058f, 0.01728282f, 0.03074496f, 
    0.02809003f, 0.04201727f, -0.04299816f, -0.00586672f, -0.01301032f, -0.00532376f, 0.03817320f, -0.00197338f, 
    0.03638275f, -0.04067830f, 0.01938317f, -0.00669217f, 0.02772291f, -0.01006988f, 0.02184399f, 0.00908614f, 
    -0.04615965f, 0.01784643f, -0.03206351f, 0.00759865f, 0.03299477f, 0.03674330f, -0.04923125f, -0.03357815f, 
    0.02948081f, -0.01156201f, 0.02010836f, 0.00117341f, -0.00413938f, -0.02603793f, -0.05238905f, 0.03942576f, 
    -0.02647121f, 0.04315981f, 0.00284225f, -0.05313675f, -0.04010179f, 0.02918684f, -0.02704404f, 0.03001407f, 
    0.00629765f, 0.01947446f, 0.03111784f, 0.04101623f, 0.00190808f, -0.02679888f, 0.01899677f, 0.00330401f, 
    -0.01729332f, -0.03917779f, -0.01741826f, -0.01225085f, 0.00573595f, 0.00060946f, 0.00923456f, 0.01670397f, 
    0.02406689f, 0.01740168f, -0.00946362f, 0.01761602f, -0.03930901f, -0.02327083f, -0.04649061f, -0.03209778f, 
    -0.02982941f, 0.03250665f, 0.00621346f, -0.05146200f, -0.04487170f, -0.00417721f, -0.04864752f, -0.01863601f, 
    0.02573683f, -0.02316567f, 0.03378706f, 0.02525371f, -0.01080991f, 0.03587278f, -0.01474282f, -0.04295571f, 
    -0.01243795f, -0.00227494f, 0.02816850f, -0.00124476f, -0.00976696f, -0.00131416f, 0.03842200f, -0.02244119f, 
    -0.00283678f, 0.00314601f, -0.03114225f, 0.00733197f, 0.03866605f, 0.03348454f, 0.01259348f, -0.03772216f, 
    -0.01074631f, -0.02418444f, 0.02659298f, 0.00205673f, -0.00922861f, -0.03989948f, -0.02932293f, 0.01020681f, 
    0.02267343f, -0.00839413f, 0.01328183f, 0.04189910f, 0.04028194f, -0.03966162f, 0.01414487f, 0.00946272f, 
    -0.00041577f, -0.01699369f, 0.00233732f, -0.03066788f, -0.05538056f, 0.00162673f, -0.00021747f, 0.01174235f, 
    0.01609794f, -0.00393802f, -0.04302863f, -0.02336289f, -0.00926247f, -0.03245239f, 0.02955569f, 0.02210340f, 
    -0.04488522f, 0.04337535f, 0.04031861f, -0.02842241f, 0.02474236f, -0.03741940f, 0.02484739f, -0.04834826f, 
    0.04237922f, 0.03754421f, 0.04410842f, 0.01774199f, -0.02195128f, -0.01628892f, 0.03062152f, 0.02997219f, 
    -0.03016333f, -0.00840757f, 0.00092494f, 0.00301684f, -0.00820813f, 0.00803574f, -0.01044092f, 0.02593948f, 
    0.01810215f, -0.01009822f, -0.02710092f, 0.01242178f, -0.01567503f, -0.05210965f, -0.03066641f, -0.01880356f, 
    -0.03343935f, 0.01040432f, 0.04615690f, -0.00168853f, -0.05182930f, -0.01189904f, 0.02542393f, 0.01526388f, 
    0.04097549f, 0.01152369f, -0.00311022f, -0.03566087f, -0.03127950f, -0.04686004f, -0.02477470f, 0.03845686f, 
    -0.04521114f, -0.04902285f, 0.01010521f, -0.02676595f, 0.04082939f, 0.01029053f, -0.02414091f, -0.04756973f, 
    0.02542212f, -0.04569582f, 0.03246566f, 0.02762633f, -0.05772378f, -0.00356132f, -0.00995944f, -0.01032280f, 
    -0.02354090f, 0.00698485f, -0.03450620f, 0.01653412f, 0.05542732f, 0.00022089f, -0.03635512f, 0.00716417f, 
    -0.03677848f, -0.00324302f, 0.03385887f, -0.03201637f, -0.00012838f, 0.02240855f, 0.04571696f, 0.01030592f, 
    0.01136379f, 0.00935882f, 0.03774871f, 0.03517598f, -0.00092595f, -0.00672645f, -0.01341067f, 0.01201878f, 
    -0.02634594f, 0.01933934f, -0.05334854f, 0.03577084f, 0.04898588f, 0.04653477f, -0.00862900f, 0.03326757f, 
    0.01958374f, -0.03891788f, -0.05252113f, 0.00900700f, -0.05605783f, 0.01169837f, 0.02318361f, -0.02855314f, 
    -0.02272240f, -0.03859719f, -0.00767189f, -0.00827685f, -0.01550716f, 0.02550261f, -0.01568504f, 0.01309912f, 
    -0.05010946f, -0.04786188f, -0.00881550f, -0.00669737f, -0.00456695f, 0.02913146f, 0.00553114f, -0.02611312f, 
    -0.01655311f, 0.03967887f, -0.02444249f, 0.02949762f, -0.00246144f, -0.00892881f, 0.03652844f, 0.01288783f, 
    0.02131946f, 0.03738429f, -0.00958455f, 0.01357289f, -0.04550248f, -0.03994406f, -0.01320412f, 0.00009564f, 
    0.02686318f, 0.01853755f, 0.01590753f, -0.02959325f, -0.01512372f, 0.01606308f, 0.00721980f, 0.01026210f, 
    -0.02668825f, -0.01248092f, -0.00886526f, 0.04020984f, 0.01063269f, -0.05134319f, -0.02718336f, -0.01698385f, 
    -0.00190682f, -0.00286257f, -0.03287778f, -0.01104459f, -0.00740067f, 0.03906707f, 0.02936498f, -0.00969860f, 
    0.00684951f, -0.02425282f, -0.04430247f, -0.00896784f, -0.03011495f, -0.04549021f, -0.03851192f, -0.05308745f, 
    -0.02654528f, 0.02336085f, 0.03158971f, 0.00265915f, 0.02266506f, 0.05428601f, -0.03385983f, -0.00149640f, 
    -0.01200180f, -0.04011476f, 0.02138177f, 0.02866898f, 0.05370482f, -0.01559494f, -0.03138367f, -0.02993537f, 
    0.03815186f, 0.00673271f, -0.04147550f, -0.05082135f, 0.02794190f, -0.02715874f, -0.02046013f, -0.00848150f, 
    0.04009569f, -0.00510598f, 0.00701982f, -0.03825680f, -0.01492860f, -0.00403264f, -0.00110821f, -0.03892487f, 
    0.00405499f, 0.03503513f, -0.00333742f, -0.04838772f, -0.00745326f, -0.01574058f, -0.03027123f, -0.02231854f, 
    -0.04213857f, -0.04247437f, -0.03388498f, 0.02162082f, 0.03722809f, 0.03474619f, -0.04740861f, -0.02257470f, 
    -0.04676516f, -0.00891331f, -0.02995595f, 0.01427646f, 0.00840912f, -0.03620122f, -0.00732669f, 0.03800325f, 
    0.01676972f, -0.02873854f, 0.00730290f, -0.04583272f, 0.01153205f, -0.00037971f, -0.04885291f, -0.04462532f, 
    -0.01722538f, -0.00119918f, 0.00602110f, 0.02017787f, 0.00922180f, 0.00022168f, -0.02370140f, -0.04501216f, 
    -0.03425034f, 0.02439698f, -0.03456116f, 0.04883900f, 0.01173761f, -0.06107045f, 0.05278085f, -0.05458067f, 
    0.02463740f, 0.00042156f, 0.03849382f, -0.05293465f, -0.04254931f, 0.05259945f, -0.00792699f, 0.04198631f, 
    -0.05795218f, -0.03939172f, 0.00252458f, 0.01670622f, -0.04941095f, -0.01586496f, -0.00364429f, -0.05788379f, 
    -0.04223477f, 0.02015819f, -0.01048496f, 0.03836343f, -0.04843589f, -0.04772102f, -0.05486014f, 0.03713515f, 
    -0.01552390f, 0.05446694f, -0.03785287f, -0.02299271f, 0.02965371f, 0.03537564f, -0.05341508f, -0.02381223f, 
    -0.00042273f, 0.01288492f, 0.02729081f, -0.00646868f, -0.05779362f, -0.03859160f, 0.00605125f, 0.04557184f, 
    -0.00305309f, -0.02503619f, 0.03145481f, -0.01667868f, -0.02466286f, -0.03589706f, -0.03435328f, -0.00891171f, 
    -0.00921881f, -0.03295499f, -0.02015518f, -0.03153076f, -0.03748428f, 0.01972743f, -0.01863982f, 0.01592697f, 
    -0.02736767f, 0.03320262f, -0.00127961f, 0.02605516f, 0.04195142f, -0.02654646f, -0.02396497f, 0.04731341f, 
    -0.04113832f, 0.00353510f, 0.03995206f, 0.04723110f, -0.04643941f, -0.03855108f, 0.04057382f, -0.00892641f, 
    0.04073562f, 0.01331552f, -0.01188983f, -0.05080963f, -0.01757677f, -0.02796470f, -0.01400364f, 0.00667266f, 
    -0.03720989f, 0.04716528f, -0.04475223f, 0.02803208f, 0.01611441f, -0.02194159f, 0.00772711f, -0.03432204f, 
    -0.02114356f, -0.01134930f, -0.02170903f, 0.03605811f, -0.02070595f, -0.01519556f, 0.00129493f, 0.03362036f, 
    0.04381417f, 0.04045096f, 0.03606689f, -0.02501139f, -0.01497760f, 0.00431723f, -0.01963123f, -0.02992600f, 
    -0.00043148f, -0.01828851f, 0.02013753f, 0.03520020f, -0.04148900f, -0.01027871f, -0.02611468f, 0.02523472f, 
    0.03716887f, 0.00844573f, 0.00927514f, 0.01369083f, -0.00911116f, 0.03428886f, 0.02540998f, -0.02262453f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.09450465f, -0.04951136f, 0.05227938f, -0.03450694f, 0.00774503f, 0.11610544f, 0.00687216f, 0.00277521f, 
    0.09024568f, 0.03652079f, -0.00601149f, 0.07668748f, 0.02763677f, 0.02653669f, 0.03626398f, -0.06325167f, 
    -0.00453007f, 0.03135844f, -0.02917947f, 0.09705872f, -0.03495748f, 0.04108326f, 0.08724660f, 0.02284157f, 
    0.02483966f, -0.05424777f, -0.03394419f, -0.01191195f, 0.08233105f, 0.03548517f, -0.00596385f, -0.01405080f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.30217299f, 0.10255217f, 0.03325909f, -0.08646739f, -0.17513624f, -0.01488634f, 0.02900119f, 0.39202237f, 
    -0.04503014f, 0.04083101f, 0.01071152f, -0.25493050f, -0.16094942f, 0.09090454f, -0.04108836f, -0.34134433f, 
    -0.04427123f, 0.23876373f, -0.13846217f, 0.34935051f, -0.05195411f, -0.01031275f, 0.23996687f, 0.42098400f, 
    -0.00560350f, -0.05636591f, 0.00127046f, -0.15445580f, -0.41668186f, 0.04553675f, 0.08685490f, 0.12275594f, 
    -0.13835253f, -0.02385353f, 0.15051118f, 0.09893677f, -0.34931129f, 0.03532346f, -0.03842816f, -0.19858475f, 
    0.11291724f, 0.23456916f, 0.04806273f, 0.19341491f, -0.09699935f, 0.14436169f, 0.33967739f, 0.13047715f, 
    -0.04889550f, -0.04159948f, 0.15845218f, -0.22283886f, 0.03965987f, -0.08804237f, 0.47892967f, 0.22589934f, 
    0.05505681f, -0.13707875f, 0.12038603f, -0.05993621f, -0.09111878f, -0.06341343f, 0.06359731f, 0.18373688f, 
    0.09689050f, 0.15469645f, 0.26392201f, 0.02953063f, 0.00909922f, 0.26653829f, -0.03939187f, 0.33156046f, 
    0.22526526f, -0.19237953f, -0.34735534f, 0.38791195f, -0.12544155f, 0.04382773f, -0.37067917f, -0.03180578f, 
    -0.10283579f, 0.25743788f, 0.01344619f, 0.02091049f, -0.02889362f, 0.13952801f, -0.11914910f, -0.44015595f, 
    0.08272381f, -0.02904871f, 0.00496592f, 0.14569469f, 0.50088423f, -0.12650976f, 0.17112553f, 0.13585365f, 
    0.19095467f, -0.16634159f, -0.23502280f, -0.02906858f, -0.37582561f, -0.16990031f, 0.04007082f, -0.45926034f, 
    0.35741717f, 0.28364512f, 0.35436910f, -0.12735060f, 0.05068000f, 0.18110840f, -0.11922415f, 0.19043441f, 
    -0.23837020f, -0.00991247f, 0.15084521f, 0.23839235f, 0.14821546f, 0.16178870f, 0.19053878f, 0.06586065f, 
    0.12744287f, 0.06239463f, 0.04973830f, 0.13382983f, -0.13545741f, 0.01989526f, 0.07647410f, -0.13734502f, 
    0.14086494f, 0.15855201f, -0.14251529f, 0.01064312f, -0.41818845f, 0.15980887f, -0.06797913f, -0.13981514f, 
    0.00166990f, 0.38143268f, 0.06957578f, 0.11127669f, 0.16278526f, 0.07943989f, 0.57093191f, -0.21603292f, 
    -0.04736928f, -0.03013198f, 0.15569617f, 0.16906121f, -0.08655986f, 0.11381378f, 0.10684318f, 0.42015278f, 
    0.11634537f, 0.09034905f, -0.14884286f, -0.04078458f, -0.12530081f, -0.14749348f, -0.01725593f, 0.15404341f, 
    -0.10743313f, -0.15414874f, 0.19666009f, -0.14406408f, 0.18069749f, 0.02910226f, 0.16301909f, -0.25641951f, 
    -0.05775415f, -0.35756645f, 0.34359595f, 0.13122956f, -0.09414902f, -0.12326166f, 0.13058546f, 0.06789853f, 
    0.18665630f, -0.35746107f, 0.00798763f, 0.21007353f, -0.08119044f, 0.01844439f, -0.00437123f, 0.00674907f, 
    0.09257389f, 0.04524730f, -0.05834407f, 0.07798130f, -0.11203146f, 0.16598904f, -0.06246154f, -0.14186615f, 
    -0.00653061f, -0.07120301f, 0.23889129f, -0.14219919f, -0.02540058f, 0.42872173f, 0.01987605f, 0.02335661f, 
    0.14954197f, -0.10137245f, 0.45042652f, 0.14733253f, 0.08878843f, 0.02719919f, 0.57042694f, -0.16793616f, 
    -0.08561525f, -0.32705456f, -0.11969598f, -0.04695914f, 0.07648714f, -0.12728338f, -0.00893475f, -0.33256233f, 
    -0.02864239f, 0.03410970f, -0.03536049f, -0.07177968f, 0.14331599f, -0.03594502f, -0.17107491f, -0.13414207f, 
    -0.16465180f, 0.14247070f, -0.13730378f, 0.11969194f, -0.01938988f, 0.00227290f, -0.02792251f, -0.14773299f, 
    -0.10849353f, 0.06709747f, -0.07650891f, -0.13047469f, -0.02539346f, -0.02355371f, -0.07582962f, -0.08982085f, 
    0.14546007f, 0.12129075f, 0.03931068f, -0.12465451f, 0.14003670f, 0.07286418f, 0.01950702f, 0.15693802f, 
    0.01373968f, 0.02269635f, 0.15732896f, 0.02208413f, -0.13171694f, -0.05548725f, 0.17211197f, 0.17428748f, 
    -0.15546069f, -0.05152341f, -0.10854950f, -0.05803039f, 0.17561433f, -0.09513150f, -0.06166567f, 0.16814972f, 
    -0.17372206f, -0.11514215f, 0.01880767f, -0.10656247f, -0.08325776f, -0.15632829f, -0.09610746f, -0.03588416f, 
    -0.00002379f, -0.07561606f, 0.14268897f, -0.15638976f, -0.02787420f, 0.02267138f, 0.00974498f, -0.11949000f, 
    -0.16245681f, -0.01708429f, 0.07903825f, 0.04758628f, 0.11669714f, -0.12064622f, 0.00597429f, 0.13852544f, 
    0.20632045f, -0.07545634f, -0.17974597f, -0.10014064f, -0.33898264f, 0.19753344f, 0.05349014f, -0.11975949f, 
    -0.13522516f, 0.24345888f, 0.08824751f, -0.10497767f, -0.07555484f, -0.05880379f, 0.34336698f, 0.11224042f, 
    0.13784596f, -0.04850937f, -0.06216514f, -0.05228939f, -0.10628033f, 0.00100535f, -0.29533243f, -0.22587988f, 
    0.13455306f, 0.00257167f, 0.12530422f, -0.10030983f, 0.27828646f, -0.07015324f, -0.16664656f, 0.01104165f, 
    -0.06174628f, 0.06318334f, -0.16886397f, -0.10783691f, -0.17261642f, 0.03097540f, 0.17616712f, -0.41182774f, 
    -0.12556516f, -0.01991069f, 0.25362435f, 0.39992306f, -0.05182632f, 0.14265572f, 0.00922902f, 0.19881535f, 
    0.01387435f, 0.29071012f, 0.11101652f, -0.08647045f, 0.06065803f, -0.17454302f, 0.03882783f, 0.17297600f, 
    -0.12782840f, 0.01057885f, -0.10588514f, -0.06670011f, 0.40171468f, 0.02492524f, -0.12722023f, -0.16033693f, 
    0.13527325f, -0.10620331f, 0.37282622f, 0.01069370f, 0.37793776f, 0.05098246f, 0.07959168f, 0.37277502f, 
    0.47010726f, -0.22288221f, -0.15535513f, 0.13680407f, -0.10828109f, -0.03518619f, 0.12683171f, 0.30499366f, 
    0.26459554f, -0.28829828f, -0.16815065f, -0.34433928f, -0.05140591f, -0.16553394f, 0.14860007f, -0.31344908f, 
    -0.03002242f, -0.13994725f, -0.14401376f, -0.08506905f, -0.05265461f, -0.02813258f, 0.00374578f, -0.05767922f, 
    -0.25666451f, 0.13820714f, 0.13768353f, 0.04362764f, 0.43018138f, -0.26863334f, -0.01312155f, 0.17602749f, 
    0.19105598f, 0.12251504f, 0.12175982f, 0.12470464f, -0.08059007f, -0.05369700f, -0.42210367f, 0.40083036f, 
    0.16555546f, 0.05565310f, 0.02139630f, -0.03291964f, 0.15229119f, 0.06195292f, 0.26951191f, 0.07803308f, 
    -0.09237887f, -0.12544715f, -0.08836874f, 0.15325440f, -0.12381770f, 0.07034528f, -0.02685830f, 0.04218138f, 
    -0.15903060f, 0.01883041f, 0.05304899f, 0.05364372f, 0.21307363f, 0.28156573f, 0.15348892f, -0.34059924f, 
    -0.37802860f, -0.19382128f, 0.48076773f, -0.02016099f, 0.06174324f, 0.12634848f, -0.14547317f, 0.06573371f, 
    0.06778049f, -0.25391895f, 0.15010977f, 0.29361719f, -0.06735477f, 0.11617677f, -0.03093002f, 0.27342185f, 
    -0.08557878f, 0.09558142f, -0.15679801f, 0.13442402f, 0.39388198f, 0.15568784f, -0.11567246f, -0.05556127f, 
    -0.17549367f, 0.09734653f, -0.15088315f, 0.06319872f, -0.17809910f, 0.07374433f, 0.10691091f, -0.08458930f, 
    0.03210790f, 0.03260373f, 0.14727639f, -0.17194939f, -0.05221957f, 0.04394041f, -0.00026274f, -0.00102599f, 
    -0.08767506f, 0.09809745f, 0.09008735f, -0.03382587f, -0.08888774f, -0.08636352f, -0.02112693f, -0.04092878f, 
    -0.08724026f, -0.16989021f, -0.16137549f, -0.10046289f, -0.14750335f, -0.09679551f, -0.16257979f, 0.03688884f, 
    -0.02568822f, -0.14883703f, 0.21982589f, -0.08317241f, 0.53627032f, 0.13942079f, 0.14063945f, -0.21452720f, 
    -0.27812001f, -0.07706844f, 0.36003360f, -0.03453455f, 0.14247875f, -0.15144315f, -0.03840313f, -0.12574469f, 
    0.38302931f, 0.00050875f, 0.17398803f, 0.09638079f, 0.17183121f, -0.01218399f, -0.08203424f, -0.14729202f, 
    0.00875765f, 0.10899151f, 0.11952868f, -0.05012498f, 0.30896980f, 0.00211109f, 0.14649969f, 0.09889363f, 
    0.14160985f, 0.15860602f, -0.00993978f, 0.06141273f, 0.24450622f, -0.31239286f, -0.08448514f, -0.08117672f, 
    -0.14888498f, -0.12942161f, -0.11477982f, 0.28640130f, -0.13472363f, -0.07885050f, -0.37499008f, -0.08837600f, 
    0.27820581f, 0.37056085f, -0.02589996f, 0.20675474f, 0.01606619f, 0.01789640f, 0.31580889f, 0.28560108f, 
    0.13783263f, -0.16312851f, 0.04817270f, -0.07588896f, -0.18576169f, 0.03061191f, 0.01088614f, 0.13148515f, 
    0.00331766f, 0.12545232f, 0.20205151f, -0.14512241f, 0.13416827f, 0.07846703f, -0.00974553f, 0.23703319f, 
    -0.44365954f, 0.10559779f, -0.07138355f, -0.18273123f, 0.05607150f, 0.09950083f, -0.11765831f, -0.34632108f, 
    -0.11972181f, 0.24952532f, -0.13702314f, 0.41309848f, 0.12462877f, 0.14644563f, 0.45495960f, 0.33523542f, 
    -0.04737631f, -0.12868173f, -0.16242345f, -0.10485979f, -0.25470540f, 0.07328381f, -0.08861518f, 0.09575739f, 
    0.21034284f, 0.03198655f, -0.27698183f, 0.13472846f, -0.19798249f, -0.13322230f, -0.04741405f, 0.35284773f, 
    -0.16895548f, 0.30858165f, 0.25498492f, -0.06330874f, 0.11954281f, 0.03048778f, 0.13068758f, 0.55527246f, 
    -0.44739491f, 0.03860642f, 0.05959045f, 0.25931510f, 0.15403007f, 0.10901526f, -0.28615141f, 0.16231227f, 
    -0.12325886f, 0.08166765f, 0.02461838f, -0.04482134f, 0.19258815f, 0.15471676f, -0.06474801f, 0.16373125f, 
    0.14774410f, 0.04324700f, -0.20784901f, 0.13357419f, -0.03654760f, 0.06907923f, 0.03390336f, -0.45640483f, 
    0.24042013f, 0.42186487f, 0.18538712f, -0.15998662f, -0.05856066f, 0.01809455f, -0.21358012f, 0.18570572f, 
    -0.25994250f, -0.00150109f, 0.07306636f, 0.07616945f, -0.07068978f, -0.05985235f, 0.09286451f, 0.34783098f, 
    -0.05467344f, -0.14494151f, 0.08916073f, -0.17484105f, -0.21141660f, 0.04332375f, -0.13336752f, -0.08623935f, 
    -0.07556684f, -0.05925559f, 0.21623367f, -0.00180579f, 0.16014305f, 0.11828581f, -0.02176255f, 0.26030937f, 
    -0.21440090f, -0.43166739f, 0.21509998f, 0.09147489f, -0.14115359f, 0.08851646f, 0.02251492f, -0.03039844f, 
    0.03837721f, -0.24980682f, 0.11467218f, 0.06869106f, 0.13112618f, 0.01252700f, -0.19420932f, 0.08179066f, 
    -0.04357512f, -0.17151906f, -0.05504044f, 0.05419126f, 0.06602204f, -0.12363365f, -0.02644765f, -0.11118516f, 
    0.03887537f, -0.17275281f, 0.04630820f, -0.17293914f, -0.08921524f, 0.14493309f, 0.00288601f, -0.15023117f, 
    -0.09350750f, -0.15722154f, -0.10009982f, -0.16164285f, 0.08569900f, 0.10464372f, -0.17122021f, -0.14696202f, 
    -0.09978248f, -0.03959116f, 0.14645819f, -0.09335019f, 0.01489005f, -0.01186763f, -0.05921878f, -0.03551684f, 
    0.14557289f, 0.11908627f, 0.10963817f, -0.16118906f, 0.12922768f, -0.03762273f, 0.16648933f, 0.12213664f, 
    -0.07031780f, 0.01659900f, 0.07077495f, 0.03157232f, -0.34570065f, 0.37944448f, 0.03581633f, 0.26863641f, 
    0.40272707f, -0.25069377f, 0.15724738f, 0.30879578f, -0.01220464f, 0.12334205f, 0.38519594f, 0.00872329f, 
    -0.25346652f, -0.02118639f, 0.10459507f, 0.01122809f, 0.17422085f, 0.11794469f, 0.20221439f, -0.35073903f, 
    -0.04338276f, 0.14453454f, 0.02036336f, -0.12003718f, -0.18288074f, -0.04711787f, 0.13976531f, 0.12912573f, 
    0.23584484f, -0.09271156f, -0.03426900f, 0.09953583f, 0.33881873f, 0.07736646f, -0.09356587f, 0.14285251f, 
    -0.18831800f, 0.06141979f, -0.29028443f, 0.18458535f, -0.05240145f, -0.10499169f, -0.44705757f, 0.09009997f, 
    0.05977616f, 0.30307207f, 0.12839422f, 0.25719029f, -0.16484384f, -0.03876505f, -0.47440886f, -0.09974120f, 
    0.01581797f, 0.14343846f, -0.08530598f, 0.14601682f, 0.49549407f, -0.14720182f, 0.13251290f, -0.05486177f, 
    -0.07325201f, -0.14469077f, -0.16223516f, -0.08492193f, -0.17016773f, 0.06328034f, -0.06449462f, -0.02004331f, 
    0.06767955f, -0.13821155f, -0.11386897f, -0.10217622f, 0.09375722f, -0.16405867f, -0.02051396f, 0.12170413f, 
    -0.14880195f, -0.18278073f, 0.07076188f, 0.03274206f, 0.08384155f, -0.14416498f, -0.16083896f, -0.00263095f, 
    0.06510076f, -0.01617889f, 0.16643141f, -0.05367934f, 0.06220039f, -0.10816850f, -0.05961541f, -0.09930371f, 
    0.15661836f, 0.02806758f, -0.10239962f, -0.16299085f, -0.05771778f, 0.34166735f, 0.15351219f, -0.03039972f, 
    0.38695043f, 0.13696989f, 0.40124014f, -0.21153228f, -0.04432551f, 0.02401562f, -0.25255552f, -0.48976693f, 
    0.58166951f, 0.35353673f, 0.10126551f, 0.31860310f, 0.02028855f, -0.11898538f, -0.20020118f, -0.45794576f, 
    0.01857521f, 0.14906803f, -0.02607918f, -0.03686315f, -0.18134761f, 0.06996659f, -0.01763694f, -0.04134978f, 
    0.18227525f, 0.09236763f, 0.31056929f, -0.03556938f, 0.31167233f, 0.23792011f, 0.10993285f, 0.11182294f, 
    0.18563505f, 0.12930852f, -0.31290713f, -0.01387501f, 0.10085820f, 0.04799788f, -0.16458368f, -0.02942625f, 
    0.13179289f, -0.19360928f, -0.13449390f, -0.28573513f, 0.04814233f, -0.13261017f, 0.45432004f, 0.25741172f, 
    -0.06269817f, 0.12820074f, 0.13334511f, -0.10988631f, -0.24008316f, 0.17551845f, -0.08710665f, 0.02079722f, 
    0.08829113f, -0.04795457f, 0.18020463f, -0.03822797f, 0.07569625f, 0.24441785f, -0.06003049f, 0.32142434f, 
    -0.19307379f, -0.17304420f, -0.33561605f, -0.01840566f, -0.15712720f, 0.15318631f, 0.35431075f, -0.12947342f, 
    -0.37192124f, -0.40747470f, -0.11966938f, 0.08276872f, 0.04849395f, 0.01899051f, 0.10286795f, 0.30641004f, 
    -0.05142952f, 0.10995407f, 0.10294878f, 0.01395250f, 0.22740762f, -0.17351079f, -0.10042016f, 0.09506539f, 
    0.34101126f, 0.11477911f, -0.07494843f, 0.06661816f, -0.01531961f, 0.15322034f, 0.14188345f, 0.00410664f, 
    -0.10459852f, 0.46822104f, -0.26614735f, -0.10164759f, 0.08959196f, 0.00454025f, -0.20716673f, 0.27605340f, 
    -0.38617542f, -0.01475955f, -0.12419773f, -0.03083849f, -0.01546409f, -0.00908535f, -0.08401629f, 0.44151759f, 
    0.03838348f, 0.06805921f, -0.13338551f, 0.10544039f, 0.44108486f, -0.03531527f, -0.02990804f, -0.17708623f, 
    -0.12309789f, 0.12032116f, 0.11507084f, 0.13351008f, 0.02613933f, -0.04406924f, 0.15193442f, 0.17099121f, 
    -0.02573632f, -0.07865794f, 0.06769497f, -0.15063868f, -0.10871553f, 0.05409967f, 0.01007729f, -0.09996387f, 
    -0.10070039f, 0.00770366f, -0.05023824f, -0.08020266f, -0.09102845f, -0.12442805f, -0.00988295f, -0.15667163f, 
    0.04074257f, 0.15500209f, 0.05798329f, 0.12509793f, 0.15530203f, -0.03694762f, -0.02981061f, 0.03843448f, 
    -0.09712191f, -0.10954498f, -0.14472264f, -0.08145723f, -0.07944079f, -0.11770110f, 0.08002748f, 0.12399780f, 
    -0.08006020f, -0.06169125f, -0.05999937f, -0.01263499f, 0.07550658f, 0.04422098f, 0.13570526f, -0.17620240f, 
    -0.03601199f, -0.10573540f, 0.00092660f, -0.04822629f, -0.11512054f, 0.01553400f, 0.07055973f, 0.06089052f, 
    0.01930111f, -0.16596876f, 0.13100947f, 0.09301672f, -0.06764978f, -0.10369315f, 0.05065466f, 0.12425741f, 
    -0.00493558f, -0.06349812f, -0.06306873f, -0.04962768f, -0.11451196f, -0.12503994f, -0.11743511f, 0.04673234f, 
    -0.07872312f, 0.15523043f, -0.04928295f, -0.08248583f, 0.14006764f, -0.12620221f, 0.08200044f, 0.04505300f, 
    0.00508127f, -0.02904682f, -0.12046477f, -0.07905146f, -0.00773885f, -0.01419627f, 0.04877304f, -0.14929436f, 
    0.02569400f, 0.11162005f, -0.05472885f, 0.16841060f, -0.09515261f, 0.14204219f, -0.11559962f, 0.10750175f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.12035901f, 0.18710336f, 0.20706865f, 0.13968028f, 0.03493061f, -0.12113478f, 0.15355019f, 0.09886501f, 
    -0.10279883f, -0.07816955f, 0.12869978f, 0.03409109f, 0.13222641f, 0.06662475f, -0.14986497f, -0.17064869f, 
    0.10786643f, 0.06566183f, 0.10235113f, 0.19425386f, 0.01340153f, 0.14209609f, 0.07594805f, 0.00100551f, 
    -0.04385034f, 0.08142930f, 0.14250056f, 0.04307753f, 0.16177140f, 0.15186195f, 0.09622777f, 0.14504489f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.43931732f, -0.25822476f, -0.27628210f, -0.13765509f, -0.03548351f, 0.37337092f, 0.21400532f, -0.14880903f, 
    0.10069436f, 0.25248545f, 0.27324295f, -0.21254034f, -0.04774218f, 0.45462877f, 0.15524341f, 0.38300931f, 
    0.01568828f, -0.18434143f, 0.04142516f, -0.37251374f, 0.25767139f, -0.00552150f, -0.21370101f, 0.10696630f, 
    -0.14714625f, 0.00251942f, -0.45530573f, -0.73654294f, -0.18562900f, 0.11513253f, -0.13431810f, -0.10470395f, 
    -0.32768193f, -0.29658464f, 0.13500383f, 0.20461524f, -0.34577832f, 0.27883950f, 0.22767407f, 0.04671838f, 
    0.15003350f, -0.22531328f, -0.19728063f, 0.26486114f, -0.07068919f, 0.21777634f, 0.01445381f, 0.08066826f, 
    -0.32137951f, -0.44045764f, -0.25750339f, 0.29075724f, 0.31884763f, 0.16505432f, 0.20501685f, -0.00706368f, 
    0.03912780f, -0.02752472f, 0.17601115f, 0.04018723f, -0.15522164f, 0.05512040f, -0.06792247f, 0.07889652f, 
    -0.11122523f, -0.17194358f, 0.05085294f, -0.31876853f, -0.43306190f, -0.02183270f, -0.26374802f, 0.17168748f, 
    0.05903248f, -0.03140897f, -0.18392701f, 0.26169279f, 0.37494713f, -0.06839120f, 0.05404510f, 0.24578643f, 
    0.42765486f, 0.22521146f, -0.60600799f, -0.42143428f, -0.39259678f, 0.13333297f, -0.31251675f, 0.07531694f, 
    -0.12255838f, -0.10532690f, 0.29498246f, -0.75733012f, -0.10830498f, -0.04943408f, -0.14982121f, 0.03982423f, 
    0.27472949f, -0.11257612f, -0.47697234f, 0.28868484f, 0.11455585f, 0.12780552f, 0.07386743f, 0.01323016f, 
    -0.04517765f, -0.13333519f, -0.25070268f, -0.37412947f, -0.12329535f, 0.14556694f, -0.13316229f, -0.18781967f, 
    -0.24798478f, 0.28563756f, 0.16875061f, 0.23816468f, -0.27714542f, -0.11217293f, 0.29611939f, -0.34754291f, 
    0.01932758f, 0.18907270f, -0.42797384f, -0.44161808f, -0.21319053f, -0.08262505f, -0.01459478f, -0.02792967f, 
    -0.26768130f, 0.24615292f, -0.10038318f, 0.21268597f, 0.13685241f, -0.09611180f, -0.01093909f, -0.04583305f, 
    0.05246663f, 0.20725444f, 0.30802059f, -0.20996743f, -0.06981148f, 0.28925806f, 0.07927282f, 0.00024089f, 
    -0.35857484f, -0.20891239f, 0.04035249f, 0.38750014f, -0.64573240f, 0.12697284f, -0.16827294f, 0.02153912f, 
    -0.02812197f, -0.20651650f, 0.09211774f, -0.37342203f, 0.39613262f, -0.09026939f, 0.10670836f, 0.12602964f, 
    -0.25721174f, -0.09273483f, 0.23192777f, -0.27984226f, 0.18718114f, -0.27673537f, 0.24888495f, 0.07443073f, 
    -0.16367817f, 0.50364310f, 0.00735154f, 0.07162324f, -0.41877407f, -0.14970876f, -0.15003258f, -0.10032641f, 
    -0.53310072f, -0.35383391f, 0.16161020f, -0.67021137f, -0.16682211f, 0.02076025f, 0.30066076f, 0.23751126f, 
    -0.13316949f, -0.16984425f, -0.10862853f, 0.15249997f, 0.21341525f, 0.06438375f, 0.13793202f, 0.10053627f, 
    0.34929341f, -0.34137487f, -0.06592167f, -0.47965789f, -0.10340799f, -0.44673580f, 0.00273501f, 0.00857615f, 
    -0.11119236f, -0.49732840f, -0.36638957f, -0.03980519f, -0.15963636f, 0.09857042f, -0.11470959f, -0.04767045f, 
    -0.20470285f, 0.50211644f, 0.12225441f, -0.19575694f, 0.09698852f, -0.12943333f, -0.20520397f, 0.17335372f, 
    -0.11991380f, -0.45204702f, 0.33579120f, 0.34406993f, 0.27646589f, 0.08913064f, 0.12570176f, -0.03077984f, 
    0.20945561f, -0.27653056f, -0.48254472f, 0.25919959f, 0.12163062f, 0.01088507f, -0.42486203f, -0.01583307f, 
    -0.07521661f, 0.21208417f, -0.39199585f, 0.02970563f, 0.00963145f, -0.61997724f, -0.00765400f, -0.24455975f, 
    0.02478120f, -0.18512462f, 0.21961872f, 0.38548234f, -0.36310384f, -0.11527970f, -0.55591166f, 0.05181243f, 
    -0.06710503f, 0.12734266f, 0.14207517f, -0.39839247f, 0.28968686f, 0.03456495f, 0.05124477f, -0.01482185f, 
    -0.22405732f, 0.41325316f, -0.05994391f, -0.08948934f, -0.06734171f, -0.23954807f, 0.15892899f, -0.12610145f, 
    0.03317324f, 0.10099044f, 0.00431569f, 0.42837259f, 0.24799122f, -0.58817971f, 0.06846014f, -0.18294367f, 
    -0.20554207f, -0.45957622f, -0.11816473f, -0.20983544f, -0.27915373f, 0.01217885f, 0.29156852f, -0.63888907f, 
    -0.07277475f, -0.12564735f, 0.24189046f, -0.19549344f, -0.33244592f, -0.11215489f, 0.00152057f, -0.18183257f, 
    -0.10924739f, -0.40674844f, 0.26664758f, -0.11322315f, -0.29463309f, -0.39855790f, -0.37087947f, 0.13205796f, 
    -0.02845114f, -0.31660184f, 0.24802363f, -0.03755777f, 0.14671385f, -0.03464511f, -0.01993892f, -0.23253602f, 
    0.36304715f, -0.09527027f, 0.26596266f, -0.23434439f, -0.22136052f, 0.04698130f, -0.08602712f, 0.46587014f, 
    0.15876798f, -0.34335443f, -0.19396052f, -0.55089360f, 0.19232406f, 0.18462370f, -0.06256462f, -0.11326001f, 
    0.28731063f, -0.33569342f, 0.14745858f, -0.14109737f, 0.11667546f, -0.43453613f, -0.02409518f, -0.06114362f, 
    -0.14107917f, 0.04223829f, -0.10911684f, -0.25610948f, -0.51305526f, -0.29589483f, -0.09519336f, 0.08083818f, 
    0.13738014f, 0.21288122f, -0.53021222f, -0.19379179f, -0.46363559f, 0.04527112f, -0.09023983f, 0.23626865f, 
    0.15958807f, 0.51378912f, 0.11730736f, -0.46987101f, -0.10334867f, 0.15448484f, -0.02197016f, 0.05963792f, 
    0.13469635f, 0.44103232f, -0.23051898f, 0.06154756f, 0.35940978f, 0.19733508f, 0.01178624f, -0.12186269f, 
    -0.13347644f, -0.64420915f, 0.12940587f, -0.12037382f, -0.21364677f, -0.09800576f, -0.01355139f, -0.46260357f, 
    0.29169887f, 0.19630301f, -0.15107046f, 0.01060812f, -0.20419335f, -0.10940876f, 0.19099580f, -0.50425225f, 
    -0.07388106f, -0.43910134f, 0.19560882f, 0.21647915f, 0.01395298f, 0.05024635f, -0.07339745f, 0.02768393f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.00344291f, -0.02066062f, -0.05539302f, -0.15807728f, 0.07242317f, 0.17540684f, 0.14990544f, -0.01566679f, 
    0.02694991f, 0.06562108f, 0.09147030f, 0.15075840f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
