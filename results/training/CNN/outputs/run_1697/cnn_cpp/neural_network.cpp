#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.46938604f, 0.42270601f, 0.12666517f, -0.37594399f, 0.19447434f, 0.47398061f, -0.37515509f, -0.36763236f, 
    0.22994171f, 1.19814456f, -0.81306106f, -0.78659672f, 0.10414621f, -0.08539367f, 0.33886898f, 0.05500891f, 
    -0.04790400f, -0.02568829f, 0.57166332f, 0.23934057f, -0.65494376f, -0.00980878f, -0.29494211f, -0.39952508f, 
    -0.47081965f, -0.33432266f, -0.69544458f, 0.58252972f, -0.17450401f, -0.50618362f, -0.12224939f, 0.41537848f, 
    0.23009884f, -0.25044534f, -0.05703886f, 0.08508421f, -0.89077348f, 0.03750140f, 0.60435790f, -0.68714583f, 
    -0.28858778f, -0.32911700f, -0.30559564f, 0.02283492f, -0.39605013f, 1.21639287f, -0.83513713f, -0.58988023f, 
    0.33098814f, 0.21770984f, -0.41090214f, 0.29179397f, 0.19437510f, -0.37928149f, 0.45911333f, 0.58588904f, 
    0.26913121f, -0.36043665f, -0.15121576f, 0.28483942f, -0.21824569f, -0.31484285f, 0.39269590f, -0.97169042f, 
    -0.80826777f, 0.99733198f, 0.63779426f, 0.27706382f, -0.32075053f, -0.25383398f, -0.22900988f, 0.25273633f, 
    -0.61891741f, -0.44216472f, 0.16320997f, -0.68651050f, -0.75916129f, -0.85160249f, 0.47157949f, -0.34968933f, 
    0.28376615f, 0.26589707f, -0.26386559f, -0.22194864f, 0.04156211f, 0.41253674f, -0.35244390f, -0.25767180f, 
    0.14148270f, 0.26866606f, -0.26162252f, 0.54710889f, -0.30993029f, 0.39067438f, -0.53044480f, -0.11149904f, 
    -0.31962976f, 0.41376436f, -0.49936390f, 0.62763602f, -0.27389774f, -0.66257918f, 0.18627404f, 0.26219249f, 
    -0.12853196f, -0.09305932f, -0.33472925f, 0.37581035f, 0.19683525f, 0.20781022f, 0.20118031f, 0.16774045f, 
    -0.16314399f, 0.33199513f, 0.18092076f, -0.19415726f, -0.02756779f, -0.99980748f, 0.35317263f, 0.35940304f, 
    0.03983413f, -0.40505660f, -0.08505239f, -0.49965322f, 0.33863735f, -0.19559598f, 0.45965627f, -0.11768996f, 
    -0.15235917f, 0.19162732f, 0.45946881f, -0.29196438f, -0.23977885f, 0.11130861f, 0.13491683f, 0.49396333f, 
    -0.16210675f, -0.38956931f, -0.58931875f, 0.79691464f, -0.63668245f, 0.12005858f, 0.31930804f, 0.09077011f, 
    -0.36879781f, -0.53937572f, -0.87908900f, 0.58669847f, 0.47418144f, -0.45439368f, -0.36562744f, 0.32343000f, 
    -0.26891413f, -0.75936300f, 0.68690908f, 0.11487820f, -0.75393838f, 0.63375384f, 0.33229506f, 0.07420039f, 
    -0.13851467f, -0.10548737f, -0.41280416f, -0.67067093f, 0.36598325f, 0.14153256f, -0.79137218f, -0.74564970f, 
    0.27372003f, -0.12570192f, 0.44469923f, -0.60487640f, -0.85260332f, -0.92519295f, 0.53667927f, 0.64102739f, 
    0.40342829f, 0.18815611f, 0.08190323f, -0.17965388f, 0.33127993f, -0.38194636f, 0.25273016f, -0.28692144f, 
    0.14404467f, 0.38322863f, 0.32210848f, -0.31718808f, -0.37338746f, -0.06042917f, 0.11640407f, 0.29221439f, 
    -0.21411118f, 0.15069723f, 0.37058252f, 0.02808093f, 0.18637328f, -0.12032203f, 0.31781703f, 0.01272020f, 
    -0.35312393f, -0.03965062f, -0.08108320f, 0.29968101f, 0.28368673f, -0.26580495f, 0.17697395f, -0.41711184f, 
    -0.92620170f, -0.64129096f, -0.15802281f, -0.28754130f, 0.52795899f, 0.24936801f, 0.51671106f, 0.13024762f, 
    -0.59836859f, 0.05728099f, 0.22404760f, -0.48041600f, -0.11602867f, 0.19505419f, 0.31461212f, -0.07865974f, 
    0.33084756f, 0.42556334f, 0.31036565f, 0.13155405f, -0.05957518f, 0.42069983f, 0.06290073f, -0.23843007f, 
    -0.11021669f, -0.23225695f, -0.07191582f, 0.76560491f, -0.52435678f, 0.11261192f, -0.04274481f, 0.08825656f, 
    -0.34702894f, 0.04379606f, 0.26042840f, 0.70642507f, -0.93694699f, -0.98150152f, 0.56262308f, 0.81239641f, 
    0.30827817f, -0.14818753f, -0.30632117f, -0.17829290f, -0.70378572f, -0.37242910f, -0.50155270f, -0.15027453f, 
    0.40491289f, 0.10361771f, 0.21541700f, -0.38184321f, -0.26968932f, 0.20127398f, 0.07075361f, -0.60485619f, 
    -0.21341364f, -0.48811570f, -0.78999037f, -0.14113805f, -0.12942693f, 0.40835804f, 0.62369144f, -0.39130497f, 
    -0.45234260f, 0.65773505f, -0.52178913f, -0.50510347f, -0.28572521f, 0.42099580f, -0.49494073f, -0.22970280f, 
    0.58430684f, -0.19758818f, 0.04924219f, 0.29355460f, 0.10625914f, -0.06766006f, 0.16005391f, -0.11951827f, 
    -0.11695517f, 0.88657963f, 0.29251003f, -0.74517077f, -0.18605109f, -0.07061449f, 0.24280857f, 0.17630862f, 
    0.36048040f, -0.76399529f, -0.39938149f, -0.40926370f, -0.42795557f, -0.68660378f, -0.32994851f, 0.15027900f, 
    -0.23906906f, 0.51271021f, 0.11014112f, -0.37692398f, 0.22297737f, -0.00173096f, 0.18512370f, -0.48869100f, 
    0.07481436f, 0.35748798f, 0.02125856f, -0.90428442f, -0.11804958f, 0.21326260f, 0.22166428f, 0.07907233f, 
    0.57177800f, -0.45498499f, -0.47462317f, -0.53614533f, 0.03411821f, 0.56139475f, -0.79121917f, -0.08950263f, 
    0.53673178f, -0.53664130f, -0.15663683f, -0.22509281f, -0.23561606f, -1.26183295f, 0.71306199f, -0.65830040f, 
    -0.32192886f, -0.08203552f, 0.73644513f, 0.24730837f, -0.36014917f, -0.12106874f, -0.60800391f, 0.45639035f, 
    0.35558912f, -0.15891792f, -0.08509357f, 0.08532540f, -0.57469553f, -0.10765096f, -0.40479276f, -0.59463388f, 
    -0.53026211f, -0.49980080f, 0.29131877f, -0.25213930f, -0.51410985f, -0.28212419f, -0.24028152f, -0.40100980f, 
    0.67147791f, 0.79716927f, -0.14545423f, -0.66270089f, -0.46112877f, 0.06978408f, -0.33118156f, 0.57055026f, 
    -0.23006389f, -0.68072659f, 0.10960647f, 0.24457815f, 0.41827419f, 0.24425717f, 0.52463561f, 0.05686131f, 
    0.22241928f, -0.17971985f, -0.36361060f, -0.22650701f, -0.29867810f, -0.76670808f, -0.06839384f, -0.67874074f, 
    -0.06730851f, -0.52466363f, -0.73696476f, 0.80437976f, -0.39324903f, -0.58439940f, 0.12581627f, 0.22724666f, 
    0.60395384f, -0.34279495f, -0.00510228f, -0.24546383f, -0.64323527f, 0.80415404f, -0.07655381f, -0.13474804f, 
    0.16668810f, -0.56824583f, 0.28353065f, 0.48728740f, -0.21597083f, 0.20332067f, 0.17280167f, 0.14847273f, 
    -0.01218342f, -0.49012476f, -0.47905013f, 0.08922935f, 0.27141827f, 0.57586026f, -0.02734452f, -0.21145159f, 
    0.54974687f, -0.29998210f, -1.03917623f, -0.62024945f, -0.18655685f, -0.23350665f, -0.40023497f, 0.79577106f, 
    -0.03517436f, -0.52755457f, 0.23976791f, 0.59387296f, -0.07085983f, -0.36415273f, -0.08682062f, -0.39951819f, 
    -0.36671597f, -0.18321013f, -0.36199000f, 0.32288963f, -0.07078284f, -0.35436013f, 0.46234283f, 0.34296098f, 
    0.03537996f, 0.71883452f, 0.10916677f, -0.56650513f, 0.34200624f, -0.08092037f, -0.08726611f, 0.02849970f, 
    -0.05379044f, -0.11336024f, 0.68536389f, -0.84246415f, 0.37117338f, 0.12979785f, -0.40577537f, -0.03611596f, 
    0.38878193f, 0.11442127f, -0.35699877f, -0.58837831f, -0.43392271f, -0.60514700f, -0.01870261f, -0.12983710f, 
    0.16187906f, -0.31676772f, -0.30126938f, -0.42711800f, -0.38946679f, 0.45701167f, -0.44023892f, -0.23564962f, 
    0.01105597f, 0.19385222f, 0.06361487f, 0.23812245f, 0.26310506f, 0.16555707f, -0.59294862f, 0.44728425f, 
    -0.27209324f, -0.29170913f, 0.41994870f, -0.12508947f, -0.31312776f, 0.52385348f, 0.05914900f, -0.17076783f, 
    -0.42722020f, -0.18270838f, -0.57179070f, -0.38963789f, 0.23209555f, 0.42062566f, -0.28168574f, 0.26281872f, 
    -1.08469987f, 0.13828588f, -0.55820107f, 0.47129372f, 0.61949331f, -0.08718231f, 0.01616749f, -0.10293226f, 
    0.54935455f, -1.05175507f, 0.61117470f, -0.62140298f, -0.27422258f, 0.27557895f, -0.38108051f, 0.04829600f, 
    0.16870320f, 0.28780219f, -0.58909678f, -0.57971615f, -0.40666699f, -0.21325727f, 0.23234585f, -0.00724568f, 
    0.38491794f, 0.47164187f, -0.86872303f, -0.42117158f, -0.49782789f, 0.16635446f, 0.34339210f, -0.45865110f, 
    -0.12415046f, -0.35567999f, -0.19150978f, -0.49720436f, -0.41515735f, 0.17646252f, 0.53162652f, -0.38982004f, 
    -0.61081398f, -0.27178597f, -0.33724836f, -0.56959057f, 0.15218370f, -0.25217414f, 0.15977634f, -0.05146408f, 
    0.15790379f, -0.08803195f, 0.22658251f, -0.32959378f, 0.25558919f, 0.74383974f, -0.61403269f, -0.55712086f, 
    -0.84843111f, -0.28604817f, -0.10300127f, -0.51222658f, -0.49665025f, 0.51721781f, -0.16766609f, 0.78963304f, 
    0.58159137f, -0.05641051f, -0.37965694f, -0.41688395f, -0.20416854f, -0.39860514f, -0.15612245f, 0.12972593f, 
    0.25387132f, -0.55697328f, 0.50877905f, 0.50270003f, -0.00047798f, -0.29666159f, -0.24702182f, -0.00540974f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.20048463f, 0.14682984f, 0.08831871f, 0.17606948f, 0.02575963f, 0.21538477f, -0.11690447f, -0.11160523f, 
    -0.00463534f, 0.08566552f, 0.09397188f, 0.21417205f, 0.01926255f, 0.04551666f, 0.23691189f, 0.00652176f, 
    -0.00864100f, 0.22788846f, 0.15426458f, 0.31788898f, 0.26338962f, 0.26092422f, 0.17597987f, 0.11089674f, 
    0.14961664f, 0.08042497f, 0.14990741f, 0.04404636f, 0.17258315f, 0.07981031f, 0.17798527f, -0.04823579f, 
    0.07088168f, -0.23437276f, 0.05224111f, -0.08928843f, 0.07205083f, 0.12945257f, -0.08724191f, -0.14847006f, 
    0.03443594f, -0.24162453f, -0.25903094f, 0.08762360f, 0.02287313f, -0.07686627f, 0.11699393f, 0.09810848f, 
    0.19867514f, 0.27780089f, 0.05835407f, -0.10478377f, 0.09124184f, 0.09048038f, 0.15017633f, 0.13713674f, 
    0.20203279f, 0.21201770f, -0.24907900f, -0.06323405f, 0.19888358f, -0.12610346f, 0.04163315f, 0.24159428f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.61752075f, -0.25287011f, 0.25893945f, -0.03531405f, 0.12581219f, -0.00064610f, -0.04250510f, -0.04216572f, 
    0.03103195f, 0.02038511f, 0.03091019f, 0.05864245f, 0.03055788f, 0.02330367f, 0.01677447f, -0.06311013f, 
    -0.00409721f, 0.05091815f, -0.18404429f, -0.11044907f, 0.02445319f, -0.03624869f, -0.49044344f, 0.12397740f, 
    0.02374673f, 0.03057106f, -0.10043266f, -0.03585706f, -0.05346815f, -0.04340946f, -0.08122347f, -0.07041783f, 
    -0.20680411f, -0.01146463f, -0.09147653f, 0.06458819f, 0.02920149f, 0.00331074f, -0.00402278f, 0.03502845f, 
    -0.05788698f, 0.12963390f, 0.07631312f, -0.09168253f, -0.20975916f, -0.08678818f, -0.08417923f, -0.07645201f, 
    -0.00400591f, 0.00455963f, -0.05133570f, -0.02886926f, -0.04833059f, 0.00535252f, 0.05541116f, 0.09724475f, 
    0.00945575f, 0.13707797f, 0.10422269f, 0.10102387f, -0.18485007f, -0.16907160f, -0.09735536f, 0.07618287f, 
    -0.05030292f, -0.03062480f, 0.00500746f, -0.04008069f, 0.00582371f, 0.02244635f, -0.04166051f, -0.07449427f, 
    -0.14511527f, -0.11978178f, -0.01663886f, -0.00912843f, 0.06858868f, 0.01209832f, -0.05096573f, -0.04266708f, 
    0.15595806f, 0.17857455f, 0.06345870f, -0.19712251f, -0.00666002f, -0.06780484f, 0.05287375f, -0.00013624f, 
    0.04936256f, -0.02979404f, -0.01325503f, -0.02594524f, -0.05007446f, -0.03096028f, -0.05720556f, -0.03722445f, 
    -0.04424730f, -0.02317408f, 0.06149982f, 0.01491380f, 0.03141634f, -0.03869569f, -0.54424500f, 0.13132589f, 
    -0.01336841f, -0.00584417f, -0.10491592f, -0.07540742f, -0.09139793f, 0.03468907f, -0.14004545f, 0.01285305f, 
    -0.10274503f, -0.01505145f, -0.08070985f, -0.04954408f, -0.01702544f, 0.03948414f, -0.07091513f, 0.13380049f, 
    -0.21721292f, -0.11803430f, 0.00056069f, -0.08461915f, -0.06566803f, 0.06333419f, -0.02816711f, -0.02215418f, 
    0.03386790f, 0.05786092f, 0.05856809f, 0.05404622f, -0.00451710f, 0.06281267f, 0.05462456f, 0.04291380f, 
    0.00448861f, -0.11133458f, -0.01610122f, -0.07619511f, 0.59301192f, 0.11767861f, -0.27889091f, -0.37624276f, 
    0.01941544f, -0.21395966f, -0.05774563f, 0.11423092f, -0.02896031f, -0.01832063f, -0.00155249f, -0.01158551f, 
    -0.05496347f, 0.00485261f, -0.04196605f, -0.05439926f, 0.07770760f, 0.05817138f, -0.01162441f, -0.04056327f, 
    0.24365166f, 0.25472212f, 0.08168206f, -0.38078460f, -0.08177792f, 0.12659158f, 0.10665800f, -0.06401478f, 
    0.06440458f, 0.09445959f, 0.03917894f, -0.03152723f, 0.03275860f, 0.00051098f, -0.02439088f, 0.02518688f, 
    -0.04526606f, -0.00119058f, 0.01261921f, 0.01944499f, -0.03881806f, 0.02587282f, -0.12524815f, 0.06478117f, 
    0.06536707f, 0.03968241f, 0.01080046f, -0.00264035f, -0.01310085f, 0.02837671f, -0.04705606f, -0.05346841f, 
    -0.02734321f, -0.04378022f, -0.03038527f, -0.05835170f, 0.00311364f, -0.06476672f, -0.03893153f, -0.01186786f, 
    -0.22371139f, 0.12793772f, -0.18961185f, -0.02820951f, -0.16047624f, -0.17196825f, -0.04673569f, -0.02054595f, 
    -0.03045353f, 0.01227797f, -0.07368035f, 0.02363337f, -0.03446153f, -0.10480712f, -0.03381986f, -0.10195660f, 
    0.06520043f, -0.03545294f, -0.19146240f, 0.01447510f, -0.14091259f, -0.10852390f, -0.13765645f, 0.07711612f, 
    0.04674620f, 0.02383819f, -0.00237608f, -0.02963786f, -0.03496092f, -0.05273739f, -0.10707467f, -0.09680431f, 
    -0.12695551f, -0.01732861f, -0.03248241f, -0.05019489f, 0.01124628f, -0.13443390f, 0.00575427f, -0.04363255f, 
    -0.09301523f, -0.10152824f, -0.06072982f, -0.02064526f, 0.01183418f, 0.04246940f, 0.02871378f, -0.00439813f, 
    0.02316612f, 0.00505510f, 0.00371466f, 0.01360129f, -0.03194072f, 0.03919827f, 0.02144901f, -0.06854907f, 
    -0.13561434f, -0.00476986f, 0.01177825f, 0.00463445f, 0.03930103f, 0.23222822f, 0.06126375f, -0.10808562f, 
    -0.06351452f, -0.10871568f, 0.07592519f, -0.01297756f, 0.09919688f, -0.00997494f, 0.01048717f, -0.01249816f, 
    -0.00270416f, -0.10829227f, -0.09874500f, -0.10155656f, 0.01626314f, -0.04831558f, -0.05529675f, 0.10691797f, 
    -0.17288262f, -0.15036450f, -0.09508776f, 0.07874671f, -0.01039632f, 0.02804366f, -0.00801008f, 0.00434396f, 
    -0.05144522f, 0.04223920f, -0.08505475f, -0.07121284f, -0.05337050f, -0.07466371f, -0.11806762f, -0.10141107f, 
    0.03379146f, -0.17436938f, -0.05180895f, 0.02475887f, 0.18855488f, 0.26287496f, -0.12540580f, -0.04326280f, 
    -0.06547415f, -0.00746269f, -0.24876177f, -0.02354326f, -0.15256736f, 0.05323478f, -0.15957563f, 0.13963830f, 
    0.00507840f, -0.01031759f, -0.02488423f, -0.03679054f, -0.05314381f, -0.02168586f, -0.16135196f, 0.04408220f, 
    0.20909728f, 0.07962038f, -0.13971700f, -0.05990133f, -0.03215431f, 0.08282081f, -0.00012097f, 0.17708336f, 
    -0.20381521f, 0.06261060f, -0.00362270f, 0.03290055f, -0.00009974f, 0.03015829f, -0.04250033f, 0.00811810f, 
    0.03534847f, -0.04472523f, -0.03411307f, 0.03175460f, -0.63599026f, -0.50756150f, 0.38654569f, 0.10170896f, 
    -0.07741847f, -0.10564218f, -0.03069397f, -0.02189043f, 0.03762475f, -0.00667207f, -0.04833172f, 0.01699666f, 
    -0.05205460f, -0.02128402f, -0.01477372f, -0.13934019f, 0.00960261f, -0.01389468f, -0.16182037f, -0.14071690f, 
    0.40943009f, 0.40597388f, 0.01937230f, -0.44462717f, 0.00413181f, -0.02303273f, 0.02185778f, -0.02178409f, 
    -0.01829002f, 0.08453098f, 0.06306080f, -0.07420822f, 0.05330124f, 0.01493619f, 0.00009268f, 0.00845653f, 
    -0.03111321f, -0.02473647f, 0.06160038f, 0.04931084f, 0.22879699f, -0.08585010f, -0.31380439f, 0.04575067f, 
    0.06747228f, 0.12607458f, 0.08083245f, 0.09975207f, -0.15834771f, -0.00864610f, -0.05146161f, -0.04733194f, 
    -0.08656707f, 0.04440461f, 0.00641292f, 0.02891395f, 0.08063577f, 0.00808190f, 0.00578947f, 0.01894149f, 
    -0.06681067f, -0.26993835f, -0.06759257f, -0.16742977f, -0.02951437f, 0.00209757f, -0.04475654f, -0.00858625f, 
    -0.02261725f, 0.02240320f, -0.01686036f, -0.03047757f, -0.03113573f, 0.08410460f, 0.04068126f, -0.08531453f, 
    -0.10892781f, -0.04885443f, -0.04871616f, 0.00540531f, -0.08957563f, -0.08177029f, -0.00610217f, -0.00482204f, 
    0.01194578f, -0.01630648f, 0.02742709f, 0.00677584f, 0.02102086f, 0.01698935f, -0.03835661f, -0.00747530f, 
    -0.00310603f, -0.00532361f, -0.04822435f, -0.01817626f, -0.07026760f, 0.00876381f, -0.01515262f, -0.03179010f, 
    -0.04085198f, -0.04780307f, -0.09754379f, 0.07067511f, 0.03559472f, 0.00100130f, -0.00894520f, 0.01375354f, 
    0.06405114f, -0.00592768f, -0.11405149f, -0.02962732f, -0.17768204f, -0.13768931f, -0.06321890f, -0.02095985f, 
    -0.00919625f, -0.03919661f, 0.01335227f, -0.08665978f, 0.38062814f, 0.21469043f, 0.05648489f, -0.05167531f, 
    0.05688902f, 0.17731887f, 0.12579753f, 0.15816234f, -0.16345182f, -0.20623900f, -0.08186053f, -0.04273004f, 
    0.03040185f, 0.03350216f, 0.05917077f, -0.02962520f, -0.02692153f, 0.00358977f, 0.01950836f, 0.00969337f, 
    0.04572715f, 0.17042169f, 0.13931927f, -0.06267834f, 0.02395456f, -0.08940709f, -0.01263543f, 0.07954475f, 
    0.10899659f, -0.07817178f, -0.03665709f, -0.07425073f, -0.05827647f, -0.02225056f, -0.04525698f, -0.00038042f, 
    -0.06266113f, -0.01076731f, -0.06080094f, -0.02332280f, -0.11294948f, -0.14347206f, -0.15842302f, -0.14988250f, 
    -0.14413916f, 0.00394846f, 0.02877384f, 0.00076853f, 0.04140347f, 0.02763027f, 0.05288701f, 0.04963563f, 
    0.05867545f, 0.01224432f, 0.00580861f, -0.02356627f, -0.05217968f, -0.04386659f, 0.00736482f, 0.00066681f, 
    -0.52706134f, -0.26720405f, -0.16545391f, 0.09319451f, -0.06772242f, 0.05403854f, 0.01760089f, 0.01709639f, 
    -0.01977953f, 0.02442141f, -0.04562959f, -0.02981652f, -0.03370837f, 0.00847861f, 0.04603790f, 0.00414030f, 
    -0.07429997f, -0.13057189f, 0.00657247f, -0.12265100f, 0.26203451f, -0.31698561f, -0.64100802f, 0.09393489f, 
    -0.03657757f, 0.05295494f, 0.00059280f, 0.04050406f, -0.08128379f, 0.04466223f, 0.00226647f, 0.05163822f, 
    -0.07645392f, 0.00687284f, -0.00031719f, 0.00933515f, 0.08041053f, -0.01103411f, 0.00624313f, 0.01514048f, 
    0.22497086f, 0.04703952f, -0.03784645f, -0.12333849f, -0.06158515f, 0.00391799f, 0.07679112f, 0.04993282f, 
    0.02002151f, 0.00349034f, -0.00802348f, 0.01506508f, 0.00644480f, 0.06139681f, 0.02955076f, 0.04066684f, 
    0.05705596f, -0.00752492f, -0.02770049f, -0.01819201f, 0.15133414f, 0.13657016f, -0.04771781f, -0.19748375f, 
    -0.18611442f, 0.01440434f, -0.00661035f, 0.06820057f, -0.03144406f, 0.05601352f, -0.01957509f, -0.00450831f, 
    0.01449789f, 0.01538799f, 0.03406683f, -0.00463315f, -0.00882756f, -0.00952976f, -0.02614774f, -0.13437036f, 
    -0.02092856f, 0.00786145f, -0.16786757f, -0.05410992f, -0.02717720f, -0.02868983f, -0.05927066f, 0.04353117f, 
    -0.10113565f, 0.10065852f, -0.04070858f, 0.01170182f, 0.01558394f, -0.09629347f, -0.06830769f, -0.09023350f, 
    -0.00032209f, 0.02030568f, -0.06367096f, 0.05206247f, -0.11971010f, -0.08577122f, -0.00176148f, 0.05340467f, 
    0.00934021f, -0.00680743f, 0.00566697f, 0.05717262f, 0.00727164f, 0.06614893f, -0.12309854f, -0.03531322f, 
    0.03463002f, -0.11844035f, -0.21572404f, -0.08318778f, 0.04670033f, 0.04007547f, -0.07595331f, 0.05444696f, 
    -0.03029842f, 0.02493475f, 0.07370476f, 0.01250022f, -0.03030141f, -0.23657660f, -0.19809972f, 0.06478970f, 
    0.00355776f, 0.02810054f, 0.01055557f, 0.07518278f, 0.01097555f, 0.00276225f, 0.03351614f, -0.02077807f, 
    0.02233653f, 0.00535653f, -0.13093832f, -0.07703701f, 0.31476367f, 0.31047001f, 0.07637147f, -0.31363988f, 
    -0.04984605f, 0.14003214f, 0.18939847f, 0.12246685f, 0.03673331f, -0.02872844f, 0.02455897f, -0.04682687f, 
    -0.00421799f, -0.01413389f, 0.02755621f, 0.00795014f, -0.05304939f, 0.03805219f, -0.03605633f, -0.02851005f, 
    0.08612208f, 0.04598239f, -0.04925046f, -0.01108058f, 0.03225066f, -0.04183995f, 0.02184981f, -0.00920407f, 
    -0.00909625f, 0.01188145f, -0.00006721f, -0.04886061f, -0.00160556f, -0.03813820f, -0.06560819f, 0.01139476f, 
    -0.04496745f, -0.11758783f, -0.06394785f, 0.03817993f, 0.16361134f, 0.07542728f, 0.31735396f, -0.16329959f, 
    0.03125649f, -0.05212518f, 0.02684798f, 0.05445034f, 0.11292027f, 0.01440129f, 0.00537135f, 0.06663270f, 
    0.07464661f, 0.07704415f, -0.09692143f, 0.07397882f, -0.06096499f, 0.07333057f, 0.01134019f, 0.00688354f, 
    -0.00650613f, 0.05376639f, 0.01903003f, 0.02870914f, -0.14346907f, -0.05474330f, -0.04827657f, -0.06895245f, 
    -0.08060510f, 0.01083126f, -0.01775771f, -0.03169766f, -0.00291133f, -0.03539212f, -0.04877951f, -0.07158440f, 
    -0.03973535f, -0.04902834f, -0.07954382f, -0.09303372f, 0.06519338f, 0.17574243f, 0.21777022f, -0.16063951f, 
    0.03820846f, -0.04077718f, 0.11910249f, 0.11729901f, 0.11198808f, 0.01145219f, 0.03298775f, -0.03143892f, 
    -0.00720766f, -0.02022587f, 0.07540959f, 0.04833082f, 0.05693794f, 0.02338019f, -0.14081980f, -0.01921670f, 
    -0.29408371f, 0.14435123f, 0.15322325f, 0.02012577f, 0.16425073f, -0.04789103f, -0.09087527f, 0.00568448f, 
    0.06204193f, 0.05088033f, 0.00660392f, -0.00081820f, 0.01959510f, -0.00551166f, 0.00794258f, 0.06948249f, 
    0.08372331f, -0.06895019f, 0.02021188f, 0.01239462f, 0.24812590f, 0.11118232f, 0.05943599f, -0.09895412f, 
    -0.06919131f, 0.09427115f, 0.11310549f, 0.11983006f, -0.04524269f, 0.05069173f, 0.00048970f, -0.00749015f, 
    -0.00575362f, -0.03874506f, -0.02075360f, -0.01567671f, -0.10096979f, 0.00098591f, -0.04597447f, 0.05541440f, 
    -0.33033395f, 0.04161984f, -0.19024344f, -0.22810389f, -0.28117874f, -0.03206743f, -0.00698656f, -0.17301244f, 
    -0.08622181f, 0.08080238f, -0.00507465f, 0.01416115f, 0.00472963f, 0.02247877f, 0.07833518f, 0.01003005f, 
    0.00275353f, -0.04897135f, -0.03564391f, 0.02743782f, -0.03671669f, -0.05625150f, 0.04402330f, 0.00220197f, 
    0.03526931f, -0.00460585f, 0.01446841f, 0.06691397f, 0.04276624f, 0.08382023f, -0.17310449f, -0.06844101f, 
    0.00178659f, 0.00055268f, -0.17254512f, 0.02808742f, -0.01624459f, 0.04288191f, -0.02648760f, -0.01322495f, 
    0.25032696f, 0.15100971f, 0.17984816f, -0.18089201f, -0.10488762f, 0.10118084f, 0.12116379f, 0.07622327f, 
    0.04316667f, 0.10283379f, 0.00575956f, 0.00813461f, 0.01607662f, -0.08439784f, -0.11860646f, -0.02889237f, 
    -0.12903477f, -0.09985795f, 0.13617389f, 0.09252242f, -0.05794281f, -0.21854810f, -0.50422293f, 0.10856254f, 
    -0.15816841f, 0.00052490f, 0.04579867f, 0.02548042f, -0.01772332f, 0.07201555f, 0.02424518f, -0.00691721f, 
    -0.12982333f, -0.06980807f, -0.10250331f, 0.04409581f, 0.03116485f, 0.01685331f, 0.04535406f, 0.00969219f, 
    0.06538983f, 0.09772639f, -0.03667647f, 0.01461336f, -0.01925698f, -0.10922596f, 0.05505476f, 0.04328721f, 
    0.05298860f, -0.00673010f, -0.10042161f, 0.10194379f, -0.11011121f, 0.01890279f, -0.13356963f, -0.05146982f, 
    0.01848412f, 0.01457798f, -0.17456649f, -0.00719837f, 0.12690559f, 0.08621061f, -0.05524294f, 0.00065964f, 
    0.01049199f, -0.14173351f, -0.01889919f, -0.15277594f, 0.05293851f, -0.03709262f, 0.04459924f, 0.02067596f, 
    0.00301294f, 0.00110641f, -0.03187709f, -0.03908938f, -0.02048606f, -0.02583329f, -0.04566780f, -0.16181673f, 
    0.08527940f, 0.24716422f, 0.00631812f, -0.32369238f, 0.00301920f, -0.02573082f, 0.00481609f, -0.06429949f, 
    -0.05458099f, 0.01203769f, 0.00686009f, -0.06640585f, -0.00990453f, 0.04840400f, -0.02927459f, -0.12571311f, 
    -0.04736674f, 0.00879137f, 0.05617055f, 0.02550630f, 0.00690623f, -0.25113863f, -0.23798536f, 0.14349416f, 
    -0.21397525f, 0.02677682f, 0.00208893f, 0.01307693f, -0.00762141f, 0.09267100f, 0.01159136f, 0.01047205f, 
    -0.01917006f, -0.01933790f, -0.01334470f, -0.10733245f, -0.02689490f, 0.08007583f, -0.04090743f, 0.08737048f, 
    0.19516549f, 0.14025113f, -0.03428368f, -0.00749340f, -0.00084496f, 0.01488510f, 0.08789309f, 0.00926460f, 
    -0.10019718f, -0.09537095f, -0.04248679f, -0.14627318f, -0.04542249f, -0.01931598f, -0.01645881f, -0.04518944f, 
    -0.04018006f, -0.08963543f, -0.00634837f, -0.02696535f, -0.27757227f, -0.26139015f, -0.32033440f, 0.15407063f, 
    -0.14535715f, -0.04885567f, -0.01571544f, -0.02385226f, 0.02811080f, 0.05172810f, -0.06081302f, -0.03002173f, 
    -0.05188785f, -0.02133347f, 0.01746166f, -0.04773019f, -0.06703460f, 0.03287062f, 0.01184417f, -0.09760412f, 
    -0.05642063f, 0.00334134f, 0.03243290f, -0.25427392f, 0.17693876f, -0.10501911f, -0.04835395f, 0.02261745f, 
    -0.11006788f, 0.07428667f, -0.08272752f, -0.00601364f, 0.07065167f, -0.02439267f, -0.05090951f, -0.07876292f, 
    -0.01987806f, -0.16303967f, -0.32230428f, -0.00971470f, 0.18068810f, 0.11332220f, 0.13225262f, -0.10604449f, 
    -0.03171824f, 0.09913871f, 0.13759468f, 0.14130224f, -0.05619895f, 0.01720117f, -0.02782918f, -0.00219386f, 
    -0.01687918f, -0.08226439f, -0.05546776f, 0.06911931f, -0.09934491f, -0.02897097f, -0.06997198f, -0.06918336f, 
    0.11423193f, 0.05101037f, 0.04529485f, 0.03293978f, -0.03766405f, 0.03122102f, 0.00590569f, 0.05177299f, 
    -0.00452113f, 0.02785261f, -0.01128964f, 0.06216480f, -0.02034956f, 0.01333881f, 0.02912526f, -0.05291376f, 
    -0.00830324f, -0.00609120f, -0.07103735f, -0.01474516f, -0.10742509f, 0.02347692f, 0.18766882f, -0.15416709f, 
    0.07228681f, -0.01637490f, -0.00726405f, 0.04436683f, -0.05861745f, -0.13971892f, -0.02877617f, -0.17125060f, 
    -0.05262913f, -0.05707959f, -0.10468557f, -0.01927433f, -0.03174184f, 0.00402114f, -0.07521439f, -0.12589706f, 
    0.21108234f, 0.16934361f, -0.12470011f, -0.26811102f, -0.19557697f, 0.06157396f, 0.01786759f, -0.12379866f, 
    -0.00387640f, 0.00261183f, 0.04393406f, 0.05536364f, 0.01927124f, 0.00225313f, 0.02369743f, -0.00079364f, 
    -0.01623348f, -0.01670219f, 0.02573276f, 0.13177346f, 0.13047147f, -0.16269869f, 0.01856314f, 0.03158069f, 
    -0.04464952f, 0.03939604f, -0.12040199f, 0.12371556f, -0.13706793f, 0.03849900f, -0.10630042f, -0.00197664f, 
    -0.14059645f, 0.03225145f, -0.05467741f, 0.04607550f, 0.07171658f, -0.00182589f, -0.02400251f, -0.08212993f, 
    -0.27104074f, -0.02268143f, 0.20549150f, -0.35547248f, 0.10363529f, -0.22220851f, -0.08027517f, 0.03533693f, 
    -0.21032093f, -0.03378777f, -0.01731449f, -0.06332060f, -0.05116928f, 0.02053444f, -0.05388682f, 0.03007877f, 
    -0.00712374f, -0.00482661f, 0.00215253f, -0.14546493f, 0.20172815f, 0.15947342f, -0.01145440f, -0.05825191f, 
    0.02190932f, 0.02526919f, 0.05889250f, 0.05841758f, -0.07154476f, -0.20347723f, -0.13476118f, -0.07886360f, 
    0.02981189f, 0.01192154f, 0.05958416f, -0.03806627f, -0.03227287f, -0.03406272f, -0.02177626f, -0.00554146f, 
    0.31039980f, 0.16552836f, 0.04829036f, -0.11613067f, -0.10785995f, 0.07639738f, 0.14583024f, 0.13987966f, 
    0.03408519f, 0.02632889f, 0.00810047f, -0.01231461f, 0.00079539f, 0.02452709f, 0.02928626f, -0.03519916f, 
    -0.02032958f, -0.08412617f, -0.08369128f, -0.02267461f, 0.22476602f, 0.15166636f, -0.03964851f, -0.24049275f, 
    0.00622496f, 0.00861016f, 0.03602077f, -0.00027599f, -0.03211060f, 0.05521311f, 0.01020744f, -0.02061225f, 
    0.02828988f, -0.11964045f, -0.11584035f, 0.01715319f, -0.10658441f, 0.03806623f, -0.03937759f, 0.14154094f, 
    -0.07571118f, -0.01811905f, -0.00651881f, -0.01872317f, 0.06351853f, 0.00750898f, 0.01249486f, 0.02632503f, 
    -0.00890666f, 0.02162817f, -0.15960701f, -0.01771930f, -0.07145707f, -0.04583053f, -0.02172280f, -0.09973126f, 
    -0.06903388f, -0.03922867f, -0.04007955f, -0.08327563f, 0.12071106f, 0.24502385f, 0.18114084f, -0.24317846f, 
    -0.21007240f, 0.09889042f, 0.08076948f, 0.08210916f, -0.12199870f, -0.05743522f, -0.01984350f, -0.02275050f, 
    -0.02621183f, 0.03751377f, -0.03304102f, -0.05722956f, -0.02493295f, 0.02214707f, 0.10149229f, -0.02820546f, 
    -0.38714975f, 0.17020892f, -0.11004173f, 0.04718170f, 0.08685023f, -0.01226563f, -0.07969765f, -0.06485582f, 
    0.04752215f, 0.03832394f, 0.04425240f, -0.02409191f, 0.01438136f, 0.06558000f, 0.02059718f, 0.08188304f, 
    0.07221013f, 0.02437096f, 0.06207274f, 0.02065847f, -0.15107943f, -0.18937877f, -0.20652261f, 0.06405447f, 
    -0.04334973f, 0.01026003f, 0.01283934f, 0.00130789f, 0.01628560f, 0.01705647f, -0.05271782f, -0.03740610f, 
    -0.02501076f, 0.06493463f, -0.02821118f, -0.05055222f, 0.01562223f, -0.05694053f, 0.00767098f, -0.02702900f, 
    -0.11718817f, -0.18309756f, 0.09695671f, 0.01649376f, 0.19764550f, -0.03087632f, -0.04281244f, 0.03474446f, 
    -0.05662023f, -0.01254593f, 0.04605395f, 0.03533016f, -0.01018641f, 0.00215391f, -0.00828531f, 0.14481029f, 
    0.03923554f, -0.08920570f, 0.11840231f, 0.15589580f, 0.70791280f, 0.14397907f, -0.14315878f, 0.08729170f, 
    -0.20459208f, -0.03909142f, 0.08266256f, -0.00999771f, -0.19174406f, 0.09082428f, 0.11200337f, -0.08382684f, 
    0.00081920f, -0.03428827f, 0.00074188f, -0.07228973f, 0.01489062f, -0.04563630f, -0.07366941f, 0.00965236f, 
    0.17580761f, 0.11414525f, -0.15167187f, -0.02868097f, -0.41883034f, 0.01394305f, -0.00216352f, -0.05322487f, 
    -0.04185240f, -0.01726216f, -0.02285695f, 0.02901791f, -0.02206229f, 0.03045171f, 0.02410426f, -0.17570141f, 
    -0.23448879f, -0.10393994f, -0.14794929f, -0.10362840f, 0.49739280f, 0.00399378f, 0.11377972f, 0.11067154f, 
    -0.08661250f, 0.04014235f, -0.01327440f, 0.02641776f, 0.01835435f, -0.01085239f, 0.02593729f, -0.06234718f, 
    -0.00327275f, -0.00288941f, -0.01142747f, -0.04954395f, 0.01375855f, 0.03722427f, 0.01191020f, -0.01054456f, 
    -0.22719821f, -0.04999372f, -0.09259071f, -0.07486436f, 0.17037137f, 0.10333609f, 0.01461149f, -0.16427170f, 
    0.10709607f, -0.04788733f, 0.05088215f, 0.04341597f, 0.05541179f, -0.04459807f, 0.00701027f, -0.10739525f, 
    -0.03525550f, 0.04971094f, -0.16828303f, -0.31540871f, 0.56817114f, 0.13643105f, -0.31640264f, 0.04287043f, 
    -0.32678607f, -0.05784419f, 0.05201562f, -0.06231544f, -0.02524256f, 0.02885605f, 0.07352430f, 0.14669238f, 
    0.11860516f, 0.06595931f, 0.11871279f, -0.00987475f, -0.06466109f, -0.00455561f, 0.05548176f, 0.11156717f, 
    0.17102391f, 0.12284921f, 0.05631215f, 0.05005609f, 0.11708099f, -0.03396328f, -0.04426367f, -0.00278049f, 
    -0.04212679f, -0.00348043f, -0.01260101f, -0.01329225f, -0.00367739f, 0.00455894f, 0.00568747f, 0.04905936f, 
    0.03691874f, -0.11074805f, -0.00045618f, -0.00073332f, -0.05136990f, -0.37661353f, 0.19442002f, 0.08475975f, 
    0.13657612f, 0.04969532f, 0.07946192f, 0.12011807f, 0.06770267f, -0.14664295f, 0.17529885f, -0.09305797f, 
    0.10916866f, -0.00006302f, -0.12782606f, 0.12982912f, -0.05463396f, 0.01941397f, -0.04897138f, -0.14102328f, 
    -0.23004928f, 0.12288403f, -0.11842338f, 0.06156383f, 0.19372016f, -0.16008188f, -0.09299793f, 0.06077756f, 
    0.04141309f, -0.08522616f, -0.00050204f, 0.02550841f, -0.00049210f, -0.01658651f, 0.04222976f, 0.00853212f, 
    0.02295037f, 0.08983297f, -0.14672315f, -0.04138499f, 0.14687851f, -0.03436805f, -0.06516805f, 0.03212147f, 
    -0.05167551f, -0.01040420f, 0.04085635f, 0.08116717f, 0.00291213f, -0.01645864f, 0.02435013f, 0.00221895f, 
    0.03385437f, 0.06302315f, 0.00281779f, -0.03704293f, 0.07489427f, -0.04967827f, 0.03077394f, -0.01509403f, 
    -0.18947902f, 0.09055793f, -0.20551799f, -0.00320823f, -0.03456857f, 0.05017669f, 0.02362213f, -0.00926705f, 
    0.06855381f, -0.12681144f, -0.05108950f, 0.02027236f, 0.01304982f, 0.01892953f, 0.02349341f, -0.15523469f, 
    -0.01712160f, -0.03481476f, 0.00832373f, -0.17300679f, 0.33723995f, -0.06090835f, 0.09138366f, 0.07393678f, 
    -0.10958342f, 0.01753387f, 0.02807786f, 0.09481155f, 0.10284363f, -0.08417399f, 0.13283077f, -0.02747080f, 
    0.14868066f, -0.13499610f, 0.01700927f, 0.01830493f, 0.01196903f, -0.04187971f, 0.00880056f, -0.00174365f, 
    0.11769793f, 0.07267734f, 0.03146870f, 0.05106943f, 0.07460339f, -0.02720261f, -0.02899984f, -0.00528102f, 
    0.01375151f, 0.00800857f, -0.01512143f, -0.00740901f, 0.04686002f, 0.03331201f, 0.01178276f, -0.02585449f, 
    -0.02253879f, -0.00259658f, 0.01843505f, -0.01288134f, -0.55568630f, -0.05110893f, -0.16850048f, 0.02173208f, 
    0.03377752f, 0.04262678f, 0.03190947f, -0.09881849f, 0.16290803f, -0.03618184f, 0.01380809f, 0.02062037f, 
    0.00215837f, 0.06762972f, 0.00564995f, -0.17385277f, 0.05260816f, 0.02104618f, -0.17351532f, -0.17308326f, 
    0.31258067f, 0.02009958f, -0.03033464f, 0.08197252f, 0.04550874f, 0.00173027f, 0.04096907f, -0.00061205f, 
    0.00604449f, -0.05508580f, -0.08325261f, 0.11025307f, 0.04538719f, 0.08083504f, 0.03295022f, 0.02075546f, 
    0.03457895f, -0.10296936f, 0.03081039f, -0.03805442f, 0.02309921f, -0.11405791f, -0.27598500f, -0.11281017f, 
    -0.20059314f, -0.19876042f, 0.13358085f, -0.12145111f, 0.05525602f, 0.05757521f, 0.19188255f, 0.02829884f, 
    -0.01179230f, 0.09657475f, 0.07911480f, -0.01106825f, -0.05970826f, -0.09005569f, 0.17444396f, 0.13409899f, 
    0.12094463f, 0.02572842f, -0.01073108f, -0.02830903f, -0.08684841f, -0.08047611f, -0.07335302f, -0.06566541f, 
    0.16410202f, -0.04280225f, 0.08457249f, -0.08833902f, 0.01218151f, -0.10138696f, -0.03746169f, 0.02981794f, 
    -0.02036786f, -0.11722265f, 0.06212907f, 0.02929500f, -0.26437011f, -0.77205658f, 0.08299714f, -0.03417970f, 
    0.15307295f, 0.04446569f, -0.02448913f, 0.01457823f, -0.08209736f, 0.07312672f, 0.04316713f, 0.08976103f, 
    0.00219322f, 0.03603324f, 0.08130040f, 0.07061592f, 0.03631071f, -0.03281442f, 0.10131080f, 0.09217926f, 
    -0.48812905f, 0.14404400f, -0.23376687f, 0.05676189f, 0.19853386f, 0.05713541f, -0.02604030f, 0.09698609f, 
    0.13922265f, -0.32773837f, -0.03186839f, -0.07048584f, 0.03163860f, -0.02240706f, -0.01530463f, -0.01488622f, 
    0.02117136f, 0.10668892f, -0.11704415f, 0.03301196f, 0.05932313f, -0.23629847f, -0.15747960f, -0.02936482f, 
    -0.17334482f, -0.04935273f, 0.02106451f, 0.07566415f, -0.04722417f, -0.03379886f, 0.03719586f, -0.07476050f, 
    -0.02008058f, -0.04917832f, -0.02889998f, 0.01872903f, -0.01916058f, -0.07411687f, -0.01142257f, 0.02224753f, 
    -0.02209129f, 0.22240046f, 0.05085428f, 0.09988275f, 0.12903142f, 0.01137037f, 0.03616974f, 0.01769658f, 
    -0.01722244f, 0.04939416f, 0.00014251f, -0.00621172f, 0.00240895f, 0.01299422f, 0.02493262f, 0.02756161f, 
    -0.00859591f, 0.07891694f, 0.03489977f, -0.14333346f, 0.05246728f, -0.01524001f, 0.05873360f, 0.08433028f, 
    0.06563263f, 0.01776989f, 0.02428626f, 0.00031984f, 0.01447792f, -0.00496576f, 0.10633174f, -0.02236490f, 
    -0.00530286f, 0.03205384f, -0.00252058f, -0.10451057f, 0.00078650f, -0.03075620f, 0.00097324f, 0.00251641f, 
    0.03233364f, 0.00560285f, 0.07571085f, 0.03452981f, -0.03135699f, -0.00326782f, -0.00628083f, 0.03000291f, 
    -0.01939901f, 0.00537061f, 0.10969884f, 0.00849532f, -0.00558413f, 0.03661575f, -0.04300676f, -0.05690242f, 
    -0.06528335f, -0.02517294f, 0.01640446f, -0.00355882f, -0.34361440f, 0.00693696f, -0.22777240f, 0.02853034f, 
    0.05161254f, -0.06357465f, 0.18393199f, 0.16191077f, -0.10750262f, -0.02416333f, -0.06939388f, 0.02120070f, 
    -0.01507249f, 0.01340862f, -0.04840810f, -0.01757964f, 0.04424586f, -0.00510356f, -0.07211052f, 0.05490331f, 
    -0.22724332f, -0.06862726f, -0.08451594f, -0.03236115f, 0.02608749f, -0.00972247f, 0.09823265f, 0.13050728f, 
    0.12327340f, 0.03509685f, 0.00214195f, 0.05155203f, 0.01748014f, -0.00976263f, 0.00392284f, -0.01434083f, 
    0.01915981f, 0.02017383f, 0.00503181f, 0.08722001f, 0.23680723f, 0.09618181f, 0.08092082f, 0.09763984f, 
    0.10647074f, -0.03407949f, 0.00103088f, 0.01712778f, -0.02584513f, 0.02765567f, -0.05018949f, 0.05326132f, 
    -0.00914309f, 0.00318909f, 0.02313764f, 0.08172431f, 0.02098128f, -0.06363824f, 0.03090985f, -0.03570360f, 
    -0.11041103f, 0.04795627f, 0.07462350f, 0.03569017f, 0.15991862f, 0.05775021f, -0.02359134f, 0.00714526f, 
    0.00131087f, -0.03092662f, -0.08643325f, 0.03691333f, 0.03854216f, 0.03614281f, -0.05647182f, -0.04553306f, 
    0.01788561f, -0.12316023f, 0.00572152f, 0.02300443f, 0.71563804f, -0.21252546f, 0.04185591f, 0.00802149f, 
    -0.26605666f, -0.00932516f, -0.03614023f, 0.00804194f, -0.02587464f, -0.03623241f, 0.19534688f, -0.28229177f, 
    -0.04543804f, -0.08038565f, -0.03097814f, 0.03655912f, -0.07598950f, -0.13707152f, -0.01273499f, -0.02925090f, 
    0.03770754f, -0.00750626f, 0.12064455f, -0.11800466f, -0.07583672f, 0.05801032f, 0.00729417f, 0.00366671f, 
    -0.10287745f, 0.00571777f, -0.03031918f, -0.02492733f, 0.02127205f, -0.07593427f, -0.07663824f, 0.08564342f, 
    0.01785240f, 0.00654894f, 0.00044589f, 0.00792012f, -0.10398359f, -0.10271051f, -0.15943131f, 0.17465252f, 
    -0.29274273f, 0.08238192f, -0.09447061f, -0.18060304f, -0.15919070f, 0.06442761f, -0.03561364f, 0.01822314f, 
    0.00667416f, 0.00681137f, 0.03341640f, 0.00307690f, 0.05864077f, 0.00346870f, -0.14778461f, -0.12482228f, 
    0.30241999f, 0.16527078f, -0.39767900f, 0.05927376f, -0.12657307f, -0.01707394f, -0.10213263f, 0.00323351f, 
    0.09086762f, 0.11125853f, 0.01604349f, 0.03785160f, -0.03671245f, 0.03625608f, 0.08252009f, -0.13556641f, 
    0.01026292f, -0.05676552f, 0.09793789f, 0.02752693f, -0.07524075f, 0.11318385f, 0.13835952f, 0.09276115f, 
    0.06106424f, -0.01749982f, -0.03392186f, -0.00390606f, -0.06604388f, 0.00184769f, 0.11642392f, -0.05915473f, 
    -0.12023737f, 0.03453816f, 0.05388276f, -0.06186176f, -0.09239951f, -0.14746700f, 0.01521796f, -0.06187242f, 
    0.03006631f, -0.02965359f, 0.02862600f, -0.06949100f, -0.00115471f, -0.01766769f, 0.06108469f, -0.18653098f, 
    -0.01030907f, 0.04768177f, -0.02797828f, -0.07790131f, 0.07811864f, 0.05369572f, 0.01568378f, -0.00576968f, 
    -0.00325753f, -0.10828516f, 0.06124770f, 0.03185477f, -0.29251412f, 0.14144948f, 0.04453075f, 0.38726091f, 
    0.07205834f, -0.04470273f, -0.03457549f, 0.11680582f, -0.31016541f, -0.08047032f, -0.01228616f, -0.01101308f, 
    0.00180903f, -0.05119720f, -0.01254840f, 0.02490900f, 0.07047671f, -0.00932445f, -0.12791491f, 0.01261220f, 
    -0.00815370f, 0.03064749f, -0.02534068f, -0.05548410f, 0.00028443f, -0.02611482f, 0.00662315f, 0.06450939f, 
    0.02199398f, -0.00603883f, 0.03734606f, 0.06111115f, -0.05259841f, 0.02903249f, -0.03129326f, -0.06301887f, 
    0.01095931f, 0.09691639f, 0.01847942f, -0.05706346f, -0.48814976f, -0.19424090f, 0.09408464f, -0.12071253f, 
    -0.12868150f, -0.03537812f, -0.00226001f, 0.05482047f, -0.01399749f, -0.05366161f, 0.09279738f, 0.03999332f, 
    -0.03553093f, -0.00450391f, 0.05362567f, 0.28874749f, -0.08324364f, -0.14433600f, 0.11799601f, -0.12287104f, 
    -0.15632647f, -0.06708613f, -0.07155935f, -0.07523697f, -0.05804385f, 0.03668462f, 0.02997074f, -0.02877844f, 
    -0.00668198f, 0.05356640f, -0.00919566f, 0.00041611f, 0.01817169f, 0.02899204f, -0.02847352f, -0.01692289f, 
    -0.10619350f, -0.21620438f, -0.06576988f, 0.06074341f, -0.80439365f, -0.14239520f, -0.05745841f, 0.00254353f, 
    -0.03885847f, 0.22388989f, -0.09591208f, -0.08938044f, -0.42917904f, -0.10758574f, -0.10010564f, 0.06524422f, 
    -0.06544568f, 0.02141915f, -0.01479054f, 0.06918861f, 0.02407637f, 0.05612152f, -0.04014245f, 0.03397688f, 
    -0.37464994f, -0.41199398f, -0.07406606f, -0.18116139f, -0.03817613f, -0.01719459f, -0.02635572f, -0.02960175f, 
    -0.08650389f, -0.02264754f, 0.01256470f, 0.00962514f, -0.02666173f, -0.00661795f, -0.01931751f, -0.17278044f, 
    -0.18068995f, -0.05860988f, -0.05595555f, -0.22013792f, 0.20356065f, 0.21965803f, 0.14842689f, 0.14887875f, 
    0.01913466f, 0.06702109f, -0.03014278f, 0.03352918f, 0.11906500f, 0.00288196f, -0.00153601f, 0.01045061f, 
    0.03030822f, -0.04265648f, 0.00382956f, -0.06023011f, -0.02291783f, -0.04539432f, -0.03293406f, 0.03959914f, 
    0.09170523f, 0.01949280f, 0.07204831f, -0.20574485f, -0.08201645f, -0.00641870f, -0.04617942f, -0.08194645f, 
    -0.10766660f, -0.01139134f, -0.02850652f, -0.03741851f, 0.02092233f, 0.07205273f, -0.02901763f, -0.07680865f, 
    0.24472328f, -0.12663218f, 0.09802041f, -0.05141107f, 0.05263229f, -0.01353221f, 0.01579221f, 0.05991569f, 
    0.02602750f, -0.04408657f, -0.03716562f, 0.03309210f, -0.02949272f, -0.03171262f, -0.01239325f, 0.05116232f, 
    -0.04872330f, 0.05571903f, 0.12412092f, -0.04664762f, -0.07680473f, -0.06153529f, -0.02578946f, -0.02160888f, 
    0.20712137f, 0.12693471f, 0.10929015f, -0.14781365f, 0.11250491f, 0.08439825f, -0.04971533f, -0.05116326f, 
    0.02020456f, 0.15228656f, -0.02398322f, 0.03593197f, 0.06081796f, -0.03201310f, 0.03779788f, -0.08209765f, 
    -0.07834293f, 0.17206201f, -0.11169256f, -0.02750568f, 0.85920084f, 0.23997316f, 0.09525882f, 0.11630847f, 
    -0.20731585f, -0.02818186f, -0.00596022f, -0.00358409f, 0.00188872f, -0.00054776f, 0.05766650f, -0.02594720f, 
    -0.15603885f, -0.12033629f, -0.09887178f, 0.04449763f, -0.00301098f, 0.07046174f, -0.05448204f, -0.02534362f, 
    -0.04657339f, -0.13443066f, 0.03969693f, 0.01086997f, -0.13641541f, -0.04050396f, 0.11338306f, -0.21358804f, 
    0.07811195f, 0.07745114f, -0.02163815f, -0.02931638f, -0.00242566f, 0.11018218f, 0.01510674f, -0.06528441f, 
    0.01072987f, -0.04444578f, 0.15070701f, -0.12764557f, -0.08844465f, -0.02417232f, -0.07504331f, -0.05529576f, 
    -0.04893632f, 0.17181544f, -0.05726067f, -0.03760881f, -0.00574348f, -0.03564705f, -0.12267344f, -0.04811306f, 
    0.10846034f, 0.06135347f, 0.03931328f, -0.04192004f, 0.01061597f, -0.02537713f, 0.02666814f, 0.00603448f, 
    -0.25563949f, -0.07464008f, -0.38090959f, -0.14196897f, -0.14788903f, 0.06499607f, -0.14838073f, -0.10536769f, 
    0.17620420f, -0.14973530f, -0.07422575f, -0.01361795f, 0.07782971f, -0.00173036f, 0.03073679f, 0.02524330f, 
    0.00350632f, -0.13556726f, -0.17438637f, -0.04037770f, 0.68746388f, 0.05829126f, 0.03147412f, 0.21043977f, 
    -0.10783624f, -0.05154321f, 0.00339830f, -0.00052561f, 0.00150506f, -0.01593883f, -0.08401067f, 0.08103176f, 
    0.00574368f, -0.00576054f, 0.06131834f, 0.14974383f, -0.11258755f, -0.07854056f, 0.03348553f, 0.07574390f, 
    -0.08530417f, -0.10440120f, -0.13346857f, -0.03348767f, -0.06298278f, 0.01649643f, 0.00629954f, 0.05786963f, 
    0.12237740f, -0.07370589f, -0.08154379f, 0.02467990f, 0.03494051f, 0.06103257f, 0.00989338f, -0.02635213f, 
    0.04575382f, 0.10143584f, -0.00259288f, 0.00417845f, 0.40097111f, 0.12620436f, 0.01484268f, 0.12141278f, 
    -0.09959626f, -0.00733787f, -0.08310442f, -0.01638168f, 0.00498077f, -0.01426346f, -0.02051444f, 0.03914310f, 
    0.00927365f, 0.00624310f, 0.03004231f, 0.06830216f, -0.08280127f, 0.13938671f, 0.12885238f, 0.02632000f, 
    0.00914872f, 0.09783209f, -0.08396279f, -0.12158684f, 0.12946416f, -0.05542470f, 0.08194464f, -0.12621821f, 
    0.10522081f, 0.00750896f, -0.09289766f, -0.04228742f, -0.04028151f, 0.19978699f, -0.02765817f, 0.06605589f, 
    -0.04882062f, -0.00367857f, -0.02494439f, -0.14296541f, 0.13422857f, 0.20738968f, 0.26238954f, 0.06824002f, 
    -0.02069313f, 0.00582531f, 0.00444708f, 0.07143487f, 0.15000662f, 0.02143480f, -0.03370656f, 0.00370129f, 
    -0.01255261f, -0.07955848f, 0.05084218f, 0.04664776f, -0.02623747f, -0.00173072f, -0.06625953f, 0.02049345f, 
    -0.17283462f, -0.16909608f, -0.01475204f, -0.01861993f, -0.00005919f, -0.00299539f, 0.03775620f, 0.02918329f, 
    0.03171715f, 0.03190152f, 0.04614957f, 0.10070628f, 0.02743242f, 0.04053972f, -0.03757691f, -0.06794862f, 
    0.00542388f, -0.01886290f, 0.01896740f, 0.03350028f, -0.30049965f, 0.07040866f, -0.06363614f, 0.03107020f, 
    -0.00191625f, -0.18079028f, 0.13885367f, 0.11295997f, -0.17810962f, 0.14353773f, 0.06312414f, 0.05832891f, 
    0.05413223f, -0.01358467f, -0.03530720f, -0.01786342f, 0.05059607f, 0.04051286f, -0.00420925f, 0.00988617f, 
    -0.14313474f, -0.01602374f, -0.10687459f, 0.12840743f, -0.00981167f, -0.05168846f, -0.02273234f, -0.01288636f, 
    0.01833093f, -0.07844990f, -0.04662522f, -0.02019438f, -0.03341652f, 0.02864927f, 0.07030597f, 0.00273453f, 
    -0.02157169f, 0.02062496f, -0.12164777f, -0.00795111f, -0.12118926f, 0.06202772f, -0.08939803f, 0.08185019f, 
    -0.06460795f, -0.07571685f, 0.09250858f, 0.03831122f, -0.19737118f, 0.10806117f, -0.04328258f, -0.08511282f, 
    -0.02328702f, -0.03132135f, -0.14045526f, -0.03172162f, 0.03719037f, 0.01822718f, -0.01862979f, 0.01808588f, 
    -0.36200941f, 0.32868537f, -0.26562622f, -0.07522534f, 0.08661916f, -0.18451242f, 0.22891124f, -0.06734124f, 
    -0.08343260f, 0.16643625f, -0.04468780f, 0.01858202f, -0.00436677f, 0.03561819f, -0.04217387f, 0.08326848f, 
    0.11251055f, 0.02018655f, -0.05051580f, 0.01483607f, -0.10986608f, -0.06672827f, -0.14211543f, 0.00368763f, 
    -0.01079046f, 0.01989620f, 0.16646607f, 0.11953938f, -0.18222450f, 0.00826897f, 0.07344390f, 0.00335138f, 
    0.01680745f, 0.00004506f, -0.01449975f, -0.01187042f, -0.00866787f, -0.00239248f, -0.00740247f, 0.06030953f, 
    0.35541198f, 0.12244685f, 0.29431069f, 0.11189241f, 0.05773908f, 0.11078069f, -0.04578186f, -0.00930478f, 
    0.03704913f, -0.12938909f, 0.05532620f, -0.01191699f, -0.01744965f, -0.08678862f, -0.01228679f, 0.03011440f, 
    -0.00523647f, -0.12780245f, -0.02534728f, 0.03129954f, 0.10964168f, 0.12070864f, -0.03385152f, 0.08910868f, 
    0.05835366f, 0.15541793f, -0.10456558f, 0.01558363f, 0.10972112f, 0.05404092f, 0.04790987f, 0.01778086f, 
    0.05339919f, -0.04638549f, 0.04639806f, -0.15388696f, -0.10235411f, -0.32978708f, -0.07072831f, -0.00330570f, 
    0.02170381f, 0.08128940f, -0.04302447f, 0.01741105f, 0.04056809f, -0.09888743f, 0.04758604f, 0.03010178f, 
    0.01969773f, 0.00750974f, 0.04641933f, -0.00739844f, 0.11767343f, -0.07473963f, -0.04231448f, -0.04350878f, 
    0.00376130f, 0.12836121f, -0.00054149f, -0.06515331f, 0.08013369f, 0.10717210f, -0.13073125f, 0.07862858f, 
    -0.37638974f, -0.10741168f, -0.01076928f, 0.05848086f, -0.15114513f, 0.09727623f, 0.02327151f, -0.02013689f, 
    0.00841936f, 0.00291138f, 0.04817639f, 0.04939830f, -0.00410489f, 0.04990936f, -0.19578575f, -0.09145724f, 
    0.20786449f, -0.01247289f, -0.11470176f, -0.03437575f, -0.11221648f, -0.04150809f, -0.03413677f, -0.07169842f, 
    -0.04375290f, -0.06404725f, -0.00572817f, 0.03238934f, 0.02635337f, 0.02903856f, 0.04223717f, -0.01086485f, 
    -0.10103443f, -0.04267772f, 0.02468978f, -0.03501289f, 0.17274204f, -0.02084703f, 0.16505705f, 0.07884983f, 
    0.01677987f, -0.02073734f, -0.01524827f, 0.02633206f, 0.00590038f, -0.04194608f, 0.03993680f, 0.06015793f, 
    0.06956184f, -0.04162327f, 0.03319943f, 0.14982294f, -0.04583537f, -0.17894408f, 0.06923234f, 0.02303506f, 
    0.03720121f, -0.00566466f, -0.25035498f, -0.09383982f, 0.04429780f, -0.00427543f, 0.03526954f, 0.01279382f, 
    0.01589974f, -0.02219683f, 0.01135527f, 0.02308870f, -0.00237874f, 0.03351430f, -0.02616640f, -0.02443901f, 
    0.05482567f, 0.04755540f, 0.10892481f, 0.00995517f, -0.27858710f, 0.35696936f, 0.15664020f, 0.17919251f, 
    -0.01554061f, -0.05748115f, 0.02885730f, -0.11416450f, -0.19222471f, 0.09508794f, 0.04928979f, 0.04799983f, 
    0.11342582f, -0.00084731f, 0.02013425f, -0.02290481f, -0.00012762f, -0.01239726f, -0.00599610f, -0.06813028f, 
    -0.03217031f, -0.05337055f, 0.17015021f, 0.03136056f, -0.23552357f, 0.00892128f, -0.01411338f, -0.01729393f, 
    -0.01029676f, 0.06831380f, 0.00787166f, 0.01615715f, -0.02339654f, -0.03373308f, -0.00671837f, 0.14236404f, 
    0.09644445f, 0.14042197f, 0.09097646f, 0.10382669f, -0.14661568f, 0.13585711f, 0.14444582f, 0.04810505f, 
    -0.03992360f, 0.02993419f, -0.08578109f, 0.01080357f, -0.03668363f, 0.11899286f, 0.01502043f, -0.05639425f, 
    0.04564891f, -0.01192628f, 0.01371276f, -0.01058099f, 0.02940921f, -0.06602995f, 0.07260966f, -0.06241030f, 
    0.26290038f, -0.03716634f, -0.17405576f, 0.05346819f, -0.06891593f, -0.09328044f, 0.06966653f, -0.07067980f, 
    0.05050138f, 0.08946881f, -0.02321365f, -0.01939697f, -0.06090042f, -0.02603773f, -0.04905823f, 0.01244836f, 
    0.00924995f, 0.03808739f, -0.07539909f, 0.06613080f, -0.29045859f, 0.22373177f, 0.02028978f, -0.16033839f, 
    -0.06936552f, -0.09193527f, -0.15420885f, -0.35817400f, -0.02046616f, -0.06842609f, -0.03645371f, -0.07506339f, 
    -0.10569533f, 0.01159095f, 0.00833394f, 0.06485599f, 0.01798739f, -0.13472377f, 0.11885852f, 0.00265238f, 
    -0.40192410f, -0.25337687f, -0.08925109f, -0.18902111f, -0.04193264f, -0.02378081f, -0.00863289f, 0.01164206f, 
    0.00338347f, 0.05082176f, 0.00332500f, -0.02256887f, -0.02117117f, -0.02130315f, 0.01974214f, -0.16384262f, 
    -0.04475933f, -0.00929845f, 0.00365327f, -0.03271572f, 0.63498122f, 0.22401364f, 0.27861109f, 0.35162228f, 
    0.25414532f, 0.01253852f, -0.07786430f, -0.04738720f, 0.05464346f, -0.12632880f, -0.03281156f, 0.01660973f, 
    0.12116934f, -0.11863916f, 0.01451524f, -0.03301658f, -0.02399895f, 0.00771753f, -0.03293686f, -0.06525902f, 
    -0.25682452f, -0.55948448f, -0.51001221f, -0.08666668f, -0.41034949f, 0.05288802f, 0.02402463f, -0.06806821f, 
    0.13888627f, 0.00093443f, -0.01289988f, 0.00062696f, 0.01312587f, -0.00637113f, -0.02513025f, 0.00785745f, 
    -0.01911086f, 0.01797115f, -0.17075890f, -0.00161142f, 0.05168275f, 0.01282453f, -0.02054049f, -0.00968486f, 
    -0.00848078f, 0.00969735f, -0.02902826f, 0.04451881f, 0.01647778f, -0.07654937f, -0.02830923f, -0.08724342f, 
    0.06847171f, 0.02951888f, 0.05213544f, 0.00362492f, -0.10657102f, -0.01557048f, 0.10703882f, -0.05004917f, 
    0.17700440f, -0.05924603f, 0.02553845f, 0.05554902f, -0.04595511f, 0.05400136f, -0.04577519f, -0.02315965f, 
    -0.01182876f, 0.02645711f, 0.00964427f, 0.06394148f, 0.02553389f, 0.01167988f, 0.06368589f, 0.08491898f, 
    -0.00077563f, -0.08530349f, 0.14198568f, 0.08749620f, -0.14147231f, 0.08405015f, 0.13569449f, -0.00987118f, 
    -0.08887320f, -0.03280637f, -0.02362680f, 0.04624488f, -0.02146586f, 0.00864425f, -0.02511789f, -0.00994770f, 
    0.07081575f, -0.05687040f, -0.01742350f, -0.03427387f, 0.01913781f, -0.04073560f, 0.03493959f, -0.05469109f, 
    -0.07426900f, -0.11611646f, 0.01777851f, -0.09809107f, 0.03244679f, 0.02247366f, 0.00300015f, -0.02142028f, 
    -0.01538632f, 0.02039689f, 0.04427725f, -0.00267116f, -0.02505423f, 0.07327378f, 0.00165648f, -0.03061084f, 
    0.01079238f, 0.06305972f, 0.02360009f, -0.04311916f, 0.37466460f, 0.06293758f, -0.16343026f, 0.23264161f, 
    -0.00746504f, -0.01197092f, 0.11219613f, -0.07504883f, 0.05540536f, -0.02902757f, -0.05965942f, 0.02085236f, 
    -0.03125091f, 0.02908916f, 0.03823585f, 0.04170472f, 0.04306737f, 0.04886744f, 0.06455129f, 0.02702965f, 
    -0.09793877f, 0.02801964f, -0.06508726f, -0.07979954f, 0.00524106f, 0.04637584f, -0.05566700f, -0.01720303f, 
    0.02767833f, 0.01900956f, -0.04026203f, -0.08131315f, 0.06222614f, -0.02305319f, 0.05071675f, 0.01868279f, 
    -0.02703018f, -0.03360506f, 0.09902590f, -0.02589580f, -0.15379985f, -0.15063100f, -0.11440786f, -0.12458675f, 
    -0.05949702f, -0.00482321f, 0.02474144f, -0.19743407f, 0.02980190f, -0.16275682f, 0.02359587f, -0.06533311f, 
    0.05385273f, -0.00819883f, 0.04235589f, 0.02741296f, 0.01666244f, -0.13194381f, 0.19918031f, -0.04456969f, 
    0.03153013f, -0.28325903f, 0.37459490f, 0.18778406f, 0.04430230f, 0.00940076f, -0.12392893f, 0.00561576f, 
    0.11476400f, -0.09485972f, 0.02612625f, -0.00495875f, 0.02494432f, 0.01453299f, -0.00415684f, 0.02038953f, 
    -0.01863067f, 0.02410377f, 0.04538288f, -0.05996684f, 0.18001662f, -0.13190989f, -0.22823600f, -0.09998443f, 
    0.12364553f, 0.10187745f, 0.01026903f, -0.03273429f, -0.07835927f, 0.02484989f, 0.03020709f, 0.05159893f, 
    -0.02798502f, 0.06227983f, -0.07645080f, 0.14328724f, 0.01696027f, 0.00619586f, 0.13445145f, 0.09185176f, 
    0.04344835f, -0.40452287f, -0.22868098f, 0.09745979f, -0.17671587f, 0.12109210f, -0.02982851f, -0.13192487f, 
    0.01483520f, -0.00116263f, -0.01343175f, 0.04976755f, -0.00658778f, -0.03598339f, -0.05415939f, -0.04619811f, 
    -0.00594435f, 0.07111625f, -0.04932037f, -0.20729074f, -0.00403341f, 0.01135247f, 0.42153662f, 0.11008254f, 
    0.22687224f, -0.01751378f, -0.01614855f, 0.08098848f, 0.10098906f, -0.09038887f, 0.05331972f, 0.02959883f, 
    -0.02780463f, -0.02216063f, 0.08107115f, 0.02217422f, -0.00405168f, 0.00321738f, 0.01428821f, -0.03792997f, 
    0.00051825f, -0.08711937f, -0.13623105f, 0.04110489f, 0.14939219f, 0.01363121f, -0.02939256f, 0.00138052f, 
    -0.01603922f, 0.06789725f, 0.04119130f, 0.07337765f, 0.01468164f, 0.03894092f, -0.00044355f, 0.08099151f, 
    0.09040381f, 0.09428242f, 0.08317006f, -0.04122815f, 0.04254859f, -0.06187901f, -0.06635126f, -0.03025543f, 
    0.06100804f, -0.03437825f, -0.01990428f, -0.03625399f, 0.04109944f, 0.05663065f, 0.05620743f, 0.00345219f, 
    -0.04309437f, 0.06391527f, -0.01576559f, 0.02359855f, 0.03997384f, 0.04366114f, 0.03717235f, -0.00428889f, 
    -0.03166870f, 0.07516514f, 0.00185979f, -0.01661984f, 0.01563795f, 0.01215977f, 0.02259883f, 0.03887529f, 
    -0.01076232f, -0.02348511f, -0.03292192f, -0.00614669f, 0.01438428f, 0.03416392f, 0.07558137f, 0.01871250f, 
    -0.00768986f, 0.02681145f, -0.01579466f, -0.04758757f, 0.12720059f, 0.18730377f, 0.08707118f, 0.18868479f, 
    0.17571864f, -0.09361718f, -0.06465735f, 0.06222205f, 0.05849842f, -0.06644817f, 0.00068882f, 0.06801540f, 
    -0.02261157f, 0.00538713f, 0.01667593f, -0.01988709f, -0.00484553f, -0.00559952f, -0.05993682f, 0.00204764f, 
    0.10405239f, 0.04252066f, -0.12459029f, 0.06809694f, 0.10869626f, -0.03405328f, 0.04197826f, -0.04172352f, 
    -0.07588869f, -0.01156894f, -0.03036233f, 0.00131342f, 0.05470914f, 0.02664889f, -0.01063849f, 0.00582546f, 
    0.01685714f, 0.03335671f, -0.05365375f, 0.02620451f, -0.09887069f, -0.16002874f, -0.08465933f, -0.32005787f, 
    -0.01043741f, 0.00827696f, 0.00720312f, 0.02214500f, -0.00029911f, 0.02507012f, -0.00887142f, -0.00755123f, 
    0.01901793f, 0.07068676f, 0.00391953f, 0.03613347f, -0.03405077f, -0.03542646f, 0.07617493f, -0.02724087f, 
    0.16152340f, -0.22131984f, 0.02198632f, -0.06898282f, -0.03033570f, 0.01344603f, -0.04027016f, -0.04176096f, 
    0.01158310f, -0.01972213f, 0.09429412f, -0.00150899f, 0.05544361f, -0.01451631f, 0.11642966f, -0.00746629f, 
    0.08463982f, -0.06889175f, 0.10669231f, -0.01239648f, -0.14086325f, 0.12359065f, 0.59062684f, -0.05387900f, 
    0.14884049f, -0.03593861f, -0.07698268f, -0.01778938f, -0.06662262f, 0.07459913f, 0.03498792f, 0.00531331f, 
    0.02196606f, -0.09374500f, 0.06410153f, 0.01634463f, 0.01625621f, 0.03284543f, 0.07151939f, -0.07380238f, 
    -0.05558876f, 0.05431534f, 0.26309404f, 0.09181521f, 0.29199097f, 0.00867973f, 0.00590663f, -0.06376734f, 
    0.11242092f, 0.03736640f, -0.01214708f, 0.04570981f, 0.07120553f, -0.03413310f, 0.09533368f, 0.03649921f, 
    0.00155047f, -0.05035362f, -0.01062321f, 0.05029809f, -0.28775761f, -0.35699850f, -0.02324778f, -0.09608699f, 
    -0.23673506f, 0.21004599f, -0.00033704f, 0.02759946f, -0.01531172f, -0.14714971f, -0.00463408f, 0.03507362f, 
    -0.01511600f, -0.03805329f, -0.05372172f, -0.03606212f, -0.03161931f, -0.01250526f, 0.02086097f, 0.04785027f, 
    -0.15656716f, 0.28267032f, 0.05290923f, -0.00321400f, -0.22358456f, 0.07532572f, -0.05045310f, -0.02210401f, 
    0.11821690f, -0.08852343f, -0.04293646f, 0.03161989f, -0.08743899f, -0.04748337f, 0.01919332f, 0.07772924f, 
    0.01232422f, 0.12097359f, 0.15821646f, -0.03305805f, 0.27126235f, -0.29531229f, -0.09889525f, -0.09669926f, 
    0.02226953f, -0.00843356f, -0.02057008f, -0.02722771f, -0.03655148f, 0.00417267f, -0.03352155f, -0.25332680f, 
    0.01446573f, 0.03369062f, 0.10806720f, 0.04269911f, 0.07774071f, -0.05261246f, 0.10506722f, 0.00398282f, 
    -0.13876170f, -0.03266926f, 0.06936771f, -0.05048768f, 0.05202820f, -0.08471448f, -0.06268522f, -0.38430005f, 
    -0.06539544f, 0.04024529f, -0.04764921f, -0.06132903f, 0.00925505f, 0.00113502f, -0.06222508f, 0.01598909f, 
    -0.06508715f, -0.06182800f, 0.00064020f, 0.00990535f, -0.26454586f, -0.54730231f, -0.51456630f, 0.21183255f, 
    -0.52904952f, -0.05262676f, -0.14574575f, -0.05936646f, -0.08536019f, -0.06242159f, -0.03576284f, -0.00065390f, 
    -0.01023053f, -0.03335136f, -0.03558085f, -0.02502556f, 0.00580792f, 0.00222566f, -0.11236679f, -0.03528631f, 
    0.05212711f, -0.02364014f, -0.01404772f, -0.03634690f, 0.07410544f, -0.00792888f, -0.06140757f, -0.04267050f, 
    0.06176352f, 0.00947074f, -0.03966595f, -0.14832699f, -0.00668912f, -0.02728513f, -0.00854137f, 0.04533436f, 
    -0.07392173f, -0.11850395f, 0.01441140f, -0.03829869f, -0.14403009f, -0.14805640f, -0.00133260f, 0.17827453f, 
    0.13856608f, -0.02171469f, 0.02943136f, -0.04934591f, -0.04488406f, -0.04788495f, -0.01867640f, -0.01873720f, 
    -0.00019905f, 0.03509922f, -0.03502277f, -0.01092276f, 0.05534098f, 0.07935973f, -0.13177599f, 0.03493712f, 
    0.26564401f, -0.23421027f, 0.04980883f, -0.03043712f, -0.00367598f, 0.03199031f, -0.06208510f, 0.04122068f, 
    0.02842813f, 0.00515285f, 0.02440334f, -0.02007480f, -0.01043852f, -0.09516691f, 0.02779996f, 0.06220163f, 
    0.05961581f, -0.10709306f, 0.12080413f, 0.01084134f, -0.09709532f, 0.42032477f, -0.17183460f, 0.13051139f, 
    0.17032751f, -0.04603351f, -0.04065793f, 0.01791571f, -0.09120464f, 0.02563264f, -0.07385628f, -0.02777226f, 
    0.03988705f, 0.04725559f, 0.02670833f, 0.00308930f, 0.02112841f, -0.01342221f, 0.03658732f, 0.11512862f, 
    0.08068305f, 0.19309708f, -0.06081424f, 0.08336195f, 0.08221509f, -0.01241028f, 0.02010870f, 0.00190034f, 
    0.03458296f, -0.01212659f, 0.01503219f, 0.00798701f, 0.00544537f, -0.01561957f, -0.04291309f, 0.00303804f, 
    0.13836133f, 0.03752770f, 0.06476068f, 0.02710417f, -0.13965888f, -0.19230457f, 0.23714942f, 0.23475207f, 
    -0.15682569f, -0.03477622f, -0.01700697f, -0.01474187f, 0.09278888f, -0.02371581f, 0.02162580f, -0.00179773f, 
    -0.00361725f, 0.01762243f, -0.03014313f, 0.00507006f, 0.01244703f, 0.01117875f, -0.00093270f, 0.04198168f, 
    -0.58493972f, -0.36104575f, 0.31256071f, -0.28406224f, -0.18949179f, -0.14260745f, 0.06624501f, -0.10638276f, 
    -0.03698521f, 0.09898993f, 0.01417992f, -0.00523999f, -0.03629201f, 0.09435553f, 0.00828002f, -0.02159615f, 
    -0.10992824f, -0.11048017f, -0.05668641f, -0.03476153f, -0.08357578f, -0.26734504f, -0.06341667f, -0.02313366f, 
    0.07911932f, 0.03117480f, 0.03398886f, 0.05135897f, 0.04151176f, -0.02857512f, -0.18904021f, -0.08045957f, 
    -0.11208767f, 0.02066848f, -0.07789695f, 0.02488017f, -0.00006023f, 0.03695900f, 0.01606913f, 0.00460619f, 
    -0.59342855f, -0.64139354f, -0.27445772f, -0.05131245f, -0.46301115f, -0.01604124f, -0.03241447f, -0.05831131f, 
    -0.01844699f, -0.01344767f, -0.00964331f, -0.05001913f, 0.00381408f, -0.00746134f, -0.03029073f, -0.05279686f, 
    -0.01894869f, -0.08453101f, 0.01757611f, 0.12267643f, -0.32582551f, 0.21726605f, 0.19883083f, 0.08224827f, 
    -0.03899571f, 0.02177336f, -0.04065746f, 0.01799343f, -0.07146759f, 0.11858440f, 0.08797151f, 0.01322508f, 
    -0.11901908f, 0.06218470f, 0.04607290f, 0.00271235f, 0.05202840f, -0.01145578f, 0.09298739f, -0.09542310f, 
    0.23341700f, -0.06671888f, 0.03064783f, -0.12499819f, 0.06965077f, 0.07196280f, -0.09216345f, -0.19765301f, 
    -0.03481388f, 0.07550503f, -0.06671753f, -0.13719329f, 0.03523732f, 0.02358384f, -0.07213085f, 0.05893807f, 
    -0.06952872f, -0.24831393f, 0.18074815f, 0.10843145f, -0.15955019f, -0.03140764f, 0.00513096f, -0.01782820f, 
    0.06028802f, 0.05959242f, -0.11043280f, -0.27900490f, -0.18846647f, 0.03612853f, 0.00874119f, -0.01750498f, 
    0.05059031f, -0.00388094f, -0.04818873f, -0.01972743f, -0.05906168f, -0.04809224f, -0.15803885f, -0.00607019f, 
    -0.24893098f, -0.10344660f, -0.00063003f, -0.10796385f, -0.07942957f, 0.03491775f, -0.03727255f, -0.09484451f, 
    0.07135192f, -0.00753815f, 0.01794502f, 0.02509759f, -0.00188799f, -0.00301433f, -0.05231966f, -0.09461815f, 
    -0.01958667f, 0.14154969f, 0.01353863f, -0.00149158f, -0.24395831f, -0.03974468f, 0.08803891f, -0.20751409f, 
    -0.23331219f, 0.03980822f, -0.04900414f, 0.02182300f, -0.01964681f, 0.08997353f, 0.07088477f, -0.03997003f, 
    -0.07366902f, 0.00810730f, -0.04468819f, 0.10960975f, -0.01101399f, -0.12276670f, 0.13707951f, 0.02217224f, 
    0.07305658f, -0.02860929f, 0.04980946f, 0.05592830f, 0.04545847f, 0.05159196f, -0.09530534f, -0.08678777f, 
    0.10797881f, -0.17489618f, 0.01319724f, 0.04544827f, -0.03683615f, -0.00058292f, 0.02592094f, 0.04887347f, 
    -0.02996562f, -0.03337208f, 0.06270327f, -0.04488957f, -0.28920040f, 0.14577471f, 0.10214935f, -0.09900858f, 
    -0.18515468f, 0.00008663f, -0.00988996f, -0.04050742f, -0.01585267f, 0.07546593f, -0.02152368f, 0.03469838f, 
    -0.03335460f, -0.00532926f, -0.00156125f, 0.03360111f, -0.05818365f, 0.05021132f, 0.10746530f, 0.02866961f, 
    -0.27895555f, 0.24493359f, -0.24618249f, 0.01805726f, -0.11282963f, -0.18246612f, -0.14564046f, -0.34209335f, 
    0.05175504f, -0.00930787f, 0.01571138f, -0.06036379f, -0.00995007f, 0.00010838f, -0.10336952f, -0.07660916f, 
    0.01342167f, 0.04376932f, -0.13350771f, -0.05309539f, -0.19525921f, -0.00772400f, 0.23231922f, 0.21870960f, 
    0.10554940f, -0.00708687f, -0.01269966f, 0.01009903f, 0.01862968f, -0.01003176f, -0.01783384f, -0.01383460f, 
    0.02273770f, 0.01230281f, 0.01759114f, -0.04531584f, 0.00787038f, -0.03883741f, -0.03394742f, 0.00040212f, 
    0.11668636f, 0.00037678f, -0.05219965f, 0.10380609f, 0.07743545f, 0.03553776f, 0.00632794f, -0.00154482f, 
    -0.03179989f, -0.13777354f, -0.07640433f, -0.07629760f, 0.02876499f, 0.04874145f, 0.05295275f, 0.00015283f, 
    -0.04851330f, -0.00836827f, 0.00353670f, -0.05008992f, 0.05307366f, 0.06600852f, -0.23358573f, 0.12232256f, 
    0.15636726f, -0.18027705f, -0.00087084f, 0.02459178f, -0.16139790f, -0.03584692f, -0.07125806f, 0.01814389f, 
    0.09036463f, -0.02682179f, -0.06317050f, -0.03954049f, -0.02665328f, 0.04621847f, -0.07328378f, -0.00275186f, 
    -0.16261871f, -0.08387771f, -0.16235366f, 0.05654332f, -0.28629112f, 0.09296402f, 0.07789279f, -0.01389080f, 
    0.01235412f, -0.11041010f, -0.01974723f, 0.07175220f, -0.07736969f, 0.05125352f, -0.01220526f, 0.04543201f, 
    0.02363415f, -0.03028225f, -0.00880560f, 0.00860348f, 0.19009465f, 0.14473848f, 0.17414200f, 0.01580153f, 
    0.21966954f, -0.08297448f, 0.09658285f, -0.01355094f, -0.07210869f, 0.08649100f, 0.06118106f, 0.11718496f, 
    0.07512358f, -0.01451526f, 0.04082232f, 0.03584639f, -0.00469127f, -0.01370262f, 0.06437153f, 0.04207928f, 
    0.09583766f, 0.16819790f, -0.33887595f, 0.19156899f, -0.05717895f, -0.24558379f, 0.04147309f, -0.03121047f, 
    -0.07367034f, 0.07711606f, 0.02446750f, -0.01203249f, 0.01470454f, -0.00549000f, -0.04143637f, -0.00663663f, 
    0.01385181f, -0.00798626f, 0.01010593f, 0.07733319f, 0.04309639f, 0.08906952f, -0.05799372f, 0.10116950f, 
    0.11747672f, -0.07976186f, 0.04149624f, 0.01739617f, -0.06224173f, -0.04741605f, 0.06485088f, 0.11280924f, 
    0.05107207f, 0.02778044f, 0.04569222f, 0.01156952f, 0.01133545f, -0.04084100f, 0.01556084f, -0.06757513f, 
    -0.15587823f, -0.40690035f, 0.41519275f, 0.34213510f, 0.03020318f, -0.06402850f, -0.03573133f, -0.07844923f, 
    0.14813273f, -0.06490435f, -0.02508080f, -0.03318255f, 0.00185021f, -0.00905352f, -0.00466240f, -0.02190020f, 
    -0.02008782f, -0.02510593f, -0.02048663f, -0.01242789f, -0.10041404f, 0.00460466f, 0.12386341f, 0.21679267f, 
    -0.05349248f, 0.00531012f, -0.00691174f, -0.07160637f, 0.09990574f, -0.06832448f, 0.02098568f, 0.01288342f, 
    -0.04530907f, -0.02101140f, 0.05158495f, -0.03789024f, 0.07985627f, 0.12122512f, 0.00540566f, 0.00071262f, 
    0.00507407f, -0.00331769f, 0.00889565f, -0.04787669f, 0.04794087f, -0.01485769f, -0.05346331f, 0.00932120f, 
    0.01321007f, 0.02415484f, -0.05099168f, -0.00194286f, 0.08395079f, 0.05784336f, 0.03555776f, 0.02874624f, 
    -0.03683694f, -0.03240534f, 0.02144770f, 0.03045938f, -0.24062526f, -0.17243868f, -0.39176181f, 0.09015703f, 
    -0.41580108f, -0.12617199f, 0.07859404f, 0.06211509f, -0.23622330f, 0.13134900f, 0.00091296f, -0.01737550f, 
    0.02166895f, -0.05631499f, -0.04580745f, -0.03464462f, 0.05129454f, -0.13559449f, -0.02647945f, 0.04064703f, 
    -0.32935032f, 0.12481115f, 0.22625062f, -0.35119289f, 0.21219940f, 0.03485080f, -0.01854157f, -0.03140575f, 
    0.03252363f, 0.00403866f, 0.00058205f, 0.01015728f, 0.04869398f, -0.02104031f, 0.02332799f, 0.01145318f, 
    0.14980988f, -0.01015489f, 0.03559218f, 0.00275364f, -0.04289132f, -0.10891092f, 0.05605324f, -0.08885583f, 
    -0.01001665f, 0.03695696f, -0.05553487f, 0.03350833f, -0.00062806f, 0.01835961f, 0.00038243f, -0.01145672f, 
    -0.03211685f, -0.06894586f, 0.00031913f, -0.02394213f, 0.06884509f, 0.04144123f, 0.08756211f, -0.06871305f, 
    0.51083070f, 0.12863518f, -0.00152501f, -0.14539893f, -0.38426080f, -0.09531306f, -0.00819583f, -0.04946204f, 
    -0.00787265f, -0.00724308f, -0.01994652f, -0.01977920f, 0.09665134f, 0.01441327f, -0.04412359f, 0.08159283f, 
    -0.02137657f, -0.09347507f, 0.02983007f, 0.05404057f, -0.31381935f, 0.04254790f, 0.23302010f, 0.19230920f, 
    0.38263404f, -0.03164799f, -0.08174958f, 0.02177413f, -0.18788518f, -0.13310400f, -0.07560699f, -0.00774004f, 
    -0.03233432f, 0.09027547f, 0.00493641f, 0.05107239f, 0.06381048f, 0.06250933f, -0.08236402f, -0.07103530f, 
    -0.04419824f, -0.15360700f, -0.02999396f, 0.14109294f, 0.18558969f, -0.04300543f, 0.06461322f, -0.05599146f, 
    0.05472398f, 0.01128791f, 0.01723639f, 0.01009343f, -0.02442765f, -0.05008676f, -0.03942878f, 0.03114603f, 
    0.01278054f, -0.04005143f, 0.03447338f, 0.01758359f, 0.09646101f, 0.18067417f, -0.04516662f, 0.12997809f, 
    -0.02413842f, 0.02628326f, -0.09024322f, -0.02696335f, -0.00510596f, -0.08943538f, -0.05348655f, -0.02590217f, 
    -0.07257342f, -0.04718495f, -0.05559262f, -0.07885092f, -0.05510736f, -0.00203106f, -0.01627201f, -0.01245050f, 
    0.16854581f, 0.14376090f, -0.09172421f, -0.17501709f, 0.17033783f, 0.00364691f, 0.05979532f, -0.00723317f, 
    -0.00882173f, 0.05164110f, -0.08939116f, 0.01413410f, -0.03008262f, 0.05918046f, -0.00191116f, -0.02943656f, 
    -0.01241376f, 0.00773832f, -0.06306741f, 0.00936901f, -0.69280952f, 0.20470804f, 0.08448615f, 0.32271191f, 
    0.33530027f, -0.05705568f, -0.10530043f, 0.01481328f, -0.20651020f, -0.01791873f, -0.01624532f, 0.13514851f, 
    0.12794520f, 0.14348854f, -0.13509636f, 0.10497519f, 0.10957085f, 0.03739881f, -0.07276638f, -0.04471793f, 
    -0.61636955f, -0.24420626f, 0.02912940f, -0.16008414f, -0.10282405f, -0.08584748f, -0.07366948f, -0.18798672f, 
    0.03190568f, -0.03860101f, 0.14649926f, 0.11347672f, 0.15994492f, 0.00681370f, 0.02866626f, 0.05130883f, 
    0.05941686f, -0.01618903f, -0.10093545f, -0.11042108f, -0.69032162f, 0.74323410f, 0.18529861f, -0.31064713f, 
    0.12322126f, 0.23786762f, 0.06495563f, -0.10260253f, 0.00105618f, -0.16041943f, -0.26606205f, 0.01939359f, 
    -0.07710238f, -0.12203953f, 0.14761806f, -0.11207678f, 0.08854949f, -0.06730388f, 0.06763635f, -0.17572804f, 
    0.12007178f, -0.09906106f, -0.13407488f, -0.01198043f, 0.18306980f, 0.06204352f, 0.05856848f, 0.01681855f, 
    0.05797491f, 0.05743454f, -0.01245118f, -0.04738210f, -0.01854568f, -0.06592862f, -0.06489606f, -0.04568648f, 
    -0.03944933f, 0.01447416f, -0.09893155f, 0.03345399f, -0.22387958f, 0.07713263f, -0.13199185f, -0.02840162f, 
    -0.01831834f, 0.10719693f, -0.11623515f, 0.06753556f, -0.00660977f, -0.03603863f, 0.05421087f, 0.02495305f, 
    -0.12971805f, -0.07035332f, -0.05891981f, -0.00642262f, -0.07152497f, -0.04187147f, -0.02207188f, -0.18019877f, 
    0.02881622f, -0.11499193f, 0.13523144f, -0.10925446f, 0.02610368f, 0.00032191f, -0.03969077f, -0.01393475f, 
    0.01773004f, -0.10087675f, 0.04495793f, -0.03792356f, -0.01092891f, 0.02991049f, -0.01366618f, -0.01947708f, 
    -0.10901228f, 0.12238065f, -0.00566535f, 0.01589249f, -0.12414288f, 0.09763171f, -0.20942011f, 0.12940593f, 
    0.07635316f, 0.07849011f, -0.03926083f, -0.06808465f, -0.13906543f, -0.00051792f, 0.05899792f, -0.09280153f, 
    -0.07568759f, -0.06317249f, -0.04860014f, -0.00075904f, -0.09790954f, 0.03365569f, 0.02118449f, -0.12564220f, 
    -0.38272479f, -0.20048578f, -0.06391230f, -0.05348216f, -0.27557328f, -0.03173529f, 0.00265928f, -0.02888607f, 
    0.00852259f, -0.04848334f, -0.00263159f, 0.03209559f, 0.07637023f, -0.02839403f, -0.05614315f, -0.07425398f, 
    0.02696716f, 0.08637909f, -0.19272904f, -0.14602375f, 0.22222859f, 0.22919738f, -0.13837390f, -0.21532254f, 
    0.19905825f, -0.03575378f, -0.05908233f, 0.03172707f, -0.05673382f, -0.02124597f, -0.13803440f, -0.01589007f, 
    -0.10820538f, 0.10241120f, -0.07188136f, -0.04384873f, -0.01435137f, 0.10912975f, 0.06765723f, 0.10204983f, 
    -0.28285182f, 0.10493848f, -0.19132695f, -0.05956925f, -0.27172825f, 0.13362139f, -0.08490396f, 0.09510151f, 
    -0.00816226f, -0.10936549f, 0.02339680f, -0.08070619f, -0.10067917f, -0.10038141f, -0.06552364f, -0.08125909f, 
    -0.04737367f, -0.04294768f, -0.05384331f, -0.14898887f, -0.00814854f, 0.32509249f, -0.24813111f, 0.14332736f, 
    0.08835168f, -0.00131527f, -0.16914693f, 0.23402257f, 0.12285430f, 0.10637537f, -0.04047612f, -0.04307082f, 
    0.10992796f, -0.17311344f, -0.07774945f, 0.06116710f, 0.15883981f, -0.00918307f, 0.17105566f, -0.05757855f, 
    -0.02119255f, 0.05592924f, -0.17458318f, 0.09920537f, 0.23680852f, 0.07112331f, -0.03692491f, -0.05250066f, 
    -0.00072616f, -0.06134922f, -0.08062378f, 0.01766676f, 0.03625394f, 0.07493550f, 0.08943553f, -0.02253493f, 
    -0.00188966f, 0.03088235f, 0.04797782f, 0.02451496f, 0.88195652f, 0.19200495f, -0.08387025f, -0.34274101f, 
    -0.37340659f, -0.01483033f, 0.02239253f, 0.08766963f, -0.10784049f, -0.10077239f, -0.14029016f, -0.11686969f, 
    0.10029545f, -0.09510442f, -0.06768083f, -0.17659591f, 0.03237238f, -0.20343514f, -0.01690863f, 0.13565718f, 
    -0.06875344f, -0.13019846f, -0.18819028f, -0.04742745f, 0.19983295f, 0.12265234f, 0.04835866f, -0.05205053f, 
    0.12128143f, -0.03503456f, -0.03884881f, -0.02745754f, -0.21220586f, -0.03919188f, -0.06510561f, -0.00102414f, 
    0.01067038f, 0.19718963f, -0.04258576f, -0.08732687f, -0.00871960f, 0.17147766f, -0.07831985f, 0.02006433f, 
    0.18356222f, 0.15239477f, -0.03771776f, -0.00231120f, -0.07848994f, -0.04405523f, -0.16869971f, 0.02454560f, 
    0.05109619f, 0.03692952f, 0.03157204f, -0.07982785f, -0.01927968f, -0.05565125f, 0.02709382f, 0.04697272f, 
    -0.50489968f, 0.17768903f, -0.05730993f, -0.16084968f, -0.34839588f, 0.05205832f, 0.01139172f, -0.10143320f, 
    -0.04394345f, -0.07331815f, 0.01022592f, 0.04637422f, -0.09249263f, -0.05017506f, -0.13250637f, -0.11616648f, 
    -0.00306561f, 0.00756469f, 0.01736392f, -0.02406551f, -0.21290241f, -0.10030121f, -0.07543568f, -0.11185253f, 
    -0.31747401f, -0.00405866f, -0.09493654f, -0.08089219f, -0.10822733f, -0.07347652f, -0.06726512f, -0.05954239f, 
    -0.05260634f, -0.02586544f, -0.04694112f, 0.00319365f, -0.01964369f, -0.10467285f, 0.01561545f, -0.07571813f, 
    -0.21619798f, 0.00850610f, -0.05086675f, -0.00687861f, -0.09991165f, -0.02678971f, -0.08813073f, -0.10482530f, 
    -0.18497770f, -0.12245554f, -0.02591159f, -0.03849316f, -0.08457967f, -0.03626682f, -0.09552737f, 0.01137848f, 
    -0.04364152f, 0.06214264f, -0.10664523f, -0.07419757f, -0.05908201f, -0.10100906f, -0.16581437f, -0.02115816f, 
    0.28937447f, 0.06277784f, 0.01174485f, 0.05251625f, 0.01267624f, -0.04156594f, -0.05889630f, 0.06909700f, 
    0.01786621f, 0.03255895f, 0.06314155f, 0.08083154f, -0.03494115f, 0.16800104f, -0.02271584f, 0.07440402f, 
    0.21405742f, -0.03444566f, -0.05318581f, -0.22904100f, -0.02964519f, 0.01020115f, 0.03033470f, 0.01668678f, 
    -0.03603576f, -0.09264345f, 0.02847821f, 0.02594752f, -0.01323787f, -0.04177357f, -0.07628796f, 0.03204984f, 
    0.03334391f, -0.06427756f, 0.13397712f, -0.03159355f, -0.67486310f, -0.21068047f, -0.04420439f, 0.06512542f, 
    -0.26219407f, 0.07647154f, 0.02475701f, 0.04773061f, 0.12162069f, 0.01582207f, 0.01544868f, -0.04361381f, 
    0.06109166f, -0.01132916f, 0.00252710f, -0.02116066f, 0.01509553f, -0.14606477f, 0.02618268f, -0.01372883f, 
    -0.07660681f, -0.14679493f, 0.28685912f, -0.03145117f, -0.04885705f, 0.04613733f, 0.09938618f, -0.07831329f, 
    -0.09184357f, -0.03635240f, 0.07327840f, -0.03504914f, 0.08843581f, 0.01684555f, -0.07193951f, -0.05873172f, 
    -0.07513905f, 0.10841803f, -0.09047186f, -0.12134018f, 0.01387340f, 0.68411940f, -0.04311508f, 0.08750559f, 
    0.24768397f, 0.14070037f, 0.01601605f, 0.03004756f, 0.00522600f, 0.04427522f, -0.11373559f, -0.04897308f, 
    0.05640812f, 0.01772194f, 0.07850365f, -0.00089843f, -0.10462714f, -0.05752647f, 0.03503394f, 0.00236968f, 
    0.06282497f, 0.00061641f, -0.05009050f, -0.05840762f, 0.13751288f, 0.05211803f, 0.01295025f, 0.02427487f, 
    -0.08943756f, -0.07632430f, -0.08895180f, 0.03646234f, 0.08110455f, -0.00110797f, 0.08454461f, -0.10024919f, 
    0.02896887f, -0.06348030f, 0.00999926f, 0.02965126f, -0.01216646f, -0.08919936f, -0.18201660f, 0.10370896f, 
    0.25099194f, -0.01951139f, 0.00217641f, 0.04597116f, -0.03396451f, 0.10945655f, -0.00755950f, -0.04195361f, 
    -0.12388822f, -0.08177068f, -0.05869931f, -0.07881905f, -0.08436631f, 0.02916105f, -0.00695957f, -0.00367286f, 
    -0.15887636f, -0.10514716f, -0.06412753f, 0.06219507f, 0.07694416f, -0.00769019f, -0.06402322f, 0.04924224f, 
    -0.06466103f, -0.02995045f, -0.09936430f, -0.01803465f, 0.02837654f, 0.00688636f, -0.08041650f, -0.04140592f, 
    -0.12535882f, 0.02026835f, -0.02528991f, 0.06779382f, -0.62932271f, -0.32310924f, -0.32811978f, 0.13753901f, 
    -0.41528943f, 0.23922542f, 0.10525376f, -0.05263318f, -0.10051335f, 0.00490361f, -0.23334680f, -0.11943427f, 
    0.06450181f, -0.03444051f, -0.05929207f, 0.12076997f, 0.00633453f, -0.11243391f, -0.02253016f, 0.07606550f, 
    0.04247125f, 0.12192373f, 0.46575060f, -0.32413629f, 0.26731405f, -0.08529536f, 0.01129527f, -0.12309807f, 
    0.05737795f, 0.00533622f, 0.06375451f, -0.02298680f, 0.01734851f, -0.04195274f, 0.13648152f, -0.08643800f, 
    -0.03579678f, -0.13833134f, 0.04442085f, -0.09502801f, 0.04007255f, -0.14881627f, -0.28957382f, -0.07153682f, 
    0.19400896f, 0.13076946f, 0.02564751f, -0.04990794f, 0.04518209f, 0.03983246f, -0.07617211f, 0.07095971f, 
    -0.02182425f, 0.05084733f, -0.04119218f, -0.01672473f, -0.02334308f, 0.06644966f, -0.06365065f, -0.05894446f, 
    -0.20144224f, -0.08936527f, -0.34712598f, 0.04345730f, -0.08638533f, 0.05303983f, -0.00358408f, 0.10163403f, 
    0.05556526f, 0.03262959f, -0.11620249f, -0.02645216f, -0.06775626f, 0.00848773f, -0.06530881f, 0.07461011f, 
    -0.07002675f, 0.04713430f, -0.08233014f, -0.01425544f, 0.30866012f, 0.21105585f, -0.12929514f, -0.18739036f, 
    0.01297649f, 0.09213039f, 0.04760989f, 0.02868308f, 0.11284836f, 0.04446050f, -0.05677756f, -0.00197704f, 
    0.02791048f, 0.01722651f, 0.02450393f, -0.08528687f, 0.13332841f, -0.01345504f, 0.03754786f, 0.01755936f, 
    0.09522777f, -0.13332418f, -0.14403819f, 0.11340839f, 0.02370139f, 0.00632938f, 0.03057129f, -0.07715810f, 
    0.00200403f, 0.01694459f, -0.04697720f, -0.06276868f, -0.09172539f, -0.07166325f, 0.02745235f, 0.05069587f, 
    -0.03004243f, 0.02591304f, 0.07039854f, -0.10999217f, 0.53461659f, -0.15950738f, -0.24635868f, -0.01565691f, 
    0.14724050f, 0.04348555f, 0.01155353f, 0.14386696f, -0.02721522f, -0.24396406f, -0.02206174f, -0.03558907f, 
    0.07022027f, 0.05461539f, 0.01436210f, -0.11202434f, -0.07063001f, 0.05717551f, 0.03101167f, -0.09030356f, 
    0.44382006f, 0.29380968f, 0.22334006f, -0.39433473f, -0.09572685f, -0.10882618f, 0.08278639f, 0.09443775f, 
    0.04852056f, 0.16792609f, -0.02511318f, -0.01730284f, 0.15748699f, 0.09678044f, 0.07063190f, 0.06776107f, 
    -0.04165056f, -0.00595477f, 0.04994371f, 0.05882050f, -0.01226834f, 0.00935157f, -0.20604967f, -0.01871129f, 
    0.19787316f, -0.00666461f, 0.00691936f, -0.03098011f, -0.02517383f, 0.05772404f, -0.04173745f, 0.08236852f, 
    -0.04660809f, 0.05629978f, 0.05090858f, 0.00504417f, -0.01917732f, 0.10748592f, 0.01707171f, 0.05064807f, 
    -0.15714946f, -0.17162600f, 0.62093920f, -0.04896598f, 0.29282707f, -0.05448520f, -0.08459088f, -0.05312870f, 
    -0.00450554f, -0.11660106f, 0.07179754f, 0.08488765f, -0.06316884f, -0.06879272f, 0.11025517f, -0.02925736f, 
    -0.08339155f, 0.16237423f, -0.00951997f, -0.01108410f, 0.04786476f, 0.22850892f, -0.15999793f, -0.16707285f, 
    -0.30112016f, 0.43578756f, 0.11360291f, 0.08377531f, 0.05287109f, -0.06759820f, -0.27976620f, -0.09983049f, 
    -0.03489914f, -0.12389654f, 0.02957625f, 0.01448791f, 0.09977537f, -0.15531830f, 0.02218154f, 0.05005000f, 
    0.08187077f, -0.05180034f, -0.18200217f, -0.06967277f, 0.14816187f, -0.04596516f, 0.15561152f, 0.07548496f, 
    0.01441836f, 0.12510805f, -0.04826929f, -0.04072250f, 0.00670059f, -0.05748322f, -0.00247371f, 0.04915944f, 
    0.08584903f, -0.01176807f, 0.00819055f, -0.07259089f, 0.08498146f, 0.22020701f, 0.15635100f, 0.09043683f, 
    0.12742405f, 0.06994152f, 0.02661073f, 0.03870887f, 0.03390451f, -0.07288431f, -0.02747106f, -0.02488083f, 
    -0.10918666f, -0.00395377f, 0.01146797f, -0.01673233f, 0.01047714f, 0.05427004f, -0.00372319f, 0.03296508f, 
    0.08932197f, 0.29707056f, -0.10137910f, -0.38357699f, 0.31607142f, 0.08856235f, 0.15374057f, -0.09130988f, 
    0.02321019f, -0.00501308f, -0.05342951f, -0.16301784f, 0.07497524f, -0.09141096f, -0.02225990f, 0.02877416f, 
    0.02630870f, -0.22741303f, 0.08189806f, 0.10232925f, 0.00823184f, 0.03609559f, 0.12454339f, 0.00003407f, 
    0.19297120f, -0.02508273f, 0.03955201f, 0.15782565f, 0.08975174f, 0.15117523f, 0.08823828f, 0.01435244f, 
    -0.11894770f, -0.01005125f, 0.13506329f, -0.00820896f, -0.05574117f, 0.09014765f, -0.05843161f, -0.14594704f, 
    -0.06472877f, -0.04036310f, 0.06541775f, 0.06109003f, 0.24114303f, -0.15054166f, 0.09614290f, 0.05772307f, 
    -0.02236120f, -0.00987000f, 0.07090104f, 0.00939369f, -0.07456985f, -0.06597442f, 0.05265572f, -0.00875852f, 
    -0.07066499f, 0.07314987f, -0.21548425f, -0.03252915f, 0.05077618f, 0.27231893f, -0.18484423f, 0.33355200f, 
    -0.08826305f, 0.05672630f, 0.00963393f, 0.04342323f, 0.15470651f, 0.00236846f, 0.00445877f, -0.04609365f, 
    0.04111587f, -0.00668190f, -0.12451105f, -0.03698196f, -0.04906300f, -0.02186148f, 0.05579786f, -0.03463295f, 
    -0.07738253f, -0.11133818f, -0.16862689f, -0.00831857f, 0.19507001f, 0.11278557f, 0.09272785f, 0.03623761f, 
    0.02165010f, 0.02972600f, -0.07246432f, 0.00883551f, 0.03215547f, 0.05964642f, -0.07634015f, 0.01011470f, 
    0.03853614f, 0.03429788f, 0.06574403f, 0.05292716f, -0.15739220f, -0.06697347f, 0.07649370f, 0.22067758f, 
    0.06543905f, -0.00879027f, -0.01997271f, -0.06132875f, -0.03756850f, -0.08209503f, -0.02503193f, -0.02950791f, 
    0.00184648f, 0.00386135f, -0.05096191f, 0.00794700f, 0.01479236f, 0.01357192f, -0.01176299f, 0.00288693f, 
    -0.70557636f, 0.00210072f, 0.11610446f, 0.19347863f, -0.23420967f, -0.04370473f, 0.12252957f, 0.02879120f, 
    -0.17615582f, -0.10646100f, -0.17438392f, 0.25785691f, -0.04738574f, 0.20720586f, -0.04271571f, 0.12716615f, 
    0.06124505f, 0.21127795f, -0.23865661f, -0.05698879f, 0.05441036f, -0.06920788f, -0.14998741f, -0.00649818f, 
    0.16916659f, 0.00040835f, -0.04314575f, -0.04472221f, 0.02505912f, -0.01198202f, 0.02798509f, 0.05066891f, 
    0.03124544f, 0.06519136f, 0.10973796f, -0.04796248f, 0.05232263f, 0.08492809f, -0.02486780f, 0.03869474f, 
    -0.01729763f, -0.07589839f, -0.14656739f, -0.01656973f, 0.13154773f, 0.09360264f, 0.01827682f, 0.03953363f, 
    -0.12132051f, -0.02951856f, -0.06821105f, -0.01010857f, 0.10590032f, 0.01714705f, 0.00879765f, 0.10862985f, 
    -0.13049595f, 0.07307677f, -0.05424752f, -0.11772887f, -0.06175651f, 0.17872494f, -0.24005143f, -0.21109308f, 
    -0.14077507f, 0.06738254f, -0.06649935f, -0.14802921f, 0.01756303f, -0.16594908f, 0.06836446f, 0.02379682f, 
    0.02865605f, -0.20218472f, 0.01604123f, 0.25756389f, 0.08342408f, -0.04424134f, -0.24962188f, -0.19558339f, 
    0.03115950f, -0.08873987f, -0.12926817f, -0.00231997f, 0.12943292f, -0.00490449f, 0.05005980f, 0.05804197f, 
    0.00565651f, 0.02327291f, 0.10191964f, -0.08140793f, 0.07173865f, -0.00091286f, -0.08098448f, 0.02349165f, 
    -0.11770066f, -0.03176662f, -0.11114928f, 0.09441816f, -0.53573090f, 0.64071208f, -0.07747520f, -0.26284781f, 
    0.07164086f, 0.07334904f, 0.04481400f, 0.01501846f, -0.05032438f, -0.08273689f, -0.04216086f, -0.04672160f, 
    -0.00964429f, -0.10753370f, -0.01938282f, -0.01952862f, -0.04708670f, 0.09294286f, -0.01850400f, 0.02204443f, 
    -0.36667049f, 0.13400240f, -0.04682107f, 0.07544358f, -0.09822682f, -0.05943471f, -0.06353974f, -0.04204958f, 
    -0.05962884f, -0.08637558f, -0.01675792f, 0.02704659f, -0.06447283f, -0.07830761f, 0.01106784f, 0.06892103f, 
    -0.04246946f, 0.12961642f, -0.14475001f, -0.07344704f, -0.04851200f, -0.00484183f, -0.14176376f, 0.10526198f, 
    0.14448392f, 0.02981465f, -0.06007229f, 0.04371313f, 0.00699387f, 0.06166718f, 0.01401958f, 0.08468395f, 
    -0.03614491f, -0.05304548f, 0.01178950f, 0.06357750f, -0.09027662f, 0.01391269f, -0.01956101f, 0.02761696f, 
    0.04245673f, -0.02716809f, -0.09516946f, -0.00877585f, 0.21849595f, 0.05442456f, -0.01213079f, -0.07549071f, 
    -0.04978738f, 0.07068209f, -0.01562881f, 0.12926456f, -0.01518464f, 0.07451253f, 0.07864365f, -0.01359571f, 
    -0.01031063f, 0.09609859f, 0.06902672f, 0.06075994f, -0.06939835f, 0.09872548f, -0.04834623f, -0.00660610f, 
    0.11130445f, 0.00732242f, 0.02697578f, 0.00868202f, 0.04428635f, 0.08979379f, -0.10938874f, 0.07072651f, 
    -0.03799834f, -0.03122408f, 0.07098215f, -0.02662897f, -0.05751603f, 0.11921409f, 0.03076326f, 0.02458547f, 
    -0.10390445f, -0.01785168f, -0.11250141f, -0.09984249f, -0.18827982f, 0.09405411f, 0.00525713f, -0.03560876f, 
    -0.06490370f, -0.09695263f, 0.01385675f, -0.03689836f, 0.08762834f, -0.12654267f, -0.11762414f, 0.03799579f, 
    0.09148668f, -0.02003279f, 0.05264334f, -0.11426637f, -0.15889020f, 0.00758401f, -0.39646325f, 0.34195155f, 
    0.25026497f, -0.12664013f, -0.10591108f, -0.00743308f, -0.00857044f, 0.01577653f, 0.00798130f, 0.04886290f, 
    -0.04156978f, -0.05530163f, -0.06711693f, -0.16807257f, -0.03814386f, -0.13134053f, 0.03551929f, -0.09111887f, 
    0.15148813f, 0.00349444f, 0.47333005f, -0.15573229f, 0.24386416f, -0.23825969f, 0.08558936f, 0.02786709f, 
    -0.03068496f, 0.05761883f, 0.08906602f, 0.00123753f, 0.05568095f, -0.04285620f, 0.04431581f, 0.00983336f, 
    -0.07968394f, -0.00289214f, -0.02113546f, 0.02042698f, 0.26128381f, 0.04739298f, -0.21181276f, 0.05167023f, 
    -0.24790002f, 0.16518646f, 0.08131315f, -0.03542105f, 0.08953708f, 0.07632006f, -0.03637074f, -0.10281515f, 
    -0.01496439f, -0.12832154f, -0.07534418f, -0.07545131f, -0.07589129f, -0.03154527f, 0.04974524f, -0.06805101f, 
    0.07332511f, -0.09835298f, -0.15591508f, -0.15278339f, -0.35418215f, 0.05524839f, -0.01771831f, -0.01961158f, 
    0.04698844f, 0.03672618f, 0.02552811f, -0.10176770f, -0.02920677f, -0.06784870f, 0.06803589f, -0.05463659f, 
    0.07449848f, 0.06494517f, -0.12148377f, 0.04860868f, 0.07008255f, -0.37556931f, 0.07450946f, -0.16190627f, 
    0.00477856f, -0.09494014f, 0.01734893f, -0.00589282f, -0.13039799f, -0.36128762f, -0.05983227f, -0.16686039f, 
    -0.05932945f, 0.07559422f, -0.08454156f, -0.06865261f, -0.00337312f, -0.05534761f, -0.00835788f, -0.08477732f, 
    -0.14798996f, 0.10163655f, -0.04545636f, -0.16718265f, 0.02423588f, -0.05778584f, -0.02191261f, -0.00488801f, 
    0.01030208f, 0.04670862f, 0.01695644f, 0.01467288f, -0.01188654f, 0.01533700f, -0.01938592f, 0.08134566f, 
    0.09422027f, 0.05965456f, 0.07330698f, 0.30836627f, -0.34805715f, -0.11207991f, -0.06445390f, -0.16346101f, 
    0.00762334f, 0.01169309f, 0.01251287f, -0.05963218f, 0.04613244f, 0.00189597f, -0.13567171f, -0.07279447f, 
    -0.01663415f, 0.06605612f, 0.01541074f, -0.00237283f, 0.00810243f, -0.02472076f, -0.06300616f, -0.08530575f, 
    -0.10497832f, -0.14023985f, 0.06676719f, 0.22487719f, 0.02597854f, 0.00112303f, 0.00448665f, 0.15627010f, 
    -0.23333564f, -0.03435700f, -0.01522135f, -0.00662428f, 0.04001959f, 0.00537338f, 0.03452317f, 0.03746568f, 
    0.03123162f, -0.02133570f, 0.00945546f, 0.12179009f, 0.29379407f, -0.35121199f, 0.06736784f, -0.26574329f, 
    -0.05274505f, 0.04866879f, 0.03536283f, 0.18378574f, 0.01942964f, -0.36578447f, 0.04723464f, -0.05996058f, 
    -0.26704225f, 0.02224407f, -0.05997935f, -0.04856753f, -0.02543509f, -0.29823568f, -0.07244504f, -0.22597413f, 
    0.06492653f, -0.00183714f, -0.08273181f, 0.08635298f, 0.11184122f, -0.01413015f, 0.05101954f, 0.04352539f, 
    0.07113707f, 0.04124207f, 0.07154624f, -0.00238042f, -0.00338991f, -0.03047574f, 0.05468266f, -0.13279393f, 
    -0.04457086f, 0.08189419f, -0.06570727f, 0.05996954f, 0.10288770f, -0.59568197f, -0.32938957f, -0.01932256f, 
    -0.04173568f, -0.18187654f, -0.18145539f, 0.07750574f, -0.18190353f, 0.10636052f, -0.08413440f, 0.07629082f, 
    0.06141753f, -0.03817741f, -0.28083283f, -0.10033946f, -0.08746848f, 0.00834828f, -0.02869607f, 0.08059744f, 
    -0.02139382f, 0.21917221f, 0.19719964f, 0.28504819f, 0.06747897f, -0.10741425f, 0.02382433f, -0.10032640f, 
    0.02760027f, 0.13456760f, 0.02226339f, 0.02048666f, 0.01437864f, 0.03773083f, 0.00573065f, 0.01990450f, 
    -0.01775466f, -0.15317896f, 0.03573940f, -0.01740299f, 0.08362868f, -0.10929611f, 0.07778516f, -0.03907381f, 
    -0.02397239f, 0.02421737f, -0.05679882f, 0.00527435f, 0.03322218f, 0.00238212f, -0.08931208f, -0.08505785f, 
    0.01778174f, 0.03566746f, 0.03112422f, 0.04726441f, -0.05768364f, 0.07435239f, -0.09006850f, -0.15091681f, 
    0.20732127f, -0.17096901f, -0.15084687f, 0.06405936f, -0.07760236f, -0.03647915f, -0.13842602f, 0.03792476f, 
    0.11960283f, 0.02601424f, -0.05593572f, -0.05547635f, -0.08643200f, -0.08130620f, -0.00795504f, -0.10910358f, 
    0.01411675f, -0.01648514f, -0.02715692f, -0.02827838f, -0.01945959f, -0.16957349f, 0.10675243f, -0.14590889f, 
    0.00110660f, -0.03057749f, -0.02629139f, -0.08927859f, -0.08018611f, -0.01642323f, -0.07836500f, -0.12519507f, 
    0.09550471f, 0.15387230f, 0.00695279f, -0.09439567f, 0.01547044f, -0.07114963f, -0.05549902f, -0.05854540f, 
    0.02413232f, 0.00913791f, -0.09225425f, -0.03661600f, -0.05395026f, 0.07032423f, 0.04052941f, 0.02305007f, 
    0.02396382f, 0.04097921f, 0.03672614f, 0.01874858f, -0.04617606f, -0.04082068f, 0.04444776f, 0.13980450f, 
    0.02383167f, -0.06309861f, -0.00090632f, 0.05340591f, 0.08188824f, -0.27883202f, 0.00738439f, 0.21253119f, 
    -0.03277691f, 0.03215366f, -0.02316940f, 0.06560072f, -0.13357812f, -0.08816281f, -0.00465195f, -0.03770298f, 
    0.02205193f, -0.08991013f, 0.03978869f, -0.01503227f, -0.03963921f, 0.03662809f, -0.05204798f, -0.23617221f, 
    0.01455727f, -0.05779252f, 0.03824127f, -0.07438344f, -0.06345157f, 0.04488062f, 0.02207492f, -0.02189503f, 
    -0.00474692f, -0.00175224f, -0.01545883f, 0.03567800f, 0.00034114f, -0.00079191f, 0.01106034f, 0.02212212f, 
    -0.00730841f, -0.00234115f, -0.06282017f, -0.05536592f, 0.15313298f, -0.18829273f, 0.16523455f, -0.04575774f, 
    -0.03477372f, 0.12394030f, -0.07558503f, 0.12654343f, -0.16509637f, 0.02566711f, 0.01733573f, 0.09298132f, 
    -0.03183873f, -0.04476080f, 0.04721776f, 0.01215233f, -0.08240724f, 0.02022774f, -0.22707964f, -0.40685824f, 
    0.08936767f, -0.04016267f, 0.18540516f, 0.13592176f, 0.15739673f, -0.14686914f, 0.05519288f, -0.10514703f, 
    -0.01649221f, 0.03414113f, -0.02406827f, -0.02922177f, 0.02419299f, 0.01859481f, -0.01903776f, -0.02785604f, 
    0.00089827f, 0.03003771f, -0.03791527f, -0.05307649f, 0.03362478f, -0.04811895f, -0.20174403f, -0.06168357f, 
    -0.25738105f, 0.18759954f, -0.10089627f, -0.02742723f, 0.12270878f, 0.01000441f, 0.20638691f, -0.11704069f, 
    0.02781121f, 0.03006015f, 0.07831877f, -0.04691706f, -0.22434297f, 0.01198036f, -0.25941074f, 0.02061800f, 
    0.07411929f, 0.21503502f, 0.15688220f, 0.22411920f, 0.09578671f, -0.05308569f, 0.00423665f, -0.01132556f, 
    0.02786096f, 0.15656641f, -0.09489421f, 0.02878597f, 0.02021537f, 0.05782247f, 0.06934495f, -0.03316727f, 
    -0.07046726f, -0.11167572f, -0.13840154f, -0.19622430f, -0.02814424f, -0.03216308f, 0.22916970f, 0.06666674f, 
    0.01436714f, -0.12640618f, -0.02991232f, -0.04040780f, -0.01188961f, 0.07399154f, 0.03104393f, -0.02911712f, 
    -0.06848541f, -0.04049452f, -0.01066830f, 0.04528212f, 0.03193013f, 0.05660240f, -0.01273955f, -0.01692750f, 
    -0.11935619f, -0.02434231f, -0.06720992f, -0.32535851f, -0.28947568f, -0.00626144f, 0.01773380f, 0.03758458f, 
    0.09785023f, -0.01432398f, 0.01217138f, 0.00493554f, -0.01416001f, -0.09034809f, -0.01157404f, 0.04026122f, 
    0.01984438f, -0.04024526f, -0.03619627f, 0.16289769f, 0.01524663f, -0.00083284f, -0.12274753f, -0.07618548f, 
    -0.04429171f, 0.05694958f, -0.02073605f, 0.03282473f, 0.03310742f, 0.04630321f, 0.03377039f, -0.04458756f, 
    0.00804261f, -0.03586820f, 0.01805561f, 0.00732676f, -0.04167292f, -0.06597359f, -0.01268815f, 0.05079342f, 
    0.01154934f, -0.05867663f, 0.07103577f, -0.06621357f, -0.04134481f, 0.02411731f, -0.00652419f, -0.00662712f, 
    -0.01951567f, -0.01080031f, 0.00600532f, -0.18349987f, -0.08664222f, -0.12751380f, -0.06131554f, 0.06622680f, 
    0.01158589f, -0.08257375f, -0.03653722f, -0.00174724f, 0.13967524f, 0.05627799f, 0.15431164f, 0.10068618f, 
    0.08026615f, -0.13657534f, -0.06401068f, -0.20267348f, -0.07581060f, 0.03350213f, 0.11522140f, -0.00528540f, 
    0.02583272f, -0.00007607f, 0.00853351f, 0.03276933f, 0.01226216f, -0.03274587f, 0.00580918f, -0.04309832f, 
    -0.08581334f, 0.08077836f, 0.06386786f, 0.13454357f, -0.06098562f, -0.01580038f, -0.01711203f, -0.10327852f, 
    -0.09005024f, 0.03207484f, 0.00686623f, -0.09528718f, -0.00465696f, 0.00135182f, 0.03873456f, 0.00629921f, 
    -0.02445616f, -0.07030439f, -0.06980401f, -0.05685619f, 0.07810336f, 0.11253045f, -0.04223098f, 0.03911428f, 
    -0.03517511f, 0.08626837f, 0.01828264f, -0.00204953f, 0.03804023f, 0.05377542f, 0.06546405f, 0.00155276f, 
    0.01965912f, -0.02668324f, -0.00408646f, -0.00097427f, 0.03730556f, 0.09127834f, -0.09202813f, 0.12491985f, 
    0.19199930f, -0.01818814f, -0.13219538f, -0.17125583f, -0.19058126f, 0.00279239f, -0.07079487f, -0.00912464f, 
    0.06829670f, -0.01586821f, 0.05514942f, 0.00837646f, 0.04744138f, -0.18967515f, 0.03231742f, -0.00398083f, 
    -0.05920734f, 0.07775781f, -0.08095473f, 0.05526393f, -0.33166727f, -0.20476434f, 0.09624617f, -0.16377138f, 
    -0.03623304f, -0.02412464f, 0.10910778f, -0.19587152f, 0.06414632f, 0.03643172f, -0.02276219f, -0.04788999f, 
    -0.09349607f, 0.08719943f, -0.00506575f, -0.04087090f, 0.01523429f, 0.04222199f, -0.00277426f, -0.07427356f, 
    -0.06175182f, -0.03204362f, 0.03987164f, 0.11753705f, 0.04454643f, -0.09569009f, 0.04122651f, -0.02754053f, 
    -0.11649464f, 0.00637939f, -0.02466351f, 0.02654758f, -0.05930024f, 0.01042045f, -0.02353165f, -0.03265447f, 
    -0.00366586f, 0.02302885f, -0.03064373f, -0.00587692f, 0.09337543f, 0.16773373f, 0.31870234f, 0.11915816f, 
    0.14088014f, -0.08803204f, 0.07392168f, -0.00296962f, 0.10774280f, 0.15313664f, 0.00090035f, -0.00300822f, 
    0.02399199f, 0.02678595f, -0.05120386f, -0.02240391f, -0.05259384f, -0.13611197f, -0.02933352f, -0.01054082f, 
    0.09631849f, -0.05041071f, 0.24257776f, -0.02194129f, 0.01699963f, 0.00837297f, 0.05536507f, -0.14181587f, 
    -0.06815940f, -0.05378831f, 0.02546081f, -0.07433358f, -0.09630181f, -0.01064427f, -0.00752868f, 0.08269908f, 
    0.01380612f, -0.11232368f, -0.14311419f, 0.00068928f, 0.21578515f, 0.12639171f, 0.01894578f, -0.02704918f, 
    -0.01341295f, 0.07617401f, 0.03462831f, 0.03648721f, 0.10581413f, 0.05956980f, -0.01018358f, -0.09238330f, 
    0.03056590f, -0.05543330f, 0.13110442f, -0.00517949f, -0.05014492f, 0.01783707f, -0.11868270f, 0.02522135f, 
    0.05387159f, 0.07136486f, -0.05575722f, 0.18062679f, 0.10159614f, 0.13892287f, 0.20003785f, 0.03161108f, 
    -0.03871266f, 0.07328250f, 0.12117739f, -0.07602101f, 0.01762333f, -0.03535150f, 0.02875884f, -0.04852751f, 
    -0.01281676f, -0.10158893f, -0.05923862f, -0.09761170f, 0.10119604f, 0.19552322f, 0.25747317f, 0.25678572f, 
    0.13360925f, -0.21287774f, -0.07492594f, -0.03454738f, 0.09371352f, 0.16974829f, 0.08710748f, 0.02072555f, 
    0.00927974f, 0.03356652f, 0.02835439f, -0.00040241f, -0.01482947f, -0.09761142f, 0.06797864f, -0.04798502f, 
    0.07755389f, -0.01058979f, 0.08854609f, 0.02525884f, -0.00032993f, 0.07615817f, 0.01482106f, -0.02403764f, 
    -0.08075490f, 0.01190463f, -0.01994801f, -0.03967658f, 0.03339920f, 0.02956444f, 0.04338762f, 0.02611758f, 
    -0.08666512f, -0.01074431f, -0.13001046f, -0.10131742f, -0.21426995f, -0.30981475f, -0.07711064f, 0.01455044f, 
    -0.04694858f, 0.03889702f, 0.00061916f, 0.03947162f, -0.05494035f, 0.03480994f, 0.02966878f, 0.01976111f, 
    -0.10152475f, -0.12592150f, -0.03291487f, -0.07528562f, 0.06510732f, -0.01833730f, 0.10172812f, 0.13346188f, 
    -0.16907698f, 0.06341895f, 0.04452838f, -0.04294004f, -0.08200217f, 0.02286464f, -0.08642671f, -0.05360307f, 
    0.01018196f, 0.02465353f, -0.06462642f, 0.02153360f, 0.03226308f, 0.07542128f, -0.10291817f, -0.11251399f, 
    0.06636494f, 0.05874161f, -0.08523361f, 0.15778199f, 0.03565666f, -0.12655252f, 0.13336135f, 0.06937854f, 
    0.02942667f, -0.00106732f, -0.02206449f, -0.16584101f, 0.14029840f, 0.08173253f, 0.05233734f, 0.05219723f, 
    -0.03886622f, 0.02331583f, -0.09646263f, -0.01316175f, -0.02396495f, -0.07564308f, -0.02888999f, 0.05642344f, 
    0.19707917f, -0.43446636f, -0.42999983f, 0.27631453f, -0.10238991f, 0.08256528f, -0.01075840f, 0.05086537f, 
    0.00832342f, 0.03138550f, 0.08817905f, -0.04184835f, -0.01083257f, 0.00023727f, 0.00535921f, 0.01680828f, 
    0.22867367f, 0.17111972f, 0.06877907f, 0.23209698f, -0.06359022f, -0.05373672f, 0.11972766f, 0.08215473f, 
    0.01690966f, -0.10154013f, 0.03866211f, -0.02872802f, -0.05949537f, -0.05508835f, -0.00892332f, 0.00886120f, 
    0.00726190f, 0.01437040f, -0.00699869f, 0.03575775f, 0.11897670f, -0.01650576f, 0.01170842f, 0.00220528f, 
    0.00178506f, 0.11605453f, -0.28415865f, 0.22914566f, 0.37371087f, -0.01580688f, -0.06625421f, 0.15169474f, 
    0.06712101f, -0.01882490f, 0.04281478f, -0.00096186f, 0.02036496f, -0.11269406f, 0.04844712f, 0.01334866f, 
    -0.02404526f, -0.02790880f, -0.13394383f, -0.07082468f, 0.16732307f, 0.12904775f, -0.02420697f, 0.01429562f, 
    0.00010765f, 0.02846909f, -0.00726218f, 0.01861625f, 0.06986893f, 0.06926838f, 0.04182139f, -0.04884638f, 
    -0.02524864f, -0.14495915f, -0.02036722f, 0.07777917f, -0.00467685f, -0.02511505f, -0.00200479f, -0.00835098f, 
    -0.13203946f, 0.10152665f, 0.01803518f, 0.09404521f, 0.06471048f, -0.04346946f, 0.07004500f, 0.04553609f, 
    -0.06599363f, 0.08608684f, 0.01218675f, 0.00299433f, -0.06628802f, 0.07782008f, -0.01050074f, 0.05958422f, 
    0.12818289f, -0.01489588f, -0.15471722f, 0.29888541f, -0.44942445f, -0.04460311f, -0.04459241f, -0.33747822f, 
    -0.04937774f, 0.07783822f, 0.05216126f, -0.00576074f, 0.07489303f, 0.05470459f, -0.13052057f, -0.07121404f, 
    -0.00465185f, 0.09983292f, 0.04082741f, -0.00564611f, 0.07350001f, -0.10269437f, -0.13107532f, 0.06599797f, 
    0.03448353f, 0.07953727f, -0.08568925f, 0.18638648f, 0.00418979f, 0.15606807f, -0.04444595f, 0.12847488f, 
    -0.14042766f, 0.17026003f, -0.04944450f, -0.07667473f, 0.11649653f, -0.01125305f, 0.12648036f, -0.00016053f, 
    -0.04373224f, -0.06408325f, -0.28248775f, -0.11120329f, 0.02605740f, 0.08723247f, 0.09889892f, 0.01599102f, 
    0.14383782f, 0.14146945f, 0.06923868f, 0.03336504f, 0.05657523f, 0.13701223f, 0.00537100f, 0.02637626f, 
    -0.01789463f, 0.00591511f, 0.03332686f, 0.00557067f, -0.09272314f, -0.08537693f, -0.03371718f, -0.15901673f, 
    0.01530727f, -0.01706133f, 0.10918417f, 0.12727423f, 0.11091759f, 0.06812815f, 0.10092260f, 0.09930447f, 
    0.00803554f, 0.06782140f, -0.03129070f, -0.01369604f, -0.01623094f, 0.01550692f, -0.02652558f, 0.00807502f, 
    0.04494393f, -0.10733929f, 0.12836947f, 0.19554168f, -0.33889744f, 0.16034378f, -0.04502038f, -0.53506881f, 
    -0.12231773f, 0.06624625f, 0.02409699f, -0.01655338f, 0.02670024f, 0.04615418f, 0.06732139f, 0.01933169f, 
    0.04012024f, 0.06291989f, -0.02473646f, -0.02711637f, 0.06722550f, 0.01154598f, -0.01134314f, 0.01754361f, 
    0.09803497f, 0.06670044f, 0.06938963f, 0.06093988f, -0.04858723f, 0.04093773f, -0.08497871f, -0.09262976f, 
    -0.12488822f, 0.08828960f, 0.06701113f, 0.03508736f, 0.04595363f, 0.02318860f, 0.00435448f, 0.02473735f, 
    -0.04887091f, -0.08051206f, -0.04162814f, -0.02997615f, -0.18032739f, 0.04670953f, -0.01874448f, -0.23965886f, 
    -0.10277516f, 0.05120748f, 0.01633622f, -0.03003264f, 0.01123072f, 0.01840668f, 0.06179100f, -0.01107504f, 
    0.06172766f, 0.07592949f, -0.09965892f, -0.08769325f, -0.10155769f, -0.06131522f, -0.04117846f, 0.02426618f, 
    0.23266512f, -0.09673101f, 0.10825305f, -0.38354346f, 0.02419949f, 0.12722775f, -0.07754364f, 0.04128752f, 
    -0.03616939f, -0.27642339f, 0.11783062f, 0.07552969f, -0.05615122f, -0.15142415f, 0.01564649f, 0.17065342f, 
    -0.01489988f, -0.14530638f, -0.15837312f, 0.08618568f, -0.10799713f, -0.04376572f, 0.01527912f, 0.07629434f, 
    0.08999290f, -0.12799171f, 0.05140765f, -0.03836124f, -0.13039716f, -0.01071448f, 0.01746123f, 0.02508784f, 
    -0.00593099f, 0.02279791f, 0.03863433f, 0.02568116f, 0.07421181f, 0.00586167f, 0.05324952f, 0.10135128f, 
    0.05029720f, 0.08907945f, 0.03765295f, 0.02685380f, 0.01360399f, -0.01875843f, -0.00423909f, -0.01090079f, 
    0.02176214f, -0.00675904f, 0.14216664f, -0.00742027f, 0.01581430f, -0.06512057f, 0.05104454f, -0.01232839f, 
    -0.04973548f, -0.08818682f, -0.08639728f, -0.02322543f, -0.11825546f, -0.08522452f, 0.09935538f, -0.01521110f, 
    0.05467262f, -0.09140522f, -0.02161744f, 0.03323873f, 0.00721424f, 0.01019616f, -0.21965323f, -0.10745658f, 
    -0.05185124f, 0.08313397f, 0.04601547f, -0.19809909f, -0.13292779f, -0.08741314f, -0.01481679f, -0.09380417f, 
    0.02385225f, 0.14672567f, 0.24299873f, 0.09804562f, 0.15518023f, -0.05404464f, -0.09629235f, -0.00713355f, 
    -0.05718105f, 0.07601377f, 0.03625549f, -0.03214940f, 0.00237548f, -0.04734123f, -0.01618194f, 0.01470903f, 
    0.00451939f, -0.07393838f, 0.01605315f, -0.28532550f, -0.31679058f, -0.22023626f, 0.04239960f, -0.18856546f, 
    -0.02891618f, -0.11513820f, -0.08864977f, -0.01329750f, 0.11617728f, -0.06794157f, 0.09633970f, -0.11594836f, 
    -0.06831494f, -0.03736204f, 0.02138246f, 0.01668519f, 0.00469054f, -0.01117414f, -0.02291897f, -0.04385976f, 
    -0.00101999f, -0.21068197f, 0.03404924f, -0.17766735f, 0.08399484f, 0.00623916f, -0.00399207f, 0.00921484f, 
    0.07124808f, -0.17190343f, -0.00853443f, -0.03874023f, 0.03516017f, -0.02286566f, -0.00059362f, -0.12959798f, 
    -0.01561554f, -0.05950576f, -0.04312002f, 0.08285215f, 0.12313796f, -0.00623041f, 0.16792434f, 0.01189184f, 
    0.00475513f, 0.04709374f, -0.08032621f, -0.12227198f, -0.10877536f, -0.00130904f, 0.02920525f, -0.04065536f, 
    0.01085027f, 0.03497677f, -0.00716886f, -0.00761998f, -0.02530725f, 0.01819364f, -0.04503809f, -0.06091686f, 
    -0.07958284f, -0.10386730f, 0.03961813f, 0.18109189f, 0.16290994f, -0.14319019f, -0.02614943f, -0.06472006f, 
    -0.13617355f, -0.05671680f, -0.03615886f, -0.01301932f, 0.00701645f, -0.00082649f, 0.01727496f, 0.02242059f, 
    0.03514914f, 0.09457161f, 0.00167495f, 0.06895746f, -0.03998008f, -0.14094867f, 0.09455979f, 0.01084606f, 
    -0.00673182f, -0.05457706f, 0.03837474f, 0.06171722f, -0.12797092f, -0.05023433f, -0.01132148f, -0.00398765f, 
    -0.01961056f, 0.00846124f, -0.08260935f, 0.04397510f, 0.14020659f, -0.01872296f, 0.03594043f, 0.14287274f, 
    0.02093576f, -0.02622453f, -0.01555027f, -0.01966621f, -0.01352298f, 0.01510414f, -0.00377699f, 0.02020107f, 
    -0.04196619f, 0.03846969f, -0.09550928f, -0.02416072f, -0.15803286f, 0.01527193f, 0.03221146f, -0.00110535f, 
    -0.04371710f, -0.02422768f, -0.08787953f, -0.11493807f, 0.03310442f, -0.08330949f, 0.29896215f, -0.17091362f, 
    0.18848170f, -0.00630799f, 0.27527514f, 0.10452129f, 0.03952150f, -0.11661314f, -0.07113191f, -0.06545696f, 
    -0.00903299f, 0.04219926f, 0.00706183f, -0.02984902f, -0.03222333f, -0.02165829f, -0.01139603f, -0.15995705f, 
    0.52222842f, -0.03453694f, -0.31888217f, 0.39091742f, 0.10637536f, 0.06478988f, 0.02441615f, 0.06879133f, 
    0.08854570f, 0.05484375f, 0.05016012f, 0.02346830f, -0.00178087f, 0.01765239f, 0.03245337f, 0.08397258f, 
    0.15090209f, 0.10869991f, 0.04659838f, 0.13487802f, -0.18734263f, -0.04139443f, 0.12808558f, -0.19842413f, 
    -0.14036731f, 0.06160136f, 0.06017406f, -0.05040023f, 0.05537087f, 0.06156804f, 0.01338618f, -0.04367091f, 
    0.14547029f, 0.01020803f, -0.05352054f, -0.03859110f, 0.03542309f, -0.01953057f, -0.15856749f, 0.04374750f, 
    -0.09638641f, 0.10653152f, -0.00487360f, 0.18840691f, 0.06101303f, 0.05287323f, 0.01436207f, -0.07997466f, 
    -0.01297232f, 0.07268334f, 0.01329410f, -0.04477596f, 0.01706692f, 0.06002963f, 0.02473088f, -0.07844448f, 
    -0.07900891f, 0.06719617f, 0.02549721f, -0.06460626f, -0.13711154f, -0.21775867f, 0.01371213f, -0.32278290f, 
    -0.03481466f, 0.03989667f, -0.00712678f, -0.03795370f, 0.15049843f, 0.02815094f, -0.02230026f, 0.10170744f, 
    0.03639746f, -0.12814170f, -0.04010508f, 0.05217576f, 0.01844020f, 0.05447018f, 0.06890450f, 0.01896697f, 
    0.18659312f, 0.07245822f, 0.08099342f, -0.05369915f, 0.33057326f, 0.02203090f, 0.07592397f, -0.03492502f, 
    0.02039643f, -0.03315216f, 0.00214801f, 0.04712712f, 0.01918031f, -0.01623433f, 0.01549855f, -0.16736077f, 
    -0.05765259f, -0.27723938f, -0.09426872f, -0.36938900f, 0.00527249f, -0.06932325f, -0.15868375f, -0.10721711f, 
    0.14853935f, -0.01110818f, -0.02765731f, 0.01749926f, -0.06808998f, 0.02729766f, 0.11235730f, 0.09166754f, 
    0.06950425f, -0.00717725f, -0.08489960f, 0.01308324f, -0.04939444f, 0.07126669f, 0.00185819f, 0.11449830f, 
    0.02527788f, -0.00911120f, 0.35084051f, 0.15029864f, -0.32152450f, 0.04218543f, -0.01178900f, 0.04510036f, 
    0.07762381f, 0.01899414f, -0.00407869f, 0.00202922f, -0.01203460f, -0.02979028f, 0.02508968f, -0.01471061f, 
    -0.00471747f, -0.02038094f, -0.11230323f, -0.00789353f, -0.09294087f, -0.00501639f, 0.11175865f, -0.58901781f, 
    0.16531667f, 0.03263374f, 0.11175831f, 0.04085748f, -0.09032737f, -0.13729286f, 0.12049422f, -0.12483313f, 
    -0.04006090f, -0.11464152f, -0.02556326f, 0.00039140f, 0.00267300f, 0.10576788f, 0.06309662f, -0.11787459f, 
    0.02472295f, -0.20765562f, -0.02338938f, 0.13968915f, 0.08818593f, 0.08613277f, 0.07056265f, -0.04392951f, 
    -0.04332305f, 0.09202313f, -0.00052918f, -0.05100622f, 0.00668896f, 0.01895106f, 0.00453738f, -0.00453527f, 
    -0.07321136f, 0.18951987f, -0.03395028f, 0.02357212f, -0.57763892f, -0.28745499f, 0.10583325f, 0.04788582f, 
    -0.40510994f, -0.02807148f, -0.12798515f, -0.23718467f, 0.02741662f, 0.04849485f, 0.00441842f, 0.02218238f, 
    -0.21767883f, 0.00409982f, 0.21016264f, 0.02439783f, -0.01305637f, -0.02040222f, 0.12866597f, 0.20719257f, 
    0.14923292f, -0.05465360f, 0.32735354f, 0.03082189f, -0.21945028f, 0.22273104f, 0.10649908f, 0.08923037f, 
    -0.09198010f, -0.15510383f, 0.02012719f, -0.06865395f, 0.04678020f, 0.05188516f, 0.06635392f, 0.00972820f, 
    0.00689929f, -0.08767293f, -0.02509980f, 0.11327213f, -0.06718905f, 0.00204057f, -0.00864379f, -0.11134934f, 
    0.07503288f, -0.02936910f, -0.03779228f, -0.02539981f, -0.01851191f, 0.05699871f, 0.05060052f, 0.13972819f, 
    -0.01530366f, -0.07105075f, -0.08245891f, 0.08246443f, -0.01443793f, 0.06717124f, 0.00480668f, 0.13530765f, 
    -0.04890325f, 0.10517124f, 0.09471165f, -0.14936058f, 0.18796876f, -0.01212732f, -0.00464285f, -0.12259826f, 
    -0.06562395f, 0.01742953f, 0.12230103f, -0.02182805f, 0.03192221f, 0.02765278f, -0.11961827f, 0.18852580f, 
    -0.13540231f, -0.14942841f, -0.00526280f, 0.03838200f, -0.03736375f, 0.04786089f, -0.26014954f, -0.23686478f, 
    0.02907072f, -0.02065605f, 0.01715358f, -0.04299453f, -0.06517643f, 0.18303642f, 0.04436120f, 0.11064108f, 
    -0.13324565f, -0.02143127f, -0.08745517f, 0.04648421f, -0.02519365f, 0.11029232f, 0.00835083f, 0.17681487f, 
    -0.07406527f, -0.11205570f, -0.10266642f, -0.01508916f, 0.08251791f, 0.07647598f, -0.04789625f, -0.08398885f, 
    -0.03839840f, 0.05261008f, -0.00186068f, -0.05238755f, 0.04333337f, 0.05283101f, 0.06669937f, -0.06103704f, 
    0.01467504f, 0.04713707f, 0.00939581f, -0.00442987f, -0.07475656f, 0.04518022f, 0.33033597f, 0.03353940f, 
    -0.11343616f, -0.01046997f, -0.04865041f, -0.02356313f, -0.03257173f, 0.03482955f, 0.01369232f, -0.01005322f, 
    -0.01410641f, -0.00282271f, -0.01130894f, 0.12658495f, -0.07567436f, -0.15126476f, 0.05351707f, 0.12711580f, 
    -0.16077009f, -0.04226834f, -0.20988452f, -0.07967639f, 0.07503121f, -0.09387600f, -0.00119787f, 0.00656924f, 
    -0.06741390f, 0.03732476f, 0.13609327f, -0.01826018f, -0.00953449f, -0.10113584f, -0.05704807f, -0.03912898f, 
    -0.04448925f, 0.17990787f, 0.06011791f, 0.09656152f, -0.01953085f, -0.06523885f, 0.14189394f, -0.05421505f, 
    0.07390562f, 0.09835207f, -0.10341645f, 0.00388140f, 0.00014171f, -0.04675794f, -0.02050923f, -0.23600137f, 
    0.01909699f, -0.00839495f, -0.08321958f, 0.02353838f, 0.08284164f, 0.10008223f, -0.02736033f, 0.06815954f, 
    -0.31885365f, 0.07216819f, -0.00713302f, -0.29912817f, -0.17040820f, 0.13253757f, 0.08366378f, 0.04509827f, 
    -0.24113210f, 0.05581364f, -0.00388680f, 0.05784323f, -0.08530588f, -0.05561562f, -0.02248861f, -0.02564650f, 
    -0.02453865f, -0.02366906f, -0.03627709f, 0.03260782f, -0.49543005f, 0.71708828f, -0.12526691f, 0.25803441f, 
    -0.02855038f, -0.10292846f, -0.19187531f, -0.06226754f, 0.05264070f, -0.00073380f, -0.02480016f, -0.02524156f, 
    -0.10044983f, 0.05291433f, -0.16280448f, 0.12900272f, -0.02227633f, 0.19683897f, -0.03996065f, -0.06911611f, 
    0.12704727f, -0.13833915f, 0.33490756f, -0.11427499f, -0.32661322f, 0.00488867f, 0.12607327f, -0.01588615f, 
    -0.17214292f, 0.13927183f, 0.11061054f, 0.01688285f, -0.00947068f, 0.06049466f, 0.02224478f, -0.00387947f, 
    0.05887521f, -0.08971334f, 0.12440428f, 0.17665292f, -0.34260464f, -0.00386623f, -0.29151428f, -0.24360086f, 
    -0.13102606f, 0.03543583f, -0.00707982f, -0.01425205f, -0.06572867f, 0.01209838f, 0.00859268f, 0.01687313f, 
    -0.02365329f, -0.00104950f, -0.04106577f, -0.07005306f, -0.02687963f, 0.04506036f, -0.03957281f, -0.00229768f, 
    0.31792492f, -0.24820553f, 0.05407204f, 0.06341322f, 0.05997445f, -0.01629366f, -0.02428668f, -0.02351033f, 
    -0.05274031f, -0.01921694f, 0.00686353f, 0.01009553f, 0.01272021f, -0.00046038f, 0.07812481f, 0.01816377f, 
    -0.03331312f, 0.05150033f, 0.06650346f, -0.05631648f, -0.13400294f, -0.06779254f, -0.18013555f, 0.08444671f, 
    0.04530666f, 0.01955009f, -0.07048465f, -0.08010487f, 0.01563604f, 0.04098301f, -0.07922743f, 0.02097204f, 
    0.02921914f, 0.09187324f, 0.05705469f, 0.02816789f, 0.07584302f, 0.11200422f, 0.02750891f, -0.02732232f, 
    0.08221058f, -0.09315503f, -0.19481787f, -0.09308374f, 0.03909883f, 0.08778146f, 0.02888683f, -0.04203597f, 
    -0.01106974f, 0.11184332f, -0.02015177f, 0.09563408f, 0.15185229f, 0.09720824f, 0.04158885f, 0.05279494f, 
    0.07201210f, -0.02739786f, -0.00600612f, 0.08256034f, 0.01507195f, -0.19016980f, -0.03615917f, -0.04273408f, 
    -0.26136896f, 0.06007266f, 0.05540795f, 0.02839688f, -0.05960198f, 0.06973267f, 0.02216239f, -0.09086172f, 
    0.01342127f, -0.02040937f, -0.08453154f, 0.00900416f, 0.09257068f, 0.02362506f, 0.02657972f, 0.00053998f, 
    0.03528747f, -0.00267485f, 0.04539295f, 0.07686099f, -0.11863544f, 0.09059666f, -0.09345776f, -0.06433295f, 
    0.07512984f, 0.03326973f, -0.01222029f, 0.01188986f, 0.02490810f, 0.00009241f, 0.04071866f, 0.00976527f, 
    0.08500018f, 0.00783773f, -0.01012117f, 0.03460545f, 0.02853048f, -0.07699193f, -0.06969554f, 0.13771673f, 
    0.09933255f, 0.05069010f, 0.00931119f, -0.02830055f, 0.00846682f, -0.02679622f, 0.06283307f, -0.07344173f, 
    -0.04285770f, 0.00051548f, 0.03142011f, -0.17907929f, -0.06412016f, 0.15442449f, 0.03187733f, -0.11173787f, 
    0.27894464f, 0.16443799f, -0.22613877f, 0.10754728f, -0.07316259f, -0.02926214f, 0.11548387f, -0.06039904f, 
    -0.14269893f, 0.06795183f, 0.00202338f, -0.07346156f, -0.04766427f, 0.01741875f, -0.06468868f, 0.08990623f, 
    -0.04960826f, -0.04163875f, 0.07262408f, 0.12064718f, -0.20662406f, -0.03348462f, -0.34619272f, -0.37065244f, 
    0.01589163f, -0.05640428f, -0.04298877f, 0.02923747f, -0.03396402f, -0.04604615f, -0.11689066f, 0.15303411f, 
    -0.05324136f, -0.05360489f, 0.05518145f, -0.08934087f, -0.03717893f, 0.07293602f, -0.02892541f, 0.01608797f, 
    -0.23546889f, 0.10644567f, -0.10806882f, 0.09078226f, -0.05892212f, -0.02349304f, -0.01316272f, 0.03299795f, 
    0.02252370f, 0.00269944f, 0.05114234f, -0.02515047f, -0.06408208f, 0.03826023f, 0.00137304f, -0.16034655f, 
    -0.05462074f, 0.01487029f, -0.01461060f, -0.04005360f, 0.19047168f, 0.14322415f, 0.19442260f, -0.09585143f, 
    0.03565361f, -0.00048795f, 0.05849640f, 0.09567229f, 0.03199363f, -0.11635330f, -0.01854579f, 0.00332954f, 
    0.03095338f, 0.01642633f, 0.03730687f, 0.04283485f, 0.03734042f, 0.00490834f, 0.06533800f, 0.23459919f, 
    -0.10135820f, 0.12738490f, 0.08662622f, -0.26385716f, 0.13469796f, 0.02976199f, 0.06693840f, -0.03195974f, 
    0.00674644f, -0.10122710f, 0.06049299f, 0.00148240f, 0.09974096f, 0.00034577f, -0.09232837f, 0.05417949f, 
    -0.06507625f, -0.24353373f, 0.07245425f, -0.04178421f, -0.11568379f, 0.10464189f, -0.19429366f, 0.08594017f, 
    0.05188680f, 0.02901005f, 0.03415705f, -0.14900011f, -0.03977050f, -0.03105686f, 0.03259766f, 0.02801027f, 
    -0.11175209f, 0.00787940f, -0.07411427f, -0.01571497f, 0.01433761f, 0.14510241f, 0.10242147f, -0.04409387f, 
    -0.16025613f, 0.00751585f, -0.11473754f, 0.15911804f, -0.01670353f, 0.13980311f, -0.31912926f, 0.09252490f, 
    0.01417927f, 0.00433278f, -0.05297929f, 0.07863956f, -0.07508470f, -0.02555409f, -0.00790530f, 0.08265027f, 
    0.05139259f, 0.32709724f, -0.14925127f, 0.00961911f, 0.06826695f, -0.13368948f, 0.18574980f, -0.13434188f, 
    -0.16514778f, 0.22409192f, 0.12070251f, -0.00240419f, 0.10856485f, -0.09210616f, 0.04074615f, -0.03775230f, 
    -0.00925552f, 0.06744181f, 0.04723496f, -0.01251231f, 0.03580934f, -0.01599612f, 0.12277444f, 0.14610276f, 
    0.06028697f, -0.05570977f, 0.05183992f, -0.05892260f, 0.00901116f, 0.05270131f, 0.00074866f, -0.01544113f, 
    0.05491411f, -0.04380272f, 0.03904116f, -0.02261201f, 0.04744970f, -0.00381677f, 0.02449317f, 0.00085004f, 
    0.04723668f, 0.00612522f, 0.05951579f, 0.08590893f, -0.16541091f, 0.23810789f, -0.14211872f, -0.01586861f, 
    -0.13980974f, -0.02234447f, -0.07343703f, 0.03017174f, -0.02125144f, -0.03445102f, -0.09383540f, -0.03062753f, 
    -0.09614424f, -0.09872406f, 0.00546597f, -0.27144676f, -0.12926391f, 0.01888527f, -0.29214489f, -0.12925793f, 
    0.22857517f, 0.34588763f, -0.01634317f, -0.15081210f, 0.10812774f, -0.02000099f, -0.05566329f, 0.03074524f, 
    -0.03849368f, -0.06547143f, 0.04313370f, -0.02415140f, -0.06344145f, -0.04056003f, 0.03611130f, 0.03220880f, 
    -0.04302833f, -0.05538926f, 0.08363467f, -0.14106917f, -0.27072808f, 0.42386517f, -0.09017645f, 0.08302258f, 
    -0.11825760f, -0.24689049f, -0.06035337f, 0.06889410f, 0.09217174f, 0.13344721f, 0.10817962f, -0.06838047f, 
    0.05518045f, -0.07214405f, -0.02605932f, -0.09588277f, -0.04140856f, -0.05478451f, 0.01441241f, -0.06451837f, 
    -0.34749135f, 0.12842244f, 0.13888408f, 0.13971786f, -0.09326524f, 0.06930527f, -0.04954443f, -0.05271524f, 
    -0.00136292f, 0.03345315f, -0.07125391f, 0.03043424f, -0.03657350f, -0.00640764f, 0.00414364f, -0.05627229f, 
    -0.24448392f, -0.00952710f, -0.15675357f, -0.22059521f, -0.17820600f, -0.00816720f, 0.08542187f, -0.06228843f, 
    -0.06819035f, 0.08020920f, 0.02585773f, -0.00590060f, -0.09125204f, -0.01280543f, 0.02045179f, 0.00120467f, 
    0.00154197f, 0.01015317f, 0.05034017f, 0.01921262f, -0.02691306f, -0.05736796f, -0.06465884f, -0.02439955f, 
    0.42970687f, -0.11863299f, -0.32893905f, 0.27671590f, -0.07959977f, 0.04351951f, 0.01621415f, -0.05018840f, 
    0.02089919f, 0.11853747f, -0.03319132f, 0.04016943f, 0.03925852f, -0.05079886f, -0.00881037f, 0.08188709f, 
    -0.17632516f, 0.12404625f, 0.05061415f, 0.04420317f, -0.18078187f, 0.05729917f, -0.19155023f, -0.01135153f, 
    0.05447904f, -0.00386794f, 0.02138230f, -0.15854202f, -0.04944428f, 0.00982775f, 0.17214651f, -0.05847280f, 
    0.01946904f, 0.09490708f, -0.01552330f, -0.06263101f, 0.07346276f, 0.08323112f, -0.00357169f, -0.01532770f, 
    -0.08060022f, 0.03895677f, 0.17723672f, 0.29102883f, -0.09168219f, 0.01993965f, -0.08456359f, 0.00231630f, 
    0.11275458f, -0.26947692f, 0.03205243f, -0.02555518f, 0.01655264f, 0.01714509f, 0.07703373f, 0.05272325f, 
    -0.02004248f, -0.18120612f, -0.15507035f, -0.45258260f, -0.22849081f, -0.21660759f, 0.00793701f, -0.23480280f, 
    0.22385243f, -0.02995823f, -0.01595243f, -0.09226066f, 0.03433954f, -0.04218803f, 0.00615575f, 0.02296606f, 
    0.14418541f, -0.05830552f, 0.10515557f, -0.10855391f, -0.07413667f, 0.00653538f, 0.11925768f, -0.05079992f, 
    -0.20975602f, 0.21682107f, 0.06164516f, -0.12921369f, 0.09972934f, -0.00780113f, -0.22382414f, 0.09210287f, 
    0.10955831f, -0.26792356f, 0.08681342f, -0.01223905f, -0.11922930f, -0.10907558f, 0.01803512f, 0.07302190f, 
    -0.05160667f, 0.19732313f, 0.00337559f, 0.07883314f, 0.10325871f, 0.01833606f, 0.02777097f, -0.03834616f, 
    -0.00555830f, -0.29748246f, -0.01038186f, 0.07632784f, -0.00868948f, -0.10317589f, 0.00474967f, -0.05606117f, 
    -0.04890790f, -0.09993051f, -0.01531255f, 0.04997230f, 0.09239998f, -0.02060648f, -0.12780599f, 0.19615377f, 
    0.13182838f, 0.05895571f, 0.30161601f, 0.03995521f, -0.22961782f, -0.11825576f, 0.06480914f, -0.00520728f, 
    0.03990971f, 0.24054007f, 0.06799950f, 0.04361394f, -0.01756252f, -0.02915481f, -0.03392227f, -0.03639685f, 
    0.02040634f, 0.06684657f, -0.05180431f, -0.17799746f, -0.09772030f, 0.04984402f, -0.14166899f, -0.37707365f, 
    0.18444143f, -0.00616306f, -0.03991734f, 0.00070651f, -0.04116505f, -0.04194914f, 0.14256029f, -0.09597711f, 
    -0.04838453f, -0.06130837f, 0.04251851f, -0.12259726f, -0.00978801f, 0.14601579f, 0.10517377f, -0.18626313f, 
    -0.04564037f, 0.07019494f, 0.09687953f, -0.23364647f, -0.03493895f, -0.01380185f, 0.04599158f, 0.04520747f, 
    -0.04320225f, 0.01189957f, 0.11954307f, -0.02794795f, -0.09110942f, -0.04132261f, -0.00154071f, -0.01348349f, 
    0.05947715f, -0.03460663f, 0.00027886f, 0.07308554f, 0.19108154f, 0.05428996f, -0.15047592f, -0.43754262f, 
    0.17784338f, -0.00574761f, 0.08679891f, -0.01900494f, 0.01868675f, -0.01888024f, 0.10730183f, -0.03518750f, 
    -0.07900979f, -0.06415697f, 0.03750497f, -0.01432165f, 0.13382085f, -0.17663088f, -0.04917940f, -0.04240993f, 
    0.26537913f, 0.06219018f, 0.08158930f, -0.05019576f, -0.11429082f, 0.04033578f, 0.05664906f, 0.18660799f, 
    -0.24151370f, -0.02647384f, 0.08586352f, -0.07598642f, 0.04316899f, -0.06182728f, 0.01350783f, -0.12846279f, 
    -0.05733918f, 0.16869535f, 0.36924097f, 0.05250250f, -0.15437308f, 0.03702386f, -0.06240783f, -0.01740725f, 
    -0.11108675f, 0.08493874f, -0.05295472f, -0.04987117f, -0.10363661f, 0.02259686f, 0.00334710f, -0.01122255f, 
    0.00504590f, 0.01560824f, -0.02328353f, -0.08137909f, -0.05495660f, -0.01733308f, -0.03858655f, -0.09256586f, 
    0.00823687f, 0.08167103f, -0.03818477f, 0.03912314f, -0.00337213f, -0.00867183f, -0.06008667f, -0.00542007f, 
    -0.00994436f, 0.08744050f, -0.10569352f, -0.13284270f, -0.08168291f, -0.00370278f, -0.07690915f, 0.08837891f, 
    0.08331522f, 0.06699144f, -0.00883609f, 0.09665100f, 0.32985753f, -0.23150277f, 0.06548261f, 0.04890123f, 
    -0.14686602f, 0.17904148f, -0.13845691f, -0.12094975f, 0.11867112f, 0.17118491f, 0.04073509f, 0.10572688f, 
    -0.03393763f, 0.02754134f, 0.07318711f, 0.04664658f, -0.06064264f, -0.05845468f, 0.01583651f, 0.28151640f, 
    0.09072294f, 0.08559808f, 0.05033020f, -0.09431584f, 0.00409437f, 0.11309104f, 0.09456824f, -0.01020153f, 
    -0.05683802f, 0.00478885f, 0.00784292f, -0.01259772f, -0.02223845f, -0.03397478f, 0.02047740f, -0.04577020f, 
    0.01266522f, -0.01247432f, 0.07218431f, 0.07416930f, 0.60445082f, -0.73011327f, -0.12576181f, 0.03536247f, 
    -0.04097264f, 0.09642859f, -0.12742545f, -0.02163570f, 0.10118806f, 0.02281021f, -0.02878855f, 0.05885436f, 
    0.02803978f, 0.12197626f, 0.10653796f, -0.04276115f, -0.04315279f, 0.01865406f, -0.03531180f, 0.04642569f, 
    0.49765995f, -0.32432979f, 0.25236669f, 0.09991974f, -0.26476428f, 0.27208689f, -0.10100663f, -0.02065913f, 
    0.00169649f, 0.04936684f, 0.13013892f, 0.03011485f, -0.01787442f, -0.06968276f, 0.10892058f, -0.09154443f, 
    -0.01282428f, -0.02972310f, 0.06795924f, 0.06309447f, 0.14574458f, -0.05874522f, 0.04838334f, -0.03592205f, 
    -0.13089854f, -0.01772816f, 0.01652794f, 0.00865414f, 0.14916502f, 0.08652968f, -0.00218553f, 0.03913107f, 
    -0.06603309f, -0.01159091f, -0.04475312f, -0.00102458f, 0.09446802f, -0.00959423f, -0.00816890f, 0.11357681f, 
    -0.39856142f, 0.07485738f, -0.06739783f, -0.08923156f, -0.15682498f, 0.05538939f, -0.05522781f, 0.04501292f, 
    -0.02382703f, 0.14325958f, 0.02098912f, -0.01813746f, 0.00129268f, 0.06064256f, -0.00944963f, -0.03470309f, 
    -0.01483293f, 0.04611914f, 0.00495191f, -0.05088032f, -0.06412062f, -0.01392489f, 0.19670193f, -0.08370843f, 
    -0.04238369f, -0.02090050f, 0.07742381f, -0.03945831f, 0.02358673f, -0.04517244f, -0.00703237f, 0.00149798f, 
    -0.01049163f, 0.06537809f, -0.01677236f, 0.09235723f, -0.08492182f, -0.05394548f, -0.08988857f, -0.17029797f, 
    0.06596351f, -0.10203800f, 0.01636855f, -0.03414442f, -0.00508721f, 0.09445716f, -0.03601942f, -0.01390271f, 
    -0.04491879f, 0.03269440f, 0.06210783f, 0.06278609f, -0.05315488f, 0.09179046f, 0.00941243f, 0.07640854f, 
    0.05774893f, -0.06271954f, 0.01618646f, 0.20001779f, 0.27561662f, -0.01119463f, 0.16317676f, 0.04284949f, 
    0.01487943f, 0.17770451f, -0.11436396f, -0.26590347f, -0.05164097f, 0.28689876f, 0.12612529f, 0.02917860f, 
    -0.00497381f, 0.04856557f, 0.00658665f, 0.06843136f, 0.00568522f, -0.05660196f, -0.13843276f, 0.26700780f, 
    -0.48596722f, -0.01953805f, -0.04044116f, -0.01060064f, -0.10966092f, 0.11611339f, 0.01885378f, -0.05577089f, 
    0.03359416f, 0.01947734f, -0.04554691f, 0.04681544f, -0.00363899f, -0.01421081f, -0.03511138f, -0.08673412f, 
    -0.05233403f, 0.08322029f, -0.11655442f, -0.11157899f, 0.05306727f, 0.20069179f, -0.40566680f, -0.14273578f, 
    0.00830669f, -0.02634341f, -0.00980464f, -0.01125652f, -0.08666617f, -0.02408582f, 0.06126074f, -0.00706816f, 
    -0.19147599f, 0.00529837f, 0.01720540f, -0.13292806f, -0.04540347f, 0.09448324f, -0.00084265f, 0.00870979f, 
    -0.05497104f, 0.15864834f, -0.03348244f, -0.14342502f, 0.06385291f, -0.07695785f, 0.04064926f, 0.01083606f, 
    -0.00271245f, 0.04585436f, -0.05923181f, 0.03037830f, 0.03149448f, 0.03191725f, -0.01083422f, 0.05975754f, 
    0.02676526f, -0.06606966f, 0.07285751f, 0.01503748f, 0.04152431f, 0.55138272f, -0.19041488f, -0.17207022f, 
    0.14533582f, -0.00221734f, 0.07800156f, -0.04405685f, 0.10599028f, 0.08064394f, 0.12361388f, -0.00729129f, 
    0.05314248f, -0.09967163f, 0.02598206f, 0.07150494f, -0.00353167f, 0.04691628f, 0.02760964f, 0.01827937f, 
    -0.22712636f, -0.12218723f, -0.06734115f, -0.03082573f, -0.18343276f, 0.04971491f, 0.08570637f, 0.01687022f, 
    0.03834894f, -0.09283294f, -0.02020152f, 0.00699343f, 0.01140147f, 0.01515669f, 0.04771543f, 0.01988617f, 
    0.06807325f, 0.12696746f, 0.04749950f, 0.00618648f, 0.01943277f, 0.17976850f, -0.01604070f, -0.01375781f, 
    0.11602930f, -0.02594306f, -0.04778719f, -0.02273725f, 0.02616090f, -0.00569203f, 0.06443636f, 0.05632450f, 
    0.00364860f, 0.00095832f, -0.00700957f, 0.01218475f, 0.01691229f, -0.13160652f, 0.03305870f, 0.01960095f, 
    -0.43957999f, -0.41398191f, -0.46133536f, -0.21552089f, 0.30024403f, -0.17203598f, 0.03009859f, 0.01931307f, 
    -0.13586801f, -0.10458039f, -0.01934355f, -0.06517459f, -0.00768716f, 0.00977389f, 0.08084098f, -0.01627378f, 
    0.00849118f, -0.05750191f, 0.21986510f, 0.04831841f, -0.01340684f, 0.33084261f, -0.07343484f, -0.02995466f, 
    -0.16985901f, 0.19240969f, 0.11059964f, 0.08290850f, -0.05250671f, -0.03942966f, 0.02259480f, -0.02598671f, 
    0.08320922f, -0.04556469f, 0.07749223f, 0.07562924f, 0.01944421f, 0.12959000f, -0.12580493f, -0.14681002f, 
    0.04072382f, 0.00105609f, -0.09752329f, -0.14381145f, 0.08581854f, -0.07450373f, -0.01541174f, 0.08108707f, 
    -0.00302917f, -0.01333552f, -0.07028381f, -0.06510551f, -0.07468274f, -0.00688370f, -0.01545142f, -0.03770723f, 
    -0.09732339f, -0.22411150f, 0.00399395f, 0.00974354f, -0.25575405f, -0.08420535f, 0.21669535f, -0.10835363f, 
    -0.12234334f, -0.06028047f, 0.05197281f, -0.06659415f, -0.03698147f, 0.16222245f, -0.09174711f, 0.05555850f, 
    -0.01133564f, 0.15749460f, -0.13118899f, 0.00568520f, 0.06850686f, -0.06390703f, 0.05262899f, 0.11479560f, 
    -0.64523733f, -0.52706355f, -0.36850101f, -0.26910478f, 0.31367064f, -0.03591349f, -0.05594420f, -0.15993808f, 
    -0.23834127f, -0.37836900f, -0.01836763f, 0.00173360f, -0.06388216f, -0.03317252f, 0.02787530f, 0.00748081f, 
    0.04200037f, 0.06465562f, 0.19777134f, 0.06914920f, -0.06190272f, 0.12077954f, 0.07129699f, 0.05486818f, 
    0.00955599f, 0.01935903f, -0.05301680f, -0.06504940f, -0.02529378f, -0.02915205f, -0.07705725f, 0.02075099f, 
    -0.04849273f, 0.05157055f, 0.04896542f, 0.02048603f, -0.10661507f, -0.00183226f, -0.11123195f, -0.01939328f, 
    -0.06538792f, -0.06976728f, -0.04017290f, 0.06966954f, -0.07744646f, 0.04281040f, 0.02415629f, -0.01210333f, 
    0.04970134f, 0.06878287f, 0.10402520f, -0.04685366f, 0.07071459f, -0.00115679f, -0.00642317f, 0.06046360f, 
    0.20902154f, 0.12957188f, -0.01508669f, 0.01828584f, -0.02346578f, 0.24252102f, -0.07320649f, -0.00384274f, 
    0.12860207f, 0.05153309f, -0.06868535f, -0.01901692f, 0.05066125f, -0.06627377f, 0.07279827f, 0.08418503f, 
    -0.01906163f, 0.15069485f, 0.08278608f, 0.06285362f, -0.00899779f, -0.04768450f, -0.09420250f, 0.03060667f, 
    0.02553288f, 0.07938178f, -0.01116638f, 0.01459960f, 0.00855216f, 0.01188810f, 0.01127425f, -0.00656556f, 
    -0.03430150f, 0.02007680f, -0.01510005f, -0.04974922f, -0.05230555f, -0.04248987f, -0.04433273f, -0.03163207f, 
    -0.06154426f, -0.07463356f, -0.00162192f, 0.02738955f, -0.26601785f, -0.36696690f, -0.38940847f, 0.15352064f, 
    0.20414139f, 0.10376944f, 0.01986243f, -0.00059829f, -0.08719572f, 0.10121802f, 0.06359677f, -0.05286084f, 
    0.00156328f, -0.07609799f, 0.00506971f, 0.00311898f, 0.00610081f, -0.00036116f, 0.13127375f, 0.06154697f, 
    0.00649415f, 0.02588880f, 0.07432677f, 0.03743461f, 0.02970563f, 0.00815390f, -0.02594904f, -0.02593284f, 
    0.01427057f, -0.02780036f, -0.02247251f, -0.00662748f, 0.09442303f, 0.01029203f, 0.01258823f, 0.08785165f, 
    -0.04754503f, 0.04536004f, -0.17062211f, -0.01966738f, 0.01159036f, 0.14787227f, -0.00642079f, 0.21143734f, 
    -0.03909899f, -0.10749263f, 0.20237868f, -0.07987523f, -0.01154352f, -0.10131896f, 0.11359990f, 0.18987028f, 
    -0.12394628f, -0.01795664f, 0.00565477f, 0.04153833f, -0.01338949f, 0.03085294f, -0.11629725f, -0.24998741f, 
    -0.31794783f, -0.08430908f, 0.24505693f, 0.28799677f, 0.25726914f, 0.02558533f, 0.04819034f, 0.02612862f, 
    0.00056035f, -0.07813913f, -0.00087439f, 0.05986866f, 0.03535926f, 0.02950529f, -0.00751196f, 0.00953878f, 
    -0.00307754f, 0.04052588f, -0.04382759f, -0.05429639f, -0.09301320f, 0.06783586f, -0.06439781f, -0.06109655f, 
    0.15356439f, -0.08632429f, 0.00668679f, 0.02875429f, 0.03597195f, 0.14367895f, 0.07145175f, 0.00865208f, 
    0.20479995f, -0.05576472f, 0.07058528f, -0.08974279f, 0.13755475f, -0.06163985f, 0.06252816f, -0.04133275f, 
    -0.88530809f, -0.62333959f, 0.01730608f, 0.01896659f, -0.10912758f, 0.06492861f, -0.12190371f, -0.33520743f, 
    0.01647832f, -0.49066374f, -0.00837544f, -0.00961128f, -0.04113014f, 0.04158554f, 0.00484849f, -0.01216795f, 
    -0.00572599f, 0.04675647f, 0.10170270f, 0.01769566f, -0.33993486f, 0.40959099f, 0.40546849f, 0.08841162f, 
    0.20970121f, -0.08914499f, -0.06758142f, -0.04134575f, -0.05645515f, 0.14385116f, -0.00773300f, 0.07419360f, 
    0.07959644f, 0.03923185f, 0.05840355f, 0.01169029f, 0.00816083f, -0.01812744f, 0.00161396f, 0.00744550f, 
    -0.02560688f, 0.17081961f, -0.10490583f, 0.01576924f, -0.00205371f, 0.03045557f, 0.00262502f, 0.00865624f, 
    0.01564777f, 0.05688548f, 0.00764685f, -0.07863866f, 0.07471832f, 0.03002890f, -0.01343900f, -0.04877891f, 
    0.08331874f, -0.16102204f, 0.08494142f, 0.16461430f, 0.00831815f, 0.01581325f, -0.05400285f, -0.03882590f, 
    -0.01571445f, 0.03133670f, 0.00882463f, -0.00986998f, -0.00405485f, 0.08155116f, -0.06843226f, -0.04033373f, 
    -0.02353286f, -0.05549872f, -0.01756124f, -0.05539286f, 0.04517675f, -0.12222515f, 0.02051774f, 0.02091404f, 
    0.05801641f, 0.15941809f, -0.04453912f, 0.01145111f, 0.08156947f, -0.00288732f, -0.01679355f, -0.03927616f, 
    0.02718040f, 0.05840151f, 0.09815456f, -0.04294834f, 0.09471390f, -0.15284683f, 0.06796081f, 0.04398268f, 
    -0.00329270f, -0.13345511f, -0.00702697f, 0.00212986f, -0.51307559f, 0.45063323f, 0.17881240f, -0.00887143f, 
    -0.16337056f, -0.25333142f, 0.02746833f, -0.23141311f, 0.00010835f, 0.08298043f, -0.00930940f, 0.00498968f, 
    0.04228499f, 0.00100373f, 0.03155638f, -0.00298200f, -0.02977442f, 0.00565161f, 0.02503931f, -0.06812395f, 
    -0.20533811f, 0.00081941f, 0.09705523f, 0.04290597f, 0.07748708f, -0.14470352f, 0.01522684f, -0.04015200f, 
    -0.07075883f, 0.09526402f, 0.02329955f, -0.00505733f, 0.00308780f, -0.01763958f, 0.05834599f, -0.02322757f, 
    -0.02132209f, 0.00124568f, 0.11013554f, -0.06796513f, -0.08876081f, -0.00417741f, 0.03984969f, -0.05419926f, 
    -0.03558360f, -0.01011549f, 0.03079263f, 0.02772179f, -0.01530175f, -0.02606036f, -0.00618638f, -0.06906854f, 
    -0.03396042f, -0.04935435f, -0.05831561f, -0.04211573f, 0.04310576f, -0.10548195f, -0.03337562f, 0.07911017f, 
    0.00116402f, 0.07227758f, 0.12731701f, -0.16673620f, 0.10311372f, -0.03694655f, -0.05000426f, 0.05618101f, 
    0.01688168f, -0.00364395f, 0.01181457f, -0.02703644f, -0.04111138f, -0.06598756f, 0.00627364f, -0.10472091f, 
    -0.06530844f, 0.08796617f, -0.07849690f, 0.00949829f, -0.34047332f, 0.32034859f, 0.07803213f, 0.01508501f, 
    0.32165965f, -0.00555095f, -0.02730739f, -0.07129502f, 0.09025419f, 0.01504194f, 0.09382948f, 0.09742693f, 
    0.11891018f, 0.05964919f, -0.03256809f, 0.03762443f, 0.01916346f, -0.00760688f, -0.00368313f, 0.02486238f, 
    -0.26084840f, -0.16094843f, 0.06367176f, -0.00405851f, 0.24194539f, -0.12316975f, -0.08727361f, 0.05040359f, 
    -0.01663538f, 0.03786170f, 0.05285471f, 0.00076528f, 0.04959202f, -0.00421087f, -0.01291782f, 0.00968769f, 
    0.00835046f, -0.00154119f, 0.08720084f, -0.00067609f, -0.17142327f, -0.41880319f, -0.56748742f, -0.09704727f, 
    -0.04233987f, -0.02336002f, -0.02275667f, -0.13450707f, -0.00065662f, -0.42319649f, 0.03041676f, -0.03826122f, 
    -0.09351776f, 0.02594403f, 0.01556834f, -0.02109395f, -0.00662073f, 0.14082697f, 0.03986834f, 0.04041731f, 
    -0.10023641f, -0.26780033f, -0.13262433f, 0.12321664f, -0.39892823f, 0.12018111f, 0.12602159f, 0.08250494f, 
    -0.05962941f, -0.28130263f, 0.04011418f, 0.00986115f, 0.03113660f, 0.10757542f, 0.04779147f, -0.06697695f, 
    -0.01409283f, 0.18039024f, -0.07758123f, 0.04084837f, -0.05927167f, -0.15822661f, 0.08199937f, -0.11370027f, 
    0.00958104f, 0.02450982f, -0.04145248f, -0.04798149f, -0.00918192f, -0.03149212f, -0.04118126f, 0.17941676f, 
    -0.03063204f, -0.00238248f, 0.07436740f, 0.00832352f, -0.05555037f, -0.00438155f, -0.01612288f, 0.01718438f, 
    0.03744828f, -0.24953738f, -0.26753286f, -0.15372029f, 0.19080265f, -0.13541566f, 0.02347055f, 0.22129722f, 
    0.05800380f, -0.01910623f, -0.02917766f, 0.00285193f, -0.07827870f, -0.08062053f, 0.01022316f, -0.01898685f, 
    -0.01488337f, 0.01186665f, 0.13414837f, -0.03897509f, -0.59566587f, -0.55886143f, -0.17064263f, -0.26562810f, 
    -0.60141611f, -0.11387288f, -0.10697612f, 0.03372042f, -0.20833936f, -0.23554221f, -0.04218220f, 0.00030638f, 
    -0.06476069f, 0.03496462f, 0.01155147f, -0.02943764f, -0.02855621f, -0.02718686f, 0.08162510f, -0.04226220f, 
    -0.01075899f, -0.03180267f, 0.14825350f, 0.03321025f, -0.02034072f, 0.00844381f, 0.02656681f, -0.04130181f, 
    -0.07744049f, -0.05677813f, -0.03801459f, -0.06534629f, -0.03947984f, 0.01860065f, 0.03931307f, -0.02965569f, 
    -0.02597623f, 0.00167559f, -0.02282050f, -0.14291668f, 0.14866178f, 0.12531686f, -0.06488483f, -0.02174074f, 
    0.14815775f, -0.05777677f, 0.00303872f, -0.05478148f, -0.01070215f, 0.08101393f, -0.07025380f, 0.03182565f, 
    0.08873291f, 0.06498071f, -0.05228875f, -0.00705334f, 0.12712385f, 0.07042139f, 0.12413050f, -0.05089702f, 
    -0.29807642f, -0.29520014f, 0.11473072f, 0.20019741f, -0.18790948f, -0.01451702f, 0.05995870f, 0.05039225f, 
    0.11399006f, -0.12254212f, -0.01680722f, 0.06016131f, 0.06065137f, 0.09982859f, 0.03293637f, -0.00083441f, 
    0.04392054f, 0.14089909f, 0.04155010f, 0.04565469f, -0.36227784f, -0.30993232f, -0.16076365f, 0.24744281f, 
    0.15417984f, -0.12696920f, -0.09922953f, 0.03421276f, 0.13651042f, 0.15237834f, 0.02700244f, -0.02330510f, 
    0.12992984f, -0.10498777f, 0.06130666f, 0.01979985f, 0.00699455f, -0.07058423f, 0.10730239f, -0.04402496f, 
    -0.12874751f, 0.00809993f, -0.04254757f, -0.04041098f, 0.10106997f, -0.06451593f, 0.05872144f, 0.00045127f, 
    -0.01407465f, 0.07536811f, -0.04764583f, -0.05005096f, -0.00871918f, 0.02380171f, -0.01178660f, 0.07150847f, 
    0.04457752f, 0.02268078f, 0.10823318f, -0.02518549f, -0.24849021f, -0.28420681f, -0.46200877f, -0.09611557f, 
    -0.05438204f, -0.04012130f, -0.11049737f, -0.12428975f, -0.10379289f, -0.07814906f, 0.00288642f, 0.02704369f, 
    -0.00956210f, -0.01280114f, -0.06296598f, -0.03659879f, -0.01961978f, 0.05618433f, 0.06360980f, -0.06389390f, 
    0.27226055f, -0.31649464f, -0.64955330f, -0.43554333f, -0.00334806f, -0.01057712f, 0.01480846f, 0.23805071f, 
    0.03465955f, -0.09609950f, 0.01617715f, -0.00321627f, -0.04018342f, -0.02267385f, -0.00621144f, -0.08644998f, 
    -0.01334651f, -0.00808648f, 0.02450311f, 0.10153040f, -0.14714742f, -0.04791844f, 0.11979768f, 0.04229489f, 
    0.00254138f, -0.07396224f, -0.06067957f, -0.07353521f, -0.06474631f, 0.05369281f, -0.06722189f, 0.00408967f, 
    0.12720504f, 0.06155401f, -0.01021179f, -0.03037943f, 0.01911382f, -0.01932720f, -0.01524518f, 0.03255453f, 
    -0.30058831f, -0.20313519f, -0.46251205f, -0.05783045f, 0.09066150f, -0.15957552f, 0.00648914f, -0.09620789f, 
    -0.11414129f, -0.33962569f, -0.01066541f, -0.00879275f, -0.02286852f, -0.01106844f, 0.07854794f, 0.00366677f, 
    -0.01008472f, 0.11601663f, 0.10803405f, 0.02610400f, -0.11781781f, 0.17529818f, 0.00373525f, -0.12516586f, 
    0.17904085f, -0.02654671f, -0.00551571f, -0.03250028f, 0.02125713f, -0.04593858f, 0.07769009f, -0.01854344f, 
    0.17710039f, 0.00791156f, -0.01497616f, 0.00505924f, 0.09251162f, -0.12242385f, 0.09366260f, -0.00720536f, 
    -0.11831515f, -0.20624252f, 0.14748399f, 0.09939022f, -0.00141984f, -0.05785886f, -0.09317611f, -0.00862725f, 
    -0.01591683f, -0.08667035f, 0.08678406f, -0.10561419f, -0.05483833f, -0.10529022f, 0.00738826f, 0.00685708f, 
    -0.01270275f, 0.02619719f, -0.00313526f, -0.16031446f, 0.03918475f, -0.16575022f, -0.15942688f, -0.03289293f, 
    0.11375581f, -0.06395067f, -0.05030825f, -0.04764773f, 0.06742892f, -0.17274748f, 0.03647785f, -0.01988599f, 
    -0.15999895f, -0.02202794f, 0.03512061f, -0.03666223f, -0.03073009f, 0.01494598f, 0.00989151f, -0.08754584f, 
    -0.52599317f, -0.53500664f, -0.50269389f, 0.02180469f, 0.15152301f, -0.01220164f, 0.11854953f, 0.04346344f, 
    -0.04816890f, -0.26176962f, -0.00875943f, -0.04369131f, 0.01316725f, 0.01393967f, 0.06913445f, 0.00410531f, 
    0.01112017f, -0.00838115f, 0.17915443f, 0.08472290f, -0.17119634f, 0.01067311f, 0.11191225f, 0.02590422f, 
    0.01450569f, -0.00010975f, 0.03140087f, -0.00168308f, -0.01752183f, -0.07832112f, 0.02155737f, -0.02227823f, 
    0.02793136f, -0.01648487f, -0.01491810f, -0.01708387f, 0.04067125f, -0.06550326f, -0.06909916f, 0.01324458f, 
    -0.21325992f, 0.04173572f, 0.21387665f, 0.01793056f, -0.04281181f, -0.07894388f, -0.04587499f, -0.06257121f, 
    -0.13067120f, -0.03771087f, -0.10795886f, 0.04544115f, -0.02921272f, -0.02021504f, 0.03360963f, 0.00860864f, 
    -0.03990518f, 0.06385626f, -0.08526547f, -0.05543079f, 0.13018943f, 0.05987367f, 0.09751010f, -0.13581389f, 
    0.01014037f, 0.04326193f, -0.00864337f, -0.00622942f, 0.00558644f, -0.06569683f, 0.02802646f, 0.01635322f, 
    0.01048091f, 0.01396612f, 0.07538088f, 0.00550647f, 0.03177761f, -0.04884501f, -0.19087481f, 0.00908741f, 
    0.02036422f, -0.02768217f, -0.08004975f, -0.03176651f, -0.08965340f, 0.05016840f, 0.19478191f, 0.10646967f, 
    -0.06163821f, 0.12328881f, 0.07528003f, 0.02789261f, 0.07888258f, -0.07138786f, 0.07159171f, -0.02416618f, 
    0.01648451f, -0.01907420f, 0.05880858f, 0.07807595f, -0.14537457f, -0.40201560f, -0.55092943f, -0.23798433f, 
    0.23918839f, -0.06335391f, -0.02698198f, -0.05357406f, -0.06689769f, -0.00843886f, 0.02289424f, -0.02291192f, 
    0.02259110f, -0.02881523f, -0.11100262f, -0.08942820f, -0.03544442f, 0.02159222f, 0.09130310f, -0.09996632f, 
    -0.06946173f, 0.12118781f, 0.06783415f, -0.09472255f, 0.01495170f, -0.08956292f, -0.00816434f, -0.03340661f, 
    0.03703445f, -0.00510812f, 0.00825180f, -0.01525828f, -0.01811009f, 0.01051960f, 0.01286766f, 0.00030979f, 
    -0.02528249f, -0.01385423f, -0.03215383f, -0.05564698f, -0.05568900f, 0.22777578f, -0.10721190f, 0.04882542f, 
    0.13411593f, -0.02959175f, 0.03839090f, -0.06739147f, 0.18995996f, 0.12439346f, -0.07335122f, -0.03013017f, 
    -0.07799537f, 0.01706693f, 0.00978402f, 0.00005987f, 0.04841611f, -0.05788447f, 0.07186980f, -0.07687710f, 
    -0.26936576f, -0.38242570f, -0.18660001f, 0.15232462f, -0.21452533f, -0.08222110f, 0.08472056f, -0.03598126f, 
    -0.07991558f, -0.24718742f, 0.04476799f, -0.06946279f, 0.04094860f, -0.08924330f, 0.01654023f, -0.01024794f, 
    0.02179247f, 0.03625342f, 0.08906939f, -0.05224826f, -0.20585270f, 0.33061877f, 0.10752060f, -0.03651648f, 
    0.16535142f, -0.16958517f, 0.03633982f, -0.03899837f, 0.05783724f, 0.22037266f, 0.09234941f, 0.03979807f, 
    0.05630392f, -0.00722808f, 0.03594113f, 0.05064905f, 0.07359774f, -0.04275732f, 0.08741929f, -0.05112680f, 
    0.01930428f, -0.09094314f, -0.27276999f, -0.15965058f, 0.13319626f, -0.03206936f, 0.00201193f, 0.13575162f, 
    0.10245003f, 0.07244275f, -0.00880695f, -0.00100606f, -0.02919596f, 0.04589443f, 0.04339763f, 0.00458550f, 
    0.02842203f, 0.03574539f, 0.09612074f, 0.00858434f, -0.15078221f, 0.32003269f, -0.03425044f, -0.10584873f, 
    -0.04665949f, -0.11029863f, -0.05274887f, -0.24345586f, 0.11458882f, 0.00846462f, 0.01519091f, -0.00923197f, 
    -0.03852731f, 0.00341335f, 0.00736693f, 0.00546177f, -0.01849433f, 0.04043156f, -0.00396378f, -0.07974747f, 
    -0.43063688f, -0.41529465f, -0.39737958f, -0.32851800f, -0.17676643f, -0.03982600f, -0.06103627f, -0.00382280f, 
    -0.11769945f, -0.00450764f, 0.00254356f, 0.04692618f, -0.01005524f, 0.06210712f, -0.06025606f, -0.02295906f, 
    -0.01551307f, -0.02900388f, 0.03829152f, -0.04973454f, -0.00372390f, -0.22325329f, -0.34147000f, 0.00261056f, 
    -0.18460055f, -0.03429529f, -0.03239696f, -0.01140069f, -0.06406823f, -0.04476431f, -0.02484762f, -0.00145812f, 
    0.00937842f, 0.02247652f, -0.02209218f, 0.08174312f, 0.03080274f, 0.16740273f, 0.09249239f, 0.00831127f, 
    0.01272576f, 0.05837546f, 0.05211434f, -0.00112006f, 0.03328238f, 0.04691101f, -0.01334316f, -0.01694592f, 
    0.01126134f, 0.07634557f, 0.01615730f, -0.04981594f, -0.05300787f, 0.02440694f, 0.02727506f, 0.02795322f, 
    -0.01473564f, -0.06764955f, -0.06396414f, -0.02212660f, -0.47705808f, -0.56713307f, -0.85359645f, -0.38423070f, 
    -0.19168665f, -0.17905095f, -0.02637550f, -0.15030992f, 0.04074567f, -0.26917833f, 0.06059801f, -0.00363438f, 
    -0.06099946f, 0.00763866f, -0.03740592f, -0.06984904f, -0.03425042f, 0.15223293f, 0.08894070f, 0.04486291f, 
    -0.46749717f, -0.38405445f, -0.25846088f, -0.06539269f, 0.02640186f, -0.02740223f, 0.07157964f, 0.06102344f, 
    -0.04142322f, -0.00776514f, 0.01077809f, -0.03811920f, -0.01877635f, 0.01846795f, 0.04294692f, 0.00080081f, 
    -0.02264517f, 0.03029132f, 0.05739219f, 0.01871081f, -0.03647855f, -0.00841767f, 0.14209244f, -0.01996002f, 
    0.11310803f, -0.02302239f, 0.00285666f, -0.01758125f, -0.02435416f, -0.00371591f, 0.01304942f, 0.03356217f, 
    0.03993020f, 0.14306977f, 0.05134294f, 0.00207533f, -0.00945217f, 0.08667465f, -0.03210144f, 0.04585155f, 
    -0.00751184f, 0.13039078f, -0.18759805f, 0.10478257f, -0.24814846f, 0.01046314f, 0.06024392f, 0.01983161f, 
    -0.08042736f, -0.02087925f, -0.02249489f, 0.01779806f, -0.00694087f, -0.00517674f, -0.00119555f, -0.10199331f, 
    -0.07037961f, -0.01347255f, -0.05979125f, -0.00818170f, -0.17984810f, -0.23744109f, -0.01228372f, -0.14292191f, 
    0.16515616f, -0.01314993f, -0.07559865f, 0.14319564f, -0.11288267f, 0.09025875f, -0.14312857f, 0.13247089f, 
    -0.02042211f, 0.08745271f, -0.02527461f, 0.01932393f, 0.00035185f, -0.00176178f, -0.02952330f, -0.06046684f, 
    -0.10329945f, 0.08328611f, 0.12940171f, 0.01797827f, 0.11451773f, -0.01276163f, -0.01217515f, 0.01760192f, 
    -0.02950438f, -0.00492258f, 0.03601909f, -0.01504065f, 0.00743692f, 0.00797469f, -0.01641151f, 0.12512451f, 
    0.00378504f, 0.04306158f, -0.04602089f, -0.01571613f, -0.13219532f, -0.00334835f, -0.01871752f, 0.08485626f, 
    -0.07806656f, -0.03939142f, 0.02136735f, 0.08305343f, -0.07259060f, -0.02290499f, -0.08909121f, 0.06279156f, 
    0.00967447f, -0.04743515f, 0.02155455f, -0.02765093f, -0.02674127f, 0.01708997f, -0.05620226f, -0.00627123f, 
    0.11534028f, -0.27606779f, -0.20252857f, 0.37601122f, -0.04694412f, 0.05291264f, -0.00880085f, 0.04151563f, 
    -0.00536644f, 0.13939710f, 0.00128855f, -0.03013548f, -0.05654667f, -0.06522369f, -0.06369220f, 0.02261784f, 
    0.05056782f, -0.04973569f, 0.09156268f, 0.03043411f, -0.24027647f, -0.27527386f, 0.31195891f, -0.23813543f, 
    0.30778706f, -0.08279257f, -0.07725263f, 0.13119733f, -0.06499959f, 0.04653964f, -0.05696695f, 0.03035356f, 
    -0.00322815f, 0.11007588f, 0.05780638f, -0.06019862f, 0.05859066f, -0.14957570f, 0.04738455f, -0.09650908f, 
    0.02573051f, 0.07952970f, -0.04665202f, 0.08714018f, -0.13792713f, -0.01204024f, 0.04580342f, -0.00625523f, 
    0.00387056f, -0.01491852f, 0.03980154f, 0.02775939f, 0.02162769f, -0.00610977f, -0.04097658f, -0.11171866f, 
    -0.16082975f, -0.04775073f, 0.03797395f, 0.01637649f, 0.51787770f, 0.15067491f, -0.17034958f, -0.35701981f, 
    -0.02043984f, 0.08505641f, 0.16751957f, -0.13955563f, 0.04382390f, 0.05079225f, -0.00809361f, 0.10168637f, 
    0.08937592f, -0.04240790f, 0.07796408f, -0.07985613f, 0.07786420f, 0.03356539f, -0.02491908f, 0.00875662f, 
    -0.00640818f, -0.35731369f, 0.00556172f, 0.41364327f, 0.01517322f, 0.00221511f, 0.11054629f, 0.02525663f, 
    0.04230306f, 0.17434323f, 0.00970773f, -0.01120537f, -0.03425077f, -0.05309007f, -0.02335977f, 0.00313003f, 
    0.02591439f, -0.10045131f, 0.09184139f, -0.05250285f, -0.05718381f, -0.00001871f, 0.08629140f, -0.02179630f, 
    0.04950595f, -0.05418251f, 0.05219618f, -0.01171118f, 0.02410684f, -0.03514215f, -0.03527335f, -0.04812359f, 
    0.00190083f, -0.04281900f, 0.00210430f, -0.01247057f, 0.00791067f, 0.01578427f, -0.03306219f, 0.01484617f, 
    0.12311524f, 0.07723934f, 0.14303561f, -0.10287187f, -0.08194842f, 0.01168667f, -0.02715958f, 0.04762445f, 
    -0.02153146f, -0.04708649f, -0.01362920f, -0.07799017f, -0.01988077f, -0.10007694f, -0.00459613f, -0.09594293f, 
    -0.03460626f, -0.01040076f, -0.09757560f, -0.07770156f, -0.13335927f, -0.06179619f, 0.11485846f, -0.02022389f, 
    0.09603065f, -0.00936739f, -0.03118075f, 0.01350272f, -0.04438430f, -0.01508261f, -0.02307471f, 0.03911103f, 
    0.00299364f, -0.01570411f, -0.03797745f, -0.02684830f, -0.00263636f, 0.00298505f, -0.02440054f, 0.03172707f, 
    0.04935537f, 0.04650011f, 0.03702906f, 0.00956776f, -0.06993340f, -0.00356179f, 0.02345915f, -0.04082040f, 
    -0.03903912f, -0.03575685f, 0.01649387f, 0.01662093f, -0.02549018f, -0.02543986f, -0.03084151f, 0.04385099f, 
    -0.03792196f, 0.03881643f, 0.04416062f, 0.00504182f, 0.16213262f, -0.23641792f, 0.25836176f, 0.14656775f, 
    -0.14410435f, 0.07178027f, 0.01810370f, 0.03801949f, -0.02274440f, 0.04879435f, 0.00377038f, -0.00779845f, 
    0.03971202f, -0.08062755f, 0.01470442f, 0.02389229f, 0.03946031f, 0.04411124f, 0.04631780f, -0.04229803f, 
    -0.00586917f, 0.11243869f, 0.11135036f, 0.00827416f, -0.00766700f, 0.01837709f, -0.02211467f, 0.00178686f, 
    -0.02389829f, -0.05710061f, 0.01021857f, -0.08836076f, -0.01648504f, -0.04728336f, -0.06966054f, -0.06480933f, 
    0.02690320f, -0.04880870f, -0.00440335f, -0.00256392f, -0.38125280f, -0.25290006f, 0.31975389f, -0.05755189f, 
    0.22802600f, 0.00812758f, -0.11363647f, 0.08047391f, -0.05160389f, 0.10259995f, -0.08430975f, 0.05700117f, 
    0.04712192f, 0.04730418f, -0.00763833f, 0.05521689f, 0.01781380f, 0.03173093f, -0.17855273f, 0.01548402f, 
    0.06448711f, -0.44459498f, -0.04736874f, -0.25688738f, -0.18852864f, -0.03281429f, 0.06177487f, -0.02676277f, 
    0.22692686f, -0.01130765f, 0.02553386f, 0.01038324f, 0.00521652f, -0.00674884f, 0.00512457f, -0.11387555f, 
    -0.01519905f, -0.02577253f, -0.00143416f, 0.01106599f, 0.23911896f, 0.38868380f, -0.12742814f, 0.04063369f, 
    -0.53671664f, -0.04930966f, 0.09737304f, 0.00562217f, -0.08329579f, -0.02276838f, -0.16093875f, 0.00033678f, 
    -0.04635507f, -0.05100056f, -0.01313511f, -0.04247281f, -0.14338379f, 0.09105272f, -0.10488098f, -0.03094127f, 
    -0.13426772f, -0.56317163f, 0.40024704f, 0.01329730f, 0.25861979f, -0.07704429f, 0.25819293f, -0.13557424f, 
    0.02735687f, 0.01270460f, 0.08824380f, 0.03350863f, 0.06383736f, 0.01379436f, 0.02164467f, 0.04797507f, 
    0.01226136f, -0.03191855f, 0.04241935f, 0.02175532f, 0.39225924f, -0.27658573f, -0.55098230f, -0.13752554f, 
    -0.17972909f, -0.02732402f, -0.14355788f, 0.00865181f, 0.12107931f, -0.11842021f, -0.00666168f, 0.03698133f, 
    -0.00782419f, 0.04733580f, 0.02442357f, -0.01101376f, 0.00502141f, 0.03123493f, 0.03694503f, 0.04813883f, 
    -0.01385878f, -0.01306474f, 0.06060727f, 0.01672594f, -0.08849318f, -0.01115261f, 0.02238056f, 0.00334367f, 
    -0.05754320f, -0.01386896f, 0.03357292f, 0.03369948f, -0.00747250f, -0.04388849f, -0.02643070f, 0.01605463f, 
    -0.07335663f, -0.12385407f, 0.02426093f, 0.02001764f, 0.05571510f, 0.11204442f, 0.04353934f, -0.01123100f, 
    -0.08386973f, -0.02440317f, -0.00804687f, -0.03621706f, -0.03086070f, -0.08254627f, -0.02364935f, 0.00652840f, 
    -0.05332662f, -0.08254980f, -0.06585444f, 0.01166117f, -0.05073827f, 0.02642202f, 0.01437881f, -0.00310538f, 
    0.02084699f, 0.02725108f, 0.00427004f, -0.04888197f, -0.01889059f, 0.04066120f, -0.02322994f, -0.00688045f, 
    -0.04530004f, -0.02010000f, -0.08964583f, -0.05892171f, -0.15627289f, 0.01930826f, -0.06557647f, 0.03146368f, 
    -0.02245823f, -0.00359045f, -0.01415672f, -0.00931732f, 0.41854367f, -0.38920379f, -0.23007213f, -0.16328360f, 
    -0.21628901f, 0.03903900f, -0.08637682f, 0.00453980f, 0.13731578f, -0.01162628f, 0.01593338f, -0.04874796f, 
    0.07680815f, 0.04659126f, 0.05536245f, 0.03821128f, -0.03076099f, 0.05450922f, -0.00060094f, 0.00346427f, 
    0.24485436f, -0.09496901f, -0.25756827f, 0.06032000f, -0.13204278f, 0.15161665f, -0.08227687f, 0.07017075f, 
    -0.06512403f, -0.08246297f, -0.00974227f, -0.00259183f, 0.03705741f, 0.00496743f, -0.03524227f, 0.01293728f, 
    0.00160092f, 0.02711075f, -0.05836840f, -0.06963907f, 0.01441439f, 0.06790922f, 0.02911331f, 0.08760328f, 
    -0.06614514f, 0.01665250f, 0.05546067f, -0.00063218f, -0.05589043f, -0.01155925f, 0.02797707f, 0.01620319f, 
    0.01213261f, -0.01014397f, -0.02570812f, -0.00236956f, -0.10318195f, -0.06960611f, 0.03042787f, 0.02282994f, 
    0.05992251f, 0.06706605f, -0.07519059f, 0.04705346f, -0.05708263f, -0.00526404f, -0.01730260f, 0.04979396f, 
    -0.03314415f, -0.05093354f, 0.04372570f, -0.00331197f, -0.00416703f, -0.03123090f, -0.01771550f, -0.12725434f, 
    -0.08537561f, 0.05841764f, -0.02987787f, -0.01152201f, -0.23386158f, -0.37673113f, -0.05117298f, 0.01361928f, 
    0.03128065f, 0.02975207f, -0.01827453f, 0.17375518f, 0.01075493f, 0.00705342f, -0.07967433f, 0.09849996f, 
    0.06308522f, 0.04691333f, 0.00706823f, -0.00662646f, 0.00664139f, -0.01483224f, 0.11613750f, 0.04851348f, 
    0.37736958f, -0.37066022f, -0.38476700f, -0.34074697f, -0.21647123f, 0.01476021f, -0.09107343f, -0.04035066f, 
    0.09294010f, -0.04062691f, 0.00582985f, 0.06407965f, -0.02305190f, -0.01306143f, -0.00019250f, -0.07147644f, 
    -0.04906430f, -0.01570168f, -0.03499462f, 0.01012698f, -0.35477480f, -0.31071338f, 0.26220423f, 0.03150120f, 
    0.13805488f, -0.09762955f, 0.06194316f, 0.00926824f, 0.07100393f, 0.07462635f, 0.00654967f, 0.00830769f, 
    -0.02974368f, -0.04162789f, -0.02881733f, 0.03024855f, -0.02691891f, -0.18360035f, -0.06830401f, 0.00668745f, 
    -0.06415799f, -0.58552414f, 0.34225088f, -0.29842684f, 0.06308141f, -0.06434996f, 0.02481843f, -0.07981206f, 
    0.05527337f, 0.04224066f, -0.03711858f, -0.01253485f, -0.07541575f, -0.03729061f, -0.11866131f, 0.04901064f, 
    -0.03172555f, 0.03300323f, -0.11805065f, -0.14919570f, 0.12239920f, 0.10434747f, 0.00028318f, 0.02141094f, 
    -0.13916025f, -0.02570303f, 0.00056866f, 0.01902296f, -0.04058828f, -0.05123324f, 0.04592248f, -0.11519239f, 
    -0.05499520f, -0.13458095f, -0.04668779f, 0.00542946f, 0.01175451f, 0.08911845f, -0.04692512f, 0.02010250f, 
    -0.01248269f, -0.01349746f, -0.08735711f, 0.08938506f, -0.20671317f, 0.04692214f, 0.03986967f, 0.09197099f, 
    0.01268644f, -0.04253923f, 0.02792158f, 0.00108160f, -0.02047362f, -0.00630260f, -0.02440145f, 0.01309134f, 
    -0.03323396f, 0.06076865f, -0.00127151f, -0.01012890f, 0.51371348f, -0.46159038f, 0.02095490f, -0.13330942f, 
    -0.02162147f, 0.02312866f, 0.16762204f, -0.03063813f, 0.10852941f, 0.04777754f, 0.02562419f, -0.00532562f, 
    0.01623933f, -0.03085697f, -0.00286346f, 0.01441271f, -0.00221902f, 0.02428767f, -0.02371575f, -0.04666176f, 
    -0.07000647f, 0.01485817f, -0.01147177f, -0.01501368f, 0.00631347f, 0.04456914f, 0.04589724f, -0.00744264f, 
    -0.00261457f, -0.00751789f, -0.01089137f, -0.08267500f, 0.07400908f, 0.01428061f, 0.05677827f, -0.00720755f, 
    0.00887740f, -0.03856514f, 0.01854862f, 0.01007794f, 0.20566073f, -0.10910652f, -0.27191216f, -0.04001158f, 
    -0.13421193f, 0.02077130f, 0.00492509f, -0.06894331f, 0.10038916f, 0.01035161f, -0.00597586f, 0.02124304f, 
    -0.08756786f, 0.09559691f, 0.00039056f, -0.01098888f, -0.07200837f, -0.12105259f, 0.04154964f, 0.08421793f, 
    -0.12157734f, -0.10721418f, 0.25792605f, -0.03494407f, 0.05939590f, 0.02499366f, -0.06591630f, -0.04772042f, 
    0.00675178f, -0.05083444f, 0.00586261f, -0.02046521f, -0.02787152f, -0.07932324f, -0.07936693f, -0.01116492f, 
    -0.02085843f, -0.02151416f, -0.13013540f, -0.01249747f, 0.61908388f, -0.12520361f, -0.21107335f, -0.23729487f, 
    -0.26838034f, 0.10031424f, -0.07378201f, 0.00545968f, -0.02303511f, -0.08776419f, 0.03123909f, 0.00922724f, 
    -0.10165787f, 0.05842013f, -0.04894156f, -0.08212268f, -0.07000397f, 0.02857940f, -0.07156479f, -0.06947073f, 
    0.14074382f, 0.24515957f, -0.25309357f, 0.12708372f, -0.13509803f, 0.08264178f, 0.07932585f, -0.04501457f, 
    -0.03439260f, -0.00923681f, -0.03227224f, 0.04471127f, 0.02470554f, 0.00012608f, -0.03514536f, 0.02987486f, 
    0.06120710f, -0.03473877f, 0.04460647f, 0.05084553f, 0.04330303f, -0.24330035f, -0.03499434f, -0.22838606f, 
    -0.06534411f, -0.03799156f, 0.04551258f, -0.12941860f, 0.15038142f, 0.06507105f, -0.01305776f, 0.03228771f, 
    -0.02875594f, -0.06160234f, 0.01115930f, -0.03509672f, 0.01944830f, -0.06549892f, 0.04781359f, -0.06400381f, 
    -0.27944401f, 0.24392661f, -0.13004774f, -0.05200392f, -0.09305820f, 0.02380037f, -0.05123198f, -0.00806962f, 
    -0.07375126f, -0.01672710f, 0.06092607f, 0.03687862f, 0.01959625f, 0.02794144f, -0.00886774f, 0.07105330f, 
    -0.07198913f, -0.02608541f, -0.02860123f, 0.01323176f, 0.17432593f, 0.14657347f, 0.06748080f, -0.11330862f, 
    -0.09957677f, 0.01572458f, 0.01760233f, -0.02324225f, -0.01713786f, -0.02196101f, -0.01306233f, -0.15451574f, 
    -0.18741816f, -0.20846613f, -0.15707855f, 0.02144904f, 0.01294538f, 0.03316727f, 0.05528226f, 0.03205399f, 
    -0.23345014f, -0.32916629f, -0.32418141f, 0.14529349f, -0.07665170f, 0.09164779f, -0.01503161f, -0.00073061f, 
    0.04105879f, 0.15110186f, -0.00340793f, -0.01138126f, -0.10576250f, -0.08243565f, -0.06503835f, -0.02071246f, 
    0.14251399f, -0.00534536f, 0.06513996f, 0.04498294f, -0.14950703f, -0.05935996f, -0.13271479f, 0.13069652f, 
    -0.05897834f, 0.01971699f, 0.01086812f, 0.15678899f, -0.04789121f, -0.00797012f, -0.08570175f, 0.07034122f, 
    -0.02839845f, 0.07876039f, -0.03220257f, 0.06300795f, -0.09262899f, -0.09959187f, -0.01607756f, 0.11401368f, 
    0.13909478f, -0.01287436f, -0.08375170f, 0.13380985f, -0.07464518f, 0.11904210f, 0.05718919f, 0.06317819f, 
    -0.01279695f, 0.04521280f, -0.06911739f, -0.13637526f, 0.13345660f, 0.02419747f, 0.00194843f, 0.01588168f, 
    0.04156524f, 0.01557447f, -0.08760779f, -0.03000329f, -0.13409726f, -0.08923151f, 0.04678306f, 0.09763934f, 
    -0.04820452f, 0.00626522f, 0.03110597f, 0.06111295f, 0.04612609f, 0.04927535f, 0.03660233f, 0.02578941f, 
    0.04787215f, 0.04229867f, -0.02755590f, 0.08218425f, 0.00980687f, -0.08745489f, 0.02627510f, 0.03204650f, 
    -0.24991912f, -0.17417896f, 0.21284744f, 0.24648608f, 0.05837721f, -0.01819103f, 0.08486743f, -0.08115920f, 
    -0.03183246f, 0.08012751f, 0.01787362f, 0.01773455f, 0.00607117f, 0.00182675f, 0.00082586f, 0.02313650f, 
    0.05251093f, -0.09266330f, -0.01370037f, -0.00805653f, -0.08734961f, 0.03036683f, 0.09013414f, 0.19077355f, 
    0.05914601f, 0.03296377f, 0.01954769f, 0.09841998f, -0.03284298f, 0.02433624f, 0.05425562f, -0.04983528f, 
    0.03497377f, 0.04771587f, 0.03028297f, 0.04949123f, 0.04406554f, -0.09689558f, -0.08246571f, -0.00433541f, 
    0.20947585f, -0.15222977f, -0.05554916f, -0.05705735f, -0.03782560f, 0.02560563f, 0.06582943f, -0.00534830f, 
    -0.01802782f, 0.04702783f, 0.00355500f, 0.02471509f, 0.06958203f, -0.00874096f, 0.01107807f, 0.01246999f, 
    0.02983732f, -0.09226855f, 0.02133032f, -0.01086942f, -0.10790297f, 0.01742003f, 0.13748065f, 0.04457927f, 
    0.09048088f, -0.01874094f, 0.04210323f, 0.04190136f, -0.03122800f, 0.01588891f, 0.03166532f, -0.06634936f, 
    0.02354311f, -0.03923238f, -0.04662754f, -0.04637566f, -0.05052043f, -0.06446148f, -0.04444795f, 0.00162366f, 
    -0.10903700f, -0.15983339f, 0.11699993f, 0.02750793f, 0.19061217f, -0.00601803f, -0.04132832f, 0.02601454f, 
    0.02562746f, 0.04852042f, 0.13252515f, -0.03607824f, 0.04042824f, 0.00320993f, 0.07136495f, -0.06349820f, 
    0.05985189f, -0.16902447f, 0.10749009f, 0.02416198f, 0.18678726f, -0.28426647f, -0.26964742f, -0.35633394f, 
    -0.15489818f, 0.07002955f, 0.01895521f, -0.08484095f, 0.08011046f, 0.00865577f, 0.03683418f, 0.03111476f, 
    -0.06239124f, 0.00279826f, 0.03625621f, -0.01922897f, 0.01793187f, 0.02204412f, -0.02976022f, 0.00674393f, 
    0.22903331f, -0.03557574f, -0.16353850f, -0.02984935f, -0.07652093f, 0.06000657f, -0.01129660f, -0.01346215f, 
    -0.07371773f, -0.04281676f, 0.02520602f, -0.07202803f, 0.06808427f, 0.02243473f, 0.00533394f, 0.04313889f, 
    -0.03675614f, 0.01309008f, -0.01766390f, -0.03323484f, 0.10003825f, -0.10911281f, -0.19856919f, 0.08986140f, 
    -0.00635143f, 0.09189519f, 0.12040244f, -0.07384164f, -0.04806135f, -0.12154952f, -0.13867882f, -0.02861670f, 
    -0.00611525f, 0.00932796f, -0.05011943f, -0.01014268f, -0.03624100f, 0.03489260f, -0.08732658f, -0.05805363f, 
    -0.34675229f, -0.30626947f, -0.07429722f, 0.12147313f, 0.06384847f, -0.05769835f, 0.08973318f, -0.04746570f, 
    -0.00835295f, 0.05836750f, 0.04233709f, 0.02329127f, 0.02760781f, -0.02839808f, -0.00749357f, -0.00908603f, 
    0.03224956f, -0.05469140f, -0.04551849f, -0.12508588f, 0.12677635f, 0.09792492f, -0.29003492f, 0.00165150f, 
    -0.31027889f, 0.01966512f, -0.06320114f, 0.04195805f, -0.02086430f, 0.01487852f, -0.04319050f, 0.00163269f, 
    -0.03362873f, -0.00832568f, -0.03935635f, 0.06501905f, -0.06512244f, 0.07502428f, 0.01942149f, -0.03302297f, 
    -0.15292555f, -0.23612054f, -0.09983885f, 0.02985237f, 0.11575631f, -0.04950377f, -0.04283826f, 0.00882830f, 
    -0.15769908f, -0.06752998f, 0.01691922f, -0.00443568f, -0.02883720f, -0.00711945f, -0.03956940f, -0.03891655f, 
    -0.07911956f, -0.00206728f, -0.11626524f, -0.01973234f, -0.22016503f, -0.26926818f, -0.15924278f, -0.09394188f, 
    -0.07293437f, -0.06594566f, -0.04669034f, 0.05250311f, 0.10548797f, -0.06830718f, -0.09341400f, 0.01296941f, 
    0.02657157f, 0.02862809f, -0.01838556f, 0.04325684f, -0.00557433f, 0.01241433f, -0.02793546f, -0.01258737f, 
    0.47407562f, -0.48558095f, -0.28758997f, -0.34913066f, -0.18808174f, 0.04061731f, 0.00166023f, -0.11506181f, 
    0.16398616f, 0.09887033f, 0.01280960f, 0.03428435f, -0.01763528f, -0.06611053f, -0.00233254f, -0.03747965f, 
    -0.00752652f, -0.04931507f, 0.02565749f, 0.01457149f, -0.01464945f, -0.35059586f, 0.22324879f, -0.16993728f, 
    0.05795603f, -0.07199884f, 0.01275165f, -0.19483382f, 0.12781619f, 0.07684682f, 0.01936287f, 0.02340937f, 
    -0.07850224f, -0.07996062f, -0.02796377f, 0.00073881f, 0.06893165f, 0.00139451f, 0.06410375f, -0.05066091f, 
    -0.02396264f, 0.01867908f, 0.00476353f, -0.07122566f, -0.02514954f, 0.04426274f, -0.00738024f, -0.01535685f, 
    -0.00964706f, -0.07133576f, -0.05094101f, -0.08940803f, -0.08273048f, -0.02903842f, -0.01921294f, -0.02715859f, 
    -0.00793079f, 0.02677600f, 0.01023684f, -0.01771211f, -0.97043514f, -0.72670352f, -0.04980263f, 0.07889666f, 
    0.39702019f, 0.15026258f, 0.07037762f, 0.18122689f, 0.09412675f, -0.05952630f, -0.03436696f, 0.08476400f, 
    -0.04140031f, -0.07692716f, -0.04103928f, 0.05039218f, -0.02596398f, 0.07757523f, -0.02042550f, -0.04191616f, 
    0.04973438f, 0.23194762f, -0.06215989f, 0.03574280f, -0.17202483f, 0.03763988f, 0.09321610f, -0.06860911f, 
    -0.02294037f, 0.04315433f, -0.01243480f, -0.00224677f, 0.05567895f, 0.00553452f, -0.03372425f, 0.06151291f, 
    0.04753119f, -0.09811077f, -0.10248552f, -0.07079440f, -0.00821289f, 0.01913621f, -0.00563084f, 0.06526800f, 
    0.00159239f, 0.01879199f, 0.02582368f, 0.07542884f, -0.02425806f, -0.03680601f, 0.00764826f, -0.05761246f, 
    -0.07095846f, -0.00411785f, 0.02428757f, -0.04331012f, -0.01059633f, -0.11758041f, -0.01732870f, 0.07660215f, 
    0.13026935f, 0.13376707f, 0.09475799f, 0.04473210f, -0.07049878f, 0.00759679f, -0.02138602f, -0.05019367f, 
    0.03697274f, -0.04952002f, -0.06010952f, -0.00982994f, 0.00776768f, -0.03641095f, 0.02986823f, -0.02436665f, 
    -0.03034851f, -0.17093955f, -0.01921622f, -0.11374520f, -0.05437465f, -0.32169706f, -0.10411498f, 0.01766513f, 
    0.25911114f, 0.11189304f, 0.07282749f, 0.05851498f, 0.00254415f, 0.08518325f, 0.11308510f, 0.10779009f, 
    0.02622857f, 0.06073461f, -0.02202371f, -0.03788573f, 0.02846185f, 0.04740205f, -0.02946840f, 0.01420868f, 
    -0.17982969f, -0.10632896f, 0.14577420f, 0.11144830f, 0.12201662f, 0.02750716f, 0.00607172f, 0.05607555f, 
    -0.03098242f, 0.00989706f, -0.00868631f, -0.00128279f, 0.00898843f, -0.02945381f, 0.01174917f, -0.10685413f, 
    -0.16290857f, -0.05483653f, 0.00061391f, -0.22543307f, -0.25255805f, -0.14646973f, 0.08693258f, -0.02422615f, 
    0.12512772f, -0.05323854f, 0.07103557f, -0.08077361f, -0.00908144f, -0.00055990f, 0.01175716f, 0.05728410f, 
    0.05005519f, 0.14189069f, 0.00955813f, 0.07639915f, -0.00325279f, -0.04259365f, 0.09736416f, -0.05429931f, 
    0.21001987f, 0.16535656f, -0.08419185f, -0.20287451f, -0.10867292f, 0.02276094f, -0.09039913f, -0.13200265f, 
    -0.05445724f, -0.24547242f, 0.03826569f, 0.02428650f, 0.03634131f, 0.06867209f, -0.00338506f, 0.09518389f, 
    0.03864225f, 0.00492719f, -0.07690720f, -0.20656742f, -0.05180995f, -0.32382894f, -0.07158240f, 0.11350822f, 
    0.14340365f, 0.03125352f, -0.03585468f, 0.06764968f, -0.01458458f, 0.20953950f, 0.04151136f, -0.01673550f, 
    0.02411670f, -0.04341782f, 0.00280215f, -0.12151655f, 0.06849055f, 0.04505735f, -0.05355591f, 0.12592342f, 
    -0.22780553f, 0.09097339f, 0.10005179f, 0.07007508f, -0.14635238f, 0.00894746f, -0.02893839f, 0.00426334f, 
    -0.01875556f, -0.04417393f, -0.08714110f, -0.05635649f, -0.03016360f, -0.00538390f, -0.02148403f, 0.07111803f, 
    0.05165226f, 0.03614401f, 0.01021132f, -0.01594923f, 0.11986263f, 0.15924390f, -0.38743383f, -0.14723954f, 
    -0.17351143f, -0.02019596f, -0.01093583f, 0.04832866f, 0.15714234f, 0.02350696f, 0.14781848f, 0.05814224f, 
    -0.02859270f, 0.05085417f, -0.03777488f, -0.04617900f, -0.03618474f, -0.02748890f, -0.03207310f, 0.02811119f, 
    0.00345610f, -0.31500021f, -0.32935017f, -0.17044142f, -0.14367992f, 0.02138076f, -0.17891544f, -0.01531974f, 
    0.06280649f, -0.00787206f, -0.01572392f, 0.03228093f, -0.01835989f, 0.00086887f, 0.02621697f, 0.00352417f, 
    0.02455907f, 0.09795732f, 0.03549161f, 0.09540671f, -0.07523809f, -0.14550352f, -0.06687480f, 0.07126825f, 
    -0.04668447f, -0.00072742f, 0.04856095f, 0.02870461f, 0.03662802f, 0.04312872f, 0.04437730f, 0.02373674f, 
    0.01097957f, 0.04306014f, 0.03968147f, 0.03287439f, 0.12463086f, 0.05693488f, 0.11508655f, 0.03857820f, 
    0.03668980f, 0.12611243f, 0.08309877f, 0.07630774f, 0.08859835f, 0.13238922f, 0.01345701f, 0.10584592f, 
    0.02567805f, 0.02205250f, 0.00847819f, 0.05927956f, -0.01437311f, 0.02040382f, 0.06786036f, 0.05861147f, 
    0.10855354f, -0.02052090f, -0.10481688f, -0.04474414f, -0.22953989f, -0.18448213f, -0.00470783f, 0.06233669f, 
    0.13977951f, 0.02476320f, 0.06236649f, -0.00045129f, -0.00286875f, 0.02253351f, 0.00780396f, 0.04745498f, 
    -0.06243367f, 0.12320058f, 0.01907421f, 0.02547085f, 0.01087351f, 0.01192573f, -0.01539205f, 0.01272939f, 
    -0.12054069f, 0.07852779f, 0.06853923f, -0.01823024f, -0.09024684f, -0.05219096f, -0.02425653f, 0.01432345f, 
    -0.00026424f, -0.03135284f, -0.02723661f, 0.00316937f, -0.00269224f, 0.00191212f, -0.00275451f, 0.03463312f, 
    0.05672751f, -0.02988236f, 0.01133501f, -0.00176197f, 0.37185130f, 0.12324523f, -0.04467546f, -0.21862568f, 
    -0.06754323f, 0.14872672f, -0.11185609f, -0.05538006f, -0.00020579f, -0.20797254f, 0.06550362f, 0.02401080f, 
    0.01116118f, -0.00559741f, 0.02480443f, 0.08060209f, 0.01503444f, 0.02174399f, -0.13438895f, -0.20330168f, 
    -0.18703480f, -0.05785376f, 0.06607022f, 0.00494983f, -0.06316081f, -0.07072948f, 0.03019855f, -0.02272849f, 
    0.01920620f, 0.04449717f, 0.02459294f, 0.05682312f, 0.06181259f, 0.08908111f, 0.08236642f, 0.09545700f, 
    0.02832925f, 0.01516434f, 0.05522841f, 0.05611384f, -0.05393740f, -0.17294721f, -0.13276085f, 0.17608324f, 
    -0.04618571f, -0.00173172f, 0.17112434f, -0.06070504f, -0.13752510f, 0.05208910f, 0.03659757f, 0.06388248f, 
    0.03660800f, -0.00774268f, -0.03244467f, -0.04514929f, 0.10570355f, 0.01796474f, 0.07638817f, 0.08400109f, 
    0.05006022f, -0.11257721f, -0.46022874f, -0.10289579f, 0.15642965f, -0.03576991f, 0.12667958f, 0.19992231f, 
    0.02255174f, 0.03256950f, -0.02083578f, -0.09330294f, -0.02156578f, 0.00558102f, 0.03552833f, 0.00405895f, 
    0.01083169f, 0.01987059f, -0.02800759f, -0.04345651f, 0.33779681f, 0.17948425f, -0.03259781f, -0.18599069f, 
    -0.05818075f, -0.05878574f, 0.17515196f, -0.11122487f, 0.13460599f, -0.11859655f, 0.05138985f, 0.00214474f, 
    0.06863938f, -0.07032839f, 0.14534669f, 0.09704538f, -0.06503446f, -0.13546436f, 0.07200687f, -0.07655256f, 
    0.41177350f, -0.22457215f, -0.38516062f, -0.13807614f, -0.18326531f, 0.01858073f, -0.18665355f, 0.01864536f, 
    0.02333077f, 0.14774407f, -0.03822165f, 0.13576013f, 0.03337047f, -0.04416623f, 0.04485068f, 0.02774080f, 
    0.07048301f, 0.05333187f, 0.00432198f, 0.19245224f, -0.02325157f, -0.40341127f, -0.39046723f, -0.08663312f, 
    0.06532350f, -0.10702049f, 0.12071811f, 0.15326867f, 0.13805820f, 0.11859202f, 0.09270500f, -0.09042930f, 
    -0.06469519f, -0.01226693f, -0.05894493f, -0.00545626f, 0.00391798f, -0.00355704f, -0.00016639f, -0.05355726f, 
    0.05480283f, 0.11966418f, 0.11859675f, -0.02045543f, -0.02000851f, -0.01782644f, -0.01719204f, -0.04379406f, 
    0.02331803f, -0.00062490f, 0.02616926f, -0.08216472f, 0.01127811f, -0.03251169f, -0.01568941f, -0.09563616f, 
    0.05444347f, 0.08315160f, -0.09660713f, -0.05515924f, -0.03376976f, 0.07405236f, 0.05551270f, -0.03234375f, 
    -0.14115418f, -0.02334740f, -0.01440016f, 0.00749874f, -0.00117942f, -0.02569235f, -0.02426932f, 0.01147163f, 
    0.03386833f, 0.07099023f, 0.09440813f, 0.02010890f, 0.07268756f, -0.03360824f, 0.04138789f, 0.04116464f, 
    -0.16287650f, -0.03426498f, -0.01022530f, -0.01430640f, 0.06939097f, 0.03261696f, 0.03850152f, 0.00489714f, 
    0.05435625f, 0.00108430f, 0.05930214f, 0.06536832f, 0.02008440f, 0.02484169f, 0.02214704f, 0.03860516f, 
    0.05740646f, 0.06756148f, 0.06892567f, -0.00640305f, -0.09996349f, -0.40108398f, -0.36078438f, -0.08315496f, 
    0.05958030f, -0.05019318f, 0.07363623f, 0.10468005f, 0.08454215f, 0.14195783f, 0.03832633f, -0.09933561f, 
    -0.09794552f, -0.04614388f, -0.03093929f, -0.03011001f, 0.03445642f, -0.03363802f, 0.03573434f, -0.01668422f, 
    0.20059507f, -0.07864728f, -0.10937889f, -0.12911011f, 0.00851621f, 0.01602247f, 0.07199550f, -0.03269548f, 
    0.00086856f, 0.06094901f, 0.00733231f, -0.00527790f, -0.01869770f, -0.01194069f, -0.01987121f, 0.02838461f, 
    0.01658334f, 0.05285521f, 0.14553787f, 0.06800309f, -0.34070989f, 0.09981839f, 0.12022874f, 0.03857539f, 
    -0.10064119f, -0.04470539f, -0.02066577f, -0.06696752f, -0.04712555f, -0.04579053f, -0.07683288f, -0.04992195f, 
    -0.03149503f, -0.02464283f, -0.01024673f, 0.00681556f, -0.00036494f, 0.00573118f, 0.00111178f, -0.01960384f, 
    -0.14357238f, -0.06699002f, 0.11492204f, 0.07397719f, -0.07854825f, -0.04104666f, -0.00555106f, -0.03392681f, 
    0.07330579f, -0.07205267f, -0.03045161f, 0.03958110f, 0.05719480f, 0.04107734f, 0.09634550f, 0.07090912f, 
    0.10410195f, -0.03299667f, -0.00138354f, 0.04518302f, -0.18645707f, -0.43174782f, 0.13360628f, 0.00396897f, 
    0.19970211f, -0.08962832f, 0.10110199f, -0.00862619f, -0.04261437f, -0.06040502f, 0.05009683f, -0.06737184f, 
    -0.04898822f, 0.01283218f, -0.04455327f, -0.02599264f, -0.03921269f, -0.01632781f, -0.06381859f, -0.08601017f, 
    -0.03098889f, -0.30807704f, -0.45836589f, -0.31814528f, 0.09587252f, -0.01813165f, 0.18173495f, 0.10169741f, 
    0.18887024f, 0.01188798f, -0.02038529f, -0.02810928f, -0.06159424f, 0.01021687f, -0.00514321f, 0.04627613f, 
    0.00139743f, -0.00950059f, -0.02402236f, -0.03986418f, -0.18902935f, -0.30310908f, -0.15798533f, 0.01860064f, 
    -0.08135372f, 0.03409000f, 0.03033094f, 0.01864530f, 0.01644339f, -0.06356370f, 0.00250600f, 0.02984488f, 
    0.05574671f, 0.01724671f, 0.02429904f, 0.05588112f, 0.02538765f, 0.13409591f, 0.01843407f, -0.01715576f, 
    0.10115863f, -0.09221628f, -0.02160499f, 0.12677059f, 0.14367627f, 0.08139562f, 0.02113040f, 0.10817435f, 
    0.02286466f, 0.04543535f, 0.05763146f, 0.02035225f, 0.07851481f, 0.05215264f, 0.11332191f, 0.03802328f, 
    0.08458247f, -0.01236673f, -0.05004861f, -0.06187354f, -0.05620755f, -0.05939199f, 0.05380188f, -0.10014152f, 
    -0.15058464f, -0.08308455f, -0.00537580f, -0.01428990f, -0.01137464f, -0.08910031f, 0.00493452f, 0.11136858f, 
    0.09687925f, 0.08188286f, 0.08683281f, 0.02766305f, 0.06828298f, -0.04044539f, 0.03466323f, 0.02603643f, 
    0.21942189f, 0.06299897f, -0.02745471f, -0.02478639f, -0.11370536f, -0.02585018f, -0.07051390f, -0.05832534f, 
    -0.01053251f, -0.14855449f, -0.05533342f, 0.05147817f, 0.06408460f, 0.00746653f, 0.02045358f, -0.00767655f, 
    0.07043676f, 0.08786376f, 0.13231120f, 0.12662044f, -0.35310605f, -0.61536682f, -0.61738098f, -0.39529887f, 
    -0.12568760f, -0.07428090f, -0.08606823f, 0.05417062f, 0.07101113f, -0.02730016f, -0.05926523f, -0.02531119f, 
    -0.08425853f, -0.03509043f, 0.00341887f, 0.00342184f, 0.00919271f, 0.02206888f, 0.08792152f, 0.12502988f, 
    0.06503518f, -0.03046885f, -0.05729079f, 0.04685294f, -0.08245952f, -0.06977399f, -0.02517431f, -0.03626039f, 
    -0.03866657f, 0.05723953f, 0.07777307f, 0.05043415f, 0.00374810f, -0.06211660f, 0.06079929f, -0.05037018f, 
    0.09609291f, 0.06348217f, 0.12965153f, 0.06675658f, 0.18386932f, 0.11065479f, -0.21051481f, -0.02516067f, 
    -0.01791537f, 0.02983106f, -0.02698994f, -0.00746249f, 0.03336992f, -0.05054888f, 0.02217298f, 0.02990434f, 
    0.00595336f, 0.00511451f, 0.02720592f, 0.04247347f, -0.03452991f, -0.06152715f, -0.21900100f, -0.26492831f, 
    -0.06715680f, -0.14447823f, 0.03992421f, 0.05641494f, 0.10190064f, 0.01687716f, 0.10172358f, 0.05498432f, 
    0.04551163f, 0.01463524f, 0.03046829f, 0.05589636f, 0.03165409f, 0.05175348f, 0.06385484f, -0.02718720f, 
    -0.14468311f, -0.03132058f, -0.03698453f, -0.10090551f, 0.20940596f, -0.60136598f, -0.56977499f, -0.37863079f, 
    0.14049655f, 0.02218629f, 0.28685915f, 0.00654138f, 0.23813900f, -0.01650015f, -0.03270753f, 0.01480734f, 
    -0.00883868f, -0.00416250f, -0.04352510f, 0.10455056f, -0.02474509f, -0.05923840f, -0.01443226f, -0.02949432f, 
    0.12834930f, 0.22279149f, 0.20750371f, 0.08258396f, -0.22089952f, 0.01471180f, -0.05281159f, -0.03572438f, 
    0.02228413f, -0.07139578f, 0.01193071f, -0.03275834f, -0.01163532f, -0.02610748f, 0.00954247f, -0.11590838f, 
    -0.15750514f, -0.16968374f, -0.11398910f, -0.17289779f, 0.04749159f, -0.09430062f, -0.35624817f, -0.24079615f, 
    -0.01966555f, -0.02314557f, -0.15439969f, 0.06939270f, -0.05131014f, -0.13236843f, -0.01914415f, -0.03240412f, 
    0.00190852f, 0.02485542f, 0.04719352f, 0.01465081f, -0.03193355f, 0.08130317f, -0.00904960f, -0.08041839f, 
    -0.43147933f, 0.16145073f, 0.16279520f, 0.10751403f, -0.07562836f, 0.00989889f, 0.00323326f, -0.12354757f, 
    0.00596555f, -0.05757422f, -0.07898438f, -0.06637621f, 0.03004729f, -0.01422312f, -0.03364686f, 0.02716643f, 
    -0.04411589f, -0.03369967f, -0.04607462f, -0.06540811f, -0.10841954f, -0.14899464f, -0.12128218f, -0.15900914f, 
    -0.16272333f, -0.09039827f, -0.00973880f, 0.00413818f, 0.02316060f, -0.05529532f, 0.15432860f, 0.08170629f, 
    0.12308145f, 0.07057860f, 0.06551564f, 0.01499254f, 0.01498620f, -0.00500517f, 0.05575792f, 0.04580807f, 
    0.05217405f, -0.14381433f, -0.33308026f, -0.25125268f, -0.08217096f, -0.17258927f, -0.06995640f, -0.09157597f, 
    -0.13861324f, -0.27069592f, 0.02672739f, -0.00538384f, 0.01158934f, 0.13570839f, 0.06123552f, 0.08779959f, 
    0.07215131f, 0.09392859f, -0.16338909f, -0.27450952f, -0.27602986f, -0.28099862f, 0.18788256f, 0.01816287f, 
    0.13673285f, -0.07309473f, -0.01219977f, -0.04436287f, -0.07448259f, -0.01505382f, 0.04035315f, -0.00048786f, 
    0.06333091f, 0.07748188f, -0.00195084f, -0.02897099f, 0.02239393f, -0.09250052f, -0.03977984f, -0.12512751f, 
    0.15582532f, -0.02712648f, -0.06387750f, -0.03037883f, -0.06723239f, -0.02857832f, -0.00812721f, 0.05472698f, 
    -0.01293895f, -0.14542657f, -0.00226766f, 0.13085023f, -0.01289131f, 0.01075569f, 0.00801828f, -0.05496680f, 
    0.04950020f, 0.10532083f, 0.16425970f, 0.08545007f, 0.02029154f, -0.04366882f, -0.00376168f, 0.00114493f, 
    -0.20356759f, -0.05062695f, -0.13915919f, -0.17007032f, -0.04856360f, -0.10331832f, -0.01917415f, 0.13217753f, 
    0.05856600f, -0.01347518f, -0.01707829f, 0.03220873f, 0.09220426f, 0.16185504f, 0.14626484f, 0.16717120f, 
    0.30744773f, 0.09748007f, 0.20280939f, -0.04851400f, -0.15468028f, 0.00209700f, -0.23090285f, -0.13188706f, 
    -0.13200979f, -0.19987026f, -0.03512730f, 0.00579728f, 0.00554146f, 0.00665400f, 0.02196859f, 0.07218187f, 
    0.03713254f, -0.03807038f, -0.06670462f, -0.33568698f, -0.45249915f, -0.19229902f, 0.26812923f, 0.10746077f, 
    0.12189410f, -0.11553115f, 0.01875647f, -0.07641833f, -0.09233565f, -0.04646866f, -0.05985261f, 0.00245944f, 
    0.03412300f, -0.05746649f, -0.06797518f, -0.17792879f, -0.16842271f, -0.11441552f, -0.17326431f, -0.09125949f, 
    -0.06924412f, -0.15045951f, -0.19012742f, -0.02213436f, 0.03783007f, -0.02172984f, -0.04045751f, 0.05389864f, 
    0.09496028f, 0.13693957f, -0.01684370f, -0.01307207f, -0.02715708f, -0.02569075f, -0.00235776f, -0.04883648f, 
    0.06518904f, 0.13268186f, 0.03821028f, 0.08301845f, -0.43209645f, -0.12469060f, 0.15826300f, 0.11880901f, 
    0.13139234f, -0.01143246f, -0.01692093f, -0.03718520f, -0.07768562f, 0.01544421f, -0.01192297f, -0.03169833f, 
    0.02236230f, 0.00519145f, -0.00248038f, -0.06208294f, -0.00030855f, 0.00217084f, -0.07136294f, 0.08288547f, 
    0.42348129f, 0.01380979f, -0.12705903f, 0.04122331f, -0.02812931f, 0.05309608f, -0.06726450f, -0.11952695f, 
    0.04195132f, 0.06324085f, 0.11307506f, 0.01024068f, 0.03520493f, -0.10717520f, 0.07212346f, -0.18784158f, 
    0.08651581f, 0.06263870f, -0.03054021f, 0.09916956f, -0.01473023f, -0.20047240f, -0.44707957f, -0.29577714f, 
    0.00119514f, -0.05971589f, -0.00629440f, 0.09642263f, 0.01350849f, -0.10442199f, 0.03122005f, -0.02457438f, 
    -0.05329041f, 0.02446767f, 0.01338515f, 0.03868122f, -0.00063781f, 0.01643249f, 0.01855944f, -0.01178009f, 
    0.09060439f, -0.12546331f, -0.05714358f, -0.04499391f, -0.03953515f, -0.09988094f, 0.02474311f, -0.01381149f, 
    0.04674466f, 0.05474884f, 0.06934357f, 0.05866151f, -0.04900789f, -0.04208977f, -0.05222854f, 0.01227538f, 
    0.14326400f, 0.02974532f, 0.08859830f, 0.05703421f, 0.39667469f, -0.00961489f, -0.12535027f, -0.00348315f, 
    -0.06757686f, 0.05469565f, -0.07372709f, 0.01127136f, -0.06774978f, -0.03920574f, 0.04402274f, 0.05873258f, 
    -0.03149963f, 0.09860882f, -0.06983944f, 0.01706196f, -0.00139055f, 0.03177247f, 0.11570546f, 0.06118980f, 
    0.07383649f, -0.08268810f, -0.14537022f, 0.00627691f, 0.06655032f, -0.07260711f, -0.03823861f, 0.06741109f, 
    0.07794239f, 0.08158635f, -0.01405241f, -0.01378726f, 0.02321781f, -0.00412145f, 0.03755156f, -0.01730779f, 
    0.06084229f, 0.07738883f, 0.02149281f, 0.10772414f, 0.24522652f, -0.15008365f, -0.12708502f, -0.15285999f, 
    -0.00412419f, -0.00710561f, 0.13155116f, 0.02821144f, 0.03731107f, 0.07454003f, 0.09039255f, -0.03562215f, 
    -0.01112084f, 0.02074361f, 0.01976364f, -0.00600696f, 0.02935338f, -0.04328859f, -0.00791896f, -0.14648519f, 
    0.61475253f, 0.09080123f, 0.05443151f, 0.15254502f, 0.00658195f, 0.13407990f, 0.00597291f, -0.04207952f, 
    0.01657302f, 0.12903015f, 0.04037739f, 0.00299789f, 0.01873182f, 0.00261064f, -0.00695914f, -0.05563190f, 
    0.03110706f, 0.01641329f, -0.00595846f, -0.09075197f, 0.08321845f, -0.30446148f, -0.19621603f, 0.03758857f, 
    0.06741921f, 0.00923957f, -0.02568667f, -0.03099143f, 0.00760181f, 0.09441230f, 0.01739551f, -0.00466795f, 
    -0.01847447f, -0.01993209f, -0.00525573f, -0.03780345f, 0.07420785f, 0.05847889f, 0.09792141f, 0.04654963f, 
    -0.18005213f, -0.20769669f, -0.61680162f, -0.39286044f, -0.12009031f, -0.06620471f, -0.01054111f, 0.09645577f, 
    0.08441030f, -0.08528681f, -0.00576675f, -0.02986378f, -0.04270249f, 0.06166754f, 0.01942920f, 0.04100763f, 
    -0.00428134f, -0.01449515f, 0.01155348f, -0.03443899f, 0.12222853f, 0.07550251f, -0.18748571f, -0.18018299f, 
    -0.04926304f, 0.07699974f, -0.16095214f, 0.05885984f, 0.07336655f, -0.02651298f, 0.01480637f, 0.01955956f, 
    0.00967357f, 0.09658146f, 0.02712569f, 0.03637958f, 0.01918214f, -0.02729292f, -0.16997513f, -0.33170947f, 
    0.01888578f, -0.00953590f, -0.05448345f, 0.01094302f, 0.01741859f, 0.00417452f, 0.01478671f, 0.00685670f, 
    -0.01764932f, -0.00640374f, 0.02258191f, 0.09173124f, 0.04453659f, 0.01584175f, 0.05407890f, -0.00418775f, 
    0.04393671f, 0.10006112f, 0.06440716f, 0.11367229f, 0.15525241f, -0.72149539f, -0.49610233f, 0.09236181f, 
    0.20354448f, 0.16050196f, 0.01578305f, 0.07941221f, -0.24020645f, -0.12461757f, 0.01461404f, -0.04731128f, 
    0.03229217f, 0.01908383f, 0.01416290f, 0.01386116f, -0.02335380f, 0.05263069f, -0.06549689f, -0.07543024f, 
    -0.00980875f, 0.14691421f, 0.16137396f, 0.08430643f, -0.14553398f, -0.04544518f, -0.12198522f, -0.04797417f, 
    -0.02716510f, -0.14278625f, -0.03355695f, -0.05606613f, -0.03827130f, -0.04733552f, -0.04296342f, -0.04604629f, 
    -0.10660756f, -0.22765012f, -0.16825768f, -0.12592691f, -0.18052422f, -0.06019236f, 0.09468088f, 0.07730055f, 
    0.00050754f, -0.09303568f, 0.00351904f, -0.03515770f, -0.02243485f, -0.04260211f, -0.00762616f, 0.04583466f, 
    0.05880968f, 0.02060059f, 0.05364463f, -0.01358436f, -0.02105805f, -0.01648237f, 0.00727245f, 0.04341513f, 
    -0.16800074f, 0.03415717f, -0.13750814f, 0.14000376f, -0.01842730f, 0.04939271f, -0.11738707f, 0.05984201f, 
    -0.01006262f, 0.00898247f, -0.01379410f, -0.02078024f, 0.01008632f, 0.02732717f, -0.09142910f, -0.01444782f, 
    0.02655210f, 0.06192290f, 0.01509278f, 0.10009047f, -0.11416529f, -0.25558183f, 0.46200979f, -0.39998215f, 
    -0.53225547f, 0.04261536f, -0.23892137f, -0.00565989f, 0.03054755f, 0.04708906f, -0.04287118f, 0.04107317f, 
    0.00769399f, 0.02034379f, -0.00195196f, 0.04559561f, -0.07633232f, -0.03846218f, -0.03653433f, 0.00151931f, 
    0.16135564f, -0.40225044f, -0.28966451f, -0.07214924f, 0.09544931f, 0.00137223f, -0.04728308f, 0.11906014f, 
    0.06977464f, 0.10779257f, 0.00258965f, 0.00421259f, 0.00019426f, -0.04878435f, 0.00464692f, 0.00484596f, 
    0.15697390f, 0.13958591f, 0.00829632f, 0.11825632f, -0.04881597f, -0.07989866f, -0.01488472f, -0.25352702f, 
    -0.04375901f, -0.02049255f, -0.07545030f, 0.06307437f, -0.02635640f, -0.03482466f, 0.00817484f, 0.10110574f, 
    -0.02888766f, 0.04343276f, -0.00162798f, 0.06603650f, -0.02541506f, 0.04258846f, -0.03896596f, 0.04716515f, 
    -0.48137838f, 0.02610915f, -0.52162671f, 0.01841878f, -0.25016993f, 0.12904975f, -0.15364893f, 0.06914117f, 
    -0.03583156f, 0.10957971f, 0.03982467f, -0.00301527f, 0.03173723f, 0.04312119f, -0.04045400f, 0.01475501f, 
    -0.02573752f, 0.11937695f, 0.13607793f, 0.09838593f, 0.09279250f, -0.42599556f, 0.44788712f, -0.50810909f, 
    -0.27477631f, -0.05643713f, -0.03826728f, -0.12226073f, 0.07332928f, 0.21236190f, 0.02469833f, 0.03174084f, 
    0.08157517f, -0.01960571f, -0.08973449f, 0.01873128f, 0.02126292f, -0.07056628f, -0.03504372f, -0.05124417f, 
    -0.27607566f, -0.00365765f, -0.36661577f, -0.08816779f, -0.08601476f, 0.10335407f, -0.05136836f, 0.17809828f, 
    -0.01741461f, 0.02047167f, 0.06579863f, 0.00968828f, 0.02545499f, 0.03544674f, -0.01509882f, -0.01056372f, 
    0.05126885f, 0.05718374f, 0.01952018f, 0.03710184f, -0.58666676f, -0.04247314f, -0.12625276f, 0.32529142f, 
    0.01522245f, -0.36088458f, 0.30941015f, -0.33370745f, 0.12364504f, -0.06956232f, 0.04381201f, -0.05419824f, 
    0.00220618f, 0.03371448f, -0.00353825f, 0.07032356f, 0.12202559f, -0.01758111f, -0.07386705f, -0.03888935f, 
    -0.05192237f, -0.19408590f, -0.03532810f, 0.16487721f, -0.20594500f, 0.00737601f, -0.13753371f, 0.19915195f, 
    0.09287366f, 0.15612543f, 0.06783599f, -0.00222238f, 0.01071151f, -0.03311326f, -0.01987751f, 0.02353672f, 
    -0.06512661f, 0.07497552f, 0.06341922f, -0.14786366f, 0.07216259f, 0.07243264f, 0.14494443f, -0.13705100f, 
    0.03127382f, -0.05943920f, 0.01139068f, -0.10989103f, -0.04189427f, -0.04810626f, 0.02853605f, 0.02182933f, 
    0.00293855f, 0.07334619f, 0.04372441f, -0.08440154f, -0.01677922f, -0.06534689f, -0.06645700f, 0.02220529f, 
    -0.00255467f, -0.15581976f, -0.19127336f, -0.10731812f, 0.04604787f, -0.01890106f, 0.08069271f, 0.06256776f, 
    -0.11336769f, 0.09913807f, 0.02446036f, 0.00849651f, -0.01701765f, -0.02709295f, -0.08886287f, -0.01580932f, 
    0.03564314f, 0.01546343f, -0.03171295f, 0.00931137f, 0.09975115f, 0.04714818f, 0.09347236f, -0.17478903f, 
    -0.18048495f, -0.08379776f, -0.01479306f, 0.05013075f, -0.02750444f, 0.01979030f, 0.00794347f, 0.02426492f, 
    -0.07367544f, 0.08064688f, 0.03037896f, -0.02261103f, -0.01823023f, 0.07785515f, -0.01077028f, -0.04548407f, 
    -0.10529394f, -0.04083626f, -0.15287466f, -0.03367047f, 0.05950090f, 0.03770409f, 0.10127208f, 0.15842658f, 
    0.02183853f, -0.03925036f, 0.00833739f, 0.06213509f, 0.03226045f, -0.02287690f, -0.01796896f, 0.02691350f, 
    0.12366552f, 0.04068236f, -0.00439170f, 0.05531570f, -0.57859397f, -0.18010265f, -0.29570976f, -0.21039771f, 
    -0.02425253f, -0.11490015f, -0.09563355f, 0.13358408f, -0.12317077f, 0.15713161f, 0.03960133f, -0.00154885f, 
    0.02127332f, -0.01557062f, -0.12514600f, 0.07433977f, 0.00136291f, 0.02986961f, 0.11622299f, 0.01290556f, 
    -0.00844620f, -0.06916489f, 0.04742936f, -0.15354082f, 0.04667192f, 0.02807840f, 0.05022157f, 0.01562293f, 
    -0.04013406f, -0.01770610f, 0.08251563f, 0.03852913f, -0.07009462f, 0.05079365f, -0.00472406f, -0.02478790f, 
    0.06806938f, -0.02630828f, -0.01585848f, 0.04654646f, 0.08757453f, 0.27119607f, 0.24230483f, -0.76780903f, 
    -0.00047196f, 0.03922093f, -0.18970546f, 0.02861572f, -0.00340093f, 0.00146616f, -0.05556575f, -0.07635543f, 
    -0.00909956f, 0.00232422f, -0.13235034f, -0.04155241f, 0.02944864f, -0.12318774f, -0.20804708f, 0.02261620f, 
    0.08224809f, -0.08422074f, -0.10824549f, -0.18376502f, -0.38759005f, -0.24615858f, -0.05179203f, -0.20387924f, 
    0.13176799f, -0.00439956f, 0.02500694f, 0.00352707f, -0.00913347f, 0.08429135f, 0.03538938f, 0.06898423f, 
    0.05412425f, 0.02394407f, 0.01331161f, 0.06433873f, -0.73662573f, 0.03955369f, -0.32278955f, 0.12703802f, 
    0.10767959f, -0.02170961f, -0.03976079f, 0.05281613f, -0.13577317f, -0.15355237f, 0.00752900f, -0.03293538f, 
    -0.00952018f, -0.07658324f, -0.02942829f, -0.01317913f, 0.03920133f, -0.09249681f, 0.01508690f, 0.10766777f, 
    0.10546261f, -0.26922780f, -0.22633903f, 0.08091805f, -0.34021825f, -0.30427423f, 0.13489033f, 0.15072586f, 
    0.06694924f, 0.03598566f, 0.01266176f, -0.03819471f, -0.01435836f, -0.08432233f, 0.04399195f, 0.04651221f, 
    -0.02220013f, -0.01770076f, -0.01580569f, -0.20975435f, 0.22680686f, 0.17601447f, 0.27458549f, 0.34409562f, 
    -0.28119045f, 0.10008933f, -0.09284909f, -0.24694294f, -0.06585417f, -0.17739281f, 0.05461944f, -0.00100620f, 
    0.06401882f, 0.07262284f, 0.02997462f, 0.06684937f, 0.01645595f, -0.00110168f, 0.03578298f, 0.05158113f, 
    -0.10519314f, -0.05398935f, -0.04889081f, -0.03253443f, 0.09579882f, -0.03979155f, 0.03962887f, 0.02237074f, 
    0.06431340f, -0.10733646f, -0.06455181f, 0.05247736f, 0.02218202f, -0.13062321f, -0.05052896f, 0.05821829f, 
    0.05780073f, -0.13826226f, 0.02240265f, 0.06829815f, -0.18596813f, 0.01405911f, -0.06460559f, 0.07943898f, 
    0.12721625f, 0.02391057f, 0.12489193f, 0.10727560f, -0.00729039f, -0.07802209f, 0.02098648f, 0.09215503f, 
    0.01325111f, -0.08391877f, 0.01428091f, 0.09344824f, -0.01070868f, 0.00300026f, -0.00385972f, 0.03210818f, 
    0.05234635f, 0.05921197f, 0.13991164f, -0.09346538f, -0.09964056f, 0.07661170f, -0.06682150f, 0.02712753f, 
    -0.03365375f, -0.11448538f, -0.04494220f, 0.09584554f, 0.02292022f, 0.01302207f, 0.04028259f, 0.01741204f, 
    0.00950603f, 0.02560506f, -0.04706473f, 0.03735549f, -0.09789440f, -0.07941394f, 0.34986329f, 0.21973333f, 
    -0.40147898f, 0.12134618f, -0.26302490f, -0.19696352f, 0.04763139f, -0.00113074f, -0.01302007f, 0.01390180f, 
    0.00453722f, 0.02611833f, 0.00666525f, -0.03193822f, -0.05936931f, -0.01203346f, 0.00132122f, 0.05824634f, 
    -0.10610206f, 0.10316978f, 0.02969705f, 0.06661677f, -0.09234865f, 0.06733068f, -0.12375028f, -0.02031224f, 
    0.01409145f, -0.08866090f, 0.01104676f, -0.03667208f, -0.03923072f, -0.00740226f, -0.02816130f, 0.03698123f, 
    -0.08920746f, -0.04856757f, -0.00097997f, -0.08006072f, -0.12623423f, -0.08109634f, -0.16502905f, -0.17164189f, 
    0.17111973f, 0.05958607f, 0.06346960f, 0.10545070f, 0.05578571f, 0.01013805f, 0.03061235f, 0.04229731f, 
    0.05935032f, 0.01378751f, -0.03702213f, 0.00761781f, 0.07725191f, -0.02563077f, -0.00939276f, 0.00258984f, 
    -0.24785106f, 0.20605652f, -0.20994854f, 0.01021739f, -0.09553500f, 0.04699427f, -0.04804823f, 0.05084592f, 
    -0.08661365f, 0.04459022f, 0.06106843f, 0.00430583f, -0.04371974f, 0.13398640f, 0.01807275f, -0.02195344f, 
    0.02363909f, -0.00605611f, -0.03833800f, 0.00272205f, 0.14433560f, -0.06837280f, 0.09787466f, 0.14032708f, 
    -0.27140155f, -0.02205161f, -0.06766272f, -0.14414316f, 0.06232443f, -0.16380641f, -0.03107899f, 0.04459935f, 
    0.03587263f, 0.05370668f, -0.04910580f, 0.08245695f, 0.05040557f, 0.02175732f, 0.00009245f, 0.09328473f, 
    -0.00283224f, 0.22319771f, 0.19742349f, 0.35066348f, -0.52394611f, 0.13476589f, -0.06602006f, -0.09239817f, 
    -0.02021034f, -0.01055195f, 0.04756778f, -0.06570075f, 0.00168270f, 0.04170130f, -0.04000857f, 0.06814113f, 
    0.04123997f, 0.01558611f, 0.00142930f, 0.03182261f, 0.09730288f, 0.21352094f, 0.00143607f, 0.00969599f, 
    -0.08775087f, -0.20291527f, 0.08227514f, 0.04560540f, 0.05359186f, 0.15205157f, -0.05645707f, 0.03423532f, 
    0.03420709f, -0.03445712f, 0.02669535f, -0.03521942f, 0.01596133f, 0.03904143f, -0.01330982f, -0.07375057f, 
    0.20037349f, -0.62384892f, -0.04135106f, -0.14550163f, 0.10073528f, -0.19361693f, -0.00835221f, 0.01388292f, 
    0.09046730f, 0.07855188f, -0.03914162f, -0.02873808f, -0.01130655f, 0.00839290f, 0.00418705f, 0.04827682f, 
    0.06292994f, 0.09887584f, -0.05926496f, -0.04021899f, -0.32796559f, 0.09796776f, -0.15577780f, -0.02512238f, 
    0.09205572f, -0.06256479f, -0.02026428f, -0.05789861f, -0.11892444f, -0.01544866f, 0.09734175f, 0.07557929f, 
    0.04674956f, -0.00291561f, -0.10748104f, 0.13786116f, 0.11875340f, -0.06229071f, -0.03328568f, 0.09872326f, 
    -0.18483271f, 0.39789841f, -0.42880878f, -0.01277273f, -0.10253658f, 0.05042570f, 0.06643606f, 0.17376095f, 
    -0.02201274f, -0.02175238f, 0.10619897f, -0.03958491f, -0.08881605f, -0.08204139f, -0.06121939f, 0.08091176f, 
    -0.04147158f, -0.19100714f, 0.02210534f, -0.14270385f, -0.43488327f, -0.20850593f, 0.21759561f, 0.15744659f, 
    -0.30203047f, -0.14088921f, -0.12641542f, 0.05158492f, 0.14155324f, 0.20080692f, 0.03689057f, 0.00524111f, 
    -0.03779785f, 0.00661323f, -0.04516872f, -0.01841822f, -0.00327077f, 0.06026188f, -0.05009961f, -0.15103036f, 
    0.07492683f, -0.01192272f, 0.09782506f, -0.01440449f, 0.10051665f, -0.02215724f, 0.06159141f, -0.12712286f, 
    -0.05956962f, -0.04792976f, 0.03425584f, 0.06555051f, 0.01645630f, -0.02284724f, 0.00922442f, -0.00688398f, 
    0.00875183f, -0.09470098f, -0.08678066f, 0.06513084f, -0.01180287f, 0.17346421f, -0.01276613f, 0.35422310f, 
    -0.04402722f, 0.05662991f, -0.04244994f, -0.06497898f, -0.00795062f, 0.01465864f, 0.07499731f, -0.09341427f, 
    0.08587156f, -0.02504186f, -0.02868056f, 0.03420088f, 0.01429774f, 0.06341010f, 0.08982074f, 0.19821569f, 
    -0.01082583f, -0.09562850f, -0.16417030f, -0.29951864f, 0.01933074f, -0.08918644f, 0.00391329f, -0.04650092f, 
    -0.03682817f, 0.13236730f, 0.02598704f, 0.02299664f, -0.01167911f, -0.00360880f, 0.01919901f, -0.05119216f, 
    0.14450620f, 0.11027247f, -0.03538725f, 0.06865995f, -0.49131474f, -0.08347734f, 0.32890186f, 0.33359116f, 
    -0.61708617f, 0.27010608f, -0.19128984f, -0.18998012f, -0.25511456f, 0.00821659f, 0.04676348f, -0.01241500f, 
    0.00205962f, 0.02125326f, 0.02062554f, -0.08947384f, -0.03925851f, -0.00673627f, -0.00564800f, 0.11971620f, 
    -0.17233410f, -0.09739719f, -0.25489768f, 0.00081564f, -0.01323310f, 0.10727696f, 0.01518886f, 0.09099035f, 
    -0.01410921f, 0.08731028f, -0.00197415f, -0.12876831f, 0.05029815f, -0.00010446f, -0.09283876f, 0.11478301f, 
    0.04732005f, 0.06219975f, 0.14417993f, 0.21141458f, -0.03344351f, -0.15203184f, -0.00708067f, 0.08788908f, 
    -0.24366379f, -0.08922765f, 0.03441185f, -0.02887156f, 0.06124495f, 0.08439077f, 0.02794503f, 0.01574580f, 
    0.03155553f, 0.06036272f, 0.02868898f, -0.05335194f, 0.06722728f, 0.02578187f, 0.06420659f, 0.03778996f, 
    -0.27907792f, 0.14899728f, -0.47828978f, -0.12133181f, -0.02025074f, 0.14646764f, 0.08514684f, 0.19725083f, 
    0.06172866f, 0.13429482f, 0.09689873f, -0.07159182f, -0.05657367f, -0.08254170f, -0.05286325f, 0.03306076f, 
    0.10709601f, -0.13071045f, 0.03255270f, -0.09655318f, -0.14704427f, 0.24924845f, 0.10209147f, 0.26318786f, 
    0.21448001f, -0.02641732f, -0.03780874f, -0.08781844f, -0.05263263f, -0.09461007f, 0.06028692f, 0.05435389f, 
    0.01502074f, -0.04751126f, -0.06340449f, 0.09155260f, 0.01036860f, -0.08432829f, -0.01514366f, -0.01219548f, 
    -0.29299602f, -0.15383767f, 0.06750775f, 0.03664947f, -0.10612681f, 0.06631705f, -0.17882048f, -0.02805126f, 
    0.05197853f, 0.16063625f, 0.04693222f, 0.01172753f, 0.06780252f, 0.09236042f, -0.04598574f, 0.02204303f, 
    0.11217172f, 0.07660762f, 0.14090385f, 0.17461027f, -0.01859985f, -0.18771437f, -0.05653639f, -0.21775347f, 
    -0.06086438f, 0.04872058f, -0.15729237f, 0.04965902f, 0.01674575f, -0.10733296f, -0.10170919f, 0.06509435f, 
    0.00422683f, 0.00162175f, 0.04504566f, 0.10901972f, 0.00593694f, 0.05651430f, -0.09714585f, 0.19065104f, 
    -0.25500157f, 0.01206115f, -0.17941175f, -0.06171693f, 0.09671566f, -0.01502920f, 0.13111253f, -0.01858793f, 
    -0.17392592f, 0.04181376f, 0.04737710f, 0.04256537f, -0.06473779f, -0.00089269f, -0.01429936f, 0.10225120f, 
    0.07356028f, -0.12461172f, -0.14909862f, -0.10577557f, 0.19876392f, 0.24110727f, -0.19303735f, 0.03061868f, 
    -0.19505629f, -0.01022131f, 0.21817620f, 0.18828642f, 0.01566592f, 0.04847704f, -0.00618153f, -0.08146249f, 
    -0.05695217f, -0.10115675f, -0.00603861f, 0.03851733f, -0.13745607f, -0.00107935f, -0.10296387f, -0.17606048f, 
    0.33378884f, -0.08368613f, -0.40284014f, 0.15480569f, -0.14066000f, 0.01562412f, 0.05982300f, 0.06412499f, 
    -0.06631784f, 0.13276722f, 0.02733785f, -0.00638970f, -0.04616052f, 0.02964368f, -0.07727189f, -0.01020997f, 
    0.03356988f, 0.01190475f, 0.06429533f, 0.08344090f, 0.06048393f, -0.24526560f, -0.07306848f, -0.50093746f, 
    0.12352411f, -0.04880601f, -0.05008445f, 0.05024718f, 0.10728010f, 0.00907496f, -0.11404299f, 0.04658211f, 
    0.06151804f, -0.08398042f, 0.00073215f, 0.08287725f, 0.18507104f, 0.07386255f, -0.00924942f, 0.08134313f, 
    0.10901223f, 0.03805145f, 0.17674281f, 0.04206179f, 0.02342942f, 0.02450430f, -0.03334307f, -0.12013243f, 
    -0.08298621f, 0.02399580f, 0.00794846f, 0.03543536f, 0.09238314f, 0.01257735f, -0.02980637f, 0.04628044f, 
    -0.04356276f, -0.10435072f, -0.02922179f, -0.05054023f, 0.04006341f, -0.17485756f, -0.07148053f, -0.26429075f, 
    0.05294197f, -0.05365459f, -0.05220082f, 0.13919580f, 0.09782654f, 0.09595277f, 0.01411674f, 0.02925286f, 
    0.08526443f, -0.03458497f, -0.01629816f, 0.05702684f, 0.07354058f, 0.09671851f, 0.03871401f, 0.01630888f, 
    0.04963285f, -0.39602941f, 0.03137869f, -0.08223001f, -0.12909427f, 0.01561927f, 0.00115864f, -0.11691386f, 
    -0.04036196f, 0.07146455f, -0.00349202f, -0.06347408f, 0.06131177f, -0.06908287f, -0.04282429f, 0.15543962f, 
    -0.01516352f, -0.29068080f, -0.18069920f, -0.11131261f, 0.03873805f, 0.00088741f, 0.13165386f, 0.36080194f, 
    -0.41578659f, 0.03092106f, -0.08174518f, -0.06518393f, 0.07782860f, 0.05060077f, 0.00436842f, -0.02720024f, 
    0.04738688f, 0.00683114f, 0.04975734f, 0.02902528f, 0.04651037f, 0.04468181f, 0.03894513f, 0.13486108f, 
    -0.13965636f, 0.24977377f, 0.19260816f, -0.01747279f, -0.07927390f, 0.04868523f, -0.06600376f, -0.08682323f, 
    -0.08112735f, 0.03422636f, -0.00112142f, 0.04152730f, 0.02589876f, -0.01293989f, 0.01341978f, -0.03405267f, 
    -0.05991363f, -0.13968907f, 0.01670357f, -0.12936799f, -0.05109504f, 0.06431440f, -0.16771255f, 0.03309955f, 
    -0.20974603f, 0.05379567f, -0.11513951f, 0.07938194f, -0.07634401f, -0.18863697f, 0.03174895f, -0.04373855f, 
    -0.04116718f, -0.04657402f, 0.01685471f, -0.11958539f, 0.05646629f, -0.04811537f, 0.00868018f, -0.01321438f, 
    0.08306642f, 0.01241730f, 0.24319142f, -0.16157635f, -0.06761287f, -0.00974987f, -0.13052309f, 0.02379116f, 
    0.11781058f, 0.16966607f, -0.11125112f, 0.01076409f, -0.00608107f, -0.00414508f, -0.07960696f, 0.05003262f, 
    0.08260340f, -0.04356939f, -0.06343713f, -0.04267964f, -0.14652303f, -0.02444502f, 0.07588346f, 0.26485446f, 
    -0.19421449f, 0.13337606f, -0.13422863f, -0.06907128f, -0.06575197f, -0.33803385f, -0.00381078f, -0.00300465f, 
    0.04928879f, -0.01637521f, 0.02293055f, 0.05967787f, -0.08404790f, -0.07742786f, -0.03805833f, 0.07766473f, 
    -0.20599289f, -0.06075983f, -0.30835217f, -0.02687703f, -0.03159077f, 0.23801878f, -0.10511459f, 0.06050175f, 
    -0.05166267f, -0.11425871f, 0.07290791f, -0.11084058f, 0.04422048f, 0.01021845f, -0.04825753f, -0.04007666f, 
    0.04832780f, -0.10732333f, 0.06276815f, 0.08887044f, -0.11856949f, 0.11859880f, 0.45013472f, -0.04417389f, 
    -0.26476309f, -0.04214269f, -0.20319380f, -0.03798543f, -0.04168702f, 0.00155668f, -0.03327611f, -0.00064310f, 
    0.02012395f, -0.03708934f, 0.01684539f, -0.00747183f, -0.04729864f, -0.06041407f, -0.05333202f, -0.02629261f, 
    -0.19701691f, -0.01832821f, -0.08811362f, 0.15271515f, -0.51901180f, -0.11658975f, 0.09854468f, -0.08297596f, 
    0.02624383f, 0.03589797f, 0.07291721f, -0.03605488f, 0.05015416f, 0.04836763f, -0.01740628f, 0.02965951f, 
    0.07559326f, 0.07959774f, -0.00769691f, 0.01385091f, -0.10527881f, -0.23025131f, -0.04178514f, 0.17915688f, 
    -0.09415481f, -0.12612069f, 0.09047915f, -0.06300048f, -0.00135862f, 0.09233367f, 0.03088832f, -0.03142485f, 
    0.03829843f, 0.07657193f, 0.05277108f, -0.03876031f, 0.08399032f, -0.02274366f, 0.15130310f, 0.06874354f, 
    0.09577299f, 0.00846100f, 0.02594954f, -0.01250086f, -0.00501434f, 0.05504276f, 0.05976642f, 0.01328187f, 
    0.03808120f, -0.08672133f, 0.04755368f, 0.01327129f, -0.01256835f, 0.00738925f, 0.04552642f, -0.00331878f, 
    0.01950604f, 0.02660021f, -0.02061222f, 0.01686734f, -0.27050468f, 0.06527442f, -0.16320585f, -0.23001890f, 
    -0.08821464f, 0.09060284f, -0.34571403f, 0.03134814f, -0.06474972f, 0.05013477f, -0.04216863f, 0.05084240f, 
    -0.02023985f, -0.04677332f, 0.09405989f, -0.10541778f, -0.00281519f, -0.02020421f, -0.04760951f, -0.04154470f, 
    -0.06704224f, -0.13463326f, -0.36715037f, 0.11575705f, 0.00265037f, 0.06950664f, 0.11879811f, 0.19526756f, 
    -0.02201607f, 0.12713593f, -0.04536054f, -0.03361636f, -0.07068125f, 0.00898960f, -0.09293139f, -0.03551191f, 
    0.02505220f, 0.07367225f, 0.02319148f, 0.06271730f, 0.06389561f, 0.03225854f, 0.04302350f, -0.01109869f, 
    0.06926471f, -0.07134822f, -0.07489479f, 0.04378505f, 0.05833039f, 0.00160319f, 0.02102636f, 0.03185702f, 
    0.02095179f, 0.04546250f, -0.04561494f, 0.10701707f, 0.06939740f, 0.05129354f, -0.05314950f, 0.08339760f, 
    0.08155386f, -0.23194256f, 0.10320292f, -0.10770884f, -0.02210174f, -0.08232030f, 0.04159414f, 0.04455329f, 
    -0.00870991f, -0.03161080f, -0.07782204f, 0.01265183f, -0.13160270f, 0.05032475f, 0.00054972f, 0.01249136f, 
    -0.00369667f, 0.08060224f, -0.06240130f, -0.14399712f, -0.26470119f, 0.09079703f, -0.18467578f, 0.20222703f, 
    0.05198871f, -0.01894187f, -0.02736512f, -0.02294632f, 0.17085434f, 0.11585016f, -0.00368708f, -0.06026433f, 
    -0.06343922f, -0.06178652f, 0.11800267f, 0.01150311f, -0.05296213f, -0.13104898f, 0.09608199f, 0.12635686f, 
    -0.02324011f, 0.03670988f, -0.08849014f, 0.03192193f, -0.04478157f, 0.02854287f, 0.00813169f, 0.03844649f, 
    -0.09841113f, -0.04909717f, 0.02542031f, 0.02366814f, -0.08000578f, 0.01591059f, -0.01628280f, -0.05660226f, 
    -0.07663587f, -0.17730217f, -0.29882374f, -0.07782219f, -0.11135357f, 0.04019609f, 0.00265801f, 0.03420068f, 
    -0.00727780f, 0.04505998f, -0.00564358f, 0.00821491f, 0.00757686f, 0.01395559f, 0.03037995f, -0.01711199f, 
    -0.00410592f, 0.01366600f, 0.01637192f, -0.04377601f, -0.03124339f, 0.01719103f, 0.03008070f, -0.06776756f, 
    -0.12199377f, 0.03771000f, -0.11553659f, 0.04761291f, 0.09414209f, -0.04420729f, 0.03043979f, 0.00893520f, 
    0.00899575f, -0.06403843f, -0.08705755f, 0.08548880f, 0.03285166f, -0.02130812f, 0.02588806f, 0.09889462f, 
    -0.00261837f, -0.13972232f, -0.02473735f, -0.18816188f, -0.18545653f, 0.34028324f, -0.04254868f, 0.16383894f, 
    0.16272996f, 0.01254088f, -0.08437736f, -0.09492034f, 0.08470742f, 0.18354726f, -0.17878538f, -0.05413232f, 
    -0.00635676f, -0.03453280f, -0.01550286f, -0.01481504f, -0.04162922f, 0.01917245f, 0.07718832f, 0.07851391f, 
    -0.10038939f, -0.28918213f, -0.05186284f, -0.10987008f, -0.17662723f, -0.21759765f, -0.14803669f, -0.01247745f, 
    -0.03985687f, -0.09884679f, -0.17042197f, -0.00858637f, 0.03082057f, 0.00179866f, -0.05382025f, 0.10147715f, 
    -0.07113183f, 0.05873762f, 0.04363551f, -0.07645619f, 0.23578177f, 0.08197998f, 0.13932624f, -0.02460505f, 
    0.07879976f, 0.16885056f, -0.08717825f, 0.05968125f, -0.02776709f, 0.06614278f, -0.14503601f, 0.01793826f, 
    -0.01073819f, -0.05541168f, 0.03645441f, -0.07532273f, 0.01314932f, -0.08037056f, -0.01510187f, -0.09247340f, 
    -0.33314282f, -0.03920576f, -0.07566301f, 0.00652005f, 0.12050790f, -0.09393023f, -0.05413307f, -0.04424595f, 
    -0.20760299f, 0.06192937f, -0.04884023f, 0.11954818f, -0.00650840f, 0.11227890f, 0.03964614f, 0.07551012f, 
    -0.04006551f, -0.07339462f, -0.00318255f, -0.03148484f, -0.08361888f, 0.10652670f, 0.11144700f, -0.00191921f, 
    -0.02055375f, 0.01714905f, 0.00426677f, -0.06783100f, 0.07835777f, 0.05637641f, -0.07409696f, -0.05496292f, 
    -0.01792943f, 0.01270878f, 0.02783745f, -0.06157996f, 0.08250180f, 0.09145518f, 0.12528573f, 0.07664496f, 
    0.07920510f, 0.01849050f, 0.19124332f, 0.12893136f, 0.05409383f, -0.03302646f, 0.08938841f, 0.08690228f, 
    0.01384323f, 0.02223463f, -0.05343142f, -0.02922569f, 0.11025657f, 0.02180387f, -0.01514011f, -0.09392526f, 
    -0.07867642f, 0.02064621f, 0.03281065f, -0.06930699f, 0.05402935f, 0.05739383f, -0.11445493f, 0.18357192f, 
    -0.03072576f, 0.03977409f, -0.05594232f, 0.01193861f, 0.08357552f, 0.01503854f, 0.03498557f, -0.03834917f, 
    0.04564757f, 0.05626903f, 0.06829721f, -0.00313282f, -0.01052361f, -0.02471209f, 0.11379475f, 0.04089059f, 
    -0.03155999f, -0.19559968f, 0.00675399f, 0.11885186f, -0.16043028f, -0.05934659f, -0.10798717f, -0.04578681f, 
    -0.05145608f, -0.02902379f, -0.04794605f, 0.05418757f, -0.08985817f, 0.00200506f, 0.03824778f, 0.06138888f, 
    -0.02914582f, 0.04118269f, 0.04813260f, 0.07821701f, 0.07648953f, 0.03409243f, 0.09499172f, -0.03947612f, 
    0.16843377f, -0.12754585f, 0.08646970f, 0.05510618f, 0.05516420f, -0.00589656f, -0.03439489f, 0.07074132f, 
    0.10337216f, -0.03071175f, 0.07717790f, 0.00662878f, -0.02953030f, -0.15963866f, -0.03774482f, -0.15171659f, 
    -0.01160988f, 0.04482723f, 0.18624642f, 0.04867244f, -0.11661617f, -0.01974862f, -0.05883515f, -0.09760806f, 
    0.04310186f, 0.07920221f, -0.08173892f, -0.03040560f, -0.01882315f, 0.07931204f, 0.01181967f, -0.09591168f, 
    0.06974079f, 0.10893325f, 0.09374877f, 0.02641445f, -0.22519463f, -0.06027062f, 0.24164750f, 0.25845721f, 
    -0.01258973f, 0.00744142f, 0.12576273f, -0.11237287f, -0.00848145f, -0.05362179f, -0.18001477f, -0.16626562f, 
    0.04857238f, -0.01112491f, 0.03170035f, -0.03006407f, 0.02156732f, 0.13182995f, 0.04796806f, 0.21191721f, 
    0.00017737f, 0.13365704f, 0.01704861f, 0.05901143f, 0.06414956f, 0.11741745f, -0.03267507f, 0.01128436f, 
    -0.06303301f, -0.07143498f, -0.08445949f, 0.01518878f, 0.02081510f, -0.05636880f, -0.12694134f, 0.00207695f, 
    0.01140698f, -0.02826818f, -0.06351502f, -0.10809889f, 0.19493887f, -0.41957214f, 0.23618397f, -0.00986783f, 
    0.03688858f, -0.07561988f, 0.01205285f, 0.09398689f, 0.08888074f, -0.10039769f, -0.04427345f, -0.00200978f, 
    -0.21054868f, 0.11460090f, 0.06083021f, -0.11809567f, 0.12008887f, 0.09543539f, -0.07584317f, -0.14800566f, 
    -0.42748159f, 0.05420423f, 0.04164430f, 0.05489478f, 0.22835042f, -0.02488745f, -0.07851700f, 0.08582835f, 
    -0.09780560f, 0.12291851f, -0.10843726f, 0.09728298f, -0.00393066f, 0.09129193f, 0.05179822f, 0.04789050f, 
    0.03841469f, -0.09237449f, 0.10457343f, 0.15165836f, 0.06625763f, 0.07400754f, -0.02852456f, -0.02616770f, 
    -0.00239540f, 0.06786321f, 0.00152368f, -0.08610800f, 0.01936409f, 0.02919425f, -0.05436027f, 0.07528008f, 
    -0.00435028f, -0.08059984f, -0.10996142f, -0.01909410f, -0.07202515f, -0.05337252f, -0.03930593f, -0.05001961f, 
    -0.07284283f, -0.05981141f, 0.06762791f, 0.00723255f, -0.00219232f, 0.05465035f, -0.05390936f, 0.03239247f, 
    0.07125607f, 0.01699928f, -0.09089612f, 0.00619230f, -0.04354642f, -0.01286622f, 0.00690260f, 0.02450812f, 
    -0.09161507f, 0.08464949f, -0.11958454f, 0.03737901f, -0.02296534f, -0.28932071f, 0.08715486f, -0.18607984f, 
    -0.14992169f, -0.04946820f, -0.11051615f, 0.04677555f, 0.02361397f, -0.01334365f, 0.03449619f, -0.00890449f, 
    0.03905120f, -0.00490555f, 0.00129305f, 0.10311721f, 0.01209056f, 0.06968529f, 0.03862014f, -0.04690311f, 
    0.05113211f, -0.08111426f, 0.03301784f, 0.22470771f, -0.02755713f, -0.09450213f, -0.00786589f, 0.03121732f, 
    0.00060200f, -0.02617258f, 0.01588169f, -0.03947842f, -0.01653275f, 0.05841722f, 0.12197804f, -0.07545791f, 
    -0.04792322f, 0.08992289f, 0.03670750f, 0.13231426f, -0.28354323f, 0.06538075f, -0.00310686f, -0.03676793f, 
    0.03205202f, -0.05299489f, 0.03486468f, -0.17090584f, 0.10835332f, 0.05042642f, 0.04343803f, 0.03319903f, 
    0.00567813f, -0.00749505f, -0.03918871f, -0.00680446f, 0.07012157f, -0.01440632f, 0.10040490f, 0.03657939f, 
    -0.03728394f, -0.08298434f, 0.20589773f, 0.00683686f, 0.07949286f, -0.13037331f, 0.08376404f, -0.02134019f, 
    -0.00669522f, 0.04720513f, 0.00736860f, 0.02982469f, -0.01936655f, 0.05136190f, 0.04526309f, 0.02393002f, 
    0.06244073f, 0.03495210f, 0.04254435f, 0.12118863f, 0.00767078f, -0.17875308f, 0.08622049f, -0.06548824f, 
    -0.16922401f, -0.08351634f, -0.05767209f, -0.03452748f, -0.04673840f, -0.08171365f, -0.09022305f, 0.01307378f, 
    -0.08476479f, 0.04417368f, -0.02262004f, 0.02286930f, 0.00782477f, -0.01373677f, -0.08434518f, -0.08691104f, 
    0.03025551f, -0.05424380f, 0.00115331f, 0.05545104f, -0.12660199f, -0.02690311f, 0.01620139f, 0.13595511f, 
    -0.01122397f, 0.04911227f, -0.07872897f, -0.05188087f, 0.01755899f, 0.03966312f, -0.05205654f, -0.06763615f, 
    0.00743513f, 0.18547246f, 0.08367737f, -0.00437391f, -0.07193532f, 0.26570237f, -0.08232272f, 0.09222373f, 
    -0.02668687f, 0.06180430f, -0.06939130f, -0.05502491f, -0.01713975f, 0.03029770f, -0.04610795f, -0.01487967f, 
    -0.01633606f, -0.07176633f, -0.11732101f, -0.04496018f, -0.09017548f, -0.03701979f, -0.01181406f, -0.07877112f, 
    -0.07227626f, -0.01400809f, -0.05371713f, 0.05265629f, 0.03094819f, -0.02456025f, -0.04761833f, -0.06403448f, 
    0.00334736f, 0.00561243f, -0.01299224f, 0.00144408f, -0.02726783f, -0.07441775f, -0.11486273f, -0.00028036f, 
    -0.03900805f, 0.00036087f, -0.05029226f, -0.02517295f, -0.11051798f, -0.03064001f, -0.13095610f, 0.04729790f, 
    0.03632473f, 0.07302790f, -0.07882166f, 0.14377254f, -0.01443148f, -0.06427107f, 0.06135308f, 0.02916638f, 
    -0.03678429f, 0.08091635f, -0.02499540f, 0.04598322f, -0.06191775f, -0.08635617f, -0.03389736f, 0.00185783f, 
    -0.04690234f, 0.10812440f, 0.02827233f, 0.16720867f, 0.13691132f, 0.00414649f, -0.02392924f, 0.03811126f, 
    -0.03766302f, 0.08359729f, -0.09503327f, -0.06004947f, 0.09389693f, -0.02477465f, -0.05225862f, -0.15696062f, 
    0.01344396f, -0.33370572f, -0.02401579f, 0.03734585f, 0.20077424f, -0.47419336f, 0.19499061f, -0.17385916f, 
    -0.27774623f, -0.07051191f, -0.05140280f, 0.18796855f, 0.00556259f, -0.03230623f, -0.08548392f, 0.12099708f, 
    -0.04758233f, -0.00655730f, -0.09866725f, -0.05300195f, 0.00874508f, 0.12495472f, -0.02382320f, -0.11394967f, 
    -0.33532265f, -0.45764300f, 0.14527650f, -0.03993314f, -0.10586112f, -0.10637784f, 0.08647881f, 0.16656832f, 
    -0.06982167f, -0.02197000f, -0.08867748f, 0.09007306f, -0.07498550f, 0.03143087f, 0.01513244f, -0.00384669f, 
    0.07465944f, 0.12280027f, 0.03284870f, 0.08743759f, -0.31168044f, -0.05889613f, -0.01021601f, -0.10459748f, 
    0.22421423f, -0.10365043f, -0.11158404f, -0.16342986f, -0.06251874f, 0.02076396f, -0.03776338f, 0.08719760f, 
    0.08705305f, 0.01145499f, 0.07479256f, -0.00769527f, -0.00235606f, -0.07400893f, 0.06542772f, 0.04486400f, 
    -0.24909845f, 0.01144517f, 0.04961689f, -0.02443990f, -0.01759273f, -0.06754749f, -0.03362924f, 0.02964531f, 
    -0.02932393f, 0.02744485f, -0.03139969f, 0.08275273f, 0.02700352f, -0.03593574f, -0.02310034f, -0.03619315f, 
    0.06387749f, 0.10903774f, 0.05643185f, 0.22393401f, 0.13059479f, -0.02322398f, 0.13910650f, 0.09200764f, 
    -0.02603825f, 0.00351392f, 0.08858693f, 0.03258788f, 0.01447020f, -0.03329510f, -0.02463755f, 0.03052755f, 
    -0.06469417f, -0.04894502f, -0.06774817f, 0.01930118f, -0.20593546f, 0.04469719f, -0.04564602f, -0.11549928f, 
    0.05650240f, -0.03071330f, 0.17239358f, 0.13425033f, -0.04145459f, -0.01104936f, -0.00203950f, 0.16419269f, 
    -0.04920870f, -0.09847861f, 0.10724369f, -0.04077381f, -0.03645030f, 0.02562927f, -0.03633468f, -0.04319163f, 
    -0.02997495f, 0.13196653f, -0.13054502f, -0.08706994f, 0.18306768f, -0.19886491f, 0.13736987f, -0.07807027f, 
    0.05575753f, -0.12042763f, 0.03951598f, 0.21583463f, 0.15127791f, 0.04844762f, -0.03218672f, -0.03527537f, 
    -0.23263694f, -0.02658537f, -0.02057336f, 0.01599077f, 0.01648654f, 0.12288945f, -0.03257999f, -0.02448706f, 
    0.14697906f, -0.24670152f, 0.06687752f, 0.02196839f, 0.14594017f, -0.11927662f, 0.11605847f, 0.06871842f, 
    -0.00513034f, -0.10427249f, 0.00575511f, -0.07347433f, 0.00387483f, -0.00154779f, 0.03422013f, 0.02892544f, 
    -0.20139535f, -0.19126053f, -0.07951771f, -0.31361231f, -0.16829185f, 0.04126809f, -0.35167420f, -0.00835629f, 
    0.01801321f, -0.03266063f, -0.06498239f, -0.00487515f, -0.11539179f, -0.04273169f, -0.02434902f, 0.04380308f, 
    0.03827330f, -0.03371434f, -0.01004654f, -0.01765508f, -0.00231501f, -0.12838089f, -0.02421099f, -0.06731693f, 
    -0.29249254f, -0.10915324f, 0.31340325f, -0.00567449f, -0.00461613f, 0.05331352f, -0.03821504f, 0.07478966f, 
    -0.03459792f, -0.11936249f, -0.14051688f, 0.05487094f, 0.08500335f, -0.00026457f, 0.02392949f, -0.13383192f, 
    0.01331426f, 0.09925056f, -0.02432435f, -0.05212995f, 0.33126488f, -0.26017109f, 0.16269723f, 0.05225344f, 
    -0.20616235f, 0.01779049f, -0.08134477f, -0.01723967f, -0.06430707f, -0.02654933f, -0.06331944f, 0.10213438f, 
    -0.10502921f, -0.10769935f, 0.00823664f, -0.05189398f, -0.12700306f, 0.04573274f, 0.02616469f, -0.04544808f, 
    -0.21634455f, -0.09203225f, 0.00588809f, 0.05251635f, 0.01423030f, 0.03037640f, -0.06263455f, -0.07978950f, 
    -0.01654712f, -0.10458618f, 0.00789571f, 0.07880583f, 0.00380689f, -0.00165240f, -0.00526972f, 0.07501538f, 
    -0.04796093f, 0.02624202f, -0.08976597f, -0.17361584f, -0.26272649f, 0.12165964f, -0.02656572f, 0.03599262f, 
    -0.05355354f, 0.08363777f, 0.01245911f, -0.07834666f, -0.03776446f, 0.00795867f, 0.07599298f, 0.07018574f, 
    -0.01197779f, 0.02065757f, -0.01553207f, -0.04291052f, -0.15464693f, -0.03407947f, -0.05746992f, -0.03403205f, 
    -0.01342849f, -0.17899495f, 0.27925143f, -0.19470681f, 0.00514348f, -0.11014380f, -0.02318629f, 0.27095017f, 
    0.04353671f, -0.02935345f, 0.14335884f, 0.01069844f, 0.17657460f, 0.05576167f, 0.02209969f, 0.02362395f, 
    -0.02902771f, 0.19393657f, 0.02638690f, 0.12863609f, -0.31060311f, -0.24309056f, 0.03747821f, -0.08279482f, 
    -0.04573279f, 0.03172071f, -0.00540230f, 0.04374178f, -0.02929424f, -0.00858987f, 0.01653836f, -0.03001519f, 
    0.06771885f, 0.05944981f, -0.02280320f, 0.07549730f, 0.10898733f, 0.04388142f, 0.22919860f, 0.22105309f, 
    -0.21725245f, -0.06597780f, -0.33471334f, -0.07156650f, 0.06419680f, 0.03903015f, -0.06013375f, 0.12644342f, 
    -0.10232095f, 0.00914755f, 0.00026737f, 0.08418281f, -0.03114677f, 0.00236918f, -0.03078683f, 0.06679908f, 
    -0.12667896f, -0.08784883f, -0.08241671f, -0.12055711f, -0.08647960f, 0.11203101f, 0.08279767f, 0.07907550f, 
    -0.20635469f, 0.05444370f, 0.01311653f, -0.03415519f, -0.07886449f, -0.04781595f, 0.05247314f, 0.11184359f, 
    -0.10414905f, 0.09487358f, -0.03054214f, -0.08722855f, -0.06911454f, 0.03447520f, -0.18017516f, -0.17032503f, 
    -0.03592037f, 0.09378975f, -0.07469519f, 0.03819135f, 0.08382369f, -0.01050117f, 0.04486351f, 0.05048189f, 
    0.00806434f, 0.01750912f, -0.04143228f, -0.00686945f, 0.04393527f, 0.03788345f, -0.02368389f, 0.04000096f, 
    0.01752895f, 0.00462332f, 0.03726518f, 0.10968948f, 0.01247419f, 0.00070332f, -0.24264468f, 0.17850973f, 
    -0.00069550f, 0.02023857f, 0.00019106f, -0.03311293f, 0.02217876f, 0.02674110f, 0.00455516f, 0.05129291f, 
    -0.08748883f, 0.01142094f, -0.02537705f, -0.01454441f, -0.03569292f, -0.08229619f, 0.00022264f, 0.07257515f, 
    -0.40790674f, 0.17809138f, -0.25626054f, 0.11170927f, 0.11448517f, 0.06121701f, 0.03713541f, 0.16236931f, 
    0.16188104f, 0.20920922f, -0.18290982f, 0.00075818f, -0.16867793f, -0.12141596f, -0.03322141f, 0.01350137f, 
    -0.02713108f, 0.03676414f, 0.17661868f, 0.25076219f, -0.18361481f, 0.00013219f, -0.18854159f, -0.01448666f, 
    -0.00781236f, -0.11775860f, -0.00860800f, -0.05312816f, 0.02810178f, 0.02232442f, -0.04999142f, 0.05112429f, 
    -0.06169422f, -0.07989579f, -0.09051500f, 0.01619156f, -0.03453497f, -0.01369405f, -0.05651332f, -0.08912383f, 
    0.01838008f, -0.13577682f, 0.15889189f, -0.05968025f, -0.03969333f, -0.06590723f, 0.12142226f, 0.12691514f, 
    0.11958593f, -0.05205982f, -0.07057508f, -0.00880047f, -0.01854561f, -0.09949407f, 0.01639573f, -0.03593434f, 
    0.09122767f, 0.13724232f, 0.15198492f, 0.11666242f, -0.39784065f, -0.24096122f, 0.20234534f, 0.08709195f, 
    0.03878720f, -0.00991363f, -0.08480086f, -0.04105119f, 0.36897087f, -0.00862576f, -0.02240244f, -0.07941249f, 
    0.08556974f, 0.07768963f, 0.01888112f, 0.08697600f, 0.03242065f, 0.03142485f, 0.25360680f, 0.12218384f, 
    -0.11332498f, 0.03852668f, 0.03310853f, -0.06179538f, 0.03857258f, 0.03932456f, -0.02914562f, 0.01881967f, 
    0.01622957f, -0.12874615f, -0.04744629f, -0.03744103f, 0.07735872f, 0.00528250f, -0.00423163f, 0.02307111f, 
    -0.03428183f, -0.05634350f, -0.04059251f, 0.05191542f, -0.45526904f, 0.10232314f, 0.08065262f, -0.02812539f, 
    -0.07699534f, 0.08547847f, 0.04218659f, -0.09401594f, 0.17051052f, 0.00313190f, 0.03233234f, -0.03695346f, 
    0.01066424f, -0.00769368f, -0.04097074f, -0.04728198f, -0.07348211f, 0.03014596f, -0.04386671f, -0.10614613f, 
    -0.42229843f, 0.05221182f, 0.01742747f, 0.09427188f, 0.01554250f, -0.07206468f, 0.01554179f, 0.05773995f, 
    0.29558212f, 0.01274039f, -0.07269853f, 0.02998606f, -0.03661850f, -0.00699030f, 0.02630172f, 0.02610369f, 
    0.01967986f, -0.05626017f, 0.06249373f, -0.00221298f, -0.25957838f, 0.01557460f, -0.03038843f, 0.03648211f, 
    -0.03905246f, 0.02192010f, 0.02573436f, -0.08971691f, 0.08243433f, 0.01104581f, 0.04189911f, -0.10264708f, 
    -0.02829051f, 0.02935415f, 0.01576567f, 0.04181398f, 0.09027389f, -0.07211440f, 0.12613320f, 0.10121126f, 
    -0.10472803f, 0.05196936f, -0.04747092f, -0.05914963f, 0.06473722f, -0.00420880f, -0.11519282f, -0.02133196f, 
    -0.04205800f, -0.02662469f, -0.00330470f, 0.07348660f, 0.08143204f, -0.11927371f, -0.07187714f, -0.00356946f, 
    0.01414949f, 0.02287631f, -0.00693966f, -0.09037196f, -0.09714470f, 0.03338162f, -0.40997791f, 0.07266214f, 
    0.10469469f, 0.01869068f, -0.01432653f, 0.04231061f, -0.15764572f, -0.07529806f, -0.03390232f, 0.02630486f, 
    -0.06401750f, -0.05381724f, 0.00687749f, -0.00289978f, -0.03499549f, -0.19927424f, -0.07157920f, -0.06270663f, 
    -0.05782020f, 0.00854168f, 0.08696086f, 0.18377954f, 0.03248696f, -0.04490146f, 0.00455290f, 0.02672753f, 
    0.09233256f, 0.05288723f, -0.05770209f, 0.01128120f, 0.06831068f, 0.06357555f, 0.03776484f, -0.04510176f, 
    0.02273013f, 0.01200681f, 0.09258454f, 0.10236937f, -0.38732824f, -0.03580161f, -0.11134864f, 0.13409305f, 
    -0.02576419f, -0.09156375f, 0.06279595f, -0.24738103f, 0.30061975f, -0.18284848f, -0.01553418f, 0.09298731f, 
    -0.02193333f, 0.05930914f, 0.08428748f, 0.00281839f, -0.01195670f, -0.16511908f, 0.00725315f, -0.11536378f, 
    0.06314847f, -0.35290733f, -0.03919172f, 0.04096437f, 0.01916599f, -0.02270269f, 0.01337923f, 0.06714509f, 
    -0.16326262f, -0.10723437f, 0.01463490f, -0.02485684f, -0.10381408f, 0.00724882f, 0.04370176f, 0.00803725f, 
    -0.27626958f, -0.15692207f, -0.11743657f, -0.10410433f, 0.04334341f, -0.03574752f, 0.05400683f, 0.01190442f, 
    -0.11377630f, 0.05658644f, 0.00709586f, 0.04712649f, -0.05336754f, -0.01767301f, -0.03853257f, 0.01212147f, 
    -0.14537095f, 0.03512140f, -0.07333636f, 0.00722590f, 0.00988761f, 0.05397529f, -0.01742862f, -0.10838610f, 
    0.16681778f, -0.10498901f, 0.06632234f, -0.12303027f, 0.19364746f, 0.02347124f, 0.03593180f, -0.04374290f, 
    0.05913766f, -0.05951578f, -0.01833695f, 0.04334819f, 0.02259361f, 0.00250014f, -0.03148146f, -0.07177766f, 
    0.07970326f, 0.02637700f, -0.03749505f, -0.03261546f, -0.26980379f, -0.43855971f, -0.00340304f, 0.34096074f, 
    -0.24714696f, -0.01684009f, 0.07689913f, 0.01966684f, 0.17269264f, -0.11452011f, -0.13983484f, -0.01949016f, 
    0.04391561f, 0.03378128f, 0.06287975f, -0.03831235f, -0.01248755f, 0.13898429f, 0.07538586f, 0.02153177f, 
    -0.05279163f, -0.21750014f, -0.03695298f, 0.10144950f, 0.10405934f, 0.02692586f, -0.04507144f, -0.02139535f, 
    0.00422675f, -0.05212442f, 0.02248703f, 0.02874240f, 0.00726516f, -0.01595451f, 0.03281904f, 0.10018584f, 
    -0.02634173f, -0.00626309f, 0.11641984f, -0.04976894f, 0.06723971f, -0.08249685f, -0.09736882f, 0.19182356f, 
    0.01426791f, -0.04391347f, 0.14977616f, -0.03823162f, 0.11615704f, -0.06585997f, -0.18454823f, 0.00131030f, 
    0.06131200f, -0.02777885f, 0.04746731f, 0.03954539f, -0.01690789f, 0.07693028f, -0.04012338f, 0.07011946f, 
    0.01047814f, -0.33118346f, -0.08919204f, -0.19639343f, 0.09646694f, -0.04499683f, -0.11874922f, 0.05332090f, 
    -0.02799474f, -0.09001445f, -0.02248420f, -0.00422500f, 0.01647102f, 0.02336895f, 0.03880078f, 0.03534717f, 
    -0.00104810f, -0.00403059f, -0.04518997f, -0.00709704f, -0.45793322f, -0.05041372f, -0.27062735f, 0.45371845f, 
    -0.12505805f, 0.01236028f, 0.07267940f, 0.02319106f, 0.22681424f, 0.05069553f, -0.10938171f, 0.06000449f, 
    0.05645593f, 0.07045726f, -0.01469094f, -0.01933169f, 0.01617119f, 0.12242994f, -0.02441866f, -0.02681233f, 
    0.40656820f, -0.07876468f, 0.28836840f, -0.18456481f, -0.03796952f, 0.03457407f, 0.03874973f, -0.12865987f, 
    0.08336712f, -0.01841758f, -0.04981742f, 0.00244962f, -0.01470946f, -0.06691850f, -0.08942906f, -0.02575484f, 
    0.09481364f, -0.04451100f, -0.01477916f, 0.01395837f, -0.66747081f, -0.18169191f, -0.28917590f, 0.27801877f, 
    0.08216098f, 0.28689498f, 0.04818495f, 0.25132427f, -0.19186348f, 0.08006742f, 0.02797455f, -0.07970636f, 
    0.04563131f, 0.11558393f, 0.14184637f, 0.01830212f, -0.11265392f, -0.00061797f, 0.08832622f, -0.03208159f, 
    0.04211844f, -0.29776442f, -0.09809963f, 0.02259254f, 0.00843991f, -0.17376287f, -0.35782814f, -0.02195829f, 
    -0.14316860f, -0.13077819f, 0.01990430f, -0.02686296f, 0.01802058f, -0.06156244f, -0.09093475f, 0.01075705f, 
    -0.10186929f, 0.01953522f, 0.03101848f, -0.09320708f, -0.10297744f, 0.04584644f, -0.10154602f, 0.11224765f, 
    0.03436554f, -0.02126821f, 0.02692266f, -0.03011490f, 0.09344846f, 0.02168946f, 0.02237885f, -0.03486425f, 
    -0.04519649f, -0.03948215f, 0.04456278f, -0.03842608f, -0.02965119f, 0.02051716f, -0.14240465f, -0.05692488f, 
    -0.10469366f, -0.08422171f, 0.12186865f, 0.04464484f, 0.07285329f, 0.02104070f, 0.02231623f, -0.15029772f, 
    0.02878503f, 0.03804075f, 0.02921419f, 0.05036836f, -0.10938335f, 0.07998366f, 0.01615887f, 0.10989348f, 
    -0.01076618f, 0.09530659f, 0.14392923f, 0.10957241f, -0.10321259f, -0.04380421f, 0.04270196f, 0.08894330f, 
    -0.07964455f, -0.04455514f, 0.07919870f, -0.03422622f, 0.14172828f, 0.03605043f, -0.10794780f, -0.00937974f, 
    0.02015565f, -0.03841129f, 0.02943924f, -0.01610757f, 0.02157142f, 0.05426164f, -0.06112071f, 0.01771644f, 
    0.16882254f, -0.00663757f, 0.03791983f, -0.02792703f, -0.09853312f, -0.06444853f, -0.00432999f, -0.02885562f, 
    0.04458980f, -0.01974096f, -0.02369989f, -0.00825043f, 0.03775126f, -0.06391295f, -0.10095600f, 0.00137497f, 
    0.02834072f, -0.00652214f, -0.07962592f, -0.04389768f, -0.18087836f, -0.28454766f, 0.04787996f, -0.24148498f, 
    0.01267186f, 0.00116772f, -0.04693475f, -0.01390899f, 0.02539464f, -0.04962170f, 0.00862193f, 0.07743987f, 
    0.00754062f, 0.16210039f, 0.04707814f, 0.08291030f, 0.04456655f, 0.02442380f, -0.03753727f, 0.07849884f, 
    0.00503569f, 0.02459607f, -0.09637766f, 0.10992718f, 0.03740255f, 0.01560190f, 0.07648092f, 0.00459227f, 
    0.10546844f, 0.00117837f, -0.05684356f, -0.05572318f, -0.07538988f, 0.04712407f, 0.01000362f, 0.03725202f, 
    0.00810753f, 0.00623993f, -0.07008786f, -0.07938642f, 0.02124296f, -0.11448632f, -0.52823561f, 0.29671493f, 
    0.29148728f, -0.04816791f, 0.18418387f, -0.02304922f, 0.12032795f, -0.05127950f, -0.08522238f, 0.02830681f, 
    -0.02445851f, -0.03172591f, 0.11680435f, -0.03143892f, -0.07977397f, -0.00937474f, -0.01046060f, 0.10356721f, 
    -0.22445634f, 0.17585544f, -0.19586881f, 0.10998803f, -0.26472369f, 0.02884874f, -0.01495282f, -0.03586271f, 
    -0.07996605f, 0.06865291f, 0.00339133f, -0.04742634f, -0.03547092f, 0.01514086f, 0.06366898f, 0.06534021f, 
    0.04902567f, 0.05280270f, -0.07106112f, 0.05369877f, 0.06628037f, -0.06319642f, -0.02465626f, 0.11346277f, 
    0.34292215f, 0.02179656f, 0.18791084f, 0.00296620f, 0.04614580f, -0.00410149f, -0.11498605f, 0.02804066f, 
    -0.03916361f, -0.04089246f, -0.12415571f, -0.06092129f, 0.01973112f, 0.09077355f, 0.05837920f, -0.01320661f, 
    -0.20828307f, -0.27660781f, -0.05937259f, 0.30743840f, -0.15209618f, -0.08366926f, -0.47821113f, 0.21451919f, 
    -0.35051084f, 0.02464886f, 0.04195574f, -0.10253086f, -0.04173968f, -0.00122132f, -0.15831828f, 0.06641791f, 
    -0.14824659f, 0.03820521f, -0.06666010f, -0.17806867f, -0.44809353f, -0.01238637f, -0.28815940f, 0.02343109f, 
    -0.33743683f, 0.06308369f, 0.06831627f, -0.04343023f, 0.04394209f, 0.04681769f, -0.08269249f, -0.05702963f, 
    0.02884285f, -0.01180354f, -0.03091913f, -0.01442806f, -0.01136067f, -0.00930925f, -0.05313502f, 0.06286025f, 
    0.04490594f, -0.05760654f, 0.04169406f, 0.15026262f, 0.01737751f, -0.00490447f, -0.02268397f, 0.00236334f, 
    0.02609634f, -0.06373297f, -0.01358317f, -0.06544820f, -0.00405989f, -0.00755263f, -0.01019424f, 0.00851729f, 
    0.00772688f, 0.04198635f, 0.00183365f, -0.03092410f, 0.03209833f, -0.00574938f, 0.06572118f, -0.07298686f, 
    0.01525609f, -0.02465723f, 0.06209745f, 0.03784520f, 0.02188981f, -0.01561131f, -0.09394797f, 0.01906230f, 
    -0.02078989f, -0.02504707f, -0.04695060f, 0.03434329f, -0.00046458f, -0.00260558f, -0.16719133f, -0.05590192f, 
    0.00355299f, -0.10753289f, 0.08020449f, 0.05867980f, -0.10060908f, -0.06393955f, 0.02452048f, 0.02892233f, 
    0.07409040f, -0.00328195f, -0.03133930f, 0.00518338f, 0.01824430f, 0.06407993f, 0.01702134f, -0.07734146f, 
    -0.04790947f, 0.06216466f, -0.01696843f, -0.06468046f, -0.03285609f, -0.34090307f, 0.01667351f, -0.04480068f, 
    -0.07929718f, 0.07905860f, -0.13959716f, -0.08297211f, 0.00816926f, -0.07836005f, 0.06385841f, -0.00731475f, 
    -0.02642868f, -0.09140890f, -0.03119483f, -0.03148958f, -0.09289540f, 0.01610179f, -0.02621788f, -0.08302236f, 
    0.02829336f, -0.12559278f, 0.06789707f, 0.00767123f, 0.14690344f, 0.08398046f, 0.03386142f, -0.06702734f, 
    -0.04269164f, -0.00182621f, 0.02249468f, 0.01675104f, -0.02014923f, -0.05329064f, -0.01617249f, 0.01921896f, 
    0.08305146f, -0.01622276f, -0.06453576f, -0.00095776f, 0.14535046f, -0.05118881f, -0.04592080f, -0.01060034f, 
    0.08262771f, 0.00669103f, -0.02365296f, -0.08598924f, -0.04747645f, -0.05280856f, -0.08781797f, -0.02928364f, 
    -0.04110949f, -0.04959692f, -0.03920091f, 0.09957600f, 0.03668833f, 0.01610394f, -0.02343821f, -0.05481672f, 
    0.13807893f, -0.18146303f, 0.15795410f, -0.10026940f, 0.18699075f, 0.02699556f, 0.11026971f, -0.15864931f, 
    0.14475301f, 0.05084004f, 0.07245133f, 0.10259233f, -0.08347289f, -0.03183853f, -0.01239190f, 0.00050061f, 
    0.07155686f, -0.07898108f, 0.11983061f, -0.08338089f, -0.62078780f, 0.04874407f, -0.43586284f, 0.23378719f, 
    -0.28499615f, 0.10208412f, 0.13280612f, 0.01717350f, 0.04807780f, 0.02854114f, -0.18833259f, -0.01506252f, 
    0.11031637f, 0.07066140f, -0.03110299f, 0.01780579f, 0.02703757f, 0.05283077f, -0.08213638f, 0.11272579f, 
    0.01394673f, -0.09513036f, -0.16339609f, -0.00042602f, -0.27343100f, -0.05714334f, 0.01915602f, -0.04559227f, 
    -0.06263512f, -0.06578702f, 0.00407814f, -0.01372167f, 0.06392326f, 0.03798389f, -0.01005519f, -0.00694853f, 
    0.04836899f, 0.02080647f, 0.07058803f, 0.06373766f, -0.11655776f, -0.21034345f, 0.07882505f, -0.07249066f, 
    0.04107524f, -0.07392507f, -0.26165375f, -0.04208506f, -0.07910413f, -0.06326052f, 0.05644953f, -0.01575310f, 
    -0.01351351f, 0.03011632f, -0.02380165f, 0.01786522f, 0.01444609f, 0.07366706f, 0.09564487f, -0.04291325f, 
    -0.31102282f, -0.00599875f, 0.07234953f, 0.24415955f, 0.03076603f, 0.03955012f, -0.05909588f, 0.05016358f, 
    -0.09447280f, 0.03708917f, 0.00012257f, 0.04634756f, -0.08730665f, 0.06183460f, 0.03872024f, 0.09370431f, 
    0.10056044f, 0.23335381f, 0.13721783f, -0.03354128f, -0.19362870f, -0.17139013f, -0.17462003f, -0.03993707f, 
    0.19513525f, -0.01644277f, 0.07977886f, -0.16700710f, 0.15394291f, 0.11141957f, -0.17510030f, 0.05811335f, 
    0.04683150f, 0.08020001f, -0.01911493f, -0.02915319f, -0.05722778f, -0.07106878f, -0.03549788f, -0.04221155f, 
    0.41488808f, 0.13408063f, 0.37208697f, -0.09316854f, 0.00578824f, 0.10325155f, 0.07385400f, -0.18303053f, 
    0.09249051f, 0.01476576f, -0.07663795f, -0.01099893f, 0.03264582f, 0.04649188f, 0.01387176f, -0.09466551f, 
    0.02430398f, -0.18173958f, -0.19671026f, 0.11467002f, 0.06232556f, -0.17583066f, -0.07831319f, -0.24695483f, 
    -0.14445418f, -0.06604131f, -0.32230642f, -0.27500454f, -0.07906856f, -0.02466784f, 0.01655498f, 0.03188515f, 
    0.08481178f, -0.08242886f, -0.16629700f, 0.00478221f, 0.00873989f, -0.00988398f, -0.02319109f, -0.13271961f, 
    -0.14059392f, 0.10660829f, -0.17104372f, 0.14247736f, -0.05734970f, -0.00837562f, 0.01789161f, 0.06082148f, 
    -0.03684016f, -0.07624809f, -0.02901993f, 0.04224641f, -0.09833943f, 0.00191977f, -0.02290575f, 0.06304086f, 
    -0.11750119f, -0.06356014f, -0.14444870f, -0.15268596f, 0.01845792f, -0.26053172f, 0.11319558f, -0.15667392f, 
    0.05774214f, 0.09071460f, 0.13295254f, 0.04088906f, -0.05633031f, -0.02691709f, 0.00746606f, -0.04468711f, 
    0.04987665f, 0.12181691f, 0.15698768f, -0.05335168f, 0.06520873f, 0.02564679f, 0.13419981f, 0.08974199f, 
    -0.20054722f, 0.06657615f, -0.12081289f, 0.20432341f, 0.27440655f, 0.06229049f, 0.07420507f, -0.02117816f, 
    -0.02144547f, -0.04247351f, 0.04290889f, 0.07632960f, 0.00978780f, 0.02255176f, 0.05782086f, 0.11275195f, 
    -0.03197259f, -0.02650769f, 0.09614667f, 0.04728462f, 0.02246347f, -0.20800015f, 0.35988066f, -0.44892421f, 
    0.00044420f, 0.08768889f, 0.00496268f, -0.24762012f, 0.19452886f, -0.04536290f, 0.01122686f, 0.10747500f, 
    -0.05010035f, 0.02504485f, -0.00746301f, 0.06583588f, 0.05257916f, -0.00662629f, 0.16618748f, 0.02791269f, 
    0.02435442f, -0.39989409f, -0.09759205f, -0.26809701f, 0.11916809f, 0.00703502f, 0.03974140f, 0.03582574f, 
    -0.00531506f, -0.05892981f, -0.05630655f, 0.09370195f, -0.01722110f, 0.03620448f, 0.03657640f, 0.01192211f, 
    0.15989067f, 0.05279137f, -0.16969684f, 0.03446376f, 0.00519719f, -0.08250675f, -0.02043712f, -0.06138328f, 
    -0.14131050f, -0.00217456f, -0.01216639f, 0.03186381f, -0.02654647f, -0.00836456f, -0.01194027f, 0.00994260f, 
    0.06822505f, 0.00112185f, -0.00309630f, 0.05889277f, 0.03148743f, 0.00735671f, 0.00090914f, 0.05297551f, 
    0.67104799f, -0.12802257f, 0.33023053f, 0.39124891f, -0.01055463f, -0.00616500f, 0.09095471f, -0.20297112f, 
    0.14014263f, -0.05212674f, -0.11905055f, 0.04453101f, -0.04629220f, 0.03514276f, -0.05476550f, -0.02980417f, 
    -0.02183603f, 0.06046011f, 0.06726884f, 0.11975708f, -0.31973243f, -0.16412421f, -0.14792247f, -0.06413930f, 
    -0.08991603f, 0.02576087f, 0.08594167f, 0.07476557f, -0.01701736f, 0.07938244f, -0.07438265f, 0.03931509f, 
    0.04040138f, 0.04688979f, 0.07498168f, -0.03806211f, -0.02471281f, -0.01522844f, -0.07550747f, -0.01566614f, 
    0.14227888f, -0.31597093f, -0.48694804f, -0.05210213f, 0.08070058f, -0.14732574f, -0.03713982f, 0.07650293f, 
    -0.14891644f, -0.06393214f, 0.02061850f, 0.04801599f, 0.00996813f, -0.14962469f, -0.10968035f, 0.05709827f, 
    -0.15176342f, -0.07863051f, 0.13462719f, 0.08406962f, -0.12116265f, -0.16911541f, -0.08743808f, 0.22280520f, 
    -0.06664462f, -0.08007832f, 0.06614600f, -0.03929134f, 0.11356547f, -0.07876243f, -0.22509901f, -0.07695612f, 
    0.05575852f, 0.07434993f, 0.06695610f, 0.04745486f, -0.04935421f, 0.12271762f, 0.01527996f, 0.06606588f, 
    -0.16366839f, 0.08001264f, -0.13516863f, 0.10976204f, 0.17940623f, -0.18958689f, -0.03789910f, -0.04947044f, 
    -0.08414986f, 0.06632992f, 0.00729189f, 0.20254476f, -0.04702118f, 0.03317570f, 0.00161353f, 0.15051202f, 
    -0.07880717f, 0.02009589f, -0.21363378f, 0.00303460f, 0.19220446f, 0.13457143f, 0.20930830f, 0.02413014f, 
    -0.12067705f, -0.20712905f, -0.02726470f, -0.01197315f, -0.17170833f, -0.05051937f, -0.07366574f, 0.07718943f, 
    -0.06469668f, 0.09670445f, 0.05242595f, -0.10765048f, -0.10011213f, -0.00499702f, -0.14562906f, -0.12414396f, 
    0.27731028f, -0.05298861f, 0.31827596f, 0.06394526f, 0.04357091f, -0.01198256f, -0.30082101f, 0.06798897f, 
    -0.11011007f, -0.17178032f, -0.01926010f, 0.04931588f, -0.01038393f, -0.00840940f, 0.00584269f, -0.02046348f, 
    -0.05205895f, 0.00449867f, 0.04711793f, 0.09720019f, -0.18816857f, 0.00929007f, -0.35423136f, 0.18035150f, 
    0.18281467f, 0.00745525f, 0.08203431f, -0.02370546f, 0.01869960f, -0.04192279f, -0.14355302f, -0.05281061f, 
    -0.03140249f, 0.01817931f, 0.08405349f, 0.15613195f, 0.03587707f, -0.02792601f, -0.00164125f, -0.04697177f, 
    -0.15815882f, -0.02983257f, -0.16531049f, 0.19403328f, 0.03647951f, -0.08216918f, -0.05020070f, -0.02621429f, 
    -0.05429853f, -0.02285491f, 0.00806727f, 0.00456681f, -0.12414464f, -0.10393122f, -0.11802687f, 0.03919086f, 
    -0.07121831f, 0.00355647f, -0.06598122f, -0.21139207f, 0.04825947f, -0.06291661f, -0.05444558f, 0.20799157f, 
    0.01979277f, -0.00236972f, 0.07447294f, 0.03133688f, 0.07875749f, -0.01630493f, -0.11434993f, 0.00093051f, 
    0.07041903f, 0.06662355f, -0.00451489f, 0.01584659f, 0.06715450f, 0.10832885f, 0.04250772f, -0.11942246f, 
    -0.17329405f, 0.08679066f, 0.18044250f, 0.39468515f, -0.19796839f, 0.00074793f, -0.12797621f, 0.14556566f, 
    0.12186034f, -0.18389487f, -0.07064603f, -0.06037252f, -0.04616116f, 0.01141892f, -0.01551165f, 0.04761052f, 
    -0.05515729f, 0.11269876f, -0.02723029f, -0.12944812f, 0.05120444f, -0.12317471f, 0.16325012f, -0.29821697f, 
    -0.23350260f, -0.03652482f, -0.05650110f, 0.00712947f, -0.00350147f, -0.03448664f, -0.01913737f, 0.00057585f, 
    0.09910123f, 0.05092941f, -0.04587737f, 0.03668424f, -0.00589833f, -0.06301449f, 0.11797667f, 0.03424998f, 
    -0.12903528f, -0.18609039f, 0.03266210f, 0.01198073f, 0.15135700f, 0.06571335f, 0.03889093f, -0.12348472f, 
    0.08824649f, 0.00659422f, 0.01382355f, 0.12635905f, -0.05604365f, -0.01134702f, 0.05031580f, -0.06085209f, 
    -0.05058225f, -0.04426752f, -0.12865081f, -0.14284533f, 0.11490498f, -0.08737825f, 0.21675506f, -0.01018594f, 
    -0.01233066f, 0.08888768f, 0.13420303f, 0.05177725f, 0.05920915f, -0.05087588f, 0.12057863f, 0.01164987f, 
    0.10789108f, 0.05635219f, 0.12615781f, 0.07118065f, 0.02080919f, -0.03858321f, -0.06661123f, -0.11530387f, 
    0.03698730f, -0.18558025f, -0.15981434f, 0.10338686f, 0.06337349f, -0.09861171f, -0.14374934f, -0.03391595f, 
    -0.03853431f, -0.06732418f, 0.02246668f, 0.00668240f, -0.10447503f, 0.00421758f, 0.00314840f, 0.00434145f, 
    -0.04241524f, 0.08795863f, 0.03596019f, -0.04979915f, -0.09715115f, -0.05427255f, 0.08943652f, 0.18066645f, 
    0.02044966f, 0.13805100f, 0.15603016f, 0.00333687f, 0.10460337f, -0.05781928f, -0.12217028f, 0.06691071f, 
    0.07405790f, 0.02978129f, -0.00945680f, 0.00417255f, 0.01634698f, 0.04832560f, -0.05282335f, 0.12544769f, 
    0.04118844f, 0.05378668f, 0.30228317f, 0.22141694f, 0.02760020f, 0.02987116f, -0.06494696f, 0.07312292f, 
    0.13747878f, -0.17847025f, -0.06010443f, -0.01448380f, 0.05819092f, 0.04145789f, 0.04902799f, 0.10162012f, 
    -0.09044135f, 0.03544266f, 0.11553638f, -0.02076503f, -0.09065425f, -0.25327882f, 0.06086693f, 0.11199449f, 
    0.05583451f, -0.03109000f, -0.04774547f, 0.02194716f, 0.03466806f, -0.07024871f, -0.03513083f, -0.02369336f, 
    -0.02030213f, -0.13926911f, 0.03660287f, -0.06380386f, -0.01946743f, 0.05316266f, -0.06906068f, -0.12849817f, 
    -0.14486475f, -0.05478699f, -0.18997334f, 0.14195773f, -0.21306640f, -0.10051797f, -0.05986866f, 0.08986615f, 
    -0.08574864f, -0.03813230f, -0.01918537f, 0.03643379f, 0.03159622f, 0.01166537f, -0.01217506f, 0.03045198f, 
    0.06157893f, 0.02771041f, 0.02427174f, 0.11472100f, -0.04101861f, -0.23165491f, -0.12015405f, 0.15692899f, 
    -0.03818829f, 0.01168793f, -0.08262144f, 0.01475735f, -0.12394638f, -0.01534191f, -0.01775413f, -0.01599320f, 
    0.09461509f, 0.04243969f, 0.01047549f, 0.06323604f, 0.00087489f, 0.07312133f, 0.05467690f, 0.03811719f, 
    -0.07320070f, -0.00823653f, 0.06535047f, 0.10176527f, -0.06972263f, -0.01918420f, -0.01837974f, 0.03418273f, 
    -0.04320380f, 0.02165973f, 0.03586569f, -0.01120512f, -0.02493291f, -0.02505792f, 0.02713820f, 0.02842735f, 
    -0.05864862f, -0.02048778f, -0.00495856f, -0.10931256f, -0.06081064f, -0.16654135f, 0.20756088f, -0.28450969f, 
    -0.09080806f, -0.17144598f, -0.27753064f, -0.09506428f, 0.22222741f, -0.28069499f, -0.10044980f, -0.03758897f, 
    0.02850983f, 0.02029238f, 0.04573838f, 0.12125488f, 0.02511701f, 0.00852942f, 0.26153225f, -0.05403939f, 
    0.44806159f, -0.06942914f, 0.30664462f, -0.13140965f, -0.11238392f, 0.00325344f, -0.05420967f, -0.01627448f, 
    0.03319063f, -0.01754964f, -0.06498795f, 0.06373465f, -0.02825890f, -0.10233613f, -0.05409915f, -0.04137961f, 
    0.12627874f, -0.00765816f, 0.10932075f, 0.09692438f, -0.20518960f, 0.03947509f, -0.14549181f, -0.04729019f, 
    0.10704152f, 0.00442010f, 0.06693022f, -0.02878662f, -0.01764580f, -0.04296996f, -0.04762514f, 0.01500427f, 
    0.03556472f, -0.03347008f, 0.03642471f, 0.01275301f, -0.04142360f, -0.01983608f, 0.00935550f, -0.07128243f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.10766867f, 0.07726050f, 0.03453911f, -0.06454588f, -0.00676006f, 0.02182858f, 0.01791284f, -0.09802467f, 
    0.01902308f, 0.02674983f, -0.00636887f, -0.01310997f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
