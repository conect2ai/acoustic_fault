#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.11031616f, 1.14993548f, -0.13202399f, -0.94856763f, -0.13725699f, 0.25429440f, -0.12965974f, -0.07839477f, 
    -0.05798612f, 0.17071287f, -0.03425117f, 0.05751864f, -0.07182299f, 0.36924288f, -0.04403303f, -0.08180903f, 
    0.19392969f, -0.21779197f, 0.03962988f, -0.20911776f, -0.11739320f, 0.12568298f, 0.29623985f, 0.06372242f, 
    0.13498373f, 0.87565368f, -0.01852397f, -0.54259425f, 0.43717325f, -0.04049718f, 0.38463977f, 0.07547265f, 
    -0.34633121f, 0.01067344f, -0.06603625f, -0.25176355f, 0.54195118f, 0.20743772f, 0.40862814f, 0.15924481f, 
    0.18231232f, -0.31684953f, 0.30971611f, 0.41285765f, -0.13124065f, -0.20177445f, -0.02086727f, -0.20157863f, 
    -0.18806775f, 0.29937488f, -0.45493680f, -0.82041788f, -0.61504054f, -0.38880527f, -0.17812312f, 0.24127352f, 
    0.92537159f, 0.23801555f, 0.30006886f, 0.54275507f, -0.01282894f, -0.31388694f, -0.29096931f, -0.34612939f, 
    -0.08646239f, -0.08866767f, 0.01397542f, 0.08846120f, -0.07798675f, -0.11863453f, -0.07311573f, -0.24625592f, 
    0.13965712f, -0.12789688f, 0.14176062f, -0.03614715f, 0.07674294f, 0.82151568f, -0.41070369f, -0.46365130f, 
    -0.70038211f, 0.25539300f, -0.56207025f, -0.21296780f, 0.17359221f, 0.22189260f, -0.07460955f, -0.42861637f, 
    -0.45115128f, 0.18422985f, 0.25450325f, 0.16449516f, 0.03634666f, 0.07549603f, 0.37071371f, -0.09020817f, 
    -0.24222991f, -0.32058936f, -0.22263573f, -0.01645501f, 0.82981157f, 0.52216321f, 0.88672072f, 0.51470453f, 
    0.39009154f, -0.60516155f, 0.12215231f, -0.33793199f, -0.55766267f, -0.09722043f, 0.30660799f, 0.19793659f, 
    -0.30800262f, 0.41627541f, 0.39079490f, -0.00056894f, -0.06586685f, 0.28322875f, 0.09778706f, 0.30268618f, 
    -0.21217956f, -0.15161319f, 0.04743789f, 0.11612491f, 0.12992422f, 0.37841788f, 0.32761881f, 0.75831169f, 
    0.08519378f, 0.45341656f, -0.38724142f, -0.32515317f, 0.26563981f, 0.10493425f, 0.41402140f, 0.35899428f, 
    -0.16734494f, -0.12242480f, 0.06965028f, 0.35079801f, -0.25570405f, 0.01073730f, 0.30033928f, -0.22914237f, 
    -0.27928391f, -0.23579393f, -0.18231587f, -0.11462735f, -0.46480349f, 0.20022325f, 0.92070973f, -0.07322219f, 
    0.26442850f, 0.14866611f, 0.23975717f, -0.30066395f, 0.64660501f, 0.01414378f, 0.39496589f, 0.55423021f, 
    -0.38041416f, 0.07880928f, -0.47262034f, -0.21928634f, -0.56476903f, 0.06331144f, 0.21502936f, -0.52155936f, 
    -0.17064765f, -0.16252665f, -0.15277451f, 0.03758884f, 0.27256036f, -0.11712755f, -0.03377433f, -0.63245088f, 
    0.25930947f, 0.21547993f, 0.52846956f, 0.11636429f, 0.02676678f, 0.53513533f, 0.51858473f, -0.20182368f, 
    0.44270778f, -0.14721467f, -0.18429393f, 0.39700690f, -0.21553610f, -0.19791597f, -0.28948724f, -0.44037849f, 
    -0.15077125f, -0.15800729f, -0.21583799f, -0.03420450f, -0.07365408f, 0.11284634f, 0.31395814f, -0.29372907f, 
    0.55554867f, 0.28251469f, -0.70574039f, -0.73176432f, -0.38658348f, 0.38291481f, -0.21114439f, -0.61254066f, 
    -0.18675110f, -0.52298057f, 0.15010086f, -0.27809250f, 0.18938641f, 0.39419204f, 0.10666247f, 0.31618932f, 
    0.22583406f, 0.01548588f, 0.17482239f, 0.30728355f, 0.07000484f, -0.13605094f, -0.11075757f, -0.17713681f, 
    0.28905165f, -0.17972055f, 1.07796133f, 0.48668081f, -0.02969994f, 0.41687086f, -1.02367532f, 0.45522973f, 
    -0.52787095f, -0.65070474f, 0.28072730f, -0.05775452f, 0.34128815f, -0.12829261f, -0.06786128f, 0.09802894f, 
    -0.13902447f, -0.44998845f, -0.10814674f, -0.39260375f, -0.29481667f, 0.26181105f, 0.18894297f, 0.04184104f, 
    0.06411187f, 0.02269645f, 0.37242460f, 0.50037318f, -0.41449967f, -0.26169103f, 0.22408235f, 0.32607633f, 
    0.36642292f, 0.38428268f, 0.52350557f, 0.65056807f, -0.23228578f, 0.30718541f, -0.12012115f, -0.08822269f, 
    0.18731548f, 0.06790408f, -0.13202631f, -0.05224913f, 0.05999487f, 0.14911073f, -0.51785761f, 0.40550721f, 
    -0.26234412f, 0.37943026f, -0.33947766f, -0.08254136f, 0.77958494f, -0.44378245f, -0.12584835f, -0.54798108f, 
    0.33691737f, -0.54665899f, -0.65154362f, -0.25432092f, -0.57945746f, 0.36808744f, 0.12304616f, -0.14991364f, 
    0.10512221f, -0.17357083f, 0.11928320f, 0.14693756f, -0.34939066f, -0.02364309f, -0.13775447f, -0.11395596f, 
    0.15732637f, 0.05807076f, -0.23749807f, 0.00085243f, 1.03804433f, 0.65296215f, 0.20430788f, 0.89473838f, 
    0.92885846f, 0.24992348f, 0.29715118f, 0.21873936f, 0.25346473f, -0.21890604f, -0.03921304f, 0.26523754f, 
    0.32941058f, 0.02280643f, 0.05819051f, -0.06802677f, -0.09973063f, 0.23644917f, -0.15046595f, -0.04221604f, 
    -0.14517537f, -0.25158259f, -0.00764989f, 0.02279169f, 0.01133092f, -0.22022824f, -1.37810326f, 0.53500497f, 
    0.59127104f, 0.53504103f, 0.62677050f, 0.29264617f, 0.62020540f, 0.04854621f, -0.14067918f, 0.01598491f, 
    0.10030152f, -0.29087123f, 0.51473761f, -0.01376211f, 0.04332661f, 0.20455432f, 0.01471135f, 0.31312978f, 
    0.18889084f, 0.07255170f, 0.21003607f, 0.05617735f, -0.10044308f, -0.08866694f, 1.02917337f, 0.70536816f, 
    0.53396386f, -0.74666679f, -0.92897534f, -0.11809500f, -0.69950992f, 0.07187574f, -0.30770770f, -0.14819174f, 
    0.36803925f, 0.28423887f, -0.07166164f, 0.12226947f, -0.08479427f, -0.03829185f, -0.09127133f, 0.02857269f, 
    -0.10504916f, -0.09558461f, -0.10481516f, 0.25499895f, 0.09141651f, 0.19500415f, -0.15022820f, -0.49829057f, 
    -0.30602571f, -0.38203451f, -0.44977912f, -0.47582114f, -0.23746620f, -0.42454669f, -0.53507632f, -0.51895636f, 
    -0.38730338f, -0.38482139f, -0.15931548f, -0.25905970f, 0.00046067f, -0.31513360f, 0.18237445f, 0.28982303f, 
    -0.01057226f, 0.00782801f, 0.20878136f, 0.18045013f, 0.19691989f, 0.30763280f, 0.13344926f, -0.25732672f, 
    0.38919020f, 0.47249076f, 0.41420320f, -0.13225536f, -0.15355156f, -0.43165880f, -0.54586494f, 0.21593688f, 
    0.01785203f, 0.41847864f, 0.45762086f, 0.56000066f, -0.35938036f, 0.07005879f, -0.10648324f, 0.41482395f, 
    0.08885598f, -0.42145619f, 0.18484019f, 0.18535464f, -0.29763836f, 0.07372424f, 0.07561943f, -0.35664430f, 
    0.12693709f, 0.61011946f, 0.13121036f, -0.44008115f, 0.85761082f, -0.71585643f, -0.09857687f, 0.04941449f, 
    0.40677953f, -0.31279638f, 0.18362579f, -0.10911762f, -0.38364413f, 0.21540584f, -0.35748395f, 0.29331419f, 
    -0.21507870f, -0.76038212f, -0.06732570f, -0.18836388f, 0.05653913f, 0.58575761f, 0.11119915f, -0.04342975f, 
    0.25313860f, -0.30222559f, 0.26435187f, -0.40948078f, -0.10597772f, -0.38591123f, -0.37149984f, 0.49848929f, 
    0.49508223f, 0.18851528f, -0.08558449f, 0.28354600f, 0.28039718f, 0.19463027f, 0.19173747f, 0.08695877f, 
    -0.53506333f, -0.16244477f, 0.20822959f, -0.37186754f, 0.00253516f, 0.48560932f, 0.23212662f, -0.27518174f, 
    -0.22926158f, -0.30617133f, -0.10082521f, 0.47313666f, 0.77495658f, -0.19072732f, -0.15454954f, -0.45111826f, 
    0.26524177f, -0.31939900f, -0.62911761f, -0.28685752f, -0.02546719f, -0.00721292f, -0.43286407f, -0.42455789f, 
    0.08521771f, -0.55683059f, -0.43511185f, 0.20354858f, 0.18759704f, -0.16392410f, -0.33672890f, -0.54545808f, 
    -0.02351865f, -0.07210607f, -0.43047059f, -0.19202925f, -0.52613145f, 0.96113867f, 0.88198018f, -0.20881312f, 
    0.69247675f, 0.78164089f, 0.29009107f, -0.53997773f, -0.26813424f, -0.41618067f, -0.20316803f, -0.26107165f, 
    0.23706678f, 0.12726313f, -0.36694077f, 0.01145953f, 0.01252717f, -0.19917217f, -0.33078864f, -0.02257287f, 
    -0.19045874f, -0.06600392f, -0.11139621f, -0.18819997f, -0.22114061f, -1.13117409f, 0.19318748f, 0.51097643f, 
    -0.32934168f, -0.51944911f, 0.48037040f, 0.70343405f, -0.55930740f, 0.07992341f, 0.40460971f, -0.16998662f, 
    -0.25528488f, 0.01639853f, -0.41203380f, -0.11059631f, 0.18624938f, -0.08206498f, -0.00042636f, -0.10520300f, 
    -0.02537469f, 0.06145004f, -0.05926275f, 0.12522048f, 0.08812909f, 0.05544638f, -0.28143647f, -0.64005738f, 
    -0.56265032f, -0.05952725f, 0.02055456f, 0.62638295f, 0.56681055f, -0.19190049f, 0.46840528f, 0.39786196f, 
    0.29271084f, 0.10234163f, -0.02051659f, 0.24637602f, 0.20187365f, 0.21256955f, -0.06157155f, -0.31044543f, 
    0.06253313f, -0.00034901f, -0.19045092f, -0.40917620f, -0.05190482f, -0.15432264f, -0.00463146f, -0.53921628f, 
    -0.71610993f, 0.14644632f, 0.51196021f, 0.47323367f, -0.59343392f, 0.53192812f, -0.19221970f, -0.83840126f, 
    -0.19609925f, 0.40527719f, 0.31496903f, 0.04284770f, -0.11229990f, 0.15952234f, -0.56424373f, 0.16575712f, 
    0.35521892f, -0.11595744f, -0.36755291f, -0.21946152f, 0.20965429f, 0.02349715f, 0.23246539f, 0.18592753f, 
    -0.61975002f, -0.14447412f, 0.17325303f, -0.26130015f, 0.51963079f, -0.82259148f, 0.67211777f, 0.36103901f, 
    -0.88998020f, 0.09662727f, -0.57204884f, 0.41943669f, 0.44389880f, 0.05793999f, -0.10024045f, 0.26991802f, 
    -0.25890696f, 0.09699760f, 0.14537990f, 0.02438296f, 0.03249020f, -0.30091685f, 0.10647573f, 0.19784184f, 
    0.05025110f, 0.72383088f, 0.63182628f, 0.35515818f, 1.00371599f, 0.47890186f, 0.32931504f, 0.19323651f, 
    -0.46774361f, 0.37970254f, 0.33547038f, 0.10915648f, -0.21689911f, -0.12782286f, 0.35700327f, -0.27118477f, 
    0.02433246f, 0.03161164f, 0.44439301f, 0.25407234f, -0.28779957f, 0.13121235f, -0.01975488f, -0.14959486f, 
    0.02178520f, 0.27167752f, 0.39968002f, 0.23383017f, -0.54902679f, -0.62314606f, -0.59963745f, 0.60202247f, 
    0.25175339f, 0.01662173f, 0.13507761f, -0.23256983f, 0.30157429f, 0.04638401f, 0.26780942f, -0.19222216f, 
    0.05473895f, -0.01828962f, -0.32072276f, 0.11406086f, 0.13266079f, -0.05183229f, -0.12462533f, -0.13522500f, 
    -0.17402497f, 0.48902366f, -0.01941444f, 0.15201604f, 0.61683297f, 0.49783650f, 0.60355693f, 0.43384168f, 
    -0.66681468f, 0.27358359f, -0.00481501f, 0.19132158f, 0.31247312f, -0.16705988f, -0.19096698f, -0.11476981f, 
    -0.31014368f, -0.22407570f, 0.31598952f, 0.24880286f, -0.40463307f, 0.13329314f, -0.03972507f, -0.10319677f, 
    -0.12325712f, 0.01907010f, 0.44420141f, -0.36744857f, 0.91793513f, -0.17562804f, 0.44925416f, 0.87103474f, 
    0.51206475f, 0.59438598f, 0.48250365f, -0.03755996f, -0.48103207f, -0.32243752f, -0.34869492f, -0.11816670f, 
    -0.21253748f, -0.14602390f, -0.15404211f, -0.27368724f, 0.16360636f, -0.08072729f, 0.21632464f, -0.17256801f, 
    0.16988587f, 0.12203479f, -0.11355197f, 0.02274883f, 0.15669982f, -0.35294679f, 0.15143037f, -0.35330021f, 
    -0.59118557f, -0.32522199f, 0.41044033f, 0.22029774f, 0.30156836f, 0.57798886f, 0.49702331f, -0.54200745f, 
    -0.07459043f, -0.02262973f, -0.25067759f, 0.05963493f, 0.18094036f, 0.00491118f, -0.33932018f, 0.19589844f, 
    0.42358306f, -0.06669919f, -0.43147227f, -0.29262340f, -0.31531990f, -0.30537397f, -0.28022778f, -0.08818487f, 
    0.17255433f, -0.25709054f, 0.23627287f, -0.35333917f, -0.38286623f, -0.04517436f, 0.02186949f, -0.57692879f, 
    -0.25440186f, 0.22075267f, 0.24686739f, 0.10999344f, 0.01015043f, -0.16945638f, 0.23744449f, 0.21507838f, 
    -0.15629290f, 0.41387004f, 0.22071506f, 0.51421517f, -0.25074229f, -0.15587975f, 0.51864260f, -0.59551531f, 
    -0.78305364f, -0.10569155f, 0.43634540f, 0.29010084f, -0.51809353f, 0.19129224f, 0.58578849f, -0.39119563f, 
    0.11264192f, 0.29509783f, -0.16045555f, 0.21757269f, -0.35671699f, 0.41253263f, -0.08246318f, 0.26342329f, 
    -0.01082231f, -0.13104972f, -0.20558348f, -0.05095139f, 0.06027317f, -0.38125974f, -0.14049327f, 0.11143024f, 
    0.07051446f, -0.23443036f, -0.56549692f, -0.55242056f, 0.47037160f, 0.27773276f, -0.02179166f, -0.35359564f, 
    0.03956493f, 0.34267014f, 0.27115390f, -0.39197546f, -0.16442747f, -0.11568680f, 0.16034538f, -0.30889508f, 
    -0.23482722f, 0.17315948f, -0.42959234f, -0.18229516f, 0.12900899f, 0.21343961f, -0.24419416f, 0.49208584f, 
    0.22142240f, -0.60750461f, 0.34755692f, -0.00114732f, 0.65601826f, -0.57262474f, -0.20479451f, 0.28900236f, 
    0.39483061f, 0.16676198f, -0.60810500f, -0.37044936f, -0.09363591f, -0.60537398f, -0.32338351f, -0.46703660f, 
    -0.21623802f, -0.05679760f, 0.22753601f, 0.36409622f, -0.03258076f, -0.05717037f, -0.46730986f, -0.26548237f, 
    -0.28878471f, -0.36547649f, 0.91585279f, 0.30578780f, -0.82099193f, -0.71755862f, -0.00734875f, 0.14607209f, 
    0.04253391f, 0.07433418f, 0.05399237f, 0.16731450f, -0.10583007f, 0.05248721f, -0.18352894f, -0.11575668f, 
    0.25229916f, 0.13586190f, -0.20332722f, -0.47138488f, 0.18971187f, 0.57016879f, -0.08788271f, 0.30332902f, 
    0.01774422f, -0.22597417f, -0.23228775f, -0.71492016f, 0.02264691f, 0.71697664f, -0.71674746f, -0.69355249f, 
    0.46846083f, -0.18520316f, -0.36356151f, -0.40326560f, -0.24084957f, -0.10570837f, 0.54601151f, 0.19378273f, 
    -0.00613019f, 0.33940578f, -0.15892753f, -0.03178158f, -0.16655211f, -0.15279344f, 0.08565601f, 0.24384075f, 
    0.22609878f, 0.03685417f, 0.08242385f, 0.38863987f, -0.87228501f, 0.46928078f, 0.14364840f, -0.55555516f, 
    0.73421079f, 0.75296247f, -0.33415547f, -0.72834796f, 0.38004276f, -0.17461772f, 0.31279591f, -0.15131889f, 
    -0.46233669f, -0.05141183f, -0.14951947f, -0.16858189f, -0.13338073f, 0.27460483f, -0.33504272f, -0.19997214f, 
    0.06466535f, 0.15112700f, -0.14785630f, 0.19860023f, -0.29023874f, -0.34440565f, 0.16190308f, -0.28802261f, 
    0.16681251f, -0.58676922f, 0.36877051f, -0.35301456f, -0.13409150f, 0.13775368f, 0.54890710f, -0.41806027f, 
    -0.14413032f, -0.35126883f, -0.05940867f, -0.24481376f, 0.26655549f, 0.49423513f, 0.24471468f, 0.04915402f, 
    0.20804146f, -0.26249394f, -0.31105524f, -0.26099291f, -0.27427959f, -0.10358633f, 0.23288767f, -0.51164597f, 
    0.26913169f, -0.26131424f, 0.43766978f, -0.39631033f, -0.96596974f, -0.53157961f, -0.42296383f, -0.37132156f, 
    0.24005488f, 0.28213128f, -0.08109991f, 0.05483769f, 0.11211419f, 0.29429674f, 0.18749128f, -0.05445237f, 
    0.17936596f, -0.37027621f, 0.11332707f, -0.19304952f, -0.28971180f, 0.09933093f, 0.34420961f, -0.26596475f, 
    -0.61756998f, -0.71500683f, -0.68342793f, -0.42867839f, 0.42308250f, -0.47634387f, -0.37262025f, 0.01635690f, 
    0.24084106f, -0.28091523f, -0.30166060f, 0.18766771f, 0.07935597f, -0.08834811f, -0.05731042f, 0.32441488f, 
    -0.07895102f, 0.28458810f, 0.31205076f, -0.20454489f, 0.04305863f, -0.03815040f, -0.03753514f, 0.26422048f, 
    0.26835960f, -0.69075608f, 0.53015119f, 0.62516683f, -0.52166468f, 0.33882314f, -0.85887891f, 0.74041617f, 
    0.03986695f, -0.19095586f, -0.02814239f, -0.43107486f, -0.13059452f, 0.09515443f, -0.21535124f, 0.35609201f, 
    0.34678376f, -0.39465374f, -0.09107260f, 0.07353272f, 0.09597221f, 0.34215525f, 0.43704134f, 0.08474541f, 
    0.29220337f, -0.22471702f, -0.06687284f, 0.61224717f, 0.13014586f, 0.51643848f, -0.46498027f, -0.73308450f, 
    -0.68167704f, -0.71775788f, -0.49184504f, 0.10881203f, 0.17079191f, 0.08211162f, 0.29983336f, 0.05003323f, 
    -0.13349020f, -0.18050054f, 0.29184893f, -0.15506925f, 0.51913786f, -0.14289184f, -0.08324682f, 0.08182681f, 
    0.50684905f, -0.18383305f, -0.38684770f, -0.89757514f, -0.29136071f, -0.47342879f, -0.55056971f, -0.18915176f, 
    0.02288187f, 0.56901062f, 0.30147848f, -0.14944725f, 0.39996836f, -0.11872210f, -0.06230202f, 0.19558091f, 
    -0.16424799f, 0.08146548f, -0.02375535f, 0.11515060f, -0.39900431f, 0.16638289f, 0.17706196f, -0.32381529f, 
    0.23366651f, -0.03034150f, -0.24722019f, 0.92713177f, 0.31012246f, 0.20424598f, 0.92762130f, 0.95471323f, 
    0.08365318f, -0.21017978f, -0.21975401f, 0.38607341f, -0.04353935f, -0.41839984f, -0.16494082f, -0.13745990f, 
    0.08550692f, 0.13570534f, 0.26934007f, 0.21570194f, 0.11821988f, -0.12700126f, 0.08164329f, 0.45058167f, 
    0.11608026f, 0.18525091f, -0.10813478f, -0.00001536f, -0.61409885f, -0.32127279f, 0.12848938f, -0.30690575f, 
    -0.40947613f, -0.13310975f, -0.17054883f, 0.12558146f, -0.46654609f, -0.21815111f, -0.03986829f, -0.19468619f, 
    -0.20452024f, -0.22308545f, 0.19391313f, 0.38527894f, 0.21020734f, 0.09082830f, 0.32603145f, 0.38197204f, 
    0.39195919f, 0.25157565f, 0.13385881f, 0.23090452f, 0.16951962f, -1.14743590f, 0.13243715f, -0.01112534f, 
    0.35881877f, -0.82863230f, 0.42749473f, 0.58483171f, -0.26255184f, 0.47049993f, 0.26841161f, 0.16712828f, 
    -0.22856076f, -0.16861124f, -0.14838780f, 0.20762554f, -0.13244879f, 0.18934138f, -0.13038713f, -0.05096867f, 
    -0.14080372f, -0.14679310f, 0.19541335f, 0.29583016f, 0.47309020f, -0.02350315f, -0.61410695f, -0.77340478f, 
    -0.63565654f, -0.10055561f, -0.02321837f, 0.45973226f, 0.32061172f, 0.57006299f, 0.44036508f, -0.41447964f, 
    -0.24939719f, -0.25095692f, -0.00054434f, 0.29275841f, 0.04705371f, 0.10364793f, -0.01023664f, -0.32892969f, 
    -0.11948121f, -0.19697326f, -0.28524333f, -0.03944175f, 0.17847136f, -0.19546078f, 0.25891325f, 0.21389885f, 
    -0.64911228f, -0.60152501f, -0.61915499f, 0.21431249f, 0.70624822f, -0.14391486f, -0.13122164f, 0.18835235f, 
    -0.00454519f, 0.11936648f, -0.32310894f, 0.23898752f, -0.15925251f, -0.28504708f, -0.03546517f, 0.15834299f, 
    -0.35043150f, 0.30081582f, -0.07085784f, 0.20439453f, 0.14575127f, -0.21441676f, 0.35146043f, 0.16818914f, 
    0.49799141f, 0.41242415f, 0.87921458f, 0.62489802f, 0.09091117f, 0.26187125f, 0.09731608f, -0.82132792f, 
    -0.74396276f, 0.12212995f, 0.44679070f, 0.34360611f, 0.08804232f, 0.15319541f, -0.00196222f, 0.02833846f, 
    -0.45878610f, -0.09307741f, 0.29595315f, -0.16766076f, 0.17464656f, 0.42633545f, 0.06046020f, 0.08124544f, 
    0.29451722f, 0.64929366f, -0.57376552f, -0.60544568f, -0.53897744f, 0.43107814f, 0.02227441f, 0.39461604f, 
    -0.07461977f, 0.06459064f, 0.50122368f, -0.41895661f, 0.08803139f, -0.11209258f, 0.05106398f, 0.05332142f, 
    -0.18058407f, 0.18569300f, 0.26854548f, -0.28683445f, -0.25362343f, -0.00715832f, -0.25881085f, 0.38599119f, 
    0.34075800f, -0.10163411f, -0.62538904f, -0.39854008f, 0.02392613f, -0.09087695f, 0.59028810f, 0.80571777f, 
    0.06656084f, -0.57184792f, -0.18679395f, -0.32289574f, -0.18304928f, 0.42710403f, 0.10607535f, 0.32639799f, 
    -0.04036633f, -0.29408574f, -0.26784199f, -0.42785811f, -0.42710075f, -0.24804559f, 0.31491736f, -0.19694614f, 
    0.08004251f, 0.09031212f, -0.39124796f, -0.16362691f, 0.62529719f, 0.50710410f, -0.01839716f, 0.55120873f, 
    0.49833307f, 0.42881006f, 0.36242875f, -0.55450702f, -0.45672858f, -0.38387188f, -0.10949513f, 0.28743586f, 
    0.36633202f, 0.37905985f, 0.24188863f, 0.44468212f, 0.06236273f, 0.26892188f, -0.22493419f, -0.21909675f, 
    0.18063729f, 0.08971494f, -0.04713786f, 0.43872875f, -0.87118912f, 0.57576597f, 0.35882768f, -0.45962304f, 
    -0.12248968f, 0.46605647f, 0.75497884f, 0.52596503f, 0.32242790f, 0.43200141f, 0.03762018f, 0.07685654f, 
    -0.35269639f, -0.38014078f, -0.31419915f, 0.32117951f, 0.15592542f, -0.18331581f, -0.17955250f, -0.14136088f, 
    0.00449575f, 0.05467384f, -0.17569031f, 0.01633724f, 0.29080924f, -0.46149912f, -0.02951476f, -0.74191207f, 
    -0.34162676f, -0.30085123f, -0.22940795f, -0.11879196f, 0.29037985f, -0.27117041f, 0.44231564f, 0.16812642f, 
    0.19634879f, 0.14405987f, 0.16938271f, -0.08355962f, -0.14707300f, -0.15614526f, 0.30570099f, 0.16619854f, 
    -0.04388129f, 0.40819642f, 0.03364839f, -0.26972285f, 0.09469920f, 0.19471964f, -0.64584368f, -0.19257845f, 
    -0.39529297f, -0.35455784f, -0.25379673f, -0.13700865f, -0.19321905f, 0.06235348f, -0.53820390f, 0.21125126f, 
    -0.13945335f, 0.46706966f, 0.29831746f, 0.08299536f, 0.18303271f, -0.56977671f, -0.45464244f, 0.36425349f, 
    0.15234226f, 0.03489141f, 0.04886423f, -0.06615157f, -0.63577878f, -0.07366820f, -0.32819352f, 0.60812193f, 
    0.16090053f, -1.04674721f, 0.65852475f, 0.38595933f, -0.20888641f, 0.02699105f, -0.49196100f, 0.48946649f, 
    -0.20286472f, -0.13982970f, 0.09434231f, -0.16286570f, 0.23350832f, 0.08573970f, 0.06385858f, -0.06855535f, 
    -0.23727202f, -0.27146199f, -0.01743761f, 0.13660012f, 0.22006594f, 0.19064398f, -0.00625036f, -0.03345139f, 
    -0.75720024f, -1.00292468f, -0.24410313f, -0.19981895f, -0.14212564f, 0.30943435f, -0.17281829f, 0.37710550f, 
    -0.33295155f, -0.10559073f, 0.20237717f, -0.07812114f, -0.16481410f, 0.39712748f, 0.40055144f, 0.01945687f, 
    0.23250510f, -0.24998318f, 0.15293220f, 0.03038882f, 0.22091459f, -0.20830506f, 0.12090892f, -0.14421837f, 
    -0.07698388f, -0.22246562f, -0.47667101f, -1.02880156f, 0.05244510f, 0.44073331f, -0.72027242f, 0.52901506f, 
    0.52295035f, 0.40281710f, 0.37502000f, 0.40360233f, -0.23885536f, 0.05842119f, -0.23930959f, 0.10274719f, 
    0.12127282f, -0.00945162f, -0.13576797f, -0.20671742f, -0.13672666f, 0.04435729f, -0.14278674f, -0.11092611f, 
    0.19198538f, -0.05679445f, 0.36977202f, -0.56491721f, -0.15091138f, -0.45817736f, -0.29157063f, 0.13257100f, 
    -0.45501152f, -0.36681795f, -0.38315472f, -0.57696509f, -0.26720542f, -0.05815685f, 0.21315886f, -0.13590652f, 
    0.28767690f, -0.20173320f, -0.29057872f, -0.26269329f, -0.05721683f, 0.03456615f, 0.43904367f, -0.04511928f, 
    -0.17856398f, -0.18722640f, -0.10659242f, -1.19660008f, 0.88991570f, 0.40636674f, -0.33704874f, 0.09819503f, 
    0.68802512f, -0.05581633f, 0.15993688f, 0.71767390f, -0.31352770f, -0.03990736f, -0.36520839f, -0.03967379f, 
    0.15879007f, -0.09752402f, -0.03760187f, -0.20897453f, -0.04656038f, -0.03362432f, 0.11007268f, -0.07127643f, 
    0.10539515f, 0.01540991f, 0.24364688f, 0.15691221f, 0.65039575f, 0.02162799f, 0.10887818f, -0.24279128f, 
    0.52490771f, 0.60439634f, 0.23327346f, 0.57778484f, 0.54396182f, 0.11766688f, -0.47347930f, 0.15527120f, 
    -0.29430744f, 0.29101056f, -0.04363573f, 0.26699126f, -0.14459616f, 0.12723282f, 0.26256302f, 0.46487075f, 
    0.29443535f, -0.13879795f, -0.17745757f, 0.03763304f, 0.33735043f, 0.16247301f, 0.63252622f, 0.10815944f, 
    -0.49155626f, -0.51305997f, -0.06695934f, -0.02075124f, 0.32178420f, 0.22873361f, 0.28636050f, -0.05170957f, 
    -0.00733417f, -0.31094226f, 0.33723459f, 0.26438302f, 0.28516960f, 0.13707542f, 0.02130024f, -0.17480972f, 
    0.43125135f, 0.33381194f, 0.38956815f, -0.02070402f, 0.14084746f, 0.51511061f, 1.01594067f, 0.27778482f, 
    0.58994389f, 0.09992422f, -0.43022093f, 0.20830034f, -0.37428477f, 0.06949971f, 0.51464206f, 0.47969645f, 
    -0.16563797f, 0.15573825f, -0.33898652f, -0.06059980f, -0.46666744f, 0.18382274f, -0.09752641f, -0.11076210f, 
    -0.21073517f, 0.16717905f, 0.13393843f, -0.39901534f, 0.21075469f, -0.18854542f, -0.10130268f, 0.46118852f, 
    -0.99986279f, 0.64171481f, 0.66230875f, 0.48624045f, -0.59991550f, 0.20512120f, 0.29612246f, 0.18620461f, 
    0.36819136f, 0.31839159f, 0.04316445f, -0.29296634f, -0.19682392f, -0.18550080f, -0.30020982f, -0.25053236f, 
    -0.20422620f, 0.05987680f, 0.04542091f, 0.17620382f, 0.08722667f, 0.06151189f, 0.04481511f, -0.12018580f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.10797955f, 0.25520870f, 0.07624231f, -0.08943050f, -0.01434011f, 0.19285297f, -0.03040625f, 0.09958851f, 
    0.35341364f, 0.34574717f, -0.01604775f, 0.18020628f, 0.15604290f, 0.28019750f, 0.26247117f, 0.11376044f, 
    0.06970580f, 0.11651808f, 0.08582029f, -0.01966954f, 0.03808568f, -0.15893243f, 0.01144381f, 0.21671928f, 
    0.18330239f, 0.11084574f, -0.01808451f, 0.31049722f, 0.06234345f, 0.10952006f, 0.01446476f, 0.16285183f, 
    0.09169678f, -0.07674825f, 0.13251333f, 0.29410952f, 0.02673841f, 0.02647151f, 0.10886472f, 0.19102554f, 
    0.13256676f, 0.30589479f, 0.17919615f, 0.18458760f, 0.14304437f, -0.08364200f, 0.02329168f, -0.00128250f, 
    0.21892345f, 0.11914539f, 0.06273720f, 0.01426449f, 0.02112314f, 0.19836979f, 0.13501437f, 0.28954735f, 
    0.32443053f, 0.02868353f, 0.06061739f, 0.01717366f, 0.23378019f, -0.02268449f, 0.25056300f, 0.16548578f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.19341573f, 0.03494267f, -0.01745560f, -0.25862885f, 0.08289014f, 0.01771780f, 0.06204955f, -0.00242298f, 
    0.05580019f, -0.01738441f, -0.05756808f, -0.10485148f, 0.11727455f, -0.11934225f, -0.04094346f, -0.04583246f, 
    -0.16911152f, -0.03866661f, -0.05426686f, 0.00254201f, 0.05075854f, 0.01538738f, -0.05851979f, 0.06627399f, 
    0.09572933f, 0.18629469f, 0.11715491f, -0.30126306f, 0.07688319f, 0.05862104f, 0.04147040f, -0.02531467f, 
    -0.04542365f, 0.08976991f, 0.00042583f, 0.09503401f, -0.05378570f, 0.06490029f, 0.08471247f, 0.07061087f, 
    0.04075642f, -0.03177259f, 0.04889304f, -0.04285111f, 0.11147343f, 0.09076738f, 0.01114496f, 0.07213064f, 
    0.20167880f, 0.12841707f, -0.15746379f, 0.03485547f, -0.29718453f, -0.08596130f, 0.02329854f, 0.11831984f, 
    0.04410592f, -0.03589595f, -0.06484979f, 0.00752697f, -0.02264490f, 0.03568832f, -0.06890074f, -0.05501814f, 
    -0.11365285f, -0.05636727f, 0.06010317f, -0.00796567f, -0.02404525f, 0.04056400f, -0.00733995f, -0.04525268f, 
    0.09692257f, -0.09462423f, 0.03836435f, 0.08764530f, -0.05157425f, -0.01128591f, -0.01447218f, 0.10177467f, 
    -0.02339234f, 0.15990014f, 0.09251432f, -0.07668249f, -0.05926222f, 0.14181837f, -0.04231171f, -0.01046817f, 
    -0.09218222f, 0.03997811f, -0.09118666f, -0.00160939f, 0.07082413f, 0.04820710f, 0.07282109f, 0.08870759f, 
    -0.20174153f, -0.03973600f, 0.13646649f, -0.29411522f, -0.10696691f, -0.00687388f, 0.03574686f, -0.03738194f, 
    0.07710710f, -0.06775072f, 0.02125476f, 0.12676764f, -0.03959700f, 0.04099913f, 0.15947796f, -0.06457528f, 
    -0.01727741f, -0.02490897f, -0.02999811f, -0.14337280f, -0.10559316f, -0.05615743f, -0.03876861f, -0.06241810f, 
    0.19878504f, -0.00420889f, -0.06687649f, -0.21370502f, -0.04431324f, 0.03902072f, 0.09774381f, -0.07005386f, 
    0.02901511f, -0.04787070f, 0.02796312f, -0.03113645f, -0.18791851f, 0.11877181f, -0.06752082f, -0.06522385f, 
    -0.14274451f, 0.05265801f, 0.00355236f, 0.02415216f, -0.06359997f, 0.00838969f, 0.00288149f, 0.01237494f, 
    0.17064768f, -0.04222029f, -0.09815805f, 0.08448725f, -0.23521250f, 0.04151972f, -0.00282644f, 0.08442518f, 
    0.03540728f, 0.01997847f, -0.03705083f, -0.05776430f, -0.06451423f, -0.01340591f, 0.01886187f, 0.11789892f, 
    -0.04331409f, 0.10091545f, 0.04473600f, -0.02946467f, 0.01508187f, -0.02701695f, 0.06368920f, -0.07182224f, 
    -0.25892949f, 0.06658565f, 0.10841766f, -0.14869505f, -0.07384725f, -0.02185517f, -0.10123853f, -0.02100390f, 
    -0.06980191f, -0.08622101f, -0.02161638f, 0.01337833f, -0.30276099f, -0.19973956f, 0.00894492f, 0.15962690f, 
    0.02030132f, -0.06650264f, -0.01295614f, 0.00278666f, -0.07156845f, -0.01592810f, 0.01176201f, -0.07201210f, 
    0.01803625f, -0.03161726f, -0.05964265f, 0.01960138f, 0.06645936f, -0.02464402f, -0.00946967f, 0.09506319f, 
    0.04162934f, -0.03643292f, 0.09969844f, -0.01449907f, -0.08685549f, 0.05776595f, -0.13911721f, 0.06404293f, 
    -0.03320246f, 0.04645140f, -0.13675372f, -0.15889920f, -0.01091192f, -0.04549271f, 0.07494274f, 0.04255936f, 
    -0.16004725f, 0.04648561f, -0.05869600f, -0.24688536f, 0.10480279f, -0.02536733f, -0.01278999f, -0.03203095f, 
    -0.03555665f, -0.02936345f, -0.05819067f, 0.02195272f, 0.03971659f, 0.06918219f, 0.10043407f, -0.19973183f, 
    -0.02613948f, 0.09370677f, 0.07846078f, 0.04367891f, 0.03617886f, 0.12446467f, -0.01645177f, -0.02364245f, 
    -0.20931804f, -0.12164690f, 0.06589524f, -0.08074085f, -0.10793122f, -0.01892478f, 0.04063098f, -0.00348427f, 
    0.04595845f, -0.06603405f, -0.01967780f, -0.04278963f, 0.64135092f, 0.03852174f, 0.30656216f, -0.06798795f, 
    -0.04644564f, 0.01704926f, 0.01102337f, 0.01128690f, 0.04013649f, 0.07801693f, 0.05043116f, -0.00892392f, 
    0.05363951f, 0.03469421f, 0.00450759f, -0.04208274f, -0.01847889f, 0.04288510f, -0.02684581f, 0.01594782f, 
    0.10779548f, 0.01886849f, -0.01495406f, 0.04924104f, -0.21168548f, 0.05059266f, -0.20911652f, 0.11329009f, 
    -0.03715427f, -0.15712237f, -0.05430788f, -0.02791066f, -0.07097894f, 0.03273847f, -0.17253767f, 0.05747706f, 
    -0.48502234f, -0.12167467f, -0.09565311f, 0.08144196f, -0.01241084f, 0.02576317f, -0.03643350f, 0.07387553f, 
    0.09551295f, 0.03066874f, 0.03092749f, -0.03900310f, 0.05508950f, -0.06203848f, -0.06502610f, 0.31259558f, 
    -0.13037947f, -0.04589241f, 0.04058548f, 0.04028763f, -0.02390285f, 0.01878769f, -0.01447618f, -0.05360573f, 
    -0.01188461f, -0.23328835f, -0.08036409f, -0.16101824f, -0.02321483f, 0.10960168f, -0.02617443f, -0.09118542f, 
    -0.01852301f, -0.01905180f, -0.00623937f, 0.04040779f, 0.02047281f, -0.05875971f, -0.03237261f, 0.12376514f, 
    -0.05202420f, 0.00674593f, -0.03197194f, -0.00779472f, -0.00640240f, -0.08127797f, -0.04364765f, 0.00774206f, 
    0.15772939f, 0.01151564f, -0.09031840f, 0.25805679f, -0.15582328f, -0.08009133f, 0.04261620f, 0.08197889f, 
    -0.12747383f, 0.05007621f, -0.02190273f, 0.00538547f, 0.25718799f, 0.01554663f, -0.11225955f, -0.10318098f, 
    -0.04115522f, -0.01547380f, 0.03198911f, -0.06099140f, -0.00567424f, -0.07426608f, -0.04110833f, 0.11487012f, 
    -0.06876101f, 0.05926895f, 0.05631202f, -0.08759028f, 0.02681765f, 0.01331550f, 0.03760920f, 0.08831178f, 
    -0.00386442f, -0.10299546f, -0.03905439f, -0.13594076f, -0.31711233f, 0.18658888f, -0.05332848f, 0.14809541f, 
    -0.00461448f, -0.02212677f, -0.03087034f, 0.01864907f, -0.04661451f, 0.00125041f, -0.04195993f, 0.05565270f, 
    -0.05148108f, -0.11305812f, 0.11791151f, -0.16326043f, -0.02050496f, -0.02458190f, 0.11754805f, 0.02855400f, 
    -0.00033198f, -0.10932110f, 0.01968292f, -0.05653676f, 0.00294097f, 0.16041419f, -0.00747667f, 0.15760846f, 
    -0.00369451f, 0.09606555f, 0.13350672f, -0.03455574f, 0.03109889f, -0.00878469f, 0.17842890f, -0.08011094f, 
    0.00396099f, -0.12493372f, 0.11370558f, -0.44988635f, -0.07605108f, -0.06859963f, 0.11231844f, 0.10059448f, 
    -0.09780085f, -0.05337184f, 0.00137113f, 0.08795399f, -0.29567558f, 0.22734675f, 0.21932949f, -0.04868992f, 
    0.01321570f, 0.06406595f, -0.00967042f, -0.02517338f, 0.02333155f, -0.00079224f, 0.01941154f, -0.02828185f, 
    -0.10530721f, -0.04402394f, 0.20068578f, -0.02788210f, 0.01030913f, -0.01462081f, 0.16279444f, -0.12337033f, 
    0.03807154f, 0.01597882f, 0.00937515f, 0.05860050f, 0.20896654f, 0.04593650f, -0.14083350f, 0.17419612f, 
    -0.00820190f, -0.00415533f, -0.00089679f, -0.02691786f, 0.02565235f, 0.07940188f, -0.01316126f, 0.08664899f, 
    -0.02320552f, -0.15153450f, 0.12922014f, 0.00068394f, 0.00142957f, -0.00174275f, 0.05008333f, -0.07107916f, 
    0.02403730f, 0.07291264f, 0.04135783f, -0.03330443f, 0.20770778f, -0.32229307f, 0.03483327f, -0.33470374f, 
    -0.01911428f, -0.05049634f, -0.00692263f, 0.01414717f, -0.10238934f, -0.02517191f, 0.07077900f, 0.05131304f, 
    0.06670088f, -0.13340904f, -0.08113710f, 0.28163975f, -0.01201656f, 0.06237315f, 0.02581956f, -0.06163269f, 
    -0.12456638f, -0.05533779f, 0.04836227f, -0.08510657f, -0.00044852f, 0.02402754f, -0.09433637f, 0.05725029f, 
    0.04887595f, -0.05347405f, -0.01734312f, -0.01616605f, 0.05814845f, -0.20135319f, -0.06844222f, 0.02868878f, 
    -0.05975236f, 0.09672062f, -0.11704767f, -0.23087043f, -0.09021468f, 0.09141207f, -0.00362082f, -0.00659994f, 
    -0.00271467f, 0.04506472f, -0.09573849f, 0.00279555f, 0.16975364f, -0.00999904f, -0.05364320f, 0.24053369f, 
    -0.01775017f, 0.05401418f, -0.04307412f, -0.02861603f, 0.03532829f, 0.00493943f, -0.00558161f, -0.04139298f, 
    -0.19384284f, 0.09778126f, -0.07215748f, -0.04223925f, 0.04830534f, 0.03925164f, 0.04635780f, 0.09797950f, 
    0.09468016f, -0.06019690f, 0.07080396f, 0.03222171f, 0.46681806f, 0.05892718f, -0.03321556f, 0.04672823f, 
    0.00127808f, 0.11690627f, -0.13053982f, -0.02315222f, 0.03159209f, 0.07280146f, -0.05700824f, 0.02559541f, 
    0.04656124f, 0.10332011f, -0.04635634f, -0.19983482f, 0.06974620f, -0.02142137f, -0.02005629f, 0.03694009f, 
    0.02405773f, -0.04315489f, -0.03445539f, -0.01039351f, 0.01375888f, -0.22366954f, 0.02000447f, -0.16561750f, 
    0.06297851f, -0.01040786f, 0.09519271f, 0.02804971f, -0.05396783f, 0.00570648f, 0.13272461f, -0.01690701f, 
    0.01488449f, 0.16351171f, 0.01165105f, 0.10864483f, -0.14994971f, 0.00538185f, 0.04121491f, 0.04796700f, 
    -0.14547974f, 0.03330650f, -0.06563807f, -0.03060203f, 0.01255387f, -0.08864831f, 0.12941644f, -0.20401369f, 
    -0.05385977f, 0.02248218f, -0.07047740f, 0.00647989f, -0.24351276f, 0.08976645f, 0.04368579f, -0.07819255f, 
    -0.37101063f, -0.12314102f, 0.17855693f, -0.07399446f, 0.14308199f, -0.03992392f, 0.04424197f, -0.04449129f, 
    -0.05067912f, -0.01987372f, 0.09686163f, -0.06840386f, -0.24971852f, 0.02729712f, 0.00522008f, 0.03019436f, 
    -0.11719931f, -0.05946557f, 0.07418314f, -0.01023344f, 0.03285631f, -0.02377764f, -0.01443395f, -0.03518595f, 
    0.27708742f, 0.09478989f, 0.19717224f, -0.04108008f, -0.00690241f, -0.02075966f, 0.07137319f, -0.10194090f, 
    -0.05753255f, -0.04971789f, -0.08289452f, 0.01753826f, -0.12197095f, -0.08758988f, -0.13695391f, -0.14575996f, 
    0.04712654f, -0.08843569f, 0.02935419f, 0.02466243f, -0.02128759f, -0.01120110f, -0.10825380f, -0.02675938f, 
    -0.19208701f, -0.18903071f, -0.02637080f, -0.02993905f, -0.05745176f, -0.06141318f, 0.12768190f, -0.08063924f, 
    0.05615792f, -0.05746636f, -0.02289564f, -0.02302880f, 0.04352205f, 0.03869633f, 0.02406440f, 0.03292766f, 
    -0.01652980f, -0.00824327f, -0.05266169f, 0.02597011f, 0.00573414f, -0.00634450f, 0.01191919f, -0.15457059f, 
    -0.20928304f, -0.07767262f, -0.02613014f, -0.00265290f, 0.09368519f, 0.10286888f, -0.16346034f, 0.02290499f, 
    0.09855844f, -0.06337630f, 0.03051727f, -0.04137814f, -0.26705733f, 0.42322063f, -0.00658949f, 0.07351089f, 
    0.01090160f, 0.05955034f, 0.00398510f, -0.06633078f, -0.02726567f, -0.00666482f, -0.05584522f, 0.03967042f, 
    -0.16725813f, -0.10237934f, 0.07802009f, -0.09064177f, 0.07185677f, 0.03023771f, 0.06116455f, -0.01294327f, 
    -0.02297119f, -0.00113370f, -0.16175714f, 0.06047574f, 0.18481678f, 0.00642010f, 0.05442920f, 0.10279535f, 
    -0.14611411f, -0.13982378f, 0.05579777f, -0.07172672f, -0.00198708f, -0.04274080f, 0.07478689f, 0.01209598f, 
    0.16562758f, -0.07787008f, -0.08050419f, -0.02211679f, -0.01753173f, -0.08082300f, -0.04585523f, 0.06290042f, 
    0.00092722f, 0.01038498f, 0.06402738f, 0.05965491f, -0.02462770f, -0.00310399f, -0.03105667f, -0.14993618f, 
    -0.01254881f, 0.06367885f, 0.04142851f, -0.05919510f, -0.01448827f, 0.06328759f, 0.04039643f, 0.06542368f, 
    0.11432011f, -0.03299196f, -0.14087532f, 0.12330509f, 0.00047003f, -0.21238700f, -0.10326713f, 0.03919162f, 
    0.05054995f, -0.03944579f, -0.02841269f, -0.10624411f, 0.17190591f, -0.07987435f, -0.13993540f, 0.27904227f, 
    -0.06962792f, -0.02054286f, -0.05083728f, -0.07004076f, 0.00715820f, -0.05487591f, -0.09170435f, -0.03186372f, 
    -0.32223868f, 0.00187288f, -0.03151427f, -0.29744577f, -0.10223810f, -0.02244567f, 0.01362180f, 0.00360318f, 
    0.05846167f, 0.09745089f, 0.01412254f, -0.05274873f, 0.23012699f, -0.14972529f, 0.06632844f, 0.04511694f, 
    0.04095365f, -0.07345886f, -0.07296858f, 0.00500661f, 0.01448041f, -0.07705375f, -0.03786249f, 0.03088603f, 
    0.21896246f, -0.12540510f, -0.07089911f, -0.10904150f, 0.05238207f, -0.04021719f, -0.07467502f, 0.06162814f, 
    0.09103382f, 0.00974961f, -0.12641698f, -0.06651609f, -0.30080596f, -0.04490678f, -0.49102220f, -0.09980356f, 
    0.10940652f, -0.07081881f, -0.06961744f, -0.11202490f, 0.02330100f, -0.06184845f, 0.01076914f, -0.02426382f, 
    0.01911633f, 0.02400239f, 0.08024626f, 0.14051925f, 0.04843318f, -0.07871711f, 0.00528478f, -0.05818210f, 
    0.01971014f, 0.03640729f, -0.03591496f, 0.11695261f, 0.03362097f, 0.04432854f, -0.00681306f, 0.09727693f, 
    -0.02734740f, 0.01078565f, -0.04531876f, 0.06190931f, -0.04488336f, -0.01136463f, 0.00695883f, -0.01664587f, 
    0.41944671f, 0.09385658f, 0.03238203f, 0.15180756f, -0.04326426f, -0.00396008f, 0.04925281f, -0.05911301f, 
    0.05906411f, -0.12183341f, -0.11539144f, -0.06778559f, 0.08060899f, 0.11773274f, 0.00507251f, 0.22300602f, 
    0.00171076f, 0.12116846f, -0.03474836f, -0.10005195f, -0.12226164f, -0.03429256f, 0.01864732f, -0.03556548f, 
    0.10252265f, -0.08230241f, 0.02379826f, -0.15401383f, -0.02471051f, 0.08018876f, 0.04568595f, 0.14230539f, 
    -0.14756407f, 0.09823518f, 0.04106446f, -0.04346152f, -0.05905487f, 0.11562414f, -0.08578291f, -0.34649923f, 
    0.03334215f, 0.07374139f, 0.13842095f, 0.06489281f, 0.09393638f, 0.00162902f, -0.01088080f, 0.04625487f, 
    0.13165434f, -0.01622323f, 0.05413198f, -0.05898461f, 0.20829685f, -0.00014227f, -0.10484893f, -0.04411392f, 
    0.02565432f, 0.06309974f, -0.05963033f, 0.08528380f, -0.14268067f, -0.19453984f, -0.13798727f, -0.16665353f, 
    -0.00286037f, 0.02600897f, -0.02015228f, -0.02073639f, 0.07750175f, 0.09216497f, -0.09019328f, 0.03650852f, 
    0.19306561f, 0.05151909f, 0.14098459f, 0.28479514f, -0.02083778f, -0.02367006f, -0.06105467f, 0.03074612f, 
    -0.01323831f, -0.04089219f, -0.05648461f, 0.07991421f, 0.17446975f, 0.03042995f, -0.07597315f, 0.10582745f, 
    -0.05765857f, 0.01780247f, -0.05820165f, 0.15073223f, 0.00235185f, 0.03615792f, -0.00344553f, 0.00811968f, 
    0.19528490f, -0.03527667f, -0.17304011f, -0.16300888f, 0.06362808f, -0.12328520f, 0.10907695f, 0.02579593f, 
    0.00148445f, 0.08155250f, 0.14108187f, 0.09723531f, -0.01344263f, 0.06036967f, 0.08469351f, -0.16957363f, 
    0.01753746f, -0.04741855f, 0.09399143f, 0.01108826f, 0.05645344f, 0.13898155f, 0.03097749f, 0.04816421f, 
    -0.08069396f, -0.08670215f, -0.00936531f, -0.05384713f, -0.07112354f, -0.07455976f, 0.00427815f, -0.00460337f, 
    -0.01142334f, 0.02626973f, -0.03773614f, 0.01692125f, 0.14595506f, -0.03148409f, 0.01246778f, 0.43499413f, 
    -0.09644660f, 0.06195153f, 0.08480660f, 0.11556322f, 0.11127370f, 0.01361684f, -0.14788638f, 0.15116404f, 
    0.09659830f, -0.15118666f, 0.12761411f, 0.01658223f, 0.01173168f, -0.05384327f, -0.06153858f, 0.03114443f, 
    -0.06887122f, 0.01417428f, -0.00706992f, 0.01032781f, 0.11957408f, -0.07095309f, -0.18230191f, -0.23099881f, 
    -0.08131919f, -0.14821376f, -0.00363647f, -0.04661096f, -0.05546508f, -0.23961368f, -0.00500157f, -0.10493843f, 
    0.18048501f, 0.01039667f, -0.03657686f, -0.11413207f, -0.09073744f, 0.15182453f, 0.00216842f, -0.16224755f, 
    -0.02629006f, 0.02688278f, 0.05647184f, 0.00614889f, -0.64455569f, -0.19414611f, -0.18715808f, -0.00469368f, 
    -0.00050920f, -0.07643783f, -0.03932578f, -0.12795657f, 0.02188912f, 0.03498117f, -0.06124595f, -0.08021133f, 
    0.11979111f, -0.10317624f, 0.00695662f, -0.00731652f, 0.02363221f, 0.01508348f, -0.01858695f, -0.05652349f, 
    -0.14485140f, 0.09956186f, -0.13949516f, 0.01749710f, -0.08609172f, -0.10397180f, -0.06054581f, 0.10329421f, 
    -0.00961447f, 0.07351046f, -0.05211858f, 0.15633114f, 0.01841585f, -0.10314494f, 0.18912335f, -0.04410317f, 
    0.05464009f, 0.16359839f, -0.01240448f, -0.24894017f, -0.00986442f, -0.01307981f, -0.09157738f, 0.00362750f, 
    0.05095638f, -0.02577390f, -0.07023710f, 0.02356098f, 0.29891348f, -0.08955052f, 0.05415039f, 0.17768914f, 
    -0.15823685f, -0.07657030f, -0.05608751f, 0.01498228f, -0.02636081f, 0.02287035f, -0.01195497f, -0.05357738f, 
    0.11796140f, -0.33652899f, 0.08771990f, -0.09405088f, -0.07385974f, -0.04078662f, 0.02219268f, -0.00140494f, 
    -0.09927198f, -0.06652702f, -0.02300405f, 0.10459347f, 0.26944113f, 0.01727792f, 0.00898247f, 0.09740376f, 
    -0.00786086f, 0.03648746f, 0.02287111f, 0.01411477f, -0.00261438f, -0.04727274f, -0.07118063f, 0.06245720f, 
    0.12804009f, -0.00066003f, 0.10096925f, 0.18046439f, -0.09010689f, 0.12199862f, 0.01316718f, -0.00554519f, 
    0.02830648f, 0.05698551f, 0.04913234f, 0.03291845f, -0.19587381f, -0.03854110f, 0.07797805f, -0.10430388f, 
    0.15649766f, -0.08235832f, -0.00234312f, -0.02637583f, -0.01914758f, 0.13877125f, 0.02365092f, -0.00952438f, 
    -0.14799717f, -0.03537647f, -0.03324335f, -0.13780032f, -0.08465540f, 0.08606438f, -0.11691654f, -0.03723233f, 
    -0.02168549f, 0.07012668f, 0.13428091f, 0.02372287f, 0.17445661f, 0.03234850f, -0.00936537f, 0.12851031f, 
    0.02144545f, 0.02340938f, -0.19896267f, -0.03300663f, -0.05396758f, -0.04610833f, 0.09255701f, 0.03192890f, 
    0.13987531f, -0.10824775f, -0.13665615f, -0.24828614f, -0.04730266f, 0.08019935f, -0.14303972f, -0.00258644f, 
    0.02809465f, -0.14007534f, -0.06594244f, 0.03447381f, -0.26543528f, -0.07851400f, -0.29584438f, 0.11617994f, 
    0.10750344f, -0.02250619f, -0.14164384f, 0.02033605f, -0.06227020f, -0.12701763f, -0.15562603f, -0.00530709f, 
    0.29735106f, -0.24359882f, 0.15736248f, -0.21858683f, -0.01805791f, -0.06554837f, 0.06423826f, -0.04351495f, 
    -0.20893823f, -0.03353285f, 0.01481583f, 0.00983445f, -0.35811099f, -0.12536733f, -0.14696015f, 0.03511163f, 
    -0.08463798f, -0.01395639f, 0.04827463f, 0.05049526f, 0.06465936f, 0.09821013f, -0.07761919f, -0.07849813f, 
    -0.15250790f, -0.09963593f, -0.09955992f, -0.16895759f, -0.01061600f, -0.08154856f, -0.13170637f, 0.06117780f, 
    -0.09117927f, -0.09159514f, -0.12343590f, -0.10614872f, -0.14953464f, 0.03333321f, -0.01720289f, -0.09578319f, 
    0.11082739f, -0.05457167f, -0.03322087f, -0.13590877f, 0.07514003f, 0.00698407f, -0.00096778f, -0.06982305f, 
    -0.17370650f, 0.00565908f, 0.08553503f, -0.09910233f, -0.06989056f, 0.13329092f, -0.04329883f, 0.09700343f, 
    0.01562251f, 0.08935753f, 0.00413834f, 0.19637832f, -0.05603415f, 0.06354394f, 0.09258752f, -0.08938093f, 
    0.08351345f, 0.01104576f, 0.10308673f, 0.11620569f, -0.04027198f, 0.01548972f, 0.01927178f, 0.00919933f, 
    -0.26465955f, 0.18113969f, 0.01164172f, 0.06163347f, -0.18059249f, -0.10859235f, 0.01185570f, 0.02946956f, 
    0.11365303f, 0.03124224f, 0.05374354f, 0.03002093f, -0.16275501f, -0.08683050f, -0.02528196f, -0.21537788f, 
    0.05293917f, -0.01556421f, 0.00986652f, -0.00690801f, -0.09036109f, 0.02298960f, 0.07809636f, 0.04805686f, 
    0.01286657f, -0.03475848f, -0.01279445f, 0.03250799f, 0.12421384f, 0.09331013f, 0.08779795f, 0.09218404f, 
    0.08542258f, -0.15272711f, 0.03873938f, 0.06611606f, 0.17729056f, -0.08541419f, 0.06011982f, 0.22765280f, 
    -0.14950386f, 0.01105076f, -0.05673613f, 0.01902080f, -0.03185174f, 0.01598720f, -0.01398871f, 0.05198687f, 
    0.05081506f, 0.02733366f, -0.10561456f, 0.11548425f, -0.03219892f, -0.00112401f, 0.01562442f, -0.05784880f, 
    0.05224409f, 0.09519453f, -0.04203987f, 0.06468105f, -0.35652524f, 0.03523104f, -0.15548858f, -0.01778780f, 
    0.06409729f, -0.12476584f, -0.03257718f, -0.12827280f, 0.03671243f, -0.08938961f, -0.02715217f, 0.14127652f, 
    0.04557382f, 0.07605738f, -0.07786199f, -0.03548888f, -0.09028760f, 0.01321757f, 0.05341455f, 0.13675061f, 
    -0.04661861f, 0.08235122f, -0.01416228f, -0.05288392f, 0.05906840f, -0.19697274f, 0.02330431f, -0.21503717f, 
    -0.01656185f, 0.05810793f, -0.10415682f, -0.06082371f, 0.05285873f, 0.03015823f, 0.00518602f, 0.09072831f, 
    -0.02832082f, -0.03011363f, 0.17983752f, -0.00264202f, -0.08702172f, 0.02228965f, 0.04587902f, 0.00942055f, 
    -0.00408463f, 0.06024516f, -0.01666862f, -0.04382978f, 0.26878884f, -0.24291086f, 0.14603482f, -0.24884418f, 
    0.06102667f, 0.01784143f, -0.06462213f, -0.03564937f, 0.03533966f, -0.05355177f, -0.05020598f, 0.05416031f, 
    0.14568809f, 0.01468551f, -0.11405340f, -0.10245523f, -0.08194920f, -0.09591220f, -0.03753868f, -0.08795681f, 
    -0.03142661f, -0.15195525f, -0.15999646f, -0.02732111f, 0.15966053f, 0.22696726f, -0.01754676f, -0.13092327f, 
    -0.04941284f, 0.12709516f, 0.03654622f, -0.02369035f, 0.05369513f, 0.05806323f, -0.07003652f, 0.05699639f, 
    -0.35798731f, -0.00200691f, -0.04232040f, -0.06705580f, -0.05973720f, -0.00926947f, -0.09607814f, -0.00991005f, 
    0.18170811f, -0.00319334f, 0.01837372f, -0.01913105f, 0.08855541f, -0.05491084f, -0.02126571f, -0.12304764f, 
    -0.00455184f, 0.04861725f, 0.01401029f, 0.04619298f, 0.08894674f, -0.00479898f, 0.04406089f, 0.05118949f, 
    0.05720630f, 0.05963622f, 0.02351033f, -0.02993148f, 0.03809562f, -0.05841304f, -0.17850390f, 0.02598426f, 
    -0.10206900f, 0.02140678f, 0.02219383f, -0.03302129f, 0.26485270f, -0.27166885f, -0.05151404f, -0.05425206f, 
    -0.01285274f, -0.01590120f, 0.05153291f, 0.08749906f, -0.07592283f, 0.07498827f, -0.08901217f, 0.02746996f, 
    0.09473529f, 0.04338987f, -0.01150629f, 0.11318882f, -0.03166496f, 0.03479063f, 0.02944838f, 0.00805450f, 
    -0.06784185f, 0.02978728f, -0.10746382f, 0.11289206f, 0.37260956f, -0.20181455f, -0.08926325f, -0.03803672f, 
    -0.02494298f, 0.06197346f, -0.12887330f, 0.12224111f, 0.02323834f, -0.01820046f, -0.03071465f, 0.02502060f, 
    0.01870713f, -0.06297737f, 0.07370796f, 0.00632081f, -0.04813812f, -0.01749792f, -0.08535503f, -0.04791214f, 
    -0.05026654f, 0.04756119f, 0.06326731f, -0.06710690f, -0.35084733f, 0.11397009f, -0.04030636f, -0.06167896f, 
    -0.01492587f, 0.06381040f, 0.03568118f, -0.01790487f, 0.01623892f, 0.18320611f, 0.04936494f, 0.05081869f, 
    0.29063687f, -0.01917471f, 0.06703549f, 0.01607223f, -0.01714120f, -0.00799225f, -0.05333010f, 0.07666516f, 
    -0.00127400f, 0.03311889f, -0.02899729f, -0.01463508f, -0.15194058f, -0.00696661f, -0.11356148f, -0.16379175f, 
    -0.04986074f, -0.15268870f, 0.03625403f, 0.07558135f, -0.03386769f, -0.02393748f, 0.07976515f, -0.09189750f, 
    0.23887850f, 0.09222016f, 0.05615153f, 0.03869677f, -0.06929962f, -0.09320628f, -0.01601093f, -0.01979405f, 
    -0.02595392f, -0.08182010f, 0.01131180f, 0.02406032f, -0.05875290f, -0.00504803f, 0.02979322f, 0.20507747f, 
    -0.13456109f, 0.00529253f, 0.01260551f, 0.05972235f, -0.02202073f, -0.02142686f, -0.05286741f, -0.01273124f, 
    0.19924076f, 0.21257749f, -0.05052704f, -0.06479421f, 0.07276580f, 0.08647062f, -0.03167780f, -0.02795596f, 
    -0.14294891f, 0.03406364f, 0.02358906f, -0.00441143f, -0.10831902f, -0.04582455f, 0.04328071f, -0.20060351f, 
    -0.02757082f, 0.04442906f, 0.02889866f, 0.05556571f, -0.09297896f, 0.08001548f, -0.02425800f, -0.05306898f, 
    0.21971430f, -0.00335777f, 0.24480823f, 0.21836460f, -0.12984358f, -0.10621276f, -0.02439044f, 0.11110937f, 
    0.06353779f, -0.01774626f, 0.04155683f, 0.03320445f, 0.04017479f, -0.13753732f, 0.04253990f, -0.13259767f, 
    -0.03377818f, 0.11057746f, 0.05366322f, 0.09286252f, -0.02271012f, -0.15014297f, -0.02735009f, -0.19589615f, 
    0.07777330f, 0.09274781f, -0.09964059f, 0.03924329f, 0.13643406f, 0.08320741f, -0.08230513f, 0.04859020f, 
    -0.00387133f, -0.01416118f, -0.04428334f, -0.09245927f, -0.00180024f, 0.03929075f, -0.01537597f, 0.04046481f, 
    -0.04348030f, 0.06157622f, 0.00289516f, -0.02571555f, 0.01634118f, 0.04917007f, -0.05704415f, 0.00027733f, 
    -0.06932087f, 0.01676076f, 0.03440486f, -0.08769224f, 0.01802450f, -0.05030422f, 0.02369441f, 0.07357813f, 
    -0.06834213f, 0.01770061f, -0.12161610f, 0.06550553f, 0.11945257f, 0.04961728f, -0.13041641f, -0.08995996f, 
    0.01827368f, 0.05782201f, -0.06485473f, -0.01183699f, 0.03639705f, -0.00116391f, 0.13870375f, -0.03987178f, 
    -0.22174732f, -0.06202830f, -0.10741044f, -0.12082134f, 0.08558386f, -0.11729367f, 0.06878883f, -0.02977100f, 
    0.05820774f, -0.02404713f, -0.01495165f, 0.03809725f, 0.24567762f, -0.01895812f, -0.22812374f, -0.11821214f, 
    0.06270253f, -0.00179836f, -0.01411577f, -0.17920655f, 0.04071791f, 0.02123874f, 0.01581836f, -0.05470664f, 
    0.08455193f, 0.03856645f, -0.02390858f, 0.16801684f, -0.07234879f, 0.02383842f, 0.05518119f, 0.07772050f, 
    -0.02253341f, -0.07272530f, 0.07919911f, -0.01488828f, -0.12215724f, 0.00692444f, -0.11575755f, -0.21828252f, 
    0.08933024f, -0.07097777f, 0.07442655f, -0.06613756f, -0.01742262f, -0.06569582f, -0.06922799f, -0.04828632f, 
    0.14010204f, -0.00096502f, -0.04094689f, 0.00551454f, 0.14886694f, -0.00646104f, -0.00613766f, -0.03639744f, 
    0.02709386f, -0.00216643f, 0.02308167f, -0.01458411f, 0.04057596f, -0.09457873f, 0.08971731f, 0.05418036f, 
    -0.11422393f, -0.01055008f, 0.04450851f, -0.03260232f, 0.04001638f, -0.11333407f, -0.00524125f, -0.07553315f, 
    -0.54896045f, -0.02377951f, 0.12142427f, -0.28518093f, -0.01519869f, 0.07657202f, 0.08427940f, -0.06268161f, 
    -0.04815988f, 0.01397723f, -0.03161546f, -0.03328521f, -0.29135856f, -0.13698965f, -0.25710344f, -0.31823620f, 
    -0.07284254f, 0.04760830f, -0.05530078f, -0.10782863f, 0.04259302f, 0.01640693f, -0.00326644f, 0.06872845f, 
    -0.06071091f, 0.11399897f, 0.07698526f, -0.02867841f, 0.00013441f, 0.04123828f, 0.09295595f, 0.01131860f, 
    0.02157487f, -0.18056235f, 0.01123355f, -0.07149425f, 0.00979085f, 0.01353985f, -0.18604392f, -0.04215243f, 
    -0.04133459f, -0.07179469f, 0.05241483f, -0.08302184f, -0.03452610f, 0.00615827f, 0.05089905f, 0.09237991f, 
    0.08854377f, 0.13181515f, 0.11894500f, -0.10451777f, -0.10355020f, -0.09437447f, 0.05030967f, 0.01712502f, 
    -0.07316553f, 0.04673128f, 0.06202339f, -0.08117618f, -0.09666788f, -0.10740158f, -0.02955492f, -0.21526490f, 
    0.17439149f, 0.03089388f, 0.08374562f, -0.10655708f, 0.01349953f, 0.04588897f, 0.00088906f, -0.02375050f, 
    0.19490044f, -0.07406384f, -0.05768903f, 0.04696813f, 0.09739990f, -0.04936910f, -0.01839932f, 0.00116568f, 
    0.04835755f, 0.07352950f, -0.01242477f, 0.02224864f, 0.46720365f, -0.19912793f, 0.03780092f, -0.21434973f, 
    0.05652930f, -0.03345565f, 0.07326640f, 0.07647371f, -0.00910288f, 0.13384083f, 0.08067682f, -0.04569454f, 
    0.20995998f, -0.02741933f, 0.16430150f, 0.05091751f, -0.01958415f, -0.13818847f, 0.04126352f, 0.13160376f, 
    0.01534018f, 0.01739228f, 0.00493562f, -0.11258723f, 0.46782038f, -0.14659815f, -0.06794912f, 0.06937648f, 
    0.03174746f, 0.02665260f, -0.05358639f, -0.05282622f, 0.00879904f, 0.05462518f, -0.06752570f, -0.03060897f, 
    0.39211759f, 0.02532505f, -0.18801007f, -0.07481690f, 0.01684107f, -0.00723437f, -0.04945459f, -0.05305979f, 
    0.02771918f, -0.00487850f, -0.02143459f, 0.00904666f, 0.16746168f, -0.10518689f, 0.00841405f, 0.00202019f, 
    0.13421069f, 0.01358674f, 0.05487327f, -0.00960241f, 0.01771980f, 0.06957543f, 0.00961805f, -0.04737747f, 
    -0.09614695f, 0.10691280f, 0.00632756f, 0.07619376f, -0.08037976f, -0.03679399f, 0.02220869f, 0.00580362f, 
    -0.16468249f, -0.04547448f, 0.08120019f, -0.07493007f, 0.08935031f, -0.02945759f, -0.15544245f, 0.00174855f, 
    0.00671164f, 0.07060568f, 0.03526778f, -0.07456135f, -0.05937125f, -0.06220080f, 0.05580400f, -0.15479276f, 
    -0.34457013f, -0.09771689f, 0.04969515f, -0.17275594f, 0.09019070f, 0.04727248f, -0.09648637f, 0.01208208f, 
    0.10711478f, 0.05504029f, -0.02496187f, 0.04199465f, 0.12461245f, 0.18051010f, -0.02593000f, 0.08225000f, 
    -0.05266420f, 0.07684093f, 0.08300430f, 0.10976812f, -0.07768504f, -0.02165566f, -0.01495731f, -0.12136417f, 
    0.01700257f, -0.06049870f, -0.17030692f, 0.08168413f, -0.04236794f, -0.05364029f, 0.09553785f, -0.01296214f, 
    -0.00578153f, -0.02102210f, -0.06422760f, 0.02787181f, 0.39113238f, -0.07521231f, -0.01100234f, 0.01518860f, 
    -0.03315306f, 0.01070778f, -0.03338096f, -0.03741047f, 0.03841928f, 0.04488914f, -0.00740509f, -0.10755285f, 
    -0.12178609f, -0.11927466f, 0.12097164f, 0.04569063f, -0.01317566f, -0.02207984f, 0.02001737f, -0.07975789f, 
    0.03287318f, -0.04637877f, 0.01579933f, 0.07494015f, -0.11424597f, 0.06109011f, -0.32473186f, -0.14111465f, 
    -0.10201453f, 0.10142482f, 0.02198705f, 0.05486289f, -0.12346074f, -0.04409331f, 0.05439550f, 0.01965981f, 
    -0.10645723f, 0.01171946f, 0.01906652f, 0.10255688f, 0.05498524f, -0.03032562f, 0.11202698f, 0.01306357f, 
    0.02885183f, -0.05355498f, 0.04860319f, 0.05715476f, 0.00157651f, 0.03947525f, -0.03682082f, -0.33647776f, 
    -0.06766263f, -0.08186123f, -0.03794547f, 0.08629983f, -0.02705343f, 0.05300748f, -0.08418601f, 0.01608878f, 
    0.15412059f, -0.11608550f, -0.01946382f, 0.05759678f, -0.14942524f, 0.03641548f, 0.10546927f, -0.06283231f, 
    0.06949170f, -0.00754239f, 0.01444841f, 0.03994558f, -0.01338038f, -0.00592034f, 0.06321107f, 0.04708085f, 
    -0.02200955f, 0.09838748f, 0.03173856f, 0.00978054f, -0.06790823f, -0.07745416f, -0.03367818f, -0.09626647f, 
    -0.07582781f, -0.14464748f, -0.10426413f, -0.13561578f, 0.09027194f, 0.00691763f, 0.03505554f, 0.03947267f, 
    0.01218539f, -0.09535576f, -0.03944887f, -0.21707541f, -0.21948077f, -0.01254132f, 0.14914902f, 0.04236813f, 
    0.05505307f, -0.13919368f, -0.03488284f, -0.02809043f, -0.05553510f, -0.04014796f, 0.03431389f, 0.02449430f, 
    -0.28680384f, -0.05960470f, -0.15314847f, 0.06944728f, -0.06484105f, 0.03057778f, -0.05152020f, -0.01467230f, 
    -0.04248599f, -0.01702559f, 0.00824940f, -0.11855742f, 0.04838312f, 0.08636082f, -0.31128863f, 0.01082879f, 
    -0.02895425f, 0.02506861f, -0.12922072f, -0.03482199f, -0.01363805f, -0.06014790f, 0.04026224f, -0.15113395f, 
    0.10478152f, 0.02836877f, 0.09670287f, 0.15529607f, -0.15911239f, 0.05059976f, 0.00147484f, 0.06006954f, 
    -0.06968262f, 0.04296785f, -0.05164669f, -0.00438095f, 0.01230713f, -0.06474753f, -0.06713461f, -0.06407186f, 
    0.08561081f, -0.03117250f, -0.07504297f, -0.03680237f, 0.10068676f, -0.03835720f, 0.01576791f, -0.09621121f, 
    0.02290227f, -0.04567469f, -0.12352899f, -0.03593292f, -0.12751944f, -0.12364606f, -0.07353477f, 0.01246393f, 
    -0.03754336f, -0.06342201f, 0.01705166f, 0.03674997f, 0.28023782f, -0.00745730f, 0.09229039f, -0.09745260f, 
    -0.04925869f, 0.05286134f, -0.07649773f, 0.07644117f, -0.10761721f, -0.02131189f, 0.03413266f, -0.03581226f, 
    0.05707651f, 0.04403502f, 0.02147101f, 0.21841438f, -0.13344550f, -0.07388489f, -0.08214579f, 0.13555065f, 
    0.04529797f, -0.00818436f, -0.03367743f, -0.06203477f, -0.34932661f, 0.07902216f, 0.10943936f, 0.08702908f, 
    -0.03989702f, -0.08774585f, -0.01997710f, -0.08402606f, 0.01739066f, -0.05973044f, -0.12897937f, 0.09769098f, 
    0.08086357f, 0.00907505f, -0.04210250f, -0.07157226f, -0.02134036f, 0.06319369f, 0.02250596f, -0.06403176f, 
    0.02573398f, 0.05604845f, -0.07551073f, 0.01226658f, 0.04837344f, -0.06099097f, 0.07701115f, 0.00255474f, 
    0.01331007f, 0.00910489f, 0.03242089f, -0.08857447f, -0.10692165f, -0.07320600f, -0.11370233f, 0.02362066f, 
    0.20746899f, -0.05758900f, 0.00298859f, -0.13500111f, -0.05820633f, 0.04489589f, -0.13828012f, 0.17557709f, 
    -0.03941841f, -0.00158532f, -0.03470791f, -0.04454202f, -0.01663217f, -0.02608472f, -0.05292361f, -0.12925608f, 
    0.08083457f, 0.00429453f, -0.05719966f, 0.05720877f, 0.01121546f, -0.01991828f, -0.08807755f, 0.05796275f, 
    0.29267657f, -0.00652857f, 0.02495760f, 0.03746417f, -0.02765658f, -0.05168760f, 0.05897483f, 0.11641277f, 
    -0.04714371f, 0.02738272f, -0.00301008f, -0.11182189f, 0.09369272f, 0.03433002f, 0.08520553f, 0.11054021f, 
    -0.07796521f, -0.08584027f, -0.00063191f, -0.02566240f, -0.08913022f, -0.06610261f, -0.11855369f, -0.03861459f, 
    0.14947927f, 0.05037506f, -0.00865986f, -0.07715877f, -0.09095222f, -0.15046248f, 0.03991246f, 0.09498804f, 
    -0.02369772f, -0.02050285f, -0.09342587f, -0.17555679f, 0.07798737f, -0.20718728f, -0.13646178f, -0.23369138f, 
    0.02562109f, -0.04923560f, 0.02470060f, -0.03014506f, 0.07314293f, -0.03585280f, -0.03217243f, -0.07579685f, 
    0.11797819f, 0.06812559f, 0.05273948f, 0.00769077f, -0.11231822f, -0.02650596f, -0.06721019f, 0.09291667f, 
    0.05189589f, -0.09219613f, 0.05405009f, -0.02801504f, 0.27620235f, -0.17614114f, 0.02217735f, 0.10127006f, 
    -0.09330437f, 0.09345504f, -0.08232842f, -0.02512030f, 0.00009947f, 0.02825642f, 0.03812177f, -0.04579159f, 
    -0.38540989f, -0.07278648f, -0.13487494f, -0.26017058f, -0.05819693f, -0.09532793f, -0.04840088f, -0.02666874f, 
    0.11955866f, 0.00796565f, -0.13310033f, 0.00785084f, 0.18968895f, 0.20071754f, -0.12967554f, 0.16576603f, 
    -0.05419061f, 0.06197916f, 0.01439132f, -0.07003369f, -0.11439415f, 0.07227850f, -0.04326181f, 0.01609146f, 
    -0.07941861f, 0.05509780f, -0.03234509f, 0.04548927f, 0.06403180f, -0.02129906f, -0.05711605f, 0.00176141f, 
    -0.06311940f, -0.07064127f, 0.00433272f, 0.03587304f, -0.02596859f, 0.03851008f, 0.04989354f, 0.05575449f, 
    0.00487914f, 0.07237697f, 0.04433211f, -0.09027488f, -0.13764718f, -0.05841328f, -0.02264373f, 0.02904307f, 
    -0.02695605f, -0.01379291f, 0.03761053f, -0.01226692f, 0.01607527f, 0.01656898f, 0.01310395f, 0.06518127f, 
    -0.05036657f, -0.00756459f, 0.03813952f, -0.16325900f, -0.04621162f, 0.08557902f, -0.08180841f, -0.07127447f, 
    -0.06489975f, 0.04210975f, 0.00636566f, -0.03987360f, -0.00242610f, 0.02486259f, -0.00677425f, 0.00420271f, 
    0.23975076f, 0.22124010f, 0.15116900f, -0.15378757f, -0.05529543f, -0.02427236f, -0.05392337f, 0.08283700f, 
    0.00701813f, -0.02375649f, -0.06868866f, 0.05456912f, 0.16985618f, -0.10468781f, -0.10877980f, 0.07601967f, 
    0.05316401f, 0.02520335f, 0.00678393f, 0.05520128f, -0.03514193f, -0.05761154f, -0.02339874f, 0.17913559f, 
    -0.03580073f, 0.00589761f, -0.10206104f, -0.03631016f, -0.05931147f, -0.10081769f, 0.02194496f, 0.05957602f, 
    -0.04103976f, -0.02011961f, 0.05270121f, -0.04172735f, -0.17439298f, 0.29439306f, -0.06967458f, 0.09976622f, 
    0.04646810f, 0.08251172f, -0.00271773f, 0.01656618f, -0.01215436f, -0.13290155f, 0.11812017f, 0.03530898f, 
    -0.58045995f, -0.13898559f, 0.00485913f, 0.19538170f, 0.01732927f, 0.05081682f, 0.07486542f, 0.04261912f, 
    0.00856873f, -0.10823965f, 0.05673953f, -0.15171696f, -0.15121788f, -0.14399244f, -0.11676402f, 0.12202139f, 
    -0.01598048f, 0.02998319f, 0.06985310f, -0.05575528f, 0.03671420f, -0.03751079f, 0.00299412f, -0.08610304f, 
    -0.35546768f, -0.09841111f, -0.12348630f, -0.08626799f, -0.07697933f, 0.00675977f, -0.12903920f, 0.00678243f, 
    -0.05307133f, 0.06609678f, -0.00068882f, 0.07471824f, -0.23824033f, 0.09324525f, 0.09528191f, -0.11368229f, 
    0.01504953f, 0.02912735f, -0.06611978f, 0.10609683f, 0.04290653f, 0.06785264f, -0.02211520f, -0.03695763f, 
    0.08872706f, 0.02816232f, 0.11091945f, -0.06691506f, -0.02687288f, -0.05694400f, -0.01217913f, -0.02703953f, 
    -0.09719427f, -0.00485654f, -0.03459157f, -0.04092028f, -0.24672891f, 0.05750895f, 0.08243097f, 0.14927742f, 
    0.06997803f, 0.05568238f, -0.05342840f, -0.07022350f, -0.14129145f, 0.07291657f, 0.07252925f, 0.04095800f, 
    -0.26243028f, -0.10649993f, -0.11528140f, -0.12285638f, -0.11755449f, -0.04461455f, 0.00258858f, 0.04517787f, 
    -0.08083802f, -0.01147681f, -0.01933281f, 0.06810238f, 0.29156670f, 0.07284093f, -0.01614709f, 0.14113666f, 
    -0.02958946f, 0.00556577f, 0.04452069f, 0.12429233f, -0.06637845f, 0.01071896f, -0.00266988f, -0.08929121f, 
    -0.27975801f, -0.36827394f, -0.02856308f, -0.15016530f, -0.07003739f, 0.01741736f, 0.02996179f, 0.00514320f, 
    0.09053691f, -0.05266650f, 0.03151442f, 0.00941974f, 0.00595020f, 0.04701957f, -0.01372096f, -0.04213009f, 
    -0.13412884f, 0.09169918f, -0.07561459f, -0.09928578f, -0.04247685f, -0.08191053f, 0.09005391f, -0.06352703f, 
    -0.01799231f, -0.29199192f, -0.24738780f, 0.07854681f, -0.04796155f, -0.06572755f, -0.02812625f, 0.05207784f, 
    0.00471192f, 0.05259548f, -0.07955618f, -0.10580463f, 0.11785296f, 0.05670504f, 0.05816216f, -0.06477710f, 
    -0.07488435f, -0.08983678f, -0.01919283f, 0.02545265f, -0.03944735f, -0.02759298f, 0.01520236f, -0.02522210f, 
    -0.18796329f, 0.01370315f, -0.24209520f, 0.12964007f, -0.04592804f, 0.09851345f, 0.01799832f, 0.08129289f, 
    -0.04716705f, -0.01331521f, 0.02087945f, -0.04836603f, 0.23644312f, -0.19220307f, -0.10008721f, -0.03998793f, 
    -0.02752842f, 0.11703519f, 0.03290965f, -0.05977433f, -0.02789013f, -0.06279638f, 0.02903608f, -0.01655713f, 
    -0.11308321f, -0.00190618f, -0.08534595f, -0.02501176f, -0.07524671f, -0.06968997f, -0.02644183f, 0.04089165f, 
    -0.04548817f, 0.02354093f, 0.07849883f, -0.02540282f, 0.17596707f, 0.08237082f, -0.01917842f, 0.04195154f, 
    -0.12873912f, 0.10721222f, 0.01136861f, 0.06408458f, 0.07780917f, 0.08195874f, 0.06034974f, 0.03383834f, 
    0.43086261f, -0.17926200f, 0.14495006f, 0.14111379f, 0.02670049f, -0.01436933f, -0.03647623f, 0.06538948f, 
    0.01479256f, -0.02713375f, -0.01850035f, -0.05593752f, -0.15546706f, 0.15129690f, 0.10932279f, -0.01862927f, 
    0.04440153f, -0.10050839f, -0.02222771f, 0.15047324f, -0.01687958f, -0.13011482f, 0.03706105f, -0.00238085f, 
    0.00022542f, -0.03506880f, -0.23143943f, -0.04591909f, 0.06170053f, -0.06795304f, -0.08331323f, -0.09822895f, 
    0.03361521f, -0.04528746f, 0.09795823f, -0.04718297f, -0.19475754f, 0.15458949f, 0.20702308f, 0.08544017f, 
    -0.00509381f, 0.08620249f, -0.00074636f, 0.08854645f, 0.02696610f, 0.09972661f, -0.12758951f, 0.04089166f, 
    -0.16647217f, 0.17683038f, 0.22851914f, 0.09475444f, 0.07156245f, -0.06749519f, -0.05789501f, -0.04028925f, 
    0.00532556f, 0.07423542f, -0.11754248f, 0.05493582f, -0.13250656f, -0.26523161f, -0.34464246f, 0.09588446f, 
    -0.04537613f, 0.02536169f, 0.04916720f, -0.07203568f, 0.03534510f, -0.08356167f, 0.08810890f, 0.01659967f, 
    0.00250586f, -0.10078236f, -0.01838859f, -0.01264290f, -0.05958553f, 0.01242841f, 0.12063023f, 0.12085490f, 
    -0.14562760f, -0.04834809f, -0.02326764f, 0.06106664f, -0.35485914f, 0.00509448f, -0.08091616f, 0.01200171f, 
    0.00515218f, -0.03519241f, 0.01330668f, 0.08762412f, -0.02578801f, -0.01942927f, -0.08275897f, -0.01206061f, 
    -0.28334919f, -0.55822003f, -0.03183447f, 0.20076822f, -0.16175437f, 0.00114785f, 0.04504727f, 0.01964919f, 
    0.03933365f, 0.00710339f, 0.02676072f, 0.05839185f, -0.16370524f, 0.05007776f, -0.04573315f, -0.11048316f, 
    0.01910222f, -0.01507379f, -0.05034085f, -0.01530396f, -0.04059501f, -0.06028857f, 0.04704850f, 0.01070150f, 
    0.00692193f, 0.06054087f, 0.09298134f, 0.03923455f, 0.02144621f, -0.05434818f, -0.10340001f, -0.09593072f, 
    0.03141855f, -0.03212300f, -0.08382910f, -0.01126868f, 0.06577335f, -0.00125891f, 0.10250121f, -0.01231742f, 
    0.00222243f, -0.02004049f, 0.07978418f, -0.03426401f, -0.09145873f, -0.03651037f, 0.01552923f, 0.06104153f, 
    0.03755347f, 0.10570052f, 0.04174854f, 0.06374188f, -0.08957743f, -0.11183009f, 0.05306362f, -0.08755435f, 
    0.01548411f, 0.04339331f, -0.06266771f, 0.00959879f, -0.16119149f, 0.17522116f, -0.02967416f, 0.01973977f, 
    -0.01883432f, 0.05185011f, -0.03554035f, 0.18409327f, -0.06334547f, 0.07812247f, 0.10866372f, 0.00868068f, 
    -0.01368125f, -0.01143822f, -0.05648553f, -0.04688403f, -0.07904425f, 0.03078801f, -0.04921829f, 0.12127304f, 
    0.01394142f, -0.03862037f, 0.00871621f, -0.00892840f, 0.12917182f, 0.03503648f, 0.21250270f, -0.08318054f, 
    0.05343386f, -0.00373267f, -0.00189266f, 0.08724868f, 0.02248139f, -0.00989558f, -0.08000443f, -0.03120679f, 
    0.50651401f, 0.15590839f, 0.05486992f, 0.06822164f, 0.00342603f, -0.08561116f, 0.02122640f, 0.01583271f, 
    -0.05030889f, 0.04737328f, 0.01485241f, -0.02145301f, -0.08356533f, 0.00969655f, 0.02048565f, 0.07402047f, 
    -0.02704247f, 0.00373089f, 0.10273251f, 0.02387232f, -0.02510306f, 0.08015238f, 0.07291521f, 0.05265316f, 
    0.05558463f, 0.10922278f, 0.10991880f, 0.27283823f, 0.03612174f, 0.02966975f, 0.05207071f, -0.06538874f, 
    0.03873380f, 0.01432597f, -0.08410905f, -0.14711028f, 0.02673672f, -0.02936170f, -0.10002663f, -0.09342089f, 
    -0.07833094f, -0.11116607f, -0.02669100f, 0.04802194f, 0.05106278f, -0.05267709f, -0.04636090f, 0.04389536f, 
    0.21251425f, -0.14578241f, 0.00617650f, 0.03615063f, -0.04425233f, 0.07163077f, 0.02493472f, 0.04049772f, 
    -0.08929736f, 0.01488810f, -0.02251553f, -0.06664692f, -0.01999503f, 0.05923323f, 0.10103185f, 0.18937686f, 
    0.12736598f, 0.03079093f, -0.02842881f, 0.03148348f, -0.04200991f, -0.08056770f, -0.09238036f, -0.07318113f, 
    0.13189697f, -0.16752057f, -0.01727547f, -0.10030724f, -0.04259236f, -0.09581925f, -0.07048091f, 0.02853458f, 
    0.01916084f, 0.06031831f, 0.00142406f, -0.01993220f, -0.07926057f, -0.18219872f, -0.11698822f, 0.07737888f, 
    0.04219256f, 0.04278113f, -0.10090208f, -0.13660645f, 0.04162070f, -0.09791744f, 0.01368152f, 0.01387124f, 
    0.11195155f, 0.01851867f, 0.02315904f, -0.20350228f, -0.05621503f, -0.11697443f, -0.01314205f, -0.00632091f, 
    0.05384361f, -0.12492862f, -0.04368631f, 0.03330955f, -0.19801401f, 0.14406997f, 0.00098472f, -0.10424525f, 
    -0.00483034f, -0.04080272f, -0.02144099f, 0.11839285f, 0.08306133f, -0.14053193f, 0.00792954f, -0.02092115f, 
    -0.02262902f, -0.02420030f, -0.07398707f, 0.01706595f, -0.07196819f, 0.01046724f, -0.00803363f, -0.02805087f, 
    -0.05843912f, 0.02534648f, 0.06619741f, -0.01785206f, 0.04984185f, 0.08877081f, -0.08930326f, 0.07501220f, 
    -0.04642497f, -0.02274885f, 0.08353070f, -0.05369353f, -0.03467005f, -0.03587790f, 0.10304065f, 0.02606795f, 
    -0.21188153f, -0.22287580f, -0.02314437f, 0.21949930f, 0.04735139f, 0.00554881f, -0.05293512f, -0.05044438f, 
    -0.04119632f, -0.03181455f, -0.00127570f, -0.02798824f, -0.04261369f, 0.08468784f, 0.06396803f, 0.08938328f, 
    0.02243777f, 0.15147786f, -0.03948085f, -0.02684198f, -0.00560740f, 0.10369138f, 0.03491094f, 0.05119833f, 
    0.41006464f, 0.04265822f, 0.03759558f, 0.06990317f, 0.00763502f, 0.05530094f, -0.05059312f, 0.05636991f, 
    -0.06973957f, -0.04011909f, 0.09618169f, -0.03418273f, -0.18768828f, -0.26589164f, 0.08071013f, 0.00909362f, 
    -0.02858899f, -0.04905294f, -0.04175128f, 0.06149979f, 0.01487257f, -0.10622898f, -0.08645838f, 0.05870506f, 
    -0.48526007f, 0.12358882f, 0.06415132f, -0.20134513f, -0.07398746f, -0.06376669f, -0.15123443f, 0.06830413f, 
    -0.04267325f, -0.04205961f, -0.07478911f, -0.04743388f, 0.01698162f, 0.02559207f, 0.04475322f, -0.05768802f, 
    -0.06884315f, -0.17328808f, 0.04447777f, -0.06412105f, -0.04829982f, -0.02188751f, -0.03429659f, 0.08755615f, 
    0.03189230f, 0.13564835f, 0.08595472f, -0.14036551f, -0.16202649f, -0.04424257f, -0.03969983f, 0.05933150f, 
    0.01732470f, -0.06894667f, -0.00810088f, 0.19153582f, 0.34008074f, 0.01057917f, 0.05736191f, 0.01172189f, 
    0.03956351f, 0.05563756f, 0.01516277f, -0.10387781f, 0.00343685f, -0.08737580f, 0.03745686f, -0.13734537f, 
    0.22169454f, -0.05203624f, -0.06422639f, -0.04510046f, -0.04001591f, -0.04622676f, -0.04353713f, -0.00489442f, 
    0.00811794f, -0.04506846f, 0.03483189f, -0.00453845f, 0.06216870f, -0.02584152f, -0.01790090f, -0.00567454f, 
    -0.06997868f, -0.03145245f, 0.09649111f, -0.04653113f, -0.15823866f, 0.05525652f, -0.04031100f, -0.04324844f, 
    0.13983323f, 0.03353128f, 0.07168283f, -0.01243646f, -0.03108620f, 0.13598368f, 0.01454432f, -0.02312178f, 
    0.00769761f, 0.09131800f, 0.01584427f, -0.03074405f, 0.18078531f, 0.19140077f, -0.04802920f, -0.09212004f, 
    0.07085387f, -0.12426975f, 0.05035095f, 0.09567887f, -0.06593017f, -0.05074551f, -0.00531409f, -0.04939804f, 
    -0.24262916f, -0.16075833f, -0.22966696f, -0.16455686f, -0.12236755f, -0.01226654f, -0.00005062f, 0.01287164f, 
    -0.01037533f, 0.03091671f, 0.12966505f, -0.02865181f, -0.11091462f, -0.05537130f, 0.02134758f, -0.17639954f, 
    -0.00496007f, 0.05297263f, -0.04363927f, 0.08650079f, 0.01014510f, 0.05149418f, -0.00772443f, 0.04574189f, 
    -0.12032463f, -0.12403914f, -0.34926650f, -0.00234720f, -0.03791272f, 0.03110049f, -0.01434934f, 0.04091903f, 
    -0.05421610f, 0.12338793f, -0.11159562f, 0.08308063f, -0.23700543f, -0.05567809f, 0.02864291f, 0.05505722f, 
    -0.04525750f, 0.14341596f, -0.04844343f, -0.01417125f, -0.03337785f, 0.10327320f, 0.02803309f, -0.03731458f, 
    0.39424059f, -0.07588127f, -0.05675512f, 0.01821566f, 0.01910860f, -0.05792470f, 0.05750930f, 0.02373672f, 
    0.04769749f, 0.04242256f, -0.10649959f, 0.01419793f, -0.00160883f, 0.18394727f, 0.05978044f, 0.02233190f, 
    -0.15202503f, -0.02550708f, 0.05091738f, -0.00350997f, -0.00108230f, -0.03949628f, -0.01375272f, 0.01713190f, 
    -0.63023657f, -0.07197526f, 0.10315850f, 0.20198096f, -0.02290215f, -0.00075357f, 0.02166662f, 0.04348162f, 
    -0.06872836f, -0.02009725f, 0.10194618f, 0.04418305f, 0.00358508f, -0.22628306f, 0.08756306f, -0.21415968f, 
    -0.11205307f, -0.03935201f, 0.07674363f, 0.04155712f, -0.01204751f, 0.04434045f, -0.02822705f, 0.04472081f, 
    -0.33879840f, -0.12516865f, 0.23245883f, 0.02489632f, 0.06640543f, -0.01404975f, -0.01845131f, -0.00474111f, 
    0.00586447f, -0.01294048f, -0.04727260f, -0.13547273f, 0.04053412f, -0.14833936f, -0.06053024f, 0.01861412f, 
    0.02432096f, -0.14824666f, -0.00355573f, -0.01186626f, -0.03299433f, 0.05485064f, -0.05973171f, 0.10665309f, 
    -0.13899197f, 0.15649199f, 0.10414746f, -0.05439848f, 0.07025462f, 0.01279426f, 0.00056598f, 0.06589763f, 
    0.01529178f, 0.02593358f, 0.08354131f, -0.03485771f, -0.13895501f, -0.00248176f, 0.06492667f, 0.02362739f, 
    -0.05794101f, -0.02013967f, 0.05407871f, 0.08901447f, -0.06032716f, -0.01481815f, -0.08752251f, -0.04268631f, 
    0.00849566f, 0.07323743f, 0.12017811f, 0.14236414f, -0.03206120f, -0.00852846f, 0.08793528f, 0.06655467f, 
    0.05492464f, -0.02835147f, -0.00434798f, -0.09969646f, -0.37678483f, -0.00649006f, 0.24264929f, 0.22403553f, 
    -0.24744330f, -0.05356224f, -0.03912343f, -0.05775834f, 0.10098770f, -0.03708802f, 0.01716550f, -0.00131409f, 
    -0.08883439f, -0.07103986f, 0.07868744f, 0.12675749f, -0.08683913f, 0.09666958f, -0.15171973f, 0.05497796f, 
    -0.05773714f, 0.03476559f, 0.06593353f, 0.00713680f, -0.00952806f, -0.05899413f, 0.03755753f, -0.10346173f, 
    -0.04232192f, -0.03270614f, -0.00271013f, -0.00150589f, 0.02416969f, -0.07578455f, 0.12340033f, -0.04942543f, 
    0.35578150f, -0.10370680f, -0.13564931f, 0.06577481f, -0.01493636f, -0.06263549f, 0.03414902f, 0.01520915f, 
    -0.04180695f, -0.01760080f, 0.07706982f, 0.00379617f, -0.31608969f, 0.12155861f, -0.18146664f, -0.14575081f, 
    0.01776823f, 0.01261305f, 0.06776722f, 0.01811350f, 0.07902115f, 0.04853116f, -0.02181027f, -0.12759338f, 
    -0.09612955f, -0.22407195f, 0.17284732f, -0.11304043f, -0.12791346f, 0.14299127f, 0.06677148f, -0.14919156f, 
    0.03212859f, 0.12492521f, 0.05597822f, -0.02740484f, 0.14899668f, -0.01551881f, 0.03610089f, 0.03993946f, 
    0.08096447f, -0.03514013f, 0.11583389f, 0.11045901f, 0.03930803f, -0.03044181f, 0.05673205f, 0.09836397f, 
    -0.01802664f, -0.27563280f, -0.01683722f, -0.05249951f, -0.12961097f, -0.01981485f, -0.04726208f, -0.18422407f, 
    -0.08996848f, 0.05470631f, -0.01435630f, -0.08328975f, 0.01901112f, -0.07873327f, 0.10657125f, -0.11000826f, 
    -0.03048440f, -0.04254014f, -0.05629146f, -0.10534768f, -0.11997989f, -0.01172549f, -0.06049114f, -0.18905917f, 
    -0.19685057f, 0.06785009f, 0.15892574f, 0.11579446f, 0.04342990f, 0.01603761f, 0.09204848f, -0.02716303f, 
    0.01088913f, 0.04922794f, -0.01307151f, -0.07670269f, -0.05281460f, -0.06763359f, 0.01387676f, 0.06227562f, 
    -0.13275655f, 0.01810160f, 0.06594733f, 0.07997064f, 0.04501176f, -0.03097150f, 0.11214730f, 0.14922352f, 
    -0.15583554f, 0.31971598f, -0.16359520f, -0.10556523f, 0.01334610f, 0.05681583f, 0.05993026f, 0.15055764f, 
    -0.11611493f, 0.08139415f, -0.03143267f, 0.03331591f, -0.15367216f, 0.07555593f, -0.11288060f, -0.03045464f, 
    -0.03216920f, -0.04555510f, 0.01489758f, 0.00921028f, -0.01265947f, 0.11200284f, -0.03080208f, 0.08982997f, 
    -0.22608851f, 0.10536479f, 0.00427780f, 0.11782973f, 0.04565630f, -0.03949170f, -0.01878290f, 0.10908081f, 
    -0.00463452f, -0.08785252f, 0.06841835f, 0.00661650f, -0.45199347f, 0.04427529f, 0.14661816f, -0.15151374f, 
    0.06662839f, -0.02531023f, -0.05140871f, -0.14915204f, 0.01136468f, -0.01675736f, -0.00571762f, 0.08429269f, 
    -0.29040524f, 0.00827856f, 0.08867432f, 0.11866453f, -0.02133207f, -0.14752899f, 0.02534798f, -0.08398038f, 
    -0.12044058f, 0.00500268f, -0.03959816f, 0.02980937f, -0.08788471f, 0.08528941f, -0.02388888f, 0.01682710f, 
    -0.14266853f, 0.04510311f, 0.05221105f, 0.06559738f, 0.04155720f, 0.07058764f, -0.01361227f, 0.09013367f, 
    -0.12941049f, -0.00955421f, -0.01028465f, 0.01668314f, 0.19307949f, -0.01435012f, -0.01896832f, -0.12476278f, 
    -0.05393742f, 0.03468009f, -0.01374099f, -0.00930320f, -0.05457898f, 0.09722129f, 0.02455273f, 0.13257949f, 
    -0.07431071f, 0.03934211f, -0.05384643f, 0.06670612f, 0.02782066f, 0.13372730f, 0.03308200f, -0.15690723f, 
    0.10204414f, 0.37534782f, -0.00853859f, -0.19055018f, 0.02367431f, -0.03828385f, -0.00435623f, 0.06217256f, 
    0.02088261f, -0.02623511f, -0.01767963f, 0.01300758f, -0.09980074f, -0.08971376f, 0.09099592f, 0.23494519f, 
    -0.07246984f, 0.07617557f, 0.03334914f, 0.06866115f, 0.08186365f, 0.01888337f, 0.06975509f, 0.05922370f, 
    -0.10781638f, -0.05383343f, -0.10799240f, -0.00894679f, -0.01156039f, -0.02600772f, -0.00343805f, -0.02064834f, 
    0.02948675f, -0.03133619f, 0.04087620f, -0.13395943f, -0.15497403f, -0.00254128f, -0.08993375f, -0.06053202f, 
    -0.01624796f, -0.09182145f, 0.03691633f, -0.01263111f, 0.05708222f, 0.04922611f, -0.04690383f, -0.04954162f, 
    0.05044578f, -0.14464281f, -0.16188061f, 0.04851199f, 0.09926736f, 0.03378502f, -0.00426082f, 0.10394382f, 
    -0.12586911f, -0.06017412f, 0.02940281f, -0.09954391f, 0.18883483f, -0.09535512f, 0.03891616f, -0.21055970f, 
    0.04683304f, 0.04701601f, 0.05976733f, 0.10952142f, -0.01072894f, -0.00672361f, -0.06332328f, 0.04864215f, 
    0.08978084f, -0.15532024f, -0.14440870f, 0.13483223f, -0.04204504f, 0.08350376f, -0.01877695f, -0.02994831f, 
    0.04735340f, 0.10943171f, -0.04386966f, -0.04420199f, 0.06912743f, -0.12015788f, -0.06710815f, -0.27199087f, 
    0.06925085f, 0.01905942f, -0.03836036f, -0.02163967f, -0.05592488f, -0.06332013f, -0.01518529f, 0.05034594f, 
    0.24583651f, 0.24117929f, -0.23071627f, -0.16198382f, -0.00670647f, 0.15442285f, 0.02668120f, -0.06639808f, 
    -0.08286490f, -0.03471035f, 0.13111478f, 0.10919014f, 0.04035436f, -0.24294956f, 0.10756048f, 0.08788750f, 
    -0.10037436f, 0.12549482f, -0.01019415f, 0.12676732f, -0.04028266f, 0.09474951f, 0.05041937f, 0.08071839f, 
    -0.00033161f, -0.14419502f, 0.18383670f, 0.12173261f, 0.07105479f, -0.01554355f, -0.00304072f, -0.06286460f, 
    0.10778914f, -0.01655411f, -0.01495450f, -0.12774144f, 0.00030181f, -0.08894007f, 0.02206245f, 0.34096161f, 
    -0.01263376f, 0.02991041f, 0.08785012f, 0.04982039f, 0.06431174f, 0.06229633f, -0.02737689f, -0.00879444f, 
    -0.12683235f, 0.01744661f, 0.04095317f, -0.05799278f, 0.02615837f, 0.09035081f, -0.21024461f, -0.02726847f, 
    0.02119729f, 0.08595281f, -0.12322524f, -0.02593378f, -0.22542930f, -0.03416275f, 0.25130412f, 0.06791681f, 
    -0.05918783f, 0.05124194f, -0.08583201f, -0.05647196f, 0.00485521f, -0.04701616f, -0.05460921f, -0.04778942f, 
    -0.12021320f, 0.08659326f, 0.07168353f, 0.08818431f, -0.01797341f, -0.04149377f, -0.01082883f, 0.08234266f, 
    -0.09500372f, -0.06261944f, 0.00472460f, 0.11006962f, 0.27024427f, 0.00971127f, 0.05580667f, 0.10661505f, 
    0.05026602f, 0.00230875f, 0.09393424f, -0.02653796f, 0.00250933f, 0.02081924f, 0.02346672f, 0.05767376f, 
    0.14147146f, -0.05415947f, 0.07292872f, -0.03958036f, -0.00446085f, -0.04546190f, -0.01394944f, 0.11399223f, 
    0.02207477f, -0.09538148f, 0.01434529f, 0.04079516f, -0.07576115f, -0.11875517f, -0.04906424f, -0.02882873f, 
    0.09709430f, 0.05951567f, -0.05868207f, 0.06220681f, -0.00901197f, -0.10652134f, -0.00637079f, -0.06654269f, 
    -0.26165816f, -0.07118171f, -0.22724099f, 0.05234033f, -0.03926074f, -0.03120944f, -0.00759114f, 0.01271269f, 
    0.12048849f, -0.14135569f, -0.00558790f, 0.04144276f, -0.12234933f, -0.05303196f, -0.14511159f, 0.22659071f, 
    0.16515577f, -0.06059204f, -0.03331793f, -0.07569859f, -0.09309141f, -0.03632035f, -0.06214035f, -0.09631115f, 
    -0.39096585f, 0.01713893f, 0.11884886f, -0.07258694f, 0.00470466f, -0.08084334f, -0.15258747f, 0.04918499f, 
    0.13079076f, -0.09674730f, -0.02406396f, -0.00153050f, -0.17062746f, -0.05552461f, -0.02170473f, 0.12334865f, 
    0.09393270f, -0.07682419f, -0.03781425f, 0.06369811f, 0.02021954f, -0.04308056f, -0.06068888f, -0.03977195f, 
    -0.31718612f, 0.12801933f, -0.08455767f, -0.26187450f, 0.06411247f, -0.00844239f, 0.05648331f, -0.02423464f, 
    0.03428689f, 0.07532817f, -0.07688341f, 0.04326962f, 0.01120014f, 0.13154715f, -0.02282873f, -0.11603517f, 
    0.03192241f, -0.20248669f, 0.03203687f, 0.03489660f, -0.08601228f, -0.01013459f, 0.14750136f, 0.00385395f, 
    0.14132392f, 0.01091716f, -0.04774205f, 0.06931510f, 0.02001894f, 0.03501035f, 0.07965640f, 0.04035996f, 
    -0.01710778f, 0.08148023f, 0.03494638f, 0.01891830f, 0.07941148f, 0.02173233f, -0.02389610f, 0.01689813f, 
    0.06415579f, 0.01043967f, -0.03517369f, 0.11782782f, -0.05193635f, -0.08026674f, 0.04242266f, -0.09523077f, 
    -0.08738331f, 0.03998432f, 0.13001128f, 0.02551415f, 0.04106319f, 0.04572957f, -0.01745559f, 0.06091607f, 
    0.02873096f, 0.03668784f, -0.02094002f, 0.00807556f, 0.16518398f, 0.11100332f, -0.02557769f, 0.08095125f, 
    -0.03338980f, -0.03193368f, -0.11447110f, -0.10638618f, -0.00311439f, -0.00730908f, -0.06862308f, 0.06085251f, 
    -0.10260809f, 0.04977151f, -0.03903946f, 0.01791801f, 0.03665560f, 0.01272802f, 0.07116911f, 0.08558230f, 
    -0.01017943f, -0.08252592f, -0.01649526f, -0.10070989f, -0.06564841f, -0.00996641f, -0.17263687f, 0.05246499f, 
    0.00463647f, 0.05984963f, 0.01823337f, 0.05315605f, 0.06450064f, 0.03214569f, 0.09061383f, -0.00984849f, 
    -0.01639950f, 0.07697252f, 0.04362868f, -0.03854302f, -0.03095587f, 0.00553751f, -0.07733248f, 0.01291713f, 
    -0.08897902f, -0.11058996f, -0.04452302f, 0.06623931f, 0.43903378f, 0.32808438f, -0.34561872f, -0.12858416f, 
    0.11893898f, -0.06809320f, -0.00432371f, 0.00001720f, 0.00848000f, -0.11574952f, -0.02803899f, -0.04054433f, 
    -0.15557119f, -0.06821202f, -0.12570277f, -0.00069166f, -0.06229796f, -0.18490465f, 0.05647502f, -0.12897807f, 
    0.01964423f, -0.09911282f, 0.01012373f, -0.00091477f, 0.17805299f, -0.20751835f, 0.03830496f, -0.07079670f, 
    -0.05598260f, -0.15737651f, -0.03118319f, 0.07668886f, -0.05592914f, -0.16973120f, -0.05599042f, -0.02033259f, 
    -0.18748170f, -0.02131990f, 0.08085343f, -0.18536313f, 0.00071292f, 0.09618635f, 0.05308164f, -0.01341856f, 
    -0.02529725f, 0.00679305f, 0.03827257f, 0.04125151f, -0.26552430f, 0.11727329f, 0.08936903f, -0.04003992f, 
    0.11824615f, -0.00737928f, 0.10979337f, 0.02324591f, 0.05054358f, -0.00768925f, 0.04959945f, -0.03343800f, 
    -0.26562473f, -0.31840807f, 0.12359011f, 0.20904872f, 0.01540736f, -0.01340026f, 0.00304553f, -0.02078927f, 
    -0.02214495f, -0.09752893f, 0.04837793f, 0.01560029f, -0.09075166f, 0.06520456f, -0.02540648f, -0.01247463f, 
    -0.01193833f, 0.08292861f, 0.06820767f, -0.01869455f, -0.06091103f, 0.01103515f, 0.14739154f, 0.07563039f, 
    -0.19660681f, 0.04206599f, -0.31580484f, -0.12815905f, 0.04219981f, 0.09382500f, -0.01692510f, -0.05759679f, 
    0.07525604f, -0.11013595f, -0.03572129f, -0.02668502f, 0.05099191f, 0.01977487f, 0.00421148f, 0.03036013f, 
    -0.10059509f, -0.03407187f, 0.01644670f, 0.05491776f, -0.05952797f, 0.17516887f, 0.06661204f, 0.07084222f, 
    0.12220601f, 0.00006468f, 0.00285132f, -0.04189733f, -0.14948039f, 0.13436538f, 0.07245381f, -0.01563663f, 
    -0.09519412f, 0.00259744f, 0.21266076f, 0.14940479f, 0.11494379f, 0.02098130f, 0.09390047f, -0.03363629f, 
    0.01524964f, 0.07798591f, -0.04264008f, -0.03991749f, -0.11018004f, -0.19742145f, 0.10852230f, 0.00814999f, 
    0.02994918f, -0.01026015f, -0.01563138f, -0.13264310f, 0.01483383f, -0.02793389f, 0.04069522f, 0.01047859f, 
    0.12894911f, 0.02228174f, -0.21773463f, -0.03032118f, -0.16560537f, -0.03008028f, 0.04174725f, -0.14053625f, 
    -0.02282059f, -0.12050776f, 0.13997808f, 0.09620064f, 0.03436218f, -0.12263343f, -0.03676233f, -0.17728135f, 
    -0.05616961f, 0.00257641f, -0.07313260f, 0.09371006f, -0.03133473f, -0.09318246f, 0.04260577f, -0.05563037f, 
    0.11627786f, 0.13277179f, 0.06600446f, 0.13390855f, 0.05976369f, -0.04306282f, 0.02531366f, 0.17965251f, 
    -0.05209951f, -0.05922090f, -0.02128338f, 0.09317544f, -0.07415557f, 0.02586166f, -0.06587318f, -0.09247168f, 
    0.12069695f, -0.09820935f, 0.05945314f, -0.21200326f, -0.10446520f, -0.16317187f, -0.04970915f, -0.19791149f, 
    -0.13261338f, -0.07087166f, -0.00310450f, -0.05158614f, -0.12428804f, 0.17061825f, 0.17108588f, 0.12142888f, 
    -0.06543338f, 0.00890955f, 0.01873498f, -0.00263326f, -0.11036671f, 0.04633487f, -0.06619700f, 0.09615869f, 
    -0.07218707f, 0.07025563f, 0.12295729f, -0.13217074f, 0.03694227f, 0.03964336f, 0.07993452f, -0.12536103f, 
    -0.00628991f, -0.04261925f, 0.04842144f, 0.09199966f, -0.52737081f, 0.14463140f, 0.05139998f, -0.12283398f, 
    0.14345074f, -0.08047605f, 0.03074481f, -0.12546881f, 0.03965076f, 0.03658189f, -0.00640581f, 0.11485349f, 
    -0.12646168f, 0.18168174f, -0.06686913f, 0.14549838f, -0.02181485f, -0.06284565f, 0.03170408f, 0.10532027f, 
    0.03991509f, -0.09997217f, 0.02883794f, -0.10415744f, -0.07558947f, 0.09076747f, -0.01343657f, 0.02364702f, 
    0.13856661f, 0.09088253f, 0.06076838f, 0.03204118f, 0.06504034f, 0.06433482f, 0.00483078f, -0.07217550f, 
    0.07937885f, 0.16233711f, -0.05064168f, -0.00258108f, -0.06237138f, -0.03569972f, -0.01201003f, -0.04453330f, 
    -0.03875930f, -0.04782193f, -0.12595226f, 0.13091730f, 0.06885891f, 0.10626560f, 0.10531330f, -0.33081359f, 
    0.03044963f, -0.12099277f, -0.02939293f, 0.16468428f, -0.15773015f, -0.03479154f, -0.03742420f, -0.40592128f, 
    0.05292209f, 0.01524161f, -0.17879398f, 0.01224519f, -0.04566995f, -0.03245650f, -0.00923600f, -0.02969977f, 
    0.07216505f, 0.06874773f, 0.02618454f, -0.00586909f, -0.02711613f, 0.01253282f, 0.01355470f, 0.16135086f, 
    0.19324572f, -0.04398169f, -0.10841434f, 0.02235830f, -0.06878544f, -0.12350441f, -0.06631467f, -0.08245287f, 
    -0.22322674f, -0.05091898f, 0.26257926f, 0.25254229f, -0.01983648f, -0.02363852f, 0.03173372f, -0.10875329f, 
    -0.05048334f, 0.08057270f, -0.03710806f, 0.01150731f, -0.27528253f, -0.11022685f, -0.06695237f, -0.00390737f, 
    0.07885133f, -0.00052405f, 0.00611705f, -0.09409119f, -0.00792409f, -0.12422421f, -0.03137165f, -0.05413199f, 
    -0.33098704f, -0.03396796f, -0.23634802f, -0.22185235f, 0.01639750f, 0.08603091f, -0.01739086f, -0.20845503f, 
    0.01287096f, -0.03822199f, -0.01885014f, -0.03475482f, 0.00329149f, 0.07119934f, 0.07564534f, -0.27540296f, 
    0.03274569f, -0.08399163f, 0.05166238f, -0.04228332f, -0.01378008f, -0.05372855f, 0.00324435f, -0.02152102f, 
    0.06921444f, -0.23718792f, 0.01179173f, -0.13181235f, 0.01523426f, 0.03294357f, 0.10283087f, -0.03157301f, 
    -0.09938856f, -0.02902344f, 0.16700783f, -0.01902439f, -0.11275536f, 0.03048759f, 0.06228766f, -0.14761071f, 
    0.08863847f, 0.01835923f, -0.03129144f, -0.05517402f, 0.00819096f, -0.08642024f, 0.03216330f, 0.08758330f, 
    0.01677158f, 0.16354546f, -0.04631449f, -0.00051500f, 0.08320574f, -0.11273023f, 0.08241481f, 0.01375121f, 
    0.03846532f, -0.05651846f, 0.02683729f, -0.09065870f, -0.08471648f, 0.04226032f, 0.03972901f, -0.08079512f, 
    -0.12362774f, -0.04611870f, 0.01642164f, -0.12005185f, 0.04854430f, 0.04681806f, -0.04084066f, 0.08459984f, 
    -0.07559810f, 0.04319017f, 0.21212964f, 0.10966481f, -0.06433651f, -0.02256337f, -0.06738046f, 0.03004948f, 
    0.09691565f, -0.10268531f, -0.02679330f, -0.05003625f, 0.18641442f, 0.01931868f, -0.07761973f, -0.05320102f, 
    -0.02963012f, -0.13547212f, -0.16268618f, -0.26473552f, -0.16196896f, -0.01898519f, -0.00130586f, -0.07422706f, 
    -0.00763675f, 0.00850047f, 0.08863015f, 0.11531954f, 0.18642008f, -0.08084713f, -0.11451086f, 0.02598891f, 
    -0.03829610f, -0.01393431f, 0.02441537f, 0.11112887f, -0.27706990f, -0.05926913f, -0.15962252f, -0.22414057f, 
    0.15176681f, 0.03262858f, -0.02383294f, -0.02246864f, -0.01845217f, 0.01210688f, -0.03325364f, 0.00360840f, 
    -0.03860316f, -0.06865654f, -0.19013084f, -0.00011214f, -0.01449318f, -0.06343289f, 0.06611209f, -0.02604485f, 
    -0.01254985f, 0.04955915f, -0.04042164f, -0.23105267f, 0.07932451f, 0.17255968f, 0.02399573f, -0.03421104f, 
    -0.01597275f, -0.10124806f, -0.05996944f, 0.03416652f, 0.11221772f, 0.14656085f, -0.01803572f, -0.13303104f, 
    0.07110933f, 0.02270744f, 0.08215392f, 0.01839260f, 0.05462641f, -0.08349281f, -0.13402027f, -0.16385020f, 
    -0.00274644f, 0.17022377f, -0.09666626f, -0.09725332f, -0.33347461f, -0.05029375f, 0.05645448f, 0.21865420f, 
    -0.04881088f, -0.01708375f, -0.02861019f, -0.02719492f, -0.12460024f, -0.00147133f, 0.09596623f, 0.06335533f, 
    0.01386820f, -0.27096045f, 0.06889191f, 0.09676816f, -0.06124701f, -0.07606332f, 0.04098077f, 0.00644554f, 
    0.03739520f, -0.00093557f, -0.10509478f, -0.14019963f, 0.10029142f, 0.07027900f, 0.06965268f, -0.08048528f, 
    0.08098064f, -0.07586206f, -0.03674904f, -0.05145405f, 0.00723612f, -0.00374916f, 0.05058355f, -0.07184335f, 
    -0.00584641f, 0.07405847f, 0.10243986f, 0.05743606f, 0.04142432f, -0.10840175f, -0.09632541f, 0.02275264f, 
    -0.09526783f, -0.09234234f, 0.10054935f, 0.12821992f, -0.15268031f, -0.07554819f, -0.14041340f, 0.01681250f, 
    0.11642184f, 0.05816418f, -0.05855181f, -0.05223978f, 0.06697877f, 0.01019453f, 0.11934275f, -0.06737614f, 
    -0.02576307f, -0.11533950f, -0.04087003f, 0.01129238f, 0.13008413f, -0.03942577f, 0.22463451f, 0.01569223f, 
    0.13841614f, 0.10803384f, -0.07077318f, 0.05766834f, 0.11202292f, -0.03291462f, -0.03516385f, 0.19409834f, 
    -0.15067539f, -0.06707155f, 0.11702054f, -0.02533463f, -0.05968368f, 0.14273472f, 0.11485647f, 0.19729745f, 
    -0.24091688f, -0.30900085f, -0.31200600f, 0.05329666f, 0.14528798f, -0.12616873f, 0.06287927f, -0.07351824f, 
    -0.02571443f, 0.10086457f, -0.08480041f, 0.01070893f, 0.02300266f, 0.03334515f, 0.09711161f, -0.22523899f, 
    0.12537725f, -0.05345218f, 0.08127178f, 0.02811636f, 0.11480476f, 0.06454968f, 0.07727250f, 0.14734806f, 
    -0.25876907f, -0.12254616f, 0.02936361f, 0.10408451f, 0.09239782f, -0.02160558f, 0.13025771f, 0.00033469f, 
    0.04348908f, 0.10087086f, 0.03515808f, -0.09194844f, -0.24403672f, 0.05716550f, -0.02073002f, 0.07512371f, 
    -0.00869565f, 0.02261144f, 0.18631890f, 0.01945359f, 0.08847605f, -0.01837845f, -0.03626070f, -0.00642992f, 
    -0.22639267f, 0.05759744f, -0.17273861f, -0.16965990f, 0.06277149f, 0.18411526f, 0.15013553f, -0.13400835f, 
    -0.02976409f, -0.01681991f, -0.05467206f, 0.05081810f, -0.01200684f, -0.00636034f, -0.11656088f, -0.00810064f, 
    0.06961773f, 0.16257240f, -0.07822156f, 0.07155524f, 0.11576488f, 0.00922431f, -0.10393153f, -0.10904907f, 
    0.13234104f, -0.07118633f, 0.09165944f, 0.14791539f, -0.00807085f, 0.09855130f, 0.06127624f, 0.04206626f, 
    -0.10528015f, 0.00964946f, 0.02850305f, 0.06135621f, -0.03255371f, 0.03112681f, -0.08180100f, -0.36757997f, 
    -0.00992702f, -0.02593264f, 0.15148331f, -0.07797582f, 0.14250146f, -0.11648308f, 0.02657241f, -0.10556010f, 
    -0.26288456f, -0.15985014f, 0.08222629f, -0.00406022f, -0.04225572f, 0.12015882f, -0.02960235f, 0.18264540f, 
    -0.07122871f, 0.10256999f, 0.05963788f, 0.03527428f, 0.01582573f, 0.07630343f, 0.19074114f, 0.25345325f, 
    -0.00810429f, 0.05316308f, 0.07174090f, -0.03513416f, 0.07539110f, 0.04387229f, 0.08666183f, 0.08783145f, 
    -0.00816232f, -0.01908581f, 0.04571768f, 0.02174091f, 0.06953545f, 0.01882904f, -0.05345277f, -0.03177943f, 
    0.08658008f, 0.08573570f, -0.02439039f, 0.15335463f, -0.17052889f, 0.02847972f, -0.21322028f, 0.19334975f, 
    0.02738388f, 0.15240112f, 0.00767006f, 0.01812256f, 0.09750286f, 0.00075452f, 0.16091669f, -0.04759812f, 
    -0.31955925f, -0.11053581f, -0.21028085f, 0.20860530f, 0.11310372f, 0.10516775f, -0.02444947f, 0.06985233f, 
    -0.00566800f, -0.01512986f, 0.12561795f, -0.02164236f, -0.07041684f, -0.03472771f, 0.06612261f, -0.18231788f, 
    0.04965967f, -0.04876003f, 0.03807493f, -0.02767830f, -0.03688486f, -0.02316494f, -0.02332106f, -0.02666602f, 
    -0.51224828f, -0.27046609f, -0.09412146f, -0.06262753f, 0.13766074f, -0.02266136f, 0.10669015f, -0.04966877f, 
    0.04726514f, 0.13899647f, -0.01207635f, 0.05670264f, -0.27531847f, 0.14092097f, -0.06245875f, -0.19493669f, 
    -0.01679671f, -0.05020190f, -0.07091700f, -0.10697229f, -0.02893501f, 0.00151668f, -0.16675034f, -0.02520559f, 
    0.19306242f, -0.00944705f, -0.07563606f, 0.18222673f, 0.04601231f, -0.02137235f, -0.04100899f, 0.12681165f, 
    0.10648580f, 0.08007878f, 0.15557088f, -0.09086736f, -0.18578643f, -0.21239613f, 0.36580122f, 0.24188310f, 
    -0.06345815f, 0.00187829f, -0.00985133f, -0.03719907f, 0.08149713f, 0.02824833f, -0.01623438f, -0.01066634f, 
    0.03922167f, 0.12203703f, 0.19611198f, -0.12019131f, 0.11018271f, 0.12468533f, -0.03850680f, -0.16182980f, 
    0.06611095f, 0.02959824f, -0.00845228f, 0.13375098f, 0.17759801f, 0.00835705f, -0.01337462f, 0.07095106f, 
    -0.01306903f, 0.07138777f, 0.01894317f, -0.09782361f, 0.13563244f, 0.15849555f, -0.00196246f, -0.00891601f, 
    0.08396149f, 0.00299289f, -0.03361368f, 0.13082460f, -0.02410460f, -0.00884430f, -0.09195840f, -0.11353862f, 
    -0.02658573f, -0.00464715f, -0.13060263f, 0.04023238f, -0.15198976f, 0.04872882f, 0.07502630f, -0.20715491f, 
    -0.00061879f, -0.02897896f, -0.09548518f, 0.08550208f, 0.09147727f, -0.04080272f, 0.08890113f, -0.10032427f, 
    -0.08358788f, 0.03257784f, 0.05623096f, 0.14897980f, -0.14113598f, 0.01202459f, 0.07090414f, 0.03042403f, 
    -0.16535679f, 0.00755956f, -0.01927733f, -0.04429599f, 0.07491812f, -0.13015935f, 0.03401848f, -0.02835806f, 
    -0.05118034f, 0.02784324f, -0.01147261f, 0.01457495f, 0.03235990f, -0.01837866f, -0.11217133f, -0.10884570f, 
    -0.01172349f, -0.25321153f, -0.15703465f, -0.16184604f, 0.00207530f, -0.02950432f, -0.03900425f, -0.06136004f, 
    0.03494402f, 0.05005650f, 0.03767942f, 0.14863810f, 0.11020231f, -0.06693482f, 0.11937258f, 0.05503038f, 
    0.00215128f, 0.00324846f, 0.05774996f, -0.03892490f, 0.05583883f, -0.13291557f, 0.03203095f, -0.31118670f, 
    0.10946067f, 0.24871333f, 0.04235650f, -0.12489729f, -0.04408116f, -0.09749480f, -0.06530559f, 0.03042067f, 
    0.00724244f, 0.01692687f, -0.21471342f, 0.03651435f, 0.01796605f, 0.23170973f, 0.14036945f, 0.03601366f, 
    -0.03255563f, -0.00209828f, 0.00409626f, 0.14120983f, 0.09359299f, 0.06038514f, -0.08238435f, 0.01241559f, 
    0.02251405f, 0.02723117f, 0.14476672f, 0.05207536f, -0.03360222f, 0.05930826f, -0.07104255f, -0.03390050f, 
    -0.06091390f, -0.07768516f, 0.14324991f, 0.17047362f, 0.10475764f, -0.20759502f, 0.05736011f, -0.02960110f, 
    0.01341229f, -0.07000445f, -0.00025761f, 0.00929026f, -0.00745729f, 0.12708810f, 0.08293828f, 0.17038859f, 
    0.12994239f, -0.16495235f, -0.19597280f, 0.20299354f, 0.05364721f, -0.04818102f, -0.12127919f, -0.10935129f, 
    0.06655911f, -0.13077232f, 0.00674248f, -0.09469415f, -0.13941386f, 0.09589962f, -0.08130066f, -0.14563617f, 
    0.10095047f, 0.03346451f, 0.00025413f, 0.02029424f, -0.08805729f, 0.01922838f, 0.04499371f, 0.12633801f, 
    -0.43393680f, 0.07601207f, -0.04983039f, 0.15856197f, -0.00292737f, 0.09536552f, 0.13700667f, 0.05451553f, 
    0.07395097f, 0.04552578f, -0.00164427f, -0.04653217f, 0.09086770f, -0.11252351f, 0.05354548f, 0.19277160f, 
    0.03155915f, -0.03020562f, -0.09298758f, 0.06210158f, -0.07836922f, 0.00960626f, 0.01331891f, 0.05164766f, 
    -0.13384967f, 0.19740784f, 0.09812403f, -0.23337358f, -0.15514107f, 0.03740357f, -0.02120519f, 0.12771331f, 
    0.03290898f, 0.09049431f, 0.08275050f, -0.08407986f, 0.21700153f, -0.32230043f, 0.03937496f, 0.07661413f, 
    0.00260095f, 0.02634207f, 0.03811566f, 0.06332269f, -0.05196609f, 0.05778756f, -0.09319012f, -0.07268410f, 
    -0.42969623f, -0.05891142f, -0.14738962f, 0.39520741f, 0.05598082f, 0.08554522f, -0.10653751f, -0.01437524f, 
    -0.04348831f, 0.00755311f, -0.18054952f, -0.01643914f, -0.02354687f, -0.05969707f, -0.23248102f, -0.07944969f, 
    -0.11745785f, -0.07207516f, -0.12048587f, -0.02322347f, -0.05283537f, 0.07707970f, 0.11892584f, 0.02531676f, 
    -0.22930828f, 0.23220488f, -0.01914833f, 0.11196647f, 0.08013934f, 0.03505416f, -0.00639340f, 0.14624530f, 
    0.07372691f, -0.00160286f, 0.07823291f, -0.07104221f, -0.19192369f, 0.03048529f, 0.14284493f, -0.08829717f, 
    0.09426615f, -0.09926878f, -0.06278155f, -0.11255747f, 0.01051094f, 0.04763128f, 0.09970689f, 0.12929013f, 
    -0.01052708f, -0.08340055f, -0.06700128f, 0.09051912f, 0.03324402f, 0.05464499f, 0.02588657f, -0.06099138f, 
    0.02360166f, -0.16173151f, 0.04287335f, 0.15896122f, 0.13878044f, 0.04982399f, -0.03381589f, 0.16622849f, 
    0.02560771f, 0.04169156f, 0.04934435f, 0.06344088f, 0.09347229f, 0.17351344f, -0.15917623f, 0.06330479f, 
    0.20026806f, -0.05674046f, -0.17012087f, -0.09377805f, -0.03277467f, -0.04805718f, 0.11861244f, 0.10482076f, 
    0.02091265f, -0.06886712f, 0.00234777f, 0.01804869f, 0.24950100f, -0.20424978f, -0.19282028f, 0.06447116f, 
    -0.11480214f, 0.16909176f, 0.00043594f, 0.09545447f, 0.04167495f, 0.04899397f, 0.02752318f, 0.11443783f, 
    -0.07694501f, -0.18964705f, -0.03030085f, 0.00289335f, -0.04830576f, 0.05550348f, 0.06332176f, 0.08826245f, 
    0.08433500f, 0.10192657f, 0.09025281f, 0.06016035f, 0.28389260f, -0.10240731f, -0.09938195f, 0.05177502f, 
    -0.00938336f, 0.03806912f, 0.08775569f, 0.10104837f, 0.14513448f, 0.11229510f, -0.10219131f, -0.04071654f, 
    -0.17119402f, -0.12821802f, -0.02632796f, 0.07054972f, -0.00931601f, 0.06713244f, -0.06854940f, -0.06551120f, 
    0.08677315f, -0.14586823f, -0.09626269f, -0.01026237f, 0.04733732f, 0.23807178f, 0.13452886f, -0.22494395f, 
    -0.02019038f, 0.05400145f, 0.08427210f, 0.04858266f, 0.06653884f, 0.11245896f, 0.00543836f, 0.01188251f, 
    0.08248401f, 0.05709760f, -0.23007631f, 0.20621219f, 0.05436583f, 0.13786608f, -0.11992824f, -0.10235186f, 
    0.00448644f, 0.13850486f, -0.14692636f, -0.02109747f, -0.00418518f, 0.18681605f, 0.15905194f, -0.18006125f, 
    0.08950229f, 0.03126721f, 0.10855289f, 0.03035126f, -0.13463610f, 0.03514843f, 0.04203054f, -0.07458753f, 
    0.24762353f, -0.20089293f, -0.01460522f, -0.35859519f, 0.01468281f, 0.00932328f, -0.02576929f, 0.07609424f, 
    -0.02400224f, 0.00596967f, 0.05785528f, -0.01657088f, -0.23587030f, -0.06956211f, -0.13881978f, 0.05616786f, 
    -0.02871284f, 0.03825547f, 0.03247470f, 0.02234671f, 0.11164974f, 0.01876869f, 0.10467524f, 0.05224250f, 
    0.10449435f, -0.06399797f, -0.13237265f, 0.00914949f, 0.09190581f, 0.04829713f, 0.13165332f, -0.03594500f, 
    0.03908460f, -0.03558447f, -0.06374637f, -0.11513880f, 0.13247341f, -0.21555077f, 0.14973448f, -0.05296132f, 
    -0.06415632f, 0.12809029f, 0.11462177f, 0.08657145f, 0.07411278f, -0.05314707f, 0.09871281f, 0.02813843f, 
    -0.04935579f, 0.03709987f, 0.01702950f, -0.10411048f, 0.01223414f, -0.01517897f, -0.02585349f, -0.13579033f, 
    -0.17315720f, 0.12537302f, 0.16650562f, 0.02926212f, 0.09832129f, -0.13669692f, 0.26752204f, 0.03024712f, 
    0.06414542f, 0.03944604f, 0.11256345f, -0.04245989f, 0.09798072f, -0.01186743f, -0.00924073f, 0.10462140f, 
    -0.27053547f, -0.02488987f, -0.22703916f, -0.01362374f, -0.02520740f, 0.14374909f, 0.12475504f, 0.11412814f, 
    0.07340263f, -0.18449062f, 0.09463882f, 0.02997740f, 0.15261720f, -0.17492977f, -0.06219068f, 0.08468133f, 
    0.08491530f, 0.04861908f, -0.06022198f, -0.05097189f, -0.05158514f, -0.04316047f, 0.03628929f, -0.12387529f, 
    0.08896057f, -0.15247580f, 0.00734766f, 0.00919990f, 0.03397099f, 0.10113358f, -0.03082724f, -0.02104484f, 
    -0.03760218f, 0.20016964f, -0.02922158f, 0.07466827f, -0.00749875f, 0.06243732f, 0.01660711f, 0.03000842f, 
    -0.06687297f, -0.07769088f, 0.06638703f, 0.13227586f, 0.01244869f, -0.09433943f, -0.04044036f, -0.05146322f, 
    0.10405532f, -0.03171090f, -0.24070831f, -0.12548274f, -0.05393992f, 0.06956942f, -0.00669523f, 0.00143195f, 
    0.06431886f, -0.03044479f, -0.10386635f, 0.04896207f, -0.04811642f, 0.03676641f, -0.19778997f, -0.10032617f, 
    -0.14780226f, -0.03049900f, -0.03758116f, -0.12996702f, -0.01260819f, 0.02822488f, -0.15728670f, 0.00976848f, 
    -0.07873770f, -0.01612110f, 0.20336093f, -0.14285640f, -0.00845442f, 0.06934804f, -0.03332182f, -0.08777843f, 
    -0.03205876f, -0.08909152f, -0.01675423f, -0.01924874f, 0.11510430f, 0.06381220f, 0.07226743f, -0.31875119f, 
    0.00430029f, 0.10510369f, 0.03575508f, -0.00296719f, -0.03400886f, -0.12806328f, -0.06880815f, -0.03661863f, 
    -0.16526553f, 0.05110158f, -0.10229236f, -0.23475780f, -0.05281419f, -0.01301997f, -0.07822371f, -0.08533440f, 
    0.01332173f, 0.02669146f, 0.09118240f, 0.04410648f, -0.18433131f, 0.18295042f, 0.07507788f, -0.36230069f, 
    -0.00945818f, 0.11425349f, -0.03283235f, -0.00494353f, -0.06547567f, -0.08176211f, -0.02212627f, -0.13211004f, 
    -0.06259270f, 0.00583142f, -0.03302309f, -0.05803668f, -0.08792678f, 0.01821613f, -0.02955368f, -0.13922922f, 
    -0.08794239f, -0.05192133f, -0.00201920f, -0.12605850f, 0.43110538f, -0.06934486f, 0.23524806f, -0.05401845f, 
    -0.09924462f, 0.00552058f, -0.02266636f, -0.12959811f, -0.07378293f, 0.04719798f, 0.12304725f, -0.02496239f, 
    -0.09613363f, -0.28293529f, -0.00892389f, -0.17757627f, -0.07737343f, -0.03830737f, -0.04397183f, -0.12141308f, 
    0.03153161f, 0.01050229f, -0.00298182f, -0.00594089f, 0.02672880f, -0.05230283f, -0.15223688f, -0.29214433f, 
    -0.28959608f, -0.03502557f, -0.01431638f, -0.11785751f, -0.08603226f, -0.00808603f, 0.03131285f, 0.00054432f, 
    0.03400245f, 0.10529863f, -0.01514034f, -0.12073693f, 0.05267931f, -0.06394774f, 0.00765309f, -0.02842977f, 
    0.01075473f, 0.02908572f, 0.04386258f, -0.03715839f, -0.13319047f, 0.01665149f, 0.13989164f, -0.00710934f, 
    -0.00759069f, -0.01149287f, -0.25522041f, 0.03375839f, -0.13191858f, 0.09381516f, -0.03771829f, 0.07470390f, 
    0.23871225f, -0.23626649f, -0.19569036f, 0.06560493f, 0.03692389f, 0.03080723f, -0.01022855f, -0.05768711f, 
    0.08669275f, -0.06540327f, -0.01131783f, 0.00118557f, -0.07150815f, -0.01162145f, -0.10391894f, 0.04672094f, 
    -0.04819645f, -0.04654478f, -0.16513808f, -0.02674018f, 0.01476430f, -0.03460342f, -0.15735531f, -0.18745497f, 
    -0.00845095f, -0.24438252f, -0.11008041f, 0.18884474f, -0.03439247f, -0.05801450f, 0.11446783f, -0.09241591f, 
    -0.08718195f, -0.09799097f, 0.04828687f, -0.02026987f, -0.16819333f, 0.11065301f, -0.00960165f, -0.05986472f, 
    -0.07433845f, -0.02714713f, -0.00385164f, -0.09311859f, -0.08375879f, 0.04904335f, -0.00510538f, -0.05918888f, 
    -0.14095582f, 0.01698974f, 0.01660586f, -0.10244776f, -0.12845579f, -0.12703210f, -0.03223468f, -0.01344472f, 
    0.13493216f, -0.09169701f, -0.06899409f, 0.12307926f, -0.23437279f, 0.10808498f, 0.01218335f, 0.11762562f, 
    -0.06809990f, 0.06521026f, -0.01148933f, -0.01922069f, 0.02606720f, -0.01990885f, -0.04000654f, 0.05167318f, 
    -0.23756909f, -0.01475686f, -0.01696170f, -0.14891298f, -0.01414442f, 0.06294601f, -0.01064242f, -0.00581529f, 
    -0.06612806f, 0.02081227f, 0.00542916f, -0.03548340f, -0.30361542f, -0.17626630f, 0.15036948f, -0.20607612f, 
    0.08936109f, 0.03510605f, 0.10440982f, 0.01582866f, 0.06359185f, -0.05256200f, 0.18938400f, -0.01891585f, 
    -0.23049246f, -0.10984096f, -0.10161065f, -0.07031242f, -0.00980871f, -0.08337088f, 0.03061309f, 0.01579912f, 
    0.01800553f, -0.16999689f, 0.11606050f, 0.05660059f, 0.16026188f, -0.19221130f, 0.03081565f, 0.08328738f, 
    -0.02767498f, 0.03897333f, -0.03557535f, -0.07338411f, -0.05186786f, 0.01148559f, -0.08361021f, -0.01112962f, 
    -0.25038719f, 0.02899794f, 0.11981674f, 0.10998565f, -0.04570905f, 0.02781843f, 0.11242713f, 0.11291026f, 
    -0.06272314f, -0.07435527f, -0.03696071f, -0.02538354f, -0.18867968f, 0.12432858f, -0.01581479f, 0.32072264f, 
    0.00155841f, -0.05875278f, 0.00956873f, -0.06349533f, 0.01565590f, -0.13034368f, 0.00120875f, -0.26444826f, 
    -0.37883571f, 0.15596819f, 0.11094850f, 0.11994088f, -0.00586280f, 0.03731174f, 0.06868605f, 0.05556890f, 
    -0.04814123f, 0.01600940f, 0.08801941f, -0.01428047f, 0.51156306f, -0.06226100f, 0.18576060f, 0.03895375f, 
    -0.08552824f, -0.06075056f, 0.04852147f, -0.02794783f, -0.08830100f, 0.02749537f, 0.02061714f, 0.12144948f, 
    0.10532424f, 0.08992834f, 0.15191111f, 0.20332532f, 0.14552146f, -0.05300547f, -0.02909501f, -0.05957969f, 
    -0.02072061f, -0.00069015f, -0.10040981f, -0.02964866f, -0.12789686f, 0.21342811f, -0.06511968f, -0.02821217f, 
    -0.11386718f, 0.02700446f, 0.02683401f, 0.01953308f, -0.02426511f, -0.00773112f, -0.05066331f, -0.10116610f, 
    0.01237204f, 0.15186049f, 0.17713712f, 0.08993724f, 0.02831302f, 0.03727059f, 0.10029811f, -0.01633589f, 
    -0.05936861f, 0.06286911f, 0.01662799f, -0.00968831f, 0.21721573f, 0.04450583f, 0.15472005f, 0.06732286f, 
    0.01872391f, -0.00287594f, -0.05481103f, 0.02649522f, -0.00767230f, -0.04275474f, -0.01995168f, 0.06395746f, 
    0.16319108f, -0.26299301f, -0.15479179f, -0.07937266f, -0.10015423f, -0.07110462f, 0.06435610f, 0.01275825f, 
    -0.02970872f, -0.01640254f, -0.00038706f, -0.01916515f, -0.13810317f, -0.12447725f, -0.13941459f, -0.11194064f, 
    -0.04280559f, 0.02271842f, 0.00812011f, -0.05573507f, -0.07615757f, 0.00885071f, -0.05137766f, -0.05880621f, 
    -0.08214017f, -0.10625179f, -0.08156747f, -0.07043102f, -0.04391127f, 0.04555963f, -0.01870239f, -0.04713365f, 
    -0.07827286f, -0.03023469f, -0.01239933f, -0.02398459f, 0.01033547f, -0.21152814f, -0.07337217f, -0.15013956f, 
    0.01462009f, 0.02586444f, -0.04011377f, -0.06911354f, -0.00943178f, -0.02194653f, -0.02329168f, 0.01360630f, 
    -0.17605478f, 0.20152129f, -0.10535560f, 0.05598065f, -0.02711794f, -0.01411088f, -0.07701233f, 0.01241179f, 
    0.05449153f, -0.05815393f, 0.02948050f, -0.00692870f, 0.15402772f, -0.30524546f, 0.05065686f, 0.03695054f, 
    -0.01271597f, -0.07335990f, -0.04217640f, 0.00565067f, -0.10045592f, -0.04439104f, -0.04723073f, -0.01242115f, 
    -0.01544458f, 0.04356495f, -0.01034229f, -0.03093502f, -0.01228136f, -0.00066824f, -0.08451497f, -0.01292002f, 
    0.07559381f, 0.00347562f, -0.02274880f, -0.08036206f, -0.05109786f, -0.00982619f, -0.03150650f, 0.15886623f, 
    -0.02941568f, -0.07290772f, -0.03215910f, 0.00428268f, -0.01482030f, 0.00177267f, -0.04851622f, 0.00103318f, 
    -0.35936028f, 0.13739640f, 0.00621032f, -0.01419675f, -0.01840612f, 0.05880794f, -0.02537689f, -0.04605645f, 
    -0.07541601f, -0.06132508f, -0.02802301f, -0.08308860f, -0.04915601f, -0.34979701f, -0.05968485f, -0.09494621f, 
    -0.01433518f, -0.00291913f, -0.03180725f, -0.03069100f, -0.04931844f, 0.00185197f, -0.01401277f, 0.01048825f, 
    -0.15967464f, -0.09706968f, -0.15120457f, 0.09342137f, -0.01111374f, -0.03532259f, -0.13817936f, 0.02807721f, 
    -0.10286102f, 0.00921124f, 0.02522979f, -0.06265000f, 0.10796355f, 0.12629007f, 0.05148176f, 0.21170837f, 
    0.07982087f, 0.03775793f, -0.04060944f, -0.05964078f, -0.08364096f, -0.05701659f, -0.03062851f, -0.10068859f, 
    -0.16418220f, -0.06734197f, -0.11745090f, -0.03936099f, -0.04528484f, 0.04434771f, -0.08908068f, 0.06057967f, 
    0.00171381f, 0.00511172f, -0.00348999f, -0.03028708f, 0.00120359f, 0.08052479f, -0.06009398f, -0.11484887f, 
    -0.14288469f, -0.03039912f, -0.03841558f, -0.06330514f, 0.01104999f, -0.10384730f, 0.07457001f, -0.03399450f, 
    -0.05273120f, 0.08161351f, -0.07833239f, -0.01332130f, -0.04731729f, -0.06484008f, 0.00388050f, -0.06004333f, 
    0.09709409f, 0.01704803f, -0.08580009f, 0.02528789f, -0.01326359f, 0.00361754f, 0.02482438f, 0.10718080f, 
    -0.11242422f, 0.02721269f, 0.05176650f, -0.01680770f, -0.07406456f, 0.07824527f, 0.01020008f, 0.05574694f, 
    -0.05922379f, 0.04333717f, 0.05510282f, 0.07989290f, -0.05494829f, 0.02267134f, 0.00638056f, -0.01214659f, 
    -0.08579214f, 0.00049084f, 0.01792290f, -0.03899396f, 0.20462207f, 0.24797311f, 0.10027907f, 0.16909996f, 
    0.18816148f, 0.08776318f, 0.03004593f, 0.08895636f, -0.00704281f, -0.01761553f, 0.10068204f, 0.02814050f, 
    -0.16644803f, 0.06388771f, 0.09390540f, -0.00902416f, -0.02429656f, 0.00208086f, -0.05290924f, 0.01692499f, 
    0.06215919f, 0.04877502f, -0.03827446f, -0.02621896f, 0.10484901f, -0.29093850f, 0.09901070f, -0.04099185f, 
    -0.04686064f, -0.04621168f, -0.04280172f, -0.11588872f, -0.02722844f, 0.03815278f, -0.09386416f, -0.07301701f, 
    0.26745498f, -0.22899967f, 0.19469386f, 0.09556885f, -0.08777697f, 0.06625950f, -0.01214647f, -0.03977834f, 
    0.03124165f, 0.03074808f, -0.04953346f, -0.00960289f, -0.31482157f, 0.21508552f, -0.06720050f, -0.11081626f, 
    -0.06427125f, 0.00894824f, -0.01501347f, -0.06876303f, -0.13873588f, -0.00846370f, -0.02193390f, -0.05209427f, 
    -0.00358450f, 0.08738703f, -0.04129847f, -0.00266582f, -0.10327198f, -0.04335240f, -0.03494018f, 0.02652529f, 
    0.02362627f, -0.00198377f, -0.07548826f, -0.10011544f, -0.02989194f, -0.20813349f, 0.03079032f, -0.12072261f, 
    -0.07229439f, 0.01651683f, -0.06372731f, -0.02927395f, -0.06825239f, 0.00210698f, -0.00619402f, -0.00924814f, 
    -0.26199782f, 0.11843114f, -0.08610439f, -0.05429551f, -0.03495579f, -0.06631792f, -0.00688459f, -0.10169962f, 
    0.01893394f, -0.02075773f, -0.08783238f, -0.10794055f, 0.09143103f, 0.06318653f, -0.03054757f, 0.03735696f, 
    0.03046689f, 0.03109812f, 0.01737077f, 0.01835908f, 0.04887538f, -0.02316023f, -0.02750773f, -0.03184326f, 
    0.10742421f, -0.09112728f, 0.04534089f, 0.10244669f, 0.08436937f, -0.02072507f, -0.03265766f, 0.02952568f, 
    -0.04086753f, 0.04901911f, -0.06356083f, 0.04138868f, 0.13265342f, -0.08260422f, 0.07175405f, -0.12563655f, 
    -0.04288220f, 0.03401982f, 0.03124908f, -0.01269392f, 0.00115269f, 0.06274080f, -0.01540225f, -0.03492851f, 
    -0.16335092f, 0.11165580f, 0.03307715f, 0.12598972f, 0.03258837f, -0.01632444f, 0.02448889f, 0.03158075f, 
    -0.06916179f, -0.01066696f, 0.04264413f, -0.01770061f, 0.16814004f, -0.06911242f, 0.14240511f, 0.05603766f, 
    0.00886008f, -0.02630110f, 0.10633916f, -0.08468959f, 0.01338077f, 0.09870975f, 0.01081667f, -0.14769703f, 
    -0.09780803f, -0.00241960f, -0.10832493f, 0.10320309f, -0.02900339f, -0.02565649f, -0.02469677f, -0.04499197f, 
    0.04958691f, 0.00137613f, -0.00095117f, -0.02054360f, 0.27301297f, -0.01312207f, 0.04087415f, 0.16317447f, 
    0.09806425f, 0.02663844f, 0.02399251f, -0.05937475f, -0.03072083f, -0.02746026f, -0.05457488f, -0.05314766f, 
    -0.27699459f, 0.14613239f, -0.04027085f, -0.01797550f, 0.03650539f, 0.00987073f, 0.02963604f, -0.03752597f, 
    -0.02491241f, -0.06636842f, 0.04971907f, -0.05247324f, 0.08463559f, 0.03358182f, -0.05895409f, 0.13924438f, 
    0.01598375f, -0.00778708f, -0.01596031f, 0.05770518f, -0.04505226f, -0.01743749f, 0.02345807f, -0.02408492f, 
    -0.06229403f, 0.01234581f, -0.09519459f, 0.03446712f, -0.02951767f, -0.07552475f, -0.05384277f, -0.05382929f, 
    0.03498629f, -0.01946879f, -0.02205463f, -0.04258613f, 0.11145380f, 0.16827583f, 0.01717001f, 0.19836426f, 
    0.07005698f, 0.04887009f, -0.00819279f, 0.01507550f, -0.02397873f, 0.01306231f, -0.00599421f, -0.06342810f, 
    0.07433424f, 0.04109075f, -0.04338044f, 0.02944535f, -0.08291193f, 0.04785874f, -0.06945247f, 0.02412506f, 
    -0.02855424f, -0.00033912f, -0.00161934f, -0.03162723f, 0.01309630f, -0.11506999f, -0.00321418f, 0.07692909f, 
    -0.10009589f, -0.06163246f, -0.03961036f, -0.10414918f, -0.02590232f, -0.00952410f, -0.08896352f, -0.11852020f, 
    0.04317648f, 0.13974801f, 0.13270915f, 0.15163802f, 0.07157386f, 0.04168034f, 0.01525380f, -0.02572070f, 
    -0.06279323f, 0.00550439f, -0.02569692f, -0.02654184f, -0.16854885f, 0.11217906f, -0.01670251f, -0.15820111f, 
    -0.04796891f, 0.04521476f, -0.01178406f, -0.03971408f, -0.07022661f, -0.02036017f, -0.02277950f, -0.02885395f, 
    0.21329460f, 0.10750686f, 0.06366655f, 0.09331620f, 0.12020624f, 0.06925480f, 0.05984251f, -0.02708235f, 
    -0.00195225f, -0.00929060f, 0.07424396f, -0.05390842f, 0.00957488f, 0.17017972f, 0.10390843f, 0.09157630f, 
    0.12560576f, 0.02630945f, 0.04134798f, 0.03003441f, -0.09626157f, -0.01378813f, 0.07658525f, 0.01207859f, 
    -0.01610789f, 0.11622366f, 0.12951343f, 0.05330342f, 0.03244551f, 0.02463423f, 0.00852957f, 0.03599758f, 
    -0.04282687f, -0.00505392f, 0.02947395f, 0.03037842f, 0.08186825f, 0.16794604f, 0.05386909f, 0.09329651f, 
    0.05537568f, 0.02242666f, 0.09622877f, 0.03036929f, 0.00075465f, 0.02276569f, -0.10152701f, -0.09785283f, 
    -0.08215585f, -0.15249808f, -0.18957293f, -0.08597078f, -0.02705890f, -0.03511454f, 0.01809280f, -0.03724581f, 
    -0.09802918f, -0.02104806f, -0.05543165f, 0.03974687f, -0.12620459f, -0.01612615f, -0.06522539f, 0.10016201f, 
    -0.08095665f, 0.01381260f, -0.06459194f, -0.00289083f, -0.01907987f, 0.07258940f, -0.05985910f, -0.01553475f, 
    -0.12658656f, 0.12383835f, 0.07475374f, 0.05798891f, 0.05328581f, 0.03933674f, 0.06692003f, -0.11665919f, 
    0.03422747f, -0.03030208f, 0.01625808f, 0.00713879f, 0.02175339f, -0.16386287f, 0.04755439f, 0.00090352f, 
    -0.07127409f, -0.09106795f, -0.02440340f, -0.00218718f, -0.00970853f, 0.08322869f, -0.04362019f, 0.07201619f, 
    -0.07051282f, 0.15980348f, 0.04712866f, 0.00118578f, 0.03485803f, -0.03215016f, -0.02263627f, -0.04531771f, 
    0.03450436f, -0.08927400f, -0.02383759f, -0.01304025f, 0.13624434f, 0.12315125f, 0.09980585f, 0.08024303f, 
    0.00400154f, 0.03924388f, 0.03342104f, -0.04460433f, -0.01034503f, 0.04868691f, -0.00660026f, -0.09826142f, 
    0.17087060f, 0.02498762f, 0.09498173f, 0.03446123f, 0.01892308f, 0.03976287f, -0.01265299f, -0.03202568f, 
    -0.09724017f, -0.01237990f, -0.10020471f, -0.05799405f, -0.26047632f, 0.10825755f, -0.13670075f, -0.07252399f, 
    -0.04319734f, -0.03005526f, 0.00412718f, -0.00065911f, -0.04037824f, 0.03608386f, -0.02994100f, -0.01873245f, 
    0.09616832f, 0.08121675f, 0.09457108f, 0.15417108f, 0.03960668f, -0.00765155f, 0.03747878f, -0.01589395f, 
    -0.02090114f, 0.01835445f, -0.02101291f, -0.03437074f, 0.14100164f, 0.01832809f, 0.09318798f, -0.13886739f, 
    -0.03430794f, -0.00907094f, 0.01589540f, -0.02752759f, -0.01674295f, -0.01932243f, 0.05027600f, -0.09863513f, 
    0.09806547f, 0.07845633f, -0.01446417f, 0.08785617f, -0.06825954f, -0.07580125f, 0.01362876f, -0.02748225f, 
    -0.08055225f, -0.15164481f, -0.10175242f, 0.02209138f, -0.17378381f, 0.21149272f, 0.07045454f, -0.01352311f, 
    0.05670808f, -0.02083123f, -0.04503550f, -0.00687094f, 0.01028060f, -0.01227023f, 0.02491468f, -0.07140822f, 
    0.10490645f, 0.01324518f, -0.09166009f, -0.05014875f, -0.01565832f, -0.03162453f, -0.01275383f, -0.07435036f, 
    -0.01726641f, -0.01440839f, -0.02804426f, -0.02178763f, -0.01378535f, -0.05573398f, -0.01532439f, -0.07397696f, 
    0.03662761f, 0.00401049f, -0.04025128f, -0.05932555f, -0.03099045f, -0.01557604f, -0.03502636f, -0.09109989f, 
    -0.07905745f, -0.04877980f, -0.07211560f, -0.11292281f, -0.12549335f, -0.01139376f, -0.00999309f, -0.07397944f, 
    0.02229858f, -0.05445350f, -0.05124588f, -0.06610319f, 0.18291257f, -0.01326603f, -0.16573763f, -0.14159133f, 
    -0.04850491f, -0.00739911f, -0.04600942f, -0.09793504f, -0.07226790f, -0.04878383f, -0.04392751f, -0.01553030f, 
    0.02039051f, 0.21270034f, -0.04694047f, 0.03405442f, 0.08999424f, -0.06945021f, -0.03483886f, -0.02578914f, 
    -0.00078709f, -0.07917354f, 0.09451554f, 0.00832960f, 0.08752779f, 0.01749704f, -0.10307448f, 0.01338258f, 
    0.03665452f, -0.02285166f, -0.06119549f, -0.03471206f, 0.01358115f, -0.00568003f, 0.08795772f, -0.03514745f, 
    -0.08524101f, 0.04136809f, 0.09580615f, 0.10261291f, -0.13733228f, 0.05134352f, -0.00122690f, -0.02519515f, 
    -0.01944182f, 0.01427709f, -0.08023567f, -0.05205302f, -0.00599614f, -0.11973659f, -0.25952661f, -0.23472518f, 
    0.00624800f, 0.02515746f, -0.00361378f, -0.14700596f, -0.01435767f, 0.03906092f, -0.06302182f, 0.03523649f, 
    -0.03612369f, -0.17328981f, -0.15213616f, 0.01656896f, 0.11164172f, 0.02505694f, 0.00841526f, -0.07332972f, 
    0.02885094f, 0.07699654f, 0.11685787f, 0.01837318f, 0.01731744f, -0.01084770f, 0.06042142f, 0.02804973f, 
    0.14822254f, -0.02235615f, -0.09788944f, 0.00030192f, 0.00407585f, -0.04876542f, 0.01587907f, -0.09313650f, 
    0.11789833f, -0.04838181f, -0.06837449f, 0.03269510f, 0.06037538f, -0.07146818f, 0.01042382f, -0.02781279f, 
    0.10276131f, 0.03969208f, -0.16318642f, 0.10538520f, 0.13328715f, -0.05458551f, 0.04059237f, 0.07631887f, 
    -0.03229451f, -0.01655431f, 0.03249723f, -0.05360393f, -0.07711824f, -0.09940879f, 0.05162593f, -0.12211349f, 
    -0.09058900f, 0.08467541f, -0.10257562f, -0.16467708f, -0.07782502f, -0.06045065f, -0.11008430f, -0.11929251f, 
    0.04974892f, -0.01036277f, 0.06639905f, 0.04589137f, -0.12844637f, 0.07306906f, -0.31060570f, 0.07866384f, 
    -0.00840897f, -0.01533965f, -0.06395284f, 0.02068674f, 0.09319749f, 0.02251362f, 0.02407720f, 0.03381010f, 
    0.12142643f, 0.17248461f, -0.12208285f, 0.17235725f, -0.06291197f, -0.13413027f, 0.00707509f, -0.02068338f, 
    0.00644271f, -0.02452660f, -0.12575653f, 0.02210993f, 0.04169784f, 0.04802360f, -0.29789391f, -0.22593153f, 
    0.01709289f, -0.14502120f, -0.13198680f, -0.05023186f, -0.02053331f, -0.08074386f, -0.04101782f, 0.02584579f, 
    0.13058938f, -0.06944614f, 0.10600526f, 0.17927882f, 0.08908177f, -0.00833443f, -0.00752021f, -0.06718024f, 
    0.04725278f, 0.02452609f, 0.00454340f, -0.10877718f, -0.02319351f, 0.03177778f, 0.09834748f, 0.07418951f, 
    -0.07815647f, -0.11251225f, -0.04982280f, -0.00095014f, 0.01588369f, -0.03548383f, 0.04998323f, 0.06396487f, 
    0.27870637f, 0.22182228f, -0.30421352f, -0.21295957f, 0.03359681f, -0.00865239f, -0.02716900f, -0.03826640f, 
    0.13709493f, -0.00836123f, -0.04017670f, 0.12854452f, -0.22037761f, -0.09039291f, -0.07488399f, -0.25648946f, 
    -0.03006859f, -0.14831357f, 0.01940604f, -0.06117568f, -0.02171006f, 0.02043066f, -0.02360860f, -0.02306553f, 
    0.14613393f, 0.05055708f, -0.19022952f, -0.09358952f, 0.09337071f, -0.00905536f, -0.06301954f, -0.02782278f, 
    -0.06265610f, 0.08537985f, -0.09313644f, 0.18992747f, 0.10977139f, -0.05851138f, -0.23933582f, -0.19308089f, 
    -0.04266553f, -0.10087172f, -0.01347124f, 0.07634629f, 0.05200142f, 0.07564605f, 0.05268960f, -0.15893726f, 
    0.14853051f, 0.08992708f, 0.04244898f, 0.01569483f, -0.08069247f, 0.05108772f, -0.03113439f, -0.02990399f, 
    -0.01331782f, -0.03085658f, 0.01579969f, 0.01282063f, -0.04352996f, 0.03454700f, -0.12169027f, -0.02974711f, 
    0.06905855f, -0.01654726f, -0.18419260f, -0.06119305f, 0.07904463f, -0.08531389f, 0.06829394f, -0.09166187f, 
    0.03632163f, -0.01542036f, -0.03407814f, 0.11942211f, 0.10175972f, -0.14413224f, -0.14496709f, -0.00556240f, 
    0.06388202f, -0.02221678f, 0.08911923f, -0.06624499f, -0.01183337f, -0.08804117f, 0.01656006f, -0.04246421f, 
    -0.01090895f, -0.05713977f, 0.16464578f, -0.02757597f, 0.02706511f, -0.13118184f, 0.00996564f, 0.04320703f, 
    -0.00592217f, 0.03640115f, 0.15692309f, 0.11221221f, 0.01010860f, 0.01451944f, -0.02456370f, -0.06870762f, 
    -0.05894764f, 0.02852295f, 0.05184197f, 0.02814030f, -0.08943399f, -0.09096476f, -0.12549727f, -0.06012619f, 
    0.00121175f, 0.03652526f, 0.04845353f, -0.12964408f, 0.04078819f, -0.00046716f, -0.03814279f, 0.10468470f, 
    0.02092650f, 0.04816542f, 0.00422714f, 0.01473160f, -0.00443235f, 0.03046761f, 0.07197101f, -0.16837300f, 
    0.03643897f, 0.07326170f, 0.02732742f, 0.09335700f, 0.15214258f, 0.00432961f, 0.11139990f, 0.17620909f, 
    0.08837958f, -0.02322269f, -0.03109423f, -0.03294296f, 0.01516077f, -0.12109173f, 0.18556355f, -0.02070843f, 
    0.05985846f, 0.27604422f, -0.16669725f, -0.00183727f, -0.07604382f, 0.05737916f, 0.03643493f, -0.06129022f, 
    -0.01316993f, -0.10377109f, 0.07116173f, 0.04675113f, -0.09164713f, -0.07794123f, 0.05069862f, 0.08918558f, 
    0.06057749f, -0.05120166f, -0.01662527f, -0.05794116f, 0.03782811f, 0.02944138f, -0.14963910f, 0.04880455f, 
    0.15846072f, 0.08061397f, 0.02524470f, 0.13161778f, 0.03109561f, -0.06922693f, -0.00204842f, -0.08259197f, 
    0.08621383f, -0.03388404f, 0.04374288f, 0.00268917f, 0.10726842f, 0.03172606f, 0.02895457f, 0.11853476f, 
    -0.03139560f, -0.01409493f, 0.02041440f, 0.01880874f, -0.07080491f, -0.00347497f, -0.12925005f, -0.00428917f, 
    -0.12313388f, -0.15251675f, 0.12961903f, -0.20226142f, 0.05668496f, 0.04370842f, -0.15436235f, 0.12038267f, 
    0.13632549f, 0.05536207f, 0.01920909f, 0.03163012f, -0.12909316f, -0.17995557f, 0.07829896f, -0.09391347f, 
    -0.07389650f, -0.10207271f, 0.03076047f, 0.03593436f, -0.01011704f, 0.05079583f, -0.10377444f, -0.02893536f, 
    -0.07973781f, 0.18390666f, 0.06713284f, 0.05659049f, 0.04743480f, 0.05089458f, -0.01827479f, 0.04609927f, 
    -0.04321282f, 0.01104237f, -0.09160993f, 0.05958562f, 0.01910344f, -0.22589503f, -0.01377546f, -0.07546844f, 
    -0.03483078f, -0.25958505f, -0.05825679f, -0.18825728f, -0.07184862f, 0.05923581f, 0.03198332f, -0.04504542f, 
    0.00582474f, 0.22726992f, -0.23340803f, 0.06840385f, -0.09111299f, -0.01786325f, -0.13192242f, 0.05707375f, 
    0.05271136f, 0.11274890f, -0.10904973f, -0.04914419f, 0.15614924f, -0.05126151f, -0.03694705f, -0.25511757f, 
    -0.03066841f, -0.01226492f, 0.10422287f, 0.00601911f, 0.03364034f, 0.06784509f, -0.01283742f, 0.05733044f, 
    -0.17811860f, -0.06480005f, 0.04837977f, 0.05709735f, 0.13658705f, -0.13689043f, -0.01121188f, 0.07051454f, 
    0.10524945f, 0.01628087f, -0.04895198f, 0.09555843f, -0.14388444f, -0.05663742f, 0.05775476f, -0.09847408f, 
    -0.02146357f, -0.08431639f, -0.16471627f, -0.04818801f, 0.08688243f, 0.01929264f, -0.03100601f, 0.05936593f, 
    -0.27406064f, -0.07423533f, -0.16662461f, -0.25773805f, -0.09123999f, -0.01432909f, -0.05326878f, -0.02878187f, 
    0.06604239f, 0.01347699f, 0.04231828f, 0.06701922f, -0.20872524f, 0.10698438f, 0.10255991f, -0.06141501f, 
    -0.03951784f, 0.02130946f, -0.11872255f, 0.00958905f, 0.06730400f, -0.03052578f, 0.02457992f, -0.05105697f, 
    -0.15274353f, 0.09440243f, 0.00974877f, -0.11130415f, -0.08243496f, 0.07233486f, 0.04894533f, 0.04977938f, 
    0.06154989f, -0.05951735f, -0.08154378f, 0.08706951f, -0.18179323f, -0.16043378f, -0.11162236f, -0.10996011f, 
    -0.03924949f, -0.01483040f, 0.02648610f, -0.10732684f, 0.01881516f, 0.11949612f, 0.02469100f, -0.11429422f, 
    -0.12870978f, -0.03885859f, 0.19916742f, -0.04656403f, 0.06225080f, -0.01022066f, 0.07890519f, -0.00765930f, 
    -0.08182599f, 0.00502169f, 0.00970074f, 0.03879195f, -0.02310815f, -0.15351079f, 0.11534273f, 0.17291416f, 
    0.04309933f, -0.08384514f, -0.00243037f, 0.06710878f, 0.08793208f, 0.03831349f, 0.05861385f, -0.02362448f, 
    -0.10063384f, -0.14642625f, 0.11177145f, -0.26186180f, -0.04055579f, 0.00367564f, 0.07051826f, -0.04522569f, 
    0.06964350f, 0.05450481f, 0.01060803f, 0.04267430f, 0.04099900f, -0.16673543f, -0.00806660f, 0.01148949f, 
    -0.07183359f, -0.09465156f, 0.06244553f, -0.09185186f, 0.08558425f, -0.00295449f, -0.08723398f, -0.02141670f, 
    -0.19049370f, -0.07892993f, 0.19152600f, -0.01504358f, 0.03935410f, -0.01986653f, 0.04612016f, -0.16812024f, 
    -0.14321661f, -0.06399129f, 0.03848758f, -0.12894748f, -0.21460114f, 0.07662577f, 0.13500457f, 0.03521289f, 
    -0.15403645f, 0.08472659f, 0.05222584f, 0.08579897f, 0.06121975f, -0.07488088f, 0.02888004f, 0.04826913f, 
    0.09169397f, -0.01177591f, -0.09803405f, 0.10980856f, 0.07466499f, 0.03435824f, 0.01688327f, -0.02589715f, 
    0.04421791f, 0.02046944f, 0.11216620f, 0.06159662f, -0.15989785f, 0.21032284f, -0.03881006f, 0.06606978f, 
    -0.14997292f, -0.12956901f, 0.05815843f, -0.08364301f, 0.01380615f, -0.05956344f, 0.01385512f, -0.01759252f, 
    -0.12344474f, -0.04011945f, 0.04104426f, -0.05340600f, -0.13759702f, 0.02775431f, 0.06070285f, 0.02583755f, 
    0.07862978f, 0.01541788f, -0.14800879f, -0.22365008f, 0.13386638f, -0.00289836f, -0.10103627f, 0.04911854f, 
    0.07671309f, 0.03413663f, -0.10409674f, 0.00507049f, 0.09651246f, -0.04701641f, 0.03492168f, -0.01810488f, 
    0.22631428f, 0.17428212f, -0.06111640f, 0.11872577f, -0.05406348f, -0.05060136f, -0.07298131f, -0.06444161f, 
    -0.02537954f, -0.03904121f, -0.06164162f, 0.04888185f, -0.09803446f, -0.03766625f, 0.05446852f, 0.07539407f, 
    -0.06362309f, 0.02399213f, -0.13353485f, -0.01953009f, -0.02550863f, -0.06631838f, 0.07264154f, 0.04923473f, 
    -0.07090691f, -0.03778003f, -0.01355863f, -0.12079846f, 0.00786194f, 0.03007103f, 0.00629065f, -0.03344852f, 
    0.03728451f, -0.04200426f, 0.04985480f, 0.02072477f, -0.04930047f, -0.03021597f, -0.11880939f, 0.05457063f, 
    0.04895881f, -0.10858392f, -0.03615965f, 0.03716332f, 0.05671729f, -0.11126973f, 0.00490055f, -0.03544225f, 
    -0.24193767f, -0.08668362f, 0.22553004f, -0.15262054f, -0.02849600f, -0.09041763f, 0.01494556f, -0.07668155f, 
    0.01903265f, 0.02353246f, 0.02267939f, -0.00825776f, -0.22326989f, 0.10795026f, 0.09134291f, 0.09702238f, 
    -0.06405986f, -0.08742549f, 0.04334337f, -0.06274262f, -0.00555610f, -0.01944131f, -0.10831290f, 0.07725982f, 
    -0.11047850f, 0.08273817f, -0.10893429f, -0.18520166f, 0.00346825f, 0.00238131f, -0.06494521f, 0.02390436f, 
    0.07531241f, 0.07320841f, -0.02573956f, -0.23441479f, 0.05715046f, 0.00362636f, -0.03845432f, -0.03802991f, 
    0.04339838f, -0.02102891f, -0.17947407f, -0.03674774f, 0.11871108f, 0.10294903f, 0.03149352f, -0.03723262f, 
    0.09611505f, 0.09052674f, -0.01857295f, 0.03176077f, -0.13370222f, 0.06573457f, -0.02285369f, -0.04613104f, 
    -0.07216019f, 0.01101594f, 0.06545605f, 0.01320175f, 0.02454056f, 0.05957954f, -0.16638899f, 0.02767811f, 
    -0.02594462f, -0.01041681f, -0.00877830f, 0.04956406f, -0.02135928f, -0.04165316f, -0.11843535f, 0.07767807f, 
    0.09861296f, -0.02418635f, -0.04769461f, 0.03703674f, 0.01275129f, 0.03155310f, -0.00178820f, -0.00861057f, 
    0.03348754f, 0.00387479f, -0.06524565f, 0.05228223f, -0.02132687f, -0.08689132f, 0.01161614f, 0.08482525f, 
    0.07448959f, -0.02226506f, -0.08005543f, -0.04082902f, 0.02929609f, -0.05224297f, 0.00866384f, -0.06580222f, 
    -0.12042763f, -0.43429637f, -0.02321686f, -0.08615866f, -0.07117809f, -0.00794294f, -0.11255160f, 0.05541244f, 
    0.01990452f, -0.05420149f, 0.13846858f, 0.10810509f, -0.17504463f, 0.30729923f, -0.07658626f, 0.02827919f, 
    0.06400967f, 0.05822741f, 0.10850153f, -0.06568088f, -0.02417080f, 0.05153316f, -0.06109442f, -0.07167492f, 
    -0.18718562f, -0.17000757f, -0.04530604f, 0.00103799f, 0.07524327f, 0.01049308f, 0.00761786f, 0.01718880f, 
    -0.03141683f, 0.02267914f, 0.02749343f, -0.02501655f, -0.06396486f, -0.08766414f, 0.04465435f, 0.11371687f, 
    0.04519193f, 0.03572603f, -0.01614415f, 0.12700224f, -0.06009486f, 0.03368627f, 0.09526236f, 0.04074015f, 
    -0.10577238f, -0.04734172f, -0.06018243f, -0.25254932f, 0.04882960f, -0.02647518f, -0.05072077f, 0.05916635f, 
    0.02459419f, -0.08908862f, -0.02692281f, -0.11667655f, 0.02626842f, -0.17086498f, 0.01890222f, -0.21152814f, 
    -0.03032823f, -0.00432034f, 0.03324752f, -0.02766259f, 0.04295712f, 0.07791112f, 0.11302648f, -0.04721471f, 
    -0.16049437f, 0.01371063f, -0.01663986f, 0.04722227f, 0.13162738f, 0.11313437f, -0.09539177f, -0.00180952f, 
    0.01825887f, -0.03087666f, 0.13342440f, 0.03440065f, 0.30442759f, -0.03512314f, -0.06580148f, -0.00045492f, 
    0.01820676f, 0.11088737f, 0.02541895f, -0.00575342f, -0.00755746f, 0.05515200f, -0.00345252f, 0.08663468f, 
    -0.25244755f, 0.18155839f, 0.25074667f, -0.04918941f, 0.11101789f, 0.16756751f, -0.10226893f, 0.05425108f, 
    -0.06932078f, -0.14585826f, -0.09362739f, -0.09119488f, 0.21132359f, -0.38866472f, 0.10808750f, -0.25278479f, 
    0.01036516f, 0.03895589f, 0.03309410f, -0.02827823f, -0.03832324f, -0.05589510f, 0.03687446f, -0.05454607f, 
    0.03830641f, 0.00464873f, 0.10476863f, -0.01999506f, 0.04633584f, 0.04244614f, 0.02916230f, 0.13083446f, 
    0.11890765f, -0.01847584f, 0.02519078f, -0.00422826f, -0.11615461f, 0.00990515f, 0.18364531f, -0.09098920f, 
    0.05230652f, 0.09798949f, 0.04550162f, 0.01723967f, 0.04618858f, -0.07669557f, 0.02020972f, -0.03188448f, 
    -0.26420629f, 0.17816100f, -0.29908431f, -0.13544372f, 0.03989992f, -0.03310962f, 0.02008925f, 0.06364123f, 
    0.01601409f, 0.03446824f, -0.05755196f, 0.05393970f, 0.50467122f, 0.09734733f, -0.08943423f, -0.14197575f, 
    0.10790698f, -0.09217233f, -0.01760583f, -0.07003196f, -0.01054143f, -0.07108505f, 0.02121098f, 0.08707881f, 
    0.39695570f, 0.00019539f, 0.28715974f, -0.02178443f, 0.01627630f, 0.07523686f, -0.00168888f, -0.01895512f, 
    -0.02594269f, -0.04277060f, -0.04925412f, -0.00648215f, -0.14137737f, -0.08273516f, -0.07988496f, 0.06089780f, 
    0.07298291f, 0.13499030f, -0.04311474f, 0.01381013f, -0.04319377f, -0.03474736f, -0.09524205f, -0.06446680f, 
    0.10602477f, -0.22408946f, 0.32262468f, -0.08848277f, 0.06581751f, -0.02916588f, -0.04292927f, -0.06031050f, 
    0.07639823f, -0.03469554f, -0.01627325f, -0.16446552f, -0.36987281f, 0.10910697f, 0.01305421f, -0.06667620f, 
    0.09690902f, 0.08091807f, 0.12366872f, 0.00144727f, 0.02830302f, 0.04406088f, 0.05030607f, 0.16996352f, 
    0.06120724f, 0.03744783f, -0.02621109f, 0.05588467f, 0.06477067f, 0.13967624f, -0.03283317f, 0.05093570f, 
    -0.03169402f, 0.09823215f, -0.08650128f, -0.04204940f, -0.15042658f, -0.01814961f, 0.17597131f, -0.07484173f, 
    -0.11314967f, -0.05504157f, -0.07465192f, -0.00160764f, -0.01349038f, 0.07417006f, 0.04415934f, -0.05453373f, 
    0.06549484f, -0.04806269f, -0.06481969f, -0.27893686f, -0.05773908f, 0.03848080f, -0.13546918f, 0.10792194f, 
    0.09425215f, -0.03939678f, 0.04144652f, 0.01807558f, -0.00582160f, -0.25455493f, 0.11525342f, -0.02742190f, 
    0.10305151f, 0.01146121f, -0.05442292f, -0.01473007f, 0.02007605f, 0.02846357f, 0.04975374f, 0.03694955f, 
    -0.07519981f, 0.01388941f, 0.02873735f, -0.00110101f, 0.04360178f, -0.07314722f, 0.03591790f, -0.02103292f, 
    0.03553217f, 0.04235299f, 0.03365862f, -0.05453149f, 0.02879314f, 0.01288346f, -0.13282028f, -0.02521600f, 
    -0.11889792f, 0.05516539f, -0.02714755f, 0.01721949f, -0.07367807f, -0.00023338f, 0.01643850f, -0.06969556f, 
    0.30918145f, -0.17316554f, -0.21687537f, 0.02046368f, 0.03186891f, 0.01322986f, 0.07396121f, 0.05896130f, 
    0.02733757f, -0.02229990f, -0.07700428f, -0.22706150f, -0.36615008f, 0.23187113f, 0.07431013f, -0.24885896f, 
    0.04192342f, -0.12568007f, -0.04888932f, -0.02819682f, -0.00265210f, 0.02177195f, -0.19214222f, -0.07654458f, 
    -0.28437775f, 0.18312345f, 0.33689979f, 0.10794757f, 0.00152456f, -0.01757098f, -0.08572579f, 0.14239800f, 
    0.10015758f, 0.01880583f, 0.09271697f, 0.01524921f, 0.09341382f, -0.17446266f, 0.07732616f, -0.05544309f, 
    0.02886377f, -0.02295864f, -0.06751766f, 0.03638398f, 0.02475887f, -0.10305826f, 0.02835366f, 0.00025647f, 
    -0.16325857f, 0.17437775f, -0.38439044f, -0.07956769f, 0.17508502f, -0.08688669f, 0.08004270f, -0.05322678f, 
    -0.18026455f, -0.11579859f, -0.03815794f, -0.03119065f, -0.10115531f, -0.07167201f, 0.13811500f, -0.14726289f, 
    0.01305430f, 0.04997052f, 0.15614538f, 0.09697828f, 0.03730181f, -0.09370252f, 0.01420779f, -0.00667391f, 
    0.14192808f, -0.06152749f, -0.17018242f, -0.14361389f, -0.15971363f, -0.10518551f, 0.06015535f, -0.14044923f, 
    -0.04351876f, 0.02316162f, -0.09752779f, 0.08279083f, 0.05732119f, -0.00344559f, -0.10477947f, -0.03889749f, 
    -0.05627496f, -0.02423803f, 0.05347797f, -0.01615835f, 0.01226253f, 0.02608936f, 0.11312365f, -0.04773260f, 
    -0.21732907f, 0.14655529f, 0.04458858f, 0.13122372f, -0.07617792f, -0.03682427f, 0.05174033f, -0.03200775f, 
    0.16559917f, 0.07282172f, 0.02066451f, 0.10990456f, -0.00365793f, -0.01082557f, -0.15839349f, 0.37707698f, 
    -0.07715058f, 0.02027769f, -0.04543108f, -0.09623743f, -0.04919199f, -0.06287263f, 0.08209874f, 0.08665822f, 
    -0.12001846f, 0.35231692f, 0.08393944f, 0.20020448f, 0.01230933f, -0.04568013f, -0.10980914f, 0.06523464f, 
    0.02571202f, -0.02869871f, 0.03448514f, 0.07118536f, -0.00064695f, 0.10820772f, -0.02466059f, -0.02110227f, 
    -0.01397923f, -0.15057580f, -0.03221379f, -0.04121576f, -0.07567408f, -0.03491953f, 0.02542462f, 0.11442640f, 
    -0.53485364f, 0.00262631f, -0.06788513f, 0.02339222f, -0.09115806f, 0.00307073f, -0.06435025f, -0.08900719f, 
    -0.02469114f, -0.11801540f, 0.14788382f, -0.03700149f, -0.05881842f, -0.05715369f, -0.02617264f, -0.23936424f, 
    -0.03172167f, 0.00502816f, 0.06391256f, 0.07782470f, -0.01385840f, -0.03408683f, -0.01961836f, 0.06162949f, 
    0.08732217f, 0.12876791f, -0.16454983f, -0.16835093f, -0.05180616f, -0.03236150f, 0.07096005f, -0.13161671f, 
    -0.12315403f, -0.03021667f, 0.05674036f, -0.04605358f, -0.17618862f, -0.05419638f, 0.09313957f, -0.06529748f, 
    0.10159431f, -0.02296467f, 0.00167957f, 0.07023323f, -0.02860615f, -0.02585393f, -0.01802780f, 0.00502600f, 
    0.49184689f, 0.17988645f, -0.07540697f, -0.13355987f, 0.07960004f, -0.06349910f, 0.09030720f, 0.00827090f, 
    -0.14668599f, -0.05600746f, 0.12085717f, -0.06001342f, -0.01046970f, 0.01850014f, -0.22193165f, -0.23131409f, 
    0.01987687f, -0.04121546f, -0.05499445f, 0.12263276f, 0.11897579f, 0.02202367f, -0.01027563f, 0.02080595f, 
    0.22722365f, -0.12113579f, -0.11354939f, 0.11169804f, 0.00252175f, 0.03039796f, -0.01411911f, 0.05487564f, 
    0.02803510f, -0.07778957f, 0.00377209f, -0.15261294f, -0.28672424f, 0.18371977f, -0.19145893f, -0.12344076f, 
    0.02020426f, 0.07832305f, -0.08767428f, -0.13729657f, -0.04019935f, -0.05609666f, -0.07923080f, -0.04551928f, 
    0.04419129f, 0.02281319f, -0.21587367f, -0.00267209f, 0.11420500f, 0.09005307f, -0.04232133f, -0.01248546f, 
    -0.07153337f, -0.11197097f, 0.01964509f, -0.02175326f, -0.12820403f, -0.01025689f, -0.19540845f, 0.07073265f, 
    -0.04164381f, 0.02783829f, -0.02558289f, -0.07776080f, 0.04977499f, 0.03550642f, 0.09185048f, -0.03108952f, 
    0.19614321f, 0.02103456f, 0.12883638f, 0.30454320f, 0.12686600f, -0.06524671f, -0.11438810f, 0.03507594f, 
    0.01304391f, 0.03756405f, 0.04248866f, 0.01502272f, -0.13729195f, 0.12464362f, 0.07048886f, 0.13749443f, 
    0.07873475f, 0.07531136f, 0.01743806f, 0.06460422f, -0.06218213f, 0.04548121f, 0.07996089f, 0.02066688f, 
    -0.07436828f, 0.19376475f, -0.05331586f, -0.27054292f, 0.02648265f, 0.03827653f, 0.01285339f, -0.03383015f, 
    -0.02693312f, 0.05504854f, -0.02767914f, -0.04107190f, -0.18584181f, 0.18778400f, -0.17201301f, 0.27846846f, 
    0.02969402f, 0.00689586f, -0.09699393f, 0.04207944f, 0.08275136f, 0.02753249f, 0.08018164f, 0.03476620f, 
    -0.18264733f, 0.02971357f, -0.18771677f, 0.16053937f, 0.08722791f, -0.02620330f, -0.07738759f, -0.00511309f, 
    0.00818375f, 0.04121351f, 0.13831851f, 0.00324190f, 0.30675367f, -0.08369747f, -0.06828056f, -0.16327323f, 
    0.08014607f, 0.01437440f, 0.03567774f, -0.00307779f, -0.13071086f, -0.08609509f, -0.23890372f, -0.01483654f, 
    0.00177695f, -0.18680105f, 0.01436395f, 0.05383569f, 0.07682862f, 0.02210343f, -0.08599015f, 0.06998806f, 
    -0.02296268f, 0.03801956f, 0.12935106f, -0.01507561f, -0.11379267f, -0.37703869f, 0.19961812f, -0.10395047f, 
    0.00821530f, -0.04179223f, 0.03421029f, -0.06283036f, -0.13173287f, 0.00073855f, -0.13323250f, 0.13770947f, 
    -0.04682938f, -0.32476410f, 0.01019279f, -0.11066969f, 0.11186883f, 0.12604693f, 0.10103028f, -0.13186795f, 
    -0.07601055f, 0.03991468f, -0.05409325f, -0.02189044f, -0.46348000f, 0.15841994f, 0.05400907f, 0.00238575f, 
    0.02103869f, 0.07445323f, 0.02567036f, -0.09543811f, -0.00841326f, -0.07085963f, 0.09543125f, 0.06176297f, 
    0.26792237f, -0.07231888f, -0.21136782f, 0.06148366f, -0.06576309f, -0.01917748f, 0.01461070f, -0.06133928f, 
    -0.03836333f, -0.10615233f, 0.07491338f, -0.02981687f, -0.02466404f, -0.16133590f, 0.01923785f, 0.10644964f, 
    0.01944359f, -0.04478669f, 0.00197727f, 0.01366605f, -0.07612760f, -0.05100331f, 0.08187018f, 0.03109331f, 
    -0.02475736f, -0.02685656f, -0.10069299f, 0.06841005f, 0.05965374f, 0.02478726f, 0.04337227f, -0.14202738f, 
    0.01981510f, 0.00630781f, 0.00592363f, 0.03286687f, -0.20845190f, -0.43049246f, -0.02064244f, -0.04276362f, 
    -0.07475499f, -0.05480206f, 0.05754668f, -0.03418043f, -0.04851758f, -0.20492788f, 0.09034783f, -0.08039797f, 
    0.04600427f, 0.16595367f, 0.00633273f, 0.02603320f, 0.05319504f, -0.06332507f, 0.04117847f, 0.08631692f, 
    -0.00716027f, 0.03747343f, 0.03155697f, -0.07373609f, 0.04610477f, -0.02368219f, 0.25429362f, -0.13454460f, 
    0.06191168f, 0.11510708f, -0.00153433f, -0.05179099f, -0.06050311f, -0.14301273f, 0.02731038f, 0.06787860f, 
    0.20966977f, 0.04188894f, 0.18883309f, -0.04887116f, 0.00749724f, 0.06982312f, 0.05840356f, -0.01006722f, 
    0.06202197f, 0.03848487f, 0.07583239f, 0.02054099f, 0.02428669f, -0.12614018f, 0.06721118f, -0.12709929f, 
    -0.04227591f, 0.05121983f, -0.01237392f, -0.07120295f, -0.01207873f, -0.02277344f, -0.03507924f, 0.07445130f, 
    -0.22888999f, 0.02000554f, -0.10044593f, 0.07612759f, 0.05773220f, 0.06222948f, 0.06091304f, -0.04942233f, 
    -0.00910522f, 0.09209039f, 0.00024951f, 0.03545522f, -0.20696299f, -0.21370186f, 0.02300369f, 0.01443992f, 
    0.09316962f, 0.07546593f, -0.06442723f, -0.03112377f, 0.06335353f, 0.08047760f, 0.06868213f, 0.02268003f, 
    0.24003471f, 0.04126557f, -0.01129294f, -0.06194144f, -0.10579064f, -0.12423661f, -0.05274872f, -0.03078324f, 
    0.00256274f, -0.02816751f, -0.07130576f, -0.09550104f, -0.18237838f, -0.04003359f, 0.10299837f, 0.01897748f, 
    0.03496485f, 0.00041597f, -0.10363807f, -0.06355570f, -0.00439912f, 0.07207885f, -0.18940702f, 0.10323905f, 
    -0.45706344f, -0.04962514f, -0.03868921f, -0.13171047f, 0.02570326f, -0.02004241f, -0.02754427f, -0.08389860f, 
    -0.01915132f, 0.12880500f, 0.06430451f, 0.10506692f, -0.32641798f, 0.11848456f, -0.00436047f, 0.07220819f, 
    0.02828400f, -0.06622998f, -0.02983478f, -0.01180978f, -0.05322451f, -0.01343756f, 0.01789724f, 0.02018782f, 
    -0.24041471f, -0.38186896f, -0.18647872f, 0.02805048f, 0.00048794f, 0.06585258f, 0.12298197f, -0.10451761f, 
    0.03168796f, -0.17275079f, -0.05704971f, -0.03050056f, -0.09160108f, -0.00037882f, -0.16534247f, 0.02898981f, 
    -0.01642810f, 0.00425291f, -0.07846196f, -0.08422309f, 0.09824917f, -0.04459067f, -0.06843570f, 0.02796965f, 
    -0.04941712f, -0.18427309f, -0.02525012f, -0.03235444f, 0.00437219f, 0.08106869f, 0.00779708f, 0.04576335f, 
    -0.00299956f, 0.04247912f, 0.01130727f, 0.03124712f, -0.05571733f, 0.14303242f, -0.09734643f, -0.05009201f, 
    0.11289247f, -0.00273319f, 0.01965037f, 0.10296616f, 0.09502333f, 0.03636939f, -0.06133295f, -0.00965012f, 
    -0.03029488f, -0.10065006f, -0.08485404f, -0.05851167f, -0.07342644f, 0.02025416f, 0.05650276f, -0.05276258f, 
    0.08834039f, 0.02753464f, 0.03638116f, -0.02678634f, -0.02373953f, 0.03075952f, 0.02787591f, -0.02429642f, 
    0.13055678f, -0.00332412f, 0.02355318f, 0.01442573f, -0.01067649f, -0.04568929f, 0.10168869f, -0.04022382f, 
    -0.52845311f, -0.34097025f, -0.15182355f, -0.17177165f, 0.00312593f, -0.02550553f, -0.06637707f, -0.03649780f, 
    0.02043618f, -0.01756170f, -0.02330643f, -0.01041317f, 0.06040708f, 0.01643363f, -0.05025575f, 0.03131900f, 
    0.07567753f, -0.09597102f, 0.00314615f, 0.11876170f, 0.06603229f, 0.10872833f, 0.02890848f, 0.07946394f, 
    -0.32512531f, -0.04308381f, 0.18321742f, 0.11889385f, 0.11258510f, -0.06909563f, 0.01407531f, -0.00180737f, 
    0.00223786f, 0.02235635f, -0.01671419f, 0.10661080f, 0.08634225f, -0.01579257f, 0.01967789f, -0.00632381f, 
    0.03806498f, 0.05229744f, 0.00868722f, -0.06753173f, 0.02867828f, -0.01476020f, -0.00317539f, -0.04641374f, 
    -0.04054363f, 0.09112940f, 0.02780435f, 0.02125502f, 0.11754034f, -0.10880020f, 0.02585749f, -0.12569000f, 
    -0.00320389f, 0.02871359f, -0.02176810f, 0.16740134f, -0.19939008f, -0.09458593f, 0.08090749f, 0.13727276f, 
    0.02940743f, 0.00741972f, 0.08693862f, 0.09718468f, 0.04173630f, 0.14754196f, -0.10105188f, 0.12494013f, 
    0.06252465f, -0.04233560f, -0.02969411f, 0.02719587f, -0.03154924f, -0.08793791f, -0.02357907f, -0.01626161f, 
    0.06030160f, -0.10993437f, 0.00708391f, 0.14455475f, -0.52816838f, -0.06463891f, 0.06491435f, 0.01059172f, 
    0.15660508f, -0.14874579f, -0.03818424f, -0.15327121f, -0.16400583f, -0.23103800f, -0.14141686f, -0.14204101f, 
    -0.39102173f, 0.09842318f, -0.23632701f, -0.22208956f, 0.14448994f, -0.03807637f, -0.06225663f, -0.09631389f, 
    0.07546820f, -0.13599797f, -0.02773079f, -0.04837943f, -0.11007810f, 0.16014268f, -0.23153278f, 0.09082794f, 
    -0.14666837f, -0.13161209f, -0.05791337f, -0.18501265f, -0.01278878f, -0.08234558f, -0.04288908f, -0.02540467f, 
    0.17727628f, 0.08735888f, 0.01749848f, 0.04102388f, -0.08721746f, -0.02311412f, 0.06564385f, 0.01600557f, 
    -0.03132999f, -0.18308127f, -0.05442880f, 0.12085501f, 0.11715651f, 0.15559357f, -0.12623295f, 0.13714425f, 
    -0.02121872f, 0.08116235f, 0.05503072f, 0.03931527f, -0.01579979f, 0.00363746f, 0.03507257f, -0.04014540f, 
    0.16105968f, 0.07851037f, -0.04721837f, -0.06240555f, -0.06545160f, 0.06258974f, 0.06285783f, 0.02426509f, 
    0.01846983f, 0.05289367f, 0.05564740f, 0.02520263f, -0.67356604f, -0.45844230f, -0.10211659f, -0.17448884f, 
    0.06538222f, -0.03471643f, -0.06157704f, -0.01849064f, 0.00031419f, -0.04747324f, 0.07217156f, 0.02264370f, 
    -0.05607485f, -0.08260763f, 0.01139400f, -0.07271308f, -0.04772320f, -0.06807104f, -0.06046426f, -0.05571541f, 
    0.08461043f, -0.01678558f, 0.00745200f, 0.07333931f, -0.39979857f, -0.05523304f, -0.09788863f, -0.10544897f, 
    0.05345326f, -0.02315211f, -0.07607305f, 0.00523380f, 0.07810703f, -0.05086713f, 0.06595635f, 0.12737757f, 
    -0.15337168f, -0.08217470f, -0.11446573f, -0.27656496f, 0.01400472f, -0.04819995f, 0.03070461f, -0.03715177f, 
    -0.00835435f, -0.04633589f, 0.06054103f, -0.10806340f, 0.03573795f, -0.04961172f, 0.04152304f, -0.11606078f, 
    -0.06619794f, 0.02375153f, -0.08114036f, -0.04744682f, 0.04132232f, -0.01217557f, -0.09506657f, -0.07371779f, 
    0.18041793f, 0.24516758f, -0.01600947f, -0.13558291f, 0.04830959f, 0.05348437f, 0.08460612f, 0.08843260f, 
    0.01157875f, 0.12213085f, 0.09879440f, 0.04964879f, -0.04043802f, 0.13576002f, -0.04695715f, 0.11092336f, 
    0.03086975f, -0.03469804f, -0.07755715f, 0.09581054f, -0.03817020f, -0.01660706f, -0.08309366f, 0.06687837f, 
    0.18519795f, -0.05547110f, -0.05976958f, 0.07072636f, -0.08845504f, 0.04707520f, 0.03765567f, 0.06973073f, 
    0.12479661f, 0.08486947f, -0.04672147f, 0.05271586f, -0.04429135f, -0.09388249f, 0.08255067f, -0.12284795f, 
    -0.03036285f, -0.12174401f, -0.13473950f, -0.09471746f, -0.03275358f, -0.17188284f, -0.10593858f, -0.00515878f, 
    -0.18516323f, -0.30786431f, 0.09885248f, 0.03468842f, -0.02345082f, 0.10336034f, 0.11291245f, -0.02859505f, 
    0.01592447f, 0.03654247f, -0.06979335f, 0.01392714f, 0.02149725f, 0.10737162f, -0.21422955f, 0.07082907f, 
    0.10833595f, 0.06457852f, 0.05189795f, -0.01911797f, 0.10264026f, 0.09181403f, 0.06901076f, -0.07746327f, 
    -0.06818395f, 0.06486420f, -0.13113052f, -0.07481628f, 0.16027418f, -0.08120817f, 0.03022520f, 0.12284613f, 
    0.07733399f, 0.01742874f, 0.03832499f, 0.06245853f, -0.15806645f, 0.08275465f, 0.01717905f, 0.11879998f, 
    0.00237149f, -0.02176072f, -0.03708801f, -0.24529299f, -0.04100200f, -0.04587564f, -0.04257116f, 0.03135252f, 
    0.08229834f, 0.08588819f, 0.05965281f, -0.09564824f, 0.09280478f, 0.00045155f, -0.10185323f, 0.15726386f, 
    -0.13679434f, -0.04409211f, 0.08823926f, 0.09166322f, 0.06452549f, 0.07776515f, -0.07771385f, -0.05588560f, 
    -0.03598911f, 0.11585835f, 0.09476051f, -0.07466712f, 0.02737540f, 0.04983658f, 0.00203437f, -0.02565068f, 
    -0.23807679f, -0.08071909f, 0.00717474f, 0.10405941f, 0.01421378f, -0.02370149f, 0.13196212f, -0.07650372f, 
    0.13691981f, 0.07562754f, 0.04096920f, 0.08662239f, 0.34577596f, 0.19231087f, 0.08938227f, -0.07064319f, 
    -0.00032954f, -0.00542512f, 0.07202326f, 0.12196410f, 0.17333609f, 0.16874801f, 0.09721068f, 0.07397778f, 
    0.16614451f, 0.01864299f, 0.15647596f, -0.20496386f, 0.01990373f, 0.00846770f, 0.05415018f, -0.09536637f, 
    -0.00111256f, -0.01132246f, 0.01671524f, 0.08965864f, -0.48192480f, -0.26741564f, -0.08282918f, -0.13876338f, 
    -0.03348185f, -0.17566623f, 0.06569958f, 0.07077856f, -0.00097148f, 0.10649913f, 0.01531290f, 0.08763701f, 
    -0.05547248f, 0.02716542f, 0.01958916f, 0.08529081f, 0.01726816f, 0.06965405f, -0.02210690f, -0.04119449f, 
    0.00806689f, 0.11210578f, 0.05850226f, 0.00897572f, 0.04336267f, 0.03172063f, -0.01354686f, 0.05274309f, 
    -0.12733904f, -0.02963805f, 0.04190270f, -0.05102583f, 0.00503882f, 0.07670312f, -0.03149852f, 0.09917916f, 
    0.29939666f, 0.02191826f, 0.08122466f, -0.19152047f, -0.15307456f, -0.04256640f, 0.04965379f, 0.04861934f, 
    0.03809166f, 0.07282939f, -0.14610335f, -0.11691418f, 0.10989128f, 0.05682694f, 0.03506419f, 0.07123615f, 
    -0.03990945f, -0.08731974f, 0.00902865f, 0.03783790f, 0.11155899f, 0.00639915f, -0.00151351f, 0.05847360f, 
    -0.11519973f, 0.01068350f, -0.04575985f, -0.04301590f, 0.06173494f, 0.05376642f, 0.05581965f, 0.04607011f, 
    0.09498087f, 0.09661216f, 0.01256424f, 0.01416090f, -0.01573034f, -0.11100476f, -0.05400532f, 0.12443338f, 
    -0.05726413f, -0.02360791f, 0.13913423f, 0.01877000f, 0.06231346f, 0.00091732f, 0.06620270f, -0.02899664f, 
    0.12649965f, 0.18814553f, -0.00472125f, 0.05311693f, -0.01173334f, -0.18438771f, 0.06303429f, -0.08779227f, 
    0.02952073f, -0.08944100f, -0.10119189f, -0.05386759f, -0.28970426f, -0.02215204f, -0.10423649f, -0.09264174f, 
    0.07199917f, -0.00130036f, -0.03946183f, -0.09811350f, 0.06028147f, 0.08675316f, 0.12844603f, -0.08607829f, 
    -0.00334937f, 0.08446839f, -0.06708700f, -0.10530157f, 0.03715123f, 0.03303611f, -0.04803609f, -0.07827380f, 
    0.02528257f, -0.01893828f, -0.03499232f, 0.05537003f, 0.10808698f, 0.08807722f, -0.00323770f, -0.03673858f, 
    0.00639222f, 0.07518741f, -0.04350072f, 0.06115190f, 0.07344363f, 0.12738854f, 0.07330198f, 0.06990856f, 
    0.17765644f, 0.03035666f, -0.15577461f, 0.01286182f, -0.03136063f, -0.00252343f, 0.05409092f, -0.03125896f, 
    0.01643651f, 0.05378631f, 0.07476813f, -0.12933616f, -0.07727679f, -0.32556647f, 0.04526748f, 0.22377162f, 
    0.02247566f, -0.01547003f, 0.08648475f, 0.17106871f, 0.05124743f, 0.07812235f, -0.00921277f, 0.05531654f, 
    0.09045934f, -0.01621597f, 0.06499501f, -0.00058482f, -0.04404012f, -0.01803989f, 0.08115207f, -0.03048300f, 
    -0.03678440f, 0.03680778f, -0.04103269f, 0.01380823f, 0.14516164f, -0.13803776f, -0.05251286f, 0.02042652f, 
    0.07527287f, -0.01384469f, -0.11805688f, 0.07252591f, -0.00496415f, -0.05796656f, -0.08114730f, 0.06256516f, 
    0.07760949f, -0.13317880f, 0.02339890f, 0.01340687f, 0.13417897f, -0.02592313f, -0.01305286f, 0.02361774f, 
    -0.12826946f, 0.03045253f, -0.05583160f, -0.02737321f, -0.26666850f, -0.06477622f, -0.00403590f, -0.21710519f, 
    0.08185624f, 0.03864099f, -0.06662869f, 0.03885569f, 0.12721619f, 0.09733929f, -0.09322003f, -0.03140787f, 
    -0.06710903f, -0.12667391f, 0.12735273f, -0.05595137f, 0.00525637f, 0.08962517f, 0.01812860f, 0.07991184f, 
    0.01718323f, 0.06184946f, -0.00195685f, 0.05739347f, -0.28198135f, 0.00990954f, 0.04149606f, 0.14715713f, 
    0.00658394f, -0.01088774f, -0.08618706f, 0.07336535f, 0.03793829f, 0.11201829f, -0.03962481f, 0.12564518f, 
    -0.55470645f, -0.21401098f, 0.11386392f, 0.03864696f, 0.17935351f, -0.07263491f, 0.01879363f, -0.15308434f, 
    0.06603530f, -0.09780215f, -0.02712521f, 0.13622779f, 0.02408911f, -0.01300992f, -0.05810639f, -0.12626205f, 
    0.07834312f, -0.04345787f, -0.11418560f, 0.01111169f, -0.02891640f, -0.00827327f, -0.11479274f, -0.04982778f, 
    -0.17300963f, -0.06701881f, -0.06148298f, 0.14984265f, 0.07666928f, 0.08703880f, -0.08069767f, 0.03529569f, 
    0.12939358f, -0.02064964f, 0.02541565f, 0.05487488f, -0.01515952f, -0.09209689f, 0.09074622f, 0.07443845f, 
    0.13611144f, -0.00858677f, -0.03196884f, -0.03142186f, -0.00470972f, 0.02256480f, -0.13265789f, -0.00125337f, 
    -0.00135494f, -0.08863568f, -0.03992862f, 0.01254528f, -0.04029363f, -0.01942974f, 0.02378417f, 0.03232186f, 
    -0.11805066f, 0.01050290f, 0.01853843f, -0.17341287f, 0.37625554f, 0.05464983f, -0.02225480f, 0.05229671f, 
    -0.01410636f, 0.00224350f, 0.02368577f, -0.00019432f, -0.06853435f, -0.17072915f, -0.03435000f, 0.11724839f, 
    0.45918956f, 0.05036069f, -0.20248781f, 0.03843858f, 0.05131761f, -0.05893124f, -0.03176152f, -0.02545773f, 
    0.00640233f, -0.06618312f, -0.11919612f, 0.02146991f, 0.24155839f, 0.07607549f, -0.09856898f, -0.11285616f, 
    -0.01702630f, -0.01162675f, -0.00607905f, 0.09698999f, 0.12760593f, 0.02633783f, -0.07353521f, 0.05971837f, 
    -0.14392607f, 0.18644118f, -0.26333135f, -0.09229139f, 0.07848255f, -0.07235771f, 0.07563520f, 0.00242949f, 
    0.02262861f, 0.03276861f, 0.15187794f, -0.07613516f, -0.43788540f, -0.06308557f, -0.07049353f, -0.02957349f, 
    0.09084401f, -0.06176990f, 0.02631205f, 0.00017129f, 0.05702340f, 0.04812991f, -0.04323466f, 0.06744289f, 
    0.25740299f, -0.21852866f, -0.21692976f, 0.11089738f, -0.00838325f, 0.01444507f, 0.02442885f, -0.02550026f, 
    -0.11791147f, -0.01181300f, -0.08067933f, -0.02981118f, 0.41699705f, 0.05040797f, -0.24186596f, 0.08824215f, 
    -0.05225820f, -0.01842361f, -0.00455502f, 0.08937846f, 0.05634752f, 0.07624307f, 0.10522996f, -0.04582356f, 
    -0.18274979f, -0.04258995f, 0.00226209f, -0.01918432f, 0.10817365f, 0.03137391f, 0.06855592f, 0.08479709f, 
    -0.00731457f, 0.08343153f, -0.00426740f, -0.04123648f, 0.19892947f, -0.16457756f, -0.07899912f, 0.04453261f, 
    -0.01517058f, -0.02124521f, 0.02368004f, -0.13139080f, 0.08264355f, 0.03372240f, 0.03259985f, -0.00580794f, 
    -0.04839729f, -0.24592529f, -0.07236516f, -0.05891782f, 0.07806569f, -0.04779079f, 0.00177180f, -0.06495691f, 
    0.06424547f, 0.04522396f, -0.09436677f, -0.05630995f, -0.14347671f, -0.07264357f, 0.11097015f, -0.06610382f, 
    -0.00006334f, 0.07526507f, -0.09007583f, 0.05737723f, -0.06230778f, -0.05546978f, -0.02670765f, 0.02730029f, 
    0.40508130f, 0.12666367f, -0.03298800f, -0.10457308f, 0.03562798f, -0.13691032f, -0.12297396f, 0.01856675f, 
    0.12548795f, 0.02689266f, 0.04629620f, 0.01104632f, 0.02430475f, -0.03594373f, -0.07984875f, -0.00133411f, 
    -0.13445097f, -0.05846478f, -0.10474884f, -0.03488174f, -0.08541996f, -0.20310606f, -0.08139990f, -0.12392413f, 
    0.29112324f, 0.07218140f, -0.01152154f, 0.02098937f, 0.01927783f, 0.12069350f, -0.01744036f, 0.08898007f, 
    0.07038680f, 0.04351868f, 0.06078647f, -0.07862823f, -0.10134008f, -0.00969857f, -0.01196308f, 0.09360395f, 
    0.06266496f, 0.03116609f, -0.06213381f, -0.03179469f, 0.11582610f, -0.08694576f, 0.04405704f, 0.07771163f, 
    -0.10756686f, -0.16847722f, -0.13313329f, -0.06491964f, 0.01026376f, 0.09748591f, 0.03789843f, -0.03482089f, 
    -0.02301712f, -0.09010980f, -0.06247847f, 0.00202190f, 0.29116282f, -0.04463580f, -0.13779183f, -0.10619731f, 
    0.06426313f, 0.01226520f, -0.02494152f, -0.09582974f, 0.20162632f, 0.14761157f, 0.10774720f, -0.02014583f, 
    -0.05560116f, -0.09480860f, -0.01378413f, 0.16058655f, -0.02156176f, 0.02925666f, -0.04143991f, -0.08114810f, 
    -0.00903420f, -0.03104481f, 0.08944477f, 0.03504631f, -0.16313758f, -0.07889006f, -0.05886155f, 0.01890174f, 
    -0.26366082f, 0.16405116f, 0.00291752f, 0.07283191f, -0.05036240f, 0.05435498f, -0.09120144f, -0.11540397f, 
    0.06393485f, -0.12622605f, 0.07204793f, 0.00136103f, 0.05445012f, 0.01110797f, 0.03239480f, 0.06021509f, 
    -0.08642600f, -0.05041280f, -0.10160474f, -0.05103964f, -0.16514783f, 0.08462887f, -0.10627260f, 0.04852565f, 
    0.00305998f, -0.08633038f, -0.01937136f, -0.04321369f, -0.05993295f, -0.02929562f, 0.09354566f, 0.00523989f, 
    -0.50299406f, 0.22836958f, -0.12528172f, 0.06088698f, -0.04784296f, -0.15507506f, 0.05283832f, 0.13366868f, 
    -0.03500469f, 0.00227024f, 0.07714532f, 0.06202377f, 0.28513575f, -0.18045124f, -0.18508364f, -0.31107223f, 
    0.01196933f, -0.00742573f, 0.03695484f, 0.06460509f, -0.14257914f, 0.02151511f, -0.11105087f, 0.00790671f, 
    0.00137552f, -0.23398864f, -0.14735496f, 0.00991631f, 0.07637262f, 0.00207686f, -0.03384154f, 0.00294849f, 
    -0.00048173f, 0.05138971f, -0.04893411f, -0.08580172f, 0.14011799f, 0.01344398f, -0.12617777f, -0.18113564f, 
    -0.02160268f, 0.02190409f, -0.05190552f, 0.09215891f, -0.01992788f, 0.00324504f, -0.00075647f, 0.01050049f, 
    0.01085870f, -0.37803277f, -0.00319067f, -0.19512542f, 0.04415725f, 0.04677758f, -0.00019223f, -0.13717563f, 
    0.04197778f, 0.06058004f, -0.07600010f, 0.04807622f, -0.13860068f, 0.04806646f, -0.06161243f, 0.01912755f, 
    -0.09613192f, 0.03332935f, -0.03335913f, -0.00874449f, 0.04219442f, -0.02235349f, -0.07716672f, -0.00409031f, 
    -0.07661337f, 0.08673843f, 0.10483041f, 0.20032933f, -0.15701517f, -0.06048147f, 0.06208706f, -0.00908830f, 
    -0.00030631f, -0.15205443f, -0.07072382f, -0.06844822f, -0.24978800f, 0.12030686f, 0.04897209f, 0.01028514f, 
    -0.16909982f, 0.00724414f, 0.00414130f, -0.07115171f, 0.03543796f, -0.03445446f, 0.04699865f, 0.00534176f, 
    0.22109194f, -0.09260933f, 0.12582746f, 0.11951299f, -0.05210060f, -0.09009881f, -0.02625420f, -0.01531440f, 
    -0.04103323f, -0.00563736f, 0.06606548f, -0.01369639f, -0.28839490f, -0.16298532f, 0.03967998f, -0.27315229f, 
    -0.08350378f, 0.09147514f, 0.00458745f, -0.05790607f, -0.08202875f, -0.02154668f, -0.02743828f, -0.01292161f, 
    -0.04083929f, 0.15958799f, -0.08039906f, 0.22877252f, 0.13091041f, -0.00615961f, -0.02548284f, -0.06844811f, 
    0.06331840f, -0.03757552f, 0.05653426f, 0.05757401f, 0.04143888f, 0.01813823f, -0.07966941f, 0.17088841f, 
    -0.22483724f, 0.09720860f, 0.06760420f, -0.03248291f, 0.10476331f, -0.06893689f, -0.00366443f, 0.01689314f, 
    0.12106519f, -0.12618497f, 0.08711953f, 0.30605716f, -0.09377849f, 0.08006584f, 0.01817833f, 0.01902542f, 
    0.01025421f, -0.00483261f, -0.02527354f, 0.05530262f, 0.11099169f, -0.06809883f, -0.02297593f, -0.12675267f, 
    -0.04533132f, -0.00043770f, 0.00654256f, -0.06002216f, -0.03456535f, -0.05162121f, -0.16868211f, -0.06067722f, 
    -0.03627473f, -0.03621097f, -0.07810704f, 0.03848703f, 0.05054642f, -0.06652521f, 0.08598007f, 0.14288804f, 
    -0.01411382f, -0.01848665f, -0.10710120f, -0.05085764f, 0.27683994f, -0.05781705f, -0.14990847f, 0.00544223f, 
    -0.10653345f, -0.06967988f, -0.08068277f, -0.01526072f, 0.07766636f, -0.03904641f, 0.00048137f, -0.06915300f, 
    0.03664706f, 0.10384711f, 0.03887108f, -0.17041068f, 0.12518564f, -0.13138026f, -0.13026123f, 0.09503176f, 
    -0.04247184f, -0.05962991f, 0.10143629f, -0.03241082f, 0.00794064f, -0.06338928f, -0.13198863f, 0.26432711f, 
    0.00176712f, -0.02763666f, 0.00878697f, 0.04138229f, -0.04941311f, -0.06187436f, -0.05452606f, -0.06034723f, 
    -0.13491133f, 0.16646984f, 0.06912389f, -0.07696343f, -0.04530356f, 0.01186991f, -0.12755741f, -0.09223931f, 
    -0.01794166f, 0.02391396f, 0.06179005f, -0.12238290f, 0.08197972f, 0.04368317f, 0.03648806f, -0.06068423f, 
    0.01701145f, -0.04961945f, 0.08814932f, 0.04474671f, 0.02882305f, -0.10200231f, -0.03318147f, -0.09314331f, 
    -0.12497021f, 0.13046293f, 0.05671018f, 0.03576156f, -0.20996153f, -0.02643820f, -0.09519212f, -0.02981700f, 
    -0.01677233f, -0.01792562f, -0.05929880f, -0.08348183f, -0.13511401f, -0.15412077f, 0.08731485f, -0.02745665f, 
    -0.02688126f, -0.00506080f, -0.06858557f, 0.09456169f, -0.07653239f, 0.11340525f, -0.04063381f, -0.11088543f, 
    -0.01831786f, -0.13795219f, 0.07602875f, -0.01963216f, 0.17171074f, -0.09432904f, -0.09981567f, 0.00653636f, 
    -0.05703917f, -0.00196164f, 0.10107267f, 0.05407796f, 0.17591275f, -0.14665116f, -0.00996581f, 0.04996982f, 
    0.01863808f, -0.08211833f, 0.00652549f, -0.01874351f, -0.03252602f, 0.00151413f, -0.04478553f, -0.06370801f, 
    0.48595861f, -0.11745458f, -0.17587855f, 0.02347575f, 0.14421681f, -0.05613337f, -0.01442571f, -0.05757486f, 
    0.05000244f, 0.03088687f, -0.02733370f, 0.02681850f, 0.06928892f, 0.20609596f, -0.18817475f, 0.09127444f, 
    0.06137249f, -0.07058414f, 0.12722380f, 0.10846497f, -0.07237429f, 0.03793496f, -0.03654509f, 0.04134657f, 
    0.00467934f, -0.08439925f, 0.05172089f, 0.18208110f, -0.04435806f, 0.11453675f, 0.08107235f, -0.02294344f, 
    0.02869674f, 0.06812596f, 0.03476585f, 0.22874853f, -0.09704459f, -0.36506060f, 0.07899601f, 0.05766924f, 
    -0.05322063f, 0.12383124f, 0.01616818f, 0.11013389f, 0.00082434f, -0.06637186f, 0.09553118f, -0.10791833f, 
    -0.33062458f, -0.05022050f, -0.03631591f, -0.14648032f, -0.06962990f, 0.11002136f, 0.06575978f, 0.12194643f, 
    -0.06331357f, 0.07596666f, 0.00778939f, -0.17492263f, 0.03538622f, 0.10680135f, -0.03665231f, -0.01324782f, 
    -0.00088996f, 0.01796423f, -0.04224141f, -0.11037997f, 0.05807371f, -0.03539894f, -0.09314784f, -0.04420742f, 
    0.02349691f, 0.12200303f, -0.03908246f, 0.02267584f, 0.03034752f, 0.01437845f, -0.08249648f, -0.00478206f, 
    0.09698067f, -0.00482769f, -0.04301288f, -0.00695791f, -0.00552612f, 0.13336290f, 0.03405425f, -0.06708515f, 
    0.10117041f, -0.04005053f, 0.06385335f, 0.00941260f, 0.08941649f, -0.03116405f, 0.06810134f, -0.01479862f, 
    0.01186055f, 0.10424826f, 0.10193412f, -0.08674376f, -0.12944439f, 0.07089771f, -0.02443926f, -0.07228941f, 
    0.02427323f, -0.01126106f, 0.09588342f, 0.03479663f, -0.11193468f, 0.09829012f, -0.01971737f, -0.00827984f, 
    -0.01731895f, -0.06295530f, 0.12094284f, -0.02124387f, 0.03649025f, -0.00645272f, 0.00210717f, -0.12326881f, 
    0.00847037f, 0.08121451f, 0.01929950f, 0.04477571f, 0.00178124f, -0.10087007f, 0.03385895f, -0.01545383f, 
    0.00748787f, 0.00102802f, -0.08002584f, 0.08143818f, -0.37507865f, -0.11311810f, 0.03417417f, 0.01775244f, 
    -0.02333965f, 0.12370921f, -0.06100366f, 0.14106710f, -0.06648363f, -0.07624111f, -0.06870441f, 0.12763414f, 
    -0.23930497f, -0.06477844f, -0.05542202f, 0.09749687f, -0.04148951f, 0.02563927f, 0.03771425f, 0.09897614f, 
    -0.08561666f, -0.02107498f, -0.15209050f, -0.13778323f, 0.13901308f, 0.01054304f, 0.00532262f, 0.00571641f, 
    0.01026496f, -0.01578683f, 0.02809518f, 0.03100244f, 0.01665179f, 0.01999090f, 0.03162051f, 0.00882789f, 
    0.18042071f, 0.05399114f, -0.09563830f, -0.23598751f, 0.03434256f, 0.07027934f, -0.12241767f, 0.06084235f, 
    0.04237741f, -0.01036174f, 0.06523653f, -0.03895643f, -0.14678268f, 0.08311807f, -0.31657234f, -0.27730718f, 
    0.07471389f, -0.00753558f, 0.03553944f, 0.08142130f, 0.03261637f, -0.03490754f, 0.09807528f, 0.11477390f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02547294f, 0.01716244f, -0.05784067f, -0.00338029f, -0.02205656f, -0.01941647f, -0.00779294f, -0.04961789f, 
    -0.02171215f, 0.04001655f, 0.04028033f, 0.04738471f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
