#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.47993621f, -0.36320299f, 0.69512844f, -0.49932280f, -0.14967522f, 0.51547730f, 0.23885792f, -0.45013848f, 
    -0.34290007f, 0.71067387f, 0.04417837f, 0.26140794f, 0.07215960f, -0.56493682f, 0.63992935f, -0.41704857f, 
    -0.01764412f, -0.38909534f, -0.23354091f, -0.40528175f, 0.59151351f, 0.43514186f, 0.33849224f, 0.14368770f, 
    -0.05780575f, 2.17917275f, -1.07383490f, -0.87860262f, -0.41599056f, -1.08567595f, 1.04393208f, 0.22471853f, 
    0.30416539f, 0.18219185f, 0.06243951f, 0.10337858f, -0.02870626f, -0.22155271f, -0.19307235f, 0.31811816f, 
    -0.09782940f, -0.26163000f, 0.13838112f, 0.13777718f, -0.12430301f, -0.06672519f, -0.18885171f, -0.02401890f, 
    0.22506179f, 0.05560612f, -1.03584695f, -1.21288371f, -0.26315278f, 0.59243864f, 0.35302532f, 0.67122650f, 
    1.17402589f, 0.10707994f, -0.47401950f, -0.38663170f, -0.12091906f, 0.38420945f, 0.00148678f, -0.41813573f, 
    -0.41760641f, -0.23701896f, -0.06724031f, -0.35364437f, 0.14009988f, 0.38519686f, 0.35832593f, -0.35548320f, 
    -0.23486334f, 0.37595493f, -0.14056037f, -0.87780941f, 0.00811942f, 0.53154713f, 1.16698444f, 0.76983368f, 
    0.21106690f, -0.35366100f, -0.38152236f, 0.06407094f, 0.19655620f, -0.11343934f, -0.10031310f, -0.38342261f, 
    0.41479042f, 0.58126390f, -0.46308702f, -0.08223029f, 0.14651626f, -0.15150966f, -0.32752553f, 0.06204095f, 
    0.07088646f, 0.08547004f, 0.12136133f, -0.46362785f, -1.36105812f, 0.59157008f, 0.21378259f, -0.60326105f, 
    0.07499807f, -0.85462034f, -1.08758521f, -0.52236962f, -0.78017050f, -0.72618788f, 0.38808435f, -0.37308472f, 
    -0.49588269f, -0.65257251f, -0.36848187f, -0.42018887f, -0.54702997f, -0.44045308f, -0.25990111f, -0.47856691f, 
    -0.07264613f, 0.08937038f, -0.05448646f, -0.26293397f, -0.26405734f, 0.78309071f, 0.90551323f, -0.57594526f, 
    0.31479695f, -0.50223511f, 0.13031754f, 0.66911364f, -0.32745278f, -0.45313451f, 0.14205390f, 0.00232084f, 
    -0.49990225f, -0.29234672f, -0.42110515f, 0.21789639f, -0.00703639f, 0.09263042f, 0.16958153f, 0.01421913f, 
    -0.37244019f, -0.51265138f, -0.28687805f, -0.57146031f, -0.81480896f, -0.87563455f, -1.56186974f, -0.36073568f, 
    0.56226474f, 0.57911015f, 0.01605421f, 0.26009372f, 0.14411600f, 0.29465061f, 0.57412392f, 0.19861813f, 
    -0.50223786f, -0.54088587f, 0.02851243f, 0.07993338f, 0.01920076f, 0.36773270f, -0.00781354f, -0.42137378f, 
    -0.23835124f, -0.20262532f, -0.33394775f, -0.43943748f, 0.10005952f, -0.29535404f, -0.67448866f, 0.93761182f, 
    1.12338889f, -0.11239603f, 0.78131872f, -0.50650436f, -0.49033320f, -0.29552665f, -0.36141726f, 0.17159438f, 
    -0.11415584f, -0.11587881f, 0.13426499f, -0.14526381f, 0.21683653f, -0.28177351f, -0.13065442f, -0.10662190f, 
    0.20716949f, 0.12112429f, -0.05558874f, 0.36153713f, -0.26736727f, -0.07948865f, 0.06679501f, -0.22818682f, 
    0.10091637f, -0.13637465f, 0.36492193f, 0.29429448f, 0.37878397f, 0.25082687f, 0.51153588f, 0.52444458f, 
    -0.21365915f, 0.13330664f, -0.21689469f, 0.33919013f, 0.22446470f, -0.56976706f, -0.17005168f, 0.23654413f, 
    0.54527205f, -0.04296040f, 0.06902749f, -0.13662845f, -0.09642620f, -0.10518698f, -0.16944931f, -0.17833640f, 
    -0.09964352f, -0.60554177f, -1.02923489f, -1.16842091f, -1.11428118f, -0.89154887f, 0.23030360f, 0.51734310f, 
    0.65742260f, 0.52442235f, 0.51114285f, 0.08964101f, 0.12390141f, -0.14229979f, 0.04200647f, -0.06897916f, 
    -0.22720604f, 0.19851428f, -0.33202881f, 0.02692923f, -0.18514256f, -0.22313200f, -0.47272754f, -0.44247133f, 
    -0.48438901f, -0.31893098f, 0.12141668f, 0.14944595f, 0.36592031f, 0.80143756f, 0.31803226f, 0.40848657f, 
    0.77741134f, -0.31983322f, -0.53755176f, 0.02422051f, -0.07577360f, 0.48874205f, 0.33513919f, -0.25314140f, 
    -0.25339785f, 0.04510413f, -0.05727191f, 0.04849295f, -0.07100108f, -0.04575983f, 0.11499931f, 0.00820486f, 
    -0.27732641f, -0.12834047f, 0.36995223f, -0.99064142f, -0.81476992f, -0.90043014f, -0.60777831f, -0.24013245f, 
    -0.60874474f, -0.78507251f, -0.25858861f, -0.49566862f, -0.99901056f, -0.17350160f, -0.09405817f, 0.21961012f, 
    0.75883853f, -0.10575884f, 0.26034343f, -0.01698976f, 0.20989567f, 0.31004754f, 0.61443830f, 0.12814532f, 
    0.28878191f, -0.43986535f, -0.36881512f, 0.14493826f, 1.14375091f, 0.75354159f, 0.18293990f, -0.13388462f, 
    0.41144308f, -0.82639474f, -0.26758695f, -0.70596820f, -0.43349740f, -0.19021332f, 0.18399274f, 0.27007636f, 
    0.40763131f, 0.30439496f, -0.02686417f, 0.35135597f, 0.07250383f, 0.55437303f, -0.05217353f, -0.57851255f, 
    0.10337982f, 0.03396437f, 0.01794090f, 0.23770411f, -0.15468878f, -0.86693197f, -1.27823114f, -0.17744572f, 
    1.13615036f, 0.39082417f, 0.68962830f, -1.40008175f, -0.72413307f, 0.70074844f, -0.16040145f, -0.12575774f, 
    -0.14130495f, -0.49795815f, 0.66637349f, -0.35552096f, 0.02330129f, 0.09933069f, 0.01723480f, -0.15933356f, 
    -0.09072237f, 0.15847844f, -0.03596133f, -0.17523453f, -0.30015478f, 0.59634888f, -1.17728865f, -1.15888214f, 
    -1.17854154f, -0.50530177f, -0.66806668f, -0.36199182f, -0.14953418f, -0.19554096f, -0.23050851f, -0.74361360f, 
    0.27560371f, -0.57508391f, -0.34023702f, 0.23612742f, 0.07705778f, -0.24966218f, -0.15079604f, -0.23564920f, 
    -0.17533419f, -0.62054098f, -0.22393602f, 0.29432604f, 0.44052985f, 0.31059924f, 0.50855225f, -1.26693642f, 
    -0.11403909f, 0.17914748f, 0.28394225f, 0.13955374f, -0.20063111f, 0.49606791f, -0.65430713f, -0.00819397f, 
    0.96801943f, -0.19296536f, -0.36224660f, -0.30724522f, 0.12178596f, 0.11144024f, 0.09861473f, 0.41398036f, 
    0.12941770f, 0.06151983f, 0.01217318f, 0.04518133f, 0.24398322f, -0.00076564f, -0.03333103f, -0.10449102f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.35377991f, 0.62227762f, 0.53083837f, 1.02738285f, 0.14824025f, 0.12916714f, 0.09507375f, 0.70691788f, 
    0.08370564f, 0.41444728f, 0.49836147f, 0.20606323f, 0.34929428f, 0.70624787f, -0.41275167f, 0.62717181f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.19876096f, -0.08390584f, -0.19311756f, -0.18815084f, -0.00979498f, 0.11389394f, 0.10126209f, -0.14606228f, 
    -0.14787216f, -0.21345426f, -0.36406580f, -0.23653904f, -0.43043527f, -0.71490484f, -1.29033446f, 0.11931010f, 
    0.02103314f, -0.07968911f, -0.09405164f, -0.00578978f, -0.06992358f, -0.13274723f, -0.30583596f, -0.03813373f, 
    0.80456460f, -0.07579210f, -0.53564978f, -0.29047072f, -0.01479189f, -0.20060295f, 0.19688100f, -0.38355854f, 
    -0.19434337f, -0.18894026f, -0.06027731f, -0.12415914f, -0.92284971f, -0.21979323f, 0.06742245f, -0.46081433f, 
    -0.02609854f, -0.02941612f, 0.09572262f, 0.02126056f, -0.03264366f, -0.03817146f, 0.01190997f, -0.02168052f, 
    0.23780073f, 0.52912170f, -0.11314781f, -0.18327597f, -0.24788892f, 0.21991280f, -0.12440488f, 0.12625384f, 
    -0.23527919f, -0.17728996f, -0.18482381f, -0.09044486f, -0.30471629f, -0.25662920f, -0.10504988f, 0.18531296f, 
    -0.01141234f, 0.01389638f, -0.12035455f, -0.08408446f, -0.27672672f, 0.02678489f, -0.04219344f, 0.41904405f, 
    0.05114751f, -0.42739671f, 0.34698772f, -0.20217632f, 0.06865502f, 0.05897309f, 0.08063599f, 0.14070231f, 
    0.02076221f, 0.05966614f, 0.06187324f, 0.27613133f, -0.44802186f, -0.34799930f, -0.18063103f, -0.15133940f, 
    0.05874792f, 0.12018494f, -0.05120606f, -0.05088544f, -0.10481633f, 0.01635518f, -0.10538887f, 0.03572305f, 
    -0.02936782f, 0.04531249f, 0.06086521f, 0.06830952f, 0.04118453f, 0.03164016f, 0.11344545f, -0.01033461f, 
    -0.13508056f, -0.18834586f, -0.04609095f, -0.02321662f, 0.28176069f, 0.06447665f, -0.07385651f, -0.02098675f, 
    0.30481687f, 0.26112983f, 0.00527886f, -0.05992144f, 0.08090769f, 0.15532014f, 0.01406814f, 0.07169411f, 
    -0.06315999f, 0.01735409f, 0.03233148f, 0.12927926f, -0.00228575f, -0.05848906f, 0.03788563f, 0.02630423f, 
    -0.11703566f, -0.14734374f, 0.09967995f, -0.02402361f, 0.69962853f, 0.29493088f, 0.00168450f, -0.28694662f, 
    0.14800914f, 0.18639950f, -0.01288482f, 0.08221902f, -0.03970803f, 0.05511090f, 0.10394225f, 0.01625901f, 
    -0.00778182f, 0.11101645f, -0.19793639f, -0.06401190f, 0.15149820f, 0.27058977f, -0.12172157f, -0.16944450f, 
    0.00481535f, 0.00934198f, 0.03681478f, -0.03052295f, 0.50780785f, 0.36874363f, 0.02690008f, -0.87602103f, 
    -0.19607747f, -0.18246001f, 0.13226670f, 0.03241108f, -0.07654855f, -0.03561100f, -0.09869164f, -0.27227372f, 
    0.55642503f, 0.28044510f, 0.02190691f, -0.35239607f, 0.16084388f, 0.18883839f, -0.03806266f, -0.17798577f, 
    -0.05992118f, -0.02352623f, -0.01846377f, 0.01028034f, 0.31799820f, 0.02083455f, 0.12541687f, -0.24899714f, 
    -0.05913229f, -0.14036113f, -0.26221502f, -0.12137774f, 0.05062515f, 0.11123801f, -0.15589195f, 0.04504186f, 
    0.05374170f, -0.01458254f, 0.05439099f, -0.08232550f, -0.08327422f, -0.16597106f, -0.08056684f, 0.32116234f, 
    -0.04206020f, -0.07317856f, 0.03963911f, 0.04736783f, 1.40981591f, 0.01503581f, -0.32635215f, -0.09972677f, 
    -0.06353793f, 0.00061146f, 0.07942856f, -0.09496412f, 0.11869074f, 0.12423495f, 0.07536287f, -0.16413487f, 
    0.21087539f, -0.61776012f, 0.12698013f, 0.13159351f, 0.04504081f, -0.15463030f, 0.28494468f, -0.26714021f, 
    0.28054836f, 0.01829550f, 0.14959511f, 0.12380785f, 0.06922843f, 0.20152539f, -0.01176403f, 0.20070110f, 
    -0.13145882f, -0.13310370f, 0.00114751f, 0.04783870f, 0.00083771f, 0.01249316f, 0.07957352f, -0.20971368f, 
    -0.15939510f, -0.19516018f, -0.38207725f, -0.19898558f, 0.19321981f, 0.03039823f, -0.24991496f, 0.06633335f, 
    0.10199111f, 0.09029742f, -0.11502084f, 0.05279581f, 0.00483457f, -0.02688189f, 0.18402182f, -0.03810320f, 
    0.00218482f, 0.01076455f, -0.17168219f, -0.03609600f, -0.27205166f, -0.36637607f, 0.03859373f, 0.12047852f, 
    -0.28106916f, -0.11340585f, 0.04604489f, 0.13087846f, -0.00347378f, -0.06870872f, -0.00446408f, -0.05079654f, 
    -0.53755206f, 0.02683498f, -0.40729830f, -0.50738287f, 0.06532710f, 0.24909122f, 0.25723013f, -0.07118510f, 
    -0.06917570f, -0.17361587f, -0.17836608f, -0.04249067f, -0.06568640f, -0.13942149f, 0.11598212f, -0.00084973f, 
    0.08986950f, -0.00558074f, 0.20914248f, 0.13498560f, -0.08435375f, -0.09170932f, 0.03988725f, -0.07453450f, 
    0.56983042f, -0.07906328f, -0.00168731f, 0.13895760f, 0.06438245f, -0.11690556f, -0.22195128f, -0.11903450f, 
    0.09453812f, 0.18970928f, -0.06309034f, -0.36136237f, 0.01464399f, -0.09853780f, -0.14103596f, -0.20448853f, 
    0.25917760f, 0.06751613f, 0.11808817f, 0.11837381f, -0.01615543f, -0.00657327f, -0.13976277f, -0.16758169f, 
    0.06130479f, -0.09926869f, -0.01881856f, 0.12265673f, -0.24074438f, 0.19942699f, 0.34820381f, 0.08076982f, 
    -0.16468419f, -0.01806803f, 0.14965402f, -0.10394611f, -0.04775093f, -0.10613337f, 0.05833169f, -0.08577353f, 
    0.08338489f, 0.01858058f, -0.06002081f, -0.17980285f, -0.09764521f, -0.13116966f, -0.04091391f, -0.05174381f, 
    -0.06551866f, -0.02900275f, 0.04312354f, 0.06201632f, -0.61757576f, 0.10920633f, -0.68138254f, -0.32689226f, 
    0.05302496f, -0.15787761f, 0.19402510f, 0.09442274f, 0.16096622f, -0.18797423f, 0.11040870f, 0.14600323f, 
    0.15568101f, 0.52774310f, 0.51721382f, -0.08778865f, 0.05156356f, 0.13152176f, 0.33046314f, -0.01109685f, 
    -0.05820709f, -0.01798810f, 0.05185958f, -0.11670845f, -0.11329993f, 0.12126565f, -0.07055295f, -0.06964299f, 
    0.02104245f, 0.20922741f, -0.09331656f, -0.15460944f, 0.05355093f, -0.03570136f, 0.00722139f, -0.14988577f, 
    0.53720111f, -0.58447701f, 0.07385506f, 0.08555015f, 0.17495757f, -0.09690759f, -0.03501696f, 0.07878878f, 
    -0.09536605f, -0.00526175f, -0.35033649f, -0.02718263f, -1.07690227f, 0.84320819f, 0.51186001f, -0.28936949f, 
    -0.00647802f, -0.05616532f, -0.07195191f, -0.30898747f, 0.08059327f, 0.13988703f, 0.06717649f, 0.09896711f, 
    0.33357766f, -0.12645932f, 0.39880526f, 0.12082516f, 0.10148523f, -0.17823546f, 0.18741751f, 0.24875279f, 
    0.04367852f, 0.08496024f, 0.00594986f, -0.26219639f, -0.17633322f, 0.53169560f, -0.50624925f, 0.01266298f, 
    0.07454247f, -0.08028905f, 0.00891551f, 0.12178455f, -0.01661443f, -0.02794041f, -0.00151806f, -0.01154874f, 
    -0.25687104f, 0.02636466f, -0.28400171f, -0.33019653f, 0.16471489f, -0.08120996f, -0.08272578f, -0.02741619f, 
    -0.07836680f, -0.07373288f, -0.01666584f, 0.07101394f, -0.08697259f, -0.21623380f, 0.12512922f, -0.43760487f, 
    0.07502767f, -0.05760469f, -0.17695764f, -0.07318316f, 0.18682288f, 0.36721227f, 0.08450175f, -0.02415645f, 
    0.22548756f, -0.12847956f, -0.10823104f, 0.16873004f, -0.01417182f, -0.04028680f, 0.04987627f, -0.00166561f, 
    0.05636758f, 0.06780656f, 0.12426034f, 0.03446304f, -0.53937888f, -0.09238380f, 0.24296756f, -0.37134704f, 
    -0.03182808f, 0.03249682f, -0.00582240f, 0.21124616f, -0.03104850f, -0.04581050f, 0.06460857f, -0.03113783f, 
    0.00419968f, -0.03601632f, -0.11212574f, 0.01699657f, -0.05313489f, 0.00131587f, 0.00933755f, 0.07335720f, 
    0.13482055f, -0.14367476f, 0.06232887f, -0.00487881f, 0.08706299f, 0.55824327f, 0.48555541f, 0.29497489f, 
    -0.06709956f, -0.05231700f, 0.16662623f, -0.10931704f, -0.14027339f, 0.01377087f, -0.16312835f, -0.00079287f, 
    -0.12535235f, 0.20409954f, -0.16676997f, -0.08532607f, -0.00028523f, -0.09491097f, 0.05108959f, 0.27199408f, 
    -0.06249479f, -0.01654785f, 0.10480919f, -0.09439959f, -0.52796185f, -0.38076818f, 0.01476058f, 0.01757823f, 
    -0.05251202f, -0.18220346f, -0.14218883f, 0.22727410f, 0.05661646f, 0.07148393f, 0.05629092f, -0.09796066f, 
    -0.52044946f, -0.44088778f, 0.25070986f, -0.02494439f, -0.31658998f, -0.35649228f, -0.35680687f, -0.11824013f, 
    0.05355839f, -0.13477993f, 0.14876370f, -0.08143485f, -0.23961471f, 0.18870282f, -0.39241305f, 0.19572978f, 
    0.08573057f, -0.26948404f, -0.18311468f, 0.55069339f, -0.06651969f, -0.03239696f, -0.02006819f, 0.11601348f, 
    -0.79840791f, -0.10688158f, 0.35777646f, -0.41630134f, -0.31067663f, 0.01474916f, -0.04063513f, 0.04865666f, 
    -0.08205691f, -0.06746992f, 0.00056834f, -0.05703817f, 0.13306557f, -0.02410816f, 0.21206611f, 0.39241043f, 
    0.13330707f, 0.34854558f, -0.30953339f, 0.11198934f, 0.18035498f, 0.08168798f, -0.20163825f, 0.05226988f, 
    0.13433315f, -0.14922032f, -0.00816525f, 0.18630458f, 0.22014992f, -0.11286143f, -0.10571095f, 0.20682025f, 
    -0.11884464f, 0.03487512f, -0.30393925f, 0.25749123f, -1.58584249f, 0.16935802f, 0.36544392f, 0.22574094f, 
    0.10840668f, -0.02121412f, 0.24939777f, -0.29693115f, -0.07719689f, -0.07359456f, 0.19862998f, 0.06015202f, 
    -0.84639150f, 1.16462433f, -0.37304139f, -0.59134138f, 0.31268239f, 0.03160614f, -0.04551375f, -0.18923110f, 
    -0.40991449f, -0.11945485f, -0.00421283f, -0.09279130f, 0.05039574f, 1.04581046f, -0.23504351f, -0.12221849f, 
    -0.07431198f, -0.09075352f, -0.12279054f, -0.11696617f, -0.07378072f, 0.08813054f, -0.16859265f, 0.11448933f, 
    0.13602579f, -0.26240021f, 0.20461635f, 0.16189109f, -0.03014742f, -0.03274138f, 0.04699530f, 0.16714817f, 
    -0.21464199f, -0.02143758f, -0.17287959f, 0.10739954f, -0.11484437f, 0.17018993f, -0.18031955f, 0.34910324f, 
    -0.31711230f, -0.01831079f, -0.16108659f, 0.15696990f, -0.04178949f, 0.46032637f, 0.00864968f, -0.09997122f, 
    0.46240270f, 0.90190142f, 0.08537474f, -0.57189441f, 0.10937624f, 0.20480056f, 0.03518865f, -0.03277242f, 
    -0.09888131f, -0.05748212f, -0.12059519f, -0.17925148f, -0.55314928f, -0.24325240f, -0.17632766f, -0.10827956f, 
    -0.15775706f, -0.16039084f, -0.43337965f, -0.13232739f, 0.25962541f, 0.10637801f, 0.01631042f, 0.09178971f, 
    -0.03249387f, 0.24470924f, -0.08716555f, -0.41191795f, 0.08261794f, 0.14343585f, 0.31599402f, 0.03400638f, 
    -0.22778480f, 0.19968548f, -0.16906253f, 0.14510185f, 0.04784596f, -0.15501577f, -0.02633389f, 0.36785960f, 
    0.28352946f, 0.16158830f, 0.29437488f, 0.09701866f, -0.04528854f, 0.04995316f, -0.09307771f, 0.17655826f, 
    -0.01582741f, -0.00040887f, -0.38505507f, -0.29457381f, 0.13836910f, -0.84105617f, -0.07456695f, -0.25123253f, 
    -0.16835544f, 0.01512943f, -0.25136063f, 0.06915720f, 0.00734245f, -0.32713330f, -0.10029994f, 0.28008196f, 
    0.15112232f, 0.05289089f, -0.10702070f, -0.06037123f, 0.04232174f, -0.15042824f, -0.03326014f, -0.16732401f, 
    -0.07676164f, 0.02078893f, 0.26973024f, 0.50257003f, -0.30798748f, 0.01214004f, 0.13216121f, 0.13475654f, 
    0.07852690f, 0.19537634f, 0.00558057f, -0.06728543f, -0.35915437f, 0.43515143f, -0.18157333f, -0.32338175f, 
    -0.00720733f, -0.32463092f, -0.20266210f, -0.13714884f, -0.35456687f, 0.10397262f, -0.01282430f, -0.12631412f, 
    0.03024374f, -0.05894843f, 0.08238592f, 0.45444524f, 0.06089124f, 0.07499820f, -0.06984904f, 0.04366009f, 
    -0.00357245f, 0.13264897f, -0.05939082f, -0.02246728f, 0.52491444f, 0.46015784f, -0.26242393f, -0.67662293f, 
    0.26528600f, 0.18159468f, -0.08705890f, -0.18798803f, -0.21246746f, -0.12299262f, -0.13902304f, -0.11974876f, 
    0.16648868f, 0.26384494f, -0.32689658f, 0.24139975f, 0.15820944f, -0.00852144f, 0.06270457f, -0.15830602f, 
    -0.14788061f, -0.22728591f, -0.12779544f, -0.41106668f, -0.20189732f, -0.16934142f, -0.01142715f, -0.03994555f, 
    0.00293101f, 0.06355519f, -0.26030496f, 0.05402285f, -0.12342282f, -0.15437713f, -0.28388852f, 0.22907588f, 
    0.06456874f, -0.38469881f, 0.21467897f, 0.06739081f, -0.30743340f, 0.06053797f, -0.27260742f, -0.20661220f, 
    -0.09855612f, 0.02697822f, -0.48160315f, -0.02695740f, -0.54577595f, -0.67769343f, -0.11296316f, 0.28049821f, 
    0.09231008f, -0.13080724f, -0.04064688f, -0.13230880f, -0.02324259f, -0.13051720f, -0.11522803f, 0.19576788f, 
    0.20016442f, 0.10271253f, 0.17978632f, 0.22560139f, 0.12392438f, -0.06193707f, 0.07108805f, -0.19814897f, 
    -0.10775547f, -0.03902785f, 0.17217733f, 0.12957163f, 0.00685976f, 0.40201828f, -0.19626738f, 0.13226672f, 
    0.09748372f, -0.16883405f, -0.11136344f, -0.27227584f, 0.17536317f, 0.11828610f, 0.12414657f, 0.37691149f, 
    -0.33215889f, -0.62799191f, -0.25957766f, -0.33976632f, -0.06534600f, -0.00277837f, 0.16152214f, -0.02326907f, 
    0.20111272f, 0.12028560f, 0.10935539f, 0.30466813f, -0.06911220f, -0.11740856f, -0.17534786f, 0.39371935f, 
    0.06557742f, 0.02673749f, 0.17805295f, 0.01696753f, 0.01625742f, 0.04473446f, -0.13397540f, -0.02989675f, 
    0.06958751f, -0.03624992f, -0.00204057f, -0.02760199f, 0.14597121f, 0.02803506f, 0.06206204f, 0.02714594f, 
    -0.17238450f, -0.08083087f, -0.16259398f, -0.06208051f, -0.25522622f, 0.25166231f, 0.16051799f, 0.04647981f, 
    -0.14831197f, -0.19065785f, 0.02540418f, -0.01846732f, 0.11079081f, 0.03395281f, 0.01451786f, 0.21397401f, 
    0.08526170f, -0.08349918f, 0.03927308f, -0.01189826f, 0.13164912f, 0.13451013f, 0.10591781f, 0.04548630f, 
    -0.12069856f, 0.05840515f, -0.05302856f, 0.04238047f, 0.08031514f, 0.10592543f, 0.34291634f, 0.23753405f, 
    -0.38265291f, -0.14811787f, -0.23618354f, -0.03048758f, 0.07684204f, 0.07153071f, -0.01746405f, 0.12676020f, 
    0.27208972f, 0.14087762f, 0.22198969f, 0.23431775f, 0.07133132f, 0.11637510f, 0.16533640f, -0.01201698f, 
    0.07366784f, -0.05184422f, -0.11751448f, -0.13221571f, 0.35250986f, -0.49281132f, 0.38464200f, 0.08841940f, 
    -0.28636137f, 0.12948704f, -0.22136794f, -0.09154266f, -0.26035485f, -0.02923393f, -0.31740949f, -0.06643177f, 
    0.24449232f, 0.12193200f, 0.22277613f, 0.20311476f, -0.15604450f, -0.11154710f, 0.09337193f, 0.00951297f, 
    -0.00235378f, 0.02789651f, 0.00358044f, -0.02417229f, -0.12840499f, -0.12173449f, -0.14437456f, 0.09348540f, 
    -0.08012886f, -0.26575923f, 0.33086488f, -0.39118576f, -0.07706619f, 0.11820982f, -0.11576355f, -0.04464136f, 
    -0.22919737f, -0.05552386f, 0.10477256f, -0.02701226f, -0.06568009f, -0.25177303f, -0.12318338f, -0.03588769f, 
    0.31388363f, 0.08969498f, 0.17305437f, 0.02536271f, -0.16372125f, -0.42093056f, -0.38567358f, -0.43800136f, 
    -0.11356992f, 0.15045469f, -0.19807871f, 0.18603681f, 0.24084875f, 0.09754128f, -0.09315605f, -0.30173790f, 
    -0.21185517f, 0.13497722f, -0.47153386f, 0.04075139f, -0.01840091f, 0.23995912f, -0.09906712f, 0.28090480f, 
    0.18240245f, 0.17455173f, -0.02730526f, 0.01905066f, 0.05902143f, -0.47510320f, 0.82510984f, 0.29600611f, 
    -0.01462360f, 0.08631270f, -0.03400362f, -0.02396718f, 0.04561289f, 0.11641694f, -0.03384681f, -0.00616756f, 
    -0.14870578f, 0.47465476f, 0.49523628f, -0.00553572f, -0.05304980f, -0.12914345f, 0.14303015f, 0.00593837f, 
    0.15405180f, -0.07529314f, -0.04249931f, -0.06662826f, 0.26120067f, 0.07179163f, -0.20747970f, -0.35855773f, 
    0.00476702f, -0.03258531f, 0.18424882f, 0.21518251f, -0.04402282f, -0.51536506f, -0.38031659f, -0.65755457f, 
    -0.60914385f, -0.42187446f, -0.01518403f, 0.04222830f, -0.06395224f, -0.00833683f, -0.12686062f, -0.04228108f, 
    0.10169122f, -0.38088769f, -0.32825151f, -0.46075225f, 0.41608045f, -0.28885946f, -0.31462991f, 0.26759666f, 
    0.09355009f, 0.12331862f, 0.10466810f, -0.01538297f, -0.13728471f, 0.16750287f, -0.02298315f, -0.20067622f, 
    -0.01604257f, -0.13748145f, -0.13396409f, 0.08145713f, 0.00327745f, -0.07473263f, -0.24031433f, 0.08443660f, 
    -0.39422041f, -0.09364019f, 0.23659250f, 0.04923995f, -0.12565655f, -0.15621273f, -0.33886352f, -0.32881260f, 
    -0.04608988f, -0.07774651f, -0.09113747f, 0.14594148f, -0.05452209f, -0.13518022f, 0.26513174f, -0.08210842f, 
    -0.15815219f, -0.28290665f, -0.14128095f, -0.04292163f, 0.02411483f, -0.14957643f, -0.14372553f, 0.09617192f, 
    0.21860446f, 0.01807892f, 0.18592975f, -0.02101052f, 0.14093737f, 0.10754722f, -0.07596495f, -0.07644565f, 
    0.40604383f, 0.14444757f, 0.10973870f, 0.04575780f, 0.01145489f, -0.00771289f, -0.02026070f, 0.09025121f, 
    -0.04199738f, -0.08615525f, -0.12193780f, -0.21098143f, 0.19780524f, 0.35289907f, 0.01304764f, 0.11100924f, 
    -0.03702914f, 0.00806796f, 0.04756641f, -0.05065474f, 0.11486535f, -0.20169178f, 0.47199503f, 0.08319294f, 
    0.01218487f, 0.34718946f, 0.00341769f, -0.09524143f, 0.24758466f, -0.04558814f, 0.11720888f, 0.14688286f, 
    -0.28450409f, -0.07023592f, -0.01522796f, -0.00845918f, -0.02556284f, 0.12458289f, 0.06961273f, -0.19595869f, 
    0.14631763f, -0.03052807f, 0.00204325f, 0.14863101f, -0.27042019f, -0.18336567f, 0.27128619f, 0.02479606f, 
    0.01563023f, -0.31841365f, 0.09289011f, 0.46994179f, -0.30740118f, -0.09953448f, -0.01319761f, 0.06090915f, 
    -0.03903997f, -0.29445049f, 0.14151037f, 0.26161689f, -0.00273069f, -0.04911401f, 0.12580043f, 0.00380877f, 
    0.14473638f, -0.17747679f, 0.07786830f, 0.09992462f, 0.32269195f, 0.97534293f, -0.47850606f, 0.36673155f, 
    0.15832889f, -0.05897449f, 0.36826172f, 0.11040716f, 0.12993833f, -0.08695601f, 0.29969567f, 0.18132599f, 
    -0.49030566f, 0.11262789f, 0.57710302f, 0.10237839f, -0.05837149f, -0.12421065f, -0.00769731f, -0.24358557f, 
    -0.15222673f, 0.16597266f, 0.08753724f, 0.03302187f, -0.33657947f, -0.28995633f, -0.29890054f, 0.44850773f, 
    0.07832093f, 0.24511325f, -0.09389272f, 0.11649206f, 0.05776241f, -0.03807797f, 0.01869753f, 0.13149619f, 
    -1.21240509f, -1.49998355f, -0.46486640f, -0.37302849f, -0.11432341f, 0.17660628f, 0.09383021f, -0.31321090f, 
    -0.11155883f, -0.05428639f, 0.21970353f, 0.02524718f, 0.14088044f, -0.28861663f, -0.00901842f, 0.09690126f, 
    0.06298701f, 0.07475314f, 0.24710195f, 0.02271955f, 0.03546515f, 0.30230388f, 0.31764203f, 0.06476920f, 
    -0.03804987f, -0.28504720f, -0.03209408f, -0.08719910f, -0.18291788f, 0.05517285f, -0.07382469f, -0.02609771f, 
    0.10981975f, 0.03430362f, 0.39278737f, 0.40707856f, 0.22963883f, -0.22212592f, -0.04973653f, -0.19020642f, 
    -0.02125628f, 0.14292061f, 0.29598331f, -0.05275731f, -0.05508733f, -0.04852582f, -0.13315395f, -0.06717607f, 
    0.00435022f, 0.01993397f, -0.06774867f, -0.22662923f, 0.04728801f, 0.03489542f, 0.02939125f, 0.18437572f, 
    -0.29622659f, 0.03176426f, -0.16330755f, -0.32320622f, -0.43434453f, 0.54039145f, 0.45224398f, 0.20715651f, 
    -0.27424026f, 0.08683378f, 0.00022627f, 0.05235829f, -0.01692327f, 0.07268477f, 0.04612795f, -0.09006680f, 
    -0.11755393f, -0.26862308f, -0.12434130f, -0.01427635f, 0.06800015f, 0.09740206f, 0.02110828f, -0.06150799f, 
    -0.03635529f, -0.01050732f, -0.12825349f, -0.03831729f, -1.63244212f, -0.88900727f, -0.46719122f, -0.27790934f, 
    0.02459803f, -0.12317748f, 0.03355578f, -0.57437855f, 0.07960822f, 0.01013300f, -0.04867504f, 0.04126789f, 
    0.32197753f, -0.53141129f, -0.63381249f, 0.03143663f, -0.13236983f, 0.11241797f, 0.06942888f, 0.06368945f, 
    -0.08247776f, -0.04320132f, -0.31467023f, -0.07652614f, -0.26972425f, -0.29042888f, -0.14420940f, 0.49026030f, 
    -0.03897886f, -0.25047818f, -0.08045693f, -0.07804264f, -0.02250403f, 0.22181489f, 0.01301684f, -0.03201640f, 
    -1.40952480f, -0.99716163f, -0.54677409f, -0.42228141f, -0.10891443f, -0.40597534f, -0.32305974f, -0.48794517f, 
    -0.12932819f, -0.00371543f, -0.02618465f, -0.14147824f, -0.03120954f, -0.25907773f, -0.21378526f, 0.10677838f, 
    -0.11316703f, -0.09025998f, 0.14591950f, 0.28571573f, -0.06461121f, 0.16565648f, 0.20286593f, 0.02561370f, 
    0.10777792f, -0.07796439f, 0.32083708f, -0.08464710f, -0.03320641f, 0.07101212f, 0.10184527f, 0.04633189f, 
    0.02463158f, 0.12348119f, 0.02752851f, 0.00274196f, -0.28107524f, -0.23075797f, 0.23944159f, -0.06104524f, 
    -0.03114044f, 0.01363922f, 0.22647095f, -0.01756014f, -0.24533130f, -0.08148388f, -0.11523858f, 0.01160015f, 
    0.61984450f, 0.37071055f, -0.30221793f, -0.35151318f, 0.05365402f, 0.18004543f, -0.22423439f, 0.18728457f, 
    -0.14368422f, -0.00642062f, 0.06519006f, 0.02658013f, 0.37128252f, -0.45167521f, -0.08598416f, -0.57031244f, 
    -0.01915096f, -0.00635708f, 0.03068755f, -0.05226518f, 0.09531678f, 0.05056786f, 0.03583894f, -0.27379283f, 
    -0.68928820f, 0.03697046f, -0.07932267f, 0.96415913f, 0.02381765f, 0.13073301f, -0.03044718f, 0.07762343f, 
    -0.05242280f, -0.10487302f, -0.03677127f, -0.09819914f, -0.04233330f, 0.13943775f, 0.14000854f, 0.09394123f, 
    -0.02511316f, -0.05951741f, -0.07515311f, 0.01949117f, 0.23086712f, -0.06691766f, 0.19350490f, 0.14754702f, 
    0.60902584f, 0.06386765f, 0.16873926f, -0.11153482f, 0.00808597f, -0.06296664f, -0.10107718f, -0.00446605f, 
    0.29671192f, 0.20046282f, 0.09737428f, 0.28431842f, 0.06644803f, 0.08585170f, 0.02822067f, -0.21644963f, 
    -0.10690917f, -0.06817979f, -0.24649635f, 0.02249596f, 0.04521668f, 0.03518684f, 0.03570626f, 0.08045829f, 
    0.02273317f, 0.27485314f, 0.10500053f, -0.01793418f, 0.01270716f, -0.05243129f, 0.05879990f, -0.10299221f, 
    -0.24330413f, -0.21834779f, 0.03500295f, -0.03364564f, 0.12052354f, -1.18305385f, -0.52715611f, -0.51125771f, 
    -0.10941360f, -0.21486340f, 0.07806885f, 0.14767779f, 0.19525684f, -0.02928151f, -0.17111251f, -0.08248934f, 
    0.03416972f, 0.27369094f, 0.01903721f, -0.08651444f, -0.02706828f, -0.12083095f, 0.09653895f, -0.02382987f, 
    -0.08686371f, 0.03515826f, 0.00701040f, -0.00412737f, -0.73323238f, -0.63640642f, -0.40164754f, -0.10929142f, 
    0.35892242f, -0.12554654f, -0.02989947f, 0.16032875f, 0.00658433f, -0.05717553f, -0.05289435f, 0.03684397f, 
    -0.15818834f, -0.11164136f, 0.29748121f, 0.05084873f, 0.02133757f, -0.26664257f, -0.09805909f, 0.04023546f, 
    0.10804311f, -0.08900986f, 0.02977723f, 0.02299807f, 0.48495984f, -1.07018530f, 1.12760997f, -0.58581412f, 
    -0.39968047f, 0.20955309f, -0.40369871f, 0.24660213f, -0.23662235f, 0.15232615f, -0.08477370f, -0.16320181f, 
    0.24402229f, -1.17869818f, -0.85666937f, -0.23918480f, -0.00336997f, -0.38372585f, -0.09058079f, 0.10490749f, 
    -0.02670354f, 0.06673331f, -0.01493134f, 0.04093509f, 0.48041263f, -0.22338536f, -0.09045705f, -0.28552362f, 
    -0.21160482f, -0.37528870f, -0.34903809f, -0.09332158f, -0.04578502f, -0.03150975f, -0.11924195f, -0.11466093f, 
    -0.45988241f, -0.39870015f, 0.02053513f, -0.05584662f, -0.10818289f, 0.26861674f, -0.16147323f, 0.01031261f, 
    0.17453174f, 0.20221326f, 0.36872360f, 0.24831234f, -0.20468444f, -0.40460551f, 0.50722033f, 0.17380586f, 
    -0.08117546f, 0.10976089f, 0.16445987f, -0.14359470f, -0.10433805f, -0.00812607f, -0.05602033f, 0.08125756f, 
    0.34830451f, -0.14726596f, -0.08672896f, -0.18038745f, -0.53421271f, -0.13114664f, 0.47988540f, 0.04844598f, 
    0.24370217f, -0.06168883f, 0.37505850f, 0.08642051f, 0.52663863f, 0.21824887f, -0.01174952f, -0.93147719f, 
    0.05864522f, -0.21843344f, -0.13509613f, -0.15914065f, -0.05198188f, 0.07047322f, 0.11297879f, 0.07954359f, 
    0.38653284f, -0.31980115f, -0.63790703f, -0.39274257f, 0.23236096f, -0.34817386f, 0.20862944f, -0.12226149f, 
    0.16073957f, 0.26196915f, -0.03509981f, -0.11710835f, -0.73066133f, -0.12359951f, 0.23827399f, 0.19370061f, 
    -0.06922927f, 0.01536366f, -0.07666541f, 0.03073385f, -0.30149356f, -0.08973914f, -0.34624940f, -0.77682787f, 
    0.10098730f, 0.21653154f, -0.45651942f, -0.22465192f, -0.13252883f, -0.11793435f, -0.02231708f, -0.06848060f, 
    0.22216015f, -0.02435225f, 0.06474411f, -0.41250139f, -0.34353486f, 0.27627540f, 0.29120445f, 0.04246540f, 
    -0.09909685f, 0.02692991f, -0.16259077f, -0.15679111f, -0.10219376f, 0.06224009f, -0.06953687f, 0.08886002f, 
    -0.14528978f, -0.04696443f, -0.18121678f, -0.33112445f, -0.11390788f, 0.06656189f, -0.05022054f, -0.03374233f, 
    0.06701367f, 0.01123885f, -0.12645547f, 0.04535700f, -0.34359416f, -0.76881135f, -0.23471856f, 0.14621590f, 
    -0.00047321f, 0.29461703f, 0.09255039f, 0.37117144f, -0.34565192f, -0.15831073f, -0.16091628f, -0.40985340f, 
    -0.12330669f, 0.02421172f, 0.13208038f, -0.17078021f, -0.19680886f, -0.02266796f, -0.02238098f, -0.05087237f, 
    0.00684454f, 0.05009913f, 0.10216332f, 0.01299966f, 0.21712689f, -0.86318195f, -0.36529532f, 0.15446897f, 
    -0.22653697f, 0.08241814f, 0.27493641f, 0.22755115f, -0.16644344f, -0.35057154f, -0.06432376f, -0.07326233f, 
    -0.25323945f, 0.15188804f, 0.16847205f, 0.08719957f, 0.11847191f, -0.10773430f, -0.06181882f, -0.08948653f, 
    0.12145479f, 0.25279248f, 0.04558810f, 0.14039591f, 0.61226809f, 0.06342094f, -0.06734403f, -0.31634271f, 
    0.36150622f, -0.04676767f, 0.28639188f, 0.05441381f, 0.09591292f, 0.21289244f, 0.32492867f, 0.17052644f, 
    -0.65843749f, -1.06913364f, -1.07812667f, -0.38198328f, 0.03254493f, 0.16549030f, 0.01017526f, 0.21361427f, 
    0.01553179f, 0.01084724f, -0.08072974f, 0.27061358f, -0.12609935f, 0.11860378f, 0.09812566f, -0.15800749f, 
    0.16455510f, 0.25490606f, 0.07217736f, 0.11052500f, -0.02133451f, 0.09351628f, 0.04256669f, 0.21836853f, 
    0.21005249f, -0.26961029f, -0.02680425f, -0.14970413f, -0.19139063f, 0.25348976f, -0.54621738f, -0.38143015f, 
    -0.09365103f, 0.05086971f, -0.27189520f, 0.02461674f, 0.28910798f, -0.83736062f, 0.79266280f, -0.99792856f, 
    0.00063248f, -0.28644416f, -0.28341958f, -0.05441103f, -0.15732387f, -0.05507207f, 0.14593257f, 0.08313284f, 
    -0.36389384f, -0.13867895f, 0.31291702f, -0.03020581f, -0.14834043f, -0.01428401f, -0.71791559f, 0.10558781f, 
    0.08018837f, -0.21343951f, 0.05269196f, 0.10684077f, 0.30525219f, -0.69053155f, 0.29467204f, 0.14514208f, 
    -0.03241392f, 0.29162651f, -0.02187734f, -0.07349576f, -0.26616761f, -0.04976203f, 0.11669452f, 0.05348529f, 
    -0.52299452f, -0.14317800f, -0.43328953f, -0.14661197f, -0.15907794f, 0.00881232f, 0.17807192f, 0.07063031f, 
    0.16915008f, 0.11022012f, 0.03552622f, -0.15389885f, 0.05309678f, -0.40549845f, -0.03001386f, -0.41282833f, 
    -0.14360587f, 0.23763978f, 0.16198291f, 0.25041533f, 0.22116230f, 0.03360475f, 0.10374979f, 0.41261545f, 
    -0.43228438f, 0.59518439f, -0.00673335f, 0.97500497f, 0.05911903f, -0.04952202f, -0.15725745f, -0.01997629f, 
    0.17204624f, 0.02945382f, 0.16965690f, 0.06691359f, -0.21045835f, -0.01414084f, -0.99982792f, 0.17653775f, 
    0.32350847f, 0.28446478f, 0.12737897f, 0.12445839f, 0.16117181f, -0.19259122f, -0.22544946f, 0.05643254f, 
    -0.20110224f, -0.22937062f, -0.05688697f, 0.23194957f, 0.26076099f, 0.27348843f, 0.25301817f, 0.05107015f, 
    0.18251331f, 0.24777421f, -0.00730944f, 0.10875402f, 0.07619323f, 0.11347955f, 0.46730158f, 0.16559951f, 
    -0.12750639f, -0.24874902f, -0.32276672f, -0.30153650f, 0.03402906f, 0.03282915f, 0.23579389f, 0.14013062f, 
    -0.11400229f, -0.74017346f, 0.48558506f, -0.03852853f, 0.23656140f, 0.36029801f, -0.06955501f, -0.01878806f, 
    0.02137815f, 0.22421861f, -0.04802540f, -0.18517353f, -0.71533018f, 0.33886564f, 0.07515167f, -0.09361152f, 
    -0.26655033f, -0.15884988f, 0.14961638f, 0.10200363f, 0.05441774f, 0.05919192f, 0.11489165f, 0.13162446f, 
    0.10680696f, 0.64621413f, -0.34251663f, -0.24846691f, 0.29929245f, -0.05991827f, 0.22478312f, 0.05386671f, 
    -0.01988034f, -0.14789267f, -0.21172410f, -0.29808846f, -0.16271059f, -0.63430929f, -0.32085839f, 0.15766150f, 
    0.03584533f, -0.05573323f, -0.00784366f, 0.03943025f, 0.00725990f, 0.02601655f, -0.17974846f, -0.13349657f, 
    -0.09114422f, 0.01804539f, 0.15542348f, -0.18855910f, 0.07136977f, -0.23538947f, -0.19772099f, 0.56834602f, 
    -0.03691794f, -0.01899999f, 0.06950839f, -0.19755697f, -0.14612316f, -0.10746606f, 0.01809378f, 0.42792794f, 
    -0.10866791f, 0.17886935f, -0.40636751f, -0.22476010f, 0.31297347f, -0.38145784f, -0.03069011f, -0.02100935f, 
    -0.06207877f, 0.48911244f, 0.24724452f, -0.01730499f, 0.03015149f, -0.19538943f, 0.39823061f, -0.15495621f, 
    -0.20735301f, 0.29163164f, 0.39317238f, 0.39791024f, -0.25754738f, 0.69238085f, -0.37808654f, 0.59473515f, 
    0.24179305f, -0.02897934f, -0.16109578f, 0.21780436f, -0.04575139f, 0.07721411f, -0.07844927f, -0.27789095f, 
    -0.21399571f, -0.08316475f, 0.32043365f, 0.28487021f, 0.00851076f, -0.01169393f, -0.45467919f, 0.24126185f, 
    -0.01025082f, -0.02942193f, -0.17260912f, 0.06589027f, -0.51758933f, 0.37328801f, -0.51828831f, 0.06573629f, 
    -0.15342082f, 0.14347568f, 0.17603742f, -0.08782103f, 0.12141739f, 0.13467522f, -0.09910387f, -0.05504800f, 
    -0.00257401f, -0.66843867f, 0.01446250f, 0.08066866f, -0.10822736f, 0.16257349f, -0.17347302f, 0.11412019f, 
    0.01498176f, 0.20043883f, -0.12571777f, -0.03237400f, -0.20081481f, 0.28629792f, 0.06782031f, 0.19900659f, 
    -0.04950611f, 0.14617294f, 0.12292027f, -0.08855811f, -0.24047028f, -0.43804297f, -0.24381165f, -0.49420303f, 
    0.29931071f, 0.00394459f, 0.23813714f, -0.83687729f, -0.10724014f, -0.04298777f, -0.02013319f, 0.10641155f, 
    -0.27607763f, -0.05165990f, -0.50138986f, -0.36684725f, -0.13606434f, 0.01441245f, 0.26081115f, -0.34010863f, 
    -0.17570685f, 0.06917296f, 0.56238180f, 0.00911505f, 0.07457566f, 0.16509834f, 0.23389068f, 0.08239970f, 
    -0.30156392f, -0.53382647f, 0.06056888f, -0.54507619f, -0.30116084f, -0.25274718f, -0.25296590f, 0.06747381f, 
    -0.04350456f, -0.10329054f, 0.10793245f, -0.06618387f, -0.02457557f, -0.20718318f, -0.12974590f, -0.16779795f, 
    0.11602540f, -0.17205204f, -0.33986571f, 0.04312653f, -0.12647392f, 0.06908976f, -0.12947246f, -0.65846664f, 
    -0.23004648f, -0.53628331f, 0.14880344f, -0.33764979f, -0.20606387f, 0.07009705f, 0.00142974f, -0.06442899f, 
    0.10345497f, -0.13995659f, 0.01843198f, 0.09217423f, -0.27832848f, 0.01225280f, -0.31539401f, 0.26010659f, 
    0.04076454f, 0.22723645f, 0.12330569f, 0.31817624f, -0.27874681f, 0.12365161f, 0.01160687f, -0.12683223f, 
    -0.56490511f, -0.39022201f, -0.23918657f, 0.19217488f, -0.09427523f, 0.04564184f, 0.04223983f, 0.03809185f, 
    -0.06666816f, 0.20070726f, -0.00682699f, 0.09940688f, -0.95610029f, 1.02298701f, -0.82077199f, 0.41171515f, 
    0.16566208f, 0.37911627f, 0.37085912f, -0.18238741f, 0.04005575f, 0.07279180f, 0.03389880f, 0.13193052f, 
    -0.35769942f, 0.03430333f, -0.49984613f, 0.26559579f, -0.37584043f, -0.05012564f, -0.01879652f, 0.21161906f, 
    0.04236259f, 0.04895850f, -0.05289405f, 0.30373946f, -0.16386290f, -0.15576081f, 0.43427098f, 0.08757520f, 
    0.00472122f, -0.12726429f, 0.08060142f, 0.13438863f, -0.22938097f, 0.10981109f, 0.17554484f, -0.09013999f, 
    -0.87957710f, 0.46815997f, -0.64570647f, -0.22282070f, 0.11264058f, -0.21111920f, 0.35787675f, -0.47897023f, 
    -0.09450214f, -0.13001001f, -0.37068629f, -0.08534568f, -0.65660477f, -0.23801690f, -0.04694479f, 0.60719520f, 
    -0.12413738f, 0.03877668f, 0.18286397f, 0.18282869f, -0.44839382f, -0.04158717f, -0.15683897f, 0.14072184f, 
    -0.67351288f, -0.09923289f, -0.77574617f, 0.53183573f, 0.48150942f, 0.20172842f, 0.26048389f, 0.01608006f, 
    -0.07306601f, -0.05351245f, -0.04175944f, 0.01055575f, -0.33789852f, 0.44676635f, -0.54854208f, -0.08309567f, 
    0.07935804f, -0.04990955f, -0.00182542f, -0.15071447f, 0.11449267f, 0.19070551f, 0.16040547f, -0.11051326f, 
    -0.22562493f, -1.01947212f, 0.34755346f, -0.17900811f, -0.02815035f, -0.23440589f, -0.19287252f, -0.05379314f, 
    -0.05642204f, 0.10263743f, 0.14022137f, 0.07115341f, -0.04621490f, 0.36546192f, -0.30645928f, 0.23270972f, 
    -0.08240353f, -0.02955856f, 0.17451411f, 0.18262145f, 0.40113634f, 0.14787029f, 0.10609722f, -0.01480548f, 
    -0.06006235f, -0.47197059f, -0.16131499f, 0.01092664f, 0.16418497f, -0.04157642f, 0.09504626f, -0.15549517f, 
    -0.20444998f, 0.07405232f, 0.22545272f, 0.24432299f, 0.54967004f, 0.04966402f, 0.38358951f, 0.25978518f, 
    0.00952418f, -0.17375731f, -0.00007245f, 0.22280148f, -0.20163888f, -0.00411782f, -0.02684564f, -0.11699016f, 
    -0.10473413f, 0.14221519f, -0.30144572f, -0.28214169f, -0.12247056f, -0.05896061f, 0.01041414f, 0.06853834f, 
    -0.17820477f, 0.22780316f, 0.10023973f, -0.14490843f, -0.21965310f, 0.17282610f, -0.43168238f, -0.60254985f, 
    -0.15019837f, -0.18178672f, -0.08240687f, 0.02762427f, 0.01230272f, 0.08307667f, 0.05029829f, 0.05288126f, 
    0.00647253f, 0.36418909f, -0.30871770f, -0.05489874f, -0.03758953f, -0.09993143f, 0.10498770f, -0.06926299f, 
    -0.16128692f, 0.04338054f, -0.02030371f, -0.17912340f, 0.12340637f, -0.22014682f, 0.13562064f, -0.38356358f, 
    0.19421099f, -0.17817378f, -0.31921002f, -0.17859247f, 0.01016973f, -0.00349361f, -0.04269080f, -0.17364576f, 
    0.79909307f, 0.40289700f, 0.36497879f, -0.12161934f, -0.04203561f, -0.04074677f, -0.05687476f, 0.28805900f, 
    -0.26038128f, 0.09200811f, -0.03660805f, -0.06052069f, -0.43595356f, -0.71725464f, 0.32047108f, 1.05120420f, 
    0.41791871f, -0.11679145f, 0.16295762f, -0.11648555f, 0.13918926f, -0.00027178f, 0.24992202f, -0.00481221f, 
    0.10830078f, -0.37862259f, -0.05513987f, -0.05791484f, -0.06206458f, -0.04186267f, 0.01221750f, 0.11624102f, 
    -0.09678910f, -0.12910470f, 0.06504824f, -0.12399600f, -0.34189475f, 0.24292839f, -0.40065300f, 0.30684349f, 
    0.19502437f, 0.12486030f, 0.45707828f, -0.07548772f, 0.03296859f, 0.02365757f, -0.12391596f, 0.01522087f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.32106411f, 0.11201873f, 0.08855562f, -0.11499164f, -0.16926275f, 0.18026879f, -0.04445903f, -0.21810530f, 
    0.21008405f, 0.08601536f, 0.10124299f, 0.07375255f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
