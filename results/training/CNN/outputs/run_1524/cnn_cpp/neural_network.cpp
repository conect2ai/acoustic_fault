#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.56981546f, -0.65951347f, -0.41354015f, -0.40292805f, -0.41284251f, -0.33515757f, 0.38547009f, -0.55917060f, 
    0.43903026f, -0.14149997f, 1.12797523f, 0.38879624f, -0.13503306f, 0.42868868f, 0.35351011f, 0.12473849f, 
    0.53179330f, -0.22995642f, -0.44128066f, 1.13241446f, -0.54076856f, -0.15662840f, 0.51568460f, -0.67151427f, 
    -0.11836844f, -0.46332076f, 0.41563436f, -0.32582188f, 0.88058025f, 0.45198834f, -0.47321132f, -0.44721499f, 
    -0.69142580f, -0.06642455f, -0.74378556f, -0.36689526f, -0.54427898f, -0.71866435f, -0.12654796f, 0.09646663f, 
    -0.23778684f, -0.30439600f, -0.48324570f, -0.33242172f, -0.52156770f, -0.65329838f, 0.04963160f, -0.34634963f, 
    -0.00990587f, 0.24538349f, 0.53736383f, 0.25518659f, 0.09448183f, 0.66297299f, 0.95318240f, 0.54022300f, 
    0.52095079f, 0.69500256f, 0.06471685f, -0.55318195f, -0.11943082f, 0.21247002f, 0.12435257f, 0.05337404f, 
    0.34638101f, 0.09071819f, -0.72797489f, -0.42218328f, -0.43059883f, 0.17658405f, 0.41884997f, 0.79294974f, 
    -0.99829310f, -0.84763891f, 0.03735606f, 0.29009971f, 0.35219720f, -0.33067822f, 0.06792560f, 0.13207328f, 
    -0.15455832f, 0.30576274f, -0.81361681f, -0.04242060f, -0.53184730f, -0.53299737f, -0.54338485f, 0.03031196f, 
    -0.11847476f, 0.07390640f, -0.48453107f, -0.51278055f, -0.43571544f, 0.44831729f, 0.78057456f, 0.74787754f, 
    -0.29459250f, -0.22062397f, -0.26702091f, -0.29565194f, 0.28306362f, 0.02820800f, 0.36594874f, 0.48314413f, 
    0.18493477f, 0.57197666f, 0.44906694f, 0.34407711f, 0.22640298f, 0.06772051f, 0.75881904f, 0.72452170f, 
    -0.24441375f, 0.63819689f, -0.05520811f, -0.38577929f, -0.62764418f, -0.14519374f, -0.12557334f, 0.21929048f, 
    0.64153993f, -0.39850855f, -0.70137042f, -0.57310951f, 0.03796393f, 0.39726710f, 0.12055073f, -0.49374354f, 
    0.29155695f, 0.58889198f, -0.50766033f, -0.33590975f, 0.67403483f, -0.35096189f, 0.04224610f, 0.46471906f, 
    1.06903470f, -0.34322128f, -0.04206591f, -0.38779822f, 0.42185259f, -0.51990020f, -0.03828945f, 0.03286912f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.01630340f, 0.17371565f, 0.02406646f, 0.03236246f, -0.27683476f, 0.32797825f, -0.11267141f, 0.16199102f, 
    0.19886543f, 0.56734318f, -0.22097674f, 0.22077426f, 0.09967646f, 0.08016383f, 0.57111382f, -0.10486384f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.16379412f, 0.01309851f, -0.22947839f, 0.01501163f, -0.04869463f, -0.18299481f, -0.01399218f, 0.12580863f, 
    0.16668862f, 0.49930879f, 0.00395254f, 0.00796089f, -0.05126809f, -0.09873170f, -0.19387649f, -0.05484882f, 
    0.01166496f, 0.05339645f, 0.04889137f, -0.19105980f, -0.01827220f, 0.19193712f, -0.06803976f, -0.06419971f, 
    0.18724960f, 0.22365774f, -0.44316784f, -0.05709002f, -0.00839131f, 0.07837001f, -0.13373037f, -0.30739766f, 
    0.02843393f, 0.05649753f, 0.10980808f, 0.12139980f, 0.08302142f, -0.26185533f, -0.33988717f, -0.07489166f, 
    -0.15019378f, 0.00942341f, -0.00908576f, 0.15580374f, -0.05281402f, 0.27144769f, -0.12517329f, -0.55722523f, 
    0.10998833f, 0.12882273f, -0.02195102f, 0.18512629f, -0.04913752f, -0.02592779f, 0.03202282f, 0.32091182f, 
    0.03673488f, -0.23003900f, -0.17012759f, -0.03133993f, -0.01709162f, 0.02963320f, 0.19441122f, 0.09060886f, 
    -0.02079448f, -0.07692587f, 0.08712269f, 0.10738856f, -0.06912375f, 0.10958469f, 0.23087139f, 0.05554703f, 
    0.20501277f, -0.33635303f, -0.59907693f, 0.18521579f, -0.09846354f, 0.01811472f, -0.04654453f, 0.19516990f, 
    0.05172443f, 0.47115085f, -0.39963126f, -0.17422311f, -0.06160022f, -0.06405548f, 0.01245922f, 0.06705317f, 
    0.08248429f, 0.05032707f, -0.07014975f, -0.34901077f, -0.57343644f, -0.24968398f, 0.11516073f, -0.13789991f, 
    -0.13986333f, -0.18794596f, 0.03438775f, 0.07660791f, -0.08301929f, -0.09853108f, -0.07233529f, 0.04747503f, 
    0.19830525f, 0.04988536f, 0.05968457f, -0.04454470f, -0.18715517f, -0.01072061f, 0.23779729f, -0.13397080f, 
    -0.01768241f, -0.09081171f, -0.08871557f, 0.02817672f, 0.02149055f, -0.21811122f, -0.28099304f, 0.51729298f, 
    -0.14673044f, -0.01448570f, -0.14183928f, 0.07339754f, 0.01306726f, -0.01585292f, -0.08459261f, -0.08476503f, 
    0.29358020f, -0.09782243f, 0.06448584f, -0.15237147f, 0.08843548f, 0.09524612f, 0.20186193f, -0.21273808f, 
    0.17125286f, -0.22216287f, -0.00907853f, 0.02506030f, 0.22737393f, -0.07156047f, 0.06341910f, -0.00808846f, 
    -0.05265251f, 0.39241129f, 0.53313547f, -0.08866470f, -0.31965756f, -0.31065893f, 0.04509407f, 0.11502708f, 
    0.13527901f, 0.07098182f, 0.49939874f, -0.23046513f, -0.13625284f, 0.32009059f, 0.23857774f, -0.12335625f, 
    0.06239757f, -0.16624992f, -0.15982279f, 0.64234006f, 0.25808135f, -0.26914477f, 0.19783463f, 0.33016992f, 
    -0.15906003f, 0.05138615f, -0.21575654f, 0.30905780f, -0.10895673f, 0.18245935f, -0.10515616f, 0.08461127f, 
    -0.22934943f, 0.10943437f, -0.01238069f, 0.09416032f, -0.13541174f, -0.30394900f, 0.30532202f, -0.03696624f, 
    0.00068549f, -0.02258224f, 0.11589886f, -0.03271654f, 0.30220300f, -0.17953472f, 0.39830044f, 0.02472583f, 
    -0.13146640f, -0.15164742f, 0.13517472f, 0.16422488f, 0.02262268f, 0.09627561f, 0.14383040f, 0.07706080f, 
    0.23046246f, -0.10995054f, -0.22362845f, -0.10329175f, 0.09127451f, 0.10090613f, -0.16615650f, -0.16122836f, 
    0.45938709f, 0.12176055f, 0.00919261f, -0.00218981f, -0.23268929f, -0.02616085f, -0.05193385f, -0.05668341f, 
    -0.06894714f, -0.27277714f, 0.41775373f, -0.08633938f, -0.06300161f, -0.31967908f, 0.06261803f, -0.07216158f, 
    0.11185645f, 0.03835422f, 0.25127771f, 0.35276330f, -0.11444800f, -0.07808315f, 0.39687216f, 0.12050527f, 
    -0.12713732f, 0.12865569f, -0.79771817f, 0.19790523f, -0.13975592f, 0.03327391f, -0.13882908f, -0.21468091f, 
    0.08282329f, 0.04819351f, 0.01613999f, -0.14281371f, -0.24802561f, -0.03076812f, -0.24835980f, 0.03046496f, 
    -0.08100206f, 0.28047335f, -0.04361616f, -0.02350406f, -0.58646345f, 0.43176961f, 0.23936506f, -0.20936844f, 
    0.01894089f, -0.50758928f, 0.03502717f, 0.19402055f, 0.08364131f, -0.52733982f, 0.30958509f, 0.33804840f, 
    -0.20380126f, 0.11145541f, -0.31726372f, 0.12638465f, 0.21713574f, 0.05931878f, -0.04663958f, -0.20017773f, 
    0.53657359f, -0.03808955f, 0.14383888f, 0.01555255f, 0.11220494f, -0.22775060f, -0.08174816f, -0.18623340f, 
    -0.30449668f, -0.36146885f, 0.07431262f, -0.07774054f, -0.14605686f, -0.08863731f, -0.06962299f, 0.16554932f, 
    0.21744205f, 0.47606555f, 0.28943190f, -0.07928780f, 0.15593585f, 0.07720867f, -0.04792855f, 0.04479471f, 
    -0.07471221f, 0.31467223f, -0.39563310f, -0.40696138f, -0.10746403f, 0.09929929f, 0.05326715f, -0.06627163f, 
    0.11045372f, 0.03144559f, -0.45867547f, -0.43326685f, -0.28293952f, 0.10954695f, -0.52823240f, -0.26337343f, 
    0.28077462f, 0.14632119f, 0.23042277f, -0.13499799f, 0.04087813f, -0.05466190f, -0.13941664f, 0.02575878f, 
    -0.19757617f, -0.01291188f, -0.15499772f, 0.06999182f, 0.42132908f, 0.10411204f, 0.14634621f, -0.00669241f, 
    0.12338223f, 0.07236409f, 0.22547671f, 0.02062245f, -0.15232602f, -0.34708908f, -0.03974619f, -0.26338446f, 
    -0.00872427f, 0.07287669f, -0.00050953f, 0.11525491f, 0.04760255f, 0.16643161f, -0.08781400f, -0.96614981f, 
    0.06682117f, -0.02456120f, 0.26979622f, -0.36397961f, -0.08732429f, -0.14644152f, -0.00792970f, 0.00096140f, 
    0.06344614f, -0.17128290f, -0.02895542f, -0.01378305f, -0.15828250f, -0.05644733f, 0.07063869f, 0.25827107f, 
    0.41054526f, 0.25292411f, 0.11476333f, -0.11500471f, 0.01572654f, 0.19560163f, -0.00243288f, -0.02151187f, 
    0.01653469f, -0.15504627f, 0.11106010f, -0.04161111f, -0.28086197f, -0.06751223f, -0.13203490f, -0.00064354f, 
    0.00872534f, 0.07712828f, -0.08921704f, -0.10321961f, 0.11794855f, -0.05733356f, 0.07238300f, 0.00509596f, 
    0.14886522f, -0.07431040f, -0.15149848f, 0.00181302f, -0.07142639f, -0.11026432f, -0.10684074f, 0.08195385f, 
    0.26512554f, 0.10635296f, 0.07987590f, 0.08599469f, -0.05838204f, -0.52600968f, -0.02218297f, -0.12686823f, 
    0.08017626f, -0.15645254f, -0.05287996f, -0.18112552f, -0.03121773f, -0.06176358f, 0.08770310f, 0.00003026f, 
    -0.06150497f, -0.03619407f, -0.01861846f, 0.00514362f, 0.10332884f, 0.11961725f, -0.07520144f, -0.11344557f, 
    -0.07431315f, -0.10010014f, -0.00278430f, 0.12028603f, 0.16974507f, 0.06136874f, 0.14422718f, 0.05107694f, 
    -0.77237374f, -0.55814904f, -0.06028984f, -0.31188267f, 0.05550939f, -0.21721655f, -0.07307316f, 0.01614605f, 
    -0.06292289f, -0.05066516f, -0.07038611f, -0.02603226f, 0.04880876f, -0.05687432f, -0.05441560f, -0.05744706f, 
    0.02751042f, -0.09713842f, -0.01903641f, -0.06683721f, -0.06148198f, -0.08733604f, -0.01650160f, -0.01202798f, 
    -0.05437150f, 0.02709945f, 0.04532683f, -0.00305976f, 0.01345212f, -0.04107311f, 0.05751754f, -0.03709881f, 
    -0.04812182f, -0.05426348f, -0.05817296f, 0.01837227f, 0.06192251f, -0.05037582f, -0.03565507f, 0.06750440f, 
    0.06938316f, 0.04780494f, 0.02686947f, -0.02941852f, 0.03549004f, -0.04884778f, 0.05437791f, -0.00304891f, 
    -0.03066423f, -0.04581087f, 0.06112758f, 0.04432808f, 0.07472167f, -0.07978296f, -0.00467218f, 0.04203032f, 
    -0.07466281f, -0.06453954f, -0.01798368f, 0.06231231f, -0.06159645f, 0.00792204f, 0.00617239f, 0.06018645f, 
    -0.00136538f, 0.01097877f, -0.03905647f, -0.02431187f, 0.01190970f, 0.04596196f, -0.00867050f, -0.01381703f, 
    0.05044365f, -0.04031660f, -0.03070991f, -0.05335179f, 0.00476107f, -0.08504348f, 0.02731037f, -0.04673694f, 
    -0.04874122f, -0.08355055f, -0.00525779f, -0.01003610f, -0.06696872f, -0.01464735f, 0.05136774f, -0.03584125f, 
    0.03118783f, -0.02260425f, -0.08917567f, 0.01520849f, -0.01156870f, 0.02961067f, -0.00574126f, -0.04452641f, 
    -0.02729837f, -0.07224525f, 0.04136099f, 0.05596234f, 0.00468138f, -0.01962346f, 0.03912517f, 0.05068294f, 
    -0.03802659f, -0.06307556f, -0.01909921f, -0.07995136f, 0.05324484f, -0.02238165f, 0.07331338f, -0.02609486f, 
    0.06714047f, -0.07131320f, -0.03347944f, -0.03134703f, 0.00346378f, -0.02089972f, 0.02365578f, 0.01485068f, 
    0.05213581f, 0.03542873f, 0.04814789f, -0.08537681f, 0.05349421f, 0.01097530f, 0.02744204f, 0.06849256f, 
    0.03066529f, -0.03339760f, -0.01706335f, -0.04340191f, 0.01428123f, -0.08848436f, -0.01715062f, 0.04209277f, 
    -0.06241350f, 0.06676169f, -0.05759522f, 0.02520077f, -0.04610321f, -0.07270790f, -0.09218094f, 0.01820022f, 
    0.03773900f, 0.02087194f, -0.09169271f, -0.01086677f, -0.00164718f, -0.02710925f, 0.03788564f, -0.04490904f, 
    0.01391872f, -0.17343596f, -0.15290369f, 0.25666007f, 0.10148296f, 0.01875798f, 0.21454321f, -0.02619392f, 
    0.11136319f, 0.32778952f, 0.26007509f, -0.06667030f, 0.00574997f, -0.01547698f, 0.09383848f, 0.03412078f, 
    -0.11274187f, 0.02268528f, 0.30624032f, -0.12842517f, -0.13430892f, 0.35081643f, -0.17696726f, -0.12047875f, 
    0.09709529f, 0.05003766f, 0.04170249f, 0.35313958f, 0.28427383f, 0.34352916f, 0.14413209f, 0.12636454f, 
    0.08992960f, 0.11361890f, 0.01373902f, 0.08801571f, -0.07505108f, -0.15952544f, 0.08086986f, 0.11335079f, 
    -0.02901982f, 0.19432484f, -0.08360010f, -0.08269713f, 0.09458421f, -0.07857760f, -0.31194523f, 0.05730905f, 
    0.06408797f, 0.12468199f, 0.12574568f, -0.19187249f, -0.17223513f, -0.37328506f, 0.14952441f, 0.37063101f, 
    -0.08328186f, -0.20970312f, -0.08060898f, 0.05979336f, -0.21353789f, 0.00109026f, 0.04793683f, 0.07547781f, 
    0.24322531f, -0.12346371f, 0.03850847f, -0.13465846f, 0.10759308f, -0.21230176f, -0.18006301f, -0.35548592f, 
    0.10904921f, -0.35974735f, 0.20807956f, -0.05508947f, -0.06462549f, 0.06472173f, 0.24415591f, -0.07595509f, 
    0.13807561f, 0.05525781f, 0.27997226f, 0.00232443f, 0.10022955f, 0.11225518f, -0.00186926f, 0.05227581f, 
    0.03654397f, 0.07775990f, -0.17557670f, -0.80572850f, 0.04898864f, -0.01672052f, 0.17551243f, -0.17961638f, 
    0.14942867f, 0.15372057f, 0.11359425f, 0.16773936f, -0.40860167f, -0.04629387f, 0.28945524f, 0.12902676f, 
    0.05802561f, -0.01943264f, -0.21948609f, -0.35452113f, 0.12347411f, 0.16457646f, -0.10689936f, 0.15155625f, 
    -0.12036487f, 0.08291487f, 0.07134657f, 0.10168599f, 0.01123920f, 0.44250935f, -0.11322352f, 0.19209573f, 
    0.12175450f, 0.05968788f, 0.19684125f, 0.00221342f, 0.25555378f, -0.11123420f, 0.31175825f, -0.07521996f, 
    0.02209250f, 0.11553954f, 0.15812571f, 0.15538396f, -0.10381811f, 0.06123744f, 0.00774703f, -0.04494173f, 
    0.29127905f, -0.38097277f, 0.13825849f, -0.01203367f, 0.02419381f, 0.17469734f, -0.13633361f, 0.10894805f, 
    -0.26893777f, 0.18086612f, -0.07788585f, 0.03487659f, 0.03014481f, -0.24704178f, 0.18969780f, 0.00985302f, 
    -0.00039656f, 0.18655454f, 0.34204394f, 0.09299797f, -0.15310796f, -0.05678622f, 0.34793773f, 0.00866415f, 
    -0.11568888f, -0.09438483f, -0.12896807f, 0.43589363f, 0.15093222f, 0.00148769f, 0.18334870f, 0.16578054f, 
    0.05311111f, 0.01196015f, 0.15225169f, -0.04990102f, 0.24469501f, -0.24610934f, -0.23187260f, 0.12722827f, 
    0.21431316f, 0.02143204f, 0.02578986f, -0.09647617f, 0.26741764f, -0.08330794f, -0.36280435f, -0.19092028f, 
    -0.15555322f, 0.23075251f, 0.16448396f, -0.08119923f, 0.14323768f, -0.07743550f, 0.15650307f, -0.32331592f, 
    0.00144180f, 0.09769917f, -0.00640001f, 0.00950485f, 0.08210734f, 0.07710735f, 0.58561617f, -0.07851911f, 
    0.03250170f, -0.04503132f, -0.10230391f, -0.10645664f, 0.36596838f, 0.00693472f, 0.15611142f, -0.24563906f, 
    0.59587973f, 0.10666501f, 0.13428462f, 0.09575746f, 0.20287822f, -0.02479274f, -0.14509280f, 0.20144135f, 
    0.01144478f, -0.26767650f, -0.16370910f, -0.22201437f, 0.05173695f, -0.09043606f, -0.14423692f, 0.04448328f, 
    -0.18611455f, -0.21062919f, -0.20749144f, 0.04872695f, -0.12030830f, 0.02719620f, 0.07021712f, 0.15360551f, 
    -0.10960177f, -0.12240949f, -0.29778302f, -0.40320072f, -0.53126991f, 0.02844430f, -0.09430730f, -0.41371515f, 
    -0.07984643f, -0.11449669f, -0.02751526f, -0.01551039f, -0.07787657f, -0.03072148f, 0.04916784f, -0.01227382f, 
    0.18988059f, 0.20016880f, -0.09270342f, -0.09487565f, 0.11936957f, 0.16091737f, 0.41501883f, -0.02016896f, 
    -0.06896769f, -0.24207698f, -0.22829080f, -0.00974273f, -0.04517924f, -0.11268892f, 0.09520770f, 0.43260288f, 
    0.14439897f, 0.00395897f, -0.13288936f, 0.16395502f, -0.03048020f, 0.13415353f, -0.19401495f, -0.10179193f, 
    0.43479145f, -0.28196925f, 0.17926036f, -0.14544715f, 0.11283997f, 0.13869473f, -0.30224255f, 0.18319908f, 
    0.07637163f, 0.04539725f, -0.04364983f, 0.11820248f, 0.08918014f, -0.02405227f, 0.01414106f, 0.00407098f, 
    0.04845861f, 0.07168702f, 0.20998834f, -0.11199029f, -0.05876212f, -0.00570224f, 0.08468109f, 0.12262949f, 
    -0.04506095f, 0.04510219f, -0.98059803f, -0.13928398f, 0.33243135f, 0.01524142f, 0.01963840f, -0.08499990f, 
    -0.19698095f, -0.09392826f, 0.48775893f, -0.63960958f, 0.45747840f, 0.23362972f, 0.03950869f, 0.12017831f, 
    0.13009968f, -0.04034775f, 0.05157204f, -0.10769460f, -0.32195988f, 0.17057376f, 0.23326439f, 0.09769423f, 
    0.00410322f, 0.07860199f, -0.04790915f, -0.09190273f, -0.18990369f, 0.06765854f, 0.08140382f, 0.08348554f, 
    0.11287670f, 0.04400899f, -0.08932393f, 0.02893116f, -0.24301852f, 0.10700537f, 0.23631604f, 0.05900633f, 
    0.13954476f, -0.13090146f, 0.11477105f, 0.13433115f, -0.00342655f, 0.15716609f, 0.03735504f, -0.42247862f, 
    -0.42650670f, -0.06781372f, 0.08217431f, -0.01474494f, -0.01365870f, 0.18012759f, 0.05319665f, 0.00460331f, 
    0.05493513f, 0.13147832f, -0.00809526f, -0.03919772f, 0.19178408f, 0.05640815f, 0.18705107f, 0.17912351f, 
    -0.28633031f, 0.20160401f, -0.01710541f, 0.09853697f, 0.11435243f, 0.06271774f, -0.04768726f, -0.07983963f, 
    -0.02130725f, 0.05532198f, 0.07158593f, 0.05540358f, 0.10069678f, 0.02742097f, 0.05810643f, 0.04434049f, 
    0.22137499f, 0.18243490f, -0.36451089f, 0.13614489f, -0.04272361f, 0.36668345f, 0.04582548f, -0.00370002f, 
    -0.17150292f, -0.31539357f, 0.01014168f, -0.14130037f, -0.00304103f, -0.19111297f, 0.08919929f, -0.01851174f, 
    0.19770384f, -0.00957295f, 0.27376920f, 0.03115549f, 0.09383068f, -0.37085369f, -0.24639310f, -0.00345460f, 
    -0.06862172f, -0.16090205f, -0.05687348f, 0.01203602f, -0.09783679f, 0.15512326f, 0.14128242f, 0.21179862f, 
    0.08006439f, -0.05686311f, 0.25084975f, -0.01230173f, -0.01682212f, 0.10257977f, 0.19738340f, 0.16229820f, 
    0.11494428f, 0.23227546f, -0.00947135f, 0.13055262f, -0.06042949f, -0.07168858f, 0.13570802f, 0.58814186f, 
    -0.33378473f, -0.37438533f, 0.00556924f, 0.00566873f, -0.19465043f, -0.05122603f, 0.16003679f, 0.08033059f, 
    -0.08666191f, 0.23112163f, 0.25492656f, -0.25735489f, 0.19505318f, 0.06212220f, -0.04982138f, -0.00862057f, 
    -0.29338735f, -0.18713892f, -0.10523236f, 0.08925238f, -0.11550117f, 0.15229747f, -0.04443013f, 0.01130605f, 
    0.29138267f, 0.26880533f, 0.19225098f, 0.05262193f, -0.18430036f, -0.12446301f, 0.22161141f, 0.07516555f, 
    -0.15663475f, 0.15674314f, -0.20740341f, 0.06912151f, -0.08402351f, 0.19972737f, 0.19983469f, 0.00559746f, 
    -0.06883406f, 0.24849164f, -0.23007695f, -0.15851110f, -0.47051683f, 0.08686963f, -0.21347187f, -0.03666056f, 
    0.18433343f, -0.17080130f, 0.32432443f, -0.15373787f, 0.20882797f, -0.10646413f, 0.12655592f, 0.14578399f, 
    -0.16301040f, -0.07745882f, -0.04273957f, 0.11949024f, 0.00819341f, -0.01344010f, -0.60946417f, -0.46430433f, 
    0.05760818f, 0.15849437f, -0.23367013f, 0.15623780f, 0.15669031f, 0.08787014f, 0.19838288f, 0.05029774f, 
    -0.10963108f, -0.25254536f, -0.07678034f, 0.12792411f, 0.11466913f, -0.10004625f, -0.23642479f, -0.00685564f, 
    -0.27838844f, -0.05675417f, 0.27640474f, -0.16444205f, -0.04075434f, 0.01077134f, 0.14752905f, -0.05833316f, 
    0.21837753f, 0.09797617f, 0.52061009f, 0.22239925f, -0.01760652f, 0.22825196f, 0.00781629f, 0.09183121f, 
    -0.02380098f, -0.27404961f, -0.30049714f, -0.14063056f, 0.07053950f, -0.01828610f, -0.18178448f, -0.13005017f, 
    0.10428484f, 0.05864515f, 0.07962705f, -0.05858923f, -0.00903262f, 0.19222102f, 0.21552116f, -0.05487249f, 
    0.26196527f, 0.21957573f, 0.14952347f, -0.00954254f, -0.28977332f, -0.06213459f, -0.00220075f, -0.17961368f, 
    -0.14335833f, -0.12890278f, 0.02903244f, -0.25942478f, -0.14345694f, -0.22107002f, -0.08539612f, 0.22392057f, 
    -0.07127860f, 0.19539206f, 0.09402410f, -0.00880658f, 0.20687382f, -0.09745357f, 0.26021218f, 0.28570518f, 
    -0.04316120f, 0.14495286f, 0.21360347f, 0.17617136f, 0.13361639f, 0.11051670f, 0.04145005f, 0.36093342f, 
    -0.12202605f, -0.34832114f, 0.00204569f, -0.09157309f, -0.05842579f, -0.15822655f, -0.05510578f, 0.10806148f, 
    -0.29592454f, -0.25972873f, 0.06445142f, -0.07379473f, 0.13211460f, -0.05197785f, 0.01485367f, -0.06373657f, 
    0.00917002f, 0.28012130f, -0.04176116f, -0.17398520f, -0.06167522f, 0.02972567f, -0.17630930f, 0.02332758f, 
    -0.00940147f, -0.04977891f, 0.00937203f, -0.48024622f, 0.01331088f, -0.04152542f, 0.07262293f, 0.06412953f, 
    0.02675900f, 0.00278545f, 0.10126152f, -0.44456041f, -0.38979328f, -0.48203701f, 0.18724374f, 0.04763268f, 
    0.06023973f, 0.12926851f, -0.12638466f, -0.08228773f, 0.23571610f, -0.01453871f, 0.19125229f, 0.10847298f, 
    0.00559930f, -0.08010349f, -0.26055440f, -0.11793952f, -0.14604983f, -0.03580898f, 0.25625387f, 0.27996135f, 
    0.06162753f, 0.18458225f, 0.11905453f, -0.00739157f, -0.03647810f, 0.22772618f, 0.04944152f, -0.17114891f, 
    0.14758919f, -0.02460071f, 0.24719852f, -0.11681578f, -0.06111016f, 0.07321496f, -0.03480155f, 0.07119417f, 
    -0.38379657f, -0.40637365f, 0.08229207f, 0.04024485f, 0.01612858f, 0.23015772f, 0.13222778f, -0.04169491f, 
    -0.15927075f, -0.08753994f, 0.35847464f, 0.02368646f, 0.06043396f, 0.18383174f, 0.04371022f, -0.00796651f, 
    0.09124731f, 0.06403187f, -0.15502809f, -0.46881184f, 0.16372713f, -0.00845296f, -0.07799650f, 0.11703016f, 
    0.04404672f, 0.20389381f, -0.29875192f, -0.12077911f, 0.11967788f, 0.06656113f, 0.01655984f, 0.03582365f, 
    -0.18272986f, -0.09607633f, -0.06301273f, -0.00287032f, 0.13296422f, -0.01260001f, 0.16064972f, 0.10572397f, 
    0.14361382f, 0.19536714f, -0.07002098f, 0.20339333f, 0.14111856f, 0.05661043f, -0.10535189f, -0.03120273f, 
    -0.13105084f, 0.11299795f, 0.12115999f, -0.07300422f, -0.00256152f, -0.18285072f, -0.21643795f, -0.07885896f, 
    0.13475268f, 0.05829705f, 0.01320617f, 0.19654246f, -0.00292902f, 0.07058027f, -0.12097470f, 0.06112456f, 
    0.32407385f, 0.02368407f, -0.00674985f, 0.00443886f, 0.25726181f, 0.16906385f, 0.16071023f, 0.09200525f, 
    0.03632980f, 0.22600099f, -0.06816918f, 0.11795026f, -0.21788479f, -0.09025899f, -0.18753837f, -0.08411570f, 
    -0.00343024f, -0.31846738f, -0.04375598f, 0.08521220f, 0.05590271f, 0.12829654f, 0.05964774f, 0.05784730f, 
    0.00603856f, -0.20795444f, 0.00492510f, -0.04570978f, 0.09387242f, -0.07051082f, 0.26921982f, -0.09478009f, 
    0.03906069f, 0.11356477f, 0.15549421f, 0.01112244f, 0.04277964f, -0.01834107f, -0.11049866f, 0.22691301f, 
    0.21650864f, -0.02693713f, 0.06571511f, -0.17101027f, 0.16915192f, 0.17322966f, 0.03375174f, -0.03298831f, 
    0.11220251f, -0.12936306f, 0.07901374f, -0.17008303f, 0.05414885f, 0.22718169f, -0.23672998f, 0.08838961f, 
    -0.26353726f, -0.06553915f, 0.06732083f, -0.14919078f, -0.14839880f, -0.13824001f, -0.06701926f, -0.09830227f, 
    0.00405826f, 0.05302045f, 0.01662220f, 0.18296376f, 0.18015918f, 0.18695989f, -0.46181428f, -0.26244354f, 
    -0.00569448f, -0.01842588f, -0.00231413f, -0.06888479f, -0.03882313f, -0.01580184f, -0.21993154f, -0.24600701f, 
    -0.05682565f, 0.04277492f, -0.05458568f, 0.07745898f, 0.12278213f, 0.27628469f, 0.21343496f, 0.23809007f, 
    0.24171075f, 0.05120590f, 0.03062679f, 0.13084713f, -0.09530358f, 0.01556930f, -0.10871328f, -0.12599561f, 
    -0.02667460f, -0.16791059f, -0.03379972f, -0.05229990f, 0.09434272f, 0.17144985f, -0.05242645f, 0.09369949f, 
    -0.00691581f, -0.11558615f, 0.20583947f, -0.05517454f, -0.01764382f, 0.19607621f, 0.15146875f, -0.13641465f, 
    -0.09283559f, -0.28354570f, -0.40145659f, 0.08823317f, 0.10916453f, 0.00990636f, 0.09204177f, 0.24380353f, 
    -0.05947067f, 0.00694345f, 0.32920089f, 0.35902908f, -0.43930030f, -0.36541164f, 0.05660107f, 0.28105253f, 
    -0.01303402f, 0.06316606f, -0.08906186f, -0.28886694f, -0.28300238f, 0.36168876f, 0.15596417f, -0.02573607f, 
    -0.03642824f, 0.06595167f, 0.08047073f, 0.19085793f, -0.02906147f, 0.20822553f, -0.05709706f, 0.13948774f, 
    0.06691135f, 0.14297093f, -0.01770876f, -0.01437576f, 0.10908155f, 0.30743498f, 0.02450327f, -0.23416978f, 
    -0.10171691f, 0.18790154f, -0.02560896f, 0.15952137f, 0.10234356f, 0.06012864f, -0.05389208f, 0.07620108f, 
    -0.29757494f, -0.05848520f, 0.00310765f, -0.07712831f, 0.06103471f, 0.09645434f, 0.03173593f, 0.06662929f, 
    -0.03862010f, 0.18172303f, 0.56147337f, 0.31829485f, 0.04341668f, -0.05246380f, -0.19245997f, -0.06437283f, 
    -0.09864528f, 0.00491745f, 0.15029353f, 0.34750545f, 0.16935854f, -0.23022209f, -0.03160337f, -0.02539871f, 
    0.13707286f, 0.14740014f, 0.01845032f, -0.23918526f, -0.04923198f, -0.00231820f, 0.15665509f, -0.11077993f, 
    -0.10130800f, 0.14070065f, 0.06547380f, 0.05355635f, -0.09419095f, 0.09762509f, 0.03138326f, -0.14738017f, 
    -0.12686364f, -0.17259280f, 0.05449281f, -0.04079184f, -0.26658422f, -0.18421730f, 0.34282088f, 0.27474129f, 
    -0.04494628f, 0.21220089f, 0.12525022f, 0.16217813f, 0.10799293f, 0.11638422f, -0.33793378f, 0.15208387f, 
    0.28222072f, -0.03743124f, 0.00201523f, -0.14210218f, -0.01470042f, -0.18975234f, 0.05903885f, -0.09109201f, 
    -0.11351481f, -0.03915961f, 0.20753469f, 0.03847320f, -0.07974012f, 0.09911256f, 0.01549440f, 0.23112236f, 
    -0.38364419f, 0.15134609f, 0.08791398f, -0.10353427f, -0.03286801f, -0.07570186f, -0.09769677f, 0.15292244f, 
    -0.21460429f, 0.13611971f, -0.13477081f, -0.21529610f, 0.13752809f, 0.00359171f, 0.10671788f, 0.17336546f, 
    0.07986054f, 0.17279343f, -0.71327478f, 0.26122278f, 0.25028110f, 0.06830564f, 0.13834648f, -0.22497588f, 
    -0.24384220f, -0.14081928f, -0.33912528f, -0.29073313f, 0.02255854f, 0.24005793f, -0.13028702f, -0.05091618f, 
    0.05254953f, 0.06413884f, 0.06187122f, 0.03382906f, -0.21835169f, -0.15373640f, 0.11453749f, 0.09050076f, 
    0.11105034f, -0.10023084f, -0.03345636f, 0.24405047f, 0.06268089f, -0.03919334f, 0.25120601f, 0.14179134f, 
    -0.09531914f, 0.07083525f, 0.05591697f, 0.11600972f, -0.00296535f, 0.03833241f, 0.23286085f, -0.10363115f, 
    -0.04020857f, -0.24401593f, -0.12253408f, -0.00168012f, -0.05229855f, 0.17597593f, 0.01582316f, -0.08635975f, 
    0.27791294f, 0.02624926f, -0.05536286f, -0.02560851f, -0.06093067f, -0.26601204f, 0.02391076f, 0.05491484f, 
    0.13080309f, -0.22737709f, -0.00450880f, 0.12537257f, 0.11446986f, -0.06611685f, -0.16815883f, -0.04046174f, 
    -0.08762284f, 0.37268648f, -0.03828932f, -0.50411803f, -0.43736768f, -0.22671458f, -0.11502799f, -0.08625457f, 
    0.16139396f, 0.11143938f, 0.11924835f, -0.44902441f, -0.04531063f, 0.02851061f, 0.07100484f, -0.07625660f, 
    -0.03078587f, -0.14610232f, 0.32793057f, 0.25657919f, -0.00958125f, 0.36065283f, -0.32158065f, 0.06855814f, 
    -0.05642751f, -0.00340303f, 0.06686644f, 0.10329735f, 0.12089973f, 0.30477989f, -0.05307944f, -0.06479594f, 
    -0.15480424f, 0.05277918f, 0.07676444f, 0.18861176f, 0.11381409f, 0.08001193f, -0.37205479f, 0.07636885f, 
    0.01973032f, 0.13280040f, -0.10205013f, -0.01339862f, 0.03124082f, -0.03211680f, 0.00223873f, 0.33601752f, 
    -0.12969525f, -0.10034074f, -0.06424598f, -0.09707831f, -0.08944140f, 0.04118396f, 0.22745422f, 0.43436512f, 
    0.06654549f, 0.18042675f, -0.15682191f, -0.19921546f, -0.00593459f, 0.07035229f, -0.07433166f, -0.13511015f, 
    -0.25285998f, 0.26352412f, -0.03520561f, 0.16858865f, -0.01510587f, 0.13876249f, -0.19081065f, -0.09726004f, 
    -0.10538843f, 0.44116291f, 0.05153529f, -0.18309757f, 0.12153544f, 0.04722383f, 0.07359182f, 0.02985824f, 
    0.03135285f, 0.04405558f, -0.16623749f, -0.19508696f, -0.25612563f, -0.01623208f, 0.06885137f, -0.08486135f, 
    -0.06629650f, -0.14372391f, 0.04317207f, -0.12769338f, 0.08150128f, 0.08535396f, -0.02382233f, 0.08083177f, 
    0.06444747f, -0.00254492f, -0.04041891f, 0.01929299f, -0.23441382f, -0.02755617f, -0.56183660f, -0.26110211f, 
    0.08564647f, 0.05924072f, 0.12156460f, -0.02395616f, -0.02393195f, -0.00397204f, -0.07076154f, 0.07585794f, 
    0.05252216f, 0.12117499f, 0.12632060f, 0.07502050f, 0.03992737f, 0.07711856f, 0.07710152f, 0.33551541f, 
    0.06623020f, 0.03609411f, 0.19615297f, 0.19606739f, 0.11900946f, 0.30190423f, 0.29808897f, -0.09442902f, 
    -0.01888597f, 0.31400952f, 0.02312509f, -0.13323981f, -0.24020769f, -0.01981738f, 0.13156240f, 0.03487087f, 
    0.23032384f, 0.34192753f, 0.22516491f, -0.08762001f, 0.09312390f, -0.00535691f, 0.07761047f, 0.01674022f, 
    0.00905493f, 0.01841483f, -0.00366175f, -0.20675306f, 0.02990792f, -0.13645345f, 0.18328445f, -0.05639742f, 
    -0.06073892f, 0.12608562f, -0.03879654f, -0.10486884f, -0.24667510f, -0.04937150f, -0.15462795f, -0.02545875f, 
    0.00229497f, 0.27148113f, -0.05716153f, -0.11202548f, 0.31423837f, 0.28478914f, -0.03298550f, 0.08559379f, 
    -0.05056825f, 0.03027187f, 0.09931785f, -0.02456238f, 0.27855238f, 0.04471562f, 0.39847517f, -0.03307562f, 
    -0.06520686f, 0.12773037f, -0.05027437f, -0.19221954f, -0.15184207f, -0.11521693f, -0.00856250f, -0.19853458f, 
    0.09352195f, 0.08837988f, 0.03235395f, -0.04627607f, 0.08467413f, -0.05369337f, -0.00810191f, -0.21901907f, 
    -0.13120326f, -0.00650800f, 0.01922083f, -0.15188757f, -0.04999187f, 0.01623436f, -0.04086846f, -0.04812272f, 
    -0.03703294f, 0.06715011f, -0.03161677f, -0.11295570f, -0.13121367f, 0.02289358f, -0.03012720f, -0.12649158f, 
    0.32978538f, 0.20381747f, 0.22669685f, 0.14252381f, 0.03150135f, 0.09987341f, -0.23565105f, -0.01497850f, 
    -0.00835338f, -0.21131228f, 0.25808272f, 0.08689131f, 0.02020160f, 0.08640093f, -0.06317382f, 0.05918789f, 
    -0.01102825f, -0.04087586f, 0.28260571f, -0.20737499f, 0.23623210f, 0.09437790f, -0.02988970f, 0.03729911f, 
    -0.00417259f, 0.00803325f, 0.06569903f, 0.20042191f, -0.04360497f, -0.02848099f, -0.01340560f, 0.10112963f, 
    0.13979687f, -0.10111051f, 0.00344344f, -0.01584179f, -0.13156703f, -0.03830606f, -0.21295084f, 0.08047780f, 
    0.06103167f, 0.04002178f, 0.09805088f, -0.04476098f, 0.08652174f, -0.03722642f, 0.12286189f, -0.20194821f, 
    -0.00716824f, -0.12838246f, -0.08482096f, -0.01255264f, -0.03768583f, -0.05820584f, 0.10206630f, 0.04345843f, 
    -0.13487525f, -0.07222381f, -0.00042306f, 0.04293369f, -0.02314860f, -0.06108041f, 0.09345139f, -0.04788063f, 
    0.32121521f, -0.51722246f, 0.17672470f, -0.03379713f, -0.02746459f, 0.15847951f, 0.00856588f, -0.13442473f, 
    0.13211948f, -0.20908627f, -0.32599014f, 0.12074761f, -0.06464528f, -0.00916693f, -0.18143784f, -0.00319037f, 
    -0.02693566f, -0.12642880f, 0.03384213f, -0.12282328f, -0.13646318f, 0.06876691f, 0.04972205f, 0.05983013f, 
    0.00792309f, 0.03900334f, 0.09098643f, 0.04386151f, -0.15593153f, 0.20015828f, 0.06033468f, 0.09886970f, 
    0.08310165f, 0.07236923f, 0.37629360f, -0.02991887f, 0.25084335f, -0.15820304f, 0.17135632f, -0.07608797f, 
    -0.06984231f, 0.10061423f, 0.03644690f, 0.17574170f, 0.03163465f, -0.06506640f, -0.26183763f, -0.00014241f, 
    0.09078334f, -0.19686845f, -0.07801813f, 0.09893204f, 0.26904845f, -0.18888594f, 0.39178076f, 0.11905552f, 
    0.18856812f, 0.21179028f, 0.10683013f, 0.03446596f, -0.14017193f, -0.16882254f, 0.18823066f, -0.08659371f, 
    0.31284595f, 0.14459063f, -0.01195165f, 0.19073935f, 0.06925287f, 0.20691980f, -0.06014399f, 0.11715166f, 
    0.26182175f, -0.02137818f, 0.17673495f, -0.05540054f, 0.09942311f, -0.14636785f, -0.12517215f, -0.38537422f, 
    -0.02370978f, 0.08205652f, -0.20184830f, -0.23206365f, 0.01591116f, -0.05013496f, 0.10750256f, -0.12143007f, 
    0.09841901f, -0.09679190f, -0.05751181f, -0.02652522f, 0.15085916f, -0.14273921f, -0.03700476f, 0.02687438f, 
    0.00673492f, -0.02832335f, 0.34235784f, 0.24388206f, 0.09213074f, -0.13878135f, 0.05329934f, -0.19038306f, 
    -0.10240705f, 0.11480295f, 0.31824467f, 0.02774825f, -0.12016820f, -0.12059643f, 0.05092132f, 0.09700952f, 
    0.07239276f, -0.06099391f, 0.02662956f, -0.15283607f, 0.25409478f, 0.32747379f, -0.24631238f, -0.05665217f, 
    0.19697563f, 0.01964077f, 0.21539144f, 0.00238019f, -0.33957520f, 0.20482467f, 0.03755673f, -0.14766593f, 
    -0.00517457f, -0.15884529f, 0.05307057f, 0.21636885f, -0.14349960f, 0.00678078f, 0.07426748f, -0.12428346f, 
    0.22518180f, 0.14454810f, 0.04177530f, -0.03985055f, -0.06423663f, -0.00718569f, -0.06974506f, -0.17900312f, 
    0.00938241f, -0.05071964f, 0.09022180f, 0.02942011f, 0.00801187f, 0.31423143f, 0.07192177f, -0.06286900f, 
    0.26345742f, 0.18185891f, 0.04246515f, 0.06946654f, -0.07510513f, -0.03610919f, -0.02854722f, 0.03680249f, 
    -0.23080663f, 0.03960723f, 0.24582557f, 0.11673976f, 0.14443518f, 0.07364991f, -0.22207329f, -0.02935567f, 
    0.13387105f, -0.10592782f, -0.01001882f, 0.40619972f, -0.01071138f, 0.03157248f, 0.13436635f, -0.08450036f, 
    -0.17548884f, -0.09946629f, 0.05070708f, 0.01771680f, -0.15008904f, -0.12179767f, 0.02182887f, 0.04460138f, 
    -0.03748653f, -0.03281917f, -0.07472688f, -0.02106618f, 0.13417462f, 0.10370672f, -0.12357839f, -0.09564923f, 
    -0.00734090f, 0.07835173f, 0.03771748f, 0.02038695f, 0.29402119f, 0.34302780f, 0.20148675f, -0.10333762f, 
    -0.00873801f, -0.05323852f, -0.13215934f, 0.13201974f, 0.08692680f, -0.23802777f, 0.16651402f, -0.12202685f, 
    0.09848380f, 0.13367105f, 0.02140957f, 0.06732665f, 0.17753594f, -0.00496600f, 0.11039457f, -0.31201589f, 
    0.07059125f, 0.30543941f, 0.13019809f, 0.21602832f, 0.12153752f, -0.01391940f, 0.10954267f, 0.41961345f, 
    0.34152958f, -0.12115157f, -0.63034540f, 0.10304826f, -0.13694194f, 0.01523951f, 0.10518574f, -0.05855472f, 
    -0.12506473f, -0.24266650f, -0.01060021f, 0.06511725f, -0.12369934f, 0.10022454f, 0.09779458f, -0.04276864f, 
    -0.11865067f, -0.05898912f, 0.37046099f, -0.03845696f, -0.11340462f, -0.02779967f, -0.39563876f, -0.14844580f, 
    -0.04216693f, 0.10604028f, -0.07055001f, 0.42770261f, 0.16180345f, 0.22378790f, -0.27775708f, -0.14177792f, 
    -0.22896460f, 0.07608879f, -0.08681874f, -0.02551834f, 0.09199574f, 0.00941651f, 0.27713397f, 0.03278020f, 
    0.02283765f, -0.09175938f, -0.00925210f, -0.18022707f, 0.05565575f, 0.02396614f, -0.19186801f, 0.11474542f, 
    -0.19248196f, 0.26190522f, -0.00124198f, 0.14109777f, -0.07924747f, -0.04477942f, 0.17550366f, -0.44871938f, 
    0.02556488f, -0.19143324f, -0.03242591f, 0.08740794f, 0.10303706f, -0.17877379f, -0.13098769f, -0.05887113f, 
    -0.14045244f, 0.01989574f, 0.19016810f, -0.02238895f, 0.21190923f, -0.07312339f, -0.14419477f, 0.18638271f, 
    0.01032232f, 0.04311101f, -0.05053334f, -0.08044327f, -0.02000709f, 0.03660097f, -0.05991160f, -0.07604922f, 
    0.00250817f, 0.04700292f, -0.06837180f, -0.05988299f, 0.04980778f, -0.03537466f, 0.05086787f, -0.06557088f, 
    -0.05859509f, 0.04856505f, -0.06237627f, 0.06042011f, -0.07938774f, -0.01984988f, -0.00520813f, -0.00188486f, 
    -0.01513835f, 0.03895644f, 0.06462935f, -0.00813456f, 0.01506000f, -0.04843456f, -0.03236975f, 0.05812482f, 
    -0.03340240f, -0.04846289f, -0.02177207f, 0.05624005f, -0.08213231f, 0.02949394f, 0.04265312f, -0.00122416f, 
    0.05498562f, -0.01509030f, 0.02165300f, 0.06232231f, -0.06974056f, -0.06761193f, 0.00412387f, 0.01998132f, 
    0.03924313f, 0.04306690f, 0.05285743f, 0.07081902f, 0.03298718f, -0.09338839f, -0.05377902f, 0.06495079f, 
    0.02864872f, 0.06207472f, 0.02675134f, 0.06399044f, -0.04579334f, -0.05441063f, -0.02705928f, 0.05286351f, 
    -0.05724778f, -0.05737620f, -0.01913773f, -0.08778130f, 0.00746274f, -0.05157578f, 0.03438041f, -0.08014186f, 
    -0.04922865f, 0.03680400f, -0.05577476f, -0.03821904f, -0.02557731f, -0.01730390f, 0.05620973f, 0.04873748f, 
    -0.02016258f, -0.01892632f, -0.03388371f, -0.03221557f, -0.01225024f, -0.03066707f, 0.03297066f, 0.06081812f, 
    -0.08001380f, -0.05074317f, -0.08430623f, 0.05850087f, 0.06610674f, -0.04583368f, 0.01270546f, -0.05084311f, 
    -0.02023714f, -0.04878799f, 0.00217059f, -0.00772085f, 0.05343558f, -0.07912075f, -0.08751150f, 0.04298319f, 
    0.03816864f, -0.04976716f, 0.00136933f, 0.05435798f, -0.06069674f, 0.03035656f, -0.04973590f, -0.03238941f, 
    0.00003973f, 0.01745347f, -0.01260385f, 0.01375774f, -0.00685299f, 0.06691633f, -0.03322043f, -0.02152676f, 
    -0.01796802f, 0.02064170f, -0.02774412f, 0.04895716f, 0.05216747f, -0.01343276f, 0.03651071f, 0.00293727f, 
    0.05190973f, -0.01688856f, 0.06813743f, -0.05457680f, -0.05072575f, -0.05300283f, -0.04942667f, -0.00436307f, 
    0.03243868f, -0.03844113f, -0.04531658f, -0.08404100f, -0.04923115f, -0.04481684f, -0.08551547f, -0.02717366f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.11559551f, 0.13002238f, -0.03836584f, 0.02912595f, 0.13056898f, 0.00361109f, 0.06902751f, 0.22316472f, 
    0.28673601f, -0.00084789f, 0.08423711f, 0.40508479f, -0.16996475f, -0.01516783f, -0.09174240f, -0.07850097f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.65039802f, 0.06175809f, -0.00001041f, 0.15084429f, -0.29964685f, 0.52838427f, 0.33407563f, 0.32760838f, 
    -0.50011951f, 0.01122846f, 0.09210978f, 0.26264870f, 0.13831706f, -0.43710285f, 0.23506780f, -0.01042733f, 
    0.59128052f, 0.01671291f, -0.52995527f, -0.19437885f, 0.03373581f, -0.17739157f, 0.30306908f, 0.13863164f, 
    -0.09091035f, 0.61945772f, -0.44685563f, 0.57361817f, -0.02432016f, -0.13356107f, -0.37272620f, -0.04265202f, 
    -0.32560566f, 0.24378654f, 0.00753733f, -0.24817172f, 0.36317602f, -0.12084347f, -0.31558767f, -0.18356591f, 
    -0.28552479f, -0.14074056f, -0.08841459f, 0.10762258f, 0.15829781f, 0.35123068f, -0.10261567f, 0.23657621f, 
    -0.30120555f, -0.43993145f, 0.01214895f, -0.11314109f, -0.12231143f, 0.15727825f, -0.00738870f, -0.69879884f, 
    -0.20063511f, -0.06749265f, 0.15419908f, -0.65359581f, 0.19739832f, -0.12208389f, 0.29102400f, 0.13344482f, 
    0.53587121f, 0.29176927f, 0.37252855f, 0.06022272f, -0.06894607f, 0.04516492f, 0.11093425f, 0.47693592f, 
    -0.14295843f, 0.58608145f, -0.23281334f, 0.25484949f, 0.37958807f, -0.53913671f, 0.09949521f, -0.07496548f, 
    0.04496202f, -0.47110850f, -0.00534123f, -0.16666216f, -0.07252983f, -0.17605148f, -0.15690471f, 0.04652139f, 
    0.10184799f, 0.57382613f, 0.10164014f, -0.78587234f, -0.09607420f, 0.29262587f, 0.31150773f, -0.04539934f, 
    0.19554189f, -0.01312453f, 0.14231008f, -0.05759078f, -0.02130438f, -0.16810882f, 0.13872990f, -0.21150054f, 
    -0.97220737f, 0.35176271f, 0.22279760f, 0.06077773f, 0.38054714f, 0.21679753f, -0.04535576f, -0.17025848f, 
    0.35901746f, -0.05217991f, -0.23784572f, 0.11832552f, -0.24143387f, -0.22185709f, 0.31171131f, 0.16098979f, 
    0.20337430f, 0.45649931f, 0.26636532f, 0.45745635f, -0.34979257f, -0.16388190f, -0.05231151f, 0.15857245f, 
    -0.17796062f, -0.27044952f, 0.36898786f, 0.14294864f, 0.26884824f, 0.15100355f, -0.22983900f, 0.06067089f, 
    0.30963787f, 0.02881014f, 0.16647419f, -0.14541639f, 0.22857337f, -0.21972005f, 0.29784906f, -0.23604561f, 
    -0.06306383f, -0.26673159f, -0.32705483f, -0.01508012f, 0.27906945f, 0.45311412f, -0.17009327f, -0.22277242f, 
    -0.34955284f, -0.21058552f, 0.19358739f, -0.52079237f, -0.65222782f, 0.23185255f, 0.03545048f, -0.14474007f, 
    -0.07888586f, -0.14161725f, -0.23753378f, 0.03908008f, -0.10708927f, -0.18737113f, -0.02243071f, -0.08185047f, 
    -0.15579332f, 0.17241246f, 0.10803763f, -0.12357558f, 0.15410298f, -0.20188826f, -0.24127425f, 0.01162142f, 
    -0.22666456f, 0.07122519f, -0.39626431f, -0.19551641f, 0.26535100f, -0.34533757f, -0.02122957f, 0.11057886f, 
    0.48509943f, -0.28353104f, -0.00133988f, 0.44440484f, -0.21937586f, 0.01889299f, -0.47496721f, 0.15562792f, 
    -0.43260753f, 0.40329751f, 0.09699183f, 0.07911059f, 0.00754219f, -0.55743617f, 0.26710564f, 0.23093060f, 
    -0.37664410f, 0.03878570f, 0.36791804f, -0.18855277f, 0.07129079f, -0.20019276f, -0.04575120f, 0.04765212f, 
    0.34464124f, -0.08961584f, 0.69021320f, -0.19601801f, 0.02591639f, -0.46383050f, 0.39095616f, 0.36574838f, 
    -0.18829079f, 0.03994735f, 0.27077481f, -0.03933232f, 0.04844139f, -0.25970080f, -0.35279822f, -0.00902336f, 
    0.48431179f, 0.29519650f, 0.12140422f, -0.10085732f, 0.14477417f, -0.10245731f, -0.08724925f, -0.44508016f, 
    -0.11513171f, -0.19013143f, -0.48637325f, 0.26863280f, 0.15406317f, 0.33368063f, 0.02309878f, -0.20017119f, 
    -0.05889355f, -0.34218001f, 0.10877832f, -0.07737588f, 0.21204872f, 0.28080794f, 0.05755397f, -0.04318767f, 
    -0.01297223f, -0.22489388f, 0.22442892f, 0.15988506f, 0.14942728f, 0.21256419f, 0.03387748f, -0.12616688f, 
    -0.39782938f, 0.44981945f, -0.63512552f, -0.23671255f, 0.01091927f, 0.16597778f, 0.30602056f, 0.10507814f, 
    0.00932226f, -0.23086929f, 0.29263136f, 0.27287167f, -0.38273379f, 0.25307152f, -0.34499258f, 0.22494072f, 
    -0.00823866f, 0.42452359f, -0.35466564f, -0.00244034f, 0.28269497f, -0.19591394f, -0.23881912f, -0.12583798f, 
    0.15115485f, -0.32797763f, -0.19810264f, 0.21766804f, 0.11228032f, 0.37866741f, -0.19698991f, -0.13554183f, 
    -0.14421505f, -0.02783945f, -0.12600258f, 0.01157087f, -0.24727160f, 0.11480749f, 0.20381084f, -0.21544316f, 
    -0.15656967f, -0.25038555f, 0.01227581f, 0.02043957f, -0.18738423f, -0.00579366f, -0.24991839f, -0.21917680f, 
    -0.07649677f, 0.16597036f, -0.06322061f, -0.23150602f, 0.42690140f, -0.24170366f, -0.37236503f, 0.23353839f, 
    -0.73560250f, -0.10495715f, -0.64005649f, 0.04176949f, 0.19197395f, 0.44318914f, -0.01032035f, -0.18084006f, 
    -0.25829056f, 0.11060745f, 0.02588548f, 0.01700489f, 0.01969211f, 0.12200981f, -0.15305331f, -0.04276764f, 
    0.16611627f, -0.43144146f, -0.29805729f, -0.19253595f, -0.56218076f, 0.20732281f, -0.00831247f, -0.05290857f, 
    0.56270301f, 0.02083347f, 0.13394399f, 0.20894505f, 0.31578293f, 0.34032804f, -0.24800600f, -0.18930554f, 
    -0.31398195f, 0.04318563f, -0.42884794f, 0.09364594f, 0.18661651f, 0.08569336f, 0.15751393f, 0.10278387f, 
    -0.14377549f, 0.42549977f, 0.76495153f, -0.14691359f, -0.01158266f, 0.20918576f, 0.21125664f, 0.35234571f, 
    -0.11529653f, 0.19576068f, -0.25187498f, -0.02012528f, 0.40991789f, -0.24621734f, 0.10905842f, 0.17603044f, 
    -0.67561853f, 0.12220449f, -0.28926024f, 0.07096764f, 0.37838668f, -0.40688679f, -0.05292678f, 0.58102018f, 
    0.18311894f, -0.15620522f, 0.12308035f, 0.13696487f, -0.19611467f, 0.20521627f, -0.35019305f, -0.02337274f, 
    0.13802591f, 0.41561803f, 0.36750904f, -0.06823464f, 0.20635155f, 0.20966077f, -0.17146726f, 0.27629462f, 
    -0.09729228f, -0.34026808f, -0.12555923f, -0.37751162f, 0.33577734f, 0.00671688f, 0.38048929f, -0.10568371f, 
    0.38758963f, 0.45041391f, -0.31747067f, 0.06602617f, 0.01788786f, 0.51784027f, 0.11857207f, -0.06296835f, 
    -0.04478964f, 0.31130791f, 0.27502596f, 0.18147677f, -0.36540100f, -0.30656859f, -0.07577374f, 0.00831085f, 
    -0.29651257f, 0.24860024f, 0.18560562f, -0.17014982f, 0.01214299f, 0.33950555f, 0.40564549f, -0.07256342f, 
    0.17932148f, -0.52611279f, -0.05338131f, 0.21505228f, -0.11565717f, 0.07510319f, -0.44633001f, 0.03139709f, 
    -0.51612204f, 0.27142671f, 0.32563734f, -0.06986290f, 0.31670871f, -0.21130383f, -0.10501730f, 0.48140365f, 
    -0.26719031f, 0.13600543f, -0.11728670f, 0.01945638f, -0.00300635f, -0.15115066f, -0.18823358f, -0.07825858f, 
    0.29369622f, -0.30736566f, 0.49853212f, -0.01281893f, -0.21884300f, -0.56839144f, -0.31867042f, -0.10505042f, 
    0.16379677f, 0.40814120f, 0.01312935f, 0.42714593f, 0.45644373f, -0.12719096f, 0.04790149f, 0.13809969f, 
    -0.02615319f, -0.45767409f, 0.48393917f, 0.06609623f, 0.34320286f, -0.13366304f, 0.09912775f, 0.04389657f, 
    -0.33292711f, 0.11685336f, -0.21153152f, -0.09947900f, 0.43882090f, 0.14089648f, 0.36333454f, -0.11992218f, 
    0.28827336f, -0.18251520f, -0.03626249f, 0.15596373f, 0.32413453f, 0.21010068f, 0.28645891f, 0.01577138f, 
    0.67364031f, -0.36805946f, -0.33063766f, 0.33420748f, -0.17393826f, 0.02007736f, -0.55904436f, -0.24539766f, 
    -0.42247805f, 0.00560518f, 0.74668485f, 0.11221434f, 0.32786256f, 0.16378708f, -0.19870418f, 0.40222844f, 
    -0.09091888f, 0.15491824f, 0.11282814f, -0.19442713f, 0.14913914f, -0.15071099f, -0.17878418f, 0.06897584f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.10517389f, 0.38422993f, -0.05054383f, 0.42195565f, -0.00976666f, -0.47260630f, -0.30472866f, 0.34699968f, 
    0.31056195f, 0.21060339f, -0.05943348f, 0.14774552f, 0.34149823f, 0.02397208f, -0.33907279f, -0.33061734f, 
    0.36796790f, 0.18335782f, 0.09683908f, 0.15767470f, 0.16356018f, 0.10016509f, -0.21721023f, 0.54774487f, 
    -0.21400085f, 0.30245832f, 0.02959863f, -0.00869684f, 0.01494987f, -0.06248400f, 0.31194618f, -0.27322841f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.04189492f, -0.17298442f, -0.12106747f, -0.05267690f, 0.14891052f, -0.14904077f, 0.08048010f, -0.09451891f, 
    0.04202439f, -0.09406561f, 0.15911442f, -0.03763591f, -0.06455433f, 0.04646204f, 0.05673280f, -0.07641520f, 
    -0.07691632f, -0.01785437f, 0.10594297f, 0.12661751f, 0.07799812f, 0.03539690f, -0.13816126f, -0.01800784f, 
    -0.13663524f, -0.10519637f, 0.00791886f, 0.17142963f, -0.07382823f, -0.09924818f, 0.15962780f, 0.00165122f, 
    0.21454956f, 0.08850744f, 0.04164676f, 0.09586205f, 0.32902107f, -0.60530233f, 0.26469851f, 0.21414350f, 
    0.02101208f, -0.10102020f, -0.16594607f, -0.03345881f, 0.20752305f, 0.64079505f, -0.62344098f, -0.10335848f, 
    -0.09224460f, -0.39730912f, -0.00963033f, 0.03559135f, -0.08144692f, 0.00836778f, -0.01353973f, 0.18600407f, 
    -0.17979206f, 0.22313994f, -0.24048527f, 0.38779685f, 0.20772457f, -0.00071208f, 0.11106407f, 0.45597726f, 
    -0.09934901f, 0.06075118f, 0.08419360f, 0.11402764f, -0.09868587f, 0.10556217f, -0.00151280f, -0.13690208f, 
    -0.05063032f, 0.03604921f, 0.03131962f, 0.06170192f, -0.11584306f, 0.11729816f, 0.02233256f, -0.22888133f, 
    0.07907972f, 0.10598545f, 0.06557879f, -0.19242373f, 0.02569729f, -0.03378596f, -0.15567258f, -0.11046378f, 
    -0.14644954f, 0.09290376f, -0.19606151f, -0.08296057f, 0.09096474f, -0.13034654f, 0.04523340f, -0.02347702f, 
    -0.11815526f, -0.12335612f, 0.09557052f, -0.03559772f, 0.21232580f, -0.15218550f, -0.03802535f, 0.00936238f, 
    0.07257221f, -0.17506285f, -0.02549104f, 0.09399676f, -0.36746553f, 0.05615823f, 0.17070578f, 0.07786013f, 
    -0.41884843f, 0.22518767f, 0.11028164f, 0.44088262f, 0.10467532f, 0.44447812f, 0.34087572f, 0.08564413f, 
    0.39059389f, 0.02471644f, -0.43145868f, 0.08041564f, 0.46089107f, 0.35214958f, -0.03654526f, 0.59980822f, 
    0.27545193f, -0.18226330f, -0.08393740f, -0.35278001f, -0.02775099f, 0.13789880f, -0.18169603f, -0.00895725f, 
    -0.20347895f, 0.07543399f, 0.12646852f, 0.06790705f, 0.02879478f, 0.05494376f, 0.07508188f, -0.03380969f, 
    0.44804996f, -0.03398489f, -0.04089301f, -0.26015905f, 0.18246102f, -0.12832099f, 0.25371686f, 0.00388147f, 
    0.31304985f, 0.23630598f, 0.72227621f, -0.06410339f, -0.38759783f, -0.10965436f, 0.30877107f, 0.14936565f, 
    -0.40558445f, 0.31991860f, 0.44551423f, -0.59753138f, -0.23464656f, -0.01345020f, 0.17402582f, 0.31972054f, 
    -0.00579980f, 0.19334725f, -0.09590124f, 0.74970424f, -0.01454415f, 0.02586889f, 0.06539609f, -0.04138864f, 
    0.52566642f, 0.52864492f, -0.08964371f, 0.50108546f, 0.04289235f, 0.00057119f, -0.16812575f, 0.51721585f, 
    -0.13355549f, 0.10310188f, 0.39959505f, -0.10497621f, -0.36584115f, -0.08722068f, 0.34885642f, -0.38560772f, 
    0.60976148f, 0.31143880f, -0.25961301f, 0.09478913f, 0.32039511f, -0.27339461f, -0.24687448f, 0.38307825f, 
    -0.53344476f, -0.35470119f, -0.13734852f, -0.06000836f, 0.02993412f, 0.05667013f, -0.00114001f, -0.16644901f, 
    0.11257701f, -0.15675321f, 0.11591566f, -0.18670346f, 0.33508605f, 0.09012043f, 0.19956872f, -0.15391314f, 
    -0.23288009f, 0.15740494f, 0.07709783f, -0.12217847f, 0.33463478f, -0.12487061f, 0.15432440f, -0.60205716f, 
    0.09241218f, 0.14031596f, -0.22462571f, -0.22177048f, 0.20454872f, 0.13289243f, 0.04226965f, 0.22351474f, 
    -0.17421530f, 0.26399761f, 0.12241371f, -0.15225528f, -0.22613306f, -0.17743771f, 0.54861653f, -0.26517200f, 
    0.16712022f, 0.29364094f, 0.17117330f, 0.05188040f, 0.19650902f, 0.11662393f, 0.22845140f, 0.02948126f, 
    -0.03072648f, 0.31214067f, 0.03198547f, -0.27412912f, 0.22340378f, -0.01721655f, -0.08875877f, -0.35963103f, 
    0.34833717f, 0.42530748f, -0.07404310f, -0.40902513f, 0.23871540f, 0.05541347f, 0.39868817f, 0.29091224f, 
    -0.03351248f, -0.04989296f, -0.03772455f, 0.12620322f, -0.32433558f, -0.00115604f, 0.11773736f, 0.04817306f, 
    -0.13575438f, 0.12766282f, 0.12001740f, 0.13204710f, -0.12423662f, 0.25789562f, -0.07273652f, -0.27675468f, 
    -0.13084671f, 0.11392446f, -0.13339011f, -0.33079797f, 1.07661831f, 0.01311585f, 0.04356743f, -0.20185150f, 
    -0.08039935f, 0.06707516f, 0.28971490f, 0.24114628f, 0.12118877f, -0.44782358f, 0.04534419f, -0.03854742f, 
    -0.73245007f, 1.10215056f, -0.05280007f, 0.48872611f, 0.20185721f, -0.08482313f, 0.25306234f, -0.24407043f, 
    0.59304392f, 0.38065073f, -0.00916273f, 0.19684304f, 0.28439179f, -0.40804252f, 0.11012774f, 0.17284298f, 
    -0.19292478f, 0.19179705f, 0.19430560f, 0.12566786f, -0.18806003f, -0.48479444f, 0.09333821f, -0.17237291f, 
    -0.06265098f, 0.36698779f, 0.02936573f, 0.10568847f, 0.14961413f, -0.19047858f, -0.16528340f, 0.34063315f, 
    -0.31482124f, 0.26070082f, -0.00320014f, 0.02277138f, 0.02491082f, -0.32072639f, 0.46408737f, -0.04979542f, 
    0.47789705f, 0.17094493f, 0.05441527f, 0.25905821f, -0.33690301f, 0.04085324f, -0.07976334f, 0.01259781f, 
    -0.25129333f, 0.48366851f, -0.15647301f, -0.10096621f, 0.09570976f, -0.07175197f, -0.02006004f, -0.67245686f, 
    -0.00309965f, 0.11465684f, 0.54541057f, -0.06798015f, 0.06506492f, -0.61849445f, 0.41459301f, -0.25554475f, 
    -0.25840259f, -0.44699943f, -0.12545255f, 0.06650887f, -0.06592806f, -0.37955260f, 0.57295460f, -0.16908215f, 
    0.20885842f, 0.35537672f, 0.07379703f, 0.61688751f, 0.09322101f, 0.22028831f, 0.03732797f, -0.13727430f, 
    0.33696458f, -0.08050491f, 0.10707694f, 0.26606682f, -0.37461320f, -0.14306054f, 0.06497584f, -0.03983549f, 
    -0.20430040f, -0.01891524f, 0.09034282f, -0.02025746f, 0.02798425f, 0.00947604f, -0.13697557f, 0.02259904f, 
    -0.02909956f, 0.02278659f, -0.07667329f, 0.12242743f, -0.00009837f, -0.10955643f, -0.14842911f, -0.02789046f, 
    -0.00470151f, -0.03148823f, 0.08776510f, 0.16911055f, -0.01004992f, -0.00919392f, -0.16808267f, -0.12273061f, 
    -0.13861029f, -0.09810405f, -0.14774510f, 0.09243835f, -0.20815594f, -0.16524643f, 0.06240569f, 0.09448193f, 
    -0.05240954f, 0.16752620f, -0.09527782f, 0.42866278f, 0.20144913f, 0.04519386f, -0.11075184f, 0.20967168f, 
    -0.06591012f, -0.87610775f, -0.07321422f, -0.14062425f, 0.34289595f, 0.38371551f, -0.35106194f, -0.14930725f, 
    0.03982696f, -0.20162541f, -0.16420172f, 0.11493097f, -0.17445254f, -0.35195732f, 0.42469347f, 0.25758401f, 
    0.18871480f, -0.19413462f, -0.15114804f, 0.43285266f, 0.18921570f, 0.28316438f, -0.20701092f, 0.25987530f, 
    0.40314445f, 0.02477498f, 0.11241641f, 0.41356581f, 0.18643858f, -0.08153764f, -0.00134327f, 0.33329913f, 
    0.16961733f, 0.13091512f, 0.14388660f, -0.18711412f, 0.32969752f, 0.20419241f, -0.17603286f, -0.23387878f, 
    0.18191262f, -0.21822570f, 0.01565115f, 0.23303457f, -0.09886629f, 0.02660933f, 0.05456290f, 0.03152358f, 
    -0.10148144f, 0.32664129f, -0.10885099f, 0.04340858f, -0.25800878f, 0.07458272f, -0.30813715f, -0.17746626f, 
    0.25832424f, -0.00340673f, -0.05434326f, -0.47703665f, 0.17427710f, -0.04352916f, -0.17806715f, -0.04140013f, 
    0.02772374f, 0.08175471f, -0.07365239f, 0.47815713f, -0.35066733f, 0.19371036f, -0.38986453f, 0.10943099f, 
    -0.39112008f, -0.27192819f, -0.00384841f, -0.03082965f, -0.13748987f, 0.28227529f, 0.09348145f, 0.02375316f, 
    -0.23612392f, -0.06912910f, -0.04279806f, 0.03255481f, 0.55215693f, 0.31351289f, 0.55931449f, -0.05095555f, 
    -0.12271389f, 0.14217483f, 0.19555034f, 0.02787326f, -0.11998834f, -0.10786739f, 0.04568182f, 0.22818521f, 
    -0.27897730f, 0.15129156f, 0.15465544f, 0.75743085f, -0.35241786f, -0.36768094f, 0.05441050f, 0.10722902f, 
    0.42274654f, 0.23270689f, -0.04704032f, 0.17849846f, 0.63328183f, 0.04433985f, -0.24834441f, 0.17824775f, 
    -0.16293241f, 0.04659735f, 0.56913620f, -0.08093847f, -0.59615332f, -0.27357349f, 0.35906079f, 0.26514962f, 
    0.38767457f, 0.08888351f, 0.13716318f, 0.31271884f, -0.04046246f, -0.31333667f, -0.36851999f, -0.06042233f, 
    -0.11691409f, 0.35482946f, -0.02343620f, -0.00155958f, -0.72018182f, -0.82178628f, 0.17465937f, 0.14019260f, 
    0.07989350f, 0.04051819f, 0.10514627f, 0.30117056f, -0.12061110f, 0.48461393f, 0.00874826f, -0.00062060f, 
    -0.06167976f, 0.25517944f, 0.37884685f, -0.40050414f, -0.29360929f, -0.22474347f, 0.44910854f, 0.08480156f, 
    0.03543631f, 0.12700577f, 0.25944272f, -0.22726513f, 0.11519167f, -0.24135739f, 0.09045417f, 0.18195058f, 
    0.30643168f, -0.76645499f, -0.15988594f, -0.00111295f, 0.45653608f, 0.27791765f, -0.43943754f, -0.20569821f, 
    -0.11410659f, -0.14838313f, -0.09370277f, 0.05457031f, -0.07784223f, -0.49526697f, 0.01891801f, 0.32492959f, 
    -0.08728572f, -0.27170673f, -0.03948737f, 0.31535628f, 0.85444784f, 0.08221658f, -0.36682525f, 0.26540110f, 
    0.30059847f, 0.22241685f, -0.39100516f, -0.08451404f, 0.23240262f, 0.13266578f, -0.12162933f, 0.14964853f, 
    -0.09378037f, 0.33085340f, -0.22544673f, -0.03900940f, -0.19914448f, -0.02395548f, -0.35795799f, -0.15050675f, 
    0.19860306f, 0.09466333f, 0.00063595f, -0.55786222f, 0.30317795f, -0.05768959f, 0.16397955f, -0.24160558f, 
    0.11051267f, 0.20695245f, 0.48529842f, -0.11247551f, -0.54360580f, -0.24463904f, 0.39909813f, 0.01919798f, 
    -0.14149345f, 0.20369378f, -0.50128895f, 0.03553305f, 0.18657258f, 0.02070840f, -0.38322717f, 0.04631395f, 
    0.10718527f, 0.25412944f, -0.14287548f, 0.32549238f, 0.10196747f, -0.10859844f, -0.64535433f, -0.17806464f, 
    0.07246803f, -0.11168187f, -0.06193287f, -0.55210018f, -0.09904059f, -0.02128654f, -0.12918414f, 0.17043756f, 
    0.01340702f, 0.39204320f, 0.30176505f, 0.01513530f, 0.30276257f, -0.26758608f, 0.49334708f, -0.09312231f, 
    -0.20244989f, 0.19912465f, 0.40925929f, 0.25456950f, 0.03921875f, 0.00684869f, -0.12546358f, -0.18414997f, 
    0.18251915f, -0.08386608f, -0.00616436f, 0.43673056f, 0.20650396f, 0.05763268f, 0.11234412f, 0.24250367f, 
    -0.15967771f, 0.01186217f, 0.16332595f, 0.75427741f, -0.33264777f, 0.14535570f, 0.05195946f, 0.39161670f, 
    -0.10989742f, -0.53529859f, 0.03003143f, 0.24852572f, 0.50194585f, 0.57997429f, 0.18185399f, -0.00797459f, 
    0.23485796f, 0.17564644f, -0.26228264f, 0.20361844f, -0.11542879f, 0.09141913f, 0.60752064f, 0.01549905f, 
    -0.11847101f, 0.25518802f, -0.11402000f, -0.18314065f, -0.50840616f, -0.56051165f, 0.22638242f, 0.33412191f, 
    0.04482834f, 0.22905582f, -0.03219964f, -0.38425827f, -0.29246542f, 0.44117168f, -0.09289265f, -0.41107318f, 
    -0.09620000f, 0.34071511f, 0.41379452f, -0.19086935f, -0.40915725f, 0.13930692f, 0.11217725f, -0.20021667f, 
    -0.54079205f, -0.01411388f, 0.13335693f, -0.27722797f, -0.09034558f, -0.08871473f, -1.52922571f, -0.02072410f, 
    0.04831661f, -0.76489282f, 0.15345839f, 0.50922066f, -0.10207373f, -0.43569931f, -0.09007151f, -0.08670743f, 
    0.37324825f, 0.39342627f, 0.17479703f, -0.58664852f, -0.44241667f, -0.20523463f, 0.17839466f, 0.55448806f, 
    0.12596199f, 0.23718767f, 0.28068250f, 0.00944991f, -0.95014524f, -0.38220733f, 0.15569170f, 0.48825508f, 
    0.71026129f, 0.13611124f, 0.21610095f, 0.05342168f, 0.23157160f, 0.07276287f, 0.10230748f, 0.05459405f, 
    -0.17811482f, 0.18421230f, -0.12415008f, -0.28652254f, 0.37307441f, 0.20179079f, -0.08553357f, -0.07517924f, 
    0.29879919f, -0.21037275f, -0.04220180f, 0.27934083f, -0.23130116f, 0.13813715f, 0.16495630f, 0.21777900f, 
    -0.15653831f, -0.02000106f, -0.02901554f, 0.14711300f, -0.22228652f, 0.20415731f, -0.46767235f, 0.11792333f, 
    0.54436016f, 0.20944281f, -0.40757465f, 0.51750076f, 0.36066306f, -0.54322642f, 0.01736909f, 0.34564617f, 
    0.06256460f, 0.48339391f, -0.14876729f, -0.48111981f, 0.22434184f, 0.16046777f, -0.28548905f, -0.23767805f, 
    0.22146155f, -0.36896288f, -0.14432400f, -0.73207504f, 0.38252622f, -0.19934002f, 0.32713187f, -0.05907312f, 
    0.10078985f, 0.50214690f, -0.08475579f, -0.13301201f, 0.16294962f, -0.38307178f, -0.28759012f, -0.37830007f, 
    -0.22903135f, -0.13199301f, 0.66518009f, 0.00364627f, -0.11190713f, -0.02367566f, -0.48930338f, 0.05467656f, 
    0.14532730f, -0.12130448f, -0.05928492f, 0.33795449f, 0.29138282f, -0.10457470f, 0.23110794f, -0.04111406f, 
    0.47255191f, 0.40482104f, 0.01779032f, 0.80587780f, 0.04184646f, -0.04062502f, -0.14283776f, 0.62006247f, 
    0.14669026f, -0.10379926f, 0.01537973f, 0.25384194f, -0.12688887f, -0.14309275f, -0.06550829f, -0.02808387f, 
    0.05333177f, -0.11490845f, -0.34671772f, -0.00986129f, 0.11685575f, -0.58789647f, -0.44550616f, 0.16229869f, 
    0.15041330f, -0.00796261f, -0.13939896f, 0.50191265f, 0.01802328f, 0.27966169f, -0.56443000f, -0.10850520f, 
    0.19620551f, -0.02280619f, -0.12417903f, -0.83963776f, -0.03509683f, -0.18891975f, 0.21771821f, 0.27215350f, 
    -0.06989536f, 0.04620263f, 0.27619657f, -0.02621856f, -0.19602717f, -0.23491521f, 0.41608268f, 0.35428345f, 
    -0.14370953f, -0.21030875f, -0.20525597f, -0.02292282f, -0.18783392f, -0.13977078f, 0.02190284f, -0.11236811f, 
    0.07902239f, -0.13001743f, 0.03083231f, -0.10542871f, -0.12523144f, -0.16292983f, 0.11552799f, -0.09612170f, 
    0.07870389f, -0.00123356f, -0.02068504f, 0.04290981f, -0.02334809f, -0.09985535f, 0.01400644f, 0.02111695f, 
    0.06964524f, 0.09710319f, -0.12428816f, 0.10221571f, 0.05217851f, -0.23845446f, -0.07376008f, -0.16015381f, 
    0.04306014f, 0.29390591f, -0.17392559f, -0.18171841f, 0.17164035f, -0.34336969f, -0.42597425f, 0.31798047f, 
    -0.75330526f, 0.67264962f, -0.03188739f, 0.80128658f, 0.11856557f, 0.16718967f, -0.06750681f, -0.59197122f, 
    0.42671442f, 0.21498509f, 0.05431191f, -0.06997495f, 0.25524288f, -0.69029826f, 0.11540865f, 0.16448434f, 
    -0.45499489f, -0.01530908f, 0.36543235f, 0.14875628f, 0.25880495f, -0.22568333f, 0.42199868f, -0.35130349f, 
    0.55509394f, -0.11908277f, 0.00207054f, -0.29673842f, 0.31692851f, -0.15678202f, 0.30884776f, -0.08178805f, 
    -0.18076259f, -0.37257656f, -0.00635768f, -0.87347233f, 0.12412398f, -0.13061224f, 0.82293320f, -0.09307436f, 
    -0.03815044f, 0.05108675f, 0.01892005f, 0.28913122f, 0.00564382f, 0.44548550f, 0.58421266f, -0.25873369f, 
    0.49219346f, 0.38746187f, 0.19336553f, -0.00069470f, -0.48776865f, 0.05938891f, -0.21799767f, 0.42615741f, 
    -0.23162246f, 0.04554670f, 0.48757142f, -0.25194663f, 0.24107450f, -0.55280459f, -0.17085394f, -0.29548734f, 
    0.27121010f, -0.32310399f, -0.01687112f, -0.13768429f, -0.15745465f, -0.11060124f, 0.46178627f, -0.06771745f, 
    -0.05725726f, 0.33045781f, -0.15915267f, 1.09531593f, -0.09130646f, 0.48512143f, 0.13443229f, 0.13436966f, 
    0.22883503f, -0.20744635f, -0.17681341f, 0.34748301f, 0.42659509f, 0.29929987f, -0.10155832f, 0.49739110f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.01422977f, 0.27769426f, -0.19347779f, 0.32509175f, 0.02055953f, 0.27819595f, 0.20059440f, 0.02975083f, 
    0.16822138f, 0.11657123f, -0.03225536f, 0.09277859f, -0.18552509f, 0.11723402f, 0.19616075f, 0.14072201f, 
    0.15716845f, 0.31262663f, 0.15754387f, 0.18895940f, 0.29448691f, -0.02456586f, 0.01892028f, 0.31784660f, 
    0.20124783f, 0.29330119f, 0.14068724f, 0.18060212f, -0.12996015f, 0.28271461f, -0.04379569f, -0.15004693f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.11720546f, 0.23227017f, 0.07832917f, 0.24864899f, -0.55059892f, -0.58057022f, -0.67456931f, -0.43784958f, 
    0.05702724f, -0.42522383f, -0.33608109f, 0.15907808f, -0.00627773f, 0.06066302f, -0.01521062f, -0.00258384f, 
    -0.11549342f, -1.49750507f, 0.29122999f, -0.41844845f, -0.02793794f, 0.17264040f, -0.20619063f, 0.68600357f, 
    0.01305683f, -0.31878242f, 0.01648236f, -0.25411680f, 0.03934705f, -0.88754344f, 0.12233309f, 0.28896767f, 
    -0.16613705f, 0.32586285f, -0.04115081f, 0.08618751f, -0.00172337f, -0.49563298f, -0.03932651f, -0.25989777f, 
    -0.01494791f, -0.73832345f, -0.67951775f, -0.83331996f, 0.12856592f, 0.02163944f, 0.06647282f, 0.14157796f, 
    -0.01765534f, 0.42793259f, 0.29038411f, 0.09192442f, 0.16640416f, -0.11810779f, 0.14507304f, 0.28983769f, 
    0.09406987f, 0.26479942f, -0.34979138f, 0.37297893f, -0.06874282f, -0.19356434f, -0.12833934f, -0.24186583f, 
    0.06874302f, 0.08884387f, 0.05578396f, -0.40407509f, -0.09041507f, 0.29493436f, -0.19537306f, -0.51988351f, 
    -0.77593744f, 0.39876086f, -0.15115841f, -0.39466429f, -0.03259427f, 0.03252436f, 0.00084522f, 0.04773007f, 
    -0.07751328f, -1.25517726f, -0.05317913f, -0.12330136f, 0.16359684f, 0.19807208f, 0.25842378f, 0.15281221f, 
    -0.26532462f, -0.31768447f, 0.30269232f, 0.17303742f, -0.09571641f, 0.51795483f, -1.37660658f, -0.37106130f, 
    -0.06709252f, -0.10808018f, -0.10077527f, -0.03705636f, -0.51682621f, 0.22160967f, 0.04480203f, 0.16967006f, 
    0.66136831f, 0.11187793f, 0.06770205f, 0.15943323f, -0.16700345f, -0.02844450f, 0.15993811f, -0.03018669f, 
    0.01708310f, -1.00810850f, 0.21782620f, -0.52701241f, -0.43413502f, 0.23726833f, -1.05559933f, -0.79088759f, 
    0.16050060f, -0.15060946f, 0.25732991f, -0.45378372f, -0.16571000f, -0.11839162f, -0.15184061f, 0.09142543f, 
    0.05369474f, -0.09434813f, -0.10567087f, -0.09684727f, 0.28356448f, 0.05701252f, -0.22515129f, -0.13908552f, 
    -0.57584143f, 0.06339747f, -0.98710901f, 0.14384575f, 0.12785405f, 0.09505879f, 0.18703017f, -0.23482984f, 
    -0.49416605f, -0.78232330f, -0.02021094f, -0.01172729f, -0.88668269f, 0.06195984f, 0.05359532f, -0.79665381f, 
    0.27546075f, -0.18734162f, 0.23923580f, -0.08868618f, -0.03750652f, -0.17914462f, 0.29751879f, 0.07515334f, 
    0.02123698f, 0.07538699f, -0.04050369f, -0.01467357f, 0.12221008f, -0.13198432f, 0.06440476f, 0.05132023f, 
    0.01077250f, -0.11536521f, 0.03956261f, -0.48706636f, -0.07612530f, 0.24226728f, -0.11636380f, 0.16412011f, 
    -0.30312464f, -0.02310984f, 0.10223289f, -0.11237892f, 0.09753151f, 0.05565422f, -0.08337336f, -0.62312639f, 
    -0.01066386f, 0.01060114f, 0.00933128f, 0.13498163f, 0.00733233f, 0.21206371f, -0.07814401f, 0.01022422f, 
    -0.05445645f, -1.26308692f, -0.12434203f, -0.06294397f, 0.20458511f, 0.29839882f, -0.71705627f, 0.10164577f, 
    -0.13897261f, 0.31609222f, -0.10901287f, -0.03716014f, -0.19419625f, -1.08536243f, -1.13364947f, -0.08731676f, 
    0.36768401f, -0.05591682f, -0.93679655f, 0.11345115f, 0.36091754f, -0.29978907f, -0.02141724f, 0.47744450f, 
    -1.46427011f, -1.06236613f, 0.18229116f, 0.28213778f, 0.00552068f, 0.18265134f, -0.71341997f, -0.48682240f, 
    -0.02215173f, -0.21041159f, 0.06870302f, 0.12514210f, 0.05481713f, -0.92420840f, 0.26204649f, 0.20030937f, 
    0.12699454f, -0.28706998f, 0.26248702f, 0.41040397f, -0.03231774f, -1.40427637f, 0.10140614f, -0.07071300f, 
    -0.29755837f, -0.46083802f, -0.70918989f, 0.09860827f, -0.11374456f, -0.17849915f, -0.06859235f, -0.53423882f, 
    -0.15310547f, 0.09004282f, -0.38080525f, -1.23386633f, -0.08338336f, -0.47988027f, 0.46580264f, 0.24001019f, 
    0.04324504f, 0.19271229f, 0.09715552f, -0.18333478f, -0.19679925f, 0.23162837f, 0.38414186f, 0.24528603f, 
    0.48088473f, -0.11799265f, 0.28849533f, -0.69719899f, 0.06272577f, -0.40559837f, 0.05084832f, 0.07009099f, 
    -0.06694644f, -0.13870320f, -0.67739028f, 0.17734869f, 0.17721948f, -0.49646303f, 0.13188790f, -0.70849568f, 
    -0.42265525f, 0.35166305f, -0.57748419f, -0.01478976f, -0.02004382f, 0.17003492f, -0.37053239f, -1.03312540f, 
    -0.01500541f, -0.09569636f, 0.04258903f, 0.27751231f, -0.09641922f, 0.26913270f, -0.49178565f, 0.00012058f, 
    -0.43118659f, -0.11558088f, -0.09960316f, 0.07314613f, -0.10653279f, 0.05498228f, -0.19866940f, -0.06274591f, 
    0.07117945f, -0.25417277f, -0.45144370f, -0.23056991f, 0.07266381f, -0.01516427f, -0.69804460f, 0.23310387f, 
    -0.40163869f, -0.59133899f, 0.39062765f, -0.19575669f, -0.12425581f, 0.01655719f, -0.35700694f, 0.43004233f, 
    0.13270515f, -0.09449545f, -0.16345693f, -0.28839779f, 0.00619886f, -0.39447945f, 0.02233087f, 0.29000148f, 
    -0.32931677f, 0.11486574f, 0.12001611f, 0.00170552f, -0.00113021f, 0.01861943f, 0.36841410f, -1.17871809f, 
    -0.80112320f, -1.04438233f, -0.01716814f, -0.08425112f, 0.12916633f, -0.97522789f, -0.90143549f, 0.19284883f, 
    0.06690048f, 0.58825028f, -0.01275359f, -0.14277455f, -0.15587120f, -0.15899736f, 0.29159251f, -0.23766907f, 
    -0.15926515f, -0.43136472f, -0.09967759f, -0.80613476f, 0.17515165f, 0.15812330f, 0.02410890f, 0.16539873f, 
    0.16587144f, 0.38487586f, 0.18148081f, -0.01833243f, -0.07294931f, -0.41195694f, -0.26048070f, -0.11958492f, 
    0.24177815f, 0.19577031f, -0.37940386f, 0.10609836f, 0.10916677f, -0.35631198f, 0.31521952f, -0.10548683f, 
    -0.06178908f, -0.19289096f, -0.19025099f, -0.32799429f, -0.04897649f, 0.11862896f, -0.07288118f, -0.37601054f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.27824157f, 0.30765566f, 0.01617206f, 0.10879054f, -0.02705735f, -0.27876642f, -0.18333691f, -0.38766015f, 
    -0.21325170f, 0.39079538f, 0.01348227f, -0.16250323f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
