#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.59789687f, 0.49187985f, 0.29601991f, -0.22379032f, 0.41765189f, 0.56857038f, 0.54850513f, 0.43142027f, 
    -0.70626932f, 0.35262182f, -0.40553701f, 0.56314272f, 0.59438711f, -0.88653946f, 0.00902230f, 0.07238950f, 
    -0.42083725f, 0.46258882f, -1.11840999f, -0.72154093f, -0.71303695f, 0.48532993f, -0.05420822f, -0.95465863f, 
    -0.62176567f, -0.64715773f, -0.27778098f, 0.84196621f, 0.24207610f, 0.81595123f, -0.90504730f, -0.51085091f, 
    -0.43613014f, 0.42949986f, -0.03048285f, 0.45329481f, -0.06895266f, -0.95118088f, -1.29909396f, 0.64997882f, 
    1.30656028f, 0.14036211f, -0.18225014f, 0.12267824f, -0.00636796f, 0.45292673f, 0.45224494f, 0.41852424f, 
    0.00485925f, -0.71544147f, -0.54861730f, 0.20731218f, 0.41979256f, 0.52551264f, -0.22941163f, -0.69611543f, 
    -0.64722043f, -0.82559264f, 0.99080741f, -0.01965985f, 0.64748901f, -0.11626270f, -0.45171237f, -0.51859510f, 
    -0.45915326f, 0.04051441f, 0.53641409f, 0.81215280f, 0.89978850f, 0.29789916f, -0.20104788f, -0.27309430f, 
    1.03636670f, -1.25102866f, -0.58973378f, -0.74461973f, -0.18333663f, -0.25108877f, -0.38513467f, -0.37244269f, 
    -0.53793532f, 0.81112140f, 0.01786287f, -0.06462874f, -0.06819154f, 0.44977459f, -0.28691527f, 0.41180763f, 
    -0.24113062f, -0.71491230f, 0.01325670f, 0.30404305f, -1.05045164f, -0.50616866f, 0.46919343f, -1.18235731f, 
    -0.49454665f, -0.31586906f, -0.35428223f, -1.00047231f, 0.39575300f, 0.39691770f, -1.03261507f, -1.08005714f, 
    -0.55626351f, 0.55893511f, 0.09721881f, 0.05018443f, 0.33818424f, 0.56937009f, -0.36646661f, -0.17461157f, 
    0.69031328f, -0.44946387f, 0.09920114f, -0.45597804f, 0.63786834f, -0.18144865f, -0.03759985f, 0.09495427f, 
    -0.59843707f, -0.18507215f, 0.39723325f, -0.71988046f, -0.06601580f, 1.10433590f, -0.96456140f, 1.71842873f, 
    -1.05919278f, -0.00059147f, 0.13932210f, -0.14362437f, -0.16902840f, 0.24721979f, 0.29256552f, 0.37514031f, 
    -0.61693746f, -0.86985791f, -0.36977097f, -0.01475726f, -0.05024891f, 0.78850281f, 0.59943360f, 0.10523063f, 
    0.01634405f, -0.24104975f, -0.34374410f, -0.58929765f, -0.07540673f, 0.28888956f, 0.10857674f, 0.14785634f, 
    0.67065835f, 0.14718042f, 0.80623281f, 0.72173929f, -0.88490754f, -0.56608301f, -0.92742777f, -0.31650555f, 
    -0.44462317f, -0.67498207f, 0.94007903f, -0.34079006f, -0.07026637f, -0.03304342f, 0.58123726f, -0.02741214f, 
    -0.72006291f, 1.28374088f, -0.66123480f, 0.01209469f, -0.32583386f, 0.19497989f, -0.00685743f, 0.29715464f, 
    0.21860492f, 0.28798181f, -0.25023541f, 0.59069258f, 0.11514546f, 0.34751621f, 0.28372094f, -0.70114619f, 
    0.59527016f, -0.12180523f, 0.33900771f, 0.35669252f, 0.64027429f, -0.89632636f, -0.28879955f, -0.04871424f, 
    -0.49562255f, 0.17649780f, -0.52914846f, 0.29028469f, 0.31407267f, 0.85350531f, -1.44837093f, -0.31198224f, 
    0.10776385f, 0.84413171f, -0.06479909f, 0.47563022f, 0.53585899f, 0.05460836f, 0.00833328f, 0.14514743f, 
    0.09433758f, -0.07440336f, 0.84117407f, 0.41469449f, 0.46123761f, -0.49241614f, -0.59735394f, -0.64135367f, 
    -0.89024520f, -1.12169957f, -0.90439719f, -0.12943409f, -0.88786018f, 1.12529516f, 0.21141051f, -0.06544176f, 
    -0.10376368f, 0.46744168f, 0.73285431f, -1.05860186f, 0.15198414f, -0.17022286f, 0.61991674f, -0.07170734f, 
    -0.11858905f, 0.10844588f, -0.03650206f, 0.70265293f, -0.49900407f, 0.50925690f, -0.10611604f, 0.32423970f, 
    0.34808716f, 0.21194685f, 0.14532319f, -0.75044841f, 0.19836676f, 1.03904164f, 0.36248928f, -0.43834281f, 
    -0.48306000f, -0.78866661f, -0.32433107f, -0.54651421f, -0.73208416f, -0.32378128f, -0.04770585f, -0.22879784f, 
    0.15052623f, 0.75343186f, -0.21719311f, -0.24936754f, 0.67637980f, -0.09930654f, -0.36815321f, -0.44685540f, 
    -1.03669631f, -0.67900354f, -1.02396524f, 0.27308124f, 0.07343999f, 0.72377145f, -0.73802418f, 0.22372442f, 
    0.58889800f, 0.43517226f, 0.52738929f, 0.38339940f, 0.27399534f, 0.55506152f, 0.17887901f, -0.95225084f, 
    0.77502811f, 0.80600667f, -0.67832536f, 0.13027592f, 0.93492478f, 0.14239696f, -0.84464699f, -0.23782888f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.14352965f, 0.16751693f, -0.12801573f, 0.40351900f, -0.00129115f, 0.35171989f, 0.45048103f, -0.05228848f, 
    -0.06805626f, 0.23296095f, 0.27678487f, 0.56727564f, 0.54730070f, -0.00024608f, 0.10382862f, 0.59271187f, 
    0.53160185f, -0.30041471f, 0.08883779f, 0.47525820f, -0.14694199f, -0.37479439f, -0.21754362f, 0.02241689f, 
    -0.06491367f, 0.31722325f, -0.22863220f, -0.20128125f, -0.27694750f, -0.24779452f, -0.08791590f, 0.17046349f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.18762973f, 0.22227988f, -0.03366182f, -0.16644055f, -0.19915020f, -0.05208298f, 0.14097521f, 0.01680558f, 
    0.19551526f, -0.26368305f, -0.39223737f, 0.15710267f, 0.09463818f, 0.02932191f, -0.26011834f, 0.20583668f, 
    0.08621044f, 0.06019586f, -0.30844146f, -0.06903742f, 0.00419251f, -0.00712664f, -0.19387671f, 0.10132901f, 
    0.04893616f, 0.12176517f, 0.02404905f, 0.01761403f, -0.38821185f, -0.04488887f, 0.07585026f, 0.11824692f, 
    -0.03477437f, -0.06122651f, 0.11299087f, 0.16264141f, -0.30324623f, 0.11646565f, 0.32767892f, 0.16937122f, 
    0.06375822f, 0.18339324f, -0.41064018f, -0.13088721f, 0.07209828f, -0.25031590f, -0.05679299f, 0.09308472f, 
    -0.03594238f, 0.08996505f, -0.10195894f, 0.23182669f, -0.04246110f, 0.08940918f, -0.04879259f, -0.05190853f, 
    0.40522760f, -0.05105589f, 0.07302493f, 0.05887600f, -0.16746080f, 0.06639110f, 0.19457689f, 0.03875852f, 
    -0.20849749f, -0.16527161f, 0.17154287f, 0.08157815f, 0.09238254f, -0.01233519f, -0.07174119f, -0.13097435f, 
    -0.03951411f, -0.01239342f, 0.08387172f, -0.19519761f, -0.02192024f, 0.07577405f, -0.07061213f, 0.14580226f, 
    0.01381217f, -0.57690209f, 0.33161831f, -0.09080046f, -0.07896068f, -0.17150997f, -0.26214290f, 0.10845900f, 
    -0.08797263f, -0.02834935f, 0.28255513f, 0.00672052f, 0.28909281f, -0.05122660f, 0.07323119f, 0.02689937f, 
    0.08487358f, 0.20486587f, 0.19763872f, 0.52826560f, -0.04872445f, 0.02621163f, 0.04226682f, -0.01698280f, 
    0.01526540f, -0.01867137f, 0.03145427f, 0.10914453f, -0.23825341f, 0.18487997f, -0.02254733f, 0.02981012f, 
    -0.01925387f, -0.19516797f, 0.09667827f, 0.15666595f, 0.20350884f, 0.20389681f, -0.12463799f, -0.17003189f, 
    0.07125007f, -0.11024547f, -0.28063077f, 0.09613155f, 0.37714002f, 0.09684785f, 0.15240125f, -0.04889574f, 
    0.10024657f, -0.02283791f, 0.05963568f, -0.10336047f, -0.18852714f, -0.05417164f, -0.01469013f, -0.17318554f, 
    -0.13046101f, 0.23333460f, 0.02255034f, 0.03169233f, 0.24353248f, -0.08100188f, 0.01554488f, 0.14744025f, 
    0.02066636f, -0.09497283f, -0.01682688f, 0.08830129f, -0.02647870f, 0.05440302f, 0.07263938f, 0.17026302f, 
    0.20382071f, 0.03111592f, -0.40925726f, 0.38116482f, -0.32403824f, -0.03963616f, -0.31461906f, -0.13469677f, 
    0.08884566f, -0.01833137f, -0.60940886f, -0.01865921f, 0.03265801f, 0.05161296f, -0.03230329f, -0.01350641f, 
    0.11822084f, 0.13890427f, 0.36324075f, 0.02622292f, 0.03899942f, -0.10988323f, 0.08408339f, -0.05635051f, 
    -0.11748421f, 0.16153979f, 0.05776091f, 0.22315620f, 0.02373063f, 0.06498268f, -0.15157953f, -0.20007718f, 
    -0.05237659f, 0.06751213f, 0.18770640f, 0.35446012f, 0.18160219f, -0.04490051f, -0.37345141f, 0.06284125f, 
    0.05367869f, 0.11436856f, -0.02445210f, -0.15153298f, 0.04148951f, -0.04755657f, -0.01604460f, -0.17841272f, 
    -0.44247144f, 0.32681125f, -0.02371314f, 0.12177082f, 0.10960153f, 0.02248980f, 0.09735187f, -0.03435539f, 
    0.07556927f, 0.20346123f, -0.25948772f, -0.03396977f, 0.01770271f, -0.07908901f, 0.09311028f, -0.15083854f, 
    -0.18962747f, -0.46208793f, 0.01682970f, 0.21602970f, -0.19204657f, -0.01264241f, -0.08658462f, 0.01519403f, 
    0.01408135f, 0.32369781f, -0.09849302f, 0.01425253f, -0.05160839f, 0.11362303f, -0.01141441f, 0.08007892f, 
    -0.02979247f, -0.05945784f, -0.13303867f, 0.05808146f, -0.02871400f, -0.04642856f, 0.02954793f, -0.29848930f, 
    0.23189470f, 0.10737719f, 0.06777988f, 0.17893751f, 0.24656563f, 0.33385885f, -0.24559554f, -0.06575590f, 
    -0.13569610f, -0.10767930f, 0.09833026f, -0.04280029f, 0.34090871f, -0.96690214f, -0.17769378f, 0.16528875f, 
    -0.13242950f, -0.24137591f, -0.06567498f, -0.21261171f, 0.02800398f, 0.05532904f, -0.20493443f, 0.25653857f, 
    0.01145542f, 0.06887855f, -0.04620745f, -0.26343745f, 0.13867004f, -0.00701577f, 0.08147651f, 0.03904686f, 
    -0.05044408f, -0.09890405f, -0.17106451f, -0.01410335f, 0.18250528f, 0.09465393f, 0.10920930f, 0.77227861f, 
    0.16446865f, -0.38827336f, -0.14370640f, -0.11048308f, -0.00475144f, -0.34284803f, 0.01974775f, 0.07829925f, 
    0.04358879f, -0.00953340f, 0.16097493f, -0.25002041f, 0.17804325f, 0.01820287f, -0.10379806f, -0.11374618f, 
    0.07931873f, -0.18412046f, -0.18292734f, 0.18186140f, 0.00697582f, 0.06517737f, 0.10036739f, 0.17674743f, 
    0.17669007f, -0.06411698f, 0.43352452f, 0.32284197f, -0.40602604f, -0.05805051f, 0.08196625f, -0.03812575f, 
    0.06547651f, 0.03154846f, -0.06588107f, -0.21651955f, 0.01097994f, 0.16541018f, -0.08702429f, 0.02449861f, 
    0.01453496f, -0.05059025f, 0.18365310f, -0.02891478f, 0.38641354f, -0.11528827f, -0.19952875f, 0.03573303f, 
    0.08719750f, -0.28993151f, 0.01394789f, -0.13287894f, -0.09407599f, -0.17772064f, -0.03419919f, 0.05076173f, 
    -0.19134395f, -0.00277210f, -0.03347119f, 0.17364153f, 0.20094536f, 0.04766088f, 0.37054509f, -0.12627254f, 
    -0.03352834f, -0.14358161f, 0.00592860f, -0.06084260f, -0.06322279f, 0.01951119f, 0.05470457f, 0.00912922f, 
    -0.05575520f, 0.23698200f, -0.07568727f, 0.06746870f, -0.16614829f, -0.09675693f, -0.14978455f, -0.14445506f, 
    0.26062658f, 0.25557655f, -0.07381269f, 0.01991564f, 0.01456102f, -0.09753607f, -0.16639875f, -0.12736104f, 
    -0.06975602f, -0.04983520f, -0.06544796f, 0.09115320f, -0.10755780f, 0.02529613f, 0.04163697f, -0.28993487f, 
    -0.30811203f, -0.17957041f, 0.16953191f, 0.19225346f, -0.00210061f, 0.05232330f, -0.01085144f, -0.13722442f, 
    0.01498575f, 0.08460202f, -0.11056098f, 0.21466455f, 0.26284161f, -0.19699346f, -0.03913523f, 0.03991638f, 
    0.01287425f, 0.04832375f, -0.01743377f, -0.27609962f, -0.17178135f, -0.31970844f, 0.31541821f, -0.16849257f, 
    -0.00022851f, 0.03661961f, -0.10102025f, 0.23798704f, 0.15462625f, 0.55326623f, 0.10274900f, 0.73600060f, 
    0.12134208f, 0.12605906f, -0.17864425f, 0.19710025f, -0.01764569f, 0.28652245f, 0.07239130f, -0.14253926f, 
    0.64437419f, -0.23855823f, -0.13168664f, 0.35433954f, 0.21780075f, 0.30569610f, 0.01884642f, 0.07318324f, 
    -0.03832190f, -0.41530213f, -0.07985575f, 0.01618045f, -0.02159329f, -0.06315511f, 0.03080462f, 0.11717229f, 
    0.09071753f, 0.08016933f, 0.13391407f, 0.03849901f, -0.06829527f, -0.11264257f, 0.01672633f, 0.04078265f, 
    0.14072709f, -0.38482049f, -0.05895616f, -0.13886136f, 0.09686031f, 0.00612464f, 0.06663711f, -0.13245988f, 
    -0.02489316f, -0.44975734f, -0.06699547f, -0.21999623f, 0.42404467f, 0.17122197f, 0.37937197f, -0.09996413f, 
    -0.03690999f, -0.20759799f, -0.15388364f, -0.12903589f, -0.00085207f, 0.17926078f, -0.12181786f, -0.07398486f, 
    -0.13620572f, -0.00707420f, 0.04626238f, 0.00711506f, 0.02100218f, 0.11699484f, 0.27489918f, -0.48006499f, 
    0.30095932f, -0.02313732f, 0.04392074f, 0.24407144f, 0.18869646f, 0.51520371f, 0.16601716f, 0.04235805f, 
    0.07666989f, 0.00955731f, -0.01324069f, 0.09770730f, 0.12115470f, 0.12026668f, 0.13297260f, -0.01524482f, 
    0.14537847f, 0.16956319f, 0.33287525f, -0.17584336f, -0.04146279f, -0.00909117f, -0.00788422f, -0.07037398f, 
    -0.03150171f, -0.00708068f, 0.28638455f, -0.00273171f, -0.02330052f, -0.21880408f, -0.40794638f, -0.64503133f, 
    0.58826315f, 0.08310119f, 0.08115686f, 0.12782957f, 0.04582766f, -0.10737736f, 0.02715494f, 0.03182602f, 
    -0.00072782f, 0.04352732f, 0.03249154f, 0.09772084f, 0.13568242f, -0.11598689f, -0.09708170f, -0.14945313f, 
    0.01945516f, 0.07340750f, 0.12769203f, 0.06357016f, 0.14827129f, 0.00289894f, -0.15389195f, 0.05657012f, 
    -0.01365000f, 0.19440779f, 0.17155583f, -0.09930606f, 0.12113351f, -0.11733332f, 0.09186406f, -0.10806415f, 
    0.12482787f, -0.42583311f, -0.17478096f, -0.45320708f, 0.22151083f, 0.16083089f, 0.44408867f, 0.27394173f, 
    -0.00715356f, -0.46845996f, 0.03410967f, 0.04672540f, 0.09306227f, 0.42258579f, 0.19648865f, -0.06216207f, 
    0.08775975f, 0.06094576f, 0.03690372f, 0.04815670f, -0.09288947f, 0.02707791f, 0.02539607f, 0.10878560f, 
    0.12521242f, -0.03366176f, 0.11437656f, -0.01081498f, -0.04450202f, 0.01188803f, 0.01153947f, -0.01687491f, 
    -0.03481641f, 0.35723412f, 0.14007735f, -0.26684409f, 0.13964291f, -0.11114640f, -0.02009061f, -0.38610762f, 
    0.13595751f, -0.00960755f, -0.04374082f, 0.20845219f, -0.00022458f, 0.02352521f, 0.10819490f, 0.19555491f, 
    0.04054089f, 0.00580899f, -0.17578256f, -0.30960849f, 0.02353086f, 0.09173339f, 0.21181628f, 0.06027593f, 
    0.16462047f, 0.15866025f, -0.24595384f, -0.03547533f, 0.23824641f, -0.06752320f, -0.03703353f, -0.11854571f, 
    -0.05309473f, -0.13077189f, 0.08402581f, -0.14041840f, 0.07177165f, -0.11245971f, 0.19147713f, 0.01976473f, 
    0.11656545f, 0.00448968f, -0.00815247f, -0.01185105f, -0.26450619f, 0.21612357f, 0.45846823f, -0.13743216f, 
    -0.16096008f, -0.09426267f, -0.05051387f, 0.12020237f, 0.40762401f, -0.03017872f, 0.11460265f, -0.09783848f, 
    0.10704904f, 0.14632639f, 0.07731602f, -0.01903231f, -0.12774269f, -0.21263230f, -0.08668553f, -0.01270226f, 
    0.21331447f, -0.06715830f, 0.05019179f, 0.01421269f, 0.08987594f, 0.18221635f, 0.05355412f, 0.30755809f, 
    0.30499509f, 0.03530651f, 0.05842403f, 0.04228725f, 0.16306025f, -0.24740165f, -0.14046548f, -0.00127851f, 
    -0.28791308f, 0.18535005f, 0.19120145f, 0.09978221f, 0.13356295f, 0.05893712f, -0.07620822f, -0.09357748f, 
    0.19543780f, -0.28509876f, -0.26777980f, -0.23501109f, 0.12209935f, -0.07671747f, 0.19417983f, 0.20499708f, 
    0.07880775f, 0.29918155f, -0.22689155f, 0.10256395f, 0.25047103f, 0.08398356f, 0.07981445f, -0.09682146f, 
    -0.00449144f, -0.00100504f, 0.16718371f, 0.26680669f, 0.07030801f, -0.00914399f, -0.05159685f, -0.25669003f, 
    -0.01708463f, -0.10152792f, -0.20796102f, -0.28929511f, -0.08144025f, -0.03799943f, -0.15343525f, 0.11443729f, 
    -0.00990597f, -0.07994866f, 0.02529969f, -0.02803641f, 0.13286787f, -0.54210538f, 0.00517674f, -0.28216133f, 
    -0.18121438f, 0.04161187f, 0.05729107f, -0.19791932f, -0.49615154f, -0.32816768f, 0.26353043f, 0.20473817f, 
    -0.23914742f, -0.03099604f, -0.10541841f, 0.02574808f, -0.11798552f, -0.03849085f, 0.11077751f, 0.06681048f, 
    -0.01406473f, 0.28688896f, 0.17125970f, 0.09349169f, -0.00354450f, 0.33372086f, -0.20359255f, -0.08907522f, 
    -0.07951412f, 0.01971118f, 0.02940555f, -0.01130663f, 0.14766586f, 0.04409095f, -0.06677030f, -0.17133160f, 
    -0.41342637f, 0.22462210f, -0.19823550f, 0.06037723f, -0.04679841f, -0.00126064f, 0.15009056f, 0.05379068f, 
    0.08311107f, 0.00999850f, -0.13694650f, -0.15575132f, -0.02496636f, 0.15277152f, 0.02128300f, 0.04437977f, 
    0.16961549f, 0.24868993f, 0.21864691f, -0.03158391f, -0.07543195f, -0.00076821f, 0.08489902f, 0.08378390f, 
    0.14727369f, -0.09905180f, -0.04521959f, -0.24537212f, 0.04152397f, -0.03553318f, 0.06753366f, -0.01473414f, 
    0.15834470f, 0.12745602f, -0.06596670f, -0.23459502f, -0.19676296f, 0.00393969f, -0.04815174f, 0.16824310f, 
    0.14391069f, 0.03473960f, -0.13102989f, 0.23884761f, 0.00923239f, -0.16515164f, 0.33443132f, -0.24149884f, 
    0.12168321f, 0.12904191f, -0.09411079f, -0.07005216f, 0.25932246f, 0.00937036f, 0.07898273f, 0.09037498f, 
    0.01211894f, -0.40024874f, 0.15968016f, 0.22558479f, 0.19087496f, 0.03889008f, -0.01670015f, 0.09286527f, 
    -0.02461503f, -0.03044246f, 0.27680182f, 0.10211059f, 0.02837333f, 0.05062447f, -0.02347384f, 0.07929656f, 
    0.13752960f, 0.02269682f, 0.11398025f, -0.38965893f, -0.08062814f, -0.05236153f, -0.03039476f, 0.14733763f, 
    0.16639870f, 0.05154774f, 0.11902228f, 0.10450358f, 0.04626921f, 0.10635225f, -0.09292003f, 0.11918899f, 
    0.01687908f, -0.29593599f, -0.30877385f, 0.31096134f, 0.04735569f, 0.02164547f, 0.01429758f, 0.01110469f, 
    0.05686479f, 0.04410208f, 0.10311851f, 0.11789088f, -0.13625364f, 0.08503037f, 0.05494408f, -0.15818912f, 
    -0.01074705f, -0.00928615f, -0.15706536f, 0.22329310f, 0.01571516f, 0.08378526f, 0.15225503f, 0.34768450f, 
    0.18549119f, 0.09088367f, 0.00050438f, 0.02084948f, -0.28621879f, -0.17361695f, 0.11715589f, 0.05263108f, 
    -0.00722998f, 0.02071620f, 0.08371726f, 0.08883059f, -0.13507913f, -0.04879421f, -0.24867341f, -0.09583006f, 
    -0.10751276f, -0.82943106f, 0.02843809f, 0.11850484f, 0.14358638f, 0.05751996f, 0.19622335f, 0.01501299f, 
    0.05988403f, 0.02904451f, 0.00728466f, 0.02596154f, 0.04826531f, -0.01903752f, -0.05681265f, -0.02964851f, 
    -0.01827768f, -0.01049721f, -0.06411932f, -0.02024263f, 0.04496550f, -0.00717390f, -0.03709589f, 0.01480192f, 
    0.01292547f, 0.02123868f, -0.06112237f, 0.01724769f, 0.00837354f, -0.01991855f, -0.00569106f, -0.06320511f, 
    0.02471743f, 0.02202123f, -0.03551779f, -0.03638969f, 0.04168130f, -0.03214468f, -0.02566154f, 0.00554257f, 
    -0.00470705f, -0.02580623f, -0.06581659f, -0.02406858f, -0.04449782f, -0.03949272f, -0.01657178f, 0.03973947f, 
    -0.04731993f, -0.05824048f, 0.01241820f, 0.03010338f, -0.03359304f, 0.06022499f, -0.03813330f, -0.02513723f, 
    -0.05354049f, 0.05567962f, -0.05201175f, -0.00829923f, -0.03335879f, 0.00195398f, -0.04810962f, 0.04302490f, 
    -0.00421906f, 0.03794966f, -0.01963933f, 0.02225351f, -0.03861813f, -0.03837578f, 0.02168187f, 0.01319784f, 
    -0.00544675f, 0.02144994f, -0.00928974f, -0.04520743f, 0.02082654f, 0.01941188f, -0.06195347f, -0.00331096f, 
    -0.02230381f, -0.04045117f, -0.04788244f, 0.04698382f, -0.01785350f, 0.01792584f, -0.03767810f, 0.00540839f, 
    -0.00108147f, -0.00147786f, 0.03155106f, 0.00197933f, -0.03816998f, 0.03881032f, 0.00972336f, -0.05221448f, 
    0.03096076f, -0.05575675f, 0.00639833f, 0.03735927f, -0.04685194f, -0.01341327f, -0.00879860f, -0.05761944f, 
    0.02497566f, 0.03710821f, 0.02725834f, 0.04528222f, -0.02529823f, -0.01380801f, -0.03068479f, -0.03800580f, 
    0.02066580f, 0.03002330f, -0.06209597f, -0.04644744f, -0.03861180f, -0.04287391f, 0.00332393f, 0.03166396f, 
    0.02547103f, 0.00439992f, -0.01167158f, -0.05623320f, -0.04820315f, -0.01669941f, -0.05321430f, 0.00179319f, 
    -0.02133883f, 0.00026213f, -0.06350744f, -0.00356663f, 0.00648604f, -0.03788036f, -0.02159629f, -0.06378381f, 
    0.00330194f, -0.00297170f, -0.03205713f, -0.04513399f, 0.04997227f, 0.04078992f, -0.05133295f, -0.05310824f, 
    0.00357456f, -0.02023761f, 0.02351259f, -0.05038886f, 0.00017220f, 0.01152167f, 0.01788095f, -0.01059750f, 
    -0.02483004f, 0.04357408f, -0.03181559f, 0.00654775f, 0.00519837f, 0.03824767f, 0.03313017f, -0.00657389f, 
    -0.02082738f, -0.05022782f, -0.02182812f, 0.03804553f, -0.03507623f, 0.00498673f, -0.02954155f, -0.00787662f, 
    0.00332728f, 0.03436550f, -0.04637980f, 0.02371189f, -0.00263654f, 0.05914333f, 0.00537895f, -0.05184293f, 
    0.03537572f, -0.01212266f, -0.04268298f, 0.03837360f, -0.05015989f, -0.03790291f, -0.06563429f, 0.02217164f, 
    0.03927714f, -0.05329335f, -0.04776442f, 0.03739617f, 0.00144857f, -0.00472705f, 0.05705617f, -0.04269419f, 
    -0.02638681f, -0.00612453f, -0.04865082f, -0.04015825f, -0.02968541f, 0.03228584f, -0.01879765f, 0.00976590f, 
    0.04011464f, -0.00031407f, 0.00080321f, 0.03987744f, -0.01991641f, 0.02103788f, -0.03912806f, 0.00231145f, 
    -0.05922192f, 0.01844965f, -0.01074843f, 0.03726724f, -0.04085805f, 0.04406748f, 0.02067586f, 0.01048642f, 
    0.04750637f, 0.02360021f, -0.01261946f, 0.02652972f, -0.05521853f, -0.04729916f, -0.03519282f, -0.00195022f, 
    -0.03453961f, -0.03072072f, 0.04533224f, -0.03814727f, 0.01306194f, 0.00221611f, -0.04619341f, -0.02237452f, 
    -0.01756169f, 0.05035376f, -0.03263390f, 0.03182482f, 0.04906965f, -0.06289859f, 0.05453734f, 0.04797886f, 
    -0.04765075f, -0.00199415f, -0.02486845f, 0.03787366f, -0.03120267f, -0.02285424f, -0.03609404f, -0.05274753f, 
    -0.00056494f, -0.02975303f, 0.02131557f, 0.01722981f, -0.06025821f, -0.01135484f, -0.01656269f, -0.02413424f, 
    0.03742151f, 0.04759028f, 0.00720792f, -0.02735283f, -0.04643058f, -0.00597625f, -0.05747060f, 0.01096859f, 
    0.02800269f, -0.01758881f, 0.04168441f, 0.03477027f, 0.01756687f, -0.01610931f, -0.04201761f, 0.01172001f, 
    -0.00035914f, -0.05617906f, 0.02606903f, -0.01371917f, 0.04735349f, -0.01173427f, -0.00986314f, -0.02936174f, 
    0.02393540f, 0.00151085f, 0.01536873f, -0.05962298f, -0.02627749f, -0.04024836f, 0.05675844f, -0.02998691f, 
    -0.02562273f, 0.02746898f, -0.03003995f, -0.05466164f, -0.00866174f, -0.00643640f, 0.02799303f, 0.01777411f, 
    -0.43063241f, -0.43145534f, 0.01021776f, -0.13819590f, 0.04017426f, -0.03142650f, 0.07398033f, 0.11913594f, 
    -0.07824011f, -0.58689088f, -0.27535534f, -0.80425215f, 0.02299899f, 0.22662041f, 0.12187392f, -0.00065132f, 
    0.04236992f, -0.04788392f, 0.10566668f, 0.33462396f, 0.63179469f, 0.10077576f, 0.16234569f, -0.10608099f, 
    0.18287982f, 0.05945706f, 0.13296863f, -0.23213159f, -0.26374656f, -0.10542003f, -0.02304383f, -0.18919820f, 
    -0.16421330f, -0.00363812f, -0.11039129f, 0.07214662f, -0.09055914f, -0.24833567f, 0.60911769f, 0.00833009f, 
    0.11899428f, -0.28352132f, 0.23953149f, 0.16824253f, 0.00803772f, -0.32118142f, -0.23632562f, -0.08797535f, 
    -0.22957522f, -0.16750138f, -0.13705213f, -0.01484241f, -0.10357412f, 0.11531644f, -0.04430309f, 0.15165862f, 
    0.46626505f, 0.11030108f, 0.02725081f, 0.15607075f, 0.22975050f, -0.03107073f, -0.26211035f, -0.26321018f, 
    -0.32276195f, 0.14442587f, 0.05009576f, -0.11686637f, -0.05300087f, 0.20756952f, 0.11519383f, -0.09016461f, 
    0.29547444f, 0.35597923f, 0.10336279f, 0.14882793f, -0.04382419f, -0.35622030f, 0.30767319f, -0.05482113f, 
    -0.15770513f, 0.05104860f, -0.11688002f, -0.22737393f, 0.03990758f, -0.12683149f, -0.09946277f, 0.04123772f, 
    0.03225330f, 0.17026265f, 0.02384090f, 0.16669579f, 0.17683735f, -0.02327217f, 0.04927383f, 0.08580670f, 
    0.18327476f, 0.10526367f, -0.11573458f, -0.12156892f, 0.08387253f, 0.04479644f, 0.07657319f, -0.05096963f, 
    0.19489144f, 0.10760479f, 0.01716906f, 0.16067225f, -0.20161635f, -0.24200177f, -0.16871342f, -0.07034132f, 
    0.05918435f, 0.15526581f, -0.01042841f, 0.05865590f, 0.28440669f, -0.00120445f, -0.01426839f, -0.15137626f, 
    -0.03105298f, 0.09328031f, 0.19668117f, 0.10229158f, -0.04345959f, 0.14699169f, -0.13612214f, -0.27393007f, 
    -0.31843251f, 0.10042033f, 0.04930592f, 0.17395471f, 0.00070394f, 0.11150006f, -0.10252585f, -0.02556076f, 
    -0.17855851f, 0.14843968f, 0.01351268f, 0.21116662f, 0.15208460f, 0.00176041f, -0.08658650f, -0.01665992f, 
    0.05935948f, -0.03910503f, 0.14309031f, 0.13320041f, 0.36043784f, 0.03326773f, -0.07939336f, -0.06608960f, 
    0.04971546f, -0.47458255f, -0.66401070f, -0.50188708f, 0.07393268f, -0.24565981f, -0.00907827f, -0.04137506f, 
    0.00648057f, -0.04665635f, 0.41780290f, -0.32154232f, -0.29827672f, 0.00106355f, 0.15042730f, -0.30386508f, 
    0.24594809f, 0.06929900f, 0.10386991f, -0.16253728f, 0.06876180f, -0.02495099f, -0.09260659f, 0.15819451f, 
    0.13619146f, 0.03259536f, 0.15581954f, 0.21011621f, -0.07561689f, -0.27436039f, -0.25035718f, -0.13988346f, 
    0.00060877f, -0.28388456f, -0.13263465f, -0.14607142f, -0.10389959f, -0.16929010f, -0.01057787f, 0.26445144f, 
    -0.15476513f, 0.26898426f, 0.29203466f, -0.15014315f, -0.02191637f, 0.21068482f, 0.09581733f, -0.47485575f, 
    -0.04302571f, -0.08140567f, 0.03333444f, 0.18542615f, -0.05813309f, 0.04008506f, 0.06962213f, -0.03809723f, 
    0.14218166f, 0.09874240f, 0.17722456f, -0.14944018f, -0.11005498f, 0.12928157f, -0.14962542f, 0.10100916f, 
    0.09672519f, 0.22660027f, -0.05470004f, -0.09606125f, 0.21296823f, 0.20890372f, 0.15755993f, 0.08427206f, 
    -0.35223308f, 0.14066580f, -0.20532961f, 0.08221508f, -0.14567927f, 0.05386186f, -0.07051473f, -0.24491675f, 
    0.19421320f, -0.14219731f, -0.39323500f, -0.12381738f, -0.23425694f, 0.03297330f, -0.13529676f, 0.11128183f, 
    -0.03048590f, 0.09582672f, -0.02062457f, -0.39618874f, -0.34714776f, -0.22647755f, 0.03896832f, -0.13367663f, 
    0.22486617f, 0.03359393f, -0.00600137f, -0.10224642f, -1.20585763f, -0.10753592f, -0.15314147f, 0.08093449f, 
    0.01540429f, 0.22662251f, 0.12304472f, 0.14860721f, -0.06808693f, -0.13325910f, 0.07387856f, 0.00534468f, 
    -0.14266172f, 0.24708065f, -0.05454496f, 0.21355322f, -0.03612255f, 0.06139943f, -0.22199766f, -0.19037861f, 
    -0.17162941f, -0.18715288f, 0.12388419f, -0.03361088f, -0.13854559f, 0.19294053f, 0.11745252f, -0.77091742f, 
    -0.31358284f, -0.38151631f, 0.30321357f, -0.36577490f, -0.26583314f, 0.18417645f, 0.04825624f, 0.03167666f, 
    0.05278234f, -0.11443008f, 0.03956274f, -0.05726911f, -0.05097127f, -0.16610785f, 0.01010471f, 0.17197335f, 
    0.01200119f, -0.46256864f, 0.10101277f, 0.18237628f, -0.13293143f, 0.00652466f, 0.09755537f, 0.20546915f, 
    -0.04974473f, 0.18025562f, 0.23666364f, 0.20450762f, -0.21354593f, 0.06078383f, -0.06150495f, -0.03415566f, 
    -0.09135967f, -0.07533672f, 0.03150576f, -0.25454402f, -0.29063094f, 0.03222163f, -0.19441710f, 0.22867589f, 
    0.20002905f, -0.12110274f, 0.04092639f, 0.11985230f, 0.09234370f, -0.71796435f, -1.42922699f, 0.15160649f, 
    -0.08078768f, 0.06749910f, -0.11698043f, -0.01577248f, 0.04837469f, -0.25374159f, -0.23996854f, 0.05886573f, 
    -0.06892398f, 0.10815528f, 0.10151064f, 0.12680757f, 0.07538581f, 0.10443217f, 0.03820345f, -0.07494482f, 
    0.19048381f, -0.04496090f, -0.05442810f, -0.24297383f, -0.08164691f, 0.07405248f, 0.05986188f, -0.27093101f, 
    -0.38107321f, -0.32185718f, 0.05641734f, -0.03223897f, -0.15957110f, 0.16333552f, 0.08071202f, 0.02041576f, 
    -0.02590554f, -0.13109443f, 0.38038784f, -0.07495704f, -0.04934516f, 0.12172870f, -0.03508383f, -0.02395930f, 
    -0.11559635f, -0.03799757f, -0.19866060f, 0.21104145f, 0.02793923f, 0.02758942f, -0.35032555f, 0.00571008f, 
    0.07098942f, 0.10076711f, 0.28764248f, 0.39875257f, 0.07170080f, -0.05473494f, -0.03345923f, 0.12390732f, 
    0.03943582f, -0.07788771f, -0.07796771f, 0.14067914f, 0.47248703f, 0.35971436f, 0.07633606f, 0.10710301f, 
    -0.20593774f, -0.15510780f, 0.02060775f, 0.10948249f, -0.12690486f, -0.11367635f, 0.07825127f, -0.08269938f, 
    -0.22240320f, 0.11356575f, 0.08560816f, 0.10729118f, 0.32144594f, 0.33650514f, 0.15119009f, 0.27222323f, 
    -0.02732125f, -0.02839026f, -0.06240106f, 0.32503250f, 0.16620544f, -0.01008740f, 0.07844324f, -0.09561834f, 
    -0.37690970f, -0.42214295f, 0.42717841f, 0.27509251f, -0.13759324f, 0.11386993f, 0.04210582f, 0.06535803f, 
    0.07735668f, 0.01127899f, -0.00239513f, -0.09457356f, 0.15409096f, -0.01721346f, -0.03947765f, -0.15883428f, 
    0.04515506f, 0.16618083f, 0.22504808f, 0.08638284f, -0.12937801f, 0.17330495f, -0.01230268f, 0.10577478f, 
    -0.23107342f, -0.31728005f, 0.38137883f, 0.14688076f, -0.12838314f, -0.02701883f, 0.05907992f, 0.02126613f, 
    0.13746279f, 0.25656465f, -0.52676946f, -0.49522611f, 0.41515774f, 0.02675915f, -0.05673541f, 0.03377771f, 
    -0.11593551f, 0.15151258f, 0.08251546f, -0.30494505f, -0.03109682f, 0.14970106f, 0.04327489f, -0.09471631f, 
    0.05770006f, 0.10964109f, 0.18878564f, -0.22870468f, -0.06101549f, -0.05115744f, 0.25935918f, -0.15889859f, 
    -0.05283970f, 0.11138755f, 0.03139573f, 0.01608534f, 0.08507629f, 0.09855182f, 0.42193967f, 0.32206568f, 
    -0.08153210f, -0.12683660f, 0.10669726f, -0.31611785f, 0.00329254f, 0.10213124f, 0.04507188f, -0.06939016f, 
    0.05783198f, 0.02474685f, 0.05858981f, -0.10858268f, 0.12677504f, -0.11259865f, 0.05512718f, -0.20343840f, 
    -0.59093934f, -0.32859489f, -0.06113576f, 0.00376594f, -0.03338154f, 0.02720501f, -0.03394150f, -0.03221161f, 
    -0.01777828f, 0.18126824f, 0.06221576f, 0.10111716f, -0.22902378f, -0.27356878f, -0.04097553f, 0.12526548f, 
    0.10380433f, -0.02560047f, -0.14115001f, -0.67413282f, -0.08354478f, -0.12589882f, -0.06232478f, 0.00946923f, 
    0.02819341f, -0.15742986f, -0.14557756f, -0.04843579f, -0.08672906f, 0.02965809f, 0.04849529f, -0.02758346f, 
    0.02812265f, 0.10939042f, 0.01735077f, -0.33918786f, 0.39788425f, -0.06136732f, -0.04466924f, -0.01688302f, 
    0.31589985f, -0.04478285f, 0.03280921f, -0.04542589f, -0.15091811f, -0.22494565f, -0.01874358f, 0.02356576f, 
    -0.35862103f, 0.06065782f, 0.10377079f, 0.18020482f, -0.01343389f, 0.31768394f, 0.57507223f, 0.43293652f, 
    -0.00545105f, -0.08405507f, -0.09327650f, 0.02088874f, -0.08587521f, 0.05782665f, -0.16398761f, -0.20087016f, 
    0.00581541f, 0.00107607f, -0.02492571f, -0.08120163f, 0.06599263f, 0.00491759f, 0.08547980f, -0.68153989f, 
    0.04348997f, 0.43088147f, -0.07177170f, -0.18909091f, 0.01175587f, -0.19648905f, 0.05652836f, 0.12288426f, 
    -0.01044551f, -0.02037726f, 0.21724284f, 0.02703058f, 0.03263565f, -0.07145251f, -0.20261632f, -0.15290944f, 
    0.02234181f, -0.33929431f, 0.10673255f, -0.11492488f, -0.01891112f, 0.20903234f, 0.08424993f, 0.23702379f, 
    0.45926002f, 0.06934235f, 0.50456262f, 0.08723923f, -0.03582243f, -0.09788068f, -0.00078489f, -0.28362268f, 
    -0.16893567f, 0.11290434f, -0.12950246f, -0.52349472f, -0.18034765f, 0.23320135f, -0.01556546f, 0.06301826f, 
    0.02658999f, -0.07208990f, -0.00243731f, 0.21537124f, 0.13366647f, -0.25706190f, 0.01880602f, -0.17595124f, 
    0.05006811f, 0.06514329f, 0.15262720f, -0.13089478f, -0.03851119f, -0.35818210f, -0.10325342f, 0.20981027f, 
    -0.14754710f, 0.01568729f, 0.21481045f, -0.01096336f, 0.05502781f, 0.07116339f, 0.12561606f, -0.14795564f, 
    0.02421675f, -0.06673466f, -0.07640994f, 0.01028982f, 0.10820866f, -0.02110084f, 0.05831677f, 0.01098562f, 
    0.01980321f, 0.03547165f, -0.19476987f, 0.25317714f, 0.08674566f, 0.11741295f, -0.05387705f, -0.16768260f, 
    0.22134028f, -0.07392651f, 0.04891210f, -0.01495790f, -0.05590745f, 0.01891980f, -0.01747096f, 0.16473654f, 
    -0.15245380f, -0.15537181f, -0.09553704f, 0.21888810f, -0.00988021f, 0.08172441f, 0.12381469f, 0.04432937f, 
    0.04987005f, 0.26903939f, 0.02117489f, -0.29364666f, -0.09979001f, 0.05062380f, -0.08417727f, -0.00850816f, 
    -0.15166104f, 0.15890767f, -0.10630342f, -0.04137549f, -0.11100060f, 0.23467809f, 0.18091881f, -0.01783452f, 
    -0.01685156f, -0.05133318f, 0.02881706f, 0.21723090f, -0.16506639f, 0.07220839f, 0.23183486f, 0.10693961f, 
    0.14592913f, -0.31818843f, -0.18682294f, -0.03218571f, 0.08526798f, -0.08473123f, -0.00366453f, -0.06091024f, 
    0.06065573f, 0.32846212f, 0.11341868f, 0.17636107f, 0.01670735f, -0.03678007f, 0.26097044f, -0.35503444f, 
    0.01409506f, 0.13594991f, 0.00993954f, 0.33376515f, -0.03319209f, -0.13848040f, -0.01040790f, 0.03980105f, 
    -0.28364059f, -0.19555856f, 0.04779250f, 0.01684225f, 0.34136516f, 0.14742002f, 0.03036286f, -0.20908402f, 
    0.03539724f, -0.06607154f, -0.06335500f, 0.09990049f, 0.21230660f, 0.22885382f, 0.01866786f, -0.04161074f, 
    0.03542356f, -0.47333658f, -0.18003096f, 0.04656776f, -0.02797267f, -0.04329743f, 0.09201980f, 0.11309853f, 
    0.13983300f, 0.03919144f, -0.00456116f, -0.04032351f, 0.18407823f, -0.21368736f, 0.21420373f, 0.10298006f, 
    0.26731455f, 0.12353715f, -0.07696443f, 0.00009388f, 0.14830025f, 0.01469577f, 0.02976616f, 0.16177508f, 
    0.02291222f, -0.00158132f, 0.11310188f, 0.02582756f, -0.19322397f, 0.10650600f, 0.03524608f, 0.23216473f, 
    -0.06728074f, 0.10023755f, -0.27890947f, -0.20418446f, 0.16597992f, 0.54787731f, 0.19405080f, 0.05471781f, 
    -0.05176838f, 0.14408460f, 0.11344687f, 0.00829771f, -0.10955750f, -0.02125497f, 0.28306013f, 0.11010654f, 
    -0.16552305f, -0.08748727f, 0.22225645f, 0.16482469f, 0.11594928f, 0.12031868f, 0.00118106f, 0.00106186f, 
    -0.05768182f, 0.16250609f, -0.01479097f, 0.22351800f, 0.10942228f, -0.02719463f, -0.08843429f, 0.06037217f, 
    0.56535125f, 0.01888699f, -0.20134386f, 0.04308932f, 0.00046723f, 0.00695437f, 0.02357277f, 0.16571802f, 
    -0.37809062f, 0.00983206f, 0.18854448f, 0.07003024f, -0.02011978f, -0.06136904f, 0.06201261f, -0.19303808f, 
    0.26923156f, 0.28570461f, -0.05660416f, -0.04298136f, -0.00214490f, 0.04893875f, 0.04282489f, -0.04253206f, 
    0.06643781f, -0.17542981f, -0.04822756f, -0.02933061f, 0.09820112f, -0.25636458f, 0.01661198f, 0.09969341f, 
    -0.04402765f, 0.13492271f, 0.10975750f, -0.16106123f, 0.21561299f, 0.19202358f, -0.19399595f, -0.03215662f, 
    0.32272360f, 0.13830639f, 0.20651866f, 0.05895553f, -0.03795965f, 0.05882656f, -0.13410968f, -0.10705836f, 
    0.00450675f, 0.10653947f, 0.04675586f, 0.00983426f, 0.00396379f, -0.32299396f, 0.04721634f, 0.09839128f, 
    0.01468516f, -0.03536117f, -0.13408192f, -0.00429102f, 0.13739127f, -0.06459047f, 0.00380207f, -0.09980891f, 
    0.16427949f, -0.01649402f, 0.13879263f, 0.14031397f, -0.15615776f, 0.21710831f, -0.14635786f, 0.09228005f, 
    0.16584569f, -0.20788671f, -0.02586774f, -0.09865981f, -0.20639692f, -0.11299238f, 0.08690162f, 0.14501147f, 
    -0.09835368f, 0.02443670f, 0.35153902f, 0.23336042f, 0.05173428f, 0.15475254f, -0.01353320f, 0.15272653f, 
    0.11990264f, 0.11788438f, -0.05622038f, -0.44035766f, 0.11758735f, -0.09054897f, -0.10891570f, -0.26589215f, 
    -0.03450013f, 0.02180337f, -0.04069353f, -0.12663363f, -0.31840813f, 0.06337797f, -0.01233201f, 0.19300607f, 
    0.00765698f, 0.12008940f, -0.08183219f, -0.00868559f, 0.34775087f, 0.19716246f, -0.28677458f, 0.00450737f, 
    -0.11855908f, 0.25902700f, 0.02428335f, 0.05043748f, 0.03856382f, -0.12422592f, 0.10251515f, 0.19345304f, 
    0.01086834f, 0.01119820f, -0.05764056f, -0.00807437f, -0.03508640f, 0.23823157f, 0.11005884f, 0.42581752f, 
    -0.46879205f, -0.01670463f, -0.05767502f, -0.02835435f, -0.02006739f, 0.18149398f, 0.01409621f, 0.17459022f, 
    0.15652218f, -0.26308146f, -0.34201550f, -0.02441471f, 0.05849923f, 0.01875639f, 0.05232759f, 0.19695938f, 
    -0.63310683f, -0.35588780f, 0.03150247f, 0.04551979f, -0.13467105f, 0.02670472f, -0.01286360f, 0.10933764f, 
    0.25519601f, 0.16586234f, -0.04756016f, 0.05032340f, 0.00802225f, 0.01091667f, 0.00412629f, 0.07692512f, 
    0.27692521f, 0.10843694f, -0.39470470f, -0.37196547f, 0.87012446f, -0.00175672f, -0.05875457f, -0.01840265f, 
    -0.09604486f, -0.01517581f, 0.09733786f, -1.59097350f, -0.35670888f, 0.00363228f, -0.05984820f, -0.00669690f, 
    -0.16413835f, 0.00584087f, -0.16128372f, -0.00128096f, 0.16691223f, 0.02365121f, 0.10722393f, -0.04542939f, 
    0.25308859f, 0.02486014f, 0.14272785f, 0.03838009f, 0.04582136f, -0.08939424f, -0.05006021f, -0.22776528f, 
    0.17363393f, -0.04264465f, 0.06554403f, 0.01888318f, 0.16405697f, 0.08099057f, 0.15942281f, 0.15227206f, 
    -0.32904333f, -0.08749907f, 0.11596336f, 0.47250926f, -0.08249977f, 0.02372888f, -0.15983157f, 0.47735009f, 
    0.15284351f, -0.23759979f, 0.05781108f, 0.08082408f, -0.02608677f, -0.00985568f, 0.02505426f, 0.07043821f, 
    0.26828593f, -0.04106220f, -0.33100218f, -0.06066848f, -0.00241371f, 0.07369278f, 0.04364948f, 0.07781155f, 
    -0.11086068f, -0.30408695f, -0.36308509f, -0.48384315f, 0.00646483f, 0.19057161f, -0.05369474f, -0.10871429f, 
    0.12107456f, -0.10283034f, 0.05960125f, -0.14667070f, 0.09466575f, -0.02497426f, 0.08546618f, -0.13905683f, 
    0.06486820f, -0.03027644f, 0.19652198f, 0.10378771f, 0.09845611f, -0.12548405f, -0.11776950f, 0.10823299f, 
    0.05422590f, 0.05005300f, -0.00892297f, 0.11999765f, -0.15164286f, 0.00845355f, 0.03715030f, -0.28522247f, 
    -0.15096600f, -0.11856160f, 0.13815169f, -0.00808142f, -0.05244588f, 0.40594447f, 0.21666856f, -0.31887445f, 
    0.21587762f, -0.00563779f, -0.06010115f, 0.00093089f, -0.06342041f, -0.02257322f, 0.19952360f, 0.29456660f, 
    -0.21498823f, -0.43840656f, -0.10695925f, -0.04304001f, 0.10057427f, -0.11641743f, 0.02164873f, 0.21935248f, 
    0.13710795f, -0.11979745f, -0.04906231f, -0.22125173f, -0.15065239f, -0.04565745f, 0.39378077f, 0.27952427f, 
    1.44807482f, 0.16802776f, -0.99299002f, 0.01347755f, 0.10274415f, 0.01236211f, -0.06741735f, 0.08005689f, 
    -0.05356652f, 0.34295276f, 0.08609816f, -0.35197744f, -0.35712540f, -0.26571029f, 0.45979172f, -0.16051169f, 
    0.05293344f, -0.08197108f, 0.12121043f, -0.02237711f, -0.18221946f, -0.31632316f, -0.19949585f, -0.03216951f, 
    0.06008721f, -0.03462979f, -0.05007341f, -0.09909633f, -0.04432923f, -0.26951140f, 0.06569235f, 0.16483580f, 
    -0.13882932f, 0.12374105f, 0.15044440f, 0.05454484f, 0.30631962f, -0.01142917f, -0.43540332f, 0.19265707f, 
    0.12226370f, 0.01574392f, -0.08177035f, -0.00030856f, -0.05115313f, -0.73597389f, -0.13249294f, -0.51852530f, 
    -0.05161206f, -0.12419925f, -0.14238964f, 0.06291829f, -0.06378017f, 0.05179914f, 0.06552079f, 0.12652893f, 
    -0.02651436f, -0.25005201f, -0.24971174f, -0.21829458f, 0.05605449f, -0.05141319f, 0.02614102f, -0.02548994f, 
    -0.19687259f, -0.00954161f, -0.07129454f, 0.05503359f, 0.06676304f, 0.12097938f, 0.34679148f, 0.01259989f, 
    -0.13764068f, 0.00286184f, -0.07009393f, -0.03678809f, 0.11997000f, -0.04032162f, 0.17708196f, 0.08312665f, 
    0.04786986f, -0.09507592f, -0.13773157f, -0.02586633f, 0.11644723f, 0.08212781f, 0.07150375f, 0.03437956f, 
    -0.41021714f, -0.04549925f, -0.07597086f, 0.19105218f, 0.17578916f, -0.08262116f, -0.07440730f, 0.05777282f, 
    0.01660513f, -0.02964013f, -0.02215833f, -0.20204543f, -0.22678071f, -0.21610759f, 0.25962541f, 0.05594491f, 
    -0.08643613f, 0.06570765f, 0.03726579f, -0.09212781f, -0.43494269f, 0.21580559f, 0.17924301f, -0.19131337f, 
    0.18831682f, -0.14887153f, 0.11912254f, 0.06277057f, 0.20698433f, -0.19873430f, -0.17000884f, -0.26412407f, 
    0.10357668f, 0.10579573f, -0.04746717f, 0.02920158f, 0.16909902f, 0.03079611f, -0.10942619f, 0.06333387f, 
    0.08107052f, 0.06498705f, -0.11627392f, -0.19643217f, -0.10430364f, 0.08927114f, 0.04428829f, 0.06438404f, 
    0.26494440f, 0.15237384f, -0.17812748f, -0.16526452f, -0.06778946f, 0.17868321f, 0.11954475f, 0.10068216f, 
    0.01963814f, 0.11675384f, -0.29949600f, 0.05657170f, 0.07090316f, 0.01309254f, -0.02174409f, 0.11084110f, 
    0.00025307f, -0.00450191f, -0.14534976f, -0.07516401f, 0.08640812f, 0.07378680f, -0.04333758f, -0.19870518f, 
    -0.12076776f, -0.10109301f, -0.02983483f, 0.24010466f, -0.26216242f, 0.10567954f, -0.00011381f, 0.01752430f, 
    0.01009936f, 0.16360703f, -0.02711642f, -0.04011341f, 0.09274239f, 0.12480410f, -0.03594909f, -0.02744096f, 
    -0.08178122f, 0.09531126f, 0.06568982f, -0.14232162f, 0.05331343f, -0.04584116f, -0.09165500f, -0.06371870f, 
    0.19796297f, -0.06541017f, 0.17881809f, -0.19356054f, 0.01529597f, -0.33979937f, -0.02709150f, 0.15256247f, 
    -0.17295635f, -0.16162355f, -0.01513857f, -0.11010292f, -0.29675171f, 0.29041696f, 0.03296043f, -0.25034109f, 
    -0.44654670f, 0.07179246f, 0.36955029f, 0.08020391f, 0.16117436f, 0.18682779f, 0.03253950f, 0.09160686f, 
    0.22101431f, -0.01064043f, 0.03101755f, -0.24961427f, 0.06971483f, -0.00920845f, 0.15201122f, -0.01727609f, 
    0.19094425f, 0.09527741f, -0.00629113f, 0.02398952f, 0.00592410f, -0.07784534f, 0.04184509f, 0.02286585f, 
    0.06673513f, 0.18364775f, -0.21081407f, -0.01443204f, 0.13865854f, 0.01711633f, -0.15100475f, 0.08913989f, 
    0.21599242f, -0.13276806f, -0.13999055f, 0.07754365f, -0.07930876f, 0.05982087f, 0.14518170f, -0.21114260f, 
    0.05364544f, 0.17268679f, -0.05377391f, 0.11433534f, -0.00348892f, 0.08051072f, -0.13438840f, -0.09564031f, 
    -0.11582523f, 0.26205957f, -0.04504959f, 0.15097027f, 0.05672280f, -0.05073139f, -0.15194120f, 0.02379235f, 
    0.12969933f, 0.05896106f, 0.16448186f, 0.07098244f, 0.11687639f, -0.05749613f, 0.07299141f, 0.01259588f, 
    0.00106781f, -0.31144464f, -0.17439176f, 0.00675036f, -0.07773061f, -0.00463352f, 0.01329384f, 0.27429628f, 
    0.33885264f, -0.08757728f, -0.05333170f, -0.06375748f, 0.12673843f, 0.08397030f, 0.02728008f, 0.06670444f, 
    0.07249100f, -0.07410578f, -0.23987988f, 0.03286324f, -0.03313212f, 0.18394548f, -0.01116279f, -0.19540499f, 
    0.04422833f, 0.28201768f, 0.24442595f, -0.00063370f, -0.10933000f, -0.03335839f, -0.13743405f, -0.00828135f, 
    -0.01755588f, -0.14853938f, 0.07783426f, -0.25876045f, -0.18285342f, 0.14935921f, -0.01453456f, 0.08041512f, 
    0.05487569f, 0.09436820f, 0.02680756f, 0.17893568f, 0.05043555f, -0.04744692f, -0.12280764f, -0.05258467f, 
    0.15124492f, 0.17962012f, 0.16439064f, -0.32313851f, -0.35973388f, -0.13676812f, 0.02335762f, -0.13689710f, 
    -0.03925755f, 0.07187461f, 0.07898894f, -0.19844648f, -0.06110274f, 0.10965064f, 0.22360678f, -0.18185656f, 
    -0.21368235f, -0.14496483f, 0.01230659f, -0.02880314f, 0.16802306f, -0.09594268f, 0.34174979f, -0.05006777f, 
    0.01521237f, -0.21598387f, -0.24377435f, 0.13798746f, -0.01019125f, -0.08647406f, 0.04074908f, 0.15953380f, 
    0.03886251f, -0.05271199f, -0.07950453f, 0.00066245f, 0.16130111f, 0.13258760f, 0.18415689f, -0.15662871f, 
    -0.15908438f, -0.08033757f, -0.05591127f, -0.04808033f, 0.02516259f, 0.00017515f, 0.12059366f, 0.19356154f, 
    -0.00366788f, -0.03458114f, 0.06368317f, 0.00824097f, 0.01302074f, -0.06376684f, 0.16683766f, -0.21830787f, 
    -0.07206023f, 0.01812613f, 0.04591486f, 0.12639934f, -0.07140359f, 0.23560670f, 0.07882354f, 0.01736843f, 
    0.17682381f, -0.05116737f, -0.09255571f, -0.04235687f, 0.08777631f, 0.14511335f, 0.04540000f, -0.10439014f, 
    0.15899849f, 0.07657366f, 0.20000258f, 0.18020539f, 0.00200525f, -0.04236849f, 0.18031949f, 0.07215595f, 
    0.01994882f, 0.03891281f, -0.04058396f, 0.06452609f, 0.15644786f, 0.16251297f, -0.11005220f, 0.02116912f, 
    -0.12892471f, -0.14114133f, 0.10725135f, -0.30916944f, 0.11981568f, 0.19393775f, 0.06778078f, -0.04039692f, 
    0.08940059f, -0.10292321f, -0.02654443f, -0.03064089f, -0.13030173f, -0.03222748f, 0.01969984f, 0.25794470f, 
    0.12377317f, 0.29885662f, 0.07775870f, 0.03291631f, 0.17839734f, 0.00213836f, 0.44864202f, 0.11938144f, 
    0.10468297f, 0.17860004f, -0.02914267f, -0.06654803f, -0.16214585f, -0.03350345f, -0.21914256f, 0.14664970f, 
    -0.19034153f, -0.18016875f, 0.09233366f, -0.10132155f, 0.05607781f, -0.08295843f, 0.14193037f, 0.17536873f, 
    0.24946089f, 0.03645914f, -0.01168084f, -0.02853855f, 0.08910972f, 0.04286503f, 0.13023800f, 0.19706284f, 
    0.00751002f, 0.04211377f, -0.03123873f, -0.38668266f, -0.07852624f, 0.03793552f, 0.09367428f, -0.08637888f, 
    0.12583414f, 0.08174255f, 0.25508913f, -0.16040716f, -0.13370113f, -0.12342133f, 0.25212747f, -0.11955652f, 
    0.13113680f, -0.06161101f, -0.08153263f, 0.15852554f, -0.02514460f, 0.01037973f, 0.11866908f, 0.19542465f, 
    0.18880126f, 0.05223667f, 0.06565019f, 0.05806473f, -0.00553654f, -0.23862940f, 0.15061732f, -0.17931239f, 
    -0.17064069f, -0.04410186f, -0.20725590f, 0.12932852f, -0.18817113f, -0.10525219f, -0.14860943f, 0.12133045f, 
    -0.23361844f, -0.32370830f, 0.05751075f, -0.11958781f, 0.05931282f, 0.06718797f, -0.00588807f, 0.12322345f, 
    0.27735168f, 0.08344126f, 0.08934448f, 0.03187860f, 0.02965933f, 0.00727155f, -0.17754737f, -0.18148556f, 
    -0.01486311f, 0.27264044f, 0.01430751f, 0.03491438f, 0.02324676f, 0.06290063f, -0.12464947f, -0.14720608f, 
    0.06167026f, 0.03661088f, 0.08577360f, -0.14813299f, 0.08422523f, 0.09344255f, 0.02772296f, 0.07317038f, 
    -0.04474771f, 0.04705374f, -0.07030086f, 0.22580187f, -0.14353225f, 0.07410359f, 0.06397196f, 0.05203818f, 
    0.16331318f, -0.18194252f, -0.07551344f, 0.04470075f, 0.09826696f, 0.11127232f, -0.03871379f, -0.04241998f, 
    -0.00605198f, 0.05020280f, 0.05143597f, -0.03762200f, -0.02727560f, -0.05197099f, -0.10199013f, 0.16041751f, 
    -0.05250093f, -0.14145790f, -0.04754774f, -0.21918754f, -0.28813979f, -0.27155843f, 0.20357655f, 0.16243012f, 
    -0.11664066f, 0.11779163f, -0.17283881f, -0.17660913f, -0.14050521f, -0.02797516f, -0.03664122f, 0.08091332f, 
    0.32981852f, -0.09177519f, -0.08965576f, -0.14606455f, -0.04572356f, -0.30347988f, -0.12342495f, 0.17413278f, 
    0.16660495f, -0.01241789f, -0.08533867f, -0.05718035f, 0.00936755f, 0.14202699f, -0.04403249f, -0.08333624f, 
    -0.04897594f, 0.00571362f, -0.04449446f, 0.05725230f, -0.04963085f, -0.36129498f, -0.06146985f, 0.05098641f, 
    0.18203108f, 0.13662285f, 0.12147278f, 0.16180825f, -0.00827664f, -0.13705918f, 0.02049951f, 0.10161568f, 
    0.23204303f, 0.31911635f, -0.07002477f, 0.04122666f, 0.07692885f, -0.04548350f, -0.16676389f, -0.14481182f, 
    0.05794937f, -0.05179570f, -0.10448369f, 0.01646371f, 0.08220624f, -0.15270509f, 0.01955588f, 0.13411230f, 
    0.11884395f, 0.03727503f, 0.05168474f, 0.03586821f, -0.50434536f, 0.07092752f, 0.04057459f, -0.06794461f, 
    -0.00044265f, -0.19778161f, -0.16346595f, -0.07152250f, -0.06042307f, -0.27522922f, -0.19172761f, 0.04988649f, 
    -0.18322267f, -0.20231864f, -0.14629418f, -0.00781139f, -0.07774270f, 0.03393254f, -0.02482379f, -0.04682177f, 
    0.13559282f, -0.11903545f, -0.14022376f, -0.21218514f, 0.10705866f, 0.00003898f, -0.07286178f, -0.04987214f, 
    0.05015067f, -0.08603510f, -0.01236579f, -0.04118413f, 0.08584770f, 0.10764074f, -0.04938620f, 0.08105757f, 
    0.01172919f, 0.05660551f, 0.01802560f, -0.09804355f, -0.23284586f, 0.04414509f, -0.00316959f, -0.01120212f, 
    0.11517293f, 0.12651369f, 0.13541044f, -0.04934143f, 0.02232977f, 0.05067599f, -0.10179454f, 0.05412202f, 
    0.00838053f, 0.13448492f, -0.37906724f, -0.02405742f, -0.04511284f, -0.05180046f, 0.04156847f, 0.01815328f, 
    -0.04553128f, -0.03004793f, 0.02432642f, 0.25680110f, -0.28002250f, 0.03445081f, 0.04534762f, 0.10834947f, 
    0.09769198f, 0.00866326f, 0.17164180f, 0.17919236f, -0.47575364f, 0.38238969f, 0.28012750f, -0.20581707f, 
    0.07872157f, -0.12750347f, -0.05474840f, 0.07253708f, 0.07917985f, -0.00311302f, -0.28641510f, -0.08658598f, 
    0.00520302f, 0.04324161f, 0.04998652f, 0.02465408f, 0.25618854f, 0.26636297f, -0.10037253f, 0.32805568f, 
    0.26925123f, 0.04033290f, 0.00759223f, 0.06326534f, 0.14047161f, 0.08999483f, -0.14662516f, -0.13270375f, 
    -0.05959255f, 0.16737138f, 0.00570861f, -0.11607208f, -0.15183608f, 0.11363806f, 0.02985197f, 0.02774371f, 
    -0.12204701f, 0.00407136f, -0.40522695f, 0.11746100f, 0.04242009f, -0.18383530f, 0.00371616f, -0.06708346f, 
    -0.17112288f, -0.05974388f, 0.09531361f, 0.04215242f, -0.04368851f, -0.01953930f, -0.05342079f, 0.20461366f, 
    0.23190261f, -0.03443724f, -0.28921086f, 0.00266456f, -0.37952745f, 0.13382639f, 0.13534063f, 0.17970325f, 
    -0.15435551f, -0.06556633f, -0.08448118f, -0.29823962f, -0.47570711f, -0.08097199f, 0.05242742f, 0.11351336f, 
    0.03790816f, 0.06471340f, 0.09486204f, -0.08780945f, 0.04218300f, -0.08672940f, 0.15716437f, 0.12297061f, 
    0.03464563f, 0.25137693f, 0.24303266f, 0.00539353f, -0.00660922f, -0.02653496f, -0.18310708f, -0.14928764f, 
    -0.06690982f, 0.17723356f, 0.14901690f, 0.15894267f, -0.00594107f, -0.02324666f, 0.40925071f, -0.22726089f, 
    -0.03431631f, 0.16635691f, -0.12197099f, 0.03113736f, 0.31766683f, -0.08840021f, 0.20335820f, 0.05558883f, 
    0.31991741f, 0.14105631f, -0.09778640f, 0.09047960f, 0.17000802f, 0.20069127f, 0.06414413f, 0.06904782f, 
    0.07131732f, 0.23102683f, -0.02332632f, 0.06310298f, 0.24603392f, 0.25433925f, 0.10458350f, 0.11625369f, 
    0.09243868f, 0.04713864f, 0.03821068f, -0.09251178f, -0.00033284f, -0.06647819f, 0.01041946f, 0.05378342f, 
    -0.04165780f, 0.00521005f, 0.03372539f, -0.09479944f, 0.03497746f, -0.01965975f, -0.03603723f, -0.10076946f, 
    -0.09771042f, -0.18894599f, -0.04921224f, 0.07917397f, 0.11820833f, 0.20308618f, 0.22421207f, 0.14916754f, 
    0.33057824f, 0.02712332f, 0.17279325f, 0.20858753f, -0.14660466f, -0.32431808f, -0.10443315f, 0.01317558f, 
    0.07368806f, 0.11775424f, -0.03250562f, 0.04447222f, 0.04746221f, -0.10656760f, 0.17281637f, 0.13042119f, 
    0.01745226f, 0.09023955f, 0.05840196f, 0.02001942f, -0.05701260f, -0.14666842f, -0.20828623f, -0.09633210f, 
    0.35517412f, -0.32284012f, 0.01341699f, -0.00556237f, 0.12823355f, -0.08713514f, -0.03189939f, -0.10956536f, 
    -0.01874704f, -0.06387118f, -0.04428219f, -0.15861186f, -0.05026225f, 0.17066085f, -0.32360259f, -0.04010167f, 
    -0.35119832f, 0.33400810f, 0.24836920f, -0.24601525f, 0.21109830f, -0.15242215f, -0.00671896f, -0.15569012f, 
    -0.15898184f, 0.02441238f, 0.31013307f, 0.05523764f, 0.13346930f, -0.06147081f, 0.07893393f, -0.17143540f, 
    0.04939742f, 0.16649561f, -0.07841669f, -0.04102780f, -0.00532624f, 0.13581401f, -0.05831490f, 0.30588713f, 
    -0.00277933f, -0.17749785f, -0.01392985f, 0.04931066f, 0.02054337f, -0.06125212f, 0.04124835f, -0.02497879f, 
    -0.03076892f, -0.02297550f, -0.13303073f, -0.14943391f, -0.36438167f, 0.18354884f, 0.09299517f, -0.38231549f, 
    0.02528330f, 0.04537580f, 0.01254774f, 0.06075458f, 0.04884898f, -0.49146169f, -0.35383537f, -0.49636531f, 
    0.03017796f, -0.01007501f, -0.11314126f, 0.01065440f, -0.04276264f, -0.25843492f, -0.09522831f, -0.03175610f, 
    0.11408006f, 0.10067298f, -0.00464533f, 0.03090294f, 0.12691848f, -0.02998579f, 0.15171650f, 0.04550316f, 
    0.11333096f, -0.08772355f, -0.01283236f, -0.09819232f, 0.05801859f, 0.01283409f, 0.01540113f, 0.13856395f, 
    0.01884193f, 0.03535817f, -0.01988659f, 0.08187364f, 0.03567117f, 0.10637160f, -0.01431907f, -0.05857205f, 
    -0.09453346f, 0.26293978f, 0.13653076f, -0.08761030f, -0.07016899f, 0.03556314f, 0.26148862f, 0.09738024f, 
    0.07822373f, 0.02362308f, 0.05848886f, -0.08507600f, -0.26439610f, -0.07503209f, 0.03233323f, 0.26184157f, 
    -0.05754590f, 0.15276761f, 0.22637130f, 0.27605328f, 0.28454643f, -0.05667690f, 0.12341780f, -0.05579433f, 
    0.08519959f, 0.14885563f, 0.09843081f, -0.06187176f, -0.41139808f, -0.26133123f, -0.00239252f, 0.12907207f, 
    0.11404706f, 0.10156781f, 0.19441083f, 0.36232725f, 0.27107903f, 0.21649940f, 0.00896731f, 0.02561283f, 
    0.06827331f, 0.03980361f, 0.18954064f, -0.05064939f, 0.05803839f, -0.34786397f, -0.10937117f, -0.18746099f, 
    -0.22883900f, 0.14480509f, 0.13975032f, 0.22501248f, 0.09716951f, 0.28704065f, 0.07034513f, 0.13898711f, 
    -0.11297400f, 0.12827757f, 0.18598035f, 0.13461885f, 0.17823207f, -0.09394841f, -0.11912514f, -0.09121790f, 
    -0.29818994f, 0.31630379f, 0.23834968f, 0.31998748f, 0.13505711f, 0.23211892f, -0.06894157f, 0.09771191f, 
    0.10332505f, -0.31653258f, 0.11640348f, 0.06157441f, 0.08295836f, 0.18761164f, 0.05178699f, 0.22035988f, 
    0.10014696f, 0.02540240f, 0.13169350f, 0.27389774f, 0.29083776f, 0.07032339f, 0.01220836f, -0.05679315f, 
    0.04858753f, 0.13907050f, 0.14786419f, 0.17594030f, 0.12972403f, -0.21107084f, 0.16009511f, -0.13437583f, 
    0.05506657f, -0.12652133f, -0.11794817f, -0.15216887f, 0.02790169f, 0.10955658f, -0.04573215f, 0.10794614f, 
    0.03265844f, 0.07813673f, -0.06733089f, -0.01767840f, -0.06834309f, -0.21520230f, 0.11665869f, -0.04926540f, 
    0.00018851f, 0.01226964f, -0.10892320f, -0.28560507f, -0.75080967f, -0.28970906f, 0.22837746f, 0.37105587f, 
    -0.03245805f, 0.04675998f, 0.09832882f, -0.23819438f, -0.09202088f, -0.01126819f, 0.17854594f, -0.07209089f, 
    -0.02176211f, 0.08856935f, 0.07451767f, 0.06474762f, -0.20836771f, 0.04961753f, -0.43540713f, -0.17516205f, 
    -0.15892555f, -0.05501650f, 0.08044180f, 0.09453759f, -0.12761492f, -0.15651564f, -0.28399235f, -0.35914862f, 
    -0.36675853f, 0.42523590f, 0.55395514f, 0.07681276f, -0.01960152f, -0.08044836f, 0.26751834f, 0.10517543f, 
    0.08161180f, 0.06934290f, -0.22112373f, 0.17672276f, -0.02755026f, 0.02708304f, 0.01937124f, 0.22058719f, 
    0.09230144f, -0.03238711f, -0.08410493f, -0.08427640f, -0.11423663f, -0.07812590f, 0.09206709f, 0.06762554f, 
    -0.05573751f, -0.25615242f, -0.36669788f, -0.46200952f, 0.03825657f, 0.05699733f, 0.08045971f, 0.06520335f, 
    0.11433072f, 0.10611245f, -0.20396997f, -0.03668866f, -0.20498240f, 0.00364361f, -0.07815450f, -0.24118923f, 
    0.29692119f, -0.18680704f, -0.26424217f, 0.12444241f, -0.13915870f, -0.15973642f, 0.03286441f, -0.14442398f, 
    0.11819591f, 0.13926205f, -0.03243659f, 0.03774706f, 0.57169235f, -0.23044153f, -0.15562490f, -0.15071552f, 
    -0.20185074f, -0.21504886f, 0.21858332f, 0.18596838f, 0.08710133f, 0.04264311f, 0.05157930f, -0.12944651f, 
    0.01082273f, -0.33241591f, -0.15830672f, 0.26233232f, -0.01559475f, 0.27713132f, 0.07270648f, 0.09324631f, 
    0.05121849f, -0.09892717f, 0.17185180f, -0.13521875f, 0.00601329f, 0.15648681f, -0.04106034f, -0.03470287f, 
    0.13803212f, 0.06506367f, 0.02536689f, -0.00435898f, -0.04848174f, 0.02274726f, 0.06925153f, 0.10769086f, 
    -0.44633815f, -0.53890169f, -0.33385226f, 0.63443542f, 0.33833411f, 0.27152303f, 0.00910585f, -0.02690246f, 
    0.08290353f, 0.03444649f, 0.03553870f, 0.07612580f, 0.27436799f, 0.29217896f, -0.19161822f, 0.10779133f, 
    0.04279514f, 0.05766396f, 0.04035087f, -0.15364550f, -0.02206535f, 0.19730705f, 0.02393961f, -0.10918941f, 
    0.42893246f, -0.05649209f, 0.10952707f, -0.09350539f, -0.19801612f, -0.23531337f, -0.05400894f, -0.00046056f, 
    0.04070725f, 0.08665252f, 0.13213979f, 0.04618051f, -0.34869447f, -0.39055327f, -0.36399215f, 0.02869859f, 
    0.27780291f, -0.18427087f, 0.13876122f, 0.09896384f, 0.06561188f, 0.12287369f, 0.00583128f, 0.02947978f, 
    -0.04132629f, 0.12907349f, 0.03371625f, -0.06880558f, -0.07827301f, -0.05443826f, -0.11574183f, 0.11074144f, 
    -0.11723013f, 0.05452123f, 0.04636576f, 0.27344558f, -0.16164863f, 0.05371849f, 0.09551519f, 0.14607942f, 
    0.04439931f, 0.02517749f, -0.01429363f, 0.18797998f, -0.32397035f, -0.14424284f, 0.33903563f, -0.16971967f, 
    -0.07792152f, 0.08132695f, -0.01466291f, 0.10370686f, 0.19720346f, -0.00796459f, 0.04135643f, -0.04281940f, 
    -0.21362379f, 0.05284050f, 0.05078112f, 0.02187742f, -0.15109956f, -0.70886421f, 0.06673584f, -0.09536746f, 
    -0.08442992f, 0.16193819f, -0.10396703f, 0.05541367f, -0.02930699f, 0.00260311f, 0.19099225f, 0.12735121f, 
    0.06011841f, -0.01641243f, -0.21352684f, 0.18637504f, 0.08160552f, 0.04697713f, 0.07609490f, -0.53849548f, 
    0.20251329f, 0.15147771f, 0.07841620f, 0.16755445f, 0.01193210f, 0.20499508f, -0.12301126f, 0.03309275f, 
    0.00315064f, -0.17394920f, 0.12236184f, 0.00863064f, 0.05155532f, 0.02935283f, -0.07029927f, 0.26177588f, 
    -0.03630210f, -0.22498354f, -0.38517347f, -0.21222836f, -0.11075827f, 0.37863621f, -0.01687532f, 0.09631564f, 
    0.00599178f, -0.17854588f, -0.00007564f, 0.12717372f, -0.03614479f, 0.03227736f, -0.10350751f, 0.01925715f, 
    0.18488984f, 0.07610816f, -0.00071857f, -0.15868858f, 0.46033317f, 0.00308258f, -0.03306615f, -0.11116084f, 
    0.14365175f, 0.08934443f, -0.13119651f, -0.34552383f, -0.08937921f, 0.15039591f, -0.31955463f, -0.09479834f, 
    -0.12479270f, 0.04968120f, 0.18252760f, 0.07257988f, -0.07243092f, 0.32254952f, 0.10254894f, 0.01327422f, 
    -0.06374528f, -0.02751645f, 0.20316505f, 0.05004263f, -0.10920829f, 0.36372170f, 0.35160133f, -0.24159116f, 
    0.15264700f, 0.11422252f, 0.24728307f, 0.29406646f, 0.00799269f, 0.05106316f, -0.26451880f, -0.54025906f, 
    -0.23058282f, 0.03448375f, -0.13619073f, 0.40020484f, 0.07421325f, -0.05285913f, -0.29527792f, -0.26896963f, 
    -0.57390350f, 0.10976255f, 0.07098967f, 0.13243157f, 0.15497933f, -0.03681489f, 0.01580893f, 0.00056020f, 
    0.05794264f, 0.03037965f, -0.22657779f, 0.11333862f, 0.03211154f, -0.05231658f, 0.12491807f, 0.09804750f, 
    -0.07608447f, -0.37448320f, 0.14540473f, 0.01689145f, -0.05599874f, -0.20097440f, -0.07294162f, 0.06354668f, 
    0.00882939f, 0.04384743f, -0.10771590f, -0.24840847f, 0.60223442f, -0.03958933f, 0.00417583f, 0.08337268f, 
    -0.16625056f, 0.18105377f, 0.14955458f, 0.01168281f, 0.02738687f, -0.08803563f, 0.09795489f, -0.08834397f, 
    -0.05131605f, 0.21844856f, -0.04525558f, 0.03398433f, 0.03334724f, 0.07954963f, -0.03101323f, 0.09173010f, 
    -0.00197601f, -0.02882111f, -0.07265206f, 0.00950041f, 0.15004623f, -0.17396905f, -0.76813054f, -0.15715006f, 
    0.04006013f, -0.20775400f, -0.30478868f, 0.23952255f, 0.02712755f, -0.11225517f, 0.08240521f, 0.00591993f, 
    -0.20457028f, -0.16035260f, 0.04650294f, -0.11108288f, -0.14739808f, 0.17470743f, 0.06418634f, -0.24948308f, 
    -0.21808082f, -0.03892274f, 0.00763424f, 0.07760888f, -0.01278511f, -0.02801998f, -0.16252683f, 0.19192374f, 
    0.10829617f, 0.45456561f, -0.50764227f, 0.00907399f, -0.28040120f, 0.32243854f, 0.09423588f, -0.00465198f, 
    -0.02493949f, -0.31690493f, -0.09235512f, -0.21887428f, 0.06552167f, 0.03025425f, 0.03510340f, 0.11620708f, 
    -0.13469066f, 0.07661109f, -0.10759193f, -0.09014352f, -0.21272622f, -0.00092579f, 0.04317441f, -0.03545659f, 
    0.08244792f, -0.00246490f, -0.10748889f, -0.00843392f, 0.02542138f, 0.09898294f, 0.05181528f, -0.01294440f, 
    -0.05465630f, 0.12986496f, 0.02442125f, 0.07229220f, 0.97229201f, 0.44443175f, -0.46511027f, 0.07771923f, 
    -0.28621280f, -0.18264677f, -0.06534047f, 0.00912027f, 0.22775048f, -0.66967720f, -0.21569732f, 0.07144744f, 
    -0.38306808f, -0.05146200f, -0.51584619f, 0.07186475f, -0.02463828f, 0.07858787f, -0.09207164f, 0.00225792f, 
    -0.27757466f, -0.02294066f, 0.07651090f, 0.02283261f, -0.02557209f, 0.13515751f, 0.07356551f, -0.00748319f, 
    0.30212775f, 0.17381093f, 0.03201741f, -0.03068461f, 0.01517029f, -0.11899842f, 0.06981557f, 0.08695767f, 
    0.31646681f, 0.15724097f, 0.28413162f, 0.04571435f, -0.17677787f, -0.04226064f, 0.00451112f, 0.22241177f, 
    -0.07504574f, 0.24452327f, 0.20870595f, 0.12859255f, 0.03970844f, -0.04349619f, -0.23083618f, 0.00110730f, 
    0.03317894f, 0.16035290f, -0.36912534f, 0.27852127f, 0.27400175f, -0.05311508f, 0.18570709f, 0.08383594f, 
    0.01629721f, 0.10161564f, 0.10644811f, 0.15829957f, 0.36446065f, -0.06942177f, 0.14444095f, -0.05526564f, 
    -0.08363386f, 0.06665507f, -0.05387707f, -0.06230020f, -0.38664141f, -0.54140836f, 0.02713351f, -0.03781988f, 
    -0.14244683f, 0.17065002f, -0.08050505f, 0.01526047f, 0.06227437f, 0.08846130f, 0.24796614f, -0.02966963f, 
    0.20113227f, 0.07657772f, -0.12951949f, 0.02543733f, -0.03164417f, -0.04290939f, -0.20774294f, -0.35411221f, 
    0.20820312f, 0.05880914f, -0.02504694f, 0.13522543f, -0.06814144f, 0.06317493f, -0.00600340f, -0.01052696f, 
    -0.04197355f, -0.08541524f, 0.06770392f, -0.02968405f, -0.12565455f, 0.05701374f, -0.02645872f, 0.08180602f, 
    0.19435896f, -0.07100156f, -0.04917528f, -0.17185770f, -0.07281581f, 0.31811816f, -0.13895892f, -0.05825999f, 
    0.11266068f, 0.60271353f, -0.13196293f, 0.33625844f, -0.05488390f, -0.03573688f, -0.02336133f, -0.07460808f, 
    0.08906085f, 0.15951908f, -0.13216649f, 0.06260023f, 0.13979939f, 0.04744348f, -0.04817685f, -0.02506878f, 
    0.02348891f, 0.01347159f, 0.00784780f, -0.44102913f, -0.03069720f, 0.23834583f, -0.09056088f, -0.14082439f, 
    0.08345225f, -0.03533080f, 0.03850636f, 0.09362251f, 0.32636014f, 0.33100089f, 0.09036747f, 0.04973362f, 
    0.12990409f, -0.21938816f, 0.06422523f, 0.00642120f, -0.01301430f, -0.08824118f, 0.41041335f, -0.20917092f, 
    0.17014356f, -0.11958402f, 0.33143705f, 0.28303897f, -0.03396378f, -0.10318413f, -0.11712581f, -0.13529666f, 
    -0.34398592f, -0.10540109f, -0.18789172f, 0.24884318f, 0.06808573f, -0.12628596f, -0.07760818f, -0.13696277f, 
    -0.42801583f, -0.18159248f, 0.18582992f, 0.02445565f, 0.15984766f, 0.06327144f, -0.00308407f, -0.10004382f, 
    -0.04944592f, -0.02595723f, -0.18073228f, 0.17242640f, 0.02879858f, -0.10140516f, 0.03990459f, 0.10199232f, 
    -0.11916554f, 0.37461695f, 0.13183771f, -0.02058354f, -0.21282220f, -0.21110095f, -0.30297816f, 0.06920040f, 
    0.05878076f, 0.02767693f, 0.34563306f, -0.51385522f, 0.46013761f, 0.17090975f, 0.04497324f, 0.22213849f, 
    0.09948003f, -0.17484231f, 0.12776661f, -0.11022604f, -0.04166389f, -0.07115135f, -0.01532058f, 0.08355522f, 
    -0.11611624f, -0.03167069f, -0.09209045f, 0.14507374f, 0.08968703f, 0.08760088f, -0.06635708f, 0.06214822f, 
    0.09179436f, -0.06403339f, -0.01600641f, -0.06999194f, -0.08562134f, -0.15460077f, -0.38812998f, 0.23141055f, 
    -0.16677111f, -0.03417097f, -0.14213221f, 0.04618045f, -0.11851839f, -0.04125780f, -0.24816939f, 0.09319893f, 
    0.04126810f, -0.02436126f, -0.00862832f, -0.18402492f, -0.20933309f, 0.05595718f, 0.04337883f, 0.15684369f, 
    -0.33832422f, 0.08357173f, 0.13128908f, -0.09781104f, -0.16894482f, -0.01901543f, -0.06824111f, 0.28475180f, 
    -0.14212914f, 0.71617305f, -0.20061761f, 0.19773665f, -0.10092187f, -0.06422764f, 0.06339954f, 0.15383181f, 
    -0.00151698f, 0.48354971f, -0.19764771f, -0.28032002f, 0.04844977f, -0.11370330f, 0.08393056f, -0.00899268f, 
    -0.03628396f, 0.01523948f, 0.12602919f, -0.02546309f, -0.11197627f, 0.06738199f, 0.01443439f, 0.10903249f, 
    0.00842798f, 0.15300781f, -0.08070324f, -0.59762222f, -0.22570024f, 0.22681138f, -0.01564161f, 0.05789375f, 
    0.03496191f, 0.02821634f, 0.08219016f, 0.10576516f, -0.02685447f, 0.40332150f, -0.06542984f, 0.14612146f, 
    -0.17857231f, -0.27544025f, -0.06096643f, -0.12584092f, 0.15852919f, -0.10961004f, 0.16794871f, 0.06645741f, 
    -0.20334436f, -0.02780573f, -0.25679603f, 0.02568650f, 0.10085383f, 0.08919569f, 0.02529305f, 0.01572529f, 
    -0.17823413f, 0.09614261f, 0.20401193f, 0.01595046f, 0.06733683f, 0.01071276f, 0.09004983f, -0.39955696f, 
    0.17033693f, 0.29175332f, -0.05253730f, -0.15811430f, -0.07758822f, -0.04603674f, 0.02294054f, -0.07577859f, 
    0.15173680f, 0.09325923f, 0.01953493f, -0.00832803f, -0.23339653f, -0.14696483f, -0.04491482f, 0.06415232f, 
    -0.01439952f, 0.10591961f, 0.07583115f, 0.33807781f, -0.03269983f, 0.17389634f, -0.00788606f, 0.40742606f, 
    -0.01072066f, 0.02155641f, 0.20280446f, -0.66253769f, -0.85537624f, -0.04266125f, 0.01382044f, -0.03820609f, 
    -0.12961803f, 0.13970968f, 0.06123945f, 0.66489232f, -0.22901708f, -0.09990886f, 0.04146211f, 0.06493626f, 
    0.06805153f, -0.01285794f, 0.01062462f, -0.19775981f, -0.36464769f, -0.14155172f, -0.10219340f, -0.00778501f, 
    -0.19286360f, -0.10602742f, 0.04812951f, -0.05579584f, 0.01548007f, 0.46562913f, -0.01449710f, -0.04260666f, 
    0.08582831f, 0.06818268f, 0.00797991f, 0.10352009f, -0.09368774f, -0.04833443f, -0.38793805f, 0.08025386f, 
    0.11769373f, -0.07382941f, 0.07358540f, -0.00692486f, 0.22253017f, 0.07874943f, 0.09428208f, -0.11101270f, 
    -0.00481292f, -0.12155366f, 0.02437282f, -0.03257542f, -0.07613586f, -0.00378123f, 0.01301814f, 0.10812482f, 
    -0.37354091f, -0.67060500f, -0.48287630f, -0.04633925f, 0.14596498f, 0.32911488f, -0.07038844f, -0.04941210f, 
    0.02317036f, 0.01301492f, 0.08319832f, 0.10176142f, 0.03339732f, -0.03936089f, 0.01974276f, 0.17894854f, 
    0.14348716f, 0.35620236f, -0.17222317f, -0.21895118f, -0.26014066f, 0.02359691f, 0.18640687f, 0.09424346f, 
    0.00333347f, -0.03485771f, 0.11552464f, -0.86003083f, -0.79220903f, -0.61908203f, -0.04496965f, 0.08440679f, 
    0.01329498f, 0.02282505f, 0.01713237f, -0.01194669f, 0.15766312f, 0.22644618f, 0.20997946f, 0.03197427f, 
    0.11880828f, 0.12986973f, 0.29571038f, 0.02945761f, -0.09387388f, 0.30571479f, 0.45327285f, -0.24499413f, 
    0.29404730f, -0.00996401f, 0.22366574f, 0.23804975f, 0.00473951f, -0.29796043f, -0.35275280f, 0.35315180f, 
    -0.01068355f, 0.17453305f, 0.21901776f, 0.24464759f, 0.12616679f, -0.12316006f, -0.17029487f, -0.10092982f, 
    0.24158528f, 0.12837942f, -0.11046929f, 0.18727580f, -0.02666263f, -0.01679426f, -0.02469126f, -0.11811975f, 
    -0.10418707f, 0.21905600f, -0.14538525f, 0.08606398f, 0.03609305f, 0.00486986f, 0.02117645f, 0.04380031f, 
    -0.01854704f, -0.03144271f, -0.04034644f, -0.31945899f, -0.05463973f, 0.10032031f, -0.06823704f, 0.06538376f, 
    -0.14011112f, 0.05014697f, 0.00708763f, 0.08643506f, 0.22491519f, -0.02002318f, -0.18247913f, 0.08906233f, 
    0.03975313f, 0.11723774f, 0.08701490f, -0.06915426f, 0.10569563f, 0.02085170f, 0.14858820f, -0.08970583f, 
    0.02074583f, 0.05239213f, 0.08102582f, -0.08583254f, 0.19754960f, -0.02757232f, -0.11536851f, 0.00173432f, 
    -0.14490438f, 0.05666016f, 0.00539562f, -0.09092220f, -0.11543728f, 0.07046298f, 0.00323739f, -0.07654439f, 
    -0.03066631f, 0.06786899f, -0.00676355f, 0.02129561f, -0.12785865f, -0.15555350f, -0.26559436f, -0.11144711f, 
    0.03021214f, -0.27134213f, 0.14792967f, -0.03871560f, -0.02587045f, 0.04491553f, -0.04009390f, -0.12855013f, 
    -0.02221676f, -0.01323286f, -0.16538833f, -0.06839135f, -0.23784986f, -0.19602680f, -0.02720350f, 0.43923491f, 
    0.06363469f, 0.12881736f, -0.44310784f, -0.05855691f, -0.01271228f, -0.11310037f, 0.12664564f, 0.00458593f, 
    0.07381062f, 0.09639400f, 0.09924988f, 0.02970261f, -0.07441442f, 0.10767446f, 0.00829224f, -0.02371679f, 
    -0.06494037f, 0.00905616f, -0.00282911f, -0.00504694f, -0.11465166f, 0.01387308f, 0.09057795f, -0.00148971f, 
    0.05587718f, -0.02411041f, -0.08573323f, -0.14291511f, 0.08970208f, -0.10443524f, -0.07843115f, 0.07480748f, 
    -0.01330508f, -0.02371229f, -0.17081502f, 0.03728899f, -0.09913296f, 0.03427583f, -0.28326327f, 0.25752574f, 
    -0.18803827f, 0.13949223f, 0.04954744f, -0.02299042f, -0.12362728f, -0.20373604f, -0.22898290f, -0.18989019f, 
    -0.04783774f, -0.00179914f, -0.03806807f, -0.01787021f, -0.01196425f, -0.22512892f, -0.13704979f, 0.02331485f, 
    -0.00284055f, 0.09842795f, 0.08554238f, -0.10969904f, 0.08879839f, 0.05600107f, -0.03589971f, 0.06032022f, 
    0.20546454f, 0.00019811f, -0.16334108f, 0.06015682f, -0.01417239f, 0.04173259f, 0.22887015f, 0.23735131f, 
    -0.06976245f, -0.02284980f, -0.03693533f, -0.17315315f, 0.08910752f, 0.00572848f, -0.12746137f, 0.10690691f, 
    0.19542149f, 0.27580708f, -0.59746283f, 0.06986080f, 0.10901537f, -0.16573212f, 0.16171108f, 0.13413692f, 
    -0.22773337f, -0.06824090f, 0.22959982f, -0.03029841f, -0.24652644f, -0.19947793f, 0.06891457f, -0.09523403f, 
    0.03725251f, 0.02966375f, -0.05819775f, 0.44432223f, -0.09586497f, -0.71912354f, 0.02912630f, 0.09100676f, 
    0.24354301f, 0.00602389f, 0.11906748f, 0.06762695f, 0.03517081f, -0.22857754f, -0.09622127f, 0.05988016f, 
    0.00431216f, -0.27023914f, -0.14987403f, -0.08803151f, 0.00657258f, 0.10855988f, -0.15004537f, -0.37213272f, 
    0.03341605f, 0.31528732f, 0.13892914f, 0.10928820f, 0.07587346f, 0.05502235f, -0.10269249f, -0.27305561f, 
    0.38464972f, 0.38425982f, -0.05618307f, 0.21099071f, -0.03650575f, -0.11790860f, 0.22958262f, -0.10002368f, 
    0.24965563f, 0.13590214f, 0.06062092f, -0.11429451f, -0.20194656f, 0.07786462f, -0.01788265f, 0.33032364f, 
    0.17011067f, -0.48120305f, -0.02997346f, -0.03910987f, -0.05889878f, 0.07237653f, 0.03226903f, 0.05048930f, 
    -0.07925384f, 0.14371933f, -0.43797413f, -0.13007478f, -0.10024795f, 0.12316488f, -0.09549243f, -0.06313129f, 
    -0.04746797f, 0.09145916f, 0.22098894f, 0.07342012f, -0.28531969f, -0.11719374f, 0.17431232f, 0.06429981f, 
    0.15434074f, 0.02013554f, 0.02203482f, -0.17671447f, 0.31368640f, -0.43614575f, 0.06795584f, 0.11960493f, 
    0.18790314f, 0.14357539f, 0.16853288f, 0.09450214f, 0.00433015f, -0.07007833f, 0.16412158f, 0.05890758f, 
    0.10846423f, 0.12656173f, 0.24932443f, 0.23261012f, -0.10232765f, -0.36061946f, 0.05158500f, -0.02912796f, 
    0.23725832f, 0.17772064f, -0.09695721f, 0.34683716f, -0.12321547f, 0.18090874f, -0.92090863f, 0.37559932f, 
    -0.47647092f, 0.20288402f, 0.16641581f, 0.14229307f, 0.29856294f, -0.01629090f, -0.01470012f, 0.01189307f, 
    0.18415107f, 0.33303022f, 0.07831948f, -0.05317095f, 0.00990260f, -0.12491161f, 0.17460181f, 0.06458507f, 
    -0.13636911f, 0.19385605f, 0.16581120f, 0.16647954f, 0.04024021f, 0.02728005f, 0.06709146f, 0.16802980f, 
    0.10287052f, -0.35479218f, -0.73194563f, -0.81411457f, 0.14290491f, 0.08182041f, -0.02627290f, -0.08375037f, 
    -0.00555712f, 0.13987413f, 0.23730370f, -0.14878207f, 0.11781488f, 0.05986609f, 0.04559040f, -0.15091257f, 
    -0.27080289f, 0.06085407f, 0.28953657f, 0.11811444f, 0.11026242f, 0.13467969f, 0.11726615f, -0.03055680f, 
    0.08535971f, 0.14052238f, -0.05386438f, 0.13576850f, -0.05945769f, -0.17117994f, -0.14078885f, -0.04653586f, 
    0.02070242f, 0.04335463f, 0.01888066f, 0.25516817f, 0.01726197f, -0.55066842f, -0.07067828f, -0.13960348f, 
    -0.02134741f, 0.05476655f, -0.05530563f, -0.05032639f, -0.07511716f, 0.04805484f, -0.26213554f, 0.11632493f, 
    0.09318288f, 0.04174104f, -0.07982389f, -0.16819642f, -0.22051939f, -0.12965122f, 0.10121042f, -0.16790102f, 
    0.10658194f, -0.08317556f, -0.19617920f, -0.00660529f, 0.03812522f, 0.12913747f, 0.00788594f, 0.22591668f, 
    -0.20657597f, -0.18926337f, 0.48304594f, 0.14363517f, -0.15198265f, 0.06254849f, 0.05740249f, -0.08587126f, 
    -0.03031032f, -0.10931304f, -0.06266052f, -0.37900847f, -0.07084525f, -0.03614242f, 0.27936533f, 0.12860091f, 
    -0.01432714f, -0.23081784f, -0.12111764f, 0.07888365f, -0.07696860f, 0.05404744f, -0.13172244f, -0.02988943f, 
    0.09283034f, 0.05427029f, -0.03316190f, -0.94231379f, -0.33800429f, -0.05070702f, 0.03651340f, -0.07222794f, 
    0.05533256f, 0.02659660f, -0.12251523f, 0.16266328f, -0.45811942f, 0.16384251f, -0.03972645f, 0.16980529f, 
    -0.22450973f, -0.17193812f, -0.08790427f, -0.12931600f, 0.00912952f, 0.04628236f, 0.25978446f, -0.37430140f, 
    -0.11157348f, -0.04089464f, -0.22600821f, 0.05701685f, 0.08297574f, 0.07002925f, -0.21685632f, 0.03690543f, 
    0.14207868f, 0.05245093f, -0.13144642f, -0.00915231f, 0.00559615f, 0.03927612f, 0.07526244f, -0.69445390f, 
    -0.02957734f, 0.05790409f, -0.01298364f, -0.05763315f, 0.11482619f, 0.03908283f, 0.08835958f, 0.22346255f, 
    -0.10450093f, 0.18786055f, 0.19105241f, 0.14300160f, -0.02622886f, -0.18839563f, 0.14832868f, -0.04763886f, 
    0.07353954f, -0.13486545f, -0.17754088f, -0.15831511f, -0.00267533f, 0.20835012f, -0.02281874f, 0.11805663f, 
    0.16483539f, -0.04900813f, 0.67417896f, 0.26629034f, 0.02381905f, -0.00219649f, -0.07645480f, -0.02925475f, 
    -0.06624220f, -0.01919470f, 0.17354198f, -0.05293119f, -0.17912701f, 0.02246320f, -0.03642767f, 0.11767500f, 
    -0.00559579f, -0.01025938f, 0.04765051f, 0.12749153f, 0.39739668f, -0.30166221f, -0.36944592f, -0.23413745f, 
    -0.02288966f, 0.10874789f, 0.12797092f, -0.13339087f, 0.18484087f, -0.10462896f, -0.02494489f, 0.09353625f, 
    -0.03856547f, 0.17154001f, 0.00878477f, 0.01656517f, 0.11375897f, 0.01988721f, 0.16443714f, -0.10965612f, 
    -0.08477363f, -0.24863827f, -0.18835102f, 0.18094793f, -0.10319429f, 0.06587834f, -0.11936712f, 0.10568591f, 
    0.01957998f, 0.24410105f, -0.28564858f, -0.35702229f, -0.48662978f, 0.01038518f, -0.14315239f, -0.02590596f, 
    0.25965723f, 0.02307988f, 0.12454065f, -0.18685503f, 0.10627204f, -0.05794313f, -0.10705838f, 0.11473083f, 
    -0.37943760f, -0.32640502f, -0.06319613f, 0.03615713f, 0.01911619f, 0.06300846f, 0.15598761f, 0.08284154f, 
    0.21866320f, 0.18292227f, -0.12717417f, -0.07740250f, -0.29956689f, -0.08400004f, -0.08087707f, 0.05657139f, 
    0.09339972f, 0.04605755f, -0.04579984f, 0.36271855f, 0.00893031f, 0.26301557f, -0.01908002f, 0.04457201f, 
    -0.03473200f, -0.12138412f, 0.01004371f, 0.13909858f, -0.05397925f, 0.01104503f, -0.00414434f, 0.01350029f, 
    -0.05061642f, -0.03635164f, 0.08050022f, 0.17745754f, 0.07588898f, -0.35410824f, -0.01668296f, 0.24338144f, 
    -0.14692481f, 0.16641884f, -0.17525630f, -0.07734284f, 0.02697776f, 0.09904375f, 0.13739173f, -0.41223326f, 
    -0.65850890f, -0.03556599f, -0.07071719f, 0.14492926f, 0.02458398f, -0.09514493f, 0.13570458f, -0.01502635f, 
    0.12685120f, -0.48921710f, 0.09363099f, -0.02522240f, 0.20964305f, 0.14056346f, 0.07958752f, 0.00310013f, 
    -0.08676707f, 0.09385753f, -0.18580650f, 0.02435052f, 0.14034468f, -0.11096653f, 0.00310294f, 0.01279757f, 
    0.03342497f, -0.53073347f, -0.01819041f, 0.22065619f, -0.06989518f, -0.00245307f, -0.02073071f, 0.14269023f, 
    -0.22017543f, 0.22080217f, 0.01228181f, 0.13434272f, -0.01104178f, 0.04667541f, -0.22287712f, -0.01567738f, 
    0.29703832f, -0.18579917f, 0.04135950f, -0.07069821f, 0.10873821f, 0.06021090f, -0.10029601f, -0.06132387f, 
    -0.10555553f, 0.15174317f, 0.09351595f, 0.00574373f, -0.05585383f, 0.10181551f, 0.12076431f, 0.00765140f, 
    0.13851424f, 0.03829323f, 0.01205440f, 0.15876877f, 0.15921137f, 0.35570818f, 0.37939194f, -0.01399827f, 
    -0.05906554f, 0.09737028f, 0.01860988f, -0.02233938f, -0.06650155f, 0.02021137f, 0.40828633f, -0.00519562f, 
    0.02904864f, 0.00884957f, 0.07492773f, 0.15341200f, 0.12810913f, 0.00633527f, 0.00105302f, -0.04770133f, 
    -0.05094071f, 0.15401818f, 0.17964046f, 0.13091406f, -0.12073810f, -0.09077308f, -0.16477296f, -0.06971146f, 
    0.60176319f, 0.11830440f, 0.28696525f, -0.15728688f, 0.04344925f, -0.10385276f, 0.00128116f, -0.01915310f, 
    -0.15602760f, -0.13829860f, 0.08645979f, -0.07194445f, -0.36442724f, 0.05174522f, -0.20479465f, 0.04826222f, 
    0.01651216f, 0.06379574f, 0.00587092f, 0.03334618f, -0.02929606f, -0.06412697f, -0.32202062f, -0.28923965f, 
    0.11004033f, -0.01314285f, 0.12828074f, -0.14528665f, -0.03891066f, -0.09922336f, -0.07354890f, -0.11357219f, 
    0.09787580f, 0.08770184f, -0.31516707f, -0.06411729f, -0.03238505f, -0.07383635f, 0.33555114f, -0.34218764f, 
    0.07474983f, -0.30929714f, 0.12465957f, 0.07726581f, -0.01129656f, 0.28507343f, 0.19496046f, -0.05576951f, 
    -0.06196894f, 0.04726004f, -0.02975038f, 0.01385841f, -0.05430653f, -0.01130195f, 0.16003078f, 0.07868303f, 
    0.10328536f, -0.28775164f, -0.25895831f, -0.37456483f, 0.08018769f, 0.04124420f, -0.04516491f, -0.11240891f, 
    0.01944636f, 0.33837900f, 0.03676807f, -0.03947405f, -0.06214066f, 0.18600999f, 0.16980413f, 0.18406972f, 
    -0.06691201f, -0.01564179f, -0.04241113f, -0.00184569f, -0.06719638f, -0.05511401f, -0.04040948f, 0.03641683f, 
    0.00538533f, 0.03693081f, -0.04717289f, 0.00963032f, 0.00949113f, -0.03060050f, -0.02334255f, -0.01097258f, 
    0.03285424f, 0.02787530f, -0.04837884f, -0.01244970f, -0.02512997f, -0.00832128f, -0.00956235f, -0.06167452f, 
    0.00039177f, -0.06543048f, -0.00963945f, -0.04852517f, -0.06311025f, -0.04887316f, -0.06804847f, 0.00873890f, 
    -0.05865399f, -0.01528155f, 0.02393273f, -0.03559429f, -0.05171729f, 0.01212346f, -0.02308238f, -0.04624300f, 
    0.03977579f, 0.03189350f, -0.04262625f, 0.01472955f, 0.04015700f, 0.03087056f, 0.01749904f, -0.00462590f, 
    0.00312137f, -0.06014862f, 0.01565046f, -0.01288992f, -0.05512461f, 0.01646689f, 0.03778287f, 0.04777941f, 
    0.01200470f, 0.03775423f, -0.05735105f, -0.05860126f, 0.01564638f, 0.04634925f, 0.03006807f, 0.04652981f, 
    -0.01992515f, 0.03708105f, -0.01927724f, -0.00516633f, 0.00939249f, -0.02344638f, -0.00593379f, -0.05793170f, 
    -0.00600376f, -0.04175549f, -0.00757708f, -0.06458389f, -0.03224214f, 0.03958471f, -0.03648650f, 0.02865924f, 
    0.03373202f, -0.04831707f, -0.04751962f, 0.01013282f, -0.03916305f, 0.04909358f, 0.03518800f, -0.02042732f, 
    0.00377586f, -0.04624462f, -0.06106049f, -0.00896385f, -0.04250781f, -0.05184647f, 0.00305228f, -0.03514917f, 
    0.02362345f, 0.02360059f, 0.01397089f, -0.00895203f, 0.01257194f, -0.05444418f, -0.02287941f, -0.05034163f, 
    -0.05615863f, 0.00744602f, 0.01255963f, 0.00945188f, -0.03083244f, -0.06171321f, -0.02575100f, -0.03889566f, 
    0.04639898f, 0.00105723f, 0.04076646f, 0.01293330f, -0.00075345f, -0.05325521f, 0.04806403f, 0.00329571f, 
    -0.06321050f, 0.01476833f, -0.02085400f, 0.01176063f, 0.02026323f, 0.02391494f, 0.01539378f, 0.00245859f, 
    0.03380460f, 0.03038589f, 0.04004885f, -0.05906943f, -0.04555625f, -0.05741568f, -0.03219011f, -0.03550411f, 
    -0.01392056f, -0.01343068f, 0.01165431f, -0.02503574f, -0.06653406f, -0.06584509f, -0.03203396f, -0.05008455f, 
    -0.06316710f, 0.02985195f, 0.02634011f, -0.01397254f, -0.02451178f, -0.03561301f, -0.03295167f, 0.00813104f, 
    -0.00361457f, -0.00456500f, -0.05178681f, -0.00664104f, 0.04133816f, -0.02867682f, -0.04533561f, 0.03108233f, 
    0.02617014f, -0.02915401f, 0.04878865f, 0.02044178f, -0.02203497f, -0.00291758f, 0.03447457f, 0.02207584f, 
    -0.04603984f, 0.04401468f, -0.01722607f, -0.03542421f, -0.05681372f, -0.02436055f, -0.04081522f, -0.04341164f, 
    -0.05919275f, 0.04878130f, 0.03041331f, -0.01876994f, 0.01784925f, -0.06373092f, 0.04389539f, -0.00880658f, 
    0.00190967f, 0.02566680f, 0.04567830f, 0.03664823f, -0.03841433f, -0.02874804f, 0.00416484f, -0.02459634f, 
    -0.04931559f, 0.04947241f, -0.05192379f, 0.01783309f, -0.05458332f, -0.06104120f, 0.03657031f, 0.02593919f, 
    -0.03407793f, -0.02015836f, 0.04115738f, 0.04295515f, -0.05012051f, -0.01543065f, -0.05134673f, -0.03607503f, 
    0.00584765f, 0.00564822f, -0.00486376f, -0.04823631f, 0.00398156f, -0.04064522f, 0.03315153f, -0.03750688f, 
    -0.05317333f, -0.00390534f, 0.02615022f, -0.04704650f, -0.03475256f, -0.06341995f, -0.03061403f, 0.01133698f, 
    0.00971455f, 0.00923113f, 0.01665749f, 0.00357134f, -0.02386871f, -0.03005916f, 0.01383135f, -0.06017222f, 
    -0.02740283f, 0.04309249f, -0.01391196f, 0.04761853f, -0.06247191f, 0.02486809f, -0.01340414f, 0.04334269f, 
    -0.01707992f, -0.02669939f, 0.01566400f, 0.04875394f, 0.01228334f, -0.01818931f, -0.06222566f, 0.02093412f, 
    -0.02185443f, -0.04536713f, -0.03920706f, 0.04689305f, -0.00121161f, 0.01119519f, 0.01056684f, -0.06211353f, 
    0.04258895f, 0.02024452f, -0.03815675f, -0.00478116f, -0.01030284f, -0.00164215f, -0.03313967f, -0.03652985f, 
    -0.04891022f, -0.03883767f, -0.06295224f, 0.04896410f, 0.00603144f, 0.02778137f, 0.04808228f, -0.03754189f, 
    0.03724109f, -0.04678421f, 0.00893211f, -0.04909127f, -0.01054178f, -0.05527017f, -0.02302337f, 0.00032583f, 
    -0.03819060f, 0.01586810f, -0.01190416f, 0.03384621f, 0.02256650f, -0.06602472f, -0.00595981f, -0.02214304f, 
    -0.08521312f, 0.11952414f, -0.27439794f, -0.12770164f, -0.19724013f, -0.25267848f, -0.01018020f, -0.09293304f, 
    -0.03605866f, 0.06577805f, 0.27353859f, 0.01008017f, 0.00742026f, -0.00537885f, 0.09135072f, 0.23393835f, 
    -0.02467570f, -0.00532229f, -0.17572299f, -0.33512124f, -0.29234812f, -0.16801652f, -0.04492577f, -0.04641432f, 
    -0.08914841f, -0.06756738f, 0.27991146f, 0.42261308f, -0.17550193f, -0.09435591f, 0.15480812f, 0.02100591f, 
    -0.03611665f, 0.14834166f, -0.04213842f, 0.13021703f, -0.90828454f, 0.13939387f, 0.30141786f, -0.06073999f, 
    0.25020596f, 0.06760106f, 0.00154881f, -0.03957573f, 0.14738037f, 0.17458297f, -0.02374765f, 0.07200812f, 
    0.15875527f, -0.02706641f, -0.10233358f, 0.05021514f, -0.05371005f, -0.00595546f, -0.25274181f, 0.03880384f, 
    0.23264687f, -0.04375404f, 0.41099316f, 0.12126015f, 0.06174611f, 0.24995495f, 0.14985338f, -0.08200318f, 
    -0.02532131f, -0.29062358f, -0.11761972f, -0.17468357f, 0.10556369f, 0.05513176f, 0.10939729f, 0.03547835f, 
    -0.46265543f, -0.20583874f, -0.52323693f, 0.00043032f, 0.12328517f, -0.10221193f, 0.14490977f, 0.14241670f, 
    0.25989309f, -0.05524655f, 0.32608399f, 0.10619570f, 0.01461838f, -0.04016011f, -0.15166710f, 0.14261006f, 
    0.29651287f, 0.18277340f, -0.37783915f, 0.00796117f, 0.10799244f, 0.06392007f, 0.16342513f, 0.02308004f, 
    0.07356882f, 0.07364630f, 0.26276243f, 0.01536433f, -0.43360281f, -0.42211485f, 0.02786508f, 0.18216686f, 
    0.10458117f, 0.11641510f, -0.03869475f, 0.06352931f, 0.11684283f, -0.13929716f, 0.20937471f, 0.21457359f, 
    0.15377769f, 0.10001357f, 0.13865009f, 0.16407530f, -0.08575147f, 0.22587098f, -0.34291127f, -0.00385538f, 
    0.08151320f, 0.15102193f, 0.11608709f, -0.17450596f, 0.06259899f, 0.03927750f, 0.28829822f, -0.80613840f, 
    -0.08979946f, 0.26955304f, -0.13097225f, 0.17196937f, 0.08726787f, 0.05555258f, -0.08936860f, -0.26188856f, 
    0.24481823f, 0.31399709f, 0.02732795f, 0.04552837f, 0.08606368f, -0.03471056f, 0.09090486f, -0.07513987f, 
    0.21083093f, -0.01699388f, 0.25980291f, -0.01933839f, 0.15197194f, 0.11321604f, 0.13330498f, -0.00037243f, 
    -0.04165835f, -0.11883984f, -0.08242342f, -0.08920643f, 0.06636357f, -0.13935661f, -0.15543915f, 0.17982703f, 
    -0.11296601f, 0.01219125f, -0.12348244f, 0.10635885f, 0.19456875f, -0.13765062f, -0.05707065f, -0.02667221f, 
    0.05188710f, 0.13087067f, 0.10753258f, 0.13053696f, 0.05875782f, -0.05155470f, 0.05961316f, -0.03590610f, 
    0.05681621f, 0.12486977f, 0.10146100f, -0.06547133f, 0.07695237f, -0.39062360f, 0.00411356f, -0.07504044f, 
    -0.19497450f, -0.11502774f, -0.24080791f, -0.16983677f, -0.14155611f, -0.26060310f, -0.39021930f, -0.18906303f, 
    -0.00100062f, 0.00269960f, -0.14002596f, -0.06631824f, -0.04952094f, -0.30500725f, -0.45149922f, -0.30539548f, 
    -0.07767111f, -0.17661299f, -0.02732470f, 0.08690862f, 0.07250607f, 0.17329524f, -0.15009853f, -0.01433596f, 
    0.11811732f, 0.00057159f, -0.06433108f, -0.08618611f, -0.00555071f, 0.01257758f, 0.07802441f, 0.12802707f, 
    -0.95437592f, 0.09681762f, -0.14585559f, -0.04568788f, 0.13924290f, 0.12580484f, -0.06441457f, -0.11048100f, 
    0.16507737f, -0.00761359f, 0.20232016f, 0.08477078f, -0.02785886f, 0.10184105f, 0.05973452f, 0.06434598f, 
    0.16328764f, 0.03280330f, -0.18737735f, -0.21172631f, -0.29497537f, -0.11583730f, -0.23420736f, -0.08297494f, 
    0.07864754f, -0.13833144f, -0.12976837f, 0.00121375f, 0.15466875f, -0.22133307f, 0.01142185f, -0.10492398f, 
    -0.07127517f, 0.15445521f, 0.01605444f, 0.15891796f, 0.00048907f, 0.21915822f, -0.30613881f, -0.13943507f, 
    0.11998273f, 0.22385602f, -0.11539333f, -0.23855439f, 0.13426754f, -0.83094221f, -0.87327009f, -0.43191597f, 
    0.01276612f, -0.07021513f, -0.15675120f, -0.04187459f, -0.10247154f, -0.08683342f, -0.06406306f, -0.06631783f, 
    -0.30003554f, -0.09929670f, -0.17673331f, 0.08914026f, 0.15569930f, 0.06034943f, -0.13456115f, 0.35161093f, 
    0.19924968f, -0.13596773f, 0.13562712f, -0.10324239f, 0.04479754f, -0.05314889f, 0.04616921f, 0.25463367f, 
    -0.03482438f, -0.01807972f, 0.02234183f, -0.04065552f, 0.03675040f, 0.02080968f, 0.03631433f, 0.01281581f, 
    -0.02538369f, 0.02781967f, 0.03545307f, 0.02546237f, -0.00296844f, -0.02790957f, -0.04349159f, 0.00558339f, 
    -0.02823145f, 0.01174588f, -0.02313944f, -0.04048783f, -0.04974432f, -0.02122591f, -0.00890514f, -0.03142307f, 
    -0.05695518f, 0.04475740f, -0.05511934f, -0.02949997f, -0.03862832f, -0.01768972f, -0.00937190f, 0.02933927f, 
    0.00491334f, 0.00483028f, 0.02961059f, -0.06360421f, -0.01196135f, 0.01474847f, -0.02949644f, 0.02191005f, 
    0.04704425f, -0.04114412f, -0.02066952f, 0.02332462f, 0.00283606f, -0.03325459f, 0.01403920f, 0.04825762f, 
    0.04379962f, 0.04347038f, -0.05035059f, -0.01304329f, -0.00656780f, -0.06094497f, 0.02674403f, -0.01388656f, 
    -0.03449152f, -0.02795587f, -0.02635896f, 0.01460167f, -0.02729563f, 0.01029281f, 0.02438856f, 0.04995285f, 
    -0.05372116f, -0.04932063f, 0.03686747f, -0.04694290f, -0.00522627f, -0.00976292f, 0.04357305f, -0.01300776f, 
    -0.02067952f, -0.01635456f, 0.04204611f, -0.04276897f, -0.01294085f, 0.05307485f, 0.04258266f, -0.02563491f, 
    0.01501405f, 0.01160822f, 0.00132703f, 0.05254650f, -0.00298697f, 0.00726774f, -0.00330188f, 0.01824756f, 
    -0.03365049f, 0.04385391f, 0.00334665f, -0.04635547f, -0.00148986f, -0.01199566f, -0.01989704f, -0.03836922f, 
    0.00187560f, -0.00035742f, 0.01629709f, 0.03605355f, -0.04857598f, -0.01944040f, -0.06382674f, -0.03959787f, 
    -0.04525587f, -0.04966782f, -0.02622533f, 0.02033002f, -0.04799357f, 0.00118174f, -0.03369112f, -0.00268834f, 
    0.01095348f, -0.05369421f, -0.04083723f, 0.03726344f, -0.00236476f, -0.03364069f, 0.04336236f, 0.03946262f, 
    0.03731316f, -0.03408053f, 0.03258278f, 0.04203368f, -0.05392387f, 0.02267075f, -0.05803968f, 0.02416240f, 
    0.04746915f, -0.05258660f, -0.00965622f, -0.02164587f, -0.01437152f, -0.03649050f, -0.01302463f, -0.02183070f, 
    -0.05439112f, -0.00003739f, 0.01004204f, 0.05141823f, -0.05120930f, 0.01044570f, 0.00366033f, 0.04106970f, 
    -0.04673226f, -0.05998576f, -0.05593546f, 0.01653399f, 0.00317299f, -0.04846145f, -0.01200784f, 0.04322794f, 
    0.03801065f, -0.03191484f, 0.00120976f, -0.03698161f, -0.03243855f, -0.04489553f, 0.02285150f, 0.00098653f, 
    -0.03955341f, 0.01035079f, -0.02433019f, -0.04948184f, -0.00682759f, -0.02509281f, -0.02745635f, -0.00495862f, 
    0.03774128f, 0.01335378f, -0.05067245f, -0.04679873f, 0.00612789f, -0.00780299f, 0.04786904f, -0.00593547f, 
    -0.01910248f, -0.05299489f, 0.00796528f, -0.00440720f, 0.03444247f, -0.01990688f, -0.04159255f, -0.04798401f, 
    -0.01341003f, -0.05477959f, -0.03845587f, 0.01541820f, 0.00924659f, 0.03704086f, -0.02847273f, -0.03601172f, 
    -0.03073559f, 0.02416507f, -0.02832055f, -0.03533329f, 0.03202041f, 0.04866426f, -0.04555809f, 0.01778295f, 
    -0.04174620f, 0.00582085f, -0.03883847f, -0.01859039f, 0.02558002f, -0.00394948f, 0.01281644f, -0.01058635f, 
    -0.00314149f, -0.00186420f, 0.01411549f, -0.00807670f, -0.03955786f, -0.03634027f, 0.00786591f, 0.03652852f, 
    0.00534801f, -0.00611747f, -0.03464173f, -0.03210847f, -0.05903740f, -0.02233263f, 0.01533469f, -0.01804408f, 
    -0.06206410f, 0.02108627f, -0.00723439f, -0.00369606f, 0.02941411f, -0.02906545f, -0.04014002f, -0.03621702f, 
    0.04103402f, -0.02957976f, -0.00371831f, -0.00542407f, -0.03280813f, -0.05770052f, 0.02377707f, 0.01972938f, 
    0.02249685f, -0.02298957f, -0.03187797f, -0.06308165f, 0.02658648f, -0.01141454f, -0.03725652f, -0.01924408f, 
    -0.02237739f, 0.02582587f, 0.04498195f, -0.04884498f, 0.00815919f, -0.05644767f, 0.03837705f, -0.02474288f, 
    -0.00991511f, 0.01901582f, -0.04202249f, -0.04445846f, 0.01715481f, -0.01298632f, -0.04878024f, 0.05458811f, 
    0.01131785f, 0.05788507f, -0.06192994f, 0.00487502f, -0.02681734f, -0.05847257f, -0.00136412f, -0.01684697f, 
    0.05452920f, -0.00312699f, -0.00529600f, 0.02301811f, -0.02533275f, -0.00159843f, -0.04032402f, 0.00195782f, 
    0.04368974f, 0.01958262f, -0.04572845f, 0.05127121f, -0.02856171f, 0.02960688f, -0.02229327f, -0.06022391f, 
    -0.05462820f, 0.00579013f, -0.03070478f, 0.01416719f, 0.00866302f, -0.05801168f, -0.02334544f, -0.06382641f, 
    0.00864736f, -0.04874825f, 0.00918608f, 0.02717620f, 0.01420022f, -0.06537923f, -0.03875799f, 0.00377629f, 
    0.01251650f, -0.04179658f, -0.03940431f, 0.00310681f, 0.02291270f, 0.01713163f, 0.01165395f, 0.04552957f, 
    0.02227820f, 0.02844263f, -0.02850348f, -0.01766927f, -0.04404332f, -0.06285694f, -0.02245924f, 0.01998970f, 
    -0.02008289f, 0.02417563f, -0.07170600f, -0.00520032f, -0.00057557f, -0.03353122f, -0.07964176f, -0.06237124f, 
    -0.01424394f, -0.05699553f, -0.07037731f, -0.05757260f, 0.02497427f, -0.06458827f, -0.00365726f, -0.05538743f, 
    -0.03449095f, -0.07971984f, -0.07381971f, -0.06901769f, -0.04886048f, -0.05818791f, 0.01465559f, -0.04456389f, 
    -0.03490094f, -0.06246184f, -0.04218368f, 0.00460712f, 0.00680486f, -0.02379134f, -0.06406288f, -0.03990087f, 
    -0.03032470f, -0.02840370f, -0.01533057f, -0.01804091f, -0.00071263f, 0.03329479f, 0.02956825f, 0.01093438f, 
    -0.00548342f, 0.05152169f, 0.02468331f, -0.06599836f, -0.06407002f, -0.00438160f, 0.02287895f, -0.05603291f, 
    -0.04446637f, 0.00075404f, -0.01349902f, 0.01564517f, -0.06776302f, 0.01508218f, -0.00589948f, 0.02088768f, 
    -0.02774036f, -0.02826810f, -0.00151002f, -0.03232250f, -0.05787389f, -0.06147350f, -0.04678199f, -0.00085995f, 
    -0.04542826f, -0.07136518f, -0.05547644f, 0.02033973f, 0.02728085f, 0.04401717f, -0.01807080f, 0.00667066f, 
    0.03309737f, -0.03207597f, -0.02672952f, -0.08767685f, -0.05665684f, -0.03577467f, -0.06744131f, -0.07138740f, 
    -0.03323078f, 0.00227142f, -0.04181330f, -0.00862456f, 0.00383375f, -0.00982294f, 0.01338784f, 0.02817284f, 
    -0.02700767f, -0.04411650f, 0.00980072f, 0.01004312f, 0.02946916f, -0.04878967f, -0.02923959f, -0.03564411f, 
    0.00714092f, 0.01502264f, -0.05350229f, 0.02318412f, -0.00709601f, -0.03475928f, 0.01307455f, -0.04462872f, 
    -0.03607893f, -0.06761710f, -0.02755033f, -0.07069663f, -0.03045810f, 0.02262807f, -0.06782716f, -0.07873856f, 
    0.03473911f, 0.01332175f, -0.01834987f, -0.05681944f, 0.00831335f, -0.05222186f, -0.02406436f, 0.00600679f, 
    -0.01959489f, 0.01129960f, 0.03185028f, 0.03639315f, -0.08548462f, 0.00404320f, 0.00843250f, 0.01177792f, 
    0.02438430f, -0.05198004f, 0.01023113f, -0.06748209f, -0.00193095f, -0.00040904f, -0.00358342f, -0.02931552f, 
    -0.02319077f, 0.00875873f, -0.02102653f, 0.00347893f, 0.01968201f, -0.07610934f, -0.04179444f, 0.00484573f, 
    0.02480596f, -0.04883892f, -0.05388092f, -0.04699219f, -0.01923152f, 0.02516758f, -0.04552594f, -0.03679044f, 
    0.02623630f, 0.00410409f, 0.02044830f, -0.02734493f, -0.00938103f, -0.05093777f, -0.02821581f, -0.02154403f, 
    -0.04254678f, -0.05785576f, 0.00288716f, -0.01445125f, 0.02155678f, -0.06005861f, -0.06006248f, -0.06481078f, 
    0.03882975f, -0.06333554f, -0.02595129f, 0.00236874f, -0.00573629f, 0.00336200f, 0.02170308f, -0.00319012f, 
    0.02148250f, -0.02859422f, 0.01014646f, 0.00524407f, -0.04895218f, -0.02839490f, 0.01861661f, -0.02774704f, 
    -0.00583808f, -0.04778877f, 0.02609272f, -0.06589163f, -0.02151405f, -0.05038657f, -0.07614244f, 0.03423393f, 
    -0.01868649f, -0.04051568f, -0.07697413f, -0.04941647f, -0.06396949f, 0.01465600f, -0.06864737f, -0.02947182f, 
    0.01490632f, -0.04498418f, -0.03977769f, -0.07322861f, 0.00919119f, -0.04932261f, 0.02255412f, 0.00961804f, 
    -0.04094407f, 0.01298203f, -0.01410102f, -0.01606181f, 0.00392017f, 0.02499734f, -0.04910578f, -0.04586539f, 
    -0.03286744f, -0.06783625f, 0.00564310f, 0.02485972f, -0.02673985f, 0.01505730f, -0.03197889f, -0.06496162f, 
    -0.04529992f, -0.04707466f, 0.00976051f, 0.02785216f, 0.00707919f, -0.05593545f, 0.05248561f, 0.01382104f, 
    -0.06923652f, -0.06783348f, -0.06485649f, -0.07867950f, -0.05917688f, -0.04483129f, -0.01137922f, -0.03407239f, 
    -0.07955991f, -0.05754160f, 0.02041783f, -0.03721307f, 0.01149416f, -0.06950165f, 0.03334577f, 0.00797407f, 
    0.02020219f, 0.03170165f, -0.05853497f, -0.01071893f, -0.06798050f, -0.04006385f, -0.00015616f, -0.02258559f, 
    -0.04210275f, -0.03892504f, -0.01369455f, -0.02504365f, -0.05733331f, -0.03835270f, -0.04164723f, -0.03696182f, 
    -0.06358843f, 0.05827682f, 0.01868491f, -0.05193130f, -0.05261243f, -0.04606173f, -0.04488693f, 0.02657670f, 
    -0.02783384f, 0.01732809f, 0.00470520f, -0.04360226f, -0.05642407f, -0.01048393f, -0.00608582f, -0.05749511f, 
    0.00820402f, -0.04981860f, -0.05383517f, 0.04324463f, -0.00940661f, -0.03635505f, -0.02918583f, -0.02538183f, 
    0.03199866f, -0.02724309f, -0.03715792f, -0.03133225f, -0.05530368f, -0.00544802f, 0.02625590f, 0.03203569f, 
    0.05271412f, 0.02298825f, -0.01713951f, -0.00410680f, 0.00937047f, 0.03232535f, 0.00828142f, -0.01722999f, 
    -0.04360457f, -0.00681067f, -0.05310160f, -0.05267763f, 0.01906398f, 0.02379542f, -0.05626627f, 0.03642602f, 
    0.01863010f, 0.00831669f, -0.02698274f, -0.00535321f, -0.05059215f, -0.00781700f, -0.04489475f, -0.02460241f, 
    0.03057731f, -0.06372159f, -0.04584619f, -0.01455102f, 0.04914876f, -0.05943135f, -0.03082954f, 0.01491276f, 
    0.03421545f, 0.05723050f, -0.00345672f, -0.04973162f, 0.03455374f, -0.06212014f, 0.01063475f, -0.00736525f, 
    0.04330764f, 0.04213651f, 0.04827858f, -0.01079682f, -0.06208165f, -0.05388581f, 0.02099984f, 0.00788340f, 
    0.02820155f, 0.00584585f, -0.03663292f, 0.05121415f, 0.04521460f, -0.02665910f, 0.03231517f, -0.01259974f, 
    -0.01750672f, 0.01137535f, 0.00710241f, 0.04135563f, 0.04289424f, 0.04284834f, -0.05801177f, -0.01504510f, 
    -0.03685289f, 0.03963592f, -0.02446786f, -0.06233047f, -0.01951971f, -0.06265618f, -0.01263777f, -0.03907443f, 
    -0.05574407f, -0.02173839f, -0.01465801f, 0.04513307f, 0.00014750f, 0.04534967f, -0.03804886f, -0.03146340f, 
    -0.03124081f, 0.01441811f, 0.05364243f, 0.04657549f, 0.03637907f, -0.02664171f, -0.04795643f, 0.01432961f, 
    -0.05921085f, 0.05019395f, -0.03991885f, -0.02266329f, 0.02450457f, -0.06183020f, -0.00635762f, 0.04490218f, 
    0.04859722f, -0.04952897f, -0.04943833f, -0.01209079f, -0.01226155f, -0.01468896f, -0.04412278f, -0.06340133f, 
    0.01980877f, -0.03758984f, -0.00322915f, -0.06373049f, 0.02036816f, 0.01900471f, 0.01890178f, -0.01517451f, 
    -0.00600535f, 0.02281967f, 0.02167045f, 0.01884582f, 0.04665952f, -0.01344245f, -0.01956391f, 0.01310126f, 
    -0.00685613f, 0.00582924f, 0.00279687f, -0.04600532f, 0.00044815f, 0.01272158f, -0.01164420f, -0.03661183f, 
    -0.03408805f, 0.02812370f, -0.04744244f, -0.02160111f, 0.00189013f, 0.00105403f, 0.02868090f, -0.04052363f, 
    0.00511055f, -0.02113514f, -0.03302234f, 0.02135603f, 0.02501555f, 0.00766830f, -0.03847888f, -0.01232282f, 
    -0.00443583f, 0.04097865f, -0.01343582f, 0.01488887f, -0.02878155f, -0.03939094f, -0.01331602f, 0.01973760f, 
    -0.04305844f, 0.00234102f, 0.03289765f, 0.03696303f, -0.05442707f, -0.02572079f, 0.04432568f, -0.01913036f, 
    0.00733768f, 0.00520411f, -0.05091404f, -0.01663378f, -0.00657612f, -0.00344384f, -0.04487043f, -0.03953843f, 
    0.04509722f, 0.04715944f, 0.02207773f, -0.00218628f, 0.00624880f, -0.00003805f, 0.00228092f, -0.06322800f, 
    -0.03990903f, 0.04857787f, 0.02583904f, -0.05509971f, 0.05354153f, 0.00108836f, 0.01528397f, -0.04637060f, 
    -0.01687740f, 0.04562809f, 0.03221449f, 0.04845249f, -0.01065595f, 0.05111362f, -0.00711226f, 0.04991262f, 
    0.01840627f, -0.01890018f, 0.03132457f, 0.00391480f, 0.04979091f, -0.03767317f, -0.03798678f, -0.00982784f, 
    -0.01853549f, 0.03531800f, 0.03560561f, 0.03736681f, -0.00583392f, -0.01283950f, -0.04647817f, 0.01379338f, 
    -0.00169784f, 0.04383212f, -0.05201966f, -0.04617327f, -0.02840225f, -0.00115265f, -0.06376380f, -0.00812429f, 
    -0.04886070f, -0.00353626f, 0.03163826f, -0.01810584f, -0.01900447f, 0.04371485f, 0.05027434f, -0.02596467f, 
    -0.02182749f, -0.02610752f, -0.05968429f, -0.05457771f, 0.00151867f, -0.03379187f, 0.03776167f, -0.00500171f, 
    0.05294910f, 0.00306414f, 0.00045489f, 0.03330530f, -0.03230949f, 0.03966784f, 0.02517253f, -0.03796277f, 
    0.05042364f, -0.05053255f, 0.04416980f, -0.06405918f, -0.03896611f, -0.04283042f, -0.03968775f, 0.00710220f, 
    0.01884954f, 0.31091252f, 0.11884842f, -0.04585728f, -0.08278678f, -0.12963901f, 0.11313350f, -0.17629506f, 
    0.09670401f, 0.02943928f, 0.12826255f, 0.06141520f, -0.01424069f, -0.29228815f, -0.28699788f, 0.13264503f, 
    0.02968290f, 0.00166106f, -0.00215971f, -0.39666215f, -0.91410923f, 0.03532238f, -0.19574812f, 0.01611589f, 
    0.05249946f, -0.02264666f, 0.02212195f, 0.19762357f, 0.13355704f, 0.28145427f, 0.00739817f, -0.01513140f, 
    -0.14391214f, 0.03108024f, 0.00326416f, 0.06343567f, -0.41628429f, -0.50805891f, -0.46401927f, -0.24679288f, 
    0.06148078f, -0.22531220f, -0.06362869f, 0.01010708f, -0.08284906f, 0.12371075f, 0.15075667f, -0.04106888f, 
    -0.02851580f, -0.09870394f, 0.14732233f, 0.01644800f, 0.02147579f, -0.02647630f, -0.43991557f, -0.39679307f, 
    -0.19797203f, -0.13626750f, 0.13646491f, -0.01384351f, -0.07863557f, 0.06563630f, 0.08329347f, 0.18410601f, 
    -0.07003244f, -0.26352146f, -0.09132887f, -0.15246108f, -0.14921352f, -0.06323348f, -0.13252096f, -0.09156331f, 
    -0.27865383f, -0.66094464f, -0.27172562f, -0.02941144f, 0.26478720f, 0.16751947f, 0.07667626f, -0.03042668f, 
    -0.20851469f, -0.05947338f, 0.37139446f, 0.16267706f, -0.01124619f, 0.08433028f, -0.06331705f, 0.13002352f, 
    0.07481506f, 0.07444886f, -0.56430781f, 0.05226617f, -0.50551599f, 0.10452816f, 0.05288115f, 0.29640165f, 
    0.06761313f, 0.05260159f, -0.01730042f, -0.15649258f, 0.17574702f, 0.38443485f, 0.01082071f, 0.17527732f, 
    -0.01289909f, 0.09555893f, 0.16107796f, 0.10844288f, 0.23284885f, 0.38307062f, 0.12594534f, 0.11851285f, 
    0.07776786f, 0.08750165f, 0.14860825f, 0.18224549f, 0.14970049f, 0.08427238f, 0.03889890f, 0.24114770f, 
    0.09999692f, 0.19462812f, -0.06686733f, -0.09012690f, 0.10735082f, 0.04740578f, -0.13236904f, -0.52380413f, 
    -0.62180859f, 0.03846601f, 0.52547604f, 0.12639768f, -0.07182379f, 0.07455794f, 0.07786560f, -0.50244087f, 
    -0.37031877f, -0.07014254f, 0.06497463f, 0.22999477f, 0.22716260f, 0.07160409f, 0.09528816f, 0.08280254f, 
    -0.25675079f, -0.34006688f, -0.07581326f, 0.19161911f, 0.11562153f, 0.03326700f, 0.08259097f, 0.06556593f, 
    0.09430224f, 0.20796750f, 0.38844436f, 0.14664963f, 0.04274889f, -0.24512474f, -0.15720735f, 0.00647346f, 
    -0.00249563f, 0.18995725f, 0.21984795f, 0.38691488f, 0.17979844f, 0.00096684f, 0.16244023f, -0.17179708f, 
    0.36123142f, 0.09503201f, 0.25166962f, 0.07136777f, -0.00977221f, -0.05368520f, 0.04763502f, 0.05592446f, 
    -0.01354381f, 0.11715044f, -0.20206058f, 0.04797016f, 0.13442346f, -0.08085269f, 0.07553691f, -0.01516341f, 
    0.10823610f, -0.00395292f, 0.13119124f, -0.16726823f, -0.02777124f, -0.12713510f, -0.23283261f, -0.06262673f, 
    -0.07806595f, -0.02422561f, 0.01751259f, 0.06965031f, -0.07499184f, -0.01873888f, 0.16271964f, -0.30624771f, 
    -0.41887379f, -0.09609603f, -0.00160543f, -0.03652251f, 0.19942395f, -0.19643906f, -0.02039616f, -0.08228865f, 
    0.01265110f, 0.11249089f, -0.00827495f, -0.00340240f, -0.05856723f, 0.01194548f, 0.05841486f, -0.00463202f, 
    -0.54082167f, -0.40582892f, -0.45103768f, -0.11367793f, -0.05282722f, -0.14995658f, 0.10335547f, -0.14306512f, 
    -0.13548937f, 0.04956221f, -0.00367232f, 0.14391990f, 0.03264067f, 0.41424757f, -0.13398562f, 0.04235400f, 
    0.05101703f, -0.05721823f, -0.07171348f, 0.08167624f, -0.18897702f, 0.00653487f, 0.04879463f, -0.03411921f, 
    0.07066368f, 0.00292479f, -0.13056189f, -0.01900729f, 0.23344399f, -0.16241494f, 0.10636259f, -0.20217822f, 
    0.02900928f, 0.00812308f, 0.02361374f, 0.14882044f, -0.12708092f, -0.38049498f, -0.17771052f, -0.16172902f, 
    -0.17691086f, -0.33218649f, -0.01954080f, -0.09575139f, -0.06709079f, -0.05352487f, 0.03112742f, 0.35026571f, 
    -0.05313374f, -0.00131923f, -0.09673488f, 0.02648337f, 0.01987872f, 0.08410860f, 0.18429320f, -0.04206119f, 
    -0.07084118f, -0.05622730f, -0.07560492f, 0.00927275f, 0.01472742f, -0.18157658f, -0.01459781f, 0.02276094f, 
    0.37357798f, 0.17382631f, 0.08742889f, 0.00714221f, -0.02699564f, 0.15821540f, -0.02463778f, 0.07830488f, 
    -0.14295496f, -0.10764079f, 0.00148710f, -0.10688784f, -0.31034273f, -0.26633599f, -0.04567650f, 0.07041400f, 
    0.25794506f, -0.19272983f, 0.18359089f, 0.04511709f, -0.08138224f, 0.08089021f, -0.02986411f, 0.13432485f, 
    0.25625792f, 0.14642996f, -0.18246646f, -0.19834927f, 0.11141896f, -0.14524695f, -0.11847112f, -0.26080570f, 
    0.19986804f, 0.05837373f, -0.05105350f, -0.17758299f, 0.04429330f, -0.08290255f, -0.01098406f, 0.12365812f, 
    0.00479281f, 0.05310266f, 0.14056653f, 0.06271582f, 0.01649296f, 0.18224442f, 0.35883677f, -0.10524033f, 
    0.00603511f, -0.07248159f, -0.02414512f, -0.10026604f, -0.09091955f, -0.15825176f, -0.09628719f, -0.10464014f, 
    -0.01093912f, 0.11213068f, -0.21138242f, 0.02152389f, 0.20379671f, 0.00850794f, 0.06236397f, 0.21146484f, 
    0.52383369f, 0.13563515f, 0.02780306f, 0.18857469f, 0.05033515f, 0.15555112f, 0.22400597f, -0.09341228f, 
    -0.08753645f, 0.05959951f, 0.13398673f, 0.04548681f, -0.02530462f, 0.05866967f, -0.01386232f, -0.09766468f, 
    -0.26515770f, -0.25579980f, 0.09419913f, -0.16256012f, -0.04855203f, 0.08683816f, 0.03777501f, 0.06440408f, 
    0.01128605f, -0.01221739f, 0.25577065f, 0.16856782f, -0.06024072f, -0.24625421f, -0.15725121f, 0.15696721f, 
    -0.05118703f, 0.13270509f, -0.01766432f, -0.04095145f, 0.25044781f, -0.10188012f, 0.05337660f, 0.07565140f, 
    0.27940056f, 0.01920981f, 0.00340487f, -0.04048053f, -0.27155885f, -0.16328949f, 0.05582283f, 0.05830919f, 
    -0.06315220f, 0.07033025f, 0.17059015f, 0.06333384f, -0.08335663f, 0.22356890f, 0.15777259f, -0.03856394f, 
    0.03917807f, -0.10661225f, 0.13448904f, 0.12429596f, 0.39499503f, -0.09918927f, 0.06828240f, -0.22997022f, 
    -0.00142972f, 0.17805214f, -0.08900250f, 0.44535989f, 0.23735063f, 0.09693300f, 0.08430009f, -0.17659397f, 
    0.03515266f, 0.12159110f, 0.02495007f, 0.24396876f, 0.12544285f, 0.00552661f, -0.05409490f, -0.17689565f, 
    -0.02433868f, 0.10188643f, 0.02731178f, 0.21642792f, 0.10289858f, 0.15416910f, 0.20936574f, 0.12722509f, 
    -0.03805307f, 0.11608980f, 0.19649674f, 0.00297321f, 0.21587864f, 0.02555247f, 0.17030542f, 0.28606102f, 
    0.08212155f, -0.79453790f, -0.03800787f, 0.12115496f, -0.15256648f, -0.04153228f, -0.17056450f, 0.01838158f, 
    -0.14689812f, -0.04394118f, 0.02164907f, -0.04552923f, 0.22685672f, -0.12595668f, -0.14676484f, 0.10800853f, 
    -0.13576922f, -0.02217571f, 0.64036167f, -0.04599898f, 0.10210615f, 0.15232022f, 0.06717598f, 0.12782763f, 
    0.26466167f, 0.07046977f, 0.21627131f, 0.32859445f, -0.22527178f, -0.11544544f, -0.09991614f, -0.08711389f, 
    -0.17514670f, -0.10629045f, -0.07330360f, 0.20159630f, 0.10878622f, -0.29204464f, -0.09333944f, 0.20514542f, 
    0.02482929f, 0.03069584f, -0.11125825f, -0.04091200f, 0.03565438f, 0.04144537f, -0.11535939f, 0.09795622f, 
    -0.07643520f, -0.04038788f, 0.00907907f, 0.04149737f, -0.10400306f, 0.05594676f, -0.05356918f, -0.17707592f, 
    -0.08313216f, -0.01347573f, -0.07956543f, -0.09669195f, -0.15408652f, 0.21599202f, -0.09870760f, -0.16552176f, 
    -0.12974738f, 0.14210401f, -0.04718861f, -0.13482547f, -0.15743515f, -0.09922970f, 0.00865132f, 0.10879803f, 
    0.08221979f, 0.20178176f, 0.13927691f, 0.08581861f, 0.01540618f, 0.04734736f, -0.14707522f, 0.11608393f, 
    0.32307395f, 0.21773075f, -0.13348480f, -0.21027738f, -0.14077160f, -0.02714028f, 0.08904095f, -0.06237209f, 
    0.00732988f, 0.03972613f, 0.17618820f, -0.03153369f, 0.14600959f, 0.10996194f, -0.11371911f, 0.09843232f, 
    -0.12439998f, 0.22419409f, -0.03408772f, -0.11523067f, 0.07445117f, 0.18496901f, -0.09320632f, 0.03381499f, 
    -0.07316770f, 0.10818051f, 0.01281815f, 0.04414426f, 0.00586857f, -0.35489893f, -0.34413427f, -0.24194804f, 
    -0.13993481f, 0.03545237f, -0.22939795f, 0.00656424f, 0.08665509f, 0.12750049f, -0.13715282f, -0.20133696f, 
    -0.19800732f, -0.15607995f, -0.03703789f, -0.05299384f, 0.01657793f, 0.09602834f, 0.07612745f, -0.04961948f, 
    -0.00245117f, 0.05452780f, -0.01925336f, -0.11191889f, -0.04844831f, 0.20247743f, -0.20081526f, -0.00338271f, 
    0.05189212f, 0.07645170f, 0.05365294f, 0.00791254f, 0.06697643f, 0.01747312f, 0.05906402f, 0.01200965f, 
    0.11078133f, -0.06519986f, -0.02767149f, 0.26933774f, -0.04837381f, 0.19050592f, 0.00580519f, 0.07264941f, 
    0.22830161f, -0.03074580f, -0.11742851f, -0.14897685f, 0.05650588f, 0.12323803f, 0.00950682f, -0.20530191f, 
    -0.10252158f, -0.13229614f, -0.06368417f, -0.08765385f, -0.19397530f, 0.13325696f, 0.05024067f, 0.20000744f, 
    0.15317450f, -0.00082860f, 0.29195365f, 0.22699472f, 0.02479393f, -0.05804242f, -0.58960730f, 0.10779771f, 
    -0.05515171f, 0.02127756f, -0.11313522f, -0.44195560f, 0.04669173f, -0.08786076f, -0.08737935f, 0.11610509f, 
    0.05055048f, 0.11822838f, 0.03366697f, 0.14370093f, 0.26285082f, 0.14786856f, 0.12259544f, 0.12924373f, 
    0.06931366f, -0.03811558f, -0.11489548f, 0.06385879f, -0.17274874f, -0.12736791f, 0.10106303f, -0.02721133f, 
    -0.14843400f, -0.04040982f, 0.32521933f, 0.06607198f, 0.15331934f, -0.23172650f, -0.09517248f, 0.02099007f, 
    -0.17768459f, -0.10596409f, -0.19164288f, 0.11571988f, 0.09049597f, -0.02465477f, -0.21562476f, 0.03122309f, 
    -0.00038047f, 0.10491689f, 0.05533946f, -0.08177677f, -0.00887075f, 0.04719742f, 0.07497623f, 0.03916558f, 
    -0.02333475f, -0.09017710f, -0.02663539f, 0.02437473f, 0.01277285f, 0.09952512f, -0.00968213f, 0.04272239f, 
    0.03164009f, -0.03369693f, -0.25763524f, -0.19945566f, -0.08674773f, -0.08403695f, 0.18358423f, 0.11368029f, 
    0.24034508f, 0.11241824f, 0.27453202f, 0.01211761f, 0.08491979f, -0.05591450f, 0.08554856f, 0.12011589f, 
    0.15446275f, 0.03783104f, 0.28048515f, -0.02771689f, 0.13307030f, 0.14215204f, 0.17016153f, 0.12531175f, 
    0.41377962f, 0.21836856f, -0.00261258f, 0.40719476f, 0.01416546f, 0.37137875f, -0.46622568f, 0.15937158f, 
    0.27446505f, -0.03817748f, -0.18104416f, 0.17952120f, 0.05725215f, -0.07704341f, 0.03940704f, 0.07851127f, 
    0.04384938f, -0.08398061f, -0.10027359f, -0.02248432f, 0.10785171f, 0.11639319f, 0.10747910f, 0.10214075f, 
    0.20816845f, 0.13262975f, -0.08090540f, -0.05612274f, 0.14501652f, 0.02576636f, 0.30376449f, 0.07712270f, 
    0.15468141f, -0.41505605f, -0.92746359f, -0.01688538f, -0.03165019f, 0.07659511f, 0.15571843f, 0.03466854f, 
    -0.01355826f, -0.11614194f, 0.12921625f, 0.01806800f, -0.02917106f, 0.00611490f, 0.13367420f, 0.12124486f, 
    -0.04231205f, -0.24757750f, -0.03047073f, 0.07323531f, 0.06479349f, 0.16507000f, 0.04108535f, 0.17082831f, 
    0.10113529f, 0.07527006f, 0.14212163f, 0.11049455f, 0.05138734f, -0.00868285f, 0.07866345f, 0.06977213f, 
    0.21433036f, 0.00298274f, 0.13625735f, 0.17823896f, 0.11849507f, 0.08696081f, 0.21535555f, 0.23252006f, 
    -0.18416044f, 0.02903312f, 0.05648625f, 0.16838425f, 0.01460872f, 0.14204612f, -0.12068934f, 0.06941195f, 
    -0.03659789f, 0.23474634f, 0.20213075f, 0.07872327f, -0.11434830f, -0.07232056f, -0.12816337f, -0.03020532f, 
    0.02765588f, -0.05245682f, -0.01586005f, -0.08193932f, 0.04911154f, 0.03108609f, -0.10904978f, -0.12280444f, 
    -0.15294801f, 0.11460104f, -0.08534827f, -0.05089585f, -0.07864072f, -0.05332052f, -0.00794072f, 0.01986320f, 
    0.11255418f, 0.06932629f, 0.01898501f, 0.01821564f, 0.13568789f, 0.19922210f, -0.05048627f, 0.05963672f, 
    -0.36918718f, 0.02376708f, 0.01823599f, 0.05945094f, 0.01355581f, 0.30583200f, 0.16571350f, 0.12845215f, 
    -0.08974918f, -0.03155996f, 0.10241529f, -0.15203021f, -0.30103838f, -0.05840015f, -0.03433741f, 0.00290103f, 
    0.09688061f, 0.03812655f, -0.22588091f, -0.34899503f, -0.01563921f, -0.06385983f, -0.15202755f, 0.18260702f, 
    -0.00627255f, -0.03622672f, 0.03162576f, -0.01472690f, 0.05796787f, 0.25742081f, -0.14189081f, -0.44339707f, 
    0.04302290f, 0.16583045f, 0.11764685f, 0.16429165f, 0.13981494f, 0.11414303f, -0.05977990f, 0.03260540f, 
    0.04361905f, 0.27383080f, 0.10481324f, -0.03261251f, -0.05640917f, 0.05912522f, 0.06056881f, 0.03418080f, 
    -0.08114465f, 0.01706311f, -0.08995844f, -0.10447597f, -0.03909319f, -0.02872495f, -0.17909671f, -0.07743813f, 
    0.06664283f, 0.26926607f, -0.24492794f, 0.01867732f, -0.04504742f, 0.02905957f, 0.16079730f, 0.14406967f, 
    0.14734536f, -0.25309330f, -0.31213859f, 0.16380444f, -0.09260930f, -0.03546295f, 0.12321444f, -0.08326170f, 
    -0.07786436f, -0.16022013f, 0.25879532f, 0.07768038f, 0.17581029f, 0.09580377f, 0.07750235f, -0.00176347f, 
    0.05980705f, -0.00492369f, 0.00663721f, -0.45168954f, -0.09143743f, 0.01814570f, 0.06247962f, 0.02614954f, 
    -0.01993683f, 0.00623337f, -0.02143056f, 0.05269872f, -0.03284093f, 0.00380470f, -0.14910455f, -0.08858901f, 
    -0.02775707f, 0.12312535f, 0.22699948f, 0.11791983f, 0.11590524f, -0.42935094f, -0.20512167f, -0.20716719f, 
    0.03797845f, 0.14592583f, -0.17815416f, 0.03733425f, 0.12579545f, 0.14101093f, -0.09241526f, -0.03560589f, 
    0.27999461f, -0.37446770f, -0.13436550f, -0.08450618f, -0.08740501f, -0.18541278f, 0.10856656f, 0.03127952f, 
    0.18298203f, -0.03471940f, -0.25423515f, -0.00020926f, -0.00773997f, 0.08166390f, -0.29199913f, 0.07514799f, 
    0.25938794f, 0.25609460f, 0.03828849f, 0.13767698f, -0.08306642f, 0.26269689f, -0.08259990f, -0.19033924f, 
    -0.05858101f, -0.08809813f, 0.24177395f, 0.02632766f, -0.09545754f, -0.08025087f, 0.04303130f, -0.08285606f, 
    0.03829434f, 0.03626437f, -0.02789897f, 0.48448983f, 0.29792628f, 0.02992365f, 0.06113302f, -0.28388220f, 
    -0.02525072f, -0.09345578f, 0.08595037f, -0.10747385f, 0.17840908f, 0.23878562f, -0.04699339f, -0.00785381f, 
    -0.13009618f, 0.06456480f, -0.00116130f, 0.30302078f, -0.28876600f, 0.07549471f, 0.30336469f, -0.01201769f, 
    -0.05547849f, -0.32881418f, -0.17499486f, 0.14268900f, 0.08405761f, -0.53378314f, 0.32645789f, 0.04246066f, 
    0.00673283f, -0.05020177f, -0.03689071f, -0.15051854f, 0.10000318f, -0.01196640f, -0.41135773f, -0.20603050f, 
    -0.36131945f, -0.09625188f, 0.38684756f, 0.36350203f, -0.07777568f, 0.19928825f, -0.16072914f, 0.14934379f, 
    0.01299175f, -0.20836042f, -0.09738950f, -0.09563525f, 0.07655005f, 0.01590184f, 0.23225883f, 0.08503780f, 
    -0.13091965f, 0.10609148f, -0.16224125f, 0.01863049f, -0.07222910f, -0.03053885f, -0.06528155f, 0.03773964f, 
    0.03827373f, 0.13163418f, -0.11104350f, -0.04527248f, -0.12944283f, -0.16956216f, -0.37078169f, 0.03935807f, 
    0.01445301f, 0.13244253f, 0.00945978f, 0.41906542f, 0.06131263f, -0.19511835f, -0.17981198f, 0.02081653f, 
    0.08289818f, 0.24794729f, -0.10146264f, -0.23061347f, -0.02864329f, 0.04415056f, -0.03647645f, -0.02209205f, 
    0.03246009f, -0.12199237f, -0.01513686f, 0.13012363f, -0.05899603f, 0.20720743f, -0.18492697f, 0.13046581f, 
    0.06955744f, -0.02075583f, -0.09347434f, -0.01945182f, 0.22343430f, 0.21776466f, 0.31538540f, 0.11748490f, 
    0.21468985f, -0.02638244f, 0.02070612f, 0.15366936f, 0.18334018f, 0.28855023f, 0.24745227f, 0.07841165f, 
    0.02561498f, -0.33308026f, -0.04403047f, -0.10577694f, -0.09203560f, 0.04577731f, -0.02002777f, 0.03251155f, 
    0.04157732f, 0.09166003f, 0.17767923f, -0.00840021f, -0.04156590f, 0.15062256f, -0.20109682f, 0.04372160f, 
    0.31584081f, 0.27969769f, 0.12119427f, -0.05171015f, -0.12559657f, 0.29848439f, -0.02658269f, 0.06000646f, 
    -0.04166015f, -0.50690782f, 0.18522418f, 0.33252305f, 0.04694745f, 0.15371990f, -0.07831687f, -0.06046169f, 
    -0.26781976f, 0.07774343f, -0.10103238f, -0.01079154f, 0.23300637f, 0.05156719f, 0.19129239f, 0.12244391f, 
    -0.06996120f, -0.05342412f, 0.06741910f, -0.37668002f, -0.65760934f, -0.10489210f, -0.12412759f, -0.03149801f, 
    -0.11816207f, -0.03322320f, -0.20038949f, -0.11363721f, -0.44776115f, 0.23765993f, -0.43335795f, -0.41997078f, 
    -0.14007585f, 0.06307638f, 0.11632966f, 0.24012943f, -0.08577087f, 0.17850335f, 0.35654658f, 0.19133870f, 
    0.01519027f, -0.14495811f, -0.04977313f, -0.00613571f, 0.04776057f, 0.21105130f, 0.03342450f, -0.01282732f, 
    -0.28709790f, -0.13902579f, 0.11061635f, 0.11621948f, -0.01557264f, -0.03057193f, 0.00156567f, -0.60698831f, 
    -0.18637331f, -0.13156475f, 0.11790983f, -0.21297759f, -0.17594527f, 0.01712715f, -0.10559380f, 0.11890920f, 
    0.09171589f, 0.10302494f, 0.13186036f, 0.02396095f, -0.08040222f, -0.06791370f, 0.03706631f, 0.08547384f, 
    -0.06083660f, -0.02580003f, -0.07815250f, 0.12557374f, -0.15280193f, 0.22286150f, 0.02271831f, -0.02043444f, 
    0.10794793f, 0.01076564f, 0.28213087f, -0.06019927f, -0.11996641f, -0.27645737f, 0.25621644f, -0.01371686f, 
    0.14080718f, 0.05788462f, 0.02397768f, 0.16850844f, 0.16047886f, -0.14555256f, -0.09811617f, 0.01049390f, 
    0.09112337f, 0.03681665f, -0.02824778f, 0.06953459f, 0.50095314f, -0.18877050f, -0.29586712f, -0.24348696f, 
    -0.18506202f, -0.07606277f, 0.05095975f, -0.21696472f, -0.06784584f, 0.20697147f, 0.04147455f, -0.09765991f, 
    0.02455228f, 0.09965737f, -0.01229531f, -0.04812948f, 0.03804607f, -0.00005951f, -0.21061432f, -0.02097221f, 
    0.27133080f, 0.33801478f, -0.27389660f, -0.15062293f, 0.02055263f, 0.00561278f, 0.03964299f, 0.08194552f, 
    0.18694079f, 0.24355420f, -0.21198700f, -0.11292832f, -0.21684855f, -0.02296927f, 0.04516444f, -0.00187308f, 
    0.17577305f, -0.48443434f, 0.03245997f, -0.01274244f, -0.09390350f, 0.02484342f, -0.02633859f, 0.04419501f, 
    -0.02994438f, 0.22187440f, -0.03796632f, 0.24437961f, 0.06729320f, -0.02093448f, 0.01790650f, -0.06789283f, 
    0.00181608f, 0.07562611f, 0.11292459f, -0.09862766f, 0.00271148f, 0.01537197f, 0.16556230f, -0.20641787f, 
    -0.00012266f, 0.04567650f, 0.04984359f, -0.13070767f, 0.24208185f, -0.32207516f, -0.16813281f, -0.06623337f, 
    0.21765752f, 0.15295054f, -0.11160912f, -0.07942814f, 0.16514415f, 0.23782411f, 0.17538235f, 0.12518850f, 
    0.02956902f, 0.02219552f, 0.00300989f, 0.03587289f, -0.03337741f, -0.34452552f, 0.34161201f, -0.16427097f, 
    0.03608620f, -0.27069703f, 0.04715214f, 0.20776534f, 0.02931247f, -0.07235262f, -0.69006693f, 0.14995201f, 
    -0.31975675f, 0.17031549f, 0.28527403f, 0.19325583f, -0.15069696f, -0.03704048f, 0.12601979f, 0.07001992f, 
    0.08256934f, 0.15335898f, 0.08738138f, 0.10841971f, 0.18276569f, -0.06750832f, -0.06268767f, -0.11094573f, 
    -0.09287532f, 0.20870382f, 0.08745256f, 0.12807924f, -0.00405253f, 0.13797611f, -0.03622576f, 0.02660413f, 
    -0.01003835f, -0.30087939f, 0.09460152f, -0.27801222f, -0.02436978f, -0.14735280f, -0.05470352f, 0.13402566f, 
    -0.10255955f, -0.00337599f, 0.25513884f, 0.10687985f, 0.22879834f, 0.05043263f, 0.07561944f, 0.07389537f, 
    -0.04246560f, 0.08920808f, -0.10683040f, -0.01270894f, 0.14183611f, 0.04460913f, -0.02545824f, 0.02927482f, 
    0.13112135f, 0.02524181f, 0.15869294f, -0.00035106f, 0.06547361f, 0.03450762f, -0.08287663f, 0.20298082f, 
    -0.00612858f, 0.00016037f, 0.02327560f, -0.03172019f, -0.11568401f, -0.34722245f, 0.30577317f, 0.10728540f, 
    0.15597349f, -0.18012112f, 0.12857912f, 0.01201360f, -0.23453833f, -0.00576998f, -0.12372588f, 0.03943266f, 
    0.08006144f, -0.18811953f, -0.01799825f, -0.09760135f, 0.17792724f, -0.01811475f, -0.04654866f, 0.14989574f, 
    0.06568409f, 0.13911165f, -0.04093838f, 0.04721181f, -0.03802884f, -0.03407047f, -0.18099491f, 0.21471293f, 
    -0.33060881f, -0.13925430f, 0.18088146f, 0.25155634f, -0.45687512f, -0.20856440f, -0.01535242f, -0.02234697f, 
    -0.01910836f, 0.19181015f, -0.07985025f, 0.21088877f, 0.05997614f, 0.05241877f, 0.03098142f, -0.00996777f, 
    0.00091593f, 0.24039069f, 0.04457160f, 0.01557111f, 0.05690312f, 0.01568295f, 0.06830560f, -0.01014053f, 
    -0.01912089f, 0.07341560f, 0.02742512f, -0.85100317f, -0.05020776f, -0.04068898f, 0.07643259f, 0.04442994f, 
    -0.05504674f, -0.03937561f, -0.04032977f, 0.01391855f, -0.75645924f, 0.22886361f, -0.20559974f, 0.02042376f, 
    -0.36068270f, 0.00414592f, 0.17948629f, -0.02184213f, -0.24186184f, 0.18874432f, 0.02940816f, 0.22318703f, 
    -0.25843656f, -0.19277211f, -0.00665459f, -0.08211309f, -0.08890398f, 0.06826887f, -0.07811306f, -0.02625581f, 
    -0.03867846f, -0.09829704f, -0.06008705f, -0.06428839f, 0.15458532f, 0.01786542f, -0.13037309f, -0.45058686f, 
    0.07060390f, -0.16150767f, 0.07491096f, -0.21167774f, -0.02191577f, 0.10336696f, 0.01649286f, 0.16171733f, 
    -0.29647866f, -0.20880249f, -0.14658597f, 0.05849012f, 0.06963633f, -0.04008280f, -0.00062661f, 0.12129675f, 
    -0.24738292f, -0.30303675f, -0.08968689f, 0.14634371f, -0.00740957f, 0.11567540f, -0.00407698f, -0.06326438f, 
    -0.06455122f, 0.10019067f, -0.53532237f, -0.37972119f, -0.21677245f, -0.12225685f, -0.13496353f, 0.03865028f, 
    -0.02885337f, 0.05017810f, 0.00731868f, -0.10233702f, 0.04373918f, 0.10712627f, -0.10620219f, 0.06822532f, 
    0.14606702f, -0.01551501f, 0.07153018f, 0.15092647f, -0.38875195f, -0.00366042f, 0.06124742f, 0.10731076f, 
    0.04648296f, 0.07804319f, -0.21214616f, -0.04761972f, -0.23137887f, -0.00974675f, 0.05354855f, -0.03180657f, 
    -0.13089392f, -0.14407669f, -0.03077905f, 0.06454087f, 0.00853922f, 0.08830262f, 0.00566521f, 0.09787415f, 
    0.15827842f, 0.21400540f, 0.04248924f, 0.12766853f, -0.09613815f, 0.09378396f, -0.09568533f, -0.27059099f, 
    -0.17198721f, -0.13451618f, 0.06642820f, 0.03442829f, 0.07030722f, -0.12329854f, 0.02726034f, -0.27931261f, 
    -0.06802396f, -0.26589420f, 0.09479727f, 0.19365834f, -0.03948571f, 0.05578999f, -0.06961879f, -0.01207869f, 
    -0.02070535f, 0.06094130f, -0.14831366f, -0.24387836f, -0.00057869f, -0.03146901f, -0.06257857f, -0.04346879f, 
    0.05626651f, -0.07428728f, 0.08246917f, 0.02600729f, 0.08862107f, 0.07493971f, 0.02989583f, 0.01779647f, 
    -0.01797058f, 0.10361532f, 0.08385033f, 0.09255878f, 0.14631763f, 0.14976446f, 0.37333632f, 0.05651673f, 
    0.15156919f, 0.03579878f, 0.17260364f, 0.29571724f, -0.11512507f, -0.02556712f, -0.10144208f, -0.04109516f, 
    0.02673728f, 0.21469118f, 0.15432450f, 0.07605625f, 0.04867477f, 0.42384219f, -0.08859691f, 0.05166099f, 
    0.11964499f, -0.04868610f, 0.21300399f, 0.05650032f, -0.01614890f, 0.21219949f, 0.19245937f, 0.49898005f, 
    0.45348272f, 0.08954511f, 0.13844477f, -0.06072333f, 0.34935042f, 0.16139217f, -0.03215327f, 0.06008943f, 
    0.08704302f, 0.21943857f, 0.03175415f, 0.08215912f, -0.06837439f, 0.22927150f, -0.03729290f, 0.13676625f, 
    0.10260088f, 0.21093887f, 0.16086523f, 0.00136882f, 0.15634048f, 0.08463999f, 0.18855916f, 0.07493295f, 
    0.21920323f, -0.36289319f, -0.34974954f, 0.32568842f, 0.19630793f, 0.10866442f, -0.01053960f, -0.15903264f, 
    0.02779496f, 0.01049151f, -0.03461625f, -0.17507908f, -0.17112963f, 0.08069286f, 0.07414541f, 0.06536629f, 
    0.03311469f, -0.16525337f, -0.12889101f, -0.12310808f, -0.07558141f, 0.06695954f, 0.07256133f, 0.06671120f, 
    0.11985102f, 0.11876424f, 0.12384251f, -0.02164891f, -0.05261599f, 0.00879802f, -0.00312210f, -0.04180304f, 
    -0.00256506f, 0.01669114f, 0.34274864f, 0.24486361f, -0.00758314f, -0.07689532f, 0.14420135f, 0.13104983f, 
    -0.09532557f, 0.23669378f, -0.09006830f, 0.17214222f, 0.05026833f, 0.18164103f, -0.32119721f, -0.02317514f, 
    0.01710979f, 0.10697378f, 0.06321782f, 0.05502428f, -0.20669496f, 0.02768543f, -0.10208428f, -0.12924343f, 
    -0.15712176f, -0.37769035f, -0.04975785f, -0.03478700f, -0.02377490f, 0.04358035f, 0.09144281f, -0.01525428f, 
    -0.31582797f, -0.37152284f, 0.06855620f, -0.12369832f, -0.13364139f, 0.03192227f, 0.10353743f, 0.07376044f, 
    0.03465344f, 0.16971892f, 0.04668815f, -0.12035629f, -0.02009424f, 0.04189283f, 0.15019144f, 0.15416275f, 
    0.11296590f, 0.07287379f, -0.09808319f, 0.01969013f, -0.02178688f, 0.06470057f, 0.13934779f, 0.09530635f, 
    0.19322771f, 0.21793780f, 0.03091258f, -0.32144955f, -0.04504204f, 0.59805322f, 0.07614687f, 0.13716891f, 
    0.09944977f, -0.10265111f, -0.05945218f, 0.00904199f, -0.12333457f, -0.18814677f, 0.01127445f, 0.06188883f, 
    -0.03969147f, 0.09060095f, -0.03283732f, -0.17540129f, 0.02491194f, -0.06980626f, -0.15533262f, 0.04166396f, 
    0.10066899f, 0.16331515f, 0.00076628f, 0.10091056f, 0.10762646f, 0.17571631f, -0.18492000f, -0.08069450f, 
    -0.00570410f, 0.12432503f, 0.06361184f, 0.02967997f, 0.12045524f, -0.04931213f, 0.03319747f, -0.30111790f, 
    -0.25136605f, -0.21680854f, 0.04075732f, -0.06155813f, -0.05110758f, -0.02872798f, 0.12303464f, 0.12666808f, 
    0.02076694f, -0.02135777f, -0.23013824f, 0.03527605f, -0.08416039f, 0.13079116f, -0.36740294f, 0.10496363f, 
    -0.10614565f, 0.15063992f, 0.12222735f, -0.03796424f, -0.07483671f, -0.08741388f, 0.06949615f, -0.07156885f, 
    -0.35178182f, -0.02561695f, -0.17932130f, -0.05833003f, -0.05462682f, -0.01722170f, -0.01969840f, -0.04710066f, 
    0.00327485f, -0.00227754f, -0.18159625f, 0.16504008f, -0.02801926f, -0.12759608f, -0.26343727f, 0.09214877f, 
    -0.02658922f, -0.03338423f, 0.05832359f, -0.03348174f, 0.01864434f, 0.23689148f, -0.31882992f, 0.07181583f, 
    0.11983506f, -0.04191438f, 0.12861697f, -0.02117704f, 0.15515807f, 0.04585224f, -0.09851418f, 0.00021501f, 
    -0.26117846f, 0.03596742f, -0.11065666f, 0.08982010f, 0.12141468f, 0.06245111f, -0.16105244f, 0.14150462f, 
    -0.05380336f, 0.04736564f, -0.01912406f, -0.05372997f, -0.09350044f, 0.04395583f, 0.04129982f, 0.13576329f, 
    0.02957732f, -0.15076235f, -0.02240985f, 0.06590638f, 0.15754919f, -0.06140684f, -0.04099450f, -0.00975939f, 
    0.13577288f, 0.16281132f, 0.03055668f, 0.21855181f, -0.00803546f, -0.01762404f, -0.12662593f, 0.15132087f, 
    -0.13975190f, 0.09118962f, 0.15541768f, -0.21424142f, 0.14713019f, -0.05398448f, 0.03819783f, -0.23063414f, 
    0.12537327f, -0.27809656f, 0.13010848f, 0.33525810f, 0.28006777f, 0.11314795f, 0.00487088f, 0.01519578f, 
    -0.02006949f, -0.07982076f, -0.04479546f, -0.19039357f, -0.02798004f, 0.15021877f, -0.00465441f, 0.02644719f, 
    -0.00488098f, 0.18471646f, -0.01267148f, 0.11391553f, 0.03607333f, 0.22818376f, 0.08596321f, 0.08861047f, 
    -0.12928618f, 0.19221689f, -0.06882538f, -0.09462781f, 0.06924502f, 0.28509662f, -0.31523919f, 0.14679016f, 
    0.28861809f, 0.10460576f, -0.04063740f, 0.16804284f, -0.15591331f, 0.17459367f, -0.34819224f, 0.69104046f, 
    0.23035952f, -0.13083123f, -0.01189550f, 0.10799342f, 0.23956499f, 0.12778921f, 0.44364840f, 0.07781093f, 
    0.06659967f, -0.18896542f, -0.17235264f, -0.17029378f, -0.09919131f, -0.06830264f, 0.11202004f, 0.08950076f, 
    -0.08426998f, 0.01872712f, 0.05690229f, 0.12615776f, -0.23774078f, -0.24326241f, 0.03842535f, -0.04810747f, 
    0.07386150f, 0.19685300f, -0.05467639f, -0.37622404f, 0.08148233f, 0.13614036f, 0.03896381f, -0.05442712f, 
    0.25766355f, -0.09191397f, 0.09404651f, 0.05393454f, -0.09346746f, 0.35822767f, -0.00337301f, 0.18048422f, 
    -0.04506249f, -0.18780723f, -0.02651740f, -0.06867739f, -0.01718557f, 0.00587487f, 0.13087656f, -0.28097817f, 
    -0.01619930f, 0.10211099f, -0.04267289f, 0.03837020f, -0.03177251f, -0.00157330f, 0.01256788f, -0.02496321f, 
    0.03231518f, -0.24664466f, 0.14030738f, 0.17404974f, 0.04829160f, -0.37419251f, 0.01261167f, -0.00960790f, 
    -0.20870392f, -0.07444712f, -0.11862016f, 0.18275358f, 0.06015473f, 0.15323986f, -0.19800925f, 0.05366031f, 
    -0.13990606f, 0.14442523f, 0.04047576f, -0.00206982f, 0.14082918f, -0.04053522f, 0.01135143f, 0.03532146f, 
    0.03309582f, -0.15935904f, 0.10235590f, -0.00598585f, 0.02977245f, -0.21439335f, -0.12714954f, -0.16516638f, 
    -0.25297230f, 0.01845523f, -0.16249460f, -0.07618564f, 0.06050226f, 0.10266858f, -0.00992589f, -0.03176475f, 
    0.05248686f, 0.20819637f, 0.19295296f, -0.09699043f, -0.06115184f, -0.04366446f, 0.13110557f, -0.11025101f, 
    -0.03656404f, -0.21281734f, -0.06560548f, 0.08758914f, -0.07951899f, 0.00345677f, 0.11867408f, 0.02622602f, 
    0.04086589f, 0.24235635f, 0.10332687f, -0.06710421f, -0.04445352f, -0.12838668f, 0.10800181f, 0.02326724f, 
    -0.04951186f, -0.44652948f, 0.02435339f, -0.08450933f, 0.07022599f, -0.16055061f, -0.17485476f, 0.13428345f, 
    0.00076795f, 0.02229732f, 0.19567707f, -0.09600524f, 0.07328921f, 0.09703700f, 0.24378234f, 0.04398971f, 
    0.10331565f, -0.03146876f, -0.04211234f, 0.14566572f, 0.14261276f, -0.02558732f, -0.04058416f, -0.05580179f, 
    -0.07085750f, 0.12749910f, 0.08124773f, 0.01634630f, 0.11786894f, 0.04539107f, 0.05939222f, -0.11889116f, 
    -0.05439778f, -0.15235724f, -0.09221257f, 0.04872246f, 0.11211749f, -0.07732394f, -0.09077126f, -0.34308690f, 
    -0.21430597f, 0.07395225f, 0.02196829f, 0.22290593f, 0.00653450f, -0.11214220f, 0.15128738f, -0.04458465f, 
    0.10977581f, 0.00258962f, -0.16617827f, -0.09545577f, -0.13508624f, 0.04738541f, -0.20243162f, 0.32370815f, 
    -0.21335100f, -0.15758833f, -0.66552663f, -0.10399256f, 0.26140982f, -0.01857564f, -0.00389159f, -0.00473583f, 
    0.16530105f, 0.04425684f, -0.17033994f, 0.12602071f, -0.04752260f, -0.15486592f, -0.01535156f, -0.12428918f, 
    0.01939411f, 0.03409802f, 0.01696364f, -0.16503826f, -0.62092334f, -0.08291240f, -0.41517773f, 0.04791086f, 
    -0.14224291f, 0.28290775f, -0.10890476f, 0.07421623f, 0.02612548f, 0.12964635f, 0.03233710f, 0.00913060f, 
    -0.18980508f, 0.02168793f, -0.11272807f, 0.01552132f, 0.02436428f, 0.00269231f, 0.04794264f, -0.02433881f, 
    0.12429868f, 0.13872080f, 0.17701735f, 0.05007195f, -0.04992031f, 0.04248376f, 0.12131739f, 0.10211731f, 
    0.07894413f, 0.04610375f, -0.04198164f, -0.27527553f, 0.03473263f, 0.05875561f, 0.06122969f, 0.03533158f, 
    0.27296862f, -0.15887167f, -0.13068385f, -0.01024796f, 0.20492560f, -0.01896019f, 0.28312117f, -0.02074638f, 
    -0.06574540f, 0.00657887f, -0.02034165f, -0.04020287f, 0.08759845f, 0.08378065f, -0.17235193f, 0.26070368f, 
    -0.33474278f, 0.11909681f, -0.09626797f, 0.08201864f, 0.05756790f, 0.08848090f, 0.00186407f, 0.15882699f, 
    0.25819561f, -0.01096782f, -0.08355946f, 0.29106480f, -0.20869467f, 0.40200457f, 0.04112655f, 0.03233653f, 
    -0.02598462f, 0.04171645f, 0.05842315f, -0.10150994f, 0.16660865f, 0.09442502f, -0.16253327f, 0.07603076f, 
    0.03931291f, 0.03821995f, 0.06131507f, 0.03942531f, -0.03093526f, -0.08661329f, -0.40002272f, 0.13967402f, 
    0.35614285f, -0.14413004f, -0.07792425f, -0.06540643f, 0.15991765f, 0.04308252f, 0.18378809f, -0.07886055f, 
    -0.77793735f, -0.01383536f, -0.24510773f, 0.07967870f, 0.01093142f, 0.05531655f, 0.18371642f, 0.08858298f, 
    -0.05197033f, -0.12452819f, 0.16819634f, 0.01587304f, 0.07648159f, -0.00921568f, -0.04973653f, -0.08997742f, 
    0.13649862f, -0.08396559f, -0.04839799f, 0.01784288f, -0.15482074f, -0.01901432f, -0.06166225f, 0.05515236f, 
    0.08895902f, 0.19764623f, -0.28741416f, 0.32849112f, 0.07775025f, -0.04616860f, -0.12137678f, 0.11386019f, 
    0.03989114f, -0.02542476f, -0.20082144f, -0.05246042f, -0.07522504f, 0.06536772f, 0.09373830f, 0.05263785f, 
    0.10945449f, -0.17948678f, 0.18623386f, 0.13337706f, -0.10273220f, -0.06730592f, 0.13185836f, -0.14797319f, 
    -0.05766360f, -0.05505380f, 0.03959370f, 0.09932304f, 0.01216309f, 0.08869458f, -0.13259740f, 0.00231515f, 
    -0.14768119f, 0.02706902f, -0.06428895f, 0.07829107f, 0.14235918f, 0.13008207f, -0.32475629f, 0.01278903f, 
    -0.04638752f, -0.21685173f, -0.11910582f, -0.01688919f, -0.02867163f, 0.06410526f, -0.13457483f, 0.17536812f, 
    -0.06643142f, -0.04888950f, -0.03322003f, -0.04831773f, 0.17486809f, -0.04428016f, 0.04474049f, -0.06956613f, 
    0.02964849f, 0.02435277f, -0.09731596f, -0.05712917f, -0.08925381f, -0.14627120f, -0.16849484f, -0.12100258f, 
    -0.03675521f, -0.12211609f, 0.18686593f, 0.13601124f, -0.01801533f, -0.08436520f, 0.02448262f, -0.11469592f, 
    0.12511122f, 0.38708314f, -0.07102399f, -0.29369336f, -0.13853836f, 0.36191624f, -0.08170377f, 0.19734497f, 
    -0.06124344f, 0.05705508f, -0.04864018f, 0.06626050f, -0.13037802f, 0.14161102f, -0.02533836f, -0.09870233f, 
    0.11275246f, 0.13136309f, 0.15379919f, -0.08300497f, -0.34721097f, 0.36896735f, -0.02469602f, -0.02891863f, 
    -0.09802724f, 0.17525014f, 0.10028759f, -0.09574865f, 0.31543243f, -0.39102381f, 0.04138311f, 0.29527530f, 
    -0.27344370f, -0.09829903f, -0.07590736f, -0.10576482f, 0.08657853f, 0.01508296f, -0.03460521f, 0.27741876f, 
    -0.01468414f, 0.00616845f, 0.01952971f, 0.03426213f, -0.09400329f, -0.15713589f, 0.12829232f, 0.07723544f, 
    -0.05834768f, -0.06413949f, -0.15315877f, 0.10164235f, 0.12082152f, 0.13318475f, 0.09670644f, -0.10997687f, 
    -0.07075404f, 0.14982757f, 0.21153384f, -0.05976311f, -0.23566058f, -0.10609665f, -0.02584734f, 0.12610328f, 
    -0.18741378f, 0.24599826f, 0.19053717f, -0.11402361f, -0.04051917f, -0.02759824f, 0.13747951f, 0.08750308f, 
    -0.03424859f, -0.29229209f, -0.19865288f, 0.05849176f, -0.09473480f, 0.07275623f, 0.19722955f, 0.09808966f, 
    -0.10012452f, -0.07903787f, -0.25389627f, -0.02657080f, 0.19211011f, 0.02754005f, 0.10227576f, -0.05164864f, 
    0.02410157f, 0.02890972f, 0.15674418f, 0.18399499f, 0.22615419f, 0.19658683f, -0.01994180f, 0.07636692f, 
    0.12106420f, -0.08185523f, -0.04195771f, -0.12041692f, -0.29868829f, 0.10848766f, 0.10808878f, -0.02005224f, 
    -0.47772902f, -0.03767077f, -0.14442204f, -0.06754337f, 0.19464386f, 0.18965009f, 0.12366826f, -0.02100893f, 
    0.04931051f, 0.04884128f, -0.15270965f, 0.11318589f, 0.12472928f, -0.13488808f, -0.12561718f, -0.08205471f, 
    0.17734681f, -0.05825929f, -0.39452961f, -0.08818662f, -0.08411411f, -0.04209405f, -0.01739007f, 0.16112502f, 
    0.31170681f, -0.28588027f, -0.02623508f, -0.07159226f, -0.16498661f, -0.12038743f, 0.03347011f, 0.01364432f, 
    -0.09872489f, -0.33932123f, -0.12525257f, 0.18306164f, -0.16415220f, 0.34566072f, -0.05314049f, -0.05186404f, 
    0.23583502f, 0.03016680f, -0.14770910f, 0.04542133f, -0.32572123f, -0.05194077f, 0.08299115f, -0.06089374f, 
    -0.00832026f, 0.06293982f, 0.09992658f, -0.02975529f, 0.25949413f, -0.02571810f, -0.04456158f, -0.18595976f, 
    -0.01577678f, 0.05667780f, 0.05590316f, 0.24399227f, 0.16584784f, 0.36849099f, 0.03666068f, -0.17940380f, 
    -0.01402504f, 0.08941544f, 0.10698690f, -0.08873008f, -0.09781304f, 0.14644808f, 0.09261782f, 0.15529726f, 
    -0.16180035f, -0.16248514f, -0.03991051f, 0.12373786f, 0.06317069f, -0.19622247f, 0.38008049f, -0.25177357f, 
    -0.19876382f, -0.00924466f, -0.03691445f, -0.27103075f, -0.15786301f, -0.03245020f, -0.42926446f, -0.05522320f, 
    -0.41062409f, -0.03976488f, 0.21990970f, 0.07357157f, -0.04808152f, 0.14733402f, -0.33117896f, -0.01685498f, 
    0.19051161f, 0.33290607f, 0.08544414f, 0.06789374f, 0.16961573f, 0.04626408f, -0.04224614f, -0.01119766f, 
    -0.23558220f, 0.22448932f, 0.18618974f, 0.09571554f, -0.02380101f, -0.08270303f, -0.00626763f, 0.08880007f, 
    -0.04311978f, 0.67484242f, 0.16558801f, 0.42219752f, -0.06149194f, 0.15594812f, -0.04427880f, 0.08360900f, 
    -0.04679349f, -0.11871883f, -0.32078397f, -0.23821436f, 0.40507609f, -0.12052354f, -0.00793897f, -0.08224483f, 
    -0.03299509f, 0.00986486f, -0.12813464f, -0.14250991f, -0.00647472f, 0.00124269f, -0.00881685f, -0.06280671f, 
    -0.14909112f, 0.01960948f, 0.02085883f, 0.07411943f, -0.01713159f, 0.19396865f, 0.22346328f, -0.07291312f, 
    -0.22033677f, 0.08873883f, -0.03906642f, 0.15019989f, 0.34692705f, 0.20018528f, 0.28490219f, 0.39560378f, 
    0.04467028f, -0.16724633f, -0.21021920f, 0.11701567f, 0.08606903f, -0.12133786f, -0.06797118f, -0.08467002f, 
    0.05384011f, -0.24223551f, 0.16707580f, -0.01584488f, 0.24483329f, -0.03217578f, -0.01929023f, -0.32624102f, 
    0.02577856f, -0.20361459f, 0.03075716f, -0.11013664f, -0.09886605f, -0.08707565f, 0.00815836f, 0.25754336f, 
    -0.13370781f, 0.21197860f, 0.26562673f, -0.07244181f, -0.25213853f, -0.02065979f, 0.15651140f, -0.01483504f, 
    -0.06382566f, -0.63705832f, -0.33552381f, -0.13379349f, 0.10601784f, -0.06887961f, 0.08209575f, -0.24145584f, 
    -0.01012059f, -0.05717251f, -0.13670008f, 0.00962658f, -0.00496015f, 0.02640803f, 0.11877076f, 0.08658652f, 
    0.08813515f, -0.00168040f, 0.04017337f, -0.35920614f, -0.13189554f, 0.35612407f, -0.06340274f, 0.16309296f, 
    -0.04245660f, 0.05961204f, -0.09133694f, 0.12023734f, 0.22505398f, 0.52832097f, -0.28162423f, -0.01147330f, 
    -0.24850783f, -0.02048825f, -0.24040557f, -0.11996108f, -0.02075920f, 0.17855214f, 0.47115108f, 0.55412132f, 
    -0.11438355f, -0.02954827f, -0.09853817f, 0.17246383f, 0.11933310f, -0.17799602f, -0.18640853f, 0.01806867f, 
    -0.19552493f, -0.08809002f, 0.11421700f, 0.06358249f, 0.22007047f, 0.08187217f, 0.05462284f, -0.16269363f, 
    -0.05629961f, -0.15160953f, -0.07921061f, -0.08662818f, 0.01678622f, -0.07963895f, 0.06069927f, 0.35270789f, 
    -0.17741528f, -0.03625437f, -0.10489296f, 0.10428645f, 0.00590019f, -0.01926932f, 0.08378211f, 0.12815401f, 
    0.04465308f, -0.31157333f, -0.34544802f, -0.50740713f, -0.07571509f, -0.00691058f, -0.14664370f, 0.11132064f, 
    -0.14785537f, -0.01929887f, 0.63284272f, 0.23696505f, 0.29448423f, 0.26554161f, 0.11942364f, 0.40315494f, 
    0.09578266f, 0.09532050f, 0.09807643f, 0.05159752f, -0.15457791f, -0.08755149f, -0.29014876f, -0.19675291f, 
    -0.46453846f, 0.04435651f, 0.03362825f, 0.07584289f, 0.62004876f, -0.58049029f, -0.93362838f, 0.10064349f, 
    0.01984617f, 0.18514064f, 0.12550594f, -0.12926821f, 0.02241531f, 0.01901051f, -0.14472671f, -0.10179986f, 
    -0.30163842f, -0.03701670f, -0.06957664f, 0.11450095f, 0.05429536f, 0.04215251f, 0.28117347f, -0.14285833f, 
    -0.02484589f, -0.05834877f, -0.17858751f, 0.27925563f, 0.00260543f, 0.15903941f, -0.32064602f, 0.13131545f, 
    -0.31576499f, -0.01137656f, -0.10265869f, -0.03375144f, 0.07897763f, 0.08108161f, 0.31042808f, 0.13498591f, 
    0.25710171f, 0.13570589f, 0.45146912f, 0.10036092f, -0.09678315f, 0.07071287f, -0.04209533f, 0.01150738f, 
    -0.06702572f, -0.27122724f, -0.37252715f, -0.01222988f, 0.04180755f, 0.10319046f, -0.06923085f, 0.01281181f, 
    -0.04239844f, 0.06926530f, -0.06471537f, -0.07292956f, 0.12363673f, 0.04954322f, -0.14362571f, 0.30304012f, 
    0.06338575f, 0.00823981f, -0.06263837f, 0.17510501f, 0.27807707f, 0.27326438f, -0.22274835f, -0.02468321f, 
    -0.35789877f, 0.04778836f, 0.03828743f, -0.02406940f, -0.17408383f, -0.44210431f, -0.30173877f, 0.02974143f, 
    -0.10948481f, -0.10823093f, 0.07850952f, -0.00896556f, 0.07072514f, 0.23376136f, -0.35503438f, 0.07017622f, 
    -0.03086540f, 0.01917420f, -0.05806945f, 0.03390145f, -0.19328313f, -0.03145018f, -0.27710763f, -0.43190792f, 
    -0.79409486f, -0.12177386f, -0.34290779f, -0.11759038f, 0.21720769f, -0.07169157f, -0.20453544f, 0.19139336f, 
    0.17537256f, -0.24103025f, 0.02212284f, -0.04691192f, 0.27593881f, 0.00662820f, 0.22510959f, -0.18880051f, 
    0.13962685f, 0.09892122f, 0.02814248f, -0.04229729f, 0.02209039f, 0.11283059f, -0.06876411f, -0.00614366f, 
    -0.03517537f, -0.51357311f, -0.01112935f, 0.07075383f, -0.06562237f, -0.20269905f, -0.25495332f, 0.04266007f, 
    0.01008840f, 0.07613121f, 0.10076261f, -0.37500978f, -0.37836078f, 0.08052392f, 0.13405693f, -0.11373534f, 
    0.17657201f, -0.00019912f, -0.15050930f, -0.11847018f, -0.05665271f, -0.16426419f, 0.03423438f, -0.11277652f, 
    0.03381749f, -0.04391430f, 0.05468165f, 0.11774799f, 0.25506637f, -0.09621123f, -0.13238791f, -0.02566867f, 
    0.01264689f, 0.01096047f, 0.19797850f, 0.18925524f, 0.12812316f, 0.39295977f, 0.29086789f, 0.08102968f, 
    0.01095386f, -0.07983886f, 0.30551550f, 0.17139985f, -0.17583480f, 0.08033936f, 0.01906050f, -0.31041738f, 
    -0.23357986f, 0.10723486f, 0.16434418f, 0.19974510f, -0.02497197f, 0.17336124f, 0.16318023f, 0.51406491f, 
    -0.08499590f, 0.21037190f, 0.04947915f, 0.03147726f, 0.18151338f, -0.07082120f, 0.31225458f, 0.18123241f, 
    0.43502113f, -0.04781571f, 0.17365772f, 0.17860751f, 0.31490067f, 0.02501694f, 0.01440568f, -0.01642162f, 
    -0.04663203f, -0.03864231f, -0.33492869f, -0.49869403f, -0.10621330f, -0.08664542f, 0.01707805f, 0.00405937f, 
    -0.13078430f, -0.33753252f, 0.04067170f, -0.06292403f, -0.23582110f, 0.06642497f, 0.05120825f, 0.00277561f, 
    0.14186853f, 0.27630681f, -0.04830831f, 0.03063497f, 0.02389626f, -0.10878764f, -0.05708702f, -0.08190642f, 
    0.03400414f, 0.07453775f, -0.01622698f, -0.01353218f, -0.09797611f, -0.64382166f, 0.09525799f, 0.10676120f, 
    0.13000210f, -0.12432203f, 0.14598027f, 0.03225377f, 0.14772500f, 0.42083445f, 0.41863874f, 0.23262915f, 
    -0.23523748f, -0.17100534f, 0.22702827f, 0.13028672f, -0.11905385f, 0.09412356f, -0.01318246f, -0.08554860f, 
    -0.13409926f, 0.11598498f, -0.03791941f, 0.13055907f, 0.03908737f, 0.07021218f, 0.12974095f, -0.43953773f, 
    -0.40415764f, 0.03431496f, 0.16654165f, -0.03902210f, -0.07357727f, -0.03779906f, -0.01673297f, -0.10343666f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.14301635f, -0.22487248f, 0.03041845f, 0.00958749f, 0.22707148f, -0.01192434f, 0.03392356f, 0.05817579f, 
    0.09358379f, 0.29751042f, 0.38009095f, -0.08420473f, 0.07290718f, 0.05595591f, 0.21940562f, 0.26028436f, 
    0.01808476f, 0.00407295f, 0.32031113f, -0.05542172f, -0.04129006f, -0.04937537f, 0.25606853f, 0.30504602f, 
    0.13591948f, -0.09181943f, 0.20657668f, 0.21355730f, -0.05150185f, 0.06423407f, -0.02489067f, -0.12831604f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.89659381f, 0.38998309f, -0.13903314f, -0.14562625f, -0.22059761f, 0.40247294f, 0.07927979f, 0.11240192f, 
    0.17599684f, -0.26795661f, -0.29971856f, 0.06882343f, -0.30552304f, -0.20305255f, 0.03171429f, -0.03184966f, 
    0.48862627f, 0.07373811f, 0.11848417f, -0.00333938f, 0.14826111f, 0.04171327f, -0.14733011f, -0.36169028f, 
    -0.16169880f, 0.32461739f, -0.15223028f, -0.25795591f, -0.12128352f, -0.40776542f, -0.43508551f, 0.57415694f, 
    -0.27837330f, -0.03028035f, -0.23307803f, 0.16943589f, 0.65710497f, -0.07627776f, 0.16567418f, 0.05271542f, 
    -0.12486051f, 0.09986196f, 0.17185999f, -0.36598739f, -0.31588918f, 0.04445468f, 0.25438049f, 0.00576998f, 
    0.10383224f, -0.03436125f, -0.35824469f, 0.05193376f, 0.13712916f, -0.04450237f, 0.41988629f, -0.03450244f, 
    0.20581660f, 0.01079026f, 0.21408914f, 0.02616017f, -0.12363031f, -0.35778648f, -0.67447013f, 0.38997915f, 
    0.15943564f, -0.15026139f, 0.26399434f, 0.08550566f, 0.18052170f, -0.77606678f, 0.05891300f, -0.06169602f, 
    0.14455786f, 0.11123289f, 0.38871941f, 0.17592736f, -0.33565366f, -0.21942523f, -0.46212932f, -0.37901178f, 
    -0.02801636f, -0.05076075f, 0.42508739f, 0.16322279f, -0.16734944f, 0.14543237f, -0.87355858f, 0.35304287f, 
    -0.08914479f, -0.26397082f, -0.31876716f, 0.14526471f, -0.34162283f, -0.00505006f, -0.44301060f, -0.42007554f, 
    0.84691602f, 0.10210915f, 0.37218666f, -0.05067431f, -0.16191970f, -0.01789664f, 0.56967461f, 0.01813693f, 
    -0.59669632f, 0.20080227f, -0.73252606f, 0.29522452f, -0.02675213f, -0.87983203f, -1.02416217f, -0.79231238f, 
    0.04322523f, -0.00286710f, -0.72768891f, -0.13925846f, -0.02096357f, 0.11903218f, -0.39582655f, 0.13784173f, 
    -0.06501272f, -0.59856755f, 0.32961529f, 0.13998070f, -0.34583110f, -0.37868708f, -0.08053110f, 0.10594911f, 
    -0.34306353f, -0.13433206f, 0.28984794f, -0.08534236f, 0.12281390f, -0.06163699f, -0.18350095f, 0.13081273f, 
    0.43216699f, -0.08013278f, 0.00057581f, 0.16840485f, -0.03345878f, 0.12419323f, -0.00963267f, -0.34470445f, 
    0.00794995f, -0.15136135f, -0.75763720f, 0.06113476f, 0.13684845f, -0.12545034f, -0.11865330f, -0.52522057f, 
    -0.27471942f, 0.29110396f, 0.25309545f, 0.02135252f, -0.09814656f, 0.07191429f, 0.70393944f, 0.09086604f, 
    0.06990392f, 0.09591816f, -0.05085483f, 0.02833025f, 0.18466432f, 0.54861230f, -0.48996255f, 0.21426845f, 
    0.08849248f, -0.32528892f, -0.22027332f, -0.05741737f, 0.00467895f, 0.14555803f, -0.40666050f, 0.16474310f, 
    -0.19211009f, -0.13181673f, -0.44959682f, -0.11119526f, -0.16434072f, -0.04341792f, 0.13526970f, 0.07896466f, 
    0.17431478f, -0.26163691f, -0.28107172f, 0.18877225f, 0.30150098f, 0.62576389f, -0.25535470f, 0.06282407f, 
    -0.12197475f, -0.36464414f, -0.15176377f, -0.02822086f, -0.83202320f, -0.70450687f, -0.19131376f, 0.64565599f, 
    0.07742592f, 0.22743277f, 0.30354792f, 0.20240819f, -0.09034222f, -0.28297594f, 0.54289734f, 0.22552828f, 
    -0.55562252f, -0.06219748f, 0.53879511f, -0.14254041f, -0.05983848f, 0.01721376f, -0.62312722f, -0.00896843f, 
    -0.02127998f, -0.10741636f, -0.07919203f, -0.01778032f, 0.14635722f, -0.25577420f, -0.47989026f, -0.61751395f, 
    -0.04063855f, -0.02040204f, 0.03494128f, -0.17181513f, -0.15010472f, -0.61097491f, 0.21327703f, 0.41706309f, 
    0.11307540f, -0.39862651f, -0.03122926f, 0.02268234f, 0.19096202f, 0.08830740f, 0.01120454f, -0.36475486f, 
    0.11164398f, 0.16587093f, 0.09428494f, -0.05500940f, 0.01411200f, -0.02610483f, 0.44841203f, -0.13263330f, 
    -0.15326594f, 0.46987224f, -0.39904210f, -0.25619856f, 0.00731220f, 0.14060548f, -0.11717880f, -0.21450919f, 
    0.41575259f, 0.18754372f, -0.54775721f, -0.08404833f, -0.42882401f, -0.84817898f, -0.08284670f, -0.69784707f, 
    0.14651686f, -0.31874678f, 0.10974702f, -0.35469177f, 0.26038721f, -0.48315385f, 0.03294937f, 0.18693233f, 
    0.06631137f, 0.04295894f, 0.70871222f, -0.11498562f, 0.12749502f, 0.09504951f, 0.33674446f, -0.01574514f, 
    0.18734144f, -0.29655528f, -0.47146958f, 0.29653990f, 0.11561679f, 0.03278700f, 0.00516217f, 0.11180365f, 
    0.04789170f, -0.64230859f, -0.10761150f, -0.03813078f, -0.09630311f, -0.58154607f, -0.24517275f, -0.37335092f, 
    0.52099156f, 0.32754776f, -0.11240406f, 0.36722395f, -0.39864889f, -0.19083889f, 0.04006661f, 0.82227689f, 
    0.25147611f, -0.12155274f, -0.34281760f, 0.14056194f, 0.05457104f, -0.15633817f, -0.14956716f, -0.24275295f, 
    -0.12383197f, -0.47170240f, 0.53310806f, -0.07780728f, -0.32873258f, 0.44972104f, 0.36823785f, -0.11526377f, 
    0.06796775f, 0.36649901f, -0.27729243f, 0.08677652f, -0.09858362f, 0.05429251f, -0.36273208f, -0.07788911f, 
    -0.23344587f, -0.04770564f, 0.08433318f, -0.26881948f, -0.18396483f, -0.24001119f, -0.23612036f, -0.06508857f, 
    -0.47704831f, -0.08739495f, -0.45793694f, 0.08613832f, -0.17393868f, 0.11953250f, -0.29389137f, 0.33305374f, 
    0.09423490f, 0.91320032f, 0.58553165f, 0.37919772f, 0.28780830f, -0.46441177f, 0.15282366f, -1.10389674f, 
    0.03688903f, -0.00100975f, -0.05599338f, 0.17135106f, -0.77179551f, -0.15898637f, -0.17189395f, -0.31713533f, 
    -0.43585879f, 0.13394083f, -0.21906367f, -0.11868098f, 0.92359364f, 0.85523260f, 0.20457366f, -0.15917960f, 
    -0.83950824f, 0.15598026f, 0.11637305f, 0.10307740f, -0.10497168f, -0.16584350f, -0.59503222f, 0.32823142f, 
    0.16017795f, -0.63851613f, 0.23170230f, 0.03955119f, -0.58847499f, -0.06622498f, 0.40876669f, 0.03318305f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.37095439f, 0.02270580f, 0.16855073f, -0.06846011f, -0.01649664f, -0.09489293f, -0.15279303f, -0.43191516f, 
    -0.01816168f, -0.06488578f, 0.11754529f, 0.10316279f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
