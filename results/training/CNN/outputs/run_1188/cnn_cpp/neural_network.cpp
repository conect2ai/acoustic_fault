#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.74613672f, -0.10541280f, -0.04687491f, 0.15810114f, 0.29560435f, -0.52324003f, 0.91567707f, 0.72364199f, 
    0.65137142f, -0.22741976f, 0.12156153f, 0.79139519f, 1.03523326f, -0.12981400f, 0.81328726f, -0.34810984f, 
    -0.81456250f, -0.51943177f, -0.54498184f, -0.66749924f, -0.37727624f, -0.72329420f, -1.08899784f, -0.38469669f, 
    0.74292850f, 0.83369267f, 0.81144077f, 0.24434595f, 0.00457754f, 0.85004926f, 0.83687538f, 0.11455088f, 
    0.71035570f, -0.02135940f, 1.11262870f, -0.52346987f, 0.78445220f, -0.43382865f, 1.44635308f, -0.04221609f, 
    -0.25766465f, 0.04703340f, -0.00431696f, 0.06982586f, 0.26573342f, 0.17904709f, -0.23556273f, -0.12387921f, 
    -0.96981174f, -1.39059412f, -1.27462113f, -0.47769302f, -0.30260074f, -0.25870416f, -0.51126397f, -0.38640425f, 
    0.06060381f, -1.02645254f, -0.07714462f, -1.16340852f, -0.22375070f, -0.53259617f, 0.77252859f, -0.23506887f, 
    -1.02759671f, -1.49048233f, 0.67710644f, 0.65706390f, 0.75439954f, -0.12602374f, 0.05924099f, -0.33853945f, 
    1.49998689f, 0.01192744f, -1.02701926f, -0.68838114f, -0.21050711f, -0.50584203f, 0.53104997f, 0.54518390f, 
    0.29485333f, -1.59610975f, -1.28090537f, -0.53597307f, -0.03233454f, 0.34823090f, -0.41702345f, -0.11921911f, 
    -0.49114037f, -1.06813025f, -1.90454805f, -0.11333918f, 0.77559155f, 1.17412686f, -0.22209130f, -1.14192688f, 
    -0.29526892f, 0.19120686f, -0.52936196f, -0.62938869f, -0.47707471f, -0.97123837f, -0.14381643f, -0.46971014f, 
    -0.26068825f, -0.63289034f, -0.69886851f, 0.36453775f, -0.53044462f, 0.24938750f, -0.11643146f, 0.82049358f, 
    0.50078297f, -0.89187992f, 0.96364254f, -0.12149525f, 0.73015445f, -1.50201929f, 1.54393935f, -1.14331460f, 
    -0.52416962f, 0.60880005f, -0.72944659f, -0.20304631f, -0.46913603f, -0.20660447f, 1.27874231f, -0.58828199f, 
    -0.55235749f, -0.49861062f, 0.18019818f, 0.37258601f, -0.04549986f, -0.41476312f, 0.51728791f, -0.36024326f, 
    -0.22477901f, 1.50576937f, -0.86897665f, 0.11993657f, 0.48029724f, 0.14230338f, -0.58816421f, -0.23901810f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.38051388f, 0.59016556f, -0.05886746f, 0.04013719f, 1.04366839f, 0.01828778f, 0.72732508f, 0.63577533f, 
    0.55184698f, 0.08501040f, 0.48301807f, -0.20022456f, 0.50559300f, 0.20438218f, 0.66582918f, 0.36996546f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.12914243f, -0.07093666f, 0.03618577f, 0.26104668f, 0.15071833f, -0.11863420f, 0.33410704f, 0.22292177f, 
    0.32738301f, -0.19047697f, -0.07279730f, -0.00285547f, 0.19540101f, 0.30924046f, 0.34643215f, -0.26715168f, 
    -0.75752252f, -0.54281604f, 0.37913084f, -0.13825534f, -0.31003857f, -0.01612042f, -0.07338008f, -0.07401025f, 
    0.25863457f, 0.10385923f, 0.07445707f, 0.05756541f, -0.01014683f, -0.00037405f, 0.05459997f, 0.17859158f, 
    -0.33409682f, -0.17430747f, -0.15059714f, 0.08728063f, -0.04983857f, 0.11445301f, -0.08845702f, 0.29056165f, 
    0.01614963f, 0.06723023f, 0.24524052f, 0.03819138f, -0.12090804f, 0.26328161f, 0.18686959f, 0.16541056f, 
    -0.05472604f, 0.15126644f, 0.20579310f, -0.22380801f, 0.11361319f, -0.17151478f, 0.56572551f, 0.08482454f, 
    -0.21898636f, -0.11028553f, 0.08064009f, 0.07724594f, 0.20057079f, 0.07228141f, 0.09723306f, 0.13133678f, 
    -0.13699247f, -0.38889438f, -0.19169094f, 0.07906140f, 0.01858530f, -0.08166075f, -0.25767118f, -0.27105090f, 
    -0.21278711f, -0.41997245f, -0.23845518f, -0.03644171f, 0.08856556f, 0.36648941f, 0.23316537f, 0.08568954f, 
    0.08180936f, 0.13773364f, -0.11846907f, -0.40567639f, 0.13567723f, -0.13194673f, 0.03027900f, -0.16539204f, 
    -0.02879339f, 0.04124948f, 0.36175317f, 0.33973667f, -0.48232388f, 0.21922594f, -0.12994829f, -0.08500139f, 
    -0.29609933f, 0.11781815f, -0.16360725f, 0.41110355f, -0.04688536f, -0.79742831f, 0.11999677f, -0.10952280f, 
    -0.20079689f, 0.15184535f, -0.01493865f, -0.05478306f, 0.01588882f, -0.10066169f, -0.04110787f, 0.13994293f, 
    0.18402092f, 0.01938134f, 0.21531799f, 0.33513570f, 0.06344919f, 0.83237386f, -0.14783485f, -0.08918417f, 
    0.05801533f, 0.19467428f, 0.24035494f, -0.15975410f, -0.04502911f, -0.29802850f, 0.11517042f, -0.07964987f, 
    -0.36802906f, 0.41596419f, 0.15171978f, -0.17052208f, 0.30987212f, 0.31397375f, 0.06258201f, -0.25308192f, 
    -0.03205324f, 0.07963396f, 0.11165872f, -0.02121136f, 0.20282906f, -0.07409888f, 0.31602484f, -0.10218442f, 
    -0.29644868f, 0.15745011f, -0.10385099f, -0.11131071f, 0.06903634f, -0.20500824f, -0.29676259f, -0.16252996f, 
    -0.20424822f, -0.30952087f, -0.06580377f, -0.16008563f, 0.05542705f, 0.10580223f, 0.17595901f, 0.23062238f, 
    0.26164493f, -0.04881533f, 0.04870321f, -0.74936336f, -0.23930687f, 0.08256500f, 0.18740356f, -0.21397868f, 
    0.06802749f, -0.06578656f, -0.25052425f, -0.36143956f, 0.12519991f, -0.26081485f, -0.09673744f, 0.12729837f, 
    0.01710231f, 0.20600735f, -0.17086723f, -0.16718189f, 0.54396731f, 0.47159919f, 0.07423618f, 0.04773055f, 
    0.12067814f, -0.16844112f, -0.08604946f, -0.00688675f, -0.30502680f, 0.32718620f, 0.10465425f, 0.46635959f, 
    0.17235182f, 0.02336090f, 0.01823672f, -0.05519387f, 0.06547555f, 0.11182151f, 0.10002902f, -0.09774151f, 
    -0.16148719f, -0.09744322f, -0.10703498f, -0.03162549f, 0.00924007f, 0.11085998f, -0.02318758f, 0.10670343f, 
    -0.48499784f, -0.05374713f, -0.00329493f, 0.17021140f, 0.45455003f, -0.01189405f, 0.11738539f, 0.16085294f, 
    -0.29487565f, 0.09943365f, 0.23880206f, 0.04884320f, 0.09793957f, -0.12418839f, 0.03211546f, -0.07037886f, 
    -0.04392480f, 0.52662861f, -0.44403577f, -0.55769640f, -0.10893321f, -0.20638929f, 0.23987120f, 0.01773784f, 
    -0.22661547f, 0.27055275f, 0.22106241f, 0.16594306f, -0.49527767f, -0.15065403f, -0.07783435f, 0.09561944f, 
    0.06116396f, -0.09674276f, 0.15555127f, 0.13440846f, -0.27967560f, -0.30032983f, -0.18125814f, -0.16928649f, 
    0.13679944f, -0.25004387f, -0.13230307f, 0.12300760f, -0.06421970f, -0.18018444f, -0.36628810f, -0.04226721f, 
    0.14213191f, 0.14491129f, 0.10966424f, 0.03751032f, -0.46397787f, 0.47558841f, -0.11330532f, 0.08974823f, 
    0.15899612f, 0.26886073f, 0.02336858f, 0.09437916f, 0.13406402f, 0.26474801f, -0.37319395f, 0.24641654f, 
    0.23548540f, 0.06997499f, 0.38716608f, 0.17502080f, 0.03312254f, -0.03171779f, -0.20879826f, 0.29765102f, 
    0.53192991f, -0.12486336f, -0.00840751f, 0.26547003f, -0.02996092f, 0.04032649f, -0.04920149f, 0.10136417f, 
    0.04637958f, -0.40531063f, -0.09332450f, -0.28945884f, -0.02859136f, 0.07640508f, -0.33114883f, -0.31795651f, 
    -0.25577298f, 0.08208435f, 0.29019955f, -0.15656762f, -0.06256729f, 0.17450801f, -0.07807441f, 0.10912752f, 
    0.21872500f, 0.21342829f, 0.38814527f, 0.20210996f, 0.26687399f, 0.01935672f, -0.01513256f, -0.23599304f, 
    0.08377321f, -0.10747354f, -0.22185519f, 0.46287617f, -0.35634494f, -0.48347902f, 0.00736568f, -0.11189228f, 
    0.01371201f, 0.12618248f, -0.21314605f, 0.47601968f, -0.13115592f, -0.25652242f, -0.09203633f, -0.20869663f, 
    -0.09310666f, 0.00315937f, 0.09335585f, -0.18595576f, 0.00310583f, -0.06995797f, 0.40849403f, 0.02173559f, 
    0.04191507f, 0.13408652f, -0.07173133f, 0.16258015f, -0.21206683f, 0.05250053f, 0.11775096f, 0.16994365f, 
    0.03743425f, 0.11461315f, -0.14339122f, 0.05230305f, -0.07614801f, 0.02337599f, -0.20918068f, -0.33742598f, 
    -0.36280453f, -0.34258229f, 0.11516402f, 0.14865811f, 0.22436322f, 0.20606171f, 0.24642771f, 0.23391779f, 
    0.12127516f, 0.25889108f, -0.34014484f, 0.01099196f, -0.28703484f, -0.14443539f, -0.00633337f, -0.07259507f, 
    -0.24528505f, -0.13199447f, -0.27350852f, 0.30134115f, -0.03487051f, -0.22352071f, -0.02598371f, -0.07864866f, 
    -0.29686552f, 0.23206110f, 0.09050886f, -0.12595053f, 0.13140218f, 0.17124079f, 0.01058714f, 0.38320965f, 
    0.25137398f, -0.00310367f, 0.00669909f, 0.24073358f, 0.01331676f, 0.10205837f, 0.15385348f, 0.01939583f, 
    0.28563875f, -0.24862909f, 0.14014195f, -0.11112738f, -0.02440160f, 0.02710838f, 0.01357000f, 0.06152051f, 
    -0.28355363f, -0.16010180f, -0.13217592f, 0.02376967f, -0.29678217f, 0.12956199f, 0.61692595f, -0.05338572f, 
    -0.36299759f, 0.01856910f, 0.26295820f, 0.12859195f, 0.03604985f, 0.25262383f, -0.10198766f, 0.58567512f, 
    -0.13198823f, 0.30506641f, 0.07356941f, 0.13705860f, 0.28404912f, 0.24825032f, -0.11252691f, 0.24444760f, 
    0.03618256f, -0.08429324f, 0.07492958f, -0.12620322f, 0.10610788f, 0.08515197f, -0.02477113f, 0.02074487f, 
    0.11686718f, -0.01900994f, 0.09169712f, 0.01039339f, 0.15261331f, 0.28031635f, -0.13251962f, 0.07390062f, 
    -0.08337086f, -0.19699709f, 0.08782668f, 0.41805875f, 0.11998360f, -0.09922016f, -0.20228168f, 0.02153824f, 
    0.08263660f, 0.02163349f, 0.25779167f, 0.43183640f, 0.14648406f, 0.23249103f, -0.07712142f, -0.29732931f, 
    0.16250840f, 0.00617664f, 0.05087378f, 0.03364075f, 0.00659572f, 0.26911259f, -0.00565511f, -0.12443146f, 
    0.01572008f, -0.17354664f, 0.28917605f, 0.28361574f, -0.37119353f, -0.25532165f, 0.07676145f, -0.17853695f, 
    0.12754145f, 0.02033216f, 0.03333709f, -0.01754056f, 0.08941303f, -0.36675075f, 0.46182558f, 0.19063456f, 
    -0.00932675f, -0.15263915f, -0.32748169f, 0.18443532f, -0.01972272f, 0.23140152f, 0.12256057f, 0.47552490f, 
    0.46259263f, -0.10849626f, -0.13580596f, 0.03160498f, -0.06027609f, 0.01033263f, 0.03256878f, 0.24073461f, 
    -0.58037210f, -0.62036359f, 0.05050071f, 0.27375323f, 0.11469925f, 0.03232650f, 0.03169451f, -0.04590461f, 
    -0.22927955f, -0.20111799f, -0.44854549f, -0.23098400f, 0.06850153f, 0.18741754f, -0.07073712f, 0.04895271f, 
    0.18937632f, 0.61635059f, 0.00660138f, -0.22174688f, 0.04350788f, 0.15071528f, -0.05545783f, -0.04226950f, 
    -0.02683658f, 0.05561638f, 0.40888807f, 0.36551175f, -0.27047086f, -0.07818954f, -0.01080949f, 0.01393097f, 
    0.03806265f, 0.04482267f, 0.02832886f, 0.32899332f, 0.20487876f, 0.23447201f, -0.28116935f, 0.09825318f, 
    0.26299825f, 0.12021525f, 0.06781318f, -0.19945776f, -0.00065483f, -0.06713723f, -0.02250895f, -0.00849269f, 
    -0.27484602f, 0.00257346f, 0.10492831f, 0.13782035f, 0.04563646f, -0.54575902f, 0.39296195f, 0.21197604f, 
    -0.28763643f, 0.13371301f, 0.41164419f, -0.01318393f, -0.16031085f, -0.05372416f, -0.32134864f, -0.29873866f, 
    0.09521776f, -0.03518704f, -0.39319429f, 0.02406393f, -0.07705286f, 0.07817341f, 0.09430374f, -0.86454296f, 
    0.04515979f, 0.45089394f, -0.10366374f, -0.00341327f, -0.00455425f, -0.18491679f, -0.03429333f, 0.06903742f, 
    -0.00460050f, -0.10230554f, -0.12378741f, -0.17556866f, -0.32772809f, -0.01007886f, -0.12691508f, -0.03561051f, 
    -0.12538016f, 0.06906354f, 0.34045178f, -0.08714118f, -0.10467148f, -0.11980174f, -0.06620431f, 0.23560579f, 
    0.08128431f, 0.40464947f, -1.03848100f, 0.20113192f, -0.89494991f, -0.54956537f, 0.16940287f, -0.25743631f, 
    -0.06597091f, -0.21964179f, -0.08862627f, -0.04825326f, -0.16951141f, -0.33133978f, -0.10556501f, -0.18242820f, 
    0.18411508f, 0.14210300f, -0.11368550f, 0.18696758f, 0.37154180f, -0.14987767f, -0.28757212f, 0.11683474f, 
    0.09322107f, 0.40478948f, 0.31639066f, -0.10366362f, 0.25614583f, -0.73895109f, -0.29501799f, -0.36212471f, 
    -0.11131927f, 0.04608675f, -0.26620552f, 0.01446288f, -0.06452311f, 0.08188652f, -0.36853966f, -0.54856199f, 
    -0.32697207f, 0.21316577f, 0.13137949f, -0.00698955f, 0.18775409f, 0.10998704f, 0.19720094f, -0.44519427f, 
    0.12902807f, 0.82747102f, -0.10295056f, 0.16345963f, -0.00236356f, 0.15285382f, 0.22474955f, 0.11361236f, 
    0.38255432f, 0.40559930f, -1.20548546f, 0.23099266f, 0.08536837f, -0.37344274f, 0.14423041f, 0.06224459f, 
    -0.07731921f, -0.36449739f, -0.76659900f, 0.46898165f, -0.13945943f, 0.07614154f, 0.10758270f, -0.25242585f, 
    0.10223670f, -0.13335168f, 0.40841621f, -0.58129120f, 0.23444654f, -0.09062674f, 0.16111533f, 0.06459169f, 
    0.25318974f, 0.14147353f, 0.13764441f, -0.38559216f, -0.24497436f, 0.05546238f, -0.00087080f, -0.02978983f, 
    -0.15249832f, -0.16277935f, -0.09925637f, 0.06557421f, -0.40116891f, -0.26221853f, 0.65974295f, 0.06542780f, 
    0.04386742f, 0.04222009f, 0.17962366f, -0.11346661f, 0.12333400f, 0.24094036f, -0.34247109f, -0.40222216f, 
    0.32708344f, 0.33596686f, 0.14027923f, 0.11937310f, -0.10220481f, 0.18952905f, 0.18966071f, 0.52562195f, 
    -0.35799652f, 0.04318821f, 0.14466055f, -0.19778460f, 0.23156682f, 0.30555707f, -0.00048393f, 0.07236750f, 
    0.17444178f, -0.60159808f, 0.01357224f, 0.03781956f, -0.01126359f, 0.08789819f, 0.27335212f, 0.31074077f, 
    -0.03374932f, -0.04256631f, -0.01489145f, 0.14379494f, 0.04648268f, 0.07894513f, -0.03635007f, -0.33354178f, 
    -0.04910440f, 0.08442191f, -0.19701523f, -0.03249271f, 0.14246289f, 0.05256194f, -0.01486721f, 0.01407659f, 
    0.16289116f, 0.05554592f, -0.29158714f, -0.04811588f, -0.02632124f, 0.21865849f, -0.01055287f, -0.63396555f, 
    0.32001695f, -0.17496578f, -0.18561558f, -0.06512663f, 0.23991930f, 0.06745467f, -0.00814655f, 0.33059111f, 
    -0.16151837f, -0.01691531f, 0.21677646f, 0.34585297f, -0.12921408f, -0.17965695f, 0.01232536f, -0.16593270f, 
    0.01117646f, 0.06989589f, 0.12114705f, -0.23016033f, -0.32609195f, 0.31777126f, 0.29648465f, 0.76437646f, 
    0.05668271f, 0.01492584f, -0.06333472f, 0.02908805f, 0.09851006f, -0.09045434f, -0.31702673f, -0.09346519f, 
    0.28927979f, -0.20654732f, -0.19388224f, -0.38430360f, -0.07905499f, -0.07612311f, 0.22343640f, -0.08691012f, 
    0.20329843f, 0.05745094f, 0.02962769f, -0.03945740f, -0.15063295f, 0.02193990f, 0.29274216f, 0.23148431f, 
    0.26414976f, 0.07818018f, 0.21486191f, 0.10629210f, -0.05850457f, 0.07857379f, -0.08261219f, -0.04307622f, 
    -0.32083690f, -0.67199862f, -0.22087799f, -0.09095747f, 0.14762326f, 0.11552470f, -0.00154385f, -0.19289435f, 
    0.14993750f, 0.04205938f, -0.24334089f, -0.06870118f, 0.23314707f, -0.26013067f, 0.14730443f, -0.18786104f, 
    0.11307942f, -0.04533040f, 0.30335087f, -0.22816280f, -0.09349483f, 0.00966415f, 0.03289851f, 0.00499046f, 
    -0.03423258f, -0.15466252f, 0.01950601f, 0.09301692f, -0.04985407f, 0.12427247f, 0.21391691f, 0.17622773f, 
    0.03670638f, 0.00705281f, 0.01654696f, -0.10591158f, -0.07146192f, 0.29780132f, 0.36839464f, 0.65934825f, 
    -0.31279761f, 0.11445025f, 0.51050097f, -0.07641953f, -0.08550363f, 0.20887779f, -0.10930470f, -0.37028143f, 
    -0.11266898f, -0.18396869f, 0.11730343f, -0.00330698f, 0.15872651f, -0.06104798f, 0.00967458f, -0.16648903f, 
    0.24950011f, -0.33893359f, -0.12653808f, 0.05823911f, 0.14153393f, -0.00238350f, -0.02947162f, -0.07388928f, 
    0.04205802f, 0.01944177f, -0.00958451f, 0.24859236f, 0.18207207f, 0.23867974f, -0.39830133f, -0.43979025f, 
    -0.37742245f, 0.48388138f, 0.01447085f, -0.22434160f, 0.27578458f, 0.30999643f, 0.16035177f, 0.00276409f, 
    0.20605358f, 0.07575969f, 0.42341968f, 0.16241489f, -0.20024288f, 0.19207141f, 0.12910068f, 0.11755674f, 
    0.25059906f, -0.10607772f, -0.23741589f, 0.13450043f, -0.24271311f, 0.07051612f, 0.28355947f, 0.01924512f, 
    0.23481606f, -0.19954930f, 0.03920840f, -0.52085137f, -0.06482510f, -0.03340251f, -0.48167655f, -0.09969456f, 
    -0.03900287f, 0.01482064f, 0.12316433f, 0.08374804f, -0.11775630f, 0.15652542f, 0.18285358f, 0.01146260f, 
    0.02328212f, -0.26832551f, 0.13293196f, -0.16283621f, -0.01956674f, -0.10127761f, 0.01096971f, -0.19041969f, 
    -0.29506773f, 0.15889876f, 0.10859106f, -0.19312072f, -0.17744765f, -0.02321245f, 0.05248941f, -0.02575983f, 
    0.03737905f, 0.21848162f, -0.03538349f, 0.19259650f, -0.03774658f, 0.06966231f, 0.19427474f, 0.20498668f, 
    -0.10940523f, 0.36679271f, -0.17823792f, 0.22244018f, -0.36348432f, -0.01721708f, -0.00117672f, -0.04942611f, 
    -0.17392655f, 0.09967262f, 0.05306505f, 0.15676077f, 0.24461375f, 0.10355504f, 0.04072420f, -0.02706322f, 
    0.07958695f, -0.03484252f, 0.36928272f, 0.00502425f, -0.20728746f, -0.04911954f, -0.00788013f, 0.05548099f, 
    -0.14883457f, -0.06224806f, 0.20473199f, 0.09502217f, 0.05584360f, -0.24212679f, 0.14626309f, 0.31593674f, 
    0.07866411f, -0.08957183f, -0.04327748f, -0.12818791f, 0.19361086f, -0.18742022f, 0.08243027f, 0.18663253f, 
    0.18832763f, 0.24367423f, -0.14320065f, -0.28478891f, -0.10905729f, 0.16743200f, 0.00055134f, -0.28688911f, 
    0.00417262f, -0.05059243f, -0.00929317f, 0.15867271f, -0.07374924f, 0.32860467f, -0.25881898f, -0.04738809f, 
    -0.16529585f, -0.06528708f, -0.05035465f, -0.02606715f, 0.02893222f, -0.28223819f, -0.12819272f, 0.25908774f, 
    -0.11043938f, -0.32524312f, -0.15317768f, 0.04677657f, 0.00162248f, 0.25846022f, 0.31123242f, 0.14266972f, 
    0.02463357f, -0.13561875f, -0.09221409f, 0.18795475f, -0.09604170f, 0.02260045f, 0.06636731f, -0.11822895f, 
    -0.15787134f, -0.02329879f, 0.31100982f, -0.30657342f, 0.03597260f, 0.20990601f, -0.02474047f, 0.26236677f, 
    0.33121035f, 0.08605002f, -0.14448403f, 0.12714809f, 0.22123294f, -0.00575271f, -0.15721884f, -0.17318800f, 
    -0.18073848f, -0.06140660f, -0.38875812f, 0.00065930f, 0.21128476f, 0.18382238f, 0.09571601f, 0.01510571f, 
    -0.00503663f, 0.33203453f, 0.54322815f, 0.11538286f, -0.18525498f, 0.23760937f, -0.22039631f, -0.05792610f, 
    0.22255433f, 0.03125118f, 0.03719001f, 0.01278642f, -0.04108329f, -0.14470750f, -0.13140774f, 0.40804595f, 
    0.00694352f, 0.15720500f, -0.08217815f, -0.20172162f, 0.01825286f, 0.02296998f, -0.11740882f, 0.22311971f, 
    0.40815881f, -0.01418932f, 0.10619643f, -0.01917675f, -0.06639919f, 0.05938494f, 0.19607250f, 0.04144026f, 
    0.23564810f, 0.50639576f, -0.10531798f, -0.14736302f, 0.27627212f, 0.17717434f, 0.09311414f, 0.08839944f, 
    0.18868272f, 0.22250432f, 0.38828474f, 0.21382271f, 0.15396948f, 0.14523131f, 0.02374357f, 0.01223638f, 
    -0.10505417f, -0.24772094f, 0.08847295f, 0.30858704f, 0.29753375f, 0.20388645f, 0.00636021f, 0.24085265f, 
    -0.01134105f, 0.07578967f, 0.18946120f, 0.39585584f, -0.15735207f, 0.06879628f, 0.14619340f, 0.02274983f, 
    0.15995894f, 0.12827492f, 0.51797706f, -0.48298422f, -0.06653573f, 0.31451666f, 0.17073174f, 0.17208713f, 
    -0.22259425f, 0.32846040f, -0.05681682f, 0.00725560f, 0.16663715f, 0.04101732f, 0.02813262f, -0.12417590f, 
    0.15826404f, 0.16465439f, -0.11698217f, 0.04649008f, 0.07155723f, 0.39838105f, -0.48603651f, 0.27569318f, 
    0.17395711f, 0.04423663f, 0.04859491f, 0.22355859f, -0.35542831f, 0.38150746f, 0.08314282f, 0.12731454f, 
    0.59618014f, -0.10424574f, 0.47956339f, -0.05272846f, 0.02899205f, 0.11616194f, 0.06684952f, 0.01442682f, 
    0.39562061f, -0.16922227f, 0.10048142f, 0.07345512f, -0.00095358f, 0.24679372f, -0.03054952f, -0.18436989f, 
    0.01783547f, 0.08505704f, -0.08456497f, -0.10223346f, -0.21931615f, 0.14353539f, 0.11275892f, 0.15285678f, 
    0.30348521f, 0.19365111f, 0.11423588f, 0.09434769f, -0.32365716f, -0.34635833f, 0.00540992f, 0.19948295f, 
    0.06616571f, 0.64361429f, -0.50065482f, -0.12705962f, 0.28066859f, -0.23360042f, 0.05659312f, 0.06993251f, 
    0.14349881f, -0.03090553f, -0.20901641f, 0.00960205f, 0.21283637f, -0.31463280f, -0.01959361f, -0.19503340f, 
    -0.39520738f, 0.08779672f, 0.11338939f, 0.01751585f, -0.10309135f, -0.14621983f, -0.11665651f, 0.02609811f, 
    0.07692306f, -0.14045656f, 0.27751479f, 0.07279466f, -0.05830233f, -0.30827063f, 0.49907771f, 0.18194796f, 
    -0.14696018f, -0.14926477f, -0.10380951f, 0.21282309f, -0.11179648f, 0.09121124f, -0.95173532f, -0.42014009f, 
    0.02361388f, 0.05249408f, 0.11150733f, -0.02699032f, -0.07832985f, -0.04890415f, -0.22273543f, -0.46707702f, 
    -0.80775589f, 0.26427719f, 0.10201372f, 0.40232083f, 0.36959577f, 0.08847015f, 0.03188572f, 0.04873946f, 
    -0.16406222f, 0.52105933f, 0.23563440f, -0.19093609f, 0.11944734f, 0.21780793f, 0.13353147f, -0.02355079f, 
    -0.31836072f, 0.47110042f, -0.56607789f, -0.72462821f, 0.00767168f, -0.21859285f, 0.32842696f, -0.00706000f, 
    -0.12895398f, 0.06434623f, -1.07068729f, 0.22329341f, -0.32286003f, 0.13427304f, -0.31896386f, 0.30853561f, 
    -0.05620190f, 0.41393518f, 0.06608645f, -0.13054135f, -0.95934421f, -1.37915754f, 0.01159102f, -0.10013770f, 
    -0.02163544f, 0.03781503f, -0.05276194f, -0.06060334f, 0.02110201f, 0.18967389f, -0.30765301f, 0.19103679f, 
    0.16190681f, 0.01259208f, 0.28405154f, 0.17164983f, 0.06776478f, -1.07038987f, -0.24594392f, -0.43439031f, 
    -0.22612925f, 0.28156334f, 0.23893671f, 0.09339178f, 0.23986134f, -0.01909580f, 0.12989450f, 0.23085959f, 
    -0.01297581f, -0.04765556f, 0.18168975f, 0.21661562f, 0.04203194f, 0.33870304f, -0.24007380f, -0.07757992f, 
    -0.00845942f, -0.09914936f, 0.21169552f, 0.15408780f, -0.21914382f, 0.15614136f, 0.22445497f, 0.14257078f, 
    -0.24142119f, -0.25444120f, -0.16949734f, 0.02924045f, 0.12649900f, 0.05181773f, 0.11791114f, 0.38279042f, 
    0.44167987f, -0.06457353f, -0.23640952f, -0.09107587f, -0.02257930f, 0.13797380f, -0.01439464f, -0.01025107f, 
    -0.58338296f, -0.62865812f, -0.24827754f, -0.08802821f, -0.34520066f, -0.25594318f, -0.14297312f, -0.02245368f, 
    0.27665389f, 0.28862485f, 0.11616235f, -0.15637791f, -0.16909660f, -0.16789883f, 0.04681605f, -0.10021655f, 
    0.21905367f, -0.04674324f, -0.07344279f, 0.27131140f, 0.10118285f, -0.12948610f, 0.01203226f, 0.02261912f, 
    0.04235193f, 0.10225184f, 0.00163310f, 0.28413913f, 0.50236082f, 0.06738105f, -0.27000719f, -0.19336227f, 
    0.12697114f, 0.04394679f, -0.03406129f, 0.20848443f, 0.09729529f, -0.23287891f, 0.04442587f, 0.04261959f, 
    0.26452479f, 0.20299740f, 0.19127189f, -0.00143709f, 0.18319996f, 0.24496552f, 0.10440505f, -0.14097126f, 
    -0.09063762f, -0.06217487f, 0.06522226f, 0.17813079f, -0.16650018f, -0.25114736f, -0.04747445f, 0.03790054f, 
    0.09330052f, -0.13062927f, -0.25391513f, -0.00793628f, 0.03624670f, 0.17011040f, 0.36890101f, 0.25118876f, 
    0.42355135f, -0.64087772f, -0.31704894f, 0.28657892f, 0.03337190f, -0.24841765f, -0.10322013f, -0.24544132f, 
    0.00728050f, -0.18407260f, -0.33614084f, -0.11709361f, 0.67515403f, 0.18219745f, -0.00473063f, 0.12028087f, 
    0.02890596f, -0.15818666f, -0.13326725f, -0.38009804f, -0.20530921f, 0.04550717f, 0.04068723f, -0.12148419f, 
    -0.03442909f, 0.31824118f, -0.09385625f, -0.19108160f, -0.14354260f, 0.13727248f, 0.06929851f, 0.30405423f, 
    0.16154619f, 0.25456256f, 0.40620318f, 0.35080582f, 0.24662779f, 0.08468776f, 0.40056762f, 0.41881266f, 
    0.12496316f, 0.00390393f, 0.19427426f, 0.08749691f, -0.15010966f, 0.14747290f, 0.61888325f, -0.01510435f, 
    0.05266872f, 0.09921444f, 0.23199502f, 0.27371067f, 0.27651155f, 0.08342054f, 0.15099418f, 0.05715647f, 
    -0.35123375f, 0.18514098f, 0.03010499f, -0.04491005f, -0.00013131f, 0.01269626f, 0.07539210f, 0.10163555f, 
    0.24880306f, 0.07895879f, 0.11282947f, 0.16545451f, 0.10355804f, -0.00529138f, -0.02072798f, -0.04687213f, 
    0.08730671f, -0.07798879f, 0.18525136f, -0.00287523f, -0.06318776f, -0.21414523f, 0.09870596f, -0.13357511f, 
    -0.27021417f, 0.05079464f, 0.12424941f, 0.05766567f, 0.14724809f, 0.02032222f, -0.05472975f, -0.08568675f, 
    -0.07536184f, -0.08466622f, -0.07411650f, 0.01560744f, 0.38791525f, -0.12655403f, -0.00198400f, 0.10159156f, 
    -0.31586900f, -0.15372880f, -0.18690559f, -0.24669218f, -0.00562888f, 0.34548190f, 0.33622134f, 0.07428394f, 
    0.11157791f, -0.04079559f, -0.01907865f, -0.01878130f, -0.03470297f, 0.08143687f, -0.22106953f, -0.53713799f, 
    0.06340162f, 0.09472226f, 0.14961934f, 0.19315146f, -0.00779620f, 0.12957942f, -0.11536732f, -0.21814665f, 
    0.01020023f, 0.11326480f, 0.05072151f, 0.08393088f, -0.01795092f, -0.17909873f, 0.24972121f, 0.14308484f, 
    -0.55941200f, -0.20952971f, 0.07072175f, -0.15431978f, 0.04304795f, 0.00197966f, -0.07462519f, -0.03423325f, 
    0.26741967f, -0.03932840f, 0.66863096f, 0.00883060f, 0.17078151f, 0.09775749f, -0.10050514f, 0.08746022f, 
    0.17878337f, -0.16371433f, -0.20079851f, -0.49718469f, 0.13871595f, 0.09184784f, -0.18225163f, 0.06147233f, 
    -0.08923305f, 0.14304928f, -0.59662795f, 0.21801159f, -0.34656104f, 0.09578258f, 0.13094629f, -0.09876343f, 
    0.13442582f, -0.12892658f, 0.11788123f, -0.01751692f, 0.19753799f, -0.07854825f, 0.19709305f, 0.02787836f, 
    -0.12314059f, 0.04543644f, -0.30801833f, 0.24293318f, -0.30521074f, 0.21658067f, -0.34305361f, 0.12544656f, 
    -0.13248096f, 0.10763823f, 0.25388211f, 0.09068986f, -0.32128209f, -0.14068037f, 0.41610578f, 0.24924506f, 
    0.12962048f, 0.03887350f, 0.06419482f, -0.04403590f, 0.36274797f, -0.22230366f, 0.77124971f, -0.22012036f, 
    0.76556486f, -0.24789217f, -0.10894527f, 0.33274418f, 0.10621940f, -0.03747120f, 0.13851012f, -0.37699768f, 
    0.61941367f, 0.09862106f, -0.01701603f, 0.04374402f, -0.02896855f, -0.17731713f, 0.01993594f, -0.10809298f, 
    0.34589934f, 0.15469570f, -0.33757225f, -0.05025525f, -0.00800935f, 0.04106950f, 0.14178611f, -0.06775010f, 
    0.19571649f, -0.39119893f, -0.28380117f, -0.25738022f, -0.37804344f, -0.17974527f, -0.10026371f, 0.11877365f, 
    -0.05557398f, -0.04809523f, 0.38888311f, 0.46605152f, 0.61598587f, -0.05186507f, 0.10783174f, -0.16392645f, 
    0.23524116f, 0.19882020f, 0.24167240f, 0.14822592f, -0.65721637f, -0.68076867f, 0.12183237f, -0.39527157f, 
    -0.00066405f, 0.17837930f, -0.24816447f, -0.19645171f, -0.38646364f, -1.21832418f, -0.95190132f, 0.04553961f, 
    -0.01901802f, 0.07420769f, 0.13132188f, 0.24456494f, 0.14854245f, 0.23163435f, 0.21654753f, 0.15294185f, 
    0.04218242f, 0.35353172f, -0.06403255f, -0.04953923f, -0.05212675f, 0.16723587f, 0.26913911f, 0.55732566f, 
    0.27241939f, 0.00685815f, 0.21046774f, -0.06488842f, 0.01605122f, -0.00333639f, -0.01024149f, 0.20424303f, 
    -0.14723401f, 0.37053666f, -0.01060806f, 0.01196721f, -0.12126583f, 0.22175460f, -0.05633627f, -0.00425901f, 
    -0.10824180f, 0.02205429f, -0.55093962f, -0.00824321f, -0.05594819f, -0.05199108f, 0.21071827f, 0.02798946f, 
    0.09062439f, 0.51243001f, -0.02909645f, 0.27413011f, -0.16270171f, 0.07776932f, -0.13395196f, 0.10331928f, 
    0.06148624f, -0.13665479f, -0.21483792f, -0.29151848f, 0.21189247f, -0.25827745f, -0.04654678f, 0.08873475f, 
    0.20341457f, -0.05976302f, -0.10718919f, 0.41151661f, 0.46119809f, 0.28670248f, -0.10578802f, 0.14491673f, 
    0.10303883f, 0.21880102f, -0.24983416f, -0.02981796f, -0.09522486f, 0.09442809f, 0.18270999f, -0.07329477f, 
    -0.11963516f, -0.22360833f, 0.14052419f, 0.19288728f, 0.34854317f, -0.32067868f, -0.11152176f, 0.00383130f, 
    -0.15877004f, -0.13607363f, 0.04721557f, 0.20855212f, 0.09706777f, -0.15178970f, -0.14445516f, 0.29781207f, 
    -0.05196514f, -0.09812459f, 0.28245586f, 0.08131407f, -0.07188258f, -0.27056125f, -0.04758645f, -0.62445545f, 
    -0.63717580f, -0.35898590f, -0.14454998f, -0.06034719f, -0.10241093f, 0.07278091f, -0.20047420f, -0.09232917f, 
    0.04066756f, -0.06537127f, 0.00979742f, 0.02090679f, -0.01556468f, 0.00691374f, -0.00848581f, 0.00849839f, 
    0.05503967f, 0.05722399f, -0.02881989f, -0.08028767f, -0.02065894f, 0.07429904f, -0.06434878f, -0.04585719f, 
    -0.01033580f, -0.04765833f, 0.05582621f, 0.05663582f, -0.01744055f, -0.01215261f, 0.01962578f, 0.01466232f, 
    -0.05337440f, 0.05495944f, 0.00561424f, 0.04905098f, -0.00126120f, -0.06302037f, 0.04390902f, 0.00974205f, 
    -0.05743802f, 0.01443636f, -0.08451722f, 0.03584956f, -0.05595255f, -0.06675896f, -0.00808508f, -0.03872126f, 
    -0.01771675f, -0.00515760f, -0.05413318f, 0.04694943f, 0.01577187f, -0.04186481f, 0.06486176f, -0.03255734f, 
    -0.04151122f, -0.05146331f, -0.07319012f, -0.01040460f, -0.07643338f, -0.01696010f, 0.02282707f, 0.00040811f, 
    -0.08832566f, 0.04678975f, -0.01212309f, -0.05548334f, -0.07420100f, -0.03627474f, 0.00484755f, -0.02338793f, 
    -0.00275651f, -0.06938314f, -0.00331269f, 0.03860546f, 0.06628849f, 0.03681722f, 0.00729924f, -0.01493238f, 
    0.01012949f, 0.06291717f, 0.00133742f, 0.02642933f, 0.07239383f, -0.06879549f, -0.05507378f, -0.07458594f, 
    -0.02636315f, 0.06614888f, -0.08262152f, 0.02871189f, -0.04694496f, -0.03251158f, -0.00348107f, -0.02636405f, 
    0.07894647f, 0.08307900f, -0.08013482f, 0.00736573f, 0.05228681f, -0.04621721f, -0.06622630f, -0.01669980f, 
    -0.07449844f, -0.00087211f, -0.08208976f, -0.03616926f, 0.02589395f, -0.05527480f, 0.04734340f, -0.04796246f, 
    0.03401306f, 0.06083388f, 0.01212502f, -0.00219516f, -0.01767914f, -0.01169537f, -0.05350694f, -0.05146181f, 
    -0.01797164f, -0.03704296f, -0.01023937f, -0.08857518f, -0.08800365f, 0.03910853f, -0.00329617f, 0.01081729f, 
    -0.08604905f, 0.02763896f, 0.02569423f, 0.03960974f, 0.02935597f, -0.07574185f, 0.02038451f, -0.06882664f, 
    -0.05772378f, -0.07129706f, -0.05417790f, 0.03349269f, -0.06005748f, 0.05062401f, -0.04319495f, 0.04117161f, 
    0.00274388f, 0.00366860f, 0.06754263f, -0.03740771f, 0.05248103f, -0.00005837f, 0.06765678f, 0.03873073f, 
    0.29290435f, -0.05560889f, 0.17500393f, 0.35186607f, 0.10197800f, 0.01707627f, 0.24189834f, -0.03613581f, 
    -0.29305547f, 0.31379572f, 0.72549492f, 0.12024646f, -0.00746993f, 0.10307769f, 0.08576220f, -0.04495081f, 
    0.01752529f, 0.17130604f, 0.01006908f, 0.37681064f, 0.33979073f, 0.15946700f, -0.29812351f, -0.10924388f, 
    0.06534322f, -0.19358772f, -0.00567100f, 0.04131051f, -0.12752397f, -0.02920703f, 0.02231206f, 0.09989389f, 
    -0.02345307f, 0.04821967f, 0.14085057f, 0.33211365f, -0.18213214f, -0.42057294f, -0.10179252f, 0.18944095f, 
    0.16713679f, 0.29425293f, 0.13960581f, 0.09485002f, -0.09055059f, 0.10888944f, 0.23466739f, -0.58881342f, 
    -0.01367533f, -0.19903941f, -0.13288717f, 0.08441945f, 0.03768391f, -0.01151170f, -0.22340995f, -0.11876120f, 
    -0.26641884f, 0.15866260f, 0.37905908f, 0.06679446f, 0.01493644f, -0.08978927f, -0.00637139f, 0.31513330f, 
    0.39517900f, 0.56034225f, -0.13544884f, -0.26542252f, -0.62991470f, 0.11050089f, 0.07299691f, 0.19786936f, 
    0.30762824f, 0.55671930f, 0.05678122f, 0.12565349f, -0.24582753f, -0.15888776f, 0.03748022f, -0.12135040f, 
    -0.46396846f, 0.08040789f, 0.10651810f, 0.43824974f, 0.04498365f, 0.12126449f, 0.03889315f, 0.04409238f, 
    -0.10850015f, -0.14555143f, -0.54008883f, -0.63364756f, -0.06818475f, -0.87261063f, 0.06938760f, -0.04165506f, 
    0.05059989f, 0.18712401f, 0.12845737f, -0.01507904f, -0.25400051f, 0.29289261f, -0.45424137f, -0.10644961f, 
    -0.24515095f, 0.12291133f, 0.03482813f, 0.19216630f, 0.15797566f, -0.44859365f, 0.01332899f, 0.00196372f, 
    0.17210117f, -0.08108853f, 0.25027615f, 0.00178490f, -0.28424597f, -0.71437454f, -0.25179195f, -0.98753190f, 
    -0.02386845f, 0.04257644f, -0.04701232f, 0.14552833f, 0.07378101f, -0.20888306f, -0.30610588f, 0.32630175f, 
    -0.27827415f, 0.04487997f, -0.49299777f, -0.19772701f, 0.16482250f, 0.27995664f, 0.09464893f, -0.14956675f, 
    -0.08820742f, -0.74538577f, 0.03906595f, 0.06828637f, 0.01330066f, 0.11776439f, 0.29408643f, 0.20289667f, 
    0.25257024f, 0.07516972f, 0.07233541f, 0.20890719f, 0.01087174f, 0.12677620f, -0.03665296f, -0.30115861f, 
    0.05848840f, 0.05834185f, 0.20782229f, 0.16541860f, 0.02449163f, -0.02060353f, -0.34173188f, -0.23839329f, 
    -0.21965159f, 0.02994266f, -0.64124852f, -0.35394272f, -0.24454296f, 0.03684238f, -0.02070952f, -0.01098001f, 
    -0.05452920f, -0.28407791f, -0.04378318f, 0.29527482f, 0.16081347f, 0.19956121f, -0.22083336f, -0.07000604f, 
    -0.24631961f, -0.35658795f, -0.08129160f, -0.02540427f, 0.57587397f, 0.29375744f, 0.08891753f, -0.37265986f, 
    0.11511675f, -0.00447061f, 0.18249413f, 0.13380496f, 0.17738321f, -0.63801432f, -0.53140193f, 0.26077339f, 
    0.00556064f, 0.08661473f, -0.25537980f, 0.22829002f, 0.10606217f, -0.01732869f, -0.39138305f, -0.32125765f, 
    0.15457347f, 0.21896648f, 0.00174445f, -0.06157241f, 0.08364064f, 0.05923386f, 0.08358298f, -0.66366148f, 
    -0.62838632f, -1.06577349f, -0.28136319f, -0.30958274f, -0.08885020f, -0.12975930f, -0.00111708f, 0.24881166f, 
    0.19870289f, -0.13043259f, -0.07699262f, 0.47379586f, 0.11035269f, 0.16022778f, 0.18507747f, -0.10232279f, 
    0.16156641f, -0.03988428f, -0.29846853f, -1.12536156f, -0.26948830f, -0.14474726f, -0.13994925f, -0.05794703f, 
    0.05087006f, -0.01029773f, 0.19850652f, -0.52636099f, 0.56271577f, -0.00151428f, -0.05105030f, -0.04016832f, 
    0.08613154f, 0.15006994f, -0.12185316f, 0.20798139f, 0.13893503f, -0.68262267f, 0.03013925f, -0.18896407f, 
    -0.09143867f, -0.20151684f, 0.00010388f, 0.11133286f, 0.09590067f, 0.18237326f, 0.13889425f, -0.00554054f, 
    0.06592681f, 0.07686500f, 0.27123159f, -0.13880301f, -0.04078544f, -0.50003630f, -0.76038003f, -0.32164523f, 
    -0.04977635f, 0.11614158f, 0.37158605f, -0.03614793f, 0.18809572f, 0.05525463f, 0.71471983f, 0.89539737f, 
    0.45603079f, 0.15907358f, -0.10495351f, 0.31210393f, 0.10983645f, 0.25555497f, -0.12531550f, 0.12227055f, 
    0.29897070f, 0.17210042f, -0.09805934f, 0.22030289f, -0.14740548f, 0.06579016f, 0.13962862f, 0.19606397f, 
    -0.33477968f, -0.03493047f, 0.14651343f, -0.02149083f, -0.19732417f, 0.21680224f, 0.05371889f, -0.00319046f, 
    -0.00236893f, -0.04422922f, 0.37278953f, 0.20789860f, -0.19753909f, -0.17633586f, -0.40531439f, 0.04173450f, 
    -0.11511676f, -0.06574614f, 0.52465558f, -0.20217653f, -0.00028391f, -0.00982491f, 0.05497476f, 0.07616666f, 
    0.05993226f, -0.11147236f, 0.11475617f, 0.01377167f, 0.47169805f, 0.33834952f, -0.17056015f, 0.10063982f, 
    -0.33147269f, -0.00761944f, 0.07913318f, 0.09378286f, -0.88977474f, -0.02812073f, -0.09338876f, -0.12114131f, 
    0.13565278f, 0.18514246f, 0.05281675f, 0.19150592f, 0.05873215f, -0.23974477f, -0.20395842f, 0.62035078f, 
    -0.24853399f, -0.28761688f, -0.12905142f, 0.13197750f, 0.15156144f, 0.05807886f, 0.11354265f, 0.13523728f, 
    0.26535264f, -0.11374940f, -0.08336109f, -0.22282548f, -0.00680973f, -0.15806183f, 0.00096373f, 0.16275041f, 
    0.18062611f, 0.27446866f, -0.07529318f, -0.18208709f, -0.20535102f, 0.21943557f, 0.03366613f, -0.08931506f, 
    -0.02522061f, -0.36221611f, 0.51103139f, -0.14813399f, -0.06688088f, 0.30332059f, -0.09943194f, 0.05107391f, 
    0.19295594f, 0.23671314f, -0.24123892f, 0.12907442f, -0.00482365f, 0.00427242f, -0.02155001f, 0.16340314f, 
    0.00475982f, 0.10197987f, 1.22796440f, 0.11983934f, 0.01880636f, -0.05542220f, 0.14501673f, -0.17364462f, 
    0.08008758f, 0.18939814f, 0.06434864f, 0.06412347f, -0.50287765f, 0.31066298f, 0.03355402f, -0.05891297f, 
    -0.22308923f, 0.08181960f, 0.06858834f, -0.16448987f, 0.04734479f, 0.07006009f, 0.20381865f, -0.14421821f, 
    0.04716697f, -0.41122925f, 0.08209414f, -0.00301607f, 0.18285359f, -0.05727433f, 0.06501894f, -0.38238502f, 
    -0.02760261f, 0.41998121f, -0.02735719f, 0.00265946f, -0.01056158f, -0.25430188f, -0.33152580f, -0.18879084f, 
    0.09071059f, -0.36877730f, 0.05442412f, 0.03992360f, -0.24612948f, -0.05526857f, 0.08605868f, -0.17448626f, 
    0.09148980f, -0.58492565f, 0.00140537f, -0.00383511f, -0.07818316f, -0.05243029f, -0.03475600f, 0.16107818f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.18904629f, 0.10422496f, 0.01344784f, -0.16621047f, 0.44483930f, -0.17949916f, -0.27600092f, 0.35579124f, 
    0.03489486f, 0.42179099f, 0.00236206f, 0.07052552f, 0.03153721f, 0.29288700f, 0.32711068f, -0.23056695f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.39669517f, -0.19024539f, 0.31558675f, 0.70040220f, -0.07884086f, -0.59565741f, 0.36055019f, -0.50401026f, 
    0.05092702f, -0.48863360f, 0.08892205f, 0.28140196f, -0.22132970f, 0.02753936f, -0.02264712f, 0.13680108f, 
    0.02174396f, -0.89168233f, -0.11301549f, 0.17521976f, -0.17949949f, -0.84001428f, -0.25169066f, 0.10694885f, 
    -0.45683193f, 0.31229457f, 0.14087942f, 0.33772293f, -0.24995951f, -0.31466413f, 0.52830917f, -0.21017571f, 
    -0.39865857f, -0.39051604f, 0.11837950f, -0.44938341f, 0.74762440f, 0.16173364f, 0.31654149f, 0.19959566f, 
    -0.70451522f, 0.28108686f, -0.80050576f, -0.52790099f, -0.12832195f, 0.09419709f, -0.45901167f, 0.36312789f, 
    0.17263307f, 0.33347154f, -0.02898296f, -0.14092560f, -0.92040527f, 0.04836753f, 0.37864932f, 0.21962108f, 
    -0.47291440f, -0.45534363f, -0.64785439f, -0.29449677f, 0.10319473f, 0.09837338f, -0.67432833f, 0.94484103f, 
    -0.45603365f, 0.26501161f, -0.08350869f, -0.03626597f, -1.01031172f, 0.22386000f, 0.02041390f, -0.10982814f, 
    -0.01916812f, -0.13604684f, 0.21893224f, 0.67267877f, -0.03291389f, 0.43514180f, -0.08988354f, -0.26474437f, 
    0.12908845f, -0.58196396f, 0.39639440f, 0.32839185f, -0.29377311f, 0.12185729f, -0.22245836f, -0.13278188f, 
    -0.37102181f, 0.48579597f, 0.13341771f, 0.11269327f, -0.02334747f, -0.13099200f, -0.03204580f, -0.75543404f, 
    -0.50036234f, 0.35137078f, 0.10580908f, -0.61657763f, 1.06788266f, 0.57205957f, 0.08841639f, -0.22917740f, 
    0.10724322f, 0.05317637f, -0.17169444f, -1.36405897f, 0.13398969f, 0.26010683f, -0.22898223f, -0.47902945f, 
    -0.26037741f, 0.18826722f, 0.11697723f, -0.30801481f, -0.41419512f, 0.28668499f, 0.01058791f, -0.31770864f, 
    0.71332884f, -0.05245053f, 0.16929881f, 0.05688836f, -0.05280981f, -0.53948289f, 0.35057533f, 0.56606871f, 
    0.64364988f, 0.60173053f, -0.97027063f, -0.12297267f, 0.25026456f, -0.47564313f, -0.50044554f, -0.13868172f, 
    0.05876727f, 0.39331847f, -0.08642980f, 0.09908631f, -0.08944836f, -0.40150964f, 0.06438225f, -0.35943756f, 
    -0.34064159f, 0.54156595f, 0.51816708f, -0.61021703f, -0.24771924f, -0.14384770f, -0.19523811f, 0.11101049f, 
    0.34289396f, -0.20502068f, 0.29157287f, 0.07887723f, -0.14022426f, 0.69866097f, -0.77927339f, -0.65318483f, 
    -0.08831752f, -0.75351173f, -0.54512113f, 0.52892202f, -0.11562208f, 0.40988573f, -0.91845715f, -0.13011514f, 
    -0.60356367f, 0.36097151f, 0.69628209f, -0.50242680f, -0.04260588f, -0.56236750f, -0.29802647f, 0.98834378f, 
    -0.41264984f, 0.24185210f, -0.95382392f, -0.12201112f, -0.42273444f, 0.45609748f, -0.50366718f, 0.57905287f, 
    -0.23497814f, 0.02523442f, 0.24564403f, -0.77318972f, 0.03269929f, -0.38580611f, 0.02573545f, -0.45808333f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.30423704f, 0.61310369f, 0.21976627f, 0.21444888f, 0.07902884f, 0.02158843f, -0.31813231f, -0.42812786f, 
    -0.00342929f, 0.11239146f, -0.14380355f, -0.07094126f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
