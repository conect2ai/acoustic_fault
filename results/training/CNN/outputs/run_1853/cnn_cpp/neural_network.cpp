#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.43498921f, 0.13762976f, 0.50136054f, 0.20479560f, 0.32424819f, -0.48024866f, -0.22232313f, -0.14802207f, 
    -0.39350992f, 0.47016871f, -0.63773525f, -0.12238232f, -0.23948365f, -0.02371029f, -0.39667326f, -0.13589244f, 
    -0.26090851f, 0.55321777f, -0.74614722f, -0.40368238f, -0.15585804f, 0.65374398f, -0.27076602f, 0.13581699f, 
    0.06268251f, -0.09211183f, 0.27155092f, 0.01578213f, -0.01532503f, -0.19188595f, -0.13957737f, -0.39602679f, 
    -0.12968646f, 0.06620622f, 0.54380441f, 0.55303228f, -0.14818054f, 0.58414018f, 0.54944420f, -0.01697981f, 
    -0.31402588f, 0.30128351f, -0.33233866f, -0.20919983f, -0.22444843f, -0.51987463f, -0.37237799f, 0.52147585f, 
    -0.28256840f, -0.29818872f, -0.33744273f, -0.15988757f, -0.10184602f, -0.38508919f, 0.50888038f, -0.48359624f, 
    0.13738789f, 0.06598724f, 0.17859398f, 0.55586690f, 0.23671468f, 0.30071467f, 0.14656892f, 0.12053623f, 
    0.68007219f, -0.15264754f, -0.47143719f, -0.37468591f, 0.02905008f, 0.03290758f, -0.00321540f, -0.31800690f, 
    -0.06324589f, 0.02849990f, -0.34310761f, -0.31768030f, -0.35273370f, -0.46791318f, -0.11432038f, 0.13730413f, 
    -0.14417611f, 0.71376413f, 0.40135074f, 0.59716326f, -0.40144923f, -0.05110176f, -0.20496145f, -0.08960332f, 
    0.12719072f, 0.30443886f, -0.48595625f, -0.29312018f, -0.33913472f, 0.35355625f, -0.07224188f, -0.32953590f, 
    0.50836682f, -0.00799193f, -0.03084946f, 0.04613287f, 0.10462277f, -0.00125383f, -0.56420225f, -0.05782276f, 
    -0.52418828f, 0.65988809f, -0.05109235f, 0.14814301f, -0.23183957f, 0.17191158f, 0.75547534f, 0.26596916f, 
    -0.22548586f, -0.13713488f, 0.18724236f, -0.18214600f, -0.20551114f, 0.25511450f, -0.31787270f, 0.09341218f, 
    -0.25796413f, -0.12896301f, 0.10094263f, -0.38174027f, 0.62187582f, -0.48239857f, -0.06486204f, -0.20722231f, 
    -0.52152985f, -0.05189583f, 0.10677429f, 0.69749290f, -0.20739354f, -0.27309245f, -0.19057205f, -0.11368851f, 
    -0.11091492f, 0.15184501f, 1.02446902f, -0.51965237f, -0.02767734f, -0.15450232f, 0.29649067f, 0.20546162f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.06542332f, -0.23780856f, -0.28695217f, -0.32970619f, -0.10519708f, -0.23313382f, 0.29835537f, 0.02883128f, 
    0.34967050f, 0.26188168f, 0.32996067f, -0.03197168f, 0.35707232f, 0.00753836f, 0.01070294f, -0.11276512f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.25394854f, -0.02805386f, 0.22126621f, 0.00961220f, 0.05780638f, 0.03718859f, 0.10912100f, -0.12220818f, 
    -0.08203230f, 0.24336416f, -0.04922812f, -0.09865130f, -0.15478133f, 0.06670769f, -0.10857695f, -0.08023480f, 
    -0.02131889f, -0.06078348f, -0.56053811f, -0.13689050f, -0.10531159f, 0.14944512f, -0.06022163f, -0.18198434f, 
    0.14060809f, 0.02828768f, -0.09313948f, 0.14586170f, 0.37182069f, 0.23229736f, -0.05880601f, 0.09993108f, 
    -0.02647108f, 0.06114082f, -0.01721363f, -0.09727838f, -0.03627383f, -0.18904231f, -0.03494655f, 0.01135820f, 
    0.03918643f, -0.00288915f, -0.03956556f, 0.01190374f, -0.05402688f, -0.21710305f, -0.33634758f, 0.43287325f, 
    0.08454356f, -0.06093948f, -0.03901199f, -0.03170078f, 0.21015970f, -0.03793559f, 0.09773268f, -0.14355440f, 
    -0.53981900f, 0.12626027f, 0.00673999f, -0.04824435f, 0.03213716f, 0.10007558f, 0.14716916f, 0.26175946f, 
    0.20678042f, -0.00397605f, -0.21964343f, 0.04088338f, -0.06444383f, 0.01863067f, 0.02661085f, -0.13837238f, 
    0.02678718f, 0.11038908f, 0.31989700f, 0.12424441f, 0.10736977f, 0.23108959f, 0.02642732f, 0.05784950f, 
    -0.01964299f, 0.02457377f, -0.24413271f, -0.34351754f, -0.05567235f, 0.05149566f, -0.03534690f, 0.13317926f, 
    -0.06249065f, 0.19678430f, 0.08325123f, 0.14793791f, 0.13917682f, 0.11314745f, 0.06504674f, 0.05379231f, 
    0.07979768f, -0.15488355f, 0.03737398f, 0.06967055f, -0.12465587f, 0.15902475f, -0.10324185f, -0.04248958f, 
    0.02015479f, -0.15139543f, -0.09648219f, -0.07636355f, -0.11931652f, -0.15926728f, 0.08400504f, -0.07973118f, 
    -0.12351236f, 0.21252656f, 0.06556240f, -0.01595079f, 0.06810395f, 0.00649492f, -0.13486432f, 0.04472104f, 
    0.15646365f, 0.09354678f, -0.00419385f, 0.13711704f, -0.22601166f, 0.11460795f, -0.07579557f, -0.19804743f, 
    -0.25205743f, 0.13368328f, -0.01112755f, 0.03582728f, 0.01918353f, 0.26869467f, -0.14287512f, -0.46830299f, 
    -0.24239773f, -0.20480907f, -0.09733944f, 0.11415558f, -0.05936354f, 0.08382932f, -0.06122259f, 0.02874455f, 
    0.02975313f, -0.08344913f, -0.02776100f, 0.02599190f, 0.03990040f, -0.00216025f, -0.07621823f, -0.09150463f, 
    -0.06362615f, -0.05872782f, 0.07183824f, 0.05331540f, 0.03984234f, -0.03058901f, -0.07986963f, -0.01588976f, 
    -0.03821029f, 0.01557281f, -0.01074094f, -0.05734402f, 0.04004983f, -0.01112858f, -0.07590682f, 0.06392989f, 
    -0.07443646f, -0.06018172f, -0.00847920f, 0.02101017f, -0.00338456f, 0.05916701f, 0.02414003f, 0.07106850f, 
    0.05863484f, -0.01411441f, 0.04090956f, -0.03386611f, -0.07902657f, -0.08603203f, -0.02225538f, -0.02554062f, 
    -0.04080259f, 0.04613378f, 0.04620201f, 0.03433568f, 0.07432444f, -0.03271687f, -0.07675314f, 0.04747782f, 
    -0.02741974f, 0.03396211f, 0.04255716f, -0.06661612f, -0.04713442f, 0.02916040f, -0.06512854f, 0.03931054f, 
    -0.08020801f, 0.03390847f, -0.08645970f, -0.01466839f, -0.04885362f, -0.06225708f, 0.03706913f, -0.00292243f, 
    -0.03626106f, 0.02912922f, -0.05536024f, 0.01265953f, -0.03950956f, -0.08003565f, -0.05602331f, -0.03977303f, 
    -0.03096692f, -0.04461686f, -0.01475606f, 0.06698048f, -0.07199357f, -0.03014601f, -0.06771646f, 0.06732763f, 
    0.01138407f, 0.06808916f, -0.07834152f, -0.02385562f, -0.05713843f, -0.06012067f, -0.04833903f, -0.02280825f, 
    0.02221445f, 0.00413081f, 0.00870437f, -0.00723931f, 0.06177062f, 0.05584012f, -0.08267262f, -0.05757109f, 
    -0.01706353f, -0.04164640f, -0.01782387f, 0.04374176f, 0.01022384f, -0.03465395f, -0.08582194f, 0.02057806f, 
    -0.02202989f, -0.00353674f, -0.05740260f, 0.07076023f, 0.01638935f, 0.03206725f, -0.04209475f, -0.04401189f, 
    0.00777378f, -0.03487423f, -0.00188208f, -0.08126021f, 0.05049917f, 0.04440425f, -0.05945680f, 0.03749664f, 
    0.03745254f, -0.04074096f, 0.01971280f, 0.01430573f, 0.03560226f, -0.00849465f, 0.04578298f, -0.05853265f, 
    -0.05339631f, -0.03299471f, -0.04444345f, 0.03887070f, 0.07283531f, 0.03909996f, 0.07449660f, -0.03118990f, 
    0.07522207f, -0.04014515f, -0.07228494f, 0.01002041f, 0.04216303f, 0.01822744f, 0.03255980f, -0.06621732f, 
    -0.00630672f, 0.15888716f, -0.28528866f, -0.06411334f, -0.08542745f, 0.05083127f, 0.11095326f, 0.05083686f, 
    0.14693484f, 0.16121772f, -0.02189752f, -0.06580489f, 0.07721988f, 0.09943945f, -0.15150209f, -0.04407350f, 
    -0.08997308f, -0.26276729f, 0.02056902f, 0.04838470f, -0.26425883f, 0.17523296f, -0.20347947f, 0.24027805f, 
    -0.03209158f, 0.17767701f, 0.06356160f, 0.06878433f, -0.05917649f, 0.25442159f, -0.14332768f, 0.00252345f, 
    0.03349722f, 0.09407943f, -0.05139978f, 0.01643242f, 0.25914568f, 0.09164307f, 0.25804824f, 0.03242673f, 
    -0.05975023f, -0.03153725f, 0.15407510f, 0.09278631f, 0.12142414f, 0.14252366f, 0.06792183f, -0.10068677f, 
    0.21751119f, -0.16786723f, 0.16590379f, 0.07121842f, -0.19941418f, 0.03107589f, -0.04916282f, -0.02989007f, 
    -0.24565001f, 0.08722297f, 0.10896406f, 0.01486261f, -0.07021327f, -0.12321826f, -0.26005369f, 0.24132636f, 
    0.05482730f, 0.21416594f, -0.08212879f, 0.08099343f, -0.14912263f, 0.08143390f, 0.00782630f, 0.09179260f, 
    -0.05329139f, -0.23753065f, -0.05226299f, 0.07780124f, 0.00879284f, -0.02794956f, 0.04096307f, -0.01912903f, 
    0.12453607f, 0.38482848f, 0.24659096f, 0.04143132f, 0.05765240f, -0.00939809f, -0.07288025f, 0.02287573f, 
    -0.11713596f, -0.11444575f, -0.12859534f, -0.07692236f, -0.10867118f, 0.03508284f, -0.12412774f, -0.00722528f, 
    0.00709314f, -0.15881488f, 0.03028121f, -0.16795853f, -0.14807869f, 0.21281952f, 0.09139901f, 0.20274808f, 
    0.02817416f, 0.01582207f, 0.06513207f, -0.13041088f, 0.00514919f, 0.36821494f, -0.04338833f, 0.01093523f, 
    0.08977263f, -0.06932127f, -0.00333933f, -0.10216912f, -0.08542692f, 0.14827067f, 0.00489357f, -0.13160443f, 
    -0.01591623f, 0.10917150f, 0.00313092f, 0.04141723f, -0.09942778f, -0.00276612f, 0.00462699f, -0.21167737f, 
    -0.02638010f, -0.14355311f, -0.04140562f, 0.11450209f, -0.03830981f, 0.08091211f, 0.11738842f, 0.00904415f, 
    0.27574220f, -0.09421938f, 0.13154840f, -0.00507141f, 0.09109164f, 0.09478331f, 0.04221515f, -0.26695901f, 
    0.47675210f, 0.35088974f, -0.04705109f, 0.01226765f, 0.06832802f, -0.10333177f, 0.04272493f, -0.09595200f, 
    0.02427240f, -0.06553518f, 0.19665501f, -0.03174520f, 0.00680815f, -0.04632144f, 0.01449845f, 0.03087214f, 
    -0.13138284f, -0.02560391f, 0.13752846f, -0.06981405f, -0.13422513f, 0.01472515f, -0.01009977f, -0.11868805f, 
    -0.13037694f, 0.07784788f, 0.02785897f, -0.01189410f, 0.15816180f, 0.10712417f, 0.01767522f, -0.18416311f, 
    0.23995717f, -0.09471055f, -0.15808652f, 0.03440268f, -0.16374943f, -0.14204462f, -0.13884452f, 0.08383323f, 
    0.18597722f, -0.14241877f, -0.16255681f, 0.01869740f, -0.09330557f, 0.42850822f, 0.26330343f, -0.08461835f, 
    0.11773484f, -0.08874963f, -0.06716590f, -0.08653478f, -0.04896795f, -0.18289009f, -0.00204324f, -0.08695525f, 
    -0.07606453f, 0.04139827f, -0.11257142f, 0.06502888f, -0.05407250f, 0.09659413f, 0.09320617f, -0.10242458f, 
    -0.05333201f, 0.35047159f, -0.19775788f, -0.17251632f, -0.14056571f, 0.13621445f, -0.10161518f, 0.15739562f, 
    0.01558383f, 0.13076431f, -0.12277749f, 0.14492358f, -0.02289576f, -0.02804518f, -0.03665492f, -0.06362539f, 
    -0.01149281f, -0.51075137f, -0.29417059f, 0.03497407f, -0.11555197f, -0.01166424f, 0.00939364f, 0.04647223f, 
    0.06865686f, -0.01435960f, 0.06627303f, -0.07491451f, -0.18966509f, 0.01796501f, 0.16128011f, 0.08566214f, 
    -0.06409070f, 0.10692319f, 0.07116654f, 0.25766993f, 0.33840543f, -0.10335039f, -0.12536083f, -0.10571300f, 
    -0.05090490f, 0.07782579f, -0.14924093f, 0.13846208f, -0.20975301f, 0.17242953f, 0.16750851f, -0.06721579f, 
    0.07119788f, 0.24988255f, -0.02613179f, 0.07562023f, 0.03696015f, -0.07040553f, -0.17814022f, 0.07923681f, 
    -0.01279043f, 0.06910317f, 0.06424115f, 0.13733363f, 0.06687497f, 0.20091157f, 0.19299756f, 0.10607395f, 
    -0.02457731f, 0.04313792f, 0.06837627f, 0.02788779f, 0.15781204f, 0.06185994f, -0.17270692f, 0.09738873f, 
    -0.32264680f, -0.34252682f, -0.08067352f, -0.05525831f, -0.01517362f, -0.02200648f, 0.02705539f, 0.11338992f, 
    -0.13837245f, 0.05738675f, -0.09085515f, 0.06099302f, 0.00006032f, 0.13218534f, -0.02844778f, 0.03453612f, 
    0.06781700f, -0.12238835f, -0.06431425f, -0.21639439f, 0.06153815f, 0.09020472f, -0.04862538f, 0.03548709f, 
    -0.07702714f, -0.04165238f, 0.00574202f, -0.35165319f, -0.03803248f, -0.03534961f, -0.12774554f, 0.00394855f, 
    -0.21244022f, -0.10530921f, -0.00492910f, -0.11184947f, -0.10251020f, -0.29936409f, -0.02276671f, -0.06368035f, 
    -0.09551688f, 0.25238284f, 0.02898821f, -0.09970475f, 0.29072994f, -0.22512951f, 0.21270020f, -0.09907883f, 
    -0.02237180f, 0.07298006f, -0.12321266f, 0.01490892f, -0.08556994f, 0.03891024f, 0.00643760f, -0.23698351f, 
    -0.11908422f, -0.08949472f, 0.08465828f, 0.00472119f, 0.04878836f, 0.25201133f, -0.17903996f, -0.01573247f, 
    -0.08227077f, -0.08127867f, 0.14380091f, 0.00765663f, 0.11529630f, 0.13607834f, 0.17540634f, 0.25678265f, 
    -0.24891078f, -0.07889507f, -0.09033669f, -0.15540761f, -0.09940983f, -0.08932221f, -0.05923127f, 0.10261137f, 
    0.00471827f, -0.07324512f, -0.10785870f, -0.00211267f, -0.09324562f, -0.14261663f, 0.09338021f, -0.09077190f, 
    0.10178198f, 0.44200817f, 0.31669298f, 0.24137741f, -0.01742490f, 0.16400898f, 0.06051522f, -0.01599981f, 
    0.27934942f, 0.00462311f, -0.03286246f, -0.14648281f, 0.00778819f, -0.09241796f, 0.17138453f, 0.07268252f, 
    0.00362140f, 0.04368385f, 0.15199137f, -0.08027511f, -0.22779389f, -0.23840004f, -0.03721603f, -0.03959042f, 
    -0.16875999f, -0.03784114f, 0.09712900f, 0.01539772f, 0.11046974f, 0.02032948f, 0.12089927f, 0.05666335f, 
    -0.01682259f, 0.08935084f, 0.13658856f, 0.06705907f, 0.10687103f, 0.13880476f, -0.12045939f, -0.03859525f, 
    0.12919737f, -0.07758631f, -0.05054462f, 0.06935653f, -0.10199478f, 0.01092507f, -0.01212783f, -0.32540652f, 
    0.11088916f, -0.00629562f, 0.16023554f, -0.03279673f, -0.08991179f, -0.08894997f, 0.04480813f, -0.34084216f, 
    -0.36094141f, -0.25742194f, -0.04090375f, 0.12420696f, -0.03964713f, 0.03647271f, -0.16689508f, -0.18631844f, 
    0.14267930f, -0.03188485f, -0.11980122f, -0.09907440f, -0.01046196f, -0.03640400f, 0.06147046f, -0.07812896f, 
    0.18039455f, -0.54044414f, -0.60542399f, 0.03757877f, 0.04801356f, 0.09706730f, -0.05167034f, -0.00863692f, 
    0.21148232f, -0.05212571f, -0.56320572f, -0.82771236f, -0.05735784f, -0.33377093f, -0.12833227f, -0.02187456f, 
    -0.11672466f, 0.09675827f, -0.24188605f, -0.49670804f, 0.03039163f, -0.18402068f, -0.12600699f, 0.01049988f, 
    -0.03037209f, 0.06083768f, -0.07337515f, 0.05532320f, 0.19930921f, 0.27303416f, -0.17465623f, -0.06116736f, 
    0.03919542f, -0.16035113f, -0.00095010f, 0.04041190f, 0.07661849f, 0.11413509f, -0.13189735f, -0.70374781f, 
    -0.43907109f, -0.10879318f, 0.04842045f, 0.06243761f, -0.13112727f, 0.07051224f, 0.14710993f, 0.22214705f, 
    -0.13724071f, 0.07401413f, 0.11387269f, 0.05492340f, -0.00361020f, -0.01648747f, 0.00096232f, 0.03170482f, 
    0.27384213f, -0.07090988f, -0.09647009f, -0.02846437f, -0.05990466f, 0.08292295f, -0.03741661f, 0.01982448f, 
    -0.08845285f, -0.18349412f, -0.07543044f, -0.00410361f, 0.15542424f, 0.02743811f, -0.02314449f, 0.07120513f, 
    0.01802091f, 0.36381683f, -0.00406303f, -0.04066540f, 0.14017546f, -0.00680879f, -0.05495535f, -0.03109430f, 
    0.00909025f, 0.12226609f, -0.10472001f, -0.61607856f, -0.18389745f, 0.02792430f, 0.04810591f, 0.12421487f, 
    0.03091292f, 0.15649757f, 0.06062481f, -0.23909731f, -0.12787844f, 0.13283759f, 0.03625287f, 0.00886708f, 
    -0.03832608f, -0.02081214f, -0.12208141f, 0.12994395f, 0.20180459f, 0.06663783f, -0.14322557f, 0.01386663f, 
    0.07356202f, -0.06141431f, 0.10376690f, 0.06275264f, 0.06206103f, 0.30374834f, 0.02963203f, 0.12116703f, 
    0.08837070f, -0.06903468f, 0.08289753f, 0.20893708f, 0.09709826f, 0.11053418f, -0.65441090f, -0.21120830f, 
    -0.25641239f, -0.04551894f, 0.04118271f, -0.18331032f, -0.00581323f, 0.02592887f, -0.05165750f, -0.24825209f, 
    -0.22409000f, 0.10574327f, -0.14267483f, 0.06298539f, -0.15417127f, 0.13559227f, -0.02801692f, -0.14344063f, 
    -0.18072353f, 0.19051541f, 0.08446694f, 0.06815118f, 0.12969550f, -0.27843174f, -0.16535185f, -0.05906123f, 
    0.02461703f, 0.04100933f, 0.12153605f, 0.21911529f, -0.08384037f, -0.07086982f, 0.25216740f, -0.02083472f, 
    0.01429288f, 0.01894908f, -0.26160777f, -0.27720755f, 0.35744375f, -0.08170978f, -0.07981981f, -0.31595945f, 
    0.02562686f, -0.09230249f, 0.01293961f, -0.05255073f, 0.02505692f, 0.07846718f, -0.07182956f, 0.02106424f, 
    -0.07351439f, 0.12726896f, -0.00561092f, -0.05055476f, -0.46102941f, 0.19453749f, -0.22927430f, 0.06630040f, 
    -0.12606157f, -0.08321530f, 0.08272738f, -0.04164906f, 0.05203607f, -0.02407876f, -0.07651766f, 0.27773872f, 
    0.02885022f, 0.22508208f, -0.08022214f, -0.00194665f, 0.03428543f, 0.01611847f, -0.12637362f, 0.10004911f, 
    0.10471585f, -0.00448657f, -0.00426807f, 0.18434954f, -0.01511365f, 0.08074097f, 0.01344333f, 0.02370190f, 
    0.06184250f, 0.06540309f, -0.00701010f, 0.17132768f, 0.07753419f, -0.04554030f, 0.17366050f, 0.01023581f, 
    0.01478499f, 0.29376113f, 0.25134802f, -0.18725696f, -0.07086574f, 0.07827739f, -0.03631384f, -0.02275505f, 
    0.03451252f, -0.10125832f, 0.38013223f, 0.05832415f, 0.00731470f, 0.06274646f, 0.00685268f, 0.03564254f, 
    -0.01212746f, -0.00536009f, -0.00969993f, -0.11334796f, 0.17121513f, 0.01925609f, -0.06263741f, -0.03473254f, 
    -0.03172886f, 0.03426060f, 0.00139446f, -0.25025213f, -0.35944924f, 0.23366727f, -0.17868093f, 0.24242423f, 
    -0.14961672f, 0.03520368f, -0.06851903f, -0.01416882f, -0.16538431f, 0.08392762f, 0.00859046f, -0.00362135f, 
    0.05124859f, -0.19606061f, 0.10411675f, 0.11797006f, -0.06125402f, -0.05002646f, 0.39549956f, 0.20846416f, 
    -0.03150814f, -0.08646048f, -0.08346143f, -0.03786994f, 0.28861329f, 0.11477806f, -0.31727457f, 0.05752144f, 
    -0.11354443f, 0.05215619f, -0.31975496f, 0.01276188f, 0.10434841f, 0.08250272f, -0.00557541f, -0.30011508f, 
    -0.38878959f, 0.21768413f, -0.17398567f, -0.08308509f, -0.05495620f, 0.07449569f, 0.02551072f, -0.09122453f, 
    -0.23798080f, -0.21928674f, -0.04344981f, -0.04760113f, -0.06745864f, -0.07684515f, -0.04509155f, -0.00592023f, 
    -0.11938278f, 0.06254555f, 0.45398831f, -0.17127180f, -0.07523680f, 0.13332489f, -0.05579391f, -0.05392383f, 
    0.02363139f, 0.00902472f, 0.23634264f, 0.23572960f, -0.01018522f, -0.02870991f, 0.05134287f, -0.05269565f, 
    -0.07158418f, 0.03824405f, -0.07114394f, 0.18571311f, -0.02248711f, 0.07208183f, 0.08485208f, 0.02880775f, 
    -0.12328807f, 0.06007312f, 0.20593980f, 0.17879859f, -0.51123452f, -0.38407248f, 0.27414316f, -0.05966683f, 
    -0.06661393f, -0.04455899f, 0.07238238f, -0.12215179f, 0.04413508f, 0.21711831f, -0.01879994f, -0.29581496f, 
    0.06822417f, 0.10750416f, -0.03017147f, 0.01615369f, 0.03608046f, 0.14879775f, -0.14406100f, 0.16451488f, 
    -0.02669596f, -0.07304519f, 0.00194918f, -0.03899835f, 0.02587248f, 0.05377829f, 0.04208191f, 0.11966484f, 
    -0.00727603f, -0.08917812f, -0.10876557f, -0.10953466f, 0.03500862f, -0.04626920f, -0.02855927f, 0.02652615f, 
    0.21415201f, 0.11052795f, 0.12935521f, 0.07963012f, 0.15078996f, 0.04964850f, 0.01429885f, -0.02568910f, 
    -0.10422365f, -0.01551101f, -0.29901350f, -0.03325305f, 0.07347079f, -0.07784488f, 0.07414575f, 0.10066523f, 
    0.08079559f, 0.06256936f, 0.36301994f, 0.07806901f, 0.22800970f, 0.15772901f, 0.07132515f, 0.04290550f, 
    -0.01797888f, 0.04152183f, 0.06330673f, 0.03919349f, 0.18507203f, 0.16715576f, -0.06483384f, -0.01706650f, 
    0.11675262f, 0.04894279f, -0.01097989f, 0.08163074f, -0.42427620f, -0.32866058f, -0.15884039f, -0.19386566f, 
    -0.02726285f, -0.08730115f, -0.02443659f, 0.08375795f, -0.01630747f, -0.03035768f, 0.03948754f, 0.05732451f, 
    0.04599904f, 0.03464279f, -0.02242185f, -0.01792232f, -0.01490671f, 0.03638741f, -0.11283225f, -0.03617524f, 
    0.16831779f, -0.05267573f, 0.12022994f, 0.04426236f, 0.00200294f, -0.01795263f, 0.04616117f, -0.05550688f, 
    -0.37919682f, 0.21519051f, -0.19948046f, -0.15632001f, -0.06726739f, 0.13285978f, -0.02127190f, 0.02420134f, 
    0.01803172f, 0.14274903f, -0.02265099f, 0.11676685f, 0.02248955f, 0.07120086f, -0.07669393f, -0.15935446f, 
    -0.31365037f, -0.29708993f, 0.07097925f, 0.13017716f, -0.08329393f, -0.02775223f, 0.06759943f, 0.25596288f, 
    -0.06435285f, -0.13066943f, 0.23853204f, -0.04862630f, -0.19484992f, 0.04904599f, -0.12218916f, 0.04256896f, 
    -0.03146945f, -0.04731017f, 0.07793604f, 0.11011721f, 0.11578868f, 0.08936242f, 0.08478843f, 0.06999625f, 
    -0.09620021f, 0.25347915f, -0.02719443f, -0.04335034f, -0.12186736f, -0.24014135f, -0.13299842f, 0.11625446f, 
    0.06722432f, 0.07291943f, -0.10278892f, -0.27815697f, -0.20048745f, 0.09708478f, 0.14760575f, -0.06681175f, 
    0.20707828f, -0.02741678f, 0.07283186f, 0.14338309f, 0.01176639f, -0.13230158f, -0.07742974f, -0.19136687f, 
    0.11488773f, 0.00895747f, -0.01105375f, -0.19380052f, -0.20694824f, 0.25806537f, 0.29715309f, -0.12006259f, 
    0.03515229f, -0.08193837f, 0.15502192f, -0.02753945f, 0.08289199f, -0.00235271f, -0.01884949f, 0.05391736f, 
    -0.04766108f, 0.03398652f, 0.00644195f, 0.12555829f, 0.07484334f, 0.15891522f, -0.00577532f, -0.04381264f, 
    -0.06298724f, -0.39660025f, -0.20885968f, 0.16582444f, 0.05456557f, 0.08865988f, 0.12101158f, 0.16827680f, 
    0.03467597f, 0.15586494f, 0.12408057f, -0.12648506f, -0.04609732f, -0.12929331f, -0.12553920f, 0.03574862f, 
    -0.05513579f, 0.02804278f, 0.04816798f, 0.03230048f, 0.13418604f, 0.03098811f, 0.00761000f, 0.11881370f, 
    0.08441982f, 0.02590702f, 0.22461438f, 0.00854459f, -0.26880178f, 0.09544747f, 0.21874812f, 0.00693876f, 
    0.06437300f, 0.06824530f, -0.00606155f, -0.00874559f, 0.07759887f, 0.00611135f, -0.03091004f, 0.20609102f, 
    -0.11170501f, 0.11429132f, -0.05787738f, -0.00355934f, 0.09997133f, 0.05715647f, 0.28353533f, 0.00016512f, 
    0.00486955f, -0.11413001f, -0.10356225f, -0.08794804f, -0.05860743f, -0.10375614f, -0.11800591f, 0.22251241f, 
    0.02552851f, -0.12452644f, 0.21057020f, 0.20967828f, 0.05000137f, 0.07044424f, -0.12013317f, 0.21303885f, 
    -0.02622161f, -0.11194767f, -0.12959005f, 0.02896277f, 0.15013193f, 0.10221776f, 0.16156670f, 0.06197159f, 
    0.09308495f, -0.12463731f, 0.12402868f, -0.08166344f, 0.19896330f, 0.32777038f, -0.18640044f, -0.17317231f, 
    0.15792465f, -0.14833997f, 0.06687056f, -0.10762225f, 0.29286155f, -0.07985851f, -0.05152506f, -0.05244118f, 
    0.11130638f, 0.19974871f, 0.07172985f, 0.00230380f, 0.14485487f, -0.05285981f, 0.07378075f, 0.08414371f, 
    -0.06973679f, -0.06081108f, -0.36373189f, -0.47873881f, 0.06268017f, -0.11355368f, -0.13369450f, 0.00515224f, 
    0.12458476f, 0.09440116f, 0.15512107f, 0.08694270f, -0.13634111f, 0.06053275f, 0.14746684f, -0.02082048f, 
    -0.00116959f, 0.07175512f, -0.12169798f, -0.02426647f, -0.16273217f, 0.14355811f, -0.09610646f, 0.07381628f, 
    0.03014808f, 0.08377963f, 0.06160850f, -0.07289396f, -0.04183141f, -0.07220561f, -0.30397433f, 0.02727196f, 
    0.16196817f, 0.08157399f, -0.13561194f, -0.21185741f, -0.03470038f, 0.06008567f, 0.00166561f, 0.20164360f, 
    -0.02562142f, 0.05377609f, 0.11914265f, 0.08281488f, -0.02780439f, -0.05247853f, 0.05956255f, 0.03344015f, 
    0.18915129f, 0.10155001f, 0.07139813f, -0.15963225f, -0.02536128f, 0.06648143f, -0.13566253f, -0.01034880f, 
    -0.07500797f, -0.05704554f, 0.10999562f, -0.01073459f, 0.18405627f, 0.01744613f, -0.01246182f, 0.03200425f, 
    -0.10022059f, -0.06955392f, 0.09679049f, 0.04433370f, -0.05061633f, 0.07693744f, 0.13944414f, -0.04422652f, 
    -0.03852952f, -0.07005667f, -0.04763790f, -0.27205825f, 0.23388311f, 0.04172795f, -0.07132093f, 0.00987294f, 
    0.07351520f, -0.06159696f, -0.10989477f, 0.10863156f, -0.24456859f, -0.19805969f, 0.09309687f, -0.01536090f, 
    -0.02098431f, 0.05787041f, 0.27308142f, 0.10873926f, 0.20259871f, 0.11038725f, -0.21490899f, -0.11368285f, 
    0.07779214f, -0.05216908f, 0.06602848f, 0.14607370f, -0.06407558f, 0.12781145f, 0.33355656f, 0.17382899f, 
    -0.22939003f, 0.08077297f, 0.11854623f, 0.07515982f, 0.01301427f, -0.04304826f, -0.08890481f, -0.05821853f, 
    -0.02162570f, -0.23878443f, -0.13716972f, -0.04507511f, 0.10617602f, -0.05368543f, -0.05153619f, 0.00799977f, 
    0.13559869f, -0.29484242f, -0.17951846f, 0.17681532f, 0.08188623f, 0.03781189f, 0.15591425f, -0.11461737f, 
    0.01095671f, -0.00464060f, 0.71405190f, -0.33809203f, 0.03504179f, 0.00531702f, -0.05715892f, -0.18069257f, 
    0.22286639f, 0.05018966f, -0.05387628f, -0.08799198f, -0.09590273f, 0.03949029f, -0.03622348f, 0.20525023f, 
    0.04963344f, -0.22001204f, 0.07051456f, 0.15861395f, 0.17741215f, 0.17142729f, 0.22185481f, 0.01853346f, 
    0.10997098f, -0.05963538f, 0.02405160f, -0.00287450f, -0.06487021f, -0.59590656f, -0.19119507f, 0.15572371f, 
    0.02123168f, -0.20789123f, 0.16844431f, -0.02163924f, 0.11850917f, -0.20463927f, 0.16227561f, -0.02386686f, 
    0.06826864f, -0.12556170f, -0.23529206f, 0.07243735f, 0.09185442f, 0.02327061f, -0.00891530f, -0.28752404f, 
    0.02039932f, -0.21551636f, 0.04888243f, 0.02315148f, 0.13167644f, 0.05714793f, 0.11743225f, -0.02179410f, 
    -0.21644858f, -0.29214665f, 0.02943171f, -0.12022769f, 0.01089057f, -0.01235627f, -0.04810828f, -0.13524361f, 
    0.04270077f, 0.07054885f, -0.01034225f, 0.10373961f, 0.12267911f, 0.27521446f, 0.13901721f, 0.07597818f, 
    0.10866126f, -0.03150337f, 0.29358646f, -0.49500713f, -0.22330870f, 0.06897812f, 0.13496581f, 0.02326271f, 
    0.12449469f, -0.05570039f, 0.02264322f, -0.31206027f, -0.14142868f, 0.08465666f, 0.01156842f, -0.15166521f, 
    -0.01000212f, -0.04816348f, -0.00820737f, 0.12057094f, 0.06074672f, -0.03290897f, 0.16944101f, -0.15799041f, 
    0.10632325f, -0.03151651f, -0.01372935f, -0.17698649f, 0.10971485f, 0.05479294f, 0.15512614f, -0.09275838f, 
    0.13553128f, -0.14854375f, 0.05053178f, 0.02855442f, 0.25064597f, -0.07546830f, -0.15773875f, -0.29146510f, 
    -0.47530708f, 0.12789191f, -0.02775604f, -0.00859491f, -0.05420631f, 0.08506493f, -0.13272028f, 0.00155991f, 
    -0.15936495f, 0.42366725f, -0.31704727f, 0.12913202f, -0.01188927f, -0.01638789f, 0.08496331f, -0.06913526f, 
    0.07634047f, -0.24481334f, 0.23583943f, 0.08579326f, 0.04834250f, -0.01889956f, -0.03767567f, -0.06330238f, 
    -0.11240049f, 0.11455042f, 0.04835366f, -0.14448367f, 0.06906559f, 0.16131842f, 0.00801456f, -0.12504870f, 
    -0.06637032f, -0.02667460f, -0.31685674f, 0.13817653f, 0.43195906f, 0.00609167f, 0.11663144f, 0.01854402f, 
    0.03033403f, -0.10057984f, -0.22637893f, -0.26486072f, 0.01802779f, -0.41819552f, 0.15516505f, -0.21237271f, 
    0.01359224f, 0.10787585f, 0.08465591f, 0.24619584f, -0.03813281f, -0.13189231f, 0.14929077f, 0.12113668f, 
    0.08295242f, 0.10729324f, 0.01992098f, -0.10999688f, -0.02342482f, -0.17901568f, -0.02189222f, -0.03731045f, 
    -0.03832055f, 0.00883577f, 0.13456984f, 0.12492863f, -0.04222933f, -0.27871826f, 0.34123269f, 0.22798990f, 
    0.12474284f, -0.03326407f, -0.13289963f, 0.17213766f, -0.15533105f, -0.01899425f, 0.05534245f, -0.07241010f, 
    -0.12274519f, -0.11657982f, -0.01025266f, 0.11592948f, 0.21875714f, 0.01805479f, 0.20808709f, -0.03495523f, 
    -0.12477877f, 0.06838527f, -0.10385879f, 0.06815665f, 0.00900787f, -0.01663029f, 0.22219522f, 0.02229218f, 
    -0.02837313f, 0.15981853f, -0.16239981f, 0.20854568f, -0.01348593f, -0.02558794f, 0.08488088f, 0.02719006f, 
    0.03778329f, 0.18748236f, -0.16697676f, -0.04593908f, -0.07650340f, -0.03414392f, 0.18968852f, -0.04181177f, 
    0.03478919f, 0.16866343f, -0.13946587f, -0.22358711f, -0.18508376f, -0.29767808f, 0.10369534f, -0.23630065f, 
    -0.07983701f, -0.01729739f, 0.13497497f, 0.12675875f, 0.04911344f, 0.02041447f, 0.15547577f, -0.00195898f, 
    -0.02944102f, 0.05928100f, -0.06354817f, 0.06546079f, 0.17997648f, -0.05498518f, 0.01120452f, -0.07825363f, 
    0.16123234f, -0.06368353f, 0.10032991f, -0.07243782f, -0.16301337f, 0.00364575f, -0.13576190f, -0.01706371f, 
    -0.04149918f, -0.00381904f, -0.01161976f, -0.10340509f, -0.08150388f, -0.03363718f, -0.15746346f, 0.06023299f, 
    -0.05757035f, 0.04457847f, 0.03766396f, 0.02650107f, -0.10014377f, -0.00228282f, 0.12702382f, -0.17252433f, 
    -0.00263519f, -0.04095317f, 0.00231235f, -0.01973731f, -0.07881655f, 0.03944766f, -0.08644301f, 0.00373151f, 
    0.03360919f, 0.01724547f, -0.04138552f, 0.04717028f, -0.01769050f, 0.01011918f, -0.08979582f, 0.01885169f, 
    0.00901730f, 0.03829160f, 0.04835758f, -0.06265899f, 0.06885787f, 0.05855193f, 0.03730039f, -0.03569382f, 
    -0.05999533f, -0.06855705f, 0.03751004f, 0.02133518f, 0.06490202f, -0.08276673f, -0.01203684f, -0.00267425f, 
    -0.00172604f, 0.01556208f, -0.00347026f, 0.06665181f, 0.04672680f, 0.00893540f, 0.01667149f, 0.06856154f, 
    -0.08277839f, -0.09054227f, 0.07482243f, -0.05205175f, -0.06614822f, 0.06110838f, -0.00702091f, 0.01335170f, 
    -0.04597863f, -0.03348255f, -0.07203339f, -0.06294668f, 0.00522068f, -0.00215090f, 0.04970986f, -0.02001322f, 
    0.00283815f, -0.00492397f, -0.08038417f, -0.03726296f, 0.06309740f, 0.05487723f, -0.02836359f, -0.06796553f, 
    -0.01625238f, -0.00787245f, -0.05963316f, 0.06245744f, 0.00459990f, 0.02409843f, -0.08845175f, -0.03304827f, 
    -0.04641702f, 0.03538011f, 0.02609750f, -0.08984090f, 0.06289351f, 0.04373298f, -0.08574633f, -0.01354594f, 
    0.01336329f, 0.01337124f, -0.04195736f, -0.01473336f, -0.09139713f, -0.02345514f, 0.02833781f, -0.08915772f, 
    0.00584794f, -0.04198105f, 0.02754339f, 0.01489839f, 0.01550638f, -0.05419218f, 0.02116385f, 0.06209259f, 
    0.06141136f, -0.04813516f, -0.05414551f, 0.04594211f, -0.04037658f, -0.03401920f, -0.01948763f, 0.04527940f, 
    -0.05609343f, -0.05528248f, -0.01970367f, -0.06141851f, -0.05085690f, -0.01539594f, -0.02113355f, 0.01706571f, 
    0.06455398f, 0.00358673f, 0.03549345f, 0.00854528f, 0.06698912f, 0.02518696f, 0.02501308f, 0.00267422f, 
    -0.05627180f, -0.02868242f, -0.00407490f, -0.08818190f, 0.00267406f, 0.03016224f, -0.01126062f, -0.01837614f, 
    0.01287108f, -0.07284967f, -0.05689334f, -0.03576957f, 0.04694687f, -0.05366093f, -0.05265455f, 0.05400564f, 
    -0.06786431f, 0.02902521f, 0.04979324f, 0.00383326f, -0.04624165f, -0.04558368f, -0.00114683f, -0.07321767f, 
    0.00842670f, -0.06315061f, -0.04623299f, -0.01257055f, -0.01884030f, -0.04778983f, -0.01849832f, 0.07165270f, 
    0.04184962f, -0.00617515f, -0.08918434f, -0.03466917f, 0.01100624f, 0.05787214f, -0.06253750f, -0.00851673f, 
    -0.00819914f, 0.00164651f, -0.01805142f, 0.02964112f, -0.09070642f, -0.08385910f, -0.03450394f, -0.07503024f, 
    -0.12280525f, -0.04865081f, 0.03371043f, -0.11779057f, 0.01161351f, -0.01268481f, -0.05344703f, -0.02234428f, 
    0.01708491f, -0.00181575f, -0.09372194f, 0.01128224f, -0.08258227f, 0.02077411f, -0.00448435f, -0.08841335f, 
    0.00966683f, -0.02166197f, -0.05109155f, -0.07226035f, -0.03666010f, -0.02908889f, -0.05745004f, -0.03477887f, 
    -0.05509126f, -0.03230337f, 0.00089108f, 0.02056597f, -0.02088149f, -0.08667832f, -0.08432598f, -0.07462994f, 
    -0.10375157f, -0.07098678f, -0.02428103f, -0.01962528f, -0.03178195f, 0.00603416f, 0.01896914f, -0.03754974f, 
    0.04606076f, 0.00035566f, 0.03059054f, -0.06047999f, 0.03495765f, -0.00975189f, -0.02524699f, 0.02894574f, 
    -0.08074705f, -0.10297655f, 0.00305175f, -0.05607533f, -0.08169585f, -0.10344669f, -0.02840579f, -0.00157487f, 
    0.00034093f, -0.04194034f, 0.04510143f, -0.09001668f, -0.00008646f, -0.00466500f, 0.03275403f, -0.06004220f, 
    0.00575429f, -0.09261387f, -0.01518222f, -0.10462908f, -0.10152646f, -0.06002282f, 0.02645861f, -0.11284675f, 
    0.00486752f, -0.01690206f, -0.10344122f, -0.10250471f, -0.09439518f, -0.01230048f, -0.08958799f, 0.03964799f, 
    -0.07453701f, -0.05314065f, -0.07609420f, -0.11887775f, -0.11224923f, -0.02903703f, -0.07788545f, -0.05153235f, 
    -0.09859664f, -0.05382105f, -0.07951649f, -0.04433829f, -0.07652368f, -0.05573982f, -0.10675064f, -0.06842673f, 
    0.02814490f, -0.00669994f, 0.05055759f, -0.08961103f, -0.05404497f, -0.04490829f, -0.08851723f, 0.02806691f, 
    -0.02023640f, -0.07988408f, -0.03417743f, 0.01527453f, 0.02467135f, 0.02050246f, -0.03043308f, -0.01214271f, 
    0.02306048f, -0.00267853f, -0.06511960f, 0.00787145f, -0.06224854f, 0.00745194f, -0.04256802f, -0.05335099f, 
    0.15891595f, 0.11507336f, 0.02235502f, -0.06727840f, -0.05977048f, -0.01645019f, -0.05494899f, 0.13297530f, 
    0.03610769f, 0.22180632f, -0.21005701f, -0.08668501f, -0.06883948f, 0.01887282f, 0.09210482f, -0.07989161f, 
    0.10174286f, -0.03646059f, -0.42584628f, 0.14645053f, 0.43111715f, -0.10266796f, -0.21219571f, -0.05227830f, 
    -0.07024994f, -0.01128631f, 0.07803105f, -0.26892728f, -0.46705481f, -0.18608965f, 0.02391509f, 0.02451427f, 
    -0.04495645f, 0.05639075f, -0.03928922f, 0.01977532f, -0.24227302f, -0.04325273f, -0.15438820f, -0.10110153f, 
    -0.09030350f, -0.06981760f, -0.16398722f, 0.09343237f, 0.07794053f, -0.06033513f, -0.32137853f, -0.27314827f, 
    -0.15954581f, -0.09792513f, -0.04315676f, -0.03042409f, 0.03363540f, -0.06151825f, 0.29511991f, 0.27907881f, 
    -0.11521700f, -0.17663343f, 0.18563567f, -0.03377221f, 0.19150506f, -0.05272865f, 0.22751243f, -0.09750448f, 
    -0.37752950f, -0.10073820f, 0.00590578f, 0.08296458f, -0.03270627f, 0.09731100f, 0.05183867f, 0.03312166f, 
    -0.12404322f, -0.10808677f, -0.05280750f, 0.09686651f, 0.07802577f, -0.00537199f, 0.01496201f, -0.01586850f, 
    0.13134034f, -0.10778845f, -0.24982083f, -0.11483315f, 0.02207542f, -0.05917057f, 0.10175350f, 0.10348511f, 
    0.10591297f, 0.00731307f, -0.05062955f, 0.04933770f, 0.21050024f, -0.06512840f, 0.09840264f, 0.06948161f, 
    0.05215299f, 0.24363038f, 0.04876302f, -0.00966525f, -0.14799456f, -0.15772028f, 0.13128647f, 0.06339827f, 
    0.11718670f, 0.15437795f, 0.11098395f, 0.07329391f, 0.13479760f, 0.03172810f, -0.19068696f, 0.02702738f, 
    0.01133169f, 0.03438153f, 0.10183568f, 0.10936836f, 0.19209392f, 0.10613087f, -0.09111540f, -0.05080330f, 
    0.04741640f, -0.07511834f, 0.06877842f, 0.02302820f, 0.05866364f, 0.10747657f, 0.19028036f, 0.05612856f, 
    0.23806402f, -0.07826277f, -0.18199432f, -0.06317499f, -0.02900782f, -0.03905841f, 0.01726750f, -0.19023962f, 
    -0.42114785f, -0.23005189f, -0.09229250f, -0.10224860f, -0.02097811f, 0.08928631f, 0.03527835f, -0.00246382f, 
    -0.39311108f, -0.17230713f, 0.07209314f, -0.01784766f, -0.00521592f, -0.02940042f, -0.01455786f, -0.19880420f, 
    0.21719849f, -0.59023875f, -0.35741526f, -0.04454345f, -0.24928454f, -0.29052970f, -0.01744550f, -0.13290946f, 
    -0.17980294f, 0.04711184f, -0.31776705f, 0.14261556f, 0.08316086f, -0.31153461f, 0.04625618f, -0.19663167f, 
    -0.19976242f, -0.00276719f, 0.01707245f, -0.00005995f, 0.07481565f, 0.06249798f, 0.04190804f, -0.12214032f, 
    0.03946790f, 0.03361308f, 0.12078129f, -0.02589985f, -0.02759318f, 0.11947613f, -0.25398585f, -0.03429369f, 
    0.06240905f, 0.20920868f, 0.11001327f, 0.02908101f, 0.06989725f, 0.06004664f, -0.73765630f, -0.76726371f, 
    -0.06890520f, -0.39419216f, 0.05905335f, -0.01590305f, 0.17088814f, -0.02641023f, 0.02576384f, 0.12184505f, 
    0.34957278f, -0.01796246f, 0.05566242f, 0.08477381f, 0.04913700f, 0.12380382f, -0.18142191f, -0.16397686f, 
    -0.14189495f, -0.72702736f, 0.13691974f, 0.05471909f, -0.13295104f, 0.04589472f, 0.00706650f, -0.07200479f, 
    -0.25134611f, -0.01868599f, -0.45321906f, 0.04044350f, 0.00969295f, 0.04522594f, 0.10340365f, 0.03589886f, 
    0.10503507f, 0.08125790f, 0.11399748f, -0.19082692f, 0.30598807f, 0.14602031f, 0.21167149f, 0.07347947f, 
    -0.07062663f, 0.03166731f, 0.02482650f, -0.55563146f, 0.16894495f, -0.00673715f, 0.03830110f, -0.36716062f, 
    0.16056883f, 0.00486137f, 0.07428414f, 0.30191439f, 0.16097786f, -0.15495375f, 0.19977434f, 0.08903508f, 
    0.36390886f, 0.16140199f, 0.05232277f, -0.09571530f, 0.12949754f, -0.13882402f, 0.07778363f, -0.06958664f, 
    0.14215539f, -0.05284761f, 0.20582941f, -0.09574778f, 0.03785631f, -0.27963114f, 0.04430249f, -0.06363508f, 
    -0.04604132f, -0.04448636f, -0.06489888f, 0.08162007f, -0.02436999f, -0.03490572f, -0.07710853f, 0.13227127f, 
    0.13432842f, 0.00694612f, -0.28680894f, -0.20226932f, 0.02414870f, 0.09480946f, -0.01992981f, -0.05997941f, 
    -0.28081298f, -0.11463346f, -0.34909987f, -0.13202262f, -0.06538529f, 0.09277961f, 0.09327721f, 0.01330215f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.17118055f, 0.03944215f, -0.01223139f, 0.04869557f, 0.07353981f, 0.11469637f, 0.02544115f, 0.05858720f, 
    0.05646004f, -0.11592039f, -0.07496289f, 0.06608731f, -0.09011898f, -0.02507931f, 0.17070204f, -0.02151253f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.25603956f, -0.24171939f, -0.25749177f, 0.07726245f, -0.33880192f, -0.24609572f, -0.14289625f, 0.28921244f, 
    0.00395382f, -0.04779821f, -0.30805907f, 0.06654574f, -0.10707544f, 0.19240111f, -0.05736160f, 0.17896067f, 
    -0.27226481f, -0.14627224f, 0.42172673f, 0.05840460f, -0.21440455f, 0.33655632f, 0.12898575f, 0.20648636f, 
    -0.29091755f, 0.00656292f, -0.06356678f, -0.07102582f, -0.02050107f, 0.06783772f, 0.22647157f, 0.25624502f, 
    -0.95656240f, 0.22481269f, 0.09269889f, -0.90884322f, -0.06469022f, 0.04340748f, -0.45701733f, -0.56774199f, 
    0.17771918f, -0.46688977f, -0.05591808f, 0.34217250f, 0.22764745f, -0.22421589f, 0.25645521f, 0.33451298f, 
    0.17001346f, 0.09235619f, 0.08719928f, 0.47548911f, 0.02453511f, -0.16142879f, -0.21888058f, -0.12129555f, 
    -0.06743282f, 0.39023840f, 0.15162341f, -0.00343339f, 0.21333452f, -0.02764963f, -0.09189416f, -0.12763460f, 
    0.08267259f, 0.02780836f, 0.35755840f, 0.07997817f, -0.21319190f, 0.21041898f, -0.22984208f, 0.28918722f, 
    0.24865459f, -0.13993309f, 0.32940134f, -0.15429138f, -0.10103794f, 0.12790602f, -0.18228558f, -0.36746573f, 
    0.36557114f, -0.16583437f, 0.40469903f, 0.02961820f, -0.30084029f, -0.11456406f, 0.21127652f, 0.24356198f, 
    -0.07825626f, 0.03936528f, -0.44784421f, -0.22061479f, 0.15313371f, -0.27486405f, -0.08269578f, 0.30246100f, 
    -0.36939520f, -0.01778220f, -0.42694339f, 0.28027242f, 0.02917472f, 0.24586621f, 0.17705403f, 0.10899264f, 
    0.08541151f, 0.14251465f, -0.04577678f, -0.05342370f, 0.23336481f, 0.25408638f, 0.22009233f, -0.09568679f, 
    0.22141118f, -0.10165907f, 0.05428680f, 0.21430755f, -0.29150939f, -0.35890874f, -0.01348042f, -0.15245166f, 
    0.16155444f, 0.12384482f, -0.19345099f, 0.01112516f, -0.01815452f, 0.15377276f, 0.07089370f, -0.34975469f, 
    0.09393305f, -0.00279354f, -0.03527576f, -0.06885918f, 0.36744890f, -0.09759935f, 0.11776807f, -0.13491939f, 
    0.12552555f, -0.18750055f, -0.35679406f, 0.00212385f, 0.22134973f, -0.08506969f, 0.20723334f, 0.21824059f, 
    -0.03763609f, -0.10902497f, 0.06625716f, 0.40442824f, -0.06035128f, 0.44449455f, -0.30454591f, -0.14718814f, 
    0.04472285f, 0.07926445f, -0.21634996f, 0.04435474f, -0.01049792f, 0.19933257f, 0.19720919f, -0.27942792f, 
    -0.18052059f, 0.15755603f, 0.03768849f, -0.16117552f, -0.22996792f, -0.20001224f, -0.21892682f, -0.15120542f, 
    0.00193650f, -0.06557503f, 0.00121084f, 0.00020120f, -0.06266645f, 0.03779039f, -0.24710220f, -0.02133697f, 
    0.39102244f, -0.22914253f, -0.25943503f, 0.02663461f, -0.01289629f, 0.17721336f, 0.19579563f, -0.25019857f, 
    0.01770254f, 0.12697427f, 0.40468672f, -0.00557863f, 0.07469691f, -0.18250857f, -0.09380021f, -0.68386060f, 
    -0.27262965f, -0.18318753f, 0.16954903f, -0.04129367f, 0.27905530f, 0.08411493f, -0.12377748f, -0.32830384f, 
    0.10416878f, 0.51488167f, 0.04337827f, 0.03560797f, -0.06842624f, -0.14934482f, 0.12490503f, -0.00343317f, 
    0.04047362f, 0.00045363f, 0.15667510f, 0.05362497f, 0.24837308f, 0.40741369f, -0.00101406f, 0.00345486f, 
    -0.14552377f, 0.37719300f, 0.20291537f, -0.24548198f, -0.21693431f, -0.09312569f, -0.06041234f, -0.17209627f, 
    0.04342988f, 0.18150955f, 0.21081130f, -0.13762932f, -0.22227854f, 0.40383601f, -0.06146217f, 0.39369786f, 
    0.06931779f, 0.17401974f, 0.16300699f, 0.12383218f, 0.14134786f, 0.01784858f, -0.29777637f, -0.23788178f, 
    0.45705658f, -0.05379017f, -0.12179666f, -0.23115396f, -0.23582138f, -0.57115597f, 0.35678113f, -0.19110183f, 
    0.20712860f, -0.23523007f, 0.00222180f, 0.13515538f, 0.09229119f, 0.08109620f, 0.02498663f, -0.27265489f, 
    -0.21613798f, -0.24508831f, 0.04905182f, -0.21051148f, 0.02693143f, 0.21242583f, -0.08341479f, 0.00830391f, 
    -0.11993968f, -0.09897211f, -0.13316005f, -0.13797227f, -0.09962162f, 0.06288302f, 0.01154742f, -0.21408743f, 
    -0.22854912f, -0.07285818f, -0.23479515f, -0.06475988f, -0.20451504f, 0.19956076f, 0.21283033f, -0.17330253f, 
    -0.20919523f, 0.01152468f, -0.20548725f, -0.07904759f, 0.16490236f, 0.11268273f, -0.01703596f, -0.03969759f, 
    0.18548413f, -0.06338757f, -0.03235408f, 0.48474935f, 0.24690840f, 0.02449171f, -0.01094793f, -0.29788345f, 
    0.33419174f, -0.14723642f, 0.44088370f, -0.19949360f, -0.22708935f, 0.15013705f, -0.09762574f, -0.42036486f, 
    -0.32576066f, -0.06688280f, 0.36051783f, 0.19067752f, 0.15717590f, -0.04780608f, 0.13334846f, -0.01034350f, 
    -0.01444905f, 0.27419853f, 0.13777035f, -0.30213878f, 0.03525052f, 0.17382003f, 0.12803581f, -0.57975823f, 
    -0.25518507f, -0.01246916f, -0.17469892f, -0.03669716f, -0.20234787f, -0.36915258f, -0.23061211f, -0.04330060f, 
    -0.03965187f, 0.28626078f, 0.37685663f, 0.28320003f, 0.13428900f, -0.20308125f, 0.18712136f, 0.04869717f, 
    0.25796926f, 0.02122280f, 0.06220552f, -0.17677228f, 0.27388892f, 0.44019493f, 0.05419809f, 0.22685973f, 
    -0.36279634f, 0.07779726f, 0.22714503f, -0.06325980f, -0.20265892f, 0.07357383f, 0.09155809f, -0.55870032f, 
    0.22163665f, -0.09357411f, 0.13517970f, -0.00723640f, 0.10780551f, 0.32531080f, -0.10989943f, 0.18256092f, 
    -0.26311040f, 0.47648799f, 0.16124265f, -0.22657929f, 0.17287165f, 0.00099357f, -0.10332059f, 0.16467349f, 
    0.07313425f, -0.21721874f, 0.24519041f, 0.23670970f, 0.19865450f, 0.30962101f, -0.13473123f, -0.22782485f, 
    -0.21695447f, -0.15725736f, -0.21741280f, 0.09954979f, 0.03576665f, 0.13547690f, 0.20067541f, -0.08240665f, 
    -0.05924988f, 0.19048756f, -0.42149040f, 0.26550364f, -0.28112563f, -0.37360516f, 0.18043868f, -0.21473363f, 
    0.20674746f, 0.01335730f, -0.12736867f, -0.15494953f, -0.07340174f, -0.12551351f, 0.27184367f, 0.17238456f, 
    -0.49941447f, -0.10463435f, -0.09345391f, 0.21316767f, 0.30576545f, 0.38623291f, 0.12493330f, -0.37957621f, 
    -0.06990126f, 0.15210435f, 0.01358781f, 0.29355705f, -0.15158832f, 0.19991267f, 0.05320161f, -0.16293795f, 
    0.25914785f, -0.07558832f, 0.08494196f, -0.16791433f, 0.22657064f, 0.51867431f, 0.15034278f, 0.30008966f, 
    -0.27974409f, -0.20312819f, -0.24495354f, 0.16806965f, -0.19967113f, 0.05482831f, 0.00124556f, 0.14761128f, 
    0.20228718f, 0.05611540f, -0.10610828f, 0.38216048f, -0.03092377f, -0.01163039f, -0.29159996f, 0.05812516f, 
    0.12090501f, 0.32676551f, -0.36409488f, -0.29335931f, -0.01698365f, 0.04284998f, 0.05934898f, -0.12162244f, 
    0.09083269f, -0.11320525f, 0.12349093f, -0.36814123f, 0.24110898f, -0.01352972f, -0.31168345f, 0.06259056f, 
    0.35924125f, -0.15628305f, -0.31309193f, 0.01696366f, -0.22645873f, -0.16640159f, 0.32257506f, -0.54683286f, 
    0.17308082f, 0.15090604f, -0.26691118f, -0.22365455f, 0.27406788f, 0.09346028f, 0.04233663f, -0.00489765f, 
    0.24688746f, -0.24764931f, -0.11831652f, 0.07540710f, -0.10391393f, -0.11719345f, 0.25457498f, -0.02187517f, 
    0.08883956f, 0.09176799f, -0.07664650f, 0.01189752f, -0.23032059f, -0.11634079f, -0.16465271f, -0.35345787f, 
    0.24277277f, 0.24218169f, 0.03580230f, -0.04284537f, 0.12091318f, 0.02492242f, 0.31145221f, -0.27358997f, 
    0.18461752f, 0.11920854f, 0.00763013f, -0.08250550f, -0.17672727f, -0.08909106f, -0.06121125f, -0.08163025f, 
    0.19947508f, 0.21730906f, -0.26442838f, -0.51220888f, 0.20469368f, 0.09133205f, 0.28897431f, 0.40028292f, 
    0.24247761f, -0.09793295f, -0.26514667f, 0.06450521f, -0.07862025f, -0.04741440f, -0.25373659f, 0.30215487f, 
    0.20411336f, -0.13412201f, 0.23853666f, 0.30302364f, 0.19234286f, -0.12632512f, -0.15179403f, -0.01240353f, 
    0.11203920f, -0.08854233f, -0.15116715f, 0.30421489f, 0.55988806f, 0.04589080f, 0.43479189f, -0.37680241f, 
    0.19032821f, -0.21036758f, -0.46605292f, -0.44349515f, -0.02829585f, -0.14473803f, 0.19841056f, -0.56872469f, 
    -0.22043794f, -0.15163581f, 0.06815027f, -0.04497636f, 0.07654935f, 0.44231415f, 0.29431939f, -0.01144764f, 
    -0.04110879f, -0.33235982f, 0.37971899f, 0.15611291f, -0.15762140f, -0.02365575f, 0.18434912f, -0.33387515f, 
    0.11698557f, 0.05516895f, 0.30540788f, -0.28952470f, 0.03709488f, -0.09558330f, 0.44455820f, -0.00040401f, 
    -0.05909283f, 0.33169907f, -0.36180916f, -0.01000294f, -0.15382048f, 0.11867901f, -0.03374569f, 0.12776579f, 
    0.26271650f, 0.18890932f, -0.43982038f, -0.22560585f, -0.35825288f, -0.19629891f, -0.08054833f, 0.04534527f, 
    0.31362042f, -0.13799052f, -0.17339861f, 0.24207729f, -0.22679549f, -0.21290016f, 0.10534328f, -0.57732195f, 
    0.16788864f, -0.17730428f, 0.33435345f, 0.11102468f, 0.13440998f, -0.61629099f, -0.38213420f, -0.35979107f, 
    -0.07374875f, 0.13489710f, -0.16391779f, 0.30059081f, -0.21451655f, 0.09145994f, -0.01017928f, -0.06618465f, 
    0.11683757f, 0.19978635f, 0.05107555f, -0.08194300f, 0.21131694f, -0.06226192f, -0.15917315f, -0.18008114f, 
    0.32206312f, -0.15253264f, -0.15845574f, 0.15485369f, 0.11178607f, -0.18253466f, 0.14481799f, -0.29350087f, 
    -0.20429327f, -0.07406396f, 0.07421003f, 0.05275149f, -0.50196528f, -0.62637454f, 0.22501445f, -0.03614369f, 
    0.27945969f, 0.05590329f, -0.07127526f, -0.00105416f, 0.05616267f, -0.07156719f, 0.15611222f, -0.26912281f, 
    -0.19626136f, 0.10534859f, -0.25844368f, 0.21220577f, -0.33958137f, -0.56294280f, -0.01447470f, 0.08555996f, 
    0.14047195f, 0.12831613f, 0.21966757f, 0.23020847f, -0.17444029f, 0.19763879f, -0.13917589f, 0.17404296f, 
    0.16844325f, 0.10329267f, -0.14905836f, 0.41611531f, -0.00515542f, 0.39700690f, -0.35891479f, 0.02657900f, 
    0.02633929f, -0.16072275f, 0.15863338f, 0.20122704f, 0.22643019f, 0.25459030f, 0.02762539f, -0.15240119f, 
    0.27997819f, -0.12648043f, -0.33564973f, -0.20415583f, 0.07662514f, 0.05576060f, 0.29020956f, 0.12805805f, 
    -0.02402255f, -0.16990528f, -0.16234377f, 0.35596991f, 0.09601679f, 0.25685823f, 0.24848749f, -0.37453797f, 
    0.45761603f, -0.06099075f, 0.08202475f, -0.26079962f, -0.24165358f, 0.03911669f, 0.07458572f, 0.47202191f, 
    -0.15039271f, 0.02983349f, 0.21496971f, 0.17227958f, -0.10938245f, -0.13110524f, -0.17432037f, -0.33514753f, 
    0.16013892f, -0.12901843f, 0.28674453f, -0.18632126f, 0.01078157f, -0.04827459f, -0.14888176f, -0.06213706f, 
    -0.10093410f, 0.44506788f, 0.24284796f, 0.04046164f, 0.16286041f, -0.19515869f, -0.15387590f, -0.21058336f, 
    -0.05332080f, -0.18695253f, -0.13741718f, 0.42728800f, -0.38466167f, -0.25833267f, 0.09483910f, 0.16628470f, 
    -0.00858540f, -0.22510894f, -0.20536262f, -0.20445320f, -0.16236380f, 0.08515438f, -0.36062294f, -0.40025526f, 
    -0.24149895f, -0.23602653f, -0.12373024f, 0.00702450f, -0.24534081f, 0.24098459f, -0.21993065f, 0.39114860f, 
    0.04679349f, -0.13037701f, -0.20153332f, 0.36138061f, -0.16343585f, -0.17945823f, 0.52824509f, -0.28022483f, 
    0.12647662f, 0.15001613f, 0.23251815f, 0.07174768f, -0.36069319f, -0.05669975f, 0.38071045f, 0.25531632f, 
    0.15133849f, -0.13368401f, 0.39112237f, -0.26617453f, -0.09862233f, 0.09420808f, -0.15574646f, -0.18441735f, 
    0.39075819f, -0.23218498f, 0.16525964f, 0.24126351f, -0.15513775f, 0.34246007f, -0.22700316f, -0.16537860f, 
    -0.03474230f, -0.27290416f, -0.11153526f, -0.16124466f, 0.18314883f, 0.13509841f, 0.16871127f, 0.22471367f, 
    -0.15752968f, -0.14920434f, 0.04672908f, 0.38760969f, 0.13070610f, -0.33849421f, -0.26675263f, 0.27190474f, 
    -0.21351714f, 0.20821674f, -0.13048540f, -0.46419001f, -0.10333353f, 0.22815506f, 0.07964391f, -0.79607946f, 
    -0.14212625f, -0.01477870f, 0.24095531f, -0.07897309f, -0.23552723f, -0.01819911f, -0.19085135f, 0.15482524f, 
    -0.00396819f, -0.05222938f, -0.10580026f, 0.20818357f, -0.19571060f, -0.18374538f, 0.10528348f, -0.22784251f, 
    -0.16930982f, 0.12995736f, 0.09297252f, 0.47606725f, 0.38175577f, -0.31780460f, 0.44666934f, -0.27284721f, 
    -0.08108965f, 0.19226764f, 0.14205399f, 0.03382714f, -0.01079093f, 0.00650008f, -0.15774308f, -0.25295049f, 
    -0.34555849f, -0.21545182f, -0.21170142f, 0.33456734f, 0.37418026f, 0.46757075f, 0.24019311f, -0.19360000f, 
    -0.14157017f, -0.02785853f, -0.13393776f, 0.14363615f, -0.04306474f, -0.24431282f, 0.23855934f, -0.24522592f, 
    -0.15266500f, -0.03320378f, -0.25302783f, 0.38802060f, 0.06724718f, -0.28450811f, 0.24451004f, 0.34745741f, 
    -0.09559639f, 0.25603181f, 0.05638894f, -0.07440849f, -0.00150219f, -0.03343586f, -0.33315605f, 0.30879438f, 
    0.24106361f, -0.09351209f, 0.36088932f, -0.28142723f, -0.24340649f, 0.00948924f, 0.24378726f, 0.07687826f, 
    0.33879068f, -0.07412940f, 0.07297802f, -0.36581758f, -0.07360655f, 0.12754163f, -0.02200885f, 0.01213424f, 
    0.25318843f, -0.21627828f, 0.34948340f, -0.25509998f, -0.28361824f, -0.41539982f, -0.18086085f, -0.13870664f, 
    -0.12629150f, 0.14360088f, -0.02305702f, 0.18986137f, 0.20942281f, -0.18430647f, 0.20332177f, 0.38249174f, 
    -0.19912475f, -0.22876245f, -0.24741660f, 0.30850804f, -0.08336277f, -0.26619786f, -0.09659880f, 0.30652493f, 
    -0.01625050f, -0.12636465f, 0.04613846f, -0.09907958f, 0.06712028f, 0.10611887f, -0.11140648f, 0.41337430f, 
    0.22999595f, 0.18228672f, 0.24395269f, 0.18319716f, -0.14354515f, 0.00017413f, 0.22275914f, 0.19895561f, 
    0.15504190f, 0.15961783f, -0.00823266f, -0.25304866f, -0.15716518f, -0.04862856f, -0.30407354f, 0.09676126f, 
    -0.03920657f, 0.22852665f, -0.34081396f, 0.25752169f, 0.15948308f, -0.52064723f, 0.42981845f, -0.37134188f, 
    -0.03526228f, 0.15318789f, -0.00029784f, 0.14949575f, 0.16947086f, -0.12544152f, -0.03584637f, 0.05472304f, 
    -0.18599163f, 0.04383019f, -0.14972702f, -0.21769898f, -0.27412990f, -0.26243567f, 0.49331683f, 0.12854324f, 
    -0.12420477f, 0.15572529f, -0.09704513f, 0.23345931f, -0.04177433f, 0.02171634f, 0.10318704f, 0.21245182f, 
    0.29358578f, -0.22335626f, 0.04544064f, -0.21826668f, 0.25426039f, -0.18901204f, 0.06962601f, 0.11200851f, 
    -0.01396722f, -0.30272514f, -0.17313071f, 0.17513061f, 0.02474395f, -0.16809247f, -0.03013504f, 0.13283803f, 
    -0.04719418f, -0.11231144f, 0.20324512f, 0.02550197f, -0.39341575f, -0.22462298f, -0.23208700f, 0.32940903f, 
    0.22739764f, -0.02554524f, -0.28293061f, 0.36777481f, 0.17349608f, 0.10961314f, 0.05613419f, -0.12847200f, 
    0.04963166f, 0.17986199f, 0.16736044f, 0.47011402f, -0.13025555f, -0.08342317f, 0.24188831f, -0.24459018f, 
    -0.23115815f, -0.28203899f, -0.06704818f, 0.21528466f, 0.13232431f, 0.01350397f, -0.29428151f, 0.17287758f, 
    0.26579300f, -0.18752126f, 0.05606850f, 0.34106287f, 0.01569165f, -0.15303670f, -0.04219212f, -0.39935642f, 
    0.02605763f, 0.29984641f, -0.25378510f, -0.11408798f, 0.20923458f, -0.01120409f, -0.02124149f, 0.42580259f, 
    0.33043906f, -0.19227973f, 0.31496423f, 0.00866340f, 0.23568983f, 0.02868124f, -0.32237071f, 0.37299660f, 
    -0.26792154f, 0.27510604f, 0.01803426f, 0.22952813f, -0.14048810f, 0.11923094f, -0.29468071f, 0.08567549f, 
    0.22996628f, 0.09056913f, -0.20603400f, 0.01611579f, -0.08254082f, 0.39138868f, -0.03705451f, -0.10447042f, 
    0.10045659f, -0.31002575f, -0.19938357f, 0.18537281f, -0.22661589f, 0.24352463f, 0.33302665f, -0.37364087f, 
    -0.20414078f, 0.14052260f, -0.15010479f, 0.03624754f, 0.38122520f, 0.27575055f, 0.30887225f, -0.19871183f, 
    0.39326841f, -0.24866197f, 0.30298513f, -0.06124409f, 0.22064656f, 0.23860419f, -0.10610172f, -0.23769486f, 
    0.09550920f, 0.00498326f, 0.20557472f, -0.18277265f, 0.04706641f, 0.25964153f, 0.35686362f, -0.11075260f, 
    -0.20744590f, -0.03547674f, -0.02541764f, 0.14210142f, -0.03553091f, -0.11782208f, -0.12265868f, -0.24138965f, 
    0.05847917f, 0.15158007f, 0.29911157f, -0.10215776f, 0.32875195f, -0.08736601f, 0.29146147f, -0.35231522f, 
    0.16383153f, 0.19987474f, -0.44227394f, -0.09785384f, 0.24691518f, 0.23171426f, -0.02078974f, -0.29154503f, 
    0.18235189f, -0.01437609f, 0.05263852f, 0.14707184f, 0.20747550f, 0.45954540f, 0.21739209f, -0.37295595f, 
    0.04843367f, -0.12825435f, -0.61990368f, -0.39754209f, 0.14986674f, -0.03523571f, 0.38919184f, -0.13523076f, 
    -0.05306407f, 0.12233448f, -0.27858666f, 0.18261948f, -0.08294375f, 0.42577595f, -0.25973848f, -0.01241941f, 
    0.27546388f, -0.03809689f, 0.21219064f, -0.07268602f, -0.23600681f, -0.08720294f, 0.00932153f, -0.18784523f, 
    0.11246748f, -0.20820689f, -0.26436362f, -0.19277494f, -0.25648448f, 0.38596269f, 0.00718943f, 0.05191927f, 
    0.16975208f, -0.06618766f, -0.19515944f, 0.33324534f, 0.22295612f, 0.01173267f, 0.28775775f, -0.60428327f, 
    -0.04343348f, -0.00382140f, 0.24789390f, 0.06731577f, 0.42375299f, 0.07916028f, 0.29610142f, 0.26155207f, 
    -0.19801763f, -0.11275964f, 0.05451513f, 0.08919494f, -0.14624730f, 0.13211477f, -0.27406374f, -0.18233427f, 
    0.39968657f, -0.19814929f, 0.07779653f, -0.00506305f, -0.43209398f, -0.04190178f, 0.28400689f, 0.06345049f, 
    -0.09252744f, 0.01502107f, -0.21792834f, 0.08721805f, -0.00045145f, 0.12692161f, 0.21720615f, 0.16566797f, 
    -0.30531448f, -0.05155104f, -0.03527672f, 0.32074893f, 0.05365377f, 0.00224421f, -0.38230932f, 0.40264228f, 
    0.25045562f, -0.05428336f, 0.00409938f, 0.08711766f, -0.05030236f, -0.11260393f, -0.13442382f, -0.11952706f, 
    0.32859370f, -0.15438554f, 0.12834859f, 0.31645766f, -0.26715669f, -0.29213864f, -0.13628580f, -0.20932820f, 
    0.11382394f, 0.20453238f, -0.19787782f, -0.18407148f, 0.02323886f, 0.02408658f, 0.20777814f, 0.12512626f, 
    0.21542265f, -0.14929909f, -0.18736234f, 0.05739185f, 0.36800396f, -0.48067397f, -0.02582304f, -0.32640079f, 
    -0.09974448f, 0.32770401f, -0.20561957f, -0.24422894f, -0.14068532f, -0.21096756f, 0.46937972f, -0.13113479f, 
    0.11886329f, -0.03329673f, 0.23061468f, -0.07297699f, 0.30621806f, 0.10587949f, 0.17248689f, 0.12108628f, 
    -0.01054962f, -0.30160728f, -0.09846938f, -0.13477062f, 0.02177132f, -0.12444042f, 0.06633732f, -0.46798030f, 
    -0.12701420f, -0.12889487f, -0.04869955f, -0.07772306f, -0.26606229f, -0.11535236f, -0.10628430f, 0.22196877f, 
    -0.22776833f, 0.30874917f, -0.17075264f, 0.19032438f, -0.02647972f, 0.10488558f, 0.34426022f, 0.06368703f, 
    0.08374985f, -0.20787254f, -0.11803406f, -0.25700027f, -0.19021446f, -0.25471586f, -0.14465016f, -0.14783181f, 
    0.17714252f, -0.10795641f, -0.00640189f, -0.09763066f, -0.14871275f, 0.10436371f, -0.19099735f, 0.06191948f, 
    0.41963723f, 0.00561133f, -0.13832396f, 0.00865814f, 0.44875437f, -0.09564184f, 0.20697702f, 0.01739212f, 
    0.19341026f, -0.16556065f, 0.02834734f, 0.07756582f, 0.21002497f, 0.04846004f, -0.16344696f, -0.16509923f, 
    -0.65692192f, 0.22176668f, 0.01263457f, -0.89544755f, 0.25434849f, 0.23544611f, 0.40645030f, -0.49297440f, 
    -0.37996769f, -0.31162235f, 0.24025291f, -0.08506332f, 0.06349223f, 0.17265819f, -0.62262839f, 0.26408249f, 
    0.18584779f, 0.03745754f, -0.13812241f, -0.04437438f, 0.08609023f, 0.23763241f, 0.03352366f, 0.24917586f, 
    -0.35802573f, 0.08524153f, -0.00218592f, 0.03532837f, -0.05087484f, -0.05811626f, 0.25805578f, -0.22317855f, 
    -0.10209596f, 0.02669556f, -0.08929539f, -0.13720873f, 0.22058149f, -0.07325132f, 0.33283070f, -0.26524752f, 
    0.13187796f, 0.17485085f, -0.07014695f, 0.15152591f, 0.17856434f, 0.14711177f, 0.22543152f, -0.36554417f, 
    -0.30391353f, 0.16499829f, 0.24957837f, -0.11614631f, 0.11464854f, -0.02461035f, 0.35685465f, -0.19953552f, 
    0.04508206f, 0.24064387f, -0.33555788f, -0.17450458f, 0.07536166f, 0.05303359f, 0.11739965f, 0.05654194f, 
    -0.25343722f, -0.22736089f, -0.37600687f, -0.03279839f, -0.29007408f, 0.41143548f, 0.29557052f, 0.32609624f, 
    0.15496045f, -0.11850186f, -0.17418872f, 0.09464372f, -0.09200469f, -0.05780553f, 0.36122859f, -0.29574391f, 
    0.30712804f, -0.18783954f, -0.16871920f, 0.11902576f, 0.07673044f, 0.27408189f, 0.00044066f, -0.25066537f, 
    0.03148537f, -0.07616948f, 0.41500199f, -0.12639895f, 0.07484242f, 0.23658201f, -0.21680486f, 0.20578103f, 
    0.14770916f, -0.05098009f, 0.13636065f, -0.09358571f, -0.06365355f, -0.00031201f, -0.14152290f, -0.21234275f, 
    -0.22430342f, -0.17481795f, -0.15479274f, -0.09129559f, -0.02706946f, -0.03387149f, -0.22591241f, -0.01871863f, 
    0.32114533f, 0.16594484f, 0.34492028f, 0.10024600f, -0.28785351f, 0.12731950f, -0.43221608f, -0.00643688f, 
    0.13598849f, 0.08084973f, 0.11551866f, -0.36129493f, 0.10298553f, 0.14854763f, 0.23533215f, 0.13801844f, 
    0.25287864f, -0.04143328f, -0.10588477f, 0.00377812f, -0.10048193f, -0.10566127f, 0.20971829f, -0.20959446f, 
    -0.24374489f, 0.20379215f, -0.22295384f, 0.18850960f, -0.06682555f, -0.08652475f, 0.35676342f, 0.16963682f, 
    0.28646636f, -0.23499048f, 0.29052237f, -0.00855918f, 0.00970740f, -0.19035171f, 0.33268005f, 0.31231594f, 
    -0.10034104f, 0.18899332f, 0.10538332f, -0.26514795f, 0.08928185f, -0.01859194f, -0.22007383f, -0.15468611f, 
    0.17547974f, -0.07121798f, 0.31646729f, 0.18383126f, 0.26211312f, 0.20473741f, 0.05403368f, -0.07101240f, 
    0.17643476f, 0.25473496f, -0.36855376f, -0.41064942f, -0.14606255f, 0.11479499f, -0.21938229f, -0.19580044f, 
    0.21009314f, -0.00878102f, -0.07899477f, 0.10710591f, -0.16925375f, -0.32482633f, -0.22294348f, 0.05272258f, 
    -0.06114515f, 0.24308732f, -0.74455208f, 0.08234943f, 0.04558883f, -0.00614960f, 0.34933573f, -0.25980154f, 
    0.30899090f, 0.00009790f, -0.29902416f, -0.06677472f, 0.16721909f, -0.08614398f, 0.07730643f, 0.22353211f, 
    0.30104393f, 0.07042275f, 0.06825801f, -0.02811922f, 0.13363233f, 0.14402145f, -0.37548792f, -0.16622248f, 
    -0.26094016f, 0.00965953f, 0.20332447f, -0.14765251f, 0.30309340f, 0.24114612f, -0.07734552f, -0.45927808f, 
    -0.44035116f, 0.19512875f, 0.06841709f, -0.05929521f, 0.15429780f, 0.23636501f, 0.06547264f, 0.10834928f, 
    0.11966600f, 0.13040897f, 0.03347300f, -0.21723631f, 0.28253421f, -0.00923690f, 0.17698915f, -0.20663494f, 
    0.35553473f, -0.10076524f, -0.28125480f, 0.21400076f, 0.17287742f, -0.06296123f, 0.22958599f, -0.28998095f, 
    0.01243337f, -0.12928391f, -0.41951245f, 0.07935954f, -0.14414665f, -0.13298412f, 0.31505746f, 0.07828474f, 
    -0.11315088f, -0.18990527f, -0.03460002f, 0.30221692f, 0.16809949f, 0.08321605f, 0.28115433f, -0.28021905f, 
    -0.04046439f, 0.01862919f, 0.18578862f, 0.22121418f, 0.11217010f, 0.40048558f, -0.24755572f, 0.33544412f, 
    -0.03514375f, 0.10984790f, -0.35014954f, -0.62079996f, 0.04062106f, 0.21852274f, 0.16302919f, -0.48333165f, 
    0.48765829f, 0.20117076f, -0.09850674f, 0.04430210f, 0.33519071f, 0.13336153f, 0.18943538f, -0.24170558f, 
    -0.01546154f, -0.10796347f, -0.33455911f, 0.16816019f, -0.13733542f, 0.25736263f, -0.12516086f, -0.44940099f, 
    -0.02926956f, -0.05581705f, 0.07873327f, 0.17537820f, -0.11923336f, 0.20060810f, 0.44765481f, -0.34399581f, 
    -0.09942921f, 0.06684899f, 0.18422975f, -0.15231429f, -0.23814729f, -0.05124285f, 0.06433414f, -0.07604273f, 
    0.04059092f, -0.05830651f, 0.26007217f, -0.00369696f, 0.45688733f, -0.04698985f, 0.50640118f, -0.12052155f, 
    0.11473844f, -0.00523097f, -0.36121115f, -0.17392012f, -0.01907751f, 0.12573303f, -0.19675241f, -0.02551032f, 
    -0.19263905f, 0.08103889f, -0.09664604f, 0.07507342f, 0.02258340f, -0.11932442f, -0.10592195f, -0.03085610f, 
    -0.04928493f, -0.23509037f, -0.10576546f, 0.00708181f, -0.15285805f, -0.20895892f, -0.18241936f, 0.18755594f, 
    0.05382084f, 0.01397143f, -0.36738500f, 0.08523913f, -0.27807617f, 0.26239404f, 0.05913227f, 0.40719816f, 
    -0.24810760f, -0.04123459f, 0.17553484f, 0.28746128f, -0.18763825f, 0.02949660f, 0.13055860f, 0.08140576f, 
    0.11577580f, 0.08821872f, 0.18798307f, -0.07787767f, 0.37341911f, -0.27157092f, 0.44457248f, 0.28202504f, 
    -0.05164566f, 0.03384570f, -0.50243074f, -0.33408320f, 0.02555579f, 0.16479491f, -0.04922882f, 0.27798232f, 
    0.30483556f, -0.01369133f, 0.35626215f, -0.12184157f, -0.06683488f, 0.36321610f, -0.16417904f, -0.00887094f, 
    -0.28321630f, 0.21503581f, -0.38501307f, -0.05233699f, 0.03514647f, -0.01887649f, 0.26374254f, -0.29956225f, 
    -0.20078860f, -0.15168464f, -0.11750563f, -0.05946041f, 0.13425194f, 0.31893122f, 0.05270182f, 0.12847634f, 
    0.02815719f, -0.09416426f, 0.06144856f, 0.28519866f, -0.06690153f, -0.11263333f, -0.01355458f, -0.30704147f, 
    -0.22383308f, -0.04540812f, 0.24006359f, -0.33167621f, 0.13001984f, -0.28590649f, 0.34466538f, 0.09090768f, 
    -0.10112759f, 0.30905053f, 0.03931886f, -0.18891658f, -0.00702244f, -0.00502370f, 0.32524273f, -0.20922701f, 
    0.15329148f, -0.18150619f, -0.33762896f, -0.20361562f, 0.42486891f, -0.48320007f, 0.23071538f, 0.32976201f, 
    0.14504789f, 0.09361114f, 0.03911448f, -0.16197281f, 0.02543094f, 0.16298276f, -0.15505177f, 0.17130539f, 
    0.29915977f, -0.01873198f, -0.14551800f, -0.03115783f, 0.20083754f, 0.26378253f, -0.28193071f, -0.10011253f, 
    0.28474683f, -0.17737366f, -0.09407493f, 0.11268833f, -0.14901312f, 0.06635949f, 0.04116007f, -0.38839182f, 
    0.02992644f, 0.06954622f, 0.23622757f, 0.00921667f, 0.39018816f, 0.09483868f, -0.16690682f, -0.02792737f, 
    0.32628208f, -0.36722374f, -0.05091114f, -0.18315904f, -0.06911784f, -0.23431653f, -0.06985310f, 0.29791495f, 
    0.32750672f, 0.16761160f, 0.24258578f, -0.12431657f, -0.13971762f, 0.03202335f, 0.17338666f, -0.13731545f, 
    -0.15743250f, -0.15054080f, 0.16244684f, -0.17786251f, -0.03138906f, -0.18952388f, 0.07799190f, -0.12048092f, 
    0.16174147f, -0.22038579f, -0.17872863f, 0.05070560f, -0.02888436f, 0.24432333f, -0.00994555f, -0.01145548f, 
    0.22540055f, -0.29284453f, -0.24478737f, 0.23043332f, 0.02141015f, -0.06559443f, 0.27246743f, -0.54387498f, 
    0.24763112f, 0.07407593f, -0.16167566f, -0.22005361f, -0.29045919f, 0.20756254f, 0.32450452f, 0.40846419f, 
    0.11203025f, -0.09979473f, -0.03694237f, -0.04166666f, -0.10401659f, 0.21075651f, -0.15124862f, 0.20568334f, 
    0.24780050f, -0.12127008f, 0.14057772f, -0.04341015f, 0.03838653f, -0.05581466f, 0.21644986f, -0.25547913f, 
    -0.24116796f, 0.32237655f, -0.02720037f, 0.04312128f, 0.15285969f, 0.17637904f, 0.27374128f, 0.09331033f, 
    -0.18657720f, -0.13524123f, 0.05911826f, 0.13892820f, -0.06216794f, -0.05729129f, 0.07066614f, -0.32444069f, 
    -0.08762828f, 0.18892562f, -0.57669139f, 0.02028978f, -0.14214239f, -0.04413727f, 0.45875645f, -0.05363511f, 
    -0.33337042f, 0.14993259f, 0.40110070f, -0.19327933f, 0.15175584f, 0.13456205f, -0.29349047f, -0.13589959f, 
    0.15693627f, 0.13464504f, -0.42144871f, 0.07092969f, -0.14698452f, -0.11054271f, 0.10873649f, 0.08777758f, 
    0.05467002f, -0.12850977f, 0.00530329f, -0.25844559f, -0.18837892f, -0.15056349f, -0.09059171f, 0.10246132f, 
    0.19978847f, -0.33149976f, -0.00031527f, 0.30682540f, 0.18643890f, 0.21466385f, 0.17438596f, 0.14392935f, 
    -0.08436595f, -0.17317483f, 0.18366300f, -0.18912622f, 0.23075782f, -0.24025434f, 0.45907184f, 0.04818811f, 
    0.36717185f, -0.14454113f, -0.19310059f, -0.11147667f, -0.08338645f, -0.14177708f, -0.08870048f, -0.11872363f, 
    0.21654472f, 0.02901806f, -0.34864113f, 0.12475799f, 0.37952229f, 0.26288721f, 0.27083716f, -0.13442212f, 
    -0.24183170f, 0.06421084f, -0.18797623f, 0.27209204f, -0.04514594f, 0.16905661f, -0.07909486f, 0.01018392f, 
    -0.35070959f, -0.16897872f, 0.20510459f, -0.13452707f, 0.29115525f, 0.21823896f, -0.26362085f, 0.44168642f, 
    0.21930350f, 0.30518866f, -0.29532805f, 0.04180353f, 0.13907993f, 0.10418639f, -0.36230114f, -0.39306974f, 
    -0.04553041f, -0.03693247f, 0.15371928f, 0.04474490f, -0.25371793f, 0.06351984f, -0.25164723f, -0.05873020f, 
    -0.13170373f, -0.06148808f, -0.17653984f, -0.06827147f, -0.21899953f, -0.15893030f, 0.05558319f, -0.13865972f, 
    -0.29145476f, 0.20656548f, -0.08446110f, 0.01156565f, 0.15308219f, 0.22435597f, 0.22733621f, 0.44058311f, 
    0.22728638f, 0.04770508f, -0.26185483f, -0.22742657f, -0.15849847f, -0.05171706f, -0.01361414f, -0.08144208f, 
    0.06533702f, 0.20951463f, 0.01624854f, 0.25524119f, 0.27105245f, -0.12113152f, 0.08159020f, 0.15276545f, 
    0.31289035f, -0.14636712f, -0.28670952f, -0.18376428f, -0.17941330f, -0.24115190f, -0.10886116f, -0.01776701f, 
    -0.11314675f, 0.19659482f, -0.13776027f, -0.17334001f, 0.26675138f, 0.05517068f, 0.39569232f, -0.22150423f, 
    0.01896509f, 0.21109593f, -0.20101541f, 0.21662703f, 0.12073940f, 0.22592507f, 0.25157619f, -0.12940276f, 
    -0.01171793f, -0.16965134f, -0.26402649f, -0.39499441f, 0.03050771f, 0.36466238f, 0.28814399f, 0.26243249f, 
    -0.05521732f, 0.14942893f, 0.24363311f, -0.01237086f, -0.25157297f, -0.00974889f, 0.17481737f, -0.30836585f, 
    -0.12761866f, 0.12955089f, 0.08573894f, 0.07884584f, 0.02774639f, -0.59056211f, 0.21458751f, 0.06962418f, 
    0.35777652f, -0.06853174f, 0.25751919f, -0.29549539f, 0.12156823f, -0.00202315f, -0.20767115f, 0.18481492f, 
    0.39104128f, -0.16491248f, -0.06725781f, 0.07334013f, 0.25768143f, -0.00849483f, 0.10956294f, 0.35514769f, 
    0.34602681f, -0.14187276f, -0.11557194f, -0.18093348f, 0.04754032f, 0.23694925f, -0.09791272f, -0.12904277f, 
    -0.37024495f, 0.13735980f, 0.14202443f, 0.27930152f, -0.35672024f, -0.02923233f, -0.02518125f, 0.22698064f, 
    0.12363210f, 0.15617226f, 0.28683385f, -0.35532784f, 0.17185742f, 0.18613607f, 0.07354615f, 0.21299095f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.21201387f, 0.45216763f, -0.58736718f, 0.07774702f, 0.08638190f, -0.17614780f, 0.03021290f, 0.22254671f, 
    0.52513957f, 0.02251020f, -0.12965891f, 0.24455169f, -0.01272944f, -0.01961368f, -0.29223096f, 0.43617934f, 
    -0.18515068f, -0.06487858f, -0.02322384f, 0.17781126f, -0.08140849f, -0.28209785f, -0.07119512f, 0.45341960f, 
    0.17780194f, -0.14413950f, -0.12151069f, 0.32040688f, 0.14984439f, 0.16186051f, 0.20964272f, -0.18701679f, 
    -0.20970151f, 0.10606613f, -0.23689061f, -0.19024502f, -0.05850501f, 0.06315966f, 0.46130219f, -0.03815832f, 
    -0.11421489f, -0.10358166f, 0.00242653f, 0.31327817f, 0.01429329f, -0.37026176f, 0.23228383f, 0.09008130f, 
    0.55755502f, -0.15948199f, 0.52743733f, -0.31950948f, 0.07098270f, -0.17159007f, -0.07900911f, -0.06453028f, 
    -0.19470990f, -0.28341892f, 0.33103573f, 0.12877825f, 0.31635058f, 0.27421990f, 0.06142227f, 0.21983989f, 
    -0.28226528f, 0.42856652f, -0.12591957f, 0.34037766f, 0.36651054f, 0.33143580f, 0.01442604f, 0.04774123f, 
    -0.20361055f, -0.02124115f, -0.08732458f, 0.11555631f, 0.37305710f, 0.06817307f, -0.11585859f, -0.21920238f, 
    -0.27585012f, -0.18226601f, 0.06069657f, 0.26402950f, 0.41505519f, 0.46810484f, 0.02423456f, 0.11202647f, 
    0.05160195f, 0.47667453f, -0.28373405f, -0.32844260f, 0.42700389f, -0.20330231f, -0.18003003f, 0.25295082f, 
    0.24422087f, -0.12046896f, 0.11496931f, 0.24536195f, 0.03315402f, -0.15945494f, -0.01155976f, -0.31646454f, 
    0.42848715f, 0.11941569f, 0.28807947f, -0.05883845f, 0.14705944f, -0.31073532f, -0.08210998f, 0.25583798f, 
    0.03887098f, 0.23849587f, 0.46852431f, -0.01899193f, 0.42555758f, 0.04061328f, 0.17858496f, -0.19113362f, 
    -0.16395675f, 0.01083861f, 0.28722045f, 0.13569033f, 0.20150633f, 0.00903969f, 0.18016674f, -0.12452317f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.08767071f, -0.00196747f, 0.23342220f, -0.01806230f, 0.09924497f, 0.44789827f, -0.25415006f, 0.28498721f, 
    0.13145076f, -0.10201114f, 0.00123103f, -0.11899909f, -0.02343622f, -0.13780192f, -0.14438225f, 0.37758783f, 
    0.07140575f, 0.03200268f, -0.49731651f, -0.00393939f, -0.45399439f, -0.30302721f, -0.04474564f, -0.10910988f, 
    -0.02902374f, -0.36073974f, 0.17810310f, 0.18984862f, 0.15778752f, 0.10833291f, 0.01270000f, 0.47769171f, 
    -0.03509079f, -0.24564789f, -0.58963203f, 0.24926279f, 0.37530121f, -0.17357475f, -0.01599829f, 0.16874900f, 
    -0.48544174f, -0.31995329f, 0.11386533f, 0.19102485f, -0.11297589f, -0.54091769f, -0.28506148f, 0.04982580f, 
    0.24788207f, -0.20516396f, -0.03739520f, -0.37013325f, -0.53310686f, -0.16940832f, 0.35662723f, 0.23099661f, 
    -0.22116059f, 0.20478815f, -0.30004707f, -0.07747240f, 0.20418920f, 0.14342622f, -0.08219325f, 0.20160395f, 
    -0.01339867f, 0.08912041f, -0.30968842f, -0.05395834f, 0.09783047f, -0.01106688f, -0.37788209f, -0.01834134f, 
    -0.03194641f, 0.13403377f, -0.24109277f, 0.18776773f, -0.00935650f, 0.05527286f, -0.02483689f, 0.02081978f, 
    0.03748101f, 0.11554143f, -0.08957618f, -0.19432883f, 0.04133759f, -0.01552697f, -0.02056352f, -0.09072607f, 
    0.24058048f, -0.00824952f, 0.10894158f, 0.19682176f, 0.19759363f, 0.04259896f, -0.12583569f, -0.03582472f, 
    0.02578246f, -0.00149845f, -0.18041788f, -0.04713829f, 0.06723021f, 0.02425911f, -0.14728138f, 0.40322345f, 
    0.14322980f, -0.33409935f, 0.04320475f, 0.09068260f, 0.03864931f, 0.25747308f, -0.09423605f, 0.05814793f, 
    0.02651034f, -0.09604581f, 0.02130844f, 0.11556105f, 0.14573218f, 0.17332101f, -0.36142036f, 0.15411948f, 
    0.11256811f, 0.11126915f, 0.11185367f, -0.08450782f, -0.08754162f, 0.10082614f, 0.06252417f, -0.05414550f, 
    0.20986205f, -0.08813749f, -0.06350687f, -0.02902504f, 0.24033961f, 0.08439345f, 0.20157692f, 0.17469501f, 
    0.08030777f, 0.18720186f, 0.08616671f, 0.06953718f, -0.41649503f, -0.20679022f, 0.05041515f, 0.12277548f, 
    0.00729093f, -0.07680078f, 0.16945253f, 0.08190842f, -0.20882142f, -0.47033876f, -0.13171273f, -0.22975501f, 
    0.30010277f, -0.31910056f, -0.26168463f, 0.14709155f, 0.14945804f, 0.15057147f, -0.09415548f, 0.31849492f, 
    0.13937078f, -0.00821755f, -0.20512532f, -0.21652506f, 0.38091633f, -0.48466623f, -0.00764146f, 0.16035908f, 
    0.02594528f, 0.10083108f, 0.05340490f, 0.07375224f, -0.45281002f, 0.11482756f, 0.16110498f, 0.20947905f, 
    0.15584630f, 0.44618016f, -0.08655044f, -0.20444241f, -0.13854520f, 0.24500908f, 0.16490762f, -0.32057968f, 
    0.20260020f, 0.20550255f, -0.06505156f, -0.06458088f, -0.11280913f, 0.07425322f, -0.35450053f, 0.08335345f, 
    -0.33962491f, 0.20008628f, 0.00834249f, -0.38720176f, -0.23484473f, -0.05735267f, 0.16291094f, 0.09357756f, 
    -0.28735846f, 0.15215580f, 0.15750778f, 0.18189611f, 0.00577559f, 0.12616792f, -0.14789461f, 0.06605560f, 
    0.03661454f, -0.02758004f, -0.04840906f, -0.08451975f, 0.04251665f, 0.12441417f, 0.02921405f, 0.00979046f, 
    0.14822905f, -0.02580018f, 0.07803138f, 0.05926980f, 0.06457335f, 0.19740874f, -0.06002529f, -0.02682256f, 
    0.10372045f, 0.35352385f, -0.12857643f, -0.19289760f, -0.21093552f, 0.01738819f, 0.05025153f, -0.05492905f, 
    -0.02752884f, -0.07591318f, -0.16602451f, 0.10423935f, 0.22367665f, 0.07463224f, 0.11536182f, 0.11454853f, 
    0.24318869f, -0.35456681f, -0.10967533f, -0.13552283f, 0.01289490f, 0.26039183f, -0.14508206f, 0.02592014f, 
    -0.08406898f, 0.14020158f, 0.20775475f, -0.20926161f, 0.00410846f, -0.04681973f, 0.28823823f, 0.06621631f, 
    0.06170496f, -0.04171585f, 0.05461336f, -0.04309674f, 0.01172229f, -0.02899058f, 0.03229408f, 0.05189605f, 
    -0.03279387f, -0.01336779f, 0.02204997f, 0.06418525f, -0.08056302f, -0.08741419f, 0.06611346f, 0.06230215f, 
    -0.00370148f, 0.05893031f, -0.04933810f, 0.01255213f, -0.00612980f, 0.04268757f, 0.07438332f, 0.00086754f, 
    -0.07435369f, 0.00536952f, -0.02328279f, -0.01455667f, 0.08556592f, 0.00626131f, -0.04148924f, -0.05445340f, 
    -0.04732480f, 0.07106113f, -0.09388156f, -0.07896639f, -0.01816788f, 0.04085103f, -0.01553231f, -0.06983373f, 
    -0.02699694f, -0.08614496f, -0.06699558f, -0.01013882f, 0.03772766f, -0.05976786f, -0.07133054f, 0.02277339f, 
    0.01887003f, 0.01609824f, -0.02536185f, 0.04690498f, 0.04086757f, 0.00983844f, -0.01170156f, 0.06352170f, 
    0.06203583f, 0.02697297f, -0.00231685f, 0.00358963f, 0.01696437f, 0.06836305f, 0.05311804f, -0.06592764f, 
    -0.01500182f, -0.06270756f, 0.08148487f, 0.05631910f, -0.07085970f, -0.05543219f, 0.07015743f, 0.05582953f, 
    -0.02930425f, -0.05192946f, -0.02585637f, -0.07273865f, -0.05102688f, -0.04510062f, -0.04136346f, -0.08084814f, 
    0.01753440f, -0.04963925f, 0.05685810f, -0.02327891f, -0.01917910f, -0.03085890f, -0.03512875f, -0.07698406f, 
    -0.07784829f, -0.03629897f, 0.05118620f, -0.00766339f, -0.08417093f, 0.02812893f, 0.03736016f, 0.01102843f, 
    0.04630365f, -0.03408752f, -0.00735350f, -0.09194557f, -0.04969547f, -0.08496467f, -0.05039151f, -0.04341180f, 
    0.01748087f, -0.02272509f, -0.09225399f, 0.05823699f, 0.03887133f, -0.02794010f, 0.08077341f, -0.07003360f, 
    -0.08875728f, -0.09153444f, -0.01408299f, -0.06012647f, -0.02084159f, -0.03323632f, 0.03361917f, 0.00889212f, 
    -0.00352387f, 0.04550656f, -0.05148586f, -0.01355104f, -0.02059187f, -0.08116249f, 0.03004279f, 0.06818718f, 
    -0.55118603f, 0.13193397f, -0.10990914f, 0.07024310f, -0.19557711f, -0.20839106f, -0.08023854f, -0.15343805f, 
    0.19700032f, 0.08229961f, -0.07893186f, -0.26786533f, 0.02901184f, 0.12039402f, 0.01515322f, -0.26902607f, 
    -0.08165074f, -0.05564196f, -0.29485077f, 0.08649593f, 0.03312129f, 0.11088337f, -0.02349438f, 0.30491099f, 
    -0.37141365f, 0.15096939f, 0.24942975f, -0.05509398f, 0.40882295f, 0.07176569f, -0.03587495f, 0.05080461f, 
    -0.19032422f, 0.25450808f, -0.06527656f, 0.12478778f, -0.38455766f, -0.11092032f, 0.07629874f, -0.43228829f, 
    -0.02261992f, -0.00504107f, -0.08721084f, -0.23506424f, 0.13345584f, 0.11066494f, 0.02155891f, -0.37437356f, 
    -0.01310336f, -0.07413391f, 0.15053360f, 0.19138026f, 0.24861155f, -0.54295194f, -0.41308257f, 0.13518390f, 
    -0.57707620f, -0.22976466f, 0.10540470f, 0.07695344f, -0.02617126f, -0.02712968f, 0.19708499f, 0.13613777f, 
    -0.00784732f, 0.13185267f, -0.04641700f, 0.08973369f, 0.21899903f, 0.33995983f, 0.00328942f, -0.21214081f, 
    0.05391947f, -0.03506780f, -0.22835177f, 0.04656292f, 0.45954710f, 0.07339384f, 0.13783017f, -0.02183756f, 
    -0.06427258f, 0.08249208f, -0.03061349f, 0.07622817f, 0.16920549f, -0.06107676f, -0.14754328f, 0.05727550f, 
    -0.16870339f, 0.20936489f, -0.14198947f, -0.08037844f, 0.19065744f, -0.21744488f, 0.25083882f, 0.07346243f, 
    -0.12481882f, -0.04567876f, 0.12922662f, 0.15577787f, 0.14666514f, -0.01346353f, -0.06781283f, 0.06293746f, 
    0.11236148f, -0.01176884f, 0.11922225f, 0.02340351f, -0.00607095f, -0.05199844f, -0.00969820f, 0.06581028f, 
    -0.20651887f, 0.18485104f, 0.16736831f, 0.08713729f, -0.16198282f, 0.08418731f, 0.28680369f, 0.14755656f, 
    0.02290315f, -0.01818439f, 0.04443567f, 0.15196297f, 0.04888697f, -0.25879097f, -0.06416796f, -0.14163272f, 
    0.05156572f, -0.12908584f, -0.11508831f, -0.05526401f, -0.03978547f, 0.13569278f, -0.18617789f, -0.03123878f, 
    0.27475312f, -0.04207280f, -0.03914857f, -0.08631251f, 0.11599107f, -0.15628687f, -0.01733619f, 0.37381431f, 
    -0.02745599f, 0.00457082f, -0.08628661f, -0.17700292f, 0.00030953f, -0.18253694f, -0.10117682f, 0.14241508f, 
    -0.03942793f, 0.07437895f, 0.10425986f, 0.01437677f, 0.27019513f, 0.15479033f, 0.19657999f, 0.17217469f, 
    0.06750983f, 0.02902825f, -0.12511127f, 0.16059235f, 0.44239396f, 0.20659348f, 0.31682998f, 0.02920177f, 
    0.01931423f, 0.02139590f, 0.19323875f, 0.12884481f, 0.09795177f, -0.24726999f, -0.22748134f, -0.02228480f, 
    0.14860889f, -0.46693271f, 0.10580925f, -0.02637044f, -0.33257970f, -0.19446139f, 0.15341900f, 0.26121151f, 
    -0.39709124f, 0.00230675f, 0.14881584f, 0.00655348f, 0.09167325f, 0.28490496f, -0.01531493f, 0.15822744f, 
    0.12217649f, 0.08067743f, -0.12974030f, 0.07753159f, 0.14012662f, 0.19872636f, -0.10328442f, 0.20049208f, 
    -0.16394015f, 0.22011451f, -0.16583955f, 0.11603845f, -0.02253915f, 0.09086765f, -0.00057312f, -0.05016590f, 
    0.19966744f, -0.50047606f, -0.01374861f, 0.20471489f, 0.12461098f, 0.05744863f, -0.17785157f, 0.02867867f, 
    -0.01927722f, 0.13469777f, -0.01031507f, -0.05247023f, 0.04534693f, 0.17257039f, -0.16057919f, 0.32221630f, 
    0.12295081f, -0.13835274f, 0.25428540f, -0.05268336f, 0.26791763f, -0.07676212f, -0.12318574f, -0.02127649f, 
    0.10673469f, 0.09885134f, 0.02028761f, 0.03703298f, 0.07503211f, -0.02467210f, -0.17743802f, 0.21313670f, 
    0.08771452f, 0.09677569f, -0.14282656f, 0.26058149f, 0.14051089f, 0.20406123f, 0.09344352f, 0.05358159f, 
    0.11172874f, -0.09970914f, 0.08733752f, 0.18509081f, -0.01114762f, -0.16193168f, -0.03348273f, -0.18893297f, 
    -0.06630455f, 0.03543837f, -0.02077636f, -0.05731346f, 0.05283123f, -0.07342194f, 0.01791861f, -0.01021787f, 
    -0.06657535f, -0.08244752f, -0.05999509f, -0.04223603f, 0.02422940f, 0.01372939f, -0.11612356f, -0.07065647f, 
    -0.03338166f, 0.08658345f, -0.08823127f, -0.06487510f, -0.00424489f, -0.07680764f, 0.03955569f, -0.06292950f, 
    -0.01876077f, -0.04459142f, -0.01835236f, -0.07049136f, -0.07423285f, 0.04579490f, -0.07043009f, -0.05370105f, 
    -0.03845927f, -0.03524525f, 0.03361864f, -0.03277468f, 0.06906825f, 0.00534828f, -0.09118708f, 0.08517479f, 
    0.00579746f, -0.04962499f, 0.00185223f, -0.08929795f, 0.01325679f, -0.05436815f, 0.06519529f, 0.01499105f, 
    -0.04981527f, -0.02880744f, -0.02927784f, 0.00008948f, -0.08890140f, 0.00950447f, 0.00259390f, 0.01501003f, 
    -0.06863032f, -0.01344843f, 0.05413560f, -0.04266046f, -0.10751673f, -0.05709232f, -0.02291784f, -0.03846113f, 
    0.04360537f, 0.05987583f, -0.05019717f, 0.03546154f, -0.01094442f, 0.04594414f, -0.03194363f, -0.10009203f, 
    -0.08411116f, 0.02400521f, -0.05733545f, 0.03837176f, -0.08631775f, -0.00879171f, -0.01115383f, 0.08067779f, 
    0.00877406f, -0.02160487f, -0.02328918f, 0.04909640f, 0.04570181f, 0.00993690f, 0.00751791f, 0.08134358f, 
    -0.03062790f, -0.09257382f, -0.05819268f, 0.04029040f, 0.00216411f, -0.06790407f, 0.00753223f, 0.01935045f, 
    -0.04592950f, -0.06843457f, 0.01865186f, -0.05812984f, -0.04893573f, -0.01740440f, -0.05459834f, 0.01880172f, 
    -0.06077904f, -0.04221890f, 0.03869160f, 0.06301088f, 0.03309919f, 0.01265599f, 0.06529354f, 0.00173902f, 
    0.06973009f, 0.04272792f, -0.05273234f, -0.10610486f, 0.00598643f, -0.01369632f, -0.08028194f, 0.06613541f, 
    -0.02055426f, -0.05566079f, 0.01794417f, 0.04791565f, -0.04107834f, 0.05029849f, 0.00175518f, -0.10035560f, 
    0.03478747f, -0.05097575f, -0.00745112f, 0.09992061f, 0.12797211f, 0.10047223f, -0.03323229f, -0.20579587f, 
    -0.12016637f, -0.05459378f, -0.07571243f, -0.13154678f, -0.01706498f, 0.15370536f, 0.20594925f, -0.34378666f, 
    -0.04595277f, -0.08120947f, 0.10205089f, -0.00820189f, -0.11306926f, 0.33445552f, 0.23494528f, -0.07867680f, 
    -0.28772780f, 0.09178430f, 0.13853040f, -0.03486292f, -0.19949932f, 0.08775715f, -0.36278185f, -0.11599024f, 
    -0.08460496f, -0.04372570f, 0.02606491f, 0.04637851f, 0.00409626f, 0.26186085f, 0.10268346f, -0.15816212f, 
    -0.08914862f, 0.13014306f, -0.08858672f, 0.15289876f, 0.12037143f, -0.11509222f, -0.35888863f, 0.15549679f, 
    -0.12164712f, 0.11468561f, 0.00925753f, 0.34102899f, 0.21129808f, -0.02308035f, -0.02558174f, -0.12891680f, 
    0.05598987f, -0.01803067f, -0.06077770f, -0.07936268f, 0.05405114f, -0.40734771f, 0.09191179f, -0.23867394f, 
    0.22835107f, -0.16058850f, 0.11412826f, 0.08124553f, -0.13970387f, -0.22567268f, -0.06618255f, -0.34704235f, 
    0.42922360f, -0.20109496f, -0.10593933f, -0.36089629f, -0.28134134f, 0.16849326f, -0.05804928f, 0.07580093f, 
    0.10274415f, 0.11634113f, 0.17926748f, 0.04701482f, -0.12622917f, -0.18583456f, 0.20598398f, -0.01215733f, 
    -0.15909539f, -0.17432794f, 0.07832003f, 0.01071947f, -0.16045636f, -0.07590657f, 0.27298042f, 0.09402724f, 
    -0.24285337f, 0.19889124f, 0.10675318f, -0.01772519f, -0.04275356f, -0.02617354f, 0.00035721f, -0.01883075f, 
    0.06372187f, 0.16054203f, -0.07305101f, 0.11313935f, 0.08364870f, 0.04146171f, 0.09650365f, -0.27313313f, 
    0.01888737f, 0.08304010f, -0.60031706f, -0.01696710f, -0.16053367f, 0.14421609f, 0.09240258f, 0.24133492f, 
    -0.01402545f, 0.09165749f, -0.04507453f, -0.03770835f, 0.08928516f, -0.00259094f, 0.03847882f, -0.14455873f, 
    -0.14442155f, 0.24244037f, -0.11431933f, 0.07926016f, 0.10679853f, -0.33829629f, -0.26477233f, -0.42986494f, 
    0.07960770f, 0.05951995f, -0.06140839f, 0.48977864f, 0.12466294f, 0.14481243f, -0.03694659f, -0.51694643f, 
    -0.07721666f, 0.01525823f, 0.29832083f, 0.13843459f, -0.27679586f, 0.14461829f, 0.04968475f, 0.16980006f, 
    -0.42815843f, 0.09734379f, -0.01665650f, -0.58480263f, -0.15869251f, 0.03404627f, 0.18937753f, -0.19212918f, 
    -0.19909154f, -0.82691002f, 0.11153428f, -0.05978195f, -0.14306994f, -0.24678610f, 0.17350408f, -0.17979616f, 
    -0.37985191f, 0.07494583f, -0.34367329f, 0.04421091f, 0.05184349f, -0.06765574f, 0.17543250f, 0.39619088f, 
    0.44146624f, -0.32737163f, 0.13495043f, 0.03128789f, 0.27809042f, -0.00285254f, 0.29470468f, -0.04118699f, 
    -0.08834378f, 0.01767275f, 0.19776326f, -0.17558677f, 0.02485411f, -0.16727927f, 0.13928051f, -0.14392214f, 
    -0.01948432f, -0.08979055f, -0.00147709f, 0.10482303f, -0.11618271f, -0.18387423f, 0.12048738f, -0.30692008f, 
    0.05684957f, 0.06579251f, -0.12328125f, -0.12463169f, -0.01572428f, -0.14377955f, 0.02024893f, -0.00029191f, 
    -0.30026445f, -0.06199170f, 0.13609716f, 0.16998793f, 0.04550326f, -0.51821315f, -0.08250192f, 0.02589524f, 
    0.13947368f, 0.18751337f, 0.23976593f, -0.24111888f, -0.18324673f, -0.36527476f, -0.10874087f, 0.08904279f, 
    -0.07565977f, -0.03432385f, -0.05777964f, 0.19383767f, -0.07058076f, 0.05398404f, -0.19758935f, -0.36051029f, 
    0.14574052f, 0.06682087f, 0.22942838f, -0.36858007f, 0.00763332f, -0.09576797f, 0.14778042f, -0.41445783f, 
    -0.29490706f, 0.19506773f, -0.04644622f, 0.12843129f, 0.03106559f, -0.33017373f, 0.07043075f, -0.12339802f, 
    0.02362712f, -0.86334252f, -0.75156969f, 0.05600911f, 0.08382984f, -0.18621671f, -0.60508513f, 0.09286258f, 
    0.12355047f, 0.12243965f, -0.33231020f, -0.23306556f, 0.06388545f, 0.08568654f, -0.12077818f, -0.20004924f, 
    -0.12975919f, -0.11766560f, 0.03985734f, -0.07493529f, -0.18282293f, 0.12897891f, 0.14416163f, -0.10711730f, 
    0.06995949f, -0.00175662f, -0.35752821f, 0.05766042f, -0.10654322f, 0.44430545f, 0.04086972f, -0.02529030f, 
    -0.20876116f, 0.06221847f, 0.25260764f, -0.11508120f, -0.06415139f, 0.00736439f, -0.25204730f, -0.24196936f, 
    0.03197921f, -0.34737328f, 0.23697577f, 0.17972434f, -0.24588771f, -0.28762582f, -0.11439858f, -0.11830679f, 
    -0.19200926f, -0.28488138f, 0.28504440f, 0.28753802f, 0.13822791f, -0.28235340f, 0.07144365f, 0.14888993f, 
    -0.18999079f, -0.04377208f, 0.12143449f, -0.14900358f, 0.04268219f, 0.08797082f, -0.03720975f, -0.24190055f, 
    0.00918774f, 0.06334777f, -0.25072518f, 0.12147816f, 0.08928559f, 0.03588755f, -0.02025861f, -0.37232965f, 
    0.18324611f, -0.09973723f, -0.05465069f, 0.16667658f, 0.03278696f, -0.36750713f, -0.29822353f, -0.06995884f, 
    0.28480229f, -0.03804403f, 0.05161293f, -0.25336060f, -0.22930016f, 0.10436527f, 0.13662730f, -0.11685482f, 
    0.12919308f, -0.40241551f, 0.21750486f, 0.06143805f, 0.02505318f, 0.08038124f, -0.10231689f, -0.00355662f, 
    -0.09990720f, -0.06695472f, 0.23619950f, 0.06204088f, -0.08174369f, 0.07300464f, -0.00184235f, -0.01703551f, 
    0.03611630f, -0.05743084f, -0.01528346f, -0.13487624f, 0.13999988f, 0.01199654f, 0.09086450f, 0.15916720f, 
    0.13678573f, 0.22694653f, 0.26020527f, 0.13447085f, -0.26911712f, -0.23185126f, 0.20609829f, -0.18650554f, 
    0.19013652f, 0.03170008f, -0.34323707f, -0.10373307f, -0.09627763f, 0.16927195f, 0.09773632f, 0.13423941f, 
    -0.00679731f, 0.12945189f, -0.06513795f, 0.00342673f, 0.41533673f, -0.14155784f, 0.10043460f, -0.00563067f, 
    0.20331299f, 0.04388355f, 0.61892712f, 0.03499525f, -0.10727090f, -0.13152169f, 0.08047563f, 0.02977598f, 
    0.18200132f, 0.18803360f, 0.07535214f, 0.21023142f, -0.10061965f, -0.03236395f, -0.19142601f, 0.10420137f, 
    0.02960868f, -0.03228888f, -0.06777365f, 0.13206096f, -0.38097864f, 0.15853751f, 0.00328782f, 0.27695468f, 
    -0.00010117f, 0.08961155f, 0.05770611f, 0.10710078f, -0.01040657f, 0.19320710f, 0.09194169f, -0.02024038f, 
    0.06750985f, -0.15292010f, 0.10860320f, -0.22191513f, 0.23033051f, 0.06184515f, 0.14513558f, -0.18207517f, 
    0.07711461f, -0.05830189f, 0.29795909f, 0.12161595f, -0.17849684f, -0.34469533f, 0.19135742f, -0.04452749f, 
    0.19872352f, -0.21377747f, 0.08196937f, -0.06978061f, 0.26919988f, 0.00458049f, -0.41708732f, -0.24184294f, 
    0.38488549f, -0.08432128f, 0.21685813f, -0.01712803f, 0.05947152f, -0.01880761f, 0.07468447f, -0.02787890f, 
    -0.17987260f, 0.20494850f, -0.18082991f, 0.12205404f, 0.09823402f, 0.08272290f, -0.08107700f, 0.13216819f, 
    -0.23427166f, -0.01761672f, -0.25719917f, 0.02252904f, 0.31121734f, 0.03269373f, 0.10840967f, 0.00785707f, 
    0.01089465f, -0.08953469f, 0.21832787f, 0.14561668f, 0.10083232f, -0.01695724f, -0.41772014f, 0.04364446f, 
    -0.12307275f, 0.27839166f, -0.09651584f, -0.15186086f, 0.14609312f, 0.02481448f, -0.27150622f, 0.08332450f, 
    0.23489779f, -0.30893719f, 0.31136745f, -0.00156231f, -0.06803979f, -0.08675130f, 0.03115443f, -0.07807444f, 
    0.19510950f, 0.03045970f, 0.11589850f, 0.01327143f, 0.13113220f, -0.17587194f, 0.12696916f, 0.05095034f, 
    -0.02796606f, 0.00517589f, 0.24037853f, 0.01158042f, -0.00994490f, -0.20438132f, 0.14431086f, -0.09758462f, 
    0.03553553f, -0.11957752f, -0.01927413f, 0.12195820f, 0.02761769f, -0.26665410f, -0.09817248f, -0.17539145f, 
    -0.00870924f, 0.11713591f, -0.21131338f, 0.11118017f, -0.10815347f, 0.06113768f, -0.04613198f, 0.13401918f, 
    0.07847261f, 0.01014159f, 0.08382205f, 0.10593694f, -0.08016519f, 0.02628977f, -0.12647924f, 0.47295731f, 
    -0.03564670f, -0.08036573f, 0.04893339f, -0.13018259f, 0.12925427f, -0.16483051f, -0.02804219f, 0.16385645f, 
    0.15135457f, -0.08817272f, -0.03792983f, 0.06022417f, 0.07587913f, 0.09593267f, 0.05535787f, 0.11931835f, 
    -0.12521909f, 0.15630007f, -0.14590204f, 0.08831495f, 0.31292757f, 0.29956701f, -0.00163433f, 0.10760838f, 
    -0.06451875f, -0.10328715f, 0.07753671f, 0.14507537f, 0.07065059f, -0.00710224f, -0.11145560f, -0.05525649f, 
    0.21620913f, -0.39344427f, -0.00554400f, -0.09623393f, -0.22246905f, -0.10499346f, 0.10883757f, 0.25883853f, 
    -0.03981075f, 0.07909573f, 0.11431676f, -0.09112830f, 0.02772910f, -0.05577490f, 0.30585805f, 0.18496627f, 
    0.04288620f, 0.17593312f, -0.17569110f, 0.00412422f, 0.19576381f, 0.29480571f, -0.09845164f, 0.12202548f, 
    -0.10184395f, 0.07992086f, -0.37420100f, 0.20654461f, 0.06089583f, -0.11491457f, 0.00820854f, -0.11254895f, 
    -0.05727070f, 0.09958615f, -0.11048354f, 0.05526073f, 0.07916029f, 0.01013231f, 0.11294971f, -0.05972924f, 
    0.11843331f, 0.19644555f, 0.04904233f, 0.00507406f, 0.09514832f, -0.08519185f, 0.15569709f, 0.00356917f, 
    0.01931427f, -0.16939957f, 0.11156137f, 0.00711770f, 0.02302305f, -0.02475200f, -0.15749177f, 0.01930632f, 
    0.10830506f, -0.19961205f, 0.02473004f, -0.09705609f, 0.13343409f, -0.19529833f, -0.28785589f, 0.17529574f, 
    -0.05173922f, 0.16038117f, 0.11844572f, -0.13003618f, 0.09629716f, 0.01551324f, 0.00000776f, -0.27829203f, 
    -0.02843816f, -0.10880056f, -0.06774940f, -0.04775787f, 0.03832176f, 0.00037516f, 0.03634707f, -0.04146895f, 
    0.07368480f, 0.05353139f, 0.05317205f, -0.03657262f, 0.01081701f, 0.06120664f, -0.02578150f, -0.07515012f, 
    -0.08445271f, -0.08402539f, -0.00758500f, -0.08593616f, -0.01357484f, 0.03710244f, -0.03958482f, -0.08894420f, 
    0.08514117f, 0.05897820f, -0.07675442f, -0.04214870f, -0.03545972f, -0.08804878f, -0.08187326f, -0.05905433f, 
    -0.00735544f, 0.02744028f, -0.03875287f, 0.02998887f, -0.07557241f, 0.03988031f, -0.04478237f, 0.05894152f, 
    -0.03047905f, 0.01754474f, 0.02015905f, -0.07529233f, 0.08735643f, -0.03770506f, 0.02607079f, 0.00019453f, 
    0.02633241f, -0.00353003f, -0.00012939f, -0.05126752f, 0.04517864f, 0.05177732f, 0.02440218f, 0.03866795f, 
    -0.06841747f, 0.06451493f, -0.03626782f, 0.04864962f, -0.03789662f, -0.03074619f, 0.05166765f, -0.09386934f, 
    0.03483557f, 0.04777064f, -0.07596568f, 0.04303194f, -0.03996280f, -0.04512791f, 0.03205574f, -0.00943807f, 
    -0.08582875f, 0.06550228f, 0.03861963f, 0.01366040f, -0.06125741f, -0.06060682f, 0.01880382f, -0.01854442f, 
    -0.03506773f, -0.09808069f, -0.04958719f, -0.06727025f, -0.07684949f, -0.02136911f, -0.04538831f, 0.03403283f, 
    -0.04454036f, 0.00213790f, -0.06472123f, -0.04068648f, 0.00491031f, -0.06648239f, -0.03298008f, 0.02338993f, 
    0.00329727f, -0.01293498f, 0.02372250f, -0.02344812f, -0.07968190f, -0.07979635f, -0.07376665f, -0.01303117f, 
    0.04315103f, -0.02826506f, -0.06589738f, 0.00581578f, 0.05002349f, -0.01133762f, 0.00577902f, 0.00459951f, 
    0.04079887f, -0.02227570f, 0.00772166f, -0.07492357f, 0.03724413f, -0.05923120f, 0.03591569f, -0.06563713f, 
    0.04828923f, 0.00205201f, 0.03866784f, 0.02142773f, 0.00736268f, -0.09821416f, -0.06757867f, 0.05094104f, 
    0.00279835f, -0.06158982f, -0.00390921f, -0.05927008f, 0.02927973f, 0.00252608f, -0.08479795f, -0.04789624f, 
    0.19250500f, 0.26033422f, 0.08330873f, 0.11770326f, 0.18846689f, 0.33137411f, -0.06279437f, 0.03883229f, 
    -0.05156605f, 0.03761623f, 0.05693009f, -0.11588355f, 0.01957184f, 0.05894928f, 0.04273393f, -0.03401316f, 
    -0.04269473f, 0.07211336f, -0.35846037f, -0.09040576f, -0.10496389f, -0.03461942f, 0.20228359f, 0.24454643f, 
    -0.25444287f, -0.03853696f, 0.28363514f, 0.09366895f, 0.00253258f, -0.07932414f, 0.00291298f, -0.13157651f, 
    0.05455044f, -0.42149708f, 0.09148311f, 0.12653761f, 0.15735580f, -0.20275947f, -0.00483884f, -0.00226971f, 
    -0.23135546f, 0.02194037f, 0.01593650f, 0.35294750f, -0.02337098f, -0.13445298f, 0.31652305f, 0.07993686f, 
    0.27893904f, 0.04355871f, 0.09069709f, -0.35820344f, -0.00285782f, -0.10734908f, 0.06398905f, 0.07980229f, 
    -0.07504372f, 0.04664217f, -0.07555084f, -0.01033198f, -0.00706239f, 0.11294940f, 0.39482313f, -0.01719171f, 
    0.18211982f, 0.03851809f, -0.23395708f, 0.03673559f, -0.15823531f, -0.23389655f, -0.08175506f, 0.15043889f, 
    -0.02473342f, 0.22162393f, 0.02128052f, 0.12915145f, -0.03205805f, -0.02813984f, 0.32351738f, 0.05780316f, 
    -0.06299885f, 0.36541846f, 0.16014792f, -0.14436840f, -0.04849739f, 0.07969035f, -0.02247756f, 0.02873836f, 
    0.25930792f, 0.13520104f, 0.02143040f, -0.05710992f, 0.15903744f, -0.09374320f, -0.00963825f, 0.01770390f, 
    0.04389981f, 0.18352120f, -0.17536657f, -0.02684922f, -0.17737821f, 0.08589852f, 0.17773348f, 0.04827490f, 
    0.21134475f, 0.04184749f, 0.09809026f, -0.02973692f, 0.05258549f, 0.02914763f, -0.01720899f, 0.06875867f, 
    0.04807375f, 0.14759737f, 0.06322569f, -0.03358418f, -0.01723944f, -0.16428526f, 0.03472536f, 0.10901619f, 
    -0.00607383f, -0.05437231f, -0.06029978f, -0.03827541f, 0.08988169f, -0.27721512f, -0.01509735f, -0.06774023f, 
    0.08514367f, -0.13042964f, -0.19026278f, -0.27411368f, -0.05690358f, -0.01613886f, 0.09371429f, -0.13240488f, 
    0.23330101f, 0.01351871f, 0.02684043f, 0.05868877f, -0.04359599f, -0.08092972f, -0.12488466f, 0.22388972f, 
    0.04569080f, -0.06440672f, -0.03502242f, 0.02352565f, -0.07373074f, 0.17753673f, -0.13657415f, 0.01184763f, 
    0.14492622f, 0.02189530f, 0.18991594f, -0.15287784f, 0.20026641f, 0.15362278f, -0.00318067f, -0.07725190f, 
    0.01239074f, 0.25772202f, 0.07424619f, 0.07156497f, 0.26759040f, 0.39858314f, 0.14949584f, -0.06012738f, 
    -0.07190506f, -0.15629961f, 0.33427104f, 0.01398216f, -0.08798895f, -0.38775808f, -0.05733795f, 0.06312659f, 
    -0.16937070f, -0.43712202f, -0.06273412f, 0.11504907f, 0.22066575f, 0.00994869f, 0.09456237f, -0.21320918f, 
    -0.15011750f, -0.06455541f, 0.13210462f, -0.05187340f, 0.14789012f, -0.05505701f, -0.16798246f, -0.19805737f, 
    -0.12009792f, 0.13269134f, 0.08667674f, 0.10706061f, 0.13547383f, 0.07564726f, -0.26525772f, 0.22130726f, 
    0.14908819f, -0.07948928f, -0.15481681f, -0.14794731f, 0.21316625f, 0.21612725f, -0.14301269f, -0.04815467f, 
    0.19815204f, 0.34981090f, 0.09287968f, 0.16410726f, 0.14989600f, 0.12646301f, -0.31735188f, -0.06130844f, 
    -0.19714925f, 0.02097300f, -0.01069451f, -0.01069391f, 0.03310631f, 0.22373524f, 0.17896050f, 0.20634532f, 
    0.05521401f, -0.29576573f, 0.31011373f, -0.10675218f, 0.35179350f, -0.02830078f, -0.02460810f, 0.07518528f, 
    0.09056249f, 0.05958022f, 0.18855958f, 0.11559124f, 0.13227522f, 0.00848779f, 0.11673534f, 0.13749447f, 
    0.15029992f, -0.00036567f, 0.02815318f, 0.00930842f, -0.04393561f, 0.24545084f, 0.21578433f, 0.19734770f, 
    -0.02055261f, 0.07660711f, 0.04093297f, 0.11766770f, 0.02654633f, -0.02545921f, 0.18745777f, -0.27500632f, 
    0.06656581f, -0.06000467f, 0.03377825f, -0.03780887f, -0.02377798f, 0.01626359f, -0.03855444f, -0.01630738f, 
    0.03662886f, -0.05738424f, -0.03084476f, -0.07694221f, -0.02652993f, -0.02836956f, -0.05770440f, 0.02842105f, 
    0.05266266f, 0.05651980f, -0.05542114f, -0.04040233f, -0.00476211f, -0.09514987f, -0.00660875f, -0.03330529f, 
    -0.00624440f, -0.05781650f, 0.00357375f, -0.02780466f, -0.03282933f, -0.07125269f, -0.00199590f, 0.01742900f, 
    0.05166589f, -0.02650338f, 0.00655538f, -0.01709851f, -0.05499688f, -0.03336170f, 0.04164624f, -0.01442364f, 
    0.00901842f, 0.03072937f, -0.11917021f, 0.05981037f, 0.04368600f, 0.06664692f, -0.06820001f, -0.01462258f, 
    -0.04882536f, 0.04233831f, 0.04030338f, -0.04495982f, -0.06838580f, 0.06258959f, 0.02524426f, -0.13019718f, 
    -0.09274957f, -0.08170512f, 0.02259916f, 0.03629359f, -0.09512833f, 0.07308031f, -0.03801408f, 0.00406795f, 
    -0.03447775f, 0.03572591f, 0.00217198f, -0.08145911f, -0.03002974f, 0.01573768f, -0.01924640f, -0.06094453f, 
    -0.12283906f, 0.05181436f, 0.01271584f, 0.01314426f, 0.05121469f, -0.05884663f, -0.06619739f, -0.03749730f, 
    0.05628718f, 0.04393086f, -0.01289834f, -0.02944998f, -0.07494283f, -0.03439847f, -0.12080599f, 0.00167341f, 
    0.05390238f, -0.00847200f, 0.06576487f, 0.03073055f, -0.08819114f, 0.04126832f, 0.08318388f, 0.00376943f, 
    0.02117787f, -0.02404951f, -0.08324518f, -0.09516072f, -0.09463678f, -0.00740619f, -0.07549307f, 0.06127282f, 
    0.05118049f, 0.02775054f, -0.09176645f, 0.03256771f, -0.10402887f, -0.00524271f, 0.07243562f, -0.04867380f, 
    0.01538468f, -0.05659619f, -0.10334158f, 0.01799483f, -0.04607319f, -0.15416321f, -0.08504716f, -0.06617955f, 
    0.02817955f, 0.03124599f, 0.00131227f, -0.08988854f, -0.03529289f, -0.01634176f, 0.01848523f, 0.01151693f, 
    -0.10767098f, 0.05655083f, -0.07954420f, -0.00663872f, -0.03137032f, 0.00633210f, 0.06327303f, 0.02409317f, 
    0.03769158f, 0.04209460f, -0.04844754f, -0.00016394f, -0.11398441f, -0.03458861f, -0.06649502f, 0.03983269f, 
    -0.07760172f, 0.01062740f, -0.05294550f, -0.00895367f, -0.08207373f, -0.02702023f, -0.05059476f, -0.08724017f, 
    -0.09294289f, -0.05338642f, 0.06274690f, -0.10743174f, -0.10077066f, -0.09961033f, 0.02631817f, 0.00855307f, 
    -0.07281626f, -0.01274563f, -0.03024211f, -0.02662124f, 0.02912275f, -0.03351668f, -0.03945885f, -0.07584731f, 
    -0.07831756f, -0.10444582f, -0.06182950f, -0.11006484f, -0.09779665f, 0.07007831f, 0.02576929f, -0.00879051f, 
    -0.02674028f, -0.04478651f, -0.00832589f, -0.00367732f, 0.03671990f, -0.07330649f, 0.07131280f, 0.04728938f, 
    0.03179386f, 0.06340169f, -0.10527600f, 0.05450606f, -0.04036546f, -0.02559787f, 0.02751829f, -0.03823886f, 
    -0.08165815f, 0.01453544f, -0.06641626f, 0.06020074f, -0.10402448f, -0.09083801f, -0.10825732f, 0.04228080f, 
    -0.06554739f, 0.01094988f, -0.09473311f, 0.06948606f, 0.02640018f, 0.02958015f, 0.01076670f, -0.02612230f, 
    -0.06191729f, 0.08364322f, -0.01565546f, -0.10066023f, -0.01756189f, -0.02320670f, -0.02830357f, -0.00013590f, 
    -0.04128173f, 0.02218127f, 0.02651226f, -0.09114539f, -0.06075998f, -0.08103601f, -0.02670621f, 0.05578142f, 
    0.02861259f, -0.02991880f, 0.02001064f, -0.03152249f, 0.02557229f, 0.02534063f, -0.08122755f, 0.00710908f, 
    0.02510791f, -0.08105503f, 0.01453677f, 0.01831570f, 0.04241664f, -0.01523620f, -0.07474831f, -0.09509944f, 
    0.01581920f, -0.06052082f, -0.07188052f, -0.07686358f, -0.07693691f, -0.04084733f, -0.08610508f, 0.05058708f, 
    -0.00116985f, -0.08271300f, -0.03405712f, 0.03984902f, -0.02248193f, 0.04602820f, 0.00120559f, -0.03964627f, 
    -0.01969825f, -0.04303320f, -0.06526957f, 0.03652462f, 0.06367414f, 0.00520160f, -0.10350155f, -0.08765677f, 
    -0.00214994f, -0.06298369f, -0.02096885f, -0.04894320f, -0.07907255f, -0.00552284f, 0.01799266f, -0.06131506f, 
    -0.07541132f, -0.04612904f, -0.04564158f, 0.03543540f, 0.00794047f, 0.02555000f, 0.03418244f, 0.01448143f, 
    -0.01790795f, -0.04576750f, 0.01999613f, -0.04109315f, -0.09007853f, -0.05382776f, 0.01957745f, -0.11976042f, 
    -0.06771417f, -0.05516056f, -0.04921039f, -0.12689410f, -0.01502038f, 0.01614643f, -0.01332346f, -0.02405020f, 
    -0.11325146f, -0.03906998f, -0.13094993f, -0.02188881f, -0.02556925f, 0.03653228f, -0.08826534f, -0.09059568f, 
    -0.10414247f, -0.04945321f, -0.08340208f, -0.02764571f, -0.02282068f, -0.05686106f, -0.09896807f, 0.02145776f, 
    0.04693816f, 0.00182859f, -0.03675662f, -0.00888274f, -0.09029484f, -0.08191216f, -0.01535141f, -0.08080454f, 
    0.05917189f, -0.08736201f, 0.01925304f, 0.05296288f, 0.02380111f, -0.10542134f, -0.02578351f, -0.05931314f, 
    -0.06871378f, -0.04086856f, 0.06815079f, -0.13967471f, -0.02254151f, 0.04917090f, -0.01792231f, 0.05266932f, 
    -0.05753259f, -0.05803857f, -0.01489217f, -0.06939834f, -0.11384506f, -0.02822969f, 0.00329771f, -0.00618886f, 
    -0.06176892f, -0.04150407f, 0.00913866f, -0.07608764f, -0.13059711f, 0.05160009f, 0.04856946f, -0.05786325f, 
    -0.01512387f, -0.05042147f, -0.12907183f, -0.05981349f, 0.05138026f, 0.07377973f, 0.00442035f, -0.00609073f, 
    -0.09802902f, -0.05122814f, 0.01212103f, -0.00706284f, -0.00348874f, 0.05755947f, -0.05228671f, -0.01318701f, 
    -0.01354409f, -0.06985150f, -0.00632670f, -0.01420255f, 0.04361643f, -0.10155095f, -0.05496878f, 0.07231126f, 
    -0.05832350f, 0.03137425f, -0.00744764f, 0.03797793f, -0.10093473f, 0.03192690f, -0.03051782f, 0.03317326f, 
    0.03820325f, 0.03902106f, -0.07765303f, -0.06356301f, 0.02222901f, -0.02297157f, -0.07767082f, -0.00845429f, 
    -0.08305770f, -0.05489235f, -0.00674843f, 0.06890853f, -0.08881589f, 0.06108699f, -0.03486741f, 0.04831770f, 
    -0.01058562f, -0.01581872f, 0.06685670f, 0.03235826f, -0.04309652f, 0.02226867f, -0.03558043f, -0.04266947f, 
    -0.00485993f, 0.06651496f, -0.01005634f, -0.05567985f, -0.04826711f, -0.10085046f, 0.05252897f, 0.01280398f, 
    -0.08955396f, 0.01302567f, -0.04052137f, -0.08589461f, -0.08792833f, 0.06391067f, -0.06953366f, -0.09728803f, 
    0.07451798f, -0.03605226f, 0.03388628f, 0.01198436f, -0.07177287f, 0.06179654f, -0.00196561f, -0.00364539f, 
    -0.07653083f, 0.07611104f, 0.08079586f, -0.06010391f, -0.07001608f, -0.00571224f, -0.06504012f, -0.05897177f, 
    0.04625707f, -0.01042889f, 0.06182622f, 0.06956001f, 0.03587389f, 0.04104063f, 0.07597703f, 0.06486465f, 
    -0.07007972f, -0.07602281f, -0.08590072f, -0.04147050f, 0.01116237f, 0.06609759f, 0.02961819f, -0.07174502f, 
    -0.04321349f, 0.04054360f, -0.07142563f, -0.02370513f, -0.04352128f, -0.02893911f, -0.08684247f, -0.08224683f, 
    -0.02987278f, -0.02633150f, -0.09184438f, 0.06690274f, -0.03660997f, 0.03500185f, 0.01572866f, -0.03800198f, 
    0.04990526f, -0.09605736f, -0.10410964f, 0.03356463f, 0.06963021f, -0.01460565f, 0.02767669f, -0.02890163f, 
    0.02451003f, 0.02039796f, 0.04880095f, 0.03573281f, -0.10062020f, -0.03041349f, -0.10172714f, 0.05029770f, 
    0.02598233f, 0.06013132f, 0.03945025f, 0.04198350f, -0.08409759f, -0.01826944f, -0.05248164f, -0.05028509f, 
    -0.03375342f, 0.01251715f, 0.03747437f, 0.00832044f, -0.01250500f, -0.01902439f, -0.06828783f, -0.00727098f, 
    -0.03668810f, -0.00571202f, 0.03338355f, -0.04144979f, -0.08814009f, 0.07406437f, 0.05071191f, 0.02384490f, 
    -0.42836836f, 0.19596921f, 0.10859890f, 0.26570842f, 0.02104177f, -0.00150921f, -0.22529343f, -0.29613328f, 
    0.10613178f, 0.09219153f, 0.07642220f, -0.28179073f, 0.21704109f, 0.03262370f, 0.11362080f, -0.44815537f, 
    -0.05120401f, -0.01322186f, 0.01844694f, 0.06588820f, -0.00093561f, -0.10448664f, 0.23656397f, 0.18068904f, 
    -0.32587099f, 0.18625173f, 0.14280029f, -0.16542944f, -0.21055892f, 0.08815708f, 0.00714489f, 0.21386307f, 
    0.07838235f, -0.53856146f, 0.22854038f, 0.00275187f, -0.26379186f, -0.32613900f, -0.03726447f, -0.13883266f, 
    0.08421499f, 0.11612781f, -0.36902535f, -0.07042149f, 0.17593312f, 0.04923809f, -0.18734364f, 0.00950860f, 
    0.26443189f, -0.11113901f, -0.06231181f, 0.08727270f, 0.18107297f, -0.12037491f, -0.03967855f, 0.12956876f, 
    0.01400525f, 0.00130135f, 0.08027465f, 0.13578159f, 0.10102467f, -0.27673417f, -0.25754571f, 0.23630156f, 
    0.06382789f, -0.12510993f, 0.15062284f, 0.11861896f, -0.10736918f, -0.08761312f, 0.15037982f, -0.63951117f, 
    -0.15125698f, 0.03009410f, -0.03444466f, -0.01001514f, 0.08676709f, -0.15375026f, 0.17669196f, -0.08378744f, 
    -0.11818563f, -0.32195336f, -0.00774508f, 0.12789935f, 0.13458057f, -0.53514135f, 0.18107618f, 0.01669622f, 
    0.20466855f, 0.18322341f, -0.00308142f, -0.10893194f, -0.12141480f, -0.09481087f, -0.07158423f, -0.08756111f, 
    -0.43382543f, 0.03202194f, -0.23698892f, 0.17568775f, 0.09421900f, 0.04472816f, 0.10942028f, 0.07271267f, 
    -0.00712166f, 0.08811276f, 0.08796151f, -0.01780963f, -0.34222251f, 0.11434972f, -0.04915810f, -0.58001828f, 
    -0.04448459f, 0.26859570f, -0.00826503f, 0.10013018f, 0.11917476f, -0.11009340f, -0.11087671f, -0.18880028f, 
    0.06175935f, -0.43755642f, -0.29923022f, 0.11521405f, -0.02094438f, 0.07735874f, -0.38149995f, 0.13668501f, 
    -0.07663638f, -0.02050332f, 0.02729083f, 0.03888544f, -0.01897248f, -0.07724017f, 0.02449801f, -0.01433099f, 
    0.03566673f, -0.09171438f, -0.08252677f, -0.01482747f, -0.03175488f, 0.01336333f, -0.06344349f, 0.05754217f, 
    0.07838836f, 0.07214077f, 0.01128003f, -0.05115812f, -0.07770158f, -0.11076162f, 0.03434525f, -0.11989105f, 
    0.02591380f, 0.04955555f, 0.02572980f, -0.00798423f, -0.07700189f, -0.07938456f, -0.01719101f, 0.02000801f, 
    0.01523164f, -0.10231146f, -0.05019350f, -0.01054381f, -0.06085857f, 0.03737189f, 0.04801365f, -0.00341985f, 
    -0.06384835f, -0.09309403f, 0.02251558f, -0.07687896f, -0.08124580f, 0.04969390f, 0.02335768f, 0.05297645f, 
    0.03688531f, -0.05645898f, -0.04161667f, 0.05413410f, -0.00923593f, 0.01230455f, -0.05809555f, -0.06348475f, 
    -0.08146103f, -0.08513488f, -0.00060739f, -0.08412842f, 0.03387916f, -0.09987497f, -0.02439814f, -0.10118606f, 
    -0.04241208f, -0.12342084f, -0.06595182f, -0.04456259f, -0.01531786f, -0.00737657f, -0.10577174f, 0.02111232f, 
    -0.07122409f, -0.07702563f, 0.03238692f, -0.00885357f, 0.00298809f, -0.04488650f, 0.00697590f, 0.03741859f, 
    -0.01371417f, 0.02979419f, -0.06489543f, -0.10068175f, 0.04620555f, -0.09140230f, -0.01087173f, 0.01966734f, 
    -0.04824466f, -0.00335684f, -0.05964268f, 0.03721946f, 0.04343155f, -0.00085021f, -0.05732831f, 0.02424964f, 
    -0.03246964f, -0.04875471f, -0.06714157f, -0.01094664f, -0.11874374f, -0.04646116f, -0.00498242f, -0.00950795f, 
    -0.01559718f, -0.02418215f, -0.05568513f, -0.09908882f, -0.07837114f, -0.10698584f, 0.08493801f, -0.04019852f, 
    -0.03095902f, -0.11960326f, -0.07519171f, -0.06426258f, -0.06826998f, -0.00939255f, -0.10371850f, 0.03599924f, 
    -0.02803594f, -0.03055697f, -0.11255310f, -0.08398526f, -0.06395763f, -0.05936982f, -0.06030246f, -0.06891108f, 
    0.02603666f, -0.08370955f, -0.17093031f, 0.26685461f, 0.17867993f, -0.18408155f, 0.06125003f, 0.04023686f, 
    -0.19980010f, 0.20212792f, -0.04080955f, 0.25848830f, 0.04076238f, 0.10333559f, -0.06061897f, -0.03366727f, 
    0.03099396f, -0.08381897f, 0.71914697f, 0.21748346f, -0.07627832f, 0.20397460f, 0.00396349f, -0.03775214f, 
    0.20191102f, 0.02646218f, -0.20932947f, -0.01856546f, -0.08330153f, -0.12976898f, 0.02448677f, -0.14319058f, 
    0.06657329f, 0.46149564f, 0.08715627f, -0.03631693f, 0.03095902f, 0.17738788f, 0.00551503f, 0.09611429f, 
    0.09404070f, 0.00550220f, -0.08281047f, -0.11214087f, 0.11987682f, 0.40342861f, -0.27574408f, 0.07540798f, 
    -0.11203162f, 0.25505328f, -0.15160348f, 0.37230623f, 0.24626148f, 0.15092036f, 0.05082422f, -0.27239534f, 
    -0.00038274f, 0.11592194f, 0.09004064f, -0.12651390f, -0.22033069f, -0.09030867f, -0.21021095f, 0.08127006f, 
    -0.11339818f, -0.11128631f, 0.14995059f, 0.08549965f, 0.16388489f, 0.01632884f, 0.02241489f, -0.13985561f, 
    0.02402799f, -0.12012184f, 0.12436478f, 0.00879978f, -0.04361909f, 0.07325511f, -0.38418278f, 0.00079916f, 
    0.08177964f, -0.32918426f, 0.03972042f, 0.02793236f, 0.04716477f, -0.12186463f, -0.12298341f, -0.05862044f, 
    0.03560427f, -0.14076342f, 0.09066343f, 0.16337973f, -0.15221356f, 0.13972500f, -0.10720028f, -0.02015041f, 
    -0.04039288f, -0.01092840f, 0.17620173f, 0.15334390f, 0.08010481f, 0.03352852f, -0.20094708f, -0.17118949f, 
    0.03085808f, -0.12043151f, -0.08094136f, 0.07502211f, 0.16014414f, -0.19235070f, 0.05401681f, -0.00739145f, 
    -0.06384065f, -0.10860116f, -0.18587229f, -0.06852756f, -0.15761292f, 0.16927576f, -0.00365488f, 0.11331351f, 
    -0.03151889f, -0.04435139f, 0.11051925f, -0.11679830f, -0.07904366f, 0.22693150f, 0.01259091f, 0.11616938f, 
    -0.27524090f, 0.29604441f, 0.09829394f, 0.14432965f, -0.28451934f, -0.25868896f, 0.13705333f, 0.13748138f, 
    0.12927184f, 0.18216726f, 0.04816265f, -0.12678762f, 0.17204100f, 0.14156090f, -0.23464935f, -0.22700854f, 
    -0.04055306f, 0.02643602f, -0.11765392f, 0.14094424f, -0.10061993f, -0.14508773f, -0.05535622f, 0.22969885f, 
    0.08735298f, 0.22884184f, -0.13068208f, 0.10383398f, 0.06583053f, -0.04438971f, 0.19661666f, 0.11579781f, 
    -0.33996189f, 0.16901694f, -0.06576118f, 0.13739058f, -0.38326228f, 0.06935390f, 0.07474519f, 0.02849659f, 
    -0.12209809f, -0.14161514f, -0.26776218f, -0.28181836f, 0.06263399f, 0.14287053f, 0.03124600f, -0.27853075f, 
    0.05370364f, 0.27018508f, 0.11746797f, 0.16256924f, 0.25608340f, -0.18908909f, -0.24514869f, 0.07540869f, 
    -0.35529336f, -0.06462447f, 0.21526191f, 0.15885150f, -0.10506716f, -0.04230215f, 0.21200086f, 0.28488162f, 
    -0.10513142f, -0.04404091f, -0.13775036f, 0.12476623f, 0.27623209f, 0.40863505f, -0.09596329f, -0.18088946f, 
    -0.05519523f, -0.04585061f, -0.27388519f, 0.09720589f, 0.48456261f, -0.04609030f, 0.16314100f, 0.00548518f, 
    -0.30809414f, 0.14425294f, 0.01450742f, 0.21683782f, 0.33718273f, -0.01175350f, -0.06897295f, -0.01655321f, 
    -0.06832509f, 0.21023729f, -0.14261766f, 0.03746074f, 0.21886665f, -0.21443427f, 0.19736163f, 0.05755053f, 
    0.02659511f, 0.18551371f, -0.13232188f, 0.09909218f, 0.12317840f, -0.07488971f, -0.28431100f, -0.00301019f, 
    0.22228542f, 0.09977521f, 0.18925378f, -0.10523430f, -0.15747853f, -0.05639923f, -0.21231823f, 0.09646417f, 
    -0.24424733f, 0.15152201f, 0.58894110f, 0.22553869f, -0.15010846f, 0.07699370f, 0.19204377f, 0.17301874f, 
    0.01218171f, 0.03632034f, 0.03296742f, 0.25833967f, 0.03840921f, -0.12946141f, -0.12891570f, -0.03128927f, 
    0.09033763f, -0.24409141f, 0.35976270f, -0.17804319f, -0.09376077f, -0.13625540f, 0.02988995f, -0.03300907f, 
    0.03969102f, -0.01403025f, -0.02434838f, 0.14839850f, -0.16130336f, -0.11386596f, -0.04739309f, 0.17769718f, 
    0.02700586f, 0.01228621f, -0.04309140f, 0.09782666f, -0.21588732f, 0.13535564f, -0.12251669f, -0.10887298f, 
    0.04372507f, 0.03019035f, 0.13401702f, -0.10682229f, 0.14570986f, 0.08094561f, -0.06011105f, -0.12585883f, 
    -0.04255238f, 0.21617500f, 0.38508871f, -0.00657394f, 0.19259417f, 0.20832242f, 0.11683505f, -0.05660407f, 
    0.11390892f, -0.17914087f, 0.31350037f, 0.10407891f, -0.10716726f, -0.31671196f, 0.01293469f, -0.06992828f, 
    -0.19433984f, -0.42153725f, -0.10368846f, 0.16767924f, 0.10301679f, -0.07128659f, -0.14231844f, -0.20010678f, 
    -0.02102464f, 0.02589335f, 0.07438380f, 0.03127999f, 0.15689449f, -0.03087118f, -0.10884854f, -0.24581601f, 
    -0.20245595f, 0.07736588f, 0.19314536f, 0.07794514f, 0.12625600f, 0.04535062f, -0.07420511f, 0.30504328f, 
    0.10151350f, 0.07069326f, -0.17661528f, -0.03974137f, 0.08050307f, 0.11701574f, -0.15191898f, -0.05869515f, 
    0.18541826f, 0.55091751f, 0.12790792f, 0.03085600f, -0.05921247f, 0.13912542f, -0.09317423f, -0.01525402f, 
    -0.22993125f, 0.06459790f, 0.05084560f, -0.00086583f, -0.03265621f, 0.11013109f, -0.13527517f, 0.19531779f, 
    0.17331579f, -0.49693882f, 0.35101986f, -0.06333742f, 0.12959911f, -0.05258765f, 0.15171751f, 0.00111360f, 
    0.01642901f, 0.12056018f, 0.06863724f, 0.00409104f, 0.30165583f, -0.07762111f, 0.18707854f, 0.17572975f, 
    0.09064824f, -0.01423473f, 0.03256298f, -0.06881618f, -0.06835628f, 0.23410200f, 0.22877389f, 0.00472407f, 
    0.08041925f, 0.03436544f, 0.03126049f, 0.14659980f, 0.19398399f, -0.21812943f, 0.09011969f, -0.32238501f, 
    0.24815534f, -0.00108211f, -0.19202401f, 0.48065010f, 0.30321360f, 0.10276999f, -0.02272238f, 0.26218846f, 
    -0.39440578f, 0.37375131f, 0.03003756f, 0.31663060f, -0.00948361f, 0.11188576f, 0.27311420f, 0.01533940f, 
    0.02404064f, -0.01266222f, 0.34720746f, 0.08574600f, 0.07830051f, 0.04492065f, 0.27373394f, -0.01640522f, 
    0.12114797f, -0.16381261f, -0.23860383f, 0.16079459f, 0.00926897f, -0.12675229f, 0.15202786f, -0.00828387f, 
    0.06393104f, -0.21047007f, -0.20760205f, -0.03237560f, 0.22372635f, 0.03319474f, 0.00811267f, 0.06242399f, 
    0.16862790f, 0.11637157f, -0.04154145f, 0.20411348f, 0.27046257f, 0.20417690f, 0.14903587f, 0.15511385f, 
    0.19179440f, 0.55498928f, 0.10594714f, -0.00373369f, -0.30016065f, 0.26485410f, 0.02211268f, -0.01170551f, 
    0.19222657f, 0.10416821f, 0.07187681f, -0.06123072f, -0.21381505f, 0.07228564f, 0.05755818f, 0.13113435f, 
    0.18689279f, 0.02125085f, -0.27550781f, -0.07530966f, -0.08857638f, -0.00829113f, -0.00193602f, 0.16805635f, 
    -0.05150396f, 0.15268396f, 0.03704111f, 0.30730024f, 0.01428509f, 0.11894765f, 0.21733549f, 0.03075413f, 
    -0.00936222f, -0.12484785f, 0.11921648f, -0.04469158f, -0.04562084f, -0.01895704f, 0.00745747f, 0.07888898f, 
    0.20425823f, 0.05156592f, 0.16901626f, 0.15676670f, 0.18789545f, 0.13862482f, 0.19248135f, -0.15884340f, 
    -0.08108838f, 0.25267687f, -0.06827469f, -0.06693222f, -0.26559809f, 0.05325285f, -0.00218830f, -0.12225820f, 
    0.14486298f, -0.06206220f, -0.05904347f, -0.03641730f, 0.17119080f, -0.11398876f, -0.05557829f, 0.11472667f, 
    -0.04256437f, 0.06084177f, -0.08802652f, -0.15830934f, -0.27008837f, -0.23794053f, -0.31976759f, 0.14914328f, 
    -0.01002986f, -0.05432232f, 0.02615183f, -0.21057449f, -0.11910818f, -0.16142403f, 0.03766058f, 0.08904203f, 
    -0.10037473f, -0.05957481f, -0.02744534f, -0.05592579f, -0.05205847f, 0.00441847f, 0.06283776f, -0.00956365f, 
    -0.00291243f, -0.12930639f, -0.01558666f, -0.01958111f, -0.07638182f, -0.12317973f, -0.04272482f, -0.02411404f, 
    0.07206367f, 0.00421119f, -0.04077751f, 0.03630769f, -0.00656414f, 0.01888428f, -0.09656984f, 0.03721561f, 
    0.00805713f, -0.04708895f, -0.08769365f, 0.01546237f, 0.03245325f, 0.03723360f, -0.10091177f, -0.09802045f, 
    -0.06930822f, -0.10472111f, -0.04368435f, -0.04168415f, -0.11734683f, 0.00862570f, 0.01295703f, 0.04152797f, 
    -0.04101467f, -0.03115085f, 0.02707727f, -0.04687656f, -0.09013089f, -0.07459527f, -0.01072086f, 0.02970540f, 
    0.02300926f, -0.09601396f, -0.11600822f, -0.01318354f, -0.02088815f, -0.06744811f, -0.01713935f, 0.02409565f, 
    0.03101797f, -0.06160973f, 0.04430177f, -0.01783319f, -0.08103691f, -0.07786062f, 0.07803252f, 0.05095371f, 
    -0.08805158f, -0.10495369f, -0.00024376f, -0.09188780f, -0.05300318f, -0.01209940f, -0.09339757f, 0.01472374f, 
    0.06005614f, 0.04256395f, -0.02442889f, -0.09966978f, -0.06960229f, -0.00352008f, -0.08132251f, 0.03759661f, 
    0.02326811f, -0.01407469f, -0.11722730f, -0.05802567f, -0.06780008f, 0.02146673f, 0.00260606f, -0.01091861f, 
    -0.03716379f, 0.01600716f, -0.11125961f, 0.01945020f, 0.02179568f, -0.02696705f, 0.00409619f, -0.10100650f, 
    0.03176194f, -0.02211678f, -0.03557957f, -0.10792625f, 0.03249628f, -0.07621253f, 0.04980972f, 0.06456752f, 
    -0.08920036f, -0.04236556f, 0.02591170f, -0.07271575f, -0.03633198f, -0.06303751f, 0.01265318f, 0.05331017f, 
    0.06565142f, 0.02348459f, 0.04392958f, -0.01937902f, -0.08788053f, 0.04661851f, -0.09672467f, -0.01667354f, 
    0.01579446f, 0.01456785f, -0.10662132f, -0.03190488f, -0.09967221f, 0.05891550f, -0.01449412f, 0.01619549f, 
    0.02272649f, 0.09922884f, -0.09695122f, -0.07177328f, 0.15131027f, 0.21465071f, -0.32295260f, -0.05813034f, 
    0.12061138f, -0.18364409f, -0.07549694f, -0.17566746f, 0.00614467f, 0.08611804f, 0.27086556f, -0.04733006f, 
    -0.01727730f, -0.05646353f, -0.44069651f, -0.14440387f, -0.14272238f, 0.30442956f, 0.19632158f, -0.06695244f, 
    -0.22765708f, 0.02243915f, 0.39117599f, -0.01023191f, 0.23222117f, 0.01746307f, -0.00333669f, 0.13091913f, 
    -0.03911895f, -0.25224620f, 0.10009994f, 0.22198121f, 0.28056443f, 0.05837581f, 0.15298876f, -0.12621869f, 
    -0.04777950f, -0.07505856f, 0.07837319f, 0.27839175f, 0.04781978f, -0.36781949f, 0.05499109f, -0.03809907f, 
    0.13552187f, -0.22454119f, 0.05992187f, -0.30021742f, -0.08818112f, -0.29609540f, 0.16514252f, 0.06866688f, 
    -0.41683856f, -0.05039685f, -0.38323310f, -0.05786799f, 0.19851604f, 0.08701148f, -0.13543127f, -0.17839426f, 
    0.19715881f, -0.02118752f, 0.02478096f, 0.11168391f, -0.02475194f, -0.03363008f, 0.04663835f, 0.15168753f, 
    0.09555213f, 0.16858648f, -0.13138884f, -0.13073514f, -0.15230426f, 0.07635283f, 0.14939135f, 0.00535308f, 
    0.06804266f, -0.11017989f, 0.20014422f, 0.01449332f, -0.12006964f, -0.04009818f, 0.12634905f, -0.06456804f, 
    0.17618576f, 0.12452406f, 0.18054269f, 0.06685434f, 0.02703687f, -0.06644507f, 0.17334750f, 0.06142172f, 
    -0.02730533f, 0.05943503f, -0.00044110f, -0.16178310f, -0.03978295f, 0.02073096f, 0.12311964f, 0.23876119f, 
    0.21220289f, 0.10166615f, 0.03662265f, -0.01509073f, 0.12681980f, 0.00725238f, 0.08375073f, -0.00762896f, 
    0.18905509f, 0.05518915f, -0.25910646f, 0.11620841f, 0.14815272f, -0.02946271f, 0.17601867f, 0.10349640f, 
    0.06144637f, -0.01557894f, 0.01605641f, -0.01366420f, 0.20180902f, -0.18478683f, -0.01612923f, -0.15970355f, 
    -0.14870335f, 0.15471683f, 0.03690896f, 0.25250515f, 0.20470826f, 0.00350288f, -0.39051929f, -0.35771722f, 
    0.13676152f, 0.26634976f, 0.00405851f, 0.48552337f, 0.01732177f, 0.19433685f, 0.04440394f, -0.06027450f, 
    0.00411020f, 0.05799282f, 0.55759078f, -0.01241681f, -0.24199881f, 0.10959028f, 0.03915340f, 0.27423474f, 
    -0.28876126f, 0.09196894f, 0.10673792f, -0.28644982f, 0.02360401f, 0.11101170f, 0.12653527f, -0.45186895f, 
    -0.02444085f, -0.14589514f, 0.00473012f, -0.08276695f, 0.18200092f, -0.07745886f, 0.36984718f, -0.67367411f, 
    -0.26402357f, 0.16593389f, 0.13902943f, 0.17123222f, 0.16535704f, -0.26113003f, 0.06676368f, 0.11452916f, 
    0.41127586f, -0.44633120f, 0.09166646f, -0.01315170f, 0.18625765f, -0.24265985f, -0.08242533f, -0.14499898f, 
    -0.38630340f, 0.15711352f, -0.02501431f, -0.32010761f, 0.08972000f, -0.19382149f, -0.01741787f, -0.01469323f, 
    0.04170111f, 0.19619977f, 0.09148794f, 0.14918178f, -0.00375610f, 0.08287080f, -0.01639393f, -0.10690667f, 
    0.18081795f, 0.10689785f, -0.14054085f, -0.06643827f, -0.06408580f, 0.04220859f, -0.24594593f, -0.10282565f, 
    0.18504460f, -0.02569564f, -0.03176422f, 0.07266523f, 0.02686792f, -0.45062807f, 0.06294321f, -0.08161152f, 
    0.19018632f, 0.03786485f, 0.29701442f, 0.06153517f, -0.11535940f, -0.10104350f, -0.04718870f, 0.21458371f, 
    -0.09624572f, -0.15102558f, 0.42667809f, 0.14417535f, 0.12042921f, 0.07035112f, -0.19904010f, -0.27304608f, 
    0.08251887f, 0.02732160f, 0.01526320f, -0.32242218f, 0.35821894f, 0.00238052f, 0.05591560f, 0.03532903f, 
    -0.32313314f, 0.07745827f, -0.35541791f, 0.05716544f, -0.12047746f, -0.07419102f, 0.10471091f, -0.00704166f, 
    -0.03550398f, -0.69473994f, -0.26052725f, 0.13804297f, -0.05922985f, -0.10547990f, -0.08167051f, -0.06991711f, 
    -0.02108931f, 0.23140459f, 0.06928052f, -0.06596490f, -0.30579552f, -0.21918653f, 0.00855659f, 0.01306690f, 
    0.20517544f, 0.20138939f, 0.05334443f, -0.07537452f, 0.07295418f, 0.10377816f, -0.08424568f, -0.06480567f, 
    -0.03871815f, 0.07652608f, -0.36037052f, -0.09022778f, -0.09918518f, -0.12968177f, 0.02985649f, 0.44756442f, 
    0.05770517f, 0.09631559f, 0.18701729f, 0.13791470f, 0.32380781f, 0.00320148f, 0.01487095f, 0.08104926f, 
    -0.22186005f, -0.10120524f, -0.01995758f, -0.07938264f, 0.08640962f, -0.12055648f, 0.16940162f, -0.23451325f, 
    -0.00886817f, 0.05576527f, 0.12590516f, -0.03962817f, -0.01577228f, -0.22113261f, 0.25479752f, -0.17887215f, 
    0.23723982f, -0.03344412f, 0.16692497f, 0.07714882f, 0.23576090f, -0.17482495f, -0.32121828f, -0.15272556f, 
    0.03961608f, -0.27396023f, 0.15557092f, -0.03938728f, 0.06626008f, 0.07609706f, 0.33214727f, 0.06108407f, 
    -0.06432128f, 0.29924229f, -0.15254268f, 0.18510473f, 0.13292687f, 0.16155478f, -0.02580926f, 0.28673223f, 
    0.11821686f, -0.07474013f, -0.19352998f, 0.12435443f, 0.31115115f, 0.12092005f, 0.09383763f, 0.05175111f, 
    -0.03134820f, 0.61500692f, 0.09781776f, 0.09684048f, 0.10086444f, 0.17432310f, 0.11639432f, -0.04043943f, 
    -0.11930916f, 0.15758350f, -0.31376618f, -0.16914521f, 0.23391581f, -0.13990560f, 0.35848475f, 0.00637610f, 
    0.18461561f, -0.13832065f, 0.11999029f, 0.10017299f, -0.06520433f, -0.01404135f, 0.09733850f, -0.11388455f, 
    0.11898819f, 0.06404712f, -0.01141094f, -0.09926016f, 0.15787654f, -0.05561080f, 0.14684680f, 0.31506068f, 
    -0.08940127f, 0.05165665f, 0.39042029f, -0.05709303f, -0.05828835f, -0.26104552f, 0.35519016f, 0.01060878f, 
    -0.07381812f, -0.05965546f, -0.07994473f, 0.10771562f, -0.02571502f, -0.33040544f, -0.05504204f, -0.26001361f, 
    0.01822830f, 0.11043297f, -0.14556023f, -0.05451252f, 0.06207619f, 0.13732019f, -0.13161987f, 0.12747961f, 
    0.07542934f, -0.09023200f, -0.02478458f, 0.21711324f, 0.01645961f, -0.07681104f, -0.01703039f, 0.40278158f, 
    -0.07068796f, -0.06436575f, -0.11218504f, -0.06287450f, 0.04188148f, 0.12120496f, -0.03371849f, -0.01263300f, 
    -0.06706115f, -0.17316988f, 0.03438218f, -0.09613949f, 0.08327940f, 0.14584562f, 0.04261118f, 0.14598703f, 
    0.01584046f, -0.25493535f, 0.08155365f, 0.10696360f, 0.40741962f, 0.00025529f, 0.05765606f, 0.10115699f, 
    -0.20704634f, -0.08920337f, 0.42697033f, 0.35508332f, 0.13875814f, -0.31411627f, 0.20218313f, -0.00005175f, 
    0.20913447f, -0.40168929f, 0.13745651f, -0.28119448f, -0.09050322f, -0.09345052f, 0.13484862f, 0.17555661f, 
    -0.10672805f, -0.02802684f, 0.03283658f, 0.11691318f, 0.11350476f, 0.04846387f, 0.13282129f, -0.01914029f, 
    -0.02678496f, 0.24057040f, -0.10383429f, 0.13511813f, 0.01429605f, -0.13926184f, 0.00600595f, 0.22261442f, 
    -0.18489689f, 0.18172093f, -0.32781762f, 0.07335858f, 0.00271882f, 0.09025396f, 0.14146844f, -0.02988514f, 
    0.02818412f, -0.47859713f, 0.16929841f, 0.11994188f, -0.02776106f, 0.06206159f, -0.01678778f, 0.05667208f, 
    0.14988050f, 0.14571428f, 0.11915259f, -0.07377845f, 0.18475151f, -0.03498504f, -0.00013398f, 0.03377267f, 
    0.25768903f, -0.29483998f, 0.15513842f, -0.01748088f, -0.15229337f, -0.07056097f, 0.09910415f, -0.04598696f, 
    0.02758997f, -0.07609486f, 0.13975321f, 0.08450104f, 0.13590255f, -0.22752070f, 0.09951866f, 0.07318170f, 
    0.11826675f, 0.18598469f, -0.06780671f, -0.17661971f, 0.01077034f, -0.12316648f, 0.10443763f, -0.26854956f, 
    0.05676783f, -0.08668765f, -0.01499630f, 0.00936810f, 0.29867321f, -0.12385178f, -0.10440716f, -0.06307253f, 
    0.18020181f, 0.07411535f, -0.25626028f, -0.20409594f, -0.14271009f, 0.19158852f, -0.16104485f, -0.09534373f, 
    0.10416910f, -0.17955573f, -0.07517453f, 0.02651049f, -0.12901981f, 0.00799220f, 0.12571993f, 0.29125580f, 
    0.05523840f, -0.07480155f, -0.38812572f, -0.19861342f, -0.06969070f, 0.31209415f, 0.02600472f, 0.00829036f, 
    -0.08568373f, 0.07935517f, 0.44599214f, 0.00379033f, 0.24645525f, 0.13144900f, -0.12299555f, -0.07008771f, 
    0.03308477f, -0.10017104f, 0.04079253f, 0.21666832f, 0.31805336f, 0.14714442f, -0.06093509f, -0.11857269f, 
    -0.14392403f, -0.16190507f, 0.38562146f, 0.27892992f, 0.09282860f, -0.44373840f, -0.16354162f, -0.09650209f, 
    0.01192108f, -0.37087390f, -0.05285553f, -0.12627257f, -0.10216388f, -0.02863251f, 0.05560087f, 0.10255875f, 
    -0.18623568f, 0.06717439f, 0.06398197f, 0.19032192f, 0.28504065f, -0.00823000f, 0.04427200f, -0.04222630f, 
    0.15885736f, 0.09259338f, -0.16674748f, 0.29755253f, 0.00217742f, -0.09095982f, -0.13450786f, 0.20366274f, 
    0.25653109f, 0.07837839f, -0.33025160f, -0.12973030f, 0.02244661f, 0.09408664f, 0.09907214f, -0.03069188f, 
    0.11707636f, -0.17123321f, 0.10094781f, 0.06851190f, 0.03655972f, -0.02269118f, -0.04900162f, 0.06505554f, 
    -0.13023499f, 0.19453782f, 0.01990078f, -0.01528230f, 0.12654570f, 0.10108550f, 0.13647626f, 0.10266124f, 
    0.15105374f, -0.21442601f, 0.37723529f, -0.03044597f, 0.07733852f, -0.07604566f, 0.21454532f, 0.23776624f, 
    0.11682126f, 0.14167227f, 0.04808616f, 0.13910463f, 0.11512589f, -0.21215405f, 0.00630328f, 0.07291164f, 
    0.06798887f, 0.23494650f, -0.11339648f, -0.04990275f, -0.03066623f, 0.11803447f, 0.32112643f, -0.01203316f, 
    0.08658327f, 0.04902222f, 0.06167860f, 0.06913362f, 0.27044550f, -0.27142733f, -0.00731031f, -0.16233344f, 
    -0.08001887f, 0.08341328f, -0.02107290f, 0.06941268f, 0.04461439f, 0.04829241f, -0.08445520f, 0.05555198f, 
    -0.08905843f, 0.06029900f, 0.00010648f, -0.00150326f, 0.01137678f, -0.03189109f, 0.05731010f, 0.03948221f, 
    -0.03922667f, -0.03161644f, 0.02430307f, -0.08014625f, -0.03453651f, 0.07947878f, -0.03090073f, -0.07041610f, 
    -0.06867289f, -0.00720083f, 0.01463302f, -0.09108814f, 0.03520200f, 0.04880004f, -0.05893617f, 0.03587655f, 
    0.05013863f, 0.03116811f, -0.08534478f, -0.02981910f, -0.06950454f, 0.08040804f, -0.03220335f, 0.05792401f, 
    -0.02969740f, 0.04333574f, 0.07920107f, -0.02465314f, -0.06944686f, 0.06146668f, 0.04151944f, -0.09724528f, 
    0.01195660f, -0.04047674f, -0.09004741f, -0.08175961f, 0.02795968f, -0.03565190f, 0.04536930f, -0.06420248f, 
    0.05541243f, -0.05264084f, -0.00321865f, -0.00222287f, 0.05051005f, -0.07123943f, -0.02164906f, 0.01926077f, 
    -0.03643453f, -0.05846230f, 0.01889453f, -0.03966813f, -0.00305293f, -0.02327576f, 0.00259498f, 0.00892173f, 
    -0.02055938f, 0.00350506f, -0.07806130f, 0.01414904f, -0.06229315f, 0.03138006f, 0.06630386f, -0.04350377f, 
    -0.10260911f, 0.07287399f, -0.06851696f, -0.08402111f, 0.02184682f, -0.04896820f, -0.00326722f, -0.08229020f, 
    -0.09495735f, -0.02671975f, -0.03891108f, -0.04675781f, 0.02985416f, -0.09204935f, -0.03013416f, 0.01711445f, 
    -0.01885068f, 0.02726019f, -0.06579360f, -0.03532336f, -0.03575859f, -0.01515516f, -0.03071955f, -0.05287215f, 
    -0.07915498f, -0.06817214f, -0.06594618f, 0.00769892f, 0.00261617f, -0.07748691f, 0.04837606f, 0.03050521f, 
    0.02061014f, -0.03037291f, 0.03032630f, -0.06978680f, -0.09918840f, 0.02061094f, -0.07508159f, -0.08745192f, 
    -0.06256957f, 0.00986137f, -0.05941520f, -0.00668589f, -0.06457845f, 0.06780206f, 0.04057984f, -0.08208817f, 
    -0.03312974f, 0.02903133f, -0.03708335f, 0.01351950f, 0.04588933f, -0.05401514f, -0.07042051f, 0.04399517f, 
    0.03435321f, -0.06572998f, -0.01698679f, -0.01741344f, -0.08220629f, 0.07335600f, 0.05006644f, 0.07269035f, 
    0.04174331f, 0.04741769f, -0.00246583f, 0.04118580f, 0.02281059f, 0.05412913f, -0.08981942f, -0.05201431f, 
    -0.06907898f, 0.00043732f, -0.04606726f, 0.02469166f, -0.08578862f, 0.07664870f, -0.00523092f, -0.03875086f, 
    -0.03228222f, 0.03870647f, -0.05778983f, -0.05086528f, 0.03310055f, 0.05192481f, -0.06602548f, -0.06569228f, 
    0.03125509f, -0.03454985f, -0.04271147f, -0.02461133f, -0.07114939f, -0.00455680f, -0.04046273f, -0.02026374f, 
    -0.09151948f, 0.04233976f, -0.05615729f, -0.08820941f, -0.03613907f, -0.00695266f, -0.03352005f, -0.03852759f, 
    -0.01354660f, 0.05104836f, -0.04950576f, 0.04718240f, 0.04644771f, 0.04314574f, 0.07045911f, 0.00898848f, 
    -0.04227818f, -0.06373094f, -0.01372708f, -0.00518083f, -0.05949860f, 0.00653363f, -0.02113262f, 0.06457175f, 
    -0.04137673f, -0.05035378f, 0.05518501f, -0.06554133f, -0.00085821f, 0.04173940f, -0.05693038f, -0.02394049f, 
    0.06024438f, 0.00218661f, 0.03952378f, -0.00644778f, -0.03638067f, 0.00294650f, -0.02872739f, -0.02243512f, 
    0.01486764f, 0.01183080f, -0.02822134f, -0.07682234f, 0.05611188f, 0.01770367f, -0.03753550f, -0.05318739f, 
    0.07958442f, 0.00868598f, 0.05468539f, -0.06822668f, -0.00483091f, -0.05625087f, 0.01755942f, -0.03184916f, 
    -0.07028639f, 0.08091858f, 0.07919894f, -0.05709374f, 0.01380051f, -0.01966804f, 0.01047609f, -0.02784703f, 
    -0.05128929f, -0.04661392f, 0.00087837f, 0.06187209f, -0.05627390f, -0.04782467f, -0.02940611f, -0.02368855f, 
    0.08497021f, 0.04817677f, 0.01588831f, -0.09257117f, -0.03990756f, -0.04276318f, -0.08076332f, -0.06798211f, 
    0.12990548f, 0.12812719f, -0.01688449f, 0.15995030f, 0.23367527f, 0.28780130f, -0.12781033f, 0.12448278f, 
    -0.00381729f, 0.05392670f, -0.07546006f, 0.02289009f, 0.02621746f, 0.13405642f, 0.16971013f, -0.03819694f, 
    0.04016994f, -0.02099141f, -0.09246910f, 0.00635993f, -0.22467321f, 0.11237664f, 0.15261884f, 0.01320366f, 
    -0.15745550f, 0.00663047f, 0.14098863f, 0.02938764f, -0.16338003f, 0.04666031f, 0.05555962f, 0.11739045f, 
    0.01289328f, -0.58815509f, 0.22083165f, 0.06022057f, 0.18564945f, -0.37099606f, -0.01969454f, 0.19492017f, 
    -0.39227316f, 0.09290677f, -0.00719319f, 0.41791862f, 0.02217505f, -0.17434211f, 0.31403005f, 0.07245533f, 
    0.35742733f, 0.02585194f, 0.11863963f, -0.36053765f, 0.04316415f, -0.00027290f, 0.17261380f, -0.00213844f, 
    -0.07045357f, 0.06395226f, -0.13923822f, -0.05981981f, 0.10001742f, -0.02716913f, 0.17470299f, -0.04632535f, 
    0.02940528f, -0.07911271f, 0.09624006f, -0.03067010f, -0.18885732f, -0.27728906f, 0.08038559f, 0.06809001f, 
    -0.00414591f, 0.12998916f, 0.03677384f, 0.02732615f, -0.14672832f, 0.04161201f, 0.05431690f, -0.01703528f, 
    -0.02483406f, 0.15666710f, 0.08719534f, -0.04059004f, -0.04329823f, -0.11876352f, 0.17216840f, -0.05620617f, 
    0.25967488f, 0.07456667f, 0.10330579f, 0.04305640f, 0.05031963f, 0.01618127f, 0.00234691f, -0.10792854f, 
    -0.06019502f, 0.16570793f, -0.16516474f, 0.11614972f, -0.14426811f, 0.03614592f, 0.05730025f, 0.16581509f, 
    0.16853586f, 0.13587070f, 0.02722239f, -0.03493351f, -0.03282864f, 0.06536187f, -0.09118070f, -0.19893831f, 
    0.11397670f, 0.02719288f, -0.06425522f, -0.06465331f, 0.00116910f, -0.05784222f, -0.11777256f, -0.06687171f, 
    -0.06214971f, -0.07581493f, -0.15800326f, -0.05090173f, 0.17471933f, -0.04805999f, -0.11595349f, 0.05025314f, 
    -0.12640743f, 0.17520152f, -0.57264489f, 0.12235114f, 0.10759471f, 0.25600824f, -0.17614534f, 0.06524421f, 
    -0.12319046f, 0.06858238f, 0.07832567f, -0.06806729f, 0.14911315f, 0.19203034f, -0.01268644f, -0.11012709f, 
    -0.08214863f, 0.03070751f, 0.10726839f, 0.08019571f, -0.11501615f, -0.10012072f, 0.20705596f, -0.01838399f, 
    0.12552747f, -0.00488780f, -0.12143418f, 0.05789790f, -0.10564722f, -0.03935226f, 0.00776037f, 0.33816543f, 
    -0.37396300f, 0.28117880f, -0.12905493f, 0.17686220f, -0.18127112f, 0.16248731f, -0.24337946f, 0.16025151f, 
    -0.14978880f, -0.06481478f, -0.44896117f, -0.16973004f, 0.16052066f, 0.55792350f, -0.45280021f, 0.12562719f, 
    0.01589284f, 0.24775419f, -0.02013481f, 0.07426631f, -0.21071775f, -0.19977006f, 0.25172073f, 0.12778261f, 
    -0.12218960f, 0.11355319f, -0.01027850f, -0.12959248f, -0.19586089f, -0.05531902f, 0.49304426f, 0.12841350f, 
    -0.01604480f, -0.27925840f, -0.14521131f, -0.01866378f, 0.14772601f, 0.27708408f, -0.08266621f, -0.48837587f, 
    0.09598684f, 0.06545102f, -0.04553491f, 0.14464213f, 0.11912037f, 0.05992667f, 0.05664368f, -0.05637911f, 
    -0.21667971f, -0.06171515f, 0.04106022f, -0.08675426f, 0.17607854f, -0.17500609f, 0.08930139f, -0.03797237f, 
    0.15756559f, -0.02289712f, 0.10449817f, 0.22237304f, 0.04211958f, -0.19784819f, 0.29037040f, -0.02975923f, 
    -0.24184702f, 0.28312498f, -0.17119519f, 0.25577736f, 0.17615283f, 0.07451240f, -0.38918474f, 0.15091529f, 
    0.14590539f, -0.18514706f, 0.12936150f, -0.11422077f, -0.40477845f, -0.22659186f, -0.01905481f, -0.35286504f, 
    -0.02721414f, 0.03038830f, 0.02540643f, 0.07515411f, -0.12744470f, 0.09756024f, -0.06980038f, -0.00313483f, 
    -0.04954410f, 0.17656307f, 0.01528819f, -0.12288968f, -0.03077430f, -0.01414041f, -0.08819573f, 0.11073923f, 
    0.04403765f, 0.13623698f, 0.45065144f, 0.22431535f, -0.27970499f, -0.35781956f, 0.30126590f, -0.05248467f, 
    0.10561573f, 0.38312432f, 0.06240560f, 0.42866310f, 0.10288073f, 0.10029583f, -0.28631714f, -0.28588334f, 
    0.05328257f, -0.07025886f, 0.30133790f, 0.19711308f, -0.11187552f, 0.11270175f, -0.00692746f, 0.31047237f, 
    0.00995044f, 0.14273785f, -0.13735482f, 0.20261097f, -0.08161961f, -0.01577118f, 0.16723530f, 0.02249023f, 
    -0.19863692f, 0.35006464f, -0.02120512f, -0.13894942f, -0.63492841f, -0.25106576f, 0.08569040f, -0.49180767f, 
    -0.11592596f, 0.06019631f, 0.02897273f, -0.18864264f, -0.11187366f, -0.19741875f, 0.03556027f, -0.28663066f, 
    0.09741588f, 0.62096512f, 0.06632020f, 0.19839913f, 0.40644318f, 0.31551027f, -0.66843343f, -0.37003514f, 
    0.15033486f, -0.08559372f, 0.24974021f, -0.14699277f, -0.11499149f, -0.20188554f, 0.03272492f, 0.01630332f, 
    -0.14518712f, 0.22561988f, 0.07767335f, 0.09277146f, 0.21242313f, 0.31258893f, 0.10572008f, 0.02383856f, 
    -0.06491468f, -0.12921387f, -0.14784297f, 0.04593586f, 0.50818354f, 0.07830583f, 0.11807594f, -0.02775852f, 
    -0.08378560f, -0.39893603f, 0.15218732f, 0.11601877f, 0.13717930f, -0.02833220f, -0.18828984f, -0.07149181f, 
    0.02244208f, 0.11258957f, -0.05157213f, -0.04490060f, 0.14015886f, -0.15585853f, -0.14906892f, 0.00802109f, 
    0.11206646f, 0.30242392f, 0.32302937f, 0.14671831f, 0.02091014f, -0.06250148f, -0.17520079f, -0.19681966f, 
    0.18240894f, -0.01441765f, 0.17591804f, 0.03305122f, 0.16054432f, -0.06665671f, 0.12634490f, 0.08203334f, 
    -0.32039088f, 0.03116619f, 0.30412132f, 0.06903648f, -0.36574975f, -0.38663679f, 0.13697758f, -0.00233828f, 
    -0.10681333f, -0.02246445f, -0.09459831f, 0.03227209f, 0.12424551f, -0.49048382f, -0.09774065f, 0.11647175f, 
    -0.06133798f, 0.24935482f, -0.32236210f, 0.11756594f, 0.01715945f, -0.03345573f, -0.00766193f, -0.01695949f, 
    0.08623526f, 0.35112527f, -0.05351434f, -0.04900680f, -0.02874156f, -0.00668936f, -0.07211643f, -0.24545495f, 
    -0.06014824f, -0.02968959f, -0.08972957f, 0.14288695f, -0.24817495f, -0.11515063f, -0.03809638f, 0.23904507f, 
    -0.00207824f, -0.02148906f, 0.06127756f, 0.11189558f, 0.24748147f, 0.06978498f, 0.16570981f, 0.07924079f, 
    -0.13069925f, -0.14731504f, 0.03247765f, -0.22218813f, -0.07622555f, 0.26933372f, 0.26741463f, -0.13699459f, 
    -0.27872932f, 0.06725153f, 0.06255196f, -0.09660160f, 0.02201344f, 0.06829128f, 0.48482138f, -0.17710777f, 
    0.45025170f, 0.36612096f, 0.25962430f, -0.39213288f, 0.08441138f, -0.18922858f, -0.12908092f, -0.10560468f, 
    0.09137074f, -0.16392942f, -0.16915795f, -0.07801844f, -0.00023975f, 0.17630075f, 0.03054376f, 0.01244476f, 
    0.02472771f, 0.25883341f, -0.21994439f, -0.04724282f, 0.11353585f, 0.23126616f, 0.05945393f, 0.34387526f, 
    -0.10370430f, 0.00087962f, 0.05559048f, 0.09950273f, 0.09992820f, 0.07758942f, 0.09983587f, 0.05820320f, 
    -0.18789615f, -0.28279263f, 0.12341376f, 0.04936706f, 0.12494630f, 0.20315155f, -0.32764810f, -0.05001474f, 
    0.19814874f, 0.14390048f, -0.21952614f, -0.11494696f, 0.21977569f, -0.10790492f, -0.17800780f, 0.21009752f, 
    0.18661241f, 0.09895041f, -0.05784601f, 0.02907254f, -0.12265365f, -0.08568241f, 0.11792764f, -0.27905577f, 
    0.15993173f, 0.07946776f, 0.02398998f, -0.28226164f, 0.34272233f, -0.07857896f, -0.02749970f, 0.22193800f, 
    -0.10615755f, 0.01945126f, 0.41176698f, 0.24320817f, -0.02356549f, -0.11054180f, -0.04841008f, 0.11785617f, 
    0.04765221f, -0.09311073f, 0.03365066f, -0.02057486f, 0.03159279f, -0.31922489f, 0.02713584f, -0.10072812f, 
    0.06792294f, 0.01329267f, -0.02118945f, -0.06168340f, -0.09363577f, -0.07521836f, 0.04752918f, -0.03620402f, 
    -0.04542930f, 0.05991212f, -0.06318972f, -0.04287381f, -0.08835791f, 0.00760509f, 0.04149031f, 0.01679513f, 
    -0.03503237f, 0.00549499f, -0.05572677f, 0.03196761f, -0.07610774f, -0.01447762f, 0.04702117f, 0.02804215f, 
    -0.04765537f, 0.01936490f, 0.02640443f, 0.03541293f, -0.02829335f, -0.05868257f, 0.03596547f, 0.08031075f, 
    -0.00485332f, -0.01104454f, -0.03170212f, 0.05703767f, -0.01458986f, -0.01509420f, -0.05549433f, 0.04092711f, 
    0.01762838f, 0.05549051f, 0.02453913f, 0.01417705f, 0.00343475f, -0.05941540f, -0.05692413f, -0.07978588f, 
    0.00228411f, 0.02399081f, -0.00186202f, 0.03633735f, 0.01201428f, -0.02905745f, 0.06260832f, -0.01556556f, 
    -0.01599989f, 0.02214455f, 0.03088773f, -0.07156455f, 0.01784089f, -0.00038670f, 0.04125024f, 0.06569915f, 
    -0.07987632f, 0.07171417f, -0.02471414f, 0.01895653f, 0.01457340f, -0.07712440f, 0.04673376f, 0.08522876f, 
    0.00420204f, -0.02786119f, -0.09531885f, -0.04100894f, 0.00408198f, 0.04962470f, 0.04326632f, 0.01877748f, 
    -0.05298582f, 0.07361528f, -0.08441935f, 0.02392628f, 0.06161831f, -0.04807036f, 0.02755935f, 0.07276350f, 
    0.02050980f, 0.01109381f, -0.07523103f, 0.00751628f, -0.03820172f, -0.09843782f, -0.03363691f, 0.04212201f, 
    -0.02067951f, -0.05012085f, -0.03383010f, -0.03055190f, -0.08920120f, -0.00039703f, -0.09469102f, -0.02762055f, 
    -0.07790914f, -0.08759746f, 0.02867319f, -0.08896302f, -0.06708115f, -0.08435260f, 0.03405237f, 0.01270224f, 
    -0.02579731f, -0.08765877f, -0.02001038f, 0.05759992f, -0.06988560f, -0.06436447f, -0.08909708f, 0.01158938f, 
    0.02454943f, -0.02758558f, -0.02821379f, -0.01754424f, -0.01695623f, -0.09325253f, -0.03171210f, -0.04801815f, 
    0.11385123f, -0.14802176f, 0.08523599f, -0.07467749f, -0.17061824f, -0.07774038f, -0.13770078f, -0.00917114f, 
    0.20771213f, 0.00276952f, -0.01554074f, -0.03898926f, 0.04884499f, -0.06868554f, -0.11355604f, 0.17440672f, 
    -0.02579272f, 0.06650511f, -0.03580915f, -0.13123897f, -0.33936155f, 0.06339501f, 0.00773375f, 0.20152199f, 
    0.09550529f, -0.00458623f, 0.29316387f, 0.06654971f, 0.36038589f, 0.03191217f, -0.00197445f, 0.13706869f, 
    0.02394854f, 0.02500132f, -0.01320702f, -0.10878016f, 0.44322580f, 0.59055859f, 0.16719994f, -0.09273672f, 
    -0.17750862f, 0.05995188f, 0.19387424f, -0.06362415f, 0.16495854f, -0.08120538f, -0.07798711f, -0.09451424f, 
    0.19642039f, -0.51114631f, -0.10602290f, -0.01951475f, -0.16701114f, -0.19509633f, 0.02855207f, 0.05675489f, 
    -0.02212179f, -0.04301089f, -0.15122436f, -0.43318099f, 0.26768968f, 0.06933274f, 0.19988732f, 0.18699880f, 
    0.21534245f, 0.15628691f, -0.09260240f, -0.02543266f, 0.14476822f, 0.24865276f, -0.19071963f, 0.19717738f, 
    0.17384307f, 0.01495676f, -0.42343852f, 0.14558189f, 0.21538274f, -0.03086622f, -0.32813194f, -0.02040936f, 
    0.16464542f, 0.45304582f, 0.01530185f, -0.04248943f, 0.00315001f, 0.01338386f, -0.01279701f, 0.00297120f, 
    -0.02143665f, 0.13379370f, -0.09458133f, 0.00396182f, 0.11307728f, 0.02504833f, 0.24298064f, 0.21810445f, 
    -0.03072384f, -0.19633010f, 0.37284526f, -0.18932295f, 0.06807369f, -0.00871546f, -0.06238490f, -0.15999828f, 
    0.04595401f, -0.04842425f, -0.07228935f, -0.01783025f, 0.37514311f, 0.10223174f, 0.02912307f, 0.15713954f, 
    -0.11734160f, 0.10300217f, 0.01782939f, 0.14362483f, 0.01121650f, -0.03004297f, 0.09813312f, -0.05958218f, 
    -0.05218257f, -0.13660438f, 0.01385812f, 0.01891386f, -0.10057461f, -0.08407643f, 0.04994892f, -0.37996745f, 
    0.07513447f, -0.00693710f, -0.16501664f, 0.12856610f, 0.08455955f, 0.29422301f, -0.14028808f, 0.24233162f, 
    0.05113556f, -0.01536166f, -0.08810220f, -0.14890787f, -0.03432110f, 0.06998421f, -0.14253473f, 0.04112287f, 
    0.00570820f, 0.00758992f, 0.33490884f, 0.06030688f, -0.20589305f, -0.34353137f, 0.04308303f, 0.07082338f, 
    0.08314364f, -0.39801151f, 0.03638006f, 0.17890772f, -0.08231350f, 0.02513527f, -0.03103370f, 0.49366698f, 
    -0.03703867f, -0.02882461f, -0.34821308f, 0.17937575f, 0.08134536f, -0.09963159f, 0.06020983f, 0.20007011f, 
    -0.08534187f, -0.12112008f, -0.18185025f, 0.03317850f, 0.00054590f, 0.26184011f, -0.41702265f, 0.21367604f, 
    0.29579309f, 0.29788613f, -0.10282809f, -0.01835305f, -0.51496136f, -0.00263725f, 0.27669582f, 0.13150826f, 
    0.19690956f, 0.10890744f, -0.06396219f, -0.18921411f, 0.03028206f, -0.03257356f, 0.04203309f, 0.14630795f, 
    0.00397231f, -0.24072763f, -0.19892643f, -0.16606341f, 0.22786710f, 0.07875036f, -0.11439153f, -0.22299296f, 
    -0.10779946f, 0.14202712f, -0.04258708f, 0.19247526f, 0.16015913f, 0.06649556f, -0.12250801f, -0.06853242f, 
    0.24677832f, -0.24472436f, 0.00015672f, -0.12081101f, 0.09516844f, -0.10011416f, 0.04956540f, -0.00772273f, 
    0.25041872f, -0.04567615f, 0.09997998f, 0.18467154f, 0.08892872f, 0.10097088f, -0.20120142f, -0.06642368f, 
    -0.13629960f, 0.36562267f, -0.14510785f, -0.02563375f, 0.24577200f, -0.03814010f, -0.24106200f, 0.21146402f, 
    0.01268427f, -0.19814107f, -0.02221334f, 0.21750915f, 0.01397234f, 0.17392568f, -0.16518179f, -0.20023277f, 
    0.03276550f, -0.11066923f, 0.03305555f, -0.06442679f, -0.02931150f, 0.21108936f, -0.23763789f, 0.01402069f, 
    0.00476897f, 0.08572329f, 0.13991277f, -0.19206445f, -0.30477354f, 0.16690268f, 0.14729501f, 0.07550098f, 
    -0.08269963f, 0.02318918f, 0.04602051f, 0.23374102f, -0.14517193f, -0.00468501f, 0.05935651f, 0.12468744f, 
    -0.10751341f, 0.12635857f, 0.03588582f, 0.19870438f, 0.00849252f, -0.02515238f, -0.12214439f, 0.09142849f, 
    0.02544400f, -0.08679216f, 0.20726864f, 0.13879678f, 0.14344524f, -0.18410257f, 0.08644205f, 0.14317247f, 
    0.01593914f, 0.04757106f, -0.26755303f, 0.10589680f, 0.04695531f, 0.00002659f, 0.19857757f, -0.02424612f, 
    0.05187828f, -0.00221580f, -0.01409613f, 0.04483971f, -0.13741234f, -0.05617148f, 0.02822815f, 0.14598028f, 
    0.04397653f, -0.05215897f, 0.01950957f, -0.01528152f, 0.08667091f, 0.45933148f, 0.10043723f, 0.05210831f, 
    0.19328998f, 0.09882462f, -0.01097912f, 0.09465893f, 0.01167405f, 0.09878783f, -0.19433862f, 0.08494919f, 
    0.19122148f, -0.07227965f, 0.28472343f, 0.04385449f, -0.07613625f, -0.20122980f, 0.21599323f, 0.10058603f, 
    -0.04299162f, 0.01023498f, -0.02931334f, 0.04403871f, 0.09494022f, 0.27264240f, -0.01022878f, 0.00615791f, 
    -0.24958777f, 0.07979813f, -0.12390456f, 0.25652075f, 0.30600742f, -0.06496802f, 0.15250139f, 0.00533376f, 
    -0.07208870f, -0.00923332f, 0.01888127f, 0.12730213f, 0.15171890f, 0.02198563f, -0.05696588f, 0.02560546f, 
    0.06149617f, 0.07311040f, -0.01115113f, 0.11810733f, 0.05164653f, -0.00052202f, -0.16656601f, -0.04823143f, 
    0.01507838f, 0.05156646f, 0.01215341f, 0.08355644f, -0.11466230f, 0.06907725f, 0.12664410f, -0.19529626f, 
    0.19855782f, 0.01856131f, 0.04796720f, 0.00053917f, 0.03638779f, -0.14612424f, -0.27532429f, -0.02500238f, 
    -0.13782796f, 0.00557977f, 0.38337132f, -0.11137892f, -0.04879869f, -0.17995845f, -0.19124763f, -0.13205415f, 
    -0.05026713f, -0.22532912f, -0.06985559f, 0.04237300f, 0.06356558f, -0.06765794f, -0.11748939f, 0.07054739f, 
    -0.05423269f, -0.11712641f, 0.10716923f, 0.10980469f, -0.00135382f, 0.06559934f, -0.02960767f, 0.19289871f, 
    0.12327886f, 0.11093863f, -0.00248639f, 0.05342610f, -0.09984671f, 0.01413962f, -0.32368100f, 0.40140364f, 
    0.07572395f, 0.06742380f, 0.40151483f, 0.07137243f, 0.11129283f, -0.09062163f, 0.00086107f, 0.05751259f, 
    0.22313483f, -0.34258601f, -0.19956453f, 0.01405663f, 0.05223733f, -0.03669194f, 0.15058196f, 0.27516365f, 
    -0.03764676f, 0.54118055f, -0.32230929f, -0.05595962f, -0.02096363f, 0.02227817f, 0.07183868f, 0.17744775f, 
    0.04397386f, -0.14430782f, -0.01996427f, -0.02003248f, -0.04193543f, 0.22066593f, -0.25958097f, -0.03379568f, 
    0.03024453f, -0.04199392f, -0.20790432f, -0.05964609f, -0.12767786f, 0.08878035f, -0.04476703f, 0.11691295f, 
    0.16699073f, 0.11624609f, 0.12305818f, -0.17118520f, 0.09727384f, -0.05749266f, 0.25474045f, 0.23395430f, 
    -0.10780437f, 0.10120432f, -0.16352493f, -0.11248934f, 0.10989510f, 0.30725119f, -0.08282553f, -0.04571562f, 
    -0.01822148f, -0.06050900f, -0.10397170f, 0.12040800f, 0.21039560f, -0.00175348f, -0.08144081f, -0.04169210f, 
    0.14989324f, 0.42631492f, -0.08418140f, -0.05888999f, 0.07952619f, 0.04198232f, 0.27947360f, -0.02167990f, 
    0.09550921f, -0.04601458f, 0.09236906f, 0.10552703f, 0.09449399f, 0.14058433f, -0.05703090f, -0.04853474f, 
    0.15897474f, -0.03224221f, 0.19606774f, 0.01995723f, 0.04731819f, 0.03561996f, -0.11445711f, 0.13696618f, 
    0.07113133f, -0.23724912f, 0.01295486f, 0.16714218f, -0.01262728f, -0.07466966f, -0.15483156f, 0.19869049f, 
    -0.00850310f, 0.03383530f, 0.17240432f, -0.16839285f, 0.08080024f, 0.11575091f, -0.15725909f, -0.15695941f, 
    -0.08171462f, 0.04041890f, 0.13200712f, -0.14080459f, -0.08557942f, 0.25739157f, 0.14933844f, -0.03483056f, 
    -0.07538385f, 0.14226456f, -0.11970831f, -0.08044264f, 0.08701883f, 0.17632203f, 0.01553061f, -0.14812912f, 
    -0.01372651f, -0.29299626f, -0.05988845f, -0.11810593f, 0.11531336f, 0.19219783f, 0.12613547f, 0.07374301f, 
    0.01030079f, -0.04497107f, -0.21706647f, 0.01507647f, -0.10500216f, 0.18231560f, 0.11958630f, -0.08693579f, 
    -0.22194496f, 0.11215469f, 0.31924707f, -0.10763907f, -0.19371179f, 0.06345901f, -0.12133550f, 0.02559183f, 
    -0.00134768f, -0.11791033f, 0.10627168f, 0.46940315f, -0.17616598f, -0.17624332f, -0.02518620f, 0.09969107f, 
    -0.08616509f, -0.12823021f, -0.01225688f, 0.13850470f, 0.06396820f, -0.09911755f, -0.39179698f, 0.07932596f, 
    -0.44392261f, 0.03148632f, -0.05989996f, -0.03829741f, -0.02937527f, 0.00619176f, 0.11591031f, -0.02001372f, 
    -0.18030965f, 0.04757208f, -0.01792265f, 0.09704348f, 0.05420108f, -0.27381432f, -0.21615015f, -0.07346235f, 
    0.11043128f, -0.47188964f, 0.16464134f, 0.06566799f, 0.02936087f, -0.23030958f, 0.02836835f, -0.31661594f, 
    0.11050847f, 0.02362384f, -0.01774213f, -0.01168324f, -0.08161511f, 0.08793269f, -0.04440011f, 0.00339139f, 
    0.13546833f, -0.49520978f, 0.08940101f, 0.16814287f, 0.00053569f, -0.05580283f, -0.13005185f, -0.01400421f, 
    -0.03835979f, 0.01531993f, 0.14286968f, 0.05506293f, -0.04911970f, 0.10984513f, 0.06355546f, 0.01734492f, 
    -0.27106512f, 0.24194753f, -0.11671468f, -0.00360864f, 0.22036020f, 0.04162731f, -0.14354219f, 0.32590368f, 
    0.02531207f, 0.07476331f, 0.23853619f, 0.09992053f, -0.30229732f, -0.03297916f, 0.01972104f, -0.34032807f, 
    0.06811301f, 0.09795870f, -0.27407938f, 0.03441873f, -0.14199398f, 0.23568441f, 0.05583428f, 0.29285461f, 
    -0.03925709f, 0.05701896f, -0.11804214f, 0.21078515f, 0.15632993f, 0.08616181f, 0.07723442f, -0.00255746f, 
    -0.18510351f, 0.37482151f, -0.52145231f, 0.11040433f, -0.14738955f, -0.08455054f, 0.18832815f, -0.01532407f, 
    0.26450413f, 0.08872127f, -0.08555762f, -0.27179819f, 0.14767186f, 0.13756879f, -0.34236047f, -0.35695258f, 
    0.03890059f, 0.00972536f, -0.21759562f, 0.23885642f, -0.36181557f, -0.16942970f, 0.03438022f, 0.19211844f, 
    0.07557195f, 0.03385109f, -0.02508868f, 0.13156933f, 0.36474013f, 0.03888262f, 0.04593479f, 0.15137218f, 
    -0.45357990f, 0.16484661f, -0.11720567f, 0.05124269f, -0.45682722f, 0.35039595f, 0.06526173f, 0.07655220f, 
    -0.24541512f, -0.23590119f, -0.29344791f, -0.32924297f, -0.03049160f, 0.12354549f, 0.29565600f, -0.13890588f, 
    0.10426948f, 0.45173270f, 0.14094470f, -0.03238734f, 0.15092938f, -0.11786494f, 0.01600373f, 0.14644426f, 
    0.10125656f, -0.14135438f, -0.09844334f, 0.03261023f, 0.01633218f, 0.03230598f, 0.20981459f, 0.15438776f, 
    -0.12466187f, -0.08869182f, -0.10102338f, 0.00046696f, 0.24320696f, 0.26129100f, -0.04905578f, -0.09838073f, 
    -0.08073605f, -0.01166167f, 0.08464257f, 0.11382629f, 0.33850393f, -0.01392209f, 0.14285500f, 0.06659448f, 
    -0.22427647f, 0.47027287f, -0.06013410f, 0.01305812f, 0.28031585f, 0.21595557f, -0.26262072f, 0.05404450f, 
    0.02835775f, 0.17831026f, -0.19674893f, 0.06518656f, 0.10177772f, -0.23846371f, 0.22677624f, 0.10947885f, 
    -0.13971089f, 0.21917146f, -0.41993177f, 0.17021866f, 0.10496628f, -0.01429170f, -0.19754495f, -0.00670731f, 
    0.19692050f, -0.07428531f, 0.19447027f, -0.00649688f, -0.19774106f, 0.01467387f, -0.08137926f, 0.06848017f, 
    -0.08857878f, 0.05233845f, 0.45232767f, 0.15472983f, -0.09798928f, 0.14512885f, -0.00166118f, 0.20229793f, 
    0.09866787f, 0.07705186f, 0.06397048f, 0.16196033f, 0.07027225f, -0.07566849f, -0.10839687f, 0.14397494f, 
    -0.03571170f, -0.05952147f, 0.00130937f, 0.06357974f, -0.15224062f, 0.29745620f, -0.01426792f, 0.28563508f, 
    0.22852077f, 0.01701539f, -0.05502355f, 0.07313517f, -0.15393630f, -0.14142010f, -0.14573902f, 0.42830899f, 
    -0.02324236f, 0.07066332f, 0.05298128f, -0.08769323f, -0.19855928f, -0.03822263f, 0.06848996f, -0.06524436f, 
    0.05230711f, -0.27437207f, -0.05129023f, 0.09336351f, -0.08163957f, 0.13843977f, 0.04486104f, 0.27333844f, 
    -0.06139938f, 0.27657062f, -0.38352039f, 0.16864114f, -0.13467990f, -0.24897842f, 0.10271646f, 0.10830160f, 
    -0.19303797f, -0.26303208f, 0.07040782f, 0.09558021f, -0.06560460f, -0.18604110f, -0.29853809f, -0.09535282f, 
    0.06642899f, -0.25069284f, -0.15821345f, -0.13600406f, -0.22196005f, 0.10380763f, 0.05781060f, 0.04776733f, 
    -0.26743802f, 0.17492388f, 0.17557701f, -0.10525905f, 0.18113126f, 0.10198996f, 0.11532489f, 0.22486547f, 
    0.02200613f, -0.01083235f, -0.06402788f, -0.14067726f, 0.06855018f, 0.11059801f, -0.31283948f, -0.21903805f, 
    0.04073255f, -0.00322722f, -0.32829249f, 0.27821118f, 0.26265344f, 0.08393371f, -0.11339222f, 0.03589393f, 
    0.29228258f, 0.24952593f, 0.06647497f, -0.00691669f, 0.01526709f, 0.00668257f, 0.06785261f, -0.00181420f, 
    0.07011907f, 0.11913204f, 0.15630342f, 0.17677136f, 0.12044885f, 0.09611283f, -0.12786840f, 0.06542094f, 
    0.02801601f, -0.07095903f, 0.24895573f, -0.09046286f, 0.18412648f, -0.02363147f, -0.12720567f, 0.34730414f, 
    0.09566573f, -0.06318008f, -0.00092219f, 0.17039263f, -0.00589430f, 0.10655902f, -0.14446285f, -0.00115153f, 
    -0.06179079f, -0.02294133f, 0.08110693f, -0.11185463f, -0.14597043f, 0.17799728f, -0.09566076f, 0.00201822f, 
    0.00853567f, -0.02485405f, 0.24513847f, -0.11659596f, -0.00053148f, 0.07159293f, 0.23095943f, -0.00701391f, 
    0.02296227f, 0.03775148f, -0.08439800f, 0.23760901f, 0.13727120f, -0.06561091f, -0.17138682f, -0.07395501f, 
    0.06184457f, 0.17473967f, -0.07447717f, 0.09968690f, 0.19386628f, 0.18416384f, 0.22723977f, -0.21291980f, 
    0.01125140f, -0.01953478f, 0.33803388f, 0.16553438f, -0.18610227f, 0.04434473f, 0.12388840f, 0.08147433f, 
    -0.00865192f, 0.16035828f, 0.02154763f, 0.04867604f, 0.12536031f, -0.10786519f, 0.13905242f, 0.03718587f, 
    -0.16880907f, 0.09104058f, -0.11870582f, 0.18358843f, 0.19478066f, 0.06567557f, 0.13313958f, 0.03297314f, 
    -0.20122640f, -0.05866038f, -0.35498255f, -0.08509384f, 0.19066824f, 0.08733170f, -0.64400482f, -0.12833750f, 
    0.05636532f, -0.05659110f, 0.14837916f, 0.32485726f, 0.06237624f, -0.00986375f, 0.14867420f, -0.10180189f, 
    -0.35494381f, 0.11164038f, 0.08079949f, -0.14248027f, 0.00978114f, -0.24896912f, 0.11097153f, 0.32360652f, 
    0.08502165f, -0.12800023f, 0.02637281f, 0.15206201f, 0.26879826f, 0.12042961f, 0.05431746f, -0.47880495f, 
    0.13096014f, -0.13739368f, -0.15082496f, 0.00111900f, 0.18644075f, 0.00661736f, -0.26025656f, 0.06959919f, 
    0.14784309f, -0.12299498f, -0.16354658f, 0.16736510f, 0.17149395f, -0.25139305f, -0.01238029f, -0.05779722f, 
    0.07830003f, 0.03645151f, 0.16134962f, 0.11644971f, -0.05049277f, 0.13510537f, 0.10560605f, 0.11628188f, 
    -0.41323566f, 0.04750632f, 0.22286576f, 0.17543586f, 0.31862056f, -0.07709651f, -0.42613062f, 0.09461717f, 
    0.00314233f, 0.03013491f, 0.07355586f, 0.01104046f, 0.13892277f, 0.02542251f, -0.00415369f, -0.17505616f, 
    -0.21748728f, 0.10421452f, -0.19150920f, 0.25479591f, -0.17233549f, 0.19308507f, 0.08936930f, 0.29025561f, 
    -0.05896183f, -0.11081748f, -0.08048161f, 0.18602416f, -0.21885781f, -0.13410884f, 0.08349115f, -0.13516006f, 
    -0.03976018f, -0.00891488f, -0.04932540f, 0.03813064f, -0.06126056f, -0.05979279f, 0.03840443f, -0.05204386f, 
    0.00009528f, -0.13231508f, 0.01383454f, -0.12393226f, 0.00960319f, 0.02723615f, -0.05494967f, -0.08093954f, 
    -0.01819959f, -0.00989496f, 0.10062745f, -0.04469825f, -0.01735255f, -0.05742295f, -0.11162494f, -0.04511656f, 
    -0.03576847f, -0.04727187f, 0.02843514f, -0.07655516f, -0.05564853f, -0.10691071f, -0.04996323f, 0.04133865f, 
    0.06190207f, -0.06769503f, 0.06746136f, 0.00304310f, -0.05945726f, -0.05202892f, 0.02475329f, -0.02445975f, 
    -0.00003273f, 0.04270168f, 0.01434733f, 0.00497095f, -0.01059288f, -0.09391901f, 0.03453771f, 0.02994893f, 
    0.02742673f, -0.00442544f, -0.10486061f, -0.04466612f, -0.01807687f, 0.04999797f, -0.04035000f, 0.09419060f, 
    0.08582733f, 0.02710610f, 0.04439129f, -0.00613624f, -0.11842956f, -0.04399481f, -0.07369790f, 0.00137500f, 
    -0.09515217f, -0.07854784f, 0.03129745f, -0.08755234f, -0.11124510f, -0.12447073f, -0.04323515f, 0.00223034f, 
    -0.07891919f, -0.11150932f, -0.10912495f, -0.08415875f, -0.00924124f, -0.12005971f, -0.03493030f, 0.01350016f, 
    -0.05551745f, 0.02229398f, -0.08251775f, -0.05805758f, -0.13497424f, -0.10621792f, -0.01413035f, 0.02665282f, 
    -0.01248969f, -0.12626521f, 0.02075200f, -0.09900605f, -0.02075434f, -0.05044310f, -0.09123022f, -0.13990879f, 
    -0.06839847f, 0.03972780f, 0.01334953f, -0.11526772f, -0.02706731f, 0.06451267f, -0.11572806f, -0.03248270f, 
    -0.04023614f, 0.02540410f, -0.08779459f, 0.00562541f, 0.01639672f, 0.03107347f, -0.08784632f, 0.02336179f, 
    0.03313042f, -0.07110835f, -0.06267750f, 0.02478683f, -0.06910013f, 0.05192885f, -0.03858593f, -0.05654153f, 
    0.04417750f, -0.02165017f, -0.00952272f, -0.13653554f, -0.12434257f, -0.00065882f, -0.03244000f, -0.00959506f, 
    0.25189695f, 0.00750237f, -0.07015143f, -0.13355574f, 0.49694002f, -0.05100033f, 0.05908113f, -0.04013996f, 
    0.00827662f, 0.02228925f, 0.02307820f, 0.31040740f, -0.13122497f, 0.00390131f, 0.14481415f, 0.03229750f, 
    -0.01467449f, -0.00124599f, 0.17388786f, -0.12003554f, -0.12866889f, 0.14144814f, -0.02783093f, 0.07630884f, 
    0.00753358f, 0.06958732f, 0.17832159f, -0.01315561f, 0.17875409f, 0.09989508f, 0.03016810f, -0.10704265f, 
    0.14148061f, -0.13671938f, 0.08816681f, -0.33091155f, 0.25487241f, 0.13892432f, 0.13831159f, 0.02247236f, 
    -0.02196659f, 0.05770530f, 0.28227627f, 0.33423930f, -0.10472251f, -0.18758923f, 0.13589446f, 0.32087097f, 
    0.15850092f, 0.03567906f, 0.13661098f, -0.06345841f, 0.10800293f, 0.11328657f, 0.29101208f, -0.21981528f, 
    -0.00356085f, 0.12595476f, -0.02218230f, -0.04226471f, 0.03444199f, 0.19887561f, 0.05034477f, -0.29135504f, 
    -0.01980291f, 0.24393386f, 0.10698040f, 0.06244642f, -0.14394034f, -0.20013806f, 0.10234103f, 0.30463365f, 
    0.05073717f, -0.03991825f, 0.19723079f, -0.08657164f, -0.50713819f, 0.03127791f, -0.30139434f, 0.02003542f, 
    0.17163473f, 0.10942403f, 0.07859334f, 0.07912642f, -0.09055823f, 0.19204554f, 0.05677190f, 0.01930383f, 
    -0.00903220f, -0.12080923f, 0.06484831f, -0.20229067f, -0.18248166f, 0.09321204f, -0.07318562f, 0.02811187f, 
    0.00399560f, -0.07568558f, 0.10201106f, 0.11848401f, -0.04966585f, -0.01528660f, 0.05676349f, -0.11441594f, 
    -0.00823051f, 0.08048999f, -0.07873343f, -0.24122788f, 0.28897110f, 0.02026660f, 0.36321440f, 0.39265212f, 
    0.08207019f, -0.00420993f, -0.24337307f, 0.02314480f, 0.11122280f, 0.10980146f, 0.05162972f, 0.09149881f, 
    -0.08115368f, 0.03496640f, 0.21297644f, -0.04249318f, 0.22783479f, -0.07753821f, 0.22509460f, -0.05875689f, 
    -0.09528785f, 0.30849099f, -0.04570435f, -0.39348760f, -0.11406834f, 0.28953382f, 0.13502489f, -0.21923237f, 
    0.20216584f, -0.06095444f, -0.01272064f, 0.10454387f, -0.12405121f, 0.09186023f, -0.08813538f, 0.00266575f, 
    -0.06092596f, 0.03323009f, -0.25880113f, -0.29117668f, -0.29895732f, 0.20334508f, 0.20769785f, 0.17646420f, 
    -0.04421987f, -0.07727134f, 0.34827980f, -0.20943040f, 0.15165262f, 0.05910928f, -0.28645143f, 0.19944870f, 
    -0.00831675f, -0.86922342f, -0.08818294f, -0.15769173f, -0.39000189f, -0.67836905f, -0.03402930f, -0.14717695f, 
    -0.16130811f, 0.07900839f, 0.00786926f, -0.00454385f, -0.21737662f, -0.22224431f, 0.32223043f, -0.02769757f, 
    0.48622271f, -0.10903616f, -0.15350834f, -0.21149395f, 0.09626911f, 0.26315898f, 0.06974068f, -0.09307573f, 
    0.42223576f, -0.03203452f, -0.36844566f, -0.23151973f, 0.12807833f, 0.00694880f, 0.10140108f, 0.02055437f, 
    0.08912919f, 0.14714275f, 0.05124592f, 0.06385629f, -0.25212699f, -0.16497132f, 0.06211840f, -0.18233688f, 
    0.21529882f, -0.11089575f, 0.14360315f, -0.25158134f, -0.15469269f, -0.03332772f, -0.31285274f, 0.06558731f, 
    -0.14497370f, 0.54108876f, 0.07267201f, -0.27283451f, -0.13415614f, -0.26586953f, 0.15637480f, -0.05078444f, 
    0.09669344f, -0.22463836f, 0.09398767f, -0.23461823f, -0.33927959f, -0.27135488f, 0.30592543f, -0.08989656f, 
    -0.13195579f, -0.51436305f, -0.01427451f, -0.03369071f, 0.06124303f, -0.01759570f, -0.02843765f, 0.41518658f, 
    -0.06737868f, 0.05227365f, -0.19679347f, -0.09332810f, 0.36387241f, 0.12144831f, 0.03213478f, -0.08401586f, 
    -0.02789698f, -0.01150836f, 0.18711145f, 0.10612477f, -0.11796641f, -0.24574126f, 0.01520238f, 0.17095324f, 
    -0.06074302f, -0.04999812f, 0.18475400f, -0.18250811f, -0.02267013f, 0.05789378f, 0.01163330f, -0.03925282f, 
    0.05665020f, -0.20086549f, 0.03326276f, 0.34409910f, 0.06400011f, -0.10459378f, 0.33477762f, 0.13105614f, 
    -0.19103628f, 0.21304448f, -0.07526305f, 0.10676354f, 0.12307967f, 0.20014919f, 0.05692800f, -0.12527262f, 
    0.00657755f, 0.05277152f, 0.23553878f, 0.03619047f, 0.08873513f, -0.14761758f, 0.08568671f, -0.15536723f, 
    0.12862386f, 0.07357013f, -0.12546802f, 0.07464875f, -0.47522619f, -0.18579552f, 0.20745917f, -0.07630821f, 
    0.00197402f, 0.24234222f, -0.13052459f, 0.10921944f, -0.39469150f, -0.16591279f, -0.25276101f, 0.21307974f, 
    0.17632674f, -0.04761921f, 0.04980864f, -0.12691860f, 0.02158785f, 0.35870466f, -0.16954958f, 0.03890202f, 
    -0.23703645f, 0.17860606f, -0.25853267f, 0.44923624f, 0.03527567f, 0.43382713f, 0.02212191f, 0.04612130f, 
    0.45493212f, 0.23711076f, 0.40508896f, 0.08833618f, -0.06077997f, -0.02658896f, -0.11964728f, 0.12075640f, 
    0.13578087f, -0.06156165f, 0.11220113f, -0.08530423f, -0.05906219f, -0.16435403f, 0.02343497f, -0.03474039f, 
    0.18156494f, -0.01439105f, 0.04356585f, 0.15098336f, 0.04275971f, -0.07796814f, -0.09481538f, 0.09687134f, 
    0.04055087f, 0.75555885f, -0.05771816f, -0.06138710f, 0.02218473f, 0.01458398f, 0.07587245f, -0.08211575f, 
    0.02611192f, -0.06661775f, 0.07329128f, -0.05916563f, 0.03246974f, 0.18822062f, 0.04084321f, -0.22413884f, 
    0.13384886f, 0.06735414f, 0.00232215f, 0.05596840f, 0.04912863f, -0.05087622f, -0.07853559f, -0.04600346f, 
    -0.14690819f, -0.01789718f, 0.04479365f, 0.08744221f, -0.08233652f, 0.07080506f, 0.05706864f, 0.10989644f, 
    -0.12956820f, -0.02141868f, 0.03159982f, -0.06087452f, -0.12634894f, -0.16091061f, 0.00728369f, 0.06469548f, 
    -0.03795725f, 0.05739649f, -0.05313399f, -0.01607754f, -0.13606596f, 0.19721454f, -0.00644005f, 0.13776009f, 
    0.05772280f, -0.03978995f, 0.01018020f, -0.06391350f, 0.03228482f, 0.02277397f, -0.08579081f, 0.03496340f, 
    0.00025285f, 0.01021496f, -0.07030362f, -0.09825674f, -0.06396692f, -0.05687610f, 0.04098570f, -0.12429786f, 
    0.01031478f, -0.04496905f, 0.07557828f, 0.00505302f, -0.00962940f, -0.02660367f, -0.11414042f, 0.00559198f, 
    0.04812434f, -0.00321785f, -0.08257684f, 0.04327307f, -0.04280793f, -0.08957998f, -0.08491787f, -0.04125759f, 
    0.03813190f, 0.03696213f, -0.02565402f, -0.02456372f, 0.05503817f, 0.00948567f, -0.10524366f, -0.08732970f, 
    -0.04179946f, 0.03820031f, -0.08985606f, -0.09946273f, -0.02276114f, 0.08181845f, 0.03750138f, -0.09420023f, 
    -0.05398184f, 0.02311797f, -0.00585592f, -0.02397965f, -0.00189215f, -0.04337124f, 0.04772171f, -0.03907349f, 
    0.04501652f, -0.11643644f, 0.02933996f, 0.01483708f, 0.01605416f, -0.00702519f, -0.05134544f, -0.01133224f, 
    -0.08567273f, -0.05856750f, -0.07756893f, -0.02492543f, -0.06102147f, 0.04749472f, 0.03783626f, -0.09145188f, 
    0.06215736f, -0.10615097f, 0.05402587f, 0.01598996f, 0.02852690f, 0.02545046f, 0.08746203f, 0.08207429f, 
    0.05643069f, 0.04316534f, 0.01640368f, -0.05929736f, 0.01247051f, 0.01611738f, 0.02630274f, -0.02018338f, 
    0.05186937f, 0.04992609f, -0.00187004f, -0.09459274f, 0.00225890f, 0.03664904f, 0.05750725f, 0.00013967f, 
    0.03381760f, -0.08647945f, -0.06619992f, -0.00368955f, 0.04329119f, -0.06048010f, -0.11060900f, -0.08679942f, 
    0.01246200f, -0.00653606f, -0.01208585f, 0.00302151f, 0.00465663f, 0.00232454f, 0.06702167f, -0.01422202f, 
    -0.10946939f, -0.06588671f, -0.03814553f, -0.11623851f, -0.08507432f, -0.05637968f, -0.04506725f, -0.01314077f, 
    0.02695887f, 0.01208488f, -0.03005816f, 0.01872318f, -0.05809818f, -0.04320277f, -0.02256939f, -0.09384251f, 
    0.29326889f, 0.03210946f, -0.53090918f, 0.16812043f, 0.23003861f, 0.11729353f, 0.01507083f, 0.11408861f, 
    -0.00940340f, 0.23746325f, -0.06652457f, -0.00407320f, -0.38842145f, -0.02704613f, 0.17491165f, 0.05811810f, 
    0.01399961f, -0.06017777f, 0.05845987f, 0.09188887f, -0.72894233f, -0.20907451f, 0.03668426f, -0.14703688f, 
    0.00135074f, -0.79114813f, -0.01380369f, 0.15409395f, 0.33139443f, 0.00106414f, 0.06666912f, 0.19710352f, 
    0.20116580f, -0.14225346f, -0.06688899f, -0.18966718f, 0.45363587f, -0.55601442f, 0.16615397f, 0.17425565f, 
    0.09603684f, 0.19072841f, 0.05468013f, 0.21801803f, -0.26978049f, 0.20432314f, 0.24112503f, 0.08852702f, 
    0.05354125f, 0.44560161f, 0.16252299f, -0.60356820f, -0.30941567f, 0.00171741f, 0.11475585f, -0.29521012f, 
    0.13075992f, 0.00302258f, -0.15129133f, -0.15604742f, -0.06677220f, 0.21811005f, 0.26381192f, -0.03540330f, 
    0.00277853f, 0.07968666f, -0.45022580f, -0.45060924f, -0.17789404f, -0.11923829f, 0.12693961f, 0.25859815f, 
    -0.24085088f, 0.14352626f, 0.15459886f, 0.19544840f, 0.13997686f, 0.10431644f, 0.06341161f, 0.02673368f, 
    0.08989873f, 0.00932488f, 0.15878773f, -0.20305713f, -0.09083167f, 0.15558189f, -0.47370976f, -0.01435164f, 
    0.22144111f, 0.02453551f, 0.04502394f, 0.07027952f, 0.12940358f, 0.03837078f, 0.09822407f, -0.04584343f, 
    -0.06021723f, 0.36104774f, -0.29145554f, -0.33221686f, -0.25278881f, 0.03040457f, 0.18469264f, -0.05195917f, 
    0.03031011f, 0.00753046f, -0.09618120f, 0.06723502f, 0.23762658f, -0.34396371f, 0.02374339f, 0.08562972f, 
    0.11404614f, -0.19071728f, -0.09519606f, -0.18311787f, 0.00076605f, -0.10869530f, -0.35857895f, 0.30544275f, 
    0.04036419f, 0.14817305f, 0.08349131f, -0.19208667f, 0.03294269f, -0.23923802f, 0.22332709f, 0.12172473f, 
    -0.04800710f, -0.11117669f, -0.19000211f, -0.26079258f, 0.19441786f, -0.00081852f, 0.03008561f, -0.12500672f, 
    0.08793082f, -0.19430299f, -0.00225938f, 0.11477005f, -0.08182770f, -0.02770885f, 0.16388072f, 0.14504461f, 
    -0.02815669f, -0.01276076f, -0.17955191f, 0.07960501f, -0.13239634f, 0.40813100f, -0.01753488f, -0.12009876f, 
    -0.18209623f, -0.02902535f, 0.14149648f, -0.22696820f, 0.16001230f, 0.21929285f, 0.04977147f, -0.07243473f, 
    -0.03275602f, 0.04780890f, 0.27926219f, 0.28316095f, 0.03406546f, 0.18187530f, 0.05526789f, -0.05255904f, 
    -0.03326596f, -0.08673660f, 0.28743696f, 0.22584112f, -0.10400863f, -0.38541546f, 0.02497970f, 0.10987975f, 
    -0.37256226f, -0.31906146f, 0.04308860f, -0.06263334f, 0.07852177f, 0.08915856f, 0.30940819f, -0.29839158f, 
    -0.09576241f, 0.12679711f, -0.03109218f, 0.12759085f, 0.11314478f, -0.05049143f, -0.39011234f, -0.42026052f, 
    -0.18603617f, 0.08629442f, 0.29702678f, 0.07598071f, 0.06707201f, -0.13574919f, 0.07788014f, 0.19734246f, 
    0.18768966f, 0.06106867f, 0.02078945f, -0.17143789f, -0.18490554f, 0.22201777f, -0.05813447f, 0.02022977f, 
    0.14025809f, 0.41344833f, 0.08341940f, 0.05451431f, 0.08535261f, 0.08937829f, -0.22668885f, -0.04131705f, 
    -0.21403614f, -0.13811764f, 0.06566375f, -0.04123658f, -0.05214483f, 0.19649474f, -0.38576216f, 0.26753199f, 
    0.00700712f, -0.08943074f, 0.16866201f, -0.04089456f, 0.17879505f, 0.04160358f, 0.02455958f, 0.09144002f, 
    0.09622037f, 0.04908404f, 0.18159671f, 0.12778875f, 0.21965887f, 0.05830897f, 0.27412462f, 0.08883430f, 
    0.15473220f, -0.17737241f, -0.26452643f, -0.06920997f, 0.01823971f, 0.37206024f, 0.07989493f, 0.24248049f, 
    0.03798919f, 0.02454974f, -0.05646043f, 0.17400911f, 0.26719239f, -0.00573398f, 0.12692806f, -0.07172897f, 
    -0.05334921f, 0.03983182f, -0.01381569f, 0.19892719f, 0.28647551f, 0.19779654f, 0.12423737f, 0.20053342f, 
    0.11720769f, 0.14942348f, 0.05052675f, 0.05069763f, -0.11349297f, 0.05221027f, 0.08868201f, 0.00577926f, 
    -0.02479714f, -0.01143728f, 0.44942093f, 0.02937948f, 0.05662891f, -0.24229290f, 0.09950349f, 0.05396835f, 
    0.15740433f, -0.25335991f, -0.07969382f, 0.06442045f, -0.20756367f, -0.02213331f, -0.05072185f, 0.26068962f, 
    0.05264207f, 0.38706228f, -0.11653785f, 0.04591743f, -0.17127004f, -0.17212360f, -0.04154124f, 0.06657098f, 
    0.12118357f, -0.00811158f, -0.23984918f, -0.00505199f, 0.01118585f, 0.23323154f, -0.29499280f, 0.33380976f, 
    0.25491893f, 0.21103446f, -0.08880812f, 0.16700225f, -0.18485259f, 0.24413155f, 0.21774760f, -0.09276603f, 
    0.33008417f, 0.28661481f, 0.12609738f, 0.00889934f, -0.09588753f, 0.09808713f, 0.04677534f, 0.23073490f, 
    0.01235929f, -0.18338709f, 0.07072123f, -0.07959729f, 0.17944570f, 0.16307846f, 0.04503556f, -0.26466605f, 
    0.01111205f, 0.04035834f, 0.19412519f, 0.14868727f, 0.13453563f, 0.00243016f, -0.25810784f, 0.09834431f, 
    0.15888080f, -0.49080819f, 0.02835160f, -0.10921805f, 0.07939295f, -0.05448317f, 0.08114056f, -0.02117572f, 
    0.19576648f, 0.04617127f, 0.16997005f, 0.16978264f, 0.06712159f, 0.19669415f, -0.49886844f, -0.20715326f, 
    -0.02497645f, 0.20601304f, -0.06500473f, 0.01259822f, 0.15783694f, -0.04673585f, 0.04553239f, 0.10881528f, 
    0.00900940f, -0.13322027f, 0.08743889f, 0.12925197f, -0.02841911f, 0.05319366f, -0.29693729f, 0.01686383f, 
    0.18159403f, -0.11695896f, 0.01493485f, -0.10424444f, 0.00260904f, 0.10333197f, 0.00035647f, 0.11429155f, 
    0.00920795f, 0.20539479f, 0.20148858f, -0.08899331f, -0.15007456f, 0.31155390f, 0.14635091f, 0.15700042f, 
    -0.01714013f, -0.08988804f, -0.06806731f, -0.08120559f, -0.08029456f, 0.06445599f, -0.08690269f, 0.04258894f, 
    -0.02112000f, -0.04914115f, -0.00069610f, 0.01124134f, -0.08618027f, 0.00164115f, -0.01942088f, -0.07619637f, 
    0.01964389f, 0.03963531f, -0.07771011f, 0.03179551f, 0.01375578f, -0.06837088f, 0.05947407f, 0.05676037f, 
    -0.04640982f, -0.02160651f, -0.05251877f, 0.01464721f, -0.00538454f, 0.00247351f, -0.06741954f, -0.02548445f, 
    -0.04850531f, -0.03000550f, -0.00227249f, -0.10334424f, -0.05572346f, 0.03219036f, 0.02641250f, -0.07397311f, 
    0.04458223f, -0.01778156f, -0.08143284f, -0.06140519f, -0.08116840f, -0.07445560f, -0.07044511f, -0.00785276f, 
    0.02918880f, -0.01149672f, -0.03198338f, -0.02045504f, -0.04325038f, -0.04192567f, -0.11513426f, 0.02318369f, 
    -0.05721424f, -0.08459434f, -0.00107125f, -0.07187951f, 0.01111903f, 0.02746629f, -0.03728323f, 0.04174101f, 
    0.03204434f, 0.07188912f, -0.10144506f, -0.03975726f, -0.01535850f, -0.08531079f, -0.06370620f, -0.09689618f, 
    -0.00285461f, -0.02660356f, -0.09590778f, -0.08795591f, -0.10350176f, -0.06375619f, -0.04230095f, -0.06008268f, 
    0.04266258f, -0.03717002f, -0.01371242f, 0.07078171f, -0.00872221f, 0.06771129f, 0.03384369f, 0.00266106f, 
    0.00901014f, -0.04100550f, -0.00775830f, 0.03380306f, 0.05447271f, 0.01738871f, -0.07550304f, -0.04298298f, 
    0.01387009f, -0.08797892f, -0.01235899f, -0.09656727f, -0.03727522f, -0.08020692f, -0.06876229f, -0.03892124f, 
    -0.02884349f, -0.01104723f, -0.01859056f, -0.02461815f, 0.05299367f, -0.04384167f, 0.08239734f, 0.05306535f, 
    -0.02781424f, 0.04275029f, 0.01318584f, 0.02768224f, -0.12342235f, 0.02131310f, -0.07065547f, -0.03223605f, 
    0.00161643f, 0.04776102f, -0.09381661f, 0.00601603f, -0.07996710f, -0.00067085f, 0.02372211f, 0.02424036f, 
    0.13367791f, 0.03292038f, -0.47505105f, 0.21880220f, 0.25364286f, 0.38326147f, 0.12116649f, 0.09858903f, 
    -0.46690589f, -0.01988870f, -0.02907309f, 0.12024993f, 0.01821876f, 0.29969257f, 0.21221140f, -0.30100089f, 
    0.02835941f, -0.06326988f, 0.19349025f, 0.16500230f, 0.17949572f, 0.35970226f, 0.31701407f, -0.14501224f, 
    0.07421401f, -0.18156339f, -0.04973418f, 0.07390108f, -0.45022589f, -0.13823828f, -0.07688820f, 0.21470338f, 
    -0.06024100f, 0.10737930f, -0.16837333f, 0.24902557f, -0.28821450f, -0.26205030f, -0.38439658f, 0.11563282f, 
    -0.09289139f, -0.08573554f, -0.05254720f, 0.13221923f, 0.20707498f, 0.32835203f, -0.24991916f, 0.18747036f, 
    -0.09385061f, 0.37183952f, -0.07794413f, 0.06094208f, -0.12821871f, 0.24825630f, 0.19636017f, -0.03856440f, 
    0.17176653f, 0.13642335f, -0.35930455f, -0.07644976f, -0.31306723f, -0.06842954f, -0.10357390f, 0.04184262f, 
    0.17903171f, -0.30440506f, -0.13223743f, -0.07872690f, -0.11063386f, -0.04580764f, -0.00530862f, -0.35113257f, 
    -0.02083305f, 0.00889722f, 0.14486602f, 0.09709986f, -0.10966013f, -0.01383330f, 0.42155561f, 0.02632162f, 
    0.01517495f, -0.28198683f, 0.04638440f, -0.07840990f, 0.00810274f, -0.00289495f, -0.05163424f, -0.08742359f, 
    0.13119780f, -0.06566572f, 0.22743842f, 0.35497466f, 0.09305431f, 0.20428991f, 0.08629317f, -0.34348899f, 
    -0.22068411f, 0.23228207f, -0.12640110f, -0.05017600f, 0.00594551f, -0.06963646f, -0.00954911f, 0.34945720f, 
    0.12519282f, -0.12592241f, 0.16296242f, 0.15131460f, -0.21580333f, -0.12547366f, 0.12327453f, -0.24360938f, 
    0.10153030f, 0.02407213f, -0.15186262f, -0.10832636f, -0.50574148f, -0.16172902f, -0.28433183f, 0.08054001f, 
    0.02387323f, 0.26585326f, 0.07577997f, -0.04465406f, 0.17899247f, -0.05842744f, 0.13902117f, 0.04679115f, 
    0.06187549f, -0.10420880f, -0.01814385f, -0.06147502f, -0.00736981f, 0.02169670f, 0.00973296f, -0.10374530f, 
    -0.05398175f, -0.05041216f, 0.08250971f, -0.07919008f, -0.04951562f, -0.06735621f, -0.12297326f, 0.04351464f, 
    -0.01989187f, -0.00565692f, 0.03832006f, 0.05415458f, 0.01282921f, -0.10877786f, -0.03831539f, -0.04593147f, 
    0.02820887f, -0.06145542f, 0.02315992f, 0.00543054f, -0.01435305f, -0.04438837f, -0.04112846f, 0.02174192f, 
    0.03273105f, -0.07294772f, 0.01010719f, -0.03673170f, -0.08986805f, 0.01263509f, -0.08091369f, 0.05174493f, 
    -0.09563848f, -0.02001047f, -0.02944504f, -0.01367611f, 0.03689785f, 0.07069036f, 0.04690145f, -0.01832156f, 
    0.02902322f, -0.00067656f, -0.04899394f, -0.02798625f, 0.05082041f, -0.00537541f, -0.01284801f, -0.08281700f, 
    0.05072706f, -0.03009715f, 0.04051891f, -0.12697661f, -0.02950316f, -0.00734395f, 0.01784135f, -0.01798406f, 
    -0.13421541f, 0.05879802f, -0.04025065f, -0.02570571f, -0.07286833f, 0.04850762f, -0.06149829f, 0.00704391f, 
    0.00056093f, -0.07849319f, -0.10262839f, 0.06516682f, -0.02908420f, -0.04137578f, -0.03450414f, 0.02965073f, 
    -0.03390611f, -0.00895819f, -0.08215643f, -0.02291996f, -0.05228150f, -0.01200956f, 0.03700902f, 0.05796296f, 
    -0.06970254f, -0.05986722f, -0.10848203f, -0.05770468f, 0.05527830f, -0.02816924f, -0.05035035f, -0.01676312f, 
    0.04228249f, 0.06357277f, 0.06725062f, -0.05994733f, 0.00193575f, 0.02589481f, 0.00473764f, -0.08887877f, 
    -0.06270837f, -0.02115518f, 0.03348606f, -0.04493112f, 0.00138625f, 0.01965392f, 0.00517956f, 0.01672237f, 
    0.06219235f, -0.06863829f, -0.08322328f, -0.03888545f, 0.04383213f, 0.06716819f, -0.09534505f, 0.00601021f, 
    0.01951632f, 0.05522096f, -0.03380774f, 0.03371801f, -0.03967213f, -0.11497244f, -0.00727776f, -0.00927102f, 
    -0.09515570f, -0.00042861f, -0.14367810f, 0.20113577f, 0.04947030f, -0.00661280f, 0.11178921f, 0.21345997f, 
    0.09670582f, 0.24641620f, -0.06749086f, 0.12080560f, -0.00644483f, -0.00588726f, -0.15655805f, 0.09725799f, 
    0.05917417f, 0.00907490f, 0.19720347f, 0.06326872f, 0.21915203f, -0.11959264f, -0.13071956f, 0.15228079f, 
    0.14550626f, -0.07692750f, -0.19534911f, 0.19223714f, 0.05891530f, -0.10277001f, 0.04851548f, -0.00651889f, 
    -0.09681396f, 0.42399144f, -0.20284665f, -0.15113676f, -0.32576171f, 0.13697533f, 0.08705204f, 0.12542327f, 
    -0.09089505f, 0.08009665f, -0.12008115f, -0.09230464f, -0.07829741f, -0.03593774f, -0.06784030f, 0.01361227f, 
    0.15259545f, -0.01005350f, -0.03648169f, -0.00238017f, -0.06176880f, 0.08032345f, -0.16071562f, -0.25848210f, 
    -0.15148586f, -0.01620858f, 0.02138837f, -0.18256967f, -0.06811237f, 0.13725694f, 0.26984158f, 0.07350111f, 
    -0.04301428f, 0.14430875f, -0.12259778f, 0.01477706f, 0.11272523f, 0.36923498f, -0.13710666f, -0.05546308f, 
    -0.07099702f, 0.04948258f, -0.10265202f, 0.20110074f, -0.00031336f, 0.07751706f, -0.16958763f, -0.01073678f, 
    0.02279654f, -0.04010520f, -0.06257299f, -0.00014308f, 0.03774431f, 0.02849961f, 0.01579787f, -0.00455433f, 
    0.08102868f, 0.02731412f, -0.07377838f, 0.25127664f, 0.17452289f, -0.01118931f, -0.57988769f, -0.02585331f, 
    0.01220418f, -0.14833789f, 0.28108427f, 0.09448298f, 0.14196435f, -0.05756160f, -0.03271091f, -0.05044910f, 
    0.12620598f, -0.05396739f, -0.10113848f, -0.00471974f, 0.21888115f, -0.10977834f, -0.05164639f, 0.12254041f, 
    -0.02959085f, -0.04115742f, 0.19060524f, -0.00681103f, -0.16095053f, -0.11855545f, -0.02535415f, 0.00711626f, 
    -0.08140719f, -0.06939119f, 0.09770112f, -0.14319347f, -0.23748825f, 0.01936779f, 0.11583652f, -0.04845425f, 
    0.13218091f, -0.01032348f, -0.33552164f, 0.23236941f, 0.20524542f, 0.28464249f, -0.42276740f, 0.07482143f, 
    -0.17059903f, 0.11290366f, -0.01213241f, 0.25038719f, 0.04515345f, 0.12105519f, 0.26354176f, 0.31154740f, 
    -0.00183524f, 0.04705941f, 0.38489085f, 0.11042786f, 0.00651720f, 0.24343105f, 0.21520197f, -0.03972727f, 
    -0.09043796f, -0.04728652f, -0.08939251f, 0.00816657f, -0.31217474f, -0.00564114f, 0.01389970f, 0.27165830f, 
    0.18684880f, -0.03503599f, -0.06397557f, 0.08687975f, 0.17121562f, 0.18491572f, -0.11000342f, 0.12005615f, 
    -0.24708416f, 0.20024197f, -0.04761414f, 0.41871002f, 0.23540615f, -0.18429105f, -0.51791036f, 0.27495423f, 
    0.17793861f, -0.31005576f, 0.07794552f, 0.01634600f, -0.05483518f, 0.02588731f, 0.28116548f, 0.09886619f, 
    -0.39128461f, 0.17416269f, -0.06124836f, -0.16818818f, -0.04935452f, -0.04582872f, 0.21619441f, 0.14038289f, 
    0.24068186f, -0.21204044f, -0.15537709f, 0.08803533f, -0.00259497f, 0.06329135f, 0.06611583f, -0.38285232f, 
    0.15259241f, 0.00819032f, -0.22054681f, 0.16512758f, -0.16398007f, 0.04151526f, -0.00023192f, -0.03462375f, 
    0.11013646f, -0.67217249f, 0.18000351f, 0.00971995f, -0.14049359f, -0.37944457f, -0.03439214f, -0.02216214f, 
    0.28850794f, 0.06724763f, 0.32611018f, 0.28095290f, -0.08809754f, 0.17455387f, -0.12688403f, -0.07517118f, 
    -0.31969339f, -0.04439995f, 0.18115579f, -0.04061015f, -0.17112210f, 0.07885462f, -0.01744791f, 0.20156586f, 
    0.08015779f, -0.00606144f, -0.00815070f, 0.12699938f, -0.02182926f, -0.19518451f, -0.07749784f, -0.25047714f, 
    -0.08439118f, 0.09060407f, -0.44647208f, -0.04609150f, -0.13179050f, -0.14585991f, -0.04458525f, -0.06939775f, 
    0.04672209f, -0.12357213f, -0.05854009f, 0.01437234f, -0.01822092f, -0.12521464f, 0.11015847f, -0.14863722f, 
    0.05130352f, 0.07293697f, 0.00145026f, 0.02109567f, 0.00417331f, 0.00342961f, 0.07307892f, -0.07418241f, 
    0.00265807f, 0.04815778f, 0.08004490f, -0.01398939f, -0.01501190f, 0.05616112f, -0.01288947f, -0.02397974f, 
    0.00667118f, 0.08612595f, 0.00344891f, 0.03372271f, -0.08793871f, 0.07707659f, 0.02080311f, -0.01993677f, 
    0.00689962f, -0.05594186f, -0.01227215f, 0.01043677f, 0.02998289f, -0.07546853f, 0.02531177f, -0.02549677f, 
    0.01299775f, -0.01218799f, -0.00166525f, -0.01890503f, -0.00639784f, 0.06403869f, -0.07916027f, 0.02703011f, 
    0.06206454f, -0.07673933f, 0.07149804f, -0.01082756f, -0.04978652f, 0.01745830f, 0.05066524f, -0.02295739f, 
    0.00341537f, -0.05341356f, 0.03248113f, 0.03100620f, 0.07041346f, -0.08790316f, 0.01775633f, 0.04985327f, 
    -0.06569980f, 0.05969273f, -0.05955631f, -0.05791866f, -0.02658880f, -0.09387875f, -0.06305136f, -0.00930029f, 
    -0.06814730f, -0.01209646f, -0.08154921f, -0.06439038f, -0.00453955f, 0.01608084f, -0.08361989f, 0.01441809f, 
    -0.06889662f, 0.03708465f, -0.05769903f, -0.09361564f, -0.02162564f, 0.00009870f, -0.07210703f, 0.04772067f, 
    -0.01857327f, -0.06063353f, 0.06669411f, -0.02716141f, -0.00274275f, 0.03889959f, -0.05274952f, -0.08388340f, 
    0.04293814f, 0.02009668f, -0.03569806f, 0.01637758f, -0.09590057f, 0.03931399f, -0.03741693f, -0.06900109f, 
    0.00048540f, -0.07749892f, -0.02755588f, -0.03894123f, 0.07925532f, 0.02778363f, -0.04527264f, -0.04523418f, 
    -0.02126675f, -0.05375104f, -0.09357335f, 0.01919868f, 0.04231181f, -0.07369821f, 0.02790278f, -0.08188691f, 
    0.04426785f, -0.03635165f, 0.06614479f, -0.03868838f, 0.00938160f, 0.03247102f, 0.04842632f, -0.05948526f, 
    0.02443144f, 0.06640588f, 0.00478263f, -0.07056062f, -0.06034313f, 0.01249731f, -0.07121818f, -0.09172539f, 
    -0.02987650f, 0.05411052f, -0.00109877f, 0.03624821f, 0.06431086f, 0.02272971f, -0.04217582f, -0.05545262f, 
    -0.09290738f, -0.07077821f, -0.08156837f, 0.05460890f, -0.01032178f, -0.05733443f, -0.05546790f, -0.04550327f, 
    -0.06532761f, 0.06506530f, 0.05022671f, -0.03862935f, -0.00410648f, -0.09143329f, -0.03803094f, -0.07932413f, 
    0.04684460f, -0.03147449f, 0.02973980f, -0.02712803f, 0.07920322f, 0.02885652f, -0.10068653f, 0.04129429f, 
    -0.04202371f, -0.03998394f, 0.01679121f, -0.08085462f, 0.04303278f, -0.02546610f, 0.03039797f, -0.02654608f, 
    -0.08760568f, -0.06753395f, 0.04662111f, -0.09914512f, -0.01942067f, 0.06565247f, -0.04514730f, 0.01394306f, 
    -0.01718905f, -0.08082187f, -0.04245142f, -0.02523635f, -0.08982725f, 0.00839569f, 0.07456124f, -0.07067658f, 
    0.06975248f, -0.01028546f, 0.04148555f, -0.06860236f, 0.04306947f, -0.07594021f, -0.02283756f, 0.02169021f, 
    0.02058264f, -0.00510961f, 0.03459615f, -0.09517118f, 0.08140074f, 0.05011616f, -0.08165529f, 0.06364484f, 
    -0.05664347f, -0.04834655f, 0.06822670f, 0.02842338f, -0.00110143f, 0.05770796f, 0.03143570f, -0.02107323f, 
    -0.07691655f, -0.02591486f, -0.02831225f, -0.08151201f, -0.03857119f, -0.06802381f, 0.07194138f, -0.01231689f, 
    -0.06392661f, -0.02592348f, 0.00401895f, 0.05482499f, 0.00453867f, -0.06139919f, -0.00448385f, -0.00467817f, 
    -0.08288469f, -0.06565992f, -0.04297052f, 0.04802178f, -0.02952351f, -0.03715605f, 0.06788890f, 0.07926801f, 
    -0.08237297f, 0.05911965f, 0.06903660f, -0.02184863f, -0.04116647f, 0.00189547f, 0.07312707f, -0.08783217f, 
    -0.04319035f, -0.09547485f, -0.08405920f, -0.04302791f, -0.07371248f, -0.03572179f, -0.09127505f, -0.04388471f, 
    -0.02037845f, 0.05485339f, -0.02277845f, 0.00999243f, 0.02782489f, 0.00559892f, 0.00250194f, -0.00951059f, 
    -0.10387260f, -0.07974464f, 0.04908858f, 0.17922176f, 0.26787895f, -0.20401250f, -0.53043133f, -0.27429485f, 
    0.14401664f, -0.09521124f, 0.04591439f, 0.19629699f, 0.04580627f, 0.20739374f, 0.23638073f, -0.07891178f, 
    -0.08505563f, 0.04237118f, 0.49258876f, 0.07862700f, -0.01858750f, 0.30431110f, 0.08767211f, 0.04748669f, 
    -0.39063019f, 0.12833922f, 0.12711638f, -0.09692162f, 0.02617274f, 0.06773349f, -0.11408889f, 0.12558110f, 
    -0.00429790f, -0.07285617f, 0.03656400f, -0.14584275f, 0.00532115f, 0.10758723f, 0.26278383f, -0.43310159f, 
    -0.12277528f, 0.13495463f, -0.06233947f, 0.21784936f, 0.06970135f, -0.14130795f, -0.63674325f, -0.03331218f, 
    0.03133175f, -0.38633835f, 0.03140542f, 0.10884718f, 0.10612115f, -0.23778133f, -0.07652084f, -0.08279312f, 
    0.08175433f, 0.06806767f, -0.08680402f, -0.18521805f, 0.17712773f, -0.33285412f, -0.28445539f, 0.09987528f, 
    0.11274484f, -0.07046346f, 0.11274748f, 0.03777252f, 0.00420843f, 0.00210859f, 0.09611658f, -0.18406384f, 
    0.23815225f, -0.29575330f, 0.01438411f, -0.20928569f, 0.00962020f, -0.03839490f, -0.11878949f, -0.05608024f, 
    0.32595798f, -0.35378560f, 0.10609096f, 0.00941767f, -0.19986315f, -0.76894480f, 0.05528162f, -0.07347022f, 
    0.05171454f, -0.18848705f, 0.02965491f, 0.05252191f, -0.25552246f, 0.10189663f, 0.05265762f, 0.11459785f, 
    -0.47806719f, -0.32035387f, 0.49029157f, 0.08322954f, 0.03083228f, -0.02964156f, -0.13736272f, -0.10977155f, 
    -0.04038751f, 0.07650369f, -0.10360192f, 0.08293393f, 0.31822923f, 0.12399867f, 0.22951555f, -0.08274235f, 
    -0.08147305f, -0.02975297f, -0.54346687f, -0.01827104f, -0.10218399f, 0.13263649f, 0.24073963f, 0.13061045f, 
    -0.04908061f, -0.31003630f, 0.10317951f, 0.13139777f, -0.02369190f, 0.04251608f, 0.10824515f, -0.11649029f, 
    0.01877990f, 0.03626266f, -0.06477707f, 0.01754294f, -0.11877178f, -0.02009818f, -0.04800705f, -0.08074337f, 
    -0.08916461f, -0.03328979f, 0.08400352f, 0.01045423f, -0.08221043f, 0.02144472f, 0.06071115f, -0.06241248f, 
    -0.04350723f, -0.07648404f, -0.02347987f, -0.11744129f, 0.01217047f, -0.01338485f, -0.07828420f, 0.03852758f, 
    0.02986979f, -0.00190726f, 0.03169408f, -0.04797385f, 0.04215240f, -0.08905505f, -0.07890376f, 0.00184669f, 
    0.06217014f, -0.01869732f, -0.10719389f, 0.06266422f, 0.01397435f, 0.00385628f, 0.04407302f, -0.07317460f, 
    0.09028223f, -0.09983194f, -0.05224042f, 0.03823883f, -0.00922280f, 0.06575800f, -0.10147338f, 0.04882769f, 
    -0.08579858f, -0.06543133f, -0.09394936f, 0.02169388f, -0.08422675f, -0.05825147f, -0.00069925f, -0.10702767f, 
    0.01209127f, -0.06584288f, 0.01032487f, -0.03079745f, -0.08124509f, 0.02696405f, -0.02802562f, -0.11577603f, 
    0.01808595f, 0.07956865f, -0.00217651f, -0.06590903f, -0.02895091f, 0.02254464f, 0.04530909f, 0.00312802f, 
    -0.03361244f, 0.04014038f, -0.02714016f, -0.04503230f, -0.07702249f, -0.02490040f, -0.00334228f, 0.00669621f, 
    -0.03865534f, -0.02271392f, -0.05821356f, 0.01512353f, -0.01562343f, -0.01955457f, -0.02542223f, -0.08665514f, 
    -0.00277356f, -0.10675949f, -0.07172351f, -0.05509596f, 0.02807751f, 0.07698006f, -0.11456613f, -0.08504378f, 
    -0.08882307f, -0.04762009f, -0.08355153f, -0.12093720f, -0.00451537f, -0.06173160f, -0.04644414f, -0.00249331f, 
    0.04305859f, -0.07631703f, 0.04794735f, 0.02635222f, 0.05368983f, 0.03667725f, -0.08824880f, -0.02250435f, 
    -0.04488118f, -0.09943336f, -0.02314787f, -0.11558510f, 0.02299330f, 0.05180238f, -0.10529306f, -0.10357399f, 
    -0.03649520f, 0.01680788f, 0.02382676f, 0.00134312f, -0.06870189f, -0.06329377f, -0.06699456f, -0.06380273f, 
    0.19417986f, 0.01540332f, 0.29255995f, -0.06957661f, -0.21893767f, -0.00272104f, 0.16799922f, -0.03301105f, 
    0.03953195f, 0.07144952f, 0.05186208f, 0.16516410f, -0.14322911f, -0.07350931f, -0.05161715f, 0.01773245f, 
    -0.00320713f, 0.03196962f, -0.28019360f, -0.10156014f, -0.15075931f, 0.00018090f, -0.12794642f, 0.26119965f, 
    0.12123524f, 0.08798591f, 0.19240908f, 0.06409969f, 0.13436185f, -0.10106913f, 0.01045199f, -0.01217562f, 
    -0.03304759f, 0.02635750f, -0.04685529f, -0.10835296f, -0.04928966f, 0.14749180f, 0.12393688f, -0.06630559f, 
    -0.09777430f, -0.05988671f, 0.25836718f, 0.07525618f, -0.09489909f, -0.49619642f, 0.17123537f, -0.09321204f, 
    0.03928404f, -0.27969909f, 0.03969943f, 0.03744076f, 0.20970598f, 0.21367815f, -0.30983725f, -0.25893822f, 
    0.24343792f, -0.09158091f, 0.23931269f, -0.07363826f, 0.00979614f, 0.03719365f, 0.39707434f, -0.04039437f, 
    0.07764648f, 0.25388995f, -0.04679058f, 0.13361661f, 0.05801635f, 0.06907878f, -0.23744392f, 0.18388177f, 
    0.05480875f, 0.08485596f, -0.16845694f, 0.07538690f, 0.28899983f, 0.05833505f, -0.02990341f, 0.00019065f, 
    -0.01868461f, 0.80095321f, 0.12914056f, -0.10099084f, -0.03230926f, 0.14930545f, -0.04018500f, 0.06301713f, 
    -0.12003630f, 0.11422830f, -0.06021234f, -0.05602410f, 0.12956122f, 0.02997016f, 0.05276783f, 0.11675999f, 
    0.20726012f, -0.25042960f, 0.29575601f, -0.01430131f, 0.06823705f, 0.06293531f, 0.09815831f, -0.02738967f, 
    0.09274316f, 0.04813328f, -0.00285555f, 0.04247813f, 0.16954511f, -0.05244270f, 0.26572999f, 0.18352006f, 
    0.08914754f, 0.07138000f, 0.33238918f, 0.06469811f, -0.07646608f, -0.17378449f, 0.29235786f, 0.05972495f, 
    0.02837264f, 0.05642866f, -0.03487182f, 0.01492033f, -0.17395990f, -0.35032651f, 0.02657310f, -0.27241051f, 
    0.02363211f, 0.07058434f, 0.03599056f, 0.07024269f, 0.02765505f, -0.06982941f, 0.03779587f, -0.04915582f, 
    -0.01806623f, 0.04769123f, -0.04321343f, 0.03107082f, -0.08343864f, -0.05318058f, -0.10474040f, 0.06708521f, 
    -0.02550061f, 0.01070218f, 0.02488372f, -0.10390413f, 0.00194516f, 0.00534625f, 0.03565867f, -0.03635948f, 
    -0.08717680f, -0.07431507f, -0.00863408f, 0.00690395f, -0.03731693f, -0.08772472f, -0.00501889f, -0.05939525f, 
    -0.04644743f, -0.00256335f, 0.04002609f, 0.07833309f, -0.02195338f, 0.02271566f, 0.02862463f, 0.03153931f, 
    -0.04518383f, 0.02422308f, 0.00027293f, -0.02585727f, -0.01989407f, -0.08028006f, 0.00899455f, -0.04111528f, 
    -0.09919899f, -0.02192822f, 0.01912064f, 0.00210327f, -0.03237410f, -0.02240472f, 0.06605086f, -0.02454531f, 
    -0.04567420f, -0.09625176f, -0.06525923f, 0.02907225f, -0.06094970f, 0.00876001f, 0.03713590f, -0.04560578f, 
    -0.07539341f, 0.00688203f, 0.01513683f, -0.10904260f, -0.07694274f, -0.09131606f, 0.00175814f, -0.06069239f, 
    0.02170771f, -0.11945190f, -0.02003667f, -0.09363656f, 0.06563042f, -0.03151798f, 0.08544201f, 0.07268018f, 
    0.08144696f, -0.08232363f, 0.03983827f, -0.08333798f, -0.09251490f, 0.01085416f, -0.07995567f, 0.07163104f, 
    0.04019515f, 0.05537792f, 0.00042669f, 0.05232419f, -0.02696444f, -0.08978706f, 0.02019878f, 0.02083163f, 
    -0.07529272f, 0.01206911f, 0.05153484f, -0.07012650f, 0.00195659f, 0.07395039f, 0.05654745f, -0.04041260f, 
    -0.03911695f, -0.00828345f, 0.06337520f, -0.05649534f, -0.00947205f, 0.04177921f, -0.06164742f, -0.04054201f, 
    -0.10179761f, -0.11025584f, 0.04880232f, -0.05397696f, -0.06206646f, -0.11170802f, -0.01399773f, 0.05665929f, 
    0.07297259f, 0.00063734f, 0.02389353f, -0.03983815f, -0.07231533f, -0.00151020f, 0.01655445f, 0.04803803f, 
    -0.08139151f, -0.09088389f, 0.05746388f, 0.04054208f, -0.05140524f, 0.01315969f, -0.06823546f, 0.01118542f, 
    -0.05942337f, -0.06911572f, 0.07970995f, -0.08733717f, -0.00085752f, -0.04115015f, -0.05018713f, -0.01888352f, 
    0.08399125f, -0.08766066f, -0.07637244f, 0.05736288f, 0.01991506f, 0.00523622f, 0.05099297f, 0.04184990f, 
    -0.05225355f, -0.06146690f, 0.03109815f, 0.02592500f, 0.03938643f, -0.09497395f, -0.00054687f, 0.07862915f, 
    0.03142980f, -0.08714595f, 0.02640703f, 0.01528411f, -0.02422225f, 0.05946083f, -0.05476111f, -0.03085063f, 
    -0.04471448f, -0.06199167f, 0.03839249f, -0.07867740f, -0.08010101f, 0.08533082f, -0.04365451f, -0.02361262f, 
    -0.10801246f, -0.04165490f, -0.06996633f, -0.05960944f, 0.00041792f, 0.05788276f, -0.02195326f, -0.01867564f, 
    -0.04739880f, -0.03297028f, -0.03268541f, 0.03498903f, -0.07120744f, -0.04801593f, 0.05713255f, 0.01541097f, 
    -0.02471169f, 0.03024637f, -0.01178908f, -0.11006969f, -0.06164739f, 0.07565779f, 0.04312266f, 0.08224136f, 
    -0.08622575f, 0.01421157f, -0.02308447f, -0.08287791f, 0.06458831f, -0.04787647f, -0.02033484f, 0.03130642f, 
    -0.05509677f, 0.01536007f, -0.10222732f, 0.02750213f, -0.01432141f, -0.06034296f, -0.00297322f, 0.04603668f, 
    -0.00235365f, 0.03940971f, 0.06108325f, -0.01035680f, 0.00030022f, 0.08529829f, 0.00230083f, -0.03223008f, 
    0.05781754f, -0.01203943f, 0.01387962f, -0.03978518f, -0.06024370f, -0.03069922f, 0.04149570f, 0.03465338f, 
    -0.01196874f, 0.02111866f, 0.03562639f, 0.01139886f, 0.02353960f, 0.04835548f, 0.05079004f, 0.02340691f, 
    -0.05285358f, -0.05210440f, -0.01199460f, -0.03447138f, -0.00560694f, 0.02352276f, -0.07202408f, -0.05130649f, 
    -0.01924471f, -0.02890674f, -0.01725084f, 0.06442569f, 0.05403471f, 0.02120360f, 0.05615723f, -0.01571349f, 
    0.17717543f, 0.17680436f, -0.04972519f, 0.07473442f, 0.27276978f, 0.11720417f, 0.11674184f, 0.07041128f, 
    -0.23056664f, 0.11105701f, -0.05890018f, -0.06212665f, -0.45978925f, -0.20003361f, 0.22007333f, -0.09012301f, 
    -0.02420100f, 0.00729898f, -0.17197119f, 0.03152193f, -0.14952095f, -0.42718267f, -0.00426423f, -0.42177841f, 
    -0.03392539f, -0.32167640f, -0.20469609f, 0.14737454f, -0.19882573f, -0.14075877f, -0.14610650f, -0.17209233f, 
    0.12403447f, -0.67425746f, -0.33839709f, -0.40904054f, 0.24770914f, -0.17743111f, -0.21606334f, 0.06961520f, 
    0.18719123f, 0.03009459f, 0.03786031f, 0.25156406f, -0.14773591f, 0.00506069f, 0.29166758f, 0.18737735f, 
    -0.03789376f, 0.37071773f, 0.16520797f, -0.49881497f, -0.42932141f, 0.26473105f, -0.05603830f, -0.14157133f, 
    0.02429200f, 0.12884903f, -0.04465320f, 0.13197432f, -0.05641535f, 0.25375208f, -0.36169919f, -0.04870320f, 
    0.07652005f, -0.01399463f, -0.38615406f, -0.21623074f, -0.55009079f, -0.69876772f, -0.09516310f, 0.20971932f, 
    -0.10640016f, 0.10067151f, 0.20325014f, 0.07678356f, -0.27462369f, -0.03268615f, 0.25627136f, -0.02797299f, 
    -0.02496321f, 0.08802112f, -0.02004513f, -0.29132828f, -0.10359464f, 0.18735459f, -0.25376806f, 0.05622905f, 
    0.06021219f, 0.02477461f, 0.06344047f, -0.05263341f, 0.16066673f, 0.07901002f, -0.03629892f, -0.30312911f, 
    0.11840706f, 0.18168138f, -0.31051308f, -0.43673238f, -0.44455823f, 0.01018821f, 0.19278827f, -0.01163147f, 
    0.00964871f, -0.06594121f, -0.17965946f, 0.07179783f, -0.05680404f, -0.08881014f, -0.09965850f, 0.01908646f, 
    0.12875742f, -0.36506203f, -0.03989489f, -0.23110041f, 0.09922498f, -0.20463663f, -0.13901322f, 0.26033530f, 
    -0.08368053f, 0.18207946f, 0.16994901f, -0.32295811f, -0.06055334f, -0.00760796f, 0.10957109f, 0.10727234f, 
    0.02948041f, 0.05502813f, 0.05331858f, 0.01500548f, -0.05188032f, -0.05807709f, 0.06478237f, 0.03355348f, 
    -0.10061186f, -0.03326526f, 0.08217641f, -0.09118114f, 0.01744818f, -0.04564983f, 0.02043592f, -0.02122881f, 
    0.00698383f, -0.04690435f, 0.04403018f, -0.03436009f, -0.10534559f, -0.00587850f, -0.05383674f, -0.06943860f, 
    0.05068973f, -0.02340942f, -0.01433168f, 0.05749505f, 0.01336186f, -0.08680151f, 0.04705786f, -0.08678408f, 
    0.01276684f, -0.01708237f, -0.08826795f, 0.03618895f, -0.09122044f, -0.03165954f, -0.01976280f, -0.03500398f, 
    -0.01550320f, -0.01166884f, 0.04808777f, 0.06113301f, 0.00257188f, 0.05168236f, -0.01155190f, -0.08110962f, 
    0.03330540f, -0.07842975f, -0.03879249f, -0.05643290f, 0.05334454f, 0.02225357f, 0.04420411f, -0.04942609f, 
    -0.03155782f, 0.02007147f, 0.03795762f, -0.03608106f, -0.02600557f, -0.01651035f, -0.04064512f, 0.01842926f, 
    -0.05081900f, 0.06615220f, 0.01560330f, 0.05381926f, 0.05695513f, -0.07691837f, -0.05236889f, 0.02317827f, 
    -0.03615441f, -0.09825537f, 0.05248864f, -0.02808300f, 0.05556938f, 0.03517920f, -0.00343650f, -0.06520211f, 
    0.04227988f, -0.03122402f, -0.08609126f, -0.07303394f, -0.04090031f, -0.08551011f, -0.03718832f, 0.06433037f, 
    -0.10009751f, -0.03260926f, -0.05499545f, -0.05138535f, -0.01542249f, -0.08014123f, 0.01366122f, 0.05613426f, 
    0.02431127f, 0.07997657f, -0.00075805f, -0.07073557f, -0.00914500f, 0.05560871f, 0.04282701f, 0.00784855f, 
    0.03584490f, 0.02317542f, -0.08213093f, 0.00161756f, -0.00226672f, 0.05879902f, -0.03571769f, -0.00475021f, 
    0.04388438f, -0.00028320f, 0.00368805f, -0.08613452f, 0.03003657f, 0.00250954f, 0.02662460f, 0.05391116f, 
    0.03107973f, 0.03522043f, -0.00313789f, -0.08309904f, 0.00719210f, -0.03220597f, -0.07972538f, 0.02431125f, 
    -0.14202897f, -0.07013622f, -0.37392187f, -0.17070201f, 0.20519367f, 0.04612090f, 0.14420225f, -0.06828635f, 
    0.09659317f, -0.07772077f, -0.01245649f, 0.10430331f, -0.04596436f, -0.12302621f, 0.01722357f, 0.10057969f, 
    0.01219732f, 0.06969257f, 0.06559854f, 0.07096538f, -0.13227822f, 0.23728693f, -0.18469734f, -0.13854517f, 
    0.04896807f, -0.09608256f, 0.19937755f, -0.08629683f, 0.21908659f, 0.11534812f, 0.01522975f, -0.15727612f, 
    0.11563712f, -0.00044591f, 0.10872078f, 0.01546463f, -0.20221139f, 0.17123826f, 0.13729917f, 0.08189858f, 
    -0.10404833f, -0.01497121f, 0.20173481f, 0.09291540f, -0.06984635f, -0.25405717f, 0.20211539f, 0.27470422f, 
    -0.33720562f, -0.09860398f, 0.02930879f, -0.01688162f, 0.08227497f, 0.03881225f, 0.30533046f, -0.22646210f, 
    -0.04155509f, 0.07278562f, -0.14802185f, -0.00026826f, 0.08530046f, 0.06602758f, -0.12547113f, -0.31516108f, 
    -0.01895669f, 0.08413833f, 0.18727304f, -0.06774530f, -0.00885227f, -0.12347862f, 0.04850386f, 0.29979172f, 
    0.31597558f, 0.06670084f, 0.13934818f, -0.09360613f, -0.53251767f, 0.16141824f, -0.13006675f, 0.04908484f, 
    0.35180900f, 0.14901957f, 0.00132583f, 0.12434557f, 0.06390028f, 0.18283719f, -0.03116051f, -0.08041743f, 
    -0.12895215f, -0.13417909f, 0.17625330f, 0.02680448f, -0.19287992f, 0.12108383f, -0.20916249f, 0.19552836f, 
    0.01430192f, 0.00455371f, 0.09727929f, -0.03663092f, 0.20112705f, 0.08154967f, -0.04581526f, 0.16615060f, 
    0.03554979f, 0.05866824f, 0.02562147f, 0.05878843f, 0.12399962f, 0.00077601f, 0.19447979f, 0.09664842f, 
    0.25276819f, -0.16842487f, -0.17608005f, -0.09446592f, -0.07601332f, 0.34280434f, 0.09748985f, 0.14782520f, 
    -0.03406597f, 0.15958609f, 0.09369960f, 0.07486382f, 0.12488896f, -0.06392414f, 0.16554880f, -0.13710614f, 
    -0.06616531f, -0.04476006f, -0.38861123f, -0.01590770f, 0.00322576f, 0.18903899f, 0.04961620f, 0.02651651f, 
    -0.03617381f, -0.08286099f, -0.05271262f, -0.08917927f, -0.11314379f, 0.08546253f, 0.02371208f, 0.25199795f, 
    0.02073496f, 0.07678268f, 0.02251445f, 0.18692310f, 0.10123052f, 0.11404568f, -0.00040528f, -0.10873293f, 
    0.13550733f, -0.10421881f, 0.04144557f, -0.08068439f, -0.03511741f, 0.12268322f, 0.07506372f, -0.13083762f, 
    0.09043885f, 0.30115902f, -0.14259529f, 0.26545736f, -0.30246741f, -0.10936937f, 0.05835653f, 0.13546459f, 
    0.11788195f, -0.06479924f, 0.04513315f, 0.01851597f, -0.11050293f, -0.34369925f, -0.16264774f, 0.10624698f, 
    -0.13005370f, -0.22552028f, -0.13758042f, 0.16008954f, -0.00571374f, 0.24446529f, 0.11141535f, -0.12484369f, 
    -0.21745095f, 0.12964286f, 0.18201455f, -0.00299365f, 0.02051613f, 0.09190436f, 0.02383232f, -0.11785799f, 
    -0.01373402f, -0.13563457f, 0.15116547f, -0.07392677f, 0.16265915f, -0.00366745f, -0.14047261f, -0.03833042f, 
    0.25022635f, -0.05363865f, -0.01016204f, 0.13489473f, -0.16448627f, 0.04844921f, -0.22375990f, 0.08856913f, 
    0.17592748f, -0.44443008f, -0.02194469f, 0.04922257f, 0.14874314f, 0.04029400f, -0.17174022f, 0.01834823f, 
    -0.14857087f, -0.09534318f, 0.16867360f, 0.08621188f, -0.00997515f, 0.20032948f, -0.22826909f, 0.06764290f, 
    -0.05832130f, -0.10169785f, 0.16076991f, 0.05779605f, 0.32433480f, 0.00925051f, 0.09070178f, 0.21941793f, 
    0.01869009f, 0.06699618f, 0.02126616f, 0.26943406f, 0.01700759f, -0.02010171f, -0.17199932f, -0.05971264f, 
    0.06036784f, -0.06998184f, -0.22667234f, -0.07895253f, -0.14505588f, 0.19363710f, 0.11168595f, 0.21703185f, 
    -0.05787270f, 0.07550184f, 0.20861585f, 0.02139524f, -0.05211679f, 0.14198661f, 0.17246909f, -0.04823126f, 
    0.27794442f, -0.26298490f, -0.44500223f, 0.13459551f, -0.10275757f, 0.21078180f, 0.04833961f, 0.27041471f, 
    0.05810893f, 0.10074544f, 0.00456553f, 0.15405439f, -0.22642861f, -0.16013463f, -0.29351753f, 0.23012112f, 
    -0.08127023f, 0.03944426f, -0.00920414f, 0.05623187f, -0.33052793f, -0.23996028f, -0.04503456f, 0.04619424f, 
    0.11766563f, -0.25383908f, -0.28464115f, 0.33353925f, 0.23844588f, 0.06414589f, 0.13816346f, 0.19600318f, 
    0.15986617f, 0.18114403f, -0.33093289f, -0.18640402f, 0.48291674f, 0.08760908f, 0.12313426f, 0.20387836f, 
    -0.03882112f, -0.13767242f, 0.24732029f, 0.27440861f, -0.14443606f, -0.11257238f, -0.05356446f, -0.01006148f, 
    0.20917271f, -0.19736573f, -0.02832978f, -0.06047352f, -0.19427401f, 0.11866637f, -0.13975601f, -0.04142386f, 
    -0.22662817f, -0.06123261f, 0.15777227f, 0.01699191f, -0.03124154f, 0.21323171f, 0.37981477f, 0.12599228f, 
    -0.11592561f, 0.07548457f, -0.41084424f, -0.15147144f, -0.02645027f, -0.01466168f, -0.12709698f, 0.16689578f, 
    -0.31323501f, 0.05055159f, -0.19860427f, 0.26282272f, 0.41231725f, 0.07212959f, 0.28572512f, -0.01524211f, 
    0.20086470f, -0.04817034f, 0.02378284f, -0.02196428f, -0.00304991f, 0.05992294f, -0.12451508f, 0.00780154f, 
    0.11666294f, 0.11605135f, 0.09034427f, -0.09171047f, 0.24479553f, 0.11355954f, -0.78228617f, 0.02918289f, 
    0.21781786f, -0.13081627f, 0.13469228f, -0.24322206f, -0.24763760f, 0.05345808f, -0.00730760f, -0.15803324f, 
    0.03883284f, -0.13616665f, 0.01872822f, 0.17922223f, 0.24164982f, -0.39997050f, 0.04084739f, 0.12652114f, 
    -0.00567056f, 0.07877865f, 0.09174800f, -0.27011129f, 0.08523036f, -0.14445455f, 0.08211055f, -0.10761711f, 
    0.02172495f, 0.00686505f, 0.11852475f, -0.05986337f, 0.08982526f, -0.26390788f, 0.04931696f, -0.10010719f, 
    -0.13538831f, -0.06034644f, -0.21055295f, 0.23623496f, 0.05783216f, 0.24422500f, 0.01622735f, 0.26363635f, 
    0.23277350f, 0.18449281f, -0.07487026f, -0.06206197f, -0.12871294f, 0.03273438f, -0.24932709f, 0.10617415f, 
    -0.04196803f, 0.01408796f, 0.34805411f, 0.09414349f, -0.30172002f, -0.25359949f, 0.04441272f, 0.02505252f, 
    0.04304780f, -0.23443666f, 0.01178214f, 0.31578860f, 0.33252761f, -0.05882122f, -0.04684858f, 0.41572452f, 
    -0.18315640f, 0.34901741f, -0.31588534f, -0.05959535f, -0.01327691f, 0.17569663f, 0.13333307f, 0.02429940f, 
    -0.35248584f, -0.09226467f, -0.03850525f, -0.02249821f, 0.01742428f, 0.31729507f, 0.00123632f, -0.18794547f, 
    0.24238367f, 0.12351144f, 0.00424397f, -0.21748947f, -0.18905312f, -0.04102857f, 0.16161765f, -0.03115645f, 
    0.03752921f, 0.18496044f, -0.15804474f, -0.37051919f, 0.06069048f, 0.19484523f, 0.04345338f, 0.22722067f, 
    0.03169153f, 0.27570766f, -0.12934379f, -0.07886379f, 0.11122078f, 0.30232367f, -0.16026720f, 0.21321620f, 
    0.09897662f, 0.03816414f, 0.08493866f, 0.22956310f, 0.10850296f, 0.18287157f, -0.03069285f, 0.07364781f, 
    0.19058166f, 0.08667601f, -0.13417612f, -0.03860297f, 0.13887723f, 0.13655269f, -0.13293535f, -0.06396156f, 
    0.15617634f, -0.02617073f, -0.08608162f, 0.29897809f, 0.14299722f, 0.07907862f, -0.17645268f, 0.05530896f, 
    0.04859700f, -0.03545752f, 0.19527383f, -0.14809379f, 0.17074408f, -0.02167326f, -0.23419853f, 0.29412577f, 
    0.01440725f, -0.22761989f, -0.06239314f, -0.02690494f, 0.36884892f, 0.16363651f, -0.11369656f, 0.46982723f, 
    -0.03148360f, -0.09326018f, 0.13559952f, 0.08830797f, -0.01706271f, 0.25162420f, -0.25804105f, 0.27161911f, 
    0.05005481f, 0.14910927f, 0.26667950f, -0.14532666f, -0.17210136f, -0.11248089f, 0.26800236f, 0.02781102f, 
    0.33970755f, -0.08278348f, -0.26882941f, 0.05021787f, 0.30969211f, 0.09610404f, -0.08860903f, 0.04508284f, 
    0.02263046f, 0.24289225f, -0.04010816f, -0.02240853f, -0.11213255f, 0.09922465f, 0.13728294f, -0.22264658f, 
    0.01153221f, -0.02772541f, 0.31097955f, -0.07617871f, -0.51871192f, -0.07574692f, -0.07060415f, 0.17831171f, 
    0.00976525f, -0.12901506f, 0.19038552f, 0.05971164f, 0.36786872f, -0.00620922f, -0.04906029f, 0.01989479f, 
    0.14900993f, -0.08511683f, 0.01022668f, -0.20870790f, 0.21535116f, 0.34098339f, 0.13083041f, -0.13862708f, 
    -0.37856495f, 0.08989123f, 0.02307675f, 0.09678905f, 0.00192288f, 0.27512932f, 0.24659677f, 0.05595969f, 
    0.15206824f, 0.27963552f, 0.04758430f, -0.15660504f, 0.01836427f, 0.01163731f, 0.16097929f, -0.07055393f, 
    0.07807738f, 0.12508203f, -0.37418079f, -0.42104787f, -0.05358138f, 0.13226682f, 0.28443843f, -0.07561296f, 
    0.02255047f, 0.21413250f, -0.05309002f, -0.01020315f, -0.06480823f, 0.12311552f, 0.10603871f, 0.29693806f, 
    0.17565881f, -0.06182498f, 0.32105908f, -0.04811452f, -0.40890029f, 0.12665573f, -0.38786161f, -0.04968977f, 
    0.10353480f, 0.27903315f, -0.09562085f, -0.01840122f, 0.00354898f, -0.00196628f, -0.14138009f, 0.06088448f, 
    0.14723778f, -0.25890538f, 0.03679028f, 0.17398606f, -0.09111258f, 0.01291257f, -0.07140290f, 0.09585924f, 
    -0.10371037f, 0.31237033f, 0.07115729f, -0.06795253f, 0.04138285f, 0.01543689f, -0.08491164f, -0.00671501f, 
    0.02361986f, -0.06840257f, -0.14917675f, -0.19202846f, 0.33322540f, -0.00312960f, 0.14586863f, 0.36327076f, 
    0.05102876f, -0.15237184f, -0.05316053f, 0.02046674f, 0.01961572f, 0.11431692f, -0.08055605f, 0.32594287f, 
    0.10260680f, 0.14567798f, 0.15169200f, -0.17636122f, -0.16361119f, -0.22347419f, 0.20055617f, -0.02825442f, 
    0.08969787f, 0.03745308f, -0.40466923f, -0.06485600f, 0.38551751f, -0.05996821f, 0.14050192f, -0.07639302f, 
    -0.08408619f, 0.23193909f, 0.02594926f, 0.08029043f, 0.08495694f, 0.19141021f, 0.20415398f, -0.68013245f, 
    -0.01093396f, -0.03678196f, 0.08710863f, 0.30844811f, -0.27618730f, 0.22027548f, -0.01749704f, 0.03837251f, 
    -0.14279594f, 0.09151589f, -0.07658169f, 0.09055182f, 0.26439789f, -0.06622732f, 0.06809899f, -0.15627012f, 
    -0.10463282f, -0.10418702f, 0.09191244f, -0.12788345f, -0.21594957f, -0.02516032f, 0.10032103f, -0.08860481f, 
    -0.17426679f, 0.06103808f, -0.13383304f, -0.02237392f, 0.04418163f, 0.06902371f, 0.36188456f, 0.09088930f, 
    -0.14466579f, 0.27101243f, 0.12261853f, -0.00761246f, 0.16478680f, 0.09403715f, 0.26064536f, -0.29841939f, 
    0.21979985f, 0.06264424f, -0.40839911f, -0.27677518f, -0.15076147f, 0.04487779f, -0.00764742f, -0.31732726f, 
    -0.02030607f, -0.09470009f, 0.09905052f, 0.00264813f, 0.06357254f, -0.06201931f, 0.15131024f, 0.15216662f, 
    0.18290462f, -0.21143581f, 0.39598745f, -0.16355596f, -0.28064850f, 0.11335015f, 0.00286231f, -0.06630012f, 
    0.00350274f, 0.07131195f, -0.05615507f, 0.03160767f, 0.17748031f, -0.04400392f, -0.09725765f, 0.04453138f, 
    0.04305564f, -0.38127431f, 0.01519800f, 0.14377172f, -0.05722750f, 0.01807921f, -0.13927606f, -0.01335231f, 
    -0.29899967f, 0.29732156f, -0.22454338f, 0.02941122f, 0.11969078f, 0.04362012f, -0.07323904f, -0.02418147f, 
    0.10590225f, 0.08981374f, 0.08328763f, -0.11785046f, 0.21338832f, -0.03920291f, 0.27775648f, -0.02475814f, 
    0.04709818f, -0.15338558f, -0.10298085f, 0.05855748f, -0.12474730f, 0.16566247f, -0.32331124f, 0.30519444f, 
    -0.01142463f, 0.13844177f, 0.03144145f, 0.01222442f, 0.09122527f, 0.05060696f, -0.04767643f, 0.15963709f, 
    -0.10123675f, 0.09529452f, -0.70306826f, 0.06777011f, 0.10337486f, 0.27308580f, -0.16768903f, 0.08516286f, 
    -0.17938760f, -0.03564632f, -0.06059252f, 0.02680216f, 0.07894403f, 0.16043493f, 0.06553617f, 0.01209266f, 
    -0.01839145f, -0.07035931f, -0.20257647f, 0.08373729f, 0.27074254f, 0.27078259f, 0.13434345f, -0.02115101f, 
    -0.02950490f, -0.14312339f, 0.06224472f, 0.06772204f, -0.30699593f, -0.04990803f, -0.06644255f, 0.18923779f, 
    -0.16800930f, 0.26036504f, -0.05769795f, 0.24133217f, -0.19115451f, -0.00671876f, -0.18345556f, 0.13148777f, 
    -0.32032686f, -0.21224035f, -0.09209896f, 0.11102807f, 0.20617947f, -0.01818763f, -0.32900417f, 0.16134258f, 
    0.09250522f, 0.01050349f, -0.08685588f, -0.22071615f, -0.15641607f, 0.00900518f, 0.28401804f, 0.02061236f, 
    -0.44255793f, 0.07966749f, -0.28253043f, -0.04458850f, -0.11083540f, 0.04334557f, -0.09818772f, 0.01426846f, 
    0.14409202f, -0.19694242f, -0.30294010f, 0.12606315f, 0.07691962f, 0.05455744f, -0.24361496f, -0.26199856f, 
    -0.00159807f, 0.13013545f, -0.21079966f, 0.08169237f, -0.08801901f, 0.08594137f, -0.04148849f, 0.03529781f, 
    -0.10436196f, -0.31295699f, 0.00084623f, 0.05522271f, 0.08054862f, 0.02796194f, 0.06199009f, 0.05352437f, 
    0.12953967f, 0.01838250f, 0.14020415f, 0.25927296f, -0.01779036f, -0.10039540f, 0.05086848f, -0.17633367f, 
    -0.16077052f, 0.16873829f, 0.02899693f, 0.16258064f, -0.00669077f, -0.05312745f, -0.10797522f, 0.30456588f, 
    0.17411834f, -0.12255576f, 0.15034747f, 0.03485319f, -0.34984902f, -0.19918960f, 0.07935838f, -0.18363442f, 
    0.06160342f, 0.14627433f, -0.07567888f, 0.04740369f, -0.26370355f, 0.10024662f, -0.05190253f, -0.08522022f, 
    0.01694167f, 0.10978124f, 0.08773275f, -0.09122206f, 0.08814209f, -0.16115606f, 0.03223344f, -0.13052052f, 
    -0.10211658f, 0.13690281f, 0.07813004f, -0.32570136f, -0.00304033f, -0.17206375f, 0.30824313f, -0.20467453f, 
    0.20384178f, -0.37846208f, 0.03291022f, 0.05868959f, -0.16798919f, -0.29762170f, -0.11470787f, 0.21095060f, 
    0.02131782f, 0.01768918f, 0.01328824f, 0.08570527f, -0.12123442f, 0.01128463f, -0.45290023f, -0.40937623f, 
    0.17161416f, -0.18290576f, -0.08896482f, -0.17511524f, -0.01673460f, 0.09015934f, -0.05345626f, -0.14547609f, 
    0.04420283f, -0.04209784f, 0.08347662f, -0.03478502f, 0.10765903f, -0.02729150f, -0.01473567f, 0.18497752f, 
    0.16449128f, -0.06969019f, 0.23199107f, -0.02306633f, -0.26126179f, 0.07908596f, 0.21917769f, 0.29475769f, 
    -0.33744487f, -0.14088295f, 0.23079738f, 0.01620717f, 0.11327714f, 0.17002054f, 0.22167915f, 0.03735208f, 
    0.36506864f, 0.06967035f, 0.20833664f, 0.23050258f, 0.10548387f, 0.06411705f, -0.17989525f, -0.29918888f, 
    -0.44354284f, -0.02671803f, 0.15086544f, 0.16075526f, -0.13308041f, -0.33434784f, 0.05847122f, 0.06715087f, 
    0.10808081f, -0.02569666f, 0.12518620f, -0.24594818f, -0.14298747f, 0.08704625f, -0.11280878f, -0.01495459f, 
    -0.04718162f, 0.20321529f, -0.03876682f, 0.10352922f, 0.09359761f, 0.31994811f, -0.04780077f, -0.00691581f, 
    -0.15960120f, -0.07856192f, -0.01560071f, -0.39725971f, -0.11038141f, 0.07404348f, -0.16729428f, 0.08680740f, 
    0.33249429f, -0.39990738f, -0.06760702f, 0.09993347f, 0.02875971f, -0.01292994f, 0.06007770f, -0.05943104f, 
    -0.33012655f, 0.09261253f, 0.23469611f, 0.14370514f, -0.01831603f, -0.05949461f, 0.00853104f, 0.11176833f, 
    0.15802145f, -0.17953748f, -0.09976258f, 0.02478350f, 0.12271352f, 0.28600815f, 0.11710135f, -0.07590337f, 
    0.00063730f, 0.09956659f, 0.00392598f, 0.06961568f, 0.25679019f, 0.21026988f, 0.14639328f, 0.19555475f, 
    0.13228339f, -0.11081034f, -0.23511206f, 0.04240713f, -0.07223465f, 0.28607634f, -0.07116558f, 0.32186148f, 
    -0.00176868f, -0.00007016f, -0.05188879f, 0.14699855f, -0.21303783f, -0.29065946f, -0.16675121f, 0.44663155f, 
    0.01916920f, -0.08278479f, -0.31984746f, -0.04008907f, -0.23314725f, -0.08670859f, -0.05498997f, -0.01699359f, 
    0.16302581f, -0.31671038f, -0.03565452f, 0.15039708f, 0.25857350f, 0.11310814f, 0.16580808f, 0.24626036f, 
    -0.06937039f, 0.16610403f, -0.22000809f, -0.01566273f, 0.25235203f, 0.09160393f, 0.11930888f, 0.17746252f, 
    -0.19440639f, -0.13581359f, 0.29740107f, 0.30848023f, -0.02155056f, -0.39524087f, 0.17872813f, -0.07624886f, 
    0.17577174f, -0.35895646f, 0.11437078f, -0.40981928f, -0.25091428f, -0.03919078f, 0.05384593f, -0.09797768f, 
    -0.36685485f, -0.01901875f, -0.01146070f, 0.03139994f, -0.03677783f, 0.16456653f, 0.36741009f, 0.03075927f, 
    -0.16237184f, 0.31668213f, -0.44143260f, -0.11102515f, 0.03751647f, 0.14748141f, -0.37403071f, 0.41748631f, 
    -0.33846051f, 0.24904156f, -0.53761572f, 0.27964872f, 0.19545043f, 0.06443547f, -0.11107109f, -0.07952303f, 
    0.14099935f, 0.06878179f, 0.11204156f, -0.02118632f, -0.01305868f, 0.09169971f, -0.17966907f, 0.04732298f, 
    0.14077739f, 0.21493462f, -0.01758185f, 0.13406724f, 0.22757381f, 0.01642633f, -0.99162042f, 0.06756614f, 
    0.25600505f, -0.28724319f, 0.22403955f, -0.10894864f, -0.13707769f, -0.01963815f, 0.11365310f, 0.03305948f, 
    0.14836621f, -0.20428027f, 0.04280206f, 0.00689417f, 0.22883776f, -0.40484723f, 0.23844744f, 0.28086495f, 
    0.20138469f, -0.05920182f, 0.26157394f, -0.09383309f, 0.04737372f, -0.05886380f, 0.02672152f, -0.12795328f, 
    0.03233413f, -0.01309248f, 0.04104765f, 0.00800943f, 0.00559014f, -0.49212787f, 0.17953305f, -0.21048015f, 
    -0.04385224f, 0.01310856f, -0.02932205f, 0.04512025f, -0.09098069f, -0.00760604f, 0.06407582f, 0.04553005f, 
    -0.03921672f, -0.04987347f, -0.03647089f, 0.04759753f, -0.02160533f, -0.07909918f, -0.06348627f, -0.02155950f, 
    0.04801512f, 0.08544222f, -0.05041090f, 0.01093801f, -0.01728310f, -0.07054129f, -0.08499715f, -0.04204991f, 
    0.00743558f, -0.03524331f, 0.01506464f, -0.02793943f, 0.06686365f, -0.05866104f, -0.00948123f, -0.03754714f, 
    -0.01664359f, -0.07470093f, 0.02214272f, 0.03342187f, 0.04130736f, -0.08129515f, -0.04000586f, -0.00357601f, 
    -0.07989801f, 0.07628442f, 0.02469341f, 0.05361379f, -0.07635448f, -0.05246136f, 0.07451335f, -0.02196813f, 
    -0.03081761f, 0.08734161f, 0.04807322f, -0.00644846f, -0.05813206f, -0.01435542f, 0.02087906f, 0.02513024f, 
    -0.05903159f, -0.02776936f, -0.07534951f, -0.09743885f, -0.07929286f, -0.03375225f, -0.00874030f, 0.05032139f, 
    -0.00418403f, -0.09761930f, 0.01851597f, -0.01958812f, 0.05098343f, 0.01660903f, -0.06402582f, 0.00729776f, 
    -0.08065961f, -0.05442049f, -0.04661022f, 0.04862692f, 0.00587166f, -0.06940824f, 0.00584345f, 0.00543623f, 
    0.05853099f, -0.06992832f, -0.06166613f, -0.06144625f, 0.00473441f, -0.09250214f, 0.08634365f, -0.01731091f, 
    -0.07772171f, -0.01251748f, 0.04602985f, 0.04556607f, -0.02576298f, 0.02070011f, 0.04579449f, 0.04480271f, 
    -0.02290185f, 0.07282674f, -0.04882782f, -0.06576426f, 0.05570548f, 0.01689510f, 0.06584112f, -0.02078672f, 
    -0.10393965f, -0.00768668f, 0.06699803f, -0.05519005f, 0.01123881f, -0.09089833f, 0.01903510f, -0.04854462f, 
    -0.00446592f, 0.04614215f, 0.02348232f, -0.03495703f, 0.04549788f, 0.07151105f, -0.07413253f, -0.00479740f, 
    -0.07443475f, 0.04735231f, -0.02666810f, -0.08013587f, -0.09415681f, 0.03031794f, -0.10321417f, 0.00977265f, 
    -0.07386470f, 0.31706506f, -0.49661037f, 0.09723394f, -0.14910726f, 0.35622588f, -0.11779771f, 0.11653278f, 
    -0.09866553f, 0.08756943f, 0.08142699f, -0.12996638f, -0.00172645f, 0.06494511f, -0.14761309f, 0.14339513f, 
    0.05610006f, 0.06658679f, -0.18436629f, 0.04892533f, 0.18891580f, -0.02463027f, 0.14519784f, 0.17651986f, 
    0.06990144f, 0.00043813f, 0.01526609f, 0.08705126f, -0.10968446f, -0.11374491f, -0.08587994f, 0.05138382f, 
    -0.35703036f, 0.15398026f, -0.34628209f, 0.28642243f, -0.33427539f, 0.11656383f, -0.17025211f, 0.12759109f, 
    -0.21131374f, -0.22831418f, -0.04458061f, 0.05008885f, 0.04048919f, 0.14875640f, -0.06874399f, 0.03951527f, 
    0.22727455f, -0.19132537f, 0.10551164f, -0.12882054f, -0.08639102f, -0.06651404f, 0.15250629f, 0.25171441f, 
    -0.30298123f, 0.12651114f, 0.05081587f, 0.13628374f, -0.09942710f, 0.07476944f, 0.09656881f, 0.23772705f, 
    -0.03417015f, -0.05648275f, -0.51831281f, 0.05686281f, 0.25190803f, 0.25608906f, -0.33398205f, -0.22488785f, 
    -0.08703098f, 0.15758897f, -0.36505395f, 0.12960692f, 0.12914971f, 0.01223138f, 0.10363725f, 0.01610092f, 
    -0.15830462f, -0.03438082f, 0.03472150f, 0.07845874f, 0.23816618f, 0.02678241f, -0.20043223f, -0.02348554f, 
    0.13789350f, 0.24593386f, 0.02946676f, 0.21855804f, 0.18258260f, -0.15943868f, 0.41785210f, -0.11716681f, 
    -0.03527470f, -0.05679290f, -0.05357112f, 0.20432357f, 0.09230966f, 0.06616313f, -0.24305680f, 0.25787127f, 
    0.24164924f, -0.19228186f, 0.11698829f, -0.13122684f, -0.28677866f, -0.39244974f, -0.25548017f, -0.04347974f, 
    -0.00354055f, 0.14185381f, 0.27227762f, 0.17015657f, -0.13735090f, 0.03611962f, -0.01504018f, -0.16513620f, 
    -0.02821210f, -0.02935089f, 0.07429696f, 0.07464775f, -0.06542242f, -0.27319983f, -0.13277972f, -0.08070821f, 
    -0.02088187f, 0.01591117f, 0.15915640f, 0.16703312f, -0.12805726f, -0.09330749f, 0.13215719f, 0.15234007f, 
    0.09086990f, 0.23755595f, 0.06264284f, 0.19810212f, -0.07780978f, 0.02497784f, -0.31550920f, 0.10273760f, 
    -0.05246675f, -0.08188540f, 0.06196832f, 0.20867135f, 0.32872078f, 0.10412091f, 0.02359646f, 0.14039458f, 
    0.16882724f, 0.10184575f, -0.09822126f, 0.10869056f, -0.01087180f, 0.07262956f, 0.11589907f, -0.15224141f, 
    -0.22009140f, 0.27424923f, -0.14148232f, -0.06338975f, -0.03415553f, 0.29384169f, -0.06764540f, 0.01235511f, 
    0.02507437f, -0.15110880f, 0.19046031f, 0.05274660f, -0.04520131f, 0.29678044f, 0.10512243f, -0.14639926f, 
    0.17092609f, -0.26790276f, 0.03366577f, -0.07812849f, 0.17711887f, -0.06197514f, -0.17546746f, -0.20926718f, 
    0.04641498f, -0.00006847f, 0.34781051f, -0.05529706f, -0.21836147f, -0.04441524f, 0.19277759f, 0.03323977f, 
    -0.17456564f, 0.06439508f, -0.38175064f, 0.09184986f, 0.21127295f, 0.29229489f, -0.16909972f, 0.18977198f, 
    -0.21513721f, 0.08809318f, -0.35290048f, 0.09477948f, 0.32289451f, 0.09790335f, 0.09172240f, 0.00637426f, 
    0.07144532f, 0.22607888f, 0.14741498f, 0.10064150f, 0.12071227f, 0.03448369f, -0.56856763f, 0.07575440f, 
    -0.04048969f, 0.19207254f, -0.00866657f, -0.00036140f, 0.11664514f, 0.05677854f, -0.03098115f, 0.06832596f, 
    0.09753122f, -0.29881486f, 0.23170683f, 0.06506531f, 0.04209636f, 0.04380072f, 0.04139590f, 0.01300917f, 
    0.23239461f, -0.03327554f, 0.06661782f, -0.02199262f, 0.08549754f, -0.63453412f, 0.04493298f, 0.10872748f, 
    -0.15644272f, 0.17499582f, 0.34206372f, -0.02799452f, -0.18647380f, -0.26681781f, 0.05514279f, -0.16140251f, 
    -0.03542208f, -0.00899743f, -0.08221282f, 0.10042781f, 0.15497345f, -0.28987232f, -0.11572064f, -0.18927044f, 
    0.05495356f, 0.23828638f, 0.03802247f, -0.06083515f, -0.06550421f, 0.09387131f, 0.03653353f, 0.07983495f, 
    -0.01098736f, -0.15746203f, -0.00099373f, -0.13706632f, -0.15647621f, -0.20705411f, 0.17080323f, 0.12432070f, 
    0.01344308f, 0.07287588f, -0.39751416f, -0.07401848f, -0.21848771f, -0.04527731f, 0.03703981f, -0.33071768f, 
    0.07449430f, 0.03474645f, 0.23611905f, 0.04789997f, -0.15203227f, -0.12003857f, -0.20657307f, -0.19027635f, 
    0.09842973f, -0.50553566f, 0.03743731f, 0.15861329f, 0.04557298f, -0.22269446f, -0.07049592f, 0.29667264f, 
    0.09773205f, -0.11295992f, 0.14147656f, 0.26702404f, -0.24966055f, -0.33633518f, 0.12875336f, 0.14982189f, 
    -0.23473138f, -0.12369028f, 0.18870351f, -0.18581031f, -0.08799158f, 0.22528265f, -0.02032099f, -0.05443828f, 
    -0.07217038f, 0.08678409f, 0.03474700f, 0.19452266f, -0.03194201f, 0.28450128f, 0.18045329f, -0.16160017f, 
    0.19000979f, -0.10824445f, -0.19219889f, 0.06626455f, -0.30691233f, -0.58841819f, -0.25170067f, -0.07922599f, 
    0.23874246f, -0.00101428f, 0.11802023f, -0.06088555f, -0.23380558f, -0.08355603f, 0.39273447f, -0.01968215f, 
    -0.03626104f, 0.55929565f, 0.01956959f, -0.13000792f, -0.01195306f, 0.08259080f, -0.08420451f, 0.00321243f, 
    -0.08550435f, -0.00652243f, 0.08911706f, -0.17906424f, -0.02200948f, 0.14904569f, 0.33928084f, -0.09865527f, 
    0.11654857f, -0.13949646f, -0.28888920f, -0.14967883f, -0.15460800f, -0.07958753f, 0.12468161f, 0.11341625f, 
    -0.12596361f, -0.01153937f, 0.04342169f, 0.08935295f, -0.25702581f, 0.01734116f, 0.22084844f, -0.00181185f, 
    0.13649572f, -0.19189529f, -0.04653518f, -0.11494716f, -0.05137402f, 0.14025030f, 0.06034916f, 0.19753970f, 
    -0.00385542f, 0.22444271f, 0.08624075f, -0.12359886f, 0.02463640f, -0.12672065f, 0.11342325f, -0.02753374f, 
    -0.05161623f, -0.20795636f, 0.56084621f, 0.09739055f, -0.14060144f, -0.14603084f, 0.01678557f, 0.17047331f, 
    0.10631797f, 0.13742609f, -0.04275697f, 0.16672094f, 0.09498518f, 0.00021950f, -0.37224427f, 0.28964886f, 
    0.04007160f, 0.05215978f, 0.19051667f, 0.01481303f, 0.37121919f, -0.05899020f, 0.00110378f, 0.04917001f, 
    0.14136307f, 0.03268571f, -0.15549421f, 0.10043278f, 0.09384743f, 0.07285067f, 0.22282676f, 0.04342110f, 
    -0.14613667f, 0.44584394f, -0.11036485f, -0.04809724f, 0.16067809f, 0.28727463f, 0.15374558f, -0.01838084f, 
    -0.11423596f, -0.02405381f, 0.09194457f, -0.04721528f, -0.06228356f, 0.16089475f, -0.19839193f, -0.00834740f, 
    0.07921522f, -0.29716530f, -0.10295147f, 0.29569033f, 0.13953744f, -0.08935755f, -0.14026190f, -0.11606611f, 
    -0.08476037f, -0.11180682f, 0.37506145f, -0.10886953f, -0.07862204f, -0.13171832f, 0.06030767f, 0.27089161f, 
    -0.15554760f, 0.11813310f, -0.16528119f, -0.09162935f, 0.25344577f, 0.38056171f, -0.12284427f, 0.11964365f, 
    -0.13232927f, 0.11159550f, -0.43355200f, 0.09391264f, 0.37357146f, 0.09407067f, -0.04636856f, 0.00092740f, 
    0.12525539f, 0.00873025f, 0.10609040f, 0.09182549f, 0.06091890f, 0.06324251f, -0.43201992f, 0.08619162f, 
    -0.05876278f, 0.23919073f, -0.07200438f, 0.01158174f, 0.05533342f, -0.01169335f, -0.03459052f, 0.22848982f, 
    0.08319476f, -0.12937035f, 0.45813686f, 0.07662834f, 0.14180659f, 0.07113917f, -0.17278913f, 0.00741880f, 
    0.06164559f, -0.13446535f, 0.10218836f, -0.02472185f, 0.21978286f, -0.55772054f, -0.24875635f, 0.22831686f, 
    0.00332340f, 0.04341977f, 0.36827627f, -0.07846803f, -0.06768727f, 0.08268369f, 0.24002382f, -0.25313291f, 
    -0.08188779f, -0.06505855f, 0.09922922f, 0.15648320f, -0.00445866f, -0.04684287f, 0.01926466f, -0.13306250f, 
    0.19322863f, 0.10213093f, -0.12205247f, 0.02471733f, 0.22260174f, 0.12942240f, -0.02840776f, -0.02312652f, 
    -0.30445197f, -0.13097173f, -0.02388330f, 0.05393158f, -0.10480075f, 0.08760355f, 0.32351208f, -0.13058551f, 
    0.05445186f, 0.08741810f, -0.16138320f, 0.06418227f, -0.05667895f, 0.41506445f, 0.25174978f, -0.06163678f, 
    -0.06590818f, -0.05360021f, 0.19776049f, 0.03021210f, -0.03372162f, 0.00096051f, -0.17976531f, -0.07323947f, 
    0.05242606f, -0.57064754f, 0.10829295f, -0.05057143f, 0.14237389f, -0.57242060f, -0.22034384f, 0.04716830f, 
    -0.23021129f, 0.06395695f, 0.22059748f, 0.35444981f, 0.10347034f, -0.13090168f, 0.01130369f, 0.02947408f, 
    -0.08616886f, 0.13285311f, 0.00985564f, -0.16875789f, -0.09466709f, 0.16690642f, 0.05051607f, -0.09393905f, 
    -0.03368150f, 0.12318785f, -0.25594267f, -0.10363927f, 0.03900528f, 0.04004629f, -0.02892287f, -0.22512424f, 
    0.22130685f, -0.15637445f, 0.03731695f, 0.07165639f, -0.35405314f, -0.60655409f, 0.02923259f, 0.19671272f, 
    0.17191295f, 0.10143534f, 0.06851173f, 0.06017109f, -0.18591093f, -0.04512880f, 0.13278057f, -0.01356643f, 
    0.05227307f, 0.00332213f, 0.26697612f, -0.04514907f, -0.06386448f, -0.10849629f, 0.06571193f, -0.01897529f, 
    -0.02566973f, -0.05403505f, 0.09680499f, -0.02549340f, 0.06294706f, 0.06720335f, -0.12990516f, -0.20240273f, 
    -0.01175970f, 0.12236509f, 0.05588020f, -0.05640372f, -0.21095459f, -0.02924882f, 0.14620024f, 0.06322969f, 
    0.08115187f, 0.10054508f, 0.16616920f, 0.04559589f, 0.07574680f, -0.07456834f, 0.18775035f, -0.04642842f, 
    0.10210253f, -0.11349087f, -0.27250925f, -0.24564113f, -0.03326402f, -0.26836407f, 0.03649334f, 0.03580792f, 
    -0.07630136f, 0.05439062f, -0.03785469f, -0.05341066f, 0.32694727f, -0.10314902f, -0.00269119f, 0.08513317f, 
    0.08415611f, -0.09836170f, 0.01392768f, 0.06832617f, -0.01405327f, -0.00686714f, 0.02621867f, 0.01542874f, 
    -0.20655432f, -0.10599160f, 0.06671055f, -0.00563602f, 0.01333031f, -0.05568997f, -0.04464162f, -0.04953545f, 
    0.00843460f, -0.03216768f, -0.09655695f, -0.02685956f, 0.05979958f, -0.07988132f, -0.07865886f, -0.06076306f, 
    0.06837477f, -0.02382618f, 0.00008886f, -0.03959322f, -0.05442545f, -0.15546760f, -0.05779064f, 0.00733445f, 
    -0.04018017f, 0.07572615f, -0.02746227f, -0.05155785f, -0.02260115f, -0.02074774f, -0.02997641f, 0.01389495f, 
    -0.04064517f, -0.05389456f, -0.04191216f, 0.02639561f, -0.02625810f, 0.02703531f, -0.05276927f, -0.06063834f, 
    0.00287708f, 0.07705313f, -0.02407797f, 0.07310449f, -0.01536983f, 0.01192217f, -0.14210308f, 0.05965981f, 
    -0.01749783f, 0.12289809f, -0.06342851f, 0.02830092f, -0.05355410f, -0.10080657f, 0.06821531f, -0.02026288f, 
    -0.01679455f, -0.02724379f, -0.14743114f, 0.02531263f, 0.03909182f, 0.06436475f, -0.05334896f, -0.02845383f, 
    -0.00484519f, -0.02688913f, -0.05211068f, -0.08042883f, -0.06411262f, -0.04452024f, -0.07328242f, -0.08419351f, 
    -0.01182099f, 0.06837787f, 0.00671951f, -0.15275168f, 0.00531829f, 0.01051635f, -0.02475366f, 0.03840927f, 
    -0.00688751f, -0.05148240f, -0.02728744f, 0.05062592f, 0.02474084f, -0.11631213f, -0.00523366f, -0.16430530f, 
    0.02067664f, 0.00815269f, 0.03690941f, -0.00642211f, 0.06035068f, -0.06410147f, -0.11860441f, -0.04235013f, 
    -0.00048570f, -0.05417494f, -0.09996216f, 0.00428703f, 0.04240237f, -0.09170127f, -0.00577278f, -0.03521188f, 
    -0.09799030f, -0.03624269f, -0.08895095f, -0.14041054f, -0.11373049f, 0.04639264f, -0.10339926f, -0.11530863f, 
    0.05034360f, -0.04107990f, -0.05682686f, -0.10116488f, 0.00340211f, 0.04661210f, -0.11161121f, -0.01538621f, 
    -0.06749954f, 0.30499655f, -0.19744535f, -0.02520154f, -0.15067258f, 0.06434236f, 0.09069873f, 0.01314234f, 
    0.04721814f, -0.09903269f, 0.04136603f, 0.04291175f, 0.04997563f, 0.11841091f, -0.20940037f, 0.19206674f, 
    -0.08782911f, 0.04369485f, -0.25447738f, 0.08879631f, -0.11931116f, 0.16339836f, 0.08420148f, 0.04425619f, 
    -0.03407937f, -0.11199188f, 0.19691406f, -0.00273432f, -0.48215839f, -0.03035400f, 0.09259187f, -0.03788649f, 
    -0.25894663f, 0.04970537f, -0.18108329f, 0.50453967f, -0.21100952f, -0.08594303f, -0.22489996f, 0.04168094f, 
    -0.26462790f, -0.23742267f, 0.02944582f, 0.05549370f, -0.02249658f, -0.01434194f, -0.13890089f, 0.08665220f, 
    0.03652275f, -0.11553098f, -0.04466590f, -0.16095580f, 0.15152740f, 0.00520533f, 0.14840151f, 0.23088703f, 
    -0.06889628f, -0.01839576f, 0.09611869f, 0.30305931f, 0.02391731f, -0.14726064f, -0.01311827f, 0.04297559f, 
    -0.06802810f, -0.00340569f, -0.28985327f, 0.13944721f, 0.13729608f, 0.08587911f, -0.17866404f, -0.11215290f, 
    -0.00188386f, 0.16838612f, -0.20459412f, -0.03032965f, 0.04452994f, 0.07625624f, 0.10793982f, -0.02904133f, 
    -0.08146059f, 0.15886202f, 0.02811300f, -0.02666618f, 0.29946235f, 0.13625596f, -0.23115955f, 0.00068077f, 
    -0.04358244f, 0.14848259f, 0.10015500f, 0.09178858f, -0.00213416f, 0.01128349f, 0.46516818f, 0.01088619f, 
    0.16825856f, -0.08825936f, -0.06789001f, 0.15300877f, 0.24597694f, -0.05753556f, -0.11677190f, 0.23612173f, 
    0.03730093f, -0.22006850f, 0.25313684f, 0.12351858f, -0.41001487f, -0.06476032f, -0.09114735f, -0.17161374f, 
    0.09288488f, 0.13363110f, 0.18540545f, 0.07650053f, -0.16670595f, 0.15233251f, 0.17970075f, -0.16441436f, 
    -0.01875480f, 0.04870873f, -0.05890568f, 0.12344594f, 0.17128335f, 0.01715490f, -0.07542749f, -0.03266333f, 
    0.05681479f, -0.08786870f, -0.02008394f, -0.01589352f, -0.04216266f, 0.01240432f, -0.08650923f, 0.00648758f, 
    0.08820034f, 0.06540126f, 0.00983718f, -0.05973806f, 0.03239963f, 0.03837043f, 0.08690606f, 0.03769572f, 
    0.07305609f, -0.01978292f, -0.05083149f, -0.00123473f, -0.01309726f, -0.06161833f, 0.06860762f, 0.02462790f, 
    -0.06644160f, -0.05873428f, -0.03660328f, -0.02861432f, -0.02742922f, -0.07755079f, 0.02967876f, -0.08786806f, 
    0.01806029f, -0.05184920f, 0.04865999f, 0.01290336f, 0.04147310f, -0.03134931f, -0.08033820f, -0.03170269f, 
    -0.08787102f, 0.02954126f, -0.07848263f, -0.07166847f, -0.03789585f, -0.06337529f, -0.05955474f, -0.01272580f, 
    0.03922157f, 0.03378259f, 0.06582652f, -0.02166861f, -0.00736629f, 0.03820232f, -0.08613040f, -0.07505020f, 
    0.04911551f, -0.05593324f, -0.01923375f, -0.01632452f, -0.07676085f, 0.01405025f, 0.07476158f, -0.07034533f, 
    -0.08793072f, -0.04953988f, 0.08541659f, -0.01720618f, 0.02200763f, -0.06031834f, 0.05164085f, -0.04306514f, 
    -0.06601238f, -0.05193377f, 0.06582328f, -0.02695370f, -0.04088623f, 0.07465161f, -0.05567117f, 0.00072778f, 
    0.00610771f, 0.03033406f, -0.01512385f, -0.03881308f, 0.04920156f, -0.01002118f, 0.05593793f, 0.04199716f, 
    0.07070697f, -0.04519309f, -0.04761767f, 0.05561101f, 0.00111172f, -0.03882170f, 0.00053374f, 0.02314567f, 
    -0.06194066f, 0.04174460f, -0.04221052f, -0.08518378f, -0.04171989f, 0.02201422f, -0.03197246f, 0.00074088f, 
    -0.00039240f, -0.03078431f, -0.08599156f, 0.03103971f, -0.00227113f, -0.08368976f, -0.07351538f, -0.04840726f, 
    0.02664767f, -0.07281946f, 0.00990808f, -0.00235252f, -0.01622516f, -0.01236487f, 0.08249745f, -0.00851951f, 
    -0.06943522f, -0.02925828f, 0.04074977f, 0.08148942f, -0.06361437f, 0.03708688f, -0.08177397f, -0.00760819f, 
    -0.21243206f, 0.08705234f, 0.12831390f, -0.27488610f, 0.05184820f, -0.34205803f, 0.06039494f, -0.20259264f, 
    0.26738924f, 0.03290097f, -0.03413959f, 0.08673870f, 0.07152081f, 0.07691758f, -0.13907920f, -0.26333043f, 
    -0.00860963f, 0.01908639f, 0.09400094f, 0.28076237f, -0.14008725f, 0.07956129f, -0.09841492f, -0.08809205f, 
    -0.16639347f, 0.02985899f, 0.02592772f, 0.01186573f, 0.49692732f, 0.23544540f, 0.19145092f, 0.05463663f, 
    -0.03214643f, -0.14178461f, 0.14833717f, 0.04693775f, 0.18345883f, -0.11267574f, 0.24703541f, -0.14132997f, 
    -0.19614062f, -0.05176594f, 0.08258272f, -0.18058169f, 0.02567218f, -0.16581695f, 0.32420784f, 0.01018857f, 
    -0.21916163f, -0.04916000f, 0.08600608f, -0.17656232f, 0.19335145f, -0.31714702f, 0.35948950f, -0.18571545f, 
    -0.05866918f, -0.03037117f, -0.25953123f, -0.07739795f, 0.00871965f, -0.16228218f, -0.21078552f, -0.24533632f, 
    -0.14038485f, 0.03867837f, 0.16472249f, 0.08827717f, 0.24291328f, 0.03767756f, 0.04669679f, 0.23473780f, 
    -0.01937038f, -0.03022205f, -0.01267701f, -0.07941294f, 0.34065086f, 0.24507041f, 0.12546656f, -0.10242496f, 
    -0.03335488f, 0.08593450f, 0.01859849f, 0.17214186f, 0.20538107f, 0.20319265f, -0.04788285f, -0.04761692f, 
    0.16142613f, -0.08572336f, -0.06522858f, -0.06801034f, 0.15340148f, -0.07655861f, -0.00874059f, 0.20348343f, 
    0.10282314f, -0.16624123f, -0.14773816f, 0.12877159f, 0.12845643f, 0.03046262f, -0.15401493f, -0.06610296f, 
    0.14310977f, 0.07477184f, 0.27614558f, 0.14757404f, 0.19017260f, 0.08524577f, 0.12867160f, 0.00832357f, 
    -0.07253489f, 0.01684593f, 0.23287271f, 0.16427062f, -0.06450652f, 0.25769508f, -0.07754163f, 0.20512860f, 
    0.06878439f, -0.03038626f, -0.07091565f, 0.12155534f, 0.31613776f, 0.05193612f, -0.03352559f, -0.00756963f, 
    0.00098454f, -0.10600573f, -0.55736995f, -0.12101278f, 0.00276223f, 0.09978210f, -0.07328193f, 0.15755212f, 
    0.10676199f, 0.13273975f, 0.03439159f, 0.18265699f, -0.16767761f, -0.14070646f, -0.10542739f, 0.35750481f, 
    -0.00606613f, -0.02167936f, 0.18948969f, -0.03850106f, -0.43822125f, -0.08560549f, -0.11294737f, 0.12040139f, 
    0.16176227f, -0.06071904f, 0.09402834f, 0.06794500f, 0.43643248f, 0.16328692f, 0.17620204f, 0.06396832f, 
    -0.03078179f, 0.22215365f, 0.16792475f, -0.04641780f, 0.22227527f, 0.18516888f, 0.08386084f, 0.03267205f, 
    -0.18346493f, 0.07842252f, 0.24919949f, 0.06631397f, -0.04148149f, 0.03802046f, 0.05921270f, 0.02389307f, 
    0.26096058f, -0.40735728f, -0.01937678f, -0.45141992f, -0.02157984f, -0.20531020f, 0.27988878f, -0.21168217f, 
    0.08163364f, -0.02994748f, -0.15662220f, -0.27330613f, 0.06462292f, -0.02677279f, 0.22888911f, 0.06963590f, 
    -0.29212099f, 0.39089897f, 0.03214923f, 0.03441076f, 0.20832381f, 0.43634632f, -0.01073142f, 0.53723770f, 
    -0.14978833f, 0.12874246f, -0.21747985f, 0.08700909f, -0.01593416f, 0.09544453f, -0.26184383f, 0.03164808f, 
    -0.02465176f, -0.21088655f, -0.06226505f, 0.08651578f, 0.00315054f, 0.17747851f, -0.06837805f, -0.04928348f, 
    0.11813914f, -0.04335692f, -0.02524719f, 0.01684662f, 0.10307394f, 0.03964493f, -0.68833071f, 0.17948356f, 
    0.18181331f, -0.14181861f, 0.27327707f, 0.13551205f, 0.04084916f, 0.06142688f, -0.02422927f, -0.16345759f, 
    -0.03432843f, 0.02821973f, -0.04888000f, -0.02602640f, 0.33172414f, -0.12412579f, 0.18510015f, 0.29462069f, 
    0.16739677f, -0.11750154f, 0.10456321f, -0.02863550f, 0.04992430f, 0.08696801f, -0.03213524f, -0.14805003f, 
    0.04409892f, 0.01012458f, 0.04750585f, 0.04398770f, 0.10947389f, -0.14302525f, 0.04601029f, -0.12401053f, 
    -0.00834511f, -0.02743600f, -0.03810313f, 0.04888575f, 0.03827878f, -0.03610671f, -0.08385187f, 0.06715529f, 
    0.00650519f, 0.02029598f, 0.07493915f, 0.02330513f, 0.03146157f, 0.02854183f, -0.00075815f, -0.09717470f, 
    -0.06170950f, 0.04593758f, 0.00747869f, 0.07502814f, 0.06110050f, 0.08004878f, -0.07041377f, -0.03894304f, 
    0.03805866f, -0.02026896f, 0.00379723f, 0.02107862f, -0.07151924f, -0.05513655f, -0.08377814f, -0.07826381f, 
    -0.08492082f, 0.03467228f, -0.06163709f, -0.08082032f, 0.00313556f, -0.01796381f, -0.01325412f, 0.03101942f, 
    0.05098988f, -0.00285615f, 0.00611460f, -0.01194437f, -0.08956919f, 0.07444994f, 0.04467490f, 0.01749674f, 
    0.01716916f, 0.05486631f, -0.08828066f, -0.03549535f, 0.08130950f, 0.00623586f, -0.07672465f, 0.02860160f, 
    0.01273091f, -0.09082176f, 0.02270287f, -0.06700308f, 0.05566450f, -0.04984477f, -0.05128524f, 0.02359039f, 
    -0.06779731f, 0.02180669f, 0.02359704f, 0.00102369f, -0.02998482f, -0.05764872f, -0.05762629f, 0.03837398f, 
    -0.05595767f, -0.00943867f, -0.07041667f, -0.09138868f, -0.03059165f, 0.01709575f, -0.04362370f, -0.07123438f, 
    -0.07252054f, 0.07284421f, 0.03108225f, -0.03344557f, 0.03076264f, -0.07516634f, -0.03905297f, 0.00178186f, 
    -0.01526324f, 0.03790287f, -0.07736634f, -0.05193332f, -0.05914251f, 0.02774789f, -0.03810056f, -0.07490863f, 
    -0.02792207f, -0.01043143f, -0.00586556f, -0.08310239f, -0.04534728f, -0.02063784f, 0.05761341f, 0.05133621f, 
    -0.06956418f, -0.09261897f, -0.01582773f, 0.07143728f, 0.05217234f, -0.08512866f, -0.01656130f, -0.09123591f, 
    -0.03223879f, -0.08363456f, -0.03664541f, -0.03665791f, -0.02367577f, -0.05913854f, -0.07071272f, -0.06648448f, 
    0.06849603f, -0.01792567f, 0.03050362f, -0.06614923f, 0.05916041f, -0.05204589f, 0.03101279f, -0.07202255f, 
    0.08838990f, -0.20585914f, -0.14461945f, -0.00690862f, 0.03511604f, -0.03117521f, 0.09952861f, 0.06513344f, 
    0.01673976f, -0.09558174f, 0.00256248f, 0.02539789f, 0.02123233f, 0.04816997f, 0.06067649f, 0.06876338f, 
    0.05106166f, -0.06847458f, 0.24656233f, 0.14648281f, -0.19412825f, 0.41622463f, 0.11633886f, -0.08871274f, 
    0.02072955f, 0.01954002f, 0.05190274f, 0.12482187f, -0.12997694f, 0.03978999f, -0.15873083f, 0.07347766f, 
    0.06246096f, 0.32953107f, -0.11470520f, 0.19664964f, 0.16375145f, -0.24948181f, -0.02583969f, 0.14741868f, 
    0.14326811f, -0.13422552f, -0.09375261f, -0.07597888f, 0.03907502f, 0.10275038f, -0.58434868f, 0.14382175f, 
    -0.42873493f, -0.11937370f, -0.17795588f, 0.27955115f, 0.01436226f, 0.19527367f, 0.10531691f, -0.24767250f, 
    -0.01494151f, 0.11410289f, 0.05402825f, -0.05954546f, -0.02139957f, -0.24723384f, -0.39502800f, -0.11957493f, 
    -0.02486134f, -0.20276563f, 0.03474227f, 0.02933558f, 0.17840049f, 0.05526472f, -0.05689798f, -0.45537308f, 
    0.19431493f, -0.04440483f, -0.03515147f, 0.05934046f, 0.34710467f, 0.17554934f, -0.35934144f, -0.04461092f, 
    0.30616254f, -0.69732744f, 0.00396185f, 0.03634293f, 0.14832547f, -0.15285803f, -0.02988459f, -0.07933483f, 
    -0.07717617f, -0.09740519f, 0.26002291f, 0.24365251f, -0.05480725f, 0.28950340f, -0.14248902f, 0.09361659f, 
    -0.07593258f, 0.02205717f, 0.19911873f, 0.01396881f, 0.21753691f, -0.03666009f, -0.24019165f, 0.30113450f, 
    0.06107967f, 0.01826539f, 0.17018196f, 0.33581576f, -0.08049498f, 0.09032860f, -0.11731559f, -0.21527156f, 
    0.16909911f, -0.04552667f, -0.16938956f, -0.06419618f, -0.07335070f, 0.14790989f, 0.03476046f, 0.17792699f, 
    0.04484688f, 0.14375171f, 0.15063533f, -0.02109580f, -0.00228925f, 0.30035886f, 0.13987067f, -0.05574416f, 
    -0.06742631f, -0.05811835f, 0.01598994f, -0.20260340f, 0.05208950f, -0.22605506f, 0.19565378f, -0.09577014f, 
    0.12091973f, -0.09338655f, 0.08250687f, 0.05742546f, -0.03013544f, -0.42479450f, -0.13807589f, 0.10863595f, 
    -0.06699204f, 0.08409355f, -0.00456147f, -0.08592066f, 0.06119390f, -0.01149967f, -0.30997416f, -0.77105194f, 
    0.24128060f, -0.19900130f, -0.15924084f, -0.13682456f, 0.00420669f, 0.18381146f, 0.12121441f, 0.21695438f, 
    0.05813048f, -0.71045226f, -0.13870844f, -0.24119708f, 0.23746787f, -0.01830142f, 0.12133386f, 0.25170663f, 
    0.27064520f, 0.06016264f, 0.03901945f, 0.04261445f, -0.10008305f, -0.69862211f, 0.39640361f, 0.18059346f, 
    -0.24487551f, -0.43808663f, 0.12676795f, 0.11178753f, -0.47723341f, 0.15436487f, 0.15934905f, 0.02595701f, 
    0.46511891f, 0.06431240f, 0.07002646f, 0.18281673f, 0.21693134f, 0.31810021f, -0.03206870f, -0.15038618f, 
    -0.10804373f, -0.04920141f, -0.07533886f, -0.16948761f, -0.51875639f, -0.74145085f, -0.02645022f, 0.13222642f, 
    0.06806624f, 0.16323332f, 0.17416283f, 0.18499692f, -0.68256032f, -0.12977637f, 0.12627546f, -0.01458552f, 
    0.07648927f, 0.39617506f, -0.29405633f, -0.18059848f, -0.03606519f, 0.17558299f, 0.00970557f, 0.05767071f, 
    0.10974421f, -0.02476338f, -0.24931081f, -0.47149149f, -0.16593936f, 0.09163941f, -0.06414594f, -0.01973870f, 
    0.08172142f, -0.41764504f, -0.56099391f, -0.18464953f, -0.81913233f, -0.07898597f, 0.15978645f, -0.29207742f, 
    -0.29379937f, 0.00468205f, -0.07365113f, 0.27162290f, 0.05055154f, 0.00679898f, 0.00801749f, 0.08752249f, 
    0.12630254f, -0.13337830f, -0.19471022f, -0.05717845f, 0.17694569f, 0.05551648f, -0.29006884f, -0.07551448f, 
    0.03775694f, -0.00312419f, 0.01358923f, -0.14798458f, -0.24920768f, 0.22051194f, 0.12676306f, 0.23500988f, 
    0.00487819f, -0.01796896f, -0.29717350f, -0.25104481f, -0.00647382f, 0.03392909f, 0.08991542f, -0.13995217f, 
    0.16570048f, -0.01580820f, 0.07588718f, -0.01749171f, -0.16298047f, -0.14617415f, -0.01203665f, 0.10628445f, 
    -0.08484840f, 0.00710750f, -0.22007671f, -0.02689127f, 0.10033802f, 0.17930174f, -0.00423974f, -0.14843215f, 
    -0.01850821f, 0.08878068f, 0.27129963f, -0.06614709f, 0.13968980f, 0.08706935f, -0.02651454f, -0.12071061f, 
    0.01260307f, 0.11335195f, 0.12756956f, 0.21445303f, -0.10030689f, 0.42673752f, -0.00159760f, -0.06721108f, 
    -0.13759337f, -0.11354759f, 0.20800470f, 0.03905084f, -0.21793148f, -0.50664926f, -0.13133569f, -0.04985404f, 
    -0.19368710f, -0.32103813f, -0.04749836f, 0.04961887f, 0.12867597f, -0.02971822f, 0.02207995f, -0.29165179f, 
    -0.17053451f, 0.03999516f, 0.03384338f, 0.06690067f, 0.14870985f, 0.00592146f, -0.21141760f, -0.23252606f, 
    -0.02559461f, 0.10037360f, 0.10989706f, 0.08863305f, 0.05278447f, 0.06276263f, -0.21479061f, 0.11316215f, 
    0.34190020f, 0.07057668f, 0.02279450f, -0.01177552f, -0.24319115f, 0.18547744f, -0.31577519f, -0.02035362f, 
    0.23552361f, 0.24554768f, 0.05715053f, 0.04508473f, 0.07374869f, 0.12516552f, -0.12492586f, -0.02701078f, 
    -0.17299065f, -0.08072104f, 0.10081732f, 0.07997982f, 0.02977050f, -0.01632273f, -0.27208003f, 0.22277187f, 
    0.03720871f, -0.17360544f, 0.30552390f, -0.01226269f, 0.29152775f, 0.07288994f, 0.04977230f, 0.23891956f, 
    -0.01289177f, 0.05073399f, 0.05363778f, 0.12616017f, 0.14438587f, 0.05089544f, 0.25826576f, 0.21472305f, 
    0.08446798f, -0.06912318f, -0.10196910f, -0.08526896f, 0.02585182f, 0.37187186f, 0.11771199f, 0.08587039f, 
    -0.04094260f, 0.16346273f, 0.09953652f, 0.07281500f, 0.18173777f, 0.06054295f, 0.16349253f, -0.21388651f, 
    0.03223522f, -0.01492557f, -0.10198998f, -0.03624445f, 0.03818622f, 0.08108900f, -0.01656343f, -0.01166086f, 
    -0.08391878f, -0.03999844f, 0.05914752f, -0.04888316f, 0.02811511f, -0.03321305f, 0.01590150f, 0.03527119f, 
    -0.00038804f, 0.05734206f, -0.08074827f, 0.06177475f, -0.00625117f, -0.02754013f, -0.05625241f, -0.00648522f, 
    0.02762331f, 0.07147837f, -0.07018344f, -0.07787464f, -0.06084391f, -0.04292655f, 0.06252063f, -0.07417438f, 
    -0.02856465f, 0.07829664f, -0.09691611f, -0.07600738f, 0.05119680f, -0.06097849f, 0.07189808f, -0.05917906f, 
    0.04075636f, -0.07649741f, 0.07377909f, 0.03899587f, -0.05122469f, 0.08424065f, -0.08506723f, -0.05878723f, 
    -0.08412386f, -0.06415865f, -0.07610972f, -0.01858660f, -0.03013353f, 0.03739912f, -0.00322840f, -0.00295921f, 
    0.08499883f, -0.06340642f, 0.01246994f, -0.08356526f, 0.06554415f, -0.08750805f, -0.00316657f, 0.01291043f, 
    -0.03174596f, -0.07711206f, -0.04386171f, -0.01758790f, -0.03334728f, 0.01211140f, -0.09283384f, -0.05999318f, 
    -0.04646032f, 0.07749673f, -0.01880991f, -0.01644378f, -0.08724084f, -0.05769949f, 0.07667699f, -0.06439775f, 
    0.08246389f, 0.03377844f, -0.04671659f, -0.01781643f, 0.03827148f, 0.05659990f, 0.00222733f, 0.01031549f, 
    0.06228862f, -0.03889736f, -0.09302051f, 0.08274347f, 0.00312102f, -0.02489207f, -0.08634803f, 0.02025145f, 
    -0.05459353f, 0.02279526f, -0.02442452f, -0.09353370f, -0.05228214f, -0.00115345f, 0.05958752f, -0.05209918f, 
    -0.04852453f, 0.03539941f, 0.02341588f, -0.09309306f, -0.07529785f, 0.00826406f, -0.05706645f, -0.01359134f, 
    0.06463746f, -0.06171717f, -0.02801105f, 0.02496967f, 0.01870863f, -0.01528226f, 0.06697305f, -0.01970459f, 
    -0.03133885f, -0.05681755f, -0.00073535f, -0.09023298f, -0.01895257f, -0.06393223f, 0.03345680f, -0.07031359f, 
    0.00630315f, 0.05076155f, -0.08964583f, 0.04241372f, -0.16844097f, 0.13088401f, -0.18058263f, 0.10854862f, 
    0.18624103f, -0.02561001f, -0.00436988f, -0.02251754f, 0.03834811f, 0.00578315f, -0.25037453f, 0.32957977f, 
    0.06193373f, -0.07936375f, -0.00287283f, -0.02000969f, 0.05518432f, -0.17138459f, 0.01578728f, 0.11339612f, 
    0.06429993f, -0.23142201f, 0.19421132f, -0.06759456f, 0.08685879f, 0.00528775f, 0.17940637f, 0.17897031f, 
    -0.08666161f, 0.07195252f, -0.33829138f, 0.45233619f, 0.05551543f, 0.15020877f, 0.03343536f, 0.18455394f, 
    -0.20729139f, -0.19957925f, 0.14319402f, 0.14148046f, 0.18731244f, 0.01166849f, -0.15377916f, 0.09150628f, 
    0.25612721f, -0.28430405f, 0.06619903f, -0.24138804f, -0.26319912f, -0.12813213f, 0.32951277f, 0.46313643f, 
    -0.13818021f, 0.06087738f, 0.05191002f, 0.02158673f, 0.18193987f, 0.09252300f, 0.23246872f, 0.18787901f, 
    0.06502717f, -0.14994793f, -0.38266322f, 0.04823261f, 0.27273849f, 0.11447290f, -0.16243042f, 0.06845481f, 
    -0.20996504f, 0.18928465f, -0.44031084f, 0.07093132f, 0.12575823f, -0.05345838f, -0.01113366f, 0.03749490f, 
    0.02974740f, 0.39723140f, 0.04000607f, 0.01701614f, 0.12586774f, -0.08646043f, -0.23148791f, -0.04311191f, 
    0.12644114f, 0.28249708f, 0.04876175f, 0.05131524f, 0.00491209f, -0.05895658f, 0.26529086f, 0.10086651f, 
    0.05419899f, -0.18277803f, 0.06938457f, 0.08177818f, 0.15938471f, 0.02020823f, -0.15009440f, 0.17513348f, 
    0.17167997f, -0.26029438f, 0.14787573f, 0.09369849f, -0.05063947f, -0.08861247f, -0.34477451f, -0.11852568f, 
    0.07477783f, 0.28534737f, 0.15334567f, 0.09860489f, 0.01273101f, 0.14008428f, -0.04480207f, -0.12130504f, 
    -0.02909379f, 0.00300603f, 0.01276179f, 0.00726429f, 0.06929711f, 0.01370790f, -0.05368698f, -0.07111920f, 
    0.21195856f, 0.01152886f, -0.38327914f, 0.28150067f, 0.10638313f, 0.17254299f, 0.15165721f, 0.19515795f, 
    -0.36743444f, 0.11598526f, -0.01171865f, 0.27285305f, 0.01710688f, 0.28934398f, 0.17861700f, -0.17361689f, 
    0.01872694f, 0.02596284f, 0.43307564f, 0.02234337f, -0.02912749f, 0.25925887f, 0.19193710f, -0.11145730f, 
    0.07828502f, -0.10295470f, -0.16050524f, 0.13906989f, -0.45395136f, -0.04342444f, 0.05267377f, 0.11597089f, 
    0.05667651f, 0.06046217f, -0.17214087f, 0.21034761f, -0.28046769f, -0.33361700f, -0.38565880f, 0.13665493f, 
    0.04354151f, 0.01195369f, -0.18025939f, 0.04380967f, 0.16004169f, 0.56830221f, -0.17766728f, 0.26943401f, 
    -0.04840438f, 0.37199512f, -0.32554904f, 0.35829106f, -0.22048414f, 0.31994119f, 0.23075937f, -0.23753014f, 
    0.33674365f, 0.29417500f, 0.10581381f, -0.15782388f, -0.35084051f, -0.00154743f, -0.09828527f, 0.11697058f, 
    0.14728770f, -0.31420225f, 0.05254354f, -0.01087252f, -0.08389746f, -0.35778072f, 0.00059022f, -0.21417215f, 
    0.14945164f, 0.19901404f, 0.10088752f, 0.11533789f, -0.11246436f, 0.02449175f, 0.02212521f, 0.05997736f, 
    0.15992904f, -0.06303163f, 0.00948639f, -0.14082675f, 0.01803621f, -0.06574357f, -0.00562625f, -0.03327539f, 
    0.16876313f, -0.08605725f, 0.20678614f, 0.20587717f, -0.05400559f, 0.18278697f, 0.12253903f, -0.40520728f, 
    0.01662739f, 0.25566328f, -0.06887964f, 0.18184948f, 0.04624082f, 0.02428687f, -0.03167490f, 0.16680202f, 
    -0.03298062f, -0.18748072f, 0.06411785f, 0.20122305f, 0.03597039f, -0.08416568f, 0.04609490f, -0.17021474f, 
    0.06745410f, -0.02299941f, -0.25448233f, -0.21418440f, -0.48085475f, -0.26656216f, -0.16475841f, 0.02887182f, 
    -0.01860912f, 0.15357430f, 0.07385896f, -0.18230076f, 0.05400347f, -0.02494660f, 0.14559655f, 0.17427745f, 
    -0.10827542f, 0.08963720f, -0.13326769f, -0.17634386f, 0.10740238f, -0.01739634f, 0.09976942f, -0.05244337f, 
    0.18890658f, -0.00547159f, 0.04328038f, 0.14057109f, -0.04758039f, -0.21979332f, -0.10470594f, 0.15498313f, 
    0.01959578f, -0.08355331f, 0.04780214f, -0.01640704f, 0.05375759f, -0.20015942f, -0.26503846f, 0.01550638f, 
    0.05406995f, -0.05249930f, 0.04151906f, -0.02251456f, 0.30455202f, 0.20411839f, 0.19640762f, 0.11067419f, 
    -0.02817533f, 0.09134851f, -0.04734497f, 0.00730823f, 0.00755853f, 0.33504117f, 0.28591999f, 0.01542749f, 
    0.03576486f, -0.14470755f, 0.13444768f, -0.01617876f, -0.13870835f, -0.20695893f, 0.15995099f, 0.12507230f, 
    0.27770665f, -0.28929684f, 0.28504521f, -0.10316915f, -0.06441119f, -0.03682172f, 0.37590623f, -0.00728397f, 
    -0.05483531f, 0.04944089f, 0.03602704f, 0.01993986f, 0.11607827f, 0.24555591f, -0.06217775f, 0.09666954f, 
    -0.25425375f, 0.24649139f, 0.08465446f, 0.08446364f, 0.15496270f, 0.14549935f, 0.12275226f, 0.29038519f, 
    -0.02049565f, 0.11307677f, -0.03549634f, -0.05654250f, -0.34599429f, -0.02297428f, -0.16957365f, 0.03047292f, 
    0.01681549f, 0.30350319f, 0.04474469f, 0.15121217f, 0.04365709f, 0.14737485f, -0.16823447f, -0.00508323f, 
    0.22611579f, 0.05334738f, -0.09949861f, -0.11715268f, -0.02253926f, -0.05973628f, -0.15249322f, 0.20452628f, 
    0.14959525f, -0.19579393f, -0.12918468f, 0.09085765f, 0.19619921f, -0.08063033f, -0.01878902f, -0.12212755f, 
    0.08461235f, 0.08285057f, 0.04538685f, -0.11114661f, 0.06022001f, 0.02413136f, 0.10590514f, 0.16517919f, 
    0.04865232f, -0.02899884f, 0.06391955f, 0.24446782f, 0.16560544f, 0.21891384f, -0.04570157f, -0.09206425f, 
    0.07164706f, 0.11428790f, 0.01216596f, 0.00129219f, -0.00541809f, -0.01243478f, -0.02855749f, 0.05705206f, 
    0.25641805f, -0.22745027f, 0.00981304f, -0.15847711f, -0.09103521f, 0.13504387f, 0.10727813f, -0.00765819f, 
    -0.01407036f, 0.01506877f, -0.04814447f, 0.00490485f, -0.16773948f, -0.08665717f, -0.09818751f, -0.04794142f, 
    -0.02498279f, -0.05850113f, 0.09539052f, -0.09623381f, 0.18873018f, 0.05149388f, 0.01096410f, -0.30167004f, 
    0.10298149f, -0.20559651f, 0.01732774f, 0.05205641f, -0.05326536f, -0.03057783f, -0.23693605f, 0.15778409f, 
    0.02488858f, 0.31488150f, -0.44338199f, 0.10720483f, 0.22199246f, -0.20655099f, -0.29253036f, -0.08706177f, 
    -0.02829396f, 0.04402690f, 0.01264087f, -0.09723733f, -0.14243878f, 0.68628383f, -0.15586892f, -0.04416246f, 
    0.04358029f, 0.09246089f, -0.62941545f, 0.01077966f, -0.10683084f, 0.17841788f, 0.14071481f, -0.12354951f, 
    0.56327504f, -0.00824731f, -0.13444449f, -0.08878303f, -0.00750556f, -0.14531036f, 0.18337192f, 0.06579269f, 
    -0.19332859f, -0.08396824f, 0.11247785f, -0.12692247f, -0.20471402f, 0.23778938f, -0.04852771f, -0.05072632f, 
    0.05149686f, 0.04074396f, -0.02359773f, 0.09550565f, -0.15974623f, -0.01655365f, -0.09526777f, 0.03692335f, 
    0.03364310f, -0.09276774f, -0.01318664f, -0.36525157f, -0.19813819f, -0.00616811f, 0.21082532f, 0.03076509f, 
    0.01361677f, -0.13235685f, 0.06338956f, 0.14419080f, -0.00341687f, 0.10142877f, -0.03332688f, -0.25556159f, 
    -0.02567958f, 0.12897398f, 0.13955630f, 0.02041023f, 0.00585045f, 0.06572699f, -0.00093256f, 0.14303178f, 
    -0.19333105f, -0.36027598f, -0.32481083f, 0.13604771f, -0.10249670f, 0.03340961f, 0.03147271f, 0.00724732f, 
    0.04507310f, -0.24757680f, -0.35989830f, 0.03044370f, -0.03047325f, -0.00749025f, 0.02958049f, -0.32871726f, 
    -0.07203312f, 0.07430736f, 0.10543733f, -0.40642849f, -0.24616267f, 0.06197853f, 0.12562422f, -0.05863930f, 
    -0.09295534f, -0.29734123f, -0.02957283f, 0.09289754f, 0.30743295f, -0.01743280f, -0.05746565f, -0.00889278f, 
    -0.07839831f, 0.03058796f, -0.02042393f, 0.29616478f, -0.01098376f, 0.05088117f, 0.06260333f, 0.12717295f, 
    0.06142375f, 0.05110156f, 0.55090302f, 0.22124746f, -0.16377902f, 0.28428960f, -0.06102524f, -0.01038856f, 
    -0.00574945f, 0.02666135f, -0.12245502f, 0.08181280f, 0.12039167f, 0.01390041f, 0.04775314f, -0.01090490f, 
    0.04963918f, 0.47487640f, 0.09477056f, 0.03752206f, 0.34756866f, 0.28147009f, 0.22569272f, 0.00694545f, 
    -0.14677072f, 0.10557684f, 0.04598114f, 0.05088969f, 0.05753656f, -0.02124031f, -0.23707981f, 0.26226717f, 
    -0.06803586f, -0.16833648f, -0.06570861f, 0.19829519f, -0.05103131f, -0.00313055f, 0.20244557f, -0.19936690f, 
    -0.35760495f, 0.19270492f, -0.18378869f, -0.40756205f, -0.04974825f, -0.27949190f, 0.07896660f, -0.06627768f, 
    -0.17863794f, -0.05467216f, 0.12114302f, 0.05087138f, 0.25604334f, 0.12539157f, 0.02795047f, -0.00393232f, 
    0.18598515f, -0.11397487f, -0.13909681f, -0.00599830f, -0.02024936f, 0.15649873f, -0.29537386f, -0.12831183f, 
    0.34443241f, -0.20804611f, -0.03673121f, 0.10553204f, -0.05608358f, -0.09664578f, 0.03510269f, -0.03998421f, 
    -0.05288651f, -0.23289171f, 0.19383626f, 0.17734270f, -0.11909548f, 0.15964641f, -0.02410965f, 0.25011316f, 
    -0.11332294f, -0.13514803f, 0.28823650f, 0.07454091f, 0.23180154f, 0.04555188f, -0.29889879f, 0.03761578f, 
    -0.05372850f, -0.00579190f, 0.06450778f, 0.07129405f, 0.29438928f, 0.06913157f, 0.10566371f, -0.02287842f, 
    -0.09686267f, -0.04814533f, -0.21576494f, 0.03417969f, -0.12941760f, 0.27654621f, -0.04993866f, 0.05162962f, 
    -0.07895833f, 0.02487230f, 0.04658586f, -0.07374721f, 0.06061526f, 0.14098375f, 0.04930816f, -0.21374707f, 
    -0.08603188f, -0.02979204f, -0.07337382f, 0.07654376f, 0.06685643f, 0.06737732f, 0.05577640f, -0.01303986f, 
    -0.01945191f, -0.08262366f, 0.02013086f, 0.06580955f, 0.03189040f, -0.09100897f, -0.02644520f, 0.02510283f, 
    -0.04067091f, -0.03748133f, -0.03418400f, -0.05582538f, 0.00913981f, 0.06644264f, -0.06935360f, -0.09164602f, 
    -0.04387550f, -0.07529004f, -0.03255553f, -0.05757006f, 0.04851057f, 0.05103314f, -0.04143418f, -0.03136979f, 
    -0.04328572f, -0.00498725f, -0.10782005f, 0.04026006f, 0.01859405f, 0.02545307f, -0.02380710f, 0.06794992f, 
    0.02170148f, 0.05035343f, 0.06193247f, -0.01311854f, -0.04042397f, 0.06547096f, 0.01965738f, -0.06274293f, 
    -0.05042218f, -0.03895647f, -0.03081868f, 0.08123212f, -0.01358432f, 0.02562029f, 0.03055446f, 0.05607197f, 
    -0.00500275f, -0.03115921f, -0.03033796f, -0.02259111f, 0.03032303f, 0.02877213f, -0.03308926f, -0.04180223f, 
    -0.01520233f, -0.01498884f, -0.02941969f, 0.04134618f, -0.06694866f, 0.06348055f, -0.05631521f, 0.05750523f, 
    -0.03036308f, 0.05182813f, -0.09863798f, -0.07821981f, 0.02175650f, 0.03664858f, 0.02915416f, -0.07977313f, 
    -0.09945983f, 0.05609222f, 0.00072794f, -0.03161209f, -0.02186413f, 0.02426272f, 0.07103036f, 0.02686009f, 
    -0.04909814f, -0.05660899f, -0.05115993f, -0.03494260f, -0.01875785f, -0.02468762f, -0.01497270f, -0.05918482f, 
    -0.08136353f, -0.03385051f, -0.00325077f, -0.06231012f, -0.09565661f, 0.03647989f, -0.01302142f, -0.10492737f, 
    0.02939858f, 0.05930619f, -0.10965637f, -0.09466870f, -0.09914204f, -0.06771877f, -0.06971203f, -0.03305246f, 
    -0.05329025f, 0.01274002f, -0.03118852f, 0.02931932f, -0.10577109f, 0.02829110f, -0.01790030f, -0.04875943f, 
    -0.05353526f, -0.09695741f, -0.03894494f, 0.04567406f, -0.03151638f, -0.07471145f, -0.09055703f, 0.04339724f, 
    -0.00377830f, 0.00743722f, -0.07499462f, -0.04613405f, 0.04512167f, -0.00692228f, 0.00656248f, -0.01179704f, 
    -0.03546478f, 0.00490638f, -0.01853482f, -0.03034390f, 0.03856984f, -0.04076669f, -0.01166735f, -0.07491398f, 
    0.06789896f, -0.00467492f, 0.05947666f, -0.04504633f, -0.05385036f, -0.06775844f, -0.01712545f, -0.00202505f, 
    -0.02375169f, 0.05657723f, -0.01764041f, -0.06725065f, -0.01792386f, -0.03952695f, -0.00688400f, -0.01001759f, 
    -0.00190388f, -0.01801912f, 0.05781238f, 0.02746790f, -0.01253013f, -0.02578147f, 0.02715087f, -0.08176331f, 
    -0.08625830f, 0.00338089f, 0.02444639f, -0.10423601f, -0.02916064f, -0.02988838f, -0.02922226f, -0.08104247f, 
    0.04032068f, 0.08789394f, -0.07325760f, -0.04900477f, 0.05293282f, 0.02391821f, 0.02265560f, 0.05734865f, 
    -0.08813447f, -0.01732770f, -0.01895975f, 0.04838395f, 0.03745997f, -0.07080171f, 0.04635069f, 0.01684745f, 
    -0.07402468f, -0.04915087f, -0.05030508f, 0.04140605f, -0.08027672f, -0.06765226f, 0.05374384f, -0.03675009f, 
    0.03505230f, 0.03571488f, 0.02616098f, -0.03834450f, 0.03280293f, -0.00814093f, -0.00038782f, 0.00717944f, 
    0.01788048f, 0.04324363f, 0.05885942f, 0.06174437f, 0.00237457f, -0.08718589f, -0.05881606f, -0.00340090f, 
    -0.06602447f, 0.03200337f, -0.04955875f, -0.01455596f, 0.04790222f, -0.05683915f, -0.06239962f, -0.02918682f, 
    0.01711941f, -0.01986997f, 0.00455743f, 0.05509641f, 0.07796777f, -0.08665995f, -0.07160996f, -0.06778123f, 
    -0.06374575f, -0.01554069f, 0.03206162f, 0.00576693f, -0.03245932f, -0.05512571f, 0.05717332f, 0.03016053f, 
    -0.03091589f, -0.01527943f, -0.06416388f, -0.01732435f, -0.02270414f, -0.00285255f, -0.07015321f, -0.01847046f, 
    -0.00901151f, -0.02482167f, 0.04026304f, -0.05886124f, -0.07940094f, -0.04490706f, 0.05353807f, 0.01978159f, 
    0.29261732f, -0.11485222f, -0.13844021f, 0.17952621f, 0.16569132f, 0.17273581f, -0.11972506f, 0.01301781f, 
    -0.33204186f, 0.17452793f, 0.04189743f, 0.19704832f, -0.05333226f, 0.09259359f, 0.19744574f, 0.03896722f, 
    -0.07451231f, -0.00117593f, 0.07921532f, 0.14407223f, 0.05492058f, 0.30445781f, 0.16526398f, -0.02729766f, 
    -0.08412234f, -0.07501417f, -0.01024009f, 0.06763618f, 0.04148106f, 0.03275597f, 0.02072158f, 0.00649555f, 
    0.13828121f, -0.40088412f, 0.01162020f, -0.06809601f, 0.35887137f, 0.00125843f, -0.08988069f, 0.00443456f, 
    0.03361408f, 0.04912006f, 0.18605457f, 0.46421242f, 0.22014290f, 0.14096203f, 0.01149556f, 0.00889221f, 
    0.12791574f, 0.08669760f, 0.07346480f, -0.09669525f, -0.16671102f, 0.11785121f, 0.08227356f, -0.01107569f, 
    0.21790329f, 0.06721943f, -0.03397183f, 0.01698386f, -0.03285846f, 0.01876542f, 0.36323455f, -0.02035721f, 
    0.05186216f, 0.10808913f, -0.12881763f, -0.08870123f, -0.03824663f, -0.16738459f, 0.00859435f, 0.16620627f, 
    -0.11091866f, 0.10137662f, 0.01784057f, 0.15617377f, 0.00829909f, 0.05998557f, 0.15101910f, -0.00141643f, 
    0.04569799f, -0.29806244f, 0.20524539f, -0.02590099f, -0.09374375f, -0.15240268f, -0.07885792f, 0.01097496f, 
    0.19146301f, 0.02415553f, 0.26120320f, 0.13864605f, 0.08275361f, 0.09808291f, -0.07348137f, 0.00016547f, 
    0.02248885f, -0.00863648f, 0.15231413f, -0.12247544f, -0.22689511f, -0.04327663f, 0.07588233f, 0.01339587f, 
    0.15253408f, 0.00618699f, -0.02371205f, 0.10691228f, 0.33580306f, -0.15254067f, 0.07421419f, 0.07437647f, 
    0.01357819f, 0.03017664f, -0.32650632f, -0.26528281f, -0.01293393f, -0.27201176f, -0.03344006f, 0.09961279f, 
    -0.10297658f, -0.16277792f, -0.12820390f, -0.05821468f, 0.11315200f, -0.09689958f, -0.01032159f, 0.03906397f, 
    -0.00175874f, 0.03332796f, 0.06879915f, -0.03362350f, 0.02084035f, -0.21572545f, 0.18718056f, -0.02550411f, 
    0.14690699f, 0.09534583f, 0.01271811f, 0.33057889f, 0.01767507f, 0.00865253f, -0.25154376f, 0.29792023f, 
    -0.07231837f, 0.06308290f, 0.33255348f, 0.10418217f, -0.00707252f, -0.06255974f, -0.22822800f, 0.11041835f, 
    0.34376359f, 0.05837716f, -0.04048791f, -0.04433784f, 0.20207405f, 0.15831327f, 0.04815143f, 0.04281735f, 
    -0.07115201f, 0.36747420f, 0.07737309f, -0.23436806f, 0.29416588f, 0.43605584f, 0.18156461f, 0.00200769f, 
    -0.12838620f, 0.00727434f, 0.19309931f, -0.13531283f, -0.06665245f, 0.04160243f, 0.14390714f, 0.03276025f, 
    0.10246401f, -0.08349968f, 0.02382712f, 0.15497652f, 0.28563949f, 0.02987426f, -0.05483226f, -0.37393415f, 
    0.17589921f, -0.05915539f, 0.20328061f, -0.16929284f, -0.00102225f, -0.00218956f, 0.00215347f, -0.00994365f, 
    -0.35123980f, 0.32392895f, 0.16323997f, -0.03494233f, 0.23815072f, 0.35642731f, 0.14825983f, 0.21749169f, 
    -0.00614337f, -0.05629864f, -0.01182418f, 0.07074478f, 0.11058484f, 0.00749663f, -0.16883411f, 0.01981393f, 
    0.03898813f, 0.58181024f, -0.06017218f, 0.02488176f, 0.16380592f, 0.12579417f, -0.25722194f, 0.02635127f, 
    0.01344082f, 0.04559554f, -0.08193106f, -0.00340713f, -0.04348588f, -0.01435734f, 0.31218541f, 0.15500578f, 
    0.13723801f, -0.16422343f, 0.32474384f, 0.12734616f, 0.18743217f, -0.04694931f, -0.00644542f, -0.14611286f, 
    -0.02221701f, -0.06676506f, -0.01499997f, -0.01483445f, 0.37518021f, -0.04353001f, 0.01723743f, 0.26502460f, 
    0.11101120f, -0.05012502f, 0.18980087f, 0.19431627f, -0.02987231f, 0.12159538f, 0.16566712f, -0.07555468f, 
    0.00190960f, 0.01240819f, 0.01161361f, 0.07662944f, 0.00753827f, -0.04643583f, 0.05698378f, -0.03563770f, 
    -0.18563487f, 0.15258722f, -0.03313838f, 0.01796773f, 0.29062653f, 0.27720234f, 0.10180046f, 0.11923310f, 
    0.03836264f, -0.10714962f, -0.01674170f, 0.14234610f, -0.23634651f, -0.00407519f, 0.00199948f, 0.43879434f, 
    0.03980203f, -0.02437001f, 0.13772923f, 0.00672715f, 0.04618840f, -0.45490900f, -0.07451483f, -0.05973130f, 
    0.28452155f, -0.18028088f, -0.20423171f, -0.09272313f, -0.09561498f, -0.09656744f, 0.09291794f, 0.18238010f, 
    0.06257872f, 0.14431538f, -0.07309206f, 0.09197263f, 0.03446370f, -0.28596050f, -0.03118691f, 0.29704991f, 
    0.10031535f, -0.21042484f, 0.01154005f, 0.24648222f, -0.08638730f, -0.47965264f, -0.06518794f, 0.40085709f, 
    0.08322836f, 0.05722232f, 0.01583634f, 0.01283938f, -0.13054137f, 0.20548005f, 0.39459217f, 0.08470058f, 
    0.10747927f, 0.19450702f, 0.18266284f, 0.28898552f, -0.09705262f, 0.14869446f, 0.12607202f, 0.03824266f, 
    -0.11394917f, 0.12204945f, -0.04600064f, 0.07114570f, 0.01616745f, -0.07266464f, 0.01017766f, 0.03172951f, 
    -0.05180956f, 0.20204204f, 0.05225462f, 0.12325918f, -0.03171189f, 0.02146254f, -0.08789399f, 0.02220765f, 
    0.06711131f, 0.12701872f, -0.12249370f, -0.05078761f, 0.20154458f, 0.20093344f, 0.09807236f, -0.07383134f, 
    0.00415284f, 0.05606654f, 0.03322412f, -0.10850820f, -0.02229315f, 0.01252640f, -0.18549930f, -0.06757207f, 
    0.18086311f, -0.08285896f, -0.01481374f, 0.19682780f, 0.17812489f, -0.03760315f, 0.13272373f, 0.10219672f, 
    -0.05778127f, -0.08747229f, 0.03159295f, 0.15405750f, -0.15827733f, -0.12674226f, -0.16085018f, 0.20664802f, 
    0.32190821f, -0.09233152f, 0.01723908f, -0.29701817f, 0.04731378f, 0.02823690f, -0.04026922f, -0.13476263f, 
    -0.06368051f, 0.05449626f, 0.16155779f, -0.06451861f, 0.04561460f, 0.11738576f, 0.23392573f, 0.25960809f, 
    -0.14275430f, 0.11107257f, -0.27550679f, -0.07766218f, -0.34213206f, 0.18133871f, -0.15625881f, 0.00219477f, 
    0.35318354f, -0.21225904f, 0.08156563f, -0.45350292f, -0.02069687f, 0.04995856f, -0.19070777f, -0.11204778f, 
    -0.02302492f, 0.06428917f, -0.44123438f, -0.01323311f, -0.20578487f, 0.03878881f, 0.26502720f, 0.15165372f, 
    -0.25031835f, 0.03619507f, 0.38154837f, 0.09694463f, 0.14761207f, 0.01236906f, -0.25307095f, 0.17113242f, 
    -0.24948151f, 0.00176127f, -0.16319062f, 0.28755188f, -0.36108470f, -0.22064935f, 0.02148156f, -0.10591412f, 
    -0.23535521f, -0.01291111f, -0.19687715f, -0.11098465f, -0.14841567f, -0.22808035f, -0.17568663f, -0.18589838f, 
    0.04008578f, 0.11394925f, -0.10819103f, -0.02244665f, 0.21087249f, 0.07119509f, 0.06671365f, -0.01437765f, 
    -0.01435038f, 0.07010613f, 0.09459370f, 0.12567975f, 0.05581162f, -0.07902522f, 0.10852626f, 0.21800357f, 
    0.17294256f, -0.30614686f, -0.08618979f, 0.05050103f, 0.03289238f, 0.12886678f, -0.24259721f, -0.44290847f, 
    0.20773531f, -0.00997606f, -0.04045934f, 0.02395212f, 0.17212917f, -0.07191152f, 0.07389651f, 0.07179594f, 
    0.05896473f, -0.07820515f, -0.14123611f, 0.02520977f, 0.08764399f, -0.19342047f, 0.16676238f, -0.02738124f, 
    -0.11427709f, 0.15104578f, 0.00377597f, 0.02025791f, 0.05211009f, 0.02299711f, 0.20219463f, 0.08682757f, 
    -0.22114219f, 0.26666728f, -0.16726199f, 0.00666660f, 0.35061219f, 0.06007749f, -0.00671038f, 0.49750894f, 
    -0.01369276f, -0.07812496f, 0.00179189f, 0.24817400f, -0.28654018f, 0.17053598f, -0.04341989f, -0.16695254f, 
    0.05834964f, 0.18967102f, 0.04250620f, -0.01975550f, -0.03001430f, 0.18828139f, 0.20648424f, 0.01248077f, 
    0.04084700f, 0.07617205f, 0.18629190f, 0.13979939f, -0.04924330f, -0.04409548f, 0.10359728f, 0.03222440f, 
    0.06784678f, -0.03768399f, 0.00511473f, 0.04701430f, -0.01894397f, 0.00942378f, -0.02147289f, 0.02505527f, 
    -0.05336041f, -0.01941104f, 0.08793022f, -0.06074025f, -0.05769813f, -0.02837417f, -0.00077321f, -0.02696878f, 
    -0.08205859f, 0.00840110f, 0.06640438f, -0.12109228f, -0.03846422f, -0.02094892f, -0.04769092f, -0.08820550f, 
    -0.02905767f, -0.00096812f, -0.10821348f, -0.01290280f, 0.02686195f, 0.03049069f, -0.06529170f, -0.06704432f, 
    -0.00830148f, 0.00110541f, -0.07910457f, -0.05815387f, -0.04959887f, 0.04060856f, -0.08859841f, -0.11776749f, 
    -0.09745218f, 0.00430472f, 0.01192739f, -0.06484820f, -0.10900741f, -0.04642350f, -0.08821744f, 0.03753785f, 
    -0.05327695f, 0.05317145f, 0.03906860f, -0.07312524f, -0.04053792f, -0.04928918f, -0.04447377f, -0.06617702f, 
    -0.04775410f, -0.07489987f, -0.06267186f, 0.03802550f, -0.11702357f, -0.11438306f, -0.00886545f, 0.02138238f, 
    -0.03367889f, 0.05374563f, -0.06373501f, -0.03949708f, 0.01293814f, -0.00570425f, 0.04779901f, -0.04789853f, 
    0.04478854f, 0.01625280f, -0.08680004f, -0.00484334f, -0.00683130f, 0.02517818f, 0.02987288f, -0.06897091f, 
    0.05344507f, -0.01136693f, -0.02469689f, -0.06062632f, 0.00901962f, -0.08832743f, -0.03339012f, 0.01600372f, 
    -0.06381577f, -0.00312802f, 0.06641731f, -0.06692616f, -0.08808963f, -0.03214894f, -0.10197242f, -0.02040207f, 
    0.03315444f, -0.07015270f, -0.03381255f, -0.02846042f, -0.05725583f, 0.06579615f, -0.06185338f, -0.07525145f, 
    -0.05223068f, 0.05195992f, 0.02926237f, -0.08499495f, -0.05293314f, -0.00595334f, -0.00982625f, 0.01005372f, 
    -0.05598892f, 0.02773688f, 0.03462615f, -0.11170319f, -0.08910797f, -0.02498129f, 0.00084219f, -0.00564391f, 
    -0.02996449f, -0.01961621f, -0.06085344f, -0.04360914f, 0.04709920f, -0.09198663f, -0.01083137f, -0.02367196f, 
    -0.26073059f, 0.41481340f, -0.79117930f, -0.10310253f, -0.02757473f, -0.12718886f, 0.18731365f, 0.02612713f, 
    0.10910642f, 0.20910698f, -0.05853915f, -0.31332693f, 0.08011021f, 0.08254666f, -0.24787390f, -0.40497050f, 
    -0.01870856f, -0.00607767f, -0.48572457f, 0.28524724f, -0.69611645f, 0.09113112f, 0.20181477f, 0.30210564f, 
    -0.15871483f, -0.03421477f, 0.16582696f, 0.04191859f, 0.47622859f, 0.00793921f, 0.16892470f, -0.08414474f, 
    -0.57735145f, -0.02642824f, -0.06586391f, 0.06139259f, -0.37500221f, 0.18820648f, 0.02426763f, -0.14900225f, 
    -0.67959678f, -0.26126724f, -0.06876942f, -0.09917657f, 0.11347044f, -0.08925811f, 0.54263216f, -0.18602958f, 
    0.16585180f, 0.39672220f, 0.24621996f, -0.22030872f, 0.11604301f, -0.39273432f, 0.00151831f, -0.02452863f, 
    -0.35160318f, -0.12791525f, -0.32117510f, -0.07081889f, -0.06155190f, 0.06946010f, -0.39778113f, 0.01788257f, 
    0.05153263f, 0.11382394f, -0.08395564f, 0.08069438f, 0.22861291f, 0.25673264f, -0.24209525f, 0.31122804f, 
    0.00009110f, -0.00947352f, 0.01356445f, -0.06891038f, 0.37612152f, 0.11440608f, 0.42015320f, 0.01567480f, 
    -0.32312179f, 0.72696805f, 0.21606807f, 0.05238742f, 0.34835112f, 0.38365781f, -0.21006070f, 0.03026683f, 
    0.05828584f, 0.19855189f, -0.19769597f, 0.02118779f, 0.30889347f, -0.31932414f, 0.31715295f, 0.14622791f, 
    0.03629244f, 0.18418700f, -0.33615038f, 0.01619387f, 0.23633130f, 0.08435520f, -0.18674888f, 0.12864077f, 
    0.25018954f, -0.07221165f, 0.31559527f, -0.15352927f, -0.12212023f, -0.13034913f, 0.07551415f, 0.16548999f, 
    -0.09703447f, 0.06073274f, 0.66261560f, 0.09353559f, -0.16074109f, 0.01056765f, 0.02455230f, 0.22431764f, 
    0.02462998f, 0.06520019f, 0.06275231f, 0.06403759f, 0.14641902f, -0.20936817f, -0.13570000f, -0.13536419f, 
    -0.13823391f, -0.03796850f, 0.02013248f, -0.14188056f, -0.05242261f, -0.11633311f, 0.01783246f, -0.02680174f, 
    -0.01537715f, 0.01570660f, -0.05001267f, -0.00421974f, -0.08851281f, -0.01511159f, -0.02588920f, -0.02565896f, 
    0.06384706f, -0.07393711f, 0.02706424f, -0.07686217f, -0.02368530f, -0.04390607f, -0.08662552f, -0.10463469f, 
    -0.01494788f, -0.01773557f, 0.04679446f, 0.04882629f, -0.07753593f, -0.11714275f, -0.06962496f, -0.00272360f, 
    -0.04349410f, -0.03160189f, 0.00834601f, -0.04614925f, -0.03728580f, 0.04082196f, 0.02494470f, 0.00224877f, 
    -0.02334640f, -0.02930967f, -0.06090233f, -0.03956440f, 0.00972357f, 0.05772546f, -0.04154113f, 0.03483667f, 
    0.04541120f, 0.00662201f, 0.04614001f, 0.03846550f, -0.07742909f, -0.00995619f, -0.07325515f, 0.05544554f, 
    -0.09411286f, -0.07522355f, -0.08483274f, 0.03919138f, -0.11504459f, -0.00767795f, -0.02890451f, 0.04158601f, 
    0.05207551f, 0.01848092f, 0.04994110f, -0.10141908f, 0.05085494f, -0.01289951f, 0.03571424f, -0.01475592f, 
    -0.05916263f, -0.07645453f, 0.04257464f, 0.07399210f, 0.02121858f, 0.06645656f, -0.06557858f, 0.05672126f, 
    -0.03538743f, 0.05181386f, 0.00887334f, -0.08630499f, 0.02158185f, -0.02188798f, 0.00433859f, 0.04155098f, 
    -0.01263919f, 0.02939013f, 0.05064393f, 0.03969425f, 0.00474756f, -0.14834641f, -0.03500885f, -0.08306417f, 
    -0.06490900f, 0.03396945f, -0.08031689f, -0.03107290f, -0.10476688f, -0.00506460f, 0.04697278f, -0.06712129f, 
    0.02534930f, -0.09600791f, -0.08941440f, -0.08694267f, -0.11437596f, -0.05933260f, -0.04810918f, 0.00283751f, 
    -0.11496684f, -0.11365122f, -0.06936564f, 0.03739427f, 0.06236798f, -0.05039542f, -0.09717982f, -0.00583834f, 
    0.01412362f, -0.05198417f, 0.00741520f, -0.11140947f, 0.07208779f, 0.04945126f, 0.05921054f, -0.10500956f, 
    0.06119696f, -0.06969466f, -0.04562986f, -0.03630581f, 0.04438321f, -0.09026983f, -0.01511072f, -0.04693932f, 
    -0.10623185f, -0.02099593f, -0.04734648f, 0.04575947f, 0.03001006f, -0.07435037f, -0.05900404f, 0.04581938f, 
    0.00806739f, -0.03583791f, -0.00077404f, -0.01161791f, 0.00036398f, -0.08527991f, 0.03571094f, -0.05993963f, 
    -0.01888818f, -0.08056241f, -0.03697099f, 0.06004917f, 0.06744580f, -0.08579811f, 0.02871520f, -0.04562504f, 
    -0.02560974f, -0.06947462f, -0.08809135f, 0.06783425f, 0.03518180f, -0.07827614f, -0.01472628f, -0.09082757f, 
    0.04681489f, 0.01439564f, -0.07598110f, 0.02085042f, -0.06232746f, -0.07903039f, -0.00325788f, -0.05559060f, 
    -0.08199115f, -0.02183293f, 0.01589194f, -0.01143489f, 0.06298762f, 0.02298576f, 0.06991327f, 0.06934896f, 
    0.01250226f, 0.04243441f, 0.01388932f, -0.05613979f, -0.02081916f, -0.05760096f, -0.03821545f, -0.02861998f, 
    0.02064892f, -0.10262331f, 0.00995229f, 0.06218761f, -0.08416907f, -0.06208545f, 0.04242689f, -0.06024763f, 
    0.01918025f, 0.05777020f, 0.05498237f, 0.06455629f, 0.05605630f, -0.07848429f, -0.01616422f, -0.02214926f, 
    0.04875549f, 0.03050831f, -0.02477209f, -0.00392392f, 0.03751183f, 0.03922693f, 0.00946654f, -0.07257886f, 
    -0.05275246f, -0.10653341f, 0.05459638f, -0.03756528f, 0.00537419f, -0.04492971f, 0.00032041f, -0.01340156f, 
    -0.04916025f, -0.02827770f, 0.03541670f, -0.00957361f, -0.04836402f, -0.07965702f, -0.05815575f, -0.01852629f, 
    -0.03673176f, -0.03007898f, -0.04452814f, 0.00441758f, -0.08218597f, 0.06358607f, -0.05985685f, -0.01697257f, 
    0.01889129f, 0.02382499f, 0.00622487f, 0.02415117f, -0.08176863f, 0.04898035f, -0.07928985f, -0.02326903f, 
    -0.03471229f, 0.04399439f, -0.01281451f, 0.04209958f, -0.01611700f, -0.08997294f, 0.03109502f, -0.04092464f, 
    -0.03782136f, 0.19045517f, -0.21626510f, -0.15207222f, 0.05828599f, 0.07441771f, -0.15124661f, -0.01656417f, 
    -0.03417848f, -0.21813929f, -0.04624311f, 0.15557919f, -0.10449170f, -0.01219462f, 0.12039482f, 0.19477184f, 
    0.02793333f, -0.02442410f, -0.36399141f, -0.09503574f, 0.15960711f, 0.25641716f, 0.14674932f, -0.08399377f, 
    -0.03945833f, -0.06940395f, 0.23938742f, -0.00387102f, -0.01477956f, 0.18851759f, 0.17870370f, 0.10608566f, 
    -0.12431081f, -0.17239460f, 0.09272325f, 0.26070648f, 0.09573187f, -0.02167613f, 0.01550669f, 0.14264362f, 
    -0.08039459f, -0.21262585f, 0.15444288f, 0.29295048f, 0.02072483f, -0.21350752f, 0.29613367f, 0.05539940f, 
    0.09816094f, -0.29332682f, 0.15313566f, -0.56442618f, -0.07690611f, -0.18220782f, 0.25530869f, 0.16046815f, 
    -0.11799112f, -0.07411887f, -0.20196697f, 0.28682610f, 0.04154285f, 0.10702367f, -0.20411521f, -0.04843491f, 
    -0.07460800f, 0.11250567f, -0.30678797f, 0.23163193f, -0.06410836f, -0.01031127f, -0.05794324f, 0.25666112f, 
    -0.10786973f, 0.08219774f, -0.08090486f, -0.02707637f, -0.16946886f, -0.04559014f, 0.28787842f, 0.07190763f, 
    -0.09602994f, -0.36589754f, 0.05909254f, 0.06324022f, -0.01536824f, 0.14470339f, -0.16692433f, -0.04284300f, 
    0.06874011f, 0.14029948f, 0.10367204f, -0.08210323f, 0.09200323f, -0.06429943f, 0.00817211f, 0.12560160f, 
    0.14638008f, -0.15954940f, -0.13381453f, 0.05719106f, -0.00115848f, -0.02568658f, 0.14508648f, -0.01605960f, 
    0.22042951f, -0.04795447f, 0.18845202f, -0.02063825f, -0.13238400f, -0.14044727f, 0.23236424f, 0.10623669f, 
    0.12514533f, 0.01512962f, 0.07028686f, 0.00295080f, 0.15352441f, -0.03611928f, -0.02081659f, -0.08669376f, 
    -0.05541649f, 0.01484851f, -0.07172961f, 0.09381324f, 0.42918396f, -0.08371826f, -0.06212127f, 0.05604914f, 
    0.00613170f, -0.11512355f, -0.08251557f, -0.02459373f, 0.05811549f, -0.00279974f, -0.02174025f, -0.06879349f, 
    -0.10638625f, -0.08628290f, 0.03875659f, 0.08593152f, 0.00358299f, 0.00935094f, -0.04608306f, -0.09475481f, 
    -0.04257417f, 0.02327919f, -0.08481905f, -0.05634423f, -0.06391658f, -0.00313587f, 0.04893348f, -0.08174973f, 
    0.05020396f, -0.10991544f, -0.02295749f, 0.04354141f, -0.05199409f, 0.05605981f, -0.11157316f, 0.01883344f, 
    -0.07111173f, 0.01510152f, -0.07259745f, -0.09850858f, -0.01676978f, 0.06547824f, -0.11546581f, 0.01767036f, 
    0.04265648f, -0.07875824f, 0.06312054f, -0.06015541f, -0.08267552f, 0.05632224f, 0.00045261f, 0.05730465f, 
    -0.11103934f, 0.06913613f, -0.04418278f, 0.07263020f, 0.06273771f, -0.08062527f, 0.02454147f, -0.01827385f, 
    -0.00790485f, -0.11276863f, -0.09182278f, -0.07225599f, -0.01686491f, 0.03018016f, 0.03015369f, -0.08699086f, 
    -0.07169095f, -0.02380538f, -0.02370864f, -0.11395713f, -0.02100794f, -0.05930793f, 0.03876711f, 0.00475479f, 
    -0.06377864f, 0.03676194f, -0.10698706f, -0.05233114f, -0.04212471f, 0.02878204f, 0.02067613f, -0.04883968f, 
    -0.11868545f, 0.04741858f, -0.03770002f, 0.02835607f, -0.00354721f, -0.02172334f, -0.06230147f, 0.01906997f, 
    0.04720481f, -0.10002298f, 0.03867076f, -0.03608468f, -0.10009316f, -0.07465780f, -0.02857829f, 0.04181686f, 
    0.08406525f, -0.04772953f, -0.02714158f, 0.01077809f, 0.03780500f, 0.07119750f, -0.10901945f, 0.03261032f, 
    -0.11376911f, -0.00937707f, -0.02072300f, 0.02138527f, 0.03270616f, 0.02355700f, -0.05827367f, 0.07644574f, 
    -0.00003024f, 0.04036293f, 0.06894721f, 0.00802313f, -0.10525182f, -0.07124111f, -0.03756392f, -0.02496665f, 
    0.05114748f, -0.07834300f, -0.09307136f, -0.05702506f, 0.04169966f, -0.01852676f, -0.11899249f, -0.02538282f, 
    -0.12943235f, -0.09803362f, -0.02432014f, -0.09316261f, -0.00639449f, 0.04537345f, -0.05664223f, -0.09555335f, 
    -0.00172458f, 0.01485401f, 0.06131278f, -0.02718986f, -0.05887809f, 0.00041997f, -0.09769716f, 0.08832746f, 
    0.06384374f, -0.05231492f, 0.14246133f, -0.01313764f, 0.04710193f, -0.12173578f, -0.13347872f, 0.00190186f, 
    0.02937740f, -0.00338096f, -0.06709989f, 0.01874418f, 0.15108670f, 0.03665447f, 0.07782286f, -0.06483795f, 
    0.00774327f, -0.01803078f, 0.03526009f, 0.00628143f, 0.00851858f, -0.05787412f, 0.01945997f, -0.04474139f, 
    -0.00853726f, 0.07548539f, 0.01280856f, 0.02514838f, -0.03822271f, -0.12415399f, 0.10208695f, 0.07629221f, 
    0.14083754f, -0.00864994f, -0.14204460f, -0.19855927f, 0.11554495f, -0.00338187f, -0.00185830f, 0.03526399f, 
    -0.14557849f, 0.05334553f, -0.07699202f, -0.13286571f, 0.00299362f, -0.07415812f, -0.05669815f, -0.05959482f, 
    -0.14718737f, 0.01262564f, 0.00640558f, -0.07294983f, -0.07591891f, -0.05377473f, 0.03357377f, -0.01625062f, 
    -0.01117120f, 0.04672701f, -0.05769641f, 0.07879599f, -0.00139847f, -0.08463149f, -0.01994209f, -0.03895355f, 
    -0.03659869f, -0.00390839f, -0.08265901f, 0.03496000f, 0.00370542f, 0.01975845f, 0.02723686f, -0.07948808f, 
    0.10908984f, 0.05245510f, -0.04694328f, -0.02273717f, 0.00051049f, 0.00762853f, -0.05332558f, 0.05808524f, 
    -0.08985695f, -0.10619547f, -0.06814977f, -0.00336216f, -0.04369718f, -0.06222035f, -0.05716861f, -0.02875417f, 
    -0.15194377f, 0.03804374f, -0.07560118f, -0.06278729f, 0.18611513f, 0.05133710f, -0.07283001f, -0.05868191f, 
    0.01614062f, -0.08829325f, -0.11464035f, -0.08506852f, 0.00740811f, -0.06137376f, -0.08407508f, -0.10606736f, 
    0.05634565f, -0.07328680f, -0.06846974f, 0.05002921f, 0.11619709f, -0.15271564f, 0.03054261f, -0.02978042f, 
    0.00448838f, -0.00033714f, 0.02697257f, 0.04385379f, 0.01038997f, -0.03277587f, -0.02653563f, 0.04716553f, 
    0.00580188f, -0.08910028f, -0.00275532f, 0.04327613f, -0.09282234f, -0.14484519f, -0.00232410f, -0.03675656f, 
    0.08009670f, 0.08036564f, -0.05661970f, -0.06973113f, -0.04409883f, -0.06449598f, -0.15108062f, -0.05908319f, 
    0.05619041f, -0.05948374f, 0.04891674f, -0.07332505f, 0.00521195f, 0.05258761f, 0.03253818f, 0.00489742f, 
    -0.00453958f, -0.06500269f, -0.09512511f, 0.02829659f, 0.03719195f, -0.06855292f, -0.04196420f, 0.06905673f, 
    -0.04767498f, -0.03926712f, -0.04995571f, -0.01922243f, -0.00044109f, -0.05836279f, -0.06343964f, -0.06285907f, 
    -0.08835743f, 0.04102093f, -0.11774123f, -0.04027571f, 0.06049797f, -0.14409934f, 0.00414384f, 0.03641501f, 
    -0.05405255f, -0.06828299f, -0.03443122f, -0.01731918f, -0.11387862f, -0.09046412f, -0.04353996f, -0.03572548f, 
    -0.03450907f, -0.03542056f, 0.02423372f, -0.04275843f, -0.08323081f, -0.10127246f, -0.06706095f, -0.01783445f, 
    -0.04709262f, 0.06794795f, 0.01287086f, 0.06138223f, 0.08149494f, 0.02246513f, -0.01706489f, -0.10761741f, 
    -0.06385095f, -0.08382163f, -0.05890939f, -0.09142206f, 0.03115250f, -0.09702648f, -0.01667144f, -0.01664975f, 
    -0.02664455f, -0.03621076f, -0.04423296f, -0.11348628f, 0.01558014f, -0.06910798f, 0.04224325f, -0.07861342f, 
    0.04992860f, -0.04180696f, 0.02125356f, -0.06651241f, -0.10027079f, -0.02887552f, -0.01336305f, -0.09931102f, 
    -0.04816967f, 0.00437623f, 0.01029259f, 0.02334473f, 0.01547035f, 0.00783942f, -0.05940340f, -0.02619476f, 
    -0.12819494f, -0.08860570f, -0.04243467f, -0.00235497f, 0.02241535f, -0.03800078f, 0.02753038f, -0.01837881f, 
    0.00994036f, -0.17934874f, -0.06471212f, 0.01940309f, -0.06330961f, -0.11321033f, 0.00910878f, -0.01658722f, 
    -0.01685891f, 0.00682643f, -0.07751259f, 0.05243472f, -0.10489450f, -0.06602094f, -0.06528131f, 0.04461269f, 
    -0.01386970f, -0.02149212f, 0.04493413f, 0.07765352f, -0.03042106f, 0.01464436f, 0.05951170f, -0.07868077f, 
    -0.08115346f, 0.02456340f, -0.07391921f, -0.09389411f, 0.05604315f, -0.08519265f, -0.08877905f, 0.07426686f, 
    -0.05658235f, 0.01987223f, 0.03521729f, -0.02844029f, -0.03641556f, 0.04355902f, -0.06544521f, -0.05529978f, 
    -0.03418693f, -0.02940037f, -0.07430754f, -0.00820087f, -0.00345812f, 0.04028365f, -0.08725484f, -0.01228724f, 
    -0.10279806f, -0.01208583f, -0.08400977f, -0.03708370f, -0.09079161f, 0.02907725f, 0.03581533f, -0.01422405f, 
    -0.10282476f, -0.01297784f, -0.03887482f, 0.03743506f, -0.03729122f, 0.03644735f, -0.01406719f, 0.03916331f, 
    -0.04303878f, -0.12405848f, -0.03449287f, -0.07508234f, 0.02060422f, 0.02993399f, 0.00713341f, -0.13634069f, 
    -0.08645548f, -0.04144078f, -0.01504551f, -0.05369381f, -0.02773604f, -0.00308922f, 0.06503963f, 0.01699286f, 
    0.07007331f, -0.00138249f, -0.04665861f, -0.00108123f, -0.00439155f, 0.03682879f, -0.01795500f, -0.06550832f, 
    -0.00104185f, -0.01526136f, -0.04988380f, -0.07638578f, -0.09105028f, 0.00102575f, -0.04996942f, -0.02278564f, 
    0.04914293f, -0.01730361f, -0.09858799f, -0.06574769f, 0.01934814f, 0.01501886f, -0.04936340f, -0.03482946f, 
    0.03685516f, -0.02240987f, -0.02827864f, 0.00198920f, 0.05394377f, -0.08435326f, -0.08991729f, -0.05264986f, 
    0.03767521f, 0.01251358f, -0.05212717f, 0.00006100f, 0.02757563f, 0.04093500f, 0.08313390f, -0.10366936f, 
    0.02137153f, -0.10364982f, -0.03577014f, -0.08466257f, 0.04708813f, -0.04542764f, 0.02193774f, -0.08426987f, 
    -0.01721900f, -0.12263987f, -0.11138248f, -0.07647309f, -0.00038893f, -0.00519940f, -0.07318740f, 0.03594784f, 
    0.27993029f, -0.03583902f, -0.34709144f, 0.09986743f, 0.07352519f, 0.14769599f, 0.14511715f, -0.03245262f, 
    -0.13119867f, 0.07346987f, -0.06283269f, -0.17210975f, 0.06773210f, 0.15751190f, 0.13812588f, -0.47036153f, 
    -0.05621735f, -0.06063447f, 0.01302600f, -0.05041030f, -0.12293337f, 0.49182031f, 0.15189719f, -0.04795307f, 
    0.07175107f, 0.34258839f, 0.25579923f, 0.15035856f, -0.22159037f, -0.05949371f, -0.27644241f, 0.08237833f, 
    0.09638347f, -0.10792550f, -0.27711865f, 0.07908987f, -0.28680900f, -0.51345223f, -0.45709288f, -0.10928652f, 
    0.00073674f, 0.14981721f, 0.02042769f, -0.05298882f, 0.07474397f, 0.31842485f, 0.09421042f, 0.01625552f, 
    -0.11889557f, 0.42556888f, -0.29639363f, 0.05888423f, 0.56469333f, 0.24803813f, -0.03560990f, -0.22051024f, 
    0.36553636f, 0.03274743f, -0.21294826f, -0.07979936f, -0.20494056f, 0.06910618f, -0.43744087f, -0.06429420f, 
    0.24401242f, -0.09239388f, -0.01932797f, -0.17938553f, -0.26539460f, -0.26845548f, -0.00653137f, -0.19988221f, 
    0.19825999f, -0.03554292f, 0.19780314f, 0.00496372f, -0.06373712f, -0.01990016f, 0.23185943f, 0.06906772f, 
    0.05372915f, 0.10457513f, 0.16413970f, -0.21767116f, -0.03769738f, 0.00703948f, -0.03659546f, -0.01054785f, 
    0.07305802f, -0.03212359f, 0.11019795f, 0.09878785f, 0.06543446f, 0.11117427f, 0.28683487f, -0.30903900f, 
    0.04677533f, 0.31782630f, -0.20738244f, -0.16082889f, -0.11250802f, -0.05283940f, 0.15242532f, 0.22806491f, 
    0.01135786f, -0.10735188f, -0.04887934f, 0.16056278f, -0.09942292f, -0.27505037f, -0.01827799f, -0.05558979f, 
    0.03755568f, -0.17505576f, -0.30481020f, -0.19876088f, -0.36257443f, -0.08115149f, 0.05662665f, 0.23225245f, 
    -0.07228894f, 0.21568686f, 0.06621382f, -0.06151413f, 0.04469964f, -0.03444322f, 0.02920642f, -0.04059366f, 
    -0.17409661f, -0.00675101f, -0.07648714f, 0.09116081f, -0.20296319f, -0.02915258f, 0.14797412f, 0.21422438f, 
    0.14966998f, -0.10164925f, -0.08105497f, -0.13587798f, -0.01905920f, -0.06182575f, -0.41214594f, 0.44913805f, 
    0.00648531f, 0.05888423f, 0.36513516f, 0.06740668f, 0.01001761f, -0.56136537f, -0.17783900f, -0.13793346f, 
    0.11566425f, -0.33072779f, -0.32616621f, 0.08680478f, 0.20346349f, 0.11343538f, 0.06744855f, 0.26723611f, 
    0.00054159f, 0.31924257f, -0.13584819f, 0.05866240f, 0.29728496f, -0.09867803f, 0.08399183f, 0.18587589f, 
    0.05006579f, -0.33593130f, 0.08048873f, -0.00968482f, -0.09966327f, 0.27439597f, -0.15131332f, 0.17967507f, 
    -0.08586507f, 0.19737434f, -0.09015734f, 0.15189099f, -0.31965306f, 0.04519314f, -0.02877730f, 0.12616116f, 
    0.36345997f, 0.00812054f, 0.22849685f, 0.07458172f, 0.19794665f, -0.08203929f, 0.21196960f, 0.10032354f, 
    -0.16944508f, 0.07185421f, -0.04379630f, -0.14034075f, 0.11688147f, 0.20334762f, -0.28941706f, -0.17845543f, 
    0.03474274f, -0.07326892f, -0.23613274f, 0.11485863f, 0.41337380f, 0.07672957f, -0.03426734f, 0.10213394f, 
    0.09749965f, 0.28226128f, -0.17760654f, 0.07313209f, 0.22187339f, 0.11905799f, 0.10191659f, 0.06544996f, 
    -0.10516474f, 0.14375065f, 0.02595928f, -0.11288522f, 0.01440410f, 0.02235374f, -0.24764155f, -0.02237615f, 
    0.15767670f, -0.05490743f, 0.01537551f, -0.03866025f, 0.05613869f, 0.07335408f, -0.10354289f, 0.08029269f, 
    -0.05348178f, -0.19739933f, 0.14233994f, 0.28368458f, 0.03767263f, -0.03339074f, -0.28244275f, -0.05260031f, 
    0.02751595f, 0.05003833f, 0.17811371f, -0.24844335f, 0.09923510f, 0.13940869f, -0.16113035f, -0.37483028f, 
    0.07208568f, 0.05055972f, 0.09600855f, -0.04277001f, 0.01403634f, 0.31791282f, 0.16751255f, 0.09358100f, 
    -0.15913537f, 0.36627376f, -0.06054036f, 0.10862309f, -0.00917187f, 0.11574249f, 0.04720996f, -0.01859210f, 
    -0.08273443f, 0.06362827f, -0.05193312f, -0.01501313f, -0.02640833f, 0.04533848f, -0.18832964f, -0.07749941f, 
    0.08372754f, 0.00709576f, -0.40453345f, 0.28438765f, -0.24742225f, 0.05834289f, 0.12476314f, 0.02880852f, 
    -0.06406529f, 0.03659599f, -0.07695512f, 0.06189767f, -0.28421915f, -0.06743219f, -0.03134764f, 0.08345542f, 
    -0.43961358f, 0.16988707f, -0.17360215f, 0.31317341f, -0.42561257f, -0.23470788f, -0.08484344f, 0.04305736f, 
    -0.31127620f, -0.31621987f, 0.05475330f, -0.06690035f, 0.01664017f, 0.25990584f, -0.08151556f, 0.10809705f, 
    -0.02393793f, 0.05663083f, 0.08481903f, 0.19796278f, 0.21893986f, 0.10683592f, 0.13562375f, 0.03866249f, 
    -0.23456548f, 0.02418975f, 0.06500081f, 0.28979135f, -0.18224616f, -0.12205662f, 0.13347585f, 0.08097636f, 
    -0.17357177f, -0.07583740f, -0.31439930f, 0.04349761f, 0.18974085f, 0.13419142f, -0.32360163f, -0.39730597f, 
    0.14586261f, -0.00832398f, -0.22278441f, 0.09087958f, 0.20423429f, 0.12015260f, 0.31021905f, -0.05374545f, 
    -0.21998057f, -0.13173248f, 0.07729380f, 0.10854530f, 0.27212757f, 0.16600268f, -0.46253043f, 0.00386011f, 
    0.09564719f, 0.20708284f, 0.21676290f, 0.09015138f, 0.07317473f, -0.24983178f, 0.27699584f, 0.05574081f, 
    0.05349396f, 0.19893184f, -0.20497909f, 0.15154956f, 0.27805984f, -0.02102929f, -0.12627906f, 0.32553077f, 
    0.11838092f, -0.14811985f, 0.33893079f, 0.10646465f, -0.43506446f, -0.33915859f, -0.05692491f, -0.16607472f, 
    -0.09619099f, 0.13132481f, 0.31209299f, 0.05405146f, -0.35774779f, 0.10714249f, 0.01378415f, 0.06365613f, 
    0.05792199f, 0.08058435f, -0.04183404f, 0.11708459f, 0.16214155f, -0.03267186f, -0.20045492f, 0.19272922f, 
    -0.04289229f, 0.14753141f, -0.01273327f, 0.16560186f, 0.26607227f, 0.28505793f, -0.02738053f, 0.04367661f, 
    -0.00932262f, 0.16043442f, 0.04335046f, -0.14519139f, 0.02117078f, 0.10761805f, 0.07905444f, -0.23871802f, 
    -0.05143230f, -0.01752858f, 0.22032544f, 0.21504529f, -0.05656994f, 0.02571724f, 0.21116789f, -0.02115691f, 
    0.05345002f, -0.21453978f, -0.04480949f, 0.11635061f, -0.03808955f, -0.02483778f, -0.06719107f, 0.22018893f, 
    0.03827678f, -0.24711120f, -0.19259724f, -0.06658900f, -0.15860856f, -0.03787696f, -0.05870808f, 0.15458213f, 
    -0.20910515f, 0.05409658f, -0.37539178f, 0.11121304f, -0.00448398f, 0.23475103f, 0.14814913f, 0.23476520f, 
    0.18462524f, 0.62440085f, 0.01683786f, -0.01157744f, -0.25657833f, 0.06565312f, 0.27997258f, -0.20315455f, 
    0.06738073f, 0.18059932f, -0.34190598f, -0.09938996f, -0.14838627f, 0.12844157f, 0.08057981f, 0.14246361f, 
    0.15346783f, -0.21283489f, -0.10155479f, -0.19499840f, 0.05150726f, 0.01089027f, 0.05684646f, -0.23667991f, 
    0.13096410f, 0.00832326f, 0.33676606f, 0.14624117f, -0.20154960f, 0.07348820f, 0.04366592f, -0.04357470f, 
    0.08584857f, -0.50297791f, 0.06494705f, -0.15188827f, 0.00514457f, 0.01184863f, 0.14481345f, -0.06642298f, 
    0.29819396f, -0.12344168f, 0.15662207f, 0.21218920f, 0.00031508f, -0.03458585f, 0.03881821f, -0.07936364f, 
    -0.31367978f, 0.51899236f, -0.47770223f, -0.16250230f, 0.02633606f, -0.04594720f, -0.20484804f, 0.27104399f, 
    0.08733776f, -0.20111807f, 0.13363869f, -0.06777298f, 0.08063652f, 0.07848755f, 0.17989904f, -0.06396588f, 
    0.02735721f, -0.00142014f, -0.00985426f, 0.09227980f, -0.19296657f, 0.05295586f, -0.44340038f, 0.32992887f, 
    0.04050264f, 0.18091536f, 0.18750574f, -0.17538151f, -0.07543400f, 0.03927333f, 0.10474515f, 0.19537105f, 
    -0.24102722f, 0.09744319f, 0.15220849f, -0.09707679f, -0.25650734f, -0.30276132f, -0.13739598f, 0.01828379f, 
    0.24389622f, -0.08514762f, 0.00781091f, -0.09578497f, 0.20387460f, -0.04292362f, -0.31367683f, 0.23655038f, 
    0.02809232f, -0.00861807f, -0.01847839f, 0.13802066f, -0.07202945f, -0.10669728f, -0.11872635f, 0.17883730f, 
    -0.06357536f, -0.02900144f, -0.00332106f, -0.11560561f, 0.23382987f, 0.10542474f, 0.06900050f, -0.28837442f, 
    -0.25384456f, 0.20920551f, -0.05783628f, 0.16153876f, 0.24505422f, 0.16405782f, 0.26103404f, 0.04542379f, 
    -0.18271656f, -0.30285186f, 0.11435350f, -0.19604799f, 0.16873764f, 0.21568580f, 0.07204762f, -0.20200588f, 
    -0.04044066f, -0.32845932f, 0.22053251f, 0.07896580f, -0.07262184f, -0.44431463f, -0.06089491f, 0.18616992f, 
    -0.46508911f, -0.09009720f, 0.03095769f, 0.06349678f, 0.16896883f, 0.10952286f, -0.11652512f, 0.16023694f, 
    -0.03902366f, 0.12705044f, -0.04881601f, 0.04291270f, 0.29283053f, 0.19931430f, -0.34609661f, 0.00203648f, 
    0.02428293f, 0.06142495f, -0.23489915f, 0.11162075f, 0.45952106f, 0.09454537f, 0.00985976f, -0.05596786f, 
    -0.09050894f, 0.57391292f, 0.05466766f, 0.20371802f, 0.18018675f, 0.01121038f, -0.26358348f, 0.09023894f, 
    0.02945568f, 0.03939243f, -0.10934077f, -0.05493323f, 0.07353044f, -0.06763882f, 0.33507946f, 0.17955467f, 
    0.09173257f, -0.21522933f, 0.19063762f, -0.01846376f, 0.31949037f, 0.06369180f, -0.24773191f, -0.00298569f, 
    0.17036359f, -0.02381643f, 0.21602525f, 0.04922226f, 0.10409915f, 0.06675009f, -0.25989550f, 0.13141805f, 
    -0.09478829f, 0.01461837f, 0.44201496f, 0.30534250f, -0.04206138f, 0.31101480f, -0.03773878f, 0.00038686f, 
    0.06955955f, -0.07753824f, 0.03548335f, 0.16963379f, -0.05823100f, 0.15139900f, -0.02397241f, -0.27675813f, 
    0.22908534f, -0.05574917f, 0.11433457f, 0.20167546f, 0.13292272f, -0.07566281f, -0.11503209f, 0.02908131f, 
    -0.07921137f, 0.15104710f, 0.03765058f, 0.21258582f, 0.06580658f, 0.01914080f, -0.04012962f, 0.04001162f, 
    -0.03397480f, 0.08648258f, 0.33610764f, -0.10144660f, -0.04374501f, 0.04522501f, -0.00213259f, 0.28585339f, 
    -0.09142135f, 0.02639479f, 0.00341087f, 0.10468799f, 0.18802406f, 0.03367537f, 0.05924530f, -0.06098908f, 
    0.04242852f, -0.30741680f, 0.01163876f, -0.21881016f, 0.27302989f, 0.41448340f, 0.03530660f, -0.31243426f, 
    0.05493074f, 0.09607174f, 0.25751537f, 0.27908313f, 0.06187775f, 0.13573404f, 0.13495533f, 0.08394400f, 
    0.38579077f, -0.02905960f, 0.09048952f, -0.00175592f, -0.02254145f, -0.05462884f, -0.03558690f, 0.01675975f, 
    0.14777055f, 0.05599960f, -0.03054182f, -0.26912743f, 0.04650873f, 0.00620365f, 0.02739038f, -0.05715939f, 
    0.02054005f, 0.29443944f, 0.02386229f, 0.07990536f, -0.07243641f, -0.05527215f, 0.05618263f, 0.23505858f, 
    -0.15798400f, 0.12867831f, -0.11147698f, 0.10546294f, 0.04113935f, 0.13993758f, -0.11188748f, 0.03817198f, 
    -0.01002665f, 0.18055429f, 0.15146250f, -0.05624048f, -0.17637220f, -0.05422886f, 0.01219228f, -0.01733912f, 
    0.04821108f, -0.00268717f, -0.01834978f, -0.08891972f, 0.10548281f, -0.03255742f, -0.07773762f, 0.05735983f, 
    0.00479419f, -0.07706011f, 0.19311184f, 0.00194086f, -0.10406506f, 0.05992512f, 0.07240234f, -0.22346297f, 
    0.00638776f, 0.03650071f, -0.06951816f, -0.09397637f, 0.23209803f, -0.09689964f, 0.16990444f, 0.17531201f, 
    -0.00043415f, 0.03090910f, -0.05548939f, -0.03564226f, -0.01192012f, -0.21106502f, 0.00479470f, 0.03632343f, 
    -0.00763075f, -0.25420520f, -0.07515138f, -0.12756692f, 0.06257743f, -0.15930787f, 0.02601483f, 0.02971791f, 
    0.09173353f, 0.11151890f, -0.11774676f, -0.11876905f, -0.26287225f, -0.00077836f, 0.04407539f, 0.00662854f, 
    0.19667558f, -0.09020433f, -0.04421419f, -0.09850574f, 0.16841371f, 0.05317038f, -0.09803243f, 0.37321678f, 
    0.00977409f, 0.04360380f, -0.18718427f, 0.04398635f, 0.05197343f, 0.02716999f, 0.15129149f, -0.06938209f, 
    0.09593365f, 0.02149620f, 0.00870936f, -0.07901440f, -0.13925369f, 0.07846806f, 0.17368662f, 0.06066803f, 
    -0.09954637f, 0.12107623f, -0.13519548f, 0.45640373f, 0.23453055f, -0.17169628f, -0.06795060f, 0.19008043f, 
    0.12190067f, -0.24814422f, -0.00371604f, -0.07909268f, -0.02851748f, -0.17555563f, -0.17172027f, -0.03621492f, 
    -0.15679136f, -0.35762867f, -0.03930013f, 0.05764488f, -0.08106973f, 0.02415339f, 0.15465577f, 0.20311601f, 
    -0.24750571f, 0.03986671f, 0.19143344f, 0.43711942f, 0.00688565f, 0.01306290f, -0.08647483f, 0.23682578f, 
    -0.00319207f, -0.06855444f, -0.08720407f, 0.08454073f, 0.11189067f, 0.18776447f, -0.09641618f, -0.12776662f, 
    0.06264199f, 0.08932896f, -0.31244120f, -0.00239226f, 0.26559860f, 0.10026592f, 0.20264488f, 0.03225310f, 
    0.06025953f, -0.03786501f, -0.01056321f, 0.21095505f, 0.17008147f, -0.05210477f, -0.24703991f, -0.02139152f, 
    -0.04019023f, 0.36351347f, 0.00975703f, 0.00378346f, 0.02922675f, 0.03874988f, 0.21367943f, 0.23218571f, 
    0.06040459f, -0.06752737f, 0.11454767f, 0.11835165f, 0.33524764f, 0.04335419f, 0.01647092f, 0.22566730f, 
    -0.03462685f, 0.06783419f, 0.20609166f, 0.13519363f, -0.23494831f, -0.12148064f, -0.21480663f, -0.11083201f, 
    0.19197673f, 0.22465618f, 0.11349265f, 0.17120571f, -0.07075612f, 0.22404222f, 0.01396184f, -0.13967448f, 
    0.05555377f, 0.06652198f, 0.02336574f, 0.20906821f, 0.05519027f, 0.00557616f, 0.05814848f, -0.00074174f, 
    -0.30425370f, -0.06723451f, 0.08156139f, -0.05529523f, -0.14403620f, -0.06739735f, 0.03506378f, -0.06669611f, 
    0.01798774f, 0.02139016f, 0.03960859f, -0.00916165f, -0.02133466f, 0.17718427f, 0.07274088f, -0.29162019f, 
    -0.07447396f, 0.01635345f, 0.22786650f, 0.16535714f, 0.01288452f, 0.26186237f, 0.02174410f, 0.09498664f, 
    -0.04682605f, 0.20490462f, 0.31467268f, 0.14232485f, -0.00581824f, 0.17072566f, -0.26080114f, 0.24110554f, 
    0.01168471f, 0.65431482f, 0.21767250f, -0.11662290f, -0.40295756f, -0.40415630f, -0.06802429f, -0.46083164f, 
    -0.14562479f, 0.15479086f, 0.16230628f, -0.26222464f, -0.05800167f, -0.37196130f, -0.33183619f, -0.08472949f, 
    -0.17540924f, 0.34024817f, -0.21680921f, 0.24778588f, 0.29958427f, -0.15040833f, -0.41256645f, -0.12406400f, 
    0.11696283f, -0.11769019f, -0.03347041f, 0.01644004f, -0.04087033f, -0.72938526f, 0.10113076f, -0.10699215f, 
    -0.10601692f, -0.03574853f, 0.28456664f, 0.07426474f, -0.03181685f, 0.25088429f, 0.16301818f, -0.35011381f, 
    0.17754386f, -0.23136671f, -0.14190589f, -0.27423453f, 0.47558042f, 0.01390484f, -0.08395503f, 0.02640077f, 
    0.11468340f, 0.07082243f, 0.13626994f, 0.12286806f, 0.04364453f, -0.00399231f, 0.23955771f, -0.00903593f, 
    -0.18960051f, 0.10472261f, 0.02839201f, 0.20138881f, 0.01891549f, -0.00029226f, 0.12721895f, 0.05875644f, 
    0.06766937f, 0.31633699f, 0.14926738f, 0.17931610f, -0.09347329f, 0.06723162f, 0.05451378f, 0.22589955f, 
    -0.02589149f, 0.15766691f, 0.03608407f, 0.03382213f, 0.03677451f, 0.02824899f, 0.20659970f, -0.05860502f, 
    0.00954311f, 0.03106513f, -0.10931467f, -0.19060022f, -0.04200795f, -0.00383898f, 0.35945746f, -0.22147138f, 
    -0.04264572f, 0.19677185f, 0.16297333f, 0.11223928f, 0.18427545f, -0.02647196f, 0.05925851f, -0.04160561f, 
    -0.05568672f, 0.13864809f, 0.13443516f, 0.02370253f, -0.12924217f, 0.17354886f, 0.05086201f, -0.04604273f, 
    0.15615582f, -0.13869081f, -0.02302208f, -0.12430385f, 0.04566290f, 0.15909934f, -0.04421686f, 0.09174202f, 
    -0.00230677f, 0.07281847f, -0.33178592f, 0.13582480f, -0.13340455f, 0.14563397f, 0.24239081f, 0.09344527f, 
    -0.01497201f, 0.09272971f, 0.23434447f, 0.05358048f, -0.38178626f, -0.10260781f, -0.21089701f, 0.02854398f, 
    -0.26432925f, 0.34710535f, -0.22269167f, 0.56046468f, -0.25053209f, -0.12842442f, -0.27776819f, -0.01110793f, 
    -0.11453117f, -0.33125341f, 0.05460656f, -0.05906567f, 0.07719332f, -0.17069778f, -0.43452874f, 0.08465908f, 
    -0.11883549f, -0.20249927f, -0.18212990f, 0.09932876f, 0.02195255f, 0.06763801f, 0.12255470f, 0.16834310f, 
    -0.17997926f, 0.08284683f, 0.00732518f, 0.27438620f, 0.12413873f, -0.17775092f, -0.02383781f, 0.16595496f, 
    -0.00701533f, -0.28535840f, -0.18830827f, 0.07688615f, 0.27918655f, 0.14582384f, -0.39389807f, -0.51824123f, 
    0.20061013f, 0.04706687f, -0.23606198f, 0.07314639f, 0.08733502f, 0.07700764f, 0.02019335f, -0.06277888f, 
    -0.08042460f, 0.12379068f, 0.05995340f, 0.00686467f, 0.17272353f, -0.00500566f, -0.22022626f, -0.00150304f, 
    -0.09219254f, 0.15834574f, 0.15319371f, 0.10631908f, 0.01913227f, -0.08777498f, 0.44665980f, -0.00347104f, 
    -0.00873593f, 0.07147699f, 0.09362599f, 0.02334352f, 0.35286200f, -0.04724083f, -0.22777374f, 0.40546808f, 
    0.04520107f, -0.05501666f, 0.11360331f, 0.00462828f, -0.36792463f, -0.07965717f, -0.18623562f, -0.21547653f, 
    0.06991420f, 0.07880245f, 0.03033425f, 0.13881779f, -0.26397526f, 0.22070272f, 0.15138946f, -0.05888413f, 
    0.09723870f, 0.09186508f, 0.03215452f, 0.15894584f, -0.01625985f, 0.04444017f, 0.05008564f, -0.13971095f, 
    0.18792668f, -0.10889500f, -0.42224833f, -0.36795709f, 0.06568118f, -0.11873698f, 0.03121218f, -0.05487199f, 
    0.23920894f, -0.04759590f, -0.07425506f, 0.12749466f, -0.20175608f, -0.15181178f, -0.03758139f, 0.16530816f, 
    -0.03256686f, 0.05938525f, -0.00881983f, -0.15447898f, -0.91609997f, 0.05491030f, -0.17039743f, 0.15035041f, 
    0.15837653f, -0.07757287f, 0.18818766f, -0.08384710f, 0.41505906f, 0.27621463f, 0.02127774f, 0.21319766f, 
    0.02579865f, 0.09280461f, 0.16234283f, -0.27951637f, 0.71073335f, 0.28331938f, 0.13566141f, -0.17263310f, 
    -0.06080603f, 0.05742629f, 0.30513874f, 0.11730362f, -0.32461470f, -0.04968680f, 0.23747556f, 0.01150463f, 
    0.07231458f, -0.20416237f, -0.08595649f, -0.55210584f, 0.06748527f, -0.11358473f, 0.08028602f, -0.34206086f, 
    0.08944824f, -0.11035227f, -0.22730045f, -0.12130174f, 0.05262661f, 0.08754086f, -0.02671613f, -0.25212067f, 
    -0.30902317f, 0.45295522f, 0.01805820f, 0.03959591f, -0.12304678f, 0.11270060f, 0.20385635f, 0.66579980f, 
    -0.24706322f, 0.04923350f, 0.03121606f, -0.08704462f, -0.01970292f, 0.14042547f, -0.25254315f, -0.08214872f, 
    0.05252096f, -0.13190514f, -0.01306175f, 0.04507003f, -0.16674523f, 0.24489452f, 0.01944724f, -0.08072662f, 
    -0.04375639f, 0.09772918f, -0.16709760f, -0.10446713f, 0.02062886f, 0.13659520f, 0.31463993f, 0.08402116f, 
    0.22181703f, -0.13195854f, 0.15548581f, -0.13656309f, -0.16156782f, -0.03893410f, 0.18855442f, -0.21364494f, 
    -0.01342313f, 0.04220194f, -0.13728921f, 0.00760835f, 0.41976717f, 0.09084170f, 0.32689053f, 0.45483300f, 
    0.16586114f, -0.12412713f, -0.01359851f, -0.01419763f, 0.14240055f, 0.00199640f, 0.04442031f, -0.08612133f, 
    0.00803227f, 0.07791883f, 0.07949939f, -0.03239509f, 0.23484418f, -0.26548108f, 0.21694075f, -0.23180647f, 
    0.04879176f, -0.17854065f, -0.05643062f, 0.04299630f, -0.22459982f, -0.02035892f, -0.14116029f, -0.15779723f, 
    0.15358622f, 0.22383372f, 0.06881197f, -0.18047118f, 0.06080167f, 0.11436265f, -0.00623439f, -0.44140533f, 
    0.03268552f, 0.02225895f, -0.06230053f, 0.06421671f, -0.29057059f, 0.32000801f, 0.18451047f, 0.19784525f, 
    -0.26411310f, 0.10221549f, 0.34795207f, 0.21036188f, 0.26635948f, 0.21080731f, -0.22774637f, 0.03546682f, 
    -0.06183976f, 0.15753843f, -0.03225164f, -0.05116350f, -0.44607580f, -0.36088353f, 0.09984568f, -0.59043425f, 
    -0.18160383f, 0.15065658f, -0.11181753f, -0.21149549f, -0.05371561f, -0.10392867f, -0.11253437f, -0.49512276f, 
    0.00692781f, 0.21256827f, -0.07100737f, 0.19796851f, 0.36178741f, 0.15333048f, -0.45144317f, -0.29561511f, 
    0.36149222f, -0.13813515f, 0.24416724f, -0.31884992f, 0.04394423f, -0.17129917f, 0.21671276f, -0.01276737f, 
    0.22586760f, -0.00712182f, -0.00088099f, 0.02656891f, 0.11523850f, 0.08736647f, 0.02458988f, -0.12606369f, 
    0.36429605f, -0.29488036f, 0.01360597f, -0.16143641f, 0.16867481f, 0.11651889f, -0.08866829f, 0.06542563f, 
    0.30387843f, 0.12625599f, 0.11908358f, -0.00491536f, -0.00433535f, -0.29460579f, -0.03499784f, -0.08998320f, 
    -0.24409884f, 0.11136383f, -0.05317495f, 0.18682446f, 0.06477221f, 0.12845914f, -0.00614705f, 0.12326336f, 
    -0.28712738f, 0.13552143f, 0.43096483f, -0.22247127f, 0.21675083f, -0.00807926f, -0.12524441f, 0.26162302f, 
    0.02665837f, 0.07172000f, -0.04919407f, 0.13283612f, 0.25138989f, 0.05632542f, 0.07532229f, 0.25872871f, 
    -0.23609281f, 0.01288181f, -0.13146208f, 0.00748418f, -0.20706064f, -0.04087023f, 0.44975758f, 0.43621087f, 
    0.04657999f, 0.22106993f, 0.27116814f, 0.03298269f, -0.18697722f, -0.19586727f, 0.21407613f, -0.33246961f, 
    -0.08776776f, -0.06995379f, 0.00640245f, -0.06098130f, -0.03567382f, 0.04653120f, -0.07241705f, -0.08254348f, 
    0.07143052f, -0.06580097f, -0.01012714f, 0.01734503f, 0.02322759f, -0.05265238f, -0.08219906f, -0.05570909f, 
    0.00922860f, 0.03572267f, -0.08301596f, -0.09292858f, -0.06281865f, -0.02212211f, -0.04251168f, -0.05318110f, 
    -0.06728479f, -0.10266231f, -0.03810548f, -0.04387450f, 0.05491184f, -0.04658634f, -0.03285183f, -0.06466383f, 
    -0.00501825f, 0.04877466f, 0.01685100f, -0.02144869f, 0.02412357f, 0.04362743f, -0.06146013f, 0.05196255f, 
    -0.07147948f, -0.05054818f, -0.02432796f, -0.04304713f, 0.08501312f, 0.07326014f, -0.06137250f, -0.08316633f, 
    0.03217812f, 0.01912198f, -0.07858752f, 0.01834110f, -0.03528893f, -0.06528439f, 0.04784551f, 0.04249404f, 
    -0.03117479f, -0.06090306f, 0.06855087f, -0.01606935f, -0.07338706f, -0.04150299f, 0.01356066f, -0.06145752f, 
    -0.00820382f, 0.01844739f, 0.05818190f, 0.01401652f, -0.00488893f, 0.03442262f, 0.04310760f, -0.07451167f, 
    0.01532602f, -0.02226616f, 0.06488294f, 0.04681007f, 0.01762244f, -0.00756786f, 0.01924808f, 0.03701848f, 
    0.00554328f, -0.03481993f, 0.03151342f, -0.02256083f, 0.02909117f, 0.01223009f, -0.02337613f, -0.06582803f, 
    -0.06250770f, -0.02922181f, -0.06213327f, -0.07630811f, 0.01258111f, 0.06867655f, -0.05413345f, -0.05606252f, 
    -0.00132919f, -0.04634878f, -0.09570131f, -0.06265557f, 0.00674357f, -0.01379498f, -0.09510519f, -0.08813421f, 
    -0.05444219f, -0.09738078f, -0.09224728f, -0.00121946f, -0.01717970f, 0.06609367f, -0.03411571f, 0.05053814f, 
    -0.04034275f, 0.01153622f, 0.01512328f, -0.04715520f, -0.03897667f, 0.00712834f, 0.01380950f, -0.04486107f, 
    -0.02274238f, -0.04875800f, -0.03562880f, 0.04561468f, -0.01413901f, 0.00003163f, -0.04478842f, 0.06848531f, 
    -0.05604293f, -0.06795216f, 0.01966081f, -0.02428569f, -0.08646911f, 0.01211755f, -0.06089282f, -0.05299252f, 
    0.00980560f, -0.02147366f, 0.08145487f, -0.02376270f, -0.05557348f, -0.02404103f, -0.09556336f, 0.03754333f, 
    0.03669479f, 0.04582265f, -0.00219665f, -0.10429773f, -0.07421916f, -0.06933883f, 0.05462719f, -0.00018658f, 
    -0.10314555f, 0.01835701f, -0.02273987f, -0.10885605f, -0.08212259f, -0.02677176f, -0.07168827f, 0.06727275f, 
    -0.10074937f, 0.06368535f, 0.05390851f, -0.08251804f, -0.03323811f, -0.04015040f, 0.01647291f, 0.05365694f, 
    -0.04315920f, 0.00545215f, 0.05457464f, 0.03844513f, -0.04184160f, -0.01090624f, -0.02136658f, 0.06154777f, 
    0.05320893f, 0.01828126f, 0.04456474f, -0.04449751f, -0.11242100f, 0.06937610f, -0.01249039f, -0.04694772f, 
    0.02307259f, -0.03106216f, 0.02262077f, 0.06389876f, -0.03745495f, 0.03371311f, 0.07527256f, -0.04371654f, 
    0.02941397f, 0.03670429f, -0.04231209f, 0.03988921f, -0.07922581f, 0.06039020f, -0.01297791f, 0.01941440f, 
    0.05889883f, 0.03744872f, -0.04582512f, 0.05911621f, 0.01711299f, -0.01280070f, -0.06522920f, 0.06321499f, 
    0.01542369f, 0.06298751f, -0.05279129f, -0.00001989f, -0.11110934f, -0.08718808f, 0.02617475f, -0.03641200f, 
    -0.02878331f, 0.04643644f, 0.02707310f, -0.04804604f, -0.09598967f, 0.05787608f, 0.00027989f, -0.08324479f, 
    -0.00023680f, 0.06311190f, -0.00173975f, -0.01303430f, -0.00575833f, -0.08270866f, -0.04581883f, 0.01100424f, 
    0.01878040f, -0.07624248f, -0.03249280f, 0.01303612f, -0.02904247f, -0.03078262f, 0.05031510f, 0.01679361f, 
    0.05274469f, -0.03064824f, -0.03445071f, -0.06415762f, 0.02652963f, -0.09003362f, -0.05457503f, -0.04302360f, 
    -0.05320897f, 0.02084452f, -0.02184605f, -0.09171189f, -0.01536659f, 0.05106403f, -0.03349941f, 0.01448501f, 
    0.31995755f, -0.24529608f, -0.23732258f, -0.18401994f, 0.13278748f, 0.05467239f, 0.14150560f, 0.18102440f, 
    0.10112107f, -0.19921678f, 0.06925056f, 0.24733241f, -0.31443748f, -0.23223281f, -0.23844060f, 0.45612741f, 
    -0.00263847f, 0.00066430f, 0.42175055f, -0.12225424f, -0.00634462f, -0.55353904f, -0.20301454f, -0.19087026f, 
    0.22924677f, -0.31559184f, -0.29582125f, 0.03098008f, 0.17715217f, 0.16979061f, 0.01663918f, 0.33428946f, 
    0.02503726f, 0.31354293f, -0.25774753f, -0.01165690f, 0.59541923f, -0.24370047f, 0.05860406f, 0.24422443f, 
    0.17632222f, -0.14949796f, 0.21625230f, 0.02664050f, -0.34499359f, -0.06655118f, -0.14395553f, 0.22611304f, 
    -0.03935585f, -0.29029810f, -0.23673707f, 0.02343506f, -0.27961653f, 0.06329711f, 0.41114184f, -0.17884156f, 
    -0.05661693f, 0.10008989f, 0.24191535f, 0.01800308f, -0.05347291f, -0.04509575f, 0.01794722f, 0.00255646f, 
    -0.54256856f, 0.05037018f, 0.08383682f, -0.07120242f, 0.04201783f, 0.09704064f, -0.08539490f, 0.11774141f, 
    -0.22566190f, 0.10977381f, -0.12665042f, 0.17181398f, 0.04980654f, 0.03815237f, -0.22575173f, -0.02021037f, 
    0.28629088f, -0.11419466f, -0.13663429f, -0.04096675f, -0.02627866f, 0.10792816f, 0.06360300f, 0.03513740f, 
    0.05620580f, -0.06665653f, 0.08683956f, -0.01569889f, 0.02491433f, 0.19352375f, -0.15102607f, 0.03901668f, 
    0.14450924f, -0.02105748f, 0.15686503f, -0.02624079f, -0.03396737f, -0.07477660f, -0.09300339f, -0.10984170f, 
    -0.13081881f, -0.24926892f, -0.10072052f, 0.17536622f, 0.20757197f, -0.14762215f, 0.02753870f, 0.13907152f, 
    0.16684011f, -0.10207705f, -0.14621319f, -0.31960276f, 0.02943929f, 0.26282787f, -0.12388682f, -0.21129757f, 
    -0.00134683f, 0.13185814f, 0.27040231f, -0.12725657f, -0.02593005f, 0.19957201f, 0.23731171f, 0.03004750f, 
    -0.02274345f, 0.34471339f, -0.19500786f, 0.04086111f, 0.15478705f, 0.02300029f, 0.19419575f, 0.11705357f, 
    -0.06399868f, -0.18103382f, 0.03679390f, 0.24542069f, -0.21230623f, -0.02826924f, -0.01943367f, 0.23210351f, 
    0.04291469f, -0.04993929f, 0.37637791f, 0.11311314f, -0.15811513f, -0.29345495f, -0.03580887f, -0.11821523f, 
    0.19744183f, -0.15588886f, -0.12108020f, -0.06120607f, -0.15715209f, -0.05441684f, -0.08719317f, 0.14732069f, 
    -0.02865881f, 0.04792579f, 0.05842528f, -0.03433407f, 0.08411929f, -0.25269961f, -0.19641943f, 0.11292169f, 
    0.05535034f, -0.03459104f, -0.01018732f, 0.13615739f, -0.14294715f, 0.13409685f, -0.11889433f, 0.34573364f, 
    0.07081345f, 0.36479402f, -0.10599161f, 0.22477277f, -0.02074218f, 0.28941071f, 0.25807092f, -0.11446164f, 
    0.25309476f, 0.21683037f, 0.11413804f, 0.22237819f, 0.00573308f, -0.05210817f, 0.21333940f, -0.06446381f, 
    -0.27864546f, -0.01372492f, 0.09637988f, 0.05886111f, -0.04130543f, -0.19191475f, -0.02080351f, -0.03416472f, 
    0.00316058f, 0.13413729f, 0.01510172f, 0.01496367f, -0.28280875f, 0.06252703f, -0.26753280f, -0.05696802f, 
    0.04856450f, -0.09656530f, -0.04211225f, -0.06356878f, 0.12912190f, 0.20429800f, -0.00917473f, -0.10194571f, 
    -0.08653861f, 0.01327594f, 0.16722016f, -0.14910458f, -0.07402869f, 0.09661224f, -0.17410904f, -0.09596634f, 
    0.09811769f, 0.18423188f, -0.10125013f, 0.39417651f, 0.08326180f, 0.08589298f, -0.03159491f, 0.02559623f, 
    -0.12426893f, -0.00791905f, 0.01603721f, 0.06068413f, -0.00402103f, -0.08919454f, -0.24780099f, 0.10927050f, 
    0.23160800f, -0.10571332f, -0.14051865f, -0.45198601f, -0.10225974f, 0.21027085f, -0.00191479f, -0.15018283f, 
    -0.03316552f, 0.18886471f, 0.10093411f, 0.05607850f, 0.14515655f, 0.05279411f, 0.20126839f, 0.20610513f, 
    0.05871821f, 0.04144773f, 0.01333007f, -0.02485149f, -0.29498795f, -0.09787727f, 0.19130415f, -0.10540510f, 
    -0.09938901f, -0.01718180f, -0.03716753f, 0.03110914f, 0.03878538f, 0.04676193f, -0.10006613f, -0.00277935f, 
    0.04983020f, -0.07652056f, -0.38046306f, 0.00841600f, 0.15936933f, 0.07670829f, -0.01622915f, 0.10084083f, 
    0.22060922f, 0.11288427f, -0.04153425f, -0.01733679f, -0.02942040f, -0.02699947f, 0.05600843f, -0.14707790f, 
    -0.08138044f, 0.17532809f, -0.00554907f, 0.03499605f, -0.13876258f, -0.03823655f, -0.00624254f, -0.11013198f, 
    0.15079768f, -0.24720351f, 0.13121650f, -0.11061645f, -0.09611706f, -0.39973181f, 0.07736170f, -0.11565343f, 
    -0.07779931f, -0.25089547f, -0.01087767f, 0.17319629f, 0.29114473f, 0.14294711f, -0.19545928f, -0.11161906f, 
    -0.08550830f, -0.13129194f, 0.34341025f, 0.25314328f, -0.06319534f, -0.06137786f, 0.01710536f, -0.08159006f, 
    -0.15750453f, 0.10626354f, -0.07654908f, 0.18938947f, 0.18893600f, 0.05278863f, -0.06584653f, 0.02255860f, 
    0.13446045f, 0.00880978f, -0.22968598f, -0.14295314f, 0.17662416f, 0.12719135f, 0.19840971f, -0.09597209f, 
    -0.01182301f, 0.55312461f, 0.04382580f, 0.10054764f, 0.20072305f, 0.26713967f, -0.01193592f, 0.01050157f, 
    -0.28840795f, 0.07767283f, -0.06267492f, -0.09954301f, 0.05396538f, -0.07761414f, 0.19939622f, 0.05335043f, 
    0.14142892f, -0.38576633f, 0.21769458f, 0.11583873f, 0.18244804f, 0.02993179f, -0.01930874f, -0.11348469f, 
    0.10046864f, -0.09220904f, 0.08360857f, -0.00047025f, -0.10159719f, -0.09506050f, 0.22720410f, 0.20033813f, 
    0.05115250f, -0.02890469f, 0.17532074f, -0.10147658f, -0.07650449f, -0.03302456f, 0.24419443f, -0.05623099f, 
    -0.00123403f, 0.06289487f, -0.00654150f, 0.06274424f, 0.04732264f, -0.06910688f, -0.00896434f, -0.07918081f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.05604853f, -0.02254114f, 0.00799884f, 0.04832439f, 0.08909507f, -0.05853529f, -0.15416062f, 0.12720762f, 
    0.00975981f, 0.20039433f, 0.07547137f, 0.00055808f, 0.24959880f, -0.01965377f, -0.02744276f, -0.02635014f, 
    0.00984268f, -0.04744226f, 0.03619149f, 0.02348890f, -0.11340945f, 0.20770548f, -0.07949315f, -0.03145978f, 
    -0.03857985f, 0.12768106f, 0.04527233f, 0.27959597f, 0.13241163f, 0.06906059f, -0.06372471f, 0.01074906f, 
    0.15739918f, 0.10585196f, 0.22539078f, 0.27130944f, 0.03332118f, 0.03151118f, 0.04205224f, -0.05960095f, 
    0.04547155f, -0.09937905f, 0.30185303f, 0.07852367f, -0.07350213f, -0.03938120f, 0.11900070f, 0.17296928f, 
    -0.09374741f, -0.06634755f, 0.05464961f, -0.06564160f, 0.09317078f, -0.07916322f, -0.19634715f, -0.09537134f, 
    0.00759803f, -0.06815608f, -0.00958882f, 0.02990793f, -0.14337912f, -0.04410923f, 0.12581517f, 0.02579594f, 
    -0.08235706f, 0.13927588f, -0.08956357f, -0.11891004f, -0.09139359f, 0.17560406f, 0.05948595f, 0.06254657f, 
    -0.09336367f, 0.06135468f, 0.18238254f, 0.13947499f, -0.05363583f, 0.13294898f, 0.10967176f, 0.18532248f, 
    0.04467668f, -0.12229893f, 0.02874476f, 0.11475483f, -0.05350924f, 0.06091430f, 0.06521227f, 0.04975627f, 
    -0.22179347f, 0.09302203f, -0.16415727f, -0.06466185f, 0.02676928f, -0.13861795f, 0.30475447f, -0.22811414f, 
    -0.21118844f, -0.07382422f, -0.06655821f, -0.07376910f, 0.10770694f, 0.26576245f, 0.17086667f, -0.10816672f, 
    0.21512060f, 0.02399200f, -0.08527362f, 0.14916170f, -0.04570493f, -0.05721787f, -0.05451351f, 0.03696620f, 
    -0.17601581f, 0.10250605f, 0.05754776f, 0.05467267f, 0.15520944f, 0.04131566f, 0.08554445f, 0.00999986f, 
    0.02204931f, 0.09169441f, -0.02991238f, -0.08538332f, 0.05099387f, 0.10917369f, 0.24898006f, 0.10299390f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.14711286f, 0.13949649f, -0.05019343f, -0.13523126f, -0.44078022f, -0.01317517f, -0.08659273f, -0.30531564f, 
    0.04091721f, 0.01565826f, -0.31028008f, -0.02768538f, 0.01632032f, -0.29507604f, 0.03869456f, -0.09306789f, 
    -0.04918386f, -0.01110952f, -0.03549673f, -0.08538859f, 0.08502775f, -0.09601914f, -0.19284336f, 0.12525347f, 
    -0.02472229f, -0.24158071f, -0.33888575f, 0.33709884f, -0.30244496f, -0.34466872f, 0.08464579f, -0.07489827f, 
    0.03374854f, -0.07244264f, 0.24547674f, 0.09853292f, -0.03336879f, -0.18799192f, 0.08561558f, 0.08703222f, 
    -0.00399383f, 0.03360647f, 0.14861700f, 0.01670405f, -0.32505149f, -0.01438047f, 0.05150780f, -0.63004899f, 
    0.11003508f, 0.03856550f, 0.17917386f, -0.24094117f, 0.07827320f, -0.07949705f, 0.23952468f, -0.06286190f, 
    -0.01655148f, -0.00684963f, 0.00442029f, -0.03747345f, -0.07139561f, 0.00657651f, -0.22101118f, -0.03851364f, 
    0.05265041f, 0.23302862f, -0.04362613f, -0.00205310f, 0.01461654f, -0.00031816f, 0.07686011f, 0.11278074f, 
    0.29161781f, -0.05062283f, 0.12565280f, -0.12888433f, -0.03246168f, -0.16598721f, -0.24761552f, 0.05759531f, 
    -0.44341582f, 0.19327316f, -0.00300639f, -0.25430250f, 0.02563329f, 0.09624139f, -0.54014844f, 0.06723373f, 
    -0.00801747f, 0.01804728f, -0.21080375f, -0.03609065f, -0.54558355f, 0.22439031f, -0.37143853f, 0.10801020f, 
    -0.19878413f, -0.02000455f, -0.03120328f, 0.03720180f, -0.30086198f, 0.01258027f, -0.06585673f, -0.01031798f, 
    0.52707839f, -0.07968418f, -0.06236603f, -0.24737582f, 0.02731492f, 0.03082631f, -0.03542978f, -0.06670558f, 
    0.31912178f, 0.06668828f, -0.12313687f, 0.16265148f, -0.06734025f, 0.05562547f, -0.41089571f, -0.73267835f, 
    -0.34612212f, -0.39363554f, 0.26384786f, -0.05634059f, 0.00207803f, -0.00210197f, 0.09591617f, -0.18613982f, 
    0.06677818f, 0.20387006f, -0.02645025f, 0.06878428f, -0.01496574f, -0.01894692f, -0.02272134f, 0.35231245f, 
    0.10042763f, 0.14868118f, -0.05114899f, -0.04342845f, 0.09249296f, -0.05180442f, 0.06294680f, -0.03058262f, 
    -0.07411074f, 0.01246645f, 0.04677605f, -0.03029140f, -0.06324344f, -0.05384496f, 0.03269592f, 0.02802400f, 
    -0.00568841f, 0.02059920f, 0.32295868f, 0.12180178f, 0.06929158f, 0.08433690f, -0.02965873f, 0.06834930f, 
    0.10656773f, -0.13042945f, 0.53477114f, 0.13963103f, 0.03843846f, 0.06878500f, -0.02409919f, -0.04804655f, 
    -0.11252330f, -0.16915376f, -0.19598600f, -0.04452268f, 0.16324207f, -0.10259668f, 0.15102811f, 0.22878695f, 
    -0.18584487f, -0.04233034f, 0.27824205f, -0.04610147f, -0.02775757f, -0.05596787f, -0.52983290f, -0.03898769f, 
    -0.08394451f, -0.08308665f, 0.04788585f, 0.07070778f, 0.08143020f, 0.07050156f, 0.16868186f, -0.00742628f, 
    -0.01452621f, 0.45834962f, -0.08091389f, -0.10681207f, -0.12281736f, 0.13568936f, 0.04319189f, 0.05298982f, 
    0.10147937f, -0.53113222f, 0.01285528f, 0.12517977f, 0.05160361f, -0.39969918f, -0.12427150f, 0.44051772f, 
    -0.04935129f, 0.19115989f, -0.05621500f, -0.28339040f, -0.06846331f, -0.03716620f, 0.03358746f, -0.00451338f, 
    -0.26817843f, -0.07954786f, -0.11002462f, 0.04983550f, -0.26354122f, -0.35953328f, -0.00462954f, -0.49451637f, 
    -0.07899848f, -0.02330316f, -0.06094173f, 0.03150116f, 0.02879936f, 0.02189511f, -0.06681643f, 0.05180390f, 
    -0.41136375f, -0.01338380f, 0.02750196f, 0.00577242f, -0.05066735f, -0.06056161f, -0.04121208f, 0.08995651f, 
    -0.44001272f, -0.00821294f, -0.25900352f, 0.03531805f, -0.28019840f, 0.09587160f, -0.21894288f, 0.08925939f, 
    -0.60592735f, 0.23903407f, 0.17307179f, -0.04491262f, -0.01624842f, 0.11034886f, 0.07821690f, 0.00818898f, 
    -0.07753941f, -0.86907077f, 0.07074602f, 0.14394511f, -0.02779798f, 0.00011498f, 0.28113282f, -0.46831757f, 
    -0.55997825f, 0.20032869f, 0.19033974f, 0.02722910f, 0.05249999f, -0.05490201f, 0.00997780f, 0.01833794f, 
    -0.07317492f, 0.05990710f, -0.19484034f, 0.05318275f, -0.19057886f, 0.26338744f, 0.05028335f, -0.01463133f, 
    -0.00425763f, -0.15306410f, -0.36663321f, 0.22587474f, 0.07886663f, -0.02574790f, -0.08314927f, -0.01763040f, 
    -0.16740952f, -0.29686430f, 0.28818807f, 0.27887219f, -0.06746902f, 0.03139911f, -0.27380043f, 0.14091648f, 
    0.10050283f, -0.79485720f, 0.07624976f, 0.02205226f, -0.48079804f, 0.06278940f, -0.24346805f, -0.19744870f, 
    0.08316535f, 0.02216619f, -0.55283725f, -0.29137039f, -0.24395785f, 0.00589972f, -0.27057171f, -0.06065135f, 
    0.14556798f, -0.21196206f, 0.04392984f, -0.00225696f, -0.06502289f, -0.04979282f, 0.19023010f, -0.06200001f, 
    -0.06563667f, -0.31441501f, -0.03892282f, -0.43204084f, -0.21857728f, 0.14524221f, 0.11883400f, -0.37010184f, 
    -0.38428590f, -0.21104692f, 0.01270599f, 0.23839535f, -0.01989394f, 0.20378113f, 0.33020166f, 0.07988895f, 
    0.29762065f, -0.11817829f, -0.03448673f, -0.05013690f, -0.07220869f, -0.03298286f, 0.18007213f, 0.05286963f, 
    -0.38081539f, 0.14532121f, -0.10012718f, -0.05275170f, 0.01700650f, -0.30347437f, 0.02454945f, -0.04018542f, 
    -0.35600212f, -0.02349087f, -0.06332489f, -0.02013739f, 0.12207595f, -0.06741145f, -0.17186096f, -0.06846759f, 
    0.14455940f, -0.10491779f, 0.04252555f, 0.09646741f, -0.05337470f, -0.04910829f, -0.03948674f, -0.07180127f, 
    -0.38219899f, 0.09274989f, -0.12293260f, -0.44952717f, 0.11180568f, 0.03900208f, -0.00624003f, -0.19386411f, 
    -0.16251926f, -0.21983941f, -0.29927531f, -0.05960238f, -0.01754387f, -0.48313344f, -0.51284367f, 0.17707944f, 
    -0.01667142f, 0.09232212f, -0.09084437f, -0.39950565f, -0.14375736f, -0.09195042f, -0.10586662f, -0.42184690f, 
    -0.54747063f, -0.37503737f, 0.07556874f, -0.08186208f, -0.15398228f, -0.23522605f, -0.00354224f, 0.03349475f, 
    -0.01796267f, -0.01042107f, -0.82426119f, -0.02968736f, 0.18939714f, 0.22448453f, -0.28191075f, 0.07733758f, 
    0.02182366f, -0.47442573f, -0.21266429f, -0.30728242f, -0.25580955f, -0.38529155f, -0.02584121f, -0.03764125f, 
    -0.08873129f, 0.22742359f, -0.11197756f, 0.05292245f, 0.07071918f, -0.18838026f, 0.17429718f, 0.07691809f, 
    0.17544501f, -0.11424091f, 0.21670151f, 0.04477349f, 0.19803965f, 0.01007151f, -0.02031066f, 0.39085934f, 
    -0.00766435f, -0.05773895f, 0.02858573f, -0.30507895f, 0.13359232f, 0.03460797f, 0.07129175f, 0.00766983f, 
    0.14580269f, 0.07539235f, -0.00319101f, 0.02751922f, -0.69415480f, 0.05352035f, -0.29821345f, 0.04016383f, 
    0.03853381f, -0.11524443f, -0.10330947f, -0.06022435f, 0.01595555f, 0.05905436f, 0.15139906f, 0.07439900f, 
    -0.10399378f, 0.13227542f, -0.01532106f, -0.02184760f, 0.05774577f, 0.13058172f, -0.11770726f, -0.37065831f, 
    0.09476227f, -0.13022803f, -0.05069869f, -0.03073409f, -0.04756127f, -0.04108999f, 0.05947822f, -0.01158517f, 
    0.05262545f, 0.33668190f, -0.18504070f, -0.07347794f, -0.08158666f, 0.08134574f, -0.04867758f, 0.20684221f, 
    0.15813929f, -0.03710577f, 0.05365147f, -0.05362785f, 0.10371238f, 0.02540202f, 0.00700890f, -0.08674075f, 
    -0.01346334f, -0.03644010f, -0.03352131f, -0.37826133f, -0.06358633f, 0.11407034f, 0.09671110f, -0.04940604f, 
    -0.09088665f, 0.19357915f, 0.05903792f, 0.11732025f, 0.02622909f, 0.01636722f, -0.14354461f, -0.10906965f, 
    0.01304734f, 0.10000165f, -0.44264239f, 0.04086365f, 0.01158097f, 0.11799742f, 0.07445110f, -0.20403029f, 
    0.14122654f, -0.05021987f, -0.08698231f, -0.27383807f, 0.05121975f, 0.01545552f, 0.10768354f, -0.37778196f, 
    0.20829590f, -0.24832650f, 0.04425104f, -0.01854278f, 0.11312613f, -0.04866883f, -0.02553417f, -0.05164915f, 
    -0.07815912f, -0.03592714f, -0.00738427f, 0.04845503f, -0.11092988f, -0.47405225f, -0.13047768f, 0.00020772f, 
    0.07154681f, 0.11853621f, -0.38174865f, -0.55676657f, 0.11381303f, 0.19299388f, -0.06463140f, 0.00275224f, 
    0.15795024f, -0.28509474f, -0.06288523f, -0.47042206f, -0.02183831f, -0.44328058f, -0.01563027f, -0.10897227f, 
    -0.06635860f, 0.18161651f, -0.54582065f, 0.12574734f, -0.24531831f, -0.05493777f, 0.07147384f, 0.07982428f, 
    -0.08808472f, -0.01894833f, -0.05682930f, 0.05574492f, -0.01170472f, 0.06342042f, 0.10391224f, -0.05677545f, 
    0.04072855f, 0.09197018f, 0.01275904f, -0.09517878f, 0.07635096f, 0.00786605f, -0.03608428f, 0.02641875f, 
    0.02895973f, -0.10590906f, -0.11491791f, 0.07305197f, 0.15521516f, 0.04548722f, 0.04305808f, -0.00855332f, 
    -0.05160527f, 0.14029722f, -0.45474923f, 0.10910266f, -0.05514695f, 0.11991848f, -0.13970251f, 0.08991133f, 
    -0.14511807f, 0.16220397f, -0.05986293f, 0.16440408f, 0.02590006f, -0.88233846f, -0.09365197f, -0.04467120f, 
    0.04273463f, -0.17171991f, 0.12652737f, -0.06434936f, 0.15073660f, 0.01345870f, -0.03474048f, -0.23014532f, 
    -0.05760972f, -0.02306662f, -0.08642485f, 0.00373926f, -0.19296549f, 0.02402775f, 0.28441465f, 0.06282720f, 
    -0.83268809f, 0.04477390f, 0.04912670f, 0.09260245f, 0.03433050f, -0.01919593f, 0.04035552f, -0.05114648f, 
    -0.01670985f, -0.02329499f, 0.06202384f, 0.07532057f, -0.54365993f, -0.04481658f, 0.02692269f, 0.15503362f, 
    0.16522640f, -0.45191479f, 0.53461140f, -0.04661054f, 0.05686662f, 0.02481436f, -0.00054536f, -0.12936638f, 
    0.10529413f, 0.01636751f, 0.06251211f, -0.18061128f, 0.18932474f, 0.04523880f, 0.04368961f, -0.16274343f, 
    -0.18178709f, -0.04989851f, 0.12852506f, -0.06037226f, -0.04456089f, 0.08439239f, -0.05853868f, 0.02843028f, 
    0.03367450f, 0.03334538f, 0.08349739f, -0.07332738f, 0.02467236f, -0.32050234f, 0.07468993f, -0.05039788f, 
    0.03037032f, 0.07723184f, 0.20110033f, -0.09571075f, 0.09539726f, 0.13769235f, -0.07258314f, 0.06454574f, 
    -0.08902002f, -0.34235981f, -0.63603830f, -0.02640961f, -0.07191919f, 0.24705783f, 0.06176046f, 0.00837118f, 
    0.12020056f, 0.03768230f, -0.39853525f, 0.09146276f, 0.19545014f, 0.02191130f, 0.03642318f, -0.56717432f, 
    -0.07010815f, -0.00361068f, 0.06810981f, -0.00973970f, -0.02855926f, -0.01610763f, -0.06362309f, 0.05152892f, 
    0.01617914f, 0.16764456f, 0.00513410f, -0.00054228f, 0.22808224f, 0.00174407f, 0.02541554f, -0.03940477f, 
    -0.02626782f, -0.29563132f, -0.00183680f, -0.02824283f, -0.02040783f, 0.17107734f, 0.15021913f, 0.07188756f, 
    -0.40793470f, -0.03938587f, -0.44217595f, 0.20432578f, 0.00020110f, -0.13882923f, -0.05601312f, -0.20766866f, 
    0.18864858f, 0.05764681f, -0.02754294f, -0.29479218f, -0.03983027f, -0.04705048f, 0.20066957f, 0.06952660f, 
    0.06851750f, -0.47158340f, 0.03769254f, 0.00294016f, 0.09019890f, 0.00818512f, -0.08263092f, 0.27010521f, 
    0.28032222f, 0.03009520f, -0.10058588f, 0.04370588f, 0.02283664f, -0.04113033f, -0.13854401f, 0.02358840f, 
    -0.31639302f, -0.18507357f, -0.01001250f, -0.04933133f, -0.10014338f, -0.06419275f, -0.01048536f, -0.02046304f, 
    -0.00678714f, 0.06956220f, -0.62103641f, -0.11824793f, 0.10453431f, 0.09459502f, -0.05430656f, -0.54599375f, 
    -0.20366739f, 0.19485557f, -0.13695651f, -0.04405237f, -0.03102156f, 0.12225845f, -0.06101270f, -0.19185877f, 
    -0.63523281f, -0.15490864f, -0.06142083f, 0.14518759f, 0.04600143f, 0.02596854f, -0.53451359f, 0.19961873f, 
    -0.26874283f, 0.25331825f, 0.04108917f, -0.07731235f, 0.14496097f, 0.06646127f, 0.00245340f, -0.00056518f, 
    0.00605584f, -0.07033537f, 0.17130663f, 0.04165708f, -0.41920239f, 0.24475597f, -0.28079817f, -0.08898512f, 
    -0.02995914f, -0.07463391f, -0.05462215f, 0.09951171f, -0.02308628f, -0.05044908f, -0.01901264f, -0.08323694f, 
    -0.05804880f, 0.12589025f, 0.12711155f, 0.16202973f, -0.03169967f, 0.05313031f, -0.81646019f, 0.20129684f, 
    -0.69950092f, -0.06123380f, 0.29137754f, -0.48292381f, -0.00974794f, 0.01542841f, -0.53803551f, 0.45521820f, 
    0.14568239f, -0.07980929f, -0.14484029f, -0.14655744f, -0.94478428f, -0.01417910f, -0.16550517f, -0.05431160f, 
    -0.59413570f, -0.40355459f, 0.04664908f, 0.07088258f, -0.43380830f, -0.02607785f, 0.14534587f, 0.03194106f, 
    -0.09725881f, -0.23101197f, 0.06264762f, -0.58010763f, -0.53930277f, -0.58654505f, -0.67904747f, -0.70498872f, 
    -0.16779163f, -0.17074440f, -0.29696816f, -0.58061790f, -0.06813094f, 0.15312879f, 0.24794333f, -0.39576155f, 
    0.15576243f, -0.50503558f, -0.03422638f, 0.17455861f, 0.07875136f, 0.21876675f, -0.43897638f, 0.07316305f, 
    -0.30984434f, 0.00175247f, -0.23665249f, -0.09466103f, 0.24630035f, 0.13320328f, -0.00600348f, -0.08938171f, 
    -0.45182461f, -0.00949397f, -0.10219126f, 0.09038492f, 0.09963981f, -0.74856913f, 0.13981180f, -0.03071544f, 
    0.25607136f, -0.04243896f, 0.06202122f, 0.04687219f, -0.05641251f, 0.03708595f, 0.04884964f, -0.06930755f, 
    -0.29814589f, -0.24085756f, 0.19673643f, -0.43786660f, 0.26820451f, -0.01525022f, 0.18807319f, -0.28686804f, 
    0.10017099f, -0.63725924f, -0.20321417f, 0.06318852f, -0.05683432f, -0.19643836f, -0.63918269f, 0.08346345f, 
    -0.16947909f, -0.26659116f, -0.10005448f, -0.29017308f, -0.49030143f, -0.03187341f, 0.15324877f, 0.22834300f, 
    0.24618819f, -0.03588271f, 0.00248194f, 0.07334537f, 0.06399006f, -0.11376683f, -0.09863813f, -0.03388896f, 
    0.01285248f, 0.06068215f, 0.04062876f, -0.04127455f, 0.09275885f, -0.55535895f, 0.25825030f, 0.38247544f, 
    -0.01932166f, 0.06784042f, 0.16034530f, -0.36568835f, 0.16731109f, -0.13739029f, 0.02103386f, 0.08289152f, 
    0.18657483f, 0.16294652f, -0.06350270f, -0.30040297f, -0.03717112f, -0.32516763f, -0.54519117f, -0.05997314f, 
    -0.35686934f, 0.03550184f, -0.44510791f, -0.41171837f, -0.05002377f, -0.02255422f, 0.03679781f, 0.01098131f, 
    -0.15124263f, 0.04724088f, -0.16541019f, 0.38786787f, -0.43250775f, 0.03236273f, 0.55791581f, -0.02633595f, 
    -0.46260408f, 0.30807182f, -0.04462764f, 0.00015078f, 0.12675105f, 0.00677718f, -0.32640195f, -0.00004467f, 
    -0.08643263f, -0.22011191f, 0.04346689f, 0.19639438f, -0.22867148f, -0.21161583f, -0.84292787f, -0.05000573f, 
    0.22314873f, 0.36775622f, 0.24091618f, -0.59901428f, -0.00427334f, 0.14386652f, 0.10064195f, -0.26564232f, 
    -0.50833815f, 0.12253238f, -0.07521374f, 0.05147381f, -0.01094775f, 0.16361609f, -0.28961477f, -0.01648886f, 
    0.06331690f, -0.26334566f, -0.04528523f, 0.06765442f, 0.04515792f, 0.31809387f, -0.02974149f, -0.17056979f, 
    0.32807204f, 0.02687450f, 0.02942245f, 0.24912730f, 0.15850186f, -0.54518306f, -0.38110849f, 0.00951048f, 
    -0.17521550f, -0.00124033f, -0.06791645f, 0.20146039f, -0.04031226f, -0.01604109f, 0.03878353f, 0.04467858f, 
    -0.09597450f, -0.62621582f, 0.23251516f, 0.41544902f, -0.44255608f, 0.06437117f, -0.24157389f, 0.12626891f, 
    -0.16151422f, 0.07200387f, -0.42033911f, 0.03647771f, 0.02818003f, -0.31628025f, -0.13924211f, -0.16831137f, 
    -0.21243678f, -0.24383904f, 0.00214315f, 0.00410771f, 0.13647975f, -0.04883411f, -0.04246529f, -0.07708353f, 
    0.10221547f, -0.09032169f, -0.23294929f, 0.00161868f, -0.03930129f, 0.19049922f, -0.02334991f, -0.07795233f, 
    0.03220593f, -0.01952895f, -0.13733397f, 0.00050037f, -0.10641552f, -0.13979593f, 0.15615402f, -0.61737430f, 
    0.04515808f, 0.12418886f, -0.08720593f, 0.08210017f, -0.17098682f, 0.05746108f, 0.03858079f, 0.00150703f, 
    -0.31721023f, 0.09205046f, -0.04136126f, 0.25142741f, 0.04101419f, 0.06410398f, -0.60508657f, -0.16429116f, 
    -0.38411373f, -0.04095230f, 0.16787937f, -0.54094374f, -0.00071512f, 0.00646844f, 0.22158735f, 0.05898769f, 
    0.11405700f, -0.01575714f, -0.47997361f, 0.25545117f, -0.23886843f, -0.04323629f, 0.16338426f, -0.02619589f, 
    -0.05259890f, -0.55871648f, -0.06986077f, -0.03785157f, -0.07552583f, -0.01614274f, 0.13726708f, 0.07551699f, 
    0.06984756f, -0.27633169f, -0.04732335f, 0.27325475f, -0.13704078f, -0.76497602f, 0.18445130f, 0.29086268f, 
    0.39751029f, 0.05975771f, -0.06831859f, -0.09804447f, -0.00985138f, -0.23188071f, -0.05650610f, -0.52010339f, 
    -0.10798216f, 0.00493510f, -0.06655052f, 0.06579548f, -0.07010961f, 0.11115867f, 0.26014349f, 0.07406320f, 
    -0.51280040f, 0.11526841f, 0.27220869f, -0.04957389f, -0.09842178f, 0.27714598f, 0.25800881f, -0.17967682f, 
    0.04541497f, -0.07410432f, -0.09676059f, -0.41624951f, 0.17173658f, -0.24604310f, -0.01923759f, -0.06923615f, 
    0.27001303f, -0.15511885f, -0.05849509f, 0.13045153f, -0.05504498f, -0.16258831f, -0.09056234f, -0.08999321f, 
    0.06006982f, -0.87933087f, -0.34571227f, -0.26599661f, -0.14345111f, 0.00072493f, -0.09500425f, -0.07245595f, 
    -0.16951887f, 0.32186317f, 0.20684251f, -0.05997487f, -0.01497268f, -0.49096659f, -0.11401688f, 0.10083514f, 
    0.45337933f, -0.34378371f, -0.08017886f, 0.09117168f, 0.04995512f, 0.04731042f, -0.10398799f, 0.03377758f, 
    0.02452076f, -0.26569590f, 0.12006465f, -0.07676811f, 0.23857042f, -0.27043703f, -0.05990145f, 0.05985318f, 
    -0.01473944f, -0.05708820f, 0.08209676f, -0.05359134f, -0.65644169f, 0.11182857f, -0.20465475f, -0.26020652f, 
    0.01390508f, 0.22090968f, -0.19655475f, 0.02447771f, 0.11860673f, 0.09559920f, -0.04215193f, -0.05865233f, 
    0.16158859f, 0.22675970f, -0.36344376f, -0.00647907f, 0.03951146f, -0.01215951f, 0.21644449f, -0.00972481f, 
    0.06117574f, 0.00986404f, 0.16096623f, 0.08512011f, -0.17531504f, -0.04561770f, -0.16455863f, -0.04702846f, 
    -0.68335778f, 0.02380173f, -0.00694515f, -0.23807672f, -0.16474353f, -0.01751119f, -0.19456667f, -0.03768471f, 
    -0.11284447f, 0.01052611f, -0.08266850f, 0.03312317f, -0.14623496f, 0.04773134f, -0.21503553f, 0.03622932f, 
    0.03850732f, -0.49056005f, -0.00296202f, -0.11117766f, -0.16167694f, 0.00284945f, 0.14221023f, -0.16256270f, 
    -0.30339754f, 0.13747182f, 0.16002750f, 0.08215453f, -0.01228284f, 0.24745525f, -0.19134748f, -0.26296756f, 
    -0.21127713f, -0.20565541f, -0.07033850f, 0.16020344f, -0.01548198f, -0.08126760f, 0.06736436f, 0.05404936f, 
    -0.20142318f, 0.03099641f, -0.10657044f, -0.00576241f, 0.19251487f, -0.68357128f, 0.01607079f, -0.12697689f, 
    -0.32841933f, -0.08984826f, -0.01447770f, -0.19515561f, -0.33542478f, 0.02053683f, 0.28105828f, -0.04131236f, 
    0.14164145f, -0.09351712f, -0.07657026f, 0.17490439f, -0.10319882f, 0.01673207f, -0.00040726f, -0.01978716f, 
    -0.12327849f, 0.11436574f, 0.09143687f, 0.03962304f, -0.02630679f, -0.16180781f, 0.06562341f, 0.00927607f, 
    0.08120625f, -0.11737458f, -0.01064059f, -0.02506733f, 0.04857290f, -0.27883896f, -0.20273131f, -0.08177825f, 
    -0.29549071f, 0.04452672f, -0.03984947f, -0.16014905f, 0.07033602f, 0.07121914f, -0.04674787f, -0.26462793f, 
    0.01560562f, 0.02682125f, -0.03855333f, 0.00689547f, -0.61141515f, 0.22948475f, -0.01649724f, 0.08299994f, 
    -0.02336399f, -0.03920091f, -1.02459204f, -0.08085753f, 0.09821613f, -0.08283757f, 0.21699221f, -0.54577941f, 
    0.08024392f, -0.35027742f, -0.40090621f, -0.24529217f, -0.02359767f, 0.08646720f, 0.05608701f, -0.04385981f, 
    -0.38260975f, -0.36723819f, -0.07374012f, -0.37407857f, -0.03821986f, -0.19811569f, -0.22502382f, -0.13182345f, 
    0.10369445f, 0.10615012f, -0.11646824f, -0.04779172f, -0.38507515f, -0.11583231f, 0.12254693f, -0.55246842f, 
    -0.05297270f, 0.05843888f, -0.57039839f, 0.26627186f, -0.01543560f, 0.07298782f, -0.42156512f, -0.01600026f, 
    -0.14476772f, -0.02811607f, 0.04159179f, -0.02443339f, -0.76402581f, -0.02500287f, 0.01993453f, 0.08156589f, 
    0.00610689f, -0.32486218f, -0.04624563f, 0.17179963f, 0.17603011f, -0.20143783f, -0.06698038f, -0.15499629f, 
    -0.16859604f, -0.24546605f, 0.50035769f, -0.15442011f, 0.01450748f, -0.27151474f, 0.01366442f, 0.25516024f, 
    0.18201038f, -0.26104766f, 0.02405243f, 0.14032546f, -0.01318712f, 0.01519591f, -0.07763591f, -0.07514029f, 
    0.14039885f, 0.17636470f, 0.18845677f, -0.06909700f, -0.01333567f, -0.22763228f, 0.15175983f, -0.38239881f, 
    0.06402542f, -0.10881453f, 0.05246896f, -0.53004575f, 0.16880991f, 0.15235631f, -0.68921512f, -0.07971229f, 
    -0.26697600f, 0.02128455f, 0.04811139f, 0.08697354f, -0.00841064f, -0.09042627f, 0.01120091f, 0.04976480f, 
    -0.35433269f, 0.13457564f, -0.18553638f, -0.39506388f, 0.12154584f, -0.41176844f, 0.18443605f, -0.36079365f, 
    0.03342527f, 0.06902159f, -0.70104724f, -0.08202091f, -0.00016083f, 0.15441857f, 0.24007672f, 0.14592609f, 
    -0.26128736f, -0.15695882f, -0.08113170f, 0.20753480f, -0.06622013f, -0.05220632f, 0.08132796f, -0.07723548f, 
    0.23311517f, 0.03523302f, -0.31077483f, -0.06517981f, -0.18786208f, 0.14660387f, -0.06854452f, -0.07070510f, 
    0.02558831f, -0.03496820f, -0.00699607f, -0.02569015f, 0.10288646f, 0.11766935f, 0.08751658f, -0.55309200f, 
    0.04769905f, 0.02327014f, -0.11610126f, -0.00319926f, -0.40521291f, 0.12558573f, -0.01862086f, 0.00108392f, 
    -0.31214452f, 0.10995618f, 0.18482846f, -0.38123962f, 0.02761716f, -0.03774730f, -0.02714671f, -0.28803352f, 
    -0.01256172f, 0.26280907f, -0.02578366f, -0.07914662f, 0.19509640f, 0.03398621f, -0.31419638f, -0.58897996f, 
    -0.44732496f, 0.06893754f, -0.33490753f, 0.11414587f, -0.05243849f, -0.00635552f, -0.38453335f, 0.00390677f, 
    -0.16525729f, -0.15787502f, 0.06686699f, 0.02140829f, 0.03492151f, -0.02429829f, 0.07312976f, 0.07637672f, 
    0.00933997f, -0.23541155f, 0.00835715f, -0.05373671f, 0.11754365f, -0.40469605f, -0.16622026f, -0.24069202f, 
    0.22842784f, -0.05064054f, -0.01971205f, -0.24608128f, 0.00524486f, -0.17662689f, -0.01148359f, -0.12459667f, 
    0.05634840f, -0.59694970f, 0.00037062f, 0.05870410f, 0.03752550f, 0.05936583f, -0.38119337f, 0.02780055f, 
    0.50851136f, 0.06329219f, 0.14816201f, 0.04699923f, -0.20069398f, -0.65572345f, -0.20253231f, -0.03498670f, 
    0.13619466f, 0.01072138f, -0.09623815f, -0.22417253f, -0.06275618f, -0.25100163f, 0.13930352f, 0.01210172f, 
    0.02169374f, -0.05558892f, 0.01297041f, -0.15362450f, -0.08159339f, -0.05253061f, -0.12197978f, -0.09972664f, 
    -0.48911068f, 0.09460815f, 0.11508012f, -0.33021602f, 0.01272235f, -0.29993457f, 0.16116154f, 0.31014737f, 
    0.21736237f, -0.59114742f, 0.28781289f, 0.02732981f, -0.04969742f, -0.13460143f, -0.44498882f, 0.15156984f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.06752243f, 0.26781356f, 0.01507045f, -0.06184528f, 0.08625145f, -0.10093105f, -0.08111483f, -0.05141644f, 
    0.08483639f, 0.12434724f, 0.17288511f, -0.13872717f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
