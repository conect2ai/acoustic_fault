#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.17782508f, 0.05044097f, -0.19242890f, 0.11198869f, 0.02857830f, -0.40789899f, -0.30432472f, 0.17958991f, 
    -0.17774537f, -0.16391252f, 0.53027970f, -0.43238360f, -0.09597265f, -0.00962046f, 0.18904413f, 0.11795925f, 
    0.23677014f, -0.12805201f, -0.02813306f, -0.27063370f, 0.16510326f, 0.19667204f, 0.18242218f, 0.20398082f, 
    0.45469329f, -1.20647120f, 0.35439146f, 0.25420365f, 0.10323405f, -0.58698773f, -0.07558081f, 0.35840777f, 
    0.53490573f, -0.06980786f, 0.13810952f, 0.04365149f, 0.14584215f, -0.10532549f, 0.18227330f, 0.25303078f, 
    0.09718487f, -0.21708967f, -0.50769299f, -0.22219580f, -0.00287808f, 0.12124196f, 0.08032391f, 0.25375411f, 
    0.24851561f, -0.03580815f, 0.65589529f, -0.29207012f, -0.40020648f, -0.98453778f, -0.72559327f, 0.45166332f, 
    -0.10224361f, 0.36116588f, 0.01484471f, 0.23164769f, 0.07154442f, 0.21412659f, 0.38467905f, 0.06840002f, 
    0.26577577f, 0.27586114f, 0.18819031f, 0.18847696f, -0.29546869f, -0.05294390f, 0.02273567f, -0.26521075f, 
    -0.27988246f, 0.10897315f, -0.12037610f, -0.99555719f, 0.23268130f, -0.83153152f, 0.04043850f, -0.32213384f, 
    -0.04299162f, -0.20258260f, 0.01297545f, 0.15283760f, 0.68612206f, 0.19956940f, 0.10219093f, 0.25298569f, 
    0.23841472f, 0.07506994f, -0.37135267f, -0.21501684f, -0.11742973f, 0.34127828f, 0.21034151f, 0.10051341f, 
    0.03939310f, 0.32704508f, -0.24506138f, 0.18517031f, -0.11775412f, 0.44365928f, 0.35732913f, 0.27410161f, 
    0.32856825f, -0.47120160f, -0.32122377f, 0.03357553f, 0.59429640f, 0.39187500f, 0.07266561f, -0.15178007f, 
    0.28907484f, 0.28062311f, 0.06681938f, -0.14886779f, 0.01394830f, 0.06188690f, -0.03776858f, -0.14873739f, 
    -0.13628924f, -0.21294883f, -0.08299383f, 0.08722465f, -0.17089126f, -1.27375627f, 0.39990476f, -0.47415736f, 
    -1.26432312f, -0.40703121f, 0.43489099f, 0.13056001f, 0.09003240f, -0.11707126f, 0.05533021f, -0.34003919f, 
    -0.15269506f, -0.26144645f, -0.44346783f, -0.11478758f, 0.48496383f, -0.05901071f, -0.13824335f, 0.13195197f, 
    -0.14060874f, 0.00862505f, 0.12846352f, -0.17801093f, -0.23600496f, -0.30259216f, -0.83838379f, -0.76882917f, 
    -0.36031619f, -0.14456759f, 0.26944923f, 0.45098263f, -0.08605859f, -0.02130543f, 0.45062488f, 0.31494156f, 
    0.05987238f, -0.06010184f, -0.16268273f, 0.15905230f, 0.30150205f, -0.24783085f, -0.06503251f, -0.22199938f, 
    -0.26732409f, -0.42126945f, -0.03238739f, -0.17391758f, 0.00112077f, -0.10042078f, -0.33767310f, -0.25278381f, 
    -0.25983015f, 0.02974953f, -0.58522749f, -0.68074358f, 0.27921119f, -0.15625519f, 0.04250172f, 0.48003021f, 
    0.30685547f, 0.01241922f, -0.35392371f, 0.05816470f, 0.30689797f, -0.14136927f, 0.06520035f, 0.17080857f, 
    -0.13031247f, -0.18047421f, -0.30225685f, 0.07409846f, 0.25489762f, 0.47286394f, 0.17544709f, 0.46557519f, 
    -0.31760636f, -0.59440148f, 0.33751613f, 0.58053327f, 0.77416199f, -0.29585084f, 0.12954882f, -0.44989884f, 
    -0.71232921f, -0.44813237f, -0.36835065f, -0.05550376f, 0.35110608f, -0.33992228f, 0.04329916f, -0.12313624f, 
    -0.29347005f, 0.31812221f, 0.53580153f, 0.30053246f, -0.02117946f, -0.02297090f, 0.03705215f, -0.12137151f, 
    -0.35667816f, 0.29476810f, 0.32534146f, 0.26669022f, -0.21974596f, 0.22870493f, 0.01495332f, 0.18120305f, 
    0.29296505f, 0.31908235f, 0.52021557f, 0.21462552f, -0.05614710f, -0.29702023f, -0.07807445f, -0.12291504f, 
    0.08417140f, -0.05621538f, -0.27757746f, -0.18062121f, -0.04722055f, 0.19850354f, 0.38803199f, 0.29459089f, 
    -0.31893405f, -0.61501592f, 0.56206983f, 0.02159802f, 0.26713577f, -0.16138874f, 0.27439499f, -0.13435510f, 
    -0.10035881f, 0.15863034f, 0.21665804f, 0.28185454f, -0.09426281f, -0.23690893f, -0.10888096f, 0.46419287f, 
    0.22020715f, -0.10792189f, -0.12911741f, -0.29654858f, 0.25839281f, -0.40877020f, 0.14982730f, -0.16265802f, 
    -0.17890091f, 0.22857897f, 0.30998114f, 0.07826054f, -0.15360840f, -0.60100871f, -0.56518209f, -0.18842459f, 
    -0.51804137f, -0.60583401f, -0.38487944f, -0.52407855f, -0.46811068f, 0.53287178f, 0.26292798f, 0.62551707f, 
    0.19695881f, 0.07769911f, 0.05189927f, 0.10748789f, -0.11984242f, -0.46387583f, -0.14577974f, 0.00772881f, 
    -0.17368577f, 0.11658801f, -0.14861177f, 0.13254744f, 0.73592418f, 1.24969232f, 0.66257894f, -0.83335799f, 
    -0.48016578f, -0.34009358f, -0.12388001f, 0.08681649f, -0.49645332f, -0.46259764f, 0.14487562f, 0.08569396f, 
    0.04047120f, 0.00331294f, -0.21399637f, 0.07112306f, -0.22875628f, -0.01498308f, 0.16174841f, 0.27721900f, 
    -0.12075694f, 0.27326965f, -0.22372721f, -0.07074238f, 0.22533564f, 0.03739802f, 0.10843987f, 0.08643410f, 
    0.00768794f, -0.42703694f, 0.54761350f, -0.29877290f, -0.02458182f, 0.48368382f, 0.09881092f, 0.63567364f, 
    -0.60089874f, -0.38107917f, 0.35651106f, -0.28699684f, -0.18618093f, -0.12471994f, 0.16215988f, 0.03035418f, 
    0.16301776f, 0.14960754f, -0.04095639f, -0.01826998f, 0.08520775f, -0.02927033f, 0.10952093f, -0.52373266f, 
    -0.97173882f, -0.78552198f, -0.19264227f, 0.11075074f, 0.39504215f, 0.37840295f, 0.26840758f, -0.26543915f, 
    0.42487508f, -0.16916728f, -0.20892477f, -0.29102740f, 0.27890402f, -0.25228432f, -0.34273118f, 0.24235758f, 
    -0.29979336f, -0.15778211f, -0.09033982f, -0.01020328f, -0.01993837f, 0.03141408f, 0.33462659f, -0.69267380f, 
    0.09106180f, 0.18214647f, -0.32359904f, -0.50576282f, -0.21980903f, -0.71497333f, -0.56169844f, 0.07327243f, 
    -0.29560134f, -0.35058597f, -0.19637735f, -0.27424270f, -0.72688109f, -0.11358628f, -0.14010568f, -0.14903030f, 
    -0.13135853f, -0.13591346f, 0.15351206f, -0.11090469f, 0.10127147f, 0.05761958f, -0.03844290f, 0.00248411f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.22977844f, 0.11621193f, 0.09543986f, 0.31757921f, 0.26559085f, -0.12985925f, 0.05941905f, -0.15514745f, 
    0.04063684f, 0.40453237f, 0.33412066f, -0.10463274f, 0.45824650f, 0.25800267f, 0.32993704f, 0.26551664f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.06371704f, -0.06892146f, 0.03514391f, 0.01291548f, 0.01856068f, -0.06005039f, -0.00648104f, 0.01202875f, 
    0.05155655f, 0.02901384f, -0.06282922f, 0.02232463f, -0.04341748f, -0.08537022f, 0.05710399f, 0.03107360f, 
    0.04565352f, -0.05647744f, 0.01698504f, -0.00394019f, 0.05389497f, -0.05164556f, -0.04980614f, 0.03316077f, 
    0.03632335f, -0.01835534f, -0.02784059f, 0.03811742f, 0.05117482f, 0.00464059f, 0.03170715f, -0.07925091f, 
    0.06151036f, 0.06268913f, 0.01575471f, -0.00681121f, -0.07114170f, -0.01256682f, -0.01571938f, -0.04821870f, 
    0.03655065f, 0.01864749f, 0.00002559f, 0.03512358f, 0.02606080f, 0.02400802f, -0.05281467f, 0.04884107f, 
    -0.07368799f, -0.01541272f, 0.00117301f, -0.06401494f, 0.02483208f, 0.02511131f, 0.02073928f, -0.00595500f, 
    -0.00403494f, -0.06849592f, -0.03843749f, -0.07666543f, 0.04591398f, 0.05744435f, 0.04879347f, -0.00195498f, 
    0.00287518f, -0.01293286f, -0.06179827f, -0.05721474f, -0.01594237f, -0.04336772f, -0.00404313f, 0.03515185f, 
    -0.05032750f, -0.06787126f, 0.04026388f, 0.01334236f, -0.03110290f, -0.01204105f, -0.05467711f, -0.06798779f, 
    0.06443133f, -0.00447514f, -0.03911483f, -0.02503386f, -0.04031106f, 0.04872492f, 0.01339316f, -0.07583259f, 
    -0.00193904f, -0.03209494f, -0.05961993f, 0.02290250f, 0.01679207f, 0.05158249f, 0.05250179f, 0.05979845f, 
    -0.05389201f, -0.06423061f, 0.03319025f, 0.02797728f, 0.05828523f, -0.06571991f, 0.02574887f, -0.03092536f, 
    -0.07601914f, 0.02589271f, 0.01244319f, -0.00240381f, 0.01354143f, 0.02885450f, -0.06262634f, -0.07298815f, 
    -0.03756200f, -0.02426898f, -0.06902508f, 0.00658471f, 0.01423002f, -0.02742598f, 0.01697330f, -0.06740839f, 
    0.00108571f, 0.00204674f, -0.00542597f, -0.05899447f, -0.07513220f, 0.00896600f, 0.03824713f, -0.07374151f, 
    0.01980225f, 0.00156062f, -0.05474677f, 0.01022414f, -0.02417029f, -0.05216189f, -0.05990905f, -0.02454767f, 
    -0.03584767f, -0.08029408f, -0.06067867f, 0.00016076f, -0.03860293f, -0.00728452f, -0.00515667f, 0.02633433f, 
    -0.05295837f, 0.00415534f, -0.06898867f, -0.03414300f, -0.02331900f, 0.02193431f, -0.02397967f, 0.03696196f, 
    0.05877642f, -0.02196091f, -0.03991465f, -0.04286854f, -0.07056095f, 0.05423715f, 0.02343712f, -0.06203925f, 
    0.04755448f, -0.07061880f, 0.04480055f, 0.05437675f, -0.03067318f, -0.01168844f, -0.01936082f, 0.02391307f, 
    0.02403381f, -0.00988541f, -0.06854584f, 0.04614027f, -0.02505905f, -0.02800672f, -0.00698806f, -0.07463948f, 
    -0.02668291f, -0.00628545f, -0.01984108f, -0.04250504f, -0.06346298f, -0.03667806f, 0.05534490f, -0.05410235f, 
    -0.02333031f, -0.00086568f, 0.01826820f, 0.00739835f, 0.04063151f, -0.01671015f, 0.05446684f, -0.07968964f, 
    0.22789034f, -0.03289510f, -0.00905787f, -0.12379458f, 0.16007559f, -0.10775319f, -0.05591014f, 0.27052221f, 
    0.03712051f, -0.01960422f, -0.00032967f, -0.13951004f, -0.50563723f, 0.50638086f, -0.20679539f, 0.05992342f, 
    0.03135891f, -0.04621164f, -0.09225988f, -0.08612484f, 0.08667058f, -0.08437929f, -0.02263623f, 0.03068195f, 
    0.00849045f, 0.10240630f, 0.20447670f, -0.24945538f, 0.07171980f, -0.06781061f, -0.23207180f, 0.01927769f, 
    0.15344112f, 0.09706432f, -0.03842638f, -0.09438631f, -0.31478742f, 0.18986145f, 0.23611802f, -0.05710376f, 
    -0.05580500f, -0.01234025f, 0.15441981f, 0.13791710f, 0.12215945f, 0.12522557f, -0.06751816f, 0.13984711f, 
    0.04790290f, -0.02211787f, -0.11505459f, 0.12106353f, 0.11980441f, 0.12544774f, 0.03165029f, -0.01087996f, 
    0.12750147f, 0.09066112f, -0.04875129f, 0.08311279f, -0.45622277f, -0.12617716f, 0.21041390f, -0.29967347f, 
    -0.10540432f, -0.05994685f, 0.06653430f, 0.08350343f, 0.07095133f, 0.06630999f, 0.09850321f, -0.02272512f, 
    -0.21446505f, -0.00834266f, 0.03530771f, 0.28997156f, -0.01054091f, -0.20646080f, -0.03709623f, -0.07538660f, 
    -0.03538347f, -0.09151535f, -0.03747082f, 0.15007088f, -0.00187158f, 0.23326150f, -0.18077156f, -0.03489220f, 
    0.08901605f, -0.26630884f, 0.18934983f, -0.00866610f, 0.05015883f, -0.04483496f, -0.05970712f, -0.19782248f, 
    -0.07478416f, -0.64414114f, 0.34279928f, 0.03197320f, 0.06839625f, 0.21561407f, 0.00053517f, 0.08203483f, 
    -0.03492699f, 0.00190769f, -0.07793770f, 0.09975470f, -0.01217704f, 0.04683539f, -0.24947461f, 0.11363607f, 
    -0.00978508f, 0.03821442f, -0.00832244f, -0.21162447f, 0.03804801f, 0.11417750f, 0.12372044f, -0.11094321f, 
    0.16408722f, -0.17243750f, -0.07647815f, -0.05408954f, 0.01116256f, -0.07811998f, -0.12281082f, 0.02624129f, 
    -0.00340639f, 0.07816536f, 0.08418061f, 0.14884906f, -0.00488959f, 0.24800777f, 0.57150704f, 0.12098242f, 
    -0.07434911f, -0.16585137f, -0.03432350f, 0.02191531f, 0.07829674f, 0.06880898f, -0.06300637f, 0.01766784f, 
    0.22562292f, 0.23626149f, -0.33953747f, 0.03331338f, 0.09353559f, 0.14248532f, 0.31551316f, -0.11111189f, 
    0.02004645f, -0.03393254f, -0.07366657f, 0.08349067f, 0.22383374f, 0.00744741f, -0.16062269f, 0.39028972f, 
    0.08702977f, -0.11796911f, -0.06793174f, -0.31657138f, -0.21956405f, -0.10014560f, 0.01749379f, 0.19113654f, 
    -0.08321451f, -0.08760092f, 0.09872284f, -0.02246746f, 0.00763767f, -0.11957350f, 0.07419235f, 0.14098172f, 
    0.06905337f, -0.03765963f, 0.01281542f, 0.00285356f, -0.05230841f, -0.04950758f, 0.08298808f, 0.15506043f, 
    -0.08190086f, -0.09475962f, 0.16772565f, -0.04042558f, 0.08043860f, -0.04487263f, 0.20822372f, 0.16551207f, 
    -0.16192256f, 0.16421378f, 0.10555730f, -0.06865644f, -0.08177719f, -0.03719529f, -0.04697411f, -0.07886812f, 
    -0.12758183f, -0.02329104f, -0.16267012f, -0.15481496f, -0.30588529f, -0.23073068f, -0.18314834f, 0.30679756f, 
    0.02723607f, -0.10835187f, 0.07868712f, -0.11001091f, -0.09418708f, 0.02736044f, 0.16712950f, 0.08085497f, 
    0.38801783f, -0.45056733f, -0.02842466f, -0.28961360f, -0.16896547f, 0.10707948f, 0.20462282f, -0.03711896f, 
    0.14965552f, 0.12023272f, -0.06294048f, 0.17195332f, 0.27962884f, -0.08272708f, -0.04802540f, 0.00165270f, 
    0.15586908f, 0.01065575f, -0.11379223f, -0.15119088f, 0.11261076f, -0.05523094f, 0.01088586f, 0.08592382f, 
    -0.29223952f, -0.42199376f, -0.27402779f, -0.36578104f, 0.28540263f, 0.11054828f, -0.09821387f, -0.02909183f, 
    0.16573130f, 0.00135184f, -0.16518001f, -0.01847704f, -0.15087901f, 0.66268015f, 0.16407838f, 0.27021757f, 
    0.07172865f, 0.18057433f, -0.16535518f, -0.03843458f, -0.06600098f, 0.03817558f, 0.08011319f, 0.01200291f, 
    0.14325136f, -0.12921295f, 0.21670145f, 0.17895588f, 0.07107301f, -0.05111507f, -0.06122343f, 0.17077319f, 
    -0.01534386f, 0.15367591f, 0.16945425f, 0.07297030f, 0.22038794f, -0.03902871f, 0.18621479f, -0.03273251f, 
    0.11049789f, 0.10010071f, 0.00024847f, 0.07677182f, -0.07651368f, -0.12354271f, 0.15584984f, -0.07807938f, 
    0.33189693f, 0.19322672f, -0.02794010f, -0.13280886f, 0.09096876f, -0.05473191f, 0.05825916f, -0.00847295f, 
    0.06396080f, 0.00421909f, 0.13185941f, 0.03661111f, 0.04282267f, -0.50992292f, -0.00541391f, -0.06625824f, 
    0.10539998f, 0.00901066f, -0.03535428f, 0.17176442f, 0.14065553f, -0.04758896f, 0.04899775f, -0.09263536f, 
    -0.19283649f, -0.47902873f, -0.04275135f, 0.10036227f, 0.14195891f, 0.02156574f, -0.02776642f, -0.20810799f, 
    -0.07902621f, -0.12756813f, 0.01416549f, 0.00841337f, 0.36694261f, 0.29919457f, 0.13363802f, -0.07236610f, 
    -0.09326772f, -0.09412972f, -0.05247466f, 0.09647828f, 0.11403994f, 0.00616079f, -0.00806840f, -0.04139489f, 
    -0.09313864f, -0.06369451f, -0.20592113f, -0.18458903f, 0.08677563f, 0.04604248f, -0.02042110f, 0.11576707f, 
    -0.08894128f, 0.11184165f, -0.05402745f, -0.03282347f, -0.24812669f, -0.06380986f, -0.13409998f, -0.32790583f, 
    -0.03428096f, 0.04016548f, 0.23141016f, 0.32983968f, 0.06471120f, 0.14691590f, -0.21754926f, -0.12931843f, 
    0.30661201f, 0.13234288f, 0.07541592f, -0.25007474f, 0.13676281f, 0.23585904f, 0.13233905f, -0.05459024f, 
    0.03837477f, 0.00371387f, -0.18915987f, -0.08244616f, -0.07255455f, 0.39313355f, -0.00017965f, 0.05585742f, 
    -0.07407825f, -0.05715044f, -0.12519294f, 0.10030591f, 0.01983438f, -0.06800556f, -0.12737666f, 0.03552875f, 
    -0.04840304f, -0.16877767f, 0.04742460f, -0.06165484f, 0.12389977f, -0.09467451f, 0.01102863f, 0.02740050f, 
    -0.40670043f, -0.21632005f, -0.07285897f, -0.37697583f, 0.13603127f, 0.07976925f, -0.17672484f, -0.01834317f, 
    -0.23138945f, -0.13148496f, 0.11438077f, -0.28063637f, -0.16753313f, -0.01515249f, -0.11753485f, -0.02709862f, 
    -0.14401878f, 0.01574949f, 0.05207097f, 0.15138865f, 0.01479011f, -0.09513736f, 0.08578142f, -0.12551577f, 
    0.10794890f, -0.01583344f, -0.28803605f, 0.02139170f, 0.32214457f, -0.10606154f, -0.02907898f, -0.01620588f, 
    0.08006722f, 0.05642154f, -0.16985816f, -0.00241544f, 0.09077183f, -0.04832469f, -0.03099008f, 0.14084113f, 
    0.12097954f, 0.00461545f, -0.00807621f, -0.10175344f, -0.24952795f, -0.00015534f, -0.31322256f, -0.50296789f, 
    -0.20377517f, -0.04303303f, -0.02046893f, 0.01514196f, 0.27670941f, -0.29742223f, -0.13799754f, 0.19388290f, 
    0.17080860f, 0.12384170f, 0.16276163f, 0.07760812f, 0.11522213f, -0.04208543f, 0.04967732f, 0.17439170f, 
    0.26787269f, -0.09905109f, -0.01635272f, 0.07689032f, -0.01239619f, 0.18141349f, -0.02355072f, -0.05794021f, 
    0.06029721f, 0.13606609f, 0.03068940f, 0.28736258f, 0.10520960f, -0.25118479f, 0.12459510f, 0.08759612f, 
    0.11845756f, 0.07959312f, -0.07027493f, 0.13889338f, -0.17892428f, -0.08687620f, -0.23845628f, -0.11796612f, 
    -0.20406573f, 0.29220703f, 0.17665106f, 0.25117972f, 0.10539333f, 0.27775753f, 0.00793839f, 0.11800575f, 
    0.09416608f, -0.01954462f, 0.01677055f, 0.18141294f, 0.13919289f, -0.12623873f, 0.08602118f, 0.01310520f, 
    0.05975892f, 0.14394979f, -0.04036861f, -0.53003770f, 0.12067057f, -0.09970697f, 0.10094652f, 0.18398368f, 
    0.12020303f, -0.06595067f, -0.05777997f, -0.12368951f, 0.02754869f, -0.02409956f, -0.24342401f, -0.47957104f, 
    -0.25909713f, -0.02317997f, -0.16081193f, -0.23395565f, 0.16246165f, 0.35180560f, 0.11431252f, 0.34371847f, 
    -0.00820845f, 0.07868168f, 0.02653285f, 0.19031286f, 0.05170600f, 0.23217945f, 0.10735775f, -0.00889177f, 
    -0.14454499f, 0.53409404f, -0.03792606f, 0.36748406f, 0.17048654f, 0.01401218f, 0.03818339f, -0.26261994f, 
    0.04888706f, -0.16021430f, -0.10190311f, -0.33302909f, 0.19886589f, -0.23750760f, 0.25436512f, -0.16503228f, 
    -0.43918091f, -0.02267838f, -0.03069876f, -0.11423033f, -0.18398404f, 0.18233611f, 0.15241630f, -0.03547328f, 
    -0.00811602f, -0.21128187f, -0.03638522f, 0.12405958f, 0.13221517f, -0.11947564f, -0.05769259f, 0.11330840f, 
    -0.09391657f, -0.07353029f, 0.12139701f, -0.07220064f, 0.12135380f, -0.08589044f, 0.17077130f, 0.27279848f, 
    -0.03012292f, -0.06507687f, -0.09553088f, 0.12053715f, 0.02294945f, 0.02876766f, 0.04321520f, -0.06857157f, 
    -0.06946592f, 0.02588095f, 0.05334250f, -0.04077899f, 0.04134325f, 0.02218725f, -0.02007603f, -0.05438941f, 
    -0.05942024f, -0.04844531f, -0.05113154f, -0.06288621f, -0.06922776f, -0.00734270f, 0.04664579f, -0.02181446f, 
    -0.05109456f, -0.05085525f, -0.04454203f, -0.07638560f, -0.02271787f, -0.00385614f, -0.05587817f, -0.00126347f, 
    -0.01076260f, 0.05900395f, -0.03215117f, -0.04040555f, -0.06779074f, -0.05845561f, -0.04225969f, 0.02006825f, 
    -0.02965392f, 0.00929362f, 0.03591365f, 0.02345527f, 0.02301566f, 0.06181748f, -0.05741663f, -0.06258226f, 
    -0.05457922f, 0.02232444f, -0.05799966f, -0.05076161f, 0.01345110f, 0.02271074f, -0.06255290f, 0.01009561f, 
    0.01855686f, -0.00167426f, 0.00388748f, 0.00651201f, -0.05008056f, -0.06723520f, 0.02128480f, 0.05996559f, 
    0.06755850f, -0.03001682f, 0.00161985f, -0.03354621f, -0.07258262f, 0.05778065f, 0.00970780f, -0.05812918f, 
    -0.07077608f, -0.03873766f, 0.06086078f, 0.04684877f, -0.05581696f, 0.02661044f, -0.05803541f, -0.01394917f, 
    -0.02645123f, -0.05970463f, -0.04973650f, 0.03584910f, -0.04375609f, 0.00714234f, 0.00394240f, 0.02360731f, 
    -0.02958869f, -0.05887243f, 0.00877090f, 0.03614161f, -0.06559654f, -0.01531631f, -0.02786812f, -0.06032151f, 
    -0.00970544f, 0.06685631f, 0.00702154f, -0.05671668f, -0.01270171f, -0.07062370f, 0.06326679f, -0.01270501f, 
    -0.03695939f, -0.07601041f, -0.01345907f, -0.03051510f, -0.02114779f, 0.01813798f, 0.00216028f, -0.00869890f, 
    -0.02102669f, 0.03568092f, 0.00585978f, -0.06413615f, 0.05862106f, -0.02432125f, -0.07271277f, 0.03673705f, 
    0.03306108f, -0.02476587f, 0.01304515f, 0.02417056f, 0.04767950f, 0.01457967f, -0.05764442f, -0.01589648f, 
    -0.06997173f, 0.02504375f, 0.01559059f, 0.02057834f, 0.05506625f, -0.02836397f, -0.01697497f, 0.00989664f, 
    0.06469430f, -0.00994811f, -0.03225199f, 0.06306182f, 0.04670351f, -0.00452145f, -0.01301135f, -0.04067843f, 
    0.03113206f, 0.02545786f, -0.03770248f, 0.00944754f, -0.00164244f, -0.03850815f, 0.01141669f, -0.00289201f, 
    -0.04400431f, -0.07868431f, -0.03802319f, -0.07385658f, -0.02984256f, 0.01690425f, -0.01639920f, -0.00325883f, 
    -0.03336402f, 0.04973328f, 0.01698361f, -0.02003685f, 0.00340550f, -0.02063780f, -0.06633572f, -0.02366305f, 
    -0.06049053f, -0.00091359f, 0.06586120f, 0.03302107f, -0.07863966f, -0.04500040f, -0.04414239f, -0.02079571f, 
    0.06106825f, -0.07507741f, -0.00121426f, 0.03969846f, 0.05334916f, -0.01329207f, 0.02123734f, 0.00694300f, 
    -0.02778956f, 0.00753718f, 0.05832696f, 0.04441916f, 0.05598728f, 0.04624200f, -0.03554516f, -0.00071054f, 
    0.02563853f, 0.05506497f, -0.00609099f, 0.03493977f, -0.02211216f, -0.03285408f, -0.07907704f, -0.02678555f, 
    0.09955774f, 0.03267805f, 0.19346853f, -0.11807789f, 0.13489196f, -0.09151578f, -0.11507174f, -0.06439941f, 
    -0.09034026f, -0.20880200f, -0.07990299f, -0.17539988f, 0.17419453f, 0.35014975f, -0.20327604f, 0.11489314f, 
    0.17679529f, -0.28994441f, -0.04015722f, -0.09916764f, -0.04314836f, 0.02412177f, -0.17670067f, -0.03468894f, 
    -0.72402567f, -0.23329650f, 0.33329901f, 0.21059197f, 0.01494912f, -0.05911231f, -0.15048659f, -0.34344390f, 
    -0.01495923f, 0.09307098f, -0.00775516f, 0.11822740f, 0.37900275f, -0.24898931f, -0.12938820f, -0.15508044f, 
    0.06247300f, -0.13993911f, 0.03302625f, -0.17376529f, 0.07970590f, 0.00226121f, 0.14884606f, 0.09134650f, 
    0.09233090f, -0.21009029f, -0.01742082f, 0.11257901f, -0.01413449f, -0.00656286f, -0.02441525f, -0.22624260f, 
    0.01110942f, 0.01404863f, 0.12276390f, 0.12887056f, 0.22839727f, -0.21503130f, -0.20998858f, -0.05894870f, 
    -0.04230396f, 0.02359001f, 0.10748658f, 0.05371723f, 0.17401646f, 0.03820645f, 0.07570491f, 0.20732470f, 
    0.24257040f, -0.14097744f, 0.12905097f, 0.24271689f, 0.19926925f, -0.00210284f, -0.04140172f, -0.17144738f, 
    0.02755731f, 0.08497924f, -0.00367490f, 0.09888648f, 0.16012976f, -0.11270269f, 0.03445142f, -0.14251605f, 
    -0.06542958f, 0.08177893f, -0.04730823f, -0.01155439f, 0.01692049f, -0.02799603f, -0.13426846f, -0.01599510f, 
    0.05104108f, 0.16861646f, 0.10733167f, -0.19853036f, 0.00379251f, 0.08736873f, 0.00656960f, 0.19451502f, 
    0.18619463f, 0.06702035f, -0.12845452f, 0.02509476f, -0.12324871f, 0.00639038f, 0.19903705f, 0.22182827f, 
    0.05796755f, 0.15134214f, 0.14835168f, -0.27143520f, 0.12736923f, -0.05241676f, -0.10930765f, 0.11981228f, 
    0.06589443f, -0.09574632f, 0.12111574f, -0.05114709f, 0.20682739f, -0.33736494f, -0.25150323f, -0.33426476f, 
    0.01387016f, 0.02956346f, -0.02183920f, -0.09973756f, 0.41691157f, 0.36790213f, 0.12877978f, 0.22289835f, 
    0.16288030f, 0.19456989f, 0.10843065f, 0.08238845f, -0.06719507f, 0.12596382f, 0.13456818f, -0.03083570f, 
    -0.47502011f, 0.72706157f, -0.36621860f, 0.50920111f, -0.00808739f, 0.02951230f, 0.11900237f, 0.07919181f, 
    0.13950953f, -0.11125573f, -0.13446432f, -0.01117786f, 0.08300487f, -0.26875231f, 0.08114593f, -0.09645482f, 
    -0.27901205f, 0.15924929f, -0.08091172f, -0.21579234f, -0.02412059f, -0.07372645f, 0.07155858f, 0.03815033f, 
    0.16755117f, -0.35795373f, -0.17996123f, -0.15987822f, 0.14974493f, -0.15066142f, -0.05724398f, -0.01572152f, 
    -0.13438772f, -0.02070044f, 0.02631566f, 0.00730299f, 0.22010984f, -0.10318951f, 0.26559174f, 0.13330215f, 
    -0.08695684f, -0.02075237f, -0.00963867f, 0.11813629f, 0.04222599f, 0.16541936f, 0.06780156f, 0.07339534f, 
    -0.07497267f, 0.02471922f, -0.10671361f, -0.18666765f, 0.11719351f, 0.10302767f, 0.26827222f, 0.06454776f, 
    -0.17826794f, 0.11904741f, 0.07123986f, 0.01442554f, -0.58610904f, -0.20028175f, 0.23721491f, 0.23455054f, 
    -0.12079282f, 0.14534019f, -0.14021313f, -0.08996750f, 0.16112915f, -0.01728542f, 0.38747287f, 0.07866608f, 
    0.24349737f, -0.14169544f, -0.19914788f, -0.35036537f, -0.04994547f, -0.00131941f, 0.02697092f, -0.11156303f, 
    0.15988550f, 0.00806336f, 0.17751344f, -0.11412349f, -0.47820479f, 0.12327307f, 0.09035661f, -0.09160929f, 
    -0.05741548f, 0.08205365f, -0.10250223f, -0.00888574f, -0.05143544f, 0.05259112f, 0.04584336f, 0.19614157f, 
    -0.04728042f, 0.06176967f, 0.07596687f, 0.02978771f, 0.04710232f, -0.08371887f, -0.05351831f, -0.01018267f, 
    0.07334851f, -0.04606599f, -0.07134016f, -0.01830170f, -0.17923823f, 0.36473387f, 0.08567900f, -0.01428467f, 
    0.14202905f, 0.08566370f, -0.20405035f, -0.05643691f, -0.07329656f, 0.09944802f, 0.02890381f, -0.02805323f, 
    -0.00976982f, 0.10816771f, 0.01931419f, -0.20748511f, -0.01637041f, 0.10374960f, -0.09928727f, 0.04549982f, 
    -0.16397268f, 0.03782493f, 0.25371000f, -0.17678881f, -0.08810548f, -0.04106410f, -0.05011705f, -0.27389753f, 
    0.15424043f, 0.01122251f, 0.12511516f, 0.12343340f, -0.06703233f, -0.07907037f, 0.16148743f, -0.07213056f, 
    0.10788400f, -0.01418158f, -0.23038669f, 0.08392140f, 0.17020592f, -0.00287828f, 0.07695363f, 0.04341978f, 
    -0.06900306f, -0.06051948f, 0.18940349f, -0.01149994f, 0.27197814f, 0.11372683f, 0.24749361f, 0.29748148f, 
    -0.08638921f, -0.22132918f, -0.23926021f, 0.05537342f, -0.10707394f, 0.10445957f, 0.09858926f, 0.04609152f, 
    0.29460737f, 0.29360828f, 0.12415674f, 0.08174606f, -0.10599504f, -0.02283192f, 0.12354104f, -0.16198942f, 
    0.14310068f, -0.02768159f, 0.04423942f, 0.04484252f, -0.31136668f, -0.03544381f, -0.13121432f, -0.20972304f, 
    -0.13274030f, -0.10769495f, -0.09907204f, 0.08254277f, -0.00877600f, -0.03478003f, -0.03712887f, 0.09399369f, 
    0.50969738f, -0.33818686f, 0.12696810f, -0.25710082f, 0.00529538f, -0.08934487f, 0.00206243f, -0.05397671f, 
    -0.06949345f, 0.06071357f, 0.07836431f, 0.06597432f, 0.05792468f, 0.18950632f, 0.07803361f, -0.06995372f, 
    0.06380612f, -0.06025763f, 0.03034741f, -0.04447423f, 0.16384915f, 0.25073862f, 0.18229912f, -0.04719545f, 
    -0.01445569f, 0.14028829f, 0.05471900f, 0.09054200f, 0.02523551f, 0.17326744f, 0.07106634f, 0.11216223f, 
    0.25746337f, 0.09996410f, 0.00019876f, 0.06150598f, -0.02674104f, 0.21323325f, -0.32158050f, -0.12283022f, 
    0.18895575f, 0.15310395f, 0.01777096f, 0.30669242f, -0.01644524f, -0.03483822f, -0.01627540f, 0.05589227f, 
    0.00716887f, 0.11010054f, 0.12031202f, 0.01811222f, -0.04089050f, -0.23968036f, 0.04995392f, 0.02738634f, 
    0.17788421f, 0.10878799f, -0.00604228f, 0.07380962f, 0.62544179f, 0.41059279f, 0.27035084f, -0.29563788f, 
    -0.07898866f, 0.04812857f, -0.09623313f, 0.03002275f, 0.02025867f, 0.14297426f, 0.33798650f, 0.19624773f, 
    -0.03259886f, 0.09153904f, -0.05012473f, 0.13493590f, 0.05992532f, -0.07933506f, 0.02232757f, 0.10439979f, 
    -0.06286976f, 0.14296772f, 0.08384960f, 0.10567936f, 0.24395974f, 0.17445752f, 0.02974277f, -0.08022684f, 
    0.00016517f, -0.07910614f, 0.06362469f, 0.00333640f, 0.04375246f, -0.07485445f, -0.11894114f, 0.08655389f, 
    -0.09067157f, 0.04153363f, -0.31049585f, -0.14379777f, -0.08344807f, 0.06551530f, -0.10354004f, -0.06290218f, 
    0.10474055f, 0.02868870f, -0.05472469f, 0.06820137f, 0.45359030f, -0.57545054f, -0.06033409f, 0.26208249f, 
    -0.15618853f, 0.12538777f, -0.04273138f, -0.00018970f, -0.03664610f, -0.07983454f, -0.02914121f, -0.03874375f, 
    0.04640455f, 0.04024305f, -0.24559182f, -0.01349060f, -0.04605218f, 0.02634072f, 0.01303073f, 0.05831990f, 
    -0.06670505f, 0.03785267f, 0.04841535f, -0.00850736f, 0.26496005f, 0.26954386f, -0.20629722f, 0.14210644f, 
    0.00216862f, 0.10452974f, -0.05287141f, 0.14277442f, 0.03500366f, 0.20930381f, 0.11772899f, 0.15294082f, 
    -0.22902885f, -0.34663460f, 0.06742287f, 0.22602558f, 0.10061574f, 0.09696216f, -0.19095728f, -0.13345116f, 
    0.02829164f, 0.01169385f, -0.00489933f, 0.03798909f, 0.04488548f, 0.07949351f, -0.00866436f, -0.29778126f, 
    -0.12532456f, -0.10313883f, -0.01003030f, -0.13753136f, 0.12377850f, 0.08035912f, 0.05669207f, 0.16907778f, 
    -0.25555646f, 0.07447835f, -0.14081860f, -0.20637347f, -0.05558736f, 0.01571389f, -0.08417118f, -0.15187667f, 
    0.14041352f, -0.07318089f, -0.02546012f, -0.15842982f, -0.00033844f, 0.13898186f, 0.19310434f, 0.49816740f, 
    -0.10535222f, 0.13584158f, 0.23983750f, 0.19232424f, 0.05754123f, 0.04019092f, 0.11558954f, 0.04232554f, 
    -0.17826293f, 0.15915453f, -0.08602294f, 0.13494724f, 0.02552717f, 0.21560374f, 0.29521847f, -0.03036418f, 
    0.16620006f, -0.00841744f, 0.12317342f, -0.06520396f, 0.07524671f, 0.08455086f, 0.06378394f, -0.38982785f, 
    -0.02669948f, 0.03931783f, -0.00122200f, -0.08453444f, -0.02223497f, 0.05646816f, -0.07535756f, -0.19084361f, 
    -0.01452877f, 0.11513963f, 0.07166385f, 0.26614615f, 0.04657509f, -0.10265287f, 0.13369231f, 0.09377544f, 
    -0.02509686f, -0.01187882f, 0.09386403f, 0.09035578f, 0.06135792f, -0.28716990f, -0.09711125f, 0.07050710f, 
    0.02151748f, 0.18893753f, -0.02382418f, -0.04140218f, -0.04513857f, -0.12434034f, 0.10176523f, 0.07062488f, 
    -0.00968287f, 0.09596983f, 0.07700305f, 0.11872645f, 0.14713952f, 0.13578287f, -0.02787398f, -0.12760757f, 
    -0.07474017f, -0.10498094f, -0.00041675f, 0.02449825f, -0.15120220f, -0.12551264f, 0.21414328f, -0.02152147f, 
    -0.09482845f, -0.06503619f, 0.08416185f, 0.03393756f, 0.16306379f, 0.14279203f, -0.23681925f, -0.00494391f, 
    0.00926273f, -0.07064608f, -0.04690538f, 0.07603125f, 0.13272575f, 0.01302687f, -0.08158643f, -0.05183862f, 
    0.19169749f, -0.22638407f, 0.04971952f, -0.20175113f, -0.68563026f, 0.18045449f, -0.03601060f, -0.14247921f, 
    -0.03874645f, 0.08206441f, 0.08180221f, 0.10078808f, -0.15616834f, 0.23479186f, 0.12586658f, -0.06535377f, 
    -0.02023555f, 0.14925902f, 0.16388041f, 0.13881592f, -0.03739364f, -0.02639723f, 0.05999703f, -0.00790962f, 
    0.19744608f, 0.02162072f, 0.05089058f, 0.23272787f, 0.11639392f, -0.14750971f, -0.47765878f, -0.14889026f, 
    0.31853169f, -0.29939497f, -0.10737767f, -0.05655915f, -0.13546377f, 0.01383858f, -0.06315508f, 0.09992438f, 
    -0.05835684f, 0.38338923f, -0.40034148f, -0.53457022f, -0.01311423f, 0.19646184f, 0.02569262f, -0.08017896f, 
    -0.20404997f, -0.23652701f, -0.13196166f, -0.06545339f, -0.05942597f, -0.07373748f, -0.06712715f, -0.24909125f, 
    0.22302289f, -0.07804185f, -0.22095640f, -0.47268844f, -0.01529030f, 0.00617030f, 0.14814030f, -0.14658193f, 
    0.19786125f, 0.05832878f, 0.14344263f, 0.12371301f, -0.29375842f, 0.02877648f, -0.25506103f, 0.01236459f, 
    -0.02078085f, -0.03908662f, 0.08847959f, -0.07250346f, 0.12072689f, 0.30050856f, -0.00575773f, 0.21280497f, 
    0.07203655f, 0.05533519f, 0.00644418f, 0.12531799f, 0.02255067f, 0.10340214f, -0.21606837f, 0.02349792f, 
    0.23808101f, 0.23238972f, 0.24155702f, 0.24514800f, -0.03769169f, 0.04662329f, 0.00369841f, 0.03590106f, 
    0.09968966f, -0.01398338f, -0.04213909f, 0.14278109f, -0.19704072f, -0.10574247f, -0.40842080f, -0.41627294f, 
    0.29966584f, 0.02883854f, 0.25939402f, 0.14404316f, -0.02931824f, -0.26671499f, -0.02159140f, 0.03124148f, 
    0.63932174f, 0.09741767f, -0.02409260f, 0.26178226f, 0.03039407f, -0.22370337f, -0.11115504f, -0.19970898f, 
    0.01643896f, -0.01161548f, 0.02166786f, 0.03089793f, 0.08904784f, 0.25427359f, -0.22408248f, 0.03162045f, 
    0.11611535f, 0.04251397f, 0.06055721f, 0.06783628f, -0.06126899f, 0.06524187f, -0.03248490f, -0.01069847f, 
    -0.13229576f, -0.84779418f, -0.33319488f, -0.30712178f, -0.06646486f, 0.11619586f, -0.00249176f, 0.07215673f, 
    0.02963214f, -0.12891713f, -0.20840392f, 0.03587672f, 0.03795374f, -0.05341579f, -0.60637403f, -0.22599544f, 
    0.21921891f, 0.12280744f, 0.14314035f, 0.34907764f, -0.16771954f, 0.03887280f, -0.02814627f, -0.01199674f, 
    -0.13213278f, 0.10236201f, 0.03384490f, 0.28572774f, -0.00691006f, 0.05221073f, -0.00099043f, -0.02104575f, 
    -0.01691607f, -0.07069250f, 0.10200366f, 0.05985599f, 0.64898598f, 0.26342705f, -0.07049075f, -0.01688399f, 
    0.08540250f, -0.12528747f, -0.04217413f, -0.03412408f, 0.07404667f, 0.18558303f, -0.04748227f, 0.06183327f, 
    -0.44752428f, -0.20341189f, -0.05695296f, 0.13642119f, -0.11698204f, -0.00276028f, 0.19017825f, 0.05754269f, 
    -0.02776539f, 0.01047294f, -0.14517406f, -0.11341309f, 0.60473347f, -0.23435648f, -0.41084287f, -0.04916033f, 
    0.17421900f, 0.08504041f, -0.03344436f, 0.04766360f, -0.07075617f, -0.00716321f, 0.02465526f, -0.10129611f, 
    0.22487657f, 0.02430454f, 0.07068703f, -0.27745730f, -0.05419666f, -0.08745131f, -0.10352343f, -0.19004016f, 
    0.19753601f, 0.14584683f, 0.15071660f, 0.08036619f, 0.43180540f, -0.18797167f, 0.03786121f, 0.32583132f, 
    0.09727990f, 0.00777641f, 0.02213019f, 0.00240003f, 0.00908251f, 0.05330018f, 0.11241078f, 0.34816876f, 
    -0.03144043f, -0.29375285f, -0.13895816f, 0.15652931f, 0.01484339f, -0.03120379f, 0.09348778f, -0.08345164f, 
    -0.25780892f, 0.02039678f, -0.08523043f, 0.09348365f, 0.02277810f, -0.25380266f, 0.17771485f, 0.23270959f, 
    0.09161077f, 0.14419195f, 0.29185632f, 0.04479138f, -0.18114260f, 0.11073293f, -0.09135797f, 0.06170643f, 
    0.03695810f, 0.37349319f, 0.08571015f, 0.18802503f, -0.13322151f, 0.03065518f, 0.07807522f, -0.06700642f, 
    0.07999239f, -0.04110730f, -0.09227444f, -0.06149952f, -0.07673146f, 0.06567902f, 0.23813154f, -0.05025017f, 
    -0.16142058f, 0.02661031f, -0.09688398f, -0.04260262f, -0.10564083f, -0.05633459f, 0.08325957f, 0.20861122f, 
    0.12502627f, 0.10808291f, 0.07565650f, -0.13452676f, 0.15385588f, -0.10886874f, -0.03994516f, -0.03305586f, 
    0.12922692f, -0.06440254f, 0.09771344f, 0.13929394f, -0.07030972f, -0.12649974f, 0.17243910f, 0.29260081f, 
    0.06120886f, 0.18750428f, 0.19195680f, 0.16453263f, -0.06904538f, 0.03900798f, 0.02477261f, -0.02867364f, 
    -0.00019656f, 0.39549473f, 0.53174818f, 0.02131760f, -0.06770375f, -0.08721103f, -0.01522355f, 0.30684972f, 
    -0.06228301f, -0.10634138f, 0.06080995f, 0.05363327f, 0.03330925f, -0.18502401f, 0.07006993f, 0.07395855f, 
    -0.09123048f, 0.12192673f, 0.13720813f, 0.08879928f, 0.05421808f, 0.12803990f, 0.12099138f, 0.06663937f, 
    -0.07054410f, -0.05199917f, -0.04280740f, 0.18140160f, 0.20796686f, 0.12145101f, 0.09597922f, 0.25941360f, 
    -0.14112666f, 0.03348550f, 0.12210061f, 0.02218215f, 0.17935732f, -0.30875885f, 0.23857194f, 0.22740895f, 
    0.08604179f, -0.10591472f, 0.05674484f, 0.02321921f, 0.01252994f, 0.04685244f, -0.09215102f, -0.05536114f, 
    -0.03561969f, -0.00997153f, -0.06087575f, -0.07888115f, -0.19675584f, -0.11220511f, -0.15833595f, -0.18583323f, 
    -0.19593868f, -0.24727863f, -0.24497549f, -0.34418687f, 0.12201673f, 0.36701810f, 0.12688258f, 0.23911710f, 
    -0.23976046f, -0.11961661f, -0.17972219f, -0.23703811f, -0.14348432f, -0.02432691f, 0.18994345f, -0.03157518f, 
    0.08836127f, 0.26464006f, -0.07111411f, -0.26302496f, -0.13680241f, -0.09495634f, 0.28092435f, 0.00313043f, 
    0.04162635f, -0.11846244f, 0.04480276f, 0.06962791f, 0.19507988f, 0.04993014f, -0.07937019f, 0.03468332f, 
    -0.11589129f, -0.06460218f, -0.15443064f, -0.15817611f, -0.00050072f, -0.15564834f, 0.00423696f, 0.08274684f, 
    0.11567731f, 0.03395922f, 0.09043425f, 0.13617329f, -0.01842842f, 0.06764252f, 0.03982585f, 0.04469740f, 
    0.11532757f, 0.04988528f, 0.01846829f, 0.03106823f, 0.21153764f, -0.11286667f, 0.00226011f, 0.32585534f, 
    0.25488806f, 0.02658334f, 0.26091450f, 0.02570042f, 0.01239544f, -0.05493030f, 0.13325027f, 0.24160239f, 
    0.40200436f, -0.01787454f, 0.22367679f, 0.15945052f, -0.08613642f, -0.09030624f, -0.15857694f, 0.08428895f, 
    -0.12185846f, 0.02726499f, 0.29534629f, 0.30045342f, -0.01573263f, 0.02690336f, -0.00196036f, -0.09854025f, 
    -0.14105020f, 0.12748922f, -0.11042842f, 0.03598933f, -0.21676512f, -0.24251939f, -0.12079753f, -0.23838404f, 
    -0.42785448f, 0.21283960f, -0.18766469f, 0.09943169f, 0.06846064f, 0.09156314f, -0.00527064f, 0.29986474f, 
    0.03601804f, 0.03978235f, 0.12962762f, -0.05390061f, 0.29891539f, -0.01323273f, 0.30905369f, 0.25398389f, 
    0.02865810f, 0.03876702f, 0.06773910f, 0.13263962f, 0.22115655f, 0.21998107f, 0.16051716f, 0.04435169f, 
    0.31603998f, 0.30868292f, 0.07182407f, 0.14687106f, -0.12961693f, -0.10104237f, 0.08150672f, -0.08055937f, 
    -0.13786919f, -0.09066347f, -0.03286726f, -0.05115701f, -0.30136713f, -0.11579028f, -0.40755361f, -0.10068230f, 
    -0.04188652f, -0.07005648f, 0.08006257f, 0.06959241f, 0.14336380f, -0.06751734f, -0.04540746f, -0.15550466f, 
    0.32489964f, 0.34587070f, 0.46132979f, 0.00030087f, 0.01195866f, -0.09550662f, 0.04952613f, -0.16264604f, 
    -0.13193992f, -0.13127540f, -0.08958559f, -0.03474874f, 0.09202999f, 0.24535888f, 0.37027824f, -0.10285784f, 
    -0.16268766f, -0.10506847f, 0.18694796f, 0.17146562f, 0.10148049f, 0.09410895f, 0.05423167f, 0.07229488f, 
    -0.13133085f, -0.04618043f, 0.14169025f, -0.06803828f, -0.02278141f, -0.18065506f, 0.05380425f, 0.19872582f, 
    -0.04803499f, -0.05001858f, 0.03049435f, -0.05180959f, 0.03121564f, -0.14595598f, -0.05607158f, 0.02434718f, 
    -0.05266204f, 0.07765076f, 0.00409659f, 0.20742124f, -0.04420360f, -0.07833825f, -0.02724247f, 0.02648419f, 
    0.05840949f, 0.12681305f, 0.15584967f, 0.12041645f, -0.05396061f, 0.02859750f, 0.06964979f, -0.01755150f, 
    -0.04290424f, 0.06575129f, 0.07618411f, 0.06810937f, -0.36899740f, -0.35139838f, 0.04145680f, -0.00640787f, 
    0.12691323f, -0.07899385f, 0.00216986f, 0.16817699f, -0.02455601f, 0.24648193f, -0.05345042f, 0.00562433f, 
    0.03645755f, -0.22317535f, -0.04766245f, 0.14943214f, 0.12378252f, 0.16689445f, 0.11101316f, -0.24588442f, 
    0.10749114f, 0.05886096f, -0.04660103f, 0.01120264f, 0.07248607f, 0.04805142f, 0.03934128f, 0.26543412f, 
    0.28896239f, 0.15423523f, -0.01131416f, -0.04247838f, -0.02230681f, -0.03828350f, -0.05863380f, 0.02294309f, 
    -0.35769531f, -0.27215430f, -0.00966410f, -0.11483216f, 0.02083773f, -0.09482567f, -0.11984774f, 0.08512249f, 
    0.08004919f, 0.15252353f, 0.01133881f, 0.00460606f, 0.16057545f, 0.59328753f, 0.05664731f, 0.26887035f, 
    0.10116277f, 0.13301052f, -0.02351668f, -0.06794796f, -0.17044149f, -0.12751497f, 0.03901514f, 0.00485851f, 
    0.10614564f, 0.13666596f, 0.19005722f, 0.06265187f, 0.09477568f, 0.14506556f, 0.05582976f, 0.07990088f, 
    -0.03174589f, 0.18231846f, 0.03560721f, -0.08649129f, 0.15981847f, 0.09754196f, 0.18016928f, 0.08290349f, 
    0.11169934f, 0.22037542f, -0.03445071f, -0.03750270f, 0.04182766f, 0.07402679f, 0.03055398f, -0.10024793f, 
    0.23352945f, 0.49854705f, -0.13061483f, -0.02079241f, 0.02940669f, -0.17478484f, -0.01767817f, -0.03346192f, 
    -0.01170277f, 0.06485739f, 0.00550693f, -0.10114779f, -0.25806895f, -0.40506333f, 0.09127928f, -0.11157785f, 
    0.04756569f, 0.08509208f, 0.00019925f, 0.15100604f, 0.01944498f, 0.14772597f, 0.07363741f, -0.14631726f, 
    -0.46139523f, -0.35116237f, -0.16637476f, -0.07692042f, 0.03846508f, 0.13005674f, -0.10335530f, 0.05916068f, 
    0.00522341f, 0.02113338f, 0.11517031f, 0.10586437f, 0.25430605f, 0.15962349f, 0.02465245f, 0.02733198f, 
    0.06146203f, 0.17370032f, 0.14300941f, 0.05389583f, -0.04235474f, -0.18564099f, -0.00510644f, -0.07822627f, 
    -0.07718905f, -0.38612571f, 0.14862348f, -0.08337630f, 0.02347450f, 0.03817579f, -0.25972226f, -0.01230670f, 
    -0.07557103f, 0.06606209f, 0.04712204f, 0.03753831f, -0.23922761f, -0.16999878f, -0.23850158f, -0.03885674f, 
    0.02336294f, 0.04004075f, 0.08626644f, 0.04535259f, 0.12493940f, 0.14816779f, -0.06702162f, -0.10282202f, 
    0.34930632f, 0.30822462f, 0.02315826f, 0.03497742f, 0.08570078f, 0.24702598f, 0.06057338f, -0.02580057f, 
    0.12170467f, -0.01141179f, -0.09219025f, -0.15915971f, 0.03552016f, 0.38014120f, 0.05667670f, 0.01180830f, 
    0.05133212f, -0.05790490f, 0.06626587f, 0.18273345f, -0.10217475f, -0.11917066f, -0.17903385f, -0.05473061f, 
    0.03077621f, -0.11925340f, -0.00711518f, -0.20653085f, 0.14160343f, -0.10936031f, -0.11463766f, 0.13371398f, 
    -0.18671925f, -0.09243996f, -0.16179605f, -0.35252056f, -0.01787302f, 0.61672622f, 0.14445633f, 0.22499160f, 
    -0.19927400f, 0.05752813f, -0.15207714f, -0.19473188f, 0.14228240f, -0.15144104f, -0.04396159f, 0.07125578f, 
    -0.04795215f, 0.55654651f, 0.44053668f, -0.13947350f, -0.05166904f, -0.06895838f, -0.07033892f, -0.09974215f, 
    0.03827782f, 0.20700061f, -0.07318727f, 0.09507333f, -0.08446253f, 0.41112444f, 0.31477666f, 0.08057324f, 
    -0.18501544f, -0.01434563f, 0.09998559f, 0.00797430f, 0.03186134f, -0.06921525f, -0.06590770f, 0.10714455f, 
    -0.26104739f, 0.04383454f, -0.34632707f, 0.12438035f, 0.00885444f, 0.17357518f, 0.17081702f, -0.27594170f, 
    0.12087332f, 0.08939522f, 0.22370072f, 0.21871670f, -0.29735798f, -0.13840403f, 0.13323919f, -0.02424127f, 
    -0.05031687f, -0.09274665f, -0.08918305f, 0.08654390f, 0.16338551f, -0.00668112f, 0.08821977f, -0.06477367f, 
    0.05872234f, 0.08067346f, 0.25654075f, 0.32350600f, -0.03514358f, -0.12218168f, -0.02338827f, 0.03563856f, 
    0.15618071f, -0.04992534f, 0.00194757f, 0.09365755f, -0.03450469f, 0.40901899f, -0.12397582f, -0.00535478f, 
    -0.02410361f, -0.15447815f, 0.00068898f, -0.09487391f, -0.09048741f, -0.27759308f, -0.02524497f, -0.16717619f, 
    -0.08374794f, -0.55775440f, 0.19073482f, -0.11923507f, 0.02795339f, 0.13613896f, -0.15865093f, 0.06112920f, 
    0.08639470f, -0.00120406f, 0.07753495f, -0.01420415f, 0.15214102f, 0.13339852f, -0.25136685f, 0.03376424f, 
    -0.00959559f, 0.00255391f, 0.14016038f, -0.18303749f, 0.17910610f, 0.08001672f, -0.00506314f, 0.15083790f, 
    -0.03693323f, -0.00766625f, -0.17963289f, 0.01522309f, -0.10234918f, -0.05315212f, -0.12828788f, -0.22682117f, 
    -0.13408503f, -0.05778103f, -0.00488723f, 0.03372259f, -0.13354006f, -0.04061192f, 0.16581236f, -0.02935288f, 
    -0.07823227f, -0.05856766f, 0.02031840f, -0.04466795f, 0.15072334f, 0.19371077f, 0.04750085f, -0.08893309f, 
    -0.26571572f, 0.40547600f, -0.25164977f, -0.05840443f, 0.14150409f, 0.17607065f, -0.00339740f, -0.23859063f, 
    -0.05859128f, -0.21412751f, -0.16707955f, 0.03535175f, 0.11423293f, 0.32003117f, -0.04349933f, 0.00212762f, 
    -0.11942213f, -0.09647827f, 0.01075310f, -0.08383346f, -0.11689128f, -0.00996797f, 0.03480859f, -0.03379959f, 
    0.03583921f, 0.18403897f, 0.32375142f, 0.07617095f, -0.09296453f, -0.17598037f, 0.02754040f, -0.00863679f, 
    0.03056187f, 0.08855273f, -0.06179862f, -0.08390847f, -0.17708680f, 0.02462138f, -0.07784504f, 0.08477186f, 
    0.01449833f, 0.15657358f, -0.02497326f, -0.00418342f, 0.05372314f, 0.13802058f, 0.16704746f, 0.14177769f, 
    -0.22404628f, -0.00679596f, 0.11924098f, -0.20063557f, 0.01507870f, 0.09819546f, -0.05560901f, 0.10164988f, 
    -0.22804382f, -0.16952710f, -0.20954961f, -0.63028854f, -0.00915399f, -0.37736636f, 0.43813649f, -0.29795876f, 
    -0.07157018f, -0.01463608f, 0.17695877f, -0.04597482f, 0.09536003f, -0.07523886f, -0.12834929f, 0.02482398f, 
    -0.21049450f, -0.25656390f, -0.26740190f, 0.34791499f, -0.11428062f, -0.06670099f, -0.13132933f, -0.14237633f, 
    0.08015110f, 0.05073757f, -0.07864477f, 0.19080576f, 0.31629431f, 0.20175514f, -0.13688664f, -0.01037402f, 
    -0.01872652f, -0.20530434f, -0.00359752f, -0.26514885f, 0.24697772f, 0.17461143f, -0.11318475f, 0.03673639f, 
    -0.06609535f, -0.20181967f, 0.21606405f, 0.13620096f, -0.26192126f, -0.10967678f, 0.10375842f, -0.24358898f, 
    -0.12372923f, -0.03555427f, -0.06023871f, -0.01720721f, 0.25470647f, -0.11679211f, -0.11612180f, 0.06244338f, 
    -0.00240348f, 0.27875340f, -0.02183996f, 0.11109544f, 0.02749995f, 0.05614666f, 0.08300228f, 0.13549444f, 
    0.37913698f, 0.12494433f, -0.10792258f, 0.12879770f, -0.02672123f, 0.09543512f, -0.01177987f, -0.27456281f, 
    0.21510699f, 0.20687921f, 0.05733196f, 0.29901591f, 0.00694409f, -0.13875204f, 0.22530544f, 0.05466718f, 
    0.16740479f, 0.11766366f, 0.01409968f, 0.06318387f, -0.02500552f, -0.20434429f, -0.14008838f, -0.33295399f, 
    0.42157561f, 0.33076596f, 0.10530697f, 0.07993273f, 0.01207965f, 0.11716019f, 0.39568070f, -0.01649848f, 
    0.04481640f, -0.05294528f, -0.17664884f, -0.07429682f, -0.41089705f, -0.37736061f, 0.18530656f, 0.27609056f, 
    -0.03942261f, -0.05629151f, 0.20420592f, -0.01056260f, -0.00061166f, -0.12576410f, -0.03206956f, 0.18604669f, 
    -0.29632974f, -0.06319606f, 0.10515888f, -0.06910399f, 0.10176627f, 0.03044623f, -0.24121232f, -0.16454487f, 
    -0.21449065f, -0.21957731f, -0.26716167f, -0.21632621f, 0.44026721f, 0.18724108f, -0.19673409f, 0.08435691f, 
    -0.12325766f, 0.16054237f, -0.06389136f, 0.12176286f, 0.15310653f, 0.13116683f, 0.20298354f, -0.07331835f, 
    -0.02116687f, -0.20767051f, 0.03879526f, 0.62385565f, 0.17940013f, -0.13319659f, -0.20343207f, 0.30709174f, 
    -0.10331391f, -0.23504588f, 0.05016078f, -0.24125020f, -0.55044013f, -0.50121963f, 0.30081683f, -0.05453451f, 
    -0.00700997f, -0.23846756f, -0.26677081f, -0.02517202f, 0.00861100f, 0.02611900f, -0.01461200f, -0.10001623f, 
    0.21408869f, -0.07709872f, -0.14103885f, 0.03632478f, 0.07322682f, -0.09201716f, -0.04349517f, 0.08212455f, 
    -0.06300204f, 0.03555071f, -0.08271101f, -0.06554682f, 0.20888723f, 0.19399926f, -0.03137957f, -0.11117826f, 
    0.10576262f, -0.03221045f, 0.00472004f, 0.08302986f, -0.11200825f, -0.07938255f, -0.07049000f, 0.04140500f, 
    -0.03338107f, -0.05618478f, 0.00041495f, -0.05660149f, -0.03040762f, 0.02700089f, 0.01979163f, -0.00419610f, 
    -0.02472329f, -0.02208431f, -0.05069461f, -0.05402314f, -0.06309024f, -0.07131031f, -0.00614084f, -0.07216451f, 
    -0.00992418f, 0.03232184f, -0.02303972f, -0.06104458f, 0.06087359f, -0.03827520f, -0.01198174f, -0.05039985f, 
    0.01395994f, 0.03005544f, 0.05377663f, -0.07216770f, 0.02037247f, 0.01067338f, 0.05632525f, -0.00905791f, 
    -0.02913938f, -0.06695955f, 0.04046790f, -0.01036188f, -0.04877663f, -0.00795406f, 0.01455698f, 0.02960375f, 
    0.05473830f, -0.07100763f, 0.02660836f, -0.01141139f, -0.06239102f, 0.02243610f, -0.00913401f, 0.00122538f, 
    -0.05683173f, -0.05084155f, 0.04043103f, 0.00927768f, 0.04604289f, -0.04409718f, 0.03112377f, -0.02328520f, 
    0.01353104f, -0.06315587f, -0.00575940f, 0.01219674f, -0.05267209f, -0.03933136f, 0.00512347f, -0.02762017f, 
    -0.06435474f, -0.06356522f, 0.04167611f, -0.02858032f, -0.05395719f, -0.02709990f, 0.02735665f, -0.01721162f, 
    -0.07168513f, -0.00640383f, 0.00948186f, 0.05429770f, 0.01556654f, -0.03870236f, -0.00518580f, 0.00901456f, 
    0.00225540f, -0.06276389f, 0.00847588f, -0.07145121f, 0.01032553f, 0.01835048f, -0.06561073f, 0.06405960f, 
    -0.01807071f, -0.02600088f, -0.00205947f, -0.04642585f, 0.03959263f, 0.03954851f, -0.01110330f, 0.00025803f, 
    -0.03412348f, 0.03682438f, -0.04802324f, -0.07393773f, -0.00063460f, -0.03291248f, -0.00890804f, -0.07520899f, 
    -0.05195447f, 0.05884852f, 0.03185109f, -0.05237612f, 0.04982749f, -0.00285674f, 0.04346231f, -0.04777132f, 
    -0.03225305f, 0.01497503f, 0.05656222f, -0.01052504f, -0.07219782f, -0.07496258f, -0.06310500f, 0.01157096f, 
    0.06422228f, -0.06912941f, 0.03656335f, -0.06698648f, -0.02323586f, 0.04091442f, -0.06891587f, -0.05739694f, 
    -0.05800605f, 0.01189441f, 0.02934986f, -0.05052527f, -0.06857833f, -0.02552237f, -0.03913283f, -0.03827484f, 
    0.06179594f, -0.04481381f, 0.06051845f, -0.00387764f, -0.05455410f, -0.03650693f, 0.05411296f, -0.04125997f, 
    0.01888573f, -0.07863759f, -0.05150425f, 0.00830117f, 0.03626962f, -0.00159485f, -0.02664230f, 0.03617484f, 
    -0.01451126f, 0.02024280f, -0.01342223f, 0.05485738f, -0.03013630f, 0.01827417f, -0.06099393f, 0.02157581f, 
    0.06114436f, -0.07288766f, 0.05389125f, 0.05009355f, 0.04776926f, -0.03946983f, -0.05613696f, -0.00589513f, 
    0.05803612f, 0.05853068f, -0.05285386f, -0.01914292f, -0.04862257f, -0.03893838f, 0.01772913f, -0.07320040f, 
    -0.06612441f, -0.02935127f, -0.06063839f, -0.00943926f, -0.04449511f, 0.06240009f, 0.02989548f, 0.04796870f, 
    0.03246809f, -0.04628091f, 0.03179953f, 0.03924952f, -0.04539585f, -0.05238404f, 0.00421121f, 0.00101482f, 
    0.20264405f, -0.15117441f, -0.02911969f, -0.04741557f, 0.21210785f, 0.13744272f, -0.15582301f, -0.03353450f, 
    0.10306148f, -0.08004896f, 0.12277803f, 0.11177951f, 0.02295407f, 0.02870745f, -0.36514902f, 0.09571847f, 
    0.12000098f, -0.02068200f, -0.02581381f, 0.05065253f, 0.11404075f, 0.02052491f, -0.17585462f, -0.09719005f, 
    -0.34481081f, 0.11528613f, -0.03745292f, 0.01462595f, 0.04096439f, -0.12765823f, -0.11479191f, 0.19931784f, 
    0.06898788f, 0.04220960f, -0.01163245f, -0.06170924f, 0.04632561f, -0.22953984f, 0.16495049f, 0.11739161f, 
    0.05926458f, 0.02949504f, 0.10700031f, 0.20511198f, -0.02485755f, 0.02350409f, 0.03297501f, -0.15377413f, 
    0.18491939f, -0.14698879f, -0.04393097f, 0.02197887f, 0.06083126f, 0.05198900f, 0.01436396f, 0.05712344f, 
    -0.15496115f, 0.03100851f, 0.06515892f, 0.06655455f, -0.06438523f, -0.18842602f, -0.00024811f, -0.39769539f, 
    -0.05900195f, -0.00809715f, 0.41368002f, 0.16405757f, -0.07865592f, 0.01510914f, 0.13775045f, 0.15868297f, 
    -0.23648171f, -0.18382145f, 0.08464291f, 0.10166153f, 0.13503650f, -0.10160211f, 0.08035833f, -0.09792352f, 
    0.18310814f, 0.11681580f, -0.03537513f, 0.13489771f, -0.21364076f, -0.23985031f, -0.17442165f, 0.10130773f, 
    0.07928825f, -0.10389667f, -0.02058366f, -0.16448514f, -0.02727064f, 0.11552890f, -0.20476943f, 0.05580100f, 
    0.02170887f, 0.09133700f, 0.49810955f, 0.16551216f, 0.00017101f, 0.15020645f, 0.13283296f, 0.12994370f, 
    0.00035108f, 0.04867725f, -0.33102080f, 0.06743053f, -0.40321481f, 0.11540096f, -0.11830109f, 0.04277012f, 
    0.05245402f, 0.05118934f, -0.05110555f, -0.31557459f, 0.03168258f, 0.12421487f, 0.04942365f, -0.02631764f, 
    -0.14169256f, -0.23234841f, 0.08209290f, -0.29608345f, 0.12269400f, -0.12772542f, 0.03264151f, 0.14583062f, 
    -0.01226135f, 0.19983888f, 0.10478708f, 0.18466036f, 0.28143483f, 0.17520948f, 0.20157366f, -0.02123523f, 
    0.18341015f, 0.07563917f, -0.12308518f, -0.03583498f, -0.15438782f, 0.05689430f, -0.05570116f, -0.08115096f, 
    -0.46296695f, 0.45226526f, -0.19429277f, 0.40020698f, 0.00116648f, 0.19688219f, 0.10604780f, 0.12430162f, 
    -0.00624143f, -0.06569035f, 0.06686978f, 0.06597701f, 0.07806709f, -0.47319466f, -0.00009431f, 0.39820921f, 
    -0.06043886f, 0.12141580f, -0.14232112f, -0.33685544f, 0.07766783f, -0.01487061f, 0.31464654f, 0.18428405f, 
    0.04777882f, -0.29562497f, -0.13757126f, 0.21719112f, 0.18166168f, -0.06494206f, -0.00628307f, 0.10868560f, 
    0.05160863f, -0.12920201f, 0.16013084f, 0.19087748f, 0.16202115f, -0.25385085f, 0.37700656f, 0.15208544f, 
    -0.06904273f, -0.01966042f, 0.21019541f, -0.05579283f, 0.01693965f, 0.13552542f, 0.07507268f, 0.04784088f, 
    0.08619311f, -0.11653320f, -0.15695858f, -0.07136134f, 0.02644109f, -0.11718631f, 0.08654619f, 0.14002207f, 
    -0.07322636f, -0.22058064f, -0.30523649f, -0.35743037f, -0.05053541f, 0.30286986f, -0.05326091f, 0.05409091f, 
    -0.07168117f, 0.00524430f, 0.10154588f, -0.15594371f, 0.01723276f, -0.04700905f, 0.00058814f, 0.12822421f, 
    0.16685762f, 0.38667327f, 0.12786895f, -0.12524594f, -0.05122479f, 0.00370144f, 0.09168711f, 0.07480629f, 
    0.14284208f, 0.05883712f, -0.12908950f, 0.04341051f, -0.11627448f, 0.34044898f, 0.19793519f, 0.17249905f, 
    -0.14870432f, 0.01012806f, 0.05763327f, 0.04171465f, 0.21176822f, 0.12022941f, -0.11863799f, 0.13449183f, 
    0.07324289f, -0.02671408f, -0.08154701f, -0.02812169f, -0.11469491f, 0.08754507f, 0.11370508f, 0.03629728f, 
    0.07834887f, 0.09359289f, -0.08092031f, 0.06949598f, -0.24140596f, -0.23342618f, 0.15442441f, 0.13225502f, 
    0.02847121f, -0.01086141f, -0.01378099f, 0.14824343f, 0.13011228f, 0.07165892f, 0.22325271f, 0.18611591f, 
    -0.24632068f, -0.06319602f, 0.04524598f, 0.33646715f, -0.01919329f, -0.13420242f, 0.09867445f, 0.04694644f, 
    0.06924205f, 0.03407968f, 0.11909027f, 0.29731268f, 0.01674964f, 0.13418694f, 0.00969023f, 0.01898883f, 
    -0.00461647f, -0.17945632f, 0.16474806f, 0.00258541f, -0.07766927f, -0.24929586f, -0.24177714f, -0.18176630f, 
    -0.37222311f, -0.31531549f, -0.01620350f, 0.20331056f, 0.05298014f, 0.01809659f, -0.06144093f, -0.13450861f, 
    -0.01488358f, 0.00211247f, 0.01347100f, 0.10384092f, 0.31416512f, -0.05365380f, -0.13858049f, 0.02722278f, 
    0.03756140f, -0.01379621f, 0.12477949f, -0.10931491f, 0.16660951f, -0.01720915f, 0.09052213f, 0.04273184f, 
    0.21082258f, 0.02925557f, -0.27009714f, -0.09011924f, -0.08316159f, 0.02439422f, 0.12243082f, -0.00436710f, 
    -0.07286517f, 0.01845247f, -0.02362088f, -0.10163320f, -0.27522075f, -0.06394219f, 0.02263066f, -0.08082779f, 
    -0.16649790f, -0.11755706f, 0.00449342f, -0.00780108f, 0.10401276f, 0.07061443f, -0.01772473f, -0.11611261f, 
    0.31551901f, 0.09281490f, 0.40718293f, -0.31605810f, 0.16881290f, -0.04775075f, 0.02457836f, -0.11562256f, 
    -0.01591596f, 0.02040260f, -0.14218093f, -0.16407497f, 0.15185335f, 0.13871118f, 0.21068633f, 0.08524773f, 
    0.00202747f, -0.21450900f, 0.06516114f, 0.11654674f, 0.11267942f, 0.03746319f, 0.08868407f, 0.00962354f, 
    -0.20932874f, 0.32943374f, 0.46157661f, 0.12295554f, -0.09161755f, -0.14463611f, 0.04543627f, 0.13317756f, 
    -0.01405549f, 0.23347893f, 0.05782232f, 0.01716237f, -0.22682551f, -0.19704376f, -0.07044545f, 0.09067245f, 
    -0.05258588f, -0.08368477f, -0.04758070f, -0.13531312f, 0.04752339f, -0.03652025f, 0.11571985f, 0.10924694f, 
    0.01551670f, -0.06621118f, 0.09254854f, -0.15164554f, 0.13052206f, 0.13476726f, 0.12559140f, 0.05543161f, 
    -0.17366512f, -0.15704624f, -0.16318469f, -0.22922806f, -0.44995373f, 0.16892089f, 0.12738226f, 0.27649161f, 
    0.09253704f, -0.09070298f, 0.04170624f, 0.00152528f, -0.04534863f, 0.01589932f, -0.22934015f, 0.12197983f, 
    -0.00589404f, 0.03001324f, 0.08300973f, -0.30841818f, -0.18015766f, -0.03915289f, 0.01511989f, 0.03753822f, 
    0.02638479f, -0.11670071f, 0.08532340f, 0.03687041f, -0.17898758f, 0.29526222f, 0.04602825f, -0.19273728f, 
    -0.05831583f, 0.04699622f, 0.04236213f, 0.00081229f, 0.11441447f, 0.14483568f, 0.07811830f, 0.12242094f, 
    -0.02519598f, -0.04279912f, 0.08920483f, 0.18372717f, 0.04210357f, 0.10218707f, 0.02932981f, -0.01361054f, 
    0.10757389f, 0.10072100f, 0.01786102f, 0.06170269f, -0.32932416f, 0.32515502f, 0.07539267f, -0.11393287f, 
    0.18806557f, -0.02961422f, -0.12902598f, 0.16384578f, 0.08508457f, -0.07649887f, 0.20820688f, 0.35330003f, 
    -0.10620673f, 0.13987269f, 0.31701460f, 0.38261953f, -0.01136097f, -0.17945203f, -0.02761786f, -0.04947120f, 
    -0.14773545f, -0.09819584f, -0.00403484f, 0.24052139f, 0.02349119f, 0.09572507f, 0.24289729f, -0.11936010f, 
    0.06971407f, 0.08413371f, 0.16052945f, -0.05206339f, -0.07336920f, -0.38663462f, -0.04624632f, -0.16929942f, 
    -0.05351079f, 0.00513314f, 0.21629854f, -0.01592988f, -0.10212416f, 0.02561996f, 0.03467942f, 0.10373908f, 
    0.16954665f, 0.04625124f, 0.01326726f, -0.04612032f, 0.27576855f, 0.02916988f, 0.02463496f, 0.36410546f, 
    0.00165382f, 0.04120770f, 0.00749142f, 0.08056242f, 0.01037574f, -0.06581353f, 0.21658307f, -0.10536843f, 
    0.28474525f, -0.04667829f, 0.09712748f, 0.17306581f, -0.02113627f, -0.07802849f, 0.07193222f, 0.01841646f, 
    -0.11657200f, 0.09642377f, -0.11024993f, 0.02864703f, 0.03867802f, 0.11825540f, 0.05851586f, -0.01769145f, 
    0.17574917f, 0.01038659f, -0.08961852f, -0.11341733f, 0.05088539f, -0.04012045f, 0.00383101f, -0.11382672f, 
    0.50308132f, -0.11323361f, 0.12533444f, 0.06381181f, -0.00915117f, -0.12127504f, 0.00732821f, 0.05949613f, 
    0.03111358f, -0.04638352f, -0.13272914f, 0.01697264f, 0.16443519f, 0.03509983f, 0.01435618f, 0.31132635f, 
    -0.00699364f, 0.00702750f, 0.24158742f, 0.22285098f, 0.05083232f, 0.02182168f, 0.09861805f, 0.20567682f, 
    0.09587097f, 0.01605355f, 0.14287257f, -0.42466128f, 0.05711643f, 0.01597765f, -0.04532677f, 0.10985928f, 
    -0.11615282f, -0.09179588f, -0.15173706f, 0.03686721f, -0.11542648f, 0.31805128f, -0.08099777f, -0.06065270f, 
    -0.02410294f, -0.20012310f, 0.15229267f, 0.09015781f, -0.01797116f, -0.00590945f, 0.02348880f, 0.00423568f, 
    0.01879686f, -0.04510945f, -0.05445167f, 0.01507567f, 0.08636934f, -0.08816565f, 0.18342760f, -0.05818850f, 
    -0.06750976f, -0.02245085f, -0.02593204f, 0.09196901f, 0.14769042f, -0.09023345f, 0.57680887f, -0.08961679f, 
    -0.17249832f, 0.12346697f, -0.13974047f, 0.16643335f, 0.14304052f, 0.20329379f, 0.07351249f, -0.04878212f, 
    0.19469659f, 0.23939852f, -0.12887277f, -0.02938345f, 0.01267655f, -0.09836869f, -0.08559393f, 0.03057710f, 
    0.14519423f, -0.02033328f, -0.10438369f, -0.01470896f, -0.42675000f, 0.41463020f, 0.41938841f, 0.04800533f, 
    -0.08240868f, 0.14370017f, 0.29978856f, 0.17724331f, 0.04399502f, 0.24881473f, 0.00809379f, -0.06962316f, 
    -0.29532614f, 0.04396680f, -0.12307603f, 0.20253302f, -0.20146967f, -0.10460553f, -0.04562873f, -0.13958213f, 
    0.10781796f, 0.21248509f, 0.05631551f, 0.18529153f, 0.41136169f, -0.58866942f, 0.11260525f, 0.17303963f, 
    0.13945685f, -0.03384896f, 0.02743954f, 0.14453617f, -0.12823409f, -0.04266164f, -0.00736444f, -0.06581273f, 
    -0.20099624f, 0.38908619f, -0.04155296f, 0.02237151f, 0.06292322f, 0.06599836f, 0.04556914f, 0.12023096f, 
    -0.04783380f, 0.07255352f, 0.13658720f, -0.05971393f, 0.06581432f, 0.23738191f, -0.19614619f, -0.03741501f, 
    0.05428834f, -0.05481870f, -0.15385112f, -0.08655758f, 0.08768208f, -0.07693771f, -0.07348612f, -0.06928062f, 
    -0.28081813f, -0.16796525f, 0.25919068f, 0.39181486f, 0.05831115f, 0.18146209f, -0.01478293f, -0.00947266f, 
    0.16477391f, -0.05001243f, -0.12915039f, 0.06659587f, 0.30882937f, 0.30488977f, -0.14732118f, 0.24625337f, 
    -0.08197588f, -0.15922908f, -0.09488366f, -0.00717944f, -0.03000130f, 0.02891203f, 0.25170770f, 0.24442881f, 
    -0.04829443f, 0.14598644f, -0.12413725f, 0.14038466f, -0.20370950f, -0.03452047f, 0.00065502f, 0.11807144f, 
    0.02887924f, 0.10264783f, 0.03654877f, -0.03515154f, -0.05764069f, 0.05451373f, 0.03007783f, 0.32920501f, 
    -0.04218305f, 0.10304546f, 0.06260490f, -0.02656155f, 0.16507703f, -0.02165701f, -0.00876640f, -0.02192212f, 
    0.48455226f, -0.30784750f, 0.00846885f, 0.24687260f, 0.22444367f, 0.05423509f, 0.20501485f, -0.25902903f, 
    0.03653006f, -0.07717716f, 0.11114740f, -0.07797241f, 0.21896847f, 0.48316830f, -0.14591676f, 0.02609929f, 
    0.00667528f, -0.02825242f, -0.06055353f, -0.20420480f, 0.11105690f, 0.06145273f, 0.06343098f, -0.02793659f, 
    -0.05625627f, 0.50282925f, 0.15519670f, 0.43567911f, 0.03168126f, 0.13647290f, 0.21238279f, 0.09284992f, 
    0.25703657f, 0.04458562f, 0.10072084f, 0.04385870f, 0.07621069f, -0.10800217f, -0.21406513f, -0.06670096f, 
    0.28866369f, 0.34039193f, 0.16262034f, 0.18511721f, -0.07177217f, -0.01578479f, 0.19207452f, 0.01896599f, 
    0.03163258f, -0.14482622f, -0.14915758f, -0.13110247f, 0.07355966f, -0.03668124f, 0.29989195f, -0.02535843f, 
    0.00032900f, 0.07719486f, -0.09988019f, -0.03619058f, -0.05690257f, 0.35582760f, 0.01225424f, 0.38910189f, 
    -0.04480275f, -0.01380992f, 0.01365905f, -0.18844613f, -0.07674811f, 0.02861050f, 0.34768221f, 0.06869957f, 
    0.19441824f, 0.37298730f, 0.14379951f, -0.22747928f, -0.05925877f, -0.13318835f, -0.08719517f, -0.25312936f, 
    0.09661201f, 0.12863527f, -0.04870209f, 0.16987461f, 0.18772091f, 0.28398532f, 0.56372869f, 0.16745776f, 
    -0.09918611f, -0.03911314f, -0.06878972f, -0.16516036f, 0.18057008f, 0.05198022f, 0.12400357f, 0.21537310f, 
    -0.05609035f, 0.05827028f, -0.09672257f, 0.01870692f, -0.12967461f, 0.09152458f, 0.11986854f, 0.03291026f, 
    -0.06464644f, -0.02952354f, -0.09997494f, -0.07746334f, -0.53507704f, 0.14186759f, 0.12854657f, 0.06490151f, 
    0.20991242f, -0.06281491f, 0.17381121f, 0.23671675f, 0.14677580f, -0.10341500f, 0.05945287f, 0.04941922f, 
    0.17330624f, -0.03110390f, 0.45419285f, 0.17045031f, 0.05106436f, -0.06867709f, -0.02597803f, 0.03234484f, 
    0.15453927f, 0.01468131f, 0.09901112f, 0.10412019f, 0.01344888f, 0.02261077f, -0.23322487f, -0.12169817f, 
    -0.18197398f, 0.13832727f, -0.13024096f, 0.20514163f, 0.06253249f, -0.01024280f, -0.03273436f, -0.10960243f, 
    -0.41444245f, -0.37601635f, -0.25548461f, 0.00518390f, 0.14346068f, -0.00009716f, -0.03030077f, 0.10855028f, 
    0.09102922f, 0.12230528f, 0.06665696f, 0.05038707f, 0.29903182f, -0.13048206f, 0.00429087f, 0.23900793f, 
    0.05548337f, -0.01105841f, -0.01819813f, -0.00002932f, 0.16318291f, -0.14687712f, 0.00768976f, 0.14035617f, 
    0.01104523f, 0.06726957f, -0.19470689f, 0.06946108f, -0.10930634f, 0.03035327f, 0.08632686f, -0.05717202f, 
    -0.08879741f, 0.02642932f, -0.06806948f, -0.16675586f, -0.49814641f, -0.15047914f, -0.38799223f, -0.19420585f, 
    0.11968515f, -0.07498237f, -0.01698918f, -0.17127638f, 0.13902004f, 0.07852000f, -0.15863480f, 0.00844273f, 
    -0.10716220f, 0.34342659f, -0.36473045f, -0.24916252f, 0.28388914f, 0.25091189f, 0.01048452f, 0.06068936f, 
    0.14078882f, -0.03775270f, -0.14840719f, -0.05723083f, 0.06772492f, 0.28482181f, 0.20805588f, -0.10948209f, 
    -0.11625186f, 0.12135216f, 0.08930991f, 0.01342185f, 0.06407194f, -0.00660077f, 0.04939213f, -0.06797462f, 
    -0.23281953f, 0.16799280f, 0.26258972f, -0.25360039f, 0.08222388f, -0.06543716f, 0.08165307f, 0.04347741f, 
    0.00950085f, 0.11476971f, 0.09980958f, -0.03949183f, -0.20238163f, 0.08428460f, -0.09028933f, 0.00404983f, 
    -0.08763684f, 0.18561161f, -0.17270401f, 0.14299360f, -0.16434403f, -0.05654790f, -0.01074898f, -0.07293867f, 
    -0.21158957f, 0.06626573f, -0.04171440f, 0.03423766f, 0.01352536f, 0.24873476f, -0.02228281f, -0.05938762f, 
    -0.09030313f, 0.13967635f, 0.11213398f, 0.10186435f, -0.30639741f, -0.40203628f, 0.01456255f, 0.06406470f, 
    0.01761706f, 0.05771607f, 0.00128121f, 0.08955006f, 0.24586187f, 0.10247697f, 0.04255887f, -0.11401153f, 
    -0.01068615f, -0.29145023f, -0.24565557f, -0.16754261f, -0.07788191f, 0.10771036f, 0.15160504f, 0.13226116f, 
    0.18407927f, -0.05082918f, -0.02531380f, -0.02704209f, -0.11541027f, -0.09539072f, -0.16910377f, 0.10432059f, 
    0.00218937f, 0.22604409f, -0.03968040f, 0.14533442f, -0.12836732f, -0.07898087f, 0.10637646f, -0.07319830f, 
    0.03413059f, 0.03797606f, 0.24310884f, -0.08196447f, 0.03442959f, -0.01852807f, -0.12229219f, 0.04287832f, 
    0.00167346f, -0.06063883f, -0.00988365f, -0.01911416f, 0.10735591f, 0.33567506f, 0.00299502f, 0.02890187f, 
    0.14671671f, 0.14416024f, -0.08943901f, -0.08613667f, -0.15606551f, 0.01448675f, 0.03223499f, -0.08929086f, 
    -0.03505120f, 0.03543655f, -0.06092630f, -0.24939579f, 0.03396570f, 0.22811902f, 0.07362381f, 0.11150350f, 
    -0.04620105f, 0.12521151f, 0.07233319f, -0.13528678f, -0.23610410f, -0.21263655f, 0.26566976f, 0.08221129f, 
    0.05751015f, 0.16464551f, 0.09053576f, 0.11299398f, -0.15938404f, 0.00814033f, 0.04073472f, -0.05042329f, 
    0.31202587f, 0.66889834f, -0.16936727f, -0.02045475f, 0.10774456f, -0.03539742f, 0.13051836f, 0.01970362f, 
    0.06759001f, 0.00855673f, -0.04331472f, -0.10771464f, -0.14283055f, -0.03518286f, 0.21398966f, 0.15275161f, 
    -0.10152587f, 0.05077973f, -0.24698885f, 0.10759454f, -0.15538599f, 0.09106458f, 0.04349397f, 0.00133974f, 
    0.15396506f, 0.16726080f, 0.17663507f, -0.04490768f, -0.01976405f, 0.03090946f, 0.12203953f, 0.09177846f, 
    0.09661690f, -0.03184017f, 0.10038321f, 0.10751628f, -0.04292321f, -0.17878404f, -0.29211250f, -0.20966743f, 
    -0.03576729f, -0.00870529f, -0.05927544f, -0.06478836f, -0.13445634f, -0.09228940f, 0.01606520f, 0.12591858f, 
    0.18132228f, -0.36907426f, 0.27248955f, -0.11276079f, 0.12853158f, -0.05184346f, -0.13221347f, 0.11185516f, 
    -0.29071927f, -0.02195130f, 0.13388644f, 0.13052823f, -0.08591624f, -0.09106138f, -0.01513291f, 0.11029834f, 
    -0.02540899f, -0.07726960f, -0.07652795f, -0.05421963f, 0.07302654f, 0.08461665f, 0.24660608f, 0.11002334f, 
    0.00305869f, 0.09433461f, -0.08656763f, 0.20048431f, 0.07460106f, 0.35263833f, 0.06716987f, 0.03644499f, 
    0.18954392f, -0.07847327f, 0.03823586f, 0.02934409f, 0.09331977f, 0.18454969f, 0.05110849f, -0.06332278f, 
    0.15087259f, -0.07018910f, 0.03428879f, 0.06056209f, 0.09518599f, 0.18144158f, -0.10330123f, 0.03545881f, 
    -0.12990469f, -0.04039951f, 0.04257574f, 0.14622955f, 0.02993737f, 0.11891276f, 0.27417469f, 0.16291185f, 
    0.05651935f, 0.06104065f, -0.04435282f, 0.12777027f, -0.32227185f, 0.04655653f, 0.01225006f, -0.00602541f, 
    0.05317697f, -0.01719366f, 0.05223190f, -0.05442763f, 0.02375854f, 0.09337413f, -0.17541178f, 0.21616460f, 
    -0.15498389f, -0.06930217f, 0.21164317f, -0.22985041f, -0.15878357f, -0.00176611f, -0.23460907f, -0.06939425f, 
    0.07476739f, 0.16816662f, 0.09216573f, 0.22502109f, 0.07056302f, 0.21059805f, 0.06671213f, -0.15812747f, 
    -0.10523120f, -0.08422413f, 0.03415711f, 0.01835242f, 0.14597410f, 0.10474832f, 0.06461716f, 0.02255606f, 
    -0.37868410f, -0.28802103f, -0.24183340f, -0.00060191f, 0.01684147f, 0.06083989f, -0.07857440f, -0.22361463f, 
    0.09232926f, 0.04413856f, 0.02561725f, 0.17790319f, -0.28552935f, 0.50188124f, 0.23975641f, -0.02116220f, 
    0.02934465f, -0.07457242f, 0.04417905f, 0.07496635f, 0.08724136f, -0.09689673f, -0.03854824f, -0.02045953f, 
    0.17951830f, 0.15339366f, 0.21768226f, 0.27948254f, -0.09077871f, -0.15497020f, -0.08886328f, 0.00962560f, 
    -0.06527133f, -0.15449309f, -0.14640670f, 0.04488936f, 0.10556036f, 0.36230803f, 0.01576993f, -0.10494465f, 
    0.02496067f, 0.08981664f, 0.20115119f, -0.04750695f, 0.03994836f, -0.08896945f, 0.14852086f, 0.11736330f, 
    0.21698694f, -0.23262462f, 0.28357211f, -0.48018762f, 0.01158676f, -0.04146189f, -0.00604122f, 0.12637734f, 
    -0.04240870f, 0.05156493f, -0.03181363f, -0.26023769f, -0.11700403f, -0.25012225f, -0.24696301f, 0.02546612f, 
    0.03378866f, -0.01019410f, 0.08145554f, -0.05632757f, 0.06633037f, -0.08126376f, -0.04049140f, 0.09917361f, 
    -0.23051146f, -0.23951431f, -0.07128581f, 0.17209463f, -0.19732417f, 0.15863635f, -0.14339493f, -0.02335770f, 
    -0.05961007f, 0.02465796f, 0.06229179f, 0.03093907f, 0.08695240f, 0.12302890f, 0.32937360f, 0.18387254f, 
    -0.12598765f, 0.00787967f, 0.11891717f, -0.03746352f, 0.07531776f, -0.19273260f, -0.00857258f, 0.00484007f, 
    -0.04206450f, 0.08254835f, -0.27081612f, 0.17082576f, -0.01819029f, -0.09558266f, 0.10694543f, 0.11459892f, 
    0.15817057f, -0.05095086f, -0.18415530f, 0.02933002f, -0.00920742f, 0.16025434f, -0.26674721f, -0.17253666f, 
    -0.04224534f, 0.15002096f, 0.07763172f, 0.01304553f, 0.02833589f, 0.00313380f, -0.11748981f, 0.08719069f, 
    0.40769047f, 0.23125792f, 0.26656932f, -0.21989129f, -0.09669004f, -0.06994954f, 0.16854337f, 0.05620156f, 
    -0.03851938f, 0.07301053f, -0.16907567f, -0.05004007f, -0.08240020f, 0.38025936f, 0.05628872f, 0.17522925f, 
    -0.06988665f, 0.00343745f, 0.18599620f, 0.04672721f, 0.06592274f, 0.07726756f, -0.04651298f, -0.02027976f, 
    -0.10793861f, -0.14632998f, -0.17975624f, 0.07985712f, 0.02796852f, 0.30507252f, -0.06760871f, -0.00671998f, 
    0.01785345f, 0.02468413f, 0.08874678f, 0.12205591f, -0.12394983f, -0.21056157f, -0.28482434f, 0.10624512f, 
    0.01517590f, 0.02772542f, -0.09081622f, 0.06286030f, 0.07411320f, 0.16926633f, -0.17651114f, -0.00936734f, 
    -0.05059039f, -0.00519853f, -0.23949842f, -0.18427931f, -0.18501720f, 0.00919954f, 0.00267745f, 0.06544902f, 
    0.18346739f, -0.08629162f, 0.02754991f, -0.02533325f, -0.03254896f, -0.32132009f, -0.12702344f, 0.27789795f, 
    -0.05992457f, 0.12467494f, 0.01503096f, 0.17854932f, 0.06841373f, 0.14431414f, 0.21481383f, -0.15662353f, 
    0.25706694f, 0.16694871f, 0.14325958f, -0.11799756f, 0.00172933f, -0.07565500f, -0.13982248f, 0.01734554f, 
    -0.13823330f, -0.02446619f, -0.05488555f, -0.09812526f, -0.07023381f, 0.38117141f, 0.32929608f, 0.24079400f, 
    0.17451671f, -0.20952420f, 0.07919481f, 0.05911917f, 0.00114276f, -0.00240365f, 0.05875644f, 0.03740022f, 
    -0.38244566f, -0.10493379f, 0.31305602f, 0.17153510f, -0.03242316f, -0.12277816f, 0.06031620f, 0.01747581f, 
    0.03431137f, 0.09366872f, -0.00162126f, -0.08209117f, -0.44412991f, -0.22444081f, -0.08341152f, -0.06216131f, 
    -0.00189379f, 0.03056484f, 0.01511424f, -0.05298417f, -0.09681515f, -0.21294069f, -0.19156072f, 0.07941318f, 
    0.09714175f, 0.33073366f, 0.10010289f, 0.07757516f, -0.06292774f, 0.00295767f, 0.08516179f, 0.16593808f, 
    -0.03825524f, -0.00570897f, -0.02703018f, -0.21032855f, 0.04457215f, 0.29855591f, 0.31330410f, 0.09383105f, 
    0.02759891f, -0.04647021f, -0.20809178f, -0.09153072f, -0.11640389f, 0.07523677f, 0.02104541f, 0.07860712f, 
    0.17918125f, 0.14011911f, 0.15455653f, 0.13048314f, -0.05261278f, 0.09410141f, -0.05287202f, 0.20298037f, 
    0.04918439f, 0.08760675f, 0.20875902f, 0.05323598f, -0.50610054f, -0.39661250f, -0.10668983f, -0.17714579f, 
    0.04690623f, 0.07201528f, -0.12804584f, -0.19745401f, -0.14877909f, -0.07770845f, -0.09938688f, 0.06277609f, 
    0.16940348f, -0.17839992f, 0.49283567f, -0.25510234f, 0.13792235f, 0.00572127f, -0.30646393f, 0.03986280f, 
    -0.07436890f, 0.04879593f, -0.01503791f, 0.07225810f, -0.04063442f, 0.17691405f, 0.11669825f, 0.27632231f, 
    0.04008910f, -0.11956275f, 0.01115057f, 0.01548550f, 0.11480191f, 0.12154508f, 0.28165498f, 0.31858519f, 
    -0.09660789f, 0.28640878f, 0.29672050f, 0.18851569f, -0.07256391f, 0.31256488f, 0.10871027f, 0.12344833f, 
    0.21270585f, 0.13438126f, 0.10942291f, 0.15330121f, -0.07205777f, 0.06783360f, 0.23929894f, 0.12695327f, 
    0.17479226f, 0.06686556f, 0.16797797f, 0.00167740f, 0.03769344f, 0.15443243f, -0.13713837f, -0.07109345f, 
    0.07123145f, 0.00317740f, -0.13951801f, 0.07052939f, -0.03715260f, -0.13068847f, -0.02628430f, 0.08825704f, 
    0.01507546f, 0.06199757f, -0.03252650f, 0.06520889f, 0.48181307f, 0.04301659f, -0.17906022f, 0.02858011f, 
    -0.15500896f, 0.04388111f, -0.02889325f, -0.05874714f, 0.13544090f, 0.09349207f, 0.13068399f, 0.02205295f, 
    -0.00404520f, 0.24924479f, -0.19356361f, -0.07717294f, -0.05027732f, -0.00810421f, 0.07775591f, 0.18785502f, 
    0.20360693f, -0.10274941f, -0.05469541f, -0.08292223f, 0.10446771f, -0.06016558f, 0.03221219f, 0.12959655f, 
    -0.12394593f, 0.03894530f, -0.03651423f, 0.24643545f, -0.06616597f, 0.05520600f, -0.05863691f, 0.05648006f, 
    0.29224679f, 0.18885067f, 0.09244636f, -0.15055372f, -0.03430544f, 0.01576439f, 0.05158184f, 0.09596881f, 
    -0.05999828f, 0.02350996f, 0.04504026f, -0.01072873f, 0.07926903f, -0.39942685f, 0.07589743f, -0.04615727f, 
    -0.02079967f, -0.07700737f, 0.24714057f, 0.04353269f, 0.05915238f, 0.00773231f, 0.07261962f, 0.01592301f, 
    -0.21810403f, -0.12446512f, -0.14569791f, -0.10841236f, -0.20731355f, -0.01458720f, 0.08910589f, 0.11490241f, 
    0.18804371f, 0.07828531f, 0.10919632f, 0.10102104f, -0.12035312f, 0.00990138f, 0.03707011f, 0.20762767f, 
    -0.04163574f, -0.11926188f, 0.17955907f, 0.13498800f, 0.04972022f, 0.06689040f, -0.18267109f, 0.03675040f, 
    -0.36326703f, 0.03901778f, 0.05928481f, 0.34975657f, 0.04596427f, 0.13187598f, 0.09794521f, -0.02222942f, 
    -0.05214458f, 0.03615532f, 0.09205900f, 0.13364904f, -0.01155090f, 0.00660436f, -0.02220414f, -0.13230892f, 
    -0.02145910f, -0.00573902f, -0.05319638f, -0.01712364f, 0.05290866f, 0.03320067f, 0.00912962f, 0.06777915f, 
    0.11966988f, 0.15906443f, 0.01464961f, -0.09763987f, 0.06189374f, -0.07121884f, 0.07080954f, 0.01786429f, 
    0.08914924f, 0.00077808f, -0.01318653f, -0.06957169f, -0.31337360f, -0.19278689f, 0.03396284f, 0.06171402f, 
    -0.12608460f, -0.05467875f, -0.18657678f, -0.01444574f, -0.07046399f, 0.05708495f, -0.07033297f, 0.06289322f, 
    0.19410878f, 0.14763734f, 0.21799183f, -0.17587149f, 0.08384291f, -0.06816930f, 0.17492558f, 0.03482655f, 
    0.06074088f, 0.06306780f, 0.06163796f, 0.05117254f, 0.03750604f, 0.19530153f, 0.28898773f, 0.18470629f, 
    0.07318579f, 0.03404668f, -0.06100800f, -0.12105591f, 0.10834954f, 0.07765862f, 0.30915561f, 0.10009576f, 
    -0.31661934f, 0.11925530f, 0.08026046f, 0.34859034f, -0.11958992f, -0.04039263f, 0.06158171f, 0.12671816f, 
    0.00481465f, 0.16887102f, 0.25341657f, 0.00467416f, -0.05411265f, -0.29059386f, 0.20991699f, 0.20355685f, 
    0.06729706f, 0.11579870f, 0.03284563f, -0.03349436f, 0.09452291f, -0.09230758f, 0.01082684f, 0.03979581f, 
    -0.17060606f, -0.01775890f, 0.00311542f, 0.27954778f, 0.05910601f, 0.09980418f, -0.07148352f, -0.10585604f, 
    -0.04817180f, 0.12550937f, 0.06426194f, 0.30215049f, 0.59207606f, 0.21882817f, -0.19575955f, -0.13860679f, 
    0.05894351f, -0.01868118f, -0.07313242f, 0.10612050f, 0.00891623f, 0.26383606f, 0.11701024f, -0.03049183f, 
    -0.13249023f, -0.19016992f, 0.00363247f, 0.10617956f, -0.13125391f, 0.01466953f, 0.12041233f, 0.01047471f, 
    0.02910964f, 0.06412713f, 0.02980119f, -0.04616167f, 0.55436337f, -0.63329673f, -0.43516532f, -0.29828119f, 
    -0.06903411f, -0.15598889f, 0.16831569f, -0.02505205f, 0.02404604f, -0.14055617f, 0.25918680f, 0.02740642f, 
    0.02539232f, 0.08512378f, 0.14677756f, 0.01584609f, -0.06512949f, -0.16457698f, -0.00992781f, -0.12423995f, 
    0.01505165f, -0.02437022f, 0.31338286f, 0.08803844f, 0.05823356f, -0.19803926f, -0.48543552f, 0.18156038f, 
    -0.12053371f, -0.09395235f, -0.02198005f, -0.04801036f, 0.02264806f, -0.07112065f, -0.09023382f, -0.14987436f, 
    0.45262247f, -0.18677600f, -0.02402462f, -0.21881069f, -0.01913884f, -0.02260759f, -0.04726891f, 0.02763306f, 
    0.27099770f, 0.03540465f, -0.10166400f, -0.07613719f, -0.10543325f, -0.09308900f, -0.22795026f, -0.10158032f, 
    -0.01872209f, 0.56748164f, -0.26743379f, -0.18576141f, 0.01746898f, 0.06289203f, 0.17294654f, 0.26644900f, 
    0.29294086f, 0.18301028f, 0.15365539f, -0.40546665f, -0.01911306f, -0.07444557f, 0.00601815f, 0.13187101f, 
    -0.04549033f, -0.02840162f, 0.00667597f, -0.05404786f, 0.00443549f, 0.22133027f, 0.25828782f, -0.07282398f, 
    0.07321977f, -0.05949940f, 0.01264743f, 0.03805513f, 0.07079953f, 0.09555569f, -0.12134782f, 0.15718029f, 
    0.03042599f, 0.10991500f, 0.34558436f, 0.10578477f, 0.06253384f, 0.08926475f, -0.21453831f, -0.14811976f, 
    0.04846539f, -0.05681910f, 0.07121189f, 0.26440358f, -0.22682501f, -0.28794274f, -0.12689053f, 0.25955284f, 
    0.18172427f, 0.26026616f, 0.27979341f, 0.21449775f, 0.06906786f, 0.10549912f, 0.09243862f, -0.02566740f, 
    -0.38448617f, 0.49165028f, -0.35411981f, 0.28120142f, -0.00038183f, -0.07360468f, -0.18755935f, 0.22420025f, 
    -0.07029148f, -0.06831177f, 0.08450198f, 0.02549803f, 0.03935575f, 0.21575938f, 0.04664560f, -0.37387735f, 
    -0.01364715f, 0.14874475f, -0.11264037f, 0.04881280f, 0.03334126f, -0.05752914f, -0.20630400f, -0.03840300f, 
    -0.01275969f, -0.46194887f, -0.30729350f, -0.03783940f, 0.02198444f, 0.01577790f, 0.24894640f, -0.11367002f, 
    0.19507687f, 0.08386369f, -0.17026934f, 0.19763324f, -0.19667646f, -0.00873889f, 0.13625941f, 0.22456634f, 
    0.10547049f, 0.23554374f, 0.02191870f, 0.11397973f, -0.03176191f, 0.04338770f, -0.05744865f, 0.00804501f, 
    -0.01604389f, -0.02875902f, -0.08461509f, 0.26547462f, -0.04963462f, 0.01145073f, -0.04849947f, -0.06281537f, 
    0.08579081f, 0.09334129f, -0.04685707f, 0.19604570f, 0.26208764f, 0.08560732f, -0.03423426f, -0.30870098f, 
    0.15842175f, 0.01598275f, -0.08238913f, 0.05091045f, 0.04622272f, 0.08427447f, -0.27293858f, 0.20771950f, 
    -0.24743351f, 0.17039515f, 0.11300628f, 0.26210728f, 0.01006121f, -0.03637962f, 0.01999082f, -0.20965600f, 
    -0.16897398f, 0.18433282f, -0.10237734f, 0.14822671f, 0.06545684f, -0.00774290f, -0.06977352f, 0.14467824f, 
    -0.01209448f, 0.05680120f, 0.11408261f, -0.01718539f, 0.03054122f, 0.02936199f, -0.07241489f, -0.07133124f, 
    -0.03633817f, 0.01549727f, -0.00013178f, -0.06170833f, -0.06058186f, -0.06837041f, 0.01585869f, -0.04642144f, 
    -0.06812850f, 0.00802406f, 0.03874480f, 0.11996083f, 0.32750425f, -0.33975080f, 0.18678565f, 0.24320360f, 
    -0.16400212f, -0.13621823f, -0.10214929f, -0.15366904f, 0.09231630f, 0.09583646f, 0.16420279f, -0.00840386f, 
    -0.30738014f, -0.02752002f, 0.07388945f, 0.37210479f, 0.04858907f, -0.08190200f, 0.18341020f, 0.02445011f, 
    -0.15643840f, 0.00784754f, -0.15357584f, -0.02971631f, -0.15243103f, 0.15197243f, -0.09431361f, 0.11770745f, 
    0.02517232f, -0.02228726f, -0.31873927f, -0.16281156f, 0.07495164f, 0.04151111f, -0.17231096f, 0.22628117f, 
    -0.16209413f, -0.03568913f, 0.24872245f, 0.09023914f, -0.07237899f, 0.03138357f, 0.02076642f, -0.03189372f, 
    -0.04286165f, -0.11318868f, -0.11740855f, -0.15684129f, -0.19261767f, 0.13801311f, -0.14476152f, -0.10382511f, 
    0.02085611f, 0.01229858f, 0.02023071f, -0.07731205f, -0.05369208f, 0.00908546f, -0.01479162f, 0.26779693f, 
    -0.43310741f, -0.10250215f, -0.03194764f, 0.04174104f, 0.02953982f, 0.15059215f, 0.01152623f, 0.01202982f, 
    0.00556702f, -0.03516804f, 0.01606233f, 0.10516498f, -0.18046966f, -0.24957843f, 0.10510074f, 0.19706641f, 
    -0.11767276f, 0.27120897f, 0.23031029f, 0.05685791f, 0.13976334f, 0.15229885f, 0.04325451f, 0.00643215f, 
    -0.29704168f, -0.09705875f, 0.43828419f, -0.12196944f, 0.04746985f, 0.22334711f, 0.00204722f, 0.10129602f, 
    0.11105503f, -0.09134823f, -0.08837937f, -0.02744160f, -0.05944589f, -0.00440834f, -0.12314329f, 0.08342257f, 
    0.09632116f, -0.07376377f, -0.02670416f, -0.00893661f, -0.07716108f, -0.04668555f, -0.32695574f, 0.09376150f, 
    0.00756126f, 0.38758019f, 0.22448578f, 0.31111318f, 0.06460251f, 0.16328779f, 0.14409152f, -0.03053414f, 
    0.08362748f, 0.11135492f, 0.08661827f, 0.06815808f, 0.04918816f, -0.24985979f, 0.15482810f, 0.24982801f, 
    0.04443137f, -0.01266783f, 0.01148568f, -0.14293534f, 0.07030692f, 0.05633950f, 0.11312081f, 0.10285071f, 
    -0.18583184f, -0.25822082f, 0.13656567f, 0.06364590f, 0.05437087f, 0.07482407f, 0.22009987f, 0.01974168f, 
    -0.10214627f, -0.01096685f, 0.06320594f, 0.05762890f, 0.16946405f, -0.28952739f, 0.10712209f, 0.12998432f, 
    -0.00276946f, -0.07155046f, 0.00805847f, 0.05043210f, -0.13140745f, 0.14784540f, -0.11383307f, 0.09197465f, 
    -0.06629407f, -0.38240889f, -0.09397676f, 0.03855452f, -0.23215777f, 0.05277641f, 0.07803558f, 0.13550751f, 
    0.01760547f, 0.03981366f, -0.04806687f, 0.34357536f, 0.15300836f, 0.04687557f, 0.07887660f, 0.10832022f, 
    -0.00338872f, -0.07888547f, 0.12828340f, 0.11335116f, -0.00776778f, 0.02684308f, 0.01487979f, 0.06600203f, 
    -0.72971922f, -0.46511298f, -0.13369325f, 0.09591489f, -0.09217462f, 0.02532370f, -0.23843497f, -0.13660373f, 
    -0.07632741f, -0.04756721f, 0.07238541f, 0.06540652f, -0.02982215f, 0.50390190f, 0.19335683f, 0.16301198f, 
    0.13366531f, 0.17003439f, 0.10204430f, 0.16942710f, -0.01783033f, -0.09024542f, -0.00390291f, 0.14165184f, 
    0.28487909f, 0.19003999f, 0.10366417f, 0.21812122f, 0.08423129f, 0.01554618f, -0.00827045f, 0.22627166f, 
    0.02959629f, 0.06486617f, -0.06683856f, -0.00589401f, 0.11778672f, 0.06187300f, 0.03620088f, 0.12396919f, 
    -0.18699692f, 0.19993079f, -0.01037057f, 0.09348437f, -0.05942226f, -0.19508798f, -0.06714294f, 0.03994827f, 
    0.18935503f, 0.19506428f, 0.16178386f, -0.14481035f, 0.13862088f, -0.13274153f, 0.06274223f, 0.18374716f, 
    -0.00052032f, 0.09242764f, 0.02222255f, -0.11726686f, 0.08786830f, -0.17916948f, -0.00141119f, 0.15367329f, 
    -0.02910014f, -0.17882124f, 0.20381331f, 0.12952505f, 0.01447299f, -0.16762570f, 0.06455708f, 0.04925125f, 
    -0.38849223f, -0.42731389f, -0.14389831f, 0.13343635f, -0.08726663f, 0.19690576f, -0.21522632f, 0.05845410f, 
    -0.09847526f, 0.07069767f, 0.00053502f, 0.03554438f, 0.30736384f, 0.15753366f, 0.01152579f, 0.02861012f, 
    0.08741321f, 0.09622029f, 0.10230219f, 0.08745580f, 0.10767402f, -0.06279246f, 0.07362928f, 0.04597790f, 
    -0.42588073f, -0.23610058f, -0.32473251f, 0.30577707f, 0.07922398f, -0.00129575f, 0.00166998f, -0.16538738f, 
    0.13768885f, 0.16287860f, -0.04727125f, -0.06004615f, -0.07170191f, 0.15124612f, -0.06757150f, -0.27288076f, 
    -0.30734372f, 0.02966980f, 0.02724955f, -0.04082004f, 0.21970181f, -0.00521416f, -0.04516989f, -0.02461973f, 
    0.33502394f, 0.29777113f, 0.01198593f, -0.05514741f, 0.04016454f, 0.11437626f, 0.10181913f, -0.07795737f, 
    0.12145015f, 0.01815001f, -0.14710443f, 0.13433255f, -0.02085474f, 0.45918453f, 0.09451618f, 0.15779670f, 
    0.14050756f, 0.09295926f, 0.01285772f, 0.10942327f, 0.03570892f, -0.03477157f, -0.05003281f, 0.06130671f, 
    -0.14537792f, 0.16820963f, -0.13272509f, 0.28989553f, -0.11959696f, 0.02905440f, 0.13270229f, 0.24820986f, 
    0.06626655f, 0.08258023f, -0.11167325f, 0.03752141f, 0.11852081f, 0.17301467f, 0.11797486f, -0.24653552f, 
    -0.03763934f, -0.01090507f, 0.04805481f, 0.07124235f, 0.03577477f, 0.11799238f, 0.10714585f, 0.07676079f, 
    -0.24368374f, -0.19263780f, 0.12696917f, 0.17489508f, -0.08915700f, -0.06743071f, -0.09170040f, -0.20003556f, 
    0.07821047f, 0.14295022f, -0.06330366f, -0.09420350f, -0.12149700f, 0.18042381f, -0.27803707f, 0.08403616f, 
    0.02885742f, 0.05176462f, 0.03781705f, -0.06691685f, 0.01745572f, 0.09192308f, -0.01609029f, -0.02235571f, 
    0.23637213f, 0.13027199f, 0.14796747f, -0.25960404f, -0.01488274f, -0.13058946f, -0.23595519f, -0.18671098f, 
    0.13774724f, -0.08307526f, -0.01077607f, -0.01972852f, 0.38595435f, -0.21642160f, 0.17476125f, 0.30786127f, 
    0.00499961f, 0.05966649f, -0.16616637f, 0.01209345f, -0.06743108f, 0.21361728f, -0.01043698f, 0.02876922f, 
    -0.14723280f, 0.04565330f, -0.24490750f, 0.19562231f, 0.02930601f, -0.05484602f, 0.15801822f, -0.17100722f, 
    -0.24951611f, 0.01475530f, -0.04561216f, -0.10684053f, -0.10289367f, -0.01207818f, 0.18537804f, 0.16973564f, 
    0.08462344f, -0.01971340f, 0.19237736f, 0.04290992f, -0.10089995f, 0.11523101f, -0.03881213f, -0.02216012f, 
    -0.04276096f, 0.11981145f, 0.01713270f, 0.18091266f, -0.08586750f, -0.01937144f, 0.13670455f, -0.02760060f, 
    -0.00804157f, -0.17494233f, 0.05832148f, -0.02830978f, -0.12371124f, 0.36150905f, 0.10417788f, -0.07603979f, 
    -0.21210502f, -0.11124266f, -0.25012258f, -0.06360976f, -0.18266052f, -0.13949963f, -0.06985775f, 0.09806240f, 
    0.02142871f, 0.11551388f, 0.11122030f, -0.09756995f, 0.11835458f, 0.03645287f, 0.09127537f, -0.12422044f, 
    -0.01039181f, -0.20797029f, 0.09180494f, -0.09513328f, -0.32189229f, -0.29980451f, 0.22047897f, 0.29674789f, 
    -0.12595156f, 0.01741499f, -0.06399368f, 0.13985239f, 0.08618922f, 0.10858980f, -0.05880351f, 0.05317060f, 
    0.27974537f, -0.23706922f, 0.87456888f, -0.46780935f, -0.01952831f, 0.01931530f, -0.17753716f, 0.27351087f, 
    -0.05552982f, 0.07732690f, 0.07157000f, -0.05326527f, -0.19281721f, -0.03673617f, 0.01966767f, 0.27016512f, 
    0.01526981f, -0.17957877f, 0.14516285f, -0.03170834f, 0.00423913f, 0.00202358f, -0.20429695f, -0.02960207f, 
    -0.00106873f, 0.19225878f, 0.17320698f, 0.31232050f, 0.08465416f, 0.18060201f, 0.11333378f, 0.06678283f, 
    0.10568873f, 0.07200440f, 0.03244267f, -0.16966084f, 0.00309772f, -0.24463762f, -0.03928366f, 0.19668688f, 
    0.20957948f, 0.02031991f, 0.13004608f, -0.07291830f, 0.05503033f, 0.05080794f, -0.08917031f, -0.01769152f, 
    -0.02485668f, -0.02628335f, -0.16981874f, 0.08789726f, -0.08296277f, 0.06697312f, -0.00137964f, 0.06495907f, 
    -0.01844963f, -0.03890840f, -0.03230300f, -0.13845487f, 0.18025964f, 0.27669129f, -0.19854149f, 0.19606110f, 
    0.01487124f, -0.13670646f, 0.11076014f, -0.08797047f, -0.00284732f, -0.13996972f, 0.05531529f, 0.05170662f, 
    -0.12732343f, 0.02917854f, 0.13458207f, 0.06396189f, -0.06966469f, -0.04979048f, 0.23259583f, -0.11780503f, 
    -0.05478184f, 0.16105269f, 0.07764565f, 0.09985617f, 0.39390880f, -0.06001147f, -0.10376965f, 0.15346156f, 
    0.15570922f, 0.01425844f, -0.23227623f, -0.16924949f, 0.00125321f, -0.08099817f, 0.07883877f, 0.04400119f, 
    0.31068844f, 0.07930519f, 0.04070505f, -0.19633302f, -0.03505065f, 0.05911224f, 0.01356528f, 0.04784806f, 
    0.03145271f, -0.03833004f, -0.00127474f, -0.11736491f, 0.38837728f, -0.01119172f, -0.03346800f, 0.24428670f, 
    -0.03729675f, 0.05622043f, -0.09140677f, -0.08261140f, 0.09964000f, 0.04797698f, 0.17569068f, 0.29724327f, 
    -0.00093178f, -0.20347188f, 0.23378448f, 0.10008628f, 0.08207007f, 0.03702195f, 0.07520821f, -0.17727321f, 
    -0.28538725f, 0.11317578f, 0.15424241f, 0.18934022f, 0.06222520f, -0.18945989f, 0.33315518f, 0.17050245f, 
    0.06969108f, 0.10374109f, 0.28970107f, 0.22187327f, -0.13146958f, -0.06677099f, 0.01840996f, -0.04985730f, 
    -0.00818361f, 0.36062285f, -0.29381815f, 0.07440580f, -0.06459472f, -0.06434636f, -0.10304368f, -0.12135490f, 
    0.06943475f, 0.10819874f, 0.13116655f, 0.08257794f, 0.02057356f, -0.18589902f, 0.28682724f, -0.08241349f, 
    -0.00047031f, 0.16212906f, -0.07537365f, -0.02468551f, -0.00903577f, -0.11505216f, -0.05258857f, 0.03607029f, 
    0.07995327f, 0.04642678f, -0.07788572f, 0.01978173f, 0.06809322f, -0.06539194f, 0.18797027f, -0.06045664f, 
    0.02308403f, -0.05119906f, 0.09025631f, -0.12771286f, -0.27781868f, -0.27076656f, -0.25087854f, -0.29584166f, 
    0.08157408f, 0.04457742f, 0.11412270f, -0.01095845f, 0.01527877f, 0.01039169f, -0.06083370f, -0.05377767f, 
    -0.07397214f, 0.17312135f, 0.44339252f, -0.43574753f, -0.06050498f, 0.07756341f, -0.19994621f, 0.06700625f, 
    -0.05783380f, -0.02112784f, -0.02615000f, -0.00047872f, -0.10139399f, -0.40802416f, 0.14988557f, 0.17442550f, 
    -0.03529672f, 0.08326724f, 0.14495045f, 0.18881418f, 0.03257488f, 0.04752082f, 0.07147539f, 0.05477883f, 
    -0.00633056f, 0.03760118f, 0.18639982f, -0.03898451f, 0.22423117f, 0.04823536f, -0.13789256f, 0.07485026f, 
    -0.22070415f, 0.02007996f, 0.11229035f, 0.05727964f, 0.09762845f, -0.20424554f, 0.06568173f, 0.01454282f, 
    -0.17755806f, -0.10679151f, -0.09886452f, -0.15640591f, -0.06223261f, 0.00679094f, -0.15933552f, -0.03809003f, 
    0.01927827f, -0.14252712f, -0.02019092f, 0.02760871f, 0.15143037f, 0.14461155f, 0.01388111f, -0.04968148f, 
    0.25885287f, 0.30755839f, 0.28487375f, 0.42597687f, 0.09052291f, -0.17976458f, 0.12492479f, -0.02075486f, 
    -0.02191226f, 0.14984967f, -0.17060709f, 0.16438070f, 0.12363037f, 0.13509989f, 0.11360706f, -0.14890160f, 
    0.03078143f, -0.26408139f, -0.38668695f, -0.12543552f, -0.04143140f, -0.29413211f, -0.18693104f, 0.14964849f, 
    0.11043853f, -0.09488479f, 0.14388981f, 0.02614171f, -0.04042018f, -0.19167787f, 0.04627322f, 0.01641523f, 
    -0.01414393f, -0.02560323f, -0.00982188f, 0.23707919f, -0.05187776f, 0.06248738f, 0.02398629f, -0.07694195f, 
    -0.06668788f, 0.09246044f, 0.04877972f, 0.04978339f, -0.18114208f, -0.13226263f, -0.01303473f, -0.07890080f, 
    -0.09842257f, -0.07357259f, 0.08571382f, 0.05132403f, 0.00452152f, -0.04660577f, -0.10818576f, -0.23956612f, 
    0.03393395f, -0.04106891f, 0.16047558f, 0.08215321f, -0.08920440f, -0.00017513f, -0.17654313f, -0.12040373f, 
    0.15837415f, 0.05527692f, -0.01540083f, -0.31673589f, 0.02036870f, 0.02580557f, -0.13411571f, 0.01745293f, 
    0.09531904f, 0.13365912f, -0.09340581f, -0.26244256f, -0.12850969f, -0.11823000f, -0.24649303f, 0.02596478f, 
    0.00619503f, 0.08329488f, -0.12962951f, 0.08966102f, 0.12607446f, 0.20161556f, -0.05456467f, 0.17767921f, 
    0.11169636f, 0.16046290f, 0.05341133f, -0.08549964f, 0.18004511f, 0.08735833f, 0.02271057f, 0.09157783f, 
    -0.18950325f, -0.01197834f, -0.21684644f, -0.11253081f, -0.18602148f, 0.23336606f, 0.14610010f, 0.00125585f, 
    -0.06474463f, -0.14497170f, -0.12259385f, -0.21935782f, -0.11343332f, 0.11415509f, 0.05098462f, -0.01972019f, 
    -0.18303889f, 0.09389035f, -0.03082223f, -0.05527464f, -0.04994456f, -0.06139034f, -0.02585412f, 0.16220059f, 
    0.13594642f, 0.21947254f, 0.11414578f, 0.19479302f, 0.15007856f, -0.04437857f, 0.06659868f, -0.01690446f, 
    -0.00595972f, 0.10373639f, 0.04062502f, 0.00769530f, -0.19749533f, -0.16233626f, -0.08966446f, 0.11363842f, 
    -0.65611434f, -0.05449876f, -0.28340557f, 0.23438707f, -0.07289583f, 0.04900113f, 0.18124068f, -0.00714746f, 
    -0.11132871f, 0.00007578f, 0.22722994f, 0.15859935f, -0.04339027f, 0.09939577f, -0.09912894f, 0.02230700f, 
    -0.00316137f, 0.18874548f, -0.29802403f, -0.25783908f, 0.17414562f, 0.03240170f, 0.09061717f, 0.13449578f, 
    -0.01703115f, -0.09044188f, -0.20867901f, 0.21916118f, -0.05738972f, 0.09496176f, 0.08218455f, 0.00699018f, 
    0.17512408f, -0.02900003f, 0.12867889f, 0.09098894f, 0.16277251f, 0.10415787f, 0.18768027f, 0.01678052f, 
    0.08253904f, 0.16074876f, 0.09322872f, 0.12053125f, 0.11264486f, 0.10274910f, 0.01896316f, -0.02239990f, 
    0.06969916f, 0.03080225f, 0.14494674f, -0.09927750f, -0.03600571f, 0.06799291f, 0.06220214f, 0.02020658f, 
    -0.00438609f, 0.04773915f, -0.05601338f, 0.00334214f, -0.25263339f, -0.03735261f, -0.03082975f, 0.15907657f, 
    -0.10771088f, -0.08976483f, 0.01974278f, -0.01900823f, -0.14739732f, -0.11334231f, 0.03968855f, -0.03585754f, 
    0.18076129f, 0.01481338f, 0.15840314f, -0.10745776f, 0.03813492f, 0.08895757f, -0.10121543f, -0.01529390f, 
    -0.03232293f, -0.02433270f, 0.23681928f, 0.01044364f, -0.08334633f, 0.06431759f, 0.10540207f, -0.14333041f, 
    -0.03061258f, -0.17367488f, 0.04424326f, -0.13692752f, 0.12745757f, 0.02367382f, 0.05365334f, 0.09698758f, 
    -0.13087681f, -0.05467699f, 0.01616443f, 0.24374546f, 0.05083048f, 0.04679605f, 0.10244873f, -0.00383970f, 
    -0.04528133f, -0.12460370f, 0.06046957f, 0.00010622f, -0.47295126f, 0.34344310f, -0.05566235f, -0.28564528f, 
    0.02136278f, -0.04026519f, -0.01387489f, 0.15950325f, 0.10492872f, -0.05178778f, -0.10516147f, -0.05390650f, 
    0.41885379f, 0.06732015f, 0.15304203f, -0.02568275f, 0.00640167f, -0.08183108f, -0.01890570f, 0.08003317f, 
    0.31016499f, -0.05000682f, -0.04088679f, 0.00434967f, 0.11373208f, 0.18761118f, -0.11802834f, -0.14417177f, 
    -0.14534056f, 0.02313169f, -0.01256537f, 0.02470634f, 0.19655168f, 0.01323484f, 0.19450873f, 0.01878709f, 
    0.02243450f, -0.16629855f, 0.12903452f, -0.31756493f, 0.12621282f, 0.02031821f, -0.06840702f, 0.13302149f, 
    0.03056967f, 0.03471866f, 0.14327018f, 0.04458047f, 0.12763865f, -0.07315693f, -0.06870908f, 0.11832181f, 
    0.07848445f, -0.00510082f, 0.14633735f, 0.04747458f, 0.17004436f, 0.03427661f, -0.17623900f, -0.24350242f, 
    0.15241797f, 0.03580446f, 0.16824900f, 0.25397852f, -0.05779651f, -0.03982110f, -0.14581549f, 0.04852463f, 
    0.03961657f, 0.06933794f, 0.01113070f, 0.02842456f, 0.37272558f, 0.46101347f, 0.16106676f, -0.01358438f, 
    0.08993281f, -0.02151083f, 0.11714063f, 0.06709052f, 0.03575484f, 0.00341218f, -0.03621386f, -0.01899017f, 
    -0.00209578f, 0.26089722f, -0.71415454f, 0.18235153f, -0.01654817f, -0.02932324f, -0.10530578f, -0.05651754f, 
    0.16880342f, 0.15370882f, -0.12198844f, 0.02034744f, 0.09090756f, 0.11514782f, -0.06213668f, -0.13558450f, 
    -0.01139684f, 0.07821709f, -0.02107690f, 0.00244291f, -0.06706607f, -0.14433557f, -0.14213942f, -0.10012726f, 
    0.13880418f, -0.20848086f, -0.14405571f, -0.35957807f, 0.03763767f, -0.10935190f, 0.00562713f, -0.12616417f, 
    0.01720063f, -0.07452303f, -0.11412230f, -0.02771023f, 0.01068941f, 0.51283199f, 0.02169713f, -0.04437932f, 
    -0.00055801f, 0.02258257f, 0.02810054f, 0.10520425f, 0.01840108f, 0.03919261f, 0.03873510f, -0.09426791f, 
    0.15511270f, -0.15891007f, -0.13895974f, -0.01173431f, 0.19775839f, 0.14645928f, -0.19825900f, 0.07801325f, 
    0.08477747f, -0.11865457f, 0.16200049f, -0.02520193f, -0.12645911f, 0.00921391f, -0.59732735f, 0.43202263f, 
    0.11380415f, -0.11092207f, -0.03363402f, -0.05334121f, 0.21220292f, 0.01981549f, -0.07872740f, -0.09577478f, 
    -0.29281798f, -0.04575223f, -0.20621035f, -0.09291681f, -0.07155851f, 0.04055597f, 0.15327683f, 0.17143960f, 
    0.16152734f, -0.09447388f, -0.12364617f, -0.07587114f, 0.31271043f, -0.44773570f, 0.02287593f, 0.15998134f, 
    0.00221521f, 0.01977929f, -0.01589601f, 0.26109922f, 0.03005005f, -0.04719618f, 0.19221920f, -0.10829278f, 
    0.42604223f, 0.01681663f, 0.16605446f, -0.11499993f, -0.00887097f, -0.04406317f, 0.00283131f, 0.10925115f, 
    -0.21869560f, 0.05615601f, 0.05965604f, -0.12500665f, -0.51840657f, 0.21948148f, -0.01922731f, -0.33269420f, 
    0.02038771f, -0.03074974f, 0.42594311f, 0.13453044f, 0.12285650f, -0.11046389f, 0.10415403f, 0.14973393f, 
    -0.14047103f, -0.29975429f, 0.26407707f, -0.04687968f, -0.06936698f, -0.17884439f, 0.04069425f, -0.06656332f, 
    0.26397401f, 0.08712519f, -0.02781796f, 0.18713981f, -0.36935109f, -0.27221474f, 0.09877686f, 0.10104363f, 
    0.06895108f, -0.06502460f, 0.06229157f, -0.00406087f, 0.02905753f, -0.06577375f, -0.14029619f, 0.03285234f, 
    0.17265441f, 0.27218178f, 0.22208536f, -0.02756051f, -0.05766445f, 0.02338208f, 0.16667499f, 0.14757946f, 
    -0.01880291f, 0.13796385f, -0.11439028f, -0.03311309f, -0.17529029f, 0.08028986f, 0.11162490f, 0.05932529f, 
    -0.04598437f, 0.10268759f, -0.09494965f, -0.14866588f, -0.02504832f, 0.08109063f, 0.08826011f, -0.09036596f, 
    0.29641718f, -0.07150788f, 0.15977558f, -0.14494403f, 0.15500136f, -0.03656390f, -0.05026545f, 0.07140920f, 
    0.07173418f, 0.12823303f, 0.04458044f, 0.25030532f, -0.04033181f, -0.03180799f, 0.10863508f, -0.26037440f, 
    0.15073541f, -0.08213674f, -0.16387941f, -0.24686497f, -0.09412048f, 0.06931442f, -0.10083277f, -0.08842908f, 
    -0.09101909f, 0.50538087f, -0.10433865f, 0.02006428f, 0.09510324f, 0.17396595f, -0.16810434f, 0.11939587f, 
    -0.13191864f, 0.07255043f, 0.02285890f, 0.16089998f, 0.07822699f, -0.29830766f, 0.22194366f, 0.30453378f, 
    0.05383967f, 0.02835760f, -0.14946611f, -0.02590967f, 0.10554731f, 0.11715355f, 0.47647783f, 0.30896130f, 
    -0.14215975f, -0.24117362f, 0.08034767f, -0.06403976f, 0.06708593f, -0.06075153f, 0.01795026f, 0.09229922f, 
    0.02987597f, -0.02607287f, 0.07304323f, 0.14459324f, -0.00318257f, -0.03415355f, 0.43444788f, 0.04887799f, 
    -0.03926820f, -0.14266694f, 0.08790306f, 0.01231654f, 0.14723697f, 0.12425384f, 0.01897231f, 0.04886013f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03494106f, 0.19201016f, 0.03662863f, -0.07852068f, -0.00117760f, -0.11925021f, 0.24573255f, -0.06236792f, 
    0.16843964f, 0.15069394f, 0.00359259f, -0.09345210f, 0.14898804f, -0.08723161f, 0.03087894f, 0.16991991f, 
    0.04348179f, 0.13398497f, 0.27385068f, 0.08656286f, 0.11847095f, 0.15248196f, 0.20204154f, 0.10018893f, 
    -0.02951338f, 0.04755492f, 0.06291438f, 0.13680398f, -0.12615770f, 0.10378233f, -0.06691518f, 0.17154181f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.12627625f, 0.19628055f, 0.02413629f, -0.08881585f, -0.12421304f, -0.22759710f, -0.14768405f, 0.25271440f, 
    -0.09755443f, -0.06466649f, 0.15809266f, 0.00823026f, 0.61125481f, -0.19003785f, -0.16810758f, -0.20422338f, 
    0.09861030f, 0.04417186f, 0.09682754f, 0.09410881f, -0.39034864f, 0.29273680f, 0.18561843f, -0.17250818f, 
    0.16534543f, 0.30668005f, 0.29444486f, 0.26324621f, -0.05477040f, -0.06618444f, 0.04379806f, -0.40428954f, 
    -0.15000242f, -0.26720241f, 0.17356375f, -0.44246167f, 0.15041538f, -0.03557123f, -0.00452120f, -0.13023736f, 
    -0.11133903f, 0.11370488f, -0.28421268f, 0.40145078f, -0.41574723f, -0.33866215f, -0.12581417f, 0.18638496f, 
    -0.36067963f, 0.02412106f, 0.26085547f, -0.27113897f, 0.43557709f, -0.02380167f, 0.18337950f, -0.01223960f, 
    0.19703273f, 0.22902761f, 0.26766151f, -0.02659191f, -0.13663001f, 0.68475926f, -0.02161498f, 0.20834322f, 
    0.16732877f, 0.00194853f, -0.02013859f, 0.04576192f, 0.07236478f, -0.07047431f, -0.12560062f, -0.14673398f, 
    -0.10279234f, 0.38075939f, -0.11001469f, 0.12041190f, -0.57939142f, -0.04389597f, 0.00826946f, 0.23488659f, 
    0.07580002f, 0.06072006f, 0.00878140f, -0.37164313f, 0.39164245f, 0.07710821f, 0.24466115f, -0.03603446f, 
    -0.23008990f, 0.23082104f, -0.24241035f, 0.77811199f, 0.28678608f, -0.21476094f, -0.30896190f, 0.25730321f, 
    -0.16666144f, 0.07250571f, -0.14165123f, -0.07112699f, -0.12365372f, 0.02184757f, -0.02778202f, -0.01173977f, 
    -0.04910002f, -0.08019965f, -0.06464127f, 0.01402066f, -0.11718789f, -0.15953338f, -0.10197291f, -0.16057962f, 
    -0.10260252f, 0.04958051f, 0.03691972f, -0.07306704f, 0.03940025f, -0.22342849f, -0.15911557f, -0.16993967f, 
    0.13985322f, -0.10433137f, -0.02626377f, 0.07166205f, -0.04632538f, -0.09587865f, -0.10004794f, -0.00720255f, 
    0.18393490f, -0.03730919f, 0.02155075f, 0.12888978f, 0.15054713f, -0.04143990f, -0.14256689f, -0.24867694f, 
    0.09929235f, -0.13082555f, -0.03823022f, -0.10304822f, -0.06956449f, -0.05230366f, -0.14719743f, -0.15263911f, 
    -0.11679780f, 0.01496116f, -0.06005274f, -0.15415722f, -0.11222913f, 0.18453754f, -0.06737161f, -0.16481332f, 
    -0.02583320f, -0.01664114f, 0.05166451f, 0.00846114f, -0.07619475f, -0.06051624f, 0.03583879f, -0.02748531f, 
    0.14513111f, 0.39246279f, -0.11933266f, -0.02345833f, -0.12652522f, 0.03159049f, 0.30845726f, -0.11335713f, 
    0.05567490f, 0.15883835f, 0.34311751f, -0.29429483f, -0.42799151f, -0.27873465f, 0.04057300f, 0.08286901f, 
    -0.00119184f, 0.19056755f, 0.11892001f, -0.16474800f, 0.07785164f, -0.36734346f, 0.10887194f, 0.31083071f, 
    0.25935733f, -0.48383144f, -0.82641262f, 0.12208568f, -0.01276572f, 0.03121094f, 0.08349096f, 0.26776755f, 
    -0.11127859f, 0.00703039f, -0.14298663f, -0.01085565f, -0.01839586f, 0.00389863f, 0.24430086f, 0.11540415f, 
    -0.17183137f, 0.28357142f, 0.09672970f, -0.08220504f, -0.17626640f, -0.74779594f, -0.12184027f, 0.19643277f, 
    -0.05181894f, -0.10995746f, 0.00583491f, 0.30035517f, 0.19346675f, -0.02351128f, 0.42217436f, 0.12485248f, 
    0.40376535f, -0.19704285f, -0.01220781f, 0.15164594f, 0.09092596f, 0.41114119f, -0.05687756f, 0.41674218f, 
    0.14092386f, 0.11158096f, 0.23525135f, 0.11449350f, 0.10367934f, 0.62966692f, 0.11858729f, -0.02031863f, 
    0.17053115f, 0.27482441f, 0.14177960f, 0.10803059f, 0.08470472f, 0.03752971f, 0.08150002f, 0.09725692f, 
    -0.18682611f, 0.31424862f, -0.05276204f, -0.02720111f, -0.10695722f, 0.34239098f, -0.14793634f, -0.28014562f, 
    0.02547477f, 0.08440822f, 0.05205160f, 0.33098757f, 0.22545634f, -0.29341942f, -0.14010628f, -0.14232533f, 
    -0.00429549f, 0.31194603f, 0.11851937f, 0.09287895f, -0.05570245f, 0.63994628f, -0.15542139f, 0.06989169f, 
    -0.14013647f, 0.08496951f, 0.11205147f, 0.06741187f, 0.26501963f, 0.58420527f, 0.00262577f, 0.20913021f, 
    -0.02338841f, 0.23796429f, 0.09980346f, -0.11748694f, -0.38318914f, 0.26388574f, -0.38682923f, -0.34332001f, 
    0.01690030f, -0.22534911f, 0.16806041f, -0.37249118f, -0.12747927f, -0.09441371f, 0.32514834f, 0.08739869f, 
    -0.04708180f, 0.31471148f, -0.30884176f, -0.11245660f, 0.04153814f, -0.21445945f, 0.22034268f, 0.42374751f, 
    -0.02789028f, 0.00208279f, 0.20730053f, -0.11627383f, 0.46071121f, 0.03868856f, -0.02534037f, -0.05218877f, 
    0.33539203f, 0.07307842f, 0.41115016f, 0.33101168f, -0.24551216f, 0.09421299f, -0.14269361f, 0.02288081f, 
    -0.46446574f, 0.11040933f, -0.16121994f, 0.30031744f, 0.11034549f, -0.28556791f, -0.14010195f, -0.38450703f, 
    -0.16137078f, -0.40652138f, 0.01816455f, -0.39213458f, -0.01953207f, -0.37763214f, 0.15801002f, 0.00033123f, 
    0.35029018f, 0.17234278f, 0.51460505f, 0.20201130f, -0.21099515f, -0.11289025f, 0.13351887f, -0.48015085f, 
    0.20631301f, 0.21402335f, 0.22088136f, -0.03263035f, 0.06834172f, 0.19275333f, 0.11434154f, -0.03667626f, 
    0.19147095f, 0.00555811f, 0.20003910f, 0.51097989f, -0.09299480f, -0.18785687f, -0.35640597f, -0.36179456f, 
    0.04684070f, -0.01892935f, -0.17098764f, 0.58893943f, -0.05860527f, 0.11834601f, -0.23417129f, 0.00329272f, 
    -0.66346443f, 0.10360290f, 0.19105268f, -0.06375339f, 0.04305105f, 0.67914635f, -0.00058312f, 0.45462444f, 
    0.25252578f, 0.23609754f, 0.11463797f, 0.18543321f, -0.15812752f, 0.01550503f, -0.04313074f, 0.10464648f, 
    -0.25471237f, -0.18503329f, 0.13319920f, -0.37443137f, -0.11359266f, 0.11584175f, -0.11955310f, 0.18430775f, 
    -0.07283010f, 0.23792572f, -0.15711772f, 0.07971266f, -0.06317741f, 0.13094130f, -0.06571522f, 0.00031820f, 
    0.02326252f, -0.06735189f, 0.11950184f, -0.10074524f, -0.22363926f, 0.06626056f, -0.09711415f, -0.05332413f, 
    0.04802531f, 0.09940819f, -0.05394733f, -0.15300418f, 0.13138789f, 0.03052121f, 0.00936007f, -0.17826951f, 
    0.15295218f, -0.20464465f, -0.06900386f, -0.06094482f, -0.18271056f, 0.24927448f, 0.04091608f, 0.19855177f, 
    0.09951454f, 0.51536959f, -0.15409073f, -0.32902315f, 0.10436694f, -0.17939168f, 0.25181651f, 0.09491697f, 
    -0.13561034f, -0.04200418f, -0.66444838f, -0.02828055f, 0.24525189f, 0.04389897f, 0.03129001f, 0.26203606f, 
    -0.04975727f, -0.01981335f, 0.26035285f, 0.02093552f, 0.00001718f, 0.15639825f, -0.04177490f, 0.01099261f, 
    -0.04579154f, -0.18564650f, 0.24846596f, 0.13757916f, -0.75990260f, 0.47480676f, 0.14702898f, -0.04655299f, 
    -0.00545887f, -0.15610619f, 0.18606375f, 0.48528218f, 0.15696329f, 0.57630771f, -0.33700103f, 0.12343388f, 
    -0.35232213f, -0.00866127f, -0.02110611f, -0.04565249f, 0.35072181f, 0.53572482f, 0.01557271f, 0.34679124f, 
    -0.08193453f, 0.12077230f, 0.06446797f, 0.31027800f, -0.26747164f, 0.01005444f, 0.05471532f, -0.16006890f, 
    0.22962686f, -0.04324331f, 0.33127430f, -0.51475322f, 0.11733748f, -0.07168844f, 0.05777418f, 0.24134493f, 
    -0.10014540f, 0.20606619f, 0.43637329f, 0.02925353f, 0.10018514f, 0.06877933f, 0.25568923f, -0.14081436f, 
    0.29570562f, -0.04707237f, 0.32440522f, 0.25018120f, 0.67129612f, 0.07485488f, -0.16709605f, -0.26961550f, 
    0.23748226f, 0.16900112f, 0.11436103f, 0.36033726f, -0.23370063f, 0.42224336f, 0.06946917f, -0.10022259f, 
    0.15734382f, 0.06197521f, 0.26875073f, -0.56398654f, -0.24697703f, -0.16887607f, 0.35277975f, -0.03153439f, 
    -0.11737106f, 0.36278152f, 0.05810456f, 0.31775054f, 0.07770134f, -0.02873797f, -0.13072471f, 0.21685825f, 
    -0.34849635f, 0.27309614f, 0.07212294f, -0.08892605f, -0.00678459f, -0.28768441f, -0.18070228f, 0.20237017f, 
    0.41932109f, 0.09417230f, 0.01654821f, 0.07624673f, -0.16191703f, -0.11578158f, 0.11048656f, 0.25231561f, 
    -0.03707100f, 0.03063862f, -0.26463157f, 0.44847614f, 0.30549681f, -0.39458773f, -0.13702911f, 0.03824094f, 
    0.06949957f, -0.18879771f, 0.06483736f, 0.17497358f, 0.15900236f, 0.36812544f, -0.37608060f, 0.08222940f, 
    0.38991165f, 0.25740594f, -0.07237601f, 0.44838658f, -0.20010233f, 0.81186742f, 0.13308197f, 0.17161931f, 
    -0.12619643f, 0.09972303f, 0.21036415f, -0.22273079f, -0.09782578f, 0.04490991f, 0.11794459f, -0.06007716f, 
    0.33485094f, 0.08914910f, 0.32861120f, 0.15583993f, -0.02184891f, 0.03112999f, -0.04894930f, -0.19637530f, 
    0.12775679f, -0.54649037f, -0.48223197f, -0.05637178f, -0.01983830f, -0.10307849f, -0.00942598f, 0.14660756f, 
    -0.11057451f, 0.28283200f, 0.07262155f, -0.10732412f, -0.09568889f, -0.08738244f, 0.10947914f, 0.09227662f, 
    -0.11776046f, -0.26392123f, 0.29763377f, 0.04407673f, 0.14522231f, -0.09869381f, 0.30180568f, 0.14432782f, 
    0.39881536f, 0.30278397f, -0.02446859f, 0.27373677f, -0.03879210f, 0.34120232f, -0.40219533f, -0.16060825f, 
    0.14448439f, 0.29172271f, -0.26777345f, 0.20596673f, -0.10331073f, 0.63476509f, -0.40802664f, -0.17507577f, 
    -0.10605872f, 0.23281342f, -0.18733408f, -0.05552978f, 0.14321280f, -0.23101279f, -0.13878617f, 0.31048000f, 
    -0.23043843f, 0.09991563f, -0.13623780f, 0.09727614f, -0.30079377f, 0.14447217f, 0.12809876f, 0.05372492f, 
    0.54060328f, 0.09326217f, 0.11176827f, -0.13982925f, 0.03189629f, 0.17029274f, 0.04215103f, 0.14737870f, 
    0.17030752f, -0.06437020f, -0.09435870f, -0.10546418f, -0.01509803f, -0.15499122f, -0.09918759f, -0.07798826f, 
    0.02367977f, -0.21442801f, -0.03157442f, 0.02118856f, 0.08218465f, -0.15948233f, 0.02928460f, 0.07000559f, 
    0.01454813f, -0.21672890f, -0.11098616f, 0.06266354f, -0.17986754f, 0.03104991f, -0.18216899f, -0.09731405f, 
    0.09675167f, -0.08817581f, -0.08682535f, 0.05597685f, -0.00805904f, -0.13900888f, -0.13405985f, 0.02517359f, 
    0.16192782f, 0.42875063f, 0.49714217f, -0.05018329f, 0.09430117f, -0.01354644f, 0.06294093f, 0.24513486f, 
    0.00033638f, 0.08352698f, -0.53579491f, 0.29502079f, -0.39244616f, 0.25708732f, -0.07576182f, -0.02329294f, 
    -0.28087395f, 0.27146760f, 0.15597238f, -0.28755146f, 0.07561719f, 0.44387659f, -0.25028047f, -0.25238168f, 
    -0.22790200f, 0.07992361f, 0.38423511f, 0.12558070f, -0.62445623f, 0.30661979f, -0.11158997f, -0.22580773f, 
    0.04961400f, -0.12484264f, 0.10819297f, 0.17750074f, 0.15129115f, 0.10454583f, -0.14624052f, -0.02144151f, 
    -0.06205209f, -0.18420659f, -0.07694806f, -0.12794380f, -0.03415525f, 0.10629595f, -0.12968461f, -0.00660411f, 
    -0.08395302f, -0.01622656f, -0.06596195f, 0.07515578f, -0.04008976f, -0.14086930f, 0.00224251f, 0.03478354f, 
    -0.11342800f, 0.04347191f, -0.04045476f, 0.01266461f, -0.19403316f, -0.03772459f, -0.01455409f, -0.01338446f, 
    -0.09650579f, 0.11649403f, -0.16526666f, 0.49643785f, 0.03713071f, 0.28243566f, -0.32941732f, 0.39921853f, 
    -0.34446627f, 0.36427334f, 0.29782462f, -0.20750767f, 0.30725458f, 0.06832767f, 0.16218245f, -0.06368295f, 
    0.33579418f, -0.22926526f, 0.13826604f, 0.05084578f, -0.35551655f, -0.27466485f, -0.20411649f, 0.28326094f, 
    0.11225025f, 0.29884180f, -0.07238482f, 0.38642287f, 0.02253138f, -0.13626133f, -0.23798031f, -0.03748534f, 
    -0.10177334f, 0.11346617f, 0.01941965f, 0.01641016f, -0.09610419f, -0.15762919f, -0.05044151f, -0.08327175f, 
    -0.05954438f, -0.10221101f, -0.21392658f, 0.01414172f, -0.14831299f, -0.16525573f, -0.10206459f, 0.14098106f, 
    0.12832560f, -0.20055526f, -0.16479446f, -0.06057665f, -0.00157026f, -0.17842050f, 0.02755699f, 0.06748137f, 
    -0.14434285f, 0.02438172f, -0.07797495f, 0.04423421f, 0.05311887f, 0.04393452f, -0.17247234f, -0.02594461f, 
    -0.04528546f, 0.25515020f, 0.38568074f, -0.53241479f, -0.13752131f, -0.05409151f, 0.35611963f, -0.24925643f, 
    0.05963548f, 0.20979065f, 0.07362075f, 0.10709026f, -0.39397696f, -0.75813538f, 0.00469393f, 0.16167642f, 
    -0.04743757f, 0.07705247f, -0.16941281f, 0.02726724f, 0.27742407f, 0.18907800f, 0.39483690f, -0.20186844f, 
    0.05115016f, -0.28942370f, -0.03573586f, 0.46855035f, 0.11525533f, 0.24057332f, -0.23219864f, 0.22659156f, 
    -0.14438049f, 0.12410067f, 0.13682655f, -0.12900342f, -0.04520456f, -0.07775953f, -0.00091906f, -0.06647327f, 
    -0.01797529f, -0.18561891f, 0.05670789f, -0.15406516f, 0.04186151f, 0.10969528f, 0.14699346f, 0.08978412f, 
    -0.11108487f, -0.01653253f, -0.15141188f, -0.14104103f, -0.01226302f, 0.14183076f, 0.14626342f, 0.04178399f, 
    -0.15000676f, -0.01471401f, -0.12551802f, 0.04566249f, 0.08554392f, -0.00159914f, -0.07635309f, -0.07489278f, 
    -0.10638669f, 0.72518098f, -0.21535294f, -0.06130203f, -0.07594568f, -0.33295032f, 0.00488920f, -0.15341845f, 
    -0.10992626f, -0.06513740f, -0.38048157f, -0.03151946f, 0.39756027f, -0.53652924f, -0.07659039f, 0.56079185f, 
    0.24973352f, 0.15725426f, 0.27877909f, -0.12613909f, 0.00628813f, 0.09250640f, 0.31446862f, 0.21813414f, 
    -0.39965811f, 0.30385405f, -0.20148908f, -0.11474734f, -0.20729665f, 0.26892897f, -0.25725162f, 0.27974018f, 
    -0.05067488f, 0.30628404f, 0.31249696f, -0.46860033f, 0.05413827f, -0.62918043f, 0.30412877f, -0.25089923f, 
    -0.10351722f, -0.15658179f, 0.26345503f, -0.08560722f, 0.40360928f, -0.45904812f, 0.01084436f, -0.19068401f, 
    0.30396092f, 0.49248672f, 0.21095464f, 0.37959427f, -0.02824295f, 0.10046320f, 0.41590604f, 0.19198224f, 
    -0.55709440f, 0.07128482f, 0.13823819f, -0.10650228f, 0.08138575f, -0.26788649f, 0.04922260f, 0.01377792f, 
    0.09237884f, -0.30559012f, 0.20135233f, 0.24789383f, -0.07723992f, -0.23344184f, 0.16106980f, -0.06156310f, 
    0.07583172f, 0.20045942f, 0.45315379f, 0.36446169f, -0.47710773f, 0.10293620f, 0.11027136f, -0.24549511f, 
    0.06791440f, 0.15301687f, -0.08206007f, 0.12271341f, 0.23883177f, -0.16943587f, 0.03784986f, -0.09344618f, 
    -0.16541342f, -0.25058493f, 0.22431830f, -0.16593882f, 0.31672600f, -0.24369219f, 0.00146351f, -0.09449771f, 
    0.12480766f, 0.08827112f, -0.10727486f, -0.11246674f, 0.08461376f, -0.14138880f, -0.19860834f, -0.24117966f, 
    -0.33673939f, 0.10499862f, 0.05082319f, -0.08494984f, 0.54911298f, -0.11954530f, 0.16285536f, -0.02265299f, 
    0.42833465f, 0.39019406f, -0.15372406f, 0.08721865f, -0.03724739f, 0.31925559f, 0.35830632f, 0.01006560f, 
    -0.45950079f, 0.08692496f, -0.00418384f, 0.25049525f, 0.05162969f, -0.53551966f, -0.15731181f, 0.34385657f, 
    0.03800025f, -0.04277049f, -0.05139029f, -0.02190637f, 0.06767239f, -0.04187690f, 0.14653423f, -0.13168497f, 
    -0.11171933f, -0.11124583f, -0.09750776f, 0.05113862f, -0.07538771f, 0.08337467f, 0.06306426f, 0.11608357f, 
    -0.07224341f, -0.17278597f, 0.03624833f, -0.09944604f, -0.05162990f, -0.02305028f, -0.03274557f, -0.13767231f, 
    0.08952168f, 0.09054760f, -0.06427230f, -0.08336017f, -0.11658978f, -0.08687578f, -0.17006795f, -0.01904861f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.17656259f, 0.31660765f, -0.09903200f, -0.00473945f, 0.05597096f, 0.07041027f, 0.16754948f, -0.12928404f, 
    -0.11085808f, 0.19948365f, 0.23392183f, 0.08393466f, -0.13865976f, 0.07155246f, 0.10960802f, -0.13962997f, 
    0.04420625f, -0.02936903f, 0.12042747f, -0.05241296f, -0.06977554f, 0.19797111f, -0.16837163f, -0.09114740f, 
    0.11240637f, 0.15310897f, 0.15207933f, 0.40241972f, 0.33445081f, -0.05547694f, 0.18433633f, -0.11398376f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.06713598f, 0.10115891f, -0.11792129f, 0.11149336f, -0.23625340f, -0.58641118f, -0.54718852f, 0.06144552f, 
    0.22888233f, -0.42349431f, -0.05104586f, 0.18519917f, -0.15284725f, -0.00153332f, 0.25127447f, 0.10173754f, 
    -0.61862922f, 0.25204077f, -0.25446838f, -0.21450466f, 0.04948106f, 0.23674180f, 0.13370250f, -0.62882841f, 
    -0.18700895f, -0.31051657f, -0.03607341f, -0.62846082f, -0.21805441f, 0.26536441f, -0.42548859f, 0.02484241f, 
    0.18060833f, 0.16732039f, 0.01959895f, 0.04072744f, 0.15084068f, 0.23338102f, 0.03782813f, -0.00117844f, 
    -0.38498184f, -0.10981159f, 0.44540289f, -0.78424531f, 0.14349082f, 0.06310511f, -0.44468185f, 0.10231467f, 
    -0.14236665f, -0.00468327f, -0.18672758f, -0.22704162f, -0.09531637f, 0.24228297f, 0.01825000f, -0.38124797f, 
    -0.13573772f, 0.23224108f, -0.05493134f, -0.18728121f, 0.18971016f, 0.14698842f, -0.27782333f, -0.10307419f, 
    0.31660289f, -0.02141526f, -0.08562084f, -0.11953247f, -0.22049293f, -0.82288820f, -0.01212524f, 0.01206656f, 
    -0.93720955f, -0.05683918f, 0.41821980f, 0.00465711f, -0.07019723f, -0.74743247f, 0.13669327f, 0.19812728f, 
    -0.04389007f, -0.00911110f, 0.11786648f, -0.07121968f, -0.15491028f, -0.69059855f, 0.03293331f, -0.17786337f, 
    -0.01215225f, -0.07377229f, 0.09174565f, -0.08874740f, 0.36834037f, 0.07453407f, 0.52686453f, 0.10196888f, 
    -0.06372795f, 0.00954318f, 0.20167185f, -0.08899605f, -0.12737021f, -0.58546996f, -0.10352027f, 0.21758282f, 
    -0.14712675f, 0.00800623f, 0.19004051f, 0.03894424f, 0.09874331f, -0.50266784f, 0.13938963f, -0.19829349f, 
    0.21721530f, 0.26007506f, 0.16911477f, 0.09082836f, -0.05906341f, -0.01978698f, -0.09527750f, 0.34522778f, 
    0.08911120f, -0.22478485f, -0.05893520f, -0.32963425f, -0.71064603f, 0.08882192f, -0.38239917f, 0.01217447f, 
    0.16321966f, -0.18618917f, -0.10131240f, -0.00471429f, -0.06996469f, 0.28273815f, -0.39274836f, -0.03512415f, 
    0.21194628f, 0.05837160f, -0.13854584f, 0.01366672f, -0.12531291f, 0.12748002f, 0.06883355f, 0.17371184f, 
    0.04362151f, 0.22405252f, -0.50299740f, 0.16717687f, 0.06246555f, 0.18840945f, -0.01039146f, 0.17115390f, 
    -0.02555376f, -0.55546027f, 0.01590263f, 0.03491186f, -0.24888924f, -0.21627933f, -0.00361234f, -0.01700378f, 
    -0.02849671f, 0.26555952f, -0.10065295f, 0.10030895f, -0.11791775f, -0.26088092f, 0.19687039f, -0.13242847f, 
    -0.14056562f, -0.39265785f, -0.42876258f, 0.03469064f, -0.08572161f, 0.28142923f, 0.08712307f, 0.07718808f, 
    -0.21839562f, 0.04493456f, -0.17595103f, 0.33043250f, -0.17986484f, 0.13934787f, -0.01642084f, -0.63531256f, 
    0.09803123f, -0.00016209f, -0.09392087f, 0.32433879f, -0.00005234f, -0.21084307f, -0.06653010f, 0.02105253f, 
    -0.33365905f, -0.48751333f, -0.47264501f, 0.06427121f, -0.20438452f, 0.14034799f, 0.13164014f, -0.89219415f, 
    -0.90165681f, 0.43256533f, -0.24366052f, 0.30473810f, 0.05604298f, -0.09197528f, -0.21131290f, 0.00979127f, 
    0.09442120f, -0.91686219f, -0.07985219f, -0.55272388f, 0.03644373f, -0.34086058f, -0.19053744f, 0.11652266f, 
    -0.07843339f, -0.36445570f, -0.07029611f, 0.29361358f, 0.41526198f, 0.18526505f, -0.01034883f, -0.02135651f, 
    -0.23030472f, -0.41178048f, -0.43514192f, 0.07717682f, -0.09087890f, 0.07238185f, 0.30643430f, -0.26027581f, 
    0.00922183f, -0.82011968f, -0.40448079f, 0.16329747f, 0.03505265f, -0.25164789f, 0.20953643f, 0.00092988f, 
    0.09964997f, 0.00148316f, 0.15426554f, 0.38696975f, 0.06156563f, -0.40579066f, -0.20252606f, 0.36650205f, 
    -0.10444845f, -0.22381125f, 0.14532730f, -0.66707522f, -0.40359190f, 0.17568944f, -0.30905572f, -0.01284906f, 
    -0.43321136f, 0.26839021f, 0.26534456f, 0.13212454f, -0.22204879f, -0.16061521f, 0.25194925f, -0.25277841f, 
    -0.15507644f, -0.55545837f, -0.27376589f, -0.61140466f, 0.08627445f, -0.18166098f, -0.23021212f, -0.46094137f, 
    0.17177175f, -0.02166944f, 0.32239014f, 0.15691374f, -0.00668725f, -0.53694797f, -0.00021067f, 0.13796647f, 
    -0.05021289f, 0.18737715f, -0.05597851f, 0.10498060f, -0.63137865f, -0.23844078f, -0.67393619f, -0.16279066f, 
    0.07944612f, -0.50040585f, -0.65473360f, -0.17113326f, -0.15975288f, -0.04352296f, 0.00210112f, 0.37821060f, 
    0.33964384f, 0.29507351f, -0.37705007f, 0.07100370f, -0.09949239f, -0.24414493f, 0.19748348f, 0.26377466f, 
    0.11957772f, -0.35519263f, -0.55147845f, 0.24408615f, -0.10689548f, -0.38736647f, 0.03287074f, 0.01351790f, 
    0.18289478f, -0.08764696f, 0.05753627f, -0.04574831f, 0.14250354f, -0.20244166f, 0.08852611f, 0.12380370f, 
    0.29956236f, 0.06164119f, -0.09551247f, 0.03877549f, 0.02891249f, -0.49707428f, -0.02138733f, -0.15640450f, 
    -0.58857799f, 0.49405655f, 0.30349320f, -0.25082684f, -0.20360665f, 0.42125890f, -0.52694410f, -0.37352264f, 
    -0.16660552f, 0.08611938f, 0.46953174f, -0.04561612f, -0.12499929f, 0.14171362f, 0.07035559f, 0.17543544f, 
    0.09737546f, -0.40321845f, 0.13452932f, 0.09412618f, -0.24223967f, -0.63519233f, -0.28058860f, -0.01788777f, 
    -0.73600024f, -0.22592881f, 0.61241108f, 0.09048961f, 0.01272287f, 0.16156770f, -0.07461486f, 0.21661776f, 
    0.08542926f, -0.26776773f, -0.11754980f, -0.00315428f, -0.00083416f, -0.63804626f, -0.28843251f, -0.36356142f, 
    0.31146690f, -0.16942847f, -0.26443282f, 0.05539424f, 0.11794984f, -0.26656514f, -0.18392262f, -0.04411419f, 
    -0.04230860f, 0.18586871f, -0.00963685f, 0.17832021f, 0.18031825f, -0.00607909f, 0.47565454f, 0.12469859f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.21909797f, -0.05285878f, 0.12169837f, -0.26969215f, -0.01682111f, 0.15878949f, 0.00179086f, -0.14106925f, 
    0.19619830f, -0.01508863f, -0.10433730f, -0.11497664f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
