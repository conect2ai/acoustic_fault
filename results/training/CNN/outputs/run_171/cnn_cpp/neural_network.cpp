#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.38351324f, 0.55728775f, 0.60743058f, 0.23696120f, 0.73417467f, -0.05361188f, 0.29143158f, -0.55452073f, 
    -0.29386908f, 0.09363478f, 0.15838236f, 0.20991838f, 0.28093386f, 0.21030495f, -0.10391802f, -0.02447639f, 
    0.00599511f, 0.25092193f, -0.02054000f, 0.16171671f, -0.23713233f, 0.29154643f, -0.04797988f, -0.12208830f, 
    -0.10049947f, -0.70504558f, -0.54759765f, -0.13966510f, 0.07531526f, -0.08744816f, 0.64256549f, 0.61498320f, 
    -0.03956647f, -0.02287401f, -0.26338235f, 0.06459728f, 0.28383058f, -0.35913655f, 0.18460546f, 0.35285261f, 
    0.05656504f, -0.09180414f, -0.18501519f, -0.28294033f, -0.03124575f, 0.09404290f, 0.26741603f, 0.17554297f, 
    0.08921210f, 0.13535200f, -0.04181160f, -0.39216787f, -0.03716446f, 0.34350488f, 0.29080281f, 0.55790257f, 
    0.59306538f, -0.28465775f, -0.00032522f, 0.28622681f, 0.11638895f, 0.18083282f, 0.19423731f, 0.00761250f, 
    -0.32710820f, -0.38339815f, -0.00994265f, -0.14429149f, -0.47271842f, -0.13050964f, 0.07244685f, -0.29265538f, 
    0.17510137f, -0.19155326f, -0.02511409f, -0.28716087f, 0.05203801f, -0.78933281f, 0.71266997f, 0.45619869f, 
    0.72271025f, -0.34685144f, -0.03338322f, 0.22135885f, -0.41850606f, -0.16201331f, -0.10247055f, 0.03385211f, 
    0.10004595f, 0.10357998f, -0.04599413f, 0.01841087f, -0.05622090f, -0.03591091f, 0.13235077f, -0.09237409f, 
    -0.18194991f, -0.02195171f, -0.14352295f, -0.03424480f, 0.67907602f, 0.42699644f, -0.30007058f, -0.22677372f, 
    -0.98334104f, -0.11036485f, 0.24007617f, 0.08733879f, -0.12943053f, -0.02686745f, 0.42200565f, 0.26051518f, 
    0.07514298f, 0.15322819f, 0.16904667f, -0.04484972f, 0.11972158f, 0.18522610f, 0.05101678f, 0.27679664f, 
    0.11445389f, -0.22804235f, 0.14058632f, 0.18797922f, 0.21539684f, 0.48436162f, -0.35862082f, -0.26049629f, 
    -0.54802847f, 0.46144587f, -0.20896900f, -0.46486712f, -0.25777349f, -0.30964899f, 0.32496288f, -0.38689190f, 
    0.11145950f, 0.30776337f, 0.10935616f, -0.36277783f, 0.17249011f, -0.07389051f, -0.02670611f, -0.14931969f, 
    0.21569110f, 0.20302661f, -0.07216256f, -0.14833221f, 0.25639969f, -0.09253612f, -0.24909806f, -0.88704067f, 
    0.16687334f, 0.32717291f, -0.46925160f, -0.00145803f, 0.63825399f, -0.35433742f, -0.08597849f, 0.22692655f, 
    0.14603010f, -0.16103753f, -0.25426385f, 0.27118659f, -0.07740538f, -0.13119739f, 0.15454920f, 0.00248077f, 
    0.29118526f, -0.14317891f, -0.08540019f, 0.00087501f, 0.32690895f, 0.04421257f, 0.13548185f, -0.57843035f, 
    -0.12383053f, -0.24261920f, -0.68807209f, -0.37424409f, 0.24472609f, 0.51642096f, 0.28224501f, 0.60820985f, 
    0.59746766f, 0.26334628f, 0.01417979f, 0.14440307f, -0.16746862f, -0.22746699f, 0.19165806f, 0.09574558f, 
    0.06401554f, 0.38179377f, 0.12090802f, -0.17968045f, -0.09994639f, -0.04899351f, -0.03878656f, 0.22913873f, 
    0.60891694f, 0.57886314f, 0.58950442f, 0.53783572f, 0.20909637f, 0.48187459f, -0.00923753f, -0.11268529f, 
    -0.64444697f, -0.37265974f, 0.16363223f, 0.24361047f, -0.03076302f, -0.00451653f, 0.01464617f, 0.07430495f, 
    -0.01377060f, 0.15936598f, 0.07564919f, 0.03632581f, 0.06844527f, -0.02763065f, 0.01102804f, 0.21060099f, 
    0.01184726f, 0.62634677f, 0.68621457f, 0.27504021f, 0.42267376f, 0.56046057f, -0.55833238f, -0.35905787f, 
    -0.07338570f, 0.04221274f, 0.08996575f, 0.42687494f, -0.08250520f, -0.17464568f, -0.13509962f, 0.11373486f, 
    -0.10643199f, 0.15392749f, 0.08092614f, -0.10089061f, 0.26012605f, 0.13727158f, -0.08740278f, 0.13295701f, 
    0.11369682f, 0.38273457f, -0.22854662f, -0.42291722f, -0.45988476f, -0.57950741f, -0.00481501f, -0.37346891f, 
    -0.52170491f, -0.23732936f, 0.34898791f, -0.51561648f, 0.21239249f, 0.40529141f, 0.33625862f, 0.10405573f, 
    0.08391653f, 0.23140354f, -0.17138904f, 0.08530467f, 0.02183911f, -0.00760390f, -0.05359050f, -0.28449935f, 
    0.02143998f, -0.17734684f, -0.08159957f, -0.31057328f, 0.13921604f, 0.32007152f, 0.89838862f, 0.16242726f, 
    -0.21431996f, 0.51887554f, 0.65037006f, 0.07506514f, 0.11111770f, -0.37099740f, -0.30405182f, -0.24567054f, 
    -0.11823586f, -0.15987247f, -0.13188018f, -0.24311833f, -0.03797049f, -0.04040804f, -0.13048646f, -0.02830056f, 
    0.02285738f, -0.10614131f, 0.29741958f, -0.34963036f, 0.68932712f, 0.31785491f, -0.16840045f, 0.74478334f, 
    0.80271536f, 0.49185976f, 0.30856988f, -0.12149763f, -0.10491674f, -0.10795546f, -0.01500342f, -0.18546344f, 
    -0.13547951f, -0.10325028f, -0.12809002f, -0.01789346f, -0.09074212f, 0.11656604f, -0.20365779f, -0.07835153f, 
    0.30602282f, 0.22201040f, 0.05464461f, 0.14229998f, 0.29548392f, -0.45039278f, 0.54720569f, -0.28817940f, 
    -0.47703984f, 0.07669199f, 0.46667579f, 0.16820744f, -0.53702861f, 0.00500349f, 0.15449646f, 0.59490013f, 
    -0.08761591f, 0.07281340f, -0.21154971f, -0.26269785f, -0.32308933f, -0.13401969f, -0.06692899f, -0.27395245f, 
    0.11317886f, -0.16648538f, 0.04031514f, -0.06174078f, 0.20086630f, -0.38895452f, 0.01644435f, 0.38755828f, 
    -0.51073909f, 0.58943915f, -0.39188942f, 0.22730841f, 0.30900723f, -0.08420685f, -0.25157318f, -0.23830691f, 
    -0.18668057f, 0.11857589f, -0.45444724f, 0.41975251f, 0.04975549f, -0.35084248f, -0.11162639f, -0.46760327f, 
    0.07010604f, -0.25643957f, 0.19604038f, 0.07226029f, -0.20671107f, 0.21897511f, 0.09000231f, 0.16659153f, 
    0.54042453f, -0.04655549f, -0.53343040f, 0.30479628f, 0.01603612f, -0.62723368f, -0.71573281f, -0.38555375f, 
    -0.43611223f, 0.24428536f, -0.33148843f, 0.01618305f, -0.11621285f, -0.08496644f, -0.13837817f, -0.12687232f, 
    -0.40947250f, -0.29169416f, -0.11739190f, -0.10253299f, 0.15493050f, 0.29481751f, -0.17716905f, -0.23616645f, 
    -0.68986607f, 0.03214803f, 0.60856807f, 0.24702539f, -0.05524332f, 0.31769359f, 0.73883128f, 0.23022027f, 
    -0.28480849f, 0.38104719f, -0.28064156f, 0.22663294f, 0.31868511f, -0.25998247f, -0.19202080f, -0.06765515f, 
    0.06753154f, 0.04497562f, 0.07529579f, -0.34048843f, 0.11773036f, 0.10596483f, 0.02959645f, 0.19719243f, 
    -0.09866581f, -0.72473520f, -0.45596346f, -0.36768585f, 0.16335839f, 0.16654259f, -0.02405914f, 0.43067077f, 
    0.61529964f, 0.19230241f, -0.05213419f, -0.22057377f, 0.11561323f, 0.10360912f, -0.10841403f, -0.20629711f, 
    -0.36788583f, -0.03491169f, -0.14309074f, -0.02700865f, 0.08029675f, 0.25214219f, 0.10120277f, 0.16667062f, 
    -0.38751438f, -0.00390260f, 0.51623350f, 0.20809570f, 0.64170277f, 0.71678221f, 0.01286917f, -0.23740187f, 
    0.18349075f, -0.21731818f, -0.29742882f, 0.37498274f, 0.01648331f, -0.19912228f, -0.04369676f, 0.28465697f, 
    -0.00854320f, -0.15620266f, -0.07011141f, 0.13305347f, 0.29871288f, -0.10466243f, 0.01231480f, 0.07821289f, 
    0.01052058f, 0.09161866f, 0.43733159f, -0.09474521f, -0.55684590f, -0.62867761f, -0.51014268f, -0.23468822f, 
    0.09266470f, 0.51913375f, -0.09942687f, 0.33380353f, 0.50764298f, 0.11536824f, -0.31068662f, -0.41727889f, 
    -0.26578277f, -0.22172181f, 0.05112908f, 0.29913551f, -0.19220757f, -0.25346798f, -0.09544589f, -0.01864640f, 
    -0.14246656f, -0.10221879f, 0.09096234f, -0.17786203f, -0.45496380f, -0.16830362f, 0.08409000f, -0.31324476f, 
    -0.04760796f, 0.13136753f, -0.11508580f, -0.01422360f, 0.17627367f, -0.76626307f, -0.20062627f, -0.19258618f, 
    -0.34019160f, 0.03846489f, -0.12602167f, 0.35067165f, 0.19654788f, -0.35552156f, -0.28344509f, 0.11485414f, 
    -0.13951567f, 0.03736278f, 0.31520754f, 0.10253789f, 0.09631129f, 0.78166771f, 0.45610148f, 0.25226107f, 
    0.25366423f, -0.20045999f, -0.11602233f, -0.20200725f, 0.24584353f, 0.27371621f, 0.63687330f, -0.28311422f, 
    0.32554695f, 0.17465071f, -0.50025064f, -0.03047219f, -0.16453789f, -0.32972559f, -0.24031793f, -0.17609255f, 
    -0.17499866f, -0.11079919f, -0.09853335f, -0.02196740f, -0.20265242f, -0.07960454f, 0.01222259f, 0.58133715f, 
    -0.31048688f, -0.81091070f, -0.15010592f, -0.16928078f, 0.36959991f, 0.20948459f, -0.28526828f, 0.19553110f, 
    0.35537973f, -0.04615728f, -0.18847476f, -0.00496905f, 0.27284008f, 0.24800172f, 0.04576024f, -0.13486075f, 
    0.10754818f, 0.03717761f, 0.21785058f, 0.37081128f, 0.21771061f, -0.05297591f, 0.32876638f, -0.31877339f, 
    -0.44183654f, -0.56216234f, -0.25187385f, -0.01685336f, 0.42442289f, -0.12006389f, 0.08558927f, 0.13629203f, 
    -0.32483339f, -0.27729949f, -0.00784758f, 0.30883032f, -0.18033597f, -0.54738849f, 0.12174619f, 0.03155928f, 
    -0.05698957f, -0.27538896f, 0.27647004f, -0.02914785f, -0.28015745f, -0.20759207f, 0.05587361f, 0.17957351f, 
    0.90527892f, 0.69439328f, 0.28535628f, -0.03486407f, -0.50138974f, 0.05896849f, 0.19410561f, -0.27823383f, 
    0.24845943f, -0.16477993f, 0.34574303f, 0.14390220f, -0.09862801f, 0.01577125f, 0.01077559f, 0.31430504f, 
    0.07291560f, -0.01812902f, -0.04429792f, 0.03072212f, 0.18106450f, 0.18367831f, -0.00439345f, -0.02958659f, 
    0.09785036f, -0.83348590f, 0.47982785f, 0.68346655f, -0.09087764f, 0.31059992f, 0.39422715f, 0.42828092f, 
    0.45933849f, 0.36018422f, 0.07562240f, -0.12997343f, -0.04219624f, 0.28919679f, -0.07574145f, -0.15290506f, 
    0.18426606f, -0.10136560f, -0.11920886f, -0.06312467f, 0.12343372f, -0.11449652f, -0.03073883f, -0.21677372f, 
    0.10849386f, -0.13527301f, -0.54384345f, 1.04656708f, 0.23583809f, -0.05876374f, 0.34272799f, -0.88401204f, 
    0.80373633f, -0.02101447f, -0.30367503f, -0.07859777f, 0.09880102f, -0.15679061f, 0.01270207f, -0.30985391f, 
    0.01492357f, 0.05979240f, 0.02398588f, -0.14616288f, -0.02791468f, -0.26867762f, 0.18734945f, 0.08119722f, 
    0.18378265f, 0.16337749f, 0.20344223f, -0.58869225f, -0.11456886f, -0.54185259f, -0.39941067f, -0.24495292f, 
    -0.34440014f, 0.20167474f, -0.23765138f, -0.07449093f, 0.45145828f, -0.34121218f, 0.26883548f, 0.24766299f, 
    -0.07390033f, 0.06023895f, -0.14177564f, -0.28816167f, -0.08842720f, 0.25593507f, -0.11922830f, 0.10586003f, 
    0.23507956f, 0.12896734f, -0.18248822f, 0.09052450f, -0.86438972f, 0.83408731f, -0.13235575f, -0.30184591f, 
    -0.90150481f, 0.49393156f, 0.29815182f, -0.63848060f, 0.21417192f, 0.25428209f, -0.24367796f, -0.11164514f, 
    0.12030528f, 0.06721345f, 0.22607993f, 0.21598588f, 0.21857916f, 0.16397022f, 0.09293058f, 0.02070071f, 
    -0.06000625f, -0.32277191f, 0.07652252f, -0.04449140f, 0.13438044f, -1.05214977f, 0.87009954f, 0.35243353f, 
    -0.67197442f, 0.13276795f, 0.43370751f, -0.28943443f, -0.32949957f, 0.16476159f, -0.56255955f, -0.28006232f, 
    -0.06417058f, 0.10905271f, 0.38229275f, 0.01056138f, -0.17928419f, 0.03247555f, -0.01784880f, 0.00725522f, 
    -0.07290716f, 0.06324276f, 0.21933693f, -0.07208102f, 0.07266200f, 0.06474202f, 0.65766191f, 0.52161580f, 
    0.33796054f, 0.44552082f, 0.61234456f, 0.10993405f, -0.28309497f, -0.02105902f, 0.28721282f, 0.11078925f, 
    -0.52333087f, -0.21835035f, -0.12746266f, 0.27931985f, 0.12794136f, -0.06769099f, -0.02692426f, -0.06470561f, 
    0.10375492f, -0.02954442f, -0.09315390f, -0.22398585f, -0.21201654f, 0.05006905f, -0.06671721f, 0.02506256f, 
    -1.18848574f, -0.43976536f, 0.43221715f, 0.58319062f, -0.35073316f, 0.40019920f, 0.04335779f, -0.15549222f, 
    0.33170161f, 0.12487037f, 0.13881038f, -0.18359372f, 0.04918260f, 0.23700148f, 0.00454603f, 0.01873112f, 
    0.07170915f, -0.01944067f, 0.04888089f, -0.13820408f, 0.09421288f, 0.01445381f, -0.00258883f, 0.09278729f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.03344022f, 0.10658605f, 0.03749153f, -0.01784959f, 0.18875451f, 0.14870624f, 0.02478003f, -0.05897168f, 
    -0.02978505f, 0.01855636f, 0.11300766f, 0.10338293f, 0.17995548f, -0.06677197f, 0.08816353f, 0.12219675f, 
    -0.03643265f, 0.14772725f, 0.21530610f, 0.16913649f, 0.20492014f, 0.24572861f, 0.24912620f, -0.12095043f, 
    0.28569183f, 0.02477426f, -0.01781452f, 0.00808711f, 0.04497221f, -0.09425767f, 0.03821770f, 0.26336065f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.13934143f, 0.01223239f, 0.17929557f, 0.11731048f, -0.01399786f, 0.03246182f, -0.03226788f, -0.01680887f, 
    -0.12713806f, -0.08164894f, 0.02209085f, 0.01359777f, -0.23194842f, -0.02747324f, -0.06368786f, -0.09449848f, 
    0.07489129f, 0.06456391f, 0.01407389f, 0.03593041f, -0.09773385f, 0.00865646f, -0.11927133f, -0.03060203f, 
    -0.09786487f, -0.10155211f, 0.04430990f, -0.05336183f, -0.08869689f, -0.02708698f, 0.07187375f, -0.04594272f, 
    0.00935643f, -0.07084074f, 0.02937025f, 0.05620375f, -0.14523445f, 0.21008565f, -0.14147663f, -0.27800611f, 
    0.02166995f, 0.02916391f, 0.13450968f, -0.01142330f, 0.00255193f, -0.11174087f, 0.05864063f, -0.04903306f, 
    0.16045460f, 0.04470424f, -0.13893832f, -0.03467103f, 0.03341864f, -0.03734112f, 0.06086590f, 0.08526132f, 
    0.03478755f, -0.09523898f, -0.07982954f, -0.09392852f, -0.10066262f, 0.06119070f, 0.01270246f, 0.19187006f, 
    -0.00864625f, 0.02840424f, 0.00888098f, -0.05481831f, 0.05152584f, -0.03942898f, 0.03797907f, -0.07735126f, 
    -0.31947795f, 0.18939854f, -0.01881242f, -0.10172101f, 0.06086895f, -0.01760267f, 0.03315276f, 0.00034941f, 
    -0.00347877f, -0.20442298f, 0.00566062f, -0.00320840f, -0.23344563f, 0.00153538f, -0.04053012f, 0.08647472f, 
    0.11958300f, 0.07462917f, 0.04767612f, -0.22368170f, 0.08372038f, -0.04597503f, 0.10145221f, 0.03980523f, 
    -0.13826762f, 0.08028384f, 0.21902482f, 0.29708141f, 0.02256083f, 0.04537260f, 0.00725904f, 0.08496834f, 
    -0.07402021f, -0.01340479f, 0.05456927f, 0.06084984f, -0.28907213f, -0.15120645f, 0.06885842f, 0.03619333f, 
    -0.01069889f, 0.05457935f, -0.07418226f, -0.06633678f, -0.03088504f, 0.02393494f, -0.04174111f, -0.05501057f, 
    0.10705446f, 0.06714632f, 0.02878879f, 0.17658564f, 0.07567633f, -0.01558591f, -0.01770172f, -0.03070866f, 
    -0.08814095f, 0.00360459f, 0.08567040f, 0.22824915f, 0.36590374f, -0.07886458f, 0.29711056f, -0.07673220f, 
    -0.05455857f, -0.11310625f, 0.12191182f, 0.03272296f, -0.01552980f, 0.05842722f, -0.03021080f, -0.07212694f, 
    0.03342137f, 0.22011884f, -0.01405655f, -0.08979703f, -0.05819422f, 0.07411424f, -0.06455014f, -0.03517381f, 
    -0.00423538f, -0.01198641f, 0.04531934f, -0.00287590f, -0.17633583f, 0.37570187f, -0.10251917f, 0.13304786f, 
    0.11286598f, -0.00276067f, 0.02984883f, -0.00427358f, -0.02044393f, 0.02099271f, -0.03741105f, 0.10637440f, 
    0.09413691f, 0.01641852f, 0.00822727f, -0.06823478f, 0.04629248f, 0.03270113f, 0.11054706f, 0.00312250f, 
    -0.09866109f, -0.02103299f, 0.00658599f, -0.03100621f, -0.07283872f, 0.05559623f, 0.03577295f, 0.25135258f, 
    -0.02071637f, -0.03292790f, -0.00854401f, -0.04710041f, -0.04951860f, 0.07976630f, 0.02319525f, 0.15188780f, 
    -0.06392930f, -0.10986246f, -0.01610777f, 0.05835167f, 0.15038703f, 0.00254092f, -0.05985983f, -0.01142463f, 
    0.00069968f, 0.03956638f, -0.04374925f, 0.06129662f, -0.08653926f, -0.13393998f, 0.06607038f, -0.02392136f, 
    0.01366846f, 0.08384554f, 0.02529283f, 0.01358426f, -0.03787299f, 0.05685224f, 0.08468722f, -0.06868736f, 
    -0.11116696f, 0.04529622f, 0.10448121f, -0.11684763f, -0.00648614f, -0.01081616f, -0.07436443f, -0.02089587f, 
    0.05205157f, -0.12147567f, 0.05224486f, 0.02412999f, -0.25058061f, 0.08110391f, -0.00953562f, 0.20518699f, 
    -0.00799551f, 0.06177811f, -0.05427691f, 0.09212246f, 0.06280939f, 0.04376337f, -0.06143695f, 0.04683810f, 
    0.09149377f, 0.22154625f, 0.08704732f, 0.02265040f, -0.03616152f, -0.00281660f, 0.12198144f, -0.10041112f, 
    0.08277466f, 0.05441268f, -0.01321573f, 0.13435224f, 0.08311321f, 0.06137878f, 0.04880386f, 0.03772437f, 
    0.01664645f, 0.03028113f, 0.01119621f, 0.01372978f, -0.12647644f, 0.02098327f, 0.05446523f, 0.03954955f, 
    -0.08314493f, 0.01673614f, -0.11621035f, 0.02529165f, 0.04723215f, -0.06136136f, -0.00881724f, 0.01452434f, 
    0.15473443f, -0.05320851f, -0.11011694f, -0.09401014f, -0.05977442f, 0.04594118f, -0.06346747f, 0.11431012f, 
    0.01868954f, 0.11891101f, -0.00354704f, 0.00687287f, 0.09163809f, 0.07690639f, 0.12520593f, -0.00207622f, 
    -0.06348943f, 0.11975797f, -0.06643875f, 0.20741089f, -0.08279947f, 0.03524243f, 0.01451596f, -0.01424858f, 
    0.00595845f, -0.04050915f, 0.04157794f, -0.05459112f, 0.05384956f, 0.04467002f, 0.01279875f, 0.11193739f, 
    0.06996854f, -0.05275188f, 0.01798028f, 0.06194942f, 0.01662960f, 0.07162445f, -0.05599376f, 0.01727664f, 
    -0.13870084f, 0.10672841f, 0.17959210f, 0.19017047f, 0.04734476f, -0.01417245f, -0.02696720f, 0.10972196f, 
    0.14434659f, -0.02400314f, -0.06112370f, 0.03154411f, -0.28757942f, 0.08090634f, 0.15991282f, 0.20943017f, 
    0.10006873f, 0.16060263f, 0.10749973f, 0.14623737f, -0.01952153f, -0.01185557f, 0.06358725f, 0.05610310f, 
    -0.20534299f, -0.05392407f, 0.16962224f, 0.07496177f, 0.06618644f, -0.07222684f, 0.01641786f, 0.01336997f, 
    -0.03463931f, 0.07528203f, 0.07194550f, 0.05374974f, 0.45076871f, 0.00429954f, 0.18045250f, -0.02926884f, 
    -0.00160791f, -0.01720690f, -0.03831963f, 0.03008945f, -0.02463509f, 0.04140041f, 0.03283813f, -0.10286812f, 
    0.08304147f, 0.15962967f, 0.12597562f, 0.05319414f, -0.05105543f, 0.02619038f, -0.00141991f, -0.08734345f, 
    -0.07300591f, 0.13950740f, 0.16461854f, 0.08153807f, -0.35114181f, 0.10239887f, -0.02346244f, -0.20618917f, 
    0.00941196f, 0.01368570f, -0.03738413f, -0.00449306f, 0.04136348f, -0.02711056f, -0.04528947f, 0.00088916f, 
    0.30347419f, -0.19585930f, -0.01932608f, 0.06313320f, -0.01775864f, -0.03757760f, 0.00815940f, -0.13248035f, 
    0.00038165f, -0.01112623f, 0.09215654f, -0.03102303f, 0.20637488f, 0.00712943f, 0.01163067f, 0.02502485f, 
    -0.08388052f, 0.01005244f, -0.03078801f, -0.01746041f, -0.04305644f, 0.08280982f, -0.04854583f, 0.02163710f, 
    0.31938317f, -0.11042709f, 0.03109035f, 0.08648082f, 0.08525418f, 0.11652050f, 0.02631179f, 0.00750160f, 
    -0.04645975f, -0.05670826f, 0.03217418f, -0.04161243f, 0.00623726f, 0.00146817f, -0.00104999f, 0.02465201f, 
    0.11252616f, -0.05174839f, 0.02421414f, 0.11658826f, -0.00308336f, 0.13660108f, 0.00875924f, -0.00738172f, 
    0.32239631f, -0.08836625f, -0.14037201f, -0.08119860f, -0.00906683f, -0.05353018f, -0.09045740f, 0.07944416f, 
    -0.04342579f, 0.09391602f, 0.06549571f, 0.06074588f, 0.15509927f, -0.01149115f, 0.05680327f, -0.15288179f, 
    0.04316033f, 0.02922981f, 0.02695861f, 0.05960060f, -0.02468551f, -0.00547911f, -0.05321162f, 0.02396126f, 
    0.17247729f, 0.01395207f, -0.18986148f, 0.19479491f, -0.02874418f, 0.00117720f, 0.03845705f, 0.01377848f, 
    0.06912244f, -0.10091329f, 0.03691384f, 0.05323434f, 0.03584118f, 0.14472421f, 0.04064675f, -0.03477420f, 
    -0.08487514f, -0.13815288f, 0.05369430f, 0.06629279f, 0.02083450f, -0.02930189f, 0.00615729f, 0.03567019f, 
    0.11132054f, -0.19393787f, 0.06039839f, 0.30009827f, 0.01828743f, 0.02694750f, 0.06865183f, -0.08409176f, 
    0.02061077f, -0.01508996f, 0.03700493f, 0.08384094f, 0.21653661f, -0.03300006f, -0.11101081f, 0.22652635f, 
    0.05852478f, 0.01656068f, 0.05527475f, 0.07272292f, -0.10694084f, 0.11022028f, 0.02599292f, 0.09675606f, 
    0.06962785f, 0.16151744f, 0.10607947f, -0.05860498f, -0.01796906f, -0.03073012f, 0.00264107f, 0.15187253f, 
    0.03375933f, 0.14023483f, 0.07552397f, 0.00676414f, -0.16160926f, 0.10674139f, -0.12259807f, 0.12695213f, 
    0.00602286f, -0.04134212f, -0.01478025f, -0.02621762f, -0.00266539f, 0.01884363f, -0.04921174f, -0.00350675f, 
    0.11941451f, -0.24569982f, 0.07925447f, 0.20332626f, -0.02035768f, 0.00192230f, -0.01242962f, -0.05243104f, 
    0.05255928f, 0.10492344f, 0.01829246f, 0.15315153f, 0.13856775f, -0.04109001f, 0.19223061f, -0.08107081f, 
    0.08808848f, -0.05767350f, -0.09899724f, 0.01535137f, -0.09246146f, -0.06363010f, -0.00968744f, -0.04867863f, 
    0.16831727f, -0.11279842f, -0.18286672f, 0.17810546f, -0.11525133f, 0.01064102f, 0.00783295f, 0.02413386f, 
    0.09122482f, -0.01990921f, -0.05916957f, -0.00430724f, 0.26337898f, -0.00800305f, -0.03869594f, -0.17990662f, 
    0.13134009f, -0.02624165f, 0.09056006f, -0.05907737f, 0.08227928f, 0.07523393f, -0.04850150f, -0.02679369f, 
    -0.13515401f, 0.09245156f, -0.05546482f, -0.02557274f, -0.08593176f, 0.06019005f, -0.02610466f, 0.03681225f, 
    -0.06758402f, 0.01497295f, 0.07353628f, -0.15186374f, 0.09252188f, 0.04029026f, -0.01826785f, 0.01137887f, 
    -0.00174010f, 0.01544035f, 0.04225457f, 0.02442176f, 0.08197913f, -0.08856429f, -0.05739256f, -0.01156021f, 
    0.13271727f, -0.09860238f, -0.11304434f, 0.24910387f, -0.04039418f, 0.02306933f, 0.08413367f, 0.02090363f, 
    -0.09263234f, 0.09840958f, 0.11249328f, -0.06770714f, 0.31121573f, -0.02999225f, -0.03508362f, -0.15599959f, 
    -0.07114949f, -0.02349319f, -0.00371743f, -0.05094581f, 0.13059118f, 0.02946516f, -0.14502053f, -0.05903781f, 
    -0.17966558f, -0.00905069f, 0.07528615f, -0.07171575f, -0.06514859f, 0.00638711f, 0.04479276f, 0.04500641f, 
    0.01568499f, 0.13688399f, -0.02309184f, 0.00607578f, 0.19669034f, -0.01528016f, -0.07322582f, 0.03376465f, 
    0.03049756f, -0.07448290f, 0.01673284f, -0.09488367f, 0.05302074f, -0.08192822f, -0.12169299f, -0.00905779f, 
    0.11290890f, 0.22261886f, -0.03875332f, -0.21039240f, -0.09192941f, 0.03985737f, -0.04389614f, -0.00532325f, 
    0.03033323f, 0.10243893f, 0.03287330f, 0.03086465f, 0.08265317f, 0.02666876f, 0.18801735f, -0.03488137f, 
    -0.12188882f, -0.01700420f, 0.05109899f, -0.02902665f, -0.03733784f, -0.03712946f, 0.05269443f, -0.05386651f, 
    0.24310091f, -0.20423877f, -0.06356217f, -0.09470628f, -0.04336987f, -0.11565918f, -0.04950302f, 0.08733311f, 
    -0.10768140f, 0.03921552f, -0.06905531f, 0.18971561f, -0.18624164f, 0.16293009f, -0.01654387f, -0.01765672f, 
    0.04966492f, -0.02863745f, -0.08945247f, -0.09341942f, -0.06184550f, 0.04149947f, 0.09189547f, -0.00260092f, 
    0.01074310f, 0.24418779f, -0.17540984f, -0.10112543f, 0.05200001f, 0.18108226f, -0.02598139f, 0.01769386f, 
    0.06896071f, 0.03005264f, 0.09585389f, 0.04323513f, 0.09591905f, 0.23051789f, 0.03451913f, -0.06057750f, 
    0.03035859f, -0.10326482f, -0.07648084f, 0.03977416f, -0.03576875f, 0.00273713f, 0.00106941f, -0.01926255f, 
    -0.28595516f, 0.07932619f, -0.02676800f, -0.11223093f, 0.07232794f, 0.02278374f, -0.07873923f, 0.02633529f, 
    0.02437195f, -0.02460141f, 0.04337675f, -0.00639532f, -0.07794097f, -0.00819717f, -0.07805732f, 0.02724592f, 
    -0.00747800f, 0.09095589f, 0.03811177f, 0.01510234f, 0.03925363f, 0.06462863f, 0.06519250f, -0.00853668f, 
    0.11148915f, -0.19924048f, -0.20029032f, 0.13586876f, -0.00009933f, 0.08058363f, 0.03850911f, 0.02705864f, 
    0.09800761f, -0.14064476f, -0.02032610f, 0.02200166f, 0.31402901f, -0.09496187f, -0.00370254f, 0.13420451f, 
    0.04131171f, 0.11743743f, 0.00546551f, 0.02629717f, -0.01518843f, -0.06123189f, 0.01679708f, 0.03003755f, 
    -0.16172448f, -0.00871659f, 0.14765614f, 0.16314012f, 0.15124318f, 0.08508635f, -0.04358693f, 0.00995296f, 
    -0.07230347f, 0.08362292f, -0.11322118f, 0.02607487f, 0.08852129f, -0.01838278f, 0.19196193f, 0.03852208f, 
    -0.02469549f, -0.01885093f, 0.04246206f, 0.06770113f, 0.03314597f, -0.04113410f, 0.11893741f, -0.03461333f, 
    -0.13684452f, -0.17378430f, 0.09724054f, -0.01187351f, 0.00178891f, 0.03736126f, -0.07713204f, -0.04249647f, 
    0.11013562f, 0.13312146f, -0.05238522f, 0.05873504f, 0.00492695f, 0.08461314f, 0.06602305f, 0.02875117f, 
    -0.01430869f, 0.03111342f, 0.10391718f, -0.08608247f, -0.00866589f, -0.08717546f, -0.01310750f, 0.09694322f, 
    -0.10388772f, 0.22643681f, -0.04517286f, -0.01996668f, -0.02075434f, -0.03885286f, 0.13756707f, -0.04299461f, 
    -0.04705377f, -0.17132404f, -0.04902178f, -0.16738340f, -0.29158768f, 0.11355472f, -0.10541555f, 0.12158301f, 
    0.09437171f, 0.05790531f, -0.04204011f, -0.14378680f, -0.01135805f, 0.08552931f, -0.02685387f, 0.01295353f, 
    0.20787752f, -0.10990337f, 0.39186957f, -0.23040321f, 0.06043298f, 0.08156258f, -0.00779021f, -0.07809334f, 
    -0.06596960f, -0.03105555f, 0.04949786f, 0.03790439f, -0.06037851f, 0.08428628f, 0.13024260f, 0.16639331f, 
    0.05443097f, 0.11529452f, -0.00872406f, -0.10883649f, 0.00723291f, -0.08772885f, 0.06336798f, 0.05396725f, 
    -0.21222809f, 0.00461295f, -0.10465755f, 0.02601250f, 0.03103954f, 0.00010678f, 0.05770888f, 0.00485368f, 
    -0.05817904f, -0.07248572f, -0.05125609f, -0.02155371f, -0.23594548f, 0.04545197f, 0.01407287f, -0.14242341f, 
    0.00914220f, 0.03509054f, -0.01097348f, 0.00755696f, 0.04472753f, -0.14394918f, 0.06244144f, -0.01325945f, 
    -0.11094239f, -0.04313812f, -0.08585803f, 0.03307206f, -0.04844275f, -0.00772824f, -0.02890485f, -0.04910417f, 
    0.08752399f, 0.02153949f, 0.05048425f, -0.02728006f, 0.22773616f, -0.03377929f, 0.14932680f, -0.16291782f, 
    -0.06057259f, -0.07517789f, 0.10524175f, -0.08574995f, 0.07207970f, 0.01818666f, 0.11225200f, 0.06628332f, 
    -0.31375951f, 0.17498717f, 0.04132724f, -0.05936933f, 0.17360140f, -0.02059929f, 0.03328247f, -0.07236884f, 
    0.07572979f, -0.00311019f, 0.03143507f, -0.03810937f, 0.05769240f, 0.26184213f, -0.01252247f, 0.04731840f, 
    0.01857167f, 0.02860175f, -0.05139785f, 0.06384080f, 0.03025548f, 0.07325424f, 0.01724511f, 0.12101170f, 
    0.04426976f, 0.12771040f, 0.04528230f, -0.09453462f, 0.13898560f, -0.05253764f, -0.01729462f, -0.13572749f, 
    -0.08927987f, 0.04659758f, 0.16658731f, 0.05161929f, -0.05062773f, 0.12030749f, -0.10732128f, 0.10471105f, 
    0.09035751f, 0.05410120f, -0.06615296f, 0.01924076f, 0.04917343f, -0.00411709f, 0.11119486f, -0.04859556f, 
    0.43284494f, -0.27600154f, 0.06877230f, -0.08017285f, 0.00778238f, -0.07094029f, 0.13523735f, 0.02026787f, 
    -0.00869070f, 0.08601731f, -0.03810397f, 0.14225201f, 0.07001615f, -0.06028390f, 0.11979349f, 0.08911432f, 
    -0.02117603f, -0.05147766f, -0.01171565f, -0.06747200f, -0.02531911f, 0.03985479f, 0.00548950f, 0.02164759f, 
    -0.10585048f, -0.03982352f, -0.04720508f, -0.11513314f, 0.07152043f, 0.06227639f, -0.06612447f, -0.05325552f, 
    -0.05538810f, -0.04901544f, -0.03232676f, 0.06365434f, -0.17911485f, 0.09091295f, 0.11885824f, 0.14029090f, 
    0.03902302f, 0.11370335f, 0.04082327f, 0.13196386f, -0.04594764f, 0.05434862f, 0.05116931f, 0.07416314f, 
    0.11335195f, 0.06102751f, -0.04905190f, 0.24758559f, 0.08415684f, 0.03245461f, -0.04979046f, -0.00014942f, 
    -0.11113846f, 0.03357587f, -0.03077139f, -0.02266422f, -0.06470682f, 0.10216905f, -0.04654254f, -0.16854568f, 
    -0.00360642f, 0.11247573f, -0.07405338f, 0.04206498f, -0.08838338f, 0.11132313f, 0.02976357f, 0.02623419f, 
    -0.18992187f, 0.10273307f, 0.14889653f, 0.21864450f, 0.09915812f, -0.13542247f, -0.03578576f, -0.03863699f, 
    -0.04061816f, -0.13387178f, 0.02461788f, -0.03718306f, -0.00687596f, -0.03412578f, 0.02135555f, 0.20166773f, 
    0.15333581f, 0.05809932f, -0.06514702f, 0.02278479f, -0.02271883f, 0.15539549f, -0.02531286f, -0.01263987f, 
    -0.18578584f, 0.18861665f, -0.11547913f, 0.05033531f, -0.00542982f, 0.12059866f, -0.00545927f, 0.01211369f, 
    -0.00905200f, -0.03220244f, 0.11264113f, -0.14189337f, 0.29371768f, -0.19880991f, 0.10166194f, 0.04827224f, 
    -0.12740609f, -0.14457369f, 0.03446095f, 0.01106738f, 0.02919109f, 0.00562317f, -0.04665736f, -0.04371693f, 
    0.23860388f, -0.22148329f, 0.19252087f, 0.19983512f, 0.11127935f, -0.05682933f, 0.01278822f, 0.02745411f, 
    -0.14883284f, 0.00349518f, -0.00992754f, 0.02921783f, -0.08059575f, -0.02019653f, 0.06111171f, 0.17657717f, 
    -0.02547191f, 0.11204303f, -0.05043088f, -0.09137531f, 0.04441734f, -0.05076597f, 0.04508133f, 0.15877892f, 
    0.41045251f, 0.23108180f, -0.07057223f, 0.05885331f, 0.11384130f, 0.00611081f, -0.00935579f, 0.20521453f, 
    -0.01296084f, -0.04430728f, 0.04622322f, 0.03322032f, 0.43752494f, 0.08793427f, 0.10380242f, 0.07120848f, 
    0.09225978f, 0.08768569f, -0.13198131f, 0.04460908f, -0.08001026f, -0.03090680f, 0.00672053f, 0.03821410f, 
    -0.23551308f, 0.04960460f, 0.12220138f, -0.10620213f, 0.09664689f, 0.04530569f, -0.00206177f, -0.09604235f, 
    -0.06796876f, 0.06397039f, 0.12729590f, 0.04607002f, -0.08949101f, -0.01288444f, 0.13087115f, -0.17605236f, 
    -0.05589005f, 0.12127122f, -0.00781084f, -0.20019171f, 0.10195059f, -0.01369406f, 0.02956881f, -0.01038446f, 
    0.21524635f, 0.06526988f, -0.03683630f, 0.03708938f, -0.05960845f, -0.10626644f, 0.08484962f, 0.02621535f, 
    -0.03222408f, -0.08558788f, 0.15287524f, 0.04372034f, -0.42700967f, -0.04899937f, -0.11202741f, -0.02464210f, 
    0.04637154f, 0.06859975f, 0.03495089f, 0.03470920f, -0.02454684f, 0.11013462f, -0.16194068f, 0.05765370f, 
    0.01823622f, 0.06331437f, 0.03866922f, 0.03962264f, 0.10831989f, 0.07350089f, 0.17847969f, 0.03956678f, 
    -0.09437030f, -0.17481764f, 0.07887107f, -0.17078108f, -0.17700458f, -0.06718310f, 0.02954173f, -0.26288858f, 
    -0.04113133f, -0.03681707f, -0.00852255f, -0.00763057f, -0.04872485f, 0.11842991f, 0.08845774f, 0.07063452f, 
    0.24856040f, 0.04967303f, 0.01299719f, 0.00899020f, 0.10938431f, 0.04160850f, -0.02908321f, 0.03781486f, 
    -0.01513454f, 0.03476387f, 0.03418716f, 0.15702932f, 0.17219165f, -0.12907159f, -0.08400366f, -0.02631379f, 
    -0.02861455f, -0.13381672f, 0.17781720f, 0.09329847f, 0.06226757f, 0.08411513f, -0.04315846f, 0.02641881f, 
    -0.40524912f, 0.19721583f, -0.35760295f, 0.21105249f, 0.07514276f, 0.09453461f, 0.08246791f, 0.07558998f, 
    0.02383088f, -0.08554388f, -0.09711175f, -0.10275223f, 0.01533508f, -0.16054557f, -0.00275605f, -0.08301576f, 
    0.03767091f, -0.04530158f, 0.00113325f, 0.01920497f, -0.00685174f, 0.00776333f, -0.00235320f, 0.08956160f, 
    0.38940379f, 0.13034695f, 0.14417021f, 0.13994151f, 0.02820616f, 0.07898445f, -0.08650889f, -0.02817027f, 
    0.01985729f, 0.14814010f, 0.09766638f, 0.13227370f, 0.23719756f, -0.09086223f, 0.12877704f, 0.10273395f, 
    0.01423530f, 0.02470603f, -0.03021765f, -0.01632421f, -0.02178178f, 0.06736321f, 0.00295250f, 0.07919814f, 
    0.01884101f, -0.07182911f, -0.05840819f, 0.06244914f, 0.11518638f, 0.03012706f, -0.03282870f, -0.02102213f, 
    -0.11459436f, 0.03687701f, 0.07930000f, 0.18578540f, 0.10706345f, 0.20593025f, 0.01524213f, 0.11184365f, 
    0.05832453f, 0.01650276f, -0.01374859f, 0.14485252f, -0.00932702f, 0.05896865f, -0.13989796f, -0.09866837f, 
    0.31228513f, 0.13257593f, 0.06435187f, 0.06019620f, -0.00213967f, 0.06322015f, -0.03646541f, 0.07940368f, 
    0.06828679f, -0.05789163f, -0.01426283f, 0.00103982f, -0.15256883f, -0.25986856f, -0.04030912f, 0.01003345f, 
    0.06058002f, 0.03684814f, 0.08338685f, -0.09841970f, -0.00308155f, -0.13937925f, -0.02844132f, -0.13016230f, 
    0.04997992f, -0.02322305f, 0.02456639f, -0.04599664f, -0.13372661f, 0.15748340f, 0.01842210f, 0.07651820f, 
    0.02120938f, -0.10898890f, -0.05424311f, -0.18038189f, 0.02471785f, -0.13118276f, 0.11125469f, 0.14367965f, 
    -0.02531637f, -0.01525187f, 0.09511730f, -0.07719827f, 0.00670116f, 0.05691814f, 0.04011726f, 0.15148146f, 
    -0.38207737f, 0.26275921f, 0.01074615f, 0.04437148f, 0.09281979f, 0.04600705f, -0.05320992f, 0.02444619f, 
    0.00500099f, -0.03449547f, -0.02637065f, -0.02690087f, -0.26161930f, 0.06064903f, -0.02401162f, -0.04952221f, 
    0.12315158f, 0.14980267f, -0.05796938f, -0.00306462f, 0.02250325f, -0.08122042f, 0.06002973f, -0.09906249f, 
    0.32620856f, 0.17282514f, 0.06366288f, 0.07751503f, 0.03610418f, -0.04412801f, -0.00011381f, 0.12605916f, 
    0.09671965f, -0.01241838f, 0.04556252f, 0.06955330f, 0.09979820f, -0.11479528f, -0.15992486f, -0.02464112f, 
    0.16446245f, -0.00366979f, -0.05392437f, 0.02599334f, 0.02814223f, -0.00395181f, -0.15289058f, -0.01602286f, 
    -0.07000527f, 0.00596904f, 0.05383223f, -0.04318476f, -0.05072771f, 0.02241597f, 0.10130952f, 0.06285607f, 
    0.08489012f, 0.07944199f, -0.12433109f, 0.08110121f, 0.28048280f, 0.02042441f, 0.15304679f, 0.02755607f, 
    0.05312539f, -0.07536268f, 0.06415373f, 0.00242209f, 0.07722426f, -0.08781563f, -0.03225679f, -0.05699454f, 
    0.02936667f, -0.05919400f, -0.08544761f, -0.11939417f, 0.06209290f, 0.06377469f, 0.07969581f, 0.06015577f, 
    0.11907137f, 0.12307046f, -0.00429147f, 0.00520914f, -0.13710152f, -0.07864898f, -0.08552806f, -0.03767803f, 
    0.07451136f, 0.10645702f, 0.01421597f, -0.08338886f, 0.08601738f, -0.05850132f, 0.05635526f, 0.06389193f, 
    0.42208236f, 0.06824229f, 0.08734418f, 0.00674241f, 0.05559320f, -0.00156737f, -0.06825761f, 0.01376335f, 
    0.03178630f, 0.06569153f, -0.05385962f, 0.06878090f, -0.16643941f, 0.22461925f, 0.10106424f, 0.01093735f, 
    0.16065912f, 0.14988317f, -0.02666169f, 0.06149553f, 0.06466904f, -0.04064056f, 0.08927018f, 0.03686927f, 
    -0.00775225f, 0.02579169f, -0.17403704f, 0.07702621f, -0.21572590f, 0.10384892f, 0.05765112f, 0.05757822f, 
    0.19794397f, 0.05231535f, 0.00483179f, 0.03911048f, -0.20260617f, -0.10709529f, -0.10058730f, -0.05626053f, 
    0.15304461f, -0.01231725f, 0.05327127f, 0.18247369f, 0.01832255f, -0.02993237f, 0.04198960f, -0.07614125f, 
    -0.38731575f, -0.23224738f, 0.16297229f, -0.07746599f, -0.05392916f, 0.01324954f, -0.04970410f, -0.14741139f, 
    0.11059681f, -0.01250002f, 0.08449098f, 0.00445047f, -0.43530300f, -0.18753988f, 0.02389652f, 0.06155208f, 
    -0.17620888f, 0.04717162f, 0.03015675f, 0.05501450f, 0.07658978f, -0.05223038f, 0.11263397f, 0.04230182f, 
    0.26682839f, 0.00559611f, 0.07520068f, 0.05437928f, 0.00607261f, -0.07165632f, -0.04756029f, 0.01432197f, 
    0.01403872f, 0.04007670f, -0.04355620f, 0.00576351f, -0.33793378f, 0.14975701f, -0.09564650f, -0.02772893f, 
    0.11764089f, -0.04375004f, -0.00113414f, 0.16606496f, 0.04541298f, 0.05996650f, 0.00001828f, 0.08906063f, 
    -0.05252913f, -0.05866516f, 0.00094100f, 0.02976715f, 0.01871544f, -0.02420989f, 0.02965486f, -0.01413781f, 
    -0.01060092f, -0.05359630f, -0.04428121f, -0.01143612f, -0.00020908f, -0.00010947f, -0.01757806f, -0.02851748f, 
    0.03476672f, -0.00204911f, -0.03546063f, -0.02267927f, 0.01712555f, -0.02603629f, 0.03144754f, -0.03335063f, 
    -0.04326012f, 0.03388374f, -0.04825654f, 0.01166344f, 0.02921348f, -0.01269296f, -0.04394448f, -0.00688257f, 
    0.04274488f, 0.02673144f, -0.02277019f, -0.03387706f, 0.02391563f, -0.00683881f, 0.00915270f, -0.00547101f, 
    -0.03789296f, -0.00777234f, 0.01979924f, -0.01406205f, 0.03911525f, -0.05537635f, -0.03398576f, -0.04521709f, 
    0.01979066f, -0.01544603f, -0.03560467f, -0.02960054f, 0.00957819f, -0.05348347f, -0.01667621f, 0.03264268f, 
    -0.03335404f, 0.03374542f, -0.03684863f, 0.00840618f, 0.00523073f, -0.03687060f, 0.04189181f, 0.01739704f, 
    0.02252986f, 0.03356214f, 0.04803734f, 0.01598908f, -0.04088690f, -0.02145165f, 0.01962213f, -0.02132024f, 
    0.01590272f, 0.03339574f, -0.04069659f, 0.01617619f, 0.02370803f, -0.03169825f, -0.01004918f, -0.02604757f, 
    -0.01044939f, 0.01768920f, -0.01350550f, 0.02444210f, -0.03530152f, 0.01131196f, -0.03703536f, -0.02064065f, 
    0.01820046f, 0.01284860f, -0.04318193f, 0.02318054f, 0.01804608f, -0.02973643f, -0.04372828f, 0.01979883f, 
    -0.00576559f, -0.00116037f, 0.02238417f, 0.03358001f, 0.02133017f, -0.04076518f, 0.01088663f, -0.02369186f, 
    -0.03379708f, -0.01496080f, 0.02301207f, -0.01220394f, -0.04913931f, 0.00952643f, -0.01209722f, 0.04612679f, 
    0.04763970f, 0.02429115f, 0.01660262f, 0.01000251f, -0.03677661f, -0.02128124f, 0.01946866f, 0.03233389f, 
    -0.03483326f, -0.03612707f, -0.03920693f, -0.03500774f, -0.04305088f, -0.04492391f, 0.00386192f, 0.00834152f, 
    -0.01068548f, 0.03617340f, -0.03402497f, -0.04814450f, -0.00914986f, 0.01583835f, 0.04168797f, 0.01924876f, 
    0.02319686f, -0.00790429f, -0.01715500f, 0.04548332f, -0.02688342f, -0.01673270f, 0.03338088f, 0.01309466f, 
    0.02030856f, -0.00835483f, 0.04506937f, -0.05072160f, 0.01673566f, 0.01746205f, -0.00938936f, 0.04728768f, 
    -0.02288880f, 0.03604028f, 0.04266275f, -0.00720410f, 0.02422996f, -0.03528198f, -0.04309019f, 0.03669209f, 
    0.02780299f, 0.00078721f, -0.05032879f, 0.03028648f, -0.00114732f, -0.04888324f, -0.05334001f, -0.00654795f, 
    -0.02009630f, 0.01700105f, 0.04004536f, -0.00675510f, -0.03456163f, -0.05331908f, -0.02874997f, 0.01740770f, 
    0.00422267f, -0.03977751f, 0.02679709f, -0.01922189f, 0.00504769f, -0.03180062f, -0.04639470f, -0.00533496f, 
    0.03397979f, -0.04100332f, 0.00595440f, -0.05002306f, 0.01475576f, -0.04369733f, -0.02443216f, 0.03043354f, 
    -0.03682800f, -0.01661586f, 0.01778474f, -0.03465548f, -0.02457961f, -0.02781868f, -0.05440200f, 0.02332800f, 
    0.04896433f, 0.01021568f, 0.01946029f, -0.00002969f, 0.01062808f, 0.03681224f, 0.03532396f, 0.04673253f, 
    0.03048436f, 0.02952695f, 0.02664929f, 0.01743665f, 0.03099415f, -0.02137133f, -0.04722052f, -0.00193534f, 
    -0.03835061f, -0.05228899f, -0.04560955f, -0.03100267f, 0.04839507f, -0.00247294f, -0.02955906f, 0.04022153f, 
    0.00844457f, -0.02215681f, -0.02919004f, 0.03493107f, -0.03278844f, -0.02965744f, 0.03515777f, -0.04231777f, 
    -0.04383110f, -0.03562846f, 0.00080024f, -0.03177519f, -0.01030265f, -0.03555903f, 0.04517613f, -0.03547075f, 
    -0.03022172f, -0.03078690f, -0.03739214f, 0.01551776f, -0.05201212f, -0.01405957f, -0.03320769f, 0.01904467f, 
    -0.03238600f, 0.00889003f, 0.04354561f, -0.00911371f, -0.04340028f, -0.01678760f, -0.05339925f, -0.03106005f, 
    0.02008387f, -0.02621597f, 0.03941265f, -0.01784916f, 0.03556126f, -0.00599558f, 0.04931993f, -0.01551270f, 
    0.00178795f, -0.03963091f, -0.04107589f, -0.05213820f, -0.00110178f, 0.01848577f, -0.02753587f, 0.01359681f, 
    -0.03243321f, 0.03086169f, 0.01930507f, -0.00675675f, 0.03149744f, 0.00353974f, 0.02146068f, -0.02279299f, 
    -0.03547837f, 0.02157146f, -0.05140756f, -0.03588959f, 0.03408218f, -0.00184123f, -0.03195538f, -0.01965214f, 
    0.01005677f, -0.04109757f, 0.00210094f, -0.02898012f, -0.00779275f, 0.00775987f, -0.04856960f, -0.03768523f, 
    -0.00369620f, 0.03748428f, -0.05151058f, 0.01044654f, 0.03102579f, -0.04708793f, 0.04003312f, -0.02968476f, 
    0.04148126f, -0.04667996f, 0.03335349f, -0.03194661f, 0.03258555f, 0.04335352f, 0.02357461f, -0.02311590f, 
    0.00323580f, 0.02168257f, 0.03185481f, 0.02323832f, -0.02416597f, 0.04470896f, -0.00654472f, -0.00592898f, 
    -0.03806639f, -0.00500005f, -0.00001279f, -0.02396996f, -0.00121095f, 0.00401200f, -0.03793054f, 0.00521782f, 
    -0.05537391f, 0.00196017f, -0.00605097f, -0.00493143f, -0.00883380f, 0.02458457f, 0.01597772f, 0.04675163f, 
    -0.04772931f, 0.02648396f, -0.02309649f, 0.00948470f, 0.00496932f, 0.01707667f, -0.03725110f, -0.04869407f, 
    -0.02077728f, 0.02578439f, 0.04202313f, -0.02960506f, 0.03541784f, -0.02896371f, -0.00769913f, -0.03209811f, 
    -0.05456712f, 0.03069858f, -0.01998959f, 0.02529210f, -0.01801134f, 0.01425389f, -0.04398481f, -0.00595291f, 
    0.00362254f, -0.00195641f, -0.01786423f, 0.00892291f, 0.00767631f, 0.02686839f, -0.03236604f, -0.00127205f, 
    -0.00360779f, 0.02436694f, -0.02830941f, -0.04344723f, -0.00503506f, -0.05322447f, 0.03441733f, 0.04468122f, 
    -0.01766327f, 0.00343008f, -0.00416228f, -0.04018754f, 0.02897013f, 0.00678717f, -0.00269925f, 0.03333316f, 
    -0.04117365f, -0.01446513f, -0.04999712f, -0.04985281f, 0.03813529f, 0.03465762f, -0.02570869f, -0.02642030f, 
    0.01108588f, -0.02864702f, 0.02233476f, -0.01687271f, -0.03808682f, -0.02569780f, 0.03655392f, 0.00555569f, 
    -0.02129867f, 0.01430125f, -0.02547654f, -0.03196549f, -0.00488137f, -0.04968704f, 0.02914013f, -0.04900097f, 
    0.02983207f, 0.01305281f, 0.03836917f, -0.03862678f, -0.02314871f, -0.01211933f, 0.01804367f, -0.01757913f, 
    0.04153680f, 0.03663941f, -0.04868973f, 0.03995227f, -0.02521773f, 0.02355611f, -0.03839845f, 0.04276397f, 
    0.03782323f, -0.01403124f, 0.04537681f, -0.00195468f, -0.03128359f, -0.05826535f, -0.00048874f, 0.02624673f, 
    0.04141963f, 0.03471085f, -0.02658107f, -0.01073159f, 0.00561596f, 0.01441282f, -0.03324752f, -0.00036483f, 
    -0.03260365f, -0.01185863f, -0.01453360f, -0.03971980f, 0.03492841f, -0.01311069f, -0.05523535f, -0.05161211f, 
    -0.02561076f, 0.02269381f, -0.02793158f, -0.03261411f, 0.00457287f, 0.02734265f, -0.04806111f, 0.03391777f, 
    0.01032049f, -0.00502551f, -0.05628058f, -0.01076437f, -0.04891228f, 0.03478783f, 0.04236189f, -0.00763275f, 
    -0.00322142f, -0.02847153f, -0.00360684f, -0.03228250f, -0.00363508f, -0.04146583f, -0.03500970f, -0.01255223f, 
    0.02816596f, -0.05633055f, 0.01434888f, -0.04190112f, -0.03159342f, 0.04337508f, 0.04486820f, -0.02407126f, 
    0.02102743f, 0.04343540f, 0.02565479f, -0.02135924f, 0.03433812f, 0.01608672f, -0.04992384f, -0.02148135f, 
    -0.01067056f, 0.02279599f, -0.04407202f, -0.01293947f, 0.00228272f, 0.02444343f, -0.03054347f, -0.03415630f, 
    -0.03484774f, -0.02345785f, 0.03757456f, -0.03862152f, 0.01580337f, 0.01394924f, 0.00131606f, -0.04044652f, 
    -0.01805468f, 0.02240679f, -0.03670550f, -0.01226719f, -0.02699586f, -0.03904258f, -0.03882976f, 0.00707213f, 
    0.01197940f, -0.04935953f, 0.01970990f, -0.02245036f, 0.02060548f, 0.01959554f, -0.01835583f, 0.02526073f, 
    -0.00124704f, 0.01910804f, -0.03243915f, 0.02601626f, -0.04568440f, 0.03312788f, 0.03641915f, 0.02995464f, 
    -0.03857244f, 0.00489840f, -0.03441365f, -0.00165027f, -0.01289984f, -0.05508555f, 0.00469101f, -0.02930734f, 
    0.02427258f, -0.01823577f, -0.05328660f, -0.04185659f, -0.03432981f, -0.04264325f, -0.00660659f, 0.03683649f, 
    -0.01369383f, -0.04043851f, 0.04253737f, 0.03132757f, -0.04750530f, 0.03551031f, -0.04464617f, -0.04065217f, 
    -0.02392199f, -0.02365564f, -0.05019714f, 0.03470657f, -0.04467560f, -0.01046171f, -0.02953754f, 0.01622271f, 
    -0.05849144f, -0.04056203f, 0.03112932f, -0.04365866f, 0.03529132f, -0.04455850f, 0.00577705f, 0.04191072f, 
    -0.03083374f, -0.05275602f, -0.04485818f, 0.04450101f, -0.03621202f, 0.00224566f, -0.04068276f, 0.00663987f, 
    -0.05641972f, 0.00197584f, -0.05050733f, -0.00430830f, -0.05538100f, -0.00323341f, 0.00132251f, 0.01694347f, 
    -0.01149610f, 0.01405378f, -0.04016432f, 0.02068252f, -0.03842433f, 0.03113606f, -0.05170043f, -0.04724324f, 
    -0.01192022f, 0.03566414f, -0.05570978f, 0.03175527f, 0.00573886f, -0.02065811f, 0.00681905f, 0.00203819f, 
    -0.01521898f, 0.03548652f, -0.03273638f, 0.00531873f, 0.00599902f, 0.00128567f, -0.03064657f, -0.05386085f, 
    -0.04180996f, 0.03612932f, -0.04077949f, 0.02916656f, -0.00818596f, -0.03107751f, 0.02008525f, -0.00853131f, 
    -0.00666117f, -0.03408942f, -0.04320599f, -0.00610458f, -0.04307515f, 0.04119251f, -0.01702146f, -0.04858033f, 
    -0.00018871f, -0.01040892f, -0.04306934f, 0.00654846f, -0.04688211f, 0.02017520f, -0.04186954f, 0.02071079f, 
    -0.03439787f, -0.00229696f, 0.02060901f, -0.01795649f, 0.03179656f, 0.00615673f, -0.02517608f, -0.02951755f, 
    -0.04937767f, -0.04124590f, 0.00736795f, 0.02082894f, -0.01461241f, 0.01902825f, -0.04566725f, -0.03827793f, 
    0.00722428f, 0.02031340f, 0.01169714f, 0.03360249f, 0.00527585f, -0.01334952f, -0.05564469f, 0.02152019f, 
    0.04556067f, 0.00477618f, -0.02531155f, 0.03584106f, 0.05274257f, -0.02693020f, 0.01488497f, -0.02633605f, 
    -0.01588458f, -0.03162632f, -0.01691240f, -0.03307020f, 0.00011319f, 0.00232441f, -0.00955786f, -0.00771768f, 
    -0.00714783f, 0.03512489f, 0.03781375f, -0.05179990f, 0.01173752f, -0.01927395f, -0.03081386f, 0.02896490f, 
    0.00706227f, 0.01305215f, 0.00988018f, 0.02617368f, -0.02397845f, 0.02244878f, -0.00810343f, 0.04293956f, 
    -0.05523587f, -0.03910843f, 0.01793474f, -0.00359389f, -0.00952085f, -0.05587340f, 0.03179509f, 0.00365906f, 
    -0.02987336f, -0.03648528f, -0.02120801f, -0.03665493f, 0.04017193f, 0.03812253f, -0.05417883f, -0.01547152f, 
    0.00032136f, -0.04866506f, 0.01816198f, -0.00187408f, -0.02744045f, 0.01135642f, -0.03740673f, -0.04817933f, 
    0.05160557f, 0.03369582f, -0.03228387f, 0.04611200f, -0.02237592f, 0.00162568f, -0.02065140f, 0.02559089f, 
    0.03844309f, 0.04015889f, 0.01138401f, -0.02211338f, -0.00676248f, -0.04246709f, 0.01416007f, 0.01535384f, 
    -0.03997316f, 0.03381242f, -0.02621382f, 0.04275237f, -0.02477121f, 0.00593393f, -0.01843401f, -0.03486589f, 
    0.02035556f, -0.01159250f, 0.03988158f, -0.02031903f, 0.03527454f, 0.03560216f, 0.04622657f, 0.02829234f, 
    -0.04970898f, -0.04152831f, 0.03619830f, 0.02691389f, -0.01563131f, -0.03928375f, 0.02625891f, 0.03636215f, 
    0.03169650f, -0.01936274f, -0.02338458f, 0.03131258f, -0.05442668f, 0.01027382f, 0.00541893f, -0.02929798f, 
    -0.04032372f, -0.04512347f, 0.02548741f, 0.02641419f, 0.03652817f, -0.01367399f, 0.01905617f, -0.02833922f, 
    0.01377950f, 0.00748073f, -0.05079024f, -0.05718843f, -0.01840760f, 0.00862814f, -0.00636509f, -0.01584492f, 
    -0.02971515f, -0.02236283f, -0.02443847f, 0.00975146f, -0.05254706f, -0.02413579f, -0.01264858f, 0.01863973f, 
    -0.01494397f, 0.02916894f, 0.02578220f, -0.04714981f, -0.02149775f, -0.01458551f, 0.04183943f, -0.02860948f, 
    -0.03472118f, -0.03229484f, -0.04949010f, 0.00454114f, 0.01040290f, 0.01429814f, -0.01404889f, -0.03770854f, 
    -0.01907080f, 0.04312457f, -0.01050105f, -0.05527322f, -0.01299458f, 0.03096384f, 0.04221088f, 0.01711030f, 
    0.00695308f, 0.02200165f, -0.03596169f, -0.04832587f, 0.04080651f, -0.02984885f, -0.02805071f, 0.03913452f, 
    0.00741659f, -0.03637516f, -0.01791801f, 0.04139612f, -0.02218067f, -0.05295924f, 0.04223442f, -0.03593838f, 
    -0.02166827f, 0.03141110f, 0.02587068f, -0.00296371f, -0.03351321f, -0.02487083f, -0.03971070f, -0.04810748f, 
    -0.03875619f, 0.01934561f, -0.05174334f, -0.00446563f, -0.02361968f, 0.01477314f, -0.04433455f, 0.00732594f, 
    -0.04360999f, -0.00558148f, 0.02321238f, -0.04446425f, 0.00657877f, -0.04710090f, -0.01018891f, -0.04585987f, 
    0.03407422f, -0.01459896f, 0.01542195f, 0.02349470f, 0.03601632f, 0.03293970f, -0.04746592f, 0.00456887f, 
    -0.05833885f, 0.04138167f, -0.01327371f, -0.03569576f, -0.03905141f, 0.00069667f, 0.01359123f, -0.01106326f, 
    -0.05077283f, -0.04564100f, 0.01604201f, -0.05432228f, -0.03217316f, 0.02896023f, -0.05751154f, 0.00932196f, 
    -0.01718242f, 0.00454334f, 0.03607472f, 0.01844669f, 0.02145612f, 0.02830749f, -0.02273217f, 0.03847893f, 
    0.02092195f, 0.01940745f, -0.00873522f, 0.02525344f, -0.03561429f, -0.05851653f, 0.00553867f, 0.01366990f, 
    0.00950164f, -0.05529287f, -0.00626499f, 0.01465999f, -0.01362115f, -0.02558393f, 0.04141490f, 0.00027411f, 
    0.01798177f, -0.05636880f, -0.03732183f, 0.01212807f, -0.00635024f, -0.02802688f, -0.04981846f, 0.02662955f, 
    -0.05190869f, -0.02434907f, 0.02546119f, 0.03713258f, 0.01207707f, -0.05526193f, -0.00752153f, 0.02907431f, 
    0.00708035f, -0.03335901f, -0.04763568f, 0.03402384f, 0.03203669f, -0.00004646f, 0.03168834f, 0.02646959f, 
    -0.03366136f, -0.01273565f, 0.03902583f, 0.02492274f, -0.02849751f, 0.02865956f, 0.01712900f, -0.02443296f, 
    0.03873987f, -0.00947824f, -0.00331690f, -0.05756998f, -0.03746738f, 0.00429518f, -0.04011892f, 0.01636899f, 
    -0.03649567f, 0.02438203f, 0.02597840f, -0.03701800f, 0.00167884f, -0.01289937f, -0.02267018f, -0.05270043f, 
    -0.00907970f, -0.05578134f, -0.03836323f, 0.03705350f, 0.00992566f, 0.02093017f, 0.02262883f, -0.02295683f, 
    -0.03435731f, -0.03901492f, 0.02030102f, 0.01393291f, 0.01367695f, -0.02055571f, -0.05374757f, -0.00104469f, 
    -0.03095737f, -0.01406776f, -0.03999018f, -0.03280132f, 0.01770495f, -0.04484776f, -0.05404439f, 0.00507535f, 
    -0.02757274f, -0.05264944f, 0.02886265f, -0.03201339f, -0.02469436f, -0.03382159f, -0.01617701f, 0.02533404f, 
    -0.02119716f, 0.03063933f, -0.02095680f, -0.04675664f, -0.02991906f, -0.01805390f, 0.03569211f, 0.03698510f, 
    -0.03866858f, -0.04593994f, 0.00694169f, -0.02463219f, -0.00280559f, 0.00203537f, -0.01201018f, -0.05387365f, 
    -0.05550329f, 0.02488741f, 0.02363392f, -0.01637432f, -0.04020710f, 0.02902810f, -0.04558616f, 0.01042281f, 
    0.03089414f, -0.05769286f, -0.03038022f, -0.02015871f, 0.00594485f, -0.05457477f, 0.03094787f, 0.03191370f, 
    -0.00291034f, -0.03952366f, -0.02324993f, -0.01271386f, 0.04116170f, 0.01631154f, -0.03399324f, -0.00716506f, 
    -0.00707506f, -0.02260524f, -0.00277032f, -0.01356147f, 0.00614111f, -0.00270653f, -0.00405788f, 0.01414482f, 
    -0.01221402f, -0.03937016f, -0.04529327f, -0.04163931f, 0.01460754f, -0.00308734f, 0.01900521f, -0.05785845f, 
    -0.01643794f, -0.01851467f, -0.04776328f, -0.00890338f, 0.02363520f, -0.02796289f, -0.02684974f, 0.00630972f, 
    0.00405240f, 0.01207871f, 0.00153368f, -0.03939642f, 0.02335890f, 0.03750107f, -0.04774706f, -0.00687843f, 
    -0.02719169f, 0.04148666f, -0.04315789f, 0.04206359f, -0.01156555f, 0.02052850f, -0.02701593f, 0.00812853f, 
    -0.04779030f, -0.02129740f, 0.00347294f, -0.00671158f, 0.01011572f, 0.01128391f, -0.02781047f, -0.04916058f, 
    0.01363447f, -0.03987158f, -0.02759113f, 0.01448476f, -0.02490170f, 0.00191201f, 0.02307261f, 0.00020387f, 
    0.00264036f, -0.04890011f, -0.00548143f, 0.00904849f, 0.02780206f, -0.01648352f, 0.01919568f, -0.03596357f, 
    0.03035491f, -0.00657194f, 0.00299215f, -0.00624260f, 0.00076614f, -0.02851217f, -0.05580150f, 0.02621758f, 
    -0.02888691f, -0.05341261f, -0.04618751f, -0.01613288f, 0.01299759f, -0.01274577f, -0.04226946f, -0.02199707f, 
    0.01827815f, -0.03359310f, -0.02506312f, -0.05644118f, 0.02110825f, 0.03842324f, -0.01460617f, 0.01291328f, 
    0.00241569f, 0.01194492f, 0.01072333f, 0.02401639f, -0.00177022f, -0.01985809f, 0.00095327f, -0.05266982f, 
    -0.02439524f, 0.00386570f, -0.02224364f, 0.00506699f, 0.00664085f, 0.03166354f, -0.03852834f, 0.01429847f, 
    -0.00970661f, -0.04868816f, 0.03110976f, -0.02878487f, -0.03210831f, 0.02117018f, -0.00845121f, 0.00663834f, 
    -0.00977679f, 0.03350022f, 0.04020261f, 0.04611812f, 0.03684704f, 0.01125851f, 0.02755582f, 0.01080422f, 
    -0.04106356f, -0.01404450f, -0.03808188f, 0.02627519f, -0.04153925f, -0.03584094f, -0.05260224f, 0.00417465f, 
    0.00424825f, -0.04969126f, -0.05144286f, -0.03763549f, -0.00723399f, 0.00218779f, -0.05782264f, -0.00225221f, 
    -0.14057244f, 0.09347924f, 0.04178186f, 0.03491755f, -0.12497528f, 0.02696860f, 0.01519169f, 0.06652820f, 
    0.05303835f, 0.01768214f, -0.02409452f, 0.03710973f, -0.07598830f, 0.00990382f, 0.01833745f, -0.05226249f, 
    0.03477740f, 0.06546181f, -0.03709300f, 0.07789143f, -0.06054153f, 0.03347530f, 0.13872559f, -0.00843252f, 
    -0.02027223f, 0.02388969f, -0.07211822f, -0.07191718f, -0.10952100f, -0.10385753f, 0.07310964f, 0.04800023f, 
    0.06077514f, 0.07056239f, 0.08851744f, 0.10355861f, 0.27810538f, -0.17594986f, 0.19004472f, 0.06700866f, 
    -0.07955007f, 0.11887515f, 0.00525298f, -0.06947432f, 0.14469627f, -0.05790857f, 0.01579446f, 0.00356723f, 
    -0.27797836f, 0.01981762f, 0.01332254f, 0.22846787f, 0.07524212f, -0.04557342f, 0.01228174f, -0.04714480f, 
    0.02225673f, 0.07133701f, -0.05224931f, -0.05124997f, 0.10840228f, 0.08042540f, 0.14504552f, 0.20741120f, 
    0.01332611f, -0.07731038f, 0.03165420f, 0.09466038f, 0.01205631f, -0.03541429f, 0.05428550f, 0.01811607f, 
    -0.13537197f, 0.12081209f, 0.20668709f, 0.09393308f, -0.00115835f, 0.08359097f, -0.01442368f, 0.00854754f, 
    -0.12265322f, 0.15505762f, -0.02737541f, -0.09185772f, -0.06796594f, -0.02992910f, -0.15895143f, -0.23239365f, 
    -0.02979908f, 0.08268481f, -0.05433075f, -0.10510767f, 0.02385632f, 0.02679804f, 0.02075509f, 0.05190644f, 
    0.12401580f, -0.02378382f, 0.02339257f, -0.11159579f, -0.16705818f, -0.06950384f, -0.04281811f, 0.09023327f, 
    0.04265004f, -0.11034013f, -0.01035703f, -0.02127543f, 0.02059494f, 0.22764283f, 0.09924804f, -0.06020713f, 
    -0.17379779f, -0.02173796f, 0.05302393f, 0.13421620f, 0.15512426f, 0.05456098f, 0.02045215f, -0.00873439f, 
    0.01869659f, -0.02137961f, -0.07646491f, -0.10901668f, 0.05734247f, -0.10417455f, 0.04184036f, -0.12310001f, 
    0.05245489f, -0.12427653f, 0.03510158f, 0.08027779f, -0.22463647f, 0.04829717f, 0.14593385f, -0.16083734f, 
    -0.04338252f, 0.02282296f, 0.08559538f, 0.01251617f, 0.01677698f, -0.08148421f, 0.01605776f, -0.06378595f, 
    0.06597225f, -0.03625926f, 0.04469823f, 0.01199097f, -0.16446479f, -0.04433336f, 0.08302828f, 0.08355575f, 
    0.08031623f, 0.08831912f, 0.07917890f, -0.00323191f, 0.20442991f, 0.00005643f, -0.23048906f, 0.22871137f, 
    -0.04663935f, 0.13607444f, 0.13965543f, 0.04820850f, 0.10582147f, 0.10989498f, -0.02609382f, 0.05904645f, 
    0.03612265f, 0.21414217f, 0.23678264f, 0.02615158f, 0.02452794f, 0.01227216f, 0.07463447f, 0.07764661f, 
    -0.02412628f, -0.00928900f, 0.16319877f, 0.09834759f, 0.14674406f, 0.18134460f, 0.21371897f, 0.25130528f, 
    -0.06601129f, -0.01498326f, -0.10447138f, 0.09863432f, 0.00376491f, -0.05576162f, -0.06580507f, 0.04588154f, 
    -0.12515132f, -0.04380862f, -0.04103075f, -0.03698530f, -0.01418381f, -0.01354584f, 0.08809835f, 0.04123438f, 
    0.11003698f, -0.00245952f, 0.00225751f, 0.03482732f, -0.11259444f, -0.06006445f, -0.11220321f, -0.25500894f, 
    0.09838568f, 0.07814846f, 0.10066810f, 0.03020608f, -0.07402417f, 0.03661884f, 0.12878065f, 0.00052870f, 
    -0.04145685f, 0.05522723f, 0.08714019f, 0.03342569f, 0.04822062f, -0.07757441f, -0.00404088f, -0.02423122f, 
    0.09659304f, -0.00107714f, 0.00998453f, 0.17245680f, 0.04429177f, 0.03028150f, -0.10012862f, -0.10133333f, 
    0.01453431f, 0.04452101f, -0.00926194f, 0.00869246f, -0.13997921f, -0.02982667f, 0.13900748f, 0.11816464f, 
    0.01466149f, 0.08479516f, 0.12743919f, -0.04082019f, 0.03027213f, 0.07676597f, 0.01329599f, -0.09208585f, 
    -0.06401564f, -0.02266873f, -0.00253237f, -0.08160307f, -0.30856887f, -0.09937102f, -0.11757287f, -0.01927781f, 
    -0.01612137f, -0.00737859f, -0.08393176f, 0.11050837f, 0.03271701f, -0.02977028f, 0.08215188f, 0.09995143f, 
    -0.32887900f, -0.11913554f, 0.08111139f, 0.05319122f, 0.10007719f, 0.04833343f, 0.20417294f, -0.02451093f, 
    0.01583350f, -0.00285236f, -0.09833643f, -0.03113466f, 0.12448080f, -0.03126948f, -0.36970800f, -0.18266125f, 
    -0.02637882f, 0.03087257f, 0.12699561f, 0.04807973f, 0.02401179f, 0.08297195f, -0.02849105f, 0.01145296f, 
    -0.29216838f, 0.08689224f, -0.06252553f, 0.11277268f, -0.05360371f, 0.08794051f, -0.05115773f, -0.00897064f, 
    0.16325372f, 0.01628212f, 0.12656665f, 0.02765701f, -0.12357318f, -0.12668195f, 0.00238821f, -0.02371506f, 
    -0.04606403f, -0.00596083f, 0.03045466f, 0.12877606f, 0.00720591f, -0.04396613f, -0.06606582f, -0.07055060f, 
    -0.47712916f, 0.07875682f, 0.12882859f, 0.21951573f, -0.03712486f, -0.19814049f, 0.06378123f, -0.02457501f, 
    0.04486021f, -0.02943181f, -0.07596802f, -0.04055635f, -0.06210122f, 0.02535657f, -0.19704676f, -0.06298681f, 
    -0.08268081f, 0.15776023f, 0.00459130f, -0.01210858f, 0.00844075f, 0.04180603f, 0.07299578f, 0.01297364f, 
    0.50948435f, 0.01667966f, -0.03453733f, 0.21946259f, -0.17656551f, -0.01494412f, 0.03913313f, -0.02151443f, 
    -0.10565428f, 0.07689485f, -0.00063073f, -0.02683880f, 0.07024661f, 0.01624971f, 0.22014929f, 0.22421509f, 
    0.01058844f, -0.00359208f, -0.03803186f, 0.05855116f, 0.03101865f, -0.02277377f, 0.00462095f, 0.06770095f, 
    -0.00619766f, 0.07890611f, 0.14820708f, -0.12469149f, -0.06654409f, -0.05949655f, 0.00876727f, 0.04450212f, 
    0.03935532f, 0.03921595f, 0.11177851f, -0.01753666f, -0.17058012f, 0.17775069f, -0.03303428f, -0.05567550f, 
    0.09873234f, -0.08827522f, 0.05906171f, 0.00703210f, -0.02033097f, 0.08659453f, 0.02261659f, -0.04878443f, 
    -0.03458107f, -0.02896451f, 0.02411258f, 0.03111751f, -0.05091348f, -0.02235008f, -0.02996435f, -0.02560155f, 
    -0.01932882f, -0.02428945f, 0.01108465f, -0.00454942f, 0.00275145f, -0.04681687f, -0.00986016f, 0.02133578f, 
    0.04083865f, 0.00197922f, -0.04597897f, -0.02666890f, 0.03135310f, 0.01709188f, 0.03725766f, -0.04194981f, 
    0.01973246f, 0.00910922f, -0.03632034f, -0.01314921f, -0.04626460f, 0.02928054f, -0.04443842f, -0.01172907f, 
    0.01265214f, -0.00452064f, -0.04354278f, -0.01712629f, -0.02131430f, -0.04806148f, 0.02686849f, -0.03700714f, 
    0.01259018f, -0.04727944f, -0.05141942f, -0.05647483f, -0.03243082f, -0.05477449f, -0.00678795f, 0.04156055f, 
    -0.02737421f, -0.01749694f, -0.03058089f, -0.05449101f, 0.03778691f, 0.01585505f, 0.03348408f, -0.04416489f, 
    0.03690501f, -0.05217582f, -0.00692365f, 0.03606036f, 0.02136555f, 0.02871943f, -0.05595485f, 0.03731360f, 
    -0.02463978f, -0.02128369f, -0.04801073f, -0.00453601f, 0.03853075f, 0.00348307f, 0.02583856f, 0.02827071f, 
    0.00733385f, -0.05357374f, -0.00021212f, -0.03664592f, -0.02774287f, -0.04938889f, -0.05108367f, 0.02134304f, 
    0.04243343f, -0.03036385f, 0.03010358f, -0.03016225f, -0.02880794f, 0.02174133f, -0.02287763f, -0.02288298f, 
    0.03947016f, 0.02782721f, 0.00033763f, -0.00517401f, 0.02840236f, -0.03475690f, -0.03184592f, 0.02472661f, 
    -0.05579234f, -0.05792448f, -0.01612452f, -0.01126776f, 0.03706184f, -0.03996450f, -0.00843410f, 0.01596877f, 
    -0.00281158f, 0.04188959f, -0.02435503f, -0.00720749f, 0.02690975f, -0.04626629f, -0.05074091f, -0.00902199f, 
    -0.02560927f, -0.05064800f, 0.01321942f, 0.01817184f, 0.03338919f, -0.04739426f, -0.01829820f, -0.03944755f, 
    0.04279528f, -0.03858374f, 0.00309411f, -0.04502126f, 0.00975179f, 0.02998090f, -0.04164242f, -0.02093485f, 
    0.02001384f, 0.03577778f, -0.03321297f, -0.00306115f, 0.01269928f, -0.02435676f, 0.04900947f, 0.04273343f, 
    -0.05261810f, 0.00576327f, 0.00900069f, -0.01757504f, -0.05321705f, -0.04783198f, 0.01077712f, -0.03914142f, 
    -0.00436345f, 0.02951670f, -0.00202693f, -0.04133712f, 0.01835867f, 0.00357348f, 0.00632347f, -0.02077853f, 
    0.03452746f, -0.02714349f, -0.05715631f, -0.03617258f, -0.05040081f, -0.03116758f, 0.01737549f, -0.04471778f, 
    0.00756238f, -0.04685487f, -0.04318636f, -0.01987491f, -0.02742132f, 0.01881170f, -0.04981718f, -0.01896416f, 
    -0.04526747f, -0.04905295f, -0.00116587f, -0.00910370f, -0.00656646f, 0.03453811f, 0.01430818f, -0.03786190f, 
    -0.04008138f, -0.01234949f, 0.01707705f, -0.04851223f, -0.02245863f, -0.00519619f, -0.03717582f, -0.01958798f, 
    0.01646040f, -0.01327789f, -0.02618407f, 0.00974813f, 0.02491375f, -0.04672721f, 0.03881357f, 0.01466760f, 
    -0.02720984f, -0.04043367f, -0.02382845f, 0.01982008f, 0.02166487f, -0.02383898f, 0.02751511f, -0.04145931f, 
    0.02321914f, -0.02316554f, 0.01929569f, -0.03183271f, -0.01909687f, -0.00722157f, 0.01894426f, -0.02862013f, 
    -0.03304756f, -0.02577225f, -0.05041040f, 0.02755596f, 0.01955053f, -0.05238378f, -0.01859083f, -0.01594754f, 
    0.02040525f, 0.04232730f, -0.05876976f, -0.02169709f, 0.03782178f, 0.00913401f, -0.03958778f, -0.03101313f, 
    -0.04230618f, -0.03388739f, 0.02636377f, -0.03806675f, -0.02767807f, 0.01875841f, -0.05510560f, -0.05663180f, 
    -0.01256473f, -0.02027828f, -0.03366500f, -0.03857144f, 0.01461894f, -0.05720028f, 0.01661078f, -0.01166300f, 
    0.00677484f, -0.00264109f, -0.01759698f, -0.03864166f, 0.03876519f, 0.01208851f, -0.03233332f, 0.03186468f, 
    -0.01399561f, -0.01385715f, -0.03035446f, -0.02100487f, -0.00372941f, -0.03833508f, -0.02253143f, -0.01749019f, 
    0.00694602f, 0.00294897f, -0.01599829f, -0.01926934f, -0.03039723f, -0.00517603f, 0.02765036f, 0.02529486f, 
    0.02618724f, 0.01072739f, 0.01315626f, -0.02634239f, -0.03733065f, -0.00042115f, -0.03672015f, -0.04640809f, 
    0.00246935f, -0.03199662f, -0.01602335f, -0.04879503f, -0.01401117f, 0.02332065f, -0.05272718f, 0.02385836f, 
    -0.00228210f, -0.02970888f, -0.04818057f, 0.01167920f, 0.01968382f, -0.03929352f, 0.03859373f, -0.04808977f, 
    0.00569678f, 0.03267534f, -0.04859544f, -0.05525072f, -0.03038216f, -0.03268246f, 0.03683180f, -0.03646553f, 
    -0.00919369f, 0.02983231f, 0.02245166f, 0.03311279f, 0.01185373f, -0.01177610f, -0.01070332f, 0.00833801f, 
    0.03919767f, -0.04193828f, -0.03165156f, -0.00838443f, -0.00683527f, 0.03506775f, -0.00971472f, 0.01890262f, 
    0.03860741f, -0.05381406f, 0.01202838f, -0.01954670f, -0.02442928f, -0.01567867f, -0.04005180f, 0.00553652f, 
    -0.04783382f, -0.00513176f, -0.04474820f, 0.03660721f, 0.02805033f, -0.00225989f, -0.04713149f, 0.00526474f, 
    0.04016882f, -0.05256795f, -0.02388932f, -0.00920983f, -0.02522965f, 0.00895817f, -0.01034367f, 0.02861791f, 
    -0.01211179f, 0.02949746f, -0.00951822f, 0.01901178f, -0.00208124f, 0.00279323f, 0.01137026f, -0.01589836f, 
    -0.05167783f, -0.05056715f, -0.03172803f, -0.03637950f, 0.01691344f, -0.03185060f, -0.04989728f, 0.01872944f, 
    -0.03463386f, -0.01625300f, -0.01570323f, -0.02823282f, -0.02374602f, -0.03660240f, 0.01636874f, -0.04662002f, 
    -0.00410485f, 0.03883022f, 0.02415364f, 0.00916540f, -0.04341668f, 0.03463959f, -0.00730645f, -0.02614360f, 
    0.02967621f, 0.02978326f, -0.05667244f, 0.02160449f, -0.05029499f, 0.01204455f, 0.03168918f, -0.04810363f, 
    -0.05477458f, 0.03539516f, 0.03368367f, 0.02435654f, -0.01335985f, -0.00475449f, -0.04297623f, 0.01226822f, 
    0.24373491f, 0.22632596f, 0.13065596f, -0.05405463f, 0.01766217f, -0.02993239f, 0.05606287f, -0.01531607f, 
    0.04981966f, 0.06419231f, -0.03981245f, -0.14700216f, 0.38943076f, 0.00310723f, 0.05217758f, 0.04533375f, 
    -0.04822547f, 0.04017132f, -0.03573988f, -0.08135018f, 0.03894376f, 0.01937421f, -0.08808845f, -0.09494089f, 
    0.19473054f, 0.03277334f, 0.17284000f, 0.10777446f, -0.03016345f, 0.01057406f, -0.04811016f, 0.06593900f, 
    0.03195693f, -0.07007224f, 0.01768374f, 0.05305781f, -0.33071470f, 0.13382021f, -0.13416845f, 0.06197546f, 
    0.07212502f, -0.01177369f, -0.09834834f, 0.09705178f, -0.08547945f, 0.02916286f, -0.16546035f, -0.08555401f, 
    0.17385377f, 0.05979947f, 0.01908717f, -0.04972100f, -0.02129245f, 0.11466731f, -0.00624504f, 0.01613808f, 
    -0.05818257f, -0.05314719f, 0.05139725f, 0.03316025f, -0.07199145f, -0.09569090f, 0.12078175f, -0.17804211f, 
    -0.00895097f, 0.14125066f, -0.06422361f, -0.07944370f, -0.06128062f, -0.07057970f, -0.01828039f, -0.04040262f, 
    0.33783489f, -0.08957788f, -0.11763761f, -0.15604582f, -0.13782495f, -0.05578160f, -0.04491024f, 0.01141292f, 
    0.04907819f, 0.01691077f, 0.12675856f, 0.18514907f, 0.16353129f, 0.04368189f, -0.02429657f, 0.18646137f, 
    0.01921863f, -0.04813479f, 0.06554547f, 0.08592495f, 0.04534267f, 0.05165205f, -0.03790786f, -0.04575685f, 
    -0.12440930f, 0.27251461f, 0.08581217f, -0.18390521f, 0.05851746f, 0.08484451f, -0.00624186f, 0.01483079f, 
    0.01578660f, 0.06476276f, -0.03695576f, -0.01914685f, -0.15304777f, 0.12198456f, 0.06761483f, -0.04049270f, 
    0.13676171f, -0.05318859f, 0.02708519f, -0.00909236f, -0.09506679f, -0.05207171f, -0.02771166f, 0.13364908f, 
    -0.16698726f, -0.04888486f, -0.02577914f, -0.07266758f, -0.00132436f, 0.12325305f, 0.00092146f, 0.09700681f, 
    -0.04735498f, -0.03832881f, -0.05889682f, -0.02209648f, 0.37642598f, -0.06233456f, 0.03478546f, 0.09562063f, 
    0.06922521f, 0.07374249f, -0.04917486f, -0.02939640f, 0.00168444f, 0.06058760f, 0.11770084f, 0.05305291f, 
    -0.02142740f, 0.14441791f, -0.00063395f, 0.07181526f, 0.12471505f, -0.05304428f, 0.01160070f, -0.00389150f, 
    -0.10576751f, 0.04890889f, 0.06898589f, 0.04369750f, -0.21237792f, 0.01836712f, 0.07019729f, -0.12149382f, 
    -0.09350001f, -0.13708803f, -0.10881219f, -0.04052810f, -0.04608758f, -0.00802918f, 0.06622501f, -0.01327140f, 
    0.02407716f, -0.02349482f, -0.17825903f, 0.06961688f, 0.10174552f, -0.02449675f, -0.06082089f, 0.04157758f, 
    0.06150431f, 0.09059403f, -0.13455576f, -0.00333901f, -0.35152414f, -0.22241759f, -0.25972319f, -0.42623511f, 
    0.09656933f, 0.01152541f, 0.12711665f, -0.09746097f, -0.09375599f, 0.01423585f, 0.02194513f, -0.01748861f, 
    0.50006837f, -0.10128380f, 0.04982241f, 0.21435769f, -0.01345034f, 0.02731097f, -0.01629120f, -0.10353363f, 
    -0.00377628f, 0.01065868f, 0.12731755f, 0.06382221f, 0.36376727f, -0.04953688f, 0.11224450f, 0.17390931f, 
    -0.03678667f, -0.06315354f, -0.05026316f, 0.01496271f, 0.08871031f, 0.04932665f, -0.01150975f, 0.04069008f, 
    0.13926552f, 0.08584538f, 0.07524654f, 0.03479364f, -0.06191968f, 0.01994500f, 0.01644144f, -0.03705936f, 
    0.10468945f, 0.06333076f, -0.11612647f, -0.06035850f, 0.10377610f, -0.05896594f, 0.04666543f, -0.10152763f, 
    0.01560420f, -0.01222227f, -0.05898783f, 0.05832384f, 0.13561955f, -0.03213315f, 0.01985074f, 0.00871179f, 
    -0.15940121f, -0.01596903f, -0.18747346f, -0.16740051f, -0.07756758f, 0.04175643f, -0.06086444f, -0.03763006f, 
    0.03191443f, 0.06722333f, 0.03509396f, 0.08091490f, 0.04443856f, 0.31465033f, 0.24497806f, 0.19437917f, 
    -0.02823655f, 0.08084735f, -0.00633309f, -0.04402348f, -0.05465449f, 0.02049569f, 0.02045123f, -0.07930601f, 
    0.13535939f, 0.15232730f, -0.14902058f, 0.03980520f, -0.06194125f, 0.04420271f, -0.06998189f, 0.07685624f, 
    -0.00009326f, -0.12314184f, -0.01873365f, -0.01889377f, -0.01710936f, 0.17139307f, 0.22794095f, 0.01345616f, 
    -0.14909010f, -0.15658602f, 0.01943791f, -0.00565893f, 0.01923325f, 0.00835403f, 0.00263410f, 0.04901307f, 
    -0.04144673f, 0.08642332f, 0.13557540f, 0.13325574f, -0.01853785f, 0.00244748f, 0.01348816f, 0.00272996f, 
    -0.13837415f, -0.08778830f, -0.00723439f, 0.03132008f, 0.41142747f, -0.00426647f, 0.00855912f, 0.11564737f, 
    -0.05475420f, 0.00498627f, 0.05721221f, -0.16185755f, -0.02462911f, 0.06206789f, 0.07350065f, 0.03746503f, 
    0.27294144f, -0.12337318f, -0.00228309f, -0.13229258f, 0.10366263f, 0.06990858f, -0.00834981f, -0.02262587f, 
    -0.05121232f, -0.07692282f, 0.05578438f, 0.14570647f, 0.11147472f, -0.06055132f, 0.14273687f, -0.12896077f, 
    -0.03881719f, -0.04629117f, 0.08033665f, -0.00295179f, 0.02770111f, 0.05775331f, -0.06056777f, -0.01840019f, 
    -0.17061409f, 0.03670199f, 0.06757164f, 0.12130038f, 0.05146856f, 0.09940847f, 0.06095545f, 0.01084482f, 
    -0.00322988f, 0.04369091f, 0.01951631f, -0.01258278f, -0.18174341f, -0.10580554f, -0.08245154f, -0.27940333f, 
    -0.04258972f, -0.02300148f, 0.04748960f, -0.03499033f, -0.04803767f, 0.08361436f, -0.06498527f, -0.07613043f, 
    -0.09116379f, 0.19483984f, 0.06338727f, 0.09412221f, 0.01207645f, 0.03204738f, 0.01259108f, 0.01531327f, 
    0.03895983f, 0.05541224f, -0.03118746f, -0.06159183f, 0.50659436f, -0.20429377f, 0.12474453f, -0.05543462f, 
    -0.05638330f, 0.03669263f, -0.07943463f, 0.02711352f, 0.01764410f, -0.07288443f, 0.00619707f, 0.07424725f, 
    0.02451472f, 0.03536752f, 0.03849171f, -0.02109922f, -0.03453606f, -0.01749634f, 0.01993366f, -0.02989846f, 
    -0.01544090f, -0.02273588f, 0.04097353f, 0.00871810f, 0.03584469f, -0.01719534f, -0.01028045f, 0.03583683f, 
    -0.02505287f, 0.01243388f, 0.00609695f, 0.01169770f, -0.03821382f, -0.05530389f, 0.00964412f, 0.02807103f, 
    -0.04990291f, 0.02693181f, -0.03658144f, 0.01279628f, 0.01416332f, 0.03722204f, 0.04176535f, -0.03011122f, 
    -0.04594950f, -0.01494590f, -0.00314586f, -0.05298207f, 0.00464184f, -0.01908645f, 0.03607697f, -0.05116667f, 
    -0.04664328f, 0.00625611f, -0.05556967f, -0.05040140f, -0.01075357f, -0.03982632f, -0.02015410f, -0.04358524f, 
    0.00492751f, 0.03881471f, -0.01208727f, 0.01533573f, 0.01478457f, -0.02019774f, 0.02306576f, 0.01325725f, 
    0.04255144f, 0.00244106f, -0.05524737f, -0.00553272f, -0.03065154f, -0.01633628f, -0.04427314f, 0.00301076f, 
    0.00648443f, -0.05633242f, -0.04226286f, 0.00482834f, -0.05182211f, -0.02564638f, 0.01759635f, 0.03330192f, 
    -0.00774054f, 0.01999975f, 0.01555661f, -0.05027779f, -0.02672508f, -0.02854797f, 0.03315987f, 0.03459335f, 
    -0.03699048f, -0.02432309f, -0.01166445f, -0.03885433f, 0.00175689f, -0.05762219f, -0.02141166f, -0.02756704f, 
    -0.05712448f, 0.04273319f, -0.03579377f, 0.02116189f, -0.02019253f, 0.00284718f, -0.03714921f, -0.01865536f, 
    -0.00479199f, 0.00797264f, 0.01442218f, 0.00365914f, -0.00871980f, 0.02696399f, 0.01685545f, 0.00103758f, 
    -0.00224756f, 0.00947323f, 0.03947800f, 0.00419437f, -0.04505070f, 0.02517118f, -0.04756061f, -0.03844893f, 
    -0.01805527f, 0.03582153f, -0.05582489f, -0.01814114f, 0.00595701f, 0.01463614f, -0.00795997f, -0.02632877f, 
    -0.04580941f, -0.01394464f, 0.00764459f, 0.03678826f, 0.00020424f, 0.03278179f, -0.02135851f, -0.01709505f, 
    0.01569348f, 0.02686907f, -0.01161316f, 0.02589015f, -0.02403182f, 0.00398696f, -0.00162949f, -0.00627632f, 
    0.01777612f, -0.02822164f, -0.02731661f, -0.05794711f, -0.02398899f, -0.04277787f, -0.02195297f, -0.03920682f, 
    -0.03387893f, -0.00280315f, -0.03759171f, 0.00867252f, 0.01614222f, -0.03365264f, 0.01670340f, 0.03998389f, 
    -0.01580353f, -0.04023931f, -0.04345127f, -0.01473231f, 0.04256121f, -0.04023121f, -0.05193089f, 0.04148801f, 
    -0.03419064f, 0.03406361f, -0.00643045f, -0.00564480f, -0.04039720f, 0.02870479f, -0.04096970f, -0.02649210f, 
    0.04380804f, 0.03173521f, -0.00441658f, -0.04826759f, -0.02968699f, -0.04446356f, 0.03229753f, 0.02865482f, 
    0.01415581f, 0.01915769f, -0.02590141f, -0.04805243f, -0.01563308f, 0.02038274f, -0.02764909f, -0.04504734f, 
    0.03742428f, -0.02281638f, -0.03060649f, -0.03390192f, -0.01864727f, -0.00713056f, -0.04433765f, -0.04794430f, 
    -0.01741417f, -0.02643255f, -0.02903624f, -0.01809282f, -0.02084714f, -0.00679108f, 0.04394507f, 0.01806577f, 
    0.00911979f, -0.01387518f, 0.00359138f, -0.02461020f, -0.02473724f, 0.02886669f, 0.02827342f, -0.05664740f, 
    -0.05375168f, 0.01339841f, 0.03495964f, 0.03274516f, 0.01275731f, -0.05214448f, 0.01241823f, -0.00658426f, 
    0.03503451f, -0.03107464f, 0.01869318f, -0.04933412f, -0.00302695f, 0.01690106f, 0.01114393f, 0.02159132f, 
    0.03541671f, 0.04113286f, -0.02612392f, 0.00821650f, -0.01927634f, 0.00495823f, -0.02478371f, -0.05252879f, 
    0.00942885f, 0.03365476f, 0.02724248f, -0.03524264f, -0.02967115f, -0.03011757f, 0.01882809f, 0.00473923f, 
    -0.05428696f, -0.00470592f, 0.03712357f, -0.01009799f, -0.05344980f, 0.03643287f, -0.03631799f, -0.03105512f, 
    -0.05403109f, 0.00035539f, -0.00426875f, -0.00635571f, -0.01375326f, -0.05607031f, -0.02673561f, -0.00027326f, 
    -0.02014270f, -0.04554056f, -0.00497979f, 0.01743820f, 0.03418312f, 0.03020374f, -0.03800769f, -0.02248309f, 
    -0.00361429f, -0.05592295f, 0.03997578f, 0.03666663f, -0.05654146f, -0.00406412f, -0.02047285f, 0.04222390f, 
    -0.05283608f, -0.01612508f, -0.03298238f, 0.01347815f, 0.04282077f, -0.05027907f, 0.03680057f, -0.02750696f, 
    0.00831771f, -0.04836096f, 0.00793759f, 0.01869157f, 0.03436632f, 0.00125675f, -0.03900072f, -0.02062875f, 
    0.02978644f, 0.00384212f, -0.04733625f, -0.03996988f, -0.05553047f, -0.00281945f, 0.01091382f, -0.02418664f, 
    -0.00778727f, 0.02847481f, 0.01400126f, -0.02028765f, 0.02051462f, -0.00613268f, -0.01252130f, 0.04322258f, 
    -0.01057062f, 0.00429863f, 0.01089345f, 0.00986642f, -0.04321802f, -0.00241527f, 0.00708157f, 0.01688438f, 
    -0.02290393f, -0.01514086f, -0.00652615f, -0.00038891f, 0.00364440f, -0.05312388f, 0.03601366f, -0.04573348f, 
    0.01442022f, -0.03015441f, -0.02696591f, -0.02519200f, -0.00289053f, 0.03824671f, 0.03507419f, -0.01588607f, 
    0.03186749f, 0.03489514f, 0.03542062f, -0.00934308f, -0.00894605f, 0.04117617f, -0.03023989f, 0.00583965f, 
    0.02770418f, -0.05382928f, -0.04354489f, -0.00063461f, 0.01627742f, 0.01811044f, 0.02122821f, 0.00276429f, 
    0.03818459f, -0.03353892f, 0.00878677f, 0.00527124f, 0.01258489f, -0.04535401f, 0.03221817f, -0.05577529f, 
    0.02165630f, 0.04288270f, -0.03140162f, -0.03058787f, 0.00438195f, -0.05243249f, -0.04163947f, -0.04889798f, 
    -0.04322091f, -0.03645806f, -0.02061098f, -0.01250693f, 0.03944339f, -0.02199952f, -0.01821664f, 0.01433109f, 
    0.03106612f, -0.03103496f, 0.00735976f, 0.00855246f, -0.05109056f, -0.01401070f, -0.05551084f, -0.01078476f, 
    0.03205363f, -0.00469651f, 0.00782439f, -0.03109452f, 0.02112309f, -0.05219000f, -0.01784503f, 0.00749911f, 
    0.03957596f, 0.02926334f, -0.04299932f, 0.00926099f, 0.01436480f, -0.05480419f, 0.04180420f, 0.01965520f, 
    -0.01827537f, -0.04676637f, 0.01106286f, -0.00340421f, 0.01595146f, -0.04493199f, 0.04397616f, -0.03050186f, 
    -0.03548278f, -0.02218203f, 0.02446140f, -0.01486653f, 0.02703756f, -0.05579790f, -0.00195768f, 0.02629358f, 
    0.00944677f, 0.00955610f, -0.02053983f, -0.04021446f, -0.05530117f, -0.05585038f, -0.01683024f, -0.03386097f, 
    -0.00899080f, 0.03337988f, -0.03199879f, 0.03870372f, -0.04920558f, 0.01955623f, -0.02172685f, -0.00632166f, 
    -0.05200165f, -0.04527530f, -0.04267648f, 0.03623157f, -0.04209980f, -0.03564397f, 0.03506949f, 0.03856152f, 
    -0.02499907f, 0.03557536f, 0.04069994f, -0.01027454f, -0.02703405f, 0.04040556f, -0.05072138f, -0.02406091f, 
    -0.01635390f, 0.03503168f, -0.00204939f, -0.04946399f, -0.03600298f, 0.00553428f, -0.04093921f, -0.00169506f, 
    0.01778897f, -0.03170251f, 0.00395018f, 0.03235224f, -0.00704218f, -0.01035663f, 0.01466057f, -0.02122210f, 
    0.02318894f, 0.03895853f, -0.04029344f, 0.00115207f, 0.00596559f, -0.03458831f, 0.00846884f, 0.02369262f, 
    0.03667708f, -0.05262725f, -0.01318520f, -0.05031243f, 0.01695574f, -0.00616818f, 0.00274697f, -0.04538378f, 
    -0.01490359f, 0.01964803f, 0.00661436f, 0.03668811f, -0.02033157f, 0.00608054f, -0.04633767f, 0.03694122f, 
    -0.03868149f, 0.03654171f, -0.02252112f, -0.04926790f, -0.05566942f, -0.02159346f, -0.05407846f, 0.02789781f, 
    -0.05511939f, -0.00481608f, 0.00964481f, -0.02592629f, -0.04679873f, 0.03687812f, -0.03642154f, -0.03702171f, 
    0.02111135f, 0.01167782f, -0.02375465f, -0.00141011f, -0.02895468f, -0.05648835f, -0.01029188f, -0.04727320f, 
    -0.01197994f, -0.01079270f, 0.02020907f, 0.03519360f, -0.03617390f, -0.00253786f, -0.00182414f, 0.00852119f, 
    -0.03553101f, -0.00144909f, 0.04361700f, -0.05211341f, -0.05241600f, 0.02592984f, 0.02012154f, 0.04216747f, 
    0.01566143f, -0.04346576f, -0.00927785f, 0.02625680f, 0.00652636f, -0.02295468f, 0.00856398f, -0.00094579f, 
    -0.05246835f, -0.00405553f, 0.02048936f, 0.00879306f, -0.00693058f, -0.03549922f, -0.02208358f, -0.03897849f, 
    -0.00968168f, -0.05679481f, -0.02896501f, -0.03987810f, 0.02178181f, 0.03535819f, -0.00210764f, 0.03660697f, 
    0.00596539f, 0.00570633f, 0.03480378f, 0.01847760f, 0.02270606f, -0.01795714f, -0.03768038f, -0.01009170f, 
    -0.03581848f, -0.05661847f, 0.02900684f, 0.01853478f, -0.02977461f, -0.02861306f, 0.00216761f, -0.01124061f, 
    0.03825231f, 0.00458780f, -0.05492704f, 0.00698486f, -0.04006429f, -0.05573088f, -0.01561368f, -0.00940017f, 
    -0.04639381f, -0.01452784f, 0.03769394f, -0.00004443f, -0.02210331f, 0.01427099f, -0.01423723f, 0.03822866f, 
    -0.03891260f, -0.05492532f, -0.02017811f, -0.02423904f, 0.01613385f, -0.00058673f, -0.05318630f, 0.02487708f, 
    0.01542443f, 0.03651686f, 0.00108553f, 0.03997271f, -0.05126191f, 0.00910528f, -0.04820444f, 0.03347454f, 
    0.02551663f, -0.03601977f, 0.00447719f, 0.00303399f, -0.00138581f, 0.01217159f, 0.02350524f, 0.01536410f, 
    -0.00687861f, 0.04146925f, -0.00712174f, 0.02153940f, 0.00212304f, 0.03140520f, -0.01861158f, 0.03619717f, 
    0.04389639f, 0.00579891f, 0.02938896f, -0.02588740f, 0.01362097f, -0.03319703f, -0.02821588f, 0.01681392f, 
    0.00544635f, -0.04630522f, -0.00770671f, 0.01704805f, 0.02531477f, 0.01150633f, -0.02709643f, -0.01688819f, 
    0.01354774f, -0.02243431f, 0.03316860f, -0.05108514f, -0.02702771f, 0.03209250f, 0.00353040f, -0.01903936f, 
    -0.03436175f, 0.01316112f, 0.00569845f, -0.01591960f, -0.05510027f, -0.02947750f, -0.02784890f, 0.00220263f, 
    -0.03749407f, -0.03750541f, -0.01688385f, -0.00001261f, -0.02971207f, 0.02204925f, -0.04399356f, -0.05371907f, 
    -0.01046113f, 0.00602378f, -0.01847910f, -0.01195539f, 0.03528403f, 0.04286758f, 0.02230898f, 0.02577824f, 
    -0.03737128f, 0.00397247f, -0.03475537f, -0.04139784f, -0.04890720f, -0.00410947f, 0.02607489f, -0.01406733f, 
    0.00170338f, 0.00131614f, -0.03483693f, 0.00611513f, -0.01812078f, 0.02390795f, -0.01246757f, -0.01861820f, 
    0.03160850f, -0.05132274f, 0.03660378f, 0.00841871f, 0.00648714f, 0.03867432f, -0.05364402f, 0.01062273f, 
    -0.03241976f, 0.03379002f, 0.01918381f, 0.03607566f, 0.01544575f, -0.03823465f, -0.04318878f, -0.05102096f, 
    0.01472001f, -0.02416741f, 0.00225534f, -0.04109811f, -0.02906776f, -0.03849246f, -0.03324616f, -0.03598269f, 
    0.02878387f, -0.02699695f, -0.01864962f, 0.03943076f, -0.02178827f, 0.00431896f, -0.05670643f, 0.03800491f, 
    -0.05154308f, -0.05146810f, -0.03065490f, -0.00058348f, 0.01921968f, -0.05055607f, -0.04377921f, 0.02090105f, 
    0.00185505f, -0.04213471f, -0.04496491f, 0.04096937f, -0.05155691f, -0.01193855f, -0.00885674f, -0.01388558f, 
    -0.05157777f, 0.02537300f, 0.02944329f, 0.01247932f, -0.05098391f, -0.02600877f, 0.01232166f, 0.02751481f, 
    0.00663818f, -0.02661984f, 0.02339525f, -0.04427758f, 0.00686246f, -0.03229042f, 0.00404808f, -0.00726576f, 
    -0.01726590f, -0.04443789f, 0.01739948f, 0.03116345f, 0.01253493f, 0.01794584f, -0.02169231f, -0.04924102f, 
    -0.05698732f, -0.03318664f, -0.02694730f, 0.02859433f, -0.03992686f, -0.04159320f, 0.01541485f, 0.02867225f, 
    -0.05215925f, -0.01225831f, -0.03829419f, -0.00816284f, -0.02235886f, 0.01352084f, -0.04695472f, 0.00252904f, 
    -0.00974822f, -0.04987209f, 0.04421420f, -0.00661967f, -0.00833486f, 0.01491069f, -0.05645390f, 0.01172561f, 
    0.03514285f, 0.02763607f, 0.00246722f, 0.00698778f, 0.04374913f, 0.02502128f, 0.01449827f, 0.04314588f, 
    -0.04372877f, -0.03222378f, -0.01387360f, 0.00658552f, -0.03693499f, 0.02005296f, -0.00929773f, -0.04403890f, 
    -0.04469045f, -0.03636503f, 0.03592186f, 0.04180833f, 0.03097398f, 0.00183419f, -0.02490081f, 0.04169101f, 
    0.02407932f, -0.02345639f, 0.00006183f, 0.00384722f, -0.02204496f, 0.00126937f, -0.00575988f, -0.03669067f, 
    -0.00755814f, -0.04482313f, -0.00093309f, -0.04922523f, -0.02057911f, -0.01493187f, 0.01504612f, -0.02967712f, 
    -0.03469985f, -0.01942144f, -0.03777219f, -0.02731544f, -0.04812452f, 0.04021823f, -0.04643447f, -0.04753916f, 
    -0.02204237f, 0.03373950f, -0.05464149f, -0.04699151f, 0.00695820f, -0.04645370f, 0.03833188f, -0.00480696f, 
    0.00366149f, 0.00519456f, -0.00804428f, -0.01262957f, 0.04101637f, 0.01398921f, -0.02939928f, -0.02862342f, 
    0.03903614f, -0.02692699f, -0.00401410f, -0.02159107f, 0.00467420f, -0.01988210f, -0.05282176f, 0.01333266f, 
    -0.04424659f, -0.00874896f, -0.02118509f, 0.03262158f, -0.04003030f, -0.00517056f, 0.03784223f, -0.05200987f, 
    0.01568982f, -0.03189700f, -0.02809379f, 0.00439229f, 0.01827548f, -0.05505292f, -0.04173683f, 0.03449563f, 
    -0.01217183f, 0.00020383f, -0.04933143f, 0.01526788f, 0.03364810f, 0.00140449f, -0.03911959f, -0.01081069f, 
    -0.04805163f, -0.04741439f, 0.03386246f, -0.04089021f, -0.00458617f, -0.03000632f, 0.04209174f, -0.02555029f, 
    0.02513613f, 0.03106497f, -0.03690140f, 0.04210860f, 0.00994459f, 0.02190238f, 0.03891053f, -0.01258045f, 
    -0.02071653f, -0.04077727f, 0.03638870f, -0.05184488f, -0.01546079f, 0.01224502f, -0.04863130f, -0.03860809f, 
    -0.01056494f, 0.03936525f, -0.05460632f, 0.01702508f, 0.02354220f, 0.03202475f, -0.04289101f, -0.04589257f, 
    -0.01401448f, -0.02700984f, 0.02915103f, -0.02099690f, -0.03706528f, 0.03027493f, 0.02037352f, 0.01587984f, 
    0.03218400f, 0.00185774f, -0.04518420f, 0.02333669f, 0.00424285f, 0.03835377f, -0.00744501f, -0.00585708f, 
    0.01905085f, -0.04581501f, -0.05364968f, -0.05275162f, 0.00528808f, 0.02668136f, -0.02527039f, -0.04037033f, 
    -0.02116160f, -0.02467244f, 0.01620072f, -0.03982983f, 0.00727267f, -0.00831832f, -0.05675691f, 0.00834801f, 
    -0.03438831f, 0.01892383f, -0.04477443f, 0.02298827f, 0.01589958f, 0.03258631f, -0.02255551f, -0.02485261f, 
    -0.01192495f, -0.00522590f, -0.00190532f, -0.03328079f, -0.00143096f, 0.01604942f, -0.05160251f, 0.00925623f, 
    -0.04711059f, 0.04051078f, 0.02049736f, 0.02227922f, -0.00064361f, -0.02016070f, -0.03584968f, 0.00968274f, 
    -0.04505573f, -0.02064725f, -0.01174382f, -0.04696528f, 0.03484670f, 0.01559772f, 0.03783802f, 0.03463150f, 
    -0.01696696f, 0.00925202f, -0.00672428f, 0.00781534f, -0.04635624f, 0.01068757f, 0.04500467f, 0.03081914f, 
    -0.04568076f, 0.02664545f, 0.00107568f, -0.02038248f, 0.02956912f, -0.05281024f, -0.02350929f, -0.03705730f, 
    -0.01433161f, 0.02212383f, -0.01128190f, 0.03867910f, -0.03198898f, 0.03922675f, -0.03546192f, 0.01455157f, 
    0.04202585f, -0.05576328f, 0.02503137f, 0.00362082f, -0.03574535f, 0.01839452f, -0.02887528f, -0.01468974f, 
    0.02454203f, -0.00670746f, -0.05052567f, -0.04745864f, 0.01632866f, -0.02154123f, -0.05531757f, -0.04077418f, 
    -0.02850632f, 0.00429345f, -0.01552571f, -0.05567624f, 0.02309506f, -0.00984039f, -0.03596571f, -0.04475144f, 
    -0.05172688f, -0.02057498f, -0.01726275f, 0.01425476f, -0.04341020f, -0.01444253f, -0.01854477f, 0.00256249f, 
    0.00057106f, 0.01432040f, -0.05501045f, -0.04259964f, 0.00548190f, -0.01648289f, -0.04979736f, -0.04895308f, 
    -0.04670474f, -0.02686600f, 0.00058375f, 0.04312686f, -0.01674427f, -0.04129640f, -0.01464722f, 0.00565756f, 
    -0.03140056f, -0.00008434f, 0.02887992f, -0.04225693f, -0.01337886f, -0.02246845f, 0.01414573f, -0.04437349f, 
    0.01890184f, -0.02986350f, 0.00342512f, -0.01857083f, 0.02609785f, -0.04185587f, -0.04231071f, -0.05240621f, 
    -0.02099458f, -0.02071571f, 0.00319669f, -0.02984567f, -0.03756920f, -0.04521941f, 0.04175696f, 0.02028952f, 
    -0.03417088f, -0.01612059f, -0.00443273f, -0.01238174f, -0.04149579f, -0.02823504f, 0.01842167f, -0.01898678f, 
    -0.04825494f, 0.00396372f, -0.04552636f, 0.01178948f, 0.01242208f, -0.01972807f, 0.01491122f, -0.02595025f, 
    -0.04917390f, 0.01559763f, 0.03095268f, 0.01506428f, -0.04000934f, 0.01815816f, -0.00135708f, 0.02089986f, 
    0.00918332f, 0.00168495f, -0.00981261f, 0.01253590f, -0.03107203f, -0.05109784f, 0.04121348f, -0.02722277f, 
    0.00085152f, 0.03546607f, 0.00084357f, 0.03232058f, -0.03357382f, -0.01380223f, -0.00148042f, 0.03705795f, 
    -0.03281181f, 0.04319051f, -0.03352340f, -0.00255053f, -0.00538168f, -0.02850732f, -0.03124789f, -0.02524787f, 
    0.02854929f, -0.01508917f, -0.00036318f, -0.02653484f, -0.02701186f, -0.02701630f, -0.01956434f, -0.01674767f, 
    0.03632505f, -0.00171928f, -0.02524679f, 0.03677060f, -0.02135495f, -0.02468609f, 0.00185221f, 0.02718321f, 
    0.02115373f, -0.05077900f, -0.02954394f, -0.05620314f, -0.00521947f, -0.05411764f, -0.01515724f, -0.01755640f, 
    0.03941988f, -0.00779816f, 0.01274086f, -0.01314343f, -0.04189504f, -0.01349334f, -0.01614204f, 0.02014194f, 
    -0.05326287f, 0.04172973f, 0.01769618f, -0.03947832f, 0.00933235f, -0.03986573f, -0.04871698f, -0.03837789f, 
    -0.03573203f, 0.00415760f, 0.00805750f, -0.01584517f, -0.05609898f, -0.03736528f, 0.00674240f, -0.01066736f, 
    -0.08747089f, -0.08502658f, 0.13246731f, -0.06462150f, -0.02693519f, 0.07584839f, 0.01750671f, 0.00843066f, 
    -0.00991231f, -0.02410219f, -0.09148640f, 0.03709498f, 0.23052172f, 0.17873220f, 0.05538612f, 0.01962784f, 
    -0.02849010f, -0.08805108f, 0.03727118f, 0.03771655f, 0.04585259f, -0.09916096f, -0.03504678f, -0.03421042f, 
    -0.18653530f, 0.25241360f, 0.03695813f, -0.04344844f, -0.04924007f, -0.08521221f, -0.13216017f, -0.00681696f, 
    -0.06958368f, 0.05937708f, -0.09259813f, -0.04679606f, 0.07426899f, 0.10092290f, -0.17427537f, 0.07557004f, 
    0.12880312f, 0.06111689f, -0.02133874f, 0.14594103f, -0.06232248f, -0.02481447f, -0.09672137f, -0.04921853f, 
    -0.22833391f, -0.18596543f, 0.09589141f, -0.07447138f, -0.09794813f, 0.02508436f, 0.02216703f, -0.01098524f, 
    -0.00403126f, 0.01531597f, 0.03372364f, 0.07958597f, 0.02379934f, -0.12858269f, 0.05868746f, 0.06626075f, 
    0.01481718f, 0.15233172f, 0.01907228f, 0.00768298f, 0.04436674f, 0.01109720f, -0.04330103f, 0.00755283f, 
    0.17778009f, 0.00542627f, 0.06807037f, -0.06309900f, -0.10408990f, 0.02312933f, -0.04422323f, 0.06400213f, 
    0.12392188f, 0.09934025f, 0.05574753f, 0.11575510f, 0.16561522f, 0.18415964f, 0.08868597f, 0.05540266f, 
    0.05590098f, -0.02500232f, 0.00847800f, 0.18423894f, -0.05771141f, 0.15981255f, 0.03762326f, -0.05253842f, 
    -0.33771139f, 0.04930745f, -0.00205767f, -0.09239659f, -0.03285498f, -0.00431359f, 0.01517414f, 0.03248980f, 
    0.01064388f, -0.00042194f, 0.03930780f, -0.06888131f, -0.02182231f, -0.09701756f, 0.03704234f, 0.07931087f, 
    -0.10175550f, -0.11423766f, 0.06465159f, -0.02283124f, -0.00048675f, 0.04234733f, 0.02810036f, -0.08474908f, 
    0.18249881f, 0.01905387f, 0.07397977f, 0.19768278f, -0.03902417f, 0.04874868f, 0.07358249f, 0.16233630f, 
    0.06833407f, 0.03311932f, -0.06141640f, -0.21996133f, -0.06171774f, 0.00377071f, -0.18759945f, 0.16622956f, 
    -0.00595242f, 0.10957483f, 0.03396406f, 0.05586980f, 0.01961661f, 0.03274247f, 0.08399361f, 0.11616554f, 
    0.09549510f, -0.00349086f, -0.06563771f, -0.08355086f, -0.00718241f, 0.03795157f, -0.01421278f, -0.08401310f, 
    -0.07971876f, 0.05208750f, 0.05593883f, 0.02272216f, 0.04764417f, 0.07814743f, 0.18888028f, -0.10634978f, 
    -0.01955481f, 0.11972333f, 0.03818256f, -0.01667708f, 0.06402908f, 0.04585491f, 0.07572111f, -0.17026119f, 
    -0.07905446f, -0.01293205f, -0.09579411f, -0.08377724f, 0.08536346f, -0.08378472f, 0.04244547f, -0.04553267f, 
    -0.00732406f, -0.01848456f, -0.10312972f, 0.07458464f, -0.15322097f, 0.08838096f, 0.03057711f, -0.09297018f, 
    0.09340015f, 0.04304104f, -0.03162883f, 0.04166102f, -0.19442461f, 0.00322995f, 0.00793021f, -0.07005730f, 
    0.03112234f, 0.16660531f, 0.06867848f, -0.03968221f, -0.01178355f, 0.01799088f, 0.06375668f, 0.01165075f, 
    0.01926537f, 0.03595816f, 0.00740134f, -0.04477297f, 0.15477303f, 0.13800339f, -0.01103543f, 0.04117652f, 
    -0.04488824f, 0.04372863f, 0.02057385f, 0.00745713f, -0.01122402f, 0.10657892f, -0.10486936f, 0.04876410f, 
    -0.25611585f, 0.00447064f, 0.03473425f, 0.01404195f, -0.12665926f, 0.13894686f, 0.05023671f, 0.00484254f, 
    0.07003177f, 0.07290555f, -0.06830513f, 0.01575627f, 0.02023222f, 0.04231928f, 0.20991734f, 0.25521404f, 
    0.00422568f, -0.06670664f, 0.05510263f, 0.10896270f, 0.09065892f, 0.01684269f, 0.16810249f, -0.03714024f, 
    0.13145989f, -0.00535317f, -0.08527736f, 0.08578350f, 0.03292410f, -0.03836953f, -0.00758631f, 0.04899058f, 
    0.03176861f, -0.07998691f, 0.13193278f, 0.00659966f, -0.17656791f, -0.03007274f, 0.00978615f, -0.02352359f, 
    -0.10836547f, 0.06783877f, 0.11298234f, -0.04913934f, 0.06728240f, -0.00177167f, 0.01980409f, -0.01740284f, 
    0.15817681f, -0.04218757f, 0.12895446f, 0.03306869f, -0.01366576f, -0.05787899f, -0.06000116f, 0.00592547f, 
    -0.00721064f, -0.00041793f, 0.07357118f, 0.00103953f, 0.08374713f, 0.13510267f, 0.14496015f, 0.24277350f, 
    0.12539317f, -0.17741291f, -0.12242098f, 0.05908244f, -0.16494727f, 0.13704915f, 0.02874352f, -0.00134811f, 
    -0.25116372f, -0.18336160f, 0.09934065f, -0.14463453f, -0.06294341f, -0.06587168f, 0.09413265f, -0.01303615f, 
    0.05308373f, -0.02402377f, -0.03741097f, 0.01474517f, 0.15391456f, 0.20098646f, -0.25183856f, -0.04044027f, 
    -0.01010874f, 0.02348627f, 0.13093053f, -0.02436619f, -0.02015197f, 0.08673419f, 0.05508149f, -0.03847428f, 
    0.07242173f, -0.08208574f, 0.09223475f, -0.05040876f, 0.04234959f, -0.05748561f, -0.02574587f, -0.02086849f, 
    -0.08420749f, -0.01557476f, 0.05635722f, -0.02368663f, 0.27155563f, 0.13915960f, 0.04914839f, -0.01866885f, 
    -0.00828041f, -0.11869056f, 0.03692099f, 0.03195791f, -0.04588702f, -0.00283926f, -0.03976367f, 0.05842245f, 
    -0.03797938f, 0.08424640f, 0.03379956f, -0.04647116f, 0.12732102f, 0.01799398f, 0.09742120f, 0.06641280f, 
    -0.01399298f, 0.08100399f, -0.00837423f, -0.00367330f, 0.31690609f, 0.37200797f, -0.28569844f, -0.23431247f, 
    0.04457793f, 0.00008470f, 0.13899547f, -0.02965108f, -0.01159717f, 0.02093793f, -0.13043842f, 0.02323262f, 
    -0.06560981f, -0.09395038f, -0.11760096f, 0.06934053f, -0.03177290f, 0.06852514f, 0.07442036f, 0.01886829f, 
    -0.00244707f, -0.05015035f, -0.10988571f, -0.03985339f, 0.20394184f, -0.24227327f, 0.06001736f, 0.09939948f, 
    -0.06532774f, 0.06216149f, 0.01480112f, 0.05709971f, -0.10251232f, -0.04626004f, 0.01605443f, 0.03528423f, 
    -0.04428243f, -0.02555319f, -0.02340681f, -0.05655287f, -0.04257794f, -0.02240971f, 0.03104650f, 0.00650037f, 
    0.04412757f, 0.00148619f, -0.02808079f, -0.02078380f, 0.03221851f, -0.03417304f, -0.04747723f, 0.03369939f, 
    0.01674791f, -0.01878507f, -0.04915405f, -0.02472615f, -0.00866676f, -0.03457237f, 0.01384096f, 0.02858782f, 
    -0.04893780f, 0.01929310f, -0.05792758f, 0.02316969f, -0.00063839f, -0.01617662f, -0.02463688f, -0.00967821f, 
    -0.04726309f, -0.01385496f, 0.02654302f, -0.04576051f, -0.05100279f, 0.04153653f, -0.03933549f, -0.01012085f, 
    0.03926701f, 0.00711578f, 0.03960413f, -0.01192094f, 0.03345608f, -0.05230058f, -0.01068073f, 0.01598256f, 
    0.03195844f, -0.00324383f, 0.00699886f, -0.04521400f, -0.02659135f, 0.00728139f, 0.01375232f, -0.03811314f, 
    0.02280444f, 0.02413741f, 0.00420134f, -0.04462891f, 0.00952345f, -0.02039342f, -0.04218020f, 0.01385304f, 
    -0.03992203f, -0.05211945f, 0.02586051f, -0.05017588f, -0.02031294f, -0.01693076f, 0.01363128f, 0.03328310f, 
    -0.05097732f, -0.04671184f, -0.04491803f, 0.03048445f, 0.03080229f, -0.03456834f, 0.04085632f, 0.03692178f, 
    0.02586379f, -0.04073998f, -0.02807919f, -0.01297611f, -0.02751194f, -0.02238348f, -0.01028549f, 0.01212826f, 
    -0.02695812f, -0.02328927f, 0.02529658f, 0.04324222f, -0.04968807f, -0.03156093f, -0.04422662f, -0.03158953f, 
    0.04167848f, -0.04690183f, -0.05061093f, 0.00427502f, -0.00718267f, -0.01347425f, -0.01327724f, -0.04379652f, 
    0.03665022f, 0.02863867f, -0.04999673f, 0.03799185f, -0.04838237f, 0.01655274f, 0.01672331f, -0.03850768f, 
    -0.03734701f, 0.00126569f, -0.03878335f, -0.01263379f, 0.02241292f, -0.05365025f, 0.04279881f, 0.02546483f, 
    0.04414373f, -0.01136895f, 0.02511959f, 0.02115583f, 0.04369327f, 0.01175834f, -0.01148031f, 0.01986842f, 
    0.00869524f, -0.02900665f, 0.02083340f, 0.02410020f, -0.01950296f, 0.03887058f, 0.02460841f, 0.01598776f, 
    -0.05262382f, 0.00187188f, 0.00930332f, -0.01884134f, -0.05524763f, 0.01443345f, 0.02901292f, -0.03439291f, 
    -0.04969081f, -0.04259041f, -0.04856574f, -0.03431998f, 0.02817659f, 0.04087551f, -0.00690755f, -0.02386685f, 
    -0.05454631f, 0.03535352f, 0.02870800f, 0.03292586f, -0.05941528f, -0.04728776f, 0.03445727f, -0.04731739f, 
    0.03217173f, -0.04690433f, -0.00716292f, 0.00531424f, -0.04343511f, -0.02566561f, -0.01365546f, -0.02016817f, 
    -0.00904842f, -0.02372574f, 0.02467173f, 0.01804990f, -0.04694207f, -0.04738333f, 0.02322029f, -0.04559531f, 
    -0.03263088f, -0.04153823f, -0.05539564f, 0.00431977f, 0.04196778f, 0.02859696f, -0.01032116f, -0.03176025f, 
    -0.03045242f, 0.04209568f, 0.02375458f, 0.01896605f, -0.02980732f, 0.01491105f, -0.03015987f, 0.02501590f, 
    0.03770334f, -0.04276422f, 0.02031988f, 0.02752767f, -0.01206202f, -0.02577118f, -0.04139886f, -0.04327490f, 
    0.03495459f, -0.05024925f, -0.02655304f, 0.02687527f, -0.02247042f, 0.03100221f, -0.00779486f, 0.03702244f, 
    -0.02637305f, 0.04003835f, -0.02172766f, -0.05813600f, 0.01827555f, 0.02425281f, 0.01782641f, 0.02851688f, 
    -0.02762822f, -0.01472310f, -0.00377134f, -0.03222826f, -0.00159574f, 0.00973104f, 0.03628312f, -0.03047366f, 
    0.04570539f, 0.02793600f, 0.02780333f, -0.02523206f, -0.01546855f, -0.03828944f, -0.02977338f, -0.05477771f, 
    -0.03818453f, -0.02335520f, 0.03608947f, -0.04822459f, -0.03582726f, -0.03072457f, 0.02640595f, -0.01201815f, 
    0.02833365f, 0.02467422f, -0.04896152f, -0.03246348f, -0.03679353f, -0.00107889f, -0.03112486f, -0.04353861f, 
    -0.02591290f, -0.03808653f, 0.01527258f, -0.01748299f, -0.02922225f, -0.00807742f, 0.03555690f, -0.03406359f, 
    0.02194044f, -0.02516735f, -0.04109272f, -0.03277367f, -0.01280220f, 0.02060503f, -0.02116410f, -0.00773729f, 
    -0.02157997f, 0.04172559f, -0.04999764f, -0.00204194f, -0.03824814f, 0.02545639f, -0.02351981f, 0.02835921f, 
    0.02900024f, -0.00065232f, 0.03273116f, -0.01373938f, 0.02459665f, -0.00167566f, 0.02571315f, 0.00500503f, 
    -0.05265832f, -0.02267506f, -0.01665614f, 0.03173217f, 0.04034501f, -0.03259543f, -0.01297163f, 0.00555650f, 
    0.00279818f, -0.04105609f, 0.01786015f, -0.01611478f, 0.02857518f, -0.03279067f, 0.01334419f, -0.05255871f, 
    0.00890631f, 0.00968665f, -0.02228785f, -0.02220240f, 0.02050592f, -0.05967402f, -0.03976352f, 0.02357799f, 
    0.02907547f, -0.02816673f, -0.00072995f, 0.02340406f, -0.00555197f, -0.00785267f, 0.00298284f, -0.04248808f, 
    0.00406126f, 0.01081884f, -0.00552698f, -0.04381898f, -0.05300533f, 0.03026709f, 0.03502801f, -0.03467319f, 
    -0.03246705f, -0.03254283f, -0.04244683f, -0.01400073f, -0.03841580f, -0.03265829f, -0.02345762f, 0.04339803f, 
    0.00702623f, -0.00394824f, -0.03293578f, -0.01229214f, 0.00679801f, -0.03315132f, 0.03511810f, -0.04622262f, 
    0.00602649f, 0.01586966f, 0.03588225f, -0.01150317f, -0.05575753f, 0.01776752f, -0.04823200f, 0.02746616f, 
    -0.00319170f, -0.04342280f, -0.00246751f, -0.02829972f, -0.03365994f, -0.00491167f, -0.00391958f, -0.02923906f, 
    0.03022483f, -0.02758830f, 0.00034191f, -0.02403159f, 0.03644675f, -0.04022448f, -0.02968587f, 0.01256705f, 
    -0.03507159f, -0.01751609f, -0.02550320f, -0.01672295f, 0.04491656f, -0.02381196f, -0.03862518f, 0.03516179f, 
    -0.01582855f, -0.00602941f, -0.04137649f, 0.01672776f, -0.01698925f, -0.01650140f, -0.03475590f, -0.01005012f, 
    -0.04127980f, 0.01694232f, 0.02129866f, 0.03293781f, 0.03883526f, -0.03231708f, -0.04238643f, -0.02686097f, 
    -0.03012377f, 0.03148662f, 0.02931110f, 0.00389855f, -0.04016186f, -0.00437787f, -0.02350181f, 0.02111189f, 
    -0.03345820f, 0.04083040f, -0.05633064f, -0.05065530f, 0.00571539f, 0.01019021f, -0.00030621f, 0.01083701f, 
    0.00723801f, 0.04469598f, -0.04754090f, 0.03121462f, -0.04121844f, -0.03593338f, 0.02480157f, 0.03316700f, 
    0.00191320f, 0.00157334f, 0.03605632f, 0.04374873f, -0.01448326f, 0.00238768f, -0.02317304f, 0.01367976f, 
    -0.02641305f, -0.00158870f, -0.05407120f, 0.01859855f, 0.03601677f, -0.03798407f, 0.00041162f, -0.02349530f, 
    0.01724570f, -0.02506528f, 0.04056890f, 0.02607540f, -0.03944774f, -0.03627170f, -0.05278751f, -0.04814769f, 
    -0.01351316f, 0.01379157f, -0.01893531f, -0.00669435f, -0.01431247f, -0.02608538f, 0.02785638f, 0.00915495f, 
    -0.05431582f, -0.00388207f, -0.00684637f, 0.04293882f, 0.02896475f, -0.02212026f, 0.00474911f, 0.03744132f, 
    -0.04233767f, -0.00586218f, -0.01839678f, -0.04938487f, -0.05293447f, -0.03413154f, 0.00799443f, -0.02921319f, 
    0.00494257f, -0.01101123f, -0.02419655f, 0.04392102f, 0.00019365f, 0.02276422f, 0.04549331f, 0.04611990f, 
    0.02219188f, -0.02918413f, -0.04840099f, -0.05538964f, 0.01263701f, -0.04123820f, -0.04448712f, 0.04643775f, 
    -0.00139291f, -0.03189387f, -0.01362785f, -0.03690123f, -0.02501653f, -0.01913620f, 0.00645510f, 0.00727992f, 
    0.04365260f, -0.03496837f, -0.00586185f, -0.01981405f, -0.03463455f, 0.01672464f, -0.01708868f, 0.04397163f, 
    0.01067368f, -0.05503883f, -0.05340764f, -0.03037298f, 0.01907627f, -0.03391188f, -0.03461307f, -0.05318288f, 
    -0.00182922f, -0.05009276f, -0.02637298f, 0.00822850f, 0.01538885f, 0.03396282f, -0.04358066f, -0.05410328f, 
    0.04120872f, -0.03709922f, -0.02506669f, -0.03570199f, -0.04997309f, -0.04932808f, 0.03612497f, -0.02193064f, 
    -0.00890249f, 0.01966387f, 0.04061519f, 0.02859208f, 0.01300288f, 0.02815041f, 0.03016646f, 0.01225090f, 
    -0.00340057f, -0.02907168f, 0.02358028f, 0.04176246f, 0.04087045f, 0.01081466f, 0.04416139f, -0.03259306f, 
    0.01437297f, 0.03472253f, -0.02853135f, -0.01784242f, -0.01640556f, 0.03426481f, 0.00712964f, 0.04288372f, 
    -0.03340760f, 0.03777680f, -0.05498757f, 0.02478736f, 0.02417718f, -0.05114369f, 0.03137409f, -0.00745441f, 
    -0.05060950f, 0.00313067f, 0.02833707f, 0.02595495f, -0.00739644f, 0.02446688f, -0.05451412f, 0.03980844f, 
    -0.04104685f, -0.01032856f, -0.01152601f, -0.00219400f, 0.03956441f, 0.01490169f, -0.03928119f, -0.04083401f, 
    0.01105016f, -0.03371880f, 0.02722603f, 0.00530608f, 0.03804731f, 0.03416419f, -0.05496365f, -0.02703279f, 
    0.03799481f, -0.01236817f, -0.02876036f, 0.01089057f, -0.04103390f, 0.03819950f, -0.01805487f, -0.02632072f, 
    -0.01601935f, -0.03135788f, 0.00137871f, -0.04347670f, -0.00010308f, -0.02844067f, 0.00899778f, -0.03863050f, 
    -0.04403349f, 0.03178220f, -0.00258878f, 0.01188214f, 0.01589571f, -0.00758196f, -0.03093106f, -0.04426233f, 
    -0.00722610f, -0.04798378f, -0.03618702f, -0.01285450f, -0.03573547f, 0.02813917f, -0.01318244f, 0.00523284f, 
    -0.00452473f, -0.00232885f, -0.03506810f, 0.02011797f, -0.02279203f, 0.01140115f, 0.05071927f, -0.01298196f, 
    -0.02752544f, 0.03576027f, -0.00340083f, 0.04515628f, 0.01579680f, -0.03063232f, -0.00938547f, -0.03170645f, 
    0.01221933f, -0.01837420f, -0.01614450f, 0.02707355f, -0.03105662f, -0.02415856f, 0.00668800f, 0.01780208f, 
    0.01336803f, 0.00118818f, -0.05532721f, -0.01290338f, -0.03732719f, 0.02681166f, -0.00283277f, 0.02862436f, 
    -0.00479457f, -0.04453208f, 0.00246265f, 0.01920679f, -0.04712589f, 0.05770156f, -0.02811183f, -0.02678782f, 
    0.02080205f, 0.00877810f, 0.00877458f, -0.00529483f, -0.00178041f, -0.05437341f, 0.02925429f, 0.04072904f, 
    0.04257040f, -0.04905443f, -0.04528376f, 0.03495581f, -0.00293860f, 0.00351749f, -0.00984091f, 0.00716305f, 
    0.02258395f, -0.04835875f, 0.01369699f, -0.03106417f, 0.01313198f, 0.02885031f, -0.01524018f, -0.01347621f, 
    -0.00577717f, -0.01287543f, 0.04316314f, -0.02194077f, -0.00110203f, 0.03051273f, 0.00323939f, -0.04096606f, 
    0.00046212f, 0.01952742f, -0.01710532f, -0.04493374f, -0.03806641f, -0.04298010f, -0.01579424f, 0.02492040f, 
    -0.00820023f, -0.05852003f, -0.00226023f, -0.01450183f, -0.01326453f, 0.00630785f, -0.04439715f, 0.01585231f, 
    -0.05028599f, -0.02197156f, 0.01672148f, 0.03921715f, -0.04381924f, -0.03920561f, -0.01530252f, -0.02959818f, 
    0.03489717f, 0.02127085f, -0.05468917f, 0.01226220f, -0.00183294f, 0.03916586f, -0.03060921f, -0.04911232f, 
    -0.02881281f, -0.00874319f, 0.01383455f, 0.05245445f, -0.01634459f, -0.04310064f, 0.02411592f, 0.01726944f, 
    0.04116922f, -0.04904216f, -0.03204570f, 0.01712260f, -0.04367520f, 0.04522600f, -0.01411157f, 0.03490459f, 
    -0.02673009f, 0.03588839f, 0.04349911f, -0.00797787f, -0.03026537f, -0.04451553f, 0.01582450f, -0.04729540f, 
    0.03145984f, -0.03996200f, 0.02806740f, 0.02555739f, 0.04240669f, -0.05616390f, -0.01236129f, -0.03468063f, 
    -0.02227897f, -0.05100842f, 0.04462322f, -0.02834333f, 0.04365012f, -0.03121346f, 0.00808999f, -0.00978954f, 
    -0.01958986f, -0.01967385f, 0.00707854f, 0.03154904f, -0.04615504f, -0.00226894f, 0.00191644f, 0.05201675f, 
    0.03980837f, -0.04096299f, 0.01120163f, 0.03905124f, 0.03551785f, 0.04022268f, -0.04027135f, -0.02070179f, 
    -0.05120500f, 0.01958880f, 0.02362491f, 0.00169846f, 0.00299473f, 0.04252147f, 0.03581773f, 0.03286799f, 
    0.01772266f, -0.02124485f, 0.02884255f, 0.03717417f, -0.01822921f, -0.03087744f, -0.02080273f, 0.00152660f, 
    -0.03955774f, -0.03261439f, 0.01320853f, 0.03248338f, -0.04436421f, 0.00242037f, -0.01626655f, -0.00344541f, 
    -0.02024541f, -0.02801652f, 0.02885816f, 0.02445563f, 0.01091278f, 0.02114107f, 0.00654575f, -0.04039827f, 
    -0.01089987f, 0.02455706f, 0.03542152f, 0.02577788f, 0.04540716f, 0.04778840f, -0.04709476f, 0.04858790f, 
    0.02809745f, -0.02327493f, -0.02294978f, -0.02046341f, 0.00466023f, 0.00047237f, 0.02850538f, 0.04029704f, 
    0.00564401f, -0.03059094f, 0.00394701f, 0.02621770f, -0.03772346f, -0.04012312f, 0.04900341f, -0.02896392f, 
    -0.01204910f, -0.04332069f, -0.02334524f, 0.00523451f, -0.02464502f, 0.00440973f, -0.03530923f, 0.03238612f, 
    -0.02985573f, -0.04028098f, -0.03509158f, 0.03460160f, 0.03209202f, -0.00909832f, 0.03786811f, -0.01980289f, 
    0.04057332f, 0.03359310f, -0.01366510f, 0.00250740f, 0.00530409f, 0.00911586f, -0.01183494f, 0.03118584f, 
    -0.01035558f, 0.04638540f, 0.01188141f, 0.03229650f, -0.03403313f, 0.00853252f, -0.00113823f, -0.03014047f, 
    -0.03718773f, -0.02613212f, -0.02850598f, -0.01478587f, 0.04438097f, -0.04514859f, -0.02044168f, 0.01009681f, 
    -0.03469469f, -0.02568191f, -0.01063200f, 0.02849297f, -0.01358487f, 0.04510363f, 0.04365439f, 0.03243960f, 
    -0.03516095f, 0.00399953f, 0.00421703f, -0.02663091f, -0.03428311f, -0.04086608f, 0.03237484f, -0.03235777f, 
    0.02249489f, -0.04924666f, -0.01443232f, 0.02564661f, -0.02643088f, -0.02718438f, 0.01725095f, -0.04718803f, 
    -0.03935002f, 0.02704204f, -0.00493748f, 0.00203963f, -0.04891258f, 0.00425322f, -0.03106926f, -0.00481783f, 
    0.02075689f, -0.00979555f, -0.03922450f, 0.01459115f, -0.02695023f, -0.03041292f, -0.02284538f, -0.01163765f, 
    -0.03022434f, -0.03994864f, 0.01886347f, -0.00398535f, -0.00442561f, 0.04584057f, -0.01103199f, 0.02015197f, 
    -0.00750547f, -0.01310049f, 0.01237964f, 0.02325062f, -0.03248784f, -0.00195112f, -0.02540955f, 0.02165573f, 
    -0.01003543f, -0.01486773f, 0.01888383f, 0.04516137f, 0.02867437f, -0.00253256f, -0.01844100f, 0.03991892f, 
    -0.03363774f, -0.03905733f, 0.02834752f, 0.04031246f, -0.01370301f, -0.01709190f, -0.03646206f, -0.01205853f, 
    0.02574404f, -0.04231221f, -0.02691032f, 0.04714113f, -0.04769941f, 0.02618097f, -0.02420207f, 0.00619214f, 
    0.03014341f, -0.02610601f, -0.03841383f, -0.00852685f, 0.03371096f, -0.03014619f, 0.02509077f, 0.01113265f, 
    -0.00250009f, 0.00006704f, 0.00126306f, 0.01308869f, -0.03648086f, 0.03113529f, 0.00785473f, -0.04666891f, 
    0.00066459f, 0.00737128f, -0.04006643f, 0.01089386f, -0.04682023f, -0.02553145f, -0.02586540f, -0.03758514f, 
    -0.01026119f, -0.04019341f, -0.00257509f, 0.03629703f, 0.00037323f, 0.01692855f, 0.00463861f, -0.00580791f, 
    0.00286642f, -0.03783055f, -0.04343606f, -0.00933075f, -0.01420409f, 0.02806778f, -0.04747413f, -0.03299329f, 
    0.02156832f, 0.03844950f, 0.03584468f, 0.00334287f, -0.01444965f, -0.00721332f, -0.01608741f, 0.04343259f, 
    -0.02590504f, -0.00478056f, 0.04139442f, 0.02402024f, -0.04060703f, -0.02704855f, 0.00459459f, -0.03015429f, 
    -0.05011939f, -0.01876370f, -0.03906273f, -0.04343663f, 0.02937192f, 0.00999611f, -0.02115917f, 0.02206428f, 
    -0.00513032f, -0.05041507f, -0.04519079f, -0.01438460f, -0.04086607f, -0.00438067f, -0.02533264f, 0.00468044f, 
    -0.01875971f, -0.01696789f, 0.03156074f, -0.05026776f, 0.04393846f, -0.01926997f, 0.02962924f, 0.03013121f, 
    -0.05044400f, -0.03405970f, 0.03447525f, 0.01690506f, -0.04990313f, -0.03885160f, 0.01790597f, -0.04325859f, 
    0.03528840f, -0.04210898f, 0.02017556f, 0.04465702f, 0.03012125f, 0.02240053f, -0.01591911f, 0.04592664f, 
    -0.03514193f, 0.01464177f, -0.03693542f, 0.00088809f, -0.00302341f, 0.04061113f, -0.04500727f, -0.01181673f, 
    -0.00996738f, 0.00431270f, -0.02223463f, -0.01506481f, -0.02672302f, -0.01289647f, -0.02955409f, -0.04793876f, 
    -0.03533741f, -0.04757956f, -0.03453347f, 0.00456125f, 0.00638422f, 0.01002410f, 0.04996151f, 0.02467262f, 
    -0.03339972f, -0.04930693f, 0.01955777f, -0.02016916f, 0.03149872f, 0.02384642f, -0.04045628f, -0.04398568f, 
    0.02353898f, 0.03956902f, 0.00610092f, -0.04571881f, -0.03579237f, -0.00864830f, -0.00259433f, 0.02578616f, 
    0.01416554f, -0.04498230f, -0.00239170f, 0.00095364f, 0.02230602f, -0.00652354f, 0.04066721f, -0.00120498f, 
    0.03019749f, -0.01624707f, 0.03636122f, 0.03006906f, -0.02765356f, -0.00428608f, -0.01827901f, -0.00616912f, 
    0.03555120f, -0.00623425f, -0.03284901f, -0.02900369f, 0.01336099f, -0.03621608f, 0.00810013f, -0.01990088f, 
    0.00902212f, -0.00456204f, -0.03484378f, 0.04883050f, -0.02179742f, -0.03666134f, 0.00009580f, -0.00507609f, 
    -0.05044289f, 0.05059900f, 0.05067654f, 0.00246013f, 0.02098656f, -0.01464456f, 0.00540292f, -0.01107745f, 
    -0.01593965f, -0.04845501f, 0.00140789f, 0.02540546f, 0.04877250f, 0.04584320f, 0.00974588f, 0.03956906f, 
    0.04376800f, 0.00560212f, -0.04927757f, -0.03154128f, -0.01781147f, 0.02019808f, -0.05091688f, 0.03972179f, 
    0.00838826f, 0.03200366f, -0.02311233f, 0.00692630f, -0.00652388f, 0.01370451f, -0.05073983f, -0.02815095f, 
    0.01796750f, 0.02513771f, -0.03493149f, -0.02822090f, -0.01036558f, 0.00703105f, -0.01068239f, -0.00359449f, 
    -0.02596916f, -0.01322870f, -0.04117569f, 0.01335288f, 0.03348843f, 0.02803160f, 0.04190845f, 0.00350203f, 
    -0.00887673f, -0.04402342f, -0.00155448f, -0.04216146f, -0.05325099f, 0.00907468f, -0.04709214f, -0.00513430f, 
    -0.05181989f, 0.03017328f, -0.03251730f, -0.05108276f, -0.04696923f, -0.03248538f, 0.00183473f, -0.03279357f, 
    -0.00700322f, 0.03897280f, -0.03319463f, 0.04687127f, 0.00543479f, -0.03747240f, 0.01393360f, 0.00834720f, 
    -0.02940527f, -0.00181286f, 0.00785063f, 0.00925457f, -0.03618520f, 0.02671585f, 0.01962300f, -0.00803916f, 
    0.00443475f, -0.05692914f, -0.05319284f, 0.01984353f, 0.03175673f, 0.03955429f, 0.00342915f, -0.05217102f, 
    0.01816591f, -0.03324199f, -0.00673816f, -0.01765214f, -0.06151652f, 0.01837280f, -0.01683242f, -0.00676194f, 
    0.04284648f, -0.01741398f, 0.04357120f, -0.03210738f, -0.05018724f, -0.04904458f, -0.03645790f, -0.02801862f, 
    -0.03169898f, -0.05094771f, 0.01055925f, -0.01586202f, 0.01209786f, -0.03620264f, -0.04263624f, 0.03522604f, 
    -0.05191160f, -0.02014345f, -0.04369769f, -0.05898346f, -0.03804906f, 0.03006804f, -0.04553545f, -0.01647655f, 
    0.00319785f, 0.03199873f, -0.01844887f, -0.04437758f, 0.00192383f, -0.00335369f, -0.01714592f, -0.02088111f, 
    0.03181683f, -0.03244535f, 0.03620001f, 0.01995931f, 0.02119911f, -0.02057011f, -0.04151365f, 0.04915107f, 
    0.03677180f, -0.00076475f, -0.04468493f, -0.01161254f, -0.03204314f, 0.00753077f, -0.00404153f, -0.02813544f, 
    0.02836586f, -0.05513561f, -0.00629887f, 0.03116918f, 0.01567323f, 0.03905970f, -0.00648030f, 0.00276258f, 
    -0.05728002f, -0.03414630f, -0.03626388f, -0.02968916f, 0.01183104f, -0.03002276f, -0.00317899f, 0.01371814f, 
    0.02908395f, -0.00178748f, -0.01931077f, -0.01929215f, -0.01432735f, 0.00435324f, -0.02738167f, -0.03829625f, 
    0.00595092f, 0.03543392f, 0.03665543f, 0.01368486f, -0.02242075f, 0.02580146f, 0.03895485f, -0.01298701f, 
    -0.02032778f, -0.00699796f, -0.03229596f, -0.03663536f, -0.05341705f, 0.01854932f, 0.00427968f, -0.02077236f, 
    0.04201813f, 0.00572562f, -0.04917211f, -0.03191744f, -0.02113590f, -0.04546382f, 0.01530124f, -0.03320933f, 
    0.02796990f, 0.04110568f, -0.02959333f, -0.03116980f, -0.04708403f, -0.01045682f, 0.00384331f, 0.04321048f, 
    0.00702922f, -0.03918356f, -0.00984419f, -0.04867461f, 0.01510254f, -0.02756748f, -0.03114244f, 0.02608108f, 
    0.02405242f, -0.03638280f, -0.02899779f, -0.01080718f, 0.00002644f, -0.02119437f, 0.02904497f, 0.01017544f, 
    0.01272765f, 0.02314561f, -0.05358203f, -0.01482580f, 0.02956739f, -0.02201714f, -0.00095231f, -0.01102931f, 
    -0.05403303f, -0.02784413f, 0.01057342f, -0.02203286f, -0.04441857f, -0.04738492f, 0.01075014f, 0.04681424f, 
    -0.03541669f, -0.00218092f, 0.02361016f, -0.04779355f, -0.04953690f, -0.00125154f, 0.02782179f, -0.04081171f, 
    -0.05190069f, 0.02881250f, 0.01786977f, 0.03871951f, -0.02663492f, 0.00563725f, -0.04197377f, 0.02485729f, 
    0.02208958f, -0.05495913f, -0.03713887f, 0.02027193f, 0.01029509f, 0.00235249f, -0.05255130f, 0.04290565f, 
    -0.02025127f, -0.00876653f, 0.02324678f, 0.00468737f, -0.02184998f, 0.03965078f, -0.01523561f, -0.01047963f, 
    -0.01062780f, -0.00313349f, 0.02513859f, 0.02418733f, 0.02623926f, -0.02645556f, 0.02277702f, -0.00710648f, 
    -0.03911104f, 0.01756718f, -0.03715442f, -0.02590017f, -0.05185434f, 0.00036269f, -0.03680233f, -0.04662036f, 
    0.03363638f, -0.01226720f, 0.03530893f, 0.03376427f, -0.02324635f, 0.04008501f, -0.03208887f, -0.02147046f, 
    0.01944786f, 0.02886342f, -0.01761871f, 0.01417574f, 0.01893947f, -0.00467829f, -0.02526015f, -0.03276593f, 
    -0.04448847f, -0.05023878f, 0.01122599f, 0.00778102f, -0.05220762f, 0.01202190f, -0.02855106f, -0.04316650f, 
    0.02925954f, 0.04185543f, -0.01523681f, 0.02276114f, 0.02501045f, 0.01272287f, 0.01224031f, -0.02626411f, 
    0.01279181f, 0.02619310f, 0.03717569f, 0.01327706f, -0.00465660f, 0.03450830f, -0.04354535f, 0.02605764f, 
    0.00286555f, -0.00364041f, -0.00253148f, 0.00046674f, 0.01927962f, -0.03908152f, 0.04941374f, 0.02617332f, 
    0.01504739f, -0.00191018f, -0.02096249f, 0.04281519f, -0.04126108f, -0.02139203f, 0.01382919f, 0.03618968f, 
    -0.03293329f, 0.00461441f, 0.00991986f, 0.03450936f, 0.01859198f, -0.00286368f, 0.01417820f, 0.02212657f, 
    -0.01004625f, -0.04335457f, -0.00157633f, -0.03917696f, 0.01119208f, -0.01758866f, -0.02391052f, -0.02574708f, 
    -0.01327406f, -0.04397061f, -0.03543659f, 0.01971350f, -0.00955642f, -0.01643446f, -0.03547743f, -0.02733552f, 
    0.03245530f, -0.02706318f, 0.03562303f, -0.03502743f, 0.04030738f, 0.00639731f, -0.01588020f, 0.04794016f, 
    -0.04425537f, 0.01464706f, -0.04912307f, -0.04659697f, 0.01136064f, -0.03653799f, 0.00638983f, 0.02992815f, 
    -0.03213381f, -0.00826773f, 0.02830603f, -0.02007338f, 0.00903132f, -0.00801972f, 0.02446061f, -0.04010512f, 
    0.00015467f, 0.04792187f, -0.03610699f, 0.03211800f, -0.01845462f, -0.00185410f, 0.02111387f, -0.01502401f, 
    0.01574885f, -0.04669539f, 0.04386595f, -0.04074325f, 0.01549593f, 0.02665205f, 0.00739009f, 0.04097242f, 
    0.03901580f, 0.02664694f, -0.03861927f, -0.00932338f, 0.00641180f, 0.02174922f, 0.03832386f, 0.03740405f, 
    -0.00074317f, -0.01984181f, -0.03243872f, -0.03034035f, -0.03378405f, -0.02622722f, -0.00777769f, -0.01961848f, 
    0.03079774f, 0.02450397f, -0.00312885f, -0.02584824f, -0.01513879f, 0.00827991f, 0.04341321f, -0.02352250f, 
    0.00463496f, -0.02226728f, 0.02135128f, 0.03998068f, 0.00583750f, 0.03394815f, 0.02033568f, 0.00908973f, 
    0.05429300f, 0.26166016f, 0.28107271f, -0.02927309f, -0.05335192f, -0.00701592f, 0.12667476f, 0.11124914f, 
    -0.05800054f, 0.02518359f, -0.01662492f, 0.03466417f, -0.26065266f, 0.10796184f, 0.02410324f, -0.18860188f, 
    0.08563256f, 0.10684824f, 0.02417791f, 0.07108856f, 0.02212269f, -0.07277127f, -0.01546988f, -0.00483539f, 
    -0.17458175f, 0.06545982f, 0.16865185f, -0.18173756f, -0.02439508f, -0.09926898f, 0.08878343f, 0.07809427f, 
    0.04651330f, 0.09463134f, 0.04673306f, 0.04596115f, -0.17787860f, -0.03779069f, 0.06300789f, -0.18896028f, 
    0.00678971f, 0.10712899f, -0.06608827f, -0.16236044f, 0.03482940f, -0.10562114f, 0.10074962f, 0.11285884f, 
    -0.10977279f, -0.02428470f, 0.10964213f, -0.03827964f, -0.09289598f, -0.07640323f, 0.11943378f, 0.05267146f, 
    -0.09586698f, -0.03249270f, -0.06480353f, -0.09378842f, 0.04677828f, -0.19618198f, -0.01193912f, 0.04406098f, 
    0.09316040f, 0.03434939f, 0.00590962f, -0.03208913f, -0.04127982f, 0.02182362f, 0.01259840f, -0.07340176f, 
    -0.25584748f, 0.21572283f, -0.03639995f, 0.02597254f, 0.04166397f, 0.09069900f, -0.06780315f, 0.12338588f, 
    -0.02816541f, -0.03645938f, -0.12438027f, -0.10148136f, 0.17401138f, -0.07367322f, -0.11163344f, -0.10866672f, 
    0.09565689f, 0.03285705f, -0.02517907f, -0.02452387f, 0.00765764f, -0.00559719f, 0.06970569f, -0.03593124f, 
    0.07646628f, 0.22950341f, 0.24731451f, 0.09232704f, -0.10743482f, 0.05031899f, 0.02388335f, 0.08251120f, 
    -0.08463678f, -0.08326086f, -0.00467591f, 0.01844764f, 0.22369136f, 0.01482433f, 0.17139605f, -0.03449746f, 
    -0.25450227f, -0.02933158f, 0.05949248f, -0.06284885f, -0.02344365f, -0.08988788f, 0.00594808f, -0.07238147f, 
    -0.16372928f, -0.21140049f, -0.02551142f, 0.23439835f, 0.15030439f, -0.01110967f, 0.09547194f, -0.03657786f, 
    0.13527448f, 0.02601195f, -0.03900538f, 0.00739394f, 0.03028850f, 0.24765693f, 0.14109585f, 0.11161744f, 
    -0.09530259f, 0.13966571f, 0.20617241f, 0.13951217f, 0.00067263f, 0.04338570f, 0.10145982f, -0.00086051f, 
    0.20417431f, 0.11268651f, 0.17978081f, -0.06691278f, -0.01499716f, 0.00594878f, 0.08629694f, -0.02320931f, 
    -0.00950029f, -0.00445200f, 0.01328531f, -0.09252454f, 0.09235585f, -0.12711452f, 0.12793589f, 0.02913069f, 
    -0.03338628f, 0.18070032f, 0.11301717f, -0.00663651f, -0.05290277f, 0.04370467f, -0.02580300f, -0.05911480f, 
    0.07593257f, 0.07528093f, 0.07283006f, -0.21545509f, -0.04739543f, 0.08975508f, 0.07840072f, 0.01131345f, 
    -0.10593714f, -0.04885679f, 0.04340585f, -0.07088948f, -0.18384825f, -0.08434995f, 0.18622331f, 0.16625684f, 
    -0.10499919f, -0.07541288f, 0.05584971f, -0.03568475f, -0.14215688f, -0.11894947f, -0.03750982f, 0.06756657f, 
    -0.09043291f, 0.21943200f, -0.01044350f, 0.00638224f, 0.01041131f, -0.03765692f, -0.01081532f, 0.06022091f, 
    0.07873216f, 0.00333301f, 0.01038182f, 0.14086126f, -0.12135153f, 0.17437704f, -0.21371852f, -0.12469655f, 
    0.07335868f, 0.20219229f, 0.02850308f, -0.07530248f, -0.05758151f, 0.04681783f, 0.00137800f, -0.00276017f, 
    0.13503285f, 0.20876090f, 0.20544356f, -0.08195892f, -0.06760700f, 0.11077419f, 0.01146911f, 0.05025585f, 
    0.00777629f, -0.00723253f, -0.09981485f, 0.08420347f, 0.03639363f, -0.15234502f, 0.02554323f, 0.03285015f, 
    0.09988599f, 0.07870435f, 0.02420893f, 0.15060420f, -0.08053186f, 0.05803718f, 0.12551460f, 0.07286052f, 
    0.03060895f, 0.11896411f, -0.05030072f, 0.15602642f, 0.10224893f, 0.03633976f, 0.08171126f, 0.00604610f, 
    0.10689745f, -0.00364298f, 0.03499468f, -0.02078696f, 0.09243621f, 0.03580077f, 0.08165278f, 0.05584386f, 
    -0.18280070f, 0.01130856f, 0.09871867f, 0.08064305f, -0.01080795f, 0.04891255f, 0.11476175f, 0.02279942f, 
    -0.20730849f, -0.24885058f, -0.00885770f, -0.13259754f, 0.10547440f, -0.00849566f, 0.01612362f, 0.07237896f, 
    0.06998721f, -0.01914591f, -0.07342599f, -0.08692225f, -0.17248149f, -0.00319682f, -0.15847546f, 0.11686771f, 
    0.22051759f, 0.04865346f, -0.04905119f, 0.04539656f, 0.05741812f, 0.23794532f, -0.02227850f, 0.02885676f, 
    -0.01729085f, 0.18455692f, -0.01175679f, 0.08002237f, -0.05397981f, -0.04408550f, 0.10610148f, -0.05204945f, 
    0.07672647f, 0.05075712f, 0.04766593f, -0.05533780f, 0.13775626f, 0.01295502f, 0.05199089f, 0.13203998f, 
    -0.06941406f, 0.01122303f, 0.10113356f, 0.06318671f, -0.03808999f, -0.01020235f, 0.02201923f, 0.00462713f, 
    -0.06184819f, -0.04742247f, 0.24680099f, 0.09145953f, -0.03845910f, -0.14262064f, 0.00808757f, -0.08439580f, 
    -0.01911006f, 0.04267623f, -0.03095976f, -0.11115037f, -0.14258686f, -0.21607348f, -0.06826044f, -0.06657672f, 
    0.11946554f, 0.15639877f, 0.09780952f, 0.11068492f, -0.07410761f, 0.02456513f, 0.01525604f, -0.01520545f, 
    0.17617477f, -0.02961270f, 0.12598772f, -0.03888642f, 0.01736692f, 0.07966626f, 0.04994902f, 0.03350129f, 
    0.10707682f, 0.07744458f, 0.03267611f, -0.01642860f, 0.10143906f, 0.04341120f, 0.28592387f, 0.07224919f, 
    -0.14317860f, 0.01703937f, 0.09304804f, -0.04485815f, -0.15428548f, -0.05764066f, -0.06363776f, 0.04382635f, 
    0.32474214f, 0.15906900f, 0.13061282f, -0.05234368f, -0.05130599f, -0.04006428f, 0.08123918f, 0.01779659f, 
    -0.03840005f, 0.07980414f, 0.12049963f, 0.05008099f, -0.19855489f, -0.01067417f, -0.12660021f, -0.13929941f, 
    -0.01121666f, 0.02539852f, -0.07170069f, 0.05365054f, -0.04326594f, 0.00993181f, 0.00606069f, -0.02175017f, 
    0.41528022f, 0.22762989f, 0.00301813f, 0.06589080f, -0.09806682f, -0.00492844f, 0.08304460f, -0.01397182f, 
    0.03820787f, -0.03886600f, -0.00277161f, -0.13814597f, 0.03215717f, -0.04648377f, -0.00211896f, -0.06495192f, 
    0.00732135f, 0.17768256f, -0.09094860f, -0.07582102f, -0.04337187f, 0.05549493f, -0.05055678f, -0.02469485f, 
    0.25663757f, -0.14099917f, 0.02423402f, 0.07565827f, -0.00363810f, 0.11169349f, -0.01374434f, 0.05733841f, 
    0.03124823f, 0.01336382f, 0.01130016f, 0.13789882f, -0.03632405f, -0.04951935f, 0.01851819f, 0.15980253f, 
    -0.06332358f, 0.04442981f, -0.06241729f, -0.06673632f, -0.00637957f, 0.06031021f, -0.00648624f, -0.07437542f, 
    0.17374645f, -0.03501482f, -0.15761086f, 0.03381314f, -0.04433847f, -0.02292328f, -0.03282712f, -0.00249359f, 
    -0.03833487f, 0.08454364f, -0.02429088f, -0.06880112f, 0.06525567f, -0.08702467f, 0.17117625f, -0.20894149f, 
    -0.02404683f, 0.02804852f, 0.00497093f, 0.02182724f, -0.07486615f, -0.03418558f, 0.03662084f, 0.01981148f, 
    0.09786917f, 0.06717343f, -0.17899007f, 0.06930541f, -0.07974717f, 0.00054096f, 0.05188521f, 0.02129187f, 
    0.02494412f, -0.01076834f, -0.02262283f, 0.12128054f, -0.04086759f, -0.09857348f, -0.18630514f, -0.12039402f, 
    0.01607217f, -0.00957298f, 0.04514764f, 0.01684057f, 0.07413267f, 0.05445058f, -0.06452547f, -0.00937000f, 
    0.33734939f, 0.04191890f, 0.09830506f, 0.09329391f, -0.08435401f, -0.11332744f, 0.08296088f, 0.05055381f, 
    0.01081568f, -0.05641034f, -0.02639030f, 0.08511594f, 0.28711149f, 0.11211060f, 0.03228150f, 0.11353276f, 
    -0.00019989f, -0.04671040f, -0.02972795f, 0.10147068f, -0.01221407f, 0.07613990f, 0.00657915f, -0.02242616f, 
    -0.16199540f, -0.07264191f, 0.05940874f, -0.05342964f, -0.06305750f, 0.02598035f, 0.05228397f, 0.11490680f, 
    0.07178546f, 0.00713198f, 0.03936829f, -0.04710173f, 0.03263910f, 0.08169068f, 0.07700855f, 0.18877284f, 
    0.02927287f, 0.01875823f, -0.03684753f, -0.03079946f, -0.01675286f, 0.01130493f, 0.04536504f, -0.01945142f, 
    0.15805556f, -0.01883472f, 0.11465250f, 0.28751510f, -0.12742092f, -0.00443961f, 0.06139431f, 0.12628962f, 
    -0.14405838f, 0.04581736f, 0.03795021f, -0.02983773f, 0.05623141f, -0.07861407f, 0.05022360f, -0.00673782f, 
    -0.07270546f, 0.08270066f, -0.05574488f, 0.06503857f, -0.17217547f, 0.08220126f, -0.00352035f, 0.07275143f, 
    0.21340449f, -0.08247688f, -0.05366900f, 0.22389013f, -0.13055012f, -0.02333030f, -0.06884871f, -0.04021647f, 
    0.07225160f, -0.00447218f, -0.05259712f, 0.04048805f, 0.05108698f, -0.22084746f, -0.05325522f, -0.16226740f, 
    -0.02345340f, -0.01300869f, 0.06674223f, 0.02622406f, -0.03324816f, -0.04351150f, -0.06802136f, 0.06496226f, 
    0.03126656f, 0.03157191f, 0.02555623f, 0.19035916f, -0.00730441f, 0.06256834f, -0.01543213f, -0.03637303f, 
    -0.00619801f, -0.01000580f, 0.07667693f, 0.08397647f, -0.07413545f, 0.03045671f, -0.04187893f, -0.00187451f, 
    0.06998679f, 0.09837678f, -0.00131941f, -0.03773827f, -0.00494034f, -0.00327717f, 0.09355347f, 0.12811516f, 
    0.43078974f, 0.13057357f, -0.08245997f, 0.21145704f, -0.07729747f, -0.05683722f, 0.06920476f, 0.01394243f, 
    -0.00696177f, 0.04968186f, -0.07796945f, -0.10362267f, 0.08173203f, 0.04344853f, -0.17762093f, -0.27714065f, 
    0.06212909f, 0.01191719f, -0.06098917f, -0.07397109f, 0.01749449f, 0.02319109f, 0.10376867f, 0.09244720f, 
    -0.21277313f, 0.05514426f, 0.08454099f, -0.19082025f, -0.10324583f, 0.00387892f, 0.05621289f, 0.00989452f, 
    0.01894087f, 0.12238957f, -0.03775759f, -0.09092223f, 0.08991712f, 0.22110440f, 0.06631150f, 0.14386249f, 
    0.02263466f, -0.05754033f, -0.05801302f, 0.10433750f, 0.08237819f, -0.00758854f, 0.08584612f, 0.00274112f, 
    -0.11548907f, 0.10549847f, -0.16225964f, -0.21862875f, -0.04127170f, 0.00989687f, 0.03273555f, -0.00375626f, 
    0.09609578f, -0.10109603f, -0.03458265f, -0.02908948f, 0.11941611f, 0.03029229f, 0.02024266f, -0.18199201f, 
    -0.05648668f, 0.04149488f, 0.09269469f, -0.04140322f, 0.09728225f, -0.01202231f, -0.07511981f, 0.02998023f, 
    0.25756955f, 0.10024858f, -0.15650658f, 0.12756883f, -0.11207510f, -0.05030004f, -0.04438329f, 0.01451563f, 
    -0.06031389f, -0.00656303f, -0.01413995f, 0.01453629f, -0.10244371f, -0.07879341f, -0.03279903f, 0.18551670f, 
    -0.00927856f, 0.07058109f, 0.04069811f, -0.05927981f, -0.02964161f, -0.00048549f, 0.01706381f, -0.01694985f, 
    -0.00641613f, 0.05961956f, -0.07157531f, -0.16294335f, 0.05513430f, -0.06776470f, 0.04168364f, 0.04516668f, 
    -0.05084668f, -0.09063149f, -0.00797784f, 0.04098878f, 0.06471942f, 0.10550015f, 0.06787001f, -0.17680787f, 
    0.11468024f, 0.03510590f, -0.06481009f, -0.00159237f, -0.06502269f, 0.00954234f, -0.11340789f, -0.03904974f, 
    0.12231963f, 0.03194124f, 0.11602391f, 0.03848118f, -0.05225696f, 0.13111188f, -0.02671853f, 0.06848070f, 
    0.11828674f, -0.00498601f, -0.03978825f, -0.00074157f, -0.24653390f, -0.10798520f, 0.20238528f, 0.08524129f, 
    -0.05449793f, -0.03170352f, 0.03033039f, 0.05360073f, 0.00794547f, 0.10068642f, -0.06201990f, 0.06790689f, 
    0.38950935f, 0.13964280f, 0.11586937f, 0.00681585f, -0.15661649f, -0.09060848f, 0.00004592f, 0.07027299f, 
    0.09894006f, 0.00819481f, 0.01484061f, -0.02659479f, 0.26297301f, -0.04280404f, 0.07115406f, -0.03199195f, 
    -0.03332340f, 0.00426379f, 0.03692580f, 0.03556233f, -0.07588688f, 0.04082941f, 0.00735064f, -0.04782058f, 
    -0.06237084f, 0.01236948f, -0.01082518f, -0.02551165f, -0.02504952f, 0.02331972f, 0.03202434f, 0.04401635f, 
    -0.05554343f, -0.00558056f, 0.04167728f, -0.05369890f, 0.01501833f, 0.03293679f, -0.01995607f, 0.01078722f, 
    0.02265055f, 0.00029374f, -0.05151006f, -0.01890816f, 0.01380350f, 0.00538483f, -0.04339536f, 0.01272891f, 
    -0.03270946f, -0.01402295f, 0.01708197f, -0.02669693f, -0.01913047f, -0.03040396f, -0.00226707f, -0.03254929f, 
    -0.01597948f, -0.04297573f, -0.03472067f, 0.01134835f, 0.01865047f, 0.02274534f, 0.02829289f, 0.00474628f, 
    -0.01970560f, 0.02770692f, -0.03100754f, -0.03973828f, 0.00456966f, -0.02893174f, 0.01227867f, 0.03690237f, 
    0.02219409f, -0.03355552f, 0.03769838f, -0.03420831f, 0.01524897f, 0.03243372f, 0.02523678f, -0.03132136f, 
    0.03130025f, 0.00864395f, -0.03701244f, -0.02486982f, -0.04132562f, -0.04082840f, 0.03451023f, 0.04466066f, 
    0.03442668f, 0.00191198f, -0.03467022f, -0.01173410f, -0.01399654f, -0.04795815f, 0.04000588f, 0.01819836f, 
    -0.02036352f, 0.03959225f, 0.04361575f, -0.00247511f, 0.02950016f, -0.00399345f, 0.01888445f, -0.05386013f, 
    -0.04885326f, -0.00547345f, -0.01572889f, 0.00655670f, -0.04116794f, 0.03333711f, -0.00369632f, -0.00493399f, 
    -0.03072420f, -0.00810364f, -0.04838991f, -0.02394712f, -0.06242382f, -0.04064287f, 0.02434912f, -0.02244399f, 
    0.00134327f, 0.00200619f, -0.00815041f, -0.01244610f, -0.03005800f, 0.03967869f, -0.04639704f, 0.00867862f, 
    -0.03864083f, -0.04256350f, -0.03807209f, 0.00271390f, 0.04119720f, -0.03686364f, 0.04276457f, 0.01161346f, 
    0.02898204f, 0.02146364f, -0.02427153f, -0.03823888f, -0.02042909f, 0.02808290f, 0.02046110f, -0.01697065f, 
    0.03895434f, -0.03859398f, -0.00113301f, 0.03015035f, -0.01703856f, 0.04237754f, -0.03150325f, -0.03732516f, 
    0.03882670f, 0.01558798f, -0.04699071f, -0.01598823f, 0.00122976f, -0.00894894f, 0.06064719f, -0.01571279f, 
    -0.00358711f, 0.01159935f, 0.04874753f, -0.01710200f, -0.03380613f, -0.02812973f, 0.00670525f, 0.03756174f, 
    -0.05957952f, -0.03436664f, 0.02604012f, -0.02203672f, -0.04459785f, 0.00118084f, -0.05269906f, -0.01195528f, 
    -0.04181106f, -0.04701494f, -0.05339043f, -0.01667461f, -0.01752477f, 0.01839509f, -0.03122121f, -0.02070122f, 
    -0.02387913f, 0.01413827f, -0.00895491f, -0.00824097f, 0.01010173f, 0.00877367f, -0.01343183f, -0.01104382f, 
    0.01201979f, -0.00614839f, -0.00600429f, 0.03246632f, -0.01786421f, -0.05316037f, -0.05326202f, -0.00889978f, 
    -0.02015621f, -0.00956446f, -0.00855954f, -0.00955082f, 0.00991108f, 0.02296390f, -0.03771478f, 0.02781868f, 
    -0.00897686f, 0.01207194f, 0.04925564f, 0.00323273f, -0.04027197f, 0.00508843f, 0.04310663f, -0.03915408f, 
    0.03698521f, 0.01788007f, -0.05641649f, 0.00583936f, -0.00631635f, -0.04577083f, 0.03072470f, -0.00309714f, 
    -0.00560505f, -0.00841886f, -0.05511532f, 0.02175829f, 0.03318023f, 0.01053359f, -0.03166723f, -0.01293505f, 
    -0.02493362f, -0.03202769f, 0.00756332f, -0.01184697f, 0.01613688f, -0.00966677f, 0.04145909f, -0.03308057f, 
    -0.01823905f, -0.00664018f, -0.04794047f, 0.03170441f, -0.05299810f, -0.01982992f, -0.00854048f, 0.00679202f, 
    0.03093616f, 0.03186074f, 0.03161985f, 0.01847761f, -0.02585566f, 0.03274755f, 0.00898436f, -0.01438821f, 
    0.04336492f, 0.02453757f, -0.03809792f, 0.03193830f, 0.00045024f, -0.02814526f, -0.03378138f, 0.02714603f, 
    -0.04149542f, -0.03001423f, -0.01238453f, 0.03305595f, -0.01384204f, 0.02074731f, -0.01405186f, -0.01562565f, 
    0.03926504f, -0.03319427f, 0.04653228f, -0.00720628f, 0.03907342f, 0.02244866f, -0.02862771f, 0.02184427f, 
    -0.00226812f, 0.00070751f, 0.04274052f, -0.04695165f, -0.04008915f, 0.03103726f, -0.00841835f, 0.03167003f, 
    -0.04873794f, -0.01650265f, -0.05165671f, 0.02707404f, 0.04447306f, 0.01456135f, 0.04687799f, 0.01013808f, 
    0.02050759f, 0.04540284f, -0.06183189f, 0.03944085f, -0.01957171f, -0.05033133f, -0.01091976f, -0.03493693f, 
    -0.01035314f, 0.00896251f, -0.01624715f, 0.03686327f, 0.04036048f, 0.00224381f, -0.04895117f, -0.03979631f, 
    -0.05499994f, 0.04048632f, -0.01423236f, -0.02767695f, 0.03382314f, 0.03773454f, -0.05964711f, 0.02044449f, 
    -0.04256681f, -0.01522669f, -0.03516592f, -0.01392914f, -0.01382150f, 0.03376477f, -0.04527820f, -0.04948808f, 
    0.00053689f, -0.04699977f, -0.01733691f, 0.03289013f, -0.03907825f, -0.02133734f, 0.01973888f, -0.05828907f, 
    -0.01930071f, 0.01031123f, -0.00401503f, -0.00482817f, -0.01621328f, 0.02470654f, -0.01499482f, -0.01786487f, 
    0.02333389f, 0.00713664f, -0.01914118f, -0.05863160f, 0.02846457f, -0.04349995f, 0.00758282f, -0.02288609f, 
    -0.00288006f, 0.03028698f, -0.01536314f, -0.04135960f, 0.01592389f, -0.04901974f, 0.04430763f, 0.02023206f, 
    -0.02332958f, 0.02712224f, -0.04818766f, 0.02290569f, 0.00003142f, -0.01095832f, 0.03814611f, 0.04081781f, 
    -0.02051799f, 0.03321016f, -0.03508757f, 0.00035854f, -0.05094820f, 0.03657265f, 0.04414990f, -0.05228894f, 
    0.04512657f, 0.02242049f, -0.04244665f, -0.02598378f, 0.03505387f, -0.01981491f, -0.02694014f, 0.00628482f, 
    -0.04955365f, -0.01631230f, -0.00194090f, 0.04646840f, 0.00146110f, -0.05448576f, 0.03291620f, 0.03551465f, 
    -0.01953222f, 0.04797849f, -0.02400840f, 0.04187823f, 0.02510585f, -0.02440184f, -0.04349254f, 0.03754263f, 
    -0.03389379f, 0.01143689f, 0.01958835f, -0.04134608f, 0.01286111f, -0.03307190f, -0.00339461f, 0.02903267f, 
    0.03217814f, 0.12632598f, -0.26907095f, 0.14547633f, 0.14166991f, 0.01131798f, -0.09776606f, 0.05071813f, 
    0.10209041f, -0.03278992f, -0.02107883f, 0.02439434f, -0.08562727f, -0.09842183f, 0.05513624f, -0.10055277f, 
    0.01112479f, -0.07033657f, -0.02262447f, 0.05454771f, 0.07278775f, -0.08226113f, 0.04042722f, 0.02830368f, 
    -0.13688213f, 0.17736466f, -0.06446339f, -0.02243593f, 0.06442867f, -0.07736909f, -0.05307656f, -0.02580529f, 
    -0.09403971f, 0.09079034f, -0.13075025f, 0.00706658f, 0.00816583f, -0.06251237f, -0.12442422f, 0.04752970f, 
    0.15323460f, -0.07833631f, 0.02235874f, 0.16625051f, -0.01226459f, -0.00441332f, 0.06695890f, 0.04663836f, 
    -0.09935714f, -0.07256209f, 0.12798852f, -0.15489739f, 0.05668183f, 0.09154254f, -0.01320121f, -0.19448020f, 
    -0.07460480f, -0.01814791f, -0.04485935f, 0.12156379f, -0.12460216f, -0.06515377f, -0.21775621f, -0.02813020f, 
    -0.00730134f, 0.05272859f, 0.10326397f, 0.02239243f, -0.05836352f, 0.11175562f, -0.05074138f, 0.00379317f, 
    0.01354123f, -0.17543529f, 0.11420585f, -0.11876564f, 0.04480186f, -0.09610886f, -0.02928811f, -0.04062724f, 
    0.03619026f, 0.06855740f, -0.04308229f, 0.02854143f, 0.21444038f, -0.01951703f, 0.15314139f, 0.26917148f, 
    0.03172591f, 0.04492854f, 0.03699163f, 0.23062001f, -0.11454714f, 0.01666231f, 0.02418698f, -0.09015525f, 
    0.14675876f, 0.25751787f, -0.06405689f, -0.12475644f, 0.17506245f, -0.03962056f, -0.09235737f, -0.03355968f, 
    0.06834616f, 0.02785999f, 0.02889287f, -0.03841197f, 0.13453496f, -0.02782050f, 0.09773660f, 0.14325602f, 
    0.06770035f, -0.11838035f, -0.04938344f, -0.07863133f, 0.03642822f, 0.02177407f, -0.02118613f, -0.09418711f, 
    -0.11518539f, -0.11888020f, -0.09437878f, -0.03893320f, -0.08225582f, 0.08325966f, 0.02943759f, 0.03378363f, 
    0.11502498f, 0.06480943f, -0.05901698f, -0.21823545f, 0.10582627f, 0.04975888f, -0.08222525f, 0.22036265f, 
    0.01876831f, 0.06867544f, -0.08392937f, -0.00449917f, 0.01016508f, 0.10588548f, 0.07466579f, 0.02622349f, 
    0.26665285f, 0.16864243f, -0.08029047f, 0.10340220f, 0.11788900f, -0.03997391f, 0.02407356f, -0.12437448f, 
    -0.09011833f, 0.03765881f, -0.02017046f, -0.03715987f, -0.04419438f, -0.09809951f, -0.01845787f, -0.12219997f, 
    0.05962142f, 0.15217678f, 0.02718090f, 0.04542373f, 0.00565071f, 0.00517318f, 0.14387858f, 0.02013869f, 
    0.08780790f, -0.00855452f, -0.13755780f, -0.09618361f, 0.11306165f, -0.05626793f, -0.09511317f, -0.02988581f, 
    -0.07201757f, -0.00980511f, 0.08322763f, 0.01557102f, -0.18683544f, -0.14558853f, 0.03986179f, -0.10795344f, 
    -0.09355115f, 0.14649962f, -0.08611307f, -0.01319946f, 0.02779312f, 0.10950280f, 0.14118582f, -0.02344466f, 
    0.15746152f, 0.06353965f, 0.08016402f, -0.06499914f, 0.00429887f, 0.03625257f, 0.03967253f, 0.03057625f, 
    -0.04740925f, -0.02952882f, -0.07221919f, -0.01089392f, -0.12242469f, 0.04529087f, 0.11171086f, 0.13520212f, 
    -0.02216480f, 0.06237618f, -0.02481317f, -0.00661802f, 0.10797444f, -0.05486061f, -0.01140015f, 0.03774773f, 
    0.00586545f, 0.08005290f, 0.06667440f, 0.10991272f, 0.00905227f, -0.03181550f, -0.10704792f, 0.00286459f, 
    0.02371695f, 0.01895487f, -0.07532553f, 0.03892184f, -0.17813775f, -0.05468781f, 0.20834532f, 0.18455572f, 
    0.00568623f, 0.00559936f, 0.03693783f, 0.12240246f, -0.05708539f, 0.02282455f, 0.06789667f, 0.03443615f, 
    0.05094268f, -0.10373646f, -0.11573282f, -0.07929448f, -0.06524047f, -0.01541014f, -0.11933482f, 0.07402901f, 
    -0.07798654f, -0.19549076f, 0.09958282f, 0.08897901f, 0.03119993f, -0.06202461f, 0.07292812f, 0.01567799f, 
    0.04441106f, -0.05675484f, 0.08516900f, 0.06145094f, 0.14275299f, 0.15510322f, 0.10513569f, 0.03442975f, 
    0.17729066f, 0.05895002f, -0.03519139f, 0.07303886f, -0.04814735f, -0.03336026f, -0.05962591f, -0.01023516f, 
    -0.12076493f, -0.10287399f, 0.18679677f, 0.01769565f, -0.30809513f, -0.15229203f, 0.09817811f, 0.01774887f, 
    0.11529823f, -0.06039334f, -0.07792606f, -0.01821774f, 0.00700319f, 0.00068844f, -0.04972364f, 0.06405540f, 
    0.37507942f, 0.02912914f, 0.13635828f, -0.10711512f, 0.05753396f, -0.04204742f, -0.05964004f, -0.04815188f, 
    0.11228746f, 0.07278880f, -0.01665910f, -0.08958229f, 0.28508952f, 0.13635840f, -0.06011446f, 0.03986504f, 
    -0.00859094f, 0.11597282f, 0.06971294f, 0.13246965f, -0.04894204f, 0.03995235f, 0.07783411f, 0.00077655f, 
    0.31999645f, -0.04649201f, -0.03465621f, -0.00376437f, 0.00202604f, -0.07435217f, 0.00549406f, -0.05137488f, 
    -0.03344781f, 0.07267953f, 0.07477282f, -0.04524846f, 0.16531011f, 0.02082359f, 0.09266547f, 0.03950674f, 
    0.05139808f, -0.05397389f, 0.02896491f, -0.01074201f, -0.06082980f, -0.09039165f, -0.13055955f, 0.02780524f, 
    0.23496081f, -0.17990750f, 0.00405647f, -0.12152950f, 0.04455540f, 0.08444196f, 0.08956448f, 0.05985578f, 
    0.00834151f, 0.08266643f, -0.09990949f, -0.00953873f, -0.12713683f, 0.01329410f, -0.19319661f, -0.27095646f, 
    -0.09354949f, -0.03487290f, -0.00603691f, -0.04016664f, 0.10614484f, -0.07016208f, 0.06077055f, 0.03912643f, 
    0.05193612f, 0.00969512f, -0.02867463f, 0.14855199f, 0.05868635f, 0.00276546f, -0.08481886f, 0.11191466f, 
    0.02832110f, 0.07494571f, 0.01514008f, -0.00419211f, -0.21818630f, 0.07937950f, 0.02902715f, 0.18080935f, 
    0.02209255f, -0.10107038f, -0.04067678f, -0.01801841f, 0.10448319f, -0.02100930f, 0.04292973f, 0.07834209f, 
    -0.15403700f, -0.01073026f, 0.09238152f, -0.01809640f, 0.15317599f, 0.02031520f, 0.02929467f, -0.04846938f, 
    0.00807467f, -0.04643052f, 0.14762171f, 0.16486242f, 0.02846346f, -0.09630358f, -0.02353473f, -0.09956784f, 
    -0.03988561f, -0.07963859f, 0.10130920f, 0.06751949f, 0.05528406f, 0.05039860f, -0.13304998f, 0.05040021f, 
    0.25596389f, -0.06536374f, 0.10409953f, -0.03941075f, -0.07801696f, 0.01478429f, 0.09602332f, 0.02225268f, 
    0.07321579f, -0.23587410f, 0.07273129f, -0.06741978f, -0.05928466f, -0.19269553f, 0.10810472f, -0.26180175f, 
    -0.03067855f, -0.05181807f, 0.05237656f, -0.04447635f, 0.10091381f, 0.01719228f, -0.08117337f, -0.01443261f, 
    0.07817619f, -0.01328804f, 0.01349286f, -0.00216147f, 0.09371680f, -0.01058875f, 0.06072582f, -0.00140738f, 
    0.14760999f, 0.06752009f, 0.04243664f, 0.09298057f, -0.04450225f, 0.05672731f, 0.06436586f, 0.10223360f, 
    -0.06963000f, -0.03135459f, 0.04175122f, 0.01363690f, 0.15051179f, -0.04285055f, 0.09950463f, -0.02935409f, 
    -0.12568480f, 0.03826931f, -0.09034348f, 0.08696751f, -0.03891121f, 0.12453790f, 0.10746476f, -0.03976319f, 
    0.05903073f, -0.08717806f, 0.05168287f, -0.07005926f, 0.07051496f, -0.06950068f, 0.00190083f, 0.13226476f, 
    -0.10342093f, -0.11018004f, 0.00149171f, -0.10514164f, -0.07607757f, -0.07502954f, 0.02719314f, 0.06035254f, 
    -0.15943968f, 0.01304720f, 0.23144539f, 0.14548770f, 0.14573385f, 0.11030141f, -0.10014002f, -0.11437631f, 
    0.01212396f, 0.07943756f, 0.08758821f, 0.08795524f, -0.11739501f, 0.21152864f, -0.07045151f, 0.03032649f, 
    0.07634820f, 0.05517983f, -0.02805416f, 0.02219855f, 0.05560202f, 0.03632867f, 0.08145273f, 0.26976943f, 
    0.15554172f, 0.12870273f, -0.05350938f, -0.16869156f, 0.14344437f, 0.01540866f, -0.07330637f, -0.04967733f, 
    -0.18563861f, 0.01142014f, 0.04805093f, 0.24565494f, 0.06034737f, 0.06438534f, -0.01543033f, -0.24299991f, 
    -0.00422843f, -0.15932781f, -0.03429918f, -0.00742697f, 0.03724915f, 0.03555048f, -0.10431997f, -0.01114298f, 
    0.14970541f, -0.10048689f, 0.03476254f, -0.13028993f, 0.05889852f, 0.05683570f, 0.00399550f, 0.09309311f, 
    0.26020116f, 0.04561670f, 0.07719308f, 0.23193656f, -0.11994775f, -0.04765437f, -0.21934618f, 0.04405773f, 
    0.17701444f, -0.09404241f, 0.04939781f, -0.02562661f, 0.06303250f, -0.02865357f, -0.04822593f, -0.00081495f, 
    0.04800635f, -0.01096447f, 0.04860849f, -0.07316926f, -0.03781110f, 0.08224900f, -0.04452740f, 0.15064564f, 
    0.00362127f, -0.07121609f, -0.03842827f, -0.09820007f, -0.04625200f, 0.03634603f, 0.06332768f, 0.13320410f, 
    0.00356365f, -0.01851397f, 0.13388480f, -0.01641655f, 0.03188227f, 0.05854164f, -0.08691847f, 0.02029371f, 
    -0.06015037f, -0.11221745f, -0.08514532f, -0.01914434f, -0.06127508f, -0.02905207f, -0.03180173f, 0.10868359f, 
    0.00282850f, 0.00266523f, 0.12203221f, 0.01265444f, 0.07430054f, -0.12097017f, 0.01691396f, -0.12349539f, 
    0.00645803f, -0.02898665f, -0.02220910f, 0.10736213f, 0.05543464f, -0.04236298f, -0.07196987f, -0.02637231f, 
    -0.14491095f, 0.04678514f, 0.21557096f, -0.04562120f, 0.07356453f, 0.15403102f, -0.04761141f, 0.00443135f, 
    0.09931198f, 0.03162315f, 0.17780231f, 0.13631630f, 0.02844911f, -0.09293467f, -0.00717026f, 0.14647810f, 
    -0.00738664f, -0.07204586f, 0.02859095f, 0.00507423f, 0.00582609f, -0.05231434f, -0.20936522f, 0.04092715f, 
    -0.04443973f, -0.05118210f, 0.00371565f, -0.09990782f, 0.06765639f, 0.03277261f, 0.17384940f, -0.07700628f, 
    0.01718987f, 0.04889755f, -0.11053403f, 0.02978373f, -0.03382353f, -0.06993510f, 0.12629189f, 0.00399256f, 
    -0.02990714f, 0.05877466f, 0.01226150f, -0.07604624f, -0.02515374f, -0.09354311f, -0.03991939f, 0.02241925f, 
    0.01844270f, -0.04724532f, -0.07224882f, 0.13131954f, 0.04210314f, 0.02360430f, 0.06400689f, -0.01590652f, 
    0.12953524f, 0.13175066f, -0.00538519f, 0.05472681f, -0.16047046f, -0.00038158f, -0.09077154f, -0.08486257f, 
    -0.15727925f, -0.03163388f, -0.00428312f, -0.12001876f, -0.01848199f, -0.07074531f, 0.15719199f, 0.04580015f, 
    -0.20745352f, -0.02453149f, 0.15587847f, 0.13789019f, 0.13760003f, 0.02311871f, -0.00845530f, 0.01361908f, 
    0.10443501f, 0.04354513f, -0.00762122f, 0.08111101f, 0.08148864f, 0.14891686f, 0.03340912f, -0.04675734f, 
    0.08669712f, -0.02406212f, -0.13327017f, 0.04097578f, -0.01276922f, 0.10665853f, -0.08268875f, 0.10222852f, 
    -0.25186995f, 0.26555404f, -0.16852312f, 0.21233544f, -0.01655286f, 0.05242015f, 0.03517812f, -0.05536094f, 
    0.15132390f, 0.03822330f, 0.06531694f, 0.09791932f, -0.23517366f, -0.12216008f, -0.13198981f, 0.13740481f, 
    0.04401591f, 0.15218729f, 0.08073843f, 0.06459809f, 0.03664578f, -0.00684161f, 0.16989847f, -0.12089946f, 
    -0.40436387f, -0.16379897f, -0.19709474f, 0.08856105f, -0.00259332f, -0.06381185f, 0.02366329f, -0.20329070f, 
    -0.04084417f, -0.06532727f, 0.13835959f, -0.08446067f, -0.06391950f, -0.07996354f, -0.10665650f, 0.06852017f, 
    0.00842429f, 0.08982110f, -0.08625527f, 0.07326072f, 0.06012775f, 0.13370997f, 0.05282350f, -0.11995997f, 
    -0.16651519f, -0.02594273f, 0.17239751f, 0.04599994f, 0.16292965f, 0.05398756f, -0.03651028f, -0.02252041f, 
    0.02829320f, 0.06679245f, 0.00220364f, 0.05484120f, -0.01285259f, -0.06735975f, -0.10474479f, -0.15919678f, 
    -0.01524961f, -0.03396568f, -0.02538426f, 0.14366195f, 0.08111276f, 0.06788546f, 0.00241788f, 0.13143252f, 
    -0.04445086f, 0.14239722f, -0.13239375f, -0.29047230f, -0.01161601f, -0.13771933f, 0.03134195f, 0.08880541f, 
    -0.02169883f, 0.10094601f, -0.02438561f, 0.10154885f, -0.18369670f, 0.14147602f, 0.02642839f, 0.26704866f, 
    0.19260006f, 0.01310341f, 0.09052890f, -0.00506771f, 0.16896257f, 0.04311652f, 0.04341923f, 0.01300105f, 
    -0.26444754f, 0.17675875f, 0.04133107f, -0.03277959f, 0.00738066f, -0.05345617f, -0.00664800f, 0.07120404f, 
    0.00425500f, -0.05288028f, -0.02989709f, -0.14597511f, -0.13808788f, 0.11160459f, 0.21321455f, -0.11463817f, 
    -0.02883957f, -0.01085661f, 0.01719865f, -0.02120998f, -0.11550488f, -0.00322072f, 0.05229381f, 0.24695830f, 
    -0.17144316f, 0.27223784f, 0.34038571f, 0.07756853f, 0.06542523f, 0.06487729f, 0.13031913f, -0.00237092f, 
    -0.01503226f, 0.01139029f, 0.08893277f, 0.08709952f, 0.11042401f, -0.13357121f, 0.01480197f, 0.06120940f, 
    0.07329448f, 0.15140609f, 0.07136826f, 0.05412336f, 0.04358852f, -0.04592066f, -0.04904580f, -0.01365157f, 
    0.04228953f, 0.13189754f, -0.06360731f, 0.06387466f, 0.16737939f, 0.13434041f, -0.03775632f, 0.02848529f, 
    -0.03794894f, 0.11066516f, -0.08370722f, -0.00588595f, 0.29408011f, -0.07368500f, 0.02209463f, -0.03954464f, 
    0.23888867f, -0.03942468f, 0.01926095f, 0.12540357f, -0.09838370f, 0.03105532f, -0.03150050f, -0.08210893f, 
    -0.29297996f, 0.19121909f, -0.24424535f, -0.26277214f, 0.04364603f, 0.04968996f, -0.02767136f, 0.00918027f, 
    -0.05370538f, 0.05303338f, 0.00360357f, 0.05406339f, -0.03197097f, 0.03259177f, 0.06906521f, -0.30232334f, 
    -0.01580951f, -0.08943644f, -0.05133350f, -0.10615052f, -0.04060737f, -0.13130812f, 0.03505126f, 0.13559787f, 
    0.06497087f, -0.10970829f, -0.00239974f, 0.12179784f, 0.08438285f, 0.04760387f, -0.05272988f, 0.02833365f, 
    0.02897801f, -0.03446935f, 0.02409816f, -0.06208204f, 0.22973602f, 0.08387522f, -0.05372423f, -0.06470568f, 
    0.09655631f, 0.07143687f, -0.06706838f, 0.01239962f, 0.10738199f, -0.01945733f, -0.01902331f, 0.19975962f, 
    -0.31363666f, 0.22995615f, -0.05563480f, -0.31994331f, 0.05445098f, 0.01780490f, -0.00587116f, -0.03242014f, 
    0.01685169f, -0.03903012f, -0.05969002f, 0.02022554f, -0.22521868f, -0.33358490f, 0.11022346f, 0.03195184f, 
    -0.07057089f, -0.09784776f, 0.08246725f, -0.02122189f, 0.08215451f, -0.08158257f, 0.05379194f, -0.12296250f, 
    -0.48672217f, 0.05374537f, 0.17339903f, -0.12871873f, 0.02073140f, 0.09824106f, -0.05164981f, 0.05037270f, 
    0.05171185f, -0.01630944f, -0.01672359f, -0.03757131f, -0.17006983f, 0.05916059f, 0.10550041f, 0.05996589f, 
    -0.03029456f, -0.05292977f, 0.03474229f, 0.04890288f, -0.05093769f, -0.02345634f, 0.00351486f, 0.03314524f, 
    0.12952532f, 0.12841867f, 0.05862976f, -0.03050634f, 0.08625644f, 0.03286534f, -0.03895716f, -0.11652000f, 
    -0.01929246f, -0.04986038f, 0.02183619f, 0.07147285f, 0.15617070f, 0.03779286f, -0.01858933f, 0.08761256f, 
    0.13044800f, 0.02438975f, -0.07644238f, -0.01423213f, 0.05225437f, 0.07291659f, -0.01587483f, -0.05250670f, 
    -0.01067643f, 0.00750485f, 0.08167217f, -0.23003918f, 0.05517600f, -0.07468189f, -0.11795202f, 0.05069280f, 
    0.05781473f, -0.05444797f, -0.07172677f, 0.04850382f, 0.05151883f, -0.01110222f, 0.02308387f, 0.02699076f, 
    0.22040892f, 0.10303826f, 0.15690336f, -0.01292678f, 0.01071876f, 0.00904376f, -0.10939275f, -0.07516500f, 
    0.06952473f, 0.02959380f, 0.00265322f, 0.22406183f, 0.19079235f, 0.13645108f, 0.11957096f, 0.14401059f, 
    -0.01127408f, -0.04247392f, -0.05983724f, 0.07734928f, 0.05804421f, -0.01466139f, 0.03067956f, -0.20103523f, 
    0.03518197f, 0.08658994f, -0.02698107f, -0.14700913f, -0.05748462f, -0.12496968f, -0.00541897f, -0.00241961f, 
    0.16670269f, -0.28185135f, 0.12953791f, 0.13957112f, 0.13309701f, 0.14872479f, 0.04922972f, 0.13146041f, 
    -0.04005439f, 0.10230438f, 0.04382664f, 0.07060918f, 0.13596360f, 0.07572573f, 0.13071649f, 0.21460406f, 
    0.14528762f, 0.11950625f, 0.06553457f, 0.12775400f, 0.11475438f, -0.00923699f, -0.02714829f, 0.02054660f, 
    -0.14704826f, 0.10583585f, 0.28644848f, -0.08743098f, 0.13233849f, 0.02061682f, 0.02449634f, -0.08121672f, 
    0.04801111f, -0.00813018f, -0.01547172f, 0.09465046f, 0.19423513f, 0.00899103f, 0.10834765f, -0.13810988f, 
    0.03206113f, 0.20983224f, 0.00903789f, -0.07603653f, 0.09843707f, -0.07682022f, 0.12683535f, 0.10174280f, 
    0.53152514f, -0.49877325f, -0.03086055f, 0.06785829f, -0.08702095f, 0.00142583f, -0.05505051f, 0.05879727f, 
    0.05817966f, 0.05369307f, 0.06792298f, 0.00822286f, 0.05399964f, -0.39956683f, -0.07034758f, 0.07598531f, 
    -0.00332352f, 0.01870278f, 0.08479258f, 0.09045381f, 0.09639953f, 0.05343174f, 0.02922586f, -0.09392799f, 
    -0.27840084f, -0.11057895f, 0.16535181f, 0.01834660f, 0.08909604f, -0.08163359f, 0.05492458f, -0.03611635f, 
    0.05065899f, -0.00685764f, 0.11770624f, -0.02707671f, -0.40535590f, -0.09884050f, -0.00841599f, 0.04904782f, 
    -0.05739238f, -0.02243730f, 0.10654891f, -0.06900495f, -0.05877541f, -0.01624752f, 0.10101137f, -0.05267270f, 
    -0.14288889f, 0.11794767f, 0.10196315f, -0.16129215f, 0.08122973f, -0.01464136f, -0.07556622f, -0.13415951f, 
    -0.05986718f, 0.06599318f, -0.07283384f, -0.01605804f, -0.13764746f, -0.06758704f, -0.02888267f, -0.13088880f, 
    0.08725139f, -0.03127602f, 0.02379689f, 0.04323252f, 0.01094697f, 0.05852753f, 0.00531965f, 0.04616009f, 
    -0.11887504f, 0.04262787f, -0.18853927f, 0.00713272f, 0.01272882f, -0.02658957f, -0.11713138f, 0.11300379f, 
    -0.05241251f, -0.07916480f, -0.03329843f, -0.04353574f, -0.14625292f, -0.02351987f, -0.08339798f, 0.02231191f, 
    -0.02606161f, -0.03166837f, 0.03156396f, 0.01767018f, -0.00076435f, -0.11090110f, 0.00733327f, 0.06604545f, 
    -0.26954886f, 0.14689587f, -0.09631531f, -0.01590328f, 0.05586130f, -0.10953354f, -0.08469769f, -0.09953664f, 
    -0.02029735f, 0.08224446f, -0.11448689f, 0.11215010f, 0.05609644f, 0.06340652f, -0.24446493f, -0.08647154f, 
    0.17394501f, -0.00649847f, -0.00422424f, 0.19340666f, -0.04588816f, -0.06952143f, 0.08813165f, 0.04562989f, 
    0.04512829f, -0.18654220f, 0.01256905f, -0.02559911f, 0.10413226f, 0.04207548f, -0.04637074f, -0.06283242f, 
    0.00766906f, -0.06690487f, -0.10802124f, -0.00207964f, 0.06579774f, -0.05494967f, -0.28744885f, 0.17576192f, 
    -0.00001699f, 0.10992515f, 0.02942946f, -0.03215493f, -0.00197693f, 0.11044041f, -0.01410687f, -0.04813434f, 
    -0.14591645f, 0.08877626f, 0.04344204f, -0.10851581f, 0.08238965f, -0.12763448f, -0.06136617f, 0.06982844f, 
    0.09983833f, 0.04938149f, -0.08301321f, -0.06498156f, -0.15736786f, 0.04293622f, 0.15871184f, 0.29063776f, 
    -0.01034033f, 0.08685987f, 0.00962683f, 0.18464756f, -0.03671937f, 0.12335986f, 0.07388411f, -0.11853132f, 
    0.02573276f, 0.19390370f, -0.10433833f, -0.15689227f, 0.13902222f, 0.00113499f, -0.12642565f, -0.01906151f, 
    -0.05714396f, -0.06096141f, 0.05213064f, -0.13917318f, -0.04474172f, -0.19210763f, 0.09506643f, 0.01334820f, 
    -0.05377883f, -0.02733172f, 0.01616153f, -0.05110043f, -0.01091886f, 0.01460855f, -0.08467376f, -0.20234524f, 
    0.21129626f, 0.11820631f, -0.00281683f, 0.19513643f, -0.03131769f, 0.13056067f, 0.06640099f, 0.05690360f, 
    0.04255057f, 0.00236199f, -0.00051984f, -0.13588075f, 0.13685295f, -0.12273779f, 0.12088879f, 0.04179808f, 
    0.08950558f, 0.07899736f, 0.05572043f, 0.11471539f, -0.03097254f, 0.10056303f, 0.06883930f, 0.05976384f, 
    0.12174893f, 0.25243795f, -0.20895419f, -0.04394851f, 0.01546248f, 0.02828155f, -0.00725018f, -0.10387524f, 
    -0.17569768f, -0.02691204f, 0.01297614f, -0.06425086f, -0.06158365f, 0.16003597f, -0.02614384f, 0.00209189f, 
    -0.04852926f, 0.11871608f, -0.06475466f, -0.01433403f, 0.02426342f, 0.02476665f, 0.09438013f, -0.01103327f, 
    -0.07026000f, 0.00093039f, 0.01714895f, -0.05417528f, 0.12423141f, -0.07250001f, 0.01046427f, -0.09195753f, 
    -0.06493034f, -0.06903327f, 0.03452628f, 0.13797298f, -0.16031834f, -0.15359804f, -0.09995975f, 0.13802958f, 
    -0.05199121f, 0.08498777f, -0.10344561f, 0.01833785f, -0.01618352f, 0.08448579f, 0.15931089f, 0.08888008f, 
    -0.02587795f, -0.02596539f, 0.00009232f, -0.12435580f, 0.09953495f, 0.05163155f, -0.01718682f, 0.00159443f, 
    0.00293772f, -0.02395746f, -0.09133822f, 0.03420024f, -0.12911469f, -0.06026927f, 0.19303997f, 0.14279883f, 
    -0.08512070f, 0.06630617f, -0.02955616f, -0.09634934f, 0.07536357f, 0.06273526f, 0.11901155f, 0.08080243f, 
    -0.09029854f, 0.10112053f, 0.09936475f, -0.18301401f, -0.04193777f, -0.02128444f, -0.03912937f, 0.00296147f, 
    0.10618957f, -0.06243157f, -0.02470554f, -0.02626154f, -0.24998716f, 0.08782680f, 0.20929237f, 0.33790255f, 
    0.02456046f, -0.11153088f, -0.00093640f, 0.16623695f, -0.07932515f, 0.00929826f, 0.12982923f, 0.01716470f, 
    0.19368806f, 0.12946655f, 0.00366796f, -0.03214197f, -0.05934991f, -0.09322194f, -0.13674735f, 0.09259509f, 
    -0.02443075f, -0.18430708f, 0.19083339f, 0.08478277f, -0.03776603f, 0.00923031f, 0.13924517f, -0.07093695f, 
    -0.02377621f, 0.03695827f, -0.00337390f, -0.00670996f, 0.09983477f, 0.09021899f, 0.13675168f, -0.00338879f, 
    0.22513357f, -0.02611669f, -0.05241641f, 0.14811249f, -0.04110573f, -0.02541995f, -0.03337523f, -0.04887225f, 
    -0.17024465f, -0.14383191f, 0.06705958f, -0.08171694f, -0.05267802f, 0.07055597f, 0.08094940f, 0.25079158f, 
    0.11938311f, -0.10127003f, -0.08140303f, 0.02433482f, 0.03469234f, 0.06211806f, -0.00170443f, 0.05493765f, 
    0.20180444f, 0.01749453f, 0.09300085f, -0.02601733f, -0.03689285f, -0.12297310f, -0.05967013f, -0.00614047f, 
    0.03948951f, -0.05149170f, 0.00099808f, -0.06756975f, 0.14182225f, 0.12327343f, -0.10560010f, -0.10062063f, 
    0.07481499f, 0.04622183f, 0.10588062f, 0.17998157f, -0.04576323f, 0.09774308f, 0.05694225f, 0.02672979f, 
    0.21774366f, -0.15014064f, 0.06911846f, 0.04689014f, 0.01205894f, -0.02529795f, 0.02233151f, 0.04608591f, 
    -0.01781836f, -0.05990234f, -0.02237350f, -0.08669175f, 0.17344080f, 0.16120718f, 0.18785478f, 0.15320753f, 
    0.11604295f, -0.05876705f, 0.02404702f, -0.01798295f, -0.00226768f, -0.01580104f, -0.09507833f, 0.03917294f, 
    -0.02256714f, -0.16710570f, 0.10985399f, 0.02460717f, 0.11691540f, -0.01713043f, 0.10337241f, 0.15576747f, 
    -0.03328267f, 0.08713633f, -0.13362966f, 0.07807773f, 0.11300728f, 0.07375124f, -0.16168410f, -0.20838603f, 
    -0.03505892f, -0.09196602f, -0.04344748f, -0.06798543f, 0.02343882f, -0.13919368f, -0.07106147f, 0.03391297f, 
    0.00660915f, 0.19168359f, -0.10448923f, -0.01146682f, -0.08279432f, -0.04069941f, 0.00553531f, 0.10162346f, 
    0.02739355f, 0.06365491f, -0.00573648f, 0.04183942f, -0.32109711f, 0.13873771f, 0.02832283f, 0.05435969f, 
    -0.05492698f, -0.03148776f, 0.02978918f, 0.02813343f, 0.10101459f, -0.01368383f, 0.06259374f, -0.02244906f, 
    0.02188695f, -0.05826994f, -0.03578994f, 0.02889989f, -0.04751508f, 0.00043557f, 0.02735326f, -0.03981749f, 
    -0.05415127f, 0.02318158f, 0.00127410f, -0.04763875f, 0.02945465f, 0.01653186f, 0.01647742f, -0.03284223f, 
    -0.02251899f, -0.01822066f, -0.00569880f, -0.05302101f, -0.03933337f, -0.02732159f, 0.04360396f, -0.01025152f, 
    0.03807899f, -0.00045492f, -0.05443883f, -0.04219375f, 0.00715876f, -0.02095887f, -0.03770488f, 0.03968536f, 
    0.03472426f, 0.03402512f, -0.02759978f, -0.00571140f, -0.03184481f, -0.00322860f, -0.03541318f, -0.03977814f, 
    0.01866094f, 0.00074583f, -0.00619452f, 0.00619082f, 0.01750204f, -0.05169529f, -0.05010267f, 0.01910797f, 
    -0.00098041f, 0.02680136f, -0.04040724f, -0.04343885f, 0.03161251f, 0.02953247f, -0.03287441f, 0.01170206f, 
    0.03537628f, -0.03173137f, 0.00502432f, 0.01197706f, -0.01454498f, -0.01975209f, -0.05008854f, -0.00330719f, 
    -0.04552285f, -0.02567132f, 0.02862637f, -0.04591003f, 0.02906611f, -0.05375099f, -0.01442217f, 0.01079648f, 
    -0.03412519f, 0.01224281f, -0.03331433f, 0.01255136f, 0.02827290f, 0.02925280f, 0.01534891f, -0.03327090f, 
    0.00496954f, 0.03332647f, -0.04715904f, -0.01954236f, -0.01340132f, -0.03491940f, -0.04560701f, 0.04106640f, 
    -0.01433102f, 0.03635139f, -0.02486125f, -0.04481042f, 0.00027219f, -0.02570215f, 0.04389824f, 0.02828354f, 
    -0.00664050f, -0.03395376f, 0.03225992f, 0.02319691f, 0.00485969f, 0.03622277f, 0.01386667f, -0.02958543f, 
    -0.03456516f, -0.04663246f, -0.00926952f, -0.02105631f, -0.01872745f, 0.03950380f, 0.01469749f, -0.03818117f, 
    -0.00196034f, -0.02148081f, -0.02901999f, 0.04256032f, -0.02577011f, 0.02802328f, 0.04379762f, 0.02585416f, 
    -0.05537835f, -0.05085647f, 0.04527654f, 0.02101853f, 0.03122601f, -0.05075366f, 0.01681492f, -0.00991475f, 
    -0.02808762f, -0.00284953f, 0.02729936f, -0.01354514f, 0.04564132f, 0.03915610f, -0.01343449f, 0.04177542f, 
    0.02643272f, -0.01519742f, -0.01091252f, -0.02303454f, 0.04075783f, 0.03252253f, -0.02457141f, -0.01384672f, 
    -0.03937089f, -0.01443999f, -0.02830951f, -0.02156963f, -0.04262128f, 0.02565115f, -0.04202078f, 0.03280824f, 
    0.01295780f, -0.00291599f, -0.00091934f, -0.02310416f, -0.03507321f, -0.03375563f, -0.04354021f, 0.01778483f, 
    0.03914945f, 0.01315686f, 0.01877884f, -0.00661540f, 0.02677008f, -0.02869436f, 0.03265753f, 0.02703479f, 
    0.00844759f, 0.04449388f, -0.04701944f, 0.02175231f, -0.00376652f, -0.05694735f, 0.00273959f, -0.00275912f, 
    0.01966364f, -0.00981927f, -0.02117625f, 0.02195534f, -0.03362838f, 0.03945538f, 0.03288860f, 0.03488551f, 
    -0.00985298f, 0.05075716f, 0.02187117f, -0.02844395f, -0.01084157f, 0.01499162f, -0.02447148f, -0.01934113f, 
    -0.02530508f, 0.00592666f, 0.04178252f, -0.01787748f, 0.02297878f, 0.02041535f, -0.04667176f, -0.00615850f, 
    -0.03113347f, -0.05554719f, -0.00857139f, 0.00798726f, 0.00520823f, -0.00731836f, -0.04216102f, -0.04474688f, 
    0.02645529f, -0.05235992f, 0.02335624f, 0.04165637f, -0.00296601f, -0.05238391f, -0.04068983f, 0.02681833f, 
    0.03182998f, -0.03990592f, 0.01991485f, -0.04458572f, 0.00333001f, 0.03094146f, -0.03985028f, -0.01470991f, 
    -0.01821025f, -0.03079351f, -0.03441534f, 0.02902530f, -0.04419133f, 0.03246789f, 0.03100830f, -0.00335426f, 
    -0.04873898f, 0.04777139f, 0.02388344f, -0.00120585f, -0.02647536f, 0.02015630f, -0.02227510f, -0.03040955f, 
    0.04991056f, -0.03744590f, -0.03190580f, -0.00942094f, 0.03157688f, 0.04020804f, 0.00368977f, 0.01765776f, 
    0.02621541f, -0.04390956f, -0.02752314f, -0.05812179f, -0.04373170f, 0.00840960f, -0.04892513f, -0.00405620f, 
    -0.00504421f, -0.02546705f, 0.02524257f, -0.04281762f, 0.02046154f, 0.01107034f, -0.01971813f, 0.03181830f, 
    -0.00834000f, 0.02348373f, -0.03226300f, -0.03844646f, 0.00601046f, 0.01077495f, -0.03157479f, -0.04297826f, 
    0.03483528f, 0.04413758f, -0.04552305f, -0.00367660f, -0.03944286f, -0.03698770f, -0.03395005f, 0.00185690f, 
    0.04266832f, 0.02197371f, 0.03248869f, -0.01789504f, -0.00595301f, 0.02819786f, -0.01904729f, -0.04504880f, 
    0.03536797f, -0.05493168f, -0.02560430f, -0.00722492f, 0.03386260f, 0.03310476f, -0.03597587f, -0.03249535f, 
    -0.00166913f, -0.02288444f, -0.00419902f, -0.03244288f, 0.01069727f, -0.01986306f, -0.02930226f, 0.00734081f, 
    0.02329716f, -0.03730398f, 0.01236998f, -0.00558766f, 0.01086257f, -0.04597577f, 0.01074493f, 0.04060034f, 
    -0.03333993f, 0.04144460f, 0.03236774f, -0.04828738f, 0.02358150f, -0.02813573f, 0.00501548f, -0.03807033f, 
    -0.05393008f, 0.03669949f, 0.04421787f, 0.01848802f, -0.03318128f, 0.02087445f, -0.02389472f, 0.04657245f, 
    -0.02701201f, 0.03103435f, -0.04640172f, 0.00465921f, 0.00295276f, 0.04315563f, -0.04147625f, 0.04730434f, 
    0.01195588f, -0.01960461f, 0.01778673f, 0.04865908f, -0.03468424f, 0.02307172f, 0.02725117f, 0.04491243f, 
    -0.03789759f, -0.00147591f, -0.00854184f, -0.02836730f, 0.03697972f, -0.03149539f, -0.04549555f, -0.02099911f, 
    -0.02233848f, -0.00404119f, -0.03205739f, -0.01013858f, 0.00855225f, -0.04348275f, 0.01613230f, 0.02191707f, 
    -0.01058340f, -0.04914334f, 0.02795923f, 0.01020502f, -0.01451393f, 0.01300978f, 0.01515661f, -0.01246409f, 
    0.02487727f, 0.03560196f, -0.05086596f, -0.03233012f, -0.03960915f, -0.02593528f, 0.03860149f, 0.03328391f, 
    -0.04876509f, -0.02266661f, 0.02285179f, -0.05518169f, -0.03325634f, -0.02412870f, -0.00745298f, -0.00954104f, 
    0.00037832f, -0.02215108f, 0.02264337f, 0.03973802f, 0.01430825f, 0.01803066f, -0.02105526f, -0.04914932f, 
    -0.04313254f, -0.05163035f, -0.02673554f, -0.00104214f, 0.01200969f, -0.02078997f, -0.02585415f, 0.02057193f, 
    -0.00718864f, 0.01122411f, 0.00248574f, 0.03069905f, -0.03649186f, -0.00333640f, 0.02601699f, 0.04201161f, 
    -0.02297443f, 0.01212085f, -0.00190887f, -0.00278756f, 0.02919249f, -0.05041799f, -0.00563674f, -0.01842430f, 
    -0.05390061f, -0.04234182f, -0.00646577f, 0.01879423f, 0.02753939f, -0.03000867f, -0.05148537f, 0.04205722f, 
    -0.00679125f, -0.04543831f, -0.03816169f, -0.05354822f, -0.02155339f, 0.03189065f, -0.05108872f, -0.04712556f, 
    -0.04764310f, -0.01300802f, -0.00051276f, -0.03919307f, 0.00500091f, 0.00980790f, -0.01317736f, -0.03079687f, 
    -0.03907573f, -0.04004274f, -0.05579272f, 0.03699414f, -0.01010969f, -0.04746011f, 0.01284844f, 0.00777167f, 
    0.01367016f, 0.03647593f, -0.01330101f, 0.03959600f, -0.03358117f, 0.02765584f, -0.00231778f, -0.03003430f, 
    -0.04596644f, -0.02370591f, -0.00163546f, -0.04394247f, -0.03754380f, -0.02858488f, 0.02905235f, -0.02424630f, 
    -0.01973604f, 0.02698927f, 0.03111346f, 0.00295667f, -0.03950461f, -0.05057758f, -0.01093195f, -0.01693388f, 
    -0.03567087f, 0.01232078f, -0.01118357f, 0.02846209f, -0.03819159f, -0.03216143f, -0.02413019f, 0.04364408f, 
    0.02893333f, 0.00723582f, -0.01015716f, 0.03852335f, -0.05289239f, -0.03023873f, -0.05559685f, -0.05517460f, 
    -0.05644229f, 0.03285957f, 0.03058353f, 0.00496169f, 0.02864592f, -0.00784787f, 0.02353637f, -0.05526079f, 
    0.02558410f, -0.04128437f, -0.01519905f, -0.03191647f, 0.00493270f, 0.04038218f, 0.00121878f, -0.05461242f, 
    -0.04632574f, -0.05488929f, -0.02411170f, -0.02725130f, 0.02387181f, 0.02282190f, -0.00112606f, -0.00961763f, 
    -0.03332077f, -0.02226843f, -0.01553662f, -0.01325515f, -0.01491338f, 0.02479854f, -0.03445205f, -0.02612395f, 
    -0.02078340f, 0.00222835f, -0.03790822f, -0.05472663f, 0.03103274f, 0.02072956f, -0.00116715f, -0.03191870f, 
    -0.02044325f, -0.00280620f, -0.02955988f, -0.03354715f, -0.01026144f, 0.01009387f, 0.00446303f, -0.00692884f, 
    0.01758959f, -0.00246979f, 0.01638279f, -0.03133057f, 0.03507120f, -0.04230963f, -0.03649231f, -0.00615366f, 
    0.04386937f, 0.00433099f, -0.04857488f, -0.01179878f, 0.00531316f, -0.01564027f, -0.02257589f, -0.02792709f, 
    0.00446384f, -0.01202444f, 0.03243705f, 0.01453602f, 0.02171855f, -0.00229516f, -0.02421382f, -0.04585803f, 
    0.00715319f, 0.03011358f, -0.04627281f, -0.00198339f, -0.04889107f, -0.01837688f, 0.01427182f, -0.01484723f, 
    -0.03902173f, 0.02111682f, 0.00318652f, 0.03817380f, -0.05002178f, 0.03958727f, -0.01978443f, -0.04779021f, 
    0.01925305f, 0.01328199f, 0.03446909f, 0.03191743f, 0.01104684f, 0.03963696f, 0.03771063f, -0.02585895f, 
    0.03925560f, -0.00118350f, 0.00923937f, -0.02797219f, 0.00684806f, 0.00279971f, -0.00276451f, -0.01814231f, 
    0.00779200f, 0.03177189f, -0.01236434f, -0.03500217f, -0.01969866f, 0.02229154f, -0.02815137f, -0.01381942f, 
    -0.02874888f, -0.04345078f, -0.01926392f, 0.04345920f, -0.00879557f, 0.03714392f, 0.01545643f, -0.00905213f, 
    0.01891951f, -0.00507118f, -0.04748420f, -0.04345935f, -0.02528307f, -0.04383367f, -0.02903116f, -0.05465681f, 
    -0.05606567f, 0.02551289f, 0.01605788f, -0.01193274f, -0.04521566f, -0.02841935f, 0.00386275f, 0.00836820f, 
    0.03683692f, -0.05064739f, -0.01583475f, -0.01888066f, -0.02986288f, -0.00004437f, -0.03606411f, 0.03431802f, 
    -0.03803236f, 0.04101085f, -0.00098552f, 0.02435465f, -0.01126158f, -0.04689136f, -0.01970075f, -0.04172083f, 
    -0.04385508f, -0.01522755f, -0.04115689f, -0.00053917f, -0.04553639f, -0.02892621f, -0.00820733f, 0.03135087f, 
    0.03130445f, 0.02072171f, 0.00543358f, 0.02565331f, -0.05513094f, 0.03346313f, -0.02094653f, 0.01891368f, 
    0.02755681f, 0.00004278f, -0.01053899f, 0.01189604f, -0.05103067f, 0.03992817f, 0.01920911f, 0.03190331f, 
    -0.01424216f, -0.00143751f, 0.01918911f, -0.04965904f, -0.03254080f, 0.00246754f, -0.00558011f, -0.00563091f, 
    -0.04746468f, 0.02337254f, 0.02276575f, 0.03517820f, 0.03650932f, 0.02192426f, -0.03442647f, 0.03605260f, 
    -0.00220788f, -0.01737351f, -0.05135253f, 0.03801323f, -0.02548775f, -0.04348615f, -0.03842540f, 0.04014638f, 
    -0.04981172f, -0.04317183f, -0.02839241f, -0.01731456f, -0.05035906f, 0.02546965f, 0.01534265f, 0.00367733f, 
    0.00612935f, 0.03426697f, -0.00846043f, 0.00219918f, 0.03002374f, -0.00278760f, -0.00486330f, -0.05267702f, 
    -0.01296754f, 0.02014477f, 0.00807049f, -0.05324828f, -0.03621268f, 0.01944931f, -0.04668502f, 0.04004249f, 
    0.04589909f, 0.01526870f, -0.00534172f, 0.00091900f, -0.05509454f, -0.01555509f, 0.01594022f, 0.00052819f, 
    -0.05132759f, -0.05454544f, -0.02241772f, 0.01902390f, 0.01658471f, -0.04639255f, 0.00834723f, -0.03782105f, 
    0.01602453f, -0.04719747f, 0.04283489f, 0.03009358f, 0.01918704f, -0.00564199f, 0.01700263f, -0.02282813f, 
    0.00160996f, -0.02638811f, 0.01168074f, 0.02353563f, -0.02640634f, -0.05156592f, 0.00040604f, -0.04284276f, 
    0.02258970f, -0.03135191f, 0.01120342f, -0.02946221f, -0.01822067f, 0.01007618f, -0.03021752f, 0.03532944f, 
    0.04399772f, -0.01740646f, -0.03388516f, -0.02873251f, 0.02754260f, -0.05586770f, 0.04376777f, -0.00755368f, 
    0.03882603f, 0.00977583f, -0.03761844f, 0.01074620f, -0.05688053f, -0.02413141f, 0.03306875f, -0.04119178f, 
    0.05153971f, -0.03986327f, 0.11888866f, -0.13901736f, -0.12013958f, -0.02460313f, -0.00540593f, 0.02106947f, 
    0.11784475f, 0.00077885f, 0.02780027f, 0.03152604f, 0.03331165f, 0.19887571f, -0.09346795f, 0.02877225f, 
    0.05366871f, -0.03284592f, -0.00428264f, 0.03856901f, 0.04817551f, 0.04357068f, -0.15150505f, 0.11194636f, 
    0.00393444f, 0.23549454f, -0.03101807f, 0.02710350f, 0.01992652f, 0.04431618f, 0.01118623f, 0.07267995f, 
    -0.14097089f, 0.04868090f, 0.06839281f, -0.13042219f, -0.07838374f, 0.07537755f, -0.17312384f, -0.00980449f, 
    0.10343049f, 0.01055436f, -0.06352579f, 0.14031769f, -0.02139083f, 0.09127566f, -0.10604172f, -0.03858152f, 
    0.06624069f, -0.11767353f, 0.07954176f, -0.08435721f, -0.10770568f, 0.07567421f, -0.02064931f, 0.04248555f, 
    -0.06899069f, 0.05856913f, 0.12349594f, 0.12952062f, 0.17905517f, -0.09837250f, 0.24095654f, -0.12335200f, 
    -0.04024996f, 0.09544386f, 0.15217336f, 0.00940069f, 0.01123348f, -0.04688425f, 0.00409408f, 0.04700517f, 
    0.02613268f, 0.12331050f, -0.21305421f, 0.14751451f, -0.03985326f, 0.00950374f, -0.06932844f, 0.06275477f, 
    0.03999864f, -0.02048420f, -0.04545021f, 0.14294717f, 0.15453641f, 0.02257154f, -0.01678520f, -0.04917416f, 
    0.13716261f, -0.04050785f, 0.03939446f, 0.16551182f, -0.00955892f, 0.04326057f, 0.06033687f, 0.08075556f, 
    -0.17609902f, 0.10821535f, 0.05641425f, 0.11333062f, -0.04208973f, 0.08384182f, 0.04792938f, 0.04137075f, 
    -0.06257163f, 0.08591358f, 0.04200551f, 0.00631884f, 0.10009811f, -0.17082086f, 0.10439683f, 0.20776083f, 
    -0.12289272f, -0.08776259f, 0.03375128f, -0.03860486f, -0.11741365f, 0.07570008f, -0.02373833f, 0.07872220f, 
    0.12703343f, 0.07413189f, 0.18789929f, 0.11054774f, -0.00622231f, -0.04423739f, -0.00371801f, 0.11327734f, 
    -0.03891416f, 0.02655842f, 0.02740475f, -0.04263517f, 0.03608995f, 0.07129497f, -0.17986532f, 0.20523241f, 
    -0.06433828f, 0.06785690f, -0.06245518f, 0.01645470f, 0.03513625f, 0.07180255f, 0.02619042f, 0.05084046f, 
    0.17097996f, -0.05962512f, 0.00350652f, 0.04987267f, -0.19632004f, 0.02771092f, -0.02939333f, 0.07981361f, 
    -0.03205111f, 0.06329646f, 0.02281959f, -0.04249676f, 0.04408401f, -0.09509151f, 0.24076520f, -0.10618757f, 
    -0.06675082f, -0.00852899f, 0.04989762f, -0.03497390f, -0.00967891f, 0.02929877f, 0.04152470f, -0.18676972f, 
    -0.06359373f, -0.08536397f, -0.07820143f, -0.01089798f, -0.03382071f, 0.02447452f, 0.01792782f, 0.12014873f, 
    0.07501083f, -0.10691948f, -0.18202072f, -0.01488201f, -0.14929074f, 0.05103995f, 0.15989080f, -0.30776721f, 
    0.00973754f, -0.05017350f, 0.15980338f, 0.06539208f, -0.11271050f, -0.08516976f, -0.06730375f, 0.03381093f, 
    -0.19392075f, 0.36000499f, 0.05900080f, 0.06906047f, 0.02461454f, 0.03208096f, -0.01471516f, 0.01645359f, 
    -0.03616339f, 0.03142853f, 0.02045801f, -0.06115755f, 0.07328903f, 0.05506120f, -0.01818047f, -0.04301870f, 
    -0.01481062f, 0.01748251f, 0.06786361f, 0.07530885f, 0.02241188f, -0.01024739f, -0.09930209f, -0.01935070f, 
    -0.16393000f, 0.02051324f, 0.09332657f, 0.16532272f, -0.12210238f, 0.06844009f, 0.03410725f, 0.00615449f, 
    0.09855072f, 0.04277592f, -0.01718948f, -0.10947123f, 0.18120208f, -0.07126716f, 0.03752182f, -0.05323172f, 
    0.09999541f, 0.01341616f, -0.03338093f, 0.03287995f, 0.07849394f, -0.00533000f, 0.04682003f, -0.07100362f, 
    0.01491501f, -0.01268645f, 0.05838722f, -0.02067570f, -0.00140452f, 0.02104575f, 0.16503386f, 0.02715776f, 
    0.12813680f, 0.01064687f, 0.06133090f, 0.08232459f, 0.13908704f, -0.12840949f, -0.00229045f, 0.06603183f, 
    -0.05752394f, -0.06516891f, 0.08404851f, -0.06543428f, 0.05384286f, -0.04956610f, -0.06364968f, -0.10331271f, 
    0.15490772f, -0.07861917f, 0.07861888f, -0.17606957f, -0.10167684f, 0.13046129f, -0.06721865f, 0.07499531f, 
    0.04175785f, 0.11908110f, -0.00142941f, 0.11258463f, 0.03330115f, -0.02550687f, 0.14146356f, 0.08870710f, 
    0.07699709f, -0.12788829f, -0.03344209f, -0.05060621f, -0.10035393f, -0.01622901f, 0.05516520f, 0.03695437f, 
    0.04116768f, -0.14247167f, 0.09961761f, -0.07680432f, 0.01995852f, -0.09635857f, 0.01250214f, 0.04056001f, 
    0.03808685f, 0.04525077f, -0.08182121f, 0.02539897f, -0.00282874f, 0.19792956f, -0.04606576f, -0.02796757f, 
    0.09087000f, 0.03750193f, -0.01474825f, -0.08341492f, 0.01119730f, 0.01126450f, 0.09867467f, -0.00062994f, 
    0.12473746f, 0.12737599f, -0.10136563f, -0.23633829f, -0.04226762f, 0.11581659f, -0.09399304f, -0.06960671f, 
    0.12450527f, 0.00022898f, 0.05837310f, -0.03712917f, 0.02392262f, 0.05664219f, 0.07930820f, -0.08109225f, 
    -0.01458766f, -0.16441146f, 0.07985324f, 0.05749417f, -0.09007727f, 0.00312716f, 0.08952364f, -0.10790431f, 
    -0.32171947f, 0.01470638f, 0.14300662f, -0.15916663f, 0.12772736f, -0.00826135f, 0.03612342f, -0.02581263f, 
    0.05988616f, -0.01740652f, 0.05811957f, 0.02137700f, -0.07009458f, 0.12274016f, -0.08013419f, -0.24709091f, 
    -0.07003990f, -0.03581649f, 0.09661196f, -0.02172063f, -0.00848907f, 0.08758368f, -0.03220400f, 0.02927617f, 
    0.09143300f, -0.09839991f, -0.10775388f, 0.19110714f, 0.00450955f, 0.01444838f, 0.04289328f, 0.05117197f, 
    0.05765390f, -0.04410115f, -0.04552059f, -0.01528717f, 0.05943109f, -0.21728994f, -0.07243375f, 0.12201320f, 
    -0.09280566f, 0.04098677f, -0.01294466f, 0.04609673f, -0.08042645f, -0.02036391f, 0.03543355f, 0.05496233f, 
    0.08434848f, 0.20191664f, -0.06033453f, -0.00331760f, 0.13677904f, 0.00934849f, -0.00694765f, -0.01713160f, 
    0.02366272f, -0.04417206f, -0.06102097f, -0.08856945f, 0.19846594f, -0.18016249f, -0.01248697f, 0.06757999f, 
    -0.04271106f, -0.05116332f, -0.10533057f, -0.11654240f, 0.02736123f, -0.02147676f, -0.00835068f, -0.06724749f, 
    0.00202165f, -0.05457522f, 0.14940596f, 0.01619102f, 0.05049584f, -0.06915094f, 0.00162369f, 0.02987775f, 
    0.08219370f, -0.00275204f, -0.10052992f, 0.11156742f, -0.21814561f, 0.00457246f, -0.01587774f, -0.04342723f, 
    0.04667991f, 0.01604208f, -0.02387835f, 0.09924701f, -0.08342875f, -0.13110299f, -0.03011851f, 0.03728562f, 
    0.08376517f, -0.04319448f, 0.14185260f, -0.01229522f, 0.10500728f, 0.02783050f, -0.01830840f, -0.03373354f, 
    -0.08251930f, -0.03783749f, 0.03852686f, -0.02688574f, -0.20361190f, 0.06018918f, -0.17432843f, 0.01269181f, 
    0.15705742f, 0.05158456f, -0.05918255f, -0.09193755f, -0.06271493f, -0.00104592f, -0.00461826f, 0.04639375f, 
    0.16580459f, -0.20718496f, 0.01675952f, -0.24232817f, 0.07425485f, -0.03465446f, -0.04701414f, 0.00641337f, 
    0.02571177f, 0.11242677f, 0.00746681f, -0.02102570f, -0.04322847f, -0.23718593f, 0.11196116f, 0.34441575f, 
    0.01006747f, -0.01556355f, 0.01982832f, 0.07328126f, -0.05326655f, 0.06477555f, -0.01644165f, -0.09117214f, 
    0.09130005f, 0.22304124f, -0.02761116f, -0.25587320f, 0.20529045f, 0.02723691f, 0.00853344f, 0.00900395f, 
    0.01801354f, 0.02420901f, 0.01205698f, -0.08322570f, 0.07362846f, 0.14308202f, 0.04037490f, -0.06739659f, 
    0.07622424f, 0.01249138f, 0.00617341f, 0.02071340f, 0.02991380f, -0.08953428f, -0.07211336f, -0.08577151f, 
    -0.10699414f, -0.06655548f, -0.08407027f, -0.01796369f, 0.05573631f, 0.14848782f, 0.05097989f, 0.04915734f, 
    0.09572888f, 0.03969038f, -0.12670875f, -0.10846749f, 0.19666910f, -0.05641019f, 0.06105551f, -0.07510020f, 
    0.12050218f, 0.05646604f, 0.03531051f, 0.08067609f, -0.02887324f, 0.02305876f, 0.04305369f, 0.10381757f, 
    0.03454495f, 0.11629290f, -0.07944656f, -0.12418512f, 0.30266088f, -0.07075417f, 0.04497842f, -0.04029983f, 
    -0.01844861f, 0.03739820f, -0.03208406f, -0.00832868f, -0.05984407f, -0.12180448f, 0.02139475f, -0.09292328f, 
    -0.09760024f, 0.03154489f, -0.12747566f, 0.00681816f, -0.08832494f, 0.06511652f, 0.12878132f, 0.14460278f, 
    -0.11322820f, -0.08513937f, 0.01037652f, -0.04277496f, 0.17869519f, -0.00391137f, -0.00198086f, -0.04869606f, 
    -0.04166351f, 0.05529402f, 0.06094230f, 0.07448871f, -0.08175486f, -0.19313113f, -0.18214488f, -0.11291659f, 
    0.01149004f, 0.17003739f, 0.01286972f, -0.02649227f, -0.02356474f, 0.10917775f, 0.12057809f, 0.06936449f, 
    0.40013397f, -0.23471384f, -0.00920517f, 0.02650703f, 0.00771487f, 0.04282361f, 0.03124157f, -0.04711624f, 
    0.05683348f, 0.01609448f, 0.02211444f, 0.13952868f, 0.06806193f, -0.08470074f, 0.07917111f, 0.25602683f, 
    0.00621763f, 0.01370434f, -0.09166529f, -0.10595823f, 0.13627490f, -0.02198111f, 0.02360011f, 0.09509436f, 
    0.08007132f, 0.18519916f, 0.10792289f, -0.17748453f, 0.11877184f, 0.15928771f, -0.02316458f, 0.04476820f, 
    0.04310335f, 0.06279220f, -0.14048667f, -0.06136136f, -0.05426566f, -0.19898769f, 0.08149251f, 0.07381181f, 
    0.05097183f, -0.01306088f, 0.04962383f, 0.07740079f, 0.01671109f, 0.10880306f, 0.11381676f, 0.04855354f, 
    0.08831534f, -0.02138506f, -0.17360480f, -0.04032961f, -0.06240756f, -0.02311783f, -0.10137700f, 0.07248549f, 
    -0.02299116f, 0.01934634f, 0.07656696f, 0.04980824f, -0.00294408f, 0.30390191f, 0.33249778f, -0.02903472f, 
    -0.05216230f, 0.02347388f, 0.08109447f, 0.08902653f, 0.10200401f, 0.14420834f, 0.15198925f, 0.04186370f, 
    0.11151439f, -0.10005584f, -0.10756762f, 0.25680178f, -0.04312610f, -0.11388952f, -0.10234687f, 0.03166033f, 
    -0.09387136f, -0.12377105f, 0.09186114f, -0.09061709f, -0.09092876f, -0.04481944f, 0.15748049f, 0.13101362f, 
    -0.07934923f, 0.00939691f, -0.11278520f, 0.03674055f, 0.07955119f, 0.08213382f, 0.02802474f, 0.02799918f, 
    0.19474398f, 0.11982802f, 0.21303207f, 0.09531357f, 0.04900099f, -0.02437945f, -0.01018712f, -0.07880639f, 
    0.01509848f, 0.01466584f, 0.06620734f, -0.12424868f, 0.35713652f, -0.11099752f, -0.11746652f, 0.05108088f, 
    -0.09333431f, 0.10115968f, 0.17527764f, 0.07598997f, -0.01125128f, 0.07679840f, 0.04304316f, 0.07824896f, 
    0.46303844f, -0.26050898f, -0.10347245f, 0.00574493f, 0.07948429f, 0.01703433f, 0.09710740f, -0.05606970f, 
    -0.12598158f, -0.03426693f, 0.03774280f, -0.04171566f, 0.14368020f, -0.14608967f, 0.08353201f, 0.05679961f, 
    -0.07332015f, 0.02490703f, -0.07638672f, 0.00400201f, 0.07703014f, 0.00718638f, -0.09160017f, 0.12070900f, 
    -0.08306630f, -0.17955679f, 0.08351351f, 0.08547431f, 0.00167779f, 0.12172431f, 0.08625416f, 0.07587334f, 
    0.04148309f, -0.04725450f, 0.02790960f, -0.06303181f, -0.09071148f, -0.19886357f, -0.09550513f, -0.12675491f, 
    -0.05496586f, 0.09452260f, -0.04898097f, -0.02092372f, -0.06187998f, -0.14169106f, -0.03454437f, 0.02682935f, 
    -0.06570554f, 0.30041963f, 0.14525418f, -0.02593846f, 0.08570284f, 0.10282450f, -0.01702329f, 0.06415940f, 
    0.04634811f, 0.07115448f, -0.02217489f, 0.00225720f, 0.22024009f, -0.08317051f, 0.04852333f, -0.07706380f, 
    0.03278818f, 0.03727764f, 0.02203844f, 0.00536816f, 0.11910282f, -0.00229817f, 0.02967687f, 0.07273576f, 
    0.00390852f, 0.03082645f, 0.01400546f, -0.23228018f, 0.03240723f, -0.09042019f, 0.02094417f, -0.05122722f, 
    0.03626870f, 0.06037664f, -0.00080656f, -0.07073619f, 0.44845840f, 0.02595776f, -0.00587289f, 0.20107560f, 
    0.02367258f, 0.04133588f, 0.04721742f, -0.11742517f, 0.00697044f, 0.04578118f, -0.07085094f, -0.06070325f, 
    0.23079120f, -0.06173047f, 0.04027474f, 0.12076438f, -0.02822574f, 0.06182212f, -0.09509517f, 0.06415753f, 
    0.04842601f, -0.06583042f, 0.00981983f, 0.03018654f, 0.03980406f, 0.16791092f, -0.04192991f, 0.16735411f, 
    -0.00752003f, -0.02436438f, -0.03667669f, 0.17081414f, -0.00069198f, 0.07143582f, -0.08717649f, -0.04792029f, 
    0.13181616f, 0.04543842f, 0.08608836f, 0.11341358f, 0.08339798f, 0.02610762f, -0.06784758f, 0.00500367f, 
    0.06281110f, 0.01724042f, 0.05848887f, 0.02755729f, 0.07082342f, 0.15808015f, 0.09708048f, -0.08779796f, 
    -0.00378928f, 0.10950980f, -0.11833452f, -0.02979292f, -0.03477128f, -0.06255716f, 0.03376207f, 0.00285861f, 
    0.45393008f, -0.13130078f, -0.03863198f, -0.07859998f, -0.00524939f, -0.00864409f, 0.06317684f, 0.02718316f, 
    0.12925784f, 0.05990021f, 0.12357663f, 0.16489296f, -0.09581819f, -0.10844287f, -0.05732380f, 0.05512196f, 
    -0.04691987f, -0.01715895f, 0.08560347f, 0.05101741f, 0.09648704f, 0.03978750f, -0.08018508f, 0.01974012f, 
    -0.18469344f, -0.03544306f, -0.09016099f, -0.14310919f, 0.08220346f, -0.01311302f, -0.01248842f, -0.08460419f, 
    -0.02681494f, -0.00960100f, -0.03137200f, 0.04519930f, -0.16341558f, 0.20554450f, -0.06398297f, -0.09655708f, 
    0.23023123f, -0.03429968f, 0.00379749f, 0.00735244f, 0.02468310f, 0.01933338f, -0.02648920f, 0.12859385f, 
    0.12527835f, 0.16616985f, 0.00030860f, -0.14183742f, 0.09219520f, 0.07948598f, 0.05936154f, 0.10957117f, 
    -0.03637695f, 0.02969232f, 0.00044963f, -0.03456232f, 0.15158315f, -0.16514251f, -0.10979620f, -0.09537833f, 
    0.13083808f, -0.06897505f, -0.18690388f, -0.06442330f, 0.02462792f, 0.05125488f, -0.01420887f, 0.13070054f, 
    -0.32283410f, -0.06781869f, -0.02943484f, -0.01165346f, 0.05422507f, -0.00453347f, 0.00969922f, 0.00056248f, 
    -0.01145342f, 0.01115370f, 0.10033621f, 0.05088351f, -0.19027144f, -0.09855642f, -0.01425979f, -0.10116643f, 
    -0.07036506f, -0.13952942f, -0.07969616f, 0.07125773f, -0.00816724f, 0.02654946f, 0.04173489f, 0.04591780f, 
    -0.12041670f, -0.01713954f, 0.00768491f, 0.25707155f, 0.06706522f, 0.04494225f, -0.08691516f, -0.01296991f, 
    0.14368483f, 0.15736417f, -0.06843185f, 0.13885848f, 0.06621020f, -0.02645621f, -0.17141244f, -0.19933112f, 
    0.11998536f, 0.03074820f, 0.02784639f, -0.02837754f, -0.01008700f, 0.12933564f, -0.00771932f, 0.00249028f, 
    0.31794423f, -0.23444673f, -0.06511710f, 0.14555642f, 0.01155566f, 0.09125489f, 0.03763579f, -0.08344629f, 
    0.05446817f, 0.03217302f, 0.06416593f, 0.03321616f, 0.41866755f, -0.18028793f, 0.05544526f, 0.20143242f, 
    0.05497321f, -0.14543381f, -0.00224756f, 0.00496367f, 0.09027995f, 0.02911414f, -0.02874229f, 0.11714491f, 
    -0.03012447f, -0.01702072f, 0.02439637f, -0.04858965f, 0.04525255f, 0.01497689f, 0.01316054f, -0.02969419f, 
    0.06011957f, 0.14190795f, -0.07036930f, -0.05722607f, 0.13727413f, -0.01809178f, -0.01029116f, -0.09548559f, 
    0.01989443f, 0.01453905f, 0.03040054f, -0.05901565f, 0.08151564f, 0.02729767f, 0.01222828f, 0.00405969f, 
    0.09928679f, -0.03410116f, -0.05531554f, -0.04384046f, -0.06007992f, 0.06314065f, 0.03252207f, 0.06870996f, 
    -0.05456439f, 0.12521699f, 0.02945470f, 0.02262248f, -0.26305151f, 0.14160335f, 0.10910033f, 0.00798336f, 
    0.08440530f, 0.08054924f, -0.07167836f, -0.02511367f, 0.00652606f, -0.08628171f, -0.06326822f, 0.01778946f, 
    0.10631666f, 0.12908319f, -0.11199044f, 0.14640427f, 0.00182721f, 0.00764381f, -0.09244684f, 0.00557542f, 
    -0.01725851f, -0.05515716f, 0.07449777f, 0.02512860f, 0.33887818f, 0.16902626f, 0.25125641f, 0.03614344f, 
    -0.12306058f, -0.04656611f, 0.06025324f, 0.08724792f, 0.04216229f, -0.08201697f, -0.05363479f, 0.04771345f, 
    -0.21387231f, -0.05629453f, 0.05702452f, 0.13669366f, 0.10349363f, -0.01756059f, 0.01400767f, 0.00702961f, 
    -0.00924630f, -0.05040072f, 0.04694701f, 0.03602343f, 0.00641887f, -0.16242601f, -0.06794766f, -0.16887191f, 
    -0.06672294f, 0.07124138f, -0.01925422f, -0.09013771f, 0.05706166f, 0.03668308f, 0.12075429f, 0.06178953f, 
    0.24412863f, -0.11339680f, -0.10438897f, -0.12556149f, 0.12723616f, 0.07173352f, -0.02464053f, 0.08371714f, 
    -0.12603380f, -0.08088334f, 0.04111508f, 0.13434404f, 0.22651400f, 0.00594931f, 0.10840978f, -0.03720983f, 
    -0.10951580f, -0.00693420f, 0.02743216f, -0.09145319f, 0.01482789f, 0.06103485f, -0.03151100f, -0.00681384f, 
    -0.24403796f, -0.03137314f, 0.00848072f, 0.20917518f, -0.01845839f, 0.01999302f, 0.07376067f, -0.01554605f, 
    -0.02580508f, -0.05612702f, -0.04039551f, -0.01783191f, -0.10283090f, -0.13444872f, -0.16508660f, -0.05945571f, 
    0.03889415f, -0.03529703f, -0.00779320f, 0.05338310f, 0.00727259f, 0.10198261f, -0.08146559f, -0.03238789f, 
    -0.25296941f, 0.11556706f, 0.07908724f, -0.10779832f, -0.02479716f, 0.06531633f, -0.04735073f, -0.07508896f, 
    0.03467287f, -0.02933746f, -0.11741528f, -0.05730809f, 0.60935044f, -0.18982586f, 0.07936282f, -0.05550557f, 
    0.01631670f, 0.03753132f, 0.05333412f, 0.12293088f, 0.05530921f, 0.00054343f, 0.04183929f, 0.05029768f, 
    -0.03163972f, -0.01261251f, -0.01635696f, -0.04848154f, -0.03195152f, 0.01259298f, 0.02216541f, -0.05685070f, 
    -0.04552899f, -0.02654533f, 0.03095857f, -0.00249232f, -0.04495449f, -0.01437888f, -0.02117841f, 0.02237791f, 
    0.03473141f, 0.01945990f, -0.01561038f, 0.04371281f, 0.01702098f, 0.03937219f, -0.03806136f, 0.03496771f, 
    0.02760523f, 0.00340218f, 0.03436235f, -0.05346225f, -0.03555353f, -0.00455981f, 0.01183483f, 0.00712972f, 
    -0.00445635f, -0.03469277f, -0.03822114f, 0.04058369f, -0.04391476f, -0.04462989f, -0.00557738f, 0.00903827f, 
    0.04430110f, -0.03851630f, 0.01848986f, 0.02882716f, 0.00593656f, -0.04795065f, 0.01952836f, 0.03206722f, 
    -0.01783226f, -0.00209476f, 0.02861219f, -0.02581338f, -0.00812072f, 0.04091315f, 0.01713055f, -0.00127191f, 
    0.00853028f, -0.04545433f, -0.00028315f, -0.02969970f, 0.05169416f, 0.02039568f, 0.00303781f, -0.02013805f, 
    -0.01542591f, 0.00563313f, 0.03260614f, 0.00019699f, 0.00163298f, 0.03550150f, -0.03538084f, -0.03243151f, 
    0.03721862f, 0.04363737f, -0.04556579f, -0.04154783f, 0.02232709f, 0.00069551f, 0.02613362f, -0.00852155f, 
    -0.02467494f, -0.00760287f, 0.00595402f, 0.04165946f, -0.01630807f, -0.03084407f, 0.02605878f, -0.04995852f, 
    0.04156660f, -0.01039551f, -0.03405994f, 0.02558483f, -0.00143939f, -0.03118894f, -0.00822499f, -0.03477845f, 
    -0.00727398f, -0.03923246f, -0.01142748f, -0.02865450f, 0.01904434f, -0.00351092f, -0.05243379f, -0.01014229f, 
    -0.02868580f, 0.03933667f, 0.02980872f, 0.02324192f, -0.04977208f, 0.04105054f, 0.01538674f, 0.01110578f, 
    0.03192817f, -0.00230470f, -0.04729739f, 0.02879218f, -0.03754005f, -0.02923200f, 0.04117670f, -0.00981793f, 
    0.03962496f, 0.00474156f, -0.05283326f, -0.04415275f, -0.00240247f, 0.02242849f, 0.00177364f, -0.03565924f, 
    0.01495712f, -0.04497491f, -0.05103135f, -0.04528429f, 0.03233762f, 0.03882117f, 0.03473907f, -0.01687699f, 
    -0.00885484f, 0.04344930f, 0.03320555f, 0.04361135f, 0.00243943f, -0.04600709f, -0.04422291f, -0.01718730f, 
    0.00351195f, 0.00194789f, 0.04350984f, 0.04290129f, -0.00271672f, 0.02475770f, -0.00419236f, -0.00029950f, 
    -0.02151156f, 0.01964066f, -0.00356826f, -0.02853215f, 0.03587451f, -0.00443597f, -0.01412434f, -0.02977720f, 
    -0.01460822f, -0.00608284f, -0.04393160f, -0.02080311f, 0.03983654f, -0.05517416f, -0.01296890f, -0.01920232f, 
    -0.01490656f, 0.00535956f, 0.02709852f, 0.04314368f, -0.00158441f, 0.03254174f, -0.01741895f, -0.00446335f, 
    0.01455065f, -0.04796128f, 0.04522241f, 0.03582954f, 0.02628240f, 0.01936984f, 0.03361247f, -0.03733391f, 
    -0.01799515f, -0.05372237f, 0.03492653f, 0.01212465f, 0.00418404f, 0.03047032f, -0.02758755f, -0.00533546f, 
    0.04397747f, 0.01076420f, -0.03661392f, -0.04668760f, 0.03705604f, -0.02884688f, 0.01551719f, -0.04355434f, 
    -0.00714181f, -0.04352268f, 0.01236689f, -0.01586134f, -0.02793727f, -0.00901191f, -0.03992504f, -0.00511650f, 
    -0.03953534f, -0.03220337f, -0.04243774f, -0.03532025f, 0.04243596f, 0.02277478f, -0.00685216f, -0.01752065f, 
    0.00773710f, -0.02205200f, 0.01851139f, -0.00212003f, -0.05773493f, -0.02864603f, 0.03940919f, -0.04333137f, 
    -0.01595305f, -0.04127923f, 0.00620883f, 0.04802242f, -0.03326669f, 0.02452570f, -0.04384192f, -0.02722590f, 
    0.02233067f, 0.01323829f, 0.03378848f, 0.03339073f, -0.00883879f, 0.03337960f, -0.01192871f, 0.03143385f, 
    -0.02790520f, 0.01624290f, -0.05069365f, 0.04551182f, 0.01693460f, -0.03122402f, -0.04763561f, 0.00549647f, 
    0.01849258f, 0.04393509f, -0.02681080f, 0.04444457f, -0.05598534f, -0.03690812f, -0.05664310f, -0.02933976f, 
    0.01775050f, 0.02813190f, 0.01888506f, 0.01951496f, -0.03790462f, -0.02708566f, -0.04725651f, -0.03297110f, 
    0.02832932f, 0.02944045f, -0.00870686f, 0.03738379f, 0.01736783f, 0.00592298f, -0.01607345f, -0.00870802f, 
    -0.02469489f, -0.01364022f, -0.04205607f, -0.03909476f, -0.01109134f, 0.00788163f, 0.05022625f, 0.03945051f, 
    -0.01900821f, -0.01635981f, 0.03568255f, 0.01743170f, -0.04886715f, -0.02072875f, 0.03995543f, 0.03809599f, 
    0.01259385f, 0.01909960f, -0.04830022f, -0.05140277f, -0.02434486f, 0.01266775f, 0.01437982f, 0.00777259f, 
    -0.01509540f, -0.05716822f, -0.01021355f, -0.02330088f, 0.00747850f, -0.04150603f, -0.05815652f, 0.00911866f, 
    0.00124746f, -0.05859058f, -0.01443381f, -0.04580228f, 0.01304566f, -0.00108706f, -0.04339473f, 0.00307660f, 
    0.00226683f, 0.02193855f, 0.02406252f, -0.03361790f, 0.02942920f, -0.03135334f, -0.02841310f, 0.02881616f, 
    0.02148208f, -0.00219037f, -0.01178994f, 0.03405359f, 0.02418807f, -0.01807960f, 0.02497959f, 0.05636288f, 
    -0.03443650f, 0.02524420f, -0.04192230f, 0.03288713f, 0.03989133f, -0.03594794f, -0.03056476f, -0.04374123f, 
    -0.01748082f, -0.03390336f, -0.02863528f, 0.02038466f, -0.03219621f, 0.00972400f, 0.01393491f, 0.00609340f, 
    -0.04993154f, -0.00122970f, 0.01870701f, -0.05077627f, 0.01330945f, 0.01091421f, -0.03663528f, 0.00199063f, 
    -0.01458878f, 0.04211015f, 0.03830849f, -0.05384492f, 0.00708910f, 0.00424162f, -0.01043886f, -0.04871355f, 
    -0.02227607f, 0.04081159f, -0.01328352f, -0.00615719f, -0.03128089f, -0.03688996f, 0.02840127f, 0.02964258f, 
    0.04048963f, -0.01263727f, -0.00394132f, -0.03324768f, -0.03790788f, 0.02504841f, -0.00825640f, -0.02376635f, 
    0.04147609f, -0.04911864f, -0.02054368f, 0.01163871f, -0.04856949f, -0.02869684f, -0.02669942f, 0.01124062f, 
    -0.22560695f, -0.07504215f, -0.01966953f, 0.09328916f, 0.06501915f, 0.07505762f, -0.01111502f, 0.08102921f, 
    -0.04192276f, -0.14444822f, 0.05625817f, 0.11144871f, -0.10274545f, -0.00331487f, -0.15570739f, -0.08822526f, 
    -0.06943947f, -0.08608827f, -0.01721235f, 0.04491709f, -0.14460853f, -0.08775727f, 0.01915679f, -0.04048956f, 
    -0.06939677f, 0.03382545f, -0.08114526f, -0.08362580f, 0.06904300f, -0.01754263f, 0.07700253f, -0.07103225f, 
    0.01448477f, -0.05847339f, 0.08250453f, 0.10236098f, 0.23659791f, 0.05201630f, -0.06132489f, -0.10294834f, 
    0.11996078f, 0.03694465f, 0.10762128f, 0.04809929f, 0.04739018f, -0.07479862f, 0.13207825f, -0.00051079f, 
    0.13185816f, -0.17594124f, 0.01136839f, 0.14100011f, 0.18538581f, -0.10006027f, -0.06928888f, 0.10110412f, 
    0.09183040f, 0.04156912f, -0.07378894f, -0.10014952f, 0.07744388f, 0.17011617f, -0.14041920f, 0.44499984f, 
    0.05431532f, -0.09427162f, 0.08999987f, -0.06194938f, 0.11038936f, 0.03550975f, 0.05831035f, -0.05742216f, 
    -0.25494036f, 0.13693944f, 0.04691790f, 0.02018045f, 0.10647709f, -0.04373711f, 0.02471043f, 0.06018967f, 
    -0.02375499f, -0.07815164f, -0.04608718f, -0.13624237f, -0.33202535f, -0.03222625f, -0.00815672f, -0.07026497f, 
    -0.03163384f, 0.02638987f, 0.02695446f, -0.15284379f, 0.00496137f, -0.03152857f, -0.02992656f, -0.07195868f, 
    0.15190400f, -0.20055485f, 0.10833609f, 0.09571914f, 0.09346313f, 0.02023252f, -0.01312533f, 0.03063831f, 
    0.01304289f, -0.02227059f, 0.15135622f, -0.02165415f, -0.05885166f, -0.08455405f, -0.05222075f, 0.03098512f, 
    -0.01560355f, 0.10708863f, -0.06102877f, 0.05064417f, 0.10483559f, 0.04711628f, -0.05965557f, -0.07562478f, 
    0.30311379f, 0.12067536f, -0.07776134f, 0.08743145f, 0.05439350f, 0.00178919f, 0.04637426f, -0.02830079f, 
    -0.00550028f, -0.02509850f, -0.01479639f, 0.08828678f, -0.11513335f, -0.08071102f, 0.07264303f, -0.15455644f, 
    0.09357549f, -0.08197546f, 0.05602327f, 0.16356464f, -0.03750551f, 0.05663777f, -0.05503280f, -0.00474458f, 
    0.06273037f, 0.08018672f, 0.00482775f, -0.09516629f, 0.05050137f, 0.08027662f, -0.00699855f, -0.06477498f, 
    0.08234697f, -0.01208947f, 0.05584527f, 0.06360716f, 0.06370951f, 0.18977375f, -0.10518724f, 0.16319160f, 
    0.02413366f, 0.13822582f, -0.02889224f, 0.01892125f, 0.02568766f, -0.00183418f, -0.04771267f, 0.09467955f, 
    0.02347162f, 0.08678574f, 0.17607591f, 0.03361518f, 0.04110166f, 0.04466263f, 0.12072218f, -0.02230878f, 
    -0.03339151f, 0.00179965f, 0.14364745f, 0.07334785f, 0.27668032f, 0.04664458f, 0.05000154f, 0.53623545f, 
    -0.01439826f, 0.04654724f, -0.03543168f, 0.02378153f, 0.01025099f, 0.07118312f, 0.10244849f, 0.16032194f, 
    -0.32118192f, -0.02497411f, -0.09521891f, -0.10338514f, 0.11448059f, 0.07171232f, -0.04312095f, 0.10331112f, 
    0.06203468f, 0.07825702f, -0.03206368f, -0.04529202f, -0.21382998f, -0.04386272f, 0.05438320f, -0.14937720f, 
    -0.07726733f, -0.01832500f, 0.07158393f, -0.04163458f, -0.00848485f, 0.01139689f, 0.11001460f, 0.05085352f, 
    -0.07906341f, -0.00235885f, 0.14469847f, -0.16999544f, 0.09378912f, -0.02224545f, -0.00419780f, 0.05370864f, 
    0.00031000f, -0.05456716f, 0.08423973f, 0.08096849f, -0.12634830f, 0.09881913f, -0.02332236f, 0.20289905f, 
    -0.08624432f, -0.12993599f, -0.01511479f, 0.03800541f, -0.05543683f, 0.07257329f, 0.06298522f, -0.06362207f, 
    0.12094142f, 0.18644935f, 0.10669315f, 0.04400386f, -0.14004201f, -0.16758423f, -0.04628495f, 0.09376758f, 
    0.05598232f, -0.04891246f, 0.08074072f, 0.04369124f, -0.10740979f, 0.05704789f, 0.05064380f, -0.01198749f, 
    0.01785674f, 0.04653046f, -0.04529955f, 0.07936645f, 0.08954949f, 0.08155160f, 0.08587181f, 0.17929648f, 
    0.07062039f, -0.10994899f, -0.04430187f, 0.10051525f, 0.17994605f, -0.03383904f, -0.03258077f, -0.03616418f, 
    0.01171965f, -0.04844060f, 0.02100026f, -0.12137125f, 0.07343599f, -0.03482250f, -0.17453684f, 0.12692404f, 
    0.02480581f, -0.03436916f, 0.04007372f, -0.05045524f, 0.10487226f, 0.00703376f, 0.04610482f, -0.01979491f, 
    0.01877584f, -0.08342922f, -0.07116964f, 0.04177319f, -0.01174046f, -0.01191821f, -0.02466730f, 0.00548201f, 
    0.05352336f, 0.08769156f, 0.04101805f, 0.02729953f, -0.29637262f, 0.13921773f, -0.10575600f, -0.13528362f, 
    0.04324348f, -0.00217901f, 0.01136603f, 0.21706517f, 0.06378243f, 0.07530177f, -0.08706697f, 0.07821660f, 
    -0.32558560f, 0.20290427f, 0.03460117f, 0.17162190f, -0.03147236f, 0.05471419f, 0.05087962f, 0.09804250f, 
    0.11135978f, 0.07438492f, -0.08115697f, -0.01697402f, -0.09705289f, 0.13658893f, -0.05932072f, 0.14580341f, 
    -0.01001954f, 0.02196945f, -0.02448236f, 0.01390486f, 0.03818171f, -0.01099405f, 0.03143547f, 0.12450985f, 
    -0.17462897f, -0.09804319f, 0.03540640f, 0.18017673f, -0.07918906f, 0.00940153f, -0.02075738f, 0.02403776f, 
    -0.07627461f, 0.00721882f, -0.06705078f, 0.02236184f, 0.42919835f, 0.09056453f, -0.06583047f, 0.21785815f, 
    -0.02160373f, 0.11579579f, -0.04929892f, 0.04942254f, -0.04694268f, -0.05358629f, -0.03804137f, -0.02773593f, 
    -0.05631844f, -0.02625882f, -0.11427038f, -0.06296204f, -0.07179685f, -0.04561995f, 0.07537314f, 0.05182856f, 
    0.06482750f, 0.02770774f, 0.09778373f, 0.02143853f, -0.25444347f, 0.26824212f, -0.06183542f, 0.03121752f, 
    0.06499288f, -0.07512458f, 0.06482117f, 0.10330889f, 0.03699990f, 0.00401592f, -0.03642986f, -0.05423279f, 
    0.07015093f, -0.11584329f, -0.21547721f, 0.14339882f, 0.03669317f, -0.07412659f, -0.00762912f, 0.00522736f, 
    -0.11192215f, -0.03071240f, 0.05257804f, 0.09966913f, -0.40440077f, 0.15423466f, 0.10953537f, 0.10442919f, 
    0.05590434f, 0.06129349f, 0.12964889f, 0.11673239f, 0.02803069f, -0.00758792f, -0.04978916f, 0.11776987f, 
    -0.21158670f, 0.03801574f, -0.06216479f, -0.10592259f, 0.07256798f, 0.00124187f, 0.13818432f, -0.00552367f, 
    -0.04284496f, -0.00653087f, 0.01976003f, -0.19649233f, 0.14179182f, 0.20166476f, 0.19351004f, -0.30715752f, 
    0.04548008f, -0.01475296f, -0.01899273f, 0.03485139f, -0.00150443f, 0.05221085f, 0.19353557f, 0.02298564f, 
    0.16479729f, 0.18797231f, -0.04941262f, -0.05300914f, 0.00111965f, -0.06846301f, 0.03057531f, 0.00332771f, 
    0.06807559f, 0.01759258f, 0.02195878f, 0.02099574f, 0.20883946f, -0.04617976f, -0.07734205f, 0.12700401f, 
    -0.00313821f, -0.07208022f, 0.05368962f, 0.06627996f, -0.00275041f, 0.08387125f, 0.01264005f, -0.02317827f, 
    -0.17816667f, 0.31976891f, -0.00017938f, 0.23001119f, 0.22647598f, 0.08502623f, -0.01760411f, 0.02269543f, 
    -0.11137863f, -0.13508201f, -0.19029748f, -0.06106261f, 0.02953364f, 0.19768782f, 0.13378440f, 0.00701039f, 
    0.16080199f, 0.06890970f, 0.01233499f, -0.03797933f, -0.04187698f, -0.02640127f, -0.01696486f, -0.01295848f, 
    0.04397268f, -0.07307632f, -0.04655345f, 0.12435729f, 0.05546125f, -0.02502187f, -0.05162226f, -0.08742148f, 
    -0.00862735f, 0.00023757f, 0.03450617f, 0.08586151f, 0.12245752f, -0.16623051f, -0.09196675f, 0.03751509f, 
    0.04368874f, 0.04079431f, -0.09147798f, -0.08205985f, -0.04159762f, 0.04031320f, -0.02470337f, 0.09018320f, 
    0.22816567f, 0.12646769f, 0.06004745f, 0.15385894f, 0.00969847f, -0.08524437f, -0.09242935f, -0.07873303f, 
    -0.01646705f, 0.01175532f, 0.07233998f, 0.15796140f, 0.01780191f, 0.06647170f, -0.01145681f, -0.11451768f, 
    -0.04276846f, -0.07902615f, -0.02356338f, 0.02566443f, 0.02891205f, -0.02807667f, -0.05507444f, -0.00523471f, 
    -0.05584439f, 0.10918950f, 0.02067639f, -0.03851414f, -0.10448159f, 0.06133829f, -0.04843627f, -0.08384196f, 
    0.05641085f, -0.01682252f, -0.08316050f, 0.00994508f, -0.12973790f, 0.01240561f, 0.01149299f, 0.14558767f, 
    0.06760924f, 0.02383786f, 0.08630283f, -0.05302761f, 0.01022385f, -0.05293781f, -0.19934165f, -0.11392807f, 
    -0.07877590f, 0.00657678f, 0.12685074f, -0.10231165f, -0.04968996f, -0.01573852f, 0.04160469f, -0.08207192f, 
    0.04210305f, -0.10852047f, 0.09578950f, -0.08594446f, 0.12709865f, 0.07203299f, 0.09381819f, 0.42345846f, 
    -0.00092645f, -0.04274472f, -0.04841774f, -0.02439796f, 0.01107646f, 0.03263372f, 0.06614687f, 0.07761586f, 
    -0.28922144f, 0.23989597f, 0.00936870f, -0.22091036f, 0.10101108f, 0.03887844f, -0.05177797f, 0.05445978f, 
    -0.08653398f, -0.03118007f, -0.08330947f, -0.09950018f, -0.13475640f, 0.01761671f, 0.08953489f, -0.19441372f, 
    0.07456472f, 0.09856252f, -0.00563926f, -0.00311193f, 0.03439945f, -0.01555125f, -0.01637519f, -0.08956141f, 
    0.16100276f, -0.10539740f, -0.13082941f, -0.00041705f, -0.01671349f, -0.14039154f, -0.07298885f, 0.00435143f, 
    -0.09841571f, -0.05049706f, 0.10010611f, 0.04878758f, 0.03763290f, 0.23164514f, 0.03624659f, 0.17431802f, 
    0.04560530f, 0.04772732f, 0.11679631f, -0.04134889f, 0.04414214f, 0.04725321f, -0.18955930f, -0.05561750f, 
    0.01780673f, 0.27461702f, 0.19545056f, 0.26961139f, 0.02590982f, -0.02714183f, -0.00453550f, 0.00010163f, 
    -0.05140881f, -0.04309784f, -0.09187532f, 0.09301754f, 0.32014897f, -0.14769915f, -0.16363010f, -0.30339885f, 
    0.04188488f, 0.03144224f, -0.08300789f, -0.03471711f, -0.03783853f, -0.01293752f, -0.04613397f, -0.01215193f, 
    0.19468467f, 0.04296368f, 0.18883036f, 0.07826208f, 0.11839232f, 0.06318059f, 0.05877046f, 0.05099083f, 
    0.04350538f, 0.13970929f, 0.02428489f, -0.01703830f, 0.20408107f, 0.15623774f, 0.10154657f, 0.15319569f, 
    0.22401044f, 0.17611951f, 0.06925268f, -0.02790727f, 0.09497164f, -0.03227130f, 0.07600699f, -0.12026018f, 
    0.29562885f, -0.01554923f, -0.05770357f, -0.10221817f, 0.01168144f, -0.04655151f, 0.05782660f, -0.07051024f, 
    -0.06332761f, -0.00062208f, -0.06159725f, 0.03400708f, -0.30343801f, 0.19490327f, 0.17741591f, -0.15214346f, 
    0.11088314f, 0.02536675f, -0.10376885f, 0.01121464f, 0.03833759f, -0.09503642f, -0.02004959f, 0.01030211f, 
    0.17739251f, -0.12695934f, 0.07564028f, 0.20718671f, -0.12910199f, 0.09781058f, -0.06439967f, -0.01295497f, 
    0.14352013f, 0.04948299f, 0.09681583f, -0.01658126f, -0.06572089f, 0.00886363f, 0.02676446f, 0.16103907f, 
    0.19691280f, 0.01697154f, 0.04354661f, 0.05984599f, 0.05963554f, -0.03979255f, 0.01818633f, -0.03801981f, 
    -0.23850274f, -0.10310754f, -0.02691969f, -0.01685007f, 0.11758560f, -0.15256749f, -0.08229435f, -0.01156545f, 
    0.04927054f, 0.02294180f, 0.00978009f, 0.06802694f, -0.16295017f, 0.03805931f, 0.12100290f, 0.24327740f, 
    -0.04298211f, 0.00310459f, 0.04565336f, -0.05185313f, -0.01224659f, -0.03778561f, 0.19872017f, -0.05418018f, 
    0.21702413f, -0.12863378f, -0.07993729f, -0.07515938f, 0.01697394f, -0.00109508f, -0.00176750f, -0.05401503f, 
    -0.11121726f, -0.03712834f, 0.00384392f, 0.00327346f, -0.54519361f, 0.27312586f, 0.03403119f, -0.06596005f, 
    0.07931475f, -0.06196097f, 0.02378111f, 0.01715802f, 0.02409030f, 0.01096327f, -0.07299117f, 0.03165121f, 
    -0.04796065f, 0.01585641f, 0.00273311f, -0.02786096f, 0.03338557f, 0.00362312f, 0.00127785f, -0.03305273f, 
    0.00617424f, -0.01248335f, -0.04957805f, 0.04455256f, 0.03562781f, 0.01385080f, -0.04907980f, 0.00166886f, 
    -0.02046464f, 0.00725400f, -0.02910476f, -0.03187967f, 0.03491011f, -0.03685897f, 0.00853373f, 0.00321654f, 
    0.04276691f, 0.03560669f, 0.00555192f, -0.01289281f, -0.03464741f, 0.01814456f, -0.02382103f, 0.01115528f, 
    -0.03063769f, 0.03377592f, -0.00200592f, 0.00059866f, -0.03269215f, -0.04289489f, -0.03712884f, -0.01151678f, 
    -0.05015846f, -0.00854817f, 0.00166517f, 0.00619692f, 0.01800278f, -0.01347764f, 0.02879317f, -0.05259924f, 
    0.01787137f, 0.04086895f, 0.01088676f, 0.02430000f, -0.00738794f, 0.00640426f, -0.00625395f, -0.03405954f, 
    0.04726632f, 0.00755545f, -0.02552862f, 0.01018967f, 0.00722479f, 0.03075361f, -0.02940791f, 0.04305768f, 
    -0.00362039f, 0.01701424f, -0.03326929f, -0.04209178f, 0.03063341f, -0.01166192f, 0.02912598f, -0.02450578f, 
    0.01561510f, 0.04114671f, -0.04815750f, 0.01003875f, 0.03611801f, 0.03558826f, 0.00121893f, -0.04055223f, 
    0.00912601f, -0.02507811f, 0.03320224f, 0.03835062f, -0.05472607f, -0.01773292f, 0.02661120f, -0.03022069f, 
    0.00654101f, -0.03496163f, -0.05671517f, -0.02806137f, 0.01768765f, 0.04634142f, 0.02318998f, 0.04197609f, 
    -0.00460552f, 0.00794807f, 0.03905386f, -0.04694711f, 0.01624734f, -0.04232865f, 0.02433744f, -0.01042374f, 
    -0.00319815f, 0.01094950f, -0.01584319f, 0.04430840f, 0.02810765f, 0.03587207f, 0.00835304f, 0.00423969f, 
    0.02530074f, -0.02308937f, -0.03714959f, 0.01531362f, -0.03466024f, 0.03701520f, -0.05249700f, -0.02828804f, 
    -0.05008324f, -0.02205757f, 0.02536585f, -0.04165955f, -0.03406988f, 0.00628673f, -0.00854114f, 0.03904336f, 
    -0.01635690f, 0.00923907f, -0.05576731f, 0.03960502f, 0.02371540f, 0.01926171f, 0.00645667f, -0.05473157f, 
    0.01823186f, -0.00354471f, -0.05386291f, -0.02323936f, -0.02573326f, 0.03519874f, -0.02872010f, 0.02608448f, 
    -0.01796090f, -0.00548656f, 0.03719380f, 0.00035915f, 0.00409330f, -0.00615594f, 0.03781271f, -0.01217549f, 
    -0.03168527f, 0.03245559f, 0.04201676f, -0.04538807f, -0.00805672f, -0.00778465f, -0.00973976f, -0.05154372f, 
    -0.03633726f, -0.01838814f, -0.03655832f, -0.03591347f, -0.01355233f, -0.02944156f, -0.00624264f, 0.00080555f, 
    -0.03907243f, -0.04228995f, -0.01480411f, -0.01270659f, -0.05052716f, 0.04610294f, -0.03958306f, 0.03234527f, 
    -0.04225558f, -0.01165764f, -0.04783070f, 0.01544941f, 0.03193017f, -0.02258589f, 0.01721512f, -0.04303706f, 
    -0.02583537f, -0.00194012f, -0.01634971f, -0.01654477f, -0.00435738f, 0.03493805f, -0.04720573f, -0.00088569f, 
    -0.05440756f, -0.04078892f, -0.04022198f, -0.05097720f, -0.01486695f, -0.00624770f, 0.01650673f, -0.01296405f, 
    0.01392012f, 0.01906217f, -0.01942261f, -0.02667790f, 0.02590655f, 0.00697600f, 0.02550447f, 0.02195201f, 
    0.04012815f, -0.02014145f, -0.00475007f, 0.03562528f, 0.03813549f, 0.02810053f, -0.05631160f, -0.05248004f, 
    -0.00483619f, 0.01453199f, 0.01413603f, 0.04521036f, 0.04599012f, -0.04390827f, -0.03590239f, 0.01191412f, 
    -0.03905597f, 0.02886269f, -0.04866723f, 0.03266007f, 0.03878972f, -0.04354175f, -0.04802847f, 0.01376713f, 
    0.01309742f, 0.02873924f, -0.00235182f, -0.04395491f, 0.03131327f, -0.00703642f, -0.04158629f, -0.03968921f, 
    0.02324133f, -0.00399009f, 0.02349980f, -0.03941052f, 0.00839868f, -0.04607364f, -0.02528362f, -0.03678385f, 
    0.02921052f, -0.04025659f, -0.04138131f, -0.05382453f, -0.03013832f, 0.02796634f, 0.04383998f, -0.01046321f, 
    0.01882961f, -0.04263991f, -0.05005649f, -0.02136608f, 0.04508330f, -0.00491065f, -0.03103798f, 0.00855517f, 
    -0.03854257f, -0.00938796f, -0.02691411f, -0.00069876f, -0.00087445f, -0.03414965f, 0.03992620f, -0.01367058f, 
    -0.00810859f, -0.02932144f, -0.03043876f, 0.03211296f, 0.02490230f, -0.04349113f, 0.03142937f, 0.00442391f, 
    0.01130954f, 0.04080029f, -0.00962238f, -0.02149918f, 0.03612762f, 0.02740075f, -0.03453446f, -0.05268783f, 
    0.00783045f, -0.04219400f, -0.02121015f, 0.00749090f, -0.04902925f, 0.00239360f, 0.00434179f, 0.04605437f, 
    -0.03232518f, -0.03796690f, 0.02022755f, -0.00131545f, -0.00719588f, 0.02149015f, 0.04593111f, 0.02004237f, 
    0.03492571f, -0.00607253f, -0.03387157f, 0.01802394f, -0.03238845f, 0.02720035f, -0.02439402f, -0.01201434f, 
    -0.01067918f, -0.04281444f, -0.00211546f, -0.05428340f, -0.01872613f, 0.04346322f, 0.00751116f, -0.05745696f, 
    0.04005210f, -0.04098248f, -0.02254940f, 0.04925982f, -0.00000198f, 0.03958676f, -0.04370001f, -0.04871734f, 
    -0.01115989f, -0.03777199f, 0.00788052f, 0.03454208f, 0.02934645f, -0.05265858f, -0.01891475f, 0.01836840f, 
    -0.00191280f, -0.01376856f, 0.02014872f, -0.04891643f, -0.03048719f, -0.04487296f, 0.01980363f, -0.01563383f, 
    -0.03410761f, -0.00566260f, -0.00329780f, 0.03053164f, -0.02889263f, -0.01686926f, 0.01513681f, 0.01544896f, 
    -0.03001454f, -0.01277462f, -0.01057026f, 0.01618104f, 0.00817917f, -0.02057194f, 0.02081545f, 0.01631754f, 
    0.04631542f, -0.01625935f, 0.03566406f, -0.00926264f, 0.03700331f, 0.02429814f, -0.02049210f, -0.03353503f, 
    -0.02345141f, -0.01033677f, 0.01589967f, 0.01508826f, 0.02506326f, 0.04394518f, 0.04586513f, 0.02802097f, 
    0.04344026f, 0.02381125f, 0.03645143f, -0.03134783f, -0.00163462f, -0.03378291f, 0.00860636f, 0.01469889f, 
    0.03708612f, -0.01152214f, 0.03068149f, -0.02315491f, -0.01674244f, -0.05064257f, -0.05353205f, 0.01702283f, 
    0.01160548f, 0.00129214f, -0.00206864f, -0.05188634f, 0.03641609f, 0.03929289f, -0.03369259f, -0.04841360f, 
    0.00298251f, -0.05391233f, -0.02464821f, -0.04674761f, 0.03493578f, 0.03033821f, -0.01750513f, -0.03063232f, 
    0.04259026f, 0.04254064f, 0.04151649f, -0.00574150f, -0.03739113f, 0.04495699f, -0.04233059f, 0.03871032f, 
    -0.01757308f, -0.03297318f, -0.02514992f, 0.03367589f, -0.00026166f, 0.04392471f, -0.03499683f, -0.02473400f, 
    -0.03573819f, -0.00494882f, 0.03734715f, -0.03364664f, -0.03859940f, -0.04456868f, -0.04923752f, -0.01786726f, 
    0.01869359f, 0.02756364f, -0.03173887f, 0.00608457f, 0.04110572f, -0.05102450f, -0.04007424f, 0.03683326f, 
    0.03916265f, 0.02939543f, -0.00712226f, -0.03614086f, -0.02710866f, -0.03500585f, 0.01330940f, 0.02883558f, 
    -0.01464869f, -0.04166383f, -0.00374720f, -0.00051424f, 0.00677514f, -0.01253117f, 0.00332654f, -0.02533229f, 
    -0.01162571f, 0.02134247f, 0.02422703f, -0.01067133f, -0.04521300f, -0.03355518f, 0.03336902f, 0.02636436f, 
    -0.05119190f, 0.03416374f, 0.05558946f, 0.00512383f, 0.00603128f, 0.01644890f, -0.01612832f, -0.03759303f, 
    -0.03092641f, -0.02518801f, -0.04913319f, -0.04984594f, -0.01823911f, -0.05205410f, -0.03864767f, -0.02134348f, 
    -0.04034716f, 0.00049920f, -0.02558628f, -0.01731154f, 0.01847708f, 0.04385195f, -0.04453112f, 0.02046010f, 
    -0.01300250f, -0.02864160f, 0.03145919f, -0.02113450f, -0.01153488f, 0.00285681f, 0.00863800f, 0.03768538f, 
    -0.00637791f, -0.02312197f, -0.04610418f, -0.03157288f, -0.01191933f, -0.02664569f, 0.02503212f, -0.00642436f, 
    0.00475011f, 0.00163013f, -0.03066669f, 0.02044684f, 0.03598943f, -0.02129817f, 0.00646055f, 0.03827020f, 
    -0.05214451f, 0.00233115f, -0.05112061f, -0.03560758f, 0.00033367f, -0.02972948f, 0.01312664f, -0.03120988f, 
    0.03386958f, -0.02199954f, 0.04291140f, -0.04394846f, -0.03015096f, 0.01807594f, 0.02869328f, -0.02842802f, 
    0.01393051f, 0.02149075f, -0.04261110f, -0.04524890f, -0.03021656f, -0.01635279f, -0.05071118f, -0.02941052f, 
    0.01664358f, 0.00572394f, 0.02877655f, 0.02083670f, -0.01231924f, -0.00465964f, 0.03821115f, 0.03234367f, 
    -0.02559214f, -0.00181623f, 0.01226828f, -0.05208322f, 0.04278480f, 0.02328783f, -0.05209293f, -0.05489414f, 
    0.02523411f, 0.02564978f, -0.05124856f, -0.03568080f, 0.01606162f, 0.02251029f, 0.02874080f, -0.02194402f, 
    -0.01194497f, -0.02814534f, -0.02339245f, 0.01532249f, -0.05010972f, 0.02818555f, -0.05604408f, -0.02478601f, 
    -0.00937972f, -0.03061687f, 0.00592168f, 0.02807543f, 0.04380256f, -0.03044984f, -0.04082299f, 0.01657597f, 
    -0.01289136f, -0.00588344f, 0.04462143f, 0.01709761f, 0.00964654f, -0.00701715f, -0.01346370f, -0.04099482f, 
    -0.01804406f, -0.01505375f, -0.00989400f, 0.02072394f, -0.02794215f, 0.01348946f, -0.05096876f, 0.03506844f, 
    0.00217745f, -0.03403493f, 0.04337640f, 0.03068469f, 0.00715684f, -0.02494120f, -0.02006323f, -0.03556725f, 
    0.03743098f, 0.01364315f, -0.04073416f, 0.04340016f, 0.00126228f, 0.03675423f, -0.02264769f, -0.04010461f, 
    -0.03239203f, -0.03765658f, 0.01386857f, 0.01582964f, 0.04199416f, 0.02872271f, 0.02880056f, 0.00863102f, 
    0.00707444f, 0.00175097f, 0.04381184f, -0.01196464f, 0.03514534f, -0.02950763f, -0.05204441f, -0.04506594f, 
    0.04059146f, 0.01546315f, -0.05163895f, -0.01405153f, -0.03498668f, 0.04421309f, -0.02044928f, 0.02592791f, 
    -0.01298874f, -0.04931382f, -0.03563482f, -0.04552210f, -0.03164601f, 0.00734663f, -0.05691819f, 0.00216412f, 
    0.01163987f, -0.03524305f, 0.01019594f, 0.03203004f, -0.00512024f, 0.01994638f, 0.01556381f, 0.00064557f, 
    -0.03750079f, -0.05425751f, 0.02277358f, 0.01327111f, -0.00998369f, -0.04788280f, -0.03685703f, -0.03474850f, 
    -0.01833267f, -0.04541503f, -0.02164902f, -0.02909839f, 0.01724013f, 0.03821788f, -0.00783315f, 0.00390835f, 
    0.04316717f, 0.02705169f, -0.02770690f, 0.00632831f, -0.00663470f, 0.01951635f, -0.04232626f, -0.00485041f, 
    0.02575343f, -0.01661279f, -0.00774911f, 0.02746177f, 0.01963454f, 0.02480874f, -0.02241002f, -0.04783256f, 
    -0.04752994f, -0.02483659f, -0.04351439f, -0.03799188f, 0.00531031f, -0.03954004f, 0.05213508f, -0.03670039f, 
    0.02223478f, 0.03845648f, -0.03882306f, 0.01867121f, -0.05034537f, 0.02121578f, -0.04273902f, 0.01739965f, 
    0.02134158f, -0.03129800f, -0.03887774f, 0.04419720f, 0.00366417f, -0.00182786f, -0.05339757f, 0.01077375f, 
    -0.01292084f, -0.02448183f, 0.00606729f, 0.00093466f, -0.03543659f, 0.01714529f, -0.02934106f, 0.03835240f, 
    -0.01797478f, 0.00065601f, 0.02740484f, -0.00592819f, -0.01878518f, 0.01193770f, -0.04042008f, -0.00536173f, 
    -0.04780456f, -0.05121897f, -0.00629021f, 0.03947964f, -0.00128558f, 0.00011224f, -0.03675738f, 0.04303064f, 
    0.00465066f, 0.01196736f, 0.00361267f, 0.00564501f, -0.02023831f, -0.02200036f, -0.04593941f, -0.01465640f, 
    -0.05427747f, -0.02176217f, -0.02288073f, 0.00287072f, 0.04445003f, 0.02353016f, 0.04218724f, 0.01021374f, 
    -0.03367460f, -0.00399177f, -0.02734674f, 0.03263132f, -0.02493873f, 0.03369224f, -0.00046953f, -0.04903598f, 
    -0.03457659f, -0.02522673f, -0.01539200f, -0.03263368f, 0.02620810f, -0.00992919f, -0.02416884f, -0.01450662f, 
    0.03859139f, -0.04270050f, 0.03842422f, -0.03171964f, -0.00242003f, -0.04674602f, -0.04066702f, -0.02862802f, 
    0.03495720f, -0.14359039f, 0.02685394f, 0.33694261f, 0.14125352f, 0.15300998f, -0.10643584f, -0.04832081f, 
    -0.04091677f, -0.03605377f, 0.03489633f, 0.08596716f, -0.04775591f, -0.11454478f, 0.06196314f, -0.11331078f, 
    -0.10637084f, -0.06178136f, -0.00282864f, 0.09102624f, -0.08119327f, -0.13795489f, -0.01501085f, 0.09446941f, 
    -0.05001689f, -0.17571174f, 0.08328988f, -0.13578638f, 0.07473711f, 0.04688082f, 0.04402000f, -0.12161672f, 
    -0.04279841f, 0.07492797f, 0.00133621f, 0.09569203f, -0.05449784f, 0.06666331f, -0.05560573f, -0.21582170f, 
    0.14715622f, 0.05252255f, 0.08466449f, -0.04571562f, -0.02323638f, -0.04127508f, 0.16738038f, -0.01252259f, 
    0.23314141f, -0.11757904f, -0.13241687f, -0.15276438f, -0.05572805f, -0.04799389f, -0.02525780f, -0.06855953f, 
    -0.02721455f, -0.12100113f, -0.04349716f, -0.05208388f, -0.14964031f, 0.06118580f, -0.23892513f, 0.13600978f, 
    0.01076740f, -0.04935195f, 0.06279843f, -0.00412001f, 0.07126180f, 0.18675749f, -0.06957446f, -0.07198969f, 
    -0.13469674f, -0.01854344f, 0.04200476f, -0.07640486f, 0.05972844f, -0.01703389f, 0.01519376f, 0.03567377f, 
    0.01094310f, -0.19157340f, 0.01851024f, -0.03732983f, -0.10280511f, 0.11993966f, 0.14880972f, 0.28894091f, 
    -0.03305034f, 0.01579418f, -0.03347448f, 0.00153377f, -0.00254791f, -0.01257849f, 0.08078460f, 0.00008409f, 
    0.15707736f, -0.08092293f, 0.05583113f, 0.33948901f, 0.07411948f, 0.07455800f, 0.01064280f, 0.03715624f, 
    -0.02078043f, -0.01732125f, 0.00755867f, 0.01929910f, 0.11287589f, -0.21280676f, -0.13849381f, 0.14096284f, 
    0.00964495f, 0.03810430f, -0.03917338f, -0.08368725f, -0.04169699f, -0.00756932f, 0.08044028f, -0.00379278f, 
    -0.02345047f, 0.03489795f, -0.03948056f, 0.02613170f, -0.07612082f, -0.00851545f, 0.04259084f, 0.00820984f, 
    0.01625525f, 0.10627711f, 0.01094231f, 0.03326097f, 0.01836659f, 0.05651699f, 0.11496622f, -0.01407471f, 
    0.03359559f, -0.03082785f, 0.15808418f, 0.04180482f, 0.00669781f, 0.06769875f, -0.04003138f, -0.07376581f, 
    0.16251385f, -0.05234398f, 0.07181585f, 0.01985353f, 0.08635688f, -0.02357348f, -0.00401702f, -0.08903930f, 
    0.00458640f, -0.00322338f, -0.04185795f, 0.00907571f, 0.08556241f, 0.27316242f, 0.13646293f, -0.01347071f, 
    0.14506407f, 0.05900099f, -0.11999801f, -0.03044041f, -0.05496623f, 0.03601720f, 0.02627681f, 0.05194388f, 
    0.26743108f, -0.15559365f, -0.09676697f, -0.14407280f, 0.08467598f, -0.06298213f, 0.09773266f, -0.11986461f, 
    -0.09109832f, 0.00733140f, 0.14068602f, -0.11325814f, 0.04460960f, -0.10301415f, -0.14855377f, 0.15646905f, 
    -0.02597234f, 0.05244026f, -0.07414376f, -0.11969652f, 0.04684851f, 0.10895522f, 0.10543450f, 0.04945259f, 
    0.05572302f, 0.00817694f, 0.02147380f, -0.15475838f, 0.00183166f, -0.07146303f, 0.07474132f, 0.08628803f, 
    -0.02187029f, 0.02452561f, -0.07932445f, -0.03835449f, -0.11678809f, 0.08155900f, 0.07164945f, 0.11371586f, 
    -0.15278202f, 0.06250001f, 0.11430480f, -0.09017072f, 0.00742634f, -0.04122660f, 0.05777923f, 0.01413712f, 
    -0.02263097f, 0.01600782f, -0.07632572f, 0.05926314f, -0.01041666f, 0.10433985f, -0.03427432f, 0.03863620f, 
    -0.05587539f, -0.01581560f, 0.06265175f, 0.00172903f, -0.14329523f, -0.02540567f, 0.17602535f, 0.26269731f, 
    -0.09116994f, -0.06447688f, 0.06810621f, 0.10118049f, -0.00650134f, -0.00996189f, 0.03913014f, 0.01341396f, 
    0.02034209f, 0.05625974f, -0.04181937f, 0.05937368f, -0.04536958f, -0.19160308f, -0.05604196f, -0.01301917f, 
    0.06032136f, -0.00872666f, -0.01025275f, 0.06043157f, 0.29142758f, 0.04528473f, 0.00973912f, -0.06188228f, 
    -0.06967300f, -0.00119611f, 0.06996510f, 0.08474097f, -0.01523112f, 0.16542169f, 0.12312397f, 0.05213916f, 
    0.08570000f, 0.12542684f, -0.07593030f, 0.04696285f, 0.01748821f, -0.16684955f, -0.04389181f, -0.00573333f, 
    -0.06152344f, -0.08454344f, 0.02187481f, -0.07797435f, -0.26461592f, -0.06738278f, 0.06484284f, 0.16752899f, 
    0.09427504f, -0.05276592f, -0.12335101f, -0.14682057f, 0.01788613f, 0.09105147f, 0.11849219f, -0.12628448f, 
    0.33907008f, 0.00512539f, -0.16261388f, -0.08245713f, -0.00386984f, -0.03892431f, 0.01331650f, -0.00644854f, 
    0.01412995f, -0.03305073f, 0.00030832f, -0.08519790f, 0.12567326f, 0.21868743f, -0.02457564f, 0.03828513f, 
    0.05301421f, -0.13309439f, 0.07771187f, 0.14340439f, -0.03109927f, 0.07273105f, -0.06024650f, -0.01648645f, 
    0.04434160f, 0.23866984f, -0.00955925f, 0.09685755f, -0.01009151f, 0.00393153f, -0.01774717f, 0.00485736f, 
    -0.01669601f, 0.07385977f, 0.00033725f, -0.10268312f, -0.06285857f, 0.17581871f, 0.09904123f, 0.18259500f, 
    0.13502330f, -0.03305119f, -0.11341987f, 0.01411871f, 0.03341901f, -0.10503256f, -0.03217552f, 0.16063686f, 
    0.00723833f, 0.03137083f, -0.03845174f, -0.15207325f, 0.11601362f, 0.00452439f, -0.05499875f, 0.11298580f, 
    0.04886485f, 0.01739338f, -0.03598259f, 0.04596752f, 0.41110012f, 0.21281600f, 0.01538883f, -0.05463830f, 
    0.04135453f, 0.09514230f, -0.04238325f, 0.00101564f, 0.03080659f, -0.01112334f, -0.04028629f, -0.01882944f, 
    0.14790304f, -0.09445240f, -0.09935702f, 0.13869792f, 0.04138879f, 0.04999238f, 0.09218056f, 0.01613721f, 
    -0.04280687f, -0.02195626f, 0.11160564f, 0.06027382f, -0.16051753f, 0.08026917f, 0.06010366f, -0.01276459f, 
    -0.06119819f, 0.04095146f, 0.02074786f, -0.01390036f, 0.14300752f, -0.07264062f, -0.02806937f, -0.05998604f, 
    -0.04090049f, -0.02172432f, -0.01906660f, -0.05074494f, -0.01284149f, -0.00306291f, -0.04303371f, 0.00563274f, 
    -0.04630027f, -0.03619377f, -0.00484360f, -0.05549832f, -0.04119289f, -0.04128647f, -0.02113005f, -0.05195345f, 
    -0.04980765f, 0.03672032f, -0.01344732f, -0.02330326f, 0.02214767f, -0.03863322f, 0.01984387f, -0.04618052f, 
    -0.02722738f, -0.03769582f, -0.03835137f, -0.02917979f, 0.04508908f, 0.02704593f, -0.04961731f, 0.02448408f, 
    0.01910770f, -0.03159016f, 0.04153380f, -0.04903844f, -0.02026612f, -0.02338050f, 0.02474894f, -0.04050795f, 
    -0.01708250f, 0.02296235f, -0.05488168f, -0.02664509f, -0.03325432f, 0.00890233f, -0.01247586f, 0.02685302f, 
    0.00062526f, 0.03673351f, -0.00371025f, -0.03873235f, 0.00867167f, 0.02496270f, 0.01870229f, -0.00169868f, 
    -0.05170372f, 0.04331751f, -0.00221498f, -0.01558763f, 0.00411843f, -0.04896996f, 0.00009778f, -0.01133472f, 
    -0.02644914f, 0.03629729f, 0.03732773f, 0.03872067f, 0.04229649f, 0.01510950f, 0.02545931f, -0.02338868f, 
    -0.02510978f, -0.03136734f, -0.02963748f, 0.02463629f, -0.00743878f, -0.00734803f, 0.00815849f, -0.02062010f, 
    0.00312496f, -0.00423244f, -0.01087996f, 0.01235233f, -0.00111843f, -0.03497588f, 0.03797006f, 0.00065136f, 
    -0.04702765f, 0.03999384f, 0.03632552f, 0.01018297f, -0.02283042f, -0.03299618f, 0.02615402f, 0.01651767f, 
    -0.00014223f, 0.03857816f, 0.00393724f, -0.01827897f, -0.03273923f, 0.00115225f, 0.01773254f, 0.02917604f, 
    -0.02572396f, -0.00884250f, -0.01037805f, 0.04337557f, 0.03213982f, 0.02582018f, -0.00854579f, -0.03413023f, 
    0.00158578f, 0.01742039f, 0.03435927f, -0.00135533f, 0.00281720f, -0.02771696f, -0.05108631f, -0.01846563f, 
    -0.05030741f, -0.03438120f, 0.01358519f, -0.05556129f, 0.04036781f, 0.03536692f, -0.00477052f, -0.03444301f, 
    -0.02335306f, -0.02973876f, -0.03967655f, 0.00369116f, -0.02652038f, -0.02170305f, 0.00304605f, 0.01117049f, 
    -0.02207608f, -0.02754139f, 0.00260293f, 0.01006207f, 0.03758756f, -0.01357896f, -0.04860658f, -0.03539025f, 
    -0.04839736f, 0.03284872f, -0.00165881f, -0.02482893f, -0.01919265f, 0.03927970f, -0.00853850f, -0.00827453f, 
    -0.01984085f, -0.02524939f, 0.00415477f, -0.00567701f, 0.02301786f, -0.03431759f, 0.00715145f, 0.02047632f, 
    -0.01586391f, -0.01285121f, 0.01864621f, -0.00704703f, -0.03183575f, 0.03853245f, 0.03528455f, -0.04271321f, 
    0.02140643f, 0.02966685f, 0.03595328f, -0.02865357f, -0.05461430f, -0.03006685f, 0.03911962f, 0.03950375f, 
    -0.04842484f, 0.04124941f, 0.01202523f, -0.01259791f, -0.05198179f, 0.04213972f, -0.02723017f, -0.03489353f, 
    0.03736245f, 0.00144869f, 0.03978919f, -0.03380414f, 0.03370470f, -0.01707309f, -0.03911408f, -0.01173488f, 
    -0.03951085f, 0.04298805f, -0.05040453f, 0.01098945f, 0.00023027f, 0.00501983f, -0.02412458f, 0.02285597f, 
    -0.00576263f, 0.01762832f, -0.04319815f, -0.03169789f, -0.04333422f, -0.01673532f, 0.00045261f, -0.02976271f, 
    0.03212483f, -0.02899856f, 0.00048050f, -0.04611003f, -0.04289608f, -0.05501490f, -0.00445727f, -0.02925592f, 
    -0.00213924f, -0.02500990f, 0.02359430f, -0.00472700f, -0.04712265f, -0.04930449f, 0.02638010f, -0.03411593f, 
    0.03786514f, 0.00319005f, 0.04398612f, -0.04360558f, -0.05087201f, 0.01209265f, 0.02199032f, -0.05251247f, 
    -0.03387805f, 0.00135300f, 0.01141383f, 0.03099585f, -0.01738155f, 0.03561512f, -0.01118726f, -0.05191043f, 
    0.02062262f, 0.03721420f, 0.02298759f, -0.02500729f, -0.00265245f, 0.03066068f, -0.03500667f, -0.01466293f, 
    -0.03547951f, -0.04751459f, 0.03915237f, 0.03035130f, -0.01949837f, -0.05169951f, -0.03043384f, 0.04462942f, 
    -0.03903234f, 0.02479522f, -0.05017748f, 0.01772911f, -0.01641572f, -0.05434314f, -0.00088116f, 0.00851138f, 
    -0.00646587f, -0.04584732f, 0.04381533f, 0.02183196f, 0.00295264f, -0.04384225f, 0.02674466f, 0.01886999f, 
    -0.01419390f, -0.00913918f, 0.02387908f, 0.04228418f, -0.00771315f, -0.01113462f, -0.04063314f, 0.01025110f, 
    0.03586935f, -0.02384282f, 0.01111260f, 0.01558202f, 0.02999043f, 0.03422150f, -0.03081514f, 0.02578001f, 
    0.00438184f, 0.00013825f, 0.00859569f, -0.03794615f, -0.00511801f, -0.01693296f, -0.01659993f, 0.01505868f, 
    -0.04249630f, 0.03701168f, 0.01931954f, 0.02872186f, -0.02716616f, -0.01461203f, -0.04115750f, -0.05685532f, 
    -0.02992843f, -0.04786744f, 0.03589366f, 0.02602534f, -0.00400220f, 0.00398778f, 0.03783185f, 0.00281894f, 
    0.00337355f, -0.05183455f, -0.01191560f, -0.03760796f, -0.05004533f, -0.05418196f, 0.02139295f, -0.02956232f, 
    -0.00724983f, 0.01416172f, -0.05182268f, -0.02769221f, -0.01166722f, -0.03248639f, 0.00048668f, -0.01069651f, 
    0.01266742f, 0.03184573f, 0.00036409f, -0.03881851f, -0.01829853f, -0.00697543f, 0.00772853f, 0.00888255f, 
    -0.03698824f, 0.00340521f, -0.03092476f, 0.03574663f, 0.00475407f, -0.04119640f, -0.02027655f, -0.01441171f, 
    -0.04136847f, -0.05276548f, 0.01926360f, 0.00507377f, -0.05419148f, -0.04518572f, 0.03105538f, 0.03843378f, 
    -0.03478432f, 0.00058611f, -0.02123328f, -0.03981528f, -0.03999031f, -0.02431174f, 0.03955926f, 0.00839986f, 
    0.01429920f, 0.01229017f, -0.02994116f, 0.03585874f, -0.00791271f, -0.01952715f, -0.04211792f, -0.00593670f, 
    0.01012495f, -0.03218694f, 0.04251493f, -0.02710215f, -0.05175177f, -0.03614474f, 0.01933838f, 0.02201172f, 
    -0.03158014f, 0.01036886f, -0.04500831f, 0.00918694f, 0.04236354f, 0.00360201f, -0.04488989f, 0.03462588f, 
    0.01820131f, 0.01640256f, -0.05115325f, -0.02576606f, 0.02648896f, -0.05389309f, 0.02301672f, -0.03314792f, 
    -0.05374491f, -0.05837165f, 0.00975867f, -0.01407258f, 0.03691074f, -0.01241491f, 0.03443049f, -0.02842039f, 
    -0.04732072f, -0.05003516f, -0.02671878f, 0.03265312f, -0.02760081f, -0.00576060f, -0.03205901f, -0.04967907f, 
    -0.02305521f, -0.01408425f, -0.05498930f, 0.03901913f, -0.04229930f, 0.00980595f, -0.00787780f, -0.02943666f, 
    -0.03026450f, 0.01751233f, -0.06324559f, 0.00234378f, 0.03204233f, -0.04365993f, -0.03149257f, -0.00824026f, 
    0.02256686f, 0.03219446f, -0.05049058f, -0.01109751f, 0.00853870f, -0.02038698f, 0.00651480f, -0.05065650f, 
    -0.04690363f, -0.00135861f, -0.00003744f, -0.00404374f, 0.02499062f, -0.00891406f, -0.00914849f, -0.01709554f, 
    0.02141920f, 0.02461475f, -0.03063593f, 0.00582809f, -0.02097200f, -0.04787302f, -0.00243767f, 0.01048570f, 
    0.02932590f, -0.04495623f, -0.00816165f, 0.00120081f, -0.00307008f, -0.03569524f, -0.02571757f, -0.01247732f, 
    0.02822610f, 0.00637527f, 0.03462144f, 0.03315382f, 0.01421764f, -0.05820506f, 0.03787384f, -0.06502987f, 
    -0.01126508f, 0.03033160f, -0.02662278f, 0.00420271f, 0.00681385f, 0.01183852f, -0.01615596f, 0.00421529f, 
    0.02692946f, 0.00066514f, -0.04525797f, -0.00095136f, 0.03530235f, -0.01854107f, 0.02652820f, 0.00560936f, 
    0.00086714f, -0.01157512f, 0.02660083f, -0.04604343f, -0.01539516f, -0.04281726f, -0.00796019f, 0.02181155f, 
    -0.01907041f, 0.02583111f, -0.04867529f, -0.00310076f, 0.03752699f, -0.04383001f, -0.00816611f, -0.04947790f, 
    -0.01718198f, -0.04217362f, -0.04386914f, 0.02549824f, 0.02344297f, 0.00892745f, 0.00275130f, 0.03048241f, 
    0.03759842f, -0.03636333f, -0.04127639f, -0.04571773f, 0.01480924f, -0.02631499f, 0.00385929f, 0.01131795f, 
    0.01702577f, 0.03905883f, -0.04608368f, -0.05670648f, -0.04130710f, -0.03626832f, 0.02337135f, -0.03798858f, 
    -0.04048044f, 0.03751617f, -0.00051871f, -0.02183013f, 0.00511515f, 0.04227005f, -0.04728707f, 0.03129163f, 
    -0.04235963f, -0.04671674f, 0.02935190f, 0.01662376f, -0.00528550f, -0.04052690f, 0.00708419f, -0.03542120f, 
    -0.03531309f, 0.01137862f, -0.02218290f, -0.04761991f, 0.01399354f, -0.00310957f, 0.03675654f, -0.03167326f, 
    -0.00917638f, -0.03306922f, 0.00863239f, -0.03764136f, -0.03412613f, -0.05579066f, -0.02689550f, -0.02541679f, 
    0.01691369f, -0.00826074f, -0.00319247f, -0.01032903f, 0.03356678f, 0.02500779f, -0.03354828f, -0.00397430f, 
    0.03546764f, 0.02481099f, -0.02557142f, 0.02369186f, -0.01215249f, -0.00931151f, -0.00765198f, -0.01258827f, 
    -0.04417231f, -0.03989400f, 0.02442189f, 0.04392884f, 0.03898863f, 0.00446527f, -0.00762758f, 0.02703026f, 
    0.03197789f, -0.05487298f, 0.03490986f, 0.03248448f, -0.04175536f, 0.00886150f, -0.05898156f, -0.04273305f, 
    0.02909930f, -0.04188333f, -0.00937149f, 0.02720611f, -0.04643276f, 0.00915887f, -0.02296870f, -0.02214995f, 
    0.03130871f, -0.05031421f, -0.02857375f, -0.05165905f, -0.01304687f, 0.00578869f, -0.00603751f, -0.06296621f, 
    -0.06183764f, 0.02226353f, 0.01905336f, 0.03435384f, 0.03314687f, -0.05685850f, 0.03319913f, 0.02509245f, 
    0.00696158f, 0.01710770f, 0.00957414f, -0.03209385f, -0.04085382f, -0.00549476f, -0.02095538f, 0.04158320f, 
    0.02449695f, -0.04973768f, -0.04965170f, -0.00986401f, -0.00394796f, -0.01949327f, 0.00031242f, -0.04900705f, 
    0.01864295f, 0.01754540f, -0.04873697f, -0.03450971f, 0.02236910f, 0.01146856f, 0.01608323f, -0.03789439f, 
    -0.03006207f, -0.00540724f, -0.03630535f, 0.02006000f, 0.01751957f, -0.01370909f, -0.00837008f, 0.03678140f, 
    -0.00936138f, -0.01564286f, -0.03767312f, 0.03976683f, 0.01304105f, -0.00297007f, 0.04393794f, 0.03995655f, 
    -0.05828929f, 0.00711023f, 0.01356657f, -0.02206377f, -0.01876528f, -0.05410817f, -0.03900897f, -0.04442244f, 
    -0.02524679f, -0.02525058f, 0.00808647f, 0.03306333f, -0.05055413f, 0.02646532f, -0.03039702f, -0.03538733f, 
    0.02050384f, -0.01581399f, -0.00246740f, 0.03017295f, -0.02828172f, 0.01620701f, -0.02857328f, -0.03289749f, 
    -0.03162666f, 0.01163293f, -0.01300373f, -0.04097869f, -0.03517164f, 0.01950879f, -0.05808856f, 0.02963581f, 
    0.00057760f, -0.05035488f, -0.05731580f, 0.01295722f, 0.00581020f, 0.01550994f, 0.00504031f, 0.02368521f, 
    0.02539493f, 0.00900626f, -0.00895102f, -0.00986867f, -0.04946282f, 0.04057087f, -0.03636177f, 0.02190402f, 
    0.00275183f, 0.00359263f, -0.00912170f, -0.03455565f, 0.01239291f, 0.00843284f, 0.01737105f, -0.04696506f, 
    -0.00860357f, -0.02651312f, 0.00750288f, 0.00266045f, 0.03240467f, -0.00925269f, 0.04091304f, 0.03597086f, 
    -0.05472605f, -0.02473441f, -0.00742143f, -0.00786512f, -0.00509497f, -0.01259055f, 0.03183383f, -0.03851788f, 
    0.00841012f, -0.04464211f, -0.01222407f, 0.00064616f, 0.04086204f, -0.05353291f, 0.01034930f, -0.05412121f, 
    -0.00637178f, 0.03327984f, 0.00407458f, 0.03469085f, -0.01239630f, 0.03001720f, -0.03056209f, 0.04124779f, 
    -0.00316314f, 0.03414143f, -0.01393973f, 0.00524841f, -0.02261609f, 0.02562296f, 0.03087141f, -0.05804884f, 
    -0.00521308f, -0.00021831f, -0.02462634f, -0.04850097f, 0.02738735f, 0.01967105f, -0.02214743f, -0.01270640f, 
    -0.04592796f, 0.00981948f, 0.01737798f, 0.02907292f, 0.03308831f, -0.01699497f, 0.04038030f, -0.02258458f, 
    0.03006303f, -0.04360228f, 0.01740930f, -0.05475290f, -0.01174988f, 0.02961121f, 0.00575925f, -0.04954708f, 
    -0.27627760f, 0.16025540f, 0.08006380f, -0.32099119f, -0.03021677f, -0.02647948f, -0.06920950f, 0.09657313f, 
    0.05523410f, 0.05429145f, 0.05405136f, 0.00665736f, -0.07921729f, 0.13509811f, -0.16712524f, 0.10093790f, 
    0.17786640f, 0.03578161f, 0.12582885f, -0.08398276f, 0.10394909f, 0.02824445f, -0.03374871f, -0.11830910f, 
    -0.12645966f, 0.14941405f, 0.03374631f, 0.02780961f, -0.02027090f, -0.08683350f, -0.00965517f, 0.06610899f, 
    0.07639297f, -0.13050996f, 0.08705591f, -0.03935261f, -0.10226812f, 0.16790000f, -0.08266740f, -0.03029448f, 
    -0.04094582f, 0.01125634f, 0.03415764f, 0.03287406f, 0.07478502f, -0.03585096f, -0.00247442f, 0.01040595f, 
    -0.02710450f, 0.25330940f, 0.15684237f, 0.18813138f, 0.11163059f, 0.12581471f, 0.09920609f, 0.07855936f, 
    0.10525923f, 0.02813371f, 0.00168955f, 0.12644763f, 0.04313741f, 0.08185556f, 0.10880686f, 0.20669021f, 
    0.04911114f, 0.08229420f, 0.04461063f, -0.05235871f, 0.04807714f, -0.10083114f, 0.01718741f, 0.01711291f, 
    -0.08883756f, 0.00985070f, -0.11879804f, 0.00011597f, 0.14898501f, 0.04938363f, 0.03020970f, 0.02625977f, 
    -0.06024332f, 0.03518022f, 0.06734433f, 0.03618410f, -0.18792386f, -0.23051807f, -0.17357506f, -0.10609121f, 
    0.12730262f, -0.00348456f, 0.03196337f, -0.07041287f, 0.05545529f, -0.02364141f, -0.00388922f, 0.07935977f, 
    -0.24730527f, 0.18800208f, -0.07356465f, -0.20043889f, 0.10030894f, 0.06967062f, -0.00359180f, 0.06214977f, 
    -0.09992005f, 0.04659899f, 0.02477680f, 0.04436337f, -0.35391963f, 0.10084976f, 0.14051776f, -0.19680429f, 
    0.05051584f, -0.02552182f, -0.07974269f, -0.00945525f, 0.04118576f, -0.08920272f, -0.02401992f, 0.03114029f, 
    0.10291215f, 0.01369061f, -0.03450415f, 0.07577582f, 0.07916692f, 0.09264705f, -0.09000237f, -0.09417085f, 
    -0.12566246f, -0.12024141f, 0.03793318f, 0.08937792f, 0.34304434f, -0.09913438f, 0.17409457f, -0.11666408f, 
    0.04132053f, -0.07101960f, -0.07322540f, -0.05638896f, -0.05247076f, 0.02039807f, -0.00286843f, 0.16388586f, 
    -0.25442401f, 0.26186484f, -0.16022941f, -0.13613895f, -0.01196451f, -0.01574578f, -0.00965488f, 0.06483223f, 
    0.01042745f, -0.08235299f, 0.06487855f, 0.01393605f, -0.25221956f, -0.09017365f, -0.15519445f, -0.00189332f, 
    -0.06501894f, -0.08467172f, 0.04163351f, -0.02013806f, 0.11001539f, -0.06727669f, 0.06027915f, 0.02932174f, 
    -0.20781428f, 0.10541333f, 0.21951137f, 0.09828568f, 0.11694185f, 0.16593909f, -0.01220741f, 0.13722624f, 
    0.06889524f, 0.03919156f, 0.01382385f, 0.05193686f, -0.03597355f, 0.13307977f, 0.10544104f, -0.00961032f, 
    -0.02385494f, -0.01314293f, 0.01278354f, 0.06297905f, -0.02543635f, 0.02238464f, 0.01088503f, 0.15577637f, 
    0.05552090f, -0.10520425f, -0.02679914f, 0.10354872f, 0.15720202f, 0.05101353f, -0.06758904f, -0.17584199f, 
    -0.02206295f, 0.01960511f, 0.04177053f, 0.11622991f, 0.20065086f, -0.13862686f, 0.00912694f, 0.06573682f, 
    0.08199975f, -0.00917424f, -0.13582979f, 0.06835571f, -0.01291370f, 0.08724377f, 0.00459337f, -0.06787912f, 
    -0.18108425f, -0.01304576f, 0.21281506f, -0.20014612f, 0.05850713f, 0.00712039f, -0.06591821f, -0.06638042f, 
    0.18558936f, -0.04054936f, 0.07579531f, 0.03899949f, -0.15255237f, 0.01529491f, -0.20608838f, -0.05016870f, 
    0.13553153f, 0.04704755f, -0.03091243f, 0.02450697f, 0.01355477f, 0.03235557f, -0.03670738f, 0.07849348f, 
    0.18570916f, 0.02529407f, 0.01743731f, 0.12815617f, -0.01392149f, 0.07604313f, 0.02101899f, -0.02403014f, 
    -0.01393731f, 0.07126691f, 0.10234351f, 0.11254518f, -0.04711233f, 0.04174496f, 0.18490942f, 0.08358623f, 
    0.06340323f, 0.07230285f, -0.12029964f, -0.09071375f, -0.00690905f, -0.03190519f, -0.11912984f, -0.01868455f, 
    0.02357151f, -0.18235570f, -0.00971730f, 0.14779532f, 0.07533152f, 0.06558407f, -0.01103203f, 0.13785344f, 
    0.04384191f, 0.15122350f, -0.02555713f, 0.05206785f, 0.08241817f, 0.04532600f, -0.10486324f, 0.01802752f, 
    -0.06807178f, 0.13556756f, 0.04776108f, 0.03336433f, 0.15565833f, -0.02704627f, 0.03044981f, 0.08915003f, 
    -0.27896172f, 0.09681632f, 0.25232860f, 0.20270479f, 0.18475845f, 0.12742281f, -0.00234176f, -0.09071308f, 
    0.01731918f, 0.03689430f, 0.10452002f, 0.02805505f, 0.08640623f, -0.16693002f, 0.06959995f, -0.11507618f, 
    0.05761705f, 0.07404240f, -0.09647116f, -0.13590251f, 0.07415327f, -0.02471269f, -0.00959992f, 0.08756474f, 
    0.06265946f, -0.28701594f, 0.05385766f, 0.13103344f, -0.06976011f, 0.02608291f, 0.01059172f, 0.05354714f, 
    0.13564824f, 0.05910524f, -0.02619746f, 0.11665083f, -0.19616058f, -0.24588452f, -0.01854023f, 0.06462573f, 
    -0.07677725f, 0.14544208f, 0.13593845f, -0.00390851f, 0.10633285f, 0.08463017f, 0.02760254f, -0.08972196f, 
    -0.30758324f, -0.15391588f, 0.22946203f, 0.19192256f, -0.09809381f, 0.00426161f, 0.10701676f, -0.04169026f, 
    -0.07456144f, -0.08549128f, 0.08864254f, 0.00566051f, 0.02707018f, -0.24039051f, 0.05416692f, 0.03526001f, 
    -0.01595275f, -0.03879406f, -0.06760225f, 0.02268709f, -0.01190803f, -0.01638084f, 0.11759511f, -0.05233450f, 
    -0.32412264f, 0.22104782f, 0.23464745f, -0.20736733f, 0.00912798f, 0.00282892f, -0.05544725f, -0.10221042f, 
    -0.01724941f, 0.04260005f, -0.01769694f, 0.01324956f, -0.15704995f, 0.15225334f, -0.06182271f, -0.09196954f, 
    0.04252473f, -0.00383363f, -0.01896336f, 0.08922818f, 0.06621961f, 0.04129571f, 0.04240984f, 0.10566092f, 
    -0.43459570f, -0.19115414f, 0.15265490f, -0.11030827f, 0.00427496f, 0.02404753f, -0.02215867f, 0.11755223f, 
    -0.05476523f, 0.02643015f, 0.03870989f, 0.07638986f, -0.12856378f, 0.17021689f, -0.14851922f, 0.03406927f, 
    -0.03552388f, -0.10787856f, 0.06568158f, 0.13598129f, 0.03933909f, -0.05709969f, 0.04508090f, 0.03951918f, 
    -0.39221221f, 0.24716780f, -0.10447777f, 0.02735101f, -0.04964876f, -0.07040003f, -0.06786827f, -0.02473261f, 
    0.01996636f, 0.03895887f, -0.02405383f, -0.00746627f, 0.11133959f, 0.12925339f, -0.18174724f, -0.01525027f, 
    0.15626979f, -0.00291511f, 0.02644441f, 0.05630753f, 0.03403057f, -0.07447276f, -0.02964107f, 0.00269055f, 
    -0.20232074f, -0.10695225f, 0.13163052f, -0.02245495f, -0.02395876f, 0.09401132f, 0.01743577f, 0.06757661f, 
    0.06027577f, 0.02037636f, 0.05551212f, 0.12361115f, 0.03215986f, 0.10039252f, 0.07850985f, 0.31434250f, 
    0.00525768f, 0.09339084f, -0.02214105f, -0.05289921f, 0.07231298f, 0.02467856f, -0.02135350f, -0.11619835f, 
    -0.13854404f, 0.08223176f, -0.03019627f, -0.01683821f, 0.05471833f, 0.01371573f, 0.00575455f, 0.09829483f, 
    -0.06054158f, 0.02211126f, 0.04103987f, -0.05672635f, -0.10093009f, 0.01793288f, 0.07992574f, 0.01224190f, 
    0.11333137f, -0.00381041f, -0.01346997f, 0.02440454f, 0.00031087f, 0.04090370f, 0.04689388f, 0.09249821f, 
    -0.39105192f, -0.00045467f, -0.06432360f, 0.01789863f, -0.05412101f, 0.00781118f, 0.02462219f, 0.10095692f, 
    -0.06803885f, 0.02862181f, 0.11912400f, -0.08727535f, -0.30816612f, -0.24261360f, 0.04042891f, -0.04798835f, 
    -0.10630757f, -0.01333507f, 0.01542973f, -0.13638337f, 0.01419213f, 0.03428567f, 0.01771898f, -0.07614936f, 
    0.19313471f, 0.00135043f, -0.01509477f, 0.22963487f, 0.01999036f, 0.00789392f, -0.04705923f, -0.01956909f, 
    -0.06377488f, -0.11530357f, 0.00391157f, -0.01166483f, 0.07319782f, 0.00983202f, -0.04900097f, -0.02048462f, 
    -0.05250556f, 0.08624268f, 0.02096296f, -0.01661287f, 0.04420035f, -0.02454291f, -0.00838041f, 0.09895478f, 
    -0.14629905f, 0.08577245f, -0.21133149f, -0.12739034f, -0.03125662f, 0.00693657f, -0.07097430f, -0.08008228f, 
    0.07080540f, -0.02773317f, 0.03888439f, -0.00599291f, -0.00306266f, 0.18439709f, 0.03639066f, 0.01177155f, 
    0.03362409f, 0.02199615f, 0.08136034f, -0.03765294f, 0.15100214f, 0.05528113f, 0.00079786f, -0.15409040f, 
    -0.17525007f, 0.07760196f, 0.13049167f, -0.01724846f, 0.16016558f, -0.03144914f, 0.08673733f, 0.07748637f, 
    -0.02462105f, 0.06035323f, 0.02386479f, 0.10337050f, 0.03956696f, 0.21867043f, 0.10560582f, 0.17233704f, 
    0.00757193f, 0.00632683f, -0.08395025f, 0.00287203f, -0.13439655f, -0.03547979f, 0.05423222f, -0.00357962f, 
    -0.08280664f, 0.08804581f, -0.00405367f, -0.13175108f, 0.10197067f, 0.09524592f, -0.07043358f, -0.05487221f, 
    0.06285733f, 0.03293464f, -0.06082309f, 0.01709899f, 0.14590546f, 0.07636011f, -0.04119331f, 0.00028979f, 
    -0.03964739f, -0.04240188f, 0.03642645f, 0.05645499f, -0.00275679f, 0.15903796f, -0.06135169f, -0.01294806f, 
    -0.50815082f, -0.08521318f, 0.04342562f, -0.07594439f, -0.07082348f, 0.00993975f, -0.07946785f, 0.03698217f, 
    0.07464273f, -0.13436970f, 0.14016239f, 0.06091095f, -0.18907440f, -0.00845731f, 0.01046062f, 0.22066021f, 
    0.00413124f, 0.03723354f, 0.08612031f, 0.12115533f, -0.00488211f, 0.01765144f, 0.07716605f, -0.04566382f, 
    0.26735580f, 0.10122906f, 0.03567103f, 0.19701681f, -0.03361731f, -0.02047709f, 0.08200128f, -0.01736461f, 
    0.10075713f, -0.04054376f, 0.11443433f, 0.11829334f, -0.12541904f, -0.17174232f, -0.01101981f, -0.01936953f, 
    -0.01662914f, 0.13550127f, 0.10101732f, -0.04985269f, -0.05103601f, 0.01088411f, 0.05317379f, 0.01776258f, 
    0.10588320f, -0.07218083f, 0.20760208f, 0.07015153f, 0.00639399f, 0.02431505f, 0.01063007f, 0.05510249f, 
    -0.07557924f, 0.05255266f, -0.05163215f, 0.04132861f, 0.01989749f, -0.01764510f, -0.04220734f, 0.16498305f, 
    0.09277154f, -0.04973995f, -0.01652130f, 0.10190811f, -0.07892874f, 0.07411171f, 0.03505166f, -0.02136068f, 
    -0.20681550f, -0.07129115f, 0.10113843f, -0.06668419f, -0.08308613f, -0.03689254f, 0.03870884f, 0.03312327f, 
    0.11248455f, 0.07371527f, 0.02123613f, -0.04247300f, 0.12448463f, 0.14490165f, -0.14122257f, -0.09150256f, 
    0.08327629f, -0.00717815f, 0.00552138f, -0.05439061f, 0.09286021f, 0.03954250f, 0.00283998f, 0.03482949f, 
    0.00533156f, -0.00220483f, 0.13387498f, 0.16715358f, -0.05131216f, 0.05201644f, -0.01902537f, 0.03115010f, 
    0.07408794f, 0.08457158f, 0.02679028f, -0.07481249f, 0.01959059f, -0.00284219f, 0.01664603f, 0.18235098f, 
    -0.02866153f, 0.00898592f, 0.03746911f, 0.03585333f, 0.03123930f, 0.07935677f, 0.03970426f, 0.03940573f, 
    -0.15381925f, 0.05599975f, 0.09026360f, 0.03219674f, 0.06519638f, -0.05431519f, 0.15565912f, 0.04002984f, 
    -0.06754645f, 0.05529805f, 0.04256196f, 0.05761002f, 0.48879540f, 0.20642495f, -0.16597012f, -0.17277800f, 
    0.03139861f, 0.02689300f, 0.03446000f, -0.02810672f, -0.00936653f, -0.00959958f, 0.07636186f, -0.09541053f, 
    -0.25685400f, -0.15215428f, -0.16081625f, -0.03858334f, -0.06663776f, 0.03965091f, -0.00175517f, -0.06174972f, 
    -0.03565534f, -0.06203370f, 0.01769669f, -0.00557979f, -0.27351117f, -0.03990860f, -0.05764967f, 0.05567147f, 
    0.05899682f, 0.01110935f, 0.05137508f, 0.01984705f, -0.00718532f, -0.03190047f, 0.02703631f, -0.02311390f, 
    0.13728496f, 0.02236088f, 0.40397194f, -0.13614362f, -0.04703269f, -0.01902734f, 0.07345814f, -0.05667020f, 
    0.01328516f, 0.16610973f, 0.02650372f, 0.04435988f, 0.04219614f, 0.05448582f, -0.11621245f, 0.07155821f, 
    0.03244431f, 0.01106480f, 0.01903515f, -0.02971392f, 0.08867595f, 0.11141116f, -0.05478658f, -0.04901123f, 
    0.18893301f, -0.03753748f, 0.12279490f, 0.11250748f, 0.01509206f, 0.10703571f, 0.06846833f, 0.11244655f, 
    0.11227074f, 0.02566427f, 0.11465523f, -0.08101777f, -0.18731485f, -0.00020476f, 0.03930788f, 0.16951814f, 
    -0.01942512f, 0.04096210f, -0.02982670f, -0.05651733f, -0.09552711f, 0.07224724f, 0.02136241f, 0.04547706f, 
    0.12077508f, 0.03671413f, -0.02651347f, 0.07167555f, -0.06821603f, 0.03138328f, 0.03577643f, 0.21211660f, 
    -0.05903281f, 0.00969430f, 0.13738111f, 0.06571555f, 0.01548651f, -0.00603301f, 0.26882905f, -0.15681940f, 
    0.10769806f, 0.05618899f, -0.02437833f, -0.05161482f, -0.01006026f, -0.06321745f, 0.00452413f, 0.00775030f, 
    0.01042216f, -0.05295008f, -0.21084780f, 0.13653842f, -0.04479709f, 0.04832429f, 0.01846882f, 0.01950578f, 
    0.05870441f, -0.06225134f, 0.10116043f, 0.08318210f, 0.08878639f, -0.17471117f, -0.13225992f, -0.30947676f, 
    0.05223724f, -0.06714072f, 0.01677855f, -0.00162469f, 0.05965449f, -0.09000151f, 0.07369051f, 0.16489309f, 
    -0.03575999f, 0.00866263f, 0.10394573f, 0.24569687f, -0.05206100f, 0.09225535f, 0.06914709f, 0.05682159f, 
    -0.05733610f, 0.05233934f, 0.06598526f, 0.10895152f, 0.06065790f, 0.04933797f, 0.01282216f, -0.01371513f, 
    -0.03588936f, 0.02211923f, 0.00998722f, -0.02085026f, -0.06048473f, 0.01941791f, 0.07111534f, 0.11665177f, 
    -0.18293151f, -0.15469193f, 0.03193506f, -0.04123413f, -0.05554834f, -0.06707133f, 0.00354220f, 0.08425638f, 
    0.00239067f, 0.02180983f, 0.05440696f, 0.05294240f, -0.07938412f, 0.13325647f, -0.03255624f, 0.21284236f, 
    -0.00775955f, -0.00266043f, -0.04075174f, -0.08579673f, 0.03243032f, 0.05048114f, 0.04210244f, 0.04541435f, 
    -0.06245186f, -0.06442802f, 0.21295357f, 0.04734780f, -0.13235518f, -0.02500640f, -0.00155563f, 0.07888144f, 
    0.09385359f, -0.04672441f, 0.07899734f, -0.03943454f, 0.11986500f, -0.15271421f, 0.19589195f, -0.14991826f, 
    -0.03846054f, -0.08842602f, -0.01393811f, -0.01243415f, -0.06289185f, 0.01897274f, -0.01538019f, -0.06951463f, 
    0.00005607f, 0.03257912f, -0.03171730f, 0.06919923f, -0.05143819f, 0.11246786f, -0.02092597f, 0.14563408f, 
    0.03930216f, 0.04051647f, -0.06341029f, 0.04142313f, 0.10265220f, 0.09800632f, 0.11067817f, -0.23385653f, 
    0.12906700f, -0.09881752f, 0.10470935f, -0.04160652f, 0.02055204f, -0.04648444f, -0.05511040f, -0.01642512f, 
    -0.03554476f, 0.14606316f, 0.03778578f, 0.10832133f, -0.07754094f, -0.03184471f, -0.00900014f, -0.03183717f, 
    -0.03687988f, 0.09047623f, 0.05015896f, 0.10398431f, 0.22972487f, 0.20311315f, -0.21127024f, 0.04318591f, 
    0.00354675f, -0.06160318f, 0.03081631f, -0.01735692f, 0.01615859f, -0.00098717f, -0.01135690f, 0.03102881f, 
    -0.04951962f, -0.03612692f, 0.02321654f, 0.15427339f, -0.04970212f, 0.07224961f, 0.01908558f, -0.02720958f, 
    0.01247802f, 0.03279096f, 0.04601014f, -0.07096455f, 0.23816665f, -0.20580368f, -0.14212912f, -0.24380875f, 
    0.08522413f, 0.10247412f, -0.04934837f, -0.01623496f, 0.13994655f, 0.05507126f, -0.01889879f, 0.05586809f, 
    -0.18625763f, -0.07019065f, -0.04635539f, 0.11806563f, 0.00511781f, -0.00202409f, 0.12277920f, 0.02435807f, 
    0.10207644f, 0.19819050f, -0.06126451f, -0.06196079f, 0.23823784f, -0.01295939f, -0.09990158f, 0.18163265f, 
    -0.04354580f, -0.00061091f, 0.08985643f, -0.06623831f, -0.06384497f, -0.05324280f, -0.07773161f, -0.05780078f, 
    -0.14972810f, -0.07521956f, -0.05298115f, -0.22714314f, -0.06695058f, 0.03032467f, -0.01917166f, 0.07856797f, 
    0.06949401f, 0.16984808f, 0.01042334f, 0.14049958f, -0.05690913f, -0.05329521f, 0.00796891f, -0.13101748f, 
    -0.06120525f, 0.07352035f, 0.05954083f, 0.06539565f, -0.03854056f, 0.01406458f, 0.00947164f, 0.04696682f, 
    0.00262178f, 0.07509556f, -0.00553609f, 0.13114144f, -0.01247145f, 0.05496655f, 0.00262823f, 0.04269259f, 
    -0.11070885f, 0.01775820f, 0.01212436f, 0.03921422f, -0.02488889f, 0.00076957f, 0.09869202f, 0.09874848f, 
    0.03265031f, 0.02232524f, 0.01777554f, -0.16523683f, 0.09492215f, 0.09306924f, 0.05564752f, 0.01543734f, 
    -0.06826958f, 0.04137772f, -0.04590380f, -0.06995597f, 0.00523023f, 0.12393446f, -0.02676664f, 0.10176457f, 
    0.12068709f, 0.05550571f, 0.05505571f, 0.10562430f, -0.08605546f, -0.21375741f, -0.08774189f, -0.12452991f, 
    -0.05354610f, 0.04927052f, 0.07011922f, -0.00603212f, 0.02171014f, 0.03477011f, 0.05539908f, -0.03187262f, 
    -0.14194208f, 0.11883470f, 0.14747988f, -0.21608838f, 0.02176064f, 0.14143415f, -0.01621284f, -0.04599720f, 
    0.04801638f, -0.10472451f, 0.11919088f, 0.02337347f, -0.05188686f, -0.13181792f, 0.20983976f, 0.04513124f, 
    -0.04846212f, 0.02386542f, 0.10413440f, 0.01675055f, -0.06315165f, 0.09279940f, 0.06275017f, 0.03891573f, 
    0.00444633f, -0.09527466f, 0.08459841f, 0.08661564f, 0.02524426f, -0.01836334f, -0.01785531f, -0.10334118f, 
    0.05153031f, -0.04626230f, 0.01245968f, 0.08326746f, 0.36285338f, -0.17618319f, -0.09804609f, 0.07882355f, 
    0.03121472f, 0.03366865f, -0.06256129f, -0.06707818f, 0.04522817f, 0.07926457f, 0.06638955f, 0.08715653f, 
    -0.08435348f, 0.08255756f, -0.00716362f, -0.10730550f, -0.07833436f, 0.06831097f, -0.05464778f, 0.09918999f, 
    0.06843983f, 0.04965338f, -0.08282749f, -0.08445974f, 0.07437014f, 0.10889614f, 0.10396678f, 0.07162487f, 
    0.09556897f, 0.07908601f, -0.00922625f, -0.06696301f, -0.02523007f, -0.06638269f, 0.21552292f, -0.03328303f, 
    -0.20637009f, 0.03322078f, -0.13894626f, 0.04089053f, -0.06881812f, -0.01967049f, -0.00976879f, -0.01459889f, 
    0.04763050f, 0.16649064f, -0.06607884f, 0.23170702f, 0.37039962f, -0.01908614f, -0.01015981f, 0.33109808f, 
    -0.02370928f, 0.06917511f, 0.00539141f, 0.03643692f, 0.08501005f, 0.00028776f, -0.02666889f, 0.00292606f, 
    -0.21103287f, 0.04693284f, -0.00805907f, 0.14364983f, 0.02322671f, -0.02494217f, -0.07714129f, -0.02975274f, 
    0.02849875f, -0.00414152f, -0.03588503f, -0.10340177f, 0.09074064f, 0.07969192f, 0.04888638f, 0.20938002f, 
    0.04893861f, 0.04647668f, -0.07542268f, -0.02807030f, -0.03835306f, -0.01725986f, 0.03372728f, 0.10402988f, 
    0.12064320f, 0.01047930f, 0.22681861f, -0.10464226f, -0.03392438f, -0.05146659f, -0.02277420f, -0.00670489f, 
    0.01028351f, 0.25067535f, -0.00250875f, -0.03505980f, -0.27794403f, -0.00045916f, -0.17390020f, -0.18668193f, 
    0.04055395f, 0.07643795f, 0.00702488f, 0.04784064f, 0.11569674f, 0.00479069f, -0.03074547f, -0.03166883f, 
    0.10510104f, 0.03419912f, -0.14818335f, -0.18233247f, -0.10575656f, -0.15517046f, 0.03697775f, 0.10903824f, 
    -0.01244215f, -0.08239888f, -0.03662630f, -0.10802927f, -0.04363236f, 0.02654771f, 0.13265099f, -0.13760923f, 
    -0.05284546f, -0.06239821f, -0.01162936f, 0.04910813f, 0.10762481f, -0.04330566f, -0.03012243f, -0.29726884f, 
    -0.09105852f, 0.00533252f, -0.03026029f, 0.05479436f, -0.06863960f, 0.05092131f, 0.11107291f, -0.02030039f, 
    0.15861714f, -0.14065181f, -0.01919711f, -0.14041728f, -0.04409328f, -0.14593966f, 0.14308199f, -0.02855249f, 
    -0.07080592f, 0.04295071f, 0.07265324f, 0.02101227f, -0.04299628f, -0.05158355f, 0.14071369f, 0.14822342f, 
    -0.15696955f, 0.09985461f, -0.11927657f, 0.12019909f, -0.10983648f, -0.05224835f, 0.01087824f, 0.04730162f, 
    -0.16775298f, -0.02166186f, 0.03469014f, -0.17264184f, 0.12719651f, 0.11658930f, -0.08638407f, 0.06929537f, 
    -0.09096557f, 0.21069658f, -0.03317620f, 0.13592835f, 0.08223461f, 0.12643151f, 0.07910295f, 0.16596949f, 
    -0.00486237f, 0.18956500f, 0.12239993f, 0.15789561f, 0.10881876f, -0.06540640f, 0.11329187f, -0.00601782f, 
    0.04333983f, 0.04948449f, 0.15962254f, 0.25558576f, 0.11620855f, 0.11882812f, 0.08175985f, 0.14074272f, 
    -0.02357749f, 0.09446790f, -0.19443963f, 0.09900013f, 0.00120883f, -0.07059381f, 0.03964550f, 0.06221160f, 
    0.02400504f, -0.10462943f, 0.04066578f, 0.05121042f, 0.15312217f, 0.05307097f, 0.04539924f, -0.04253064f, 
    0.00635795f, 0.04858484f, -0.05290422f, 0.10741513f, -0.01153988f, -0.06490628f, 0.02616384f, -0.06929842f, 
    0.05655308f, 0.00838593f, -0.00671521f, 0.03182089f, -0.08076628f, 0.09426049f, 0.16247021f, 0.13963273f, 
    0.00633609f, -0.00781352f, -0.00367601f, -0.04838573f, 0.00549788f, -0.17755465f, 0.04542770f, -0.05449210f, 
    0.05044103f, -0.00097101f, -0.07147768f, 0.01840317f, -0.16865759f, 0.15825948f, -0.00349207f, -0.11918291f, 
    -0.01878321f, 0.08836749f, 0.04180242f, 0.02216990f, -0.11776607f, 0.01658919f, 0.16751458f, 0.04543759f, 
    0.14740485f, 0.11801776f, 0.13056843f, -0.02627845f, -0.00314614f, 0.02963076f, -0.08485051f, 0.07883155f, 
    -0.03588758f, -0.06250570f, 0.20628721f, -0.01964926f, -0.25880662f, -0.00186651f, -0.02462319f, 0.04157593f, 
    0.04193316f, 0.00601171f, -0.12622115f, 0.08722802f, 0.08392604f, 0.09892388f, 0.08872349f, 0.09923463f, 
    -0.19040647f, -0.01165617f, 0.06391335f, 0.04372704f, 0.08831292f, 0.01082379f, 0.02946555f, 0.00332981f, 
    0.01812012f, -0.06511208f, 0.00758836f, -0.12137625f, 0.24309000f, 0.01023566f, -0.10863283f, -0.02703980f, 
    0.07482371f, 0.03837463f, 0.15497035f, 0.21259817f, 0.04294790f, 0.05766197f, -0.09478765f, 0.05950747f, 
    -0.18292625f, 0.07864900f, -0.16718337f, 0.11590335f, -0.08309343f, 0.01111479f, -0.05473486f, -0.04184030f, 
    -0.03811079f, -0.00874630f, 0.03323627f, -0.12499388f, -0.16178441f, -0.24910690f, -0.10246289f, 0.02058155f, 
    -0.05608835f, 0.01676548f, 0.04643587f, 0.08952188f, 0.01843436f, -0.01266725f, -0.05451547f, -0.01434496f, 
    -0.19377436f, -0.13250621f, 0.24010456f, 0.04270727f, 0.13775453f, -0.13835585f, 0.01505802f, 0.01839688f, 
    -0.14812370f, -0.02638333f, -0.08079147f, -0.05454254f, 0.11045667f, 0.06713250f, -0.01165823f, -0.09498525f, 
    -0.15442404f, 0.07786221f, 0.02350483f, -0.13722801f, -0.06568545f, 0.01841441f, -0.12490449f, 0.10855275f, 
    0.50588298f, 0.06021697f, 0.07973795f, 0.24315020f, -0.03783074f, 0.08368756f, 0.12615772f, 0.20717600f, 
    -0.03012543f, 0.10518104f, -0.09174886f, -0.00804596f, 0.28239876f, 0.11737659f, 0.16094342f, 0.12671991f, 
    0.06063173f, -0.07803482f, 0.03132219f, 0.02898115f, 0.01178094f, -0.07175742f, -0.02683210f, 0.07225962f, 
    0.05017861f, 0.19489862f, 0.07774462f, -0.07602366f, -0.20322767f, -0.09460919f, -0.00349666f, 0.05289842f, 
    0.11826200f, 0.04024236f, 0.08537257f, 0.05103222f, -0.03362442f, 0.18888603f, 0.09416810f, 0.13271159f, 
    0.01486671f, -0.04253647f, 0.00339730f, -0.02066950f, -0.03513288f, 0.06135945f, 0.02679587f, -0.05011562f, 
    -0.05513822f, -0.18191777f, 0.10765374f, 0.10627694f, 0.01081471f, 0.09067260f, 0.04141916f, 0.00648764f, 
    -0.02684795f, -0.07149807f, 0.10967737f, 0.02649790f, -0.00378845f, -0.07634840f, -0.27179784f, -0.20652463f, 
    -0.12526576f, -0.12566747f, 0.01479924f, -0.03878371f, -0.12974168f, 0.05694242f, -0.13520291f, 0.03404681f, 
    0.23170187f, -0.08263294f, 0.05616211f, -0.01403127f, -0.03307927f, 0.06876557f, 0.09139430f, -0.07384404f, 
    0.05982533f, -0.13876659f, 0.12694979f, 0.08004708f, -0.03027174f, -0.05101199f, -0.19827650f, -0.05558897f, 
    0.12374618f, -0.00592420f, 0.06980728f, 0.02312479f, 0.12818453f, 0.01255782f, -0.06337012f, -0.08759864f, 
    0.25904322f, -0.23725128f, -0.20677684f, -0.00557795f, 0.01871137f, 0.00184989f, -0.01759198f, 0.07371438f, 
    0.05454222f, 0.10544372f, 0.03534035f, 0.10315896f, 0.07467889f, 0.09169278f, 0.12996770f, 0.09531116f, 
    -0.01480528f, -0.00525019f, 0.10526980f, 0.05104105f, 0.08900446f, -0.01759819f, 0.01801625f, -0.06618633f, 
    -0.18805671f, 0.04441995f, -0.27276406f, 0.10338246f, -0.17480099f, -0.09046592f, 0.03076238f, 0.05883904f, 
    0.10976253f, -0.11362071f, 0.08385145f, 0.07035549f, -0.18390325f, -0.05111187f, -0.06215922f, -0.04303678f, 
    -0.12078428f, -0.09393086f, 0.01532636f, -0.10793516f, -0.02367035f, -0.08150310f, 0.10879787f, 0.02490887f, 
    -0.02031646f, -0.12890176f, 0.35766649f, 0.33296308f, 0.02604569f, 0.04121865f, -0.04542344f, 0.02876480f, 
    0.05444393f, -0.00337664f, 0.13016619f, 0.08063547f, -0.08169182f, -0.07828198f, 0.00205706f, 0.27407378f, 
    -0.03043109f, 0.08339642f, 0.04780517f, -0.03891497f, -0.03322303f, 0.15795121f, -0.05295946f, 0.06864928f, 
    0.16834150f, 0.09229440f, 0.05548380f, -0.05414463f, 0.07432441f, -0.01668873f, 0.01983738f, 0.08291096f, 
    -0.09665152f, 0.05744759f, 0.03740545f, 0.23175216f, -0.02192683f, -0.06956039f, -0.04145361f, 0.17171302f, 
    0.03541043f, -0.06689847f, 0.06597064f, 0.03379494f, -0.00396934f, 0.02876068f, -0.09812672f, -0.05838134f, 
    0.33096439f, -0.12788065f, -0.03926693f, 0.09251639f, -0.04555088f, 0.06754837f, 0.00430815f, 0.06903277f, 
    0.09850013f, 0.00878169f, 0.12656707f, 0.06162753f, 0.00931085f, 0.24147129f, 0.02451222f, -0.04153227f, 
    0.08400931f, -0.05115360f, -0.05656204f, -0.01620885f, -0.01744871f, -0.02263230f, 0.02365014f, -0.03874107f, 
    0.27898893f, -0.04010358f, -0.07200107f, 0.04836378f, 0.04146965f, 0.07295415f, 0.10625953f, 0.18445539f, 
    0.07477067f, 0.05194931f, -0.03777210f, 0.01840147f, 0.15731196f, -0.03188109f, 0.06627093f, 0.01863098f, 
    0.05764698f, -0.03009446f, 0.03100633f, -0.04266622f, -0.06871886f, 0.13387737f, -0.02304121f, 0.01724801f, 
    -0.31183031f, 0.00705604f, -0.12009000f, 0.10272996f, -0.00624959f, -0.00050497f, -0.14510952f, 0.10862068f, 
    -0.00528573f, 0.04405090f, 0.10912696f, 0.00640588f, -0.05023687f, -0.00652112f, 0.00307068f, -0.07467820f, 
    -0.11327129f, 0.03892620f, 0.16229773f, 0.04399831f, 0.01670371f, -0.02517617f, 0.00957901f, 0.01143923f, 
    -0.18565662f, 0.00025786f, 0.08282606f, 0.15450744f, -0.04424613f, 0.10657342f, 0.00063347f, 0.06700667f, 
    0.09377389f, -0.08607244f, 0.18088730f, 0.05016018f, -0.04570744f, -0.08672918f, -0.01208188f, 0.07763997f, 
    -0.08211282f, -0.07334996f, -0.12441730f, -0.03120289f, 0.06523275f, -0.03739036f, -0.06398378f, 0.03124915f, 
    0.03910274f, 0.03690594f, 0.08220132f, -0.12639709f, -0.14692214f, -0.11019173f, 0.09568847f, -0.01793706f, 
    0.12043346f, 0.13958849f, -0.01372397f, 0.05771461f, 0.04880514f, -0.05163521f, 0.11028293f, 0.19526720f, 
    0.05653245f, -0.04012257f, 0.05761609f, 0.01134759f, 0.01776788f, 0.01282810f, -0.01169887f, 0.10716524f, 
    0.05379857f, 0.01650334f, -0.15228692f, -0.17068362f, -0.03893518f, -0.05332465f, -0.00241577f, 0.09482399f, 
    0.13071454f, 0.00753404f, -0.01864082f, -0.01925019f, -0.12355221f, 0.01548116f, -0.04407585f, -0.03587292f, 
    -0.14258978f, -0.17232352f, -0.02287617f, -0.06471105f, 0.02734214f, -0.08248490f, 0.17236508f, 0.08091685f, 
    0.07056841f, -0.10244074f, 0.01363969f, 0.13040715f, 0.00023538f, -0.05652682f, 0.00687303f, 0.09701540f, 
    0.00725104f, -0.00664111f, -0.02958854f, 0.08149522f, -0.07797971f, 0.26282728f, -0.21900098f, -0.05573451f, 
    0.10274837f, -0.03720196f, -0.05235251f, 0.05125670f, -0.03724930f, 0.15974639f, 0.00550774f, 0.10334732f, 
    -0.46378699f, 0.48331293f, -0.17751394f, 0.07464145f, -0.02565229f, 0.09241216f, 0.09547562f, 0.04716152f, 
    0.15649015f, -0.01313611f, -0.03030482f, 0.08409058f, -0.21129753f, 0.22780110f, 0.06522004f, -0.01460761f, 
    0.05733135f, 0.03328200f, 0.06254073f, 0.11592565f, -0.06507351f, 0.01841598f, 0.06526945f, 0.00254388f, 
    -0.40382206f, -0.04955965f, 0.07585891f, -0.02999173f, -0.08878353f, -0.02201098f, -0.00853938f, -0.01819975f, 
    0.04207212f, 0.06254997f, 0.00553941f, 0.04207088f, 0.31887221f, 0.04508691f, -0.15301664f, -0.20217840f, 
    0.01591644f, 0.01446479f, -0.02408788f, 0.12453135f, 0.00095504f, 0.07090220f, -0.04360145f, -0.01668431f, 
    0.00331659f, -0.18755417f, -0.02579134f, 0.21783191f, -0.08828882f, -0.05066793f, 0.01153012f, 0.01035662f, 
    0.01712906f, 0.00390028f, 0.04797158f, 0.02560096f, 0.09130115f, -0.00270906f, -0.06057551f, 0.11570993f, 
    -0.01373311f, 0.03904039f, -0.01000289f, 0.17042588f, 0.04536052f, -0.05574695f, 0.02552157f, 0.08570775f, 
    -0.14272101f, -0.06812934f, -0.08041035f, 0.01153614f, 0.08573324f, 0.04573377f, 0.02423143f, -0.06178636f, 
    -0.00502018f, -0.10674278f, 0.04208117f, 0.08096105f, 0.12510565f, -0.00976027f, 0.00333552f, 0.01982930f, 
    -0.06644788f, -0.04742231f, -0.06489398f, -0.02550773f, -0.07890214f, 0.01245723f, 0.06576413f, -0.05795996f, 
    -0.01369387f, -0.01167392f, -0.03594527f, -0.00448366f, -0.02283476f, -0.04323129f, -0.00188681f, -0.05827811f, 
    0.02622339f, -0.08863300f, 0.00021973f, 0.08177554f, 0.36283892f, -0.07214202f, 0.17461722f, -0.07763921f, 
    0.05973342f, 0.02988708f, 0.11568487f, 0.08900189f, 0.09852377f, 0.03527927f, 0.03460981f, 0.03542908f, 
    -0.16715862f, -0.12794103f, 0.09588821f, 0.19060601f, 0.09756833f, -0.11619716f, -0.08071774f, -0.06355444f, 
    0.15099354f, 0.08348780f, -0.04932334f, -0.05912767f, 0.13433075f, 0.11374268f, -0.06196275f, 0.25876805f, 
    0.00705636f, -0.14512931f, -0.00687688f, 0.00385313f, 0.12253994f, 0.08879038f, 0.11779751f, 0.06023646f, 
    0.06040541f, 0.09113437f, 0.17387524f, 0.02272455f, -0.01113400f, 0.05441884f, 0.10401671f, -0.01853262f, 
    -0.03996557f, 0.17013104f, -0.05946837f, -0.09766088f, -0.15350151f, 0.04168096f, -0.01568072f, 0.04872540f, 
    -0.12525351f, 0.06776763f, 0.01998711f, -0.02967852f, -0.02687335f, 0.12124772f, -0.11101592f, -0.04883026f, 
    0.05102470f, -0.21211216f, 0.00845171f, -0.26556036f, 0.08177608f, -0.05889286f, 0.01425137f, -0.03448166f, 
    0.12719911f, -0.02203321f, 0.01313702f, 0.02215404f, 0.09340787f, 0.29709986f, -0.10987621f, -0.09345999f, 
    -0.02003427f, 0.11359398f, 0.03957679f, 0.10398644f, 0.02213971f, 0.05651992f, -0.06190950f, -0.04300312f, 
    0.28937912f, 0.22143021f, -0.09563682f, -0.05508907f, 0.15158401f, 0.11152771f, -0.00434777f, -0.04027620f, 
    0.00340540f, -0.07105269f, -0.00496301f, -0.00660236f, -0.20789060f, -0.14925835f, -0.03484184f, -0.36419109f, 
    0.09570426f, -0.04819506f, -0.07423705f, 0.08202124f, 0.02278429f, 0.07493033f, -0.04028390f, -0.02551774f, 
    0.01904372f, -0.17123809f, -0.08821437f, -0.16269167f, 0.06973337f, 0.02743970f, 0.00052450f, 0.01233880f, 
    0.04445870f, 0.11157576f, 0.04333890f, 0.10912937f, 0.01552000f, 0.07829991f, -0.14522848f, 0.22356892f, 
    0.02029195f, 0.11355577f, -0.02357849f, -0.00119311f, 0.08701741f, 0.01567001f, -0.00947687f, 0.04139172f, 
    -0.06442224f, 0.09430232f, 0.14977768f, 0.10051847f, 0.01563732f, -0.01307520f, 0.10910702f, -0.07546411f, 
    0.02182546f, 0.01373077f, 0.11617546f, 0.12875196f, 0.23042895f, 0.03518259f, 0.01076585f, 0.40360817f, 
    0.02400960f, 0.03995423f, 0.01342665f, 0.05228303f, -0.04461927f, 0.05132546f, 0.06154747f, 0.03876822f, 
    -0.17826499f, -0.16622135f, -0.11682288f, -0.06237417f, 0.02081458f, -0.00956562f, -0.03394733f, 0.14463204f, 
    0.10789114f, 0.02267626f, 0.06796521f, -0.01469630f, 0.03399298f, -0.07268274f, 0.06144049f, -0.18233582f, 
    -0.04294372f, 0.02836462f, 0.09754315f, 0.04038986f, 0.04047747f, 0.04978682f, 0.11103529f, 0.03940580f, 
    -0.04073988f, -0.00504785f, 0.05634495f, -0.16055749f, 0.12502395f, -0.01973393f, 0.04489703f, 0.07125138f, 
    0.08981280f, 0.02273956f, 0.00633727f, 0.12503093f, 0.06838206f, 0.06005768f, 0.02559320f, 0.11623351f, 
    -0.13094352f, -0.05185580f, 0.11488514f, -0.01163603f, -0.04571021f, -0.03679625f, 0.04017423f, -0.01214956f, 
    0.24996024f, 0.14646798f, 0.10022061f, -0.04378287f, -0.02829673f, 0.00918074f, -0.08475069f, 0.05650254f, 
    -0.01712249f, -0.02880020f, 0.08018073f, -0.03107162f, -0.36108398f, 0.05590628f, 0.06656977f, -0.17515886f, 
    0.07634707f, 0.04644600f, -0.03942729f, 0.05080384f, 0.11797624f, -0.00835043f, 0.08991268f, 0.12694886f, 
    0.10533124f, -0.10269102f, 0.08333742f, 0.19276324f, 0.15944158f, 0.04570797f, 0.04505624f, -0.07760894f, 
    -0.00816046f, 0.02883048f, 0.05798829f, -0.11416069f, 0.25964034f, 0.12169559f, -0.03576827f, 0.09044052f, 
    -0.08255204f, -0.00740568f, -0.01633391f, -0.02428410f, 0.07293185f, -0.00153022f, 0.00433769f, 0.01522293f, 
    -0.24931836f, -0.10953448f, 0.00449999f, 0.03748881f, 0.04690651f, 0.00160217f, 0.05171463f, -0.00905234f, 
    0.07133280f, -0.04246546f, 0.01167758f, 0.06153053f, -0.24368183f, 0.04173281f, -0.14002621f, -0.21361698f, 
    0.01525179f, 0.04156486f, 0.02182947f, 0.20996943f, -0.00997110f, 0.04278448f, -0.05237806f, 0.06621464f, 
    -0.29482260f, 0.04815374f, -0.10129201f, 0.16881354f, 0.01143059f, -0.02395230f, 0.07527400f, 0.02779577f, 
    -0.07541427f, -0.03723744f, -0.02229236f, -0.05030870f, 0.14467670f, 0.13932076f, -0.14643717f, 0.01675976f, 
    -0.08362824f, 0.02512410f, -0.01160300f, -0.07288642f, -0.00276895f, -0.01488750f, -0.03410240f, -0.02703598f, 
    0.09566392f, -0.07370470f, -0.22379082f, 0.30247065f, -0.13429259f, -0.02407187f, 0.09834120f, -0.02251111f, 
    -0.18138906f, 0.08443008f, 0.02298626f, -0.09500739f, 0.11284240f, 0.12414720f, -0.21301973f, 0.23883311f, 
    0.02525016f, 0.09053538f, -0.01873708f, -0.01142051f, -0.04035532f, 0.00043693f, -0.01298924f, -0.03324699f, 
    -0.17603445f, 0.11621721f, -0.09279869f, -0.20596465f, 0.05380512f, 0.02856513f, 0.01098459f, 0.10252004f, 
    0.06134253f, 0.05328640f, -0.06331062f, -0.07809759f, 0.15265474f, 0.19347604f, -0.02220582f, -0.00939085f, 
    0.05948954f, -0.09949376f, 0.05970097f, 0.16618684f, -0.05394645f, -0.00064495f, -0.00590906f, -0.03385129f, 
    -0.05118001f, 0.20022938f, 0.18972482f, -0.08332054f, -0.10514221f, -0.05313626f, 0.07941534f, 0.03665929f, 
    0.02337267f, 0.01402175f, -0.04725023f, -0.04823034f, 0.08732671f, 0.01768570f, 0.09501616f, -0.18220574f, 
    -0.01367930f, 0.04849774f, -0.01817728f, 0.06347618f, 0.03725121f, 0.01339352f, -0.04883880f, -0.01211007f, 
    0.02479336f, 0.01008738f, 0.09604196f, -0.03914167f, -0.12070056f, -0.04740698f, -0.02525477f, 0.00842294f, 
    -0.00915595f, -0.01904716f, -0.00943364f, -0.02948489f, -0.26233184f, -0.06639681f, 0.00445243f, -0.04911185f, 
    -0.08393350f, 0.09299393f, -0.01367273f, -0.13028151f, 0.03138273f, -0.06089788f, -0.15447889f, -0.08889639f, 
    -0.22553234f, 0.04994156f, 0.02293003f, 0.03660758f, -0.08088057f, -0.01447936f, 0.05909042f, -0.11033836f, 
    -0.03326761f, -0.06629518f, -0.03751203f, -0.03721818f, -0.01785693f, -0.11539605f, 0.23637252f, -0.07847001f, 
    -0.09613350f, 0.05532096f, 0.02985420f, -0.04530253f, -0.04190922f, -0.12498534f, 0.02285085f, -0.07407311f, 
    0.12359137f, 0.15975113f, 0.00639748f, -0.10356659f, -0.08889852f, 0.08629890f, -0.05105470f, 0.00445902f, 
    0.00000139f, 0.11504439f, 0.05553515f, 0.05955837f, 0.31749621f, 0.12868910f, -0.06109189f, 0.10807139f, 
    0.08532711f, 0.04026334f, 0.02508125f, -0.12436979f, -0.02958559f, 0.06311405f, 0.15117826f, 0.01013670f, 
    -0.22065458f, 0.26988134f, 0.22243841f, -0.12273417f, -0.09912427f, 0.04157935f, -0.01062728f, 0.00556688f, 
    0.03163387f, -0.05577659f, -0.02240522f, 0.01890968f, -0.04289645f, 0.13352498f, 0.16292040f, -0.06090839f, 
    -0.18735650f, -0.08081327f, 0.06859322f, -0.05067231f, 0.05898712f, -0.01917282f, 0.07713068f, 0.05525818f, 
    -0.08866762f, -0.01388951f, 0.04298503f, -0.04125937f, 0.14554521f, -0.01934739f, 0.04135076f, 0.06840219f, 
    -0.04412232f, -0.03407967f, -0.05067654f, -0.00658777f, 0.23968616f, 0.07640205f, -0.04028011f, 0.03995533f, 
    -0.05024787f, 0.11966324f, 0.03473391f, -0.05052804f, 0.03539355f, 0.02828253f, 0.06530142f, -0.01900921f, 
    0.24852172f, 0.03961328f, 0.08892743f, -0.05504296f, -0.04253202f, -0.08296245f, 0.02050121f, 0.10012826f, 
    0.06146984f, 0.10503464f, 0.08524799f, 0.02817464f, 0.00464443f, 0.01169884f, -0.08475935f, 0.01314169f, 
    0.02866477f, -0.00251141f, 0.12885390f, -0.04127501f, 0.01780639f, 0.10371260f, 0.04509377f, -0.05968037f, 
    0.05428124f, 0.09245837f, -0.11419860f, -0.06634162f, -0.01276203f, 0.01084188f, 0.05406533f, 0.12122861f, 
    -0.06525370f, -0.02030163f, -0.12336487f, -0.13868596f, -0.31002861f, -0.02167395f, 0.07374457f, -0.15609366f, 
    -0.02737888f, -0.03574815f, 0.03967777f, 0.05172497f, -0.20272474f, -0.05806725f, -0.09578309f, -0.06336431f, 
    0.25325906f, 0.04620021f, 0.04530191f, 0.17822704f, 0.02366637f, -0.07247998f, 0.00877277f, -0.01506550f, 
    0.08827795f, 0.01830052f, 0.13328858f, 0.08049917f, 0.10031325f, -0.05660986f, -0.05817095f, -0.15765101f, 
    0.09195054f, 0.15294558f, 0.00385735f, 0.09548146f, -0.00017188f, 0.00952511f, -0.05790840f, 0.00620046f, 
    0.04459862f, 0.22267099f, 0.05922553f, 0.03168781f, -0.05445484f, 0.04494319f, 0.00965394f, 0.03916622f, 
    0.03838478f, 0.12147330f, -0.02553728f, -0.02178952f, 0.01362776f, -0.06001052f, 0.09094212f, 0.11870161f, 
    0.14945851f, -0.01412605f, -0.02000019f, 0.10535676f, 0.02806130f, -0.03686089f, 0.14843161f, 0.04038853f, 
    -0.03480212f, 0.04565258f, -0.04976143f, -0.07796826f, 0.12216599f, 0.16334647f, 0.05287353f, -0.14052254f, 
    0.03321132f, 0.05935384f, -0.06948671f, -0.02765837f, -0.21614501f, 0.02801995f, 0.04551754f, 0.08242401f, 
    -0.13554935f, -0.01122566f, 0.04388900f, 0.04898498f, -0.14122826f, 0.03241272f, 0.03652778f, -0.00798598f, 
    -0.14663900f, 0.00218163f, 0.00890271f, -0.05649247f, -0.03130106f, 0.00248146f, 0.11030536f, -0.03049847f, 
    0.11315452f, -0.09759457f, -0.13064466f, 0.04675969f, -0.10426505f, 0.21718314f, -0.02654088f, -0.01380397f, 
    0.06973698f, 0.05031250f, -0.04841524f, -0.01697285f, -0.03883664f, 0.20293912f, 0.02830500f, 0.03596276f, 
    -0.33385473f, 0.13611545f, -0.02804197f, 0.11960886f, -0.01084105f, -0.07806986f, 0.01983215f, 0.02818082f, 
    0.12007026f, -0.03520846f, 0.02940164f, -0.00096050f, 0.32248712f, -0.05538128f, -0.01123796f, 0.14812951f, 
    -0.08739175f, 0.02096456f, 0.14286427f, -0.03378985f, -0.03644923f, -0.03232852f, -0.09725673f, -0.04900516f, 
    -0.11727065f, -0.03128986f, 0.14487506f, 0.05851174f, 0.03678787f, -0.08227313f, 0.02329083f, -0.08851247f, 
    0.01057129f, -0.06906763f, -0.01369360f, 0.01499172f, -0.02432499f, -0.06550618f, 0.13555925f, -0.06011940f, 
    0.15531893f, 0.16204017f, 0.15319389f, 0.09742460f, 0.02620224f, 0.06262235f, 0.08528277f, -0.07119276f, 
    0.34021068f, 0.08149409f, 0.00698596f, 0.11159546f, 0.13651243f, -0.09751222f, 0.08278462f, -0.01622856f, 
    0.04560585f, 0.09684452f, 0.00305928f, -0.09167538f, 0.08176499f, 0.11434557f, 0.03289225f, -0.10253297f, 
    0.06195424f, -0.00413343f, 0.01998136f, -0.08074304f, -0.05776791f, 0.17489053f, -0.06527342f, -0.00373807f, 
    0.07416554f, 0.21628438f, 0.24497804f, 0.07278969f, 0.02090989f, -0.00368289f, 0.04412642f, -0.05283829f, 
    0.00513356f, 0.10315971f, 0.06572785f, -0.09034333f, 0.13271403f, -0.23166852f, -0.02407677f, -0.19377357f, 
    -0.07434155f, 0.05941249f, -0.08233192f, 0.01380599f, -0.01915366f, 0.00340503f, -0.01970474f, 0.06917593f, 
    0.07617309f, -0.04787491f, -0.08848102f, 0.21026964f, 0.12414623f, 0.06602193f, 0.02850854f, -0.08380314f, 
    0.03966783f, 0.07551136f, 0.03297893f, 0.04313146f, -0.08639260f, -0.06327721f, 0.23659818f, -0.02168965f, 
    -0.03057704f, -0.00238184f, 0.03423985f, 0.08702569f, 0.05443731f, 0.05812827f, 0.05573313f, -0.02229494f, 
    0.03948025f, -0.05064061f, 0.04152133f, -0.05823473f, 0.01366351f, 0.03652628f, 0.02408395f, 0.04654692f, 
    0.06718470f, 0.08285081f, 0.05004528f, -0.10984855f, 0.17602593f, -0.13845885f, 0.39371893f, -0.06080431f, 
    -0.12881677f, 0.02167457f, 0.05666550f, -0.11973021f, 0.01302895f, 0.02986003f, 0.05165850f, 0.09812521f, 
    -0.17233044f, 0.19212960f, -0.03730657f, 0.00320924f, -0.04531655f, -0.08602466f, 0.02106342f, -0.05197244f, 
    0.01517542f, -0.01477006f, 0.00937687f, -0.08127101f, -0.03374023f, -0.01285067f, -0.11965667f, -0.08673432f, 
    0.04726690f, -0.16971609f, 0.00991631f, 0.03724202f, 0.01814259f, 0.01739157f, -0.00716313f, 0.02478864f, 
    0.06187955f, 0.03910674f, 0.26386282f, 0.09281328f, 0.07436051f, 0.15416323f, 0.09559986f, -0.00236344f, 
    -0.14554486f, 0.00697137f, -0.05764804f, -0.11511023f, 0.22214629f, 0.18829618f, 0.05675254f, 0.06426879f, 
    -0.10261238f, 0.02435808f, 0.00496524f, -0.08604887f, 0.01230137f, -0.07573447f, -0.01475354f, -0.02542187f, 
    0.08448076f, -0.07165629f, -0.06278174f, 0.06081042f, -0.02561837f, -0.03296267f, 0.06232302f, -0.04284446f, 
    0.07240265f, 0.00772498f, -0.02883732f, 0.08521228f, 0.07784462f, 0.14339679f, -0.04668105f, -0.02016310f, 
    0.01557230f, 0.09098194f, -0.04022729f, 0.05239886f, -0.02610392f, -0.04785784f, 0.05569238f, 0.09737031f, 
    -0.17371428f, -0.02591424f, -0.05278313f, -0.15274981f, 0.05938756f, -0.13677493f, 0.01142362f, -0.10243978f, 
    -0.01865714f, 0.04321338f, 0.08435379f, 0.15798639f, -0.12225007f, 0.16674942f, 0.01669081f, -0.25910255f, 
    -0.02248960f, -0.01557552f, 0.00546018f, 0.00944998f, 0.06426087f, -0.01722717f, -0.05035314f, -0.05898486f, 
    -0.07099508f, -0.08297634f, 0.11957617f, -0.00766094f, 0.03174511f, 0.02987385f, 0.00958843f, 0.01050378f, 
    0.16026534f, 0.01164758f, -0.08389276f, 0.01574109f, 0.12672764f, -0.06192272f, -0.14898896f, 0.19855365f, 
    0.12429567f, -0.02342321f, 0.12875779f, 0.11786309f, 0.02304939f, 0.06695601f, -0.09985366f, -0.00192789f, 
    0.11164370f, -0.00449893f, 0.02564809f, -0.10481374f, -0.11586518f, -0.01246556f, -0.11397617f, -0.07186935f, 
    0.00511981f, -0.09223164f, 0.14637658f, -0.13987051f, 0.13499980f, 0.19735588f, 0.08274177f, 0.22311848f, 
    -0.01346578f, -0.09825864f, 0.06001717f, 0.05177443f, 0.17953320f, -0.06193154f, -0.03049394f, -0.04141231f, 
    -0.03832764f, -0.03952413f, 0.03804658f, -0.10747237f, -0.08219989f, -0.07944452f, 0.07296383f, 0.07867479f, 
    -0.01696274f, -0.03525917f, 0.01037574f, -0.09704569f, -0.09625546f, 0.05093373f, 0.05777565f, -0.11257624f, 
    0.02905220f, 0.04385221f, 0.04471518f, 0.01468598f, -0.00769838f, -0.01058736f, 0.00146203f, -0.06474558f, 
    0.17097317f, -0.06557694f, -0.07814038f, 0.00421575f, 0.07000480f, -0.00688275f, -0.00986976f, 0.03442939f, 
    -0.17901273f, 0.05932871f, 0.01125698f, 0.13169974f, 0.10609796f, 0.08817744f, 0.09272613f, -0.01387782f, 
    -0.06773545f, 0.08963548f, 0.14175099f, 0.02839799f, -0.12187525f, -0.05522803f, -0.08143056f, -0.01747734f, 
    -0.07593630f, -0.01734939f, 0.03414848f, 0.19564430f, 0.17680202f, 0.08617109f, -0.01112734f, 0.01029219f, 
    -0.15627758f, 0.04029753f, -0.11892210f, -0.05206836f, -0.01080968f, -0.07447377f, -0.12355456f, -0.11306571f, 
    -0.00673398f, -0.02004837f, -0.04167227f, -0.01436379f, -0.06427386f, -0.05628230f, -0.00006762f, 0.01206441f, 
    -0.15926927f, 0.05907230f, 0.15189627f, 0.14954126f, 0.03828477f, 0.08357780f, 0.04914251f, -0.08549258f, 
    -0.02144702f, 0.06296480f, -0.05096610f, 0.01690716f, -0.00946526f, -0.00053709f, -0.09602341f, -0.09485941f, 
    0.03521199f, 0.24134256f, 0.11918170f, 0.00926816f, 0.01491305f, -0.00509589f, 0.00649277f, -0.09245051f, 
    0.05360387f, 0.07471871f, -0.06702128f, -0.02155708f, 0.03223822f, 0.06988945f, 0.03873830f, -0.03743337f, 
    0.04227462f, 0.03997210f, 0.01287053f, 0.00510344f, -0.05960975f, -0.11618149f, 0.21528831f, 0.01808763f, 
    -0.04622851f, 0.02692804f, -0.07084044f, 0.01362600f, 0.08406457f, -0.05378510f, -0.06572889f, -0.03060684f, 
    -0.03533778f, -0.00040747f, 0.03631999f, 0.18456933f, -0.08533916f, -0.03650734f, -0.03018449f, -0.01308338f, 
    0.00300871f, 0.09828016f, 0.08703005f, -0.03478718f, -0.05905176f, -0.08481551f, -0.18801178f, 0.11584961f, 
    0.04853413f, 0.09651121f, -0.02928467f, 0.04912580f, 0.00611139f, -0.04217851f, 0.12126171f, -0.04251913f, 
    0.39923260f, 0.16445611f, -0.20140438f, -0.06905156f, 0.04826348f, -0.08066029f, -0.13131794f, 0.00466318f, 
    -0.00161494f, -0.01000519f, 0.15940039f, -0.00627880f, -0.17453036f, 0.01753131f, 0.13069043f, 0.31655192f, 
    0.14559330f, 0.05484904f, 0.00238067f, 0.03303641f, 0.00142449f, 0.07544605f, 0.12857665f, -0.00189515f, 
    -0.05534707f, -0.11388072f, 0.04163780f, -0.06415631f, 0.18381430f, -0.01460036f, 0.01174301f, 0.04607481f, 
    0.01495963f, 0.04052295f, 0.08561333f, 0.00423721f, -0.08588677f, 0.18079455f, -0.00605289f, -0.08296186f, 
    0.04586561f, 0.02138720f, 0.01020885f, -0.05885431f, 0.02610752f, 0.04953726f, -0.01971859f, -0.02242716f, 
    0.15762483f, -0.15605846f, -0.23181893f, 0.14063495f, 0.06260852f, 0.03945936f, 0.02123550f, -0.02750893f, 
    0.13127246f, 0.09577569f, 0.01663638f, 0.06968868f, 0.12792225f, -0.05417510f, 0.22040796f, 0.05960687f, 
    -0.07380407f, -0.06839620f, 0.03665753f, 0.05639087f, 0.11395600f, 0.11179151f, 0.06650320f, 0.09969259f, 
    0.27625728f, -0.02120279f, -0.10223091f, 0.01904451f, 0.13101952f, 0.05472672f, -0.04497650f, -0.00839874f, 
    0.02944183f, 0.00445828f, 0.03160111f, -0.01195855f, 0.19482484f, -0.11886737f, 0.22238488f, 0.13852960f, 
    -0.03660588f, 0.01349781f, 0.02533331f, 0.01137623f, -0.00342360f, 0.11451179f, 0.05916610f, 0.14081337f, 
    0.00256691f, 0.02552983f, 0.05276506f, -0.09036583f, -0.00010625f, -0.09617514f, 0.01103788f, -0.06360745f, 
    0.05442865f, 0.06312274f, 0.03261700f, 0.09204006f, 0.00816811f, 0.06577837f, -0.09094598f, -0.16496457f, 
    0.06306297f, -0.06304654f, 0.04491052f, 0.11428407f, 0.00343984f, 0.02010745f, 0.00006659f, 0.13065735f, 
    0.17059945f, -0.18964237f, 0.10636162f, 0.16031195f, -0.04197683f, 0.03672198f, 0.07099442f, 0.03214791f, 
    -0.00448589f, -0.00407341f, -0.00232621f, 0.03228279f, 0.18539552f, 0.08223491f, 0.10064668f, 0.09267296f, 
    -0.19995068f, -0.02178182f, -0.01366328f, 0.06824122f, -0.06693704f, 0.02826235f, -0.04703470f, -0.06512748f, 
    0.09647157f, -0.17746647f, -0.19112550f, 0.02735303f, 0.00508346f, -0.05129322f, 0.04002753f, -0.05198344f, 
    0.07857037f, 0.04167502f, -0.01127841f, 0.04182389f, 0.13111158f, 0.08303723f, -0.16409276f, 0.05794824f, 
    0.16251902f, 0.12735094f, 0.02388363f, 0.04592630f, 0.01226759f, 0.03818457f, 0.05151597f, 0.09477077f, 
    -0.02844140f, 0.13071190f, 0.04887010f, -0.15619583f, -0.11983015f, 0.00093434f, -0.04461340f, 0.04179857f, 
    -0.03865254f, 0.03528099f, -0.01949671f, -0.01709136f, -0.29883921f, -0.01082195f, -0.17560315f, -0.11330804f, 
    0.06706064f, -0.04375217f, -0.08865277f, -0.08756655f, 0.02201428f, -0.07319459f, -0.02320083f, -0.00565483f, 
    0.04101876f, -0.23988579f, 0.05068069f, 0.10954361f, 0.13683955f, 0.04184538f, 0.05443225f, 0.01014982f, 
    0.08103923f, 0.05353323f, -0.03336522f, 0.13584171f, 0.11337100f, -0.10883342f, 0.01105734f, -0.00133941f, 
    0.07903580f, -0.04890399f, 0.03263439f, 0.10074232f, 0.07686122f, 0.01165420f, -0.07780984f, 0.04926331f, 
    0.10700160f, -0.05952999f, -0.04858369f, -0.01050195f, -0.02706166f, 0.00363497f, -0.14530399f, 0.00929490f, 
    0.08390465f, -0.03621151f, -0.01290252f, -0.10990737f, 0.24108681f, 0.08695696f, 0.02347818f, -0.09088306f, 
    0.07545777f, -0.04116786f, -0.00484820f, 0.09030554f, 0.25080031f, 0.03417683f, -0.01262016f, -0.13847612f, 
    0.00229165f, 0.00161327f, -0.00265936f, -0.07416207f, -0.11224633f, 0.00263361f, 0.08456820f, 0.06230201f, 
    -0.06527420f, -0.03744395f, 0.01715682f, -0.07533991f, -0.01324940f, 0.10364005f, 0.04167649f, -0.02436913f, 
    -0.04602890f, -0.04025786f, -0.00044380f, 0.08638266f, 0.12309919f, -0.04431648f, 0.00259171f, 0.00292407f, 
    0.11573625f, -0.13597816f, -0.18868738f, 0.09076498f, 0.09929523f, -0.02424338f, 0.10949504f, -0.00789188f, 
    -0.07180314f, 0.07825370f, 0.08775248f, 0.04096876f, 0.19416758f, 0.08717351f, 0.08068809f, -0.05386175f, 
    -0.07517354f, 0.04769249f, 0.04181167f, -0.12110402f, 0.01789889f, -0.05712152f, -0.15855819f, -0.06384479f, 
    -0.12120585f, -0.18219002f, 0.10772085f, 0.02068582f, 0.04212871f, 0.03242925f, -0.01141400f, 0.01254455f, 
    -0.15221456f, 0.02780304f, -0.10641021f, -0.00135592f, 0.06675415f, -0.09965044f, -0.17091115f, -0.08343821f, 
    0.10166433f, -0.03408181f, -0.06246481f, -0.04318138f, 0.09973332f, -0.06029930f, -0.02921716f, 0.01679469f, 
    0.05107379f, 0.16193821f, 0.12594566f, 0.06701868f, -0.01140703f, 0.05430895f, 0.07347273f, 0.03786870f, 
    -0.07591300f, 0.04977095f, 0.04631758f, 0.04662425f, 0.05322275f, -0.06529484f, 0.10730734f, -0.11984526f, 
    -0.09158062f, -0.02021250f, -0.00392579f, 0.01987343f, -0.09483425f, -0.10342404f, -0.03953763f, 0.01049010f, 
    0.14932889f, -0.16419137f, -0.03865906f, -0.22755635f, 0.11634532f, 0.06705602f, 0.04797038f, 0.04693102f, 
    -0.04296988f, -0.03916843f, -0.03245924f, 0.17916201f, -0.11541816f, -0.01823973f, 0.09995971f, -0.06830747f, 
    -0.04786414f, 0.06154650f, -0.07353526f, 0.04187192f, -0.01431660f, -0.04829806f, -0.01686382f, -0.03458057f, 
    0.08275757f, 0.09208676f, -0.17066142f, -0.05155686f, 0.01222277f, 0.04631227f, 0.03594648f, 0.01736515f, 
    -0.03803178f, 0.03943370f, 0.08748477f, 0.09372595f, 0.11937332f, 0.10009570f, -0.07789289f, 0.04420397f, 
    -0.01781982f, -0.11506527f, -0.08476190f, 0.02714410f, 0.07270549f, 0.02089338f, 0.09024709f, 0.00713254f, 
    0.10581382f, 0.09809490f, -0.25214046f, -0.09575116f, -0.03275686f, -0.03726533f, -0.09697615f, -0.05814981f, 
    -0.02976818f, -0.05916941f, 0.07269899f, -0.01951054f, -0.36804837f, -0.00713613f, -0.01106323f, 0.14334333f, 
    0.13195376f, 0.05530595f, 0.02015676f, 0.08291013f, 0.06846468f, 0.05156536f, 0.07770050f, -0.01710867f, 
    -0.15576662f, -0.25858518f, -0.17051314f, 0.03523933f, 0.16260271f, 0.03657740f, -0.02747912f, 0.01543154f, 
    0.02118170f, -0.08274422f, -0.04729326f, 0.01020606f, 0.16972613f, 0.09886211f, 0.02920433f, 0.15803173f, 
    0.07641239f, 0.06601845f, 0.05167217f, 0.00894474f, 0.00712945f, 0.08577637f, -0.01997778f, 0.00321298f, 
    -0.20111717f, -0.08637296f, -0.15830250f, -0.00732195f, -0.05374630f, -0.03137886f, -0.03840165f, 0.03589967f, 
    0.07493369f, -0.00871172f, 0.07201961f, 0.05826633f, -0.13437736f, -0.00844313f, -0.01825640f, -0.14340436f, 
    -0.06975345f, -0.04700215f, 0.06673798f, 0.06355625f, 0.03260872f, 0.09020732f, -0.07441211f, 0.10340024f, 
    0.17423707f, 0.24127309f, -0.12908210f, 0.08908232f, -0.13312419f, -0.04385046f, 0.02247260f, 0.01045759f, 
    -0.06794512f, -0.13574697f, -0.03249155f, -0.00430910f, 0.05997681f, -0.16678721f, -0.12260833f, -0.02361393f, 
    -0.03496226f, 0.01840253f, -0.04633156f, 0.05691226f, 0.08790644f, 0.12596412f, -0.02243715f, -0.16706459f, 
    -0.10204981f, -0.04932284f, -0.09450967f, -0.03515063f, 0.03899736f, 0.02782387f, -0.01256992f, -0.07544908f, 
    0.06584113f, 0.04773469f, 0.00457860f, 0.25784269f, 0.09030078f, -0.22960339f, 0.11950329f, -0.05712312f, 
    -0.18658623f, 0.05144959f, 0.06757457f, 0.08522801f, 0.07088646f, -0.03512318f, -0.00498223f, -0.03782131f, 
    -0.13354582f, 0.12094924f, -0.05876840f, 0.11777897f, -0.10166524f, 0.05589103f, -0.01401371f, -0.01487435f, 
    0.10215992f, 0.05234434f, -0.02387235f, 0.11893284f, 0.23625243f, 0.16986632f, 0.01991764f, 0.09626608f, 
    -0.08958082f, -0.05308544f, 0.00198573f, 0.00935035f, 0.04005737f, 0.09747677f, -0.01759882f, 0.04783105f, 
    -0.19250089f, 0.20229472f, 0.02551407f, -0.11934169f, -0.02297936f, -0.09107360f, -0.07777315f, -0.01128959f, 
    0.05079923f, 0.06768518f, 0.08747549f, 0.12898597f, -0.07019212f, -0.04563772f, 0.11399233f, 0.15989470f, 
    -0.01298031f, -0.00127861f, 0.04817017f, 0.00103133f, 0.06847371f, 0.19182077f, -0.06241419f, 0.05901444f, 
    0.09837553f, 0.10418274f, 0.04369245f, -0.19445910f, -0.00500361f, -0.03048390f, 0.03192228f, -0.00417468f, 
    -0.09538159f, -0.03083849f, 0.02892305f, 0.05253725f, 0.11594364f, 0.02002901f, -0.14816105f, 0.21359015f, 
    -0.09089250f, -0.00286248f, 0.00013119f, 0.03640481f, -0.00095637f, -0.01816423f, -0.07347393f, 0.00391036f, 
    0.40801066f, 0.00348784f, -0.11245053f, 0.17779386f, -0.13900356f, 0.08784164f, -0.02456897f, 0.17452466f, 
    0.03471223f, 0.01878057f, 0.15181036f, 0.04945730f, -0.03478623f, 0.00050431f, -0.19719288f, 0.04708708f, 
    0.15278523f, 0.04587390f, 0.08637220f, -0.09873497f, 0.20679256f, -0.02079737f, 0.04108949f, -0.04702407f, 
    0.08918957f, 0.03023093f, -0.00103042f, 0.05699204f, -0.00298304f, -0.05473002f, -0.07090566f, 0.19498083f, 
    -0.00242164f, -0.09620474f, -0.16933683f, -0.11449778f, -0.18924351f, 0.00033933f, 0.10340928f, -0.24228430f, 
    0.01465944f, -0.00385346f, 0.04781395f, 0.10453533f, -0.02392872f, -0.05489714f, -0.17800529f, -0.11549667f, 
    -0.22844927f, 0.25140968f, -0.01225328f, 0.14670657f, -0.01284598f, -0.02631436f, -0.04366123f, -0.02604399f, 
    0.00643864f, -0.05736364f, 0.06832722f, 0.01980976f, -0.03643781f, 0.03100916f, 0.09835512f, -0.08837696f, 
    -0.00143964f, 0.08151425f, 0.01479576f, 0.08290585f, 0.05388529f, 0.02225519f, 0.01526803f, -0.00818903f, 
    -0.02311986f, 0.08315734f, 0.03230664f, 0.23197539f, -0.03454930f, -0.10576627f, -0.01764704f, 0.03890213f, 
    0.11471783f, 0.03435498f, 0.15144251f, 0.05278578f, -0.01548883f, 0.09011085f, 0.06257872f, 0.06026538f, 
    0.03198009f, -0.07227156f, -0.14517350f, -0.06645805f, 0.03351279f, -0.11431672f, -0.09373838f, -0.04658120f, 
    -0.04695201f, -0.09743048f, 0.06162557f, -0.23836339f, 0.00949106f, 0.14401850f, 0.09911619f, -0.04309408f, 
    0.01271694f, -0.10033602f, -0.08613980f, 0.00291618f, -0.04658352f, -0.29183534f, -0.00659211f, 0.11185960f, 
    0.12878442f, -0.13774176f, -0.01342038f, -0.02125175f, -0.01448263f, -0.02115055f, -0.08165282f, 0.01036519f, 
    0.02455744f, 0.12481788f, -0.08346757f, -0.12486439f, -0.05174732f, 0.08223116f, 0.11648315f, 0.03961231f, 
    0.04895528f, 0.10794993f, -0.00011710f, 0.15428293f, -0.09422655f, 0.07005046f, 0.00622951f, -0.19753963f, 
    0.02722571f, -0.03199631f, -0.03503823f, -0.07323062f, -0.01143592f, -0.11103343f, -0.00377617f, 0.07172626f, 
    -0.06774054f, -0.07024997f, 0.01542538f, -0.05334082f, 0.06981935f, -0.01132893f, -0.09496669f, 0.11113973f, 
    0.08750423f, 0.01324362f, -0.00619384f, 0.12897372f, -0.05148240f, 0.22914830f, -0.02725985f, 0.06537145f, 
    -0.00834131f, -0.02575722f, -0.06418966f, 0.01309931f, 0.00703615f, -0.06908443f, 0.00270681f, 0.02033531f, 
    -0.29526800f, 0.29115665f, 0.02287064f, 0.02296914f, -0.12585974f, 0.03112914f, 0.07942062f, -0.03431526f, 
    0.12461393f, 0.07784376f, 0.01692437f, 0.06628061f, 0.05681187f, 0.07898064f, -0.04260387f, 0.04124891f, 
    0.08300904f, -0.04447363f, 0.21511051f, 0.09963293f, -0.04527705f, 0.07342068f, 0.08188132f, -0.02652993f, 
    -0.01577028f, -0.11121958f, -0.02066476f, 0.00170899f, 0.02423239f, -0.04104862f, 0.02991220f, -0.11194244f, 
    0.06338657f, 0.11691253f, 0.05649621f, 0.00611043f, -0.14009070f, 0.02781656f, -0.17546606f, -0.32047835f, 
    0.01139455f, -0.03156954f, 0.06653186f, 0.06002729f, 0.08339253f, 0.05566395f, 0.09494581f, -0.09004048f, 
    0.07096931f, -0.12319740f, -0.00716897f, 0.20824866f, 0.02875584f, -0.07801716f, -0.06654235f, 0.11490087f, 
    -0.04952232f, 0.05263670f, 0.00104206f, -0.03489320f, -0.18628684f, 0.09284868f, -0.04054485f, 0.18002875f, 
    -0.01399846f, 0.00673002f, -0.05688129f, 0.10268227f, 0.02663745f, 0.09734752f, -0.00590185f, 0.10695905f, 
    0.12769622f, -0.04763868f, 0.08723600f, -0.04457287f, 0.00028751f, 0.04055958f, -0.05443968f, 0.04901510f, 
    0.02525096f, 0.01919412f, 0.01348853f, -0.00004833f, -0.22100849f, 0.01727814f, -0.13810509f, 0.07960106f, 
    0.09373410f, -0.07698765f, 0.02763116f, 0.01668192f, 0.03007410f, -0.05815864f, 0.06837204f, 0.06394436f, 
    -0.04565439f, 0.13407148f, 0.00329812f, 0.08295860f, 0.05579881f, 0.12811184f, -0.00376318f, 0.09083133f, 
    0.00082773f, 0.14914343f, 0.13500406f, -0.02455855f, -0.06314880f, 0.03550216f, -0.10371353f, 0.23760313f, 
    0.02922511f, -0.06114826f, -0.01988561f, 0.02172041f, -0.05669273f, 0.00510091f, 0.13817562f, 0.08506428f, 
    0.17490238f, 0.07344968f, -0.00056063f, -0.08676621f, 0.00575984f, 0.08447354f, 0.07902314f, 0.15623267f, 
    -0.08927258f, -0.05683470f, 0.10196646f, 0.13630448f, 0.01084293f, 0.04299925f, -0.03452031f, -0.02459148f, 
    0.05284011f, 0.07671239f, 0.06815151f, 0.06157555f, -0.07627036f, 0.06381269f, -0.01483275f, 0.01050745f, 
    -0.31808025f, -0.09995450f, -0.15874651f, 0.14957628f, 0.02012814f, -0.02719115f, -0.08939674f, 0.05346473f, 
    -0.00735484f, -0.12710138f, 0.00978798f, -0.00889940f, -0.08398741f, -0.18248901f, -0.05416638f, -0.30545664f, 
    0.10268212f, -0.10066384f, -0.03635520f, 0.11720444f, 0.04581197f, -0.06283066f, 0.02800188f, 0.13074209f, 
    0.27717447f, 0.03297314f, -0.05975106f, 0.30708280f, 0.05983271f, 0.04327257f, -0.02299326f, 0.06452014f, 
    -0.11838354f, 0.05495964f, 0.07852768f, 0.02009752f, 0.07648999f, -0.34042099f, 0.03807449f, 0.14565800f, 
    0.04169773f, -0.00920079f, -0.05114633f, -0.02795935f, -0.04107973f, -0.08477628f, -0.01943485f, -0.08045867f, 
    -0.18127675f, -0.23429210f, 0.09271885f, 0.14468822f, -0.15886554f, -0.01892993f, 0.02533640f, 0.06134263f, 
    0.09816128f, 0.07020985f, 0.06842767f, -0.03117309f, -0.06799820f, 0.24907230f, 0.12527880f, 0.44026735f, 
    0.00825921f, 0.04991042f, 0.08400679f, 0.04267950f, 0.03714059f, 0.01970882f, -0.02187573f, 0.09515742f, 
    0.02643984f, 0.13277596f, 0.05189860f, 0.14803638f, -0.13663778f, 0.03262727f, 0.02262782f, -0.04342793f, 
    -0.07385603f, -0.05887833f, 0.05402064f, -0.03049674f, 0.12910821f, -0.05501280f, 0.17239827f, -0.10427825f, 
    -0.11020791f, 0.01199261f, -0.07107688f, 0.05545295f, 0.01551241f, 0.04033889f, -0.01889436f, 0.00847923f, 
    0.08544942f, -0.03731391f, 0.08450446f, 0.00776047f, 0.05368674f, 0.04972780f, -0.00631311f, -0.00863283f, 
    0.07029732f, 0.00501487f, 0.02266990f, 0.08016529f, 0.14084134f, 0.06056579f, 0.14433159f, -0.11678503f, 
    -0.06717879f, 0.04407382f, -0.00583117f, 0.03495490f, 0.10599927f, -0.10116770f, -0.00162752f, -0.01118095f, 
    -0.15239775f, 0.25106770f, 0.07999612f, 0.00077948f, 0.03552413f, 0.10938124f, 0.01000808f, 0.00250092f, 
    -0.08236827f, 0.05748221f, -0.07008534f, 0.10932936f, -0.02174583f, 0.17890315f, -0.01692517f, 0.11871023f, 
    -0.02019081f, -0.09002815f, 0.02400162f, -0.07138544f, -0.05797395f, 0.03175906f, 0.07021104f, 0.03978398f, 
    -0.14250304f, -0.17337646f, -0.06526905f, 0.23358126f, -0.03585044f, -0.05194100f, -0.02640826f, -0.00183069f, 
    -0.04118285f, -0.10264321f, 0.06681409f, -0.06255603f, 0.04552865f, -0.07279387f, -0.13398224f, -0.19639707f, 
    0.00032157f, 0.09330478f, -0.02728885f, 0.05571444f, 0.07893527f, 0.03992854f, -0.03282417f, 0.01832419f, 
    -0.12821527f, -0.04900227f, -0.01782304f, 0.13290861f, -0.07206978f, -0.12583199f, 0.03011381f, 0.06313168f, 
    0.05615182f, 0.05991956f, 0.03303633f, 0.05255080f, 0.46679798f, -0.15053846f, -0.08654058f, 0.21938284f, 
    0.10430094f, -0.04217200f, 0.02911895f, -0.08258403f, 0.01575456f, 0.02519672f, -0.06743722f, -0.01666677f, 
    0.00509673f, -0.00181591f, 0.02683639f, -0.20947187f, -0.03519255f, -0.00084525f, -0.03362963f, 0.13593256f, 
    -0.04774481f, 0.12823972f, 0.02297282f, 0.10448986f, -0.17726758f, -0.23758116f, -0.02724365f, -0.08426786f, 
    0.05474659f, -0.02458284f, 0.03093463f, 0.05620173f, 0.00274112f, -0.00362429f, 0.03349516f, -0.02132999f, 
    0.38690463f, 0.04416525f, -0.02132843f, -0.02515054f, 0.01337948f, 0.08424123f, 0.03935992f, -0.00133479f, 
    -0.02733692f, 0.08204294f, 0.04426290f, -0.03114470f, -0.02661446f, 0.09831043f, 0.11018503f, 0.13731524f, 
    0.16338789f, -0.01643835f, -0.01826717f, -0.03238029f, 0.00876528f, -0.00218514f, 0.06464820f, 0.06947535f, 
    0.07778896f, 0.03349043f, 0.03755562f, -0.13130410f, -0.05149649f, 0.07945849f, -0.01176632f, 0.07486320f, 
    0.05829751f, 0.02990314f, -0.04136954f, -0.04889279f, -0.11806583f, -0.07425003f, -0.06419554f, -0.04030634f, 
    -0.09384941f, 0.00698597f, 0.05341558f, 0.01967464f, 0.00888947f, -0.03616770f, -0.01795435f, 0.09825383f, 
    -0.04863012f, 0.04492169f, 0.27990010f, -0.27563995f, -0.01792774f, 0.13520488f, -0.01003746f, 0.05184299f, 
    0.16434190f, -0.11182736f, 0.00236313f, 0.09930532f, 0.05006295f, -0.14225088f, 0.16025177f, -0.13639784f, 
    -0.03934453f, -0.07949065f, -0.01096108f, 0.09108471f, 0.02537921f, -0.06801851f, 0.08024459f, 0.11314085f, 
    0.18939628f, -0.27259442f, -0.05780054f, 0.08448674f, -0.07900195f, -0.01614706f, -0.04667805f, -0.01492395f, 
    0.04626880f, -0.05738697f, 0.09343288f, 0.07230899f, -0.27601716f, 0.09390622f, -0.07313015f, 0.26312923f, 
    -0.02717788f, -0.02696253f, 0.04372197f, -0.11052956f, 0.04147835f, 0.00048205f, 0.07450602f, -0.03182944f, 
    -0.09389465f, -0.04103244f, -0.09446334f, -0.10991279f, -0.00239120f, 0.01427853f, -0.03081916f, -0.04962483f, 
    0.01585912f, 0.00372848f, -0.08451611f, -0.02765077f, 0.39596221f, 0.06946971f, -0.01316560f, 0.18417248f, 
    0.01801682f, 0.01445347f, -0.06460279f, -0.08440304f, -0.02895346f, -0.09024374f, 0.12486236f, -0.01056030f, 
    -0.04197367f, 0.03431610f, -0.10458206f, -0.01465438f, 0.01519696f, 0.04008970f, -0.04203748f, -0.03443185f, 
    0.08856706f, 0.02145981f, -0.01063488f, 0.13075562f, 0.28931183f, 0.06148639f, 0.01793654f, 0.24226396f, 
    0.02439552f, 0.02676798f, 0.11717797f, 0.13081780f, 0.06658626f, -0.00855356f, 0.00743427f, 0.03572724f, 
    -0.06324963f, -0.10978810f, 0.08629737f, 0.18934475f, 0.13727383f, -0.04615341f, -0.02642786f, 0.01008395f, 
    0.05874681f, 0.06740387f, -0.04053595f, -0.09761497f, 0.07397382f, 0.24349983f, -0.09801068f, 0.15425819f, 
    0.07298155f, 0.07898716f, -0.10630761f, -0.04442738f, -0.00319282f, 0.02358353f, 0.10540489f, 0.01172981f, 
    0.27463487f, -0.09398053f, 0.19962725f, -0.07792689f, 0.02499399f, -0.03431416f, 0.02173206f, 0.02894092f, 
    0.03601239f, 0.16871688f, 0.09655562f, 0.03652647f, -0.21345112f, 0.00731084f, -0.06867977f, 0.01425169f, 
    -0.00556109f, 0.02725168f, -0.01975634f, 0.09755287f, -0.02194720f, 0.03255395f, -0.09454945f, -0.06121642f, 
    -0.03716305f, -0.16925520f, -0.19340472f, -0.19986981f, 0.02837603f, -0.10026664f, -0.03520442f, -0.04642907f, 
    0.04951215f, -0.02986315f, -0.06986447f, -0.09993125f, -0.07321467f, 0.18742637f, -0.15499994f, -0.20139414f, 
    0.10834082f, 0.01724909f, -0.02569931f, 0.05842532f, 0.02147738f, 0.00011559f, 0.00498739f, -0.09763302f, 
    0.13250785f, 0.11566864f, -0.04945787f, 0.04042345f, 0.01026663f, 0.11939242f, 0.08730434f, 0.06698330f, 
    0.11888691f, -0.06718003f, -0.02394828f, -0.13210909f, -0.03486489f, -0.18885972f, -0.03997375f, -0.28297201f, 
    0.11993006f, -0.03278838f, -0.05981988f, 0.02339129f, -0.07922194f, 0.00986233f, 0.05492758f, 0.11675356f, 
    -0.34731179f, 0.01912217f, -0.15754324f, -0.11571410f, 0.10362361f, -0.00994642f, -0.02814647f, -0.02906464f, 
    -0.04421698f, -0.00401278f, 0.10130327f, -0.06040162f, 0.00854092f, 0.06510924f, -0.00561126f, 0.06750131f, 
    -0.13930187f, 0.03225937f, -0.14853695f, 0.13729736f, 0.04095655f, 0.10329862f, 0.07096690f, 0.10551451f, 
    -0.17399643f, 0.09405976f, 0.17123775f, 0.14675047f, 0.14701091f, -0.01577075f, 0.03751416f, -0.08587299f, 
    0.03179378f, 0.13975464f, 0.07877550f, 0.26311141f, 0.27415413f, 0.09440961f, -0.10511842f, 0.13621104f, 
    0.04486743f, 0.09013253f, -0.07016288f, 0.03250429f, 0.01415607f, 0.01226485f, 0.13527900f, 0.05724488f, 
    0.12911649f, -0.31394726f, -0.03971148f, -0.03537697f, 0.07074634f, 0.10920685f, 0.00741607f, -0.03657419f, 
    0.04601898f, 0.09042826f, 0.04192983f, 0.08640172f, 0.20465244f, -0.08612718f, 0.06132638f, 0.12169109f, 
    -0.00495253f, -0.14840198f, -0.01492950f, -0.05280232f, -0.01613595f, 0.10907392f, 0.03783711f, 0.10950846f, 
    -0.18925998f, -0.07142709f, -0.04113111f, -0.22607869f, 0.08347210f, 0.00954687f, 0.00202868f, -0.01159597f, 
    0.05106773f, 0.03862426f, -0.11915211f, 0.03057113f, -0.00367048f, 0.03378744f, 0.04788576f, 0.05140636f, 
    -0.05767481f, -0.06729124f, 0.14478190f, -0.00582491f, -0.06340440f, 0.01437581f, 0.15362684f, -0.04220067f, 
    0.18835567f, 0.09722462f, -0.01604981f, 0.06801827f, -0.03983171f, -0.08230882f, -0.07562602f, 0.12821211f, 
    -0.13505915f, -0.04345964f, 0.21140218f, 0.01879344f, -0.32742679f, 0.10231660f, 0.04472532f, -0.10760199f, 
    0.11452280f, 0.17886175f, -0.07648465f, -0.02007727f, 0.10580321f, 0.03968374f, 0.05368164f, 0.06908037f, 
    0.06290080f, -0.01681320f, -0.00084163f, 0.20805338f, 0.08617826f, -0.02653669f, -0.01091619f, 0.00988299f, 
    -0.16046841f, -0.06428517f, 0.06582928f, -0.13149817f, 0.31669891f, 0.03537821f, 0.03116926f, 0.12163123f, 
    -0.10703545f, -0.02613105f, 0.04828322f, 0.08593029f, -0.04421475f, 0.02291219f, -0.05318625f, -0.02911559f, 
    -0.24996811f, -0.12536897f, -0.01781337f, 0.07403770f, 0.05517023f, 0.03287250f, 0.01743555f, 0.02383580f, 
    -0.05529078f, -0.02339088f, 0.03395057f, 0.01666135f, -0.09981672f, -0.19857064f, -0.20734301f, -0.16821970f, 
    -0.06598211f, 0.01265176f, -0.03612550f, 0.06517581f, 0.03399527f, 0.02749160f, -0.00552970f, 0.08437249f, 
    0.04757435f, -0.08323065f, -0.00585467f, 0.02954975f, 0.12035145f, 0.02223570f, 0.07455973f, 0.11923628f, 
    -0.19863570f, -0.00488078f, 0.03526708f, 0.03486525f, 0.27777681f, 0.08593377f, 0.06414860f, 0.06456243f, 
    -0.16667271f, -0.03932302f, -0.13211595f, -0.10553370f, 0.01280740f, 0.06383803f, -0.11383561f, 0.04441107f, 
    0.11077812f, 0.01967469f, -0.07917619f, 0.28826079f, -0.08166404f, 0.10251678f, 0.05833773f, 0.12041324f, 
    -0.13358642f, -0.01033213f, -0.13575932f, -0.05287948f, 0.22230479f, 0.02194203f, -0.12620261f, 0.10811345f, 
    0.06204292f, 0.05307312f, -0.04194787f, 0.01503418f, -0.01296292f, -0.05440332f, -0.09083629f, 0.09032833f, 
    -0.25711733f, 0.10350212f, -0.11062028f, -0.20414630f, -0.05261433f, 0.07500917f, -0.01732692f, 0.01208164f, 
    0.11216293f, -0.02854237f, -0.02313882f, -0.02208996f, 0.41192913f, 0.05466688f, 0.10518751f, 0.09061214f, 
    0.06337471f, -0.02925186f, 0.11572881f, 0.03329917f, 0.02342257f, -0.06935924f, 0.04976859f, -0.08524040f, 
    -0.10696228f, 0.02710354f, -0.13916104f, 0.03554938f, 0.03139103f, -0.00497250f, -0.10608029f, 0.00752044f, 
    0.13199949f, 0.00939948f, -0.08095907f, -0.04628790f, 0.13893157f, -0.00132595f, -0.02468851f, -0.28665620f, 
    -0.04809114f, -0.07375493f, -0.02938695f, 0.07387801f, -0.00021309f, -0.15527108f, 0.11345087f, 0.04022341f, 
    -0.14165652f, 0.20346563f, -0.13119610f, -0.11962391f, 0.04232740f, -0.07319038f, -0.07813223f, 0.01648565f, 
    0.00175472f, 0.15479948f, -0.02168395f, 0.09076875f, 0.21629962f, -0.30772242f, -0.09994259f, 0.11660971f, 
    0.18479736f, 0.08512135f, -0.05258067f, 0.11154787f, 0.10209548f, -0.05813985f, -0.05598376f, -0.00403504f, 
    -0.39500731f, -0.18830143f, 0.05267372f, -0.09262959f, -0.08125576f, 0.06814568f, -0.00151714f, -0.10428464f, 
    -0.00824789f, -0.04783735f, -0.11002807f, 0.02610750f, 0.02976823f, -0.17232281f, -0.03983235f, 0.10158052f, 
    -0.06467138f, 0.03205288f, 0.05287694f, 0.01935155f, 0.06166780f, 0.07476396f, 0.01713362f, -0.00664653f, 
    0.02152415f, -0.18013836f, 0.12097073f, -0.04884442f, -0.04391487f, -0.07899404f, -0.11723418f, 0.04888658f, 
    0.13142583f, 0.11141188f, -0.13920210f, 0.07421277f, 0.26291519f, 0.07407732f, 0.06305251f, 0.05838864f, 
    0.03347471f, 0.10242575f, 0.04590831f, 0.22564042f, -0.16075104f, -0.00077058f, 0.02347830f, -0.03942688f, 
    0.01607899f, 0.13757373f, 0.03553302f, -0.19917221f, -0.02929379f, -0.10053889f, -0.04697212f, -0.00225666f, 
    0.12836374f, -0.10004356f, -0.00014411f, -0.08707817f, 0.23040873f, 0.06227084f, 0.11579578f, 0.07276322f, 
    -0.10776310f, -0.18690361f, 0.07224656f, -0.03663934f, 0.12476241f, 0.00099318f, -0.02941922f, -0.25479662f, 
    0.04895717f, -0.00876233f, -0.07611233f, 0.02016949f, -0.02328948f, 0.06012245f, 0.03972317f, 0.09217645f, 
    0.11267082f, -0.04357208f, -0.13690889f, -0.22799769f, -0.17557223f, -0.00432957f, -0.19135413f, 0.21882538f, 
    0.02186918f, 0.16047952f, -0.02366906f, 0.02720983f, -0.03863925f, 0.00491449f, 0.17744052f, 0.08413311f, 
    0.39777845f, -0.11167108f, -0.03329723f, 0.01237637f, 0.02479621f, -0.06653184f, 0.03540223f, -0.11453474f, 
    -0.11027513f, 0.12492147f, 0.09961941f, -0.01602975f, 0.33607969f, 0.00789680f, 0.05108221f, -0.18283871f, 
    -0.05655777f, 0.19387668f, 0.02300431f, 0.09065815f, 0.12284062f, 0.10711189f, 0.23703068f, 0.03832019f, 
    0.09465997f, 0.11725447f, -0.12960158f, -0.24524258f, 0.07488076f, -0.05708720f, -0.02812817f, -0.07800551f, 
    -0.04361030f, -0.03615796f, 0.03768892f, 0.21780212f, -0.04615397f, 0.00549821f, 0.14454462f, -0.14512658f, 
    -0.00796260f, 0.10940385f, -0.11158057f, -0.03939922f, 0.02926190f, 0.04519687f, 0.11021628f, 0.01810773f, 
    0.14573103f, 0.02883079f, -0.02959028f, -0.17090498f, -0.00445120f, 0.04703865f, 0.08716049f, 0.03467489f, 
    0.13257252f, -0.01844865f, -0.10556280f, 0.02357925f, -0.09793878f, 0.11177684f, -0.06651456f, 0.10516471f, 
    -0.06872616f, 0.12738553f, 0.12118732f, 0.07497776f, -0.00798850f, 0.02186875f, 0.06693244f, 0.18557909f, 
    -0.15191543f, 0.09987886f, -0.04701089f, 0.10381091f, -0.06764352f, 0.00684222f, -0.05530149f, -0.05949936f, 
    0.08753268f, 0.00593898f, -0.06516527f, 0.14903846f, -0.04705197f, -0.21917145f, 0.27418068f, 0.15132208f, 
    0.04753540f, 0.00559849f, 0.06523360f, 0.17626029f, -0.08304790f, 0.03669222f, 0.29939952f, 0.09888546f, 
    0.19198695f, -0.04646058f, 0.01960653f, -0.09803099f, 0.01160168f, -0.05937889f, -0.10390901f, -0.00795291f, 
    -0.01818083f, -0.11862226f, 0.12710835f, -0.05506915f, -0.16192943f, -0.08805241f, 0.00291689f, 0.08297180f, 
    -0.03877858f, 0.07799741f, 0.04744199f, 0.06792286f, 0.03174962f, 0.14156291f, 0.10546768f, 0.15869778f, 
    -0.01869356f, -0.10140209f, -0.04278846f, -0.10745879f, 0.00536299f, -0.04910417f, 0.06777295f, 0.01589781f, 
    -0.09209993f, -0.13551857f, 0.05750310f, -0.03347937f, -0.21335931f, -0.08330479f, -0.12390808f, -0.09718733f, 
    0.00337626f, -0.24729206f, -0.04638570f, 0.12787078f, -0.03492054f, 0.09024847f, -0.03402643f, 0.01859516f, 
    -0.02286025f, 0.01501225f, 0.10481151f, -0.16888194f, -0.04077183f, 0.00707526f, 0.03195957f, -0.00406390f, 
    0.17044188f, -0.00267615f, 0.03894418f, -0.05195442f, 0.25920349f, 0.06155914f, -0.33465853f, 0.01553189f, 
    -0.06199864f, 0.07743398f, 0.09729394f, 0.17046684f, -0.03517390f, 0.03150614f, 0.04734707f, -0.04919545f, 
    -0.08527575f, 0.10161699f, -0.02580998f, -0.10083377f, 0.05101648f, -0.17595282f, -0.03773844f, -0.18981957f, 
    -0.07904468f, 0.05804604f, 0.05299601f, -0.01239253f, 0.42057386f, 0.08291896f, -0.15479863f, -0.10964525f, 
    -0.01287136f, -0.15078567f, 0.02692808f, 0.03934243f, -0.08658633f, 0.05277608f, -0.04764316f, 0.14532351f, 
    0.70349848f, 0.03216830f, -0.07839054f, -0.15030482f, 0.01603172f, 0.09518749f, 0.06538512f, 0.11450139f, 
    -0.03472472f, 0.05756438f, -0.19550112f, 0.04248809f, 0.30001590f, 0.30894539f, -0.15312248f, -0.27625737f, 
    -0.06931953f, 0.01215729f, -0.07576076f, -0.10405841f, 0.07679373f, -0.06009789f, -0.09001854f, 0.10660166f, 
    0.05047727f, 0.00647551f, -0.02334838f, 0.04028912f, -0.05286497f, -0.08167742f, -0.05086784f, 0.11292320f, 
    0.00409401f, -0.01951935f, 0.02095228f, 0.04361987f, 0.03505976f, -0.04374283f, 0.02188412f, 0.27742833f, 
    0.05400594f, -0.12946288f, -0.04553593f, 0.02493897f, -0.04422452f, -0.08735727f, 0.06558315f, 0.03689221f, 
    0.01186680f, 0.00750261f, -0.02775700f, 0.01513236f, 0.02388459f, 0.03379266f, -0.04347914f, 0.02490711f, 
    -0.03059857f, -0.01549842f, -0.02355532f, 0.02555130f, 0.02246987f, 0.04587399f, -0.01579814f, 0.00270527f, 
    0.04122114f, -0.00824549f, 0.01531742f, -0.00625863f, -0.05787916f, -0.02962706f, -0.05449782f, -0.04876997f, 
    -0.02415248f, -0.04386138f, -0.02325908f, -0.01089709f, -0.05508335f, -0.01596026f, 0.01568607f, -0.00525715f, 
    -0.03782756f, 0.04296528f, 0.02651160f, -0.04475898f, -0.02171734f, -0.03489881f, 0.01246283f, -0.01220539f, 
    -0.01136434f, -0.04878036f, -0.01940497f, 0.00500759f, -0.04749277f, 0.01701831f, -0.04084762f, -0.01552319f, 
    -0.00647095f, 0.01409065f, -0.02152324f, -0.03211861f, -0.04507459f, 0.04191416f, -0.02917931f, -0.01580670f, 
    0.00043732f, 0.01448480f, -0.02662574f, -0.04040618f, -0.02432092f, 0.03537662f, -0.00424217f, 0.03051590f, 
    -0.05848965f, -0.01758906f, -0.02436600f, -0.03950423f, -0.04124672f, 0.03473192f, -0.00542394f, 0.03888403f, 
    -0.03845658f, 0.03660468f, -0.00844068f, 0.03504336f, -0.02051653f, -0.03509901f, 0.00681947f, -0.03978531f, 
    -0.05894802f, 0.03482067f, -0.03872434f, -0.02841216f, -0.05182730f, -0.04089959f, -0.01775111f, 0.03478585f, 
    0.00465965f, 0.01842608f, 0.03297922f, 0.03079898f, 0.03136276f, -0.03223748f, 0.00821490f, 0.01168492f, 
    0.03459957f, 0.03294803f, 0.01645773f, 0.02365978f, 0.02747624f, 0.03836332f, -0.03702759f, -0.01309035f, 
    -0.03730383f, -0.01526440f, -0.04459339f, -0.01436810f, -0.04279029f, -0.04077384f, -0.05215639f, -0.03229648f, 
    0.01231293f, 0.03212870f, -0.01144986f, -0.02242520f, -0.00674773f, 0.03074943f, 0.03424903f, -0.05126127f, 
    0.00217357f, -0.03917338f, -0.02403977f, -0.05728203f, -0.05858960f, 0.02819509f, 0.01168360f, 0.01153746f, 
    0.01835944f, 0.02840841f, -0.03303215f, -0.05467255f, 0.01295706f, -0.03243009f, 0.02035398f, -0.01102881f, 
    -0.03771007f, 0.02181467f, 0.01993046f, -0.05516001f, -0.03648400f, -0.02761926f, -0.00014878f, -0.00745675f, 
    -0.00762419f, -0.01185589f, -0.03605284f, -0.04468726f, 0.01833462f, 0.03918736f, -0.05536601f, 0.03090105f, 
    -0.04451456f, -0.00556296f, 0.02836206f, 0.03013099f, 0.03320886f, 0.00681950f, 0.01823043f, -0.04575954f, 
    0.03734458f, 0.02582499f, 0.03847061f, 0.02454576f, 0.03171516f, -0.04878910f, -0.01535580f, 0.03528990f, 
    0.00488810f, 0.00945243f, -0.01750540f, 0.01285097f, -0.05869215f, 0.01856072f, -0.03650267f, -0.00918603f, 
    0.02415251f, 0.02868275f, -0.05326641f, 0.01603051f, -0.04954193f, -0.03292554f, -0.04780219f, -0.01762241f, 
    0.04451627f, -0.04568886f, -0.01214834f, 0.00676958f, 0.04396384f, 0.02409898f, -0.02562240f, 0.02916731f, 
    -0.01831469f, -0.03219459f, 0.02973198f, -0.03181445f, 0.03197367f, -0.03727417f, -0.03202330f, -0.01279771f, 
    -0.04077794f, 0.04151675f, 0.02758995f, -0.01581390f, -0.03787454f, 0.03720217f, 0.00439776f, -0.01873745f, 
    -0.01171064f, -0.00371194f, 0.00814967f, 0.04043679f, -0.00967611f, -0.04490019f, -0.04276974f, 0.00798882f, 
    0.02066258f, 0.03664377f, 0.03836321f, 0.04201130f, -0.00722334f, -0.05351117f, -0.02500829f, -0.04191658f, 
    0.00522264f, 0.03516554f, -0.00636960f, -0.03796459f, -0.00148163f, -0.01061618f, 0.02283128f, -0.05693598f, 
    0.03436726f, 0.00770216f, 0.00149928f, 0.04068163f, 0.00539784f, -0.04994477f, 0.02755892f, 0.04186625f, 
    0.00887523f, 0.02402015f, 0.02363100f, -0.02941922f, 0.01531959f, 0.02342760f, 0.00812563f, -0.01328040f, 
    -0.03171229f, -0.04190021f, -0.04723901f, 0.02820501f, -0.00318834f, -0.04112988f, -0.03620739f, 0.01866872f, 
    -0.02490566f, -0.00904614f, 0.02953023f, -0.05401332f, -0.05306692f, -0.01617263f, -0.03720953f, 0.00067234f, 
    -0.01073467f, -0.02769697f, 0.04046924f, -0.02992648f, -0.04632287f, 0.01204034f, -0.05492965f, -0.02664736f, 
    -0.00709100f, 0.04285029f, 0.03792101f, 0.02082452f, -0.05075623f, -0.00297527f, 0.01326834f, -0.05532019f, 
    0.02753147f, -0.02550999f, -0.01413104f, -0.04503587f, -0.03969009f, 0.03220565f, 0.00027178f, -0.02288732f, 
    -0.03346959f, 0.03380126f, -0.02239906f, 0.02110508f, -0.03512671f, 0.00040114f, -0.00943408f, 0.00710618f, 
    0.00606480f, -0.05209280f, -0.00746444f, -0.04826383f, -0.00305440f, -0.00333812f, -0.05067975f, -0.03867208f, 
    -0.01480759f, -0.04202753f, 0.03245210f, 0.01480405f, 0.00159004f, 0.03227883f, -0.02420707f, -0.00426809f, 
    -0.05907214f, 0.01569024f, 0.03764575f, -0.01291118f, 0.00927960f, -0.04321776f, -0.02020672f, 0.01005845f, 
    0.01128807f, 0.00058722f, -0.01557457f, -0.04099688f, -0.02307939f, 0.00394607f, 0.02747260f, 0.03175959f, 
    0.01860335f, -0.00336295f, -0.04880304f, 0.00302823f, 0.01036061f, 0.01340457f, -0.01307499f, -0.03418978f, 
    -0.03460192f, -0.04631970f, -0.03688388f, -0.01274515f, -0.01604021f, -0.04221478f, 0.00927876f, 0.02384412f, 
    -0.03641834f, 0.01229108f, 0.03535047f, -0.01618526f, -0.03174700f, -0.01674637f, 0.03396974f, -0.02963937f, 
    -0.04461803f, 0.03996004f, 0.02397311f, -0.00345333f, -0.02131811f, -0.02709843f, -0.00014086f, 0.01545190f, 
    -0.03644184f, -0.02905270f, -0.01351100f, 0.02482800f, 0.01420926f, -0.03356883f, -0.04937733f, 0.04925891f, 
    0.03020336f, -0.01790099f, -0.04844145f, -0.02451900f, -0.04032982f, -0.03485846f, -0.01252287f, -0.01605047f, 
    -0.05483291f, -0.02527935f, -0.05477256f, -0.01998505f, -0.02393102f, -0.03545199f, -0.02300573f, 0.03467220f, 
    0.31427547f, 0.21832265f, 0.06416823f, 0.02293630f, -0.05470727f, -0.05068852f, 0.14468849f, -0.06983261f, 
    -0.07369237f, -0.08941897f, 0.08685649f, 0.04217440f, -0.05803199f, -0.11180094f, -0.14189366f, -0.05711765f, 
    -0.04330916f, 0.10899875f, -0.02178490f, -0.03593190f, -0.06742305f, 0.02227335f, -0.14845438f, -0.02106162f, 
    0.12551503f, -0.19902508f, 0.04152910f, -0.07948348f, 0.02909233f, 0.03944679f, 0.14873365f, 0.03666616f, 
    -0.04346992f, -0.22704870f, 0.01790654f, 0.04717834f, -0.15515752f, 0.05628964f, 0.02339424f, -0.30832177f, 
    -0.04495120f, -0.00393302f, -0.00260619f, 0.00167400f, -0.03530241f, 0.11358051f, 0.08036377f, -0.03508385f, 
    0.27133527f, -0.04095472f, -0.08217096f, 0.09286878f, 0.10231012f, -0.06263306f, -0.04217105f, 0.05045926f, 
    -0.05201717f, 0.07738948f, -0.05007757f, -0.10820081f, 0.22074537f, -0.03586705f, -0.04023896f, -0.06181295f, 
    0.06593397f, -0.06180375f, 0.02667118f, -0.03356060f, -0.05773239f, 0.03312134f, 0.09168844f, -0.01312557f, 
    -0.08590395f, 0.18000641f, -0.22551794f, 0.13634050f, 0.02815229f, -0.02120874f, 0.03743199f, 0.01925260f, 
    -0.01140481f, 0.00411635f, -0.04106905f, -0.05460190f, -0.20152113f, -0.18921864f, -0.16221198f, 0.01932077f, 
    0.01841998f, 0.02040051f, 0.06346110f, -0.08749682f, 0.01803858f, -0.01195710f, -0.03302512f, -0.12479527f, 
    0.32227364f, 0.09759314f, 0.28390092f, 0.05438161f, -0.01912829f, -0.02896742f, 0.02761901f, -0.06367234f, 
    -0.00216754f, 0.05908880f, 0.02123045f, 0.06779280f, 0.31840071f, 0.17241155f, -0.08860808f, 0.07449656f, 
    -0.09386224f, 0.02211517f, -0.01147157f, 0.05680212f, -0.02694789f, 0.03978741f, 0.02596505f, 0.10693238f, 
    0.05299703f, 0.06634607f, -0.04312336f, 0.00472113f, 0.18402103f, 0.04099694f, -0.00910979f, -0.03429533f, 
    -0.05816810f, 0.02767639f, 0.00942364f, 0.17572778f, 0.06440765f, 0.02722878f, 0.01391721f, -0.14104705f, 
    0.03287518f, 0.02784649f, 0.00526103f, 0.08652808f, 0.03542219f, 0.05788291f, -0.07497610f, -0.10315122f, 
    0.17176326f, -0.09477992f, 0.20808890f, -0.01352154f, -0.01301306f, -0.05683547f, 0.01290512f, 0.02534446f, 
    0.04933760f, 0.02782218f, -0.00913351f, 0.09033475f, -0.10884716f, -0.15652592f, 0.05261990f, 0.05801485f, 
    0.04461004f, 0.04197797f, -0.01330138f, -0.04358428f, -0.10143401f, -0.07643066f, -0.00616709f, 0.01078077f, 
    0.10163715f, -0.05528988f, 0.01912580f, 0.04189976f, -0.16269395f, 0.08292763f, 0.05076017f, -0.02322672f, 
    0.06210324f, 0.01359938f, -0.11255016f, -0.07912974f, 0.09225701f, -0.18768725f, -0.06621059f, 0.29366487f, 
    -0.07203835f, -0.06550144f, 0.09093209f, -0.01629429f, -0.06586570f, 0.05225924f, -0.00573590f, 0.15619142f, 
    -0.18529865f, 0.00643180f, -0.05911219f, -0.01411398f, 0.04187472f, 0.00914187f, -0.06659531f, 0.08639529f, 
    0.08459479f, 0.03536017f, 0.13981229f, -0.00681210f, -0.15326138f, -0.03752178f, -0.09969151f, -0.15173206f, 
    0.04807580f, 0.12620442f, 0.06402987f, -0.03557939f, -0.00872702f, -0.05578002f, 0.04461221f, 0.00054000f, 
    0.39934310f, 0.16944525f, 0.15708116f, -0.15292998f, -0.04342274f, -0.00712481f, -0.00373847f, 0.10750838f, 
    0.05258449f, 0.01557536f, -0.00492261f, -0.01512848f, 0.09737556f, -0.04255346f, -0.12185699f, -0.09623438f, 
    0.07265572f, -0.01775917f, -0.03797845f, 0.02621569f, 0.07790281f, -0.01927594f, -0.09546442f, -0.02108622f, 
    -0.01157180f, 0.09886406f, 0.02209339f, -0.03938802f, -0.05359036f, 0.02102389f, 0.03494684f, -0.00069192f, 
    0.10015059f, 0.08801217f, -0.01268436f, -0.03710881f, 0.02834340f, 0.21153490f, 0.22640806f, -0.06794252f, 
    -0.07054400f, -0.04321169f, -0.00367531f, 0.07563818f, 0.04764117f, -0.03287095f, 0.09703237f, 0.05125710f, 
    0.01321317f, -0.02235534f, -0.11705048f, 0.02822770f, 0.07321997f, -0.00072265f, 0.01533180f, 0.01030917f, 
    0.11678249f, -0.01957713f, 0.02245120f, -0.08569695f, 0.04739069f, 0.09222763f, -0.05136304f, 0.01620771f, 
    -0.04209005f, 0.10120194f, -0.00262873f, -0.06563889f, 0.14232457f, 0.02666885f, 0.06718536f, 0.01306530f, 
    0.20155047f, 0.01979984f, -0.00439587f, 0.12747404f, -0.05088486f, -0.12790395f, 0.02181942f, -0.01338578f, 
    0.01706040f, -0.01785585f, 0.03140974f, 0.05988388f, -0.22891326f, -0.00782750f, -0.03260087f, -0.02829796f, 
    0.03662572f, 0.08423672f, -0.05563939f, 0.08371042f, 0.00620345f, 0.11158150f, 0.06866956f, 0.03211910f, 
    -0.03306363f, 0.10325419f, -0.16128390f, 0.08302486f, -0.06133293f, 0.04649948f, 0.03106026f, 0.06220691f, 
    0.07232980f, 0.02826966f, -0.00967958f, -0.00006960f, -0.09665370f, -0.02204577f, -0.01966807f, -0.07214135f, 
    0.17474064f, 0.05367099f, -0.02122253f, 0.12537140f, -0.01858971f, -0.02691382f, -0.04986724f, -0.07210960f, 
    -0.37026727f, -0.13281113f, 0.02684002f, 0.16855913f, -0.02869526f, -0.01293954f, 0.01746701f, -0.02473872f, 
    0.00905967f, -0.01903226f, -0.05145790f, -0.01830919f, -0.22133870f, -0.16378532f, 0.00131983f, 0.26406148f, 
    -0.14889841f, 0.15653457f, 0.06324593f, -0.00961343f, 0.01719587f, 0.05437236f, -0.02118654f, 0.00323661f, 
    0.27073610f, 0.22039880f, 0.12675180f, -0.12382443f, -0.05704584f, -0.00967022f, -0.01013838f, -0.00125118f, 
    0.03423056f, 0.04835821f, -0.01866097f, 0.04163901f, 0.18749270f, -0.03421142f, -0.03791543f, -0.26523373f, 
    0.06353617f, -0.00237729f, -0.01020702f, 0.13146092f, 0.04164302f, -0.02365773f, 0.02493129f, -0.02574324f, 
    0.00656187f, -0.03371725f, -0.23216498f, -0.05006422f, -0.01549508f, -0.01659454f, -0.13279741f, 0.04227473f, 
    0.13669981f, 0.04912074f, 0.03160411f, 0.02726967f, 0.09046792f, 0.06269591f, 0.07683008f, 0.05432905f, 
    0.00115346f, -0.07202281f, 0.01876143f, 0.11834358f, 0.13911478f, 0.04680993f, 0.02805513f, 0.17168558f, 
    0.05364999f, 0.24149948f, -0.18193620f, 0.11488121f, 0.03163518f, -0.02267793f, -0.08622430f, 0.06597383f, 
    0.04406882f, 0.14157297f, -0.03233157f, -0.12197021f, 0.18220556f, -0.16761728f, 0.02666260f, 0.21633425f, 
    0.04040873f, -0.07441460f, -0.07395037f, 0.05446700f, 0.10364688f, 0.05992642f, 0.00005834f, 0.07792572f, 
    -0.22330676f, 0.03996100f, 0.17955218f, -0.15158677f, -0.00633716f, 0.00466838f, 0.06250678f, -0.08737244f, 
    -0.02826085f, 0.02498006f, 0.01520627f, 0.21849199f, -0.03999846f, -0.17980246f, 0.00949270f, -0.05629882f, 
    -0.02859746f, 0.06220289f, 0.05872530f, 0.06079355f, -0.02801318f, -0.03999563f, -0.06185305f, 0.07586358f, 
    0.15946424f, -0.19658503f, 0.08180027f, 0.03171099f, 0.00644029f, -0.04410455f, -0.01140432f, 0.01306110f, 
    0.05062623f, 0.00124585f, 0.00555672f, 0.10841630f, 0.30885330f, 0.09064257f, 0.17957121f, 0.04130027f, 
    -0.00104685f, 0.00158085f, 0.07318989f, 0.19143939f, -0.09861579f, 0.09892283f, -0.03463817f, -0.03798867f, 
    -0.08188538f, 0.09314451f, -0.17092246f, -0.04525310f, 0.06438677f, -0.07038479f, -0.07972038f, -0.07154871f, 
    0.05753889f, -0.00768209f, -0.03879013f, -0.03497254f, 0.02654181f, 0.03294125f, 0.13177793f, 0.07489317f, 
    0.05734975f, -0.06777120f, 0.01978271f, -0.10249159f, -0.02933501f, 0.00160271f, -0.01524401f, -0.03261663f, 
    -0.12349372f, -0.06000073f, 0.04446144f, -0.05844807f, -0.13893995f, 0.07622259f, -0.07467637f, 0.12749527f, 
    0.00255615f, -0.00263505f, -0.00181994f, -0.20204166f, -0.03245487f, 0.10305876f, -0.16336894f, 0.25416690f, 
    -0.07479207f, -0.10988495f, -0.05039421f, -0.12605898f, -0.03310618f, -0.02927923f, 0.02586785f, 0.09080868f, 
    0.09039832f, -0.00917869f, -0.02861205f, 0.11234025f, -0.03134452f, -0.01466241f, -0.02617236f, -0.04561264f, 
    -0.01511403f, 0.02434989f, 0.04720601f, 0.03142220f, 0.13650066f, -0.16874346f, 0.05976020f, -0.11900157f, 
    0.01621205f, -0.00677340f, -0.09057780f, 0.09467851f, 0.12695765f, -0.00931030f, 0.11947226f, 0.01505088f, 
    0.04708602f, 0.02732055f, 0.01916104f, -0.10073001f, 0.05614484f, -0.08990711f, -0.04651214f, 0.02794627f, 
    0.04598878f, -0.07753406f, 0.00089716f, 0.06305364f, -0.09040615f, 0.08196889f, 0.14247303f, -0.35246792f, 
    0.03381851f, 0.04747716f, -0.10573895f, 0.11615110f, 0.16813917f, 0.03677841f, -0.01572939f, -0.15680972f, 
    0.18330954f, 0.18545546f, 0.08955517f, -0.07921205f, -0.15373929f, -0.01850293f, -0.04163438f, -0.03832798f, 
    -0.08409257f, 0.00380634f, -0.07240675f, 0.00562207f, 0.13371846f, 0.14412491f, 0.07852698f, 0.10768051f, 
    -0.01958868f, -0.05280558f, -0.02882874f, 0.10232067f, 0.06598885f, 0.03445657f, -0.00370253f, 0.02980910f, 
    -0.04569417f, -0.02746329f, -0.13933298f, 0.22198543f, -0.00574004f, -0.08978718f, -0.08352915f, -0.04087620f, 
    -0.06883585f, 0.02831419f, 0.09612712f, 0.00190701f, 0.08305508f, 0.03294732f, 0.11344830f, -0.03523884f, 
    0.00124165f, 0.09793563f, 0.14806624f, 0.05629853f, 0.03805165f, -0.05759019f, 0.02212143f, 0.05240092f, 
    -0.06308648f, -0.24809252f, 0.04780211f, -0.06021316f, 0.14136063f, 0.00197171f, -0.02717056f, 0.10924961f, 
    -0.04285647f, -0.14121050f, -0.04621923f, 0.03604636f, 0.16148736f, -0.29601902f, -0.16817927f, -0.00292941f, 
    0.13640898f, 0.02105335f, -0.03441196f, -0.09556637f, 0.07455455f, 0.01266837f, -0.08945568f, 0.00238157f, 
    0.11530238f, 0.03584693f, 0.09575713f, -0.01397234f, -0.03344122f, 0.02217539f, -0.01369187f, 0.02013204f, 
    -0.13873182f, 0.12821350f, 0.00370824f, 0.18181603f, -0.06741232f, -0.10480934f, 0.18278553f, -0.18211395f, 
    0.03973084f, -0.05636377f, 0.00587761f, 0.11678028f, -0.03385625f, -0.16294889f, -0.03235118f, 0.06160529f, 
    0.10409169f, -0.01426114f, 0.07691956f, -0.20727979f, 0.06754560f, 0.00676747f, -0.05682662f, 0.04232814f, 
    0.03417505f, -0.02960299f, 0.02050088f, 0.11034304f, 0.21898082f, 0.09101523f, 0.09525756f, -0.04115758f, 
    -0.02957739f, -0.02319713f, -0.10422521f, -0.00802938f, -0.01690943f, -0.02535094f, 0.07102714f, -0.06383679f, 
    0.25399792f, -0.02629216f, -0.09660134f, -0.13027994f, -0.11434066f, 0.04550168f, -0.12015691f, -0.06074690f, 
    -0.02679133f, 0.09655373f, 0.03411684f, 0.05243191f, 0.23272607f, -0.03760173f, -0.13843276f, 0.07416234f, 
    -0.03452643f, -0.00826082f, 0.02064282f, 0.00050017f, 0.06446981f, 0.06001328f, 0.04822085f, -0.06681708f, 
    0.36204270f, 0.04497742f, -0.02179301f, -0.33133492f, 0.07681223f, 0.03415924f, -0.03347379f, 0.03096256f, 
    0.10527198f, 0.03201231f, -0.05508520f, 0.03833176f, -0.22578070f, 0.06935235f, -0.07087769f, -0.30424437f, 
    0.05205021f, -0.15322863f, 0.00883346f, 0.04245346f, 0.08415603f, -0.00977974f, 0.09301971f, 0.06673472f, 
    -0.00661734f, -0.21912073f, -0.03605377f, 0.04547289f, 0.00862376f, -0.04549457f, -0.11252312f, -0.02387861f, 
    -0.00281010f, -0.08446928f, 0.06520526f, 0.02031305f, -0.05400629f, 0.04821454f, -0.08133268f, 0.35316068f, 
    0.05732903f, -0.04406925f, 0.01435341f, -0.10255750f, -0.03770355f, -0.05616712f, 0.08232573f, 0.11250450f, 
    -0.02963727f, 0.02359534f, -0.04103468f, -0.01848985f, 0.03895250f, 0.02456337f, 0.04360176f, -0.04104949f, 
    0.03109089f, 0.01779381f, 0.02908080f, -0.02401707f, 0.03146760f, -0.05864224f, -0.02994388f, -0.02263215f, 
    -0.00076237f, 0.00862231f, -0.04915161f, 0.00386536f, -0.05672741f, 0.04710153f, 0.00614265f, 0.03743837f, 
    -0.03306341f, -0.01397783f, 0.03366806f, 0.00232551f, 0.00443956f, 0.01946357f, -0.03524789f, -0.05361604f, 
    0.01806162f, 0.01964829f, 0.02154069f, -0.05164781f, 0.01785007f, 0.00070853f, 0.02605686f, 0.01530581f, 
    0.04220958f, -0.05321461f, 0.00088104f, -0.00069039f, -0.03692376f, 0.00990514f, 0.01957165f, -0.01526035f, 
    -0.00533739f, 0.00692740f, 0.03553488f, -0.01565458f, -0.04501501f, 0.02208711f, 0.00486232f, -0.05534387f, 
    -0.03610858f, -0.01043805f, -0.04096466f, 0.01746553f, -0.02854392f, 0.03335845f, 0.03126431f, -0.01939296f, 
    0.03882964f, -0.00187079f, -0.00246169f, 0.03722120f, -0.03779611f, -0.05016206f, -0.00111200f, -0.03102999f, 
    0.01286137f, 0.00136374f, -0.01136992f, -0.01195265f, 0.01122842f, -0.05359526f, -0.00418910f, 0.02064825f, 
    -0.02790052f, 0.04162129f, 0.01638189f, -0.05145054f, 0.01520989f, -0.01165857f, 0.00131596f, 0.02360551f, 
    0.03157846f, -0.02097935f, 0.04154222f, -0.01846543f, 0.02397216f, 0.02254405f, -0.04586554f, 0.03325711f, 
    -0.03096835f, -0.04397293f, -0.00185916f, 0.04348022f, -0.05658008f, 0.03677212f, -0.01968640f, -0.00185252f, 
    0.02803671f, -0.04552591f, -0.03096856f, 0.04293916f, -0.01085046f, 0.04069087f, -0.04001764f, 0.01332690f, 
    0.00989521f, -0.01038338f, -0.05250062f, 0.00132481f, -0.01634976f, -0.01749289f, -0.02533674f, 0.04056427f, 
    -0.02021542f, -0.01069872f, -0.01504997f, -0.03547015f, 0.00475194f, 0.03914662f, -0.03210085f, 0.01981548f, 
    0.03839693f, 0.04538440f, -0.00734808f, 0.02211178f, 0.02771392f, -0.04334797f, 0.04646756f, -0.05488157f, 
    -0.05378516f, -0.01326587f, -0.04519747f, -0.03386875f, -0.04300188f, -0.04474092f, 0.03838972f, -0.04923889f, 
    -0.03841062f, 0.02054082f, -0.04598140f, -0.00848317f, -0.02743431f, -0.01202746f, -0.02940208f, 0.04194304f, 
    -0.05372463f, -0.01136967f, -0.04849643f, -0.03864046f, 0.03918901f, 0.02783399f, 0.04330719f, 0.03502258f, 
    -0.01736274f, -0.01979610f, -0.01775539f, -0.05208704f, 0.03798852f, -0.05116990f, -0.01338063f, -0.00984810f, 
    -0.05546542f, -0.05851161f, 0.02817022f, -0.00376617f, 0.02454058f, 0.03262755f, -0.03093913f, 0.01823399f, 
    -0.02164627f, 0.03226876f, -0.01164484f, 0.00494604f, 0.03081978f, -0.04813829f, -0.05368706f, 0.01207012f, 
    -0.00256454f, -0.05591480f, 0.03419235f, 0.02407830f, -0.02494452f, -0.03487655f, -0.01683321f, 0.00814589f, 
    0.02496666f, -0.05343863f, 0.03286980f, 0.00171866f, -0.02552911f, 0.00724131f, -0.04937566f, 0.01113432f, 
    0.02183006f, -0.04058339f, -0.04189610f, -0.01495730f, -0.03529583f, -0.05180039f, -0.02893940f, 0.00522249f, 
    0.01509983f, -0.02538287f, -0.05194915f, -0.00349243f, 0.04830151f, 0.01793298f, -0.02991140f, -0.01642240f, 
    -0.01233567f, 0.02601813f, -0.04953958f, 0.03079718f, 0.00661122f, -0.05175780f, -0.05573506f, 0.00057240f, 
    0.00643687f, -0.05679419f, 0.04162610f, -0.01236065f, -0.01707219f, -0.02649213f, 0.00123903f, 0.02089933f, 
    0.03758030f, -0.03156691f, 0.03234138f, 0.02845285f, -0.04216481f, -0.03259058f, 0.04690930f, 0.01056173f, 
    0.00391277f, 0.03319018f, -0.03862902f, -0.03028940f, -0.01669354f, -0.01040695f, 0.02558815f, -0.01554821f, 
    -0.05462130f, -0.01459635f, 0.01233246f, 0.01160491f, -0.01925410f, 0.01545103f, -0.05199586f, -0.00129683f, 
    -0.05763926f, 0.03051580f, -0.00976715f, -0.05593847f, -0.00626753f, 0.00333383f, -0.01435736f, -0.02134092f, 
    0.03873230f, 0.02214958f, 0.00571723f, 0.02691807f, 0.04712791f, -0.05528105f, 0.01250052f, -0.02655951f, 
    -0.00320443f, 0.01469095f, -0.02761753f, -0.01097274f, -0.01038386f, -0.03441655f, -0.05493379f, 0.03862992f, 
    0.01353833f, -0.04573463f, -0.04552107f, 0.01109745f, -0.00626811f, 0.01795054f, -0.05171224f, -0.01952849f, 
    -0.01763098f, 0.02418223f, -0.01233834f, 0.01441784f, -0.06218602f, -0.01647091f, 0.00027795f, -0.03046768f, 
    -0.02128576f, -0.03310053f, -0.02199477f, 0.01619293f, 0.04011207f, -0.00612393f, -0.05653108f, -0.01639039f, 
    0.02267830f, 0.03843710f, -0.05935785f, -0.04212585f, -0.01917246f, -0.03444380f, 0.03126699f, 0.03965260f, 
    0.01978429f, -0.02251062f, -0.02098435f, 0.01480349f, -0.00190747f, -0.03390605f, -0.03028700f, -0.03604609f, 
    0.02597414f, 0.00053296f, 0.02289605f, -0.03048509f, 0.04465199f, -0.03364041f, -0.00184130f, -0.05237318f, 
    0.03746023f, -0.00412672f, 0.03371191f, -0.01591362f, 0.04603860f, 0.02551927f, 0.02653845f, -0.00116249f, 
    -0.01180410f, 0.04149671f, 0.00085836f, -0.03781421f, 0.04562237f, -0.00583562f, -0.01921650f, -0.02195036f, 
    -0.00201379f, 0.00662232f, -0.03114308f, 0.00431323f, 0.03522022f, 0.05264778f, 0.02977285f, -0.03462107f, 
    0.00875681f, 0.02695910f, -0.03665639f, -0.04343322f, -0.05607485f, 0.01731277f, 0.00306056f, -0.03256888f, 
    0.02049041f, -0.00832562f, -0.04246165f, -0.03053058f, -0.05703405f, 0.02033138f, -0.00693135f, 0.02623956f, 
    -0.02500440f, -0.00593929f, -0.04089480f, -0.01894443f, 0.02033154f, -0.02821050f, -0.00670670f, 0.04130918f, 
    0.00488513f, -0.03663602f, -0.02528019f, -0.02846439f, 0.04438268f, 0.01898957f, 0.02753186f, -0.00277512f, 
    0.24646363f, -0.02073826f, 0.10277408f, -0.04097698f, -0.18847783f, -0.03714652f, 0.04719191f, 0.01605943f, 
    -0.04253112f, -0.02534276f, 0.02889155f, 0.00161452f, -0.02556577f, 0.23437946f, 0.05215152f, 0.00311188f, 
    -0.00194144f, 0.03277477f, -0.04401781f, 0.09743676f, 0.02123933f, 0.01815477f, 0.03750352f, 0.01520712f, 
    0.04231096f, 0.07630157f, -0.05876118f, 0.00073951f, -0.03139602f, 0.07785767f, -0.02236384f, -0.00732436f, 
    -0.09616454f, 0.11470854f, -0.00807915f, -0.00197944f, 0.00239282f, 0.08775312f, -0.05192990f, 0.09537835f, 
    0.06042654f, 0.02777106f, -0.10281578f, 0.01216991f, 0.00715034f, 0.10821689f, -0.08742458f, -0.08054949f, 
    0.01873563f, -0.22064152f, -0.07221912f, -0.08885569f, -0.16056634f, 0.02759882f, 0.02000865f, 0.02507003f, 
    -0.07456522f, 0.06295156f, 0.03503786f, 0.04589047f, 0.26830953f, -0.24812672f, 0.20558885f, -0.20145321f, 
    0.01551265f, 0.07666288f, 0.06650717f, 0.10213545f, -0.03014445f, 0.01178126f, 0.03457841f, 0.04015030f, 
    0.04853165f, 0.16093811f, -0.17624176f, 0.19903582f, -0.04396877f, 0.00640178f, -0.07036443f, 0.06655298f, 
    0.03521917f, 0.03956068f, -0.02084623f, 0.09349023f, 0.17429528f, 0.19668442f, -0.11733884f, -0.20678671f, 
    0.05963127f, -0.06396787f, 0.00495660f, 0.15505971f, 0.06677847f, 0.08588151f, -0.06641007f, 0.00847741f, 
    0.11130838f, -0.06172632f, 0.14950041f, 0.17174260f, -0.18077180f, -0.08845235f, 0.08174171f, 0.03218214f, 
    0.03299038f, -0.05620563f, 0.00955296f, 0.00527671f, 0.23018955f, -0.14076652f, 0.06448667f, 0.15168694f, 
    -0.11261109f, -0.08217291f, 0.01370165f, -0.01402206f, -0.12895906f, 0.07783947f, 0.01703475f, 0.01347792f, 
    0.06569074f, 0.03048779f, 0.12729636f, 0.14902943f, -0.14792176f, -0.00450841f, 0.09557997f, 0.12518069f, 
    0.06813185f, 0.05350280f, -0.03309351f, -0.18224169f, -0.13573325f, 0.14706707f, -0.16843726f, 0.24313296f, 
    -0.09347130f, 0.11504021f, 0.01317707f, -0.05244269f, 0.05291925f, 0.01499568f, 0.08246861f, 0.01865055f, 
    0.18201871f, -0.17143671f, 0.13061719f, 0.10813068f, -0.22203138f, 0.03128514f, -0.03885493f, -0.01650885f, 
    -0.12974821f, 0.09464920f, 0.03092285f, -0.00833109f, 0.20811784f, -0.00221479f, 0.26661554f, -0.04046224f, 
    -0.05321140f, 0.07255255f, -0.02052929f, -0.04631450f, -0.06694015f, 0.07722484f, -0.03608570f, -0.17260724f, 
    0.06103527f, -0.04025213f, -0.12068461f, 0.09673879f, -0.12199354f, -0.01392329f, 0.00752173f, 0.04459276f, 
    0.08035421f, -0.05125789f, -0.14195240f, 0.09051768f, -0.00735798f, -0.03319700f, 0.08688882f, -0.08801674f, 
    0.00927356f, -0.04324656f, 0.02687556f, 0.02439719f, -0.09666657f, -0.10944628f, -0.03222564f, -0.01321193f, 
    -0.21454850f, 0.35965744f, 0.08814076f, 0.04033549f, -0.00032527f, 0.01962380f, -0.06529450f, 0.02935487f, 
    0.07020767f, -0.03650723f, 0.01526904f, -0.07437699f, 0.03058880f, 0.19165333f, -0.11691089f, -0.04171312f, 
    -0.02737022f, 0.06866635f, 0.07770029f, -0.00361072f, 0.00544805f, 0.02147836f, 0.01973007f, 0.04541514f, 
    0.07997686f, 0.01357539f, -0.09439382f, 0.15736780f, -0.22188333f, -0.07642911f, 0.04838127f, -0.01209106f, 
    0.00508917f, 0.07137380f, -0.00348213f, -0.04332062f, 0.24457680f, 0.02967714f, 0.01944300f, -0.14919300f, 
    0.03453289f, -0.02259989f, 0.02432405f, -0.02363889f, 0.07846519f, 0.03453087f, 0.16620067f, -0.02561079f, 
    -0.13599308f, 0.04885502f, 0.13451491f, 0.07058111f, 0.02570170f, -0.00052609f, 0.01742592f, 0.05554155f, 
    0.08992430f, 0.05922154f, 0.07681910f, -0.07541486f, 0.09948435f, 0.01339648f, -0.10623994f, 0.14890704f, 
    -0.14483184f, -0.05273938f, 0.12798588f, 0.02038651f, 0.04700642f, 0.00000126f, 0.06919552f, 0.00202007f, 
    0.02830755f, 0.07520238f, 0.06241170f, -0.36642987f, -0.07059306f, 0.01613234f, 0.00211268f, -0.02351144f, 
    0.06491239f, 0.01747312f, 0.07804523f, 0.01730796f, 0.12201942f, 0.12405479f, 0.10763248f, -0.01194622f, 
    0.10044128f, -0.05487658f, 0.14056343f, 0.10279786f, -0.07177384f, 0.08367375f, -0.00640293f, 0.00746190f, 
    0.03563426f, -0.15565389f, -0.08795565f, -0.13305040f, -0.20829032f, -0.18043785f, 0.03367751f, 0.03468506f, 
    -0.00435536f, -0.05376539f, -0.02163995f, 0.00348705f, -0.13804021f, 0.21731254f, -0.11172888f, 0.02504221f, 
    -0.02810411f, 0.01876217f, 0.07631876f, -0.05426484f, 0.02798652f, 0.04151769f, 0.04181850f, -0.06298449f, 
    -0.09379253f, 0.08114702f, 0.05946872f, -0.16289650f, 0.07757553f, -0.03458533f, -0.04681335f, -0.06514733f, 
    0.05465864f, -0.04946489f, 0.00099572f, 0.03140184f, 0.19867644f, 0.13207842f, 0.07454380f, -0.29069632f, 
    0.13671413f, -0.12571758f, 0.00374118f, 0.08718789f, -0.10361587f, -0.00618317f, -0.02591582f, -0.04656447f, 
    0.06865834f, 0.13074070f, 0.05290536f, -0.08537691f, 0.04697454f, -0.02344983f, 0.01605429f, 0.06127115f, 
    0.12958178f, 0.01286071f, -0.04678169f, -0.01327187f, -0.06230692f, 0.25651976f, 0.05036085f, -0.00521256f, 
    -0.04991543f, -0.04848431f, 0.14453995f, -0.05551838f, -0.05689250f, 0.01744114f, 0.01494923f, 0.03931765f, 
    0.27369624f, -0.04329551f, -0.16342814f, 0.14867669f, -0.13092509f, -0.01354507f, 0.04912355f, 0.06620407f, 
    0.08237079f, -0.14097862f, -0.02405614f, -0.02885536f, 0.20323165f, -0.18908077f, 0.03028141f, 0.19006908f, 
    -0.03315294f, 0.01079372f, -0.02101325f, 0.04728827f, -0.12684159f, 0.02325920f, 0.05725544f, -0.01596028f, 
    -0.13743842f, -0.19507925f, 0.17506987f, 0.13511130f, 0.02307602f, 0.09067505f, -0.02666663f, -0.11226431f, 
    -0.02549624f, -0.04643650f, 0.11200157f, -0.01508807f, 0.25030613f, -0.02580975f, -0.05876867f, -0.19906026f, 
    -0.13793872f, -0.03426924f, 0.02514748f, 0.04897553f, -0.01158854f, -0.01332196f, -0.13039599f, 0.07073975f, 
    0.24948300f, -0.03155860f, 0.07867431f, 0.02905991f, -0.11891467f, -0.06339353f, -0.06517425f, -0.07781738f, 
    -0.00557839f, -0.14129616f, 0.04777965f, 0.12787390f, 0.00440508f, 0.14336483f, -0.18526632f, -0.02489316f, 
    0.07130744f, 0.00607289f, 0.15690678f, 0.02856462f, 0.05334583f, 0.03853268f, -0.15541196f, -0.18905182f, 
    0.02944324f, -0.18660474f, -0.18094464f, -0.12172715f, -0.06897509f, 0.01492121f, -0.03068129f, -0.00471537f, 
    0.13202041f, 0.00664743f, 0.02186944f, 0.01132467f, -0.01324514f, 0.11128436f, 0.08693864f, 0.15916665f, 
    -0.03926671f, -0.01317753f, 0.04683076f, -0.05538173f, 0.13661695f, -0.04083093f, 0.13160470f, -0.04945912f, 
    0.14071438f, 0.04017849f, -0.03135180f, -0.08853494f, -0.20817956f, 0.02201140f, -0.01152567f, 0.00337603f, 
    0.08321720f, 0.01935995f, 0.04743100f, 0.18105450f, 0.08516820f, 0.19248341f, 0.05426377f, 0.16009600f, 
    -0.09888367f, -0.06780432f, -0.03306726f, -0.02246799f, 0.00057608f, -0.00253521f, 0.08114120f, 0.05891655f, 
    -0.29782888f, -0.09957056f, 0.22545049f, 0.20477894f, 0.09395203f, 0.08476267f, 0.00398260f, -0.04610299f, 
    0.04244701f, -0.09180214f, -0.00412096f, 0.00450107f, -0.22788742f, -0.01299929f, -0.09317377f, 0.11082540f, 
    0.02116381f, -0.04577664f, 0.02049667f, -0.07739116f, -0.03306413f, 0.11977606f, 0.04827375f, 0.07984966f, 
    0.25934443f, 0.18699086f, 0.01102594f, -0.08109064f, 0.01206160f, -0.00855588f, 0.01753791f, 0.12937915f, 
    -0.05371627f, 0.06813293f, -0.00338148f, 0.16273871f, 0.00811515f, -0.06197603f, -0.12522127f, 0.01859424f, 
    0.04188442f, -0.07627466f, -0.05746618f, -0.03449669f, -0.01094086f, 0.04167272f, -0.09979242f, 0.01053433f, 
    0.07877803f, -0.19650237f, -0.01952117f, 0.00603917f, 0.01184775f, 0.08511586f, 0.02944013f, -0.06498066f, 
    0.03768732f, -0.01513729f, 0.10374571f, 0.04639495f, 0.10321756f, 0.35364312f, 0.00717822f, -0.06421250f, 
    0.11540007f, -0.11629883f, -0.04427651f, 0.01018523f, 0.11394167f, -0.06318703f, 0.08129591f, 0.00009054f, 
    0.07426852f, -0.07707866f, -0.09776525f, -0.00131380f, 0.05075028f, 0.02409009f, 0.04938903f, 0.09942245f, 
    0.02041665f, -0.01725906f, -0.00006696f, 0.05253328f, -0.03980261f, 0.12454487f, 0.01965322f, -0.02691423f, 
    0.20624432f, 0.02367666f, 0.02896781f, 0.07248341f, -0.07971600f, 0.09574112f, -0.07128438f, -0.04028131f, 
    0.04502916f, 0.00685236f, -0.10188677f, 0.06337608f, 0.00955700f, -0.02843257f, -0.07190465f, 0.13545746f, 
    0.06430583f, 0.03184298f, 0.01623323f, -0.03990635f, 0.14343593f, -0.04840963f, -0.00468478f, -0.06653015f, 
    -0.10571234f, 0.02543044f, 0.10670429f, 0.14608261f, -0.07410152f, 0.04046384f, -0.07222551f, 0.06682099f, 
    -0.31987342f, -0.01444531f, 0.03305252f, 0.06063414f, 0.00600929f, 0.16995056f, -0.00927896f, 0.00365951f, 
    0.13588832f, -0.06876050f, 0.15316811f, 0.02487471f, 0.02705228f, 0.03581765f, 0.14799772f, 0.26483667f, 
    -0.13451271f, -0.07361320f, -0.01467516f, 0.02379963f, 0.05559279f, -0.04462925f, 0.01974567f, 0.05511260f, 
    0.05240444f, -0.02911825f, 0.00399370f, -0.12990548f, 0.00193804f, -0.03985475f, 0.14693628f, -0.04396437f, 
    0.06928168f, 0.07869532f, 0.00414863f, 0.03149135f, -0.19911712f, -0.05225622f, -0.04128242f, 0.11282232f, 
    0.00999637f, 0.05607771f, 0.05425438f, -0.07680491f, -0.09983464f, -0.02815860f, -0.10857802f, 0.08270855f, 
    0.10150050f, 0.09387631f, 0.04234679f, -0.11645217f, 0.02310746f, -0.05723282f, 0.01110282f, -0.05701779f, 
    0.12360012f, 0.04416671f, 0.01014847f, -0.00562052f, -0.00939793f, 0.22512068f, -0.00206065f, 0.06358677f, 
    -0.11831200f, -0.09720585f, -0.07232405f, 0.03067819f, -0.11502113f, -0.04266188f, 0.17729314f, 0.05264353f, 
    -0.30297256f, -0.15268779f, -0.02922452f, -0.04948598f, 0.02912997f, -0.03675132f, -0.02574889f, -0.00017780f, 
    0.04225523f, -0.02060375f, -0.00933707f, 0.07541723f, 0.10788359f, 0.16407225f, -0.20685399f, -0.11771280f, 
    0.07952671f, -0.13913167f, -0.10757948f, 0.00723263f, -0.02032167f, 0.16871454f, -0.06729960f, -0.03031262f, 
    -0.29450008f, 0.40780431f, -0.07990469f, 0.08349264f, 0.11501548f, 0.01841911f, 0.02455461f, -0.01554313f, 
    0.05896100f, 0.07133631f, 0.00840286f, 0.11879699f, 0.05954989f, 0.22616041f, 0.03623259f, 0.05574554f, 
    0.06548534f, -0.01514799f, 0.01570750f, 0.05807945f, -0.02265612f, 0.03888478f, 0.06147815f, 0.00386258f, 
    -0.20211567f, 0.07319677f, -0.12934287f, -0.02426231f, 0.10592189f, -0.11375379f, -0.00388277f, 0.01990087f, 
    0.00504859f, 0.10807756f, 0.06083865f, 0.05692456f, 0.46953416f, 0.23964050f, -0.28243086f, -0.22486576f, 
    0.16467057f, 0.04948821f, -0.04898959f, 0.03465430f, -0.00196257f, 0.16317651f, -0.06891797f, -0.08347443f, 
    -0.24227004f, -0.14933479f, -0.07929439f, 0.18704984f, -0.01624421f, 0.08666046f, -0.05064210f, -0.02566674f, 
    -0.02194217f, -0.07027798f, -0.01432264f, -0.01262997f, 0.17959474f, -0.09910180f, 0.00299202f, 0.02029567f, 
    -0.07830250f, 0.07453438f, -0.05554182f, 0.06048345f, 0.01855257f, -0.05037846f, 0.00110624f, 0.02752601f, 
    -0.07735006f, -0.01021064f, -0.04526670f, -0.03891600f, 0.10372062f, 0.04511198f, -0.04845684f, -0.01466677f, 
    0.03245463f, 0.03255139f, -0.10353809f, 0.06488670f, 0.05485972f, 0.08404725f, -0.06016440f, 0.17429124f, 
    0.01982987f, -0.07400911f, -0.02515835f, -0.04466473f, 0.12761156f, -0.10417988f, 0.15851283f, -0.04452171f, 
    -0.15277700f, 0.04259823f, -0.07334355f, -0.01200590f, 0.16318414f, -0.03361976f, 0.03335834f, -0.00073095f, 
    0.06450158f, 0.12154084f, -0.06487609f, 0.12879595f, 0.19537528f, -0.09606012f, 0.14598730f, 0.04144844f, 
    0.04828335f, -0.02025938f, 0.11425412f, 0.02719112f, -0.05253192f, -0.11010199f, 0.10048882f, 0.23144078f, 
    -0.10450936f, -0.07963791f, 0.17091738f, 0.09772693f, 0.09985609f, -0.01467590f, 0.04696361f, 0.04946886f, 
    0.06774917f, -0.01716564f, -0.00835059f, -0.05511265f, -0.04680012f, 0.17228213f, -0.30664504f, 0.16880232f, 
    0.17586148f, 0.00603247f, -0.06608862f, -0.11063423f, 0.02239077f, 0.14537397f, 0.03165430f, 0.07057584f, 
    -0.03264264f, -0.16770315f, 0.19919237f, -0.07391955f, 0.10671023f, -0.01112108f, -0.07919458f, 0.02244164f, 
    0.00393176f, 0.05215439f, -0.05315381f, -0.07206415f, -0.15883142f, -0.17787811f, 0.02683350f, -0.09931138f, 
    0.00936010f, -0.00527369f, -0.09213357f, 0.10683088f, -0.03110734f, 0.05021909f, -0.10932711f, -0.02576293f, 
    0.11306459f, -0.05597122f, -0.23094574f, -0.25576699f, 0.18507424f, -0.02631027f, -0.01954660f, 0.04026052f, 
    0.08729249f, 0.04109191f, -0.01682085f, -0.03682343f, 0.11978931f, 0.09631903f, -0.01363429f, -0.10806307f, 
    0.08818946f, 0.08435863f, -0.04880006f, -0.02801121f, 0.03848634f, -0.02880293f, 0.04179928f, -0.17746665f, 
    0.00256095f, -0.10316273f, -0.11059230f, 0.09337405f, -0.01085762f, 0.05572715f, 0.01413746f, -0.05050721f, 
    0.18043414f, 0.00563147f, -0.03165316f, -0.16748160f, -0.22755592f, -0.08603561f, 0.08034005f, -0.19741626f, 
    0.12154750f, 0.00298079f, -0.04948598f, 0.09532185f, 0.03789707f, 0.06890250f, 0.10311481f, 0.08473226f, 
    -0.14245985f, 0.06823049f, -0.10932545f, -0.14160053f, 0.24378090f, 0.00521112f, 0.07346850f, -0.04349141f, 
    -0.00846927f, 0.00258121f, -0.02338068f, -0.00991566f, 0.13421184f, -0.18555991f, 0.09671676f, -0.09393132f, 
    -0.16722696f, 0.12131967f, -0.03828592f, 0.04572421f, 0.05439507f, 0.04290850f, 0.06984133f, 0.10565448f, 
    -0.17590852f, 0.09938351f, 0.19281614f, -0.11562080f, 0.09362946f, 0.04056531f, -0.01214748f, -0.08988614f, 
    -0.05818812f, 0.05191947f, 0.20742027f, 0.12675571f, 0.24832121f, -0.00797083f, -0.05008398f, 0.18573311f, 
    -0.01169149f, 0.10878350f, -0.10438156f, -0.03994824f, 0.09149333f, 0.04613118f, 0.11203618f, 0.08608896f, 
    0.11414827f, -0.13860428f, -0.00352944f, -0.18024805f, 0.00969051f, 0.06773705f, 0.00568540f, 0.09219034f, 
    0.01102828f, 0.08497149f, -0.06317501f, 0.10373769f, 0.00065984f, 0.07652263f, 0.04807030f, 0.09902813f, 
    -0.02471596f, -0.14666308f, -0.01177751f, -0.03120078f, 0.02169978f, 0.06803260f, 0.06925687f, 0.04463970f, 
    -0.14404628f, -0.02049773f, 0.06182688f, -0.18364380f, 0.09317953f, 0.06780204f, -0.03406984f, 0.01324520f, 
    -0.00773580f, -0.02258100f, -0.09817617f, 0.06717502f, -0.02177336f, -0.15706006f, -0.01433195f, 0.03843078f, 
    -0.00404632f, 0.00665784f, 0.12616080f, 0.10829209f, -0.11963980f, 0.07200872f, 0.13061014f, -0.00334049f, 
    0.16586521f, -0.02807971f, -0.07231500f, 0.18642990f, 0.03107855f, -0.15942422f, -0.13673881f, 0.17110862f, 
    -0.06439216f, -0.13094200f, 0.11334714f, 0.03433326f, -0.04535569f, 0.07186019f, -0.00114405f, -0.10292707f, 
    0.11087523f, 0.15423800f, -0.00209511f, 0.01456733f, 0.11435891f, 0.09526420f, 0.06303245f, 0.07497104f, 
    0.08882012f, -0.23943925f, 0.06150038f, 0.14343551f, 0.07758141f, -0.02450649f, -0.04466275f, -0.02987325f, 
    -0.15659860f, -0.00917124f, 0.09718720f, -0.08385310f, 0.06502475f, -0.19691035f, -0.14836420f, 0.12362506f, 
    -0.04790679f, -0.00788089f, -0.04993909f, 0.06456732f, 0.05056435f, 0.01016439f, -0.00103792f, -0.04041839f, 
    0.08493154f, 0.06868810f, 0.17978001f, -0.04030484f, 0.10558728f, 0.09183552f, 0.05984908f, -0.11668236f, 
    0.10332900f, 0.05033647f, 0.06940269f, -0.09773078f, -0.00210641f, -0.10732340f, -0.05446420f, -0.12978430f, 
    0.05454894f, 0.04639933f, 0.01093869f, 0.12670460f, 0.10484396f, 0.05475497f, 0.12163214f, 0.01434672f, 
    0.23483437f, -0.17401573f, -0.00523119f, 0.01847385f, 0.00660361f, -0.00972798f, 0.03881545f, 0.07692352f, 
    -0.03423233f, 0.02172077f, 0.08541857f, -0.12234688f, 0.11684853f, -0.15225606f, -0.16371922f, 0.03472775f, 
    -0.15858158f, -0.07288493f, -0.13415347f, -0.08149874f, 0.03005700f, -0.01710348f, -0.08023247f, 0.08930028f, 
    0.01530748f, -0.11115105f, 0.01032274f, 0.03187568f, -0.06948867f, 0.06570763f, 0.00108736f, 0.08394597f, 
    -0.08817335f, -0.02889076f, -0.03350633f, 0.05834886f, 0.08333815f, -0.02595556f, -0.09035476f, 0.13486236f, 
    -0.07991545f, 0.10335570f, -0.03462956f, 0.02401731f, -0.00593338f, -0.12279625f, 0.05080128f, 0.15697436f, 
    -0.22588709f, 0.10127427f, -0.09034486f, -0.13374439f, 0.03587219f, 0.02766579f, 0.00393527f, 0.01945621f, 
    0.12831169f, 0.03278989f, -0.00663642f, 0.08929449f, 0.05012648f, 0.20476876f, -0.00146681f, 0.09932964f, 
    0.08577996f, -0.06220928f, 0.03909169f, -0.02160004f, -0.01474381f, -0.02496756f, 0.03393670f, -0.05101133f, 
    -0.04621406f, -0.10983916f, -0.13799343f, 0.25027677f, 0.08461288f, 0.08316055f, 0.01279546f, 0.01685743f, 
    -0.06686223f, -0.00823413f, 0.04239758f, 0.01482273f, -0.20304684f, 0.04437822f, 0.25065428f, -0.03499512f, 
    -0.01815597f, 0.07027544f, 0.09854708f, 0.07016670f, 0.04087345f, -0.04220124f, 0.02414641f, 0.15019317f, 
    -0.09865353f, 0.01493266f, 0.01379320f, -0.07250225f, 0.03344702f, -0.02993333f, 0.00746864f, 0.01645555f, 
    -0.01348524f, 0.07481258f, -0.01537419f, -0.01617791f, 0.17773640f, 0.00456756f, 0.15215492f, -0.08793975f, 
    -0.05010015f, 0.01543563f, 0.06666988f, -0.06301669f, 0.02584995f, 0.03888885f, 0.07395084f, 0.00900538f, 
    -0.04925719f, 0.18556127f, -0.05499497f, -0.09463981f, -0.09572535f, -0.07838573f, 0.04964396f, -0.08371446f, 
    0.05103391f, -0.05379348f, -0.01142285f, -0.05495521f, -0.04601491f, -0.01285642f, -0.13044827f, -0.00232142f, 
    -0.07854248f, -0.17333962f, 0.05043504f, 0.06886402f, 0.05176162f, 0.12130976f, 0.00374899f, 0.05915067f, 
    -0.04390604f, 0.15088002f, 0.26729926f, 0.00538460f, 0.10700046f, 0.09759654f, 0.02330728f, -0.05559899f, 
    -0.06112568f, -0.03459585f, -0.06449261f, -0.02645888f, 0.13928863f, 0.30634868f, 0.17711340f, 0.14780524f, 
    -0.00616244f, 0.11182249f, -0.03088689f, -0.06458952f, 0.00224382f, -0.06624386f, 0.05782030f, 0.00712006f, 
    0.08553240f, -0.04669742f, -0.11968405f, 0.13840093f, -0.02049534f, 0.00997508f, -0.01449556f, -0.05742670f, 
    0.02895382f, -0.02169374f, -0.00266942f, -0.01571462f, 0.05024488f, -0.06039688f, 0.01602796f, 0.05998362f, 
    -0.00026954f, 0.10114226f, -0.04225466f, -0.01734478f, 0.06491956f, -0.03508444f, 0.00382807f, -0.03141345f, 
    -0.00050220f, 0.05634524f, 0.01989189f, -0.07596323f, 0.00551542f, -0.07817537f, -0.07498288f, -0.08942571f, 
    -0.00130543f, -0.01159297f, 0.13344055f, 0.10692653f, -0.01599282f, 0.11825095f, 0.08534901f, -0.06898087f, 
    -0.05524816f, -0.09803443f, 0.07843863f, -0.04709642f, 0.03730276f, -0.01502977f, 0.00013418f, -0.08010452f, 
    0.06080674f, 0.03771675f, 0.07732741f, 0.09095959f, -0.00744612f, -0.04144292f, -0.03733475f, -0.02092591f, 
    0.00025723f, -0.03374017f, 0.01279123f, 0.03583608f, 0.04401927f, 0.19003354f, -0.02780077f, 0.16301656f, 
    0.14038137f, 0.04124195f, 0.04337090f, 0.01036852f, 0.07585452f, -0.02108923f, -0.03978971f, 0.06931539f, 
    0.13369906f, 0.06407757f, -0.03818337f, -0.11783350f, -0.08199210f, -0.08784163f, 0.00643972f, -0.08645225f, 
    0.00831703f, -0.13546531f, 0.11904451f, -0.13318500f, 0.01638759f, 0.12598816f, 0.07710484f, 0.25540355f, 
    -0.06726711f, -0.07400054f, -0.01437529f, 0.06526548f, 0.09771187f, -0.06258169f, -0.00134652f, -0.05352278f, 
    -0.03534713f, 0.04124568f, 0.04793140f, -0.06428456f, -0.07762823f, -0.08219319f, 0.03399631f, 0.07417254f, 
    -0.06970473f, -0.05492179f, -0.11549634f, -0.06144132f, -0.17498836f, 0.04741731f, 0.08591437f, -0.11533297f, 
    0.06550659f, 0.05062370f, -0.00653576f, 0.01928019f, -0.06053428f, 0.02275260f, 0.02280600f, -0.07139786f, 
    0.15363890f, -0.06599281f, -0.13575031f, 0.09272959f, 0.04835352f, -0.13452847f, -0.01785907f, -0.06034071f, 
    -0.16226000f, -0.04913915f, 0.02651393f, 0.02110188f, -0.14032720f, 0.25318781f, 0.20585525f, 0.14090125f, 
    0.04779448f, 0.09109066f, 0.06032567f, 0.04389968f, -0.10152653f, 0.01986920f, -0.05146172f, -0.01153333f, 
    -0.02691286f, 0.12197063f, 0.17890486f, 0.14261030f, 0.11067123f, 0.06541853f, -0.03098385f, -0.00833903f, 
    -0.10999113f, -0.09341426f, -0.12428910f, -0.01519373f, 0.11678375f, -0.14083330f, -0.20956260f, -0.16729423f, 
    0.04775188f, -0.07420523f, -0.03091709f, 0.03251089f, -0.05041539f, 0.03269511f, -0.03615186f, 0.00031099f, 
    -0.08854062f, 0.16794825f, 0.15536334f, 0.03375465f, 0.07800755f, 0.01161078f, 0.07688965f, -0.04020766f, 
    -0.05059442f, -0.01498493f, -0.02590602f, 0.00372644f, 0.00802556f, 0.03808459f, 0.04708070f, 0.08668065f, 
    0.23463513f, 0.16981806f, 0.02702314f, 0.05651226f, 0.03727818f, 0.05167717f, 0.03787785f, -0.09087881f, 
    0.12173408f, 0.07683085f, -0.12165878f, -0.12849337f, -0.06796384f, -0.01915887f, 0.03712334f, -0.05825477f, 
    -0.00528688f, 0.04095102f, -0.07727168f, 0.00321062f, 0.00269629f, 0.06242722f, 0.19123313f, 0.12865336f, 
    0.01732223f, 0.00674575f, -0.04425670f, 0.03188178f, 0.03509830f, -0.08704930f, -0.07535502f, -0.06214642f, 
    -0.04083237f, 0.03742437f, 0.15412398f, 0.22764975f, -0.06088050f, -0.08421975f, -0.02732940f, -0.08336528f, 
    0.00101828f, 0.03446164f, -0.00054199f, 0.02792870f, -0.06209985f, 0.08353932f, -0.00755767f, 0.15531783f, 
    0.19570704f, 0.03568887f, 0.03109465f, 0.06598815f, -0.00953248f, -0.10122622f, 0.04897970f, -0.01570204f, 
    0.42963582f, 0.14224136f, -0.19585657f, -0.07194471f, 0.13724236f, -0.04037461f, -0.09193823f, 0.03684416f, 
    -0.00754752f, 0.06677103f, 0.05020763f, 0.10876659f, -0.03868352f, 0.13801742f, 0.20704359f, 0.15427138f, 
    0.06030658f, -0.02024775f, -0.06158657f, 0.03405232f, 0.04596395f, -0.01937786f, 0.09341785f, -0.03674583f, 
    0.13151647f, -0.12877102f, -0.03087144f, 0.08252126f, 0.06142661f, 0.01168995f, -0.00679760f, 0.02096578f, 
    -0.06260838f, -0.06292270f, 0.07145838f, -0.02546358f, -0.45855743f, 0.24172574f, 0.13076878f, 0.00327682f, 
    0.05428310f, -0.01817866f, 0.03182240f, -0.08354156f, 0.00617919f, 0.04470544f, -0.00086746f, -0.02293101f, 
    -0.00029829f, 0.02683186f, -0.03066186f, -0.04151132f, -0.00854639f, -0.03243821f, -0.03066125f, -0.01468766f, 
    -0.01667284f, 0.00640098f, -0.04799930f, -0.00449443f, -0.00877862f, -0.04045636f, 0.03024421f, -0.03941493f, 
    0.00289355f, 0.01192632f, 0.03414482f, -0.02256446f, 0.02021579f, -0.04191889f, -0.03140375f, -0.05348317f, 
    0.02351979f, -0.02800490f, 0.00760259f, 0.00580450f, 0.00700489f, -0.01884582f, -0.02154668f, -0.02699675f, 
    0.01661005f, 0.04199869f, -0.01716909f, -0.00709179f, 0.03225523f, -0.03922525f, -0.02018085f, 0.03615133f, 
    0.00568410f, 0.03743109f, -0.01395646f, 0.01837662f, -0.00244267f, -0.01813952f, 0.01515828f, -0.04034519f, 
    -0.05411627f, 0.02067496f, -0.00465151f, -0.00198455f, 0.04331391f, -0.03374998f, 0.02717944f, -0.04261604f, 
    0.01105179f, 0.01429118f, -0.04074570f, -0.03286626f, 0.00214395f, -0.03011432f, -0.01944194f, 0.00736873f, 
    -0.03910052f, 0.03972025f, -0.04678850f, -0.03081714f, -0.03544966f, 0.01737759f, -0.04375783f, -0.03839577f, 
    -0.00521109f, -0.00583684f, -0.01568453f, -0.01423911f, -0.01041324f, -0.02534379f, 0.00358109f, -0.04033301f, 
    -0.00145917f, -0.03121062f, -0.02693862f, -0.04720268f, 0.01232841f, 0.03625767f, -0.03128777f, 0.00789337f, 
    0.03212100f, 0.00228558f, 0.04334959f, 0.00778651f, -0.04001422f, 0.02045167f, 0.01883780f, 0.01898638f, 
    -0.03021992f, -0.03055962f, 0.01864467f, 0.00614998f, -0.01674834f, 0.01229212f, -0.02925756f, -0.03715799f, 
    -0.02653458f, 0.02464024f, 0.01921102f, -0.00477396f, 0.03658219f, -0.02350198f, -0.00625468f, -0.02227603f, 
    0.04181634f, 0.02435036f, -0.00777537f, -0.00858760f, 0.03146685f, -0.04812920f, -0.03193299f, 0.03262920f, 
    -0.03384774f, -0.00029273f, 0.01839394f, 0.02062172f, -0.02752560f, -0.02017630f, 0.05100462f, -0.00785002f, 
    -0.00032226f, -0.00653561f, -0.01806346f, -0.05081526f, 0.01971532f, -0.04211312f, 0.04029263f, -0.03899334f, 
    -0.02644408f, 0.00122316f, 0.01010294f, 0.01193807f, -0.04050969f, -0.03548931f, 0.01788006f, -0.00775378f, 
    0.03697287f, -0.02130388f, 0.00887574f, 0.02201341f, -0.01192725f, -0.04770083f, -0.04551099f, 0.04313882f, 
    0.04073866f, -0.04461389f, -0.02778512f, -0.00015249f, -0.02058930f, -0.00959528f, -0.02156684f, 0.03256938f, 
    -0.02302261f, 0.01596662f, -0.00158719f, -0.03909170f, 0.02688963f, -0.04429080f, -0.03121180f, -0.03750717f, 
    -0.01028554f, -0.01196464f, 0.00637599f, 0.00394306f, 0.04425570f, -0.01036842f, -0.03126981f, -0.00890412f, 
    0.02729070f, 0.01661436f, -0.00627068f, -0.00015089f, 0.01409808f, 0.02827017f, 0.00388241f, 0.02336466f, 
    0.04511882f, -0.05195685f, 0.04186629f, -0.02112683f, -0.04155394f, -0.01911211f, 0.04780420f, 0.01092378f, 
    0.02131216f, -0.05568364f, -0.03379574f, -0.02913375f, -0.04788340f, 0.02830400f, -0.02815169f, -0.00390900f, 
    -0.02319686f, 0.02066699f, 0.00263898f, 0.04287273f, -0.03483383f, 0.03794068f, 0.01630225f, 0.02939581f, 
    0.03946127f, -0.01785086f, -0.03069729f, -0.03105715f, -0.00951875f, -0.03977743f, -0.01230585f, -0.01970882f, 
    0.04016271f, -0.05121041f, -0.02940788f, -0.05447304f, -0.01870287f, -0.03345362f, -0.00756653f, -0.04093913f, 
    -0.01339066f, -0.03255672f, -0.03311059f, 0.04412585f, -0.01841813f, 0.02491095f, -0.04781093f, 0.02838317f, 
    0.00849463f, -0.01107195f, -0.02317339f, -0.01433544f, 0.03496537f, 0.01385793f, -0.03179047f, 0.04607644f, 
    0.01934023f, 0.01740683f, 0.00626398f, -0.00470609f, -0.01290479f, -0.01225719f, 0.03906918f, 0.00404070f, 
    0.02223483f, -0.00823636f, 0.01443744f, -0.04022944f, -0.00436838f, 0.00457771f, -0.00530130f, -0.04269679f, 
    -0.02746863f, 0.03755083f, -0.01605237f, 0.01357542f, 0.00249799f, 0.00834782f, 0.02622548f, -0.00423906f, 
    0.00233799f, -0.02697931f, 0.00970405f, 0.03724875f, -0.01458423f, -0.00708508f, 0.02365290f, 0.02570088f, 
    0.03908875f, -0.01507639f, -0.04711349f, 0.03751994f, -0.01246274f, 0.01369700f, 0.03787190f, -0.02494833f, 
    0.00649348f, 0.01526954f, 0.02441965f, 0.04796674f, -0.01746945f, 0.00504351f, 0.02453332f, 0.01274182f, 
    -0.05329944f, -0.02848970f, -0.00436837f, 0.02327332f, -0.01979094f, -0.01580782f, -0.03942252f, 0.02280871f, 
    -0.04852957f, -0.03096064f, -0.01836443f, 0.03413333f, -0.04064291f, -0.01740553f, -0.01959920f, -0.05393483f, 
    -0.02557488f, 0.01477463f, -0.04292825f, 0.01886357f, -0.04529827f, 0.02208779f, 0.00607285f, -0.00826996f, 
    -0.04188676f, 0.00944251f, -0.04097504f, -0.01077372f, 0.00380537f, 0.04098354f, -0.04795946f, -0.00977095f, 
    -0.03777898f, -0.03235761f, 0.02884600f, -0.05356763f, 0.01981916f, 0.03403124f, 0.04459041f, -0.03805337f, 
    -0.01891060f, -0.04130631f, 0.02044511f, 0.01767925f, 0.00476166f, -0.01265800f, -0.04561153f, -0.02030578f, 
    -0.03569182f, -0.01359682f, -0.01786693f, -0.01707043f, 0.00124543f, 0.04772787f, -0.02244561f, 0.02191546f, 
    -0.01836555f, 0.04413851f, -0.03021305f, 0.00644770f, 0.03023734f, -0.04502856f, 0.01917801f, -0.04223580f, 
    0.02494415f, 0.00866910f, 0.00204322f, 0.03969880f, -0.03614352f, 0.02709500f, -0.03981147f, -0.01478046f, 
    -0.03410993f, 0.03902255f, -0.00289480f, 0.01052095f, -0.00055101f, 0.03249092f, 0.02654853f, -0.00959261f, 
    0.00680380f, -0.03926788f, -0.05383399f, 0.02471213f, 0.00453445f, 0.04201157f, 0.03930668f, 0.00342991f, 
    0.00635313f, -0.03663808f, 0.00886788f, 0.02833633f, 0.01752480f, -0.03484756f, 0.01577896f, -0.02263724f, 
    -0.04995879f, 0.01672410f, 0.02012539f, 0.01108573f, 0.10172398f, 0.03984195f, -0.04615069f, 0.02137304f, 
    0.06526071f, 0.12464940f, 0.04477421f, 0.02055935f, -0.16903180f, -0.05609329f, 0.03003733f, 0.01009330f, 
    0.06504162f, -0.04892137f, 0.06295506f, 0.07914205f, 0.09953932f, 0.05814341f, 0.05615232f, 0.06082441f, 
    0.10314184f, 0.08820035f, 0.07040545f, 0.07060052f, 0.05326763f, 0.00668690f, 0.01136963f, 0.10411952f, 
    0.07231230f, 0.01596915f, 0.06409468f, -0.10523500f, -0.12195010f, -0.17290629f, 0.02911110f, 0.08850669f, 
    -0.04324487f, 0.02334546f, -0.04520604f, -0.11599422f, -0.03453251f, 0.03731493f, 0.02980261f, 0.14435814f, 
    -0.06636617f, 0.11528622f, 0.10267812f, -0.08455759f, 0.01489227f, 0.08986518f, 0.08732484f, 0.00383649f, 
    -0.06364148f, 0.00150782f, 0.06744906f, 0.06679385f, -0.10108696f, -0.06467030f, 0.09675826f, -0.08961710f, 
    0.06711537f, 0.07608845f, 0.11855731f, 0.04875926f, 0.01853211f, 0.02610809f, -0.07998791f, 0.07778770f, 
    -0.05062704f, -0.08291350f, 0.01220507f, 0.00225191f, -0.04533334f, 0.05757013f, -0.02004905f, 0.01532726f, 
    -0.06044104f, -0.11694404f, 0.04194155f, 0.05427215f, 0.30145529f, -0.08510161f, 0.02935282f, 0.00185474f, 
    -0.02818519f, -0.03396518f, -0.00198206f, -0.02230570f, -0.06453840f, -0.03547918f, 0.03801249f, 0.14031328f, 
    0.04693928f, 0.15403454f, -0.01641769f, 0.06504759f, 0.02177770f, 0.12347545f, 0.02194858f, 0.07178616f, 
    -0.04517802f, 0.07191181f, -0.03070867f, 0.07899790f, 0.05435179f, -0.02042047f, 0.15128697f, 0.03144638f, 
    0.06325866f, 0.00964121f, -0.00333258f, 0.00798507f, 0.04689946f, -0.01689123f, 0.06772052f, 0.12915453f, 
    -0.22677082f, -0.11650734f, -0.00902396f, -0.09912300f, 0.02129593f, -0.04759632f, 0.02325794f, -0.01464593f, 
    0.00011519f, 0.03258044f, 0.04304436f, 0.05161897f, 0.01870963f, 0.20588134f, 0.06618525f, 0.15494451f, 
    -0.06619669f, -0.00653174f, 0.05257241f, -0.02887731f, -0.01720735f, -0.01686979f, 0.01037130f, 0.05280180f, 
    0.12236984f, 0.04675041f, 0.00394835f, -0.01448320f, 0.08687126f, -0.03380554f, 0.05447244f, 0.04656911f, 
    0.11284906f, -0.08287057f, 0.00000215f, -0.03385522f, 0.13102490f, -0.10128221f, 0.02654059f, -0.04679716f, 
    0.05933050f, 0.00690389f, 0.07509737f, 0.06445747f, 0.13266501f, 0.02637745f, 0.01767743f, 0.02025936f, 
    0.03257120f, -0.01070026f, 0.04218864f, -0.10115339f, 0.08779529f, 0.05384178f, -0.05636607f, 0.12348430f, 
    0.01563648f, -0.05421264f, 0.00981402f, -0.07229848f, -0.08713180f, 0.14344805f, 0.19219168f, -0.16624779f, 
    -0.01840399f, -0.02233171f, 0.05615815f, 0.05750492f, 0.15435323f, -0.04568312f, -0.05582560f, 0.01221609f, 
    0.07532366f, 0.11741866f, 0.10286453f, 0.06233359f, -0.10710066f, -0.00258344f, 0.04960195f, -0.04568098f, 
    -0.03349060f, 0.03469506f, -0.06554282f, 0.05414035f, -0.02443232f, 0.12096289f, 0.01170957f, 0.10154660f, 
    0.03862261f, 0.01943545f, 0.01776823f, 0.06132403f, 0.00983022f, -0.03791514f, -0.06331346f, -0.04978093f, 
    -0.14420703f, 0.04354485f, 0.01355436f, 0.15489282f, -0.01983956f, 0.02728501f, -0.05247962f, -0.01752768f, 
    -0.06342245f, -0.05417763f, 0.04170318f, 0.04757285f, 0.04862930f, -0.15150301f, -0.05855045f, -0.06994312f, 
    0.08817833f, 0.13372728f, -0.00231603f, 0.00152147f, -0.03484435f, -0.01457859f, -0.08617901f, 0.09250423f, 
    -0.08264785f, -0.13978025f, -0.06473293f, -0.03437294f, 0.06711747f, 0.10627664f, 0.12862447f, -0.02777446f, 
    0.05088105f, 0.03015436f, -0.09922211f, 0.02457751f, 0.21541668f, -0.14378102f, -0.04520142f, 0.14544377f, 
    0.01653272f, -0.06689298f, 0.05043353f, -0.06646563f, -0.03293171f, 0.01916097f, -0.08880875f, -0.01263369f, 
    -0.11612973f, -0.01852201f, 0.03007214f, -0.03686975f, -0.07917336f, 0.02379503f, 0.00238434f, 0.11504101f, 
    0.04308536f, 0.10144977f, 0.00071110f, 0.11463054f, -0.19904967f, -0.13344415f, -0.05062258f, -0.11299738f, 
    0.04639652f, 0.08714497f, -0.04783157f, -0.00865766f, 0.00461177f, -0.05591074f, 0.03488679f, 0.09138205f, 
    0.10028299f, 0.13694450f, 0.11877842f, 0.00231974f, 0.13711359f, 0.11271135f, 0.03071933f, 0.02799509f, 
    0.09352324f, -0.00313011f, 0.09067931f, -0.04527467f, 0.18560430f, 0.00669071f, 0.12749727f, 0.11359791f, 
    0.05201289f, -0.04574405f, 0.02286374f, -0.06661271f, 0.02240512f, -0.04752328f, 0.00343545f, 0.01457244f, 
    0.04563690f, 0.00480219f, -0.06930891f, -0.02546253f, -0.07769427f, 0.02301333f, 0.02967788f, -0.04350940f, 
    0.11351538f, 0.07044465f, -0.00388487f, 0.04685492f, -0.16984199f, -0.12305468f, -0.13553198f, -0.02098771f, 
    -0.07413431f, 0.01046433f, 0.02222780f, 0.00086920f, 0.01550570f, 0.05308406f, 0.08027597f, 0.06120563f, 
    0.16282324f, -0.03586131f, 0.06720974f, -0.31935698f, -0.03573539f, 0.10484947f, -0.02244794f, -0.11501648f, 
    0.10409202f, -0.06541767f, 0.16932188f, 0.06155647f, -0.19639160f, -0.07683334f, 0.10256419f, -0.10173357f, 
    0.02439811f, 0.02365369f, -0.00116691f, 0.08200514f, 0.02402236f, 0.04175535f, 0.05575288f, 0.08516275f, 
    -0.04823754f, -0.12978345f, 0.18995510f, 0.06451065f, 0.08827379f, 0.01887275f, -0.05739618f, -0.02074131f, 
    -0.01142921f, 0.05769320f, 0.02285784f, -0.03702064f, -0.20764360f, 0.02508618f, -0.05932895f, 0.05456028f, 
    -0.00785315f, -0.01730574f, -0.02617528f, -0.06014968f, 0.02925266f, 0.04822662f, 0.04260071f, 0.09457356f, 
    0.01650723f, -0.04837599f, -0.01716671f, 0.04252782f, 0.01032244f, 0.04100814f, -0.01504540f, 0.01651139f, 
    0.03649383f, -0.01865415f, -0.01544397f, 0.02822454f, 0.03339041f, 0.03973462f, -0.05075361f, -0.00132064f, 
    -0.03037617f, -0.00171278f, -0.01109742f, -0.00146030f, 0.00264965f, 0.03618127f, 0.02107408f, -0.00201547f, 
    -0.02327008f, -0.03499148f, -0.03245559f, -0.04633037f, 0.00028145f, -0.03092317f, 0.02868259f, 0.02257474f, 
    -0.01672708f, 0.00191729f, -0.04197762f, -0.05326139f, 0.05016193f, -0.03143784f, -0.00958240f, 0.03057744f, 
    0.00399269f, 0.01914200f, -0.00654671f, 0.04381286f, 0.04741101f, 0.03883164f, -0.03521648f, -0.01006153f, 
    -0.03162807f, 0.00314568f, -0.03321046f, 0.02812607f, -0.03876724f, 0.01803802f, 0.00919827f, -0.03024960f, 
    0.04079648f, 0.01143435f, 0.00308113f, 0.02895024f, 0.01743090f, -0.03633553f, -0.00349715f, -0.01379453f, 
    0.04822550f, -0.02559635f, -0.03973901f, 0.04768142f, -0.01704723f, 0.02948416f, -0.03822206f, 0.00057090f, 
    0.00962910f, -0.02477897f, -0.03705128f, 0.03088550f, -0.00820654f, 0.02978905f, 0.03960840f, 0.04522016f, 
    -0.05306977f, 0.02816313f, 0.03900136f, -0.03497113f, 0.00407443f, 0.03427139f, -0.02856812f, 0.04109135f, 
    -0.00845465f, 0.03189471f, 0.00596110f, -0.05158211f, 0.02400093f, -0.00825447f, -0.04066538f, -0.03249595f, 
    -0.02639838f, -0.04288096f, 0.02405976f, -0.05101809f, -0.05195912f, -0.00663898f, -0.01694251f, -0.01680146f, 
    -0.01300396f, 0.00449417f, -0.02732560f, -0.01891945f, 0.04861869f, 0.03699685f, -0.04826450f, 0.04870014f, 
    0.00411515f, 0.00207471f, 0.00766085f, -0.00044269f, 0.03616963f, 0.04453090f, 0.00287370f, -0.04453336f, 
    0.00759054f, -0.02850567f, 0.04075782f, 0.03268811f, -0.01734436f, -0.04223510f, -0.00446542f, 0.04976672f, 
    -0.05635780f, -0.02265431f, -0.03007746f, 0.03039305f, -0.00048116f, -0.00004302f, -0.03725928f, -0.02148090f, 
    -0.00721179f, 0.04550394f, -0.04628822f, -0.02676374f, 0.03089512f, 0.03895073f, -0.00801625f, -0.02456138f, 
    0.01589080f, 0.04249848f, -0.01346493f, -0.01242994f, -0.03524545f, 0.03509585f, 0.01666791f, -0.03254355f, 
    -0.02692688f, -0.05337633f, -0.02708042f, 0.00682321f, -0.05231134f, -0.03407897f, 0.01906448f, -0.02822034f, 
    -0.04728194f, 0.00132088f, 0.02668831f, 0.00957000f, 0.01742152f, -0.00990926f, -0.05145966f, -0.05110487f, 
    0.00512521f, 0.04461790f, 0.04367806f, -0.04129710f, -0.04089570f, -0.02327522f, -0.01892775f, -0.01994080f, 
    -0.01392851f, 0.03422543f, -0.03013114f, -0.04942612f, -0.02389222f, 0.03853167f, 0.04228915f, 0.01426458f, 
    0.01517224f, -0.00857060f, 0.00182918f, 0.01051970f, 0.01301742f, 0.02830797f, -0.02800495f, 0.04820832f, 
    -0.02960885f, -0.01319179f, -0.05066503f, -0.02602360f, 0.03107054f, 0.03674358f, 0.01847462f, -0.05228375f, 
    -0.04996112f, -0.01519506f, -0.00028156f, -0.00086327f, 0.02189932f, 0.03308006f, -0.03468609f, -0.02981187f, 
    0.01778767f, -0.04332267f, -0.00450920f, -0.04081068f, -0.04676596f, -0.04547116f, 0.02500035f, -0.04465109f, 
    0.03886264f, 0.03937566f, -0.00688315f, -0.02847905f, -0.00987245f, 0.01916939f, -0.00294207f, -0.04576264f, 
    -0.00916316f, 0.03438057f, -0.00526832f, -0.01452024f, -0.01526189f, -0.04484131f, -0.03284460f, -0.03874049f, 
    0.05044888f, -0.03550950f, 0.03208923f, -0.04425135f, -0.04084159f, -0.04054690f, -0.04167885f, 0.00252056f, 
    -0.03297342f, -0.02243421f, -0.05371990f, -0.03416393f, 0.03748550f, -0.03197573f, -0.00569522f, -0.00299148f, 
    0.03795421f, -0.04772821f, 0.02284602f, -0.00189918f, -0.04869978f, -0.03425033f, -0.05001055f, 0.05550235f, 
    -0.02218580f, -0.02737464f, 0.03016426f, -0.01416586f, -0.04975785f, -0.04369884f, -0.01460471f, -0.03149116f, 
    0.03932698f, 0.03794626f, -0.00912619f, 0.01143627f, -0.02130413f, -0.00371041f, 0.00270327f, 0.03552387f, 
    0.04280802f, 0.04322942f, -0.03883294f, 0.00534168f, -0.03621570f, -0.01044850f, -0.04162731f, -0.04910692f, 
    -0.03440527f, -0.04644410f, -0.04359877f, 0.03249157f, 0.05268798f, -0.05496928f, 0.01744967f, -0.01313433f, 
    -0.01335470f, -0.04238053f, -0.01350482f, -0.03086367f, -0.04365823f, -0.00963893f, 0.01167801f, 0.00458673f, 
    -0.03815319f, -0.02706235f, 0.01838777f, -0.04626776f, 0.02148514f, -0.03810569f, 0.03926941f, 0.03866591f, 
    -0.03274795f, 0.00699760f, -0.00245846f, -0.02190509f, 0.02287472f, 0.00225276f, -0.01206177f, -0.00262456f, 
    0.00752648f, -0.00618781f, -0.00264545f, -0.04355029f, -0.05453487f, -0.04005551f, 0.00636681f, -0.01900788f, 
    -0.05064157f, -0.02040745f, -0.02617029f, 0.02287168f, -0.02335158f, -0.02557882f, -0.00758686f, 0.01766395f, 
    0.02568878f, -0.01652090f, 0.04624024f, 0.01291038f, -0.04143944f, 0.05372976f, -0.03696664f, 0.03010030f, 
    -0.00030565f, -0.00743011f, 0.04367793f, 0.04552763f, 0.02369213f, -0.00192003f, 0.00265459f, -0.04306781f, 
    -0.05228850f, -0.00631020f, -0.01694703f, 0.02173837f, 0.03644006f, -0.01149067f, -0.04802507f, -0.01048238f, 
    0.00222124f, -0.00814583f, -0.01472493f, 0.02023365f, 0.00422851f, 0.00052720f, -0.04920159f, -0.01369335f, 
    -0.04518338f, 0.04183148f, -0.01692879f, 0.00146292f, 0.03120810f, -0.00985234f, -0.00148107f, -0.02865667f, 
    -0.01509466f, -0.01745606f, 0.04214403f, -0.01405920f, 0.02586415f, -0.02419353f, -0.04708931f, -0.00904530f, 
    -0.02402985f, -0.04752613f, 0.00276177f, 0.01125032f, 0.04554915f, -0.01709740f, -0.01131968f, -0.03985715f, 
    0.29104269f, 0.07220288f, -0.11723980f, 0.05480044f, 0.10162316f, -0.02447672f, -0.00337643f, -0.10920056f, 
    0.04112599f, 0.05041343f, 0.10031523f, -0.01633454f, 0.24456434f, -0.20375390f, 0.02118971f, 0.04879260f, 
    0.02623830f, 0.00529787f, -0.04218018f, -0.08890153f, 0.03647719f, 0.13748208f, -0.06393969f, -0.01026873f, 
    0.42097434f, -0.15049477f, 0.04408095f, 0.04651455f, 0.09636717f, 0.07811136f, 0.03937319f, 0.06819185f, 
    0.03920513f, -0.13449948f, 0.08344606f, 0.05515767f, 0.04268667f, -0.16131315f, 0.14351748f, 0.02872848f, 
    -0.09428760f, -0.03090256f, 0.05697710f, 0.04964061f, 0.04423139f, 0.13146719f, 0.02267525f, 0.01793373f, 
    0.28894889f, 0.02381902f, 0.01070243f, 0.04273996f, 0.14028975f, -0.04582575f, -0.04530202f, 0.04333774f, 
    -0.00923750f, 0.11480316f, 0.03344223f, 0.08360662f, 0.04783249f, 0.11696561f, -0.01308366f, -0.19641575f, 
    -0.00939192f, -0.06191839f, -0.03204072f, 0.03489820f, 0.01899486f, 0.02128533f, 0.04229971f, 0.08698849f, 
    0.19278955f, -0.11561929f, -0.12653975f, 0.04339067f, 0.02544953f, -0.07971583f, 0.11159309f, -0.07864946f, 
    0.09635010f, -0.02746775f, 0.08831112f, 0.09390917f, 0.03095284f, -0.14099006f, -0.00979829f, 0.07512087f, 
    -0.18257405f, -0.05120696f, 0.11167131f, 0.02211374f, -0.02668874f, -0.05101512f, -0.06840158f, -0.05305105f, 
    0.20301184f, -0.11756174f, -0.08399207f, 0.03697849f, 0.11781356f, 0.06498036f, 0.00020213f, -0.10353351f, 
    0.06774695f, -0.00395219f, -0.00381733f, 0.06384843f, 0.11606067f, 0.28538337f, -0.18517698f, 0.03440116f, 
    0.15818974f, 0.01694618f, 0.04094867f, 0.12869525f, -0.01070798f, 0.09461246f, 0.00878192f, 0.18987316f, 
    0.00754404f, 0.14208983f, -0.02479343f, -0.22235522f, 0.03176764f, 0.09289964f, 0.06942082f, 0.02857048f, 
    -0.10575329f, 0.03254481f, 0.00031476f, 0.08642311f, 0.02392920f, -0.08978985f, -0.05147650f, -0.11414463f, 
    0.06405378f, -0.02343203f, -0.09639420f, 0.00233194f, -0.03915647f, -0.01628920f, -0.08102965f, -0.02170535f, 
    0.05585114f, -0.14893743f, 0.02812826f, 0.13217509f, 0.08263686f, 0.01193040f, -0.02151996f, 0.04235085f, 
    0.04108102f, 0.03585567f, 0.01279671f, 0.15292300f, -0.04351130f, -0.22396038f, -0.09944539f, -0.01279547f, 
    0.07363970f, -0.13596593f, -0.11582461f, -0.00190434f, -0.02112220f, 0.01107972f, -0.03838027f, 0.10907032f, 
    0.09115253f, -0.11021411f, -0.09265110f, 0.21386479f, -0.10134924f, 0.11232229f, -0.08663808f, 0.02352046f, 
    0.07193464f, 0.10020781f, -0.03058779f, -0.07206025f, 0.16998208f, -0.07473908f, -0.17493924f, -0.14479004f, 
    0.07405585f, 0.02281012f, 0.07881539f, -0.02993480f, 0.11743777f, 0.09618504f, 0.01657867f, 0.02372890f, 
    0.06083890f, -0.18657249f, -0.05669777f, 0.10202757f, -0.08334950f, 0.01470325f, 0.00964421f, 0.03049733f, 
    -0.00213994f, 0.02871195f, 0.14291953f, -0.00417369f, 0.05602837f, -0.13297296f, 0.02945658f, 0.08504589f, 
    0.05143013f, -0.03028614f, 0.02344900f, 0.04427617f, 0.15570354f, -0.05353342f, -0.04035684f, 0.04247689f, 
    0.32531345f, -0.02820222f, -0.04076019f, 0.12385078f, 0.13955687f, -0.03465211f, 0.10169266f, 0.01931605f, 
    0.05885031f, 0.10831705f, 0.05844282f, -0.02150768f, 0.22016890f, -0.10267926f, -0.08250593f, -0.18149251f, 
    -0.07563172f, -0.09551092f, 0.03499605f, -0.10649662f, 0.09341519f, 0.03396166f, -0.14577173f, 0.04471140f, 
    -0.07641158f, -0.14238852f, 0.05639056f, -0.19173996f, -0.02419356f, 0.10955907f, -0.03122420f, -0.02510965f, 
    0.00791488f, 0.14640948f, -0.10336412f, -0.03842410f, -0.02326336f, 0.07180453f, 0.06134878f, -0.00204684f, 
    0.13285850f, -0.09450516f, -0.02742735f, 0.02771583f, 0.04658510f, -0.05679231f, -0.11190256f, 0.07288279f, 
    0.07373431f, 0.13306271f, -0.10777611f, 0.05621560f, -0.06035105f, -0.00524798f, -0.02349472f, 0.05602355f, 
    0.01849385f, 0.02782744f, 0.07589739f, 0.02654264f, 0.12633888f, -0.04762405f, 0.14505658f, -0.20760879f, 
    -0.24625984f, 0.05610039f, 0.09716712f, -0.09297155f, 0.07240044f, -0.21516486f, -0.02455381f, 0.06368216f, 
    0.19396743f, -0.06857698f, -0.00452805f, 0.06294224f, 0.11262091f, -0.02564205f, -0.08925640f, 0.04274914f, 
    -0.05778519f, -0.04976925f, 0.03011673f, 0.19000797f, -0.14321531f, -0.12779702f, 0.02806831f, -0.03235446f, 
    0.06132605f, 0.09243447f, -0.06980979f, 0.02972905f, 0.04632394f, 0.00829083f, -0.01046448f, 0.12101984f, 
    0.09013314f, 0.16630737f, -0.34902507f, -0.07120714f, -0.02737803f, 0.17830187f, 0.01047959f, 0.04748675f, 
    -0.01625757f, -0.03147710f, 0.10690954f, 0.11754979f, 0.04378735f, 0.07949968f, 0.04455860f, -0.10627232f, 
    -0.00767046f, 0.01678961f, -0.04101826f, 0.06121533f, 0.02345925f, 0.02123729f, -0.04573425f, -0.02183611f, 
    -0.15665482f, -0.15933065f, -0.05895523f, 0.05862775f, -0.07101215f, 0.07850216f, 0.00039453f, -0.06082553f, 
    0.02599708f, -0.00684193f, 0.05207856f, -0.01768749f, -0.41780192f, -0.29224834f, -0.11384372f, 0.06895580f, 
    0.01547153f, 0.06357350f, -0.02049899f, 0.03703283f, 0.09947338f, 0.06771223f, 0.04161925f, -0.03648072f, 
    -0.07008799f, -0.00939761f, 0.00495422f, -0.04231293f, 0.02692979f, 0.02221755f, -0.00434291f, 0.02356909f, 
    0.08581617f, 0.02058714f, -0.06825975f, 0.02374033f, 0.50231636f, -0.05881757f, 0.02816852f, 0.01074927f, 
    -0.00247608f, -0.01922473f, 0.02048531f, 0.06940694f, 0.07742515f, -0.01992303f, 0.02337288f, 0.08636273f, 
    0.01762917f, -0.04245813f, 0.04416576f, -0.00238904f, -0.03004320f, 0.00199181f, 0.02735833f, -0.04419921f, 
    0.04294384f, -0.02002626f, -0.01912371f, -0.04062082f, -0.02203632f, -0.02226555f, 0.05394337f, 0.03664919f, 
    0.04374707f, -0.02459049f, 0.01836054f, 0.02170582f, -0.00519968f, -0.00388233f, 0.02304237f, -0.01391002f, 
    0.01817574f, -0.01932218f, -0.03529378f, -0.01693549f, -0.01751559f, 0.02423875f, -0.00379790f, -0.00209575f, 
    -0.01562176f, 0.04359606f, 0.03056819f, 0.02526133f, -0.01881647f, -0.05544531f, -0.05120718f, 0.01134379f, 
    -0.03797720f, 0.01337282f, 0.04005280f, 0.01322421f, -0.04920244f, -0.02044946f, -0.03809915f, -0.02215738f, 
    0.01561211f, -0.01328186f, -0.04515954f, -0.03889057f, 0.02772150f, 0.00754773f, 0.02711323f, 0.02431606f, 
    -0.02115305f, -0.02597522f, -0.05440688f, 0.00915126f, 0.00453590f, -0.01164234f, -0.02719624f, -0.00380675f, 
    -0.00226424f, 0.04235936f, -0.03725937f, 0.00653668f, 0.02713362f, -0.03635627f, -0.03382410f, 0.00353319f, 
    0.03940850f, -0.03253428f, 0.03193894f, 0.03802218f, -0.04161301f, 0.02252658f, 0.00256683f, 0.03051850f, 
    0.01507520f, 0.02451292f, -0.04522575f, -0.02144064f, 0.03246158f, 0.01628349f, -0.01340837f, 0.01321517f, 
    -0.04171361f, 0.03222017f, -0.03825979f, 0.01279467f, 0.01151364f, 0.00377507f, -0.02185504f, -0.04769830f, 
    0.03424343f, 0.03231716f, -0.02241528f, -0.03331250f, -0.02336717f, 0.03445365f, -0.04520846f, 0.01714720f, 
    0.00297856f, -0.03486358f, 0.03684580f, -0.04976379f, -0.02520655f, -0.04299206f, 0.00770571f, -0.00463405f, 
    -0.05675071f, 0.01874236f, -0.05035203f, -0.05439274f, 0.04274201f, -0.04040563f, -0.02218070f, -0.01737789f, 
    -0.05408424f, -0.01597075f, -0.00288263f, -0.03916796f, 0.01521569f, -0.05591659f, 0.05361039f, 0.03551326f, 
    0.03728088f, -0.05103227f, -0.00092756f, -0.01016488f, -0.01398290f, -0.00043075f, 0.01488186f, -0.01220636f, 
    -0.00245491f, -0.01472426f, 0.02876968f, -0.00072595f, -0.01193917f, -0.02709591f, 0.01200288f, 0.00544010f, 
    -0.03686447f, -0.01225951f, 0.03796834f, 0.02352927f, -0.05662830f, 0.00295296f, -0.04043610f, -0.02377999f, 
    0.02818470f, 0.02021133f, 0.03811440f, 0.02151833f, 0.01895462f, -0.01776462f, -0.04077194f, -0.04173798f, 
    0.00327707f, 0.02651354f, -0.04147499f, -0.04966503f, -0.03557935f, 0.04047915f, 0.03662718f, 0.03167191f, 
    -0.05114822f, -0.05551162f, -0.02124048f, -0.00199744f, -0.00074034f, 0.00816290f, -0.03091714f, 0.02166767f, 
    0.01667181f, -0.05534194f, 0.00335229f, -0.01982095f, -0.01663175f, 0.02795482f, -0.01228512f, 0.03757036f, 
    -0.05639348f, -0.04187448f, 0.04412138f, 0.04721322f, -0.00349984f, 0.03789900f, 0.00024456f, 0.01263758f, 
    0.03834584f, 0.00234958f, -0.04120367f, 0.03836687f, 0.01520588f, -0.00145520f, -0.01118802f, 0.00025311f, 
    -0.01863271f, -0.00610563f, -0.02000623f, 0.00206252f, 0.02709414f, -0.05355494f, 0.04389058f, -0.01092010f, 
    0.01792483f, -0.02912191f, -0.03967555f, 0.03563185f, 0.01356406f, -0.04754437f, -0.03884521f, 0.03393755f, 
    -0.05461821f, 0.01566523f, 0.00054646f, -0.03180528f, -0.05050107f, 0.03541692f, -0.03072710f, -0.05080242f, 
    -0.05014612f, -0.01732332f, -0.03537032f, -0.00677426f, 0.02859429f, 0.02449010f, -0.00428973f, -0.02110057f, 
    -0.05361235f, -0.01277597f, -0.01198092f, -0.02687618f, -0.03157647f, -0.03536735f, 0.03306558f, -0.00738401f, 
    -0.00195342f, -0.05154815f, -0.04559328f, 0.01648679f, -0.02366761f, -0.05432029f, -0.02252615f, 0.00611116f, 
    0.01136064f, -0.03555449f, 0.00327183f, 0.00579452f, 0.01516961f, 0.02500945f, 0.03683653f, 0.01523297f, 
    0.04686588f, 0.01581108f, -0.03589793f, -0.00390702f, -0.02099824f, 0.01949986f, -0.05610628f, 0.01676900f, 
    0.01431493f, -0.01293601f, -0.01927238f, -0.05516103f, -0.00566421f, 0.00156844f, -0.04105563f, 0.02233745f, 
    -0.02677464f, -0.04199405f, 0.00946595f, -0.05449618f, -0.04665049f, -0.01177540f, -0.00507647f, -0.05530335f, 
    0.01944102f, 0.03984819f, -0.04992561f, 0.03040196f, 0.00119441f, -0.04061978f, -0.04981942f, -0.02805355f, 
    0.01507794f, -0.01499291f, -0.01576096f, 0.01632003f, -0.03316844f, 0.00609259f, -0.00695935f, 0.03260985f, 
    -0.03825856f, 0.00082925f, -0.00780792f, -0.01526106f, 0.01976504f, 0.05474712f, 0.02054715f, 0.01457292f, 
    -0.02661136f, -0.05351306f, 0.03561468f, -0.05131255f, 0.01780478f, -0.04729219f, 0.03999758f, 0.01620977f, 
    -0.05080424f, 0.00825203f, -0.03368133f, -0.03903408f, 0.01137643f, -0.02623605f, 0.00499915f, -0.04389337f, 
    0.01012023f, -0.00531266f, 0.01157021f, -0.01910250f, -0.02891790f, 0.01715425f, 0.03573691f, -0.03465137f, 
    0.04376675f, -0.03049772f, -0.01187471f, 0.01810084f, -0.03877879f, -0.01549897f, -0.05448432f, -0.04348455f, 
    -0.01011670f, 0.00015262f, 0.01225928f, 0.00496691f, -0.00172967f, -0.00092236f, 0.03960612f, 0.03777854f, 
    0.01453821f, -0.05005000f, -0.05075209f, 0.01663023f, 0.04073562f, -0.02407453f, -0.03188239f, -0.04343805f, 
    -0.05337690f, 0.04500887f, 0.04012240f, -0.01689035f, 0.03834766f, 0.05649227f, -0.04149552f, 0.04663371f, 
    0.02781270f, 0.00007923f, -0.00724174f, 0.02281736f, 0.00207942f, -0.01586220f, -0.01066296f, -0.01777183f, 
    -0.01646070f, -0.01483888f, -0.02965153f, -0.01449001f, -0.02138234f, -0.00310875f, 0.00249328f, 0.01419461f, 
    0.05140170f, -0.01297489f, -0.04023890f, 0.00241032f, 0.03379233f, 0.03406670f, -0.04779941f, 0.02368325f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.04675641f, 0.01380296f, -0.05164397f, 0.08141486f, -0.01117895f, -0.05039893f, 0.01985303f, 0.03139478f, 
    0.02547925f, -0.00284138f, 0.01313972f, 0.01618459f, -0.03158297f, -0.00047769f, -0.00921598f, -0.04334582f, 
    -0.01089844f, 0.02580778f, 0.02451330f, 0.01147200f, 0.03847938f, -0.00166136f, 0.06159244f, 0.03788597f, 
    -0.01510415f, 0.03408011f, 0.00498121f, 0.06817573f, -0.02267280f, 0.06834751f, -0.04259349f, 0.11927655f, 
    0.02403074f, -0.04955404f, 0.00074770f, 0.00624992f, -0.04434094f, -0.04037773f, 0.06768987f, 0.03654052f, 
    0.03543732f, 0.04281816f, 0.07593497f, 0.04750573f, -0.06206024f, 0.00850328f, 0.02422379f, 0.04758829f, 
    0.00774348f, 0.03877594f, -0.00587612f, -0.01983960f, 0.05464943f, -0.03845610f, -0.00720709f, -0.04767741f, 
    -0.00248570f, 0.08165319f, -0.02988701f, -0.01366832f, 0.02431261f, -0.04001131f, 0.04475704f, -0.02036924f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.29835472f, -0.05668003f, -0.14631946f, 0.02497351f, -0.11989602f, -0.04844812f, -0.00210770f, 0.23998980f, 
    0.08495247f, -0.11114242f, 0.00254394f, 0.06189488f, -0.05539031f, 0.04170319f, 0.04700183f, 0.01173616f, 
    -0.08606885f, -0.01648258f, 0.15904380f, 0.23005693f, 0.01570519f, 0.09223299f, -0.42369655f, -0.03121278f, 
    -0.23533724f, 0.09930854f, -0.10698723f, 0.15934160f, -0.20611344f, -0.35727194f, -0.12010825f, -0.29593217f, 
    -0.12601201f, -0.00484470f, -0.09901936f, -0.18252352f, -0.01705242f, -0.03244806f, -0.22484826f, -0.13084345f, 
    0.15871933f, 0.25434887f, -0.33441228f, -0.24817616f, 0.23523793f, 0.09904645f, 0.02455704f, 0.19064009f, 
    0.15178874f, -0.28845420f, 0.30748969f, 0.01963324f, -0.16187115f, 0.35699016f, 0.01505051f, 0.31177956f, 
    -0.40727392f, -0.20625961f, 0.16252239f, 0.04365895f, 0.15584004f, 0.07737875f, -0.15244989f, -0.12322573f, 
    -0.02978410f, 0.33910865f, -0.48286521f, 0.20314455f, -0.06818887f, 0.06733890f, 0.00786914f, -0.41099036f, 
    0.01448866f, 0.17989199f, -0.08288117f, -0.10004863f, -0.12510970f, 0.05096564f, -0.03695096f, 0.10675267f, 
    -0.02901335f, 0.10732235f, -0.03077411f, 0.23823360f, 0.05327174f, -0.04415495f, 0.02217892f, -0.11100314f, 
    0.02620997f, -0.10589850f, 0.03317730f, 0.31380257f, -0.05017864f, 0.09027963f, -0.10974868f, -0.08706207f, 
    -0.07060504f, -0.06413151f, -0.02263978f, 0.00192788f, 0.06765901f, -0.03073090f, -0.13099311f, -0.15032159f, 
    0.22256887f, -0.25491837f, 0.33872581f, -0.25644293f, 0.03923857f, -0.36385632f, -0.13375916f, 0.08475731f, 
    0.11365627f, -0.20938684f, -0.24657761f, -0.08914265f, 0.26042649f, -0.14245884f, 0.07732067f, 0.28925663f, 
    0.11059251f, -0.36925095f, -0.31042981f, -0.04311823f, -0.01519970f, 0.03669619f, 0.12003415f, -0.09886212f, 
    -0.36477792f, 0.08277104f, 0.26096267f, -0.27830967f, -0.05469417f, -0.08589847f, 0.10605444f, -0.43634784f, 
    -0.10187782f, 0.23302466f, 0.06433478f, 0.03270358f, -0.11721981f, 0.32313889f, -0.00814555f, 0.11669495f, 
    -0.07522088f, 0.11656647f, 0.01689526f, -0.18848255f, -0.07634324f, 0.18811224f, 0.07166608f, -0.02704881f, 
    -0.12253901f, -0.10000593f, -0.08569451f, 0.03966054f, 0.25968090f, 0.11555540f, 0.08078128f, -0.38453683f, 
    -0.56639183f, 0.10158655f, -0.06213922f, 0.20669274f, -0.07058627f, -0.05453816f, -0.48561305f, -0.10208575f, 
    0.09615920f, -0.39758837f, -0.24930170f, -0.11659686f, 0.30529073f, 0.12284888f, 0.12431010f, -0.33528844f, 
    -0.27001473f, 0.01462832f, 0.27729720f, -0.04344774f, -0.10327577f, 0.15239488f, -0.11478955f, -0.00575644f, 
    0.17325048f, 0.02393728f, -0.09795084f, -0.09851511f, 0.10159792f, -0.06746779f, 0.03400050f, -0.05002498f, 
    0.10785761f, 0.18065830f, 0.17545497f, -0.37574703f, 0.08477809f, -0.05893100f, 0.01684180f, 0.12507279f, 
    -0.08024051f, -0.65965360f, -0.07384777f, 0.10645065f, -0.05536897f, 0.09742144f, -0.04189610f, 0.06315277f, 
    0.10304223f, 0.00297005f, -0.16131181f, -0.19846882f, 0.09524835f, -0.46378148f, -0.13782501f, -0.76316637f, 
    -0.17324756f, -0.05421428f, 0.11172568f, -0.04882151f, -0.44861025f, -0.13392378f, -0.02463582f, 0.25851151f, 
    -0.05204833f, -0.12670083f, -0.07315763f, 0.22822821f, -0.06550483f, -0.10367566f, -0.20730589f, 0.25031957f, 
    0.17900626f, 0.24089569f, 0.33997226f, 0.03477433f, -0.31924948f, -0.00451973f, -0.00214688f, -0.27652064f, 
    0.25213298f, 0.20053175f, 0.02375828f, 0.08785226f, -0.32670471f, -0.10377940f, -0.05473377f, 0.12257288f, 
    0.27730399f, 0.07493583f, 0.07125521f, 0.02714765f, -0.08665527f, 0.04824222f, -0.18535477f, -0.06948844f, 
    0.24898396f, -0.33888510f, -0.06137054f, 0.09540381f, -0.04542144f, -0.10198984f, -0.00199670f, 0.03049971f, 
    -0.10555558f, -0.16576058f, 0.10906587f, -0.04839543f, 0.01039367f, 0.18583670f, 0.01900632f, -0.10249202f, 
    0.05253790f, -0.04569697f, 0.14560869f, -0.27548823f, 0.11968470f, 0.24433078f, 0.08437892f, -0.13000804f, 
    0.41316691f, -0.03217834f, 0.00229024f, 0.03808407f, -0.00126861f, -0.48594970f, 0.07809077f, 0.20163076f, 
    -0.01154177f, -0.02382692f, 0.06592132f, 0.20172639f, -0.09574230f, 0.10955916f, -0.02227505f, 0.26487511f, 
    -0.21835279f, 0.01440232f, 0.23579079f, 0.00065764f, 0.17365371f, -0.24757335f, -0.40435258f, 0.24136797f, 
    -0.06697359f, -0.17531335f, 0.36061233f, -0.00038017f, -0.02855014f, -0.08402926f, 0.03563598f, -0.05976699f, 
    0.14462221f, -0.04694972f, 0.03074230f, 0.02281070f, -0.00200199f, 0.01926786f, -0.35297322f, -0.08803809f, 
    0.21298850f, -0.12379078f, -0.03045691f, 0.27688187f, -0.04867873f, 0.09928229f, 0.07512257f, 0.10543025f, 
    -0.03758247f, -0.18805152f, 0.03324007f, 0.04204311f, 0.02123705f, -0.32408497f, 0.04879437f, 0.09817903f, 
    -0.08138478f, 0.03876965f, 0.19556943f, -0.10053956f, -0.08446755f, -0.26713544f, 0.29939750f, 0.24207507f, 
    -0.41388381f, 0.07088289f, -0.00730778f, -0.03086905f, -0.12717138f, -0.29494268f, -0.06181114f, 0.06731557f, 
    0.27864912f, 0.05210211f, 0.11075342f, -0.01517393f, -0.03644647f, -0.10499129f, 0.19558698f, -0.02542435f, 
    0.20758779f, -0.20290734f, -0.00864679f, -0.13542116f, 0.09396327f, 0.21148135f, -0.09912903f, -0.10068475f, 
    0.06307217f, -0.40983537f, -0.66631258f, 0.11697912f, 0.21961544f, -0.32921979f, 0.06392156f, -0.13634835f, 
    -0.28554490f, -0.11267172f, 0.10034532f, -0.01835496f, 0.14862682f, -0.12299870f, -0.06136322f, 0.04332471f, 
    0.11264855f, -0.32618970f, 0.14352259f, -0.12199254f, -0.02660652f, 0.03527466f, 0.05800338f, 0.26601252f, 
    -0.05134568f, 0.22098930f, 0.03334305f, 0.10781684f, -0.07456918f, -0.21693720f, -0.10363462f, -0.03267316f, 
    0.06928575f, 0.05332502f, 0.04073499f, 0.21446864f, -0.02725005f, -0.16882472f, 0.06368406f, -0.17138015f, 
    -0.13807365f, 0.03475682f, 0.04689275f, -0.39823809f, 0.17477901f, 0.33261818f, 0.01353210f, 0.04607338f, 
    -0.71390903f, 0.09125002f, -0.08417083f, -0.16832434f, -0.01203406f, 0.03579538f, 0.22746715f, -0.23652034f, 
    0.06904452f, 0.33882987f, 0.00113582f, 0.09816495f, 0.26184702f, -0.14420308f, -0.33003047f, -0.21959487f, 
    -0.23397467f, 0.28119040f, -0.03407048f, 0.05134655f, 0.19739845f, -0.49475172f, -0.01286691f, -0.27293685f, 
    -0.00364809f, -0.01135333f, -0.36307177f, 0.10607104f, -0.04504159f, 0.03464413f, 0.11102476f, 0.04103736f, 
    0.15616861f, -0.08754592f, 0.25246128f, -0.32945648f, 0.11188821f, 0.07619385f, -0.01608907f, -0.12089910f, 
    0.05157121f, 0.22253348f, 0.08996605f, -0.11286115f, -0.09041844f, 0.21894118f, -0.08942930f, -0.04078379f, 
    0.09773862f, 0.11388838f, -0.12729500f, -0.13556276f, -0.07327914f, -0.23561975f, -0.31414288f, 0.16989553f, 
    0.15311141f, 0.06526358f, -0.07821346f, -0.04499388f, -0.15873781f, 0.14418587f, 0.11036500f, 0.03892971f, 
    0.27600411f, -0.02700765f, -0.07301700f, 0.00253103f, 0.02963297f, 0.06801540f, 0.00722429f, 0.14618970f, 
    -0.27944338f, 0.20066594f, -0.45190075f, 0.08608265f, 0.12720013f, 0.01644559f, -0.13812903f, -0.24160756f, 
    -0.44123352f, 0.21074966f, -0.34326062f, -0.05137976f, -0.05946822f, -0.21734750f, 0.06758480f, 0.09969886f, 
    0.10594334f, -0.16100010f, 0.25619981f, 0.02085033f, -0.34946883f, -0.05985390f, -0.24696286f, -0.12702718f, 
    0.11973266f, 0.15555881f, 0.15655111f, 0.03392213f, -0.02157886f, -0.05092308f, -0.00287824f, -0.33538881f, 
    0.08376109f, 0.10062408f, 0.10528586f, -0.06871966f, -0.06455517f, -0.36103532f, 0.10136069f, 0.10137939f, 
    0.05153894f, 0.09970584f, -0.39589220f, 0.00418918f, -0.00157949f, 0.21549214f, 0.15115286f, -0.37818030f, 
    -0.00919444f, 0.10123659f, -0.01712868f, -0.17133114f, -0.02715336f, -0.00814253f, -0.12187625f, -0.17469373f, 
    0.02757511f, 0.04106013f, 0.10494311f, 0.23059405f, 0.04589522f, 0.08158037f, -0.10501791f, -0.28542322f, 
    -0.03961878f, -0.23295946f, 0.09632610f, -0.34013999f, 0.00726711f, 0.19076051f, 0.24032235f, 0.22591071f, 
    0.03284245f, -0.32284141f, -0.31744391f, -0.11648401f, -0.19921395f, 0.30796856f, -0.04707648f, -0.38003129f, 
    0.11799818f, -0.45221448f, 0.34499893f, -0.07996926f, 0.17641936f, -0.11427163f, 0.21344653f, -0.02568466f, 
    -0.11981229f, -0.28869691f, 0.12746359f, -0.01515419f, -0.00782643f, -0.03074364f, -0.09316149f, -0.33744386f, 
    -0.06910758f, 0.16288656f, 0.06756829f, -0.04989098f, -0.05104510f, 0.08779829f, -0.02294811f, -0.04464066f, 
    -0.00267582f, -0.08930516f, -0.07742476f, -0.26814121f, 0.03025557f, 0.24877483f, -0.25007963f, 0.45109364f, 
    0.27020484f, 0.08217927f, 0.02601986f, 0.04442287f, 0.24015236f, 0.23205861f, 0.02391626f, -0.09289073f, 
    -0.03866467f, -0.06214527f, 0.03569056f, -0.11614735f, -0.11693090f, 0.07075936f, 0.37209639f, 0.24059983f, 
    0.09530251f, 0.10062348f, -0.48871669f, -0.23373625f, -0.23033510f, -0.32829300f, -0.13437755f, -0.47833329f, 
    0.26525971f, 0.19568698f, -0.06125325f, 0.11761249f, -0.24543484f, 0.23189482f, 0.00930861f, -0.27371559f, 
    -0.55743146f, 0.32755882f, -0.28231430f, 0.02120141f, 0.11193719f, -0.11851568f, -0.11386774f, -0.08264044f, 
    -0.34667078f, 0.07198435f, -0.30425116f, -0.14607377f, 0.00211127f, -0.01031703f, -0.10363811f, 0.15979183f, 
    0.10776930f, -0.06786792f, 0.00662417f, -0.04040288f, 0.08199397f, 0.16859131f, 0.05058863f, -0.10463303f, 
    0.09363431f, 0.05619173f, -0.57652813f, -0.52196455f, -0.05126055f, -0.31029829f, 0.36442134f, 0.19469936f, 
    -0.25201508f, -0.06590650f, 0.10126009f, 0.14511898f, -0.25898027f, 0.32022893f, 0.06061735f, 0.04043938f, 
    -0.07395914f, -0.08345483f, -0.02447342f, -0.41175258f, 0.08562820f, -0.11439843f, 0.24283752f, 0.20063366f, 
    -0.01669930f, -0.05010320f, 0.12735008f, 0.28926808f, 0.00381357f, 0.02071295f, 0.21704626f, 0.33369923f, 
    -0.39244017f, 0.22886272f, -0.08650395f, 0.09584575f, -0.21280997f, 0.17264707f, -0.07168612f, -0.06721206f, 
    0.31423742f, -0.05013743f, -0.16818994f, 0.04573195f, -0.03133638f, -0.02609834f, 0.15210220f, -0.10956488f, 
    -0.31580755f, 0.19235556f, -0.21195184f, 0.17187157f, -0.06833777f, -0.03957551f, -0.00822699f, 0.05740080f, 
    -0.05436214f, -0.41976416f, 0.05982663f, 0.07548731f, -0.01899016f, -0.23082802f, 0.02857459f, -0.07128448f, 
    0.08864269f, 0.08094840f, -0.13593890f, 0.14585604f, -0.03720982f, 0.13080397f, -0.10573883f, -0.17200878f, 
    0.15443107f, 0.03521439f, 0.09711480f, -0.30992815f, 0.07173771f, -0.09939969f, 0.06973712f, 0.23517539f, 
    0.23472486f, -0.09027010f, 0.09906429f, 0.15599774f, 0.10690961f, -0.00871405f, -0.39347592f, -0.35953969f, 
    -0.22771171f, 0.10760609f, -0.15203963f, 0.27098137f, -0.52231997f, 0.20765141f, 0.26888251f, -0.26114124f, 
    -0.06121617f, 0.20557563f, 0.02690074f, -0.03761390f, 0.30749357f, -0.05141417f, -0.10787316f, -0.01239927f, 
    -0.38604787f, 0.29356954f, 0.14563917f, -0.02009814f, -0.14225104f, -0.07941452f, 0.23332298f, -0.02659626f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.03720153f, -0.06776906f, 0.08379865f, 0.08018543f, -0.05398623f, 0.07360603f, 0.01821363f, -0.07016805f, 
    -0.03118750f, 0.13596787f, -0.04269885f, -0.00640606f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
