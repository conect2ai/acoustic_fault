#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.57837564f, -0.72619134f, 0.51979393f, 0.93771976f, -0.51313776f, -0.38078642f, -0.23570301f, -0.24548568f, 
    -0.62129766f, 0.94754958f, -1.38804185f, 0.89907813f, 0.80858350f, 0.12016819f, 0.65421575f, -0.27883852f, 
    -0.45170367f, -0.59320462f, 1.09586072f, 0.66040981f, 0.49505949f, 0.63277620f, -1.11853886f, 0.35059968f, 
    -0.27515984f, -0.62039149f, -0.68850118f, 0.77866954f, -1.36549282f, -1.20209432f, -0.37115133f, 0.56789649f, 
    0.18111174f, -0.23740312f, 0.26459077f, 0.27762190f, 0.08323037f, 0.05421092f, 1.03321302f, -0.53014249f, 
    0.82096112f, 0.54276794f, -0.48489374f, -0.79724187f, -0.80386657f, 0.85319835f, 0.05075530f, -1.15578270f, 
    -0.54283267f, 0.60986942f, -0.75021815f, -0.04106798f, -0.09099112f, -0.57295042f, 1.23090398f, 0.71699065f, 
    0.64330101f, -0.27668348f, 0.33898783f, -0.08599760f, -0.56452912f, 0.35480338f, -0.61330599f, 0.02006046f, 
    0.27620742f, -0.84739804f, 1.28011572f, -0.68352753f, 0.58203351f, 0.41718608f, 0.67731690f, -0.28220063f, 
    -1.10816061f, -0.15002388f, -0.64644063f, -0.72203434f, 1.09184515f, -0.32685500f, 0.54635954f, -0.15780722f, 
    0.44554371f, 1.15878344f, -1.04312778f, -0.99754196f, -0.29692921f, -0.77691072f, -0.93444943f, 0.09508656f, 
    0.06890661f, 0.30415848f, -0.66845989f, -0.22579177f, 0.63066804f, -0.85982567f, 0.24257550f, 0.22522700f, 
    0.59451020f, 0.81610775f, -0.71152997f, -1.21316624f, -1.18212593f, -0.29657623f, -0.07248030f, -0.61730725f, 
    0.99390227f, -0.03910771f, -0.04901402f, 0.38100621f, -0.26821774f, -0.84337729f, -0.49216619f, 1.29004967f, 
    1.07956719f, 0.60111475f, -0.26378569f, -0.43908441f, -0.00028633f, -1.12670827f, -0.37039223f, 0.74621117f, 
    0.90072393f, 0.42946586f, 0.93515664f, 0.68858641f, -0.74903035f, 0.38957185f, 1.04502392f, 1.08046281f, 
    0.75918758f, -0.87478387f, 0.73154682f, -0.40030292f, -0.05183333f, -0.10206485f, 0.52061695f, 0.76621151f, 
    -0.35139266f, -0.70672739f, -1.27030563f, 0.46201926f, 0.27222127f, 0.04938363f, 0.59791428f, 0.82832938f, 
    -0.85680312f, 0.55131286f, -0.25068063f, -0.12809329f, -0.65212834f, -1.09734583f, 0.19092487f, -0.19676596f, 
    0.82878923f, -1.04364026f, -1.15198958f, -1.03880942f, -0.15503170f, -0.68077785f, -0.35256699f, 0.51506203f, 
    0.28101498f, 0.42467126f, 0.86606818f, 0.75607699f, 0.81638902f, 0.79302841f, 0.48897719f, 0.35499191f, 
    -0.30411428f, 0.50615680f, 0.55570316f, 0.45334980f, 0.41035077f, 0.24398685f, -1.00835335f, -1.01508367f, 
    -1.16125381f, 0.59181398f, 0.71495032f, 0.45261058f, -0.42228839f, -0.59147888f, 0.08783455f, -0.54782188f, 
    1.24415267f, -1.37379539f, -0.00226945f, 0.56938541f, -0.16605990f, -1.15470624f, 0.38025194f, 0.89936882f, 
    -0.94583827f, -0.48596191f, 0.27072120f, -0.02708808f, 0.05597204f, -0.12471094f, 1.06531882f, 0.72699720f, 
    -0.35807273f, 0.93971592f, 0.72726345f, -0.24335766f, 0.75152296f, 0.23320353f, -0.29175898f, 0.72019321f, 
    0.99509972f, -0.85983592f, -0.89690608f, 0.20174038f, 0.00830199f, 0.75785798f, -0.07301117f, -0.63881934f, 
    0.91205245f, 1.06320071f, 0.39856467f, -0.58560765f, -1.29152167f, 0.37955838f, 0.41797560f, 0.21061958f, 
    0.38780147f, 0.83352280f, 0.16058877f, 1.13339102f, -0.22943570f, -0.23019502f, -0.72870803f, 0.65226328f, 
    -0.09370898f, -0.21600771f, -1.36428702f, -0.40859666f, -0.15814486f, 0.73545778f, 0.50998497f, -0.22856386f, 
    0.24216519f, -0.40677536f, -0.88711894f, 0.56088662f, -1.31805503f, 0.51909298f, -1.12250721f, -0.53366905f, 
    0.69175553f, 0.41785854f, 0.06117087f, 0.48733783f, -0.63018841f, -0.95117152f, -0.96777040f, -0.02051567f, 
    0.32527721f, 0.44191977f, -0.56316221f, -0.02703594f, -0.49596530f, -0.39004877f, -1.08326936f, -0.48239040f, 
    0.07986337f, 0.16148758f, 1.16310966f, -0.14854151f, -0.65996969f, -0.16302687f, 0.25398719f, -0.86270159f, 
    0.55576444f, -1.06826448f, -0.82551557f, -0.91380060f, -0.55495328f, 0.05799251f, -0.62789780f, 0.10802846f, 
    -0.65454519f, 0.09702228f, -1.22808623f, 0.71594042f, -0.30169067f, 0.04748813f, -0.36609206f, 0.17442878f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.13707463f, -0.03930248f, 0.40643552f, -0.07994896f, -0.04115701f, 0.26986048f, 0.19013844f, -0.12647136f, 
    0.46002850f, 0.11427633f, 0.14606483f, 0.07469797f, -0.03629958f, -0.28945449f, 0.14900757f, -0.45540240f, 
    0.12529814f, 0.23409069f, 0.40832517f, 0.31360471f, -0.19352268f, 0.51173824f, 0.52800566f, -0.19189306f, 
    -0.16489637f, 0.04253568f, 0.24883394f, -0.10183331f, -0.24319823f, 0.03796013f, -0.18012230f, 0.16717121f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.00018806f, -0.02658732f, -0.05178427f, -0.04863976f, -0.03850523f, -0.02827143f, -0.03616973f, -0.03790589f, 
    -0.00559112f, -0.03341900f, 0.01576187f, -0.02269649f, -0.01621951f, -0.03473813f, -0.05542247f, 0.04279276f, 
    0.00309693f, 0.00178515f, 0.00336537f, -0.05632677f, 0.04160598f, 0.03370598f, 0.05246628f, -0.02440166f, 
    -0.03278750f, -0.06382834f, -0.04429777f, 0.00274741f, 0.00079348f, -0.04757315f, -0.06199310f, -0.00279370f, 
    -0.03433346f, 0.04976653f, 0.00045855f, -0.01497454f, 0.05262185f, 0.05155391f, -0.00825515f, 0.05218918f, 
    -0.01813120f, 0.04360885f, -0.05484056f, -0.03425576f, -0.02071799f, -0.05160413f, -0.04278176f, -0.00629795f, 
    -0.02377523f, -0.05032257f, 0.03267985f, -0.03009926f, -0.05183594f, -0.00360678f, -0.02234156f, -0.01139569f, 
    -0.01991901f, 0.00639435f, -0.04587954f, -0.05577469f, 0.00743276f, -0.05547878f, -0.01659065f, -0.02359789f, 
    -0.06037403f, 0.02982933f, 0.01464370f, -0.06143004f, 0.04765759f, 0.03866364f, -0.00950754f, -0.03332418f, 
    -0.01217037f, 0.04329108f, 0.00271613f, 0.02934677f, -0.06447390f, 0.02485588f, -0.05732528f, 0.04340023f, 
    0.04104433f, -0.02617625f, 0.00294756f, 0.00707379f, -0.01815881f, -0.02205935f, -0.05366490f, -0.04872927f, 
    -0.01756434f, 0.02604212f, -0.02470863f, 0.00292710f, 0.04307640f, -0.00204717f, 0.03324547f, 0.02151869f, 
    -0.03376972f, -0.00298224f, -0.03932637f, 0.01854603f, -0.03667146f, -0.01316632f, 0.00374251f, 0.00228206f, 
    -0.02372722f, 0.00054387f, -0.05892455f, -0.00151196f, 0.01925249f, -0.05816206f, -0.04118211f, -0.00323292f, 
    -0.04507838f, -0.04918389f, 0.00749986f, -0.02326834f, -0.06232405f, -0.04581215f, 0.01734534f, 0.03467438f, 
    0.02527299f, -0.04659059f, -0.04921591f, 0.00607307f, 0.00918323f, 0.01288484f, -0.04109976f, 0.03693295f, 
    -0.03777554f, 0.04179431f, -0.02100819f, -0.02000633f, -0.04323017f, 0.02238246f, 0.02425670f, 0.02804722f, 
    -0.04099083f, 0.04581486f, 0.04609012f, -0.03534809f, -0.01823762f, 0.04569428f, -0.00352252f, -0.04844693f, 
    -0.02322656f, -0.04470741f, -0.03320020f, 0.03606339f, 0.02124077f, 0.03757970f, 0.01797311f, -0.01293659f, 
    -0.04370618f, -0.01517558f, -0.04393810f, 0.01317673f, -0.02886892f, -0.01082054f, -0.00252214f, 0.03420023f, 
    -0.06200345f, -0.03731744f, -0.00985576f, -0.05066210f, -0.01157584f, 0.00796128f, -0.00020193f, 0.03535504f, 
    0.02645909f, -0.02277911f, -0.06408258f, 0.01157034f, -0.01427228f, -0.06263454f, 0.02152696f, -0.05566329f, 
    -0.02132386f, -0.05036127f, -0.02573086f, 0.02150466f, 0.00295484f, -0.05379791f, 0.01308483f, -0.01530591f, 
    0.02852892f, 0.01336468f, 0.03698514f, -0.01548267f, -0.05972428f, -0.02224680f, 0.01801486f, -0.04056955f, 
    0.00612949f, 0.05092643f, -0.00795273f, -0.05366026f, -0.05811894f, 0.02912963f, 0.00290697f, 0.03915947f, 
    0.00188829f, 0.02339855f, -0.02919615f, -0.02766968f, 0.01637721f, -0.00158101f, 0.04467357f, 0.04502819f, 
    0.05214624f, -0.04881302f, -0.01175636f, 0.05120908f, 0.02199040f, 0.05197580f, 0.00354686f, -0.02653616f, 
    -0.00254847f, -0.05058772f, -0.00202834f, -0.04472007f, 0.01434012f, 0.02395389f, -0.00807518f, 0.05053680f, 
    0.01942910f, -0.00728434f, -0.00524279f, 0.00190705f, -0.01043355f, 0.01311217f, -0.04209698f, -0.06141756f, 
    -0.04817239f, -0.06277952f, -0.04645176f, 0.00738761f, -0.03116466f, -0.04373084f, -0.05373431f, -0.06132475f, 
    -0.02677103f, -0.05752670f, 0.05251895f, 0.00910534f, -0.01571538f, -0.01709323f, -0.04790073f, -0.05692552f, 
    0.00787207f, -0.01677535f, 0.00416095f, 0.01929319f, 0.04910417f, 0.00666059f, -0.02215187f, 0.04852609f, 
    0.00135126f, -0.01394898f, 0.04884947f, -0.01267522f, -0.04326929f, 0.00835575f, -0.05514345f, 0.05201996f, 
    -0.06118369f, -0.02742541f, 0.00173357f, 0.04060707f, -0.03051292f, -0.04021341f, -0.04205160f, -0.00993231f, 
    -0.04184650f, -0.01182184f, -0.04042063f, -0.00325561f, 0.03900464f, -0.03615022f, -0.06248584f, 0.00923377f, 
    0.00431835f, 0.03327819f, 0.05009370f, -0.00313525f, -0.02653907f, 0.02088411f, -0.01403410f, 0.01490693f, 
    -0.11132679f, 0.11487436f, -0.10222950f, 0.09934365f, 0.07562756f, -0.05511155f, 0.10364363f, 0.07605731f, 
    0.01998591f, 0.52267063f, 0.29566824f, -0.18948893f, -0.00732483f, 0.09409301f, -0.07433127f, 0.12940878f, 
    -0.03427914f, 0.18528797f, 0.17186952f, 0.11916192f, 0.32814017f, -0.16688478f, -0.11100440f, 0.01289658f, 
    0.21799906f, 0.30759668f, 0.10900196f, -0.28248081f, -0.36349037f, -0.04245231f, -0.04345615f, 0.01432679f, 
    -0.11456598f, -0.07987428f, -0.08293442f, 0.10400917f, 0.02057409f, 0.32098168f, -0.08281097f, -0.08699267f, 
    -0.18190415f, -0.05660306f, 0.46639895f, 0.14966053f, 0.21564288f, 0.20870329f, 0.02267493f, -0.19459076f, 
    0.00674991f, -0.34729782f, -0.07405268f, 0.04968179f, 0.29731789f, 0.06772058f, 0.14240500f, 0.18248023f, 
    0.26065865f, -0.00952357f, -0.14097580f, 0.03534303f, -0.08736686f, 0.12375977f, 0.04571101f, -0.04752792f, 
    -0.13294668f, -0.05274751f, -0.07359815f, -0.15017982f, 0.12222856f, -0.10726406f, -0.26220778f, 0.01055032f, 
    0.23385216f, -0.03344772f, -0.19014002f, 0.02396003f, -0.11120750f, 0.09773234f, 0.05019973f, -0.06524485f, 
    -0.01976639f, -0.06006567f, -0.23475884f, 0.10057075f, -0.06511315f, 0.17533366f, -0.01605035f, 0.13811201f, 
    0.03451325f, 0.06502943f, -0.50157195f, -0.04852570f, -0.42339402f, -0.00563884f, -0.02307854f, -0.02609814f, 
    0.01930088f, -0.01154539f, -0.09010552f, -0.04869398f, 0.17555279f, -0.10623100f, 0.17386097f, 0.17924115f, 
    0.06052433f, 0.00355547f, -0.08690576f, -0.02864539f, 0.23243429f, 0.21172522f, -0.12047074f, 0.26410964f, 
    -0.03489444f, 0.13000523f, 0.20450804f, -0.04344254f, -0.05278852f, -0.15521429f, 0.70135909f, -0.11212994f, 
    0.01422930f, -0.13192940f, -0.03759730f, 0.11005203f, -0.10108306f, -0.13087760f, -0.14911123f, 0.10032221f, 
    0.18789265f, -0.02891828f, -0.12399296f, 0.09246460f, 0.01258737f, 0.01065654f, -0.06430379f, -0.21272321f, 
    -0.18886979f, -0.39349741f, 0.03462865f, -0.18617620f, 0.02509147f, -0.08698115f, -0.21953048f, 0.02565057f, 
    -0.04446002f, 0.18355179f, -0.12249292f, -0.01706578f, 0.00214474f, -0.05898882f, 0.02145037f, 0.08759418f, 
    -0.08855485f, -0.27848318f, -0.13653259f, -0.06016345f, 0.18099244f, 0.08012210f, -0.05739014f, -0.06610564f, 
    0.07224009f, 0.14350896f, -0.13747482f, 0.31145826f, 0.28932121f, 0.18861865f, 0.12149157f, 0.04502932f, 
    0.20324351f, -0.05595806f, -0.02472425f, -0.22047210f, -0.12101463f, 0.17015950f, -0.13061538f, -0.16004956f, 
    0.00825425f, -0.03254904f, 0.09575722f, 0.05926781f, -0.50177866f, -0.31753930f, -0.04853329f, 0.16840960f, 
    0.08319239f, 0.18091761f, -0.11190355f, -0.01636523f, 0.01501549f, 0.02299215f, -0.03205562f, -0.16694665f, 
    0.04837859f, 0.11694451f, 0.00609978f, -0.07582884f, 0.17233202f, -0.09617754f, -0.09142953f, -0.13096388f, 
    0.15070018f, -0.10930831f, 0.19532403f, 0.10975234f, -0.08342609f, -0.08374950f, -0.09292605f, 0.22102810f, 
    -0.04319632f, -0.11421365f, -0.36767450f, -0.25645074f, -0.03271625f, -0.08341904f, 0.14300333f, 0.18015972f, 
    -0.29130277f, -0.21339671f, 0.35811901f, -0.15128841f, -0.33314192f, 0.00946707f, -0.14378904f, 0.08926828f, 
    0.04390671f, -0.22032619f, -0.12416821f, 0.22648914f, -0.06564029f, 0.03709894f, -0.10409020f, 0.12328105f, 
    0.06516807f, -0.02001951f, 0.09517995f, -0.01459989f, -0.29541466f, 0.08020085f, 0.11986535f, -0.03701124f, 
    0.14823557f, 0.02198793f, 0.06967799f, -0.32715434f, -0.54493582f, -0.27031064f, 0.09437621f, 0.04459104f, 
    0.06025387f, -0.14123049f, 0.11426723f, -0.07354192f, -0.34065542f, -0.12360475f, 0.09725034f, 0.19343123f, 
    0.02205294f, 0.19058098f, 0.05495614f, -0.10454602f, 0.25520837f, 0.16263850f, 0.33689755f, -0.26028380f, 
    0.03767522f, -0.01350239f, 0.21581101f, 0.16435327f, -0.03514954f, 0.08471700f, 0.21267091f, -0.08148826f, 
    0.29236904f, 0.01371319f, 0.03959317f, -0.18365763f, -0.02711481f, 0.38550460f, 0.26618606f, -0.41452864f, 
    -0.07754220f, 0.12240165f, 0.05794729f, -0.00368551f, 0.20224831f, 0.10727824f, 0.11043762f, -0.04544896f, 
    -0.30574495f, 0.05023696f, 0.17151748f, 0.09473644f, 0.10728612f, 0.12688464f, -0.18503259f, 0.08104195f, 
    -0.17195112f, 0.29411054f, 0.00224321f, 0.09987751f, 0.09969185f, 0.18311684f, 0.07173342f, 0.09890466f, 
    0.19413827f, -0.01768554f, 0.18818033f, 0.05996591f, 0.10368634f, 0.01371521f, -0.13345331f, 0.12625070f, 
    -0.02436448f, 0.12204655f, -0.20609859f, 0.04517866f, -0.41095942f, -0.11653723f, -0.05737214f, 0.08584951f, 
    -0.13640346f, 0.14430015f, -0.06394739f, -0.08818651f, -0.28807411f, 0.04147859f, -0.07133225f, 0.07801283f, 
    -0.11567336f, -0.01512742f, 0.26350740f, 0.13827519f, -0.01294991f, 0.19213438f, -0.08034443f, -0.34115216f, 
    -0.04929487f, -0.04688403f, 0.02800299f, -0.07107367f, -0.12695996f, -0.30168086f, 0.59871197f, 0.08753624f, 
    -0.23471196f, -0.06329209f, -0.01874967f, -0.04928776f, 0.02063405f, 0.05189670f, -0.08001645f, -0.09554396f, 
    -0.33984679f, 0.05533784f, 0.02019840f, 0.00422789f, 0.07524231f, 0.03855208f, -0.04839247f, 0.24831450f, 
    0.60168546f, -0.07066686f, -0.18095806f, -0.02725623f, 0.23393919f, -0.03593804f, 0.07440645f, -0.13315183f, 
    -0.28068799f, 0.14157659f, -0.38834015f, 0.10473794f, -0.00864126f, 0.07470740f, 0.05604729f, 0.03953926f, 
    -0.06045426f, 0.05146674f, -0.25284594f, -0.06942039f, -0.19083236f, -0.12471212f, -0.01578641f, -0.07814083f, 
    -0.04289461f, 0.04901950f, 0.05254287f, -0.12230345f, 0.56683254f, 0.10061722f, -0.01410996f, -0.11097823f, 
    0.06291286f, 0.03606170f, 0.07739894f, -0.05126771f, 0.02523500f, 0.13210969f, -0.29054466f, -0.02678680f, 
    -0.14729467f, -0.16390157f, 0.03793984f, -0.08612856f, -0.04422524f, -0.46341905f, 0.33535430f, 0.22274645f, 
    -0.05231915f, 0.20724395f, -0.03271346f, -0.14064008f, 0.02863759f, 0.00195169f, 0.57590616f, 0.18421750f, 
    -0.28512323f, -0.10354176f, -0.02043110f, 0.03188306f, 0.01936902f, 0.06232635f, -0.05136532f, 0.36230290f, 
    -0.12302995f, 0.05139530f, 0.14151323f, 0.00277531f, 0.05746465f, 0.08561961f, 0.09956526f, 0.05922843f, 
    -0.21405597f, -0.31304660f, -0.45865110f, -0.13597928f, -0.04749817f, 0.11362321f, -0.06411638f, -0.05264153f, 
    -0.00974923f, -0.04398591f, 0.17404865f, -0.07051422f, 0.01162461f, -0.22505301f, 0.18289423f, -0.05004184f, 
    -0.04411666f, -0.08969788f, 0.11156378f, 0.32194099f, 0.10539342f, -0.33481780f, -0.04668420f, -0.13889861f, 
    -0.04417902f, -0.02147512f, -0.07189621f, -0.12105383f, -0.25620502f, 0.04525459f, 0.10167804f, -0.14510226f, 
    0.21222097f, 0.18803556f, -0.06180175f, 0.01500459f, -0.14846438f, -0.35115916f, -0.19344401f, 0.16317043f, 
    0.15950173f, 0.05233865f, 0.00067701f, 0.10849930f, -0.20737159f, -0.21032749f, 0.06723195f, -0.42968428f, 
    -0.15990743f, 0.13938005f, 0.04578606f, -0.01968962f, 0.04174070f, 0.12164166f, 0.22376864f, -0.24110080f, 
    0.05964347f, -0.17947704f, -0.06783277f, -0.01134764f, -0.09321089f, -0.00711817f, 0.08005342f, 0.30769974f, 
    0.07996581f, -0.29436812f, -0.08792971f, 0.00983715f, 0.05278392f, 0.02478096f, 0.03753944f, 0.18397251f, 
    0.34556174f, 0.17641723f, 0.04957421f, 0.06081503f, -0.09506544f, 0.03472283f, -0.18411818f, -0.15259832f, 
    0.17723589f, 0.10600609f, 0.15016928f, -0.01761748f, 0.09581935f, -0.10798295f, -0.02615980f, 0.19978532f, 
    0.00834706f, 0.04817499f, 0.24513669f, -0.03858370f, -0.03993514f, -0.03131227f, -0.11237562f, -0.02434642f, 
    -0.03015543f, 0.12186899f, -0.18813637f, -0.10065956f, -0.03722293f, 0.17153576f, 0.09461365f, -0.27524602f, 
    -0.01326212f, 0.09246598f, 0.26976407f, 0.25495645f, 0.03135708f, -0.08854790f, -0.51665616f, -0.00386508f, 
    -0.05330930f, -0.08492599f, 0.17613886f, 0.04029829f, -0.00134907f, 0.08406951f, 0.43069088f, -0.20456661f, 
    0.15405813f, 0.03736216f, -0.03407129f, 0.21351238f, -0.18351923f, -0.02163141f, -0.13142543f, -0.20716769f, 
    0.09860627f, 0.00855916f, 0.25622874f, 0.17925581f, 0.04100466f, 0.03382821f, 0.02485245f, 0.24276692f, 
    -0.28070161f, -0.10232604f, -0.03823414f, 0.00548794f, 0.05644703f, 0.12050254f, -0.11948613f, -0.11037720f, 
    -0.07684430f, -0.19636928f, 0.06644073f, -0.12409203f, 0.10970630f, -0.12195042f, -0.06365452f, 0.04576207f, 
    -0.07697587f, 0.11558097f, 0.06127921f, 0.05944172f, -0.23165178f, -0.06261518f, -0.05030621f, -0.02840430f, 
    -0.02254807f, -0.13202599f, -0.30303437f, 0.16929199f, -0.33089435f, -0.08129320f, -0.03642334f, 0.17821802f, 
    -0.06466282f, 0.06639628f, -0.05073973f, 0.00773490f, -0.14373989f, 0.02842924f, 0.00362149f, 0.02007661f, 
    -0.03994622f, 0.22129314f, -0.10021055f, -0.30181968f, 0.13141577f, -0.17176177f, -0.22346058f, -0.07167832f, 
    0.03449287f, 0.24174026f, -0.04616882f, -0.12134166f, -0.02951737f, 0.00815091f, 0.23127981f, 0.28844973f, 
    -0.11052876f, -0.10576954f, -0.01320296f, 0.26110926f, 0.11030992f, -0.10102220f, -0.17143513f, 0.01672322f, 
    -0.12873416f, 0.17820065f, 0.12936018f, 0.06657471f, -0.01976197f, -0.02661368f, -0.28144017f, -0.18233091f, 
    0.05366108f, 0.15127334f, 0.10739425f, -0.01419817f, -0.08878514f, -0.22033080f, 0.05397976f, -0.04088895f, 
    -0.17672919f, 0.10745771f, 0.00644219f, -0.09024127f, -0.16580065f, 0.10200230f, -0.00801988f, 0.15165675f, 
    0.16144337f, 0.38257596f, -0.25605616f, 0.09861158f, 0.04732261f, -0.07968010f, 0.10307262f, 0.13979733f, 
    0.10985345f, 0.11973087f, 0.21349089f, 0.21426813f, -0.07999530f, 0.07324058f, -0.02519404f, -0.02608711f, 
    0.01896307f, 0.12000323f, 0.08097474f, 0.14882438f, 0.01673140f, -0.13752590f, -0.14922649f, -0.01542629f, 
    -0.30454803f, 0.18100873f, -0.06305484f, -0.07505243f, 0.09653778f, -0.10805283f, 0.38558072f, -0.17238246f, 
    0.14810711f, 0.16323000f, -0.30363393f, 0.13969263f, 0.12898646f, 0.02667153f, -0.15946575f, -0.11857297f, 
    0.07789119f, 0.19984894f, -0.01333138f, 0.18448327f, -0.26697329f, -0.34022290f, -0.20223884f, -0.02796505f, 
    -0.01380287f, 0.15582187f, -0.17827290f, 0.06149130f, -0.02212255f, 0.08088212f, -0.09999873f, -0.18092191f, 
    -0.11691840f, -0.06876104f, 0.21372646f, 0.21702555f, -0.09375767f, 0.03604727f, -0.05672480f, 0.18676813f, 
    0.05240774f, 0.14857136f, 0.14062884f, 0.00790700f, -0.03726056f, -0.17235997f, 0.06666994f, -0.03711817f, 
    0.01984024f, 0.27656826f, -0.08420280f, -0.04631944f, -0.02313717f, 0.18383068f, 0.02925879f, 0.10842407f, 
    -0.15622762f, -0.13243319f, -0.34385541f, -0.17108046f, -0.04610346f, 0.07014658f, 0.07566731f, 0.24544758f, 
    0.03644510f, 0.10436609f, -0.11013564f, 0.20379996f, 0.03390963f, 0.18562023f, 0.02903791f, 0.02017039f, 
    -0.30840030f, -0.09225547f, 0.03839679f, 0.10036119f, 0.06436103f, -0.11851475f, 0.19759133f, -0.06665499f, 
    -0.11695678f, -0.00133868f, 0.11412436f, -0.04160129f, -0.06048625f, 0.34464490f, 0.21098192f, -0.07288029f, 
    -0.29102221f, -0.08111794f, -0.08412940f, 0.13293785f, 0.15050927f, 0.02369344f, -0.07161009f, 0.05004028f, 
    0.22913116f, -0.11964084f, -0.15103418f, 0.12033736f, 0.13516088f, 0.08550887f, -0.21820152f, -0.02616060f, 
    -0.08061475f, 0.11029961f, -0.03260521f, 0.05027916f, -0.15331590f, -0.01159776f, 0.14854793f, -0.24051014f, 
    -0.39974099f, -0.14618592f, -0.12768067f, 0.01907073f, 0.03864769f, -0.14864537f, -0.03362514f, 0.08328756f, 
    0.06378990f, -0.04571352f, 0.10141753f, -0.12151522f, -0.02885052f, -0.00111382f, -0.09390588f, -0.22077459f, 
    0.00699726f, -0.12286352f, 0.03977912f, 0.04727019f, 0.05833490f, -0.18410586f, 0.15093113f, 0.01999697f, 
    0.05516708f, 0.15339856f, 0.16574664f, 0.13242364f, 0.10396846f, -0.11266644f, -0.26154029f, 0.16203527f, 
    0.03704292f, 0.17413171f, -0.08331671f, -0.01088617f, 0.08837146f, -0.16499215f, 0.30972055f, -0.08674767f, 
    0.06340735f, 0.17619701f, 0.07675444f, -0.01693238f, 0.27456510f, 0.00333349f, -0.15149608f, 0.19569872f, 
    -0.06195625f, 0.12614214f, 0.07706230f, 0.14861834f, -0.03415824f, 0.15971501f, 0.16924539f, 0.03092308f, 
    0.12894005f, 0.16730782f, 0.05855126f, -0.00852373f, -0.02790678f, -0.24820913f, 0.18848240f, -0.23390013f, 
    -0.14276403f, -0.07275052f, 0.05399720f, -0.10225161f, -0.05062679f, -0.00276609f, 0.05111525f, 0.26683101f, 
    -0.22862163f, -0.04284297f, 0.27693978f, -0.03090430f, -0.00196973f, -0.02688862f, 0.05588907f, 0.19594699f, 
    -0.15273966f, -0.73042500f, 0.13050722f, 0.01941682f, 0.03354768f, -0.09021974f, 0.06253032f, -0.33542213f, 
    -0.06973628f, -0.03270001f, -0.15014756f, -0.00932126f, -0.20097260f, 0.07306302f, 0.01352970f, 0.01963710f, 
    -0.07685865f, 0.07835544f, 0.16045201f, 0.11743323f, -0.01108211f, -0.07950982f, -0.01657080f, 0.19412529f, 
    -0.01308493f, -0.01830366f, -0.18601534f, 0.03359234f, -0.26721513f, -0.08874968f, -0.35365567f, 0.12689574f, 
    0.13372688f, 0.06704624f, -0.27900264f, -0.06445063f, -0.01243480f, -0.21721433f, -0.15625292f, 0.06548729f, 
    0.11454073f, -0.01267814f, 0.10266132f, -0.15466294f, -0.10438805f, -0.16807815f, 0.12196157f, -0.12260024f, 
    -0.34854737f, 0.18231210f, 0.04382218f, 0.11596238f, -0.12184481f, 0.07346344f, 0.01811511f, -0.46332592f, 
    -0.12021135f, 0.09453341f, 0.34283212f, 0.04745862f, -0.13823539f, 0.10529885f, 0.24343227f, 0.06074455f, 
    0.18379813f, 0.03834920f, -0.02336418f, 0.06589774f, 0.03303077f, 0.10420786f, -0.04700537f, 0.01409385f, 
    -0.06542378f, -0.35335863f, -0.29502729f, 0.07018267f, -0.00298639f, 0.03721375f, 0.19686180f, 0.08601263f, 
    0.09059671f, -0.30560371f, 0.17085148f, -0.00844823f, -0.12389854f, -0.06716722f, 0.10914192f, -0.04576593f, 
    0.06130342f, 0.18879183f, -0.13666956f, 0.12974973f, 0.15900390f, 0.04865748f, 0.18786553f, 0.13525383f, 
    0.07036296f, 0.02921578f, -0.09779450f, 0.09261049f, 0.20340495f, 0.27663663f, 0.20289639f, -0.08446477f, 
    0.14502047f, -0.07690433f, 0.02115322f, 0.00005765f, 0.00297589f, 0.04881136f, 0.15539467f, -0.03403066f, 
    0.13005745f, 0.01170439f, 0.13997900f, 0.07084712f, -0.02785357f, 0.19739850f, -0.11269093f, 0.29480153f, 
    -0.18988848f, 0.09045478f, 0.06722273f, -0.00372696f, -0.02692775f, 0.02314088f, -0.04217654f, 0.25820276f, 
    0.05330928f, -0.17262369f, 0.08553169f, -0.01312373f, 0.00189315f, -0.06225405f, 0.11164159f, -0.01711071f, 
    0.07848407f, -0.16890614f, 0.06452375f, 0.02938919f, 0.06181378f, -0.04557209f, 0.01276648f, 0.04712369f, 
    -0.22782956f, 0.23388588f, 0.07645500f, -0.01634120f, -0.06489485f, -0.00827998f, -0.02745325f, 0.13117389f, 
    0.02846286f, -0.01448823f, -0.02857062f, -0.14406496f, -0.22795644f, 0.09911900f, 0.00680412f, -0.02689310f, 
    -0.04561832f, -0.03340847f, 0.41132724f, 0.12883256f, -0.02741177f, 0.08507110f, -0.07298402f, -0.24121521f, 
    0.19930570f, 0.04032458f, -0.04759115f, -0.16107146f, 0.10668883f, -0.03983975f, -0.04533163f, -0.08976565f, 
    -0.15469617f, 0.06032660f, 0.01154980f, 0.16525279f, -0.19735904f, 0.08558684f, 0.06918406f, -0.30338556f, 
    -0.08834987f, -0.05482741f, 0.00710050f, -0.11337619f, 0.11625887f, -0.01882251f, -0.15424027f, -0.20475096f, 
    0.01595459f, -0.02224695f, -0.00437908f, -0.04006773f, 0.10284294f, 0.00162664f, 0.14926836f, 0.06407657f, 
    -0.04491553f, -0.27932093f, -0.03173712f, 0.07032101f, 0.04432125f, 0.04224215f, 0.17877738f, 0.13495204f, 
    -0.15800141f, 0.27872372f, -0.45121700f, 0.08648025f, -0.10442121f, 0.16936255f, 0.22896214f, 0.00299640f, 
    0.10314082f, -0.04858954f, 0.09959253f, -0.28337473f, 0.05216567f, 0.08811654f, 0.08187966f, -0.06161268f, 
    0.07816362f, -0.26860037f, 0.29971156f, 0.08671853f, 0.20549209f, -0.18658288f, 0.01065983f, 0.05601392f, 
    -0.12444221f, 0.16879112f, -0.10870838f, 0.45263442f, -0.03933927f, -0.28416699f, -0.27399275f, -0.08615420f, 
    -0.03519552f, -0.01196484f, 0.02583461f, 0.20188750f, 0.34099087f, 0.21170568f, 0.04684843f, 0.02075605f, 
    -0.04910176f, -0.27212515f, -0.08170791f, 0.14477354f, 0.06085159f, 0.29348049f, 0.13825503f, 0.09996299f, 
    -0.05838698f, -0.04453917f, -0.04995904f, -0.01755425f, 0.00800267f, 0.18142445f, -0.33807981f, -0.07325068f, 
    -0.07681845f, -0.13772109f, 0.12360899f, 0.10713463f, -0.23257092f, 0.19401035f, -0.09746653f, 0.33637619f, 
    0.09909775f, -0.06235468f, 0.06220837f, 0.08510660f, -0.32891965f, -0.09759568f, -0.03806011f, -0.00380345f, 
    0.01647638f, -0.12011679f, -0.13890047f, 0.09280741f, 0.28638452f, 0.05371498f, -0.11728415f, 0.09984369f, 
    -0.00469846f, 0.29115564f, 0.01321125f, -0.36551714f, 0.01467129f, 0.02605278f, 0.07749488f, -0.02279381f, 
    -0.03263647f, -0.03473915f, 0.16490521f, 0.16057822f, -0.32142946f, -0.19299221f, 0.01602860f, 0.18298990f, 
    -0.10386375f, 0.04331100f, -0.07457627f, 0.30059919f, 0.02862090f, 0.11037780f, -0.00004805f, 0.08944383f, 
    -0.05611208f, -0.05179760f, 0.14999650f, 0.10748609f, 0.25389448f, 0.15873404f, 0.12798823f, 0.04790515f, 
    0.01288586f, 0.05601190f, 0.18381770f, 0.08719511f, 0.19968608f, 0.15819748f, -0.17067419f, -0.27731150f, 
    -0.19125248f, -0.03789101f, 0.00002901f, -0.14561668f, -0.01220337f, 0.09187178f, -0.22320157f, -0.00294444f, 
    -0.09956904f, 0.18095432f, 0.02578056f, 0.00453100f, -0.00649718f, -0.02323424f, 0.05370130f, 0.28005478f, 
    0.19949414f, -0.16132715f, -0.14329913f, 0.14231746f, -0.07806080f, 0.00205134f, 0.14581467f, -0.03458531f, 
    -0.43535072f, 0.00039613f, 0.03436176f, 0.07233336f, 0.09095361f, -0.03552731f, -0.03384849f, -0.08524661f, 
    -0.08365138f, 0.39026785f, 0.20086573f, -0.11785479f, -0.18762204f, -0.12508889f, -0.29450172f, 0.00192507f, 
    0.12267796f, 0.06711127f, 0.05742340f, -0.01423961f, -0.07707497f, 0.03169073f, 0.07505930f, -0.10803429f, 
    -0.01697742f, -0.22138433f, -0.20238985f, -0.04074994f, -0.22069566f, 0.04552339f, 0.03423085f, 0.10709365f, 
    0.08681732f, -0.12863797f, 0.11459520f, 0.00173655f, 0.08197834f, 0.14104730f, 0.18559131f, 0.06158412f, 
    0.06625888f, 0.04536018f, 0.02893552f, -0.03770137f, 0.07645676f, -0.00022534f, -0.15476385f, 0.15099692f, 
    -0.02271401f, 0.04409213f, -0.16798538f, -0.07069284f, -0.15190974f, -0.00737059f, -0.12197675f, 0.13565789f, 
    -0.14216715f, 0.02242200f, -0.06846847f, -0.05680329f, -0.13198116f, -0.05796296f, -0.13309993f, 0.24887244f, 
    -0.16353031f, 0.11840212f, -0.25601348f, 0.18253930f, 0.08188219f, -0.06701596f, 0.03338528f, -0.21056390f, 
    0.06722623f, 0.15579186f, -0.18118583f, 0.33613214f, -0.15232709f, -0.03674288f, 0.01143598f, 0.01716286f, 
    0.16156998f, -0.27239481f, -0.12061837f, 0.05453654f, 0.06995473f, 0.03976531f, -0.25663820f, -0.12208823f, 
    0.17831406f, -0.04278044f, -0.27641758f, 0.00445579f, 0.11715525f, 0.02618696f, -0.02604270f, 0.11909304f, 
    -0.14418028f, 0.00483105f, -0.23340428f, 0.12190495f, 0.22852178f, -0.23276512f, -0.09621566f, -0.04217553f, 
    -0.30629468f, 0.11037409f, 0.01507226f, 0.02345640f, -0.20337528f, 0.41043553f, 0.25958619f, 0.25566569f, 
    0.06523142f, -0.12223736f, 0.02501534f, 0.05566648f, -0.18055449f, 0.05841991f, 0.02199174f, 0.02262064f, 
    0.11676646f, -0.27166763f, -0.25623149f, 0.00092453f, -0.11294191f, -0.13578051f, -0.01182159f, 0.24125266f, 
    0.09557186f, -0.19222279f, -0.18290624f, -0.20328528f, -0.13142924f, -0.02330218f, -0.07881418f, -0.27177247f, 
    -0.07914314f, -0.18647219f, 0.15415856f, 0.01400720f, 0.00059261f, 0.07542334f, -0.00288755f, 0.08463970f, 
    -0.11956349f, 0.01780509f, -0.13068743f, 0.15455151f, 0.01081177f, -0.16444822f, -0.09843032f, -0.01200910f, 
    -0.06775448f, -0.13137226f, 0.09056934f, 0.09420181f, -0.31564125f, -0.02892964f, -0.11269067f, 0.02249134f, 
    0.01825466f, 0.12148686f, -0.23741914f, 0.13494030f, 0.03670106f, 0.06734211f, -0.02115007f, 0.16259667f, 
    -0.02760348f, 0.03746301f, 0.13747856f, 0.20290707f, 0.04389522f, 0.02913755f, -0.35035101f, -0.12540889f, 
    0.13491744f, -0.02770930f, -0.00438777f, -0.14254098f, -0.02552744f, 0.05348746f, 0.35896999f, 0.17814350f, 
    0.15065053f, 0.23502664f, 0.21339989f, -0.09884566f, 0.14200273f, 0.17390728f, -0.04650843f, 0.16220260f, 
    0.15328310f, 0.15239394f, 0.14004803f, 0.12307277f, 0.00960154f, 0.00508618f, 0.15234379f, 0.19884713f, 
    0.01811787f, -0.04223056f, -0.11684727f, 0.00079343f, 0.19378255f, -0.12112649f, 0.08497499f, 0.01766777f, 
    0.09552559f, -0.00162709f, -0.14474674f, -0.00967783f, -0.00419474f, 0.17704989f, 0.12541582f, 0.07893753f, 
    -0.04222195f, -0.20377788f, -0.25261620f, 0.01779151f, -0.00293917f, 0.08656388f, -0.06710133f, -0.02936438f, 
    -0.02104815f, 0.45896518f, -0.16764066f, -0.14554271f, -0.03656320f, 0.29947329f, -0.12253216f, 0.04474000f, 
    0.01524765f, -0.00669470f, 0.04658046f, 0.18206853f, 0.09139377f, 0.06390496f, 0.17632382f, -0.02314418f, 
    -0.13498421f, -0.05309282f, -0.04219924f, 0.12766202f, -0.15736517f, 0.25500736f, 0.05159351f, -0.12565263f, 
    -0.08065218f, 0.13021247f, -0.05803838f, 0.14652817f, -0.18396269f, 0.10387348f, -0.29423249f, -0.08839018f, 
    -0.00044359f, 0.13259977f, -0.12414886f, 0.03274610f, 0.21836685f, 0.21279070f, 0.12121744f, 0.26358587f, 
    -0.06498771f, -0.04938054f, 0.03453326f, 0.05525170f, -0.01292715f, 0.12805088f, -0.06451683f, 0.35144112f, 
    -0.24712111f, 0.22636279f, 0.05341691f, -0.07975698f, 0.03934249f, 0.06649350f, -0.17125271f, -0.10806866f, 
    0.19395179f, 0.03592962f, -0.13611692f, 0.33630848f, 0.18446706f, -0.03985036f, -0.08783872f, -0.05128381f, 
    -0.35612375f, -0.06099616f, 0.03377965f, 0.19480015f, 0.04750205f, 0.10683216f, -0.06234518f, -0.02256192f, 
    0.03955207f, -0.28189459f, 0.17780718f, 0.22987193f, 0.16055185f, -0.17244236f, 0.04560969f, 0.04486050f, 
    -0.00564999f, 0.02934974f, -0.34585854f, 0.21619369f, -0.06354856f, 0.10706307f, 0.05196173f, -0.14467739f, 
    -0.02504003f, 0.09983365f, 0.00191625f, -0.00446884f, -0.33446354f, 0.10346467f, 0.05883683f, -0.06744337f, 
    0.01784181f, -0.05147209f, 0.01476806f, -0.05091535f, 0.01025159f, -0.07994688f, 0.36500785f, -0.28815854f, 
    -0.12419428f, -0.03179464f, 0.02257545f, -0.05422611f, 0.07475688f, 0.02117151f, -0.06030116f, -0.03221380f, 
    -0.07750098f, -0.14797595f, 0.00250639f, 0.20095260f, 0.07414235f, -0.00018609f, -0.46310872f, 0.40709656f, 
    -0.40321648f, 0.16918273f, 0.02039761f, -0.04845359f, 0.03729200f, 0.02669746f, -0.06686314f, -0.11914800f, 
    -0.24006635f, -0.01763672f, -0.04432016f, -0.11031966f, -0.02849440f, -0.07110929f, -0.16885376f, 0.29820332f, 
    -0.10248647f, 0.24707487f, -0.11512362f, -0.01447442f, 0.19423985f, 0.10645717f, 0.12740473f, 0.03063547f, 
    -0.01896164f, -0.15342683f, -0.15727508f, 0.27029020f, 0.15096515f, 0.07058170f, 0.01927160f, -0.03319298f, 
    0.06624480f, 0.15326481f, 0.18010837f, -0.07519832f, -0.11852220f, 0.15426196f, 0.07519925f, 0.07871020f, 
    0.01499747f, -0.01294403f, 0.21868777f, -0.04068404f, 0.22184160f, -0.21694121f, 0.08660549f, -0.04055447f, 
    -0.09954769f, 0.14972101f, 0.15135990f, -0.10787952f, -0.41661784f, -0.07644300f, -0.05466513f, -0.02776582f, 
    -0.12784947f, 0.00747269f, 0.02280625f, -0.01431860f, 0.04970295f, -0.25234640f, 0.36706746f, -0.03601776f, 
    0.05267740f, -0.16866153f, 0.05233336f, -0.00193770f, 0.13709812f, 0.15058053f, 0.26003015f, 0.24326767f, 
    -0.15214284f, -0.14824285f, 0.03034761f, -0.01497140f, 0.03471212f, 0.01289121f, 0.15715128f, -0.40701860f, 
    0.48254040f, 0.12960455f, -0.19491443f, -0.19722417f, 0.04708258f, -0.12784474f, 0.01344931f, -0.30959421f, 
    -0.03040390f, 0.16343863f, -0.08971990f, -0.13824461f, 0.11208619f, -0.20559439f, 0.12593690f, 0.07347225f, 
    -0.02375091f, -0.19182858f, 0.09074745f, -0.35166144f, -0.01584973f, 0.33111694f, 0.20802049f, -0.08094597f, 
    -0.01847824f, -0.01517793f, -0.23482981f, -0.24362086f, 0.04896273f, -0.02827744f, -0.21411483f, -0.02145373f, 
    0.03207394f, 0.14682142f, 0.08649233f, -0.37169445f, -0.25822160f, -0.21444155f, 0.13320713f, 0.10168868f, 
    -0.02112249f, -0.00153607f, 0.20067738f, -0.04636706f, -0.35817510f, -0.19637245f, 0.34061608f, -0.12165112f, 
    0.00629216f, 0.06175354f, -0.16466919f, -0.09727565f, 0.10970359f, -0.00463206f, -0.10669301f, 0.25214782f, 
    -0.05341099f, -0.00672029f, 0.11548179f, -0.05249502f, 0.14389470f, -0.11027984f, -0.14875422f, 0.00608514f, 
    0.03588565f, 0.20674892f, -0.00918366f, -0.16740115f, -0.26833239f, -0.04572451f, 0.07732049f, -0.14082554f, 
    -0.07704826f, -0.07993951f, 0.15116510f, 0.07176252f, 0.29936460f, 0.07059595f, -0.12643287f, 0.14506660f, 
    -0.02408762f, -0.06090305f, -0.00596946f, 0.11942160f, 0.12890263f, -0.06870945f, -0.16524866f, 0.07110509f, 
    0.11460894f, -0.04690980f, -0.20792930f, -0.08884214f, 0.18274227f, 0.17712978f, 0.10428103f, -0.12713850f, 
    -0.04997390f, 0.21170041f, -0.31321195f, 0.17002639f, 0.23549585f, -0.06228696f, 0.19548900f, -0.13544767f, 
    -0.03877920f, -0.02948131f, 0.11191472f, 0.06726415f, -0.15259150f, 0.02286558f, 0.04988900f, -0.05357533f, 
    0.05236693f, -0.11521909f, -0.05520200f, -0.13373211f, -0.03749649f, 0.02611709f, 0.22072563f, 0.09845895f, 
    0.13982381f, -0.05199575f, 0.16872968f, 0.03645536f, 0.10673510f, -0.00520233f, -0.26303804f, 0.08671582f, 
    0.41121766f, 0.11677729f, 0.10833967f, -0.01793299f, 0.01542564f, 0.11857038f, -0.08461812f, 0.28135616f, 
    0.31013986f, 0.11870122f, -0.01587529f, 0.05837697f, 0.04179180f, -0.00537893f, 0.01968778f, -0.19092421f, 
    -0.13884816f, -0.41415337f, -0.05728602f, 0.00619033f, -0.00501571f, 0.07850777f, 0.32645777f, -0.06101400f, 
    -0.03508905f, 0.06878759f, -0.07245918f, 0.21863775f, -0.03128565f, 0.27930307f, -0.06137000f, -0.19454889f, 
    0.07881861f, -0.16685189f, -0.16156472f, 0.04432989f, -0.13517429f, 0.10867028f, 0.06887217f, 0.08219927f, 
    -0.07378898f, 0.00746528f, -0.13522027f, -0.23054190f, 0.06365868f, 0.22995549f, 0.09040030f, 0.00909698f, 
    0.03967109f, 0.15593819f, -0.01676061f, 0.03803304f, -0.13045101f, -0.09759896f, 0.29912135f, 0.07903232f, 
    -0.07061137f, 0.02037628f, -0.26296094f, -0.07202756f, 0.20381270f, -0.27147886f, -0.35643852f, 0.17316560f, 
    0.10574178f, 0.18824515f, 0.18064930f, -0.02211300f, -0.00590580f, 0.44420794f, -0.34996304f, 0.10041944f, 
    0.11395275f, -0.06498210f, 0.07156808f, -0.12671264f, 0.06685272f, -0.04737855f, -0.01084291f, 0.41845885f, 
    0.31596288f, -0.10308169f, 0.10639451f, -0.20377305f, 0.01187438f, 0.06284750f, 0.07569264f, -0.25995690f, 
    -0.20617521f, -0.54090494f, 0.11099663f, 0.02210166f, 0.00942882f, -0.09332220f, -0.04908725f, 0.01946348f, 
    0.07483921f, 0.01935117f, 0.04788302f, -0.00092013f, 0.23159915f, -0.09640422f, -0.03115983f, -0.00126144f, 
    -0.10506060f, 0.11518686f, 0.16276625f, 0.08619657f, 0.20581354f, 0.04908615f, -0.02577430f, 0.02075423f, 
    0.14156455f, 0.00537862f, -0.07895692f, 0.05303314f, 0.07491211f, 0.07668710f, 0.04178252f, 0.04926954f, 
    0.20723246f, 0.03511908f, 0.04233834f, -0.12065277f, 0.10554013f, 0.20669405f, -0.07259172f, 0.05975558f, 
    -0.10168198f, -0.00024658f, -0.06298476f, -0.05256949f, -0.19871795f, -0.11627869f, 0.07961231f, 0.33521932f, 
    0.03766508f, 0.18587168f, 0.02783669f, -0.27189258f, -0.04640577f, 0.08833620f, -0.12655403f, -0.13686323f, 
    -0.15606727f, 0.12147668f, -0.19407055f, 0.17267400f, 0.13658437f, -0.15110777f, -0.38134488f, -0.00109569f, 
    -0.19777991f, 0.08662371f, -0.06162202f, 0.00780745f, 0.25499570f, -0.01492792f, -0.00968076f, -0.37117344f, 
    -0.04680712f, -0.15716611f, 0.07397533f, -0.05018784f, -0.18693466f, -0.10276798f, 0.18663219f, -0.03204941f, 
    -0.61789948f, -0.11917666f, 0.14887750f, -0.38559225f, -0.02217287f, -0.42634124f, -0.05462466f, 0.15206134f, 
    -0.25793496f, -0.39218661f, 0.27365100f, 0.19438989f, -0.01187852f, -0.07164213f, -0.22915792f, 0.06806796f, 
    -0.07863600f, -0.08455580f, 0.48664773f, 0.17114019f, -0.12468898f, 0.10126426f, 0.13631530f, 0.03893264f, 
    -0.12385552f, 0.06405828f, 0.12451403f, -0.00176611f, -0.31428593f, -0.09544802f, -0.01462416f, -0.10071412f, 
    0.01802404f, -0.02373272f, -0.20743887f, 0.01365687f, -0.09566564f, -0.01818987f, -0.08978952f, 0.03103573f, 
    0.01217107f, 0.08343879f, -0.14853019f, -0.00625186f, 0.24273112f, 0.05951257f, -0.31149346f, -0.11958691f, 
    0.11038616f, 0.03753864f, 0.02892009f, 0.13833036f, 0.04558636f, -0.05814255f, -0.02871294f, 0.19431190f, 
    0.42584783f, 0.09113070f, -0.16787656f, -0.14404114f, -0.10981040f, -0.19738534f, -0.21752922f, 0.00548038f, 
    -0.07572273f, 0.06353600f, 0.13780028f, -0.01086953f, 0.27949765f, 0.03196844f, -0.25922063f, 0.00530960f, 
    -0.02247807f, -0.02529075f, -0.02023073f, 0.02443193f, -0.05232064f, -0.00566505f, -0.02259326f, 0.04653585f, 
    -0.02398569f, -0.03494568f, 0.02829397f, 0.03375536f, -0.02257052f, 0.03642862f, -0.02685934f, -0.00166998f, 
    -0.04430868f, -0.04289415f, -0.06351478f, -0.00173952f, 0.03719924f, -0.01188545f, 0.03126209f, -0.01605991f, 
    0.00518667f, -0.05618284f, -0.03011807f, -0.00828687f, -0.03045073f, 0.03351032f, -0.02399684f, 0.03308977f, 
    0.01613230f, -0.00163334f, 0.00222568f, 0.02351216f, -0.01906024f, -0.03256553f, -0.03206380f, -0.05616239f, 
    -0.02198108f, -0.02853621f, 0.01843577f, 0.01253676f, 0.04548351f, -0.04959098f, -0.05603086f, -0.06180350f, 
    0.01093592f, -0.00407135f, -0.05369272f, -0.05344133f, -0.04329463f, -0.04109724f, -0.02902992f, -0.00671127f, 
    0.04973580f, -0.05168027f, -0.02803579f, 0.01991601f, 0.01353638f, -0.04873836f, -0.02539044f, 0.03242745f, 
    0.03229779f, -0.05098891f, 0.04367240f, 0.03849530f, -0.05133820f, -0.02712839f, 0.00026613f, -0.01722007f, 
    0.00159581f, 0.00375334f, -0.04463594f, -0.00622354f, -0.03584407f, 0.02389633f, -0.00592520f, 0.03357060f, 
    0.03144664f, -0.03619938f, 0.02540689f, -0.04412423f, -0.02562880f, 0.04019457f, -0.05079615f, -0.01948867f, 
    0.02807114f, -0.02673327f, -0.02943655f, -0.04956921f, 0.02418027f, -0.02870062f, 0.04733809f, 0.04300414f, 
    0.02256770f, -0.00227766f, -0.02324918f, -0.02848642f, 0.00293519f, 0.04668421f, 0.03040457f, -0.01784443f, 
    -0.03203281f, -0.00512823f, 0.03598808f, -0.04198337f, 0.05172932f, -0.03093633f, -0.04930552f, -0.05253282f, 
    0.03755115f, 0.03016766f, -0.01645174f, -0.03506566f, 0.02903727f, -0.00461261f, -0.05904312f, -0.01634028f, 
    -0.00157980f, 0.02721606f, -0.05243356f, -0.02111147f, 0.02745809f, 0.04490222f, 0.04509657f, -0.05262958f, 
    -0.00585608f, -0.04526939f, -0.02555693f, 0.02020210f, -0.03517700f, -0.01693680f, 0.05255302f, -0.04142608f, 
    0.03059318f, -0.00258969f, 0.03580613f, -0.01538029f, 0.04257287f, 0.00909458f, -0.06005032f, -0.04605177f, 
    0.00315307f, 0.03328402f, -0.03783838f, -0.00872113f, -0.01652151f, -0.04023166f, 0.03123632f, 0.01321634f, 
    -0.02899278f, -0.05572917f, 0.04793667f, -0.04309026f, 0.00050274f, -0.03512783f, -0.02700845f, 0.01519795f, 
    -0.06420545f, -0.01801050f, -0.02352725f, -0.01811300f, -0.03895325f, -0.03707516f, -0.04692902f, 0.04446465f, 
    0.04468234f, 0.03091255f, -0.02961947f, -0.06198208f, -0.03159741f, 0.04917823f, 0.02938643f, -0.00948409f, 
    -0.00713699f, 0.04951070f, -0.05270217f, -0.04379759f, -0.00935237f, 0.02663594f, -0.05322174f, 0.00011890f, 
    -0.00620795f, -0.01035939f, -0.00336312f, 0.02231568f, -0.01317468f, -0.01293318f, 0.01078853f, -0.01419382f, 
    -0.02399383f, 0.00311381f, -0.03918185f, -0.03362850f, -0.05920863f, -0.00101447f, -0.01534601f, -0.00718311f, 
    0.01232617f, -0.06381183f, 0.02087921f, -0.01519532f, -0.02114115f, -0.00802092f, 0.02692040f, -0.05297629f, 
    0.02902122f, -0.04878382f, 0.01354305f, -0.01956724f, 0.00508042f, 0.00309510f, -0.00795529f, -0.05425246f, 
    0.01882521f, 0.02233595f, -0.02920804f, -0.05755819f, 0.00715665f, -0.06290384f, -0.02563495f, 0.04629711f, 
    0.04675360f, 0.03365684f, 0.03816651f, -0.00134418f, -0.03357502f, 0.02910691f, 0.00107911f, -0.05015880f, 
    0.04470867f, -0.01349606f, -0.02138523f, 0.01752064f, 0.00093014f, 0.04533707f, -0.03145477f, -0.06262358f, 
    -0.03835848f, -0.02578909f, -0.04585203f, -0.03245147f, 0.00691824f, 0.00118718f, 0.01565912f, -0.03394300f, 
    -0.05530887f, 0.02348760f, 0.04480674f, 0.00049592f, -0.02409057f, 0.01821003f, 0.02730137f, 0.00821401f, 
    -0.02848578f, 0.01489541f, -0.04905842f, 0.04765612f, 0.03474370f, 0.04420902f, -0.00892992f, -0.00220954f, 
    -0.01536079f, -0.02117468f, -0.02409657f, -0.02862401f, -0.01639483f, -0.03003214f, -0.04400488f, -0.03014449f, 
    -0.01918270f, -0.01663883f, -0.05736402f, 0.04376417f, 0.01609565f, 0.05091796f, 0.02956899f, -0.06380316f, 
    -0.04925330f, 0.02928642f, 0.03920456f, 0.01548966f, 0.02985137f, -0.04970306f, -0.02036499f, -0.01241686f, 
    -0.03681654f, 0.02111382f, 0.02302490f, -0.06135949f, 0.01490551f, -0.02453232f, -0.06820470f, 0.04111505f, 
    -0.00320918f, -0.03229138f, 0.03336464f, -0.06287843f, -0.01890820f, 0.00074738f, -0.03261399f, 0.04277769f, 
    -0.04973587f, 0.01191562f, 0.00556767f, 0.01194391f, -0.02160511f, -0.01882370f, -0.06279510f, -0.02944711f, 
    -0.03316963f, 0.04448663f, -0.03224618f, -0.00771019f, 0.00835604f, 0.04147786f, -0.05986718f, -0.05491260f, 
    0.02112554f, -0.05544723f, -0.02860810f, 0.02674123f, 0.00165408f, 0.01623144f, -0.02543426f, -0.04476239f, 
    0.02033176f, -0.03632447f, -0.05606044f, 0.01580086f, -0.02671808f, -0.03081767f, 0.03498001f, -0.01793315f, 
    -0.04861815f, 0.04528468f, 0.00607431f, -0.04953390f, -0.05461140f, -0.02680862f, 0.03499243f, -0.02561659f, 
    -0.01532865f, 0.00968749f, -0.00947552f, -0.03443531f, 0.00324237f, 0.04581768f, -0.05270331f, -0.03482099f, 
    -0.00328931f, -0.05502612f, -0.03757669f, 0.03163708f, -0.00557296f, -0.05202259f, -0.06286857f, 0.03013974f, 
    -0.01435685f, 0.04284181f, -0.06839348f, -0.01461791f, -0.03733633f, 0.01402007f, -0.03959607f, 0.03141162f, 
    -0.02464820f, -0.00680221f, 0.00287482f, -0.04855153f, -0.00969771f, -0.01734516f, -0.04792069f, 0.00045669f, 
    0.01164664f, 0.02873302f, -0.02958504f, -0.05411981f, 0.03654655f, -0.04139425f, -0.05904410f, -0.01890644f, 
    0.03226816f, 0.04226836f, -0.02553833f, 0.01577892f, -0.00424858f, -0.00399840f, -0.01736136f, -0.06001357f, 
    -0.05431983f, 0.02350035f, 0.00487157f, 0.01549348f, 0.04168741f, 0.03350694f, 0.03319925f, 0.03174237f, 
    -0.00729633f, 0.02402184f, -0.00207794f, -0.02372964f, 0.03619125f, 0.01668776f, -0.03859208f, -0.01083347f, 
    0.04433190f, -0.01619019f, -0.06464513f, 0.02733564f, 0.01386093f, 0.04807200f, -0.01157560f, 0.02916216f, 
    -0.03694825f, -0.03536664f, 0.00832300f, -0.02821879f, -0.06477474f, -0.04119640f, -0.05147568f, -0.05403142f, 
    -0.02723789f, 0.00648202f, 0.03183625f, 0.03331123f, 0.03750581f, 0.03749039f, -0.01024547f, 0.03322727f, 
    -0.05916906f, 0.03775927f, 0.04106636f, -0.01061721f, 0.01442522f, -0.02442975f, -0.00015749f, -0.03368402f, 
    0.03365305f, -0.01298860f, 0.03072556f, -0.06105380f, 0.01842700f, 0.03114296f, -0.01575381f, 0.04018989f, 
    0.02453284f, -0.05396702f, -0.05185295f, -0.01102415f, 0.05105231f, 0.00302521f, -0.03837815f, -0.05286113f, 
    -0.04887551f, 0.00169151f, -0.04435775f, -0.02322601f, -0.06415472f, 0.00336968f, -0.04103582f, 0.01842238f, 
    -0.04207361f, -0.03208916f, -0.06799604f, -0.00796864f, 0.03399035f, -0.00864451f, -0.06084405f, 0.01991810f, 
    0.04233972f, -0.01711000f, 0.04353810f, -0.01596013f, -0.02851908f, -0.04115020f, 0.01709172f, -0.03819470f, 
    -0.04556281f, -0.02310552f, 0.02655242f, 0.03257070f, -0.02449150f, 0.00964763f, 0.00656857f, -0.02578355f, 
    0.00881408f, 0.00867978f, -0.02275107f, -0.04646938f, -0.02782723f, 0.03900553f, 0.04125029f, -0.01724204f, 
    -0.07013615f, 0.01128594f, -0.04339984f, -0.05939230f, -0.05260268f, 0.02591565f, -0.06204315f, -0.04850247f, 
    0.04522018f, -0.01476503f, 0.03071218f, -0.03572415f, 0.02516540f, -0.01897246f, 0.04057659f, -0.00872155f, 
    -0.04765755f, -0.00798492f, -0.06368061f, -0.03914880f, 0.03367186f, 0.02070378f, 0.04539835f, -0.04928069f, 
    -0.00193798f, -0.05409382f, -0.02860627f, 0.00717883f, -0.00315577f, 0.00500600f, -0.05267544f, 0.00799645f, 
    0.04006143f, -0.03316451f, -0.01348721f, 0.00764767f, -0.06137580f, -0.04259761f, 0.00526260f, 0.03205115f, 
    0.03157901f, 0.02357026f, -0.05335028f, -0.01404099f, -0.04542346f, 0.04206225f, -0.02075294f, -0.05193150f, 
    -0.00092177f, 0.01101290f, 0.00238071f, 0.02131357f, 0.02104417f, -0.04398270f, -0.01365046f, -0.01838471f, 
    0.00615935f, -0.04575993f, 0.04254364f, -0.03284734f, -0.01069492f, 0.02819682f, 0.04450481f, 0.02694542f, 
    0.02020001f, 0.01509931f, -0.06651536f, 0.00602355f, 0.01066810f, 0.04227274f, -0.04445702f, 0.03657977f, 
    -0.03183678f, 0.03214400f, -0.01646103f, 0.04082952f, 0.02858568f, 0.04494212f, -0.00234085f, -0.06239748f, 
    0.01404269f, -0.00993765f, -0.00177804f, -0.05810275f, -0.01971737f, -0.03024502f, 0.03735800f, -0.01623432f, 
    -0.03530509f, -0.02492208f, 0.01583588f, -0.05554102f, -0.05683704f, 0.04521320f, 0.01862022f, -0.02641449f, 
    0.03456884f, 0.03229118f, -0.01155102f, 0.04410470f, 0.03296839f, 0.00704761f, -0.00392372f, -0.05265102f, 
    0.00459548f, 0.00920242f, -0.02931223f, 0.04994622f, 0.01242606f, 0.01926914f, -0.02661403f, 0.02283153f, 
    -0.05291127f, 0.04332615f, -0.06077353f, 0.04100483f, -0.04225879f, -0.00164151f, 0.02762252f, -0.03175027f, 
    0.01347686f, 0.02621081f, -0.05896842f, -0.06485679f, -0.02542946f, 0.00479253f, -0.03628458f, 0.03520196f, 
    -0.00213172f, -0.05392913f, 0.01227328f, -0.06091730f, -0.00005625f, 0.04907956f, -0.04660375f, 0.01515751f, 
    0.05217306f, 0.02799059f, -0.00659266f, 0.05793499f, 0.00417968f, 0.03479598f, -0.01932595f, 0.03679483f, 
    0.01065013f, -0.01485604f, 0.04308573f, -0.02698475f, -0.02903871f, -0.03966086f, -0.01757719f, -0.01484149f, 
    -0.01475755f, 0.04356169f, -0.04416491f, 0.00535344f, -0.05320470f, -0.05115157f, 0.04690634f, 0.00940392f, 
    -0.06435394f, -0.00303626f, -0.01146904f, 0.00416820f, 0.02972772f, 0.00353422f, 0.02265767f, -0.05783207f, 
    -0.00302348f, -0.03060196f, 0.01535464f, 0.00193579f, -0.05740976f, -0.00525300f, -0.00885522f, -0.05242569f, 
    -0.00736521f, -0.00199339f, -0.02786401f, -0.05470638f, -0.04931915f, 0.00915812f, -0.01043477f, -0.05325816f, 
    0.03727832f, -0.04130944f, -0.05601360f, 0.01775265f, 0.01789258f, 0.02971833f, 0.04258022f, -0.01954040f, 
    -0.06147319f, 0.01641707f, 0.03496875f, -0.05389882f, 0.00455237f, -0.05134854f, -0.05696119f, -0.05989075f, 
    0.01935434f, -0.01788929f, -0.00865828f, -0.00902038f, -0.00354125f, 0.03373043f, -0.04375794f, -0.04076108f, 
    0.04875129f, -0.02187308f, 0.00270673f, -0.03578852f, -0.06481693f, 0.03598633f, -0.04745363f, -0.03090067f, 
    0.04652549f, -0.02571233f, -0.05764748f, -0.06307390f, -0.02533525f, -0.03420823f, 0.01224955f, -0.06273007f, 
    -0.01993779f, -0.03434113f, -0.01603880f, -0.02618338f, -0.04672423f, 0.00162372f, -0.03427424f, 0.03527404f, 
    0.02725730f, -0.04322864f, 0.01651125f, 0.02267113f, -0.00631884f, -0.02156427f, 0.04583799f, 0.00178510f, 
    -0.00532383f, 0.00394391f, 0.01843223f, 0.00696458f, 0.03334455f, -0.06393663f, 0.05655767f, 0.04536846f, 
    -0.05866671f, 0.05264113f, 0.03708691f, -0.04944597f, 0.03612949f, -0.00318141f, -0.02385812f, -0.00863464f, 
    0.00290023f, -0.01973439f, -0.01532436f, 0.01547700f, 0.02516550f, -0.02182701f, -0.04932646f, -0.05614702f, 
    -0.04456465f, -0.03141726f, 0.04397299f, -0.03396245f, 0.04723727f, -0.04520483f, -0.00271160f, -0.04552174f, 
    0.00311766f, 0.02177854f, 0.04893653f, 0.02374374f, 0.05160239f, -0.05546536f, -0.04389041f, 0.03393516f, 
    -0.01815863f, 0.01584359f, -0.05460945f, 0.04062445f, -0.04585230f, -0.02069575f, 0.00909215f, -0.05764906f, 
    -0.05830524f, 0.03130409f, 0.00541059f, -0.05426648f, -0.01430364f, 0.05170253f, 0.00436493f, -0.03115522f, 
    0.04511808f, -0.01734187f, 0.00219916f, -0.01532168f, -0.04957917f, 0.03600915f, -0.01702446f, -0.02552968f, 
    -0.05025049f, -0.02018999f, -0.06385724f, -0.02310796f, -0.05110815f, -0.04631963f, 0.00947887f, 0.02957720f, 
    -0.02757869f, -0.03776447f, 0.00323995f, -0.01571294f, -0.05829902f, -0.01679350f, 0.03085755f, 0.02533481f, 
    -0.05718298f, -0.04233697f, 0.03535369f, 0.00878063f, -0.06481858f, -0.04894495f, 0.00424943f, -0.01030094f, 
    0.04899377f, -0.03731074f, -0.06023122f, -0.05565976f, -0.02182201f, 0.01487628f, 0.01902059f, 0.00903453f, 
    -0.05779878f, 0.04061643f, -0.03532355f, 0.00743149f, 0.01221216f, -0.04911614f, 0.00136661f, 0.01816202f, 
    0.04787076f, -0.02098901f, 0.00328738f, -0.04832928f, 0.02589404f, 0.01224700f, 0.04653757f, 0.00682037f, 
    0.01200651f, -0.01402239f, -0.06382860f, 0.03582755f, -0.00021735f, 0.04746050f, 0.05181664f, 0.03072313f, 
    0.00273799f, -0.00686894f, -0.04945971f, -0.00608534f, -0.04125041f, -0.00509639f, 0.04033647f, -0.02143439f, 
    -0.26867974f, 0.00564786f, -0.06894889f, -0.18187904f, 0.01788218f, 0.19892040f, 0.01198924f, -0.04467466f, 
    0.02978808f, -0.38860372f, 0.02046893f, 0.05444753f, -0.10289121f, -0.03667926f, 0.07687559f, 0.06502525f, 
    0.11102667f, -0.07399699f, 0.20348418f, -0.01455019f, 0.04224281f, 0.26579875f, 0.05796943f, 0.02706499f, 
    -0.06160067f, -0.09388596f, 0.07660735f, 0.33793250f, 0.05965311f, -0.00778438f, -0.20709085f, -0.14777409f, 
    -0.16208546f, 0.16918017f, 0.12932040f, -0.01140238f, -0.28112733f, -0.27264464f, -0.36902177f, 0.06108715f, 
    -0.06074662f, 0.17538849f, -0.07673313f, -0.05015364f, 0.10347486f, 0.15803081f, 0.21186897f, -0.05653716f, 
    -0.10998482f, 0.12319483f, -0.22703430f, -0.02135361f, -0.07532372f, 0.01297796f, 0.07561423f, 0.02058117f, 
    -0.06233000f, 0.13101040f, 0.21259443f, 0.06143686f, -0.01732519f, -0.10446429f, 0.01647952f, -0.02011314f, 
    0.00015389f, 0.28925800f, 0.06133081f, 0.01500474f, -0.04614706f, -0.22498854f, 0.25133580f, -0.20179735f, 
    0.02665941f, -0.09792541f, -0.12367480f, -0.24932384f, 0.15905672f, -0.08602464f, 0.07625885f, 0.19444117f, 
    0.13899900f, 0.38134196f, 0.13152823f, -0.25141963f, 0.11893997f, -0.04670748f, -0.04101841f, 0.05469796f, 
    0.06507818f, 0.03661651f, 0.20317966f, 0.06701542f, -0.09870670f, 0.08476437f, 0.06173450f, -0.06043642f, 
    -0.00551641f, -0.03087538f, -0.07646176f, -0.04114388f, 0.08269068f, -0.06571777f, -0.29033303f, -0.27309853f, 
    -0.13942836f, -0.12336472f, 0.11198866f, 0.07831626f, 0.22459252f, -0.08678919f, 0.12306370f, -0.45085031f, 
    -0.30272713f, 0.05067292f, -0.17675769f, -0.08939755f, -0.11285242f, 0.12511136f, 0.13003576f, 0.16279528f, 
    -0.06142078f, -0.10245674f, -0.11084758f, -0.16132979f, 0.13118824f, 0.09962197f, -0.05241472f, -0.04300892f, 
    -0.01891578f, 0.32908514f, -0.02823152f, 0.12575889f, -0.21804330f, -0.22444320f, -0.08278143f, 0.01561394f, 
    0.21936920f, 0.00111408f, 0.00226627f, 0.07844715f, 0.08237658f, 0.07488164f, 0.21404301f, -0.07132906f, 
    0.24577619f, 0.23917319f, -0.17978111f, 0.24841781f, -0.17352852f, -0.11789657f, -0.03871325f, 0.06871575f, 
    0.08576778f, 0.16242112f, 0.30878630f, 0.06759041f, -0.06128424f, -0.16939679f, -0.13028781f, -0.13383636f, 
    0.13187024f, 0.03821694f, -0.26435652f, -0.48865142f, -0.15645787f, 0.05659596f, 0.26901895f, 0.06927632f, 
    -0.09030736f, 0.06375657f, 0.01344351f, 0.59919238f, 0.35628909f, 0.02633084f, 0.27515715f, -0.10378426f, 
    0.00521503f, -0.03762830f, 0.09368432f, 0.06812850f, -0.05804987f, -0.16879097f, -0.41366944f, -0.24014808f, 
    -0.01660775f, 0.11854360f, 0.00387477f, -0.01403116f, -0.12351870f, 0.17186792f, 0.42171311f, -0.15831424f, 
    0.02193321f, -0.01500919f, -0.07280605f, -0.03266053f, -0.12305847f, -0.00598393f, 0.12963033f, -0.40935007f, 
    -0.33443600f, 0.15753938f, 0.08606946f, 0.04982400f, -0.12565681f, 0.01025367f, 0.01940179f, 0.18888828f, 
    -0.15003239f, 0.09923322f, 0.06304859f, 0.02699975f, -0.23532403f, 0.18495077f, -0.04989481f, 0.07568450f, 
    0.59163857f, 0.16298778f, 0.01409008f, 0.19585897f, 0.18546171f, 0.11531693f, 0.00515680f, -0.10925659f, 
    0.07591719f, 0.27285102f, -0.10045038f, -0.08216137f, 0.13513732f, 0.18045919f, 0.12711589f, -0.06994376f, 
    0.08777246f, 0.06956031f, -0.19116913f, -0.14161488f, 0.02952715f, -0.17890161f, 0.05435732f, -0.13727038f, 
    -0.03063935f, -0.06878722f, 0.03480912f, 0.15364453f, 0.26269469f, 0.09235244f, 0.22770438f, -0.20490183f, 
    0.03272180f, 0.14745033f, 0.09759278f, -0.14036091f, 0.06205054f, -0.25936157f, 0.03634969f, -0.62964177f, 
    -0.28424862f, -0.15425161f, -0.03933134f, 0.16080165f, -0.09862684f, 0.06982677f, -0.04101385f, 0.31380600f, 
    -0.44978926f, -0.02612233f, 0.00152329f, 0.06930117f, 0.11591505f, -0.20848486f, -0.02445268f, 0.25084606f, 
    -0.17968841f, 0.23640613f, 0.01149672f, 0.03882872f, 0.03153601f, -0.24652889f, -0.01046338f, -0.09531606f, 
    0.02242135f, -0.19673744f, -0.08467509f, 0.04964445f, 0.12717137f, 0.09981322f, 0.03399162f, -0.01373160f, 
    -0.04011384f, -0.04471758f, -0.03299310f, -0.04517721f, 0.00124608f, -0.01606112f, -0.06110528f, 0.02980091f, 
    -0.05312337f, 0.00391527f, -0.00168316f, -0.01578514f, -0.02309204f, 0.04829429f, -0.06255348f, -0.05945063f, 
    -0.06476908f, -0.02831520f, 0.05228249f, 0.02077951f, -0.04821201f, -0.01883744f, -0.03003763f, -0.05239937f, 
    0.04794119f, -0.05388807f, 0.04998762f, -0.00138612f, 0.05120471f, 0.01984245f, -0.02871343f, -0.05161884f, 
    0.01975729f, -0.04566832f, 0.04181369f, 0.00711213f, -0.05569986f, -0.00312679f, -0.05101525f, -0.02716041f, 
    -0.05516360f, 0.01482647f, -0.03635938f, 0.02150730f, -0.06101746f, 0.00437606f, -0.04605161f, -0.04818394f, 
    -0.01851275f, -0.04097220f, -0.05658744f, -0.00870414f, -0.02052385f, -0.06388522f, -0.00665202f, 0.04978829f, 
    -0.06370083f, -0.04938910f, 0.04501944f, -0.04002192f, -0.00566079f, 0.01156133f, -0.03088599f, -0.02611792f, 
    0.00682664f, -0.01671659f, 0.04015784f, 0.03490175f, -0.02308544f, -0.04265941f, -0.06434234f, 0.02302630f, 
    0.01594689f, 0.04546410f, -0.03461334f, -0.02968553f, -0.04964033f, -0.05955412f, 0.02966030f, 0.04321858f, 
    -0.05106451f, -0.00680102f, 0.01724117f, 0.04512880f, 0.01908519f, 0.05241654f, 0.04161543f, -0.00476548f, 
    -0.02550205f, -0.01211353f, -0.00481252f, -0.00500228f, 0.00323577f, -0.05427055f, -0.01316620f, -0.05920633f, 
    -0.06441803f, -0.04506613f, 0.02042340f, -0.02758977f, -0.03281496f, 0.00267530f, -0.01816231f, 0.00186611f, 
    -0.02063197f, 0.04208677f, 0.00250563f, 0.02454896f, -0.03508240f, 0.00361762f, -0.03177940f, -0.03428674f, 
    -0.00804961f, 0.01514476f, -0.06445146f, 0.04303980f, -0.00891268f, -0.01436334f, 0.00027949f, 0.03034001f, 
    0.00099917f, 0.04985246f, -0.03196493f, -0.03984560f, 0.04859951f, -0.01376753f, 0.03625443f, 0.04209445f, 
    -0.03812438f, 0.03561441f, -0.02291910f, 0.00802133f, 0.00632070f, -0.00721175f, -0.04086529f, 0.05153445f, 
    0.04176878f, 0.03325617f, -0.01902188f, 0.00655323f, 0.01728451f, -0.03979637f, -0.00732241f, -0.01634194f, 
    0.03129403f, -0.03422915f, -0.06096125f, 0.00321844f, 0.04090700f, 0.01018363f, -0.01768698f, 0.00267162f, 
    -0.06170620f, -0.05600566f, -0.04286308f, -0.04916187f, -0.01362562f, -0.01036384f, -0.04838987f, -0.02155206f, 
    0.02942320f, -0.02253147f, 0.04805463f, 0.03302560f, 0.01586132f, -0.02022009f, -0.02810267f, 0.03352646f, 
    0.03448390f, 0.04489224f, -0.01634884f, -0.01743687f, 0.02123794f, -0.03910856f, -0.02536446f, -0.01026818f, 
    -0.03380767f, -0.02973347f, 0.03188028f, 0.03206306f, -0.04208378f, -0.03077186f, -0.00931880f, -0.01751319f, 
    -0.04440419f, -0.01245109f, 0.00781146f, -0.03330503f, -0.03487186f, 0.03555521f, 0.05091825f, -0.00361928f, 
    0.02533276f, -0.04123643f, -0.00757386f, -0.02492803f, -0.04427044f, 0.00803986f, -0.02207056f, -0.02043443f, 
    -0.00097588f, -0.05422746f, 0.04218266f, -0.06472363f, -0.04451106f, 0.03305551f, -0.06540907f, 0.01726103f, 
    0.01003855f, 0.04721467f, 0.03743676f, -0.02466296f, 0.04153315f, 0.00423026f, 0.00224541f, 0.00094125f, 
    -0.02652864f, 0.01723786f, 0.04399676f, 0.01843162f, 0.01682072f, -0.00756251f, 0.02685394f, -0.04199249f, 
    0.02051909f, 0.00056808f, 0.01407584f, 0.02198813f, -0.05015067f, -0.05103708f, -0.00899394f, -0.00318048f, 
    -0.00144727f, -0.00813483f, 0.05002652f, 0.00517367f, 0.02479425f, -0.04904968f, 0.02223117f, 0.01300698f, 
    -0.02939891f, -0.04274336f, -0.01138898f, -0.06104021f, -0.00999799f, 0.01678031f, -0.01687774f, 0.04162039f, 
    -0.03856886f, -0.04058731f, -0.02675170f, -0.02842752f, -0.01600033f, 0.00772505f, 0.04785408f, 0.00057363f, 
    0.00950279f, 0.02588208f, 0.03775809f, -0.04170761f, 0.05142347f, -0.04339837f, 0.00691533f, -0.01169214f, 
    -0.05394403f, -0.00102890f, 0.01473383f, -0.05914885f, 0.00708539f, -0.01028117f, -0.02596146f, 0.01643629f, 
    -0.02530755f, -0.01328663f, 0.02592838f, -0.00320568f, 0.00648811f, -0.05045128f, -0.04868986f, 0.03130090f, 
    -0.04116720f, -0.00475345f, -0.00195952f, 0.04320056f, 0.01979699f, 0.00616434f, -0.05247084f, -0.05146874f, 
    -0.01223691f, -0.05554698f, -0.05665933f, -0.05589174f, -0.01586995f, 0.03415815f, -0.03015017f, 0.03655063f, 
    0.01977826f, -0.00857256f, 0.00463566f, 0.03803533f, -0.03592629f, -0.03919438f, 0.03600273f, -0.03302402f, 
    0.00423151f, 0.03869097f, 0.03405558f, 0.01254130f, -0.02450255f, -0.01407427f, 0.03454397f, 0.04074562f, 
    -0.02087301f, 0.02249125f, -0.00642793f, -0.02017595f, 0.04242260f, 0.02420703f, -0.01386970f, -0.00170400f, 
    0.01427801f, 0.03355872f, -0.00192559f, -0.03073499f, -0.05870787f, -0.04051932f, -0.05952387f, 0.03650035f, 
    -0.01501344f, 0.02054227f, 0.03237113f, -0.01042897f, -0.05719277f, 0.00805091f, -0.01285765f, 0.00053751f, 
    -0.01785417f, 0.03944608f, -0.02566279f, 0.02089221f, -0.04694105f, -0.02034515f, 0.02633713f, -0.04840919f, 
    -0.05394768f, 0.00162532f, -0.05430234f, 0.01454666f, -0.03009860f, 0.02176470f, 0.01243993f, 0.02416864f, 
    -0.06576894f, 0.04474293f, 0.01578386f, -0.05690569f, -0.03872023f, -0.06055891f, 0.04660385f, 0.04631644f, 
    -0.04970228f, -0.01316284f, -0.04466811f, -0.02272438f, -0.00280932f, 0.01516466f, 0.02399414f, 0.03770718f, 
    0.00226862f, -0.02130887f, 0.04142857f, -0.01422586f, 0.00564617f, -0.02239608f, -0.05190552f, -0.02208316f, 
    -0.03481195f, 0.01097499f, -0.00906372f, -0.04139226f, -0.01252900f, -0.01175201f, -0.03929447f, 0.00740527f, 
    -0.01710959f, -0.04566206f, -0.01770366f, -0.00957511f, 0.02135514f, -0.04874538f, -0.05382774f, -0.01348397f, 
    0.01616848f, 0.01814258f, -0.00515079f, -0.05264618f, -0.05787453f, 0.00321930f, 0.00756086f, 0.03856121f, 
    -0.06147605f, 0.03909907f, -0.06188530f, 0.03354027f, -0.00253945f, 0.00851927f, 0.00430969f, 0.05136770f, 
    0.04143379f, -0.03198278f, -0.06366106f, -0.06150925f, 0.04208328f, -0.05377033f, -0.04595722f, 0.00208968f, 
    0.00069362f, -0.04356901f, 0.00950297f, -0.02938046f, 0.03607969f, -0.03717341f, -0.02730414f, -0.01778097f, 
    -0.04347136f, 0.03551850f, -0.03829270f, -0.00414034f, 0.05399212f, 0.02446735f, -0.02687959f, -0.02293311f, 
    -0.06028600f, -0.01993848f, -0.04611458f, 0.01217627f, -0.04258442f, -0.00369836f, -0.04239780f, 0.02220433f, 
    0.04962337f, 0.02944994f, 0.04502197f, -0.01688409f, -0.05759400f, -0.04223001f, -0.00913861f, -0.06237204f, 
    -0.06229943f, -0.04462478f, -0.06177105f, -0.05244776f, -0.06298224f, -0.03287435f, -0.01616160f, 0.04061566f, 
    -0.02882841f, 0.00182836f, -0.02636614f, -0.06466545f, -0.01377312f, 0.03833063f, -0.00449880f, -0.04497351f, 
    -0.03892828f, 0.03320776f, 0.01273940f, -0.00293932f, -0.01001049f, -0.03155254f, 0.05119848f, -0.05061647f, 
    0.03631493f, -0.00442020f, -0.05166801f, 0.00578727f, -0.01890197f, -0.02071938f, -0.02831562f, 0.02235065f, 
    0.03308537f, -0.01814010f, 0.05084109f, -0.02697432f, -0.05206669f, -0.05661837f, -0.01549450f, -0.01479399f, 
    -0.03054988f, 0.01796622f, -0.01396789f, -0.04717881f, -0.06252639f, 0.00585472f, -0.05634810f, -0.02215509f, 
    -0.05557054f, -0.00948214f, -0.06516706f, -0.02624504f, -0.05089655f, -0.06564806f, 0.01933954f, 0.01218518f, 
    0.00747310f, 0.03849570f, -0.06466769f, 0.00536455f, -0.00277308f, -0.00880387f, -0.03744227f, 0.03404221f, 
    -0.05791710f, -0.01219664f, 0.04380204f, 0.03176562f, 0.00106667f, -0.06205840f, 0.04744476f, -0.04541264f, 
    -0.05899416f, -0.02266995f, 0.03457727f, -0.00990574f, 0.01272929f, -0.03104588f, 0.01765063f, -0.03894595f, 
    -0.02987219f, -0.01576925f, -0.00100844f, -0.02988989f, 0.01921278f, -0.00427259f, -0.01180188f, -0.01073339f, 
    -0.02278479f, -0.03700435f, -0.01484328f, -0.04296079f, -0.05876794f, 0.01028249f, 0.03635015f, -0.01646806f, 
    -0.04334275f, 0.04298877f, -0.00263653f, 0.00536454f, -0.01552684f, 0.03297041f, -0.04941868f, -0.05636080f, 
    0.01688635f, -0.04246939f, -0.00759200f, 0.04007476f, 0.02567602f, 0.02418841f, 0.03219382f, -0.05212241f, 
    -0.04702842f, -0.06012316f, -0.03584394f, -0.02225457f, -0.04226508f, 0.01292693f, -0.04098198f, -0.02215666f, 
    -0.04235968f, -0.01758301f, 0.01018649f, 0.00490394f, 0.02381068f, 0.01920283f, 0.02030920f, 0.05049795f, 
    -0.05979165f, -0.31825382f, -0.49817440f, 0.00954937f, 0.03702261f, 0.00507272f, -0.01864148f, -0.05704496f, 
    -0.07928017f, -0.23515972f, -0.32274666f, -0.21377081f, -0.06149033f, 0.09395909f, 0.21141973f, -0.12719668f, 
    -0.01807666f, 0.00767773f, 0.07817055f, 0.14797176f, 0.09654398f, 0.08754481f, 0.05143069f, 0.20188318f, 
    0.11199074f, -0.00549375f, 0.05833673f, 0.07285291f, -0.11983323f, -0.03660692f, 0.14285539f, -0.10626425f, 
    -0.01099603f, 0.11561636f, -0.01155448f, 0.14201257f, 0.21366264f, 0.09525849f, 0.00951148f, 0.12026507f, 
    0.18507122f, 0.11991704f, -0.12473522f, -0.08377792f, 0.38810560f, 0.10355698f, -0.26231429f, 0.15716466f, 
    -0.03443603f, -0.01204570f, 0.25626260f, -0.04172647f, -0.03092093f, 0.03747087f, 0.19307370f, 0.25139835f, 
    0.24196498f, 0.05693262f, 0.05678324f, 0.17331116f, 0.02765718f, -0.07625309f, 0.07448816f, -0.32987416f, 
    -0.00236736f, 0.06850278f, 0.03346047f, 0.13823348f, -0.16618548f, -0.00305280f, 0.17888890f, -0.41235244f, 
    -0.26211289f, 0.02879348f, 0.05967876f, -0.00863097f, 0.13499591f, 0.12726998f, 0.00478349f, -0.02836395f, 
    -0.02197096f, 0.13333417f, -0.13339126f, -0.66266763f, 0.05099371f, 0.05752568f, -0.09907994f, -0.06703524f, 
    -0.07813661f, -0.05691618f, 0.06448314f, -0.04367971f, 0.02361959f, 0.09310948f, 0.07598898f, 0.06088293f, 
    0.02974270f, 0.31505415f, 0.08248270f, -0.36690611f, -0.23538645f, -0.11962491f, 0.16922510f, 0.17833449f, 
    -0.08920874f, -0.00226166f, -0.13798240f, -0.01188482f, -0.38557804f, -0.66597199f, -0.06748620f, 0.10525873f, 
    0.16957887f, -0.05605013f, -0.09531035f, -0.03067710f, 0.10172883f, -0.61280358f, -0.39411613f, -0.26484096f, 
    0.21778788f, 0.24463247f, 0.02805814f, 0.00084879f, -0.02899097f, -0.24552123f, 0.41268861f, 0.41039440f, 
    0.20738579f, -0.10624032f, 0.23601472f, 0.01895037f, 0.18160157f, -0.21252906f, -0.09349322f, -0.05887951f, 
    0.18057637f, 0.02985038f, -0.03282992f, -0.22283405f, -0.04611126f, 0.27991113f, -0.11029753f, -0.13545527f, 
    0.11446751f, 0.18823604f, -0.08616176f, 0.11028142f, -0.02937142f, -0.10089350f, 0.12519366f, 0.02189287f, 
    0.13859607f, 0.15160853f, 0.25826189f, -0.27217641f, 0.17408407f, 0.09090237f, -0.18401368f, 0.12322280f, 
    0.03249000f, 0.07430467f, -0.05197769f, 0.11077435f, 0.23206791f, 0.08346911f, 0.12001195f, 0.07226196f, 
    0.31637260f, -0.05185070f, -0.03732852f, 0.23667769f, 0.12921341f, -0.09135273f, 0.04383668f, -0.10417844f, 
    0.11490553f, 0.24805650f, 0.02207941f, 0.03504726f, 0.23018530f, 0.04574957f, -0.14739098f, -0.02732402f, 
    0.17492940f, 0.12417068f, -0.21998589f, -0.22137836f, -0.03561877f, 0.27241352f, -0.23244235f, 0.09207726f, 
    -0.08851768f, -0.02099148f, -0.06159960f, -0.02011108f, 0.00577247f, 0.13654436f, -0.02407661f, -0.00859984f, 
    0.05927171f, 0.01735913f, -0.08254754f, 0.05935727f, 0.01995203f, -0.10386614f, 0.02370401f, 0.09748577f, 
    -0.17961016f, 0.23340191f, -0.19222961f, -0.02548949f, 0.04973051f, 0.11218233f, 0.02621941f, 0.13775183f, 
    0.31908736f, 0.16603178f, -0.00300501f, 0.09493142f, -0.09185235f, 0.20348385f, -0.02230059f, 0.06032733f, 
    0.00850198f, 0.26036626f, 0.29911605f, 0.19665788f, -0.05558335f, -0.07099751f, -0.06183125f, 0.16348574f, 
    0.11703161f, 0.00978867f, -0.05207872f, -0.00618521f, -0.42306694f, -0.00496997f, -0.04252480f, 0.04944143f, 
    0.00276167f, 0.12439076f, -0.02832151f, -0.06958701f, 0.20906077f, 0.09594069f, 0.07941536f, -0.14265254f, 
    0.16093019f, 0.10469580f, 0.00483708f, 0.20029016f, 0.09388902f, 0.05100091f, -0.17615260f, 0.06142882f, 
    0.00177652f, 0.04864773f, -0.11288836f, -0.12586656f, -0.04026406f, -0.05240636f, -0.16198605f, -0.25192562f, 
    0.10290611f, 0.10246260f, -0.01693814f, -0.10236575f, -0.24714465f, 0.03349719f, -0.04941430f, 0.09679162f, 
    0.00363220f, -0.18289202f, 0.05270346f, -0.15897115f, -0.40449569f, 0.09340881f, -0.01240495f, 0.12059303f, 
    0.17875506f, -0.02893118f, -0.03459818f, 0.25587752f, 0.11676952f, 0.06507837f, 0.04187663f, 0.02137665f, 
    0.34523922f, 0.01718497f, 0.16721220f, 0.10949767f, 0.11760148f, -0.18075663f, 0.07398722f, -0.04699238f, 
    0.01537807f, -0.05481213f, -0.06221250f, -0.12008181f, -0.15708333f, -0.03232313f, -0.05398204f, 0.22025876f, 
    -0.09342646f, 0.25561896f, 0.22249873f, -0.24128278f, -0.05974302f, -0.12536556f, -0.23155144f, -0.00272149f, 
    0.31367421f, -0.04810815f, -0.02982803f, 0.08005881f, 0.20468107f, 0.10133023f, -0.00587365f, 0.12001791f, 
    0.11012773f, -0.19087639f, 0.10909005f, -0.14071168f, 0.21734235f, -0.13509908f, 0.07570010f, -0.06813172f, 
    0.23006061f, 0.13623551f, 0.00855029f, -0.11656330f, 0.03958907f, -0.00525077f, -0.00162460f, -0.13377394f, 
    -0.04008729f, -0.06766696f, -0.13421008f, -0.11365836f, -0.00876335f, 0.00842899f, -0.03739224f, -0.42098778f, 
    -0.14337276f, -0.07688864f, -0.23078707f, 0.07498214f, -0.08546023f, -0.11912677f, -0.00566840f, 0.25821692f, 
    0.20228995f, 0.03561218f, -0.02828548f, -0.09684705f, -0.07038665f, -0.12330151f, 0.08704375f, 0.02440461f, 
    -0.02979815f, 0.07857829f, 0.24997863f, 0.12367988f, 0.09578271f, -0.04792096f, -0.17120282f, -0.28242639f, 
    -0.30278412f, 0.05627994f, 0.08964963f, 0.13761608f, -0.21415667f, -0.04152529f, 0.18920642f, -0.02693337f, 
    -0.20448460f, 0.14603981f, -0.21355137f, -0.11343607f, 0.14489023f, 0.10480118f, -0.08568782f, -0.10577203f, 
    0.11135729f, -0.12091386f, 0.06859823f, 0.25587067f, 0.07528550f, 0.27971825f, 0.21032982f, 0.17735989f, 
    0.12455250f, 0.06440087f, 0.10260142f, -0.17778835f, 0.43892160f, 0.18333901f, -0.05092797f, 0.12263970f, 
    0.16071069f, 0.01909391f, -0.08059426f, 0.14000762f, 0.20211156f, 0.07325094f, 0.14265132f, 0.10847420f, 
    0.29648674f, 0.00211361f, -0.23045848f, 0.10214792f, 0.10881144f, 0.04696213f, -0.06782800f, -0.22537850f, 
    -0.07726108f, -0.21339992f, -0.18944126f, 0.09868092f, -0.13160354f, 0.03404748f, 0.04573160f, -0.14939147f, 
    0.08863770f, 0.09911688f, -0.13640265f, 0.14623384f, -0.10608503f, 0.01800225f, 0.07390187f, -0.02009962f, 
    -0.14466920f, -0.28532347f, 0.09681270f, 0.14430039f, -0.17066503f, -0.19906168f, 0.02182925f, 0.01962224f, 
    -0.12559998f, -0.03003150f, -0.23648855f, 0.16078982f, 0.04716692f, -0.02649736f, 0.00293293f, 0.06748979f, 
    0.16121186f, -0.02907132f, 0.04845461f, 0.16012202f, 0.02963911f, -0.17612763f, -0.14342839f, 0.03518102f, 
    -0.06326919f, 0.21762447f, -0.08291811f, -0.15263608f, -0.38671941f, 0.04236821f, -0.29702836f, -0.11061946f, 
    -0.05637871f, -0.10387719f, 0.09202512f, 0.00273536f, -0.14683564f, 0.48266479f, 0.32282427f, 0.21358722f, 
    -0.03608016f, 0.16792193f, -0.13308337f, -0.27167574f, -0.34690148f, -0.08332296f, -0.27032602f, 0.07250375f, 
    -0.00911237f, -0.14139067f, 0.03238758f, 0.03108066f, -0.03853880f, 0.02221757f, -0.30645117f, 0.14217560f, 
    -0.05482820f, 0.02485588f, -0.15593457f, -0.12507835f, 0.13645245f, -0.07475971f, 0.01248732f, -0.18336904f, 
    0.04817285f, -0.15713657f, -0.42495498f, -0.24997905f, -0.12668134f, 0.08745221f, -0.04266895f, 0.08825296f, 
    0.04233258f, -0.07957364f, -0.12645419f, -0.18830328f, -0.30118978f, -0.03005453f, -0.06405441f, 0.01681604f, 
    -0.10930791f, -0.13361092f, 0.08654538f, 0.00850369f, -0.37614757f, -0.25704104f, 0.07439920f, -0.02921487f, 
    -0.02351202f, -0.14318401f, 0.18518841f, 0.43075639f, 0.32503894f, 0.06990189f, 0.01858200f, 0.04702375f, 
    -0.07767696f, 0.11872969f, 0.11571519f, 0.46477249f, 0.04299843f, 0.08358976f, -0.29937473f, -0.19750874f, 
    0.17536348f, 0.07428950f, -0.16762444f, -0.07849741f, 0.39345285f, 0.23217168f, 0.05608217f, 0.19514774f, 
    0.05910665f, -0.07860783f, 0.07116394f, 0.18110943f, 0.07730982f, 0.41409925f, 0.14182068f, -0.03090794f, 
    0.19900668f, 0.05778751f, -0.09263895f, -0.03657436f, -0.06138878f, 0.11531731f, 0.15390421f, 0.17493768f, 
    0.07084467f, -0.04214518f, -0.21899645f, 0.06612317f, -0.18582340f, 0.03670992f, -0.08486474f, 0.13122445f, 
    -0.07923092f, 0.14638622f, -0.00378101f, 0.23724391f, -0.02472956f, -0.17543945f, -0.13935062f, -0.25484356f, 
    -0.04419035f, -0.02463601f, 0.03553950f, 0.04219499f, -0.02743442f, -0.04565785f, 0.02792184f, -0.06637560f, 
    -0.00222999f, -0.06433889f, -0.00630915f, 0.01015648f, 0.04531876f, -0.04571626f, -0.00448661f, 0.00654446f, 
    -0.03590461f, -0.02037703f, -0.01745139f, -0.02987139f, 0.03712348f, 0.00520540f, 0.02049398f, -0.02077267f, 
    0.03075023f, 0.04276530f, 0.01476463f, -0.06001363f, 0.04455812f, -0.05729745f, -0.04557310f, -0.01537577f, 
    0.04599806f, -0.02356364f, -0.02892450f, 0.01942696f, -0.00579128f, 0.00065886f, 0.04926224f, 0.03714388f, 
    0.04883497f, 0.04470209f, -0.02442462f, 0.01135260f, 0.05003339f, -0.01734893f, 0.02909524f, -0.03429106f, 
    0.03599871f, 0.03417972f, -0.01562310f, -0.00330310f, -0.05044927f, -0.06036648f, -0.04967813f, -0.04667239f, 
    -0.03603636f, -0.06303450f, -0.04537070f, -0.00618421f, -0.01620420f, -0.03923830f, -0.02991115f, 0.04885268f, 
    -0.06398355f, -0.01615481f, -0.03059300f, -0.05586684f, 0.04389654f, -0.01142415f, -0.00517332f, 0.04172422f, 
    0.02459593f, 0.04498422f, -0.00934359f, 0.05030020f, -0.02668167f, 0.01480622f, -0.03344510f, 0.01912805f, 
    -0.04808068f, 0.00609196f, 0.00454333f, -0.00737308f, -0.06587061f, -0.05637397f, -0.04519123f, -0.05635904f, 
    0.04894022f, -0.05319987f, 0.00908664f, 0.05032441f, -0.06763645f, 0.01942116f, -0.02015932f, 0.01289133f, 
    -0.01259137f, 0.02725281f, -0.04878999f, -0.01100850f, 0.01789066f, 0.01926686f, -0.04973878f, 0.02817981f, 
    -0.02095596f, -0.04431294f, -0.05437919f, -0.02508164f, 0.00743609f, 0.02136378f, -0.00060501f, -0.02222333f, 
    0.04093557f, -0.04779927f, 0.00295627f, 0.02672010f, -0.04622449f, -0.02042311f, 0.03932530f, -0.05738434f, 
    -0.04703116f, 0.04435394f, -0.05803343f, 0.00444083f, -0.02197663f, 0.05270192f, -0.01921376f, 0.02944293f, 
    -0.05331369f, -0.00685769f, -0.05155843f, 0.02461383f, 0.05399461f, -0.00865157f, -0.01997725f, -0.04019944f, 
    -0.01281214f, -0.02256339f, 0.01069174f, -0.01429350f, 0.02218570f, -0.00306028f, -0.05906675f, -0.03465633f, 
    0.04197368f, -0.05390389f, 0.00403351f, 0.03999162f, 0.01588761f, -0.04231380f, 0.04230465f, -0.05596277f, 
    -0.03513194f, -0.02222335f, -0.05975857f, 0.03675989f, -0.04052820f, -0.04220595f, 0.00223359f, -0.05652185f, 
    -0.05784982f, -0.06211115f, 0.01941867f, 0.01531582f, -0.04767894f, -0.03679066f, -0.00365922f, -0.06211425f, 
    -0.04428985f, 0.01515738f, 0.01826552f, 0.03262050f, -0.06043924f, 0.02011255f, -0.04737942f, -0.02666230f, 
    -0.00971230f, -0.00913138f, -0.01148398f, 0.01781559f, -0.05015384f, -0.03812907f, 0.02487155f, 0.02819862f, 
    0.03636789f, 0.03005922f, -0.04336746f, 0.00401967f, -0.00666916f, 0.02418921f, -0.06719303f, 0.00165830f, 
    0.04572527f, -0.02515666f, -0.02044375f, -0.03690487f, -0.01039862f, 0.03184969f, -0.00493079f, -0.01069740f, 
    -0.01981613f, -0.03549271f, -0.01651560f, 0.02736016f, -0.04463761f, -0.04984285f, 0.03342635f, -0.06715330f, 
    -0.02417571f, -0.05884286f, -0.00610075f, 0.03764924f, -0.01164434f, -0.04198900f, 0.04563080f, 0.00357931f, 
    -0.01813758f, -0.04032753f, -0.02285906f, 0.01570461f, -0.02237820f, 0.01574530f, -0.05592470f, 0.02113334f, 
    -0.01556511f, -0.02476174f, -0.02445330f, 0.02355336f, -0.04846752f, -0.03731825f, 0.00001230f, 0.00500514f, 
    0.04910913f, 0.03835208f, -0.04632923f, -0.03474643f, 0.01654345f, -0.02810130f, -0.02837321f, 0.02778020f, 
    -0.05660347f, 0.03907666f, 0.01099004f, 0.02734025f, 0.04167121f, -0.01164984f, 0.02032588f, -0.03870220f, 
    0.02143439f, -0.05794544f, -0.00870381f, 0.03092212f, -0.00887467f, 0.01221211f, -0.02902302f, -0.02758303f, 
    0.04789196f, 0.02312168f, -0.03149270f, 0.00465704f, -0.01955614f, -0.04231034f, -0.04803675f, 0.01334073f, 
    0.01384351f, -0.01134023f, -0.02307434f, -0.06651498f, -0.00254285f, 0.04157133f, 0.04471850f, 0.01160622f, 
    -0.01161817f, -0.03868765f, 0.02833848f, -0.01447740f, -0.06563696f, 0.02565647f, 0.03140391f, -0.04923334f, 
    0.04014619f, 0.01027453f, -0.03942962f, -0.01157736f, -0.02243512f, 0.01308038f, 0.00998225f, 0.03229052f, 
    -0.06113831f, 0.03829520f, -0.06404842f, -0.03387506f, -0.02621775f, 0.00359602f, 0.02236635f, -0.05973881f, 
    -0.03277200f, -0.00244453f, 0.05272840f, -0.00763802f, 0.00352938f, -0.01641657f, 0.04704136f, -0.01624105f, 
    -0.06013971f, 0.00987652f, -0.01461203f, -0.02172521f, -0.05799424f, 0.03566982f, -0.05520704f, 0.00013011f, 
    -0.04489842f, -0.04642768f, -0.05921724f, -0.05203318f, -0.02511456f, 0.01990083f, 0.03782074f, -0.02138788f, 
    0.04754349f, -0.01367656f, -0.03377086f, -0.01737884f, -0.00875814f, -0.05817007f, 0.01779467f, -0.02863278f, 
    -0.00632343f, -0.01105580f, -0.01945869f, -0.06200768f, 0.01190050f, -0.00556988f, 0.03679356f, 0.00286695f, 
    -0.00591358f, -0.03644118f, -0.04930162f, 0.03001285f, -0.04206100f, -0.00088791f, 0.05331153f, 0.02923083f, 
    0.00575795f, -0.01064957f, -0.00527151f, -0.02964211f, -0.00426243f, 0.02331575f, 0.03474587f, 0.02285044f, 
    -0.03608197f, -0.03004649f, -0.04447145f, 0.02814974f, 0.00321854f, -0.03745690f, -0.03787746f, -0.06352229f, 
    -0.01407112f, 0.01324027f, -0.01733409f, 0.04328860f, -0.03360134f, -0.06359541f, 0.02003804f, 0.05062301f, 
    -0.02962579f, -0.02299557f, 0.01680412f, 0.00540048f, -0.03800463f, -0.00086643f, -0.06277367f, -0.01887130f, 
    0.04356382f, 0.02658751f, -0.04277896f, -0.01062786f, 0.02596261f, -0.01075252f, 0.05252019f, -0.03102602f, 
    -0.04927401f, -0.04590493f, 0.03818016f, -0.05483393f, -0.02278860f, 0.03752806f, -0.03295424f, 0.01051758f, 
    0.03290863f, 0.01787357f, 0.04267422f, 0.02804602f, -0.03808619f, -0.00518010f, -0.05979862f, -0.01430834f, 
    -0.03046850f, -0.03674227f, -0.00038424f, -0.00917360f, -0.01920848f, -0.04179477f, 0.00450188f, 0.01954540f, 
    0.04653393f, -0.04619611f, -0.05604140f, -0.03338365f, 0.05127602f, -0.02142449f, 0.03801808f, -0.05584845f, 
    -0.02030850f, -0.04331689f, -0.04918287f, 0.02176985f, -0.00676350f, 0.04639261f, 0.04096062f, -0.04747153f, 
    0.05191634f, 0.04792630f, -0.04871266f, -0.01170373f, -0.01162306f, 0.04149862f, 0.03793053f, 0.01682966f, 
    -0.03229186f, 0.03086142f, 0.00590268f, 0.02569161f, 0.04353062f, -0.05828500f, -0.04113090f, -0.03283229f, 
    -0.03159577f, 0.01057281f, 0.00719855f, -0.03669657f, 0.05245758f, -0.03948242f, 0.02884049f, 0.01194803f, 
    0.03038228f, -0.02882521f, 0.04368122f, 0.02879490f, -0.04698690f, -0.00339647f, 0.03019726f, 0.03948703f, 
    0.04495480f, -0.04347316f, 0.04000387f, 0.00784795f, -0.04069513f, 0.01511431f, 0.03155478f, 0.04451210f, 
    -0.00334819f, 0.01344136f, -0.03531813f, -0.01513753f, -0.00640506f, 0.04596579f, -0.01497804f, 0.02770147f, 
    -0.04725916f, 0.03169553f, -0.04172355f, -0.02051627f, -0.04542061f, -0.03244075f, -0.04431019f, -0.02207574f, 
    -0.01746534f, 0.02362347f, -0.05620087f, -0.00087432f, -0.03135617f, -0.01592931f, -0.04358840f, -0.00460991f, 
    0.02351062f, 0.03490898f, -0.03882466f, 0.00929730f, -0.02597354f, -0.06211770f, 0.05105405f, -0.02242934f, 
    0.02652069f, -0.04068595f, -0.01527144f, -0.00074826f, 0.02718625f, -0.03302449f, -0.04981732f, -0.01605632f, 
    -0.05257270f, 0.00550778f, -0.03993398f, -0.01819165f, -0.05911243f, -0.01494953f, 0.05851194f, -0.03009916f, 
    -0.01761899f, -0.05892655f, -0.04839228f, -0.03857228f, 0.00885733f, 0.01768871f, 0.00562211f, -0.02838995f, 
    0.00999483f, -0.00150193f, 0.00353025f, -0.00553449f, 0.03700970f, 0.00049625f, -0.02830813f, 0.03741031f, 
    -0.01004893f, -0.02304938f, -0.00827619f, -0.01821841f, -0.00902931f, 0.00697075f, 0.01642621f, 0.05360151f, 
    -0.05643840f, -0.04415084f, 0.00322392f, 0.02754854f, -0.02372999f, 0.03436144f, -0.02693843f, 0.03209661f, 
    -0.03460273f, -0.00458140f, -0.04693381f, -0.04024479f, -0.03533978f, -0.03372052f, -0.01536713f, -0.01956307f, 
    -0.01387294f, -0.05503643f, -0.04138338f, -0.04748556f, -0.03877239f, 0.00630326f, 0.05193501f, 0.00195158f, 
    -0.06037407f, -0.05942227f, 0.03309134f, -0.00835026f, -0.02011266f, -0.03369144f, 0.05692268f, -0.01098014f, 
    -0.03098475f, -0.03723208f, 0.03909132f, 0.03274405f, -0.03294287f, 0.00228147f, -0.06164219f, -0.05988465f, 
    -0.66106051f, 0.11363609f, -0.02539747f, -0.10081746f, 0.02287130f, 0.04822769f, 0.11074503f, -0.08811201f, 
    0.21972309f, -0.22889885f, 0.09816270f, -0.01695867f, -0.06171219f, -0.20200266f, -0.06631343f, -0.10615329f, 
    0.10834527f, -0.13022013f, 0.21609123f, -0.13694318f, 0.06173366f, 0.18151782f, 0.07773710f, 0.05690927f, 
    0.13010766f, -0.16687317f, 0.17993961f, 0.37811443f, -0.03648593f, -0.19586480f, 0.14561351f, 0.04878540f, 
    0.16159841f, -0.08516633f, -0.14044461f, 0.15707023f, -0.02449623f, -0.01267371f, -0.11739819f, -0.03112123f, 
    -0.15037297f, -0.10920031f, 0.01755087f, -0.12166589f, 0.06937237f, 0.38561723f, 0.05230345f, -0.09915033f, 
    -0.05282373f, 0.07457846f, 0.07702149f, -0.20248647f, -0.10979703f, 0.21245791f, -0.01767274f, -0.21621606f, 
    0.08318884f, 0.04763509f, -0.01093986f, 0.05711875f, 0.01184670f, -0.03161735f, 0.20901830f, 0.21252741f, 
    0.05441721f, -0.04165595f, -0.03269809f, -0.00293040f, 0.02825290f, -0.00214241f, -0.08014958f, 0.25857788f, 
    -0.13715041f, 0.04614408f, -0.10118526f, 0.06462321f, 0.13333912f, -0.01448363f, 0.04366350f, 0.00758346f, 
    0.01882526f, 0.40776247f, 0.23991558f, -0.35562599f, 0.13435633f, 0.10263500f, -0.08782565f, -0.07832629f, 
    -0.05581300f, 0.14485489f, 0.19047496f, -0.05853641f, 0.15787965f, 0.18934314f, 0.00755607f, -0.15906081f, 
    0.10571580f, -0.07053654f, 0.07996724f, -0.12382463f, 0.41969410f, -0.19679222f, 0.05058024f, 0.14830807f, 
    0.11302911f, -0.18348634f, 0.06573157f, 0.21829255f, -0.20691426f, 0.03573700f, 0.20845246f, -0.30582845f, 
    0.10795085f, -0.02404243f, -0.25763649f, -0.14554727f, -0.09882851f, -0.30070326f, 0.12472996f, 0.22174813f, 
    -0.10515070f, 0.06755091f, -0.25222412f, -0.14880696f, -0.15332240f, 0.10422323f, -0.05966540f, -0.40478623f, 
    0.03299415f, 0.00699581f, -0.11640801f, 0.09894548f, 0.00381762f, -0.03950414f, 0.12834504f, 0.06416783f, 
    -0.14827006f, -0.44931772f, 0.06413745f, -0.16430411f, 0.00722055f, 0.37539408f, -0.03685319f, 0.23320481f, 
    -0.10634612f, -0.07656462f, -0.24976869f, 0.03672935f, -0.06283840f, -0.08319433f, -0.13281676f, 0.10815790f, 
    0.08939045f, -0.03721967f, 0.27527615f, -0.39437971f, 0.02224229f, 0.10457023f, 0.11540730f, -0.02794420f, 
    0.07945388f, 0.09274670f, 0.00621123f, -0.14258848f, 0.04666564f, 0.14720432f, -0.08383566f, -0.00914798f, 
    -0.11098373f, 0.12600815f, -0.23151340f, 0.26622519f, -0.04774644f, -0.22608788f, 0.25829643f, 0.07784779f, 
    -0.08087189f, 0.09054010f, 0.08000813f, 0.09834193f, -0.24548092f, -0.28586400f, 0.24157721f, -0.21926647f, 
    0.11302651f, 0.00438754f, -0.21211196f, 0.14613597f, -0.10146683f, -0.57774782f, 0.12946188f, 0.01042733f, 
    -0.10865750f, 0.06169757f, -0.01325834f, 0.14477630f, -0.17589720f, 0.13728520f, 0.22115634f, -0.04438699f, 
    0.05766521f, -0.00853971f, -0.03335570f, -0.01634286f, -0.07501935f, 0.06034966f, 0.14805450f, 0.25693104f, 
    -0.38562930f, -0.06084800f, -0.00961646f, -0.05554708f, 0.03500220f, -0.24050336f, -0.12957644f, 0.31920639f, 
    0.72582245f, -0.32873738f, -0.02757856f, 0.11662590f, 0.08011907f, -0.24932007f, 0.12561521f, 0.12044767f, 
    0.03918384f, 0.37486294f, -0.36483914f, 0.10088880f, 0.14950891f, 0.16530286f, -0.07803909f, -0.01636603f, 
    0.07875064f, 0.19050227f, -0.58257788f, 0.23640911f, 0.00381671f, -0.13142417f, 0.01288848f, 0.11426578f, 
    0.09358460f, -0.14662699f, 0.07640309f, -0.40166089f, 0.07673876f, -0.20812267f, 0.23244235f, 0.01891083f, 
    -0.14458241f, 0.08147675f, 0.10813687f, 0.15434729f, 0.11774217f, 0.17247838f, 0.21421254f, 0.06299449f, 
    0.01221381f, 0.13597223f, -0.12403948f, -0.11184409f, 0.00159399f, 0.02690491f, 0.31315267f, 0.09708054f, 
    0.11081772f, 0.17658196f, -0.22302069f, -0.04023465f, 0.01738573f, -0.02847838f, -0.01547580f, 0.15940101f, 
    -0.30517918f, 0.21226521f, 0.03812503f, 0.06011367f, 0.10216364f, 0.01777721f, 0.03016750f, -0.20498851f, 
    0.00140858f, -0.09801111f, -0.10635921f, 0.01807773f, -0.07953376f, 0.09549001f, -0.10292542f, 0.04465280f, 
    -0.13893931f, -0.03527815f, -0.27805254f, -0.04332965f, 0.11428500f, 0.00707085f, -0.04222783f, 0.08417336f, 
    -0.09662357f, 0.08056711f, -0.08205702f, -0.25128368f, 0.24757925f, 0.17397283f, -0.27198204f, 0.11716822f, 
    0.16165620f, 0.07688985f, -0.27237129f, -0.65346396f, 0.21733733f, 0.14415443f, 0.09375998f, 0.20727871f, 
    -0.09463426f, -0.16389884f, 0.21723330f, 0.30098486f, 0.04027583f, -0.26416278f, 0.04234165f, -0.11272018f, 
    -0.04654879f, 0.01350658f, -0.00309205f, 0.33086365f, 0.31844559f, -0.21739796f, 0.17290819f, -0.01077299f, 
    0.13363010f, -0.12381777f, 0.06327209f, -0.13857238f, 0.23209335f, 0.26746544f, 0.17014836f, -0.48541248f, 
    0.10515835f, 0.08587039f, 0.01383539f, -0.17260028f, -0.26915479f, -0.15237193f, -0.13312803f, -0.27991003f, 
    0.05215287f, 0.04705475f, 0.03386124f, 0.13152863f, -0.28490672f, -0.11427776f, 0.02238536f, 0.18272731f, 
    -0.07445284f, 0.10650811f, 0.04393506f, -0.09288902f, -0.05498875f, 0.22928725f, 0.23104094f, 0.02437313f, 
    -0.21777253f, 0.00470511f, 0.00009245f, 0.15134950f, 0.09162673f, 0.13702221f, -0.03493578f, 0.03672212f, 
    -0.35885936f, 0.52276129f, 0.17487139f, -0.30887124f, -0.07694216f, 0.08168796f, 0.04155061f, -0.10111646f, 
    0.06188204f, 0.00849348f, -0.05268518f, -0.06540631f, -0.03825849f, -0.01488948f, -0.23541667f, -0.28197488f, 
    0.00355609f, 0.00431270f, 0.17470790f, -0.02971395f, 0.29783410f, -0.07662405f, -0.03659641f, -0.08506522f, 
    0.06758904f, -0.22149089f, 0.21510868f, 0.20229657f, 0.36921930f, 0.07251547f, -0.26824316f, -0.20995469f, 
    0.12919776f, -0.28866506f, 0.16373158f, 0.27870286f, 0.23206523f, 0.15502255f, 0.24649078f, -0.08294849f, 
    0.04264940f, -0.15828517f, -0.17086276f, 0.04287665f, -0.01106904f, 0.09611816f, -0.46011388f, -0.49600098f, 
    -0.02884362f, 0.09281737f, 0.11748789f, 0.16821466f, -0.19258735f, -0.03119534f, 0.11095634f, -0.18761325f, 
    -0.06259687f, -0.07149229f, -0.11531962f, -0.06455330f, -0.05539683f, 0.12134872f, 0.01366077f, 0.17689882f, 
    0.24642129f, 0.08218086f, 0.27790207f, 0.16546354f, 0.01130357f, 0.17767817f, -0.23178400f, -0.25420180f, 
    0.02628689f, -0.12721549f, 0.19932371f, -0.02181726f, -0.19776525f, -0.15176815f, 0.01166077f, -0.20276171f, 
    0.04171759f, 0.14309841f, -0.56640524f, -0.01987531f, 0.03418184f, -0.01591340f, -0.09729070f, 0.07730235f, 
    0.18713385f, 0.17542832f, 0.23990910f, 0.25722688f, 0.02177694f, 0.05038850f, 0.00666257f, -0.01840901f, 
    0.20870890f, -0.15510988f, -0.06697567f, -0.12715410f, 0.02217541f, -0.06350150f, -0.03640426f, -0.00887554f, 
    0.05714815f, 0.12765476f, -0.16453482f, -0.10918722f, -0.27587831f, -0.02470052f, 0.06070575f, -0.02021208f, 
    -0.06552753f, 0.01075094f, -0.00423185f, -0.08767985f, -0.00495671f, 0.13750982f, -0.04682196f, -0.48661432f, 
    -0.33925134f, -0.25402722f, -0.10604915f, -0.25211212f, 0.16657318f, 0.18536176f, 0.08294402f, 0.08764529f, 
    -0.53954864f, -0.44534835f, 0.09985517f, -0.15492946f, -0.08117278f, -0.02443028f, 0.07812055f, 0.01809795f, 
    0.22118473f, -0.71855915f, 0.15769736f, 0.13306284f, 0.02847806f, 0.04521072f, -0.10048708f, 0.01076183f, 
    -0.11255967f, -0.20043091f, -0.27664328f, 0.29720208f, 0.04123090f, 0.21658437f, 0.25006333f, -0.07611468f, 
    0.22719122f, -0.09543997f, -0.09223858f, 0.02241619f, -0.08194765f, -0.02662051f, -0.08763815f, -0.07561240f, 
    0.05663005f, 0.02841732f, -0.04667787f, -0.10182158f, 0.16167356f, 0.20779787f, -0.02503378f, 0.01686578f, 
    -0.00281072f, 0.01852759f, 0.04158294f, 0.08733114f, 0.22724782f, 0.08463972f, 0.10350218f, -0.00577245f, 
    -0.16334695f, -0.24480835f, 0.06230691f, 0.02800015f, -0.01060076f, 0.07405105f, 0.05106675f, -0.05963007f, 
    0.08770931f, 0.02101141f, -0.05930994f, 0.16000655f, 0.08410437f, -0.01814215f, 0.30241513f, 0.54721862f, 
    0.26963347f, 0.03090619f, 0.08948129f, 0.15251088f, -0.11412355f, 0.02611791f, -0.28615353f, 0.01943649f, 
    -0.00802022f, -0.01506133f, 0.32127333f, -0.05385882f, 0.07505883f, 0.03979566f, -0.04259810f, -0.30488351f, 
    0.05645483f, 0.07007542f, 0.02738055f, 0.06043189f, 0.12084285f, 0.17277882f, -0.07948072f, 0.01102580f, 
    -0.14001700f, -0.48978952f, -0.24578138f, -0.15385452f, 0.17153287f, 0.10881878f, 0.06034751f, 0.10958523f, 
    -0.08662808f, -0.11228777f, 0.17694631f, -0.27924833f, -0.18137145f, 0.21073873f, 0.08486041f, 0.09779966f, 
    -0.01605398f, 0.10127351f, 0.13908295f, -0.19663838f, 0.20612520f, -0.17268267f, 0.21724252f, -0.19806950f, 
    0.06516529f, 0.01174368f, 0.03404327f, -0.02969893f, -0.51460713f, 0.04222339f, -0.14852524f, 0.02468252f, 
    0.11803084f, -0.00273318f, -0.06805460f, 0.18410027f, 0.04364001f, 0.07222475f, 0.28701669f, 0.04407958f, 
    0.11202615f, -0.11994349f, -0.11052127f, -0.07639771f, 0.00047656f, -0.09941448f, -0.01164455f, -0.18659608f, 
    0.12315912f, 0.07389044f, 0.15993756f, 0.08486818f, 0.21330813f, -0.09970400f, 0.23428053f, 0.03352693f, 
    0.10589452f, -0.04707545f, 0.19449809f, -0.04854617f, -0.16280140f, 0.07870049f, 0.00023099f, -0.12079503f, 
    -0.10738527f, 0.15236515f, 0.05595204f, 0.08071516f, 0.09730855f, -0.02951292f, -0.22773559f, -0.11135249f, 
    -0.08524685f, 0.22806950f, -0.07367265f, -0.10502990f, -0.06233015f, -0.05870841f, 0.13992174f, 0.14224651f, 
    0.07998671f, -0.08983508f, -0.03933680f, -0.03490042f, -0.21086226f, 0.06063078f, -0.08001040f, 0.04088125f, 
    0.21184774f, 0.01653553f, -0.03433448f, 0.12813513f, 0.38130319f, 0.02998262f, 0.01020936f, 0.19603398f, 
    -0.09953377f, -0.03111014f, 0.07473203f, -0.14943032f, -0.21515818f, 0.06844978f, -0.04142246f, 0.16681761f, 
    0.17240375f, 0.10719852f, -0.04734379f, -0.03370185f, -0.00323852f, -0.28556642f, 0.23074928f, 0.09850722f, 
    0.33400932f, 0.00079969f, 0.01412989f, -0.27170441f, 0.00927362f, -0.08196585f, -0.09551594f, 0.01204077f, 
    0.18177408f, -0.08887247f, 0.09370665f, 0.14059982f, 0.08121165f, -0.03099001f, 0.11953758f, -0.55859339f, 
    0.18702619f, -0.14276066f, 0.09708169f, -0.18716663f, 0.17619655f, 0.00922460f, -0.01001903f, 0.04885338f, 
    0.12616764f, 0.01330562f, 0.29323739f, -0.15498434f, 0.05846702f, -0.00755702f, 0.09512952f, -0.32920501f, 
    -0.20058723f, -0.03987531f, 0.29464257f, -0.08806267f, -0.07719972f, 0.12462468f, 0.02519781f, -0.01025656f, 
    -0.11693089f, -0.04408120f, -0.08036596f, 0.06165338f, -0.01623132f, 0.23468398f, 0.22398153f, 0.12769035f, 
    0.02721552f, 0.06382209f, 0.07226478f, -0.00069965f, -0.22252326f, -0.04086082f, -0.03825460f, -0.15067141f, 
    0.07567439f, 0.11041626f, -0.00243806f, 0.09736666f, -0.07666779f, 0.35621709f, -0.09377125f, -0.00373787f, 
    -0.09494093f, -0.01072484f, -0.08317696f, -0.02567657f, -0.16597712f, -0.19048241f, 0.00765961f, 0.08026516f, 
    -0.25407887f, -0.28502944f, -0.07543454f, 0.02268260f, 0.07398738f, -0.10348042f, 0.11679827f, -0.12456726f, 
    0.04476732f, 0.05923343f, -0.03854370f, -0.12494468f, -0.06775036f, -0.10972830f, 0.16581869f, 0.11536844f, 
    -0.14796931f, -0.28982437f, 0.09887366f, -0.08100750f, -0.16788098f, -0.07346335f, 0.03376354f, -0.12997034f, 
    0.40211400f, -0.37023383f, -0.12672964f, 0.13910428f, -0.25256118f, 0.13210550f, 0.02426152f, 0.13757524f, 
    -0.07515057f, 0.09750853f, -0.15956013f, 0.12801775f, 0.13191612f, 0.15406117f, 0.03442680f, 0.01366452f, 
    0.09603693f, -0.13398492f, 0.11893785f, 0.23396921f, 0.11459941f, 0.02917914f, 0.20398672f, -0.07606805f, 
    -0.11215889f, 0.19818182f, 0.06231355f, -0.12230866f, 0.02656819f, -0.32236984f, -0.12109047f, -0.18005741f, 
    0.09837033f, -0.06806494f, 0.21826237f, -0.04775127f, 0.02311172f, 0.47212186f, 0.18010738f, 0.02796165f, 
    -0.12982336f, -0.29015478f, 0.07139620f, 0.11547066f, 0.44028413f, -0.03304093f, 0.13426608f, -0.09903607f, 
    0.19321217f, 0.01391471f, -0.13515607f, 0.12526931f, 0.13347881f, 0.05473322f, -0.17145443f, -0.04296550f, 
    0.00364554f, -0.10083461f, -0.01641706f, 0.02474642f, -0.05518563f, 0.02145876f, 0.03531699f, -0.38717034f, 
    0.12949947f, -0.01188529f, 0.00149332f, -0.03628957f, -0.17774445f, -0.09494328f, -0.03735092f, -0.06160026f, 
    -0.14347349f, -0.08767206f, -0.41597885f, 0.04369876f, 0.07509059f, -0.00489752f, -0.20387557f, -0.16704877f, 
    0.05742051f, -0.08485023f, -0.29047212f, -0.13170022f, -0.03795644f, -0.13875069f, 0.24414277f, -0.04421225f, 
    0.10928718f, -0.03907121f, 0.19981261f, 0.03793032f, -0.17097831f, -0.16955383f, 0.05951785f, -0.07726844f, 
    -0.28673533f, 0.05405840f, 0.05703981f, 0.25624979f, -0.01056930f, 0.39605582f, -0.00980167f, -0.06075961f, 
    -0.35026324f, 0.01353915f, -0.00667024f, 0.03822695f, 0.22991313f, -0.12234256f, -0.04921061f, -0.15360212f, 
    -0.13231614f, 0.19009607f, -0.02175819f, 0.22877096f, 0.09102250f, 0.46815658f, 0.13005012f, -0.09778783f, 
    -0.26301757f, -0.01441309f, 0.13098791f, -0.03291850f, 0.06709145f, 0.21714658f, 0.58366609f, 0.20492244f, 
    -0.18183146f, -0.14055647f, -0.02285918f, -0.03148872f, 0.02211940f, -0.03284376f, 0.16236340f, -0.02569161f, 
    0.13891669f, 0.16175565f, 0.26096651f, -0.09276889f, 0.10850958f, 0.01163093f, 0.04840359f, -0.15111855f, 
    0.08740433f, -0.16348749f, 0.15944560f, 0.04268205f, 0.07068235f, -0.03309877f, 0.02686710f, 0.02514970f, 
    -0.00387186f, 0.38306111f, -0.19138394f, 0.07751695f, 0.02785447f, 0.05155824f, -0.02002380f, 0.12375663f, 
    0.16544808f, -0.06324176f, 0.02472205f, -0.07411315f, -0.35461015f, 0.11914028f, 0.11138599f, -0.06245083f, 
    -0.21125448f, 0.26619881f, -0.03776620f, 0.22565955f, -0.10260656f, 0.02435002f, 0.11519294f, 0.03244056f, 
    0.08371520f, 0.01350898f, -0.28935611f, 0.09526068f, -0.38425279f, 0.04646157f, 0.47395095f, -0.00990600f, 
    -0.07720570f, -0.02594888f, -0.09710949f, 0.04637999f, 0.12101975f, 0.03984117f, 0.09652644f, -0.06286453f, 
    0.13855733f, 0.22596642f, 0.05273377f, -0.24260786f, -0.33175236f, 0.04305817f, 0.47837374f, 0.05783444f, 
    0.00673389f, 0.14761104f, -0.12405527f, 0.03390611f, -0.00551937f, -0.05019060f, -0.24865574f, 0.38827366f, 
    -0.15092090f, 0.07566150f, -0.02749866f, 0.25028196f, -0.17476882f, -0.18093000f, 0.01574671f, -0.27152446f, 
    -0.29950771f, 0.08080346f, 0.16685739f, 0.24186866f, -0.03817252f, -0.12094997f, -0.06877492f, -0.20635071f, 
    0.35914144f, 0.00584582f, 0.13863103f, 0.32211965f, 0.06323814f, -0.07074628f, 0.13238765f, 0.09745836f, 
    -0.21692152f, -0.10243114f, -0.12576854f, -0.05692382f, -0.10515276f, -0.19830169f, 0.05371956f, 0.10489471f, 
    -0.08174500f, -0.01181460f, 0.03106804f, 0.13754138f, 0.21019103f, -0.25292987f, -0.03977475f, 0.06812917f, 
    -0.10945953f, 0.14058430f, -0.06591973f, -0.16906156f, -0.01011034f, -0.13534014f, 0.11245515f, 0.14761087f, 
    0.10586676f, 0.05901165f, 0.04615063f, -0.28261235f, -0.12994614f, -0.00829988f, 0.08979845f, -0.39220315f, 
    -0.01603614f, -0.10594888f, -0.15533046f, 0.09219757f, 0.04290683f, 0.00992052f, -0.15031849f, 0.16593395f, 
    0.18431070f, -0.09676804f, -0.03839590f, -0.01403845f, -0.20018876f, 0.01382675f, -0.13539146f, 0.18854783f, 
    0.15424936f, -0.25991830f, 0.13368067f, -0.11905754f, -0.01986921f, 0.07447406f, -0.05055759f, -0.14334072f, 
    -0.22321475f, 0.07587193f, -0.15306228f, -0.15005907f, 0.12024767f, -0.08618432f, -0.07223132f, -0.14840673f, 
    -0.12493590f, 0.03270043f, 0.06765074f, -0.34908921f, -0.12305381f, -0.07273011f, -0.05749069f, 0.03770260f, 
    -0.04237982f, -0.13256903f, -0.22327510f, -0.30345649f, -0.00905719f, 0.13512070f, -0.00749781f, 0.14997520f, 
    -0.31134078f, 0.12501043f, -0.08515994f, 0.00673948f, -0.05679706f, -0.26505753f, -0.13453229f, 0.06144998f, 
    0.23691601f, 0.08789466f, -0.07779033f, -0.14523810f, -0.14048502f, -0.12834805f, 0.84679443f, -0.05144529f, 
    0.06191171f, 0.12051013f, -0.05947435f, 0.15523997f, 0.34438503f, 0.00190973f, 0.01834868f, 0.31258366f, 
    0.07759007f, 0.03905991f, -0.04642003f, 0.07368984f, 0.07321200f, 0.15495384f, 0.07355492f, 0.04628599f, 
    -0.32953382f, -0.04921594f, -0.06106170f, 0.14279673f, -0.07623951f, -0.00881022f, 0.13579482f, 0.19109018f, 
    -0.11416136f, 0.02478359f, -0.18411386f, -0.07493668f, 0.11338390f, 0.00668317f, 0.05696347f, 0.10339922f, 
    -0.07052052f, -0.04394184f, 0.16820829f, -0.02786005f, 0.08736003f, -0.22197513f, -0.12643255f, -0.04205969f, 
    -0.03172813f, -0.21113639f, 0.36174431f, -0.05282027f, 0.04777319f, 0.19932342f, -0.21940124f, 0.11885908f, 
    0.07272764f, 0.03912851f, 0.04961753f, -0.02414999f, -0.06705051f, 0.10451140f, -0.07492849f, 0.10266328f, 
    -0.01867347f, 0.17372854f, 0.05063598f, 0.17393470f, 0.09929478f, 0.05041832f, -0.24724491f, -0.09457456f, 
    -0.02279572f, 0.03579948f, 0.08782014f, -0.05212820f, -0.24370688f, 0.06474600f, -0.05734466f, 0.12648283f, 
    0.00976690f, -0.08370554f, 0.13495180f, 0.02544004f, 0.01843636f, -0.10842589f, -0.30585459f, -0.18664047f, 
    -0.10771452f, 0.06141825f, 0.00471752f, -0.15390225f, -0.15362103f, -0.16511983f, -0.16311398f, 0.08676571f, 
    0.02087028f, 0.11035677f, -0.14327036f, 0.05546780f, -0.17566854f, 0.18148901f, -0.07417500f, -0.17718938f, 
    -0.12244968f, 0.17399558f, 0.02136331f, 0.08202817f, 0.21408655f, 0.03938264f, 0.08726671f, -0.16912977f, 
    0.44441837f, 0.10830154f, -0.04292224f, 0.04018029f, 0.04865232f, 0.08201188f, 0.02578009f, -0.06318179f, 
    -0.05602740f, -0.39636990f, -0.02919978f, -0.01172984f, 0.14424832f, 0.14504556f, -0.05109929f, -0.07695862f, 
    0.00551976f, -0.09309054f, -0.23364580f, -0.08090220f, -0.51479489f, -0.05462756f, 0.01567704f, 0.01462058f, 
    0.01389650f, 0.13696942f, 0.06998925f, -0.05493371f, 0.24346638f, 0.17846014f, 0.09409240f, -0.24985009f, 
    -0.07287877f, -0.22950247f, -0.02296673f, 0.00942328f, 0.29828969f, 0.34095183f, 0.25391099f, -0.01208006f, 
    -0.08021124f, -0.13648820f, 0.25712708f, 0.13242987f, 0.02960850f, 0.24407952f, 0.41600761f, -0.06322379f, 
    -0.20445752f, 0.06486360f, 0.03569307f, 0.04969215f, 0.06056568f, -0.10684180f, -0.07167776f, 0.17759235f, 
    0.05493160f, 0.11386912f, 0.07694560f, 0.09044878f, -0.11317979f, 0.18549515f, -0.01505014f, 0.66820627f, 
    0.18812306f, -0.10098531f, -0.02846741f, -0.03144712f, 0.17682017f, -0.01811655f, -0.11111360f, -0.02802276f, 
    -0.16521852f, -0.10614485f, -0.53274584f, 0.08205782f, 0.02654077f, 0.09864751f, 0.11261278f, 0.02716766f, 
    -0.06749456f, 0.30279180f, 0.04985112f, 0.17319953f, 0.04536219f, -0.12955813f, -0.15465999f, -0.03910111f, 
    0.33413333f, 0.08426901f, 0.01543425f, 0.18309888f, 0.25353393f, 0.01131848f, -0.03719588f, 0.00575295f, 
    0.12880328f, 0.17207846f, 0.27840173f, -0.23892573f, -0.22756588f, -0.06323726f, -0.04309489f, -0.11023730f, 
    -0.05590072f, -0.05817633f, -0.07496598f, -0.00513015f, -0.14965764f, -0.02179816f, -0.44487867f, 0.02025427f, 
    0.19557790f, 0.05329178f, -0.08705714f, -0.21694301f, 0.02930225f, 0.08586713f, 0.05523391f, -0.62791824f, 
    -0.10969673f, -0.11234947f, 0.03883202f, -0.13864253f, 0.00776820f, -0.06792004f, 0.36846119f, -0.35675931f, 
    0.22643131f, -0.11073043f, -0.02398573f, 0.07603766f, 0.02531439f, 0.08313507f, 0.15193161f, 0.04413782f, 
    -0.12607436f, -0.26912344f, -0.04351100f, 0.06540973f, 0.24348725f, -0.20543684f, 0.07269055f, 0.37143061f, 
    -0.69039375f, -0.18781786f, -0.06017487f, 0.11712516f, -0.16668555f, 0.05823895f, -0.13296367f, -0.26759857f, 
    0.09923367f, -0.31415033f, 0.03455786f, 0.05151341f, 0.08099668f, -0.02248264f, -0.11631780f, 0.02274550f, 
    -0.14618516f, 0.07354230f, 0.31458697f, 0.03400869f, -0.01475346f, -0.03933194f, -0.02156777f, 0.03372378f, 
    0.02676935f, 0.07622521f, 0.02225299f, -0.01721295f, -0.18310775f, -0.34664991f, -0.02412601f, -0.05634551f, 
    -0.07794759f, 0.05814536f, -0.02526454f, 0.20761836f, 0.10823498f, 0.50351912f, 0.03105376f, 0.22683284f, 
    -0.04368887f, -0.02278608f, 0.06813985f, 0.23050053f, 0.20059077f, 0.07939959f, 0.34446844f, -0.28102472f, 
    0.19709395f, -0.12873366f, 0.01356748f, 0.04379265f, -0.03781261f, 0.15342842f, -0.48259777f, -0.00926503f, 
    0.17534140f, 0.21824014f, 0.07890546f, -0.00852905f, -0.09057830f, -0.11871439f, -0.06262195f, 0.35535228f, 
    -0.00945022f, -0.03334890f, -0.06487524f, 0.10078972f, -0.02769790f, 0.02675566f, 0.01235020f, -0.08924912f, 
    0.05224158f, -0.00415989f, -0.06078802f, 0.20833892f, 0.02966469f, -0.03798337f, 0.15282579f, 0.12926026f, 
    -0.04956856f, -0.48727033f, 0.27396134f, -0.00021531f, 0.01762089f, -0.09095066f, -0.09988969f, -0.11098929f, 
    -0.01094763f, -0.22802792f, -0.10560813f, 0.11028617f, -0.00499361f, 0.00024194f, 0.21700263f, 0.21270330f, 
    0.29001430f, 0.13795063f, -0.17478906f, -0.80717766f, -0.96740407f, -0.07378985f, 0.10474475f, 0.13352922f, 
    -0.04132050f, -0.12645598f, -0.01479355f, 0.14934628f, 0.14154740f, 0.24451327f, -0.16356905f, -0.07723986f, 
    0.03893371f, -0.16596796f, 0.25219327f, 0.28633466f, -0.20189881f, -0.10168816f, -0.44238538f, 0.06282199f, 
    0.26168361f, 0.16412534f, -0.03792157f, 0.12752333f, 0.11649765f, -0.13594408f, -0.16005388f, 0.14683710f, 
    0.12625548f, 0.01287829f, 0.12102319f, 0.12515116f, -0.10112647f, 0.03370202f, 0.02102319f, -0.25706881f, 
    0.42983925f, -0.35267931f, -0.12657170f, -0.12173127f, 0.02915705f, 0.01515911f, -0.15645285f, -0.20761840f, 
    -0.26252174f, 0.16032422f, -0.06793761f, 0.14118893f, -0.02409310f, 0.05199061f, 0.31360587f, -0.13727556f, 
    0.10912982f, -0.09570859f, -0.34202999f, -0.39467642f, 0.05054969f, 0.06509954f, 0.05639759f, 0.13041060f, 
    0.00754847f, 0.07701766f, 0.10233135f, -0.10489308f, -0.21115310f, -0.06854274f, 0.08083931f, -0.00444165f, 
    0.08094307f, 0.23077400f, 0.11594870f, -0.64485663f, -0.36358795f, -0.47486222f, 0.11184120f, 0.09755740f, 
    0.12921657f, 0.03645489f, -0.00034019f, 0.21073127f, 0.06420056f, 0.00857155f, -0.09361823f, -0.07262830f, 
    -0.05594975f, -0.20040518f, -0.04392465f, 0.13129567f, -0.14491038f, -0.35094789f, 0.20142181f, -0.13199843f, 
    0.01380197f, -0.11038865f, -0.08421323f, 0.06703667f, -0.20213933f, -0.07986787f, 0.03677413f, 0.20635624f, 
    0.16172907f, -0.19268247f, 0.15827426f, 0.27124065f, -0.22387420f, 0.05867143f, 0.09322271f, -0.45486847f, 
    0.03916058f, -0.22479367f, -0.09940519f, -0.35669971f, -0.00024627f, 0.00901737f, -0.10575297f, 0.01937612f, 
    0.16459669f, 0.05860975f, 0.11097326f, 0.09042144f, 0.00557234f, 0.07806119f, 0.13955784f, 0.06082178f, 
    0.31828424f, -0.55057168f, -0.64106226f, -0.82103252f, 0.05150804f, -0.00794003f, -0.11383075f, 0.08145111f, 
    0.12333602f, 0.00695113f, 0.10756270f, 0.18403034f, 0.45011586f, 0.17985477f, 0.12166655f, -0.01400983f, 
    0.14314197f, -0.16187723f, 0.07937185f, 0.08975431f, 0.08486263f, 0.08508759f, -0.16686828f, -0.07500967f, 
    0.15508106f, -0.10938112f, 0.00806021f, 0.39142781f, -0.22375770f, 0.24100581f, -0.21729887f, 0.02161348f, 
    0.03014532f, 0.21117441f, -0.00319749f, -0.16823900f, 0.17020179f, 0.56030262f, -0.15195180f, -0.33621520f, 
    0.25925481f, 0.07046985f, 0.26107278f, 0.11648171f, 0.08089863f, 0.04899443f, -0.13600005f, -0.02648939f, 
    0.08840139f, 0.17462501f, 0.00706011f, -0.19179498f, -0.13121438f, 0.01140884f, 0.12390803f, -0.20022489f, 
    -0.09819169f, -0.00525605f, -0.02141372f, 0.02168777f, -0.12902474f, -0.14872062f, 0.13704607f, -0.01327305f, 
    -0.20015606f, 0.16317166f, -0.06709407f, -0.26314437f, -0.03234852f, 0.10316068f, -0.06357116f, -0.13580622f, 
    0.14196193f, -0.06546935f, 0.02674975f, 0.13194263f, 0.25694716f, 0.25346458f, 0.06985320f, -0.03351843f, 
    -0.16810925f, 0.06890405f, -0.17808053f, 0.05123420f, -0.30658895f, 0.06916551f, -0.11874811f, 0.17780507f, 
    0.44332787f, -0.02782283f, -0.11731807f, -0.49710888f, -0.33673915f, -0.44794065f, 0.13677731f, -0.02489636f, 
    0.02953859f, -0.06065342f, 0.03273968f, 0.07707918f, -0.25542846f, 0.03421132f, -0.10246585f, 0.15666246f, 
    0.14956181f, -0.15058400f, -0.12879716f, -0.07323468f, -0.27602807f, -0.20448601f, -0.00455833f, -0.17341042f, 
    -0.06377371f, 0.06721827f, -0.04924882f, 0.01502884f, -0.01246261f, -0.06184984f, 0.04609224f, 0.10433286f, 
    -0.10796672f, 0.14653414f, -0.15353954f, 0.02407931f, -0.14543803f, -0.03739173f, -0.21473750f, -0.08443613f, 
    0.18450841f, -0.05867425f, 0.22583182f, 0.08345960f, 0.04095725f, 0.25923654f, -0.02186666f, -0.00246255f, 
    0.03872459f, 0.04411263f, 0.03795644f, -0.03167555f, 0.01735367f, 0.01345492f, -0.03931059f, -0.03148929f, 
    -0.03554164f, -0.01209630f, -0.02703825f, 0.01052428f, 0.01877526f, 0.02939318f, -0.01431194f, -0.03198460f, 
    -0.00904442f, 0.01096516f, -0.03776431f, -0.02464671f, 0.04323243f, 0.03475054f, 0.03856782f, -0.01817593f, 
    0.04600337f, 0.00963963f, 0.00194677f, 0.03502287f, -0.01531784f, 0.04479534f, -0.02955576f, -0.05794615f, 
    -0.04312834f, -0.05372653f, 0.03528972f, -0.05124176f, 0.05308250f, -0.00437361f, -0.00907773f, -0.01872904f, 
    -0.02229101f, 0.04240530f, 0.02165444f, 0.04832627f, -0.05178393f, 0.01544623f, -0.05334065f, 0.02812030f, 
    0.03744091f, 0.01252652f, -0.00889942f, -0.04364184f, -0.03447979f, -0.02242344f, 0.02534161f, 0.04305273f, 
    -0.02163559f, -0.04304317f, -0.00197641f, 0.01416980f, -0.06061605f, 0.02108010f, -0.05148827f, 0.00513706f, 
    -0.02873486f, -0.00315221f, 0.04097610f, -0.02954341f, -0.06525384f, 0.02646198f, -0.02704109f, -0.00017094f, 
    -0.00213793f, 0.00151478f, -0.02845660f, -0.03628862f, -0.03019726f, -0.01447358f, -0.04424291f, 0.00065855f, 
    -0.05807913f, 0.00822449f, -0.05572602f, -0.03991453f, -0.03600027f, -0.04151084f, -0.01800239f, 0.02479690f, 
    0.01201741f, 0.03346687f, -0.03705201f, -0.02936289f, -0.01378119f, -0.05176197f, 0.01407361f, -0.03203226f, 
    0.03355845f, -0.04613534f, -0.02255278f, -0.03935935f, -0.04659811f, 0.00248717f, -0.00590968f, -0.03081561f, 
    -0.02438379f, 0.01063640f, -0.00463135f, -0.04266867f, 0.01455163f, 0.04271786f, 0.01949615f, 0.02549545f, 
    -0.01784184f, 0.01187616f, 0.02741035f, -0.04460843f, -0.02945282f, 0.00970599f, -0.01829389f, -0.00186671f, 
    -0.02757436f, -0.00623503f, -0.02887567f, -0.05465089f, -0.04339517f, -0.04780417f, -0.04150495f, -0.01765478f, 
    0.03418920f, -0.02709963f, -0.06584423f, -0.05108551f, 0.01900414f, 0.03401849f, 0.02573952f, -0.00948028f, 
    0.03160225f, 0.02425701f, -0.05108992f, 0.02495367f, 0.02256524f, -0.03351560f, 0.00711405f, 0.02998227f, 
    0.05125833f, -0.05014037f, 0.03950199f, 0.01692956f, 0.02460168f, -0.00832497f, 0.00962839f, 0.00551929f, 
    -0.01851377f, 0.03392688f, -0.00328640f, 0.03541808f, 0.04095474f, -0.00924371f, -0.00659895f, -0.04481459f, 
    -0.05212336f, 0.05125801f, -0.07542586f, -0.01561309f, -0.05413027f, -0.02662193f, -0.07056942f, 0.01272799f, 
    0.02031001f, -0.06157849f, 0.01338267f, 0.01180504f, -0.05379369f, -0.01336760f, 0.00883699f, -0.04243532f, 
    -0.01773615f, -0.03480331f, -0.02409251f, -0.04477797f, -0.02724344f, -0.01260623f, 0.00645051f, -0.05211204f, 
    0.04915686f, 0.02392412f, 0.03313284f, -0.04951692f, 0.00098400f, -0.04295158f, 0.00243903f, -0.04418632f, 
    0.02053052f, 0.02628199f, -0.04368266f, 0.02430113f, 0.01880931f, 0.02554238f, 0.01198484f, -0.05640071f, 
    -0.03181742f, -0.00434189f, 0.04745277f, -0.03679304f, -0.02055342f, -0.01899714f, 0.02977743f, -0.03551858f, 
    -0.01223527f, 0.03595461f, -0.03498271f, -0.04634259f, -0.03159512f, -0.04675810f, 0.03587689f, 0.04871590f, 
    0.00061843f, -0.01541685f, -0.02898845f, -0.03840554f, 0.01398316f, 0.02375969f, 0.01278112f, -0.00243828f, 
    0.01977584f, -0.04217848f, -0.02960550f, -0.06126932f, 0.00356363f, 0.02747944f, -0.01326109f, -0.00455700f, 
    -0.00844402f, -0.05667595f, 0.04890356f, -0.02584372f, -0.04366486f, -0.00926278f, 0.04601281f, -0.01512617f, 
    0.04700032f, -0.03044773f, -0.04527549f, 0.05662393f, -0.01842802f, -0.02798022f, 0.03978975f, 0.04048778f, 
    -0.05510219f, 0.03400194f, 0.02591633f, -0.05434647f, 0.05601503f, 0.05166232f, 0.04698223f, -0.01545342f, 
    -0.01653980f, -0.03528227f, 0.05352374f, 0.00992575f, -0.02267833f, 0.02047888f, 0.01633593f, 0.03098512f, 
    -0.05440709f, -0.04824110f, 0.03190334f, -0.05058860f, -0.04480261f, 0.04617508f, 0.00099377f, 0.05648969f, 
    0.04053771f, 0.00680233f, -0.01404297f, -0.05654338f, -0.03777181f, 0.00942713f, 0.01359764f, -0.04788227f, 
    0.03101277f, -0.02305596f, 0.01637609f, 0.04655860f, 0.04454553f, -0.03991149f, -0.03419191f, 0.02726050f, 
    -0.01951295f, 0.03746544f, -0.05971503f, 0.03230482f, -0.04373864f, -0.01843600f, -0.03367617f, -0.00308266f, 
    -0.02472522f, 0.01051389f, 0.02813089f, -0.06886139f, -0.06861762f, 0.03524719f, -0.02766813f, 0.03400242f, 
    -0.02314486f, 0.00651964f, 0.00360742f, -0.02046613f, -0.01702890f, -0.00989945f, -0.03694583f, -0.05682056f, 
    0.03048943f, -0.01418209f, 0.04825042f, 0.02423383f, -0.01465404f, -0.02681798f, 0.03174610f, -0.01769697f, 
    -0.00354104f, -0.02062627f, 0.03616936f, -0.00676569f, -0.02687897f, 0.03978905f, 0.04476607f, 0.00582580f, 
    -0.00999728f, 0.00473748f, -0.04501079f, 0.02299621f, -0.03134146f, -0.03760203f, -0.02695182f, -0.03177040f, 
    -0.02128951f, 0.00647198f, 0.01724752f, -0.02976795f, -0.00871261f, -0.05878736f, 0.00113238f, -0.02135519f, 
    -0.00028884f, 0.03385296f, -0.04503480f, -0.03706213f, -0.01915145f, 0.03015645f, -0.00269216f, 0.03494370f, 
    -0.02292552f, -0.03860751f, -0.00152393f, -0.02295508f, -0.05873246f, -0.05405785f, -0.02417209f, -0.03887525f, 
    -0.01759576f, 0.00777394f, -0.06514352f, -0.03892937f, 0.02083023f, 0.04550576f, -0.03308259f, -0.03848251f, 
    -0.00532042f, 0.02786469f, 0.04472356f, -0.00455934f, -0.04070257f, -0.04453756f, 0.04638079f, -0.05741421f, 
    0.04324065f, 0.04507960f, -0.01009572f, -0.04151230f, -0.00492137f, 0.00267766f, 0.01223474f, 0.01336529f, 
    -0.05526330f, -0.00965273f, -0.03614503f, 0.01582652f, 0.01564631f, 0.03591953f, -0.01615220f, 0.01202523f, 
    0.04535144f, 0.01421746f, -0.01272661f, 0.04731215f, 0.04318207f, 0.02974074f, -0.04947242f, -0.02860051f, 
    0.00304313f, 0.04513007f, -0.04546507f, -0.02590840f, -0.02959936f, -0.03396418f, 0.03740497f, 0.00243571f, 
    0.00003854f, 0.03259366f, 0.01402782f, 0.00012979f, -0.04969178f, 0.00452198f, 0.00474424f, -0.03223173f, 
    -0.02869210f, -0.01702968f, -0.00299357f, 0.02778063f, -0.06486828f, -0.04732579f, 0.00685469f, -0.01384919f, 
    0.00097437f, 0.05159549f, 0.00096148f, -0.06409914f, -0.02632986f, -0.03268342f, 0.04553518f, -0.03070399f, 
    0.00794484f, 0.01218071f, 0.01916349f, 0.04158960f, -0.01849864f, -0.01067352f, -0.04250997f, -0.00185290f, 
    -0.06496755f, -0.06511252f, 0.03233029f, -0.05754558f, 0.03441155f, 0.02940079f, 0.00379549f, 0.04426008f, 
    -0.00556928f, -0.04390779f, -0.04938482f, -0.00742956f, -0.06256698f, -0.04901329f, -0.03206045f, 0.00077328f, 
    -0.00941886f, 0.02440681f, -0.01649184f, -0.04584730f, 0.02292262f, -0.00861052f, 0.04589528f, 0.01240899f, 
    -0.04871847f, -0.04616901f, 0.03609567f, -0.00191746f, 0.03149385f, 0.02253318f, 0.04956215f, 0.01843961f, 
    -0.04570057f, 0.00466952f, -0.03646694f, -0.05793757f, -0.05009232f, -0.05537769f, 0.01727932f, 0.02627074f, 
    -0.05114175f, 0.04883477f, -0.04322477f, -0.00365203f, -0.04884957f, -0.00941069f, 0.02810703f, 0.03784050f, 
    0.04402795f, 0.00148919f, -0.05579183f, 0.05372993f, -0.02118311f, -0.03838389f, -0.03744174f, -0.06074327f, 
    -0.01724319f, -0.05413697f, -0.00482067f, 0.01971250f, 0.01445252f, 0.01449343f, 0.05332417f, 0.04716800f, 
    -0.03338257f, -0.03402911f, -0.05106658f, -0.01289869f, 0.00463588f, 0.00513050f, -0.00449374f, -0.02483631f, 
    -0.02271058f, -0.01178955f, -0.02585101f, 0.01622975f, 0.03021891f, -0.05110418f, 0.03661696f, 0.00012825f, 
    -0.02445198f, -0.06227496f, 0.02202405f, 0.00500561f, 0.02221777f, -0.02237805f, -0.02066352f, -0.04150612f, 
    -0.04747018f, -0.02054786f, -0.05952610f, 0.04528607f, -0.05044325f, -0.03164417f, 0.04002209f, -0.01370977f, 
    0.04568585f, 0.00835908f, 0.02652912f, 0.02996747f, 0.04978627f, -0.00554954f, -0.04373072f, -0.05282031f, 
    -0.01214388f, 0.01123902f, 0.03711931f, 0.04216295f, 0.03491521f, -0.06202960f, 0.02210155f, -0.02163411f, 
    0.03709903f, -0.06800773f, 0.04908985f, 0.02639765f, 0.02831117f, -0.00783270f, 0.00758306f, -0.06126570f, 
    0.02135336f, -0.04152451f, -0.04658779f, -0.02835739f, 0.02002927f, 0.05070221f, 0.01522385f, -0.01620688f, 
    -0.05020453f, -0.02804295f, -0.00413922f, -0.04200440f, 0.03565479f, -0.02129935f, -0.05380255f, -0.04521583f, 
    0.26029128f, 0.06616305f, 0.16908802f, 0.05547671f, -0.19465075f, 0.00871006f, 0.10195708f, -0.06000921f, 
    -0.10637260f, 0.04103907f, -0.10194871f, 0.36426336f, 0.12216152f, 0.21456295f, -0.13723472f, -0.12388491f, 
    0.09542386f, 0.13919894f, -0.30224475f, -0.10296817f, -0.12862477f, 0.00139033f, 0.15871410f, 0.06995956f, 
    -0.10265040f, -0.00249059f, -0.06749397f, -0.02307113f, 0.02326496f, -0.06900585f, -0.08301902f, 0.00979118f, 
    -0.08267723f, -0.04399998f, 0.12680449f, 0.02646776f, -0.15190284f, -0.00464439f, -0.01110090f, 0.15829185f, 
    0.05152664f, -0.04721576f, -0.00967267f, 0.01251757f, -0.06855927f, -0.30413440f, -0.23796792f, 0.17950934f, 
    0.04050279f, 0.00812264f, 0.22600336f, 0.01360545f, 0.02895988f, -0.11972027f, -0.57370806f, 0.01346616f, 
    0.14161094f, -0.07728815f, -0.10357225f, 0.01422354f, -0.29343417f, -0.03275485f, 0.10333476f, -0.12439554f, 
    -0.08227936f, -0.09659187f, 0.01543183f, 0.03308978f, 0.11136837f, 0.08464425f, -0.18214238f, 0.01533279f, 
    -0.04569391f, 0.10053197f, 0.23583898f, 0.07607561f, 0.03701719f, 0.04187082f, -0.06919558f, 0.16060661f, 
    -0.05447163f, -0.02045935f, 0.02328765f, -0.13058388f, -0.14104600f, 0.17582268f, 0.20345059f, -0.05804488f, 
    -0.16739972f, 0.07943627f, -0.16906838f, 0.18593432f, -0.00593388f, 0.06006694f, -0.25362086f, -0.25497186f, 
    0.09317190f, 0.13787906f, 0.29157674f, 0.14377819f, -0.00109718f, 0.30731088f, -0.28933355f, 0.00276474f, 
    0.18239476f, -0.08156589f, -0.00621010f, 0.23299779f, 0.48094738f, 0.05119912f, -0.12063365f, 0.20760579f, 
    0.14062925f, 0.10038684f, 0.18804221f, 0.14660968f, 0.11743813f, 0.25521734f, -0.00569169f, -0.07874645f, 
    0.04535661f, 0.16381066f, -0.01503300f, -0.07481452f, -0.10451108f, 0.02032096f, -0.51383126f, -0.09531169f, 
    -0.24004599f, -0.01055235f, -0.03688527f, 0.12258678f, -0.14350185f, -0.03298433f, 0.15921105f, -0.44498226f, 
    -0.03449159f, -0.15750130f, 0.11603583f, 0.11468653f, -0.09643322f, -0.02956677f, 0.10059189f, 0.04009114f, 
    0.27336314f, 0.23260540f, -0.01134493f, -0.10597132f, 0.04326328f, 0.27370629f, -0.04110548f, 0.19291693f, 
    0.04308075f, 0.26168010f, 0.03967741f, 0.29805401f, -0.21329197f, -0.05749661f, 0.09361499f, 0.03054810f, 
    0.11065352f, 0.20942134f, -0.62334973f, -0.14615954f, -0.07358316f, -0.00993943f, -0.06504286f, -0.06374957f, 
    0.03455283f, -0.02686154f, 0.32613826f, 0.04675779f, 0.22926024f, -0.03583952f, 0.00782824f, 0.02740628f, 
    0.14003813f, -0.15452901f, 0.02005704f, -0.02156520f, -0.05085161f, 0.02661185f, -0.02408480f, -0.01165160f, 
    0.05980886f, 0.18225820f, -0.01444045f, 0.07540271f, -0.08699141f, 0.03675733f, 0.12636523f, -0.36846545f, 
    0.03139894f, -0.11113498f, 0.16968183f, 0.00613347f, 0.04032966f, 0.17382902f, -0.45324996f, -0.22552611f, 
    -0.11281922f, -0.04125544f, -0.03224520f, 0.03940934f, 0.14465614f, 0.11903859f, -0.02163989f, -0.29651546f, 
    -0.25432375f, -0.16709293f, 0.14026047f, -0.11990727f, 0.16377926f, 0.13845605f, 0.04685047f, 0.04510832f, 
    -0.39634159f, 0.06813730f, -0.44657385f, 0.07662708f, 0.05501029f, -0.13058609f, -0.15284127f, -0.12957478f, 
    0.23953818f, -0.21758646f, -0.00717245f, -0.07915852f, 0.03954799f, 0.08247755f, 0.01320468f, -0.04171774f, 
    -0.07971011f, -0.04386336f, 0.34433487f, 0.10397618f, 0.07588003f, -0.07431602f, -0.03292241f, 0.10024701f, 
    0.15374528f, -0.08334707f, -0.25753903f, -0.15879928f, 0.15254693f, -0.06026630f, 0.02668964f, 0.06935421f, 
    -0.04369261f, -0.15637723f, 0.09418949f, 0.17651133f, 0.35105750f, 0.10435533f, 0.29725581f, 0.18589483f, 
    -0.05443304f, -0.06007563f, -0.26256207f, 0.07594534f, -0.15510470f, 0.14850752f, -0.10796428f, 0.01824517f, 
    0.00042625f, 0.04189093f, 0.13034476f, -0.01476362f, -0.00899185f, 0.13672367f, 0.11141516f, 0.27622524f, 
    0.32238546f, 0.01492280f, 0.15689963f, 0.20424214f, -0.37235883f, 0.13474469f, -0.14054577f, -0.13263974f, 
    -0.08561740f, 0.20695725f, 0.25702161f, 0.08197021f, -0.01820561f, 0.00066688f, -0.16881412f, -0.19093563f, 
    0.04417070f, 0.25434601f, -0.06619027f, -0.04968135f, 0.06564095f, -0.07884495f, -0.07319739f, -0.01062503f, 
    -0.17618831f, 0.21935083f, -0.08422066f, 0.03324503f, 0.18156038f, 0.16283867f, 0.09710901f, -0.04358945f, 
    0.16029307f, -0.07421029f, 0.01381633f, 0.22485468f, 0.16232206f, -0.05321048f, -0.06770656f, 0.07107723f, 
    0.11442114f, -0.10177011f, -0.01566959f, 0.18391229f, -0.19260561f, 0.35971713f, -0.11696046f, 0.05536684f, 
    -0.09848041f, 0.01424014f, -0.01730097f, 0.02585265f, -0.15665673f, 0.08599162f, -0.05300131f, 0.06574278f, 
    -0.09342734f, -0.20642330f, 0.02280353f, 0.07175608f, -0.23979506f, 0.21009505f, -0.03855966f, -0.21516271f, 
    0.11295798f, -0.10007376f, 0.10456347f, -0.12599567f, -0.14550835f, -0.08287998f, -0.12707667f, 0.02856905f, 
    0.00188482f, 0.22980013f, -0.10347693f, -0.05813324f, 0.00792850f, -0.10992552f, -0.19140284f, -0.00701837f, 
    -0.30226612f, -0.03172192f, 0.24616382f, 0.30297273f, 0.16063778f, -0.01395511f, -0.06130505f, -0.09560435f, 
    0.12716216f, -0.14998035f, -0.22554412f, 0.02667258f, 0.10330910f, 0.02409522f, 0.11788397f, 0.15637167f, 
    -0.08891774f, 0.23491322f, 0.22304274f, -0.19010566f, 0.06658638f, -0.22643580f, 0.10189298f, -0.00619000f, 
    -0.16414528f, -0.21418095f, -0.14442208f, -0.12535168f, 0.00968214f, -0.11536136f, 0.01876269f, -0.24637143f, 
    0.16332939f, -0.11779739f, 0.09787811f, -0.11761697f, 0.50629628f, 0.22421174f, 0.12587596f, -0.07602451f, 
    -0.10101711f, 0.02401439f, -0.02990790f, -0.11333970f, 0.09756336f, 0.02634050f, -0.08806939f, -0.06104071f, 
    0.09968112f, -0.05098991f, -0.02022497f, 0.02113704f, -0.11128056f, -0.04006532f, 0.42764667f, -0.22158329f, 
    -0.15199743f, 0.26089358f, 0.04041617f, -0.07437542f, 0.10240504f, -0.16941294f, -0.07533029f, -0.21528035f, 
    -0.00763834f, 0.28664526f, -0.16659473f, -0.02217708f, 0.09411111f, 0.09734106f, 0.03358776f, 0.21590747f, 
    -0.39236280f, -0.05989632f, 0.20083572f, -0.19874607f, -0.07585786f, 0.00739116f, 0.01856579f, 0.01943008f, 
    -0.16693896f, -0.12030386f, -0.14728843f, -0.15872940f, 0.12215029f, 0.21046172f, 0.03662937f, -0.06996179f, 
    -0.15178820f, 0.27482653f, 0.53600359f, 0.18368840f, 0.17253269f, -0.07578529f, 0.14213499f, 0.15295628f, 
    -0.03899808f, -0.07352408f, 0.26561096f, 0.13037933f, 0.14193402f, 0.01222583f, 0.01939963f, -0.07550859f, 
    0.10755002f, 0.08771596f, 0.22937550f, -0.06202115f, -0.48917931f, -0.29397950f, 0.10742408f, 0.07281019f, 
    0.15632521f, -0.01097600f, -0.08970910f, 0.07717141f, -0.24746935f, -0.01772610f, -0.71124202f, 0.07803486f, 
    0.04864935f, -0.00648058f, 0.11943136f, 0.07671341f, 0.36756846f, -0.23984042f, 0.09809129f, -0.09226093f, 
    0.02821165f, -0.00511293f, -0.03689933f, -0.12018166f, 0.04768315f, 0.00596188f, 0.27297071f, -0.13224785f, 
    0.10210779f, 0.00670102f, -0.16826887f, -0.08224359f, -0.05315734f, -0.02893506f, 0.12232386f, 0.15356967f, 
    -0.51906455f, -0.23836440f, -0.00639926f, 0.01709321f, 0.31769243f, 0.23309354f, -0.05581740f, -0.02230942f, 
    0.06567138f, -0.03426803f, 0.08208413f, 0.27150765f, -0.33468381f, -0.08058514f, 0.08630615f, -0.16106687f, 
    0.00419216f, 0.10425171f, 0.02600655f, -0.03968891f, 0.04095107f, -0.01249268f, -0.10401750f, 0.00841111f, 
    -0.01005215f, 0.05731480f, -0.18233515f, 0.10852551f, -0.23891941f, 0.06023055f, 0.02548837f, -0.02354593f, 
    -0.02959085f, 0.02473477f, 0.11027820f, -0.65009964f, 0.16156305f, -0.35948336f, 0.28747326f, -0.05486502f, 
    0.02479209f, 0.18044564f, 0.03513978f, 0.34041741f, 0.29704836f, 0.02251197f, 0.41320923f, -0.09405349f, 
    0.11867534f, -0.31980729f, 0.07020427f, 0.02175668f, 0.21608388f, 0.07207599f, 0.25806913f, 0.14090031f, 
    0.02021899f, -0.00189885f, -0.12579149f, -0.02680481f, -0.08369631f, -0.12859370f, -0.37545907f, -0.16269775f, 
    -0.33513272f, 0.13746664f, 0.05710321f, 0.08768854f, -0.33823344f, 0.16778669f, 0.09641089f, -0.18926384f, 
    0.05705477f, -0.15842175f, 0.09585115f, 0.01970843f, -0.06282295f, 0.01894852f, 0.02251001f, 0.02864881f, 
    0.28110424f, 0.07801373f, 0.00065636f, 0.11508007f, -0.06438994f, 0.07387941f, -0.09390974f, -0.02569868f, 
    0.14555807f, 0.46290424f, 0.03120906f, -0.32372573f, -0.00922348f, 0.01886349f, 0.14282069f, -0.04193093f, 
    -0.05721467f, 0.01554366f, 0.14004718f, -0.13983360f, 0.06542163f, 0.05633054f, -0.05999200f, 0.11045869f, 
    0.08758972f, 0.01934830f, -0.08994267f, -0.52021337f, -0.36219603f, -0.22954912f, 0.02961205f, 0.02969684f, 
    -0.07621783f, -0.02045609f, 0.10419586f, -0.13545769f, 0.02783142f, -0.10662024f, -0.14105389f, -0.15247454f, 
    0.16456309f, -0.11731178f, 0.08730627f, 0.08122629f, -0.31616774f, -0.29578069f, 0.12802781f, 0.31355545f, 
    0.06166270f, 0.10523160f, 0.09399363f, 0.05351587f, 0.17891544f, 0.10314811f, 0.15190600f, -0.05252650f, 
    -0.01539958f, -0.00654171f, 0.14034288f, -0.08385571f, -0.06297736f, 0.14810692f, -0.10202925f, -0.17569833f, 
    0.01945106f, 0.05114535f, 0.09772982f, 0.21335384f, 0.00267073f, 0.38147092f, -0.15236260f, -0.15083537f, 
    0.34394696f, -0.00891554f, 0.00934201f, -0.13279282f, 0.11520100f, -0.01727707f, -0.06447627f, 0.14357848f, 
    0.01751147f, 0.02203870f, -0.15569229f, -0.06378695f, -0.02340259f, 0.11977071f, 0.01518597f, 0.04504811f, 
    0.09195153f, -0.14018819f, -0.06497045f, -0.16210248f, 0.04907076f, 0.04070527f, -0.05971109f, 0.09524378f, 
    0.28667206f, -0.01488383f, 0.18019941f, 0.52358413f, 0.12335196f, -0.26859379f, 0.05530493f, 0.28073913f, 
    0.14615774f, -0.03236269f, -0.04805221f, -0.02536966f, 0.20084459f, 0.03721980f, -0.08257098f, 0.23999898f, 
    -0.09801237f, -0.13001040f, -0.02056918f, 0.04802778f, 0.07877904f, 0.09406377f, 0.14395952f, -0.09183901f, 
    0.17792448f, 0.02478002f, 0.18725879f, 0.09530442f, 0.03343230f, 0.03411368f, 0.03940037f, -0.14817648f, 
    -0.09409863f, -0.00678475f, 0.28485566f, -0.11763332f, 0.03227537f, 0.03970104f, 0.08121254f, -0.71096420f, 
    0.16369426f, -0.07000639f, -0.14407970f, -0.27365452f, 0.03212761f, -0.05184625f, 0.01494142f, -0.17070955f, 
    -0.08544615f, -0.01062087f, 0.16021964f, -0.09550316f, -0.05935692f, -0.04603118f, -0.07521559f, -0.06995450f, 
    -0.03109663f, 0.05548514f, 0.09916904f, 0.04564724f, 0.00494567f, 0.12358997f, 0.05744811f, 0.11476510f, 
    -0.02732754f, -0.05938491f, -0.32178470f, 0.03037552f, -0.17275837f, 0.05851612f, 0.24003141f, 0.18530059f, 
    0.12161867f, 0.01825424f, -0.07182017f, 0.11057624f, 0.13957903f, 0.19779009f, -0.09991156f, -0.00391428f, 
    -0.09375343f, 0.06242629f, -0.05243887f, 0.15153749f, -0.10284646f, -0.30160883f, -0.06192002f, -0.09943528f, 
    -0.05538532f, 0.11447080f, 0.03865540f, -0.08723966f, 0.12431371f, -0.09135531f, -0.32897466f, 0.03099858f, 
    0.07189307f, -0.01635830f, -0.02785653f, -0.05761595f, 0.05490254f, 0.35341796f, -0.37716305f, 0.10966392f, 
    0.18846111f, 0.16356905f, 0.26642787f, -0.04110446f, 0.30497214f, 0.06281284f, 0.02657513f, -0.05878402f, 
    -0.31560087f, 0.14263545f, -0.10594244f, 0.19243024f, -0.27087656f, 0.11687059f, 0.07346044f, -0.03107877f, 
    0.12118585f, -0.13705568f, -0.08528363f, -0.23227575f, -0.08435286f, 0.11264759f, -0.04852680f, 0.04280345f, 
    -0.02676982f, 0.07391693f, -0.15518704f, -0.27600050f, 0.01432311f, 0.04232865f, 0.01397985f, 0.06717675f, 
    -0.01830087f, 0.01270960f, -0.10898849f, -0.14620429f, -0.16863050f, 0.01995624f, -0.14541203f, 0.09403310f, 
    0.02744695f, -0.07423932f, 0.13142560f, 0.09537163f, -0.08874676f, -0.16124381f, -0.16744362f, 0.09999055f, 
    -0.01141954f, 0.15864140f, -0.03099400f, -0.06939865f, 0.05192633f, -0.29936928f, -0.26369214f, -0.35175779f, 
    0.24790503f, -0.06258064f, -0.31032827f, -0.06708565f, 0.07546791f, 0.59202027f, 0.04368057f, -0.21164674f, 
    -0.04405486f, 0.00030181f, -0.05815272f, 0.03230912f, -0.14665496f, 0.03343083f, -0.07125691f, -0.25433415f, 
    0.20424697f, -0.02555714f, 0.05586602f, 0.04846586f, -0.13885380f, 0.02739335f, -0.00323925f, -0.28428128f, 
    0.03281657f, 0.15736906f, -0.14251900f, 0.04708199f, 0.05092105f, -0.00797337f, 0.05906530f, -0.19603458f, 
    0.03759425f, 0.04403830f, -0.05703491f, 0.02895566f, 0.03953632f, 0.01515100f, -0.02007863f, 0.03397882f, 
    -0.05632459f, 0.00075803f, -0.02149929f, 0.03274133f, 0.03485909f, -0.04670473f, -0.01111077f, 0.01320729f, 
    0.03112039f, -0.06108085f, -0.06584496f, 0.00529189f, -0.02412919f, -0.00027776f, -0.04575238f, 0.04302384f, 
    0.04546745f, 0.04086667f, -0.00996662f, 0.02648289f, -0.04781191f, 0.03175826f, 0.01000022f, -0.03936377f, 
    -0.01494848f, -0.01607082f, 0.03634906f, 0.02097632f, -0.03647364f, 0.03160923f, -0.06061713f, -0.00901579f, 
    -0.06917230f, -0.04145887f, -0.00537303f, -0.00843902f, 0.02640673f, -0.02688804f, -0.05249207f, 0.01995942f, 
    0.00912312f, -0.04020619f, 0.02852628f, 0.04553377f, -0.06648708f, 0.00876197f, 0.00503876f, 0.03202989f, 
    -0.03135399f, -0.03824306f, -0.05085600f, -0.01069387f, -0.02145268f, -0.05456019f, 0.01935535f, -0.05180086f, 
    0.00273102f, 0.01164536f, 0.01656716f, 0.04581618f, -0.03345413f, -0.02273245f, 0.03413200f, -0.04819389f, 
    -0.01095323f, -0.06494924f, 0.01225877f, -0.01806460f, -0.05720658f, -0.04111099f, -0.01179352f, 0.03201207f, 
    -0.04532872f, -0.01134801f, 0.01300500f, -0.03103880f, -0.03232615f, 0.04118869f, 0.02661371f, -0.03671516f, 
    0.00718190f, -0.04080411f, 0.02535974f, 0.02959323f, -0.01569641f, -0.00779115f, 0.02748043f, -0.01526270f, 
    -0.06050253f, 0.04376230f, -0.03920196f, 0.02676624f, -0.01470956f, -0.01781891f, 0.02194762f, -0.04867373f, 
    0.01108472f, -0.00572065f, 0.01800194f, -0.05675004f, 0.04719796f, 0.04540784f, 0.03344678f, -0.01235584f, 
    -0.03977924f, 0.02397147f, -0.03733539f, 0.02831105f, -0.06642611f, 0.01058958f, 0.01119684f, 0.01214999f, 
    0.01348269f, 0.03733670f, -0.01811323f, -0.02138065f, -0.02936054f, 0.04357566f, -0.06118838f, -0.05545549f, 
    0.00572337f, 0.03880434f, 0.03231033f, -0.04061428f, 0.02004319f, -0.04325739f, 0.04795822f, -0.00440199f, 
    0.04618975f, -0.00154352f, 0.00478394f, -0.06140305f, -0.02842670f, -0.01471773f, 0.00287159f, -0.06514634f, 
    0.03608176f, 0.01818678f, -0.03582921f, -0.01038018f, 0.04631273f, 0.02757908f, 0.02645814f, -0.00730892f, 
    -0.02377254f, 0.04352301f, -0.02271433f, -0.00903509f, -0.01739291f, -0.03610883f, -0.01005005f, 0.04293749f, 
    0.04433056f, 0.03163070f, 0.04554711f, -0.02815309f, 0.04503988f, 0.03930203f, -0.05407456f, 0.01921061f, 
    -0.05753192f, -0.04023463f, -0.02154617f, -0.05891839f, -0.02047910f, 0.02395378f, -0.03337179f, -0.01772285f, 
    0.01620347f, 0.00341088f, -0.00602171f, -0.04402854f, -0.02248014f, 0.01083504f, 0.02228194f, 0.00500824f, 
    -0.00007261f, -0.02308699f, 0.02223577f, -0.02861490f, 0.00616161f, -0.06573708f, 0.03761667f, 0.02993841f, 
    0.03668413f, -0.01050077f, 0.00595928f, -0.06907507f, -0.02022862f, -0.02380572f, -0.05770240f, 0.00482894f, 
    -0.06800942f, -0.04377848f, -0.06325848f, 0.01685029f, 0.01902553f, -0.05303749f, 0.02580844f, -0.03725753f, 
    0.00942356f, -0.00125696f, 0.01753350f, 0.03185101f, -0.05835453f, -0.04091158f, 0.03532814f, -0.01147325f, 
    0.01877036f, -0.00367455f, 0.00765798f, -0.03125897f, -0.06562760f, -0.01360308f, -0.04090858f, -0.02659309f, 
    -0.02103457f, -0.02747682f, 0.00700698f, -0.04440438f, -0.06007906f, -0.02801139f, -0.00159010f, -0.02330678f, 
    0.00702653f, 0.02165812f, -0.04614422f, -0.04438534f, -0.02848574f, -0.03550766f, 0.02548710f, 0.00473637f, 
    -0.03691640f, -0.01173816f, -0.06028060f, -0.04048755f, -0.02207764f, 0.00570163f, -0.02147879f, 0.03431285f, 
    -0.00807060f, -0.02313916f, -0.05718398f, 0.02258290f, -0.05557447f, -0.02483971f, 0.04643362f, -0.04841478f, 
    -0.03368143f, 0.03642030f, -0.03860978f, -0.05985584f, 0.00598148f, -0.00067731f, 0.04398433f, 0.02019206f, 
    -0.00650232f, -0.05241138f, -0.05933421f, -0.04560176f, -0.03942817f, -0.02484462f, 0.00787481f, -0.05046642f, 
    0.00799305f, -0.02547905f, 0.03566476f, 0.00710777f, 0.03403533f, -0.00880788f, 0.00511009f, -0.00702690f, 
    -0.00281834f, 0.04483172f, -0.05195813f, -0.03042459f, 0.00970118f, 0.03170980f, -0.03272997f, 0.01160229f, 
    -0.15543848f, -0.07195059f, -0.25411001f, 0.18235992f, 0.09537821f, 0.11202125f, 0.12986025f, 0.19307765f, 
    0.11930570f, 0.90268177f, -0.22137934f, -0.23757739f, -0.20907860f, 0.10169853f, 0.20138653f, -0.09322627f, 
    0.08177847f, 0.14914778f, 0.20004544f, 0.17826042f, 0.20937338f, 0.15030077f, -0.03161396f, 0.11165635f, 
    0.07634849f, 0.14781632f, 0.08017930f, -0.16490780f, 0.22636689f, -0.27315900f, -0.06047173f, 0.05127289f, 
    -0.00610501f, 0.06878626f, 0.12127919f, -0.28656495f, -0.03833316f, -0.13062598f, 0.13329571f, 0.05089652f, 
    -0.02139797f, -0.13360378f, 0.20177604f, 0.32175052f, 0.09068142f, -0.60167080f, -0.00693874f, 0.18287762f, 
    0.18195510f, 0.00017026f, -0.07822430f, 0.16217691f, -0.07052324f, 0.16113831f, 0.19637519f, 0.15535223f, 
    0.12437289f, -0.05099943f, 0.04210034f, -0.28961161f, -0.12818010f, 0.06642453f, 0.17452247f, -0.17624882f, 
    -0.20398030f, 0.48151836f, -0.01589285f, 0.23742072f, -0.07139717f, 0.06089097f, -0.07768797f, 0.22557470f, 
    0.30648428f, -0.20520790f, -0.12582490f, -0.02721740f, 0.07288241f, 0.13056016f, -0.12036190f, -0.18347578f, 
    -0.14234309f, -0.22065113f, -0.21877086f, -0.21550751f, -0.02829757f, 0.13252442f, -0.20195973f, -0.21112807f, 
    0.01852651f, -0.05059793f, -0.40455931f, -0.39149636f, 0.19122507f, 0.00473259f, 0.09430342f, -0.00435536f, 
    0.09608152f, 0.06470431f, 0.01892832f, -0.26025102f, -0.00835746f, -0.56511152f, 0.00695819f, 0.12890781f, 
    -0.03976957f, 0.05527921f, 0.22543643f, 0.13056992f, 0.09842511f, 0.07125928f, -0.31973332f, 0.15717022f, 
    0.09739789f, 0.01901462f, -0.14533865f, -0.14067617f, -0.04263824f, -0.26567820f, -0.48429611f, 0.08622969f, 
    -0.07932102f, 0.11732514f, 0.35215744f, 0.14432657f, 0.01819272f, 0.01096418f, 0.32692355f, 0.14162801f, 
    0.19568816f, -0.00844092f, -0.06139561f, -0.19058955f, -0.27533245f, 0.00192284f, -0.04864440f, -0.51051807f, 
    -0.01473495f, 0.30514017f, -0.00876289f, 0.04486440f, -0.16455561f, -0.13382411f, 0.00520558f, -0.36072457f, 
    0.15553476f, -0.04863070f, -0.14368582f, -0.15814497f, -0.07268025f, -0.23048629f, 0.07643664f, 0.19984430f, 
    0.21276227f, -0.54090136f, 0.06849737f, -0.31344399f, -0.04149937f, 0.17625247f, -0.12240915f, -0.12215392f, 
    0.03764686f, -0.04667826f, 0.10811625f, 0.02026498f, 0.18104593f, 0.01200296f, 0.05535213f, 0.03170538f, 
    0.17233592f, -0.15514755f, -0.30572549f, 0.28073788f, 0.16044754f, 0.00278595f, 0.07008572f, -0.03378165f, 
    -0.00922893f, -0.14643237f, 0.00671528f, -0.21215799f, 0.01869273f, -0.44713545f, -0.26730019f, 0.08588210f, 
    0.09043730f, 0.07718987f, 0.10828753f, -0.30562761f, -0.20884866f, -0.33845723f, 0.01945064f, -0.01806466f, 
    -0.06887676f, -0.01457095f, -0.04970742f, 0.08065086f, 0.21494611f, 0.16526644f, 0.20272478f, 0.19666578f, 
    0.16278599f, -0.00728764f, 0.16642174f, 0.00302631f, 0.07271455f, 0.25660345f, 0.02061147f, -0.12895980f, 
    0.05999503f, 0.51225048f, -0.05078207f, -0.22220731f, -0.23117825f, -0.08324960f, -0.05515714f, 0.08041565f, 
    0.39648235f, 0.20960167f, -0.13054228f, 0.05506601f, -0.05686285f, 0.04928127f, -0.01778497f, -0.03924012f, 
    0.08957126f, 0.32882908f, 0.33059329f, -0.13169906f, -0.34875739f, -0.17827630f, 0.09322804f, 0.06187504f, 
    -0.00601238f, -0.07640633f, -0.19705291f, -0.45711046f, -0.21087086f, 0.09762650f, 0.07857838f, 0.00328406f, 
    0.05874776f, 0.14560890f, 0.05967418f, 0.36542094f, 0.07087953f, -0.11462171f, -0.02239009f, -0.00322227f, 
    -0.23914877f, -0.06574655f, 0.14481173f, -0.05375723f, -0.29557833f, 0.10334963f, -0.88232833f, -0.14373685f, 
    0.08851750f, -0.10516725f, 0.04515798f, -0.03638225f, -0.02003843f, 0.25658920f, 0.35314143f, -0.67068195f, 
    -0.01847539f, 0.01156003f, 0.10649484f, -0.06733181f, -0.11578967f, -0.06080037f, 0.07767028f, 0.06421752f, 
    -0.02707941f, -0.24044023f, 0.27309850f, 0.36511871f, -0.04919583f, -0.02160608f, -0.11109206f, 0.01824916f, 
    0.04090128f, -0.08347894f, -0.00971559f, 0.20894249f, 0.04003953f, 0.06303122f, 0.06366026f, -0.05251921f, 
    -0.01925720f, -0.12785351f, 0.09943991f, 0.27275553f, -0.18121302f, 0.11422968f, 0.00426301f, 0.05798674f, 
    0.22498272f, -0.38559380f, -0.04500698f, -0.26458752f, -0.03778414f, -0.13589075f, 0.11322001f, 0.09810419f, 
    -0.02834534f, -0.12252840f, -0.13305490f, -0.11285021f, -0.19133496f, 0.17216855f, 0.25431857f, 0.09272054f, 
    0.23878992f, 0.00013462f, 0.06203280f, -0.12217448f, 0.01945993f, -0.01124988f, 0.10258660f, -0.07854601f, 
    -0.12108342f, 0.01766366f, -0.02500114f, -0.15610160f, -0.07251406f, -0.25168103f, 0.08140165f, -0.12647220f, 
    -0.04802115f, 0.31061134f, 0.20297657f, 0.03163397f, -0.17347179f, 0.19239444f, 0.27387160f, 0.08820805f, 
    0.03271127f, -0.00668462f, -0.06164853f, 0.09444696f, -0.05038781f, 0.03903778f, -0.35173449f, -0.43859851f, 
    -0.00668420f, -0.02276293f, 0.14289039f, -0.00136856f, 0.33766595f, -0.05424035f, -0.01626777f, 0.17082629f, 
    -0.05982729f, -0.05796326f, -0.11305551f, 0.11095773f, 0.17685694f, -0.17822541f, 0.01748763f, 0.03126673f, 
    -0.02899935f, 0.26067162f, 0.00421335f, -0.01943881f, -0.09017400f, -0.07501402f, 0.17500351f, -0.00183970f, 
    0.07253305f, 0.01604610f, -0.10386483f, 0.07655073f, 0.01641488f, -0.20660235f, 0.05102237f, 0.01266771f, 
    0.13549955f, 0.35673150f, 0.00827298f, 0.26635820f, 0.07735552f, 0.10314871f, 0.02438335f, 0.16813077f, 
    -0.01414760f, 0.16480474f, -0.07291056f, 0.25079197f, 0.04350887f, -0.14983724f, 0.02557492f, 0.16057964f, 
    -0.10764828f, 0.02927065f, -0.03724620f, -0.12006392f, 0.17633024f, 0.08179128f, -0.06227018f, -0.06157449f, 
    -0.07659313f, 0.34104589f, -0.10064036f, 0.18580434f, 0.05830297f, 0.06291061f, -0.08201926f, -0.02751587f, 
    0.09858339f, -0.10312208f, -0.07626186f, -0.22603194f, 0.08027137f, -0.13650972f, -0.23624435f, -0.04052345f, 
    0.31497875f, -0.09557677f, 0.06497043f, 0.05258229f, -0.02052576f, -0.00621780f, 0.00214475f, -0.15329891f, 
    -0.09217979f, -0.00174296f, -0.08162451f, 0.02573756f, 0.05410628f, -0.03484635f, 0.19436871f, -0.12424240f, 
    0.29695752f, -0.06341413f, -0.06861512f, 0.19948032f, 0.06981569f, 0.05688344f, 0.04615295f, -0.18396053f, 
    -0.03489262f, 0.02347592f, -0.13907893f, -0.03501772f, 0.23891436f, 0.09664575f, -0.02965702f, 0.07782075f, 
    -0.09353103f, 0.15494598f, -0.65557146f, -0.32089674f, -0.10368650f, 0.17082840f, -0.07021022f, 0.00823739f, 
    -0.10161898f, -0.03282969f, -0.10752749f, 0.27770701f, -0.05281046f, 0.14376971f, 0.11026708f, -0.02704705f, 
    -0.18353076f, -0.08384927f, -0.04613056f, 0.26480010f, 0.09755891f, 0.19446072f, 0.22227211f, -0.20017543f, 
    -0.32999915f, -0.17468810f, 0.14790429f, 0.00739075f, 0.01501818f, 0.02040121f, 0.16452070f, 0.26711798f, 
    0.09791574f, -0.20104742f, 0.08211362f, 0.18734558f, 0.03081617f, -0.00698068f, -0.61371583f, -0.17053936f, 
    -0.04470011f, 0.19738542f, -0.09475785f, 0.12858270f, 0.00019088f, -0.02079076f, -0.02216667f, -0.03672110f, 
    0.21279593f, -0.02555936f, -0.03425641f, -0.19332530f, -0.16320410f, -0.03969684f, 0.10625578f, -0.14548494f, 
    -0.16169986f, -0.31276190f, -0.04512245f, -0.08068044f, 0.04495753f, -0.08634647f, 0.21655619f, -0.13383266f, 
    -0.11515306f, -0.44657218f, -0.13836491f, 0.25778848f, -0.03257940f, 0.06380574f, 0.03314702f, -0.00526903f, 
    -0.05661387f, -0.03904379f, -0.13373144f, 0.06625899f, 0.20337908f, -0.02145390f, -0.02320363f, 0.10253702f, 
    0.05890470f, 0.03580482f, 0.26795825f, 0.17943910f, -0.15228057f, -0.15140240f, -0.11981694f, 0.00966577f, 
    0.17539084f, 0.10428204f, -0.06187435f, -0.16833535f, 0.15892763f, 0.07045881f, -0.00696480f, -0.21717001f, 
    0.05031564f, -0.05880002f, -0.07755917f, -0.08982796f, 0.21204747f, 0.13743591f, -0.11405738f, -0.03478210f, 
    -0.06872526f, -0.01220149f, 0.26580068f, 0.00443391f, 0.17752440f, -0.06074528f, 0.28847289f, 0.10188325f, 
    0.39864197f, 0.23822235f, 0.05534830f, -0.10877134f, 0.03325420f, -0.22923988f, 0.39886823f, 0.15843636f, 
    0.28097904f, -0.06415740f, 0.02007272f, -0.02307227f, -0.14601728f, 0.10459894f, -0.12613623f, 0.15438716f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.05220536f, 0.17720962f, -0.04147351f, 0.03522003f, 0.08606075f, -0.13626638f, 0.12304911f, 0.13625214f, 
    -0.01116069f, -0.02644517f, -0.03426662f, -0.00624363f, -0.00291064f, -0.04731202f, 0.07796834f, -0.13669145f, 
    -0.00477982f, -0.02170351f, -0.07899915f, 0.02628584f, 0.01407708f, -0.05649794f, 0.02454205f, 0.27597576f, 
    -0.00677230f, -0.06190559f, 0.07008227f, 0.02893124f, 0.22967646f, -0.01092810f, 0.01723735f, 0.09976341f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.08669224f, 0.34672120f, 0.54609293f, 0.07246329f, -0.06154670f, -0.16711108f, 0.07676011f, 0.28010476f, 
    0.06992372f, -0.11109360f, -0.00662768f, -0.35466304f, 0.13646522f, 0.14820534f, -0.59436744f, 0.52134889f, 
    -0.07777170f, -0.08004837f, 0.01971368f, -0.33388731f, -0.27272967f, -0.32166192f, 0.16448641f, -0.61365211f, 
    0.07156384f, 0.01416862f, -0.01963476f, -0.62287587f, 0.16231909f, 0.04452498f, 0.32967898f, 0.25510401f, 
    -0.14034055f, 0.37823275f, 0.66668290f, -0.32884231f, -0.10882380f, -0.44431883f, -0.32571861f, 0.23118481f, 
    -0.14261821f, -0.14467797f, 0.05288306f, -0.28134400f, -0.10112665f, 0.08987721f, -0.16608317f, -0.39252129f, 
    -0.02483771f, -0.05467620f, -0.54487914f, 0.08438097f, -0.40016025f, 0.13467024f, 0.31085816f, 0.45809633f, 
    -0.08561420f, -0.02831222f, 0.49427310f, 0.61160910f, -0.06155386f, -0.12517998f, -0.32549536f, -0.62051857f, 
    -0.14751777f, -0.21729159f, 0.17092745f, 0.02203539f, 0.70189452f, 0.32407901f, 0.23019506f, -0.52049124f, 
    -0.15057519f, 0.17419808f, -0.02141520f, 0.38200828f, -0.12990905f, 0.15419678f, -0.05356301f, -0.88327408f, 
    -0.17584400f, -0.15817763f, -0.14832880f, -0.79839182f, -0.72139889f, 0.33128583f, 0.83301497f, -0.26257363f, 
    0.01964821f, -0.17097265f, -0.07502906f, -0.51702756f, -0.29291081f, -0.05723213f, -0.04603338f, -0.22372900f, 
    0.04222722f, -0.20527321f, -0.26348567f, 0.11649465f, -0.42673492f, 0.28685233f, 0.29085183f, -0.22330797f, 
    0.11394991f, -0.12944268f, -0.02646142f, 0.28760511f, 0.00757618f, -0.01656182f, -0.32652622f, -0.08344045f, 
    -0.08244821f, 0.00130152f, 0.32971939f, 0.85322201f, 0.28410086f, -0.45871931f, -0.33168811f, -0.33651197f, 
    0.14746872f, 0.11616828f, -0.13249204f, -0.72692013f, -0.22951318f, 0.04207857f, -0.27640405f, 0.40116236f, 
    0.11563717f, 0.29657400f, -0.71270275f, 0.49214894f, -0.37564653f, 0.03843015f, 0.25158510f, 0.46363410f, 
    0.15010881f, 0.00897849f, 0.05866443f, -0.06894056f, -0.01802266f, -0.13206764f, 0.06926655f, -0.29995745f, 
    0.14222500f, 0.06264684f, -0.31291360f, -0.37507167f, 0.17160739f, 0.33018208f, 0.13035899f, 0.04426066f, 
    -0.12360366f, 0.06907506f, -0.15546927f, 0.08153883f, -0.13713837f, 0.01624908f, -0.78809047f, 0.10362622f, 
    -0.11574759f, 0.17484878f, -0.46747002f, -0.42662716f, 0.34143946f, 0.17000410f, -0.09982343f, -0.21282090f, 
    0.03170374f, 0.15651502f, -0.09611264f, -0.45249265f, 0.05707522f, 0.12088659f, 0.24853021f, 0.66084820f, 
    -0.06679083f, -0.02824775f, -0.06804539f, 0.07322137f, 0.19175467f, -0.99007612f, -0.14275043f, 0.93939483f, 
    0.09389687f, 0.04167002f, -0.03873113f, 0.06958733f, -0.01450280f, 0.11099136f, -0.02601163f, -0.16252151f, 
    -0.16555512f, -0.22926964f, 0.12143070f, -0.07667804f, -0.54231173f, -0.07746293f, -0.29172960f, 0.47268316f, 
    -0.14019227f, -0.04154312f, 0.03921022f, 0.03712237f, -0.08110497f, 0.16247864f, 0.66178566f, -0.54769415f, 
    -0.04404834f, 0.16765237f, 0.09575468f, -0.42854780f, -0.23214433f, -0.24604951f, -0.55192757f, -0.21521440f, 
    -0.05510873f, 0.08557784f, -0.04484416f, -0.33772987f, -0.46203449f, -0.16655698f, 0.56402987f, 0.28655586f, 
    -0.00871055f, -0.35907918f, -0.32457364f, 0.23209372f, 0.25031126f, 0.61399812f, -0.55373973f, -0.34599885f, 
    -0.16895518f, -0.12432065f, 0.07618558f, -0.34148329f, -0.12724213f, 0.09905388f, -0.34218723f, 0.56922764f, 
    -0.09505165f, -0.12548316f, -0.43177053f, -0.01053593f, 0.50055885f, 0.16414833f, 0.15233238f, 0.00111263f, 
    0.09494355f, -0.04793745f, 0.11489371f, -0.03015467f, -0.49308747f, 0.08835402f, -0.21926580f, 0.04268350f, 
    -0.16473974f, 0.07333732f, 0.05293094f, -0.57145590f, -0.32394466f, -0.14340681f, 0.19826193f, -0.21191093f, 
    -0.17890483f, 0.10424098f, 0.00511014f, 0.26358101f, -0.03359088f, 0.08389336f, -0.07666343f, -0.31185660f, 
    -0.02645552f, 0.09478475f, 0.68164670f, 0.21155776f, -0.05611693f, -0.16724032f, 0.16731898f, -0.17970181f, 
    0.00018896f, -0.05035279f, -0.39660180f, 0.74180591f, -0.88037729f, 0.15696564f, -0.02253143f, -0.67445385f, 
    -0.17215058f, 0.10275849f, -0.63696903f, -0.08954988f, -0.18026781f, 0.42809826f, 0.75863391f, -0.15507685f, 
    0.14487956f, -0.09477761f, 0.04745055f, 0.09077828f, 0.14712901f, 0.13509849f, -0.18207869f, 0.20486833f, 
    -0.01009771f, 0.02861065f, -0.22916496f, -0.29252371f, -0.38431266f, 0.41843462f, -0.70260119f, -0.41407758f, 
    0.05481553f, -0.05041076f, -0.24409050f, 0.00540413f, 0.82736570f, 0.13042398f, 0.64114606f, -0.23178570f, 
    0.06157207f, -0.74423832f, 0.12000079f, 0.17728356f, 0.44565710f, -0.91255665f, -0.00340341f, -0.25121084f, 
    -0.08850303f, 0.05377552f, -0.06191885f, 0.33052135f, 0.15137842f, 0.00443308f, -0.31316069f, -0.48337892f, 
    0.02129460f, -0.05981985f, -0.39144593f, 0.27569064f, -0.25527442f, -0.34956893f, 0.15560746f, -0.03239093f, 
    0.00322095f, 0.05948909f, 0.70585018f, -0.02371265f, 0.16089302f, 0.09825359f, -0.18959324f, 0.30433774f, 
    -0.03792146f, -0.41127816f, 0.00806770f, 0.27511096f, 0.18103412f, -0.48976758f, -0.56596482f, -0.53698933f, 
    0.03811732f, -0.14617531f, 0.08980267f, 0.39521471f, 0.10149277f, -0.04165740f, 0.31628358f, -0.24044296f, 
    -0.11664364f, 0.10124008f, 0.38236383f, -0.32476929f, 0.57175589f, 0.48493212f, -0.62674582f, -0.38843170f, 
    0.03460663f, 0.15483533f, -0.64822918f, 0.09555808f, 0.30989578f, -0.00485381f, -0.30200434f, 0.26208881f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.05643472f, 0.12769359f, -0.11877910f, -0.14902109f, 0.08523768f, 0.20711207f, -0.10216673f, -0.36275056f, 
    -0.16662553f, -0.06297095f, 0.05896522f, -0.00742589f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
