#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.03427422f, 1.08043265f, 0.50763810f, -1.19027972f, -0.46988916f, -1.02404761f, 0.17704402f, 0.38274404f, 
    0.62760532f, -1.68526709f, -0.49391395f, 1.28748274f, 0.05037950f, 0.89081091f, -0.81453311f, -0.10319260f, 
    0.13195714f, -0.40388545f, -1.22767985f, -0.15949339f, -0.78963560f, 0.32667601f, -0.41673073f, -0.20772845f, 
    -0.51887304f, -0.63177967f, -0.66953838f, -0.79505813f, -0.67540544f, -0.40605778f, -0.30301917f, -0.59809369f, 
    -1.18286788f, -0.53338349f, -0.34971184f, 0.01741439f, -0.75698268f, 0.33193269f, 0.16004227f, -0.97184455f, 
    -0.88952184f, -0.88680339f, 0.80594671f, 0.91446507f, -0.19634545f, 0.29449916f, -0.46422115f, -0.81933266f, 
    -1.15267062f, -0.79559726f, -1.04684925f, 0.12885605f, -0.50552356f, 1.03084862f, -0.97731233f, -0.02347592f, 
    0.06069414f, 0.31301159f, 0.86650091f, 1.12499869f, 0.38362437f, 0.12098216f, 0.56815535f, -0.23930925f, 
    -0.24432290f, 0.05211973f, 0.32968250f, -0.03222053f, -0.36613664f, 0.39659941f, 0.23459384f, 1.14876628f, 
    0.50885624f, 1.03195322f, -1.37453771f, 1.00905704f, 0.38999844f, 0.06839104f, -0.38360772f, 0.50754082f, 
    -0.35686967f, -0.49330950f, -0.96711844f, -1.19125497f, 0.98671538f, 1.06622446f, 0.62404197f, -0.10959965f, 
    -0.20559835f, -0.26843303f, 1.09234846f, -1.16358268f, 1.09404612f, 0.03055847f, 0.15340275f, 0.20548664f, 
    0.01859026f, 0.16642563f, 0.15057759f, 1.84397805f, -1.97435975f, -0.74226415f, 0.10946251f, 0.24540682f, 
    0.21097033f, 0.08585149f, 0.36356005f, 0.07320468f, -0.28651223f, 0.36276445f, 0.40240183f, 0.64141279f, 
    0.58775330f, 0.48517632f, -0.30474475f, -0.99943608f, -0.58997297f, 1.06941652f, -0.09139767f, 0.78564560f, 
    -0.09747424f, -0.20988697f, 0.13091691f, 1.06462896f, -0.05427042f, -0.76702195f, 0.01230906f, 0.76755410f, 
    0.08223381f, -0.56339842f, -0.96665370f, 1.05612230f, -0.13715020f, -0.85806555f, -0.59680998f, 0.40428498f, 
    1.16494322f, 0.28592014f, -1.07020867f, -0.54219568f, 0.62810314f, -0.43466979f, 0.17817621f, 0.61009371f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.27433282f, 0.28496528f, 0.83432287f, -0.60596907f, 0.44748205f, -0.08619208f, 0.58643216f, 0.32750621f, 
    -0.04782844f, 0.06369183f, 1.12642145f, 0.34971988f, 0.71706420f, 0.21127062f, 0.30419242f, 0.67907280f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.08124952f, 0.02288424f, 0.04988593f, 0.03903160f, -0.12188528f, -0.20862772f, -0.11526212f, -0.07164659f, 
    -0.00706695f, 0.24915601f, 0.60047990f, -0.32184964f, 0.01412847f, 0.16651538f, 0.27603090f, 0.10935187f, 
    0.18936737f, 0.23383816f, -0.02494818f, 0.26256660f, 0.08800314f, 0.04099496f, 0.32393438f, -0.05489932f, 
    -0.09119330f, 0.23790701f, 0.37259069f, 0.17780149f, 0.38782999f, 0.30227238f, -0.06817427f, 0.02067949f, 
    -0.00996632f, -0.10156519f, 0.02098085f, -0.03300942f, 0.06187585f, -0.27529886f, -0.53526664f, 0.12900823f, 
    -0.05333821f, -0.11785752f, -0.29547963f, -0.40441129f, -0.18262155f, -0.25370538f, 0.09206517f, 0.05626812f, 
    0.14684828f, 0.27379861f, -0.22847046f, -0.36509597f, 0.04543942f, -0.12435893f, 0.25508419f, 0.32736230f, 
    0.37379700f, -0.05937904f, 0.15353440f, 0.13616534f, -0.11356326f, -0.04287717f, -0.07667390f, -0.02742394f, 
    0.13238621f, -0.08301676f, 0.19387627f, -0.05211466f, 0.02493963f, -0.55342430f, -0.54037493f, -0.77817768f, 
    0.16363652f, -0.73612171f, 0.09104563f, 0.40274590f, 0.05501718f, 0.42145538f, 0.02097451f, -0.01104447f, 
    0.19563437f, -0.06418601f, 0.23954603f, 0.51359600f, -0.11512531f, 0.14944583f, 0.04437678f, 0.10007793f, 
    0.10666696f, 0.43737733f, 0.02526623f, 0.28728610f, -0.05203164f, 0.03400636f, -0.08152030f, 0.06046506f, 
    0.13744527f, 0.18334089f, 0.05182117f, -0.33290341f, 0.46159902f, 0.75782913f, -0.12609719f, 0.01580961f, 
    0.03538712f, -0.03895309f, 0.34431440f, -0.00616276f, 0.05188431f, -0.37996614f, -0.28685597f, 0.35366517f, 
    0.40898794f, 0.06997740f, 0.21039148f, -0.06407623f, -0.18583876f, -0.00432189f, 0.07253211f, -0.15528375f, 
    0.05540327f, 0.15684275f, 0.14087342f, 0.08679161f, 0.16837499f, -0.11753827f, -0.16469719f, -0.28528765f, 
    0.21646036f, -0.01663096f, 0.18649697f, 0.00759338f, 0.16607308f, 0.32431263f, -0.00110887f, -0.05451965f, 
    -0.19211072f, -0.00869907f, 0.06635906f, 0.05412867f, -0.01260022f, -0.00912988f, -0.09600984f, -0.19229437f, 
    -0.75938845f, 0.51237327f, 0.11833117f, 0.06720877f, 0.07338072f, -0.07220783f, 0.11879328f, -0.07626220f, 
    -0.03444052f, 0.58935291f, 0.10002565f, -0.57557231f, 0.01900958f, -0.01326370f, -0.14063269f, 0.05291237f, 
    0.00042586f, -0.08142143f, 0.20307386f, -0.05876103f, 0.33315161f, 0.05361857f, -0.08748185f, 0.18465266f, 
    0.26820672f, 0.15052705f, 0.03313061f, -0.59260166f, 0.00106184f, 0.64837915f, -0.18148977f, -0.00658112f, 
    -0.24776186f, 0.19743153f, -0.24943233f, 0.02353738f, 0.22133219f, 0.07087739f, -0.08644179f, -0.24875170f, 
    -0.04596990f, -0.03813962f, 0.09908368f, -0.12637769f, 0.05035905f, -0.00897195f, -0.31131771f, 0.62183082f, 
    -0.32250455f, -0.07734047f, -0.22691169f, 0.02168708f, -0.13449018f, 0.06368177f, 0.44885087f, 0.18365113f, 
    -0.07235380f, 0.01907799f, -0.31691846f, -0.09739517f, 0.03504122f, 0.23918216f, 0.19696479f, 0.15793303f, 
    -0.11962171f, -0.04495750f, -0.15890528f, -0.02346267f, -0.25610551f, 0.08346629f, 0.15789825f, -0.05001567f, 
    -0.12607907f, 0.06481852f, 0.03569254f, -0.64270675f, -0.32382941f, -0.44760057f, 0.22175753f, 0.15849133f, 
    -0.24072343f, 0.19543111f, 0.11528619f, -0.11032309f, -0.11433628f, -0.00879576f, -0.01601394f, -0.03500146f, 
    0.06165208f, 0.14369135f, 0.12230893f, -0.30131766f, -0.04580389f, 0.04277963f, 0.02266088f, 0.01343863f, 
    0.21704338f, 0.13820608f, 0.20940356f, -0.49363390f, 0.10425401f, 0.25326458f, -0.20928925f, 0.04520883f, 
    0.30640781f, 0.09140756f, 0.22265032f, -0.21810058f, 0.11131326f, 0.05646332f, -0.01807033f, -0.45709091f, 
    -0.01499793f, -0.06341319f, 0.23444800f, 0.12213058f, 0.09080283f, -0.19012682f, -0.09034464f, -0.13563393f, 
    0.00012959f, 0.14043735f, -0.12885712f, 0.09509420f, -0.11953132f, 0.27507460f, -0.06498487f, 0.03883091f, 
    -0.12655792f, 0.40498167f, 0.14852934f, 0.08542618f, 0.05733205f, 0.29020277f, 0.08193985f, -0.42513013f, 
    0.29008010f, -0.23241222f, 0.13978232f, 0.10004183f, -0.07475720f, 0.06697068f, 0.20634164f, 0.01517579f, 
    0.26271844f, -0.59583020f, -0.47308552f, -0.20506500f, -0.05137610f, -0.04447125f, 0.01839306f, 0.22056273f, 
    0.15398148f, 0.13064674f, -0.61026192f, -0.21177530f, -0.21634918f, 0.05079019f, 0.17910112f, -0.05284311f, 
    0.17772882f, -0.11841391f, 0.00878475f, 0.45320654f, 0.42475599f, 0.02711138f, 0.22327749f, 0.23291682f, 
    0.24099943f, 0.08125740f, -0.24579908f, 0.45259947f, 0.19840552f, 0.23622625f, 0.18706584f, 0.00147689f, 
    -0.16388912f, 0.33633500f, -0.03092568f, 0.23534267f, 0.03682267f, 0.21504849f, 0.34070072f, -0.34471607f, 
    -0.08329676f, -0.29239058f, -0.22726181f, 0.27568731f, -0.05058016f, 0.09035958f, 0.46578369f, 0.48333281f, 
    -0.15558952f, -0.31887087f, -0.25662041f, -0.03106921f, -0.24552278f, 0.24762201f, -0.79345036f, -1.03768897f, 
    -0.19803177f, -0.16986059f, 0.05356688f, -0.11085711f, 0.18486808f, 0.08572929f, 0.32654482f, 0.19945753f, 
    0.25445864f, -0.00131949f, -0.01757766f, 0.21877053f, 0.16982463f, -0.09421977f, 0.17636104f, 0.28099263f, 
    0.81055260f, -0.36074921f, -1.39058113f, -0.13402550f, -0.37272248f, -0.00259815f, 0.01148153f, 0.10645931f, 
    -0.20231652f, 0.74417001f, -0.25677514f, -0.01954420f, 0.17624296f, 0.21306893f, 0.18070489f, 0.28657305f, 
    -0.08150691f, -0.18015586f, -0.40091011f, -0.20376925f, -0.49895301f, -0.49046418f, 0.30109769f, 0.21416339f, 
    -0.00706378f, 0.14984548f, 0.12883750f, 0.79138702f, -0.80138695f, -0.96483928f, -0.18522102f, -0.15893075f, 
    -0.02529774f, 0.00535347f, 0.24249475f, -0.18631956f, -0.32253882f, -0.11273462f, 0.11963923f, -0.01057026f, 
    -0.32994065f, -0.05913857f, 0.33775774f, 0.08503844f, -0.02033703f, -0.62273371f, 0.05228877f, 0.27205577f, 
    0.08037101f, 0.29113081f, 0.06524992f, -0.29044983f, 0.07511501f, 0.18508707f, -0.88084990f, 0.26579258f, 
    0.39868072f, 0.00531058f, -0.23809451f, -0.07834429f, 0.04926969f, 0.15638000f, -0.32547176f, -0.05600921f, 
    -0.59706295f, -0.39725435f, -0.07718422f, -0.13824667f, 0.09282003f, 0.15112919f, 0.20779942f, 0.27476367f, 
    -0.74603981f, -0.26195776f, -0.00927422f, -0.12303406f, -0.04716241f, -0.03623335f, -0.01234858f, 0.11030483f, 
    0.14444228f, 0.76716018f, -0.17453936f, -0.33107081f, -0.04467208f, 0.28254816f, -0.11398566f, 0.22064281f, 
    -0.11220107f, -0.13506179f, 0.44958743f, 0.03787790f, -0.39921159f, 0.15623103f, -0.11895474f, 0.25868577f, 
    -0.02722893f, 0.10852810f, -0.26534224f, 0.45067608f, -0.08794729f, -0.34342250f, -0.09806246f, -0.15644236f, 
    -0.31731766f, -0.12242538f, -0.05770838f, 0.01838342f, 0.52328330f, -0.06011396f, -0.03547642f, 0.09464208f, 
    -0.20964830f, 0.22580937f, 0.17905502f, -0.08449057f, 0.27183113f, 0.47474372f, -0.18686812f, -0.72986698f, 
    -0.33590552f, -0.08968075f, -0.14741512f, -0.00561242f, 0.06160014f, 0.25911674f, -0.01384181f, -0.01488640f, 
    -0.11695050f, -0.10530370f, 0.06922357f, 0.00682080f, 0.02105018f, -0.01931788f, 0.04536712f, -0.04659653f, 
    -0.24736965f, -0.19284542f, 0.12514639f, 0.05752903f, 0.02228290f, 0.16904899f, 0.20050089f, 0.20770638f, 
    -0.42141178f, -0.47909740f, 0.18530545f, -0.17588733f, -0.23174165f, 0.00503348f, 0.03516651f, -0.09341025f, 
    -0.19908099f, -0.05286077f, -0.26219779f, 0.15325607f, -0.04040974f, 0.04268306f, -0.23398712f, -0.05012885f, 
    -0.32492477f, -0.18802431f, 0.50313115f, 0.14128657f, -0.09221499f, -0.04786752f, 0.08762408f, -0.05186370f, 
    0.09222989f, 0.02966906f, 0.14137666f, 0.57524073f, -0.47180060f, -0.45936009f, -0.14243163f, 0.10826021f, 
    0.01702622f, 0.31934625f, 0.05574953f, 0.07759813f, -0.12656742f, -0.01195277f, 0.42290273f, -0.21003020f, 
    -0.14924292f, -0.09748941f, 0.16826580f, 0.03532787f, -0.28381076f, -0.01979837f, 0.38612822f, -0.05859602f, 
    0.02594083f, -0.14658248f, 0.01759735f, -0.10918309f, 0.15826264f, 0.24996674f, -0.08380237f, 0.21473759f, 
    0.15373716f, -0.23520081f, -0.08027151f, -0.12702218f, 0.04605331f, 0.05059528f, 0.17797011f, -0.44003931f, 
    0.13611950f, -0.03329348f, 0.02927473f, 0.15515243f, -0.00470993f, 0.02476216f, 0.15742429f, 0.24249271f, 
    -0.03271157f, 0.02920479f, 0.22328043f, 0.10074577f, 0.07864312f, 0.36547247f, 0.14877361f, -0.18506105f, 
    -0.08150055f, -0.02901182f, -0.23657319f, -0.18252307f, -0.49971336f, 0.11635575f, -0.25929633f, -0.02196894f, 
    -0.47267467f, -0.00448909f, 0.03425467f, -0.34684515f, -0.89384276f, -0.14698313f, -0.03656187f, -0.21252950f, 
    -0.05870140f, 0.00737919f, -0.17649868f, -0.40840039f, 0.22557685f, -0.07144105f, -0.22669233f, -0.25018382f, 
    -0.13448609f, -0.15694305f, 0.23166524f, 0.31678513f, -0.35847038f, 0.15251224f, 0.03821541f, 0.02653516f, 
    -0.27559182f, 0.07438702f, -0.04677847f, -0.13308850f, 0.16440380f, 0.02896006f, 0.04217776f, -0.38532281f, 
    -0.06631873f, -0.30006084f, 0.08629730f, -0.04481268f, 0.01170799f, 0.20477156f, 0.21918657f, 0.22018516f, 
    0.27127102f, -0.27571511f, -0.23847263f, -0.17524038f, 0.00245241f, 0.14106418f, -0.38081342f, 0.13585128f, 
    0.21512122f, -0.03379792f, 0.04328866f, 0.22106047f, 0.24987876f, 0.07377028f, 0.15806268f, 0.21168056f, 
    0.68145716f, 0.14944041f, -0.09470427f, -0.15942220f, -0.03296353f, -0.20593873f, -0.04195414f, -0.28739634f, 
    -0.11190778f, 0.10177224f, -0.05522374f, -0.15277307f, -0.46869025f, -0.55321389f, -0.55106652f, 0.26215550f, 
    -0.16649430f, -0.32722127f, -0.02395213f, -0.03965694f, 0.21202299f, 0.24226713f, 0.25218299f, 0.03199229f, 
    -0.03017223f, 0.06774183f, 0.03147973f, 0.48887464f, 0.12816614f, -0.89263076f, -0.32907861f, 0.15973103f, 
    0.15108436f, 0.13481320f, -0.07809017f, -0.03631094f, 0.34825987f, 0.34741068f, 0.51954466f, 0.10375887f, 
    0.21616946f, 0.00052133f, 0.11098974f, 0.09770611f, 0.22672151f, 0.23815663f, 0.01796265f, 0.12609200f, 
    0.09109451f, 0.14181824f, 0.18694901f, 0.23100416f, 0.08955360f, 0.05661964f, -0.05216251f, 0.25560632f, 
    0.12620440f, 0.03012313f, 0.19226119f, -0.01760797f, 0.12471248f, 0.16390724f, 0.09702864f, -0.15288141f, 
    0.04264257f, 0.02935816f, 0.10929221f, 0.14606397f, 0.19050306f, 0.02299912f, 0.06572866f, -0.14616846f, 
    -0.06897111f, -0.07698247f, 0.02598671f, -0.08870241f, 0.03739183f, -0.03020877f, -0.06625526f, -0.00226264f, 
    -0.07602751f, -0.07360360f, -0.03764364f, 0.01281961f, -0.09648037f, 0.05256158f, 0.03126686f, -0.05234522f, 
    -0.00352679f, -0.07088589f, -0.07433341f, 0.06571921f, -0.00161574f, -0.09424895f, 0.03064852f, 0.06795302f, 
    -0.03539718f, -0.04009847f, -0.07600297f, 0.00408403f, 0.06614153f, -0.02624201f, -0.05614712f, -0.07191105f, 
    0.00128701f, 0.03274336f, 0.04839042f, -0.07666591f, -0.04979294f, -0.03729523f, -0.01142301f, 0.05760375f, 
    -0.04969251f, -0.01535253f, -0.00225878f, -0.03728841f, -0.01534848f, -0.04091325f, -0.03778541f, -0.00983102f, 
    -0.05830598f, -0.05698867f, 0.03290039f, 0.07499722f, -0.07253622f, -0.00906038f, -0.08333236f, 0.05465740f, 
    0.08134539f, -0.09467345f, -0.02681972f, 0.05044734f, -0.09123682f, -0.00191905f, -0.02472306f, 0.02358120f, 
    -0.00857621f, 0.06691899f, 0.03867648f, 0.00031549f, 0.07109714f, 0.02830001f, -0.05335179f, 0.00095363f, 
    -0.06788230f, 0.02614389f, 0.01043397f, -0.07711285f, -0.01403131f, -0.01687077f, 0.06412356f, -0.02928876f, 
    0.02960931f, -0.03205813f, 0.04747030f, 0.06548736f, 0.00160063f, -0.02599825f, -0.02693597f, 0.03483284f, 
    0.01509221f, 0.03369084f, -0.02706772f, -0.04248014f, -0.04283854f, -0.00467156f, 0.05742411f, -0.08668074f, 
    -0.03929441f, 0.03552620f, -0.03296316f, -0.08420795f, 0.03577618f, -0.07045379f, 0.02368923f, -0.04832095f, 
    -0.05986001f, -0.05937516f, -0.07208406f, -0.07886148f, -0.01556628f, -0.02136749f, -0.06258516f, -0.07540124f, 
    -0.04175889f, -0.09574402f, -0.00150935f, 0.00940059f, -0.05723887f, -0.07761155f, 0.05234047f, -0.07213844f, 
    0.04049148f, -0.04009846f, -0.03220062f, 0.05926626f, 0.02377703f, -0.03661538f, -0.05727253f, -0.06515201f, 
    0.00146245f, -0.09347267f, 0.06593867f, 0.04137054f, 0.03142174f, -0.00137698f, -0.01408102f, 0.02918576f, 
    -0.01174473f, -0.01643057f, -0.05262659f, 0.01228740f, -0.07925238f, -0.05719869f, -0.05202046f, -0.03434046f, 
    -0.25174123f, -0.57232106f, 0.02826847f, 0.15466626f, 0.18705058f, 0.10634588f, 0.11125374f, 0.14837439f, 
    0.09643093f, 0.00585094f, 0.30432892f, 0.98800921f, 0.36767155f, -0.23522167f, 0.26063213f, -0.10000896f, 
    0.09006408f, -0.00565443f, -0.31640476f, 0.29502985f, 0.32606569f, 0.09033522f, 0.02385002f, -0.13615009f, 
    -0.06358260f, -0.30305713f, -0.41146070f, -0.17239867f, -0.05626107f, -0.08319269f, 0.15036532f, 0.08415287f, 
    0.18609035f, 0.29289261f, -0.12329040f, -0.12551598f, -0.00447518f, 0.04210427f, -0.06088021f, 0.24516624f, 
    0.03716392f, 0.05312981f, 0.09770928f, 0.30179405f, 0.30217361f, 0.19322719f, 0.27027160f, -0.18341880f, 
    0.14621831f, 0.11183022f, 0.05448205f, 0.29014161f, 0.06197426f, -0.08380092f, -0.03803297f, -0.09809494f, 
    0.12367376f, 0.20507148f, 0.18348517f, 0.17368418f, 0.02440313f, 0.07913842f, 0.27652052f, -0.03586074f, 
    -0.10338007f, 0.17047845f, -0.13887033f, -0.01088174f, -0.10758156f, 0.34592542f, 0.26546177f, 0.52726179f, 
    0.01427696f, -0.03416288f, -0.00650602f, 0.50541502f, 0.39187351f, 0.12313132f, -0.00005919f, 0.19456090f, 
    -0.09755314f, 0.06797726f, -0.06314737f, -0.42925873f, 0.11064359f, -0.10183896f, -0.10288402f, -0.36935946f, 
    -0.36821094f, -0.35860443f, 0.11755425f, 0.34676138f, 0.47676545f, 0.02695864f, 0.08470000f, 0.10465503f, 
    -0.33564055f, 0.17558622f, 0.31710193f, 0.46473885f, 0.35927662f, 0.35021064f, 0.49024022f, 0.03524143f, 
    -0.29283452f, -0.16039629f, -0.11429696f, 0.42406109f, -0.31999314f, -0.28943753f, -0.18105474f, 0.15534903f, 
    -0.03839149f, 0.07856201f, -0.20532387f, -0.35067236f, -0.68262929f, 0.16463090f, 0.17703812f, -0.00365736f, 
    0.08775408f, -0.02061952f, 0.18067591f, -0.13660407f, 0.32876721f, 0.02565305f, -0.02517171f, -0.45073801f, 
    -0.30070603f, -0.08840186f, 0.08387633f, 0.16348220f, -0.82588804f, -0.15594187f, -0.62010723f, 0.19449368f, 
    -0.17843652f, 0.40863362f, -0.05731983f, 0.15095118f, 0.04025785f, -0.32176757f, 0.05663677f, 0.19053158f, 
    0.31024191f, -0.42122447f, 0.11677495f, -0.12682839f, 0.14877883f, 0.16891254f, 0.10752366f, -0.02090989f, 
    0.02297509f, -0.43334910f, 0.14614348f, -0.39000744f, 0.28094184f, -0.27581131f, 0.07158889f, 0.19944215f, 
    -0.19258586f, -0.00037880f, 0.12173755f, 0.09877411f, -0.00305129f, 0.19790821f, -0.09013670f, 0.22994860f, 
    0.02135025f, -0.03379490f, 0.00706513f, 0.07333315f, 0.09693194f, 0.02874477f, 0.09425636f, -0.00843041f, 
    0.01631262f, 0.09664328f, -0.03497330f, 0.18210745f, 0.63029367f, 0.02518071f, 0.36124703f, -0.15927224f, 
    0.07114803f, -0.21426412f, -0.05206340f, -0.04597088f, -0.19012338f, 0.54781914f, 0.05841621f, -0.19583850f, 
    -0.25561124f, -0.04655837f, -0.08855498f, 0.05605158f, -0.04437818f, 0.11590900f, 0.21842186f, -0.00883532f, 
    0.05207665f, 0.24979469f, -0.27594718f, -0.20866844f, 0.16336808f, 0.13155261f, 0.18821877f, -0.12407663f, 
    0.03953771f, -0.35569301f, 0.17886952f, -0.07130660f, -0.11708577f, 0.30911738f, 0.21827520f, -0.00291743f, 
    -0.48889887f, -0.44276309f, -1.33477604f, 0.10389291f, 0.10802381f, 0.08626400f, 0.20205529f, -0.21819712f, 
    -0.01484751f, 0.12218837f, -0.02334323f, -0.21024606f, -0.19679499f, -0.32194972f, -0.03548595f, -0.06241475f, 
    -0.01824782f, -0.08600572f, -0.05827596f, -0.07927713f, -0.27139565f, 0.35846403f, 0.01820023f, -0.02725532f, 
    0.12058495f, 0.16273573f, 0.04489977f, -0.23149800f, 0.17426860f, -0.54340839f, -0.25554109f, 0.03309356f, 
    0.10369714f, 0.23025301f, 0.12944639f, 0.02942796f, 0.37812245f, 0.38859072f, 0.28375125f, -0.02867755f, 
    0.01577300f, 0.04256992f, -0.08018936f, -0.05763096f, 0.03932700f, -0.32610524f, -0.66031963f, -0.08935311f, 
    0.19028993f, -0.07778664f, -0.21961823f, -0.06647887f, -0.03096941f, -0.12092911f, -0.22735137f, -0.24891102f, 
    0.17118609f, 0.03113678f, 0.27028763f, -0.23633142f, 0.14048810f, 0.08182523f, 0.06145906f, 0.46570235f, 
    -0.54909921f, 0.15080823f, -0.03551674f, 0.25459105f, -0.19908547f, 0.14814009f, 0.25744116f, 0.12484600f, 
    -0.02521093f, -0.05629342f, -0.02872238f, -0.06256228f, -0.00050443f, 0.03887378f, -0.06564862f, -0.08428919f, 
    -0.02106167f, 0.06344135f, -0.06781933f, 0.03384625f, -0.05798763f, 0.06709345f, -0.05331548f, -0.07377834f, 
    -0.06989340f, 0.01997880f, 0.04307728f, -0.05430387f, 0.00544751f, -0.08395950f, -0.00813572f, -0.02552958f, 
    0.00564981f, 0.03529727f, -0.05884157f, 0.07737776f, -0.06029578f, -0.07183952f, 0.05255698f, 0.07437555f, 
    -0.01077727f, 0.07276980f, 0.04810447f, 0.06750797f, 0.01200228f, -0.05739648f, -0.09082814f, -0.04385630f, 
    0.04152737f, -0.09039315f, 0.06990505f, -0.02834857f, 0.01586934f, 0.06292167f, 0.06798241f, -0.07549341f, 
    -0.01727146f, 0.07223118f, -0.07281684f, -0.04350336f, 0.04971632f, -0.02218593f, 0.04872327f, 0.03908325f, 
    0.00837017f, -0.06441145f, 0.05086122f, -0.06009419f, 0.06120978f, -0.01743235f, -0.02833631f, -0.03263912f, 
    0.02514736f, -0.04165628f, -0.02682843f, 0.00577806f, -0.03111994f, -0.06686091f, -0.00353937f, -0.02255991f, 
    0.02805794f, 0.00085862f, -0.08077031f, -0.08949876f, -0.02138262f, -0.04329869f, 0.03797007f, -0.00364033f, 
    -0.03364308f, -0.02038333f, 0.06224592f, -0.04521204f, -0.08080736f, 0.05703125f, 0.01475167f, -0.05358337f, 
    0.05975400f, -0.02516478f, -0.04454029f, -0.02658959f, 0.06562743f, 0.03776943f, 0.06318484f, -0.02057818f, 
    -0.00232488f, 0.04812423f, -0.07574286f, -0.01378101f, 0.07246694f, -0.05855678f, 0.06878249f, -0.02166499f, 
    -0.05008986f, -0.05651454f, -0.08796109f, 0.05570269f, -0.07252363f, -0.07381086f, -0.04860669f, -0.03416051f, 
    0.00615010f, -0.08371287f, 0.02132577f, -0.06787540f, 0.05169413f, -0.00113694f, -0.02038479f, 0.04770031f, 
    -0.06758387f, -0.08534999f, -0.00389466f, 0.03980749f, 0.04810688f, -0.04663566f, -0.06744677f, -0.05126036f, 
    0.04619455f, 0.02850203f, -0.06610197f, -0.01244194f, -0.03805576f, -0.07683518f, -0.08530285f, 0.04466761f, 
    -0.03390972f, 0.00191157f, -0.07355662f, -0.01273523f, 0.04460800f, 0.07352741f, -0.05374642f, -0.02919518f, 
    0.02708417f, -0.08734418f, -0.05515965f, -0.06356020f, 0.02129236f, -0.09112755f, -0.07855091f, -0.09571186f, 
    0.04257421f, -0.07254555f, -0.01756849f, -0.04387028f, -0.06559479f, 0.03227657f, 0.00688680f, 0.03885464f, 
    0.06075041f, 0.02353415f, 0.00494292f, 0.00767443f, 0.04698078f, -0.02690309f, 0.00022649f, 0.01316583f, 
    -0.06448159f, 0.03669592f, -0.03446874f, -0.05587888f, 0.06293183f, 0.03825193f, 0.03588788f, 0.05655736f, 
    0.01953648f, 0.02163906f, -0.00953651f, 0.01525172f, -0.09286762f, 0.03510047f, 0.06391945f, -0.05535685f, 
    0.04839203f, -0.06062584f, 0.00992021f, -0.05153282f, -0.03353675f, -0.04127093f, 0.02067406f, 0.04125652f, 
    0.06601205f, 0.01564135f, -0.01325231f, -0.00570315f, 0.00546304f, -0.06447751f, 0.01990330f, -0.06897895f, 
    -0.01093471f, 0.00461947f, 0.00480387f, 0.01809943f, -0.08547290f, -0.03024362f, -0.03546782f, -0.00002819f, 
    0.08330405f, 0.05197490f, 0.07023411f, 0.07460155f, 0.01747633f, -0.06160803f, -0.03414923f, 0.07098665f, 
    -0.08343067f, -0.00906300f, 0.05292059f, 0.06838175f, -0.02218465f, 0.06125453f, -0.04642316f, -0.01226063f, 
    0.03435826f, -0.03904996f, -0.01808671f, -0.06268987f, -0.05959342f, 0.01707708f, 0.01825984f, -0.01244393f, 
    -0.02276651f, -0.08269151f, 0.07312050f, -0.03613852f, -0.02556213f, 0.04837869f, 0.02017264f, -0.03645094f, 
    -0.08200851f, 0.00126197f, -0.05218147f, -0.04598171f, 0.04855872f, -0.07849231f, -0.02591940f, 0.04355882f, 
    0.06137750f, -0.04923189f, -0.07317183f, -0.02738237f, 0.04091595f, 0.06402326f, 0.02001662f, -0.02218946f, 
    0.01269676f, -0.05983415f, 0.06790928f, -0.02396198f, 0.06061900f, -0.05163986f, -0.06176032f, 0.04150052f, 
    -0.03515225f, -0.06599943f, -0.00038846f, 0.03295244f, -0.08699281f, -0.08269998f, 0.03358331f, -0.03256229f, 
    -0.04215362f, 0.00635572f, -0.01217374f, -0.06221585f, -0.00450914f, -0.05239452f, -0.08418059f, 0.00325756f, 
    0.07584698f, 0.00085750f, -0.07632359f, -0.02914400f, -0.00262235f, -0.07041923f, -0.06217648f, -0.03123768f, 
    1.13003457f, -0.40316939f, -0.51083928f, 0.17313759f, 0.14039123f, -0.08144447f, 0.04403435f, -0.10934527f, 
    -0.17926668f, -0.23807079f, -0.46641666f, -0.35670289f, -0.31798857f, 0.07469336f, 0.02358653f, 0.13386241f, 
    -0.04738670f, 0.10990652f, 0.19308096f, -0.42048752f, -0.48318768f, -0.07569173f, -0.05223661f, -0.00854713f, 
    0.02617582f, 0.11725732f, 0.25071052f, -0.40199551f, 0.32348877f, -0.56982642f, -0.06701615f, -0.08184616f, 
    -0.22403684f, -0.09962820f, 0.05709414f, 0.02458630f, -0.47046944f, -0.46557125f, -0.36714119f, -0.08614738f, 
    0.27611178f, -0.12821583f, 0.11347191f, 0.14017935f, -0.24249788f, -0.74837899f, -0.25343031f, -0.71495253f, 
    -0.02452142f, 0.09820284f, -0.41428620f, 0.06570143f, -0.03184472f, -0.07817347f, -0.31812829f, 0.05637617f, 
    0.12268771f, 0.08976062f, 0.12927601f, -0.01749201f, 0.25971192f, 0.09789066f, 0.01737277f, -0.09610763f, 
    0.22590524f, -0.10317153f, -0.14081834f, -0.22174518f, -0.07085031f, 0.02938093f, -0.25339416f, -0.25436541f, 
    -0.55057287f, -0.12143315f, 0.17926882f, -0.23708306f, -0.05544867f, 0.07045992f, 0.19399849f, -0.11333083f, 
    0.12668578f, -0.74307734f, -0.10430595f, 0.46224219f, 0.05672221f, 0.11100189f, -0.00409574f, -0.02968935f, 
    0.04078255f, 0.36765930f, 0.63359040f, 0.12435356f, -0.15479071f, 0.33193246f, 0.08540194f, 0.10890286f, 
    0.04245598f, -0.08092746f, 0.03289956f, -0.17731363f, 0.55212867f, 0.04730690f, -0.15329674f, 0.08685667f, 
    0.26777205f, 0.10802269f, 0.16950150f, 0.10754728f, -0.10912565f, 0.40574244f, 0.33107623f, -0.22048742f, 
    0.02365583f, 0.07358363f, -0.09275625f, -0.06362105f, 0.48578185f, 0.43223947f, -0.09602626f, -0.17537917f, 
    0.09534192f, 0.05072684f, -0.24991879f, 0.01585527f, -0.04243181f, 0.10613438f, -0.20201096f, 0.08088715f, 
    -0.08065959f, -0.03326868f, -0.05438126f, 0.06106929f, 0.31950378f, 0.34852579f, 0.45758727f, 0.51554245f, 
    -0.03825061f, -0.09261972f, 0.14537643f, 0.00237181f, 0.29931223f, 0.05294091f, -0.05912076f, -0.18648405f, 
    -0.11832737f, 0.35168356f, 0.28361422f, 0.04706934f, 0.13634406f, 0.03917056f, 0.06247661f, 0.11180501f, 
    0.06406077f, -0.25803652f, 0.21355864f, 0.07449288f, -0.19058517f, 0.06236643f, -0.99556321f, -0.07051340f, 
    0.09256089f, -0.08410433f, 0.11993138f, -0.41795367f, -0.17104129f, -0.00540752f, 0.36610270f, 0.06783522f, 
    0.03300176f, -0.04317172f, -0.00945962f, 0.22867355f, -0.30805832f, 0.36738148f, 0.24494155f, 0.08854453f, 
    -0.05389551f, 0.20102373f, 0.20209381f, -0.07668133f, 0.46316054f, 0.23076609f, 0.36206508f, -0.06054034f, 
    0.07518782f, 0.02278406f, 0.16458194f, 0.11952370f, 0.15896337f, 0.30994958f, 0.46075910f, 0.58688360f, 
    -0.35535997f, -0.02185380f, 0.03231759f, 0.00305805f, -0.06778657f, 0.06454928f, -0.31710449f, 0.20731185f, 
    0.02120037f, -0.09770722f, -0.05027393f, -0.15234505f, 0.15342291f, -0.23313494f, 0.04533558f, -0.11256423f, 
    -0.01143791f, 0.23235503f, -0.00854009f, 0.02096729f, -0.18261085f, 0.33962786f, 0.27691472f, 0.12952729f, 
    -0.10233083f, 0.02045053f, 0.48399714f, 0.03317183f, -0.06493936f, -0.00304095f, 0.16146950f, 0.05889245f, 
    0.37281987f, 0.06444678f, -0.01411149f, 0.15223520f, -0.03635231f, -0.43872550f, -0.32546321f, -0.03342865f, 
    0.01934104f, -0.00852648f, -0.33963481f, -0.16595320f, -0.46831238f, -0.15219769f, 0.31497452f, 0.28571531f, 
    0.09663051f, 0.06830329f, -0.34633580f, 0.02752519f, -0.65612829f, 0.03397293f, -0.17537977f, 0.01089545f, 
    0.67269892f, -0.12337177f, -0.04595786f, 0.00450669f, -0.27731082f, 0.02572898f, -0.11638372f, 0.00311111f, 
    -0.06764717f, -0.13891815f, -0.02909898f, -0.20244846f, 0.05100846f, -0.19041795f, -0.06762912f, 0.09299365f, 
    -0.12963425f, 0.16705525f, -0.07912897f, 0.31648007f, 0.15008500f, -0.05311430f, -0.45310992f, 0.08917657f, 
    -0.44037354f, -0.08115517f, -0.12581947f, 0.09265756f, -0.13277799f, -0.04907787f, 0.07269076f, -0.51920873f, 
    0.27140945f, -0.51106679f, 0.04550687f, -0.27772260f, 0.01490030f, 0.18475930f, -0.05199810f, 0.08996107f, 
    0.17683516f, 0.38465416f, 0.32869154f, 0.07828062f, 0.09408033f, -0.09379796f, 0.04825602f, 0.26708925f, 
    0.04678401f, -0.28993276f, -0.37774020f, 0.59772652f, 0.32550246f, 0.37395012f, -0.23596679f, 0.12035275f, 
    -0.04081402f, -0.06353223f, -0.45219719f, -0.06868725f, -0.24512555f, -0.02570499f, 0.23834793f, -0.06014503f, 
    0.03737970f, -0.24014354f, -0.03307470f, 0.16381079f, 0.33120722f, 0.20983307f, -0.27305189f, 0.23606153f, 
    0.16795632f, 0.11874092f, 0.24076578f, -0.16782391f, -0.46186143f, -0.20080544f, 0.25797695f, 0.03352242f, 
    0.23561914f, -0.12257042f, -0.07657989f, 0.23405315f, 0.26242214f, 0.19236036f, 0.08617526f, 0.00982932f, 
    -0.46615756f, 0.03502238f, 0.04261046f, 0.14116080f, 0.19665875f, -0.01374363f, 0.11693315f, 0.13307232f, 
    -0.39601171f, 0.16988836f, -0.12404405f, -0.14132531f, 0.21405070f, 0.09108128f, 0.04378634f, -0.03671419f, 
    0.02222480f, -0.08954826f, 0.16564099f, 0.11426110f, -0.24391139f, 0.22026955f, 0.43580195f, -0.00790839f, 
    -0.02106121f, -0.05475181f, 0.21227852f, -0.15375409f, -0.20465969f, 0.02846314f, 0.02145215f, 0.00429107f, 
    -0.32719460f, -0.08012351f, -0.81906015f, -0.78836918f, -0.09823497f, -0.20133644f, -0.16613723f, -0.35225874f, 
    -0.48806602f, -0.03378353f, 0.44953495f, 0.19838226f, 0.25355330f, -0.01822411f, 0.25110638f, 0.20937203f, 
    0.06691295f, -0.03775317f, 0.19740914f, -0.05126417f, -0.93349123f, -0.11487182f, -0.27252814f, 0.09390795f, 
    0.65908092f, -0.02772827f, 0.00662394f, 0.11046471f, -0.15823868f, -0.05110094f, -0.06230259f, -0.05625623f, 
    -0.17733669f, -0.25347477f, 0.06159317f, -0.31226897f, 0.09947232f, 0.06206650f, 0.26515689f, 0.85584956f, 
    -0.19941621f, 0.01574904f, -0.13691612f, -0.26421973f, 0.29424709f, 0.17115821f, -0.30508333f, 0.24201712f, 
    0.16886128f, -0.06578704f, -0.18571293f, -0.05856580f, -0.29217505f, -0.17304461f, 0.06246333f, 0.21353284f, 
    0.28783622f, -0.00330785f, 0.19482914f, 0.02683420f, -0.00727470f, 0.39978337f, 0.17592454f, 0.15044555f, 
    0.35623455f, -0.93728966f, -0.40633577f, -0.00269696f, 0.06706086f, 0.00607186f, -0.16941658f, -0.04462329f, 
    -0.17072092f, -1.03685892f, -0.31773689f, 0.39425719f, -0.03704660f, -0.20063628f, 0.11268720f, 0.13552962f, 
    0.00060846f, 0.13423832f, -0.35508874f, 0.07828384f, 0.19455118f, -0.04799170f, 0.13997726f, 0.34310320f, 
    0.23245578f, 0.19644338f, 0.24034709f, -0.38071325f, -0.03456979f, 0.06107521f, -0.12811881f, -0.18011999f, 
    -0.31107810f, 0.13025956f, 0.20769563f, 0.09982915f, -0.32481608f, -0.06609043f, 0.37884411f, -0.12555286f, 
    0.03804970f, -0.06637448f, 0.16025966f, 0.00342020f, 0.03216362f, -0.34636712f, 0.06783968f, 0.21597895f, 
    0.00801724f, -0.04781040f, -0.40274656f, 0.12916879f, -0.21267380f, 0.05197137f, -0.33277100f, 0.29606843f, 
    0.35969257f, -0.12025359f, -0.07778223f, -0.06038063f, 0.24572484f, 0.19215626f, 0.07985206f, -0.00656489f, 
    0.08378302f, -0.00288288f, -0.10131525f, -0.08636806f, -0.09262791f, 0.32495502f, 0.23454489f, 0.27233699f, 
    0.06243310f, -0.94738394f, -0.69606155f, -0.00871457f, -0.21406598f, -0.00558682f, 0.36388898f, -0.07263801f, 
    0.11715327f, -0.90612453f, 0.27847633f, 0.65492815f, -0.18713571f, -0.13714212f, -0.15530464f, 0.06489307f, 
    -0.03287298f, 0.23598891f, 0.38785568f, -0.63919806f, -0.53333741f, 0.22673908f, 0.02747571f, 0.41171879f, 
    0.38730630f, 0.10397627f, 0.08884083f, 0.75040442f, 0.11434503f, -0.26275256f, 0.18681118f, -0.06389038f, 
    0.14495203f, -0.08983497f, -0.08129898f, 0.16327754f, -0.26462188f, 0.47132111f, -0.11130143f, -0.10750344f, 
    -0.14716494f, -0.03964662f, 0.18179570f, 0.03846383f, 0.20449837f, -0.38476127f, -0.55344641f, -0.86719525f, 
    0.06237824f, -0.12447535f, -0.04258242f, 0.14321393f, -0.16617055f, 0.25008437f, 0.23740478f, -0.29430526f, 
    -0.29539481f, -0.12777302f, 0.17124505f, -0.02083134f, 0.15912369f, 0.00937148f, 0.23919772f, 0.03197005f, 
    -0.66567516f, -0.19574082f, -0.28209272f, 0.21081892f, 0.15742251f, 0.05352920f, 0.21413596f, -0.15421915f, 
    -0.50071895f, -0.11832619f, 0.03736309f, -0.00293268f, -0.21266173f, -0.17512986f, -0.09536337f, -0.04230724f, 
    -0.00709264f, 0.84613454f, -0.22156583f, 0.28616044f, -0.10721929f, -0.10753270f, -0.07306958f, -0.10716112f, 
    -0.02634040f, -0.04637975f, 0.26160175f, 0.43306178f, 0.59555012f, 0.30674186f, 0.35375062f, 0.10573322f, 
    0.17650761f, 0.20654996f, -0.06443757f, 0.08638189f, -0.21124794f, 0.19815814f, -0.12656885f, -0.35416579f, 
    -0.10473097f, 0.03367678f, 0.02794484f, -0.20093837f, 0.08745768f, 0.06036418f, 0.13012210f, -0.16316198f, 
    -0.07481981f, 0.10855265f, -0.10325656f, -0.32269746f, 0.23974754f, -0.30148315f, -0.17949343f, -0.02648995f, 
    0.05736754f, 0.05320592f, -0.06904188f, -0.08712249f, -0.02215320f, -0.23373836f, -0.10388502f, -0.12821849f, 
    -0.05047685f, -0.08600167f, 0.21423987f, 0.01800663f, 0.03981948f, 0.07325390f, 0.07285772f, 0.13822633f, 
    -0.07212016f, 0.21380924f, 0.05466169f, 0.05769932f, 0.14419913f, -0.25529563f, 0.24979404f, 0.02290074f, 
    -0.17837882f, -0.83359331f, -0.18255706f, 0.11526218f, -0.10651033f, -0.09945436f, 0.06691780f, 0.19758306f, 
    0.05067916f, 0.30684882f, 0.38090336f, 0.63639218f, 0.13883838f, 0.05155309f, -0.32172301f, 0.16500309f, 
    -0.00266553f, -0.05626024f, -0.24211606f, -0.35079834f, 0.01140647f, -0.22024488f, 0.10586376f, -0.02837645f, 
    0.12537770f, 0.21837819f, 0.17264000f, 0.51508433f, -0.19934440f, -0.31188819f, 0.03882280f, -0.15446515f, 
    -0.11476853f, -0.00603148f, 0.09589086f, 0.12497555f, -0.19586208f, -0.10332666f, -0.03990509f, 0.22193813f, 
    0.06802826f, -0.14759801f, 0.12157864f, -0.01518672f, -0.04244077f, -0.20111422f, -0.30907351f, 0.07703041f, 
    0.08881438f, 0.03830507f, 0.00627512f, 0.12128479f, -0.08588717f, 0.38841397f, -0.63100535f, -0.21049577f, 
    0.28876635f, 0.22594078f, 0.03986244f, -0.16517107f, 0.09763043f, -0.13456748f, 0.03975851f, -0.41485485f, 
    -0.26222965f, -0.07107885f, -0.04212547f, -0.01437888f, -0.07863197f, -0.01079727f, 0.07102872f, 0.11167005f, 
    0.03286572f, -0.26856932f, 0.19295202f, 0.24957542f, 0.05775480f, 0.05300888f, -0.06760455f, 0.02854445f, 
    -0.20691094f, -0.21795516f, -0.04656478f, 0.46233481f, -0.03173123f, -0.01790319f, -0.07225557f, 0.05664054f, 
    -0.02218378f, -0.06540367f, -0.08712982f, 0.03208574f, 0.05806455f, -0.02758439f, 0.06815005f, -0.02820444f, 
    -0.11004919f, -0.20641276f, 0.10450024f, 0.46048149f, 0.17830764f, 0.00964150f, 0.15624510f, -0.04397624f, 
    -0.12868446f, 0.01953023f, 0.00064485f, 0.18470931f, 0.39412621f, 0.26350537f, 0.28903526f, -0.05312470f, 
    0.08926126f, -0.00333774f, 0.27181008f, 0.00710240f, -0.16922916f, 0.39748102f, 0.52897787f, 0.40164179f, 
    0.27940482f, -0.05561136f, -0.14491272f, 0.05604592f, -0.17683016f, -0.20059638f, -0.07383084f, 0.06339324f, 
    -0.04103173f, -0.05251478f, 0.03546471f, 0.10620110f, -0.02465340f, -0.25029972f, 0.14438646f, 0.29527941f, 
    -0.42091927f, -0.09660266f, 0.08838488f, -0.24364217f, -0.36443257f, 0.24004190f, -0.28359413f, -0.10260979f, 
    0.13390598f, 0.63147628f, -0.27788341f, -0.08338674f, 0.08046997f, 0.17561698f, -0.00274009f, 0.12732071f, 
    0.10761772f, -0.17780274f, 0.35760599f, -0.02823735f, 0.10109347f, 0.06968330f, 0.06996202f, 0.19877994f, 
    0.02507434f, 0.48412353f, -0.23502551f, -0.28802544f, -0.67841572f, 0.10110307f, -0.08789459f, 0.05180403f, 
    0.11407416f, -0.15379559f, -0.22778034f, -0.42447558f, 0.54813278f, -0.35147792f, -0.06885632f, 0.12900361f, 
    0.30648404f, -0.02027130f, 0.12364318f, -0.06073747f, -0.17677473f, -0.38625768f, -0.34973964f, -0.08145477f, 
    -0.26952896f, 0.09973745f, -0.19576608f, -0.16022971f, 0.32994649f, 0.13628739f, 0.03259900f, -0.06952816f, 
    0.27391547f, -0.19782083f, -0.18882933f, 0.03192534f, -0.07367206f, -0.05964865f, 0.19320577f, 0.24634330f, 
    -0.36736289f, -0.05430359f, -0.05149902f, -0.08799090f, 0.11377639f, -0.13679379f, 0.23740573f, -0.15962613f, 
    -0.04520609f, -0.59188604f, -0.06306382f, -0.03176022f, 0.09108179f, -0.17318770f, 0.09639902f, -0.14886184f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.10742765f, 0.19665056f, -0.16742805f, 0.20503627f, 0.06524535f, -0.08542415f, -0.06102474f, 0.41406447f, 
    -0.04242174f, -0.02462123f, 0.48324016f, -0.12373078f, 0.27304360f, 0.73604494f, 0.18505752f, -0.20643419f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01089344f, -0.52211088f, 0.70994771f, 0.60762560f, 0.38309267f, -0.24145627f, -0.16151291f, -0.06084990f, 
    0.14258108f, 0.23072782f, 0.19212042f, 0.14716235f, -0.54983956f, -1.05416417f, 0.33683464f, 0.09131048f, 
    -0.51098490f, -0.41874942f, 0.69120246f, 0.25753853f, 0.31567347f, 0.11513326f, 0.17027855f, 0.13513926f, 
    -0.09642328f, 0.06765690f, 0.06756324f, -0.30620146f, 0.18372087f, -0.01548721f, 0.44690281f, -0.50368142f, 
    0.35450777f, 0.35935080f, -1.07346058f, 0.11722690f, 0.04187354f, -0.15792726f, -0.10710414f, -0.67286116f, 
    0.23174356f, 0.12473560f, -0.08994057f, -1.01888680f, -0.75941801f, 0.63677227f, 0.78076518f, -0.17976831f, 
    0.43613431f, 0.54792255f, -0.40218577f, 0.25474054f, 0.37359956f, -0.15223069f, -0.31627521f, 0.27838397f, 
    -0.13239504f, -0.22539331f, -1.42588365f, 0.35677561f, -0.73722744f, -0.77805692f, 0.17185807f, -0.06990077f, 
    -0.04210621f, -0.20080039f, -0.01746671f, -0.78977066f, 0.45670262f, 0.07804973f, -0.29169208f, 0.03934008f, 
    0.00110011f, -0.13724983f, -0.14397030f, 0.43970180f, -0.09141251f, 0.30881175f, 0.20345984f, 0.54276401f, 
    -0.43327978f, 0.01509349f, 0.18610275f, -0.18973476f, 0.16516793f, 0.19139028f, 0.34335917f, 0.63905865f, 
    -0.05751995f, -0.21577546f, -0.54505342f, -0.77983952f, 0.29575062f, 0.37436810f, -0.22991370f, 0.37649077f, 
    0.46027455f, -0.28230146f, -1.23691678f, -0.06901520f, -0.22913565f, 0.04400984f, -0.32486126f, -0.55304164f, 
    -0.09714096f, -0.13495693f, 0.99303651f, -0.51190293f, -0.65827352f, 1.05121803f, -1.17543828f, -0.64143533f, 
    -0.07593418f, 0.59324342f, -0.58575457f, 0.12041819f, -0.10171989f, -0.09803499f, -0.09110706f, -0.63502818f, 
    0.18768781f, 0.01695099f, -0.14980760f, -0.25646463f, 0.40057382f, -0.14007832f, -0.91877735f, 1.08674932f, 
    -0.66978502f, -0.11507715f, -0.99347627f, 1.01707840f, -0.54614711f, 0.09880466f, 0.60369027f, 0.02681955f, 
    0.09032591f, -0.08154178f, 0.48264629f, 0.21650845f, 0.13446128f, -0.02661336f, -0.67309111f, -0.18449561f, 
    0.19801985f, 0.29871479f, -0.92179567f, -1.13039160f, 0.22836865f, -0.22613229f, -0.55583203f, 1.02732170f, 
    -0.09137050f, 0.17455176f, 0.06395679f, 0.24316283f, -0.27209434f, 0.51204306f, -0.25716394f, -0.52105445f, 
    -0.29716814f, 0.25314152f, -0.47505105f, -0.09155428f, -0.29554886f, 0.20542681f, 0.56022382f, -1.18895018f, 
    0.13517036f, 0.19351707f, -0.82258618f, 1.00365996f, 0.18550299f, -0.02722857f, 0.15423922f, -0.77921051f, 
    0.45796451f, -0.21634831f, -0.74021506f, -0.68947011f, -0.71791613f, -0.21658602f, -0.04583222f, -0.11170481f, 
    -0.11694908f, -0.05464740f, 0.15776224f, 0.44475245f, 0.64855480f, -0.14442569f, -0.68585503f, -1.22061753f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -1.08692038f, 0.65235507f, 0.15802117f, 0.00941943f, -0.45856935f, -0.11489178f, 0.15156092f, -0.97319067f, 
    -0.01986199f, 0.45747948f, -0.31673029f, 0.20281118f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
