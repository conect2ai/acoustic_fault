#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.87356055f, -0.06550072f, 0.35400707f, 0.94639874f, 0.68089068f, 0.58349228f, -0.73593169f, -0.03116211f, 
    0.27293035f, -0.10833482f, 0.48106304f, 0.10962451f, -0.33782530f, -0.02563515f, 0.02731276f, 0.36974713f, 
    0.10831143f, 0.18599680f, 0.13696921f, 0.36994365f, 0.01835799f, -0.09264252f, 0.32586145f, -0.08049229f, 
    0.25132531f, 0.11654946f, 0.29487273f, 0.61632031f, 0.63769126f, -0.54345894f, 0.00459747f, 0.11924386f, 
    0.15641604f, -0.56714880f, 0.55742985f, 0.49176785f, 0.36751181f, -0.37448460f, 0.03825340f, -0.32871836f, 
    0.22665478f, 0.09512532f, 0.41464040f, 0.20349805f, -0.06265844f, 0.17122528f, 0.09374393f, 0.34979162f, 
    0.28003412f, -0.57946551f, 0.61842430f, -0.63969541f, 0.90976471f, 0.30338448f, 0.06684218f, 0.57246536f, 
    -0.22730193f, 0.58914322f, 0.51874554f, -0.25470233f, -0.36947131f, -0.22818847f, -0.04802617f, 0.38509512f, 
    0.08130327f, 0.39643773f, 0.07499003f, -0.01115883f, -0.12751876f, -0.18086432f, -0.30140132f, -0.02279072f, 
    0.31841508f, 0.13285992f, -0.03773867f, 0.72547358f, -0.14517306f, -0.80535483f, -0.85043550f, 0.05274384f, 
    0.04781453f, -0.27509579f, 0.06593453f, -0.07133608f, -0.00956366f, 0.17993385f, 0.05006141f, 0.40327257f, 
    0.29801074f, -0.19763501f, 0.24727167f, -0.14448592f, 0.01429105f, 0.40285733f, 0.32785982f, -0.05846422f, 
    0.14951585f, 0.32942262f, -0.15056938f, 0.32699949f, 0.26910800f, 0.66248184f, 0.46239817f, 0.28885248f, 
    0.66062790f, 0.26954818f, 0.32987943f, 0.14726263f, 0.41671297f, 0.43242532f, -0.25396556f, 0.10561255f, 
    -0.03912499f, -0.07630165f, 0.02085223f, 0.32212338f, 0.14107400f, 0.24280649f, -0.27724135f, -0.29974771f, 
    -0.11561016f, -0.52356988f, 0.26017776f, 0.22912350f, -0.11291797f, 0.66035473f, 0.50696194f, 0.58214360f, 
    0.19782242f, 0.46750978f, -0.25368300f, -0.21466629f, 0.04040548f, 0.24699110f, 0.37623838f, -0.22973733f, 
    0.45501006f, -0.21149635f, -0.28288940f, -0.21061818f, 0.28129658f, 0.05641393f, -0.32747692f, -0.19691795f, 
    -0.01256325f, -0.25049049f, -0.11039378f, 0.55410212f, -0.01536333f, 0.05395262f, 0.54078567f, 0.64713740f, 
    0.15219192f, 0.39755288f, 0.72479856f, 0.41483960f, 0.35213792f, 0.08071656f, 0.05689787f, -0.40291962f, 
    0.22607855f, -0.27870086f, -0.17542228f, -0.07593551f, 0.10829785f, 0.26658180f, 0.24227272f, -0.11312333f, 
    -0.20465513f, 0.17827921f, 0.24090847f, 0.30086464f, 0.27796063f, 0.23279199f, 0.43157676f, 0.62681013f, 
    0.26895335f, -0.25276464f, -0.73635846f, -0.51325935f, 0.52278775f, -0.32947972f, 0.18503857f, 0.29621917f, 
    -0.16599052f, -0.23245497f, 0.03797251f, 0.04076329f, 0.13742498f, -0.05966768f, 0.11135490f, 0.07978614f, 
    0.53372830f, 0.35854977f, 0.16917069f, -0.18480906f, 0.17764515f, 0.28716132f, -0.11933599f, 0.10522713f, 
    -0.47025737f, 0.26085621f, -0.70691234f, 0.55743253f, 0.32127896f, -0.64953744f, 0.66748041f, 0.06070198f, 
    0.07982441f, -0.51022589f, 0.33531550f, -0.20339999f, -0.06253739f, -0.18016252f, 0.37489504f, 0.12280414f, 
    0.21365888f, -0.18989249f, 0.06222888f, -0.17128581f, 0.01161295f, 0.17725044f, -0.18702948f, 0.60232478f, 
    -0.31102049f, -0.49556124f, 0.50700051f, 0.49389997f, -0.63379985f, 0.90342623f, 0.44129047f, 0.30763716f, 
    0.17354812f, -0.65405589f, -0.56304324f, 0.26742980f, 0.00352247f, 0.21070379f, 0.03420981f, -0.22731993f, 
    0.21570598f, 0.00443583f, 0.20282766f, -0.04325108f, 0.00959397f, -0.09020458f, 0.06205926f, 0.08658532f, 
    0.06079039f, 0.46748734f, -0.42445686f, 0.26739544f, 0.00492583f, -0.48742428f, -0.25024557f, 0.73312283f, 
    -0.56215805f, -0.35448262f, -0.85344499f, -0.43073565f, 0.25097963f, -0.27982882f, 0.34802169f, 0.16084434f, 
    -0.18886136f, -0.08164775f, -0.11087004f, 0.31173223f, 0.16513385f, 0.13635701f, 0.22353494f, -0.10479315f, 
    -0.07053766f, 0.02716837f, -0.16316640f, -0.71228039f, -0.97790003f, -0.61056358f, -0.00144693f, 0.50590116f, 
    0.51731366f, 0.62144321f, 0.24664976f, 0.12977269f, -0.16947524f, -0.04734252f, -0.28172341f, -0.22096334f, 
    -0.48495528f, 0.35403338f, 0.13615087f, 0.34960583f, -0.14281772f, -0.15001173f, 0.06081034f, -0.39385724f, 
    -0.04371173f, -0.01627559f, -0.27830747f, -0.17972119f, 0.65992969f, 0.88909447f, -0.67678851f, 1.10105813f, 
    -0.16940790f, 0.42462626f, -0.46083599f, -0.54108894f, -0.32403120f, 0.04803481f, 0.37443069f, 0.37208965f, 
    0.20833831f, -0.00984248f, 0.03230310f, -0.13463433f, -0.42490986f, 0.15162684f, -0.22626050f, -0.08732111f, 
    -0.45953250f, 0.27234676f, 0.03642023f, 0.02083612f, 0.11250308f, 0.13496526f, 0.77570945f, 0.56138211f, 
    0.31052497f, 0.39303613f, 0.36796385f, 0.09240136f, -0.13347153f, 0.07234398f, 0.41211444f, -0.41018119f, 
    0.08925158f, 0.12399396f, -0.48505199f, -0.37976101f, -0.41860831f, 0.09310263f, 0.06610140f, -0.35587144f, 
    0.03690299f, 0.12009294f, 0.22240514f, 0.08947552f, -0.27321005f, 0.10465296f, 0.25835547f, 0.11812737f, 
    0.17216158f, 0.16355947f, 0.25572985f, 0.13816178f, -0.54830056f, 0.17854761f, 0.10755051f, 0.44897413f, 
    0.15778004f, -0.35106444f, -0.03219844f, -0.32589003f, 0.33305016f, 0.26240653f, -0.41137889f, -0.18198088f, 
    -0.41681391f, 0.18654248f, -0.25712347f, -0.23126338f, 0.34803629f, -0.27504742f, -0.48104250f, -0.84066653f, 
    0.32514107f, 0.66406256f, -0.81877065f, -0.21435471f, 0.75631601f, -0.03329339f, -0.38234583f, 0.37672698f, 
    -0.26861125f, 0.41424611f, 0.01711123f, 0.35634997f, 0.31686446f, -0.46628255f, -0.00434566f, -0.30672130f, 
    -0.20596421f, -0.42202318f, -0.20753278f, 0.10715823f, -0.24022964f, -0.03809929f, -0.15749058f, -0.23581661f, 
    -0.63703334f, -0.23711173f, -0.13818470f, 0.35395080f, 0.18173558f, -0.65963829f, -0.31097546f, -0.30496481f, 
    -0.54290164f, -0.44947505f, -0.05517535f, 0.40231696f, 0.44512057f, 0.33975169f, 0.24681570f, 0.35563549f, 
    -0.34675491f, 0.06418388f, -0.32711560f, -0.28460684f, 0.05105107f, -0.00395364f, -0.10749605f, -0.14132671f, 
    -0.31605461f, 0.88891149f, 0.53533852f, -0.72299463f, -0.70775819f, 0.41595668f, 0.69114292f, -0.31242678f, 
    0.28989729f, 0.45860261f, 0.45720953f, 0.18788907f, 0.12430146f, -0.15851976f, -0.12316716f, -0.04999958f, 
    -0.20075923f, 0.01805997f, -0.04280593f, -0.04974951f, 0.17800328f, 0.12775172f, -0.12533411f, -0.00583891f, 
    0.18517947f, 0.07544345f, 0.84516871f, 0.36093828f, -0.10490929f, 1.06345236f, 0.61114860f, 0.36825067f, 
    -0.28048342f, -0.53891355f, 0.60924989f, -0.22981414f, -0.48417634f, -0.24323136f, 0.17615589f, 0.12065305f, 
    -0.01220384f, -0.11893129f, 0.06279190f, 0.01232238f, -0.12891531f, 0.29134154f, -0.14019124f, -0.21393014f, 
    -0.26613817f, -0.02291634f, 0.16116798f, 0.07952566f, 0.43946832f, 0.23348506f, 0.12473259f, 0.79818964f, 
    0.04959661f, 0.44879484f, 0.90137798f, -0.03007498f, -0.41468781f, -0.54042673f, -0.47341031f, -0.28761154f, 
    -0.06734715f, -0.15197609f, -0.09328408f, 0.15931493f, 0.20064515f, 0.10970624f, -0.01529390f, -0.11201058f, 
    0.24573822f, -0.31808046f, 0.23550515f, -0.25012806f, -0.76467443f, -0.19817615f, -0.64274710f, -0.45896459f, 
    -0.04540801f, -0.08089443f, 0.91174424f, 0.43134767f, 0.09795961f, 0.52142441f, -0.01060123f, -0.24123061f, 
    0.19708121f, -0.21749994f, 0.11647007f, 0.03583711f, -0.05263839f, -0.04878029f, 0.14662515f, -0.21148285f, 
    0.12443875f, 0.02134673f, -0.07601011f, -0.05224669f, 0.10137536f, -0.31255168f, -0.23503000f, -0.05372935f, 
    0.26093322f, -0.09866183f, -0.35905990f, -0.14546864f, -0.13994579f, -0.15041743f, -0.16238523f, 0.31997192f, 
    0.11728027f, -0.06968995f, -0.10957126f, -0.34431416f, 0.45492348f, -0.04046395f, -0.56687218f, -0.35227895f, 
    0.45388341f, -0.32861254f, -0.52709949f, 0.45964921f, -0.20476192f, -0.36594990f, -0.30790195f, 0.34877872f, 
    0.26008189f, -0.49098253f, -0.33503541f, 0.38792899f, 0.13431415f, -0.86868972f, 0.30788854f, 0.07572438f, 
    0.01271768f, -0.11787599f, 0.26842692f, -0.50687695f, 0.48122853f, -0.07069377f, -0.35031739f, -0.00298579f, 
    -0.38351086f, -0.39742640f, 0.09148517f, -0.08991998f, -0.32741031f, 0.44422862f, -0.21729629f, 1.12144697f, 
    0.74302661f, -0.33934817f, 0.01776246f, -1.09669602f, -0.34082875f, -0.01907283f, 0.25207821f, 0.11667515f, 
    0.21079464f, 0.30301327f, 0.23068948f, 0.09523109f, 0.05805437f, -0.07739054f, -0.01250611f, 0.06610599f, 
    -0.14640658f, -0.08535249f, 0.03819362f, -0.08155615f, 0.02475203f, -0.11703059f, 0.24173611f, -0.02207493f, 
    -0.09647122f, -0.21863107f, -0.59952384f, -0.74974692f, -0.32464695f, -0.45742059f, -0.19112279f, -0.24554746f, 
    0.26109019f, -0.16407639f, -0.04839445f, -0.20185752f, -0.21885745f, 0.25608110f, -0.01253674f, 0.05551147f, 
    0.29363263f, 0.21178821f, -0.08809274f, 0.27624616f, 0.36519298f, -0.02951142f, 0.09572849f, 0.17848971f, 
    0.17035066f, -0.62623620f, 1.04725194f, 0.74857140f, -0.32323074f, -0.01530149f, -0.79291362f, 0.72895920f, 
    -0.24752311f, -0.52798438f, -0.37538141f, -0.11877099f, 0.28422895f, 0.21322753f, 0.01946003f, 0.13212885f, 
    -0.02416477f, -0.12694353f, -0.16191441f, 0.05183477f, -0.14068799f, -0.00435095f, 0.19614990f, 0.20298932f, 
    0.11261818f, 0.26390594f, -0.68380088f, 0.91468298f, -0.19387595f, -0.75056809f, 0.73465157f, 0.07118283f, 
    -0.57862556f, -0.41150072f, 0.32976812f, -0.23388943f, 0.25982657f, -0.28673738f, -0.54086572f, 0.17846164f, 
    -0.00608841f, 0.06672699f, 0.06723859f, -0.44701505f, -0.07353137f, -0.21133725f, -0.12375811f, 0.24005635f, 
    0.05398521f, 0.21854348f, -0.26217398f, -0.43908387f, 0.18533787f, -0.11182456f, -0.61727148f, -0.24606980f, 
    0.37155095f, 0.02894357f, 0.16937838f, 0.50674415f, 0.50860047f, 0.12533869f, 0.19301869f, 0.32528761f, 
    0.10621257f, -0.17489280f, 0.49663192f, 0.35610679f, 0.10718194f, 0.30086762f, -0.01372232f, -0.16737445f, 
    -0.37150750f, 0.10414959f, 0.06637114f, -0.07435066f, -0.39669433f, -0.29303277f, 0.13657637f, -0.41988999f, 
    0.32568270f, -0.45166931f, -0.06350552f, 0.01632970f, 0.18671498f, -0.55319637f, -0.46609446f, -0.20673701f, 
    0.29575339f, -0.29631457f, -0.07308996f, -0.22324701f, -0.11373992f, -0.40610230f, -0.39523596f, -0.39652297f, 
    0.26159137f, -0.12940675f, 0.34965703f, 0.19142480f, -0.00565608f, 0.02722653f, 0.53683597f, 0.25983509f, 
    0.32223931f, -0.84832168f, -0.51996636f, 0.25389016f, 0.23556803f, -0.24833031f, -0.49574566f, 0.30662060f, 
    0.37108296f, -0.27954331f, 0.01886033f, 0.02748881f, -0.02480077f, 0.25175506f, -0.06161280f, 0.39120504f, 
    -0.20324026f, -0.05380245f, -0.36560366f, -0.18690081f, -0.19931129f, 0.07234997f, -1.13840735f, 0.69287515f, 
    -0.01874394f, 0.14141586f, 0.79025799f, 0.27230468f, 0.79548603f, -0.31338447f, -0.35403356f, 0.12707880f, 
    -0.31522682f, -0.44032151f, 0.36961380f, -0.01585128f, 0.09874573f, -0.02076964f, -0.01712042f, -0.26116824f, 
    0.11676375f, -0.03363287f, 0.37088880f, 0.10596327f, -0.15492713f, 0.00558045f, -0.14878167f, -0.73703200f, 
    -0.47610018f, -0.57685769f, -0.24192755f, -0.45292157f, 0.06920958f, -0.22777279f, 0.09405932f, 0.46839562f, 
    0.13169503f, 0.26778638f, -0.14628109f, 0.12053334f, -0.16153792f, -0.11891546f, -0.25098744f, 0.17943802f, 
    -0.18471083f, -0.19104376f, -0.35292381f, -0.30460447f, 0.11300308f, 0.30019403f, 0.04499584f, 0.10786092f, 
    -0.74899298f, -0.36435536f, -0.48254749f, -0.39854315f, -0.47030926f, 0.42695644f, -0.14605480f, -0.28581077f, 
    0.40009505f, 0.20349725f, -0.38502669f, 0.14095536f, 0.31092867f, -0.03903734f, -0.04193214f, 0.13102378f, 
    0.06279834f, 0.19906227f, 0.17863226f, 0.16842489f, 0.01855524f, -0.49997890f, -0.51246768f, -0.32838959f, 
    -0.02177951f, 0.33992600f, 0.52437711f, -1.00459301f, 0.13794550f, 0.08999221f, -0.40977386f, 0.00554843f, 
    0.40315992f, 0.43596163f, -0.42674682f, -0.03187717f, -0.43747351f, 0.11320928f, -0.12918724f, -0.18654738f, 
    0.40157977f, -0.27500570f, 0.09955832f, -0.41444671f, 0.08067896f, 0.32085177f, 0.06647602f, 0.30316499f, 
    0.32913250f, 0.45067427f, -0.13007823f, -1.12089336f, -0.23209859f, 0.69786268f, -0.16466409f, -0.40228835f, 
    1.06345809f, 0.68435520f, -0.70510554f, 0.22749233f, 0.37608534f, -0.06340477f, 0.06977282f, -0.11171164f, 
    -0.10449500f, -0.39824241f, 0.14392340f, -0.23623237f, -0.13974218f, -0.26000789f, 0.12697212f, 0.01404864f, 
    0.03401685f, -0.03095691f, 0.17650487f, -1.12485492f, 0.20236109f, 0.98865801f, -0.03543372f, 0.04791328f, 
    0.25509223f, -0.02583778f, 0.34674531f, 0.42122081f, -0.43919632f, -0.01273724f, 0.09964503f, -0.33758092f, 
    0.40416378f, 0.00857814f, 0.31734100f, 0.16951600f, 0.02211557f, -0.17031360f, 0.15795060f, -0.11385089f, 
    0.14729092f, 0.01981451f, 0.07031950f, -0.05252976f, 0.06986394f, 0.85192955f, 0.47040927f, 0.61671519f, 
    0.44058618f, -0.79217607f, -0.55369461f, -0.12681375f, -0.58387893f, -0.04278746f, 0.26353157f, 0.27157405f, 
    -0.22766489f, -0.07085894f, 0.35290697f, 0.18624131f, -0.16700056f, 0.15805610f, -0.06007162f, 0.44456005f, 
    0.37899274f, 0.22770321f, 0.01005074f, 0.18927325f, 0.24199143f, 0.31946003f, -0.01155578f, 0.45927715f, 
    0.93259561f, 0.56418622f, -0.28233060f, 0.31745356f, 0.52142715f, 0.38256243f, -0.14621469f, -0.47215316f, 
    -0.22652468f, -0.16480468f, 0.25147310f, -0.20189269f, -0.24895446f, -0.11573472f, 0.03862254f, 0.38293174f, 
    -0.00901135f, 0.19737886f, -0.07179891f, -0.26633230f, -0.16827418f, 0.02103390f, -0.78180659f, -0.20323616f, 
    0.63279003f, -0.09684309f, 0.34918129f, -0.00867150f, 0.64002860f, 0.62360901f, 0.28846991f, 0.43283698f, 
    -0.38339272f, 0.06038777f, -0.21041629f, -0.16980192f, -0.20621428f, 0.11088713f, -0.28612056f, -0.03177673f, 
    0.08645193f, 0.40953100f, -0.14049172f, -0.12164140f, -0.14696021f, -0.13466540f, 0.07522508f, 0.27722499f, 
    -0.25617364f, -0.66058844f, 0.10052847f, -0.25868577f, -0.85063410f, -0.20794287f, 0.20030856f, -0.54561675f, 
    0.10465822f, 0.06621690f, 0.38700831f, 0.40906841f, -0.33004597f, 0.34131485f, -0.43028215f, -0.07048119f, 
    -0.04888042f, -0.10627412f, -0.09579271f, 0.36134219f, -0.25722671f, 0.08837340f, 0.35677934f, 0.19778034f, 
    -0.70599037f, 0.73361492f, -0.20081222f, 0.41147429f, -0.52161312f, 0.18835147f, -0.08796553f, 0.29355296f, 
    -0.23234984f, -0.58574802f, -0.15203130f, 0.32274911f, -0.15302913f, 0.42224348f, -0.22608143f, -0.42525113f, 
    0.37447673f, -0.07269462f, -0.30729392f, -0.23731887f, -0.08785488f, -0.03747912f, -0.14545818f, -0.04611405f, 
    -0.41133815f, -0.25706604f, -0.59686321f, -0.69829798f, -0.50309896f, -0.23059370f, 0.19200650f, 0.75959611f, 
    0.15619129f, -0.33284026f, 0.47453341f, 0.17866740f, -0.07976010f, -0.08778098f, -0.36025473f, -0.12149370f, 
    -0.16091710f, 0.13529271f, 0.39778319f, -0.06798558f, -0.07735146f, -0.18366769f, -0.05526270f, 0.14496954f, 
    -0.10095320f, 0.31661433f, -0.65820545f, -0.98118001f, 0.00450457f, 0.09139324f, -0.22926271f, 0.14485213f, 
    -0.31520721f, 0.50270545f, 0.07967883f, -0.63061243f, -0.14753206f, -0.05974100f, 0.12749295f, 0.32551241f, 
    -0.29107359f, 0.02158906f, 0.40980190f, -0.13493685f, -0.33211651f, 0.24592808f, 0.10802172f, 0.02140488f, 
    0.44452089f, 0.23801528f, 0.16671073f, -0.72534627f, -0.08811238f, 0.00259229f, -0.70228899f, -0.63833553f, 
    0.28517231f, 0.41568530f, 0.18084623f, -0.15940776f, 0.38201728f, 0.09565444f, 0.07086908f, -0.45011044f, 
    -0.15851355f, -0.30580023f, 0.29994702f, -0.33025834f, 0.05669357f, -0.01535420f, 0.29279089f, -0.08217921f, 
    0.01534150f, 0.21880339f, -0.18525998f, 0.43620026f, -0.03490506f, -0.87937921f, -0.63720989f, -0.39189982f, 
    -0.42698032f, 0.29399371f, 0.22944489f, 0.35471398f, 0.16035727f, -0.02706682f, 0.06520212f, -0.07680874f, 
    -0.33677202f, 0.15009642f, 0.41738155f, -0.09961672f, -0.37545034f, 0.06413464f, 0.05535373f, 0.16343305f, 
    0.22891183f, -0.08248878f, 0.06442986f, 0.41441062f, -0.26577085f, -0.02294616f, -0.07276093f, 0.36061573f, 
    0.02980201f, 0.08911462f, 0.50756055f, 0.07171475f, 0.33764327f, 0.44874632f, 0.63989127f, 0.18037491f, 
    0.17371054f, 0.47726846f, 0.51117718f, 0.42336965f, -0.09202431f, -0.38879216f, -0.40566084f, -0.07549468f, 
    0.02097719f, 0.04865387f, -0.17249964f, 0.13254829f, 0.07891510f, 0.22937681f, 0.02069413f, 0.12661025f, 
    0.06913896f, -0.27965236f, 0.58045870f, 0.01766962f, -0.77755278f, -0.71351463f, -0.36822590f, -0.51321977f, 
    -0.28160727f, 0.60404432f, 0.38646582f, -0.23097122f, 0.33035955f, 0.25459659f, 0.22604902f, 0.29267183f, 
    0.29050744f, 0.08538294f, 0.21303016f, -0.18518417f, -0.20102732f, 0.34267348f, 0.03820768f, 0.31421378f, 
    -1.11664212f, 0.10172656f, 0.90172547f, 0.27876675f, -0.94799680f, 0.16026975f, -0.09166251f, -0.28035316f, 
    0.32143942f, 0.20615578f, 0.30240762f, 0.11882409f, -0.25055858f, -0.03165523f, -0.29921725f, 0.09783521f, 
    0.30794075f, 0.20623615f, -0.28180835f, -0.08342308f, 0.08516580f, -0.03661996f, -0.10216881f, -0.12017300f, 
    0.61555105f, -0.07464492f, 0.68908757f, 0.77174401f, 0.06940581f, -0.67289799f, -0.37143087f, -0.24955525f, 
    0.08643518f, 0.28259540f, -0.26315010f, -0.18324564f, -0.22803144f, 0.34042060f, 0.26453429f, -0.31466374f, 
    0.27041805f, 0.25695768f, -0.21406205f, -0.22631600f, -0.10965780f, 0.16586599f, 0.03487879f, -0.47164074f, 
    -0.07706583f, 0.42920423f, 0.37186328f, -0.50253725f, -0.58128691f, -0.10918577f, 0.46276742f, 0.45293471f, 
    0.51872057f, 0.17297322f, 0.59289372f, 0.08014417f, -0.42197368f, -0.38616106f, -0.00100807f, -0.62498879f, 
    -0.06195038f, -0.02132940f, -0.32199523f, 0.04375077f, -0.02158649f, -0.04250288f, -0.08252525f, -0.59140325f, 
    -0.44584817f, -0.10306059f, -0.55280781f, -0.23352034f, -0.29731169f, -0.21200775f, -0.50292379f, 0.50172681f, 
    0.35744822f, 0.29079387f, 0.06354649f, 0.47558424f, -0.56912732f, -0.32797498f, -0.04670535f, -0.05314805f, 
    -0.58625710f, 0.00633628f, -0.19019610f, 0.18016799f, 0.01218496f, -0.25519246f, 0.05499393f, -0.00746051f, 
    0.12367717f, -0.17827894f, 0.37024495f, 0.70517439f, 0.34058914f, 0.42045537f, -0.62324631f, -0.55631673f, 
    0.53244948f, -0.57702941f, 0.17571180f, 0.07651465f, 0.02403223f, 0.10895786f, -0.38228586f, -0.53065300f, 
    -0.27448025f, 0.00054967f, -0.09516314f, -0.17365998f, -0.43062535f, -0.07173204f, 0.18912128f, 0.24220756f, 
    0.21345323f, -0.07594753f, 0.06073150f, 0.35203192f, -0.51478940f, 0.08119269f, -0.12445730f, -0.55185652f, 
    -0.33681169f, -0.33186916f, -0.45497689f, -0.03528981f, -0.37345898f, -0.69185597f, -0.39339986f, 0.44764841f, 
    -0.33822224f, -0.08249122f, -0.27766681f, 0.01958884f, -0.12192811f, 0.10140265f, 0.10325449f, 0.08699553f, 
    -0.05128564f, 0.08943210f, 0.13253282f, 0.08425006f, -0.02514183f, 0.66784430f, -0.57961094f, -0.81839633f, 
    -0.27252641f, 0.17661597f, 0.72123128f, 0.68857980f, -0.32505390f, 0.65551054f, 0.50398350f, -0.46297786f, 
    0.12964073f, -0.19890702f, 0.18703745f, 0.03188863f, -0.27801299f, 0.12584382f, 0.17997979f, 0.03081050f, 
    -0.24281104f, 0.04085872f, 0.03610995f, -0.00031973f, -0.13756603f, 0.28215960f, 0.08933944f, -0.92969441f, 
    0.16660593f, 0.18836404f, 0.21150582f, -0.58941740f, 0.23840059f, 0.31429759f, -0.41969076f, 0.10945381f, 
    0.62131190f, 0.36468670f, -0.34502774f, 0.12045539f, 0.16897045f, -0.11689131f, -0.50026882f, -0.36052051f, 
    -0.04062746f, -0.08576838f, -0.05463365f, -0.08951901f, 0.32585353f, -0.00433321f, -0.06806532f, 0.92067808f, 
    0.94249398f, 1.00240672f, 0.18579821f, 0.04706077f, -0.39370272f, 0.14984907f, -0.29388720f, 0.01408986f, 
    0.35900199f, 0.06304258f, 0.08997338f, 0.02172110f, 0.01767036f, 0.05157562f, -0.02546956f, -0.16589126f, 
    0.20597979f, 0.15583637f, -0.42725596f, 0.01136091f, 0.02413509f, -0.18227707f, 0.17991984f, 0.07906885f, 
    0.48562130f, -0.08667764f, 0.14358470f, 0.58656520f, -0.97715479f, 0.44467258f, 0.43992671f, 0.52879733f, 
    0.44919595f, 0.36840865f, 0.19328214f, 0.08849312f, 0.32493359f, -0.57529533f, -0.43413773f, -0.26009735f, 
    -0.09993590f, -0.01732598f, -0.03104395f, -0.06144232f, -0.01571795f, -0.01908180f, 0.09169896f, 0.09342599f, 
    -0.01147799f, -0.23212017f, -0.16399819f, -0.23320338f, -0.43115562f, -0.13478385f, 0.03679612f, 0.05266715f, 
    -0.64170784f, -0.65364081f, -0.14107902f, -0.54054165f, -0.04365232f, 0.14826828f, 0.24489751f, -0.41665813f, 
    -0.70135051f, -0.15567146f, -0.20026217f, -0.13789420f, -0.65424979f, -0.01018856f, -0.17603220f, 0.23568705f, 
    -0.01304701f, 0.38889977f, 0.04489757f, -0.41409856f, 0.50574249f, 0.43290073f, 0.77248412f, -0.54512888f, 
    0.14702691f, -0.47300053f, -0.88358843f, 0.36117381f, -0.03509792f, 0.40911403f, -0.11654163f, 0.30636981f, 
    0.07027100f, 0.32461751f, 0.00856629f, -0.07509515f, -0.21119492f, -0.14552893f, -0.02326790f, -0.05026088f, 
    -0.02007067f, 0.22078098f, -0.13381936f, -0.69852036f, 0.30612749f, 0.81322068f, 0.36073756f, 0.30684265f, 
    0.59400916f, 0.50749362f, 0.06912504f, -0.17140102f, 0.44616678f, -0.19736683f, -0.31857449f, 0.35236710f, 
    -0.56549084f, -0.17498933f, -0.49202999f, -0.36285344f, -0.28556907f, -0.33099088f, -0.44538751f, 0.15280139f, 
    0.20287082f, 0.08286922f, 0.21607728f, 0.06546244f, 0.87208092f, 0.64449632f, 0.10261894f, 0.02026976f, 
    -0.14230666f, 0.15525122f, 0.42711064f, -0.20000291f, -0.18659781f, -0.29270566f, -0.24979667f, -0.01378036f, 
    -0.35546756f, 0.30089015f, -0.08580750f, 0.42654675f, 0.03487474f, 0.43507659f, 0.50969315f, 0.14389968f, 
    -0.13071072f, -0.31668526f, -0.20454974f, -0.28667328f, 0.21697043f, 0.27426106f, 0.75157821f, 0.20889941f, 
    -0.32246938f, -0.50842386f, 0.66092145f, -0.84607637f, -0.26203537f, -0.65026557f, -0.16653132f, 0.20245868f, 
    -0.03637410f, 0.15214586f, 0.33600849f, -0.24321902f, 0.18764259f, -0.34007832f, 0.08513971f, -0.08347354f, 
    -0.01686219f, -0.05919553f, 0.42352280f, 0.01296232f, 0.03377395f, -0.08779389f, -0.58101153f, -1.07786155f, 
    -0.78039521f, 0.16269529f, 0.19675082f, -0.74676967f, 0.39676487f, 0.50041389f, -0.14202005f, 0.13890594f, 
    0.45252916f, -0.03760469f, -0.11337803f, 0.00357773f, 0.19164732f, -0.10662350f, -0.00606009f, -0.05238398f, 
    -0.00834776f, -0.29248896f, -0.03742810f, -0.07350150f, -0.28189379f, 0.17080766f, 0.00655329f, -0.90363163f, 
    -0.42851859f, -0.12003302f, 0.04184552f, 0.60221565f, -0.03851948f, 0.04516497f, 0.02444140f, -0.79125333f, 
    -0.40634230f, -0.22046590f, 0.23930079f, 0.62359828f, -0.03903343f, 0.08222695f, 0.28469574f, 0.01316732f, 
    0.23876420f, 0.26711750f, 0.02996825f, 0.05504577f, -0.23984964f, -0.18234630f, -0.09519608f, -0.16306171f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.25976798f, 0.13032618f, 0.02752973f, 0.29043177f, 0.00937060f, 0.10471175f, 0.27461380f, 0.20758705f, 
    0.03187183f, 0.18107809f, 0.17882761f, -0.03429659f, 0.10592067f, 0.14158738f, 0.23654495f, 0.01717122f, 
    0.06275767f, 0.08261032f, 0.11295827f, -0.06275211f, 0.12070008f, 0.17141116f, -0.11488103f, 0.09636839f, 
    0.13772111f, 0.12812787f, 0.22348815f, 0.13996996f, 0.12780158f, 0.16678436f, -0.12167846f, -0.11656751f, 
    0.07713763f, 0.04420003f, 0.20286764f, 0.15429372f, 0.14925799f, 0.27324262f, 0.12065555f, 0.23054537f, 
    -0.04806243f, 0.18304220f, 0.21598606f, 0.09940509f, 0.19966134f, 0.03082277f, 0.07991284f, 0.10124711f, 
    0.15784539f, 0.08084435f, 0.03794639f, 0.14179581f, 0.06961154f, 0.04759504f, 0.02282863f, 0.22173406f, 
    -0.02327750f, 0.04643553f, 0.14572738f, -0.10205789f, 0.07327355f, 0.01159856f, 0.13025774f, 0.36767399f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.17169167f, -0.18398975f, -0.05297203f, 0.26801872f, -0.13970560f, 0.02559862f, -0.04526193f, 0.06169251f, 
    0.08804644f, 0.05655888f, -0.04163859f, -0.10818443f, -0.11671764f, 0.13224161f, -0.12481055f, 0.06113455f, 
    -0.07941215f, -0.00839523f, -0.06653795f, -0.00952004f, 0.07668406f, 0.04144423f, 0.06017780f, -0.11073444f, 
    0.26445672f, -0.12242219f, -0.06399588f, 0.23380953f, 0.06569581f, 0.02742660f, 0.01861166f, -0.02788659f, 
    0.01558348f, 0.02931891f, -0.06782359f, -0.12247904f, -0.06095337f, -0.13878706f, 0.10653219f, -0.24285881f, 
    -0.04024389f, -0.00791751f, 0.09144963f, 0.04101616f, 0.03235330f, -0.10542750f, -0.06412694f, 0.01170155f, 
    -0.04795635f, -0.08988990f, 0.00757354f, 0.04913433f, -0.00282788f, 0.00723465f, 0.09517851f, 0.04111985f, 
    0.06909116f, 0.02009191f, 0.05776703f, -0.09942252f, 0.12992446f, -0.07418410f, 0.01061164f, -0.01183870f, 
    -0.17843930f, -0.17239866f, -0.09899102f, 0.09370936f, 0.05519406f, -0.04121296f, 0.06498743f, -0.11892919f, 
    0.06918886f, 0.00090084f, 0.08669285f, -0.05373057f, -0.09288930f, 0.01290251f, 0.00583522f, 0.06228577f, 
    -0.08246335f, -0.05172189f, -0.04055720f, -0.02738121f, 0.18155530f, 0.01826439f, 0.08668427f, -0.17305183f, 
    0.02898510f, 0.01514707f, -0.04120662f, -0.04692924f, -0.08598229f, 0.01644390f, 0.03446575f, 0.04493096f, 
    -0.08077979f, 0.32893026f, 0.03102517f, 0.11091027f, 0.06137731f, 0.07262163f, -0.05072075f, -0.18416014f, 
    0.00329256f, -0.04203878f, -0.09926184f, 0.00369857f, -0.29294646f, -0.09640028f, 0.03135552f, -0.35224700f, 
    -0.10943327f, -0.02813753f, -0.03677035f, 0.00269433f, 0.04636477f, -0.05161210f, 0.03677058f, 0.01311676f, 
    -0.45269081f, -0.02618717f, 0.00993375f, -0.20511396f, -0.05759614f, -0.03015445f, 0.00794573f, -0.00231268f, 
    0.08484579f, 0.07058282f, 0.12819558f, 0.00581622f, -0.12039372f, 0.06478444f, 0.14412135f, -0.08755160f, 
    0.05138636f, 0.11618535f, 0.07522219f, -0.01129956f, -0.01534719f, 0.01368501f, 0.09340387f, -0.06086757f, 
    0.26654088f, 0.02684583f, -0.08349599f, 0.03575871f, -0.27332807f, -0.06120582f, -0.07738303f, 0.10872244f, 
    -0.05287214f, 0.05134907f, -0.13816905f, 0.02188628f, -0.04095832f, -0.01704643f, 0.11433038f, 0.02397347f, 
    -0.11252835f, -0.12868120f, 0.06005805f, -0.06818119f, 0.03966916f, -0.05771308f, -0.13107902f, 0.06139490f, 
    0.03800418f, -0.06759129f, -0.03541714f, 0.07935285f, -0.14626186f, 0.05376486f, -0.00089339f, 0.09206657f, 
    -0.03737610f, -0.06402977f, 0.01691263f, -0.03334397f, -0.06044053f, -0.11917621f, 0.02103261f, -0.08173455f, 
    -0.21512215f, -0.06022562f, -0.06506061f, -0.05389103f, 0.08358321f, 0.00871757f, 0.00371450f, -0.06972315f, 
    -0.18187808f, -0.05372343f, 0.02231633f, 0.14185534f, 0.07335199f, -0.04784996f, -0.01454095f, 0.04336186f, 
    0.10534121f, 0.01903675f, -0.07992508f, -0.02186242f, 0.19199789f, -0.04388212f, 0.09767948f, -0.16413933f, 
    0.06807294f, 0.06096078f, 0.06323659f, 0.06954401f, 0.01798154f, -0.01223252f, -0.01410984f, 0.00547598f, 
    0.06314100f, -0.07505465f, -0.07014696f, 0.32052961f, -0.04936475f, -0.01211160f, -0.03248682f, 0.02661983f, 
    0.06639996f, -0.01017174f, -0.02469302f, 0.14283992f, -0.16693370f, 0.19471806f, 0.09435022f, 0.00417040f, 
    -0.18184823f, -0.01126001f, 0.01745548f, -0.01224735f, -0.00742838f, -0.07609478f, 0.00351512f, -0.04758084f, 
    0.17898762f, 0.19598667f, 0.08129548f, -0.28026640f, 0.13651539f, -0.00163382f, -0.02661893f, 0.02386515f, 
    0.03783114f, 0.05779916f, -0.04978317f, 0.14048982f, -0.04380704f, 0.01352077f, -0.12476581f, 0.14830565f, 
    -0.04708865f, 0.12035297f, -0.00908144f, 0.01594962f, 0.08342821f, 0.01156250f, -0.00696836f, -0.23139729f, 
    0.20107888f, 0.05436179f, 0.05697240f, 0.01728216f, -0.02707527f, 0.10053513f, 0.14432527f, -0.07600605f, 
    -0.14611693f, 0.07865474f, 0.05188614f, -0.00090431f, -0.28884116f, -0.01685174f, 0.06759065f, -0.00675532f, 
    -0.04125353f, -0.08796546f, -0.12028349f, -0.00420455f, -0.08041971f, -0.08679168f, -0.08699350f, 0.01871492f, 
    -0.28436676f, -0.01569099f, -0.13041294f, -0.15183824f, -0.00896416f, 0.07094201f, 0.06702340f, 0.06144329f, 
    0.03310329f, 0.09538157f, -0.07569122f, -0.01407582f, -0.31625924f, 0.06723865f, 0.07936584f, 0.04649204f, 
    0.03976615f, 0.06696980f, 0.03323092f, 0.02594570f, -0.09470295f, 0.00305958f, -0.09265991f, 0.00542428f, 
    -0.14980951f, 0.02066337f, 0.18881474f, -0.21427795f, 0.01552036f, -0.00868808f, -0.01434977f, -0.07469853f, 
    0.05736743f, -0.01964447f, 0.02570849f, -0.00839516f, 0.20189601f, 0.00499052f, -0.10249417f, -0.26182136f, 
    -0.04389431f, 0.09418498f, -0.05281233f, 0.02117104f, 0.01093254f, 0.07409324f, -0.15386420f, -0.05077989f, 
    -0.21164528f, 0.06804297f, -0.02397400f, -0.02946116f, -0.04091552f, -0.01512037f, 0.09620516f, -0.07091701f, 
    0.01788530f, -0.13637812f, 0.07071728f, 0.01837416f, -0.17745431f, 0.19979870f, 0.03577835f, 0.07738163f, 
    -0.06284117f, -0.00681024f, 0.01864983f, -0.07454131f, -0.04760771f, 0.02345376f, 0.07661473f, -0.10547930f, 
    0.09192407f, 0.02199951f, 0.24723785f, -0.02291088f, -0.00195906f, 0.00269469f, -0.02498509f, -0.06459875f, 
    0.03582365f, -0.07115114f, -0.03780616f, 0.01286612f, 0.19165754f, -0.00259182f, -0.23984222f, -0.15019514f, 
    0.06274561f, -0.03534406f, -0.00475024f, 0.10757245f, -0.08564475f, 0.02306159f, -0.07369363f, -0.01586956f, 
    0.31225649f, -0.02817569f, -0.02308780f, -0.14851484f, 0.06774025f, -0.01782269f, 0.11322777f, 0.01000974f, 
    0.12168167f, -0.12570737f, -0.09940215f, 0.04198642f, -0.02180300f, 0.12592261f, 0.00920662f, -0.07754632f, 
    -0.17639209f, -0.03117426f, 0.04451092f, -0.01867817f, -0.00855253f, 0.12126539f, 0.11568015f, -0.03269306f, 
    -0.41623756f, 0.18154338f, -0.04447795f, 0.05001511f, -0.05420601f, 0.04047531f, -0.06557133f, -0.01021969f, 
    -0.00742911f, -0.01322268f, -0.07116945f, 0.06339733f, -0.34300119f, -0.01324800f, 0.08201279f, 0.18936606f, 
    0.00249555f, 0.01272635f, 0.04022645f, -0.00498236f, 0.05471273f, 0.04796734f, -0.03429212f, -0.02366028f, 
    0.09329896f, 0.11982247f, 0.02822259f, 0.01047171f, -0.04234051f, -0.05554986f, 0.00833107f, -0.09563683f, 
    -0.01769150f, -0.02175257f, -0.04490516f, 0.02767126f, 0.09083088f, 0.02554091f, -0.08896034f, 0.17054196f, 
    -0.12880763f, 0.05592368f, 0.07634035f, -0.04021966f, -0.02747373f, -0.07110856f, -0.01310191f, 0.04625085f, 
    -0.03627583f, 0.03752512f, 0.10227197f, -0.01517025f, 0.01305363f, 0.06688295f, 0.04142305f, -0.01296725f, 
    -0.01269645f, 0.02622959f, -0.00746898f, -0.00657747f, -0.22829469f, -0.29646364f, 0.07088213f, 0.09818976f, 
    -0.03776407f, -0.06693337f, -0.03196960f, -0.00918328f, -0.03760972f, 0.00267355f, -0.01232889f, 0.03534029f, 
    -0.20360103f, 0.15285081f, -0.11126763f, 0.00562185f, 0.05604596f, 0.09180848f, 0.05137738f, 0.03823409f, 
    0.07221986f, -0.01946706f, -0.05687975f, -0.00901118f, 0.01789640f, 0.10190651f, 0.15926540f, -0.30920848f, 
    0.10327329f, -0.03961149f, -0.06049859f, 0.12396935f, -0.03287559f, 0.05028919f, -0.04224541f, 0.05628863f, 
    -0.22446917f, -0.04326444f, -0.13257731f, -0.01583549f, 0.13557968f, 0.12254827f, -0.00446102f, 0.01807049f, 
    -0.00842627f, 0.04882539f, -0.07717289f, -0.13658322f, 0.19543146f, 0.03416064f, 0.21938315f, -0.32538053f, 
    0.08923654f, -0.02814726f, -0.01801071f, 0.06995612f, -0.05138702f, 0.01674168f, 0.02564287f, -0.02506938f, 
    0.03036253f, -0.03574732f, -0.10378864f, -0.24895009f, 0.06110521f, 0.01699937f, -0.01901593f, 0.05574517f, 
    0.09053116f, -0.07489452f, 0.05849463f, 0.00943196f, -0.05663918f, -0.18805113f, -0.06571711f, 0.00851161f, 
    0.03031893f, -0.00791814f, -0.10489937f, -0.11186932f, 0.11215849f, 0.04485397f, 0.13286214f, 0.08337943f, 
    -0.09067817f, 0.02006686f, 0.25772315f, -0.12858748f, -0.05787054f, 0.03309542f, 0.08279007f, 0.03088915f, 
    -0.06073250f, -0.08965524f, -0.13412535f, 0.03942080f, 0.30481637f, -0.25158802f, -0.20789966f, 0.30492777f, 
    -0.05994498f, -0.05432176f, -0.00375040f, -0.09204143f, 0.00653633f, 0.04483510f, -0.17970674f, 0.06135629f, 
    0.22071581f, -0.09294046f, -0.24920416f, 0.25834218f, -0.10844468f, -0.07634965f, 0.08041299f, -0.00584288f, 
    -0.12300703f, 0.04544257f, -0.12273441f, 0.00849265f, 0.00762720f, -0.02233195f, 0.01533280f, -0.25054955f, 
    0.07696199f, -0.01172030f, 0.08388215f, -0.02388779f, -0.06402250f, 0.13732633f, -0.01892671f, 0.00520691f, 
    0.26433489f, 0.11605744f, 0.04389730f, -0.07555736f, 0.10181943f, 0.09774623f, -0.01635523f, 0.02633962f, 
    -0.02591639f, 0.00105643f, -0.06465496f, -0.04992295f, 0.11545677f, -0.10213151f, 0.04304158f, -0.07906567f, 
    -0.04926046f, -0.04399647f, 0.04314991f, -0.01850033f, -0.09363467f, -0.05566531f, 0.05418791f, 0.15112196f, 
    -0.37267861f, 0.12118033f, 0.07693823f, 0.11557683f, 0.02077144f, -0.04967345f, -0.01798483f, -0.00897603f, 
    -0.05137145f, -0.12239024f, 0.02504606f, -0.15646134f, 0.09334402f, 0.03180110f, 0.01890247f, -0.11848054f, 
    -0.03462566f, 0.03412738f, 0.02370099f, -0.02666032f, -0.01279232f, 0.09071244f, 0.06827280f, 0.10602662f, 
    0.03943155f, -0.01934806f, -0.15571381f, 0.21330477f, -0.06264358f, 0.00763645f, 0.02578794f, -0.07291219f, 
    0.04612628f, 0.10773378f, 0.00213961f, 0.05208002f, 0.03623539f, 0.04410422f, -0.08861761f, -0.01657546f, 
    -0.11441567f, -0.15646641f, -0.02077499f, 0.00238390f, -0.05811775f, 0.04295922f, -0.08716105f, -0.13881294f, 
    -0.09521322f, 0.15735285f, -0.16580521f, 0.17166980f, 0.04958460f, 0.02627984f, -0.04304062f, -0.19529714f, 
    -0.00518472f, -0.03316141f, -0.09662825f, 0.12590256f, -0.16762067f, -0.10711756f, 0.16729805f, -0.09946845f, 
    -0.02788354f, 0.10067231f, 0.04891635f, 0.03439430f, 0.04635767f, 0.08171722f, -0.12890492f, 0.08409365f, 
    0.12876551f, -0.08722313f, -0.11078550f, 0.11553776f, -0.03863920f, -0.09497575f, -0.03642488f, -0.07123891f, 
    -0.06273071f, -0.04603356f, 0.03239987f, -0.04454979f, 0.05521912f, 0.10720474f, 0.17741300f, 0.09436686f, 
    -0.07592698f, -0.07322429f, 0.02170362f, -0.11497989f, -0.06126739f, -0.02343442f, 0.02419049f, 0.04169982f, 
    0.02385492f, 0.21682815f, 0.05070667f, -0.10649318f, -0.16530021f, -0.00867747f, 0.03999810f, 0.16717845f, 
    0.06197472f, 0.06078126f, 0.00340131f, 0.09438223f, -0.14729917f, 0.12265870f, 0.08586463f, -0.31580782f, 
    -0.20003490f, -0.01657628f, 0.01348746f, -0.08816338f, -0.10842494f, 0.00563329f, -0.17753609f, 0.11350136f, 
    -0.31996164f, 0.23282424f, -0.13750698f, 0.03969478f, 0.10649633f, -0.04658353f, -0.11862956f, 0.01272312f, 
    -0.03085448f, -0.01396369f, -0.04926870f, 0.07175458f, -0.50010741f, -0.17700604f, 0.05882252f, 0.05434467f, 
    0.04271117f, 0.01093963f, -0.02645879f, -0.01163989f, 0.10247494f, -0.04122379f, -0.04849390f, -0.01671507f, 
    -0.01214739f, 0.09391749f, 0.22301109f, 0.21541730f, -0.09382100f, -0.02048850f, -0.04369998f, 0.01724523f, 
    -0.13742599f, 0.05592569f, 0.06530429f, 0.06023646f, -0.14902104f, 0.01183676f, -0.02879584f, 0.19674751f, 
    -0.07008762f, -0.06149558f, 0.00121538f, -0.08147730f, -0.01920625f, -0.07486097f, -0.02180017f, 0.05371906f, 
    0.00384082f, 0.09468361f, -0.00338819f, -0.03869892f, -0.11597309f, 0.00561137f, 0.01101058f, -0.05581350f, 
    0.09844856f, -0.09766275f, 0.07853823f, 0.09266701f, 0.23598111f, -0.36694664f, 0.09396629f, -0.27214593f, 
    0.15232636f, -0.12213459f, 0.09125257f, -0.01181760f, -0.13884950f, 0.03788621f, 0.06132874f, 0.01863541f, 
    0.23908158f, 0.13425148f, 0.11631527f, 0.07938334f, -0.01273642f, 0.00514287f, -0.06529145f, -0.02166164f, 
    0.05225857f, -0.00847273f, 0.00803501f, 0.07409514f, 0.21777746f, 0.06058913f, 0.11600342f, 0.23061207f, 
    0.09486425f, -0.03852648f, 0.12192268f, -0.04349105f, -0.05573185f, -0.10470879f, -0.07079443f, 0.04526006f, 
    0.07249642f, 0.07181735f, 0.12497632f, 0.17551628f, -0.11630870f, 0.06834292f, 0.01177878f, -0.00358670f, 
    -0.01712215f, 0.08714154f, 0.06504180f, 0.05779370f, 0.05840040f, -0.19952029f, 0.09394480f, -0.21379189f, 
    0.06355911f, -0.00291210f, 0.05879257f, 0.01061885f, 0.07018622f, -0.04363894f, 0.05516002f, -0.07902817f, 
    0.18416773f, -0.13764481f, -0.20978926f, 0.02539034f, -0.07922884f, 0.14810212f, -0.12739031f, 0.05801417f, 
    0.03973786f, 0.05788286f, 0.05335132f, 0.11278464f, 0.15680727f, 0.10494466f, -0.00821587f, -0.21330693f, 
    -0.07359741f, 0.12963320f, 0.00507919f, -0.11045236f, -0.11460535f, 0.03658829f, -0.02044784f, 0.05807753f, 
    0.12259546f, -0.17443350f, 0.01109667f, -0.00058237f, 0.06123975f, 0.07739615f, 0.10679477f, -0.13067751f, 
    -0.05125034f, 0.01129453f, -0.04285194f, -0.01562247f, 0.23422143f, 0.10568907f, -0.05653728f, -0.07191677f, 
    0.03455321f, 0.06540967f, -0.06910548f, -0.07122234f, 0.03101148f, 0.10601587f, -0.08055969f, 0.01531699f, 
    0.02412097f, -0.16087818f, 0.13688870f, 0.06510919f, 0.17144008f, -0.13890515f, 0.10821585f, 0.02439583f, 
    0.06081925f, 0.03218436f, 0.00601694f, 0.02516427f, 0.17935437f, 0.10226307f, 0.09496745f, 0.10540804f, 
    -0.10912365f, 0.05550772f, 0.05796022f, -0.04343555f, -0.08124519f, -0.02163558f, 0.14703315f, -0.14956905f, 
    -0.00043282f, 0.11821296f, 0.10464224f, 0.10130050f, 0.05718385f, -0.06031848f, 0.01707305f, -0.07536733f, 
    0.05915879f, 0.06046500f, -0.10155755f, 0.12981969f, -0.44264358f, -0.03157626f, 0.13297455f, 0.04983033f, 
    0.04151983f, 0.07978468f, -0.02965401f, 0.03579082f, -0.09151708f, -0.18586889f, -0.07187101f, -0.10503598f, 
    -0.20128676f, -0.00127705f, 0.00131013f, -0.06501275f, -0.05984525f, 0.00817505f, -0.13604860f, -0.02243642f, 
    -0.03258080f, -0.03557682f, -0.00306374f, 0.01420385f, 0.06982791f, -0.22467896f, 0.19905207f, -0.18699145f, 
    -0.09883843f, -0.10076168f, -0.09372578f, -0.00321883f, -0.00875883f, -0.04735183f, 0.02367961f, 0.08326167f, 
    0.10994647f, -0.05275089f, -0.11163189f, 0.14824313f, -0.10245528f, 0.02220100f, -0.09087531f, 0.04488706f, 
    -0.11288743f, -0.01258164f, -0.01564508f, -0.19737333f, 0.07960852f, 0.13097678f, -0.05780146f, 0.15766415f, 
    0.08198313f, 0.06737719f, -0.00913711f, 0.06639351f, 0.04615318f, 0.10308106f, -0.07062805f, -0.01804141f, 
    0.21152566f, -0.02176110f, -0.11300771f, -0.12119410f, 0.08128964f, 0.00811679f, -0.08221394f, 0.10853302f, 
    0.07721297f, 0.00453285f, -0.02819672f, -0.05412599f, -0.04690848f, -0.11575411f, -0.12872870f, -0.00238385f, 
    -0.01101313f, -0.05257127f, 0.02670802f, -0.14256965f, -0.14794253f, -0.09967227f, -0.03352939f, 0.14955804f, 
    -0.34512502f, -0.04317775f, 0.02629679f, -0.14803314f, -0.21466772f, -0.01096723f, -0.15108278f, 0.05007306f, 
    0.09073269f, -0.32121643f, -0.11210003f, 0.11010320f, 0.39021680f, -0.09586029f, -0.14610904f, -0.11331552f, 
    -0.10580876f, -0.01733579f, 0.09716687f, 0.00153888f, -0.06845262f, 0.07242376f, 0.05090269f, 0.08351504f, 
    0.03135474f, -0.08579725f, 0.06722546f, -0.17004757f, -0.06176693f, 0.09812976f, 0.03430995f, 0.13832550f, 
    0.01471897f, -0.04087179f, 0.11543532f, 0.00358509f, -0.26230478f, 0.17752677f, -0.22548224f, -0.36268407f, 
    -0.06364372f, 0.06501409f, 0.09231422f, -0.07016353f, 0.12793550f, 0.00108486f, 0.00040555f, -0.04795984f, 
    -0.15762430f, -0.01042044f, -0.15578790f, -0.20639673f, 0.05269771f, 0.07789674f, 0.08652387f, -0.03404967f, 
    0.03905825f, 0.07352019f, -0.10045011f, -0.06968037f, -0.16202787f, -0.05930050f, 0.12349801f, -0.06861307f, 
    0.05678727f, -0.02188152f, -0.01522745f, 0.04814317f, 0.05148159f, 0.00862805f, 0.07500163f, -0.00286861f, 
    -0.03767564f, -0.17380376f, -0.04239966f, -0.19729725f, 0.00421351f, 0.00484942f, -0.01886881f, -0.00051086f, 
    -0.04509726f, -0.07684687f, -0.23726024f, -0.08168572f, -0.17687561f, -0.12950411f, -0.27405849f, 0.08584742f, 
    0.02552892f, -0.01129786f, -0.07982415f, 0.02022985f, -0.03606508f, -0.00736011f, -0.03726267f, 0.11952515f, 
    -0.08506623f, 0.00110963f, -0.39855900f, -0.04214760f, 0.04051135f, 0.02650241f, -0.03344306f, -0.04526341f, 
    -0.01134303f, 0.12117218f, 0.05384976f, -0.03148948f, -0.04178734f, 0.09409572f, -0.03798337f, -0.03800183f, 
    0.06479668f, -0.01997767f, -0.00959060f, 0.04023458f, 0.08782146f, -0.16574135f, -0.08370699f, 0.07534253f, 
    -0.16534056f, 0.11069393f, 0.07544471f, -0.02005688f, 0.03764496f, 0.01873091f, -0.00390632f, 0.01530722f, 
    -0.02204758f, 0.10825319f, 0.10788500f, -0.00947785f, 0.09379377f, -0.19005208f, -0.03548956f, 0.11743647f, 
    0.03907444f, 0.04843190f, -0.04256762f, 0.07112554f, 0.06214607f, -0.11327996f, -0.02967197f, 0.10276642f, 
    0.16720799f, -0.11645032f, -0.11369155f, 0.16845571f, -0.06365870f, 0.01241902f, 0.01009388f, -0.00377469f, 
    0.07140343f, -0.13795033f, 0.02824304f, -0.03169737f, -0.10877880f, 0.19509080f, -0.25899017f, -0.08062622f, 
    -0.08138082f, 0.08276437f, -0.06906848f, -0.04084076f, -0.00511546f, -0.00378822f, 0.01579796f, 0.04452782f, 
    -0.11120801f, -0.10398813f, -0.09994584f, 0.15403154f, 0.03700533f, 0.01302281f, -0.03659794f, -0.00137642f, 
    -0.02376174f, 0.09659848f, -0.01378594f, 0.12336583f, 0.17916998f, 0.00789633f, -0.01743841f, 0.25527099f, 
    -0.01514340f, 0.01765786f, -0.06879053f, 0.05976463f, -0.03149052f, 0.03637600f, -0.03417383f, -0.07268210f, 
    -0.14459014f, 0.03016482f, -0.04071812f, 0.03737298f, 0.10379341f, 0.00438675f, -0.01936836f, -0.03676103f, 
    -0.00011401f, 0.05332289f, -0.09427820f, 0.05315369f, 0.08754884f, -0.21856110f, 0.03129328f, -0.02949055f, 
    0.05596703f, 0.07218660f, -0.10766140f, 0.07232789f, -0.06130783f, 0.11947114f, 0.07403430f, -0.08555306f, 
    -0.24609178f, -0.07351929f, -0.25884062f, 0.17123480f, 0.02151434f, -0.13322251f, -0.01167457f, -0.13214044f, 
    -0.02895731f, -0.14375833f, -0.03624022f, -0.04264098f, 0.22337499f, -0.12439279f, -0.18252678f, -0.20352642f, 
    -0.06632843f, -0.02662657f, 0.04738782f, -0.04512911f, 0.10187591f, -0.08235785f, 0.07001135f, -0.04196101f, 
    -0.13771631f, 0.01552200f, -0.01305405f, 0.04678442f, -0.12728611f, -0.08810369f, 0.05872475f, 0.05769340f, 
    0.08119643f, -0.05723661f, 0.00720296f, 0.17067103f, -0.26803288f, -0.04362974f, -0.30010915f, -0.14063153f, 
    0.02326529f, -0.05362786f, 0.00984178f, -0.02319079f, 0.12640773f, 0.06287158f, -0.11189488f, 0.00531331f, 
    0.16843855f, -0.19659142f, 0.03094737f, 0.03265539f, -0.09950987f, 0.01054784f, 0.05806038f, 0.02532718f, 
    0.01154388f, 0.06869344f, -0.12070741f, 0.09322237f, 0.09391826f, 0.05525525f, 0.03773931f, 0.00366755f, 
    -0.06955141f, 0.02361438f, 0.06678338f, -0.03401909f, -0.16601980f, -0.00613306f, -0.16620624f, -0.07045867f, 
    -0.12751073f, -0.06699511f, 0.02245837f, -0.17594296f, -0.05696806f, 0.01566916f, 0.10732394f, -0.05202078f, 
    0.09939272f, 0.09703399f, 0.05531340f, 0.08977485f, -0.33698684f, -0.35155976f, -0.12589930f, 0.12374240f, 
    -0.06389893f, -0.01110250f, 0.01960117f, 0.08573803f, -0.02010015f, -0.06808034f, 0.13348107f, -0.00744285f, 
    0.10087997f, 0.00817721f, 0.00411072f, 0.08258894f, -0.10462159f, -0.04010702f, -0.01296938f, -0.09345277f, 
    0.04540918f, -0.07852767f, 0.11692962f, -0.04085537f, 0.16028626f, -0.09649436f, 0.13948122f, -0.10365576f, 
    0.01346501f, -0.10546516f, -0.03287659f, -0.01843980f, 0.06028654f, -0.03686394f, -0.07749069f, -0.13054664f, 
    -0.19224700f, -0.00385800f, -0.05600313f, 0.01195056f, -0.01643125f, -0.06519412f, -0.02582924f, -0.01835431f, 
    0.08991137f, 0.07617705f, 0.01708509f, -0.06138691f, -0.05955153f, 0.11066663f, 0.00904732f, -0.13925600f, 
    -0.07541911f, 0.01148128f, 0.01988782f, -0.02759856f, -0.06643891f, 0.00185746f, -0.02074170f, -0.04340625f, 
    0.06167090f, -0.07472265f, -0.09516757f, -0.29361871f, 0.10877842f, 0.06240513f, 0.10881408f, -0.00334441f, 
    0.04175952f, 0.13000193f, 0.05048412f, -0.02784509f, 0.43288055f, -0.36303607f, -0.02063646f, -0.12541825f, 
    0.05882655f, -0.07655802f, -0.13678846f, 0.06813027f, -0.08837742f, -0.06289642f, 0.00481021f, 0.03901436f, 
    -0.15612654f, -0.07384425f, 0.05677697f, 0.04139686f, 0.06067448f, 0.04254627f, -0.08476342f, 0.04078927f, 
    -0.12763901f, -0.04297360f, -0.07743881f, -0.07162768f, 0.19547950f, 0.11355424f, 0.00038875f, 0.15923205f, 
    -0.06240933f, -0.07400642f, 0.06180338f, 0.02596010f, 0.06947251f, -0.11999950f, -0.01158069f, 0.06888986f, 
    0.02987780f, -0.10514093f, 0.04428414f, 0.12635426f, -0.05655900f, -0.11155169f, 0.08277313f, 0.05908987f, 
    -0.00244197f, -0.14276829f, -0.02216860f, -0.01726405f, -0.00192154f, 0.01819679f, -0.08287144f, -0.13610381f, 
    0.03736978f, -0.10637461f, -0.01294242f, 0.13000727f, -0.11257717f, -0.15271169f, -0.02984596f, -0.15969327f, 
    -0.12755196f, -0.02633127f, 0.00786516f, -0.09085958f, -0.01861530f, 0.08023468f, -0.06589577f, 0.09967384f, 
    0.04438263f, 0.00641744f, -0.10413011f, 0.03517055f, -0.01200812f, 0.11398073f, 0.05331365f, 0.15579614f, 
    -0.05144622f, 0.16603978f, 0.08070050f, -0.00379758f, -0.13213488f, -0.02528080f, 0.03207858f, -0.08005336f, 
    0.32449844f, -0.03584442f, 0.08837617f, 0.02438536f, 0.08703008f, 0.00436350f, -0.06067530f, 0.02329350f, 
    -0.03359700f, -0.09589827f, -0.03493701f, -0.00683329f, 0.03726584f, -0.08447170f, 0.00457445f, -0.10025104f, 
    0.04329598f, -0.06607453f, 0.08589682f, -0.00924036f, 0.04917130f, 0.12336306f, 0.13205467f, -0.02557767f, 
    0.32247043f, -0.06100740f, -0.08351579f, 0.08798753f, -0.03997947f, 0.02688290f, -0.06397153f, -0.01248036f, 
    0.03947322f, -0.04645169f, -0.01587645f, 0.06854132f, 0.23931174f, 0.07990290f, -0.02943938f, -0.13181549f, 
    -0.01742854f, 0.03087576f, -0.05395190f, -0.08543458f, -0.01932588f, 0.01411616f, 0.05534246f, 0.01140871f, 
    0.00763228f, 0.02994735f, -0.09038947f, 0.06716932f, 0.00302575f, 0.01680925f, -0.05906044f, -0.00870210f, 
    -0.01203639f, -0.05931531f, 0.01181182f, -0.09027466f, -0.03227471f, 0.01586284f, 0.09996331f, -0.07060303f, 
    -0.16274923f, 0.06842373f, 0.13235146f, -0.01334493f, -0.03186756f, -0.14162691f, 0.00878329f, -0.09126550f, 
    -0.34977821f, 0.01309630f, -0.09056547f, 0.04064911f, 0.16322361f, -0.02208618f, -0.00340678f, 0.04244000f, 
    -0.05048661f, 0.01269015f, -0.08899973f, -0.09478148f, -0.34932247f, -0.04664325f, -0.02144295f, -0.01365600f, 
    -0.04349824f, -0.06623600f, 0.06865172f, -0.02898616f, -0.10223734f, -0.04281751f, -0.04152828f, -0.00857740f, 
    0.12297075f, -0.09507071f, -0.04976342f, 0.03827772f, 0.10495523f, 0.06945441f, 0.07203037f, -0.04065707f, 
    0.01637397f, -0.04803933f, -0.07754641f, -0.09118725f, 0.03381312f, 0.09674490f, -0.06485079f, 0.01512077f, 
    0.07769891f, 0.08443616f, -0.00957496f, 0.06636611f, -0.05817501f, -0.01982827f, 0.04087485f, -0.10488483f, 
    0.12979142f, -0.08699385f, -0.02333008f, -0.05836472f, 0.09010380f, -0.05004910f, 0.05577452f, -0.10016924f, 
    0.09294640f, -0.03127610f, 0.04129176f, 0.02919799f, -0.28590831f, -0.00871310f, 0.01717613f, 0.03114461f, 
    0.11320264f, -0.02844434f, 0.02884622f, -0.01387536f, -0.13714969f, -0.01690689f, -0.05072908f, 0.01210263f, 
    0.19794913f, -0.14947750f, -0.23439202f, -0.22384627f, 0.08335820f, -0.03368052f, -0.13803318f, -0.09011923f, 
    -0.07795775f, -0.01457044f, 0.13413952f, 0.01165225f, 0.10179854f, -0.08525213f, -0.07146399f, 0.09347299f, 
    0.07780797f, -0.06228958f, -0.04063495f, -0.13641012f, -0.03619829f, 0.00301498f, -0.04979363f, -0.07233548f, 
    -0.33851248f, -0.00432208f, -0.00707859f, -0.20183352f, -0.00966230f, -0.12408276f, -0.06480677f, -0.00025659f, 
    -0.01072714f, -0.05833893f, -0.06280197f, -0.05951115f, 0.04880961f, -0.01311568f, 0.16239686f, -0.03063539f, 
    -0.10352673f, 0.06436210f, -0.08342574f, 0.11718196f, 0.04000783f, 0.02218030f, -0.04497833f, 0.02196356f, 
    0.16473441f, -0.03949549f, 0.01726884f, -0.22971559f, 0.05961943f, -0.11048140f, 0.04709326f, -0.03160242f, 
    -0.03870561f, 0.08081017f, 0.06808734f, -0.02516697f, 0.19678994f, -0.10448314f, -0.01083782f, 0.05841677f, 
    0.02967920f, 0.08780316f, 0.02277108f, -0.06926800f, 0.02747272f, 0.16331574f, -0.01442159f, 0.07616307f, 
    -0.00310476f, -0.00900848f, -0.06919205f, -0.06292503f, -0.08299810f, 0.03080276f, -0.08654775f, -0.01930751f, 
    -0.06060587f, -0.06722479f, -0.01285827f, -0.12462616f, 0.14829564f, 0.13440572f, -0.07725903f, -0.03505979f, 
    0.02805195f, 0.02644708f, -0.03299160f, -0.01025304f, -0.06858220f, 0.14185204f, 0.00811495f, -0.09231973f, 
    0.12053709f, 0.07121414f, -0.04425263f, -0.13941516f, 0.00408312f, 0.02398772f, -0.10601316f, 0.04535702f, 
    0.01079479f, 0.01739720f, -0.15373425f, -0.19147688f, 0.12244490f, 0.08112598f, 0.05739686f, 0.04277334f, 
    0.03433519f, -0.09928003f, 0.19315670f, 0.01387480f, -0.07966179f, -0.05733784f, 0.05594458f, 0.01286768f, 
    0.01159078f, -0.02804069f, 0.06689280f, 0.02150457f, 0.11889160f, 0.01163972f, 0.04014765f, -0.10245926f, 
    -0.06326892f, 0.05627319f, -0.02345874f, 0.01131556f, -0.17497936f, -0.10965236f, -0.12729453f, -0.06658726f, 
    0.10407658f, 0.01725720f, -0.01972512f, -0.02846858f, 0.10485313f, -0.14997886f, 0.04966284f, -0.00179986f, 
    0.22314376f, 0.17140181f, 0.04270834f, 0.29916695f, -0.10556326f, -0.08421659f, 0.02671959f, 0.06235770f, 
    -0.04328584f, 0.02315861f, 0.01667832f, 0.02185693f, -0.05388768f, -0.05328713f, -0.00678323f, -0.10622539f, 
    -0.04186117f, 0.10503512f, 0.01673792f, -0.06336057f, -0.11200450f, -0.01951689f, 0.00687777f, -0.10528105f, 
    0.11154328f, -0.03894551f, 0.06399524f, -0.11230528f, 0.00954404f, 0.03007158f, 0.12779105f, 0.14110227f, 
    0.02058989f, 0.03223015f, -0.03547088f, -0.01050350f, -0.04700136f, 0.03943348f, -0.04947598f, -0.10105002f, 
    -0.18829633f, -0.07212372f, 0.11146722f, 0.06240106f, -0.13329217f, 0.01606350f, -0.00565281f, -0.08678833f, 
    -0.29303837f, -0.14147592f, -0.05797221f, 0.02524234f, -0.08017343f, -0.07048076f, -0.04796563f, -0.02866426f, 
    -0.03458956f, -0.05518646f, 0.00459549f, -0.02153876f, 0.31067541f, 0.09347241f, -0.49681500f, -0.05645250f, 
    0.03767854f, 0.03296443f, -0.07387935f, -0.02919536f, 0.00620234f, 0.01473374f, -0.01856639f, -0.08832904f, 
    0.09463774f, -0.21626936f, -0.06983399f, -0.02292584f, -0.08838791f, 0.06074263f, 0.00379068f, -0.08101973f, 
    -0.00354874f, 0.01240684f, -0.00376193f, -0.11131687f, 0.14602758f, 0.14548375f, 0.06425714f, 0.10779882f, 
    -0.06057243f, 0.02608631f, 0.08221127f, 0.05326629f, -0.04712765f, -0.00755409f, -0.03838819f, -0.02190013f, 
    0.06089932f, 0.01185870f, -0.15004231f, -0.04882884f, -0.02542266f, -0.01259336f, -0.05736520f, -0.06218676f, 
    0.05501675f, -0.00209430f, -0.01562154f, 0.04026719f, 0.00830858f, 0.09071126f, -0.14978610f, -0.06934709f, 
    -0.00510504f, -0.02578477f, -0.00314556f, 0.00547718f, -0.05785296f, -0.01036243f, 0.06985889f, -0.02663310f, 
    0.17148389f, -0.13243960f, 0.03416389f, -0.11323158f, 0.09043049f, -0.02527131f, -0.01648168f, -0.11601457f, 
    0.09710632f, 0.09255899f, 0.04395227f, -0.04984395f, 0.07432537f, 0.01073430f, 0.12526464f, 0.10817047f, 
    -0.17647943f, -0.12143429f, -0.16851872f, 0.01199250f, -0.05743275f, 0.10449722f, 0.03824198f, -0.08474827f, 
    -0.04024359f, 0.14868681f, -0.03912027f, 0.00434344f, -0.07939397f, -0.07898942f, 0.03162115f, 0.04702292f, 
    -0.02974370f, 0.03594320f, -0.03961689f, -0.05977534f, 0.01963452f, -0.08329813f, -0.27591026f, 0.02782581f, 
    -0.06553140f, -0.09011532f, 0.01897141f, -0.04060455f, 0.01074458f, 0.06963779f, 0.08610253f, -0.03922426f, 
    0.46860370f, 0.05764974f, 0.10682210f, 0.08615534f, -0.06496609f, 0.00676435f, 0.00173607f, -0.02834980f, 
    -0.03450589f, 0.09137308f, -0.00997156f, 0.01055342f, 0.27439979f, 0.01353075f, -0.19758606f, 0.07756950f, 
    -0.12486150f, 0.00554149f, -0.07011714f, -0.00160294f, 0.02780085f, 0.00382435f, -0.07453813f, -0.09936040f, 
    0.09335554f, 0.04393169f, -0.14728947f, -0.00180035f, -0.00307250f, 0.02263944f, 0.00781161f, -0.10960600f, 
    -0.08921527f, -0.04040828f, 0.09297591f, -0.00683328f, -0.18770988f, -0.00492268f, -0.07745347f, -0.00914995f, 
    0.06989405f, 0.08249646f, 0.02472035f, 0.02714834f, -0.03477528f, -0.01285840f, -0.11818601f, 0.02939904f, 
    0.24106404f, -0.05166718f, -0.09409364f, 0.06302349f, -0.15134746f, -0.02444779f, 0.12402064f, 0.06768852f, 
    -0.02155733f, 0.04540672f, 0.00226763f, -0.01764555f, 0.34264797f, 0.01093515f, -0.02404345f, -0.19323568f, 
    -0.04334270f, -0.01010798f, 0.04165744f, -0.08089551f, -0.06964837f, 0.04597668f, -0.05974461f, -0.07554813f, 
    -0.11592034f, 0.11299898f, -0.28849313f, -0.37292552f, -0.07756034f, 0.04788288f, 0.01033878f, -0.00511901f, 
    -0.08241513f, 0.07384963f, 0.02465265f, -0.10637251f, 0.17294690f, -0.01311935f, 0.16268231f, 0.19823828f, 
    -0.01438213f, -0.07145847f, -0.04395443f, 0.02024187f, -0.07557023f, -0.05458833f, 0.05496061f, 0.04281253f, 
    -0.09674454f, 0.00001926f, -0.07370236f, -0.05095949f, -0.06336675f, 0.02536609f, -0.15313163f, -0.04498249f, 
    0.03651640f, -0.04551176f, 0.07259343f, -0.06859126f, 0.18724714f, 0.00132492f, 0.07090849f, 0.09297518f, 
    -0.12118458f, -0.10898144f, -0.09329609f, 0.02317598f, -0.04446210f, 0.00833534f, 0.10943268f, -0.02623913f, 
    -0.05250640f, 0.13274048f, 0.08175318f, 0.22122122f, -0.17816707f, 0.04022187f, 0.00167613f, -0.00039673f, 
    -0.07214227f, -0.06724098f, 0.06733540f, 0.05784664f, 0.17884204f, 0.15647520f, 0.06211118f, -0.01047847f, 
    -0.05034628f, -0.00596685f, -0.01575035f, 0.01429755f, -0.13108894f, -0.02984843f, 0.01911498f, -0.03304311f, 
    -0.15564518f, 0.02598567f, -0.01337334f, -0.08548191f, 0.11283894f, -0.01937829f, 0.00556033f, -0.02166396f, 
    -0.07019326f, -0.03877105f, 0.02438150f, -0.11848912f, 0.53637385f, -0.07954718f, 0.02204974f, 0.07035013f, 
    -0.12531632f, 0.10999092f, 0.01938833f, -0.02922231f, -0.02613040f, 0.00970382f, -0.09537619f, -0.08686488f, 
    -0.13100484f, 0.02848064f, -0.00419582f, -0.05234437f, 0.01786657f, 0.02577986f, -0.10114132f, 0.00222470f, 
    0.05528214f, 0.08013552f, -0.07385523f, -0.03305224f, 0.03818738f, 0.18682726f, 0.01601612f, 0.07904541f, 
    0.02986351f, -0.04774722f, 0.09220453f, 0.10594360f, -0.07040055f, -0.02612649f, 0.06055072f, 0.03286475f, 
    0.12170204f, 0.08207906f, -0.02971554f, 0.17807175f, -0.11116613f, -0.05645038f, 0.04009096f, 0.06496689f, 
    0.01105448f, 0.07513488f, -0.01057301f, 0.00589713f, -0.25783953f, -0.04228829f, 0.04091384f, -0.03121811f, 
    0.04169390f, -0.03191728f, 0.06487773f, -0.02115664f, -0.06217396f, -0.07535842f, 0.02611113f, -0.02690009f, 
    -0.41744506f, -0.10109085f, -0.20726310f, -0.34996042f, -0.00577460f, -0.06187747f, -0.04994500f, -0.09114449f, 
    -0.08631837f, 0.02474151f, 0.02092884f, 0.02630383f, 0.10157164f, -0.01213867f, 0.12387166f, 0.11141561f, 
    -0.03364363f, -0.02895801f, 0.05957635f, 0.03149311f, -0.07878823f, -0.05407124f, -0.05834462f, 0.04339248f, 
    0.33524185f, -0.14837009f, -0.05199337f, 0.00252080f, -0.08395429f, 0.02511868f, -0.01947165f, -0.10166718f, 
    0.03055735f, -0.11164438f, 0.05752494f, 0.00779815f, -0.06986132f, 0.13895908f, -0.04358455f, -0.06877672f, 
    0.00540540f, 0.08392008f, 0.08475822f, -0.01558885f, 0.01047861f, 0.05904631f, -0.00391871f, -0.01389073f, 
    -0.00785954f, 0.00817109f, 0.06444819f, -0.04577870f, -0.04674910f, -0.01854229f, -0.02065317f, 0.15346402f, 
    -0.05941616f, 0.05593656f, 0.01518023f, -0.02715232f, -0.27022833f, 0.01501132f, -0.16042906f, -0.21251917f, 
    -0.00115901f, -0.02630444f, -0.15950553f, -0.11624607f, 0.02375053f, 0.14952973f, -0.06292964f, 0.05616576f, 
    0.26974607f, -0.15543926f, -0.12722379f, -0.02243532f, 0.05023667f, -0.02587800f, -0.00089429f, -0.10154717f, 
    -0.08464640f, -0.01282750f, 0.00871261f, -0.13941722f, 0.27053562f, -0.15443270f, 0.03612734f, 0.00009414f, 
    -0.00419083f, -0.06206745f, -0.04605091f, -0.02216694f, 0.09618400f, 0.21451920f, -0.01542992f, 0.04841483f, 
    0.06928712f, -0.01603760f, -0.04265656f, -0.14652337f, 0.10851310f, 0.01816968f, 0.09420919f, -0.01983924f, 
    -0.08417786f, -0.00116753f, -0.06852993f, -0.01314919f, -0.36602017f, 0.13969833f, -0.08609638f, -0.25481406f, 
    0.04669133f, 0.04912954f, 0.02651075f, -0.02854469f, 0.02911208f, 0.03649080f, -0.17965920f, -0.02488292f, 
    0.41110814f, -0.17654185f, -0.04468594f, 0.19527256f, -0.06311835f, -0.01378048f, -0.04113338f, -0.02553822f, 
    -0.00021458f, 0.05085031f, 0.08216092f, 0.00526908f, 0.19636534f, -0.23169100f, 0.01611804f, 0.00899038f, 
    -0.08634803f, -0.05100795f, -0.08942141f, -0.02393160f, -0.02954041f, -0.04823711f, -0.05597481f, -0.09563965f, 
    0.07554570f, -0.16624042f, -0.21752019f, 0.26311243f, -0.04485067f, 0.04121595f, 0.04056704f, -0.07104854f, 
    -0.03750615f, 0.00520980f, -0.06579485f, -0.12903877f, -0.40058738f, -0.10953239f, -0.02068717f, 0.20901752f, 
    0.00522826f, 0.02029409f, -0.07337348f, 0.02352183f, -0.03626942f, 0.01687960f, -0.04589034f, 0.04684265f, 
    -0.26636001f, -0.07575564f, -0.01158248f, 0.01798555f, -0.05442324f, -0.00290635f, -0.06424464f, 0.00448617f, 
    -0.01362562f, 0.02068343f, -0.10814103f, 0.00077950f, 0.03946010f, 0.02253743f, -0.12065674f, -0.02112103f, 
    -0.08931634f, 0.08367532f, -0.00523799f, 0.06580316f, 0.08130926f, -0.01327307f, -0.10584903f, 0.01736399f, 
    -0.14200220f, -0.09195440f, -0.14601049f, -0.30524176f, -0.08723308f, -0.12480615f, 0.02643395f, -0.02225132f, 
    -0.02791833f, -0.01641367f, -0.01492547f, 0.09524772f, -0.33178252f, -0.16775921f, -0.29248685f, 0.08625200f, 
    -0.03514266f, -0.03056835f, 0.05046666f, -0.04726206f, -0.00977477f, 0.03599715f, -0.15341608f, 0.04554600f, 
    -0.21453975f, -0.11939206f, -0.19855034f, -0.04122352f, -0.15156402f, -0.04038925f, 0.00158592f, 0.02351343f, 
    -0.09136274f, -0.07101261f, -0.03032325f, -0.05183688f, -0.13844956f, -0.17017742f, 0.04447693f, -0.03104776f, 
    -0.07058847f, -0.03298282f, -0.09024268f, 0.02421965f, 0.03234375f, 0.05458135f, -0.08112681f, 0.05972944f, 
    -0.26497364f, 0.12306134f, 0.08618277f, -0.03800461f, -0.01338849f, 0.00477155f, 0.10794089f, -0.02048969f, 
    -0.04767139f, -0.04303946f, -0.04650513f, -0.05886330f, -0.07813090f, -0.14810807f, 0.25646001f, 0.04185571f, 
    0.03597153f, -0.09174868f, -0.02594689f, 0.07049762f, 0.05553051f, 0.00864733f, -0.09358608f, -0.08588570f, 
    0.34096989f, 0.14730977f, 0.06445190f, 0.12242721f, -0.02154228f, 0.08696330f, -0.02201903f, 0.02909757f, 
    0.01047903f, -0.14359407f, -0.03155577f, 0.02835004f, -0.00994680f, -0.07410739f, -0.18880592f, 0.12716055f, 
    -0.01807759f, -0.10189966f, 0.08335441f, 0.02056824f, -0.00620680f, -0.03272698f, 0.03485193f, -0.08898283f, 
    0.35228512f, 0.03713516f, -0.30873817f, 0.15103620f, 0.04510895f, 0.00515378f, 0.11581383f, 0.13256380f, 
    0.02002378f, -0.01733016f, 0.00150933f, -0.07602965f, -0.06977558f, -0.33085626f, -0.32387623f, -0.02291666f, 
    -0.07307382f, -0.07716738f, -0.00482924f, 0.03896241f, 0.06874529f, 0.08112648f, -0.10880807f, 0.06262328f, 
    0.02522264f, -0.03668942f, -0.04640898f, 0.10719541f, 0.06107198f, 0.11178146f, 0.02539857f, -0.03950940f, 
    0.00308291f, 0.02817330f, 0.12143140f, -0.04844170f, 0.21407577f, 0.12683980f, 0.10038900f, 0.00718440f, 
    0.11484215f, 0.01804014f, 0.07333735f, 0.05608698f, 0.05945453f, 0.05387340f, -0.00709921f, 0.01840061f, 
    0.05125848f, 0.15680483f, 0.16058247f, 0.10505293f, 0.06824622f, -0.00327875f, 0.02050441f, -0.04865937f, 
    0.09159748f, 0.09782556f, 0.05600236f, 0.01730094f, -0.08862032f, 0.06575523f, -0.11596397f, -0.04961400f, 
    -0.14302120f, -0.03436965f, 0.00977985f, -0.00772628f, -0.07854056f, 0.00138233f, -0.00933768f, 0.06021382f, 
    0.13236248f, -0.15721773f, -0.09032978f, 0.09655029f, 0.03736870f, -0.04747803f, 0.09208778f, -0.06142867f, 
    0.07089660f, -0.05865955f, -0.07798807f, 0.07575407f, -0.49418014f, -0.36704966f, 0.08409279f, -0.00094385f, 
    -0.10226526f, -0.10827287f, 0.05618326f, -0.04260316f, -0.04626166f, -0.03288274f, -0.00447297f, 0.05413107f, 
    -0.16039012f, 0.09530848f, -0.04313489f, -0.06428961f, -0.07946225f, -0.12053321f, 0.08073567f, -0.00338846f, 
    -0.06494631f, -0.04874165f, -0.09748884f, -0.06820936f, 0.13342264f, 0.02616048f, 0.01325155f, 0.03859898f, 
    0.03708969f, -0.08968376f, -0.04152698f, 0.10268073f, 0.00369988f, 0.00179111f, -0.01804012f, -0.16883831f, 
    0.04687486f, 0.01026399f, 0.10870229f, -0.15021594f, -0.04971563f, -0.08348721f, 0.01338337f, -0.08314607f, 
    -0.01920141f, 0.00623502f, 0.04459639f, 0.08389312f, 0.23598821f, -0.63546807f, -0.23121342f, -0.02049490f, 
    -0.18823235f, 0.02223133f, -0.02602268f, 0.08720040f, 0.05590234f, 0.03294976f, -0.08300785f, -0.06801713f, 
    0.13295034f, 0.04219962f, 0.08702584f, -0.09073431f, -0.15857804f, -0.12988596f, -0.06216304f, -0.06294437f, 
    0.03808152f, 0.03510230f, 0.01113765f, 0.09721141f, -0.22121517f, 0.30555642f, 0.18468280f, 0.02019981f, 
    0.08397491f, 0.02782486f, -0.00516195f, 0.14649861f, -0.01539965f, 0.05375736f, -0.04959421f, 0.01445606f, 
    0.48436987f, 0.22443698f, 0.06119708f, 0.08167005f, 0.03088721f, 0.03093482f, -0.05554789f, -0.07220520f, 
    -0.03293923f, -0.06864048f, 0.06818189f, -0.11956188f, -0.11445157f, -0.00289407f, -0.12771805f, -0.18207036f, 
    -0.05346608f, -0.09416788f, -0.03163576f, -0.06007026f, 0.02699525f, 0.05674558f, -0.02916178f, -0.04666726f, 
    0.00103756f, 0.20855366f, 0.14446190f, 0.19968729f, -0.01508133f, -0.07868342f, -0.02843894f, 0.03176962f, 
    -0.03309500f, 0.08829374f, -0.06910738f, -0.02777470f, -0.10855111f, 0.17158145f, 0.02447328f, 0.01073029f, 
    -0.03254472f, -0.03707141f, 0.00788935f, 0.00844235f, -0.05526586f, -0.01618848f, -0.03453254f, -0.00895166f, 
    0.24590327f, 0.18553029f, 0.19776016f, 0.09487653f, 0.00794717f, 0.03356862f, -0.12488918f, 0.15338138f, 
    0.04018436f, 0.04482307f, -0.05888049f, 0.04447246f, 0.11980528f, 0.05603828f, -0.06339497f, -0.02352874f, 
    -0.21290147f, -0.05572844f, -0.02700371f, -0.00262296f, -0.01717644f, 0.01547704f, 0.06255483f, 0.05645679f, 
    -0.05731543f, -0.09291025f, -0.11326712f, -0.14521259f, -0.04421699f, 0.00172010f, 0.04207627f, 0.06235506f, 
    -0.13254808f, -0.04310253f, -0.02115939f, 0.06652458f, 0.28121027f, 0.11267496f, -0.03422788f, -0.03973576f, 
    0.01391750f, 0.01655054f, 0.13308023f, -0.05023269f, -0.02067065f, 0.08598919f, 0.00365195f, 0.01057299f, 
    0.05783085f, -0.10922900f, 0.12177461f, -0.04765181f, 0.07730455f, 0.09400086f, 0.04227891f, -0.03190778f, 
    -0.08429971f, 0.06841074f, -0.11205759f, 0.06397219f, -0.20614120f, 0.06068604f, 0.07664782f, -0.02836589f, 
    0.02073567f, -0.09820823f, 0.04251283f, 0.06807556f, 0.06772124f, -0.00785667f, 0.00117941f, -0.02000037f, 
    -0.19119243f, -0.16769697f, -0.07443973f, 0.18478435f, 0.06131604f, -0.00352263f, 0.00853112f, -0.02044526f, 
    -0.04457296f, -0.05994419f, -0.01639375f, -0.15770446f, -0.26033810f, -0.10912643f, 0.06232533f, -0.00116445f, 
    -0.04798061f, -0.01913667f, 0.11322652f, -0.07394859f, -0.07056576f, -0.05868504f, 0.02448660f, 0.01710480f, 
    -0.22071126f, 0.05001424f, 0.04677688f, -0.14497063f, -0.02004773f, -0.11241592f, -0.04091383f, 0.00512127f, 
    -0.04411238f, -0.04732540f, 0.02304538f, -0.10819314f, 0.24078986f, -0.05317199f, 0.04448386f, 0.07759110f, 
    -0.02575085f, 0.03869187f, -0.00925081f, -0.11549862f, 0.07636210f, 0.03611296f, 0.02698841f, -0.01080845f, 
    0.12366752f, 0.20322546f, 0.04904295f, 0.06697533f, -0.01484631f, 0.06641743f, 0.05055010f, 0.15989582f, 
    -0.00249559f, 0.11200842f, 0.03368505f, 0.04756445f, -0.02087282f, -0.07554211f, 0.03116814f, -0.06983436f, 
    -0.06706476f, 0.03367504f, -0.01088536f, 0.05233046f, 0.02292167f, -0.03581367f, -0.06259058f, 0.09912051f, 
    0.21829721f, 0.00669335f, -0.01516754f, 0.03700096f, -0.08815703f, -0.11877645f, -0.05806855f, 0.02479718f, 
    -0.04054593f, -0.03750554f, 0.05647928f, -0.05451560f, -0.00936155f, 0.03016983f, 0.05814897f, -0.17704120f, 
    0.02231421f, -0.06959645f, 0.03594031f, 0.00620393f, -0.01942535f, -0.13838004f, 0.02664613f, 0.03903631f, 
    0.11149701f, -0.16658396f, -0.07126526f, -0.09831596f, -0.10124415f, 0.03663725f, -0.01081987f, 0.01209434f, 
    -0.04297021f, -0.09360056f, 0.00964890f, -0.01310458f, -0.17560054f, 0.06750748f, -0.06835881f, -0.24972919f, 
    0.01358767f, -0.02424304f, -0.05688502f, -0.17540108f, -0.03536170f, 0.08592849f, 0.07492348f, 0.03853739f, 
    0.07901945f, -0.08654599f, 0.11102432f, 0.19719155f, 0.06900976f, 0.05420751f, 0.03309811f, -0.05878911f, 
    0.02826839f, 0.01863794f, -0.15926938f, -0.04403263f, -0.17820129f, 0.15534171f, 0.13982162f, 0.09886561f, 
    -0.03929977f, 0.16434576f, -0.01115504f, 0.02855154f, -0.07466626f, 0.13663889f, -0.11578959f, -0.05460051f, 
    -0.12266733f, -0.11274814f, -0.01202630f, 0.08006714f, -0.05214218f, 0.14246434f, -0.00855981f, 0.00298416f, 
    0.08253738f, -0.01568385f, 0.09848744f, 0.04888331f, -0.27723753f, 0.09102467f, -0.03946088f, 0.00788790f, 
    -0.02938313f, 0.06241973f, -0.09830733f, -0.01039446f, -0.07590076f, 0.06924113f, 0.03611153f, -0.02736409f, 
    -0.09997551f, -0.08032902f, 0.00820284f, -0.10362608f, -0.03348586f, 0.00772795f, 0.06984711f, 0.04053582f, 
    -0.02371258f, 0.02828138f, -0.02259955f, -0.03637424f, -0.19124253f, -0.04375637f, -0.01558160f, -0.07298366f, 
    -0.00865594f, 0.10699566f, 0.03101096f, 0.01445375f, -0.00349324f, 0.10922920f, 0.02780554f, -0.02578452f, 
    -0.00634849f, 0.13164894f, 0.02431529f, 0.09957107f, -0.10454288f, 0.05618222f, -0.04781890f, 0.01779263f, 
    0.01883866f, 0.00389048f, -0.04297883f, 0.07678358f, 0.08075263f, 0.00424126f, 0.03045115f, 0.02586951f, 
    -0.05910394f, -0.05120369f, -0.06002860f, -0.07654999f, -0.06073813f, -0.04644752f, -0.00670239f, 0.07919568f, 
    0.06242343f, 0.12205052f, 0.14913484f, 0.05473097f, 0.06642147f, 0.01899295f, -0.10921441f, -0.04623107f, 
    -0.02539805f, -0.04078534f, 0.05772996f, -0.01471545f, -0.54150426f, -0.31770608f, -0.42533097f, 0.11838818f, 
    -0.07882850f, -0.03409566f, 0.11080353f, -0.09997977f, -0.11621106f, -0.02141197f, 0.04012578f, -0.01067363f, 
    -0.03346494f, -0.22419262f, 0.00840791f, -0.23292950f, -0.04440773f, 0.07470191f, -0.01148460f, -0.04876475f, 
    -0.10931974f, 0.10025258f, -0.00319775f, -0.16369841f, 0.16635180f, 0.11587646f, 0.06185419f, 0.00166619f, 
    -0.09776411f, -0.06962785f, -0.00026921f, 0.01877587f, -0.01245657f, 0.08262763f, -0.02115949f, 0.08985805f, 
    -0.39067793f, 0.00284529f, 0.19059552f, 0.25246570f, 0.13122435f, 0.06888237f, -0.05802481f, -0.09225225f, 
    0.01312320f, -0.01726508f, -0.00828968f, 0.03160564f, -0.37890100f, -0.15917633f, -0.07301186f, -0.14711437f, 
    0.01559307f, -0.05372465f, -0.04515526f, -0.02452918f, 0.12599984f, 0.03666540f, 0.09900416f, 0.06292577f, 
    -0.12437568f, -0.09645213f, -0.11155363f, 0.02571712f, -0.06849154f, -0.04915819f, 0.02847408f, 0.00645674f, 
    0.01184687f, -0.02843370f, 0.09102619f, 0.07119382f, 0.33215448f, -0.00442891f, -0.05558791f, 0.26513979f, 
    -0.01461567f, 0.06666688f, -0.02915983f, 0.10012252f, 0.09829507f, -0.03117254f, -0.04941403f, -0.01740774f, 
    0.17775691f, 0.00634956f, 0.06828526f, 0.04940752f, -0.04727248f, -0.13892888f, 0.06316218f, -0.13589890f, 
    -0.04372295f, 0.02470821f, -0.01659190f, 0.04156162f, -0.04404593f, -0.02641843f, 0.16090475f, 0.10132608f, 
    0.08001835f, -0.04308272f, 0.06600229f, -0.04431314f, -0.01413094f, 0.05154385f, -0.19682348f, 0.05179935f, 
    -0.00234909f, 0.01044538f, 0.06243496f, 0.06591492f, -0.00366085f, 0.04861428f, 0.05989138f, -0.04068901f, 
    0.09986095f, -0.17123035f, -0.08344105f, -0.04637137f, -0.31720904f, -0.13736314f, 0.01065640f, -0.19850357f, 
    -0.11692218f, 0.04789840f, -0.00586725f, 0.15604012f, 0.01025703f, 0.01857481f, -0.04721992f, -0.00941589f, 
    -0.22203138f, 0.06806058f, -0.03777551f, -0.11054294f, -0.05587383f, -0.00146582f, 0.04062806f, 0.11236408f, 
    0.08354505f, -0.06063865f, 0.03697190f, 0.03332099f, 0.07592683f, -0.02870776f, -0.11907233f, 0.08820142f, 
    -0.11777072f, 0.03209351f, 0.08087971f, -0.04649511f, -0.04851929f, 0.09063837f, -0.03488013f, -0.05742152f, 
    -0.06358655f, -0.04027138f, -0.08769782f, 0.06767336f, -0.15316218f, 0.02366692f, -0.00513113f, 0.07733268f, 
    -0.08841327f, 0.03769920f, -0.08333400f, 0.05277649f, 0.01457311f, 0.00069356f, 0.09925066f, -0.02652650f, 
    -0.10534198f, 0.09801129f, -0.07989833f, 0.06011691f, 0.02862823f, 0.11512662f, -0.01833199f, -0.00033792f, 
    0.20160924f, 0.02831775f, -0.00744803f, -0.02340982f, -0.00606251f, -0.04859737f, -0.09836985f, -0.05689686f, 
    0.01917864f, -0.03661195f, 0.07486568f, -0.05847550f, -0.06082173f, 0.01093643f, -0.02159556f, 0.06236744f, 
    -0.12883435f, -0.01076703f, 0.00769829f, -0.06332701f, 0.05347740f, 0.00057924f, 0.08666667f, 0.01241427f, 
    -0.00380677f, -0.14714949f, 0.00188924f, -0.10642073f, 0.01754153f, -0.00196673f, -0.03733425f, -0.09033345f, 
    0.03176076f, 0.02941689f, -0.12990841f, 0.00861297f, 0.04565481f, 0.32412124f, -0.18543875f, -0.28119719f, 
    0.01441494f, -0.05829165f, -0.04838217f, 0.00385943f, -0.06594426f, -0.07656810f, 0.10368361f, -0.06227874f, 
    -0.02920108f, 0.10532168f, 0.17439204f, -0.06784745f, -0.01017132f, 0.05957162f, 0.01575144f, 0.14450161f, 
    -0.13767038f, 0.02056049f, 0.03897122f, 0.08682866f, -0.38353509f, -0.09555046f, -0.20626026f, -0.03278175f, 
    0.02592381f, 0.01515204f, 0.03477868f, -0.00668520f, 0.04657388f, -0.01701978f, 0.10904713f, 0.08913625f, 
    -0.28388169f, -0.01389122f, 0.03532124f, 0.02632797f, -0.14432770f, 0.10700729f, 0.00534960f, -0.07103904f, 
    0.04791781f, -0.20278828f, 0.07411516f, 0.02168051f, -0.05830215f, 0.03722949f, 0.00897230f, 0.07311075f, 
    0.03667855f, 0.07744389f, 0.03232771f, 0.10930528f, -0.03783426f, -0.01230611f, 0.00655602f, 0.06406040f, 
    0.08237854f, -0.04266751f, -0.10296368f, 0.04737030f, 0.00010695f, 0.07149915f, -0.03286963f, 0.00478403f, 
    -0.05953523f, 0.05597098f, -0.00287682f, -0.05379166f, 0.30977362f, 0.40779766f, -0.03328084f, -0.17595272f, 
    0.06833327f, -0.00827271f, 0.05094399f, 0.09226695f, 0.01263133f, 0.18544000f, -0.12448698f, 0.07869635f, 
    -0.18342052f, -0.09054837f, 0.11407072f, 0.09950290f, 0.08194444f, -0.06491632f, 0.02232471f, -0.13347566f, 
    0.06281815f, -0.06823888f, -0.04140633f, 0.07526843f, -0.07711665f, -0.31797948f, -0.32246345f, 0.10967849f, 
    0.03246520f, -0.01045739f, -0.03222248f, -0.10729244f, -0.03960830f, -0.09638606f, -0.09135609f, -0.01237261f, 
    0.20559976f, 0.17840092f, -0.03461112f, 0.06877897f, 0.02825292f, 0.04081658f, 0.04307856f, 0.00302527f, 
    -0.06215209f, -0.13417687f, 0.06208042f, -0.01006551f, 0.33839342f, 0.02657220f, -0.04436138f, -0.07444271f, 
    0.04452553f, -0.04297356f, 0.00928942f, -0.06104863f, -0.00362652f, 0.03526369f, 0.04448408f, 0.08452032f, 
    -0.31923488f, -0.05173119f, 0.01258300f, 0.12922479f, 0.00590606f, -0.01768469f, 0.07038085f, -0.06495461f, 
    0.03304449f, -0.06174065f, 0.05604360f, -0.01466702f, -0.05028859f, 0.07413679f, -0.06420387f, -0.04692774f, 
    -0.02508056f, 0.05903623f, 0.05668948f, 0.05833030f, -0.03606358f, 0.08382098f, 0.04114994f, -0.03778671f, 
    -0.10142843f, -0.07157958f, -0.09725755f, -0.17729910f, 0.01013487f, 0.05901015f, -0.02329940f, -0.12739760f, 
    -0.02223393f, 0.01227338f, -0.03699926f, 0.01630346f, -0.08053008f, -0.35128549f, 0.01195581f, -0.10290872f, 
    -0.09557538f, 0.09330186f, 0.09014743f, -0.12906133f, 0.06738648f, 0.02603581f, 0.01124403f, -0.04218681f, 
    0.14927864f, 0.05829718f, 0.08239803f, 0.11797173f, 0.04753472f, -0.05155126f, 0.09548393f, 0.13455120f, 
    0.01725400f, -0.13513915f, 0.07289477f, 0.03389732f, -0.19862066f, 0.11799897f, 0.13155119f, 0.08664171f, 
    -0.06150520f, -0.06171912f, 0.07553615f, -0.05049531f, -0.00841428f, -0.09024368f, -0.02632649f, -0.02145748f, 
    0.33241063f, 0.07622056f, -0.13845730f, 0.04895571f, -0.06988344f, -0.03926777f, 0.00359100f, -0.08664338f, 
    -0.08910204f, -0.04916501f, -0.00089292f, 0.02289020f, 0.15524973f, 0.09218983f, 0.03838976f, 0.20129965f, 
    0.00891384f, -0.01689507f, 0.02299707f, 0.00686330f, 0.02433349f, 0.02884193f, 0.03160040f, -0.01923713f, 
    0.07148497f, 0.04644589f, -0.04795008f, -0.07304408f, 0.02733417f, -0.12010060f, -0.01771205f, 0.07287667f, 
    -0.16592900f, -0.00011235f, 0.01338182f, 0.09210207f, -0.11479127f, -0.27653494f, 0.09156618f, -0.14176318f, 
    0.14324622f, 0.11730225f, 0.10775390f, 0.06661713f, 0.01171181f, 0.00900381f, -0.03772371f, -0.05954237f, 
    -0.27203733f, 0.27500352f, -0.01481916f, -0.08709008f, -0.09754884f, 0.00174920f, 0.05784788f, -0.00317065f, 
    0.06420819f, -0.02625607f, -0.02556350f, -0.03511346f, 0.04273283f, 0.02900151f, -0.12593254f, 0.10944153f, 
    0.10037450f, 0.12439810f, 0.03019379f, 0.12733145f, 0.01170083f, 0.09179443f, 0.14330333f, 0.03122352f, 
    -0.09252045f, 0.01283552f, 0.20731035f, 0.25228256f, 0.00290241f, -0.07170156f, 0.05801814f, 0.10642900f, 
    -0.00536417f, 0.05164151f, -0.05565202f, 0.06405327f, 0.29240906f, -0.05329137f, -0.27407578f, -0.10271249f, 
    0.05289084f, -0.13325028f, 0.01083975f, -0.06890179f, -0.11578436f, 0.06115985f, 0.02058234f, -0.10342637f, 
    -0.55542672f, 0.06420107f, -0.06305344f, -0.19050381f, 0.05764335f, -0.00265643f, 0.00453057f, 0.03689930f, 
    -0.09458803f, -0.01845081f, -0.02039300f, 0.04979474f, 0.39660794f, 0.24703391f, -0.15292402f, -0.30201405f, 
    0.02842062f, -0.09867017f, 0.01977702f, 0.03508979f, -0.03325078f, -0.04809884f, -0.04592802f, 0.01419387f, 
    -0.18931971f, -0.17241426f, 0.17364116f, 0.20419669f, -0.15725146f, -0.06718963f, -0.00670333f, -0.07395899f, 
    0.09581896f, 0.00351814f, -0.07270014f, -0.20230474f, 0.10971592f, 0.16494396f, -0.07861490f, 0.02740623f, 
    0.06499501f, 0.06295286f, 0.09165356f, 0.00662549f, -0.02871951f, -0.04346189f, 0.08182028f, 0.02407561f, 
    0.00328256f, 0.14172955f, -0.04848986f, 0.02693001f, -0.03063031f, -0.02889446f, 0.01315142f, 0.09618764f, 
    -0.04891650f, -0.01054264f, 0.11748509f, 0.08260865f, -0.01598911f, -0.10866324f, -0.07613116f, 0.06746151f, 
    -0.07442708f, -0.02097049f, 0.04657699f, -0.01679055f, -0.02963988f, -0.01366871f, -0.08166879f, 0.00762957f, 
    0.28989631f, -0.13921340f, -0.02658684f, -0.26442733f, 0.06516982f, 0.05173356f, 0.17280774f, -0.04583163f, 
    -0.02399514f, -0.04636768f, 0.02612744f, 0.15247551f, -0.47371745f, 0.00984300f, 0.16479445f, 0.19298416f, 
    0.00330579f, -0.03779896f, 0.07275148f, -0.02454170f, -0.04463310f, 0.05664449f, -0.00279212f, 0.06830828f, 
    -0.09440594f, -0.01353621f, -0.16306880f, -0.12867397f, 0.08501416f, -0.02228450f, -0.07205998f, 0.02232870f, 
    -0.05805419f, -0.03180837f, -0.04626724f, 0.02804609f, -0.00238114f, -0.06810554f, 0.07373112f, 0.16864461f, 
    0.01137028f, 0.04554152f, -0.01846220f, 0.05931280f, -0.08741578f, -0.02227625f, 0.01145843f, 0.01367135f, 
    -0.34168836f, 0.15878947f, -0.00411327f, 0.07134373f, 0.00193540f, 0.01703180f, -0.00479108f, 0.09281863f, 
    -0.07585280f, -0.13863879f, 0.02251323f, -0.02165489f, -0.03395627f, 0.06417410f, -0.07623508f, 0.00882401f, 
    0.19599865f, -0.10228609f, -0.10309664f, 0.12387268f, -0.00595353f, -0.13347565f, 0.11945744f, 0.02550912f, 
    -0.06595307f, 0.01136725f, 0.04925707f, 0.12052217f, -0.01021643f, 0.06332097f, -0.06993492f, 0.00939200f, 
    0.06349631f, -0.11253075f, -0.13126437f, -0.03234790f, -0.34438041f, -0.02824523f, 0.01904125f, -0.01231126f, 
    0.11493016f, -0.00620317f, -0.11733944f, -0.07952398f, 0.08624303f, -0.00271756f, -0.06171045f, -0.05422122f, 
    -0.14340390f, 0.00653122f, 0.07753807f, 0.07083562f, -0.04200313f, 0.16724250f, -0.05644217f, -0.02287585f, 
    0.09010145f, 0.03930081f, -0.05784753f, 0.07525519f, -0.19779640f, -0.22150205f, 0.03253783f, 0.22778897f, 
    -0.02229902f, 0.04833473f, 0.05495941f, 0.03957142f, 0.05386524f, -0.09111153f, 0.04888695f, 0.03941237f, 
    -0.17715727f, -0.09604055f, 0.04871222f, 0.14117454f, -0.00856423f, -0.03099342f, -0.12288019f, -0.00192578f, 
    -0.01235592f, 0.04339096f, 0.02464040f, 0.00067572f, -0.03925290f, -0.08211748f, 0.16842870f, 0.09652165f, 
    0.02731881f, 0.02041818f, -0.07974312f, -0.06992381f, 0.00252483f, -0.11613128f, 0.08937907f, -0.01159597f, 
    0.19703762f, -0.01415896f, 0.10381493f, 0.03625120f, 0.00287083f, 0.01437666f, 0.09415760f, 0.06103356f, 
    -0.01059401f, -0.01280891f, 0.12205465f, 0.10341077f, -0.46660316f, 0.07339066f, 0.11380813f, 0.16654341f, 
    -0.00357055f, -0.13818346f, 0.09282232f, -0.06811080f, -0.07381261f, 0.00981675f, -0.06111681f, -0.00855286f, 
    -0.49877185f, 0.01626391f, 0.01247918f, -0.03134975f, 0.06369419f, 0.02768237f, 0.13571639f, 0.01884902f, 
    -0.11569895f, 0.08041684f, 0.00888166f, 0.06721937f, -0.15563971f, -0.11102624f, 0.09128482f, -0.04843718f, 
    -0.12087061f, 0.02114432f, 0.02214432f, 0.09884755f, 0.16615874f, 0.03007432f, 0.06892003f, -0.02829791f, 
    -0.42624050f, -0.03718734f, 0.13187313f, -0.06233793f, -0.00834048f, -0.06384934f, -0.11633459f, 0.00028672f, 
    -0.04339035f, 0.01251704f, 0.05718763f, -0.05359271f, -0.00455156f, 0.00371980f, 0.11223087f, -0.12420654f, 
    0.04070050f, -0.03051921f, -0.06571073f, 0.06089847f, 0.09455850f, 0.04858728f, -0.05545700f, 0.05740671f, 
    -0.30671033f, 0.02945824f, 0.19878531f, 0.03864342f, 0.03872871f, -0.10272117f, -0.09941939f, -0.08608282f, 
    0.08876053f, 0.03642772f, -0.05954799f, -0.02844151f, -0.07637060f, 0.29247949f, -0.08979917f, -0.01709307f, 
    0.07282410f, -0.12229416f, -0.02396705f, 0.09627401f, 0.01790379f, -0.05802676f, -0.06589104f, 0.05536003f, 
    0.08199305f, 0.10393333f, 0.14345345f, -0.17393190f, 0.00311669f, 0.03855707f, 0.08399564f, -0.00215026f, 
    0.01473664f, 0.00467593f, -0.02769464f, -0.05951149f, -0.12875167f, -0.03154338f, 0.14863740f, 0.02941254f, 
    -0.01550414f, 0.02723765f, -0.12554310f, -0.02613275f, -0.05440866f, -0.00461043f, 0.06749541f, -0.00966589f, 
    -0.32715592f, 0.03381268f, -0.21838805f, 0.06151171f, 0.05457692f, 0.00273578f, 0.06925038f, 0.14393249f, 
    0.01182839f, -0.00863765f, -0.02279132f, -0.04452065f, -0.21172062f, 0.13556978f, 0.05006814f, -0.02411517f, 
    0.09124591f, -0.14607331f, -0.02231693f, 0.06977022f, 0.07349886f, -0.00077012f, -0.05404339f, 0.08581759f, 
    -0.06726970f, 0.00002897f, -0.12736559f, -0.06786803f, 0.06759320f, 0.00042904f, -0.03625889f, -0.03438525f, 
    0.15610442f, 0.05351383f, 0.08572759f, 0.16072130f, 0.08401126f, 0.03824664f, -0.01297194f, -0.14500315f, 
    0.13439995f, -0.05276166f, 0.00558226f, 0.10420033f, 0.15525919f, 0.02310454f, 0.03821028f, 0.01842316f, 
    -0.08900879f, 0.12040728f, 0.11127134f, 0.17384142f, 0.01187445f, 0.01383138f, 0.10074126f, -0.11153582f, 
    0.05196828f, -0.01364189f, 0.01691835f, 0.05358596f, -0.11150460f, 0.07290264f, 0.11539117f, 0.12501280f, 
    -0.02090440f, 0.02839638f, -0.16735347f, 0.09319398f, 0.11830229f, -0.04383601f, 0.06911098f, 0.09139931f, 
    0.08379004f, 0.00505823f, 0.17185046f, 0.01787366f, 0.10176293f, 0.03007265f, 0.11948116f, -0.12754397f, 
    0.17064263f, -0.08794713f, 0.00233271f, -0.06772015f, -0.01285681f, -0.00222395f, 0.00564935f, -0.04005243f, 
    -0.03911625f, -0.06234953f, 0.03423399f, -0.11672623f, 0.05484863f, -0.10896680f, -0.13615967f, 0.01831009f, 
    0.01384509f, 0.05878476f, 0.17096439f, 0.07591900f, -0.00695212f, 0.00176326f, 0.14121538f, 0.02133755f, 
    0.18014824f, 0.02343530f, -0.10680899f, 0.16611928f, 0.00338416f, 0.05138642f, -0.02164182f, -0.08203145f, 
    -0.13111164f, -0.11277013f, -0.01431996f, 0.03046830f, -0.00403700f, 0.06080043f, 0.03974840f, 0.02382521f, 
    -0.22756259f, 0.16588816f, 0.17766610f, -0.31899083f, -0.09834345f, -0.18719319f, 0.10359304f, 0.09081677f, 
    0.10677622f, -0.00190965f, -0.03436082f, 0.03422534f, -0.05011589f, -0.16975346f, 0.33288220f, 0.31496966f, 
    0.03910540f, 0.00986861f, 0.05825448f, 0.03414302f, 0.11025164f, 0.02116226f, -0.06455059f, 0.06450971f, 
    -0.23757625f, -0.32926720f, 0.04075620f, 0.13229741f, 0.05255171f, -0.01986130f, -0.04234173f, -0.03142565f, 
    0.05735708f, 0.04080720f, 0.06086258f, -0.00454998f, -0.32240444f, 0.16820936f, -0.14202860f, -0.18600905f, 
    0.11085676f, 0.03844129f, -0.01546338f, -0.15303230f, 0.06648055f, 0.02801231f, -0.18649521f, -0.05474474f, 
    -0.03612120f, 0.00474454f, 0.18993595f, -0.06776200f, -0.20920722f, 0.12612736f, -0.00621436f, 0.00622298f, 
    -0.16140097f, -0.17267311f, 0.00617703f, -0.09689572f, -0.02677256f, -0.15755750f, 0.11942893f, 0.04417205f, 
    0.03779106f, -0.08711525f, -0.05644276f, 0.00253918f, -0.00768174f, -0.04963212f, 0.00649265f, -0.15232265f, 
    0.08960300f, 0.01924314f, -0.08372312f, 0.02898665f, 0.04297407f, -0.04860437f, 0.10022581f, -0.13159294f, 
    0.03023162f, -0.05415028f, -0.14035632f, -0.09613501f, -0.23459040f, -0.29594338f, -0.10323624f, 0.08146916f, 
    -0.05365906f, -0.02905267f, -0.01537316f, -0.04717975f, -0.01871588f, -0.10926208f, 0.03487699f, 0.02564118f, 
    0.15044844f, -0.03750423f, 0.03056578f, 0.02492278f, -0.01519982f, 0.05525942f, -0.04594681f, 0.06761957f, 
    -0.15727489f, 0.10285337f, 0.12440193f, 0.15316594f, 0.09174285f, 0.02752705f, -0.07881532f, -0.21404640f, 
    -0.13419724f, -0.01482994f, -0.14593115f, -0.08080296f, -0.01093829f, -0.03056127f, -0.04427853f, -0.02107792f, 
    0.06524416f, -0.06361021f, 0.13876624f, -0.32002360f, -0.12488058f, -0.06529495f, -0.08333491f, -0.14446862f, 
    -0.14261910f, 0.01460239f, -0.02416863f, 0.10818692f, 0.09920375f, 0.05507898f, 0.28684714f, 0.07181467f, 
    -0.02960803f, -0.04667377f, -0.01832136f, -0.09251899f, 0.05442899f, -0.10713273f, 0.04419785f, -0.03573149f, 
    -0.34185222f, -0.02758621f, -0.15583952f, -0.12443373f, -0.01367861f, 0.11724667f, 0.04796800f, -0.10704862f, 
    0.13615559f, 0.05233154f, 0.04179223f, 0.00381986f, 0.08792483f, -0.14453943f, 0.12137882f, -0.04932049f, 
    0.01412903f, 0.00353004f, -0.01010517f, -0.10969480f, 0.14884776f, 0.05879100f, -0.09434813f, 0.07209241f, 
    -0.20674632f, 0.03171757f, 0.05165844f, 0.17134552f, 0.08532195f, -0.17589128f, -0.02493108f, 0.02826332f, 
    0.00089973f, 0.08004472f, -0.00250324f, -0.32321623f, 0.18357551f, 0.22468151f, -0.05231038f, -0.02796055f, 
    -0.01600133f, 0.02986768f, -0.03101185f, 0.00260670f, -0.11661261f, -0.11920712f, -0.06691527f, -0.02500731f, 
    0.08107770f, -0.22121523f, 0.00454384f, 0.13004787f, 0.12361883f, -0.00011586f, 0.10373242f, -0.07470606f, 
    0.04115246f, 0.10716390f, -0.01765345f, -0.01215999f, 0.03549558f, -0.09096944f, 0.03395542f, 0.29869777f, 
    0.01528885f, -0.08102275f, -0.05260368f, 0.00972664f, -0.04614159f, 0.05704839f, 0.08331840f, 0.00437520f, 
    0.03465607f, -0.13240005f, 0.11103288f, 0.26527366f, -0.00598542f, -0.10103550f, 0.09794142f, 0.02163132f, 
    -0.05828934f, -0.00302351f, -0.12274454f, 0.07076426f, 0.02763204f, 0.00228355f, 0.00319237f, -0.07886170f, 
    0.07499942f, -0.01691249f, -0.00431062f, -0.23686817f, 0.07787105f, -0.04504696f, 0.08037882f, 0.07640325f, 
    0.01006221f, 0.00659968f, -0.03473254f, 0.06659233f, 0.13208042f, 0.11255054f, 0.04564964f, 0.05020861f, 
    0.06138157f, 0.02303338f, 0.02268021f, -0.18971424f, 0.07630351f, 0.13909374f, -0.09132714f, 0.02879119f, 
    -0.15581110f, -0.01043295f, -0.07713101f, 0.14200534f, -0.00907925f, 0.00146611f, -0.06662415f, -0.05920421f, 
    -0.41135761f, 0.07143842f, 0.26616094f, -0.11483700f, -0.04053535f, 0.01081290f, 0.14179541f, -0.01913342f, 
    -0.00390282f, 0.02702321f, 0.10791849f, -0.01373397f, -0.22435130f, -0.35327303f, -0.21562551f, 0.08005931f, 
    0.11149931f, 0.17218117f, 0.12745903f, -0.08306875f, -0.04441217f, -0.11793844f, -0.12471443f, 0.07587668f, 
    -0.22596748f, -0.24776460f, -0.15358993f, -0.01404405f, 0.03083120f, 0.14051411f, -0.19531630f, -0.22648798f, 
    0.03698448f, 0.03749370f, 0.25453904f, -0.08408122f, -0.01483013f, 0.03448461f, 0.09152915f, 0.06509918f, 
    0.07175581f, 0.21417151f, 0.03669946f, -0.03683811f, 0.16975616f, -0.19159715f, -0.16045979f, 0.02721366f, 
    -0.43556875f, 0.09995846f, -0.04704152f, -0.26880342f, 0.01294804f, -0.01401441f, -0.10169113f, 0.04920737f, 
    -0.00188072f, -0.08835038f, 0.06518176f, -0.12490700f, -0.15412949f, -0.10451055f, 0.14726262f, 0.11642531f, 
    0.00474098f, 0.03563517f, 0.04905932f, -0.07784346f, 0.04471794f, 0.08978610f, -0.06300715f, -0.00101030f, 
    0.13656989f, -0.00052329f, 0.00674040f, 0.05768418f, -0.21995147f, 0.06799299f, 0.02740532f, 0.09521622f, 
    -0.06866435f, -0.00021789f, 0.03907657f, 0.15005058f, -0.06911719f, 0.12514687f, 0.19221629f, -0.22785838f, 
    0.03175491f, -0.08897191f, -0.05201817f, -0.06274058f, 0.02031879f, 0.02622005f, 0.05821800f, -0.09421036f, 
    0.10456387f, 0.17932968f, 0.05588444f, -0.10690890f, -0.00337244f, -0.04016285f, -0.02531287f, -0.12555210f, 
    0.02300570f, -0.00312344f, 0.00355149f, -0.03769921f, -0.12059691f, -0.00035452f, 0.04988103f, 0.10119871f, 
    -0.08375178f, -0.06210916f, 0.00038429f, 0.10514053f, -0.06475684f, -0.18935278f, 0.05480993f, -0.00924376f, 
    -0.16027430f, -0.05150654f, 0.17381793f, -0.03451798f, -0.01710122f, 0.07413423f, -0.13780528f, 0.15205298f, 
    0.08057351f, 0.04725656f, -0.01066376f, -0.06138606f, -0.22400190f, -0.05041619f, -0.26005441f, 0.07405610f, 
    0.03144397f, 0.11858775f, -0.01233832f, 0.06094993f, 0.08428732f, -0.04826179f, -0.01655680f, -0.01310316f, 
    -0.33954298f, -0.21996002f, -0.05074652f, 0.07203212f, 0.10141070f, 0.04766335f, 0.14705685f, -0.06141442f, 
    0.07669941f, 0.10250113f, -0.05751740f, 0.01631036f, 0.13617344f, -0.11305064f, -0.07356120f, 0.07691958f, 
    0.01002695f, 0.10359620f, 0.03538569f, -0.05100661f, 0.00856981f, -0.06373427f, -0.07494038f, 0.07300601f, 
    -0.29739574f, -0.13213992f, -0.31822172f, -0.01303258f, 0.16239163f, -0.07764585f, -0.01052180f, 0.06106594f, 
    0.07848824f, 0.17856906f, 0.09428544f, -0.08721282f, -0.05235420f, 0.09434853f, -0.07494441f, -0.08880606f, 
    -0.06769732f, 0.04185566f, 0.08156057f, 0.13876334f, 0.06669651f, 0.10323219f, 0.00055018f, 0.04796236f, 
    0.07005052f, -0.07459394f, -0.01543229f, 0.05566915f, 0.03136891f, -0.13392892f, -0.03158007f, -0.02957568f, 
    -0.14860588f, 0.05521008f, 0.24271631f, 0.14278960f, -0.12271523f, 0.12264737f, 0.01917887f, -0.25759292f, 
    -0.02045820f, -0.05176112f, -0.02933465f, 0.01732639f, 0.10980120f, -0.06806326f, 0.21116774f, -0.14145835f, 
    0.04579511f, 0.04229403f, -0.03413077f, -0.07770868f, 0.04210425f, -0.05576012f, -0.03778498f, 0.08837136f, 
    -0.06257728f, -0.03334991f, 0.10129192f, -0.07088194f, 0.33810243f, 0.20435892f, -0.05265287f, -0.04693610f, 
    -0.04792654f, -0.03021946f, -0.33254856f, -0.06922058f, -0.05928809f, -0.02750489f, -0.13039884f, -0.00031784f, 
    0.06874555f, 0.02898221f, -0.15908791f, -0.06269486f, 0.10186846f, 0.00278234f, 0.01451664f, 0.04034297f, 
    -0.01748746f, -0.20967853f, 0.00204270f, -0.07006460f, 0.08513140f, -0.16766208f, -0.11268779f, 0.06746028f, 
    0.08969225f, -0.06403440f, 0.05386356f, 0.00795810f, 0.17477018f, 0.12663482f, -0.06231881f, -0.00613458f, 
    -0.05652970f, -0.00609000f, -0.07811686f, 0.25966600f, 0.03778833f, -0.03033897f, -0.06309468f, 0.06019809f, 
    -0.01056449f, 0.02235691f, -0.02405780f, 0.10583078f, -0.00399509f, -0.07731481f, -0.15224828f, -0.19576606f, 
    -0.02110873f, 0.08018190f, -0.00207724f, -0.05548975f, 0.10805720f, -0.12809752f, 0.02201962f, -0.06494243f, 
    -0.10575773f, -0.15564722f, 0.06002040f, -0.14462842f, 0.00603221f, -0.02897363f, -0.02564324f, 0.05745999f, 
    0.05076722f, -0.10439273f, -0.09216593f, 0.05641251f, 0.06355512f, -0.12150325f, 0.08875191f, 0.15412661f, 
    0.03490893f, 0.05465792f, 0.00210324f, -0.04714239f, -0.05992775f, -0.08735123f, 0.10564906f, 0.04158226f, 
    0.41947615f, 0.10398880f, -0.11303007f, -0.13080676f, -0.07100820f, -0.04253065f, -0.03590177f, 0.02584424f, 
    0.01198175f, -0.08451042f, 0.09968548f, -0.07262603f, 0.02967929f, 0.04658012f, 0.02438514f, 0.33312550f, 
    -0.00646362f, 0.12707128f, 0.09711093f, -0.04916774f, -0.04933980f, -0.25813910f, 0.28626978f, -0.23334567f, 
    0.18050881f, 0.11229499f, 0.14710951f, -0.11606248f, -0.01145173f, -0.05027566f, 0.07155278f, -0.06830178f, 
    -0.04648054f, -0.01830975f, 0.05425173f, 0.03496217f, -0.33350426f, -0.14008370f, 0.04570921f, -0.01281323f, 
    -0.04356179f, -0.08829911f, 0.10410841f, 0.12114076f, -0.03111875f, 0.04560380f, -0.11177095f, -0.21346422f, 
    0.01306897f, -0.02039763f, -0.04111383f, 0.14929253f, -0.05781933f, 0.08218681f, -0.04538845f, -0.08778711f, 
    0.03044281f, 0.09997237f, 0.19500607f, 0.16647626f, -0.26492763f, -0.00923650f, 0.03582626f, 0.22893873f, 
    -0.07385331f, 0.03145580f, 0.05587449f, 0.02347715f, 0.01754572f, -0.11941254f, -0.01739540f, -0.08762734f, 
    -0.46682048f, -0.04251968f, -0.04731657f, -0.32771742f, 0.08853620f, 0.01190996f, -0.00220930f, -0.03376289f, 
    -0.03130895f, 0.04973221f, -0.04165249f, -0.04102342f, -0.09739427f, -0.19558154f, -0.13131973f, -0.03156058f, 
    0.13751233f, 0.05424574f, -0.01269778f, -0.08836934f, -0.07730507f, 0.03431064f, 0.21513446f, 0.01787146f, 
    0.09418129f, 0.12323111f, 0.12470938f, -0.52988100f, -0.18465573f, -0.00161638f, 0.11230870f, 0.02274532f, 
    0.07393437f, -0.05228086f, -0.12096231f, -0.12954850f, 0.11265735f, 0.06584769f, 0.00100057f, 0.02630814f, 
    -0.04517379f, 0.09845747f, 0.02296248f, 0.02612100f, -0.08827845f, 0.02158658f, -0.16062775f, -0.06775571f, 
    -0.14478055f, -0.01716754f, 0.08793195f, 0.03333421f, 0.00228519f, 0.03537635f, 0.05780421f, -0.10694818f, 
    -0.05920860f, 0.11659562f, -0.05005122f, -0.02561481f, 0.05394004f, -0.09812311f, -0.15538207f, -0.02382289f, 
    0.05716489f, 0.09089720f, 0.03127723f, -0.09201116f, 0.04515407f, -0.08438838f, -0.05323830f, -0.05110310f, 
    -0.14315954f, 0.13467200f, 0.05783005f, -0.01721965f, -0.18033025f, -0.04415898f, 0.07213994f, 0.11992110f, 
    -0.01897757f, 0.09791392f, 0.03141508f, 0.11762350f, -0.22071238f, 0.20192732f, 0.18109219f, 0.00114649f, 
    -0.09006745f, 0.01934640f, -0.01980977f, 0.07712117f, -0.00598271f, 0.06262507f, 0.09235141f, 0.02102620f, 
    -0.17432433f, 0.09992667f, -0.10315584f, -0.02273728f, 0.05815865f, -0.10013472f, -0.07696503f, 0.11101663f, 
    0.04151336f, 0.01283627f, 0.08334197f, -0.13683929f, 0.07655955f, 0.01275945f, -0.08646093f, 0.28533089f, 
    0.01786212f, 0.02969804f, 0.03974705f, -0.05338427f, 0.00777871f, -0.00584338f, -0.06229092f, 0.04176334f, 
    -0.01231739f, 0.12910046f, 0.09928958f, 0.41122466f, 0.12928295f, 0.03900008f, 0.09086633f, 0.07447123f, 
    -0.08333967f, 0.05601180f, -0.01152245f, -0.07884419f, 0.00535667f, -0.14267334f, -0.16635317f, 0.04947992f, 
    -0.08926938f, -0.04890697f, 0.05435424f, 0.01362403f, 0.06216507f, -0.00451294f, -0.12301230f, -0.10061335f, 
    0.14493439f, -0.03957294f, -0.12891971f, 0.10854778f, -0.04367899f, -0.00199883f, 0.00076053f, -0.00278630f, 
    -0.10685059f, -0.09577829f, -0.04094749f, 0.08433375f, -0.01764214f, -0.29579583f, -0.11179446f, -0.08269935f, 
    -0.08755337f, 0.00210251f, -0.12084246f, 0.12406658f, -0.00432780f, 0.07562724f, 0.07312715f, 0.04827676f, 
    0.02993356f, 0.14632307f, 0.01892319f, 0.15962771f, -0.07246998f, 0.01598765f, -0.11035425f, -0.04023648f, 
    0.04169257f, -0.00083188f, -0.07564557f, -0.04248322f, -0.03977105f, 0.26658285f, -0.02674192f, -0.04010472f, 
    -0.12321313f, -0.04511318f, 0.08876059f, 0.05401180f, -0.00911499f, -0.01550146f, 0.08394929f, 0.09425645f, 
    -0.11544817f, 0.08962279f, 0.07842150f, -0.08648619f, -0.00801774f, 0.01750611f, 0.07871503f, 0.13565950f, 
    -0.01307373f, 0.08502079f, 0.13733208f, 0.09085008f, 0.21112745f, -0.05341265f, -0.19008373f, 0.20356971f, 
    -0.12083054f, -0.00825486f, -0.00047756f, 0.11499885f, -0.08289609f, 0.05392274f, -0.01696007f, 0.13854226f, 
    -0.09146276f, 0.05607526f, -0.01233277f, -0.13810986f, 0.05325615f, 0.05474044f, -0.06467756f, -0.07007439f, 
    0.04834642f, -0.11257610f, 0.13577443f, -0.14102049f, -0.36290815f, -0.01188485f, -0.08391409f, 0.10338137f, 
    -0.02432738f, 0.02025327f, 0.08700235f, 0.07725026f, 0.10038032f, 0.13002427f, 0.02055774f, -0.10117118f, 
    -0.13751324f, 0.18114847f, 0.02107285f, -0.27236980f, -0.14589170f, 0.02106160f, 0.09135879f, 0.06031847f, 
    0.11834431f, -0.02855334f, 0.01058488f, -0.01139888f, -0.09670883f, -0.06043295f, 0.02497318f, -0.08476947f, 
    -0.00092762f, -0.03610577f, 0.03283417f, 0.02846427f, -0.08260804f, 0.02045309f, -0.11244591f, -0.01419575f, 
    -0.28424835f, -0.20263511f, -0.07720183f, -0.04000884f, 0.02320066f, -0.01207194f, 0.02534604f, -0.05441888f, 
    -0.02167065f, -0.07486823f, -0.02775497f, 0.11408776f, 0.01092340f, 0.15931211f, -0.09081894f, -0.14628792f, 
    0.02133728f, 0.06116715f, 0.04023341f, 0.00028727f, -0.02070688f, 0.01349768f, 0.12120008f, -0.02009869f, 
    0.11142330f, -0.02992129f, -0.06584100f, 0.11635123f, 0.07419064f, 0.08305909f, 0.00849539f, -0.00103622f, 
    -0.23123664f, 0.17109458f, 0.01154299f, 0.04078090f, -0.25879925f, 0.11756649f, 0.08580160f, 0.32777917f, 
    0.09235194f, 0.07923799f, -0.20195836f, 0.03428623f, 0.07989050f, 0.09671008f, -0.04667776f, -0.09853206f, 
    -0.27413762f, 0.02055276f, -0.18625106f, 0.08931629f, 0.02613798f, -0.08129751f, -0.13797830f, -0.16156900f, 
    -0.03424666f, 0.02428142f, 0.02062261f, -0.11066210f, 0.08099922f, -0.14813142f, -0.03134641f, -0.09710997f, 
    0.04953490f, 0.01087182f, 0.01157250f, 0.01250150f, -0.00758299f, 0.02480030f, -0.07394750f, -0.07521378f, 
    -0.24303865f, 0.06780043f, 0.08155379f, -0.08542169f, 0.04269741f, -0.02437107f, -0.08732159f, -0.05816945f, 
    -0.14192045f, 0.16490290f, 0.06455783f, -0.00369295f, -0.30248088f, -0.10399188f, -0.10397010f, 0.20105514f, 
    -0.00773855f, 0.03586259f, 0.14925165f, 0.07163815f, -0.05136741f, 0.04918698f, 0.01618622f, 0.01406137f, 
    0.01185226f, -0.07657677f, -0.10892322f, 0.02652398f, -0.10145393f, -0.10811127f, -0.10153576f, -0.00447096f, 
    -0.03560621f, 0.10331117f, -0.02138130f, 0.01304720f, 0.09160441f, -0.05371548f, 0.25234294f, 0.12368680f, 
    0.08232648f, -0.03449043f, 0.05398277f, -0.05717686f, -0.03129268f, -0.01617266f, -0.00459957f, 0.00349742f, 
    0.09181307f, -0.35444766f, -0.17639168f, 0.13050479f, 0.14143887f, -0.01327337f, 0.00265208f, 0.02281331f, 
    -0.06422564f, -0.04674329f, -0.21178667f, -0.06286564f, -0.04078749f, 0.11058816f, 0.10128881f, -0.38606957f, 
    -0.10270228f, -0.04413936f, -0.03739681f, -0.15314537f, -0.02684684f, 0.11251020f, 0.03312975f, 0.08413618f, 
    -0.13795267f, -0.07433143f, -0.07029993f, -0.06434458f, -0.11673289f, -0.13178064f, 0.03301328f, 0.04651716f, 
    0.05472425f, 0.02941313f, -0.14312978f, 0.03115244f, -0.31395540f, 0.10644221f, 0.08195877f, 0.04402823f, 
    0.03427174f, -0.11937828f, 0.01963741f, -0.07676629f, -0.04377406f, -0.11755066f, -0.06350856f, -0.05862387f, 
    0.39813739f, -0.34126478f, 0.09887750f, -0.13200378f, -0.01251497f, 0.01479903f, 0.17205487f, -0.04264082f, 
    0.13316759f, 0.00380105f, 0.12160641f, 0.08489613f, 0.10909560f, -0.18879850f, 0.00056551f, -0.07583709f, 
    0.00353930f, 0.03835440f, -0.00583758f, -0.04464410f, -0.07505322f, 0.03544258f, -0.00585553f, -0.15430491f, 
    -0.02950276f, 0.18611272f, 0.02288209f, -0.27667770f, 0.03802080f, 0.07891619f, -0.00294671f, -0.04710015f, 
    -0.05635148f, -0.06687055f, 0.02666371f, -0.07328352f, 0.12733911f, -0.02093829f, 0.10683451f, -0.27925560f, 
    0.03421632f, 0.05539569f, 0.04502770f, 0.08898083f, -0.02560852f, 0.00315720f, -0.08110337f, 0.06673960f, 
    0.02443497f, -0.36459658f, -0.10345149f, 0.20256917f, -0.03629236f, -0.03409446f, 0.07942723f, 0.01502188f, 
    0.02117734f, -0.02526707f, -0.00556655f, -0.03749615f, -0.19887862f, 0.00572671f, 0.08011442f, -0.11434671f, 
    -0.06251658f, 0.00542341f, -0.06954177f, -0.06597406f, 0.02117731f, 0.08912002f, -0.05301651f, -0.01619214f, 
    0.18166633f, 0.12550284f, 0.25259861f, 0.19206862f, -0.00812910f, 0.00553414f, -0.00975845f, -0.00870081f, 
    -0.02189396f, 0.01983533f, 0.11604586f, 0.14490676f, -0.04852153f, -0.01983610f, -0.22624363f, -0.11976743f, 
    0.04443834f, -0.02455289f, -0.10279121f, -0.02841294f, -0.03564196f, 0.03212719f, 0.01672186f, 0.09098141f, 
    -0.15374333f, -0.10428865f, 0.06906744f, -0.16236660f, 0.02542590f, 0.01581118f, -0.02122945f, -0.06512789f, 
    0.01999982f, 0.02593416f, -0.14874539f, -0.06764065f, 0.08667978f, 0.00380892f, -0.36976674f, 0.12673940f, 
    -0.08376822f, 0.00036643f, 0.02475660f, -0.12061879f, -0.02277560f, -0.05936315f, 0.06795251f, 0.04152396f, 
    0.01530889f, -0.02933256f, -0.15967868f, -0.17114697f, -0.02714008f, 0.00951917f, 0.09011520f, -0.20938678f, 
    0.06257257f, 0.06694276f, -0.07094982f, 0.02823981f, -0.14526272f, -0.11493533f, 0.12782764f, 0.19778691f, 
    -0.07592713f, 0.03513547f, -0.00655162f, 0.07355722f, -0.02818965f, -0.08936101f, 0.01501446f, 0.05183407f, 
    0.04756119f, -0.00938344f, -0.07735164f, -0.10358741f, 0.02870929f, 0.06427041f, -0.03397529f, -0.11975754f, 
    -0.03365764f, -0.09417495f, -0.12481023f, -0.00471500f, 0.44104379f, 0.04193033f, 0.11036908f, -0.20285346f, 
    -0.12030649f, 0.07429115f, 0.06047424f, 0.05252748f, -0.02237597f, 0.05778375f, -0.15093696f, -0.02319724f, 
    0.11198803f, 0.19350845f, 0.06340759f, -0.13206713f, 0.13859719f, 0.01178244f, 0.08883127f, -0.02586769f, 
    -0.08938162f, 0.13278466f, -0.14579365f, 0.10804326f, -0.32043904f, -0.20922935f, -0.20269199f, 0.08778864f, 
    -0.03461539f, 0.00346575f, 0.05259604f, 0.00909720f, 0.10228242f, 0.01196712f, 0.04599482f, 0.19230987f, 
    0.06080388f, -0.08894926f, 0.00629221f, -0.08727980f, -0.10596712f, 0.04765323f, 0.01176147f, -0.08639819f, 
    -0.05417320f, 0.07521609f, 0.01964938f, 0.21164790f, -0.24687992f, 0.11679037f, -0.30575052f, 0.26399744f, 
    -0.06513331f, 0.09371242f, 0.06922914f, 0.08516059f, -0.07091375f, -0.05025827f, 0.11650637f, -0.11641382f, 
    -0.09550992f, -0.18083782f, -0.09260321f, -0.04524877f, -0.14156391f, 0.01163040f, 0.05491503f, -0.07849995f, 
    0.02130970f, -0.12527125f, -0.02787519f, 0.14468837f, -0.18646042f, -0.16653131f, 0.01274733f, -0.12257960f, 
    -0.08019464f, 0.03328160f, 0.00475944f, -0.00296491f, -0.08812945f, 0.09513641f, 0.03092230f, 0.08052331f, 
    0.36458299f, 0.18043670f, -0.01678432f, -0.05123287f, -0.07072105f, -0.06542540f, 0.01551064f, 0.00424537f, 
    -0.00011382f, -0.07088307f, 0.08462726f, -0.00935032f, -0.12708957f, 0.26032186f, 0.16291948f, 0.02592679f, 
    0.04851775f, -0.06521405f, 0.03052820f, 0.00804761f, 0.07172661f, 0.13679075f, -0.07986631f, 0.01420535f, 
    0.00083338f, -0.13898423f, 0.31709138f, 0.06970577f, 0.01557788f, 0.04423150f, 0.00909170f, -0.10925193f, 
    -0.05424429f, 0.07406609f, -0.02981509f, 0.12086470f, 0.01132878f, -0.17748910f, -0.11448030f, -0.03590842f, 
    -0.00987336f, 0.04057160f, -0.09504128f, -0.15625168f, 0.01932412f, 0.17307885f, -0.03228226f, 0.07426830f, 
    0.16144744f, 0.06720603f, -0.04502437f, -0.11728000f, 0.02820078f, 0.04903689f, 0.03084381f, -0.06550952f, 
    -0.01897291f, -0.01624804f, 0.01192283f, -0.04045256f, 0.28588867f, -0.12415060f, -0.12205631f, 0.10324150f, 
    -0.05290031f, -0.02670871f, 0.01170056f, -0.02360023f, -0.03829114f, -0.03307002f, 0.12793687f, 0.17978184f, 
    -0.03584941f, 0.04853834f, -0.00353268f, 0.06547681f, 0.03753495f, -0.11779325f, -0.00906662f, 0.01157849f, 
    0.01972960f, -0.01192015f, -0.20000276f, -0.08608697f, -0.05339481f, 0.02069183f, -0.09915256f, 0.23240550f, 
    -0.05121053f, 0.00240932f, -0.04996964f, 0.00913328f, -0.18004310f, 0.04000120f, 0.01968873f, -0.03428563f, 
    0.00697026f, -0.12568176f, 0.08780646f, -0.23057601f, -0.07374284f, 0.00777690f, 0.16307431f, -0.05961033f, 
    0.08441355f, -0.08784668f, 0.09039660f, 0.01894342f, -0.08501394f, 0.04197453f, -0.06654613f, -0.07183295f, 
    -0.05349060f, 0.06929990f, -0.06300544f, 0.06535380f, 0.05747395f, -0.04485812f, -0.15462489f, 0.01240784f, 
    -0.34963471f, 0.21252972f, -0.18997574f, -0.09274619f, -0.13149440f, 0.01871482f, -0.02529301f, -0.09144270f, 
    -0.04005704f, -0.05187092f, -0.01125089f, -0.06594788f, 0.09190094f, -0.05875023f, 0.00285395f, -0.10881009f, 
    0.00992425f, -0.02540430f, 0.02276065f, -0.04178843f, -0.00267909f, 0.00195011f, 0.05888727f, -0.09036930f, 
    0.09235872f, 0.00505924f, -0.11707773f, -0.12347735f, -0.11294301f, -0.00558848f, -0.01735798f, -0.02326596f, 
    -0.07671241f, -0.00236864f, -0.04470994f, -0.10342398f, -0.06264654f, 0.15918866f, -0.03634720f, 0.08882575f, 
    -0.01728503f, -0.05347715f, -0.01759913f, -0.05043463f, -0.01061620f, -0.00852942f, -0.00259677f, -0.07228860f, 
    -0.14854410f, 0.08471052f, -0.00521271f, 0.01383146f, 0.04831691f, 0.02454652f, -0.01807886f, 0.02010448f, 
    -0.00763401f, -0.04344426f, -0.05762668f, 0.04490471f, -0.22141498f, -0.15974715f, -0.12923431f, -0.00858579f, 
    -0.01579920f, 0.07914145f, -0.00392275f, -0.02060772f, -0.01748967f, 0.01686741f, 0.07279104f, -0.09483957f, 
    -0.31344178f, 0.05645103f, -0.04053675f, -0.04006976f, -0.06808750f, -0.05422674f, -0.07601663f, -0.04671105f, 
    -0.00792085f, -0.07650662f, -0.00926222f, -0.01930683f, 0.11397640f, 0.13205366f, -0.16689922f, 0.03534983f, 
    -0.01594857f, -0.03707491f, -0.00365994f, 0.02054236f, -0.00723794f, 0.07678063f, 0.00902709f, 0.01599843f, 
    0.12457537f, -0.20879762f, 0.12378139f, -0.19516063f, 0.02297221f, -0.02796198f, -0.05885036f, -0.04086807f, 
    0.00596090f, -0.00012639f, -0.04591093f, -0.07930478f, 0.04265826f, -0.12191597f, 0.08920600f, 0.17786200f, 
    -0.04711574f, -0.08702340f, -0.03637773f, 0.01246693f, 0.00306314f, -0.00948547f, -0.07735772f, -0.04802166f, 
    0.06086201f, 0.07052675f, -0.05540483f, 0.20377001f, 0.03963156f, -0.13132374f, -0.07141701f, 0.04342209f, 
    -0.03210298f, -0.01482305f, 0.00974156f, -0.12406084f, -0.06024423f, 0.14102376f, 0.17781875f, -0.03385340f, 
    0.08937860f, 0.00388718f, 0.04019861f, 0.10006563f, 0.01003513f, 0.01103063f, 0.03948724f, 0.01246550f, 
    -0.41776633f, 0.21072440f, 0.00065114f, 0.00843837f, -0.08254326f, -0.08072316f, -0.01990340f, -0.01277620f, 
    -0.07941969f, -0.01468758f, 0.00777765f, 0.02241294f, -0.22254504f, 0.04686707f, -0.06924499f, -0.15099381f, 
    -0.00337456f, -0.01747931f, -0.04733555f, -0.07595424f, -0.01075588f, 0.05176693f, -0.07912028f, -0.02375008f, 
    -0.09349614f, -0.08496481f, -0.19265653f, -0.08063690f, -0.03746453f, -0.02186570f, -0.09565365f, -0.04706177f, 
    -0.09468004f, 0.01491898f, -0.02987704f, -0.02371383f, 0.04686438f, 0.09155376f, 0.03317475f, 0.11468416f, 
    0.05337098f, 0.02825949f, -0.00968949f, -0.01858507f, 0.02568204f, 0.00885768f, -0.03929551f, -0.07153969f, 
    0.05521328f, -0.11399252f, 0.09981459f, 0.00745209f, 0.01108468f, -0.10329769f, 0.06234597f, -0.07193983f, 
    0.01157467f, -0.00641688f, -0.03753410f, 0.01335753f, -0.05260409f, 0.04072504f, -0.06678231f, -0.01515800f, 
    0.04510215f, 0.01006441f, -0.05709770f, -0.02943326f, 0.02371289f, 0.06124336f, -0.02167480f, -0.08826504f, 
    0.00729407f, 0.21825075f, -0.00796547f, -0.09181576f, -0.01408255f, -0.01411706f, 0.02365371f, -0.08460029f, 
    -0.06093677f, 0.03999546f, -0.00758269f, -0.05954896f, 0.10860121f, -0.05354714f, 0.06739364f, 0.07895418f, 
    -0.09197506f, -0.01592047f, -0.00648618f, -0.03821717f, 0.07752939f, -0.02109679f, -0.00082663f, -0.01831922f, 
    0.00508622f, 0.06575367f, 0.12749800f, 0.09107479f, 0.05435127f, 0.00315876f, 0.03540281f, -0.00256288f, 
    0.00660709f, 0.04136006f, 0.03355626f, -0.01231772f, 0.03088103f, -0.02492784f, -0.00668137f, 0.00891027f, 
    -0.04065198f, 0.05762478f, -0.09687515f, 0.00599932f, 0.01594803f, -0.03181306f, -0.04164176f, -0.04407464f, 
    0.00082942f, 0.09363829f, -0.20245525f, 0.10647897f, 0.10771940f, -0.03967239f, -0.08459128f, -0.03284546f, 
    -0.03369625f, -0.01183910f, -0.02300411f, -0.07317521f, -0.12254598f, 0.12321587f, -0.09736332f, -0.13336842f, 
    -0.07030861f, 0.03392849f, -0.03350095f, 0.01054720f, 0.00677986f, -0.01351798f, 0.09703123f, -0.08507464f, 
    0.03007042f, 0.19353600f, 0.02585830f, 0.07780851f, 0.09833536f, 0.03414810f, -0.01803822f, 0.01413863f, 
    -0.11882224f, -0.10212554f, -0.01071279f, 0.00356195f, 0.27624536f, -0.41500795f, 0.16415608f, 0.15222391f, 
    0.06884421f, -0.10975423f, -0.06111587f, -0.07376347f, -0.02679050f, 0.03180390f, -0.06300810f, -0.05333729f, 
    -0.26731229f, 0.08344137f, -0.01081552f, 0.05989518f, 0.06724425f, -0.02818134f, -0.04856504f, 0.01239761f, 
    -0.05679768f, -0.03673179f, 0.02372637f, -0.08779574f, -0.11690901f, 0.08168405f, -0.00794594f, 0.02390729f, 
    0.11105074f, 0.01233746f, 0.04085773f, -0.06719581f, 0.04118928f, -0.02877071f, -0.00244699f, -0.00361928f, 
    0.04012167f, -0.09617091f, 0.08337264f, 0.08621881f, 0.00655403f, -0.00695691f, -0.06581043f, -0.01285858f, 
    -0.11328974f, 0.00601696f, 0.04707303f, -0.00392182f, 0.13111119f, -0.12469582f, 0.08405586f, -0.03482213f, 
    -0.06482664f, -0.04809990f, 0.03077661f, -0.00961503f, 0.00605367f, -0.07976904f, -0.02860054f, 0.00362600f, 
    -0.07127209f, -0.03955992f, 0.12143748f, 0.05723712f, 0.01288082f, -0.03637747f, -0.03425032f, 0.01687224f, 
    -0.00098998f, 0.01633293f, -0.02205936f, -0.01064703f, -0.01602602f, 0.14386241f, 0.07390072f, 0.15160471f, 
    0.13803165f, 0.07156832f, 0.09605003f, 0.02337002f, -0.04890686f, 0.09386007f, -0.00347381f, -0.12326298f, 
    0.14780350f, 0.17410837f, 0.02694808f, 0.18343964f, 0.13031721f, 0.04085245f, 0.09861859f, 0.03626566f, 
    -0.04640802f, -0.02103817f, -0.07471958f, -0.02000067f, 0.02902239f, 0.00565234f, -0.02165263f, -0.10066365f, 
    0.04308218f, -0.02677346f, 0.00919047f, 0.00179962f, -0.03874623f, 0.01560974f, 0.07990497f, -0.05151268f, 
    0.28132468f, -0.01412330f, 0.13520561f, -0.15038319f, -0.05458158f, -0.00321399f, -0.07779916f, 0.02602239f, 
    0.04493399f, 0.12719899f, -0.05948596f, 0.00261026f, 0.05400209f, -0.14133149f, 0.05608758f, 0.01727410f, 
    0.04577483f, 0.00440506f, -0.04827114f, -0.09560299f, -0.11989352f, 0.01142300f, -0.04692510f, -0.06259853f, 
    -0.13069429f, -0.23584981f, -0.10392218f, -0.16740920f, -0.00497947f, -0.08903215f, -0.02471256f, -0.05285095f, 
    -0.04869774f, -0.00816880f, 0.02730348f, -0.04364110f, 0.02051681f, -0.03350076f, 0.00200225f, -0.15796036f, 
    -0.09208808f, 0.01477700f, -0.03012692f, -0.16230567f, -0.04110076f, 0.00910956f, -0.04274100f, -0.05638282f, 
    -0.00329701f, 0.00157700f, 0.03910241f, -0.02258313f, 0.09357411f, 0.03799856f, 0.00785121f, -0.00496656f, 
    0.03869598f, 0.00719935f, 0.02998292f, -0.01542458f, 0.17222129f, 0.14862530f, 0.03834961f, 0.02299349f, 
    -0.12677668f, -0.06360089f, -0.05138000f, -0.01829032f, -0.05273848f, 0.02222317f, -0.02088210f, 0.00232637f, 
    0.12406673f, -0.02868658f, 0.12481032f, 0.12429609f, -0.02429057f, -0.05646548f, 0.04293602f, -0.10136237f, 
    0.01777507f, -0.00507583f, 0.00374289f, -0.06539431f, 0.07855205f, 0.19130941f, 0.17365152f, 0.15359999f, 
    0.02772149f, -0.01052442f, 0.04059858f, -0.04483385f, -0.03654378f, 0.05501183f, 0.03981305f, -0.06555489f, 
    0.05968754f, 0.10136665f, 0.06655997f, 0.15333985f, 0.11448362f, 0.12344215f, 0.03405882f, 0.02646510f, 
    -0.11253485f, 0.06787004f, -0.02351733f, 0.01889095f, 0.10744192f, 0.17688887f, 0.13547352f, 0.21835263f, 
    0.10418631f, 0.03127278f, 0.04975813f, -0.02897565f, -0.01871304f, -0.03339022f, 0.01182086f, -0.00799753f, 
    0.02876444f, 0.14658201f, 0.04025059f, 0.15247102f, -0.05861451f, 0.03994372f, 0.00594934f, -0.04142981f, 
    -0.04388406f, 0.00272788f, 0.03141855f, -0.07683198f, 0.02213567f, 0.00217326f, -0.08319161f, -0.07777050f, 
    -0.02523780f, -0.03583581f, -0.06409279f, -0.02746003f, 0.03881897f, 0.00732722f, 0.01183817f, -0.01337250f, 
    -0.05741487f, 0.04910260f, -0.06703265f, 0.11229129f, -0.06912243f, -0.12475648f, -0.12896359f, -0.01991427f, 
    0.04034581f, -0.07938529f, -0.02390722f, -0.03757758f, 0.38951007f, 0.06429900f, 0.07596619f, -0.11581091f, 
    -0.06086713f, 0.02843222f, 0.02134486f, -0.06040088f, -0.12925610f, -0.00742981f, -0.10452196f, -0.01212714f, 
    0.19875599f, 0.02028977f, -0.12710586f, -0.08704549f, -0.05793066f, 0.02627712f, 0.01279976f, -0.01481209f, 
    -0.07381067f, 0.05460924f, -0.04596719f, -0.05430717f, -0.11133935f, 0.02234754f, 0.00558040f, -0.05116040f, 
    -0.11747302f, -0.03739235f, 0.04412228f, -0.08607268f, 0.00982516f, -0.02339526f, -0.06575932f, -0.07974237f, 
    0.02116306f, 0.06134910f, 0.07065246f, 0.05703198f, 0.04694931f, 0.08528311f, 0.05734681f, -0.00734816f, 
    0.01991350f, -0.02551114f, 0.04852675f, -0.00829665f, -0.04436212f, 0.01303352f, -0.20815946f, 0.01628125f, 
    0.00702697f, -0.03117889f, -0.00288955f, -0.00752086f, 0.04372176f, 0.00220057f, 0.00759606f, -0.00092281f, 
    0.13954137f, 0.03013252f, 0.11229056f, 0.20495561f, 0.11094312f, 0.02321142f, -0.05661165f, -0.09886704f, 
    -0.06474102f, -0.09021325f, -0.06738774f, -0.11532632f, -0.06131375f, 0.09491207f, 0.00019774f, -0.03642154f, 
    -0.13611843f, 0.05461544f, -0.01275312f, -0.05298410f, -0.05636753f, 0.05234748f, -0.05450933f, -0.13254121f, 
    0.21581705f, -0.02014734f, 0.02496033f, 0.01329113f, -0.08115719f, -0.01702540f, -0.07566475f, 0.01001523f, 
    -0.03714440f, -0.04038197f, -0.04831858f, 0.03673813f, -0.12660041f, -0.14142875f, -0.20736033f, -0.23465945f, 
    0.01995767f, -0.07556888f, 0.00291235f, 0.00059011f, -0.04569173f, -0.00503044f, -0.01914065f, -0.05078781f, 
    -0.04356941f, 0.08133829f, -0.03560688f, -0.04484437f, -0.04501144f, -0.02963340f, -0.05868917f, -0.02468731f, 
    -0.01599601f, -0.02299710f, -0.07105863f, -0.06013413f, 0.09403845f, -0.00064724f, 0.09786437f, 0.15478697f, 
    0.07568099f, 0.00522144f, 0.00185223f, -0.00912641f, -0.07092810f, 0.03884332f, -0.01857197f, -0.01794061f, 
    0.01393702f, -0.20858076f, -0.05167691f, -0.01902338f, -0.09348394f, -0.06566438f, 0.02715462f, 0.00460992f, 
    0.09022930f, 0.02262147f, -0.01447195f, -0.08311078f, -0.01515344f, -0.13560034f, -0.02747276f, -0.11182377f, 
    0.03823668f, -0.01401143f, -0.06606050f, -0.04318521f, -0.08008758f, 0.07031173f, -0.05192674f, 0.02874348f, 
    -0.19294731f, -0.08315090f, -0.03443996f, -0.03144300f, -0.10148887f, -0.06392171f, 0.13613574f, -0.02675107f, 
    0.04522594f, 0.01770628f, 0.00366335f, 0.02973635f, -0.06691869f, -0.03087779f, -0.04039792f, 0.15467297f, 
    -0.04877346f, -0.15143877f, -0.05505414f, 0.00513028f, -0.10777768f, 0.00675452f, 0.02385077f, 0.00691234f, 
    0.10539277f, -0.02083793f, 0.17567691f, -0.03822529f, -0.00324769f, 0.01873649f, -0.04842009f, -0.06374007f, 
    -0.03558007f, 0.05682469f, 0.01927065f, -0.03334554f, 0.03321516f, -0.10968001f, 0.12185074f, 0.03869016f, 
    -0.00086990f, 0.00461042f, 0.01908128f, 0.00035695f, 0.04752905f, -0.02858703f, -0.06903781f, -0.08277059f, 
    -0.14224075f, -0.05479463f, 0.09783202f, 0.11924129f, 0.07778680f, 0.04429421f, -0.02510318f, -0.11683069f, 
    0.03350858f, 0.06258345f, 0.01762384f, 0.06836541f, 0.13025735f, -0.13354282f, -0.11338968f, 0.03093133f, 
    0.06450532f, -0.01540258f, 0.01622020f, -0.00192535f, 0.02188779f, 0.05266756f, 0.05923037f, 0.05655797f, 
    0.10880858f, 0.02290091f, 0.12116426f, 0.05674167f, -0.07865472f, 0.02100497f, -0.02645720f, -0.13097769f, 
    -0.08525445f, -0.00829461f, -0.02796713f, 0.01512408f, -0.07251041f, 0.23599146f, -0.07339980f, 0.00605391f, 
    -0.02843798f, 0.08904950f, -0.13908115f, 0.03486316f, 0.10695070f, -0.06646992f, 0.02249870f, 0.01559250f, 
    0.17262796f, -0.01650081f, -0.01098706f, 0.14552996f, 0.04266880f, 0.00482576f, -0.05479056f, -0.09220545f, 
    -0.03705047f, -0.02352560f, -0.02398890f, -0.00806175f, -0.03594429f, -0.08542835f, -0.02084243f, 0.02542929f, 
    0.07125280f, -0.03266159f, 0.00912330f, -0.08327843f, 0.00850317f, 0.02700570f, -0.09188695f, 0.18513106f, 
    0.05987580f, 0.06122553f, 0.02458683f, 0.12199530f, 0.06267801f, 0.08763372f, -0.04585131f, -0.03483408f, 
    0.02824786f, -0.01648518f, -0.00294193f, 0.14007278f, -0.00327129f, 0.19959870f, -0.10899100f, -0.03249083f, 
    -0.07414881f, 0.02923515f, -0.03662834f, 0.03236120f, 0.03465409f, -0.00759941f, 0.04045761f, -0.09835285f, 
    -0.05977616f, -0.06693278f, -0.10579704f, -0.10167699f, -0.06108014f, -0.12087736f, -0.02818559f, -0.08695195f, 
    0.09805606f, -0.06926791f, -0.02707324f, 0.02983745f, 0.07784063f, 0.09071588f, -0.16072950f, 0.11683768f, 
    0.00451667f, 0.06081692f, -0.09737192f, -0.02061995f, -0.00960543f, -0.04727296f, 0.09511743f, 0.08530078f, 
    -0.06779364f, 0.23498558f, -0.19034728f, -0.26359016f, -0.03112581f, -0.16605993f, -0.09000930f, 0.04900757f, 
    0.08901120f, 0.03614977f, 0.12352426f, -0.02511715f, -0.17983222f, -0.07336911f, 0.08957978f, 0.02953037f, 
    -0.11076504f, -0.15156431f, -0.04886787f, -0.13071628f, 0.01416306f, 0.02480796f, -0.10065351f, 0.02925857f, 
    0.04344486f, -0.02926006f, -0.13469532f, 0.08525845f, 0.10400338f, 0.02132130f, -0.05913310f, 0.00414721f, 
    0.05404088f, 0.13871984f, 0.06382142f, -0.03812674f, 0.15555346f, 0.04886523f, 0.03799922f, 0.11177730f, 
    0.18150027f, -0.00610745f, -0.06676111f, 0.01191704f, 0.07123525f, 0.01600152f, -0.03495193f, -0.02051727f, 
    -0.05250388f, -0.00326336f, -0.05927117f, 0.06860910f, 0.14444152f, -0.11160834f, -0.04155438f, -0.11213779f, 
    0.01557536f, 0.06106638f, -0.12576693f, -0.08855749f, 0.18690947f, -0.00698332f, -0.11988422f, -0.15603386f, 
    0.10822906f, -0.00426468f, -0.06606881f, 0.06872168f, -0.00693231f, 0.06559335f, 0.11767729f, -0.01267485f, 
    -0.03722792f, -0.18075950f, -0.12450998f, -0.13311362f, 0.02954177f, -0.02757362f, 0.10034240f, -0.05863503f, 
    0.00570129f, -0.00297619f, 0.09802297f, -0.03845505f, 0.01225468f, 0.19627631f, -0.05453071f, 0.12352062f, 
    -0.07740746f, 0.01463758f, -0.09647973f, 0.00494772f, -0.03002292f, 0.04291254f, -0.01338937f, 0.06665880f, 
    0.02093579f, -0.22983386f, 0.16729534f, 0.18708579f, 0.10471143f, 0.03668816f, 0.03555392f, -0.02469059f, 
    0.08648080f, 0.07987094f, 0.11937317f, -0.09390138f, 0.15735251f, 0.07284839f, 0.04300925f, 0.05890469f, 
    0.07078720f, -0.11783813f, -0.08808336f, 0.00740123f, -0.05367565f, 0.08590196f, -0.00654193f, 0.01545583f, 
    -0.00383100f, -0.03391753f, 0.09415264f, 0.16208138f, -0.14660440f, 0.01135199f, -0.06259209f, -0.10037673f, 
    -0.00115160f, -0.00985086f, 0.04758387f, -0.13172571f, -0.09431392f, -0.16653767f, 0.01786989f, -0.12617515f, 
    0.01629275f, -0.06681515f, 0.07370442f, -0.00284392f, -0.11860625f, 0.04262780f, -0.06393070f, 0.15725295f, 
    0.14368542f, 0.07161324f, -0.17488618f, -0.05752116f, 0.08142953f, -0.01407205f, 0.05317391f, 0.03560187f, 
    -0.02984510f, 0.02364188f, -0.13898286f, -0.05137158f, 0.13066636f, 0.17499329f, -0.17367752f, -0.09547495f, 
    0.08278339f, -0.01930643f, 0.03304071f, -0.03520168f, 0.06483211f, 0.00334231f, -0.04179931f, 0.10696787f, 
    -0.17416029f, 0.09320442f, -0.00352651f, -0.22320992f, 0.02538147f, 0.05389718f, -0.12710039f, -0.03691627f, 
    0.05478567f, 0.02615275f, 0.00328039f, -0.08172129f, 0.04134946f, 0.04348097f, -0.09398516f, -0.05671895f, 
    -0.03411514f, 0.04847386f, 0.01124703f, -0.00679139f, 0.05750635f, 0.03322821f, -0.01083839f, 0.05430442f, 
    -0.17960308f, 0.04189913f, -0.09154322f, -0.14475000f, 0.06472251f, -0.10984826f, -0.02879016f, 0.05523577f, 
    0.05648264f, -0.05039131f, -0.08844923f, 0.05476852f, 0.02859316f, 0.07566370f, -0.00045940f, 0.17419775f, 
    -0.05620437f, -0.06446883f, -0.01536864f, -0.03768319f, -0.04858461f, -0.08757226f, 0.01176637f, 0.11404645f, 
    -0.11568677f, -0.13205723f, 0.18221782f, -0.14538965f, -0.05355586f, 0.03015173f, -0.05790873f, -0.03028513f, 
    0.01728232f, -0.06642769f, -0.02192434f, -0.06486023f, 0.19612306f, -0.05724600f, -0.10722890f, -0.07670835f, 
    0.01510778f, -0.13045588f, -0.00859898f, -0.04968124f, 0.00066848f, -0.07987474f, -0.03963302f, 0.14054085f, 
    -0.04189724f, 0.11378404f, -0.07806676f, 0.14386690f, 0.01165301f, -0.09631134f, -0.10862971f, -0.10844469f, 
    -0.00099990f, -0.01000089f, 0.02824265f, -0.04991656f, -0.22545208f, -0.11511813f, 0.23006487f, -0.04585415f, 
    -0.07801542f, -0.07198843f, 0.03076471f, -0.05061485f, -0.01326564f, -0.05505603f, -0.03855599f, 0.06064905f, 
    -0.13032232f, -0.13165219f, 0.12612407f, -0.15640892f, 0.05848218f, -0.02412743f, -0.09263327f, -0.05483251f, 
    -0.05848356f, -0.02682914f, -0.00631525f, -0.00149141f, -0.24584010f, -0.13537529f, -0.05267084f, -0.19701168f, 
    0.02140321f, 0.09117161f, -0.06110381f, 0.14793292f, 0.04834569f, -0.00133937f, 0.03426063f, 0.01421611f, 
    0.09967768f, -0.10842723f, 0.02646066f, -0.03078312f, -0.00858097f, -0.05308839f, -0.02340498f, 0.02376689f, 
    -0.00577264f, -0.00421021f, -0.08574039f, 0.04079773f, 0.07495710f, -0.22145844f, 0.05719127f, -0.00849425f, 
    -0.04009643f, -0.07189379f, -0.02110625f, -0.10861186f, 0.05835443f, 0.02978991f, -0.06062473f, 0.05833735f, 
    -0.08044606f, -0.11027776f, -0.07363187f, -0.02498076f, 0.11118075f, -0.03519591f, 0.07091217f, 0.07614372f, 
    0.10338861f, 0.11877508f, 0.05932689f, 0.08894835f, 0.04739936f, -0.06365857f, 0.04333850f, 0.13584204f, 
    0.12879997f, -0.07598232f, -0.07158072f, -0.01483698f, -0.02028009f, -0.06237805f, 0.11019795f, -0.10827146f, 
    0.25229776f, -0.01013361f, 0.12321905f, 0.11060352f, -0.12345307f, -0.00217691f, -0.07266103f, -0.10590088f, 
    -0.02115476f, -0.05126242f, -0.06697519f, -0.00026780f, 0.00855470f, 0.20128277f, -0.08248131f, -0.14764908f, 
    -0.02511388f, -0.00876121f, 0.01910592f, 0.07993682f, 0.05609667f, -0.04610471f, -0.00325548f, 0.10776645f, 
    0.10067856f, -0.08930241f, -0.05252529f, -0.24991600f, -0.10196181f, -0.15288961f, -0.04337943f, -0.10597166f, 
    -0.00752076f, -0.08026519f, -0.02043346f, -0.04799942f, -0.05663320f, 0.07221083f, 0.03678643f, 0.06187453f, 
    -0.06470989f, 0.00926916f, -0.00100820f, -0.06113782f, -0.04414041f, -0.02353284f, -0.04523722f, 0.01734650f, 
    -0.22970541f, -0.05604477f, 0.20722073f, -0.13853779f, -0.08655322f, 0.00319003f, 0.16207924f, -0.08348912f, 
    -0.08613703f, -0.08125140f, 0.05201293f, -0.01433930f, -0.08156705f, -0.04229278f, 0.03858498f, 0.02431174f, 
    0.02267987f, -0.00632584f, 0.04469709f, 0.00159582f, -0.04165649f, -0.03168922f, -0.05184990f, 0.05874399f, 
    -0.06373130f, 0.13746729f, 0.14047991f, -0.02363398f, -0.07705524f, 0.01693848f, 0.10157246f, 0.04363046f, 
    -0.07857348f, 0.06670087f, 0.02087544f, -0.06555986f, 0.16859685f, -0.04183238f, 0.04004868f, 0.12746118f, 
    0.00183712f, 0.09605715f, 0.04389341f, -0.12219485f, 0.00138572f, 0.10642461f, 0.10881089f, -0.16618526f, 
    -0.18374181f, -0.14852667f, -0.15217002f, -0.17796534f, -0.04942071f, -0.06643648f, -0.09475990f, -0.04301819f, 
    0.13725671f, 0.07550713f, 0.08148739f, 0.05582609f, -0.05113050f, 0.01164608f, 0.04973388f, -0.10085250f, 
    -0.09760487f, -0.04505837f, -0.04468742f, 0.09768042f, 0.01918916f, -0.10253927f, 0.06039077f, 0.03087467f, 
    -0.24948372f, -0.15981154f, 0.05455766f, -0.00130883f, 0.08072848f, -0.00591110f, -0.06130735f, 0.04004815f, 
    0.12114511f, -0.08622459f, -0.01029289f, -0.11419540f, 0.04932908f, 0.11764933f, -0.08463820f, 0.08408796f, 
    -0.02071455f, 0.08694680f, -0.22736366f, -0.04022232f, -0.05813428f, 0.04232034f, 0.03750314f, -0.10046321f, 
    -0.01159981f, -0.06147088f, 0.11991529f, 0.00844789f, -0.01133693f, 0.06389221f, -0.08768082f, 0.05572759f, 
    -0.01205752f, -0.13282949f, 0.04325128f, -0.19369191f, 0.05187077f, 0.15774900f, -0.19798978f, -0.10466786f, 
    -0.04509412f, 0.02215065f, -0.03591485f, -0.05628849f, 0.09175774f, 0.05734236f, -0.13305114f, -0.01513444f, 
    -0.18883243f, -0.07809659f, -0.16752341f, -0.45696607f, -0.00195151f, -0.04145423f, -0.02752236f, 0.03761991f, 
    -0.01772876f, 0.06152721f, -0.06104195f, 0.04962719f, 0.07319282f, 0.16570036f, 0.03615861f, 0.05721022f, 
    -0.08799621f, 0.03538981f, -0.06067055f, 0.05469637f, 0.02659987f, 0.03003919f, 0.02519537f, -0.11753748f, 
    -0.09902480f, -0.03222745f, -0.00866854f, -0.12726881f, 0.08134551f, 0.05756106f, 0.07484176f, -0.16765532f, 
    0.08741891f, 0.06056312f, 0.03667607f, 0.03249936f, 0.07672302f, -0.11610665f, -0.18034741f, 0.07506321f, 
    0.13513087f, 0.06110876f, -0.03660955f, -0.08206275f, -0.03607312f, -0.03509660f, 0.10126319f, -0.04434689f, 
    0.16594601f, 0.02878004f, -0.03248508f, 0.07641295f, -0.02745775f, -0.06580900f, 0.01024771f, 0.00262420f, 
    -0.04526027f, 0.03712302f, 0.03359012f, 0.08362523f, -0.12488041f, -0.07173457f, -0.14289430f, -0.10646129f, 
    0.04121558f, 0.06410948f, 0.04090022f, -0.04386903f, -0.01367067f, -0.06559793f, 0.06316465f, -0.25997964f, 
    -0.16264759f, -0.04587079f, -0.21804355f, 0.11403509f, -0.03335507f, -0.06610753f, -0.00139424f, 0.00658238f, 
    0.10002338f, 0.00979575f, 0.06900632f, -0.01126067f, 0.14635859f, -0.08095536f, 0.02195087f, 0.01502177f, 
    0.06654806f, 0.02562984f, -0.01456978f, -0.06935016f, 0.05563404f, -0.05822171f, -0.11457347f, -0.31823796f, 
    0.03992147f, -0.11696321f, -0.22407353f, 0.06300671f, 0.04827624f, 0.03144737f, -0.10911221f, -0.09370063f, 
    -0.07488840f, 0.00395913f, 0.13131574f, 0.00887813f, 0.00287210f, 0.08696954f, -0.21265317f, -0.18827236f, 
    0.00936313f, -0.03633962f, -0.09942415f, 0.08487327f, 0.10622688f, 0.06764275f, 0.06118166f, -0.00923582f, 
    -0.26355168f, -0.06848173f, 0.17570968f, 0.03691504f, 0.02212578f, 0.00290433f, -0.01192488f, -0.02319697f, 
    0.02312866f, -0.02860770f, 0.00344671f, -0.03364784f, -0.23026608f, -0.18815574f, -0.02524836f, -0.10168699f, 
    -0.04801968f, 0.01423228f, 0.03089335f, -0.15764736f, -0.08422510f, -0.04568489f, 0.06118148f, -0.04167244f, 
    -0.01685059f, 0.21660917f, -0.19360693f, -0.23396890f, 0.09666850f, -0.09523121f, 0.05465473f, -0.00647189f, 
    -0.11413037f, -0.02516089f, 0.07683118f, -0.20352390f, 0.11277191f, 0.07316262f, 0.11601678f, -0.03294794f, 
    0.07169899f, 0.01342511f, -0.02441579f, -0.06505642f, -0.01849847f, -0.00238138f, -0.03732095f, 0.02600355f, 
    0.51008439f, -0.04328247f, -0.12629443f, -0.20532124f, 0.12330217f, -0.07894263f, -0.17128825f, 0.05509558f, 
    0.01479957f, -0.04048239f, 0.04370576f, 0.02405376f, -0.10096825f, 0.15593724f, 0.09218998f, 0.20581368f, 
    0.01217000f, 0.11492371f, -0.15777412f, 0.00736587f, -0.02706261f, 0.03443186f, -0.12124531f, -0.08046708f, 
    -0.08762408f, -0.00498121f, 0.00148871f, -0.13058713f, 0.06475490f, 0.01681311f, -0.21171574f, -0.09049559f, 
    -0.02313984f, -0.00041841f, 0.07655636f, -0.14114720f, 0.00316149f, -0.10760655f, 0.08541283f, -0.08499666f, 
    0.07765078f, 0.04928206f, -0.02345682f, -0.05137971f, 0.08253726f, -0.03913583f, 0.12972757f, -0.13973403f, 
    -0.23301865f, 0.07517795f, -0.20692365f, -0.23064969f, 0.07506929f, 0.09785779f, -0.04363075f, -0.00878676f, 
    -0.17804174f, -0.10161611f, -0.03462680f, -0.10794977f, -0.03339710f, 0.01869009f, 0.18739958f, 0.08162951f, 
    -0.00418275f, -0.02539160f, 0.00213310f, 0.13776267f, 0.03157186f, -0.01606906f, -0.09181735f, -0.03016932f, 
    0.15432124f, -0.16364190f, -0.15182258f, 0.06006705f, -0.11863127f, -0.02663800f, 0.14694765f, 0.05994120f, 
    0.03581342f, -0.06177859f, 0.13600181f, -0.08424468f, 0.07818200f, -0.08665159f, -0.17100078f, -0.13747612f, 
    0.00421277f, -0.01995077f, -0.06965595f, 0.01478239f, -0.01787716f, -0.02303852f, -0.06742766f, -0.10094021f, 
    -0.17272261f, -0.04707927f, 0.04913023f, -0.31170598f, 0.04260399f, -0.00599275f, -0.05753139f, 0.00005473f, 
    0.08282982f, -0.09791209f, -0.03317171f, -0.03673341f, 0.23542781f, -0.00529341f, -0.28298068f, 0.28185919f, 
    0.05992600f, -0.07454194f, 0.06191017f, -0.03924112f, -0.01754560f, -0.13821556f, 0.04296731f, 0.04406356f, 
    -0.47256753f, 0.13145550f, -0.00674709f, -0.31082359f, 0.07027020f, 0.06084346f, 0.04116997f, -0.03268288f, 
    -0.10661694f, 0.00859645f, 0.02784095f, -0.05043269f, -0.09534175f, 0.00385408f, -0.02024037f, -0.24226254f, 
    -0.02338495f, 0.04982937f, -0.02639928f, 0.01613447f, 0.02157821f, 0.01226111f, -0.03867098f, 0.07689291f, 
    0.00552688f, 0.11812399f, 0.02635487f, -0.19770494f, 0.01153855f, 0.03503082f, 0.03073798f, 0.02530439f, 
    0.13395046f, -0.03504277f, 0.08701076f, 0.06553713f, -0.25098819f, -0.12024292f, 0.06573837f, -0.14786808f, 
    0.04108746f, -0.09586193f, 0.00593576f, -0.14388272f, 0.10275629f, 0.02440276f, 0.14691538f, -0.00881923f, 
    0.13909635f, -0.14112133f, -0.15636316f, 0.14806828f, -0.13916121f, -0.01063618f, 0.05441627f, 0.13079077f, 
    0.04718875f, 0.08870818f, -0.18997546f, 0.03154405f, -0.02426418f, 0.46594182f, 0.20911701f, 0.22086813f, 
    -0.05172964f, 0.08002617f, -0.07544134f, 0.11383543f, 0.01351276f, 0.05250602f, 0.08005358f, -0.04035453f, 
    -0.40041682f, 0.21265902f, -0.05486131f, -0.21192592f, 0.11556712f, 0.06925171f, -0.02045174f, -0.02521328f, 
    0.04340821f, 0.01938250f, 0.04782634f, 0.05581607f, 0.11269273f, -0.07388779f, -0.24659479f, 0.02696327f, 
    0.07386886f, 0.05297953f, 0.02869968f, 0.06690276f, -0.18945935f, -0.01469001f, 0.04779195f, 0.03592476f, 
    0.15638120f, -0.30184585f, -0.06847959f, -0.01341519f, 0.05268651f, -0.05596824f, -0.07151274f, 0.11086401f, 
    -0.08594484f, 0.09422536f, -0.00854676f, -0.06337254f, -0.09481145f, 0.05410294f, 0.12625636f, 0.15512428f, 
    -0.00460056f, 0.02581302f, -0.08091000f, 0.05772875f, 0.10533554f, -0.12005339f, -0.00939924f, -0.15188168f, 
    -0.23579584f, 0.00343823f, 0.25635582f, 0.01229853f, -0.04978345f, -0.08181060f, 0.01054921f, -0.00465101f, 
    0.22586277f, -0.04610015f, 0.15531926f, 0.06474968f, 0.00905687f, 0.16618010f, 0.22946079f, 0.09821138f, 
    0.03463754f, -0.00436263f, 0.10760661f, -0.13675591f, -0.00221365f, -0.08475139f, 0.05070933f, -0.04786165f, 
    -0.04072357f, -0.16466428f, 0.01907483f, 0.01448436f, -0.04417163f, 0.05195748f, -0.04919230f, 0.06180758f, 
    -0.14526187f, -0.06406386f, -0.06644411f, 0.03147338f, 0.29311305f, -0.40829575f, 0.19438513f, -0.30514067f, 
    -0.00312883f, 0.00161923f, -0.10347528f, 0.03760789f, -0.09505656f, -0.01089631f, -0.03056213f, 0.08159529f, 
    -0.24598113f, -0.21343587f, -0.05105652f, -0.07032235f, -0.06928940f, 0.08093666f, 0.03402944f, 0.11751956f, 
    0.02239320f, -0.16048552f, 0.12290385f, -0.00608172f, -0.01175093f, -0.20767184f, 0.01489377f, -0.16460250f, 
    0.09619564f, -0.04292007f, -0.02595359f, 0.14453293f, -0.00793055f, -0.08154622f, -0.02736385f, -0.04496923f, 
    0.06332898f, -0.18783011f, -0.05153706f, 0.06691009f, 0.00095345f, 0.05126182f, 0.05441550f, 0.02542113f, 
    0.10719753f, -0.05146828f, 0.18995988f, 0.10220072f, 0.07314048f, -0.04329534f, 0.05657691f, 0.04206665f, 
    -0.02850889f, 0.04621432f, -0.02419508f, -0.00240120f, 0.10104008f, 0.02248598f, 0.12153935f, -0.09522703f, 
    0.46511006f, -0.27899694f, -0.01485231f, -0.17145821f, -0.11222082f, 0.00762803f, -0.04399570f, 0.11685491f, 
    -0.05411260f, -0.02429694f, -0.02742078f, 0.03155487f, -0.20167978f, -0.29430735f, -0.06265554f, 0.13785699f, 
    -0.05059605f, -0.15532334f, -0.05510529f, 0.04253953f, -0.02360399f, -0.03251506f, 0.04572580f, -0.09746984f, 
    -0.09820592f, -0.09296222f, 0.10462898f, -0.12490836f, -0.00570300f, -0.00177035f, 0.02923230f, 0.03493966f, 
    -0.07426014f, -0.04601579f, -0.06954219f, 0.04899151f, -0.16557530f, 0.01351463f, 0.21525936f, -0.02906827f, 
    -0.10786470f, -0.07146757f, -0.07570930f, 0.07969771f, -0.09442329f, -0.03768788f, 0.07373408f, 0.01545719f, 
    -0.04784146f, -0.05303850f, -0.11700898f, 0.12036002f, -0.02396965f, -0.00418389f, 0.03923559f, -0.00834833f, 
    -0.10738337f, 0.13950162f, 0.00550664f, -0.03128672f, 0.13666491f, -0.05443935f, -0.05309181f, 0.07850091f, 
    0.02769249f, 0.01209955f, 0.06026625f, 0.03259057f, 0.05591275f, -0.03984880f, 0.00698569f, 0.07869389f, 
    -0.00841165f, -0.05510087f, 0.07251596f, -0.30107614f, 0.00587314f, 0.03932821f, -0.02335557f, -0.01039075f, 
    -0.01252699f, -0.05266349f, -0.01631559f, -0.17075317f, -0.11344195f, -0.06423242f, -0.04283765f, 0.09981731f, 
    0.03473178f, -0.06381015f, 0.06198458f, -0.12651303f, -0.01530590f, 0.08390455f, -0.01014742f, 0.06710530f, 
    0.10567965f, -0.23622526f, 0.21314313f, -0.01777268f, 0.08228615f, 0.00088064f, 0.07948711f, -0.08147005f, 
    0.07058307f, -0.05674311f, -0.02359991f, -0.03728402f, -0.27550477f, -0.07136668f, -0.10520710f, -0.05406764f, 
    -0.00036380f, 0.03133008f, 0.16779010f, -0.09472885f, 0.06476267f, -0.06619387f, 0.01522498f, 0.09755534f, 
    0.03752461f, -0.18259564f, 0.06962600f, 0.18467207f, -0.01801466f, 0.03655271f, -0.08003883f, 0.05891760f, 
    -0.00872098f, 0.14093107f, -0.02771169f, -0.01918904f, -0.13785197f, -0.23316038f, -0.04777461f, -0.00134442f, 
    -0.01013626f, 0.01626920f, -0.02898212f, 0.08165237f, 0.05525515f, 0.08434483f, -0.02746095f, 0.00720741f, 
    0.55429810f, -0.02084457f, -0.16185118f, 0.19984004f, 0.02853806f, -0.04432493f, -0.21232656f, 0.14314923f, 
    -0.10634499f, 0.02562016f, 0.11597703f, -0.03476974f, -0.15199909f, -0.17576861f, 0.00649243f, -0.06174003f, 
    0.08701560f, -0.04036651f, 0.01989845f, 0.00174686f, 0.01498372f, 0.05272101f, 0.04955079f, 0.03679571f, 
    -0.00125809f, 0.04739814f, 0.09321469f, 0.06115382f, 0.05136753f, -0.02961128f, -0.10392033f, 0.06730854f, 
    -0.02407355f, -0.21582016f, 0.02474045f, -0.08868920f, 0.08086421f, 0.10245339f, -0.05610176f, -0.19409999f, 
    0.01983749f, -0.07943459f, 0.08491424f, -0.14048399f, 0.07710108f, 0.01878585f, -0.11298674f, 0.00044551f, 
    -0.04107878f, 0.18169768f, -0.15229422f, -0.19230826f, -0.07489182f, -0.03543150f, 0.07325990f, -0.02067685f, 
    0.04404585f, 0.06511936f, -0.04562273f, -0.20326184f, -0.38809660f, -0.05337089f, 0.09373998f, -0.09824229f, 
    -0.03362872f, 0.03259812f, 0.10386876f, -0.00185010f, 0.01052928f, 0.00619747f, -0.00538138f, 0.10057016f, 
    -0.10888562f, -0.10055050f, 0.08212619f, -0.18504667f, -0.03169850f, -0.02397065f, 0.04355048f, -0.04253186f, 
    -0.02864841f, -0.05181517f, -0.00014304f, 0.03057140f, -0.00113621f, 0.06114852f, 0.12692915f, 0.06520744f, 
    -0.01944808f, 0.06121930f, 0.10237906f, 0.08722556f, 0.00490787f, 0.09401071f, 0.11935545f, -0.01136223f, 
    0.01251540f, -0.00822964f, 0.09647927f, -0.15202093f, 0.06066435f, -0.04340165f, 0.03556506f, -0.00248950f, 
    0.02826914f, 0.04846114f, 0.00903439f, 0.09257559f, 0.27948716f, -0.00676833f, 0.22362308f, -0.05480872f, 
    0.00744699f, -0.04466061f, -0.10834695f, 0.07306905f, -0.02995187f, -0.02027318f, -0.04008285f, 0.05372719f, 
    0.01043803f, -0.15484348f, -0.03101304f, 0.03058393f, 0.02403067f, -0.02306869f, -0.03730650f, -0.00495335f, 
    0.04171557f, -0.04238562f, 0.02430974f, -0.02150688f, -0.45380920f, 0.37825069f, 0.10456912f, 0.11484729f, 
    0.16750540f, -0.04213401f, -0.11808135f, 0.13589801f, 0.11466732f, -0.05694225f, -0.07322472f, 0.07113878f, 
    0.01811070f, -0.15552074f, -0.01573624f, 0.00955575f, 0.02574500f, -0.00099746f, -0.00258062f, -0.01336536f, 
    0.13620260f, 0.04003615f, 0.10033872f, 0.01475245f, 0.03285004f, -0.15694208f, 0.16141897f, -0.14882958f, 
    0.05480215f, 0.07505250f, -0.08302131f, -0.01776122f, -0.20344333f, 0.06653558f, -0.01260980f, -0.01301233f, 
    0.08039112f, 0.21610408f, -0.28809941f, 0.13505405f, 0.04255813f, 0.09033138f, 0.04724664f, 0.02193465f, 
    0.10086906f, 0.09185845f, -0.10636673f, -0.01740252f, -0.11811648f, -0.04213417f, -0.00756863f, 0.02819489f, 
    0.02923867f, -0.06255570f, 0.01496506f, 0.00797296f, -0.09614448f, -0.01365040f, 0.05607984f, 0.08341132f, 
    -0.07615846f, 0.15562244f, -0.15436980f, -0.27795514f, 0.05563918f, 0.08806299f, -0.07425126f, 0.05005594f, 
    -0.05685013f, -0.01733213f, -0.04642146f, -0.08573065f, 0.03946384f, -0.05259862f, -0.00152906f, -0.32133344f, 
    0.02941139f, 0.03797663f, -0.02469665f, -0.08685113f, 0.00581979f, -0.00166798f, 0.07217711f, 0.22373992f, 
    -0.28929248f, 0.09800377f, 0.15791297f, 0.04105910f, 0.02683016f, -0.01032841f, 0.00548674f, 0.10480854f, 
    0.03932063f, -0.02754596f, 0.01256211f, -0.04096502f, 0.02916511f, -0.06774925f, 0.15775965f, -0.37441033f, 
    0.02509417f, 0.00422415f, -0.00283829f, -0.08742068f, 0.03622400f, -0.09160693f, -0.04283040f, 0.05260494f, 
    -0.00070771f, -0.18972127f, -0.04029315f, 0.14032270f, -0.12758993f, 0.04193759f, -0.03517657f, -0.00419870f, 
    0.01644528f, 0.12808293f, 0.05612157f, -0.06406504f, 0.35351354f, 0.01605616f, -0.15757881f, 0.16041930f, 
    0.00352550f, 0.08149672f, 0.04516313f, 0.06726161f, 0.01424782f, 0.01468465f, -0.14275320f, -0.05870751f, 
    -0.36083189f, -0.19982541f, -0.04119882f, -0.20367359f, 0.10539807f, -0.07088677f, 0.07602797f, 0.09035007f, 
    0.04610329f, 0.07665390f, 0.05074359f, 0.15048178f, -0.27461031f, -0.07559021f, -0.02873512f, 0.06291553f, 
    0.02196643f, -0.04930011f, 0.05444397f, -0.03915722f, -0.01735395f, -0.00871036f, 0.13771576f, 0.09074800f, 
    -0.35885927f, -0.22581124f, 0.05707346f, 0.04288134f, 0.01706946f, 0.00432409f, 0.00849309f, -0.02851305f, 
    -0.05043852f, 0.08106951f, 0.07778286f, -0.00915043f, -0.10190214f, -0.05912965f, 0.13206159f, 0.03424659f, 
    0.03183637f, 0.00481120f, -0.02343493f, 0.05103746f, 0.07242196f, 0.08190519f, 0.10474280f, 0.06157157f, 
    -0.33569139f, -0.12925701f, -0.12024726f, -0.08605713f, 0.06177949f, 0.01111466f, -0.08361316f, -0.05104562f, 
    -0.02563763f, -0.04033140f, 0.12072089f, 0.04201316f, -0.25898322f, -0.17462711f, -0.02549662f, -0.19098532f, 
    0.10280272f, -0.02368238f, 0.00082913f, -0.12300854f, 0.07874419f, -0.06812957f, 0.00493976f, 0.11183596f, 
    -0.14906982f, -0.16219555f, -0.14718464f, -0.22139724f, 0.04860539f, 0.07364971f, 0.09309465f, 0.05041641f, 
    0.15951380f, 0.15109290f, 0.01757078f, 0.10996211f, -0.31986484f, -0.11999746f, 0.03628410f, 0.02975326f, 
    0.02171424f, 0.05633687f, -0.05509160f, -0.11305412f, 0.01684065f, 0.08741841f, 0.04732527f, -0.01389051f, 
    -0.06717839f, -0.17012510f, 0.02466802f, 0.35912853f, -0.05243899f, 0.02849840f, -0.07880262f, 0.04587540f, 
    -0.04592233f, -0.02469394f, 0.02773614f, 0.16078962f, 0.00281704f, 0.21405184f, -0.08590734f, -0.19166137f, 
    0.04054756f, 0.12211005f, 0.01795125f, 0.00745143f, 0.09958484f, 0.05614894f, 0.06829963f, 0.07443926f, 
    0.06264993f, 0.05681003f, -0.10097322f, 0.00039156f, 0.02823629f, -0.02366526f, 0.06320122f, -0.00402439f, 
    -0.03426948f, 0.06163145f, 0.05160165f, -0.01179924f, 0.25042060f, 0.05196029f, 0.09070895f, 0.08208587f, 
    -0.18848160f, -0.21566465f, -0.00552611f, -0.02355320f, -0.03893544f, -0.03483326f, -0.13071516f, -0.06045637f, 
    -0.04576989f, -0.43406799f, 0.00599828f, -0.10938962f, 0.06992913f, -0.01347326f, -0.04045026f, -0.01658157f, 
    0.09344554f, 0.07283693f, 0.03596544f, 0.07892003f, -0.31938097f, 0.00169101f, -0.21138376f, -0.19885866f, 
    0.14545505f, -0.02423451f, -0.10031109f, -0.05694407f, 0.00374389f, -0.11770874f, 0.07210369f, 0.00367202f, 
    -0.20714788f, -0.07367837f, 0.02842293f, 0.05250628f, 0.02817880f, -0.00369789f, -0.01692553f, -0.06008580f, 
    -0.03784820f, -0.10325801f, -0.10488839f, 0.10622522f, -0.08718184f, -0.03300103f, -0.12124084f, -0.20231150f, 
    -0.08818705f, -0.10110489f, -0.11405004f, -0.07710765f, -0.09723537f, -0.13433227f, -0.00352708f, -0.15865982f, 
    0.27109706f, 0.04310885f, -0.04405425f, 0.01790422f, -0.01996531f, -0.04232224f, 0.09183784f, 0.03536418f, 
    -0.07311980f, -0.04749976f, -0.02081279f, 0.00641260f, -0.28189811f, -0.33946872f, -0.08301406f, 0.00041200f, 
    0.03529648f, 0.04199002f, 0.02487259f, 0.04077062f, 0.09670548f, 0.06693552f, -0.02439046f, 0.05719377f, 
    -0.43714061f, -0.43328089f, -0.03113140f, -0.21045369f, -0.03627669f, -0.09761610f, -0.06797402f, 0.04884876f, 
    0.10439885f, 0.03457965f, -0.09783104f, -0.02557493f, -0.07256615f, -0.09518315f, -0.22796328f, -0.26505560f, 
    0.00247990f, 0.07314546f, -0.13538125f, 0.03910773f, -0.03013621f, 0.02477116f, 0.04196279f, -0.16732229f, 
    0.24172653f, 0.00360328f, 0.01876739f, -0.07726279f, -0.17124082f, -0.01963795f, 0.01222900f, 0.04168758f, 
    0.01834417f, 0.08413779f, -0.01128128f, -0.04515064f, 0.15680474f, 0.04683490f, 0.11499927f, -0.05722206f, 
    0.01678084f, -0.14925522f, 0.05375423f, -0.02181621f, 0.13593426f, -0.03061870f, -0.00437205f, 0.17520188f, 
    -0.04321074f, 0.02143340f, -0.18739992f, 0.09639925f, 0.13632815f, 0.04502114f, -0.02743577f, -0.01835893f, 
    0.03550549f, -0.12562612f, 0.02018473f, -0.09607768f, -0.63760513f, -0.12904276f, 0.20879823f, 0.09159755f, 
    0.19439638f, 0.03406909f, 0.01472536f, -0.07486370f, 0.08903299f, -0.05798132f, -0.00532804f, 0.07067636f, 
    0.07449093f, -0.08006769f, 0.09709010f, -0.02582947f, 0.05540013f, 0.11532718f, -0.01333704f, 0.00674908f, 
    0.05189425f, 0.04787825f, 0.02608666f, -0.05466096f, -0.26777932f, 0.14258778f, -0.13226783f, -0.07137951f, 
    0.05993744f, 0.02490406f, 0.05310714f, -0.02688874f, 0.08665074f, -0.01770598f, 0.01329629f, -0.01062792f, 
    -0.05850384f, -0.00249398f, -0.01046954f, -0.04164784f, 0.12618762f, -0.02730005f, 0.03923367f, 0.04050336f, 
    0.08631907f, 0.09859867f, -0.13108979f, 0.07757899f, -0.02988257f, 0.08620892f, 0.02509357f, -0.03680995f, 
    -0.00856054f, -0.02395824f, 0.02423093f, -0.05523606f, -0.08635467f, -0.01461483f, 0.10596342f, 0.06639306f, 
    0.17835887f, 0.03710936f, 0.02201066f, -0.02049975f, 0.02630815f, 0.08864680f, -0.00322025f, 0.03531475f, 
    0.06246335f, -0.08373167f, -0.02578093f, 0.01175790f, -0.28360152f, -0.04605857f, 0.04895047f, -0.08650381f, 
    0.00252136f, 0.03695397f, -0.01843067f, -0.00010075f, 0.03222021f, 0.00116124f, 0.06894558f, 0.06826600f, 
    -0.15734611f, 0.06411355f, -0.27877280f, 0.00645324f, 0.03755080f, -0.08985116f, -0.03121962f, -0.01819673f, 
    0.08495042f, 0.05598738f, -0.00170537f, -0.07319804f, 0.05417648f, 0.01596235f, 0.17636777f, -0.08698291f, 
    -0.01656625f, -0.04671700f, 0.01489499f, -0.08250718f, 0.04178882f, -0.08076794f, -0.00766532f, -0.07212713f, 
    0.09109326f, 0.16483048f, -0.11320654f, -0.06507138f, -0.00627319f, 0.04638940f, 0.01839168f, -0.10868189f, 
    0.00120664f, -0.01991383f, 0.00418885f, -0.06352622f, -0.10001389f, -0.23010862f, 0.12805873f, 0.12372207f, 
    -0.13625628f, 0.11297885f, -0.00437503f, 0.03484276f, 0.09961327f, 0.01718897f, 0.02167243f, 0.11234263f, 
    0.09703544f, 0.07101763f, -0.09783962f, 0.11236209f, -0.04034344f, 0.00967926f, -0.03372151f, 0.01892505f, 
    0.02625895f, -0.09445197f, -0.08074918f, 0.00731939f, -0.27715653f, -0.01189829f, -0.05140571f, -0.00612971f, 
    0.00836074f, 0.04906342f, -0.01346809f, 0.04387318f, -0.01327894f, 0.01013914f, 0.08861779f, 0.11608455f, 
    -0.02352628f, 0.21458797f, -0.01547755f, -0.11890761f, 0.05607553f, -0.00712572f, 0.02580027f, 0.15079035f, 
    0.07352515f, 0.13511008f, 0.09515677f, 0.23860106f, -0.08262721f, -0.20740139f, -0.13429041f, -0.26196906f, 
    0.00849357f, -0.02948733f, -0.13783376f, 0.09615533f, -0.02928400f, 0.07526673f, 0.00932937f, -0.09177722f, 
    0.05764987f, 0.09877308f, -0.01487972f, -0.07867600f, 0.02672272f, -0.04115831f, -0.13170436f, 0.04125582f, 
    0.08305541f, 0.06677248f, -0.10064359f, 0.08299095f, 0.12067153f, 0.11267041f, -0.04892309f, -0.02571148f, 
    0.08619852f, 0.21621265f, 0.00429045f, 0.08599080f, 0.07207654f, 0.05631685f, 0.05557728f, 0.06943411f, 
    -0.23935562f, -0.04144708f, -0.02019318f, -0.01597843f, 0.05302154f, -0.04198207f, 0.05401769f, 0.00839178f, 
    -0.03716145f, -0.14361359f, -0.02419075f, -0.18167493f, 0.18723629f, 0.05973991f, -0.02857156f, 0.01970330f, 
    -0.12052461f, -0.02869570f, 0.04082231f, -0.01555456f, 0.03764846f, 0.02098079f, -0.01186819f, -0.07369804f, 
    0.09010106f, 0.02773808f, 0.02341968f, -0.09766240f, -0.02797336f, 0.12439892f, 0.07245466f, 0.01421979f, 
    0.10593960f, 0.09825625f, 0.07644619f, 0.07848119f, 0.04407081f, 0.04912626f, 0.04240468f, -0.01680142f, 
    -0.17798884f, 0.00635229f, -0.02453722f, 0.00488595f, -0.00301087f, 0.05067264f, -0.04290055f, -0.03746846f, 
    0.19254953f, -0.12109511f, 0.11602330f, -0.09447069f, -0.09761937f, -0.03692122f, 0.02807412f, 0.03013857f, 
    0.13332041f, 0.15562239f, -0.10823578f, -0.03944748f, 0.00630409f, -0.07338083f, 0.07743441f, 0.13908844f, 
    -0.01887405f, -0.05783978f, 0.03878846f, 0.06397000f, 0.01598352f, -0.02249279f, -0.04589580f, -0.01262794f, 
    0.31343859f, 0.04980263f, -0.00844908f, -0.15371475f, 0.05525854f, 0.09931396f, 0.00844024f, 0.08688672f, 
    -0.10341691f, 0.06211630f, 0.22483668f, 0.03416668f, 0.15071812f, 0.06321113f, 0.02464505f, -0.04196200f, 
    0.14587104f, -0.04862870f, -0.05905961f, 0.05204184f, -0.05880306f, -0.05583670f, 0.05493213f, 0.00110233f, 
    -0.36662215f, -0.05001594f, 0.00207809f, 0.07897611f, 0.11578223f, -0.09334984f, -0.00568731f, -0.06369740f, 
    -0.08824563f, 0.03234648f, -0.00646795f, -0.02762359f, 0.13574786f, -0.06152121f, -0.07161696f, -0.12804775f, 
    0.00662028f, -0.00311986f, 0.07527942f, -0.06048195f, -0.03987722f, -0.22272573f, -0.13812353f, -0.07838163f, 
    0.12227570f, 0.11385277f, 0.01545232f, -0.00090464f, -0.19644266f, -0.02413647f, 0.00052622f, 0.13502428f, 
    0.00178393f, -0.03495130f, 0.06703246f, -0.08114513f, -0.18023397f, -0.09583803f, 0.13385382f, 0.00435246f, 
    0.11397988f, 0.01881021f, 0.03680260f, -0.01390258f, 0.10193521f, 0.08581641f, -0.18232952f, 0.06424196f, 
    0.21641833f, 0.01631821f, 0.00095835f, -0.09497610f, 0.04649313f, 0.03690896f, 0.06087796f, -0.04042060f, 
    -0.03896335f, 0.01792059f, -0.02535249f, -0.11234201f, -0.08702260f, -0.04691756f, -0.16693401f, 0.04128036f, 
    -0.04958358f, 0.04896715f, 0.11467838f, 0.07844732f, 0.10504868f, -0.01975340f, 0.09428915f, -0.08381404f, 
    0.10203988f, 0.07637317f, -0.02481167f, 0.08339134f, 0.02892037f, -0.03271449f, 0.01173312f, 0.00948658f, 
    -0.02971008f, 0.00904067f, -0.11133155f, -0.00363858f, -0.56837898f, -0.29626107f, 0.06415248f, -0.06165179f, 
    0.10352993f, 0.16161519f, -0.13935095f, -0.06674258f, 0.10089599f, 0.01835177f, -0.08445320f, 0.07045101f, 
    -0.07900113f, -0.06273766f, -0.03678378f, -0.04892919f, 0.02036080f, -0.00961138f, 0.06043947f, -0.02490162f, 
    0.13085182f, -0.15018027f, 0.01494768f, 0.11381795f, 0.13414839f, 0.12584394f, -0.02032676f, 0.02454933f, 
    -0.03898486f, 0.06296772f, 0.05323707f, 0.03819787f, -0.00696379f, -0.08060482f, 0.01351626f, -0.20211227f, 
    0.20744982f, -0.10510731f, -0.03175740f, -0.02349689f, 0.04668889f, -0.06098037f, -0.05787989f, 0.03184758f, 
    0.05516196f, -0.03563512f, 0.00413014f, 0.03450047f, -0.15320367f, 0.16700473f, -0.15461165f, -0.03844321f, 
    0.04756078f, -0.02607617f, -0.10997903f, 0.02057617f, 0.02049377f, -0.10934653f, -0.07448342f, -0.08581203f, 
    -0.54053646f, -0.42930317f, 0.06279220f, -0.13150279f, 0.00896983f, -0.01624811f, -0.14950803f, -0.06499686f, 
    0.04720131f, -0.03286503f, 0.07381903f, -0.00390293f, -0.27912349f, -0.11740562f, 0.01450393f, -0.01220037f, 
    0.17618473f, 0.00930197f, 0.06467593f, -0.05313307f, -0.11624090f, 0.03324611f, 0.06284770f, -0.00836075f, 
    0.08486879f, 0.03545630f, -0.00622201f, 0.00614497f, -0.01182496f, 0.03562592f, -0.10317533f, 0.11742663f, 
    -0.03492358f, -0.01109144f, -0.08744419f, 0.03395081f, 0.20937288f, 0.14930555f, -0.05090827f, 0.00871418f, 
    -0.06278070f, 0.01541117f, 0.00088595f, 0.05342100f, -0.13339849f, 0.00886529f, 0.09684683f, -0.01555058f, 
    0.13805248f, -0.20563735f, 0.00403320f, -0.07626972f, 0.10294713f, -0.07389933f, -0.01207510f, 0.06061694f, 
    -0.06985195f, -0.03216793f, 0.00873747f, -0.05558089f, 0.38714111f, -0.03769067f, 0.04443139f, -0.12637870f, 
    0.07052876f, 0.03064093f, -0.12664023f, -0.05488452f, -0.06617340f, 0.05595598f, 0.00276575f, -0.10539218f, 
    -0.06735031f, -0.11803968f, 0.03845631f, -0.25812286f, 0.02857648f, -0.02944776f, -0.03183590f, 0.14346102f, 
    -0.07291415f, -0.08008303f, 0.02487231f, 0.00583295f, 0.08048472f, 0.09400365f, -0.11576959f, 0.16054164f, 
    0.11024404f, -0.14824545f, 0.00573365f, -0.11268551f, -0.04022620f, 0.02561674f, -0.10424259f, -0.01782021f, 
    -0.08896749f, -0.11867356f, -0.20210992f, -0.07730693f, -0.05052125f, 0.00979099f, 0.03494755f, 0.14137062f, 
    0.03652885f, -0.02665357f, -0.03328861f, -0.11348344f, 0.22629431f, 0.11072975f, -0.25561658f, -0.07109839f, 
    -0.00993336f, -0.03722769f, -0.06350934f, 0.03725454f, -0.05322022f, 0.07500590f, 0.05787552f, -0.01928946f, 
    0.15717199f, -0.27183887f, 0.07701263f, 0.09367066f, 0.04067930f, 0.04466527f, -0.01730460f, -0.03986523f, 
    -0.10588671f, -0.04500385f, -0.02654694f, -0.04579180f, 0.05640396f, 0.00310112f, -0.09072305f, 0.09836055f, 
    0.05097822f, 0.08267418f, -0.09303402f, -0.03463198f, -0.16091575f, -0.03835299f, -0.07187326f, -0.03231029f, 
    -0.09820129f, -0.01412566f, 0.04361232f, -0.08389997f, 0.12377948f, -0.06336576f, -0.00077297f, -0.01184919f, 
    -0.12039030f, -0.00610002f, 0.01102354f, -0.14874293f, -0.05723870f, -0.10975230f, 0.07712494f, 0.25091788f, 
    -0.03780452f, 0.06068840f, 0.05467222f, 0.05158574f, -0.16997594f, 0.03843480f, 0.13758858f, -0.01772283f, 
    0.02528122f, -0.21061674f, -0.07859279f, 0.21652657f, -0.13433181f, 0.04575172f, 0.01928557f, -0.03470848f, 
    0.03071753f, -0.00791843f, -0.10214972f, -0.08834700f, 0.04178665f, -0.17854476f, 0.21930079f, -0.07460248f, 
    -0.06528535f, -0.04262701f, -0.00360439f, 0.02735396f, -0.10209861f, -0.00730454f, 0.11775616f, -0.01003888f, 
    0.22375643f, -0.14629383f, -0.08949464f, 0.02331145f, 0.23494203f, -0.10760099f, 0.03340082f, -0.09276775f, 
    0.02946537f, 0.09450378f, -0.01791405f, 0.07157029f, 0.03511886f, -0.14024988f, -0.14614864f, -0.09725691f, 
    0.04119169f, 0.07123615f, 0.02431278f, -0.00739680f, 0.03036787f, -0.04482410f, 0.02244022f, 0.01351817f, 
    0.17577024f, -0.10212842f, 0.05772746f, -0.08104675f, -0.01777958f, -0.05372651f, 0.01248390f, 0.12651423f, 
    -0.01019697f, 0.00880642f, 0.06024108f, 0.01203245f, -0.03548181f, -0.17822956f, 0.01532125f, 0.13157554f, 
    0.10096862f, 0.04129023f, -0.01403568f, -0.06513520f, -0.00482598f, -0.05652851f, -0.06282461f, 0.18061551f, 
    -0.15023752f, 0.10583887f, -0.10977890f, -0.04369389f, -0.06128616f, 0.10208326f, 0.11164963f, 0.07667689f, 
    0.02573938f, -0.11173391f, 0.01634083f, 0.05077424f, -0.02400289f, 0.02446666f, 0.03528566f, 0.19105406f, 
    0.16690107f, 0.01609034f, 0.06679265f, -0.07084963f, 0.06790766f, 0.03020884f, 0.06568353f, 0.03714798f, 
    0.06134176f, -0.08766473f, 0.01705008f, -0.15214339f, 0.04063443f, -0.04414307f, 0.04531825f, 0.09834267f, 
    0.10455501f, 0.00615569f, -0.05137277f, 0.01937268f, -0.39580122f, -0.00669703f, -0.00265433f, -0.16462372f, 
    0.03228075f, 0.00453297f, 0.04750244f, 0.03456825f, 0.04619639f, -0.02652101f, 0.01340552f, -0.00662972f, 
    -0.14592461f, 0.01791286f, 0.03090435f, 0.07949241f, 0.01916850f, 0.01026172f, 0.00715545f, -0.00972756f, 
    -0.08047638f, -0.03736051f, 0.05704878f, -0.03107463f, -0.00396993f, 0.04335456f, -0.01841388f, -0.02572075f, 
    0.07384666f, -0.00652925f, -0.05396764f, 0.02762195f, 0.01644568f, -0.05576998f, 0.09246752f, -0.03453824f, 
    0.23200224f, -0.15940534f, -0.07924935f, 0.14571445f, -0.09675436f, 0.03577280f, -0.03501578f, 0.12001806f, 
    0.09670472f, 0.15477720f, -0.03062964f, 0.01808685f, 0.15055963f, 0.15514158f, -0.01056790f, -0.08216647f, 
    0.16977005f, -0.02608616f, -0.08641968f, 0.00389441f, -0.02254724f, 0.10172013f, 0.05453611f, 0.07010634f, 
    0.14745000f, 0.08873554f, -0.05667367f, -0.05622311f, -0.10434030f, -0.10323444f, 0.01014834f, -0.20610803f, 
    -0.05815816f, 0.04474673f, -0.10736360f, -0.01584009f, 0.14221554f, -0.03532956f, -0.07489960f, 0.14503168f, 
    -0.12564330f, -0.05505215f, -0.01065699f, 0.05032108f, 0.03493626f, -0.06358819f, 0.06005650f, -0.00324297f, 
    0.09368475f, -0.06826042f, 0.00146615f, 0.23066522f, -0.08262138f, 0.03777200f, -0.02818521f, 0.08398090f, 
    0.11302151f, -0.06032179f, -0.01322052f, 0.03968185f, 0.04239005f, -0.10442343f, -0.00923354f, -0.04796406f, 
    -0.10729624f, 0.04229102f, -0.03220534f, 0.01241494f, 0.01151162f, -0.02735571f, -0.13833819f, -0.11828962f, 
    -0.18808950f, 0.06710630f, 0.10245824f, -0.00844237f, -0.06722827f, 0.04147550f, 0.07919201f, -0.07311172f, 
    0.01473728f, 0.14279585f, 0.09075130f, 0.07648110f, 0.19892974f, 0.00493746f, 0.01085881f, -0.07866628f, 
    -0.01290556f, -0.09822465f, 0.02813383f, 0.03579873f, 0.01525295f, 0.08382560f, -0.00370148f, 0.00216960f, 
    -0.25318524f, -0.17457041f, 0.13171983f, 0.04617809f, -0.02297455f, 0.04254387f, -0.05277931f, 0.04203214f, 
    -0.08254635f, -0.03978851f, 0.11900584f, 0.15112089f, 0.10193479f, -0.00046922f, 0.05551941f, -0.08951739f, 
    -0.09999098f, -0.00538586f, -0.00713920f, -0.07158171f, 0.03564701f, 0.03321886f, 0.06384212f, -0.13083923f, 
    0.22571895f, -0.01520350f, -0.08116892f, -0.00273895f, -0.09148634f, 0.06856014f, -0.00522341f, -0.01039666f, 
    0.11140548f, -0.08713146f, -0.02206551f, -0.05292824f, -0.21422900f, 0.08970524f, 0.01332133f, 0.10239777f, 
    0.13120340f, 0.03088485f, 0.04922344f, 0.02927122f, -0.02236174f, 0.02740009f, -0.12174358f, -0.10347412f, 
    -0.32468361f, 0.13072205f, -0.00592122f, 0.09832622f, 0.08464359f, -0.02080760f, 0.03058160f, -0.09403844f, 
    0.02901808f, -0.01432926f, 0.03967742f, 0.01080449f, -0.25907966f, 0.07633790f, 0.13439484f, -0.02908021f, 
    -0.02369654f, 0.02202483f, -0.08278163f, 0.10966305f, -0.09408370f, -0.03708786f, 0.09297945f, 0.05331285f, 
    0.31588253f, 0.09549247f, -0.13618697f, 0.05816347f, 0.05756843f, 0.03966076f, 0.07441236f, 0.09547038f, 
    -0.02349859f, -0.11918124f, -0.02808774f, -0.14504072f, -0.21557862f, -0.07670957f, 0.00768483f, -0.32532698f, 
    -0.03077815f, -0.02049234f, -0.06906857f, 0.06242505f, 0.10993847f, -0.06926926f, -0.06297810f, 0.00456909f, 
    -0.46647432f, 0.08251877f, -0.09054932f, -0.10156753f, -0.10762567f, 0.09309397f, -0.01037099f, 0.14182867f, 
    -0.04105907f, 0.01773426f, -0.03274519f, -0.05767647f, -0.24765484f, 0.19438982f, -0.04803117f, 0.09622224f, 
    0.17277716f, 0.02311010f, 0.00691226f, -0.09069755f, 0.01887321f, -0.01135286f, -0.02830698f, 0.00159283f, 
    -0.16016580f, 0.08519299f, 0.11733963f, -0.13814682f, -0.09094448f, -0.03482002f, -0.10060815f, -0.20008810f, 
    -0.03523503f, -0.03273428f, 0.03770557f, 0.04735937f, 0.11985090f, -0.10809805f, -0.00313680f, 0.10035738f, 
    -0.01119602f, -0.00147419f, 0.04608548f, -0.01835680f, -0.13896485f, -0.01515230f, -0.03567001f, -0.10000595f, 
    0.01971412f, 0.14725815f, 0.09176996f, -0.15228985f, -0.17857976f, 0.00082512f, -0.12791222f, -0.08884370f, 
    -0.03359511f, -0.04492494f, 0.03222331f, -0.07805973f, -0.07908242f, 0.08856372f, -0.04262098f, 0.08426403f, 
    -0.10808433f, 0.07917933f, -0.05978460f, 0.01529178f, 0.03342205f, 0.04835039f, 0.01312441f, -0.14304857f, 
    -0.08781266f, -0.03717958f, 0.08198341f, 0.06195739f, -0.00363483f, 0.00009096f, -0.09526847f, -0.06099132f, 
    -0.14553611f, -0.04006935f, 0.03821433f, 0.03568609f, -0.22038765f, -0.19168247f, 0.00969577f, -0.00170162f, 
    0.01129917f, 0.03120490f, -0.01215322f, 0.07184349f, -0.08303958f, -0.16032858f, -0.06292227f, 0.00110773f, 
    0.04790841f, 0.02545281f, -0.10780938f, 0.27873173f, 0.00735349f, -0.04785341f, -0.01472307f, 0.11905465f, 
    -0.03948893f, 0.01656599f, -0.10855059f, -0.14555156f, -0.35600215f, 0.20679493f, -0.17343280f, -0.01139975f, 
    0.24896276f, -0.09700848f, 0.03000331f, -0.11546811f, -0.01802941f, -0.06903569f, 0.05806903f, 0.09465522f, 
    0.13189161f, 0.08840166f, -0.06949675f, -0.24119954f, 0.05464682f, -0.08126245f, 0.02968042f, 0.08158611f, 
    0.06379349f, -0.03854534f, -0.00560401f, 0.01521395f, -0.08920442f, -0.18300858f, -0.10597812f, 0.07354252f, 
    0.02062486f, 0.01967855f, 0.13700524f, -0.02655195f, 0.06077426f, 0.07120962f, 0.09656052f, 0.06325372f, 
    -0.09375627f, -0.03058372f, -0.08139551f, 0.05688508f, -0.02037960f, 0.05031817f, -0.03196069f, 0.01754798f, 
    0.01359405f, -0.05268805f, 0.00963394f, -0.11726597f, 0.20379609f, 0.00337192f, 0.01975799f, -0.06843761f, 
    0.04903122f, -0.03236865f, -0.09501578f, 0.02602026f, -0.01719182f, -0.00742703f, 0.06207105f, 0.03838443f, 
    -0.16731216f, 0.08175274f, -0.05575955f, 0.03865055f, -0.12142298f, 0.01744130f, -0.05490177f, -0.00004553f, 
    -0.05118810f, -0.11376090f, -0.05579627f, -0.14671935f, -0.03952523f, -0.13904390f, -0.10150722f, 0.07803545f, 
    0.01120649f, -0.03430616f, 0.04833012f, 0.02369126f, 0.03997572f, 0.03766058f, -0.01548387f, -0.04150795f, 
    -0.17929755f, 0.17198391f, -0.16874731f, 0.01376320f, 0.06560788f, 0.08055559f, 0.16782366f, 0.01895325f, 
    -0.04334755f, 0.05378047f, 0.03229914f, -0.05853831f, 0.56580091f, 0.29792339f, -0.22149050f, -0.18174827f, 
    -0.01544361f, -0.12761831f, -0.09770919f, 0.00813072f, 0.04450457f, 0.03328391f, 0.02794984f, 0.05024344f, 
    -0.41997194f, -0.31533298f, 0.00904146f, -0.15474169f, 0.11407767f, 0.02798206f, -0.00394028f, 0.14008729f, 
    -0.00650966f, 0.00094420f, -0.04587213f, -0.17240278f, -0.10940492f, -0.06008013f, -0.23580256f, 0.10442168f, 
    -0.07868923f, 0.02629872f, 0.01596319f, -0.08073834f, 0.15182617f, 0.03255434f, -0.00806671f, 0.16635041f, 
    0.08509798f, 0.00491634f, -0.19338350f, 0.04861625f, -0.01383032f, -0.00821328f, 0.05840149f, 0.11786416f, 
    -0.05977358f, -0.02149264f, -0.05420303f, 0.05450624f, -0.13666525f, -0.30991963f, -0.07074221f, -0.09980359f, 
    -0.01298053f, 0.04304728f, 0.02814374f, -0.00955042f, 0.06579170f, 0.06262846f, -0.04278772f, -0.03922426f, 
    0.11120440f, -0.11262763f, -0.17679779f, 0.01591127f, 0.07262698f, 0.03913115f, 0.03324991f, -0.07525313f, 
    -0.09434486f, 0.00951488f, -0.16378982f, -0.11281807f, 0.31427759f, -0.13703817f, -0.15412895f, -0.03404750f, 
    0.00261234f, -0.01219108f, -0.03408663f, 0.05330123f, 0.10930774f, -0.02998140f, 0.01802504f, 0.01253515f, 
    -0.12675934f, 0.20894633f, -0.01046886f, -0.08675767f, 0.04698389f, -0.01499061f, -0.00606916f, -0.08351868f, 
    -0.02879202f, 0.01848454f, 0.02121455f, -0.06095911f, -0.11132096f, 0.17367095f, -0.01800545f, 0.03423383f, 
    -0.07784649f, 0.03586609f, 0.04853962f, -0.00025088f, -0.03221612f, -0.06306060f, 0.11214110f, 0.08436877f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04797055f, 0.05624770f, -0.04724976f, -0.04402523f, 0.03739424f, -0.00747877f, 0.02592784f, -0.08663542f, 
    -0.00410248f, 0.03430425f, 0.08755928f, 0.04212428f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
