#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.05735598f, 0.64588743f, 0.86389798f, 0.57492435f, 0.15116508f, 0.30775350f, 0.13836282f, 0.19312310f, 
    0.01252623f, -0.08252273f, -0.66042173f, 0.12576272f, 0.23005800f, -0.47664472f, 0.71873546f, -0.20732746f, 
    -0.27682576f, 0.08030603f, 1.03606808f, -0.78939205f, -0.05648104f, 0.48401377f, -0.18936668f, -0.42475507f, 
    0.08642721f, -0.37229711f, 0.02483434f, 0.41068053f, -0.43501949f, -0.73504299f, -0.23591757f, -0.72136784f, 
    0.22954367f, -0.62379473f, -0.16966599f, -0.27448469f, -0.64513993f, -0.97174740f, -0.65035021f, -0.20838767f, 
    0.38725105f, 0.44268540f, -0.09566583f, 0.27829978f, 0.50559056f, 0.86406922f, 0.52499908f, -0.86921042f, 
    -0.35895279f, 0.29448390f, -0.31395927f, 0.06924993f, -0.09987038f, 0.01023829f, 0.52736002f, -0.90942824f, 
    0.64589870f, 0.59682369f, -0.03626362f, 0.25695270f, -0.12529781f, 0.08263403f, -0.27932888f, -0.66931713f, 
    0.23354143f, 0.32603502f, -0.45366424f, -0.59538752f, -0.19537926f, 0.38977519f, -0.45726642f, 0.37346905f, 
    -0.44891796f, -1.09955013f, -0.40548176f, 0.38149741f, 0.69169921f, 0.54870510f, -0.27446318f, -0.06399186f, 
    -0.25039366f, 0.01599496f, 0.59707415f, -0.60600191f, -0.41533253f, -0.70525151f, 0.20362632f, -0.34095746f, 
    0.05460224f, 0.25123626f, 0.91176790f, 0.72350168f, -1.00995982f, -0.38816890f, 0.25885275f, 0.38089603f, 
    0.26954830f, 0.31595179f, 0.35173270f, -0.96468109f, 0.19614281f, 0.48486188f, -0.04906214f, -0.10760047f, 
    0.52094024f, -0.34955350f, -0.07065310f, -0.42126349f, -0.20635064f, 0.67350906f, 0.67469442f, -1.08772087f, 
    0.39493567f, -0.16313635f, -0.01965926f, 0.19260630f, -0.06787846f, -1.03489268f, 0.07853387f, -0.51442564f, 
    0.13407056f, 0.43924478f, -0.00964684f, -0.33740726f, 0.27095419f, 0.25868785f, 0.37024736f, -0.53407031f, 
    0.53760535f, 0.69571394f, -0.46274975f, -0.29464433f, -0.20777352f, -0.00478047f, -0.34944507f, 0.12194225f, 
    0.24132018f, -0.19092619f, 0.14545903f, -0.10141169f, 0.32061079f, 0.59609199f, -0.49538058f, 0.21614601f, 
    0.36619997f, 1.03432608f, -0.13150238f, -0.38191706f, -0.43566164f, -0.21784440f, 0.32460371f, -0.07284249f, 
    -0.04813424f, 0.75287032f, -0.93016773f, 0.46404210f, -0.00303825f, 0.51839066f, -0.02695560f, 0.19021954f, 
    -0.03281824f, 0.06373399f, -0.80199903f, -0.86200917f, -0.22530167f, 0.05658146f, -0.42298371f, -0.35351127f, 
    -0.26705655f, 0.50775403f, -0.18913706f, 0.80245709f, 0.00867956f, -0.75922966f, -0.35161909f, -0.43435091f, 
    0.45605358f, -0.24605060f, -0.39059636f, 0.28839296f, -1.07417583f, -0.71041459f, 0.44072467f, 0.70891476f, 
    0.56041110f, -0.04658570f, -0.01598967f, -0.48901048f, -0.17224745f, 1.11455488f, 0.17398727f, -0.92022491f, 
    0.50481123f, 0.21383415f, 0.18257029f, 0.02295882f, -0.16985932f, -0.29418474f, -0.13808864f, 0.87658823f, 
    -0.79276288f, 0.70932269f, 0.05116785f, -0.58997589f, -0.40850392f, 0.25632259f, -0.05685165f, 0.13868324f, 
    -0.67612863f, 0.68603098f, -0.69877857f, -0.90568811f, 0.05538269f, 0.23183338f, 0.36806318f, -0.29752555f, 
    0.24805266f, -0.85749805f, 0.27351663f, -0.87733078f, 0.22695452f, 0.28006694f, -0.11221129f, 0.04818381f, 
    0.11391919f, -0.41310158f, 0.57180989f, -0.48611388f, -0.74038464f, -0.57714963f, -1.00279832f, -0.14608276f, 
    0.20100366f, 0.41261727f, 0.49330649f, 0.04444311f, 0.67223400f, 0.46836698f, -0.19774368f, -0.27500257f, 
    0.49199268f, 0.55234206f, -0.02691849f, 0.45978948f, -0.50708568f, 0.72489130f, 0.13463661f, -0.44076857f, 
    0.32038984f, 0.30064961f, -0.48998898f, -0.73590690f, 0.68487912f, 0.44407642f, 0.44578761f, 0.43657911f, 
    0.44614419f, 0.42552447f, -0.55129856f, 0.23009975f, -0.29817677f, -0.14013641f, 0.50886679f, -0.62211984f, 
    -0.34790167f, -0.66125089f, -0.44273400f, -0.16765477f, 0.33401692f, -0.08289355f, 0.80309057f, -0.87515974f, 
    0.69953871f, -0.40343943f, -0.24181940f, -0.56213444f, -0.37094045f, -0.01510208f, -0.48790976f, -1.17405295f, 
    0.53592664f, 0.47578961f, 0.62271780f, 0.24672735f, 0.54134220f, 0.13285141f, -0.31872916f, 0.08831597f, 
    0.75874454f, -0.93318456f, -0.82487446f, 0.46850586f, -0.49578688f, -0.06869248f, -0.40671149f, 0.41380531f, 
    0.07971307f, -0.27981541f, -0.93356133f, 0.56054753f, -0.65569288f, 0.04648943f, -0.35381040f, -0.30861390f, 
    -0.37194997f, -0.53215575f, 0.68085903f, 0.62402356f, 0.70308131f, 0.37847435f, -0.75240213f, -0.03494373f, 
    -0.54709321f, -0.22844502f, -0.16312757f, 0.30488014f, 0.60060120f, 0.00243118f, 0.62212598f, 0.46063295f, 
    0.15214856f, 0.23829228f, -0.00975579f, 0.02006830f, 0.69393969f, -0.03826728f, 0.23285900f, 0.64947671f, 
    0.04807212f, -0.53937536f, 0.25908351f, 0.38736665f, 0.16602784f, -0.08971214f, 0.51106763f, 0.79761595f, 
    -0.69320041f, 0.92876261f, -0.08279320f, 0.49161813f, 0.24918883f, -0.09176348f, 0.61740440f, 0.35235476f, 
    0.63312292f, -0.73877496f, 0.35563445f, -0.11775859f, -0.17241311f, 0.45799208f, 0.03660989f, -0.04078128f, 
    -1.02941263f, -0.66209483f, -0.31434730f, 0.78550959f, -0.10592871f, 0.40089446f, 0.01414215f, -0.25964844f, 
    -0.55839205f, -0.06999005f, -0.69736797f, -0.40932131f, 0.59683466f, -0.33969760f, -0.17296036f, -0.14767677f, 
    -0.20637213f, 0.65475076f, -0.57914364f, -0.24012055f, -0.11269166f, -0.55212218f, -0.42233011f, 0.03088265f, 
    -0.18716846f, 0.43021476f, 0.09080192f, -1.02918291f, 0.74381721f, 0.51779336f, 0.38859528f, 0.65183544f, 
    -0.32378528f, -0.11583947f, -0.08238318f, -0.49117857f, -0.62536734f, 0.59558070f, -0.30569342f, -0.59025455f, 
    -0.25835446f, -0.22840722f, 0.33757183f, 0.18509693f, -0.40695879f, 0.17480311f, -0.69083232f, 0.35908946f, 
    -0.45111740f, -0.77214658f, -0.52724081f, 0.41309536f, -0.12777701f, -0.15603520f, 0.82590830f, 0.17332032f, 
    0.11239310f, -0.11583684f, 0.58938026f, -0.24493560f, 0.26567480f, -0.19748771f, 0.65966153f, 0.56598645f, 
    0.62801743f, 0.03171415f, 0.35937116f, 0.06415842f, -0.23887134f, 0.21762182f, -0.20310822f, 0.88602221f, 
    0.85324270f, 0.17504019f, -0.39868373f, 0.08751485f, -0.26844683f, 0.41245532f, 0.01252376f, -0.33711362f, 
    -0.52004606f, 0.21775244f, -0.24437419f, -0.10071930f, 1.07057464f, 0.54814088f, 0.12588419f, -0.64308006f, 
    0.07366265f, -0.67456627f, -0.59705687f, -0.94493723f, -0.85400975f, -0.11468724f, 0.44130796f, 0.54212683f, 
    -0.05382205f, 0.30446166f, 0.58476633f, 0.64311618f, -0.25659826f, 0.57182425f, -0.09296633f, -0.56218016f, 
    0.31888759f, 0.02237750f, -0.00835777f, -1.12096119f, 1.05444419f, 0.33700997f, -0.13718632f, 0.86195064f, 
    -0.48503777f, -0.15535016f, 0.24422872f, -0.03853150f, -0.29287609f, 0.53222477f, 0.40878412f, -0.64862382f, 
    0.23767243f, 0.41375872f, -0.46594495f, 0.06540229f, 0.36497608f, 0.79710084f, 0.05070142f, 0.26176187f, 
    -0.75185299f, -0.73644173f, -0.74523777f, 0.41032714f, -0.15775354f, -0.22399868f, -0.44689456f, 0.87477124f, 
    0.37081799f, 0.21081057f, -0.43505266f, -0.42504752f, -0.43716452f, -0.16803971f, -0.31730214f, 0.91276389f, 
    0.40944052f, 0.57636803f, -0.06201995f, -0.46726525f, 0.56447941f, -0.04457545f, -0.27816117f, 0.41878602f, 
    -0.58659554f, -0.85905808f, -0.57906145f, 0.42581931f, 0.95422035f, -0.22507267f, -0.25218737f, 0.06123699f, 
    0.17322733f, 0.46599537f, 0.75422525f, 0.63373417f, -0.91921860f, 0.20985578f, -0.39555207f, 0.01648947f, 
    -0.18575105f, -0.05383040f, 0.78097481f, 0.68313187f, 0.60903800f, -0.26853356f, 0.19739014f, 0.06569123f, 
    0.15430489f, 0.12248338f, -0.40260842f, -0.65930057f, 0.55166095f, 0.77490246f, 0.62477922f, 0.08273089f, 
    0.03471639f, 0.04210087f, 0.19416292f, 0.35162833f, -0.73475218f, -1.02129805f, -0.37755132f, -0.23449689f, 
    0.37175539f, 0.52995843f, 0.29827842f, -0.00904274f, -0.05787987f, -0.87699205f, 0.00905475f, 0.27074459f, 
    0.42334557f, 0.04621661f, -0.75110072f, 0.09568164f, -0.02669680f, -0.40834823f, -0.52127957f, 0.47070321f, 
    -0.38840026f, 0.58484352f, 0.80698520f, -0.73836070f, 0.43109038f, -0.38341966f, -0.01965765f, -0.11570423f, 
    0.43569297f, 0.69883996f, -0.85083610f, -0.27333179f, -0.45530576f, 0.46313381f, -0.10338166f, 0.23035780f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.18668683f, -0.06251299f, -0.26981562f, -0.11784703f, 0.02867093f, 0.11017776f, -0.02042598f, -0.11758915f, 
    0.07908407f, 0.00828650f, -0.10506754f, 0.01123546f, -0.05739513f, 0.05015305f, 0.06864186f, 0.05494796f, 
    0.02975695f, 0.04766795f, 0.26930723f, -0.15508235f, -0.07055258f, -0.04719174f, -0.00755439f, 0.04368263f, 
    0.02023812f, -0.26780066f, 0.10630160f, -0.16610804f, 0.29518211f, 0.12569785f, -0.12534969f, -0.03453587f, 
    -0.06171555f, -0.33359191f, -0.05351600f, 0.19506897f, -0.17615707f, -0.22559136f, -0.15596245f, 0.19969180f, 
    -0.22383115f, 0.08990272f, -0.06663231f, 0.14835191f, -0.17472160f, 0.06890491f, 0.27725896f, -0.05922835f, 
    -0.24944654f, 0.25639910f, 0.11487187f, -0.04834751f, 0.11055537f, -0.05874739f, 0.00369637f, 0.17419519f, 
    0.11082559f, -0.08131088f, 0.09739577f, 0.14116865f, 0.26231954f, -0.13342468f, -0.26843503f, -0.20318927f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.19034669f, -0.01386113f, 0.08532562f, 0.03225529f, 0.13764903f, 0.00511091f, -0.12195142f, 0.07153439f, 
    -0.09518382f, -0.04379366f, 0.01561561f, -0.04675090f, 0.01695439f, 0.02181759f, 0.03284401f, -0.04791728f, 
    -0.00022403f, -0.00950140f, -0.03424754f, 0.03347060f, 0.18420304f, -0.04409331f, -0.01357601f, 0.02712036f, 
    -0.25434095f, 0.02281720f, 0.10304023f, -0.02865398f, -0.03937733f, 0.00479544f, -0.00202380f, -0.02153726f, 
    0.03263883f, -0.00059204f, 0.02310342f, 0.06896394f, 0.01836150f, 0.00622250f, -0.00262569f, -0.02467297f, 
    0.13767897f, -0.27830932f, 0.22861116f, 0.16739959f, 0.00486206f, 0.04461011f, -0.02377806f, -0.00782892f, 
    0.04402097f, -0.05071275f, -0.16938491f, 0.06146843f, -0.08937980f, -0.01928797f, 0.08817330f, -0.01814957f, 
    -0.00337992f, -0.00680992f, 0.03098541f, -0.01404297f, 0.13009436f, -0.28629559f, 0.05449517f, 0.17477460f, 
    -0.03110184f, 0.04340300f, 0.06945790f, -0.07722034f, 0.00269798f, -0.07880592f, -0.06125824f, -0.04206624f, 
    0.02091871f, 0.09416978f, -0.00951031f, 0.01208474f, 0.01443910f, -0.00241879f, -0.03389909f, -0.08560268f, 
    -0.26070866f, 0.12353438f, -0.19918454f, -0.10243651f, -0.25256670f, 0.01925472f, 0.01058591f, 0.04331762f, 
    0.04779272f, 0.01304171f, 0.04691478f, 0.03676695f, 0.00314042f, 0.02466051f, -0.02009625f, 0.01401621f, 
    -0.04374773f, 0.03136123f, 0.00007504f, 0.00841781f, -0.12593597f, 0.04933038f, 0.02741191f, -0.00903089f, 
    0.20523751f, -0.07614502f, -0.02906461f, 0.01345046f, 0.01552160f, -0.00656384f, 0.01121215f, -0.04929180f, 
    0.04713053f, -0.04976784f, -0.00966835f, -0.02055675f, -0.02493453f, -0.05383378f, 0.02913414f, -0.09750377f, 
    0.14600696f, 0.01216713f, 0.07723201f, 0.03395616f, -0.39441368f, 0.07535025f, -0.02426635f, 0.05066535f, 
    -0.02852174f, -0.03725461f, -0.09031788f, 0.06980050f, -0.04725372f, -0.04057973f, 0.03045870f, 0.01524947f, 
    -0.00888319f, 0.01686786f, -0.05993404f, -0.00257620f, -0.26277322f, 0.00163175f, 0.00868045f, -0.01705872f, 
    0.08085291f, -0.09113634f, -0.01158708f, -0.04638391f, 0.03671460f, -0.00294539f, 0.02308923f, 0.03203812f, 
    0.08892541f, -0.02485992f, -0.00940923f, -0.03920629f, -0.00111857f, -0.03805665f, -0.00747426f, -0.08809189f, 
    -0.15981361f, 0.18977049f, -0.01892220f, -0.22605084f, -0.39679226f, 0.07313844f, 0.07807307f, -0.01499039f, 
    0.05522738f, -0.04502635f, 0.00502113f, -0.04426340f, 0.01149962f, 0.02598211f, -0.07898746f, 0.05051546f, 
    0.03910958f, -0.01737531f, -0.03301943f, 0.02232032f, 0.07332220f, -0.00874817f, 0.08665632f, -0.03959452f, 
    0.02185641f, -0.02372253f, -0.08472785f, -0.08008442f, -0.04308979f, -0.03682068f, -0.03480127f, 0.02832928f, 
    0.00942938f, 0.02712882f, 0.01004613f, -0.00374523f, 0.02925732f, -0.00667531f, -0.05805931f, -0.01363241f, 
    -0.24952076f, -0.02188512f, 0.09139843f, -0.09718022f, 0.24516086f, -0.04702904f, -0.07100388f, -0.07630335f, 
    0.11680979f, 0.04309637f, -0.02239875f, -0.02001480f, 0.04600939f, 0.06742863f, 0.09725196f, -0.04527748f, 
    -0.05755056f, -0.04213379f, -0.02092527f, -0.01086559f, -0.16747832f, 0.09047049f, 0.10859986f, 0.15681003f, 
    0.06889610f, 0.00843738f, 0.02657542f, 0.00462030f, 0.04024521f, -0.01279426f, 0.06477194f, -0.01319324f, 
    0.02518168f, -0.03591477f, -0.08648327f, 0.02717168f, -0.08407057f, -0.11675404f, 0.08238687f, 0.04231999f, 
    -0.05627263f, -0.01439063f, -0.09498297f, 0.02056524f, 0.12754866f, -0.08501263f, 0.02539989f, -0.02179592f, 
    -0.08516031f, 0.01762657f, 0.00001282f, -0.04485703f, 0.02634464f, -0.02115687f, 0.02664576f, 0.00116593f, 
    0.00671470f, 0.03813942f, 0.02094338f, -0.05324027f, 0.30156779f, 0.10579196f, -0.02066249f, -0.15504940f, 
    -0.19290397f, 0.08935238f, -0.00494962f, -0.05078350f, -0.05136077f, -0.00721727f, 0.07650889f, -0.05652535f, 
    -0.10112972f, -0.05169138f, -0.00363674f, -0.04106242f, -0.01977124f, 0.04583296f, 0.01944598f, -0.02260048f, 
    0.05133073f, -0.18279740f, 0.09058544f, 0.04640660f, -0.20712011f, 0.11575397f, -0.06247347f, 0.05753222f, 
    -0.04988515f, -0.03009937f, -0.15541501f, 0.06988785f, -0.07550941f, 0.07106189f, -0.00878133f, -0.00493330f, 
    -0.01103838f, 0.06916389f, -0.03716728f, -0.05839023f, -0.06644567f, -0.10019084f, 0.01258435f, -0.06084691f, 
    0.02956467f, -0.11526937f, 0.07029614f, 0.02014694f, -0.06029753f, -0.01846542f, -0.04222422f, -0.00778079f, 
    0.07002498f, 0.08909582f, 0.02551062f, -0.00423481f, 0.02983561f, -0.02598208f, -0.11061520f, -0.12292145f, 
    0.07965305f, 0.12023403f, 0.16801201f, -0.11940472f, 0.17517287f, -0.08646014f, -0.05444712f, 0.01300527f, 
    0.03232028f, -0.02408849f, 0.01468917f, -0.00582438f, 0.00020081f, -0.07403132f, 0.02028274f, 0.03068676f, 
    0.01114393f, 0.08574492f, 0.00008309f, -0.07037258f, 0.06965019f, 0.04781438f, 0.08368218f, 0.04077913f, 
    -0.23368348f, -0.14214985f, -0.13474356f, 0.01156188f, -0.02327462f, -0.04280765f, 0.00094202f, 0.04496917f, 
    -0.07117545f, -0.03978202f, -0.04177806f, -0.07410811f, -0.08793463f, 0.05312318f, -0.02741868f, 0.00146052f, 
    -0.31229982f, -0.20247178f, -0.03066989f, -0.04741944f, -0.21553673f, 0.01314103f, -0.04135942f, 0.01609513f, 
    0.03836484f, 0.05576997f, -0.03113531f, -0.06108889f, -0.01821320f, -0.08960684f, -0.02559760f, 0.02485414f, 
    -0.04244711f, 0.00718555f, -0.06766218f, 0.03265035f, -0.08547158f, -0.19634426f, 0.06147784f, 0.04683392f, 
    0.14405964f, -0.00035945f, 0.09258009f, -0.03109998f, 0.09815195f, -0.09298929f, -0.06364764f, -0.02794532f, 
    0.01419308f, 0.02664034f, 0.05023864f, 0.02762374f, -0.01003723f, -0.06822787f, -0.02304964f, -0.04097281f, 
    0.02802077f, 0.00639285f, 0.25356156f, 0.01412694f, -0.29755688f, 0.05269977f, 0.02360653f, 0.05441196f, 
    0.07889772f, -0.04443626f, -0.00864229f, -0.01863532f, 0.01119186f, -0.03919692f, -0.04952762f, 0.02368056f, 
    0.06797065f, -0.01638739f, 0.00233407f, 0.03545867f, 0.13363017f, -0.15441935f, 0.07105552f, -0.01782652f, 
    0.32429641f, -0.05567776f, 0.00389266f, -0.00445195f, 0.07333429f, -0.07526287f, -0.06158294f, -0.06267141f, 
    -0.00814747f, -0.13827308f, -0.05389575f, 0.02931539f, 0.01751599f, 0.04368668f, -0.02214880f, 0.03825352f, 
    0.28663713f, -0.04416353f, 0.05171095f, -0.07245404f, 0.16327001f, -0.05756930f, -0.06957492f, 0.04866686f, 
    -0.06722072f, 0.02549168f, 0.01954278f, 0.01080002f, -0.03554456f, 0.09330942f, -0.02478985f, -0.12288651f, 
    -0.02212417f, 0.05198851f, -0.08992277f, 0.04541363f, 0.11582524f, -0.15832007f, -0.17337169f, 0.04535322f, 
    -0.23007587f, -0.11340149f, 0.01490017f, 0.03905945f, -0.08104240f, 0.00598886f, -0.04636861f, 0.04142453f, 
    0.01738876f, -0.05008401f, -0.04413153f, -0.03664844f, -0.02590184f, -0.04355700f, 0.01890999f, 0.00142220f, 
    0.08347140f, -0.22423668f, -0.10019878f, 0.07627881f, -0.30769882f, -0.06591023f, 0.02585525f, 0.02825650f, 
    -0.00012470f, 0.01027902f, 0.06135654f, 0.00540630f, 0.03342889f, -0.09348816f, 0.01335867f, -0.06417163f, 
    -0.03270322f, -0.00061543f, -0.05020219f, -0.04744229f, -0.17213333f, -0.28762656f, 0.12332056f, -0.03787917f, 
    0.03732776f, -0.01678876f, 0.03077735f, -0.05340568f, -0.01688651f, 0.11938459f, 0.00375761f, 0.02701404f, 
    -0.03878194f, -0.00917086f, -0.03284727f, 0.01319761f, -0.00493232f, 0.14309557f, 0.05601123f, -0.09353135f, 
    0.00068845f, -0.04062223f, 0.02232988f, -0.05326919f, -0.16000231f, -0.04938728f, -0.01785104f, 0.04838333f, 
    -0.01614595f, -0.06188672f, 0.02417985f, 0.07771258f, 0.03055373f, -0.01182724f, -0.05632334f, -0.00652091f, 
    -0.08084595f, 0.07563926f, 0.00912714f, -0.02994463f, 0.10382693f, -0.12670638f, -0.03172367f, 0.10294050f, 
    -0.19872378f, -0.10967278f, -0.10302895f, 0.02901314f, -0.05959574f, 0.05958610f, 0.02278402f, 0.01797916f, 
    0.03013551f, -0.01109963f, -0.02714809f, -0.03256113f, -0.12419717f, 0.04859142f, 0.11239696f, 0.08636169f, 
    0.07743232f, 0.03849933f, -0.04587573f, -0.03713410f, 0.12618324f, -0.05443346f, -0.07716388f, -0.09578890f, 
    0.00228313f, -0.00793144f, -0.00957252f, -0.00398957f, 0.01298143f, 0.02442622f, -0.04304991f, 0.06112786f, 
    -0.00559350f, -0.09735014f, -0.06425530f, 0.01011295f, 0.02718502f, -0.11919685f, 0.16733876f, -0.03460665f, 
    0.10749052f, -0.03026303f, 0.00375090f, -0.02491435f, -0.06353409f, 0.07192339f, -0.07372712f, 0.00419639f, 
    -0.06776132f, -0.00880167f, 0.00134819f, -0.07448897f, 0.03654467f, 0.03358719f, 0.04846679f, -0.10137153f, 
    0.25654817f, -0.15799183f, 0.06639968f, 0.10280482f, -0.25247705f, -0.00858308f, -0.02652119f, 0.02058483f, 
    0.03524480f, -0.02218851f, -0.07306761f, 0.15303698f, 0.01984983f, 0.04012396f, 0.02806319f, -0.00335571f, 
    -0.13591047f, 0.10091527f, 0.01882133f, -0.01157619f, 0.24779931f, -0.08466943f, 0.16748805f, 0.02619462f, 
    0.03456134f, -0.03933056f, 0.00495572f, 0.07528230f, -0.05903537f, 0.01677293f, 0.00307407f, -0.05945864f, 
    0.04660649f, -0.03845496f, 0.05269610f, -0.00642051f, -0.03029619f, -0.04230823f, 0.01165798f, 0.00507318f, 
    0.20506704f, -0.52340490f, 0.16016456f, -0.04472033f, -0.12511796f, 0.04280240f, 0.03925332f, 0.06744265f, 
    -0.07446442f, -0.02133417f, -0.14348409f, 0.06246913f, 0.06246219f, 0.03854748f, 0.10608202f, 0.03697025f, 
    0.04877843f, 0.03964783f, -0.05589851f, -0.02603473f, 0.07396499f, -0.34352744f, -0.17047703f, 0.16247600f, 
    -0.28690904f, -0.03727126f, -0.01838694f, 0.08143260f, 0.12670840f, 0.02063138f, 0.10257368f, 0.06331988f, 
    -0.10961895f, -0.00897899f, 0.05997935f, 0.03497350f, -0.18865019f, 0.04689416f, -0.05342523f, 0.08703667f, 
    0.17885245f, 0.01717885f, 0.07579592f, -0.02757895f, 0.00583338f, -0.02044971f, -0.13645807f, -0.00856854f, 
    0.01809786f, 0.05193864f, -0.01914743f, -0.01661470f, -0.11579702f, 0.03869440f, -0.03581913f, 0.12535010f, 
    0.04786339f, -0.03143168f, -0.01571322f, 0.06238104f, 0.06711157f, -0.06000618f, 0.05869028f, -0.13150471f, 
    0.08335408f, -0.12697740f, -0.04848970f, 0.11187429f, 0.00835176f, -0.09525588f, 0.01766506f, 0.01745770f, 
    -0.07188267f, 0.02306111f, 0.04592010f, -0.02446513f, 0.01246792f, 0.01430316f, -0.02180698f, 0.02392163f, 
    0.07802123f, -0.06707522f, 0.11115012f, -0.08301865f, 0.01197395f, -0.14605768f, -0.02191063f, -0.00430791f, 
    0.01606964f, -0.02910834f, -0.02262767f, 0.10233202f, 0.04825747f, -0.00354700f, 0.01501817f, 0.14902884f, 
    0.00319885f, 0.05471553f, -0.05061434f, -0.00742112f, -0.13185047f, -0.03223255f, 0.01647824f, 0.04729649f, 
    0.04954592f, 0.00053945f, -0.06057717f, 0.00900267f, -0.12063838f, -0.00306903f, -0.01914060f, -0.03587446f, 
    0.08528308f, 0.03119878f, 0.04580004f, 0.00046703f, -0.08142748f, 0.00489427f, -0.03737387f, -0.16240187f, 
    0.22677056f, 0.06242446f, -0.08130228f, -0.08136860f, -0.00403597f, -0.11265069f, -0.01865697f, -0.15020810f, 
    0.06028076f, -0.02697162f, 0.01693113f, 0.02322546f, 0.03873900f, 0.00650698f, 0.02127844f, -0.02080124f, 
    0.01183913f, -0.00625427f, -0.00781619f, -0.02064437f, -0.29210651f, 0.11718577f, -0.03374134f, -0.02357684f, 
    -0.29615679f, -0.04846479f, -0.03045771f, 0.00344244f, -0.01041044f, 0.03139634f, -0.02820664f, -0.01692272f, 
    -0.03803420f, -0.05059363f, -0.00572588f, -0.02034015f, 0.03125006f, 0.05333313f, -0.04795016f, 0.03320608f, 
    0.24810025f, 0.11087932f, 0.10273794f, -0.14341040f, -0.15339315f, 0.07818047f, 0.02541411f, -0.02669832f, 
    -0.02565819f, -0.00319900f, -0.00108136f, 0.05336941f, 0.04463112f, -0.03666860f, 0.04754215f, -0.09487948f, 
    -0.00668711f, 0.07659849f, 0.01148346f, -0.06128631f, -0.00721768f, -0.28723335f, 0.20283529f, 0.06071138f, 
    -0.04624421f, 0.02286068f, 0.09120934f, 0.07052885f, 0.05103799f, 0.05184644f, -0.10183369f, -0.01051880f, 
    0.02196493f, 0.02125543f, -0.05462249f, 0.01639366f, -0.05937492f, -0.00894862f, 0.06591663f, -0.09185657f, 
    0.04696494f, 0.16277361f, 0.07288543f, 0.05878901f, -0.24949369f, 0.07688026f, 0.02084974f, 0.05009924f, 
    0.02066572f, -0.10803656f, 0.05564508f, -0.01220773f, -0.07217608f, -0.08848663f, 0.01499717f, 0.02918873f, 
    0.09116098f, -0.02857431f, -0.02445108f, 0.02972029f, -0.15020199f, -0.19531506f, -0.09776289f, 0.08218960f, 
    -0.06026500f, 0.01085455f, -0.00495296f, 0.06038090f, 0.03458179f, 0.02967492f, -0.01108420f, 0.04339638f, 
    -0.01767214f, -0.00489044f, -0.01099718f, -0.00228120f, 0.00039188f, -0.01884864f, -0.00683063f, -0.02381084f, 
    0.03055031f, -0.33251721f, 0.02947723f, 0.02595327f, -0.02112569f, 0.09157138f, -0.05713702f, 0.06790491f, 
    -0.10028978f, 0.07251663f, -0.00603089f, -0.02330341f, -0.03681014f, 0.15201622f, -0.04937131f, -0.04228038f, 
    -0.01982962f, 0.02120385f, -0.13785742f, -0.06608955f, -0.16060014f, 0.08011925f, 0.12119339f, -0.01292516f, 
    0.29364771f, -0.04465917f, -0.09663472f, 0.03060303f, -0.00384069f, -0.04695537f, -0.00386495f, -0.06444070f, 
    -0.02358371f, -0.02380676f, 0.01107902f, 0.03950291f, 0.03006216f, -0.05708998f, -0.04616626f, 0.03816290f, 
    0.11576867f, 0.04879064f, 0.00289446f, -0.09863306f, 0.11052892f, -0.08699443f, -0.10152967f, -0.05210761f, 
    0.04036385f, -0.04351095f, -0.00682060f, 0.01669935f, 0.02145029f, 0.04001847f, 0.02642084f, 0.02584312f, 
    0.01503177f, -0.05608521f, -0.00211337f, -0.00582749f, 0.09264496f, 0.17702329f, 0.05842851f, -0.07619717f, 
    0.21490404f, -0.10095465f, -0.05250007f, 0.00488881f, 0.05291384f, 0.01657325f, -0.03869630f, 0.01397394f, 
    -0.08716977f, -0.03599659f, 0.07678869f, -0.02858918f, -0.03925551f, 0.00184707f, 0.03600710f, 0.00145748f, 
    0.19473983f, 0.27878985f, 0.18217357f, -0.28558591f, 0.11089791f, -0.01028763f, 0.09082635f, -0.08647502f, 
    0.10315364f, -0.02073353f, -0.08372752f, 0.02883304f, -0.03927537f, 0.08966342f, 0.08899817f, 0.06812308f, 
    0.06730110f, -0.10134522f, 0.08740453f, 0.03865143f, -0.34132090f, -0.01186283f, -0.19960244f, 0.06154928f, 
    -0.16786799f, -0.05311712f, -0.01916661f, -0.02618978f, 0.03416894f, -0.00071186f, 0.02082815f, -0.04272733f, 
    -0.05647442f, 0.05338873f, 0.03027050f, -0.00995217f, -0.04756051f, 0.03093057f, 0.06224401f, -0.07567357f, 
    0.00903780f, -0.05307326f, 0.00757067f, -0.01091776f, 0.15938048f, -0.14754939f, 0.03646460f, 0.06898084f, 
    0.03769644f, -0.03058065f, 0.03985084f, 0.03516523f, -0.01581525f, -0.00953699f, -0.04902741f, 0.08353731f, 
    0.03697261f, 0.08311172f, -0.07676210f, -0.01227714f, 0.18584122f, -0.01818875f, 0.24859461f, -0.18773025f, 
    0.05543065f, 0.01982289f, -0.04482037f, 0.07958277f, -0.05938270f, 0.04802632f, -0.02862224f, 0.02468350f, 
    -0.05572303f, -0.06572349f, 0.00380607f, -0.00149442f, -0.00073609f, 0.06385108f, 0.03374733f, -0.06678277f, 
    -0.14320903f, -0.00620513f, -0.06173770f, 0.08745737f, 0.16426040f, -0.04516857f, -0.05617148f, -0.05980310f, 
    0.02921703f, -0.09014618f, 0.09130511f, -0.04506487f, 0.04571977f, 0.01654907f, 0.00360482f, -0.01219455f, 
    0.04097933f, 0.03778589f, 0.03298517f, 0.06338146f, 0.11928221f, 0.01371334f, 0.09998748f, 0.12806772f, 
    0.01974433f, -0.00012196f, -0.06440357f, -0.02851311f, 0.05975057f, 0.00675232f, 0.03116270f, -0.06447995f, 
    -0.05844319f, -0.06932292f, -0.03398796f, 0.00431624f, 0.00872137f, 0.05310315f, 0.09677001f, 0.04182123f, 
    -0.10518868f, 0.14614823f, 0.08167173f, -0.02941127f, 0.09241358f, -0.02172315f, -0.16716911f, 0.03239692f, 
    -0.00168736f, -0.01265182f, -0.00065253f, 0.06289431f, -0.09815236f, 0.13374729f, -0.05490933f, -0.02855065f, 
    -0.07497744f, 0.04869806f, -0.02716799f, 0.00800520f, 0.15729220f, -0.05067317f, -0.01532159f, -0.10728748f, 
    -0.03155185f, -0.08347860f, -0.09925990f, -0.14549537f, -0.00729810f, -0.02111425f, -0.01841992f, 0.00698644f, 
    -0.00303784f, 0.03347277f, -0.01081578f, 0.09288559f, 0.01460853f, -0.07099123f, 0.00895577f, 0.11652715f, 
    -0.01420210f, 0.14802557f, 0.02402072f, -0.16342197f, -0.27952784f, -0.01094346f, 0.00724267f, 0.02461366f, 
    -0.01150113f, -0.03762083f, 0.03423426f, 0.02629531f, -0.02534440f, 0.02170286f, -0.00583566f, -0.00386353f, 
    0.04046378f, 0.10505134f, -0.00002648f, -0.00302249f, 0.06906792f, 0.10028239f, -0.03340601f, -0.08501814f, 
    0.08009514f, -0.13109180f, -0.10086705f, -0.09330704f, 0.01824719f, 0.02549747f, -0.02040674f, 0.00431386f, 
    -0.06850516f, -0.10712420f, 0.00347893f, -0.01538022f, 0.02147073f, 0.07267929f, -0.01358614f, 0.02472396f, 
    0.16507761f, 0.11227760f, -0.02913321f, -0.09455766f, 0.18117805f, -0.13441382f, -0.08400191f, -0.07704015f, 
    0.02576690f, 0.02512949f, -0.05566111f, 0.01970197f, -0.00223620f, -0.00621783f, 0.06019602f, -0.01194111f, 
    0.01110757f, -0.03338091f, 0.01601714f, 0.04177570f, -0.10570325f, -0.05112526f, 0.11535507f, 0.05395074f, 
    -0.00321236f, 0.00719845f, -0.09905008f, 0.04019031f, -0.12446934f, -0.02777080f, 0.00675801f, -0.05622246f, 
    0.05519094f, 0.03919837f, 0.06959075f, -0.04746791f, 0.00820023f, -0.01354313f, -0.03199263f, -0.01939868f, 
    -0.27903575f, 0.09291379f, -0.07042202f, -0.07012060f, -0.32053307f, -0.01492532f, -0.02189545f, -0.05147555f, 
    0.07008542f, 0.04667459f, 0.02722611f, 0.00578444f, -0.05862420f, 0.03652171f, -0.03005512f, 0.07145160f, 
    -0.02094588f, -0.02820493f, 0.03917452f, -0.04280093f, -0.08249274f, -0.16478543f, 0.19896193f, 0.01934256f, 
    -0.15755850f, -0.00093004f, -0.10913835f, 0.04806498f, 0.03790627f, -0.00728364f, 0.03012205f, 0.08393408f, 
    0.05355690f, 0.03810600f, -0.03810020f, -0.00001399f, -0.02197776f, -0.07327662f, -0.00864713f, -0.03995119f, 
    0.57856387f, 0.08751359f, 0.18939993f, -0.15366356f, 0.06028830f, -0.17740196f, 0.10254679f, 0.10705999f, 
    0.03212260f, -0.11862297f, 0.09870639f, 0.04545095f, 0.07064103f, 0.11530764f, 0.14422497f, 0.04709648f, 
    -0.00504270f, 0.01553702f, -0.00236859f, -0.04184912f, -0.06809969f, 0.10602201f, -0.05698299f, 0.00411951f, 
    0.01794742f, -0.05556476f, -0.04559607f, -0.08125028f, -0.03050109f, -0.01045845f, 0.01276038f, -0.03177826f, 
    0.05205308f, -0.05134028f, 0.00185213f, -0.00180943f, -0.01285568f, 0.07046479f, 0.02046506f, 0.00122320f, 
    0.06856797f, 0.10334870f, 0.12862045f, 0.01107005f, 0.10959189f, -0.13335751f, 0.03247942f, 0.00286330f, 
    -0.07124945f, 0.04625916f, -0.01734868f, -0.00409349f, 0.04362413f, -0.00834193f, 0.01027831f, 0.01822235f, 
    0.00123990f, 0.03295519f, 0.00947781f, 0.07209510f, -0.34894761f, 0.03191165f, -0.00650902f, 0.03196902f, 
    -0.10648484f, -0.02249430f, 0.00883005f, -0.03630255f, 0.01732725f, 0.07400078f, 0.14776814f, 0.05549824f, 
    -0.07633889f, -0.01301894f, -0.02575961f, -0.00720762f, -0.03577624f, -0.04766258f, 0.04552275f, 0.03147679f, 
    0.09366132f, -0.26116106f, 0.05936817f, -0.28666493f, -0.23163079f, 0.05071542f, 0.01555029f, -0.00294921f, 
    -0.06107147f, -0.07334324f, 0.10429480f, 0.06735282f, 0.09154893f, -0.03846775f, -0.03780134f, 0.00259048f, 
    0.01834588f, -0.12379707f, 0.06233583f, -0.06929785f, -0.09100240f, -0.14740272f, 0.09885071f, -0.32644236f, 
    0.04228422f, -0.10922462f, 0.00755296f, 0.00195530f, -0.01983891f, 0.00930971f, -0.05585951f, -0.06426329f, 
    0.00206227f, 0.00082283f, -0.14999323f, -0.06675453f, -0.10407451f, -0.08720843f, 0.05056215f, -0.11858725f, 
    0.15825713f, -0.01546135f, -0.00697003f, 0.04987669f, -0.09084325f, -0.00466928f, 0.02698314f, 0.09920589f, 
    0.07180433f, 0.08041170f, -0.08116128f, -0.03942325f, 0.04420128f, -0.01313100f, -0.00809410f, 0.11254681f, 
    0.03287217f, -0.03169100f, -0.03991450f, 0.02688100f, 0.29381007f, -0.20319918f, -0.06742469f, -0.15704186f, 
    -0.08187484f, -0.02125278f, -0.07071005f, -0.00510002f, 0.06864341f, 0.00521711f, -0.03695633f, 0.01023872f, 
    -0.03765608f, 0.09542732f, 0.08446530f, -0.04966663f, -0.03564989f, -0.01270917f, -0.06570105f, 0.02314177f, 
    0.29978916f, -0.16026558f, 0.03802726f, -0.01381866f, -0.15714963f, 0.00321611f, 0.11926055f, 0.03369669f, 
    0.00533383f, 0.11929443f, 0.08089589f, -0.01549973f, 0.07383519f, -0.02848181f, -0.00483646f, 0.03946913f, 
    0.05204150f, 0.01785129f, 0.04824401f, 0.02555320f, -0.04761810f, -0.12717420f, -0.00800924f, -0.15029387f, 
    -0.07891136f, 0.17813203f, -0.00495164f, 0.05250437f, 0.07193077f, -0.01887487f, -0.13718985f, -0.03942883f, 
    -0.01200953f, 0.04078533f, 0.02551253f, 0.06533188f, -0.01806015f, 0.00932836f, 0.03692190f, 0.00620710f, 
    0.17259927f, -0.07721101f, -0.10972878f, 0.04002685f, -0.25600839f, -0.06407059f, 0.05874756f, -0.01222536f, 
    -0.02997399f, 0.00902746f, 0.08217713f, 0.05796597f, -0.04612089f, 0.04503547f, -0.01200282f, 0.05615978f, 
    0.05611226f, -0.04325203f, -0.02758997f, 0.01551003f, -0.10768664f, -0.20246676f, -0.03458251f, -0.22410409f, 
    0.08941607f, -0.00893647f, -0.08128411f, 0.03606405f, 0.14010292f, -0.09351664f, -0.07304016f, -0.05439404f, 
    -0.04173502f, -0.01662033f, -0.01208099f, -0.08350348f, -0.03458416f, 0.03088745f, 0.09062097f, -0.12409934f, 
    0.40432748f, -0.16550067f, 0.10096403f, -0.06470389f, -0.03420828f, -0.07359604f, -0.10189195f, -0.01149299f, 
    0.02608164f, -0.06362133f, 0.00075209f, 0.02331592f, -0.07024061f, 0.01984077f, 0.05483371f, 0.01700710f, 
    -0.10008718f, 0.06675949f, -0.04341019f, -0.00645267f, -0.09010199f, 0.01396295f, -0.11441620f, -0.10131509f, 
    -0.08979434f, 0.08357767f, 0.00407502f, -0.02794107f, -0.02790366f, -0.04644120f, -0.07078989f, 0.10743198f, 
    -0.05964091f, -0.00416332f, 0.00314158f, 0.02222723f, -0.01619254f, 0.12034586f, 0.03605814f, -0.02119178f, 
    -0.14272976f, 0.14888360f, -0.21348153f, -0.08294384f, -0.02795405f, -0.00279586f, -0.00479821f, 0.00432060f, 
    0.01314242f, -0.00158704f, 0.04072601f, -0.03666555f, 0.04987885f, 0.07730749f, -0.04156465f, -0.06568651f, 
    -0.01054330f, 0.05175711f, -0.12474971f, 0.07240658f, -0.22470210f, 0.01704955f, -0.10272509f, -0.10657355f, 
    0.03227270f, 0.07795294f, 0.01125926f, -0.00357491f, 0.01024168f, 0.08215377f, 0.00237217f, 0.05297407f, 
    0.04951245f, -0.01366887f, 0.00141239f, 0.02284007f, 0.04728672f, -0.00723951f, -0.01492751f, 0.01454739f, 
    0.10584890f, 0.15800750f, 0.04127128f, -0.10133048f, -0.09553572f, -0.13985293f, 0.04992065f, 0.04871568f, 
    0.02874094f, 0.07714579f, -0.00414182f, -0.01860449f, 0.11903379f, -0.05749422f, 0.08582118f, -0.00606103f, 
    -0.01156680f, -0.07995350f, 0.08450556f, 0.18056478f, 0.07059907f, 0.10560542f, 0.11332937f, 0.03972552f, 
    0.13882777f, 0.07426962f, -0.06511743f, -0.02384103f, -0.03095255f, -0.05580195f, -0.00043050f, -0.00400365f, 
    0.01841135f, -0.04247061f, -0.08498243f, 0.08008426f, -0.03592638f, 0.05252990f, 0.07130538f, 0.21456657f, 
    -0.00462650f, -0.01172217f, -0.10120645f, -0.05699958f, 0.10726610f, -0.04574561f, -0.04500137f, 0.01954939f, 
    -0.00269749f, 0.00747110f, 0.09776429f, -0.00969644f, 0.03239740f, 0.06363079f, -0.02320002f, -0.05567921f, 
    -0.04391744f, -0.11081528f, -0.04405427f, -0.03728750f, 0.12724128f, -0.28253725f, 0.03519649f, -0.01980863f, 
    0.02970178f, 0.03623163f, -0.03782012f, 0.01310908f, -0.00363255f, -0.02550574f, 0.14010051f, -0.00387247f, 
    0.03407803f, -0.02656528f, -0.06035575f, 0.05205489f, 0.02910396f, 0.00402908f, -0.00741259f, 0.02676538f, 
    0.20697114f, 0.03568102f, -0.04895451f, 0.03440175f, -0.14737806f, -0.00989444f, -0.01286324f, 0.01534039f, 
    0.03924207f, 0.07564204f, -0.01896693f, -0.02837516f, 0.02046883f, 0.08718143f, -0.06098490f, -0.05703193f, 
    0.13300246f, -0.03079495f, -0.06824402f, 0.09171133f, 0.04937029f, -0.45874289f, 0.06979116f, -0.21605341f, 
    -0.08165792f, -0.13686423f, -0.12636876f, 0.01324569f, 0.01240523f, -0.02249383f, -0.00941823f, 0.01097059f, 
    -0.11567038f, 0.03711589f, -0.06378381f, -0.10613449f, -0.15371169f, 0.00329392f, 0.03070877f, -0.11598008f, 
    -0.18064347f, 0.12289400f, -0.15193023f, 0.07543694f, -0.17762531f, 0.04013562f, 0.02119049f, -0.01115339f, 
    -0.09358198f, -0.02358485f, 0.01460652f, 0.12360881f, -0.12315003f, 0.02277154f, 0.07645126f, 0.03435498f, 
    0.02910673f, -0.00345404f, 0.02374870f, -0.07171575f, 0.22580905f, -0.60649729f, 0.15903150f, -0.14383727f, 
    -0.04429514f, -0.04391624f, -0.01671897f, -0.03268453f, -0.04308658f, -0.01276977f, -0.01582558f, -0.02051030f, 
    -0.12860920f, 0.15714552f, -0.00548546f, -0.11921100f, -0.02511171f, -0.09732250f, 0.07392693f, 0.07563189f, 
    -0.27306864f, -0.17127666f, -0.01701738f, -0.13729857f, 0.16381571f, 0.05096053f, -0.09727590f, -0.04292279f, 
    -0.05861012f, 0.00746347f, 0.08679699f, 0.11827036f, 0.05995707f, -0.04995253f, 0.07757973f, -0.03129369f, 
    -0.05112446f, -0.09996286f, -0.00176492f, -0.05774372f, -0.42110819f, 0.15173948f, 0.03959590f, 0.00001295f, 
    -0.22795549f, 0.08519034f, -0.02096126f, 0.02291691f, 0.04208193f, -0.04775346f, -0.06762365f, -0.03631618f, 
    0.00507120f, 0.04456660f, -0.01245105f, -0.02986958f, -0.04814190f, -0.06007589f, 0.01888156f, -0.02879661f, 
    -0.17031984f, -0.17436838f, 0.02080567f, 0.03693210f, 0.11293289f, -0.00889673f, 0.02212043f, -0.05469636f, 
    -0.00693277f, -0.07875937f, 0.00044795f, 0.02343497f, -0.08236032f, 0.03318211f, -0.12960389f, 0.02706819f, 
    -0.14025670f, 0.05627627f, 0.04516816f, 0.00674504f, 0.02946584f, -0.11118560f, -0.08971186f, -0.18653719f, 
    0.02440130f, 0.00297692f, -0.09164122f, 0.15420726f, 0.00508327f, 0.02831012f, -0.07950069f, -0.08627917f, 
    0.10892904f, -0.00513383f, 0.13667506f, -0.14152929f, -0.00572659f, -0.12461077f, -0.21315137f, -0.04679407f, 
    -0.09002352f, 0.07720054f, 0.13598543f, -0.03802973f, -0.00896601f, -0.05309900f, -0.08418863f, -0.00559195f, 
    -0.02000023f, 0.01037503f, -0.01563233f, -0.07350977f, -0.02009084f, -0.02032031f, 0.00403776f, -0.03530524f, 
    0.04531793f, -0.06990317f, -0.01805446f, 0.08526690f, -0.12803295f, 0.23961498f, 0.12972283f, 0.07597974f, 
    -0.03441533f, 0.02415318f, -0.07636207f, 0.06605254f, 0.02056188f, 0.10435562f, 0.04566071f, 0.02148047f, 
    -0.04441011f, -0.04699607f, 0.00196222f, 0.07935791f, -0.01980233f, 0.04642273f, -0.02496977f, 0.01404345f, 
    0.25315404f, 0.18304779f, 0.06525701f, 0.07744474f, 0.13125981f, 0.00804496f, -0.06888442f, 0.02896204f, 
    0.00668751f, 0.05913918f, -0.00918459f, 0.04159570f, -0.00124900f, -0.02268157f, -0.02919202f, -0.00595055f, 
    0.02620161f, 0.04934468f, 0.04403863f, 0.00508929f, -0.07060044f, -0.12057331f, -0.08122852f, -0.23386195f, 
    0.01869749f, 0.04325632f, -0.05077384f, 0.07540088f, 0.02922028f, 0.02209617f, 0.03604049f, -0.00898220f, 
    0.07270242f, -0.01169191f, 0.02780265f, -0.03437868f, -0.01575132f, -0.06404080f, -0.08126853f, -0.06939790f, 
    0.15902667f, -0.02447070f, 0.00565438f, -0.01559370f, 0.01284062f, -0.00270551f, 0.01961496f, 0.04561969f, 
    -0.07897437f, 0.02643215f, 0.01713003f, -0.08539101f, 0.07077644f, -0.05841557f, 0.02549822f, -0.06966037f, 
    -0.00700681f, -0.09400859f, -0.02790762f, 0.11857525f, -0.26113653f, 0.16010877f, -0.06784642f, -0.03774462f, 
    0.00310943f, 0.03270783f, 0.01954194f, -0.01069497f, -0.08461124f, -0.05205074f, -0.03159995f, 0.08657494f, 
    0.04343202f, 0.01793244f, 0.03917622f, 0.14164828f, -0.06100882f, 0.10275068f, 0.06428559f, 0.06688889f, 
    0.07424752f, -0.24353760f, 0.13426794f, -0.08579488f, 0.03339183f, 0.00679682f, 0.13057038f, 0.00812411f, 
    0.00664472f, -0.01991781f, 0.05425240f, -0.18524018f, 0.06426036f, -0.05492186f, -0.10927258f, 0.05042330f, 
    0.04852075f, -0.15266807f, 0.02179562f, -0.02942683f, -0.15021993f, 0.02907385f, 0.03600721f, -0.02174285f, 
    -0.22383143f, 0.01308245f, 0.03502503f, -0.01539935f, -0.04017567f, 0.02202393f, 0.05237015f, -0.06732015f, 
    -0.03581409f, -0.00891596f, -0.01235737f, -0.05826012f, -0.05457677f, -0.09509201f, -0.12070136f, -0.00970667f, 
    0.08667881f, 0.09455102f, 0.09567160f, 0.02170908f, 0.17433843f, -0.14256407f, -0.05228458f, 0.07416973f, 
    0.02394180f, -0.01240589f, -0.00925391f, -0.08717728f, 0.06093856f, 0.02534509f, 0.01277264f, 0.00750294f, 
    -0.06197086f, -0.01293056f, 0.01240699f, 0.03288427f, 0.02565487f, 0.06183264f, 0.12382258f, 0.01758715f, 
    0.12070701f, -0.08596082f, 0.00623915f, -0.00563112f, -0.03962894f, -0.02766893f, -0.08960763f, -0.01199845f, 
    0.00245370f, -0.00713800f, -0.04025327f, 0.01093235f, 0.03567881f, 0.02081649f, 0.04424571f, 0.03046316f, 
    0.03113120f, -0.14817886f, 0.17258564f, -0.08531947f, -0.01846851f, 0.01704251f, -0.13621360f, -0.00317694f, 
    -0.03044606f, -0.01597074f, -0.05154998f, -0.02543391f, 0.00204562f, -0.04342710f, 0.03899119f, 0.00871303f, 
    0.03353193f, -0.06734148f, 0.06953152f, -0.00835610f, -0.11787421f, 0.22076614f, -0.01016581f, -0.06444543f, 
    0.21858782f, -0.13415863f, -0.02817690f, -0.02739713f, 0.00057454f, -0.02112394f, 0.09298511f, -0.07542641f, 
    0.04500950f, -0.01364921f, -0.15674698f, -0.01860777f, -0.01000149f, 0.03476874f, -0.10388372f, 0.06039083f, 
    0.14519484f, 0.12553163f, 0.03037396f, 0.12366875f, 0.09877533f, 0.08347744f, -0.11349560f, -0.03377698f, 
    0.00741748f, 0.01542698f, -0.00001681f, -0.00947712f, -0.03367141f, 0.05245532f, -0.05178668f, 0.06826595f, 
    0.02347039f, 0.05625573f, -0.05661842f, 0.04733159f, 0.28525823f, -0.22054063f, -0.20256849f, 0.09791562f, 
    -0.02505319f, -0.03431658f, 0.01602103f, 0.00466629f, 0.07813993f, 0.08609504f, 0.09066289f, -0.02032858f, 
    -0.00536522f, 0.06538036f, 0.00906288f, 0.12438024f, -0.00763456f, -0.05912863f, -0.02309605f, -0.03011681f, 
    0.01394356f, -0.09877887f, -0.21968244f, -0.02847609f, -0.06056035f, 0.09363149f, -0.02526455f, -0.01601138f, 
    0.11480696f, 0.18204014f, 0.04084332f, 0.00076669f, -0.09888364f, -0.03388356f, 0.07482936f, -0.02885845f, 
    0.08536925f, 0.00923953f, -0.11761510f, -0.04336654f, 0.00151846f, -0.06632686f, 0.00022203f, -0.02742710f, 
    0.00789255f, 0.06625534f, -0.02134621f, 0.06415743f, 0.00057485f, 0.00110148f, 0.02786870f, 0.03750932f, 
    -0.03540780f, 0.02137843f, 0.01938679f, -0.01676351f, -0.00367272f, -0.11406763f, 0.05302204f, -0.12119932f, 
    0.03268108f, -0.03272693f, -0.02164959f, 0.10084094f, -0.13102001f, 0.03238194f, 0.09392177f, 0.01394572f, 
    -0.03250373f, 0.15626219f, 0.09850667f, 0.06177552f, -0.03197823f, -0.03612828f, -0.05894324f, 0.00576778f, 
    0.06984318f, 0.05500442f, 0.03254557f, -0.02277629f, -0.23106596f, 0.06212692f, 0.03807447f, -0.02116342f, 
    -0.18295528f, -0.14841320f, -0.00926140f, 0.00552031f, 0.03937750f, 0.02834445f, -0.04099610f, 0.01657869f, 
    0.00645680f, -0.00669745f, -0.00008687f, -0.12484749f, 0.07191150f, -0.07122860f, -0.06643797f, 0.09693574f, 
    -0.14366157f, -0.01304032f, -0.10995623f, -0.23188207f, 0.09450887f, 0.04542502f, -0.16058616f, 0.05380028f, 
    0.02714983f, 0.02669145f, 0.03319437f, 0.00465185f, 0.05497346f, -0.11199094f, -0.03131039f, -0.04768670f, 
    0.02224730f, -0.16299239f, -0.06383928f, -0.02004723f, 0.09600940f, 0.04590557f, -0.02552956f, 0.07603639f, 
    0.18055184f, 0.03861089f, -0.05046079f, -0.00338984f, -0.04785484f, -0.02385245f, 0.04258164f, 0.05780083f, 
    0.02695964f, 0.07136506f, 0.04568739f, -0.05942677f, 0.06669061f, 0.09449724f, 0.05041958f, -0.04694911f, 
    0.14880407f, 0.17086621f, 0.09292049f, 0.08912101f, 0.13852997f, -0.01955117f, -0.03756313f, 0.05052162f, 
    0.00877372f, 0.07022180f, -0.01477256f, -0.04796966f, -0.02547835f, 0.04204941f, -0.01900526f, 0.03667741f, 
    0.05915788f, 0.06682993f, -0.01568902f, 0.04170108f, 0.17846750f, -0.03067522f, 0.02217146f, 0.03082230f, 
    0.07451582f, -0.07508638f, -0.10122225f, 0.01468978f, -0.02188559f, -0.05304516f, 0.01871406f, 0.01345832f, 
    0.00389829f, 0.07251829f, -0.06672386f, -0.00541121f, 0.03853771f, -0.01863188f, -0.02061052f, -0.03653553f, 
    0.11324329f, -0.01373949f, -0.03924467f, 0.01349569f, 0.00827112f, -0.07085868f, 0.10186050f, -0.10019394f, 
    0.01046868f, -0.09153128f, 0.07551692f, -0.02641837f, 0.01390959f, -0.09890661f, 0.14031136f, 0.00116159f, 
    -0.03277214f, 0.04701344f, -0.10341539f, 0.07081330f, 0.24713349f, 0.01701613f, -0.03953205f, -0.00673624f, 
    -0.05674778f, 0.05349536f, 0.01600446f, 0.00592087f, 0.09323156f, 0.05322316f, -0.04830477f, -0.10478207f, 
    0.02523525f, 0.04032300f, -0.03172042f, 0.11695154f, -0.03927957f, 0.00940504f, -0.04448089f, 0.01873365f, 
    0.04391290f, -0.18160127f, 0.10127933f, -0.07870489f, 0.04284070f, -0.04165879f, -0.13208303f, 0.02701638f, 
    -0.03196908f, -0.00219455f, -0.05988887f, -0.01085158f, 0.01656344f, -0.01272021f, -0.01261480f, -0.01623207f, 
    0.01260827f, -0.09540682f, 0.04214479f, -0.01497750f, -0.40825000f, 0.08250695f, -0.12551959f, -0.12333387f, 
    0.17559642f, -0.17928258f, 0.07672661f, 0.03725425f, -0.03093237f, 0.06465244f, 0.07907472f, -0.02107547f, 
    0.11405873f, 0.00540017f, -0.03423331f, -0.03198871f, -0.04318070f, 0.06755753f, -0.07655168f, 0.01141619f, 
    0.00402049f, 0.12985681f, -0.10574113f, -0.12285538f, -0.07067804f, 0.02043473f, 0.05932509f, -0.03689836f, 
    -0.04144996f, 0.00788326f, -0.10121681f, -0.04092449f, -0.03349308f, 0.03411292f, 0.03726685f, 0.02564982f, 
    -0.03580646f, 0.06944084f, -0.00819861f, -0.00297143f, 0.12618965f, -0.08306979f, -0.15528622f, 0.00751156f, 
    -0.10211863f, 0.10063048f, -0.07706685f, 0.07496179f, -0.01117706f, -0.02540568f, 0.02196521f, 0.03474198f, 
    0.03311795f, 0.03776562f, -0.05668696f, -0.02971834f, -0.04773647f, -0.11677664f, -0.07334959f, -0.04702213f, 
    0.06839171f, -0.06592365f, -0.20537861f, -0.03703589f, 0.14908271f, -0.05753772f, 0.04538663f, 0.04628257f, 
    -0.08620879f, 0.04880459f, 0.00265410f, -0.03040632f, 0.06229256f, -0.07951340f, 0.03375722f, 0.00951606f, 
    -0.05293442f, 0.01330331f, -0.08739129f, 0.04068660f, 0.10327706f, 0.08498665f, 0.03100335f, 0.12626545f, 
    0.11525418f, -0.01213767f, -0.06263392f, 0.08330429f, 0.02472907f, 0.04922444f, 0.00637854f, -0.00526826f, 
    -0.03696762f, 0.02657522f, -0.00545553f, 0.09582924f, -0.05734922f, 0.11173981f, 0.00730307f, -0.08162733f, 
    0.11834408f, -0.10897814f, -0.15507646f, 0.02496233f, -0.19783451f, 0.02721682f, 0.00153416f, -0.01022086f, 
    0.02597764f, 0.09138218f, -0.01170458f, 0.03923259f, -0.00429304f, 0.03843175f, -0.02335833f, 0.09965134f, 
    0.00904845f, -0.06996796f, -0.04236296f, -0.01242603f, 0.12805772f, 0.11772810f, -0.14527580f, 0.03736089f, 
    0.09499744f, 0.06177320f, -0.05744083f, 0.07968744f, 0.02209649f, 0.01229746f, 0.07866238f, -0.04303695f, 
    0.02124281f, 0.11216811f, -0.04028971f, 0.00990589f, 0.04981309f, 0.00273383f, -0.06768678f, -0.00716288f, 
    0.07400698f, 0.11455586f, 0.02079008f, 0.19006242f, 0.09559793f, -0.03946821f, -0.07217234f, 0.00254887f, 
    0.01138704f, 0.01324847f, 0.05231398f, 0.00479072f, -0.01163652f, 0.10016906f, -0.12182406f, 0.03556758f, 
    0.07646767f, 0.01484925f, -0.02310651f, -0.01374276f, -0.11203788f, 0.03632217f, 0.05489183f, -0.03212177f, 
    0.14342311f, -0.09732092f, -0.01234351f, -0.04246514f, -0.08492005f, 0.06552362f, -0.01665493f, 0.06318246f, 
    0.03940118f, -0.04266839f, -0.03754110f, 0.02508165f, -0.03466101f, 0.03417156f, 0.03822822f, 0.08898395f, 
    0.21998419f, 0.00967507f, -0.11429545f, 0.08247295f, -0.10660575f, -0.02940973f, 0.00385536f, 0.00936381f, 
    0.01018768f, -0.00651912f, -0.00388381f, 0.01749821f, 0.00099967f, 0.07642186f, -0.02707540f, 0.02527192f, 
    0.06263714f, -0.03023073f, -0.07975141f, 0.00045725f, -0.25706404f, -0.05894279f, -0.22756723f, 0.00743340f, 
    -0.08397769f, 0.08734582f, -0.04119436f, 0.02672598f, -0.01854046f, 0.02852172f, -0.05603090f, 0.00459069f, 
    -0.16904834f, -0.02965841f, -0.00905113f, 0.01511685f, -0.03428156f, 0.05358962f, 0.05773303f, 0.06352142f, 
    -0.42553341f, -0.19635156f, -0.07832342f, -0.06680151f, 0.08210881f, -0.02006023f, -0.08831967f, -0.11181447f, 
    -0.08399303f, -0.05593522f, -0.01891474f, -0.02215388f, -0.02977540f, -0.16236436f, -0.00060012f, 0.00916578f, 
    0.00347022f, -0.06504812f, 0.04034689f, -0.05834709f, -0.15825742f, -0.06352876f, -0.12280635f, -0.15738931f, 
    -0.14176412f, 0.06768158f, 0.00162375f, 0.01983515f, -0.02283446f, 0.04833976f, 0.03257361f, -0.00132835f, 
    0.06888587f, 0.02357150f, 0.01705641f, -0.04940276f, 0.00684568f, -0.06985074f, -0.07223856f, 0.01235626f, 
    0.08137413f, 0.00852202f, -0.04103994f, -0.00421033f, 0.04283193f, -0.03405982f, 0.07458362f, 0.03314826f, 
    0.02025840f, -0.03462537f, -0.01929590f, 0.01011444f, -0.03297907f, 0.01653084f, -0.01108922f, -0.01472259f, 
    -0.06704181f, -0.07877634f, -0.06537511f, -0.02442367f, -0.07536268f, 0.08720253f, 0.00838931f, 0.09235992f, 
    0.04391425f, -0.02720585f, -0.05954681f, -0.04167382f, 0.01892094f, 0.05435774f, -0.02529538f, -0.05275490f, 
    0.02376839f, -0.02615105f, 0.02291732f, 0.00903135f, 0.00515607f, -0.06268562f, -0.01624611f, 0.02664720f, 
    -0.31029701f, -0.07442303f, -0.01218898f, -0.15021285f, -0.03035128f, 0.00865263f, 0.02001895f, 0.03382104f, 
    0.10050781f, 0.07704333f, -0.03304591f, -0.05397106f, -0.06086338f, -0.00304557f, -0.03092577f, 0.01057423f, 
    0.00286305f, 0.00180058f, 0.02669080f, 0.06142695f, 0.00813223f, -0.12125882f, -0.21769907f, 0.15026672f, 
    -0.17920521f, 0.04417098f, -0.04813324f, 0.03331221f, 0.08829410f, 0.02681581f, 0.08450654f, 0.00647372f, 
    -0.01570043f, 0.03077950f, -0.06812591f, -0.02061009f, 0.04176558f, 0.06282648f, 0.00314727f, -0.02795557f, 
    0.29150751f, -0.02638757f, 0.02556816f, 0.14689399f, 0.14374119f, -0.13752221f, -0.05850756f, -0.10234619f, 
    0.03030949f, -0.00668401f, 0.09069813f, -0.03776412f, -0.04105573f, -0.03208765f, -0.04177872f, -0.10803396f, 
    0.05733947f, 0.03808790f, 0.01249344f, -0.03737934f, 0.08276895f, -0.11635595f, -0.04721471f, -0.12373675f, 
    -0.09852068f, -0.00454246f, -0.03163882f, 0.04391242f, 0.04393542f, 0.01252052f, -0.06420618f, -0.02337500f, 
    0.01107906f, -0.02832155f, -0.01951540f, 0.03332173f, -0.03416716f, 0.07808064f, 0.03605230f, -0.01902429f, 
    -0.33869350f, 0.12040741f, 0.08520810f, -0.02337673f, 0.06061930f, -0.02423793f, 0.00533899f, 0.01150875f, 
    0.02974958f, 0.02747531f, 0.00179730f, -0.03572449f, 0.08067328f, -0.09400534f, 0.09371929f, -0.04251971f, 
    0.02868970f, -0.07353002f, -0.02371472f, 0.06120399f, 0.08541287f, 0.13906316f, -0.09098668f, 0.09641141f, 
    -0.08729418f, 0.01049354f, 0.03783252f, -0.01154267f, -0.06424223f, -0.03013296f, -0.02877811f, -0.01023794f, 
    0.00585077f, -0.00413160f, -0.02200105f, 0.02347675f, 0.01435777f, -0.05378811f, 0.01529896f, -0.02652136f, 
    0.19693516f, -0.00273302f, 0.18788455f, 0.13482888f, 0.24694696f, -0.13786948f, -0.12303123f, -0.08594521f, 
    0.03718846f, 0.06311273f, 0.06977669f, -0.05223766f, -0.02854095f, -0.00745844f, 0.00251200f, -0.10526497f, 
    -0.06886113f, -0.04475478f, -0.00865868f, -0.00213531f, -0.23982461f, 0.01402231f, -0.05317227f, -0.04692177f, 
    -0.13446276f, 0.08589627f, 0.02509429f, 0.08552904f, -0.06336956f, 0.03955137f, 0.00073940f, -0.00960942f, 
    -0.02840297f, -0.03893418f, 0.02651155f, 0.08008496f, -0.03245009f, 0.05450329f, -0.00013937f, -0.03449721f, 
    0.10536595f, 0.03754383f, -0.02314010f, -0.12877530f, -0.13594212f, 0.04166241f, -0.05500023f, 0.12029964f, 
    -0.04991627f, 0.01704197f, 0.00738903f, 0.02702288f, 0.08346803f, -0.09748597f, -0.02183983f, 0.01462295f, 
    -0.04636399f, 0.04695534f, 0.08103413f, -0.05063768f, 0.22992416f, 0.00050352f, -0.16416572f, 0.01577220f, 
    -0.02866146f, -0.03810256f, -0.02404138f, 0.02003788f, 0.06210621f, 0.01447909f, -0.02738483f, -0.03162831f, 
    0.04769538f, -0.05487344f, -0.01114285f, 0.05185347f, -0.03430237f, -0.11350017f, -0.00109222f, -0.00097369f, 
    0.23584801f, 0.15542457f, -0.20606378f, -0.05611801f, -0.07762622f, -0.00494570f, 0.07799253f, -0.02075244f, 
    -0.08268709f, -0.03494014f, -0.03796102f, -0.06583156f, -0.01057527f, -0.05873576f, 0.01361537f, 0.05061485f, 
    -0.00381229f, -0.09645109f, -0.01555666f, -0.01711136f, 0.19460192f, 0.00859782f, -0.00717171f, 0.01876965f, 
    0.09183297f, 0.00088921f, -0.08216550f, -0.07284945f, 0.05193180f, 0.01317655f, 0.01373508f, 0.01409005f, 
    -0.03727646f, -0.05890505f, -0.03519204f, -0.03408004f, 0.00729323f, -0.03638428f, -0.06308802f, -0.03116614f, 
    -0.22546081f, -0.14690471f, 0.04445425f, 0.03162844f, 0.01663223f, 0.02818132f, 0.04361584f, -0.03797826f, 
    -0.00773833f, 0.02556614f, 0.03588947f, -0.08241405f, 0.02160090f, -0.00390656f, -0.01355239f, 0.00225724f, 
    -0.01197789f, -0.01209146f, -0.08028906f, 0.02543006f, -0.02731189f, 0.06571539f, 0.00458058f, 0.01911790f, 
    0.05656389f, 0.00329095f, -0.06948780f, 0.00856424f, -0.01014248f, 0.01143582f, -0.02228955f, 0.02955597f, 
    0.01833978f, 0.07509395f, 0.04971594f, -0.04155396f, -0.05102002f, -0.05388627f, -0.10528951f, -0.00434147f, 
    -0.01511410f, -0.00891902f, -0.03686108f, -0.07372714f, 0.01147371f, -0.01582825f, -0.00175974f, 0.13147005f, 
    -0.07314692f, 0.01648578f, -0.11346101f, -0.00352991f, -0.00959613f, -0.05649781f, -0.02688437f, 0.02567197f, 
    -0.00429262f, 0.14101166f, -0.07994626f, 0.03961411f, -0.01786341f, 0.06056198f, 0.05438469f, -0.13104600f, 
    -0.01085459f, 0.00901300f, -0.02723450f, 0.02319103f, 0.03860030f, 0.02545997f, -0.04544722f, -0.04172209f, 
    -0.01104743f, -0.02571108f, -0.04252759f, 0.02382859f, -0.00993106f, 0.03917580f, 0.02967739f, 0.01044148f, 
    0.07831096f, -0.20093232f, 0.02436690f, -0.13169454f, -0.02492046f, -0.12000003f, -0.08389959f, -0.07105095f, 
    0.00895667f, -0.00248796f, 0.00532118f, -0.03419430f, 0.01517995f, 0.00387331f, 0.01836075f, -0.07404850f, 
    -0.00208474f, 0.01141185f, 0.02914930f, -0.04344732f, 0.00437173f, -0.15246718f, -0.16960150f, 0.06843203f, 
    -0.31218344f, 0.04847458f, -0.05565371f, 0.15167978f, 0.09449829f, 0.07120252f, -0.01297585f, 0.01980359f, 
    0.04340097f, -0.02627525f, -0.10379410f, -0.01172230f, 0.00138099f, 0.08868392f, -0.00381248f, 0.04138212f, 
    0.32094061f, -0.08837792f, 0.11550204f, -0.00701775f, 0.11517067f, -0.06855149f, -0.09607648f, 0.00599122f, 
    -0.00964786f, 0.06840634f, 0.07365841f, 0.00251496f, -0.00300536f, -0.05758259f, -0.00217576f, 0.03675820f, 
    -0.05910554f, -0.01137416f, -0.00973907f, -0.03306283f, 0.14665379f, -0.18730384f, -0.02510137f, -0.08117917f, 
    -0.05138957f, -0.01567881f, -0.12043893f, 0.08793667f, 0.14489320f, 0.01947680f, -0.00596417f, -0.04013823f, 
    0.05329713f, -0.00569713f, -0.02839181f, 0.02835567f, 0.01080724f, 0.00861375f, 0.04804830f, -0.04465169f, 
    0.13301048f, -0.10727667f, 0.02811066f, -0.09573091f, -0.05896280f, 0.01829347f, 0.00178387f, 0.05296603f, 
    -0.00301189f, -0.00073262f, -0.04185353f, -0.02137267f, -0.05758966f, 0.00334734f, -0.03781288f, -0.00837652f, 
    -0.03820730f, 0.05205255f, 0.03570268f, -0.01630595f, -0.03356775f, 0.01190008f, -0.03766621f, -0.04418261f, 
    -0.04148776f, -0.01480722f, 0.08781835f, -0.05547260f, -0.04850049f, -0.02199315f, 0.04470392f, -0.05198812f, 
    0.06283459f, -0.07339394f, -0.01432263f, 0.00010738f, 0.01571651f, -0.06123383f, 0.03208662f, 0.01253622f, 
    0.36714187f, 0.01205817f, -0.12784301f, -0.09003307f, -0.07336222f, -0.04769308f, -0.01168051f, 0.03361333f, 
    -0.00915154f, 0.02835904f, -0.02095874f, -0.02316659f, -0.01728286f, -0.00191391f, -0.04662895f, 0.01899579f, 
    0.06498467f, -0.03820483f, 0.03724131f, 0.06805352f, -0.26083368f, 0.08082284f, -0.05890759f, -0.19632271f, 
    -0.19704890f, 0.19657592f, -0.01526004f, -0.01260666f, -0.01837912f, 0.02625190f, 0.01529229f, 0.04021676f, 
    -0.03022081f, -0.05660373f, -0.03733280f, -0.05045675f, -0.01746558f, 0.12319327f, 0.02079627f, -0.06632362f, 
    -0.01912258f, 0.02810813f, 0.05055866f, -0.01884000f, 0.03963975f, -0.01019551f, 0.01956558f, 0.05086119f, 
    0.02635721f, -0.04781581f, 0.08736052f, 0.01368503f, 0.04113832f, 0.01306944f, -0.00092310f, -0.02860530f, 
    -0.03063878f, -0.02673914f, -0.02097572f, 0.01350012f, -0.38905904f, 0.12969562f, -0.05135298f, -0.05416790f, 
    0.03288381f, -0.01013712f, 0.02047907f, 0.00312950f, 0.07684671f, -0.04378964f, -0.02287479f, 0.02316202f, 
    0.01304002f, 0.04555321f, 0.04937072f, -0.04338751f, 0.05841865f, -0.11956374f, -0.08972051f, -0.00716462f, 
    -0.01408891f, -0.05687624f, 0.02159430f, -0.09308834f, 0.01195892f, 0.04889205f, -0.00406846f, 0.03374196f, 
    -0.02349368f, -0.03143891f, -0.01479817f, 0.01120406f, 0.06196314f, 0.00461948f, -0.01046634f, -0.06866658f, 
    -0.06504512f, -0.05276843f, -0.07234914f, -0.02670600f, -0.23764305f, -0.06836742f, -0.02884089f, -0.20102385f, 
    -0.17489564f, 0.08319771f, 0.01023015f, 0.03362200f, -0.04771750f, 0.01697389f, -0.00105138f, 0.01358686f, 
    -0.04681037f, -0.06279089f, -0.01529502f, 0.02680321f, -0.00511228f, 0.10439061f, 0.01476258f, -0.03854132f, 
    -0.41452768f, 0.04643292f, -0.17433739f, -0.18277839f, 0.04453362f, 0.02441279f, 0.00272557f, -0.03061471f, 
    0.08721997f, -0.05723582f, 0.01708771f, -0.00288517f, -0.05205822f, -0.04056482f, 0.02644270f, -0.02359740f, 
    0.04397386f, 0.05494089f, 0.09495708f, -0.02186070f, 0.23378320f, 0.16351387f, -0.01661196f, 0.03130672f, 
    0.12847351f, -0.03683202f, 0.00113008f, 0.01922084f, 0.04364591f, -0.01483545f, -0.03641497f, 0.02811562f, 
    0.01779582f, 0.03576174f, 0.04514800f, 0.03536622f, 0.01382096f, -0.10402700f, -0.06737412f, -0.00369911f, 
    -0.25745422f, -0.24591435f, 0.05036129f, -0.12851599f, -0.14436147f, -0.08061621f, -0.00767134f, -0.01213915f, 
    0.01848746f, 0.01895462f, -0.09640045f, -0.01756171f, -0.06233756f, -0.02549564f, -0.01252740f, 0.02558504f, 
    0.04300236f, 0.05108363f, 0.03408178f, -0.07510222f, 0.06934922f, -0.12073150f, -0.18245287f, -0.02155463f, 
    -0.10676876f, -0.09636837f, -0.00992136f, -0.00615725f, 0.03145032f, -0.04831340f, 0.01904266f, 0.00486715f, 
    0.00521360f, 0.04465174f, -0.00252833f, 0.05502787f, 0.00740945f, 0.02869558f, 0.03444551f, -0.02469630f, 
    -0.15918761f, -0.02770919f, -0.03549605f, -0.05515744f, 0.03344419f, 0.09588473f, 0.07581308f, -0.00228226f, 
    0.01903519f, -0.02578167f, -0.02335863f, 0.03592000f, -0.05369888f, -0.01397758f, -0.01183573f, -0.06334970f, 
    0.02495286f, -0.01638882f, -0.12712745f, 0.00054095f, 0.12888825f, -0.05156264f, 0.05506724f, -0.05609190f, 
    0.03917196f, 0.00305552f, 0.01816536f, 0.03819007f, -0.03939162f, 0.00654618f, -0.04028254f, 0.01262310f, 
    0.03528422f, 0.01799955f, -0.05478099f, -0.04156991f, -0.04804040f, -0.02306731f, -0.05394850f, -0.04491914f, 
    -0.02957191f, -0.08432069f, 0.07623338f, -0.06830701f, 0.03341717f, 0.01293805f, -0.05648991f, 0.00767370f, 
    0.02542573f, -0.03135367f, -0.00857806f, 0.08095311f, -0.02398757f, -0.03329693f, -0.01117175f, 0.00018081f, 
    -0.10879821f, 0.03145693f, -0.03261878f, 0.02779722f, 0.24525915f, 0.14142983f, -0.05212762f, 0.00946273f, 
    -0.07678217f, 0.03530994f, 0.05713177f, 0.02076973f, -0.02813668f, -0.10053841f, -0.05589172f, 0.04502711f, 
    0.03957994f, -0.03081486f, -0.01315717f, 0.03434741f, -0.05352825f, -0.08676199f, 0.00260004f, -0.03245879f, 
    0.05132534f, 0.16521402f, -0.07108539f, -0.10399853f, 0.11086388f, -0.02255561f, 0.06970472f, 0.05690795f, 
    -0.02223196f, -0.09545454f, -0.02972786f, 0.03137418f, -0.05633454f, -0.04791640f, 0.07201318f, 0.01979504f, 
    0.03941827f, -0.06266855f, -0.02374374f, 0.03679388f, 0.23781236f, -0.15175146f, 0.12112014f, 0.04345655f, 
    0.02624505f, -0.13218059f, 0.00110150f, 0.00430389f, -0.00083411f, 0.00194534f, 0.00424495f, -0.01170896f, 
    0.01072461f, 0.02140942f, 0.01438618f, 0.00235071f, -0.04251170f, 0.05086054f, -0.01419721f, 0.01406318f, 
    0.11546617f, -0.11330410f, -0.08594897f, -0.04441577f, 0.00545839f, -0.09102096f, 0.06448339f, -0.05270652f, 
    -0.03804733f, -0.03969388f, -0.02186542f, -0.01089677f, 0.03588415f, 0.04989173f, 0.04683796f, -0.01712045f, 
    -0.04823059f, 0.05392705f, 0.04116024f, -0.04381116f, -0.12066894f, -0.07536270f, -0.04185431f, -0.14630872f, 
    -0.21374279f, -0.02024570f, 0.04317736f, -0.01867542f, 0.00229439f, 0.02888154f, 0.00764920f, 0.04616221f, 
    0.02371326f, -0.07313490f, -0.05236135f, -0.02037801f, 0.00763066f, 0.04990841f, 0.00199444f, 0.00869755f, 
    -0.10129356f, 0.05872388f, 0.06677437f, 0.00455891f, 0.09548478f, -0.06581978f, -0.02091498f, 0.00775100f, 
    0.00739440f, 0.00816882f, 0.00908956f, -0.05095163f, 0.03419254f, -0.10696202f, 0.06986877f, -0.07252879f, 
    -0.00662135f, -0.04557930f, -0.01206131f, 0.03672388f, 0.10266969f, -0.07772820f, -0.06767241f, -0.02319445f, 
    -0.13732715f, -0.05797811f, -0.02188740f, 0.01959698f, 0.06432725f, -0.01191744f, 0.04195121f, -0.02866317f, 
    -0.01528007f, -0.08386360f, -0.02843152f, -0.00781313f, 0.01572649f, 0.06850073f, -0.00745255f, -0.07586179f, 
    -0.28837293f, -0.24065538f, 0.06978286f, -0.25440288f, -0.24889010f, 0.04935336f, 0.01115168f, -0.01727717f, 
    0.03516382f, -0.08691283f, -0.05305279f, 0.05313748f, -0.00702607f, 0.01677533f, 0.00090314f, -0.04259071f, 
    -0.06301193f, 0.02798738f, -0.01613725f, -0.01835673f, 0.17883502f, -0.01549324f, -0.07249672f, -0.06752075f, 
    -0.04899075f, -0.03491902f, 0.03100511f, 0.03870884f, 0.04519373f, 0.03506573f, -0.04286704f, 0.01518636f, 
    0.05931107f, 0.00353232f, -0.06099858f, -0.02551718f, -0.02454405f, -0.01411701f, -0.00890335f, 0.03275056f, 
    -0.03692086f, -0.01024337f, -0.05082684f, -0.10196782f, 0.06340310f, 0.02788143f, 0.03565168f, 0.07195954f, 
    -0.01753561f, -0.04565924f, -0.01997983f, 0.02309796f, 0.00773119f, -0.01691429f, 0.02531809f, -0.03712292f, 
    -0.02150722f, -0.03295600f, -0.03169818f, 0.00405884f, 0.06651395f, 0.06130684f, 0.05927037f, -0.05364413f, 
    0.08033740f, 0.02032194f, -0.01259051f, 0.06497886f, 0.01473645f, 0.00601465f, -0.07644255f, 0.01425897f, 
    0.03111898f, 0.00539495f, -0.01724936f, 0.05247059f, -0.01219800f, 0.06687064f, 0.02055924f, 0.02494773f, 
    0.06845603f, 0.07323846f, 0.08438796f, 0.04520174f, 0.09484687f, 0.03992409f, -0.06160922f, 0.05914810f, 
    0.06597500f, 0.10852353f, 0.04827939f, 0.00821726f, 0.04464453f, 0.00971810f, -0.01137287f, -0.03457172f, 
    -0.15869354f, -0.06401451f, -0.05681499f, -0.03256742f, 0.31982431f, -0.17294011f, -0.05044360f, 0.07235406f, 
    -0.18125938f, -0.10602356f, 0.02437134f, -0.01292748f, -0.05356848f, 0.01204614f, -0.01506268f, -0.00878713f, 
    -0.01903090f, -0.07155152f, -0.02636569f, 0.02317799f, -0.08233698f, 0.03954307f, 0.05147999f, 0.02661899f, 
    0.14744055f, -0.16069539f, -0.00097576f, -0.06396278f, 0.01550426f, 0.05455261f, -0.05837664f, 0.07047677f, 
    -0.00682508f, -0.03331029f, -0.00479606f, 0.05014091f, -0.02482159f, -0.05763105f, -0.03905838f, 0.00496753f, 
    -0.04775008f, -0.00572205f, -0.07784113f, -0.00625624f, 0.22368595f, -0.01440368f, -0.14080514f, -0.18829346f, 
    -0.01796261f, 0.04483386f, 0.00362750f, 0.03798564f, -0.06934907f, -0.02337618f, -0.03400626f, 0.02199572f, 
    0.02468180f, -0.04011642f, 0.02369734f, 0.00241254f, -0.04997372f, -0.07668667f, 0.01594682f, -0.04194148f, 
    0.05094451f, 0.08181759f, -0.18392874f, 0.05998768f, -0.05912418f, 0.00483941f, 0.06312976f, 0.04466685f, 
    0.00986660f, -0.03544728f, -0.01231135f, -0.03170606f, -0.01106454f, 0.03810200f, -0.02766727f, -0.01353764f, 
    0.06328018f, -0.07600306f, 0.00465558f, 0.03941564f, -0.21499276f, 0.07807643f, 0.03112219f, -0.10417157f, 
    0.03774153f, -0.00109367f, 0.00194209f, 0.01193547f, -0.03174970f, -0.00591541f, -0.03052147f, 0.02530250f, 
    0.00016287f, -0.06180765f, -0.02964009f, 0.03715212f, 0.01553760f, -0.04415057f, 0.01883892f, 0.00141133f, 
    0.11940347f, -0.05634272f, -0.06347548f, -0.04371679f, -0.09140135f, 0.02902055f, 0.05957780f, 0.06318273f, 
    -0.04254615f, -0.00161649f, -0.06884114f, 0.00767657f, -0.07591778f, 0.01595690f, -0.09240235f, 0.00080300f, 
    0.02503135f, -0.00917732f, 0.01372496f, 0.03210143f, -0.24015659f, 0.09343304f, -0.05495618f, -0.04343757f, 
    0.10071500f, 0.06147401f, 0.03143620f, 0.02755794f, 0.04383289f, -0.00387517f, -0.10784354f, 0.03935091f, 
    0.04810625f, -0.00893336f, -0.03278963f, -0.11183985f, 0.00064274f, -0.00912093f, -0.05266233f, 0.02048029f, 
    0.23792106f, -0.10167409f, 0.17726716f, -0.01353799f, 0.18762232f, -0.06989639f, -0.07981218f, -0.02588033f, 
    0.04851937f, 0.04748934f, 0.09360778f, -0.02179305f, -0.02773386f, 0.04094149f, 0.01586558f, -0.08746692f, 
    -0.00296847f, 0.02379663f, -0.02814446f, -0.02917559f, -0.02829723f, 0.09985106f, -0.11818502f, -0.08574671f, 
    0.05384140f, 0.01009578f, 0.01945784f, 0.00989711f, -0.03996055f, -0.03281138f, -0.07338645f, 0.01578147f, 
    -0.08247656f, -0.09227148f, 0.00210789f, -0.02928970f, -0.00371123f, -0.00017620f, -0.05705585f, 0.01123190f, 
    -0.06256866f, 0.07076059f, -0.02164429f, -0.06853090f, 0.09859531f, 0.03816935f, 0.01125098f, 0.04065529f, 
    0.00973021f, -0.06223843f, -0.04576434f, 0.00149262f, -0.00243225f, -0.03459729f, -0.01846257f, -0.02753903f, 
    -0.03018622f, -0.04625727f, 0.00436357f, -0.00206927f, 0.17693472f, 0.13384049f, -0.03799870f, 0.05665671f, 
    -0.01560768f, -0.06529485f, 0.05824920f, 0.03567524f, 0.01624440f, -0.02911494f, -0.06777707f, 0.05327760f, 
    -0.03388277f, 0.00453676f, -0.01270450f, -0.01736353f, 0.02431852f, -0.02683207f, 0.00197978f, -0.02941813f, 
    0.19276689f, -0.07200006f, 0.03016050f, 0.10606573f, 0.09751729f, -0.12913086f, 0.01029569f, -0.01231490f, 
    0.01051494f, 0.04219530f, 0.05075269f, -0.05644786f, -0.00749889f, -0.05885552f, -0.03446086f, 0.06643227f, 
    -0.03905628f, -0.00655423f, 0.06594811f, 0.03179393f, 0.35195160f, -0.30648953f, -0.05800098f, -0.04679270f, 
    -0.03109520f, -0.01729400f, 0.00483765f, -0.05501680f, 0.01386975f, -0.04166312f, -0.00858500f, 0.01894358f, 
    -0.00063979f, -0.01210939f, 0.02026876f, 0.01844761f, -0.01484310f, -0.04812077f, 0.07782432f, -0.07702907f, 
    0.26699805f, -0.03316210f, 0.17475607f, -0.09195951f, 0.04538729f, 0.09241308f, -0.07917213f, -0.03071766f, 
    -0.02121679f, 0.06616738f, 0.02172699f, 0.00924644f, -0.04129293f, 0.01147645f, 0.02085390f, 0.01338870f, 
    -0.15112278f, 0.02673604f, -0.02282512f, -0.03109471f, 0.16379339f, 0.10690542f, -0.15934274f, 0.10071406f, 
    -0.12575962f, 0.01847277f, 0.11589004f, -0.04181992f, -0.09459186f, -0.03780195f, -0.06831870f, -0.05373767f, 
    -0.00802808f, -0.06340946f, -0.05383204f, 0.02001276f, 0.04740162f, 0.00022218f, -0.02961136f, -0.06001282f, 
    -0.24121010f, -0.46182293f, -0.04433719f, -0.03191371f, -0.09661393f, -0.07579186f, -0.03883502f, 0.04077151f, 
    -0.01376779f, -0.07979885f, 0.01693037f, 0.01378229f, 0.04119955f, 0.00740595f, -0.02882702f, 0.00960234f, 
    0.00291019f, -0.03782102f, 0.02787914f, -0.00536143f, 0.18038873f, 0.02808766f, 0.05761106f, -0.00168027f, 
    -0.01400653f, 0.00436269f, 0.03280616f, -0.03166100f, -0.07968239f, 0.01660347f, -0.08411165f, 0.02578663f, 
    -0.05739392f, 0.00078972f, -0.02975943f, 0.01062202f, 0.04586272f, 0.06361658f, -0.02990600f, 0.01008476f, 
    0.02226060f, 0.14891909f, 0.06439182f, 0.09810083f, -0.03403409f, -0.11044417f, 0.07944891f, -0.03204359f, 
    0.07008981f, 0.01828878f, -0.02247166f, 0.01184296f, -0.03314083f, -0.00479709f, 0.00386363f, -0.08333890f, 
    0.01214192f, 0.00124402f, 0.02883232f, -0.02066415f, 0.06410554f, 0.02579968f, 0.12030804f, 0.13086861f, 
    -0.00636805f, -0.03944097f, 0.02103903f, -0.00509091f, -0.03559603f, -0.03267808f, -0.04907199f, 0.00776328f, 
    -0.05994399f, -0.02196318f, -0.02596688f, 0.00030612f, 0.01922771f, 0.00836867f, 0.01580556f, 0.03394612f, 
    0.04317608f, -0.01510518f, -0.01902174f, -0.05384050f, -0.14207479f, -0.02858673f, -0.08711964f, -0.06907265f, 
    -0.09121477f, -0.01072069f, -0.08684563f, -0.01239189f, 0.00271864f, 0.05626096f, 0.06871382f, 0.01359501f, 
    0.03007807f, 0.02782532f, 0.02409426f, -0.00296795f, 0.05597273f, -0.12735865f, 0.01454332f, -0.05512108f, 
    0.11160061f, -0.04591405f, -0.00692851f, 0.00317414f, -0.03710408f, 0.07547831f, -0.00068872f, -0.01265106f, 
    -0.02373461f, 0.01156677f, -0.01215725f, 0.01353144f, -0.00453615f, -0.00731098f, 0.00136611f, -0.02122178f, 
    0.00950805f, 0.02090785f, -0.27134579f, -0.07643246f, -0.12164137f, -0.05448347f, 0.07391938f, -0.06925625f, 
    -0.04459834f, -0.03543828f, 0.02037561f, 0.05125252f, -0.00549701f, -0.02309444f, 0.00763315f, -0.02183771f, 
    0.03979943f, -0.06315409f, 0.01133448f, 0.00075309f, -0.03718606f, 0.21384506f, 0.02390029f, 0.03999287f, 
    -0.04757508f, 0.00755645f, 0.06930482f, 0.02169646f, -0.00458048f, -0.04086896f, 0.01909330f, 0.00938911f, 
    -0.00937018f, -0.03279129f, -0.05188900f, 0.03388540f, 0.02908802f, -0.06881340f, -0.03429931f, -0.06126062f, 
    0.14008032f, -0.16812436f, -0.04865453f, -0.03619401f, -0.21077356f, -0.03288863f, -0.15024991f, -0.00733279f, 
    -0.05094120f, 0.00983517f, -0.07025184f, 0.03154588f, 0.08026269f, -0.07467515f, 0.05224625f, 0.01728937f, 
    -0.01308851f, 0.04162474f, 0.02562081f, 0.05936238f, 0.15028463f, 0.03884766f, -0.00566600f, 0.13804524f, 
    0.05982236f, -0.07924095f, 0.03796003f, -0.00613619f, 0.01931243f, 0.06558010f, 0.06195327f, -0.00794589f, 
    -0.04073482f, 0.00795375f, -0.03521712f, -0.01019007f, 0.00351268f, 0.06741620f, 0.03693467f, 0.05028009f, 
    0.19091523f, -0.38973570f, -0.13440566f, 0.03849140f, 0.02501040f, -0.14453040f, -0.01881386f, 0.05101680f, 
    0.07765921f, 0.02395193f, 0.03936322f, 0.02019454f, -0.01849925f, -0.04343669f, 0.05331104f, -0.06677012f, 
    0.01332814f, -0.07178112f, 0.00412760f, -0.01598891f, -0.18812639f, -0.01961689f, 0.11651437f, -0.07395213f, 
    -0.01628733f, -0.05560148f, -0.06964497f, -0.01545197f, 0.01569496f, 0.02529617f, -0.00162393f, -0.05360610f, 
    0.00594036f, 0.05835199f, -0.03342440f, -0.01327982f, -0.02057798f, -0.03715571f, 0.02383772f, 0.02905450f, 
    -0.41096762f, 0.28946900f, -0.05855952f, 0.05987048f, 0.13259263f, 0.03301518f, 0.08293685f, 0.04337513f, 
    0.06743503f, -0.01844947f, -0.06613012f, -0.01029796f, -0.01314395f, 0.00045850f, -0.02665186f, -0.05386963f, 
    -0.00928720f, -0.07571332f, 0.06267227f, -0.01083745f, -0.13177295f, 0.17785448f, -0.04740090f, -0.06060955f, 
    -0.03878120f, -0.09101069f, -0.03088094f, -0.00052097f, 0.00883836f, -0.01384752f, -0.06394639f, -0.05328265f, 
    0.00522999f, 0.01452872f, 0.03023830f, -0.01970946f, -0.00762713f, -0.03475485f, 0.07914695f, -0.00817353f, 
    -0.04848769f, -0.05884761f, -0.12538858f, 0.15258262f, 0.01006273f, 0.01771144f, 0.03422545f, -0.01448864f, 
    -0.02041914f, 0.00568181f, 0.05643494f, -0.01033569f, -0.04172461f, 0.03513611f, -0.02710171f, 0.02446218f, 
    0.04463273f, 0.03062781f, 0.01545247f, -0.04765698f, 0.05472603f, 0.04134043f, -0.09246299f, 0.03200485f, 
    -0.02518858f, -0.00877064f, 0.03883889f, -0.05164465f, -0.00972036f, 0.02208108f, 0.04024146f, -0.01875507f, 
    -0.01944898f, 0.07090338f, 0.02084501f, 0.00262173f, 0.05048286f, 0.01105102f, -0.06032028f, -0.02364907f, 
    0.08272421f, -0.09000471f, -0.17370005f, 0.01990396f, 0.16390590f, -0.05517275f, 0.04515082f, -0.01041864f, 
    0.05708266f, 0.07338087f, 0.01179179f, 0.02096730f, -0.03906103f, -0.11039350f, -0.01841799f, -0.03150445f, 
    -0.00576044f, -0.05036588f, 0.07408944f, -0.02326922f, -0.16599564f, 0.00493478f, -0.16792005f, 0.09982603f, 
    -0.04880429f, -0.05407085f, 0.07061712f, -0.04335895f, 0.06351552f, -0.05466083f, -0.05537519f, 0.03168030f, 
    -0.01169254f, -0.00958204f, -0.00561902f, -0.04139512f, -0.02045291f, -0.01844013f, -0.02558790f, 0.01690157f, 
    -0.00744158f, 0.03324746f, -0.01497849f, -0.02222187f, -0.00678560f, -0.05785088f, -0.06666517f, -0.06189084f, 
    0.04919538f, -0.02221780f, -0.05722720f, -0.01453669f, 0.03038932f, 0.02546341f, 0.01450257f, -0.03755433f, 
    -0.03306106f, 0.05448139f, 0.02541225f, -0.01781461f, 0.24764843f, -0.11265225f, 0.14481917f, 0.13257529f, 
    0.05265239f, -0.04264113f, 0.05397853f, 0.00334148f, -0.09682602f, 0.00559446f, 0.00542723f, -0.01380267f, 
    -0.07219650f, 0.01372347f, 0.00094551f, -0.04059567f, 0.03541775f, 0.00890998f, 0.02392472f, 0.06411097f, 
    -0.07063004f, -0.09096450f, 0.02893487f, -0.00378797f, -0.03137138f, -0.03557348f, -0.17311242f, -0.06930457f, 
    0.05742885f, -0.07928442f, 0.05097408f, -0.10603094f, 0.01908460f, -0.05887833f, -0.00370197f, -0.03875108f, 
    0.01640412f, 0.01029984f, -0.03467011f, 0.00577004f, 0.02298410f, -0.04334679f, -0.00067149f, 0.02909109f, 
    -0.03297759f, -0.14175408f, -0.01095437f, 0.01966880f, 0.03184333f, 0.03398088f, -0.08575989f, 0.03564191f, 
    0.02020331f, 0.04078525f, 0.04436498f, -0.00083044f, -0.00892387f, -0.06420862f, -0.02971351f, 0.03638989f, 
    0.33354476f, 0.09438342f, -0.08800738f, 0.02359573f, 0.02323596f, 0.00320154f, 0.01297634f, -0.01740645f, 
    0.06985020f, 0.03554466f, -0.03635219f, -0.01829830f, -0.08312499f, 0.01632978f, 0.02777459f, -0.00348985f, 
    -0.01801348f, 0.02556682f, -0.01258842f, 0.05892559f, 0.00289507f, 0.14099768f, 0.09971388f, 0.14408594f, 
    0.06915671f, 0.01535391f, 0.06941532f, -0.00672297f, -0.02760432f, 0.06350420f, -0.04979816f, -0.00737660f, 
    -0.03617814f, 0.02180569f, -0.02676736f, 0.03404233f, -0.05055833f, -0.00675457f, 0.09283920f, -0.10939087f, 
    -0.05622575f, 0.15534125f, 0.10421957f, 0.11616354f, 0.09220804f, 0.02900963f, -0.02199806f, -0.07947505f, 
    0.03397704f, -0.05749537f, -0.02880061f, 0.02228203f, -0.09730961f, -0.00287563f, 0.06568755f, 0.01227552f, 
    -0.03344176f, 0.01084157f, -0.00187787f, 0.02337362f, 0.17121100f, 0.19863726f, 0.09074141f, 0.09594564f, 
    0.02452099f, 0.01823691f, 0.12348629f, 0.08720475f, -0.01046748f, 0.02873058f, -0.04476946f, -0.02014317f, 
    -0.02596448f, -0.04433611f, -0.01103104f, 0.07725475f, -0.04096885f, 0.18019132f, 0.03824632f, 0.03358636f, 
    -0.11927742f, -0.29087222f, -0.10580189f, 0.08971439f, -0.00836324f, -0.03345620f, -0.03733779f, 0.06511706f, 
    0.04076962f, -0.04653339f, 0.02992049f, 0.02254214f, -0.03870166f, -0.05983504f, 0.01911154f, -0.00980821f, 
    0.01219542f, 0.07526944f, -0.01038119f, -0.11461556f, -0.05917192f, -0.34781799f, -0.08936734f, 0.05128782f, 
    0.01771987f, -0.05418602f, 0.08395828f, -0.07768303f, -0.03243850f, -0.01995742f, -0.02909553f, 0.08920968f, 
    0.03919986f, -0.07951454f, 0.00542761f, -0.00537523f, 0.07909430f, -0.05530988f, 0.06928207f, -0.04224963f, 
    -0.29532990f, -0.32273406f, -0.21262699f, -0.06352210f, -0.08545940f, -0.12260380f, -0.04658332f, 0.00607566f, 
    0.04733421f, -0.07273028f, -0.04216186f, -0.03593372f, 0.01188963f, 0.01738822f, 0.02201682f, 0.07745188f, 
    -0.06716205f, -0.00116547f, -0.05223228f, 0.07133101f, 0.11197215f, 0.09779435f, 0.04019194f, 0.14508663f, 
    0.04577488f, -0.00735979f, 0.08734559f, -0.02223047f, 0.02767311f, -0.00380700f, -0.00025736f, 0.01779635f, 
    -0.02688557f, -0.06780607f, 0.00667662f, 0.03641403f, -0.02101968f, 0.13826266f, 0.03884745f, 0.04621850f, 
    -0.11151826f, 0.18108575f, 0.02008865f, 0.04809568f, 0.02786172f, 0.02714246f, 0.06680700f, -0.00510698f, 
    0.02706927f, 0.02249035f, 0.07360566f, -0.03915040f, -0.07838202f, 0.02366559f, -0.09844538f, 0.01997038f, 
    -0.00263730f, 0.02094558f, 0.07645560f, 0.05631887f, -0.19590512f, 0.13106279f, 0.01637981f, -0.15350607f, 
    -0.15767099f, -0.04908032f, -0.05304231f, -0.06816882f, 0.04040927f, -0.04946475f, 0.06039309f, -0.04691010f, 
    -0.03705904f, 0.00623440f, -0.04879225f, -0.03195724f, 0.02471089f, -0.07350929f, 0.01130321f, 0.02624199f, 
    0.05265943f, 0.22938944f, -0.12858820f, 0.18222983f, -0.23119539f, -0.00437063f, 0.05624596f, -0.07553247f, 
    0.00912807f, -0.05205572f, -0.03574239f, 0.01663980f, 0.06732896f, 0.00436959f, 0.04008600f, 0.11280446f, 
    -0.03948353f, 0.02366362f, -0.01322888f, 0.04327498f, -0.01332633f, 0.20356971f, 0.09998451f, 0.11674085f, 
    -0.01838665f, -0.00524472f, -0.04632835f, 0.04021592f, -0.06839377f, -0.02150515f, 0.02403629f, -0.05285798f, 
    0.04818908f, 0.02573654f, 0.04038232f, -0.02014409f, 0.05675979f, 0.04057699f, 0.09426954f, 0.01032905f, 
    -0.08067098f, -0.39268628f, -0.32903355f, 0.11301345f, 0.04934956f, 0.00035648f, 0.01733704f, 0.05748017f, 
    -0.05574738f, -0.06934476f, 0.05119889f, 0.01161076f, -0.02568651f, 0.03364106f, -0.02968025f, 0.01683991f, 
    0.04208646f, 0.06113781f, -0.06342186f, -0.01039191f, -0.08457568f, -0.16062593f, -0.08053748f, -0.02064127f, 
    -0.16867425f, -0.11445237f, -0.06702055f, -0.05560425f, 0.04744456f, -0.00889114f, -0.03309687f, -0.02583170f, 
    -0.00270898f, -0.01991620f, 0.00191376f, -0.00286648f, -0.03299261f, -0.02962310f, 0.02873569f, 0.07509613f, 
    -0.08118633f, -0.15222047f, -0.17932326f, 0.17974564f, -0.06039584f, -0.02980497f, -0.03908871f, 0.00547002f, 
    0.06432754f, -0.07836337f, -0.04774909f, -0.02978431f, -0.03223852f, -0.01189213f, -0.01743454f, -0.03786578f, 
    0.01324570f, 0.08541857f, -0.07037623f, -0.12024944f, -0.55864841f, 0.22958249f, 0.00922827f, 0.01491879f, 
    0.06871556f, 0.00767368f, 0.01640733f, 0.00078843f, 0.07467289f, -0.08801438f, -0.01168079f, -0.04374273f, 
    0.03442257f, -0.00247828f, 0.05222354f, -0.12500367f, 0.01212635f, -0.16683911f, 0.05744004f, 0.02417853f, 
    -0.44523704f, 0.18668847f, -0.22400187f, 0.09535675f, 0.16106726f, -0.03101842f, 0.04102093f, 0.05539571f, 
    0.01149183f, -0.08980107f, 0.00648236f, -0.02004162f, -0.00821328f, 0.02843479f, 0.04488133f, -0.01233077f, 
    -0.08907052f, -0.07904708f, 0.02895607f, 0.03525201f, 0.03060841f, -0.04828677f, -0.01049312f, 0.01460863f, 
    -0.07602758f, -0.04410190f, -0.09965494f, 0.04970893f, -0.03549022f, 0.00924406f, -0.05604351f, 0.01808103f, 
    0.00783751f, 0.03778116f, 0.03382270f, 0.01381453f, 0.02429460f, 0.00300139f, 0.01800279f, 0.02571238f, 
    -0.05803884f, 0.17015591f, 0.00907790f, -0.00721549f, -0.06779756f, -0.13487311f, -0.13550337f, 0.13013329f, 
    -0.03131546f, -0.00375572f, -0.08205594f, 0.02241848f, -0.02254770f, 0.10742971f, -0.01849678f, 0.08953397f, 
    0.02918683f, 0.08942171f, 0.17081843f, -0.03510394f, 0.08487955f, 0.14556880f, 0.08350863f, 0.06404630f, 
    0.01284499f, 0.03573028f, 0.01853270f, -0.07157215f, 0.04974986f, 0.03828077f, 0.03983558f, 0.00351713f, 
    0.02516676f, -0.01493550f, -0.03373379f, -0.00196116f, 0.02642322f, 0.01500021f, 0.01403615f, -0.00424064f, 
    0.21912727f, -0.17576192f, -0.04815385f, -0.15920012f, -0.21289217f, -0.03477940f, -0.00659341f, -0.03319095f, 
    -0.04602717f, -0.01271013f, -0.02077651f, -0.03635695f, 0.00001905f, -0.01545868f, 0.01720671f, -0.00816155f, 
    0.02895722f, -0.03766508f, 0.01342796f, 0.00726703f, 0.00869040f, 0.09251690f, 0.15130280f, 0.02623526f, 
    0.00299858f, 0.00633006f, -0.00463831f, 0.02511208f, -0.04744091f, 0.02543508f, 0.01997933f, -0.02147857f, 
    -0.06493393f, 0.03331540f, -0.10428273f, -0.04716751f, -0.03348853f, -0.01120827f, 0.04761922f, -0.01601355f, 
    0.30873951f, 0.08341866f, -0.04285346f, 0.06990123f, 0.06242792f, -0.05817813f, 0.00821561f, -0.09271714f, 
    0.01614776f, 0.07469831f, -0.10974447f, -0.02234275f, -0.03722837f, 0.03478618f, 0.05598150f, 0.03877347f, 
    -0.00310159f, 0.11472616f, 0.01190748f, 0.02554055f, -0.25513735f, -0.41013575f, -0.03969877f, -0.00480192f, 
    0.00663765f, -0.11567161f, 0.00887376f, 0.02473740f, 0.03219878f, 0.00409770f, -0.08821905f, 0.04627033f, 
    -0.04131678f, 0.06144563f, 0.02652422f, 0.01710356f, 0.00401768f, -0.07610859f, 0.02243196f, 0.04955975f, 
    -0.29769212f, -0.17588681f, -0.17832473f, -0.00338356f, -0.03040494f, -0.07964144f, -0.04326048f, 0.00023714f, 
    -0.01226640f, -0.07762151f, -0.02583185f, -0.01118069f, 0.00662635f, 0.03529831f, 0.03287849f, 0.00335214f, 
    -0.05929350f, -0.00000303f, 0.00174048f, 0.05309309f, -0.22766086f, -0.27800757f, -0.25072300f, -0.01421553f, 
    0.18065770f, -0.06495414f, 0.02579403f, -0.00360410f, 0.03321187f, 0.05688461f, -0.00749129f, 0.02106033f, 
    0.01959820f, -0.08980811f, 0.02704880f, -0.08323223f, 0.00742232f, -0.05148620f, 0.01582274f, -0.00721787f, 
    -0.35327265f, 0.05396065f, -0.01207725f, -0.11283411f, -0.21423446f, -0.02064464f, -0.08518915f, 0.09226655f, 
    0.01155781f, -0.05423519f, 0.00583528f, -0.01529809f, -0.07327171f, 0.07507645f, -0.03514359f, 0.10595275f, 
    0.00257368f, 0.01806912f, 0.09589731f, 0.01856544f, 0.02588043f, 0.00722388f, 0.00206194f, -0.04157316f, 
    -0.02587323f, -0.09805624f, -0.03920969f, -0.03842050f, -0.05260723f, -0.05864801f, -0.09887390f, -0.02289296f, 
    0.03364751f, -0.02814231f, 0.04154832f, -0.01477290f, 0.05800472f, 0.04523845f, 0.02607210f, 0.01163720f, 
    0.13790944f, 0.04931633f, -0.19375867f, 0.10229155f, -0.02156872f, -0.02390319f, -0.00817140f, -0.05374171f, 
    0.02367542f, -0.00911651f, -0.05727753f, -0.00533345f, 0.00304740f, -0.00116842f, 0.00280655f, -0.04372947f, 
    0.03294797f, 0.02272363f, -0.05437117f, -0.02311488f, 0.23937066f, 0.24050556f, 0.06674109f, 0.03713106f, 
    -0.05933259f, -0.05084318f, 0.04292640f, -0.06639502f, 0.13139038f, 0.00900630f, -0.02185998f, -0.01066874f, 
    -0.00234552f, 0.01335486f, -0.07490321f, -0.07581981f, -0.01058457f, -0.12779330f, 0.10672654f, 0.07128063f, 
    -0.22725312f, -0.04065664f, 0.02178246f, 0.00475062f, 0.08818650f, -0.08618226f, 0.00311198f, -0.00516078f, 
    0.04286440f, -0.06275722f, -0.03783045f, 0.04487924f, -0.05829880f, 0.05156622f, -0.00803806f, 0.01784279f, 
    -0.02054365f, -0.05825322f, 0.02852567f, -0.01566727f, 0.04286224f, -0.05221975f, -0.03137043f, 0.09300012f, 
    0.18037973f, 0.07546932f, 0.13155235f, 0.01242784f, -0.01633582f, 0.07652522f, -0.02778060f, 0.00969701f, 
    -0.05551580f, -0.11307304f, -0.03237646f, -0.01854966f, 0.02214362f, 0.06648858f, -0.02352841f, -0.07920667f, 
    0.32553631f, -0.02180251f, -0.10396473f, 0.06906653f, 0.06140067f, 0.07492547f, 0.00592424f, -0.00625568f, 
    0.00751228f, 0.00550074f, -0.05459974f, 0.02734189f, -0.00222743f, 0.01592962f, -0.04780593f, -0.01063926f, 
    0.03621320f, -0.03723440f, 0.02308594f, 0.01607658f, 0.09496870f, -0.42603886f, -0.15343162f, 0.11539964f, 
    0.09418603f, -0.01174738f, -0.00530975f, 0.07030096f, -0.03578337f, -0.08956975f, -0.02190066f, -0.00912976f, 
    0.02928453f, 0.03759389f, 0.02841642f, -0.01119704f, 0.08226222f, 0.00226024f, -0.02158357f, -0.02134550f, 
    -0.03676506f, 0.04449414f, -0.04350484f, 0.02910193f, -0.01900111f, -0.05576631f, -0.14237718f, 0.04372831f, 
    0.00161817f, -0.00343545f, -0.02760242f, 0.01624308f, 0.03455222f, 0.02287092f, 0.01134982f, 0.04065503f, 
    0.01672611f, -0.02907639f, 0.04569590f, -0.00964532f, -0.32115817f, 0.03077862f, -0.18360364f, 0.07177250f, 
    0.18024072f, -0.00461376f, 0.00198242f, 0.02346855f, -0.00975751f, 0.01569873f, -0.07501421f, 0.00336232f, 
    0.06216005f, -0.03998990f, -0.02952508f, 0.04606375f, 0.03378388f, -0.00538051f, 0.01743536f, 0.04242150f, 
    -0.34152213f, -0.13051350f, -0.19256723f, 0.00014133f, 0.07648024f, -0.07312742f, 0.05492048f, 0.01959678f, 
    0.01131339f, -0.03175508f, -0.03912289f, 0.00679616f, 0.02861725f, -0.01830557f, 0.04962201f, -0.02100066f, 
    -0.06787244f, -0.04224281f, 0.02190515f, -0.01179915f, 0.03421218f, -0.16440003f, 0.08751487f, 0.00780627f, 
    -0.06978805f, -0.02058921f, -0.01160176f, -0.00259604f, 0.04542198f, -0.10508810f, 0.05001681f, 0.01866560f, 
    -0.01216239f, -0.00816192f, -0.02784369f, 0.00543225f, -0.01504841f, -0.11404399f, 0.02947602f, -0.01296426f, 
    0.09670554f, -0.04651954f, 0.04745858f, -0.03035791f, -0.03178216f, -0.06093587f, -0.10967618f, -0.03351814f, 
    -0.05393127f, -0.05467958f, -0.06901162f, 0.01935326f, 0.04115785f, 0.00853901f, 0.00682242f, -0.00586196f, 
    0.03113340f, 0.02560796f, 0.01931860f, 0.01257024f, 0.20843773f, 0.08232164f, 0.02936262f, 0.06651700f, 
    0.01577503f, 0.05382487f, -0.07636052f, -0.12933959f, 0.10893241f, -0.04395316f, 0.06798619f, 0.04860544f, 
    0.04696475f, -0.01600562f, 0.02631214f, -0.10343225f, 0.00538781f, -0.01279776f, 0.02546508f, -0.04876618f, 
    0.16846085f, 0.17573801f, -0.05883800f, 0.06832969f, -0.04098946f, 0.07435484f, -0.05536884f, -0.04326678f, 
    0.06187657f, -0.02586819f, 0.00423891f, -0.08063105f, -0.04843977f, 0.13846208f, 0.02463615f, -0.07089082f, 
    0.04365632f, -0.06417063f, -0.00953551f, 0.02616792f, -0.32072496f, 0.02167569f, 0.03264251f, 0.18125010f, 
    0.10119545f, 0.05362693f, 0.08573230f, 0.03678057f, -0.00290849f, 0.00001193f, -0.03785061f, -0.00736630f, 
    -0.05292588f, -0.08207414f, -0.06119150f, 0.06109954f, 0.01960842f, -0.01245429f, -0.02604515f, -0.09094748f, 
    0.11418779f, 0.18112050f, -0.16808946f, -0.05599197f, 0.10956750f, 0.01452458f, -0.03348112f, 0.02973766f, 
    0.07055275f, 0.03576295f, -0.04182412f, -0.02583519f, 0.02707141f, 0.04584460f, -0.00420627f, 0.05718118f, 
    -0.00046696f, -0.05777390f, -0.00335974f, -0.00177959f, -0.10832060f, -0.13618550f, -0.02352974f, -0.02335642f, 
    0.12437540f, -0.05217272f, 0.01301476f, -0.06489532f, 0.02598832f, 0.02543522f, -0.02713045f, 0.05566587f, 
    0.00420367f, -0.02245330f, -0.07878530f, -0.00140368f, -0.06701964f, -0.10916796f, 0.01710936f, -0.01831621f, 
    -0.08270009f, 0.27232894f, 0.01438727f, -0.01346744f, -0.26748458f, 0.02077245f, -0.09912169f, -0.01447878f, 
    -0.02895395f, -0.05248900f, 0.05255966f, -0.04174786f, -0.02193418f, 0.02625695f, -0.04664216f, -0.02539353f, 
    -0.04573840f, 0.11807847f, -0.06192558f, 0.08392996f, -0.01224508f, 0.02835138f, -0.15536936f, 0.12088381f, 
    0.00237122f, 0.02133496f, -0.03708465f, 0.04725261f, 0.03541971f, 0.06537636f, 0.02684986f, 0.09509403f, 
    0.00941493f, -0.02586784f, 0.00269604f, 0.03389973f, 0.03490573f, 0.00964716f, 0.03621151f, 0.01560710f, 
    -0.31527525f, 0.15882027f, -0.00932247f, 0.05625582f, 0.12076855f, 0.10059924f, -0.03395890f, -0.06991123f, 
    0.12220133f, 0.08895209f, -0.06816362f, 0.03530232f, 0.01118261f, 0.00859150f, 0.01636207f, 0.02406173f, 
    -0.05420666f, -0.00963052f, 0.03156421f, -0.13575822f, 0.12833452f, -0.00762650f, -0.05055875f, -0.05591473f, 
    -0.11134849f, -0.05919551f, -0.01510666f, -0.04609936f, 0.00062039f, -0.03063565f, -0.00887430f, -0.02478862f, 
    0.02120351f, -0.03130452f, -0.02955468f, -0.01039914f, 0.06505837f, 0.04803938f, -0.01247662f, -0.00098646f, 
    -0.34960133f, 0.19266470f, -0.03943611f, -0.14269854f, -0.05441031f, 0.07661704f, -0.11872131f, -0.01206316f, 
    -0.04463334f, -0.11813043f, 0.02015218f, -0.05255293f, -0.07411744f, 0.03236245f, -0.02426853f, 0.01873506f, 
    -0.01531030f, -0.01818606f, -0.07233014f, -0.02812514f, 0.00765891f, -0.05019736f, 0.10523667f, 0.08813099f, 
    0.04653592f, 0.03516412f, 0.02222333f, -0.04276892f, -0.03318132f, -0.08172598f, 0.02226715f, 0.02485387f, 
    -0.13823861f, -0.00778071f, 0.04125381f, -0.06861893f, -0.01575370f, -0.11542896f, -0.11526582f, 0.01164807f, 
    -0.71193099f, -0.01852807f, 0.01335334f, 0.16963218f, 0.18820126f, 0.11464498f, -0.03963408f, -0.00518315f, 
    0.04064824f, 0.13228965f, -0.04076734f, -0.00142560f, 0.05218247f, 0.06151016f, 0.03412502f, 0.05927128f, 
    0.05182170f, 0.08373612f, 0.12369875f, -0.09903663f, 0.05816589f, -0.19565603f, -0.03017587f, 0.09431713f, 
    -0.11420340f, -0.04450286f, 0.02518700f, 0.12735899f, -0.08144293f, -0.02638060f, -0.00146821f, 0.08006307f, 
    0.04463082f, -0.01594863f, 0.00334436f, 0.00272999f, -0.04437959f, 0.00610448f, 0.04237482f, 0.01832716f, 
    0.19586611f, -0.29842949f, -0.10039982f, -0.05826714f, -0.11786317f, -0.04022411f, -0.08225014f, -0.00556980f, 
    -0.12169950f, -0.02691153f, -0.03575803f, 0.04573224f, -0.05445624f, -0.03800407f, -0.03824123f, -0.01794744f, 
    -0.00307383f, -0.00036973f, 0.00082150f, -0.10153563f, 0.36604124f, -0.00081535f, -0.03828352f, -0.11751886f, 
    0.13512796f, -0.07267825f, 0.04109213f, 0.08327285f, 0.07880666f, -0.06273706f, 0.00262101f, -0.06750549f, 
    0.03067836f, 0.06892368f, 0.02245687f, -0.06656324f, -0.02092055f, -0.01537301f, -0.03257132f, 0.03158466f, 
    -0.34167844f, -0.03787550f, 0.15493566f, 0.22420175f, 0.03733585f, -0.06335536f, -0.12445164f, 0.07359912f, 
    -0.04322688f, -0.04156477f, 0.01513917f, -0.00360204f, -0.04431351f, -0.06574608f, 0.01037869f, 0.03028104f, 
    -0.00527751f, -0.07101163f, -0.02489243f, -0.07785783f, -0.03392405f, -0.02377346f, 0.00249370f, -0.05205840f, 
    0.06193818f, 0.03923129f, 0.00023859f, -0.01179491f, 0.06956346f, 0.05028966f, 0.03481474f, -0.00071918f, 
    -0.05139940f, -0.00879566f, 0.00916579f, 0.02086036f, -0.00752197f, 0.03191018f, 0.05450434f, -0.04314663f, 
    -0.00983127f, 0.12062437f, 0.02079104f, -0.07342357f, -0.04112260f, 0.09584650f, 0.00341104f, 0.04563002f, 
    0.02999525f, -0.11576909f, 0.00581942f, -0.05619717f, -0.06697448f, 0.05709703f, -0.09861893f, -0.03966723f, 
    -0.04122854f, 0.05623640f, -0.06334762f, -0.01689755f, 0.04842345f, -0.01729709f, -0.06358474f, -0.00726259f, 
    -0.04737700f, 0.00342700f, -0.02318137f, -0.07197696f, -0.04441528f, 0.03066981f, -0.00990024f, 0.02858475f, 
    0.06132955f, 0.02544077f, -0.02088526f, -0.07648312f, -0.10784546f, -0.03833990f, -0.07983648f, -0.05108642f, 
    -0.10597640f, -0.20819132f, 0.02324886f, 0.13295797f, -0.06637521f, -0.12294050f, -0.09105815f, 0.00588376f, 
    -0.10670763f, -0.02990901f, -0.00906220f, 0.06404224f, -0.02253384f, -0.04969376f, -0.00784926f, -0.02912733f, 
    -0.01390454f, 0.08285888f, 0.04907772f, 0.07806517f, -0.33791256f, 0.18663244f, 0.05700951f, -0.20060207f, 
    -0.15231347f, 0.00052960f, -0.00471260f, -0.00510368f, 0.00002399f, -0.00795276f, -0.02227729f, -0.02504049f, 
    0.04674352f, -0.02395168f, -0.00676081f, 0.00483718f, 0.02232354f, -0.01791322f, -0.01927981f, 0.02021140f, 
    -0.00257790f, 0.08734108f, 0.08326231f, -0.03407319f, 0.05645419f, 0.01284022f, 0.06365461f, -0.04695135f, 
    0.13242973f, 0.02466806f, 0.05519135f, -0.01727111f, -0.04053660f, -0.00949309f, 0.03154302f, 0.01889400f, 
    0.04584773f, -0.02757645f, 0.08873051f, 0.02478066f, 0.29668492f, -0.02623335f, -0.12845393f, 0.07325716f, 
    -0.26066518f, -0.06806067f, -0.11296690f, -0.03250923f, -0.20041461f, -0.04717696f, -0.00189923f, 0.09345398f, 
    0.04172235f, -0.00409135f, 0.03053845f, -0.05398953f, 0.04044290f, 0.06299641f, 0.01175564f, -0.01842090f, 
    -0.02612985f, 0.15352884f, -0.24903539f, -0.08861710f, 0.11689726f, -0.06547598f, 0.00632086f, 0.05439591f, 
    0.02424334f, -0.03055633f, 0.06295472f, -0.02716854f, -0.05817801f, 0.04589782f, 0.04923695f, -0.02302258f, 
    0.02105180f, 0.02227235f, 0.03139755f, 0.06650743f, 0.06516907f, 0.08681302f, -0.14409718f, 0.10119454f, 
    -0.35818136f, 0.00363945f, 0.01627315f, -0.02755534f, -0.05879477f, 0.05262734f, 0.00810221f, 0.02953786f, 
    0.02760481f, 0.03692780f, 0.03584028f, 0.03517726f, 0.04123251f, 0.02683356f, -0.12144279f, -0.01070663f, 
    -0.06909087f, -0.04825068f, -0.10513091f, -0.01245833f, -0.23912865f, 0.05646212f, -0.04140936f, 0.08660731f, 
    0.08300406f, -0.05857314f, -0.00408297f, -0.03772882f, -0.00869617f, -0.06172235f, 0.06654365f, -0.09113676f, 
    0.08857965f, 0.00291887f, 0.00495371f, 0.05914133f, -0.03404377f, -0.29536524f, 0.02487885f, 0.02856159f, 
    0.03320676f, 0.04464128f, -0.03493218f, -0.00504610f, -0.06026839f, 0.01053706f, 0.04842743f, 0.07008758f, 
    0.03106632f, -0.01260992f, -0.04758189f, -0.00739256f, -0.02148895f, 0.00803235f, -0.03466029f, -0.00414580f, 
    -0.35405955f, -0.00226247f, -0.03185206f, -0.08251592f, -0.06473911f, -0.01474995f, -0.02172751f, 0.01429263f, 
    0.00493497f, 0.07735720f, -0.04628414f, -0.00139110f, 0.05971134f, 0.04456548f, 0.03799686f, -0.03480409f, 
    0.02811331f, 0.02625043f, 0.08209222f, -0.11193794f, -0.03791040f, -0.19333580f, 0.17088327f, 0.11660062f, 
    -0.08665670f, 0.03703553f, 0.08345635f, -0.09186167f, 0.00979961f, -0.08593870f, 0.07410115f, 0.03678183f, 
    -0.00149846f, 0.00301335f, 0.06571284f, -0.04358289f, 0.03603688f, -0.04650291f, -0.01555708f, 0.02791829f, 
    -0.13972966f, -0.10689797f, 0.06570872f, -0.05353003f, 0.04032739f, 0.05196204f, 0.02796070f, -0.15221646f, 
    0.00899895f, 0.05303710f, -0.02741692f, -0.02669964f, 0.01100514f, -0.00747044f, 0.02743076f, -0.03024473f, 
    -0.10525837f, -0.02205096f, -0.03305263f, -0.03811775f, 0.02811076f, -0.07900200f, 0.20909458f, -0.05030088f, 
    -0.00484427f, 0.03859685f, 0.00689637f, 0.02581441f, -0.04492309f, 0.03691390f, 0.02296293f, -0.01824846f, 
    -0.08082471f, -0.05550635f, 0.02114817f, -0.03339371f, 0.07074881f, -0.02801354f, 0.02443640f, 0.02097323f, 
    -0.00554944f, 0.05793231f, 0.09235474f, -0.08224979f, -0.02154993f, -0.01776391f, -0.03253594f, -0.02315170f, 
    0.03197094f, 0.02432550f, 0.08519325f, 0.02243480f, 0.04551165f, -0.04174132f, -0.00392256f, 0.04413299f, 
    0.02299829f, -0.02617900f, -0.02059332f, -0.05547679f, 0.09063937f, -0.03321841f, 0.01467658f, 0.08894826f, 
    -0.10625199f, -0.05525468f, 0.02020768f, 0.04099835f, 0.03882760f, -0.02455020f, -0.03507720f, 0.01524957f, 
    0.02074425f, 0.03366774f, 0.04787650f, -0.05826950f, -0.03586593f, 0.04601657f, -0.00231008f, 0.05351431f, 
    -0.05442139f, 0.13558304f, 0.11562167f, 0.09246786f, -0.02942963f, 0.13866404f, -0.00589786f, -0.02479654f, 
    -0.02441642f, -0.01017272f, 0.07653841f, 0.04904744f, -0.05079461f, -0.02204641f, -0.04222999f, 0.07761952f, 
    -0.04568183f, 0.07049493f, 0.01052404f, 0.03133447f, 0.33158869f, 0.25773367f, -0.23114292f, -0.03174624f, 
    0.05126718f, 0.06900877f, 0.00678531f, 0.05224178f, 0.06133870f, -0.00339577f, -0.03263716f, -0.00728101f, 
    -0.00302668f, 0.01709370f, -0.03928186f, -0.05527323f, 0.05367405f, -0.10644548f, -0.05454459f, -0.00427831f, 
    -0.16263804f, 0.21374245f, -0.23105226f, 0.18692158f, -0.25307339f, -0.07084075f, -0.02222895f, 0.05149986f, 
    -0.04331132f, -0.05461271f, 0.02844958f, -0.02474764f, -0.06947910f, 0.01693265f, -0.06010270f, -0.01790394f, 
    -0.01165640f, -0.02401158f, -0.01774478f, 0.03848668f, -0.11457350f, -0.05045306f, -0.02861152f, -0.02045427f, 
    0.00787693f, 0.02090112f, -0.00797186f, -0.04776227f, -0.01872473f, 0.10321558f, 0.06861937f, -0.00286544f, 
    -0.00602004f, 0.05392140f, 0.03102539f, -0.01035086f, 0.08565859f, 0.06353734f, 0.10397145f, -0.02700201f, 
    -0.01009688f, 0.00372857f, 0.10793822f, 0.02862901f, 0.00112909f, -0.03848644f, 0.07459614f, -0.00591953f, 
    0.06015558f, 0.01868162f, 0.07000467f, 0.01966107f, 0.04255773f, 0.08107986f, -0.09218738f, -0.05751640f, 
    0.04422696f, 0.03040371f, 0.01907049f, 0.02109607f, -0.17924984f, 0.01068787f, -0.10626096f, 0.11687366f, 
    0.03370837f, 0.05882907f, -0.05126153f, -0.01747124f, 0.04241505f, 0.05684356f, -0.02845643f, -0.01755327f, 
    0.02158450f, -0.01015550f, 0.03831534f, 0.03881468f, 0.06366950f, -0.00354465f, -0.01934153f, -0.01638842f, 
    -0.03116105f, 0.05816063f, 0.02141493f, -0.07226016f, -0.06083205f, 0.02200207f, -0.03793566f, -0.04116554f, 
    0.02183851f, -0.03465372f, 0.00704858f, -0.12817809f, -0.03005709f, 0.08177917f, 0.06217172f, -0.18857652f, 
    -0.01809235f, -0.02463377f, -0.08509845f, -0.02467386f, -0.55598617f, -0.03762349f, 0.02756540f, 0.07957179f, 
    0.08754795f, -0.12005395f, -0.01324388f, 0.07795590f, 0.02006586f, -0.01158660f, 0.02571168f, 0.07991560f, 
    -0.14073494f, -0.03366451f, -0.01071835f, 0.04020589f, 0.02445006f, -0.09129102f, -0.00689854f, -0.05236462f, 
    -0.14686191f, -0.13796836f, 0.14779544f, 0.07558273f, 0.01567934f, -0.04861324f, -0.07254556f, -0.01205847f, 
    -0.01500313f, 0.00528254f, 0.09169182f, -0.01418521f, 0.03483688f, -0.06248868f, -0.02193851f, -0.00871609f, 
    -0.03923352f, -0.07365979f, 0.00293937f, -0.02486794f, -0.40294039f, 0.14644080f, 0.06435290f, 0.07652873f, 
    0.10815773f, 0.04765441f, 0.04368561f, 0.00785356f, 0.10846600f, 0.06355537f, -0.07107574f, 0.00409041f, 
    0.04198778f, 0.01662041f, -0.05676785f, -0.09788860f, 0.02781216f, 0.08618572f, 0.06605102f, -0.03037605f, 
    -0.08023226f, -0.07238095f, 0.11711542f, -0.05791287f, 0.04462684f, 0.00075173f, -0.01224261f, -0.07657725f, 
    0.08808072f, 0.07405275f, -0.02601614f, -0.05530446f, 0.01376453f, 0.03693173f, -0.05298563f, -0.00265173f, 
    -0.02285491f, 0.03787608f, 0.12069980f, -0.05070517f, 0.00932562f, 0.06452775f, -0.08338655f, 0.13650307f, 
    -0.07181077f, -0.06746401f, -0.00922670f, 0.01425278f, -0.01518441f, -0.09406490f, 0.06445152f, -0.07928664f, 
    -0.00056085f, 0.01075910f, 0.01462692f, -0.01397634f, 0.01960439f, 0.06831405f, 0.05300246f, 0.04776382f, 
    -0.38425109f, 0.02547938f, -0.04347385f, -0.03513987f, 0.05985513f, 0.04295199f, -0.02153372f, 0.00134179f, 
    0.04607515f, -0.00796952f, 0.00195242f, 0.01064991f, 0.01719334f, 0.11291348f, 0.06080481f, 0.09719060f, 
    0.03439993f, -0.05308641f, -0.00864635f, -0.03001193f, 0.04316403f, -0.03613072f, 0.07772796f, -0.00508829f, 
    0.07632848f, -0.03796068f, 0.04823426f, -0.13617492f, 0.00427696f, 0.00945406f, 0.02242412f, -0.08444464f, 
    -0.06446962f, 0.04661101f, -0.02949200f, -0.04153075f, -0.01749735f, 0.03361412f, 0.03037021f, 0.04618734f, 
    0.04935873f, 0.05151126f, 0.06947038f, -0.11167109f, -0.16155371f, -0.07558630f, -0.00321501f, -0.05358285f, 
    0.17271057f, 0.00473500f, 0.12880644f, -0.11378118f, 0.01344404f, 0.00956169f, 0.14636481f, -0.00430257f, 
    -0.03216609f, -0.03595323f, 0.02036875f, 0.09503202f, 0.33161861f, -0.10326672f, 0.08302440f, 0.02137163f, 
    0.02742408f, -0.06872050f, 0.01195778f, 0.12017731f, 0.03023320f, 0.06795508f, -0.03141351f, -0.02773042f, 
    0.08178987f, -0.03044266f, -0.06107734f, 0.01708776f, -0.03090400f, 0.01649057f, -0.01638016f, -0.00897443f, 
    0.05027241f, 0.06443421f, 0.09418463f, -0.10765044f, -0.03525290f, 0.00457695f, -0.01470890f, -0.03384204f, 
    0.05721195f, 0.02018751f, 0.05115864f, -0.01358741f, 0.02886807f, -0.05787229f, 0.00696128f, 0.03383705f, 
    -0.02552915f, -0.05334517f, -0.00069116f, 0.03907846f, -0.08939250f, -0.19582936f, 0.13251230f, 0.03826423f, 
    -0.04023646f, -0.12049345f, -0.04121022f, 0.07345542f, -0.01566017f, 0.04054949f, 0.02850018f, -0.02617606f, 
    -0.05808786f, -0.10254891f, 0.01843416f, 0.06836591f, -0.00066279f, -0.00742295f, 0.02279043f, 0.05319471f, 
    -0.28044435f, -0.18764399f, -0.00691869f, 0.09426241f, 0.11533452f, 0.04131804f, -0.04465583f, 0.09713586f, 
    -0.11766253f, 0.00697596f, 0.01724940f, -0.10431746f, 0.08439531f, 0.14384429f, -0.05926439f, -0.10511645f, 
    0.08611508f, -0.08157356f, 0.06838512f, -0.04513538f, 0.11809257f, 0.07255796f, -0.17219545f, -0.00390249f, 
    0.14075050f, 0.12566304f, -0.00277594f, 0.05540975f, 0.03818831f, 0.00491890f, 0.05040379f, 0.05249517f, 
    -0.03882888f, -0.03125915f, -0.04119907f, -0.02598555f, -0.12148052f, 0.02665891f, 0.02859097f, -0.06580383f, 
    -0.18971734f, 0.04960901f, 0.05886163f, 0.01559702f, -0.09220298f, 0.03624684f, -0.05645449f, -0.03456154f, 
    0.03740379f, -0.01988546f, -0.02068889f, -0.06994727f, 0.00028636f, 0.03368378f, 0.06549234f, -0.05266181f, 
    0.02133062f, -0.01171042f, -0.05452644f, 0.00753491f, 0.00096498f, 0.24557477f, 0.08555110f, -0.08342418f, 
    -0.13728110f, 0.01663207f, 0.03878812f, 0.09041525f, -0.04519979f, -0.01463355f, -0.01674532f, 0.07192989f, 
    -0.09493316f, 0.03794347f, -0.00808787f, -0.01886806f, 0.06925230f, -0.02825942f, -0.08190800f, -0.06664413f, 
    -0.04668871f, 0.08044954f, 0.09339530f, 0.06312212f, -0.00853609f, -0.00079851f, 0.00005455f, 0.04905681f, 
    -0.03614071f, -0.00548258f, -0.01946986f, -0.03979999f, 0.00817080f, -0.01806368f, 0.02448193f, 0.04259824f, 
    -0.01891835f, -0.04141302f, -0.03830432f, -0.11982690f, -0.11701135f, -0.22167347f, 0.13034263f, 0.23699223f, 
    -0.04065686f, -0.05949422f, -0.03400420f, 0.04125533f, -0.06838451f, 0.00137313f, 0.07120165f, 0.01306608f, 
    0.01553103f, -0.07132129f, 0.14024596f, 0.03240099f, -0.06788525f, 0.09553201f, 0.05690493f, 0.09096553f, 
    0.17781700f, 0.10016779f, 0.04422143f, -0.02176619f, -0.01742826f, -0.09385564f, 0.05582378f, 0.01537564f, 
    0.00935429f, -0.04185545f, -0.01301041f, -0.02036925f, -0.00137248f, 0.05846990f, -0.00976825f, -0.09101183f, 
    0.06600373f, 0.08520907f, 0.03073294f, 0.04856585f, 0.08331555f, -0.04128056f, 0.13947591f, -0.01243508f, 
    0.00271302f, -0.09741072f, -0.01738297f, -0.09572899f, 0.01490445f, 0.06125819f, 0.06034628f, 0.04332646f, 
    0.01159581f, -0.01796205f, 0.00078795f, -0.14524733f, 0.08427673f, -0.06983966f, 0.07691032f, 0.00338383f, 
    -0.58447117f, 0.00710660f, 0.04222512f, 0.07707286f, 0.10249233f, 0.04045969f, -0.05149828f, -0.01139717f, 
    0.03515298f, 0.03073716f, -0.00815921f, 0.01158992f, 0.01796826f, 0.01550922f, 0.03463796f, 0.05015298f, 
    0.00171399f, 0.10935090f, 0.04144290f, -0.00191033f, -0.27609551f, -0.09418821f, 0.11745620f, 0.16099443f, 
    -0.04186796f, -0.05018570f, -0.07712239f, 0.04001879f, -0.02873323f, 0.03851102f, 0.05222081f, 0.01056852f, 
    0.06468268f, -0.01752723f, -0.02401799f, -0.03011072f, 0.04766496f, -0.07419966f, 0.04780856f, 0.01425865f, 
    -0.03447433f, -0.07583065f, 0.09062129f, 0.00030463f, -0.03562318f, 0.01124485f, -0.02005612f, 0.02689903f, 
    0.02371840f, 0.05492586f, 0.07359143f, 0.00420306f, 0.00709937f, -0.11020663f, 0.00330893f, 0.07758907f, 
    -0.01367014f, -0.02920301f, 0.00980887f, 0.04366346f, 0.06781844f, 0.26172894f, -0.17198758f, -0.17523323f, 
    0.02129897f, -0.00578959f, 0.02446314f, 0.03238044f, 0.03472599f, -0.00531842f, -0.03510286f, 0.04135987f, 
    -0.03456446f, 0.01956358f, -0.01789192f, 0.07351708f, 0.03268629f, -0.01981688f, -0.05045903f, -0.03207898f, 
    -0.45598185f, 0.04151359f, -0.09495467f, 0.01932360f, 0.16463883f, 0.06123496f, 0.00365421f, 0.02780750f, 
    0.02435635f, 0.09288310f, -0.02577691f, -0.04219916f, -0.03223337f, 0.05006880f, -0.02494847f, -0.06999241f, 
    0.10215673f, 0.04098647f, 0.02992662f, -0.07252333f, 0.17555349f, 0.17789616f, -0.05026781f, -0.38094500f, 
    -0.18438303f, -0.10877037f, 0.05909974f, -0.03612000f, -0.03748380f, -0.03600643f, -0.01418731f, -0.02081479f, 
    0.05167858f, 0.05331597f, 0.00395519f, -0.04434411f, 0.01243250f, -0.04750533f, -0.06902087f, -0.03698967f, 
    -0.31346983f, -0.01414744f, -0.08522855f, -0.08003467f, -0.03835418f, 0.09226974f, 0.10023311f, 0.12121721f, 
    -0.12774861f, -0.03123492f, -0.05044188f, 0.07601504f, 0.02507846f, 0.02670435f, -0.04731447f, -0.13915755f, 
    0.09700356f, -0.01226051f, 0.01250008f, 0.02540269f, -0.32536653f, -0.21353410f, 0.12239496f, 0.21188687f, 
    0.04881147f, -0.01434896f, 0.00550294f, 0.05006597f, -0.06522778f, -0.02914167f, -0.04741693f, 0.03090191f, 
    -0.04918086f, 0.03142935f, 0.01401934f, -0.03597342f, -0.03403258f, -0.03809417f, 0.02192328f, -0.05211250f, 
    -0.03013287f, -0.03396880f, 0.10476129f, 0.12177469f, -0.21213351f, 0.05295436f, 0.05283105f, -0.04556043f, 
    -0.00285434f, -0.00662852f, -0.02884377f, 0.01625281f, 0.02094367f, -0.01976437f, 0.00735332f, -0.01814994f, 
    0.00471245f, 0.11239272f, 0.02121488f, -0.04886032f, -0.04961679f, -0.02719737f, -0.07746401f, 0.00259636f, 
    -0.02797760f, 0.07694273f, 0.00868365f, 0.05165143f, 0.02000429f, -0.02248203f, -0.00973523f, 0.05141441f, 
    -0.05699701f, -0.05136723f, -0.11052850f, 0.00989748f, -0.00526319f, 0.03083617f, -0.02483871f, 0.03539629f, 
    0.11480918f, -0.19180459f, -0.11010778f, 0.11121707f, 0.18197054f, -0.03599203f, 0.00014996f, 0.04626507f, 
    0.02967359f, 0.01685284f, 0.12265766f, -0.00090336f, 0.00512122f, 0.03192511f, -0.01022257f, 0.04587332f, 
    -0.03754944f, -0.05432852f, 0.00463592f, -0.11333484f, 0.05196654f, -0.07974915f, 0.00341535f, -0.18358181f, 
    -0.00149771f, 0.08276317f, 0.03692031f, -0.01818851f, -0.00951895f, 0.14011970f, 0.03233821f, 0.10950430f, 
    0.04692362f, -0.11012992f, 0.06653432f, -0.09038405f, -0.09656635f, 0.02153932f, -0.05268389f, 0.04035129f, 
    -0.57568771f, -0.14257647f, -0.26393655f, -0.12965015f, -0.06681148f, 0.05684225f, 0.10494724f, -0.01686469f, 
    -0.01693816f, -0.20681012f, 0.04426122f, 0.04841814f, 0.06276139f, 0.00703045f, -0.01828970f, 0.00777622f, 
    0.02371443f, 0.01791602f, 0.06686497f, 0.06135852f, -0.07537989f, -0.09884516f, 0.07916257f, 0.09302053f, 
    0.12585157f, -0.00698869f, -0.05100012f, -0.02388420f, -0.08666338f, 0.06025821f, -0.06637902f, -0.04632965f, 
    0.01041164f, 0.01072107f, 0.03120003f, -0.02851331f, 0.02876798f, -0.07113781f, 0.02688069f, 0.05484688f, 
    -0.30821621f, 0.19757454f, 0.12565729f, 0.17188054f, -0.10541828f, -0.13164532f, -0.04618379f, -0.00623018f, 
    -0.07371845f, 0.03537726f, 0.02680946f, 0.03324639f, -0.02066888f, 0.01949404f, -0.01283317f, -0.01382278f, 
    -0.00410005f, -0.01563472f, -0.00454881f, -0.07601456f, 0.06138635f, -0.02738819f, 0.02582210f, 0.13302438f, 
    -0.01008484f, -0.06754028f, -0.01425004f, 0.04394957f, -0.11316999f, 0.15059248f, 0.07518344f, 0.06898428f, 
    0.06487310f, 0.07790368f, 0.06987959f, 0.02219100f, 0.04433817f, 0.00763759f, -0.10840439f, 0.07394984f, 
    -0.27078095f, 0.21155502f, -0.33617058f, -0.15402319f, -0.07065324f, 0.09011712f, 0.07155287f, 0.09380170f, 
    -0.07406922f, -0.15913519f, -0.02602649f, 0.00106646f, -0.05091127f, -0.11039462f, -0.02599891f, 0.03260836f, 
    0.02552696f, 0.05785272f, 0.10591480f, -0.00745926f, 0.04949828f, 0.04463610f, 0.09859349f, 0.08053714f, 
    -0.06384672f, -0.00218381f, 0.05675384f, -0.01593024f, -0.04367561f, 0.12599783f, -0.01122838f, -0.06198847f, 
    -0.05215259f, 0.08666126f, -0.01528069f, 0.02107396f, -0.01632446f, -0.03834006f, -0.00752908f, 0.11005730f, 
    -0.11978458f, 0.15054695f, 0.05139249f, 0.09640951f, -0.04111897f, -0.14244635f, -0.08067590f, 0.02853788f, 
    -0.02936222f, 0.08140526f, -0.03900840f, -0.11354191f, -0.09164397f, 0.05603207f, 0.01988677f, 0.07130870f, 
    0.03937768f, -0.05874596f, 0.03087389f, 0.03972534f, -0.04222007f, 0.11571067f, 0.07278454f, 0.07497444f, 
    -0.08319140f, 0.03959143f, -0.02561434f, -0.02703918f, -0.06667919f, 0.10617289f, 0.02290736f, 0.01754868f, 
    -0.03157862f, -0.06030538f, -0.05532902f, -0.08247533f, 0.02639043f, 0.12989508f, -0.02646350f, -0.02023351f, 
    0.20697452f, 0.04411839f, -0.05668211f, 0.05984445f, -0.23309341f, -0.09337959f, 0.01509389f, -0.00482366f, 
    0.02134404f, 0.00984246f, 0.00192661f, 0.02349359f, 0.03328510f, 0.07845435f, 0.12964366f, -0.08545124f, 
    -0.00381448f, 0.04758659f, 0.01129108f, -0.06485749f, -0.35056028f, -0.06219116f, -0.07810988f, -0.10138349f, 
    -0.02939097f, -0.01026600f, 0.13336894f, 0.04611124f, 0.00488943f, -0.02904013f, 0.04720310f, -0.01554263f, 
    0.07614908f, 0.01167518f, 0.04544924f, -0.01322112f, 0.02176662f, -0.05907320f, -0.02127432f, 0.00911373f, 
    -0.15148534f, -0.03936357f, 0.01114464f, 0.19445273f, 0.05200209f, 0.00150686f, -0.09499675f, 0.00002710f, 
    -0.00384147f, 0.01425103f, 0.09509075f, 0.07133660f, 0.03361177f, -0.01208700f, 0.04646863f, 0.03923263f, 
    0.04036868f, -0.06856414f, 0.02377123f, -0.14713782f, -0.01581416f, 0.04851803f, -0.03116260f, 0.00233483f, 
    -0.05417959f, 0.05796134f, -0.09072498f, -0.02283055f, -0.00558556f, 0.02095792f, -0.05498974f, -0.02464946f, 
    -0.10159560f, -0.05450777f, -0.08440337f, 0.08884335f, 0.06491996f, 0.01266254f, 0.02365923f, -0.01220094f, 
    0.09963902f, 0.04248758f, 0.03802108f, 0.20671320f, -0.09779549f, 0.01556527f, -0.01996718f, -0.02759800f, 
    0.05002967f, 0.11763561f, -0.07855511f, -0.13617118f, -0.04206569f, 0.12018619f, 0.05518883f, -0.00245060f, 
    0.02257524f, -0.09649169f, 0.04716264f, 0.02071136f, -0.10152938f, 0.14575829f, 0.07772195f, 0.08453643f, 
    -0.00916472f, -0.05998056f, 0.02550637f, -0.01171972f, 0.03011902f, 0.03623498f, 0.00540432f, -0.11414369f, 
    -0.02601980f, 0.01104784f, 0.08861638f, -0.02328702f, 0.00022144f, -0.03400777f, 0.02018376f, -0.02009468f, 
    -0.26332390f, 0.01833240f, -0.25893226f, 0.01886355f, 0.09398472f, 0.06961818f, 0.04521865f, 0.06684975f, 
    -0.03033535f, 0.05488630f, 0.00328662f, 0.10468504f, 0.08079059f, 0.01864105f, 0.07149459f, 0.03554154f, 
    -0.00026684f, 0.02100840f, -0.07053624f, -0.09866941f, 0.02539035f, -0.00015160f, 0.10655726f, -0.18388006f, 
    0.06414846f, -0.02950072f, -0.06220448f, -0.12326756f, 0.03715836f, 0.09746855f, -0.01680939f, -0.00914912f, 
    -0.01825769f, -0.03764909f, -0.07917212f, 0.06236844f, -0.11437280f, -0.05396080f, -0.07047299f, 0.11795253f, 
    -0.25097671f, 0.07341350f, -0.03064039f, -0.03452282f, -0.10973431f, 0.03319284f, 0.08261272f, 0.09921377f, 
    -0.07937932f, -0.02961681f, 0.00258352f, -0.07580519f, -0.03717517f, -0.09176098f, -0.08387756f, 0.01585863f, 
    -0.00253355f, 0.01517951f, 0.06307890f, -0.05389470f, 0.05617342f, 0.20781262f, -0.03917543f, -0.09511206f, 
    0.02119709f, -0.02231314f, -0.03200386f, -0.07876533f, -0.07610115f, -0.05606042f, 0.01891322f, 0.07578676f, 
    -0.07035751f, 0.01077958f, 0.07495558f, -0.02988232f, -0.04430686f, 0.01747400f, 0.04008918f, -0.10555499f, 
    0.01577888f, -0.02947251f, 0.12224299f, -0.05737496f, -0.10018394f, -0.07251307f, 0.11682678f, -0.03334066f, 
    -0.04663990f, 0.08008748f, 0.00212788f, -0.07372690f, 0.02669662f, -0.07084129f, -0.10593591f, 0.01076237f, 
    -0.01199018f, -0.11089025f, 0.09089156f, 0.00785948f, 0.03435452f, 0.00716829f, -0.00167023f, 0.13215557f, 
    0.13093822f, -0.05758202f, -0.06039571f, -0.05463202f, 0.12493873f, 0.08934308f, 0.11199325f, -0.10636219f, 
    0.00339955f, 0.08089355f, 0.08131309f, 0.00913131f, 0.03782959f, -0.03241750f, -0.14743741f, -0.00709279f, 
    -0.10661743f, -0.06435751f, -0.05587617f, -0.01473753f, -0.10833654f, 0.01860897f, -0.02918441f, -0.06385326f, 
    -0.01677404f, -0.05176809f, 0.04619913f, -0.01254514f, -0.03478803f, -0.04786590f, -0.08956693f, -0.06349993f, 
    -0.03458212f, 0.00057337f, -0.04525400f, 0.08812860f, 0.06452151f, 0.14876811f, -0.01561858f, 0.23066927f, 
    -0.04043838f, -0.05938580f, -0.09241343f, 0.02384632f, -0.08490097f, 0.06375545f, -0.00386391f, -0.03046276f, 
    -0.01154016f, 0.13662654f, -0.08515515f, 0.00517776f, 0.01792948f, -0.16964278f, -0.10100182f, 0.00636654f, 
    0.07045633f, 0.01023573f, 0.05941389f, 0.20714927f, 0.09890047f, 0.00569035f, 0.07373811f, 0.08473524f, 
    0.03269057f, 0.03947979f, 0.04050196f, -0.01866880f, -0.01456212f, 0.04507935f, 0.07861108f, 0.04744342f, 
    0.11970372f, -0.04453519f, 0.01806434f, -0.07516837f, -0.09740415f, 0.05667962f, -0.14276655f, 0.12485306f, 
    -0.16393241f, -0.04189467f, 0.09854007f, -0.07918332f, -0.01417995f, 0.06200651f, 0.00492407f, 0.02339993f, 
    0.17902119f, 0.01124114f, -0.02061395f, 0.05782571f, 0.05426200f, -0.06737909f, -0.05861976f, -0.07539412f, 
    0.10009597f, -0.02555160f, 0.13017817f, 0.04941139f, 0.00671548f, 0.00867944f, 0.06082349f, -0.02376146f, 
    -0.01082528f, -0.04618434f, 0.02124106f, -0.00082442f, -0.02889012f, 0.05007123f, 0.01903648f, 0.02473876f, 
    0.04891776f, 0.04635498f, 0.03356945f, -0.01073987f, -0.00920947f, 0.03021871f, 0.03122732f, 0.11655702f, 
    -0.04542056f, -0.01251439f, 0.01145470f, 0.04960878f, 0.03516488f, 0.01407189f, -0.00573628f, -0.04843082f, 
    -0.05986011f, 0.13175143f, -0.01414639f, 0.03837591f, 0.01264348f, -0.07698035f, -0.11301013f, -0.02682903f, 
    -0.03825637f, -0.00892052f, -0.08139463f, 0.09204944f, 0.14024051f, -0.00361390f, -0.11548309f, -0.00099440f, 
    0.08449336f, 0.09728432f, -0.05353915f, 0.04773869f, 0.04159895f, 0.00391567f, 0.01592839f, -0.11128581f, 
    0.01306835f, -0.04181075f, -0.08862856f, -0.21645002f, -0.35658476f, -0.08989689f, 0.20769204f, 0.01038959f, 
    -0.18519449f, 0.04687434f, -0.07429330f, 0.00606080f, -0.07598002f, 0.03545739f, 0.08511520f, -0.04571974f, 
    -0.07689040f, -0.05557464f, -0.15596153f, -0.03982972f, 0.02797663f, 0.08561107f, -0.01743816f, 0.02271195f, 
    -0.14313893f, -0.19285600f, -0.12143198f, -0.10147364f, 0.04254374f, 0.02735508f, -0.11186676f, -0.02598965f, 
    0.04685291f, 0.16055393f, 0.12524118f, 0.08071905f, 0.15479970f, -0.05854379f, -0.01137063f, -0.09330370f, 
    -0.03464774f, -0.01759225f, 0.09658522f, -0.07141197f, -0.09396569f, 0.27415481f, -0.10705092f, 0.09741611f, 
    0.17204098f, 0.07872225f, 0.04645244f, -0.03131420f, 0.01964939f, 0.06677161f, -0.14365706f, 0.17003541f, 
    0.05431197f, -0.09321652f, -0.02788372f, -0.14531198f, 0.06052160f, -0.00601701f, -0.11415673f, -0.09773547f, 
    0.07549024f, -0.06361746f, 0.05766237f, 0.13650310f, -0.00526393f, -0.00689271f, -0.08492509f, 0.05773973f, 
    -0.02721850f, -0.04910560f, 0.04336115f, 0.04354968f, 0.03993974f, -0.02525390f, 0.11536908f, -0.01529805f, 
    -0.01759318f, 0.11703485f, 0.06839015f, -0.03713169f, 0.18582930f, 0.10391608f, 0.05592321f, 0.05207779f, 
    -0.05576906f, 0.04328951f, -0.00174868f, -0.03014936f, -0.05000123f, 0.03072458f, 0.05446230f, -0.04451504f, 
    0.00487098f, -0.05147679f, 0.03215717f, 0.10208172f, -0.03905604f, 0.01584212f, 0.04596197f, 0.06880748f, 
    0.08957297f, 0.09297665f, 0.02473879f, 0.22873515f, 0.17889865f, -0.01344927f, 0.07457683f, 0.16823006f, 
    0.04881633f, 0.02663157f, 0.07383629f, -0.03186366f, 0.00528972f, -0.03319944f, 0.01566398f, 0.01145801f, 
    0.15700802f, -0.07941101f, 0.10108078f, -0.00657780f, 0.12941040f, -0.09909895f, -0.09626277f, -0.11828651f, 
    -0.34073061f, -0.09466145f, 0.00152581f, -0.02564058f, 0.06528604f, -0.05906894f, 0.07519542f, 0.08746982f, 
    -0.00797851f, 0.02863207f, -0.01577788f, -0.02435364f, 0.02535455f, 0.07864155f, 0.01070208f, 0.08249279f, 
    -0.00407795f, -0.00083413f, 0.02036886f, -0.06470231f, -0.08047571f, -0.08687190f, 0.06929476f, 0.08936653f, 
    -0.04285395f, 0.04611221f, 0.03437744f, -0.08076341f, 0.06584804f, -0.04125726f, 0.02559819f, -0.06215432f, 
    -0.11780088f, 0.04482089f, 0.08153804f, 0.01506966f, -0.43807757f, -0.08021741f, -0.10106856f, -0.10170881f, 
    0.03919521f, 0.13193078f, -0.07100468f, -0.04038122f, -0.04604428f, -0.07853197f, 0.00436717f, 0.01887526f, 
    -0.04418272f, 0.06104964f, -0.03212526f, 0.03899776f, 0.03577270f, -0.04374100f, -0.04803192f, -0.04283516f, 
    -0.21092796f, 0.00321580f, -0.13496716f, -0.22379993f, 0.09995171f, 0.07004780f, 0.10345072f, 0.16186246f, 
    0.00885992f, 0.00767514f, 0.13712460f, -0.03233553f, -0.03768199f, -0.03283789f, -0.06683742f, -0.00559719f, 
    -0.06958162f, -0.14791311f, -0.15137637f, 0.08317665f, 0.00337265f, -0.13100755f, -0.02127243f, 0.09038734f, 
    0.13202482f, -0.06959266f, -0.12636955f, 0.03062743f, 0.06073227f, 0.02985618f, 0.04676016f, -0.02778737f, 
    0.05825765f, 0.11626498f, -0.00719858f, 0.05057875f, -0.08633111f, -0.10801477f, -0.12867782f, 0.02507281f, 
    -0.20708801f, 0.28742146f, 0.01258941f, 0.06493027f, -0.20679744f, -0.05059278f, -0.10255269f, -0.03412627f, 
    -0.05318331f, -0.07592471f, -0.11116642f, 0.01795070f, -0.03662523f, -0.01376075f, -0.09134789f, 0.04277510f, 
    -0.04603657f, 0.06020025f, 0.10067613f, 0.05838325f, 0.11344959f, -0.04789636f, -0.16210213f, 0.12340672f, 
    0.06458390f, 0.10025455f, -0.05125144f, 0.03060092f, -0.00360231f, 0.01530538f, -0.02894277f, 0.04791677f, 
    0.07071641f, 0.07703692f, 0.10737320f, 0.06154841f, 0.05790019f, -0.03713251f, -0.10957208f, -0.05588708f, 
    -0.09584172f, -0.01429654f, -0.05500348f, -0.06432916f, -0.05951650f, 0.07165598f, 0.09752793f, 0.04594836f, 
    -0.06817168f, 0.04524446f, -0.08142751f, 0.15742624f, 0.02888900f, -0.07129095f, -0.09633697f, -0.11996979f, 
    0.06893449f, -0.09148384f, 0.10343930f, -0.12456056f, 0.00215908f, 0.03055064f, 0.06779069f, 0.00737716f, 
    -0.17966188f, 0.02567891f, 0.09801749f, -0.08242469f, -0.03879153f, 0.00393847f, 0.04541796f, 0.03630814f, 
    -0.10581796f, 0.04608000f, -0.00192146f, 0.01356180f, -0.04222016f, 0.07136168f, 0.11120977f, -0.03142503f, 
    0.05656389f, -0.05534861f, 0.07787881f, 0.06805043f, -0.00354552f, -0.04228921f, 0.06749746f, -0.01346894f, 
    -0.01335973f, -0.05070129f, -0.03268695f, 0.01901408f, 0.02918429f, 0.03781650f, 0.02139292f, 0.01482062f, 
    -0.00888797f, 0.07628010f, 0.03675374f, 0.01315875f, 0.08409390f, -0.03155332f, -0.03920193f, 0.08698624f, 
    0.02187263f, 0.03085149f, 0.00207752f, -0.06024396f, -0.00115304f, -0.00677526f, -0.10141263f, -0.08098523f, 
    0.11799791f, 0.02120408f, 0.11217955f, -0.02325056f, 0.06214505f, 0.05160939f, 0.01383870f, 0.03922546f, 
    -0.19785966f, 0.25674090f, -0.08966234f, 0.02889839f, -0.04735781f, -0.03410066f, -0.01495703f, 0.13241179f, 
    -0.06741141f, -0.00521067f, 0.14622931f, -0.01652623f, -0.12076223f, -0.04735507f, -0.12252880f, 0.05105338f, 
    -0.11915594f, 0.01635733f, 0.00367701f, -0.11846261f, -0.35158604f, -0.21476077f, -0.02833001f, -0.01838974f, 
    0.10337964f, 0.10357475f, 0.01593206f, -0.10352036f, 0.00023278f, -0.03433928f, 0.04821529f, 0.12113439f, 
    -0.05502391f, 0.10880082f, -0.05811659f, 0.02980417f, 0.11364805f, 0.00622022f, -0.23428880f, 0.05490299f, 
    0.00930353f, 0.02597584f, -0.04715186f, 0.09349455f, 0.09240483f, 0.06110434f, 0.01953981f, 0.00580267f, 
    -0.05596197f, 0.06801824f, 0.03683211f, -0.06098130f, -0.07995491f, 0.00992732f, -0.01806455f, 0.02279095f, 
    0.02666703f, -0.08969379f, 0.11152859f, 0.02774134f, -0.24570063f, -0.21833363f, 0.03622952f, 0.14682005f, 
    -0.29483768f, 0.02931688f, -0.02817614f, -0.01896220f, -0.01746031f, -0.07588121f, -0.03408935f, 0.02856776f, 
    0.04954569f, 0.01752871f, -0.00306901f, -0.02039136f, -0.06412949f, 0.00071069f, 0.00980153f, -0.01857132f, 
    0.13450184f, -0.04227857f, -0.03674153f, -0.00165007f, -0.07889384f, -0.00244642f, 0.06713531f, 0.00949785f, 
    0.01778013f, 0.06302445f, 0.06289158f, 0.00696337f, 0.01985069f, -0.00877133f, -0.09187325f, -0.01376411f, 
    -0.02320135f, 0.02404351f, 0.12063251f, 0.03745010f, -0.00319528f, 0.02128275f, -0.03297251f, 0.01162837f, 
    0.20327252f, -0.01020008f, -0.00209888f, -0.02182776f, 0.03616888f, -0.00662971f, -0.05467322f, -0.12980075f, 
    0.05949765f, 0.13388778f, 0.09341412f, 0.03578769f, 0.08766334f, -0.01763954f, -0.08859108f, 0.00860997f, 
    -0.05296194f, -0.07831196f, 0.13473545f, 0.18666254f, -0.20113391f, -0.00561466f, -0.09675065f, -0.02962629f, 
    0.04314487f, -0.06905220f, -0.03600175f, 0.07015435f, -0.00279915f, -0.08907408f, 0.12860560f, -0.06568523f, 
    -0.04464175f, -0.03198481f, 0.09558725f, -0.11653576f, 0.06517867f, 0.05531263f, 0.03910690f, 0.08118716f, 
    0.04729033f, -0.02013700f, 0.00128139f, -0.01672772f, -0.00420150f, -0.01435196f, -0.00489730f, -0.05107163f, 
    -0.04060314f, 0.02599511f, -0.02772894f, 0.08931141f, -0.16762039f, 0.04937392f, 0.00518280f, 0.06680359f, 
    -0.41842002f, 0.06320895f, -0.26940453f, -0.16372949f, 0.06762061f, 0.06944130f, 0.08626693f, 0.04160304f, 
    -0.03479730f, -0.08142611f, 0.06154027f, -0.05752080f, 0.03967924f, -0.04199962f, 0.09335946f, -0.00610031f, 
    0.05362545f, -0.12471110f, 0.01066186f, -0.00181688f, 0.10605145f, 0.01222164f, 0.03211058f, 0.07574304f, 
    -0.10907387f, -0.14169241f, 0.00062184f, 0.00194249f, 0.00546906f, 0.03504998f, -0.07885137f, -0.03053791f, 
    0.10580708f, 0.06983361f, 0.09861244f, -0.07604092f, -0.10149934f, 0.04046769f, 0.05563821f, 0.01039858f, 
    0.05503638f, 0.02771624f, 0.03232230f, 0.08236052f, -0.03615502f, -0.08812428f, 0.08092032f, -0.03932782f, 
    -0.02314056f, -0.01029962f, -0.03314096f, -0.02227754f, 0.05310076f, 0.00917330f, 0.08569627f, -0.00579601f, 
    0.00456357f, 0.07071006f, 0.02315357f, 0.02272397f, -0.28852263f, -0.19589277f, 0.13735522f, 0.12865640f, 
    -0.18373930f, 0.00427222f, 0.01280663f, -0.03022836f, 0.02063800f, -0.00708587f, -0.03260911f, -0.01921180f, 
    -0.00665683f, -0.00210338f, 0.04517259f, -0.04417965f, 0.07694044f, 0.04554189f, 0.02004174f, 0.00571404f, 
    -0.37140143f, -0.13166973f, -0.22948182f, -0.17929579f, -0.08705302f, 0.09609584f, 0.02867922f, 0.09147037f, 
    -0.01499459f, -0.10790585f, 0.00413717f, 0.08337840f, -0.02664691f, -0.01797336f, -0.00826884f, 0.06506030f, 
    -0.05387148f, -0.01763383f, -0.01863303f, -0.00409851f, -0.13667366f, -0.02740880f, 0.05444577f, 0.02185659f, 
    -0.06999934f, -0.00229843f, 0.03739407f, 0.03844634f, -0.03182033f, -0.06635973f, 0.01054736f, 0.04500972f, 
    0.03180808f, -0.06474541f, 0.02942129f, -0.06828216f, 0.02511944f, 0.12441158f, 0.01780069f, 0.01696545f, 
    -0.24860685f, 0.07629513f, 0.08634370f, -0.04222190f, -0.07239948f, -0.03852759f, -0.11808892f, 0.19005118f, 
    0.01026064f, -0.01093819f, 0.02366325f, -0.02437711f, -0.05718263f, -0.13225798f, -0.12883680f, -0.05123451f, 
    -0.01419837f, 0.00137895f, -0.04986189f, 0.16927898f, 0.14890596f, 0.11940801f, 0.00175636f, 0.02746618f, 
    -0.07854050f, -0.14278743f, -0.03034626f, -0.00347821f, 0.01540451f, -0.01602302f, -0.01142351f, -0.01603212f, 
    -0.01102052f, 0.09504915f, 0.19990504f, -0.01844355f, 0.03736056f, 0.05663203f, -0.07770950f, 0.03683109f, 
    0.09342145f, 0.08792848f, -0.13096449f, 0.14956626f, -0.13089514f, -0.05263056f, -0.10027260f, 0.02066714f, 
    0.05801437f, 0.04400199f, 0.07273491f, 0.02764724f, -0.00739730f, 0.01513336f, 0.00477361f, -0.02097239f, 
    -0.01185947f, -0.10186373f, -0.08071863f, -0.05251905f, -0.21556076f, -0.20814954f, 0.10280240f, -0.02799407f, 
    -0.02084580f, 0.07374322f, 0.06291787f, 0.03609361f, -0.04434084f, 0.00049525f, -0.01720149f, -0.00523537f, 
    -0.04953979f, 0.08109822f, 0.07610178f, -0.02071745f, 0.01521414f, 0.00677022f, 0.10322078f, -0.15688464f, 
    -0.02798881f, -0.06532334f, -0.15919305f, -0.17449787f, 0.32203394f, -0.03752380f, 0.05705503f, 0.03016586f, 
    -0.02430113f, 0.04250808f, -0.06414222f, -0.00324838f, 0.05947530f, 0.03796335f, -0.02928030f, 0.06025944f, 
    -0.09976170f, 0.11999028f, -0.03451962f, 0.12426380f, -0.05159096f, -0.09722855f, -0.06693030f, -0.21535183f, 
    0.09743772f, 0.03654729f, -0.03573110f, 0.06679779f, 0.02061465f, -0.07779170f, 0.01704458f, -0.10250050f, 
    -0.05138361f, -0.01478963f, -0.09561697f, 0.05660575f, 0.01784221f, 0.02123257f, 0.10083430f, 0.01055539f, 
    -0.09003292f, -0.16070509f, 0.01946608f, -0.23725587f, 0.12208147f, -0.04252941f, -0.02428582f, -0.04888506f, 
    -0.05604288f, 0.02353705f, 0.06451983f, -0.02061228f, 0.04525709f, 0.09439424f, -0.03479097f, -0.06839120f, 
    -0.04737775f, -0.07699805f, -0.03051259f, -0.01945855f, -0.17446108f, 0.10214919f, -0.16388601f, 0.18720548f, 
    -0.14892422f, 0.09033441f, 0.06839834f, -0.00610479f, 0.05269477f, -0.02247133f, -0.03466400f, -0.03059719f, 
    -0.03266195f, 0.01667644f, -0.08972263f, 0.03103873f, -0.00879325f, 0.00715158f, 0.00200321f, 0.00554015f, 
    0.10820489f, -0.15098614f, -0.05999442f, 0.06232076f, 0.41959015f, 0.01759586f, 0.00988165f, 0.03403926f, 
    0.05610434f, 0.04783611f, -0.10265087f, -0.01590082f, 0.04952129f, -0.01477551f, 0.09388358f, -0.05473126f, 
    -0.06017176f, 0.06468776f, -0.02233605f, 0.03796731f, 0.12785903f, -0.11173798f, -0.05415715f, -0.15008697f, 
    0.09936603f, -0.08778808f, -0.06392355f, -0.03990038f, 0.02039310f, 0.03862378f, -0.11082420f, -0.08014903f, 
    0.00673229f, -0.05218552f, -0.08563221f, -0.01929639f, 0.03262018f, 0.03432791f, 0.07554901f, 0.00425200f, 
    0.04564107f, -0.49848661f, -0.00562326f, -0.31352761f, 0.03548312f, -0.05223273f, 0.02217612f, -0.06231010f, 
    0.03188308f, -0.02587451f, 0.00510865f, 0.03833416f, 0.04014643f, 0.12465749f, -0.03782444f, 0.00240313f, 
    0.01798794f, -0.12976409f, -0.13348545f, 0.00447026f, -0.09215192f, 0.12418254f, 0.01812949f, -0.02288105f, 
    -0.09257068f, 0.00766228f, -0.10578771f, -0.03138748f, -0.01819345f, 0.07039245f, 0.04609128f, -0.01169884f, 
    0.00342679f, -0.00742865f, -0.07649547f, -0.01830393f, -0.08098792f, -0.00552674f, -0.08230173f, -0.02221071f, 
    -0.25196820f, 0.09534656f, -0.00933329f, 0.20080628f, -0.01988734f, 0.00299525f, 0.04258465f, -0.04326306f, 
    0.01434984f, 0.03864469f, 0.04304114f, 0.03687813f, 0.06171022f, -0.06334183f, -0.08549476f, -0.04411205f, 
    0.08297564f, -0.01784419f, -0.07888954f, -0.02894836f, 0.02802595f, -0.15070333f, -0.07540586f, -0.08295356f, 
    -0.04933612f, 0.01041625f, -0.05735356f, -0.02804911f, -0.06146729f, 0.02809257f, 0.00913077f, -0.01837550f, 
    -0.02503205f, -0.01258172f, 0.11250325f, 0.10623268f, -0.02392764f, -0.00690946f, 0.06636620f, -0.03562173f, 
    0.06508108f, 0.03970495f, 0.16811465f, -0.08835723f, -0.06961821f, 0.15006557f, -0.03830349f, 0.06557867f, 
    -0.02989923f, -0.02233802f, -0.01645309f, 0.03843606f, -0.06702755f, 0.00981512f, -0.09904632f, 0.01351629f, 
    -0.01348859f, 0.01069575f, 0.00144650f, -0.01342315f, 0.00912990f, -0.08536834f, -0.00675605f, 0.00173910f, 
    0.11008524f, -0.10093413f, -0.05407625f, 0.00862022f, -0.05191235f, -0.03923630f, -0.01542620f, 0.07099523f, 
    -0.04713928f, 0.02823503f, -0.00558411f, 0.01197549f, 0.03202944f, 0.06495488f, -0.00535093f, 0.04303759f, 
    -0.08491630f, 0.02595376f, -0.06332280f, -0.09048241f, 0.18827634f, -0.05319119f, 0.00656501f, 0.03151647f, 
    0.02597758f, -0.02706867f, 0.00778372f, -0.00022527f, 0.00034526f, 0.01842751f, 0.06448419f, -0.00872069f, 
    0.00198544f, 0.03307772f, 0.00578565f, 0.12048336f, -0.16266035f, -0.03753537f, -0.02393057f, 0.04359749f, 
    -0.00690662f, 0.02967007f, 0.02431427f, -0.00043596f, -0.02564224f, -0.01268509f, 0.07721204f, 0.03701573f, 
    0.07002359f, 0.05834926f, 0.01479800f, 0.00362437f, 0.04184803f, 0.01948710f, 0.06196833f, -0.02819241f, 
    -0.14080572f, 0.15186247f, -0.02945537f, -0.01765823f, -0.21855487f, 0.08034539f, -0.04904626f, -0.01538609f, 
    0.01044093f, -0.00074119f, 0.01926300f, 0.10083583f, -0.05098242f, -0.03514810f, -0.06442777f, 0.04119030f, 
    -0.05651463f, 0.04977609f, -0.02885089f, 0.03528260f, 0.32784712f, -0.00788406f, 0.04280782f, 0.08619589f, 
    0.26706901f, -0.05354058f, -0.05592947f, 0.03450810f, -0.05940307f, -0.03283920f, 0.03860742f, 0.00355563f, 
    0.11673081f, 0.01051298f, 0.05690842f, 0.05377597f, -0.04131618f, 0.02721481f, -0.04473333f, 0.01675594f, 
    -0.01343845f, 0.01977063f, 0.00860903f, -0.15204023f, -0.00657734f, 0.04961959f, 0.06603003f, -0.00848191f, 
    -0.09391693f, -0.09102410f, 0.05196929f, -0.00780235f, -0.03071138f, -0.04089336f, -0.02892276f, 0.00357033f, 
    -0.07545748f, -0.01845008f, -0.01304838f, 0.04692601f, -0.04268304f, -0.14396240f, -0.00024792f, -0.04193788f, 
    0.03484502f, 0.18022229f, 0.06406482f, 0.01151503f, -0.01988432f, 0.08601782f, 0.03134805f, -0.07481758f, 
    0.06687033f, 0.02083163f, -0.18988173f, 0.05469650f, 0.06411757f, -0.06497888f, 0.04668378f, -0.03551702f, 
    0.18035656f, -0.40304515f, -0.19628313f, -0.06539690f, -0.08114893f, -0.03135386f, 0.04954194f, -0.07384096f, 
    0.02535765f, 0.07408310f, -0.02788878f, 0.07784897f, 0.03793782f, 0.03388576f, 0.04709402f, 0.00316153f, 
    0.01139951f, 0.04244238f, -0.11296655f, 0.04520529f, -0.13004018f, -0.20229553f, -0.26887077f, 0.10621227f, 
    0.15417409f, 0.01611851f, 0.03805207f, 0.02273256f, 0.07670592f, 0.06653301f, 0.01396868f, -0.11577129f, 
    0.00080072f, -0.02691686f, -0.09109577f, 0.02117013f, -0.03374172f, -0.03434513f, -0.04051032f, 0.01689767f, 
    0.01450945f, -0.01415303f, -0.01367785f, 0.16124059f, 0.02572806f, -0.12277588f, 0.01731912f, -0.01017250f, 
    -0.00841307f, -0.08318175f, -0.02541473f, 0.09163960f, -0.00315688f, -0.00949240f, 0.06768806f, 0.07994283f, 
    0.02431365f, 0.13035926f, -0.03156246f, -0.00530801f, 0.09987035f, 0.11289790f, -0.00440627f, -0.04897175f, 
    -0.05005525f, 0.04134559f, -0.00408686f, 0.08061990f, -0.03638225f, -0.00676383f, 0.00421594f, -0.00934886f, 
    -0.11410064f, -0.01637603f, -0.02717934f, -0.03434895f, -0.02508123f, 0.08570474f, 0.07717470f, 0.00084995f, 
    0.27132112f, -0.00105388f, 0.06663929f, 0.04349847f, 0.06988950f, -0.01905770f, -0.01945067f, 0.03228946f, 
    -0.04738515f, 0.06729808f, 0.07243221f, -0.07837983f, 0.03354951f, -0.04127373f, 0.05843466f, 0.00082996f, 
    -0.02795409f, -0.04127325f, 0.00375079f, -0.04333330f, -0.06591839f, -0.06960052f, 0.01207958f, -0.02844071f, 
    0.10683852f, 0.07802711f, 0.00237320f, -0.06170161f, -0.05209463f, -0.03937522f, -0.16598837f, 0.00477767f, 
    -0.09018677f, 0.07522435f, -0.04318333f, 0.01451038f, 0.03981321f, 0.16306230f, 0.14921440f, -0.02413102f, 
    -0.11064890f, 0.14087979f, -0.07615254f, 0.06570872f, 0.05500754f, -0.03651268f, 0.00829780f, -0.01797917f, 
    -0.03474067f, -0.03961799f, -0.02865010f, 0.07490906f, -0.01262396f, -0.03281245f, -0.11334734f, 0.00000119f, 
    -0.06836514f, 0.04845150f, -0.08620854f, 0.02488066f, -0.05005474f, -0.00070081f, 0.03715013f, -0.03464843f, 
    0.12878872f, -0.00015494f, -0.06799078f, 0.06371240f, 0.04709711f, -0.12492843f, 0.03015214f, -0.01086046f, 
    -0.08605175f, 0.11572838f, 0.02307181f, 0.00721122f, -0.05729919f, 0.02403191f, 0.08244023f, -0.01787696f, 
    -0.20413795f, 0.02192412f, -0.01819650f, 0.13634461f, 0.01496924f, -0.08366933f, -0.08880469f, -0.02627363f, 
    0.06619990f, 0.06519752f, -0.09279651f, -0.00977833f, 0.01184324f, 0.06560591f, 0.04413380f, -0.03233281f, 
    0.03410595f, -0.08505978f, -0.06785800f, -0.05749886f, -0.01711743f, -0.04475427f, -0.01377176f, 0.09106501f, 
    0.00822929f, -0.04411200f, 0.02967075f, -0.00709082f, -0.08102947f, -0.00996694f, -0.01341145f, -0.06077341f, 
    0.02243666f, 0.00151794f, 0.00119399f, 0.00578312f, -0.03548290f, 0.09569453f, 0.02271830f, 0.02449769f, 
    0.07368007f, 0.09693363f, -0.03689839f, -0.00973865f, 0.03465870f, -0.07016206f, 0.05299648f, 0.05078945f, 
    -0.07773320f, -0.01669732f, -0.05086356f, 0.03986117f, -0.02141750f, -0.06478123f, 0.05114726f, 0.12367341f, 
    -0.03371776f, -0.03077768f, 0.08843249f, 0.10641473f, 0.23518288f, -0.37258664f, -0.10605165f, 0.09591362f, 
    -0.07038582f, -0.06409545f, 0.00864725f, 0.02965961f, -0.01763695f, 0.07713454f, -0.03303292f, 0.02199491f, 
    -0.01355222f, -0.01526296f, 0.06022201f, 0.00651860f, -0.03129967f, -0.06373888f, -0.00947566f, -0.01337941f, 
    -0.00522906f, -0.18498661f, -0.05080273f, -0.27522963f, 0.21149847f, -0.01168314f, 0.02622113f, -0.00296745f, 
    -0.01224272f, -0.09859175f, -0.03919464f, -0.05580620f, -0.16918068f, -0.03675714f, 0.02115750f, -0.05301166f, 
    -0.02283096f, 0.14662348f, -0.00796186f, 0.05937445f, 0.17146708f, -0.14488176f, -0.05609284f, -0.25588316f, 
    -0.10451609f, -0.02741264f, 0.01927948f, -0.00791875f, -0.02762488f, -0.02776293f, -0.03376031f, -0.00935235f, 
    0.02279634f, -0.09002227f, 0.05541795f, 0.09885783f, -0.03070876f, -0.01635157f, 0.06956127f, 0.04879216f, 
    -0.24999213f, 0.29524127f, -0.02439480f, 0.05504130f, -0.22517271f, -0.00361697f, -0.04057425f, 0.04486049f, 
    0.05145188f, 0.07697575f, -0.00704697f, 0.03696443f, 0.01039436f, -0.02847171f, 0.04260221f, -0.04994247f, 
    -0.06039347f, -0.02988877f, 0.02425987f, 0.05977508f, -0.03162229f, -0.06056231f, -0.14481059f, 0.11820477f, 
    -0.08966128f, -0.07874242f, 0.01436365f, -0.00318213f, 0.07982796f, 0.03226618f, -0.01484333f, 0.02721320f, 
    0.05843204f, 0.01587588f, -0.03217443f, -0.04497792f, 0.00177899f, -0.03215205f, -0.10887370f, -0.12730998f, 
    -0.14713149f, -0.12696873f, -0.18492070f, 0.00925398f, 0.01948282f, -0.14329295f, 0.05411771f, 0.00978318f, 
    -0.11391038f, 0.05172691f, -0.04801732f, 0.01342965f, -0.00721328f, -0.06752439f, -0.01234484f, 0.07626607f, 
    -0.07333837f, 0.03935453f, -0.16437858f, 0.03637449f, 0.12451313f, 0.03599069f, 0.16953665f, 0.03930782f, 
    -0.05138223f, 0.12810649f, -0.00030831f, 0.02161750f, -0.01076029f, -0.04099981f, -0.02997714f, -0.06990299f, 
    0.03263820f, 0.01957896f, 0.03124139f, -0.05661373f, 0.05729813f, 0.02533137f, -0.05263157f, -0.18297660f, 
    0.02273116f, 0.11331528f, 0.13414817f, 0.10061713f, -0.20519592f, 0.02450008f, 0.00219625f, -0.03961071f, 
    -0.04105737f, 0.07173371f, -0.08367860f, 0.01095155f, 0.06192532f, 0.10750062f, -0.05229358f, 0.03914881f, 
    0.03987220f, -0.00397830f, -0.07168041f, -0.10666870f, 0.22195111f, 0.03760882f, -0.06781075f, -0.23516406f, 
    0.09830748f, 0.01626769f, 0.04785891f, 0.06211954f, -0.05099088f, -0.07072398f, 0.00497311f, 0.00569711f, 
    0.08972652f, -0.06993038f, 0.02136205f, -0.00545071f, 0.05513877f, 0.07286014f, -0.03389961f, 0.11741462f, 
    -0.32824644f, -0.10206453f, -0.08651367f, -0.01382411f, 0.03437223f, -0.02572848f, 0.06502876f, -0.01430680f, 
    -0.04070748f, -0.12940890f, -0.15938622f, -0.00761527f, 0.03946863f, 0.02310903f, 0.08464072f, 0.07247918f, 
    -0.00101707f, 0.04209740f, 0.08016682f, 0.04432368f, 0.01536209f, -0.05888532f, -0.19817421f, -0.10177966f, 
    0.03571486f, 0.02138782f, 0.02949527f, -0.02561540f, -0.08242058f, 0.10410199f, 0.01614924f, -0.01705615f, 
    0.03480469f, 0.01516321f, 0.00635613f, 0.04104370f, 0.03896598f, 0.08763184f, 0.08334499f, -0.01270509f, 
    0.04093689f, -0.41478482f, 0.01111096f, 0.08978851f, 0.24806094f, 0.01623596f, 0.06924132f, 0.03757752f, 
    0.01348979f, 0.03543953f, -0.05060222f, 0.00664103f, 0.08179906f, 0.04785636f, 0.15881416f, -0.07486798f, 
    -0.00656440f, -0.09133757f, -0.05489290f, -0.08653694f, -0.04088819f, -0.01304589f, -0.02141284f, -0.02504285f, 
    -0.03125903f, 0.10946642f, 0.04885222f, -0.03815029f, -0.09257329f, -0.05100698f, 0.04941233f, 0.01611529f, 
    0.02603655f, -0.04943326f, -0.07094756f, 0.00987921f, -0.15747441f, 0.04106805f, 0.02614061f, -0.01222694f, 
    -0.00931373f, -0.18504794f, -0.10445567f, 0.03107002f, 0.20515867f, -0.11203568f, 0.08344804f, 0.01562354f, 
    -0.05485973f, -0.15589339f, 0.04819161f, -0.06703249f, 0.01854433f, 0.05278792f, 0.13375887f, 0.02922452f, 
    0.04426270f, 0.24011549f, 0.00884555f, 0.02951389f, -0.19493139f, 0.20608120f, -0.05701907f, 0.07828972f, 
    -0.09042944f, -0.10087854f, -0.05934790f, 0.06579440f, 0.02689868f, 0.01915556f, 0.07213628f, 0.00329881f, 
    0.03994006f, 0.02478869f, 0.04143620f, 0.06259447f, -0.02543515f, -0.05188069f, -0.08871629f, -0.03349833f, 
    -0.21197557f, 0.13782211f, 0.01105833f, 0.11702852f, -0.17658477f, -0.02694078f, -0.09376766f, 0.00880672f, 
    0.02808856f, 0.04465563f, 0.00699895f, -0.03310229f, 0.04599484f, 0.03138372f, 0.05490955f, -0.01787743f, 
    -0.01839482f, -0.08701961f, -0.03428257f, -0.07414105f, -0.24140164f, 0.25974622f, 0.05649622f, 0.04345306f, 
    -0.25869367f, 0.03464458f, -0.02190180f, -0.02037125f, 0.08452471f, -0.03800802f, 0.05868820f, 0.05950234f, 
    -0.05695213f, 0.05518314f, -0.09872796f, 0.02192737f, -0.07253683f, -0.03600633f, 0.03080379f, -0.02844395f, 
    -0.12219619f, -0.36951461f, -0.04752528f, -0.04590936f, -0.12814040f, 0.00958989f, -0.01226555f, 0.11313268f, 
    0.00427261f, -0.02460997f, -0.01745335f, -0.04305696f, 0.07942080f, 0.11578657f, 0.06005264f, 0.00113038f, 
    0.04902335f, 0.01253946f, -0.03611267f, -0.00757796f, -0.31372443f, 0.03857671f, 0.00059673f, -0.11193039f, 
    0.06171843f, -0.05345795f, 0.02308214f, 0.03806933f, -0.04361352f, 0.03983154f, 0.04990815f, -0.08374535f, 
    -0.01297687f, 0.02630405f, 0.01924419f, -0.05229561f, 0.02140542f, -0.07698801f, 0.11378037f, -0.01566023f, 
    0.02146663f, 0.03294424f, -0.11714275f, 0.09741140f, -0.17390439f, -0.07712788f, 0.07733589f, -0.03295641f, 
    0.11005443f, -0.01867808f, 0.01743932f, 0.06508464f, 0.00202895f, -0.02055917f, 0.00372075f, -0.06334551f, 
    -0.01854311f, 0.06109509f, -0.08815657f, -0.00696019f, 0.12386635f, -0.11270195f, 0.00622484f, 0.07456674f, 
    0.11384247f, 0.11380091f, -0.06735390f, 0.07433607f, 0.06457628f, -0.06320963f, -0.01298289f, -0.01574172f, 
    -0.02074780f, 0.01749183f, -0.07483357f, -0.00811009f, -0.02327188f, 0.10696414f, 0.04204470f, 0.05491904f, 
    -0.03607146f, 0.05298845f, 0.05418605f, -0.07934966f, -0.01189622f, 0.05727937f, -0.09644683f, 0.10186830f, 
    0.01230900f, 0.03568086f, 0.02590349f, 0.05030327f, -0.07998501f, -0.07916850f, 0.01969659f, -0.06088387f, 
    -0.01868023f, -0.04534871f, -0.09201881f, -0.08473165f, -0.12008600f, 0.18407358f, -0.10009417f, -0.11507727f, 
    -0.23174688f, -0.03785059f, 0.03219331f, -0.03142984f, 0.03033267f, 0.02620125f, -0.02380231f, 0.04290240f, 
    -0.11297429f, 0.06210715f, -0.11956442f, 0.02141016f, -0.03007473f, 0.05929330f, 0.07820666f, 0.02057112f, 
    -0.00640485f, 0.14755826f, -0.05666312f, -0.08566429f, 0.03021366f, 0.00491674f, 0.02395977f, 0.01929205f, 
    0.06284127f, 0.04543471f, 0.01397302f, 0.03166863f, 0.04004969f, -0.04110631f, -0.11185169f, 0.05420905f, 
    -0.02495157f, 0.01143643f, 0.04739492f, 0.04524742f, -0.19683337f, 0.15127912f, 0.06074422f, 0.01458314f, 
    -0.04049395f, 0.03193905f, 0.04880425f, -0.03466881f, 0.03131718f, 0.07426990f, -0.04794396f, 0.01676611f, 
    0.08128791f, -0.09840607f, 0.03958967f, 0.01203818f, 0.07297208f, -0.04873398f, 0.05030909f, -0.14571205f, 
    0.12786646f, -0.22098456f, -0.04073616f, -0.19688149f, 0.04247131f, -0.07206140f, 0.02484205f, -0.07082956f, 
    -0.12000922f, -0.14420252f, 0.07156368f, 0.00873288f, 0.01939681f, 0.08975521f, 0.05298871f, 0.06720587f, 
    0.01638270f, 0.02615619f, -0.03342579f, 0.04761973f, -0.03006204f, 0.19625528f, 0.22555858f, 0.00068254f, 
    -0.21104857f, 0.15738547f, -0.01362153f, 0.07063198f, 0.02528558f, -0.06343203f, -0.02538027f, 0.01555806f, 
    -0.11795827f, -0.00512632f, -0.05951536f, 0.09738533f, -0.08777951f, -0.01074299f, 0.04206202f, -0.03669408f, 
    -0.16946773f, 0.14155029f, 0.05598996f, 0.06832384f, -0.17940535f, 0.01507937f, -0.09743124f, -0.02967255f, 
    0.01927606f, -0.01672138f, 0.01538758f, 0.05017943f, 0.02508495f, 0.07685810f, -0.01598740f, 0.02882664f, 
    -0.00149095f, -0.10868354f, -0.00060575f, -0.04404636f, 0.18591741f, -0.10093468f, -0.04325415f, 0.12180065f, 
    -0.01109503f, -0.02569970f, -0.00685053f, 0.01317367f, 0.06640729f, 0.00980309f, 0.04276246f, -0.00271947f, 
    -0.04911849f, 0.02461781f, -0.09001579f, 0.02352566f, 0.00577484f, -0.07142162f, -0.03664874f, 0.00659937f, 
    0.06096864f, -0.16834953f, -0.00617478f, -0.19097506f, 0.01423624f, -0.04857064f, 0.05891842f, 0.02508214f, 
    -0.04931495f, -0.00800997f, -0.00745137f, -0.00522396f, 0.04386495f, -0.03325367f, 0.01147653f, -0.04092845f, 
    -0.01644819f, -0.02414787f, -0.02831171f, 0.05291866f, 0.19199559f, -0.06862692f, -0.04987285f, 0.01036942f, 
    0.11604288f, -0.00731028f, 0.09455021f, -0.02273000f, 0.03399447f, 0.05945055f, 0.06083788f, 0.04390404f, 
    0.03808851f, -0.02032137f, -0.00961604f, 0.02060435f, -0.03444325f, -0.01928912f, -0.10927649f, 0.11106295f, 
    0.07515337f, -0.06762896f, -0.14031281f, 0.16557898f, -0.03992404f, -0.02286338f, 0.09412135f, -0.01660285f, 
    0.10795183f, 0.00727899f, -0.09165755f, 0.00250481f, 0.07103382f, -0.02045357f, 0.15385769f, -0.07030485f, 
    0.00241621f, 0.11690347f, -0.06475162f, 0.00968002f, 0.13177264f, 0.02064386f, 0.14907414f, -0.16939642f, 
    -0.02877161f, 0.05879065f, -0.03467650f, 0.01240216f, 0.02109278f, -0.02835011f, 0.00017264f, -0.00192911f, 
    -0.13775514f, -0.05633894f, -0.11267742f, 0.04889542f, -0.01615818f, 0.00343248f, 0.01572481f, -0.04334281f, 
    -0.00171066f, -0.06175638f, 0.06888162f, -0.10277764f, -0.10910691f, 0.06993499f, -0.04134203f, 0.00374157f, 
    -0.03893972f, -0.05792259f, -0.05217957f, -0.03018915f, -0.07167566f, -0.04069076f, -0.01911931f, 0.02256342f, 
    0.01011062f, -0.00932333f, -0.04156481f, 0.00728705f, 0.12337013f, -0.00730311f, 0.03329441f, 0.12348653f, 
    0.03383598f, -0.06488534f, -0.00778243f, 0.00548180f, 0.03051432f, -0.01140661f, 0.00423947f, -0.04154611f, 
    -0.00706841f, -0.00215214f, -0.01016562f, -0.01450405f, -0.03788177f, 0.00121076f, -0.02616222f, 0.02318199f, 
    -0.11765956f, 0.16691592f, -0.24984831f, 0.11615315f, 0.08090258f, -0.06355964f, -0.03891091f, -0.05552873f, 
    -0.01837199f, -0.01401319f, -0.12259898f, 0.05010583f, -0.06970547f, 0.04127291f, 0.00237375f, 0.03967753f, 
    -0.02186006f, 0.02917519f, -0.11635082f, 0.03132458f, 0.07799477f, 0.11569946f, 0.11765834f, 0.14023282f, 
    0.20197955f, -0.03114527f, 0.09993485f, -0.07138376f, 0.03448225f, 0.02345093f, -0.03365886f, -0.05971848f, 
    -0.04530280f, -0.05894073f, -0.00350007f, 0.04506343f, 0.02153820f, 0.08299664f, -0.00013437f, 0.00431550f, 
    0.12794173f, -0.02475308f, 0.18837118f, 0.04948014f, 0.04231212f, 0.02398626f, 0.07431172f, 0.02033797f, 
    -0.05936145f, -0.05786534f, -0.00390331f, 0.08307800f, -0.08832036f, 0.03363256f, -0.05570507f, -0.08303934f, 
    -0.03533922f, 0.01738198f, 0.04004635f, -0.03725031f, -0.14080267f, 0.09861001f, -0.06052152f, -0.06298693f, 
    0.03948668f, 0.02328105f, 0.02830404f, -0.05940976f, 0.01877972f, -0.01644966f, -0.03064620f, 0.01098689f, 
    -0.02019442f, -0.00880458f, -0.05799052f, 0.00167202f, -0.04501833f, -0.02294113f, -0.03109846f, -0.00426264f, 
    -0.12401388f, -0.06629050f, -0.11551779f, -0.04337135f, 0.13855042f, -0.04378962f, -0.03208505f, -0.07102948f, 
    0.05991966f, -0.05567460f, 0.02712766f, -0.00725516f, -0.11670453f, -0.01267420f, -0.04252924f, -0.01786327f, 
    -0.08798636f, -0.01643818f, -0.03571732f, 0.03576131f, -0.00290464f, -0.17303033f, -0.04096606f, 0.14186795f, 
    0.04358037f, 0.05601421f, -0.05486837f, -0.06875414f, 0.02998330f, -0.04598580f, -0.02672247f, -0.02340769f, 
    -0.00993796f, -0.06488107f, -0.04481696f, -0.03571033f, -0.02106793f, -0.02850932f, 0.00741876f, 0.03258119f, 
    0.05303943f, 0.06366299f, 0.22529015f, 0.07619878f, 0.12596424f, -0.00881727f, 0.13041028f, -0.01186936f, 
    -0.00162495f, -0.05075906f, -0.02127867f, 0.06243016f, -0.04378145f, -0.03865094f, -0.06186613f, -0.02064708f, 
    0.02015075f, 0.03886159f, -0.01116600f, -0.01794017f, 0.08326142f, 0.09471588f, 0.00682833f, -0.05608444f, 
    0.07949603f, 0.02180067f, 0.02445963f, -0.11571919f, 0.04427494f, 0.03148486f, -0.03900802f, -0.00109478f, 
    -0.00008303f, -0.03067773f, -0.01569733f, 0.00934999f, -0.00167277f, 0.02469544f, -0.01398239f, 0.01662971f, 
    -0.17071243f, 0.15358491f, 0.00026115f, -0.11972088f, 0.00423161f, 0.02058882f, 0.06815511f, -0.05193606f, 
    0.03045579f, -0.00003392f, 0.01927463f, 0.06145627f, 0.03029929f, -0.01163680f, -0.04316872f, 0.01512785f, 
    0.01805176f, -0.01108342f, -0.06720978f, 0.04651195f, 0.10348622f, -0.02358007f, 0.04085208f, 0.05602116f, 
    -0.01882957f, 0.07434697f, 0.06367227f, 0.00307679f, -0.08478551f, 0.03896743f, 0.03603698f, 0.02360917f, 
    -0.02060906f, -0.02725453f, -0.03615429f, -0.05785768f, 0.03491221f, -0.05787623f, -0.03361145f, -0.05030334f, 
    0.16731678f, -0.41593638f, 0.15393111f, -0.01243451f, -0.08368480f, 0.06520813f, 0.01561094f, -0.05737093f, 
    0.01978138f, -0.01680427f, -0.05024742f, -0.02417224f, -0.02515585f, -0.01443201f, -0.09444961f, -0.04395444f, 
    0.08577648f, 0.00732452f, -0.00453747f, 0.01051952f, 0.06115498f, -0.00064504f, 0.11907099f, 0.06329197f, 
    0.04572092f, 0.09044542f, -0.00828850f, 0.06469335f, -0.03619597f, -0.02594474f, -0.05316288f, 0.02897577f, 
    -0.00708121f, 0.00826781f, -0.05113006f, -0.03797650f, -0.01310484f, -0.00036648f, -0.00253559f, 0.00457116f, 
    0.01187874f, 0.00543181f, -0.10441168f, 0.04126003f, 0.06794164f, -0.01057110f, -0.01932483f, -0.08830269f, 
    0.00223767f, -0.03747091f, -0.07235021f, 0.03723703f, -0.04087203f, -0.01730524f, -0.04441665f, 0.01560759f, 
    -0.06951769f, -0.07188167f, -0.06130301f, -0.03214131f, -0.24086450f, -0.03754162f, -0.02130944f, -0.04398720f, 
    -0.10004703f, -0.01727154f, -0.00324478f, -0.03829394f, 0.02012970f, 0.00079194f, 0.04542813f, -0.06227360f, 
    -0.03197281f, -0.05785198f, 0.01602896f, -0.04558123f, -0.03081044f, -0.07541267f, -0.02801414f, -0.03329412f, 
    -0.37715334f, 0.05737709f, 0.04880663f, -0.10289007f, -0.02305303f, 0.02109651f, -0.03302578f, -0.07506695f, 
    0.01634198f, -0.05802422f, -0.08764941f, -0.02611862f, 0.00329230f, -0.05598184f, -0.03407438f, -0.03538043f, 
    -0.02227362f, -0.00138089f, -0.01845580f, 0.02410785f, 0.02921223f, 0.03893954f, -0.11244720f, -0.01021297f, 
    0.09773667f, -0.07576287f, -0.05605710f, -0.00829628f, 0.00954137f, -0.01417149f, 0.02779084f, 0.00943938f, 
    -0.10301802f, 0.06716140f, -0.02632550f, 0.00561106f, -0.03057178f, -0.03032142f, -0.04519149f, -0.05162171f, 
    0.06690633f, 0.05279979f, 0.14789082f, 0.13980080f, 0.08835814f, 0.08838648f, 0.11144073f, -0.01139239f, 
    -0.00332936f, -0.03609939f, -0.04232883f, -0.01389163f, -0.07941835f, -0.06680636f, -0.02688241f, -0.03761382f, 
    -0.01833610f, 0.00990150f, -0.00327281f, 0.00302504f, 0.02912003f, 0.23394017f, -0.00290644f, -0.02931700f, 
    0.11639895f, 0.03471228f, 0.15095609f, -0.04254906f, 0.01163475f, 0.02274770f, -0.06141676f, -0.06923875f, 
    0.03756952f, -0.04829023f, 0.00378888f, 0.10524140f, 0.04412567f, 0.03508234f, -0.06779624f, 0.08864978f, 
    0.00938294f, 0.14750043f, 0.11459779f, 0.09309036f, 0.16741891f, 0.07195026f, 0.09471018f, -0.03112412f, 
    0.01227707f, -0.03287730f, -0.03544639f, -0.00556581f, 0.08966886f, -0.04616499f, -0.01869010f, -0.00789919f, 
    -0.00063598f, -0.02028382f, -0.01567616f, 0.01597082f, -0.16643819f, 0.07527106f, -0.04248856f, -0.01609796f, 
    -0.01931063f, -0.03539778f, 0.04991340f, -0.06903598f, -0.02110933f, 0.01226602f, -0.04519703f, 0.03161352f, 
    -0.00271122f, 0.01191706f, 0.01605200f, 0.09696356f, -0.00031782f, 0.02160402f, -0.00084151f, -0.00145735f, 
    -0.04169181f, 0.14408793f, 0.04375498f, 0.00271859f, 0.03525333f, -0.07074820f, -0.08153930f, -0.04283691f, 
    0.05259394f, -0.00080683f, -0.00933391f, 0.06572822f, 0.00541000f, 0.03751624f, -0.14991306f, -0.01156356f, 
    0.03987576f, 0.00178353f, 0.02019814f, -0.03563452f, 0.08648327f, 0.07509387f, -0.07430904f, 0.02884574f, 
    0.17071112f, -0.06221680f, -0.04622057f, -0.01577515f, -0.00523469f, 0.00304992f, -0.10607933f, 0.00210716f, 
    0.00712634f, -0.00826480f, -0.05658563f, -0.03236710f, -0.03756898f, 0.03521347f, 0.00036105f, -0.00729456f, 
    0.17225422f, -0.01889214f, 0.06562693f, -0.11973297f, 0.11975621f, -0.12565757f, 0.07239899f, 0.03629869f, 
    -0.01721474f, 0.05632717f, -0.00409524f, 0.00916331f, -0.04918871f, 0.02592258f, 0.07344870f, -0.01407957f, 
    0.01709148f, -0.00101478f, 0.00915744f, -0.07564387f, -0.01676399f, -0.01532528f, -0.03078299f, 0.04070578f, 
    0.16500844f, 0.03903218f, -0.08422150f, -0.11674467f, -0.00048617f, -0.04472103f, 0.03396028f, 0.01757207f, 
    0.02125186f, -0.04017846f, -0.08262506f, -0.02373039f, -0.10173276f, 0.01911080f, 0.07329835f, 0.01232152f, 
    -0.17616731f, 0.03195915f, -0.15327062f, 0.00974391f, 0.04981786f, -0.02553273f, 0.02354011f, -0.03070369f, 
    -0.02082524f, -0.04715708f, -0.11348059f, 0.00668093f, -0.04074430f, 0.03530539f, 0.02607072f, -0.01805524f, 
    -0.08680354f, -0.03492224f, -0.03712473f, 0.00629247f, -0.02929847f, 0.05374938f, -0.18623234f, -0.08031168f, 
    0.08150558f, -0.06343484f, -0.04281602f, -0.06115792f, -0.01510279f, -0.02053796f, 0.03366282f, -0.00267786f, 
    0.00649465f, 0.01804690f, -0.01705525f, -0.05382572f, -0.14676401f, -0.02818395f, -0.05547499f, -0.03581525f, 
    -0.01543223f, -0.09167851f, -0.04817199f, -0.09941275f, -0.10864718f, -0.04917687f, -0.03671161f, 0.01119172f, 
    -0.04044234f, -0.05393980f, 0.06069636f, -0.03200673f, -0.03486466f, -0.02224212f, -0.06319124f, -0.00178391f, 
    -0.03980173f, -0.02756684f, -0.05022768f, -0.01271184f, 0.00235839f, 0.06707507f, -0.00820020f, 0.00986865f, 
    0.13639300f, -0.01140639f, -0.10557281f, -0.11152938f, 0.01405527f, -0.02115607f, -0.01125592f, -0.03098829f, 
    -0.01086813f, -0.07104918f, -0.07406417f, -0.03064099f, -0.05078193f, -0.01420695f, 0.01477911f, 0.00285338f, 
    0.06309997f, -0.01901469f, -0.09021470f, 0.14315894f, 0.19947144f, -0.04296492f, -0.04814155f, -0.01430174f, 
    0.00285744f, -0.02747953f, -0.07488690f, -0.01084407f, -0.09917586f, -0.00053832f, -0.03485451f, 0.03832841f, 
    -0.06043259f, -0.03713120f, -0.05219050f, -0.00466983f, 0.07617797f, -0.07798872f, 0.03693246f, 0.05615184f, 
    -0.05823515f, 0.09625030f, -0.03202568f, 0.01996589f, 0.03702423f, 0.04367914f, -0.01905533f, -0.01742888f, 
    -0.01486631f, -0.07239471f, -0.02472853f, -0.00055306f, -0.02545386f, -0.05123492f, -0.01146227f, 0.01020103f, 
    0.07245994f, 0.10344926f, 0.09870214f, 0.06555046f, 0.17837964f, -0.08196027f, 0.08515799f, -0.09385841f, 
    0.04365665f, 0.02843306f, -0.03090919f, 0.05438038f, -0.14312802f, 0.01656485f, 0.00311227f, -0.04917957f, 
    -0.05096600f, 0.06428605f, -0.10948396f, -0.04086176f, 0.16512731f, -0.02096612f, 0.15352796f, 0.02645827f, 
    0.20859483f, 0.01022396f, 0.02628466f, 0.01570078f, 0.01615862f, -0.05154433f, -0.05394502f, 0.04840939f, 
    -0.05050737f, 0.01360033f, 0.03787751f, 0.03110477f, -0.02719413f, 0.00527978f, 0.00930741f, 0.01383303f, 
    0.07698770f, 0.08352326f, -0.20272939f, -0.13199827f, -0.04307530f, -0.01685933f, -0.07952604f, -0.01184127f, 
    0.01598694f, -0.02912527f, -0.11363687f, 0.03558632f, -0.02628788f, 0.02393073f, -0.03682565f, 0.03562555f, 
    -0.05184078f, -0.04172029f, 0.04439597f, -0.00826597f, -0.09124884f, -0.00069158f, 0.08694941f, -0.05423649f, 
    -0.11656848f, -0.02976694f, -0.07364579f, -0.01131860f, -0.02628002f, -0.06246015f, 0.01861332f, -0.00839584f, 
    -0.02680957f, 0.02886750f, -0.00017330f, 0.01196909f, 0.01146164f, -0.00689335f, -0.01549422f, -0.04027588f, 
    -0.27008748f, 0.14621578f, -0.03315556f, -0.01048923f, 0.05995237f, -0.09941161f, -0.00029396f, -0.14525151f, 
    0.00929582f, -0.01798793f, -0.04681573f, 0.03157221f, -0.07553445f, 0.04513084f, 0.02550752f, 0.02637435f, 
    -0.01927595f, -0.02344112f, -0.06413946f, 0.00261831f, 0.19652954f, -0.22826318f, 0.12215186f, -0.03277086f, 
    -0.11371262f, -0.00226339f, 0.04500203f, 0.00300093f, -0.00629672f, 0.03729262f, -0.07776543f, -0.03382502f, 
    -0.08764131f, 0.05255903f, -0.03579292f, -0.04888966f, 0.09308359f, 0.01367034f, -0.01776154f, 0.02341686f, 
    0.06402899f, -0.24669681f, -0.13219480f, -0.11856407f, -0.19216287f, -0.03389767f, 0.00171396f, -0.01058091f, 
    0.00136209f, -0.05032715f, -0.05878258f, -0.07013007f, 0.04287136f, 0.02279236f, 0.03725342f, 0.03966957f, 
    0.04138388f, -0.03173381f, 0.02001799f, 0.02712318f, 0.12616692f, 0.11703018f, 0.21001743f, -0.00557801f, 
    0.11184859f, -0.06211130f, 0.03807889f, -0.01937012f, 0.02115217f, -0.01435534f, 0.00635124f, 0.04785537f, 
    -0.03253230f, -0.03001299f, -0.06219259f, 0.01638651f, -0.06960920f, -0.00067918f, 0.03801291f, -0.06800583f, 
    0.04437270f, 0.06629875f, 0.16822751f, 0.06909550f, 0.15827128f, 0.11234615f, 0.03920165f, -0.03605706f, 
    0.01282000f, -0.04532947f, -0.04201891f, -0.01100525f, 0.00927704f, -0.05183563f, -0.10330708f, 0.04536130f, 
    -0.08287133f, -0.01066296f, 0.03668328f, 0.00845784f, 0.04656213f, 0.09817245f, -0.07396229f, -0.03139750f, 
    0.05738230f, -0.06592302f, 0.03377011f, -0.08013980f, -0.05048352f, -0.04217919f, -0.06724039f, -0.06252861f, 
    -0.00255699f, -0.05736560f, -0.06035598f, -0.02233843f, 0.02411436f, 0.06383410f, -0.04325208f, -0.02562132f, 
    -0.04321645f, -0.17622167f, -0.06371443f, -0.01917077f, 0.11050523f, -0.03531774f, 0.00158724f, -0.01318908f, 
    0.02937680f, -0.08970576f, 0.03826866f, -0.03284580f, -0.02439135f, 0.00631776f, -0.00136341f, 0.01035158f, 
    -0.02738889f, -0.02373030f, -0.00477965f, -0.00754679f, 0.05309310f, -0.07525885f, 0.02086073f, 0.06015357f, 
    0.11555046f, 0.03197939f, 0.00641593f, -0.01869256f, 0.01499195f, -0.05551543f, -0.01132649f, -0.03096026f, 
    0.00683239f, -0.08753499f, 0.00088088f, -0.04519274f, -0.02162435f, 0.01713920f, 0.06632543f, -0.02194575f, 
    0.07745619f, 0.17147116f, 0.05837557f, 0.15076716f, 0.20634672f, 0.10917596f, -0.01950378f, -0.03139869f, 
    0.04480090f, -0.03314624f, 0.00297366f, 0.03658871f, -0.02654980f, -0.01422881f, -0.14955994f, -0.03989048f, 
    0.00864161f, 0.08705661f, 0.07680752f, -0.08615300f, 0.00019093f, 0.04798301f, -0.09641899f, -0.12057026f, 
    -0.16997288f, 0.00202672f, -0.10779294f, -0.01272169f, -0.05380004f, -0.02564661f, 0.05540952f, -0.03592267f, 
    -0.05687567f, -0.01282580f, -0.09929465f, 0.04735546f, 0.04977272f, -0.03201750f, -0.01988555f, -0.00114540f, 
    -0.08319129f, -0.18743135f, -0.05774863f, -0.12627006f, -0.17565835f, -0.00929696f, -0.08210027f, 0.00541629f, 
    -0.03297306f, -0.06554983f, 0.01294812f, -0.08154593f, -0.01686217f, -0.03672146f, -0.01968512f, -0.00311447f, 
    0.01113130f, -0.05233000f, 0.00857987f, -0.03624082f, -0.28911701f, -0.04465420f, -0.13094579f, -0.20797773f, 
    -0.15622015f, 0.03558629f, 0.01401447f, 0.02153902f, 0.00177226f, -0.02257349f, -0.02312386f, -0.01698501f, 
    -0.01889863f, 0.02962060f, 0.02330843f, -0.00629357f, 0.01245503f, 0.04516643f, 0.00356199f, 0.05237002f, 
    0.14034452f, 0.02007934f, 0.03969528f, 0.07175268f, -0.06850593f, 0.04511113f, -0.02021779f, -0.06521644f, 
    -0.02501141f, 0.01905383f, -0.03503239f, 0.04275263f, -0.04481747f, 0.01401939f, -0.10124873f, 0.00901905f, 
    -0.03822898f, -0.01248157f, 0.02873451f, 0.02826158f, 0.14164327f, -0.01226543f, 0.14197730f, 0.01450038f, 
    0.05567587f, 0.00497754f, -0.00107101f, -0.06430686f, -0.02657768f, -0.02297577f, -0.00486482f, 0.08541857f, 
    -0.03647053f, -0.04536089f, -0.04996856f, -0.02148680f, -0.03796675f, -0.02858561f, 0.05721543f, -0.07733844f, 
    -0.25345755f, 0.12958567f, 0.00413373f, -0.07731286f, -0.01871581f, -0.06546902f, -0.01599318f, -0.04791069f, 
    -0.01243709f, -0.02349359f, -0.08862136f, -0.00454726f, -0.05898053f, -0.00209642f, -0.02807236f, -0.04303007f, 
    -0.04599869f, 0.01747354f, 0.01251221f, -0.01649768f, 0.05220863f, -0.06025922f, 0.07504819f, 0.09770491f, 
    -0.16401954f, 0.11643627f, -0.04390300f, 0.03551411f, 0.00275426f, -0.04218050f, -0.00746593f, -0.02628709f, 
    -0.02583444f, -0.00818372f, -0.05253706f, 0.08175798f, 0.02898599f, 0.02098977f, -0.05906038f, -0.03631202f, 
    0.13606705f, -0.27033055f, 0.03134453f, -0.07408503f, -0.11030262f, -0.03017836f, -0.03082270f, -0.05589664f, 
    -0.01632374f, -0.01198311f, -0.02095912f, 0.03781997f, 0.02262250f, -0.00009219f, -0.06232339f, -0.04971353f, 
    0.06982231f, -0.05523925f, 0.01148933f, 0.01543097f, -0.10965081f, 0.00665236f, -0.16944453f, 0.04118111f, 
    0.09095557f, -0.10678514f, -0.01208177f, -0.09029451f, 0.00180250f, -0.02007687f, -0.06547949f, 0.04257343f, 
    -0.02700355f, -0.04869808f, -0.07889018f, -0.02927214f, -0.02620007f, 0.02408201f, -0.00297165f, 0.07840541f, 
    -0.10683667f, 0.06376503f, -0.03909338f, 0.08006963f, 0.03794003f, 0.02024501f, -0.05670624f, 0.01426462f, 
    -0.02144574f, -0.01185764f, -0.04049284f, 0.02531952f, -0.04659095f, 0.04640043f, -0.07909870f, 0.04890478f, 
    -0.00038147f, -0.01738700f, 0.02577852f, -0.04611493f, -0.15078117f, 0.00892289f, -0.20638426f, -0.15701169f, 
    -0.15357253f, -0.01681956f, -0.03312898f, -0.04207120f, -0.01444190f, -0.01631360f, -0.06152298f, -0.06934225f, 
    0.05696158f, -0.03350649f, -0.00766608f, -0.03033444f, -0.01954095f, -0.05266878f, 0.00075795f, 0.08088613f, 
    0.03835788f, 0.10525315f, 0.18086895f, 0.03817989f, 0.10391764f, 0.01476007f, 0.08474838f, 0.02461822f, 
    0.02375836f, -0.03895358f, -0.03965390f, 0.02635754f, -0.04790030f, -0.06289680f, -0.05730518f, -0.05218083f, 
    0.01274741f, 0.05136184f, 0.02388905f, -0.02197688f, -0.04436345f, -0.34038609f, 0.04274395f, -0.09377541f, 
    -0.12868926f, -0.01701017f, -0.01996090f, -0.00712941f, 0.02083290f, -0.04051874f, -0.03650481f, -0.03371800f, 
    -0.04434094f, 0.01487695f, -0.00086338f, -0.02576878f, -0.00304595f, -0.01157351f, 0.00114010f, 0.03268487f, 
    -0.13734759f, -0.19533257f, -0.05590706f, -0.19937362f, -0.21543731f, -0.01207863f, -0.03086723f, 0.03604138f, 
    -0.02200815f, -0.04393032f, -0.00719598f, -0.05442465f, -0.03949207f, -0.00038561f, 0.02723616f, -0.01153041f, 
    0.02867193f, -0.00887609f, -0.01027612f, -0.00055711f, 0.01053330f, -0.07517709f, -0.01812616f, -0.02744367f, 
    -0.06983972f, 0.04675453f, -0.06859544f, 0.03159775f, 0.04884573f, -0.02509023f, -0.04490269f, -0.01416502f, 
    -0.03661847f, -0.03363259f, -0.00332473f, 0.01980766f, 0.00124935f, 0.03116912f, 0.01447537f, -0.02056699f, 
    0.09322357f, 0.05771077f, 0.17371607f, 0.06336376f, 0.06675886f, 0.02006466f, 0.09278727f, 0.00755112f, 
    -0.04622452f, 0.00016277f, -0.03596769f, 0.02027175f, -0.03346716f, -0.04052804f, -0.03044513f, -0.00741544f, 
    -0.05426316f, -0.03865771f, 0.05707020f, -0.05991111f, 0.02150379f, 0.12637989f, 0.12116533f, 0.09152690f, 
    0.04933492f, 0.12326749f, 0.12976144f, 0.02820276f, 0.04016687f, 0.01885079f, -0.03271388f, -0.09836739f, 
    0.06541876f, 0.01360710f, 0.00525936f, 0.08361787f, 0.01311235f, 0.00486895f, -0.00366999f, 0.00191682f, 
    -0.12218000f, 0.17035261f, 0.07188051f, 0.07951856f, -0.06352618f, -0.01549667f, -0.07515288f, -0.00663641f, 
    0.11799007f, -0.00832361f, -0.01682548f, 0.05364838f, 0.00988760f, -0.00315521f, -0.06024845f, 0.09876492f, 
    -0.00359069f, 0.14116530f, 0.01865052f, 0.02416045f, 0.04256797f, -0.23779972f, 0.02879025f, 0.05047119f, 
    0.01522056f, -0.04724851f, -0.01386697f, -0.05720087f, 0.00817160f, -0.01619594f, -0.07891779f, -0.03810511f, 
    -0.01931443f, -0.06018645f, -0.06580384f, -0.06886109f, 0.02218663f, 0.04898976f, 0.02808329f, 0.07286834f, 
    0.14809825f, 0.10946260f, -0.03052494f, 0.06674825f, 0.12002139f, 0.08901259f, -0.03399797f, -0.03520201f, 
    -0.00055817f, -0.06440412f, 0.03739973f, -0.00083621f, -0.02404578f, -0.02718928f, -0.07288249f, -0.00741762f, 
    -0.02811641f, 0.03652345f, 0.01139677f, 0.02681015f, -0.08380724f, 0.09920106f, 0.08062570f, -0.08583213f, 
    0.08728383f, -0.02866969f, -0.01998555f, -0.00755784f, -0.00950619f, -0.10164351f, -0.00958201f, -0.02330807f, 
    0.00824094f, -0.00290745f, 0.01349014f, -0.02038793f, 0.05856241f, 0.02816615f, -0.03103950f, -0.04482647f, 
    -0.08664995f, 0.22571737f, 0.13694486f, 0.04293793f, -0.12873916f, -0.09109493f, 0.01736156f, -0.03101553f, 
    -0.12469076f, -0.08368276f, 0.01825360f, -0.04079498f, 0.03731006f, -0.01891867f, -0.05053158f, -0.13467748f, 
    0.06201518f, -0.07585188f, 0.04084607f, -0.01373114f, -0.14499170f, 0.09566433f, 0.00408902f, -0.17258687f, 
    -0.27616632f, -0.04606867f, 0.04795239f, -0.02817609f, 0.04888202f, -0.09820694f, 0.06653764f, 0.04766348f, 
    -0.04991167f, 0.01371068f, 0.04762122f, -0.07788198f, 0.03214577f, -0.07460795f, 0.00838621f, -0.01285917f, 
    -0.14154817f, -0.00170411f, 0.19255199f, 0.01743815f, 0.11049824f, -0.01837736f, 0.04340973f, 0.04000187f, 
    0.00822468f, -0.02821666f, 0.04246977f, -0.08243891f, 0.03749608f, 0.00127701f, 0.01127946f, 0.01462569f, 
    0.04124092f, 0.00523362f, 0.01216236f, 0.03950668f, -0.09438218f, 0.09799256f, -0.17827789f, -0.00758397f, 
    -0.01119740f, 0.00144122f, -0.00374572f, -0.10347000f, -0.03591819f, -0.00131164f, 0.02031089f, 0.02032768f, 
    -0.01826478f, 0.00965940f, 0.03310736f, -0.01281873f, -0.08792208f, -0.08581000f, 0.05897728f, -0.04517001f, 
    0.03090104f, 0.17712568f, 0.13074201f, -0.02065847f, 0.03839836f, -0.06257735f, -0.06946154f, -0.03974427f, 
    -0.07845330f, -0.14844701f, 0.04644996f, 0.00477250f, -0.04439486f, -0.00574497f, -0.03696626f, -0.07695314f, 
    0.03810437f, 0.02543773f, 0.03713935f, -0.07034490f, -0.07287315f, -0.08017789f, 0.01555022f, -0.24936095f, 
    -0.03414591f, 0.02905541f, -0.13028181f, 0.03550508f, 0.02058740f, -0.01888286f, 0.03626135f, 0.07048736f, 
    0.04164060f, -0.02444657f, -0.01672908f, -0.03808098f, -0.03878769f, -0.01969359f, -0.07433051f, -0.03184474f, 
    -0.10538597f, -0.03881509f, 0.21377294f, 0.04752100f, 0.22152169f, -0.08248631f, -0.05113680f, 0.10204380f, 
    -0.01217398f, 0.00266299f, -0.00216538f, -0.07468868f, -0.05132479f, -0.14012590f, 0.07645797f, -0.01511234f, 
    0.00844598f, 0.01649708f, 0.03167586f, 0.05166778f, -0.16155969f, 0.00338726f, -0.15310799f, -0.19219068f, 
    -0.20130663f, 0.05556633f, -0.05158678f, -0.08546515f, 0.02833143f, -0.02665457f, 0.07825080f, 0.02238871f, 
    0.02718290f, -0.00045097f, 0.00685781f, 0.00949677f, 0.02185992f, -0.09350370f, 0.01010502f, -0.04106852f, 
    -0.01925372f, 0.19461742f, -0.22389393f, -0.00444870f, -0.03521969f, 0.02601171f, 0.00394348f, -0.09545346f, 
    -0.05295601f, 0.03047998f, 0.04900336f, 0.01916195f, 0.00716709f, 0.01533486f, 0.03742673f, 0.00418821f, 
    -0.07500248f, -0.03705529f, 0.07106966f, 0.02465621f, -0.00757265f, -0.13477987f, 0.11157248f, 0.00184830f, 
    0.04714912f, -0.01799871f, -0.01936720f, -0.00076198f, -0.09244884f, 0.03527264f, 0.00807911f, 0.00837192f, 
    -0.06398716f, 0.00053774f, 0.03673668f, -0.04032823f, 0.03226994f, 0.06923683f, -0.07807649f, -0.01874629f, 
    0.02332141f, -0.08915401f, -0.12269563f, 0.02312226f, 0.11722462f, 0.04939229f, -0.00235012f, -0.04104865f, 
    -0.01670761f, -0.01843697f, 0.04351455f, 0.03850357f, -0.01738975f, 0.01214786f, 0.06385239f, 0.06535783f, 
    -0.02037276f, 0.02449222f, 0.05866262f, 0.05009760f, -0.08182191f, -0.06122474f, 0.05906196f, 0.10096370f, 
    -0.02438929f, 0.02401567f, 0.01318987f, -0.01350150f, -0.06970666f, 0.01015878f, 0.00197674f, -0.00651009f, 
    -0.03201448f, -0.04195916f, -0.05685444f, 0.00269476f, 0.02031534f, -0.04058507f, 0.04631659f, 0.03992753f, 
    -0.00146836f, 0.10493412f, 0.12713233f, -0.02006834f, -0.07752971f, -0.03512145f, 0.01569337f, -0.06093327f, 
    -0.05471503f, -0.02675993f, 0.04659791f, 0.02628099f, -0.03079361f, -0.03673598f, -0.01185871f, -0.06083658f, 
    -0.02730865f, 0.01181211f, -0.01938115f, -0.08803245f, -0.01315887f, 0.13953161f, -0.05469826f, -0.01421836f, 
    -0.02025753f, 0.03465720f, -0.03075883f, -0.01159008f, 0.02628299f, -0.05385045f, -0.02401019f, 0.01332802f, 
    -0.02185534f, -0.01270130f, 0.04865262f, -0.08142258f, -0.02032571f, 0.03614478f, -0.00453147f, -0.02726341f, 
    -0.05486536f, 0.02538593f, -0.20057906f, -0.02855407f, 0.05502284f, 0.11528807f, -0.01665921f, -0.05745847f, 
    0.04063210f, -0.02541710f, 0.00305284f, 0.01398244f, 0.09436475f, 0.00258090f, 0.02526707f, -0.00193633f, 
    -0.03386947f, -0.04729163f, 0.08700816f, -0.05700324f, 0.03646601f, 0.08771239f, -0.06576488f, -0.02699145f, 
    -0.03268862f, 0.00928112f, -0.02991273f, -0.02146803f, -0.11126990f, -0.05628548f, 0.03328351f, -0.03994455f, 
    0.00323845f, -0.02965907f, -0.07166060f, -0.03195680f, 0.02822383f, -0.03947381f, 0.04881204f, 0.02198966f, 
    -0.16469727f, -0.16465598f, 0.14616701f, -0.10369170f, -0.16465914f, -0.00108037f, 0.02528242f, 0.02616909f, 
    -0.05848602f, -0.05342153f, -0.00028364f, 0.03230033f, -0.01778614f, 0.06977967f, -0.02276029f, -0.06218623f, 
    -0.01879699f, -0.04907849f, -0.14653890f, 0.01171433f, -0.30099073f, 0.10670445f, -0.11894157f, -0.27796647f, 
    -0.36865145f, -0.04471849f, 0.02495120f, -0.00684770f, 0.06598481f, -0.07076509f, 0.10963799f, -0.01570075f, 
    0.00907670f, 0.01339443f, 0.08354169f, -0.10085907f, 0.02865681f, -0.05076254f, 0.06405600f, -0.02691154f, 
    -0.04814173f, -0.15779158f, 0.15462507f, 0.01001390f, 0.03400399f, -0.05549131f, -0.04015033f, -0.02392012f, 
    -0.05683571f, 0.04393819f, -0.03543640f, 0.02779347f, -0.00460532f, -0.02969654f, -0.01553609f, -0.01822599f, 
    0.01607046f, 0.00187379f, 0.06673692f, -0.00108054f, -0.03283275f, 0.18795349f, 0.00676424f, 0.01905142f, 
    -0.08304277f, -0.05465534f, 0.01463885f, -0.07266407f, -0.04843351f, -0.02175203f, 0.08986685f, 0.03247444f, 
    -0.00854116f, -0.02114841f, 0.05579916f, -0.05758622f, -0.01019169f, 0.00781442f, 0.09254227f, -0.07096726f, 
    0.06148173f, 0.03609636f, -0.18521537f, -0.01533935f, -0.07199112f, -0.00504205f, -0.04141719f, -0.18786238f, 
    -0.03655937f, 0.01684758f, 0.07325502f, -0.03894112f, -0.00933857f, -0.07785369f, -0.00257377f, 0.03575863f, 
    -0.02510038f, -0.06522233f, 0.14473879f, -0.01521165f, -0.13641424f, -0.14369147f, 0.05197971f, -0.18848294f, 
    -0.02218731f, 0.01596643f, 0.01713469f, -0.03511678f, -0.01522855f, -0.05495706f, 0.00860955f, 0.00763967f, 
    -0.03358604f, 0.04503826f, -0.03924234f, 0.08850425f, 0.05419914f, 0.04789440f, -0.14239398f, 0.01332608f, 
    -0.14899734f, 0.02176084f, 0.09039867f, -0.13620831f, -0.08789865f, -0.02252523f, 0.03868688f, 0.01462436f, 
    -0.04343759f, -0.04730564f, 0.01406643f, -0.03840969f, 0.02584650f, 0.02033470f, 0.03466774f, 0.00929585f, 
    0.06149314f, -0.02203469f, -0.07476179f, -0.01537136f, -0.18683812f, 0.09149256f, -0.14681187f, -0.23009679f, 
    -0.17013396f, -0.05046069f, -0.09118743f, -0.13553342f, 0.01884924f, -0.01504714f, 0.08392213f, 0.04109450f, 
    0.07672317f, -0.02304624f, 0.02478830f, 0.00907240f, -0.00637351f, -0.14337653f, 0.04948407f, 0.09105139f, 
    0.12456051f, 0.05109776f, -0.09287283f, -0.00850532f, 0.03431030f, 0.00741494f, 0.00106501f, 0.02441676f, 
    -0.03292122f, -0.01124458f, -0.02475494f, 0.00002502f, -0.01032471f, 0.04473598f, -0.04953787f, 0.01176663f, 
    0.01347257f, 0.05718349f, 0.05448138f, 0.00068310f, -0.04863379f, 0.08917316f, 0.00373320f, 0.06950293f, 
    0.02192453f, 0.05098535f, 0.01960221f, -0.06080169f, -0.05480025f, -0.06238919f, -0.00089706f, 0.01249405f, 
    -0.00754071f, -0.01793718f, -0.07719053f, -0.09435809f, 0.00057429f, 0.07761495f, -0.04913149f, -0.15345441f, 
    0.13469033f, 0.04777839f, -0.01836788f, 0.08172251f, 0.09548809f, 0.00599487f, 0.05773240f, -0.02161704f, 
    -0.02601100f, -0.00943023f, -0.04764400f, 0.00916004f, -0.07478695f, -0.01015265f, -0.00237700f, -0.08405896f, 
    -0.02484369f, 0.04780857f, 0.06908531f, 0.02091715f, -0.11439933f, 0.07087442f, -0.18548630f, -0.18962167f, 
    -0.16675778f, 0.04077391f, -0.04036879f, -0.12742023f, 0.04923458f, -0.07769553f, 0.06171687f, 0.03845772f, 
    0.00921217f, -0.00756942f, 0.00059656f, -0.00952894f, 0.03522848f, -0.07673062f, 0.02004838f, 0.03758476f, 
    -0.09747782f, -0.04394222f, 0.04989599f, -0.08334216f, -0.01821336f, -0.03469251f, 0.05625867f, -0.13673095f, 
    -0.07383826f, -0.03424624f, 0.05127441f, -0.00653305f, 0.09182162f, 0.02020530f, -0.07052485f, -0.06465509f, 
    0.01828078f, 0.00964992f, -0.06953079f, -0.10554142f, 0.07984593f, -0.00710857f, 0.07006095f, 0.03067007f, 
    0.15066135f, -0.10678990f, -0.10680245f, -0.02520044f, -0.06037043f, -0.00950781f, -0.06191220f, -0.02252724f, 
    0.04766853f, -0.04430500f, -0.05140096f, -0.05792949f, 0.02412259f, 0.03204532f, 0.02297188f, 0.04107196f, 
    -0.14691833f, 0.26924402f, 0.08077244f, -0.12226344f, -0.20875247f, -0.04765929f, 0.02522501f, -0.01987128f, 
    -0.02243742f, -0.09004050f, 0.09158906f, 0.08426584f, 0.06893420f, 0.06792067f, 0.01784424f, -0.07720961f, 
    0.05489421f, -0.15467373f, 0.10806484f, 0.05763029f, -0.13909686f, -0.14213394f, 0.00869483f, -0.23418060f, 
    -0.23214427f, 0.07269862f, 0.00465887f, -0.02814538f, -0.07798490f, 0.08181399f, 0.06317323f, 0.04927826f, 
    0.08374679f, 0.02989277f, -0.00181357f, -0.06116373f, 0.05168884f, 0.03698809f, -0.06778827f, -0.02770786f, 
    -0.08497687f, 0.01015354f, 0.02275345f, 0.03175519f, 0.17356060f, 0.04638915f, 0.10746005f, -0.05482624f, 
    0.00126724f, -0.00995934f, 0.06694658f, 0.03784581f, 0.05379992f, 0.02126249f, 0.01894505f, -0.10096473f, 
    0.03991830f, 0.06227303f, 0.01224747f, -0.03014708f, 0.10679761f, 0.11399186f, -0.07742019f, 0.04304920f, 
    0.10205688f, 0.05214019f, -0.00017673f, -0.05062253f, -0.02656375f, -0.06890493f, -0.02417218f, -0.04812707f, 
    0.00095040f, 0.00258711f, -0.03735895f, 0.02082082f, 0.00831124f, 0.00220973f, 0.07160646f, 0.01534465f, 
    0.14985764f, 0.09973252f, 0.00467311f, 0.03050048f, 0.00116463f, -0.05159783f, 0.05955897f, 0.02795704f, 
    -0.07683527f, -0.04093369f, 0.01176497f, 0.01340585f, 0.08849907f, 0.03259541f, 0.01050339f, -0.06640315f, 
    -0.01474852f, 0.00026754f, 0.06164357f, -0.00088142f, 0.11506875f, -0.06422431f, -0.13793598f, 0.02481123f, 
    0.08532657f, 0.09969105f, -0.00816255f, -0.03619998f, -0.01602911f, -0.11457752f, 0.01876760f, 0.05466532f, 
    0.01548907f, 0.02114316f, -0.04795326f, 0.09288852f, 0.00738411f, 0.00171870f, 0.08284602f, 0.01303912f, 
    0.08475140f, -0.19825113f, -0.12691794f, 0.01102779f, 0.12161521f, 0.04779154f, 0.02794746f, 0.00580262f, 
    -0.06210963f, 0.02995790f, -0.00723824f, 0.05769715f, -0.04409428f, 0.06615885f, -0.00868306f, -0.03328333f, 
    0.05966127f, 0.05133611f, 0.02797923f, -0.03037219f, -0.10470283f, 0.12298957f, 0.12118810f, -0.02015754f, 
    -0.02555914f, -0.00647663f, -0.03030089f, -0.01406414f, 0.00531550f, -0.02055090f, -0.00456223f, -0.00556098f, 
    -0.03583213f, 0.02619299f, 0.04841094f, 0.00907019f, 0.02149166f, -0.04162544f, 0.02062795f, 0.04588728f, 
    0.02271806f, 0.06922406f, -0.08093034f, -0.06505943f, -0.13174975f, -0.01485908f, -0.03894234f, -0.03495925f, 
    -0.07566945f, -0.00726475f, 0.02016040f, 0.04176554f, -0.12098202f, 0.06020711f, 0.02976289f, 0.01201423f, 
    -0.06977656f, -0.06904029f, -0.10012449f, -0.03637993f, -0.12840027f, 0.07677972f, -0.01714333f, -0.16768253f, 
    -0.16105841f, -0.05691184f, 0.01880846f, -0.02678155f, -0.04952843f, -0.09381879f, 0.06938802f, 0.06463231f, 
    0.06229145f, 0.03186506f, 0.02740546f, -0.06742345f, 0.05756944f, -0.09172155f, -0.01852572f, 0.02269867f, 
    0.06419375f, 0.10408665f, 0.07218169f, 0.01829298f, 0.13582958f, -0.05404577f, -0.02750438f, -0.03389139f, 
    -0.05562651f, -0.14684069f, 0.01692979f, -0.02580267f, -0.02532988f, -0.06102195f, 0.06433793f, -0.01329469f, 
    0.01043816f, 0.03898017f, 0.05396319f, -0.02506999f, -0.10917001f, -0.17344695f, 0.08994450f, -0.14797458f, 
    -0.08727269f, 0.02079160f, 0.00559220f, -0.00422969f, -0.03563791f, -0.03916586f, -0.01025780f, -0.01898482f, 
    0.04906570f, -0.00536980f, 0.03544988f, 0.02175326f, -0.07357791f, 0.00622537f, -0.11792023f, 0.04800513f, 
    -0.08984286f, -0.04718275f, -0.14496222f, -0.24454160f, -0.34228912f, 0.01171757f, -0.04005095f, -0.13195477f, 
    0.02124257f, -0.06128037f, 0.08815382f, 0.02160136f, -0.02143466f, -0.03426660f, 0.01584230f, -0.10307001f, 
    -0.01201241f, -0.21311320f, 0.03379797f, -0.00980034f, 0.05605887f, 0.04958319f, -0.04783478f, 0.05793195f, 
    0.10189100f, 0.04959597f, -0.00884357f, -0.07962494f, -0.04736220f, -0.04426230f, -0.03350659f, -0.00198780f, 
    -0.04283704f, -0.03112070f, -0.00848028f, -0.04337865f, -0.03825321f, -0.00641639f, 0.03097876f, 0.00423298f, 
    0.09334745f, -0.04664280f, -0.08143923f, 0.09606855f, 0.10314319f, 0.04887213f, 0.04092451f, -0.05963673f, 
    -0.01926344f, -0.02935529f, -0.02741250f, -0.02183389f, -0.04937655f, -0.00489265f, -0.02055073f, -0.07321052f, 
    -0.00815125f, 0.03884487f, 0.03254130f, -0.03181074f, 0.02534150f, -0.01984895f, -0.18240444f, 0.06140701f, 
    0.09210146f, 0.11225193f, 0.02357929f, -0.01377983f, -0.04154238f, -0.03726134f, -0.03146928f, -0.04862611f, 
    0.03204798f, 0.00984783f, -0.01332593f, 0.00308590f, -0.05704696f, -0.00209519f, 0.06314749f, -0.01729561f, 
    0.16489698f, -0.07020859f, -0.00952208f, 0.07637217f, 0.16418734f, -0.05931078f, -0.04377099f, -0.05381586f, 
    -0.14775336f, 0.03621028f, -0.11093585f, 0.05165615f, -0.00723334f, -0.02699134f, 0.05251796f, 0.04677730f, 
    -0.00320340f, -0.02347923f, 0.03695362f, -0.01225844f, -0.14279695f, -0.00804566f, 0.17856309f, -0.08875531f, 
    -0.05776189f, 0.00269916f, 0.02992310f, 0.02255599f, -0.02638799f, -0.04670885f, 0.00065743f, -0.02379413f, 
    0.04962513f, 0.09354428f, 0.02707101f, -0.02628164f, -0.00561388f, 0.03199430f, -0.18460859f, 0.02798773f, 
    0.02363174f, 0.07570951f, -0.03929670f, 0.05088770f, 0.01608444f, 0.02689031f, 0.04637431f, -0.02146219f, 
    -0.04838330f, -0.03610997f, 0.01949032f, -0.01280514f, -0.00023894f, 0.02166442f, 0.04917800f, -0.00149619f, 
    -0.00608190f, -0.00812202f, 0.11409244f, -0.00814125f, 0.02244336f, 0.09862872f, -0.26573133f, 0.07492458f, 
    -0.01652718f, -0.00709389f, -0.04736969f, -0.09980074f, -0.02992107f, 0.00802531f, 0.01781073f, -0.06534215f, 
    -0.00878512f, -0.02706948f, 0.06981914f, 0.00382141f, 0.01176430f, -0.03248721f, 0.04771611f, 0.01560395f, 
    0.06082800f, -0.08664314f, 0.07995175f, -0.00023681f, 0.12757786f, -0.02763967f, 0.03141795f, -0.05136934f, 
    -0.03829040f, 0.03630779f, -0.02502726f, 0.03882392f, -0.02642416f, -0.02574662f, 0.04163307f, -0.00465917f, 
    -0.00070317f, 0.03956902f, -0.02247893f, 0.00824273f, -0.10591041f, -0.08883718f, -0.14844051f, -0.18510486f, 
    -0.02376112f, 0.06926724f, 0.04236303f, -0.00660116f, -0.00558895f, -0.03999675f, 0.04386457f, 0.01198056f, 
    -0.00562881f, 0.00561943f, -0.05369075f, -0.01647481f, 0.09718401f, 0.01982569f, -0.01961404f, -0.02933457f, 
    -0.12234571f, -0.11154914f, -0.07137685f, -0.02757574f, 0.06046697f, 0.03661130f, -0.06599075f, -0.06079919f, 
    0.03056897f, -0.04754893f, 0.09809717f, -0.00466391f, 0.08824737f, -0.03642744f, 0.10570759f, -0.02964771f, 
    0.03532061f, 0.01427662f, -0.05254307f, -0.07993507f, 0.01429776f, -0.02567150f, -0.01735850f, -0.00784902f, 
    0.11517280f, 0.01560235f, 0.02989218f, -0.07249774f, -0.01377821f, -0.06163923f, 0.08262347f, 0.04583606f, 
    0.00778395f, -0.00176932f, -0.02714624f, -0.09533474f, 0.03003374f, 0.06877638f, 0.01812798f, -0.01626172f, 
    -0.07862321f, -0.03805121f, 0.13079429f, 0.02519135f, 0.01952663f, -0.09858602f, -0.04142259f, 0.02247720f, 
    -0.03682207f, -0.04562527f, 0.03921741f, -0.06742029f, -0.00395917f, -0.03302732f, -0.01710761f, 0.02142733f, 
    -0.00641262f, -0.06840318f, 0.06524905f, 0.01279796f, -0.09472410f, -0.22191471f, -0.20819527f, 0.07994679f, 
    0.17730793f, 0.07599757f, 0.05986794f, -0.03877514f, -0.01724378f, -0.04555409f, 0.04705517f, 0.01484237f, 
    0.06205491f, 0.01555764f, 0.05371724f, 0.01525155f, 0.01819878f, 0.04346716f, 0.02901199f, -0.05567470f, 
    0.06138563f, -0.11516916f, -0.08348089f, 0.07581459f, 0.10635993f, 0.13798854f, 0.03471940f, -0.03676753f, 
    -0.02047496f, -0.00532892f, -0.00959354f, -0.02157170f, -0.05640922f, 0.00793269f, -0.03420054f, -0.05566966f, 
    0.00625565f, 0.04770205f, 0.06376175f, -0.05408464f, 0.07681894f, 0.02646616f, -0.02966854f, 0.01798922f, 
    0.05249897f, 0.00395784f, -0.04799310f, -0.00166543f, 0.03291951f, -0.00613919f, 0.06070437f, -0.04049007f, 
    0.04286362f, -0.02499885f, -0.00140247f, 0.01358489f, -0.03400515f, 0.01470217f, 0.02150631f, 0.08371426f, 
    -0.11796285f, -0.08980466f, 0.22042046f, 0.01978936f, 0.12226660f, -0.06986389f, 0.03886330f, 0.08467247f, 
    -0.04904972f, -0.03070616f, 0.00073730f, 0.00853105f, 0.00101288f, 0.05074515f, 0.01729803f, 0.01468661f, 
    -0.00305141f, 0.01073466f, -0.01990078f, 0.08103875f, -0.14011037f, -0.27403966f, 0.07083779f, -0.07704638f, 
    -0.27096975f, -0.04110107f, -0.10017316f, -0.01991007f, -0.01304112f, 0.08070766f, 0.10772694f, 0.00851194f, 
    -0.00901424f, 0.05794129f, 0.05541584f, 0.01721631f, 0.01351226f, -0.02147319f, -0.06691007f, -0.00099184f, 
    0.09982828f, 0.08363412f, -0.20818064f, 0.11789271f, 0.03182472f, 0.06344611f, 0.01043556f, -0.04802609f, 
    0.01378121f, 0.03114438f, 0.03884115f, -0.05072771f, -0.00507019f, 0.10712808f, 0.01966588f, 0.07289308f, 
    0.09953489f, -0.10764220f, 0.09642191f, -0.08320934f, -0.01698860f, -0.09351159f, -0.11225352f, -0.14375226f, 
    0.12523070f, 0.07663842f, -0.06050091f, -0.02860000f, 0.00769006f, -0.14438544f, 0.05341934f, 0.05769834f, 
    -0.02597844f, -0.04276796f, -0.00043690f, 0.05488124f, 0.04648816f, 0.00331473f, -0.04838675f, -0.03976408f, 
    -0.08799915f, -0.05672187f, 0.10369510f, -0.17590451f, -0.05094830f, 0.04878311f, 0.10787336f, -0.06986937f, 
    -0.05494968f, -0.05158161f, -0.01616071f, 0.01591197f, -0.02230434f, -0.00392098f, 0.01964202f, -0.02914259f, 
    0.04887397f, -0.10959928f, 0.03212888f, -0.06193868f, 0.35422418f, 0.11167764f, -0.14505953f, -0.09349250f, 
    0.04151148f, 0.01925276f, -0.12261079f, -0.04023070f, 0.01598009f, -0.06276898f, -0.05271528f, -0.05576300f, 
    0.09566682f, 0.03974725f, 0.04468425f, 0.08615972f, 0.00473824f, 0.06795401f, -0.05408167f, 0.06654820f, 
    0.07606335f, 0.04636982f, -0.17020509f, 0.11226562f, -0.23744109f, 0.03511062f, 0.07732148f, 0.02579282f, 
    0.03865293f, 0.00699742f, -0.11282576f, -0.05534947f, 0.03692439f, 0.00944990f, 0.05909385f, 0.03812331f, 
    -0.00412601f, -0.08554203f, -0.09698669f, -0.04224373f, 0.01523206f, 0.17246869f, -0.04588663f, 0.04427637f, 
    -0.09525295f, -0.03338229f, -0.03275527f, -0.05125254f, -0.09127569f, 0.01232864f, 0.02304788f, -0.07969722f, 
    0.02709149f, 0.07229337f, 0.12310774f, 0.06003033f, 0.08094083f, 0.09216963f, -0.11013511f, 0.15108399f, 
    0.05246309f, -0.18142207f, -0.01524307f, 0.12314253f, 0.02179761f, -0.01482206f, -0.01359439f, -0.05604961f, 
    0.02726722f, 0.06924099f, 0.02820073f, 0.07960083f, -0.08337703f, -0.08813325f, 0.02866036f, -0.04185428f, 
    -0.01987777f, -0.00015943f, 0.00561929f, 0.01062558f, -0.29846090f, 0.16097964f, 0.18509935f, -0.03462940f, 
    -0.04415965f, 0.01362298f, -0.01448533f, -0.00896549f, -0.00058708f, -0.01330313f, 0.04890338f, -0.00897723f, 
    0.06262717f, 0.03012956f, -0.03049911f, 0.02683501f, 0.01970322f, 0.06655356f, -0.02730040f, -0.02899795f, 
    0.48025367f, -0.05938455f, -0.21502133f, -0.14286390f, 0.00126063f, 0.07581897f, 0.05900756f, 0.13390934f, 
    0.06316759f, -0.05775542f, -0.01161853f, 0.00890183f, 0.00967419f, 0.11328626f, -0.05197989f, 0.01784772f, 
    0.04184541f, -0.03313532f, 0.04742340f, -0.01126416f, -0.00471199f, 0.00272233f, -0.09127915f, -0.03583882f, 
    -0.05899760f, -0.01339183f, -0.03578895f, 0.06096398f, 0.00476014f, 0.05056334f, 0.06167594f, 0.02169598f, 
    0.10499456f, 0.00199034f, 0.01104315f, 0.05809617f, -0.11138289f, 0.10623875f, 0.11350910f, -0.02128010f, 
    0.20251857f, -0.03186021f, -0.17714579f, 0.02142789f, -0.01497264f, 0.07140373f, -0.01972089f, -0.00310633f, 
    -0.03952928f, 0.14843282f, -0.01324675f, -0.02905268f, -0.01589586f, -0.03312121f, 0.06216745f, -0.03475769f, 
    -0.08566378f, -0.05136847f, -0.01073478f, -0.03405769f, -0.08411825f, -0.25556624f, 0.04562423f, 0.00390634f, 
    -0.06115027f, -0.00603309f, -0.00082367f, -0.02627866f, 0.03546893f, -0.03915083f, -0.03715460f, 0.01887239f, 
    0.01445598f, 0.05441235f, 0.03365261f, 0.08540431f, 0.07790240f, -0.01947142f, 0.03221161f, 0.01457934f, 
    -0.22219566f, -0.06824576f, 0.20000722f, -0.04580023f, -0.12798847f, 0.10470422f, 0.01217175f, 0.00120607f, 
    0.04491793f, -0.03287114f, 0.01787302f, -0.02335349f, 0.02933403f, -0.02374095f, -0.07711782f, 0.03060482f, 
    0.04101200f, 0.01849015f, -0.00532034f, -0.03729309f, -0.05145486f, -0.15297681f, 0.00032640f, 0.11276358f, 
    0.00721513f, 0.02946570f, -0.02319861f, 0.01715397f, 0.00453674f, 0.00643099f, 0.02238982f, -0.03033640f, 
    0.10491003f, 0.06107144f, 0.05240421f, 0.00021468f, 0.00410458f, -0.08805972f, 0.01507362f, -0.00458361f, 
    0.11163071f, -0.31556562f, 0.20694301f, -0.18246271f, -0.05687298f, -0.06169106f, 0.03615797f, -0.03301268f, 
    0.03024211f, 0.04716769f, 0.00870597f, -0.03584845f, 0.06945723f, -0.12110560f, -0.04143500f, -0.01304413f, 
    -0.00704126f, -0.04329596f, 0.00520460f, 0.06455969f, 0.17036368f, -0.31152391f, 0.02032584f, 0.17003401f, 
    -0.03881881f, -0.01185715f, -0.00004977f, 0.05313812f, 0.03535774f, 0.03648097f, 0.01253572f, 0.00297546f, 
    0.03234003f, -0.00974485f, -0.03651713f, -0.00408272f, -0.02560333f, -0.01999860f, 0.02755456f, 0.07097240f, 
    0.21140307f, 0.05013693f, -0.14060359f, -0.26862827f, -0.01457479f, 0.02183623f, -0.01342865f, -0.01778589f, 
    0.04862077f, 0.03733165f, -0.04172067f, 0.00162351f, 0.05899300f, -0.00967143f, -0.06796199f, 0.10723399f, 
    0.09593023f, 0.08069526f, -0.00427273f, -0.03236137f, 0.00747759f, 0.03663635f, 0.08630276f, -0.04875169f, 
    -0.06715972f, -0.11868613f, -0.02409199f, 0.09558801f, 0.05931587f, 0.01375990f, -0.00218497f, -0.03807023f, 
    -0.00844007f, 0.00069942f, 0.04081331f, -0.00607257f, 0.04154099f, -0.06926302f, -0.01179000f, -0.03171211f, 
    0.00792970f, -0.11613566f, 0.14147373f, -0.12894362f, -0.11951917f, -0.04750439f, 0.07077975f, -0.00836852f, 
    -0.00683035f, 0.02828840f, -0.00662591f, -0.07587325f, 0.03106398f, -0.07011103f, -0.00351473f, -0.10891558f, 
    0.04397233f, 0.07325725f, -0.01203906f, -0.07529709f, 0.15531895f, -0.10299344f, -0.15879290f, 0.06934729f, 
    -0.20272326f, 0.05942309f, 0.10490220f, 0.02229688f, -0.00289358f, 0.02966283f, -0.13430174f, 0.07035779f, 
    -0.00328811f, 0.10304116f, -0.01472964f, -0.03968692f, -0.05368882f, -0.07785172f, 0.02461474f, -0.01804903f, 
    -0.01918036f, -0.12278332f, -0.03765521f, 0.17729054f, 0.07928295f, -0.02932533f, -0.01470697f, 0.02390273f, 
    -0.06351821f, 0.02661523f, 0.03380189f, -0.00285607f, 0.05865072f, -0.02355218f, -0.01290950f, 0.05916625f, 
    -0.01793025f, -0.01496430f, 0.06257606f, -0.01997831f, -0.36655578f, 0.03831558f, 0.04038513f, 0.06813897f, 
    -0.04857384f, -0.07215273f, 0.04337468f, -0.01327713f, 0.05108444f, 0.00473828f, 0.04720027f, -0.02990583f, 
    0.02647974f, 0.04040661f, 0.13336980f, 0.05116092f, -0.02138383f, 0.10643446f, 0.04123665f, -0.01726527f, 
    0.01817558f, -0.06963718f, -0.04128945f, 0.01018949f, 0.11861500f, 0.08730148f, -0.08673691f, 0.04128158f, 
    -0.07625557f, 0.20917018f, 0.03270179f, -0.03375252f, 0.06075067f, 0.10160965f, 0.00180662f, -0.01557798f, 
    0.01935966f, 0.00757479f, -0.00298043f, -0.07807420f, -0.38166076f, 0.32813269f, 0.23754382f, 0.12654734f, 
    0.07130813f, 0.09135458f, 0.03167758f, 0.08244154f, 0.02156413f, -0.06795623f, 0.05828202f, -0.02098251f, 
    0.11688661f, 0.03979631f, 0.05813035f, 0.11348156f, -0.02869429f, 0.10887830f, -0.14004031f, 0.05621844f, 
    -0.28526986f, 0.09409252f, 0.17295890f, 0.04930340f, 0.10613147f, 0.04500977f, 0.00240196f, -0.00954665f, 
    0.05055993f, -0.05185831f, -0.01101117f, -0.00352990f, -0.04274847f, 0.08426584f, -0.06767933f, 0.08396564f, 
    0.01156134f, 0.05242144f, -0.06954328f, 0.05926081f, 0.18384874f, -0.07897337f, 0.01018383f, -0.19586872f, 
    -0.07318448f, -0.02901853f, 0.00406814f, 0.12997973f, -0.08785804f, -0.04765258f, 0.03128704f, 0.00828548f, 
    0.05223372f, -0.03831301f, 0.04602771f, -0.01357426f, 0.05838743f, -0.01836135f, 0.12627536f, 0.08951757f, 
    -0.00533189f, -0.08243664f, -0.07243422f, 0.08294740f, -0.13262096f, 0.03258174f, 0.04657049f, -0.03742408f, 
    0.01990338f, 0.01665959f, -0.07548409f, -0.02305301f, -0.02335883f, 0.04770181f, 0.04198714f, 0.04653260f, 
    0.03709109f, 0.07455358f, 0.00367237f, 0.04025604f, -0.05953072f, -0.08089170f, -0.03525477f, -0.07177538f, 
    -0.00422342f, -0.17371945f, 0.08376542f, 0.14784825f, 0.06241760f, -0.06665731f, 0.03715750f, -0.04995554f, 
    -0.08514063f, -0.11020444f, -0.07877447f, 0.05697278f, -0.02522386f, 0.05021860f, 0.03389842f, 0.09913431f, 
    0.15879840f, 0.12742689f, -0.08567900f, -0.34769461f, -0.13860515f, 0.04338401f, 0.01371017f, 0.01524234f, 
    -0.00087671f, 0.01785582f, -0.11034460f, 0.00983375f, 0.03998658f, -0.00474638f, 0.07800195f, -0.00740204f, 
    0.07830722f, -0.01921810f, 0.13002582f, -0.00577491f, 0.39784676f, 0.01960202f, -0.13515030f, -0.12082205f, 
    -0.03903969f, -0.07505143f, 0.00117938f, 0.16843827f, 0.04300700f, -0.07181296f, 0.08330677f, -0.08259874f, 
    -0.00042264f, -0.02615345f, -0.03600976f, 0.10893828f, 0.05079939f, 0.03097305f, 0.00770287f, 0.07484158f, 
    -0.08048369f, 0.06908164f, -0.02134627f, 0.10586117f, -0.04463703f, 0.07057619f, 0.10811105f, 0.00762849f, 
    -0.00928630f, -0.14500837f, 0.01445034f, 0.01595878f, -0.02203526f, 0.01410862f, 0.02749780f, -0.01081785f, 
    -0.00681604f, -0.00282663f, 0.01802359f, 0.01824887f, -0.12755293f, -0.14402041f, 0.04181616f, -0.02352474f, 
    -0.05801152f, -0.07836505f, 0.06034101f, -0.01323253f, -0.01800555f, 0.00984712f, -0.02979049f, 0.03056012f, 
    0.03321143f, -0.02081552f, -0.02223740f, 0.02371715f, 0.01264661f, -0.02140791f, 0.04178905f, 0.04866776f, 
    0.06922115f, -0.17399086f, -0.07758176f, -0.17120036f, -0.31201974f, -0.09694589f, 0.01677329f, -0.01242755f, 
    0.11679145f, -0.03065808f, -0.05930053f, -0.08286110f, -0.00415401f, 0.10386242f, -0.00178033f, -0.03397718f, 
    0.10514431f, 0.09687085f, 0.06262703f, -0.01482368f, -0.08299067f, -0.16574316f, -0.09435030f, -0.03967282f, 
    -0.10509858f, -0.03077723f, 0.06004684f, -0.00110216f, 0.01328859f, -0.01320958f, 0.02442897f, -0.02763140f, 
    0.02294285f, 0.15085246f, 0.05453000f, 0.00519038f, 0.01313744f, -0.05141305f, 0.00542198f, -0.08079813f, 
    -0.17214955f, 0.11198667f, -0.00688636f, 0.20982698f, 0.01820702f, 0.05940494f, 0.02708063f, -0.06595651f, 
    -0.05756371f, 0.04220198f, -0.02810909f, -0.00068195f, 0.04678219f, 0.00453661f, 0.07910961f, 0.05711668f, 
    -0.03744784f, 0.00035524f, -0.05945592f, 0.01521399f, 0.14776395f, -0.10857024f, 0.00288841f, -0.09498266f, 
    0.01032863f, -0.08094506f, 0.05502415f, 0.04106057f, 0.01072657f, -0.06262563f, 0.01062316f, -0.07017271f, 
    0.00346776f, 0.13122365f, -0.07043343f, -0.01079278f, 0.04702901f, 0.06555469f, 0.01844312f, 0.07444388f, 
    0.07738127f, -0.04624700f, 0.02833967f, -0.17923898f, -0.10140755f, -0.01050034f, 0.08040640f, -0.08530559f, 
    -0.08179612f, -0.02004189f, -0.01834403f, -0.04665079f, -0.05889537f, -0.04540908f, -0.02324627f, 0.05256175f, 
    0.07380826f, -0.16907786f, -0.08376244f, -0.04813312f, -0.08862288f, 0.03573562f, 0.09409450f, -0.10650371f, 
    -0.01538173f, 0.07831570f, 0.03205071f, 0.00565000f, -0.07595763f, -0.08527606f, 0.00832613f, 0.05604718f, 
    -0.01188393f, 0.04414922f, -0.01411719f, -0.02675294f, 0.04088752f, -0.01698919f, -0.00469811f, 0.04428009f, 
    0.06784856f, 0.29991579f, -0.14181143f, -0.19627774f, -0.13464963f, 0.00972750f, 0.00174347f, -0.03366828f, 
    0.11055987f, -0.03351477f, 0.01015925f, 0.04274268f, 0.01221816f, -0.01632625f, 0.01480593f, -0.02285111f, 
    -0.04359136f, 0.09882160f, -0.05848861f, -0.04827731f, 0.09603233f, -0.23906215f, 0.20852108f, -0.04352133f, 
    -0.17568548f, 0.05869895f, 0.01923846f, -0.06095182f, -0.03519421f, 0.05065043f, 0.00813855f, -0.00183909f, 
    -0.01450955f, -0.02019654f, 0.10494515f, -0.03416087f, -0.04422874f, -0.06403584f, 0.12698160f, 0.14155670f, 
    -0.13572061f, -0.20398559f, 0.17679296f, -0.10173589f, -0.17240910f, 0.08997918f, 0.02683012f, 0.04807277f, 
    -0.04634079f, -0.05077147f, -0.04906928f, -0.02637267f, -0.03667813f, -0.00619949f, 0.01344441f, -0.10041856f, 
    0.04760607f, 0.02181259f, 0.06953205f, -0.02977813f, -0.17567858f, -0.11841765f, -0.04334297f, 0.06426198f, 
    -0.03400807f, 0.00617081f, 0.04091087f, -0.10898923f, 0.00118545f, 0.05388715f, -0.02851992f, 0.06025940f, 
    0.06067107f, -0.05907906f, 0.08573079f, -0.03915890f, -0.05731735f, -0.06195524f, -0.02224291f, -0.06129710f, 
    0.07331373f, -0.17331928f, -0.02560156f, 0.19260016f, -0.00806627f, -0.11942995f, 0.04061737f, -0.01784566f, 
    -0.05164023f, 0.04631274f, 0.00463068f, 0.01378116f, 0.05097537f, -0.02033287f, 0.00281416f, -0.03317136f, 
    0.07139281f, 0.01663278f, 0.06126400f, 0.06649566f, -0.06160085f, 0.02375313f, 0.04090192f, -0.03118860f, 
    -0.11584093f, 0.04499152f, 0.07240807f, -0.00935622f, -0.02703578f, -0.06839447f, -0.11541025f, -0.02696707f, 
    -0.05137593f, -0.01327192f, 0.09118206f, -0.01824803f, -0.02278695f, 0.01059084f, -0.03862262f, 0.04619575f, 
    0.49100050f, -0.04243636f, -0.06528755f, -0.16608922f, 0.03350344f, 0.08248322f, 0.01936088f, 0.02356862f, 
    -0.08829774f, -0.01215394f, -0.09174784f, 0.06310989f, -0.01777514f, 0.10377431f, -0.09876674f, 0.00541597f, 
    0.04740391f, -0.13418129f, 0.00140049f, -0.01787193f, 0.01699947f, 0.02632488f, -0.03706139f, -0.05899684f, 
    0.05168508f, 0.00661500f, -0.03368601f, 0.02976706f, -0.00954134f, 0.02658604f, 0.00915697f, -0.00119376f, 
    -0.05627512f, -0.07754183f, -0.01429102f, 0.08386021f, 0.03848143f, 0.00061947f, 0.05350278f, 0.05024373f, 
    -0.39476335f, -0.04074828f, 0.10230421f, 0.19127050f, -0.00393966f, -0.05594813f, 0.01631519f, 0.03898902f, 
    -0.00768593f, 0.02097303f, -0.05239688f, -0.06076013f, -0.08442951f, 0.06972446f, -0.06287375f, 0.14690952f, 
    -0.04508163f, 0.00260485f, 0.07258123f, 0.08686654f, 0.07205978f, -0.26848146f, 0.04058768f, 0.05598909f, 
    -0.12810113f, -0.05496810f, -0.01000052f, -0.07357354f, -0.00933139f, -0.09460521f, -0.12658791f, 0.05988624f, 
    0.06873094f, -0.04082098f, -0.01342939f, -0.00928082f, 0.07432814f, -0.15244779f, -0.08869948f, 0.01605652f, 
    -0.00675857f, -0.12310638f, 0.10189488f, 0.02406997f, -0.06544235f, 0.02167217f, 0.12149268f, -0.00739076f, 
    -0.00135857f, -0.06390671f, -0.07418963f, 0.04551803f, -0.07934105f, 0.01271982f, -0.01668037f, 0.01381443f, 
    0.05123558f, -0.04806162f, 0.03315346f, -0.00717748f, -0.02720178f, -0.04187391f, 0.17328355f, -0.05057256f, 
    -0.18840285f, 0.00890374f, 0.09345531f, -0.04156219f, -0.10712031f, 0.06285185f, -0.02122173f, -0.04039655f, 
    0.00520501f, -0.09461183f, -0.03720760f, -0.02892571f, -0.06523222f, 0.09737437f, -0.07441492f, -0.03334954f, 
    0.23646188f, -0.14152566f, -0.05129980f, 0.06144415f, -0.03387870f, 0.02884680f, -0.06113899f, -0.08008282f, 
    0.10127214f, -0.01946963f, -0.12161794f, 0.04689238f, -0.03954155f, -0.06578362f, -0.04917778f, 0.03445589f, 
    0.03860844f, 0.05265572f, -0.00703629f, 0.03513354f, -0.02215925f, -0.25763273f, 0.02752704f, 0.11741063f, 
    -0.09300133f, -0.08253183f, 0.00223259f, -0.04280126f, 0.08717182f, 0.00022848f, -0.01899743f, -0.00321991f, 
    0.04922443f, -0.06881215f, 0.03107280f, -0.02636876f, 0.06761547f, 0.01510314f, 0.08471038f, 0.01851948f, 
    -0.11905865f, 0.20946968f, 0.14308125f, -0.16519254f, 0.03734928f, 0.02938772f, 0.08063205f, -0.00692677f, 
    -0.03828676f, 0.05991274f, -0.00139708f, 0.04024943f, 0.01436178f, -0.03894349f, 0.04247681f, 0.05483492f, 
    0.02087317f, 0.09876268f, -0.11646699f, 0.03260140f, 0.16160922f, -0.37276471f, 0.08470733f, -0.11102043f, 
    0.28896031f, -0.00491273f, 0.00181827f, -0.04451898f, 0.01304619f, -0.12754750f, 0.01013903f, -0.11261703f, 
    -0.05788140f, 0.02142096f, 0.02000209f, 0.04096958f, 0.03986584f, -0.07138597f, -0.06321020f, 0.10149585f, 
    0.20301759f, -0.28805801f, 0.14426614f, 0.07417449f, 0.02881925f, 0.01772575f, 0.01833836f, 0.00730667f, 
    -0.01607002f, -0.07522163f, -0.01708333f, -0.02271676f, 0.07147018f, -0.03537665f, 0.00467683f, 0.04954698f, 
    0.00210657f, 0.02220854f, -0.03056671f, 0.02488423f, -0.03691765f, 0.02616058f, 0.04883701f, -0.21873613f, 
    -0.34103680f, -0.09309410f, -0.04054730f, -0.00813913f, -0.03036778f, 0.07494208f, -0.05624206f, 0.02709612f, 
    -0.03853276f, -0.08300387f, -0.00124946f, -0.04872235f, -0.00883951f, -0.02994463f, 0.01307818f, -0.05552961f, 
    -0.09647222f, -0.27596745f, 0.10648192f, -0.15104860f, -0.01345661f, -0.10545509f, 0.05001840f, -0.12865525f, 
    -0.04676501f, 0.07189143f, -0.05714944f, -0.05009711f, -0.01645136f, 0.00478113f, 0.01089590f, 0.08925371f, 
    0.08707973f, -0.06951304f, -0.10655547f, -0.08684368f, 0.07350182f, -0.06533987f, -0.05137465f, 0.01349201f, 
    -0.18335909f, -0.00375070f, 0.05343730f, 0.13910615f, -0.06086183f, -0.08394593f, 0.01590526f, -0.04357739f, 
    -0.04503213f, -0.00234577f, -0.04996785f, 0.02461298f, -0.01671342f, -0.07333261f, -0.05724417f, -0.00837137f, 
    -0.05241941f, -0.20352839f, -0.05892359f, 0.14503507f, 0.05571216f, 0.00458016f, -0.05742972f, -0.07142757f, 
    0.02959937f, 0.15827006f, -0.01938298f, 0.01275424f, -0.04855599f, -0.00678448f, -0.05862214f, -0.11481701f, 
    -0.12566353f, -0.01494791f, -0.04716853f, -0.02032121f, 0.01130864f, -0.21244407f, 0.07968666f, -0.15803060f, 
    -0.10795743f, -0.07000549f, 0.06886142f, -0.11158609f, -0.02726704f, 0.05104259f, -0.03384131f, 0.02612175f, 
    0.02919415f, -0.07441340f, -0.10672186f, -0.07610208f, -0.00656212f, 0.01619369f, -0.01124757f, -0.01256060f, 
    0.07906026f, -0.08907111f, 0.12293214f, -0.01710307f, -0.19326639f, -0.01096485f, 0.09210533f, 0.01194102f, 
    -0.06451016f, -0.02984046f, -0.04464062f, 0.00325394f, -0.02175427f, -0.04823665f, -0.01465423f, -0.02889429f, 
    -0.03627710f, 0.03588179f, 0.01461877f, -0.01396719f, -0.03609180f, -0.01695308f, -0.00945303f, -0.10107370f, 
    -0.09085360f, -0.01953997f, 0.02751029f, -0.00910976f, -0.02575270f, -0.02725309f, 0.03212787f, -0.06228732f, 
    0.06412145f, 0.01930753f, -0.01890589f, 0.02199213f, -0.02496967f, -0.08898105f, -0.03659955f, -0.09688305f, 
    0.16260752f, -0.13154863f, -0.09642317f, 0.11517401f, 0.02643902f, -0.00320759f, 0.00223565f, -0.07886617f, 
    0.03431130f, 0.06593709f, 0.05618543f, 0.03896242f, 0.04161003f, -0.05931183f, 0.07005954f, -0.03932915f, 
    0.02092579f, -0.00101695f, 0.05485130f, -0.03263344f, -0.37455693f, -0.09424376f, -0.07400382f, 0.19319981f, 
    0.24473584f, -0.00693753f, -0.02569690f, -0.00506281f, -0.01639527f, 0.11159709f, -0.01838306f, -0.01119054f, 
    -0.01323084f, -0.03678211f, -0.04752029f, 0.10071604f, 0.06104814f, -0.04701522f, 0.06462353f, -0.00288334f, 
    -0.30564308f, -0.15971307f, 0.11910143f, -0.02704294f, 0.19717531f, 0.03143279f, -0.01287158f, -0.13673553f, 
    -0.04122712f, 0.02623444f, 0.08927006f, -0.03857695f, -0.10684395f, 0.07913776f, -0.04192079f, 0.06856844f, 
    -0.02313290f, 0.02698647f, -0.08384169f, 0.09349100f, -0.06061463f, 0.00377516f, 0.06132262f, -0.19505894f, 
    -0.08766957f, -0.07838818f, 0.00513285f, -0.01256562f, 0.03655270f, 0.08944865f, 0.06696501f, 0.01845220f, 
    0.13714097f, -0.06583880f, -0.08950961f, -0.04234899f, -0.12164664f, 0.04739863f, 0.09577096f, 0.07218947f, 
    -0.42585820f, -0.18399760f, -0.12969248f, -0.19131035f, -0.07828035f, 0.07783139f, 0.02288223f, -0.08610929f, 
    -0.00790051f, 0.05488827f, -0.01378856f, 0.01336507f, 0.00651958f, -0.01989132f, 0.07019450f, -0.06654884f, 
    -0.02564238f, 0.11076745f, 0.04004745f, 0.03172684f, -0.03299558f, 0.03458705f, 0.04681582f, -0.04146397f, 
    0.00615551f, -0.00829073f, 0.01404374f, 0.05718277f, 0.07878238f, 0.05301255f, 0.01430306f, 0.06102596f, 
    0.06397008f, -0.01712071f, 0.00044690f, -0.00057312f, 0.00045371f, 0.00959650f, -0.01397542f, 0.00277259f, 
    -0.30138347f, -0.20880805f, 0.10316078f, 0.05161810f, -0.13478713f, 0.09007750f, -0.01637232f, 0.10639215f, 
    -0.01443170f, 0.04989296f, 0.10722353f, 0.04493162f, 0.01585461f, -0.06877629f, 0.07788042f, -0.01672822f, 
    -0.04769770f, -0.09695866f, 0.02676783f, 0.00090910f, -0.20553860f, -0.20173684f, 0.03955383f, -0.03855229f, 
    0.08985848f, 0.04491487f, 0.02884188f, -0.01061486f, -0.02084409f, 0.05158670f, 0.03338854f, 0.06102451f, 
    -0.03830037f, -0.01771544f, -0.02341167f, 0.02846498f, -0.06720141f, -0.21443217f, -0.11355041f, 0.03604684f, 
    0.14144988f, 0.07715262f, -0.02695114f, -0.01606907f, -0.05250159f, -0.08841046f, -0.04650672f, 0.07465919f, 
    0.04705779f, 0.00671249f, -0.05358385f, -0.01107978f, -0.00061674f, -0.03966583f, -0.02237483f, 0.00832071f, 
    0.07436053f, 0.00917625f, -0.00536041f, 0.06060180f, -0.20289807f, -0.19157624f, 0.04953664f, 0.06534777f, 
    0.02868237f, 0.05371242f, 0.04553916f, 0.03228652f, -0.02873146f, -0.08256554f, 0.06392279f, 0.05918862f, 
    0.02642732f, -0.00246074f, 0.04374897f, -0.01642368f, -0.01170626f, 0.00621998f, -0.02205499f, -0.05856109f, 
    -0.17956409f, 0.05022309f, 0.19768682f, 0.14648165f, -0.02965518f, -0.00067359f, -0.01306670f, 0.00982050f, 
    0.00346011f, 0.04900222f, -0.03716714f, -0.03263000f, 0.04305793f, -0.09516966f, 0.01144500f, -0.01973915f, 
    -0.05973842f, 0.06640895f, 0.04425080f, 0.03864631f, 0.09981029f, 0.22840235f, 0.04564939f, -0.06599958f, 
    0.04684581f, 0.03368627f, -0.00309022f, 0.08725648f, -0.03547119f, 0.08592877f, -0.03747493f, -0.02891167f, 
    0.01005462f, -0.01451006f, 0.02940885f, -0.00694319f, 0.09277821f, 0.04538827f, -0.05811699f, 0.07369750f, 
    0.25919354f, 0.13164036f, -0.00703042f, -0.00811673f, -0.03437963f, -0.20450024f, -0.14633253f, -0.03523530f, 
    0.06105501f, -0.09408675f, -0.05406602f, -0.02974685f, -0.03638908f, -0.06948663f, -0.07386281f, -0.05901308f, 
    -0.00322573f, 0.06909394f, -0.08200684f, -0.02845623f, 0.07419185f, 0.01059698f, 0.05292723f, 0.05501056f, 
    0.17214426f, 0.08550618f, 0.04311517f, 0.03141521f, 0.03782853f, -0.08189600f, -0.04270426f, 0.07460554f, 
    0.00033544f, 0.00607335f, 0.03313465f, -0.04545228f, 0.06233559f, -0.02586480f, -0.01282804f, -0.03966625f, 
    -0.37466154f, -0.26378489f, -0.12390453f, 0.02533526f, 0.24359134f, 0.01433955f, 0.03226737f, -0.06785449f, 
    -0.04082767f, -0.08275284f, 0.03362279f, -0.04344836f, -0.02404348f, 0.03121544f, -0.02715616f, 0.00459096f, 
    0.10864600f, 0.11073319f, 0.07262694f, 0.00918229f, -0.10220817f, 0.05678996f, -0.05089543f, -0.05897169f, 
    0.05627628f, 0.03680778f, 0.07624748f, -0.03835256f, 0.04069730f, -0.04576755f, -0.00996159f, 0.05961079f, 
    -0.00787586f, 0.01107743f, -0.00653960f, -0.00554618f, 0.00073047f, 0.06327115f, -0.03286582f, 0.04528131f, 
    -0.15795282f, 0.08636083f, -0.06577540f, -0.03894686f, 0.04505326f, 0.05423509f, -0.01892356f, -0.00781406f, 
    0.03358878f, 0.08322856f, 0.01814675f, 0.05222638f, -0.01103268f, 0.06711756f, 0.01895923f, 0.12188912f, 
    -0.01447299f, 0.09339974f, -0.07798018f, 0.06353873f, 0.13946408f, 0.07175565f, 0.05023955f, 0.11306806f, 
    -0.04974844f, -0.10744975f, -0.03338451f, -0.02157590f, 0.03064963f, 0.01427160f, -0.03131728f, 0.02205355f, 
    0.05026905f, -0.09107787f, 0.10006405f, 0.05040395f, -0.00064018f, 0.06553310f, -0.01529982f, 0.00155888f, 
    -0.14687875f, 0.03488725f, 0.09246907f, 0.04411604f, -0.06634711f, 0.06382841f, 0.05318877f, 0.01492049f, 
    -0.00881455f, 0.02437378f, -0.00585909f, 0.00879237f, 0.05170930f, 0.00564029f, -0.00354081f, -0.02581378f, 
    -0.00293401f, -0.01421135f, 0.05671432f, 0.03168899f, 0.06763466f, -0.10344409f, -0.05345080f, -0.05913221f, 
    0.11994731f, 0.00624444f, 0.00261293f, 0.06154947f, -0.02639234f, -0.00187198f, -0.00461353f, -0.01567412f, 
    -0.03076886f, 0.00644707f, 0.05792457f, -0.00203079f, 0.09873771f, 0.10090208f, 0.08826714f, 0.05956955f, 
    -0.08413240f, 0.00335958f, -0.03681150f, 0.02613256f, -0.00210506f, 0.10612317f, -0.01547826f, 0.00735440f, 
    0.00020841f, -0.05660474f, -0.01127041f, 0.06238633f, 0.05859650f, 0.10125095f, 0.05750712f, -0.01684869f, 
    -0.00616022f, -0.06865013f, -0.06964362f, -0.01144955f, -0.10304415f, -0.13864128f, 0.02516080f, -0.00712863f, 
    -0.04260517f, 0.00784069f, 0.01997628f, -0.00903589f, -0.00135613f, 0.01508119f, 0.05378263f, -0.01145741f, 
    0.04128099f, -0.05414927f, 0.03531588f, 0.01439741f, -0.00103991f, 0.04683851f, 0.03784061f, 0.08341311f, 
    0.20633323f, 0.14014475f, -0.03784407f, -0.01197692f, -0.05287841f, 0.06422170f, -0.02396752f, 0.09734201f, 
    -0.00777213f, 0.01693715f, 0.00209573f, 0.01989891f, 0.01533864f, -0.02168116f, -0.02926636f, 0.08001547f, 
    0.05445754f, -0.04624771f, -0.03123116f, -0.00230435f, -0.36872631f, -0.36283484f, 0.00411203f, -0.00835987f, 
    0.20851263f, 0.01757714f, 0.05661674f, 0.00527935f, -0.03276348f, -0.09355891f, 0.02661352f, 0.01046871f, 
    -0.02797492f, 0.01163623f, 0.08025840f, -0.04218141f, -0.00821564f, -0.11825007f, -0.09079610f, 0.00917821f, 
    0.15452892f, 0.15956506f, -0.15111636f, 0.06537128f, -0.05784940f, -0.05806893f, -0.09840274f, -0.04202304f, 
    0.01819601f, -0.00258337f, 0.00413996f, 0.01623520f, -0.05944311f, -0.06314062f, -0.04311011f, -0.04513345f, 
    -0.05464565f, 0.04404443f, 0.00481436f, 0.00200378f, -0.19913615f, -0.21973020f, -0.16994457f, -0.04154469f, 
    0.05294315f, -0.01946641f, 0.00944845f, 0.00569790f, -0.07634132f, -0.00907156f, 0.11647990f, -0.07060958f, 
    -0.07590383f, -0.12127082f, 0.02174561f, -0.00778707f, 0.01347447f, -0.02501250f, 0.10653990f, 0.01368214f, 
    -0.14701188f, -0.03400077f, -0.10705386f, 0.05301137f, -0.01142374f, 0.02173914f, 0.03286767f, -0.04031612f, 
    0.00418227f, 0.07019959f, 0.02372627f, 0.00984338f, 0.06432780f, -0.05949651f, 0.03949580f, 0.05109483f, 
    -0.04623462f, -0.03803232f, 0.06590478f, 0.01709633f, 0.05900981f, 0.16760378f, 0.05305638f, -0.05602938f, 
    -0.06925325f, 0.09344834f, 0.04466229f, 0.01935776f, 0.04660053f, -0.04330982f, -0.02784413f, 0.06526624f, 
    0.02891634f, 0.06179674f, 0.02359842f, 0.05148014f, 0.05245200f, -0.00686294f, -0.05719536f, 0.05199255f, 
    -0.03807165f, 0.00640691f, 0.01056688f, -0.04400550f, 0.01284272f, 0.03505313f, 0.03872469f, 0.06968639f, 
    0.01054745f, 0.00346431f, 0.02079822f, 0.04402262f, 0.03816430f, 0.04834314f, -0.00262470f, 0.00979243f, 
    -0.00492822f, 0.00899308f, -0.09128904f, 0.06465437f, 0.28817213f, 0.14683490f, 0.06521467f, 0.06225435f, 
    0.00013463f, 0.05434853f, 0.02765959f, -0.04006184f, -0.00106002f, 0.00685992f, -0.11194735f, 0.01084059f, 
    0.04424337f, -0.00498492f, -0.00228176f, 0.02595203f, 0.04352535f, -0.24934323f, -0.10439069f, -0.05075311f, 
    -0.15688547f, -0.13008974f, -0.04505232f, -0.05462437f, -0.14175174f, 0.03356758f, -0.00722051f, -0.01787468f, 
    0.02466260f, 0.05179679f, 0.03538578f, 0.01073609f, 0.03965507f, 0.04131234f, 0.02307807f, 0.03511281f, 
    0.11159539f, 0.05933090f, 0.07289317f, 0.09956934f, -0.31086740f, -0.00328276f, 0.09306905f, 0.02184809f, 
    -0.06668003f, 0.09367310f, -0.05479676f, -0.00177761f, -0.00989713f, 0.03259094f, -0.13388835f, -0.01800397f, 
    0.00844528f, -0.08412308f, 0.01455681f, -0.10128556f, 0.06630588f, -0.03498555f, -0.04092411f, 0.00068972f, 
    -0.26917920f, -0.16672564f, -0.11185858f, -0.03759792f, -0.11537898f, 0.04704098f, 0.07557460f, -0.00637794f, 
    -0.06133313f, 0.02289883f, 0.02776073f, -0.08335511f, -0.01942886f, -0.03959851f, 0.01462792f, -0.05656617f, 
    0.04569309f, 0.03639202f, 0.12222264f, 0.05094434f, 0.20884296f, 0.01429666f, 0.05897715f, 0.05912485f, 
    0.02878449f, 0.02193986f, 0.04169679f, 0.03299213f, 0.03985470f, 0.02021734f, -0.07314767f, 0.01449241f, 
    -0.00213725f, 0.01087146f, -0.02090795f, 0.03159891f, 0.03868788f, -0.20466347f, -0.02326399f, -0.00876671f, 
    -0.27670690f, -0.08844712f, 0.15455703f, -0.09802174f, -0.23627453f, 0.06266285f, -0.00200008f, 0.03980858f, 
    -0.06689312f, 0.01877266f, 0.02488815f, 0.02645222f, 0.06812787f, -0.07928538f, 0.04354008f, -0.04200618f, 
    -0.00674689f, -0.12774640f, -0.13831398f, -0.06145897f, -0.14283371f, 0.00826028f, -0.15988295f, -0.06658547f, 
    0.05606675f, -0.01111180f, 0.03374275f, -0.07384451f, -0.01420252f, -0.01233455f, 0.02310684f, 0.03195739f, 
    -0.02785345f, -0.02437882f, 0.10163822f, -0.01812673f, -0.00942837f, 0.16422285f, 0.02997680f, 0.00747629f, 
    -0.03730506f, -0.06283101f, -0.02966934f, -0.05206973f, 0.11488062f, 0.06613239f, -0.06994104f, 0.06542724f, 
    -0.03983508f, 0.04568839f, 0.00367664f, -0.01857197f, 0.02756186f, 0.01315122f, -0.01196937f, -0.00432535f, 
    -0.01267213f, -0.14139247f, 0.04828561f, 0.00462164f, -0.00291708f, -0.05446162f, 0.03262074f, -0.00047754f, 
    0.03715875f, -0.04522549f, -0.01271289f, -0.09919227f, -0.00038898f, -0.02235948f, -0.04974402f, 0.04885584f, 
    -0.05441683f, -0.05961702f, -0.02676504f, 0.05759866f, -0.09009808f, -0.17040795f, -0.18045519f, 0.01356188f, 
    -0.37788025f, -0.21700461f, 0.01897498f, -0.14309382f, -0.20062053f, 0.07891981f, 0.01040319f, -0.00424341f, 
    -0.10634515f, 0.04919595f, 0.00792822f, -0.02891516f, -0.00266099f, 0.04771908f, -0.03044217f, 0.02168207f, 
    -0.14717413f, -0.02398873f, 0.02533538f, -0.05885288f, -0.12249223f, -0.07941762f, -0.18830469f, -0.09412054f, 
    -0.05855338f, 0.01883548f, 0.04507214f, 0.00314580f, -0.03517693f, -0.00814133f, 0.06886631f, 0.00306669f, 
    -0.02737060f, -0.03671477f, 0.03914203f, -0.03033451f, 0.01811812f, 0.09070788f, 0.04694239f, 0.02401967f, 
    -0.22218099f, -0.28178495f, -0.08735897f, -0.09228115f, -0.15756853f, 0.11357886f, -0.03450935f, 0.01899771f, 
    -0.06485230f, 0.05104640f, 0.13250840f, -0.01907521f, -0.01672644f, -0.03258659f, -0.03448553f, 0.04400196f, 
    0.02908479f, -0.02766423f, 0.07292759f, 0.04868750f, -0.37429947f, -0.07457154f, -0.23235062f, -0.08605924f, 
    -0.01487462f, 0.03866538f, 0.02395944f, -0.03389403f, -0.01619929f, 0.12159905f, -0.00662724f, -0.03857556f, 
    -0.09279377f, -0.03869254f, -0.00771677f, 0.12769708f, -0.05881190f, 0.13931830f, 0.04330341f, 0.13275686f, 
    -0.40790781f, -0.24180418f, -0.07140421f, -0.05384965f, -0.16794759f, 0.05469177f, 0.02510739f, -0.02957649f, 
    -0.03135718f, 0.05399603f, 0.04953067f, 0.04048568f, -0.03138279f, 0.03150150f, -0.01077909f, 0.05366803f, 
    0.06822266f, 0.07156920f, 0.00013687f, 0.02040125f, 0.16687530f, 0.00430120f, -0.09032039f, 0.00012087f, 
    -0.02711427f, -0.03512909f, -0.03252928f, 0.00052896f, 0.00449867f, 0.02728645f, 0.00771531f, -0.05700110f, 
    -0.05471702f, -0.01871598f, -0.01451929f, -0.00207206f, 0.05345618f, -0.02094747f, -0.00682311f, 0.02512466f, 
    0.20020524f, -0.10012554f, -0.05098511f, 0.15966506f, -0.03920531f, -0.07132303f, -0.01060047f, -0.06127087f, 
    0.03813420f, 0.00362598f, 0.04201326f, 0.08620138f, -0.00978881f, -0.07057903f, 0.01592671f, -0.05168577f, 
    0.02180395f, -0.15344289f, -0.22794130f, -0.12132312f, -0.01369351f, -0.01403142f, 0.06370622f, -0.00406769f, 
    0.00985043f, 0.02368594f, 0.04696152f, 0.05513946f, -0.00452897f, 0.02670184f, -0.00386162f, 0.04675866f, 
    -0.02191341f, 0.05793509f, 0.00520644f, 0.03641841f, 0.03092306f, -0.11997287f, 0.01154263f, -0.04918224f, 
    0.04105471f, 0.07332015f, 0.08024001f, 0.07051484f, 0.05233554f, -0.09026042f, 0.01618937f, -0.02296313f, 
    0.07040418f, -0.04515468f, -0.05336066f, -0.00615869f, -0.01485215f, -0.04555134f, -0.01503319f, -0.08300207f, 
    -0.04406240f, 0.10662238f, -0.01680507f, -0.00413334f, 0.16977175f, 0.20692496f, -0.02861364f, -0.04067830f, 
    -0.05141068f, 0.04870407f, 0.06029389f, 0.06297997f, -0.04465263f, 0.03664291f, -0.03652436f, 0.03904884f, 
    0.04449487f, -0.00090537f, -0.00792366f, 0.04416573f, 0.07550316f, 0.01606775f, -0.02751508f, 0.02599774f, 
    0.07337993f, 0.09016290f, -0.04750068f, 0.04659205f, -0.03132685f, -0.00207202f, 0.02138284f, 0.07403167f, 
    -0.09643213f, 0.06733905f, -0.07407553f, -0.07425077f, 0.09132163f, -0.11388841f, -0.04690012f, 0.00307996f, 
    -0.01089946f, -0.14104219f, -0.02219783f, 0.12832047f, -0.35405853f, -0.02302011f, -0.08220734f, -0.12643500f, 
    -0.04263465f, 0.11159766f, 0.06615494f, -0.08049300f, -0.02934061f, -0.00639413f, 0.04905770f, 0.03638434f, 
    -0.04532433f, 0.01626358f, 0.03322891f, -0.01687312f, 0.06153572f, 0.08905260f, 0.03247566f, 0.10836058f, 
    -0.33559176f, -0.25263166f, -0.17298938f, -0.06322290f, -0.18478428f, 0.01276160f, 0.07157914f, -0.04278478f, 
    -0.08321344f, 0.03520399f, 0.03749545f, -0.01260474f, -0.02170295f, 0.03301961f, -0.01518017f, -0.02758786f, 
    -0.00148427f, 0.05223566f, 0.04698898f, 0.00541931f, -0.32747668f, -0.16514382f, -0.09418734f, -0.07575399f, 
    -0.18716605f, 0.08788174f, -0.01257411f, -0.03236765f, -0.04181544f, -0.00490932f, 0.02563328f, 0.06133391f, 
    0.01845710f, 0.10027897f, 0.01451799f, 0.00105725f, -0.02002061f, 0.01453971f, -0.05337949f, -0.04574052f, 
    0.14408153f, -0.06456980f, -0.16916284f, 0.00101845f, 0.02350321f, -0.08678738f, 0.02893651f, -0.15835166f, 
    0.01437989f, -0.05318473f, 0.00537983f, 0.10410592f, -0.05076618f, -0.06066201f, 0.06926176f, -0.01646671f, 
    0.03340839f, 0.05488104f, -0.06693292f, 0.04190195f, 0.07560436f, 0.08917342f, 0.08693468f, -0.08284540f, 
    -0.00297327f, 0.10065643f, 0.05296421f, 0.06818769f, 0.07661762f, 0.03855497f, 0.01080392f, 0.01212841f, 
    0.03258725f, 0.02277599f, -0.01897387f, 0.02162889f, 0.03711434f, 0.03541442f, -0.10365476f, 0.09257746f, 
    -0.22535650f, -0.25083330f, -0.06114910f, -0.04790600f, -0.02449837f, 0.06794824f, -0.00856225f, 0.08372325f, 
    0.01244359f, 0.00235927f, 0.10850187f, 0.03688003f, -0.00672873f, -0.00755200f, 0.00772105f, 0.02287401f, 
    -0.00906894f, -0.02104683f, 0.08672398f, -0.00416727f, -0.37482688f, 0.00262591f, -0.26029199f, 0.04603692f, 
    0.11999018f, -0.00583650f, -0.02121084f, -0.05813953f, -0.02348391f, 0.12108347f, 0.04437330f, 0.02583085f, 
    0.02592627f, -0.06691217f, 0.15132175f, 0.05539276f, -0.01522383f, 0.01630437f, -0.01751974f, -0.02418899f, 
    -0.21278480f, 0.01528142f, -0.07646005f, -0.00650426f, 0.05894917f, 0.02359573f, 0.02868191f, -0.05024236f, 
    0.00439023f, 0.05595165f, 0.00719615f, 0.04402770f, 0.00248686f, 0.00061918f, 0.07212097f, 0.05670054f, 
    0.04698730f, 0.08122409f, 0.03723998f, 0.05273468f, -0.04332805f, 0.06383819f, 0.26265702f, -0.01145680f, 
    -0.23818269f, 0.07536791f, 0.00829667f, 0.05417900f, 0.04466778f, -0.00534579f, -0.01480590f, 0.00284372f, 
    0.01006203f, 0.11837058f, -0.05717709f, -0.01806447f, -0.02557210f, -0.05880233f, -0.09173042f, -0.08393382f, 
    -0.35324237f, 0.02149310f, -0.03847119f, -0.02991780f, 0.00729047f, 0.09273596f, -0.04223968f, -0.00941072f, 
    -0.03103397f, 0.02856693f, 0.05159260f, 0.04039184f, 0.04496441f, -0.10558093f, 0.05390246f, 0.04371588f, 
    -0.10471211f, -0.03760050f, -0.06941695f, 0.03673569f, -0.36377409f, -0.23157895f, 0.04457498f, -0.05639500f, 
    -0.07012037f, 0.06667261f, 0.02719085f, 0.02924007f, -0.01025136f, 0.01507471f, 0.04158528f, 0.01035857f, 
    0.01040978f, 0.13363346f, 0.05102653f, 0.02532488f, -0.03259819f, 0.10483046f, 0.02182240f, 0.01162575f, 
    0.25081202f, 0.11914812f, -0.09017397f, 0.06404661f, -0.11787215f, -0.15040086f, -0.08526817f, 0.02452035f, 
    0.03780286f, -0.02566137f, -0.03384463f, 0.00410687f, 0.02690593f, -0.11220564f, -0.06420561f, 0.00526906f, 
    0.05140718f, -0.03949193f, -0.07520393f, -0.00698463f, -0.32285658f, -0.11193723f, 0.04852436f, -0.11979169f, 
    -0.13727701f, 0.05257620f, 0.02526874f, 0.00741392f, 0.05491256f, 0.03959265f, -0.00501468f, 0.01114003f, 
    -0.01628946f, 0.09995208f, 0.02808576f, 0.04307432f, -0.00537405f, 0.02331595f, -0.04967140f, -0.03563589f, 
    -0.34242651f, -0.17574438f, -0.13830519f, -0.10714507f, -0.21651800f, 0.04089057f, 0.00925674f, 0.00661353f, 
    -0.05165317f, 0.02528804f, 0.00273601f, 0.01147231f, 0.02018438f, 0.07252894f, 0.00960769f, -0.01924129f, 
    0.04799011f, 0.07632151f, -0.00423293f, -0.00333397f, -0.24775058f, -0.06526976f, -0.10395903f, -0.06910961f, 
    0.05158130f, -0.02538310f, -0.01699710f, -0.04792247f, -0.01125976f, 0.08872607f, 0.02341853f, 0.00004049f, 
    0.10452992f, -0.02712798f, 0.04148386f, -0.06423299f, -0.02376850f, 0.10332745f, 0.04804739f, 0.08397316f, 
    0.12176729f, 0.10009515f, 0.01015194f, -0.03566762f, -0.04339933f, -0.01665394f, -0.07181253f, 0.02979385f, 
    0.01337901f, 0.02010205f, -0.00259287f, 0.02068509f, -0.01325164f, 0.07146226f, -0.06888460f, 0.01604233f, 
    0.05468306f, 0.01214381f, -0.07890312f, 0.04249442f, -0.00955673f, 0.08321407f, -0.12479911f, 0.09808286f, 
    -0.02027712f, -0.00316675f, -0.03587749f, -0.02267488f, -0.06876167f, 0.01692660f, 0.01183073f, 0.02634881f, 
    0.00453858f, 0.02406778f, 0.01659042f, -0.03175241f, -0.04704944f, 0.02300895f, 0.00203357f, -0.01986926f, 
    -0.02776880f, 0.00557452f, -0.27464151f, -0.00150334f, -0.12661375f, 0.00370919f, -0.02373768f, -0.02411459f, 
    -0.02286569f, 0.04006651f, 0.03159880f, -0.00953497f, -0.00711702f, -0.11674896f, 0.04268553f, -0.03538245f, 
    -0.01396374f, -0.01920281f, 0.07313643f, -0.05914815f, 0.06199509f, 0.14305913f, 0.03534054f, -0.08798324f, 
    0.01901343f, 0.04164416f, -0.05757144f, 0.00287585f, 0.05615755f, 0.07130164f, -0.00517749f, 0.01076663f, 
    0.01248153f, 0.06757934f, 0.01170917f, 0.08196821f, 0.02875560f, 0.03140863f, -0.08619329f, -0.01886499f, 
    0.08072717f, -0.21433873f, -0.10160897f, -0.07481034f, -0.06749406f, -0.01167628f, 0.05797325f, -0.02625524f, 
    -0.00775442f, 0.01204728f, 0.05901458f, -0.03164041f, -0.00125987f, -0.02473161f, 0.01037562f, -0.00143761f, 
    0.03073463f, -0.03352473f, -0.01579196f, -0.03783594f, 0.00576218f, 0.03283675f, 0.03234785f, -0.04873511f, 
    -0.01906000f, -0.04856310f, -0.00848065f, -0.02005909f, 0.03241493f, -0.01895725f, 0.00760871f, -0.08777852f, 
    0.04191010f, 0.00199411f, -0.03322397f, -0.00467051f, -0.07201487f, 0.00366733f, -0.08980367f, -0.05843212f, 
    0.02578700f, -0.14296523f, 0.00750824f, 0.06368577f, 0.09465764f, 0.06693755f, -0.14275804f, -0.02086701f, 
    0.04817482f, 0.06341381f, -0.04320259f, 0.09415347f, -0.07673272f, -0.05053806f, -0.05316475f, -0.04115938f, 
    0.03886146f, -0.01754107f, -0.03576590f, -0.05372981f, 0.03044833f, 0.19168846f, -0.17092673f, -0.01162229f, 
    0.04988374f, 0.04266900f, -0.16467020f, 0.02495307f, -0.06867688f, -0.06939636f, 0.04596775f, 0.03870929f, 
    0.04789799f, -0.02347936f, 0.02761540f, 0.02606686f, 0.05331166f, -0.01133779f, 0.11293838f, 0.06597240f, 
    -0.03583437f, 0.08319928f, -0.06617876f, 0.04861243f, 0.05773234f, 0.03875610f, -0.10675403f, 0.06494429f, 
    -0.07253756f, -0.01696351f, 0.02682690f, -0.06582304f, 0.06488645f, -0.00235390f, -0.01743445f, -0.03797011f, 
    0.05916140f, -0.03126168f, -0.05087000f, -0.06280891f, 0.07207190f, 0.17852022f, 0.00593631f, 0.08240073f, 
    -0.02784893f, 0.04046186f, 0.10119529f, 0.00768312f, -0.01906770f, 0.04648381f, 0.04349547f, 0.06538570f, 
    0.01694527f, 0.03875691f, 0.05133351f, -0.04593094f, 0.01378124f, 0.06861091f, -0.03651823f, 0.01665292f, 
    -0.20454593f, -0.38966033f, 0.03652622f, -0.08376677f, 0.05673571f, -0.03977100f, -0.05431540f, 0.04027192f, 
    0.04228396f, 0.02356727f, -0.05755347f, 0.01953004f, -0.01845330f, -0.00310482f, -0.03573532f, 0.05532250f, 
    0.04929575f, 0.01432530f, -0.07340688f, -0.07115543f, -0.02922237f, -0.09461505f, -0.01489138f, -0.00301707f, 
    0.09422886f, -0.13902590f, 0.06402326f, 0.02398905f, 0.05369148f, -0.10218558f, 0.06857278f, -0.00549862f, 
    -0.08001072f, -0.00069151f, 0.00418050f, 0.00053076f, -0.02349075f, 0.00769195f, 0.15624022f, -0.05425770f, 
    -0.18587391f, 0.02595417f, -0.03085959f, -0.01774595f, 0.00923234f, 0.00459329f, -0.03124287f, -0.03612570f, 
    0.01681511f, 0.02670662f, -0.06074942f, -0.05545408f, 0.02660218f, -0.00290436f, 0.01275859f, -0.06938630f, 
    -0.12711065f, -0.07655921f, -0.08097762f, -0.01284153f, -0.09691843f, 0.27451891f, -0.06112038f, 0.01728914f, 
    0.17527159f, 0.03824236f, 0.03990743f, -0.06623923f, -0.02153321f, -0.05974679f, 0.09518015f, 0.11394254f, 
    -0.00514211f, -0.00267072f, 0.01101005f, -0.02537964f, 0.06133132f, 0.00608978f, -0.08900891f, 0.05483989f, 
    -0.16708843f, 0.21505313f, -0.02983383f, 0.04465345f, 0.04583799f, 0.14395069f, 0.18395725f, 0.02526434f, 
    -0.01534866f, -0.01380902f, -0.06391815f, 0.08245265f, 0.01555738f, 0.01786626f, 0.04546335f, -0.06853905f, 
    -0.00500402f, 0.01571902f, -0.09833668f, 0.08804944f, -0.36412004f, 0.10492058f, 0.06968041f, -0.02948049f, 
    -0.02421190f, -0.00442813f, 0.03382160f, -0.05889864f, 0.08363115f, -0.12184072f, -0.00954182f, 0.02104191f, 
    0.04023679f, 0.03951874f, -0.02072601f, 0.06078584f, 0.01159815f, -0.03653852f, -0.06410263f, 0.03394474f, 
    0.24901687f, -0.01335352f, -0.11737278f, 0.02530642f, 0.01537454f, -0.10116218f, -0.05188024f, -0.02717387f, 
    0.04823103f, -0.00096790f, 0.03565221f, 0.05498580f, -0.02544484f, 0.02568464f, 0.00808457f, 0.01441293f, 
    -0.03813557f, -0.03888606f, 0.04207867f, 0.02649724f, 0.02115639f, 0.04896983f, -0.01437336f, -0.03703641f, 
    -0.04182866f, -0.04102332f, -0.03902890f, 0.02384707f, -0.03217379f, -0.10394011f, -0.11354879f, -0.00609095f, 
    0.05706016f, 0.04062660f, -0.04745156f, -0.01549436f, -0.04406554f, -0.02612069f, -0.12209333f, -0.03010011f, 
    0.09647193f, -0.26284674f, 0.01361016f, 0.01048266f, 0.10048509f, -0.06399669f, 0.02753209f, 0.01175948f, 
    0.04927481f, 0.00863260f, 0.01634236f, 0.04569720f, -0.01021540f, 0.00588147f, -0.01858198f, 0.07647941f, 
    0.10413282f, 0.02761202f, 0.06319945f, -0.06663542f, 0.08276953f, -0.25355437f, 0.03632667f, 0.06994388f, 
    -0.01600457f, 0.00904002f, 0.13139355f, -0.03830852f, 0.05670025f, 0.05965443f, 0.03977469f, 0.07083640f, 
    -0.02521328f, -0.05044340f, -0.00771530f, 0.02495784f, -0.03121683f, -0.03602607f, 0.01261136f, -0.01415410f, 
    0.34012678f, 0.05860926f, -0.11800566f, -0.02117792f, -0.00545961f, 0.00789571f, 0.17155926f, -0.04888483f, 
    0.01940393f, -0.03913100f, 0.07115828f, 0.04028471f, -0.01420508f, 0.02008611f, 0.03956240f, -0.00891557f, 
    0.03039366f, 0.01066936f, -0.02934087f, 0.10195716f, -0.18732718f, 0.00901073f, 0.05326237f, 0.01063563f, 
    0.12769108f, 0.14159104f, -0.01567826f, 0.02055870f, 0.01029613f, 0.08141611f, -0.04154591f, 0.06361268f, 
    0.03063908f, 0.03138698f, -0.01027230f, -0.03508213f, 0.02023465f, -0.01547049f, -0.09244652f, -0.06452982f, 
    0.13490908f, 0.11744037f, -0.01506995f, -0.06362274f, -0.00797915f, -0.08694924f, -0.10031673f, 0.00413205f, 
    -0.02204491f, -0.07004145f, 0.02095310f, 0.00262167f, -0.05096720f, 0.02752825f, 0.00143427f, 0.04940609f, 
    -0.08350267f, 0.03627185f, -0.00122963f, -0.04426387f, -0.25616643f, 0.44372827f, -0.13128385f, 0.10917030f, 
    0.12936537f, 0.10696493f, -0.02014622f, 0.07042877f, -0.05619587f, -0.00079184f, 0.04797890f, 0.07335608f, 
    0.03594289f, 0.00644903f, 0.03650522f, -0.07107483f, 0.10940896f, -0.02723029f, -0.03335655f, 0.08432375f, 
    -0.08588205f, -0.07974278f, 0.04453585f, -0.00962884f, 0.10019120f, -0.07090939f, 0.05258298f, 0.00517172f, 
    0.07939848f, -0.16531970f, -0.03329418f, 0.00089783f, 0.04147821f, 0.12248754f, -0.00705962f, -0.03940619f, 
    -0.08469351f, -0.05557596f, -0.12432068f, 0.11165612f, -0.16361669f, -0.01867038f, -0.03103744f, 0.03722243f, 
    -0.09288961f, 0.13815285f, 0.05861345f, 0.08186861f, -0.05358095f, 0.04740617f, 0.00121186f, 0.06228016f, 
    0.00682156f, -0.03725592f, -0.11716073f, -0.18351109f, -0.00447595f, -0.08786757f, -0.00266649f, 0.01131097f, 
    -0.02643382f, -0.03878223f, -0.07698549f, 0.12725160f, -0.16164918f, 0.09266806f, 0.09638834f, 0.01500537f, 
    0.00956823f, -0.07891802f, 0.07301614f, -0.04903699f, 0.07243061f, 0.08811561f, -0.02695324f, -0.02043283f, 
    0.05518849f, 0.01130470f, -0.12426185f, -0.08698311f, -0.13020876f, 0.04034930f, -0.03746706f, -0.17362341f, 
    0.21956693f, 0.05310510f, -0.04879985f, -0.07152814f, 0.06479757f, 0.02913701f, -0.01329982f, -0.03071429f, 
    0.02942432f, -0.00536542f, 0.10021874f, 0.01371569f, -0.02169284f, -0.00407226f, 0.02627077f, 0.02986091f, 
    -0.33321872f, 0.22440121f, -0.01673298f, -0.01492355f, 0.24353845f, 0.10510276f, -0.08905658f, 0.05411871f, 
    0.01279261f, 0.04402018f, -0.03804490f, 0.05876698f, 0.08289200f, 0.00418206f, 0.02326098f, 0.01854711f, 
    0.10137179f, -0.01720478f, 0.00464716f, -0.04844108f, -0.03809202f, 0.05080206f, -0.20653956f, -0.03143429f, 
    0.01441594f, -0.11231796f, -0.01723744f, 0.01379391f, 0.07164308f, -0.06176635f, 0.09566193f, 0.03399615f, 
    -0.02241782f, -0.03153297f, -0.03740769f, 0.07799740f, 0.06714533f, 0.00374636f, 0.02936357f, 0.01434849f, 
    0.25599581f, -0.12910889f, -0.10821092f, 0.05757357f, 0.05319038f, 0.10155102f, -0.04240545f, -0.01642008f, 
    0.01767747f, 0.01929452f, 0.08453355f, 0.01198425f, 0.00270519f, 0.02584940f, 0.01315422f, 0.03839835f, 
    0.00551936f, 0.00755762f, -0.02003384f, -0.02467613f, -0.06419005f, -0.18142657f, -0.07091989f, -0.26128957f, 
    0.08028472f, 0.08775235f, 0.02244823f, 0.00599907f, 0.03796451f, 0.02317242f, -0.07617927f, -0.02177634f, 
    -0.03469634f, 0.05094483f, -0.02432472f, 0.01728397f, 0.01189508f, 0.03504899f, 0.02912163f, -0.02761597f, 
    -0.12362335f, -0.17466295f, -0.09258121f, -0.14664292f, -0.21956460f, 0.03480452f, -0.00167314f, 0.05832613f, 
    -0.01219689f, 0.09064467f, 0.02951413f, 0.01794514f, -0.03123469f, -0.07189488f, -0.00526620f, -0.02900966f, 
    -0.00941752f, 0.02908075f, -0.02206395f, -0.02169788f, -0.00776012f, 0.16002928f, -0.09779488f, 0.00618149f, 
    0.05997395f, 0.01962716f, 0.02471308f, -0.01817932f, -0.01402452f, -0.05002404f, 0.08872377f, 0.07994556f, 
    0.04004430f, -0.05443136f, -0.00809982f, 0.07671295f, 0.02002077f, 0.02296546f, -0.06389146f, 0.01599626f, 
    -0.07913617f, 0.02947275f, -0.00932738f, -0.11053053f, 0.30885744f, 0.07142499f, -0.08902665f, -0.05470244f, 
    -0.04563198f, -0.01767999f, 0.08117534f, -0.01837433f, -0.01179661f, 0.06108439f, -0.04548251f, 0.09840856f, 
    0.06868279f, 0.01885587f, -0.00684002f, 0.00677615f, -0.46301630f, -0.07718582f, 0.06645080f, 0.00694518f, 
    0.09091788f, -0.04556540f, 0.09691811f, -0.04559421f, 0.07697384f, -0.02060575f, -0.05336154f, 0.07881742f, 
    0.01603726f, 0.08971287f, 0.04465721f, -0.06479587f, -0.01012805f, 0.02125322f, -0.10402603f, -0.03777426f, 
    0.11511260f, -0.04939819f, -0.06588960f, -0.00714031f, 0.05836964f, 0.05507401f, -0.15600580f, 0.00421808f, 
    0.04637476f, -0.00938823f, 0.02413755f, 0.05414148f, -0.04606966f, -0.00079790f, 0.00391473f, -0.00354048f, 
    0.09158916f, 0.04873176f, -0.11365092f, 0.00569782f, -0.26577169f, 0.01462247f, -0.04779676f, -0.07287507f, 
    0.30723968f, 0.11924876f, -0.17737466f, -0.06857908f, -0.06039454f, -0.07116435f, -0.00898009f, -0.10303123f, 
    -0.01332596f, -0.01411030f, 0.01799766f, 0.05070347f, -0.03117941f, -0.01504546f, 0.04438617f, -0.01980354f, 
    0.21556835f, -0.05331411f, -0.11528522f, -0.18525419f, -0.12313719f, 0.01995702f, 0.03858380f, -0.02108373f, 
    0.01954861f, 0.03275071f, 0.03140138f, -0.04440770f, -0.00249294f, -0.02290529f, 0.03207933f, 0.04755139f, 
    0.04665776f, -0.02615901f, 0.02899754f, 0.03838928f, -0.05488503f, -0.22479162f, -0.06841512f, -0.04069293f, 
    -0.13509122f, 0.03337174f, 0.05720311f, 0.06222134f, 0.00128455f, 0.06527680f, -0.00981389f, 0.03336963f, 
    0.00700344f, 0.03164414f, -0.03846431f, -0.02029944f, -0.06938466f, -0.05081235f, -0.07689852f, -0.05453645f, 
    0.21301757f, -0.25568447f, -0.20219232f, 0.11852331f, -0.02529319f, 0.14788702f, 0.00590469f, -0.01993246f, 
    -0.00639374f, 0.04444036f, 0.04507015f, -0.00569168f, -0.04703638f, 0.03344097f, -0.05508490f, 0.03684674f, 
    -0.01839679f, 0.01415279f, -0.03868163f, -0.07234886f, 0.32555321f, 0.00795068f, -0.16108155f, 0.05194414f, 
    -0.02473052f, -0.03496351f, 0.01593892f, -0.02005937f, 0.01443843f, 0.09841144f, -0.03759894f, -0.00505280f, 
    -0.00674987f, -0.04686489f, 0.05988544f, 0.02719101f, 0.01644323f, -0.02786996f, -0.06474362f, -0.05617527f, 
    0.24221370f, 0.10043012f, -0.09088632f, -0.09383138f, 0.12621443f, -0.01037779f, -0.06046333f, -0.01371600f, 
    0.02230913f, 0.04949011f, 0.02294104f, 0.03761072f, -0.07085858f, -0.08769471f, 0.04361426f, 0.05273066f, 
    -0.07854436f, 0.00286766f, -0.03496028f, 0.05923153f, 0.00376921f, 0.11561934f, -0.03702018f, -0.01988301f, 
    -0.03253028f, 0.06419789f, -0.01665618f, 0.05842517f, -0.05659241f, -0.07999892f, 0.02525428f, -0.05997162f, 
    0.04528401f, -0.09492643f, -0.08726406f, -0.07231868f, -0.01789009f, -0.03511877f, 0.05341192f, 0.03135728f, 
    0.12163714f, 0.01031981f, -0.02898596f, -0.05729637f, -0.15846385f, -0.05853606f, -0.16526608f, -0.07491448f, 
    -0.15377273f, -0.20183299f, -0.06733266f, -0.04920364f, 0.03317760f, -0.10908438f, -0.07998731f, 0.06533667f, 
    -0.00717622f, 0.00950757f, 0.02738651f, -0.03010241f, 0.04839234f, 0.05621265f, -0.03619150f, -0.02814675f, 
    0.12327317f, 0.05984779f, -0.17748764f, -0.03637173f, 0.09785878f, -0.01463930f, 0.06730283f, 0.02243222f, 
    -0.00374246f, -0.02240836f, -0.00808687f, 0.00868347f, 0.03182474f, 0.06289646f, -0.06149765f, 0.06876967f, 
    -0.46215418f, -0.19356649f, -0.05623272f, -0.08655306f, -0.01480679f, 0.00244444f, -0.01097582f, 0.04230424f, 
    0.08213596f, 0.07948665f, -0.04054018f, 0.01766127f, 0.05887689f, -0.07801218f, -0.06661723f, -0.00451174f, 
    -0.09821178f, 0.03667416f, -0.11415101f, 0.01399915f, -0.12287002f, 0.10782457f, -0.01688931f, -0.01015141f, 
    0.15740621f, -0.04457924f, -0.02164186f, 0.00118946f, 0.04921024f, 0.00841266f, -0.01172426f, 0.01744914f, 
    -0.05787906f, 0.02613484f, 0.07273053f, 0.02738509f, -0.07444780f, -0.05505760f, 0.05754492f, -0.01546559f, 
    0.07207775f, 0.03582403f, -0.13126016f, 0.09259348f, -0.15076835f, -0.05071944f, -0.01219090f, -0.04003124f, 
    -0.08302668f, -0.05236682f, 0.07126707f, -0.03860134f, 0.01865463f, 0.02461999f, -0.05867507f, 0.02718147f, 
    -0.07178462f, -0.00572935f, 0.02895712f, -0.09043753f, -0.25835472f, -0.06428245f, 0.05022658f, -0.07218691f, 
    -0.18422091f, 0.10765200f, 0.05762872f, -0.07159607f, -0.02019016f, -0.02109505f, 0.01481223f, -0.06992239f, 
    0.02629684f, -0.05856362f, -0.02492528f, -0.03427682f, -0.03700753f, 0.07041389f, -0.02364830f, 0.04496890f, 
    0.25013292f, -0.08242550f, -0.12009159f, -0.12863550f, -0.16641626f, -0.01436626f, -0.01408240f, 0.02509096f, 
    0.00610810f, 0.05433394f, 0.08657620f, -0.02334130f, 0.00152783f, -0.04767083f, -0.01036427f, -0.05952607f, 
    -0.00850795f, 0.00062966f, -0.02693478f, 0.04917772f, 0.36747164f, 0.05324823f, -0.10151152f, 0.01070281f, 
    -0.10467803f, 0.01432973f, 0.08279494f, -0.00914544f, -0.01794261f, 0.00688138f, 0.09409652f, 0.06889612f, 
    0.03459822f, 0.01105748f, 0.01161854f, 0.01691437f, -0.04312392f, -0.04458087f, -0.05578658f, 0.01180716f, 
    -0.24189293f, -0.07480960f, 0.04160191f, 0.00582666f, -0.09754373f, 0.00143813f, 0.06246298f, -0.03122876f, 
    0.02454128f, 0.08188926f, -0.20495471f, 0.06038910f, 0.04783426f, -0.07809558f, -0.01241753f, -0.16155623f, 
    0.00503975f, 0.03514753f, -0.07789719f, -0.06493500f, -0.08937437f, 0.20886178f, -0.06855567f, -0.11279019f, 
    0.01480745f, -0.09141305f, -0.03656575f, 0.09430590f, -0.21067512f, -0.03682357f, -0.00216246f, 0.00429101f, 
    -0.02428762f, -0.08395824f, 0.00271191f, 0.07628874f, 0.01579901f, -0.02034963f, 0.05748646f, -0.03732141f, 
    0.23599073f, -0.14585254f, -0.01661848f, 0.06140348f, -0.02544631f, 0.06635786f, -0.04645478f, 0.02425782f, 
    -0.07310928f, -0.00690282f, 0.01968087f, 0.03115120f, 0.01860110f, 0.02194087f, -0.05103724f, -0.01743616f, 
    0.00543588f, -0.04508866f, -0.01005421f, -0.01781482f, -0.06728254f, 0.10003430f, -0.07176668f, 0.09701679f, 
    -0.19292416f, -0.09040380f, -0.04298588f, -0.03150551f, -0.01035298f, -0.01006362f, -0.03462889f, -0.03527869f, 
    0.13235743f, 0.05387813f, -0.02086901f, 0.08957996f, 0.01090047f, -0.05431949f, -0.05224176f, -0.04729204f, 
    -0.25680548f, 0.07931223f, 0.00920112f, -0.04103391f, -0.01104120f, -0.08587810f, -0.04417847f, -0.05399357f, 
    0.03781631f, 0.05042116f, 0.00958541f, -0.00489318f, -0.00727260f, -0.03850685f, -0.02728717f, -0.05196278f, 
    -0.03787295f, -0.03364748f, -0.00319875f, 0.07597609f, 0.26360780f, 0.12680151f, -0.09959576f, -0.19392100f, 
    0.15196018f, 0.06645109f, -0.09940090f, -0.04522017f, 0.02417704f, -0.03323220f, 0.07397451f, -0.00648901f, 
    0.01916081f, -0.01564980f, -0.02758808f, -0.02708641f, -0.00981884f, 0.05302887f, -0.03726961f, 0.04109796f, 
    0.04362749f, -0.00822471f, 0.02939099f, 0.00148113f, -0.10655478f, -0.02884111f, 0.08696064f, 0.01094600f, 
    -0.00502625f, -0.08163729f, 0.11539556f, -0.07596421f, -0.03802047f, 0.08128403f, -0.01113684f, 0.01506424f, 
    0.02643984f, -0.02671201f, 0.03258704f, 0.05478713f, 0.08224022f, 0.11814022f, -0.09766561f, -0.14119281f, 
    -0.08510139f, -0.01944894f, -0.05673004f, 0.00797842f, 0.03138201f, 0.05606224f, 0.04908586f, 0.04313284f, 
    -0.02709428f, -0.05668890f, 0.01257051f, -0.02066163f, -0.01569642f, -0.01701696f, -0.08302766f, 0.04285328f, 
    0.09574436f, -0.01809716f, -0.01018862f, -0.02091064f, -0.04583363f, -0.01018935f, 0.05943783f, 0.03762928f, 
    -0.01565459f, -0.04334052f, -0.04084245f, -0.08987298f, 0.03744816f, -0.00737145f, 0.00229450f, -0.03050977f, 
    -0.02572160f, -0.00516300f, -0.08565865f, 0.00173522f, 0.34121767f, 0.13536023f, -0.20494384f, -0.08835793f, 
    0.04286202f, -0.03883645f, -0.02293582f, -0.04513234f, 0.00408398f, 0.01209936f, 0.08724985f, 0.04864702f, 
    -0.00425021f, 0.03760242f, -0.04791403f, 0.00355521f, 0.03085411f, 0.03401799f, -0.05829427f, 0.01112448f, 
    0.31435019f, -0.01665292f, -0.14433542f, -0.11003073f, -0.08047719f, 0.01523740f, -0.03207267f, 0.04984032f, 
    -0.02207186f, 0.02061753f, 0.11177777f, -0.03614671f, 0.01628776f, 0.02452169f, -0.02546412f, -0.01347904f, 
    -0.05328407f, -0.05926140f, -0.03613396f, 0.02762358f, -0.07543544f, -0.00933766f, 0.01867671f, 0.05052219f, 
    0.06256448f, 0.02273276f, 0.09626642f, 0.02488947f, -0.01471354f, -0.02316322f, 0.03775304f, -0.02094007f, 
    -0.06496842f, -0.00234412f, 0.03045869f, -0.00920659f, -0.01605496f, -0.05126977f, 0.01057450f, -0.01581095f, 
    -0.13604702f, 0.19108835f, 0.00054575f, -0.03416053f, -0.00568750f, -0.02975516f, -0.04542032f, 0.03390534f, 
    -0.04093859f, -0.09275137f, 0.03906214f, -0.03066305f, 0.05670109f, -0.07949028f, 0.04223643f, -0.04955622f, 
    -0.04042554f, 0.01545697f, -0.00289699f, -0.02416672f, -0.05927299f, -0.11420495f, 0.01459352f, 0.07512920f, 
    0.07956914f, -0.11665478f, -0.03998233f, 0.07102733f, -0.05148155f, -0.11897999f, -0.04179525f, -0.04512356f, 
    -0.07864205f, 0.04450411f, 0.01714798f, 0.02836825f, 0.06825285f, -0.04240105f, -0.00009154f, 0.04983161f, 
    0.17534831f, -0.23965172f, -0.02344016f, 0.05552334f, -0.10103836f, -0.07074869f, 0.06551041f, -0.01439981f, 
    0.01868768f, 0.04218743f, -0.15627217f, -0.05832333f, 0.00236087f, 0.05298683f, -0.09660759f, 0.06378271f, 
    -0.03733234f, -0.03016677f, -0.13549106f, -0.11296802f, 0.23511209f, -0.10373693f, -0.13142163f, -0.02535958f, 
    0.09745292f, -0.05666720f, 0.03179236f, -0.04222255f, 0.05625689f, -0.02148443f, 0.07487166f, 0.07901493f, 
    -0.00994430f, 0.07987660f, -0.02331850f, -0.03558931f, -0.02745757f, -0.02715543f, 0.08013951f, 0.06466149f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03044277f, 0.03535987f, -0.05740053f, -0.00003155f, 0.00880696f, -0.00573101f, -0.00454608f, -0.06552286f, 
    -0.04492386f, -0.00290088f, 0.04678981f, 0.03208552f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
