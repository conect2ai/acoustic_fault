#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.59489232f, -0.28492600f, -0.04378974f, -0.12897040f, -0.13783818f, -0.08800319f, -0.52762192f, -0.66261381f, 
    -0.45757294f, -0.48204929f, -0.05986714f, 0.00990595f, -0.06822798f, -0.65245682f, -0.39262000f, -0.14419599f, 
    -0.17483124f, -0.13325913f, 0.15751095f, -0.05303381f, 0.06174902f, -0.01197082f, 0.11107761f, -0.19342156f, 
    -0.00065725f, 0.09021815f, -1.17000675f, -0.22682817f, 0.63658071f, -0.10227733f, 0.14948983f, 0.44013187f, 
    -0.53548670f, -0.84769988f, -0.46622479f, 0.07240304f, -0.28247377f, -0.00844357f, -0.66116506f, -0.25952196f, 
    0.14765087f, -0.46585450f, 0.23324935f, 0.18690646f, -0.20761088f, -0.12550874f, -0.36841786f, 0.01986757f, 
    0.21072493f, 0.00624360f, -0.08579636f, -0.00160569f, -0.56024563f, -0.91654956f, -0.51486158f, 0.28875104f, 
    0.24625558f, 0.43084642f, 0.29312742f, -0.16902356f, 0.09611776f, 0.87246221f, -0.35893920f, -0.32330585f, 
    -0.18250708f, -0.40030938f, 0.26749909f, -0.17934898f, -0.33889067f, -0.20398217f, 0.29182783f, -0.00454224f, 
    -0.00307001f, 0.14200106f, 0.33592585f, 0.38671583f, 0.22431773f, 0.55719316f, 0.67333645f, 0.39190206f, 
    -0.34317553f, -0.16367586f, -0.35319602f, 0.21840274f, -0.36490986f, -0.26029438f, -0.43728498f, 0.00812319f, 
    0.24888514f, -0.16150424f, -0.11734917f, 0.16450675f, -0.10921873f, -0.21112514f, 0.47149435f, 0.07498369f, 
    -0.10048595f, -0.26441222f, -0.14141202f, -0.01627650f, 0.78770357f, 0.74208063f, 0.07249555f, 0.29025432f, 
    -0.29896840f, 0.21921110f, -0.30042329f, -0.40506786f, 0.11750234f, -0.33863622f, 0.35979551f, -0.43767649f, 
    0.09624621f, 0.05360107f, -0.20310633f, -0.01934667f, -0.07777518f, 0.08665171f, -0.30568936f, 0.18436296f, 
    -0.17935359f, 0.25273395f, 0.16648071f, 0.27845070f, 0.00434882f, -0.45657119f, -0.16980426f, -0.38879126f, 
    0.13242419f, 0.07082959f, -0.66242510f, -0.24583681f, -0.16038936f, -0.77882588f, -0.11765959f, 0.34101242f, 
    -0.34543979f, 0.39299920f, -0.19864292f, -0.12193614f, 0.07839666f, 0.12835523f, -0.08648036f, -0.08926671f, 
    -0.24000840f, 0.22562389f, 0.33218363f, 0.19854856f, 0.37784982f, 0.19079576f, 0.06074531f, 0.63714880f, 
    0.46066964f, 0.28547415f, -0.24913853f, -0.78168184f, -0.33754241f, 0.21054500f, 0.32219490f, 0.12417339f, 
    0.50659508f, -0.08603695f, -0.44301200f, -0.37215906f, -0.11910972f, 0.34941211f, 0.11491562f, -0.22649488f, 
    -0.32971630f, -0.26978409f, 0.06336755f, -0.05432722f, -0.38703600f, -0.04708862f, 0.02044817f, -0.60788095f, 
    -0.81273139f, -0.51324278f, 0.06174915f, 0.86043429f, -0.16784245f, -0.24226449f, 0.08011010f, 0.45865610f, 
    0.46444750f, 0.33261317f, 0.07083821f, 0.06175228f, 0.13140111f, 0.10843148f, -0.10043730f, -0.04678040f, 
    0.06480919f, -0.26666042f, -0.52292818f, -0.33807340f, 0.18996643f, 0.29956964f, -0.08197418f, 0.32702392f, 
    0.31896305f, -0.76541638f, -0.55316043f, -0.40460065f, -0.54981357f, -0.39403692f, -0.19143423f, -0.12822367f, 
    -0.45392093f, 0.00287823f, 0.07604444f, 0.10310427f, -0.16293092f, -0.50307542f, 0.26062056f, -0.16775365f, 
    0.32726210f, -0.06086124f, -0.17131867f, -0.02245018f, -0.09812529f, -0.22499251f, -0.32851365f, -0.39925349f, 
    -0.18258560f, 0.29799354f, -0.44152606f, -0.34227735f, -0.24507575f, -0.19838524f, -0.01162645f, 0.09200900f, 
    0.48580283f, -0.00262547f, 0.18474478f, -0.05543782f, 0.14965083f, 0.38303819f, -0.23901251f, 0.31684986f, 
    -0.16565165f, 0.00903331f, -0.50589067f, 0.00838092f, 0.21501155f, -0.13962860f, -0.50549513f, -0.07934045f, 
    0.52417886f, 0.40583190f, -0.96470737f, -0.70117772f, 0.17302454f, -0.81722653f, -0.59560889f, 1.15316296f, 
    0.46293253f, -0.54180390f, -0.42364240f, 0.61011350f, 0.11703693f, -0.26153231f, -0.02105496f, 0.03456079f, 
    -0.09274686f, 0.32383320f, 0.16360573f, 0.10678674f, 0.06423727f, -0.06726686f, -0.08311906f, 0.02910698f, 
    0.00225711f, -0.05062952f, 0.09416191f, 0.50214893f, 0.46859717f, -0.21187131f, 0.06773088f, 0.25193089f, 
    -0.26576072f, -0.52073908f, -0.24534565f, 0.07056575f, 0.66072363f, -0.19530965f, 0.09224131f, -0.00217471f, 
    -0.22384781f, -0.25870237f, 0.08636681f, 0.04903211f, -0.27158424f, 0.25227776f, 0.02170448f, -0.05224052f, 
    -0.01258961f, 0.04838256f, 0.07325333f, -0.10355215f, 0.76335496f, -0.52044982f, 0.01409921f, 0.46503910f, 
    -0.00893996f, 0.07739454f, 0.14443074f, -0.31321833f, -0.06725266f, -0.17542976f, 0.24063751f, -0.13139860f, 
    -0.15592229f, 0.31616613f, -0.09880155f, 0.06612839f, -0.42169032f, 0.15207200f, 0.10257405f, 0.25413156f, 
    0.11614965f, 0.21046001f, -0.27142447f, 0.48758247f, 0.15446830f, 0.69899356f, -0.79395682f, 0.19658051f, 
    0.02574491f, -1.00502956f, 0.20803061f, 0.43194947f, -0.00296315f, 0.11708064f, -0.03622953f, -0.29343688f, 
    -0.22784220f, 0.06484441f, -0.05534691f, 0.00622151f, 0.33174524f, -0.36710885f, -0.31078508f, -0.39125550f, 
    -0.31570628f, -0.45400926f, 0.09663238f, -0.05948317f, 0.04978000f, -0.53838801f, 0.26465496f, 0.57160658f, 
    0.31041634f, -0.23080367f, 0.48724771f, 0.14566082f, 0.60970002f, 0.32341155f, 0.03439205f, -0.12423182f, 
    -0.05917992f, 0.25248989f, 0.55800706f, -0.29349440f, -0.27133003f, 0.28892016f, -0.33251807f, -0.17469427f, 
    -0.10976216f, -0.06962856f, -0.06321070f, 0.42586386f, 0.01160000f, -0.08428165f, 0.42911020f, -1.00743175f, 
    0.07250226f, -0.81943882f, -0.39934725f, 0.21766527f, 0.16555755f, 0.08598357f, 0.38441974f, 0.61122036f, 
    0.54245168f, 0.09277026f, -0.02292335f, -0.04827423f, 0.02950447f, 0.08365055f, -0.08017945f, -0.21078256f, 
    -0.28544745f, 0.32217729f, -0.03690952f, -0.03091369f, -0.10889634f, -0.00270621f, -0.14874314f, -0.26486418f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.17006646f, 0.16671187f, 0.21086523f, 0.14448220f, 0.24643831f, 0.19501650f, 0.42999873f, 0.32157794f, 
    -0.20760040f, 0.41350219f, 0.38444659f, 0.45713398f, 0.32898861f, 0.14231630f, 0.00676311f, 0.03854038f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.25198141f, 0.29468864f, -0.06247991f, 0.04887842f, 0.03153629f, 0.10908232f, 0.09078009f, 0.16121477f, 
    0.02362829f, 0.00501898f, 0.04468144f, -0.00923677f, 0.18990228f, 0.12873530f, -0.05171348f, -0.12124888f, 
    0.12345133f, 0.13690075f, 0.01142010f, 0.08115570f, -0.07599419f, -0.10398430f, 0.00920694f, 0.17189862f, 
    0.03072887f, -0.20107001f, -0.22555828f, -0.11850361f, -0.07943921f, 0.11675320f, -0.03840046f, 0.04806932f, 
    0.08904430f, -0.00187055f, 0.32829216f, -0.03168065f, 0.35637572f, -0.02580464f, 0.38666216f, 0.07379926f, 
    -0.01446902f, -0.11475048f, -0.09192609f, -0.00675818f, -0.03703144f, 0.01779851f, -0.05181268f, -0.08092125f, 
    -0.02923057f, 0.08365328f, 0.02016947f, 0.31199831f, -0.02556893f, 0.07005398f, -0.17052495f, 0.00019965f, 
    0.03061314f, 0.10493783f, 0.02526010f, 0.05196759f, -0.02217532f, 0.12134519f, 0.17249896f, 0.08488509f, 
    0.04071782f, 0.19826388f, 0.00363928f, 0.07144581f, -0.00339378f, 0.06005876f, -0.00580569f, 0.12704800f, 
    0.26805758f, 0.15395328f, 0.36487815f, 0.04899583f, -0.00369661f, 0.04944702f, -0.19478053f, -0.01519889f, 
    -0.21029662f, -0.10895462f, 0.12860839f, 0.01878354f, 0.25061101f, 0.01839663f, -0.12075534f, -0.14867534f, 
    0.05232707f, -0.00608419f, 0.12645414f, -0.10972991f, 0.13989781f, 0.00150252f, 0.10179958f, 0.03210926f, 
    0.26938826f, 0.07983373f, 0.01599539f, 0.05514177f, 0.22357100f, -0.08513851f, -0.00730326f, 0.22462539f, 
    -0.16484302f, -0.06484551f, 0.04025629f, -0.09797774f, -0.01792558f, -0.15164106f, 0.09770822f, 0.01561176f, 
    -0.00878740f, 0.06660290f, -0.09446372f, 0.11411019f, 0.13719481f, 0.02928215f, 0.00091020f, 0.00119226f, 
    0.04211619f, 0.19806045f, -0.46378139f, -0.10746886f, 0.08599840f, -0.03765078f, -0.01404320f, 0.15298037f, 
    -0.02530907f, 0.02673368f, 0.00623902f, -0.07920242f, -0.03889766f, 0.47164282f, -0.01895947f, -0.09476683f, 
    0.02068688f, -0.08483955f, -0.00595734f, -0.10631607f, 0.00848852f, -0.10380745f, -0.01333786f, 0.05654112f, 
    0.04692937f, 0.06849773f, 0.05199257f, 0.03154049f, -0.09164321f, 0.06427214f, -0.08168319f, -0.02281020f, 
    0.01580987f, 0.05485529f, -0.01299798f, -0.00790164f, 0.10680650f, -0.29233485f, 0.02433580f, 0.05327152f, 
    0.00481045f, 0.08613139f, -0.02229076f, 0.08297409f, 0.01136244f, 0.09055541f, -0.16786036f, -0.19388792f, 
    -0.01851100f, 0.19090682f, -0.01385709f, -0.02535350f, -0.09501019f, 0.02345201f, 0.02723793f, -0.00865002f, 
    -0.01231308f, -0.02587713f, -0.06520572f, 0.06133144f, 0.22494942f, -0.10830804f, -0.19708619f, -0.45283100f, 
    -0.03930264f, 0.03878625f, -0.05135394f, 0.03982112f, 0.19576076f, 0.18784526f, -0.10874633f, -0.25259486f, 
    -0.03358130f, -0.00967176f, 0.03894024f, -0.00399279f, -0.02537422f, -0.00329085f, 0.10020608f, 0.11461534f, 
    0.05042422f, 0.00759205f, 0.12409034f, 0.15628429f, 0.21257339f, -0.06365314f, 0.16954421f, -0.07993881f, 
    0.05161385f, 0.25054258f, 0.06279396f, 0.24304041f, 0.07476957f, 0.10251713f, 0.05192673f, 0.11494391f, 
    -0.42398468f, -0.03451759f, 0.02542667f, -0.02642676f, 0.08817219f, -0.02666043f, -0.03876710f, 0.02936522f, 
    0.27009687f, -0.06878679f, 0.31505951f, 0.14781526f, 0.15351552f, -0.11901845f, 0.03196447f, -0.01901105f, 
    0.15573725f, 0.02670017f, 0.10229430f, -0.13485958f, -0.10501450f, -0.05797098f, -0.05514761f, -0.07434314f, 
    0.03625070f, 0.10084739f, -0.03058051f, -0.00352898f, 0.05042155f, 0.14012897f, 0.05494799f, -0.08840046f, 
    0.15554702f, -0.11202157f, 0.10256366f, 0.06124362f, -0.01469096f, -0.13442227f, -0.20041232f, -0.11253635f, 
    0.03059484f, 0.12573093f, 0.05031107f, 0.18892971f, -0.00365223f, 0.04567147f, 0.08821825f, 0.00639211f, 
    0.33923057f, 0.47301093f, -0.15583961f, 0.40187126f, 0.08582228f, 0.05257076f, -0.03098592f, -0.22526404f, 
    -0.09655387f, 0.12496451f, 0.06795947f, 0.04777756f, 0.25580418f, -0.31002051f, 0.41175050f, 0.01033791f, 
    -0.02274377f, -0.25342962f, -0.12213612f, -0.06250091f, 0.18969736f, -0.01647329f, 0.10058238f, 0.08600891f, 
    0.06739973f, -0.17976789f, -0.01629567f, -0.19265057f, -0.06412647f, -0.08687264f, 0.25770357f, 0.22517608f, 
    -0.05955758f, -0.16394264f, 0.06868662f, -0.04257844f, 0.09324219f, 0.04134978f, 0.17578073f, 0.03627549f, 
    0.03806634f, -0.05787541f, -0.01198253f, 0.18902780f, 0.13825570f, 0.19947498f, 0.06447011f, 0.14512222f, 
    -0.48065081f, -0.21217440f, -0.21674949f, -0.20929056f, -0.08541587f, 0.21425846f, 0.10417598f, 0.11551152f, 
    0.18242356f, -0.03370815f, -0.11663444f, 0.05702341f, 0.36857697f, 0.13692968f, 0.13144444f, 0.04955843f, 
    0.20145546f, -0.04933779f, 0.19361454f, -0.13318621f, 0.13473365f, -0.06787064f, 0.08884306f, -0.00840461f, 
    -0.00468943f, -0.19726934f, 0.01144891f, -0.07497335f, 0.08947742f, 0.13520131f, 0.21259286f, -0.19983079f, 
    0.26468870f, -0.04966487f, -0.00109665f, 0.10709569f, 0.37250444f, 0.11894979f, -0.17337734f, -0.02793306f, 
    0.15530749f, 0.16711262f, 0.13128991f, 0.06302353f, 0.14107819f, 0.18349628f, -0.01036335f, -0.35619578f, 
    -0.22103362f, 0.17347981f, -0.05613938f, 0.03263469f, -0.08480816f, -0.06954776f, -0.01651757f, -0.19361512f, 
    0.05674880f, 0.10973787f, 0.02553776f, 0.16904855f, -0.01035251f, -0.25842237f, 0.11521959f, -0.18553604f, 
    -0.06918055f, -0.16394004f, -0.10724700f, -0.12737870f, 0.03547614f, 0.00550936f, 0.18676768f, -0.08712903f, 
    -0.02085465f, -0.03314112f, -0.16030470f, -0.02203619f, 0.18754175f, 0.11666494f, -0.00095074f, 0.19855465f, 
    -0.11350164f, 0.03760872f, -0.17042175f, -0.15366985f, -0.30783585f, 0.38840637f, -0.10864306f, 0.23549360f, 
    0.21460874f, 0.00927458f, 0.00066174f, -0.05515402f, 0.04961779f, -0.01682523f, 0.07868554f, 0.08015774f, 
    0.05014950f, 0.02547023f, -0.05807505f, 0.36709729f, 0.11137844f, 0.18498877f, 0.07533745f, 0.12309158f, 
    0.03767387f, 0.09839398f, -0.08599485f, 0.11843709f, -0.13242158f, 0.21110687f, 0.22868660f, -0.00255394f, 
    -0.08236926f, -0.16241904f, -0.10016334f, -0.08033605f, -0.17479627f, 0.08747732f, 0.07734834f, -0.07749046f, 
    -0.38133582f, 0.12174857f, 0.10073960f, 0.08510847f, -0.28483713f, -0.16076891f, -0.21899718f, 0.02043908f, 
    -0.03871652f, 0.07772052f, 0.05738302f, 0.04311337f, 0.08709476f, -0.13953646f, -0.08823381f, 0.17715840f, 
    0.18676567f, 0.09042442f, 0.02499187f, 0.03608555f, 0.08714098f, 0.00715351f, 0.06201930f, 0.09334963f, 
    0.06544813f, -0.11226007f, 0.41145146f, -0.08612723f, -0.04368494f, 0.02784341f, -0.10466038f, 0.11549185f, 
    -0.04779333f, 0.03184600f, -0.03431391f, 0.07441502f, 0.14153272f, 0.03434839f, -0.28823543f, -0.20099439f, 
    -0.00410633f, 0.00656445f, 0.13680495f, 0.02588654f, -0.00841358f, 0.11585068f, -0.00545374f, 0.20701009f, 
    -0.06127908f, -0.00157587f, -0.21315038f, 0.26208273f, 0.14573111f, 0.00513547f, -0.06845920f, -0.09574933f, 
    -0.00177405f, 0.01754718f, -0.19371493f, -0.10157763f, -0.25709799f, 0.07167831f, -0.04061553f, 0.15763532f, 
    0.02859479f, 0.09431198f, 0.14301851f, -0.05360701f, 0.11691106f, 0.11968433f, 0.04051924f, 0.00311396f, 
    0.37742937f, -0.06029378f, 0.05223334f, 0.17728077f, 0.30664459f, 0.18780583f, -0.00272875f, 0.03399102f, 
    -0.01428256f, 0.08193994f, 0.03139792f, -0.02548297f, -0.26845413f, 0.12390804f, 0.13927001f, -0.10669713f, 
    -0.05290568f, -0.05701238f, -0.10411914f, -0.03088640f, 0.05782489f, 0.04463939f, -0.09185380f, -0.00971737f, 
    -0.22495608f, 0.22589277f, -0.10523447f, -0.07928663f, -0.00358838f, -0.09214911f, -0.17297338f, -0.00739911f, 
    -0.06530567f, 0.13992649f, 0.21179149f, -0.00887928f, -0.19250146f, -0.00647841f, 0.27005413f, 0.20091358f, 
    -0.20522673f, -0.00247568f, 0.02131044f, 0.01849751f, 0.04213236f, 0.01963669f, -0.07927787f, -0.17855752f, 
    0.23404942f, -0.00490613f, 0.00919289f, -0.03714912f, -0.18471561f, -0.26172832f, -0.06535361f, -0.10569219f, 
    -0.04694416f, -0.07223767f, 0.06408141f, 0.10305040f, 0.69188684f, -0.03998785f, -0.27016208f, -0.08845463f, 
    0.15633297f, 0.16511716f, 0.10471915f, -0.11334950f, -0.05688817f, 0.12656687f, -0.07264840f, -0.05764509f, 
    0.02818378f, -0.37263313f, -0.23840629f, 0.00800018f, 0.06120855f, -0.05992390f, 0.07142776f, -0.25929025f, 
    -0.00711314f, 0.01606798f, 0.00388729f, 0.08959685f, -0.09924629f, 0.10907979f, -0.13085701f, 0.36336872f, 
    0.01852108f, 0.09653340f, -0.00735160f, 0.08425511f, 0.00052198f, 0.02326520f, 0.15959305f, 0.06653816f, 
    -0.26411262f, -0.25452542f, 0.04654967f, 0.34188896f, -0.07795751f, 0.05045405f, 0.06371044f, 0.05754939f, 
    -0.10336625f, 0.02373561f, 0.02030478f, -0.04084301f, 0.29668456f, 0.39892772f, 0.38960999f, -0.23446463f, 
    -0.04064842f, 0.00803232f, -0.02493186f, -0.15847546f, -0.12008916f, -0.01449358f, 0.02577736f, -0.16686414f, 
    0.07759455f, -0.00170305f, 0.33298925f, 0.01231016f, -0.05500071f, 0.03198493f, 0.04145911f, -0.07116657f, 
    -0.03604069f, 0.05220653f, 0.03580530f, 0.10541293f, -0.06202138f, -0.11940197f, -0.16767496f, -0.07632180f, 
    -0.04517419f, -0.00086175f, -0.11603202f, 0.05682343f, -0.11387593f, -0.03648295f, 0.02838055f, -0.02517081f, 
    0.35004815f, 0.17134817f, 0.22587843f, -0.09667291f, -0.04256602f, -0.04269720f, 0.04804027f, 0.06720474f, 
    -0.14385365f, -0.11056317f, 0.11689042f, -0.02727017f, -0.26009050f, 0.10602421f, -0.32246137f, -0.09116281f, 
    -0.02924646f, 0.13494791f, 0.05841855f, 0.02730700f, 0.15107708f, 0.15524653f, 0.05795231f, -0.02894489f, 
    -0.14414425f, 0.07865826f, -0.29380032f, -0.01829535f, 0.00521089f, -0.02138666f, 0.09464193f, 0.04401853f, 
    0.07218767f, 0.02748273f, -0.08197929f, 0.05571324f, 0.01126924f, 0.04664883f, 0.23834857f, 0.08780878f, 
    0.02791493f, 0.21421291f, 0.07044736f, 0.02198322f, 0.28648251f, 0.02378030f, 0.08051959f, 0.17196637f, 
    0.02219341f, 0.34461010f, -0.06645701f, 0.34058651f, 0.09059194f, -0.08172035f, 0.22493401f, -0.09771351f, 
    -0.18902525f, 0.05308817f, -0.01069229f, -0.13560943f, 0.35359988f, 0.19747514f, 0.18455051f, 0.03846063f, 
    0.01506370f, 0.07582851f, -0.08540913f, 0.05735644f, -0.13040526f, -0.01403669f, 0.00048750f, -0.07136611f, 
    -0.01453470f, 0.24714358f, 0.00292104f, 0.07203873f, 0.07290253f, 0.01508674f, 0.09995995f, 0.10141360f, 
    0.10230861f, 0.09009336f, 0.12874685f, -0.01195168f, -0.15257847f, -0.02365663f, 0.19294722f, 0.26785859f, 
    -0.05452402f, 0.11080314f, 0.08017752f, 0.21703047f, 0.20739776f, -0.05457305f, 0.07355046f, 0.01079993f, 
    0.08169265f, 0.19112276f, 0.04562038f, -0.17536436f, -0.13159619f, 0.17352946f, 0.04824497f, 0.04633604f, 
    0.00419675f, 0.03039114f, 0.16847150f, 0.03249447f, 0.06296101f, -0.10695974f, -0.34739453f, -0.43775380f, 
    0.08869857f, 0.02459615f, -0.13442388f, -0.23237140f, 0.09598445f, 0.05664823f, 0.14063425f, -0.04076551f, 
    -0.06800113f, -0.00948267f, -0.00713762f, 0.02685812f, -0.01553895f, -0.02566563f, -0.00859862f, 0.06044201f, 
    -0.00952683f, -0.01546409f, 0.03586465f, 0.04356030f, -0.06805217f, -0.06615072f, -0.01166665f, -0.01826907f, 
    0.04837913f, 0.02155917f, 0.01007997f, 0.06033003f, 0.00148527f, -0.02647016f, 0.02411393f, -0.00816634f, 
    -0.02724756f, -0.04563797f, -0.01870649f, 0.05597432f, 0.00833188f, -0.05948502f, 0.02346462f, 0.02543722f, 
    -0.05055599f, 0.02083027f, 0.04846993f, -0.03135092f, 0.05987041f, -0.05557622f, 0.04674965f, -0.06634273f, 
    -0.02216568f, 0.02224226f, -0.03734456f, 0.04290070f, 0.00497305f, -0.05722498f, -0.07613091f, 0.04896933f, 
    -0.01403056f, 0.01562617f, -0.03529782f, 0.05892535f, -0.00956246f, 0.01820205f, -0.07108008f, -0.01080367f, 
    -0.07104460f, 0.00368976f, -0.07681949f, -0.01761909f, -0.04123079f, -0.00151278f, 0.04532504f, -0.07390414f, 
    0.04010068f, -0.04672989f, 0.01240175f, -0.03947427f, -0.02922151f, 0.03200121f, 0.03736269f, -0.06422622f, 
    -0.01981545f, 0.02295571f, -0.01281333f, -0.07138954f, -0.05189160f, 0.04323510f, 0.01374983f, 0.05088668f, 
    -0.02587906f, 0.01395932f, 0.05950582f, 0.05638038f, 0.04374724f, 0.01513512f, 0.05590388f, -0.01060752f, 
    -0.04469251f, 0.02550824f, 0.01341076f, -0.02468535f, -0.07400509f, 0.01032014f, 0.02165877f, -0.03944574f, 
    -0.05512056f, 0.05868403f, -0.04658556f, 0.00596494f, -0.06003029f, -0.05833354f, 0.05965287f, 0.04068203f, 
    -0.06056810f, -0.05201420f, 0.01191357f, -0.06525522f, -0.06533466f, 0.01802852f, -0.00743110f, -0.07408932f, 
    0.01882605f, -0.05890528f, -0.03874870f, -0.03764449f, 0.05487874f, -0.08005366f, 0.00512260f, 0.04542473f, 
    0.06017894f, 0.04430453f, -0.01379033f, -0.06483079f, 0.04092120f, -0.03360249f, 0.00643841f, -0.00067035f, 
    0.05205132f, -0.04326512f, -0.07508957f, -0.06589335f, 0.02425710f, 0.01605109f, -0.06666560f, 0.06072614f, 
    -0.07559949f, -0.01030419f, -0.04297423f, 0.05631277f, -0.03907954f, 0.03833212f, -0.07993882f, 0.05385139f, 
    -0.04621977f, -0.05161411f, 0.04639089f, -0.05355944f, -0.05315251f, -0.03789736f, -0.07130570f, 0.05179773f, 
    0.01248073f, 0.00857569f, 0.01071509f, 0.02861293f, 0.04307782f, 0.02915240f, 0.03664460f, 0.04163324f, 
    -0.06178482f, -0.00173748f, 0.03583182f, 0.02557707f, 0.02279875f, -0.01496705f, -0.04245969f, -0.03767525f, 
    -0.03172582f, -0.07302105f, -0.05764176f, 0.01190393f, -0.02232262f, -0.06993954f, -0.04342087f, 0.03343763f, 
    0.01675911f, 0.00211581f, -0.07515857f, -0.05481331f, 0.03845421f, -0.00140611f, 0.06262507f, 0.02683904f, 
    0.01098461f, -0.02112885f, 0.02263398f, -0.00853282f, -0.06279948f, 0.01204087f, -0.01603140f, -0.07072753f, 
    0.24023412f, 0.21631101f, 0.00418834f, 0.20424505f, 0.18750972f, 0.01658019f, 0.02397451f, 0.23511122f, 
    -0.06103068f, -0.01589872f, -0.03645993f, 0.04426543f, -0.13646212f, 0.35397521f, -0.32042414f, 0.24664295f, 
    0.20984858f, 0.07804324f, 0.02619369f, -0.19957003f, -0.04419179f, 0.15388884f, 0.02482755f, -0.04673685f, 
    0.06891113f, -0.12951270f, -0.04747700f, 0.41545650f, 0.23144160f, 0.14723238f, 0.03461987f, -0.16848820f, 
    -0.11153965f, -0.06123175f, -0.08045462f, 0.11002535f, 0.23211297f, -0.04390772f, 0.56075543f, 0.30134973f, 
    0.20563082f, -0.16541864f, 0.02692781f, 0.07292667f, -0.02947788f, 0.12805815f, 0.10721985f, -0.00675472f, 
    -0.14031376f, -0.40056518f, 0.28478989f, 0.14036161f, 0.03744461f, 0.09890425f, -0.44898736f, 0.03726648f, 
    -0.28852335f, -0.24017055f, -0.09317280f, -0.49083003f, 0.20979612f, 0.19895726f, 0.00892052f, -0.04031896f, 
    0.08275188f, 0.06302325f, -0.05773198f, 0.02338262f, -0.09277848f, -0.02073687f, -0.15715928f, -0.33486256f, 
    -0.01532033f, -0.25650361f, 0.23321190f, -0.19487940f, -0.17105982f, -0.11954848f, 0.05321928f, -0.05942733f, 
    0.02436060f, -0.02156442f, 0.03806898f, 0.05131447f, 0.02638229f, 0.29158267f, 0.19474092f, -0.06347436f, 
    0.25024310f, -0.00673404f, -0.14510186f, -0.21386024f, -0.12816295f, -0.09962489f, -0.09387868f, -0.13866858f, 
    0.09401717f, 0.02717006f, -0.05795697f, 0.31568387f, 0.25036287f, 0.03082860f, 0.07476176f, 0.12475071f, 
    0.07584387f, 0.25639600f, 0.17753443f, 0.28815532f, -0.38125747f, 0.03333223f, -0.04183473f, 0.11267336f, 
    -0.02076240f, -0.13818285f, -0.04936204f, -0.26972213f, -0.26649407f, -0.10263704f, -0.12077311f, -0.27198660f, 
    -0.05510633f, -0.23266245f, -0.17827646f, -0.05097430f, 0.25006020f, 0.15973327f, -0.15475801f, -0.14939307f, 
    0.13468434f, 0.13382395f, 0.06285002f, 0.04629349f, -0.18131046f, 0.11918981f, -0.12144060f, -0.06906619f, 
    -0.24150805f, -0.12026787f, 0.04737457f, -0.09709228f, -0.11783135f, -0.07285116f, 0.04433370f, 0.06526783f, 
    -0.18607774f, 0.02978729f, -0.18349588f, 0.21776146f, 0.02978498f, -0.19577740f, 0.00424322f, 0.05895577f, 
    -0.18550420f, 0.02277680f, -0.15872426f, -0.35208002f, -0.33870757f, -0.19123761f, 0.15035062f, 0.22749057f, 
    -0.11186776f, 0.00669651f, -0.01714567f, -0.13165617f, 0.11016725f, -0.00392214f, 0.20106804f, 0.28455108f, 
    -0.16325246f, -0.22027571f, -0.19299217f, 0.15804674f, 0.19980979f, -0.06039867f, -0.60538411f, -0.13986266f, 
    -0.21380334f, -0.20883846f, -0.13293892f, -0.24475163f, 0.23815683f, -0.04345183f, 0.04752143f, 0.20121957f, 
    0.31599039f, 0.19438003f, 0.11793315f, -0.25203606f, -0.02673014f, 0.08162995f, 0.32309040f, 0.18659526f, 
    -0.19856204f, -0.12456457f, 0.02370074f, -0.12224142f, 0.08343983f, -0.01503102f, -0.01524290f, -0.14567493f, 
    0.07426631f, -0.01785447f, 0.13914283f, 0.09830462f, -0.12705040f, 0.11172882f, 0.01470041f, 0.20167284f, 
    0.12622125f, 0.17761099f, 0.05572740f, -0.14860947f, -0.02259124f, 0.08933669f, 0.14807568f, 0.13017455f, 
    -0.20486031f, 0.03394530f, 0.10640512f, 0.33176476f, 0.11348499f, -0.05036484f, -0.02157962f, -0.10821432f, 
    0.20355605f, 0.04472768f, 0.10843799f, 0.10453727f, -0.31932223f, 0.07496417f, 0.00296370f, 0.11216754f, 
    0.12184012f, 0.14432180f, 0.06881607f, -0.11134177f, -0.08080976f, -0.05071433f, 0.05321839f, -0.05574742f, 
    -0.35624495f, -0.09660174f, 0.11656507f, -0.14897253f, 0.00882998f, 0.15716229f, 0.14976400f, -0.02410326f, 
    0.11830911f, -0.01427310f, 0.02330687f, -0.00365890f, -0.03228568f, -0.38629028f, -0.35329247f, -0.13937394f, 
    0.02544617f, 0.05182936f, -0.11732642f, 0.02395864f, 0.14696875f, 0.13204303f, -0.01160356f, 0.03234012f, 
    0.25229737f, 0.10395803f, -0.15656224f, 0.09047079f, 0.00320327f, 0.00181500f, 0.08932310f, -0.09209705f, 
    -0.01587027f, 0.05005243f, -0.01044166f, -0.16716938f, 0.11589051f, 0.12411473f, 0.28461319f, -0.12329478f, 
    0.07116165f, -0.08146365f, -0.09708764f, 0.16773364f, 0.13782848f, 0.04011767f, 0.03342555f, 0.16810030f, 
    -0.19511111f, -0.15056138f, -0.22501546f, -0.08916413f, -0.09279624f, 0.08315833f, 0.26258323f, 0.15548342f, 
    -0.02992480f, -0.10680228f, 0.16109374f, 0.04485547f, 0.01709920f, 0.44370943f, 0.04690167f, 0.04191622f, 
    -0.06105245f, -0.03031465f, 0.02494506f, 0.18537679f, 0.02719045f, 0.01604502f, 0.16648796f, 0.05321034f, 
    -0.53665048f, -0.29788423f, 0.46167213f, 0.10210166f, 0.10558046f, 0.01203813f, 0.04037859f, -0.04294808f, 
    0.11664729f, 0.05180100f, -0.00394120f, 0.18648967f, 0.15754962f, -0.32156396f, -0.08332849f, 0.10009151f, 
    -0.01829594f, 0.06902689f, 0.18912826f, -0.02838168f, 0.06311662f, 0.08078660f, 0.09811977f, -0.03768171f, 
    -0.16238676f, -0.03246722f, -0.04254890f, -0.02649593f, 0.16567495f, 0.04715838f, 0.06072330f, -0.12075396f, 
    0.07825249f, 0.06737757f, 0.01450024f, 0.01940394f, 0.04412358f, 0.33174869f, -0.15734331f, -0.06119103f, 
    0.04602011f, 0.17886904f, 0.00733207f, -0.08257466f, 0.22863917f, 0.11803283f, -0.03363545f, -0.07747447f, 
    -0.19162260f, -0.01216906f, -0.03893990f, -0.10677662f, -0.03891682f, -0.09837125f, 0.02130678f, -0.03050412f, 
    -0.00835621f, 0.03394405f, 0.06026652f, -0.21026558f, -0.03887133f, -0.03583050f, 0.32682204f, 0.23469487f, 
    0.05252309f, -0.04456479f, 0.08878987f, 0.03478523f, 0.02170621f, 0.02534970f, 0.07383732f, -0.03702305f, 
    0.18887824f, 0.40133187f, 0.21920469f, 0.02874931f, -0.04243475f, -0.02458611f, 0.14941198f, -0.00143421f, 
    0.00003433f, -0.02477545f, -0.04444351f, 0.03824300f, -0.01105242f, 0.62044394f, 0.00384742f, 0.02903597f, 
    -0.07566298f, -0.02889484f, 0.23591539f, -0.09933210f, 0.01944214f, 0.09567391f, 0.12390488f, 0.00587200f, 
    -0.19748031f, 0.06338133f, -0.31238076f, 0.17511483f, 0.14818783f, 0.19986814f, 0.06849290f, -0.02356980f, 
    0.18139322f, 0.09630363f, 0.04897216f, 0.06608911f, 0.11666537f, -0.36586687f, 0.51260436f, -0.00457763f, 
    0.03375314f, 0.03001407f, -0.09452087f, 0.03831779f, 0.03656461f, -0.02324605f, -0.03653275f, -0.00499188f, 
    -0.25884277f, -0.13353720f, 0.11130401f, -0.00445271f, 0.10624013f, 0.08416165f, -0.07671829f, -0.12243389f, 
    0.03612089f, -0.05895095f, 0.11342704f, 0.06049224f, 0.27465674f, 0.31771773f, -0.08168117f, -0.01718922f, 
    0.10366033f, 0.02077371f, 0.13861427f, 0.09483071f, 0.02596056f, 0.13001139f, 0.03742432f, -0.04312074f, 
    0.19142778f, -0.07234222f, 0.30464906f, 0.10839184f, 0.15387025f, -0.14274050f, -0.10524208f, 0.05299776f, 
    -0.04699423f, 0.19585119f, 0.14669819f, 0.13301662f, 0.04547682f, -0.34150472f, -0.04810216f, -0.26126072f, 
    -0.03484748f, -0.03841733f, 0.06047194f, 0.03945354f, 0.30368236f, -0.10049565f, -0.03363271f, -0.04625069f, 
    0.22474729f, -0.13524853f, -0.02042003f, 0.23184289f, 0.04756835f, -0.14664459f, -0.02394032f, 0.00771769f, 
    -0.06144918f, -0.03016286f, -0.02757215f, 0.03270108f, -0.07375330f, -0.18262635f, -0.09351435f, 0.23430984f, 
    0.17334127f, 0.04130021f, 0.15926138f, 0.15312812f, 0.13905111f, 0.12359017f, -0.15977499f, 0.00942993f, 
    -0.10718998f, 0.25259680f, -0.03015585f, -0.01335784f, 0.12527488f, 0.32497960f, 0.09253369f, -0.15950172f, 
    0.03256277f, -0.14465691f, -0.01493070f, 0.06551256f, 0.13201796f, 0.07331766f, 0.30007464f, -0.02260950f, 
    -0.04071052f, -0.08227029f, -0.08763813f, 0.06535751f, 0.18837053f, -0.08996865f, 0.05493934f, 0.05989742f, 
    -0.05875694f, 0.03697696f, -0.08167227f, 0.07448807f, -0.18186146f, -0.04147831f, 0.13564998f, -0.11715423f, 
    0.07731100f, -0.04507577f, 0.05480387f, -0.02651897f, 0.22985712f, -0.34287453f, -0.20264848f, 0.23032731f, 
    0.01234771f, -0.01890621f, 0.14431863f, -0.01712242f, -0.00788282f, 0.05475098f, -0.12988113f, -0.29775777f, 
    -0.07161174f, 0.05028153f, -0.12356634f, 0.01088244f, -0.08381305f, 0.09189446f, -0.17557694f, 0.06690250f, 
    -0.19178848f, 0.06195009f, 0.02487936f, 0.03831876f, 0.06944550f, -0.47837251f, -0.30278903f, -0.06025823f, 
    0.15518914f, -0.02756709f, 0.16071363f, -0.00497495f, 0.00129533f, -0.04617069f, 0.15781409f, -0.05868981f, 
    -0.06817852f, -0.00179698f, 0.06039331f, -0.00611097f, -0.07640592f, -0.01721000f, 0.02588618f, -0.01463517f, 
    0.03383097f, 0.01944016f, -0.05408193f, 0.03941021f, 0.02574395f, -0.06828394f, -0.03606663f, -0.04312023f, 
    -0.07792673f, -0.01319380f, 0.03989749f, -0.07507208f, 0.02497078f, 0.03366915f, -0.02561065f, 0.01699558f, 
    0.00148171f, 0.03217755f, 0.01821525f, -0.01320674f, 0.02670449f, -0.07503367f, 0.00667655f, -0.04229267f, 
    -0.00215860f, 0.02783430f, 0.04679555f, -0.04139686f, 0.02241580f, -0.06425316f, -0.05376539f, 0.01376154f, 
    0.00306946f, -0.01388784f, -0.00428175f, 0.04024060f, 0.01445122f, -0.06361692f, 0.06243014f, 0.02329018f, 
    -0.02149638f, 0.01628742f, -0.07617537f, -0.00637700f, -0.00043294f, -0.01947067f, 0.02282297f, -0.05350715f, 
    -0.05489733f, 0.00752962f, -0.03653178f, -0.03611800f, 0.00487280f, 0.03316595f, -0.04757969f, 0.01703919f, 
    0.02076787f, 0.00687499f, -0.05302051f, -0.03574316f, -0.04342588f, -0.03448176f, -0.04587135f, 0.04147547f, 
    0.02872282f, -0.05904003f, -0.04818900f, -0.06342056f, -0.05760801f, -0.04754268f, -0.01453733f, -0.00009115f, 
    -0.03807849f, -0.03699318f, 0.02174858f, 0.04685289f, -0.05071943f, -0.07009557f, 0.01684149f, 0.05848449f, 
    0.02441677f, -0.03492117f, -0.05180919f, 0.05504231f, 0.04607955f, 0.00828383f, -0.00900235f, 0.01374681f, 
    0.04120268f, -0.02142426f, -0.00522257f, -0.03810762f, -0.06226550f, -0.06207230f, 0.06415620f, -0.04410690f, 
    -0.05148382f, 0.05417635f, -0.03812986f, -0.06344537f, -0.05364181f, 0.01344854f, -0.07313494f, 0.00536815f, 
    0.05362243f, 0.03345195f, -0.04376451f, -0.01877057f, 0.05659473f, 0.01752817f, 0.06187857f, -0.07560180f, 
    0.02689739f, -0.06979651f, 0.03042543f, 0.05898358f, -0.05126532f, -0.04212437f, -0.02304632f, -0.02806112f, 
    -0.05893668f, 0.03075682f, -0.07429019f, 0.05366903f, -0.02511596f, -0.07414062f, -0.02820322f, -0.04689587f, 
    -0.06388030f, -0.04569702f, 0.00102796f, 0.00435480f, 0.05433838f, -0.07713094f, 0.02322596f, 0.01185326f, 
    -0.05851334f, -0.05563057f, 0.04687381f, -0.03482481f, -0.07456625f, 0.03092783f, 0.03141869f, -0.05403092f, 
    -0.05424902f, 0.05422037f, 0.00631493f, 0.00419209f, -0.03311025f, -0.04500997f, -0.04251635f, -0.01842341f, 
    -0.05780645f, 0.01135003f, -0.05967344f, 0.04235829f, -0.03401361f, -0.03889999f, 0.06123485f, -0.07286770f, 
    0.01740599f, 0.03183147f, 0.06343105f, -0.02577325f, -0.00447701f, 0.04115174f, 0.02580270f, 0.01817106f, 
    -0.07606272f, -0.03076928f, -0.07245918f, -0.00041407f, 0.04645928f, 0.04319027f, -0.02595738f, -0.02477260f, 
    0.00253379f, 0.04801968f, -0.05387689f, -0.02326753f, -0.02361954f, -0.06608783f, -0.03012603f, -0.06384728f, 
    -0.08113071f, 0.15227070f, -0.04313131f, 0.11870044f, -0.00943717f, 0.12113802f, 0.07478025f, 0.37045825f, 
    -0.04597001f, 0.03866846f, -0.05341509f, -0.07169604f, -0.11597209f, 0.43989664f, 0.02553056f, 0.09872928f, 
    0.04192938f, 0.15329091f, 0.14850180f, -0.03520137f, 0.17356125f, -0.05943701f, 0.10842396f, 0.15305574f, 
    0.36671695f, 0.27656478f, 0.12393578f, 0.10675112f, 0.08597407f, 0.24130158f, 0.13962144f, 0.14428096f, 
    -0.05494980f, 0.13240698f, -0.05526963f, 0.17518526f, -0.19999711f, 0.07448171f, -0.10647813f, -0.17042448f, 
    -0.21109743f, -0.18499891f, -0.06500067f, 0.05066633f, -0.05713672f, -0.02019193f, -0.09276455f, -0.03784464f, 
    -0.49229863f, -0.02872283f, -0.24868414f, 0.10641684f, -0.11871018f, -0.09621186f, -0.08422402f, 0.02729283f, 
    0.03495732f, 0.06689786f, -0.00214712f, 0.04635822f, 0.10609782f, 0.08414797f, 0.15592524f, 0.20615181f, 
    0.15076375f, 0.18291464f, 0.23687628f, 0.18477112f, 0.03668931f, 0.05514944f, 0.17281482f, 0.21933503f, 
    -0.51497799f, -0.13927566f, 0.17574316f, -0.00199320f, 0.00512710f, -0.04763670f, -0.06050383f, 0.04295731f, 
    0.13571259f, 0.03767718f, -0.17034490f, 0.08984468f, 0.01075236f, 0.07113458f, -0.16931863f, 0.13870187f, 
    -0.00310783f, -0.08121800f, 0.09947432f, -0.13776036f, -0.03435069f, -0.01628574f, 0.10204282f, 0.26915413f, 
    0.00250104f, -0.04881162f, 0.09807137f, 0.29888588f, 0.08036164f, 0.01642774f, -0.30409893f, -0.02198083f, 
    0.06315175f, -0.03103459f, -0.11240244f, 0.05741905f, 0.00053741f, -0.02974190f, 0.05128405f, 0.18488395f, 
    0.07536630f, 0.15187523f, 0.09487349f, -0.17013951f, 0.23319913f, 0.24234840f, 0.06931165f, 0.05317124f, 
    0.52829736f, -0.03522232f, 0.06628323f, 0.08848332f, 0.12707289f, 0.12049231f, -0.06428071f, 0.04259650f, 
    0.04068420f, -0.07359613f, 0.10712284f, 0.10212353f, -0.29711714f, -0.01353811f, 0.12568246f, 0.04290457f, 
    0.00764574f, -0.09611085f, -0.04677213f, 0.00830135f, 0.10803027f, -0.05856825f, -0.08506188f, 0.00867218f, 
    -0.19855613f, -0.14451930f, -0.19192019f, -0.20965430f, -0.09319825f, -0.01581065f, -0.04780622f, 0.01375971f, 
    -0.04618854f, 0.07677774f, 0.20543328f, 0.12968656f, -0.20087077f, 0.00146434f, 0.31575981f, 0.32172537f, 
    0.00323745f, 0.02398374f, -0.05566225f, -0.05319357f, -0.15154831f, 0.01417234f, -0.12801924f, -0.06543020f, 
    -0.12234104f, -0.07483912f, 0.11885331f, -0.01117077f, -0.13695221f, -0.14319912f, -0.09153687f, -0.19456293f, 
    -0.02417460f, -0.01273592f, 0.10023710f, 0.17483930f, 0.27599305f, -0.12107901f, -0.20938456f, 0.32192871f, 
    0.19682853f, -0.06857283f, -0.09202810f, -0.22917964f, -0.03585305f, 0.00217593f, -0.05308085f, 0.07174478f, 
    -0.02843785f, -0.02088849f, -0.03312586f, -0.06350955f, 0.06372378f, 0.01235145f, 0.05014431f, 0.00594699f, 
    0.02180488f, 0.04374970f, -0.00716747f, -0.06459470f, 0.04558694f, 0.03129478f, -0.02374215f, -0.00169050f, 
    -0.05105758f, -0.00717853f, 0.03708683f, -0.07258219f, 0.02812349f, 0.04515645f, -0.04726921f, 0.04338617f, 
    -0.00771619f, 0.01455887f, -0.00010960f, -0.02088861f, 0.02069121f, -0.05994632f, -0.00590593f, -0.02710614f, 
    0.01794922f, 0.02817094f, -0.03835820f, 0.03958448f, -0.01344604f, 0.03324508f, -0.02942652f, 0.02487149f, 
    0.01729928f, 0.00702325f, -0.03283257f, -0.01518451f, 0.05241131f, -0.03066115f, 0.01451666f, 0.02319987f, 
    -0.05811485f, -0.03499151f, -0.00521658f, 0.00268186f, 0.04890661f, -0.02940314f, 0.01608619f, 0.05371115f, 
    0.02654298f, -0.04436321f, -0.07090468f, 0.02665219f, 0.01965382f, 0.04076985f, -0.06178227f, 0.01092788f, 
    0.03887777f, 0.00033383f, -0.00436088f, 0.00882203f, -0.00862406f, -0.04612947f, -0.00946904f, -0.00888289f, 
    -0.04862741f, -0.04513905f, -0.00128315f, 0.00164946f, -0.03456881f, -0.02136042f, 0.02313181f, 0.04534687f, 
    0.00476427f, 0.00473574f, 0.01043964f, -0.01711512f, -0.02519412f, -0.01442555f, 0.00758476f, 0.02802042f, 
    0.04937522f, 0.00860545f, -0.04794697f, 0.01470091f, -0.06466240f, -0.01467333f, -0.01234199f, 0.01958191f, 
    0.01351679f, -0.03050638f, 0.04151993f, -0.02824147f, 0.00112956f, 0.02537965f, -0.05639844f, -0.07257624f, 
    0.04373765f, -0.06077558f, 0.04059377f, 0.04116254f, -0.03727941f, -0.01167912f, -0.01235632f, 0.05711783f, 
    0.02781441f, 0.04410974f, -0.04185025f, -0.06813306f, -0.00969854f, -0.00205375f, -0.01572267f, -0.06643962f, 
    -0.06160636f, -0.07116326f, 0.00620862f, 0.01978622f, -0.06005210f, -0.02671549f, -0.05195442f, 0.01613049f, 
    0.05805696f, -0.01704287f, 0.02577815f, -0.04859902f, -0.03201408f, -0.03938311f, 0.05612965f, -0.07149401f, 
    0.02341234f, 0.06665301f, 0.00314455f, 0.02774881f, -0.04949486f, -0.01820446f, 0.02318483f, -0.06641727f, 
    -0.02534851f, 0.03993156f, -0.00432330f, 0.00206726f, -0.00810714f, 0.02121109f, 0.05968349f, 0.06823278f, 
    -0.07536280f, 0.03921076f, -0.01694123f, -0.05866710f, -0.05586683f, -0.05493879f, 0.00015199f, 0.01668185f, 
    -0.03722434f, 0.00957685f, -0.05118954f, -0.04249038f, -0.01915741f, -0.03240307f, -0.02661395f, 0.00713418f, 
    -0.03597485f, -0.02093454f, -0.06304155f, -0.01466721f, -0.04945575f, -0.02515147f, 0.02180183f, -0.05532249f, 
    0.00327032f, 0.01615755f, -0.05059915f, 0.05111871f, 0.00061085f, 0.02970160f, 0.04755893f, -0.05317924f, 
    -0.01036099f, 0.02267916f, -0.04109064f, -0.02445193f, 0.01408027f, -0.03383241f, 0.00657474f, -0.07483689f, 
    -0.06125139f, -0.28324702f, -0.01415181f, 0.26931512f, 0.10189505f, 0.02191416f, 0.02192123f, -0.00177426f, 
    -0.09233385f, -0.01032134f, 0.01253987f, 0.04356923f, -0.18579592f, -0.07792973f, 0.04622858f, 0.12263960f, 
    -0.01233195f, -0.03768816f, 0.05188760f, 0.17430043f, 0.02094292f, -0.02349685f, 0.03719094f, -0.12397974f, 
    -0.16644022f, -0.22070220f, -0.04966455f, 0.23387419f, 0.05040533f, -0.10854075f, 0.17818917f, 0.15210795f, 
    0.07365062f, 0.04398445f, 0.08718430f, 0.05316395f, 0.33335567f, 0.14776753f, 0.02882688f, 0.01274203f, 
    -0.04304192f, -0.07090901f, 0.05953645f, 0.05292528f, 0.12331443f, 0.08738844f, 0.15920921f, 0.14334857f, 
    0.50885302f, 0.27917013f, 0.14031202f, 0.15914233f, -0.20043100f, -0.09560064f, 0.08988279f, 0.05782287f, 
    -0.01459458f, -0.17161962f, -0.09010130f, -0.15481688f, -0.05325960f, -0.18981679f, -0.12366794f, -0.00266631f, 
    0.04131816f, -0.07044061f, -0.03541613f, 0.04166388f, 0.04252336f, 0.00677220f, -0.10081151f, -0.05606955f, 
    0.26688558f, 0.06724873f, 0.20122762f, -0.11541224f, -0.05275102f, 0.16596994f, 0.02273824f, 0.02398655f, 
    0.05872762f, 0.03395552f, 0.00283775f, -0.01213971f, 0.39385647f, -0.16159290f, 0.10551421f, -0.08376242f, 
    0.05580314f, 0.05515565f, -0.12615797f, -0.11335590f, -0.12544067f, 0.08224792f, 0.08916885f, 0.19153319f, 
    -0.17312431f, -0.01457277f, -0.11555522f, 0.10042607f, 0.02120511f, 0.11333717f, 0.16996630f, 0.02098334f, 
    0.12048825f, 0.18318340f, 0.11222716f, 0.29196361f, -0.08397310f, 0.09992637f, -0.06186936f, -0.11843611f, 
    -0.11031459f, -0.01119348f, 0.03836929f, 0.08661202f, -0.22410490f, -0.07659806f, 0.32942548f, 0.20155959f, 
    -0.00100563f, -0.30727214f, -0.10486257f, 0.20914719f, 0.06728045f, -0.04512960f, -0.20945624f, 0.08025243f, 
    0.03660529f, 0.10096685f, -0.01460507f, -0.08464601f, 0.45537013f, 0.00376675f, -0.02020046f, -0.13609956f, 
    0.02397359f, 0.04128440f, -0.01624460f, -0.02592871f, 0.06789169f, 0.28271565f, -0.05968076f, -0.02274515f, 
    0.17412078f, 0.08346063f, 0.13700815f, 0.04864941f, -0.03090380f, 0.10930145f, -0.05589845f, 0.06531279f, 
    -0.13420095f, -0.10321312f, -0.06442803f, -0.07566543f, 0.00067884f, 0.15270807f, -0.09461743f, 0.15022609f, 
    -0.07831260f, -0.08151663f, -0.02984867f, 0.20055489f, 0.14330913f, 0.09173482f, 0.37245497f, 0.12812580f, 
    0.23762985f, 0.12689011f, 0.08385104f, 0.00513879f, 0.08013082f, -0.05789140f, 0.01341728f, -0.06122912f, 
    0.10815419f, -0.08891431f, -0.20558724f, -0.21903846f, 0.66957599f, 0.07553541f, -0.17614877f, -0.17211108f, 
    -0.03290857f, -0.10417517f, -0.18548112f, -0.20926823f, 0.00486548f, -0.23017517f, 0.06364032f, 0.20855732f, 
    0.13268684f, 0.12667225f, -0.31129450f, -0.27077204f, 0.06210111f, 0.01148435f, 0.03554005f, 0.17633553f, 
    0.04583526f, 0.13486834f, -0.05050733f, -0.06726271f, -0.05487424f, 0.25507882f, -0.23618609f, 0.07404815f, 
    0.10434946f, 0.12999022f, -0.04530425f, -0.12835802f, 0.11271796f, -0.03542461f, 0.06062260f, 0.15327726f, 
    0.01428479f, -0.01069484f, -0.06188006f, 0.15489885f, -0.05889445f, 0.19212773f, -0.04598673f, 0.04119590f, 
    -0.06581660f, 0.00646044f, 0.00367968f, 0.03118952f, -0.18674955f, 0.21675235f, 0.28577209f, 0.10093639f, 
    -0.05523972f, 0.00195578f, -0.04605996f, -0.12024616f, -0.20203455f, 0.03608320f, -0.03103025f, -0.03440742f, 
    -0.42876452f, 0.04924837f, -0.00684259f, 0.13304296f, -0.09317428f, -0.12328771f, -0.02950170f, 0.01732663f, 
    0.04039539f, 0.09378595f, -0.01223340f, 0.18113686f, 0.01996670f, -0.00098092f, 0.01451748f, 0.02914589f, 
    0.13317929f, 0.05091035f, 0.06285280f, 0.04435698f, -0.01623512f, 0.06082660f, 0.03025870f, 0.17899013f, 
    -0.12571871f, 0.02481314f, 0.33641410f, 0.04366865f, 0.11561564f, -0.01764227f, 0.06260489f, 0.08365011f, 
    -0.05310805f, -0.06997421f, 0.04147909f, 0.16621998f, -0.06564144f, 0.20092128f, -0.41855094f, -0.22702529f, 
    -0.09371128f, -0.00570816f, 0.18790293f, 0.04597059f, 0.03699232f, -0.00676746f, 0.05351287f, 0.06452490f, 
    -0.02866400f, 0.02075063f, -0.20983396f, 0.17525937f, 0.15426414f, 0.09846033f, -0.07232792f, -0.02805673f, 
    -0.03862834f, -0.06729616f, -0.19345507f, -0.17125550f, -0.04873184f, 0.00811053f, 0.07229400f, 0.07321722f, 
    -0.00099024f, 0.02661039f, 0.06836006f, -0.11374681f, 0.26970929f, 0.08449350f, 0.02370340f, -0.02058513f, 
    0.37742496f, 0.10425424f, -0.04462568f, 0.07659686f, 0.21729556f, 0.16656999f, 0.11460730f, 0.12587284f, 
    -0.11868829f, 0.01365823f, -0.08740743f, -0.10040993f, -0.45001873f, 0.40082756f, 0.03564899f, 0.02569677f, 
    -0.06776768f, -0.05513099f, 0.03312478f, -0.01567531f, -0.06570874f, -0.01226975f, 0.12288056f, 0.01094227f, 
    -0.20064600f, 0.10040499f, 0.00249733f, 0.03074778f, 0.01496410f, -0.07308634f, -0.17575651f, -0.20420431f, 
    -0.14180912f, 0.12280872f, 0.21018644f, 0.02340168f, -0.21428917f, -0.13693503f, 0.35545266f, 0.18696392f, 
    0.07111028f, 0.07081404f, 0.02477976f, 0.06192530f, -0.06366344f, -0.03313480f, -0.27765533f, -0.10238066f, 
    -0.15486109f, -0.00878409f, -0.02024806f, -0.11552094f, -0.14635594f, -0.01666806f, 0.04350826f, -0.01574796f, 
    -0.17269334f, 0.11010019f, 0.14851756f, 0.31793547f, 0.28226963f, -0.12818123f, -0.21759038f, -0.11125170f, 
    0.12570404f, 0.11548074f, 0.09451305f, 0.04669600f, -0.01936557f, 0.01211692f, -0.09563676f, -0.11735621f, 
    0.27690595f, 0.41226029f, 0.25671330f, 0.12941599f, -0.06574914f, 0.08691897f, 0.07880725f, 0.33811024f, 
    -0.04601127f, -0.01528590f, 0.00278476f, 0.07589275f, 0.23003279f, 0.24040009f, 0.05359599f, -0.06059512f, 
    0.13188238f, -0.03661962f, 0.07388120f, 0.12403396f, -0.11721582f, 0.03654034f, -0.20523831f, 0.09466383f, 
    0.09316570f, -0.02886740f, -0.01202834f, -0.04392661f, 0.20341542f, 0.03860382f, -0.10778916f, -0.06464504f, 
    0.07372414f, -0.09313736f, 0.20333770f, 0.02664641f, -0.09016237f, -0.83101201f, 0.11365315f, 0.13626879f, 
    0.02467499f, 0.05744454f, 0.04977025f, -0.10081078f, 0.10525466f, 0.00630193f, -0.00492813f, 0.09202986f, 
    -0.04055094f, -0.34537777f, -0.22822234f, -0.02269236f, 0.19313027f, 0.28030789f, -0.01947899f, 0.02443959f, 
    0.03743185f, -0.10477999f, 0.05452602f, -0.08672841f, 0.26703015f, 0.37674433f, 0.34047472f, 0.26183656f, 
    0.08829354f, 0.09371331f, -0.10482111f, 0.04812759f, 0.10401070f, 0.09690884f, -0.00148639f, -0.02427406f, 
    -0.02949126f, -0.12446230f, -0.06658056f, 0.10571083f, 0.05427518f, -0.01409504f, -0.03123952f, -0.05252178f, 
    0.01960125f, 0.05364098f, 0.04694458f, 0.02090719f, 0.31546640f, -0.05699649f, 0.39623639f, 0.02873229f, 
    0.03853851f, -0.07339521f, 0.01577426f, 0.13256016f, 0.19082670f, -0.06223980f, -0.01445800f, -0.08097038f, 
    0.31153858f, 0.07678606f, 0.17047000f, 0.08700269f, 0.21756288f, 0.03152951f, 0.03366814f, 0.21286871f, 
    -0.15043300f, -0.10310653f, 0.05779433f, -0.02101719f, 0.03131839f, -0.15013719f, 0.02372217f, 0.14447050f, 
    0.15521194f, -0.12039234f, 0.00511778f, 0.10613036f, -0.01224519f, -0.04729857f, -0.09120846f, 0.10351542f, 
    -0.15554300f, 0.05267687f, -0.21667415f, -0.25362495f, 0.06370775f, 0.21614403f, 0.21560813f, -0.05831863f, 
    -0.02365744f, -0.12619412f, -0.03981977f, 0.02059359f, -0.05095722f, -0.19382122f, -0.16691701f, -0.14758977f, 
    -0.09421523f, -0.17495733f, -0.03158042f, -0.06598166f, 0.05429433f, -0.19116282f, -0.05308504f, 0.06269604f, 
    -0.00231372f, -0.24077600f, -0.04562246f, -0.02002053f, -0.02096291f, 0.16326943f, 0.31057039f, -0.05118004f, 
    0.09310837f, -0.03423766f, -0.12777101f, 0.11584406f, 0.14616965f, -0.36648828f, -0.22928363f, -0.01658049f, 
    -0.10548505f, 0.00326792f, 0.02329023f, -0.08691332f, -0.05286331f, -0.03771492f, -0.17729382f, -0.09977526f, 
    -0.40156630f, -0.30792007f, -0.40887290f, 0.06564142f, 0.21003023f, 0.01031924f, -0.07936680f, -0.06699803f, 
    0.16524822f, 0.04857140f, -0.03652418f, 0.10360555f, -0.12925513f, 0.01025824f, 0.01067370f, -0.11902197f, 
    0.13285342f, 0.09249369f, 0.15985155f, 0.20847940f, 0.07899711f, -0.02890190f, 0.09122561f, 0.05178683f, 
    -0.10540305f, -0.38915664f, -0.12099563f, -0.01714934f, 0.03767653f, -0.01746833f, -0.00426491f, -0.17736666f, 
    -0.07126292f, 0.11396517f, -0.01364044f, -0.02453006f, -0.28021878f, -0.07955667f, -0.07947491f, 0.36516482f, 
    -0.07848378f, 0.19159792f, -0.12316769f, 0.02720191f, 0.03698093f, -0.01118051f, 0.16849869f, 0.00330890f, 
    0.13945542f, 0.00690386f, 0.33065209f, 0.40018925f, -0.00735877f, -0.05573081f, 0.07256230f, 0.03416457f, 
    0.03685915f, 0.07092994f, 0.10771507f, -0.03120142f, -0.07689377f, 0.43925917f, 0.13185902f, -0.11132318f, 
    0.04709393f, -0.12875243f, -0.08138438f, -0.12300896f, -0.05484891f, 0.09811569f, -0.00553065f, -0.10075864f, 
    -0.03611544f, -0.04577016f, 0.22424655f, 0.09618138f, -0.01755385f, -0.14392307f, -0.03785631f, -0.16723880f, 
    -0.02307988f, 0.08854146f, -0.10112517f, -0.05399543f, 0.10978406f, -0.05978537f, -0.03648075f, 0.15040453f, 
    -0.09502862f, -0.04075706f, -0.10043067f, -0.01453258f, -0.02095458f, -0.07588577f, -0.05019975f, -0.06513073f, 
    0.12888309f, 0.18276510f, 0.02292936f, -0.19905607f, -0.15911633f, -0.18898503f, 0.03596705f, 0.02677018f, 
    -0.00340371f, -0.01079770f, 0.19625077f, 0.05788616f, -0.15730041f, 0.37090209f, -0.22100325f, 0.15529324f, 
    0.06476150f, -0.04297766f, 0.05047616f, 0.13470201f, -0.03321550f, 0.13664550f, 0.01930335f, 0.15570477f, 
    -0.34216493f, 0.04330166f, -0.11363279f, 0.03961666f, -0.14595087f, -0.02553657f, 0.09281790f, 0.04908496f, 
    0.05245845f, 0.18136744f, -0.04248324f, 0.07429124f, 0.05953496f, 0.22073895f, 0.21481675f, -0.00001695f, 
    -0.03808194f, 0.13678466f, -0.19802758f, 0.08788151f, 0.20548256f, 0.00006346f, 0.19880955f, 0.07075270f, 
    0.03283733f, 0.25391698f, 0.17906851f, 0.34078825f, 0.16118926f, -0.08444153f, 0.16521253f, -0.05978249f, 
    -0.14077604f, 0.06264424f, -0.03417644f, -0.10241424f, 0.36480373f, 0.04737599f, -0.02934315f, 0.18509398f, 
    -0.05618295f, 0.07970732f, -0.12523495f, -0.05548362f, -0.18301876f, 0.14702000f, -0.11315379f, -0.04144608f, 
    -0.18413693f, 0.04393850f, -0.10911571f, 0.13797249f, 0.15914948f, -0.01745833f, -0.04489585f, 0.22891812f, 
    -0.09383785f, 0.08665606f, 0.12383292f, 0.03335288f, -0.48082769f, 0.21418613f, 0.26282361f, 0.20405868f, 
    -0.01419388f, 0.04637146f, -0.13573989f, 0.16280468f, 0.18505657f, 0.02648502f, 0.15156248f, 0.25022817f, 
    -0.02714797f, 0.10826246f, 0.20649180f, -0.45214739f, -0.11257190f, 0.07028837f, 0.03151157f, 0.08857250f, 
    -0.02060997f, 0.06051923f, 0.19220440f, 0.10149433f, 0.08142779f, 0.08352822f, -0.10377367f, 0.01930607f, 
    0.09303115f, -0.05962683f, -0.20993610f, -0.06002215f, 0.09040651f, 0.06651557f, -0.04330411f, -0.00506379f, 
    0.24989064f, 0.26937693f, -0.23690850f, -0.15363730f, -0.04888793f, -0.09136627f, -0.09162065f, 0.06307084f, 
    -0.08230487f, 0.02216583f, -0.09327098f, -0.13730638f, 0.33271164f, -0.14690532f, -0.00574283f, -0.09237836f, 
    0.10295255f, -0.07459689f, 0.12140671f, -0.22708096f, -0.01596656f, -0.18548284f, 0.11006498f, 0.09118404f, 
    0.04580406f, 0.02900213f, -0.25828150f, 0.12412130f, 0.08214164f, 0.19708641f, -0.00220432f, -0.00688695f, 
    -0.23725049f, 0.06423691f, -0.12534589f, -0.01533896f, -0.22943564f, 0.04325558f, -0.02704456f, -0.06501066f, 
    0.07387279f, -0.15877579f, 0.01995102f, -0.01905597f, -0.03566086f, 0.10312258f, 0.03761561f, 0.20119035f, 
    -0.18253137f, 0.10176530f, 0.13287906f, -0.05042656f, 0.03389569f, -0.21381091f, -0.04572670f, 0.10350165f, 
    0.13160941f, 0.08001983f, 0.05743118f, -0.02384613f, 0.08287251f, 0.16367169f, -0.04730650f, -0.05924932f, 
    0.02727694f, -0.12179141f, 0.03309669f, -0.18145701f, -0.09500518f, 0.13969657f, 0.00278356f, 0.07365909f, 
    -0.34329277f, 0.18491457f, 0.24408582f, -0.40783200f, 0.05367130f, 0.13276261f, -0.01973692f, 0.11837525f, 
    0.08448595f, -0.07669918f, 0.04983569f, 0.07486089f, 0.14564906f, 0.11588423f, -0.26968116f, -0.22619559f, 
    0.17821959f, 0.10416558f, -0.02552397f, -0.04183497f, -0.09832868f, 0.13186613f, 0.05373507f, 0.06655029f, 
    0.02707717f, 0.01762106f, -0.08067990f, 0.00701902f, 0.13080329f, 0.16422585f, -0.05476392f, -0.23462830f, 
    -0.01430445f, -0.07738084f, -0.18231095f, -0.05170862f, 0.08273139f, -0.22787282f, -0.27547732f, 0.15577564f, 
    0.00968488f, 0.01460453f, 0.36282101f, -0.16933326f, 0.02483785f, -0.10819171f, 0.14434876f, 0.07835463f, 
    0.75233310f, -0.13732332f, 0.02180750f, 0.19460201f, 0.03776509f, 0.29968524f, -0.10032363f, 0.10514560f, 
    0.00804730f, 0.04793503f, -0.05610670f, -0.13873579f, -0.52915651f, -0.05806308f, -0.00580144f, -0.21391688f, 
    -0.04491548f, -0.12783267f, -0.06377836f, -0.03960519f, 0.03102004f, 0.02640540f, 0.01930251f, 0.06799772f, 
    -0.04306231f, 0.07712568f, 0.00277457f, -0.07911527f, 0.01976091f, 0.12936252f, -0.01776195f, -0.22664011f, 
    -0.02725827f, 0.03764758f, 0.27824396f, 0.06413475f, -0.13341744f, 0.03685076f, 0.14061990f, 0.17279629f, 
    -0.08999848f, -0.13905634f, 0.00281733f, 0.00330663f, -0.05790012f, -0.01733550f, -0.16792749f, 0.10235405f, 
    -0.15389067f, 0.13398215f, 0.12781671f, 0.08115298f, 0.09973633f, -0.01502972f, 0.16588749f, 0.07569645f, 
    -0.00083689f, 0.24783702f, -0.12106811f, 0.28969556f, 0.24606419f, -0.05408520f, -0.05814053f, 0.26585987f, 
    0.01351635f, 0.16058704f, 0.06215854f, -0.01912980f, -0.01127546f, -0.17666396f, -0.03213758f, 0.04480914f, 
    0.03307597f, 0.18909802f, 0.03151909f, -0.01248781f, 0.01500391f, 0.01182302f, -0.04351975f, 0.22277290f, 
    0.00692313f, -0.04536265f, 0.02854009f, -0.03546923f, -0.08935881f, 0.21798399f, 0.18759903f, -0.12303650f, 
    0.04745191f, -0.06607787f, 0.17949104f, 0.03577306f, -0.09633510f, -0.04956055f, 0.10962678f, -0.04233187f, 
    0.00734009f, 0.19635190f, -0.13562207f, 0.20345326f, 0.05284744f, 0.11448408f, 0.08484326f, 0.08556749f, 
    -0.09314378f, 0.10824316f, -0.11669558f, -0.02846934f, -0.16058955f, 0.07530103f, 0.05859557f, 0.13140719f, 
    0.07770451f, -0.33296168f, -0.19423990f, -0.04369872f, 0.11536933f, 0.06298460f, 0.11764061f, 0.28573102f, 
    -0.24868609f, 0.02229531f, 0.17590599f, -0.30495325f, -0.19316337f, -0.22538489f, -0.29106057f, -0.10471118f, 
    -0.08880533f, -0.26781583f, -0.09505907f, -0.20887336f, 0.16903047f, 0.10573558f, -0.19563584f, -0.01850028f, 
    0.15832826f, -0.10893967f, 0.12881209f, -0.07563235f, -0.17570540f, -0.06139676f, -0.13071090f, -0.24513604f, 
    -0.11245181f, -0.26432347f, 0.46871740f, -0.11349342f, -0.13590577f, 0.14945258f, -0.06701519f, -0.06755501f, 
    0.01901991f, 0.00869910f, -0.06173070f, 0.04731410f, 0.35237384f, -0.06715908f, 0.08824535f, -0.00233233f, 
    0.11746706f, -0.12796636f, -0.07426495f, -0.04050224f, 0.07262670f, 0.15743487f, 0.24176674f, -0.10390959f, 
    -0.09257207f, 0.00860038f, -0.03184741f, 0.16164933f, 0.04053567f, 0.00161816f, 0.20405282f, -0.04759079f, 
    0.13796359f, 0.04207490f, 0.15225349f, 0.15723191f, -0.12670700f, 0.03754695f, -0.31494674f, 0.08448304f, 
    0.01809075f, -0.01395051f, 0.00680433f, -0.18809415f, -0.11568953f, 0.16214199f, -0.05850235f, -0.10133801f, 
    0.45273843f, -0.27481282f, 0.33406192f, -0.00365105f, 0.03182526f, 0.22402824f, -0.09652556f, 0.22878371f, 
    0.11458902f, 0.06380723f, 0.12948804f, 0.20792100f, -0.29430404f, -0.10136130f, 0.27262324f, -0.02274040f, 
    0.15235756f, -0.18326882f, -0.23644640f, -0.22379342f, 0.13493696f, -0.02337185f, 0.03853314f, 0.01672952f, 
    -0.19114639f, 0.17034282f, 0.00387928f, -0.40753001f, 0.01093289f, -0.02192828f, 0.14130872f, -0.11381015f, 
    -0.32568380f, 0.01855949f, 0.10634528f, -0.09020247f, -0.11112284f, 0.24169032f, -0.11002237f, 0.29949346f, 
    -0.15559447f, 0.04848075f, 0.17569223f, -0.14727516f, 0.09886847f, 0.03013062f, 0.27414036f, 0.19277924f, 
    0.08396834f, 0.05178659f, -0.08749764f, 0.01768227f, 0.20657191f, -0.32981738f, -0.12533866f, -0.19744027f, 
    -0.12781172f, -0.02537702f, 0.08535362f, -0.18079107f, 0.75658232f, -0.12196007f, -0.07744068f, 0.47586516f, 
    0.02641516f, 0.04145560f, -0.00958942f, -0.11721453f, 0.09070315f, 0.01643359f, 0.06449731f, 0.23962021f, 
    -0.02037496f, -0.04032378f, -0.05044631f, -0.07088042f, -0.03275111f, -0.06018183f, 0.00861809f, -0.06780566f, 
    -0.07990204f, -0.06250767f, -0.06509504f, 0.00438012f, -0.02216426f, 0.01475674f, -0.05926143f, -0.07454749f, 
    -0.03283427f, -0.03314172f, 0.04104863f, 0.00524613f, 0.00308679f, 0.00116902f, -0.05353271f, -0.06843561f, 
    -0.06279680f, 0.02068959f, 0.03711173f, 0.05963705f, -0.05533975f, 0.03040667f, -0.02602317f, 0.00157269f, 
    -0.02791773f, -0.02836982f, -0.00910684f, -0.04152404f, -0.05227797f, 0.01332954f, -0.05866248f, -0.00455623f, 
    -0.05581424f, 0.03245151f, -0.00390340f, 0.06000454f, -0.03773293f, 0.02460651f, 0.04707253f, 0.05134132f, 
    -0.03797270f, 0.05663050f, -0.07129969f, -0.02290407f, -0.07776451f, 0.05466771f, 0.05735018f, 0.04220843f, 
    0.03690961f, -0.02566346f, -0.06942010f, -0.01713492f, -0.07789574f, 0.05956040f, 0.03456694f, -0.05749344f, 
    0.02520536f, 0.05589656f, -0.06398001f, 0.05585376f, 0.01753699f, -0.03383591f, 0.04161931f, 0.00210310f, 
    0.03195636f, -0.00304301f, 0.05520274f, -0.01704437f, -0.01074893f, -0.07884512f, -0.07803144f, -0.04382977f, 
    -0.02799337f, 0.00626767f, 0.03744986f, -0.04473851f, -0.00505052f, -0.08072108f, 0.02289813f, 0.01891075f, 
    0.01671327f, 0.04184291f, -0.02776646f, 0.05679401f, -0.04737139f, 0.04389307f, 0.01873266f, 0.03965260f, 
    -0.04508288f, -0.01975654f, 0.03511427f, 0.03336626f, -0.03693518f, -0.00484306f, -0.05882116f, -0.01921512f, 
    -0.02226030f, -0.00545024f, 0.03520915f, -0.02664112f, 0.00773159f, 0.03904931f, -0.01049782f, -0.04384154f, 
    0.05222862f, -0.04459508f, -0.00397474f, -0.01543097f, -0.04008684f, -0.04757551f, 0.00985465f, -0.07053414f, 
    0.04431292f, -0.04304879f, 0.02895769f, 0.05140901f, -0.01900363f, -0.04240651f, 0.04178410f, -0.05993646f, 
    0.03589122f, 0.05576796f, 0.01801169f, -0.03219157f, -0.04540555f, 0.02506559f, -0.04629101f, 0.03536453f, 
    -0.03417714f, -0.00075393f, -0.00093974f, -0.07634493f, 0.03311145f, 0.01643580f, 0.02378908f, -0.03970970f, 
    -0.03193894f, -0.04909476f, 0.00553845f, 0.03428682f, -0.07925224f, -0.03297806f, 0.03675228f, 0.01975481f, 
    0.03495283f, -0.03218344f, -0.02240697f, -0.05127822f, 0.05442182f, 0.05945353f, 0.00583682f, 0.00367163f, 
    -0.05315948f, -0.03965155f, -0.00549745f, 0.00985991f, 0.00707757f, -0.05185514f, -0.06303383f, -0.07652870f, 
    -0.05858488f, -0.01531419f, 0.01246790f, -0.03853679f, 0.00697999f, 0.03011242f, 0.01841132f, -0.05418367f, 
    -0.05572853f, 0.00317322f, -0.07005916f, 0.05746131f, -0.03837249f, -0.05907232f, 0.00347078f, -0.05877676f, 
    -0.05626266f, 0.01615008f, -0.02730514f, -0.04172982f, -0.03478936f, -0.06885141f, 0.04205932f, -0.05061755f, 
    0.11013408f, -0.31205887f, -0.19223122f, 0.01463834f, -0.12910178f, -0.01552976f, 0.02154264f, -0.03049828f, 
    -0.04652981f, -0.00008897f, 0.03037445f, -0.04178822f, 0.08931351f, -0.58614445f, -0.53817922f, -0.12099919f, 
    0.08465103f, 0.02279840f, -0.14479461f, 0.08974707f, 0.08015276f, -0.00070999f, -0.04911505f, 0.02774262f, 
    0.20081127f, -0.08799836f, 0.07119859f, -0.38387567f, 0.11486860f, -0.35436878f, 0.03359508f, 0.21210791f, 
    0.17014810f, 0.09514343f, -0.05627142f, 0.07361916f, 0.07367883f, 0.17106681f, -0.11913189f, 0.28630453f, 
    -0.25919440f, -0.03902019f, -0.05639029f, 0.00291228f, -0.01616438f, -0.05232187f, 0.05356705f, 0.09962019f, 
    0.52505565f, 0.19526048f, -0.17205320f, 0.17157194f, -0.06971937f, -0.07057387f, 0.02338836f, -0.05981816f, 
    0.05301123f, -0.00432517f, 0.01399870f, 0.00291695f, -0.17726547f, -0.35292649f, -0.10816167f, -0.32650355f, 
    0.18496871f, 0.18855794f, 0.11065043f, 0.09307265f, -0.02403435f, -0.03855014f, -0.10182457f, 0.05550269f, 
    0.18446580f, 0.15291961f, -0.20401207f, 0.21601142f, -0.10524502f, 0.03379557f, 0.09099136f, 0.10536008f, 
    0.10125358f, 0.13514757f, 0.02158036f, 0.18885842f, -0.12755218f, 0.20887899f, 0.55559009f, -0.06470416f, 
    -0.09368332f, -0.01858101f, -0.10705164f, -0.04575460f, -0.18493764f, 0.04959372f, -0.02769781f, 0.01264318f, 
    -0.07785579f, 0.04015234f, -0.06634976f, -0.02039865f, 0.08424836f, 0.08422821f, -0.17459586f, -0.10761854f, 
    0.07830905f, -0.10116876f, -0.00952286f, 0.18360361f, 0.12696767f, 0.13712963f, -0.01943405f, -0.13330996f, 
    -0.16462611f, -0.08837201f, 0.11701217f, 0.01057845f, 0.09608436f, 0.29312086f, 0.05293113f, -0.00443505f, 
    0.07252257f, -0.43136495f, -0.30905795f, -0.74103844f, 0.14912775f, -0.04773125f, -0.19563922f, 0.03101085f, 
    -0.03744854f, 0.04295882f, -0.04107346f, 0.05459231f, 0.15305789f, 0.19355829f, -0.03533618f, 0.15555081f, 
    -0.07815120f, -0.06845304f, 0.09127833f, -0.01969152f, 0.21116495f, 0.01882931f, 0.09968406f, 0.01001160f, 
    0.26403907f, -0.04903923f, 0.04777657f, 0.13266779f, 0.06187359f, -0.00089745f, -0.09737395f, -0.14662588f, 
    -0.01979956f, -0.03043310f, -0.04656918f, -0.03726077f, 0.33111686f, 0.00736998f, -0.00813825f, -0.46035084f, 
    0.01669968f, 0.01120947f, 0.12640890f, -0.09638588f, -0.02856310f, 0.06485439f, 0.19813024f, -0.00405845f, 
    0.18439075f, 0.00495500f, 0.09049676f, 0.28063762f, 0.05330215f, -0.09807479f, 0.02335447f, -0.08734415f, 
    0.14574468f, 0.01486861f, -0.10696489f, 0.07826498f, -0.40874910f, 0.26002657f, 0.28196108f, 0.01087218f, 
    -0.08060878f, 0.00743756f, -0.02934384f, -0.07651342f, -0.16485371f, -0.15689270f, 0.02533977f, -0.00127037f, 
    -0.35482255f, 0.16316105f, 0.07877300f, 0.03013060f, 0.16314316f, 0.27693176f, 0.08944566f, 0.31971154f, 
    0.05746917f, -0.01652529f, -0.08367465f, -0.09547746f, -0.08107664f, 0.31677505f, 0.16215938f, -0.07417377f, 
    0.14317545f, 0.12591618f, 0.14393638f, 0.15729049f, 0.10022036f, 0.07404058f, 0.03762868f, 0.12151396f, 
    0.51589859f, 0.30866027f, 0.18780194f, -0.28672627f, 0.15400788f, 0.18462677f, 0.03923573f, 0.14200146f, 
    0.08709235f, -0.02093572f, -0.06932038f, 0.01527410f, -0.28561255f, -0.09832238f, -0.33784041f, 0.06952515f, 
    -0.31964946f, -0.08781724f, -0.20388162f, -0.05745359f, -0.07740960f, -0.10652652f, -0.14012812f, -0.13032545f, 
    -0.17499435f, -0.08383699f, -0.39668792f, -0.03595367f, -0.10783938f, -0.10250847f, -0.05634553f, -0.06210469f, 
    0.10136937f, 0.01753206f, -0.00334587f, 0.07932679f, -0.11616810f, -0.09858334f, 0.17287543f, 0.09499226f, 
    0.11193272f, 0.22626978f, 0.36532897f, 0.29233432f, 0.08206385f, 0.03927561f, 0.13109501f, 0.28095627f, 
    -0.41822472f, -0.08905570f, -0.19413064f, 0.08604484f, 0.03630292f, -0.04784143f, -0.10338464f, -0.22272246f, 
    0.14328174f, 0.15362786f, -0.12829910f, 0.24022447f, -0.02449496f, 0.16698675f, 0.10561229f, 0.24620205f, 
    -0.03201162f, -0.10826615f, 0.17230126f, 0.01635977f, 0.06424371f, -0.06391641f, 0.09034622f, 0.21043971f, 
    0.07099543f, 0.07437087f, 0.36604264f, 0.20128989f, 0.22604749f, 0.12334651f, -0.23388717f, 0.02463894f, 
    0.12805018f, -0.09556876f, -0.13926868f, -0.18217932f, 0.26868570f, 0.06121573f, 0.08641908f, 0.16409078f, 
    0.04239933f, 0.17064704f, -0.02034625f, -0.03798951f, 0.12008537f, 0.16703051f, 0.06638110f, -0.00864070f, 
    0.22826584f, -0.03894973f, 0.22780614f, -0.09651770f, 0.28746718f, 0.00799370f, -0.01580940f, 0.06878120f, 
    0.07457133f, -0.07536422f, 0.03108707f, 0.05670207f, -0.29275969f, 0.03092205f, -0.01660659f, 0.20146610f, 
    -0.08922070f, -0.20732719f, -0.13101815f, -0.06700033f, 0.24914315f, -0.07920014f, -0.02400356f, 0.00036665f, 
    -0.01069248f, -0.12698931f, -0.10220058f, -0.18647474f, -0.06686365f, 0.06136669f, -0.06825349f, 0.06677750f, 
    0.12794706f, -0.00755566f, 0.17037892f, 0.20091356f, 0.27607039f, 0.07325331f, 0.17316861f, 0.07108334f, 
    0.06757669f, 0.01437396f, -0.07396846f, -0.03738691f, -0.09396788f, 0.07972100f, -0.03912679f, -0.06503521f, 
    -0.00251350f, -0.26489764f, 0.08713963f, 0.12946823f, -0.17117965f, -0.27149782f, -0.02067383f, -0.16612196f, 
    0.23770291f, 0.06548823f, 0.13052881f, 0.23635967f, -0.03264775f, 0.07972487f, 0.07497956f, 0.34604028f, 
    -0.10193338f, -0.19544847f, -0.16141354f, -0.24631085f, -0.07133388f, -0.01775979f, -0.16043934f, -0.03793616f, 
    0.03618631f, 0.05856527f, -0.04619366f, -0.06620260f, 0.01725535f, -0.03267422f, -0.00774900f, 0.04648341f, 
    0.04936574f, -0.04848241f, -0.02255196f, -0.04443074f, -0.06254421f, 0.01713108f, 0.01966316f, 0.05134396f, 
    0.02515736f, -0.05975536f, 0.04475661f, 0.06537572f, -0.01386134f, -0.03337901f, 0.03020524f, -0.00745363f, 
    -0.03019942f, -0.01270902f, -0.02998688f, -0.00232733f, 0.05806613f, -0.07232154f, -0.01625212f, -0.01102586f, 
    -0.03163417f, -0.05453992f, 0.04347240f, -0.05313575f, 0.06252951f, -0.00641287f, -0.01002613f, 0.03887732f, 
    0.03874875f, -0.02372527f, -0.06392117f, 0.03517047f, -0.04782357f, -0.01433358f, -0.07149012f, -0.03506425f, 
    -0.01548071f, 0.04927995f, 0.00836387f, -0.05751448f, -0.03400690f, 0.04145076f, -0.03586647f, 0.02002319f, 
    -0.06453383f, 0.05416488f, -0.06526822f, 0.05221545f, -0.02742263f, -0.04759439f, 0.02760972f, -0.02089768f, 
    -0.01387378f, -0.04910053f, -0.02194802f, 0.05378356f, -0.07064499f, 0.05103997f, 0.04507462f, -0.03408170f, 
    0.05963584f, -0.03998303f, -0.03961707f, -0.00314110f, -0.04777931f, 0.02070812f, -0.01248255f, -0.06065571f, 
    0.05321625f, -0.02403505f, 0.04755997f, 0.05918571f, 0.06424779f, 0.01172728f, 0.05278130f, 0.00589195f, 
    -0.06649424f, -0.05493422f, 0.02803639f, 0.04929872f, 0.05127150f, -0.05432924f, -0.01347861f, -0.03202210f, 
    0.01501515f, -0.02831677f, -0.07137056f, -0.03107475f, 0.01791544f, 0.06445257f, -0.01490333f, -0.01112592f, 
    -0.04730771f, -0.07593668f, 0.05640794f, 0.04121783f, -0.00767991f, -0.06277274f, 0.03952022f, -0.04949525f, 
    0.05736988f, 0.02893945f, -0.02012951f, -0.00829816f, 0.03708933f, -0.05523261f, -0.06898760f, -0.00659787f, 
    -0.04443061f, -0.02601492f, 0.01070370f, 0.05143143f, 0.03919781f, -0.03849726f, 0.05542143f, -0.02675467f, 
    -0.06880460f, 0.03031088f, -0.04606932f, -0.04387746f, -0.04622623f, 0.05858546f, -0.05424974f, 0.03318904f, 
    0.00031160f, 0.01062001f, 0.01599265f, -0.07544941f, 0.03199806f, 0.06572118f, -0.07453297f, -0.01416402f, 
    -0.00634902f, -0.03563081f, -0.05575393f, -0.04900287f, 0.05197912f, -0.02778867f, -0.00127816f, -0.03560646f, 
    -0.03758801f, -0.04131044f, -0.07030383f, 0.04952846f, 0.01273332f, 0.03308205f, 0.00832407f, -0.00863930f, 
    0.00433852f, -0.05926072f, -0.07648406f, -0.04614604f, 0.04095067f, -0.02049060f, -0.05473924f, 0.06485482f, 
    -0.04903761f, -0.07058130f, -0.05347382f, 0.02016182f, -0.05998378f, -0.03396951f, 0.02372497f, 0.00710168f, 
    0.07538769f, -0.05390306f, -0.03918640f, -0.03360717f, -0.03591127f, 0.01097330f, 0.01783888f, 0.06717929f, 
    0.00442274f, -0.06150036f, 0.06162647f, 0.02266273f, -0.06344600f, 0.03618409f, 0.03581717f, 0.02931411f, 
    -0.05711596f, -0.02298175f, 0.32338944f, 0.34251982f, -0.08795869f, 0.03850921f, 0.16164826f, -0.00877984f, 
    0.07066148f, 0.02305307f, -0.02691489f, 0.02615099f, 0.04808558f, -0.09792802f, 0.13215029f, 0.11216354f, 
    -0.14576864f, -0.06374679f, 0.04072785f, 0.05248870f, 0.03799926f, 0.14407025f, -0.00393613f, -0.08297569f, 
    0.26905546f, 0.05948504f, 0.10435603f, -0.01978259f, 0.02760356f, 0.04437483f, 0.05934180f, 0.02797263f, 
    -0.02701634f, -0.00453784f, 0.02388760f, -0.07735481f, 0.36563665f, -0.04785128f, 0.04571501f, 0.05983116f, 
    -0.08103873f, 0.01593648f, -0.11341049f, 0.17691715f, 0.24165800f, 0.01548774f, 0.00410151f, 0.00728304f, 
    0.35725841f, -0.04818469f, 0.06319930f, 0.26209056f, 0.02187148f, 0.07613213f, 0.01483987f, 0.00658589f, 
    0.01140704f, -0.02925273f, -0.02451920f, -0.08088647f, -0.01942219f, 0.14770219f, 0.38899288f, 0.25501138f, 
    0.03050033f, 0.13138691f, 0.12275161f, 0.03106148f, 0.08658664f, -0.06410161f, 0.09524427f, -0.04061892f, 
    0.13062078f, -0.09732823f, -0.06665448f, 0.01515175f, -0.02173170f, -0.10588514f, -0.04787453f, 0.06514809f, 
    0.01556849f, -0.05553617f, -0.07676650f, 0.02505273f, -0.13949211f, -0.08723985f, -0.07341171f, 0.21820213f, 
    -0.01918780f, 0.06665646f, 0.08618759f, -0.02004830f, -0.06433637f, -0.10332245f, -0.04155794f, -0.13991190f, 
    0.05914614f, 0.17368028f, 0.32309976f, 0.10781921f, -0.03836083f, -0.07999764f, -0.09964192f, 0.10564879f, 
    0.16704899f, 0.21637991f, 0.03335145f, 0.06535964f, -0.12672924f, -0.24485683f, 0.01707666f, -0.08771469f, 
    0.11388171f, 0.15591887f, -0.09934843f, -0.05902175f, -0.07068260f, 0.17328043f, -0.08575918f, -0.00076767f, 
    -0.07335602f, 0.40182236f, -0.12379026f, 0.11028569f, -0.08444410f, -0.28282946f, 0.03448153f, -0.26718602f, 
    -0.13258298f, -0.00906988f, 0.06865793f, -0.04174327f, 0.35937661f, 0.10211337f, -0.00901699f, 0.08347017f, 
    0.03881453f, 0.07628649f, -0.07074142f, 0.06896108f, -0.04490330f, -0.03680211f, -0.00004089f, -0.08625309f, 
    0.27727005f, -0.02259532f, 0.04773467f, 0.04576351f, -0.13338567f, -0.12587221f, 0.05848897f, 0.32147563f, 
    -0.07357221f, -0.08862200f, -0.17865695f, -0.07557926f, -0.01175687f, -0.12463448f, 0.05270395f, -0.08512659f, 
    -0.02575523f, -0.18078288f, 0.02871096f, 0.02207047f, -0.02185285f, -0.15248078f, 0.03926545f, 0.09138440f, 
    0.16040179f, -0.00700815f, 0.04775944f, 0.08221027f, -0.00929779f, 0.16287994f, -0.05466789f, 0.14399995f, 
    0.05207441f, -0.08044264f, 0.09224245f, -0.04258537f, -0.31335488f, -0.01844511f, -0.23880485f, -0.11633410f, 
    -0.02679765f, -0.10725126f, -0.11380736f, 0.07189597f, -0.00424749f, -0.06721582f, -0.04895088f, -0.01512640f, 
    -0.18692438f, -0.25013074f, 0.25118145f, 0.29930505f, 0.13369761f, 0.08460861f, 0.12347847f, -0.09935906f, 
    0.02780686f, 0.07857123f, -0.06477298f, -0.07837107f, -0.23775616f, 0.17164555f, 0.00096470f, 0.34455258f, 
    -0.04449298f, 0.02655247f, -0.06751710f, 0.02350295f, -0.02925498f, 0.24472141f, 0.08445102f, -0.15381505f, 
    0.11033603f, 0.19209930f, 0.21923867f, 0.08183533f, 0.10173056f, -0.07940038f, -0.03626170f, 0.01286781f, 
    -0.00410801f, 0.08412359f, -0.11464045f, 0.06832403f, 0.12620880f, 0.03052138f, 0.02671985f, -0.02910152f, 
    -0.05756329f, 0.07779865f, 0.09798010f, 0.23258525f, 0.08314493f, 0.00676543f, -0.04976770f, -0.03350895f, 
    0.36359125f, -0.23729314f, 0.03341519f, 0.17255746f, 0.06645940f, 0.06409902f, 0.00759471f, 0.00994687f, 
    -0.01629209f, -0.01631350f, -0.12594116f, 0.00106153f, 0.02504976f, 0.01432624f, 0.14434515f, 0.19294345f, 
    0.01886248f, 0.16926995f, 0.03158353f, 0.09538325f, 0.05126116f, -0.16332768f, 0.04560966f, -0.11850343f, 
    0.18099523f, -0.07163889f, -0.26281363f, 0.05795701f, 0.00177667f, -0.17161751f, 0.19967821f, -0.03022263f, 
    0.03147374f, 0.02721099f, 0.03357721f, 0.10696504f, -0.37717724f, 0.12237876f, 0.21718438f, 0.40940675f, 
    -0.02533066f, 0.04654466f, 0.06233308f, 0.03104010f, -0.16388963f, 0.01832577f, 0.06481121f, -0.02501563f, 
    -0.16838355f, 0.05938240f, 0.12762682f, 0.22077399f, -0.02542784f, -0.01700788f, 0.01068328f, 0.16090651f, 
    0.02575780f, 0.26303437f, 0.02838919f, 0.17183225f, -0.15948719f, 0.16341491f, 0.29914567f, -0.05845971f, 
    -0.00046696f, 0.00896789f, -0.22258829f, -0.10962151f, -0.18674518f, 0.10561775f, -0.26532760f, -0.04679729f, 
    -0.49353155f, 0.36409289f, 0.22650248f, 0.17252310f, 0.01269577f, -0.19521971f, 0.04508663f, -0.29157093f, 
    -0.08114288f, -0.05120365f, 0.15421180f, 0.12204535f, 0.54796910f, -0.07555985f, 0.14969727f, 0.30534655f, 
    0.00539068f, 0.18314368f, 0.06218364f, 0.17349696f, -0.02159898f, 0.10145017f, -0.04488030f, -0.02405363f, 
    -0.03444493f, -0.00824566f, -0.00739543f, 0.12581156f, 0.04184598f, -0.14774875f, 0.13500109f, 0.22184569f, 
    -0.06379034f, -0.03277160f, -0.11542481f, -0.08442108f, -0.19880323f, -0.04080064f, 0.08392141f, -0.06546334f, 
    -0.00851157f, -0.10301717f, 0.01582739f, 0.01688967f, 0.07599691f, -0.03318143f, 0.21709116f, 0.17456152f, 
    0.11079445f, -0.19569030f, 0.02880898f, -0.08195728f, -0.03694489f, 0.21969958f, -0.08553007f, 0.17621279f, 
    -0.04101787f, -0.09208028f, 0.13202207f, -0.20778257f, -0.39880836f, 0.04715608f, -0.04218181f, 0.09537239f, 
    0.05579342f, -0.07311630f, -0.09799105f, 0.11783863f, -0.11799806f, 0.02659126f, 0.11558347f, 0.07813328f, 
    -0.19028813f, -0.10206225f, 0.26335582f, -0.00425590f, -0.02757119f, -0.06619678f, 0.04524836f, -0.08077484f, 
    -0.00732538f, -0.08839521f, 0.13802215f, 0.13585846f, -0.03809343f, -0.24078825f, 0.15936422f, 0.03022620f, 
    -0.07896023f, 0.07978931f, 0.05317340f, 0.12105507f, -0.01078967f, 0.07317971f, 0.01903346f, -0.12457809f, 
    -0.20305753f, 0.15330741f, 0.03742211f, 0.08807897f, 0.08843078f, -0.16893481f, 0.05094868f, -0.03555072f, 
    0.10544297f, 0.04285117f, 0.04886128f, 0.01087065f, -0.04617695f, -0.18129231f, -0.05047102f, -0.03221262f, 
    0.03167842f, 0.02251758f, 0.13623779f, -0.06259397f, -0.00177992f, -0.07118907f, 0.06862079f, 0.09883707f, 
    0.04223152f, -0.15990466f, 0.06425370f, -0.23711228f, 0.14917190f, 0.20963764f, 0.15573128f, -0.07181327f, 
    -0.03242845f, -0.20337997f, -0.05876654f, -0.16567364f, 0.10050460f, -0.05897179f, -0.05572340f, 0.00097693f, 
    0.02845021f, -0.06458105f, 0.01644249f, -0.08499715f, 0.04304953f, -0.12737761f, -0.18093772f, -0.27223414f, 
    0.22393417f, 0.21912757f, -0.43423957f, 0.13961732f, -0.01069424f, -0.14518605f, 0.12125784f, -0.03128093f, 
    0.17885888f, 0.22293948f, 0.10600457f, 0.03960739f, 0.10055926f, -0.04563219f, 0.45452532f, 0.22064814f, 
    -0.02328652f, -0.13597946f, -0.11412444f, 0.14178143f, 0.10893966f, 0.06588673f, 0.02231106f, -0.00131968f, 
    -0.01109836f, -0.01927398f, 0.15708187f, -0.08772204f, -0.06407150f, -0.00690976f, 0.16395266f, 0.05059318f, 
    0.05329463f, -0.07352056f, 0.15522203f, 0.14145768f, 0.15002735f, 0.09292857f, 0.10229386f, 0.00303200f, 
    0.01760658f, -0.07882068f, 0.01880355f, 0.16319247f, -0.06424252f, 0.09635216f, -0.01651969f, 0.06681034f, 
    -0.50382066f, -0.05414660f, 0.16028784f, 0.00119244f, -0.15250345f, 0.02929028f, 0.10513555f, -0.12168692f, 
    -0.06238921f, -0.13520502f, -0.00618951f, 0.05763646f, 0.47189519f, -0.42363662f, 0.17796783f, 0.16475052f, 
    -0.03186424f, 0.03312142f, 0.05886936f, 0.03304499f, 0.08527353f, -0.00731943f, -0.02359226f, -0.01295827f, 
    0.03345451f, -0.18998489f, 0.03093980f, 0.07655799f, 0.09113452f, 0.12833561f, 0.22350395f, -0.05900399f, 
    0.15029891f, -0.14484276f, -0.25033492f, -0.03229261f, 0.14711733f, 0.10157488f, -0.26101544f, -0.09469999f, 
    0.10888091f, 0.04622967f, 0.08643478f, -0.07088959f, 0.27207965f, 0.09089371f, 0.23957139f, 0.03849191f, 
    -0.18620613f, -0.09873336f, -0.16349553f, -0.12637144f, 0.08683264f, 0.15671800f, -0.15784250f, 0.07685609f, 
    0.09091280f, 0.21147233f, 0.06999011f, -0.03031321f, -0.37748724f, -0.04003970f, 0.43363369f, 0.31417158f, 
    -0.11628436f, -0.08620845f, -0.04883659f, 0.19970536f, 0.00478753f, 0.06757029f, 0.18734829f, 0.07796731f, 
    -0.22787344f, -0.23332310f, 0.06330255f, 0.21748972f, 0.06580382f, -0.10496038f, -0.13632956f, 0.05982331f, 
    0.03911944f, -0.08955363f, 0.05807035f, 0.01556737f, -0.26090279f, 0.07519885f, 0.04661365f, 0.08683519f, 
    -0.02511052f, 0.03015405f, 0.02883512f, -0.09202693f, -0.04034202f, 0.11436664f, 0.07142477f, -0.02348526f, 
    0.27441475f, 0.17975534f, 0.14019179f, 0.23102519f, 0.06371728f, -0.11049651f, 0.15400650f, -0.02094284f, 
    -0.07191002f, 0.01499329f, -0.03695458f, 0.11570837f, -0.06569739f, 0.09731215f, -0.04258051f, 0.29044399f, 
    0.01836815f, -0.01176188f, -0.08914007f, 0.02517591f, 0.21906678f, 0.16559984f, 0.12473731f, 0.18980628f, 
    -0.09536657f, 0.03870558f, 0.21563336f, 0.09039117f, 0.08359400f, 0.13437834f, -0.06982981f, -0.07784867f, 
    -0.11428023f, -0.34379807f, -0.27548021f, -0.52631021f, 0.04290800f, -0.01350285f, 0.02406005f, 0.22423004f, 
    0.02511861f, 0.00189704f, 0.03698816f, -0.13003430f, -0.04781601f, -0.13178596f, -0.16913065f, -0.23970874f, 
    0.04450007f, -0.07664864f, -0.04273041f, 0.02401815f, -0.24369918f, 0.02987972f, 0.13310879f, 0.05381491f, 
    0.20324895f, 0.05629958f, 0.13613011f, 0.02243568f, 0.32079950f, 0.12909487f, 0.23622014f, 0.15066199f, 
    0.05182756f, -0.22836180f, -0.14150381f, 0.08633716f, -0.07301740f, 0.17425923f, -0.04277252f, -0.11398269f, 
    -0.37098330f, 0.04953500f, -0.04086333f, 0.20493782f, -0.01106753f, 0.03457593f, 0.19325790f, 0.02291800f, 
    0.09758294f, 0.11038470f, 0.10749745f, 0.15991300f, 0.01348594f, 0.29056606f, -0.03873718f, -0.01538329f, 
    -0.20405412f, -0.20156837f, -0.16080789f, -0.12506005f, -0.30956924f, 0.13665575f, -0.01044548f, -0.17714262f, 
    -0.10910583f, -0.11902688f, 0.28099966f, 0.24181303f, 0.08182529f, -0.06047167f, -0.08705736f, 0.02415459f, 
    0.00094834f, 0.07502887f, -0.01162038f, 0.06268416f, -0.04838272f, -0.24843718f, -0.13083167f, 0.23816785f, 
    -0.00851448f, 0.15792449f, -0.09784643f, -0.18103409f, -0.05354976f, 0.12752442f, 0.00782396f, -0.06790622f, 
    -0.14530322f, -0.05927011f, 0.12593283f, -0.16637768f, 0.21402697f, 0.04408175f, 0.08310454f, 0.02720090f, 
    -0.07400174f, -0.11111191f, -0.13060978f, -0.20163208f, -0.39003301f, 0.26151654f, -0.04579017f, 0.13889171f, 
    -0.06172363f, 0.04288527f, 0.02564344f, -0.08470955f, 0.12437649f, -0.02257271f, 0.28229350f, 0.35829186f, 
    0.05376882f, -0.06687780f, -0.10042317f, -0.32826653f, 0.35352039f, -0.06503937f, -0.10305772f, -0.04992262f, 
    -0.05234568f, -0.11750060f, -0.00861094f, -0.30214110f, 0.44066858f, 0.11242499f, 0.05442099f, 0.37059075f, 
    -0.07273760f, -0.07096384f, 0.08586404f, 0.30443817f, 0.09615862f, 0.08563717f, 0.14104237f, 0.21321398f, 
    0.08170238f, 0.08584048f, 0.06257502f, 0.11297241f, -0.08992945f, -0.04015641f, 0.04464197f, 0.14623904f, 
    0.05768625f, 0.17237018f, 0.01997390f, 0.00407330f, 0.29652557f, -0.27853334f, 0.34477279f, -0.14922163f, 
    -0.05239655f, -0.08301494f, 0.00898395f, 0.01703860f, 0.10921007f, -0.02017306f, 0.11556420f, 0.02973915f, 
    0.33359861f, 0.27986255f, 0.19058013f, -0.15723313f, 0.04412473f, 0.17688598f, 0.09631246f, 0.04978594f, 
    -0.22425787f, 0.09522699f, -0.07647742f, -0.01982210f, -0.33761555f, 0.03145189f, -0.60541779f, -0.34268039f, 
    0.08475500f, -0.07860408f, -0.11198259f, -0.14040905f, -0.02373162f, 0.00719747f, -0.13536708f, 0.08085518f, 
    -0.11414866f, -0.08821324f, -0.27430069f, -0.10240298f, 0.13441947f, -0.12387062f, 0.06389278f, 0.06330758f, 
    -0.05764838f, 0.02426707f, -0.10159063f, -0.02750919f, -0.01402039f, 0.14224894f, 0.27671984f, 0.22180614f, 
    -0.05820158f, -0.08434844f, 0.16173424f, 0.12228819f, -0.02515284f, -0.02366271f, 0.06498786f, 0.00460383f, 
    -0.60401136f, -0.09081300f, 0.02483090f, -0.17636815f, 0.20045672f, 0.08755050f, -0.13109760f, -0.00730510f, 
    0.06639073f, -0.27485231f, -0.08250223f, 0.07434274f, -0.04598294f, 0.23501116f, -0.17891061f, 0.36191013f, 
    -0.06049116f, 0.08078245f, 0.03703833f, 0.00648334f, -0.05583893f, 0.10190435f, 0.03204316f, 0.02475292f, 
    0.03699960f, 0.21600808f, 0.16496538f, 0.04584634f, 0.00503996f, 0.15347973f, -0.07858263f, -0.12478346f, 
    0.16781278f, 0.19088034f, 0.10230982f, 0.01893166f, 0.36763635f, -0.04706288f, 0.03093810f, 0.00113555f, 
    -0.09680655f, 0.13961548f, -0.01477035f, 0.03562906f, -0.08910986f, -0.10755242f, 0.08927607f, -0.13442865f, 
    0.48350579f, 0.26015481f, 0.04658738f, 0.21472356f, -0.08133397f, -0.06007271f, -0.01445239f, 0.14628181f, 
    0.19866844f, 0.12484995f, 0.20157221f, -0.10777721f, -0.51371467f, -0.15466993f, -0.16035250f, -0.06595156f, 
    0.22268431f, 0.15560652f, -0.25235808f, -0.06361691f, -0.05921989f, -0.02018977f, 0.03258257f, -0.02561959f, 
    0.05109402f, -0.06111058f, -0.04455912f, -0.33594149f, -0.14563347f, -0.08077575f, -0.08863802f, 0.04846994f, 
    -0.16289236f, -0.08059268f, 0.07691079f, -0.02840396f, -0.01805976f, 0.07105149f, 0.22883913f, 0.05013395f, 
    0.09336287f, -0.02040605f, -0.02332075f, 0.06443720f, -0.07391002f, -0.04008638f, -0.02068141f, 0.37198687f, 
    -0.01505385f, -0.27750948f, 0.15919961f, -0.25645211f, 0.00711007f, -0.03872153f, 0.14236251f, -0.05957728f, 
    0.08812741f, -0.08800690f, -0.03499176f, -0.01524367f, -0.06394818f, 0.31791335f, 0.06745838f, 0.14938015f, 
    -0.15621774f, 0.02208903f, -0.24493334f, 0.03615709f, 0.17687197f, 0.07830058f, -0.25925717f, 0.19317934f, 
    0.06098987f, 0.21460551f, -0.00986614f, -0.08977570f, 0.03029742f, 0.17489620f, 0.03382010f, 0.16923064f, 
    0.04347102f, -0.00222514f, 0.05595998f, -0.09256045f, 0.23731476f, -0.11897466f, 0.06114002f, -0.28331712f, 
    0.14585379f, 0.03655527f, -0.04842094f, 0.00940987f, -0.06653089f, -0.01527064f, -0.13190518f, -0.01757348f, 
    0.16911721f, 0.13493465f, 0.15485592f, -0.37097570f, -0.02076462f, -0.05229054f, -0.03489246f, -0.12089525f, 
    0.06520724f, -0.01257163f, 0.18698069f, -0.09010235f, -0.26835391f, -0.34706116f, -0.19455798f, 0.17519206f, 
    0.08373886f, 0.07450447f, -0.04115057f, 0.15218166f, 0.10077626f, 0.00882336f, -0.05098924f, 0.10557639f, 
    0.19521664f, -0.02711820f, -0.31346199f, 0.12058140f, 0.12497254f, 0.16580501f, 0.05641265f, 0.00534926f, 
    0.04370986f, -0.00112334f, -0.07959487f, 0.01775411f, -0.06668273f, 0.17947140f, 0.31903952f, -0.02458975f, 
    0.11050841f, 0.08288696f, 0.07160823f, 0.10118209f, 0.03185854f, -0.07420709f, 0.00722820f, 0.10578346f, 
    -0.14890373f, 0.04494083f, -0.33166373f, 0.26282439f, 0.14571421f, -0.02295357f, -0.07273178f, -0.00481932f, 
    0.08549599f, -0.00097858f, 0.01852963f, 0.06619803f, -0.00161000f, 0.17010514f, 0.35064253f, 0.27248082f, 
    -0.04862053f, 0.06791376f, 0.07790324f, -0.01122235f, -0.04934150f, -0.00593719f, -0.04498341f, -0.06899521f, 
    0.24475032f, 0.06203940f, 0.17498799f, -0.25157169f, 0.16822214f, -0.01405255f, -0.00592032f, 0.13811153f, 
    -0.02971181f, -0.07639400f, 0.06774955f, -0.08719269f, 0.12338313f, -0.02679003f, 0.00229421f, -0.08141754f, 
    0.00467382f, -0.01691858f, -0.19737388f, 0.05875892f, -0.05687124f, 0.02109760f, -0.01788130f, -0.07920992f, 
    -0.07389930f, 0.01185104f, -0.15034375f, -0.34931538f, -0.09361205f, -0.02764435f, 0.09288906f, 0.26005402f, 
    0.10226252f, 0.03268487f, 0.10877357f, 0.03709548f, -0.32794613f, -0.00223393f, -0.16464150f, 0.14985023f, 
    0.04188244f, 0.05281558f, 0.05279851f, 0.09423428f, 0.11573774f, 0.00544411f, 0.02496372f, 0.10440310f, 
    0.12037643f, -0.20809670f, 0.04511767f, -0.05130097f, -0.15296039f, 0.07538250f, -0.06779145f, 0.11402780f, 
    0.05877499f, -0.04977677f, -0.17214690f, 0.06689149f, 0.16077088f, 0.00381279f, -0.09199264f, -0.08935066f, 
    0.14373799f, 0.03823260f, -0.10266218f, -0.03412322f, -0.09516088f, -0.01330310f, -0.11953261f, 0.19283733f, 
    -0.12181384f, -0.06110291f, -0.11168749f, 0.08982006f, 0.13172263f, -0.03614929f, 0.08205421f, 0.05313907f, 
    0.13623157f, -0.11048267f, -0.07915384f, 0.08469690f, -0.40426773f, 0.23587564f, 0.28894320f, 0.17346673f, 
    -0.11102697f, 0.02561620f, -0.00109474f, 0.25968760f, 0.04528375f, 0.09851871f, -0.07239098f, 0.00719894f, 
    0.08554851f, 0.25249767f, 0.11226608f, -0.11926490f, -0.10248351f, 0.16439387f, 0.09821299f, 0.00495003f, 
    -0.03635401f, 0.09175886f, 0.04035736f, 0.02655833f, 0.44329220f, -0.14978592f, 0.21934263f, -0.21940018f, 
    0.11154865f, 0.02361093f, 0.37852669f, 0.23243184f, 0.16425565f, 0.10577367f, 0.07227302f, 0.06216558f, 
    -0.21116839f, 0.06403735f, -0.11609156f, -0.12049623f, 0.05207556f, 0.10802986f, 0.12337522f, 0.17470486f, 
    0.11369622f, 0.12607935f, -0.16197014f, 0.06175324f, 0.14399193f, 0.02577002f, 0.03236710f, 0.04664624f, 
    -0.11740671f, -0.10740780f, 0.02723130f, -0.04753723f, -0.08753964f, -0.04603000f, -0.04356655f, 0.12214005f, 
    0.31309980f, 0.15450341f, -0.06351949f, -0.25579679f, 0.12661830f, -0.20404728f, -0.04567561f, -0.00325257f, 
    -0.15195362f, -0.13117829f, 0.08137537f, 0.02778837f, -0.13091174f, -0.02525729f, -0.11030497f, -0.19020461f, 
    0.06547394f, 0.14162497f, 0.30812821f, 0.19755389f, -0.27832177f, -0.04472039f, -0.11204640f, -0.12844823f, 
    0.22855102f, 0.37282765f, 0.22182733f, 0.43245339f, 0.10387428f, -0.08284366f, -0.01658746f, -0.05967465f, 
    -0.04662934f, 0.10552154f, -0.00748673f, 0.18334131f, -0.26082909f, -0.31596142f, 0.21033372f, -0.03976887f, 
    -0.12842432f, 0.14216061f, -0.04357535f, -0.00728967f, 0.31240401f, 0.13764037f, 0.20482276f, 0.10542655f, 
    0.26059234f, -0.07255503f, 0.11828620f, -0.21986264f, 0.13033667f, 0.09332814f, -0.05290503f, -0.11328205f, 
    0.22849841f, -0.07443902f, -0.03961614f, 0.16307642f, 0.49567795f, -0.20426638f, -0.00461841f, -0.02404437f, 
    0.00021991f, 0.07701829f, 0.23326877f, 0.02447962f, 0.32982036f, 0.24398696f, 0.01108186f, 0.09047388f, 
    0.05584145f, 0.06912362f, 0.07717697f, -0.15625498f, -0.08768251f, 0.09872548f, -0.10277990f, 0.13274214f, 
    0.08936930f, -0.03735219f, -0.11016086f, 0.08120538f, 0.37576595f, 0.22467637f, 0.33458194f, 0.00908227f, 
    0.17530984f, -0.03326800f, -0.02044932f, 0.06386452f, 0.17171583f, -0.14726472f, 0.09861514f, 0.03856355f, 
    0.18308590f, 0.05655820f, 0.05348110f, -0.01310214f, -0.07192966f, 0.06356500f, 0.03356992f, -0.19108462f, 
    0.02066650f, -0.02536424f, 0.03175615f, 0.05617590f, 0.75218225f, 0.06850948f, -0.00413375f, -0.05940966f, 
    0.04657950f, 0.01319035f, 0.06213972f, -0.08108254f, 0.05805741f, 0.15368167f, 0.20060188f, 0.01293371f, 
    0.10193568f, 0.01548677f, 0.09213326f, 0.25978011f, -0.04939537f, -0.06459577f, -0.00863510f, -0.01992772f, 
    0.05561996f, 0.05922420f, 0.04339264f, 0.17215951f, -0.56192929f, 0.09203532f, 0.15544914f, 0.17678231f, 
    -0.16289863f, -0.05585491f, -0.06798144f, -0.35418373f, 0.14819163f, -0.01219767f, 0.20505524f, 0.20904121f, 
    0.25723916f, 0.14773199f, 0.04211940f, 0.04755688f, -0.07715812f, 0.03977811f, -0.00239111f, 0.20208083f, 
    0.08650204f, 0.05907000f, 0.05137321f, -0.00940589f, 0.28766817f, -0.18647480f, -0.09769771f, -0.12498723f, 
    0.12732485f, 0.08323879f, -0.19759041f, 0.08723748f, -0.00378588f, 0.04700158f, -0.12583205f, 0.04120077f, 
    0.26862860f, 0.02394043f, 0.08289611f, -0.23340906f, 0.01871848f, -0.02929185f, -0.09911458f, 0.19907732f, 
    -0.22453056f, -0.14938956f, 0.12514096f, -0.00447625f, 0.22278559f, -0.32536566f, -0.09108035f, -0.07872494f, 
    0.25750875f, 0.18442942f, 0.24504942f, 0.10804567f, 0.04999375f, -0.09425622f, 0.02906761f, 0.10625271f, 
    0.11527774f, -0.27754813f, -0.25207913f, 0.40431213f, 0.15168940f, 0.29241219f, -0.11491806f, 0.16226780f, 
    -0.19252223f, -0.16772225f, 0.02919571f, -0.15553355f, 0.11577557f, 0.20719536f, 0.06844189f, 0.05144797f, 
    0.09085105f, 0.07167682f, -0.02277637f, 0.09762271f, -0.19437554f, -0.10482483f, 0.03194948f, -0.00633675f, 
    -0.38207296f, 0.23757297f, -0.08462331f, 0.26075777f, -0.17856325f, 0.19304280f, 0.00466014f, 0.01548635f, 
    0.07212131f, -0.10053190f, 0.11543206f, -0.03219716f, 0.57153428f, 0.21282715f, 0.34875447f, 0.25140682f, 
    0.03644395f, -0.12212831f, -0.17573658f, -0.34878293f, -0.05157977f, -0.21743225f, -0.00682718f, 0.01046534f, 
    0.24212943f, 0.01967487f, 0.12756732f, -0.10038874f, 0.18387537f, -0.01981781f, -0.03671465f, 0.24390951f, 
    0.02602292f, 0.07760339f, 0.18267129f, 0.03227701f, 0.15749510f, -0.03118201f, 0.24060887f, -0.20645656f, 
    -0.11902556f, -0.20655373f, -0.10118437f, -0.14670371f, -0.24800837f, 0.05313126f, -0.03042559f, -0.16332559f, 
    0.05901112f, -0.03912527f, -0.52242035f, -0.17671496f, -0.07802176f, 0.11481589f, -0.01760209f, 0.04006142f, 
    0.16595507f, -0.01096409f, -0.06756739f, -0.02124711f, -0.29129994f, 0.14203463f, -0.21352556f, -0.16058768f, 
    0.14650731f, 0.09899744f, 0.17024100f, -0.21394308f, -0.08316114f, -0.15000170f, -0.01747318f, 0.00652859f, 
    0.41313711f, -0.43982184f, 0.28293493f, -0.16624528f, -0.03837389f, 0.07207755f, -0.11551137f, 0.06680978f, 
    -0.02672908f, -0.12574829f, -0.55624783f, -0.37775898f, -0.02428550f, -0.15048596f, 0.06126373f, 0.01161933f, 
    0.07547309f, -0.06403282f, 0.01034347f, -0.02483843f, -0.00557614f, 0.10678450f, -0.04198920f, 0.25319910f, 
    -0.52506036f, 0.23175161f, 0.02192717f, 0.28949454f, 0.28527090f, 0.11714587f, 0.05240381f, -0.04750948f, 
    0.14519830f, -0.08528385f, -0.06245235f, 0.12393580f, 0.23415339f, 0.10994752f, 0.27937207f, 0.08195328f, 
    -0.04230344f, -0.01003355f, -0.03086161f, -0.01683248f, 0.12427279f, 0.10182735f, 0.06680963f, 0.10899098f, 
    -0.27985406f, -0.31006780f, -0.01566572f, 0.10830054f, 0.02089768f, 0.05683561f, -0.07153798f, -0.03682148f, 
    -0.01647161f, -0.02351828f, -0.01165181f, 0.01585562f, -0.16533367f, -0.18147333f, 0.09989212f, 0.06346609f, 
    -0.09807751f, 0.00030987f, 0.01068906f, 0.03478847f, -0.10363551f, -0.03653254f, 0.10035322f, -0.01817161f, 
    0.12328086f, 0.25781861f, 0.29808843f, 0.15332699f, 0.16158281f, -0.15644696f, 0.11782083f, 0.03355664f, 
    -0.01722030f, -0.00961501f, -0.19359723f, 0.09508146f, -0.24419871f, 0.26471266f, -0.20071986f, 0.00585314f, 
    0.07535350f, 0.00627196f, 0.05696794f, 0.01814179f, 0.05817370f, -0.07388952f, 0.03077088f, -0.00800391f, 
    -0.07304529f, -0.08377463f, 0.04829215f, -0.18332604f, -0.02498752f, 0.05937465f, 0.03231143f, 0.01574719f, 
    0.01973439f, 0.04021912f, -0.10007060f, -0.09271347f, -0.15389834f, -0.31062946f, -0.05926786f, 0.03163941f, 
    0.02654031f, -0.10011818f, -0.02133173f, -0.01408492f, -0.04062995f, -0.00874800f, -0.06802127f, 0.03006633f, 
    -0.07541929f, 0.08966300f, -0.09406834f, 0.02768658f, -0.02521591f, 0.05155815f, 0.11522220f, -0.12259964f, 
    0.13838479f, -0.02214829f, -0.03435959f, -0.04931890f, 0.14236467f, 0.16423066f, 0.23464723f, 0.16629016f, 
    0.10758094f, -0.07016185f, -0.10648458f, 0.05302611f, -0.12781520f, 0.07539269f, 0.12197071f, 0.08781365f, 
    -0.32713699f, 0.08367874f, 0.01408595f, 0.01107320f, -0.13199422f, 0.14812258f, 0.11790395f, 0.02164550f, 
    0.04656284f, 0.05240395f, 0.07564878f, 0.11208604f, 0.09651828f, 0.46451575f, 0.10409911f, -0.03436090f, 
    -0.12057493f, -0.02124981f, -0.12389536f, -0.09288153f, -0.12329008f, -0.02302741f, 0.22713989f, -0.04904122f, 
    -0.13137101f, -0.09476609f, 0.48879546f, 0.27644753f, -0.03147894f, -0.08893430f, -0.01733999f, 0.10121316f, 
    0.10504041f, 0.05573539f, 0.08366258f, 0.06420746f, 0.09683950f, -0.27324125f, -0.08214179f, 0.05348474f, 
    0.00249560f, 0.14325339f, 0.10286380f, 0.04079908f, -0.04531779f, 0.10989857f, 0.03420097f, 0.00740718f, 
    -0.06995133f, -0.04434544f, 0.01755105f, -0.09110378f, 0.26360762f, 0.02070643f, 0.04412189f, 0.09872792f, 
    0.00840297f, 0.04875961f, 0.02791644f, 0.05667216f, -0.24293491f, 0.44237038f, -0.01242111f, 0.03983497f, 
    -0.00172738f, -0.00493832f, -0.04763117f, -0.09863929f, 0.16742852f, 0.10399506f, 0.26325721f, 0.34330049f, 
    -0.05923671f, -0.07498887f, 0.03522218f, -0.11192951f, 0.03678269f, -0.01975171f, -0.03122153f, 0.02597037f, 
    0.10861946f, -0.05104877f, 0.05424912f, -0.10345804f, 0.24270003f, 0.31481338f, 0.28956985f, 0.35242486f, 
    -0.14706022f, -0.07305774f, -0.03783222f, 0.03461350f, 0.01992629f, 0.08081131f, 0.02631509f, 0.19536386f, 
    -0.03657193f, -0.09003018f, -0.10631716f, -0.18270163f, -0.18415119f, -0.09108810f, -0.01721730f, -0.08951800f, 
    -0.01096694f, -0.04889121f, 0.06222432f, -0.06986465f, -0.09552590f, -0.12855911f, -0.05790577f, -0.14121597f, 
    -0.11465347f, -0.05461967f, -0.04871810f, -0.09385743f, 0.01408880f, -0.07209140f, -0.05281664f, -0.04643551f, 
    -0.05209520f, -0.05690265f, -0.08586802f, -0.04772854f, -0.04031311f, -0.04556772f, 0.05534298f, -0.04707123f, 
    -0.04983611f, -0.17785157f, -0.00057545f, -0.07652516f, 0.05261335f, -0.03453515f, -0.01965107f, 0.05481839f, 
    -0.06021249f, -0.01187528f, -0.04221985f, 0.07623526f, 0.02254869f, -0.02005979f, 0.00370518f, -0.01045929f, 
    0.04513241f, -0.03608701f, 0.05846599f, 0.00964091f, 0.05915609f, 0.05401485f, 0.04854204f, -0.04971457f, 
    0.00248369f, -0.00676675f, 0.00869214f, -0.03390345f, -0.04394809f, -0.07277565f, -0.11243479f, -0.03476343f, 
    -0.12070295f, -0.04491729f, 0.00570318f, -0.05271737f, -0.06359303f, 0.00127495f, -0.10724191f, 0.01735887f, 
    -0.04598600f, -0.07265090f, -0.02288684f, -0.11579316f, -0.05302339f, -0.12667114f, -0.10322595f, -0.05568943f, 
    -0.08261948f, -0.09325468f, 0.00060463f, -0.09560862f, -0.07690354f, -0.13045660f, -0.13156269f, -0.02506781f, 
    0.06022518f, 0.03999716f, 0.03096951f, -0.09098149f, 0.09747550f, -0.08586724f, -0.11388282f, -0.05383340f, 
    0.01953837f, -0.02405456f, -0.11207384f, -0.13444027f, -0.11571809f, -0.07342990f, -0.09128694f, -0.05661729f, 
    -0.02582746f, 0.01315019f, 0.03475340f, 0.00185340f, -0.05184672f, 0.03019336f, -0.10196601f, 0.05491313f, 
    0.03719299f, 0.01526296f, 0.02811851f, 0.04955056f, -0.00462929f, -0.06158007f, -0.03100664f, 0.00798684f, 
    -0.14720318f, -0.09583931f, -0.11418560f, -0.06803250f, -0.05610675f, -0.07305020f, -0.13284817f, -0.00110417f, 
    0.01057357f, -0.01494890f, -0.09088313f, -0.09980059f, -0.09454558f, 0.00895057f, 0.02529395f, 0.02767020f, 
    0.05070728f, -0.03976807f, -0.03266928f, -0.02064237f, 0.01948122f, -0.02528823f, -0.01242822f, 0.04530162f, 
    -0.02140925f, -0.00127297f, -0.05129836f, -0.03715660f, 0.05362202f, -0.03231231f, 0.01558905f, 0.03966340f, 
    -0.02605372f, 0.02337775f, 0.06585726f, -0.04307773f, -0.13799839f, -0.05676096f, -0.06350648f, -0.07460707f, 
    -0.07882421f, -0.01012760f, 0.02539616f, 0.01138231f, -0.14086179f, -0.10455859f, -0.12881100f, -0.10883569f, 
    0.06572824f, 0.07615916f, 0.01881771f, -0.06095849f, 0.04960370f, 0.04100075f, 0.07794259f, 0.02025965f, 
    0.07962617f, 0.05120200f, 0.06973934f, -0.05093099f, -0.02698545f, 0.06633765f, 0.02242560f, 0.04941367f, 
    -0.01874606f, -0.00426116f, -0.05052194f, 0.02117220f, 0.01689281f, -0.12564555f, -0.08209797f, -0.08644735f, 
    -0.05692650f, -0.01821841f, -0.08969219f, -0.22700617f, 0.02678338f, 0.02557307f, 0.05493015f, -0.24795443f, 
    -0.08672139f, 0.08627137f, -0.05068680f, 0.01308749f, 0.32428092f, -0.13069084f, 0.12815267f, 0.03296372f, 
    -0.00363798f, 0.00638495f, 0.07017383f, -0.09786628f, 0.14413567f, 0.16664043f, -0.04540061f, 0.11837494f, 
    0.17730726f, 0.13315445f, 0.18990825f, -0.16502644f, 0.00018023f, 0.14972106f, 0.03646620f, -0.02306694f, 
    0.14406005f, -0.02520332f, -0.04594188f, -0.03837305f, 0.01114777f, 0.09212211f, 0.02049662f, -0.10231692f, 
    -0.13929214f, 0.12431756f, -0.12490010f, -0.06704679f, -0.07401838f, -0.12943278f, -0.13765813f, -0.23603977f, 
    0.14010249f, -0.07478199f, 0.06350558f, -0.07755590f, 0.11483674f, 0.01002011f, 0.10852622f, -0.19174500f, 
    -0.05564030f, 0.10206781f, -0.14173840f, 0.07078592f, -0.17622013f, -0.00663491f, 0.31155106f, 0.00226283f, 
    -0.19273950f, 0.12860242f, 0.08054955f, 0.06225524f, -0.00339893f, -0.04261926f, 0.09633677f, 0.02469241f, 
    0.20629025f, 0.11918097f, -0.13877246f, 0.09727413f, 0.30187795f, -0.12499565f, 0.01201206f, 0.02216312f, 
    -0.02293505f, -0.00779662f, -0.02842771f, -0.00974057f, -0.40576947f, 0.41303447f, -0.13079120f, 0.09221008f, 
    -0.25261053f, 0.16062783f, 0.04187471f, 0.21962823f, 0.12235360f, 0.08034713f, 0.08439224f, 0.00368936f, 
    0.11501396f, 0.19677398f, 0.17081009f, -0.29628229f, -0.03358596f, 0.13143143f, -0.08238399f, -0.08270784f, 
    0.08129352f, 0.05556868f, -0.05419582f, -0.12127993f, 0.31837264f, 0.09346716f, 0.06966172f, 0.10008133f, 
    -0.03285269f, 0.18387268f, 0.07808160f, 0.14828537f, 0.16857199f, 0.04072800f, 0.00900123f, 0.00972257f, 
    0.07729179f, 0.57361478f, 0.35842949f, 0.14938265f, 0.13396342f, -0.08772365f, 0.24442261f, -0.12439577f, 
    -0.14167181f, 0.03550486f, 0.10810857f, -0.04415819f, 0.38022542f, 0.07062848f, 0.01016032f, 0.24830706f, 
    -0.09219550f, 0.18217824f, -0.14952412f, 0.16408834f, -0.27398804f, -0.03511822f, -0.05296524f, -0.13194369f, 
    -0.00494916f, 0.00585374f, -0.20308930f, 0.04576918f, 0.11035606f, 0.04013876f, 0.04267127f, 0.03573900f, 
    0.12860352f, -0.09450860f, 0.07920457f, 0.09930277f, 0.21984310f, 0.12161621f, 0.26886189f, -0.20272259f, 
    0.15302351f, 0.13012543f, -0.03412684f, 0.08448794f, 0.09223372f, 0.06458954f, 0.01362543f, 0.23764665f, 
    0.09470691f, -0.12512210f, 0.02960612f, -0.15129331f, -0.11223727f, 0.11106932f, -0.09884743f, 0.09409611f, 
    0.10380519f, -0.10696017f, 0.04244429f, 0.04354284f, -0.78208131f, 0.39167359f, 0.11593711f, -0.14629252f, 
    0.00110845f, -0.00389969f, -0.21625686f, 0.09775256f, 0.00659325f, 0.06757545f, -0.07208005f, -0.02466753f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.10257100f, 0.23623785f, 0.10382399f, 0.13129672f, -0.05471499f, -0.15668741f, 0.13659725f, 0.01322086f, 
    0.05774086f, 0.07389831f, -0.05949208f, 0.02566608f, 0.11639003f, -0.03818205f, 0.18633595f, -0.13283800f, 
    -0.03960827f, -0.07017583f, 0.14423092f, 0.11921687f, -0.05219298f, -0.05006528f, 0.15809979f, 0.11939464f, 
    0.04029318f, -0.04572654f, 0.03009729f, 0.19687551f, -0.17779864f, 0.20137079f, -0.06372838f, 0.20748276f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.02234940f, -0.01911204f, 0.38241863f, 0.20362450f, 0.00740728f, 0.24168096f, 0.21899505f, 0.26358899f, 
    0.06023035f, 0.23922376f, 0.08239833f, 0.24162944f, 0.33299801f, -0.05794723f, 0.30634433f, 0.03557293f, 
    0.34946188f, -0.06028885f, -0.47739372f, -0.17671101f, 0.10194981f, -0.29861796f, -0.04936866f, -0.04517815f, 
    0.20913979f, -0.29748815f, -0.51255727f, -0.13620833f, -0.27994400f, 0.15781464f, -0.14274204f, -0.26755375f, 
    0.03826843f, 0.23294008f, -0.00319588f, -0.06654155f, -0.11987962f, -0.06501912f, -0.11393937f, -0.00554183f, 
    0.01162928f, -0.28561544f, 0.16912764f, 0.29773518f, -0.49336970f, -0.17700064f, -0.14044055f, -0.40325755f, 
    0.41758931f, 0.11966635f, -0.27596921f, -0.27921763f, -0.12126520f, 0.08454563f, -0.03274383f, -0.00107091f, 
    0.31807810f, -0.15161727f, -0.04776485f, 0.19783777f, 0.49741119f, 0.07198542f, -0.05134280f, -0.21263310f, 
    0.17848420f, -0.00683971f, 0.39534870f, 0.00426185f, 0.06998605f, 0.31517720f, -0.07471008f, 0.18711160f, 
    0.09000868f, 0.29520237f, -0.01082774f, 0.07522574f, 0.03187156f, 0.24731569f, -0.24062510f, -0.05116173f, 
    0.11152449f, -0.11777513f, 0.07077125f, 0.21328129f, 0.05648902f, 0.02539394f, 0.33856907f, -0.19796479f, 
    -0.00102547f, -0.15237869f, 0.13036560f, -0.01931651f, -0.01077163f, -0.09264427f, -0.11568760f, -0.21811680f, 
    0.28385770f, -0.12659313f, 0.11822291f, -0.07634998f, -0.09598226f, 0.02701026f, -0.15859710f, 0.22432654f, 
    0.12333946f, 0.27721977f, -0.13694456f, -0.12791665f, -0.12295894f, 0.22859560f, 0.14296237f, -0.52294666f, 
    0.12496468f, 0.00435152f, -0.50564218f, 0.27268517f, 0.10958035f, 0.49693888f, 0.38464287f, 0.04702503f, 
    0.03144879f, 0.04330505f, 0.01173756f, 0.10628290f, 0.20168896f, -0.00465182f, 0.10492753f, -0.02160374f, 
    0.22126107f, 0.08294696f, 0.18022360f, 0.15778211f, 0.03775017f, -0.00729824f, 0.16159847f, -0.09703682f, 
    -0.03464507f, 0.18622342f, 0.12905188f, 0.13037772f, 0.36584115f, -0.04292013f, 0.31037587f, 0.03110775f, 
    0.20582300f, 0.04693055f, -0.35922155f, 0.10284588f, 0.00992973f, -0.25617087f, 0.08665840f, -0.31545341f, 
    0.17041723f, -0.00009858f, -0.35116053f, -0.25095865f, -0.06830560f, -0.10866708f, -0.11157263f, -0.04689390f, 
    0.01616960f, -0.27870160f, 0.18164267f, 0.32269487f, -0.01787747f, 0.44322890f, 0.07878024f, 0.13150756f, 
    -0.17051835f, -0.10921748f, 0.14849323f, 0.01600640f, 0.10004075f, 0.01194459f, 0.53016853f, -0.09277199f, 
    -0.21277681f, -0.06855566f, -0.12694292f, 0.06458338f, 0.00172060f, 0.12634657f, 0.34757408f, -0.00445315f, 
    0.20905113f, -0.22831385f, -0.08108754f, -0.22890106f, -0.10965908f, 0.09300124f, -0.08921360f, 0.21701819f, 
    0.02670622f, -0.01519467f, 0.26965007f, 0.03532311f, -0.12145135f, -0.18251586f, 0.20031372f, 0.00093811f, 
    -0.16328092f, -0.46169022f, 0.10019707f, 0.24085465f, -0.04525813f, -0.49364376f, 0.16983040f, -0.04116144f, 
    0.20015237f, 0.04072878f, -0.17817798f, -0.03427439f, -0.13581492f, -0.33180422f, 0.07244816f, 0.17374986f, 
    0.36149850f, -0.33080634f, -0.10033701f, 0.12439860f, -0.75278062f, 0.13383338f, -0.14038169f, 0.31184345f, 
    -0.13020341f, -0.39773539f, 0.06918133f, 0.02499278f, 0.08054016f, -0.07167634f, -0.31578228f, -0.18566604f, 
    -0.06263682f, 0.33528721f, 0.06090458f, 0.10128956f, 0.00299361f, -0.17978230f, 0.32427490f, 0.09988223f, 
    0.19738485f, 0.08374377f, 0.05996095f, 0.13157417f, -0.02047216f, 0.11728327f, 0.19585608f, -0.28240559f, 
    0.22702253f, 0.54111487f, 0.15065840f, -0.09371991f, -0.07245253f, 0.20666583f, -0.20325090f, 0.18318431f, 
    -0.11939256f, 0.21618804f, 0.01436836f, 0.11914614f, 0.10691153f, 0.13750373f, 0.31338537f, -0.33431166f, 
    0.07767269f, -0.02981383f, -0.01701910f, 0.31845051f, -0.38220197f, -0.15483046f, 0.06096214f, -0.00298595f, 
    0.27294388f, 0.01072557f, 0.30138245f, 0.00191943f, 0.01840398f, 0.03787962f, 0.14526756f, 0.44262719f, 
    0.40605140f, 0.07628581f, -0.11569604f, 0.10826182f, -0.13166536f, 0.32240596f, 0.02566131f, -0.04968117f, 
    -0.03455703f, -0.25025496f, 0.29515484f, 0.37490749f, 0.05399697f, 0.14558072f, 0.04361596f, 0.08154861f, 
    0.00818784f, 0.08462974f, -0.07676261f, 0.10696314f, 0.03284177f, -0.35541776f, 0.40257582f, 0.14601278f, 
    0.46982306f, 0.16091436f, -0.04371597f, -0.14650394f, 0.13916518f, 0.02726150f, -0.02098822f, -0.07677017f, 
    -0.01350679f, 0.04957004f, -0.41160241f, 0.21383142f, -0.78778201f, 0.15676543f, -0.01235134f, 0.26159900f, 
    0.22842430f, 0.06699236f, -0.20850153f, -0.24523684f, 0.13252410f, 0.02690044f, 0.11877779f, 0.25004208f, 
    0.04310593f, -0.03087246f, -0.06632679f, -0.19709817f, -0.08649803f, 0.27651802f, -0.50982648f, 0.14843668f, 
    0.24363424f, 0.07684193f, -0.15629043f, 0.05867386f, -0.04152668f, -0.06983566f, -0.09017479f, 0.03374762f, 
    -0.22343124f, 0.20254147f, 0.31128344f, 0.36886537f, 0.35283294f, -0.12091969f, -0.04995835f, 0.16968392f, 
    0.26700917f, -0.09620459f, -0.06009619f, 0.25650847f, -0.02779939f, 0.32934573f, -0.00949507f, 0.08457892f, 
    -0.11239415f, -0.04994589f, 0.00824054f, 0.06189977f, -0.08182742f, 0.39338750f, 0.34019130f, -0.41496402f, 
    -0.45024219f, 0.16737697f, -0.44842094f, -0.16100812f, 0.01702716f, 0.40436357f, 0.39137250f, 0.08398380f, 
    0.20932211f, 0.05271754f, -0.06189651f, -0.23446779f, 0.42589501f, -0.10264243f, -0.04547828f, 0.30615121f, 
    -0.02664921f, 0.00130756f, -0.01033635f, 0.24405137f, -0.13585778f, 0.13018569f, -0.22463854f, -0.05268644f, 
    0.17362325f, -0.10663272f, 0.14978550f, 0.27735537f, -0.24155606f, -0.24304663f, 0.35721150f, -0.22615774f, 
    -0.41832915f, 0.02288597f, 0.20235443f, -0.23337567f, 0.12225315f, -0.01477698f, 0.30263960f, 0.18219535f, 
    -0.41887698f, -0.10595277f, -0.31048194f, 0.32047784f, 0.55428547f, -0.08111827f, -0.06907818f, -0.04278739f, 
    0.03910892f, 0.16274862f, 0.23636866f, 0.24957481f, 0.07500742f, -0.67874837f, 0.24069703f, 0.08967604f, 
    -0.16785440f, 0.07006925f, -0.02802777f, -0.18140316f, 0.24358256f, -0.22326820f, 0.15235150f, -0.28441340f, 
    -0.46888268f, -0.13216692f, 0.21026577f, 0.18066673f, -0.05882012f, 0.16979101f, 0.24590264f, -0.00336766f, 
    -0.32593894f, 0.08115977f, -0.02915114f, 0.18407813f, -0.68064374f, 0.14284156f, -0.16148059f, 0.29571289f, 
    0.40734690f, 0.29743606f, 0.32804939f, 0.14322329f, -0.08744580f, 0.14425001f, 0.02452028f, 0.28570622f, 
    0.08062878f, 0.25362986f, 0.04659615f, 0.09575778f, 0.31946135f, 0.10671662f, -0.11086010f, 0.17808658f, 
    0.37126592f, -0.01054716f, -0.00502100f, 0.17299975f, 0.10867999f, -0.25749964f, -0.42495319f, -0.36224762f, 
    -0.37634903f, -0.09558093f, -0.31658918f, 0.23192461f, 0.02509201f, -0.06095684f, -0.04461941f, -0.33455077f, 
    -0.19562103f, 0.25749248f, -0.09568736f, -0.04271637f, 0.06232139f, -0.02954018f, 0.40582320f, 0.19824952f, 
    -0.16870804f, 0.20814781f, 0.07676483f, -0.12896185f, -0.07858229f, 0.05176672f, 0.45410949f, -0.15793806f, 
    -0.21404088f, -0.18228333f, -0.28734839f, 0.06342510f, 0.14723054f, -0.09893008f, 0.18333167f, 0.47255501f, 
    0.30723038f, -0.18364377f, -0.18019137f, -0.16871893f, -0.32189563f, 0.18048486f, -0.04762740f, 0.07888529f, 
    0.21809372f, -0.17965522f, 0.09315958f, 0.18487452f, 0.03431882f, 0.25317460f, -0.26150355f, 0.07767949f, 
    0.03690932f, 0.34296292f, 0.02002390f, 0.19657925f, 0.31629023f, 0.16801839f, -0.05427743f, 0.29096025f, 
    -0.13014716f, 0.07636697f, 0.31584805f, 0.14342532f, -0.11545361f, 0.25105777f, -0.03863331f, -0.34804434f, 
    0.01243886f, 0.45168322f, -0.08107351f, 0.13571632f, 0.23677912f, -0.16401793f, -0.10531975f, 0.15578194f, 
    0.10628013f, -0.19202350f, 0.02066254f, -0.04854991f, -0.02028702f, 0.02133324f, -0.17369875f, -0.19007832f, 
    -0.01116735f, 0.04872717f, -0.11337235f, 0.08083310f, 0.09940082f, -0.19861694f, -0.07058822f, 0.06830348f, 
    0.01725590f, 0.05743650f, -0.00855981f, -0.12541534f, 0.15834333f, 0.01574144f, -0.13156381f, -0.11432442f, 
    -0.02976143f, -0.02577931f, 0.06795599f, 0.00113454f, -0.14554355f, 0.05399031f, -0.02895586f, -0.02498672f, 
    0.25903922f, 0.21195856f, 0.14688100f, 0.38918272f, -0.14292605f, 0.07305480f, -0.21844636f, 0.15318336f, 
    -0.04243705f, -0.23811711f, -0.07326155f, 0.03187515f, 0.03614929f, 0.02616590f, 0.19193399f, 0.27482212f, 
    0.45786405f, 0.04135193f, -0.33793098f, -0.47888115f, 0.03145922f, 0.10715648f, -0.30261099f, -0.03749234f, 
    -0.20851269f, -0.41095653f, -0.34715208f, 0.09627288f, 0.03091977f, 0.00628470f, 0.11777187f, -0.09223770f, 
    0.11947865f, 0.27757531f, -0.04734761f, -0.05423922f, 0.10247267f, -0.18198055f, 0.01764255f, 0.28422639f, 
    -0.03507733f, 0.20821969f, -0.06398466f, -0.16217984f, -0.03480127f, 0.26150259f, -0.41952735f, -0.13138708f, 
    -0.29641950f, 0.04579234f, 0.19491702f, 0.17858292f, -0.07584199f, -0.25164607f, -0.23022701f, 0.09003255f, 
    -0.61191702f, -0.12416752f, -0.03510894f, 0.37583622f, 0.07384212f, -0.28176612f, -0.04304374f, 0.25227106f, 
    0.13112283f, -0.03804721f, 0.18949081f, -0.13379735f, 0.04156221f, 0.01845735f, -0.27208203f, 0.06776689f, 
    -0.09507709f, -0.11453035f, 0.03914572f, -0.26822740f, 0.09978978f, 0.26142511f, 0.16646923f, 0.08854315f, 
    -0.09546168f, 0.16808167f, -0.06484395f, -0.06693476f, 0.11247516f, -0.01729612f, -0.21903181f, -0.01087417f, 
    -0.13560575f, -0.03620663f, 0.01364019f, -0.22558005f, -0.14943238f, 0.03580875f, 0.12295089f, 0.04528626f, 
    -0.18748192f, 0.25558126f, -0.24628124f, 0.07457604f, 0.09424275f, -0.39138910f, -0.02183887f, 0.21276474f, 
    0.13418534f, 0.00153781f, 0.16715910f, -0.01893777f, -0.39954424f, 0.14028326f, -0.19924247f, -0.46179757f, 
    -0.02229714f, -0.16120107f, -0.32410678f, 0.04240064f, -0.03398541f, 0.22474764f, 0.47481775f, 0.36262462f, 
    0.02452122f, -0.22730933f, 0.12045503f, 0.13983110f, -0.28103688f, 0.16841900f, -0.08062795f, 0.16629900f, 
    -0.35916862f, -0.09932096f, -0.04729401f, -0.20632073f, 0.17461345f, 0.30012181f, 0.08472183f, 0.12767796f, 
    0.14319000f, 0.13293914f, 0.14282477f, 0.16838004f, -0.18446714f, 0.14655438f, -0.03899570f, 0.06099543f, 
    0.16100110f, -0.06662858f, 0.48035568f, 0.18226157f, 0.09150477f, 0.21540146f, 0.18629247f, 0.35495442f, 
    0.25396210f, -0.06395416f, -0.10126331f, 0.17821309f, -0.26810709f, 0.11468693f, 0.07378909f, -0.00764101f, 
    -0.03340229f, 0.08188733f, -0.33279720f, -0.10452847f, -0.03901915f, -0.09126201f, 0.24639480f, -0.26402476f, 
    -0.16623098f, 0.00283857f, -0.14261711f, 0.32712224f, -0.35430306f, 0.10462321f, 0.19941507f, -0.01313291f, 
    0.09410607f, -0.11666681f, 0.25335184f, -0.07285677f, 0.08640075f, -0.14655554f, -0.18300307f, 0.39370635f, 
    0.33291951f, 0.28642720f, 0.24768539f, 0.02726050f, 0.61328858f, 0.33367369f, -0.16111980f, -0.14646517f, 
    -0.07858005f, -0.05757233f, 0.23831105f, -0.19022624f, 0.06421316f, 0.17816851f, 0.14558537f, 0.27689654f, 
    -0.03124369f, 0.26519847f, 0.12677811f, -0.21089140f, 0.28112426f, 0.28619027f, -0.05611406f, 0.04648616f, 
    0.25622699f, -0.14938051f, -0.25697172f, 0.35448152f, 0.05476194f, -0.04938849f, 0.06778596f, 0.08957109f, 
    0.23053291f, 0.06366855f, 0.06345060f, -0.15269436f, 0.13808255f, 0.11542781f, -0.08041061f, -0.06768773f, 
    -0.29681227f, 0.10240112f, -0.03486911f, 0.18031913f, -0.02219606f, -0.59167075f, 0.34880945f, -0.10303106f, 
    -0.16091456f, 0.02371827f, -0.16838792f, -0.31408608f, 0.20294423f, -0.45937648f, 0.48117521f, 0.05365501f, 
    -0.22799179f, -0.01396089f, -0.08215037f, 0.17179625f, -0.14385986f, -0.24613343f, 0.11777418f, 0.32119685f, 
    -0.02816793f, 0.09075172f, 0.08758870f, 0.29703289f, -0.66827232f, 0.27627617f, 0.11310160f, 0.23484759f, 
    0.08078042f, -0.02692621f, 0.23463860f, 0.02798688f, -0.12157299f, -0.72685218f, -0.10124054f, -0.07788243f, 
    -0.13866231f, 0.25866473f, 0.13273568f, 0.25794595f, 0.02658414f, -0.24244751f, 0.30155885f, -0.18957791f, 
    -0.06987010f, -0.00983369f, 0.20719509f, 0.39077628f, -0.01277613f, 0.13149579f, -0.01171444f, -0.38019416f, 
    -0.32012853f, 0.47815502f, -0.29273844f, 0.18059514f, -0.74571943f, 0.03651118f, 0.03343133f, 0.15514386f, 
    0.50044316f, 0.32894263f, -0.03470588f, 0.28366318f, 0.15882790f, -0.30638009f, 0.18826593f, 0.46346653f, 
    0.08939785f, -0.16111633f, 0.01504549f, 0.24115421f, -0.04457945f, 0.26309001f, -0.01043898f, -0.20612897f, 
    -0.06510584f, 0.10782913f, -0.17876668f, -0.29947075f, -0.01462888f, 0.25968710f, 0.12795891f, 0.02849630f, 
    -0.45642525f, -0.37434143f, -0.07752928f, 0.12212005f, -0.05247268f, -0.20303148f, 0.06020309f, -0.05193063f, 
    0.40033057f, 0.15096167f, 0.16614926f, -0.17665187f, -0.05435222f, 0.34514785f, 0.01245909f, -0.22271876f, 
    -0.01232439f, 0.09200191f, 0.13789028f, -0.07122390f, 0.15152209f, 0.22391708f, 0.03306402f, -0.23211481f, 
    0.00454634f, 0.09437417f, -0.03541902f, 0.34327710f, -0.10303285f, -0.12716630f, -0.11829244f, -0.10261720f, 
    0.09091598f, 0.06741561f, 0.32945883f, 0.07238639f, 0.75370705f, 0.28934503f, 0.16577758f, 0.13249364f, 
    -0.24575293f, 0.19181211f, -0.09351759f, -0.22927372f, -0.15987810f, -0.12995003f, 0.01479562f, 0.26423752f, 
    0.11567093f, -0.08679201f, 0.01400080f, 0.40036404f, -0.46809503f, 0.32324389f, -0.08808861f, -0.06487016f, 
    0.19031692f, 0.12456983f, 0.31833753f, 0.21103142f, -0.06339923f, 0.19719650f, 0.22398494f, 0.55053961f, 
    0.38419893f, 0.15732116f, -0.15037993f, 0.22270836f, 0.33076233f, 0.05163572f, -0.09204425f, -0.24460757f, 
    0.07009484f, -0.50645417f, 0.14911085f, -0.16357577f, 0.06357335f, 0.11456362f, -0.25296560f, 0.22019324f, 
    -0.16132641f, 0.10752515f, -0.01181522f, -0.42171589f, 0.22533074f, 0.20288095f, -0.19282180f, 0.21932098f, 
    0.30905157f, -0.09529570f, 0.12223800f, 0.15910958f, 0.06666233f, 0.00081121f, -0.09216426f, 0.04493929f, 
    0.06238152f, 0.39712238f, 0.08066751f, -0.02256067f, -0.12738651f, 0.06741896f, 0.01821975f, 0.10811446f, 
    0.07215570f, 0.29337123f, -0.32544819f, 0.17078340f, 0.12517142f, -0.34433305f, -0.26757887f, -0.09755688f, 
    -0.03063022f, -0.10009050f, -0.03024624f, -0.13904363f, -0.12653308f, 0.19577745f, 0.16373602f, -0.14848229f, 
    -0.37868097f, 0.02789442f, -0.08352882f, 0.12703356f, -0.12966518f, 0.11270922f, 0.13065767f, 0.29984543f, 
    -0.38561633f, 0.03958838f, 0.12162586f, 0.31472519f, 0.18182571f, -0.11527327f, 0.19194634f, 0.31078723f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.01513991f, -0.15986678f, 0.01157425f, 0.15509254f, 0.08061764f, -0.17190948f, 0.04339188f, 0.08788136f, 
    0.11696198f, 0.18144569f, 0.01274879f, -0.03352938f, 0.06631443f, 0.29844281f, -0.08224238f, 0.26276824f, 
    0.08323511f, -0.02555886f, 0.09085637f, 0.13792405f, 0.06661696f, 0.16028962f, -0.08260297f, 0.00278580f, 
    -0.05129696f, 0.31458637f, 0.00714986f, -0.10910495f, 0.18469013f, 0.14277688f, 0.04504624f, 0.13162807f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.15931523f, -0.24910089f, 0.14236231f, 0.01972268f, -0.02964810f, 0.05505556f, -0.12413396f, 0.00787929f, 
    -0.41849446f, -0.02954134f, 0.39386296f, 0.02164617f, 0.15056388f, -0.60559648f, 0.23643142f, -0.59311444f, 
    0.12563178f, -0.10354147f, -0.36186531f, 0.30031765f, -0.30450165f, -0.74713653f, -0.09708066f, -0.09566589f, 
    0.19698079f, -0.26549026f, -0.89200383f, -0.17162356f, 0.29018128f, -0.16025694f, 0.28732726f, -0.24826194f, 
    -0.54009485f, 0.00126479f, -0.08755197f, -0.09901538f, -0.26585022f, -0.39008647f, -0.19294937f, 0.34684119f, 
    -0.10672870f, 0.29494411f, 0.05236945f, -0.41563278f, 0.55891097f, 0.15534872f, 0.10474409f, -0.25316662f, 
    0.20762788f, 0.00692030f, -0.20141485f, 0.27518213f, -0.18997042f, -0.18909132f, 0.03660359f, -0.35441074f, 
    -0.04624815f, 0.06475406f, 0.51779675f, -0.10082213f, -0.24874361f, -0.04194499f, 0.34822166f, 0.07833199f, 
    0.05859156f, -0.58152235f, -0.08186099f, 0.04076790f, -0.07362781f, -0.16059305f, 0.33060470f, 0.27591717f, 
    0.16507708f, 0.51325125f, -0.05310839f, -0.58191520f, -0.99516660f, 0.01380930f, -0.29657510f, 0.03186706f, 
    -0.24129643f, 0.14820768f, -0.30392686f, -0.46597651f, -0.06878602f, 0.15648523f, 0.24571167f, -0.17424127f, 
    0.10070334f, 0.34828731f, 0.04208087f, -0.70057362f, -0.13363878f, -0.01115988f, -0.11466958f, -0.22182606f, 
    0.46570054f, -0.12418568f, 0.28056160f, 0.08589312f, 0.35482091f, 0.30351353f, -0.36323604f, 0.01002733f, 
    -0.08370801f, 0.16584164f, -0.34792492f, 0.06715414f, 0.03665103f, -0.22081575f, 0.12773414f, 0.20855682f, 
    0.01918021f, -0.20772955f, -0.35057196f, -0.25681439f, 0.32430682f, -0.24341919f, 0.20316240f, -0.42793819f, 
    0.22476904f, -0.45340317f, -0.22574387f, -0.21814501f, -0.01031099f, 0.06093330f, 0.04606383f, -0.86277336f, 
    -0.47916615f, -0.73470247f, -0.08222230f, 0.24862081f, -0.28294769f, 0.08857217f, -0.55310625f, 0.18337117f, 
    0.10447820f, -0.10612782f, -0.00245838f, 0.33663550f, -0.85333359f, -0.21450068f, -0.27690634f, 0.11138391f, 
    0.19670679f, -0.22810732f, 0.12938654f, -0.36053690f, 0.41900799f, -0.08836975f, 0.16697480f, 0.04813947f, 
    -0.02645292f, -0.46015593f, -0.32386059f, 0.22957000f, 0.04810382f, 0.11119212f, 0.14247419f, -0.15986489f, 
    -0.43769595f, -0.20318815f, 0.06097082f, 0.16191848f, -0.37919912f, -0.33903068f, -0.22034283f, -0.43212312f, 
    -0.25503823f, -0.55077994f, 0.20910871f, 0.02902512f, -0.46838671f, 0.18541206f, 0.01237947f, 0.06132420f, 
    -0.17886472f, -0.20677646f, -0.30152866f, 0.55355096f, -0.12071260f, 0.26821429f, -0.08924567f, -0.15123908f, 
    0.05673303f, -0.08144968f, -0.13448025f, 0.37187132f, 0.06846554f, 0.06953081f, 0.05116715f, 0.19259286f, 
    -0.07290076f, -0.11225436f, -0.62945449f, -0.60073024f, -0.22944868f, 0.23099187f, 0.47280434f, -0.65383464f, 
    0.28535718f, 0.11052468f, -0.12396488f, -0.02532815f, -0.36866185f, 0.29543599f, -0.78546232f, 0.18485034f, 
    -0.59607112f, -0.20319237f, -0.53683120f, -0.34517869f, -0.17043422f, 0.06559870f, 0.10511950f, 0.29730764f, 
    -0.46912834f, 0.30812222f, -0.26357868f, -0.19334833f, -0.28117812f, 0.05831684f, -0.13874988f, -0.06501362f, 
    0.34250015f, 0.50556010f, 0.07840293f, -0.15257646f, 0.06541514f, -0.47778356f, 0.21770900f, -0.37850556f, 
    0.12117120f, 0.16609262f, 0.15659264f, -0.63328868f, -0.41783366f, -0.15853204f, 0.37724379f, -0.45058590f, 
    -0.00071099f, -0.13060156f, 0.30707055f, -0.37750420f, 0.11572195f, -0.18585622f, -0.18046692f, 0.23514703f, 
    -0.40595543f, -0.38756132f, -0.05577523f, 0.19391340f, -0.32877076f, 0.06313789f, -0.18387035f, -0.17625330f, 
    0.39935675f, -0.30795860f, -0.46619800f, -0.46156809f, 0.39220095f, -0.09624799f, 0.02056797f, -0.70320690f, 
    -0.12805976f, 0.31433120f, -0.05740049f, -0.30778998f, 0.07285640f, -0.01562947f, 0.37042072f, 0.22297150f, 
    -0.09289110f, -0.15128987f, 0.37520078f, 0.21411183f, 0.06145647f, -0.47659057f, -0.47475058f, -0.05453796f, 
    0.09818372f, 0.32091907f, -0.14352080f, 0.08465347f, -0.13672422f, -0.44232538f, -0.38323727f, 0.01322433f, 
    -0.54334384f, 0.06299501f, -0.33687469f, -0.02988541f, -0.27678266f, -0.57931906f, -0.40496296f, -0.04014291f, 
    0.22598854f, -0.56920385f, -0.00891571f, -0.14595698f, -0.06120844f, -0.24595633f, -0.29388019f, 0.13615167f, 
    -0.27923205f, 0.04798658f, -0.12663612f, -0.09849349f, -0.13662992f, 0.10878070f, 0.10649625f, 0.38019058f, 
    0.09958275f, -0.01517114f, -0.47374234f, -0.30390778f, 0.30849075f, 0.37396160f, -0.47281811f, 0.20914666f, 
    -0.23257214f, -0.38535330f, 0.00193460f, 0.06762514f, 0.38698313f, 0.32668713f, -0.04347457f, 0.32730204f, 
    -0.27005181f, -0.02902861f, -0.71622163f, 0.30712995f, -0.29012582f, 0.36765337f, -0.16853519f, -0.02596402f, 
    0.00714885f, 0.02402495f, -0.68688530f, -0.30094817f, 0.10809552f, -0.21512850f, -0.51176029f, -0.30204362f, 
    -0.00815431f, 0.09090092f, 0.44270819f, -0.20057863f, 0.25964332f, -0.60842460f, -0.25231615f, 0.16777505f, 
    -0.00338761f, -0.07753771f, -0.21874708f, 0.30128536f, -0.11165819f, 0.34152988f, -0.05107562f, -0.26055694f, 
    -0.15325642f, 0.29448539f, -0.17904763f, 0.64056915f, 0.23000887f, 0.09938773f, -0.41094306f, 0.04192607f, 
    -0.20715581f, 0.13717420f, 0.19130839f, -0.31436139f, -0.31197104f, 0.31993717f, -0.19492914f, -0.34813842f, 
    -0.42361242f, -0.00195949f, -0.18710659f, 0.29229140f, -0.53724176f, -0.02564417f, -0.62986338f, 0.17191131f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.23562963f, -0.14431110f, -0.01210382f, -0.21956952f, -0.16850574f, -0.03488895f, -0.05053892f, 0.08089836f, 
    -0.14156176f, 0.12960356f, 0.01603346f, -0.10777631f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
