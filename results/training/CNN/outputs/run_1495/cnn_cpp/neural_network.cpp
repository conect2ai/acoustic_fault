#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.09371209f, -0.24185240f, -0.58464944f, -0.39316350f, -0.70224303f, -0.47865471f, -0.13803731f, -0.17835601f, 
    -0.75514996f, -0.91428238f, 0.00843429f, -0.27317381f, -0.19427176f, 0.10974520f, 0.51506406f, -0.08545454f, 
    -0.13549428f, -0.35998479f, -0.32347673f, -0.51184899f, 0.03998262f, -0.29990622f, 0.18256474f, 0.07359274f, 
    -0.24162680f, -0.10831040f, -0.35149947f, -1.02168214f, -0.20375051f, 0.38443083f, -0.09819651f, -0.00606429f, 
    0.26349702f, 0.12461101f, -0.15396903f, -0.38500315f, -0.28139284f, -0.31365454f, 0.04680983f, 0.16112211f, 
    0.38334543f, 0.25455496f, -0.02897914f, 0.27340391f, -0.26440099f, -0.19931839f, -0.02906333f, -0.22076860f, 
    -0.28515834f, -0.09371372f, -0.29260772f, 0.48863322f, -0.41034907f, -0.10009789f, -0.37635684f, -0.37299052f, 
    -0.37021661f, 0.02363741f, 0.37268433f, 0.22203819f, -0.36446723f, -0.45965353f, -0.13254918f, -0.21887144f, 
    -0.22519100f, 0.05193034f, 0.11805154f, 0.50304610f, 0.09166964f, 0.00459787f, -0.03993846f, -0.13449688f, 
    0.06381011f, -0.24837425f, -0.39519486f, 0.56491035f, -0.61160332f, 0.37753835f, -0.18422566f, -0.49505571f, 
    0.15226090f, -0.35092175f, 0.00186873f, 0.10762381f, 0.19245435f, -0.07815702f, 0.08797980f, -0.34570131f, 
    -0.02904975f, 0.05296182f, -0.26539665f, -0.15864494f, -0.31207040f, -0.21161592f, -0.46250987f, -0.22665738f, 
    -0.41727155f, -0.11491469f, 0.07588971f, -0.29433215f, 0.14676134f, 0.19241914f, 0.10040491f, 0.29060802f, 
    0.24932702f, 0.21236126f, -0.20952137f, -0.18649948f, 0.27979568f, 0.07358962f, -0.11502154f, -0.23153785f, 
    -0.01487651f, 0.01644649f, -0.04105253f, 0.07857520f, 0.19456771f, -0.29243436f, -0.11931914f, -0.08119195f, 
    -0.38157922f, 0.08899365f, -0.04311461f, -0.19034226f, -0.45916766f, 0.21292931f, -0.41018215f, 0.40759239f, 
    0.32076874f, -0.53090602f, -0.36975867f, -0.63291407f, 0.22278966f, 0.62683517f, 0.17307776f, -0.57505959f, 
    -0.51004535f, -0.37534890f, -0.13386248f, 0.09789545f, -0.16332051f, -0.48419580f, -0.36246571f, 0.40794137f, 
    0.21294653f, -0.31080335f, -0.07398956f, 0.04634448f, -0.08380646f, -0.15061674f, -0.11944763f, -0.45838249f, 
    -0.49981213f, -0.15133804f, -0.48861030f, 0.34375587f, 0.17278831f, -0.13699520f, -0.14207695f, 0.25788271f, 
    -0.26816317f, -0.38461185f, -0.16809218f, 0.25175685f, 0.08339471f, -0.30146986f, -0.33896241f, -0.24669936f, 
    -0.21668044f, -0.30270690f, -0.37344459f, -0.20707552f, 0.06264735f, -0.17325026f, -0.39651531f, -0.70316654f, 
    0.38839626f, -0.59912461f, -0.38135469f, -0.32331869f, -0.40944827f, -0.18435441f, 0.26713979f, 0.60669291f, 
    0.18330213f, 0.00154877f, -0.02586517f, 0.02693822f, -0.23038241f, 0.14938413f, 0.13203828f, -0.32927665f, 
    -0.47741920f, -0.38158503f, -0.22782801f, -0.32884869f, -0.15265627f, -0.28152433f, -0.30209684f, 0.02884601f, 
    0.16383407f, -0.24425921f, -0.50819176f, -0.43978381f, -0.47590488f, 0.42266291f, 0.05650192f, 0.11477187f, 
    -0.21357532f, 0.51304239f, -0.07723666f, 0.49435568f, -0.01207937f, -0.06839948f, 0.14695740f, -0.13586955f, 
    0.03413551f, -0.03096102f, -0.09062838f, -0.03913400f, 0.05043069f, -0.15220295f, -0.05626320f, 0.03885815f, 
    0.13089260f, -0.03032051f, -0.32507312f, -0.05749807f, -0.17450473f, 0.40819624f, -0.18097703f, 0.41142204f, 
    -0.27128997f, -0.17878762f, 0.08036558f, -0.12001412f, -0.08473694f, 0.20138423f, -0.15369336f, 0.01058071f, 
    -0.30422351f, -0.06746135f, 0.19680808f, -0.07358769f, 0.15296772f, 0.26965865f, -0.24770278f, -0.19549981f, 
    -0.05684905f, 0.22259024f, 0.59633648f, -0.21780135f, -0.08214319f, 0.38718793f, -0.64278090f, 0.43505350f, 
    -0.14666846f, 0.26454505f, -0.25627896f, 0.00774749f, 0.08989861f, 0.20731467f, -0.30062112f, -0.32085538f, 
    0.07149149f, 0.00308965f, 0.03690412f, -0.05624037f, -0.06033497f, 0.14141685f, 0.12406547f, -0.32791933f, 
    -0.01986408f, 0.00709983f, 0.07334545f, 0.75465328f, 0.04522176f, 0.01377965f, 0.27709514f, -0.19108950f, 
    -0.56060165f, -0.37994316f, -0.29340509f, -0.23974037f, 0.21860360f, -0.08749626f, -0.09760108f, 0.09524426f, 
    0.05399831f, -0.30459103f, 0.01461094f, 0.06812581f, 0.21717928f, 0.00984567f, -0.05993544f, 0.04966110f, 
    0.01780971f, 0.24889438f, -0.04324513f, -0.01516523f, 0.21321911f, -0.18641630f, 0.02942748f, 0.31292802f, 
    0.30550107f, 0.18403034f, 0.01391677f, 0.21984547f, 0.03331379f, -0.19481617f, 0.14260437f, 0.44296569f, 
    0.29178724f, -0.18778364f, -0.34054357f, -0.24244972f, 0.07191312f, 0.06170847f, 0.00643850f, -0.21783631f, 
    -0.05538098f, 0.15526855f, 0.03076807f, 0.13453585f, -0.06692619f, 0.13929650f, 0.66695350f, 0.32522762f, 
    -0.58894122f, 0.08775777f, -0.35321382f, 0.22375838f, 0.16717517f, 0.10924914f, 0.12592353f, -0.48848715f, 
    0.36990824f, 0.05733196f, -0.10764980f, -0.36948863f, -0.02141298f, -0.22596517f, 0.07344662f, 0.01880760f, 
    -0.18339424f, -0.24037126f, 0.26216701f, 0.14198269f, -0.02198434f, -0.19266357f, 0.20207915f, 0.49075946f, 
    0.32149610f, -0.48408952f, -0.58579975f, 0.28328317f, -0.01896329f, 0.00992066f, -0.00157122f, -0.32579127f, 
    0.28714833f, -0.49037117f, -0.18205227f, 0.30621773f, -0.14532635f, 0.38178453f, 0.03312266f, -0.16311902f, 
    0.15340242f, -0.06629464f, -0.40665394f, -0.24806914f, -0.15662895f, 0.27744007f, 0.26175401f, 0.94177085f, 
    -0.84411526f, -0.88315064f, -0.28199691f, -0.12396768f, 0.88245767f, 0.23025827f, -0.17311125f, -0.25502601f, 
    0.64024413f, 0.15648907f, 0.26824695f, -0.48770088f, -0.21208794f, -0.06493346f, -0.04744521f, -0.18149251f, 
    0.33901733f, 0.23159412f, -0.18359172f, 0.00152851f, -0.20999053f, -0.03839527f, 0.20284897f, 0.01758439f, 
    0.18836525f, 0.51440006f, 0.22399063f, -0.32527345f, -0.17546640f, -0.18341340f, 0.08295587f, -0.17274733f, 
    0.34954745f, -0.17009732f, 0.04401766f, 0.17235713f, -0.20190333f, -0.23276615f, 0.06639206f, -0.21687125f, 
    0.28837878f, 0.08297276f, -0.11319296f, -0.47633344f, -0.38473940f, -0.32330927f, -0.11638212f, -0.64116645f, 
    -0.46152750f, 0.35092756f, 0.72005445f, 0.27179831f, -0.33405313f, -0.64985955f, -0.01403734f, -0.44165888f, 
    -0.23386613f, -0.14377370f, -0.30812591f, 0.40020230f, -0.14618559f, 0.29001042f, 0.43805397f, -0.01989812f, 
    -0.28294346f, 0.27415502f, -0.04253693f, 0.19869642f, -0.39587584f, -0.15854929f, -0.03082321f, -0.02167214f, 
    -0.01921244f, -0.18416151f, -1.23834658f, -0.72442704f, -0.67923677f, -0.25619516f, -0.06260005f, 0.89146560f, 
    0.49868110f, -0.01781658f, -0.78307939f, -0.35457781f, -0.01411690f, -0.37950963f, -0.22770008f, 0.36693141f, 
    -0.47668797f, -0.11738693f, 0.18144654f, -0.35979956f, -0.34317741f, 0.03565363f, 0.02864426f, -0.27681530f, 
    0.10021752f, 0.05361053f, -0.16223271f, 0.82838321f, 0.24237147f, -0.17217083f, -0.29951638f, -0.29254094f, 
    -0.11632910f, 0.08075973f, 0.33061954f, -0.87008315f, -0.70890129f, -0.26192766f, -0.01204846f, -0.04549359f, 
    -0.13633734f, -0.05712350f, -0.02885399f, -0.15203662f, 0.10500930f, 0.13056293f, 0.20385914f, 0.10972570f, 
    -0.24625519f, -0.34201461f, -0.38215214f, -0.31735003f, -0.42723447f, -0.24233443f, -0.76617551f, -0.22004181f, 
    0.56607413f, 0.44837320f, 0.42832521f, -0.17328617f, -0.16235445f, -0.19099337f, 0.12468945f, -0.22656582f, 
    0.30322424f, 0.13850285f, 0.16321948f, -0.11271112f, 0.21724696f, -0.14721160f, -0.31221646f, -0.25697199f, 
    0.11319663f, 0.03567583f, -0.20893529f, 0.19904257f, 0.21844852f, -0.67061049f, 0.04765834f, 0.57303131f, 
    0.28493857f, -0.20444040f, -0.68536717f, -0.38211226f, 0.31391224f, 0.51721120f, 0.39647013f, 0.34708807f, 
    -0.04134184f, -0.04363763f, -0.16570278f, -0.04463007f, -0.22798944f, -0.27278689f, 0.12280785f, -0.00632631f, 
    0.21603744f, 0.08325738f, 0.30340639f, -0.09408228f, 0.05757163f, -0.17380592f, 0.06576390f, -0.47422865f, 
    -0.51988965f, -0.69876182f, 0.00351992f, -0.01170761f, -0.02653290f, -0.21808085f, -0.10387842f, -0.15768838f, 
    0.55664074f, 0.43114966f, 0.24008806f, 0.00228104f, -0.11052768f, -0.24631290f, 0.02118850f, -0.14885607f, 
    -0.04259196f, -0.10735247f, 0.00430634f, -0.08228024f, -0.34173009f, -0.15052319f, -0.49823892f, -1.05529213f, 
    -0.92414159f, -0.25571364f, 0.89555407f, 0.76296955f, -0.27242491f, -0.68783635f, -0.51959455f, 0.45393288f, 
    -0.12734672f, 0.09263922f, 0.10639097f, -0.07939918f, 0.05361161f, -0.13629931f, 0.05054900f, 0.10564595f, 
    0.25963101f, -0.07848749f, 0.01678444f, -0.03862437f, 0.01425038f, -0.03776381f, -0.21210334f, -0.30848393f, 
    0.00237711f, -0.21460344f, -0.24386370f, 0.03386587f, 0.25236830f, 0.08336337f, 0.14870930f, 0.13773906f, 
    0.42284793f, 0.06594813f, 0.06057755f, 0.23781614f, 0.06666663f, -0.30521968f, -0.19532408f, -0.17293987f, 
    -0.14057428f, 0.17598671f, -0.30232686f, -0.02034014f, -0.06448215f, 0.20725940f, -0.27685156f, 0.15661813f, 
    0.43142617f, 0.03154454f, 0.53166252f, 0.11310133f, 0.24038956f, 0.58388019f, 0.03028169f, -0.12143366f, 
    -0.37808388f, -0.49309412f, -0.46306655f, -0.07638948f, 0.14938559f, 0.10648662f, 0.03920276f, -0.07992665f, 
    -0.05268507f, -0.07698032f, 0.16582705f, 0.13408129f, 0.17190836f, -0.01137262f, -0.04285519f, -0.00025609f, 
    -0.14590977f, -0.14202829f, 0.12919283f, 0.03122658f, 0.13059908f, -0.25165543f, 0.10418849f, 0.15595193f, 
    0.05949987f, 0.19593650f, -0.35803589f, 0.00839311f, -0.09373263f, 0.05325924f, 0.24948709f, -0.10593060f, 
    -0.06955526f, -0.29728541f, -0.06476013f, -0.11996791f, 0.30204359f, -0.17527114f, 0.17924269f, -0.28394628f, 
    -0.06982879f, 0.08667312f, 0.21622701f, -0.91198617f, -0.18789743f, -0.45765796f, -0.22539049f, -0.08933292f, 
    0.11724476f, 0.43970889f, 0.46907681f, 0.49553159f, -0.14148320f, 0.03286776f, 0.22670148f, 0.02045342f, 
    0.19366546f, -0.07441121f, -0.07401153f, 0.00580388f, 0.13461019f, -0.09052864f, -0.12973502f, -0.00099321f, 
    -0.20511159f, 0.01477940f, 0.10644117f, 0.04726121f, -1.28447425f, 0.06327610f, 0.53622961f, -0.93309164f, 
    -0.76425874f, 0.17278723f, 0.09202709f, -0.02064019f, 0.45838058f, 0.57719690f, 0.01140538f, 0.10657079f, 
    0.12414362f, -0.17259313f, 0.13680957f, 0.04800122f, -0.09948584f, 0.18132837f, -0.13502289f, -0.03687223f, 
    0.02041095f, 0.20629305f, 0.05450873f, -0.02533301f, -0.05619669f, 0.40847883f, 0.78190321f, 0.61469734f, 
    0.12619698f, -0.46861401f, -0.30293721f, -0.37239805f, -0.19822572f, -0.37225109f, -0.52984118f, 0.15610997f, 
    -0.04056506f, -0.04902595f, -0.25724277f, -0.00425299f, 0.21397193f, 0.11406086f, 0.25313112f, 0.09367530f, 
    0.24891889f, -0.05376902f, 0.05079068f, -0.10677361f, -0.21732803f, -0.08626696f, -0.08016753f, -0.52681333f, 
    -0.29861546f, 0.37003899f, -0.43462217f, 0.19532140f, 0.10912535f, 0.23028956f, 0.17858145f, -0.32885346f, 
    0.03949532f, -0.04111793f, 0.00341768f, -0.27030349f, -0.06490625f, 0.07343288f, 0.17506620f, 0.07316858f, 
    0.12427554f, 0.29968914f, -0.03135392f, -0.34144416f, -0.13588481f, 0.08960672f, -0.41370645f, 0.82876951f, 
    0.23418128f, 0.25070530f, -0.24453670f, -0.27918693f, 0.40247241f, -0.12583819f, 0.29444370f, 0.09650718f, 
    0.06636179f, 0.05387676f, 0.05725046f, -0.32794201f, -0.33963910f, -0.06229525f, -0.01839671f, -0.14754687f, 
    0.12951195f, -0.14297882f, -0.13707833f, 0.23303065f, 0.32881397f, -0.10300156f, -0.30354705f, -0.07075718f, 
    -0.56289870f, 0.03253696f, 0.10017748f, -0.56348187f, -0.39588290f, 0.24270995f, 0.34488711f, 0.15230994f, 
    -0.10030130f, 0.12025183f, 0.15638845f, 0.31690881f, -0.22008127f, -0.00686383f, -0.01062476f, -0.41137031f, 
    -0.38301319f, -0.10062288f, -0.33757922f, -0.11873385f, 0.20060936f, 0.22074339f, 0.05308377f, 0.24790633f, 
    0.28875279f, -0.03117103f, -0.35292131f, -0.12642586f, -0.17542386f, 0.30826268f, -0.11291373f, -0.02469473f, 
    -0.01267374f, 0.27150905f, -0.17761409f, 0.39314729f, 0.26698282f, 0.08135756f, -0.32773128f, -0.23811743f, 
    -0.13903600f, 0.11142524f, 0.10775098f, 0.04965267f, -0.34391189f, 0.06293015f, 0.45577556f, 0.10695843f, 
    -0.07740897f, 0.22768128f, 0.07468756f, -0.88529259f, -0.24553439f, 0.41951230f, 0.02147192f, -0.13440230f, 
    -0.37412697f, -0.47802997f, -0.25912899f, 0.44108340f, -0.53462660f, -0.22732690f, 0.12346991f, 0.00354272f, 
    0.42374408f, -0.36625522f, -0.13536645f, -0.21595383f, -0.28770408f, -0.57301301f, -0.23865217f, -0.27042916f, 
    -0.28986949f, -0.01033690f, -0.37842184f, -0.93183845f, -0.69672531f, -0.32720608f, 0.02768690f, -0.19774076f, 
    -0.28354979f, -0.65485001f, -0.79855412f, -0.39683947f, -0.09245953f, -0.14472158f, -0.15536213f, -0.25682235f, 
    -0.37495476f, -0.27882114f, -0.26079577f, -0.00047352f, -0.16196856f, 0.10591868f, -0.05018932f, 0.01890231f, 
    0.01679816f, -0.29564503f, 0.10848490f, -0.15058097f, -0.65030092f, -0.32106403f, -0.11116862f, 0.43980518f, 
    0.51875013f, 0.34154433f, 0.18727681f, 0.08488627f, -0.18359959f, -0.23361634f, 0.20119745f, 0.16387236f, 
    0.22028786f, -0.26463953f, -0.05928465f, -0.02220728f, -0.05456384f, -0.14580821f, 0.19269972f, -0.13393527f, 
    0.21026622f, -0.17570309f, 0.02515530f, 0.10598877f, -0.04552346f, 0.20343074f, -0.12963066f, -0.02675341f, 
    -0.27082434f, -0.06246668f, 0.03114504f, 0.02799731f, 0.37740612f, 0.05426410f, -0.07766900f, -0.03425637f, 
    0.42470035f, 0.23239154f, -0.21383923f, -0.14063697f, -0.39681572f, 0.33796543f, 0.13052802f, -0.38780719f, 
    0.19450702f, -0.20746928f, 0.38886771f, -0.00642112f, -0.25563693f, 0.03736682f, -0.11312269f, 0.64247274f, 
    -0.08641215f, -0.80839938f, -0.66491467f, -0.20506001f, -0.20096631f, 0.35910672f, 0.55245781f, 0.20395935f, 
    -0.26826370f, -0.09431878f, 0.22249195f, 0.02475469f, -0.17613114f, 0.22623637f, 0.15122573f, -0.02111888f, 
    0.13744599f, 0.01539797f, 0.05822162f, 0.03379917f, -0.28340191f, 0.20329843f, -0.45478341f, 0.43485948f, 
    0.13175446f, -0.30670908f, -0.33433518f, -0.54316545f, -0.49313569f, -0.43306977f, -0.12852998f, -0.57246435f, 
    -0.91130549f, -0.10360534f, -0.05769729f, 0.14322655f, 0.08027552f, -0.01584825f, -0.04425287f, -0.66088003f, 
    -0.00718172f, -0.02856021f, -0.03276916f, 0.05277281f, 0.08814966f, 0.09938491f, 0.19763649f, -0.10805093f, 
    0.23626275f, 0.54843038f, 0.55453777f, -0.13540767f, 0.09516178f, -0.14532629f, 0.12764190f, -0.21043240f, 
    0.20721282f, -0.00294757f, -0.24769355f, 0.01769436f, 0.40963507f, -0.29691738f, -0.22204821f, -0.19040471f, 
    -0.15517388f, -0.14771008f, -0.14437626f, 0.13900335f, -0.00857948f, -0.08375292f, -0.05048645f, 0.17760240f, 
    -0.08880520f, 0.60382688f, -0.20682660f, -0.01736674f, 0.35086143f, -0.16028720f, 0.45206010f, 0.65934825f, 
    -0.47280401f, -0.60935414f, -0.50592369f, 0.21065253f, 0.17598192f, 0.12221526f, -0.34295204f, -0.21104060f, 
    0.03190832f, -0.20675758f, -0.17447358f, 0.21818624f, 0.05185586f, -0.38527003f, 0.33486626f, 0.01044140f, 
    0.10288351f, -0.18350786f, 0.05278809f, -0.10092074f, 0.31103635f, -0.27311614f, -0.23243028f, 0.62326807f, 
    0.08462045f, -0.57733381f, -0.42461318f, 0.70950294f, -0.21020924f, 0.49962980f, -0.23914565f, -0.19724903f, 
    -0.18352285f, -0.20505366f, -0.08126582f, 0.19722898f, -0.03047690f, -0.28753045f, 0.06936014f, 0.13384151f, 
    -0.01957759f, 0.15712412f, 0.04554066f, 0.48892343f, 0.18548441f, 0.33548588f, 0.11935946f, 0.26789123f, 
    -0.27486238f, -0.16008373f, -0.02897864f, 0.22894470f, 0.04415214f, 0.19964182f, 0.06591491f, -0.21535994f, 
    0.08663899f, -0.01899782f, 0.15401839f, 0.03986633f, 0.03007394f, -0.13908796f, 0.05657724f, -0.11247762f, 
    0.31810582f, 0.11901733f, -0.03870324f, -0.29299897f, 0.27868319f, 0.00960933f, 0.14661829f, 0.19040146f, 
    -0.31582573f, -0.14832130f, 0.33318272f, -0.29662645f, -0.32914993f, 0.15269721f, 0.23496386f, -0.35843411f, 
    -0.06858494f, -0.05453274f, -0.07748105f, -0.04526008f, -0.40461186f, 0.30696246f, 0.08643074f, -0.35227695f, 
    -0.00182005f, 0.03705243f, 0.10617927f, 0.19978781f, 0.23330642f, 0.29870445f, 0.63941294f, 0.24448411f, 
    -0.06533678f, -0.44447994f, 0.14616409f, -0.46876976f, -0.16855608f, 0.07068570f, 0.00116612f, 0.10153061f, 
    -0.36580727f, 0.07365514f, 0.33400768f, -0.22549850f, 0.06700373f, 0.22633052f, -0.05612361f, -0.26116684f, 
    0.25242469f, 0.29450041f, 0.00853646f, -0.01503595f, -0.33087349f, -0.13466923f, 0.01793152f, 0.05240321f, 
    -0.26995999f, 0.25978890f, -0.01538541f, -0.86389357f, -0.26203048f, 0.70622098f, 0.51604319f, 0.18271343f, 
    -0.02122904f, -0.09785091f, -0.09000953f, -0.15010819f, -0.33375916f, 0.09090137f, -0.06328177f, 0.22749822f, 
    0.11382974f, -0.05533378f, -0.22385381f, 0.06109441f, -0.33694926f, -0.01506355f, 0.25537500f, -0.53089690f, 
    -0.59426677f, -0.09551976f, -0.35136929f, -0.47737402f, -0.35490158f, -0.38336805f, -0.47305900f, -0.29460192f, 
    -0.46889511f, -0.14814317f, 0.07438935f, 0.01704878f, 0.31848195f, -0.27580419f, 0.10829865f, -0.12378269f, 
    0.19631435f, -0.14676069f, -0.11038538f, 0.23809041f, 0.39339066f, -0.02037723f, 0.22412041f, 0.34836364f, 
    0.10509853f, -0.37199897f, -0.38886559f, 0.28481641f, -0.00694110f, -0.28880820f, -0.08328159f, -0.56154507f, 
    -0.32703865f, -0.16995190f, 0.58970308f, 0.45614082f, 0.23308553f, 0.19066742f, -0.06354123f, -0.01426178f, 
    0.09310669f, 0.03585240f, -0.28819439f, -0.14546469f, -0.09867711f, 0.06164026f, -0.07796864f, -0.03300916f, 
    -0.27877599f, -0.52889365f, -0.13335739f, 0.09141498f, -0.09289271f, -0.32262111f, 0.34486172f, 0.14221083f, 
    -0.17780992f, 0.01534366f, 0.14103699f, 0.49378338f, -0.04356791f, 0.33388335f, -0.60790783f, -0.29325190f, 
    0.03069974f, -0.21799183f, -0.18319876f, -0.36363173f, -0.19503528f, 0.00101269f, 0.09287246f, 0.35845307f, 
    0.34802765f, 0.41713142f, 0.27043572f, 0.16828509f, 0.16215573f, 0.08298369f, 0.28255805f, 0.19167104f, 
    0.10373293f, 0.04097850f, 0.23649976f, -0.18830475f, -0.23300351f, -0.20060882f, 0.04943805f, 0.05060163f, 
    -0.17093600f, -0.07949721f, -0.18960303f, -0.21058974f, 0.03313587f, 0.19030547f, -0.25938773f, -0.25011590f, 
    -0.12125410f, -0.39443263f, -0.49205270f, 0.31603241f, -0.33277169f, -0.18036389f, -0.28257498f, 0.05296365f, 
    0.13106041f, 0.06904123f, 0.16830756f, 0.44650188f, 0.20562750f, 0.27494144f, 0.09543370f, -0.03795347f, 
    -0.19815603f, 0.02242805f, -0.18530399f, -0.13999337f, 0.05471357f, 0.10368595f, 0.10148389f, 0.31754509f, 
    0.29688093f, -0.03374032f, -0.38349053f, -0.02110252f, -0.84885484f, -0.93221021f, -0.12281592f, 0.45712414f, 
    0.40035012f, 0.38625437f, 0.32781750f, -0.01698695f, 0.07562658f, 0.20330432f, -0.41008884f, -0.39679614f, 
    -0.39643013f, -0.04601013f, -0.24270536f, -0.11850946f, 0.09220065f, -0.06377914f, -0.04470166f, -0.25125203f, 
    0.13834119f, -0.18033521f, -0.07242127f, 0.07421708f, -0.07442448f, -0.45885155f, -0.25309309f, 0.16198602f, 
    -0.66508627f, -0.59951818f, -0.20323743f, -0.08719674f, 0.06053537f, -0.17884964f, -0.04772223f, -0.02901326f, 
    -0.04490229f, 0.21570098f, 0.10968764f, -0.19550677f, -0.10187903f, -0.05234601f, 0.01101131f, -0.02052253f, 
    -0.09609403f, -0.21145590f, -0.24909589f, -0.11826112f, -0.39486569f, -0.38713124f, 0.41153559f, 0.11063087f, 
    0.27254042f, 0.15432723f, -0.06688593f, -0.18744899f, 0.07073153f, 0.44745165f, -0.09398289f, 0.08119947f, 
    0.09838074f, 0.14106321f, 0.15330270f, 0.10279074f, -0.20626520f, -0.04199817f, 0.08287334f, -0.16768077f, 
    -0.06812418f, 0.07347652f, 0.14844602f, -0.13844784f, -0.09333456f, 0.08696655f, 0.12991554f, 0.72006977f, 
    0.22205308f, -0.34864798f, -0.70027930f, -0.52969366f, 0.26365364f, -0.11507171f, 0.33705905f, 0.18622062f, 
    0.17209813f, -0.31793514f, -0.21372770f, 0.30814359f, -0.01717147f, 0.33305007f, -0.03861819f, -0.02087556f, 
    -0.33776811f, -0.15287991f, 0.07369439f, -0.08929437f, -0.09441334f, 0.08050316f, 0.23836778f, 0.22110935f, 
    0.47601941f, -0.45343420f, -0.57241207f, -0.58094805f, -0.83760726f, 0.41995436f, 0.14625785f, 0.31138828f, 
    0.02092421f, 0.08948833f, 0.17583659f, 0.16813534f, 0.03677082f, 0.19494671f, -0.13243386f, -0.21068436f, 
    0.06523082f, -0.00192147f, -0.23397575f, 0.24887685f, -0.29195037f, -0.18379395f, 0.00236255f, 0.16267268f, 
    -0.24975011f, -0.03379572f, -0.41399565f, 0.39121553f, 0.16994676f, 0.16995977f, -0.21467078f, 0.19945142f, 
    -0.32721090f, -0.20485397f, 0.20694585f, -0.43012047f, 0.66067499f, -0.24479412f, -0.02882984f, -0.02771950f, 
    -0.40668923f, 0.16151443f, 0.13568799f, 0.01194159f, 0.21444860f, 0.33239561f, -0.27898973f, 0.05530481f, 
    -0.04615360f, -0.27959827f, -0.44086125f, 0.06362151f, -0.08371971f, 0.28625035f, 0.23923883f, 0.13039574f, 
    -0.33950150f, 0.07668552f, 0.13936485f, -0.28927103f, 0.17064747f, -0.00164785f, 0.15169299f, -0.01285027f, 
    0.06840690f, 0.01410178f, -0.08829843f, -0.09471727f, -0.00342793f, 0.15440504f, -0.19628346f, 0.20475675f, 
    0.22607352f, -0.04350128f, 0.05037184f, 0.16059938f, -0.19001769f, 0.35378522f, 0.09321938f, -0.17236714f, 
    -0.52048391f, -0.44370204f, -0.17264146f, -0.24087958f, -0.11108173f, 0.22296809f, -0.04660841f, 0.10599704f, 
    0.02483237f, 0.03847599f, 0.11982390f, 0.19879255f, -0.18639076f, -0.03286769f, -0.44006532f, 0.13250184f, 
    -0.04270235f, 0.14434271f, 0.30167803f, 0.19491951f, -1.03622472f, -0.63370448f, -0.46941605f, -0.03520898f, 
    0.01263633f, 0.38712224f, 0.03626426f, -0.06356216f, -0.18647920f, 0.08794258f, 0.41698703f, -0.20295712f, 
    0.01710316f, 0.43749389f, 0.46090022f, -0.12396103f, -0.00119416f, -0.18267368f, -0.15993240f, -0.08956746f, 
    0.36685786f, 0.26796168f, 0.16291840f, 0.27350697f, -0.24642047f, -1.08676648f, -0.41220385f, -0.25113589f, 
    -0.81321734f, -0.71468401f, 0.72122991f, 0.41255346f, 0.15497436f, 0.03265366f, 0.70845711f, -0.05991568f, 
    -0.01618113f, -0.17350303f, 0.00365869f, -0.09437080f, -0.02397159f, 0.20194747f, -0.09604856f, 0.01492727f, 
    0.08496955f, -0.00957899f, -0.04270314f, 0.17376702f, -0.03451585f, 0.08320206f, 0.33635238f, -0.20689340f, 
    -0.17363225f, 0.22133659f, -0.14170948f, 0.13737966f, 0.07759891f, 0.38571170f, -0.15302004f, 0.02346691f, 
    0.26501945f, 0.10804479f, -0.20749804f, 0.02480124f, -0.11759631f, 0.11996827f, 0.25586930f, -0.31888786f, 
    -0.15829848f, 0.09562720f, -0.05604694f, -0.10554057f, 0.03758353f, 0.18353805f, -0.04045407f, -0.24696185f, 
    -0.53276736f, -0.44257593f, -0.20372657f, -0.53603446f, -0.15576607f, -0.21176508f, -0.33347425f, -0.69488978f, 
    -0.62494797f, -0.10000578f, -0.04560864f, 0.21580933f, 0.23619135f, 0.07510376f, -0.01740854f, -0.11876842f, 
    0.29218182f, 0.09446434f, 0.04730726f, -0.07185657f, -0.12147262f, -0.11984814f, 0.14398457f, 0.23734513f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.42468333f, -0.25838375f, -0.04161730f, -0.03425130f, 0.14916286f, 0.23435183f, -0.03332519f, -0.04298594f, 
    0.32789826f, 0.34547028f, 0.13098267f, 0.19703160f, -0.09348264f, 0.43683404f, 0.34474757f, 0.28215289f, 
    0.05208917f, 0.27916986f, -0.11922367f, -0.13329808f, 0.27224195f, 0.15028240f, 0.16922913f, 0.14646414f, 
    0.37773210f, 0.03570774f, 0.40062508f, 0.17310493f, 0.11535136f, 0.18679321f, -0.21967100f, 0.08941977f, 
    0.27360693f, 0.20246373f, 0.20994022f, -0.36351326f, 0.13043012f, 0.06966462f, 0.17479195f, -0.02256150f, 
    0.18403667f, 0.31047934f, 0.28363311f, 0.04786797f, 0.11660548f, 0.19277757f, 0.23731655f, -0.08383502f, 
    -0.12798521f, -0.12841086f, -0.03708881f, -0.12300359f, -0.07767516f, -0.11307324f, -0.01394505f, 0.33644128f, 
    0.10201033f, 0.15177254f, -0.02011066f, 0.22263025f, 0.04366706f, 0.01781685f, 0.30727914f, -0.00768559f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.31202742f, 0.03960321f, -0.03180453f, -0.06342933f, 0.12798156f, 0.16530974f, -0.07528870f, -0.01973228f, 
    -0.04193093f, -0.00013518f, -0.01253868f, -0.02665525f, 0.19345102f, -0.06371060f, 0.15017451f, 0.07272258f, 
    0.05547134f, 0.11194181f, 0.17317663f, 0.02167599f, -0.07407230f, 0.03737521f, -0.04878593f, 0.05287580f, 
    -0.09668522f, 0.24799819f, 0.24874884f, 0.16975191f, -0.01612540f, 0.10539462f, -0.02563471f, 0.13078216f, 
    0.04792674f, 0.02989500f, 0.06711680f, -0.03286954f, 0.05220362f, -0.02847444f, 0.05009268f, -0.14747898f, 
    -0.02556707f, -0.08826881f, -0.02833587f, -0.08285793f, -0.09758044f, -0.09755664f, 0.06122933f, 0.16937362f, 
    -0.47803870f, -0.08816338f, 0.15775064f, -0.02581366f, -0.02798328f, -0.03609836f, -0.00033641f, -0.01543242f, 
    -0.01668359f, 0.06665733f, -0.03126041f, 0.03369734f, -0.33522996f, 0.22849207f, 0.37145424f, -0.48405862f, 
    0.00782716f, -0.01088246f, 0.04770430f, -0.02358515f, -0.00450717f, -0.11663777f, -0.01105949f, -0.03780137f, 
    0.20683014f, 0.03777202f, -0.07625337f, -0.05181183f, 0.00388064f, 0.00746372f, -0.07378131f, -0.14806493f, 
    0.11954596f, -0.11367971f, 0.01064688f, 0.10280913f, -0.04380381f, -0.03442283f, 0.13379185f, -0.11805950f, 
    0.01990573f, -0.02496624f, -0.05494980f, -0.07324304f, -0.00501483f, 0.00493075f, 0.01547109f, 0.10524926f, 
    0.18121473f, -0.02098224f, -0.09884452f, 0.02674509f, 0.03429297f, 0.05460074f, -0.03507723f, -0.19562945f, 
    -0.07843546f, 0.03627382f, 0.00291830f, -0.03460975f, 0.05757394f, 0.01979741f, -0.17668183f, -0.03807413f, 
    -0.03827489f, -0.14382301f, -0.02760863f, -0.16499303f, -0.09798252f, -0.09941044f, -0.00833036f, -0.10606679f, 
    -0.06825940f, -0.02332224f, -0.02357380f, -0.05530199f, -0.04717340f, 0.06659909f, 0.00608766f, -0.04283569f, 
    -0.18485071f, 0.03130674f, 0.01846593f, 0.00510498f, -0.05673299f, 0.12963308f, 0.04934831f, -0.33757380f, 
    0.03492433f, 0.07940668f, -0.17845640f, -0.02080631f, -0.03494382f, -0.01150389f, -0.01586360f, 0.01993074f, 
    -0.21393400f, -0.06549694f, -0.14619620f, 0.03144696f, 0.00068714f, 0.05403283f, 0.00000597f, -0.02675547f, 
    -0.03849902f, -0.01158137f, 0.02079746f, 0.01153989f, -0.87847757f, -0.66757607f, -0.31757373f, 0.16831370f, 
    0.00935040f, 0.00583484f, 0.01170928f, 0.02139047f, -0.02102279f, -0.03095348f, -0.06681062f, -0.08114567f, 
    -0.03123588f, -0.17616777f, -0.08326838f, -0.05825076f, -0.21952705f, 0.04994189f, -0.05165781f, -0.02158063f, 
    -0.10435916f, 0.03948736f, -0.00135993f, -0.08140994f, 0.10730147f, 0.12963530f, -0.53897035f, -0.02438234f, 
    0.05268321f, 0.02245879f, -0.09960204f, -0.20431338f, 0.10513261f, -0.00640256f, -0.31198519f, -0.02359189f, 
    -0.11727287f, -0.09797331f, -0.03461013f, 0.02104306f, 0.01474071f, 0.03102417f, -0.12873997f, 0.08371584f, 
    -0.10109062f, -0.05566847f, -0.08063813f, 0.12959124f, 0.14104211f, -0.11694119f, -0.15569821f, -0.03503827f, 
    -0.11225567f, -0.05847498f, -0.01723283f, 0.00602987f, -0.04334743f, 0.03708021f, -0.03449477f, -0.00466576f, 
    0.43679330f, -0.04276126f, -0.33794975f, -0.21387723f, -0.01979975f, 0.09660476f, 0.07810803f, 0.03961772f, 
    -0.03999145f, -0.08060294f, -0.01624372f, -0.08698740f, 0.14427854f, -0.14690229f, -0.07418689f, 0.04046944f, 
    0.02106798f, -0.14266506f, 0.10903114f, 0.02732444f, 0.00435513f, 0.07856163f, -0.02458993f, -0.12516335f, 
    0.00696819f, 0.04000793f, -0.22457938f, -0.00953710f, -0.02355594f, 0.04513703f, 0.03856578f, -0.11133112f, 
    -0.10144347f, -0.18468408f, -0.10374917f, -0.09539515f, -0.56511515f, -0.11693390f, 0.40846911f, -0.15201224f, 
    -0.22933115f, -0.02945133f, 0.03868587f, 0.00745515f, -0.09864226f, -0.15960446f, 0.02361073f, -0.10380301f, 
    0.26443404f, 0.17861842f, -0.23034583f, -0.01287493f, 0.06943042f, -0.03163558f, -0.06851150f, -0.03169498f, 
    -0.05459775f, 0.05794019f, -0.01546075f, -0.04473814f, 0.44736525f, 0.30003843f, 0.19153167f, -0.28767297f, 
    0.14605215f, 0.00371720f, 0.06593554f, 0.03189833f, 0.01855244f, -0.03027254f, -0.05904300f, -0.10379910f, 
    -0.15833636f, 0.02173326f, -0.20506321f, -0.10844920f, -0.02946492f, 0.06789471f, -0.00909040f, 0.01598952f, 
    -0.09898134f, -0.17062487f, 0.00531630f, -0.26202023f, -0.04332719f, 0.05237583f, -0.51595885f, 0.08576667f, 
    0.01667697f, -0.14251345f, -0.00813500f, 0.00236981f, -0.02143489f, 0.03455968f, 0.03768121f, 0.03442417f, 
    -0.21624541f, -0.02963315f, -0.35939518f, 0.05235149f, -0.01384562f, -0.02370485f, 0.01003488f, -0.07109205f, 
    -0.07153239f, -0.02547449f, -0.07665519f, 0.01178681f, -0.03162484f, -0.07312462f, 0.00961506f, 0.04875349f, 
    0.04152172f, 0.11114276f, 0.06951471f, -0.00322532f, -0.01286163f, -0.03423041f, -0.02549382f, 0.02749800f, 
    0.10769127f, -0.11691231f, 0.23832324f, -0.11516058f, 0.02589630f, 0.23773871f, 0.01506175f, -0.02048143f, 
    0.02812831f, -0.03453216f, -0.03215411f, 0.03494096f, -0.05729800f, -0.04652748f, -0.03278171f, -0.08826569f, 
    -0.03720915f, 0.03764295f, -0.07844964f, -0.06350489f, -0.00506423f, 0.04229598f, 0.03399686f, 0.05164897f, 
    0.07603039f, -0.03129605f, 0.03200546f, 0.04010708f, 0.19603555f, 0.06928259f, 0.09433908f, -0.13663694f, 
    -0.07674883f, 0.11537101f, 0.14900365f, 0.14925775f, -0.30005851f, -0.58065760f, -0.89794856f, 0.06159414f, 
    0.04818274f, 0.04148784f, -0.00300686f, 0.01239330f, 0.01628943f, 0.05492039f, -0.00013344f, 0.00460376f, 
    -0.01277448f, -0.20818934f, -0.03955000f, 0.01601762f, 0.06371681f, 0.10946362f, -0.05469820f, -0.08335841f, 
    -0.14727432f, -0.24000122f, -0.24224594f, -0.02788339f, 0.02744846f, 0.11672676f, -0.09424831f, -0.07088134f, 
    -0.07085750f, 0.03687481f, -0.15360418f, -0.16151240f, 0.00695693f, -0.08607507f, 0.02500657f, -0.08329754f, 
    0.23660997f, 0.19974235f, 0.01115867f, -0.11922787f, -0.13511673f, -0.08280580f, -0.02116514f, -0.29385546f, 
    -0.06371542f, -0.11571591f, -0.04121508f, 0.11276893f, 0.42478687f, 0.26701865f, 0.02824919f, -0.26938218f, 
    0.23260160f, 0.11291432f, 0.08690891f, 0.00770443f, -0.03095501f, -0.04636580f, -0.03200075f, -0.03789517f, 
    0.05299825f, 0.08015167f, 0.09952330f, -0.02658633f, -0.02220460f, 0.01191833f, 0.05025671f, -0.03470723f, 
    -0.27503464f, -0.23586459f, 0.08221442f, -0.01069883f, -0.00116172f, -0.00187025f, -0.09170889f, 0.04381189f, 
    -0.03822352f, -0.00120657f, -0.02234931f, 0.03393251f, -0.09576361f, -0.10508887f, -0.00759409f, -0.14739721f, 
    -0.25081864f, -0.25536275f, 0.11749933f, 0.04215046f, 0.04643149f, 0.04908352f, -0.01988839f, -0.10473029f, 
    0.03413852f, -0.07562008f, -0.00897889f, 0.03407558f, 0.20422763f, 0.06286137f, -0.12972146f, -0.17222589f, 
    0.06315267f, -0.10011900f, -0.07454427f, -0.03955563f, 0.02400227f, 0.03848688f, -0.01628473f, -0.06567640f, 
    -0.56541371f, -0.32585603f, -0.18222296f, 0.40139523f, 0.09740068f, -0.02857349f, 0.00450823f, 0.05059415f, 
    0.01509554f, -0.01630174f, 0.00241426f, 0.09216282f, 0.01271147f, -0.19167750f, -0.28349990f, 0.09922893f, 
    -0.07097044f, -0.29125923f, 0.04705835f, -0.09111381f, -0.14966251f, 0.03534735f, 0.03700677f, 0.07597284f, 
    0.10397333f, -0.25389984f, -0.11763114f, -0.04831943f, 0.01949801f, 0.01756537f, -0.00831551f, 0.01604032f, 
    -0.00215280f, -0.14525849f, -0.07185332f, -0.10983470f, -0.10438271f, -0.02950255f, 0.02345811f, 0.03914907f, 
    0.00751870f, 0.00978659f, -0.04556261f, -0.00441712f, -0.04625304f, 0.04126017f, -0.07121689f, 0.01776534f, 
    -0.08806527f, -0.17568639f, 0.04781215f, 0.05946985f, -0.05796485f, 0.02998153f, -0.02430319f, -0.01057649f, 
    -0.02712135f, -0.04276254f, -0.00010766f, 0.03299820f, -0.23494196f, -0.16698490f, 0.04755408f, 0.08516038f, 
    0.05767910f, 0.03774163f, 0.02852246f, -0.01979370f, -0.10329898f, -0.00605170f, -0.02714915f, 0.03386983f, 
    -0.24003351f, 0.01959928f, 0.11741998f, -0.09034277f, 0.06522942f, 0.00659438f, 0.03521833f, -0.01123403f, 
    0.02053598f, -0.06606848f, -0.00541340f, 0.04459774f, 0.26827246f, 0.18464093f, -0.06819517f, -0.25510126f, 
    0.03570442f, 0.12251426f, 0.11030774f, 0.08753825f, -0.01152134f, -0.06461070f, 0.01520005f, -0.00751500f, 
    0.21922667f, 0.29767898f, -0.04551281f, -0.16068412f, -0.09961491f, -0.03215444f, -0.03500299f, -0.03028326f, 
    0.10374884f, 0.29447049f, -0.07324006f, 0.04270457f, 0.09475923f, -0.06237422f, 0.00252584f, -0.04697286f, 
    0.19682355f, 0.01155560f, 0.07061611f, 0.02055930f, -0.15350848f, -0.12436625f, -0.13214569f, -0.08460897f, 
    -0.35897955f, -0.28647774f, -0.10683537f, 0.00218427f, 0.00350981f, 0.00759683f, -0.01603035f, 0.06487294f, 
    0.04580458f, -0.01007575f, 0.10009849f, 0.12131914f, -0.01999040f, -0.03852054f, -0.10465212f, 0.05430818f, 
    0.03704479f, -0.06400958f, 0.02419531f, 0.07171326f, -0.11773445f, 0.02260285f, -0.00083790f, -0.03637800f, 
    0.38040769f, 0.02444205f, -0.06263282f, -0.05466639f, -0.00328131f, -0.02296112f, 0.09010088f, -0.04476295f, 
    0.05963079f, 0.03658848f, -0.11586323f, 0.07360398f, 0.12194871f, 0.03077953f, -0.02223854f, -0.05347085f, 
    0.00653368f, 0.19350201f, -0.00446204f, 0.12247351f, -0.03584864f, -0.01626065f, -0.06574613f, 0.09410109f, 
    -0.05354962f, -0.06580462f, -0.03867233f, 0.00209673f, 0.02112276f, 0.04585708f, 0.04799759f, 0.04729101f, 
    -0.01463305f, -0.02737824f, -0.01198470f, 0.07017324f, -0.03670695f, -0.24463208f, -0.12906504f, 0.01129729f, 
    0.01250776f, -0.04277451f, -0.06380200f, -0.19419228f, 0.01620870f, -0.20623307f, -0.07217756f, 0.03084623f, 
    0.26601797f, -0.15195353f, -0.17738049f, 0.06308417f, 0.09410349f, 0.04457468f, -0.04281415f, -0.03569343f, 
    0.02538483f, 0.01750308f, 0.01427265f, -0.01185407f, -0.04612210f, 0.04449783f, 0.08304137f, -0.11545619f, 
    0.02942283f, -0.14215776f, -0.00244849f, -0.03020020f, -0.05241414f, -0.03165504f, -0.02019945f, -0.08494740f, 
    0.05967321f, 0.02994311f, 0.10639145f, -0.02549846f, -0.05976199f, 0.05547471f, -0.00258150f, -0.01831103f, 
    -0.04430212f, -0.08245281f, 0.03532695f, -0.10160533f, 0.10900632f, 0.13538323f, 0.02794598f, -0.23337571f, 
    -0.02086012f, 0.10338094f, -0.05974241f, -0.04961135f, -0.01610726f, -0.05626188f, -0.05221732f, -0.00082449f, 
    0.20790701f, 0.18004251f, 0.00905489f, -0.08172777f, 0.05320906f, 0.12840395f, -0.07221626f, -0.17620714f, 
    -0.12649006f, -0.05131388f, -0.02956005f, -0.05675763f, 0.06104706f, -0.19227077f, -0.04171118f, -0.05588910f, 
    0.12843448f, 0.24199213f, -0.05207744f, 0.09737027f, -0.00719888f, 0.08188586f, 0.01188271f, -0.02232442f, 
    -0.11573991f, -0.08427485f, -0.06428816f, -0.00063825f, -0.09711057f, -0.01430227f, -0.00152103f, -0.02236820f, 
    -0.09677816f, -0.15056022f, -0.31247342f, -0.10591471f, 0.32809874f, 0.07061617f, -0.18036072f, -0.11416806f, 
    0.09894498f, 0.01873877f, -0.02290777f, -0.01096076f, 0.01527953f, -0.02981204f, -0.00907709f, 0.03550709f, 
    0.01459889f, 0.05190463f, 0.39239931f, -0.11898627f, 0.06371799f, 0.03948390f, 0.04165766f, 0.00254597f, 
    -0.02112330f, -0.00051070f, 0.02921923f, -0.06964773f, 0.05517177f, 0.08700779f, -0.05579416f, 0.23780718f, 
    0.23373713f, -0.02814147f, -0.17690642f, -0.40903264f, 0.03648078f, -0.02625882f, -0.07879530f, -0.07667361f, 
    -0.37791395f, 0.09183148f, 0.13813274f, -0.24755807f, 0.06480035f, 0.01297827f, -0.23845607f, -0.24430469f, 
    -0.05597095f, -0.00713537f, -0.04924790f, 0.00260841f, 0.09894509f, -0.06437359f, -0.03748255f, -0.26536039f, 
    -0.01557975f, -0.00909975f, 0.00377641f, -0.05513212f, -0.03277604f, -0.18344766f, -0.30974466f, -0.56326467f, 
    -0.00305261f, 0.19355597f, 0.05526161f, 0.08435318f, 0.01882365f, 0.00414202f, 0.00472198f, 0.03179969f, 
    -0.04777275f, 0.21116294f, -0.01206116f, -0.07292918f, -0.25231981f, 0.23988718f, -0.12518191f, -0.21108313f, 
    -0.06440131f, 0.06427679f, -0.04074727f, -0.11910351f, 0.07915021f, 0.00308167f, 0.09785822f, -0.08268683f, 
    0.15085658f, 0.16223696f, 0.17206690f, 0.09603617f, 0.09711826f, 0.02104423f, 0.03053333f, -0.03791022f, 
    -0.18574548f, -0.00603470f, 0.00073629f, -0.32812744f, -0.44352379f, 0.01089901f, -0.14201291f, -0.17911401f, 
    0.11103709f, 0.08228415f, -0.02626481f, -0.10674795f, -0.12392263f, -0.08085964f, -0.00659626f, -0.04582952f, 
    0.21009398f, -0.28434226f, -0.21371131f, -0.18303721f, 0.01998423f, 0.07941010f, -0.06445801f, -0.06114337f, 
    0.21522960f, 0.15299143f, -0.11847508f, -0.02829197f, -0.00911698f, -0.07913524f, -0.02009792f, 0.04396023f, 
    0.08402100f, 0.04506392f, 0.03483641f, -0.05286412f, 0.08164972f, 0.00782586f, -0.01675005f, -0.02080260f, 
    0.36399749f, -0.02086949f, 0.00928152f, 0.02854069f, -0.08859209f, -0.07912805f, 0.02952112f, -0.07775169f, 
    0.16526760f, 0.00757896f, -0.01800131f, 0.02550386f, 0.15109371f, 0.08547806f, -0.08520941f, -0.26207408f, 
    -0.02082441f, -0.11728989f, -0.09958094f, -0.15877028f, -0.05757837f, -0.04962578f, -0.00388950f, -0.00876641f, 
    0.07203178f, 0.02216423f, 0.17715679f, 0.06235632f, -0.01435271f, -0.01181008f, 0.02106908f, -0.03291002f, 
    -0.07180341f, 0.06811285f, -0.06952009f, 0.13892540f, 0.31681362f, 0.07738546f, 0.43396398f, 0.00583676f, 
    0.01822991f, -0.05327286f, 0.01555945f, 0.02143729f, -0.04263391f, 0.08386537f, -0.01950246f, -0.10600008f, 
    0.22762902f, -0.21675891f, 0.05197001f, -0.00695159f, 0.16586718f, -0.08879227f, 0.13000639f, -0.01274858f, 
    0.26602432f, -0.01685255f, -0.15895484f, -0.13330346f, 0.83942711f, 0.04135064f, -0.25624585f, -0.22608490f, 
    -0.08722504f, -0.09149900f, -0.06755025f, -0.04233063f, 0.05454532f, -0.11440973f, 0.00651088f, 0.02906528f, 
    -0.01232504f, -0.10964426f, 0.12394010f, -0.15577663f, -0.00983159f, 0.00436976f, -0.13693905f, 0.07574229f, 
    -0.28789297f, -0.26325947f, -0.43764633f, -0.25553891f, -0.08675040f, -0.15495169f, 0.02635521f, -0.34819323f, 
    0.03472960f, -0.10123629f, -0.00590376f, 0.13083826f, 0.01437846f, 0.18832599f, -0.03971623f, 0.24858496f, 
    0.29764447f, -0.12057513f, 0.53399110f, -0.02722605f, 0.12708473f, -0.12461157f, 0.33204296f, -0.06227565f, 
    0.11373911f, -0.03193346f, 0.02966655f, -0.06249635f, 0.44801256f, -0.13238145f, -0.05840193f, -0.19223458f, 
    -0.07205070f, -0.02519760f, -0.33310932f, -0.07353686f, -0.04426176f, -0.08786792f, -0.05965689f, 0.04330377f, 
    -0.14690270f, -0.31953591f, 0.05911142f, 0.06415297f, 0.04262325f, 0.03353497f, 0.12587185f, -0.03976300f, 
    0.15983796f, -0.06610312f, 0.06825154f, -0.13872682f, -0.26079643f, 0.27279407f, 0.03672283f, -0.13160770f, 
    0.02259903f, -0.02918878f, 0.06432126f, 0.06885260f, 0.06816264f, 0.02136381f, 0.01010013f, 0.07784885f, 
    -0.02159313f, -0.19286789f, -0.08871928f, 0.08528898f, -0.00555496f, 0.07457773f, -0.04138604f, 0.08369735f, 
    -0.01828367f, -0.05235692f, -0.03432458f, 0.09983385f, -0.49542913f, 0.03355791f, -0.23786137f, -0.10588249f, 
    -0.07647672f, -0.21779345f, 0.14815396f, 0.11287562f, 0.01582622f, -0.04917061f, -0.07870614f, -0.03141535f, 
    0.04300774f, 0.07288970f, 0.01583908f, 0.03345273f, 0.02133641f, 0.02469768f, -0.04482169f, -0.01606723f, 
    0.09727795f, 0.11095341f, -0.08192605f, 0.07637613f, 0.02747666f, 0.09925536f, -0.01268121f, -0.04768662f, 
    -0.00763130f, -0.20535673f, 0.01339327f, -0.01532528f, -0.07064471f, 0.03442657f, -0.00793929f, 0.04080009f, 
    0.09686175f, -0.01114452f, 0.09098607f, 0.13041104f, -0.00815356f, 0.03548933f, 0.02241698f, -0.00868236f, 
    0.03336554f, -0.09552359f, 0.01327285f, 0.05627244f, -0.14124261f, -0.31364453f, -0.04108382f, -0.06668077f, 
    -0.03658554f, 0.00085879f, 0.02638727f, -0.04935178f, 0.03669542f, -0.01179988f, 0.00992230f, -0.01848606f, 
    -0.44200933f, 0.09534720f, -0.01040306f, -0.15022212f, 0.07853580f, 0.04572239f, -0.23634218f, 0.17469475f, 
    -0.19412489f, 0.00147804f, 0.01521197f, -0.08410920f, 0.07122041f, -0.04053483f, 0.03176962f, -0.22511180f, 
    -0.26762533f, -0.09226060f, -0.06380497f, -0.13156633f, -0.01831446f, 0.00312996f, 0.00041654f, -0.00756809f, 
    -0.04181008f, -0.00059444f, -0.01558207f, 0.00705403f, -0.05808676f, -0.12573880f, -0.10129605f, -0.05155556f, 
    0.16591284f, -0.11654656f, 0.02072432f, -0.16188292f, 0.58521754f, 0.04499858f, 0.17659701f, 0.18672146f, 
    -0.01243201f, -0.05699994f, -0.04704537f, 0.01601273f, -0.09169961f, -0.08522701f, -0.07036185f, 0.04863423f, 
    -0.13369700f, -0.22704563f, -0.04416705f, -0.19438444f, -0.00288817f, 0.01518835f, 0.08677348f, 0.15762047f, 
    0.03072273f, 0.09974336f, -0.01146336f, 0.03070278f, -0.04501893f, 0.01596641f, -0.05885619f, -0.01150428f, 
    0.10270327f, -0.00467803f, -0.04098310f, 0.08512275f, -0.08839627f, 0.05813134f, -0.12224445f, 0.03449011f, 
    -0.16480725f, -0.07200726f, -0.14335774f, 0.06696621f, 0.13651499f, 0.06367701f, 0.04191021f, -0.05149984f, 
    0.00977447f, -0.08478507f, 0.23059568f, -0.30771780f, 0.14442831f, 0.15155211f, 0.09631067f, 0.21918179f, 
    -0.08399931f, -0.12831885f, -0.08081139f, -0.02843794f, 0.00538902f, -0.02350618f, -0.01538840f, -0.00836459f, 
    0.01747553f, -0.07377812f, 0.00696403f, 0.22645769f, 0.00907425f, -0.03878016f, 0.01995838f, 0.00384344f, 
    0.06164986f, 0.03253266f, -0.01359271f, 0.11157335f, 0.12330098f, -0.11387726f, 0.08596837f, -0.05971845f, 
    -0.00659966f, -0.05830869f, 0.03219227f, 0.01553197f, 0.16311248f, 0.06086606f, -0.24812296f, -0.09696756f, 
    -0.18464153f, -0.20827667f, 0.12831579f, -0.10562237f, -0.00129187f, -0.02949219f, -0.02578381f, -0.18429318f, 
    -0.09889675f, -0.06779740f, -0.08180652f, 0.02192394f, 0.04159998f, -0.10935155f, 0.05720054f, -0.07454167f, 
    -0.29654780f, -0.11227020f, -0.08172411f, 0.03963142f, -0.04658522f, -0.00159750f, -0.04650475f, 0.08500912f, 
    0.48795149f, 0.29648232f, 0.10678066f, 0.26623321f, -0.01098110f, -0.01654848f, -0.03228364f, 0.01026016f, 
    0.00117279f, 0.00787149f, 0.01418234f, -0.03850767f, 0.39763752f, -0.12949727f, -0.08450103f, -0.07602752f, 
    -0.13374677f, -0.06712628f, 0.06654842f, 0.05790769f, -0.12777823f, 0.03288030f, 0.06947556f, 0.07074723f, 
    0.27359056f, -0.09002849f, 0.08497971f, -0.03925088f, -0.05232937f, 0.03427454f, 0.01911282f, 0.04405938f, 
    -0.02487445f, -0.00918756f, -0.02650024f, 0.10800760f, 0.10912608f, 0.06846982f, 0.06542354f, 0.10944013f, 
    0.01593190f, -0.02861167f, -0.04706037f, 0.05438071f, -0.02601067f, 0.04343574f, -0.03374049f, 0.04896308f, 
    0.07115299f, 0.08435646f, 0.02009226f, -0.16553837f, -0.10661683f, -0.00407386f, 0.05061679f, -0.01152050f, 
    -0.03622491f, -0.03823343f, 0.06611820f, -0.10427339f, 0.01691519f, 0.09096936f, -0.02401708f, -0.13165705f, 
    -0.00120834f, -0.06370140f, 0.02580710f, 0.06444526f, -0.02172980f, -0.01356983f, 0.06446978f, -0.03144037f, 
    -0.45971879f, 0.37421715f, 0.24392070f, -0.01029765f, -0.04515258f, 0.02244939f, 0.00056697f, -0.10952456f, 
    -0.00473269f, 0.00512268f, -0.02089608f, 0.12284896f, -0.08256757f, 0.05235249f, 0.20268080f, 0.23136787f, 
    -0.13859607f, 0.05032555f, -0.10210043f, 0.15969534f, -0.03479774f, -0.04903777f, -0.00018824f, 0.00169795f, 
    -0.23189038f, -0.03982048f, -0.15322074f, -0.08569393f, -0.04849356f, 0.03143606f, 0.11411124f, 0.14735292f, 
    0.01559158f, -0.24571125f, -0.07682160f, 0.11051560f, -0.02426503f, 0.16815795f, -0.35987774f, -0.24991798f, 
    0.10212871f, 0.10085366f, 0.05825512f, 0.06049452f, -0.01019822f, 0.11718745f, -0.08036505f, 0.11121985f, 
    0.15102753f, 0.13666248f, 0.10827297f, 0.08371528f, 0.00396772f, -0.02767449f, -0.03422411f, 0.01382841f, 
    -0.25434685f, 0.04532011f, 0.22040713f, -0.12490768f, 0.09447177f, 0.00112996f, -0.00308546f, 0.06124401f, 
    -0.01811585f, -0.02062883f, -0.06762823f, 0.06724419f, -0.01632220f, 0.12658088f, -0.07053064f, -0.07823592f, 
    0.23362029f, -0.08661943f, 0.00308661f, -0.24593107f, -0.03573685f, 0.02167066f, -0.01967446f, 0.00214978f, 
    0.14343280f, 0.02185694f, -0.26035035f, -0.10330080f, -0.01849289f, 0.04455864f, 0.11675593f, 0.10347469f, 
    -0.05530948f, 0.09326764f, -0.11271457f, 0.08809001f, 0.00946275f, 0.00589547f, 0.15052243f, -0.04335917f, 
    0.06932686f, 0.07603367f, 0.11672566f, 0.04892887f, -0.02157782f, -0.02471235f, 0.03498111f, -0.02287311f, 
    0.01995511f, -0.04924215f, 0.02590686f, 0.06499489f, 0.40724078f, -0.16455974f, 0.03910968f, 0.01301363f, 
    -0.04420676f, 0.06034821f, 0.12387051f, 0.02820623f, -0.01873602f, 0.15136316f, -0.04582306f, -0.26816803f, 
    0.24700247f, -0.09224632f, -0.05817396f, -0.13523093f, -0.03749377f, 0.00316118f, 0.03213419f, -0.09620523f, 
    0.17565130f, 0.00209120f, 0.00371369f, -0.08756703f, -0.07270878f, 0.25647593f, 0.01768498f, -0.13770846f, 
    -0.09108488f, 0.01457616f, 0.04059689f, 0.02189071f, 0.17070979f, -0.08177749f, 0.02997532f, -0.01864873f, 
    -0.02498258f, -0.01337314f, 0.01823451f, 0.00276381f, -0.00542929f, 0.00740325f, -0.00196168f, 0.01689038f, 
    -0.16470148f, 0.07576990f, 0.01604884f, -0.03600243f, -0.12363114f, 0.04406116f, -0.10381918f, -0.07578315f, 
    0.00483309f, -0.08642404f, 0.07148308f, 0.11338437f, -0.04943453f, -0.05815642f, 0.06775749f, 0.04952965f, 
    -0.39616561f, -0.03567969f, 0.22648415f, 0.00375409f, -0.03631833f, 0.08821251f, 0.12111229f, 0.07225692f, 
    -0.16884591f, -0.06024912f, 0.17110439f, -0.03023732f, 0.38156003f, 0.10270260f, -0.18265377f, -0.15608293f, 
    0.00232484f, -0.04807484f, -0.17888653f, -0.23680018f, -0.09930140f, -0.07092243f, 0.00324185f, -0.09409926f, 
    0.18602073f, -0.01433483f, 0.01317317f, 0.06862017f, -0.07101686f, -0.02989993f, 0.07446902f, -0.03722406f, 
    0.06467563f, 0.05875099f, 0.06712027f, 0.15002500f, -0.08986215f, -0.01675029f, 0.25589359f, 0.07802218f, 
    0.02192198f, 0.04554141f, 0.02758959f, -0.09281013f, 0.03933144f, -0.02219162f, -0.02076440f, 0.00135806f, 
    -0.71914589f, -0.27166447f, 0.12186040f, -0.43443644f, -0.04814939f, 0.01447960f, 0.07153906f, -0.36075753f, 
    -0.01467973f, -0.02487777f, -0.03587712f, -0.02279582f, -0.17973240f, -0.06555472f, 0.26074150f, 0.01693064f, 
    0.19588432f, -0.04081581f, 0.05861164f, 0.07653455f, 0.06438700f, 0.02189772f, 0.04337696f, -0.01840444f, 
    -0.05770605f, 0.14526559f, -0.00541113f, 0.01384987f, 0.04393259f, -0.08844192f, -0.06391940f, -0.09561840f, 
    -0.04974088f, 0.03233023f, 0.02015143f, -0.04892837f, -0.22148815f, 0.33349511f, -0.02359757f, -0.20970283f, 
    -0.04750076f, -0.00494756f, 0.03309168f, -0.03325699f, -0.01836056f, 0.03009046f, 0.08380198f, 0.16917425f, 
    -0.07829811f, 0.07061464f, -0.10909479f, 0.04259337f, 0.02271972f, -0.00160991f, 0.04801741f, -0.00019987f, 
    0.04527567f, -0.02191919f, 0.02614355f, 0.19995707f, -0.35499904f, 0.22026847f, -0.14770898f, 0.09185677f, 
    -0.05386724f, 0.01735867f, 0.03272360f, 0.03455369f, -0.05668692f, 0.06526443f, 0.00438328f, -0.03378309f, 
    -0.14359570f, 0.06851432f, 0.43295729f, 0.08590093f, -0.03456330f, 0.03012561f, 0.07205654f, 0.02073406f, 
    0.06943759f, 0.02716703f, 0.12174198f, 0.00100128f, 0.24170457f, 0.26436892f, -0.09953228f, 0.22457372f, 
    -0.06072154f, 0.05383994f, 0.04740564f, -0.17450041f, 0.01999115f, 0.07509468f, -0.08147278f, 0.23525544f, 
    0.13326548f, 0.09678541f, 0.10141601f, 0.09141986f, -0.02587912f, 0.05013868f, -0.03154365f, -0.15227215f, 
    -0.05154025f, 0.06225168f, -0.09372304f, 0.11382800f, 0.14458428f, -0.00436250f, -0.00199984f, -0.09935351f, 
    0.05857410f, 0.05758329f, -0.03965247f, 0.17401533f, 0.12291786f, 0.09107860f, 0.07107143f, -0.15613531f, 
    -0.17584150f, 0.15363403f, -0.08586801f, -0.08414650f, -0.04910334f, -0.02418389f, -0.02995273f, -0.01493164f, 
    0.03310062f, 0.01481286f, -0.22753268f, 0.12236195f, -0.53438991f, 0.08538376f, 0.20055071f, 0.02141317f, 
    -0.08339017f, 0.00823591f, -0.14050977f, -0.01768312f, 0.03261623f, -0.00633609f, 0.06463321f, -0.01199008f, 
    -0.22156124f, -0.01540257f, -0.23077266f, -0.04106777f, -0.08771672f, -0.08276764f, 0.03237509f, 0.08426257f, 
    0.04508378f, -0.06126929f, 0.05278513f, -0.12320276f, 0.24413231f, -0.13442264f, 0.21151966f, -0.10396127f, 
    -0.04960933f, 0.01618943f, -0.01162268f, -0.00627811f, 0.00287684f, -0.06935060f, 0.04954508f, 0.00887168f, 
    0.01789836f, -0.00026983f, 0.07860955f, -0.29767117f, 0.11000256f, 0.00082475f, 0.00543450f, -0.02641950f, 
    -0.14084448f, 0.07520453f, 0.15382211f, 0.09317924f, -0.37010765f, 0.27111864f, 0.23606420f, -0.10311922f, 
    -0.02361033f, -0.09275857f, -0.16859241f, -0.09803057f, -0.05149614f, 0.11196209f, 0.00789570f, -0.02918977f, 
    -0.03252270f, -0.05720855f, 0.09595802f, -0.10757425f, 0.00656449f, 0.00708445f, 0.02135741f, -0.14845118f, 
    0.21897015f, 0.25673389f, 0.03682561f, 0.22063638f, -0.12506653f, -0.09926667f, 0.20360820f, -0.18282411f, 
    0.01041821f, -0.15159482f, -0.09802625f, -0.18746842f, 0.10515299f, -0.12812142f, 0.05370890f, 0.06163286f, 
    -0.14785488f, -0.19291620f, 0.66156983f, 0.20455192f, 0.03453223f, -0.11542293f, 0.05421237f, 0.10800128f, 
    -0.01045133f, -0.04858271f, 0.03396549f, -0.10862464f, -0.21757410f, -0.02197404f, -0.02624150f, -0.19331977f, 
    -0.01386262f, 0.03813205f, -0.19495314f, -0.29350880f, 0.08254793f, 0.02140579f, -0.04043203f, 0.00515544f, 
    0.06081924f, -0.28210399f, 0.15458441f, 0.11127137f, 0.03811383f, -0.04929421f, 0.01554878f, 0.08806317f, 
    -0.00029647f, -0.12511778f, 0.01496840f, -0.01231271f, 0.29985917f, 0.30327907f, -0.37099120f, 0.02441268f, 
    0.16386785f, 0.14399891f, -0.08935052f, 0.04749911f, 0.09064796f, -0.03067688f, 0.00593200f, -0.00556564f, 
    -0.04976209f, -0.02718424f, 0.03323981f, 0.06358858f, -0.00780944f, -0.10336557f, 0.04900394f, 0.10999334f, 
    0.07501698f, 0.04668413f, 0.03964494f, 0.08774372f, -0.23741214f, -0.09633245f, -0.38733470f, 0.07583839f, 
    0.00460949f, -0.09974649f, -0.09487405f, 0.19218236f, 0.02375268f, 0.03035855f, -0.08007719f, 0.00781442f, 
    -0.04807674f, 0.02217988f, -0.06481478f, 0.04883735f, 0.05165442f, 0.01579804f, 0.00001531f, -0.04021254f, 
    0.12828624f, -0.04332804f, 0.02526004f, -0.02879388f, -0.07171354f, 0.08977829f, 0.05362483f, -0.29839668f, 
    0.00467070f, -0.10197306f, -0.08495699f, 0.12326295f, 0.01183022f, -0.02664847f, 0.02361732f, -0.04556006f, 
    0.10247693f, -0.11480279f, 0.03857708f, -0.15489943f, 0.01099492f, 0.01155937f, 0.00588292f, 0.05790416f, 
    0.00179038f, -0.05368644f, 0.08416452f, -0.24209909f, -0.09765571f, 0.11673592f, 0.14346965f, 0.11395667f, 
    -0.06445737f, 0.02967269f, 0.03081978f, 0.02897809f, -0.09579787f, 0.06152141f, 0.00184092f, 0.01258803f, 
    0.60281473f, 0.45555162f, 0.07912183f, 0.36192623f, -0.01513106f, 0.05188328f, -0.14846657f, 0.06491220f, 
    -0.05561978f, -0.00711612f, 0.05722500f, 0.05887514f, -0.22029771f, -0.02255875f, 0.18002914f, -0.54989994f, 
    -0.06130134f, -0.17424624f, -0.36684686f, -0.13892402f, -0.00799902f, 0.00930250f, -0.02354995f, 0.03276861f, 
    -0.01573443f, -0.02129001f, -0.00790469f, 0.00014656f, -0.08655832f, -0.10646392f, 0.07649479f, -0.03984759f, 
    0.01216254f, 0.09845479f, 0.07923961f, -0.04937785f, -0.24149506f, -0.05254506f, 0.02859437f, -0.41543716f, 
    -0.02632415f, -0.03337925f, -0.12385081f, 0.04692716f, 0.07670562f, 0.00884942f, -0.06764692f, 0.07434112f, 
    0.22349922f, 0.08212785f, 0.08065230f, -0.00541896f, 0.03099487f, 0.07149005f, -0.07390760f, 0.06620565f, 
    0.02169573f, -0.10467447f, -0.19482268f, -0.02506023f, -0.06456674f, 0.01117541f, -0.13335039f, 0.01995486f, 
    -0.00711974f, 0.06325387f, -0.16258338f, 0.02787542f, 0.04081763f, -0.04200684f, 0.05063745f, -0.00085069f, 
    0.00919011f, -0.10399933f, 0.14018455f, 0.09613284f, -0.06567653f, 0.00761321f, -0.07655850f, -0.03348308f, 
    -0.11777164f, 0.00149805f, -0.13362463f, 0.01083956f, -0.58632714f, -0.42850298f, -0.10439440f, 0.08897635f, 
    -0.11618953f, -0.08382108f, -0.05574362f, 0.12561275f, 0.03578648f, -0.04932466f, 0.02258090f, -0.02219014f, 
    0.00255729f, -0.01888615f, -0.18245102f, -0.04012671f, -0.01303814f, -0.06723458f, 0.04037695f, 0.10414004f, 
    -0.03391746f, -0.01252476f, 0.01887924f, -0.05294404f, -0.06087231f, 0.04166811f, -0.08474438f, 0.02325564f, 
    -0.03391606f, 0.06377625f, 0.02008859f, -0.01603034f, 0.02055413f, -0.01915931f, -0.04165007f, -0.00497621f, 
    0.01649359f, 0.18971273f, -0.09468064f, 0.21432018f, 0.02222531f, 0.01756748f, 0.18530358f, 0.09935208f, 
    -0.01776914f, 0.10950812f, 0.01598257f, 0.06818437f, -0.69213885f, -0.19786431f, 0.08135901f, -0.28380388f, 
    0.09968630f, 0.13006751f, -0.00484104f, -0.29507372f, -0.01734512f, -0.04583979f, -0.02556204f, -0.03292201f, 
    -0.11600544f, -0.12870647f, 0.23256706f, -0.36390957f, 0.01155642f, -0.02366638f, -0.01197362f, 0.05620233f, 
    -0.01077077f, -0.04126593f, 0.01092924f, -0.03448592f, -0.24988289f, 0.08169354f, -0.17848447f, -0.31844372f, 
    0.05260415f, -0.00981173f, -0.03049155f, 0.19130306f, 0.03784568f, 0.00804683f, 0.04611076f, -0.05628939f, 
    -0.02356300f, -0.11568084f, 0.30971748f, -0.23266098f, 0.07870536f, -0.06569206f, -0.12897603f, 0.12324584f, 
    -0.00578909f, 0.01510211f, 0.18475233f, -0.12471621f, -0.13644141f, -0.07596004f, 0.02522036f, 0.06274205f, 
    -0.02919000f, -0.01261836f, 0.01406265f, -0.05057388f, -0.03582011f, -0.01604824f, -0.04519795f, 0.09042361f, 
    -0.19589941f, -0.02534217f, 0.05568186f, -0.14520374f, 0.09080112f, 0.08567961f, -0.04082345f, 0.04034235f, 
    -0.02614926f, -0.06436066f, 0.04133247f, -0.01566926f, -0.04216959f, 0.06445819f, 0.05653686f, -0.24979651f, 
    0.00494748f, -0.05611954f, -0.10375134f, 0.09581485f, 0.03882750f, 0.02875267f, -0.07051680f, 0.08138498f, 
    -0.15867628f, 0.23126593f, -0.16932733f, 0.05069616f, -0.00431301f, 0.12115185f, -0.02049051f, -0.04996214f, 
    -0.00159286f, -0.04053845f, 0.09611997f, -0.05829522f, -0.25015363f, -0.33836532f, -0.32498720f, -0.25409740f, 
    0.12369244f, 0.07914063f, -0.02088173f, 0.07212184f, 0.02222055f, -0.01909980f, 0.03434594f, 0.04281126f, 
    -0.10444710f, -0.15197568f, -0.10233827f, 0.00385670f, -0.01505282f, -0.14728272f, -0.22603205f, -0.10661078f, 
    -0.00599580f, -0.21928798f, 0.05894320f, 0.04831107f, -0.08810807f, -0.33441505f, -0.06888070f, -0.18875992f, 
    0.16567451f, -0.10297523f, -0.10145752f, 0.00045131f, -0.01088394f, -0.16735370f, -0.15102923f, 0.08549622f, 
    -0.06718025f, -0.04201042f, -0.15438575f, -0.01436968f, -0.02833059f, -0.04223852f, 0.03472164f, 0.01745753f, 
    0.13004370f, -0.01050242f, 0.08498723f, -0.07794166f, -0.17256239f, 0.12828524f, -0.00947464f, 0.04419864f, 
    0.01248622f, 0.03220135f, -0.00632144f, 0.04641557f, -0.01680403f, 0.02162113f, -0.09744209f, 0.09795020f, 
    -0.16047767f, 0.02477933f, 0.39677897f, 0.10164180f, 0.03545227f, -0.01977656f, -0.06960700f, -0.05764940f, 
    0.00641540f, -0.06619315f, -0.02517079f, -0.07619148f, 0.12194403f, 0.10398069f, -0.01033614f, 0.14019582f, 
    -0.08532882f, 0.02763590f, 0.01678368f, -0.04589229f, -0.00519408f, -0.06693222f, 0.10697460f, -0.00029838f, 
    -0.16979946f, 0.04664860f, -0.04143623f, 0.03001406f, -0.06885117f, -0.02823042f, 0.01321986f, 0.00105376f, 
    0.01121540f, -0.04584406f, -0.01216667f, -0.00183219f, -0.27902421f, 0.20224473f, -0.04311797f, -0.04967009f, 
    -0.07539982f, 0.09992967f, 0.00330886f, -0.09921194f, -0.14003833f, 0.03759899f, -0.15543734f, -0.06028645f, 
    -0.06413946f, 0.21455716f, 0.17875679f, 0.07574369f, -0.06980583f, -0.04669023f, 0.13058424f, -0.06020224f, 
    -0.01057010f, 0.04001786f, -0.07489458f, 0.05517340f, 0.19084890f, 0.04575527f, -0.11510034f, -0.13894115f, 
    -0.01928385f, -0.06631260f, 0.04676349f, 0.01502440f, -0.02464145f, -0.00502963f, 0.00156477f, 0.05865040f, 
    -0.03090828f, -0.00936478f, -0.07074580f, 0.01867410f, -0.00882701f, -0.01501739f, 0.01169975f, -0.00400403f, 
    -0.11350533f, 0.06343407f, 0.00272452f, -0.00944692f, -0.15867995f, -0.09148408f, -0.00189576f, 0.02881273f, 
    -0.01353616f, 0.00349229f, -0.07275096f, -0.12015720f, 0.02208454f, -0.05882856f, 0.01130559f, -0.02863992f, 
    -0.11035460f, -0.26062673f, 0.25253925f, 0.17532854f, -0.01970956f, -0.08606314f, 0.03596213f, -0.03615505f, 
    0.01310026f, -0.03378181f, -0.04718413f, 0.01131893f, 0.16800876f, 0.30534628f, 0.50236398f, 0.29354975f, 
    -0.03400151f, 0.04906219f, -0.07045405f, 0.18074454f, 0.08448648f, -0.00057698f, -0.03344033f, 0.10756054f, 
    -0.08493575f, -0.01803114f, -0.01822613f, 0.05600903f, -0.03206316f, -0.07157458f, 0.04179535f, 0.00363436f, 
    0.00281058f, 0.02849079f, -0.11172079f, 0.19987056f, -0.41322613f, -0.27193132f, 0.05519909f, -0.10525479f, 
    -0.10141993f, 0.00884123f, 0.09204906f, -0.08330228f, -0.00954200f, -0.01047311f, 0.03260632f, -0.05297541f, 
    -0.00685447f, -0.16060722f, -0.03699891f, 0.19052440f, -0.03325108f, 0.08403601f, 0.14783172f, 0.13854297f, 
    -0.02578253f, 0.03236057f, 0.00752549f, -0.06286218f, 0.31058905f, 0.01953904f, -0.29231992f, 0.24209043f, 
    -0.02350871f, -0.08319370f, -0.11199664f, -0.04791676f, -0.00988863f, 0.10886718f, 0.06780548f, 0.16826916f, 
    0.24582577f, -0.23909530f, -0.01749770f, -0.01079435f, -0.00913046f, -0.01516653f, -0.02207058f, -0.01703504f, 
    -0.01074424f, -0.00617668f, 0.02720695f, 0.01854734f, -0.43335629f, -0.05805333f, 0.13865270f, 0.09595520f, 
    -0.16290297f, -0.04843742f, -0.06674713f, 0.00747650f, 0.03447791f, 0.14893442f, -0.07457380f, 0.08592611f, 
    -0.15858665f, 0.11669994f, 0.12638511f, -0.16848910f, -0.07460735f, -0.02177034f, -0.04749427f, 0.13241501f, 
    0.04194973f, 0.13972431f, 0.09581645f, -0.10802519f, -0.20990257f, -0.19629110f, 0.09116328f, -0.21082306f, 
    0.00796444f, -0.07638143f, -0.07103429f, 0.05842741f, -0.12952822f, -0.03536898f, 0.08555099f, -0.17306164f, 
    -0.11144404f, -0.05663559f, 0.00596893f, 0.12940699f, 0.03185899f, 0.04776471f, -0.09093060f, -0.05579105f, 
    -0.03045440f, -0.05853694f, 0.01851578f, 0.02573010f, 0.38165364f, -0.03294709f, -0.09497615f, 0.13181867f, 
    0.05295777f, -0.02485603f, -0.06083019f, -0.15191069f, -0.07021114f, 0.16007160f, 0.05007531f, 0.10746399f, 
    -0.57244593f, -0.33526373f, -0.13051321f, 0.17767836f, 0.12241825f, -0.10226028f, 0.15643835f, -0.09620367f, 
    -0.01176416f, 0.09522005f, -0.10987456f, 0.01958744f, -0.19917025f, 0.28557575f, -0.13553146f, -0.31534350f, 
    -0.01012644f, -0.17197974f, -0.00581543f, -0.09676520f, 0.02073975f, -0.09230818f, -0.04193623f, -0.19349925f, 
    -0.48579794f, -0.04831400f, 0.17721751f, 0.02671547f, -0.02890156f, 0.05926770f, 0.08721813f, 0.03149339f, 
    0.00173620f, 0.03611494f, -0.06029269f, -0.06681389f, -0.18973660f, -0.06509984f, -0.04172888f, 0.21039689f, 
    -0.01754536f, -0.00103655f, 0.19134536f, -0.01043566f, -0.00508758f, -0.04271234f, -0.09636586f, 0.05884254f, 
    -0.03753608f, -0.37455535f, 0.01988236f, 0.02384572f, -0.03604222f, -0.15550143f, 0.05597148f, -0.16995555f, 
    -0.21228541f, 0.01621342f, -0.15262000f, -0.07470884f, 0.38760021f, 0.16593550f, 0.17117722f, -0.27099797f, 
    -0.22906722f, -0.09655377f, -0.21578693f, -0.07337293f, -0.05770953f, -0.12197577f, 0.12019790f, 0.09504148f, 
    0.06697847f, -0.12609597f, 0.23668927f, 0.04902710f, -0.22992814f, 0.02571203f, -0.21531713f, 0.04229289f, 
    0.02830786f, -0.01442736f, 0.03614736f, -0.23151056f, -0.38855520f, -0.19627568f, -0.06947023f, -0.01662347f, 
    0.13719475f, -0.06536946f, 0.10511984f, -0.19814387f, -0.00101025f, 0.01834647f, 0.29036292f, 0.02459547f, 
    0.08396148f, -0.09962118f, 0.03679179f, -0.05747163f, -0.19335900f, 0.11765034f, -0.15116084f, 0.02209670f, 
    -0.00921896f, 0.08664911f, -0.13126761f, -0.03505224f, -0.08308289f, -0.13606241f, 0.37940100f, -0.05844883f, 
    -0.05999178f, 0.07650342f, -0.02784906f, -0.04491792f, 0.08962631f, -0.03397256f, -0.02347923f, 0.06998586f, 
    -0.14346857f, 0.08735144f, -0.18222283f, 0.10639099f, 0.14985256f, 0.04556677f, -0.09846040f, -0.03934694f, 
    -0.14145480f, 0.05058404f, -0.02424340f, 0.02671496f, -0.02977159f, -0.03325361f, 0.26310113f, 0.37169757f, 
    -0.01286529f, 0.13357025f, 0.05905095f, 0.14690258f, 0.12256046f, 0.00962276f, 0.06911968f, -0.07453493f, 
    0.02272415f, 0.16471410f, -0.37932318f, -0.04720879f, 0.10870195f, -0.02093485f, 0.04371561f, -0.06537461f, 
    -0.13385504f, 0.03093142f, -0.15633881f, 0.06308936f, 0.50708789f, 0.07250655f, 0.06684987f, -0.51407230f, 
    0.07228257f, -0.04065977f, -0.00838913f, -0.09391572f, 0.11288386f, 0.03845146f, -0.08958529f, -0.17766514f, 
    -0.13398924f, 0.01396829f, -0.04283945f, 0.13301885f, 0.10026283f, 0.00598462f, 0.05944479f, -0.00481591f, 
    -0.08935658f, -0.00299088f, -0.02067724f, 0.07288940f, -0.15125728f, 0.23036964f, -0.35231432f, 0.00912528f, 
    0.15817101f, 0.01274038f, -0.00516636f, 0.18664859f, -0.03629440f, 0.04010310f, -0.06811595f, 0.02749981f, 
    0.04479332f, -0.10297729f, -0.07955191f, -0.10121717f, 0.21494567f, -0.08125366f, -0.09382975f, 0.05673911f, 
    -0.17338938f, 0.18222791f, -0.14056772f, -0.03897205f, 0.07670411f, 0.16588941f, 0.46615583f, 0.34466797f, 
    -0.05696143f, 0.21190263f, -0.23712134f, 0.06875882f, 0.15094866f, -0.01237912f, 0.03613207f, 0.19255351f, 
    -0.17747129f, 0.08819006f, -0.04158040f, 0.07896785f, -0.02132804f, -0.17618288f, 0.00483118f, -0.29757705f, 
    -0.01640664f, -0.09736572f, 0.07961060f, -0.02152991f, 0.29285213f, -0.24957164f, -0.10731740f, 0.00680556f, 
    0.27380100f, 0.02053631f, 0.04553003f, -0.05446682f, -0.15582165f, -0.00467777f, -0.13421716f, 0.01124614f, 
    0.89677691f, -0.06343477f, 0.16678356f, 0.20172451f, 0.12630352f, -0.07021748f, -0.11047363f, -0.03954449f, 
    -0.00630332f, 0.03374532f, -0.14679030f, 0.01655064f, -0.03705253f, -0.21171114f, 0.43596184f, 0.24359685f, 
    -0.05292547f, 0.04980411f, 0.05190831f, 0.12362406f, 0.12671278f, -0.00733233f, -0.13432859f, 0.06799234f, 
    -0.16753784f, 0.20926693f, 0.13370788f, 0.08892368f, 0.16114353f, 0.02123708f, -0.00576443f, -0.00174657f, 
    0.01309178f, -0.10036179f, 0.00113695f, 0.08652406f, -0.74204278f, -0.17896006f, 0.08471277f, 0.11823235f, 
    0.11773589f, 0.24488644f, -0.04454567f, -0.01256388f, -0.03469801f, 0.01451634f, -0.07501666f, -0.05742082f, 
    0.21572717f, 0.08836374f, -0.02647060f, 0.21766149f, 0.03576527f, -0.20757899f, 0.00119241f, 0.01963857f, 
    0.00160027f, 0.12174728f, -0.03663324f, -0.04648846f, -0.06524864f, -0.02612746f, -0.17700560f, -0.03656410f, 
    -0.02950813f, -0.15931650f, 0.03025746f, -0.13337824f, -0.02323922f, 0.04855695f, 0.02983589f, 0.15738036f, 
    -0.23228373f, 0.04553432f, -0.15235053f, 0.13998500f, 0.02907334f, 0.05902216f, -0.15208501f, -0.06783136f, 
    0.06344690f, 0.12587281f, -0.12218411f, 0.02163744f, -0.15346901f, -0.00753875f, -0.12547541f, 0.04946021f, 
    0.01976568f, 0.02328463f, 0.00048305f, 0.07759587f, -0.09208675f, 0.08065776f, -0.08324334f, -0.01299496f, 
    -0.49237710f, 0.52116209f, -0.16602845f, -0.46443340f, 0.12887168f, 0.20991199f, -0.10490823f, -0.23078755f, 
    -0.09551629f, -0.05824656f, 0.10983131f, 0.02458122f, -0.17025688f, -0.18374610f, -0.21599178f, 0.08383595f, 
    -0.03316527f, -0.01676657f, 0.09040668f, 0.07659411f, -0.03414566f, 0.16340138f, -0.27578712f, -0.03720720f, 
    0.51281208f, 0.02372927f, -0.07183177f, 0.25318503f, -0.09711248f, -0.02746167f, 0.02760101f, 0.02849268f, 
    -0.03422929f, -0.15420884f, 0.11939080f, 0.17824292f, -0.04471827f, -0.11634870f, 0.10960189f, 0.20483807f, 
    0.03384779f, 0.07782698f, 0.10080663f, 0.16433451f, 0.00452225f, -0.09257595f, 0.09972499f, -0.15736033f, 
    -0.03164192f, 0.03347631f, 0.17354381f, -0.50225943f, -0.09820459f, -0.12043084f, -0.13466102f, -0.07466944f, 
    0.07222220f, 0.08939058f, 0.03733738f, 0.03152648f, -0.56400740f, 0.39742547f, -0.13171391f, 0.39503479f, 
    0.08504415f, -0.10539657f, -0.11047767f, -0.00611225f, -0.03450272f, -0.13331446f, 0.01289148f, 0.01761967f, 
    -0.18818353f, -0.11964722f, -0.30847856f, 0.02143361f, 0.14784048f, -0.10451172f, -0.00638479f, -0.02198619f, 
    -0.20949623f, -0.06121735f, -0.11737414f, 0.00710867f, -0.23046258f, -0.30835071f, -0.15205078f, -0.27509621f, 
    -0.29766843f, -0.08023603f, -0.05596842f, -0.02020739f, -0.09704392f, -0.02369970f, 0.07705493f, 0.01759888f, 
    -0.08027101f, 0.08516918f, -0.11942599f, 0.26494309f, 0.04144438f, -0.11380353f, -0.00502590f, -0.15850717f, 
    -0.04665406f, 0.01008997f, 0.22040370f, -0.07314243f, -0.24921516f, 0.00108260f, 0.27269581f, -0.34636661f, 
    -0.19039451f, 0.08058583f, 0.06776994f, -0.03351423f, -0.01690879f, 0.08676500f, -0.03309324f, 0.04464248f, 
    0.43047228f, -0.24638616f, -0.05080974f, -0.10583013f, -0.17626768f, -0.09601191f, 0.07077385f, 0.12102636f, 
    -0.09630602f, -0.03283065f, -0.22848825f, -0.24763669f, -0.02379311f, -0.13239339f, -0.05834301f, 0.14504971f, 
    -0.04646278f, -0.00394838f, -0.06593298f, 0.01063073f, 0.03440395f, 0.19099186f, -0.08385228f, -0.02593816f, 
    0.06591128f, -0.12776089f, -0.17466500f, 0.21139717f, 0.15876405f, 0.09709144f, 0.12547152f, 0.17815955f, 
    -0.03357754f, 0.03838012f, -0.02161580f, -0.00381149f, 0.05099101f, 0.01769935f, 0.20023614f, 0.04883559f, 
    0.04868109f, 0.15011667f, -0.13464150f, -0.01328851f, 0.12441661f, 0.30927628f, -0.05738222f, 0.05144891f, 
    -0.00744265f, -0.02322393f, 0.05647101f, -0.08005840f, -0.02172114f, 0.03882338f, -0.02708979f, 0.02512822f, 
    0.07723571f, -0.03097982f, 0.03703133f, -0.22746445f, -0.08202927f, 0.03359933f, -0.07545944f, 0.10046038f, 
    0.08405399f, 0.26110595f, -0.02802689f, -0.07278658f, -0.27216163f, -0.13183388f, -0.07010238f, -0.00639330f, 
    -0.18488732f, 0.49558076f, -0.15834919f, -0.25923640f, 0.19079165f, 0.10691587f, -0.01380547f, -0.03583723f, 
    -0.29845276f, 0.06242805f, 0.09564496f, 0.00772424f, 0.13015482f, -0.10611910f, 0.07623339f, 0.17701441f, 
    0.08141464f, -0.01551262f, 0.02161922f, -0.01343979f, -0.00965535f, 0.03880198f, 0.09621657f, 0.00810400f, 
    -0.33207768f, -0.43231153f, -0.10882714f, -0.19372405f, 0.00874234f, -0.26479048f, -0.03565208f, -0.23864718f, 
    -0.03137426f, 0.09570998f, -0.06923319f, -0.03418704f, -0.15499020f, 0.05085135f, -0.03586758f, 0.19699244f, 
    -0.01379735f, -0.03853144f, -0.16735014f, 0.03405548f, -0.05710881f, 0.04301045f, 0.03625515f, -0.00561716f, 
    -0.46457109f, -0.21636307f, 0.06421071f, 0.30111596f, 0.05351114f, -0.02316807f, 0.11700527f, -0.05485053f, 
    0.00340593f, 0.11908795f, -0.06636740f, 0.06142247f, -0.31295773f, 0.37353745f, -0.15286265f, -0.27896208f, 
    -0.19342384f, 0.04110754f, 0.04365597f, -0.42052999f, -0.00045770f, -0.00906180f, -0.19000860f, 0.18767649f, 
    -0.21556427f, -0.06567874f, -0.11355999f, -0.28574446f, -0.01586954f, 0.07446159f, -0.16951105f, 0.17727573f, 
    -0.03345688f, 0.06193416f, 0.09283486f, -0.20675352f, 0.09532124f, -0.01153228f, 0.04844895f, 0.14772320f, 
    -0.04382673f, -0.07302060f, -0.07267494f, -0.02007259f, 0.03227190f, 0.06145496f, -0.01038458f, -0.01224388f, 
    0.02688164f, 0.01933868f, -0.06402037f, 0.00288529f, 0.03392505f, 0.05331833f, 0.06598932f, -0.01611252f, 
    -0.07430596f, -0.02702174f, -0.00238411f, -0.00076608f, 0.42448175f, -0.34539250f, -0.03861308f, 0.15910955f, 
    0.16791928f, 0.03294911f, 0.05636131f, -0.04589863f, -0.10463670f, 0.05251678f, 0.00637909f, 0.06121252f, 
    -0.22259653f, 0.00489512f, 0.05544445f, -0.27964658f, 0.04658000f, -0.18380281f, 0.06262446f, -0.06390274f, 
    -0.14755571f, -0.13348264f, -0.04230791f, 0.08796387f, -0.15521866f, -0.09193880f, -0.07631611f, 0.18404587f, 
    0.01786154f, 0.00461100f, -0.07750582f, -0.00172826f, 0.00922742f, 0.00579496f, -0.02797696f, -0.04823889f, 
    0.03651276f, 0.20409913f, 0.10583895f, 0.18969096f, -0.01448555f, -0.02005770f, 0.07906440f, 0.13357455f, 
    0.06647470f, 0.01652570f, -0.04708333f, 0.05812104f, -0.24822766f, -0.00610154f, 0.10402700f, -0.13945837f, 
    -0.15646061f, 0.16407488f, -0.22241810f, 0.00843676f, -0.08972134f, -0.00569370f, 0.01720213f, 0.05977342f, 
    -0.05353804f, -0.04376643f, -0.06555648f, 0.05402423f, -0.01016215f, 0.10877214f, -0.02358487f, -0.02275356f, 
    0.01318064f, -0.10102756f, 0.02840468f, 0.12792252f, 0.04085577f, 0.12577122f, -0.15999569f, 0.12047478f, 
    -0.03719382f, -0.04659178f, -0.00669349f, -0.08449303f, -0.03320634f, 0.11652000f, -0.02728521f, 0.09463600f, 
    0.25756297f, -0.12396590f, -0.12781368f, 0.01021093f, -0.04350033f, -0.02913403f, 0.01509102f, -0.06090317f, 
    0.08019248f, -0.04664807f, 0.00991722f, 0.12845726f, -0.05606048f, -0.01344504f, -0.39965242f, -0.21077943f, 
    -0.04240592f, -0.01015534f, 0.01861045f, -0.00112283f, -0.11719609f, 0.04176870f, -0.02659706f, 0.01513409f, 
    -0.06320253f, 0.13858378f, 0.00798286f, 0.04646497f, -0.12852941f, -0.08618930f, -0.00165925f, 0.09108716f, 
    0.15672100f, -0.06303607f, -0.03580219f, 0.12021202f, -0.01273003f, 0.06141891f, 0.07920756f, 0.17737006f, 
    -0.16306990f, -0.01563598f, 0.00219922f, 0.04595200f, 0.10012680f, 0.07428567f, 0.02079185f, 0.03246497f, 
    0.14450030f, 0.15231256f, -0.00177611f, 0.07416213f, 0.03080354f, -0.05080584f, -0.07945099f, 0.06688818f, 
    -0.09752332f, -0.23309721f, 0.15203586f, 0.03201585f, -0.13463701f, -0.26305044f, -0.08078799f, 0.11904229f, 
    -0.01774719f, -0.00847899f, -0.06476733f, -0.11603086f, -0.04271624f, 0.07569490f, -0.17201395f, -0.11227781f, 
    -0.00332389f, 0.01020588f, -0.01345125f, -0.03042702f, 0.05608712f, 0.03785281f, 0.00155646f, -0.00105609f, 
    -0.03503575f, 0.05221025f, -0.13767058f, -0.02715951f, 0.03137968f, -0.09284374f, 0.04279619f, 0.20471866f, 
    0.03111334f, 0.04323950f, -0.00443667f, 0.00316986f, 0.00724791f, -0.06922852f, -0.03649847f, -0.05206876f, 
    0.06257215f, 0.10936359f, -0.03892251f, -0.04692963f, 0.05729820f, 0.02937237f, 0.01137716f, 0.00376145f, 
    0.02077105f, 0.02085778f, -0.02692546f, -0.07262385f, -0.01738442f, -0.36294553f, -0.77751058f, -0.15184247f, 
    0.03600405f, 0.01105591f, 0.02791442f, -0.05491672f, 0.02395642f, -0.08559291f, -0.03457366f, -0.06453832f, 
    -0.15512414f, 0.23854600f, -0.15922756f, 0.11887588f, 0.24826783f, 0.03904405f, -0.10885388f, -0.04743687f, 
    -0.25536636f, 0.00170942f, -0.13115041f, -0.07361482f, -0.33474702f, -0.03214753f, -0.29589307f, 0.14318600f, 
    -0.11843381f, 0.01142260f, -0.18777871f, 0.01314132f, -0.10060033f, -0.07381164f, -0.29628089f, 0.01481233f, 
    0.06456997f, 0.10066162f, -0.22718754f, 0.12140960f, 0.04746087f, -0.10934594f, 0.09405424f, -0.17202584f, 
    0.04471806f, -0.14589390f, 0.39240614f, 0.31843314f, -0.02532484f, 0.22202043f, -0.06680169f, 0.37085578f, 
    0.12703583f, 0.06457980f, -0.21591942f, -0.13107845f, -0.03291030f, 0.07696825f, -0.06354159f, -0.10562474f, 
    -0.05840374f, -0.03964199f, 0.14607494f, 0.02910145f, -0.06912277f, -0.01225424f, 0.02602602f, -0.13720529f, 
    -0.07426810f, 0.01675057f, -0.05380642f, 0.02730172f, -0.03632851f, 0.28324068f, -0.07516728f, -0.13977133f, 
    0.14374647f, -0.03513350f, 0.03134716f, -0.05997131f, 0.03769503f, -0.04263280f, 0.03227201f, 0.08129595f, 
    0.20353290f, -0.25576419f, -0.06075113f, -0.03833112f, 0.04998593f, -0.00121487f, -0.07670195f, 0.04248296f, 
    0.01142562f, 0.05060910f, 0.03031540f, -0.10386493f, -0.01777653f, -0.09339484f, -0.04204673f, -0.09950966f, 
    0.03536325f, 0.04333567f, -0.06269868f, -0.11872240f, 0.03860429f, 0.02978171f, 0.08298083f, 0.05520877f, 
    -0.02906522f, -0.00854975f, 0.06867404f, 0.07414086f, -0.00823671f, -0.08049054f, -0.02683791f, -0.07441949f, 
    0.27113515f, 0.06498484f, 0.01449058f, 0.01712212f, 0.06291897f, -0.30836669f, 0.23417412f, 0.19539435f, 
    -0.14367026f, 0.10865714f, -0.30167112f, -0.15166047f, -0.09569137f, -0.02457196f, 0.05420464f, 0.00216974f, 
    0.06539332f, 0.00495343f, 0.05988672f, -0.05178929f, -0.04432913f, -0.02408005f, 0.01739472f, 0.03386240f, 
    -0.17552361f, -0.12293052f, -0.10910297f, -0.20151019f, 0.25587639f, -0.05664906f, 0.14019303f, 0.25612795f, 
    0.11840625f, -0.04897280f, 0.03656556f, -0.07256068f, 0.04386774f, -0.01369456f, 0.03036531f, 0.01717592f, 
    -0.11220167f, 0.03790227f, -0.30430329f, -0.11800790f, 0.04443162f, 0.01048678f, -0.04268409f, 0.00904391f, 
    -0.09831204f, 0.07821389f, -0.12721923f, -0.23726365f, 0.07537585f, -0.01383013f, 0.01953638f, 0.00939735f, 
    -0.09530348f, -0.03636838f, 0.04983074f, 0.08756827f, 0.05510163f, -0.01381632f, -0.01155803f, -0.09994085f, 
    -0.30884215f, 0.21168233f, -0.09538920f, 0.08680823f, -0.06182104f, -0.14940768f, 0.08570788f, -0.18090682f, 
    -0.06576224f, -0.10189290f, 0.09666314f, -0.08454394f, 0.27356565f, 0.35238177f, -0.02425193f, 0.33901998f, 
    0.13207313f, 0.16347758f, 0.14445798f, 0.12920205f, 0.05079855f, -0.06176355f, 0.03503157f, -0.06916974f, 
    0.03203858f, -0.08759638f, 0.00258826f, 0.03309813f, -0.06667198f, -0.16218190f, -0.01310370f, 0.12572940f, 
    -0.03217393f, -0.06876711f, -0.02185545f, 0.02894271f, 0.28247952f, 0.23504998f, -0.18393810f, -0.49239317f, 
    0.07634439f, -0.01993972f, 0.08709707f, 0.03147428f, 0.03978740f, 0.02996669f, 0.02107912f, -0.04550669f, 
    0.13741964f, 0.18307598f, 0.08442698f, 0.12593679f, 0.03321138f, -0.04906335f, 0.01308061f, -0.14826180f, 
    -0.15749109f, -0.29786345f, 0.05970493f, -0.02147216f, 0.04707037f, 0.03713001f, 0.19555798f, -0.07543918f, 
    -0.04870995f, 0.01750785f, -0.02963690f, -0.07429232f, 0.12000024f, -0.00456259f, -0.23347893f, -0.16219872f, 
    0.05939406f, 0.02789456f, 0.02526735f, -0.05429604f, 0.03241671f, -0.08164535f, -0.00781815f, 0.04611081f, 
    -0.08221171f, -0.04230069f, -0.05835811f, 0.18438634f, -0.07233043f, -0.08422481f, 0.09826673f, 0.09357642f, 
    -0.13082527f, 0.07099932f, 0.03901447f, -0.00332083f, 0.01520162f, 0.00570806f, -0.02139791f, 0.03543723f, 
    0.13696851f, -0.04813546f, 0.03564694f, 0.06906437f, 0.07953986f, -0.03357626f, -0.07300103f, -0.01536998f, 
    0.05318704f, 0.15330151f, -0.17296492f, -0.07337782f, 0.05822190f, -0.01626169f, 0.02896108f, -0.01832907f, 
    0.07875354f, -0.01330877f, -0.01438935f, -0.08944790f, -0.15515551f, -0.26944795f, -0.19852380f, -0.14934245f, 
    -0.03198987f, -0.05830418f, 0.01564344f, -0.04523407f, -0.03183948f, -0.05081182f, -0.31005517f, 0.05266878f, 
    0.00794781f, 0.03066688f, -0.02597770f, 0.00662166f, 0.02430549f, 0.23738612f, 0.07460745f, 0.10666890f, 
    0.04447084f, -0.02756911f, 0.09005156f, 0.08594316f, -0.02690403f, -0.07371814f, 0.01339155f, 0.00412225f, 
    -0.17420524f, -0.36662507f, -0.36875013f, -0.15730922f, -0.01943712f, 0.05292690f, 0.02344119f, -0.00355338f, 
    0.06155137f, -0.03025426f, -0.00813343f, -0.06640334f, 0.07519282f, -0.31691509f, 0.12326769f, -0.25775945f, 
    0.03045962f, 0.12902384f, -0.05534897f, -0.07124905f, -0.07287674f, 0.01745246f, -0.00583651f, -0.02564563f, 
    0.03574516f, 0.26573440f, -0.66832340f, -0.00048118f, 0.04166023f, 0.01595307f, 0.09661873f, -0.07512259f, 
    -0.22784978f, -0.03000019f, -0.01687358f, -0.09669637f, -0.04744509f, 0.04968867f, -0.01605654f, -0.03042495f, 
    0.03045783f, 0.01706938f, 0.08461075f, -0.04492959f, 0.11377829f, 0.01927281f, 0.06536391f, -0.01002468f, 
    0.00714677f, -0.00690145f, -0.02779688f, 0.06474135f, 0.02470376f, 0.00442627f, 0.01497879f, 0.07732347f, 
    -0.02185584f, -0.04425966f, -0.07380288f, -0.07802346f, 0.16489390f, -0.01264775f, -0.23407623f, 0.25369111f, 
    -0.03947506f, 0.00844627f, -0.28650892f, -0.07823073f, 0.10147902f, -0.03436108f, -0.03227217f, -0.01948912f, 
    -0.30440632f, -0.18281172f, -0.12258475f, -0.18774790f, 0.07590274f, 0.01916970f, -0.02316525f, 0.15731496f, 
    0.14750387f, -0.00186078f, 0.11904775f, -0.22748980f, 0.04666582f, 0.10305011f, 0.18700947f, 0.15228848f, 
    -0.07208602f, -0.05522316f, 0.05845178f, -0.07559732f, 0.06695192f, -0.00367435f, 0.02641942f, 0.02931598f, 
    0.10608999f, 0.06816130f, 0.30619892f, 0.16873038f, 0.00600173f, -0.09602793f, -0.11132653f, -0.05711049f, 
    0.09405095f, 0.05536107f, 0.12071466f, -0.04214901f, 0.26117969f, 0.19753616f, -0.03312757f, 0.18661070f, 
    -0.00677925f, 0.08480831f, 0.01303306f, -0.13305539f, -0.08050781f, -0.41652536f, 0.01585374f, -0.18186389f, 
    0.05117219f, -0.07005358f, -0.03032068f, -0.12138858f, 0.06200438f, 0.01238828f, 0.02833721f, 0.00348555f, 
    0.04654955f, 0.01718205f, 0.00462583f, 0.36109808f, 0.08166749f, 0.13876669f, 0.00281025f, -0.05305714f, 
    -0.02362407f, 0.11582651f, 0.02179131f, 0.05104144f, 0.25049329f, 0.04075345f, -0.24467608f, -0.03536993f, 
    -0.14119023f, -0.43536386f, 0.01407021f, 0.09274792f, -0.02111775f, 0.03530344f, 0.05820620f, 0.00660490f, 
    -0.12182931f, -0.08748110f, 0.05484933f, -0.06415466f, -0.13804625f, 0.08413569f, 0.06038226f, 0.12476347f, 
    0.02637808f, -0.17655806f, 0.08464259f, -0.09252144f, 0.00480849f, -0.02017599f, -0.00099524f, 0.17561387f, 
    -0.01523672f, -0.01922919f, -0.04948377f, -0.03636672f, 0.07065615f, 0.08575875f, -0.02658473f, 0.06139042f, 
    0.02830440f, 0.08714043f, 0.01301083f, -0.02356444f, -0.44501460f, -0.16137500f, -0.21238805f, 0.08853240f, 
    -0.02398210f, -0.05135579f, -0.13316558f, -0.00214354f, -0.14154728f, -0.15104122f, 0.08203021f, 0.04651882f, 
    -0.12283816f, 0.14447965f, 0.15166542f, -0.02878688f, 0.09335037f, -0.04164893f, 0.00944444f, -0.03481182f, 
    -0.10165775f, -0.18153498f, -0.11933248f, -0.00777592f, -0.07140496f, -0.29712555f, 0.03058189f, 0.31392866f, 
    0.08055613f, -0.16732289f, 0.00212413f, -0.02979416f, -0.11165706f, -0.06294570f, 0.00849627f, -0.01045281f, 
    0.03975263f, -0.01508023f, 0.01970438f, 0.04167652f, 0.08017971f, -0.07041050f, -0.08008021f, 0.03273617f, 
    0.10309546f, -0.09845132f, -0.02491316f, 0.01394472f, -0.03712556f, 0.02875058f, 0.15021302f, 0.18141636f, 
    -0.07525004f, -0.05299255f, -0.03939477f, 0.17918114f, -0.05961667f, -0.05148795f, -0.11004529f, -0.07380641f, 
    0.11129224f, 0.06776753f, -0.08511394f, -0.01496992f, -0.10174762f, -0.10721375f, 0.08690482f, 0.14266239f, 
    0.13767163f, 0.04128798f, -0.03764256f, 0.07919957f, -0.13045458f, 0.31090328f, 0.22003530f, 0.09229497f, 
    -0.14564398f, -0.18958110f, 0.07837210f, -0.01570475f, -0.00215030f, -0.00979031f, 0.04383218f, 0.01596346f, 
    0.01921326f, -0.01668044f, -0.00948632f, -0.06194240f, 0.00549463f, -0.00067631f, -0.01994331f, 0.04212882f, 
    -0.17744324f, -0.14578988f, -0.01815304f, -0.10011376f, 0.07264370f, 0.14508101f, 0.16572696f, 0.08806799f, 
    -0.18822850f, -0.04891625f, 0.08097394f, 0.11115512f, 0.03613349f, 0.05005920f, 0.00431318f, -0.02135445f, 
    0.08653971f, 0.14144690f, -0.11846519f, 0.00507666f, 0.12319564f, -0.07914915f, -0.14769968f, -0.05641948f, 
    0.01312433f, 0.00695822f, 0.00581201f, -0.00424721f, -0.14884244f, 0.03060052f, 0.13622014f, -0.29822227f, 
    -0.13198949f, -0.16521366f, 0.06873933f, 0.08349271f, -0.01302722f, -0.19038945f, -0.03498088f, 0.00137761f, 
    0.24691899f, 0.04175707f, 0.04122277f, 0.01424569f, -0.03316154f, -0.14629348f, 0.02214891f, 0.17491446f, 
    -0.06391786f, -0.03059220f, 0.06314413f, -0.20077820f, 0.30071208f, -0.05001064f, -0.00008501f, 0.10031652f, 
    0.01396757f, 0.06752083f, -0.01492804f, 0.10229266f, 0.06574108f, -0.07127537f, 0.05784984f, -0.12003413f, 
    -0.00314273f, -0.38078561f, 0.01773391f, 0.07565316f, 0.03437215f, 0.04255680f, 0.05663494f, -0.01833864f, 
    0.08063138f, -0.24565654f, -0.06545380f, -0.16690056f, 0.55146998f, -0.34844491f, 0.17142114f, 0.27130082f, 
    0.03164532f, -0.00466762f, -0.00355744f, 0.08493952f, 0.00363099f, -0.01522295f, -0.21901803f, 0.05072720f, 
    -0.02452160f, -0.07853767f, -0.12086443f, -0.17577513f, 0.06793793f, 0.02507893f, -0.00672821f, -0.01031721f, 
    -0.06821792f, 0.14719495f, -0.14768966f, -0.22081287f, -0.07607059f, -0.05594452f, 0.05836418f, 0.13922401f, 
    -0.03245792f, 0.00308626f, 0.01736315f, 0.15630592f, -0.03218925f, -0.20735396f, -0.24641159f, -0.17142108f, 
    -0.18268828f, -0.00545035f, -0.09159736f, -0.09861723f, -0.00591939f, 0.03327404f, 0.08380911f, 0.18005088f, 
    0.01382561f, -0.11042467f, 0.10244726f, -0.00741479f, 0.16471797f, 0.02293379f, 0.07776417f, -0.20041397f, 
    -0.07852816f, -0.02799805f, -0.03477797f, 0.31525695f, 0.04897806f, 0.03393853f, 0.03697878f, 0.26075092f, 
    -0.14425929f, -0.10172150f, -0.22242807f, 0.01665125f, 0.19686444f, -0.04502539f, -0.13979147f, 0.12638485f, 
    0.04761078f, -0.03245141f, 0.14279066f, -0.05113214f, 0.26377493f, 0.05529461f, -0.03087773f, 0.05378082f, 
    -0.04411355f, 0.03337003f, 0.00254535f, 0.23243645f, 0.07659589f, 0.05857007f, -0.00884371f, 0.01136533f, 
    0.12740950f, -0.12411910f, -0.17392109f, 0.07041386f, -0.01813478f, 0.02615416f, -0.04308986f, -0.01776860f, 
    0.06566378f, -0.07327043f, 0.19236639f, 0.02392350f, -0.37857494f, 0.09980343f, -0.48339680f, 0.27977136f, 
    0.03621362f, 0.04970338f, -0.02209064f, 0.00638345f, 0.06523392f, 0.08760350f, 0.01576054f, 0.16271660f, 
    -0.02809355f, 0.13680692f, -0.36421141f, -0.08437904f, 0.00206627f, 0.01407188f, -0.07699607f, -0.06455313f, 
    0.06079672f, -0.06267212f, 0.14526567f, 0.23440501f, -0.13320500f, -0.19123739f, 0.17348877f, -0.42660508f, 
    -0.04346836f, 0.20424485f, 0.03624139f, 0.14185771f, 0.07211662f, 0.04266365f, 0.03642978f, -0.01678003f, 
    0.05864817f, 0.00610558f, -0.15595964f, 0.09678075f, 0.05089895f, 0.07033569f, 0.10945527f, 0.09708533f, 
    0.14392349f, -0.10052811f, 0.01675490f, -0.34524402f, 0.00387152f, 0.14179972f, -0.17704059f, -0.00480836f, 
    0.14351936f, 0.18741198f, 0.14068498f, -0.09148987f, -0.07200290f, -0.13664007f, 0.05177489f, -0.27178487f, 
    -0.36925015f, 0.32110047f, -0.22249877f, 0.07193236f, 0.00067890f, 0.01236100f, -0.15219857f, -0.02643744f, 
    0.01885807f, 0.05100568f, -0.04791388f, 0.00525331f, -0.13257156f, -0.00459410f, -0.22532965f, 0.02462136f, 
    -0.14622460f, 0.01776762f, 0.00310469f, 0.14791781f, -0.09576878f, -0.04256843f, -0.04702822f, -0.24578100f, 
    -0.03740467f, 0.37474018f, -0.02057310f, -0.18790543f, -0.08861154f, -0.03099563f, -0.07092363f, 0.11643325f, 
    0.04183017f, -0.02227902f, -0.10523605f, 0.21423981f, -0.30144569f, -0.41937184f, -0.15702075f, 0.47270331f, 
    -0.13933748f, -0.31974396f, -0.04135869f, 0.12504084f, -0.13275069f, -0.03080711f, -0.09464810f, -0.05692900f, 
    0.09786597f, 0.15246813f, 0.01098261f, -0.24394552f, 0.04039581f, 0.09689637f, 0.00190093f, -0.08067440f, 
    -0.19385694f, -0.19959807f, 0.13024457f, -0.14611821f, 0.00537127f, -0.06668656f, 0.40488711f, 0.00815473f, 
    -0.02958391f, 0.00781717f, 0.15198283f, -0.10749047f, 0.04046680f, -0.00684258f, 0.07540247f, 0.01239549f, 
    -0.09887110f, -0.26731235f, 0.03137761f, 0.13871048f, -0.15491641f, 0.01396144f, 0.03560770f, -0.00580711f, 
    0.03107613f, -0.15803479f, 0.17004824f, 0.28729418f, -0.13567947f, -0.07594311f, -0.02321521f, -0.10318671f, 
    -0.00058502f, -0.19211571f, 0.04489329f, 0.06140398f, 0.01840697f, -0.06474120f, -0.02966096f, -0.04336689f, 
    0.06691664f, -0.01404505f, 0.01804309f, 0.12516564f, -0.05182122f, -0.01587907f, -0.05908084f, 0.08623956f, 
    0.01865317f, 0.11042977f, -0.00104467f, 0.13511606f, -0.18558861f, 0.13855125f, -0.23068322f, 0.01452065f, 
    -0.00275826f, 0.00175264f, -0.07573013f, -0.00815652f, -0.03481953f, -0.05401202f, -0.03561871f, 0.04938438f, 
    -0.82818139f, -0.33883461f, -0.21985492f, -0.17949666f, -0.06865051f, -0.06459113f, 0.07765898f, 0.11929467f, 
    0.00697874f, 0.03924944f, 0.01491134f, -0.02938282f, -0.08484060f, -0.04926809f, -0.28656635f, 0.12870060f, 
    0.24862844f, -0.10971326f, 0.03674185f, 0.17307548f, -0.02610156f, 0.05991064f, 0.07511491f, -0.04178099f, 
    -0.00704002f, -0.01866571f, -0.14321223f, -0.08000046f, -0.09207051f, 0.07983589f, 0.09503214f, 0.03261895f, 
    -0.28239012f, 0.04353764f, 0.08716601f, -0.00706015f, -0.25126460f, 0.02589652f, -0.34378579f, -0.11775110f, 
    -0.04424147f, -0.00996884f, -0.06389150f, -0.04768207f, 0.07507199f, -0.08007335f, 0.04225926f, -0.00513998f, 
    -0.11461575f, -0.05100177f, -0.13233852f, -0.08885843f, -0.04629026f, 0.05125600f, -0.04865829f, -0.05502346f, 
    0.16283369f, 0.09998477f, 0.13250194f, -0.04352935f, 0.08947025f, -0.11579150f, -0.03442885f, -0.00990293f, 
    -0.03587222f, 0.03604253f, 0.12103833f, -0.04733376f, 0.06105318f, -0.08286430f, 0.22098488f, 0.03863693f, 
    0.13607828f, -0.04106294f, 0.36938751f, -0.01161049f, 0.01848530f, -0.01577741f, 0.01779630f, 0.05154231f, 
    0.08914759f, 0.04493652f, -0.14334725f, -0.16388124f, -0.11372463f, 0.08595340f, 0.27217162f, -0.06340114f, 
    0.08980594f, 0.02731514f, 0.01393309f, -0.00737707f, 0.02863523f, 0.00696394f, 0.07062189f, 0.04567590f, 
    0.02081528f, 0.18544672f, 0.04213726f, -0.12351640f, -0.04651912f, -0.13107651f, 0.01095395f, 0.05447970f, 
    0.05409314f, -0.06131686f, 0.04770440f, -0.03134057f, 0.08794914f, -0.07138275f, -0.07469927f, 0.09010945f, 
    0.05756155f, 0.01162799f, 0.04089115f, -0.07871865f, 0.03633090f, 0.04758863f, 0.49528673f, 0.12865542f, 
    0.08721725f, 0.07471693f, -0.22322634f, -0.06801976f, 0.13130106f, 0.00383944f, 0.00957834f, 0.16938227f, 
    -0.04443868f, -0.09829874f, 0.06152954f, -0.13959958f, 0.13759209f, 0.14670271f, 0.01277761f, -0.04367478f, 
    0.29708734f, 0.11165483f, -0.05929342f, -0.18116355f, 0.06967563f, 0.10957152f, 0.01113300f, -0.03661241f, 
    -0.44069630f, -0.38014704f, -0.09290566f, 0.18159194f, 0.03648004f, 0.03717494f, -0.00736881f, -0.02953631f, 
    -0.02054036f, -0.06212332f, 0.05268017f, 0.01033976f, 0.16902731f, 0.25286961f, -0.33619899f, -0.21805277f, 
    0.10819749f, 0.04183607f, 0.03431252f, -0.14269781f, 0.23569877f, 0.07194860f, -0.12683149f, -0.07513145f, 
    -0.22310635f, 0.12056714f, 0.06228023f, -0.21080177f, -0.09902710f, -0.01352809f, -0.04710764f, 0.04959761f, 
    0.17202634f, 0.04990731f, 0.08824780f, -0.01468772f, -0.26953766f, -0.23565134f, -0.00705834f, 0.05072760f, 
    0.06806137f, -0.01733654f, -0.03126917f, -0.09947395f, 0.01173191f, -0.08878696f, 0.04971963f, -0.06921194f, 
    0.17740700f, -0.03141161f, -0.01565965f, 0.05749834f, 0.13155778f, -0.15247881f, -0.04206662f, -0.00895566f, 
    0.10753139f, 0.06439450f, -0.04667965f, 0.17670004f, 0.08920016f, -0.07796147f, -0.05433216f, 0.20147774f, 
    0.05839906f, 0.15248749f, 0.08724391f, -0.06866156f, -0.00711146f, 0.02904724f, -0.02344222f, -0.07064518f, 
    0.44910389f, -0.33950147f, -0.02300322f, 0.34787101f, -0.03354144f, -0.07790881f, -0.08151305f, 0.06647003f, 
    -0.02291521f, -0.11952619f, -0.01856752f, 0.06744542f, 0.10300385f, 0.11809911f, 0.11539548f, -0.14703351f, 
    0.27815899f, 0.12757291f, 0.17111063f, -0.08310091f, 0.06946582f, -0.00739691f, 0.02093634f, 0.06630581f, 
    0.21282353f, 0.00305117f, 0.18818085f, -0.28790003f, 0.07759170f, -0.02854447f, -0.02952089f, -0.11396807f, 
    -0.20325926f, -0.14673156f, 0.04126843f, -0.04734759f, -0.27560881f, -0.09726471f, -0.10611311f, 0.06923912f, 
    -0.22980352f, -0.15556508f, -0.03078053f, -0.14205439f, 0.15219590f, 0.00807688f, 0.01581630f, 0.03700608f, 
    -0.02797902f, -0.18787414f, -0.11503492f, 0.08432131f, 0.00317490f, 0.01042686f, 0.04033291f, -0.02769886f, 
    -0.04846168f, -0.20560141f, -0.32133338f, -0.43792346f, -0.00645673f, -0.08454698f, -0.16064212f, -0.11827172f, 
    -0.03836875f, -0.07272460f, 0.00033472f, -0.14582470f, -0.04498554f, -0.04471358f, 0.21258916f, 0.14439991f, 
    -0.24883303f, 0.02815743f, 0.20143165f, 0.02155178f, -0.09288523f, -0.09019131f, -0.01827704f, -0.05391977f, 
    -0.03067362f, -0.11740914f, -0.10067251f, -0.11281577f, -0.03511885f, 0.08967771f, -0.09679518f, -0.19857875f, 
    0.01344403f, -0.02592104f, -0.03272986f, -0.06162505f, -0.07117829f, -0.15043305f, -0.13659637f, -0.22081260f, 
    -0.02014637f, -0.14331888f, -0.15512067f, 0.13401015f, 0.04660898f, -0.10017879f, -0.08358657f, 0.00067815f, 
    -0.05510839f, 0.07351496f, 0.03473585f, 0.01147532f, 0.08698069f, 0.03255657f, -0.00826607f, -0.19193795f, 
    0.10780937f, -0.03841199f, -0.04083129f, 0.08764280f, 0.30784544f, 0.01469284f, -0.10638701f, 0.04194023f, 
    0.05421479f, -0.14600164f, -0.38707414f, -0.06612528f, 0.01577262f, 0.10062609f, -0.13234241f, 0.08370955f, 
    -0.00055695f, -0.05405305f, 0.13341247f, -0.06350359f, 0.20182221f, -0.45023230f, 0.06077642f, 0.09733643f, 
    0.07230334f, -0.01761222f, -0.00181792f, 0.25830230f, 0.06525043f, 0.09816879f, 0.12541588f, -0.21509211f, 
    -0.03931500f, -0.02554510f, 0.02630347f, 0.06175756f, -0.10913503f, -0.08931457f, 0.17057773f, -0.03674224f, 
    0.27934679f, -0.11805067f, -0.00598028f, 0.01873660f, 0.12500387f, 0.04584016f, 0.00989676f, -0.08587595f, 
    0.06893964f, 0.28790060f, 0.03881810f, -0.00264191f, 0.04173236f, 0.04316744f, 0.02866562f, 0.04667636f, 
    0.05087609f, 0.14058435f, -0.01065685f, -0.10480463f, 0.03006757f, 0.01852022f, 0.00977751f, 0.05906706f, 
    0.27139726f, 0.06119695f, -0.08791488f, -0.12102147f, -0.79576021f, -0.19149478f, -0.31954381f, -0.26746979f, 
    -0.00697663f, -0.04153721f, -0.06372619f, 0.06302744f, 0.05610758f, -0.08724012f, -0.04771546f, -0.02229590f, 
    -0.10280477f, -0.04859379f, -0.16447338f, 0.05430712f, 0.17669328f, -0.06986416f, -0.08237556f, -0.06741027f, 
    0.02998429f, 0.14868230f, 0.00325485f, -0.02523759f, 0.17127904f, 0.24721193f, 0.00800098f, -0.07972316f, 
    0.23655640f, 0.15889639f, -0.05058330f, -0.03202121f, -0.01369851f, 0.04660240f, 0.05847046f, 0.04886220f, 
    -0.30293450f, -0.57134753f, -0.53823698f, -0.17146522f, -0.26758203f, -0.14503662f, -0.13209714f, -0.26192436f, 
    0.03489917f, -0.05436092f, 0.07388102f, -0.03399729f, -0.07493709f, -0.30145860f, -0.43627959f, -0.12326562f, 
    -0.18390846f, 0.04171619f, 0.02978237f, 0.06332329f, 0.03477104f, 0.06131874f, 0.06274308f, -0.01643242f, 
    -0.21132812f, -0.15444371f, -0.33928773f, 0.01543551f, -0.24893671f, 0.07742459f, -0.01273006f, 0.11716812f, 
    0.07130277f, 0.00767259f, 0.02366298f, 0.14009552f, 0.16695750f, 0.01785714f, -0.10856606f, -0.08029672f, 
    0.01706879f, 0.00900062f, 0.05078327f, 0.04426671f, 0.04340915f, 0.07968730f, 0.20929146f, 0.12078653f, 
    0.03814636f, 0.03959090f, -0.02328661f, -0.01422186f, 0.00767987f, 0.06480017f, -0.02388669f, 0.05811865f, 
    -0.04580374f, -0.02198981f, 0.08351082f, 0.05220839f, 0.06371941f, 0.12019936f, -0.24310395f, 0.14997199f, 
    -0.05547677f, 0.05036204f, -0.00416402f, 0.05219448f, -0.07286696f, -0.05714552f, 0.13190655f, 0.11901071f, 
    -0.21039826f, -0.01718020f, -0.02911911f, -0.16949959f, -0.05231621f, 0.05684087f, -0.02024476f, -0.03797015f, 
    0.02164483f, 0.09894124f, 0.17523775f, 0.18977173f, 0.09258817f, 0.18108329f, -0.18880875f, -0.02344997f, 
    -0.09909596f, -0.04643072f, -0.02168845f, 0.15383302f, -0.02243189f, 0.09655515f, 0.17572513f, -0.06044457f, 
    0.18195145f, 0.19472018f, 0.13601334f, 0.24413106f, 0.01098984f, -0.05846777f, 0.03146537f, 0.10474723f, 
    -0.08495799f, 0.03715868f, 0.08274701f, 0.07948188f, -0.12205830f, -0.00002431f, 0.13188185f, 0.17471118f, 
    0.09764626f, -0.12330057f, 0.14189059f, 0.16183186f, 0.04150940f, -0.01949071f, -0.03119427f, 0.20204924f, 
    0.15985242f, 0.00188172f, 0.08127590f, 0.04137065f, 0.05873726f, -0.00034883f, 0.03010130f, -0.20289692f, 
    0.02004743f, -0.05135546f, 0.09757856f, -0.04031095f, 0.09257726f, -0.51376462f, -0.51101333f, -0.22021800f, 
    -0.15427138f, 0.11498863f, 0.19445238f, -0.00949858f, 0.02007839f, -0.00147071f, -0.05295221f, 0.01150746f, 
    -0.18686119f, -0.02636712f, 0.02123352f, -0.10829581f, 0.06484873f, -0.00465227f, -0.06926659f, -0.03833463f, 
    -0.03364032f, 0.00853359f, -0.15510298f, -0.04586006f, 0.12348529f, 0.02689673f, -0.05481226f, -0.22371143f, 
    -0.06326897f, 0.04760149f, -0.04509271f, -0.00010428f, -0.10054375f, 0.09739002f, -0.00668052f, -0.13229758f, 
    0.18785173f, 0.08742738f, 0.16305326f, -0.02871903f, 0.06399503f, -0.02791262f, 0.00142384f, 0.00938070f, 
    0.02453231f, -0.02147464f, 0.09684674f, -0.07879613f, -0.42239934f, 0.13849293f, 0.05974453f, 0.35335493f, 
    0.08177389f, 0.06837607f, 0.13030782f, 0.20325978f, -0.03489916f, 0.12612061f, 0.07885828f, -0.18985899f, 
    0.16328341f, -0.04823563f, -0.01590293f, -0.06051717f, -0.01116446f, 0.07120098f, 0.03313949f, 0.06352726f, 
    0.07042548f, 0.24104740f, 0.15837109f, 0.14770253f, 0.33667964f, -0.03858042f, -0.12232620f, -0.33101189f, 
    0.00234970f, 0.02007759f, 0.05454723f, 0.02856207f, 0.04571426f, 0.01914108f, -0.12568636f, 0.01107901f, 
    -0.31297424f, -0.66878062f, 0.33723921f, -0.31924224f, -0.07950148f, -0.14497951f, -0.20708892f, -0.18648075f, 
    -0.09890728f, 0.04139174f, 0.02771807f, 0.05934197f, -0.16939026f, -0.29398528f, 0.25632671f, -0.19030102f, 
    -0.05753920f, 0.00769553f, 0.03427313f, -0.33657125f, 0.06599632f, -0.06280920f, 0.05626046f, 0.08949949f, 
    -0.19220419f, 0.24247061f, 0.21910560f, -0.14844860f, -0.03792880f, -0.11991086f, -0.00648647f, 0.08137085f, 
    -0.02344994f, 0.15170057f, 0.08026618f, 0.07294196f, -0.03231556f, -0.22352907f, -0.00964429f, 0.13866505f, 
    -0.07864130f, 0.13881066f, 0.00065781f, -0.11401387f, -0.10045387f, 0.04377071f, 0.10676504f, 0.02691953f, 
    -0.16208407f, 0.19037655f, 0.21121246f, -0.15558816f, -0.03465378f, 0.05266351f, -0.01914576f, -0.13767873f, 
    -0.03332122f, 0.07604925f, -0.04552353f, 0.06560445f, -0.38217008f, -0.39287627f, -0.48129511f, 0.11790196f, 
    -0.16649039f, -0.00782195f, -0.15567665f, -0.14157131f, -0.02310329f, 0.04344368f, 0.10308018f, -0.09497874f, 
    -0.04244927f, 0.00840047f, 0.01464888f, 0.05926385f, 0.01562551f, -0.09370795f, 0.03712554f, 0.08474625f, 
    0.03379981f, 0.06170572f, 0.08299545f, 0.06690423f, -0.37903908f, -0.37788057f, -0.10925893f, 0.21879323f, 
    0.17301142f, 0.22018656f, 0.09115390f, 0.00878750f, 0.01934128f, -0.00165201f, -0.03414362f, 0.08486551f, 
    -0.00862414f, 0.05916458f, 0.06298860f, -0.14385180f, 0.01800339f, 0.00606641f, -0.03601885f, 0.01797075f, 
    0.01616986f, 0.02695340f, -0.11681771f, 0.11370920f, -0.47805277f, 0.23897873f, 0.28375798f, 0.03610366f, 
    -0.11586192f, -0.06722815f, -0.02949334f, -0.04509716f, -0.05048090f, 0.11701269f, -0.03153523f, 0.04022418f, 
    -0.16851149f, -0.24284627f, 0.21771215f, 0.25844359f, 0.00534254f, -0.04978429f, 0.03524863f, -0.01435706f, 
    0.05960967f, 0.11544324f, -0.01745775f, -0.02076748f, 0.07250355f, -0.38911974f, -0.21827184f, -0.21034701f, 
    -0.12219755f, 0.14945899f, 0.27124646f, -0.17880102f, 0.05769676f, -0.01642186f, -0.01695698f, 0.03401784f, 
    -0.09778710f, 0.05888699f, 0.01104379f, -0.03603095f, -0.03283029f, 0.19379769f, 0.15976627f, -0.15539274f, 
    0.05867132f, 0.05352031f, 0.07678181f, -0.00930882f, 0.10868702f, 0.07553583f, -0.15179920f, -0.28549975f, 
    0.03183336f, -0.00826388f, 0.04078626f, -0.09671884f, 0.12037870f, -0.06580309f, 0.04107969f, -0.11392522f, 
    -0.14307375f, 0.04967998f, 0.25244400f, 0.11414749f, -0.03983271f, -0.18978921f, -0.03594116f, -0.06502138f, 
    0.08560736f, -0.09602591f, 0.03786665f, 0.06283047f, -0.11521092f, -0.07218180f, 0.09842446f, -0.06651805f, 
    -0.10526409f, -0.07859661f, -0.08578228f, 0.12647459f, -0.09479656f, 0.00926167f, -0.14431526f, -0.10161512f, 
    -0.31928608f, -0.36071476f, -0.49315557f, -0.00360329f, -0.08426487f, 0.00356687f, 0.02840874f, 0.14200747f, 
    0.02048097f, 0.06987181f, 0.07490177f, 0.15367477f, -0.39805657f, -0.44733921f, -0.53943938f, -0.02444450f, 
    -0.24165280f, -0.08773623f, -0.09999318f, -0.30566734f, -0.02744849f, 0.01883980f, -0.01106877f, -0.05970904f, 
    -0.20734924f, -0.04131442f, 0.16055191f, -0.00451623f, -0.04685870f, -0.05265887f, -0.01447428f, -0.07034013f, 
    -0.01424276f, -0.02661298f, 0.03223325f, -0.13223158f, 0.05265235f, 0.11049558f, 0.02815074f, -0.03841730f, 
    0.01840285f, -0.04833392f, 0.02505833f, 0.02880867f, -0.09676412f, -0.05321400f, -0.05592491f, 0.07988288f, 
    0.40032816f, 0.16358006f, -0.10383990f, -0.01116117f, -0.06025374f, 0.06280740f, 0.05467759f, 0.34516799f, 
    0.11311074f, 0.11439716f, 0.00376366f, -0.07003843f, -0.21645059f, -0.43715370f, -0.14283447f, -0.26322189f, 
    0.00609030f, -0.09372890f, -0.02386929f, -0.23111971f, 0.03485778f, -0.03595732f, -0.02959231f, 0.03045103f, 
    -0.04870855f, -0.11539697f, -0.07165089f, -0.13498089f, -0.02904686f, 0.02139291f, 0.00231779f, -0.06911156f, 
    -0.08683441f, 0.02354032f, -0.04442967f, 0.09903767f, -0.16991740f, -0.11847852f, 0.04869963f, 0.22491522f, 
    0.15387268f, 0.05177503f, 0.02463924f, -0.32245073f, 0.02042849f, -0.01466390f, -0.01731735f, 0.05139138f, 
    -0.06353419f, -0.24739350f, -0.18463056f, 0.19002108f, 0.10862491f, -0.00418964f, 0.09366658f, -0.00030004f, 
    0.09220498f, 0.11166774f, -0.11904795f, -0.01385785f, 0.04567563f, -0.06027240f, -0.14792280f, -0.08702176f, 
    -0.01723205f, 0.02160361f, -0.06792220f, -0.00853828f, -0.04340043f, -0.07207820f, -0.03682699f, -0.12394061f, 
    -0.01933242f, -0.10086361f, -0.18860246f, -0.11454498f, 0.05836781f, -0.04701097f, 0.15382181f, 0.02587157f, 
    -0.01865594f, 0.00760039f, -0.04100241f, 0.02945556f, 0.15928520f, -0.03677613f, -0.13020170f, -0.14970586f, 
    -0.11017791f, 0.15064037f, 0.08745936f, -0.04112907f, 0.03746608f, 0.00212521f, 0.03383931f, -0.06233954f, 
    0.11133008f, 0.22842333f, -0.28108314f, 0.00617529f, -0.04444368f, -0.04162895f, 0.18056671f, 0.06979072f, 
    -0.01164533f, 0.12231541f, 0.01421347f, 0.00914206f, -0.55388921f, -0.63123357f, -0.42999753f, -0.35404003f, 
    -0.07234907f, -0.37082702f, -0.15687682f, -0.41173235f, -0.04996986f, 0.00797187f, -0.02595617f, -0.01899119f, 
    -0.14881422f, 0.01110871f, 0.04060353f, -0.23415859f, -0.10940654f, 0.04838137f, -0.06200274f, -0.25676140f, 
    0.18968967f, -0.08047107f, -0.11729904f, -0.00522562f, -0.03536987f, -0.14403583f, 0.57013959f, 0.19368361f, 
    -0.23648907f, -0.35067523f, 0.04815201f, 0.03086397f, -0.04337233f, 0.14715444f, 0.02836674f, -0.29474610f, 
    -0.03935450f, 0.03196092f, -0.00242779f, -0.04346066f, -0.01347653f, -0.00088745f, 0.01003283f, 0.04552086f, 
    0.02522989f, 0.01485510f, 0.03800781f, 0.08222553f, 0.05089135f, 0.13901146f, 0.02738019f, 0.06562535f, 
    0.03614393f, -0.06159979f, -0.04586889f, -0.07330123f, -0.15248682f, -0.12439343f, 0.03081799f, 0.07891306f, 
    0.07679819f, -0.17823987f, -0.17259289f, -0.21729586f, -0.00344776f, -0.02063711f, -0.01175151f, -0.00959526f, 
    -0.04150773f, 0.08790091f, 0.11926043f, 0.08669958f, -0.34317520f, -0.30119976f, 0.01140157f, -0.22020072f, 
    -0.12021963f, 0.17710324f, 0.03800450f, -0.15480977f, 0.05088488f, 0.08776475f, -0.06785081f, 0.13363864f, 
    0.08994211f, 0.01366770f, -0.07099811f, -0.13465238f, 0.03435810f, -0.01568913f, -0.00437213f, -0.02201056f, 
    -0.07467810f, 0.00036775f, -0.15029819f, -0.05637624f, 0.55511361f, 0.33229795f, -0.04448071f, 0.13769694f, 
    0.02267147f, -0.16950145f, 0.07906247f, 0.17168802f, 0.01480403f, -0.06805494f, 0.07817146f, 0.07376778f, 
    0.15227930f, 0.43309525f, 0.19588402f, 0.09106418f, -0.05407381f, 0.01650215f, -0.12113242f, 0.00247417f, 
    0.06735016f, -0.05252104f, 0.06350928f, 0.07120595f, -0.11655522f, -0.01333035f, 0.01498893f, 0.15393034f, 
    0.03223213f, 0.12037312f, 0.15822713f, -0.00026817f, 0.06002678f, -0.00194331f, 0.02913078f, 0.14251414f, 
    -0.16911286f, -0.04589609f, 0.01794802f, 0.02777169f, -0.10259121f, -0.07814818f, -0.08124900f, 0.04760102f, 
    -0.08439089f, -0.15988846f, 0.03445773f, 0.00749766f, -0.00603459f, -0.26918614f, -0.25919351f, -0.21778202f, 
    -0.12793353f, 0.03930074f, 0.09316181f, -0.12343570f, -0.02111839f, 0.03661317f, -0.08471800f, -0.11120677f, 
    -0.58730900f, 0.01701495f, 0.13561550f, -0.23019320f, -0.16448522f, -0.06514449f, -0.17769428f, -0.02275828f, 
    -0.08545644f, -0.00916725f, 0.01622009f, -0.02328142f, -0.39925155f, 0.03187978f, 0.35707685f, 0.21171166f, 
    -0.03827772f, -0.10181896f, 0.09336989f, 0.07481126f, -0.01715545f, 0.02413770f, 0.06616440f, 0.02664104f, 
    0.00441017f, 0.10161990f, 0.02832462f, -0.04318670f, -0.00589100f, 0.03067138f, -0.04030356f, -0.05552217f, 
    0.16984433f, -0.10359290f, 0.20343868f, -0.16510177f, -0.52910727f, -0.58376908f, -0.42623845f, -0.17755145f, 
    -0.09520320f, -0.18531634f, 0.01705522f, -0.32971641f, 0.00802884f, -0.01733140f, -0.02643257f, 0.03609759f, 
    -0.27793324f, 0.23766673f, -0.18982838f, 0.29051507f, 0.11763930f, 0.10110826f, 0.22792058f, -0.03161458f, 
    -0.01706871f, -0.02821314f, -0.02149826f, -0.04009718f, -0.54621822f, -0.17930587f, -0.19736899f, -0.14004628f, 
    0.15673327f, -0.08959492f, 0.22376367f, -0.04484303f, -0.00563563f, 0.04519905f, -0.08214954f, -0.02844491f, 
    -0.25199342f, -0.05056445f, -0.00678214f, -0.01735333f, 0.05963339f, 0.09095299f, 0.07370408f, -0.04656474f, 
    0.04142324f, -0.09463507f, -0.02872805f, 0.07808638f, 0.08300696f, -0.16158059f, 0.25932476f, 0.02518420f, 
    -0.01855907f, -0.06386219f, -0.11426117f, -0.04139330f, 0.02096323f, 0.02874045f, 0.06695216f, 0.03518092f, 
    0.05959817f, -0.04249249f, 0.04928095f, -0.06584678f, -0.01662203f, -0.08476648f, -0.03185648f, -0.02784127f, 
    0.00054214f, -0.01664957f, 0.00891874f, -0.01771105f, -0.01754172f, 0.13113335f, 0.15623848f, 0.12029804f, 
    0.09483299f, 0.07475412f, -0.05558270f, -0.20557886f, 0.03875612f, 0.03780572f, -0.07123537f, 0.08533360f, 
    0.09966527f, -0.40426669f, -0.16534720f, -0.26263788f, -0.13721855f, -0.14924480f, -0.03408424f, 0.08353545f, 
    0.04412663f, -0.00662661f, -0.04609336f, 0.04663540f, 0.37006739f, -0.40523684f, -0.51791137f, 0.05505411f, 
    -0.04804296f, -0.13362652f, -0.02208237f, -0.01876542f, 0.16138178f, -0.03059529f, -0.10805104f, -0.00580314f, 
    -0.24144676f, -0.26494223f, -0.18529736f, -0.11846233f, -0.06000556f, 0.03053889f, -0.00543020f, -0.03568277f, 
    0.01893812f, -0.11654226f, 0.04565150f, -0.06735922f, -0.04864735f, -0.02061800f, 0.08773898f, -0.04977048f, 
    -0.08269646f, -0.04900306f, -0.05962858f, -0.14126098f, -0.14684495f, -0.00459467f, -0.04727784f, -0.10706849f, 
    0.02357246f, 0.08265480f, 0.11887173f, -0.01865338f, 0.00565629f, 0.08372889f, 0.00654677f, -0.03321411f, 
    -0.13067636f, -0.00988427f, -0.07229146f, 0.00927455f, -0.35289797f, -0.31657660f, 0.00349442f, -0.03567285f, 
    0.00010020f, -0.01020200f, -0.04506013f, -0.06762286f, 0.01482384f, 0.01229769f, 0.00225859f, -0.01284424f, 
    0.00823672f, 0.06790431f, 0.05393411f, -0.05251534f, -0.01017088f, 0.00692326f, 0.05514701f, -0.04881278f, 
    -0.00577818f, -0.05791815f, -0.01509919f, -0.10379316f, -0.10776050f, -0.05676090f, -0.04625215f, 0.03474578f, 
    0.01530240f, 0.02685487f, -0.01907899f, -0.03272474f, 0.07886923f, -0.11298905f, -0.01525508f, -0.03754928f, 
    -0.16494824f, 0.17395991f, 0.08435301f, 0.05636092f, -0.21288319f, 0.11790016f, 0.02801196f, 0.01838159f, 
    -0.17677923f, 0.02347851f, -0.10326502f, -0.01092928f, -0.21263635f, -0.16285627f, 0.40500391f, -0.03957662f, 
    -0.02274462f, 0.08645152f, 0.10058691f, -0.02695962f, 0.10427645f, -0.03636041f, -0.07033204f, -0.06816076f, 
    -0.07241840f, 0.03765769f, 0.05538180f, 0.01152296f, -0.02487849f, 0.01983122f, 0.08462182f, -0.09680005f, 
    0.10165087f, 0.04268547f, -0.02148911f, -0.04076834f, -0.18592840f, 0.12712932f, -0.02279601f, 0.04705232f, 
    -0.15078802f, -0.02781218f, 0.01766556f, 0.10861639f, 0.01554139f, -0.11907211f, 0.08820157f, -0.02672267f, 
    0.34932616f, -0.40271434f, -0.05894491f, -0.31231916f, -0.07631277f, -0.06594113f, -0.11630715f, 0.18418272f, 
    0.04371548f, 0.02849378f, -0.03107137f, 0.16240720f, -0.28768352f, 0.63780409f, -0.16987862f, 0.16426428f, 
    0.05902067f, -0.10584572f, 0.18077764f, 0.13966338f, -0.12410202f, 0.07430871f, 0.14698882f, 0.10892717f, 
    0.08044758f, -0.01283022f, 0.14442949f, -0.13925155f, -0.02753924f, 0.02633596f, -0.00117003f, -0.07115608f, 
    -0.01520157f, 0.11462127f, -0.03835358f, 0.07576896f, 0.25940588f, -0.20101346f, 0.02516577f, -0.00175582f, 
    0.03317077f, -0.01067904f, 0.00465487f, -0.03657469f, -0.10636971f, 0.12879118f, -0.03997428f, -0.07395554f, 
    -0.39347515f, -0.38734287f, -0.08885227f, -0.04235874f, -0.00719345f, -0.07481584f, 0.06175617f, 0.05637948f, 
    0.04208253f, 0.01701335f, 0.01400006f, 0.01588614f, 0.65402538f, -0.81041741f, 0.31988162f, -0.17603719f, 
    -0.03912789f, 0.20811135f, -0.10617860f, 0.06036117f, -0.06490547f, -0.00985569f, -0.12594306f, -0.05108278f, 
    0.08085495f, -0.01002419f, -0.06204985f, -0.14712732f, 0.02969352f, 0.01191216f, 0.02330464f, -0.02934122f, 
    -0.03429803f, -0.12717582f, -0.10283285f, -0.16824283f, 0.06277035f, 0.03615241f, -0.08174015f, -0.06555779f, 
    -0.06541765f, -0.09194799f, 0.07552816f, 0.03013726f, 0.02457233f, 0.04462649f, 0.02161104f, -0.00578111f, 
    -0.05371578f, 0.06770609f, -0.04860679f, 0.00006513f, -0.04439316f, -0.02404209f, -0.03815446f, 0.00170044f, 
    -0.05327163f, 0.02614161f, -0.10606313f, -0.15940836f, 0.29583263f, 0.04735903f, -0.04981532f, -0.11081370f, 
    0.03574560f, 0.01722574f, -0.07450225f, -0.08265242f, 0.01679570f, 0.03314043f, 0.01075957f, 0.03327930f, 
    0.53935027f, -0.80919331f, -0.17952791f, -0.20658550f, -0.01035829f, 0.15295921f, -0.15428019f, -0.09913666f, 
    0.16021056f, 0.02507862f, 0.06662008f, 0.04429644f, -0.08501729f, 0.18996418f, -0.20701317f, -0.00738862f, 
    0.02926369f, -0.03765139f, 0.04031192f, 0.04837988f, -0.03089478f, 0.05978042f, 0.06188852f, 0.01925004f, 
    0.05020529f, 0.05214514f, 0.04419679f, -0.01022873f, -0.02405403f, 0.03728815f, -0.00229597f, 0.02500434f, 
    0.00882457f, -0.07904716f, -0.03956398f, 0.05216419f, -0.10129884f, -0.01643468f, 0.18077828f, -0.04930232f, 
    0.01981128f, 0.01709400f, 0.01275160f, -0.00774783f, 0.05370584f, -0.04272720f, 0.08001107f, -0.01512910f, 
    0.09506682f, 0.02950327f, -0.27703023f, -0.18139501f, 0.01436354f, 0.08097070f, 0.05932535f, 0.01402938f, 
    -0.07922229f, -0.00327815f, 0.10062402f, 0.02703181f, 0.05064190f, -0.05801338f, -0.03183801f, 0.00963006f, 
    -0.06517500f, -0.09836677f, -0.02806056f, -0.01590605f, -0.03649762f, -0.02108071f, 0.01100061f, 0.03750944f, 
    -0.03876599f, -0.78919482f, 0.33143196f, -0.26542455f, -0.13205376f, -0.09357361f, -0.06665631f, -0.06626243f, 
    -0.04505362f, 0.01126250f, -0.00384242f, -0.01333173f, 0.04288870f, -0.36608168f, 0.12196464f, 0.11540012f, 
    -0.02644112f, -0.05496074f, -0.04957192f, 0.21787842f, 0.01540680f, -0.02268688f, -0.05654735f, -0.03565336f, 
    0.15534467f, 0.14674793f, -0.03628665f, -0.16491091f, 0.00333587f, 0.12050425f, 0.03613104f, -0.02823915f, 
    -0.08689781f, -0.05324137f, -0.07949125f, 0.00588263f, -0.03841529f, 0.05080424f, -0.05519560f, -0.00635490f, 
    -0.00325105f, 0.01541564f, 0.00834069f, -0.00926440f, -0.07961172f, -0.26282451f, 0.11815918f, -0.02059028f, 
    -0.11223708f, 0.08268527f, -0.12902710f, 0.08982121f, -0.29670766f, 0.08924908f, 0.06867934f, -0.12572873f, 
    0.02139697f, -0.01983286f, -0.00269657f, 0.05344684f, -0.47106510f, 0.61875355f, 0.01425162f, 0.52322340f, 
    0.07728962f, 0.00978382f, 0.09906051f, -0.01945358f, -0.01330345f, -0.05733456f, -0.07675383f, -0.06676711f, 
    -0.06713454f, 0.10718709f, -0.17684098f, -0.12881245f, 0.04366444f, -0.02695318f, -0.03893453f, -0.07260340f, 
    0.06682199f, -0.01491138f, 0.01504816f, -0.01670591f, -0.18796228f, 0.18250464f, 0.16499282f, -0.12402134f, 
    -0.03028836f, -0.10035758f, 0.09763980f, 0.12880065f, 0.00897106f, -0.03702992f, 0.00905612f, -0.07056378f, 
    0.16135322f, -0.03417908f, 0.19197601f, -0.10282347f, 0.05674884f, 0.03138568f, 0.00414600f, 0.02861305f, 
    -0.05225943f, -0.08098349f, -0.01670639f, -0.00971603f, 0.07199425f, -0.06534555f, 0.05174007f, -0.04461917f, 
    -0.04450240f, -0.01757841f, -0.04734700f, -0.01852527f, 0.08057510f, -0.02024442f, 0.00876885f, 0.01305838f, 
    0.05806632f, 0.05313141f, 0.00508003f, -0.01745727f, -0.07040049f, 0.08663019f, -0.02100767f, 0.00133780f, 
    -0.00092635f, -0.01248937f, 0.00443125f, 0.02528908f, 0.00945946f, 0.01544923f, 0.03705681f, -0.06829748f, 
    -0.04532656f, 0.02702752f, -0.08139072f, 0.00746630f, 0.01606497f, 0.03075405f, 0.02564156f, 0.03715090f, 
    0.09994695f, -0.21195081f, 0.06587750f, -0.02721097f, 0.08391565f, 0.01050387f, 0.02058762f, -0.18809016f, 
    -0.11598200f, 0.04505255f, -0.04002637f, 0.06481807f, -0.42367002f, -0.50324500f, -0.38173419f, 0.09012394f, 
    0.06166542f, 0.06243963f, -0.10514967f, 0.04915334f, 0.01250727f, 0.06092104f, 0.01465673f, 0.03136254f, 
    -0.20502073f, -0.18516891f, 0.15224378f, 0.06338283f, 0.16915219f, 0.08876832f, 0.08560877f, 0.16082998f, 
    0.06516207f, -0.06788198f, 0.12546402f, 0.06632183f, 0.08546115f, 0.09354918f, 0.05894765f, -0.03248455f, 
    -0.19785637f, 0.16002065f, 0.10030564f, 0.11184891f, -0.04818116f, -0.13268012f, 0.10358131f, 0.02222480f, 
    0.07707318f, 0.07541371f, -0.00767198f, 0.03452856f, 0.02057968f, -0.05261102f, -0.06416046f, -0.02948290f, 
    0.11914386f, 0.07423201f, 0.00961599f, -0.06981044f, 0.10036483f, -0.11559904f, 0.02221551f, -0.15474269f, 
    0.02258524f, -0.01893608f, 0.00565831f, -0.00722258f, -0.11839304f, -0.12043737f, -0.10949634f, -0.10758717f, 
    0.36846545f, -0.46800959f, -0.14132391f, -0.27505094f, 0.02333422f, -0.12034425f, 0.01098259f, 0.07253868f, 
    -0.01950255f, 0.03970094f, 0.02790176f, -0.05931712f, -0.28861985f, -0.28767794f, -0.22573172f, -0.04392540f, 
    0.13238922f, 0.16068502f, -0.00697194f, 0.04740335f, 0.03766860f, -0.01904177f, -0.05767754f, -0.01186188f, 
    0.02878282f, 0.05663814f, -0.01084244f, -0.00717515f, 0.03329429f, -0.01761530f, 0.00758634f, -0.02766800f, 
    0.03043165f, 0.03495884f, -0.02754474f, -0.04777368f, -0.17068599f, 0.03999719f, -0.09831794f, 0.05669668f, 
    -0.04805810f, 0.05035573f, 0.07747312f, -0.05614886f, -0.12366375f, -0.03784867f, 0.01577875f, -0.00974071f, 
    -0.16163258f, -0.22601472f, -0.22620879f, -0.11838401f, -0.07572344f, 0.02454754f, 0.01416166f, 0.13153160f, 
    0.07553443f, -0.01882764f, 0.01335294f, 0.08960577f, -0.03011584f, -0.01815854f, -0.04950025f, -0.11313028f, 
    -0.01148401f, -0.10569740f, -0.01528230f, -0.06933239f, -0.16641153f, 0.04728579f, 0.00372844f, -0.04063131f, 
    0.14014547f, -0.03401762f, -0.01100920f, -0.07180515f, 0.05381617f, 0.02731141f, 0.01800273f, -0.06080228f, 
    -0.11792462f, -0.00762176f, 0.00579145f, 0.00622568f, -0.26254565f, -0.03271493f, 0.10617689f, 0.22067133f, 
    -0.14093918f, -0.10067314f, -0.11991016f, -0.19653422f, 0.01189009f, -0.02335946f, -0.02913106f, 0.00423703f, 
    0.67273432f, -0.53773314f, -0.15983875f, -0.37181735f, -0.01690630f, -0.10890514f, -0.11476504f, -0.03647618f, 
    -0.01270055f, 0.08795297f, 0.04454339f, 0.01392763f, 0.50339329f, -0.62708431f, -0.49191600f, -0.16465986f, 
    -0.11035344f, 0.06790998f, -0.28891733f, 0.06386014f, 0.11256787f, 0.04987941f, 0.02762509f, -0.01167937f, 
    0.01232468f, 0.00422040f, -0.00822716f, -0.05616552f, 0.03457918f, 0.00262264f, 0.03842257f, -0.05187075f, 
    -0.04087786f, -0.11610673f, -0.15593609f, -0.11092856f, -0.31683761f, -0.20273259f, -0.13095972f, -0.15535095f, 
    0.08619333f, -0.07365626f, 0.00273703f, 0.13893944f, 0.03282254f, 0.01622147f, -0.05388780f, -0.00309106f, 
    -0.43313634f, -0.43714672f, -0.44711083f, -0.37586063f, -0.09238096f, -0.04266611f, -0.11724978f, -0.18957412f, 
    0.00255495f, 0.04852826f, 0.04593112f, -0.02221707f, 0.21108638f, -0.18736956f, -0.24357036f, -0.02388377f, 
    -0.17798777f, 0.09042812f, 0.14414065f, 0.03360427f, -0.04894038f, -0.06986682f, 0.02232951f, -0.17112394f, 
    0.00195883f, -0.07851208f, -0.06976955f, 0.17074011f, 0.09642293f, 0.15359069f, 0.08006816f, -0.01633003f, 
    0.01981745f, -0.00715090f, -0.10897952f, 0.02744154f, 0.19390564f, -0.04875477f, -0.12623797f, -0.06665263f, 
    0.08275375f, 0.03198115f, -0.04872900f, 0.05051110f, 0.11915031f, -0.05172433f, -0.08308808f, -0.16192287f, 
    -0.05671448f, 0.08790833f, 0.00926279f, -0.22929360f, -0.03233809f, -0.07832909f, 0.01280674f, -0.05515307f, 
    -0.02776809f, -0.03323478f, -0.15277360f, -0.09118029f, 0.21637051f, 0.36767626f, 0.32369152f, 0.14239821f, 
    0.07100961f, -0.03490964f, 0.01894241f, 0.03306303f, 0.08379426f, -0.03813778f, 0.05068299f, -0.06451418f, 
    0.02492854f, -0.42864272f, 0.05076642f, -0.00083979f, 0.07410908f, 0.09220468f, 0.11325556f, -0.00026929f, 
    -0.05530746f, -0.13966841f, -0.08026146f, -0.33514979f, 0.08789053f, -0.27188957f, -0.01244551f, -0.12210569f, 
    0.13421254f, 0.11645521f, 0.04688991f, -0.02264755f, -0.06804875f, -0.08040687f, -0.07999535f, -0.21642031f, 
    -0.36334655f, -0.37222061f, 0.02058940f, 0.30003610f, 0.06767760f, 0.08227811f, 0.11180302f, 0.05900571f, 
    0.05206545f, -0.00132691f, 0.00755853f, -0.08868931f, 0.10588554f, 0.04737763f, 0.01547001f, 0.05281747f, 
    0.00370066f, 0.02735088f, 0.06327171f, 0.12691355f, -0.03275636f, 0.02889221f, 0.13972238f, 0.08270536f, 
    -0.28913933f, -0.01154063f, 0.04804955f, 0.01545317f, -0.04416224f, -0.00162593f, -0.05156156f, -0.02720163f, 
    -0.03857186f, -0.02622613f, 0.06926802f, 0.15252025f, -0.16448350f, 0.06789784f, 0.20826799f, 0.13434508f, 
    0.07559464f, -0.06104833f, -0.12066524f, -0.24258463f, 0.00135262f, 0.04899037f, -0.02275310f, -0.01531358f, 
    -0.03653213f, -0.02620351f, -0.09776039f, -0.12542805f, -0.08991092f, -0.05977426f, 0.01684911f, -0.02176138f, 
    0.09907072f, 0.07589345f, -0.03763518f, 0.06233121f, -0.11780850f, 0.18277596f, -0.01678258f, 0.06774271f, 
    -0.02842330f, -0.02291464f, -0.02928916f, 0.02058211f, 0.01916024f, 0.01399819f, -0.05320421f, 0.16930483f, 
    -0.43139413f, 0.09780357f, 0.17486916f, 0.17765722f, 0.08591869f, -0.03776664f, -0.08033931f, 0.06821069f, 
    0.05860965f, -0.01014447f, 0.10943684f, -0.03143917f, -0.07377119f, -0.30677181f, 0.10603466f, 0.19374663f, 
    -0.02137134f, -0.08698182f, 0.16972919f, 0.03712775f, 0.01851463f, -0.05692584f, 0.10458357f, 0.07336415f, 
    -0.28277868f, 0.10551195f, 0.06785946f, 0.08775940f, 0.07317760f, 0.01105752f, -0.02063812f, -0.06807216f, 
    -0.15026389f, 0.09815921f, -0.14703354f, -0.11250698f, -0.24209657f, 0.07990374f, 0.00891236f, 0.07729602f, 
    0.08232156f, -0.08228014f, -0.06070750f, 0.17803814f, 0.00578924f, -0.07339906f, 0.00629989f, -0.13995157f, 
    0.07456961f, -0.16606534f, -0.60432255f, -0.08708517f, -0.06164971f, 0.08350180f, 0.22564885f, -0.05218506f, 
    -0.01533661f, -0.09073973f, -0.01372890f, 0.09642911f, -0.20378956f, -0.16680171f, -0.12794173f, 0.23776560f, 
    -0.07373845f, 0.09816109f, -0.10309702f, -0.29297465f, 0.00884625f, -0.05323992f, 0.06710195f, 0.02049817f, 
    -0.09476921f, -0.11830308f, -0.11757291f, -0.14091153f, -0.09152559f, 0.07601292f, 0.05013177f, 0.01145584f, 
    0.02338106f, 0.11340783f, -0.03699059f, -0.02364928f, 0.36210784f, 0.17361689f, -0.20797290f, -0.16676949f, 
    0.16852310f, -0.00268620f, -0.08242929f, 0.04010914f, -0.10322906f, -0.06518743f, 0.15606739f, 0.19128057f, 
    0.06528893f, -0.03423855f, -0.12515236f, 0.03066339f, -0.03492137f, 0.05500416f, 0.04595327f, -0.00140719f, 
    -0.28284422f, -0.05462441f, -0.22388558f, -0.20962337f, 0.45207140f, 0.31650347f, -0.23889624f, -0.25443435f, 
    0.01215974f, -0.16812655f, 0.01107018f, -0.21538337f, 0.03151070f, 0.07218255f, -0.04915244f, 0.14518219f, 
    -0.02572854f, 0.00496783f, -0.03455789f, 0.00287313f, -0.03999874f, -0.05783836f, 0.03744466f, -0.04535663f, 
    0.19648966f, 0.09569503f, 0.06817088f, 0.13870642f, -0.07784998f, 0.08529150f, 0.01466530f, -0.18380775f, 
    -0.17373207f, 0.06100362f, -0.00083945f, -0.16629450f, -0.07749343f, 0.03365611f, -0.13436903f, -0.02105877f, 
    -0.01083094f, -0.13134472f, 0.00291602f, 0.01141568f, -0.04260467f, -0.02912555f, 0.09837621f, 0.01119772f, 
    0.07187771f, -0.00315973f, 0.12387510f, 0.10883567f, 0.00137491f, -0.15120636f, -0.14034292f, -0.07472962f, 
    -0.05540040f, 0.13533054f, 0.06841225f, 0.08698912f, 0.20703597f, -0.01376511f, -0.00772301f, -0.01249736f, 
    -0.43673307f, -0.42998102f, -0.35595647f, 0.34981295f, 0.16195919f, 0.11855871f, 0.08235488f, 0.13955557f, 
    0.11888365f, 0.02424569f, -0.03681148f, -0.07892118f, -0.38256085f, 0.06571784f, 0.13535534f, 0.06578932f, 
    0.13285838f, 0.00212574f, -0.36999169f, -0.21389049f, -0.09536765f, -0.00447988f, -0.05421114f, -0.07332904f, 
    -0.02372121f, -0.09459424f, -0.11715981f, -0.04711176f, 0.01680476f, 0.04677990f, 0.04451488f, -0.02179813f, 
    0.09766823f, -0.22344178f, -0.25775665f, -0.17959450f, -0.71782809f, 0.06586022f, 0.19067478f, 0.11791036f, 
    -0.12937833f, -0.13068523f, -0.07788585f, -0.06305236f, -0.12778783f, 0.12719975f, -0.09966788f, 0.05296736f, 
    -0.17427926f, -0.02458357f, -0.01416011f, 0.16095950f, -0.01445282f, 0.13948825f, 0.07842366f, 0.05816378f, 
    0.11150651f, 0.12186670f, 0.15419406f, 0.09655751f, 0.03679559f, -0.08610330f, -0.05190380f, -0.01911884f, 
    0.01993317f, -0.05207615f, 0.03325605f, 0.06496251f, 0.02035418f, 0.07125138f, 0.01355563f, 0.09176816f, 
    0.52764016f, -0.30072138f, -0.13861069f, -0.33363649f, 0.14737001f, 0.05523328f, 0.11650245f, -0.03202321f, 
    0.11172927f, -0.12699115f, -0.09683257f, -0.30302501f, 0.14623009f, -0.05347506f, -0.42710236f, -0.31510755f, 
    -0.00515609f, -0.23620483f, 0.02506485f, -0.18802342f, -0.02925382f, 0.01934856f, -0.03646773f, 0.03176068f, 
    0.11598800f, -0.07760398f, -0.17784727f, -0.22408596f, -0.19921920f, -0.09468730f, 0.09005531f, -0.06330598f, 
    0.12336056f, 0.03219539f, 0.08756516f, 0.09111304f, -0.14440764f, 0.05919268f, 0.00940447f, 0.03220967f, 
    -0.04991654f, 0.03627795f, -0.01298238f, -0.01787955f, 0.01398561f, 0.11005459f, -0.07156586f, 0.10987733f, 
    -0.19601905f, -0.01680396f, -0.00917361f, 0.07410729f, 0.09707944f, 0.17739724f, -0.14673646f, 0.10196853f, 
    -0.10763580f, -0.06247528f, 0.04947469f, -0.02573022f, -0.40113437f, -0.33716366f, -0.16717800f, 0.06322616f, 
    -0.11267403f, -0.00398300f, -0.15627824f, -0.14820418f, 0.00674830f, 0.08377109f, 0.11542425f, 0.09961478f, 
    -0.00712445f, 0.09993592f, 0.06208879f, 0.07128606f, -0.03793163f, -0.05137565f, -0.03206931f, 0.01339511f, 
    -0.06167216f, 0.01051068f, -0.04740439f, 0.01229907f, -0.22146231f, -0.01420540f, 0.13922788f, 0.21148872f, 
    -0.12473025f, 0.04362662f, -0.08619477f, -0.14026763f, 0.00594343f, 0.06743439f, -0.03084153f, 0.00601718f, 
    -0.01950746f, -0.17361498f, 0.11073198f, 0.32398000f, -0.01262763f, -0.00194262f, -0.02912833f, 0.05000041f, 
    0.04512955f, 0.06948210f, 0.06126318f, 0.10153536f, -0.18006514f, 0.16000333f, 0.06428575f, -0.09309938f, 
    0.03127975f, -0.07904637f, 0.03015360f, -0.02557498f, -0.07825886f, -0.00756957f, 0.00727046f, -0.00338245f, 
    -0.09712581f, -0.03761078f, 0.08857919f, 0.13339782f, -0.05158880f, -0.03680560f, -0.10682197f, 0.02102793f, 
    0.09497260f, 0.15451650f, 0.09617951f, 0.09210098f, -0.33152854f, 0.13925652f, 0.05958908f, 0.15694454f, 
    0.05091595f, -0.06265441f, -0.12205046f, 0.11203001f, -0.07755714f, -0.00960733f, 0.00093699f, -0.09620401f, 
    0.29368013f, 0.14059973f, -0.00467886f, -0.19784388f, -0.00759114f, 0.00707018f, 0.01478883f, -0.14396855f, 
    0.13546123f, 0.00757229f, -0.13200733f, 0.14291647f, -0.11835726f, -0.39013726f, -0.18691507f, 0.07892706f, 
    0.09087615f, -0.01786316f, -0.05174761f, 0.01620001f, -0.03877961f, -0.00212175f, 0.02184209f, 0.10039515f, 
    -0.04891085f, -0.17703830f, -0.25146160f, -0.15804991f, -0.21345517f, -0.05810855f, 0.05954632f, 0.00360168f, 
    0.06100897f, 0.17638701f, -0.08695178f, -0.09963533f, -0.02422312f, -0.08323024f, -0.15242337f, 0.17196384f, 
    -0.03987717f, 0.02877979f, 0.00263774f, 0.10454006f, 0.12769179f, 0.07085332f, 0.10907508f, 0.01778292f, 
    -0.15577121f, -0.10951110f, -0.01332186f, -0.08040864f, -0.03486260f, -0.10759529f, -0.06812820f, -0.04121862f, 
    -0.02493044f, 0.01024462f, -0.21918774f, -0.20088226f, -0.15370281f, -0.05967560f, 0.05943926f, -0.01946246f, 
    -0.03363229f, -0.07639644f, 0.04263221f, 0.02678148f, -0.02074200f, 0.08042406f, 0.06715439f, 0.04450466f, 
    0.10885179f, 0.02775259f, -0.28172335f, -0.26860425f, -0.03365392f, 0.03045457f, -0.04008995f, 0.02041329f, 
    0.03860984f, 0.00359233f, -0.00152862f, -0.00785106f, -0.00415994f, -0.19716752f, -0.15404592f, 0.11430182f, 
    0.12508501f, 0.10737813f, 0.00535922f, 0.06268937f, -0.16234733f, -0.12008274f, -0.11857934f, -0.10512838f, 
    -0.13904724f, 0.08234543f, 0.00609107f, 0.00397116f, -0.08914133f, -0.00077147f, 0.03710685f, -0.02760232f, 
    -0.00924323f, -0.04002948f, 0.03215559f, 0.01566421f, -0.72981727f, -0.15034275f, 0.15878376f, 0.12937097f, 
    0.10699270f, 0.05446425f, 0.00987002f, 0.01672524f, 0.00296320f, 0.13457628f, 0.14895289f, 0.16114436f, 
    -0.33036163f, -0.17892234f, 0.12179141f, 0.17358944f, -0.02023100f, 0.08857115f, 0.02830128f, 0.06690022f, 
    0.00466334f, 0.02690058f, -0.02871618f, -0.01717715f, 0.13272144f, 0.27099779f, -0.02614027f, -0.02155044f, 
    0.03857380f, 0.08896217f, -0.09362971f, 0.00838394f, -0.02737473f, -0.07762763f, -0.13888025f, -0.11289565f, 
    0.09940746f, -0.03640750f, -0.01809849f, -0.08733679f, -0.05816328f, -0.02944527f, -0.03183220f, -0.02371334f, 
    0.01966667f, 0.12558724f, 0.05216530f, 0.09649884f, 0.12678558f, -0.01539605f, -0.07117570f, 0.02879885f, 
    0.04392682f, -0.16786002f, -0.13977316f, 0.00653128f, 0.14778088f, 0.14822575f, 0.14849865f, 0.03091621f, 
    -0.09536665f, -0.55401045f, -0.44300276f, -0.40919539f, -0.01020973f, 0.09147789f, 0.10132197f, 0.07925156f, 
    -0.01077949f, -0.00813667f, -0.05679625f, 0.00924587f, -0.25671729f, -0.30777147f, -0.15365760f, 0.30059761f, 
    -0.10262100f, 0.13360722f, 0.10618675f, 0.11580589f, 0.01557061f, 0.02928268f, -0.06933289f, 0.00894888f, 
    -0.21474260f, 0.05189895f, 0.01271529f, -0.01816303f, -0.06665470f, -0.00060401f, 0.06593898f, 0.01277996f, 
    0.19883458f, 0.02921963f, -0.00045453f, 0.10738824f, -0.14681754f, -0.28622091f, -0.21608600f, 0.01287841f, 
    -0.16425224f, -0.08513147f, 0.16649227f, -0.08447325f, 0.01847300f, -0.05796387f, 0.00878311f, 0.03739517f, 
    -0.22175826f, 0.14028694f, 0.03934969f, -0.26705056f, -0.05053625f, 0.01501435f, 0.09319089f, 0.14911625f, 
    0.00594614f, 0.07561934f, -0.01232919f, 0.01778536f, 0.06834831f, -0.03845853f, 0.12876849f, 0.32579929f, 
    0.04836952f, -0.16653080f, 0.00178314f, 0.12330955f, 0.04601549f, 0.07966485f, -0.02924279f, 0.01879420f, 
    0.01849240f, -0.12706238f, -0.16710602f, 0.03311583f, 0.06660844f, -0.10037348f, 0.06376845f, -0.17203158f, 
    0.08236351f, 0.05473242f, 0.01985553f, 0.11265634f, 0.07147548f, -0.13758531f, -0.05673502f, -0.16737652f, 
    0.03979389f, 0.01505237f, -0.02456286f, -0.03347044f, -0.01365340f, 0.18530370f, 0.08859386f, 0.12745880f, 
    0.07696111f, -0.07252009f, -0.01806669f, 0.10742003f, 0.09863049f, 0.04270777f, 0.10488676f, 0.01524827f, 
    0.03679862f, 0.03842179f, 0.12166194f, -0.03087898f, -0.10109735f, -0.30446374f, -0.36765650f, 0.01275759f, 
    0.07091833f, -0.02685452f, 0.03714376f, 0.00661314f, 0.01867702f, -0.01505144f, 0.10725801f, 0.10596224f, 
    0.06314884f, -0.02688762f, 0.00694756f, 0.10490089f, 0.00082757f, -0.02768478f, 0.00781014f, 0.00473710f, 
    0.01749638f, -0.02469042f, 0.03794696f, 0.15780802f, -0.33301464f, 0.16856831f, 0.29478720f, -0.01084738f, 
    0.03524394f, -0.14189221f, -0.02282875f, -0.03700379f, -0.01787389f, 0.07941110f, 0.14888115f, 0.08701126f, 
    0.19082263f, 0.22318329f, 0.50102448f, -0.59131348f, -0.11646838f, -0.18520570f, -0.08560335f, -0.07647868f, 
    -0.07668360f, 0.08212603f, -0.02116408f, 0.10533636f, -0.15994501f, -0.20876119f, 0.03494034f, -0.23024976f, 
    0.01590582f, 0.07623490f, 0.05279666f, -0.17595665f, -0.05672653f, -0.04703058f, -0.13635041f, 0.03106261f, 
    0.03600253f, -0.25408804f, -0.06569817f, -0.25927496f, -0.02007018f, 0.05235514f, -0.01908598f, 0.18415684f, 
    -0.07718863f, -0.17150579f, 0.09115219f, 0.04608982f, 0.17591578f, -0.16995583f, -0.21025789f, 0.13315248f, 
    0.09913923f, 0.06346795f, 0.10925161f, -0.07874636f, -0.07056077f, -0.02887129f, 0.01350561f, -0.01972676f, 
    -0.01461827f, -0.41883126f, 0.11248749f, 0.23730026f, 0.18032913f, 0.14426839f, -0.07194382f, 0.02801823f, 
    0.04227650f, 0.00279602f, -0.05089428f, -0.11591168f, -0.21660949f, 0.05187165f, -0.09695428f, 0.01314909f, 
    0.06788661f, -0.13616522f, 0.06888843f, -0.13479488f, 0.11674017f, -0.04325973f, -0.10705952f, -0.02416385f, 
    -0.26574701f, -0.00766930f, -0.30281428f, -0.09879839f, -0.22145337f, -0.01315565f, 0.17271334f, 0.12436467f, 
    -0.04976467f, 0.01977394f, 0.04767203f, -0.06376230f, 0.38430908f, -0.66067672f, 0.48166147f, -0.57928926f, 
    -0.07331147f, -0.10383136f, -0.06662355f, -0.05009120f, -0.05799539f, -0.03178703f, -0.09299816f, 0.08625355f, 
    -0.02791377f, 0.00748941f, -0.09917548f, 0.05676999f, -0.02937714f, -0.04607338f, 0.02120669f, 0.10022590f, 
    0.06953735f, 0.04767039f, 0.05546215f, 0.02610597f, 0.08740968f, 0.39037445f, -0.48613718f, -0.07343920f, 
    -0.11494146f, -0.07093263f, 0.17855294f, 0.12745273f, -0.00246218f, -0.01877020f, -0.06218400f, -0.07380423f, 
    -0.29198942f, 0.06428291f, -0.45703718f, 0.14118852f, -0.17638499f, 0.14437161f, -0.25551936f, 0.09512299f, 
    0.05656705f, -0.12570125f, 0.07897298f, 0.02843441f, -0.22910218f, 0.03968814f, -0.08827427f, -0.33025330f, 
    0.10994321f, -0.05673794f, 0.23046994f, 0.18682137f, 0.02855945f, 0.02095485f, -0.06908454f, 0.09191859f, 
    0.22483708f, -0.03011919f, 0.05949338f, 0.27289066f, -0.05198743f, -0.03981693f, -0.15625335f, -0.15576017f, 
    -0.16825598f, -0.01567710f, -0.02486471f, -0.09606795f, -0.27462375f, 0.11847243f, -0.13950540f, 0.17428359f, 
    0.04378636f, 0.16290466f, -0.04028776f, -0.08177631f, 0.26598692f, 0.00477176f, -0.23100859f, 0.03931982f, 
    -0.00032372f, 0.14896895f, 0.32432985f, -0.12813115f, -0.03640864f, -0.09295259f, -0.00611352f, -0.05125550f, 
    0.04902597f, 0.09193357f, 0.03985548f, 0.07584924f, -0.31501609f, -0.26842844f, 0.10894325f, 0.19477746f, 
    0.13592273f, -0.14475073f, 0.04919147f, 0.18765254f, 0.04823533f, 0.04202003f, -0.05719772f, 0.07621929f, 
    0.14310624f, 0.00805026f, 0.21687260f, 0.07526007f, 0.07512975f, -0.08970931f, -0.06481613f, -0.05669248f, 
    -0.18641284f, 0.09232276f, -0.15189227f, -0.10730311f, 0.26204211f, -0.22988982f, 0.04457323f, -0.16480297f, 
    0.12607764f, 0.10600191f, 0.08324043f, 0.12154032f, 0.01786864f, -0.01961061f, -0.04888076f, -0.01546350f, 
    -0.09017724f, -0.09692688f, -0.00125812f, -0.07345418f, 0.03559068f, -0.00756889f, 0.04801738f, -0.12008097f, 
    -0.07335620f, -0.03289764f, 0.04139934f, -0.01345624f, 0.23444147f, 0.24265663f, 0.08679160f, 0.32200700f, 
    0.21349236f, -0.19463134f, -0.14978434f, -0.09483293f, -0.02521237f, 0.02115432f, 0.06270660f, 0.10355030f, 
    -0.32686180f, 0.37522817f, -0.17840320f, -0.30124870f, -0.35871583f, -0.15407126f, -0.16798669f, -0.27051529f, 
    0.11385272f, -0.00414090f, -0.04329910f, 0.11165954f, 0.09535815f, 0.05280578f, -0.45670584f, 0.14221115f, 
    0.04215103f, 0.13134682f, 0.13025361f, 0.13334052f, -0.05050580f, -0.08397228f, -0.11344869f, -0.02924499f, 
    0.02297824f, -0.02476053f, 0.11245017f, -0.07277321f, -0.12379231f, -0.12078985f, -0.35487783f, 0.08333600f, 
    0.14722881f, 0.04294308f, -0.02261471f, 0.15047611f, 0.05209773f, -0.22929320f, -0.24710105f, -0.09150607f, 
    -0.08441275f, 0.09967648f, 0.13853949f, 0.00981164f, 0.03222177f, 0.02811676f, -0.01388317f, -0.01116547f, 
    -0.03403503f, 0.29305434f, 0.08229243f, -0.14951016f, 0.03109661f, -0.05383386f, -0.15978713f, -0.14275746f, 
    -0.06964073f, 0.03746093f, -0.03642277f, -0.00485518f, 0.08466157f, 0.02733256f, 0.16319199f, 0.08850908f, 
    0.22340500f, -0.21950944f, 0.00742887f, -0.04316599f, 0.12820397f, 0.04900791f, -0.20079660f, -0.00286586f, 
    0.19430451f, -0.47614920f, 0.07238709f, 0.05040049f, -0.08991920f, 0.01548236f, 0.01086159f, -0.11398458f, 
    -0.05630045f, -0.07959484f, 0.06735502f, 0.10924453f, -0.22754802f, -0.16473837f, 0.02165761f, 0.06820232f, 
    -0.04998823f, -0.08149222f, 0.00679911f, 0.03471164f, 0.02396761f, 0.04100549f, 0.11032482f, 0.00989063f, 
    -0.09901277f, -0.32757586f, 0.28179753f, 0.25602850f, 0.02923922f, 0.16245878f, -0.21992320f, -0.03909472f, 
    -0.07801274f, -0.00847817f, -0.06536158f, 0.01112453f, -0.07754025f, 0.20744567f, 0.21893060f, -0.08044744f, 
    0.10637618f, -0.18340272f, -0.09296262f, -0.04445202f, 0.06597132f, 0.02892541f, -0.09168217f, -0.04581220f, 
    -0.32937902f, 0.32577738f, 0.04839158f, -0.33021373f, -0.09319349f, -0.31166086f, 0.05531167f, -0.47902745f, 
    0.05346991f, 0.08324870f, 0.08822989f, 0.02106486f, 0.03386576f, 0.23471415f, -0.20723271f, -0.33803484f, 
    -0.06118155f, -0.09438968f, 0.08953644f, 0.12669975f, 0.01617486f, 0.07395156f, -0.01404572f, -0.05016099f, 
    -0.28483951f, -0.16086464f, -0.26031694f, 0.21254073f, 0.10364188f, 0.06896761f, 0.07587051f, -0.00399433f, 
    -0.01401463f, -0.02841395f, -0.06136033f, -0.01847533f, 0.32756537f, -0.47493094f, 0.24549806f, -0.22332695f, 
    0.00152554f, 0.17471580f, -0.16107102f, 0.13588002f, 0.06081060f, 0.02578867f, -0.03278522f, 0.00161802f, 
    0.08750787f, -0.52252686f, 0.23646365f, -0.36751422f, -0.22366619f, 0.09841666f, -0.07641236f, -0.20533767f, 
    0.01135814f, 0.13756588f, -0.19557939f, 0.07471411f, 0.05588158f, -0.22240129f, -0.40054747f, 0.07189572f, 
    0.20143044f, 0.19045280f, 0.24353656f, 0.04163250f, 0.12522900f, -0.06443200f, 0.06369185f, -0.02574248f, 
    -0.00952206f, -0.41404939f, -0.00159977f, -0.16421707f, -0.07084478f, 0.11978960f, -0.07283318f, 0.01365976f, 
    -0.03301596f, -0.10420263f, -0.20019002f, -0.05724087f, -0.13183503f, 0.21361350f, -0.37718561f, 0.01682843f, 
    0.20088631f, -0.05938087f, 0.14509639f, -0.09821922f, -0.00888263f, -0.05083057f, -0.17160738f, 0.06728408f, 
    -0.18299422f, -0.25320628f, -0.14085747f, 0.08219299f, 0.06326418f, -0.11273523f, 0.05547681f, -0.12477200f, 
    -0.07887799f, -0.00118952f, -0.05983269f, -0.07100492f, -0.32116532f, 0.05568724f, -0.10092468f, -0.14407863f, 
    -0.26065618f, 0.04801017f, 0.08130479f, 0.14984508f, 0.01934879f, -0.01285439f, -0.00207214f, -0.06993851f, 
    0.17221993f, 0.12897199f, 0.07958611f, -0.08002981f, 0.04032648f, -0.11402069f, -0.10425550f, 0.08671680f, 
    -0.02751229f, 0.14753069f, -0.06261086f, -0.04507198f, -0.13957649f, 0.12584278f, -0.11035586f, -0.18503407f, 
    -0.06122945f, 0.12845002f, -0.16198939f, 0.07987162f, -0.15266876f, 0.06535081f, -0.15426005f, -0.06308775f, 
    -0.05012637f, -0.05161819f, 0.09173997f, 0.07396856f, 0.06174671f, 0.07023516f, 0.12521592f, 0.01113700f, 
    0.08895535f, 0.07640279f, 0.16625705f, 0.33695412f, 0.15125522f, 0.00996166f, 0.42868927f, -0.06585737f, 
    0.06359839f, -0.11147034f, 0.03300085f, -0.15519975f, 0.12663403f, 0.01980321f, -0.01893858f, -0.15668823f, 
    -0.10083850f, 0.14799890f, 0.12985183f, 0.56774402f, 0.07354324f, 0.05557205f, -0.03043028f, -0.01214270f, 
    -0.00261854f, -0.02063040f, 0.08899836f, -0.00796306f, -0.15232450f, 0.21907650f, -0.02098294f, -0.23716636f, 
    -0.09888037f, -0.18918931f, -0.02707285f, 0.07142805f, 0.08750209f, 0.06346362f, 0.05045933f, 0.05683830f, 
    -0.20271307f, -0.02554712f, -0.14746280f, 0.08407246f, 0.16523212f, 0.11988883f, 0.12386811f, 0.04298082f, 
    0.17348792f, 0.04377525f, -0.01786843f, 0.03929575f, -0.09476250f, 0.15389082f, 0.00306727f, -0.56156743f, 
    -0.14120345f, -0.23727562f, -0.00704075f, -0.22235917f, -0.11659347f, 0.10065904f, 0.09841503f, 0.04180353f, 
    0.13767266f, 0.22351585f, 0.37669352f, -0.23462521f, -0.00880045f, -0.15910806f, -0.03963860f, -0.03089836f, 
    -0.06405537f, 0.05102129f, 0.15617286f, 0.17086612f, -0.02598600f, -0.33361930f, 0.08378483f, -0.15906002f, 
    -0.04992931f, 0.14629389f, -0.24001645f, -0.13754119f, -0.10458618f, -0.08535133f, -0.04533873f, -0.00858705f, 
    0.01026547f, -0.02948992f, 0.04636384f, 0.03440772f, 0.13268016f, 0.00243210f, 0.01707110f, -0.05976114f, 
    0.16697165f, -0.02299550f, -0.00556420f, -0.00754548f, 0.02559061f, 0.11631218f, -0.33668500f, -0.01866443f, 
    0.17692362f, -0.04257958f, -0.00090666f, 0.03282581f, -0.02761457f, -0.09018861f, -0.08614916f, -0.09509649f, 
    0.21785496f, -0.04513603f, 0.11022698f, 0.36824146f, 0.03647945f, 0.04138014f, -0.27119964f, -0.11770649f, 
    -0.00097305f, -0.17297773f, 0.05665400f, 0.02753692f, -0.02827857f, 0.07247413f, -0.18781339f, -0.17161794f, 
    -0.19899590f, -0.10878389f, 0.05503296f, -0.15531799f, 0.07689768f, -0.03248492f, 0.01208253f, 0.03456685f, 
    0.04213234f, -0.07397300f, -0.05833329f, -0.05032300f, 0.12337913f, 0.01968389f, -0.13003862f, 0.10733277f, 
    -0.06698333f, 0.11098416f, -0.09774549f, -0.12290491f, -0.29561409f, 0.03432122f, -0.01990310f, -0.18570215f, 
    -0.12084803f, 0.03898475f, 0.06547190f, 0.25988868f, 0.03633866f, -0.00585300f, 0.01779708f, -0.02226664f, 
    -0.09202211f, -0.19598663f, -0.27253279f, 0.21371688f, -0.04753321f, 0.10106382f, -0.17259701f, 0.04614130f, 
    0.19798824f, 0.09153825f, -0.04714362f, 0.01523337f, -0.15805946f, 0.10814992f, -0.10424456f, -0.06643930f, 
    -0.02642002f, 0.12065251f, -0.02525906f, 0.05348027f, -0.00442905f, 0.07242084f, -0.09284854f, -0.09017218f, 
    0.05811379f, -0.06554431f, -0.18685812f, 0.01365725f, 0.02268887f, -0.05073610f, 0.11190394f, 0.05247825f, 
    -0.01854833f, 0.14056173f, -0.15453421f, -0.08167318f, -0.27070498f, 0.16272472f, 0.08160308f, 0.11898293f, 
    0.06890728f, 0.10412028f, 0.02983451f, 0.14458251f, -0.12834604f, -0.20450184f, -0.09498347f, -0.35789764f, 
    -0.09780400f, 0.09341905f, -0.22244172f, -0.10030953f, -0.16761357f, 0.00448773f, -0.05542928f, -0.09661515f, 
    -0.05037149f, -0.08598343f, -0.13083805f, -0.17078431f, -0.18220773f, 0.07091650f, 0.01040884f, -0.06039853f, 
    -0.08678240f, -0.01668165f, -0.12643658f, 0.03522481f, 0.06636125f, 0.05999249f, -0.19711612f, -0.22797926f, 
    -0.11305754f, 0.14796637f, -0.25383061f, 0.00748017f, 0.04874211f, -0.00295079f, 0.04729548f, 0.00869884f, 
    0.05636577f, -0.00887764f, -0.32589623f, -0.35057369f, 0.15561907f, -0.11583147f, 0.13645796f, -0.32690036f, 
    0.00795697f, -0.03057970f, 0.10817950f, 0.02313974f, -0.01965665f, -0.25528732f, -0.21982530f, -0.40284023f, 
    -0.23523255f, 0.22778499f, 0.20979460f, 0.30601349f, 0.01172733f, -0.02447850f, -0.08299507f, -0.03241805f, 
    -0.07170955f, 0.01590768f, 0.09617579f, -0.08505856f, -0.18760799f, 0.01183758f, 0.07130973f, 0.21617427f, 
    -0.09714399f, 0.11835508f, 0.09495056f, -0.02275890f, 0.01392398f, -0.13755333f, 0.19752964f, -0.00732982f, 
    -0.25064790f, -0.09697310f, 0.16278905f, 0.22953007f, -0.00352798f, 0.21448301f, -0.38277116f, 0.11292443f, 
    -0.07044823f, 0.02399231f, 0.02104850f, -0.17057607f, -0.14873332f, 0.11054394f, -0.30195740f, 0.09296153f, 
    0.06442831f, -0.02492231f, 0.04128015f, 0.15423821f, -0.09334362f, 0.08518239f, 0.00218850f, 0.07946090f, 
    -0.36585194f, -0.05674378f, -0.11887183f, 0.05973637f, -0.21101429f, -0.07792817f, 0.06748191f, -0.00909237f, 
    0.18228789f, -0.09556375f, 0.05009768f, 0.05876875f, 0.05798110f, 0.15032221f, 0.17754313f, -0.01320246f, 
    -0.22263353f, -0.03422373f, 0.10407495f, 0.04365041f, -0.15769935f, 0.04612627f, -0.00823335f, 0.13930252f, 
    0.26373473f, -0.06530114f, 0.00563223f, 0.10687330f, -0.11545315f, -0.03504668f, -0.00936033f, -0.09039315f, 
    -0.00258197f, 0.20261382f, -0.27100566f, 0.11903664f, -0.23561500f, 0.33714357f, -0.04450503f, 0.30432341f, 
    0.16461194f, 0.00126046f, -0.07637291f, -0.02985400f, -0.00325234f, 0.02365370f, -0.17572479f, -0.07507084f, 
    -0.00920306f, 0.31463534f, 0.14429818f, 0.03779097f, -0.08653821f, -0.14271198f, 0.04821717f, 0.01145794f, 
    -0.21487071f, -0.05462945f, -0.16267347f, -0.13021748f, -0.13307109f, -0.21156880f, -0.20717539f, 0.33191040f, 
    -0.16462538f, -0.07058798f, 0.09531588f, -0.18235870f, -0.20161453f, 0.11324285f, -0.12611279f, 0.01853223f, 
    -0.06442625f, 0.21688475f, -0.20188101f, 0.19550750f, 0.07496233f, -0.11271413f, 0.03124382f, 0.14203455f, 
    -0.02026561f, 0.20122820f, -0.05646528f, -0.07486800f, 0.00600524f, -0.33489189f, 0.01688095f, 0.10473260f, 
    -0.00866412f, 0.06342422f, -0.09052001f, -0.05559596f, -0.12639642f, -0.13607499f, -0.05246013f, -0.11426729f, 
    0.14530036f, 0.15459670f, -0.18047044f, 0.13137808f, 0.00670944f, 0.09811372f, 0.12478131f, -0.00398862f, 
    -0.01869862f, 0.02840782f, 0.16025996f, 0.17461966f, -0.26633352f, -0.10589792f, 0.11815308f, -0.37317047f, 
    -0.27004984f, -0.02070769f, 0.14478242f, 0.02635153f, -0.07404158f, -0.00160639f, 0.04631223f, 0.14224474f, 
    -0.03721511f, -0.13301983f, -0.01370200f, 0.11370756f, -0.03217307f, 0.02744786f, 0.05557477f, 0.04282523f, 
    -0.08692896f, -0.25825465f, -0.24240874f, -0.19581227f, -0.62788427f, 0.25727597f, -0.47153378f, 0.07081216f, 
    0.08923352f, 0.19895771f, 0.02843510f, -0.02866929f, -0.25953069f, -0.04333682f, -0.04472166f, 0.06872627f, 
    -0.06077645f, 0.18982263f, -0.01471198f, -0.12061646f, -0.07529847f, 0.01710732f, 0.09189419f, -0.07866465f, 
    0.18918371f, -0.15529723f, 0.21328108f, 0.07564695f, -0.15300387f, -0.19917253f, -0.09942529f, -0.08725190f, 
    -0.18914473f, 0.10247106f, 0.02259798f, -0.20383862f, 0.07113305f, -0.06730083f, -0.09691431f, -0.11955487f, 
    0.02515351f, -0.08857978f, 0.14376011f, 0.13099180f, -0.09349646f, -0.02480824f, 0.05243616f, 0.16522142f, 
    0.15799259f, -0.01501908f, 0.05062546f, 0.09228417f, 0.22158557f, 0.21861772f, 0.12447916f, -0.14008310f, 
    -0.04151864f, -0.01616475f, -0.10053228f, 0.02955943f, 0.00657482f, 0.00927043f, 0.14347355f, -0.06485911f, 
    0.52844912f, -0.20754208f, 0.23848870f, -0.38779786f, -0.00105727f, -0.06466669f, 0.06454229f, 0.00927304f, 
    -0.17155792f, -0.01393750f, 0.13467410f, 0.07424916f, 0.04954991f, -0.36931410f, 0.09686533f, -0.02694892f, 
    -0.07944879f, 0.00415593f, 0.00264443f, -0.10072787f, -0.01808420f, 0.03865537f, -0.07360118f, -0.08090673f, 
    -0.18997519f, 0.04956275f, -0.05718759f, -0.09129769f, 0.02299373f, 0.30260789f, -0.19941898f, -0.07354661f, 
    -0.23212349f, 0.02711161f, -0.06270708f, -0.24677834f, -0.08733088f, 0.14950168f, -0.15433401f, 0.35113207f, 
    -0.05731673f, -0.32136941f, -0.03440304f, -0.06277571f, -0.08326363f, -0.08351041f, 0.12556134f, -0.03721483f, 
    0.23964405f, -0.05170793f, 0.18287531f, -0.15677524f, -0.16500588f, -0.00988995f, 0.10064385f, 0.03142957f, 
    0.06842856f, 0.06193677f, 0.11952248f, 0.00116086f, -0.20668198f, 0.19755864f, 0.03720905f, 0.10983709f, 
    -0.12546685f, 0.09584050f, 0.18263261f, -0.03068214f, 0.14553493f, -0.01185842f, 0.08199094f, 0.23573004f, 
    -0.59058970f, 0.46382219f, -0.29318228f, 0.14655456f, -0.03845482f, 0.25392255f, 0.01413651f, 0.09535039f, 
    -0.08918280f, -0.04449807f, -0.17381978f, -0.05048767f, -0.24142493f, -0.25209561f, -0.49586412f, 0.00061896f, 
    0.06255676f, -0.03318534f, -0.13772124f, 0.05135711f, -0.05030643f, 0.05675924f, -0.02005256f, -0.05300087f, 
    -0.21776606f, -0.22182894f, -0.04739396f, -0.03257008f, -0.03491036f, 0.07490930f, -0.18407668f, -0.03395995f, 
    0.03694417f, -0.02804959f, -0.16279204f, -0.02842224f, -0.18208367f, -0.00783385f, 0.17173405f, 0.00959713f, 
    -0.20805170f, -0.12148236f, 0.05634468f, 0.13295043f, -0.07536834f, 0.06647108f, 0.14817493f, 0.12740779f, 
    0.15599491f, -0.06173530f, -0.02785488f, 0.19660681f, -0.06069288f, 0.06295879f, 0.00771513f, -0.06653751f, 
    -0.07788555f, 0.07765039f, -0.13203758f, -0.12159067f, -0.02989847f, -0.41406271f, -0.00318994f, 0.12592992f, 
    -0.00010638f, 0.09300908f, 0.00294330f, 0.09132812f, 0.11430072f, 0.03836659f, 0.04714572f, 0.01447011f, 
    -0.04386935f, -0.17231946f, 0.17988883f, -0.06224049f, -0.25496188f, -0.06404202f, -0.05356092f, 0.10176957f, 
    0.07846610f, -0.01726232f, 0.03068958f, 0.10574675f, 0.04170917f, -0.02432225f, 0.27178368f, 0.15647034f, 
    0.04185087f, 0.07488707f, -0.16158891f, 0.04544579f, -0.03181579f, -0.06013867f, -0.10384564f, -0.07168389f, 
    -0.06177508f, 0.33800074f, 0.13400578f, 0.34088960f, 0.08258636f, 0.03597858f, 0.08621132f, -0.03442935f, 
    -0.01836443f, 0.08373677f, 0.05410130f, 0.26150012f, -0.04547010f, -0.13888173f, -0.37419760f, -0.24069703f, 
    -0.18203485f, -0.10855471f, 0.07410242f, 0.00169805f, -0.23176016f, 0.10175976f, -0.05777349f, -0.01208601f, 
    -0.01089785f, -0.10675368f, 0.09162816f, 0.05543597f, -0.02882201f, 0.11701225f, -0.11391985f, -0.01684465f, 
    0.16066237f, 0.06860445f, -0.04251929f, 0.11578166f, 0.15126686f, -0.00742752f, -0.22139850f, 0.18230742f, 
    -0.11375197f, -0.10424682f, 0.14353889f, -0.14356194f, -0.13014103f, 0.02448682f, -0.09544554f, 0.11949018f, 
    -0.35250416f, 0.30096912f, -0.10952554f, -0.13390559f, -0.02807664f, 0.03729669f, 0.01014732f, -0.22581525f, 
    -0.04734181f, 0.03975888f, 0.03349879f, -0.01929700f, -0.17252101f, 0.15887897f, -0.02814060f, 0.13485573f, 
    -0.18170975f, 0.09843235f, 0.00460121f, 0.01118629f, 0.01685983f, 0.16848275f, 0.11456436f, 0.15710370f, 
    -0.46249524f, -0.04696352f, -0.09448476f, 0.25036654f, -0.07675702f, 0.19711451f, 0.01076361f, -0.09812199f, 
    -0.07626883f, -0.03950967f, -0.13408245f, -0.02771415f, 0.06933830f, -0.11409107f, 0.22642238f, 0.12405581f, 
    -0.20219292f, -0.01247401f, 0.05946118f, -0.04583621f, -0.00913943f, -0.05244463f, 0.12093969f, 0.21071687f, 
    -0.01966457f, 0.04175644f, -0.09796508f, -0.22967699f, -0.09416529f, 0.01106860f, -0.10508875f, -0.07741458f, 
    0.01605109f, -0.09868070f, -0.38146633f, -0.24035613f, -0.29984429f, 0.15769038f, -0.07280259f, -0.02562897f, 
    -0.11312363f, -0.12457623f, 0.06229990f, 0.00818854f, -0.01162378f, -0.10570396f, 0.11318588f, -0.00277343f, 
    -0.29672340f, 0.01648469f, -0.27108860f, 0.13895987f, 0.00212230f, 0.07439906f, 0.07523803f, -0.03816462f, 
    0.02799925f, -0.04909668f, 0.04012294f, -0.01803387f, 0.12666281f, -0.09110380f, 0.07190017f, -0.09067358f, 
    0.01901275f, -0.11475951f, -0.02724874f, 0.04281877f, -0.02187307f, -0.02142274f, -0.23538940f, -0.14899288f, 
    -0.08292288f, -0.39697987f, -0.03585123f, -0.23876017f, -0.10407410f, -0.09553368f, -0.11076178f, 0.09620062f, 
    0.02297195f, -0.04948464f, 0.05368409f, -0.15097207f, -0.03262256f, 0.12055813f, 0.00012932f, 0.28062186f, 
    0.01308321f, -0.07806286f, 0.00849464f, -0.01174932f, 0.14037217f, 0.04346886f, 0.01831676f, -0.06659039f, 
    -0.23073590f, -0.06412032f, -0.05490369f, 0.05029047f, 0.06399431f, 0.00446114f, -0.14604855f, 0.05094979f, 
    -0.09460849f, 0.04668372f, -0.13890538f, -0.36868152f, -0.35564250f, -0.04459867f, 0.35530543f, 0.14012764f, 
    0.01033312f, -0.00523126f, -0.09328495f, 0.13287240f, -0.22919337f, 0.06118106f, 0.07085062f, -0.05302254f, 
    -0.10213997f, 0.01823092f, -0.01530112f, 0.03284802f, -0.17003872f, 0.12485842f, 0.18849690f, 0.14872125f, 
    -0.08462039f, 0.08965129f, 0.03810863f, 0.12886898f, -0.15191987f, -0.22505994f, 0.02290465f, 0.09026370f, 
    0.00093865f, 0.06858201f, 0.12039390f, 0.11326885f, 0.01425871f, 0.16126779f, 0.07715981f, 0.11523426f, 
    -0.10327195f, 0.18613344f, -0.21357049f, 0.09523304f, 0.09970117f, 0.02308602f, -0.16457523f, 0.03574994f, 
    -0.15056136f, 0.16537015f, -0.00035236f, 0.11897747f, 0.14718443f, -0.01625641f, 0.17562963f, -0.01084312f, 
    0.10738150f, -0.14609861f, 0.12056177f, 0.03307920f, -0.16774151f, 0.18086511f, -0.04792384f, -0.23978125f, 
    -0.05231303f, -0.09371694f, 0.21164472f, -0.01547075f, 0.02223222f, 0.04364232f, -0.15447295f, 0.03764072f, 
    -0.00172456f, 0.12865141f, 0.14078815f, -0.05460208f, -0.16575794f, -0.15012051f, -0.10454546f, 0.23596273f, 
    -0.02185759f, 0.11159975f, -0.14068742f, 0.05863469f, 0.12111632f, 0.05832621f, 0.10509580f, -0.02700141f, 
    -0.33845678f, -0.27567551f, 0.12822299f, -0.24651273f, -0.41230956f, -0.11514901f, -0.22964731f, -0.03649174f, 
    0.01942893f, -0.00180495f, -0.01525852f, -0.00734963f, 0.04907437f, 0.05535745f, 0.14904976f, -0.13156845f, 
    -0.02218144f, -0.07355756f, -0.07086822f, 0.03829461f, 0.10299407f, 0.07852696f, 0.08853473f, 0.09371275f, 
    0.26785076f, -0.16883108f, 0.00142226f, -0.26071915f, 0.03800707f, -0.00686401f, 0.13146594f, 0.11229614f, 
    -0.04433782f, 0.19622606f, 0.16123880f, -0.04778153f, -0.34815070f, 0.00471453f, -0.05750789f, 0.19903295f, 
    0.02782018f, -0.03903277f, 0.12569667f, -0.01241506f, -0.01306396f, 0.02355961f, -0.07463060f, 0.20550431f, 
    0.05512900f, 0.07306943f, -0.01137520f, 0.01653373f, -0.03779474f, -0.04594081f, -0.09245733f, 0.04663888f, 
    0.01811550f, 0.02741514f, 0.13380343f, 0.05077717f, 0.37227833f, -0.45654073f, 0.16590798f, 0.22385685f, 
    0.13348126f, -0.02030753f, 0.16539879f, 0.05730826f, 0.01410637f, 0.10147999f, 0.00825620f, 0.13343647f, 
    -0.23593336f, 0.11336909f, -0.22550274f, 0.05432928f, -0.00276076f, -0.09553367f, -0.06000903f, 0.07470653f, 
    -0.00373735f, -0.02955256f, 0.02598015f, 0.17957425f, -0.34562618f, -0.30805498f, 0.13651577f, -0.54931575f, 
    0.06052087f, -0.07935064f, -0.11190230f, 0.03717478f, 0.01276505f, 0.10283621f, 0.12430757f, 0.04708917f, 
    -0.26048166f, 0.26960838f, -0.21781173f, 0.12590623f, 0.00420845f, -0.10951199f, -0.00914671f, 0.05843133f, 
    -0.01648141f, 0.02331733f, -0.19803581f, -0.06880008f, -0.18126367f, 0.13233398f, -0.10920040f, 0.21250781f, 
    -0.02141188f, 0.01593344f, -0.09448183f, -0.15392873f, -0.03704560f, -0.00184802f, -0.09183303f, -0.04613101f, 
    -0.25181612f, 0.05942209f, -0.09780339f, 0.17418295f, -0.11647236f, -0.19767402f, 0.35712031f, 0.22430244f, 
    -0.02460480f, 0.05371977f, -0.14366101f, 0.01926912f, 0.50987828f, 0.20484377f, 0.42600927f, 0.02096897f, 
    -0.01899093f, -0.18670014f, -0.03288575f, 0.05903814f, -0.19825777f, -0.00959643f, 0.07333233f, -0.13388711f, 
    0.10262774f, 0.19131932f, -0.17639849f, -0.09416022f, -0.10317381f, 0.04925250f, -0.01799195f, 0.13538295f, 
    0.01158300f, 0.08845574f, 0.14765383f, -0.14005059f, 0.16864702f, -0.09227061f, 0.25814971f, -0.07242413f, 
    0.02398270f, 0.12801108f, -0.04519633f, 0.09443035f, -0.09943169f, 0.07848675f, 0.08658491f, -0.02755309f, 
    0.07371799f, -0.18280837f, 0.27088615f, 0.18290211f, -0.04430021f, -0.02168144f, 0.04541038f, 0.12556128f, 
    0.06642234f, -0.01413821f, 0.05798724f, 0.18778764f, -0.69865417f, 0.44541022f, -0.47384536f, 0.41649076f, 
    0.01872146f, 0.01889325f, 0.07739989f, 0.16186965f, -0.23958166f, 0.04450460f, 0.11264439f, -0.00427853f, 
    0.07682794f, 0.02785727f, 0.02622858f, -0.09450886f, -0.00458087f, 0.08657824f, -0.00340696f, 0.03181943f, 
    0.13769393f, 0.08026202f, 0.09188276f, -0.00236252f, 0.22806649f, -0.15133038f, 0.40935260f, 0.15192746f, 
    0.09569643f, -0.00404947f, -0.17052612f, 0.05157716f, -0.04886571f, 0.00175080f, 0.12412926f, 0.18374202f, 
    -0.30120045f, 0.07451775f, 0.12447730f, 0.12398159f, -0.16366303f, 0.04002319f, 0.02531650f, -0.13546665f, 
    -0.09566465f, -0.08669662f, 0.02812424f, 0.05577472f, -0.14158605f, -0.16088204f, 0.31676665f, -0.27682546f, 
    -0.14321999f, 0.02674316f, -0.18019414f, 0.06160799f, 0.03257975f, 0.12421556f, -0.01371135f, 0.00838858f, 
    -0.34565198f, -0.03423727f, -0.01308770f, 0.21851514f, 0.13547821f, -0.05554402f, -0.11432178f, 0.09336066f, 
    -0.12735933f, -0.03542096f, -0.00932824f, -0.14602624f, 0.12548816f, -0.05040148f, 0.16391683f, 0.08212291f, 
    -0.07169338f, 0.03122467f, 0.15430662f, -0.06452529f, -0.00243636f, 0.03671420f, -0.00328570f, -0.04477009f, 
    -0.09505507f, -0.20314482f, -0.21844234f, -0.07058427f, -0.08266708f, 0.04669441f, 0.05308435f, -0.08059280f, 
    0.01660194f, 0.05152543f, 0.03394514f, -0.08377071f, -0.11316152f, -0.48515794f, -0.00409350f, 0.31970957f, 
    0.00817406f, -0.03618745f, 0.07145147f, -0.08423854f, 0.00579377f, 0.11404451f, 0.18713622f, -0.13344297f, 
    -0.11123802f, -0.05474683f, -0.10600331f, 0.05504568f, 0.00214895f, 0.03597495f, -0.08993250f, 0.04697572f, 
    -0.10438035f, 0.06920140f, -0.02682271f, -0.23099163f, 0.36855215f, 0.26466361f, 0.02078226f, -0.35954979f, 
    -0.16480522f, 0.05297647f, -0.12264872f, 0.02392867f, -0.02114724f, 0.04757739f, -0.00336631f, 0.04592674f, 
    0.01810561f, 0.00558259f, 0.08001185f, -0.17134747f, -0.03718828f, -0.00267981f, -0.04237579f, -0.08523956f, 
    -0.12166256f, 0.03126588f, -0.07722373f, 0.03186227f, -0.24495973f, -0.11427277f, -0.04356438f, -0.05741058f, 
    0.05869018f, -0.02650637f, -0.08830162f, 0.05558223f, -0.11227595f, 0.04842230f, 0.05613621f, -0.06255182f, 
    -0.23656069f, 0.15326577f, 0.02278686f, -0.45327321f, -0.03981219f, -0.07159518f, 0.34064713f, -0.18524265f, 
    0.05302427f, 0.10471641f, -0.06649494f, -0.13188876f, 0.15971650f, 0.13922761f, 0.29774269f, -0.23768558f, 
    -0.11531187f, -0.17047052f, -0.07672658f, -0.03585550f, -0.05973768f, -0.00715520f, -0.05078510f, -0.06435011f, 
    0.00884551f, 0.01084065f, 0.06890570f, 0.05742941f, -0.01598666f, -0.07469745f, 0.14576831f, 0.11916157f, 
    0.12524171f, 0.20585640f, 0.00121355f, 0.06127079f, -0.11552578f, -0.11999820f, 0.08211881f, 0.07067218f, 
    -0.06149606f, 0.04762555f, -0.01556420f, -0.09858780f, -0.25125539f, 0.03133268f, 0.05601999f, 0.03222038f, 
    -0.18786889f, -0.10426308f, -0.25972444f, -0.05302283f, 0.06182812f, -0.04687377f, 0.12802123f, -0.00379770f, 
    -0.18724199f, 0.03423510f, -0.16397397f, -0.02705931f, 0.04922528f, 0.05152748f, 0.04778926f, 0.03801399f, 
    -0.11532515f, 0.14649817f, 0.06015248f, 0.06316402f, -0.04785151f, -0.07927106f, 0.26407659f, -0.37463751f, 
    -0.41532984f, 0.06692742f, -0.32729670f, 0.12423830f, -0.01278706f, -0.20357125f, -0.03287807f, 0.17443570f, 
    0.03865607f, 0.11107042f, 0.21169563f, 0.08484294f, 0.12676242f, -0.29209134f, -0.09780614f, -0.04511126f, 
    -0.01206402f, -0.12263615f, 0.09356204f, -0.16759406f, 0.02492058f, 0.06792430f, 0.00556924f, -0.07180168f, 
    -0.34165284f, -0.02475333f, -0.25123960f, -0.07669164f, 0.08107038f, 0.04233001f, 0.02362669f, 0.05714197f, 
    0.07111248f, 0.09607801f, 0.07526932f, 0.03455530f, -0.03262974f, 0.01245836f, 0.02176375f, 0.00552962f, 
    -0.05608984f, 0.20962901f, 0.06144852f, 0.05789336f, -0.00186261f, 0.12557475f, 0.17390476f, -0.06112716f, 
    0.22498266f, -0.43112168f, 0.29009864f, -0.24340463f, 0.07275923f, -0.02208039f, 0.01853631f, 0.13509078f, 
    0.02176485f, 0.05693568f, 0.07639213f, -0.05102972f, 0.16765377f, -0.24902469f, 0.26201200f, -0.17824262f, 
    -0.35579404f, -0.05501777f, -0.23475629f, -0.00696348f, -0.03121196f, 0.11053393f, -0.03190306f, 0.02690721f, 
    0.28182498f, 0.00992531f, 0.38087893f, -0.27753624f, -0.04151752f, -0.04527216f, -0.07000858f, -0.04585176f, 
    -0.15699665f, 0.14905404f, -0.13905819f, -0.06643899f, -0.25614193f, 0.28897652f, -0.15890145f, 0.07698776f, 
    -0.22356802f, -0.00599627f, 0.10376632f, 0.05347004f, -0.07680255f, -0.07432248f, 0.06420231f, 0.14349741f, 
    -0.42603716f, 0.48119774f, -0.25657716f, 0.10526901f, -0.04020450f, 0.00651051f, 0.15307400f, -0.14902823f, 
    -0.14595249f, -0.04064941f, -0.15071820f, -0.17931581f, 0.26982355f, 0.15292454f, 0.10144215f, 0.03146806f, 
    -0.08814090f, 0.07655635f, -0.04280131f, 0.11033218f, -0.10705056f, -0.08572564f, 0.03006497f, -0.09152128f, 
    -0.06118906f, 0.21495210f, -0.13401684f, 0.09704819f, 0.08889046f, -0.12909839f, 0.11538704f, -0.09311692f, 
    -0.04367261f, -0.06666595f, 0.00855022f, -0.17188983f, 0.09933031f, -0.28071934f, 0.41730422f, 0.00648697f, 
    0.10522006f, -0.01159091f, 0.03773485f, -0.05719668f, -0.01549620f, 0.03714878f, 0.07593247f, -0.03411413f, 
    0.30341393f, -0.34528446f, 0.15332827f, 0.03046302f, 0.00675574f, -0.11725281f, -0.23763262f, 0.17062508f, 
    -0.15866186f, 0.02354093f, 0.10323886f, 0.01506175f, 0.04141133f, -0.12508202f, 0.06603653f, -0.08544926f, 
    -0.00278014f, -0.31402245f, 0.01853333f, -0.13914484f, 0.03892760f, -0.04807178f, -0.12222330f, -0.13124393f, 
    -0.14365642f, -0.13598120f, -0.32136253f, 0.28555456f, -0.19450045f, -0.06608005f, 0.06431271f, -0.07793613f, 
    0.01592652f, 0.03069865f, 0.04184737f, -0.08936772f, -0.36940435f, -0.00091172f, -0.18652980f, -0.08605924f, 
    0.17767918f, -0.07212774f, -0.00008029f, 0.00273057f, -0.11324673f, 0.12625310f, -0.01492966f, -0.19636139f, 
    0.13471118f, -0.05213459f, -0.02558542f, -0.11713156f, 0.00578786f, 0.01266885f, -0.00562693f, 0.01240502f, 
    0.14026594f, 0.11228794f, -0.03543605f, 0.21176857f, -0.16659883f, -0.19821340f, -0.05599688f, 0.12757237f, 
    -0.08616915f, 0.06159817f, 0.00846027f, -0.04119119f, 0.07926317f, 0.03028237f, 0.14637814f, 0.02810704f, 
    -0.38717601f, 0.05576316f, -0.32539353f, 0.25911880f, 0.10206845f, 0.10033671f, 0.12228087f, -0.07349493f, 
    0.01646807f, -0.02391375f, 0.24769381f, 0.31063083f, 0.03185862f, -0.12227961f, -0.13698305f, -0.31424901f, 
    0.02647186f, -0.08448903f, 0.03051522f, -0.01041401f, 0.04748309f, 0.07053588f, -0.03825350f, 0.01007626f, 
    0.26141658f, 0.04417158f, 0.13324942f, -0.20432848f, -0.01747667f, -0.00779410f, 0.02765075f, 0.08509506f, 
    -0.12814413f, 0.01755048f, 0.07593865f, -0.08399453f, -0.05404923f, -0.34012827f, 0.35350877f, -0.29054046f, 
    -0.00572639f, 0.13283055f, 0.00694203f, 0.06957597f, -0.08771670f, -0.09040609f, -0.16081861f, -0.07333200f, 
    -0.24777526f, -0.20591807f, -0.02597806f, 0.09094501f, -0.12228798f, -0.11749635f, -0.01008238f, 0.05092665f, 
    -0.11035077f, 0.13354503f, -0.11446095f, 0.03289424f, -0.00978784f, 0.06424428f, -0.41106087f, 0.18038136f, 
    -0.04668332f, 0.06593797f, 0.06051407f, -0.02335807f, -0.01459299f, 0.10182542f, -0.07089388f, 0.15678756f, 
    -0.06219117f, 0.03384905f, 0.05210117f, -0.01247023f, 0.09610292f, 0.06959122f, -0.13828826f, -0.00062299f, 
    0.07494577f, -0.10541639f, 0.03578673f, -0.09395766f, 0.19210495f, 0.16101789f, 0.09772348f, -0.07039723f, 
    -0.01322273f, -0.16437134f, 0.11968517f, -0.16843963f, -0.14863089f, -0.04927442f, 0.07209089f, 0.05887474f, 
    -0.38575572f, 0.07751399f, -0.15118410f, 0.35011238f, 0.07218011f, -0.22383414f, 0.04662040f, -0.09492233f, 
    -0.07507633f, 0.03448414f, -0.13365544f, -0.05339290f, -0.30951184f, 0.30245814f, -0.25325817f, -0.22488222f, 
    -0.03015074f, -0.00380774f, 0.13094258f, -0.08668107f, -0.07690825f, 0.02223919f, -0.00934223f, -0.05099911f, 
    -0.07395073f, -0.01018337f, -0.11224235f, 0.15504041f, -0.03301119f, -0.00748183f, 0.13220380f, 0.22423440f, 
    -0.04953032f, 0.00852389f, 0.01178486f, 0.02258555f, 0.02068790f, 0.05487425f, -0.06286158f, -0.10138811f, 
    -0.10749931f, -0.11583636f, -0.26774049f, 0.04333998f, 0.01711433f, -0.01608790f, -0.13650030f, -0.12859274f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13932642f, 0.08777960f, 0.05513499f, -0.11276472f, -0.09908722f, 0.10402403f, 0.00153220f, -0.10466357f, 
    0.08463144f, 0.01408035f, 0.01843320f, -0.03959616f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
