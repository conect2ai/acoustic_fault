#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.41012794f, -0.18081237f, 0.33935997f, 0.72330344f, 0.39948809f, 0.08209747f, 0.06367122f, 0.14520879f, 
    -0.16753446f, 0.10628194f, -0.42135778f, 0.22789836f, -0.47675553f, -0.68228984f, 0.23231125f, 0.26562017f, 
    -0.08146750f, 0.17962393f, -0.39823049f, -0.23317590f, -0.51668423f, -0.13478853f, 0.42789280f, 0.62311256f, 
    0.05968295f, -0.24991998f, 0.23280038f, 0.26453263f, 0.40064159f, 0.48208246f, -0.02169056f, 0.28216243f, 
    -0.30073383f, -0.34490928f, -0.14863539f, -0.21915384f, 0.23643371f, 0.04958063f, 0.51636952f, 0.44500995f, 
    -0.50391543f, 0.03897497f, 0.43376324f, 0.26165262f, 0.43285134f, 0.70542943f, 0.50920653f, 0.24997462f, 
    -0.31410185f, 0.01586113f, -0.42207468f, -0.10327974f, 0.31410968f, 0.25756061f, 0.44286844f, -0.59492731f, 
    0.46840823f, 0.55953223f, -0.20950712f, 0.53387558f, -0.04006334f, -0.49969575f, 0.06496479f, -0.25987101f, 
    0.25086820f, 0.53294671f, 0.51366580f, 0.65224200f, -0.46475908f, 0.42930594f, 0.19574162f, -0.07299195f, 
    -0.22655785f, -0.40406665f, -0.51239115f, 0.44740993f, 0.20313354f, 0.50359493f, -0.11728772f, -0.41912371f, 
    -0.42807928f, -0.28000313f, 0.23019685f, -0.05178437f, -0.52335048f, -0.14289100f, 0.04907016f, 0.34098297f, 
    0.51271546f, -0.27971047f, 0.77535665f, -0.61346179f, 0.31605896f, 0.74826753f, 0.00580032f, -0.18818681f, 
    0.24718057f, -0.23045136f, -0.43879962f, -0.53547508f, -0.39694256f, -0.14864905f, 0.50881755f, 0.58065867f, 
    0.14576882f, -0.04837305f, 0.12658434f, -0.03676362f, 0.01161266f, -0.05801319f, -0.42326921f, 0.70774877f, 
    -0.37526619f, -0.42576832f, -0.30661455f, -0.23076704f, -0.42026871f, 0.36980003f, 0.57929772f, 0.55328089f, 
    -0.27999783f, -0.09562013f, 0.22772035f, 0.24064913f, -0.07415314f, -0.00976382f, 0.09309936f, -0.79250419f, 
    -0.53517288f, -0.34026015f, -0.36549994f, 0.12978980f, 0.08883746f, 0.11229032f, 0.09573066f, -0.37183616f, 
    -0.39510673f, -0.34079948f, 0.00789940f, -0.11173569f, -0.47345808f, -0.38137996f, 0.21795055f, 0.42376691f, 
    0.27055615f, 0.30453867f, -0.27606657f, -0.48185313f, -0.67174655f, 0.14989570f, -0.39061287f, 0.03780145f, 
    0.52403957f, -0.11213236f, -0.38303113f, -0.52735883f, -0.31037530f, 0.58206266f, -0.41360682f, -0.11089618f, 
    0.04925035f, -0.52897775f, 0.15723652f, 0.39826053f, 0.32492813f, -0.07845318f, 0.39643854f, 0.56616133f, 
    0.38551849f, -0.38782394f, -0.38739505f, -0.04851393f, 0.35881057f, -0.37007862f, 0.35714689f, 0.46710229f, 
    0.33180168f, -0.35461897f, 0.43473256f, 0.25938731f, -0.53338194f, 0.87200350f, -0.38758859f, 0.12864611f, 
    -0.19305182f, -0.36431041f, 0.28144896f, -0.12867309f, -0.15024070f, 0.44569242f, 0.56368262f, 0.49340427f, 
    -0.43356457f, 0.03210481f, -0.35434446f, 0.27827793f, -0.06995021f, -0.44873154f, 0.54033256f, -0.41274044f, 
    -0.57142210f, -0.17387763f, -0.09121738f, -0.41015485f, -0.20073518f, -0.41603619f, 0.36767367f, 0.13354418f, 
    -0.02180250f, 0.30352685f, -0.76213634f, -0.01141637f, -0.59408408f, -0.00850006f, -0.24317056f, -0.15143962f, 
    0.49370795f, -0.04574889f, -0.42067388f, -0.35249481f, 0.48862731f, 0.23708805f, 0.24735405f, 0.34213427f, 
    0.21987921f, -0.72356099f, 0.84483153f, -0.00618524f, -0.24556416f, 0.43075839f, -0.11837146f, -0.31693462f, 
    -0.00019836f, 0.01421401f, 0.26583898f, 0.12863360f, 0.05899824f, -0.39939311f, -0.58116889f, 0.52059621f, 
    0.06137835f, -0.12115593f, -0.37286314f, 0.23511487f, 0.31884187f, 0.46795580f, 0.37528422f, 0.23058258f, 
    0.36486733f, -0.03133834f, -0.13211381f, -0.01809325f, 0.45792904f, 0.40544155f, 0.38358843f, 0.36165053f, 
    0.24757655f, -0.10279312f, -0.35650533f, 0.29510728f, 0.16147545f, -0.47483197f, -0.25932276f, -0.06772858f, 
    -0.38296965f, -0.16376522f, 0.49466786f, 0.36141220f, 0.26382637f, 0.38108182f, 0.50780118f, 0.30191550f, 
    0.43195659f, 0.26434654f, -0.43252379f, 0.31638345f, -0.01272213f, 0.20265640f, -0.30956829f, -0.64918762f, 
    -0.22267090f, -0.37075073f, 0.08435096f, 0.60069782f, -0.05287464f, 0.20659946f, -0.11430742f, 0.03929479f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.06429752f, 0.27356398f, 0.06907235f, 0.35939774f, -0.38175476f, -0.19032118f, -0.12442237f, -0.18539977f, 
    0.02330719f, -0.04599054f, -0.23023331f, -0.17164019f, -0.12175332f, -0.23800041f, -0.02031511f, 0.21272193f, 
    0.09854551f, -0.25598511f, -0.07738852f, -0.14293200f, -0.27516130f, -0.28278148f, -0.05360934f, 0.28008217f, 
    -0.27324763f, -0.23550287f, 0.09230478f, 0.20390356f, -0.02425543f, 0.05370929f, 0.19589956f, 0.18593754f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.03976657f, 0.04321828f, -0.02999494f, -0.03563419f, -0.05365571f, -0.02570429f, -0.03550442f, -0.01990690f, 
    0.05504534f, -0.05696362f, 0.03132910f, 0.01853240f, -0.03804228f, -0.05719320f, -0.03103986f, -0.03526744f, 
    0.02889048f, 0.01476484f, -0.00035366f, -0.02885909f, -0.01422524f, -0.00085440f, 0.05121475f, -0.05154383f, 
    0.05187186f, 0.05158367f, 0.00603589f, 0.00207253f, 0.02712218f, -0.05132908f, -0.04478665f, -0.05054323f, 
    -0.03701673f, 0.03140658f, -0.01872606f, -0.00386449f, 0.03852125f, 0.05107326f, -0.03539789f, -0.00660326f, 
    0.05445499f, -0.01838776f, 0.01171818f, -0.04259169f, 0.00283903f, 0.05618408f, -0.02867538f, 0.03752649f, 
    0.03109937f, -0.05183876f, -0.03251436f, 0.05764042f, -0.03740035f, 0.03058206f, 0.02611039f, -0.00481812f, 
    0.00970043f, -0.03159774f, -0.00088628f, -0.00721335f, 0.02539908f, -0.02273492f, -0.02113556f, 0.05289329f, 
    0.02269336f, -0.02292909f, -0.01208766f, -0.04634345f, -0.04024617f, -0.05691140f, 0.03524825f, -0.05313919f, 
    -0.04168914f, 0.01890897f, 0.02915375f, 0.04308658f, -0.00912311f, -0.04253568f, -0.00952547f, -0.01074972f, 
    0.00450289f, -0.01736038f, -0.03310678f, -0.03436890f, 0.04534198f, -0.01496607f, -0.03183732f, 0.01528707f, 
    -0.02310676f, -0.04949338f, 0.00158138f, 0.02804130f, -0.02568719f, -0.01969008f, -0.04380750f, 0.05402671f, 
    -0.01399336f, -0.04359176f, -0.04563637f, -0.01003066f, 0.01743657f, 0.00898845f, -0.04528984f, -0.03974374f, 
    -0.04505080f, -0.02752368f, 0.03210092f, 0.01853883f, -0.01600713f, -0.05611802f, -0.03512827f, -0.02109022f, 
    0.01916238f, 0.03021976f, 0.05307098f, -0.02814443f, -0.02246601f, -0.02429380f, -0.00512981f, 0.00377752f, 
    0.02173583f, -0.01206624f, -0.00674263f, 0.01833047f, 0.04894318f, -0.04894676f, 0.05045282f, -0.04262855f, 
    -0.02582729f, -0.01411742f, -0.04470948f, -0.04125054f, 0.03692615f, -0.02436056f, 0.02236460f, 0.03103488f, 
    0.04821312f, -0.01740102f, -0.04924375f, 0.03366395f, -0.04137325f, 0.02085563f, -0.05241333f, 0.05448954f, 
    0.01400550f, 0.05422860f, -0.04834442f, 0.04155121f, -0.05521616f, 0.00768054f, 0.03251375f, -0.00100509f, 
    0.01375571f, -0.02953339f, 0.02247730f, -0.04485455f, -0.01784833f, -0.03537183f, -0.05045290f, 0.00400602f, 
    0.05816715f, 0.00957874f, 0.00928824f, 0.01841649f, -0.00912701f, 0.00572264f, -0.05563841f, 0.04316276f, 
    0.02183642f, 0.01958589f, 0.02053428f, -0.04641932f, -0.03504860f, -0.05863458f, -0.04792390f, -0.00016906f, 
    -0.04162516f, 0.00760801f, -0.02745622f, -0.02650171f, -0.02331447f, 0.00399837f, -0.03947671f, -0.00398442f, 
    -0.01390636f, 0.02938976f, 0.02426728f, -0.04667364f, -0.04683815f, 0.02465460f, -0.00336682f, 0.02779819f, 
    -0.01961447f, -0.03362985f, 0.01790388f, 0.00467384f, 0.00138225f, 0.02934193f, -0.05698593f, -0.04603917f, 
    0.00296231f, 0.03558461f, 0.01385328f, -0.02063438f, -0.00633220f, -0.03949008f, 0.00635801f, 0.00381660f, 
    0.05686034f, -0.02706983f, 0.01029463f, -0.01876232f, -0.04034929f, -0.02247386f, 0.01106261f, 0.01709558f, 
    -0.00937944f, 0.03628184f, -0.03809578f, -0.00298136f, 0.01283153f, -0.00798954f, 0.01065932f, -0.03090254f, 
    0.05523741f, -0.03263704f, -0.01559577f, -0.00864065f, -0.02239183f, -0.04561328f, -0.03622276f, -0.03566378f, 
    -0.01507968f, -0.02304900f, -0.03844720f, 0.02350717f, -0.01406245f, -0.04714973f, -0.02198732f, -0.01859098f, 
    -0.04164277f, -0.02242845f, 0.04641356f, 0.04705991f, -0.02275735f, 0.00473174f, -0.03494933f, -0.01704723f, 
    -0.04582505f, 0.01568192f, 0.00765092f, 0.05563615f, 0.05770148f, 0.01649172f, 0.04707109f, 0.04132894f, 
    -0.00578329f, -0.00446204f, -0.05563159f, 0.04008542f, -0.02337919f, -0.05518147f, 0.03759376f, -0.04289063f, 
    -0.01906115f, 0.00201698f, -0.02112937f, 0.00049085f, 0.03874638f, 0.05660871f, 0.00440678f, -0.04533787f, 
    -0.01581172f, -0.03672479f, -0.03339720f, 0.01836859f, 0.01900874f, 0.05403449f, -0.01581777f, -0.00783357f, 
    -0.02148344f, -0.04554327f, -0.04770452f, -0.03569864f, 0.03635550f, -0.01436931f, -0.05462582f, 0.01570527f, 
    0.00973399f, 0.01295660f, -0.05021767f, -0.06505174f, 0.04358229f, 0.02844719f, -0.04309955f, -0.03181785f, 
    -0.02511372f, -0.03480728f, -0.06275016f, -0.03297245f, -0.01566139f, -0.01098625f, -0.00030202f, -0.05074108f, 
    0.01138994f, 0.00671021f, 0.00473274f, 0.04404165f, 0.00840125f, -0.02716508f, -0.00464558f, -0.05562701f, 
    0.03504269f, 0.01135802f, -0.03858706f, 0.02639388f, 0.03616135f, 0.00060002f, -0.04263989f, -0.01552937f, 
    -0.05607697f, -0.03494845f, 0.04527307f, -0.05351074f, 0.04342043f, 0.04035344f, 0.01392815f, -0.03311288f, 
    -0.03751028f, -0.00261837f, 0.03730026f, -0.05877792f, 0.03713561f, 0.01419079f, 0.03868250f, -0.00367945f, 
    -0.02815671f, -0.05494970f, -0.06667272f, 0.00977014f, 0.00824421f, -0.01180420f, -0.03766255f, -0.03406654f, 
    -0.03507102f, -0.03156919f, -0.00914958f, 0.00393917f, -0.02816837f, -0.01784879f, 0.01174779f, -0.04215590f, 
    0.01387866f, -0.05883245f, -0.01285913f, -0.01439840f, 0.01017997f, 0.01022412f, -0.03637016f, 0.00168249f, 
    0.04312468f, 0.03828087f, -0.02530387f, -0.04963909f, -0.02065459f, 0.03937611f, -0.01370237f, -0.04029232f, 
    0.04982328f, 0.05037772f, -0.05386532f, -0.03515506f, -0.03824365f, -0.03745760f, -0.01989633f, -0.04353048f, 
    -0.03773479f, -0.03955602f, -0.06100957f, 0.04730713f, -0.02072450f, -0.03256043f, -0.06088423f, 0.03563698f, 
    -0.02244479f, 0.04118470f, -0.02842426f, 0.02925780f, 0.01584246f, 0.01401817f, 0.03627788f, 0.04083186f, 
    0.02850023f, 0.00073109f, -0.04478250f, 0.03857611f, 0.01969332f, -0.01226281f, 0.04832596f, 0.02162860f, 
    -0.02264533f, -0.04496809f, -0.02501127f, 0.00865414f, -0.01826220f, -0.03713182f, 0.02329517f, 0.01726696f, 
    -0.00582030f, 0.02891328f, 0.04051986f, 0.02570671f, -0.06129542f, 0.00663336f, 0.02827195f, -0.03461591f, 
    -0.04709131f, -0.00398946f, -0.06412602f, -0.06510240f, 0.03219102f, -0.03935090f, -0.06528936f, -0.01837720f, 
    0.01379886f, 0.03755667f, -0.02271104f, -0.01615854f, 0.04563146f, 0.02221445f, -0.02438180f, -0.00595842f, 
    0.01418388f, -0.04857309f, 0.04556155f, 0.03172139f, 0.01317725f, 0.00947507f, 0.01722863f, -0.04917106f, 
    -0.05988388f, -0.02029838f, -0.05715025f, 0.02992179f, 0.00123643f, -0.00818671f, 0.01995791f, -0.00594098f, 
    0.04464043f, 0.04008920f, 0.03572022f, 0.01319768f, 0.03291287f, -0.05832654f, -0.00619180f, -0.06933764f, 
    -0.06239463f, -0.05329458f, -0.01116648f, 0.03172549f, -0.04704472f, -0.03092634f, -0.02284591f, -0.01588200f, 
    0.00850572f, 0.04430427f, -0.03019947f, 0.02167317f, 0.03564592f, 0.04013397f, 0.03290812f, -0.07083604f, 
    -0.00461378f, -0.05859031f, 0.04620355f, -0.03251128f, -0.00289970f, -0.02501430f, 0.00232290f, 0.03175895f, 
    0.03656109f, -0.06082202f, 0.04136981f, 0.02280026f, -0.03014387f, 0.04112485f, 0.01344233f, 0.00911771f, 
    0.02141288f, -0.00601464f, -0.06855372f, -0.01222760f, -0.01955190f, 0.02355956f, 0.00529334f, 0.02813239f, 
    -0.00233535f, 0.04115305f, -0.04027505f, 0.04617313f, -0.04867264f, 0.01850715f, 0.01126524f, 0.04799491f, 
    0.03796635f, 0.02749142f, -0.05363450f, -0.02333828f, 0.01293134f, -0.02704457f, 0.01193590f, 0.03580707f, 
    -0.00115244f, 0.04335899f, -0.04436045f, 0.01401482f, 0.04096117f, -0.03212051f, -0.00445249f, 0.02412097f, 
    0.01273759f, 0.03214994f, 0.03178455f, -0.05202395f, 0.01382263f, -0.03219359f, 0.01193795f, -0.05368159f, 
    0.04222935f, 0.02363805f, 0.00311628f, -0.06465261f, -0.02387182f, 0.04900604f, -0.00888825f, 0.03328265f, 
    -0.04530994f, 0.02373563f, -0.05489169f, -0.01477569f, 0.02185304f, 0.03757278f, -0.02063576f, -0.06408843f, 
    -0.02667724f, 0.02203796f, -0.05719925f, 0.00959235f, -0.03951872f, -0.00123612f, -0.06324939f, -0.05907366f, 
    0.04648133f, 0.01144616f, 0.00218410f, 0.03850286f, -0.02596240f, -0.05683301f, 0.01842033f, -0.06997918f, 
    -0.02932087f, 0.01449765f, 0.00723885f, 0.00108253f, -0.04758361f, -0.06624607f, 0.02651351f, 0.04482028f, 
    -0.01546977f, -0.06698196f, 0.05060257f, 0.02534023f, 0.03608606f, 0.04732282f, -0.03309557f, -0.03887594f, 
    0.01849236f, 0.03439240f, -0.01170856f, -0.00705560f, -0.08996492f, -0.03797062f, 0.07822914f, 0.04257382f, 
    0.17761140f, 0.08345529f, 0.03987534f, -0.13476896f, -0.06849991f, -0.00874318f, 0.18031850f, 0.14113034f, 
    0.14756989f, 0.00481504f, 0.05125114f, 0.06445369f, 0.03561579f, -0.08895487f, 0.06373698f, -0.04575736f, 
    0.00202680f, 0.04948188f, -0.01046022f, -0.07159363f, -0.11803751f, -0.14169219f, 0.14837773f, 0.06730655f, 
    0.08142921f, -0.06377345f, 0.07779031f, 0.13296850f, -0.31419066f, -0.13381387f, 0.05903622f, 0.03080656f, 
    -0.14127676f, 0.05687903f, 0.05420825f, -0.19477090f, 0.15447134f, -0.09417248f, -0.09986956f, -0.04350654f, 
    0.06898019f, 0.00818481f, -0.11112198f, -0.05930715f, -0.16197714f, 0.08405433f, -0.19872564f, -0.05606543f, 
    -0.06445770f, 0.06675550f, 0.06454191f, -0.00425885f, 0.02942797f, 0.05164680f, 0.03860002f, -0.08437565f, 
    0.04017853f, -0.31135806f, 0.05775290f, -0.05179862f, 0.03545314f, 0.01810358f, 0.19409733f, 0.08630201f, 
    0.06883523f, 0.08923630f, -0.02565306f, -0.00477908f, 0.08914248f, -0.09417684f, 0.04450133f, 0.15206665f, 
    0.04311448f, 0.22211412f, 0.06955843f, -0.07995857f, 0.04507837f, -0.06047910f, -0.08817638f, 0.11248469f, 
    -0.11687635f, -0.03964397f, -0.33055013f, -0.20696014f, -0.01639608f, 0.13230176f, 0.11798894f, -0.05140597f, 
    0.15026426f, 0.03715720f, 0.11531770f, 0.21460226f, 0.08158693f, 0.05572618f, -0.01326506f, -0.12915237f, 
    -0.04815941f, -0.02660476f, 0.12652741f, 0.02313329f, 0.05219884f, -0.10213444f, 0.07411319f, -0.08553958f, 
    0.07325760f, 0.05315170f, 0.05647359f, -0.01680327f, -0.10024145f, 0.14941400f, -0.16967858f, -0.17154971f, 
    -0.01102041f, -0.09027234f, 0.06288460f, -0.01321127f, 0.05362227f, -0.26190719f, 0.04921618f, -0.04451766f, 
    -0.03467186f, -0.11113833f, -0.26049143f, -0.04997025f, 0.03640580f, 0.07626217f, -0.03142177f, 0.00657961f, 
    0.00548205f, -0.05531478f, 0.07569125f, -0.04496776f, -0.01472364f, -0.00492826f, 0.02093650f, -0.03361585f, 
    0.06786211f, 0.01759755f, 0.02899387f, 0.04694926f, -0.00301033f, 0.03018258f, 0.05894423f, 0.05947448f, 
    0.01025533f, 0.08781639f, 0.00985873f, -0.01082146f, 0.00104357f, -0.14291379f, 0.10296874f, -0.02239119f, 
    0.11417090f, -0.12445831f, -0.14243434f, -0.20523636f, -0.17146748f, 0.03230246f, 0.14931929f, -0.02440092f, 
    -0.05337280f, 0.05681282f, -0.17206873f, 0.11635626f, 0.06429157f, -0.02867047f, 0.01036888f, -0.03724234f, 
    0.06870315f, -0.13819948f, 0.12373690f, 0.01009169f, 0.01422589f, -0.11346969f, 0.22095343f, 0.09346318f, 
    -0.07699464f, -0.03162715f, 0.05329999f, -0.15448441f, -0.04859794f, 0.11313151f, -0.08640072f, -0.15337534f, 
    0.13586751f, 0.03980144f, 0.05981458f, -0.09545644f, 0.08945066f, -0.02256432f, 0.09249130f, 0.07336392f, 
    0.02335205f, 0.04775057f, -0.00326430f, 0.04480029f, 0.03794227f, 0.02157792f, -0.13434033f, 0.13685068f, 
    0.16023396f, 0.02160622f, -0.01561801f, 0.08058888f, 0.08005290f, -0.15606083f, 0.00034753f, 0.05048485f, 
    -0.14812402f, -0.05044844f, -0.02029937f, -0.02700160f, -0.19592550f, 0.05978934f, 0.08860879f, 0.06886498f, 
    0.01533055f, -0.18098174f, 0.02212226f, 0.04496705f, 0.07113661f, -0.11359276f, -0.05487936f, -0.09416967f, 
    -0.13719182f, -0.10354031f, 0.05263747f, -0.18779932f, -0.10923705f, 0.05597149f, -0.00265239f, -0.02707429f, 
    -0.01057682f, 0.10708477f, 0.00815012f, -0.28924793f, -0.13508016f, -0.19303742f, 0.09369396f, 0.09836328f, 
    0.05458397f, -0.00748752f, -0.08176371f, 0.09505238f, -0.12092413f, -0.02690799f, -0.17203690f, 0.02967287f, 
    0.01225693f, -0.00950798f, -0.05051321f, -0.09393486f, 0.04885521f, -0.00357717f, 0.10993992f, -0.13891642f, 
    0.01639909f, -0.08182304f, -0.09553163f, 0.06645674f, -0.02497438f, 0.02566441f, -0.09021766f, -0.15614741f, 
    0.01227494f, 0.09216865f, -0.05159583f, 0.03215027f, 0.07291019f, 0.05753207f, 0.09962702f, 0.18515910f, 
    0.02904963f, 0.06412532f, -0.04188723f, 0.15398090f, -0.11591268f, 0.08245574f, 0.07619341f, -0.03433629f, 
    0.22000046f, 0.02701448f, 0.00188836f, -0.01779192f, 0.06883650f, -0.03162438f, 0.14143191f, 0.03632053f, 
    -0.06662823f, 0.04096274f, 0.00106681f, -0.04739792f, -0.00270418f, 0.01488418f, 0.00697711f, -0.05430375f, 
    -0.00078860f, 0.14176168f, 0.33629254f, 0.08576693f, 0.13356754f, 0.03167681f, 0.02190009f, -0.04537817f, 
    -0.00356229f, -0.12091550f, 0.09315560f, -0.12068475f, -0.17409737f, 0.04306901f, -0.01499704f, 0.06872158f, 
    0.11448751f, -0.05506857f, -0.09455685f, -0.04628536f, -0.23678054f, 0.09830696f, -0.12626475f, -0.04336439f, 
    0.09946766f, -0.06165480f, -0.06440958f, -0.08275601f, -0.00456875f, -0.05238762f, -0.00664915f, -0.10911234f, 
    0.04588297f, 0.11841034f, 0.03073669f, -0.05434746f, -0.10460486f, -0.03973939f, -0.25129595f, 0.16400363f, 
    0.04544041f, 0.01457001f, 0.08863459f, 0.06924935f, -0.07647007f, -0.04080213f, -0.06033826f, 0.01532687f, 
    -0.12963088f, 0.02060524f, -0.24867921f, -0.00431286f, 0.12076813f, 0.09584110f, -0.01691663f, 0.05532768f, 
    -0.05697799f, 0.20447120f, 0.07826649f, 0.03574803f, 0.02201891f, 0.01828843f, 0.00812469f, -0.07241814f, 
    0.10601917f, 0.05845218f, -0.00928655f, 0.09774862f, 0.03997160f, -0.13042182f, -0.22552167f, 0.05761718f, 
    0.07508216f, 0.03577262f, -0.30155340f, -0.17798342f, 0.02133055f, -0.02782726f, 0.10685299f, 0.06873692f, 
    0.06442706f, 0.05639849f, 0.09174323f, 0.46863809f, 0.16354704f, 0.11302090f, -0.05108823f, -0.20660032f, 
    -0.01546734f, 0.01264493f, 0.05424872f, 0.05843054f, -0.18755226f, -0.45596093f, 0.17497826f, -0.02840216f, 
    0.09717058f, -0.08484109f, -0.13033623f, 0.04196170f, -0.12556495f, -0.14473805f, 0.03444971f, 0.00714340f, 
    0.02764533f, 0.13930719f, 0.12912729f, -0.10757258f, -0.15719612f, -0.02828062f, 0.21554549f, -0.19095814f, 
    0.16550139f, -0.14718600f, -0.04273203f, -0.06645311f, -0.12229466f, 0.00678949f, -0.02945865f, -0.07116233f, 
    -0.12270807f, -0.08276922f, -0.09376207f, -0.18796940f, -0.11931396f, 0.10681165f, 0.00428364f, 0.00509517f, 
    -0.12740265f, 0.07086324f, -0.02487973f, 0.01899092f, 0.08842368f, 0.08070818f, -0.08529978f, -0.05363694f, 
    0.01741973f, -0.20654219f, -0.25849816f, 0.06623601f, 0.00173178f, 0.10067259f, 0.08669630f, -0.00925757f, 
    -0.06194950f, 0.10585929f, -0.12915161f, 0.12425984f, -0.15368596f, -0.04865867f, -0.09040810f, 0.00702055f, 
    -0.04240080f, 0.10135211f, 0.19345556f, -0.05144967f, 0.03570120f, 0.08192627f, -0.12303009f, -0.06230610f, 
    -0.00983786f, -0.06198824f, 0.11062121f, 0.09542215f, 0.28314120f, -0.18412587f, -0.12735923f, -0.08174085f, 
    0.24032424f, -0.01443503f, 0.07710563f, -0.03159976f, 0.04649510f, 0.07396764f, 0.11785129f, 0.05226873f, 
    0.08723000f, 0.07840112f, -0.00036303f, 0.01534871f, -0.10299904f, -0.02002044f, -0.15297562f, -0.18345125f, 
    -0.00249431f, -0.12659003f, 0.00254227f, 0.03644254f, -0.05500813f, -0.02370775f, -0.01372135f, 0.26181817f, 
    0.10713869f, 0.04320646f, 0.03770177f, 0.09440164f, -0.00555230f, -0.12851767f, 0.01991851f, 0.02584695f, 
    0.30502233f, -0.00875069f, 0.00994832f, -0.23080464f, 0.11302063f, 0.11028177f, 0.12129140f, -0.14874795f, 
    0.04953928f, 0.12808113f, -0.07115985f, -0.17156276f, -0.10724694f, 0.11151481f, 0.03552780f, -0.13510327f, 
    -0.06057092f, 0.01114642f, -0.22967413f, 0.01555405f, -0.08701984f, -0.02922470f, -0.09197991f, 0.11050807f, 
    -0.11939265f, 0.06245718f, 0.06499108f, -0.29286468f, -0.02437205f, -0.02834241f, -0.02043047f, 0.08137371f, 
    0.07538313f, -0.06494995f, -0.06552979f, 0.03129842f, -0.24210502f, -0.26698637f, 0.11173618f, -0.06339119f, 
    0.05922516f, 0.07219628f, -0.05843132f, -0.07647521f, -0.04533054f, 0.17164342f, -0.02233757f, -0.02608278f, 
    -0.12092791f, 0.09678400f, -0.15474965f, 0.02367563f, -0.08207741f, -0.10739382f, -0.11666714f, -0.06882524f, 
    -0.00829556f, 0.06588446f, 0.08249298f, 0.13311800f, -0.11780803f, -0.13979909f, -0.02570718f, 0.32439834f, 
    0.07017736f, 0.09098569f, -0.06118912f, -0.06841370f, -0.04842360f, 0.08588985f, 0.03363406f, 0.04937009f, 
    -0.05825364f, -0.25365025f, -0.02955502f, 0.05631171f, -0.02164060f, 0.07992005f, -0.01370333f, -0.11534023f, 
    0.02422982f, -0.00567488f, -0.07077119f, -0.12843809f, 0.03455992f, 0.01062875f, 0.02144188f, 0.04662512f, 
    -0.08468166f, -0.04791094f, -0.14330778f, -0.05347056f, 0.17220573f, -0.01015294f, 0.04811985f, 0.08071499f, 
    0.02156221f, -0.04156863f, 0.06097912f, 0.11322298f, 0.23193955f, -0.12422828f, 0.00574379f, -0.06417038f, 
    0.12993422f, -0.04053744f, -0.05758848f, -0.04512893f, 0.10331945f, 0.08212153f, -0.16096196f, -0.09657346f, 
    0.10590153f, -0.09741352f, 0.04451523f, 0.18469198f, 0.01025317f, -0.08264395f, 0.06660418f, -0.06008569f, 
    0.03568460f, -0.03732647f, -0.04532573f, -0.04037119f, 0.02737725f, -0.10189283f, 0.19571619f, 0.09904057f, 
    -0.00579403f, -0.01895607f, -0.10189707f, 0.06036901f, 0.04537955f, -0.09292742f, -0.05373028f, -0.05287027f, 
    -0.05945355f, -0.17333342f, 0.13553715f, 0.00462760f, 0.05323769f, -0.01971320f, -0.03270116f, -0.00214901f, 
    -0.09420969f, -0.17070247f, 0.23533842f, -0.01180485f, 0.09816667f, -0.00870991f, -0.01529966f, -0.13192064f, 
    0.15091200f, 0.03611616f, -0.06937970f, -0.08236400f, 0.03970053f, 0.02375705f, -0.19473016f, -0.04185778f, 
    0.09219096f, -0.03101184f, 0.05917636f, 0.00032934f, -0.11869358f, 0.01192166f, 0.01658664f, -0.02149892f, 
    -0.11203446f, -0.00559137f, -0.12913658f, -0.05675854f, -0.20340087f, 0.21378449f, 0.06625389f, -0.11773517f, 
    0.01837788f, -0.00707717f, 0.01036256f, -0.02013916f, -0.05708899f, 0.08132334f, 0.13471639f, -0.06061621f, 
    -0.00499950f, -0.03328872f, -0.10285518f, -0.08757082f, -0.07686744f, -0.14049006f, 0.11791998f, 0.07091917f, 
    -0.09584244f, 0.03664666f, 0.03806302f, 0.02654225f, 0.14454442f, -0.14719611f, 0.14821358f, -0.19775850f, 
    0.09673328f, 0.08689504f, -0.04752616f, -0.04522925f, 0.02098352f, 0.07805028f, 0.09622902f, -0.16711095f, 
    -0.07201447f, 0.17907250f, 0.02885015f, -0.05707276f, -0.05148480f, 0.05305919f, 0.00965038f, 0.03978089f, 
    0.01161186f, 0.03723950f, 0.05294715f, 0.13440739f, 0.05497889f, -0.07245406f, 0.09320288f, -0.03224236f, 
    0.01630369f, -0.04269851f, -0.11902481f, 0.41182369f, 0.00491090f, -0.14207850f, -0.02796041f, 0.00589925f, 
    -0.01279203f, 0.05129462f, -0.00071970f, 0.21118788f, 0.04397142f, -0.11647419f, -0.11392219f, 0.22865406f, 
    -0.06572719f, -0.05340851f, -0.14716724f, -0.12825654f, 0.14564376f, 0.05180379f, -0.03692666f, 0.02676499f, 
    0.20452286f, -0.03422617f, -0.08389387f, 0.03876916f, -0.03398836f, 0.15024789f, -0.27086389f, -0.10323348f, 
    0.04138175f, -0.01736142f, 0.07407191f, 0.00267087f, 0.10457318f, -0.12848482f, 0.20057668f, 0.03486618f, 
    0.02555605f, -0.08462761f, -0.00377498f, -0.16725653f, -0.00186917f, -0.06799138f, 0.23429449f, -0.06288236f, 
    0.32287112f, 0.07237863f, -0.01209560f, -0.04504362f, 0.05211796f, 0.03180088f, 0.08643785f, -0.05520475f, 
    0.08067998f, 0.02368455f, 0.05503014f, 0.02131919f, -0.09547217f, -0.04527450f, 0.03072519f, -0.12101868f, 
    0.04562279f, 0.01662381f, 0.00179352f, 0.00459869f, 0.03130586f, 0.09407920f, -0.06893393f, -0.01779431f, 
    0.03068134f, 0.15282357f, 0.23256655f, 0.03952251f, 0.02251198f, -0.08220430f, 0.07868997f, -0.01364799f, 
    -0.03664010f, 0.02459815f, -0.05067441f, -0.00179659f, -0.09209721f, -0.09645279f, 0.06891303f, 0.02402570f, 
    0.07891173f, 0.05077730f, 0.01319358f, 0.07685075f, 0.07093737f, -0.11422160f, -0.03103155f, -0.06242618f, 
    0.18348025f, 0.00629723f, -0.08084321f, 0.06001343f, 0.05320569f, 0.17871961f, -0.19713362f, 0.09307612f, 
    -0.09982380f, 0.20530021f, 0.05415878f, -0.07939735f, 0.00605917f, 0.02317265f, -0.02523752f, -0.07752272f, 
    -0.04053484f, 0.01253755f, 0.12190821f, -0.02121502f, -0.07798807f, 0.02390935f, 0.02430666f, -0.00844035f, 
    -0.11203414f, -0.03311474f, 0.07974809f, 0.06017959f, -0.11626130f, 0.04998341f, -0.06737394f, -0.07939790f, 
    -0.18168406f, 0.16840810f, -0.00931312f, -0.08694606f, -0.02704808f, -0.10392698f, 0.07977916f, 0.04262099f, 
    0.05860027f, 0.03469474f, -0.10643627f, -0.02899964f, 0.06963684f, 0.01999607f, -0.01035932f, 0.00126371f, 
    0.01718333f, 0.13445975f, -0.01261558f, -0.07650007f, 0.02005894f, 0.02215843f, -0.09778874f, 0.07095039f, 
    0.04802833f, 0.06756900f, 0.11911035f, 0.04908972f, -0.08347359f, 0.00812521f, -0.00383645f, 0.00676224f, 
    0.02068667f, 0.02669371f, 0.07441460f, -0.06001900f, 0.16737336f, -0.04479887f, 0.03306906f, 0.07941759f, 
    0.09914342f, -0.08008394f, 0.05388036f, 0.02190406f, -0.24446383f, -0.09903885f, -0.14772707f, 0.04104059f, 
    -0.04447953f, -0.02362758f, -0.17151888f, -0.07162111f, 0.15836824f, -0.38150442f, -0.20930696f, 0.09397890f, 
    0.02722395f, 0.09229264f, -0.01002391f, -0.12786248f, 0.04953902f, 0.03912150f, -0.18497759f, -0.20163749f, 
    -0.16890466f, 0.02698470f, 0.02350669f, -0.05697368f, -0.00456310f, -0.00406735f, 0.01505761f, -0.17163776f, 
    0.01899385f, -0.29414225f, -0.09666473f, -0.02436890f, -0.06958136f, 0.09656745f, 0.09120682f, -0.11429826f, 
    0.03397677f, 0.06403042f, -0.01460617f, 0.01722605f, 0.17286792f, -0.07149002f, -0.06343443f, 0.06030128f, 
    -0.03538013f, -0.10508203f, 0.15669927f, -0.07549854f, -0.09158171f, -0.02428466f, -0.21039164f, 0.00170697f, 
    0.18322821f, -0.16833201f, -0.41002095f, -0.06815548f, -0.07835823f, -0.06282069f, 0.08918083f, -0.05615624f, 
    -0.00187816f, 0.06759222f, -0.09526017f, 0.09562174f, 0.21329708f, -0.09103361f, -0.03992417f, -0.01774353f, 
    -0.00072484f, -0.00096085f, -0.00115675f, 0.01903648f, 0.16359264f, 0.07413301f, 0.13419224f, -0.04888052f, 
    0.03157641f, -0.02502292f, -0.05748311f, -0.07714771f, -0.05852921f, -0.21873663f, -0.05815635f, 0.02776907f, 
    0.04042352f, -0.05790250f, 0.01944606f, 0.05081397f, 0.01672379f, 0.02438117f, 0.08527840f, -0.10583688f, 
    -0.01759956f, 0.03949657f, -0.06409898f, -0.14867540f, -0.03702325f, -0.00469949f, -0.03354030f, 0.11732031f, 
    -0.05900794f, 0.12657304f, 0.02301442f, -0.04197129f, 0.10736650f, 0.02186311f, -0.04490288f, 0.04481698f, 
    0.12700845f, 0.03947597f, -0.09486353f, 0.12373975f, 0.04392386f, -0.08217263f, 0.14974296f, -0.04763670f, 
    0.24036334f, 0.04909224f, 0.03857913f, 0.16876400f, -0.02901458f, 0.11643634f, -0.11773240f, 0.02078454f, 
    -0.07884949f, -0.01396475f, -0.05354764f, 0.00247171f, -0.07712753f, -0.01981161f, -0.00525712f, -0.10784959f, 
    0.01849197f, -0.01002585f, -0.08209126f, -0.08610710f, 0.00358016f, 0.11603528f, -0.03987634f, 0.07002527f, 
    0.00821253f, 0.04039960f, 0.06110787f, -0.08999939f, 0.18241091f, 0.01917191f, -0.16699666f, 0.13107938f, 
    -0.07222357f, -0.03952523f, 0.06781884f, -0.00000249f, -0.06942306f, -0.21007597f, 0.00168417f, 0.11791211f, 
    -0.05856217f, 0.03224532f, 0.04371340f, -0.10474659f, 0.11419007f, 0.01729198f, -0.09332607f, -0.00998120f, 
    0.12855355f, 0.10996681f, -0.01467077f, 0.11365430f, 0.09528743f, -0.09363432f, -0.01269089f, 0.04433611f, 
    0.18301117f, 0.12621568f, 0.14556207f, -0.03484943f, 0.05592855f, -0.06509576f, 0.02965225f, 0.13638307f, 
    -0.19510022f, -0.09166946f, -0.04086646f, -0.04493090f, 0.03066103f, -0.01509050f, -0.05841336f, 0.11506754f, 
    -0.06352940f, -0.08018871f, 0.06311533f, -0.07553650f, 0.02159102f, -0.11530130f, -0.07991692f, -0.11056619f, 
    0.03565373f, -0.17454313f, -0.05881469f, 0.04437803f, -0.00255269f, 0.06694434f, 0.01600779f, -0.06808107f, 
    0.02638085f, 0.02269663f, 0.02791333f, -0.12443401f, 0.02419138f, -0.12972879f, -0.00775920f, 0.02205559f, 
    0.05408281f, -0.02132772f, 0.06668098f, -0.01522097f, -0.17163439f, -0.06343728f, -0.21286549f, -0.01306642f, 
    0.08246271f, 0.03609675f, 0.06775016f, 0.13582765f, -0.02562381f, 0.02769097f, -0.04307394f, -0.01797289f, 
    0.13462090f, -0.00666700f, -0.09898678f, 0.08440004f, -0.03910935f, 0.02917471f, -0.19174385f, -0.08264937f, 
    0.00743920f, 0.07182149f, -0.01837684f, 0.00892726f, 0.02914347f, -0.03217018f, 0.00035618f, 0.10976390f, 
    0.16437605f, 0.01078408f, 0.03401897f, 0.00102796f, 0.03188793f, 0.04726820f, -0.06635778f, 0.14732225f, 
    0.04714272f, 0.00310530f, -0.04064626f, 0.02280924f, -0.00060592f, -0.04009728f, 0.01540761f, 0.04755199f, 
    -0.05123211f, -0.02237440f, 0.04509464f, 0.04493084f, -0.05117555f, -0.05575795f, -0.03207101f, 0.02865015f, 
    0.04541408f, -0.02686403f, 0.04906455f, 0.00670482f, -0.06129843f, 0.01453826f, -0.05746104f, 0.00637339f, 
    -0.00873241f, 0.02001241f, -0.02394413f, 0.03148052f, -0.01127974f, -0.05725496f, -0.03798185f, 0.03780801f, 
    -0.01617071f, 0.02196261f, 0.03379840f, 0.03726992f, -0.04098691f, 0.01674475f, 0.02390710f, 0.00295114f, 
    -0.02235548f, -0.01949979f, -0.01680915f, -0.05372458f, 0.02697491f, 0.02467952f, -0.04408618f, 0.01968503f, 
    0.03927804f, 0.01120305f, 0.02618118f, 0.02111258f, -0.00566221f, 0.04860321f, -0.00225622f, 0.02899420f, 
    -0.02722407f, -0.05385197f, -0.03205750f, 0.02509624f, -0.06376016f, -0.01302538f, -0.01572537f, 0.01539494f, 
    0.01756518f, -0.02572854f, 0.04572011f, 0.00336588f, -0.00935259f, -0.04255456f, 0.00089794f, 0.03511456f, 
    -0.00277631f, 0.02533125f, 0.02513792f, 0.03622679f, -0.02044803f, 0.03659547f, 0.02910095f, 0.02508396f, 
    -0.01853350f, -0.05111570f, 0.01761638f, -0.02065233f, -0.01137870f, 0.00558822f, -0.06173389f, -0.04172408f, 
    -0.01174505f, -0.04808915f, -0.04614676f, 0.02817777f, 0.04649346f, 0.02063157f, 0.03010594f, -0.02012314f, 
    -0.03175990f, 0.02511607f, -0.06704585f, 0.01882372f, -0.05563317f, -0.03724479f, -0.03106817f, 0.04007389f, 
    -0.03288483f, 0.00732964f, 0.03236919f, -0.04733424f, 0.04101411f, -0.03571510f, -0.02460935f, -0.02658184f, 
    -0.06472834f, -0.06602240f, -0.06395379f, -0.04993548f, -0.04144634f, -0.03251485f, -0.00723588f, 0.03358698f, 
    -0.04248232f, -0.00999619f, 0.03350550f, -0.05240448f, 0.03434256f, 0.03488516f, -0.03892910f, -0.05254277f, 
    0.02525313f, 0.01184142f, 0.01048139f, 0.00104921f, 0.01172231f, 0.00994153f, -0.02890614f, 0.00946815f, 
    -0.02369406f, 0.03192169f, 0.01975784f, -0.04322141f, 0.04003445f, -0.06432027f, -0.06597693f, 0.01142393f, 
    0.02646882f, -0.05130853f, 0.02318397f, -0.03837622f, -0.02152585f, -0.06013943f, -0.01009482f, -0.03319596f, 
    -0.01952571f, 0.04144664f, 0.01783674f, -0.04739036f, 0.00523394f, -0.06336421f, -0.05918018f, 0.00038406f, 
    -0.06444455f, 0.00922892f, -0.00679298f, 0.02315981f, 0.01590943f, 0.03931195f, -0.03281350f, -0.01942220f, 
    -0.06489874f, -0.02141150f, -0.01223874f, 0.00614615f, 0.00094473f, -0.05336905f, -0.04625019f, -0.04152743f, 
    -0.03107703f, 0.03706449f, 0.00172286f, 0.01833129f, -0.01780588f, -0.01767824f, 0.02852874f, -0.02326538f, 
    0.03322198f, 0.01057977f, 0.03588482f, 0.00000888f, -0.04253148f, -0.02007869f, -0.02294166f, 0.05198763f, 
    -0.01286668f, 0.02210948f, 0.04794606f, 0.04917751f, 0.01445749f, -0.02406253f, 0.00346314f, 0.00206669f, 
    -0.01308892f, 0.05043665f, 0.02735191f, 0.04973434f, -0.03798306f, -0.00157582f, 0.00401727f, 0.02156218f, 
    -0.05608368f, 0.01713732f, 0.02301579f, -0.00459779f, -0.05189931f, 0.03383162f, 0.02420009f, -0.00854291f, 
    -0.05598474f, -0.05260596f, -0.02804287f, -0.03840714f, -0.04176214f, 0.03594059f, -0.04383290f, -0.00279695f, 
    -0.04347396f, -0.04314151f, 0.04396009f, 0.01662651f, -0.00962577f, 0.04651191f, 0.02203327f, 0.05940306f, 
    -0.02533632f, -0.04191903f, -0.05566311f, 0.00347861f, -0.06323607f, -0.04142576f, -0.00816630f, -0.02433081f, 
    -0.05314498f, 0.02767697f, 0.01184157f, -0.05165651f, -0.01775309f, -0.01195140f, 0.01990884f, 0.02179175f, 
    0.02821822f, -0.04003887f, -0.01632601f, -0.02159859f, 0.04722730f, -0.06049135f, 0.00487814f, 0.02116609f, 
    -0.02339849f, -0.02754386f, 0.03114108f, -0.04372149f, -0.03235047f, 0.04145922f, -0.02301788f, 0.02981753f, 
    -0.05605187f, -0.01855751f, 0.00455935f, -0.04638794f, -0.00439893f, -0.00993656f, -0.04959412f, -0.03402799f, 
    0.04458991f, -0.01884623f, -0.02016292f, 0.00208074f, 0.04306590f, 0.02646961f, 0.03905247f, -0.03110430f, 
    -0.04637703f, -0.02120217f, -0.05714045f, -0.01818967f, 0.03282940f, -0.04810642f, 0.00458932f, -0.06504188f, 
    0.04423911f, 0.02491899f, -0.07073526f, 0.11586215f, 0.07055815f, -0.00396742f, 0.05955650f, 0.00201701f, 
    0.04272737f, 0.11599424f, -0.10959003f, -0.08822797f, 0.02275481f, -0.02653866f, 0.08426172f, -0.03917402f, 
    0.11001510f, 0.04917630f, 0.07970157f, -0.01999156f, -0.04180310f, -0.10417075f, 0.03639696f, 0.01287799f, 
    -0.09222005f, 0.03002677f, -0.03880034f, 0.01358175f, 0.01305346f, 0.06613158f, -0.00785292f, 0.11837667f, 
    -0.01232840f, -0.03132953f, 0.05815685f, 0.04633352f, -0.05316734f, -0.16329527f, 0.01131919f, 0.13611995f, 
    -0.03781595f, 0.04146058f, -0.05665720f, -0.08374891f, -0.05452221f, -0.28005132f, -0.38122129f, 0.00871932f, 
    0.13272578f, -0.08028818f, 0.00000282f, 0.13905412f, -0.02684372f, -0.07613982f, -0.00579910f, 0.02514010f, 
    0.06810956f, 0.07337119f, 0.10204299f, -0.04250477f, -0.10598108f, 0.11628941f, 0.06610216f, -0.05394993f, 
    0.13729741f, -0.21448950f, -0.04025141f, 0.00522597f, 0.06854156f, 0.03146901f, -0.01622516f, 0.02618022f, 
    0.03626997f, -0.14146847f, -0.01159163f, 0.13405620f, 0.06678228f, -0.02975145f, -0.04522331f, 0.07684651f, 
    0.00871995f, -0.12398021f, 0.07143364f, -0.05046596f, -0.00083809f, 0.07065611f, -0.12906173f, -0.03389613f, 
    -0.06590383f, -0.06586826f, -0.04286668f, 0.03334830f, -0.13486096f, 0.06921407f, 0.05879869f, -0.10309319f, 
    -0.04852887f, -0.00921557f, 0.03207304f, 0.15461536f, 0.13770331f, -0.09527766f, 0.01573750f, 0.00603820f, 
    0.12025349f, 0.05557611f, 0.09119291f, 0.02651318f, 0.13707483f, 0.05470811f, -0.01180913f, 0.06732133f, 
    0.03936823f, 0.11856574f, -0.06497340f, -0.02810705f, -0.06288837f, -0.20183212f, -0.29145455f, 0.04429491f, 
    0.10152637f, -0.03199354f, 0.01532987f, 0.06832299f, -0.06460515f, -0.19978024f, 0.09098395f, 0.02825481f, 
    0.04001397f, -0.03032704f, -0.00113563f, -0.08510368f, -0.08517516f, 0.02167366f, -0.04546880f, 0.05327611f, 
    0.07506518f, 0.06602728f, 0.01426018f, -0.06957332f, 0.12926953f, 0.06500690f, 0.01886389f, 0.02310716f, 
    0.06585308f, -0.21330990f, 0.01082164f, 0.01696000f, 0.04702548f, -0.12051857f, -0.01144804f, 0.04574391f, 
    0.03576230f, 0.10783219f, -0.02326433f, 0.07311193f, 0.07749881f, -0.02833241f, 0.02213759f, 0.05520033f, 
    -0.08655493f, -0.01289690f, -0.07011653f, 0.01328156f, 0.13785303f, -0.03593034f, 0.04754717f, -0.12268826f, 
    -0.09799671f, 0.16321620f, -0.00635719f, 0.07247585f, -0.03592611f, -0.08058649f, -0.03249688f, 0.02562990f, 
    -0.04540084f, 0.00267530f, 0.03532813f, 0.03899226f, 0.18028367f, 0.09318186f, 0.06270237f, 0.02158434f, 
    0.08863006f, -0.02733085f, -0.02936210f, -0.09127995f, -0.11445260f, -0.26943260f, -0.15127727f, 0.15240075f, 
    0.05395888f, 0.08389676f, -0.02899921f, 0.03640229f, -0.00139342f, -0.01933765f, 0.09468795f, 0.18503012f, 
    -0.12453324f, 0.15249798f, -0.00873153f, 0.07976973f, -0.09784656f, -0.01299644f, -0.03918250f, 0.03386259f, 
    0.03835216f, 0.06653994f, 0.00468928f, 0.00831724f, -0.00893386f, 0.04797785f, -0.06900511f, 0.01689819f, 
    -0.10324520f, 0.04565810f, -0.08415280f, 0.04652379f, -0.08378369f, -0.05250765f, -0.06432018f, -0.04887439f, 
    0.08217926f, 0.08341527f, 0.26216072f, -0.09482446f, 0.05710988f, -0.00047304f, -0.06704729f, -0.01140351f, 
    -0.08375428f, 0.00601599f, -0.09444574f, -0.18213348f, -0.00687201f, 0.03931098f, -0.04196801f, 0.01176835f, 
    -0.07579335f, -0.00085928f, 0.01436966f, -0.07784980f, -0.15452327f, 0.11425010f, 0.00740639f, 0.10557510f, 
    0.00046700f, -0.11026049f, 0.05890532f, 0.10374273f, -0.00278438f, 0.00739692f, -0.16623302f, 0.06945783f, 
    -0.01116702f, 0.22571835f, 0.06113968f, -0.04303315f, -0.02457296f, 0.00747255f, -0.04663869f, 0.06641286f, 
    -0.09495918f, 0.05595383f, -0.12457763f, -0.04663426f, -0.00560454f, -0.00281479f, -0.23621777f, -0.17970203f, 
    -0.02740599f, 0.09965917f, 0.00623285f, 0.11012219f, -0.05418588f, 0.02162408f, -0.11455287f, 0.18076889f, 
    0.15250088f, -0.02631758f, -0.00931026f, -0.03008895f, 0.01911792f, 0.05644191f, -0.01248998f, -0.02524708f, 
    0.01847374f, 0.21979211f, 0.19816896f, 0.14183916f, 0.05842586f, 0.07771584f, -0.07154123f, -0.04616750f, 
    0.08970845f, -0.11520636f, -0.15518335f, 0.00677249f, 0.01815281f, 0.01269716f, -0.10049514f, -0.02081315f, 
    0.01978602f, 0.04378219f, 0.17441908f, 0.27864847f, -0.41002056f, 0.09608354f, 0.06063289f, 0.11199843f, 
    -0.00219530f, 0.01010017f, -0.08263673f, 0.01726698f, 0.13293375f, 0.06577225f, 0.04990421f, -0.01713425f, 
    0.05055155f, 0.00892767f, 0.05424442f, 0.07800432f, -0.29202583f, -0.05736818f, -0.06275827f, -0.10874972f, 
    0.02817756f, -0.26713777f, -0.00744143f, -0.06354836f, -0.09071061f, 0.27071637f, 0.13166216f, -0.03986576f, 
    -0.16459458f, 0.03749038f, -0.11184080f, -0.03150752f, -0.01594449f, -0.04459428f, 0.24020053f, -0.06257403f, 
    -0.03394484f, 0.04482294f, 0.08219076f, -0.07761032f, 0.08534386f, -0.02612935f, -0.07666191f, -0.14620475f, 
    -0.26745778f, 0.40116182f, -0.27035359f, -0.07210429f, -0.00862569f, 0.07908818f, 0.00458996f, 0.20489623f, 
    0.12846206f, 0.07699423f, -0.26732191f, 0.00889003f, 0.04368160f, 0.16038197f, -0.02039099f, 0.03593847f, 
    0.04123220f, -0.36026594f, -0.09445073f, -0.13274463f, -0.08274330f, 0.02653849f, -0.01810171f, 0.01699980f, 
    0.10062246f, 0.10677247f, 0.29368302f, -0.45778036f, -0.04779446f, -0.13437758f, 0.00796367f, 0.04065899f, 
    0.08116803f, 0.02101055f, -0.04814740f, 0.36135283f, 0.23563182f, 0.02775387f, -0.01657450f, 0.01054966f, 
    0.00731513f, -0.01852693f, 0.00609512f, 0.00035938f, 0.19924115f, -0.39912224f, 0.15426265f, -0.00373478f, 
    0.03046405f, -0.02383139f, 0.16677791f, 0.02255849f, -0.05486657f, -0.15376098f, 0.17562746f, -0.04761407f, 
    -0.02628025f, -0.25860822f, -0.06922507f, -0.01712050f, -0.00295962f, -0.05339284f, -0.10970632f, -0.24880382f, 
    -0.04204031f, -0.13260584f, 0.11991950f, -0.00434678f, 0.14473216f, -0.09612968f, -0.09734833f, -0.28858063f, 
    0.01060612f, 0.04428780f, 0.10659266f, 0.02217263f, -0.07126929f, 0.08749311f, -0.01582961f, 0.10830536f, 
    0.09691076f, -0.08980981f, 0.04430592f, -0.02481384f, -0.17578124f, -0.08440012f, 0.13378128f, 0.05789044f, 
    0.16455463f, -0.41948825f, 0.03694833f, -0.13978817f, 0.01936973f, 0.11470726f, 0.09286488f, -0.07344674f, 
    -0.09542320f, -0.14215004f, -0.24768333f, 0.04324852f, -0.08313815f, -0.03479114f, 0.01255856f, -0.00107232f, 
    0.07802307f, 0.04072686f, 0.03587988f, 0.10785352f, 0.05493253f, -0.27893373f, 0.16497079f, 0.05325545f, 
    0.09552711f, -0.08875313f, -0.04605478f, -0.00297433f, 0.28284115f, -0.09508502f, -0.04990740f, -0.24331686f, 
    -0.02695227f, -0.06908212f, -0.07811094f, 0.06065943f, -0.10744173f, -0.00325884f, 0.14166841f, -0.07900061f, 
    -0.00658361f, -0.23530641f, -0.05997127f, 0.12810074f, 0.07129769f, -0.01610363f, 0.00045185f, -0.29214334f, 
    0.24018197f, -0.13798884f, 0.21429317f, 0.00247942f, -0.10483824f, 0.06449885f, -0.00916671f, -0.01646272f, 
    -0.13110565f, -0.18494472f, 0.07290647f, 0.05277263f, 0.04255177f, 0.15701206f, 0.09183656f, 0.17206727f, 
    -0.19046827f, -0.23026551f, -0.18692139f, 0.08160741f, -0.12935530f, 0.01837633f, -0.08189372f, -0.06430642f, 
    -0.04929913f, 0.33298329f, 0.07621183f, -0.01325204f, -0.04674980f, -0.12808794f, -0.06582526f, 0.03366011f, 
    0.05490508f, -0.11628934f, -0.06110166f, -0.03553382f, 0.05313717f, -0.05022985f, 0.08175353f, -0.05732332f, 
    0.12583812f, 0.13780753f, 0.10334753f, -0.05586918f, -0.00752008f, 0.10203837f, 0.04072120f, 0.02269551f, 
    0.07667845f, 0.02388232f, 0.00674491f, 0.04030170f, 0.23627907f, 0.13178028f, 0.02467315f, -0.20412208f, 
    0.01029262f, -0.12113808f, 0.04047675f, 0.02521131f, -0.07092059f, -0.43577558f, 0.06536480f, -0.30676785f, 
    0.01531811f, 0.04702874f, -0.03980671f, 0.05002476f, -0.05928279f, -0.00821122f, 0.11752310f, 0.08056350f, 
    0.08322998f, -0.07248966f, -0.08042403f, 0.02747276f, 0.10136423f, -0.08922269f, -0.11473551f, 0.48501158f, 
    0.18203922f, 0.05600449f, -0.07919321f, 0.07992472f, 0.03258650f, 0.03768442f, -0.02879404f, -0.03370363f, 
    -0.04278671f, -0.14130642f, -0.07435338f, 0.01795186f, -0.00539094f, -0.01295761f, -0.06196805f, -0.06067578f, 
    0.00396428f, -0.13198338f, -0.02734557f, 0.08818865f, 0.22716875f, -0.07588681f, -0.03426204f, 0.14033890f, 
    -0.02148875f, -0.07928886f, -0.13449244f, -0.00057780f, 0.24370910f, 0.01035109f, 0.07892507f, -0.12707369f, 
    -0.05804716f, -0.03238942f, -0.04618763f, 0.13646013f, -0.02331850f, -0.15126702f, 0.07581514f, -0.07891388f, 
    0.08817089f, -0.07621576f, 0.03837941f, -0.01536418f, 0.06206243f, -0.03582992f, -0.02419769f, 0.19962403f, 
    0.06213186f, 0.09324186f, 0.01383423f, -0.31178683f, -0.16489790f, 0.35269290f, -0.00138700f, -0.25669387f, 
    -0.07992012f, 0.06913717f, -0.09193617f, 0.02517284f, -0.08333196f, -0.03195588f, -0.10023597f, -0.03843775f, 
    -0.16729775f, 0.05985070f, -0.03525772f, 0.13390976f, -0.02335791f, -0.11596625f, -0.14442560f, 0.11488094f, 
    0.03942382f, -0.17513691f, 0.10956726f, 0.04687472f, 0.03162909f, -0.00952725f, -0.04049953f, -0.02673322f, 
    -0.06315029f, -0.02859055f, 0.18734813f, 0.05283463f, -0.16590670f, 0.06554989f, -0.06440257f, 0.07529178f, 
    -0.00419334f, 0.01320158f, 0.10843205f, -0.04111414f, 0.04340549f, 0.11223952f, -0.00932357f, 0.00473353f, 
    -0.04295359f, 0.06517612f, 0.09509613f, -0.02462405f, -0.15671463f, 0.14330983f, -0.05992990f, 0.13778712f, 
    -0.07596540f, 0.07097612f, -0.22657871f, -0.00614510f, -0.07530712f, 0.12254130f, 0.03825688f, -0.00030650f, 
    0.09135571f, -0.09897333f, -0.00859205f, 0.07483821f, 0.04467557f, 0.01552017f, -0.02694577f, 0.02752222f, 
    -0.14129052f, 0.02576177f, -0.12054859f, 0.13206495f, -0.03358378f, 0.16094036f, 0.10254195f, -0.06011492f, 
    0.04975834f, 0.12667787f, -0.16374733f, 0.10310151f, 0.04355137f, 0.01452411f, -0.04938946f, 0.07248824f, 
    0.02313978f, 0.13844520f, -0.01520590f, -0.17235357f, 0.07639230f, 0.01968246f, -0.06920872f, 0.03108422f, 
    0.20349617f, 0.01850793f, 0.09473994f, -0.09667528f, -0.04210284f, -0.11103781f, -0.04191276f, -0.03535590f, 
    0.02449520f, 0.01100340f, 0.01912185f, 0.14177079f, 0.00535216f, 0.01951298f, 0.08817390f, 0.01977417f, 
    0.03024203f, 0.02051981f, 0.03593846f, 0.01022805f, -0.00898832f, -0.03606678f, 0.04987303f, -0.16807489f, 
    0.16990209f, 0.18060528f, -0.14253944f, -0.14349550f, 0.00792558f, -0.03526335f, 0.07617637f, 0.00705088f, 
    0.05105236f, 0.01229542f, 0.05527076f, 0.10359270f, -0.02076555f, 0.04587593f, 0.09499288f, 0.13539396f, 
    0.09836117f, -0.08979648f, -0.14383461f, -0.22867775f, 0.02968206f, 0.02579510f, 0.02202411f, -0.06662686f, 
    0.01842161f, -0.04676167f, -0.04643825f, -0.01690965f, 0.18772605f, 0.30713221f, 0.00456499f, -0.10036716f, 
    0.00418280f, 0.10755982f, -0.20893222f, -0.04938567f, 0.01657263f, 0.01282248f, 0.14068450f, 0.16857176f, 
    0.06614451f, -0.09097548f, 0.12990116f, -0.00337324f, -0.04268124f, 0.11136261f, -0.02504515f, 0.01851863f, 
    0.11589079f, -0.05286415f, 0.03000819f, -0.02132404f, -0.12736824f, 0.01786959f, 0.14571209f, 0.01003184f, 
    0.14595422f, 0.09242702f, -0.05534186f, -0.02748444f, 0.16637942f, 0.07156359f, -0.03117877f, -0.19292332f, 
    -0.17544313f, -0.11224738f, 0.16377427f, 0.05292472f, -0.04462077f, 0.02580050f, 0.04596762f, -0.09715103f, 
    -0.08503790f, 0.11189432f, -0.14989550f, -0.01158059f, -0.06194162f, 0.06354855f, 0.06983183f, -0.05144186f, 
    -0.01416289f, 0.07057682f, -0.12534881f, 0.11330093f, -0.11441324f, -0.20161338f, 0.07673437f, 0.05615936f, 
    0.05901723f, 0.07921519f, 0.09249114f, -0.04093613f, 0.11690482f, -0.07458602f, -0.04231878f, 0.13233949f, 
    0.06457253f, 0.05373926f, -0.00801894f, -0.06793680f, 0.00466469f, 0.03681301f, 0.16995148f, 0.00082402f, 
    -0.02964633f, 0.16192627f, 0.03975239f, -0.00332159f, -0.24718282f, -0.09475246f, 0.11156315f, -0.08457059f, 
    -0.04438846f, 0.11275867f, 0.14847454f, -0.09669260f, 0.04103728f, 0.01215837f, -0.02002496f, -0.01853815f, 
    0.06108794f, 0.07093469f, 0.02088872f, 0.06021228f, 0.01001835f, -0.05754777f, 0.04543134f, 0.11516992f, 
    0.00433043f, -0.05078359f, -0.03993557f, 0.04812242f, -0.00977728f, -0.03845760f, 0.04316822f, 0.03323244f, 
    0.01852003f, -0.04523704f, -0.02675399f, 0.00176798f, -0.00053044f, -0.01425307f, -0.03368053f, -0.01471572f, 
    -0.03830468f, 0.02010970f, -0.00864668f, -0.01601458f, -0.00495003f, 0.01412674f, -0.00338097f, 0.02418357f, 
    0.04589518f, -0.03644623f, -0.03342702f, -0.06932981f, -0.02184268f, -0.01752680f, 0.00264894f, -0.04639236f, 
    0.00648403f, -0.06811848f, 0.03643196f, -0.02478758f, 0.00649102f, -0.03183344f, 0.00257692f, 0.01259316f, 
    0.01640807f, -0.01200089f, 0.01701587f, 0.01764137f, 0.05000257f, 0.00940726f, -0.04354297f, 0.05248571f, 
    0.00260898f, 0.00421778f, -0.05567383f, -0.06096184f, 0.04354625f, 0.04755584f, 0.01278194f, 0.00334469f, 
    -0.06427749f, -0.00524339f, -0.01680478f, -0.05097033f, 0.01519780f, 0.03166007f, -0.03167946f, 0.04376199f, 
    -0.04564677f, 0.03435664f, -0.06011450f, -0.01324682f, 0.00339149f, -0.02874908f, -0.06253082f, -0.00564589f, 
    -0.00115684f, 0.02743706f, 0.03621675f, 0.01984828f, -0.06500454f, -0.05902091f, -0.05136727f, -0.04324912f, 
    0.04147152f, -0.04170033f, 0.02039811f, 0.04350254f, 0.00529057f, 0.05382747f, -0.05532393f, -0.00939744f, 
    -0.00923980f, -0.05293947f, 0.03236646f, 0.01288700f, -0.00152404f, 0.01517309f, 0.04929423f, 0.00526803f, 
    -0.01115637f, -0.02336909f, 0.02214921f, 0.05299569f, -0.04899121f, -0.04185331f, 0.00297195f, 0.02954600f, 
    0.04450993f, -0.01325637f, 0.03579806f, -0.04329538f, 0.02388837f, -0.05984499f, -0.01364364f, -0.03502344f, 
    -0.02651097f, -0.03626567f, -0.00415471f, 0.00463533f, -0.06182719f, 0.02000370f, -0.04029064f, 0.01789564f, 
    0.01926902f, -0.03767259f, -0.05320914f, 0.04174468f, -0.02434332f, -0.00391322f, 0.04884070f, 0.00009102f, 
    -0.01561505f, 0.04784901f, 0.04192569f, 0.03967896f, 0.03884628f, -0.03181246f, -0.02731302f, -0.02483089f, 
    -0.00290034f, -0.07067244f, -0.01200124f, 0.03195621f, -0.01606540f, 0.03137859f, -0.04704797f, 0.04202159f, 
    -0.02501788f, -0.05353489f, 0.04138413f, -0.04287503f, 0.00412302f, 0.04309080f, -0.01022336f, 0.04200931f, 
    -0.05303320f, -0.02504276f, -0.02637471f, -0.05394512f, -0.01354295f, -0.05744258f, -0.00055172f, 0.02201964f, 
    -0.00899975f, -0.05232926f, -0.00377916f, -0.05743244f, -0.01309048f, 0.02326220f, 0.04532972f, 0.02523995f, 
    0.02933231f, 0.02255573f, -0.04098743f, -0.03915558f, -0.04760152f, 0.04843629f, 0.01138344f, 0.02436115f, 
    -0.06140210f, -0.02471093f, -0.01291228f, -0.00652259f, -0.03908487f, -0.04161839f, -0.03143760f, 0.03827301f, 
    -0.03377752f, 0.03614491f, -0.05169606f, 0.00901700f, -0.03186179f, 0.01925938f, -0.02948405f, 0.00824708f, 
    0.02719529f, -0.04155733f, -0.00818494f, 0.02291873f, -0.04833520f, -0.00505066f, 0.03752604f, -0.01465654f, 
    -0.01231856f, -0.01528234f, -0.00318429f, 0.02546206f, 0.01154768f, -0.05351672f, -0.05001109f, -0.01571567f, 
    0.04679863f, 0.01923503f, -0.03837325f, 0.01506703f, -0.01623263f, 0.03884187f, -0.05605103f, -0.00648658f, 
    0.02667750f, -0.00719569f, 0.04681787f, 0.02084732f, 0.04226676f, -0.03823766f, 0.04743521f, -0.06247407f, 
    0.03932805f, -0.04171534f, -0.06081042f, 0.04661170f, 0.02113521f, -0.05331371f, -0.04459843f, 0.02505541f, 
    -0.03357483f, 0.02763925f, -0.03324469f, 0.02767994f, -0.03995376f, 0.00264434f, -0.06074933f, 0.02976047f, 
    0.00745220f, -0.05914410f, -0.04269014f, -0.01111062f, -0.01813548f, -0.00059493f, 0.01869770f, 0.02525100f, 
    -0.06398429f, -0.04245863f, -0.04007792f, 0.01469297f, 0.03827412f, -0.06544308f, 0.00266831f, 0.02316853f, 
    -0.04996763f, -0.01464421f, -0.04588724f, -0.00501382f, -0.03364276f, -0.00031932f, 0.03223770f, -0.01885177f, 
    -0.04387162f, 0.03690111f, 0.03741284f, -0.03084714f, 0.02497077f, 0.02547825f, 0.03772471f, -0.05403545f, 
    -0.02464337f, 0.04617474f, -0.03924815f, -0.05879124f, 0.02256737f, 0.03191341f, 0.05094686f, 0.00543368f, 
    -0.03651889f, 0.01846452f, -0.01678874f, -0.01778031f, 0.01654281f, 0.04140562f, -0.04293364f, -0.00399148f, 
    0.19955511f, 0.03351662f, -0.02936039f, -0.08754633f, -0.07345281f, -0.03474746f, 0.08230470f, 0.10326420f, 
    0.07015441f, 0.03013199f, -0.00157702f, -0.04825568f, -0.03069560f, 0.03718582f, 0.01169506f, 0.01974540f, 
    0.05371956f, 0.00071670f, -0.04606659f, -0.10996704f, 0.00933761f, -0.00342421f, 0.06165737f, 0.13578026f, 
    0.05229103f, 0.03148069f, 0.04048663f, -0.03695656f, 0.15113656f, -0.07033876f, 0.08269390f, -0.00794449f, 
    0.10794944f, -0.14272125f, 0.04587664f, 0.11700599f, 0.20083213f, -0.13789938f, -0.30895561f, -0.01740456f, 
    0.08636147f, 0.00732476f, -0.02338973f, -0.10289530f, -0.16427727f, 0.07441521f, 0.02041319f, -0.24100946f, 
    -0.02582280f, -0.07456395f, -0.07870589f, -0.04821936f, 0.00004855f, -0.05399933f, 0.13115422f, -0.10066000f, 
    -0.14167014f, -0.00121900f, 0.08828606f, 0.05655324f, -0.01670606f, -0.08976007f, 0.05569240f, 0.02247382f, 
    0.20490319f, -0.17541766f, 0.02556612f, -0.12158558f, 0.12950820f, 0.03429175f, 0.01828239f, 0.01745843f, 
    0.01260306f, -0.13940336f, -0.08619637f, -0.05398116f, 0.10304604f, 0.12072415f, 0.09242077f, 0.12951203f, 
    0.11728746f, -0.14465934f, 0.02736853f, -0.03819067f, 0.00326730f, -0.14103131f, -0.02643811f, 0.08388960f, 
    0.01558236f, -0.24893831f, -0.06547730f, -0.25368237f, 0.11782128f, -0.19140606f, 0.14364626f, -0.06977699f, 
    0.09995639f, 0.05030765f, 0.07708985f, 0.13551930f, -0.04647887f, 0.09588427f, 0.01999500f, -0.07182564f, 
    -0.02331443f, 0.02093055f, 0.12514639f, -0.04125710f, 0.12771378f, 0.02384816f, -0.15311407f, -0.03878571f, 
    -0.07588968f, 0.01701403f, 0.00797452f, -0.04084307f, 0.05242585f, -0.10694464f, 0.19859859f, -0.05287195f, 
    0.09644232f, -0.00550807f, -0.18811277f, 0.06395509f, 0.13242270f, -0.03911911f, -0.13371308f, -0.02179492f, 
    0.18305208f, 0.22347894f, -0.06948843f, -0.13938445f, -0.09163079f, -0.04061754f, 0.05150583f, -0.05854177f, 
    -0.01825677f, 0.12890601f, -0.02791347f, 0.02936332f, 0.03531863f, 0.10192779f, -0.06202867f, -0.00430413f, 
    0.05606859f, 0.09273899f, -0.06405681f, -0.13175365f, -0.06563336f, 0.16752543f, 0.08495427f, -0.02705185f, 
    -0.01913343f, -0.03927724f, 0.04972773f, 0.00791281f, 0.08664627f, -0.04100208f, 0.02697064f, -0.02704229f, 
    -0.00102228f, -0.06683521f, -0.10099653f, -0.01253051f, -0.13558613f, 0.05383695f, 0.06382214f, -0.12633808f, 
    0.03129615f, 0.02224846f, -0.06273614f, -0.03312870f, -0.08391198f, -0.13440019f, 0.19036141f, -0.04584434f, 
    0.21310845f, 0.07692557f, 0.02242229f, -0.04019877f, -0.42794544f, 0.21847393f, -0.12115793f, 0.02050949f, 
    -0.17347670f, 0.00827786f, -0.17936748f, 0.00712029f, -0.03689590f, 0.01080614f, 0.11936952f, -0.14594917f, 
    0.04096610f, 0.01208596f, 0.01811091f, -0.16076842f, 0.10124926f, -0.07951047f, 0.00845676f, 0.03025258f, 
    0.12330844f, -0.09939075f, -0.20163290f, 0.00963901f, -0.05884990f, 0.10320184f, 0.06838768f, -0.16893186f, 
    -0.03272286f, -0.11680830f, 0.07207999f, 0.01286194f, 0.02387771f, 0.00985157f, -0.03986388f, 0.07167696f, 
    -0.14868534f, -0.04519486f, 0.04366495f, 0.04303765f, -0.14266123f, -0.02651866f, -0.01733307f, -0.10285551f, 
    -0.08653649f, -0.41983250f, 0.00995542f, 0.16990323f, -0.01099234f, -0.07034815f, 0.01272449f, 0.02083212f, 
    0.04524178f, -0.06095279f, -0.17814200f, -0.04743965f, -0.23668036f, 0.08282941f, 0.05989578f, 0.11139276f, 
    0.06661576f, 0.11850803f, 0.05878713f, 0.02589278f, 0.12522581f, -0.11541188f, 0.17430124f, 0.12738079f, 
    -0.02681665f, -0.05637088f, -0.08857338f, 0.09313176f, 0.20551421f, 0.07924543f, -0.10180222f, 0.00679951f, 
    0.05151407f, 0.06410445f, -0.12321261f, 0.04161815f, -0.02799820f, -0.18548365f, -0.14815643f, 0.08756101f, 
    -0.12337404f, -0.02571807f, 0.05358653f, -0.05552229f, -0.09774072f, 0.08664571f, -0.05428128f, 0.04893787f, 
    -0.06965653f, 0.03790871f, 0.20287849f, -0.02073272f, -0.03929351f, -0.09076726f, -0.09563881f, -0.07419815f, 
    0.05713565f, 0.13240145f, -0.03851470f, -0.00560804f, 0.01288454f, 0.07187617f, 0.07506211f, 0.07768870f, 
    0.22436988f, -0.18484439f, -0.15290417f, -0.00429198f, 0.02188417f, -0.10830913f, -0.01540008f, 0.03910280f, 
    -0.03728088f, -0.08579587f, -0.01509119f, 0.00529041f, 0.07996293f, -0.06903081f, -0.06220002f, -0.09474812f, 
    0.05374815f, 0.05853015f, 0.38255170f, 0.08736948f, -0.07643114f, 0.02958199f, 0.08222616f, -0.03571566f, 
    0.04276766f, -0.04297821f, 0.01082783f, 0.05488332f, 0.09229687f, 0.07360626f, -0.01058662f, 0.06381012f, 
    0.06193415f, 0.08669169f, 0.03497988f, -0.16209720f, -0.27746543f, 0.15844506f, 0.02576591f, 0.16249251f, 
    0.03005694f, -0.13349542f, 0.02322719f, 0.05176091f, -0.09832894f, 0.11816427f, 0.16595338f, -0.00455353f, 
    0.10773695f, -0.00030315f, 0.00453121f, -0.14649066f, -0.00504625f, -0.01623079f, -0.52910614f, 0.20540832f, 
    0.03106696f, 0.11841850f, -0.07428816f, -0.06240781f, 0.14699423f, 0.00701076f, -0.10398438f, 0.07157696f, 
    -0.31887752f, 0.15859495f, -0.17793529f, 0.07985067f, -0.02840638f, -0.10317976f, -0.00647397f, 0.09973295f, 
    -0.01795189f, 0.13226727f, -0.09000211f, 0.02149159f, -0.02791696f, -0.12470745f, 0.12104233f, 0.03992118f, 
    0.06160918f, -0.07419028f, -0.05329237f, -0.06944127f, 0.02037407f, 0.03745573f, 0.10678376f, -0.04691558f, 
    0.12513182f, 0.07624949f, -0.02967970f, -0.06247489f, 0.12215801f, 0.04206122f, -0.05894075f, 0.00849705f, 
    0.04369398f, 0.12018483f, -0.00377668f, 0.26963332f, -0.19166057f, -0.09297682f, 0.03468534f, -0.07792926f, 
    -0.09096255f, 0.04025711f, 0.12666968f, 0.00332478f, -0.23019163f, -0.13998619f, -0.04836929f, 0.07955265f, 
    0.05254177f, -0.02906651f, -0.11361527f, -0.06876018f, -0.05270411f, -0.12714773f, 0.14562333f, -0.11397591f, 
    -0.04589231f, 0.12612194f, 0.02437159f, 0.11784427f, -0.03593508f, 0.01162625f, 0.15204944f, 0.00236720f, 
    0.13106985f, 0.00694179f, 0.04895607f, 0.03332557f, -0.01156589f, -0.04924347f, 0.01844573f, 0.04438203f, 
    -0.03948150f, -0.13456325f, 0.09817207f, 0.15219124f, 0.00129799f, 0.05481142f, 0.02049593f, -0.01601141f, 
    -0.18433209f, -0.05644714f, -0.10753035f, 0.02463400f, -0.01238810f, 0.04035267f, -0.03806075f, -0.04780940f, 
    0.01182674f, 0.18563239f, -0.43459803f, -0.26359966f, 0.08668458f, 0.06594887f, 0.05433555f, -0.05663783f, 
    -0.03129404f, 0.11569731f, 0.01716400f, 0.10339328f, -0.09745780f, 0.05129682f, -0.04729429f, -0.00135487f, 
    0.08913492f, 0.18390247f, 0.03994473f, 0.06301724f, 0.08943151f, 0.08475667f, -0.10955268f, -0.02767194f, 
    -0.07473749f, -0.04347841f, -0.00940533f, 0.04345753f, 0.08573635f, -0.13462538f, -0.65736765f, 0.04919397f, 
    0.18720533f, 0.08473454f, -0.08424601f, -0.02521185f, -0.00547791f, 0.11000862f, 0.11251693f, 0.08998717f, 
    0.03014774f, -0.05152342f, -0.00868317f, 0.07787074f, 0.03223733f, 0.11710307f, 0.00106615f, -0.42487085f, 
    -0.27653602f, -0.06143292f, 0.01852852f, 0.17667103f, 0.09313952f, -0.01419557f, -0.05051488f, 0.16715011f, 
    0.06712293f, -0.14512625f, 0.09210169f, -0.12858100f, -0.01796002f, -0.00253707f, 0.00978513f, 0.12866142f, 
    0.45571136f, -0.26611817f, -0.05074679f, -0.06469026f, -0.04642307f, 0.00984162f, -0.07579685f, -0.02934170f, 
    0.02173861f, 0.14425699f, 0.06882852f, -0.47557509f, -0.10939352f, 0.23688170f, 0.06848314f, 0.03743710f, 
    -0.06292459f, 0.01400396f, -0.41996649f, 0.06149821f, 0.06669257f, 0.06837648f, 0.05971765f, 0.06974424f, 
    -0.03305388f, 0.05124747f, -0.06074046f, -0.11740024f, 0.01486724f, -0.02231398f, -0.10547183f, -0.02904165f, 
    -0.00555751f, -0.00892986f, 0.18598744f, -0.06483912f, -0.04655279f, 0.06735405f, 0.06323403f, -0.14461508f, 
    0.08613596f, -0.05988684f, -0.08620505f, -0.03362928f, 0.00597035f, 0.15190153f, 0.16131656f, -0.00899498f, 
    -0.07197457f, -0.03665899f, 0.03561489f, -0.10808789f, -0.04421430f, 0.07310098f, -0.16058226f, 0.15141031f, 
    0.07049605f, 0.00063945f, 0.00650287f, -0.03101094f, 0.04458421f, 0.01423847f, 0.14215566f, 0.18825430f, 
    -0.04706043f, -0.10951018f, -0.02296323f, 0.07556486f, -0.08419467f, 0.01194904f, 0.09742102f, -0.03054797f, 
    -0.05489370f, 0.00544596f, 0.03261566f, 0.01290987f, -0.00928322f, 0.01680894f, -0.05718597f, 0.03944312f, 
    0.03457034f, -0.07030967f, -0.06354321f, 0.00638787f, -0.01426105f, 0.03360320f, 0.00642368f, -0.05065490f, 
    -0.05340813f, 0.00154074f, -0.02426548f, 0.01470749f, -0.05683616f, -0.06227483f, -0.01006311f, -0.00406042f, 
    0.01978229f, -0.04869744f, -0.03015721f, -0.06966580f, 0.01854876f, -0.01203899f, -0.02130020f, 0.04119607f, 
    -0.05052719f, -0.05043305f, -0.03210883f, 0.01398032f, -0.07011994f, -0.06880271f, -0.05208715f, -0.03167303f, 
    -0.03656295f, -0.06150661f, -0.00135688f, -0.03805848f, -0.01298160f, -0.01117282f, -0.06639810f, -0.02113630f, 
    -0.08124982f, -0.02629378f, 0.00104125f, -0.01982119f, 0.00619430f, 0.00295066f, -0.01877132f, -0.06110485f, 
    0.03706394f, 0.02007982f, -0.04298713f, -0.05182418f, 0.03769401f, -0.02779976f, -0.02771011f, -0.04849500f, 
    0.03985860f, -0.05955406f, 0.02156614f, -0.05713670f, 0.01848788f, 0.02200508f, -0.06018262f, 0.02724863f, 
    -0.06510409f, 0.01554522f, 0.02404433f, -0.02490221f, 0.02394207f, 0.01704000f, 0.03618688f, -0.00257761f, 
    0.00186391f, 0.03113127f, -0.05826518f, 0.02858482f, -0.00037438f, -0.00811300f, -0.04223173f, 0.03087804f, 
    -0.00861977f, -0.00820998f, -0.03404723f, 0.02148372f, 0.00680202f, -0.05941192f, -0.02837582f, 0.04231640f, 
    0.03151954f, 0.04324991f, 0.02473039f, -0.04147806f, -0.02983422f, -0.00852353f, 0.00875084f, -0.00932177f, 
    -0.00417676f, -0.07617619f, -0.05293037f, 0.00500272f, 0.00995682f, -0.04859867f, -0.05404744f, -0.00269804f, 
    -0.03450417f, 0.04768055f, 0.00615519f, -0.04731520f, -0.03156909f, -0.05205476f, -0.04114015f, -0.01883302f, 
    -0.03855937f, -0.07447767f, -0.05412709f, -0.06813717f, -0.04452071f, -0.00113446f, 0.02842042f, 0.03167870f, 
    -0.08308499f, -0.02183491f, 0.02739136f, 0.04603065f, 0.01371385f, -0.03078587f, -0.02033152f, -0.01773954f, 
    -0.05886133f, -0.01825329f, -0.02766934f, -0.05457252f, 0.02683749f, -0.00348747f, 0.00981458f, 0.02934694f, 
    0.01596372f, 0.01512602f, -0.05413926f, -0.04912910f, -0.05801917f, -0.02384939f, -0.05412015f, -0.02274658f, 
    -0.05776147f, -0.05625711f, -0.00916501f, -0.04596823f, -0.06719716f, -0.04774454f, 0.03557364f, 0.01428306f, 
    0.00863729f, -0.02279234f, -0.04802042f, 0.00555889f, -0.01208696f, -0.04268456f, 0.01351873f, 0.06157701f, 
    -0.06008182f, 0.01445095f, -0.00729067f, 0.04475353f, 0.02765047f, -0.05537772f, 0.00874894f, -0.01902044f, 
    -0.02836890f, -0.03701850f, -0.06786575f, -0.06343037f, -0.02809934f, 0.01043510f, -0.01732607f, 0.03965627f, 
    0.03776365f, 0.03857092f, 0.04535310f, -0.03007383f, 0.00815279f, 0.00996765f, -0.04000035f, -0.02225516f, 
    -0.03309691f, -0.04842306f, -0.04792398f, -0.06116293f, -0.03855092f, 0.01138872f, 0.02057570f, -0.02980361f, 
    -0.01877415f, -0.03918611f, 0.00006279f, 0.01416409f, 0.03965562f, -0.01670285f, -0.00995606f, 0.02015070f, 
    0.01204073f, 0.00366555f, -0.01738865f, 0.00598549f, -0.01201362f, -0.00988178f, -0.02765298f, -0.01079595f, 
    0.00942624f, -0.05808444f, -0.00455175f, -0.05389683f, -0.03681597f, -0.02419575f, -0.04148309f, 0.02387126f, 
    -0.04804230f, -0.03237167f, -0.06655093f, 0.05587810f, -0.02293861f, 0.03027689f, -0.02285355f, 0.00119141f, 
    0.02015500f, 0.00262049f, 0.00486516f, -0.02526152f, -0.00229798f, -0.06248681f, 0.02436439f, -0.01222107f, 
    0.02739473f, -0.03241811f, 0.04421674f, -0.01292719f, 0.00715588f, -0.02426814f, -0.04131685f, 0.00167873f, 
    -0.06540366f, -0.00827698f, 0.02157684f, -0.01586700f, 0.01955663f, 0.03121756f, -0.03501292f, 0.01353939f, 
    -0.02242063f, 0.00192257f, -0.07817602f, 0.03509593f, 0.00701828f, -0.01078266f, -0.03981190f, -0.03320067f, 
    -0.05417881f, -0.00442890f, 0.01239087f, 0.01463092f, 0.01332439f, -0.07108564f, -0.02641128f, -0.03895718f, 
    -0.05718860f, -0.07016247f, 0.03683532f, -0.00542264f, -0.03451015f, -0.00267241f, -0.05620365f, -0.01103351f, 
    -0.04273460f, -0.02216088f, 0.00738023f, -0.00573999f, 0.05137340f, 0.03572686f, 0.02656364f, 0.00197354f, 
    -0.08813998f, 0.04835417f, -0.11000044f, 0.17187043f, 0.05441323f, -0.06916011f, -0.10645248f, 0.01288319f, 
    0.07514694f, 0.12910545f, -0.19417086f, -0.05809740f, -0.02495911f, 0.00789700f, 0.04962911f, -0.03027047f, 
    0.04601155f, 0.15094127f, -0.02032438f, -0.02334233f, -0.00977587f, 0.00183193f, -0.05189981f, 0.01100388f, 
    -0.00915291f, -0.01728065f, -0.01467147f, 0.09048125f, 0.06950987f, 0.09541530f, 0.05088284f, 0.00612334f, 
    0.07440202f, -0.09868281f, -0.08425493f, -0.05207145f, -0.27545315f, 0.11511246f, 0.00920855f, 0.23422088f, 
    -0.02381638f, 0.16533045f, -0.01817555f, -0.26613066f, 0.03824449f, 0.18510082f, -0.21258180f, 0.11976451f, 
    -0.20305747f, 0.06831618f, 0.06755702f, 0.07384078f, -0.05252446f, 0.08893166f, -0.32347640f, -0.09637849f, 
    0.06428169f, 0.09552694f, 0.02343986f, 0.08148026f, 0.13743836f, -0.02404853f, 0.06794036f, 0.11220871f, 
    -0.12232354f, -0.00628780f, 0.03567730f, -0.05224033f, 0.10495017f, -0.00872077f, -0.06231207f, 0.00618237f, 
    0.00120917f, 0.13840948f, -0.01616860f, 0.02883286f, 0.07373074f, -0.10418833f, -0.11281972f, 0.10800301f, 
    0.06002156f, -0.01404876f, -0.01404017f, -0.01054691f, 0.05361145f, 0.10030035f, 0.10083073f, 0.12616579f, 
    -0.10845918f, -0.16741951f, -0.45949963f, -0.20110691f, 0.03174770f, 0.11141217f, 0.05244488f, -0.05462373f, 
    0.04453247f, 0.06448719f, -0.01107735f, -0.08768349f, 0.06264914f, -0.06921724f, 0.16442633f, 0.06259592f, 
    -0.11603761f, 0.02775041f, 0.15775467f, 0.12241920f, -0.07207008f, -0.04467138f, -0.07746021f, -0.07346833f, 
    -0.15353575f, -0.03230999f, 0.04430959f, 0.04046819f, 0.14078447f, -0.03020984f, -0.04414468f, -0.20372333f, 
    -0.09838308f, 0.01717701f, 0.20296988f, 0.13682599f, -0.07816977f, -0.02266463f, 0.05632081f, -0.14539230f, 
    -0.08081173f, -0.23696363f, -0.12179145f, -0.18122914f, -0.01197833f, -0.11547615f, -0.00496347f, -0.02989691f, 
    -0.17641541f, 0.04994814f, 0.09883916f, 0.11023647f, 0.09014873f, 0.06163477f, -0.13424006f, 0.05737810f, 
    0.31060588f, -0.07405634f, 0.10030546f, -0.11136825f, -0.17850512f, 0.05854742f, -0.06096489f, 0.00838786f, 
    0.01926747f, -0.03534966f, -0.00095724f, 0.04296668f, -0.00429468f, 0.12994343f, -0.23625875f, 0.04094419f, 
    -0.14919814f, -0.11077897f, -0.00142467f, -0.03091347f, -0.07085229f, -0.06443892f, -0.06052011f, 0.07623340f, 
    0.02510823f, 0.03923328f, -0.17284587f, -0.11797635f, -0.04280072f, 0.14889765f, 0.16952865f, 0.12948284f, 
    0.07452368f, 0.05528188f, 0.03548044f, -0.01443787f, -0.20205985f, -0.12296942f, 0.24234289f, 0.12012608f, 
    -0.20491098f, -0.07054073f, 0.03691621f, -0.04213327f, -0.10357217f, 0.10426075f, -0.09626966f, -0.21074648f, 
    -0.06316497f, 0.02693361f, 0.14977238f, 0.17745472f, -0.12582350f, -0.00411861f, 0.11806445f, -0.17338711f, 
    0.13977112f, -0.01298856f, 0.11573020f, 0.05313462f, -0.07466597f, -0.06395797f, 0.05025088f, 0.15003020f, 
    -0.04051383f, -0.07672569f, 0.04299285f, -0.00183039f, 0.07465394f, -0.01597607f, -0.08652026f, 0.07087236f, 
    -0.10986651f, -0.07387793f, 0.05110827f, -0.04619151f, -0.00276340f, 0.00493409f, 0.06733088f, -0.14685632f, 
    -0.01414236f, 0.07359958f, -0.00817879f, 0.16314560f, -0.07669135f, -0.14244455f, 0.15727413f, -0.03598084f, 
    0.13590345f, -0.03763372f, 0.14901303f, -0.15586381f, -0.04802752f, 0.01525749f, 0.01527429f, 0.00821658f, 
    -0.02092553f, -0.05525092f, 0.02456681f, -0.23201807f, 0.10664473f, -0.09786256f, 0.05994586f, 0.09545564f, 
    0.11232383f, 0.06003049f, -0.07181582f, -0.04113857f, -0.00874071f, -0.05235053f, 0.01856123f, 0.01388395f, 
    0.05202181f, 0.03639702f, -0.08431704f, -0.06476565f, -0.02405045f, 0.04565553f, -0.09381454f, -0.14940341f, 
    0.09388372f, -0.00391093f, -0.13122202f, 0.11222655f, -0.00298144f, -0.02392173f, -0.04736143f, 0.01897596f, 
    -0.09835621f, 0.05067303f, -0.00193671f, 0.08947085f, 0.11624813f, 0.01320854f, 0.01568986f, 0.18285398f, 
    0.00597907f, -0.07425656f, 0.07910484f, 0.01082021f, -0.01629951f, -0.04503831f, 0.09084633f, -0.03697609f, 
    0.13963293f, 0.06843189f, 0.12664837f, -0.09890384f, -0.10444397f, -0.00864230f, 0.12103523f, 0.00541411f, 
    -0.04345454f, 0.08000965f, 0.04603554f, -0.05713326f, 0.00958822f, 0.05258548f, 0.01242317f, 0.04003718f, 
    0.11407659f, 0.06452797f, 0.17414117f, 0.13262498f, 0.06677733f, -0.13742514f, 0.08190531f, -0.17033195f, 
    -0.01282876f, -0.01420327f, 0.06375360f, -0.06908349f, -0.03763065f, -0.17517015f, 0.00817181f, 0.01320221f, 
    0.01498685f, -0.15124767f, 0.03764144f, -0.04355538f, 0.06135664f, -0.02191040f, -0.02129474f, -0.08729127f, 
    -0.00687532f, -0.17178108f, 0.15924549f, 0.01155748f, 0.11620290f, 0.05725959f, -0.12065208f, -0.01881973f, 
    0.14109254f, 0.06928721f, 0.12363338f, 0.05395250f, 0.00088387f, 0.01010453f, 0.10457045f, 0.02083800f, 
    0.13628377f, -0.10009582f, 0.01031466f, -0.05203567f, 0.03750391f, 0.05108837f, 0.04598593f, 0.06206309f, 
    0.04623370f, -0.00264991f, -0.01353108f, -0.00086342f, 0.09072861f, 0.07729623f, 0.03842750f, 0.04950522f, 
    0.17217861f, 0.07368179f, 0.21316741f, -0.05937873f, 0.07358898f, -0.09344441f, -0.10486595f, 0.03660326f, 
    -0.11447266f, 0.16121030f, -0.07885040f, 0.04352848f, 0.04572287f, 0.08635049f, -0.03217491f, 0.09367988f, 
    -0.13062006f, -0.15312399f, -0.09310594f, 0.09132828f, 0.06733037f, -0.11042962f, 0.02243509f, 0.01033983f, 
    0.11333735f, -0.02821932f, 0.01742350f, 0.27746707f, 0.22451583f, 0.12075812f, -0.23048092f, -0.18600748f, 
    0.12517396f, 0.00948409f, -0.00811695f, -0.11480539f, -0.04425280f, -0.17767616f, 0.03294034f, -0.05220639f, 
    0.01681740f, 0.01470320f, -0.00348981f, -0.07971279f, -0.01620221f, 0.00603186f, 0.01380625f, -0.08903911f, 
    0.11574330f, 0.12864572f, 0.06434052f, -0.01995428f, 0.05598848f, -0.10064824f, 0.21901700f, -0.06682637f, 
    -0.07969838f, -0.01303157f, 0.03414306f, -0.06873209f, -0.00130078f, 0.02116513f, 0.01759351f, -0.08884414f, 
    -0.20488141f, -0.09460890f, 0.07821324f, -0.00643091f, 0.00122839f, 0.04377539f, 0.03231362f, -0.00535063f, 
    0.00681129f, 0.06589077f, 0.17970631f, 0.01192380f, 0.07131286f, 0.07439987f, 0.08029505f, 0.02746671f, 
    0.08028979f, 0.00019325f, -0.19251536f, -0.09376355f, 0.04083899f, -0.05601408f, 0.02631425f, -0.05982400f, 
    0.02424982f, -0.15294521f, 0.02602213f, 0.09747611f, -0.03623651f, 0.06300733f, 0.03038481f, -0.15797697f, 
    -0.03855501f, -0.03274496f, 0.01905936f, 0.16585420f, 0.15600894f, 0.15066692f, -0.08727648f, -0.22119604f, 
    -0.03302889f, -0.05220838f, 0.08611341f, 0.03740858f, -0.18904740f, -0.25752595f, -0.06925607f, 0.00224327f, 
    0.08487364f, -0.15382314f, 0.14657515f, 0.03524597f, -0.05590440f, -0.06333430f, -0.12239628f, -0.10861783f, 
    0.06134692f, 0.06031238f, 0.13797133f, 0.05421763f, -0.06737577f, -0.00651750f, -0.12927702f, -0.06581165f, 
    0.06810679f, 0.02577225f, 0.11455034f, 0.03871237f, -0.00035861f, 0.00296709f, -0.12152827f, -0.06564084f, 
    -0.15447418f, -0.04490492f, 0.12760188f, 0.04828868f, -0.06900373f, -0.06674463f, 0.04288449f, -0.16894464f, 
    0.18377787f, 0.14682291f, -0.05979618f, 0.02683925f, -0.11916440f, 0.04621997f, 0.07965069f, -0.05724423f, 
    0.06764719f, -0.04332881f, -0.02349242f, -0.24962808f, -0.01692226f, -0.09439044f, -0.05682032f, -0.10775686f, 
    -0.01022972f, -0.33330154f, -0.10408395f, -0.04830764f, -0.03016727f, -0.05530740f, -0.08190794f, -0.04224730f, 
    0.01403398f, 0.03812574f, -0.00537945f, 0.08684570f, 0.04083941f, 0.10518682f, 0.04631638f, 0.05037758f, 
    0.01353931f, 0.02211694f, -0.01064276f, 0.05653102f, 0.10459840f, -0.07137235f, -0.10452946f, 0.14070939f, 
    -0.10927700f, 0.06291916f, -0.08553378f, 0.01958002f, 0.05215383f, 0.05608587f, 0.08872769f, -0.17978711f, 
    0.00590899f, -0.01285855f, 0.15053172f, 0.06734465f, 0.04453447f, 0.02057701f, -0.15417568f, 0.04617314f, 
    -0.13577311f, 0.03407228f, 0.03331435f, 0.21049389f, 0.07471702f, 0.01563788f, 0.11290294f, 0.24166533f, 
    0.10325997f, -0.05324029f, -0.05416896f, -0.04791556f, 0.05541645f, 0.02499213f, -0.03876998f, -0.05543273f, 
    -0.20501129f, -0.20830414f, -0.10891125f, -0.01943694f, 0.09172321f, 0.04858514f, 0.08789901f, -0.03038958f, 
    0.05900944f, -0.03934894f, 0.04887069f, 0.02266925f, 0.01206948f, -0.02975887f, 0.01501776f, 0.04132043f, 
    -0.01335798f, -0.00643489f, -0.27576119f, -0.00757239f, 0.07284006f, 0.12327278f, -0.05223290f, 0.08959481f, 
    -0.07135757f, -0.04329942f, -0.01006698f, 0.12400635f, 0.08472466f, -0.08003722f, 0.08386235f, -0.01146212f, 
    -0.01777660f, 0.08804633f, -0.00051026f, 0.08026455f, 0.02885506f, -0.09117655f, -0.07844479f, -0.15544668f, 
    -0.05026051f, -0.07505014f, -0.08207091f, 0.08989526f, -0.10329067f, 0.34128752f, 0.12559982f, 0.07081003f, 
    -0.04555403f, -0.11267306f, -0.11270699f, 0.00346257f, 0.04124331f, -0.04097453f, 0.08677325f, -0.00569132f, 
    -0.03759054f, -0.09261053f, -0.15242805f, 0.04996286f, 0.00972444f, 0.08030909f, 0.03057409f, -0.26020688f, 
    -0.16513059f, -0.13681434f, 0.00406173f, 0.06067422f, -0.05402849f, -0.03198091f, 0.01182513f, 0.05190447f, 
    0.03578634f, 0.00510204f, -0.01453862f, 0.02195339f, 0.01638412f, -0.05846041f, 0.10205480f, -0.04424470f, 
    -0.01044336f, -0.08494092f, -0.09724224f, -0.27969134f, 0.14983630f, -0.01551908f, -0.00671481f, 0.06159779f, 
    0.07538302f, -0.03224339f, 0.05746808f, -0.04036462f, -0.15050671f, -0.16563292f, -0.08279063f, -0.00725211f, 
    0.09813093f, 0.05052308f, 0.13498995f, -0.21822053f, -0.18053490f, -0.16607477f, 0.03421767f, 0.15479702f, 
    -0.02071412f, 0.03342921f, -0.03872806f, -0.11262664f, -0.11979859f, 0.09264379f, 0.02211190f, 0.01746201f, 
    0.04167332f, 0.00358070f, 0.16613688f, -0.10359547f, 0.07801533f, 0.14983846f, 0.06439988f, 0.11570159f, 
    0.00548199f, -0.21816264f, 0.11335756f, 0.12637404f, 0.00190925f, -0.02044359f, -0.13316251f, 0.06858770f, 
    -0.16913845f, -0.02941875f, 0.04806400f, -0.11300921f, 0.08579702f, -0.02546309f, 0.04917243f, -0.10578215f, 
    -0.03633678f, -0.20461299f, 0.10598971f, 0.08753276f, -0.00238833f, -0.06289460f, 0.06208816f, -0.08136931f, 
    0.07564895f, 0.03252324f, 0.06502572f, 0.18907805f, -0.06824345f, 0.01537863f, 0.06786327f, 0.02985642f, 
    0.19238001f, -0.00543522f, 0.01705438f, -0.07749612f, 0.12198359f, 0.13687335f, -0.00287663f, -0.00162847f, 
    -0.18482703f, -0.12092299f, 0.05812400f, -0.02408895f, -0.04808632f, -0.09539240f, -0.07634625f, 0.01698984f, 
    0.13940875f, -0.05900295f, 0.14310314f, -0.04158425f, -0.08062842f, 0.13325243f, -0.08124483f, 0.00379963f, 
    -0.01764275f, 0.09246822f, 0.04980336f, 0.05993743f, -0.25543416f, -0.11299460f, 0.21675655f, 0.08017550f, 
    -0.09237193f, 0.00178484f, -0.00191589f, -0.04619565f, -0.03094526f, 0.23920898f, 0.09426665f, 0.04448585f, 
    -0.01011535f, -0.12074522f, 0.00907940f, -0.01767680f, 0.01607473f, -0.03204136f, -0.16789365f, -0.13337739f, 
    -0.24062665f, 0.06585170f, -0.10983017f, -0.07489961f, 0.03386516f, -0.10656025f, 0.09811828f, 0.01504508f, 
    0.03849030f, -0.05753154f, 0.05988812f, 0.19446436f, 0.07872382f, 0.11161968f, 0.00359776f, 0.01682717f, 
    0.05304136f, 0.01385835f, 0.30857185f, -0.13359343f, -0.12128240f, -0.02161222f, 0.06689955f, 0.01484923f, 
    0.06277467f, -0.04678563f, -0.26537800f, 0.04995541f, -0.06758056f, 0.08258575f, -0.08689170f, 0.00181165f, 
    0.01220375f, 0.01672618f, 0.05738969f, 0.03394675f, 0.10104716f, 0.04585440f, -0.02039735f, -0.03268302f, 
    0.12690963f, 0.00313466f, 0.05741566f, 0.19976045f, 0.02512100f, 0.11153390f, -0.04472062f, -0.07642274f, 
    -0.00317061f, -0.07508510f, -0.01832772f, 0.04343364f, 0.08621022f, 0.03379726f, -0.01588995f, 0.01619989f, 
    0.01656618f, 0.06142717f, -0.07201976f, -0.00192267f, -0.09411713f, -0.19142693f, -0.04294870f, -0.04775207f, 
    0.01626175f, 0.02702079f, 0.04389769f, 0.11951596f, -0.09012131f, -0.09176371f, 0.24037711f, 0.05567948f, 
    0.19072495f, -0.15310507f, 0.02885256f, 0.07964722f, 0.04880686f, 0.03946840f, 0.08513039f, -0.29779127f, 
    -0.31846750f, 0.01105689f, 0.06338590f, 0.11845944f, 0.04471137f, -0.06487641f, 0.05086228f, -0.04365084f, 
    0.07915422f, -0.17249595f, -0.12885892f, 0.09471411f, 0.01113687f, 0.17654514f, -0.09622280f, -0.02132203f, 
    -0.08047591f, -0.09346232f, -0.17894095f, -0.11179350f, 0.12922648f, 0.03258818f, 0.11850829f, -0.02655706f, 
    -0.01522884f, 0.10644613f, -0.21342690f, -0.03532922f, -0.19554436f, 0.05896080f, 0.00728647f, 0.08511992f, 
    0.02927367f, -0.10819957f, -0.03504626f, 0.00811503f, 0.19201477f, 0.14924534f, 0.15688141f, 0.10251836f, 
    0.12466041f, 0.06839986f, 0.08027685f, 0.08430881f, -0.09077647f, -0.16336572f, 0.11211768f, -0.15253301f, 
    -0.05775861f, 0.04827532f, -0.19703525f, -0.07418107f, -0.09071625f, -0.11842724f, 0.23618774f, 0.22618788f, 
    -0.06253205f, 0.03959741f, 0.10174800f, -0.05308232f, 0.00163254f, 0.07507528f, -0.29297611f, 0.02247064f, 
    -0.10198478f, 0.11554017f, 0.09695398f, 0.05059532f, -0.03678405f, -0.09563362f, -0.03148012f, -0.05842441f, 
    -0.12044771f, -0.08893228f, 0.12343886f, 0.02854057f, -0.06272716f, -0.06213399f, 0.01716607f, -0.06136375f, 
    0.09029643f, -0.05793834f, -0.24963106f, 0.07500674f, 0.09901538f, 0.17021938f, 0.14332013f, -0.04502231f, 
    0.09279366f, -0.01639655f, 0.04940255f, -0.10370966f, 0.07028371f, 0.08846607f, 0.01460548f, -0.04687057f, 
    -0.01803368f, 0.09182101f, -0.34609762f, -0.13663067f, -0.17525804f, -0.10243729f, 0.04221942f, 0.05638649f, 
    -0.01483697f, -0.00329308f, 0.09719629f, -0.13146646f, -0.13836649f, -0.13838123f, 0.19466619f, -0.01206879f, 
    0.19472620f, -0.00573913f, -0.10300191f, 0.01307132f, -0.07307666f, -0.06263114f, -0.01990176f, -0.14040329f, 
    0.15609521f, -0.04341162f, 0.15249430f, -0.00569205f, -0.05575019f, -0.13542859f, 0.18278699f, 0.36701098f, 
    -0.06728486f, -0.02904529f, -0.12771104f, 0.08133846f, 0.00291418f, -0.05981776f, -0.19109793f, -0.04855833f, 
    -0.09341287f, 0.07031637f, 0.02931158f, -0.05554435f, 0.10012016f, 0.05970368f, 0.02055603f, -0.06992314f, 
    0.00510267f, -0.02687003f, 0.08589315f, -0.07220320f, 0.02929309f, 0.05128396f, 0.06240989f, 0.16148853f, 
    0.12083418f, 0.05559338f, 0.19512714f, -0.07664798f, -0.00337877f, -0.00870440f, 0.07914281f, 0.01278685f, 
    0.20658453f, -0.10737230f, 0.02252351f, -0.09329603f, 0.11214192f, -0.00444137f, 0.06280450f, -0.12190595f, 
    -0.11554882f, -0.01317810f, 0.00876309f, -0.02988952f, 0.02865370f, 0.16782427f, 0.02048596f, 0.03862270f, 
    0.08704473f, -0.02021633f, 0.10413344f, -0.19366056f, -0.05167954f, 0.07106656f, 0.15018706f, 0.02377558f, 
    0.02575301f, 0.09594174f, 0.01071027f, -0.01114358f, -0.08560122f, 0.10794359f, 0.00611108f, -0.10021058f, 
    -0.09490294f, -0.05927662f, 0.01182597f, 0.09371120f, 0.04230149f, -0.15985574f, 0.35878816f, 0.31643000f, 
    -0.03528760f, 0.04612899f, -0.07483374f, -0.07600528f, 0.07882664f, 0.02074390f, -0.03724197f, -0.33518687f, 
    -0.12098776f, 0.00238078f, -0.00445856f, -0.10087186f, 0.10919899f, 0.12231612f, -0.02792981f, 0.10410360f, 
    0.22209121f, 0.04809242f, 0.01076107f, 0.21815671f, 0.04856723f, 0.02111915f, 0.08389298f, 0.03448492f, 
    -0.06902350f, -0.01075181f, -0.08578939f, 0.02426646f, -0.13206224f, 0.01389832f, 0.03857481f, -0.12734525f, 
    -0.04523047f, -0.07362687f, 0.05791814f, -0.13988492f, -0.00110327f, 0.01894005f, -0.00264778f, -0.14229974f, 
    -0.05129058f, -0.07155521f, -0.10533943f, -0.02589952f, -0.04291812f, -0.02286627f, 0.04812300f, -0.00344193f, 
    -0.02688950f, 0.00248756f, -0.02436160f, 0.25267056f, 0.20828412f, 0.22495425f, 0.25059703f, 0.05218274f, 
    0.10393707f, 0.12951626f, 0.02312020f, 0.05303159f, -0.13881193f, 0.20694889f, 0.18427365f, 0.12458453f, 
    0.02874540f, 0.13226663f, 0.10948908f, 0.05849677f, 0.12076433f, -0.21738262f, -0.12349882f, -0.02031878f, 
    0.23010196f, 0.05295426f, 0.22461499f, 0.03985327f, -0.07838602f, -0.09632596f, -0.12999438f, 0.07551670f, 
    0.31733119f, 0.02040503f, 0.11047619f, 0.10709927f, 0.15660311f, 0.09936573f, -0.09837260f, -0.36251760f, 
    -0.14216270f, -0.12020680f, 0.08266549f, 0.14044288f, 0.09657544f, 0.01222168f, -0.10602292f, -0.02091412f, 
    -0.07202933f, -0.00008173f, 0.12813114f, -0.06857227f, 0.03531757f, -0.02828031f, 0.09366052f, -0.00416874f, 
    0.01616043f, -0.08407164f, 0.04032871f, -0.16176245f, -0.05852947f, -0.06667134f, 0.05660840f, -0.06183388f, 
    0.13045880f, -0.07287166f, 0.05974355f, 0.07703421f, 0.10872619f, -0.10150801f, 0.11027536f, -0.07040574f, 
    0.01419928f, -0.02087338f, 0.04031998f, -0.11781722f, 0.00992451f, 0.04988232f, 0.00165343f, 0.00789755f, 
    0.00731891f, -0.02930155f, -0.10134194f, 0.04396342f, -0.02904052f, 0.02059220f, 0.19186850f, -0.05149393f, 
    0.08873256f, -0.05241717f, 0.04964221f, 0.05482896f, 0.13317980f, -0.22023076f, -0.33076125f, 0.21232250f, 
    0.14363661f, -0.02390267f, -0.14622664f, -0.05706136f, -0.12934303f, 0.22678171f, 0.12502827f, 0.01237043f, 
    0.01922609f, 0.13452718f, -0.05396551f, -0.13505593f, -0.01023193f, -0.04455584f, -0.11227673f, -0.04511534f, 
    -0.09618275f, -0.01916059f, 0.03903670f, 0.03774676f, -0.13492762f, 0.08106138f, 0.02036598f, 0.13166803f, 
    0.06275156f, 0.10970505f, 0.10933378f, -0.04194023f, 0.03970830f, -0.12728447f, 0.09190914f, -0.07094521f, 
    -0.02796560f, 0.05273602f, -0.14202867f, -0.26062104f, 0.08409968f, -0.09341222f, 0.01197175f, 0.06561455f, 
    -0.15961312f, 0.00898859f, 0.13067898f, 0.03742232f, 0.16936916f, 0.08489560f, 0.09956299f, -0.01231537f, 
    0.00329969f, 0.01016320f, -0.02809430f, -0.06784526f, 0.20343372f, 0.20417546f, -0.08621719f, 0.09994639f, 
    -0.08217584f, -0.01861514f, -0.02958901f, 0.05009456f, 0.04352540f, 0.17128800f, -0.22640413f, 0.10772783f, 
    -0.03975222f, 0.08114950f, -0.08912297f, 0.06454770f, 0.03054954f, -0.12269799f, 0.00347404f, 0.11340437f, 
    0.10382005f, -0.16338247f, -0.14245927f, -0.10281987f, 0.01223671f, -0.01004700f, 0.10913223f, 0.26640010f, 
    -0.13363153f, 0.08089397f, -0.04092398f, 0.20725395f, -0.01451944f, 0.00408109f, 0.16379806f, 0.20787449f, 
    0.14017279f, -0.15524587f, -0.03567784f, 0.08563117f, 0.07338151f, -0.11746532f, 0.09484865f, -0.08293753f, 
    -0.01831078f, -0.23768316f, -0.05657651f, -0.04794650f, -0.08099785f, -0.01728643f, -0.01420952f, 0.04562504f, 
    -0.04802655f, 0.23710896f, 0.12051513f, 0.15884748f, 0.11650937f, -0.08057670f, -0.06402590f, -0.11166894f, 
    -0.04862078f, -0.11383552f, 0.06495984f, -0.04648584f, 0.03875440f, -0.03375064f, -0.00962242f, -0.08361847f, 
    0.05256213f, 0.02947517f, 0.00266395f, 0.03784305f, -0.01033292f, 0.04308713f, -0.03315764f, 0.11211511f, 
    -0.06403422f, 0.00384334f, 0.04335995f, 0.02329750f, -0.03375748f, -0.14917260f, -0.16186345f, 0.20433620f, 
    0.10411094f, 0.05159288f, -0.08866267f, 0.08675323f, 0.02497316f, -0.30152047f, -0.02706316f, 0.12356056f, 
    0.06245254f, 0.01225150f, 0.00736180f, -0.14159794f, 0.00873391f, 0.06808157f, 0.05859083f, -0.09304068f, 
    -0.12457778f, 0.00275049f, 0.01444534f, 0.03255259f, -0.02745799f, -0.02780602f, -0.17173433f, -0.10269470f, 
    0.01867783f, -0.08455397f, -0.03462781f, 0.08851662f, 0.09539759f, -0.19695510f, 0.06905773f, -0.05651671f, 
    -0.02818277f, -0.24357177f, 0.06370632f, 0.00622673f, -0.12528628f, -0.06603167f, 0.10268313f, 0.08524963f, 
    0.04890735f, -0.19857189f, -0.15593518f, 0.06838401f, -0.03722990f, 0.13720693f, -0.06939594f, -0.23625654f, 
    -0.13587227f, -0.09114895f, -0.15450415f, 0.01319691f, -0.06562851f, 0.02729099f, -0.13084768f, 0.01683928f, 
    0.00549842f, -0.04763740f, 0.00098608f, 0.10267276f, -0.00095366f, 0.07389876f, 0.05533373f, -0.05583622f, 
    -0.17101695f, -0.01368613f, -0.01160763f, -0.04798716f, -0.07805661f, -0.03389621f, 0.04235712f, 0.05412887f, 
    0.07917196f, -0.06904916f, 0.13062069f, -0.02049208f, 0.13948341f, 0.07581924f, 0.07298340f, -0.05718768f, 
    -0.03780555f, -0.21829434f, 0.12503338f, 0.02614048f, 0.07029030f, -0.03282877f, -0.03292609f, -0.08253153f, 
    0.11323755f, 0.13317631f, -0.05389200f, -0.17868786f, -0.05549281f, -0.08419256f, 0.03285334f, 0.00644131f, 
    0.26457447f, 0.09200216f, 0.01270753f, 0.01852384f, 0.00924287f, 0.04159668f, 0.02276418f, -0.07182315f, 
    0.27100182f, -0.03063266f, -0.15025964f, -0.02950138f, -0.00582895f, -0.04275467f, 0.13389736f, 0.08320643f, 
    0.02867342f, 0.13377322f, -0.08218238f, -0.05224027f, 0.03177313f, -0.03618133f, -0.12018799f, 0.08641966f, 
    -0.09223388f, 0.00269364f, 0.01579024f, -0.04689421f, -0.05052294f, 0.03333499f, -0.00752934f, -0.03371930f, 
    0.03912886f, 0.04380002f, 0.05717333f, -0.14969608f, 0.13424647f, 0.07690779f, 0.07705753f, 0.07850225f, 
    0.08737505f, 0.09469267f, 0.01038206f, 0.01570524f, -0.04034680f, -0.19151323f, -0.17058106f, 0.07718465f, 
    -0.03286288f, -0.12030495f, -0.03534912f, -0.03368369f, -0.11016719f, -0.32088274f, 0.04091252f, 0.13766819f, 
    -0.11068268f, -0.00553277f, -0.16158237f, -0.04592367f, -0.02460932f, -0.01345076f, 0.10862322f, 0.04716673f, 
    -0.12965208f, 0.08403069f, 0.11596695f, 0.03007931f, 0.12750955f, 0.05276378f, -0.18172391f, 0.06296468f, 
    0.03524664f, -0.11229332f, 0.08478800f, 0.00978829f, -0.01815052f, 0.13337615f, -0.08799932f, 0.05300488f, 
    -0.05998024f, -0.22455820f, -0.08680948f, -0.01705043f, 0.12721267f, 0.06758457f, 0.11420538f, 0.08206145f, 
    0.19264008f, -0.01603415f, 0.06312135f, 0.00356358f, -0.09448988f, 0.10437205f, -0.04136184f, -0.15708821f, 
    0.15946206f, 0.05410277f, -0.09165858f, 0.16819645f, -0.02877558f, 0.00494019f, 0.13030033f, -0.11513496f, 
    0.19785400f, 0.03175884f, -0.04093068f, 0.08557722f, 0.18300800f, -0.19239266f, 0.08059230f, -0.06155084f, 
    -0.08573401f, 0.01071595f, 0.06817766f, 0.04575904f, -0.00444662f, -0.04517792f, -0.11869764f, 0.01763951f, 
    -0.04955047f, 0.02069836f, -0.01555699f, -0.02743693f, 0.15698873f, -0.27094018f, -0.14510313f, 0.15975407f, 
    0.05722928f, 0.12393000f, -0.13964401f, -0.00137339f, -0.09712324f, -0.05123325f, 0.09353775f, -0.06502257f, 
    -0.07076841f, -0.01242190f, -0.11572175f, -0.09294520f, -0.00822216f, 0.09551587f, -0.02001110f, 0.11975837f, 
    0.05591778f, 0.11380476f, 0.01721407f, -0.20244260f, 0.09292882f, -0.00561636f, 0.10956425f, 0.04051861f, 
    0.04610267f, -0.11462092f, -0.01381860f, 0.06279232f, 0.05987430f, 0.05382864f, 0.00630865f, 0.20228966f, 
    -0.03077391f, -0.06415746f, -0.03817904f, 0.02484197f, -0.12686823f, 0.10715213f, -0.02028122f, -0.12569687f, 
    -0.00548445f, 0.17345455f, -0.21042202f, -0.07318892f, -0.02871001f, 0.05512204f, 0.00636258f, 0.01542372f, 
    0.15577793f, -0.03009266f, -0.09784450f, 0.02227400f, 0.10798203f, -0.02906221f, 0.10540443f, 0.16269328f, 
    -0.02007070f, 0.04947874f, 0.00121713f, -0.06563327f, 0.12805912f, -0.00910936f, -0.03893311f, 0.04129448f, 
    0.04689158f, -0.16863531f, -0.12756181f, 0.05054376f, -0.00203497f, -0.20497216f, 0.16109642f, 0.12989117f, 
    0.05614258f, 0.00643324f, -0.16240560f, 0.07208659f, -0.05872498f, 0.02441917f, 0.08116151f, -0.05819555f, 
    0.06248789f, 0.09975223f, -0.02318543f, -0.09695337f, 0.13414329f, 0.01425217f, 0.10867749f, 0.07089149f, 
    0.06937586f, 0.17001309f, -0.05962853f, 0.01356765f, -0.05081854f, 0.07308590f, 0.08839590f, 0.06785373f, 
    -0.01647654f, 0.01775570f, 0.03913662f, 0.06631157f, 0.05844377f, -0.03329419f, 0.09294049f, 0.10775767f, 
    0.00588649f, 0.14055339f, 0.19006123f, -0.01444246f, 0.04565474f, 0.20609961f, -0.09258103f, 0.01986103f, 
    0.04236817f, -0.08678000f, -0.23860073f, -0.16546953f, -0.00006350f, 0.02512319f, 0.13405952f, -0.02354437f, 
    0.11418325f, 0.00502092f, -0.04503746f, -0.08229520f, -0.08197426f, 0.02889001f, 0.05913817f, 0.07765727f, 
    0.14193778f, 0.11358686f, 0.01539540f, -0.06967705f, -0.19668840f, 0.06486517f, -0.01112414f, -0.02557342f, 
    0.00201003f, 0.05955767f, 0.18285809f, 0.09310799f, -0.02975323f, 0.07121048f, 0.11068729f, -0.17494154f, 
    0.08661315f, 0.06469460f, -0.02221564f, -0.06406222f, 0.04538486f, -0.00793691f, -0.22297694f, -0.03576351f, 
    0.03712368f, 0.05391123f, 0.20718293f, 0.00921753f, 0.05776642f, -0.10821210f, -0.07852613f, 0.04986322f, 
    0.02465535f, -0.06697464f, -0.06083341f, 0.00597026f, 0.06005810f, 0.00670006f, 0.17388617f, 0.05588254f, 
    0.03140422f, -0.02972370f, 0.03265076f, -0.01168289f, -0.01608481f, 0.03874453f, -0.01314710f, -0.06283626f, 
    0.00438298f, 0.02707660f, -0.01834284f, -0.05389215f, -0.04037250f, -0.02574049f, -0.00104941f, -0.00048119f, 
    0.02908790f, -0.05857855f, -0.06027446f, 0.03655916f, -0.00291890f, -0.04780042f, -0.04808445f, 0.01631625f, 
    -0.03952397f, -0.03051525f, -0.05796124f, -0.02761688f, 0.00440908f, 0.00663014f, -0.04564777f, -0.04872676f, 
    -0.04020736f, -0.06179947f, 0.01294017f, 0.03764247f, -0.02572690f, 0.00950009f, 0.03044862f, -0.01284003f, 
    -0.01190351f, 0.00282509f, -0.04078559f, 0.01579891f, -0.00007552f, -0.04218267f, 0.02164540f, -0.00902020f, 
    0.01815308f, 0.01996338f, 0.01147441f, 0.00381028f, -0.00192711f, 0.04349932f, 0.05266206f, -0.02604692f, 
    0.00936224f, -0.03142905f, -0.00331925f, -0.00951623f, -0.02645683f, 0.02931711f, 0.02700042f, -0.02262523f, 
    -0.02303651f, 0.03807974f, 0.03250645f, 0.01244159f, 0.01515151f, -0.04722863f, -0.03696604f, 0.04959023f, 
    -0.02690464f, 0.00062043f, 0.00500345f, 0.03757339f, -0.05886371f, 0.04846516f, 0.02228641f, 0.00912013f, 
    0.03526109f, -0.03673800f, -0.01165948f, -0.04550685f, -0.03519472f, -0.04317466f, -0.06029315f, -0.02360465f, 
    0.03908247f, 0.04063645f, -0.00994165f, 0.02450041f, 0.04401365f, -0.00864592f, 0.03674284f, -0.06039208f, 
    0.02306253f, 0.04292537f, 0.00869587f, 0.01314809f, 0.04181505f, -0.05471072f, -0.02794871f, -0.03423543f, 
    -0.02719039f, 0.03425723f, -0.04202404f, -0.01858198f, 0.04309571f, 0.00990202f, -0.05129588f, -0.02439946f, 
    -0.04997186f, -0.01975512f, -0.04333526f, -0.01494176f, -0.02567800f, -0.04310203f, -0.02873461f, -0.01778916f, 
    0.03705389f, -0.02421508f, -0.05978725f, 0.00313688f, -0.00872500f, 0.04824922f, -0.03521853f, 0.03787670f, 
    -0.04371333f, -0.01255535f, 0.04532335f, -0.01811278f, 0.02139799f, -0.03959527f, -0.06792574f, 0.02650336f, 
    -0.03605571f, 0.04252911f, -0.00343958f, 0.00644800f, 0.02834887f, 0.04690001f, 0.02402183f, -0.02508037f, 
    -0.01727482f, 0.02881429f, -0.04271041f, -0.00224565f, 0.02186650f, -0.00006211f, 0.00625628f, 0.04832452f, 
    0.00553817f, -0.05084582f, 0.04320914f, 0.01785325f, -0.00947940f, -0.02068334f, -0.00599956f, 0.03607026f, 
    0.04006349f, -0.03508593f, -0.02041640f, 0.03820953f, 0.04909956f, -0.00666665f, 0.00943030f, 0.04249838f, 
    -0.02055930f, -0.00998665f, -0.05784562f, 0.04851395f, -0.02905196f, 0.00675171f, 0.02415454f, -0.04185574f, 
    0.04870219f, -0.06029754f, 0.04742768f, -0.06587755f, -0.00244087f, -0.05902423f, -0.02102579f, 0.02767506f, 
    0.00911297f, -0.04215940f, -0.02722854f, -0.03678817f, 0.05635562f, -0.04146026f, 0.04908361f, 0.02742086f, 
    -0.02514181f, -0.01833589f, -0.03823914f, 0.02390728f, 0.00086515f, 0.02150960f, -0.05096833f, -0.01128706f, 
    -0.06538831f, -0.02196403f, 0.00915699f, -0.03211379f, -0.01792894f, -0.04413346f, 0.00323099f, -0.02691809f, 
    0.02568533f, 0.05045043f, 0.05139890f, -0.00751197f, -0.01635416f, 0.01822548f, 0.03778704f, -0.03934538f, 
    0.00749896f, 0.03586115f, -0.01637995f, -0.00020762f, 0.00051518f, 0.03188667f, -0.03143306f, -0.06336806f, 
    0.01998212f, -0.05202299f, -0.02272952f, 0.04590790f, -0.03811204f, -0.03497818f, -0.01028982f, 0.01001760f, 
    -0.01055938f, 0.00909262f, 0.03674940f, -0.02447299f, -0.05264457f, 0.04486598f, 0.00810598f, -0.01063196f, 
    0.03041092f, -0.00538392f, 0.00891374f, 0.02116284f, -0.01579299f, -0.04192027f, 0.01789589f, 0.00813846f, 
    -0.04223321f, -0.02130312f, -0.01412299f, -0.05063339f, 0.05277409f, 0.02414538f, -0.04996844f, -0.03034000f, 
    -0.00478195f, -0.01225744f, -0.00748537f, -0.02725426f, 0.00779008f, -0.01998063f, 0.03841606f, -0.05072388f, 
    -0.05885639f, -0.05504746f, -0.03757808f, -0.01176780f, -0.05822632f, -0.04127228f, -0.03018520f, -0.03187968f, 
    -0.00249464f, -0.00342191f, 0.02544788f, -0.04325951f, 0.00494731f, -0.01659860f, -0.00855693f, -0.05036695f, 
    -0.01961978f, -0.02095082f, -0.05895218f, 0.02324225f, 0.03647062f, 0.02223214f, 0.01388881f, -0.00012093f, 
    0.04815294f, -0.01188132f, -0.01847743f, -0.00198565f, -0.05132712f, -0.00693363f, -0.08251433f, 0.10686388f, 
    0.04947061f, 0.02480674f, -0.04965229f, -0.15437074f, -0.04752358f, -0.04565823f, 0.00961758f, -0.11787611f, 
    -0.10119497f, -0.04780161f, 0.04440602f, 0.02671616f, 0.00060822f, 0.03707096f, -0.01437278f, 0.05447550f, 
    -0.00618678f, -0.00645842f, 0.08679308f, 0.09407023f, -0.26650894f, -0.05418602f, -0.07395450f, 0.02901606f, 
    0.09344871f, -0.10434864f, 0.00614845f, -0.06285370f, 0.16581413f, -0.20605542f, 0.00146975f, 0.10315449f, 
    0.02116317f, 0.15134627f, -0.14801015f, 0.01091420f, -0.10194132f, 0.03610813f, -0.46937567f, -0.08095635f, 
    0.00513457f, 0.14243844f, 0.00805249f, -0.03402974f, -0.00863891f, 0.06077315f, 0.09837877f, -0.11168807f, 
    -0.19771861f, 0.05261806f, 0.05695957f, -0.02267516f, -0.00654424f, -0.00113250f, 0.01660122f, 0.06998064f, 
    -0.11260320f, 0.16574706f, 0.00201688f, -0.00802007f, -0.12358655f, -0.10943144f, 0.05249354f, -0.08679660f, 
    0.14261496f, -0.02806680f, -0.00066671f, 0.08250463f, 0.07752195f, 0.04699158f, 0.04457587f, 0.05214019f, 
    0.14265721f, -0.26168162f, 0.07665689f, -0.01694792f, -0.02812049f, 0.03280786f, 0.06489851f, -0.01378053f, 
    0.00302547f, -0.10600060f, -0.01868173f, -0.20011866f, -0.27059817f, -0.10360508f, 0.00079693f, -0.01653972f, 
    0.08576436f, 0.01554984f, -0.00204650f, 0.08503792f, 0.03042131f, 0.06032314f, 0.07978141f, 0.00224761f, 
    -0.05544948f, 0.05200033f, 0.17295358f, 0.00093954f, 0.19395830f, 0.10928942f, -0.12779853f, -0.05098057f, 
    0.06252524f, -0.01467169f, 0.09453682f, -0.01272937f, 0.03173192f, -0.44141093f, -0.26172715f, 0.07488303f, 
    -0.02004026f, 0.08078298f, 0.00207281f, 0.04655821f, 0.08532906f, -0.01402713f, 0.12525362f, 0.22561646f, 
    -0.09040628f, -0.03213763f, -0.15722074f, -0.05379127f, 0.00451445f, -0.03945147f, 0.02489688f, 0.02646794f, 
    0.19701715f, 0.12521505f, -0.01258321f, -0.03811760f, 0.09588647f, -0.03273339f, -0.14778978f, -0.03244305f, 
    0.19646963f, -0.01706920f, -0.12277768f, 0.01223160f, 0.04476674f, 0.03372436f, 0.06083560f, -0.01226704f, 
    0.01476726f, 0.05289169f, 0.31955278f, 0.04860685f, 0.00343957f, 0.12203735f, -0.04455528f, -0.16239059f, 
    -0.05813935f, -0.06101274f, -0.23340969f, -0.30085769f, 0.28671068f, -0.01038990f, -0.07018312f, 0.02596138f, 
    0.03293733f, -0.12784836f, 0.19286257f, -0.14611797f, -0.02234939f, -0.18760748f, 0.03433242f, -0.05783308f, 
    -0.05762487f, 0.05047778f, 0.08065747f, -0.14981563f, 0.31938538f, -0.01782222f, 0.11203991f, 0.08919279f, 
    0.06207255f, -0.00721606f, -0.04902147f, -0.06386257f, 0.00391047f, -0.09592678f, -0.38481936f, 0.06165953f, 
    0.06460603f, 0.07802883f, 0.04130279f, 0.04933429f, 0.12272327f, -0.04478222f, 0.23738074f, 0.22925194f, 
    -0.12040036f, -0.10058402f, -0.00642644f, -0.12267321f, 0.02377149f, -0.03598851f, 0.02402540f, -0.15778641f, 
    0.12302671f, 0.06236856f, 0.00295460f, -0.01464179f, 0.02835159f, -0.12160172f, -0.10074726f, 0.01790174f, 
    0.06029602f, -0.20983490f, -0.07740973f, -0.14295875f, -0.01486868f, -0.08960423f, -0.08117335f, -0.02589008f, 
    0.00758883f, 0.28234297f, 0.00989299f, 0.03481992f, 0.01834425f, -0.00643701f, -0.00184193f, -0.01244351f, 
    -0.18406326f, 0.01509847f, -0.08799459f, -0.07815740f, -0.01493785f, 0.09595303f, 0.07010560f, 0.13156049f, 
    -0.01579651f, -0.08797695f, -0.00051575f, -0.27666402f, -0.15267363f, 0.17775728f, 0.04559258f, -0.05680406f, 
    -0.00456777f, 0.11127730f, 0.04147139f, 0.07655154f, 0.19036728f, -0.45012918f, -0.08949993f, -0.07775793f, 
    -0.00385850f, 0.10216287f, -0.02562827f, 0.01167181f, -0.07513862f, -0.15657414f, 0.05074727f, -0.09132018f, 
    -0.12680586f, -0.03093419f, 0.04554356f, -0.07477005f, 0.01166186f, 0.01363531f, -0.27310029f, -0.40394890f, 
    0.07623695f, 0.05346550f, -0.05460214f, -0.01576057f, -0.17602357f, -0.08541235f, -0.09700758f, -0.01473153f, 
    0.11696891f, 0.15009610f, -0.00171353f, 0.02420051f, -0.00230663f, -0.01409931f, -0.01149374f, -0.04485529f, 
    -0.03549023f, 0.05200147f, 0.13055922f, -0.04954228f, -0.08580643f, -0.03541961f, 0.01337188f, 0.08114886f, 
    0.04144742f, -0.05300196f, 0.17712958f, -0.03424288f, 0.01351284f, -0.06506631f, 0.14070868f, 0.00322735f, 
    0.17318194f, 0.18985713f, 0.04555222f, 0.10049354f, -0.23281284f, 0.00267447f, 0.04080154f, 0.01818821f, 
    0.03560567f, -0.00051700f, 0.09396427f, -0.06701154f, -0.06511380f, 0.04985270f, 0.03323562f, 0.02343296f, 
    -0.05443172f, 0.00809583f, 0.00381872f, -0.10527487f, 0.01585298f, -0.01653233f, 0.18763751f, 0.02658870f, 
    0.00179084f, -0.08366909f, 0.16008306f, 0.18717124f, 0.08564611f, 0.20994958f, 0.01362258f, -0.01641338f, 
    0.03964699f, -0.06962845f, 0.07001922f, -0.15123948f, 0.16351472f, 0.09256590f, -0.01409840f, 0.09955130f, 
    0.17924659f, -0.05785280f, -0.03161149f, -0.14152509f, 0.04633403f, -0.00672141f, -0.00214354f, -0.07074641f, 
    -0.06408875f, 0.37388611f, -0.11873769f, 0.11223955f, -0.07663519f, 0.03129584f, 0.00439960f, 0.13582911f, 
    0.14113030f, 0.11538467f, -0.30618709f, -0.00006630f, -0.14582361f, -0.06897584f, 0.03356469f, 0.06049288f, 
    -0.18596466f, 0.12775983f, 0.00603335f, -0.05811132f, -0.11690766f, -0.08468594f, 0.11696430f, 0.11186155f, 
    0.10097777f, 0.01161547f, -0.05292753f, -0.09026991f, 0.17984283f, -0.06270274f, 0.10801611f, -0.02385370f, 
    0.12089716f, 0.03084987f, 0.11196610f, -0.17479038f, 0.07829854f, -0.14750001f, -0.07011390f, -0.00970007f, 
    0.00513999f, 0.05076046f, -0.05949037f, -0.06068369f, -0.08943553f, -0.12016403f, -0.07005475f, 0.05291570f, 
    0.13731538f, 0.00036746f, 0.06431435f, 0.10209758f, 0.06284893f, 0.09464167f, 0.01794597f, -0.16487914f, 
    0.07112155f, -0.10383302f, 0.12798771f, -0.15870872f, -0.09589219f, -0.03773926f, -0.36850303f, 0.03463513f, 
    0.12460700f, 0.09204164f, 0.07691650f, -0.00359131f, 0.15678905f, 0.04571398f, 0.00945538f, -0.06915022f, 
    0.01657839f, -0.16280416f, -0.00547754f, 0.21487302f, 0.14775753f, -0.09990214f, 0.07563227f, 0.00854383f, 
    0.10957626f, 0.07309822f, -0.05185706f, 0.05072770f, -0.10298134f, 0.10401103f, 0.02091847f, -0.04013848f, 
    0.15479575f, 0.06878457f, -0.06987971f, -0.11980635f, 0.15503556f, -0.18562081f, 0.21121290f, 0.04113818f, 
    -0.09258750f, -0.27619106f, 0.15734638f, 0.05743042f, 0.02130201f, 0.06444839f, -0.06818715f, -0.18371134f, 
    0.04395434f, 0.11821616f, 0.03212721f, -0.01003733f, -0.00157536f, -0.10025361f, 0.04115754f, -0.00969018f, 
    -0.14998448f, -0.13454401f, -0.07182082f, 0.16344211f, 0.02007341f, -0.34796986f, -0.13011664f, 0.14576028f, 
    0.13947041f, 0.03625756f, -0.06477986f, -0.00120914f, -0.04651788f, 0.20353886f, -0.08845875f, -0.08494404f, 
    0.03960958f, 0.03949834f, 0.02232624f, -0.10169389f, -0.02142931f, 0.05827899f, -0.17782263f, -0.04552075f, 
    0.04820182f, 0.05925504f, -0.03288954f, -0.06546593f, -0.00254212f, -0.16629541f, 0.01530476f, 0.09153613f, 
    0.10406765f, -0.12454358f, 0.07318623f, 0.06899858f, 0.14399621f, -0.03793885f, 0.10686365f, -0.09916545f, 
    -0.02067872f, -0.17190801f, 0.01265338f, -0.05847579f, -0.12250546f, -0.02915521f, 0.06558104f, -0.06394486f, 
    0.05642747f, -0.19432761f, -0.20486906f, -0.08919174f, 0.22518373f, -0.11472306f, -0.05655087f, 0.05163026f, 
    -0.07277768f, 0.08347701f, -0.06236798f, 0.20795248f, -0.02765429f, 0.10564473f, -0.01200062f, 0.09407242f, 
    -0.01576762f, 0.05177179f, 0.03052439f, 0.03539095f, 0.10399951f, 0.19108833f, 0.04091994f, -0.02712383f, 
    -0.16882484f, -0.00040990f, 0.10420270f, -0.02656837f, 0.03755823f, 0.07327368f, 0.05642589f, 0.15648901f, 
    0.02176396f, -0.10485461f, -0.09574015f, 0.15542950f, 0.05788189f, -0.13666259f, 0.12161920f, -0.18314618f, 
    -0.03674611f, -0.01968711f, 0.10575530f, 0.06584900f, -0.01530948f, -0.02845838f, 0.00291299f, 0.05997211f, 
    0.02711847f, 0.07697289f, -0.06853512f, 0.08750771f, -0.09158564f, 0.01515529f, 0.07206094f, 0.00203202f, 
    0.03035094f, -0.18672028f, 0.07305162f, -0.02339267f, -0.00203093f, 0.10621198f, 0.03201783f, -0.15257603f, 
    -0.04034009f, -0.17201239f, 0.02427525f, -0.03428123f, -0.09703670f, -0.05811016f, 0.03569983f, 0.08475310f, 
    -0.04134417f, 0.00377184f, -0.06758386f, 0.05206918f, 0.12907444f, 0.04331253f, 0.19053704f, 0.09415141f, 
    0.09763734f, 0.18056567f, -0.03674664f, -0.01585850f, 0.16691837f, -0.14184038f, -0.17699449f, 0.14443025f, 
    0.02967655f, 0.21910770f, -0.08168028f, -0.00989009f, -0.05960122f, -0.07925957f, 0.08969348f, 0.07987878f, 
    0.01372371f, 0.06333578f, 0.00897506f, -0.02412731f, 0.15281746f, 0.11826389f, -0.01101990f, 0.10096240f, 
    -0.13376336f, -0.08899569f, 0.00686492f, 0.01356557f, 0.10380088f, 0.12116280f, -0.01761546f, -0.11965697f, 
    0.17109720f, 0.02566498f, -0.02617415f, 0.00779770f, 0.05833866f, 0.04015605f, 0.16707225f, 0.15147218f, 
    -0.03092996f, 0.10584610f, 0.00784162f, -0.01234523f, 0.06675678f, -0.09810007f, 0.04837057f, 0.24824101f, 
    -0.02926636f, -0.10216207f, -0.08347297f, -0.06141351f, -0.08076876f, 0.02965100f, -0.01460537f, 0.02406347f, 
    -0.06414256f, 0.01710703f, -0.02997735f, -0.03392057f, -0.06629480f, -0.13371649f, 0.07498934f, 0.19452295f, 
    -0.13880648f, -0.08982786f, -0.01925753f, -0.31160933f, 0.00118195f, -0.02008166f, 0.03090394f, 0.09175301f, 
    -0.19130063f, 0.00711131f, 0.06901936f, 0.10876834f, 0.00356316f, -0.13483346f, 0.01835752f, -0.02994444f, 
    -0.00537487f, 0.03064808f, 0.07297309f, -0.31705743f, -0.36579403f, -0.06310439f, -0.07227802f, -0.02024905f, 
    0.02548224f, -0.07539258f, -0.11018452f, -0.10795891f, 0.04475909f, -0.20063165f, -0.13286115f, -0.01165455f, 
    0.00205178f, -0.07394939f, 0.07521355f, 0.04295521f, -0.05090639f, 0.13512631f, -0.11743699f, 0.11067419f, 
    0.16408929f, -0.04409011f, -0.18276584f, -0.01858635f, 0.04651162f, 0.13799237f, -0.21680593f, 0.24592100f, 
    0.19266708f, 0.14055517f, 0.04800865f, 0.11616815f, 0.03970839f, 0.01862095f, -0.08310021f, -0.34363008f, 
    0.10599244f, -0.00136885f, -0.03632793f, 0.16016030f, 0.07679779f, -0.06927883f, 0.00533397f, 0.18332253f, 
    -0.10949593f, -0.05055598f, -0.25682771f, 0.10603916f, 0.09664386f, 0.07337482f, 0.11552288f, -0.05835373f, 
    0.06116344f, 0.12786651f, 0.24961083f, -0.20888977f, -0.00759392f, 0.01579294f, 0.03771956f, 0.01932091f, 
    -0.10912977f, -0.04652680f, 0.22168872f, -0.06155257f, 0.06681241f, -0.03682879f, -0.00562705f, -0.11433608f, 
    0.03772341f, 0.08180200f, 0.10369217f, 0.17433244f, 0.16598107f, -0.15224275f, 0.07897437f, -0.14032671f, 
    0.04856669f, 0.06156123f, -0.00179921f, 0.14247872f, -0.24395195f, -0.11393414f, -0.36361361f, 0.06904829f, 
    -0.03202290f, -0.07268780f, -0.06841768f, 0.10371915f, 0.03892763f, -0.03714794f, -0.24544348f, -0.04026095f, 
    0.09283120f, 0.07625565f, -0.10040479f, 0.08729167f, -0.06480635f, 0.05623353f, -0.01487826f, 0.10690462f, 
    -0.04683547f, 0.05719515f, -0.11174653f, -0.01080204f, -0.03036049f, -0.05334997f, 0.06013202f, -0.18310021f, 
    -0.14686389f, -0.21991467f, 0.20059250f, 0.05241034f, 0.18287492f, 0.15520869f, -0.02860143f, 0.04269048f, 
    0.00130953f, 0.16849032f, -0.19811748f, -0.10258665f, 0.01437423f, 0.02869524f, 0.04015176f, 0.02117671f, 
    0.00478196f, -0.29556659f, -0.07546107f, -0.26217380f, -0.04050789f, -0.05307351f, -0.01857042f, 0.07217398f, 
    0.02883540f, -0.08763391f, -0.12936486f, -0.11794818f, -0.07702476f, 0.10515220f, 0.03998153f, 0.08962577f, 
    0.09773456f, -0.05907187f, 0.13002671f, 0.10520136f, 0.22452374f, 0.12646045f, 0.06509911f, 0.03087144f, 
    -0.09634010f, 0.08782980f, 0.10868283f, 0.00526241f, 0.09108870f, 0.16093674f, -0.06497040f, 0.14894879f, 
    -0.00275654f, -0.04985848f, -0.03741733f, 0.07959950f, 0.01635110f, 0.13441066f, 0.05169745f, 0.20696189f, 
    -0.10097848f, 0.02860486f, 0.01266343f, 0.06321787f, 0.02180481f, 0.11371841f, -0.02726368f, 0.15890872f, 
    0.02959932f, 0.14968650f, 0.09792162f, 0.00739789f, 0.04509679f, 0.04993892f, 0.03913652f, -0.32402503f, 
    -0.25074625f, 0.19132371f, 0.00061999f, -0.02426460f, -0.03955387f, 0.06153053f, 0.01505737f, -0.01502631f, 
    -0.02378448f, -0.03342239f, -0.06986637f, -0.02114559f, -0.06803570f, -0.04208900f, 0.03983940f, 0.02554632f, 
    -0.05524679f, 0.02642046f, -0.01298915f, 0.01410205f, -0.05505743f, -0.03274867f, 0.01660121f, 0.02881597f, 
    0.01169071f, 0.00256772f, -0.06345021f, -0.01549075f, 0.00758522f, 0.04014771f, -0.00363800f, 0.04859218f, 
    -0.00042003f, -0.05905260f, 0.04083193f, -0.04996833f, -0.05095045f, 0.04733974f, -0.05361402f, 0.02303988f, 
    -0.05695695f, -0.02641998f, 0.04157664f, -0.04168546f, 0.00786054f, 0.00312869f, -0.04843433f, -0.05473524f, 
    -0.03175746f, 0.00327173f, 0.01090053f, -0.02313183f, 0.00078014f, -0.00198566f, -0.01371664f, 0.05181508f, 
    -0.04120525f, -0.00461865f, -0.02327608f, -0.05687078f, -0.04504656f, -0.04489549f, 0.03780361f, 0.01158095f, 
    -0.01884115f, -0.02080207f, 0.01520413f, -0.02723025f, -0.06637593f, 0.04303331f, 0.01223666f, -0.08593254f, 
    -0.01910022f, 0.00554639f, -0.03457472f, 0.00444250f, -0.04180975f, -0.07383127f, -0.05352154f, -0.02007929f, 
    0.02062801f, 0.02320931f, -0.02778369f, 0.02823026f, -0.01622180f, -0.06287608f, -0.01255203f, 0.01191209f, 
    -0.00757838f, -0.05169125f, 0.05108130f, 0.00513947f, 0.01739008f, 0.01728944f, -0.03015190f, -0.04906179f, 
    -0.05462969f, -0.03086077f, -0.01087790f, 0.02734209f, -0.07616135f, -0.09037349f, -0.02699705f, -0.03274602f, 
    -0.04244212f, 0.02792091f, 0.02729305f, -0.01824824f, -0.03565530f, -0.07466596f, 0.02320881f, -0.03093538f, 
    -0.00181097f, -0.01006439f, 0.00840513f, -0.05239923f, -0.02353187f, 0.05754708f, -0.02078550f, -0.03815934f, 
    -0.06582462f, 0.00361290f, -0.03852814f, -0.02526535f, -0.03735553f, 0.04532944f, -0.06474261f, -0.01209542f, 
    -0.02606366f, -0.02153613f, -0.01686443f, 0.01177524f, -0.02695541f, 0.02078854f, -0.05240874f, -0.02941884f, 
    -0.04634852f, -0.04422269f, 0.04488214f, 0.03298887f, -0.01946986f, -0.07644702f, -0.07481775f, -0.04768251f, 
    0.04353487f, -0.08007051f, 0.02253847f, -0.03014201f, 0.02207233f, -0.03645170f, -0.04994608f, -0.00984925f, 
    -0.04811789f, 0.03148320f, -0.00031716f, 0.02490772f, -0.01370535f, -0.05029751f, -0.02754996f, 0.03013882f, 
    -0.04278397f, 0.02495076f, 0.02119058f, -0.00865151f, 0.03276972f, 0.02629009f, -0.05152912f, -0.08106152f, 
    0.01873880f, 0.02210024f, 0.02283230f, 0.01395205f, 0.03726396f, -0.03831239f, 0.02876684f, -0.04205165f, 
    0.02171393f, 0.03520332f, 0.02748936f, 0.00540845f, 0.03011816f, -0.00626851f, 0.00356211f, -0.00395703f, 
    0.04846638f, -0.06414765f, -0.00603582f, 0.01124342f, 0.01786753f, 0.02419588f, 0.04941447f, -0.06425486f, 
    0.02859425f, -0.00709342f, 0.01491062f, -0.04826728f, 0.03451904f, -0.02058110f, 0.00821170f, 0.02818567f, 
    -0.09418267f, -0.06800730f, -0.00068703f, 0.01022560f, -0.05789655f, -0.00448441f, -0.03667451f, -0.02163700f, 
    -0.00748510f, -0.04263065f, 0.03479582f, 0.03011737f, 0.01117264f, -0.01801850f, -0.01124390f, 0.00082140f, 
    -0.06052085f, -0.01512689f, -0.06807563f, -0.04329824f, 0.00331407f, -0.04623280f, 0.01842271f, 0.03125067f, 
    -0.06981723f, -0.04685612f, -0.08993323f, -0.07832237f, 0.03454323f, 0.03777520f, -0.02349731f, -0.05959443f, 
    -0.04906863f, 0.06378223f, -0.08597578f, -0.03494471f, -0.06474116f, 0.02407947f, -0.07415003f, 0.01984407f, 
    -0.01682638f, 0.00800087f, 0.01841155f, 0.00772232f, 0.05133100f, -0.01246963f, -0.08140891f, 0.00911347f, 
    -0.02966938f, 0.02081475f, 0.00621801f, -0.05907080f, -0.02838963f, -0.02000538f, -0.08018394f, 0.00721049f, 
    -0.05489181f, -0.08040658f, -0.04259453f, 0.02361940f, 0.00700053f, -0.00354433f, 0.02664822f, -0.02313858f, 
    0.00751247f, -0.04998547f, -0.07861936f, 0.00173373f, 0.00417170f, -0.02919041f, -0.07008154f, -0.04256746f, 
    -0.06423418f, -0.00235507f, -0.03457766f, -0.01025132f, -0.04389403f, 0.01729306f, -0.06093008f, 0.01451338f, 
    -0.04485340f, -0.06513992f, -0.02596255f, -0.01960578f, -0.02142502f, -0.00180136f, -0.02124096f, -0.05132097f, 
    -0.03850992f, -0.06012006f, -0.00477091f, -0.06429680f, 0.00199478f, -0.03763938f, 0.01208104f, 0.00876818f, 
    -0.02398793f, -0.04463730f, -0.04621695f, -0.00708161f, -0.04157590f, -0.05469307f, -0.01852987f, -0.05151687f, 
    -0.03442335f, 0.01435270f, 0.01043355f, 0.00991036f, -0.01504117f, -0.02459775f, 0.00735338f, -0.06189737f, 
    -0.01636010f, -0.03727113f, -0.06189744f, -0.05282410f, 0.01170000f, -0.05948064f, 0.02158946f, -0.05997243f, 
    0.00656607f, -0.05385040f, 0.01338512f, 0.05329031f, -0.03794453f, 0.04620760f, 0.00045171f, -0.05352723f, 
    -0.03309310f, -0.00389355f, -0.04155907f, 0.03128749f, -0.01075892f, -0.02303089f, -0.00144482f, -0.03250843f, 
    0.01455690f, -0.05630407f, 0.00132081f, -0.01531724f, -0.03793156f, 0.01271413f, -0.05264811f, -0.05752145f, 
    -0.01551292f, -0.04325506f, 0.04397372f, 0.02220116f, 0.00957146f, 0.00583637f, -0.05746072f, -0.05176464f, 
    -0.06070408f, -0.05375835f, 0.05353428f, 0.04827752f, -0.00853395f, -0.00838928f, -0.05385336f, 0.03002858f, 
    -0.03663963f, 0.04645393f, -0.02967788f, -0.01967840f, -0.00077554f, -0.06062545f, -0.02094078f, -0.02145758f, 
    0.03453062f, 0.03653776f, 0.02287051f, -0.03767563f, 0.01563336f, -0.04361234f, -0.03972551f, -0.01965704f, 
    -0.04964692f, 0.01098328f, -0.04654407f, -0.01426280f, 0.00572977f, -0.01913572f, -0.00311065f, -0.04663692f, 
    -0.06121187f, 0.00294585f, 0.02095682f, 0.05215381f, -0.05483101f, 0.04704403f, -0.05353977f, -0.01155832f, 
    -0.05539839f, 0.02378238f, -0.04322526f, -0.05075341f, -0.03371513f, 0.00493319f, -0.03601210f, 0.05207522f, 
    -0.05437085f, -0.01832116f, 0.02836366f, -0.03392320f, 0.02836213f, -0.00076727f, 0.03952675f, -0.04265210f, 
    -0.04454830f, 0.00886016f, 0.04287634f, 0.02579395f, 0.01891547f, 0.04800390f, -0.02266749f, 0.04930136f, 
    0.04212646f, -0.01211565f, 0.00203047f, -0.01705842f, 0.00840718f, -0.02193009f, 0.05103988f, 0.04620773f, 
    -0.00003706f, -0.03230103f, 0.01039507f, -0.01395767f, -0.05126808f, -0.01672788f, 0.01110246f, 0.01930975f, 
    -0.00292315f, -0.01443909f, 0.00744864f, 0.01363859f, -0.04334961f, 0.03797278f, -0.04717207f, -0.00695081f, 
    0.00398265f, 0.01958834f, -0.05486094f, 0.01868539f, -0.05486247f, -0.03121907f, -0.00948182f, 0.01773017f, 
    -0.06134860f, 0.04275209f, -0.03748714f, -0.00917053f, 0.02519314f, 0.04174193f, 0.01515652f, -0.03920878f, 
    -0.05049314f, 0.00903670f, 0.02056986f, 0.03342525f, -0.01950805f, -0.00226781f, 0.00825705f, -0.06254818f, 
    0.02015212f, -0.00387496f, 0.02666798f, 0.04688092f, -0.01556544f, -0.05222204f, 0.03890113f, -0.03248428f, 
    -0.00210909f, 0.03808173f, 0.02029751f, -0.01443170f, -0.02323310f, -0.03746308f, -0.00813009f, -0.01582415f, 
    -0.04252292f, 0.04650615f, 0.03794524f, -0.00855285f, -0.00919266f, 0.01961404f, 0.02051652f, -0.01908477f, 
    0.02811114f, -0.02367909f, 0.03158769f, -0.05688905f, 0.03815375f, 0.03519241f, -0.02200480f, 0.01661534f, 
    -0.03693292f, 0.02321389f, 0.03152480f, -0.02179319f, -0.05062469f, -0.04461292f, -0.04752510f, -0.05790918f, 
    0.03238371f, -0.04422054f, 0.00925514f, 0.04194639f, 0.01239096f, -0.04615295f, -0.04549554f, 0.04138526f, 
    -0.05834638f, -0.01018690f, -0.03449753f, -0.04414129f, -0.06028433f, 0.04765781f, -0.04742512f, -0.01521170f, 
    0.03740385f, 0.04063943f, 0.02966021f, 0.02248623f, -0.00654133f, 0.03195759f, 0.03771172f, -0.03367417f, 
    -0.04729367f, -0.01261431f, -0.04437048f, 0.00582153f, 0.03735527f, 0.05237930f, 0.03990935f, -0.01262632f, 
    -0.04700802f, -0.01802206f, 0.02187943f, -0.06001400f, 0.01960978f, -0.04791358f, 0.02149818f, -0.04630987f, 
    0.03894307f, -0.05297875f, -0.04854002f, 0.03126280f, -0.03298849f, -0.04282404f, 0.02951882f, 0.03607278f, 
    -0.01774467f, -0.02836500f, 0.03401310f, -0.02002853f, 0.04917105f, 0.05840525f, -0.04053219f, -0.03098804f, 
    0.03224527f, -0.02113192f, -0.01108249f, -0.00553733f, 0.02190999f, 0.02443841f, 0.05268713f, -0.05525255f, 
    -0.01406353f, 0.00264274f, -0.05628486f, 0.03965173f, 0.04855652f, 0.05103530f, -0.01990607f, -0.00106654f, 
    -0.03804949f, -0.03467006f, -0.00324561f, 0.01640370f, -0.05657898f, -0.02671709f, 0.00231022f, -0.03666563f, 
    0.00187062f, 0.08127551f, -0.00934698f, -0.01230268f, 0.05670250f, -0.05140228f, 0.06396690f, -0.01530780f, 
    -0.04184581f, -0.02650972f, -0.13846423f, -0.19102840f, -0.15772527f, -0.18506199f, -0.06046385f, -0.01006614f, 
    0.04403315f, -0.03476531f, 0.05120144f, -0.12281136f, 0.06884135f, 0.01091226f, 0.01909429f, -0.08726474f, 
    -0.03405198f, 0.00441046f, 0.07332912f, -0.11413971f, -0.03480524f, 0.03826034f, 0.00692665f, -0.06124348f, 
    0.01637540f, -0.04677733f, -0.09191632f, -0.03895716f, -0.14144862f, 0.07389348f, -0.07911626f, -0.03124662f, 
    -0.18182957f, 0.06751222f, -0.16526243f, 0.10856888f, -0.04481502f, -0.05873297f, -0.05093509f, -0.00043774f, 
    -0.15674885f, -0.07920294f, -0.02713621f, -0.04666194f, -0.02890242f, 0.05617889f, 0.03319091f, -0.15464538f, 
    -0.30634215f, -0.13639180f, -0.02558834f, 0.07835101f, 0.05118331f, -0.10116057f, 0.07153885f, 0.00008329f, 
    0.32755080f, -0.05650393f, 0.04884855f, 0.02342784f, 0.09294034f, -0.01134520f, -0.10736366f, 0.02810476f, 
    0.19318150f, 0.06593068f, 0.01935231f, 0.22622940f, 0.08720583f, 0.00591390f, -0.00823897f, 0.06206919f, 
    0.05533811f, -0.05082483f, -0.10401326f, 0.02665359f, -0.17968169f, -0.08211123f, 0.04297646f, -0.02868027f, 
    -0.07289320f, -0.12700142f, -0.12219818f, 0.07387274f, -0.21797091f, -0.10701401f, -0.04314590f, 0.08102065f, 
    0.08612481f, 0.07553405f, -0.09062293f, 0.16502042f, 0.16305695f, 0.14239714f, 0.15964140f, 0.10818456f, 
    0.03266433f, 0.02874155f, 0.14495754f, 0.12593076f, 0.33523735f, 0.07230969f, 0.09756477f, -0.05948199f, 
    0.09999175f, -0.00239021f, -0.00789972f, -0.10954645f, 0.02779657f, -0.11721819f, -0.02567349f, -0.18442625f, 
    0.00561999f, -0.04528050f, -0.02136061f, -0.02946110f, 0.06049049f, -0.04861552f, 0.32162485f, 0.09869315f, 
    0.17789540f, -0.12149926f, 0.04096643f, -0.01396287f, 0.10052539f, 0.09686823f, -0.00037676f, 0.01810957f, 
    0.05504597f, 0.13443559f, 0.07136216f, 0.04707920f, 0.04649352f, -0.04934159f, 0.02196621f, -0.14845005f, 
    0.01918452f, 0.06257720f, -0.12211684f, -0.00894702f, -0.06473108f, -0.19338626f, -0.11652214f, 0.09295501f, 
    -0.02037084f, 0.12018818f, 0.19258377f, 0.27279595f, 0.13165754f, 0.06941302f, 0.09323252f, 0.02227760f, 
    0.08731832f, 0.02298277f, 0.07757618f, -0.22947946f, 0.07659616f, -0.12324559f, 0.12910531f, -0.04366312f, 
    -0.00115110f, 0.01292909f, 0.03331285f, 0.00095810f, 0.00761277f, -0.07383917f, -0.00471283f, -0.08116698f, 
    -0.11782886f, -0.03801395f, 0.00518792f, 0.03760984f, -0.19981097f, -0.05659989f, 0.23000041f, 0.14447445f, 
    0.01161458f, 0.01785004f, 0.10342985f, 0.01912759f, 0.00939923f, -0.08203550f, -0.20533378f, 0.05620460f, 
    0.01862079f, -0.07402856f, 0.06598536f, 0.00458356f, 0.03184886f, -0.09497019f, 0.17845172f, 0.11854839f, 
    0.12494352f, 0.02091617f, -0.01046779f, 0.01154138f, -0.10190163f, -0.04312628f, -0.04665801f, 0.07787938f, 
    -0.25409397f, 0.00140653f, -0.06711391f, -0.14656439f, 0.07323167f, -0.12057815f, -0.03229466f, -0.05660263f, 
    -0.06981537f, 0.01697884f, 0.07580017f, 0.00123507f, 0.12923349f, -0.03266928f, 0.05224925f, 0.00724912f, 
    -0.03182440f, 0.11904948f, -0.27606949f, 0.07595977f, 0.10202125f, -0.12311696f, 0.13126473f, 0.01312487f, 
    0.07844111f, -0.03085776f, -0.07158805f, -0.01269837f, -0.10407513f, -0.24927486f, -0.02811444f, -0.19135535f, 
    -0.04350434f, 0.01592877f, -0.04630843f, 0.22748499f, -0.06083821f, 0.06351843f, -0.11990912f, -0.02963897f, 
    -0.05280122f, 0.02945169f, -0.03704152f, 0.06528094f, 0.01885684f, 0.29682401f, -0.04959664f, 0.00955742f, 
    0.10498138f, -0.01559450f, 0.06490181f, 0.03971918f, 0.02565845f, 0.01994939f, -0.15784192f, 0.07838120f, 
    0.02289544f, -0.13546593f, -0.01548884f, 0.06318513f, -0.06151190f, 0.04283397f, 0.11876436f, 0.10581115f, 
    -0.08345289f, -0.13653113f, -0.09864964f, -0.01983864f, -0.07896692f, 0.00170633f, -0.08529831f, 0.09122634f, 
    0.11878619f, 0.23796229f, 0.01869325f, 0.02385816f, -0.03479810f, -0.10057765f, -0.00936413f, -0.00229803f, 
    0.03642960f, -0.09670673f, -0.19740951f, 0.21338420f, 0.07297406f, 0.03077250f, 0.02153188f, -0.04464627f, 
    -0.04657715f, 0.00870815f, 0.03024953f, -0.10627574f, -0.09538192f, 0.07344138f, 0.02781970f, 0.00465676f, 
    0.02745421f, 0.00763359f, 0.10881452f, 0.01190991f, -0.12157431f, 0.10087839f, -0.03554540f, 0.06045381f, 
    0.03495701f, -0.04879691f, -0.11894819f, -0.05091091f, -0.06166397f, 0.07294276f, 0.09753590f, -0.00240134f, 
    -0.02799568f, 0.01139680f, 0.05457173f, 0.03769314f, 0.05543904f, 0.11300240f, -0.12092680f, -0.10528322f, 
    -0.05623793f, 0.05452386f, -0.00879605f, -0.02212440f, -0.13655895f, -0.00271305f, 0.10202866f, 0.14973193f, 
    -0.12469722f, 0.01489601f, 0.02298136f, -0.09186272f, 0.03469002f, 0.00610407f, 0.40368676f, 0.05890495f, 
    -0.14591300f, 0.02445022f, 0.02108216f, -0.02826821f, 0.09205773f, -0.00833784f, 0.03657158f, -0.09279434f, 
    -0.18704908f, -0.01939120f, 0.12700410f, 0.10645861f, -0.03460138f, -0.04495457f, -0.02453773f, 0.01030475f, 
    0.22576809f, 0.02073231f, -0.15198834f, 0.02951572f, -0.03265032f, 0.08416074f, -0.01454156f, 0.00131323f, 
    0.07554425f, -0.10480892f, -0.03946333f, -0.02325032f, 0.04715189f, 0.07765197f, -0.14042205f, -0.03188379f, 
    -0.01620735f, 0.00865580f, 0.22809744f, -0.09786459f, -0.21006058f, -0.06659854f, -0.07526570f, 0.14802067f, 
    0.06697922f, 0.05149082f, 0.12348911f, 0.16028327f, -0.16534595f, -0.33710495f, 0.21663335f, 0.05890394f, 
    -0.06313212f, 0.01185289f, -0.03583904f, -0.09057925f, -0.18836981f, 0.10796709f, 0.13543811f, 0.08389576f, 
    0.06346691f, -0.06795159f, 0.12184760f, 0.06114747f, -0.07642798f, 0.02117769f, 0.03915426f, 0.17571782f, 
    -0.15704903f, -0.05699331f, 0.05402467f, -0.03438248f, 0.10060547f, 0.06051025f, 0.03474073f, -0.10686794f, 
    -0.12053168f, 0.04043602f, 0.06475580f, -0.09914295f, -0.12389313f, 0.02499352f, -0.04407318f, -0.15130618f, 
    0.09137156f, -0.03869262f, 0.16175590f, -0.02572465f, 0.06711999f, -0.01792460f, -0.11941677f, 0.02261170f, 
    -0.04280680f, -0.02164587f, -0.09261364f, -0.00809730f, -0.02704797f, 0.01160297f, -0.08828416f, 0.09292609f, 
    -0.02086948f, -0.15315148f, -0.08277494f, -0.29441780f, 0.10406404f, 0.13056800f, 0.07793863f, -0.05191595f, 
    0.03416540f, -0.01420895f, -0.01892038f, 0.03827922f, 0.05997202f, -0.20861614f, -0.08474287f, -0.05308735f, 
    0.12398966f, 0.08486059f, -0.06786954f, 0.12908764f, -0.17081429f, 0.19985293f, 0.08563000f, 0.05425155f, 
    -0.01487563f, 0.10955685f, 0.02098663f, -0.04881081f, -0.18116711f, -0.07923391f, 0.12795183f, -0.10095827f, 
    0.00055283f, -0.00063683f, 0.00594989f, -0.08947928f, -0.13741735f, 0.02234481f, -0.04073937f, 0.11811017f, 
    -0.04980962f, -0.09170355f, 0.01315646f, -0.02524304f, -0.02193314f, 0.03628128f, -0.15613100f, -0.09041204f, 
    -0.08922327f, 0.10352463f, -0.04205303f, -0.04847648f, -0.18253101f, 0.00520960f, -0.00347170f, -0.03353589f, 
    -0.00329425f, -0.05723043f, 0.00834073f, 0.04198740f, 0.06946632f, 0.00082334f, 0.09436592f, 0.14145342f, 
    -0.06675438f, -0.11650411f, -0.10705574f, -0.11463963f, -0.09121829f, 0.01179931f, 0.03948333f, 0.02388348f, 
    -0.06415258f, 0.53887904f, -0.31620929f, -0.03871339f, -0.20355654f, 0.02238750f, 0.00855398f, -0.13899581f, 
    0.00120967f, 0.00420195f, 0.06219291f, 0.12331873f, 0.14497603f, 0.02882620f, 0.04184682f, -0.02888269f, 
    -0.03742902f, 0.15612265f, 0.16627987f, -0.07130744f, 0.08118855f, 0.16279416f, 0.10617914f, -0.00423982f, 
    -0.01473802f, 0.07126412f, 0.06636962f, -0.06175050f, -0.19099511f, 0.04259640f, 0.15988545f, -0.04468256f, 
    0.05011585f, -0.04361399f, 0.00671962f, 0.10739769f, -0.02323326f, -0.18205602f, 0.07859956f, -0.04527117f, 
    -0.08413062f, 0.03822206f, -0.03816988f, 0.01190205f, 0.01309118f, -0.13931568f, 0.08314232f, 0.12532426f, 
    0.26131874f, 0.02892325f, 0.06290309f, 0.03475409f, 0.02898365f, 0.09350574f, 0.04701031f, 0.07105305f, 
    -0.16790397f, -0.20186201f, 0.09415258f, 0.04174238f, 0.02559836f, -0.03671303f, 0.03948679f, -0.18372409f, 
    0.00538130f, 0.01441846f, -0.03850187f, -0.02466406f, 0.03995534f, 0.03888906f, -0.06573752f, -0.00481862f, 
    -0.05101264f, -0.00210288f, 0.03826978f, 0.01404733f, -0.01807904f, 0.03216286f, -0.00899723f, 0.00032386f, 
    0.00338472f, -0.06572245f, -0.05022391f, -0.05947747f, 0.02033738f, -0.02046963f, -0.01743023f, -0.04935620f, 
    0.04030297f, -0.04288327f, -0.04572406f, -0.05606856f, 0.01808037f, -0.05289132f, 0.00339515f, -0.00027051f, 
    -0.01028172f, 0.01536684f, -0.01034869f, -0.00097319f, -0.01545240f, -0.04808843f, 0.01682146f, 0.04050136f, 
    0.03483700f, -0.06045863f, -0.03430320f, -0.01598533f, 0.03716941f, 0.05131510f, 0.04941050f, -0.02393784f, 
    -0.01269373f, 0.01973681f, 0.03751904f, -0.05912695f, 0.01208867f, -0.02502667f, 0.00321342f, 0.04294089f, 
    -0.03236443f, 0.03662595f, -0.02290210f, -0.02678019f, -0.04381198f, -0.03154182f, -0.04107624f, -0.05266483f, 
    -0.02065041f, 0.00581959f, 0.01949087f, -0.01070241f, -0.00904093f, -0.01191865f, 0.02578302f, -0.01853151f, 
    -0.04909969f, -0.02538363f, -0.00286221f, -0.04377908f, -0.02612895f, -0.04143004f, -0.00489871f, 0.00821816f, 
    -0.06670596f, 0.00152868f, -0.01691823f, -0.05432799f, -0.01246696f, -0.02704093f, -0.01545507f, 0.03881106f, 
    -0.06242419f, 0.00150008f, -0.04203506f, 0.04080103f, -0.04484503f, -0.05703005f, 0.03136733f, 0.02390729f, 
    -0.05094003f, -0.04120416f, 0.00308319f, 0.05028544f, 0.00056094f, -0.03580704f, 0.00078616f, -0.01262129f, 
    0.03516388f, -0.03985348f, -0.05223350f, 0.02049242f, 0.04302880f, 0.01602435f, -0.00555094f, -0.02929281f, 
    -0.03595978f, 0.04885080f, -0.01789394f, 0.01019873f, 0.01943626f, -0.06618208f, 0.03146084f, -0.00442073f, 
    0.01683046f, -0.05211658f, -0.04514560f, -0.05506184f, -0.01212801f, 0.02703318f, -0.01016524f, -0.00700609f, 
    -0.04882987f, 0.04065612f, -0.02456020f, 0.02955372f, 0.04275826f, 0.00524146f, -0.04907020f, -0.01704158f, 
    0.02305620f, -0.04855678f, 0.04395089f, -0.03858441f, -0.06016016f, -0.02698598f, 0.02142720f, -0.00604553f, 
    -0.06533112f, -0.01970092f, -0.03720642f, -0.05244109f, -0.03107557f, 0.01141611f, 0.01574306f, -0.05669080f, 
    -0.05717234f, 0.00166581f, 0.02765950f, -0.01417583f, 0.00593354f, 0.00261764f, -0.03836657f, 0.04045053f, 
    0.03677863f, -0.02301556f, -0.01162768f, 0.03441284f, -0.05461150f, 0.01370533f, 0.04124913f, -0.03816996f, 
    0.00149069f, -0.04481937f, -0.04386726f, 0.01712783f, -0.01804873f, -0.04657270f, 0.01346738f, 0.01745403f, 
    -0.02185511f, 0.02242115f, -0.00805702f, -0.05314526f, -0.05093549f, -0.03779247f, 0.05121376f, 0.01210045f, 
    -0.02138980f, -0.05589001f, -0.05159110f, -0.06323957f, -0.02422141f, -0.01738282f, -0.04919294f, 0.01397240f, 
    -0.06054609f, -0.03279246f, 0.03133474f, 0.00439191f, -0.05447656f, -0.06984540f, -0.02072877f, 0.00036859f, 
    -0.07017999f, -0.01602504f, 0.00947679f, -0.03380977f, -0.00672151f, -0.02325730f, 0.01561111f, -0.06608879f, 
    -0.01598685f, -0.00389685f, 0.00710510f, -0.00387234f, -0.02557840f, -0.02820848f, 0.02255995f, -0.05204870f, 
    0.00991494f, -0.04797361f, -0.03138267f, -0.05676943f, -0.06241888f, -0.03784708f, 0.01552904f, 0.04471078f, 
    0.03414423f, 0.02416454f, 0.01839241f, 0.01626180f, 0.04371972f, -0.00258400f, -0.06107113f, 0.04220332f, 
    -0.04933226f, -0.01043798f, -0.03038056f, -0.02800483f, -0.00517936f, 0.03189054f, -0.01702905f, 0.03684473f, 
    0.00235889f, 0.00843124f, 0.01099638f, 0.00780495f, 0.00137210f, 0.00911405f, -0.02563039f, 0.02714217f, 
    0.02856475f, 0.00836795f, 0.00823810f, 0.01770278f, -0.02767631f, -0.05910206f, -0.03765008f, 0.02046111f, 
    -0.02731098f, -0.05063727f, -0.05755530f, -0.06089158f, 0.03671457f, -0.01137903f, 0.01720450f, 0.00983296f, 
    0.01820378f, 0.01939189f, -0.05447528f, 0.02086034f, -0.03990864f, 0.02255503f, 0.00589710f, -0.06057287f, 
    -0.03783038f, 0.00794245f, 0.01835318f, -0.02425847f, 0.01023454f, 0.02840602f, -0.05046073f, -0.06265614f, 
    -0.06392144f, -0.03473654f, 0.05045849f, -0.05609998f, -0.04218422f, -0.02523635f, -0.03593088f, -0.00091771f, 
    0.06725921f, -0.08242904f, 0.07691790f, 0.06185932f, 0.07089981f, -0.02762109f, 0.02685189f, 0.09219930f, 
    -0.00729242f, 0.15764254f, -0.10222731f, -0.06497689f, -0.03836735f, 0.07915042f, -0.15170188f, -0.00567639f, 
    0.03873029f, -0.00906447f, 0.01525799f, -0.01457328f, 0.04629351f, 0.06667997f, -0.00057792f, 0.02010327f, 
    0.10161105f, 0.00741846f, 0.03397789f, 0.12996137f, 0.10724668f, 0.08049163f, 0.10474873f, 0.00395207f, 
    0.11234447f, 0.04869841f, 0.05495214f, -0.05892534f, -0.26543814f, 0.05696092f, -0.06758018f, -0.01782750f, 
    -0.06423251f, -0.01071171f, -0.06225822f, 0.01143849f, -0.08391427f, -0.04316526f, -0.10419291f, 0.09935384f, 
    -0.06694680f, -0.06527027f, -0.00805599f, 0.02706284f, 0.02700555f, 0.04231436f, -0.21282740f, -0.03176605f, 
    -0.20853415f, -0.13167553f, 0.02341579f, 0.03796276f, 0.00263057f, 0.08763371f, -0.07344590f, 0.14276269f, 
    -0.03704717f, -0.03183460f, -0.08666072f, 0.06460615f, 0.11348031f, -0.02753646f, 0.06880078f, -0.24915780f, 
    -0.06726918f, 0.02258997f, -0.00749187f, -0.03387741f, 0.02269281f, 0.03411309f, 0.12864652f, 0.07180382f, 
    0.00508869f, 0.16617961f, 0.01823114f, -0.06273589f, 0.03516481f, 0.06302833f, -0.06153809f, -0.05337398f, 
    0.10273248f, 0.04175558f, -0.19000188f, -0.13510266f, 0.04357472f, -0.04244176f, 0.08140981f, -0.04749765f, 
    -0.00306099f, 0.08796334f, -0.03249403f, 0.12143534f, -0.10753595f, 0.00560501f, 0.05232392f, 0.09965974f, 
    -0.04012378f, 0.02874989f, 0.12118964f, 0.06578349f, 0.02123520f, 0.07128304f, 0.13654841f, -0.06835362f, 
    -0.09902940f, 0.03430018f, 0.02531771f, 0.15124267f, 0.12131216f, -0.06227593f, -0.18463913f, -0.01544238f, 
    -0.01515620f, 0.04443493f, 0.07817023f, -0.00726028f, 0.00318636f, 0.01179951f, 0.11950488f, -0.03678360f, 
    0.00332606f, -0.05349435f, -0.07092965f, -0.12019709f, 0.00606631f, 0.06160256f, 0.00860345f, 0.07012111f, 
    -0.03108912f, 0.05711652f, -0.01026536f, 0.01690312f, -0.14170916f, 0.09217702f, -0.06121001f, 0.06316618f, 
    0.12309702f, -0.03999155f, 0.05388834f, 0.02285467f, 0.08569066f, -0.06505675f, 0.09333183f, 0.02629094f, 
    0.01229241f, -0.07131959f, 0.10966540f, 0.17373683f, 0.00625422f, 0.07167979f, -0.11969584f, -0.08768776f, 
    0.00968229f, 0.13192727f, -0.09133513f, -0.07151453f, -0.01809729f, -0.03990342f, -0.01429037f, 0.09101316f, 
    0.08595319f, -0.14316380f, -0.18573034f, -0.03369731f, -0.03540220f, 0.08474346f, 0.05831235f, 0.03340302f, 
    0.01779704f, -0.03788737f, -0.06078235f, -0.15106001f, 0.22193073f, -0.00140672f, 0.08403856f, -0.10619395f, 
    -0.17305392f, 0.10390874f, -0.05091073f, 0.13153604f, -0.04183456f, 0.14729126f, -0.11450655f, 0.15862577f, 
    -0.06038926f, 0.05643794f, -0.03461108f, -0.01876736f, -0.04167778f, 0.04698117f, 0.10939453f, 0.05612352f, 
    -0.02491735f, 0.02142928f, 0.02474048f, 0.04524883f, -0.00284331f, 0.18083961f, 0.09954141f, 0.17754753f, 
    0.10915247f, 0.07995602f, -0.00489168f, -0.08813988f, -0.19116327f, 0.01097764f, 0.01680210f, 0.15641910f, 
    -0.15694425f, 0.05977717f, -0.03609365f, 0.13121523f, -0.00991282f, -0.10249098f, -0.07785587f, 0.05636116f, 
    -0.16645251f, 0.21595638f, 0.10594074f, 0.09184147f, -0.05608317f, -0.12726691f, 0.09969004f, -0.04733483f, 
    0.01666348f, -0.19032307f, 0.11433030f, 0.00557799f, -0.10768849f, 0.00599105f, -0.03523184f, 0.05253419f, 
    0.02835802f, -0.02957975f, 0.00444795f, -0.22189862f, -0.11733817f, -0.11020046f, 0.05413169f, -0.04233302f, 
    0.22726023f, -0.06911192f, 0.01911470f, -0.07887628f, -0.15497035f, 0.05191104f, -0.05630517f, 0.04823510f, 
    -0.06093112f, 0.11487778f, -0.10873081f, -0.04209505f, -0.09112585f, 0.02017624f, 0.08997331f, -0.11385234f, 
    0.01411128f, 0.11666834f, -0.10370793f, 0.04063142f, 0.04337332f, -0.05966839f, -0.14557253f, -0.10912081f, 
    -0.03399024f, 0.10064349f, 0.07505136f, 0.03221137f, -0.10528501f, -0.03890951f, 0.01568037f, 0.05099094f, 
    0.01158916f, 0.10721686f, -0.08706053f, 0.00564411f, -0.03489267f, -0.00352669f, 0.04796864f, 0.07407034f, 
    0.04907071f, 0.12529878f, 0.08256870f, 0.03631917f, 0.01717670f, 0.01459376f, 0.06370448f, 0.01682422f, 
    0.04776620f, 0.17765656f, -0.14316498f, -0.03305097f, -0.12234602f, 0.04667507f, 0.06848040f, -0.07117470f, 
    0.05458109f, 0.06304552f, 0.11462483f, 0.10493597f, -0.11716665f, 0.01615361f, -0.00930508f, -0.00414259f, 
    0.04175474f, -0.07985700f, 0.10827585f, -0.09458297f, 0.04356633f, 0.01806716f, -0.06570120f, 0.08060396f, 
    0.13468586f, 0.01172405f, 0.07015706f, 0.03600100f, -0.23061979f, -0.17555621f, 0.03078217f, 0.05056284f, 
    0.09601291f, 0.03272614f, -0.02446003f, -0.02585558f, 0.07504075f, -0.12849577f, -0.03010202f, 0.15701519f, 
    0.00032703f, -0.07233458f, 0.08002578f, -0.13259928f, -0.12274149f, 0.03939833f, 0.04395011f, -0.05888752f, 
    -0.13909060f, 0.07649174f, 0.05437245f, -0.12515432f, -0.04430455f, 0.03331254f, 0.13719109f, -0.07637855f, 
    0.07941520f, -0.01194313f, 0.05019353f, 0.12123259f, 0.00627434f, 0.15320385f, -0.02653152f, 0.02180729f, 
    0.18894747f, 0.02131298f, -0.03332755f, 0.13818361f, 0.01581768f, -0.02645925f, 0.14406988f, 0.05257226f, 
    -0.01804342f, -0.02309381f, -0.11421180f, 0.09323800f, -0.04359821f, 0.02648978f, -0.08324440f, -0.01294053f, 
    0.07500157f, -0.14987241f, -0.09617637f, -0.19054969f, 0.00716825f, -0.02392425f, 0.08885648f, 0.18148898f, 
    0.09067065f, -0.06640847f, 0.06825525f, 0.09885922f, 0.18680535f, 0.06770565f, 0.02133426f, 0.02043912f, 
    0.08616549f, -0.05869242f, -0.06633136f, 0.09100188f, 0.12775384f, 0.12868240f, -0.03129120f, 0.05956307f, 
    -0.01298357f, 0.04548478f, 0.03443696f, 0.06939656f, -0.04367066f, 0.04281409f, 0.00850159f, -0.11429720f, 
    -0.14827293f, -0.01518289f, 0.03010927f, -0.10158270f, -0.02388013f, -0.06282373f, -0.09324104f, 0.06405055f, 
    -0.04357599f, -0.05897927f, -0.14140016f, 0.04133298f, 0.00651824f, 0.02095761f, -0.17436661f, 0.03966044f, 
    0.05545558f, -0.14336596f, 0.06643816f, 0.00213635f, 0.12423012f, 0.01578351f, 0.03629306f, -0.10133228f, 
    0.00762130f, 0.07745510f, -0.00570452f, -0.02148860f, -0.09031148f, 0.05674308f, -0.00758651f, -0.05798277f, 
    0.04344390f, -0.01023075f, 0.02882724f, 0.02807455f, 0.13043045f, -0.13535044f, 0.03434637f, -0.11548213f, 
    0.09451058f, -0.12406349f, -0.04421294f, 0.12529494f, -0.07986136f, -0.04740329f, 0.07982511f, -0.04935296f, 
    0.05091131f, 0.02098523f, -0.05067913f, -0.13795595f, 0.12444220f, 0.00905892f, 0.09565875f, 0.07713843f, 
    -0.05896618f, 0.03089101f, 0.08740687f, 0.12030801f, 0.09577862f, -0.06556468f, -0.04559593f, -0.05298240f, 
    -0.04653326f, 0.09373363f, -0.09814056f, 0.11274745f, -0.12341179f, -0.08979897f, -0.08817276f, -0.11908854f, 
    -0.00434534f, 0.02692229f, -0.05910808f, 0.00161090f, 0.02797664f, -0.05137089f, -0.05554982f, 0.02500829f, 
    -0.05820570f, -0.00745430f, 0.12728627f, -0.03541201f, -0.05997233f, 0.06708720f, -0.10875552f, 0.03268651f, 
    0.09878096f, 0.11055433f, -0.04133829f, 0.06191871f, -0.04997670f, -0.09718127f, 0.01766728f, 0.01807126f, 
    -0.36993417f, -0.10577585f, 0.01706145f, -0.03433442f, -0.06046689f, -0.02968312f, 0.09120522f, -0.02554904f, 
    0.09297226f, -0.01460403f, 0.06114921f, 0.03365786f, 0.05792764f, -0.15264837f, 0.01938139f, 0.04041855f, 
    -0.09788117f, 0.01227755f, 0.09040502f, -0.14623116f, -0.12647557f, -0.08057534f, 0.00294585f, -0.10567763f, 
    0.00789921f, 0.04218630f, -0.02078075f, -0.07227412f, 0.04793965f, -0.08770222f, 0.01194055f, 0.03555320f, 
    0.06738656f, 0.05334667f, -0.02660361f, 0.04920936f, 0.02151094f, 0.16814035f, -0.04178775f, -0.04680897f, 
    -0.13502628f, 0.20783570f, -0.06545585f, -0.02113996f, 0.00422367f, -0.14827013f, -0.03989929f, -0.01255776f, 
    -0.13013026f, 0.05783975f, -0.00049413f, 0.03552813f, 0.08075914f, 0.02159578f, 0.04500326f, -0.06679584f, 
    -0.07842987f, -0.11131649f, -0.05079515f, -0.05982285f, -0.05720950f, -0.04184958f, 0.09429590f, 0.12126684f, 
    0.17159997f, 0.12425505f, -0.08456676f, -0.03760849f, 0.03073143f, -0.05017829f, -0.00234212f, -0.10590436f, 
    -0.04915784f, 0.02250044f, 0.03676952f, 0.01183600f, -0.04168550f, 0.01229529f, -0.00218169f, -0.02209211f, 
    0.02997009f, -0.00557406f, 0.03253970f, -0.06432144f, -0.00599584f, -0.04779115f, -0.00178631f, -0.04202138f, 
    -0.05093566f, -0.06504979f, 0.04263647f, -0.05629344f, 0.04811107f, -0.02150458f, -0.02399980f, -0.04252449f, 
    -0.01206040f, -0.00625314f, 0.05105131f, 0.01146239f, 0.03321347f, 0.01277254f, 0.01015238f, -0.06289198f, 
    -0.06236277f, -0.00313435f, 0.04514480f, 0.05093432f, -0.04106478f, 0.02806648f, -0.02164453f, -0.03180628f, 
    -0.03197734f, -0.00248869f, 0.03677914f, 0.03195599f, -0.02396726f, 0.00057608f, -0.03840335f, -0.02331554f, 
    -0.00222023f, -0.01221828f, -0.05532337f, 0.05407150f, -0.03964289f, -0.05850809f, -0.05016368f, 0.04930627f, 
    -0.04726477f, 0.02029171f, 0.04088771f, 0.01110987f, 0.00183642f, -0.03183147f, 0.01809854f, -0.00459465f, 
    -0.02015924f, -0.02296215f, -0.06496476f, 0.05066240f, 0.02061138f, 0.04995257f, 0.01583661f, -0.01793114f, 
    0.01719152f, -0.03008568f, 0.04016142f, 0.03594166f, 0.01394093f, 0.03836795f, -0.03333981f, 0.03818193f, 
    0.01387219f, -0.01948274f, 0.03446047f, -0.02252300f, -0.02762273f, -0.05692673f, 0.03233095f, 0.01226344f, 
    0.03434523f, -0.04767029f, -0.05691685f, -0.01506414f, 0.01926392f, -0.04162015f, -0.05329757f, 0.00191564f, 
    -0.02313293f, -0.02339232f, 0.02199611f, -0.00063732f, 0.04883085f, -0.03846606f, -0.03434701f, -0.01669451f, 
    0.04504916f, -0.04745693f, -0.03611001f, 0.05162067f, 0.01142015f, 0.01032622f, -0.00639421f, -0.04013145f, 
    0.00309233f, 0.02993718f, 0.02581593f, -0.01894851f, -0.02900549f, 0.00156468f, 0.00625199f, -0.03286545f, 
    -0.02251887f, -0.05062917f, -0.00798620f, -0.04866776f, -0.00785774f, -0.02864474f, 0.00121421f, -0.03664077f, 
    -0.00299592f, 0.00302139f, -0.01160966f, -0.04134634f, 0.02307799f, -0.05440120f, -0.05690828f, -0.04149783f, 
    -0.05947009f, -0.05171753f, 0.02846264f, -0.06106179f, -0.04553756f, -0.01948068f, 0.00098376f, 0.04498494f, 
    0.00782132f, -0.04455355f, -0.05247094f, 0.02507071f, -0.01466498f, -0.05415106f, -0.03271728f, -0.01778074f, 
    -0.03336918f, 0.00023983f, -0.03523206f, 0.03873932f, 0.02930240f, -0.04395816f, -0.02711622f, -0.05450155f, 
    0.03580716f, -0.04130103f, -0.06447282f, -0.04984138f, -0.00261025f, -0.02970353f, -0.03886604f, -0.04794190f, 
    0.04090190f, -0.05773083f, 0.02691149f, -0.05458193f, -0.00351002f, -0.01837999f, -0.04497198f, -0.04505654f, 
    0.03322357f, 0.02324807f, 0.03672315f, 0.01521105f, -0.05413682f, -0.03060916f, 0.01991841f, -0.05135501f, 
    -0.03491910f, -0.05665629f, -0.00350987f, -0.06224907f, -0.04947523f, -0.02685634f, -0.03081274f, 0.00988750f, 
    0.04194386f, -0.00428904f, 0.03143630f, 0.00974957f, 0.00692719f, -0.00248642f, -0.00268286f, 0.00299282f, 
    0.00508089f, -0.05644757f, -0.01957424f, 0.03895109f, 0.03854728f, -0.02393860f, -0.00642043f, -0.03878992f, 
    0.00431416f, -0.06467687f, -0.05832194f, 0.01982520f, -0.01387251f, 0.04849997f, -0.03090172f, 0.00155055f, 
    0.05376120f, 0.00732640f, -0.04562891f, 0.03893520f, -0.01933252f, 0.02600482f, -0.01838776f, -0.06112396f, 
    0.03198479f, 0.01374866f, 0.03025894f, -0.03094951f, 0.05046204f, -0.06307146f, -0.03733336f, 0.01903813f, 
    -0.04187343f, 0.02491757f, -0.02541270f, -0.01134443f, -0.05752386f, 0.00538438f, -0.03786021f, 0.01164070f, 
    -0.01380450f, -0.05207196f, -0.05469835f, 0.02776092f, 0.01441305f, 0.04373582f, 0.00111768f, -0.01319921f, 
    0.00818927f, 0.04566425f, 0.00969701f, -0.03259374f, 0.04953161f, 0.01924966f, -0.00515247f, -0.04995930f, 
    0.04277569f, 0.00826024f, -0.05267086f, 0.00379073f, -0.00457782f, -0.02681633f, -0.05941090f, -0.06228852f, 
    -0.04767894f, -0.00297093f, 0.05163722f, 0.03682641f, -0.02705514f, -0.02107810f, 0.03697696f, -0.02808684f, 
    -0.01312968f, 0.00223878f, 0.03148414f, 0.02243492f, -0.02922060f, -0.00390200f, -0.00603252f, 0.00005287f, 
    0.00165438f, -0.00894678f, -0.00532616f, 0.04267316f, -0.00386997f, -0.00924035f, -0.03138059f, -0.03693291f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.00747684f, -0.05747997f, 0.10411172f, 0.03630701f, -0.00403296f, 0.01188919f, 0.04576008f, -0.01128230f, 
    0.02344847f, 0.07253964f, -0.05378519f, 0.03433182f, 0.03812404f, -0.02691231f, 0.10439721f, 0.05174172f, 
    0.05955259f, 0.17795238f, 0.01636235f, 0.04385554f, -0.02733347f, -0.14173998f, -0.01575615f, 0.16748542f, 
    -0.04587288f, 0.03859938f, -0.11405914f, 0.09256861f, -0.04537782f, 0.02889238f, 0.03526996f, 0.02937494f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.05426185f, -0.07298633f, -0.28111294f, -0.23447691f, 0.38877895f, 0.18318261f, -0.12175047f, -0.05821491f, 
    0.01516254f, -0.03104910f, 0.03011737f, 0.23344180f, -0.28546190f, 0.08169551f, -0.23349318f, -0.11946083f, 
    0.04739698f, 0.11568663f, 0.04102832f, 0.24302192f, -0.06550910f, 0.16950019f, -0.14061177f, 0.32106036f, 
    -0.01342519f, -0.16688173f, -0.27702400f, 0.06569732f, 0.07530768f, -0.06727915f, 0.09621766f, -0.05806080f, 
    0.12277002f, -0.00268196f, -0.01863026f, -0.16153736f, 0.13255347f, 0.08700418f, 0.13186666f, -0.14760712f, 
    -0.02767465f, -0.08521837f, 0.01813648f, -0.01306274f, -0.05424242f, -0.04050991f, -0.12156016f, -0.09174970f, 
    -0.07387637f, 0.06664311f, -0.10408570f, -0.10186979f, 0.11567128f, -0.15005758f, -0.04660205f, -0.05255282f, 
    0.09165647f, 0.12013436f, 0.12923956f, -0.04498315f, -0.08937843f, -0.17547369f, -0.04287755f, 0.06542607f, 
    0.08380372f, 0.11072786f, 0.20686637f, 0.11783885f, 0.25156331f, 0.10410074f, -0.04100718f, -0.03067062f, 
    0.17741720f, 0.26923695f, 0.06311462f, -0.06267814f, -0.09807267f, 0.04807602f, 0.37518549f, 0.21940646f, 
    -0.16106373f, 0.01551816f, -0.28041840f, 0.17789698f, 0.06682757f, -0.44824630f, -0.08140057f, -0.19828191f, 
    0.12809178f, -0.10753261f, -0.28230730f, -0.01075334f, -0.06228842f, 0.38876018f, 0.02292055f, -0.06151253f, 
    -0.04890623f, -0.11837064f, -0.43865478f, 0.09320054f, -0.03542863f, -0.17983796f, -0.05068104f, 0.23342369f, 
    0.44917491f, -0.06318530f, 0.17382811f, -0.14277570f, 0.41629806f, -0.03519787f, 0.14539227f, -0.00060032f, 
    -0.20587537f, -0.13984683f, 0.01640984f, -0.08607149f, 0.04520826f, 0.51282966f, 0.17474680f, 0.32848558f, 
    -0.13036051f, 0.04613394f, 0.24000813f, -0.01798841f, 0.00307609f, 0.03423837f, 0.16966555f, 0.12579203f, 
    -0.08630671f, -0.09377286f, -0.07907877f, -0.08484584f, -0.22505818f, -0.19825919f, -0.06415088f, 0.16278508f, 
    0.44734544f, -0.00168729f, -0.04036193f, -0.08433582f, -0.14496715f, -0.04303046f, -0.24405000f, 0.12777121f, 
    -0.13755836f, -0.08350637f, 0.08136833f, 0.04825953f, -0.02285493f, 0.12992944f, -0.05822304f, -0.05785328f, 
    -0.16014993f, 0.01017610f, 0.58400512f, 0.08286139f, 0.16465327f, 0.00984380f, 0.24768946f, -0.01226012f, 
    0.14332959f, 0.09758242f, -0.17509337f, -0.30926248f, 0.02034844f, 0.05924957f, -0.04122756f, -0.30527851f, 
    0.11959480f, -0.10247937f, 0.05567956f, 0.22460061f, -0.26346242f, -0.00081799f, -0.25179505f, -0.17055143f, 
    0.33492389f, 0.29899168f, 0.08462979f, 0.05272134f, -0.12851006f, 0.02401983f, 0.14470465f, -0.06584738f, 
    0.12430563f, -0.06899679f, 0.07590064f, 0.31455758f, 0.04607903f, 0.09628176f, -0.06968539f, 0.13453518f, 
    -0.00797501f, 0.04493792f, -0.10013092f, 0.02531372f, 0.28268707f, 0.05503346f, 0.04202134f, -0.25588739f, 
    0.00043105f, 0.38590783f, -0.14951183f, 0.20493516f, -0.11872616f, -0.00719235f, 0.18765987f, -0.09924334f, 
    0.19269748f, 0.03107884f, -0.14032516f, 0.18465610f, 0.05325219f, -0.11463697f, 0.01280676f, 0.01516330f, 
    -0.04813072f, 0.02585894f, -0.33442807f, 0.30840331f, 0.03982329f, 0.21639727f, -0.23283918f, -0.03024898f, 
    0.10721239f, 0.10116764f, 0.23726252f, 0.05864794f, -0.19355136f, -0.16006942f, 0.09268484f, 0.11013367f, 
    -0.26435813f, 0.25172046f, 0.15278752f, -0.17851199f, 0.12420377f, 0.05546935f, -0.06485274f, -0.03447771f, 
    0.32976148f, 0.01517632f, -0.05734334f, -0.11958118f, 0.11412360f, 0.34769276f, 0.32141095f, 0.29754397f, 
    0.12769938f, 0.02413243f, -0.44913921f, 0.07720252f, 0.08783370f, -0.03013598f, 0.11117628f, -0.02036882f, 
    -0.16442366f, -0.13508849f, -0.25628951f, -0.03294136f, 0.37874144f, -0.09186636f, 0.12037729f, -0.14897995f, 
    0.19164149f, 0.31120652f, 0.09814215f, 0.02171398f, 0.19657956f, -0.15740728f, -0.22852948f, 0.03956658f, 
    0.12064566f, 0.08399439f, -0.23706403f, 0.19541554f, 0.11772493f, -0.10661381f, -0.21899624f, -0.06160411f, 
    -0.16709462f, 0.12003005f, 0.14549378f, 0.27106023f, 0.03349497f, -0.04774647f, -0.13960949f, -0.11552622f, 
    0.09405168f, -0.11229113f, 0.38724482f, -0.05061643f, 0.25291517f, 0.46698532f, 0.01965297f, 0.26141858f, 
    -0.09707898f, 0.11957464f, 0.17953213f, -0.14944047f, -0.19356380f, -0.05138609f, -0.10402451f, -0.03528588f, 
    -0.16869083f, 0.05125344f, 0.21058156f, 0.22356741f, 0.14195471f, -0.11583713f, 0.11510983f, -0.16828355f, 
    0.03754772f, 0.13573341f, 0.10373633f, -0.27759591f, -0.14875285f, 0.10046232f, 0.06454477f, -0.15884590f, 
    -0.04010114f, -0.04364653f, -0.37028831f, 0.10864363f, 0.10378659f, -0.09428970f, 0.13804528f, -0.05501876f, 
    0.25904262f, 0.00095354f, 0.12939921f, -0.32187575f, 0.16837387f, -0.07124551f, 0.20357332f, 0.12723240f, 
    0.19345392f, 0.26137108f, -0.38797575f, 0.38879102f, -0.04337575f, -0.07991159f, -0.00707267f, -0.22022714f, 
    -0.16116938f, -0.11529295f, -0.23094110f, -0.18856201f, 0.06222145f, 0.31210822f, -0.16988871f, -0.06656291f, 
    0.01396860f, -0.05033161f, -0.25625348f, 0.12349180f, -0.03430420f, -0.08899065f, 0.14568147f, 0.21072875f, 
    -0.05087642f, -0.14992578f, -0.03125208f, -0.05606437f, 0.23446481f, 0.10895280f, -0.14367384f, -0.22564155f, 
    0.09547991f, 0.26051691f, 0.08787137f, -0.08012962f, 0.08133219f, 0.28320563f, -0.12258843f, 0.29235700f, 
    -0.00969797f, 0.15720651f, 0.47344461f, 0.04620814f, -0.04539638f, 0.06064352f, 0.08623260f, -0.14639071f, 
    -0.10883663f, 0.13286528f, 0.08942624f, 0.04206963f, -0.18668595f, 0.01178035f, 0.15980881f, -0.26101384f, 
    -0.03429517f, -0.17315415f, 0.10471410f, 0.30161974f, -0.25385833f, 0.04178419f, 0.25278819f, 0.09904832f, 
    -0.08180753f, 0.15180509f, 0.07525154f, -0.12524870f, 0.10078054f, -0.30114368f, 0.26275843f, 0.07991236f, 
    0.05515416f, -0.08350123f, -0.08946271f, -0.17521462f, 0.09199049f, -0.05840411f, 0.27644271f, -0.08328220f, 
    -0.07798372f, 0.16254194f, -0.20189068f, -0.42052442f, -0.13333027f, 0.06832273f, 0.07015603f, -0.09656550f, 
    0.23725358f, -0.09485696f, 0.02162229f, 0.01777647f, -0.19022234f, 0.09329746f, -0.11929763f, -0.10754568f, 
    0.25578830f, 0.30815777f, 0.34669468f, 0.06491189f, 0.11189119f, -0.01034023f, 0.21109007f, 0.28639534f, 
    -0.14560692f, 0.16899510f, -0.15463501f, 0.26693380f, 0.10974406f, -0.18964638f, 0.07608836f, 0.16405755f, 
    -0.16288878f, 0.07103536f, 0.09383368f, 0.03529007f, 0.02447145f, 0.10735738f, 0.06848661f, 0.04698288f, 
    0.29977387f, -0.00756741f, 0.05995401f, -0.04054953f, -0.21142890f, 0.03557023f, 0.15758292f, 0.03435281f, 
    -0.35077238f, 0.08897322f, -0.16556081f, 0.16105115f, -0.12523547f, 0.31088269f, -0.01942851f, -0.05073527f, 
    0.03874165f, -0.01509877f, -0.11860805f, -0.19459186f, 0.03724707f, 0.14412501f, 0.29324436f, 0.11275827f, 
    -0.06332410f, -0.09262727f, 0.32308912f, 0.14277530f, -0.07607478f, 0.27559766f, -0.16526784f, 0.21655224f, 
    0.26172951f, -0.27597553f, 0.03429645f, 0.10974371f, -0.23596017f, 0.01533045f, 0.13201334f, 0.28961882f, 
    -0.35643479f, -0.14472444f, -0.10501276f, 0.03918975f, -0.09957378f, -0.05487174f, 0.33118176f, 0.15919815f, 
    0.13671897f, 0.17173770f, 0.22083846f, -0.13761112f, -0.00827278f, 0.17629911f, 0.33735558f, 0.02095828f, 
    -0.16120476f, 0.17559959f, 0.24165909f, 0.22917013f, -0.29645884f, 0.20356862f, -0.15686481f, -0.04256869f, 
    0.35533950f, -0.01350713f, 0.12547228f, -0.31004500f, 0.23442717f, -0.03069144f, 0.13101792f, 0.07586674f, 
    -0.02075922f, 0.10624417f, -0.18604963f, 0.29278284f, -0.15261091f, -0.39442143f, 0.10958689f, 0.16482674f, 
    -0.13856719f, 0.12143669f, -0.47320759f, 0.16737261f, -0.08248425f, 0.26916802f, -0.00680797f, 0.17358495f, 
    -0.01235752f, -0.01539292f, 0.21528469f, -0.23174331f, 0.24410021f, -0.13387038f, -0.01152082f, 0.12941949f, 
    0.15471025f, 0.42732257f, -0.09094990f, 0.18039574f, -0.13486788f, 0.12591308f, 0.38554540f, 0.32205191f, 
    -0.14923389f, -0.28346696f, -0.20399891f, -0.01244803f, 0.02549694f, -0.23743121f, -0.12532236f, 0.18721217f, 
    0.15463455f, 0.05949075f, 0.25396627f, -0.19099474f, 0.17730689f, 0.23667216f, 0.15326358f, -0.13529709f, 
    0.01779965f, 0.15193166f, 0.12972759f, 0.07204887f, 0.33515731f, 0.22910720f, 0.16564631f, 0.27282646f, 
    0.08044796f, 0.03313758f, 0.11941724f, 0.25882196f, -0.26136169f, -0.05887552f, -0.25014406f, -0.19471683f, 
    0.07712255f, 0.19947046f, -0.12910601f, 0.23267266f, 0.09495331f, 0.39129785f, -0.18733080f, -0.17147648f, 
    0.10904051f, 0.03660079f, 0.36745688f, -0.09542669f, 0.10024324f, 0.28020006f, 0.07755406f, -0.12092030f, 
    -0.02488419f, 0.00123349f, -0.04544108f, 0.05543937f, -0.20203733f, 0.11494976f, -0.11948825f, -0.23464087f, 
    0.03092832f, 0.09517825f, 0.13140106f, -0.00374829f, 0.18402961f, 0.03936283f, -0.11910193f, -0.19070588f, 
    0.32881233f, 0.17517783f, -0.04675925f, 0.18952677f, 0.09201435f, -0.28850657f, 0.11300428f, 0.15074937f, 
    -0.03543472f, 0.01846153f, -0.32679126f, 0.32055983f, -0.03588682f, 0.05158805f, -0.20516054f, 0.00962038f, 
    0.08124776f, 0.07003372f, 0.49924517f, 0.24840319f, -0.02270779f, 0.18388544f, -0.14477524f, 0.02076799f, 
    -0.30933228f, 0.05421616f, -0.15044253f, 0.09472679f, -0.00471878f, -0.09103059f, 0.12574652f, 0.18122624f, 
    -0.10713472f, -0.14701523f, 0.15850224f, -0.05158868f, -0.07167092f, -0.40741381f, 0.04539007f, 0.22634293f, 
    -0.10889289f, -0.14681032f, 0.03670760f, -0.24898253f, -0.05543349f, 0.25170135f, 0.23077644f, 0.06814184f, 
    0.09073643f, 0.06064209f, -0.28784859f, -0.27935916f, -0.07442759f, 0.12714827f, -0.14709872f, -0.18597628f, 
    0.12616943f, 0.09056665f, -0.02104240f, 0.33862510f, -0.31506571f, 0.11999764f, 0.14930497f, 0.15968522f, 
    0.05631635f, 0.39433405f, -0.01629166f, 0.02131273f, -0.07443430f, 0.01743681f, -0.10373376f, -0.16390477f, 
    -0.03022441f, -0.04806884f, 0.44182950f, 0.28686467f, 0.11518838f, 0.01630347f, 0.24891277f, -0.15683167f, 
    0.14322272f, 0.15414439f, 0.17177050f, -0.15563148f, 0.36762562f, 0.38938913f, 0.07216465f, 0.33456764f, 
    -0.12592398f, -0.18708451f, 0.01522550f, 0.20771752f, -0.13892095f, -0.02946283f, 0.27597076f, 0.05581084f, 
    -0.25392130f, 0.10886709f, -0.06208745f, 0.20563558f, 0.13297343f, 0.32675940f, -0.27507785f, -0.02936460f, 
    0.19354449f, 0.12022537f, -0.05118080f, 0.16660775f, -0.13412681f, 0.22118963f, 0.13791117f, -0.17123938f, 
    0.10993209f, -0.07981420f, 0.05936629f, 0.11417189f, 0.35778755f, 0.35653055f, -0.07115359f, 0.19834338f, 
    -0.13436832f, -0.03639472f, -0.13527752f, -0.02773239f, -0.00796792f, -0.12743948f, 0.14380121f, 0.03629557f, 
    -0.08761691f, -0.08179195f, 0.09876616f, 0.16629674f, 0.10301144f, 0.37277910f, -0.04508892f, 0.05407347f, 
    0.03414227f, -0.06650218f, -0.03662603f, -0.31488311f, -0.10981001f, 0.01895856f, -0.01285648f, 0.16949628f, 
    0.11112143f, -0.11090597f, -0.07885274f, 0.05873006f, -0.29406473f, 0.06142470f, -0.07968453f, 0.13427214f, 
    -0.00158201f, -0.06659546f, 0.16805878f, -0.22097847f, 0.34797820f, -0.13747559f, -0.24324405f, 0.20386298f, 
    0.00268680f, 0.25044540f, 0.36630669f, -0.15039305f, 0.10238105f, -0.10551044f, 0.27381700f, 0.26145250f, 
    -0.07154325f, 0.16485050f, -0.03469241f, -0.20949651f, 0.09121476f, -0.18496175f, -0.07354494f, 0.14531693f, 
    -0.11721763f, 0.00192525f, -0.13706310f, 0.00601117f, -0.10295252f, 0.12033506f, -0.05626168f, 0.07513054f, 
    -0.09072729f, -0.00753715f, -0.08020271f, 0.03085712f, -0.03515154f, 0.16634138f, 0.01222140f, 0.00866019f, 
    -0.10841543f, -0.14296640f, -0.03845794f, -0.02660622f, 0.06646413f, -0.10480388f, -0.15599033f, -0.15014827f, 
    -0.04905815f, -0.13048364f, -0.18459634f, 0.06409704f, -0.16929393f, -0.13134998f, 0.11812156f, 0.17186658f, 
    0.01258739f, -0.10084639f, 0.15915352f, -0.02515693f, -0.17721772f, 0.02729837f, -0.10532800f, 0.14254557f, 
    0.22156702f, -0.39895380f, 0.13913149f, -0.20132053f, 0.12101417f, -0.00135781f, 0.09865338f, -0.10351891f, 
    0.00672740f, 0.19881020f, -0.17073134f, -0.00893029f, 0.10965691f, -0.12816653f, 0.35075486f, 0.09419650f, 
    -0.14231625f, -0.15487713f, 0.32800001f, -0.25289875f, -0.03701226f, -0.03236901f, 0.35929975f, 0.15341672f, 
    -0.08991594f, 0.15532309f, 0.23806550f, 0.23522606f, 0.07577732f, 0.12325960f, -0.02195755f, 0.11871615f, 
    0.13495238f, 0.03288801f, 0.02339284f, 0.26695317f, -0.01908107f, 0.00911203f, -0.27723643f, -0.12952086f, 
    0.28290650f, 0.03617994f, 0.30512875f, 0.26644027f, -0.13230327f, -0.20857307f, -0.24611670f, 0.26630720f, 
    -0.15064435f, -0.17050192f, -0.49063480f, 0.32308784f, -0.03138676f, -0.11074888f, 0.07055988f, 0.07640304f, 
    0.01002357f, 0.11855097f, -0.15449281f, -0.00956940f, -0.06677353f, -0.14325562f, -0.17304005f, -0.12017993f, 
    -0.08660943f, -0.00267717f, 0.02780180f, -0.07741792f, 0.15341054f, 0.06921239f, -0.00864830f, -0.17743476f, 
    -0.02509988f, -0.11928760f, -0.00401212f, -0.08460545f, 0.07778024f, 0.05217608f, 0.08360011f, -0.12465402f, 
    0.02320676f, 0.11782744f, 0.08258595f, 0.01761332f, 0.06871926f, -0.00516010f, -0.18168077f, -0.02282212f, 
    -0.08461199f, 0.02556867f, -0.02064235f, -0.13050140f, 0.03169179f, 0.32539833f, -0.11409408f, 0.04425869f, 
    -0.23195747f, 0.04033956f, 0.05550566f, -0.00025958f, -0.12239303f, 0.01049339f, -0.23208971f, 0.20239651f, 
    0.06869661f, 0.09862681f, 0.25269666f, 0.23402251f, -0.05031301f, -0.45321363f, -0.20880666f, 0.18286410f, 
    0.16350088f, 0.02527228f, 0.44094402f, -0.30705473f, 0.13120078f, -0.14051327f, 0.15980604f, 0.01426809f, 
    0.07314491f, -0.13701026f, -0.34619451f, -0.22788662f, 0.14417788f, 0.09311468f, 0.04294787f, 0.24846430f, 
    0.27766553f, 0.14713153f, -0.10529419f, -0.08243047f, 0.13590749f, 0.00590765f, 0.07706522f, -0.10447665f, 
    -0.26284081f, 0.11878811f, -0.28941667f, 0.05996977f, -0.17430100f, 0.56863767f, 0.03846652f, -0.03641168f, 
    0.04145236f, -0.02443190f, 0.09154794f, 0.14215733f, 0.05871083f, 0.25836828f, 0.19168645f, -0.04635601f, 
    -0.06276684f, -0.03119039f, -0.06984296f, 0.01751597f, -0.01183294f, 0.21507642f, -0.07848833f, 0.13438222f, 
    0.17394117f, 0.13213374f, -0.03754622f, -0.17711200f, -0.10486196f, 0.06527674f, 0.28667074f, 0.21688543f, 
    0.13059212f, 0.06497080f, -0.31912115f, 0.27237093f, 0.09052258f, -0.35703135f, -0.12004495f, -0.05840675f, 
    -0.13551801f, 0.11879538f, -0.04634057f, -0.22687791f, 0.17977020f, 0.41470829f, 0.17015445f, 0.07831036f, 
    0.06704143f, -0.08706348f, 0.34409326f, -0.24834524f, -0.25748280f, 0.16502637f, -0.06514178f, 0.57879668f, 
    -0.26750430f, 0.21676977f, -0.13935044f, -0.20023292f, -0.02253704f, 0.07527620f, 0.41194171f, -0.02398031f, 
    0.08848906f, 0.09950434f, 0.30201247f, 0.11305940f, 0.06818471f, 0.00056725f, 0.03766670f, 0.17446905f, 
    -0.11432111f, 0.00827319f, -0.54420775f, -0.31202230f, -0.02313495f, 0.31453729f, -0.10953365f, 0.12283412f, 
    -0.03372176f, -0.10152458f, 0.09796743f, 0.24080367f, 0.18438575f, 0.40380210f, 0.11290314f, 0.17573619f, 
    0.22011843f, -0.43148938f, -0.12890163f, 0.00242813f, -0.11061709f, 0.07935453f, -0.35041210f, 0.00725733f, 
    -0.14554025f, 0.01375397f, 0.20552918f, 0.05362752f, 0.05770111f, 0.37518886f, 0.10848262f, 0.05797704f, 
    0.07999093f, 0.11091648f, -0.12118556f, -0.02715631f, -0.15762241f, 0.08758435f, 0.39360610f, -0.17333545f, 
    0.04571205f, -0.05102541f, -0.02202002f, 0.25852990f, -0.00541688f, -0.17908140f, 0.05419489f, -0.03211765f, 
    0.01954312f, -0.00034256f, 0.14665532f, -0.15490220f, 0.40558439f, 0.01432025f, -0.23378350f, 0.07997546f, 
    0.39443502f, -0.09128783f, -0.00478093f, 0.17180236f, 0.10900436f, 0.09172583f, -0.06724237f, 0.33383206f, 
    -0.09225672f, -0.15152700f, -0.41786018f, 0.23776495f, 0.16099545f, -0.08576513f, -0.06002721f, -0.07943172f, 
    -0.01425836f, -0.03645847f, 0.05501162f, 0.07146420f, -0.18671231f, -0.15911646f, -0.08382790f, 0.11217709f, 
    -0.19516037f, -0.11687185f, 0.15610059f, -0.15079990f, -0.14635104f, 0.08721223f, 0.07264409f, -0.19736716f, 
    -0.04725009f, -0.10024489f, -0.09832934f, -0.03476394f, 0.13607724f, -0.22011752f, -0.00381025f, 0.11346564f, 
    0.09673553f, -0.03056388f, 0.12775241f, 0.10347378f, 0.00781371f, -0.09770007f, 0.13012476f, 0.16986573f, 
    0.02855417f, -0.13526228f, 0.22907902f, -0.13592188f, -0.17015304f, 0.42112809f, 0.10125244f, -0.02212027f, 
    -0.15936798f, -0.09507757f, 0.14290325f, -0.08381835f, -0.07313690f, -0.11832675f, -0.01654107f, 0.16091272f, 
    0.07040909f, 0.02176796f, 0.41079393f, -0.16562419f, -0.08990218f, -0.07113146f, 0.33235750f, 0.30948323f, 
    0.02250074f, -0.01448022f, 0.01889100f, -0.03955549f, 0.13077781f, -0.30363655f, 0.00780325f, -0.09331883f, 
    0.06155022f, -0.16500279f, 0.03595711f, 0.36548376f, 0.22674938f, -0.19561905f, -0.06451251f, -0.03801631f, 
    0.18722151f, 0.35719067f, -0.13059705f, 0.05510743f, 0.35126352f, -0.05568577f, -0.16465741f, 0.27113003f, 
    -0.12705068f, -0.15021601f, -0.11558244f, -0.02113238f, -0.05739405f, -0.31326637f, 0.01535257f, 0.11041643f, 
    0.11708180f, -0.14165881f, -0.50585788f, 0.14670528f, -0.12571324f, 0.16190307f, -0.22086324f, 0.13628557f, 
    -0.03754121f, 0.09135740f, 0.32259867f, -0.16393484f, 0.00586649f, 0.07999459f, -0.16860765f, -0.06784758f, 
    0.21891554f, 0.16473451f, -0.01207086f, 0.53270251f, -0.33192545f, 0.13773982f, -0.12537505f, 0.07299561f, 
    -0.22632262f, -0.26033515f, 0.01744275f, 0.11947457f, -0.15933289f, 0.27094638f, 0.31213596f, 0.17479405f, 
    -0.09546471f, 0.13232911f, 0.34655526f, 0.15529835f, 0.14342833f, -0.19254553f, 0.34699082f, -0.02832097f, 
    0.07400967f, 0.13908972f, -0.01574103f, -0.24671306f, -0.30061007f, -0.20294450f, 0.10199370f, -0.28220844f, 
    0.23969647f, 0.24435051f, -0.01056327f, 0.21621305f, -0.21237348f, 0.14768064f, -0.00435849f, -0.14812058f, 
    0.20337063f, 0.20375752f, 0.11726252f, -0.25288865f, -0.12159367f, 0.39049542f, 0.25177076f, 0.14448754f, 
    -0.14210989f, -0.12095066f, 0.25436819f, 0.30569756f, 0.11336351f, -0.09278494f, 0.21906610f, -0.07542441f, 
    -0.15748243f, 0.08489653f, -0.03116084f, -0.22719835f, 0.40078893f, 0.20569491f, 0.13843969f, -0.18971661f, 
    -0.31011692f, 0.21336333f, 0.00511276f, 0.05396445f, -0.16490486f, 0.06959306f, 0.01011398f, 0.00744432f, 
    0.16756883f, 0.22094546f, 0.02964184f, 0.12996525f, -0.11884194f, -0.02513631f, -0.33100086f, 0.11314279f, 
    0.08833894f, 0.00349257f, -0.21589954f, 0.18780442f, -0.12144522f, 0.20446415f, 0.02193322f, -0.16666146f, 
    -0.12043811f, 0.10774395f, -0.24096097f, -0.17592898f, 0.14790925f, 0.22519077f, 0.14422576f, -0.13596122f, 
    0.15617822f, -0.00144241f, -0.02745906f, 0.51196456f, -0.09211233f, 0.11658996f, -0.05101284f, 0.14164953f, 
    0.04673385f, -0.22508065f, -0.06026783f, 0.04223976f, 0.14556529f, -0.11799797f, -0.02758009f, 0.34299344f, 
    -0.04386717f, -0.04759323f, 0.16937520f, 0.40312228f, 0.17418997f, -0.13562025f, 0.02544810f, 0.07435618f, 
    -0.09503556f, -0.01402578f, -0.01214879f, -0.10275072f, 0.05658325f, -0.06494211f, 0.04007394f, -0.10642853f, 
    0.03955966f, 0.18905897f, -0.00416951f, -0.20128505f, 0.35817429f, -0.14208537f, 0.14258006f, 0.28768712f, 
    0.22919777f, 0.17240898f, -0.14189547f, 0.26579568f, -0.10368119f, -0.54313028f, -0.14832328f, -0.05651832f, 
    0.04556709f, -0.00410472f, -0.12631145f, 0.11146788f, 0.02840928f, 0.12926057f, -0.21704869f, -0.06830750f, 
    0.01900646f, 0.15479751f, 0.14344035f, -0.22275478f, -0.26463053f, 0.14246185f, 0.14043373f, 0.33135462f, 
    -0.04490007f, -0.19009368f, -0.10252533f, -0.07187167f, -0.08351742f, -0.03830472f, 0.26004985f, -0.10119688f, 
    -0.02714322f, 0.35607433f, 0.24824317f, 0.11411113f, 0.11301638f, 0.14022318f, 0.23691675f, -0.09632976f, 
    0.02890390f, -0.04999451f, 0.42263103f, -0.26074430f, 0.05069849f, 0.07963350f, 0.17383164f, -0.13022321f, 
    0.15077457f, -0.14630798f, 0.13290384f, -0.03315947f, 0.03618266f, 0.15170750f, 0.05458612f, -0.02873382f, 
    0.05012729f, -0.12662877f, 0.05042779f, 0.33226031f, -0.11962741f, -0.13430466f, -0.05612900f, -0.07839112f, 
    0.20962335f, -0.15789898f, 0.09519878f, 0.11273245f, -0.11517019f, -0.21166807f, -0.22789484f, -0.12062121f, 
    0.07405465f, -0.08583952f, 0.62696099f, 0.19201528f, 0.08811831f, 0.22075409f, 0.14638762f, -0.15253288f, 
    0.02505011f, 0.12387931f, 0.05515624f, 0.09530719f, -0.06572448f, 0.06862225f, -0.15212105f, -0.14263925f, 
    -0.14555040f, -0.12761468f, 0.06539886f, -0.05769407f, 0.01495914f, 0.03936302f, -0.07456213f, 0.09877734f, 
    -0.04815813f, -0.09043515f, -0.02594341f, -0.07313666f, 0.07987335f, -0.13925998f, -0.00491438f, -0.05193854f, 
    -0.06220859f, -0.12710361f, 0.10022205f, 0.02414385f, 0.01717853f, 0.07355817f, -0.19405630f, 0.03146906f, 
    0.16849245f, 0.05061940f, -0.18966267f, 0.30640501f, 0.33722439f, 0.12514368f, -0.02457394f, -0.09901050f, 
    0.04078719f, 0.26095471f, -0.03942265f, 0.03360647f, 0.25627556f, -0.09579111f, -0.35199621f, -0.10891522f, 
    -0.00420557f, 0.05302445f, 0.14638859f, 0.06948604f, -0.13362820f, 0.42507523f, -0.22704177f, 0.32808775f, 
    -0.18066271f, -0.07560725f, 0.02289826f, -0.13500507f, -0.08348522f, -0.06546853f, -0.17376365f, 0.09699463f, 
    -0.10301457f, 0.01744614f, -0.04451947f, -0.16728732f, 0.03482945f, 0.14938109f, 0.01673620f, 0.24046482f, 
    0.33021498f, -0.14591730f, 0.10987412f, 0.30848411f, -0.18449658f, 0.04190742f, 0.35398123f, 0.19983298f, 
    -0.37037662f, -0.12031165f, -0.14019361f, -0.02054682f, 0.02467961f, 0.07601627f, 0.05392182f, -0.05019412f, 
    -0.07249784f, -0.14421630f, 0.04509414f, 0.17882660f, -0.15378322f, 0.23022987f, 0.39782599f, -0.07544283f, 
    -0.02514865f, -0.10644970f, 0.02470485f, -0.08268153f, 0.10587340f, 0.03847013f, -0.04482115f, 0.13798450f, 
    -0.11176002f, -0.04337034f, 0.14638405f, -0.14293608f, -0.11017174f, -0.06974452f, 0.08639459f, -0.09769992f, 
    -0.16201743f, -0.04573543f, -0.11028116f, -0.08755542f, -0.16066547f, -0.20231202f, -0.05757107f, -0.05082294f, 
    -0.06167382f, -0.10322370f, -0.13191085f, -0.18996708f, 0.03116730f, -0.19606470f, 0.07256871f, -0.16460659f, 
    -0.05901549f, -0.12928112f, 0.16342470f, 0.04402929f, 0.04431828f, -0.15337725f, 0.09805989f, 0.23724134f, 
    0.03790024f, -0.07937262f, -0.14639246f, -0.14112881f, -0.01834881f, -0.14073850f, 0.27234679f, 0.14743160f, 
    -0.14216366f, -0.08279236f, 0.21151316f, -0.27489442f, 0.05335641f, 0.33862570f, 0.26450518f, 0.15636595f, 
    -0.15783358f, 0.04572234f, 0.45975035f, 0.10729720f, -0.12744279f, 0.01244184f, 0.12165079f, 0.07945518f, 
    0.14289746f, 0.09571692f, 0.05355101f, -0.07857604f, -0.14876831f, 0.07190304f, -0.13177308f, 0.09122316f, 
    -0.04302397f, -0.06949585f, -0.00524724f, 0.12524597f, -0.18126455f, -0.08831986f, -0.13983303f, 0.11869085f, 
    -0.10528877f, -0.15947984f, -0.08745395f, -0.06084414f, 0.08769002f, 0.02487030f, -0.16865489f, 0.10669977f, 
    -0.08779436f, 0.03228194f, -0.02948791f, -0.03189197f, 0.16838020f, -0.12293743f, -0.10795636f, -0.13430063f, 
    0.10372329f, 0.07192977f, -0.57012415f, 0.10768602f, 0.09067040f, -0.11786763f, -0.05991234f, 0.07875354f, 
    0.48499081f, 0.03756004f, 0.01868881f, -0.20132197f, 0.40908408f, 0.02677421f, 0.05785166f, -0.14600909f, 
    0.13108096f, 0.22167692f, -0.15914518f, 0.11466674f, -0.05528172f, 0.12546007f, 0.15968087f, -0.09418543f, 
    -0.00051465f, -0.10073376f, -0.07709846f, -0.19110997f, 0.11939871f, 0.16939229f, -0.14127794f, 0.09581490f, 
    0.07241524f, 0.13250683f, -0.14122421f, 0.26806000f, 0.06346701f, 0.14362673f, 0.08950195f, 0.31549877f, 
    0.39650342f, -0.29327315f, 0.07783737f, -0.29200494f, 0.28684029f, -0.06413530f, -0.19794525f, 0.08354449f, 
    -0.17806627f, 0.04727367f, -0.19933712f, 0.14306363f, -0.15653728f, 0.09006792f, 0.04524404f, 0.04641295f, 
    -0.09518387f, -0.14541902f, -0.48359919f, -0.10051840f, 0.07632072f, 0.17233841f, 0.11309031f, 0.11672734f, 
    0.05707545f, 0.12664130f, -0.08765781f, 0.26011163f, 0.24354014f, -0.04660927f, 0.03547747f, 0.09930084f, 
    -0.20011297f, 0.11744475f, 0.14919667f, -0.08307596f, -0.10998473f, -0.06116983f, -0.16855827f, -0.05447488f, 
    0.10815350f, 0.18213925f, -0.17283694f, 0.00270632f, 0.01776983f, 0.42186874f, -0.04620885f, -0.01055972f, 
    0.07992323f, -0.07691631f, 0.08664391f, -0.21826737f, -0.11482273f, -0.00141128f, -0.10468355f, -0.02924836f, 
    -0.15972440f, -0.08484684f, -0.13221443f, 0.00987867f, 0.24566461f, 0.11124739f, -0.12066552f, 0.03531981f, 
    -0.01526111f, -0.04198903f, 0.00392715f, -0.15188660f, 0.05543576f, 0.03915341f, -0.08274014f, 0.04509936f, 
    -0.16121075f, 0.12496893f, 0.19919978f, 0.06295794f, -0.06377455f, -0.25653768f, -0.11388616f, -0.07227866f, 
    -0.03198507f, -0.13308266f, 0.04014666f, -0.05430455f, 0.03392734f, -0.19311382f, -0.04840249f, -0.07866708f, 
    0.09435282f, 0.12857206f, -0.07214841f, -0.24125235f, 0.01051615f, -0.24007007f, -0.17357849f, -0.27824405f, 
    0.18063053f, 0.30488476f, -0.08742606f, 0.11687782f, -0.17051668f, -0.14448771f, 0.22128314f, -0.21719949f, 
    0.07036801f, 0.23701577f, -0.02648991f, 0.05224816f, 0.16771564f, 0.21837178f, -0.10168912f, 0.21663868f, 
    0.01505896f, -0.04519820f, -0.25322327f, 0.16967811f, 0.13087709f, 0.15854101f, -0.14554179f, 0.13642031f, 
    0.11682069f, 0.14297451f, 0.17357194f, -0.36911675f, -0.37766111f, -0.05809912f, 0.14850578f, -0.20167944f, 
    0.12607166f, -0.03922478f, 0.15822682f, -0.38546702f, 0.05036894f, 0.13206096f, 0.27238148f, -0.00554059f, 
    0.35478428f, 0.15416203f, -0.05559249f, -0.18995881f, -0.02816133f, 0.02618520f, 0.32461059f, 0.03559878f, 
    -0.09278014f, -0.07748877f, 0.36659271f, 0.01076283f, -0.13422707f, 0.06745039f, 0.10006358f, -0.04523830f, 
    0.05361136f, -0.05914388f, -0.03589874f, -0.29937872f, -0.08450773f, 0.07906560f, -0.15358137f, -0.15551367f, 
    -0.06998842f, -0.04710490f, 0.16793014f, 0.37982973f, -0.24887949f, 0.14777415f, -0.03423659f, -0.19142376f, 
    0.43656576f, 0.15638617f, -0.29147443f, -0.02068630f, 0.03703972f, 0.06595612f, 0.05411623f, 0.05576060f, 
    0.10794088f, 0.04784759f, 0.05123371f, 0.46396238f, -0.14650083f, 0.00826166f, -0.10359804f, 0.13979501f, 
    -0.04027148f, -0.06922638f, 0.18059993f, -0.04242902f, -0.00727209f, -0.02670692f, -0.14419208f, -0.21950357f, 
    -0.03937145f, 0.19922039f, 0.15164550f, -0.13226923f, -0.01616830f, -0.15398231f, 0.53875732f, 0.30864286f, 
    -0.23700975f, -0.03848767f, 0.13027897f, -0.11309559f, 0.05283022f, -0.36128798f, 0.18699752f, 0.20193200f, 
    -0.08712626f, -0.06343172f, 0.44042593f, -0.23149002f, -0.16369155f, 0.07105650f, -0.09519830f, 0.16852944f, 
    -0.03240098f, 0.03263734f, -0.19071102f, -0.29906693f, 0.17067254f, -0.14136058f, -0.14424440f, -0.34616238f, 
    -0.07407591f, 0.21329200f, -0.12766163f, 0.50562483f, 0.08988018f, -0.01358393f, -0.40983668f, 0.06162328f, 
    0.02607131f, -0.07666431f, -0.11467770f, 0.11086997f, 0.02363518f, -0.05061802f, -0.04722963f, 0.08872594f, 
    0.08180054f, -0.09567863f, 0.08075862f, -0.09128626f, -0.15292296f, 0.00175555f, -0.13048358f, -0.13132387f, 
    -0.13821395f, -0.11611435f, 0.02037196f, 0.20145623f, -0.12805165f, 0.28257993f, -0.17070334f, 0.28673443f, 
    -0.06599367f, -0.22768874f, -0.09658810f, 0.19222416f, -0.01907070f, -0.06890459f, 0.16319288f, 0.02312798f, 
    -0.13268842f, 0.14040573f, 0.25369397f, 0.03829626f, -0.13641198f, 0.44752160f, -0.10463396f, -0.26678362f, 
    -0.09071700f, -0.03267436f, 0.58668274f, 0.07855583f, -0.05298330f, -0.00251916f, 0.13646412f, -0.15867275f, 
    -0.07164170f, -0.06571036f, -0.02680669f, 0.27061361f, -0.24977922f, 0.07381058f, -0.16917500f, 0.18517132f, 
    -0.09204163f, -0.05227177f, 0.13872544f, -0.12686525f, 0.46585262f, -0.02513743f, 0.17642988f, 0.01094598f, 
    0.33945343f, 0.01557565f, -0.20671004f, -0.08601965f, -0.08201943f, -0.16706620f, 0.13210692f, 0.01671531f, 
    0.16596173f, -0.01652945f, 0.36326253f, -0.13079470f, -0.02648154f, 0.02672032f, -0.12008969f, 0.05851302f, 
    0.02492084f, -0.15262036f, 0.20313974f, -0.23848180f, -0.38366753f, 0.11966647f, -0.07102884f, -0.12357957f, 
    0.03704254f, -0.11660951f, -0.10849721f, -0.26409680f, 0.07176023f, -0.11906115f, -0.07939660f, 0.00752092f, 
    -0.03817074f, 0.15828735f, 0.33436885f, -0.00193136f, 0.01284546f, -0.21131098f, 0.44351929f, 0.27580035f, 
    0.03275307f, -0.13188399f, -0.19485636f, -0.05585757f, 0.00450076f, -0.15405336f, 0.23867056f, 0.17142834f, 
    0.12834664f, 0.16807744f, -0.02420236f, 0.10648859f, 0.23116463f, 0.43754569f, 0.15003040f, 0.25100496f, 
    -0.06297031f, -0.11962876f, 0.15852688f, -0.04075476f, -0.00433533f, -0.08456145f, 0.16501269f, -0.08588649f, 
    -0.34575093f, -0.07293595f, 0.17213176f, 0.06837425f, -0.01439217f, 0.34647214f, 0.06732209f, 0.11159170f, 
    -0.08331490f, -0.13518316f, -0.52046609f, -0.08417364f, 0.12045406f, 0.10166869f, 0.27558640f, 0.05105835f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.19645646f, 0.02502928f, 0.23486561f, -0.05329713f, 0.16473739f, 0.11096905f, 0.30506760f, 0.12216333f, 
    0.14366700f, 0.06996897f, 0.28130323f, -0.15408504f, 0.26673457f, 0.20782989f, 0.17793120f, 0.01015693f, 
    0.17524281f, 0.02018194f, 0.01291284f, 0.28829980f, 0.09985082f, -0.01991378f, 0.10849768f, -0.09310535f, 
    0.20026243f, -0.05100759f, -0.07488571f, 0.09910456f, 0.13999663f, 0.29850253f, 0.20304921f, 0.02712975f, 
    0.30277866f, -0.03905613f, 0.24337499f, -0.12574612f, 0.16436030f, 0.17815225f, 0.01948137f, 0.17199473f, 
    0.15450370f, -0.05128790f, 0.17084399f, 0.22277528f, -0.19155028f, -0.09696408f, -0.14505327f, 0.17392591f, 
    -0.04079767f, -0.25609350f, 0.08023205f, 0.05375462f, -0.04279669f, -0.10428830f, 0.11064796f, 0.21460639f, 
    -0.04333017f, 0.21040171f, 0.16914603f, 0.00342613f, -0.10738257f, 0.02157286f, 0.14340544f, -0.04103953f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.21536101f, 0.11479998f, 0.26040226f, -0.15635537f, -0.34396017f, 0.25247914f, 0.30991355f, 0.01700571f, 
    0.22139716f, -0.03225222f, 0.20407416f, 0.01542503f, -0.04850882f, 0.10395159f, 0.00969312f, -0.29055855f, 
    -0.00985964f, 0.09070747f, 0.14680697f, 0.06345164f, -0.07624035f, 0.26638553f, 0.06063857f, -0.11178038f, 
    0.01199077f, -0.02518290f, -0.19491744f, -0.04379280f, 0.10013876f, -0.03487636f, 0.11386304f, 0.17751162f, 
    0.01244234f, -0.28015226f, -0.04500353f, 0.10466768f, -0.10732245f, 0.13117449f, -0.19819276f, 0.06663073f, 
    0.55264002f, -0.10598689f, 0.13963898f, 0.00280747f, 0.00453367f, -0.10587346f, 0.13346581f, -0.15932800f, 
    -0.10702176f, -0.19173966f, -0.16349499f, 0.04651104f, -0.23399021f, -0.08975796f, -0.03096183f, 0.33699718f, 
    -0.10296707f, 0.33100414f, -0.05327208f, 0.25588566f, -0.01715679f, 0.10543362f, -0.11118452f, -0.19419882f, 
    0.36321640f, -0.01439722f, -0.00502600f, -0.11350386f, 0.04124066f, -0.06190243f, 0.22665437f, -0.07768750f, 
    0.00629074f, 0.19981281f, -0.13785812f, -0.22371680f, -0.04476168f, 0.13918428f, -0.01445182f, -0.02561590f, 
    -0.05103614f, 0.39534590f, 0.21556866f, -0.02281353f, 0.21369301f, 0.15143746f, 0.17593156f, 0.26847818f, 
    -0.24963512f, 0.03243484f, -0.28257054f, 0.02921236f, 0.04870977f, 0.11414280f, -0.03672528f, 0.08869518f, 
    0.15966134f, -0.00383508f, 0.04536421f, -0.05152769f, 0.23089558f, 0.15314296f, 0.42851451f, 0.13863897f, 
    0.14106072f, 0.36358491f, -0.07619345f, -0.17103231f, 0.11405789f, -0.07880183f, 0.03096852f, 0.24052544f, 
    -0.03468185f, 0.19114816f, 0.05088770f, -0.36556354f, -0.12518257f, 0.00213229f, 0.23565234f, 0.21024005f, 
    -0.27077210f, 0.02135932f, -0.10896992f, 0.26276863f, -0.08549636f, -0.35001990f, -0.05829581f, 0.21860284f, 
    -0.82194126f, 0.00141178f, -0.01753869f, 0.09337825f, 0.26152053f, -0.14533263f, -0.46294254f, -0.29365110f, 
    0.05810688f, 0.15631385f, -0.10614997f, 0.17309080f, -0.11091059f, -0.19802621f, 0.09729527f, 0.08110134f, 
    -0.10151767f, 0.30338359f, 0.14373375f, -0.56404799f, 0.07347080f, 0.30067188f, -0.04498741f, 0.04020486f, 
    -0.06077943f, -0.12470637f, 0.19325045f, -0.19770765f, 0.08367044f, 0.18907812f, 0.02691254f, -0.01299981f, 
    -0.11738102f, -0.08498545f, -0.35970724f, -0.03826765f, -0.03125955f, -0.22066592f, 0.20327120f, 0.13287447f, 
    -0.25341406f, 0.31842282f, 0.01949415f, 0.18622075f, 0.63079810f, -0.06564735f, -0.00485397f, 0.17128961f, 
    0.02558278f, 0.29621217f, 0.04339129f, -0.21495466f, -0.19341612f, 0.21867055f, 0.00561411f, -0.38269770f, 
    0.23844910f, -0.09787008f, 0.21469828f, -0.10494765f, 0.08062283f, 0.23717716f, -0.26703182f, -0.13298807f, 
    -0.01716125f, -0.11449359f, 0.13201004f, 0.01381902f, -0.20627922f, -0.44167045f, -0.11093107f, 0.29022655f, 
    -0.22308810f, 0.20691438f, -0.16950838f, 0.14625165f, 0.17076899f, -0.10093471f, 0.12358014f, 0.11685800f, 
    -0.03866506f, 0.07083067f, 0.09783991f, -0.16290277f, 0.39564461f, -0.47706607f, 0.21134920f, 0.39932629f, 
    -0.21478286f, -0.09477194f, 0.05194903f, 0.09989607f, 0.11757012f, -0.27223215f, 0.11768829f, 0.03080079f, 
    0.20871951f, 0.16339444f, -0.08805095f, 0.05691674f, -0.01651133f, 0.04036601f, 0.11504659f, -0.41117629f, 
    -0.07699541f, -0.10958639f, -0.24511902f, 0.05210788f, -0.22549674f, -0.06971898f, -0.03736351f, 0.00570694f, 
    0.08788392f, 0.11968575f, 0.14132610f, -0.16629948f, 0.09968898f, 0.09823490f, -0.02314201f, -0.11309101f, 
    -0.44182125f, -0.38271606f, -0.03803148f, -0.08046972f, 0.07529745f, -0.05437617f, -0.03618043f, 0.44534072f, 
    -0.23109628f, -0.08440678f, -0.16570459f, 0.00703502f, 0.04137559f, 0.06309567f, 0.16010737f, 0.41432184f, 
    0.04531075f, -0.09961189f, 0.00808768f, 0.12815695f, 0.04377045f, 0.16398346f, -0.17123058f, -0.09349099f, 
    0.03762287f, -0.14557989f, -0.00252282f, 0.25197062f, 0.18617380f, -0.00228265f, -0.24102379f, -0.09897824f, 
    0.28716072f, 0.10817987f, 0.02889554f, 0.09806177f, -0.10856178f, 0.09708986f, 0.05948005f, -0.11187999f, 
    0.41660103f, -0.23400278f, 0.19196855f, -0.07055727f, 0.34552270f, -0.10108622f, -0.16326210f, 0.35904354f, 
    -0.07663170f, -0.45506185f, -0.02995135f, 0.23265192f, -0.36464077f, -0.10176043f, 0.05065736f, -0.22384122f, 
    0.03680765f, 0.10133865f, 0.04682286f, -0.07957740f, -0.17392215f, -0.09960920f, -0.16318223f, 0.23900129f, 
    0.34992051f, 0.11889008f, 0.25191826f, -0.14994811f, 0.01958037f, 0.23555519f, 0.35074094f, -0.15147509f, 
    0.02904664f, 0.09733653f, -0.00809703f, -0.02708525f, 0.09747861f, -0.05255605f, -0.17509671f, 0.19504100f, 
    -0.28534281f, 0.05419613f, -0.10529301f, 0.13544111f, -0.18586372f, 0.15628782f, -0.20902200f, 0.18070823f, 
    0.08942894f, -0.01889964f, -0.07755319f, 0.16635242f, 0.25703567f, -0.24540654f, -0.10372479f, 0.04113258f, 
    0.21690926f, 0.02559177f, 0.11085133f, 0.03234248f, -0.03370163f, 0.31735432f, -0.11654133f, 0.04392547f, 
    0.22156274f, 0.16054948f, 0.01826585f, 0.10891724f, 0.34361371f, -0.11289316f, 0.04970838f, -0.16023932f, 
    -0.17906085f, 0.18512982f, 0.08494554f, 0.06638976f, 0.15699099f, 0.03238039f, -0.11925235f, 0.06079229f, 
    0.00587966f, 0.16231266f, -0.03225132f, -0.20474805f, 0.09676877f, -0.07720698f, -0.05439743f, -0.32366410f, 
    0.24977395f, -0.04378433f, -0.11433881f, -0.34815606f, -0.15253325f, 0.11121427f, 0.29722509f, 0.11371973f, 
    0.13548651f, 0.09029984f, 0.09639762f, -0.03488559f, 0.18168464f, 0.37847427f, 0.08670739f, 0.04320854f, 
    0.21494263f, -0.06909294f, 0.26602167f, -0.09297930f, 0.16846420f, 0.12435332f, 0.13298596f, 0.04395740f, 
    0.08698542f, -0.23681974f, 0.12234808f, -0.01731683f, -0.38234833f, 0.39022842f, 0.10907415f, -0.11496555f, 
    -0.21457686f, -0.01967532f, 0.05598501f, 0.14865346f, -0.04120915f, -0.37822363f, 0.40962693f, 0.20444068f, 
    -0.18244016f, 0.10518317f, 0.01672371f, 0.10866306f, -0.33040875f, 0.06132273f, 0.13977990f, 0.15087096f, 
    0.12226391f, 0.12667595f, 0.06924903f, 0.00474009f, -0.23591083f, 0.13556366f, 0.01865313f, 0.27054533f, 
    -0.00477129f, -0.18967327f, 0.05182016f, 0.27259499f, 0.17859845f, -0.07548007f, -0.02572232f, 0.16430560f, 
    -0.04440516f, 0.37244919f, -0.18627131f, 0.30068439f, 0.05468977f, -0.22190709f, -0.20221575f, 0.13032760f, 
    0.64291894f, 0.01886742f, -0.05524638f, 0.05735029f, -0.15160854f, -0.15450829f, 0.09736864f, -0.16469656f, 
    -0.00231146f, 0.16698517f, -0.01047200f, 0.19846800f, -0.11131711f, -0.10539525f, 0.28486487f, -0.11233757f, 
    0.02942172f, -0.07544051f, 0.25675985f, -0.24173178f, -0.02213502f, 0.00911406f, 0.19687419f, 0.38876006f, 
    0.02926344f, -0.08374583f, -0.15206534f, 0.06146094f, -0.02830547f, 0.19010626f, 0.24144724f, 0.16393313f, 
    -0.07694897f, 0.17759815f, 0.06674343f, -0.07961008f, -0.09440213f, -0.11497608f, -0.19324094f, -0.09937980f, 
    0.27576390f, 0.18627436f, -0.13541657f, 0.03785121f, -0.18355188f, -0.07795735f, 0.34424403f, 0.01572640f, 
    0.09370207f, 0.00406600f, -0.03915655f, -0.08128907f, 0.16346259f, 0.41873994f, 0.10057459f, 0.07164048f, 
    -0.54601675f, -0.12637231f, -0.27512488f, -0.19707353f, 0.26018393f, -0.15431352f, -0.24192326f, 0.16152175f, 
    0.15230314f, 0.09935967f, -0.17314479f, -0.15913080f, -0.20256059f, 0.24211918f, -0.16176566f, 0.23236948f, 
    -0.17864066f, 0.37339985f, -0.07047036f, 0.02721717f, 0.12415332f, 0.24823022f, 0.12307882f, -0.06743512f, 
    0.11947504f, -0.17282274f, -0.13360524f, 0.05199702f, 0.06335068f, 0.14486010f, 0.08774877f, 0.13218164f, 
    0.33053505f, 0.03697699f, 0.29543111f, 0.04980928f, 0.10055348f, 0.46048462f, -0.05873438f, -0.04032328f, 
    0.38155520f, 0.17871591f, -0.13703811f, 0.08578144f, 0.54215741f, -0.22943239f, -0.01329510f, 0.05723357f, 
    0.14885671f, -0.31966531f, 0.04413060f, 0.40212750f, -0.51256037f, 0.01842856f, -0.12022764f, -0.02856711f, 
    0.11838076f, 0.00352460f, 0.06422652f, -0.09599397f, -0.07676860f, -0.11250775f, -0.04533560f, 0.07516348f, 
    0.24244837f, 0.07663591f, -0.07697502f, -0.10962044f, 0.03123575f, -0.10183020f, 0.27030289f, 0.19598038f, 
    -0.05237871f, 0.06954592f, -0.02736468f, 0.24583314f, 0.20939621f, 0.26541892f, 0.05853478f, 0.11581876f, 
    0.07706989f, -0.24644284f, 0.21403095f, 0.02258774f, -0.02413761f, 0.21824852f, 0.04025061f, -0.04167071f, 
    0.08591987f, -0.01913380f, -0.14242801f, 0.03254687f, -0.15397765f, 0.36415219f, -0.03608352f, -0.27784562f, 
    0.03580816f, -0.01402707f, 0.23760255f, -0.11649191f, -0.07494968f, -0.04728491f, 0.29870382f, 0.20451081f, 
    0.04361708f, -0.28896144f, -0.10494654f, 0.04113212f, -0.06079315f, -0.15079473f, -0.16855420f, 0.35679132f, 
    0.00572904f, -0.14160012f, 0.26783124f, 0.21677142f, 0.09211388f, 0.06996452f, -0.24287733f, 0.08781136f, 
    0.10391863f, -0.00153840f, -0.12341384f, 0.24079303f, -0.05032590f, 0.00496089f, -0.14838950f, 0.34648904f, 
    0.46275550f, 0.54972684f, 0.09294002f, -0.02576089f, -0.06418908f, 0.14529608f, 0.16139103f, -0.25274757f, 
    -0.04885767f, 0.00677381f, -0.03486176f, 0.03497818f, -0.09596948f, 0.06905209f, -0.05735774f, 0.06138206f, 
    -0.02929128f, 0.07614626f, -0.12224806f, 0.03478860f, -0.01182532f, -0.08855282f, -0.08060370f, 0.07328429f, 
    -0.10478384f, 0.02992150f, -0.11551192f, 0.01094095f, -0.12126298f, -0.04983310f, 0.02548866f, 0.03915429f, 
    0.06701594f, 0.08615573f, -0.06570426f, -0.06947739f, -0.02492112f, -0.07388774f, -0.09031545f, 0.04005175f, 
    0.06377006f, -0.07468116f, -0.08896495f, 0.08372752f, -0.12716503f, -0.00724134f, -0.02480669f, 0.03620106f, 
    -0.05647507f, 0.08905184f, 0.00829416f, -0.01872868f, 0.03256208f, 0.00747824f, -0.01665914f, 0.09099064f, 
    -0.07047397f, 0.03062189f, -0.00211984f, -0.13074458f, -0.06473599f, 0.03229199f, -0.08407199f, -0.04423706f, 
    0.06935894f, 0.01070239f, 0.05774689f, 0.02482052f, -0.00659390f, 0.07287570f, 0.03457836f, -0.05778755f, 
    0.19312778f, -0.02561583f, -0.05332976f, 0.40014789f, -0.08754504f, -0.18179852f, -0.04041748f, 0.16348763f, 
    -0.17219968f, 0.11401121f, 0.15423477f, -0.05467573f, -0.17793840f, 0.13040541f, 0.17944469f, 0.27052671f, 
    0.15286408f, -0.07352321f, 0.11049011f, -0.04876420f, 0.04316403f, -0.37724748f, 0.12234236f, 0.32165435f, 
    0.02897796f, 0.12776871f, 0.29866689f, 0.01825034f, 0.07896205f, -0.18286011f, 0.30094361f, 0.20379129f, 
    0.28861189f, 0.16298577f, -0.00888518f, 0.04293488f, -0.03347623f, -0.05929321f, -0.00556470f, -0.16688250f, 
    -0.24051471f, -0.15833978f, -0.10069154f, 0.24488007f, -0.43475905f, -0.10717005f, -0.03105898f, 0.16509977f, 
    -0.05933224f, -0.06781218f, -0.07095094f, 0.22525044f, 0.27738085f, 0.23187533f, -0.09665637f, 0.00572186f, 
    -0.06105368f, -0.04579012f, -0.24247593f, -0.35845268f, -0.11098230f, 0.03727809f, 0.05484525f, 0.30108824f, 
    -0.01551709f, 0.03779651f, 0.02533573f, 0.13860017f, 0.02036681f, -0.04750231f, 0.05636421f, -0.02393571f, 
    -0.07556407f, 0.02951392f, 0.04085467f, -0.09058541f, -0.02011589f, 0.05324803f, -0.04896471f, -0.10729346f, 
    -0.13196568f, -0.12631492f, -0.14045408f, 0.09375052f, -0.15396529f, 0.06756688f, -0.07158437f, 0.00289968f, 
    0.00263847f, 0.07313350f, 0.12073039f, -0.14162511f, 0.05573325f, 0.08579037f, -0.06573577f, 0.02683762f, 
    -0.00690839f, -0.06312147f, -0.00006641f, 0.06591256f, 0.01186772f, 0.10589152f, -0.01706333f, -0.04522226f, 
    0.01820714f, -0.00074378f, 0.00042933f, -0.13284864f, -0.08407471f, -0.11132360f, -0.06082911f, -0.05261456f, 
    -0.01070829f, -0.00106514f, 0.05881822f, 0.03032066f, 0.07412926f, 0.00197470f, 0.10322213f, -0.11073852f, 
    0.05914371f, -0.07320730f, -0.10287403f, -0.06496979f, 0.04736369f, -0.03688670f, -0.10844665f, -0.04420194f, 
    0.14767310f, -0.02382604f, 0.17646244f, -0.13361123f, -0.25144115f, -0.16250721f, 0.06171599f, 0.19605874f, 
    -0.02525748f, 0.31888583f, -0.10361145f, -0.13513881f, -0.04993855f, -0.02714642f, 0.12778707f, 0.27720383f, 
    0.03807453f, 0.37208471f, 0.11603480f, -0.08185410f, 0.43377888f, -0.08698842f, 0.37676117f, 0.40335208f, 
    -0.25212410f, -0.04145907f, 0.04634448f, 0.09353668f, -0.11510751f, -0.27587438f, 0.02471772f, 0.01701075f, 
    0.22784607f, 0.13452290f, -0.10214709f, -0.03601112f, 0.03860987f, 0.02991804f, 0.29415688f, -0.13474950f, 
    0.31842491f, 0.35258764f, -0.06114122f, 0.07989170f, -0.09526222f, 0.05489264f, -0.14111847f, 0.29575220f, 
    0.01146530f, 0.15642422f, -0.10527515f, -0.26706624f, 0.07204083f, 0.01647661f, 0.08833022f, -0.04467785f, 
    -0.25271529f, 0.00255344f, 0.20205927f, 0.34897444f, 0.15260932f, -0.18458554f, -0.07764421f, 0.42931941f, 
    0.14402571f, 0.09364524f, -0.27263656f, 0.25334576f, 0.06561293f, 0.30946654f, 0.06122925f, 0.14740928f, 
    0.15607090f, -0.25331965f, 0.10672230f, 0.36042786f, 0.00169230f, 0.31467023f, -0.26917744f, -0.23658301f, 
    -0.06354618f, -0.19864260f, -0.05406867f, 0.21345034f, -0.31507128f, 0.14321202f, -0.07794326f, -0.24388957f, 
    0.17387405f, -0.11993365f, 0.07242607f, 0.07614897f, -0.01712536f, 0.19564845f, 0.05435625f, -0.02351300f, 
    0.00356367f, -0.05922545f, 0.22528194f, -0.10850086f, 0.14007224f, 0.00178363f, -0.11478182f, 0.43048686f, 
    -0.01430942f, 0.11104880f, 0.13315700f, 0.13064887f, 0.18521920f, 0.02804093f, 0.24403629f, -0.25208673f, 
    0.04040736f, 0.05893277f, -0.01901313f, 0.24444190f, 0.04651126f, 0.02158495f, -0.10292849f, 0.03493332f, 
    0.34334272f, 0.49887747f, 0.03434858f, 0.07757471f, -0.01287529f, 0.14050423f, 0.25823900f, -0.32432002f, 
    -0.00172764f, 0.01913799f, -0.11618324f, 0.05106584f, -0.08118922f, 0.03008153f, 0.05853464f, 0.01903260f, 
    -0.08975715f, -0.04667049f, 0.02685898f, -0.00122498f, -0.11042088f, -0.16858286f, -0.09854930f, -0.01611447f, 
    0.03387085f, -0.09682045f, 0.02307179f, -0.06804000f, -0.02541430f, 0.08183082f, -0.10151662f, 0.05589673f, 
    -0.07602472f, -0.00120811f, -0.11424529f, 0.06046982f, 0.04695836f, 0.13352624f, -0.14567411f, 0.00737415f, 
    -0.16406429f, -0.00579410f, -0.11089339f, 0.04197247f, -0.15053262f, 0.03861457f, 0.12092650f, -0.10841940f, 
    -0.00952613f, -0.11703774f, 0.05970611f, 0.01980066f, 0.00581791f, 0.01873428f, 0.08786133f, -0.06469403f, 
    0.09143609f, -0.02364052f, -0.07522488f, -0.16053484f, 0.06815948f, 0.09781879f, 0.12258402f, -0.11402655f, 
    -0.13966876f, 0.06312764f, -0.00205385f, 0.12025301f, -0.14941756f, -0.00796063f, -0.02725548f, -0.02499561f, 
    -0.07778005f, 0.03928653f, 0.11115504f, -0.04525835f, 0.16918439f, 0.01153480f, -0.16978899f, -0.18371487f, 
    -0.15815765f, 0.19536124f, -0.13447058f, -0.18482180f, 0.34674349f, 0.17201787f, 0.19298477f, 0.27867907f, 
    0.04481446f, 0.08321609f, -0.02520910f, -0.09017683f, 0.18724582f, 0.14437787f, -0.06471577f, -0.04872012f, 
    0.26372597f, 0.10130800f, 0.22454977f, -0.13304581f, -0.00760013f, 0.45537657f, -0.07929593f, 0.04874064f, 
    0.03134033f, 0.00194389f, -0.22449847f, -0.01072348f, 0.43121335f, 0.01719736f, 0.33968002f, 0.18266799f, 
    -0.17455892f, -0.26070604f, 0.02315488f, 0.17795719f, -0.13635084f, -0.03700446f, -0.03676398f, -0.00545448f, 
    -0.00627078f, 0.02447902f, 0.11542240f, 0.00521316f, -0.08577962f, -0.24369936f, 0.00209024f, -0.07929815f, 
    0.26627848f, -0.16295019f, 0.39328736f, -0.09541725f, 0.16778161f, -0.28221667f, 0.43199092f, -0.01221091f, 
    -0.12800303f, 0.01138481f, 0.19127367f, 0.19666664f, -0.20062403f, -0.24018726f, -0.17273030f, 0.15019421f, 
    -0.17226528f, 0.07893947f, 0.04538274f, 0.00309044f, 0.19101198f, -0.07152800f, 0.36329269f, 0.08435453f, 
    0.13049059f, 0.33701456f, -0.00838661f, -0.10419454f, 0.22537363f, -0.09118716f, 0.18634029f, 0.21083520f, 
    0.18142262f, 0.00026000f, 0.10495634f, -0.13569871f, -0.10076423f, -0.26060650f, 0.28546968f, 0.16330923f, 
    0.30896047f, 0.11113416f, -0.03972673f, -0.04836239f, 0.17719604f, -0.04229129f, 0.02332543f, -0.00591841f, 
    -0.22479546f, -0.41411629f, -0.07138209f, 0.19876945f, -0.35903603f, -0.08526777f, 0.06797706f, 0.15419580f, 
    -0.11506600f, 0.14432862f, 0.08430465f, 0.05435957f, 0.06623257f, 0.14145060f, 0.16829695f, 0.06929448f, 
    0.03932761f, -0.41610354f, 0.37137869f, -0.16316701f, 0.10408058f, 0.12240683f, 0.19478264f, 0.41092941f, 
    -0.31204832f, -0.10846023f, 0.13351431f, 0.49442086f, 0.34190202f, -0.04584356f, 0.06573039f, -0.15578780f, 
    0.26501709f, -0.32487959f, 0.03395946f, -0.04398849f, -0.24759421f, 0.05245005f, 0.06427801f, 0.13513327f, 
    0.23675093f, -0.13084505f, -0.18489972f, 0.08493519f, -0.18659648f, -0.37248132f, -0.32040918f, -0.34124991f, 
    0.23141351f, 0.01471481f, 0.06730222f, 0.18942395f, 0.03701048f, -0.10872386f, 0.06999002f, 0.02921892f, 
    -0.19785176f, 0.14917870f, 0.36584079f, -0.14852946f, -0.17069800f, 0.39376444f, -0.01709433f, -0.17702137f, 
    -0.51027405f, 0.19956900f, 0.13800716f, -0.32520074f, -0.28353953f, -0.08277094f, 0.19352613f, 0.10735396f, 
    0.01065271f, -0.00890062f, -0.06908226f, 0.35623577f, 0.22855033f, -0.11672546f, 0.12002051f, -0.16661979f, 
    -0.00770838f, -0.38748509f, -0.09802933f, -0.41994187f, -0.26990744f, 0.26495686f, 0.04247575f, -0.09102580f, 
    0.07540544f, -0.08776885f, 0.05657097f, -0.11417059f, 0.03898747f, 0.09041779f, 0.00835385f, -0.10763402f, 
    0.01241139f, -0.09948155f, -0.11979705f, 0.05481153f, -0.01646167f, -0.01101144f, 0.02426396f, -0.07397477f, 
    -0.06123139f, -0.03869186f, 0.08697817f, -0.07818861f, -0.10327964f, -0.14065611f, -0.00047187f, 0.10029207f, 
    -0.12130395f, -0.04903802f, 0.02261985f, 0.11196673f, 0.06956542f, 0.01787740f, 0.00036143f, -0.07162643f, 
    -0.04155727f, 0.02624607f, -0.10929476f, -0.01879108f, 0.03344993f, 0.00656562f, -0.04513187f, 0.07911444f, 
    -0.05099534f, 0.06910495f, -0.07161407f, -0.10143575f, -0.01612097f, -0.11648381f, -0.11648005f, 0.04897352f, 
    -0.05719206f, 0.08137070f, -0.06597859f, -0.02721334f, -0.07321167f, 0.06048361f, -0.08073823f, 0.02495948f, 
    -0.07782983f, 0.08297831f, -0.08354881f, -0.12223716f, -0.12035280f, -0.00187126f, 0.10246761f, 0.00680992f, 
    0.06990695f, 0.01699654f, -0.08960211f, -0.03851245f, -0.04486105f, -0.16435660f, 0.06692725f, 0.04154448f, 
    -0.03524526f, 0.11006515f, -0.15680549f, -0.00247465f, -0.06736417f, -0.10563082f, -0.01096006f, -0.11466672f, 
    0.01988471f, 0.06371675f, -0.10536058f, -0.01925800f, -0.05709306f, -0.06322718f, 0.02713787f, -0.10276639f, 
    -0.10438102f, -0.11868615f, -0.09273186f, -0.18015967f, 0.11013897f, 0.12643234f, -0.02031281f, 0.02568638f, 
    -0.11204282f, -0.13621588f, -0.04293941f, -0.05783254f, -0.17970143f, 0.01170902f, 0.10117813f, -0.11632896f, 
    0.04378329f, -0.00300704f, 0.02416019f, 0.04619679f, -0.05284251f, -0.00592324f, 0.07523368f, -0.05699499f, 
    -0.10477510f, -0.11813209f, -0.12296402f, 0.08393484f, -0.09917074f, 0.10798667f, 0.06808143f, -0.09500612f, 
    -0.17738006f, -0.01751599f, -0.16216910f, 0.10610017f, -0.08298405f, -0.02276555f, -0.06340840f, 0.13805428f, 
    0.02389987f, -0.03159660f, -0.05923522f, 0.00453607f, 0.20773181f, -0.06300832f, 0.09208236f, 0.16044731f, 
    -0.19193718f, -0.03310233f, -0.15690461f, -0.14202607f, 0.38762522f, -0.00841835f, 0.08791200f, 0.14915057f, 
    0.12032921f, 0.50166261f, -0.22927299f, -0.09444842f, 0.45637575f, -0.10626505f, -0.08055451f, -0.03914894f, 
    0.13324569f, -0.11522367f, 0.02451353f, 0.14669928f, 0.08770598f, 0.08269565f, -0.08711322f, -0.04321631f, 
    -0.04612998f, 0.07686214f, -0.01932984f, 0.02991026f, 0.49664882f, 0.01376714f, 0.45573750f, 0.13069902f, 
    -0.12115096f, 0.45516837f, 0.04357789f, 0.01927136f, 0.20297201f, -0.04908292f, -0.10470047f, 0.09144399f, 
    -0.02011227f, 0.43492171f, 0.06049012f, -0.30956611f, -0.16495536f, -0.22919153f, 0.10311431f, -0.04020061f, 
    0.18337376f, 0.16489474f, 0.51734525f, 0.53231907f, 0.10361044f, 0.12902106f, 0.29153290f, 0.08635200f, 
    0.06223636f, -0.08682120f, 0.03819441f, 0.06326395f, -0.05729416f, 0.02813594f, 0.02529470f, 0.05288496f, 
    -0.09711953f, -0.13227788f, 0.02836548f, 0.00427200f, 0.03016323f, -0.04954258f, -0.10970059f, -0.04585186f, 
    -0.04678110f, -0.03586327f, -0.08181135f, -0.09534779f, 0.02586750f, -0.02677907f, -0.12146152f, -0.04612391f, 
    -0.12920341f, 0.05745955f, 0.04488503f, 0.05813909f, -0.12065737f, -0.00362285f, 0.06044428f, -0.09353285f, 
    -0.07654838f, -0.02013561f, 0.00654155f, 0.04806159f, 0.10970655f, -0.12746504f, 0.02898843f, -0.09717719f, 
    -0.08197134f, -0.07544398f, 0.01659572f, 0.06002814f, -0.12577750f, -0.09476800f, 0.14136380f, 0.02164521f, 
    -0.04903243f, 0.06385032f, 0.09812719f, -0.08093312f, -0.09963496f, 0.00410923f, 0.11844382f, 0.08040953f, 
    -0.03623456f, 0.09923590f, -0.00901927f, 0.16421306f, -0.10430922f, -0.06548224f, -0.10907839f, 0.13725594f, 
    0.28355724f, 0.04792617f, -0.18115447f, 0.24830188f, -0.21044223f, -0.05801129f, 0.06520064f, 0.27973410f, 
    0.13424429f, -0.25879082f, -0.15391167f, -0.07334002f, 0.38810983f, 0.11979678f, -0.24723037f, 0.11998174f, 
    -0.10108972f, 0.27746218f, -0.43267241f, -0.04275832f, 0.19892384f, -0.29833677f, -0.23554078f, -0.12170526f, 
    0.18540268f, -0.10630164f, -0.06215619f, 0.00060490f, 0.05945628f, 0.12003483f, -0.12525402f, -0.22592667f, 
    -0.17329505f, -0.21380198f, 0.24396348f, 0.06519631f, 0.40204269f, 0.27602431f, 0.21432212f, 0.07847530f, 
    0.18864171f, 0.76507950f, 0.04708107f, -0.50262266f, 0.10640142f, -0.11378954f, 0.32158104f, -0.05320623f, 
    -0.10437799f, 0.07488196f, 0.05177097f, -0.06722500f, -0.11274985f, -0.01937726f, 0.04270366f, 0.12577771f, 
    -0.00800932f, 0.04927748f, 0.33758584f, 0.47023124f, -0.53273404f, -0.12204891f, 0.16690373f, 0.12429967f, 
    -0.04861179f, 0.07611120f, 0.06485488f, -0.11322981f, -0.04217717f, 0.02091729f, -0.02742089f, -0.00451770f, 
    0.04072170f, -0.12072036f, -0.12618354f, 0.02203184f, -0.11385556f, -0.07297616f, 0.05476268f, -0.00441629f, 
    -0.02951175f, -0.12295727f, 0.01621920f, 0.06570315f, -0.14871791f, 0.08258877f, -0.05825563f, -0.09797882f, 
    -0.12926467f, 0.10856971f, -0.08001054f, 0.01316235f, -0.07038203f, 0.00995982f, 0.09472685f, -0.06506652f, 
    -0.12084340f, 0.00588773f, 0.01858367f, 0.06217356f, -0.06404693f, 0.02244670f, -0.11059177f, -0.09821770f, 
    0.01794028f, 0.06054121f, -0.01656242f, 0.05426420f, -0.15574661f, -0.00584570f, -0.11740492f, 0.08506440f, 
    0.00098282f, -0.13536815f, 0.10383700f, -0.01248972f, -0.05977470f, 0.00038512f, -0.06308204f, -0.06638636f, 
    -0.10050153f, -0.02076358f, 0.07968291f, 0.06583340f, -0.03891707f, 0.02449127f, -0.05690890f, 0.06093091f, 
    0.01156863f, -0.04206436f, -0.06963719f, 0.47666076f, 0.34521347f, 0.08888232f, -0.17182298f, 0.02018501f, 
    -0.12257789f, -0.03978541f, 0.02428864f, 0.04947393f, 0.29458165f, 0.06354825f, 0.27043542f, 0.17779890f, 
    0.03244497f, -0.24277496f, -0.14527953f, 0.03499055f, -0.14793164f, -0.10169021f, -0.07683292f, -0.07327846f, 
    0.37419415f, -0.00061923f, 0.33646953f, -0.03869004f, -0.07560915f, -0.19714546f, 0.05762837f, -0.15758432f, 
    -0.21209809f, 0.38190952f, 0.16833261f, 0.07731667f, 0.23953673f, 0.17000036f, 0.28053200f, 0.28073245f, 
    -0.49493384f, 0.06484742f, -0.09976213f, 0.12356608f, -0.41037932f, 0.02671010f, 0.00528968f, 0.08914003f, 
    -0.01454149f, 0.29412624f, 0.08550523f, 0.10382127f, 0.23938726f, 0.09403952f, -0.01234853f, -0.01877221f, 
    0.21362780f, -0.22867703f, 0.07133227f, -0.32671985f, 0.00968680f, 0.04146208f, 0.32399413f, 0.29139253f, 
    0.03866265f, -0.07366634f, 0.01576650f, -0.03904328f, 0.02092284f, 0.12379407f, -0.12367341f, -0.15614264f, 
    0.24458620f, -0.04032642f, 0.06787597f, 0.28755769f, 0.03698944f, -0.05255909f, -0.10850938f, 0.14035290f, 
    -0.03259706f, 0.04304229f, 0.16689199f, -0.01181197f, 0.12703563f, 0.47146398f, 0.17795159f, 0.11762266f, 
    -0.21942535f, 0.01016585f, -0.10850794f, 0.08495718f, 0.08776510f, 0.21979342f, -0.05796747f, -0.02714966f, 
    -0.34195834f, 0.00533199f, -0.08248279f, 0.07942315f, -0.15657924f, -0.10410769f, 0.03145159f, -0.14491563f, 
    0.02083566f, 0.41356829f, 0.11277733f, 0.09101363f, 0.64810264f, 0.03208896f, 0.04279511f, 0.10873145f, 
    0.02583281f, 0.17413899f, -0.03578401f, -0.11103325f, -0.16015798f, 0.07054380f, 0.13431138f, 0.04782746f, 
    -0.19402839f, 0.24247734f, 0.05650538f, 0.22586758f, 0.28978556f, 0.11614726f, -0.58720636f, -0.09435593f, 
    0.15220332f, -0.11032576f, 0.19185351f, -0.16183536f, -0.09193683f, 0.50287652f, 0.27821934f, -0.23703288f, 
    0.24444702f, 0.10149000f, 0.05157573f, -0.08245120f, 0.11155114f, 0.02453496f, 0.16873278f, -0.16879128f, 
    0.12918298f, -0.07777041f, 0.23987271f, 0.07582505f, -0.44067314f, 0.56665671f, 0.20690382f, -0.38095224f, 
    -0.26886052f, 0.10107285f, 0.02363698f, 0.11717138f, 0.06443130f, -0.01970349f, 0.20815663f, 0.17263988f, 
    -0.15713456f, 0.04663253f, -0.14491531f, 0.07804581f, -0.17922126f, -0.09152354f, 0.16155933f, 0.27255723f, 
    0.22156039f, 0.14470197f, 0.05207379f, 0.04630939f, 0.10935853f, 0.10230645f, -0.26949254f, 0.02085826f, 
    -0.06594442f, -0.35477343f, -0.00858922f, 0.08027357f, -0.05317124f, 0.05530784f, -0.15682209f, 0.21204126f, 
    0.13539128f, 0.48340711f, -0.29354054f, 0.27331272f, 0.10153026f, -0.30491742f, -0.05752948f, -0.14108057f, 
    -0.10891539f, -0.01024426f, 0.30054450f, -0.31933975f, 0.01163370f, 0.24955669f, 0.28576234f, 0.05092153f, 
    0.07539129f, 0.19502980f, 0.17131788f, -0.40210134f, 0.12764691f, 0.12362315f, 0.10266619f, -0.07272750f, 
    0.21301650f, 0.03814822f, 0.07122331f, 0.25577906f, -0.01486063f, 0.27666512f, 0.20683824f, -0.14592400f, 
    -0.29010540f, 0.04704909f, -0.10155771f, 0.14412957f, -0.07827519f, -0.01627648f, 0.05161099f, 0.26094332f, 
    0.11564364f, -0.13880253f, 0.05987089f, 0.10022932f, -0.17096671f, 0.10781164f, -0.10837232f, -0.05288037f, 
    0.24250178f, -0.23168713f, 0.30273858f, -0.03472816f, -0.19651538f, -0.10293707f, -0.41744363f, 0.14688548f, 
    -0.10058250f, -0.23716430f, 0.01764183f, -0.17131598f, -0.09997237f, -0.26122743f, -0.13123767f, 0.14603356f, 
    0.04270633f, 0.40025890f, -0.01267570f, 0.39889914f, -0.11127295f, -0.16292968f, 0.10988136f, -0.22931401f, 
    0.39113852f, -0.07926110f, 0.05435853f, 0.16526540f, 0.27549693f, -0.04008622f, -0.23499517f, -0.34550148f, 
    0.13306594f, 0.09598246f, 0.09352203f, 0.05956895f, 0.24099351f, 0.08194234f, 0.29909790f, 0.14202462f, 
    0.10917916f, -0.03982863f, 0.23102494f, -0.20080391f, -0.08075861f, 0.11023130f, 0.22622479f, 0.27104077f, 
    -0.02959055f, -0.02861261f, 0.21518825f, 0.14218055f, 0.04636886f, 0.21281931f, 0.22167659f, 0.07320178f, 
    -0.12010803f, 0.31982392f, -0.16700691f, 0.03892390f, 0.13930701f, -0.14968398f, 0.29197311f, -0.17626157f, 
    -0.14222866f, 0.55527139f, -0.10293761f, 0.22024101f, 0.42204049f, -0.03244073f, 0.17443180f, 0.32457170f, 
    -0.06368687f, -0.11709267f, 0.02841559f, 0.01845555f, 0.20459640f, -0.02470988f, 0.31886566f, -0.08735910f, 
    -0.38225994f, -0.24109979f, -0.19849521f, -0.16818011f, 0.25742003f, -0.24990781f, -0.01738749f, 0.26587611f, 
    0.08762015f, 0.01418529f, -0.17214957f, 0.16811293f, 0.43818951f, -0.42091531f, -0.36553082f, -0.14962780f, 
    0.02003040f, 0.08716612f, -0.18523978f, 0.02466187f, -0.13650048f, -0.21339855f, 0.09405153f, 0.21878575f, 
    -0.10930497f, 0.23967652f, 0.22435802f, -0.26740426f, 0.10533171f, -0.18930280f, 0.00639633f, 0.23544118f, 
    -0.03340569f, -0.04954911f, -0.00927484f, 0.04559443f, -0.02827118f, 0.26290488f, 0.00833934f, -0.11520696f, 
    -0.06859984f, 0.09299281f, -0.07154702f, 0.05038806f, -0.16134815f, -0.08912949f, 0.29520303f, 0.01574693f, 
    -0.17389981f, 0.27237141f, -0.26840886f, -0.03390109f, 0.48740062f, -0.00873835f, 0.16956791f, 0.02851744f, 
    -0.02425370f, 0.27059075f, -0.02623148f, 0.02259349f, -0.02261851f, 0.04463162f, -0.09775587f, -0.17165634f, 
    -0.06657381f, -0.24578232f, 0.06299356f, 0.17856050f, 0.23603402f, 0.13135809f, -0.38275480f, 0.01305925f, 
    0.32957199f, -0.07730682f, -0.07450482f, -0.02220488f, -0.11687973f, 0.13654713f, 0.22749078f, 0.01465614f, 
    0.23595266f, 0.09450213f, 0.15137471f, 0.09446763f, -0.31233090f, 0.17008354f, -0.03507161f, -0.04814113f, 
    0.01266081f, -0.28166136f, 0.28195009f, 0.24214426f, -0.14981478f, -0.08765677f, 0.02710194f, 0.01581388f, 
    0.04034326f, -0.10620614f, -0.15273599f, 0.21698804f, 0.09814215f, 0.14619891f, -0.01918703f, -0.04265251f, 
    -0.14693387f, 0.17611970f, 0.26185200f, 0.05864897f, -0.01928694f, 0.10687853f, 0.00750937f, -0.01150692f, 
    0.31715035f, 0.22836412f, 0.15249100f, -0.14896408f, -0.07253277f, 0.05660749f, 0.45385668f, -0.22560647f, 
    -0.06155650f, -0.26517400f, 0.09321634f, 0.06277159f, -0.01668471f, 0.16716769f, 0.16935760f, 0.11450864f, 
    -0.41397211f, 0.18643869f, -0.30167872f, 0.05825054f, -0.10186645f, -0.22359125f, -0.09572028f, -0.11354062f, 
    -0.10528987f, -0.10439456f, 0.18198225f, -0.06925823f, -0.31542644f, -0.27949679f, -0.03269224f, 0.11140636f, 
    -0.02574960f, 0.19661894f, 0.14370322f, -0.07595073f, -0.16708012f, 0.01302470f, -0.10427084f, 0.03169918f, 
    0.17046803f, 0.19583246f, -0.06299833f, 0.00859595f, 0.25342354f, -0.25036359f, -0.01323290f, 0.05207459f, 
    0.37600034f, 0.11687074f, 0.17131189f, 0.13086168f, -0.03481891f, 0.45813882f, -0.09974690f, 0.27033570f, 
    0.37875202f, -0.26472399f, 0.05173676f, -0.04181113f, 0.44158074f, 0.08156561f, -0.24941351f, -0.24402852f, 
    0.19588621f, -0.52251434f, 0.28664637f, 0.25319275f, -0.25966039f, 0.01784240f, 0.07678307f, -0.18144922f, 
    -0.07897291f, -0.07704876f, 0.08590146f, 0.07950440f, 0.00551637f, 0.07652370f, 0.10699680f, -0.05427716f, 
    0.20336673f, -0.39570266f, 0.17696583f, -0.34265110f, -0.20652799f, 0.17453328f, 0.22500896f, -0.01271165f, 
    -0.13858312f, -0.12861127f, 0.28265885f, 0.05751103f, 0.00304922f, -0.11032447f, 0.07974001f, -0.08262739f, 
    -0.21735555f, 0.03477264f, 0.04204209f, -0.40473193f, 0.28604978f, 0.08332511f, 0.16371700f, 0.24922664f, 
    0.05207947f, 0.43762130f, -0.22449465f, 0.07676993f, 0.22935440f, 0.09173347f, -0.16274157f, -0.18265042f, 
    0.20135051f, 0.11040592f, -0.01653361f, -0.03703889f, -0.06531281f, -0.01995716f, -0.11569607f, 0.04725238f, 
    0.16528967f, -0.13973105f, -0.13052610f, -0.08422803f, 0.24915747f, 0.07537092f, 0.30311593f, -0.03666179f, 
    -0.10443613f, -0.10112824f, 0.00363785f, -0.01790833f, -0.25582963f, 0.05283677f, -0.40189067f, 0.29983455f, 
    -0.10245582f, -0.01647268f, -0.03711775f, -0.03286993f, -0.07922923f, -0.23475179f, -0.03371606f, 0.01688564f, 
    0.29979742f, -0.22048411f, 0.34000236f, 0.00556829f, -0.01908059f, -0.05480139f, 0.27012500f, -0.03298408f, 
    0.01423161f, -0.03256302f, -0.28382853f, 0.39143002f, 0.34626347f, 0.01679668f, -0.18279938f, -0.02726498f, 
    -0.08884103f, 0.03590650f, -0.14802845f, 0.09373243f, 0.25956807f, 0.15324973f, 0.07239360f, 0.10783554f, 
    0.01669371f, 0.11127622f, 0.01107821f, -0.07496233f, -0.06607614f, -0.02722359f, -0.13309780f, 0.03592015f, 
    0.30366734f, 0.02733088f, 0.26185200f, -0.08386562f, -0.11347070f, -0.22543441f, 0.21896592f, -0.08700767f, 
    -0.00726205f, 0.24108551f, -0.03961292f, 0.04820217f, 0.36792156f, -0.17952642f, 0.29295552f, 0.25395617f, 
    -0.11503927f, 0.02643270f, -0.13612646f, 0.28557834f, 0.05495887f, 0.02797223f, 0.10211637f, 0.10770312f, 
    -0.08774358f, 0.30780911f, 0.02843630f, 0.13475892f, 0.00209717f, 0.11213281f, 0.02032950f, 0.10056461f, 
    0.14581072f, -0.01250455f, 0.08612191f, -0.22567131f, 0.11299265f, -0.14783722f, 0.30297357f, 0.17161512f, 
    0.30227321f, -0.02214151f, -0.06828810f, -0.02014941f, -0.01903771f, -0.02135409f, -0.21434568f, -0.16706745f, 
    0.05876686f, 0.32028177f, 0.17533068f, 0.10011984f, -0.17330208f, 0.02548839f, 0.27549544f, 0.10051949f, 
    -0.09856386f, -0.06545988f, 0.26275641f, -0.07056999f, -0.01797324f, 0.03682375f, 0.29178500f, 0.38101444f, 
    0.17891492f, 0.11100230f, -0.04248831f, 0.12208126f, 0.02658363f, 0.41154155f, 0.01932376f, 0.09683556f, 
    0.10107595f, 0.33011785f, -0.10776563f, -0.00965925f, -0.03282895f, -0.22292453f, 0.04168581f, -0.20396781f, 
    0.09097588f, -0.00556144f, -0.04384761f, 0.10400835f, -0.14237623f, 0.00267116f, 0.10671543f, 0.09302998f, 
    0.07312362f, -0.23783544f, 0.14761564f, 0.06836596f, 0.33903885f, -0.10395972f, 0.06820406f, -0.18872645f, 
    -0.40946907f, -0.29561028f, -0.15655881f, -0.30451122f, 0.08725916f, -0.03397502f, -0.03776889f, 0.35075045f, 
    0.23019205f, -0.09598798f, -0.07329885f, -0.28981563f, -0.32282537f, 0.19182877f, 0.10137039f, 0.17892893f, 
    0.18612967f, 0.15951863f, 0.10715811f, -0.08129974f, -0.02115234f, 0.15503581f, 0.04260717f, -0.17831144f, 
    0.06141035f, -0.27614486f, 0.11569424f, 0.27220523f, 0.03617163f, 0.01324397f, -0.06568669f, 0.15566802f, 
    0.20533969f, -0.04030693f, -0.25283495f, 0.26126432f, 0.05612468f, 0.40517557f, -0.13225131f, 0.04278651f, 
    0.12214397f, 0.07867678f, 0.29873157f, -0.12529109f, 0.25437194f, 0.18529567f, -0.26442754f, -0.03303466f, 
    0.30287081f, -0.05091996f, 0.15780331f, -0.04071574f, -0.25862801f, -0.07119488f, 0.35215998f, -0.26422557f, 
    0.07911570f, -0.35726219f, 0.08973772f, -0.10895721f, 0.12788196f, -0.13080989f, 0.10186614f, 0.12370153f, 
    -0.03126780f, 0.19283696f, -0.25580651f, 0.11499166f, 0.00138504f, 0.17611301f, 0.14249088f, 0.08505096f, 
    0.31897670f, -0.01874839f, 0.18726857f, -0.23218255f, -0.14875534f, 0.01882472f, 0.26498151f, 0.02841778f, 
    0.14638381f, 0.16710143f, -0.11055429f, -0.09305651f, -0.26434264f, 0.05400499f, -0.03286111f, -0.07977337f, 
    -0.01459134f, 0.44718152f, 0.12078189f, 0.05812558f, 0.18288977f, -0.08699827f, 0.23700003f, 0.15699568f, 
    -0.07941366f, 0.08765626f, -0.60513794f, 0.20153169f, -0.03024677f, 0.21998394f, 0.05822309f, -0.02280954f, 
    0.25492972f, -0.02295943f, 0.03170343f, -0.11429490f, 0.08375477f, 0.19967088f, 0.13646078f, -0.23745722f, 
    0.53147799f, 0.17922175f, 0.21070603f, -0.04493668f, -0.04790571f, -0.05336203f, 0.30046988f, -0.12871683f, 
    -0.11911809f, -0.09198805f, 0.08180420f, -0.16996375f, -0.25829297f, -0.06864459f, 0.23161875f, 0.11977106f, 
    -0.38380641f, -0.03671106f, 0.16838355f, 0.18114029f, 0.07018688f, -0.28601095f, -0.25034162f, 0.16101979f, 
    -0.04116005f, -0.02898622f, 0.10388309f, -0.05516541f, -0.09950821f, 0.03493296f, -0.01077270f, -0.04475717f, 
    -0.11239922f, 0.04772233f, -0.06961223f, 0.03795634f, 0.05446261f, 0.10390697f, -0.13984530f, 0.03290193f, 
    -0.05681355f, 0.02172033f, 0.01724121f, -0.03978556f, 0.03287194f, -0.09403410f, -0.00212065f, -0.05786451f, 
    -0.04830001f, 0.05733138f, -0.01161811f, 0.04038629f, -0.06298333f, 0.04705071f, 0.00146469f, -0.10213351f, 
    -0.14776270f, -0.13576353f, 0.00086406f, -0.09565167f, 0.07808299f, -0.04427354f, -0.11268853f, -0.09523038f, 
    -0.12519571f, -0.11068396f, 0.05751521f, 0.09995367f, -0.03591028f, -0.05280736f, 0.08328113f, 0.07486670f, 
    -0.02431747f, -0.02535287f, 0.10596963f, -0.09804070f, -0.10493699f, -0.01623138f, 0.00850088f, 0.13239488f, 
    0.07836448f, -0.11067595f, -0.04636360f, 0.00478932f, -0.09331703f, -0.04070434f, -0.08762486f, 0.06851993f, 
    -0.10594130f, 0.05411240f, -0.10569403f, -0.04441321f, 0.00612538f, -0.10031967f, -0.08443812f, -0.08677441f, 
    -0.01389608f, -0.12113471f, -0.07209247f, -0.02441067f, 0.10775751f, -0.01192017f, -0.06068334f, -0.03003050f, 
    -0.11293517f, 0.02485360f, 0.01206684f, 0.04702777f, 0.07109430f, 0.09046096f, -0.12426575f, 0.10221989f, 
    0.05133176f, -0.05751115f, 0.04344523f, 0.09170797f, -0.08900248f, -0.11176671f, -0.00015207f, -0.01883729f, 
    0.09761955f, -0.04026952f, -0.09279676f, 0.03904179f, -0.05386978f, 0.07910489f, -0.12148337f, -0.06611456f, 
    -0.09025067f, -0.11325479f, 0.05530652f, -0.10461923f, 0.05133565f, -0.10088697f, -0.07896622f, 0.02827013f, 
    -0.03200713f, -0.05019267f, 0.12485512f, 0.04789719f, -0.01520737f, 0.02388075f, 0.04549713f, -0.07494301f, 
    -0.05211866f, -0.10489066f, 0.03862557f, -0.09576617f, 0.01735659f, -0.06497432f, -0.08894476f, -0.09116736f, 
    -0.00528399f, -0.01753023f, 0.01681860f, -0.08170422f, 0.07181928f, 0.03592415f, -0.01768431f, -0.10841458f, 
    -0.05994358f, 0.08505847f, 0.08674081f, 0.00963033f, -0.00555150f, -0.09394293f, 0.02639563f, -0.06175930f, 
    -0.05721666f, -0.02164333f, -0.13029927f, 0.09622825f, 0.09392694f, -0.04980325f, 0.09704635f, 0.05099831f, 
    0.04005363f, -0.08055878f, -0.03082213f, -0.01603139f, -0.00686811f, -0.07485968f, -0.12629129f, 0.06486664f, 
    -0.11401118f, -0.04427002f, -0.04002469f, -0.04234020f, -0.07466196f, -0.02546278f, 0.04657836f, -0.12270659f, 
    0.04365101f, -0.11400296f, -0.03952974f, -0.01614223f, -0.02354257f, -0.02591525f, 0.03230661f, -0.11250985f, 
    0.04141141f, -0.03001569f, -0.06545708f, 0.11075133f, -0.05751251f, -0.12351021f, -0.09555642f, -0.00564337f, 
    0.01049483f, -0.03699158f, -0.04426002f, 0.12196021f, -0.12626573f, -0.08916969f, -0.12171286f, 0.04540478f, 
    0.04661229f, 0.08127750f, -0.06545901f, -0.01071672f, 0.05679660f, -0.04000914f, -0.06897385f, -0.07144492f, 
    -0.00248286f, 0.01971889f, 0.03853748f, -0.15406589f, 0.05915310f, -0.11980421f, 0.03577538f, 0.01191549f, 
    -0.11251848f, -0.02292504f, 0.01185805f, -0.10443603f, 0.00055308f, -0.10635807f, -0.04563889f, -0.08346902f, 
    0.00661797f, -0.06493790f, -0.08569075f, -0.12493010f, -0.01159266f, 0.04726555f, -0.01301814f, -0.07126663f, 
    -0.10504146f, -0.10340492f, -0.11203365f, -0.00464906f, -0.03547306f, -0.04555846f, 0.08677777f, -0.10455637f, 
    0.05423920f, 0.11085096f, 0.00468919f, -0.03170143f, -0.06664836f, 0.07453617f, 0.00349198f, 0.01066743f, 
    0.06765632f, 0.00366650f, -0.09829186f, -0.02010220f, -0.12370982f, 0.03028714f, -0.09719631f, -0.06627174f, 
    0.01524218f, -0.10067363f, -0.15057954f, 0.00402017f, -0.00543326f, 0.07907866f, -0.01856922f, -0.01192559f, 
    -0.17882389f, 0.07734269f, 0.20960642f, 0.17799725f, 0.22057948f, 0.07907583f, 0.18775843f, 0.11462031f, 
    0.03593126f, -0.05288962f, -0.14519800f, -0.30374178f, -0.02968694f, 0.08938894f, 0.24172759f, 0.17326778f, 
    -0.02524748f, 0.33755061f, 0.13215227f, -0.02693082f, -0.11089253f, 0.08217453f, -0.04398006f, 0.07357880f, 
    -0.21055362f, 0.00833119f, -0.09579279f, -0.06572982f, -0.06755573f, -0.52089506f, 0.21372886f, -0.04365853f, 
    -0.16923977f, 0.11226425f, -0.06222408f, 0.08409949f, -0.22232026f, 0.08172272f, 0.38896421f, 0.25820380f, 
    -0.11749240f, 0.35711870f, -0.11953831f, -0.21586838f, -0.26468834f, -0.03978312f, 0.12878460f, 0.25852436f, 
    0.05361125f, 0.06634086f, 0.08400013f, -0.03489356f, -0.02663592f, -0.14002283f, -0.30020255f, 0.15648893f, 
    0.14709164f, 0.19305687f, -0.00020482f, 0.37781972f, 0.10902581f, -0.20144117f, -0.19362187f, -0.03124570f, 
    -0.39855361f, 0.06589973f, 0.44261739f, 0.06109252f, -0.08197800f, -0.31216529f, 0.02862403f, 0.00725631f, 
    0.01249688f, 0.09392057f, 0.22652927f, -0.22615865f, 0.15430875f, -0.24264814f, 0.31492794f, 0.35617933f, 
    0.26998946f, 0.28205130f, -0.03045592f, 0.10680652f, 0.36146972f, -0.29555485f, -0.11677691f, 0.03675479f, 
    -0.03186756f, 0.01602748f, 0.13070671f, 0.10295049f, -0.03549512f, -0.08847427f, -0.08192948f, 0.37113154f, 
    -0.01314549f, 0.07963993f, 0.04755615f, 0.09038074f, -0.17295764f, 0.35891530f, 0.19940606f, -0.31893337f, 
    -0.40731403f, -0.11860225f, 0.23363285f, -0.09867158f, -0.33314767f, -0.06803413f, -0.10220518f, 0.16838321f, 
    0.10345326f, -0.10667973f, 0.10261256f, 0.14897634f, 0.35368195f, 0.05089632f, -0.00629517f, -0.27235919f, 
    -0.23964798f, -0.62683988f, 0.03204627f, -0.20224744f, -0.25243548f, 0.12378736f, 0.00790781f, 0.15364468f, 
    -0.39853853f, -0.00485632f, -0.04559704f, -0.01780401f, 0.35799956f, -0.11676772f, -0.41055596f, -0.21028472f, 
    -0.03440435f, 0.15150252f, -0.15232791f, 0.03075281f, -0.22452852f, 0.00988590f, 0.02078332f, 0.20618515f, 
    -0.16608621f, 0.19803017f, 0.13746697f, -0.34515336f, 0.24253139f, 0.10038157f, 0.09309907f, 0.02792910f, 
    -0.06763244f, -0.00666783f, 0.27415776f, -0.13495725f, 0.07461812f, 0.40669447f, 0.01115541f, 0.13576475f, 
    -0.15200378f, -0.05823347f, -0.39332116f, -0.03607666f, -0.10790683f, -0.19722250f, 0.19472036f, 0.03172519f, 
    -0.20421359f, 0.32578266f, -0.09263571f, 0.09905715f, 0.37851295f, -0.02065654f, -0.14519054f, 0.12389891f, 
    -0.04681556f, 0.12923300f, 0.00209419f, -0.28310943f, -0.09716319f, -0.14445938f, 0.06878803f, -0.18592645f, 
    0.03588412f, -0.01417681f, 0.08803687f, 0.03874237f, 0.04948585f, -0.04439117f, 0.00644944f, -0.15980364f, 
    0.55955005f, 0.10276623f, -0.26658279f, 0.14649534f, -0.09476834f, 0.08465977f, 0.06548607f, 0.15558054f, 
    0.32053655f, -0.17771317f, -0.08071942f, 0.28647408f, -0.14159900f, 0.21709746f, -0.22612327f, -0.10224696f, 
    0.17549951f, -0.23599796f, 0.05126235f, 0.29337782f, -0.13034894f, 0.01432833f, -0.11745142f, -0.10451295f, 
    0.18574068f, 0.06739399f, -0.10872690f, 0.27429456f, 0.06959178f, 0.51769501f, 0.01661018f, -0.21517222f, 
    -0.07152163f, 0.03242515f, 0.23884395f, -0.13423751f, 0.04931124f, 0.15605319f, -0.29152855f, 0.16094223f, 
    0.18799683f, 0.48855188f, 0.25290468f, -0.22334649f, -0.12243836f, 0.01875721f, 0.50154221f, -0.28430355f, 
    0.05042295f, -0.15290111f, -0.11304548f, 0.11107707f, 0.15674749f, 0.11316668f, 0.04676029f, 0.06360436f, 
    -0.15066229f, -0.01911778f, -0.14572200f, -0.03792759f, -0.20585696f, -0.09179345f, 0.04961255f, -0.19928280f, 
    0.05946195f, -0.07903385f, -0.19520228f, -0.18971385f, -0.17853990f, 0.00282413f, 0.04551737f, 0.12779087f, 
    -0.21194150f, 0.05859501f, -0.25328267f, 0.00472736f, 0.15120567f, 0.09079702f, -0.16278340f, 0.18687554f, 
    0.12638426f, -0.21874110f, 0.01321616f, 0.02634657f, 0.22884837f, -0.24352922f, 0.09719671f, -0.07207806f, 
    0.08288781f, -0.00777599f, 0.26351953f, 0.18881048f, -0.05770832f, 0.00364020f, -0.03571034f, -0.15832408f, 
    0.04976004f, 0.22710744f, 0.22474952f, -0.07302121f, 0.42484972f, 0.09648684f, 0.31758219f, 0.10897081f, 
    -0.08423650f, 0.41878527f, -0.06667942f, 0.03465080f, -0.04950382f, -0.00186069f, -0.29827702f, 0.07969698f, 
    -0.04321778f, 0.12956856f, 0.04058716f, -0.24914469f, 0.01967209f, -0.11176971f, -0.39575449f, -0.25406438f, 
    0.02075616f, 0.31359139f, -0.20588537f, 0.08946883f, 0.18152945f, 0.10743853f, 0.25983766f, 0.05544044f, 
    0.12293542f, -0.00870401f, -0.14453700f, -0.12219336f, 0.01133616f, -0.04758601f, 0.00057661f, -0.11112997f, 
    -0.10775248f, 0.05616078f, -0.06567703f, 0.01377950f, 0.08007589f, -0.06400374f, 0.10260213f, -0.09307783f, 
    0.07907476f, 0.07808743f, 0.08969785f, 0.09003580f, -0.12101168f, -0.04206583f, -0.11194980f, 0.00615856f, 
    -0.12476394f, -0.07826367f, -0.14600961f, 0.02637034f, -0.01246786f, 0.09740514f, 0.01337689f, 0.08858795f, 
    -0.08158389f, -0.03261863f, -0.10121955f, -0.04157735f, -0.15896825f, 0.05807127f, -0.02943968f, -0.14763932f, 
    -0.01317571f, -0.13500650f, -0.02189665f, -0.11267869f, -0.03390298f, 0.03518569f, 0.02742710f, 0.08096800f, 
    0.00571297f, -0.05489143f, 0.08238399f, -0.06046686f, 0.08401465f, 0.03782703f, 0.05250348f, 0.09063041f, 
    -0.10695722f, -0.11071800f, -0.04609060f, 0.00591178f, -0.02653619f, 0.10806060f, -0.11419091f, -0.12706661f, 
    0.08835574f, -0.01685938f, 0.06919723f, -0.01652330f, 0.02725492f, -0.03831326f, -0.03778101f, -0.12098397f, 
    -0.02422064f, -0.11148660f, -0.02367750f, -0.10691990f, 0.10115115f, -0.01218338f, 0.01834574f, 0.06770094f, 
    -0.02137230f, 0.07615075f, 0.03638827f, -0.06400465f, 0.04306964f, -0.04382860f, 0.09529682f, -0.12791242f, 
    -0.09954806f, -0.04887739f, 0.05335596f, -0.10982343f, -0.03267350f, -0.12020329f, -0.00385642f, -0.15360998f, 
    0.06618321f, -0.13011421f, 0.10541156f, 0.01283154f, -0.03554139f, 0.06917750f, -0.02677353f, -0.05293600f, 
    -0.03214267f, -0.04383377f, -0.14611997f, -0.02943130f, 0.01928751f, -0.04489618f, -0.00034068f, -0.07904148f, 
    -0.07354189f, 0.04370439f, -0.09915391f, 0.06847664f, -0.13193192f, -0.09662662f, 0.12632070f, -0.05913391f, 
    -0.08692610f, -0.01059767f, -0.06057540f, -0.04385497f, -0.04178840f, 0.02081778f, -0.11169499f, -0.11845362f, 
    0.09790127f, -0.03747948f, -0.01919929f, -0.14891441f, 0.15982434f, 0.14602859f, -0.01755391f, 0.09660520f, 
    0.10372672f, -0.13283075f, -0.17148449f, -0.13052616f, 0.57416642f, 0.04772808f, -0.04493436f, -0.06644382f, 
    0.09565008f, -0.14254177f, -0.02087346f, 0.17337216f, -0.08277182f, 0.23831946f, 0.05039132f, -0.25602177f, 
    -0.11417958f, -0.03228135f, -0.01113160f, 0.05385420f, 0.01386741f, -0.12801905f, -0.00576363f, 0.05388426f, 
    -0.22081608f, 0.11271483f, -0.09013987f, 0.04397504f, 0.13872088f, -0.01926689f, 0.29109195f, 0.12921838f, 
    0.14440863f, 0.36121833f, -0.07471386f, 0.09892815f, 0.07797246f, 0.07013636f, -0.29167569f, 0.33203229f, 
    -0.01943174f, 0.01629522f, 0.03628697f, -0.16695389f, -0.26071090f, -0.21112649f, 0.02873177f, 0.02608381f, 
    -0.03160290f, 0.39693144f, -0.23334426f, 0.48111868f, 0.22526383f, -0.25366867f, 0.00443612f, 0.05434930f, 
    0.02820674f, -0.05925690f, 0.28741607f, 0.16797245f, 0.24541554f, -0.02476086f, 0.01933602f, -0.33140573f, 
    0.04169384f, 0.12935561f, 0.31827268f, -0.09553763f, 0.05421538f, 0.10022747f, 0.35820645f, 0.18368497f, 
    0.04987559f, 0.34661022f, 0.12188439f, -0.17977421f, -0.08196884f, 0.35316625f, 0.12828274f, 0.09586785f, 
    -0.18400612f, -0.07254567f, 0.16200526f, -0.10210530f, 0.07019410f, 0.05071706f, 0.27213740f, 0.35985708f, 
    -0.05405181f, 0.13431698f, -0.20778866f, -0.04647900f, -0.22994822f, -0.05393140f, 0.02855797f, -0.03027492f, 
    -0.10069710f, -0.15729687f, 0.21655779f, 0.05488371f, 0.47648662f, -0.00331812f, -0.10460693f, 0.42434102f, 
    -0.05803223f, 0.06270773f, 0.12099556f, 0.24491000f, 0.24950270f, 0.16104949f, -0.04050454f, 0.04122169f, 
    -0.07288849f, -0.10511007f, 0.24581183f, -0.14715923f, 0.01724337f, -0.09499858f, -0.09465807f, 0.16531986f, 
    -0.15509109f, -0.08116756f, 0.16984081f, 0.25624681f, 0.18154874f, -0.09566478f, 0.26179937f, -0.04188015f, 
    0.26898533f, -0.25824070f, 0.19797456f, -0.09491976f, -0.18978718f, 0.00288309f, -0.02002157f, -0.06396325f, 
    0.19015339f, 0.37958905f, -0.07086001f, 0.06603569f, -0.09000415f, -0.12621765f, -0.10799971f, -0.25562429f, 
    0.01320660f, -0.09645656f, -0.22781901f, 0.12249985f, 0.08794875f, -0.15745892f, 0.14102696f, 0.19121222f, 
    0.07519662f, -0.22886662f, 0.13509570f, -0.10629223f, -0.29704273f, 0.26785865f, 0.00871758f, 0.16850783f, 
    -0.03017993f, 0.25585309f, 0.20881177f, -0.21342349f, -0.09246452f, -0.07655262f, -0.12193415f, 0.15333691f, 
    -0.01591246f, -0.07094669f, -0.09608535f, 0.16726409f, 0.05416859f, 0.15280694f, -0.09051505f, 0.34827167f, 
    0.13919085f, 0.08282613f, 0.00968651f, 0.12872025f, -0.56329501f, -0.02307118f, -0.12111432f, -0.25791410f, 
    -0.10503247f, 0.06196590f, 0.32232237f, 0.27082700f, 0.02500817f, -0.32367915f, 0.14183876f, -0.10285582f, 
    0.10527427f, 0.14341465f, 0.28238079f, -0.06774455f, -0.35179767f, -0.13551617f, 0.06989533f, -0.02630022f, 
    0.17851368f, 0.28133404f, 0.00290003f, -0.01797804f, 0.07293145f, -0.32306090f, 0.14388582f, 0.21034950f, 
    0.09353742f, 0.12389312f, -0.00855191f, -0.01547878f, -0.06193360f, 0.10433837f, 0.18731239f, 0.30912778f, 
    0.20454656f, -0.10060854f, 0.15186121f, 0.01381787f, -0.16882916f, 0.34051800f, -0.08528326f, -0.34942049f, 
    0.09314810f, -0.15627958f, 0.20436186f, 0.02352673f, -0.31621656f, -0.05344881f, 0.14952785f, -0.01445149f, 
    0.08951964f, -0.14668818f, -0.03296236f, 0.26523781f, 0.35147488f, 0.29023656f, -0.05699209f, -0.03355919f, 
    -0.16215968f, -0.47572470f, 0.09433781f, -0.21384595f, -0.27769905f, 0.08760574f, -0.19271749f, 0.18959397f, 
    0.01989697f, 0.09527398f, 0.01868979f, -0.09712859f, 0.01228355f, 0.09353346f, -0.04752977f, 0.06855299f, 
    -0.01394605f, 0.08177718f, 0.08477447f, -0.12332110f, -0.03111004f, -0.12918809f, -0.07425726f, 0.06848472f, 
    -0.06706672f, -0.09081704f, -0.05920998f, 0.05903602f, -0.02315038f, -0.05040300f, -0.02113603f, 0.01089155f, 
    -0.00653285f, 0.00313765f, -0.04727723f, -0.07219784f, 0.09788743f, 0.02654872f, 0.04174128f, -0.00674353f, 
    0.04784308f, -0.07877949f, -0.13726194f, -0.06642950f, -0.06962682f, -0.11646773f, -0.09472681f, 0.05778757f, 
    -0.07688548f, 0.02304510f, 0.02297261f, -0.05761344f, -0.01415321f, -0.02022789f, -0.04487732f, 0.03851847f, 
    0.09913161f, 0.11235511f, 0.00974235f, 0.06656412f, -0.11630834f, 0.06451196f, 0.05842238f, -0.06157978f, 
    0.02829032f, 0.07173023f, -0.05492208f, -0.03513918f, 0.07750790f, -0.12569535f, 0.09905571f, -0.10396016f, 
    0.31787664f, -0.07703760f, -0.26183766f, 0.15692680f, 0.32739037f, 0.51787323f, -0.13510843f, 0.01512860f, 
    -0.10073326f, -0.16422319f, 0.00117030f, 0.32708904f, -0.02678948f, 0.36095050f, -0.08838733f, -0.02933303f, 
    -0.01067265f, -0.29549190f, 0.00260713f, 0.10040379f, -0.37777951f, 0.30010423f, -0.07066168f, -0.12717463f, 
    0.26303297f, -0.05615922f, 0.14031236f, 0.15371069f, 0.00764611f, 0.08405629f, 0.02289864f, -0.13211918f, 
    0.07162008f, 0.23094568f, -0.01766237f, 0.08868513f, 0.18942849f, -0.17978303f, 0.14105690f, 0.40828204f, 
    -0.05150396f, 0.13688837f, -0.17550585f, 0.25542909f, 0.05791086f, -0.09346954f, -0.04520077f, -0.02916713f, 
    0.12180912f, 0.00922997f, 0.09919883f, 0.16615573f, 0.00810152f, 0.00361249f, -0.09786297f, 0.26443520f, 
    0.18379286f, 0.49189427f, -0.00251175f, -0.14006101f, 0.14598319f, 0.06640884f, 0.36027086f, 0.00224529f, 
    -0.02117021f, -0.06651255f, 0.04639857f, 0.39305845f, 0.09514782f, -0.13697614f, 0.24973722f, 0.17428860f, 
    0.17840691f, -0.10944726f, 0.13286045f, 0.10928813f, -0.24263468f, 0.05294606f, 0.03232619f, -0.01675713f, 
    0.02487702f, 0.20174456f, 0.11670404f, 0.10631561f, -0.30661079f, -0.18012604f, 0.04428666f, 0.04164793f, 
    -0.11865089f, -0.08864979f, -0.06808375f, 0.01742801f, 0.05283304f, -0.46446052f, 0.36695126f, 0.00600767f, 
    0.05110309f, 0.03280562f, 0.17199315f, -0.08719140f, -0.35142255f, 0.24467237f, 0.05835522f, 0.15422733f, 
    0.02785674f, 0.32194671f, 0.04403275f, -0.25387430f, -0.49371248f, 0.01195466f, 0.15105222f, 0.26201934f, 
    -0.10671003f, 0.07980549f, 0.05808293f, 0.08637997f, 0.14325990f, 0.04359183f, 0.10316844f, 0.15419881f, 
    -0.02197549f, -0.07619435f, -0.11463755f, 0.13123873f, -0.05399541f, -0.01616679f, -0.08845451f, 0.12955669f, 
    -0.00797315f, 0.09783532f, -0.06474315f, -0.07335734f, -0.11308490f, 0.08158396f, -0.01915796f, -0.05866458f, 
    0.08192292f, 0.12068211f, -0.00471719f, -0.07998195f, -0.01979633f, -0.05150294f, -0.12078457f, -0.06828925f, 
    -0.07316816f, -0.10661471f, 0.05390050f, 0.03389886f, 0.08668943f, -0.08765697f, -0.06002252f, -0.06436679f, 
    -0.05955590f, -0.00977661f, 0.05631638f, -0.03966604f, 0.08093047f, -0.08954959f, 0.08831106f, 0.03050315f, 
    0.00014468f, -0.12489198f, -0.02636792f, -0.09446709f, -0.12369296f, -0.04724440f, -0.09538390f, -0.04155213f, 
    -0.07613385f, -0.01504846f, 0.05935490f, -0.00099194f, 0.09115228f, -0.06114401f, 0.09949790f, -0.03548647f, 
    0.03999586f, 0.02979895f, -0.08740063f, 0.07661098f, 0.00299288f, 0.03094120f, 0.07745732f, -0.07093662f, 
    -0.10702614f, 0.08020492f, 0.07209326f, 0.09246476f, -0.07049765f, -0.06305465f, -0.11025317f, -0.00698549f, 
    -0.05376954f, 0.11228088f, -0.06465194f, 0.02755308f, -0.09567592f, -0.02948581f, 0.07272413f, 0.03196378f, 
    -0.08095445f, -0.10095186f, 0.06295624f, 0.09834769f, -0.03603008f, -0.13155827f, -0.04151297f, -0.01538683f, 
    0.08932464f, 0.06690684f, -0.11752912f, -0.11956239f, -0.11351226f, -0.04476298f, 0.09284743f, -0.06357051f, 
    0.00602054f, 0.07642609f, -0.06086831f, 0.10180151f, -0.09793267f, 0.04585323f, -0.01329904f, 0.09818379f, 
    -0.07892826f, -0.11507624f, -0.07120227f, 0.04244234f, 0.08896569f, -0.08815780f, -0.09281871f, -0.01213556f, 
    -0.10845256f, -0.03569987f, 0.06119306f, -0.07460123f, -0.06694181f, 0.04549772f, -0.02563000f, 0.04111226f, 
    0.04039396f, 0.05640443f, -0.04655680f, -0.12143432f, -0.05774176f, -0.03374793f, 0.04725215f, -0.08393547f, 
    0.07336494f, 0.02499105f, -0.03309026f, 0.03317508f, 0.05271732f, -0.05418786f, -0.01217974f, 0.02923170f, 
    -0.07292354f, 0.05213730f, 0.25446877f, -0.14853217f, -0.27192184f, -0.01273717f, 0.16533494f, -0.01916671f, 
    0.06262161f, 0.16811006f, 0.33145311f, 0.16296777f, -0.16123210f, -0.13272972f, 0.10981900f, -0.19051158f, 
    0.02224720f, 0.21790275f, 0.18395154f, 0.07174580f, 0.00405654f, -0.01469092f, -0.06437673f, 0.07255374f, 
    0.09854295f, 0.06779133f, -0.09537119f, -0.10310135f, -0.06611950f, 0.42833546f, 0.08895025f, 0.30759174f, 
    0.15527907f, -0.32708293f, 0.11085221f, 0.00814150f, -0.26807728f, -0.04194691f, -0.29825118f, -0.11359841f, 
    0.12863460f, -0.47705185f, 0.08896101f, 0.25223988f, 0.09928782f, -0.00137241f, 0.07837249f, -0.15346985f, 
    0.03937667f, -0.14126486f, -0.00146438f, 0.24423453f, -0.14580813f, 0.10263260f, 0.11783824f, 0.02005963f, 
    0.04778887f, -0.21590123f, 0.24507077f, -0.30524948f, 0.00660765f, 0.10795747f, -0.21808864f, -0.30372712f, 
    -0.03875573f, -0.12039968f, 0.13039199f, 0.16669787f, 0.17690223f, -0.03592221f, -0.00816714f, 0.16702111f, 
    0.15851638f, -0.13962880f, 0.32806230f, 0.09421948f, -0.17716654f, 0.10426972f, -0.02761552f, -0.13667722f, 
    0.14424367f, -0.15713409f, 0.13658632f, 0.13764103f, -0.13275909f, -0.10242781f, -0.23527861f, -0.24571471f, 
    0.25051320f, -0.04413331f, 0.16299659f, 0.02037611f, -0.05396764f, 0.10285430f, 0.00342856f, 0.02316693f, 
    -0.10165239f, 0.15048191f, 0.32879519f, 0.03364137f, -0.18904887f, 0.15045705f, -0.35198826f, -0.08134415f, 
    -0.12878607f, -0.34155121f, 0.18516311f, -0.07680602f, -0.09054173f, 0.00977833f, 0.09166665f, -0.25652871f, 
    0.11885661f, -0.22708544f, 0.12091233f, 0.28855437f, 0.32916281f, 0.32172495f, -0.17983226f, 0.03247111f, 
    0.01173184f, -0.04452891f, -0.12116025f, -0.38666275f, -0.54398781f, 0.36367509f, 0.06009962f, -0.36342904f, 
    0.03474861f, 0.06535190f, 0.39723128f, -0.38692889f, -0.08158133f, 0.07976506f, 0.19595854f, -0.29710278f, 
    0.00896664f, 0.28654513f, 0.16281143f, -0.28368104f, 0.27854094f, 0.05813933f, -0.02112425f, 0.13804363f, 
    0.01967351f, 0.17405492f, 0.19681139f, 0.05345675f, 0.13367015f, 0.47755423f, 0.24105251f, -0.09352133f, 
    -0.11111507f, 0.09411289f, 0.14554894f, -0.08200444f, 0.02341829f, 0.35539690f, -0.01144918f, 0.30781767f, 
    0.10870218f, -0.03305044f, -0.16395643f, -0.09892550f, 0.01027639f, -0.16104878f, 0.02257202f, 0.00868746f, 
    0.19024852f, -0.04420417f, 0.17594250f, 0.16525015f, 0.64689142f, -0.03195584f, -0.44450387f, 0.15766962f, 
    -0.01065887f, -0.21969748f, -0.01998659f, -0.08579509f, -0.10282551f, -0.26636693f, 0.00967190f, -0.06038013f, 
    0.16527717f, 0.32146314f, 0.28737301f, 0.28831804f, 0.23292980f, 0.01310019f, -0.14718954f, -0.24067955f, 
    0.10683357f, -0.08059971f, 0.09509087f, 0.22179788f, 0.02737042f, -0.17957614f, -0.11638556f, -0.03446499f, 
    -0.00867110f, 0.09088340f, -0.04876016f, 0.07897773f, -0.09969977f, -0.22501858f, 0.12548706f, 0.10220473f, 
    -0.08325265f, 0.04216240f, 0.05078147f, -0.30599380f, 0.05759894f, -0.21731837f, 0.21058546f, 0.29465088f, 
    -0.31269851f, 0.00809008f, -0.03388451f, -0.07699177f, -0.09207952f, -0.08177068f, 0.22143929f, 0.00352512f, 
    0.08780021f, 0.09187261f, -0.14926751f, -0.10376011f, -0.11983083f, 0.00164127f, 0.10028248f, -0.11051036f, 
    0.04478710f, -0.01069647f, -0.21879484f, 0.00887544f, 0.34331372f, -0.08010299f, 0.24633478f, 0.17670292f, 
    -0.05830101f, 0.22188996f, 0.11332896f, -0.01949071f, -0.04712314f, 0.27101213f, -0.05070600f, -0.00319473f, 
    -0.19691603f, -0.31704488f, -0.19513120f, -0.05923338f, 0.13609633f, -0.04451231f, -0.18619227f, 0.18023960f, 
    0.24438764f, -0.04932468f, -0.37231463f, 0.04538992f, 0.09672286f, 0.08991463f, -0.14204651f, 0.11969299f, 
    -0.24338937f, 0.03855404f, -0.42357180f, 0.02367004f, 0.11129756f, 0.02139604f, -0.47215435f, -0.01916695f, 
    -0.09235785f, 0.24869636f, -0.19579436f, -0.00331778f, 0.14123607f, -0.10391010f, -0.22543260f, 0.05460529f, 
    0.01253974f, -0.01689576f, -0.21785575f, 0.24287985f, -0.11333555f, 0.36442041f, -0.29870653f, -0.15243979f, 
    0.06483737f, 0.13025342f, 0.17583475f, 0.04995389f, 0.30918318f, 0.05559040f, 0.23548329f, 0.21278393f, 
    -0.07454529f, 0.32624516f, -0.00618187f, 0.03308095f, -0.16670772f, 0.07728036f, 0.18288353f, -0.25592458f, 
    0.10965985f, 0.15902583f, 0.01328281f, -0.32569918f, -0.19122705f, 0.24693152f, 0.26840672f, 0.01304173f, 
    -0.08313395f, 0.11350309f, 0.04280348f, -0.19075286f, -0.18780415f, -0.10492179f, 0.18325797f, -0.09354842f, 
    0.46298248f, -0.04296109f, -0.15081407f, 0.22280690f, 0.28426754f, 0.50502950f, 0.11316061f, 0.02187794f, 
    -0.08608480f, -0.05896378f, -0.10835326f, 0.31048051f, 0.22794056f, 0.35479715f, 0.19763939f, 0.10085257f, 
    -0.02565263f, 0.03177897f, 0.02886731f, -0.10098365f, -0.44709930f, 0.65757078f, 0.13158341f, -0.13066852f, 
    0.02740032f, -0.08509941f, 0.11028776f, -0.02952675f, 0.11566455f, -0.20175031f, 0.36635432f, -0.14657870f, 
    0.13266863f, -0.04502288f, -0.11236840f, -0.05744148f, 0.16030107f, -0.22268139f, 0.22367865f, 0.39477873f, 
    0.17123371f, 0.16556089f, -0.11936561f, 0.32583499f, 0.18997471f, -0.03997501f, -0.05695381f, 0.29055437f, 
    0.06070364f, 0.20619991f, 0.07547995f, 0.08165764f, -0.10823394f, -0.07062295f, 0.00860478f, 0.41359031f, 
    0.34256145f, 0.57729292f, 0.05853260f, 0.11208522f, 0.23091021f, -0.27304682f, 0.11784332f, 0.07462939f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.00842757f, 0.08104885f, -0.17285538f, 0.10626691f, 0.13058464f, -0.04954947f, 0.22064140f, -0.08062230f, 
    0.16153075f, 0.01056214f, -0.11007742f, 0.10222608f, -0.04266600f, 0.05760525f, 0.04231231f, -0.15587687f, 
    0.15620929f, 0.05346894f, 0.01806686f, -0.10544517f, 0.01774017f, 0.08602895f, -0.06485910f, 0.08145081f, 
    -0.13544592f, -0.12906229f, -0.04795004f, 0.09659683f, 0.12602276f, -0.07324795f, -0.06047422f, 0.11307658f, 
    0.15099867f, 0.12047783f, -0.01951896f, 0.00060993f, 0.14201535f, 0.13526325f, -0.01187750f, 0.11871406f, 
    -0.09551903f, 0.01544240f, 0.01099096f, 0.20622642f, -0.03825962f, -0.00632394f, 0.04438539f, -0.08771929f, 
    0.05542523f, 0.02846502f, -0.02729106f, 0.16401574f, 0.22003882f, 0.02090714f, -0.10201846f, -0.07807149f, 
    -0.10404922f, -0.13095421f, -0.06132311f, 0.01658656f, 0.08538909f, -0.19797368f, -0.06276872f, -0.04440662f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.22439873f, 0.09532265f, -0.59970659f, -0.53324562f, -0.32668155f, -0.22999339f, 0.14102824f, -0.16125929f, 
    -0.18237673f, -0.02218239f, -0.01078840f, 0.03928065f, -0.04018435f, -0.07221841f, -0.21914361f, 0.00906050f, 
    0.20991705f, 0.00006348f, 0.17665187f, 0.04183100f, -0.04183584f, -0.04372386f, 0.07869387f, -0.45702404f, 
    0.10695367f, 0.27579394f, 0.12650579f, 0.11003627f, 0.02442195f, 0.22051153f, -0.42342058f, -0.09722456f, 
    -0.30373427f, 0.18406110f, 0.16022578f, 0.02517431f, -0.25099203f, -0.31145823f, 0.09584176f, -0.08352059f, 
    0.07471098f, 0.09958363f, 0.32773569f, 0.27535394f, -0.71600896f, -0.49964654f, -0.15460598f, -0.07328284f, 
    0.01095157f, 0.18739906f, 0.26561403f, 0.08164113f, -0.00299180f, 0.04675737f, 0.06609750f, 0.08156057f, 
    0.09689647f, 0.11237267f, -0.20163627f, -0.02559558f, 0.05685641f, -0.24768355f, -0.12950692f, 0.14575708f, 
    -0.20867477f, -0.44037759f, 0.34843844f, 0.19997142f, 0.02694573f, 0.16880955f, -0.15278564f, 0.27580124f, 
    -0.03859175f, 0.18980290f, 0.06160559f, 0.15643041f, 0.02317921f, -0.30927974f, 0.23508327f, -0.04767657f, 
    -0.08259945f, 0.03001595f, 0.33381650f, 0.01363343f, -0.08909852f, -0.06375244f, -0.09425575f, 0.14129545f, 
    0.00864065f, 0.27278879f, -0.06200832f, -0.30507734f, -0.18289807f, 0.06010141f, 0.46704027f, -0.06312720f, 
    0.03983568f, -0.00194840f, 0.17278852f, -0.04813641f, -0.04340470f, -0.33191946f, 0.06438982f, 0.06046699f, 
    -0.13980457f, -0.02556336f, -0.11020837f, -0.17472589f, 0.20933923f, 0.18628916f, 0.06043280f, -0.08198578f, 
    0.06527323f, -0.46739972f, -0.08836408f, 0.13186161f, 0.05099135f, -0.06928036f, 0.15731481f, 0.18274494f, 
    -0.08217694f, -0.02853872f, -0.29566979f, 0.14241207f, -0.47367099f, 0.05332585f, -0.60107940f, 0.07779546f, 
    0.04641266f, -0.23069018f, -0.83222920f, -0.10835443f, 0.03032589f, -0.16039273f, -0.10996337f, -0.00965265f, 
    -0.65503287f, -0.13143112f, 0.11232010f, -0.21745789f, 0.01699896f, -0.29742882f, 0.07055368f, 0.08332786f, 
    -0.31741309f, -0.01959539f, 0.39801595f, -0.10776146f, -0.16494261f, -0.03158085f, -0.15872639f, 0.28053606f, 
    -0.01495296f, 0.06810982f, -0.13732009f, -0.35871226f, 0.00167600f, -0.38301560f, -0.46842358f, 0.18721566f, 
    0.19512923f, -0.05595704f, -0.46223411f, -0.35162133f, 0.15639912f, 0.09776580f, 0.01384708f, 0.06018384f, 
    0.02981675f, 0.08627260f, 0.03989432f, 0.42811930f, -0.10067178f, 0.18929146f, -0.13206214f, -0.10874613f, 
    -0.00672753f, -0.19306408f, -0.15927964f, 0.26492411f, 0.35079426f, 0.03707388f, -0.44375470f, 0.18337254f, 
    0.11253050f, -0.04354009f, 0.16840462f, 0.36007902f, -0.24505994f, -0.22690541f, -0.15393640f, -0.70909542f, 
    -0.12553054f, 0.13630858f, -0.45079416f, 0.31139848f, -0.23366039f, -0.13738938f, 0.14259984f, 0.32803237f, 
    0.02683376f, -0.52258515f, 0.08489590f, 0.28022182f, -0.09545613f, 0.26946166f, -0.51958835f, -0.00917549f, 
    -0.28575781f, 0.24119069f, -0.29852399f, -0.03178417f, 0.12412946f, -0.17261983f, -0.02928166f, -0.42952198f, 
    -0.11687975f, 0.18117918f, -0.37193263f, -0.10381623f, -0.20050323f, 0.21969393f, 0.00086824f, 0.06972325f, 
    -0.14617305f, -0.26112863f, 0.10558738f, 0.26124322f, -0.07719890f, 0.08530738f, 0.04111549f, -0.10295646f, 
    -0.06784852f, -0.06524347f, 0.15461203f, 0.04824103f, -0.23810606f, -0.26601073f, -0.06347416f, 0.10185573f, 
    -0.03194774f, 0.07587624f, -0.00956955f, -0.37154889f, 0.08272781f, 0.11531618f, -0.10268923f, 0.24106839f, 
    -0.01929519f, 0.04444289f, -0.28643751f, -0.21140534f, -0.17422445f, 0.16276686f, -0.20438662f, 0.00627102f, 
    0.21557826f, 0.09876880f, 0.14037903f, -0.47765121f, -0.20034342f, -0.23273358f, -0.04529233f, 0.24938110f, 
    0.05551807f, -0.16661450f, -0.05995196f, -0.13543424f, 0.06827173f, -0.05197879f, -0.17836432f, -0.00856672f, 
    0.13759650f, -0.04739454f, -0.13255817f, -0.07078768f, -0.04097901f, -0.27814651f, -0.10900440f, 0.05760062f, 
    -0.01908250f, -0.24634230f, 0.15431733f, 0.10212747f, 0.04430460f, 0.21414268f, -0.50590867f, 0.15414006f, 
    0.13329677f, -0.05146293f, -0.10801958f, 0.29832241f, 0.11130706f, 0.30658019f, 0.09345565f, -0.05894205f, 
    0.05678207f, 0.04612552f, -0.20729207f, -0.17624883f, -0.08456363f, 0.04256596f, -0.44452804f, 0.10138375f, 
    0.01747380f, -0.23373073f, 0.10952399f, -0.07676267f, 0.21315205f, -0.02788456f, -0.10663829f, -0.09491973f, 
    -0.05822606f, -0.01708130f, 0.17973655f, -0.09432731f, 0.10997529f, -0.36766726f, 0.02178859f, 0.01870494f, 
    -0.00792801f, -0.35945424f, -0.01118723f, -0.12011012f, 0.21241882f, 0.00736462f, -0.01040685f, -0.59569728f, 
    0.28519812f, 0.25260743f, -0.02329303f, -0.13541055f, -0.12550856f, -0.23090205f, 0.18068224f, -0.08140018f, 
    0.32167065f, 0.06601413f, -0.62864780f, 0.00710908f, -0.07324824f, 0.11937376f, -0.06141997f, 0.13526177f, 
    0.04595429f, 0.13678981f, -0.36126402f, 0.05327254f, 0.01759188f, -0.05540371f, -0.09636243f, -0.12536860f, 
    0.06174635f, 0.08669675f, 0.18409333f, 0.01284596f, 0.02509431f, -0.43205440f, 0.08848561f, 0.04787624f, 
    -0.13201992f, -0.08947115f, 0.01446376f, -0.46065336f, 0.04256002f, -0.15772922f, 0.03583248f, 0.04355713f, 
    0.07636026f, 0.23056896f, -0.09489734f, -0.24541378f, -0.43522802f, 0.01823055f, 0.19142678f, -0.20724748f, 
    0.04578161f, -0.01425623f, -0.17777036f, -0.12455542f, 0.12623923f, -0.34815797f, -0.36715743f, 0.19098173f, 
    0.22170174f, -0.17594162f, -0.15578291f, 0.02770061f, 0.18009207f, -0.27969435f, 0.09061118f, -0.41772491f, 
    0.06416986f, 0.23794988f, -0.00331623f, -0.00993105f, 0.03925925f, -0.37768921f, 0.22918372f, -0.06175304f, 
    -0.48292571f, -0.32598090f, -0.09334895f, 0.02565281f, -0.02194248f, -0.62458986f, -0.08085852f, -0.84770769f, 
    0.07668100f, -0.29363704f, -0.33017609f, 0.18403749f, 0.16851915f, -0.48556527f, -0.19273038f, 0.20113218f, 
    -0.04343000f, -0.24689551f, -0.21921273f, -0.16952758f, 0.16701023f, -0.07478416f, 0.07270087f, -0.11071394f, 
    0.03682890f, -0.12153145f, -0.19931301f, -0.14767106f, 0.00054602f, 0.08744035f, -0.23299408f, 0.07329366f, 
    -0.10338102f, -0.16810398f, -0.08309550f, 0.15742396f, -0.05995356f, -0.09236667f, 0.19859104f, -0.00555052f, 
    0.08781357f, -0.12853855f, 0.21394052f, 0.28992283f, 0.05104152f, -0.23350257f, -0.22865944f, 0.09640357f, 
    -0.09797352f, 0.06589739f, 0.46657205f, 0.12085693f, -0.33463925f, -0.02700246f, -0.16007754f, 0.00428475f, 
    -0.16409479f, 0.11019936f, 0.00166087f, 0.03605394f, -0.01428538f, 0.12116048f, 0.14855272f, 0.08409719f, 
    -0.14916876f, 0.07334417f, -0.10635357f, -0.10273247f, -0.11109281f, 0.03744901f, -0.12040232f, 0.21685345f, 
    0.02086978f, -0.03214151f, 0.20676199f, -0.20035324f, -0.49238494f, 0.18306267f, 0.24096240f, -0.31895453f, 
    -0.17410031f, -0.25453866f, 0.09251962f, 0.09017670f, -0.41382456f, -0.10214347f, 0.03497059f, -0.07477976f, 
    0.09623328f, -0.10835775f, -0.23001608f, -0.07253561f, 0.42741606f, -0.14139576f, -0.23905832f, 0.07505659f, 
    -0.04540980f, -0.09460346f, 0.20068216f, -0.13314223f, -0.07183939f, 0.02743312f, -0.04886956f, -0.25239953f, 
    0.07068163f, -0.04202496f, 0.08813613f, 0.13890147f, 0.18541172f, 0.17255111f, 0.10708073f, 0.05580282f, 
    -0.23218371f, 0.35434183f, -0.95737696f, -0.22621903f, 0.26174366f, 0.13967089f, -0.69989699f, -0.16713668f, 
    0.19529477f, -0.21943943f, 0.05287687f, -0.25960532f, -0.06698842f, -0.03231011f, 0.17440152f, -0.00767242f, 
    0.19024576f, -0.11555252f, -0.12991250f, -0.04656223f, -0.06564135f, 0.38070673f, 0.02461750f, 0.45883140f, 
    0.04040112f, 0.19642282f, -0.01665094f, -0.54495323f, -0.23127659f, -0.25033039f, -0.12292629f, 0.08931367f, 
    -0.05291780f, 0.05747107f, 0.29260090f, -0.22079428f, 0.03304056f, 0.08988544f, 0.04954733f, 0.01398864f, 
    0.04305388f, -0.12695318f, -0.03231037f, -0.36670181f, -0.32534498f, 0.20884551f, 0.33003986f, -0.06043678f, 
    0.08407408f, 0.04968696f, -0.59545511f, -0.06912966f, -0.50706506f, 0.07427938f, 0.21911392f, -0.17007807f, 
    -0.03229123f, -0.04720369f, -0.27875209f, -0.26137391f, -0.52430475f, -0.30350155f, 0.59997445f, 0.10275187f, 
    0.19586052f, 0.29238155f, -0.20019758f, -0.05674947f, -0.19169314f, -0.26470467f, 0.12823820f, -0.24168083f, 
    -0.25414050f, 0.01732112f, -0.00343857f, -0.44914803f, 0.04304557f, 0.08014017f, -0.00003433f, -0.11124957f, 
    -0.35566753f, -0.46348572f, -0.22519580f, -0.10890789f, -0.04557196f, 0.10345626f, 0.03823036f, 0.28994626f, 
    0.11089666f, -0.56516916f, 0.36632797f, 0.27243081f, 0.20522198f, 0.00509465f, -0.04175363f, 0.14185393f, 
    -0.53857034f, -0.03203399f, -0.29287279f, -0.22890948f, 0.04167103f, 0.24833481f, 0.08973411f, 0.01343167f, 
    0.09498418f, -0.09357797f, 0.26204792f, -0.35777649f, -0.18450844f, -0.00159423f, 0.18591040f, -0.04051838f, 
    0.02202515f, 0.53917289f, -0.08223552f, 0.11619475f, -0.23854016f, 0.00316486f, 0.01839716f, 0.15201598f, 
    -0.00462948f, -0.06355004f, -0.42717397f, -0.47670266f, 0.11488102f, -0.38193351f, -0.13227177f, 0.12660787f, 
    -0.49081182f, 0.11320224f, -0.25900289f, 0.20228381f, -0.11757573f, 0.42186838f, -0.56195754f, -0.15007822f, 
    0.24250379f, -0.60101390f, 0.05549209f, 0.16105358f, -0.05616275f, 0.18786259f, -0.42276302f, 0.07168341f, 
    0.17650169f, 0.05987962f, 0.16887198f, -0.03730778f, -0.00038964f, 0.21242444f, 0.07745619f, -0.34108332f, 
    -0.03703945f, -0.02089216f, -0.30566254f, -0.37929803f, 0.11305109f, 0.08130924f, -0.16549093f, -0.03191219f, 
    0.27941555f, 0.15236446f, -0.19641654f, 0.12079935f, 0.09402940f, 0.03119018f, 0.04000263f, 0.01582597f, 
    0.07997057f, -0.03080598f, -0.43809873f, 0.33087796f, 0.02451109f, -0.15275790f, 0.45038331f, -0.15179776f, 
    -0.07372771f, 0.04484884f, -0.07494858f, -0.41888648f, 0.14098999f, 0.09229565f, -0.19856447f, -0.38865346f, 
    -0.09731887f, -0.13356334f, -0.13335916f, 0.11910836f, 0.17466934f, -0.21199584f, 0.04696287f, -0.38981557f, 
    0.11917283f, 0.19044319f, 0.10349624f, -0.22481781f, 0.08508909f, -0.09128277f, -0.20346916f, -0.52907652f, 
    -0.05275575f, 0.14553118f, 0.03079290f, 0.04809876f, -0.03495634f, 0.15395595f, -0.39790139f, -0.15106331f, 
    0.06441624f, 0.25278181f, -0.30078390f, -0.11476467f, -0.08052053f, 0.17918575f, -0.03164412f, -0.17483661f, 
    -0.12690310f, -0.30307981f, -0.43006128f, -0.19086631f, 0.17756893f, -0.35370699f, -0.15167239f, -0.33361828f, 
    0.27885213f, 0.27212957f, -0.11464479f, -0.32188186f, -0.18855835f, 0.20708287f, 0.00733566f, -0.04484558f, 
    -0.04105147f, 0.04261030f, 0.15258321f, 0.13246256f, -0.10702816f, -0.74389178f, -0.20265681f, -0.04581851f, 
    -0.10340595f, -0.24909241f, 0.11555338f, 0.20716734f, 0.21037266f, -0.03112807f, -0.42448196f, 0.11156073f, 
    0.05346750f, -0.08758467f, 0.31004816f, -0.25437903f, 0.12073188f, -0.14671560f, 0.05299470f, -0.03852830f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.17511034f, -0.04750447f, -0.04805031f, 0.01898429f, -0.06656603f, -0.07018348f, 0.14482437f, -0.17679815f, 
    -0.20602156f, 0.03623768f, 0.18191609f, 0.09067541f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
