#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.11784016f, -0.01884655f, -0.45240527f, 1.03162920f, -0.96638530f, -0.38485798f, -0.08322515f, -0.01466891f, 
    -0.13990471f, 0.04385616f, 0.56234831f, -0.52676129f, -0.47021821f, -0.11491416f, -0.63173276f, -0.31050465f, 
    -0.68919986f, 0.32569772f, -0.63321239f, -0.65038103f, -0.07815617f, 0.81358427f, 0.30482212f, 0.31593040f, 
    0.22838549f, -0.27816811f, -0.13969859f, 0.20592308f, 0.35209107f, 0.44930980f, 0.46617490f, -0.73981947f, 
    -0.80749565f, 0.12062242f, 0.05743441f, 0.45253220f, -1.05350626f, 0.68378317f, -0.55853677f, -0.49756846f, 
    -0.20855330f, -0.06233514f, -0.21069323f, -0.47444537f, -0.19692566f, -0.53494287f, 0.22835808f, 0.57624817f, 
    -0.22403458f, -0.75397044f, -0.60808539f, -0.30432233f, -0.13421176f, -0.45553681f, 0.44601205f, 0.14135006f, 
    0.19976491f, -0.65215278f, 0.85643518f, -0.26562989f, -0.39918056f, 0.04025974f, 0.14830494f, -0.56665725f, 
    -0.46288323f, -0.32481459f, 0.10769945f, -0.11167258f, -0.72293848f, 0.03569992f, -0.32848856f, 0.42405736f, 
    1.06611407f, 0.31974012f, 0.21756044f, 0.35549939f, 0.06545889f, 0.02085996f, 0.11196933f, 0.44795766f, 
    -0.11831638f, 0.30500880f, -0.07650372f, 0.22907718f, 0.33913630f, 1.04409814f, 0.29966635f, 0.26276249f, 
    -0.19403528f, 0.54007053f, 0.92931771f, 0.31401709f, 0.26182887f, 0.08184268f, -0.24356608f, 0.04846327f, 
    0.32232144f, 0.44210389f, 0.32857266f, 1.19021010f, -0.79317892f, -0.42485753f, 0.10055981f, 0.25569481f, 
    -0.16028655f, -0.01401802f, 0.34196138f, 0.25674832f, -0.38582605f, 0.21598153f, -0.18859640f, -0.80341232f, 
    -0.31140548f, -0.84507263f, 0.49038678f, 0.31807834f, 0.62837917f, -0.63938129f, 0.55956584f, -0.91667897f, 
    -0.49670109f, 0.87850523f, -0.40052515f, 0.10738353f, 0.05812604f, -0.17637850f, 0.72067857f, 0.33832383f, 
    0.07348780f, -0.48725286f, -0.19691859f, -0.46300015f, -0.20837609f, 0.25894699f, -0.56233722f, -0.56064761f, 
    -0.47617012f, -0.38584399f, 0.48568162f, 0.25112864f, 0.22664452f, -0.27714220f, -0.37654933f, -0.40501377f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.48540592f, 0.49819627f, -0.02141898f, -0.12267727f, -0.29254439f, -0.22285399f, 0.41302463f, 0.09431122f, 
    -0.18792807f, 0.05882127f, 0.16920383f, 0.39378074f, 0.05703816f, 0.53274173f, -0.00114641f, -0.11766410f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.00602720f, -0.05248639f, -0.06596667f, 0.03974038f, 0.05205864f, 0.02842686f, -0.07377213f, 0.02212497f, 
    -0.07158525f, -0.02811079f, -0.05387004f, 0.02097446f, -0.03229997f, -0.05090452f, 0.05778314f, 0.05406131f, 
    -0.05179902f, -0.04805861f, 0.05061982f, -0.07740984f, -0.07261068f, -0.06893820f, -0.02667656f, 0.06310669f, 
    -0.04380756f, 0.01938712f, -0.01040708f, 0.02451602f, -0.06270173f, 0.01222487f, 0.00027548f, 0.01877211f, 
    -0.02932012f, -0.06741022f, -0.03187246f, -0.04420772f, -0.03887224f, 0.00078832f, -0.01342401f, 0.06046783f, 
    -0.04038924f, -0.00341132f, -0.07378119f, 0.01730527f, -0.08297178f, -0.05732914f, -0.08995841f, -0.02349023f, 
    -0.05614824f, -0.07815070f, -0.07224540f, -0.01110385f, -0.00732629f, -0.06848517f, -0.00512349f, -0.09297275f, 
    -0.01971157f, -0.08570374f, -0.07191583f, 0.02609402f, 0.03940448f, -0.02082396f, 0.06027380f, -0.05409361f, 
    -0.04947335f, 0.02497582f, 0.05243571f, 0.02082398f, -0.00466664f, 0.05440511f, -0.00133681f, -0.07906912f, 
    -0.06169559f, 0.03386894f, -0.05330397f, 0.03574826f, -0.04743552f, 0.01950499f, 0.06482325f, 0.00647493f, 
    -0.06605491f, 0.06247143f, 0.06748376f, -0.03782159f, -0.04803835f, -0.05306897f, -0.08610628f, 0.04685107f, 
    -0.06512764f, -0.07961362f, -0.07615264f, -0.09250706f, -0.01760573f, -0.03663388f, 0.02631741f, -0.05060373f, 
    -0.03359286f, 0.05960665f, -0.08702289f, -0.07489267f, 0.02919988f, 0.02047471f, 0.01578503f, -0.00903514f, 
    -0.05937818f, 0.06658971f, -0.03683314f, -0.03666960f, 0.06730247f, 0.03997772f, -0.06909986f, 0.06427442f, 
    0.00397790f, -0.04650507f, -0.00439430f, -0.03860358f, 0.05223705f, -0.02673999f, -0.09232797f, 0.00898660f, 
    -0.01036712f, -0.02578982f, 0.00572320f, 0.00370844f, -0.05007032f, 0.04929703f, -0.03565705f, -0.07554989f, 
    0.02764996f, 0.04318133f, -0.00469635f, 0.01104703f, -0.02177216f, 0.04933441f, 0.03083065f, -0.02429874f, 
    0.04248109f, 0.03215951f, -0.03379522f, -0.01075000f, 0.04510012f, -0.09231574f, -0.00426064f, -0.05053995f, 
    -0.62782013f, -0.15257853f, -0.21862413f, 0.12516360f, 0.08493139f, 0.17071168f, 0.15877084f, 0.16863887f, 
    -0.12419735f, -0.26186788f, 0.06709097f, -0.12327135f, 0.18455434f, 0.19052744f, -0.11155124f, 0.04959249f, 
    -0.00288704f, 0.04275794f, -0.13402511f, -0.83345294f, -0.46368402f, 0.04001484f, 0.08157886f, 0.24091329f, 
    0.02670593f, -0.08316353f, 0.06882493f, -0.03310271f, 0.38417855f, 0.07770714f, 0.00234336f, -0.30722862f, 
    -0.26849639f, 0.13485324f, 0.04606866f, -0.12203103f, -0.04123273f, -0.41545513f, -0.56307870f, -0.21554787f, 
    0.00436717f, -0.01252970f, 0.05496228f, -0.09576638f, -0.02309861f, 0.04557386f, 0.60253829f, 0.01186384f, 
    -0.19811137f, -0.26342243f, 0.08099905f, 0.06678673f, -0.06257124f, 0.14708914f, 0.28877696f, 0.35643154f, 
    0.18559310f, 0.15708098f, -0.03447695f, 0.06590657f, 0.21793033f, 0.16790493f, 0.04706737f, 0.23461425f, 
    -0.33606860f, -0.14604251f, -0.09639856f, 0.06207923f, 0.16202670f, 0.00520370f, -0.07465877f, -0.03260762f, 
    0.14337328f, 0.27939618f, -0.14944291f, -0.24486409f, -0.07180982f, -0.09382489f, -0.07903697f, 0.10454458f, 
    0.10237449f, 0.13168879f, 0.00408357f, -0.04243199f, -0.03935985f, -0.06929001f, -0.23203330f, 0.01660269f, 
    0.05860294f, 0.03750721f, 0.17214213f, 0.13851315f, -0.11533438f, -0.18937312f, -0.02858109f, 0.12739035f, 
    0.05656241f, 0.04988797f, -0.04374877f, -0.18319793f, 0.20906743f, -0.09443080f, -0.04044089f, 0.24270354f, 
    0.20921049f, 0.01679903f, 0.12673099f, 0.00316950f, -0.72120374f, -0.34437540f, 0.11826387f, -0.10830840f, 
    -0.05584398f, -0.05202992f, 0.00375831f, 0.10940813f, 0.11495789f, -0.27291352f, -0.24287459f, -0.40867206f, 
    0.16530097f, 0.20773336f, 0.07344040f, 0.04235349f, -0.02913717f, 0.04453050f, 0.17888430f, -0.11283492f, 
    -0.18560863f, -0.06351010f, -0.14150231f, -0.12770544f, -0.09428856f, 0.12430254f, 0.08540165f, -0.08484867f, 
    -0.48853123f, -0.48308918f, 0.05538516f, 0.00442395f, 0.04707775f, 0.09975266f, -0.11740175f, -0.02829072f, 
    -0.02842730f, -0.15827416f, 0.17451552f, 0.08753115f, 0.13307254f, 0.09084327f, 0.19096342f, 0.02416527f, 
    0.28558585f, 0.30861226f, 0.06391414f, 0.30830255f, 0.04443950f, 0.10549169f, -0.01644879f, 0.04800452f, 
    0.17249358f, -0.00381735f, -0.48121071f, -0.13198261f, -0.22540714f, 0.06943435f, 0.07268174f, 0.19997378f, 
    0.13650240f, 0.00436848f, 0.07382628f, 0.36554557f, -0.16621831f, 0.23558687f, -0.24720785f, -0.00621381f, 
    -0.14830191f, -0.15015355f, -0.04975994f, -0.14971820f, 0.22542141f, -0.12173386f, -0.08129911f, -0.17414397f, 
    0.11433848f, 0.01855843f, -0.03850555f, -0.14941286f, 0.32061869f, 0.27203274f, 0.28501120f, 0.36084110f, 
    -0.16618305f, -0.15951596f, -0.15487152f, 0.11735801f, 0.11867441f, -0.12867732f, -0.29440317f, 0.23381390f, 
    -0.12405174f, 0.31058812f, 0.06012933f, 0.30214667f, 0.08620441f, 0.06439382f, 0.01693301f, -0.18726610f, 
    -0.27308494f, 0.01130313f, 0.15033789f, 0.02817432f, -0.04705171f, 0.10298876f, 0.01443306f, -0.10398445f, 
    0.14179368f, 0.24061020f, -0.12445553f, -0.29552943f, -0.14568089f, 0.13549691f, 0.06172562f, -0.10359270f, 
    0.05474038f, -0.01162855f, -0.15132169f, 0.00173236f, 0.17472081f, 0.11908957f, 0.11984032f, 0.14244325f, 
    -0.01220081f, -0.09261100f, 0.12994264f, 0.24557334f, -0.05396226f, -0.19395836f, -0.09372232f, -0.16507329f, 
    0.02532979f, 0.13486540f, 0.05384683f, -0.27971852f, 0.26092109f, 0.20293382f, 0.13540240f, 0.14239554f, 
    0.01086861f, 0.08781302f, -0.02246550f, -0.06093907f, 0.00656276f, -0.06989305f, 0.04320337f, 0.18228206f, 
    0.02764912f, 0.03709820f, -0.02840789f, -0.14646089f, -0.23925786f, 0.29249308f, 0.26307094f, 0.07665449f, 
    0.04455944f, 0.26401567f, 0.03898256f, 0.06539959f, 0.03057877f, 0.24126035f, 0.14015377f, -0.10146537f, 
    0.13235489f, -0.01990341f, -0.05907105f, 0.07875838f, 0.04591550f, -0.04346368f, 0.16309266f, -0.35557181f, 
    -0.07757679f, -0.14805856f, -0.05169988f, -0.04083592f, 0.04994554f, 0.06391633f, -0.02039702f, 0.12170285f, 
    0.17290695f, 0.12864006f, -0.13998783f, 0.05067925f, -0.03077242f, 0.09429139f, 0.08860608f, 0.19667375f, 
    0.11502312f, 0.17726012f, -0.17477466f, 0.20400336f, 0.05697863f, -0.01348224f, 0.33510816f, 0.07415453f, 
    0.16349968f, 0.08287060f, -0.23219784f, 0.14236745f, 0.14070258f, -0.05663085f, 0.14880043f, 0.00644802f, 
    -0.04582088f, 0.04964377f, -0.07769013f, -0.35690090f, -0.72849089f, -0.23569016f, 0.11770241f, -0.27993885f, 
    -0.17332724f, 0.17561112f, 0.04377802f, 0.19600727f, -0.66459566f, 0.12764612f, -0.30022690f, -0.06943429f, 
    -0.16314049f, 0.09435629f, 0.04932080f, 0.08242512f, -0.21476622f, -0.53731793f, -0.22005497f, -0.19807209f, 
    -0.10493439f, 0.01664087f, -0.12317607f, -0.01205163f, 0.05578411f, -0.01955973f, 0.06263832f, -0.42252272f, 
    0.20078117f, -0.04349706f, 0.12843673f, 0.10347465f, 0.00928344f, 0.05106438f, 0.10799088f, -0.30417678f, 
    -0.27890280f, 0.38237956f, -0.03751009f, -0.11768007f, 0.11233532f, 0.02872387f, 0.00840552f, 0.10939270f, 
    -0.29602435f, 0.12227260f, -0.04473455f, -0.27503228f, -0.23653346f, -0.04132212f, -0.00211109f, 0.08561829f, 
    -0.04468963f, -0.02351676f, 0.09524236f, 0.08782687f, -0.23307905f, -0.29744217f, -0.22820151f, 0.12676562f, 
    0.02376268f, 0.15392826f, -0.15266277f, 0.17810182f, -0.02639586f, -0.11330926f, 0.02166203f, 0.08332945f, 
    0.07341456f, 0.15406328f, 0.18379346f, 0.27398703f, 0.17577536f, -0.40645704f, 0.00078585f, 0.15241387f, 
    -0.04790622f, -0.02705476f, 0.04344075f, 0.17435887f, -0.18255167f, -0.29129609f, -0.03287360f, 0.08490101f, 
    -0.07795966f, -0.00292288f, -0.04085485f, 0.02756737f, -0.11180823f, 0.13284729f, -0.07549006f, 0.45501977f, 
    0.07953840f, -0.02673636f, 0.22581428f, 0.11943452f, -0.04894462f, 0.15085684f, 0.17748193f, -0.01804983f, 
    0.08778685f, -0.12773176f, 0.13801847f, -0.41106942f, -0.20177075f, -0.20416039f, 0.11771514f, -0.44912946f, 
    0.17887044f, 0.04883783f, -0.12398213f, 0.05189519f, -0.01725399f, 0.15231505f, 0.02955931f, -0.17886972f, 
    0.11237024f, 0.12047601f, 0.43547469f, -0.29270497f, 0.22383983f, -0.11751770f, 0.11513173f, 0.00539510f, 
    -0.14935753f, -0.03893297f, 0.05709900f, 0.26482931f, 0.00780635f, 0.14779647f, 0.01486289f, -0.01276363f, 
    -0.01084546f, -0.01698388f, 0.08864285f, -0.04498503f, -0.28068048f, -0.00068186f, -0.16845515f, -0.09434219f, 
    0.08156155f, -0.15234374f, -0.11341061f, 0.01612812f, 0.13693173f, 0.05424368f, -0.36061940f, -0.03409691f, 
    -0.14803112f, -0.12888619f, 0.31815708f, 0.17936982f, -0.23079285f, -0.38365582f, -0.15898649f, -0.22943968f, 
    0.11191908f, 0.19359471f, 0.09852778f, -0.02759049f, -0.03387703f, -0.30276376f, -0.35064507f, 0.37373793f, 
    -0.31118801f, 0.20807448f, -0.30079687f, 0.01786450f, 0.07616735f, 0.13079655f, 0.08888109f, 0.29035813f, 
    0.37218156f, -0.10384253f, 0.04407522f, -0.02624736f, -0.05425908f, 0.04787630f, -0.14007299f, 0.09984560f, 
    0.25769496f, 0.17894103f, -0.12446264f, 0.06538802f, -0.19006515f, 0.10107689f, 0.17108952f, -0.23348795f, 
    0.13696110f, 0.05015120f, 0.26628911f, -0.23598018f, -0.03680239f, 0.13927270f, 0.00241071f, 0.19817483f, 
    -0.11385716f, 0.01257730f, 0.30649132f, -0.18179303f, -0.09928014f, -0.07375331f, -0.17123413f, -0.02941082f, 
    0.10518643f, -0.09499217f, -0.03014933f, -0.02234572f, 0.21505152f, -0.01355550f, 0.01509465f, 0.18529989f, 
    -0.00667393f, 0.08488280f, -0.22826067f, 0.04350890f, -0.19715853f, -0.05491858f, -0.26842189f, 0.00006337f, 
    0.22119091f, -0.00451686f, 0.01510011f, -0.01433301f, -0.26884428f, 0.14676617f, 0.02488077f, 0.22982261f, 
    0.10161209f, -0.27399111f, -0.22265497f, 0.13678081f, 0.00631328f, -0.01465407f, 0.44458702f, 0.38626799f, 
    0.03230194f, -0.04460253f, -0.02198174f, -0.10401822f, -0.19421929f, -0.04588829f, -0.19657341f, 0.00124207f, 
    0.03737632f, -0.21827132f, 0.17791750f, 0.26934239f, -0.14067571f, 0.09593014f, -0.15520631f, 0.00503435f, 
    -0.10699867f, -0.35333964f, 0.12132459f, -0.19545780f, -0.06851423f, 0.18560518f, -0.05037361f, -0.05464836f, 
    -0.31843942f, -0.68636572f, -0.19641015f, 0.04799552f, -0.06238509f, 0.21039075f, 0.19411626f, 0.15056950f, 
    0.08363283f, 0.06878704f, -0.19473700f, -0.74755931f, 0.23678333f, -0.05065051f, 0.28054300f, 0.09356840f, 
    0.04607367f, -0.06030397f, -0.28293186f, 0.28304172f, 0.47057575f, -0.32913059f, -0.17759930f, -0.17057869f, 
    0.08692362f, -0.10708927f, -0.13384339f, 0.34223896f, -0.56932116f, 0.06715675f, -0.02640314f, 0.18389288f, 
    -0.08635519f, 0.03846286f, -0.12396178f, -0.04047056f, -0.76391929f, 0.24906446f, -0.01498214f, -0.21678454f, 
    -0.27049014f, -0.12908445f, -0.04252629f, 0.09090156f, 0.11013672f, 0.08226714f, 0.01716097f, -0.37288231f, 
    -0.28105107f, -0.21735972f, -0.04100215f, -0.00536380f, 0.11527228f, 0.19586515f, -0.14334181f, -0.29157194f, 
    0.01050274f, 0.25157815f, 0.16632931f, 0.12558377f, 0.14583248f, -0.12117589f, 0.14821507f, -0.26841429f, 
    0.12308984f, 0.23483250f, -0.10071670f, 0.24030465f, 0.00513621f, -0.09776423f, 0.10600417f, 0.02693477f, 
    0.29425481f, -0.19087870f, -0.04342703f, 0.00672685f, -0.00959371f, 0.04680970f, 0.10891516f, 0.01985151f, 
    0.11509188f, -0.01301646f, 0.05446049f, 0.32802308f, -0.18791229f, -0.11236664f, -0.11730903f, 0.09670937f, 
    0.02153397f, -0.05210892f, 0.30095932f, -0.06351947f, -0.11525609f, 0.09798079f, -0.12108165f, 0.26700789f, 
    0.01819898f, 0.16636160f, -0.23778467f, 0.35076821f, 0.28015390f, 0.05090548f, 0.17900014f, -0.02350249f, 
    0.18791626f, 0.02990214f, -0.05217163f, 0.01444408f, 0.07505325f, 0.42087117f, -0.04279021f, 0.21854825f, 
    0.09037744f, 0.02209493f, 0.15723716f, -0.16934383f, 0.12959468f, -0.77614152f, -0.31509861f, -0.23804291f, 
    -0.09832133f, 0.29438460f, 0.09837617f, 0.04506721f, -0.01958921f, -0.10628417f, 0.32392970f, -0.29815638f, 
    -0.56989604f, 0.15651433f, -0.02749372f, -0.20847289f, 0.28951824f, 0.04247354f, -0.00504680f, 0.05269514f, 
    0.05770933f, 0.19128279f, -0.07002552f, -0.18721323f, -0.22852103f, -0.03936834f, -0.01818787f, 0.30138335f, 
    0.05648490f, -0.02710108f, 0.04033700f, -0.05048492f, 0.01090241f, -0.07731792f, 0.06234009f, -0.00498125f, 
    0.01774582f, -0.03704580f, -0.02499148f, 0.02497095f, -0.01163746f, -0.06489202f, 0.06375404f, -0.06522858f, 
    -0.05636986f, 0.03079671f, -0.03783474f, -0.07460480f, -0.07781777f, 0.03158110f, 0.03070806f, 0.00361538f, 
    -0.04852173f, 0.04007434f, 0.05272684f, 0.04068113f, -0.05562672f, 0.04751524f, 0.04331014f, -0.02352925f, 
    0.02927060f, 0.05952853f, -0.03889965f, 0.01435566f, -0.03599808f, -0.06013821f, -0.06669594f, -0.06083662f, 
    0.07621609f, 0.06034745f, 0.07653141f, 0.02306745f, -0.00219645f, 0.00241278f, -0.00121652f, -0.02229575f, 
    0.02062835f, 0.04925432f, -0.02753412f, -0.08500515f, -0.00367588f, -0.06981378f, 0.02381838f, -0.05354026f, 
    -0.08128028f, -0.07302176f, 0.00275795f, -0.02584509f, 0.07475573f, -0.08344468f, 0.01405955f, -0.00821043f, 
    -0.05593962f, 0.01900614f, 0.00567691f, -0.03798503f, -0.07108320f, 0.03806689f, -0.08085111f, -0.05999936f, 
    -0.07133668f, -0.08402872f, 0.07051327f, -0.08672462f, -0.08557167f, 0.00315509f, -0.00326158f, -0.07634491f, 
    -0.00445601f, -0.04992403f, 0.01090952f, -0.07263859f, 0.00190570f, -0.06434186f, 0.02530559f, 0.02696099f, 
    -0.06683905f, -0.07254332f, -0.06482030f, 0.01462900f, 0.03375770f, -0.06715596f, -0.00192767f, 0.00473447f, 
    -0.07829018f, -0.08050808f, -0.05577251f, -0.05130960f, -0.00908526f, 0.03577306f, 0.01051528f, -0.08533718f, 
    -0.05038849f, -0.03420587f, -0.04164684f, -0.04820375f, -0.01052580f, 0.00725599f, -0.05216134f, -0.07006558f, 
    0.01515036f, -0.04796564f, -0.07389629f, -0.03971488f, -0.00222741f, -0.05403171f, -0.02720974f, 0.05171068f, 
    0.07541428f, -0.06424342f, 0.02253089f, 0.07549297f, 0.01994726f, -0.02304424f, -0.03052199f, -0.04023567f, 
    0.07145151f, 0.07479109f, -0.00716644f, -0.05499208f, 0.05020816f, 0.05950698f, 0.07290976f, 0.02758499f, 
    -0.03217633f, 0.03251110f, 0.00541328f, 0.02827296f, 0.00630241f, -0.02252736f, -0.08468061f, 0.00047549f, 
    0.03569451f, 0.01016178f, 0.11048726f, -0.10455476f, 0.16187766f, -0.08212038f, -0.07190295f, -0.04082595f, 
    0.09086731f, -0.03409404f, 0.12334470f, -0.10745689f, 0.02339111f, 0.26187181f, 0.00245780f, -0.08455989f, 
    -0.05740687f, -0.08037689f, -0.15862603f, -0.33678824f, -0.03556817f, -0.12129295f, -0.13017096f, -0.04480659f, 
    0.08122809f, -0.06119545f, -0.23339501f, -0.00323389f, 0.24858604f, -0.05038211f, -0.06786951f, 0.20976929f, 
    0.14768495f, 0.13889316f, 0.08739584f, 0.13128315f, -0.12175624f, 0.33382544f, -0.14915910f, -0.15641986f, 
    0.09027964f, 0.13895577f, -0.02184841f, 0.09695105f, 0.06235421f, -0.08823331f, -0.09479529f, -0.04152074f, 
    0.12646979f, -0.01243804f, -0.00519987f, -0.01983592f, -0.08602563f, -0.09813938f, 0.05822415f, -0.13347504f, 
    0.50321722f, 0.15140764f, 0.15511172f, -0.00902258f, 0.18089622f, -0.17403656f, -0.14560351f, -0.16297545f, 
    0.02001747f, -0.07795215f, -0.00538400f, -0.08867519f, 0.03053656f, 0.00186932f, -0.04096949f, -0.13705550f, 
    0.04126139f, 0.02927357f, 0.23333402f, -0.09755179f, -0.11257187f, -0.19782822f, 0.07308868f, 0.07087277f, 
    0.17545168f, 0.23656501f, 0.17894645f, 0.33964899f, -0.14955263f, -0.17547674f, -0.16517255f, 0.01428415f, 
    -0.23100625f, -0.26020303f, 0.05227783f, -0.00100598f, 0.08519778f, 0.12622754f, -0.03601316f, 0.14665741f, 
    0.06082663f, -0.06585527f, 0.25487641f, -0.03814103f, -0.02653732f, 0.30575112f, 0.18674238f, -0.11333884f, 
    0.15880084f, 0.05897912f, 0.01803749f, 0.20209406f, 0.16186005f, 0.28509796f, -0.06977630f, 0.09315568f, 
    -0.04957538f, 0.16713198f, -0.09259007f, 0.20017794f, 0.25180790f, 0.24032277f, 0.16419350f, 0.03992073f, 
    -0.05714349f, -0.03712592f, -0.05620051f, 0.01681207f, 0.16678736f, -0.02662282f, -0.05764290f, -0.23850006f, 
    -0.08745433f, -0.07339186f, 0.14099057f, -0.00394116f, 0.05993637f, 0.06789208f, 0.14618403f, -0.27047712f, 
    -0.13388629f, -0.07264157f, 0.07395315f, -0.11621913f, -0.16415553f, 0.06165685f, -0.31568101f, -0.21507515f, 
    -0.06632446f, -0.01934160f, -0.05909542f, 0.02278818f, -0.07745389f, -0.02221157f, -0.07452288f, -0.02828729f, 
    -0.09321624f, -0.05865570f, -0.06180999f, -0.01941477f, 0.01303365f, -0.10339565f, 0.02818904f, -0.02685504f, 
    -0.05199249f, 0.01581109f, -0.05364314f, 0.01219170f, -0.09598399f, -0.08779873f, 0.05704956f, -0.00817066f, 
    -0.02128240f, 0.02250049f, -0.04279267f, -0.07215451f, -0.07562248f, -0.06907789f, -0.07379472f, 0.00018101f, 
    -0.02172855f, 0.04082190f, 0.05541690f, -0.03592512f, -0.07390558f, -0.04539107f, -0.01758436f, -0.08538029f, 
    -0.05686412f, -0.06500937f, -0.00171868f, 0.00099869f, -0.01654057f, -0.07428222f, 0.02107518f, -0.03495499f, 
    0.03218379f, 0.02870682f, -0.02333098f, -0.02768527f, 0.05102666f, 0.05516734f, -0.01484656f, -0.07313009f, 
    0.02198157f, 0.01917347f, 0.01384229f, 0.00093583f, 0.02682633f, -0.08540723f, -0.09750137f, -0.07647838f, 
    -0.02564757f, -0.06854185f, -0.08546129f, -0.05321377f, -0.09907044f, 0.01490387f, -0.04623062f, -0.03317518f, 
    0.01814904f, 0.05615696f, -0.00933305f, 0.00359500f, -0.11692944f, -0.10060921f, -0.09649106f, -0.08354373f, 
    0.03784036f, -0.05702226f, -0.04200011f, -0.07100729f, 0.03823115f, 0.03304524f, -0.02852164f, -0.00507764f, 
    -0.03669781f, 0.02871352f, -0.10603142f, -0.04380831f, -0.06067488f, 0.03631464f, -0.08324051f, -0.01077651f, 
    -0.04332233f, -0.03712550f, -0.01114888f, -0.03931199f, 0.05333720f, 0.01006189f, 0.02358196f, -0.05098889f, 
    0.01699634f, -0.06185742f, 0.05378341f, -0.03555644f, 0.02534873f, -0.07397507f, 0.04351484f, 0.00225357f, 
    -0.03173953f, -0.00659336f, -0.09454945f, -0.02076618f, -0.03957571f, -0.08709499f, 0.04412466f, 0.02293206f, 
    0.02983894f, 0.03297244f, 0.05465109f, -0.04583078f, -0.05371474f, 0.03043349f, -0.00710283f, 0.04169941f, 
    0.05796198f, 0.01991239f, 0.03717522f, -0.06765472f, -0.06619848f, -0.05201933f, -0.06405005f, 0.01560552f, 
    0.04838684f, 0.03754407f, 0.02943276f, 0.04848866f, 0.04112343f, 0.02153895f, -0.07434516f, -0.01191485f, 
    -0.21849865f, 0.22791536f, -0.11147055f, -0.05518749f, 0.04083478f, 0.01580839f, 0.08105598f, -0.13962342f, 
    0.10908530f, -0.00451717f, 0.05537586f, 0.06945334f, -0.01066790f, 0.05116473f, -0.05329995f, -0.11169229f, 
    0.06124495f, 0.03428853f, 0.27771243f, -0.38135347f, -0.39360693f, -0.07300517f, -0.07073113f, 0.12145822f, 
    -0.02924673f, 0.09863964f, 0.15791374f, -0.39878356f, -0.82191116f, -0.31809938f, -0.08067678f, -0.05718571f, 
    -0.22494531f, -0.04260676f, 0.00384104f, -0.02391948f, -0.51982671f, 0.38286287f, 0.28558096f, -0.12305718f, 
    -0.18006891f, 0.18015988f, 0.08704840f, -0.04889077f, -0.05915275f, -0.06865811f, 0.10153781f, -0.05039013f, 
    -0.01534668f, 0.06351552f, -0.16593005f, -0.02275877f, -0.01563881f, -0.10948312f, 0.15328255f, -0.30468741f, 
    -0.32964653f, -0.18088499f, -0.25640407f, -0.08089087f, 0.02733970f, 0.18254763f, 0.11789190f, 0.37692732f, 
    0.32501045f, 0.28889686f, 0.03685901f, -0.07185565f, 0.11526147f, 0.17296715f, -0.07185873f, 0.15182391f, 
    -0.05042543f, -0.62847376f, -0.07788818f, 0.09690511f, 0.01494561f, 0.00850801f, 0.05027454f, 0.06478807f, 
    -0.02087558f, -0.21447751f, -0.09796791f, -0.32290953f, -0.40398583f, -0.06786783f, -0.20352940f, 0.08797768f, 
    -0.13123052f, 0.02704199f, 0.27891424f, -0.20499496f, 0.28263316f, -0.19105971f, 0.02755458f, 0.12342971f, 
    0.06948703f, 0.19822946f, 0.15612431f, 0.40676695f, 0.22251840f, -0.60279006f, -0.11166798f, 0.09368021f, 
    0.16282924f, -0.08967655f, 0.08151938f, -0.01353049f, 0.14810222f, 0.32124481f, 0.21402988f, -0.22809619f, 
    -0.07318643f, -0.17030261f, -0.00757968f, -0.03509940f, 0.04648844f, -0.49017593f, -0.12191768f, -0.06537671f, 
    0.14294893f, 0.10632439f, 0.22138172f, 0.21609771f, 0.15582915f, -0.07916339f, 0.18078040f, 0.01126253f, 
    -0.15887158f, 0.01458449f, 0.09226932f, -0.27668718f, 0.08454559f, -0.18868466f, 0.03662303f, 0.25248346f, 
    -0.07295419f, 0.16465117f, 0.13799413f, -0.00829521f, 0.10114718f, 0.41984916f, 0.06148986f, -0.01805271f, 
    0.08043167f, -0.02965696f, -0.19537909f, 0.06568573f, 0.06846678f, 0.05732184f, -0.06187908f, 0.21948034f, 
    -0.07120805f, 0.23146155f, -0.06577623f, -0.34818918f, 0.01744233f, -0.00738558f, 0.15478812f, 0.07665146f, 
    0.05252957f, 0.05148234f, 0.05891353f, 0.15252581f, -0.04162855f, 0.23349661f, -0.12658054f, 0.14913812f, 
    -0.20517911f, -0.12702675f, -0.18044488f, -0.26693708f, 0.10830100f, -0.13432209f, -0.11329474f, -0.24126790f, 
    0.00212052f, 0.09532590f, 0.23409982f, 0.08413017f, -0.02259731f, 0.09865323f, -0.07127362f, 0.03655243f, 
    0.08023391f, -0.09049263f, -0.14555420f, -0.01238681f, -0.06758590f, 0.07697615f, -0.31006426f, -0.20918523f, 
    0.19743796f, 0.00096434f, 0.11236995f, -0.01768931f, -0.18344645f, -0.08148175f, 0.04603214f, -0.14220750f, 
    0.37840953f, -0.05791556f, 0.07976313f, -0.12463738f, -0.06755008f, -0.04637365f, -0.02330790f, 0.03639193f, 
    0.18472582f, 0.15939511f, 0.09224006f, -0.07499834f, -0.05874643f, 0.04729588f, 0.00569788f, -0.02743425f, 
    0.05319801f, 0.16095665f, 0.11787380f, -0.08997995f, -0.15415768f, -0.23836762f, -0.19268446f, 0.00331035f, 
    0.08179195f, -0.03071574f, -0.12857170f, 0.25653237f, 0.23118900f, 0.26398796f, 0.31229740f, 0.09233049f, 
    -0.05228565f, 0.06496204f, 0.07288224f, 0.02886911f, 0.21267174f, -0.03506853f, -0.16797155f, -0.22008781f, 
    -0.08659748f, -0.04361248f, 0.18379645f, 0.49485707f, -0.17563382f, -0.15410267f, 0.10651287f, -0.03721246f, 
    -0.36560026f, -0.03784074f, 0.05336684f, 0.12128208f, -0.05112832f, 0.04940270f, -0.22689322f, -0.13721286f, 
    0.00603183f, -0.00263599f, 0.17447235f, 0.27772701f, 0.11375419f, 0.08659385f, 0.20818703f, 0.12133606f, 
    0.09152110f, -0.10560857f, 0.07598282f, -0.03449817f, 0.24449679f, -0.05482130f, 0.27660915f, -0.01771969f, 
    -0.26895654f, 0.05423543f, 0.18247023f, 0.06240046f, -0.17384110f, -0.06821006f, -0.20427535f, -0.37746018f, 
    0.11324482f, 0.12529120f, 0.11729106f, -0.00504908f, -0.21279095f, -0.15473928f, -0.42134809f, -0.32828203f, 
    0.06947593f, -0.03220525f, 0.05480421f, 0.02618398f, 0.02955287f, -0.08653886f, -0.08207590f, 0.07064987f, 
    -0.06240780f, -0.00596638f, -0.00744290f, -0.00409313f, -0.01422182f, 0.01261065f, 0.03225832f, -0.00865857f, 
    0.05323111f, 0.07288202f, -0.03875822f, -0.06026560f, 0.01039437f, 0.05226932f, -0.01585040f, -0.06929753f, 
    -0.03917858f, -0.07631612f, 0.00924717f, -0.08894879f, -0.03577481f, -0.00875361f, 0.00749048f, 0.05320340f, 
    -0.06534218f, 0.00879321f, -0.00412600f, 0.07189740f, 0.03393075f, -0.07650009f, -0.03801383f, -0.06434049f, 
    0.02242824f, 0.02565031f, -0.04651798f, 0.04691677f, 0.03713598f, 0.06985312f, -0.01327881f, 0.03081469f, 
    -0.02419665f, 0.00983367f, -0.05781663f, 0.05792392f, -0.08507211f, -0.06814028f, -0.01527041f, -0.02979778f, 
    -0.08175223f, -0.01988226f, 0.01781481f, -0.09151752f, -0.08486798f, 0.04854448f, -0.03588553f, -0.02915304f, 
    -0.02685959f, -0.04667392f, -0.08525953f, -0.02589222f, 0.03453925f, -0.08888436f, 0.06216359f, 0.03941051f, 
    -0.00104571f, -0.05218360f, -0.05234616f, -0.05297552f, 0.07399593f, -0.03737625f, -0.01000801f, 0.00073947f, 
    -0.02248769f, -0.03228751f, 0.00455045f, 0.04003356f, 0.02506752f, -0.08329453f, 0.07178935f, -0.04683112f, 
    -0.00911312f, 0.01537763f, -0.08312075f, 0.06661377f, -0.06358252f, -0.04041461f, 0.06787601f, -0.03614711f, 
    -0.06993998f, -0.07574732f, -0.04006424f, 0.01290747f, 0.02820378f, -0.08768807f, -0.06057531f, -0.07301056f, 
    -0.00986881f, 0.00784218f, -0.06947343f, 0.01213615f, -0.00620467f, -0.08623729f, -0.07182533f, -0.02837574f, 
    -0.04609308f, -0.02191911f, 0.03271501f, -0.01890848f, 0.06142237f, 0.04876706f, -0.04826047f, -0.04381105f, 
    -0.07553696f, -0.04808793f, 0.07319365f, -0.01398082f, -0.05811496f, -0.05104811f, -0.06964161f, 0.01189831f, 
    0.05960777f, 0.05438004f, -0.01743285f, 0.04674755f, -0.07228648f, 0.02353119f, 0.00765938f, 0.03439675f, 
    -0.08972727f, -0.02374673f, -0.01489974f, -0.02198488f, 0.06776466f, -0.03149547f, -0.06783380f, -0.01740894f, 
    -0.06378696f, 0.31869879f, 0.48571643f, -0.12458663f, 0.04714493f, 0.07059993f, 0.05741592f, -0.04250553f, 
    0.03844520f, 0.36878750f, 0.20415175f, 0.13881786f, 0.24663098f, 0.26176274f, -0.16243546f, 0.15232231f, 
    -0.08559409f, 0.05638273f, -0.31794092f, 0.08166141f, 0.33235395f, -0.03300584f, 0.03302570f, -0.15072930f, 
    -0.18385461f, -0.15588750f, -0.18585670f, -0.56645507f, -0.30359557f, -0.55583477f, 0.20658918f, -0.00994417f, 
    -0.10001855f, -0.01306705f, 0.00965995f, 0.07527284f, 0.18753207f, 0.03042463f, 0.44395891f, 0.18396971f, 
    0.04000689f, -0.03130250f, 0.33926067f, -0.06414051f, -0.11681841f, -0.27385238f, -0.09372009f, 0.13758966f, 
    0.05305314f, 0.19456729f, 0.00300077f, 0.12953644f, -0.12805250f, -0.24757291f, 0.24744156f, -0.31254578f, 
    -0.32264057f, 0.08234457f, -0.09384784f, 0.13106957f, -0.02743025f, 0.00765462f, -0.04619277f, 0.02873545f, 
    0.35940984f, 0.28724730f, -0.14201462f, -0.08792015f, -0.10638548f, 0.15150113f, 0.00537987f, 0.10379476f, 
    -0.16731246f, -0.03694951f, -0.08319671f, 0.16276318f, 0.00404782f, 0.09830424f, 0.29317728f, 0.12840781f, 
    -0.09367248f, 0.09220597f, 0.09273395f, -0.11935267f, -0.08763582f, 0.04475835f, 0.06645130f, 0.07126138f, 
    0.19978216f, 0.05346646f, 0.09301738f, 0.00001028f, -0.19503103f, 0.18156534f, 0.08733844f, 0.01404968f, 
    0.31904179f, 0.10289169f, 0.09604045f, -0.24205667f, -0.12201530f, -0.11536515f, -0.11474314f, 0.00709553f, 
    0.08295566f, -0.02075780f, -0.08549836f, 0.23349980f, 0.15819746f, 0.31281176f, 0.38683105f, 0.15068477f, 
    -0.03996693f, 0.11538164f, 0.16941668f, 0.06110836f, -0.02943345f, -0.11793306f, 0.51744533f, 0.23192872f, 
    -0.04319651f, 0.09791397f, 0.22384350f, -0.02232197f, 0.23093012f, 0.25037238f, 0.29379508f, -0.42293268f, 
    0.04350759f, 0.13339908f, 0.17810753f, 0.09228729f, -0.07233600f, -0.00135402f, 0.00084578f, -0.59417003f, 
    -0.11057371f, 0.18369713f, -0.07951114f, -0.32094297f, -0.03208715f, 0.01749925f, -0.22719561f, 0.13518277f, 
    -0.18869568f, 0.13898681f, 0.22204049f, -0.02748990f, -0.28206143f, -0.18950441f, -0.06469120f, 0.13590996f, 
    0.22068749f, -0.04311810f, 0.05946517f, -0.15597557f, -0.04312284f, -0.08097136f, 0.12062554f, 0.08945840f, 
    0.05256348f, 0.06531057f, -0.15502074f, 0.09432909f, 0.06146463f, -0.14680488f, 0.13219918f, 0.33691248f, 
    -0.21827388f, -0.10610291f, 0.00748774f, 0.08524732f, -0.16229627f, 0.05334462f, -0.07311152f, -0.05628475f, 
    -0.21456051f, 0.20278478f, -0.06669108f, 0.27260366f, -0.16405383f, -0.15873376f, 0.01708530f, 0.09594460f, 
    -0.17883892f, 0.19921204f, -0.13295165f, -0.04261228f, -0.02852943f, -0.26883262f, -0.05429598f, -0.13034348f, 
    -0.04254271f, 0.29989180f, -0.14590751f, 0.17485090f, -0.07870119f, -0.03300148f, 0.05154398f, -0.02308169f, 
    0.41230252f, 0.11393027f, 0.02582358f, -0.03281913f, 0.10691300f, 0.04922605f, 0.00848396f, -0.01775926f, 
    0.16137037f, 0.07933982f, 0.19088918f, 0.12925345f, -0.15101570f, 0.06548746f, -0.09617635f, 0.09873603f, 
    0.50168478f, -0.03136869f, -0.04136432f, -0.00812061f, 0.02273470f, 0.09071732f, 0.07663950f, -0.05494813f, 
    0.04159089f, -0.24275829f, -0.01965643f, -0.24702592f, -0.10463660f, 0.03694012f, 0.03870752f, 0.13942361f, 
    -0.07280442f, 0.08515486f, 0.44206089f, -0.04029029f, -0.06166152f, -0.17764100f, 0.13743494f, 0.03509003f, 
    -0.00623702f, 0.15246402f, -0.23185585f, -0.05892652f, 0.04327900f, 0.05880048f, 0.05126134f, 0.07682475f, 
    0.17459334f, 0.12203229f, 0.00287269f, -0.03895529f, -0.57030141f, -0.28785151f, -0.56385046f, -0.06681595f, 
    0.07057424f, 0.01933849f, 0.06532731f, 0.06419624f, -0.23753512f, -0.15731007f, 0.04455400f, 0.51719630f, 
    -0.06349947f, 0.36012110f, 0.07180090f, -0.07334290f, 0.10101973f, 0.10608283f, -0.02226664f, -0.44939253f, 
    -0.00443642f, -0.00395017f, -0.00756747f, 0.06850374f, -0.03481903f, -0.12655747f, 0.16665491f, -0.06715273f, 
    -0.31935060f, 0.03707529f, 0.07666930f, 0.15963134f, 0.03267482f, -0.15403487f, 0.05976626f, 0.13463035f, 
    -0.00860466f, 0.09622244f, -0.19939643f, 0.15590756f, 0.17778933f, 0.03400950f, -0.07281898f, -0.00040278f, 
    -0.11275593f, 0.04621112f, 0.37415838f, -0.02869970f, -0.12160159f, -0.10723805f, 0.05861131f, -0.01518918f, 
    0.22030169f, -0.03127971f, -0.05652251f, -0.22279704f, 0.01754869f, -0.06163750f, 0.04541364f, 0.08946403f, 
    -0.05302174f, 0.19988790f, 0.30936393f, 0.13403943f, -0.05349401f, -0.13823920f, -0.12345728f, -0.13156942f, 
    -0.17955920f, 0.17939804f, -0.03381055f, 0.03959478f, 0.06086831f, 0.34471601f, 0.25341973f, -0.01303228f, 
    -0.18423498f, -0.11840966f, -0.08030160f, -0.10215466f, 0.10619109f, 0.21804383f, 0.37097660f, 0.03705953f, 
    0.27401012f, 0.03136083f, -0.14044073f, 0.26603928f, -0.00159766f, 0.25514153f, 0.02165606f, -0.17837363f, 
    0.05319684f, 0.45995983f, -0.08707622f, 0.29357558f, 0.06318873f, 0.19547109f, -0.03986585f, 0.19338015f, 
    -0.14330716f, 0.12682685f, 0.29616722f, 0.00563673f, 0.25452486f, -0.20171253f, 0.01989563f, -0.05115505f, 
    -0.12806389f, 0.14514288f, -0.08996768f, 0.08755350f, 0.10882343f, -0.04339899f, -0.02590597f, -0.03788606f, 
    -0.13155542f, -0.21967879f, -0.28364971f, -0.64132571f, 0.26889944f, -0.05435821f, 0.07771968f, 0.09426034f, 
    0.01187719f, -0.02307877f, -0.27626523f, -0.01493885f, -0.06458538f, -0.00464764f, -0.06106819f, 0.07816054f, 
    -0.09776785f, -0.06502421f, -0.18864782f, -0.24858567f, 0.47672158f, 0.05529818f, 0.22844961f, 0.17727649f, 
    0.17850803f, -0.05088458f, 0.28726172f, -0.22200209f, 0.20029911f, 0.25873208f, 0.01852405f, 0.12710144f, 
    -0.10972470f, -0.16492060f, -0.09106231f, -0.02557744f, -0.24886654f, 0.06330214f, 0.04780046f, -0.10028486f, 
    0.14493759f, 0.08737021f, 0.19210184f, -0.01036279f, -0.21535183f, 0.16370180f, -0.25584981f, 0.31505081f, 
    -0.00069433f, -0.05160486f, -0.11075055f, -0.26847851f, 0.16738935f, -0.00804641f, 0.10784722f, 0.11649210f, 
    -0.22773081f, 0.29868424f, -0.01294845f, -0.16560693f, -0.05014705f, -0.17729689f, 0.01232859f, 0.03065874f, 
    0.21938638f, -0.08677983f, -0.26533568f, -0.10079060f, -0.11828150f, 0.09993575f, -0.02446875f, 0.02922428f, 
    0.00529520f, -0.15525427f, 0.02713996f, 0.12031738f, 0.20213474f, -0.10694865f, 0.16127400f, -0.07642816f, 
    -0.03187481f, -0.02042250f, 0.45911703f, -0.13349676f, 0.02215937f, -0.09736681f, 0.15110132f, -0.10841103f, 
    -0.27915791f, 0.01204175f, -0.14983287f, -0.28661945f, -0.30322942f, -0.09269496f, -0.23794568f, -0.13961081f, 
    0.03950166f, 0.04082073f, 0.13938817f, 0.03609735f, 0.13815120f, 0.17745338f, -0.01203905f, -0.02045744f, 
    -0.02947943f, 0.19718784f, 0.06130127f, -0.15601757f, -0.04355268f, 0.17717157f, 0.09304082f, 0.03910980f, 
    -0.10088637f, 0.02064151f, -0.15745029f, -0.04688302f, 0.00274125f, 0.04064363f, -0.50364143f, -0.32157949f, 
    0.38442785f, 0.01454204f, -0.19317657f, -0.01632397f, 0.01356561f, 0.20086904f, 0.14010002f, 0.46457511f, 
    0.24265555f, 0.08975688f, 0.08402713f, -0.01333450f, -0.00965868f, 0.11345127f, 0.07638726f, -0.01391984f, 
    -0.20065586f, -0.38609299f, 0.16670187f, 0.17728426f, 0.09216687f, 0.05455933f, -0.00098879f, 0.02745532f, 
    -0.03341714f, -0.19292794f, 0.13326581f, 0.22552854f, 0.06315562f, -0.14381585f, -0.17597899f, -0.06041847f, 
    0.23090780f, 0.05294647f, 0.05040066f, 0.00459371f, 0.04260473f, -0.15695982f, -0.19465956f, -0.04254822f, 
    -0.04559975f, 0.03410884f, 0.03505585f, -0.05807467f, -0.00650937f, -0.11596994f, -0.04166723f, -0.08385601f, 
    0.05707542f, 0.13065682f, -0.10343643f, 0.26878956f, 0.18148227f, 0.19732839f, 0.33062512f, -0.44814646f, 
    -0.07412386f, -0.06818022f, 0.00801932f, 0.16105174f, 0.19960134f, -0.23552139f, -0.04988613f, 0.09854539f, 
    0.03167351f, -0.00517907f, 0.17343283f, -0.09628557f, 0.23847193f, -0.10529818f, -0.43525037f, -0.05693220f, 
    0.13336626f, 0.03261191f, -0.16966073f, 0.21539541f, -0.15085755f, -0.09588786f, -0.08542997f, 0.24995714f, 
    0.08558923f, -0.19509810f, -0.21613315f, 0.20863010f, -0.05977116f, 0.18424502f, 0.08121035f, -0.17239916f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.05901975f, 0.28902772f, 0.21158595f, 0.50014824f, 0.03666396f, 0.16354886f, 0.01938935f, -0.01366085f, 
    0.04499037f, -0.00706473f, 0.13594681f, -0.02259022f, 0.07158859f, 0.12553331f, 0.03525773f, -0.04703892f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.20963660f, -0.84507102f, -0.08178093f, 0.69021952f, 0.34470230f, -0.41341513f, -0.17980358f, 0.01969227f, 
    -0.07168788f, 0.29057759f, 0.41382965f, -0.11883253f, -0.00642438f, -0.25552675f, -0.12688686f, 0.53696340f, 
    0.09615116f, 0.61376244f, -0.25064108f, -0.28854331f, 0.05342925f, -0.21550353f, -0.02121826f, 0.25318727f, 
    0.17193554f, -0.12057735f, -0.05810895f, 0.13325530f, 0.20295101f, 0.30374146f, 0.10319096f, 0.27172986f, 
    0.09208664f, 0.26162177f, -0.24675064f, 0.46757469f, 0.42950338f, 0.21315782f, 0.08460805f, 0.17399052f, 
    -0.08228877f, 0.55991536f, 0.18393849f, -0.02926881f, -0.36256811f, 0.36506826f, 0.36861348f, -0.10100710f, 
    0.00237810f, 0.16900976f, 0.25276503f, -0.55183029f, -0.17977545f, 0.25322744f, 0.12673299f, 0.10177904f, 
    0.15386914f, -0.00489041f, -0.80283123f, 0.04146487f, -0.08754635f, -0.35325545f, 0.33227146f, 0.41972345f, 
    0.22742409f, -0.16933429f, -0.05107465f, -0.16594720f, 0.14608964f, -0.09890181f, -0.23748457f, -0.21981600f, 
    0.15246272f, -0.01832461f, -0.11687142f, -0.21055683f, -0.17057425f, 0.03661641f, -0.04007223f, -0.21094632f, 
    -0.13467753f, 0.11656639f, -0.15001188f, 0.50038320f, -0.47473878f, -0.19668846f, -0.06986731f, 0.18670785f, 
    0.21411307f, 0.21321727f, 0.07478905f, -0.15518507f, 0.35651624f, -0.37378067f, 0.17128912f, 0.01179402f, 
    0.02619936f, -0.57482320f, 0.48007765f, -0.30042866f, 0.18142577f, 0.22441012f, 0.09932276f, -0.31033692f, 
    0.11395060f, 0.17068414f, -0.06998592f, 0.14240648f, 0.29158759f, -0.19103745f, 0.06681477f, 0.31523299f, 
    -0.03766611f, -0.00120866f, 0.17056005f, 0.04869394f, -0.13535379f, 0.06027710f, 0.11543056f, -0.27616501f, 
    -0.12387627f, 0.03736758f, -0.22130030f, 0.11194786f, -0.04570071f, -0.14913173f, -0.14285950f, -0.11056311f, 
    0.13918212f, -0.78253454f, -0.36631769f, 0.41848838f, 0.13181488f, 0.06063635f, 0.11512059f, -0.26344082f, 
    0.09236035f, 0.49726096f, -0.29264188f, 0.18248275f, 0.39583811f, 0.18787566f, 0.09789868f, 0.04406290f, 
    -0.13333720f, -0.13743249f, -0.18477511f, -0.00644156f, -0.22912705f, -0.21042752f, -0.08793056f, -0.24645060f, 
    0.12801921f, 0.13670510f, -0.14126760f, 0.00586465f, -0.12160185f, -0.16066760f, -0.08956274f, -0.17357445f, 
    0.19194658f, 0.43612608f, -0.21990684f, 0.46203825f, 0.16296878f, -0.63437986f, -0.03233182f, 0.20315750f, 
    -0.06806239f, 0.10454260f, 0.50735986f, 0.09575590f, 0.08624037f, -0.37724221f, 0.21888673f, 0.08540553f, 
    0.07928713f, -0.16224460f, -0.30898479f, 0.21125782f, 0.22288196f, 0.23002850f, -0.15772714f, 0.41902637f, 
    -0.22191219f, 0.27065191f, 0.17593190f, 0.00541426f, 0.06400744f, 0.00248128f, -0.19557135f, 0.35790980f, 
    -0.19387189f, -0.19622977f, 0.27852193f, 0.30189639f, 0.17206436f, -0.12595811f, 0.07755730f, 0.03599930f, 
    0.09899551f, 0.54585886f, 0.03003340f, -0.18765011f, -0.03522990f, -0.36839408f, 0.40603745f, 0.01716737f, 
    0.01400823f, 0.37348619f, 0.25725263f, -0.38174203f, -0.14953162f, 0.00542916f, -0.07840387f, 0.30534515f, 
    0.20494427f, -0.18266688f, -0.07980226f, -0.03732480f, -0.34249645f, 0.07483854f, 0.50038469f, 0.11482190f, 
    -0.08001918f, -0.26969934f, -0.29029399f, 0.40130234f, -0.06309789f, 0.28249472f, -0.01501653f, 0.13247502f, 
    0.16946641f, -0.86298430f, -0.07448187f, 0.16140810f, 0.37338728f, -0.32103899f, -0.30652878f, 0.22468165f, 
    0.12702793f, -0.27981216f, 0.07063153f, -0.30570677f, -0.11260669f, -0.18169503f, 0.04499205f, 0.12086800f, 
    0.04845554f, 0.33318579f, -0.25092396f, 0.18803249f, 0.44577241f, -0.34484574f, -0.01994777f, 0.47268653f, 
    -0.07991112f, 0.50386733f, -0.20283498f, -0.51513958f, 0.47193119f, -0.42263117f, -0.06543598f, 0.18878698f, 
    -0.00265475f, -0.17036055f, -0.06946579f, -0.07118877f, 0.30550373f, 0.12642628f, 0.10549400f, 0.37633777f, 
    -0.19446635f, 0.06241074f, -0.23926288f, -0.19424996f, -0.20666111f, -0.11863950f, -0.23808104f, 0.09310168f, 
    0.02340135f, -0.12374043f, -0.12762100f, -0.00182465f, -0.11955532f, 0.00253600f, -0.22160655f, -0.01455423f, 
    0.11419591f, 0.19810316f, 0.28302437f, 0.40737447f, 0.16635969f, -0.48174053f, 0.04596824f, 0.10698004f, 
    -0.20788696f, -0.36833057f, 0.12139339f, -0.23455551f, 0.17063683f, 0.22650906f, -0.24781178f, -0.06243673f, 
    -0.16951632f, -0.86231494f, -0.30909276f, -0.50717670f, -0.36346483f, 0.15366603f, -0.19563684f, 0.19380228f, 
    -0.23121132f, 0.40142518f, -0.02899033f, 0.06560677f, 0.28772539f, -0.15795256f, 0.22650412f, 0.48413575f, 
    -0.25012326f, -0.13059609f, 0.43004066f, -0.22789443f, 0.15846233f, -0.32611680f, 0.05574415f, -0.08156697f, 
    -0.01160917f, 0.17998360f, -0.20065600f, 0.15249737f, 0.01764695f, 0.39274839f, 0.17990726f, -0.15027332f, 
    -0.08561145f, 0.48066655f, -0.20002387f, 0.06903075f, 0.25709879f, -0.28403330f, -0.10031843f, 0.15910204f, 
    0.20862003f, 0.65878856f, -0.06456079f, -0.21372285f, -0.05719198f, -0.37365806f, 0.25714302f, 0.26525259f, 
    0.14255281f, -0.04536673f, 0.12913437f, 0.51713675f, 0.10160698f, 0.16100362f, -0.22224274f, -0.20131294f, 
    0.23473153f, 0.23356973f, 0.03827128f, -0.18619026f, 0.40439129f, 0.29175076f, 0.06860179f, -0.26961723f, 
    0.05252923f, 0.04168964f, 0.09264413f, 0.42476115f, -0.39015245f, -0.35947499f, 0.20237002f, 0.34570330f, 
    -0.20538156f, -0.19538347f, 0.24133164f, 0.04798272f, 0.22942027f, -0.26719859f, -0.23514150f, 0.23168129f, 
    0.22108473f, 0.50727767f, 0.15486734f, -0.08416224f, 0.50911367f, -0.29183495f, 0.13929826f, -0.29452714f, 
    0.18250373f, 0.41933161f, -0.16601418f, 0.11266863f, 0.05267275f, 0.51062262f, 0.44420439f, -0.43890324f, 
    0.10141036f, 0.04500298f, -0.25581381f, -0.13885731f, 0.63729173f, -0.58796901f, -0.07098088f, 0.41060621f, 
    0.18748468f, -0.26784059f, -0.26470277f, 0.11798392f, 0.30689484f, 0.15734959f, -0.08609704f, 0.11406683f, 
    -0.07758984f, 0.09107721f, -0.22314042f, 0.14877641f, -0.04810214f, -0.22217712f, 0.15884095f, -0.14671418f, 
    0.16983542f, -0.09475565f, -0.10040471f, -0.16003895f, -0.20678237f, -0.19131234f, 0.23246530f, -0.21852028f, 
    0.03744593f, -0.77148855f, 0.29873952f, 0.69953799f, 0.32626602f, -0.67082965f, 0.16346005f, 0.09339133f, 
    0.05302280f, -0.47832015f, 0.13429989f, 0.10330376f, -0.13026470f, 0.12103025f, -0.19468485f, -0.08603696f, 
    -0.17641054f, 0.48599371f, -0.24828650f, -0.25133669f, -0.14078152f, 0.32553780f, 0.20501834f, 0.19915006f, 
    0.23879139f, 0.18635713f, 0.03384576f, 0.07989660f, 0.18776017f, -0.31731194f, 0.18544067f, 0.21183299f, 
    -0.21811990f, -0.35687348f, 0.13825744f, 0.46027285f, -0.12237579f, 0.04823763f, 0.02613645f, -0.02161379f, 
    0.05547979f, -0.24233419f, 0.24619184f, -0.18895605f, -0.02619672f, 0.31062821f, 0.19175445f, -0.38168013f, 
    -0.04650902f, -0.06714030f, 0.44055074f, -0.09456307f, -0.23592572f, -0.20377214f, 0.14949378f, -0.69462901f, 
    0.06017940f, -0.27413034f, -0.55696326f, -0.10697722f, 0.04147371f, 0.29055157f, 0.44098055f, 0.06432382f, 
    -0.18005081f, -0.51033723f, 0.35401016f, 0.45096573f, 0.44891915f, -0.31837156f, -0.00385421f, 0.05337752f, 
    -0.12536873f, -0.28573051f, 0.12698725f, -0.06605946f, 0.22695588f, 0.34048960f, -0.25097504f, -0.38140854f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01154155f, -0.08507093f, 0.12427439f, 0.15434006f, -0.23797822f, 0.41208872f, -0.11179117f, -0.02160932f, 
    -0.23808789f, -0.05049193f, -0.21951135f, -0.22333179f, 0.18616986f, -0.19432399f, -0.18807027f, 0.26013735f, 
    -0.19814155f, -0.24125153f, 0.48276231f, -0.13381369f, 0.36768934f, -0.02178725f, 0.27315360f, -0.01807326f, 
    0.04339041f, 0.05613373f, -0.04913062f, -0.03349330f, -0.40570527f, 0.35243711f, 0.37815848f, 0.45290259f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.24372818f, 0.52513874f, -0.26257974f, 0.01494915f, -0.00018370f, 0.19227831f, -0.22804517f, 0.10121805f, 
    -0.12956479f, -0.04806051f, 0.88862985f, -0.32006487f, -0.26724386f, -0.08382921f, -0.71571624f, 0.24984223f, 
    0.94745201f, -0.14182405f, 0.24447931f, 0.06434890f, 0.19284278f, 0.33768076f, -0.16328487f, 0.35609102f, 
    0.29202425f, 0.66608477f, -0.07989632f, -0.08323156f, -0.03372470f, -0.41176841f, 0.30272320f, -0.02854971f, 
    0.32069349f, -0.08956131f, 0.28154922f, -0.24847165f, 0.08219468f, 0.52038962f, -0.06673392f, -0.12339284f, 
    0.20104319f, -0.03072385f, 0.24011716f, -0.05508203f, 0.32317671f, -0.15447931f, -0.23726588f, -0.17451766f, 
    -0.82763934f, -0.13770956f, 0.17324607f, -0.24956104f, 0.16768245f, -0.02308150f, 0.18178760f, 0.16461088f, 
    0.11608221f, -1.07796896f, 0.02540722f, -0.50827646f, 0.14839791f, 0.27545312f, -0.00130432f, -0.03106610f, 
    -0.42535117f, -0.10483456f, 0.33607101f, -0.57602638f, -0.06056293f, -0.16486739f, -0.04736841f, 0.09532207f, 
    -0.27664515f, -0.14242677f, -0.45066682f, 0.14518438f, -0.04923027f, 0.17916751f, -0.05579873f, -0.55602491f, 
    -0.56434667f, 0.04099839f, 0.11452776f, 0.21731757f, 0.24509396f, -0.51327032f, 0.09158042f, -0.01975917f, 
    0.35350156f, -0.43090585f, -0.11501725f, 0.67742580f, -0.18509123f, 0.36900312f, 0.20396914f, 0.29589304f, 
    -0.27826351f, 0.10630600f, 0.25717035f, 0.36711130f, 0.12828434f, -0.68055993f, 0.17452697f, -0.12426283f, 
    -0.30085921f, 0.02564060f, -0.33831277f, -0.24486625f, 0.08372780f, 0.31125405f, 0.50331575f, -0.32987922f, 
    0.00088727f, -0.01994547f, 0.02052687f, -0.24380709f, 0.37779814f, 0.04146148f, -0.07110728f, -0.24846962f, 
    0.17009166f, 0.12123929f, -0.11979079f, 0.08069759f, 0.00558317f, -0.02021718f, 0.88063437f, 0.07574136f, 
    -0.10795356f, -0.02292489f, -0.14362879f, 0.06711669f, 0.04504385f, -0.04165613f, -0.10569616f, 0.08384698f, 
    -0.07376938f, -0.03012155f, 0.01369195f, 0.07140850f, 0.15241794f, -0.07029744f, -0.05109983f, -0.02064812f, 
    -0.01105128f, -0.16140577f, -0.13220507f, -0.06480347f, -0.05928681f, 0.11767317f, -0.07947420f, -0.08819331f, 
    -0.05499820f, -0.07740730f, -0.16327865f, 0.02512395f, 0.10232843f, 0.06324130f, 0.05875764f, -0.05919812f, 
    -0.08122326f, 0.08382021f, -0.13662694f, 0.03609081f, 0.16967641f, 0.04980270f, -0.12855436f, -0.09421746f, 
    0.17306066f, 0.11782461f, 0.12911516f, 0.10223147f, 0.07059234f, 0.00685100f, 0.07973858f, 0.11806808f, 
    0.02237608f, 0.10659751f, -0.21100001f, -0.18246682f, -0.13801408f, 0.14134440f, -0.13204916f, 0.02363619f, 
    -0.16209373f, 0.06594679f, 0.09025805f, -0.08609798f, -0.15016045f, 0.10429128f, -0.11431546f, -0.05928477f, 
    0.30299532f, -0.04291558f, 0.45047274f, -0.39800808f, 0.11159644f, -0.01460964f, -0.07592316f, -0.04752727f, 
    0.28924739f, -0.07778323f, 0.53825432f, 0.11437950f, 0.34824023f, -0.13404454f, -0.20419222f, -0.08063915f, 
    -0.04242876f, -0.07089751f, -0.23629560f, 0.30551049f, -0.06472653f, 0.65815121f, -0.03075524f, -0.24000405f, 
    0.19584113f, 0.14887346f, 0.01910993f, -0.09810573f, 0.01362729f, -0.21559569f, -0.64910161f, -0.07483736f, 
    0.01509956f, 0.17262399f, 0.25955427f, 0.07073066f, -0.03962253f, 0.18832213f, 0.04629890f, 0.04797096f, 
    0.51901495f, 0.16512991f, -0.12656720f, 0.05000984f, 0.09153183f, 0.00980033f, -0.70792168f, 0.01296931f, 
    -0.07640451f, 0.03361289f, -0.09762224f, 0.18175727f, 0.03590106f, 0.17325181f, 0.22727472f, -0.20537098f, 
    0.22390667f, -0.62459826f, 0.09862333f, -0.79433805f, -0.05052039f, 0.13051279f, -0.38825336f, -0.08505899f, 
    -0.09550964f, 0.05097702f, -0.16845682f, -0.42398801f, -0.09462383f, 0.15501960f, 0.25307596f, -0.13396387f, 
    0.02352253f, -0.15288804f, -0.29228652f, -0.08559774f, -0.07333564f, -0.54409456f, -0.09101710f, 0.00747040f, 
    -0.00178786f, 0.02226003f, 0.29957917f, -0.33319411f, 0.19409607f, -0.19534859f, 0.24666345f, 0.17548172f, 
    0.27756065f, 0.29429388f, -0.08225158f, -0.43914431f, -0.06946047f, 0.19496542f, 0.02994712f, 0.49159431f, 
    0.13095208f, -0.03328008f, 0.20562214f, -0.14674929f, 0.03257420f, -0.00754105f, 0.20481390f, 0.02544332f, 
    -0.17310576f, -0.16013305f, -0.11433981f, -0.30219057f, 0.07233453f, 0.33337033f, 0.29325157f, -0.02623116f, 
    -0.25554642f, 0.17531995f, 0.22948657f, -0.17545089f, 0.13083285f, -0.20190436f, 0.28878260f, -0.18595517f, 
    0.17652157f, -0.77294493f, 0.16344100f, -0.47481707f, -0.16448407f, 0.44552711f, 0.37951833f, 0.23638372f, 
    -0.10434687f, -0.12126402f, -0.05918634f, -0.11117475f, 0.10228351f, -0.14614771f, -0.06143187f, -0.04549367f, 
    -0.13736562f, -0.10707864f, -0.05174040f, 0.03555898f, -0.05831885f, -0.04053820f, -0.05357840f, 0.07291958f, 
    -0.13732961f, 0.02103370f, -0.13565321f, -0.04453528f, 0.06232620f, 0.13165087f, -0.12263121f, -0.07672491f, 
    0.01507461f, 0.10353668f, 0.08471251f, 0.08305474f, -0.05020084f, -0.08058300f, 0.13076033f, -0.09448870f, 
    -0.13722019f, -0.18750936f, -0.01561979f, -0.16653693f, -0.09734295f, 0.11309279f, 0.09134360f, 0.09834733f, 
    0.14928362f, -0.15153262f, 0.01481457f, -0.09305985f, -0.04976340f, 0.04343087f, -0.01257259f, 0.03184563f, 
    0.00148249f, 0.12393557f, -0.14136805f, -0.16478533f, 0.03882245f, -0.14099038f, -0.13881266f, -0.01834774f, 
    -0.08848571f, 0.17490105f, 0.02849169f, -0.17475246f, 0.05528544f, 0.06705540f, -0.11289912f, -0.04921636f, 
    -0.92965353f, 0.29077387f, 0.06440512f, -0.37774795f, -0.15200707f, -0.15458247f, -0.26868004f, 0.14811544f, 
    -1.19995785f, 0.12116951f, 0.49801910f, -0.27463931f, 0.05128088f, 0.18065999f, 0.13734908f, -0.32386509f, 
    0.41750795f, 0.02223687f, 0.23887482f, -0.41861358f, 0.12396193f, 0.55757278f, 0.16391328f, 0.11033329f, 
    0.42349035f, 0.32998604f, -0.16778027f, -0.24510755f, 0.20927049f, -0.07416175f, 0.33423957f, -0.09472036f, 
    0.47018585f, -0.21113308f, 0.38844237f, -0.82830822f, 0.05033923f, 0.13418666f, -0.20058356f, -0.07914740f, 
    0.17992692f, -0.01550047f, 0.04882516f, 0.07872450f, 0.08427388f, -0.03704992f, -0.40895912f, 0.11133906f, 
    -0.21307136f, 0.16939741f, 0.08296639f, 0.18386886f, 0.06219059f, 0.09536941f, 0.07596456f, -0.23859096f, 
    0.11450411f, 0.23633999f, -0.07759159f, 0.45661885f, -0.37143984f, 0.24179740f, -0.44453734f, 0.12805001f, 
    0.20008619f, -0.01508667f, 0.14918314f, 0.46607476f, -0.09752947f, -0.07919259f, 0.00996773f, 0.01776954f, 
    -0.22318953f, 0.04541390f, 0.03370740f, -0.03211306f, 0.03161272f, 0.47266635f, -0.04197710f, 0.12134839f, 
    0.13106312f, -0.16364530f, -0.55793673f, 0.19163758f, -0.05212349f, 0.30885226f, -0.26616088f, -0.60272235f, 
    0.19869375f, -0.38023469f, -0.14542378f, -0.17111659f, 0.11285508f, -0.44964284f, 0.00603959f, -0.76367635f, 
    -0.35656086f, 0.12827639f, 0.20782393f, 0.46023232f, 0.04450838f, -0.38978294f, 0.14748888f, 0.12448829f, 
    -0.14658661f, 0.08309696f, -0.55045712f, 0.01642799f, -0.02117845f, 0.37736177f, -0.11395571f, 0.13556784f, 
    0.14971575f, 0.15568747f, 0.01733798f, 0.18594953f, 0.39708781f, 0.03326034f, -0.04314412f, -0.11390936f, 
    0.26387590f, 0.16460484f, -0.17566429f, -0.13035762f, -0.00412619f, -0.02086558f, 0.86821276f, 0.03208092f, 
    0.45173022f, 0.15833661f, -0.09475597f, 0.41521937f, -0.02307580f, 0.25944009f, -0.00370729f, -0.02126520f, 
    0.14468323f, 0.05713696f, 0.38560778f, 0.14211883f, 0.38251257f, 0.04817702f, -0.00304198f, 0.37120488f, 
    0.28992873f, -0.07672534f, 0.14370263f, 0.51332295f, 0.08958642f, 0.28206232f, -0.06012715f, 0.09142613f, 
    -0.09646251f, 0.17781678f, 0.06137649f, -0.06437161f, 0.13104521f, -0.20107360f, -0.60337371f, 0.01312570f, 
    -0.82780057f, 0.01521861f, 0.32811606f, 0.00485435f, -0.06489068f, -0.29317114f, 0.09566557f, 0.00650007f, 
    -0.21510154f, -0.04402171f, -0.43201542f, -0.18615425f, 0.25740686f, 0.16879588f, -0.31686589f, -0.28023040f, 
    0.06058255f, -0.15309530f, 0.09108363f, -0.18462010f, 0.35534853f, -0.14687863f, 0.16235340f, -0.68270439f, 
    0.45322156f, 0.03494306f, -0.06444563f, -0.70356077f, -0.02840077f, 0.12326364f, -0.10572236f, 0.04568719f, 
    -0.07333645f, 0.16510563f, 0.31623161f, -1.12328255f, 0.16390249f, -0.47344670f, -0.43156362f, 0.12154862f, 
    0.11159766f, 0.13072252f, -0.21784675f, -0.04562055f, -0.99530083f, 0.12664442f, -0.39961123f, -0.41291407f, 
    0.15178122f, 0.03910121f, 0.02104831f, 0.00081654f, -0.22157772f, 0.44508141f, -0.19604628f, -0.28749964f, 
    0.17971751f, -0.02655477f, -0.11133718f, 0.36129856f, 0.20231394f, -0.30479646f, -0.56549597f, -0.12100815f, 
    -0.01541629f, -0.37721908f, -0.13817847f, 0.62336850f, 0.01576511f, -0.11804667f, 0.27645528f, 0.13011248f, 
    0.50785470f, 0.16443580f, -0.00986219f, -0.57403088f, 0.44323581f, 0.06381386f, -0.03590204f, -0.07796621f, 
    -0.07499163f, -0.09657573f, -0.05812803f, 0.26452428f, 0.35005206f, -0.01533336f, 0.12251633f, -0.18602832f, 
    0.31638187f, -0.42067593f, 0.07144576f, 0.56193215f, -0.25898963f, 0.07989191f, 0.60331869f, 0.06449901f, 
    0.15218253f, -0.10513777f, 0.04024566f, 0.09377256f, -0.02893356f, -0.15791100f, -0.16254210f, -0.06501333f, 
    0.11355861f, 0.06632254f, 0.04922541f, -0.17355378f, -0.12662196f, 0.14303032f, -0.01703772f, -0.01578359f, 
    0.05704914f, -0.07423674f, -0.04921682f, -0.01686428f, -0.20159596f, -0.17481546f, -0.04844916f, 0.14725950f, 
    -0.05946507f, 0.04356890f, 0.05483646f, -0.03652863f, 0.01246599f, 0.09401695f, 0.10150253f, -0.00345136f, 
    0.19263734f, -0.52447468f, -0.56562638f, 0.54281193f, 0.15053838f, 0.17257449f, 0.21440248f, 0.04327086f, 
    0.26566058f, 0.03633113f, -0.24189107f, -0.45287371f, 0.25752431f, -0.48670721f, 0.36965510f, 0.19962789f, 
    -0.19704519f, 0.02810425f, 0.04756935f, -0.14331122f, -0.01106265f, -0.15489933f, -0.02046403f, 0.12171985f, 
    -0.01897874f, -0.08439270f, 0.12395432f, 1.09929061f, -0.48515302f, 0.14848864f, 0.42647547f, 0.08608322f, 
    -0.20486313f, 0.07702398f, -0.27490085f, -0.33845121f, -0.10123877f, 0.05757040f, 0.06629672f, -0.16713788f, 
    -0.61707366f, 0.14297958f, 0.22433822f, -0.41770434f, -0.04224986f, -0.10786786f, 0.46723935f, -0.24161437f, 
    0.12113355f, -0.09381429f, 0.35988736f, -0.57016844f, 0.24814731f, -0.19333868f, 0.15591377f, 0.04841402f, 
    0.12998907f, 0.32274306f, 0.05781618f, 0.72255391f, -0.36444846f, 0.33081320f, 0.44102016f, 0.39062181f, 
    0.01375482f, 0.00518816f, -0.13615516f, 0.43850324f, 0.09112172f, -0.11940426f, 0.14940801f, -0.03180386f, 
    0.07905903f, 0.17000102f, -0.02637241f, -0.33462575f, 0.24938583f, 0.30669227f, 0.08398067f, 0.07015065f, 
    0.21340446f, -0.05174455f, -0.18605964f, 0.14765625f, -0.06651802f, 0.17895725f, -0.07369518f, -0.13098127f, 
    -0.02293123f, -0.39051235f, 0.08265322f, 0.33043221f, 0.09604228f, -0.10802019f, 0.26215637f, -0.08643775f, 
    0.63745314f, 0.11106205f, -0.11439376f, 0.49550092f, 0.10719728f, 0.72903514f, 0.03958855f, -0.07183213f, 
    0.13107903f, -0.13228029f, 0.67167914f, 0.05572603f, 0.30769140f, 0.10861540f, 0.22503719f, 0.34706247f, 
    0.58413291f, -0.09018768f, 0.01944120f, 0.39421797f, -0.01936151f, 0.15979283f, -0.07052881f, 0.59645516f, 
    -0.08127935f, 0.38245305f, 0.14559697f, 0.30861047f, -0.05671593f, -0.13936749f, -0.50990301f, -0.02248826f, 
    0.05477379f, -0.13471816f, -0.01339066f, -0.01726105f, -0.06276456f, -0.20084658f, 0.03445475f, 0.14573848f, 
    0.06268876f, 0.13329478f, -0.02049084f, 0.21888809f, -0.22558251f, 0.09659137f, 0.32848826f, 0.05860456f, 
    -0.02347443f, -0.02506869f, -0.20625952f, -0.19373277f, -0.14248087f, -0.11731555f, -0.17050162f, 0.05566080f, 
    -0.29842076f, -0.03179616f, 0.09270094f, 0.07959992f, 0.21340512f, -0.00923164f, -0.10758583f, -0.06776311f, 
    0.17978230f, 0.20047390f, -0.27682516f, -0.19592738f, 0.11937147f, -0.18994814f, 0.31157249f, -0.14449789f, 
    0.29517758f, 0.15822940f, -0.42102182f, 0.13414611f, -0.04313371f, -0.16460975f, -0.34950295f, 0.37952718f, 
    0.15738936f, 0.09324438f, 0.11141641f, 0.04059463f, 0.20769674f, -0.37943813f, 0.28401113f, -0.11036002f, 
    0.04822340f, 0.49779701f, 0.07263268f, 0.73070151f, 0.21860120f, 0.09645781f, 0.33770886f, 0.24071406f, 
    0.15463547f, 0.06251273f, 0.26580691f, -0.10792682f, -0.09382765f, 0.21059464f, -0.11507414f, 0.07403280f, 
    0.16468437f, -0.16820236f, 0.67085189f, 0.12211308f, 0.15660164f, 0.06811505f, -0.08966676f, 0.02159000f, 
    0.43272653f, 0.07927222f, -0.01438316f, 0.06684336f, -0.10328602f, 0.48330343f, -0.02307286f, -0.03164477f, 
    0.24136262f, 0.62205869f, 0.03716136f, -0.14782965f, 0.19647144f, -0.25894523f, -0.57715356f, 0.01919245f, 
    0.06906115f, -0.20727584f, -0.40724525f, 0.78760350f, -0.10663895f, 0.45773146f, 0.16926411f, -0.10209076f, 
    0.23362522f, -0.14853287f, -0.42268866f, -0.17704645f, 0.27047494f, -0.23470543f, -0.22060394f, 0.50718617f, 
    -0.25162980f, 0.05480747f, -0.01973487f, 0.23159580f, 0.05450200f, -0.29164541f, 0.11632223f, 0.04473438f, 
    -0.13069615f, -0.13239208f, 0.08302034f, 0.18301266f, 0.17104864f, -0.14105773f, 0.16215785f, -0.12943438f, 
    -0.01642307f, -0.09608456f, -0.38492897f, 0.57346147f, 0.03102805f, 0.14356138f, 0.34046724f, -0.14659443f, 
    0.39447704f, 0.05430805f, -0.62091261f, -0.02997164f, 0.12284157f, -0.07270103f, -0.19726226f, 0.55804312f, 
    -0.07693594f, 0.11270459f, -0.08652139f, 0.26541409f, 0.21352911f, 0.14958794f, 0.15782554f, 0.01638119f, 
    0.10766307f, -0.29492575f, -0.03219351f, -0.80481130f, 0.26456752f, -0.25330922f, -0.09727175f, -0.13774213f, 
    0.30034751f, -0.23535898f, -0.22235744f, -0.58478326f, 0.16974685f, 0.05223742f, 0.19104350f, -0.12660365f, 
    0.18891738f, 0.09570679f, 0.52059066f, -0.14225705f, 0.19407305f, -0.90208524f, 0.31504932f, -0.11823879f, 
    0.12725954f, -0.12699752f, 0.17665006f, -0.16422758f, 0.13127218f, -0.03529508f, 0.09675934f, 0.04009072f, 
    -0.05550918f, 0.33897918f, -0.06836836f, 0.62460446f, -0.24302393f, 0.04978450f, 0.02796724f, 0.25400552f, 
    0.35109445f, 0.26150328f, -0.10352891f, 0.05482427f, -0.13231093f, 0.29994750f, 0.05865101f, -0.17427467f, 
    -0.14901334f, 0.02259178f, 1.02163124f, 0.05539474f, -0.06265450f, 0.13595028f, -0.37317857f, 0.09007029f, 
    0.21593790f, 0.15297131f, -0.13413067f, 0.40375626f, 0.00170427f, 0.26857269f, 0.02007857f, 0.37700602f, 
    -0.18785219f, 0.00880779f, 0.13653356f, 0.21138936f, 0.19952837f, 0.04256916f, -0.29547614f, -0.31672361f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.23647863f, 0.83719158f, 0.08210244f, 0.18883039f, -0.17540483f, -0.06316071f, -0.07538582f, -0.06431353f, 
    0.37500596f, 0.52260000f, -0.02477401f, -0.15509643f, 0.18229280f, 0.35557097f, -0.29647905f, -0.10611167f, 
    0.39091554f, 0.51524037f, 0.57569832f, 0.09011974f, -0.12794469f, -0.02759779f, 0.37445492f, -0.39679137f, 
    0.33915401f, 0.26262447f, -0.25682867f, -0.27100787f, 0.25180525f, 0.32010335f, -0.00637435f, -0.10616975f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.09424251f, -0.07178381f, 0.13875104f, -0.08573141f, 0.01029454f, 0.02949692f, 0.20365801f, 0.23007236f, 
    -0.49893713f, -0.31352893f, -0.10504331f, 0.14833659f, -0.79699600f, -0.07634278f, 0.95556557f, 0.06631246f, 
    0.07950652f, -0.39355567f, -0.90352714f, 0.11703668f, -0.12236718f, -0.00673632f, 0.40939987f, 0.31744790f, 
    0.13396376f, -0.04787502f, -0.19910398f, 0.16912429f, 0.13495198f, 0.07766590f, -0.58932024f, 0.17861584f, 
    -0.13568150f, 0.19585237f, -0.08957447f, -0.36643732f, 0.14151461f, -0.05225981f, 0.56314200f, 0.21144365f, 
    -0.16150232f, -0.17735608f, -0.13837467f, -0.06708000f, 0.29596424f, 0.40978765f, -0.02477244f, -0.45531008f, 
    0.21911123f, 0.46474981f, 0.38792130f, -0.27340385f, -0.13825475f, -0.30605406f, -0.50866604f, -0.50267649f, 
    0.20081048f, 0.00423520f, -0.31736499f, 0.17548063f, -0.03225913f, 0.26085666f, -0.14203632f, 0.00389554f, 
    -0.89333779f, 0.45986995f, 0.34798136f, -0.12561354f, -0.12928434f, -0.03585545f, -0.47763538f, -0.24504603f, 
    0.04601173f, 0.15954813f, -0.14511721f, -0.08444943f, -0.65329027f, 0.18109493f, -0.29328084f, -0.18344608f, 
    -0.26124126f, -0.72988605f, -0.21370083f, 0.38017061f, -0.14354186f, 0.65093338f, 0.09811249f, -0.43468818f, 
    0.09645527f, 0.11808790f, -0.14430906f, -0.36453408f, 0.14448820f, -0.64548934f, 0.23856890f, -0.22675301f, 
    0.12778819f, -0.32417241f, -0.56435865f, 0.29281548f, 0.17642480f, 0.03947815f, -0.74563038f, -0.18157797f, 
    -0.22044559f, 0.09716219f, 0.05167428f, -0.12938902f, -0.31045279f, -0.30799583f, -0.16635817f, 0.31696355f, 
    0.03323155f, -1.14135957f, -1.28958786f, 0.32637030f, -0.01025904f, 0.24014848f, 0.11696130f, 0.13769545f, 
    0.20799740f, -0.31078315f, 0.17498764f, -0.42172873f, 0.21637669f, 0.19840202f, -0.28411508f, -0.06225217f, 
    0.18175913f, -0.32198185f, 0.16071545f, -0.46198088f, 0.04256941f, -0.12201013f, -0.27330720f, 0.16469291f, 
    0.06645039f, -0.29332015f, 0.05152687f, -0.13044097f, 0.00115153f, -0.26522529f, -1.08358979f, 0.16458218f, 
    -0.04967469f, -0.02353221f, 0.23988380f, 0.23753804f, -0.07015572f, 0.38337320f, -0.91677719f, 0.05927926f, 
    0.03751466f, -0.18002835f, 0.32907337f, -0.08476930f, 0.25291333f, 0.34468183f, -0.04909764f, -0.07349465f, 
    -0.00713221f, 0.06729612f, -0.34719715f, -0.27768871f, -0.08490852f, 0.04660366f, 0.34617615f, 0.30524901f, 
    -0.04252817f, 0.11934808f, 0.05082531f, 0.10771719f, -0.06163308f, 0.09016775f, -0.62423396f, -0.14752094f, 
    -0.02763567f, -0.06199657f, -0.85915607f, 0.21347602f, 0.15618944f, -0.07541130f, -0.20822211f, -0.00842877f, 
    0.11436068f, -0.26088342f, 0.13085054f, 0.12550005f, -0.08503789f, -0.07157444f, 0.05939468f, 0.04478464f, 
    -1.12732244f, 0.50330967f, 0.61735588f, 0.36801165f, 0.02300295f, 0.05601399f, -0.06305449f, -0.00205643f, 
    0.13341874f, 0.37258199f, 0.00696689f, 0.04474570f, -0.14412026f, 0.17374428f, -0.24267991f, 0.16979025f, 
    -1.30588233f, 0.22836563f, -0.00899448f, 0.18837693f, 0.14117274f, -0.43413848f, -0.05027474f, -0.75648022f, 
    -1.40323961f, 0.15978821f, -0.10048728f, -0.89546895f, -1.00955927f, -0.69110060f, 0.17649898f, -0.34863505f, 
    0.47320518f, -0.55726814f, -0.33950925f, 0.27020514f, 0.10587589f, -0.15614986f, 0.38770103f, -0.22267550f, 
    -0.27196294f, -0.30884594f, 0.02801598f, 0.01980189f, 0.45347208f, -1.08849907f, 0.04415026f, 0.26544848f, 
    -0.11613643f, 0.03135217f, -0.94108176f, 0.06879038f, -0.06811416f, -0.27915221f, -0.15641452f, -0.09959276f, 
    -0.05270994f, 0.31579685f, -0.34443718f, 0.29652095f, -0.75342810f, -1.46938348f, -0.29142988f, -0.08148403f, 
    0.64448422f, 0.25308365f, -0.47039080f, -0.41635969f, -0.06342845f, 0.02652961f, -0.57025278f, -0.23139411f, 
    0.35168639f, 0.04352578f, -0.04016536f, -0.11162182f, 0.27256969f, -0.23107679f, -0.27859387f, -0.41365731f, 
    -0.05273347f, -0.31552359f, -0.82494968f, -0.92113864f, -0.08277976f, -0.93017733f, 0.22983429f, -0.27633080f, 
    0.14949279f, -0.28251889f, -0.16333041f, -0.00633725f, -0.60093147f, -0.15195291f, 0.12740657f, 0.16037135f, 
    -0.93097860f, 0.27578339f, -0.24575408f, 0.38970461f, -0.15372682f, -0.01703646f, -0.17315665f, 0.14200124f, 
    0.29816070f, 0.30216610f, 0.10449851f, -0.03703353f, -0.50076735f, -0.26234633f, 0.06974104f, 0.15761015f, 
    -0.10148696f, 0.19569676f, -1.05910373f, 0.23174895f, -0.13675335f, -0.15554823f, -0.08487132f, -0.75944489f, 
    -0.21352334f, 0.19594511f, -0.01423074f, -0.63506687f, 0.14785221f, 0.53940809f, -0.04782621f, -0.97638816f, 
    -0.20094207f, -0.53328836f, -0.25388733f, -0.66468954f, 0.17525519f, -0.15430640f, 0.30118835f, -0.70922267f, 
    0.11999580f, -0.12244042f, -0.10759829f, 0.03172614f, -0.88310349f, 0.33507690f, -0.19163129f, -0.65379453f, 
    0.21050930f, -0.61787862f, -0.57345641f, -0.52501035f, -0.12132550f, -0.31058243f, 0.15321681f, -0.30750161f, 
    0.28937086f, -0.10490930f, 0.29636869f, 0.35121137f, -0.80290866f, -0.64710110f, 0.35806412f, 0.05937380f, 
    0.22635137f, -0.51818115f, 0.20771500f, 0.16783047f, 0.12315916f, -0.02905623f, -0.13230497f, -0.43148443f, 
    0.30558521f, -0.12377320f, -0.10343973f, 0.01744064f, 0.18204351f, 0.23348328f, -0.42618343f, 0.24726814f, 
    -0.36971208f, 0.21718368f, 0.37456170f, -0.26597816f, 0.14594008f, -0.23339640f, 0.35044718f, -0.91623259f, 
    -0.26567721f, -0.39332920f, 0.07881469f, -0.10364998f, 0.04123213f, -0.06777257f, 0.07331446f, -0.79629427f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.18322276f, 0.52919763f, 0.02033002f, 0.15216617f, -0.43633571f, -0.21225639f, -0.22660375f, -0.40146250f, 
    0.45057872f, 0.56989717f, -0.19331193f, -0.09304395f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
