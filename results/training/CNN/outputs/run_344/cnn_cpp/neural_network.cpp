#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.71660638f, 1.10409236f, 0.97528040f, 1.30561304f, 1.13715804f, 1.06869423f, 0.05339132f, -0.17124726f, 
    -0.66644156f, 0.11990169f, 0.13821475f, -0.04999308f, 0.14917555f, -0.04132062f, -0.43596667f, -0.38355327f, 
    -0.40358448f, 0.45917177f, -0.14030765f, -0.35023722f, 0.45358384f, 0.25385985f, -0.34767342f, -0.19732006f, 
    0.14999636f, -0.00369178f, -0.45982680f, -1.00133181f, -0.60009092f, -0.41241172f, 0.75539929f, 0.57047236f, 
    -0.13392039f, 1.11956370f, 0.99923897f, -0.25241908f, 0.16993701f, 0.02822172f, 0.25286484f, -0.16144435f, 
    0.00146978f, 0.23468371f, 0.07562983f, 0.28955609f, 0.00094250f, -0.45600834f, 0.24463643f, -0.40475795f, 
    0.13440779f, 0.49009126f, 1.37137425f, 0.64481932f, 0.64045590f, 1.03161418f, -0.72961181f, -0.04753279f, 
    -1.16329861f, -0.81828952f, -0.18155649f, -0.12040279f, 0.08549189f, 0.30206549f, 0.60901874f, -0.21665703f, 
    0.07126561f, 0.34801432f, -0.30193496f, 0.45386916f, 0.05198931f, 0.19753505f, 0.27329111f, 0.25936952f, 
    0.56684566f, -0.12115924f, 0.20188709f, 1.08464718f, -1.30262339f, -1.36425245f, 0.38557750f, -0.49549112f, 
    -1.39959860f, 0.63379943f, -0.81359977f, 0.01652133f, 0.52786231f, 0.37039348f, 0.20895666f, 0.02764623f, 
    0.01960596f, 0.11992076f, -0.02128466f, -0.19857879f, 0.02378330f, -0.01510609f, -0.09054273f, 0.01559896f, 
    0.12211622f, -0.05598227f, 0.26404196f, 0.43043160f, 0.73038703f, 0.63413948f, -1.00256646f, -1.26428819f, 
    -0.41032735f, 1.32408404f, 0.51041675f, -0.18360777f, 0.42511770f, 0.58616191f, -0.23749010f, -0.39591718f, 
    -0.54046649f, -0.43868631f, -0.21780111f, -0.15946855f, -0.01233308f, 0.05889343f, 0.07904355f, 0.07960466f, 
    0.15740359f, -0.25029770f, -0.36398780f, -0.22619763f, 0.02320625f, 1.20815527f, 0.34236115f, -0.34134910f, 
    1.13520420f, 0.49681431f, 0.65665007f, 0.09733918f, 0.24759303f, 0.84860879f, 1.17200470f, -0.66375327f, 
    -0.42906851f, -0.15245460f, -0.64313745f, -0.20290412f, -0.16129509f, -0.28202137f, -0.46221763f, -0.73523372f, 
    0.07979532f, -0.28479561f, -0.68839389f, 0.14201002f, -0.24854894f, -0.44260964f, 0.10909870f, -0.39196405f, 
    -0.57112020f, -0.55456984f, 0.29267055f, -1.08740592f, 0.45133364f, 1.31871605f, 0.45577613f, -0.88973618f, 
    -0.55720198f, -0.52401364f, 0.82304764f, 0.12917958f, -0.48636821f, -0.12763032f, -0.26114169f, -0.14218259f, 
    -0.32850397f, -0.59372580f, 0.01580521f, 0.01422080f, 0.09576710f, 0.14644505f, 0.15901671f, -0.86968529f, 
    -1.10777438f, -1.27365637f, -0.62801230f, -0.25909925f, -0.06362731f, 0.24725550f, 0.51046968f, 0.13715260f, 
    0.65651208f, -0.48705199f, 0.11805985f, 0.04436395f, -0.41678017f, -0.34924600f, -0.00659141f, -0.08041559f, 
    0.54804724f, -0.11895548f, -0.19700362f, -0.29661930f, 0.25251922f, -0.53985643f, -0.20183639f, 0.08726896f, 
    0.90108621f, -0.28696865f, 1.50864017f, -0.05962450f, -1.14413953f, 0.75905567f, -0.80310935f, -0.00332452f, 
    -0.29240099f, 0.67199677f, 0.32885852f, 0.01624322f, -0.23913762f, 0.58811557f, -0.32739788f, -0.16069676f, 
    -0.12610523f, -0.19222984f, -0.31848747f, 0.20088425f, -0.14699630f, 0.51031673f, 0.14595567f, -0.04928572f, 
    0.24304031f, -0.89222640f, -1.61655283f, -0.68633020f, 0.66494596f, -0.06653846f, 0.55898798f, -0.01615185f, 
    0.31037021f, 0.36832583f, -0.28255478f, 0.23703191f, -0.06266957f, -0.06027380f, 0.59189141f, 0.40194809f, 
    0.40821880f, -0.25258324f, -0.47796670f, -0.43991831f, -0.10578574f, 0.02578379f, 0.29477158f, -0.14168806f, 
    0.33158770f, -0.43430576f, 1.49411595f, 1.15288889f, 0.93510014f, -0.65683061f, -0.53554332f, -0.57253581f, 
    0.94365370f, -0.51009780f, -0.08288771f, 0.36132118f, 0.08554397f, 0.42996922f, -0.31980482f, 0.06471886f, 
    0.52094483f, 0.01066523f, -0.10560431f, 0.25231761f, 0.26070875f, -0.15208019f, -0.02774985f, 0.06705748f, 
    0.40195930f, 0.21700999f, 0.36112398f, 0.56524038f, -2.10419941f, 0.75012195f, 1.11412096f, 0.40007925f, 
    0.00851159f, 1.38734937f, 0.47031683f, -0.04039493f, 0.87028348f, 0.07120872f, 0.80708224f, -0.01761984f, 
    0.17570816f, -0.28442740f, -0.28132713f, -0.07488488f, 0.05235408f, 0.05713380f, -0.23744327f, 0.01834917f, 
    0.11022659f, 0.22721155f, 0.01257886f, -0.21630448f, -1.06075895f, -0.98377466f, -0.52567810f, 0.89622080f, 
    0.95850241f, 1.20105350f, 0.70636934f, 0.40347904f, 0.30185136f, -0.57895505f, 0.19421774f, 0.20857956f, 
    0.28050810f, 0.63317418f, 0.51225108f, -0.16931339f, 0.36264566f, 0.62528050f, 0.08046114f, 0.14324193f, 
    -0.10462847f, -0.13319784f, -0.53497046f, -0.15818149f, -0.08673073f, -0.45371884f, -1.11324441f, -0.56373811f, 
    -0.79588199f, -0.33302191f, -0.49213016f, -0.07218117f, -0.83164227f, -0.29934222f, -0.54552680f, -0.62383395f, 
    0.04982413f, -0.02816658f, 0.00143886f, -0.50651556f, -0.09794983f, -0.33968192f, -0.44807380f, 0.02386834f, 
    0.71615154f, -0.21208650f, 0.16679156f, 0.31161946f, 0.69185096f, -0.13147411f, -0.44747776f, 0.15010107f, 
    0.88711834f, 0.19812496f, 1.06461859f, -1.38737845f, -0.45066485f, -1.06301510f, -1.26542759f, -0.02666017f, 
    0.78682411f, 0.51528561f, -0.01251365f, -0.00630882f, 0.26668483f, 0.26412472f, 0.06860918f, 0.11464036f, 
    0.04883077f, 0.61997813f, 0.48642212f, -0.17818303f, -0.03427076f, 0.06269752f, 0.04999496f, 2.02600408f, 
    0.10703190f, 0.64961123f, 1.84832799f, 0.90475637f, -0.46853840f, 0.24002913f, 0.22393428f, 0.52155364f, 
    0.01206257f, -0.17863391f, -0.06488740f, -0.15620761f, 0.42652729f, -0.01920221f, 0.39823648f, 0.29782069f, 
    0.32624334f, 0.26040825f, 0.15513273f, 0.26174647f, 0.18201996f, 0.01289095f, 0.00976201f, 0.34551764f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.11285555f, 0.11345620f, 0.10691652f, 0.63388819f, 0.07528649f, 0.08363414f, 0.33130410f, 0.18890236f, 
    0.02489242f, 0.14242159f, 0.35808727f, 0.50511736f, 0.46013194f, 0.42494425f, 0.46421871f, 0.29453367f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.16567026f, 0.12778930f, -0.07601760f, 0.19135270f, -0.43389946f, -0.03178946f, 0.20589213f, 0.01296955f, 
    -0.02598731f, 0.14790675f, -0.16075982f, -0.10498883f, 0.59103483f, 0.13389333f, -0.25842997f, -0.52362376f, 
    0.08910512f, -0.00545286f, 0.10544480f, -0.13308620f, 0.13720447f, 0.04490000f, 0.03224102f, 0.12569351f, 
    0.22734566f, -0.12997791f, -0.11058706f, 0.05111355f, 0.11511780f, -0.02082345f, -0.23102815f, 0.21221775f, 
    -0.27653876f, 0.08006642f, -0.29293281f, 0.14341244f, -0.23328717f, -0.56592643f, 0.26787561f, 0.36218742f, 
    -0.08610490f, -0.13390256f, -0.00881488f, -0.10213511f, 0.09335421f, 0.04962415f, -0.14694624f, -0.00877479f, 
    0.55329955f, -0.03279522f, 0.30773619f, -0.58665550f, 0.03557533f, 0.03689341f, 0.25551492f, 0.09748482f, 
    -0.17986599f, 0.25035179f, 0.03153228f, 0.12417635f, 0.19079083f, 0.05780366f, -0.19550139f, 0.72120941f, 
    -0.39122725f, 0.22548647f, -0.12257380f, 0.11300524f, -0.08399934f, 0.02392667f, -0.04857472f, 0.13675937f, 
    -0.36138687f, 0.48467505f, 0.02824038f, -0.34633860f, -0.12071454f, -0.05610108f, -0.03007142f, -0.19541855f, 
    0.01252408f, 0.16474262f, -0.00420463f, -0.03839964f, 0.31683958f, 0.10760355f, -0.14568916f, -0.74750078f, 
    0.00358979f, -0.16312021f, 0.12275163f, 0.06562603f, -0.17298983f, -0.13934141f, -0.10151564f, 0.04389623f, 
    -0.02674441f, -0.30065286f, -0.33212781f, 0.16464517f, -0.10574707f, -0.09288953f, 0.04131857f, -0.13299653f, 
    -0.34418553f, 0.22453022f, -0.11968227f, 0.05884674f, -0.06786209f, -0.10300217f, -0.01181465f, 0.24848661f, 
    0.17072603f, 0.33878464f, -0.11860910f, 0.05359911f, 0.16428044f, -0.02686949f, 0.15512210f, -0.20186944f, 
    -0.24483229f, 0.19088310f, 0.07265632f, -0.44757870f, -0.13580075f, -0.10187953f, -0.13447726f, 0.19897926f, 
    -0.07977898f, 0.05902009f, 0.08667205f, -0.19639346f, -0.10164833f, 0.14306158f, -0.34458360f, 0.31516969f, 
    -0.18025000f, -0.04493119f, 0.08338171f, -0.17434759f, 0.01231141f, 0.14135706f, -0.13335054f, 0.02842205f, 
    -0.82074374f, -0.01557515f, -0.03301070f, -0.09443352f, 0.21751410f, -0.02150747f, -0.00506296f, 0.00568326f, 
    0.18882087f, -0.16506441f, -0.00042979f, 0.06609037f, -0.53808129f, -0.58565539f, 0.07714386f, -0.27954036f, 
    0.05580644f, 0.22526979f, 0.22430164f, 0.17358401f, -0.04522167f, -0.11860335f, -0.15230320f, -0.36833441f, 
    -0.12053460f, -0.15384939f, 0.08745454f, 0.09396264f, -0.09132852f, -0.06935565f, -0.12236585f, -0.20542009f, 
    0.13484809f, -0.06263607f, 0.00051407f, 0.01595380f, 0.60227329f, 0.06280632f, -0.54229289f, 0.64560109f, 
    -0.20353355f, -0.05265655f, -0.06353141f, 0.06809539f, -0.07366208f, 0.12191023f, 0.02977139f, -0.07713264f, 
    0.19731310f, -0.01455659f, 0.14458169f, 0.29187879f, -0.27693322f, -0.02908061f, 0.12434153f, 0.00193780f, 
    -0.26802140f, -0.11737518f, -0.02098384f, -0.04804103f, 0.18697920f, -0.49497625f, -0.00687966f, -0.17932837f, 
    0.18429172f, -0.06500575f, -0.03078970f, 0.16166131f, -0.05996135f, 0.02033091f, 0.09657282f, -0.00957446f, 
    0.06333774f, 0.00918853f, 0.04272474f, 0.08729201f, -0.22243072f, -0.16681787f, 0.29383907f, 0.08812562f, 
    0.17674959f, 0.03068960f, 0.15444542f, 0.10058928f, 0.42262521f, -0.69747126f, -0.75771677f, -0.08047093f, 
    -0.05372720f, 0.06181800f, -0.15898713f, 0.22615568f, -0.03790202f, 0.02954962f, -0.05594020f, -0.12552749f, 
    -0.13122551f, -0.56505316f, 0.23524377f, -0.38059902f, 0.15007536f, -0.26654351f, -0.23752944f, -0.08155332f, 
    0.14020634f, -0.14961205f, -0.18834549f, -0.12588839f, 0.51418060f, -0.03576997f, 0.33872131f, 0.15732680f, 
    -0.05453921f, 0.01560255f, 0.06763630f, -0.03947217f, 0.10397801f, 0.15900844f, -0.08050080f, -0.07907176f, 
    -0.46839523f, -0.47344226f, -0.01731906f, -0.37413260f, 0.09092306f, -0.04540844f, -0.32627955f, 0.04691152f, 
    -0.09524837f, -0.38170367f, -0.16874138f, -0.18235858f, 0.03792980f, 0.03849373f, 0.18635029f, -0.07721581f, 
    0.21214858f, 0.05228803f, 0.10189453f, -0.05015593f, 0.27364445f, -0.19630989f, 0.02949100f, -0.11539528f, 
    -0.31866965f, 0.36813825f, -0.07538334f, -0.21592474f, -0.18011034f, -0.04587526f, 0.11316148f, 0.09998593f, 
    -0.09764314f, -0.09611014f, 0.18198001f, -0.41980335f, 0.05040575f, 0.27448678f, -0.25938961f, 0.15910259f, 
    -0.05683197f, 0.05803834f, 0.15201594f, -0.03125339f, -0.10856536f, 0.11429755f, -0.45955643f, 0.34076840f, 
    0.40649733f, 0.16035567f, -0.07606147f, -0.11661832f, -0.02457692f, -0.07613259f, -0.08115357f, -0.02731372f, 
    0.08295388f, 0.08797196f, -0.03668935f, 0.33213282f, 0.32584247f, -0.25389588f, 0.10820642f, 0.12244660f, 
    -0.19456251f, 0.10065811f, 0.08577829f, -0.07669096f, 0.04360127f, -0.18306382f, 0.13351080f, 0.14008769f, 
    0.32694054f, 0.40705636f, -0.49177125f, 0.21750237f, 0.33385745f, 0.13554624f, -0.42609289f, 0.04471414f, 
    -0.15186253f, 0.12123369f, 0.30759442f, -0.08639859f, -0.00650527f, -0.08554686f, 0.20204441f, -0.30209783f, 
    -0.03927014f, -0.23360503f, 0.05490641f, -0.09592825f, 0.00268884f, 0.09728346f, -0.02847051f, 0.01367600f, 
    -0.39236531f, -0.18945937f, -0.13709234f, -0.29596898f, 0.03117225f, 0.03139388f, -0.11854865f, 0.10399432f, 
    -0.10528437f, 0.14464012f, 0.12490510f, 0.07587959f, 0.31531668f, -0.25536203f, 0.18268105f, 0.40264443f, 
    -0.13333488f, 0.07953420f, -0.21320589f, 0.02569373f, 0.14903612f, -0.07678898f, -0.10072958f, -0.02027920f, 
    0.03552128f, -0.20126745f, 0.16933317f, 0.04783298f, 0.26340708f, -0.00234258f, -0.02198563f, -0.25176898f, 
    0.06551227f, 0.37356740f, -0.06364240f, 0.21988806f, 0.22840190f, 0.19179456f, 0.34365195f, 0.26075742f, 
    0.01699724f, -0.36503112f, 0.02231557f, 0.31727356f, -0.13245000f, 0.07125556f, 0.08311653f, 0.10685714f, 
    -0.71813345f, -0.03064033f, -0.04216215f, -0.60371882f, -0.00797554f, 0.17715408f, 0.03415358f, -0.04697512f, 
    -0.12494250f, -0.04792636f, -0.04324106f, -0.13754945f, 0.81275171f, -0.30067003f, 0.18263441f, -0.25668669f, 
    -0.03415947f, -0.02699033f, 0.18085207f, 0.06702119f, -0.06379296f, -0.03882671f, -0.06204158f, -0.18410136f, 
    0.16002862f, 0.02594417f, 0.08567237f, 0.14880089f, 0.09392679f, -0.23431519f, 0.19524211f, -0.12227006f, 
    -0.12351792f, -0.02903604f, 0.20216228f, -0.13089684f, 0.36712214f, -0.12347430f, -0.07819560f, -0.31986856f, 
    0.27433658f, -0.00948261f, -0.04055398f, 0.07623201f, -0.11781324f, 0.17099798f, 0.02882025f, -0.14283919f, 
    0.14386472f, 0.34435448f, -0.53692919f, 0.21849740f, -0.03024218f, -0.06623133f, -0.01526137f, -0.15582870f, 
    -0.10284618f, 0.13139528f, -0.03174728f, 0.11354839f, 0.42691028f, -0.39973938f, 0.01614641f, 0.44380152f, 
    -0.23218828f, -0.22084904f, 0.16822512f, 0.05875477f, 0.27778080f, 0.09302773f, -0.13064103f, -0.06357005f, 
    -0.48662409f, 0.39298177f, -0.07894147f, -0.25156578f, 0.00271016f, 0.32898170f, 0.06587583f, 0.02445615f, 
    0.09961915f, 0.05426846f, -0.26981246f, 0.02497301f, 0.24280766f, -0.28692171f, -0.02268054f, 0.03189614f, 
    -0.22497031f, -0.05186695f, -0.14657715f, -0.10027886f, 0.17182104f, -0.02665533f, -0.11933015f, -0.27557367f, 
    0.02683716f, 0.26879072f, 0.00426263f, -0.48340008f, -0.08742907f, 0.03966189f, 0.11672041f, 0.03018047f, 
    -0.13906199f, -0.09805682f, 0.00589036f, -0.29233861f, 0.44207335f, -0.24005026f, 0.20787595f, -0.16834205f, 
    -0.31983590f, 0.10421775f, 0.07878929f, 0.05745934f, -0.10453154f, 0.01250953f, -0.03576194f, -0.00060797f, 
    0.18789130f, -0.46809322f, 0.32883531f, 0.01643580f, -0.07977767f, -0.08683544f, -0.13281016f, 0.06280635f, 
    -0.00145463f, -0.39508194f, -0.37962663f, 0.06477606f, -0.71696526f, -0.37206492f, -0.39079800f, -0.65888989f, 
    -0.11963621f, -0.11018796f, -0.34423706f, -0.17188938f, 0.01235069f, -0.07109518f, -0.00518311f, -0.08719321f, 
    0.80930704f, -0.07362373f, -0.19228159f, 0.16946132f, 0.08452918f, 0.04155666f, -0.08578463f, -0.16617203f, 
    -0.21461861f, -0.16276799f, 0.06173500f, -0.13841206f, -0.18984015f, 0.34492558f, -0.17402928f, -0.09092889f, 
    0.19427781f, 0.01145521f, -0.04156530f, 0.09156788f, -0.05703089f, -0.05377545f, -0.07574818f, -0.08116932f, 
    -0.19251540f, -0.73845971f, -0.15623637f, 0.46553299f, -0.10869803f, 0.08802968f, -0.06857856f, -0.27866742f, 
    0.04630558f, -0.04596768f, -0.09771217f, 0.03836690f, -0.11728902f, -0.06418379f, -0.28408527f, -0.31032816f, 
    -0.23936887f, -0.15571870f, 0.18955459f, -0.17963484f, 0.09321221f, -0.13994348f, 0.00241390f, 0.02741032f, 
    0.73764563f, -1.01503015f, -0.20639531f, -0.01148788f, 0.13098423f, 0.17949133f, -0.08096676f, 0.09201831f, 
    0.01489837f, 0.03076413f, -0.16821761f, -0.03117709f, 0.24637064f, 0.26729071f, 0.07255597f, 0.16183971f, 
    -0.18326986f, 0.04488280f, -0.13706584f, -0.13880944f, 0.13715973f, 0.10835334f, 0.09308889f, 0.04740020f, 
    -0.27443278f, 0.21189177f, -0.00309264f, 0.15920050f, -0.11098443f, 0.11525598f, -0.01693933f, 0.10226755f, 
    -0.24306864f, -0.10956486f, 0.07251850f, 0.11693536f, -0.27033475f, -0.27285236f, -0.46042728f, 0.11136114f, 
    -0.05024219f, -0.11244500f, 0.14070486f, -0.10322578f, 0.13418525f, 0.00906862f, 0.08643674f, 0.10434724f, 
    0.04822513f, -0.04524397f, 0.24653225f, 0.22082756f, 0.08338533f, -0.00067456f, 0.15448749f, -0.04389773f, 
    -0.11943916f, 0.32703528f, -0.02876742f, 0.02492811f, 0.00873873f, 0.00726031f, -0.10592914f, -0.25355786f, 
    -0.27348426f, -0.20718592f, -0.03067550f, 0.16120766f, -0.33073494f, 0.22275858f, 0.14785083f, 0.24746417f, 
    0.03502435f, -0.35191935f, 0.18166584f, 0.20565480f, 0.21192293f, -0.12994970f, 0.06603484f, 0.22208002f, 
    0.05419664f, 0.05406789f, -0.18920237f, 0.11789060f, 0.61547518f, 0.06741427f, -0.22027455f, 0.19622622f, 
    -0.01408529f, 0.01501595f, -0.04416503f, -0.14535560f, 0.22701544f, -0.09535266f, 0.07668056f, -0.21080440f, 
    -0.94929081f, 0.19048049f, -0.25073972f, -0.05934885f, -0.04858142f, -0.13919853f, -0.07335326f, 0.03096260f, 
    -0.01704802f, -0.04707843f, 0.02074498f, -0.05235355f, -0.52383411f, 0.27788004f, 0.03014640f, -0.11679243f, 
    0.00191205f, 0.25159374f, -0.24096315f, 0.12488651f, -0.05920587f, 0.23538738f, -0.00205958f, 0.03737263f, 
    -0.05620313f, -0.06215163f, -0.08185512f, 0.13240311f, -0.22520252f, -0.10446837f, 0.32256529f, -0.08997127f, 
    -0.02094291f, -0.02541405f, -0.17419861f, -0.01603404f, 0.19647832f, 0.21623655f, 0.12074672f, 0.10502876f, 
    -0.07043535f, -0.20304677f, -0.04026602f, 0.29417840f, 0.17716223f, -0.24322262f, 0.22457837f, 0.07912578f, 
    -0.54393101f, 0.58057874f, 0.36006582f, 0.49932912f, 0.21323812f, 0.16607857f, 0.06280687f, -0.22536531f, 
    -0.04210606f, -0.12601599f, -0.18003501f, -0.18617353f, -0.61359286f, -0.69794464f, 0.00485897f, -0.21978793f, 
    -0.22574987f, -0.01261163f, 0.11433084f, -0.21206866f, -0.03485005f, -0.29883322f, 0.09337514f, -0.03417207f, 
    0.16225444f, 0.06553116f, -0.13537459f, 0.06105419f, 0.05658027f, 0.05766606f, -0.00455307f, 0.21121569f, 
    -0.00385870f, -0.02587361f, 0.09775579f, 0.07578297f, -0.47310397f, 0.07573969f, 0.13133858f, 0.30759528f, 
    0.03654460f, 0.03126894f, -0.01972388f, 0.10808133f, -0.07272883f, -0.05250559f, 0.16783753f, -0.04624892f, 
    -0.39196053f, -0.12193352f, 0.29774368f, 0.11996222f, -0.48559260f, 0.01973736f, -0.10425024f, -0.25119093f, 
    0.34567600f, -0.29216024f, 0.01432132f, -0.07575997f, -0.17891356f, 0.31599608f, 0.08483904f, 0.02223763f, 
    -0.03665585f, 0.11307920f, 0.04183412f, 0.11240608f, -0.17318462f, -0.14484756f, 0.03673844f, -0.04059702f, 
    -0.34392357f, -0.41328204f, -0.06941897f, 0.24725997f, 0.03073919f, -0.12998250f, 0.13751632f, 0.08847941f, 
    -0.09402809f, 0.01316662f, 0.11736871f, 0.02635468f, 0.12009374f, -0.10327115f, -0.15957752f, 0.06809314f, 
    0.10049142f, -0.02340167f, 0.18686169f, 0.16552211f, 0.00901371f, 0.01199852f, 0.20320739f, 0.00980798f, 
    0.46514073f, -0.00030555f, -0.11410401f, -0.06526077f, -0.23391032f, -0.15577061f, 0.08756097f, 0.00165366f, 
    -0.12210185f, -0.16687913f, -0.04658980f, 0.18501352f, -0.50552887f, -0.02275069f, 0.18302366f, 0.45242187f, 
    0.07629831f, 0.00874238f, 0.05487811f, 0.04981330f, -0.08729815f, 0.22838195f, 0.18578415f, 0.10381906f, 
    -0.10712060f, -0.05097392f, 0.39976305f, -0.37834123f, 0.22726148f, 0.03823671f, -0.41287434f, 0.06522108f, 
    0.13876468f, -0.05831164f, -0.06527652f, 0.10200905f, -0.58584660f, 0.20517421f, -0.09151872f, -0.08979174f, 
    -0.01789202f, 0.13935938f, -0.04347029f, 0.24180587f, -0.15488195f, -0.31626859f, 0.06700514f, -0.13485977f, 
    -0.63822240f, -0.19835661f, 0.21291536f, -0.20339689f, 0.11589124f, -0.00449095f, -0.11922596f, -0.14310834f, 
    0.16268371f, 0.05637897f, -0.08842598f, -0.10946329f, -1.12029433f, 0.54011232f, 0.02512052f, -0.23717198f, 
    0.19751522f, -0.17254025f, -0.25311869f, 0.12065896f, 0.02666059f, 0.07415347f, -0.10083652f, 0.05083738f, 
    -0.40394223f, 0.10783200f, -0.32894757f, -0.45150208f, -0.04758951f, -0.17673500f, 0.41492137f, -0.08962785f, 
    0.19001631f, 0.06253774f, -0.04308135f, -0.05028963f, -0.07531362f, -0.08635861f, 0.18170981f, 0.23627846f, 
    0.16744153f, 0.00276746f, 0.07946245f, 0.31393373f, -0.01310972f, 0.17568649f, -0.02575002f, 0.21145672f, 
    -0.77548528f, -0.16468301f, 0.26592183f, 0.17711054f, -0.11760402f, -0.14459960f, 0.00037257f, -0.20760837f, 
    0.19353543f, -0.12634751f, -0.26738045f, -0.12188671f, 0.38502321f, 0.19169657f, 0.06312084f, 0.19258077f, 
    0.07226468f, 0.10598513f, 0.23067184f, -0.00548198f, -0.01064300f, 0.03281748f, -0.12783325f, -0.17548007f, 
    -0.01743018f, -0.09458597f, 0.47815168f, -0.08733261f, 0.15547767f, 0.14545634f, -0.00118612f, 0.09423031f, 
    0.01779974f, 0.00068513f, -0.08402820f, -0.01428168f, -0.16985202f, -0.10341819f, -0.18591984f, -0.11242469f, 
    0.02329444f, 0.08742084f, -0.00458198f, -0.30286837f, -0.03611550f, -0.23413430f, 0.02375869f, 0.06166909f, 
    0.01335488f, 0.26141343f, 0.12409838f, 0.24036001f, 0.06488038f, -0.27471951f, 0.08557399f, 0.10558207f, 
    -0.16471697f, -0.01006299f, 0.19738285f, 0.09777510f, -0.64411730f, -0.60900706f, 0.21542068f, 0.24990328f, 
    -0.01315927f, 0.08918700f, 0.03461488f, 0.00234553f, 0.05298593f, -0.19506501f, 0.09654387f, 0.04532305f, 
    0.43444240f, 0.03798319f, -0.27589211f, -0.19959345f, -0.03988941f, 0.14873444f, -0.45171091f, -0.00170042f, 
    0.31298533f, -0.14218053f, -0.02139881f, -0.14871450f, 0.22783764f, 0.12500203f, 0.13002953f, -0.38563299f, 
    -0.05471607f, -0.12601653f, -0.09333462f, -0.07780919f, -0.14788389f, 0.03680894f, -0.26035357f, -0.25139403f, 
    0.00215309f, -0.20097873f, 0.02321193f, -0.02295007f, 0.10776608f, 0.19673876f, -0.02697072f, 0.05686841f, 
    0.11914054f, -0.12022185f, 0.17042106f, -0.13036369f, -0.29061717f, -0.22824161f, -0.49202350f, 0.01212201f, 
    0.13713606f, 0.18012850f, -0.19489960f, -0.05203805f, -0.05917962f, -0.18969703f, -0.04010821f, -0.09856743f, 
    -0.06779021f, 0.02743479f, 0.02680048f, 0.44392154f, -0.23157114f, 0.03644997f, 0.13071615f, 0.03353520f, 
    0.24555853f, -0.26657027f, -0.02479179f, -0.01151701f, -1.03546393f, -0.40061042f, -0.22156082f, -0.57624346f, 
    0.06350348f, -0.01030193f, 0.09717174f, 0.18682688f, 0.02189364f, 0.26842332f, 0.15499380f, -0.04751812f, 
    0.14778596f, 0.01491662f, -0.05805722f, -0.09754960f, -0.10381880f, 0.09068117f, 0.26988873f, -0.00480709f, 
    0.03655883f, -0.12167499f, -0.00761204f, -0.00505140f, -0.54890704f, 0.42928866f, 0.25574413f, -0.03815198f, 
    0.09519415f, -0.21224101f, 0.04472106f, 0.00635018f, 0.02338478f, -0.24889109f, 0.07499841f, -0.18504252f, 
    -0.64009207f, 0.20471632f, 0.28515911f, -0.41284162f, 0.04678929f, 0.00322850f, -0.10233053f, -0.35962448f, 
    0.08828128f, 0.06395854f, 0.09781494f, 0.10505789f, 0.06937195f, -0.14570206f, -0.35409060f, 0.43848529f, 
    0.03560124f, -0.00192316f, 0.11630322f, -0.07961395f, -0.04803450f, 0.01553439f, 0.00678866f, 0.05468617f, 
    0.18191135f, 0.04466129f, 0.02972364f, -0.02852027f, -0.13195503f, -0.06092722f, 0.19392648f, 0.22225104f, 
    -0.25978589f, 0.15669192f, 0.01145362f, 0.41236988f, -0.16949965f, 0.01038995f, 0.11280531f, -0.19002688f, 
    0.08714525f, 0.00893129f, -0.05302005f, -0.07319552f, 0.12465055f, 0.18633991f, 0.12100910f, 0.30366933f, 
    0.23159456f, 0.01712951f, 0.05894924f, -0.51780766f, -0.18149495f, -0.14232700f, 0.22121941f, 0.14018032f, 
    0.07118056f, 0.00954334f, 0.06436744f, 0.14498097f, -0.32287690f, 0.05615411f, -0.36113080f, -0.13716176f, 
    -0.17457834f, -0.03707572f, 0.07685539f, -0.10433806f, -0.00805697f, 0.35639960f, -0.14428623f, 0.02211066f, 
    -0.23654482f, 0.06428431f, -0.10680275f, 0.03310775f, 0.06439947f, 0.25236949f, -0.01457347f, -0.09607995f, 
    0.09248174f, 0.09941243f, -0.02906083f, 0.12896845f, -0.05423576f, 0.20734349f, -0.24697526f, -0.14414310f, 
    -0.00169650f, -0.04351510f, 0.10147908f, -0.17259666f, -0.14888386f, -0.10445789f, 0.07891384f, -0.04710807f, 
    -0.36509761f, 0.13653509f, -0.59726638f, 0.53817034f, -0.02842513f, 0.06072060f, 0.14732935f, 0.07240028f, 
    0.03952734f, 0.01747042f, 0.02355709f, -0.13602744f, -0.72819448f, 0.24768722f, 0.02686138f, -0.08285644f, 
    -0.16422950f, 0.06607978f, 0.08729956f, 0.14035544f, 0.05510062f, -0.10075935f, 0.06846242f, 0.34060180f, 
    -0.06429254f, -0.01013991f, 0.07315350f, 0.07491618f, 0.09625684f, -0.00756442f, 0.06286216f, -0.04568985f, 
    0.13861963f, 0.06680343f, 0.13838689f, 0.18644762f, -0.30711856f, -0.35126314f, -0.11237961f, -0.52980858f, 
    -0.14740455f, -0.01629493f, 0.06248299f, -0.13877474f, -0.17389165f, 0.04954959f, 0.18555370f, 0.29129437f, 
    -0.36872411f, 0.03910271f, -0.08849891f, 0.28427598f, -0.09368654f, 0.05030308f, 0.03804233f, -0.13127066f, 
    -0.25429776f, -0.07248289f, 0.04189907f, -0.10081075f, -0.08789568f, -0.16985565f, 0.17135648f, -0.14307684f, 
    -0.07527538f, -0.11503289f, 0.14229617f, -0.51327765f, -0.05361370f, -0.23250729f, 0.16390675f, -0.03695283f, 
    -0.38920861f, 0.20774597f, 0.15394263f, 0.55362988f, -0.04016549f, 0.02735589f, 0.02053962f, -0.04596701f, 
    -0.08171377f, 0.06404917f, -0.17121467f, -0.08627082f, 0.91658783f, -0.73484403f, 0.17220262f, 0.09752064f, 
    -0.04153622f, 0.00143129f, -0.16939247f, -0.01940781f, -0.02786530f, 0.05520349f, -0.05008058f, 0.16359869f, 
    0.02940373f, -0.63866472f, -0.24222901f, 0.07574427f, -0.07417803f, 0.18997970f, 0.06834258f, 0.25738174f, 
    0.16688907f, 0.03866653f, -0.21138076f, -0.09637353f, 0.22889479f, 0.26086453f, -0.76130927f, -0.48487967f, 
    -0.09480200f, 0.25981691f, -0.02492986f, -0.02740289f, 0.32297701f, 0.07774106f, 0.02300511f, 0.16272339f, 
    0.37147743f, 0.26555026f, 0.13460617f, -0.20526496f, 0.20470491f, 0.19942969f, 0.04914260f, 0.00476556f, 
    0.13876432f, -0.09453641f, -0.20018168f, -0.07090294f, 0.04172435f, 0.35099086f, 0.31190509f, -0.70688301f, 
    -0.06198888f, 0.01612812f, 0.02954277f, 0.00980599f, -0.25304672f, 0.08370756f, -0.02584197f, -0.25309917f, 
    -0.72025371f, 0.36302599f, -0.20403554f, -0.26887450f, -0.04755727f, 0.04038677f, 0.10872803f, -0.21449447f, 
    -0.04072153f, 0.05181649f, -0.22843073f, -0.02491804f, -0.08808530f, 0.41831505f, -0.04722907f, 0.15642467f, 
    0.15976746f, 0.09765757f, -0.06861552f, 0.12185613f, 0.13910690f, 0.09633001f, -0.00204502f, -0.13621375f, 
    -0.29354858f, 0.40692011f, -0.41348466f, 0.28984737f, -0.23434070f, -0.04727372f, -0.14235845f, 0.04519742f, 
    -0.15814722f, 0.01103908f, 0.03134483f, -0.13361965f, 0.22755381f, 0.51724386f, 0.39644173f, -0.01587836f, 
    -0.39049682f, 0.03364546f, -0.06067326f, -0.08960466f, -0.09508204f, -0.07625288f, -0.11878141f, -0.01693236f, 
    0.12207446f, 0.44521493f, -0.09319610f, 0.21929750f, 0.12634057f, -0.06261458f, 0.00209334f, 0.03608847f, 
    0.03621251f, 0.13537574f, 0.11925470f, 0.02841602f, -0.23454183f, 0.10103567f, -0.04458593f, -0.36853528f, 
    -0.14986975f, 0.07427774f, -0.19196214f, -0.17301837f, -0.02853868f, -0.14657255f, -0.12293153f, -0.06751530f, 
    0.61667377f, -0.48683867f, 0.15568651f, 0.12238465f, -0.05325023f, 0.10114624f, -0.00393943f, -0.05314639f, 
    -0.00635519f, 0.02963462f, 0.02365487f, -0.00700981f, 0.12006479f, 0.20180105f, 0.43442523f, 0.35529202f, 
    0.33895162f, 0.21299702f, 0.25445759f, -0.07334074f, -0.08947902f, 0.10508533f, -0.06500930f, -0.06723040f, 
    -0.11428258f, -0.24189480f, -0.14544210f, -0.26160994f, 0.09526714f, -0.07047074f, 0.02397870f, -0.04773135f, 
    -0.19375801f, 0.22799906f, -0.15267946f, -0.07861748f, -0.36557984f, -0.02432728f, 0.27631557f, -0.13510250f, 
    -0.08616760f, -0.04555755f, -0.20244701f, 0.03498189f, 0.01106500f, -0.06491200f, 0.01828469f, -0.15857178f, 
    -0.34328529f, -0.58807945f, -0.28420654f, -0.06337979f, -0.03148101f, -0.03242960f, 0.05906719f, -0.12443631f, 
    -0.02177014f, -0.12056237f, -0.02846509f, -0.04039970f, 0.28588438f, 0.03925725f, -0.14404507f, -0.25807938f, 
    -0.03272106f, 0.12195624f, -0.04636656f, 0.01228566f, -0.13873370f, -0.06513444f, -0.22395681f, 0.14313558f, 
    -0.17217408f, -0.20817633f, 0.34744585f, -0.38012874f, -0.16874611f, 0.03854715f, -0.05170453f, -0.15723561f, 
    0.10463168f, 0.10482974f, -0.02368592f, -0.33005282f, 0.10685419f, 0.16815014f, 0.12562178f, 0.36779058f, 
    0.24167186f, 0.05958941f, 0.00643876f, -0.11987696f, -0.04348899f, -0.04339959f, -0.25848380f, -0.17875792f, 
    0.12453486f, -0.59745347f, 0.02270996f, 0.26489016f, -0.04942578f, -0.19988827f, -0.11181375f, -0.09212679f, 
    0.10239129f, -0.08098074f, -0.05117520f, -0.24409911f, -0.06301416f, 0.47546172f, -0.05597597f, -0.26393649f, 
    0.00858623f, 0.05883479f, 0.08164226f, -0.17678426f, -0.01915641f, -0.17485027f, 0.05866934f, -0.04770770f, 
    0.32702050f, 0.04632014f, 0.05104384f, 0.56904393f, 0.16772638f, -0.12487039f, -0.29535216f, -0.01183979f, 
    0.17829703f, -0.12492269f, 0.06357874f, -0.15281302f, 0.17860383f, 0.11492225f, 0.18388307f, 0.22872655f, 
    -0.23937088f, 0.21851306f, -0.29251444f, -0.04994666f, -0.10580797f, -0.19824402f, 0.15288445f, -0.09009347f, 
    0.16131656f, -0.39821595f, -0.06205067f, -0.26756951f, 0.27845398f, 0.00457356f, 0.01663445f, -0.06821299f, 
    0.13366316f, 0.16545165f, 0.21975473f, -0.18000109f, -0.01098944f, 0.51627803f, -0.05949455f, -0.32679471f, 
    0.01075512f, -0.12782934f, -0.45167321f, 0.03396666f, 0.12928078f, -0.03741894f, 0.11790674f, 0.12774831f, 
    0.01883732f, 0.59986216f, -0.25885579f, 0.00724738f, -0.34114435f, 0.15021683f, -0.42962000f, 0.19153462f, 
    0.02151768f, -0.06521018f, -0.17562923f, -0.02240236f, 0.37112257f, -0.17663683f, 0.10826506f, 0.00281902f, 
    0.19543193f, -0.29064187f, -0.06238313f, -0.29510239f, 0.07525924f, 0.09644710f, -0.26097074f, -0.02102031f, 
    -0.32494682f, -0.25157076f, -0.03961888f, -0.43251097f, -0.06359057f, 0.06533695f, 0.12264898f, 0.07434344f, 
    0.01956245f, -0.18044795f, -0.01246452f, -0.09228688f, -0.53538823f, 0.00359020f, 0.43827254f, 0.03972259f, 
    -0.13731933f, -0.03970618f, -0.76897383f, -0.04558434f, 0.04260180f, -0.20485790f, -0.25910860f, -0.39553267f, 
    0.27475572f, 0.03912722f, -0.12391292f, -0.12134568f, 0.00894973f, -0.09270242f, 0.01576203f, -0.09782102f, 
    0.12231765f, -0.06386968f, 0.05883703f, 0.01587933f, -0.28154480f, -0.06861072f, 0.42345116f, -0.05495904f, 
    0.02643821f, -0.08144627f, 0.08277833f, 0.11981952f, -0.10267880f, 0.08978055f, 0.01783636f, -0.03312063f, 
    0.49509695f, -0.02700254f, -0.44719803f, -0.04935068f, 0.09569964f, -0.03851026f, 0.10019772f, -0.12399161f, 
    -0.04530377f, -0.12764964f, 0.10684668f, 0.11071328f, 0.30882239f, -0.11826819f, -0.06413451f, 0.09795643f, 
    -0.15477917f, 0.02629062f, 0.08905654f, -0.09033255f, 0.03677137f, -0.20668057f, 0.04281064f, 0.09287050f, 
    -0.17272343f, -0.11677092f, 0.12518688f, 0.08326344f, -0.26145995f, -0.12594762f, -0.12903732f, -0.02608798f, 
    -0.17249335f, 0.04292136f, 0.08091301f, 0.27453020f, -0.30781776f, -0.11554778f, -0.11415401f, -0.50724232f, 
    0.03472542f, -0.22381388f, 0.31418654f, -0.22818537f, -0.05772964f, -0.28060016f, 0.21506609f, -0.08447589f, 
    -0.32267669f, -0.22852850f, -0.32645682f, -0.32138598f, -0.09999135f, -0.04065122f, 0.02540370f, -0.12936710f, 
    0.05928797f, 0.20236239f, -0.02105323f, 0.25033888f, 0.04426735f, -0.30460161f, 0.19534744f, 0.20943238f, 
    0.19068167f, 0.01532656f, 0.07595381f, -0.04192899f, 0.00921571f, -0.04670366f, 0.18753126f, 0.06133560f, 
    -0.62347627f, 0.55902970f, -0.39134586f, -0.41267687f, 0.29095358f, 0.06915954f, -0.13737303f, -0.08178569f, 
    -0.12916689f, -0.11941509f, -0.13609071f, -0.02199716f, -0.60943526f, -0.04649600f, 0.30654347f, -0.09143955f, 
    0.24818130f, -0.10720060f, 0.02198979f, 0.25250795f, 0.17713274f, 0.10668105f, -0.05761555f, 0.02412884f, 
    -0.07353660f, 0.46281901f, 0.11339601f, -0.60441697f, -0.11922126f, 0.04803920f, -0.05395411f, -0.20720489f, 
    -0.25404108f, -0.01357039f, -0.04848491f, -0.37879601f, -0.81217784f, 0.00894019f, -0.10761180f, -0.09671564f, 
    -0.03057306f, 0.00499431f, 0.03830021f, 0.02220411f, -0.08934237f, 0.30587974f, -0.05347789f, 0.13251220f, 
    -0.56955600f, 0.28017262f, 0.42415017f, 0.06209758f, -0.09132527f, 0.13132955f, 0.09042604f, 0.27960452f, 
    0.05956665f, 0.15033753f, 0.05990560f, 0.12571031f, -0.46884465f, 0.50765878f, -0.07422423f, -0.13104977f, 
    -0.02071496f, 0.01101927f, -0.18913844f, 0.05212957f, 0.23631729f, -0.07032557f, 0.32070103f, 0.06235834f, 
    0.39549765f, -0.31929117f, -0.34273663f, 0.41239777f, -0.07111369f, -0.06994966f, -0.06066941f, 0.27259588f, 
    -0.02691047f, 0.21734971f, -0.10099334f, 0.07485134f, -0.09253020f, -0.77410889f, -0.17363535f, -0.11561969f, 
    -0.13931367f, 0.07066649f, -0.07147955f, 0.16170996f, -0.10824693f, 0.17247184f, -0.19295906f, 0.10026316f, 
    0.86581814f, 0.22143149f, 0.10150162f, -0.67766780f, -0.01033785f, 0.09247627f, 0.12658837f, -0.05732645f, 
    -0.05898585f, 0.04107042f, 0.19060697f, 0.21685226f, 0.32320714f, 0.28661406f, -0.24119884f, 0.38947117f, 
    0.04936915f, 0.12542781f, -0.04222575f, -0.04337227f, 0.06960629f, 0.17230174f, 0.03931032f, 0.07601299f, 
    0.31313011f, -0.22762565f, 0.36996424f, 0.36541307f, 0.06683575f, -0.00460691f, -0.27707005f, 0.14727609f, 
    -0.22067443f, 0.11560550f, 0.03323039f, 0.06684148f, -0.08768277f, -0.28857383f, -0.07367972f, -0.21339011f, 
    0.14569779f, 0.19092785f, 0.06908390f, -0.13762556f, -0.08784891f, 0.11339680f, 0.04691366f, -0.14224297f, 
    0.42811731f, 0.36172995f, -0.44382304f, 0.34948841f, 0.09783887f, 0.00055853f, 0.01879254f, 0.03058683f, 
    0.04809964f, -0.16305044f, -0.26845548f, 0.01737727f, -0.06658190f, 0.07647582f, 0.13681740f, 0.05913078f, 
    0.10699394f, 0.16308378f, -0.32719305f, 0.00515995f, -0.13542783f, -0.09797891f, -0.03814684f, 0.04180394f, 
    -0.15894565f, -0.15229420f, -0.02007351f, -0.51892060f, -0.08087502f, -0.10915513f, -0.01131844f, -0.21240459f, 
    0.14181754f, 0.02931802f, 0.16199979f, -0.47870389f, -0.42035174f, 0.24448957f, -0.12041421f, -0.17816040f, 
    0.15551846f, -0.20615900f, 0.05241672f, -0.11026488f, -0.05868917f, -0.28247625f, -0.00953402f, -0.02715088f, 
    -0.68052167f, -0.18434364f, -0.56215298f, -0.75936806f, 0.18168961f, -0.09770472f, -0.31249177f, 0.09904987f, 
    0.16201116f, -0.16980851f, 0.27731410f, 0.05505104f, 0.06857356f, 0.25270590f, -0.16067904f, 0.11674894f, 
    -0.08756715f, -0.02656764f, 0.00043144f, -0.11791670f, 0.16754007f, -0.08525965f, 0.08473209f, 0.04351708f, 
    -0.59986758f, -0.17013904f, 0.11585347f, -0.12949637f, 0.26768598f, -0.04486110f, 0.00777686f, -0.05241203f, 
    0.03073999f, 0.35154685f, 0.10472083f, 0.24995111f, -0.32807767f, -0.25978360f, 0.08309517f, -0.08996996f, 
    0.27915362f, 0.19438465f, 0.06726544f, 0.10979404f, 0.01084989f, -0.06937438f, 0.10566270f, 0.09916034f, 
    -0.28813607f, -0.48416257f, -0.13039736f, -0.21800794f, -0.06097345f, -0.14855337f, 0.02121047f, -0.16560368f, 
    0.17621563f, -0.22509697f, -0.14272994f, -0.18753642f, -0.53618968f, -0.62132686f, -0.18402752f, -0.27753901f, 
    0.12268433f, -0.14953269f, -0.08409909f, -0.18565799f, 0.21298051f, -0.23871952f, -0.32607257f, 0.02579121f, 
    0.11033925f, -0.01774866f, 0.27963451f, -0.07443143f, -0.12434150f, 0.26544914f, 0.12483033f, 0.17426653f, 
    0.13606353f, -0.12368894f, -0.14420411f, -0.04808533f, 0.34886211f, 0.20137823f, -0.17615867f, -0.17646204f, 
    -0.09177195f, -0.00627058f, -0.05702696f, 0.02189833f, 0.04484446f, -0.21195301f, -0.15805291f, -0.13683593f, 
    -1.11970270f, -0.17180713f, 0.10307966f, 0.36577877f, 0.13651173f, 0.03308227f, 0.02077669f, 0.02625548f, 
    -0.08221389f, -0.00618680f, 0.05018724f, -0.14603846f, 0.48028567f, -0.13552219f, -0.01762702f, -0.04377215f, 
    0.04435689f, -0.18479460f, 0.13000321f, 0.13325137f, -0.10833264f, 0.11746496f, -0.02039902f, 0.34691751f, 
    -0.89170951f, -0.49117911f, 0.19225340f, 0.16444746f, 0.17401733f, 0.20466968f, 0.05715160f, -0.06049449f, 
    0.19004865f, 0.16008542f, 0.06386073f, 0.15544945f, 0.30400023f, -0.32844219f, 0.02268498f, 0.14301679f, 
    -0.13840698f, -0.07211798f, -0.07906393f, 0.03390549f, 0.11341612f, -0.00852357f, -0.11245906f, -0.16181962f, 
    0.68151098f, 0.08717526f, 0.02895798f, 0.16249911f, 0.00265902f, -0.05377075f, -0.07527287f, 0.24643940f, 
    -0.11055814f, 0.02265953f, 0.06245903f, -0.03107823f, 0.22169584f, -0.00338386f, -0.23083785f, 0.01218212f, 
    0.08697461f, 0.04321166f, 0.15347189f, -0.15671539f, 0.15359546f, 0.01298665f, 0.12180072f, -0.07100302f, 
    0.53408641f, 0.38894093f, -0.04779157f, -0.22317526f, 0.11793794f, 0.25478932f, 0.03074087f, 0.38208503f, 
    -0.07675339f, 0.10862296f, 0.16980031f, 0.28566891f, -1.41670692f, -1.09050763f, -0.23484711f, -0.45760769f, 
    0.07620016f, -0.06224428f, -0.06404834f, 0.12279114f, -0.03798817f, 0.42250144f, 0.00754711f, 0.08280683f, 
    0.40911493f, -0.36713329f, -0.38464582f, -0.25728032f, -0.14369868f, 0.10309031f, -0.03010366f, -0.24354997f, 
    0.01589595f, 0.03497112f, 0.05850548f, 0.04591219f, -0.00640571f, -0.35310006f, 0.10408442f, 0.11963625f, 
    -0.14252861f, -0.00895772f, -0.03418152f, 0.07735981f, -0.14794412f, -0.06339330f, -0.29944745f, -0.24464531f, 
    0.45372993f, -0.01143198f, -0.12380403f, 0.03298373f, 0.31350008f, -0.05605477f, -0.31553841f, -0.00061632f, 
    -0.07420789f, -0.08187854f, 0.07975930f, 0.21265781f, -0.01406663f, 0.24515273f, -0.27631649f, -0.13203819f, 
    0.37888235f, -0.07647730f, 0.08389377f, -0.13089009f, 0.00910633f, 0.12462825f, -0.01552911f, 0.11643483f, 
    0.02678002f, -0.46629816f, -0.09365251f, 0.28326693f, 0.04528752f, 0.14291294f, 0.18697625f, -0.32376236f, 
    -0.08904876f, 0.08113790f, -0.00588133f, -0.01950987f, -0.31871441f, -0.13371117f, -0.10020483f, -0.42372552f, 
    0.11114552f, -0.03224389f, 0.04303510f, 0.25116140f, -0.00115037f, -0.06570562f, 0.19334039f, -0.13082945f, 
    -0.91584730f, 0.55897373f, 0.27533799f, -0.08890991f, 0.21698661f, -0.03143490f, 0.15275885f, -0.11729562f, 
    0.08048259f, 0.11064258f, 0.13020326f, -0.00507131f, 0.01719147f, 0.22616486f, -0.45928985f, -0.09327879f, 
    -0.22251548f, -0.13608432f, 0.09857343f, -0.32602680f, 0.15520062f, 0.24944399f, 0.05831762f, -0.05865186f, 
    0.75398529f, -0.59758687f, 0.00716248f, -0.01995685f, 0.01415053f, -0.09855398f, -0.13507958f, 0.10523555f, 
    0.16481517f, 0.05507660f, 0.14877181f, 0.06594725f, 0.31358212f, -0.09319492f, 0.14674801f, -0.26913822f, 
    0.12279321f, -0.19016652f, 0.02402708f, 0.02719254f, 0.00218087f, -0.12734316f, -0.03139791f, 0.01982699f, 
    0.85906589f, 0.07798640f, -0.08637288f, 0.09963374f, 0.03394198f, -0.18644460f, -0.01606684f, -0.01802314f, 
    -0.08407482f, 0.15747805f, -0.05118039f, 0.08729293f, -0.86402041f, -0.00194589f, -0.56768978f, -0.18616720f, 
    0.24303989f, 0.05675898f, 0.05280855f, 0.18412484f, 0.06311757f, -0.01381391f, -0.00083702f, -0.07201352f, 
    0.16257522f, -0.22540814f, 0.49552217f, -0.02829441f, -0.03958744f, 0.11894483f, 0.02984907f, -0.11469265f, 
    -0.25472289f, 0.11752764f, 0.09462282f, 0.19332263f, 0.22835733f, -0.02946424f, -0.21889068f, 0.21278118f, 
    -0.27163401f, 0.03245313f, -0.22598998f, -0.18709785f, 0.03008043f, 0.01907605f, -0.22604030f, -0.18868881f, 
    0.22902875f, -0.08794045f, -0.48460901f, 0.35716149f, 0.06747256f, 0.18484199f, 0.11766253f, 0.28476524f, 
    -0.12686691f, -0.09844402f, -0.01972945f, -0.24270231f, -0.11092281f, -0.15954979f, 0.06503971f, -0.47622797f, 
    -0.01709634f, 0.12427426f, -0.17971236f, 0.18233585f, 0.04060389f, -0.15561427f, -0.36613271f, -0.05798416f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15975112f, 0.06176866f, -0.10945536f, 0.12240028f, -0.03089346f, 0.09795570f, -0.00533119f, -0.12255020f, 
    -0.02148227f, 0.04608215f, 0.27995029f, 0.04673603f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
