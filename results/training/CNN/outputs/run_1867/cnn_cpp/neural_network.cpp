#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.49228039f, -0.21055010f, 0.29737687f, 0.24085347f, -0.32628232f, -0.15772462f, 0.09149788f, -0.26614648f, 
    -0.05798894f, 0.00879866f, 0.14545551f, -0.18825039f, 0.41029802f, -0.32101402f, -0.02660106f, 0.16251181f, 
    -0.24985258f, 0.15922375f, -0.21639819f, -0.37167755f, 0.08953463f, 0.31936687f, 0.28983718f, 0.13180386f, 
    0.62036115f, 0.45499870f, -0.21652314f, -0.65567636f, -0.29474148f, -0.37990269f, -0.35431409f, -0.39938346f, 
    -0.13968623f, 0.23657881f, -0.43147695f, 0.54885244f, 0.26574865f, 0.20794789f, 0.24125133f, -0.10230378f, 
    0.07613142f, -0.10586312f, -0.07126974f, -0.32337087f, -0.31588691f, -0.32611018f, 0.01586340f, -0.19029523f, 
    -0.26909149f, -0.42758366f, 0.76584184f, -0.63979346f, -1.04015803f, -0.75984144f, -0.83611530f, 0.55620080f, 
    0.46406180f, 0.51089782f, 0.39830622f, -0.03173894f, -0.18635063f, 0.12155915f, -0.02917743f, -0.22752374f, 
    -0.06181609f, 0.13043326f, -0.22464874f, -0.11266478f, -0.19534035f, 0.08385023f, 0.01674194f, -0.00084225f, 
    -0.12054992f, 0.09384350f, -0.15893124f, -0.30939940f, 0.14429963f, 0.23931442f, -0.47666708f, -0.30331069f, 
    -0.70753521f, -0.78491998f, -0.23061106f, -0.06016473f, -0.77004772f, 0.33294621f, -0.27732232f, 0.54749793f, 
    -0.10435398f, 0.18595047f, -0.26847112f, 0.02110178f, -0.13930444f, 0.04379865f, 0.14340948f, 0.05405007f, 
    0.37713552f, 0.34449941f, -0.10804943f, 0.33583286f, 0.97063583f, 0.87438345f, 0.28133720f, 0.23100325f, 
    -0.25454998f, -0.26411819f, -0.26289463f, -0.01361009f, 0.15074857f, -0.35204807f, 0.01516633f, -0.00155827f, 
    0.23990993f, -0.25697422f, -0.38481164f, 0.11142896f, 0.21262601f, 0.17587940f, -0.07339990f, -0.24941695f, 
    -0.19496697f, 0.03770496f, 0.07086404f, -0.01405974f, -0.05284921f, 0.79867083f, -0.15936069f, -0.05715503f, 
    -0.46663976f, 0.36620075f, 0.07819705f, 0.16990848f, 0.40488249f, -0.00889083f, 0.23901604f, -0.32065964f, 
    0.62644136f, 0.12228813f, -0.35691118f, 0.18731947f, 0.02971856f, 0.16719580f, -0.32740542f, -0.00261211f, 
    -0.06573899f, 0.21002731f, 0.36357579f, 0.16358484f, -0.36369780f, 0.09422028f, -0.37000766f, 0.57996571f, 
    0.82648969f, -0.58344817f, -0.45619002f, -0.21301734f, 0.39133146f, 0.06144951f, -0.22619747f, -0.25007251f, 
    0.09172197f, -0.03709980f, -0.18157591f, -0.23080942f, 0.08160578f, -0.21507336f, 0.11217988f, -0.06382634f, 
    -0.50411457f, -0.16562364f, -0.08336477f, -0.32290739f, -0.04265945f, -0.29378960f, -0.75129843f, -0.49201819f, 
    -0.55317038f, -0.55815554f, 0.00742994f, -0.32022861f, -0.25674975f, -0.34586883f, -0.60677409f, -0.19529627f, 
    -0.13923346f, 0.09514594f, -0.02522865f, 0.51619714f, -0.03314670f, 0.91649914f, -0.05043083f, 0.06414959f, 
    -0.25709474f, -0.27545270f, -0.26091537f, 0.09707967f, -0.07677782f, 0.23674090f, 0.05248282f, -0.05105780f, 
    -1.11846542f, -0.54057938f, 0.22230895f, -0.62658459f, -0.45644301f, 0.63415772f, 0.16870217f, -0.11519279f, 
    -0.02653178f, 0.68671757f, 0.10225356f, -0.00848664f, -0.06931349f, 0.08785608f, 0.22698186f, 0.02317931f, 
    0.14577454f, -0.19299743f, -0.13381998f, 0.04929480f, 0.06732915f, 0.28448048f, 0.07795969f, -0.07765156f, 
    -0.14364210f, -0.49084979f, 0.15278840f, 0.06881257f, 0.48649135f, 0.71737218f, -0.07121788f, 0.03684048f, 
    0.46870041f, 0.20874321f, 0.20020714f, 0.25905198f, -0.19840989f, -0.16807096f, -0.44146761f, 0.01679503f, 
    0.29681975f, -0.05195241f, 0.07531784f, -0.05743910f, 0.12107480f, -0.30206564f, -0.19375965f, -0.10845849f, 
    -0.27933642f, -0.35053638f, -0.21347800f, 0.99143881f, -0.10518055f, 0.03672399f, -0.38043308f, -0.30785379f, 
    -0.23074161f, 0.29347357f, 0.65082818f, -0.22082113f, -0.13713618f, -0.53113180f, 0.14474751f, 0.15630074f, 
    0.00108797f, -0.03638080f, 0.34563148f, 0.14369340f, -0.40752435f, 0.14650138f, 0.13051963f, 0.16400926f, 
    -0.55079961f, -0.17799854f, 0.05318174f, -0.75627941f, -0.19666132f, 0.00538356f, -0.75234085f, 0.13052155f, 
    -0.65475827f, -0.56447077f, 0.77697587f, 0.46043199f, -0.17974985f, -0.60276073f, -0.47298184f, -0.29382151f, 
    0.29836780f, -0.29893470f, 0.20242840f, -0.38989475f, -0.01407182f, 0.07258099f, 0.00678207f, -0.08721708f, 
    0.19679731f, 0.07166354f, -0.07721038f, -0.18474486f, -0.75028652f, -0.17474660f, 0.33058369f, 0.18575639f, 
    0.44670722f, 0.26409957f, 0.37506789f, -0.36781272f, 0.33103645f, 0.44935456f, -0.29385528f, 0.09523451f, 
    -0.21556696f, -0.27772328f, 0.43830049f, -0.09947698f, -0.34109050f, -0.30937591f, 0.06173741f, -0.10524867f, 
    -0.05911799f, 0.08039106f, 0.19285305f, 0.37879404f, 0.01644046f, 0.69809365f, 0.07040430f, 0.42251047f, 
    -0.43220541f, -0.72477055f, -0.27829236f, 0.11868848f, 0.63507944f, -0.50968432f, 0.05324632f, -0.23392911f, 
    0.07639834f, -0.21695794f, 0.21492055f, 0.12370300f, 0.37447503f, 0.18631570f, -0.55442762f, -0.11075138f, 
    0.16212556f, -0.05964033f, -0.18665549f, -0.07142458f, 0.10967413f, 0.42741454f, 0.28646952f, -1.18997741f, 
    -0.64243728f, 0.25907934f, 0.92174488f, -0.13150157f, 0.40641838f, 0.04820435f, -0.31138590f, -0.44445297f, 
    -0.37831464f, -0.70393753f, 0.27569875f, -0.57150227f, 0.01793265f, 0.21353576f, 0.03697200f, 0.13620992f, 
    -0.07187366f, 0.05262480f, -0.04227781f, -0.26989731f, -0.31900313f, -0.15594968f, -0.18497699f, 0.75717413f, 
    0.35587341f, -0.29615650f, 0.18426672f, -0.11184066f, -0.30336967f, -0.41720766f, -0.08945671f, 0.22517468f, 
    0.71894878f, -0.04366906f, 0.22209634f, -0.08495318f, 0.18711418f, 0.41521403f, -0.07892887f, -0.19802625f, 
    0.18065414f, -0.38547543f, -0.20010705f, -0.01216876f, -0.04311629f, 0.28624216f, -0.03944271f, 0.18492837f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.08547261f, 0.14108118f, 0.12024970f, 0.27016580f, 0.30136964f, 0.24895912f, 0.14573021f, -0.11188345f, 
    0.42749935f, -0.04539136f, 0.29603115f, 0.35819370f, 0.34136608f, 0.34656450f, -0.31964761f, 0.11613058f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.20872453f, 0.07851626f, -0.23984604f, -0.07649693f, -0.07870039f, 0.13374649f, -0.01120083f, 0.03710843f, 
    -0.01350225f, -0.00890649f, -0.12057057f, -0.17013262f, -0.04471349f, -0.19464512f, 0.39900434f, -0.01013992f, 
    -0.08653153f, 0.11037431f, -0.03387466f, 0.12475526f, -0.01385511f, -0.01637805f, 0.02422583f, 0.19362016f, 
    -0.24857131f, -0.33112633f, 0.24440643f, -0.08948919f, -0.03767547f, -0.09758735f, -0.04411745f, 0.02719757f, 
    -0.09873860f, 0.18047799f, -0.06148186f, -0.08201744f, 0.20875077f, -0.13462184f, 0.17304063f, -0.05774786f, 
    -0.07334594f, 0.09878492f, -0.02177886f, 0.07368072f, 0.04155038f, -0.11363003f, -0.01662422f, -0.02500492f, 
    0.51710850f, 0.36040688f, 0.43117425f, 0.09736829f, -0.12352988f, -0.11353924f, -0.10831772f, -0.00024312f, 
    -0.18420018f, 0.10654969f, -0.13645758f, -0.13868630f, -0.02774684f, 0.02451773f, 0.05427896f, 0.24099909f, 
    -0.18671784f, 0.22891437f, -0.09929658f, -0.05340675f, -0.13637429f, -0.00356649f, 0.00844397f, -0.15902235f, 
    -0.15848815f, 0.00138848f, -0.00603753f, -0.13877112f, -0.02305691f, 0.10635487f, -0.01909356f, -0.05603130f, 
    -0.03030670f, -0.04763103f, 0.17141621f, 0.15851934f, 0.05462128f, 0.06765144f, -0.02585285f, 0.03326100f, 
    0.07897676f, -0.18286903f, 0.04552013f, -0.04032077f, 0.15911821f, 0.13135856f, 0.09490456f, -0.05151355f, 
    -0.39208356f, 0.31517249f, -0.32714218f, -0.04147588f, -0.13601394f, -0.03974972f, 0.00060276f, -0.16620336f, 
    -0.08656343f, 0.14385253f, 0.12186410f, -0.02922122f, -0.19171254f, 0.05065266f, 0.09453826f, -0.00884247f, 
    0.01085075f, 0.10347445f, -0.10749312f, -0.12511428f, 0.12605681f, 0.06121281f, 0.14125657f, 0.04068591f, 
    0.32770064f, -0.04850680f, 0.15089838f, -0.07894812f, 0.00793818f, -0.05199330f, -0.05747697f, 0.03875445f, 
    -0.06353926f, 0.06103329f, 0.00960231f, 0.17087224f, 0.39315087f, -0.25389537f, 0.27731404f, 0.01667397f, 
    0.09826574f, -0.04387403f, 0.12908554f, -0.15732200f, -0.09196260f, 0.09728999f, 0.19694965f, 0.08530119f, 
    -0.05763085f, 0.06057500f, -0.16624406f, 0.13057204f, 0.24278724f, 0.13194455f, -0.03295170f, -0.27414823f, 
    -0.25439277f, -0.14673498f, -0.04030850f, -0.03606857f, -0.05821601f, -0.30049041f, 0.39401874f, -0.17198913f, 
    -0.02239552f, 0.00630380f, 0.09673255f, 0.10749824f, 0.01134444f, -0.20974141f, 0.13035890f, -0.04327235f, 
    -0.24646297f, 0.05764595f, -0.04530252f, 0.19365014f, 0.14686349f, 0.17628546f, 0.03828975f, 0.02818209f, 
    0.05231278f, 0.29692438f, -0.08132268f, 0.11375741f, 0.40325475f, 0.24472901f, 0.05104316f, 0.08701815f, 
    0.22628619f, 0.01179572f, -0.06838953f, -0.09387550f, -0.14549582f, -0.12064050f, 0.02800799f, -0.08234239f, 
    0.10683178f, 0.18783399f, -0.00428480f, -0.05120742f, 0.03499407f, 0.12781921f, -0.03765514f, -0.08246721f, 
    0.12890993f, -0.09679267f, -0.07528348f, -0.07771351f, 0.29211447f, 0.13421901f, 0.01549559f, -0.18320023f, 
    0.00180491f, -0.06958286f, 0.05110572f, -0.15278372f, -0.02645611f, 0.07828199f, 0.12652329f, -0.04669037f, 
    0.20111261f, 0.06926304f, 0.11636458f, -0.16047084f, 0.24727578f, -0.02126735f, -0.12073683f, 0.14895433f, 
    -0.02405728f, 0.13310784f, 0.07619857f, -0.09075733f, 0.20494813f, 0.27910897f, 0.16406219f, -0.13321711f, 
    -0.07189196f, -0.10571361f, 0.09843838f, 0.17269571f, 0.20059694f, 0.01729903f, -0.01014234f, -0.04358244f, 
    -0.26135305f, -0.19533989f, -0.39911240f, 0.12544937f, 0.07347617f, 0.23565891f, 0.09208139f, 0.09208418f, 
    0.00168100f, 0.01269026f, -0.01254404f, -0.10221163f, -0.20874891f, 0.16527520f, 0.05441245f, -0.02184676f, 
    0.04320844f, 0.00256859f, 0.04066746f, -0.03694524f, 0.04646222f, -0.06289370f, 0.07605065f, -0.27665114f, 
    -0.19776399f, 0.20161100f, -0.29522523f, 0.17927262f, -0.04018950f, 0.01005148f, 0.07110620f, -0.04496849f, 
    0.09129750f, 0.05549026f, 0.00821791f, 0.15026687f, 0.60926193f, 0.39072987f, 0.02563323f, -0.00063636f, 
    -0.06365305f, -0.12093684f, 0.08883815f, 0.18589488f, 0.13892573f, -0.12293070f, -0.02060358f, 0.16287017f, 
    -0.04835210f, 0.34278449f, 0.02853572f, -0.01925136f, -0.11460799f, 0.10128658f, 0.02880221f, -0.26424712f, 
    0.08272967f, -0.06086091f, 0.07440995f, 0.08496454f, -0.23755607f, 0.05841431f, 0.00673281f, 0.15829991f, 
    0.03092836f, 0.00090546f, 0.00535714f, -0.04279398f, 0.11291853f, 0.05298976f, 0.21417043f, 0.08640099f, 
    0.01765525f, -0.00420115f, -0.13485499f, 0.07620080f, 0.00309518f, -0.03529976f, -0.06773952f, -0.16675612f, 
    -0.02365077f, -0.14887230f, 0.06662656f, 0.03613270f, -0.15039650f, 0.03131885f, 0.13751444f, -0.09733010f, 
    -0.15936182f, 0.00910966f, -0.05374088f, 0.00351139f, 0.04514479f, 0.05936641f, 0.04666880f, 0.18310682f, 
    -0.11677182f, 0.04281630f, 0.15457186f, 0.20932020f, 0.04631395f, 0.02435078f, -0.01428927f, -0.09624100f, 
    -0.15318316f, -0.20664835f, -0.15175556f, 0.14929284f, -0.52270550f, -0.20658755f, 0.17965609f, -0.12135483f, 
    0.05513835f, -0.11976743f, -0.17935158f, 0.22721238f, -0.18291062f, 0.02348041f, 0.19376370f, 0.00458191f, 
    0.19996418f, -0.20983671f, 0.26393098f, -0.25118503f, -0.04789497f, -0.03046856f, -0.12636672f, 0.11185512f, 
    -0.07243340f, 0.15894660f, -0.11867605f, 0.02534290f, 0.10552690f, 0.14325221f, -0.13010216f, 0.12282749f, 
    0.08460074f, 0.00964748f, 0.11289158f, 0.03532394f, -0.08234087f, -0.07894032f, 0.01938092f, 0.00946719f, 
    -0.04891849f, -0.03991989f, 0.04110205f, -0.02669657f, 0.01228484f, 0.00390064f, -0.01959517f, -0.00352396f, 
    -0.05022972f, 0.05025093f, 0.03462524f, 0.04189935f, 0.03752741f, -0.06536916f, -0.04853017f, 0.02721259f, 
    -0.07630629f, -0.01031304f, -0.02932593f, 0.03392237f, 0.03599406f, 0.00931861f, -0.02132266f, -0.04549125f, 
    -0.03643651f, 0.01704756f, -0.04051127f, 0.06038661f, -0.07470807f, -0.05560712f, -0.06761897f, -0.02088857f, 
    -0.04508067f, -0.04501434f, 0.01547460f, -0.04468814f, -0.01451874f, 0.05304096f, 0.00634740f, 0.03767449f, 
    -0.02585500f, 0.05304004f, -0.07826409f, -0.07050410f, 0.01732735f, 0.05352538f, 0.02753790f, -0.08868604f, 
    0.03735758f, 0.01178202f, -0.02705451f, -0.00426738f, -0.00331953f, 0.03400200f, 0.01033659f, -0.07302757f, 
    -0.05181653f, 0.04743537f, -0.05300296f, -0.06289019f, 0.00042773f, 0.03874828f, 0.03869146f, -0.01606810f, 
    0.04105951f, 0.02731157f, 0.04488280f, -0.02001192f, 0.06444609f, 0.02953183f, -0.01676149f, -0.03962181f, 
    -0.07412266f, -0.00797785f, -0.03605071f, -0.03557821f, -0.07633510f, -0.00473182f, -0.04132213f, -0.03917317f, 
    0.05718239f, 0.05857289f, -0.02603643f, 0.05542766f, -0.03392521f, -0.07310053f, -0.02213559f, -0.00767950f, 
    0.00140276f, 0.01311742f, 0.02763567f, -0.07152059f, 0.04951290f, 0.05709826f, 0.00442582f, -0.02746173f, 
    0.02881101f, -0.05959669f, 0.01984687f, 0.02038238f, -0.05949581f, 0.00601632f, 0.01929402f, -0.03976480f, 
    -0.02526934f, -0.06498231f, -0.04196269f, -0.04387772f, -0.01293438f, 0.06143789f, 0.01504093f, 0.03856898f, 
    0.01381401f, -0.04513528f, -0.04249289f, 0.03970774f, -0.00295939f, -0.02668943f, 0.02583976f, -0.05457710f, 
    0.02237751f, -0.03283455f, -0.07444920f, -0.05241073f, 0.05451711f, -0.01595667f, 0.05319625f, -0.03376226f, 
    0.02113556f, -0.03572085f, 0.00029080f, -0.07979347f, 0.02163268f, 0.01141613f, -0.07895488f, -0.03766298f, 
    -0.00530396f, 0.01214126f, -0.05896815f, 0.05299987f, -0.05046544f, 0.00952260f, -0.04266136f, 0.02515340f, 
    0.01021056f, -0.04209866f, -0.01582900f, -0.07139134f, -0.07466114f, -0.07004568f, 0.01012643f, 0.04627711f, 
    -0.04832219f, 0.01103648f, 0.01139776f, 0.04733545f, -0.03965742f, -0.04738561f, 0.01302033f, 0.03329673f, 
    0.05530445f, -0.08207662f, -0.01906047f, 0.04952288f, -0.02916862f, 0.03063013f, -0.08267727f, 0.03398601f, 
    0.03200466f, 0.02961602f, 0.03060553f, 0.00254998f, -0.00243598f, -0.04606374f, -0.08068817f, -0.01656526f, 
    0.00703881f, -0.01082677f, 0.06050954f, -0.01673218f, -0.01505629f, 0.02413485f, -0.04569173f, -0.07747157f, 
    0.04388410f, -0.06481068f, -0.08081616f, 0.02785507f, -0.00268615f, -0.03361314f, -0.03493005f, -0.03558789f, 
    -0.06632943f, 0.07064398f, -0.07726457f, -0.03084478f, -0.07859637f, -0.00365710f, -0.01632359f, -0.02981515f, 
    -0.04163047f, 0.04856083f, -0.02864275f, 0.06754825f, 0.03095799f, -0.02888290f, -0.04456655f, 0.04714555f, 
    0.02127408f, 0.04361347f, -0.00494513f, 0.06021237f, 0.01212581f, 0.05176457f, -0.07764784f, 0.02327666f, 
    -0.04949976f, -0.06986167f, -0.03794951f, -0.06389982f, 0.04809990f, 0.01580883f, 0.02873229f, 0.02044867f, 
    -0.02858935f, -0.03776520f, 0.05684533f, -0.05240275f, -0.01960739f, 0.02489642f, 0.02302655f, 0.04389487f, 
    0.00164778f, 0.01294439f, -0.02561247f, -0.01069615f, 0.00850456f, -0.01832708f, -0.01854718f, 0.00658349f, 
    0.02923320f, 0.00371023f, 0.05428702f, 0.05559536f, -0.02747892f, -0.06727182f, -0.00414588f, -0.03867785f, 
    0.00854197f, -0.01694142f, -0.03725700f, 0.01059034f, -0.06456051f, -0.06610553f, 0.02308643f, -0.06419621f, 
    0.05233082f, 0.01064523f, -0.07019086f, -0.05131305f, -0.05871439f, 0.05966487f, 0.00772352f, -0.01176775f, 
    0.05956538f, 0.01884688f, -0.01590571f, 0.00877373f, -0.03325732f, 0.01697174f, -0.06728005f, -0.06440458f, 
    -0.06910226f, -0.00910917f, 0.03849647f, 0.00428019f, -0.03349041f, 0.02453085f, -0.04585061f, -0.00504548f, 
    -0.03288539f, -0.06842176f, 0.05002336f, -0.03848508f, -0.02620672f, 0.02976013f, 0.00149847f, 0.04714887f, 
    0.01581693f, -0.04128335f, 0.03482912f, 0.00654624f, -0.03638182f, -0.06316984f, -0.06564429f, -0.01289001f, 
    -0.08404596f, -0.03118688f, -0.05168903f, -0.06484214f, 0.05951247f, 0.03997163f, 0.02134372f, -0.02854961f, 
    0.01902080f, -0.04789328f, 0.00348290f, -0.06404488f, -0.02504124f, -0.05427329f, -0.02701847f, 0.04904169f, 
    0.02243739f, -0.05566445f, -0.02294697f, 0.00160935f, -0.06664043f, 0.06213032f, -0.01924415f, -0.07361525f, 
    -0.03505167f, 0.06819446f, 0.05122211f, -0.07526740f, -0.01797052f, 0.04331358f, -0.07958619f, -0.04955769f, 
    0.02215823f, 0.00525649f, -0.03004374f, 0.00468823f, 0.03972239f, -0.06722522f, 0.04901027f, 0.02105192f, 
    -0.02417038f, -0.00814218f, -0.05158742f, -0.01229381f, 0.06176047f, -0.07569950f, 0.01707662f, -0.02388097f, 
    -0.06115496f, 0.05120638f, -0.02020407f, 0.00909180f, -0.04866233f, -0.06685971f, -0.07024226f, -0.03350946f, 
    -0.03008056f, -0.03716065f, 0.00466123f, 0.04410106f, -0.00683179f, -0.07857595f, 0.03202507f, -0.00986386f, 
    0.03086201f, 0.02203035f, -0.04008977f, 0.00269085f, -0.01194248f, -0.04247410f, -0.06382217f, -0.02897923f, 
    0.03752322f, 0.01587830f, 0.01056968f, -0.02145417f, -0.00864505f, -0.01428614f, -0.04759122f, 0.02310634f, 
    -0.02705142f, -0.06177623f, -0.02942462f, 0.00811828f, 0.04350681f, -0.02920004f, -0.03010600f, 0.06108686f, 
    -0.02070266f, 0.10414714f, 0.23128673f, -0.05513289f, -0.14247388f, -0.22994514f, 0.18007112f, -0.20642360f, 
    -0.11884280f, -0.15460116f, -0.18219468f, -0.26867735f, 0.26506004f, -0.04793638f, -0.22914039f, -0.17295675f, 
    -0.07229349f, 0.16073710f, -0.09675585f, -0.00501697f, 0.04978121f, 0.25709623f, 0.08203172f, 0.02553093f, 
    -0.03204785f, 0.12057342f, -0.32181829f, 0.17851393f, 0.01126391f, 0.07068593f, 0.03782879f, 0.05309802f, 
    0.00661592f, 0.09267273f, -0.04142100f, 0.02244065f, 0.07115801f, -0.43614489f, 0.16914150f, -0.35251328f, 
    0.00648849f, 0.14696001f, -0.25899225f, -0.19348781f, 0.05553034f, -0.23090798f, -0.07337131f, 0.00040539f, 
    0.25561020f, -0.08118989f, 0.33899260f, -0.41281486f, -0.12796706f, -0.08252486f, 0.01025649f, -0.04999614f, 
    -0.20311351f, 0.15267782f, -0.17568949f, 0.12006938f, 0.04189361f, 0.16531651f, -0.12474583f, 0.02473741f, 
    -0.12321497f, 0.10800059f, 0.20554559f, 0.24815880f, -0.30410850f, -0.22829676f, 0.02828137f, -0.09344792f, 
    0.08626198f, -0.27740589f, 0.06956816f, 0.03034832f, -0.12495883f, -0.15308367f, -0.05391107f, -0.14294380f, 
    -0.01729536f, 0.19378635f, 0.32053229f, 0.27331397f, 0.08631591f, 0.28792119f, -0.17322658f, -0.36183378f, 
    -0.00883122f, 0.04182523f, -0.17195411f, -0.07176890f, -0.01312268f, 0.04077182f, -0.03911825f, -0.10392777f, 
    0.09172929f, 0.05254111f, 0.06475545f, -0.11691026f, -0.00006562f, 0.11007638f, 0.18224138f, -0.00413877f, 
    -0.02508072f, -0.14566745f, -0.02840571f, -0.06290745f, -0.18909992f, -0.06209622f, -0.08882509f, -0.21912499f, 
    0.05356304f, 0.10301419f, 0.12303925f, 0.13041630f, 0.15659882f, 0.20266975f, 0.18833937f, -0.07184975f, 
    0.38767278f, -0.24168730f, 0.44006994f, -0.16060624f, -0.21302786f, 0.08759591f, 0.13038644f, 0.19447224f, 
    0.06024463f, 0.15091643f, 0.04766741f, -0.00233275f, 0.45462343f, -0.09458752f, 0.16689043f, -0.34753305f, 
    -0.01810346f, 0.27819452f, -0.03512965f, 0.06454758f, -0.17390081f, 0.02216674f, -0.09530475f, 0.09258007f, 
    0.11725852f, 0.31006238f, -0.11176004f, -0.21769425f, 0.08501568f, 0.16182533f, 0.12462425f, 0.01529685f, 
    -0.06980649f, 0.04066664f, 0.36672157f, 0.09750985f, 0.56636190f, -0.14757024f, 0.37050006f, 0.01610727f, 
    -0.00096041f, -0.04127981f, 0.47473124f, -0.00603337f, -0.14353482f, -0.09219177f, 0.12358531f, -0.08382449f, 
    0.23262498f, -0.20744638f, -0.06217194f, 0.24796808f, -0.07335563f, 0.20685489f, 0.19491602f, 0.11041649f, 
    -0.04773351f, 0.27608603f, 0.14431542f, 0.03339930f, 0.39926872f, -0.01594627f, -0.39035606f, 0.17435339f, 
    -0.01147467f, 0.15232532f, 0.23887800f, 0.22262214f, -0.30562153f, -0.13121712f, -0.09331267f, -0.00674062f, 
    -0.18925060f, 0.00260163f, 0.01249258f, -0.08448016f, 0.11690429f, -0.16624375f, -0.01337223f, -0.08930565f, 
    -0.07176191f, -0.09937477f, -0.12753542f, -0.07656895f, 0.34535739f, 0.25232154f, -0.12053747f, -0.13043258f, 
    -0.05932555f, 0.11829204f, -0.00265692f, -0.12860705f, -0.06446466f, 0.05142966f, 0.08629154f, 0.05427034f, 
    0.28930750f, 0.52903581f, 0.03982399f, 0.23795803f, 0.12908456f, 0.25811234f, 0.05844244f, -0.01013902f, 
    0.16786852f, 0.00546154f, -0.05636412f, 0.01237359f, -0.24457137f, 0.07241190f, 0.13373886f, -0.06270967f, 
    -0.09063156f, 0.22104070f, -0.02132197f, -0.08914623f, 0.06976522f, 0.02050318f, -0.10627084f, 0.00177516f, 
    0.16516751f, -0.32516459f, 0.16773576f, -0.15065876f, -0.03400328f, 0.12847140f, -0.13093765f, -0.11948172f, 
    0.02176315f, -0.07043544f, -0.05230246f, -0.01496664f, 0.07447170f, 0.02665168f, -0.12956557f, 0.11138366f, 
    -0.08389588f, 0.00102502f, 0.13147983f, 0.10814186f, 0.09282541f, 0.01935525f, 0.01723894f, 0.06096078f, 
    0.14615913f, 0.01605311f, 0.11037444f, -0.03090105f, 0.18057820f, 0.07453194f, 0.04728545f, -0.08179638f, 
    0.15848845f, 0.11351065f, -0.06224450f, -0.14569294f, -0.24995270f, 0.19845150f, 0.31883559f, 0.00810581f, 
    -0.01923296f, -0.09757999f, -0.03358206f, 0.07578284f, 0.10476013f, 0.03188593f, -0.01943177f, 0.06285237f, 
    -0.48470250f, 0.13764174f, 0.34528121f, 0.21572700f, 0.06014257f, 0.04072991f, 0.16672462f, 0.03303332f, 
    0.13689023f, -0.10301811f, -0.07087048f, -0.01991039f, -0.21474375f, -0.16377003f, -0.27454522f, 0.05957256f, 
    0.07880618f, -0.11874633f, -0.01430690f, 0.11469160f, -0.06938003f, -0.14329663f, -0.00066635f, -0.01403691f, 
    0.23043297f, -0.30920494f, -0.00737564f, 0.03076985f, 0.06589040f, 0.01819941f, -0.10257839f, -0.04839642f, 
    0.10285213f, 0.06054739f, 0.07430588f, 0.02789935f, -0.22489056f, 0.26685092f, 0.39082301f, 0.00542536f, 
    -0.02221152f, 0.25618142f, 0.05148368f, 0.16213076f, 0.05198263f, 0.11166693f, -0.02141453f, 0.06818987f, 
    -0.45052370f, -0.17043649f, -0.09311169f, 0.40787941f, 0.06937576f, -0.10603694f, 0.05135872f, 0.06886608f, 
    0.14644404f, 0.21469715f, -0.01859068f, 0.10563397f, 0.61140794f, -0.17464025f, 0.24394487f, -0.04844244f, 
    0.03660512f, -0.00652681f, -0.04343062f, 0.18565880f, 0.01731525f, -0.18712455f, -0.03885247f, 0.23188710f, 
    0.25528610f, 0.01025117f, 0.43688673f, -0.06952606f, -0.24265110f, -0.00845463f, -0.14711820f, -0.00608154f, 
    0.00387716f, -0.01570143f, 0.19407073f, 0.01212549f, -0.01674928f, 0.08215762f, -0.08342899f, 0.22615737f, 
    0.08374896f, -0.00782261f, 0.07056514f, -0.01247979f, -0.07717806f, 0.03923550f, -0.08756257f, 0.19478197f, 
    -0.15749559f, 0.09840901f, -0.12572387f, 0.09225694f, 0.02395175f, -0.07371011f, -0.09120961f, -0.00838219f, 
    -0.04308536f, -0.04955292f, -0.04178253f, -0.17426649f, -0.09224055f, 0.17719522f, 0.32327378f, 0.01378709f, 
    -0.04880099f, -0.02676531f, -0.07422072f, -0.04295931f, 0.18482971f, -0.04960687f, 0.05510947f, 0.00039748f, 
    -0.19580628f, 0.42686912f, 0.54371071f, -0.09656662f, -0.11825051f, -0.29922953f, -0.09378678f, 0.04892808f, 
    -0.01561137f, 0.08146345f, 0.14460239f, 0.04045556f, -0.06898553f, 0.09893354f, -0.09463216f, 0.03377298f, 
    -0.00215389f, 0.05758144f, -0.06898352f, 0.05992498f, 0.05409969f, -0.11587020f, 0.03916430f, 0.00239432f, 
    0.39314729f, -0.18462057f, 0.07899474f, -0.02573512f, -0.07388608f, -0.00184404f, 0.12608187f, -0.11415627f, 
    0.06659890f, 0.01443919f, -0.08269651f, -0.11115161f, 0.07200489f, 0.17286105f, 0.10630938f, -0.20739231f, 
    0.05880988f, 0.09311637f, -0.01196092f, 0.08667839f, 0.13454665f, 0.12515375f, -0.06881612f, -0.00340320f, 
    -0.08030154f, 0.11662795f, -0.12690410f, -0.14657353f, 0.06005605f, -0.06299789f, 0.02635641f, -0.20742221f, 
    0.10965773f, 0.01487339f, 0.06563668f, 0.16102269f, -0.08628191f, -0.11115083f, 0.03241008f, 0.18751624f, 
    -0.09523253f, -0.08108503f, -0.12298556f, 0.07554570f, -0.01549974f, -0.05377836f, 0.06077241f, 0.01181725f, 
    -0.37780032f, 0.36226943f, 0.16050392f, 0.25380817f, -0.16039740f, -0.10411493f, 0.17330374f, -0.16197129f, 
    0.01864133f, -0.05766309f, 0.12705730f, 0.07534016f, -0.12965618f, 0.06301086f, -0.03744762f, 0.14453524f, 
    0.05353030f, -0.01081572f, -0.10911784f, 0.05267059f, 0.15851916f, 0.15924618f, 0.24659856f, 0.09840924f, 
    0.06188496f, 0.15603434f, -0.30531427f, -0.09441936f, 0.08784882f, -0.07710247f, -0.04010070f, 0.06999496f, 
    0.13851707f, 0.13534132f, -0.02856320f, 0.03614981f, -0.28641644f, -0.21408556f, -0.11712263f, 0.11586646f, 
    -0.00477381f, -0.17263991f, -0.04853392f, -0.11336287f, 0.05152237f, 0.03786042f, 0.16169876f, 0.12000684f, 
    -0.31428355f, -0.14125109f, -0.19731857f, 0.32734588f, 0.12126952f, 0.06940020f, -0.14341310f, -0.09276854f, 
    -0.19757752f, -0.13628966f, -0.05512780f, 0.14225408f, 0.26941550f, 0.12554660f, 0.03160899f, -0.15566233f, 
    -0.02839850f, -0.02879915f, 0.01788958f, 0.16981310f, 0.12847225f, -0.02545345f, 0.23510988f, -0.14405032f, 
    -0.25121734f, -0.11574090f, 0.00167277f, -0.15109046f, 0.13662986f, 0.10649135f, -0.08963446f, 0.09142712f, 
    0.07871150f, 0.06369678f, 0.05006875f, 0.13328946f, 0.42264795f, 0.16842507f, -0.15508392f, 0.08450785f, 
    0.08492867f, -0.02933534f, 0.08493221f, 0.00725785f, 0.02288577f, -0.03091945f, -0.11594667f, -0.05102500f, 
    -0.06605054f, -0.18893369f, -0.25683743f, 0.14646946f, 0.05291134f, 0.09482981f, -0.13530938f, 0.02773472f, 
    0.10908575f, 0.20364171f, -0.02618671f, 0.10557031f, -0.18127745f, 0.05720783f, 0.07286865f, 0.02513281f, 
    -0.04144777f, -0.01738475f, -0.00915814f, 0.05584982f, 0.04967910f, -0.02888421f, 0.04953562f, -0.02550094f, 
    -0.26182756f, 0.25561541f, 0.17457841f, 0.14106466f, -0.11828990f, 0.03270482f, 0.12415101f, -0.02628024f, 
    0.03457423f, 0.04706438f, 0.28331292f, 0.14538041f, 0.01454268f, 0.01492443f, -0.20400766f, 0.04222959f, 
    0.17825702f, 0.12226553f, 0.14844735f, -0.01732383f, -0.04539885f, 0.00570262f, -0.02034617f, -0.04837630f, 
    -0.25574625f, 0.13232070f, 0.08233353f, 0.17040130f, 0.07782829f, 0.00680801f, 0.06614405f, -0.11115728f, 
    0.17639636f, -0.06082429f, -0.10152972f, -0.05281578f, -0.16370106f, -0.10427342f, 0.04944205f, -0.22867341f, 
    0.00539378f, 0.01415786f, -0.04184837f, -0.12849298f, 0.20418395f, 0.11469205f, 0.08884268f, 0.29617766f, 
    0.00845817f, 0.22536469f, 0.09304699f, 0.17356940f, 0.09328520f, 0.07821539f, 0.07815063f, 0.02305516f, 
    0.09627505f, 0.10247035f, 0.04118470f, 0.01694530f, -0.12718937f, -0.43335623f, -0.19373344f, 0.10746232f, 
    0.03715654f, 0.01247628f, 0.05826414f, 0.13195039f, 0.02458203f, -0.06351706f, -0.07560940f, -0.05819998f, 
    0.03811753f, -0.16389103f, 0.23219450f, 0.25879541f, 0.01978988f, 0.05627990f, 0.22534467f, 0.11719866f, 
    0.21213603f, -0.08305164f, 0.12719104f, 0.17685921f, 0.23026887f, 0.02113955f, -0.16435340f, -0.20930731f, 
    -0.09216318f, -0.06482451f, 0.08972494f, 0.07816895f, 0.03180723f, 0.24529992f, 0.10134192f, 0.11022243f, 
    0.07757609f, 0.03474271f, -0.34439862f, 0.06803126f, 0.06979950f, 0.05525156f, 0.06126760f, 0.02469633f, 
    0.17217225f, 0.08102827f, 0.06375735f, 0.23765557f, 0.27548984f, -0.17433214f, -0.28838247f, 0.10410791f, 
    0.08887845f, -0.13049218f, 0.10909246f, 0.24155992f, 0.15364535f, -0.01497355f, 0.15400024f, 0.19298840f, 
    0.08517661f, 0.10528821f, -0.04852242f, 0.00164950f, -0.03804604f, -0.00183601f, -0.10511465f, -0.05019854f, 
    -0.10024723f, 0.06516645f, 0.08081132f, 0.27325493f, -0.31006983f, 0.45041427f, -0.27509069f, 0.11014895f, 
    0.06316375f, -0.03216641f, -0.01973218f, 0.02397643f, 0.17854761f, 0.06227955f, 0.09582449f, 0.11023122f, 
    -0.13645074f, 0.39763215f, -0.29647076f, 0.09980336f, 0.13379373f, -0.07424391f, 0.07894966f, 0.01644333f, 
    0.09400503f, 0.16997439f, -0.05392784f, -0.00411080f, -0.04447801f, 0.02085471f, 0.04781155f, -0.13627443f, 
    -0.04693297f, -0.00767421f, -0.04620801f, 0.08713350f, 0.20773672f, -0.06055904f, -0.04763919f, 0.08328747f, 
    -0.03496310f, -0.05265374f, 0.08233528f, 0.04054429f, -0.09764060f, -0.01404503f, -0.23214719f, -0.01593891f, 
    -0.10921732f, -0.03603977f, -0.18721603f, -0.22389551f, -0.04201875f, 0.21188790f, 0.14701965f, -0.07474513f, 
    0.03762637f, 0.06887396f, 0.01899489f, 0.15425889f, -0.04433977f, 0.10323062f, 0.08788079f, 0.17872597f, 
    0.13015579f, -0.17089970f, -0.15001607f, -0.29056799f, 0.08956812f, -0.05254267f, -0.04027616f, -0.13601176f, 
    0.02045682f, -0.04285062f, 0.00332203f, 0.22212429f, 0.15542504f, -0.03944510f, -0.52021754f, -0.25573611f, 
    0.02712419f, 0.05541050f, -0.07912543f, 0.08067539f, -0.13151799f, -0.09961008f, -0.12312079f, -0.02057466f, 
    0.42258322f, 0.20881045f, -0.00224404f, -0.05170379f, -0.16055614f, -0.08114469f, -0.03972505f, -0.11758998f, 
    -0.00565123f, 0.16373332f, -0.11185136f, 0.15763173f, 0.21389714f, 0.12735978f, 0.08508282f, 0.01771022f, 
    0.09664781f, -0.08152462f, 0.01424157f, 0.08153524f, 0.05426747f, 0.04548647f, -0.18497947f, -0.01625255f, 
    0.08055870f, -0.16262777f, 0.17707151f, -0.09114288f, -0.11297867f, 0.15352604f, -0.07673790f, 0.15387458f, 
    0.02169352f, 0.00871879f, 0.27240992f, 0.14721781f, -0.00913610f, 0.08839297f, -0.04693751f, -0.22595215f, 
    0.06200035f, -0.05352717f, -0.13706778f, -0.04158485f, -0.17211321f, -0.06397919f, -0.02538550f, -0.13875467f, 
    0.00942762f, -0.13457394f, -0.01976519f, -0.20910338f, 0.06484946f, 0.15648413f, -0.18327931f, 0.10420665f, 
    -0.11686005f, -0.13875717f, 0.06496324f, -0.05222114f, -0.05958194f, 0.03354997f, 0.16302985f, -0.03966093f, 
    -0.13482146f, 0.03671322f, -0.04367167f, 0.02545527f, 0.07632596f, 0.15255029f, 0.26197699f, 0.09784269f, 
    -0.03863234f, 0.22247450f, -0.06462839f, -0.00536757f, -0.08346695f, -0.06666054f, 0.08132935f, 0.08308914f, 
    0.04171333f, 0.23403588f, 0.18013290f, -0.02930083f, -0.23943409f, -0.06418584f, -0.23467410f, 0.11506519f, 
    0.06633820f, -0.02293701f, 0.16267347f, 0.02510971f, -0.06147148f, -0.03205426f, 0.08907871f, 0.13436109f, 
    0.02483372f, -0.01321615f, 0.05894474f, 0.19182637f, -0.13865359f, -0.07005166f, -0.03420806f, 0.01791566f, 
    -0.02214336f, -0.04045039f, 0.42014927f, -0.03618954f, 0.43050653f, 0.09674023f, -0.13575293f, -0.11242861f, 
    -0.05568302f, 0.04075820f, 0.15512738f, -0.15154496f, 0.06535055f, -0.07958520f, 0.04781874f, -0.12009958f, 
    -0.00610741f, -0.26564553f, -0.20274608f, 0.07997852f, 0.07780778f, 0.11280001f, 0.09686089f, 0.16156018f, 
    0.06488129f, 0.06409945f, 0.11075643f, 0.15564953f, 0.41652802f, 0.14307304f, -0.01856699f, -0.04042002f, 
    -0.10932077f, 0.04626771f, -0.07712547f, 0.02060465f, -0.02646530f, -0.06114794f, -0.04378744f, -0.11739371f, 
    0.12226197f, 0.25943020f, 0.06751496f, 0.03869418f, 0.00821109f, 0.04174210f, 0.11963153f, 0.01216768f, 
    -0.04049765f, 0.18928504f, 0.06285034f, -0.03806489f, -0.14825611f, 0.02213693f, 0.01197074f, 0.08352955f, 
    0.02817914f, -0.00897607f, -0.03723483f, 0.22997437f, 0.13772851f, 0.14068888f, 0.01977489f, 0.21421216f, 
    0.21716592f, 0.14103450f, -0.07345792f, 0.45046282f, 0.04959481f, 0.07686111f, 0.07940793f, 0.01019139f, 
    -0.07224649f, -0.01039599f, -0.05006697f, 0.19519098f, 0.08548579f, 0.13913456f, -0.09988064f, -0.10388438f, 
    0.05329655f, -0.08345433f, -0.13605106f, 0.16998798f, 0.14708576f, -0.12676807f, -0.12098631f, -0.18847910f, 
    -0.68190610f, -0.21681042f, 0.22073469f, -0.06112598f, -0.02036520f, -0.18428054f, -0.14581074f, -0.09875147f, 
    -0.12253941f, 0.16362669f, 0.00715717f, 0.06398359f, 0.31502211f, -0.39589575f, -0.19296640f, 0.05593377f, 
    -0.15049951f, 0.13245375f, -0.15264906f, -0.27386674f, -0.02795639f, 0.10348288f, -0.33072674f, -0.10367972f, 
    0.01465643f, 0.04279967f, 0.05540917f, 0.07216702f, 0.02125445f, -0.26753414f, -0.13403603f, -0.09307087f, 
    -0.17105074f, 0.06105230f, 0.21674332f, 0.30766186f, 0.18616973f, -0.02672734f, -0.08685754f, 0.05016663f, 
    0.03983170f, 0.18357594f, 0.26668748f, 0.19772890f, 0.11225460f, 0.02487170f, -0.01290587f, -0.12380722f, 
    0.57327008f, 0.10037073f, 0.16184226f, 0.12143285f, 0.02965547f, 0.18923119f, 0.01288455f, -0.07255912f, 
    -0.09790411f, -0.11185811f, 0.09670601f, 0.10491689f, 0.00604978f, -0.02667469f, -0.11229211f, 0.06463631f, 
    -0.03571629f, -0.05019822f, 0.17661814f, 0.04575197f, 0.11580583f, 0.25572014f, 0.03416851f, 0.27921671f, 
    -0.36996064f, -0.45870736f, 0.20790952f, -0.40620437f, 0.03591143f, 0.06335727f, -0.22057870f, -0.03911556f, 
    0.14040406f, 0.13837443f, -0.15329005f, 0.09237076f, 0.08752631f, 0.01733633f, 0.00468062f, -0.05689659f, 
    -0.04845374f, -0.02021235f, -0.11689332f, -0.08172745f, 0.01520133f, -0.02669748f, 0.05754601f, 0.04979191f, 
    0.17055500f, 0.17766960f, -0.23364845f, -0.18778868f, 0.15499724f, 0.07818022f, -0.00092840f, 0.05668466f, 
    -0.11982923f, -0.13411741f, -0.09207559f, -0.13946684f, -0.00325061f, 0.07277918f, 0.09306523f, -0.03617994f, 
    -0.04079603f, -0.09656055f, 0.14343810f, -0.18090403f, -0.14852089f, 0.02846297f, -0.00468667f, -0.15866975f, 
    0.23195916f, 0.13249207f, -0.04841067f, 0.23876433f, 0.11594704f, 0.21473645f, 0.19313656f, -0.03722223f, 
    0.28012320f, 0.08761457f, -0.05141590f, 0.12213354f, -0.43152276f, -0.46012330f, 0.44734934f, -0.13125962f, 
    0.16771191f, 0.24596281f, -0.16895273f, -0.21211019f, -0.15723863f, -0.14519367f, -0.11717772f, 0.05051263f, 
    -0.16498123f, -0.03466167f, -0.07293841f, 0.10289543f, 0.05118425f, -0.09950475f, 0.10945854f, -0.09573090f, 
    -0.10323057f, 0.14908020f, 0.14495757f, 0.03934411f, -0.28619403f, -0.00012395f, -0.14547598f, 0.00081343f, 
    -0.00812598f, 0.13960168f, -0.00157477f, 0.07912468f, 0.04430366f, -0.02491091f, -0.01967134f, 0.03552551f, 
    -0.00141113f, 0.43195683f, 0.16764908f, 0.40730968f, -0.01064257f, 0.20469932f, 0.11897559f, -0.02609026f, 
    -0.02210123f, 0.11569674f, 0.08837175f, 0.09011471f, -0.12169039f, -0.20252687f, -0.09699728f, -0.04580497f, 
    0.12665763f, 0.19658868f, -0.07894515f, -0.23717891f, -0.11902779f, -0.08274638f, -0.02060237f, 0.08756836f, 
    0.25162226f, -0.06427454f, 0.55871993f, -0.36551505f, -0.08461034f, -0.14079358f, 0.00879072f, -0.21454063f, 
    0.06753705f, 0.10686268f, -0.08771050f, 0.05273051f, 0.28722262f, 0.02397029f, -0.17645180f, -0.10023362f, 
    -0.09226432f, -0.04238578f, -0.18494499f, 0.01639377f, 0.04573489f, 0.21891420f, -0.10916829f, 0.18958426f, 
    0.26221964f, -0.08878213f, 0.24533275f, -0.12548591f, 0.12355737f, 0.03662412f, -0.09061925f, 0.03130398f, 
    -0.01900487f, 0.09650320f, -0.09284462f, -0.18413346f, -0.51843750f, -0.36411306f, 0.02469889f, 0.09189252f, 
    0.05702240f, -0.01468297f, 0.07749246f, -0.12331296f, -0.10344016f, 0.09596220f, 0.00115330f, -0.10551424f, 
    -0.14676312f, -0.07890190f, 0.29381374f, 0.26173979f, 0.20951068f, 0.06687173f, 0.10999568f, 0.24561219f, 
    0.00992291f, 0.02034032f, -0.00365438f, 0.13586274f, 0.03162477f, -0.06085624f, -0.25706783f, -0.14612763f, 
    -0.08658618f, -0.19679558f, 0.01096748f, -0.05976489f, -0.07896447f, -0.00431978f, -0.19995499f, -0.02199355f, 
    0.06622699f, -0.14344397f, -0.05237548f, -0.10251880f, 0.01996120f, 0.02776466f, 0.04392507f, 0.20702381f, 
    0.05621121f, 0.20420742f, 0.00127577f, 0.08919086f, 0.14043009f, -0.07924327f, -0.06110272f, 0.07896721f, 
    0.02515667f, 0.06176466f, -0.00038125f, -0.02256920f, 0.00648451f, 0.04374307f, 0.01689173f, -0.07231472f, 
    -0.01456116f, -0.02185006f, -0.20015295f, 0.09951177f, 0.01641509f, -0.07646073f, -0.01380010f, 0.12255058f, 
    0.03097058f, 0.09267250f, -0.06591691f, 0.10021593f, 0.75211632f, 0.21442433f, -0.07910039f, -0.03674241f, 
    0.11238913f, 0.13870890f, 0.01479608f, -0.18004520f, 0.20699117f, -0.10642634f, -0.07050432f, 0.06336973f, 
    -0.11655509f, 0.33358097f, -0.17587161f, 0.17813073f, -0.13450870f, 0.03861352f, 0.02215589f, -0.07116555f, 
    0.14901909f, -0.08583794f, 0.09720312f, -0.15296011f, -0.00703471f, 0.04002733f, -0.06050501f, -0.18936223f, 
    -0.08164195f, -0.09578554f, -0.04070204f, 0.05168568f, 0.11931262f, 0.06417851f, -0.14512727f, -0.04818330f, 
    0.01087412f, -0.02028532f, -0.00760069f, -0.07549883f, -0.07164799f, 0.03133491f, -0.00596371f, 0.06278272f, 
    0.03843262f, -0.05848239f, 0.01252894f, -0.00643560f, -0.05354359f, 0.04520996f, -0.03337232f, -0.05561894f, 
    0.04915104f, -0.01700695f, -0.05554648f, 0.05760237f, -0.06960500f, -0.00131537f, 0.03908486f, -0.00165902f, 
    -0.01651704f, -0.04104175f, -0.01206341f, -0.04182895f, 0.02587940f, -0.03871153f, -0.03094395f, -0.07166050f, 
    -0.01859872f, 0.00902519f, 0.03976298f, -0.02793868f, -0.01896398f, -0.00867706f, -0.00481031f, 0.00590151f, 
    -0.07166662f, -0.06969026f, 0.03457936f, -0.05641582f, -0.02877806f, -0.03066431f, -0.04043373f, 0.03435155f, 
    0.04551558f, 0.04416602f, -0.01358058f, 0.05530529f, 0.01127849f, -0.02530726f, -0.01074546f, 0.06389775f, 
    -0.03002359f, 0.02008388f, -0.05346743f, -0.05823204f, -0.01149638f, -0.00116339f, -0.06409281f, -0.05168866f, 
    -0.07451537f, 0.04251534f, -0.04365623f, 0.00409661f, -0.00304071f, 0.03601835f, -0.00169639f, 0.00368748f, 
    0.01101833f, -0.04736847f, 0.06302188f, -0.03955472f, -0.01898744f, -0.06352790f, 0.01183001f, 0.03082841f, 
    0.04969376f, 0.05641719f, 0.03207872f, 0.04294929f, -0.04673746f, -0.00760252f, 0.05135578f, -0.06104968f, 
    0.02347837f, -0.02769597f, -0.04460880f, 0.02329856f, -0.00720306f, 0.06445446f, -0.02977242f, -0.02864232f, 
    0.03960516f, 0.04836068f, -0.07431559f, -0.04373801f, -0.05794543f, 0.00187798f, -0.06264489f, -0.03974092f, 
    -0.02242920f, -0.05456013f, -0.03419298f, -0.02736360f, 0.02649313f, 0.02223174f, -0.05571901f, -0.01500152f, 
    0.01069328f, -0.00607871f, -0.05585250f, 0.07174901f, -0.01335990f, 0.06694919f, -0.07284928f, 0.05939206f, 
    -0.01915574f, 0.01236919f, -0.05482501f, 0.01419179f, -0.01446331f, 0.00479534f, -0.07337815f, -0.05908263f, 
    0.06943812f, 0.04033626f, -0.01762047f, 0.02996459f, 0.01867470f, 0.02577352f, -0.05013351f, -0.07425874f, 
    -0.02727331f, -0.00097423f, -0.01235310f, 0.01435270f, -0.00657323f, -0.05680848f, 0.00249228f, -0.04850297f, 
    0.06247484f, -0.02867226f, 0.00397850f, 0.06908839f, -0.01365542f, -0.01751196f, 0.02878937f, -0.00983051f, 
    -0.05920706f, 0.02911529f, 0.03440141f, -0.05522766f, -0.01314309f, 0.01984074f, 0.03114038f, -0.07300369f, 
    -0.06370588f, -0.00918459f, -0.04508900f, -0.03592835f, 0.03542699f, -0.05681108f, 0.06254039f, -0.02231330f, 
    -0.05323495f, -0.04083079f, 0.04659663f, 0.05834753f, -0.02167561f, 0.04753256f, -0.05198249f, -0.02019021f, 
    -0.03911886f, 0.06387199f, 0.03763436f, -0.04536105f, -0.06035286f, 0.04504971f, -0.00788439f, 0.05546529f, 
    -0.01600708f, 0.02447314f, 0.02652494f, -0.01895439f, 0.00093929f, 0.01586482f, 0.06808458f, -0.03965935f, 
    -0.06710787f, -0.18655296f, -0.21314909f, 0.19709268f, -0.10187118f, -0.13977608f, -0.01452039f, -0.06467696f, 
    0.04129232f, 0.08273327f, 0.03882395f, 0.05101456f, -0.22754939f, -0.19191316f, 0.07847189f, 0.15150145f, 
    -0.03843135f, 0.03850385f, 0.04023776f, 0.05100960f, -0.05112067f, 0.03901806f, 0.05679952f, -0.01945002f, 
    -0.66466284f, -0.17783269f, 0.04226088f, 0.16358083f, -0.06424251f, 0.12374334f, 0.26091608f, -0.02617733f, 
    0.12245964f, 0.08158635f, 0.01418517f, 0.02405993f, -0.23234664f, -0.25510690f, -0.01548728f, 0.15974712f, 
    0.11413965f, 0.20068425f, 0.04222597f, -0.16201563f, 0.00219602f, -0.02012305f, 0.05564579f, 0.01610479f, 
    0.16790158f, 0.40264496f, 0.33567560f, 0.03400602f, 0.01147410f, 0.03202851f, -0.03169586f, 0.07318397f, 
    0.06759498f, 0.09528255f, 0.05639460f, -0.05078275f, -0.12241787f, -0.04168387f, 0.09001926f, -0.00657405f, 
    0.01849386f, 0.02320727f, 0.07093741f, -0.13828176f, -0.09838295f, -0.09444954f, 0.27637810f, 0.17875497f, 
    0.04810905f, 0.25235477f, -0.02477446f, 0.11186469f, -0.05544390f, 0.06272731f, 0.04352124f, -0.07440231f, 
    0.22158529f, 0.15811238f, 0.07447835f, -0.12720937f, -0.16217802f, -0.35208705f, -0.24821170f, 0.11105509f, 
    0.09433554f, 0.01600049f, 0.12156257f, -0.11835951f, 0.03158125f, 0.08616579f, -0.13373531f, -0.08332987f, 
    0.14268816f, -0.35663739f, -0.02121489f, 0.20393981f, 0.09029270f, -0.06262320f, 0.15024079f, 0.02650119f, 
    0.20602645f, 0.03908488f, -0.00341484f, 0.07668489f, 0.27416912f, 0.12798633f, -0.17956316f, -0.20409636f, 
    -0.04015277f, -0.06888743f, 0.09544141f, 0.05606820f, 0.06350016f, 0.12248894f, 0.00839252f, 0.07495948f, 
    0.35751954f, 0.06612647f, -0.21072881f, 0.10345651f, -0.02027015f, 0.17706087f, 0.14899836f, 0.06126590f, 
    -0.13031536f, 0.06749979f, 0.07070945f, 0.07881986f, 0.42388400f, -0.31415802f, -0.06890510f, 0.01722413f, 
    -0.01737368f, 0.07742357f, -0.03550874f, 0.04500711f, -0.00925708f, -0.05493829f, 0.03084319f, 0.06708100f, 
    0.34243670f, -0.03230640f, -0.21584374f, -0.26368007f, 0.15628840f, 0.05070309f, -0.00293275f, -0.12943740f, 
    -0.09254277f, 0.00235402f, -0.18037398f, 0.14097664f, -0.17767388f, 0.22944705f, -0.06161753f, 0.19771868f, 
    0.04673517f, 0.01838819f, 0.13111384f, 0.08952101f, -0.00545001f, -0.12289620f, -0.07238458f, 0.15437682f, 
    -0.24067858f, 0.35753644f, -0.08919989f, 0.12780647f, -0.07665600f, 0.07468209f, 0.07544582f, 0.11375155f, 
    -0.13787870f, 0.04742835f, 0.11345401f, -0.00659628f, 0.14540356f, 0.04953103f, 0.18975292f, 0.16451782f, 
    0.00572779f, 0.07400946f, -0.07882842f, -0.03673735f, -0.01097872f, 0.00667113f, 0.05462803f, 0.05624011f, 
    -0.03435448f, -0.02968764f, 0.03771645f, 0.04627543f, -0.07212926f, -0.02963414f, -0.00164925f, -0.03924813f, 
    0.06143823f, -0.03332161f, -0.07118059f, -0.00779970f, -0.03702986f, -0.03891038f, -0.00124929f, 0.01810549f, 
    0.04338947f, -0.02691425f, 0.03529502f, -0.07603405f, 0.00925799f, 0.02740021f, 0.01358426f, -0.07157141f, 
    0.01972077f, -0.01916661f, 0.03005766f, 0.02814331f, -0.03979928f, -0.00705785f, -0.03284098f, -0.03415797f, 
    -0.00442498f, -0.01067065f, -0.07343701f, 0.02870063f, -0.07726450f, -0.06858123f, -0.06485786f, 0.02124977f, 
    -0.07023733f, -0.01330124f, 0.03424041f, -0.00627755f, -0.07798465f, 0.02271640f, 0.05408659f, -0.06664216f, 
    0.02836322f, -0.02480702f, 0.03616445f, 0.01201782f, 0.04391689f, 0.05652349f, -0.07357552f, -0.03404144f, 
    -0.06190318f, -0.08030581f, 0.02185566f, -0.01137090f, -0.06319966f, -0.01799705f, 0.00955515f, 0.04779248f, 
    0.05344524f, -0.04761959f, -0.00387819f, -0.07384200f, 0.05702664f, -0.02769852f, -0.07209315f, -0.04258244f, 
    -0.05357795f, -0.00718267f, -0.04003755f, 0.00122700f, -0.02400425f, 0.00226632f, -0.06116442f, -0.07665194f, 
    0.00386219f, -0.03932033f, -0.06054312f, -0.04799144f, -0.04456431f, -0.03292326f, 0.03917624f, -0.04407156f, 
    -0.01176119f, -0.00925560f, 0.00841806f, -0.00397921f, 0.03222225f, 0.03609283f, -0.03503403f, 0.04637660f, 
    0.05048303f, -0.05550206f, -0.04793289f, 0.05681505f, 0.04653893f, 0.02062854f, -0.05764145f, -0.00362737f, 
    -0.01954003f, 0.01816154f, -0.02501374f, -0.03475719f, -0.04111777f, -0.01329632f, -0.03408580f, 0.02402241f, 
    -0.00662429f, -0.00646807f, 0.03120709f, -0.05761840f, -0.02931330f, 0.00730215f, 0.05078134f, -0.01782837f, 
    -0.06228312f, 0.01352652f, -0.00258126f, -0.01926647f, 0.01385502f, 0.01326153f, 0.05634521f, 0.01456941f, 
    0.00744511f, 0.04535503f, -0.04152197f, 0.01549250f, -0.06095296f, -0.00503064f, 0.03099084f, 0.04934557f, 
    -0.03633320f, 0.02205792f, -0.03333805f, 0.02472132f, -0.01952156f, -0.07243348f, -0.05871249f, -0.04610158f, 
    0.01846668f, -0.05249478f, 0.01571189f, 0.02204599f, -0.01297943f, -0.00731053f, -0.07729372f, -0.07950592f, 
    0.04976869f, -0.04727232f, 0.04158375f, -0.01900987f, -0.04737670f, -0.01237491f, 0.03482753f, 0.03826981f, 
    0.05042069f, -0.06917663f, -0.03554621f, -0.00508483f, 0.00865473f, -0.02385811f, -0.06218727f, 0.04194485f, 
    0.02239386f, -0.02005420f, 0.03944198f, -0.06296128f, 0.06298756f, -0.07072006f, 0.01084581f, 0.03951051f, 
    -0.05245145f, 0.00781213f, 0.00106149f, 0.06375599f, -0.06354155f, 0.01717607f, 0.03703484f, -0.04337478f, 
    0.01328488f, 0.06382069f, 0.04717066f, -0.00365183f, 0.02070112f, -0.02502131f, -0.04755892f, -0.04567678f, 
    -0.11130850f, -0.08717178f, 0.00584465f, -0.06615627f, -0.12888119f, 0.02442804f, 0.08353003f, 0.08297618f, 
    -0.04678375f, 0.02845139f, 0.01519967f, -0.09872243f, -0.14496507f, 0.22939171f, 0.14641643f, 0.07515030f, 
    0.01498673f, 0.04967337f, 0.01154036f, -0.04556964f, 0.26536518f, -0.06237011f, 0.10079013f, 0.08554470f, 
    -0.02536836f, 0.45346326f, 0.28144845f, -0.06679978f, -0.14040987f, -0.16409825f, -0.02690451f, 0.06923228f, 
    0.01312564f, -0.14832905f, 0.00516465f, -0.04726922f, -0.25738463f, 0.09772964f, -0.13735640f, 0.12207124f, 
    0.11443005f, -0.06643149f, 0.07856821f, -0.09904099f, 0.02953974f, -0.04994811f, -0.03583094f, 0.03237469f, 
    0.48923901f, -0.09281067f, -0.15479192f, -0.24525225f, -0.03342926f, -0.12321557f, 0.02730639f, -0.08069966f, 
    0.05214920f, 0.05462879f, 0.11563714f, -0.03860917f, 0.36698297f, 0.10006213f, 0.07910111f, -0.17083503f, 
    0.02989038f, -0.12275834f, -0.04067148f, 0.08698533f, 0.24016316f, -0.03767780f, -0.20684920f, 0.00334972f, 
    0.18168586f, 0.01905965f, -0.08797856f, -0.09242709f, 0.03841341f, -0.07360431f, 0.16494772f, -0.00516899f, 
    0.03996116f, -0.04221847f, 0.18889268f, 0.14538668f, -0.24765335f, -0.12686640f, 0.23460223f, 0.23338617f, 
    -0.00579555f, -0.03694791f, -0.07358070f, -0.08678251f, -0.02979579f, -0.02519257f, 0.15164126f, -0.03241315f, 
    -0.00592747f, 0.15812403f, 0.31263959f, 0.13934523f, 0.04979983f, -0.04790910f, -0.01463386f, 0.03599041f, 
    0.13710953f, 0.09523445f, 0.15593982f, 0.09590396f, 0.17604257f, 0.03007438f, 0.08070889f, 0.14319107f, 
    0.03607540f, -0.01346562f, -0.12035786f, 0.09031641f, 0.23805398f, 0.06975743f, 0.11271864f, 0.03918312f, 
    -0.02050975f, 0.36079881f, -0.20706551f, -0.05031896f, -0.00459062f, -0.09451860f, 0.01842477f, -0.07673541f, 
    0.16650937f, 0.03501640f, -0.02965154f, 0.13580465f, -0.66363049f, -0.02787874f, -0.05922756f, 0.20110667f, 
    -0.01799969f, -0.04704795f, 0.05372730f, -0.06398224f, -0.04723588f, 0.07454473f, -0.00246279f, 0.02232740f, 
    0.00971595f, -0.21864903f, -0.01858789f, 0.31744871f, -0.06953386f, 0.04583275f, 0.02556031f, 0.04593929f, 
    -0.11465663f, 0.04115750f, -0.00255447f, -0.04211909f, 0.44087613f, 0.29983783f, -0.27740026f, -0.21612877f, 
    0.02824559f, 0.05277066f, -0.00809270f, -0.05524307f, 0.11602958f, 0.07250789f, -0.07645032f, -0.05724007f, 
    -0.25083697f, -0.45679390f, 0.03314377f, -0.25253910f, 0.03607957f, 0.08853605f, 0.06246604f, -0.04864667f, 
    0.14722246f, -0.15704694f, 0.21010923f, 0.03309423f, 0.20307140f, -0.16552506f, 0.00281450f, -0.11753103f, 
    -0.05715602f, -0.07013003f, -0.01248764f, -0.05861025f, 0.01428763f, -0.01500224f, 0.00033423f, -0.16313700f, 
    0.14121360f, -0.02047521f, -0.21723251f, -0.17615315f, -0.02236286f, 0.02030618f, -0.03740037f, 0.04091201f, 
    0.17074405f, -0.05108600f, -0.35774747f, -0.09103650f, 0.11228680f, 0.03761683f, 0.25155601f, 0.05863103f, 
    0.13349771f, -0.01697779f, 0.16802619f, 0.00852988f, 0.00563818f, 0.11334000f, 0.20319632f, 0.16976619f, 
    0.09070709f, -0.31588408f, 0.04855073f, -0.10817522f, 0.12096639f, 0.07409383f, -0.07379447f, -0.09198704f, 
    0.09474583f, -0.02338151f, 0.16634811f, -0.00428346f, 0.13387768f, 0.25988981f, -0.04204438f, 0.05151065f, 
    0.10304365f, 0.23749273f, 0.19460085f, 0.10871854f, -0.00406305f, 0.07493249f, 0.04838628f, -0.13358305f, 
    0.03383768f, -0.15552086f, -0.34451085f, 0.56421143f, 0.08402906f, 0.03821620f, -0.05805005f, 0.10409599f, 
    0.06418022f, -0.03361213f, -0.02748530f, -0.14360283f, -0.23327743f, -0.19946355f, -0.24111988f, -0.05964330f, 
    0.15380199f, -0.23070055f, -0.17674415f, -0.42453679f, 0.22320645f, -0.02383290f, 0.13866599f, 0.05031231f, 
    -0.04771676f, 0.39854491f, -0.12268995f, 0.28311348f, -0.00543046f, 0.09521709f, 0.08161547f, 0.09426720f, 
    0.02671194f, 0.00075021f, -0.13918506f, 0.09276727f, 0.58353955f, -0.03121179f, -0.10650720f, -0.07876536f, 
    0.14063476f, 0.13510168f, 0.19597341f, 0.07859018f, 0.16367871f, 0.10040383f, -0.09725908f, 0.11455397f, 
    -0.16541204f, -0.03889168f, -0.05215806f, -0.06350072f, 0.00765752f, -0.01842035f, -0.02155949f, -0.03250523f, 
    0.11116109f, 0.03682629f, -0.05623364f, -0.06773095f, -0.15993279f, -0.03300280f, -0.08714486f, 0.17345685f, 
    -0.03922126f, 0.06833395f, -0.06822354f, 0.07082506f, -0.00572206f, 0.27839071f, 0.06516872f, 0.18872179f, 
    -0.06792183f, -0.27125710f, -0.42193627f, 0.03280042f, 0.00475443f, -0.09369171f, -0.15139411f, -0.19894861f, 
    0.14556004f, -0.07126114f, -0.02911715f, 0.04448958f, 0.06068216f, -0.03396799f, 0.05188963f, -0.09354953f, 
    0.12665740f, 0.11718041f, 0.06442387f, 0.02722848f, 0.07195830f, 0.01583312f, 0.15724000f, 0.07775005f, 
    -0.02861271f, 0.22486298f, 0.18056226f, 0.08265192f, 0.06928702f, -0.08221823f, -0.19485757f, -0.28402683f, 
    -0.02968819f, 0.01691413f, -0.13788739f, 0.01001713f, -0.34266761f, 0.08460719f, -0.33227816f, 0.11913824f, 
    0.20248589f, -0.17704728f, -0.24111024f, 0.17172699f, 0.04004432f, 0.32155630f, -0.13844407f, 0.05309264f, 
    0.19935572f, 0.41112840f, 0.09735084f, -0.21214925f, 0.23912545f, 0.04339872f, -0.03966789f, 0.05290761f, 
    -0.03744574f, 0.12860921f, -0.06179686f, 0.22829704f, -0.20526306f, -0.28895828f, -0.23881339f, -0.02480425f, 
    -0.17668122f, -0.09642925f, -0.10630886f, -0.17353629f, -0.09436393f, 0.00029317f, -0.15789723f, -0.14074317f, 
    0.02635525f, 0.11068144f, 0.02416522f, -0.15715355f, 0.09709170f, 0.05699445f, 0.08402713f, -0.06521012f, 
    -0.17768942f, 0.18944305f, 0.24914862f, 0.18384135f, -0.33555889f, -0.07147763f, -0.29439378f, 0.03883542f, 
    0.01607227f, 0.01475255f, 0.00755918f, 0.06928743f, 0.02816557f, 0.05051104f, -0.08085606f, 0.21455020f, 
    0.34237957f, 0.49521998f, 0.20232365f, 0.54280871f, 0.06485642f, 0.27700993f, 0.13217160f, 0.15952356f, 
    0.01024207f, 0.19682793f, -0.01141281f, 0.14511463f, 0.05489261f, -0.01912616f, -0.09136625f, -0.22119135f, 
    -0.06474090f, -0.06712263f, -0.10212055f, 0.16885747f, -0.10097776f, -0.03015400f, -0.11411675f, -0.05096630f, 
    -0.51335615f, 0.00808865f, 0.53678381f, -0.04732186f, -0.18953866f, -0.25027683f, -0.12491026f, -0.39965060f, 
    -0.11384150f, 0.09293313f, -0.05482842f, 0.21084392f, 0.26528975f, 0.07249540f, -0.05263919f, 0.05282135f, 
    -0.03523178f, 0.10239213f, -0.29983643f, -0.10822648f, -0.09899343f, 0.28692260f, -0.28569636f, 0.20040701f, 
    0.38758028f, -0.23461907f, 0.34296167f, -0.23807336f, 0.01327689f, -0.16568083f, -0.16785139f, 0.10771099f, 
    -0.01152295f, 0.07216524f, -0.18758580f, -0.04414873f, -0.43541533f, -0.15935600f, -0.01061661f, -0.02808031f, 
    0.16645703f, 0.12811004f, 0.12842251f, -0.11746753f, -0.22123758f, 0.01399159f, -0.03626016f, -0.13709812f, 
    0.26704732f, 0.16913876f, 0.26785502f, 0.33579180f, 0.10877816f, 0.10141035f, -0.04097060f, 0.09063847f, 
    -0.19845729f, 0.05309183f, -0.05598780f, 0.21811287f, -0.05812513f, 0.04068481f, -0.19710015f, -0.13903596f, 
    -0.07735202f, -0.20614739f, -0.06765413f, -0.21404260f, -0.02176892f, -0.12748079f, -0.37889817f, 0.06485843f, 
    -0.37561387f, -0.14342201f, 0.23294616f, -0.11399470f, 0.15273307f, 0.05355658f, -0.07403179f, 0.00632329f, 
    0.01177902f, 0.23520212f, -0.15773241f, 0.18778519f, 0.08178160f, 0.20898783f, -0.07495796f, 0.09538363f, 
    -0.14464140f, -0.02517983f, 0.13492256f, 0.07278983f, -0.09077320f, -0.02466934f, -0.05778186f, -0.13779092f, 
    -0.05178902f, 0.15070474f, -0.00292845f, -0.06573907f, -0.05352041f, 0.00325709f, 0.10289129f, 0.11074799f, 
    -0.01269222f, -0.06342356f, -0.03839656f, -0.06403898f, 0.37030777f, -0.17168270f, 0.29271582f, -0.13308458f, 
    0.10033207f, 0.07666656f, 0.18005565f, -0.07039777f, 0.21606611f, -0.07271874f, -0.04982251f, 0.08283215f, 
    0.08385809f, 0.29906133f, -0.37725204f, 0.36865431f, 0.00960966f, 0.11200956f, -0.09358075f, -0.03442125f, 
    0.18005753f, -0.21335068f, -0.05233907f, -0.13229614f, -0.51629555f, 0.20816550f, 0.24416515f, -0.09676667f, 
    0.13508552f, 0.15540843f, -0.10623533f, -0.24768433f, 0.10277083f, 0.17635427f, 0.01413635f, 0.24924852f, 
    -0.09581096f, -0.02139259f, 0.02760820f, -0.03994563f, 0.14446731f, 0.25069565f, -0.00389520f, 0.07477880f, 
    -0.07778381f, 0.18112077f, 0.16533996f, 0.06753354f, 0.13462107f, -0.00350955f, -0.27512494f, -0.10966966f, 
    0.13247806f, 0.08306377f, 0.12531914f, 0.17662656f, -0.05840646f, 0.08231472f, -0.03592145f, 0.03058144f, 
    0.58610302f, -0.38108841f, -0.47929651f, -0.30702716f, 0.00231131f, 0.20491475f, 0.01201012f, -0.13105449f, 
    0.00635897f, -0.13891461f, 0.09831197f, -0.04092850f, 0.01894777f, 0.16028176f, -0.08754154f, 0.03535020f, 
    0.05040325f, -0.04770724f, 0.23767392f, 0.13811995f, -0.14868946f, 0.26201954f, 0.07543990f, 0.15220426f, 
    -0.13783613f, 0.27277943f, -0.15328541f, 0.36898929f, -0.08343861f, -0.03538232f, -0.13888405f, 0.00080981f, 
    -0.13318568f, -0.07855351f, 0.05421814f, 0.12030338f, -0.04199798f, -0.01162316f, 0.05067132f, 0.04703907f, 
    -0.07583234f, -0.07662383f, -0.01045333f, -0.06400289f, -0.03936949f, 0.14694387f, 0.05775343f, 0.19391087f, 
    -0.02668302f, -0.18339990f, 0.15848686f, -0.09703243f, 0.08055712f, 0.15470517f, -0.04805080f, 0.29227889f, 
    -0.01293710f, 0.01708054f, -0.20852140f, -0.28874731f, -0.13280149f, 0.25684163f, 0.03221659f, -0.10020157f, 
    0.14740396f, 0.10833438f, 0.11824259f, 0.08680885f, 0.14472027f, 0.10173529f, -0.02163223f, -0.09781028f, 
    -0.09407157f, -0.11206381f, -0.29277048f, -0.19736142f, -0.02419026f, -0.02355788f, -0.11613412f, 0.24736503f, 
    -0.06352310f, -0.02095810f, -0.08826671f, -0.25691861f, 0.03295216f, 0.04901863f, 0.18239744f, -0.01218540f, 
    -0.03614909f, -0.06259685f, -0.08699435f, -0.06882846f, -0.07549756f, -0.23006041f, -0.20263697f, -0.05010918f, 
    -0.32601458f, 0.02100001f, 0.18785749f, 0.14697726f, 0.11660605f, -0.00432229f, 0.04801475f, -0.07993851f, 
    -0.11769282f, 0.06826635f, 0.20159236f, 0.18918322f, -0.05515748f, 0.36320812f, 0.11320941f, 0.21809484f, 
    0.39565989f, 0.21511084f, 0.16572012f, 0.13676675f, 0.06550394f, 0.04504099f, 0.00628489f, -0.03482240f, 
    -0.09697025f, 0.06294335f, 0.51701248f, 0.23984826f, -0.24650316f, -0.05151027f, -0.01262040f, -0.03004406f, 
    0.25845045f, 0.19335642f, 0.18060999f, -0.05140906f, -0.02280964f, -0.07617113f, -0.01180064f, 0.16665255f, 
    0.18219270f, 0.13631080f, 0.03044584f, 0.04528709f, 0.07424565f, 0.09259879f, -0.10267708f, 0.17518313f, 
    0.33996847f, -0.13731740f, -0.01158789f, 0.03667741f, -0.00566927f, -0.12052350f, 0.06030979f, 0.03334142f, 
    0.10965522f, -0.22601824f, -0.13995433f, -0.01934445f, -0.21683516f, 0.07331201f, 0.10948635f, -0.16799159f, 
    0.00858055f, 0.03312189f, 0.03055971f, -0.05822523f, 0.04262158f, -0.01270865f, 0.23629302f, -0.00468280f, 
    -0.18482515f, 0.01176035f, 0.03645621f, -0.13128249f, -0.04263128f, 0.01570145f, 0.09585264f, -0.12439422f, 
    -0.14486159f, -0.25479469f, -0.06469634f, -0.12583031f, 0.13928920f, 0.12668815f, 0.12550117f, -0.03158456f, 
    0.00598561f, 0.04071638f, -0.04393885f, -0.13492912f, 0.16395065f, -0.04669445f, -0.00865045f, 0.09394057f, 
    -0.00849362f, 0.10966599f, 0.18846606f, -0.35737896f, -0.00133627f, -0.14275120f, -0.22971259f, 0.09404329f, 
    0.09535436f, -0.06500275f, -0.04804257f, -0.08939356f, -0.13436531f, 0.05825051f, 0.10100424f, 0.05292853f, 
    -0.07058951f, 0.06995742f, 0.11306868f, 0.13359964f, 0.13504647f, -0.06508761f, -0.13404670f, -0.08729681f, 
    0.57265306f, -0.11336216f, 0.06210595f, -0.06190397f, -0.05038014f, 0.07365500f, 0.06083327f, 0.10114662f, 
    -0.08293273f, -0.01375543f, 0.00384207f, -0.09850881f, 0.07495325f, 0.22048880f, -0.05936387f, 0.02038116f, 
    -0.03535592f, 0.07979822f, 0.07137950f, 0.11851605f, 0.03859611f, -0.04356116f, 0.00106652f, -0.16527086f, 
    -0.07397854f, 0.01881063f, -0.07399949f, -0.07448150f, -0.04859732f, -0.00119703f, 0.06971477f, 0.00888941f, 
    0.14828578f, -0.06433499f, 0.06460381f, 0.12290010f, -0.02280307f, 0.33149475f, 0.11725918f, 0.07494670f, 
    -0.07962436f, -0.03548888f, -0.03923092f, 0.02682242f, 0.00860521f, 0.01274546f, 0.05168188f, 0.07804503f, 
    -0.41598317f, 0.32737026f, 0.02941537f, -0.01994225f, -0.09269494f, -0.00030649f, 0.07078033f, 0.01879321f, 
    0.01478570f, 0.11019740f, 0.00827757f, 0.04527261f, -0.28750601f, -0.09349462f, 0.25815749f, 0.29382369f, 
    0.03018260f, -0.01121447f, -0.12955925f, 0.00005579f, 0.29413819f, -0.11573166f, 0.13116014f, 0.09471776f, 
    0.02818804f, 0.31156838f, 0.12446273f, -0.05420507f, -0.10030714f, -0.15859900f, 0.03106468f, 0.01688920f, 
    0.08973255f, 0.06402711f, 0.15684545f, -0.01295159f, -0.38814533f, 0.05038289f, 0.21565633f, -0.08135360f, 
    -0.03394641f, -0.02756090f, 0.02576875f, -0.13250700f, -0.07473263f, 0.06942340f, 0.04370306f, 0.11987522f, 
    -0.37177831f, -0.00575629f, 0.12486188f, 0.43727303f, 0.02632440f, 0.03917189f, 0.04055748f, -0.10349711f, 
    -0.01782931f, -0.11161332f, -0.01986707f, 0.01223223f, 0.29380840f, -0.17677161f, 0.20662792f, -0.22519971f, 
    0.09766131f, 0.01009620f, 0.02961207f, 0.10582440f, 0.08519201f, -0.00132146f, 0.16105472f, -0.07972508f, 
    -0.28436130f, -0.45089808f, 0.28304899f, -0.24536219f, -0.01415054f, 0.06602074f, -0.21452722f, 0.12839170f, 
    -0.01263678f, 0.05429333f, 0.06480259f, 0.12150528f, 0.40188673f, 0.25216943f, -0.09525716f, 0.09850275f, 
    0.04906227f, -0.03837848f, 0.13103074f, 0.05489369f, -0.14145359f, -0.01325511f, 0.01502994f, 0.03321302f, 
    -0.03246669f, 0.09569743f, -0.08752727f, -0.00735604f, 0.03519970f, 0.07224653f, 0.04250357f, -0.11592111f, 
    0.11500885f, 0.22339059f, 0.12609269f, 0.04337917f, -0.28423724f, -0.39648315f, -0.03546860f, -0.05649584f, 
    0.00124553f, 0.14141251f, -0.14773785f, -0.10039787f, 0.09382794f, 0.23231684f, 0.16276950f, -0.01149006f, 
    -0.07624876f, -0.38612255f, -0.37321442f, -0.11237576f, 0.12021227f, 0.12297912f, 0.01666087f, 0.08622850f, 
    -0.34395945f, 0.11433691f, -0.05298704f, -0.01761507f, -0.00503983f, -0.13514738f, 0.07087936f, -0.09800783f, 
    0.15145218f, 0.16449553f, 0.01144314f, -0.12928997f, 0.21200958f, -0.07592649f, 0.08918621f, -0.02314477f, 
    0.39883950f, -0.10995029f, 0.07976636f, -0.08980002f, -0.14135340f, -0.09401444f, -0.06958297f, 0.16267584f, 
    0.08282316f, 0.14302300f, 0.04333713f, 0.08820283f, 0.00554999f, -0.01973206f, -0.10729138f, 0.07462017f, 
    -0.08087388f, 0.23103729f, 0.00873654f, 0.06174188f, -0.03225311f, 0.12546360f, -0.03903276f, -0.16252126f, 
    -0.14552684f, 0.08584964f, -0.13574293f, -0.15809570f, -0.08709750f, -0.16895621f, -0.03248811f, -0.06143660f, 
    -0.08350325f, -0.02333557f, -0.00668271f, 0.00416485f, -0.03157422f, -0.09725953f, -0.04755161f, -0.07615275f, 
    0.10067268f, 0.13303947f, 0.26703733f, 0.05820945f, -0.01160690f, -0.06134431f, -0.04108802f, -0.05966518f, 
    -0.50312448f, 0.15724540f, -0.40737423f, -0.07461111f, 0.07556500f, 0.14609984f, 0.24033110f, 0.06384859f, 
    -0.23666389f, 0.01849070f, -0.05846299f, -0.10198750f, -0.12708749f, -0.01694618f, -0.04910942f, 0.11156639f, 
    0.07278071f, 0.06297857f, 0.14370184f, 0.17742604f, -0.28731796f, -0.10186511f, 0.01950497f, -0.15825072f, 
    0.16148557f, -0.29797840f, 0.07138823f, 0.07192754f, 0.14659481f, -0.03562767f, -0.12228546f, 0.08294440f, 
    0.00088839f, 0.08593232f, -0.09795372f, -0.09619632f, 0.37688565f, -0.18561393f, 0.51103711f, -0.26430744f, 
    0.04095452f, 0.22610250f, 0.10872564f, -0.27854198f, 0.03682291f, 0.05035480f, 0.10690973f, -0.08073628f, 
    0.01994969f, 0.11882994f, 0.05279435f, -0.00488214f, 0.28112593f, 0.20700468f, 0.14487135f, 0.10138534f, 
    0.03611735f, -0.02752422f, -0.16758488f, -0.06103652f, 0.21582162f, -0.26668701f, 0.18564492f, 0.06971377f, 
    -0.08901793f, -0.08860960f, -0.20891933f, -0.14578494f, -0.01574484f, 0.20509230f, -0.09342200f, -0.06903666f, 
    0.03501481f, 0.21172200f, 0.35512221f, -0.13761665f, -0.16918679f, 0.10172483f, -0.04404736f, -0.01903377f, 
    -0.13292935f, -0.06981404f, 0.04470557f, 0.08744204f, 0.02946926f, 0.18851966f, -0.07542464f, 0.13038087f, 
    0.13849929f, 0.04235630f, -0.04880023f, 0.01773948f, -0.06720875f, 0.10859127f, 0.11107200f, -0.00188220f, 
    0.24241117f, 0.35418892f, 0.31339327f, 0.10328674f, -0.12899564f, 0.04979340f, -0.03535260f, 0.10131720f, 
    0.13278167f, -0.02686549f, -0.00472266f, 0.12505311f, 0.25563276f, 0.10787259f, 0.18253750f, 0.06613681f, 
    0.00470115f, -0.04080648f, 0.10931565f, 0.10710496f, -0.10468965f, -0.00751312f, -0.05699122f, -0.05895461f, 
    0.24252357f, -0.10829154f, 0.01954659f, -0.08515491f, 0.19461130f, -0.01254665f, -0.12540400f, 0.09922807f, 
    0.02783137f, 0.05422381f, -0.03913013f, 0.01956678f, 0.37001872f, 0.39912540f, 0.49933639f, 0.19697478f, 
    -0.01930984f, -0.00553330f, 0.01052569f, 0.34384584f, 0.12326650f, -0.02336220f, -0.00470734f, -0.03582194f, 
    0.23921731f, -0.13078453f, -0.26167664f, 0.06927986f, -0.10201214f, -0.04423273f, -0.09003334f, 0.09945285f, 
    0.09314564f, 0.07885192f, -0.02295135f, 0.02085094f, -0.20089272f, -0.03612789f, -0.16942851f, 0.16533390f, 
    0.02783201f, -0.01963677f, 0.09776401f, -0.04623659f, 0.22304177f, 0.04615819f, 0.28625390f, 0.00105932f, 
    -0.16376752f, 0.07491488f, -0.08836084f, 0.21781862f, -0.03517733f, -0.07825428f, 0.00995673f, -0.04263928f, 
    -0.04155846f, -0.10425636f, -0.10635981f, 0.10772104f, 0.71865600f, 0.64212227f, 0.09301811f, 0.16128135f, 
    0.12423852f, -0.02543262f, 0.03602014f, 0.34693408f, 0.02568924f, -0.15476109f, -0.01150183f, 0.02226854f, 
    0.14105274f, 0.33176401f, -0.08712722f, -0.12954402f, 0.03199750f, -0.09853020f, -0.00001827f, -0.06484793f, 
    -0.17818671f, -0.06358864f, -0.04835631f, -0.07688104f, -0.57157201f, -0.25136614f, -0.03085294f, -0.12157922f, 
    0.03598079f, 0.11504771f, -0.00797746f, 0.04873632f, 0.03114322f, -0.02574226f, -0.05587070f, 0.00028359f, 
    0.08303282f, -0.22147098f, -0.08969511f, -0.08579474f, -0.11667521f, -0.00564527f, 0.05467666f, -0.13174897f, 
    0.13747998f, -0.05029785f, 0.01491445f, 0.00593885f, 0.23654456f, 0.09409655f, 0.37083107f, -0.00095002f, 
    -0.20042221f, 0.06271616f, -0.04906242f, -0.00248749f, -0.07830745f, 0.03994318f, -0.06678455f, 0.02860063f, 
    -0.24325411f, 0.15554589f, 0.07744894f, -0.00394365f, 0.13431281f, -0.02222318f, -0.03844007f, -0.06151416f, 
    -0.02803648f, -0.10666814f, -0.04443529f, 0.00187792f, -0.18227850f, -0.15577158f, 0.20030445f, 0.06479540f, 
    0.05182968f, -0.08228705f, 0.08085543f, 0.11733634f, -0.08039787f, 0.12433737f, 0.14885257f, 0.03788359f, 
    0.03156111f, 0.32549897f, 0.21197769f, 0.09239769f, -0.09080765f, -0.01278974f, 0.01574523f, 0.05375208f, 
    -0.21852884f, 0.03295034f, -0.22137570f, 0.11351971f, 0.00750242f, -0.03702229f, -0.24879597f, 0.08425545f, 
    0.01254208f, -0.02597568f, 0.22669300f, -0.03234600f, -0.10168372f, 0.24386904f, 0.06673583f, 0.13430671f, 
    -0.03291526f, -0.01438453f, -0.10088453f, -0.12645267f, 0.28706822f, 0.05495218f, 0.21444169f, 0.00115223f, 
    -0.19477640f, -0.29954141f, -0.39912894f, -0.13800448f, 0.25504345f, 0.01849796f, 0.09342390f, 0.21370029f, 
    0.09105016f, 0.05416630f, 0.07840460f, 0.01778960f, 0.13969971f, 0.18726097f, 0.20127138f, 0.20311522f, 
    0.21044928f, 0.04438133f, -0.11172312f, 0.07018101f, -0.01787996f, -0.00420726f, 0.19318321f, -0.08141186f, 
    0.20955904f, -0.03247880f, -0.00471665f, 0.09260835f, 0.07672106f, 0.38286006f, 0.18446524f, 0.10000420f, 
    0.19096655f, 0.22054739f, -0.03789629f, 0.07047994f, -0.08687373f, -0.03806719f, -0.12110193f, -0.18374626f, 
    0.12622757f, -0.14720041f, 0.06902411f, 0.12357200f, 0.03624908f, -0.04923761f, -0.42522788f, 0.01828193f, 
    -0.03187693f, -0.06448335f, 0.14478943f, -0.02910630f, 0.23047085f, -0.36974490f, -0.54516429f, 0.27276483f, 
    -0.18967327f, -0.15882485f, -0.05354723f, -0.12522608f, 0.19631590f, -0.16375020f, 0.08874656f, -0.17146923f, 
    0.06320355f, 0.27669683f, -0.00273008f, 0.32881525f, -0.01169378f, 0.05723415f, 0.09031408f, -0.14484444f, 
    0.10071466f, 0.10285451f, 0.06526493f, 0.07028782f, 0.30558932f, 0.16484287f, 0.10021970f, -0.06727671f, 
    0.11859807f, 0.11941197f, 0.13311630f, 0.01586407f, 0.15172556f, 0.08532415f, -0.10061402f, 0.03813859f, 
    0.21954353f, 0.15641110f, 0.14834882f, -0.07896347f, -0.00182446f, 0.04342210f, -0.21068877f, 0.16269603f, 
    0.23777063f, -0.10034417f, -0.06794985f, 0.02313741f, -0.07490546f, -0.23417592f, -0.20843640f, 0.19875371f, 
    -0.13355479f, -0.17107552f, 0.11832911f, -0.05467304f, 0.04702222f, 0.25086081f, 0.07565457f, 0.28657758f, 
    -0.06585606f, -0.32216397f, 0.09171420f, -0.03875680f, 0.03092147f, 0.08739548f, -0.24303888f, -0.13007373f, 
    0.26057899f, 0.11885931f, 0.19082168f, 0.08786011f, -0.13045964f, 0.19402449f, 0.27805829f, 0.03525950f, 
    0.13878953f, 0.27176929f, -0.04455855f, -0.07766536f, -0.06862339f, 0.02467432f, 0.04929858f, -0.02696183f, 
    0.14005466f, -0.01277251f, 0.03701384f, 0.13420834f, -0.09392008f, -0.23483500f, 0.02587903f, -0.02361582f, 
    0.00597135f, -0.02124900f, -0.14096779f, -0.24056582f, 0.14906526f, 0.19987267f, -0.16172317f, 0.27156526f, 
    -0.00242970f, 0.14844657f, 0.07760156f, -0.11211327f, 0.00191225f, 0.11652211f, -0.23160796f, -0.03994142f, 
    0.19233124f, 0.07842265f, 0.33319420f, -0.08710575f, 0.07059712f, -0.08371364f, 0.10526226f, 0.01374234f, 
    0.01847446f, 0.15588146f, 0.02546798f, 0.14361762f, -0.26728681f, -0.64841789f, 0.17193803f, 0.30815336f, 
    -0.18291822f, -0.00645906f, -0.12860903f, -0.09679876f, -0.22456737f, 0.04406187f, -0.19677052f, -0.16300039f, 
    0.05933193f, -0.11128075f, 0.21611872f, -0.06539403f, 0.07155727f, 0.06471228f, 0.27522099f, 0.21057332f, 
    -0.01888872f, -0.05135251f, 0.27565289f, 0.18021478f, 0.11349640f, 0.05992263f, -0.20935583f, 0.03133952f, 
    0.11312434f, -0.02071426f, 0.11971494f, 0.14831969f, -0.31618381f, -0.06474407f, -0.24241526f, -0.05014664f, 
    0.43910789f, 0.02452991f, -0.14838025f, -0.10570346f, -0.00178720f, 0.06186261f, -0.03033781f, 0.12292840f, 
    -0.05912046f, 0.01822501f, -0.09726391f, -0.18996409f, 0.12171491f, 0.07070080f, 0.20273799f, 0.19417728f, 
    -0.06578011f, -0.00669520f, -0.02818852f, 0.06925605f, -0.06817112f, 0.26973361f, -0.02175318f, 0.13688259f, 
    -0.42876783f, -0.12617655f, -0.19171122f, -0.19745781f, -0.21063182f, 0.00925026f, -0.09000406f, -0.17875931f, 
    -0.16689131f, -0.18512830f, -0.02614962f, 0.05966153f, -0.09380069f, 0.03559427f, -0.05092148f, 0.04504317f, 
    -0.28690436f, -0.22204420f, -0.01098034f, 0.07912781f, -0.11762474f, -0.00518720f, 0.10821897f, -0.06201952f, 
    0.08438613f, -0.21769693f, 0.19167463f, -0.05957406f, -0.08340558f, -0.00896542f, 0.10170984f, 0.19183771f, 
    -0.07974736f, -0.08070790f, -0.19008154f, -0.32659999f, -0.15770489f, 0.50184178f, 0.25253183f, 0.11928736f, 
    0.17272885f, 0.09996390f, -0.01190641f, 0.18017954f, -0.23979467f, 0.00725962f, -0.04280017f, 0.10144660f, 
    0.21873878f, 0.10142557f, -0.01428214f, -0.12821534f, 0.20320679f, -0.13582361f, -0.12190501f, 0.10097121f, 
    -0.17036599f, 0.15282144f, -0.05236898f, -0.08181761f, -0.05944421f, -0.06350292f, 0.04479777f, -0.24184169f, 
    -0.02888787f, -0.19994135f, -0.20643567f, -0.17261916f, -0.06324701f, -0.20080125f, -0.20118271f, -0.16117650f, 
    -0.29864958f, 0.04472255f, 0.18730123f, 0.08176208f, -0.10461499f, -0.06259061f, 0.18796107f, -0.08560567f, 
    0.14551431f, -0.03230669f, 0.05713074f, 0.04657547f, 0.01739828f, 0.45769653f, 0.12938581f, 0.22713731f, 
    0.09344065f, 0.14249241f, 0.04424824f, 0.19543682f, 0.06383780f, 0.08550788f, -0.20403287f, -0.09234817f, 
    -0.06728987f, -0.00023425f, 0.36298805f, -0.05975366f, -0.29846248f, -0.25523791f, -0.00689226f, 0.00735545f, 
    0.28472671f, 0.31662220f, 0.15998633f, 0.04987976f, 0.26981783f, -0.24743527f, 0.36887822f, 0.15888885f, 
    0.07711159f, 0.12638266f, 0.27059919f, 0.18134664f, 0.10203094f, 0.05180991f, -0.12255928f, 0.09291390f, 
    0.10412954f, 0.08836982f, 0.10890982f, 0.26027885f, 0.11039962f, 0.08048262f, 0.01398122f, 0.02081753f, 
    -0.04692665f, -0.19851148f, -0.02139460f, 0.09696925f, -0.53181046f, 0.08058106f, -0.09467791f, -0.29057035f, 
    -0.05742938f, 0.10347335f, 0.06687430f, -0.23097308f, 0.03482165f, 0.20563072f, 0.12696412f, 0.02839066f, 
    0.10043279f, 0.22064044f, 0.31474274f, 0.15431306f, 0.07619953f, -0.06856213f, 0.06405651f, 0.00199070f, 
    -0.15970418f, -0.14890037f, 0.01841735f, 0.00021888f, 0.04266990f, 0.06025941f, 0.21109898f, 0.23891172f, 
    -0.01694188f, 0.02427586f, -0.02816574f, -0.02836013f, 0.22030482f, -0.05569443f, 0.02896426f, 0.20556404f, 
    0.09107358f, 0.38185754f, 0.31767851f, 0.24019705f, -0.01775254f, -0.04471919f, 0.11967583f, 0.17955622f, 
    0.11232369f, -0.15832753f, -0.19469650f, 0.09315174f, -0.08428922f, 0.23973191f, 0.28604919f, 0.26197228f, 
    -0.08704409f, -0.06251750f, -0.05916876f, 0.13318510f, 0.14757074f, -0.09553468f, -0.15141478f, -0.04028701f, 
    -0.17276552f, -0.23816948f, 0.03626869f, -0.22131984f, -0.11132378f, -0.03278667f, -0.03258979f, 0.01831740f, 
    0.08159022f, 0.00015554f, 0.20836700f, -0.17387368f, 0.34141085f, -0.16524823f, -0.24252570f, -0.22281866f, 
    -0.00276120f, -0.04724909f, 0.15265356f, 0.15527226f, 0.07239787f, -0.04220924f, -0.24582678f, -0.10833289f, 
    0.33237639f, 0.03064506f, 0.08144796f, 0.02967899f, 0.10347343f, -0.13918607f, 0.07143921f, -0.09420860f, 
    -0.17971598f, -0.09558436f, 0.14971301f, 0.24280848f, -0.03827161f, 0.15242466f, 0.41174796f, 0.31992477f, 
    -0.03456214f, -0.02101500f, -0.00868249f, 0.03320357f, 0.13990441f, 0.00318864f, 0.07393179f, -0.00934877f, 
    0.30808201f, 0.40039611f, 0.29729065f, 0.22269556f, 0.08416107f, -0.06004970f, -0.01193398f, -0.04668759f, 
    -0.03038482f, 0.04343985f, 0.05808667f, 0.22221155f, -0.03324273f, -0.15173389f, -0.03091946f, -0.06341384f, 
    0.03961595f, -0.19293806f, -0.08337307f, -0.00146218f, 0.01396556f, 0.03644303f, -0.07909483f, 0.26756227f, 
    -0.15027151f, -0.02526250f, 0.11346706f, -0.41268057f, -0.01511098f, 0.02365036f, -0.32037893f, 0.03100128f, 
    0.11986919f, -0.00078484f, -0.03896616f, 0.00332131f, -0.46688467f, 0.10298471f, 0.14106227f, 0.19641528f, 
    -0.08356908f, -0.03396269f, -0.02732627f, -0.08209118f, -0.08942743f, 0.09556223f, 0.05255619f, -0.08302274f, 
    -0.03276550f, -0.15943556f, -0.26258081f, -0.10475377f, 0.04368654f, 0.07366822f, 0.09855202f, 0.02955717f, 
    -0.12263779f, -0.05677774f, -0.12927744f, -0.06648035f, 0.38086781f, 0.04330166f, 0.10903343f, -0.17223831f, 
    -0.17573765f, 0.10043292f, 0.00052061f, -0.07213713f, -0.13826102f, -0.00795227f, -0.05772369f, -0.22742061f, 
    -0.02770379f, -0.25244039f, 0.25524971f, 0.13928467f, 0.02835203f, 0.14027283f, -0.07905094f, 0.06850003f, 
    0.21680854f, -0.09504718f, 0.09512403f, 0.05370325f, -0.45169872f, -0.37369528f, 0.08194751f, 0.06891134f, 
    0.15428460f, 0.13307060f, -0.04980295f, -0.10333426f, -0.09136394f, -0.07724114f, 0.00335284f, 0.01770735f, 
    -0.09608814f, -0.10955649f, -0.26340199f, 0.11085109f, -0.00496393f, -0.06186515f, -0.13211012f, -0.03520276f, 
    0.25797299f, 0.09201840f, -0.14713310f, -0.21698269f, -0.02648371f, -0.16917680f, 0.06798878f, 0.03804585f, 
    0.01640778f, 0.04852702f, -0.01902101f, -0.01586088f, -0.21403943f, -0.07933620f, 0.09356628f, -0.14976764f, 
    -0.40152752f, -0.41163036f, 0.01680475f, -0.05520377f, 0.01840504f, 0.07549777f, 0.15892817f, 0.05642960f, 
    0.02678964f, -0.04623430f, 0.14425983f, 0.00445186f, 0.08670496f, 0.05873847f, 0.20183396f, 0.22164921f, 
    0.04428241f, 0.24075429f, 0.07409298f, -0.05628631f, -0.07255576f, 0.01912852f, -0.05284785f, -0.01157545f, 
    0.37044457f, 0.26917803f, 0.15252553f, 0.22121921f, 0.23677672f, 0.05527325f, -0.13548481f, 0.18353871f, 
    0.04271066f, -0.12249303f, -0.04961613f, -0.26170057f, -0.40932840f, -0.24492346f, -0.12111889f, 0.17359759f, 
    0.12451442f, 0.00141154f, 0.01875660f, -0.22634046f, 0.06964152f, 0.07314090f, 0.33920643f, 0.07588913f, 
    -0.34046817f, 0.28678274f, -0.24127221f, 0.17540833f, 0.13598877f, 0.19433729f, 0.03471670f, 0.05341465f, 
    0.00855481f, 0.09556560f, -0.04883568f, -0.10020860f, 0.29439524f, -0.18583445f, -0.01179316f, 0.10164125f, 
    0.02115920f, 0.00206927f, 0.12433914f, 0.00573889f, 0.08905372f, -0.12537235f, -0.07481984f, 0.01272395f, 
    -0.41488618f, -0.21727803f, -0.14806138f, 0.12477685f, -0.00880457f, -0.05522737f, 0.03829921f, 0.11539143f, 
    0.18098393f, -0.01193357f, -0.02279503f, -0.10267882f, -0.01557901f, -0.10374906f, -0.42252991f, -0.30865693f, 
    -0.09818161f, -0.00686700f, 0.14152862f, -0.04944622f, -0.08437619f, 0.16112521f, 0.10548237f, -0.03802661f, 
    0.33422142f, -0.16327614f, -0.13944934f, 0.06069223f, 0.08143163f, 0.07788826f, -0.05903792f, 0.08587089f, 
    0.09088774f, 0.00998660f, 0.15303190f, 0.00696054f, 0.60304832f, -0.21615022f, 0.15396401f, 0.07320559f, 
    0.16361839f, 0.02737704f, 0.07026933f, 0.08961044f, 0.10525889f, -0.10715920f, 0.19570696f, 0.07948006f, 
    -0.22494204f, -0.23321356f, -0.26624086f, -0.07532424f, 0.02993985f, -0.10106186f, -0.33691484f, -0.10458416f, 
    0.09984756f, 0.12397101f, 0.09177328f, 0.19181049f, -0.14989333f, 0.31546429f, -0.24974360f, 0.22071356f, 
    0.08898858f, -0.01541769f, -0.14147058f, 0.01876375f, 0.02683905f, -0.05866905f, 0.08023591f, 0.15510407f, 
    0.13476805f, 0.44608471f, 0.15709740f, 0.05516489f, -0.04060362f, -0.27813083f, 0.18737637f, 0.09400512f, 
    -0.14971142f, -0.01290133f, 0.01452154f, 0.02952002f, 0.18566003f, -0.04905074f, 0.04648536f, 0.14549837f, 
    -0.03275458f, -0.06213901f, -0.08751594f, 0.12361837f, 0.02925710f, 0.04111644f, -0.04499907f, -0.04548521f, 
    -0.16165876f, -0.11048459f, 0.05431075f, 0.12486973f, -0.08508070f, -0.08927078f, -0.05719828f, -0.15726425f, 
    -0.09722631f, -0.16509995f, 0.17960301f, 0.08740987f, -0.15568376f, -0.17039566f, -0.18972108f, 0.02019155f, 
    0.03555510f, 0.03863138f, 0.09213125f, 0.23752804f, -0.14625014f, 0.03020779f, -0.15420119f, 0.11906476f, 
    -0.37926975f, 0.05261564f, 0.13438454f, 0.30482897f, 0.03632450f, 0.00564372f, 0.10911229f, 0.14360996f, 
    0.08109527f, 0.25168639f, -0.04741747f, 0.06838349f, -0.01796238f, -0.44536415f, 0.24964151f, 0.01092747f, 
    -0.09186975f, 0.11276221f, 0.05107066f, -0.01640085f, -0.01963940f, -0.00728504f, 0.08621041f, 0.14372852f, 
    -0.07376608f, 0.10747030f, 0.57781404f, 0.02686740f, -0.14286309f, 0.05742304f, 0.04010452f, -0.11743379f, 
    -0.13573627f, 0.02826305f, -0.09206417f, 0.02171775f, -0.22591220f, 0.12014674f, -0.08468470f, 0.05052328f, 
    -0.20499079f, 0.06743339f, -0.05561289f, -0.12300909f, -0.27104172f, 0.07370535f, 0.22289093f, 0.09084518f, 
    0.39743677f, -0.09992346f, 0.27940556f, -0.03808438f, 0.12339127f, 0.01052292f, 0.09175999f, 0.07564766f, 
    0.07102672f, 0.10613584f, -0.23389003f, -0.10016488f, -0.40050164f, -0.04845538f, -0.26480845f, -0.01115070f, 
    0.00995346f, 0.00991327f, -0.03973397f, 0.00561269f, -0.19355652f, 0.03457888f, -0.03191568f, 0.03940276f, 
    -0.11567629f, -0.13684961f, -0.04040500f, 0.09160247f, 0.03755010f, -0.13927011f, 0.25976458f, 0.16935059f, 
    -0.07825946f, 0.16883342f, -0.02561365f, 0.04275825f, -0.02129149f, -0.05998572f, -0.16036887f, -0.39174694f, 
    -0.06802975f, -0.01369317f, -0.07222676f, -0.07143804f, 0.01236205f, -0.01104240f, -0.12142462f, -0.12180411f, 
    0.42613783f, -0.03284023f, 0.10795914f, 0.07964029f, -0.04796368f, 0.11342038f, 0.20448533f, 0.21148507f, 
    -0.22512768f, 0.11935774f, 0.02444147f, -0.01787262f, 0.62746412f, -0.17402646f, -0.11426880f, -0.16900359f, 
    -0.09615719f, 0.08092481f, 0.00715719f, 0.27947268f, 0.04608052f, 0.01005098f, -0.00359223f, 0.07032071f, 
    -0.06059602f, 0.19689241f, 0.07216850f, -0.25056058f, -0.06338938f, -0.03380782f, 0.03768911f, -0.12476295f, 
    0.04621299f, 0.04105603f, 0.04661032f, 0.38158402f, 0.06297263f, -0.22970784f, 0.52126867f, 0.06506655f, 
    0.11833099f, -0.05809316f, 0.10159834f, 0.23949338f, 0.11305064f, -0.12352866f, 0.09208767f, -0.01498209f, 
    -0.21482308f, 0.36657649f, -0.05512084f, 0.29843175f, -0.00988847f, 0.11886130f, -0.06504872f, 0.08454696f, 
    -0.06157759f, 0.13131846f, 0.18890376f, 0.00728617f, -0.02759127f, 0.39849630f, -0.25883701f, 0.05901103f, 
    -0.10646227f, 0.03219314f, 0.07639097f, -0.02366585f, -0.10504754f, -0.03703811f, -0.07852003f, 0.08990849f, 
    -0.27116776f, 0.00236600f, -0.19326730f, -0.13514538f, 0.21552564f, -0.01225331f, -0.17161402f, 0.23792775f, 
    0.15526703f, 0.20138225f, -0.17095074f, 0.00902643f, 0.08311932f, 0.42777902f, -0.14643191f, -0.36320347f, 
    -0.07968992f, 0.03948110f, -0.08675227f, 0.06901867f, -0.04539477f, 0.03417350f, -0.07717767f, -0.16814691f, 
    0.23043834f, 0.60294360f, -0.02737129f, 0.19407287f, -0.10173377f, 0.17988817f, -0.08367503f, -0.03901586f, 
    -0.07404420f, 0.09729413f, 0.14444768f, 0.03493477f, 0.03650558f, 0.13900138f, -0.46364236f, -0.17385994f, 
    -0.01539055f, -0.33096147f, -0.16361460f, -0.33882472f, -0.06881651f, 0.06662618f, -0.04303780f, 0.08031908f, 
    -0.52169669f, -0.26359519f, -0.33329713f, -0.18319823f, 0.06632689f, 0.20975181f, 0.15782005f, -0.12983485f, 
    -0.11698449f, 0.07094815f, -0.09535697f, 0.10633948f, 0.01803800f, -0.07772867f, 0.07145556f, -0.22743295f, 
    0.13148865f, -0.09811953f, 0.01639653f, 0.02387179f, -0.07521655f, 0.22429833f, -0.06052865f, 0.29033265f, 
    -0.13149419f, -0.22313727f, 0.11778560f, -0.21983288f, 0.05115932f, 0.19010727f, 0.00495363f, 0.23196575f, 
    -0.07756964f, 0.19000298f, 0.01896397f, -0.05615894f, -0.40360636f, -0.50206161f, 0.02974055f, -0.24499986f, 
    -0.14740482f, -0.09228778f, -0.01361245f, -0.20418711f, -0.03280404f, 0.04932322f, 0.09435207f, -0.06031387f, 
    -0.29253531f, -0.05948871f, 0.35745388f, 0.34945723f, 0.06301966f, 0.24849799f, 0.00437134f, 0.07710218f, 
    0.09192296f, -0.17634961f, 0.10693775f, 0.12478162f, 0.05556988f, -0.01639805f, -0.09104925f, 0.01818185f, 
    0.00930733f, -0.05595041f, 0.06106314f, 0.04230818f, 0.18011534f, 0.15433314f, 0.24455851f, -0.10483547f, 
    -0.44243109f, 0.06496847f, -0.15068655f, -0.01485015f, 0.28934270f, 0.00067217f, -0.10902926f, 0.10161759f, 
    0.08351666f, 0.19943364f, 0.04424043f, 0.03843151f, -0.08659008f, 0.19363707f, -0.16668965f, 0.26735020f, 
    0.27167585f, -0.05908443f, 0.08820958f, 0.22845082f, 0.07268783f, -0.00782831f, 0.05462306f, 0.05294617f, 
    -0.15427199f, -0.30992642f, -0.06925669f, 0.19878578f, -0.13672696f, -0.13097128f, -0.01063163f, 0.21563163f, 
    0.16221468f, 0.01826814f, 0.34319949f, 0.08182136f, 0.17250681f, 0.28466752f, -0.12813087f, -0.01042474f, 
    0.00050567f, 0.00625831f, 0.12504059f, -0.04487650f, 0.08104172f, -0.04930624f, 0.14662439f, 0.04344724f, 
    0.46932295f, -0.24973090f, -0.14051975f, -0.03003742f, 0.10757831f, -0.12323060f, 0.30405134f, -0.12327998f, 
    0.24088562f, -0.05082481f, -0.10030449f, -0.05355566f, 0.02125152f, -0.07795125f, 0.03699660f, -0.06379675f, 
    0.07955290f, -0.05959250f, 0.03815854f, 0.16540170f, 0.22715579f, 0.02597763f, -0.06476072f, 0.03608869f, 
    -0.24932943f, -0.27721253f, -0.35634291f, -0.06315199f, 0.24382761f, -0.02860508f, 0.04935113f, 0.03640962f, 
    0.04007223f, 0.10016845f, -0.19207053f, -0.06533180f, 0.27726731f, -0.00100632f, 0.01332134f, -0.08100986f, 
    0.09794426f, 0.08026810f, -0.01621544f, 0.08665649f, 0.01576630f, -0.00949255f, 0.14548224f, 0.01378700f, 
    0.13382468f, -0.03822005f, -0.15111631f, -0.01200784f, -0.04600434f, 0.21281950f, 0.00248839f, -0.03765978f, 
    0.18965504f, 0.05929266f, 0.20216237f, 0.16654366f, -0.14178553f, -0.06318858f, -0.11656600f, 0.04699831f, 
    0.21489944f, 0.21987830f, 0.11562444f, -0.00596323f, -0.14068803f, 0.12942415f, -0.05245422f, 0.03956240f, 
    0.40732512f, 0.13104625f, 0.34556019f, 0.07042146f, 0.05135874f, -0.04122442f, -0.09035214f, 0.00219306f, 
    -0.01488991f, -0.14507203f, 0.05459638f, -0.09632250f, -0.00449867f, -0.11066765f, -0.08026539f, 0.10061981f, 
    -0.05146465f, -0.02778159f, -0.13347988f, 0.01191592f, 0.15436947f, 0.14714827f, 0.29662174f, 0.23930278f, 
    -0.09484867f, 0.02986318f, 0.02896653f, 0.12969075f, 0.12651278f, 0.09877633f, 0.02319643f, 0.13894415f, 
    0.14175744f, 0.22015674f, 0.07007822f, -0.24860933f, 0.00728201f, -0.08940764f, 0.04913312f, -0.17401445f, 
    0.15718418f, -0.03752413f, 0.12462278f, -0.01337471f, 0.17658989f, -0.04356174f, -0.03817317f, -0.11848226f, 
    -0.58068860f, -0.09557396f, 0.00753208f, 0.11484560f, 0.03028630f, 0.08742723f, 0.08897246f, 0.20753774f, 
    0.28898916f, -0.05531333f, 0.14228328f, 0.05810655f, -0.02080670f, -0.20873071f, -0.37269711f, -0.20675465f, 
    -0.17741303f, -0.08126317f, 0.05192750f, -0.01777055f, 0.11316454f, -0.02224734f, 0.13417941f, 0.01521717f, 
    0.07028567f, -0.14467342f, -0.03866325f, 0.06349986f, 0.17499769f, 0.13143198f, -0.02869943f, 0.12792197f, 
    0.01377032f, 0.15730204f, 0.33630508f, 0.23170857f, 0.20026247f, 0.10755338f, 0.27843741f, 0.01852216f, 
    0.33232212f, 0.19690575f, 0.23796421f, 0.09027171f, 0.07101833f, -0.05348838f, -0.07455263f, -0.05439338f, 
    -0.12461818f, -0.17474325f, 0.03981113f, 0.44111186f, -0.06496286f, -0.07645587f, -0.09870191f, 0.01033142f, 
    0.32224324f, 0.33470058f, 0.03020343f, 0.24360807f, 0.48797905f, 0.11024859f, -0.10081124f, 0.15043664f, 
    0.29166889f, 0.09031383f, 0.03508455f, 0.24627337f, 0.09317921f, 0.06489006f, 0.06036372f, 0.35378042f, 
    0.28003460f, 0.01597462f, 0.19556265f, -0.06807441f, -0.13990913f, -0.09864470f, 0.08026937f, 0.03174900f, 
    -0.03976113f, -0.11172897f, 0.09604811f, 0.07142973f, 0.10194950f, -0.05252063f, 0.03085257f, 0.05779368f, 
    0.10349556f, -0.03908154f, -0.04999875f, 0.15783171f, 0.12419115f, 0.06725632f, -0.03259690f, 0.09239987f, 
    0.12316129f, 0.00950048f, -0.00714153f, -0.20334481f, 0.00358255f, -0.03384873f, 0.12874590f, 0.05648513f, 
    -0.27272815f, -0.53485709f, -0.44420195f, -0.47109365f, 0.00386331f, 0.19866338f, -0.06175092f, 0.09641685f, 
    -0.24719286f, -0.15256041f, 0.02926864f, -0.03069984f, 0.23780735f, 0.28328890f, 0.26992857f, 0.01628616f, 
    -0.26117355f, 0.34624654f, 0.27297351f, 0.42376593f, -0.01033612f, -0.02636907f, 0.18251127f, -0.01856485f, 
    -0.03908320f, 0.00934769f, 0.10251073f, 0.20076798f, -0.01787946f, 0.06324253f, -0.19751601f, -0.21495785f, 
    0.11367746f, 0.10985401f, -0.04392649f, 0.06001124f, -0.10862532f, -0.30656400f, -0.09789959f, -0.35418132f, 
    -0.26789543f, 0.00611452f, 0.12540054f, 0.06284851f, 0.07946824f, 0.02127334f, 0.12320886f, -0.02966630f, 
    -0.13682635f, -0.07430935f, -0.07872079f, -0.09404530f, -0.02629189f, 0.06648409f, 0.09649677f, -0.10749950f, 
    0.16855539f, -0.34419328f, 0.00233821f, -0.15036406f, -0.15117998f, -0.18271080f, -0.17269266f, -0.06409408f, 
    0.26365563f, 0.17433003f, 0.08538388f, 0.23705418f, -0.00426204f, -0.18492787f, 0.00794926f, -0.20707719f, 
    0.12113909f, 0.31350064f, 0.28791761f, 0.49304032f, 0.23362643f, -0.20372480f, -0.17610224f, -0.09158133f, 
    -0.20633979f, 0.00127284f, 0.00173738f, 0.00019699f, 0.01197989f, -0.03352860f, -0.14112864f, 0.00531406f, 
    0.61131793f, 0.00193218f, 0.42959297f, 0.35007435f, -0.16392837f, -0.00473451f, -0.12712428f, -0.05371423f, 
    0.20472439f, 0.00783634f, -0.00045739f, 0.30721006f, 0.24616444f, 0.19271630f, -0.00648024f, 0.03140258f, 
    0.03750520f, 0.17960086f, -0.07571091f, -0.11022266f, 0.10487767f, 0.29100960f, 0.28791460f, 0.20566556f, 
    0.04845629f, 0.07224514f, -0.02842516f, -0.09448756f, -0.18340002f, -0.02881822f, -0.00945283f, -0.14731218f, 
    0.14207344f, 0.13117583f, 0.05487711f, -0.08165509f, 0.14292441f, -0.05788884f, -0.09266671f, 0.16671483f, 
    -0.03723714f, 0.02770847f, 0.05610034f, 0.10555152f, -0.04495071f, -0.05826282f, 0.20913249f, 0.05513866f, 
    0.19302689f, 0.24233395f, 0.07756692f, 0.02484182f, -0.00865859f, 0.01316527f, -0.03723174f, -0.05674346f, 
    -0.25480124f, -0.21794441f, 0.09422371f, -0.10069781f, -0.45073801f, 0.52835184f, -0.07246941f, 0.07461526f, 
    0.08034788f, 0.02887258f, 0.19575670f, -0.10254585f, -0.18433237f, -0.08487366f, -0.03588822f, -0.29971978f, 
    0.07364047f, 0.22410387f, -0.25323236f, 0.15919772f, 0.17611419f, 0.01587097f, 0.20045543f, 0.13353309f, 
    0.13202244f, 0.42600831f, 0.13303865f, -0.03663237f, 0.03287223f, -0.39979985f, -0.00127013f, -0.02463296f, 
    -0.09399685f, -0.01274395f, -0.22521518f, -0.15167616f, -0.22565092f, -0.16226369f, -0.21978360f, -0.21550894f, 
    -0.15006804f, -0.17143983f, 0.03200801f, -0.03574161f, 0.05506243f, 0.03722803f, -0.01319217f, -0.07098981f, 
    -0.11235314f, -0.00670395f, -0.01363202f, -0.13939042f, 0.22925460f, 0.09204278f, -0.05331003f, 0.09272897f, 
    -0.04480248f, -0.03562692f, 0.12915705f, 0.06393942f, 0.08775157f, 0.05960966f, 0.05342034f, 0.03749985f, 
    0.10809069f, -0.30818930f, -0.17107202f, -0.41741073f, -0.03237183f, -0.04139542f, -0.02822316f, 0.01642596f, 
    0.17807525f, -0.05480098f, 0.04424366f, -0.09893424f, -0.14981966f, -0.13842705f, -0.08159974f, 0.08418374f, 
    0.08668739f, 0.08064330f, 0.26011157f, 0.03378067f, -0.11391670f, 0.12961455f, -0.03850064f, 0.11520068f, 
    0.31224245f, 0.44016606f, -0.05725161f, 0.15013202f, 0.02520186f, 0.07481073f, 0.00058967f, -0.04884259f, 
    0.00644853f, -0.04658900f, 0.06720077f, 0.06279006f, 0.11874472f, 0.21558468f, 0.17115137f, 0.06648969f, 
    -0.04514938f, -0.11665373f, -0.07706084f, -0.04456443f, 0.07915904f, -0.10972850f, 0.12921131f, 0.04803198f, 
    0.07287838f, -0.04153100f, 0.11374918f, 0.00181454f, -0.18810417f, 0.25107500f, 0.04537440f, 0.24557109f, 
    0.11529930f, -0.01837852f, 0.02157343f, 0.01013900f, -0.11733690f, 0.25930580f, 0.13554986f, -0.12718570f, 
    0.09843601f, 0.04116131f, -0.07895635f, -0.11702359f, 0.02327489f, 0.02947677f, 0.05494646f, -0.08824458f, 
    -0.02105962f, -0.10716475f, -0.23625422f, -0.26637447f, -0.10199588f, -0.05926826f, -0.18213670f, 0.11057734f, 
    0.15138201f, 0.20416646f, 0.12365324f, 0.02935902f, 0.22115502f, 0.19138396f, 0.21547358f, 0.07580690f, 
    -0.11829282f, -0.07356530f, -0.22088075f, -0.21844758f, 0.12853192f, -0.06816850f, -0.03287273f, -0.06864882f, 
    -0.00854546f, 0.44781217f, 0.03802790f, 0.25668749f, -0.11403552f, -0.03927356f, 0.37103289f, -0.09319648f, 
    -0.05240313f, -0.00146526f, 0.16740736f, 0.12499376f, -0.12543300f, 0.23381339f, -0.02140176f, 0.19122273f, 
    0.28811541f, 0.06362201f, 0.22143751f, 0.04295934f, -0.07117952f, 0.01755193f, -0.22197965f, 0.04914112f, 
    0.14376926f, 0.12195510f, 0.32693800f, 0.21223198f, -0.15633368f, -0.06922996f, -0.06969357f, -0.12560472f, 
    0.13572678f, 0.07905282f, 0.07800463f, 0.04017264f, 0.03798031f, 0.03212088f, 0.03466392f, 0.00777735f, 
    0.17759356f, 0.20736589f, 0.20351082f, 0.24274695f, 0.10703889f, 0.00028706f, 0.10428179f, 0.10250819f, 
    0.00984661f, -0.42230454f, 0.06339844f, -0.09354227f, -0.03181087f, -0.04799347f, 0.14233997f, 0.06811972f, 
    -0.03432348f, -0.00868237f, 0.11478543f, 0.09371607f, 0.20809916f, 0.10839907f, 0.08036923f, -0.16708297f, 
    -0.07085358f, -0.04260738f, -0.00125296f, -0.04176053f, 0.12717319f, 0.00793865f, 0.17558447f, -0.01833523f, 
    0.06306817f, -0.07521627f, 0.06268761f, 0.07103354f, -0.17340676f, 0.01605143f, -0.13035882f, 0.02262617f, 
    -0.15337738f, -0.09626881f, 0.05983574f, 0.05724663f, -0.25315106f, -0.11101125f, 0.32524168f, 0.28694439f, 
    -0.00573607f, -0.09062531f, 0.19409177f, 0.00000569f, 0.03934783f, -0.12401379f, 0.04077185f, -0.01174956f, 
    -0.29843920f, -0.01290300f, 0.60644245f, -0.26572356f, -0.05841919f, -0.19535929f, 0.01551930f, 0.10858546f, 
    -0.00695630f, -0.02629179f, -0.07166483f, -0.15670899f, -0.09834857f, 0.08927178f, 0.16538362f, 0.45068058f, 
    -0.06201183f, 0.07312036f, 0.20218579f, 0.17171842f, 0.02029327f, 0.08250589f, -0.05103698f, -0.01594160f, 
    0.45621163f, 0.16313002f, -0.09811795f, 0.21302353f, -0.07597820f, -0.01925493f, -0.12436491f, -0.05866787f, 
    0.08161265f, -0.15604958f, 0.21190993f, -0.11256383f, -0.02674004f, 0.06486269f, 0.12656899f, -0.12291370f, 
    -0.02314175f, -0.16912360f, -0.07500865f, 0.04798920f, 0.06691656f, -0.15219696f, 0.13611351f, 0.15072913f, 
    0.13867174f, 0.16134439f, -0.04560000f, 0.04625203f, 0.02390627f, -0.01732479f, 0.20919111f, 0.06238656f, 
    0.13652058f, -0.12723668f, -0.09487230f, -0.00642426f, -0.25089327f, -0.02522250f, 0.28429842f, 0.43076530f, 
    0.02031732f, 0.03823328f, -0.06232643f, -0.09487448f, -0.00547907f, 0.01293394f, 0.03719503f, -0.00816091f, 
    0.21405235f, 0.19286001f, 0.02114124f, 0.13720264f, -0.13982639f, -0.23877443f, -0.03754261f, 0.02767401f, 
    -0.01140118f, 0.15927714f, -0.03720230f, 0.08517064f, 0.01382917f, 0.00485134f, 0.06112348f, 0.02530133f, 
    -0.09002837f, 0.00167516f, -0.21089259f, -0.16747776f, 0.21099374f, -0.03690445f, -0.19900328f, -0.01991360f, 
    0.18727836f, 0.49573261f, -0.25399363f, 0.07658596f, -0.20374283f, 0.01011342f, 0.17995751f, -0.12692620f, 
    0.15677850f, -0.03135836f, 0.11078460f, 0.13955489f, -0.28994092f, -0.01894815f, -0.12692806f, 0.17430022f, 
    -0.00982009f, -0.08094285f, 0.10305424f, 0.04346974f, -0.03980879f, 0.05256065f, -0.02241828f, 0.03768208f, 
    0.02473526f, 0.07155224f, 0.11755890f, 0.20333564f, -0.02035399f, 0.04725173f, -0.10382189f, -0.11154266f, 
    -0.01944972f, 0.09942146f, -0.04990517f, 0.06192753f, -0.15038216f, 0.13884613f, -0.08115114f, -0.13938047f, 
    0.12906452f, 0.15936510f, -0.04784537f, 0.13655791f, -0.01874043f, 0.04337582f, 0.03664669f, 0.09781773f, 
    -0.50929159f, -0.05366309f, 0.15158573f, -0.00408781f, -0.03679769f, -0.02670791f, -0.17810103f, 0.20931935f, 
    0.01812305f, 0.05991490f, 0.11272409f, 0.02059284f, 0.04760322f, 0.18985324f, 0.07770959f, -0.14110292f, 
    -0.13325731f, -0.05789104f, 0.05947683f, -0.17206116f, -0.08696533f, -0.03239620f, 0.23508264f, -0.03965739f, 
    -0.13115732f, 0.03420408f, -0.15284918f, 0.17993142f, -0.14796254f, -0.10193680f, -0.24800278f, -0.13037698f, 
    -0.03615168f, 0.11653266f, -0.15901025f, -0.29424700f, -0.22945833f, 0.06084120f, 0.34536245f, 0.08025353f, 
    -0.11041471f, -0.08277000f, 0.04251402f, 0.06936859f, 0.20066354f, 0.07866503f, 0.16239895f, -0.00447904f, 
    -0.29893470f, 0.24423464f, 0.46160805f, -0.06942006f, -0.12018719f, -0.23617491f, 0.00158270f, 0.30011413f, 
    -0.06964286f, 0.08381882f, 0.14188163f, -0.04413885f, 0.01272456f, 0.17736261f, -0.03217523f, 0.29734257f, 
    0.12096542f, -0.03851051f, -0.00190966f, 0.13250321f, -0.17193724f, -0.28061059f, -0.04663987f, -0.08747823f, 
    -0.00581479f, 0.10566839f, -0.18950363f, 0.01071398f, 0.01521807f, 0.08454676f, 0.18994407f, 0.07062823f, 
    -0.04081990f, 0.13731317f, -0.01153379f, -0.12100124f, -0.21332854f, 0.11334147f, 0.13543360f, -0.35300776f, 
    0.17423323f, -0.14514567f, -0.06943987f, -0.12579514f, 0.08535843f, -0.01110518f, -0.02613543f, 0.02526115f, 
    -0.11085583f, 0.18805920f, -0.20063196f, 0.05463758f, -0.07170676f, -0.05265057f, 0.14184085f, -0.11593076f, 
    0.07640434f, 0.11327825f, 0.22931819f, 0.16608873f, 0.16708976f, -0.21619324f, -0.07260178f, 0.26244006f, 
    -0.07986965f, -0.09397800f, -0.08776558f, 0.11809479f, 0.01996734f, -0.20296001f, -0.03426810f, 0.06964268f, 
    0.16769071f, 0.10379503f, 0.05002903f, 0.29412049f, -0.14739518f, 0.02160244f, 0.01577056f, -0.07933243f, 
    -0.00586990f, -0.14650030f, -0.03417445f, 0.13302048f, -0.10108583f, 0.03261597f, 0.02811797f, 0.06886040f, 
    0.16335773f, 0.35649493f, 0.01457401f, 0.05630777f, 0.16384317f, 0.33027852f, 0.16510569f, 0.05682417f, 
    0.13678567f, 0.27098921f, -0.51132798f, -0.11079913f, -0.12185671f, -0.09168368f, 0.15280357f, -0.19105904f, 
    0.16303015f, 0.06484495f, -0.06711794f, 0.10184019f, 0.06482107f, -0.24905425f, -0.29941556f, 0.19532920f, 
    0.07257437f, -0.25221649f, -0.02173881f, 0.21592826f, 0.01389390f, -0.00149523f, 0.13545893f, 0.17385079f, 
    0.16786116f, 0.03189936f, -0.20055497f, -0.03279369f, 0.07290469f, 0.14808582f, -0.30390695f, -0.14661035f, 
    -0.17520462f, 0.02249534f, 0.19220529f, 0.05877683f, -0.40364403f, 0.39856848f, -0.15619031f, -0.07007758f, 
    -0.00760761f, 0.03059327f, 0.12268503f, 0.14712782f, -0.15763029f, 0.03561589f, 0.13148314f, -0.24764761f, 
    -0.41480109f, 0.17965506f, 0.03263571f, -0.01206791f, 0.16458723f, -0.03950085f, 0.09713569f, 0.33994329f, 
    0.10152499f, 0.26423872f, -0.00350308f, 0.10714540f, 0.41408342f, -0.13993239f, -0.07829528f, -0.17810640f, 
    0.01065969f, -0.04724758f, 0.07132092f, -0.01986993f, -0.05494227f, -0.14266938f, -0.09676182f, -0.24647792f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02356109f, -0.15530257f, -0.05460579f, -0.02980858f, -0.08073575f, 0.20050953f, 0.12836444f, 0.13570479f, 
    0.16058949f, -0.09745293f, 0.20409988f, -0.04611757f, 0.07997558f, 0.05151606f, 0.20549175f, -0.06241828f, 
    0.13842867f, 0.21572590f, 0.09670942f, -0.08107585f, -0.10855316f, -0.00214724f, 0.09668631f, 0.00814351f, 
    0.02057958f, 0.08839516f, 0.22191308f, 0.33643511f, -0.00795318f, 0.18780404f, 0.15170969f, 0.05295134f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.14385381f, 0.20475303f, 0.17025541f, -0.09133601f, -0.08238652f, -0.06639694f, 0.22745985f, 0.11007242f, 
    -0.01511353f, 0.08730397f, 0.06027326f, 0.17428842f, -0.17104712f, -0.03879344f, 0.11663870f, 0.27093884f, 
    -0.02873248f, 0.06408828f, 0.10678456f, -0.08157311f, 0.11120325f, 0.05317874f, 0.17165834f, -0.23866548f, 
    -0.37368235f, 0.11239535f, 0.25857681f, -0.01340004f, 0.13451417f, 0.14555150f, -0.09184049f, 0.25641540f, 
    -0.30812028f, 0.10239346f, 0.12395179f, 0.06919375f, 0.11732149f, 0.23004918f, -0.40065143f, -0.09486911f, 
    -0.15833887f, 0.72639364f, 0.20024808f, -0.13672160f, -0.21055862f, 0.08071950f, 0.01866661f, -0.05477624f, 
    0.37340075f, 0.14229189f, -0.43002766f, 0.25621289f, 0.14362164f, 0.37621397f, 0.28129616f, 0.19826773f, 
    -0.21873119f, -0.19850913f, 0.16535324f, 0.18561560f, 0.28712228f, -0.32873687f, -0.42196837f, -0.31472293f, 
    0.52262908f, 0.32348952f, 0.10730513f, -0.11750092f, 0.54647005f, -0.05906704f, -0.13184324f, -0.07454955f, 
    -0.00169637f, 0.08810460f, -0.25462991f, -0.10673027f, -0.07969609f, 0.01924687f, -0.52119911f, 0.12013334f, 
    -0.24665868f, -0.15197369f, -0.03693515f, 0.03261345f, 0.42675573f, 0.25460267f, 0.01883645f, 0.14992891f, 
    0.42444351f, 0.22980928f, -0.82017863f, 0.21920948f, -0.00889866f, -0.03660051f, -0.13563910f, 0.20290345f, 
    0.36432204f, -0.11905559f, 0.08804564f, -0.07403347f, 0.03638159f, 0.17156576f, 0.12306673f, -0.04703544f, 
    0.01872462f, -0.49447441f, 0.19636467f, 0.17159107f, 0.03696099f, 0.02282465f, 0.17566940f, -0.34301308f, 
    -0.04412160f, 0.08011127f, 0.45484531f, -0.25890055f, 0.07849936f, 0.06196839f, 0.29851595f, 0.02683757f, 
    0.18522710f, 0.31399930f, -0.16858073f, 0.14218058f, -0.65255290f, 0.14520696f, 0.26897445f, -0.24905992f, 
    -0.33040842f, 0.00918783f, 0.12358050f, -0.03499939f, -0.52876788f, 0.25203556f, 0.17923367f, 0.24928714f, 
    -0.36412093f, 0.26445267f, -0.09833379f, 0.05025833f, -0.02530897f, -0.07237397f, -0.00031842f, 0.54688632f, 
    -0.17535701f, -0.04323920f, -0.23582290f, -0.00758200f, 0.29174897f, 0.43216711f, -0.07333648f, 0.39063996f, 
    0.46167561f, -0.51663119f, 0.16496202f, 0.18285424f, -0.02586159f, -0.31621650f, -0.11197163f, 0.13840765f, 
    0.00728972f, 0.13719997f, -0.11491616f, -0.17296568f, -0.14924084f, 0.06175630f, 0.33815613f, -0.06302639f, 
    0.33097312f, -0.34085196f, -0.03308960f, -0.11321831f, -0.13559650f, 0.17103215f, 0.27923456f, -0.04555393f, 
    -0.25043231f, -0.03877140f, 0.36103225f, -0.18015644f, 0.19005726f, -0.12784845f, 0.24487188f, 0.03983160f, 
    -0.06938460f, -0.08011863f, -0.16288199f, 0.09777787f, -0.13406624f, 0.23288400f, 0.45619100f, 0.24232735f, 
    -0.19051112f, -0.33615682f, -0.05406811f, -0.12099825f, 0.43510339f, 0.24312145f, 0.10440884f, 0.08566122f, 
    -0.07585748f, -0.08104178f, 0.40568808f, -0.15579206f, 0.25923342f, -0.00056650f, 0.04371563f, -0.44098553f, 
    0.35251549f, -0.29309356f, 0.01538255f, -0.00105501f, 0.06487626f, -0.11003130f, 0.05473001f, 0.14655103f, 
    -0.07545673f, 0.59950179f, -0.13483639f, 0.16398109f, -0.14398232f, -0.01974124f, 0.19364901f, -0.25188532f, 
    0.04138764f, 0.09199721f, 0.06628738f, -0.03115634f, 0.40538916f, -0.12096793f, 0.15234134f, 0.29731649f, 
    0.19715002f, 0.15176085f, 0.05943144f, -0.09246591f, 0.06845769f, -0.11407728f, 0.27098814f, -0.24244903f, 
    -0.14708360f, 0.10154405f, 0.06762952f, -0.25485381f, -0.35822645f, -0.16932930f, -0.64291734f, -0.36527494f, 
    0.07703337f, -0.34207004f, 0.30618280f, 0.10468619f, 0.61634350f, 0.24234471f, 0.10138897f, 0.57642025f, 
    -0.09666140f, -0.15090564f, -0.05678020f, 0.15756480f, -0.20705438f, 0.08082403f, -0.00248205f, -0.03394666f, 
    -0.09179686f, 0.01665320f, -0.24203549f, -0.02765078f, 0.07328014f, -0.00998892f, 0.01010798f, -0.06918136f, 
    0.18718727f, -0.31250572f, -0.37067118f, 0.10304635f, 0.01608861f, -0.16860558f, 0.01567075f, -0.11547770f, 
    -0.08079629f, -0.15156327f, 0.09565719f, -0.06116140f, -0.13678700f, -0.24521929f, -0.23215289f, 0.00620471f, 
    -0.30350515f, -0.10191005f, 0.04555414f, 0.07621653f, 0.32956532f, -0.03441829f, 0.23708834f, 0.37374029f, 
    0.11526304f, -0.18569796f, 0.20959595f, 0.15677032f, 0.09218683f, -0.16413070f, 0.16644666f, -0.11249558f, 
    0.01385261f, -0.26488578f, -0.19167344f, -0.37270188f, -0.23371421f, 0.07657370f, -0.35079008f, -0.00145002f, 
    0.12974377f, -0.01808768f, 0.28117406f, 0.08710072f, 0.65555412f, -0.10852575f, 0.03127832f, 0.58204544f, 
    -0.22394362f, -0.22018698f, -0.01156714f, 0.03800695f, 0.08752113f, -0.35993594f, -0.46240357f, 0.24111508f, 
    0.02435202f, 0.28009334f, -0.17116846f, -0.07860598f, 0.29452083f, 0.16404617f, 0.03284523f, 0.13193239f, 
    -0.25079128f, 0.08113484f, -0.45984724f, -0.44401711f, -0.07701114f, 0.04304608f, -0.09845141f, -0.23455828f, 
    0.28217620f, -0.15907374f, -0.21193145f, 0.02600093f, 0.13191295f, 0.25273082f, 0.18593661f, 0.33945757f, 
    -0.17495337f, 0.03543755f, -0.12270853f, -0.00471075f, 0.12770025f, 0.07447539f, -0.43005478f, 0.12011022f, 
    -0.18999018f, 0.00246081f, 0.06295657f, 0.03203825f, 0.12614618f, 0.05402501f, -0.13784973f, 0.31691682f, 
    0.29132211f, 0.32821757f, -0.38018245f, -0.00396393f, 0.21362184f, 0.25737748f, 0.30124244f, 0.12381966f, 
    0.07612276f, 0.19924276f, -0.34566092f, -0.06990138f, 0.18804869f, -0.03476679f, 0.25339752f, -0.12375592f, 
    0.01213392f, 0.24108934f, -0.00828016f, 0.15472418f, 0.23898166f, 0.21495788f, -0.34539202f, 0.17875819f, 
    -0.02820468f, -0.28277516f, -0.20682593f, -0.11925960f, -0.07022045f, 0.01966104f, -0.42003414f, -0.07473289f, 
    -0.02882083f, 0.29318348f, -0.11105285f, -0.13119613f, 0.22309062f, -0.26237932f, 0.31524780f, -0.36548978f, 
    0.10598843f, 0.45833614f, 0.19294079f, 0.25069872f, -0.29931158f, 0.24242032f, -0.18986979f, -0.25215814f, 
    0.07410177f, 0.09161694f, -0.13373853f, 0.14940558f, -0.00148460f, -0.19486585f, -0.20279209f, -0.13709372f, 
    0.05193590f, 0.03552422f, -0.13465866f, -0.00948675f, -0.23668450f, 0.13823274f, 0.05483489f, 0.04036180f, 
    0.09248545f, -0.14700525f, 0.06655878f, -0.02638709f, -0.12730120f, -0.18098775f, -0.17822495f, 0.13035113f, 
    0.11283931f, 0.07083296f, -0.07700880f, 0.05393265f, 0.13016081f, 0.00803161f, -0.16057135f, -0.12515420f, 
    0.07598702f, 0.27774790f, 0.01865677f, -0.01272588f, -0.11455700f, 0.07238803f, 0.17274781f, 0.01957778f, 
    -0.22351849f, -0.07034438f, -0.18649983f, 0.05133397f, -0.01055874f, -0.02986697f, 0.02293685f, 0.61382103f, 
    -0.14181727f, -0.30226672f, 0.32440105f, 0.17513028f, 0.29097456f, 0.30206722f, -0.22440444f, 0.05757753f, 
    0.09309356f, -0.06816513f, -0.32831144f, 0.12716952f, 0.55756116f, -0.00817192f, 0.17825806f, 0.17739242f, 
    0.27193695f, -0.15574218f, 0.13687950f, 0.07051282f, 0.39631945f, 0.16095077f, 0.37159464f, -0.06152325f, 
    0.45304224f, 0.28209457f, 0.25771117f, -0.01755274f, -0.07758084f, 0.05161192f, 0.42094177f, -0.39983270f, 
    0.40631256f, -0.20637198f, 0.04285858f, -0.09118816f, 0.00831378f, 0.16668341f, -0.02008871f, 0.51392406f, 
    -0.55007869f, 0.12267239f, -0.12697408f, -0.10737576f, 0.12027382f, 0.02053333f, 0.32559091f, 0.32863423f, 
    0.57994795f, -0.13339010f, -0.08707005f, -0.03769593f, 0.38397545f, 0.06569397f, 0.27964649f, 0.11755633f, 
    0.25312126f, -0.04295673f, 0.16280244f, -0.06796374f, 0.03386172f, 0.11923680f, -0.12388425f, 0.03244665f, 
    0.01048499f, 0.01251996f, 0.30315864f, -0.03980716f, 0.10177109f, -0.34228370f, -0.58191669f, -0.31576297f, 
    -0.19895966f, -0.07602326f, -0.24017845f, 0.11042392f, -0.39681336f, 0.10450407f, -0.00248120f, -0.00673760f, 
    -0.21390255f, 0.05558489f, -0.02156898f, -0.14832604f, 0.20401800f, 0.22120124f, -0.42560917f, -0.11500147f, 
    0.18732117f, -0.01640497f, 0.15972437f, -0.12845960f, -0.52089459f, -0.02094452f, -0.32700685f, 0.06880210f, 
    0.08204301f, 0.33818117f, -0.12758073f, -0.02759411f, 0.26700383f, 0.35173100f, 0.33121264f, -0.06866789f, 
    0.01220367f, 0.12502632f, -0.18365201f, 0.15071775f, -0.25726306f, 0.30576855f, -0.27202201f, -0.55193573f, 
    0.04672533f, -0.26702926f, 0.02134505f, 0.08614445f, -0.22679912f, 0.06217067f, -0.29684880f, -0.05121251f, 
    0.04623947f, -0.31846419f, 0.29824618f, -0.15467627f, 0.06874938f, 0.05052942f, -0.05097291f, -0.13385905f, 
    0.26505500f, 0.22045083f, -0.10858771f, -0.10814282f, -0.02677060f, 0.12899458f, 0.36028889f, -0.22471596f, 
    0.27461299f, 0.08007120f, 0.05433226f, 0.28239378f, -0.27589884f, 0.18266109f, 0.08628058f, -0.42199975f, 
    0.20141403f, -0.01110417f, 0.00875256f, -0.05041303f, 0.24541613f, -0.15547964f, 0.08653261f, 0.37964314f, 
    -0.04216857f, 0.01876920f, 0.01724636f, -0.08100466f, 0.37430069f, 0.16996606f, -0.25882119f, -0.04174792f, 
    0.23618628f, -0.09030330f, -0.51911324f, -0.12104598f, 0.11108970f, -0.18642826f, -0.13615747f, -0.34947729f, 
    0.38597411f, 0.45614332f, -0.09682391f, 0.12072910f, 0.02037835f, -0.06214111f, -0.08665606f, 0.36273894f, 
    0.04502803f, 0.05751853f, -0.01611280f, 0.07771776f, 0.52790898f, 0.15737675f, 0.11079803f, -0.08894634f, 
    0.22056149f, 0.06206306f, 0.05322459f, -0.12068234f, -0.17511158f, 0.06451967f, 0.30826271f, -0.12678361f, 
    -0.03668616f, 0.06973288f, 0.35501832f, -0.06014668f, -0.21428789f, 0.27491674f, -0.18976462f, 0.01022958f, 
    0.01312191f, -0.38460484f, 0.46524912f, 0.23075171f, 0.13569112f, 0.21227139f, -0.30031589f, -0.34058389f, 
    -0.32633904f, -0.01249213f, -0.05643120f, 0.10200818f, -0.52281797f, -0.06517763f, -0.17857236f, 0.09514884f, 
    0.22332247f, 0.22180632f, -0.03262483f, 0.04455221f, -0.15335546f, 0.03260862f, 0.38802966f, -0.39883739f, 
    0.45487708f, 0.26586622f, 0.11588968f, -0.49841166f, -0.21103500f, 0.04574637f, 0.24508628f, 0.31966472f, 
    -0.47326243f, 0.01108196f, -0.03968052f, 0.13920330f, -0.01290541f, 0.33924332f, 0.30641419f, -0.12896991f, 
    0.15224858f, -0.27492473f, 0.06556861f, 0.13579670f, -0.31486708f, -0.44967082f, -0.23598626f, 0.07717242f, 
    0.23305839f, -0.10687897f, 0.00723986f, -0.09399801f, 0.28812853f, 0.06687535f, 0.12115269f, 0.38473782f, 
    -0.19776776f, 0.30226621f, -0.10589857f, 0.20764558f, -0.23093019f, 0.25589123f, 0.01823092f, -0.63359058f, 
    0.04842355f, -0.19013409f, -0.28158763f, 0.06940384f, 0.14036411f, 0.30905917f, 0.21679395f, -0.14763361f, 
    -0.46420181f, -0.01577088f, -0.11892249f, -0.00218043f, -0.04628918f, 0.28384408f, 0.27619186f, 0.21567999f, 
    -0.15743223f, 0.02861851f, 0.36542132f, 0.14922526f, -0.01567816f, -0.09449527f, 0.25863427f, 0.26025340f, 
    0.06345259f, -0.04760518f, -0.01518701f, 0.03209764f, -0.13645394f, 0.19338749f, -0.17510661f, 0.10448884f, 
    -0.03701906f, -0.13279277f, 0.13072303f, 0.08627937f, 0.10216729f, -0.24961549f, -0.23305668f, 0.00981199f, 
    -0.32280174f, 0.16874215f, 0.01718490f, 0.06117810f, -0.46645299f, -0.11727050f, 0.11390410f, -0.02174122f, 
    -0.21863443f, -0.23706719f, -0.19725086f, 0.11979991f, -0.14372942f, 0.12096406f, 0.24886982f, 0.26423556f, 
    -0.30349973f, 0.18754184f, 0.12674280f, 0.00144426f, 0.15117982f, 0.17122011f, 0.07863274f, -0.19024363f, 
    0.16009250f, -0.44311288f, 0.05739922f, 0.01156428f, 0.14421642f, 0.25480422f, 0.23507057f, 0.28908122f, 
    -0.21190420f, 0.02959640f, -0.03446972f, 0.02077739f, -0.51477975f, 0.17567509f, 0.22484343f, 0.09369076f, 
    0.24342287f, -0.36864465f, -0.00427621f, -0.16583274f, -0.26922888f, -0.11953531f, 0.26238412f, 0.11022574f, 
    -0.15905438f, 0.29660055f, 0.15247525f, -0.29236826f, 0.02459571f, -0.15848136f, 0.09038963f, 0.08611208f, 
    0.19141714f, -0.23968680f, 0.18549566f, 0.19436872f, -0.45022154f, 0.19452006f, 0.35832533f, 0.18000917f, 
    0.40766501f, 0.25457779f, 0.11698460f, 0.00354794f, -0.01490831f, 0.01623351f, 0.43542087f, 0.07868126f, 
    -0.15450422f, 0.17496473f, 0.06251284f, -0.06464168f, -0.04651996f, 0.02091695f, 0.11520533f, 0.21070826f, 
    -0.01457816f, -0.23830537f, 0.17318517f, -0.02333828f, 0.32729065f, 0.07843814f, -0.35625118f, 0.14461458f, 
    0.30325842f, 0.16177462f, -0.43331963f, -0.03227874f, 0.01608216f, -0.31280789f, 0.28958794f, 0.17523777f, 
    0.10377526f, 0.02762377f, 0.06300057f, 0.14465031f, 0.46532542f, -0.04604538f, -0.09373786f, -0.12939398f, 
    0.10638858f, 0.17219140f, -0.27942401f, 0.05116688f, 0.18745658f, -0.17263378f, -0.17476986f, 0.11337995f, 
    -0.33710176f, -0.26811057f, 0.14166294f, 0.20670225f, 0.09500547f, 0.12125179f, 0.05436246f, 0.19637464f, 
    -0.14556691f, -0.16298303f, -0.23719357f, 0.05884373f, 0.11490770f, 0.02622511f, 0.12348292f, -0.52824306f, 
    -0.17676660f, -0.10030745f, -0.00882120f, 0.04706554f, -0.15800013f, 0.20522468f, -0.09034769f, 0.25403312f, 
    -0.39463377f, -0.34478223f, 0.31996775f, 0.06975780f, 0.49921024f, -0.04002198f, -0.01953168f, -0.03840790f, 
    -0.26665166f, 0.00200692f, -0.20535195f, 0.06203340f, -0.16716042f, 0.16879094f, -0.15545504f, -0.15252399f, 
    0.60873741f, 0.39561385f, -0.16180170f, 0.26397413f, -0.09519958f, 0.10072836f, 0.16104113f, 0.25268108f, 
    -0.04894671f, -0.44440269f, 0.06773504f, 0.00452545f, 0.41472748f, -0.24801603f, 0.00272711f, -0.03685191f, 
    0.27382705f, -0.30043977f, 0.26336718f, -0.10805999f, 0.22427018f, -0.17503223f, 0.30362478f, -0.18093958f, 
    -0.41088888f, 0.10489119f, -0.01318404f, 0.22162975f, -0.32742414f, -0.12276530f, -0.32411340f, -0.12083366f, 
    0.01221649f, 0.07562914f, -0.23355268f, 0.24263252f, -0.05208516f, 0.36216891f, -0.12037756f, -0.03848306f, 
    -0.06459267f, -0.17788655f, -0.02126547f, -0.13965605f, 0.36139429f, -0.09279703f, -0.26157013f, -0.03848782f, 
    0.00772520f, -0.27600360f, -0.07173298f, -0.10741339f, -0.01540975f, -0.15904069f, -0.10912471f, -0.13530949f, 
    0.08328942f, 0.00024471f, -0.03631594f, 0.15089698f, 0.32136929f, -0.05392081f, -0.24463576f, -0.14905356f, 
    0.03359081f, -0.11380930f, -0.12672174f, -0.01166392f, 0.10275219f, -0.15068869f, -0.22293980f, -0.11421220f, 
    0.18031731f, -0.21782069f, 0.01258761f, 0.07552443f, -0.53969574f, -0.13933013f, 0.21437111f, 0.30318457f, 
    0.12596136f, 0.28335300f, 0.33908641f, 0.16532785f, 0.02574778f, 0.14779337f, -0.10755036f, -0.06556939f, 
    0.56912494f, 0.15972592f, -0.49132839f, -0.06990814f, -0.00815322f, -0.19850451f, 0.12586607f, -0.01822075f, 
    0.12209880f, 0.16764605f, 0.28935748f, 0.12204847f, -0.12152202f, -0.08774489f, 0.01289931f, 0.13695619f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.06598010f, -0.14246836f, -0.04533051f, -0.02111807f, 0.16364388f, 0.13882400f, 0.10165621f, 0.04688489f, 
    -0.26592407f, 0.13560078f, -0.25918213f, 0.03771691f, 0.12716246f, 0.07868574f, 0.06681416f, 0.08947529f, 
    0.10928123f, 0.10407694f, 0.22480418f, -0.05452249f, 0.10511719f, 0.14215910f, -0.12534747f, 0.04844540f, 
    0.12118456f, 0.20440707f, 0.16039930f, 0.35892141f, 0.19909477f, -0.00538242f, -0.03714117f, 0.14775467f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.05262596f, 0.33135393f, 0.29356462f, -0.30080035f, 0.08322521f, -0.45831394f, -0.60071403f, -0.17803036f, 
    0.17796247f, -0.32717818f, 0.02793162f, 0.18726628f, 0.15789594f, 0.10227783f, 0.18559088f, -0.17736243f, 
    -0.17099683f, 0.25411412f, -0.08255299f, -0.39668423f, 0.21528225f, -0.17055917f, -0.63629836f, -0.02051555f, 
    -0.01388903f, -0.59163207f, -0.07727778f, 0.07204779f, -0.65118760f, -0.17418829f, -0.07075393f, -0.46998700f, 
    -0.02825513f, 0.28312051f, -0.38034075f, 0.15246508f, 0.07271645f, -0.07466676f, 0.08524041f, -0.22960825f, 
    -0.06283075f, -0.59182459f, -0.30733496f, -0.02844493f, -0.12874100f, -0.15013503f, -0.38878658f, 0.22548099f, 
    0.43953297f, 0.20709470f, 0.19772471f, -0.37261730f, 0.09491702f, 0.34502384f, 0.21380964f, 0.04715835f, 
    -0.31868619f, 0.22436266f, -0.24902797f, 0.06632537f, -0.42708632f, 0.24678856f, 0.20294394f, 0.18414341f, 
    -0.00712338f, 0.06433482f, -0.81718582f, -0.17949259f, -0.08809600f, -0.44017541f, 0.27963790f, 0.00679858f, 
    -0.12528318f, 0.21747488f, -0.48278034f, 0.01079184f, -0.25487509f, 0.00164395f, 0.11874729f, 0.18798551f, 
    -0.61220324f, -0.55428725f, 0.10843932f, -0.19281802f, 0.12719424f, 0.37257418f, -0.46734032f, 0.22198640f, 
    -0.13907425f, -0.09470902f, -0.02956569f, 0.28780109f, 0.09974292f, -0.56927437f, -0.01207625f, 0.26370224f, 
    0.13168225f, 0.11655869f, 0.09756263f, -0.30668133f, 0.11460825f, -0.60911882f, 0.05165671f, -0.24757534f, 
    -0.14732286f, 0.05319555f, -0.06514563f, 0.29920924f, -0.13426647f, -0.16034015f, 0.10245510f, 0.00325224f, 
    -0.12872157f, -0.07218263f, -0.14767076f, 0.39686453f, -0.50095731f, -0.41265514f, 0.11390719f, 0.13083495f, 
    -0.49458790f, -0.59466481f, 0.18240531f, -0.32259256f, 0.05997768f, -0.39643812f, -0.11849225f, 0.34366775f, 
    -0.01767836f, 0.04340444f, 0.25072488f, -0.05486824f, 0.26284698f, 0.11738147f, -0.08481671f, -0.41257301f, 
    -0.15221487f, -0.19486302f, -0.43709600f, -0.10839362f, -0.48135233f, -0.15989593f, 0.14857249f, 0.08860059f, 
    -0.14257300f, -0.21900305f, -0.45716944f, -0.29025424f, -0.00001615f, -0.08375208f, 0.28374183f, 0.16648169f, 
    0.15278341f, -0.01084218f, 0.37509134f, -0.05688456f, -0.10087644f, 0.17203750f, -0.28252140f, -0.43313941f, 
    0.00313833f, -0.08166045f, -0.08257214f, 0.20061126f, 0.22804296f, 0.08302674f, -0.16026299f, -0.32714203f, 
    -0.01925350f, -0.26714492f, -0.13361581f, 0.09784115f, 0.14165351f, -0.16212444f, -0.01106179f, -0.44408077f, 
    -0.33639225f, 0.11357845f, 0.20418258f, -0.24332063f, -0.07508119f, -0.19062653f, 0.18658869f, 0.11729740f, 
    0.23240811f, 0.31159231f, -0.03593268f, -0.58046919f, 0.26284039f, -0.20828350f, -0.46739295f, -0.24794561f, 
    0.19093294f, -0.35726202f, -0.41079235f, -0.00704507f, -0.82636774f, -0.00941844f, 0.27587456f, 0.24962667f, 
    -0.24352673f, 0.34565923f, -0.72083020f, -0.82074887f, 0.01658572f, 0.11942806f, -0.25324064f, 0.20893526f, 
    -0.09214716f, -0.41827059f, -0.19901259f, 0.00687475f, 0.30672419f, -0.31537667f, -0.58399308f, 0.24382286f, 
    -0.22056682f, 0.06875052f, -0.17664808f, -0.77569646f, -0.10037158f, 0.05263677f, 0.00470533f, -0.37394661f, 
    -0.49645799f, -0.33884865f, 0.00225225f, -0.15645361f, -0.32327598f, -0.11820070f, -0.26444706f, 0.14221300f, 
    -0.15338293f, 0.19658411f, 0.64140689f, 0.20000213f, -0.39528751f, 0.02228767f, -0.30848563f, -0.00858136f, 
    -0.47402737f, -0.23401380f, 0.09114110f, 0.06834291f, -0.19666763f, -0.04462850f, 0.29753664f, -0.47638091f, 
    0.21010637f, 0.01356792f, -0.44976783f, 0.01983269f, 0.22562937f, 0.12497011f, -0.10232817f, -0.15235600f, 
    -0.15775315f, -0.17098728f, -0.36416310f, -0.08155781f, -0.29798815f, -0.58291310f, 0.13716623f, -0.06064580f, 
    -0.19610277f, -0.09119209f, -0.07376207f, -0.15051880f, 0.50970268f, -0.13639452f, -0.58715278f, -0.53087252f, 
    -0.21159339f, -0.24541402f, 0.14203309f, 0.48383272f, -0.14312612f, -0.03032521f, 0.01782381f, -0.11085675f, 
    -0.39247930f, 0.20505758f, -0.44696328f, -0.12036201f, 0.27509385f, -0.27576709f, -0.11636212f, 0.49700937f, 
    0.28366560f, -0.32423806f, -0.25569579f, -0.24593103f, 0.12347662f, 0.27371749f, -0.71946603f, 0.20518480f, 
    -0.27428320f, 0.15511988f, -0.27823114f, -0.25982961f, -0.13315603f, -0.01657804f, 0.17380962f, 0.00597328f, 
    0.14929067f, -0.33641684f, -0.22888213f, 0.06290540f, -0.17561938f, 0.02523662f, -0.08021981f, -0.07420253f, 
    0.33210036f, 0.32670259f, 0.14934447f, -0.48700723f, -0.36984646f, -0.47060576f, -0.18625093f, 0.10284470f, 
    -0.05440370f, -0.28476664f, 0.03250948f, 0.37178394f, -0.68139941f, 0.46014684f, 0.26989841f, -0.49774969f, 
    -0.14040688f, -0.40867481f, -0.33035931f, 0.23724821f, 0.34367105f, 0.03996539f, -0.21651950f, 0.25503793f, 
    -0.23833980f, 0.14048514f, 0.17153555f, -0.11199968f, -0.66114247f, 0.33872023f, -0.49307334f, -0.55814111f, 
    -0.31714538f, 0.17462181f, -0.13262446f, 0.05006637f, -0.28820422f, -0.40990722f, -0.58679712f, -0.21657659f, 
    -0.37489799f, -0.57785845f, 0.50295919f, 0.28420818f, -0.29507035f, -0.15439023f, 0.11501417f, -0.03772330f, 
    -0.03978230f, -0.12484451f, -0.49742258f, -0.39290127f, -0.02663466f, -0.01945390f, 0.03191791f, 0.07548973f, 
    0.33219686f, -0.36032018f, 0.17363812f, 0.25650930f, 0.02098434f, -0.95318139f, -0.32560313f, -0.23471141f, 
    -0.30892462f, -0.13443726f, 0.38361824f, -0.40488157f, 0.21095712f, -0.12574604f, -0.54133379f, -0.12313224f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.22347981f, 0.18797037f, 0.19674270f, -0.01302600f, -0.19037738f, 0.02212360f, -0.09112392f, 0.04184150f, 
    0.16999817f, 0.22133787f, 0.21337430f, 0.14426449f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
