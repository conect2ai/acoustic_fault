#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.20409890f, -0.03785866f, 0.18270797f, -0.00331487f, 0.17177506f, -0.37130055f, -0.07515254f, 0.28400806f, 
    -0.26759279f, 0.42395368f, -0.06931791f, 0.06733060f, -0.04712090f, -0.11329857f, 0.16272035f, -0.14698541f, 
    0.06688416f, 0.01695212f, -0.13731623f, 0.02435285f, 0.10052049f, -0.09733281f, 0.31411546f, -0.19748691f, 
    -0.12881990f, -0.64727873f, -0.04668743f, -0.44799718f, -0.41740972f, -0.30046251f, 0.02516329f, 0.16937302f, 
    -0.35892564f, -0.64140898f, -0.29674542f, -0.29495370f, 0.14924072f, -0.18638518f, -0.39900926f, -0.26281667f, 
    -0.04357596f, 0.02020948f, -0.00523636f, -0.14816478f, -0.13033490f, 0.17070755f, -0.06429352f, -0.19143426f, 
    0.09324457f, -0.05642758f, -0.42436069f, -0.26213560f, 0.15590310f, 0.32975945f, 0.40660825f, 0.43989548f, 
    -0.13847074f, -0.33694100f, -0.11137470f, 0.15006289f, 0.01427223f, 0.17709035f, -0.36287868f, -0.12740995f, 
    0.18720745f, -0.19665600f, -0.22191273f, 0.15603559f, 0.25245836f, -0.16288000f, 0.25210750f, -0.37765291f, 
    -0.05911710f, -0.06591779f, 0.12919334f, -0.14961611f, -0.38315389f, 0.09951128f, 0.33867803f, 0.07341380f, 
    0.26870772f, -0.15959200f, -0.28532550f, -0.21264482f, 0.18720381f, 0.11569737f, 0.14662568f, -0.17353316f, 
    0.11940672f, -0.10193921f, 0.08189725f, 0.06810611f, 0.11205119f, -0.32209823f, -0.37175143f, -0.19657907f, 
    0.37421578f, 0.16076173f, -0.05724747f, 0.26656130f, -0.81602234f, -0.37437686f, 0.14738888f, 0.62224376f, 
    0.58305126f, 0.47701564f, -0.16961408f, -0.60202825f, -0.53783780f, -0.33220258f, -0.39514011f, 0.08185592f, 
    -0.15226802f, -0.41543522f, -0.24214798f, 0.07418899f, 0.08526340f, -0.00462897f, 0.08259753f, 0.18120967f, 
    0.06613401f, -0.14960158f, -0.25425231f, -0.11274527f, -0.29293168f, -0.08972034f, -0.19821648f, -0.24662894f, 
    -0.39867863f, -0.44774953f, -0.56542826f, -0.36903554f, -0.67280239f, -0.62923080f, -0.60874492f, 0.51320535f, 
    0.14474568f, 0.45931116f, 0.29944593f, 0.23455496f, -0.14189738f, -0.17148446f, -0.19146006f, -0.04774950f, 
    -0.10459270f, 0.07395826f, -0.10783535f, 0.03988033f, 0.15146095f, 0.10938992f, 0.22292055f, 0.36665377f, 
    0.29178151f, -0.92949516f, -1.01240361f, 0.33565959f, 0.17304841f, -0.04115758f, 0.17766215f, 0.22232261f, 
    0.08708354f, 0.37196502f, -0.14916809f, -0.20958005f, -0.00152086f, -0.23535915f, 0.09145618f, -0.05541855f, 
    -0.08928309f, -0.15275310f, 0.09883350f, -0.05524153f, 0.20332932f, -0.26823094f, -0.29855925f, -0.04276713f, 
    0.19429775f, 0.21186617f, 0.20254332f, 0.03236743f, -0.18539082f, -0.50005901f, -0.17385310f, 0.31000045f, 
    0.03060107f, 0.05827195f, -0.32609019f, -0.12226507f, 0.03853847f, 0.06459654f, -0.18307030f, -0.01267658f, 
    0.10155295f, 0.03718268f, 0.10970325f, 0.02066007f, -0.13527106f, 0.08424365f, -0.00215543f, 0.04558222f, 
    0.68185061f, 0.62848449f, -0.58209616f, -0.81138200f, -0.82669759f, -0.35695034f, 0.29036540f, 0.26278725f, 
    0.14088945f, 0.49765810f, 0.03797104f, 0.24357802f, 0.16413249f, -0.10441010f, -0.09720779f, 0.15030611f, 
    -0.20457420f, 0.13887024f, -0.09974080f, -0.29474571f, 0.06728435f, 0.14273481f, 0.03737322f, -0.12977862f, 
    0.22386019f, -0.38799834f, -0.86803526f, 0.18592824f, 0.28432181f, 0.59964365f, 0.40270281f, -0.85021967f, 
    -0.37414554f, 0.55476105f, 0.34855238f, -0.17544974f, 0.08707362f, 0.03594126f, -0.01235137f, 0.20553756f, 
    0.12639850f, -0.14288369f, -0.13126384f, 0.14366557f, -0.35187471f, 0.03895198f, -0.06182895f, -0.24672011f, 
    0.29418033f, 0.19911903f, -0.22802857f, 0.05988107f, -0.12600794f, 0.12805584f, -0.17786114f, -0.05831948f, 
    -0.29064023f, -0.36348453f, -0.17439495f, 0.12209255f, 0.10787780f, 0.39606002f, 0.12997162f, -0.14167458f, 
    0.31376353f, -0.13811131f, 0.24240386f, 0.03112127f, -0.27298862f, -0.14821795f, 0.20322609f, -0.26671392f, 
    -0.18361293f, 0.15248950f, -0.43190566f, -0.71873069f, -0.79710716f, -0.15119970f, -0.17954080f, -0.36269027f, 
    0.76876163f, 0.03656957f, -0.62665951f, -0.21238357f, 0.25333723f, -0.01481446f, -0.35637549f, -0.48338577f, 
    -0.34543753f, -0.36726093f, 0.01732243f, -0.04968955f, -0.16141286f, -0.11801952f, 0.20322883f, -0.14895745f, 
    -0.27011424f, -0.14722328f, 0.11893020f, -0.08043859f, 0.03168209f, -0.72183937f, -0.44254303f, 0.17017150f, 
    0.29312414f, -0.18181013f, 0.46247253f, 0.39934483f, 0.24840811f, -0.13061497f, 0.08573043f, -0.49489874f, 
    -0.44834924f, -0.31938002f, 0.13958316f, 0.17604361f, 0.00578951f, 0.22478814f, -0.04522621f, -0.06940433f, 
    -0.18744376f, -0.21165432f, 0.34017891f, -0.13372813f, -0.36707625f, 0.30215532f, 0.61135155f, -0.21058348f, 
    -0.10174679f, 0.14659178f, -0.34254387f, -0.35352939f, -0.02597609f, -0.18773271f, -0.55678350f, -0.21154274f, 
    -0.14669582f, 0.06639670f, -0.09293835f, -0.19745605f, 0.03371383f, 0.04062531f, -0.12034551f, -0.31219643f, 
    0.00458701f, -0.24761404f, 0.12343536f, -0.03502329f, -0.16007133f, 0.18012311f, -0.93108773f, -0.61570811f, 
    -0.26466855f, 0.61792064f, 0.66842955f, -0.70366061f, -0.90569258f, -0.43229803f, -0.05700184f, 0.61252683f, 
    0.25875324f, -0.37015814f, 0.38266292f, 0.06213935f, -0.31104493f, 0.03465117f, -0.14993694f, 0.09785006f, 
    -0.48292056f, -0.19300416f, -0.16328683f, -0.06047604f, 0.06469768f, -0.44622347f, 0.11455527f, -0.56079060f, 
    -0.35393623f, -0.21075843f, -0.52294785f, -0.25516099f, 0.57648230f, 0.19298159f, 0.32885087f, -0.25478876f, 
    -0.32639733f, 0.36794397f, -0.04350971f, 0.27130356f, 0.08052749f, -0.01856081f, -0.06918947f, -0.19586152f, 
    0.01917308f, -0.22039980f, 0.09333792f, 0.23843499f, 0.18835071f, -0.12125067f, 0.13083191f, 0.02619044f, 
    0.97047651f, -0.24676660f, -0.17261736f, 0.01060930f, -0.76543885f, 0.24419455f, 0.31765953f, 0.36719286f, 
    -0.31098929f, -0.40136620f, 0.09513858f, 0.13115335f, -0.24028409f, 0.03209183f, -0.26461092f, -0.20435214f, 
    0.21596067f, 0.32227457f, -0.11986223f, -0.09333462f, -0.08909962f, -0.32021362f, -0.26666081f, 0.42071638f, 
    -0.11301914f, -0.50811380f, -0.24162064f, 0.12129918f, -0.16108978f, -0.13869308f, 0.22154757f, -0.15519908f, 
    -0.28826293f, 0.30414146f, 0.71303207f, 0.27533379f, -0.26151145f, 0.09122328f, -0.24307145f, 0.40841842f, 
    -0.52223629f, -0.04746163f, 0.07068121f, 0.02204109f, -0.13053003f, 0.06960134f, 0.23378798f, 0.08896583f, 
    0.26778078f, -0.06408095f, -0.80034798f, 0.09949464f, 0.48002997f, 0.19468591f, -0.26435786f, -0.19596031f, 
    -0.03227291f, 0.00891112f, 0.29077497f, -0.08693399f, -0.48129764f, -0.02232649f, 0.30208445f, 0.14653054f, 
    -0.32258588f, 0.23728074f, 0.13567102f, 0.13794608f, -0.15092045f, 0.15559113f, 0.29367018f, -0.08921552f, 
    -0.07237121f, -0.22329053f, -0.15216890f, -0.62834787f, -0.35856590f, 0.47814754f, 0.18529600f, 0.27555877f, 
    0.04485875f, -0.20307085f, 0.06800459f, -0.15919964f, -0.05789954f, -0.08771483f, -0.10521983f, -0.34085542f, 
    0.27780986f, 0.22337042f, -0.22796854f, 0.09969078f, -0.03645376f, 0.15521887f, 0.10677059f, 0.00468625f, 
    0.15789011f, 0.17661917f, -0.11137082f, -0.14764003f, -0.15786025f, -0.02791520f, -0.29813218f, 0.35734758f, 
    0.28137341f, -0.48695207f, -0.15675281f, -0.06522805f, 0.29193592f, -0.04891486f, 0.09844868f, -0.23245692f, 
    -0.41113228f, 0.46185943f, 0.22375603f, -0.01693374f, 0.05000910f, -0.30394644f, -0.05549487f, -0.11309997f, 
    -0.06857977f, 0.22022231f, 0.21905668f, 0.25994632f, -0.31538239f, 0.03450257f, -0.05491427f, -0.33701605f, 
    0.22916390f, -0.48802382f, -0.25954303f, -0.00198487f, -0.37805980f, -0.24850172f, -0.42351905f, 0.17781274f, 
    0.45150757f, -0.14096035f, 0.34229833f, 0.00476336f, -0.11900262f, -0.37131506f, -0.20155093f, -0.34110466f, 
    -0.34436044f, -0.09518864f, -0.14932385f, 0.07607830f, -0.13283020f, -0.51554537f, 0.54008234f, -0.42184159f, 
    -0.74244982f, -0.71808195f, -0.57851136f, -0.29464620f, -0.33053157f, -0.09872586f, 0.19660480f, 0.46375635f, 
    -0.01779980f, 0.19187188f, 0.33737260f, 0.08263364f, -0.15774883f, 0.06247998f, -0.08476190f, -0.04030936f, 
    0.08675651f, -0.17004925f, -0.30705959f, -0.37616348f, -0.09379591f, -0.32392105f, -0.29232246f, -1.05937338f, 
    -0.20660669f, 0.01483939f, -0.38405228f, -0.17386407f, 0.12482322f, -0.19620861f, 0.07316732f, 0.62656635f, 
    0.45165223f, 0.23358709f, 0.24424843f, -0.12912087f, 0.07639642f, -0.15115300f, 0.08341321f, -0.30948827f, 
    -0.29454812f, -0.28941983f, 0.12826058f, 0.04532498f, -0.07629084f, 0.03330719f, 0.20522529f, 0.21071735f, 
    -0.19743809f, 0.15131003f, -0.02256973f, 0.35238099f, -0.49518612f, -0.01298404f, -0.17989443f, -0.04883178f, 
    -0.07007901f, 0.30679286f, 0.49822134f, -0.33021340f, 0.14163308f, -0.29560012f, -0.03677267f, 0.13292605f, 
    0.13816634f, -0.27062222f, 0.03638452f, 0.00651785f, -0.23977834f, -0.08161534f, 0.19142558f, -0.34150723f, 
    0.48317063f, -0.11644505f, -0.46825242f, -0.37298387f, -0.48456690f, -0.40578347f, -0.53274292f, -0.71433312f, 
    -0.45024812f, -0.58932781f, -0.49939981f, 0.26860964f, 0.25598851f, 0.22975662f, 0.34254119f, 0.07985630f, 
    0.03985537f, 0.09096697f, -0.03807376f, -0.09403994f, 0.06096346f, -0.21262087f, -0.16598949f, 0.19667754f, 
    0.09746865f, 0.00699699f, -0.73435992f, 0.03198076f, 0.07310723f, -0.00901456f, 0.32605702f, -0.21712624f, 
    -0.15679480f, 0.05518232f, 0.39244583f, 0.01565394f, -0.13477010f, -0.07889853f, 0.07852294f, 0.06970612f, 
    0.19240847f, 0.24048218f, 0.04335063f, -0.01627904f, -0.14014637f, -0.26839945f, 0.21498014f, 0.24005659f, 
    -0.02244605f, -0.18331490f, -0.18835729f, 0.42381874f, -0.66224498f, 0.00872427f, 0.45565024f, 0.35164347f, 
    -0.28544289f, 0.08335424f, -0.16668323f, 0.17141496f, -0.33341449f, -0.13462923f, -0.01270395f, 0.01067037f, 
    -0.29275045f, -0.04942378f, -0.12555085f, 0.40386063f, 0.12509952f, -0.17153797f, -0.12896997f, 0.23311049f, 
    -0.16144782f, -0.00909101f, -0.22152750f, -0.18168093f, 0.06913219f, -0.21342014f, 0.00955730f, 0.28619954f, 
    -0.60646200f, 0.21714360f, -0.49053597f, -0.28776863f, 0.18336879f, -0.07971410f, 0.05905791f, 0.06377800f, 
    0.28419822f, 0.19385915f, -0.01186720f, -0.27796835f, 0.14620402f, 0.23367274f, -0.18708305f, 0.12589063f, 
    0.06443275f, 0.22898936f, 0.10857884f, -0.14668272f, -0.02961419f, 0.15935466f, -0.33017001f, 0.02198601f, 
    0.18420702f, 0.13797332f, -0.33397505f, -0.36014619f, 0.32816660f, 0.43336698f, -0.37762162f, 0.47289848f, 
    -0.16007456f, 0.20807630f, -0.33057106f, 0.02083372f, 0.06741615f, 0.09194329f, -0.20918579f, -0.09069370f, 
    -0.06402285f, 0.28866360f, 0.06830733f, -0.26640821f, 0.21803823f, -0.17254697f, 0.45640108f, -0.29002210f, 
    -0.25053775f, 0.00648003f, 0.04208890f, 0.37749347f, 0.04462776f, -0.36574635f, 0.20406786f, -0.19263752f, 
    0.04821471f, -0.13545814f, -0.00595145f, -0.05971305f, 0.31746525f, 0.21476017f, -0.32564062f, -0.09621454f, 
    -0.01249575f, -0.21384314f, 0.01663083f, 0.11720388f, 0.25767156f, 0.10813595f, -0.12150556f, -0.02265928f, 
    -0.05004051f, -0.43829003f, -0.39473772f, -0.68090296f, -0.06810150f, -0.19229090f, 0.27293098f, 0.40473676f, 
    0.19098125f, 0.16313784f, -0.11778404f, 0.07941239f, -0.21211661f, 0.51704168f, 0.02028059f, 0.09135558f, 
    -0.01776718f, -0.09197269f, 0.23017919f, -0.20617469f, -0.16033992f, 0.00418200f, -0.20675538f, 0.09818101f, 
    0.10816500f, 0.34181470f, -0.21582673f, 0.04605323f, 0.33177063f, -0.14750323f, 0.18683569f, 0.17017478f, 
    0.05751101f, 0.19547738f, 0.11452121f, 0.16717860f, -0.10797622f, -0.20363267f, 0.14435427f, -0.05975092f, 
    0.02481251f, -0.15309469f, 0.10851020f, 0.01024588f, 0.12787403f, -0.01108758f, 0.00378641f, 0.09020448f, 
    -0.22324705f, -0.83746237f, -0.79411811f, -0.18204290f, 0.49457327f, 0.62072855f, 0.48526257f, 0.44805002f, 
    0.32923126f, 0.01756093f, -0.20386262f, -0.10690990f, -0.01738107f, 0.22303812f, -0.12025057f, -0.20913300f, 
    -0.03898202f, 0.17809224f, -0.26627105f, -0.18982057f, -0.05512439f, 0.04302189f, 0.05894183f, -0.02282019f, 
    0.03751349f, 0.27361959f, 0.83624947f, -0.35939020f, 0.06813296f, 0.35108826f, -0.22600777f, 0.00719172f, 
    0.33652100f, -0.11919399f, -0.14845407f, -0.29240742f, -0.11354414f, -0.03221269f, -0.23967968f, -0.35439914f, 
    0.16547443f, 0.05823401f, -0.21325098f, -0.23296756f, 0.25169039f, 0.00500110f, -0.32894745f, -0.18839084f, 
    -0.40167943f, -0.33414194f, -0.56975001f, 0.41889605f, -0.16133784f, -0.95562506f, -0.63301259f, 0.55393398f, 
    0.46127161f, 0.57251978f, 0.01642878f, -0.49480790f, 0.32160175f, 0.00452799f, 0.23270747f, -0.15730551f, 
    -0.49785379f, 0.02824042f, 0.27011210f, -0.12164752f, 0.12942047f, 0.14662533f, 0.00538994f, 0.19162968f, 
    -0.18917327f, 0.00152798f, -0.25469306f, -0.17042056f, -0.77387708f, 0.40038678f, -0.00151205f, -0.39425382f, 
    -0.08663838f, 0.03980910f, 0.05235002f, -0.09291860f, 0.23840536f, 0.19963290f, 0.07891978f, -0.17024791f, 
    0.05814297f, 0.15210590f, 0.09156012f, 0.12225894f, -0.29860106f, -0.16990139f, -0.01976904f, -0.43820477f, 
    0.06367639f, 0.27827746f, -0.05763588f, 0.12875557f, 0.31583509f, -0.84605974f, 0.27252322f, -0.47898224f, 
    -0.28144893f, 0.04529995f, -0.17954151f, 0.16407703f, -0.39859882f, -0.00594622f, 0.72363353f, 0.12660900f, 
    0.38649240f, 0.16467731f, 0.07139650f, -0.22881797f, 0.19680029f, 0.12280633f, -0.17621423f, -0.14006045f, 
    0.19643213f, -0.03433703f, 0.26281583f, 0.04703832f, -0.18744379f, -0.11569404f, 0.30316335f, -0.21078598f, 
    -0.20144618f, -0.42424139f, 0.23144193f, -0.17056558f, -0.04651038f, -0.20932879f, -0.05943527f, 0.10901520f, 
    0.08147102f, 0.68512225f, -0.17478818f, -0.47722948f, 0.15175909f, -0.57493925f, 0.05648196f, -0.23976272f, 
    -0.25249809f, 0.08964603f, -0.14794920f, 0.03669952f, 0.04774797f, 0.29851741f, 0.07161845f, 0.23203754f, 
    0.35364509f, -0.10389117f, -0.40016299f, -0.27921867f, -0.08897148f, 0.34130102f, -0.25969118f, -0.40109882f, 
    0.60092252f, -0.27981153f, 0.54839933f, -0.22157484f, -0.25910574f, -0.17922528f, 0.27224344f, 0.20731376f, 
    -0.05069519f, -0.13296984f, -0.04481999f, 0.06730372f, -0.16372646f, 0.21673849f, -0.15867287f, 0.22826359f, 
    -0.31199861f, -0.38716644f, -0.08640306f, -0.35713318f, 0.15251966f, -0.25454259f, -0.47113967f, -0.17991129f, 
    -0.16736275f, 0.00861842f, -0.17313416f, -0.25541565f, -0.09705788f, 0.46508279f, -0.33289477f, 0.12602523f, 
    -0.12174707f, -0.32096028f, -0.21611585f, -0.41468859f, 0.00340762f, 0.18977335f, 0.30855867f, 0.11548275f, 
    -0.12602143f, 0.47679722f, -0.11790895f, -0.14451402f, -0.07907268f, -0.24393471f, -0.13565704f, 0.30713218f, 
    -0.07161704f, -0.01196781f, -0.40205336f, -0.15698530f, 0.33780959f, -0.19773316f, -0.17347190f, -0.02576013f, 
    0.25458950f, 0.20848840f, 0.34544182f, -0.05506740f, -0.31115380f, 0.08184152f, -0.00756753f, -0.20588012f, 
    -0.29304817f, 0.19729592f, -0.68360370f, -0.34875244f, -0.02691177f, 0.20669404f, 0.48935404f, 0.20193563f, 
    0.08798820f, -0.51660961f, -0.30034128f, 0.51746637f, -0.05462927f, -0.01104003f, 0.14234233f, -0.00279923f, 
    -0.37037653f, 0.08851138f, 0.06927925f, -0.37642714f, -0.16670296f, 0.10605848f, -0.31504986f, -0.20750399f, 
    -0.31022203f, -0.19217505f, -0.55006307f, -0.58117443f, -0.07565410f, -0.31479129f, -0.04526511f, 0.06180244f, 
    -0.27060646f, -0.06092778f, -0.36355653f, 0.07319263f, 0.05689870f, 0.02768082f, -0.13069019f, -0.04341862f, 
    -0.07759745f, -0.41444719f, -0.02195587f, -0.02263955f, 0.12073458f, -0.09860483f, -0.06121412f, 0.12845647f, 
    0.33010042f, 0.32203725f, 0.01035232f, 0.25976852f, -0.51068580f, 0.19577082f, 0.00099994f, 0.19367158f, 
    0.15336671f, 0.19430171f, 0.08168156f, 0.16599315f, 0.14426373f, -0.34575126f, -0.11770143f, 0.18538317f, 
    0.10009367f, 0.00520236f, -0.07770582f, -0.07282792f, -0.20436938f, -0.21931331f, -0.16180153f, -0.09622761f, 
    -0.16539201f, 0.20214489f, -0.08487002f, -0.30906591f, -0.31456742f, -0.86710006f, -0.52689451f, -0.47509232f, 
    -0.19712943f, -0.73445767f, 0.52751797f, 0.48064125f, -0.17417681f, -0.56142437f, 0.23994042f, -0.09450878f, 
    -0.05370549f, -0.08525597f, -0.06520517f, 0.43979079f, -0.14629288f, -0.00529604f, -0.19562957f, -0.25187364f, 
    -0.30151483f, 0.03806006f, -0.19978492f, 0.19219625f, -0.05038439f, -0.03298944f, 0.34972993f, -0.48453331f, 
    -0.27498716f, 0.52616459f, -0.71429646f, 0.29090455f, -0.62252432f, -0.85798830f, -0.38080597f, -0.49391627f, 
    -0.15123415f, -0.00474996f, -0.24185653f, -0.30589664f, -0.42807662f, -0.10895574f, 0.21775950f, -0.05892042f, 
    -0.15675233f, -0.16277125f, -0.22281055f, 0.12408819f, -0.22261955f, -0.25153124f, 0.00947520f, 0.34113136f, 
    0.94698900f, -0.00064632f, -0.47032449f, -0.40861610f, -0.44732550f, 0.05234934f, 0.18287303f, -0.16142632f, 
    -0.33124292f, -0.27156383f, 0.04048968f, 0.58600616f, 0.26964700f, -0.06917102f, 0.14749716f, -0.16784956f, 
    -0.21811038f, -0.02666920f, -0.24404871f, 0.06397207f, -0.03130456f, -0.05203053f, -0.00105731f, -0.06409395f, 
    -0.38992390f, -0.50696045f, -0.30544761f, 0.31161740f, -0.14508043f, -0.16499577f, -0.29767138f, -0.03734304f, 
    0.60342604f, 0.16649374f, 0.02361407f, -0.03024374f, -0.04872335f, -0.12900826f, -0.02785362f, 0.09040481f, 
    -0.12473660f, -0.08319851f, -0.17990218f, -0.29081407f, -0.25371400f, -0.24978454f, -0.27154455f, -0.49881285f, 
    -0.42898461f, 0.42690766f, -0.43209672f, -0.61917353f, -0.45457110f, 0.04643161f, -0.07772087f, 0.25559366f, 
    -0.12068710f, 0.47182822f, -0.08527955f, 0.21357617f, 0.03704397f, 0.09681202f, 0.29297665f, 0.03492948f, 
    -0.35678259f, -0.33041400f, -0.27158877f, 0.33583644f, -0.10640599f, 0.18875645f, 0.28619242f, -0.25625172f, 
    -0.04366113f, -0.12518479f, -0.30201447f, 0.34473032f, -0.28736567f, -0.40123436f, 0.04576402f, -0.72784066f, 
    -0.27210352f, 0.68305856f, -0.34765860f, -0.50520957f, -0.14090627f, 0.00911811f, -0.43030104f, 0.01337763f, 
    -0.24273321f, 0.03328913f, -0.54345059f, -0.26467282f, -0.25468224f, -0.29174784f, 0.06047549f, 0.04361948f, 
    -0.07244411f, -0.13142444f, -0.08012217f, -0.47910875f, 0.53987628f, 0.45777580f, -0.23897800f, 0.09306353f, 
    0.06415006f, 0.12359093f, -0.34726200f, 0.25153238f, -0.15380202f, 0.12349950f, -0.11906102f, -0.13159171f, 
    -0.39651066f, 0.16191420f, 0.06171475f, 0.01603034f, 0.14990953f, 0.27564487f, 0.05050387f, 0.06661789f, 
    -0.07975596f, -0.10084712f, -0.07775343f, -0.37446523f, -0.25206748f, -0.01725162f, -0.54982954f, -0.55145657f, 
    0.03831921f, 0.03016725f, -0.11845281f, 0.08403952f, 0.03328039f, -0.41990870f, -0.07250253f, -0.32959372f, 
    -0.14506705f, -0.04627325f, -0.14574981f, -0.43069702f, -0.26631024f, -0.11030393f, -0.26531976f, 0.08228819f, 
    0.07367708f, -0.01823624f, 0.24352653f, -0.16952281f, 0.12446921f, -0.34970284f, -1.01323164f, 0.13275710f, 
    0.81637096f, 0.34668022f, -0.15941893f, 0.34966281f, -0.48973066f, -0.50626612f, -0.86833394f, -0.07339554f, 
    0.03909238f, 0.26468161f, 0.31685665f, -0.15204820f, -0.09370554f, -0.05398936f, -0.11887757f, 0.26155192f, 
    0.30390796f, -0.12117873f, 0.06575605f, 0.11537200f, -0.20477231f, -0.27431291f, -0.71170360f, -0.11623195f, 
    -0.45151272f, -0.50927162f, -0.70691168f, 0.20873177f, -0.34434801f, -0.08479821f, -0.07163368f, 0.03480606f, 
    -0.01307370f, -0.08146148f, 0.38539642f, -0.20499764f, -0.03966933f, 0.24034730f, -0.09454022f, -0.02466674f, 
    0.01696673f, 0.05066261f, -0.13200231f, 0.27685630f, -0.08403224f, -0.47124469f, 0.12273361f, 0.38225338f, 
    0.70019907f, -0.55848157f, 0.08188805f, -0.78846794f, -0.54338837f, -0.42938954f, 0.03106065f, 0.18178870f, 
    0.23557316f, 0.01563814f, -0.09633856f, -0.06821201f, 0.42102537f, -0.25354445f, 0.21070504f, -0.06597087f, 
    0.06375810f, 0.20260189f, -0.25312126f, -0.12427808f, -0.07832073f, -0.36155218f, -0.22844400f, 0.27936876f, 
    0.49827120f, 0.41464508f, 0.30691832f, -0.17274100f, -0.17161591f, -0.41195074f, -0.02765035f, 0.06904224f, 
    0.27473071f, -0.27154765f, 0.18403788f, -0.20175149f, 0.03184026f, 0.28541541f, 0.16767552f, 0.15844977f, 
    0.04387583f, -0.20475839f, -0.20214494f, -0.38075152f, -0.18293621f, 0.30163616f, 0.21314178f, 0.10236127f, 
    -0.20313524f, 0.01086643f, 0.06404641f, 0.17175311f, -0.26086429f, -0.34897748f, 0.08997903f, 0.34633777f, 
    0.23518060f, 0.34969464f, 0.13669649f, -0.17484744f, -0.19212262f, -0.09253905f, -0.20593804f, -0.01655549f, 
    -0.19469367f, 0.09474384f, 0.00955932f, -0.24753593f, 0.16130689f, 0.20105462f, 0.01185588f, 0.15674098f, 
    0.00070299f, 0.39198402f, 0.21872066f, 0.30948815f, 0.13420933f, 0.34469324f, 0.22382665f, -0.24101023f, 
    -0.20177270f, 0.02745267f, 0.36575907f, 0.31226277f, 0.23622827f, -0.12678495f, -0.19585437f, -0.12401163f, 
    -0.02433724f, -0.07017556f, -0.02454069f, -0.04013006f, -0.07939734f, 0.01207815f, 0.01041384f, -0.12051808f, 
    -0.16281971f, 0.04119508f, -0.10828996f, 0.76254314f, 0.07010911f, 0.16929556f, -0.01936180f, 0.13916589f, 
    0.32679352f, -0.02173086f, -0.08870766f, -0.08867732f, 0.16353691f, -0.23174503f, -0.16058041f, 0.01735540f, 
    -0.10365292f, -0.10200413f, 0.01323038f, 0.06964528f, 0.11336536f, -0.28227970f, -0.31700450f, 0.10590260f, 
    -0.21171732f, -0.36609638f, 0.19788602f, 0.06934722f, -0.94664097f, -0.44863105f, -0.43963325f, -0.55979359f, 
    -0.42319217f, 0.43360662f, 0.09472512f, 0.00334752f, 0.35155642f, 0.75503457f, -0.32514229f, 0.01321766f, 
    -0.34634617f, -0.29754612f, -0.41490960f, -0.00194214f, 0.20488203f, 0.12872419f, 0.03169960f, 0.31664506f, 
    -0.00134035f, -0.01730767f, 0.00561494f, 0.13332549f, -0.06376777f, -0.92838347f, -0.29657713f, -0.33807465f, 
    -0.56371146f, -0.61013550f, 0.56629336f, 0.28428903f, 0.35440364f, 0.40937251f, 0.32589033f, 0.02782710f, 
    0.19639988f, 0.04596598f, 0.14277487f, -0.24857995f, -0.08976058f, 0.03113451f, -0.17352985f, -0.04405939f, 
    0.04475525f, -0.12292037f, -0.12018799f, 0.09993796f, 0.01230700f, -0.24200407f, -0.49227473f, -0.02328383f, 
    -0.20544128f, -0.53379977f, -0.60826778f, 0.00980719f, -0.05288150f, -0.07095268f, 0.07396397f, 0.30567566f, 
    -0.22096545f, -0.33814654f, -0.17079629f, -0.27262777f, 0.17603086f, 0.31111917f, -0.05590282f, 0.15777905f, 
    0.26363137f, -0.09457472f, -0.30645850f, -0.38501590f, -0.24767309f, -0.01777473f, -0.24649321f, 0.55380368f, 
    0.18676431f, 0.45533398f, 0.36214739f, 0.25561807f, -0.44311574f, -0.36001632f, -0.40902555f, -0.30683315f, 
    -0.08621307f, -0.05940651f, 0.20542264f, 0.26192236f, -0.15671174f, -0.27147987f, 0.26487559f, -0.14980613f, 
    -0.03522823f, 0.30780232f, -0.15217441f, -0.06209304f, 0.10869947f, -0.05802923f, -0.12180473f, 0.21972808f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.37928098f, -0.49616030f, 0.36236045f, 0.05262229f, -0.06761117f, -0.17925921f, 0.14522994f, -0.03414838f, 
    0.36363378f, 0.28341201f, -0.06663635f, -0.46794882f, -0.12759078f, -0.08137250f, 0.12266599f, -0.01947973f, 
    0.30956447f, 0.26631540f, 0.10394891f, 0.17396337f, 0.12279286f, -0.03026260f, -0.16731972f, 0.22196493f, 
    0.23788238f, -0.19875441f, 0.16200967f, 0.08467581f, 0.23498961f, 0.19498338f, 0.06759208f, 0.00741892f, 
    -0.16285366f, 0.34305486f, -0.08948027f, -0.00666446f, 0.01522428f, -0.06363432f, -0.11259045f, 0.08510548f, 
    -0.00333186f, 0.11457469f, 0.02664650f, -0.32791850f, -0.09142699f, -0.08073967f, -0.18599354f, -0.03368498f, 
    -0.16632721f, 0.00055429f, 0.07727112f, 0.08915128f, -0.30017555f, 0.28788221f, 0.03607752f, 0.09404571f, 
    0.10039726f, -0.12625049f, -0.04751502f, 0.15897416f, -0.21209292f, -0.02871891f, 0.01889750f, 0.14525837f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.32847932f, -0.02028169f, 0.08545767f, -0.02143199f, -0.04705515f, -0.05618596f, 0.03650496f, -0.00436716f, 
    -0.04966992f, -0.07802518f, -0.04473422f, -0.22179689f, 0.28175887f, 0.28985569f, -0.12605445f, -0.03966420f, 
    0.12136579f, 0.19325575f, 0.14802276f, 0.03651963f, -0.02637750f, 0.02335914f, 0.02247537f, -0.04437056f, 
    -0.06817431f, 0.10410352f, 0.07236493f, -0.04664943f, -0.03890173f, -0.04718733f, 0.05154067f, -0.06413707f, 
    -0.05792275f, -0.10513738f, -0.01258463f, 0.01123029f, -0.01503421f, 0.08519103f, 0.02863067f, -0.01910476f, 
    -0.12770259f, -0.01763205f, 0.09827714f, -0.09131857f, -0.01635376f, 0.00845475f, -0.04926652f, -0.02081874f, 
    0.42705444f, 0.26103291f, -0.13659891f, -0.02425730f, 0.06690667f, -0.05594887f, 0.05878210f, -0.01436353f, 
    -0.06385328f, -0.05547352f, 0.04036889f, 0.01907016f, 0.27964315f, 0.18375213f, -0.21044263f, -0.21778603f, 
    0.05652365f, -0.00655144f, -0.00420603f, 0.06681426f, 0.00795628f, 0.02604265f, 0.03702409f, 0.02806450f, 
    0.04392018f, -0.78975797f, -0.12534644f, 0.05720238f, 0.01081526f, -0.00449212f, -0.09967753f, 0.11347765f, 
    -0.12296312f, -0.00600860f, -0.19264542f, -0.01878604f, -0.03326288f, 0.08578353f, 0.03990234f, -0.00915188f, 
    -0.01064918f, -0.01009751f, -0.03267117f, 0.02067756f, 0.03051720f, 0.02250917f, 0.00768685f, 0.01669326f, 
    -0.11318258f, -0.26707354f, -0.07678512f, 0.11071283f, 0.10593286f, -0.04873009f, -0.07767848f, -0.29642478f, 
    -0.09704281f, -0.15549555f, -0.12000164f, -0.02680473f, 0.14959104f, 0.35092524f, 0.25429532f, -0.35187706f, 
    -0.07696673f, 0.01668377f, 0.03741483f, -0.03424129f, 0.00517855f, -0.18838319f, -0.05049616f, -0.15620825f, 
    0.09209742f, 0.15300259f, 0.04365987f, 0.00002599f, -0.00992489f, -0.02448014f, -0.03875549f, 0.02388053f, 
    0.04303018f, -0.08423800f, -0.00448986f, 0.02854886f, 0.41959211f, 0.26350129f, -0.07782152f, -0.22040758f, 
    0.11403595f, 0.10418626f, 0.18732263f, 0.07254627f, -0.01482692f, 0.00045823f, -0.06327856f, -0.13427107f, 
    0.44934762f, -0.47198191f, -0.18243112f, -0.01303622f, 0.01521849f, -0.01869782f, 0.08240919f, 0.09215365f, 
    0.05859292f, 0.14685252f, 0.05790138f, 0.29490316f, -0.02527091f, 0.00423354f, -0.07760844f, 0.09411394f, 
    -0.16263062f, -0.14003861f, -0.11961091f, -0.01125935f, -0.03368812f, 0.04255081f, -0.01776508f, 0.02889095f, 
    0.35027775f, 0.39879969f, 0.30659124f, -0.32414436f, 0.09273440f, 0.06931104f, -0.03414982f, -0.11727720f, 
    -0.05428547f, -0.11283160f, -0.22656764f, -0.15063603f, 0.08588983f, -0.05326090f, -0.10065940f, -0.00940895f, 
    0.08583184f, 0.10648916f, -0.10428488f, -0.01912068f, -0.07068247f, -0.17180347f, -0.03903001f, -0.04799743f, 
    -0.13743237f, -0.53042430f, -0.39554206f, 0.08160096f, -0.02816171f, 0.09037561f, -0.10606860f, -0.13812003f, 
    -0.01422640f, 0.09940381f, -0.21683660f, 0.03902441f, -0.14950961f, -0.02328571f, 0.06531868f, -0.12893592f, 
    -0.05011373f, 0.00652219f, 0.02740286f, -0.00786841f, 0.01124084f, -0.25619245f, -0.09106830f, -0.06294047f, 
    -0.02810514f, -0.02681976f, 0.13273129f, -0.04295219f, -0.16833319f, -0.08844306f, -0.17883591f, 0.11700697f, 
    -0.00008551f, -0.03698879f, -0.02974558f, -0.01816221f, 0.14499465f, 0.00499351f, 0.06530992f, -0.11089481f, 
    -0.03279177f, -0.07908063f, -0.06231928f, -0.13223256f, -0.02520127f, -0.00759780f, -0.10191597f, 0.00446396f, 
    0.03936596f, 0.19243264f, 0.05866937f, -0.16927531f, 0.01856110f, -0.02326142f, -0.11244055f, -0.11812744f, 
    0.03400034f, -0.04720823f, -0.20328274f, 0.00426318f, 0.22332482f, 0.01762950f, -0.03994928f, -0.07485414f, 
    -0.12117948f, -0.09961295f, -0.06583817f, -0.11603983f, -0.04590261f, 0.03215948f, -0.04115340f, 0.03539541f, 
    0.18013118f, 0.07837366f, 0.04139964f, 0.08170234f, 0.05618757f, 0.00219365f, -0.02324411f, -0.05206788f, 
    -0.08409175f, -0.00953542f, 0.02283609f, 0.17205526f, 0.06384470f, -0.01247459f, 0.23606959f, -0.26229155f, 
    0.01476004f, 0.08756494f, 0.10057722f, 0.06638072f, 0.02229553f, -0.06185468f, -0.14644659f, -0.06742095f, 
    -0.07753775f, -0.04120611f, 0.01982678f, -0.18163368f, -0.01626481f, -0.11823151f, -0.01787550f, -0.01555578f, 
    -0.10025305f, -0.05342976f, -0.14261886f, -0.14667882f, 0.36602068f, 0.20901473f, -0.17279594f, -0.23844402f, 
    -0.01206305f, -0.05426845f, -0.07254444f, 0.09877601f, 0.02733700f, 0.04729480f, 0.07923304f, 0.02907138f, 
    -0.15831019f, 0.16382453f, 0.15318960f, -0.06438251f, -0.05698814f, -0.02910961f, 0.07760113f, -0.01768501f, 
    -0.14650325f, 0.01650332f, -0.08397415f, -0.22968866f, -0.02026340f, -0.37647033f, 0.14842315f, -0.16061392f, 
    -0.03334300f, -0.23801845f, 0.03891249f, -0.03566106f, 0.01460381f, -0.01241326f, -0.00840142f, 0.02997394f, 
    0.04890887f, 0.05664479f, 0.02023359f, -0.05537769f, -0.30348924f, 0.01143009f, -0.17247294f, 0.00872697f, 
    0.00510195f, -0.04872270f, 0.02818319f, -0.03602555f, -0.33699000f, -0.11304625f, 0.05244464f, -0.21400861f, 
    -0.15640543f, 0.01962965f, -0.01561033f, -0.02957639f, -0.05153751f, -0.07482964f, 0.12131941f, -0.02902119f, 
    -0.06224598f, 0.04974496f, -0.06242755f, 0.05810506f, -0.05016812f, -0.04019113f, 0.00826679f, -0.03843094f, 
    -0.03974175f, -0.00680521f, -0.06611800f, -0.05774967f, 0.10369577f, -0.00123311f, 0.02620597f, 0.00783010f, 
    0.09023835f, 0.01355236f, -0.25069135f, 0.07862255f, -0.03280939f, -0.02104328f, 0.02156409f, 0.02445247f, 
    -0.02777750f, 0.01797693f, 0.02922193f, 0.03120050f, -0.00026166f, 0.02212004f, 0.06882998f, 0.03992549f, 
    -0.02292543f, 0.01592155f, -0.01044598f, 0.00822038f, 0.21114284f, 0.00032741f, -0.38489202f, -0.13139184f, 
    -0.00634781f, 0.01701169f, 0.07864384f, -0.07843214f, -0.08521374f, -0.16051094f, -0.11878237f, -0.27979499f, 
    -0.20548542f, -0.23848873f, 0.00312480f, -0.07397807f, 0.03888161f, 0.00642744f, -0.00208849f, -0.02211946f, 
    -0.17552179f, 0.04541106f, 0.13047309f, 0.17058535f, -0.03118220f, 0.12216599f, -0.25663817f, 0.06074776f, 
    0.01881918f, 0.04695005f, -0.01047117f, -0.09372164f, -0.02734222f, -0.02400408f, -0.10095230f, -0.15541385f, 
    -0.05117108f, -0.14085808f, 0.07281961f, -0.10707630f, -0.00570366f, 0.07495324f, -0.00782084f, -0.00642559f, 
    -0.02785743f, -0.11128395f, -0.12313724f, -0.13798186f, 0.11961870f, 0.13093293f, 0.04841514f, -0.00685342f, 
    -0.02215790f, 0.07319299f, 0.05196384f, -0.06073640f, -0.10464806f, 0.01915256f, 0.02179516f, 0.04463581f, 
    0.05816997f, 0.24067131f, -0.20416087f, -0.04894331f, -0.02971543f, 0.01464505f, 0.01895148f, -0.07903069f, 
    -0.01263420f, -0.01951376f, 0.01769449f, -0.19626290f, 0.02021395f, 0.09282667f, -0.18086551f, -0.10235481f, 
    -0.00252262f, -0.05523426f, -0.15823403f, -0.12914483f, -0.03261786f, -0.04028625f, 0.07703203f, -0.12056319f, 
    0.19829673f, 0.13346289f, 0.04460050f, -0.16529693f, 0.11368013f, 0.11632658f, 0.04888425f, -0.11422101f, 
    -0.01282146f, -0.04371659f, -0.00079384f, -0.10265576f, -0.00899884f, -0.16333233f, -0.04850088f, -0.05484400f, 
    -0.07691333f, -0.13349070f, 0.08909619f, -0.04149712f, -0.03470764f, 0.06663560f, 0.02640062f, -0.06004162f, 
    0.20635590f, 0.07377435f, -0.13049459f, -0.01361060f, -0.05456276f, 0.03272967f, 0.07976606f, -0.06095298f, 
    -0.05446784f, 0.00437628f, 0.05071186f, 0.00774039f, 0.20660977f, 0.23644489f, 0.08882409f, -0.32911566f, 
    0.09499273f, 0.09507074f, -0.01277356f, -0.08638213f, 0.01808634f, -0.02835888f, 0.00232287f, -0.03742253f, 
    -0.24621846f, -0.09937002f, -0.05042355f, 0.03707203f, -0.01369904f, 0.04300726f, 0.03591134f, 0.02559197f, 
    -0.16493064f, 0.05783077f, 0.12561369f, -0.00662610f, 0.22653224f, 0.15361437f, -0.16740331f, -0.14223695f, 
    0.01110203f, 0.06662561f, -0.10755149f, -0.07225350f, -0.16581939f, -0.09775835f, -0.01291362f, 0.04796726f, 
    0.27744529f, 0.14882015f, -0.17276075f, -0.25413495f, 0.05264464f, 0.07437492f, 0.06354375f, 0.00684888f, 
    -0.06988188f, 0.02760560f, 0.02333545f, -0.03665776f, -0.03721155f, -0.39399740f, -0.09037130f, 0.05657110f, 
    -0.04453214f, -0.17071100f, -0.02397659f, -0.03069096f, 0.05607723f, 0.01741437f, -0.04147123f, -0.04530161f, 
    0.00302527f, 0.11271653f, 0.12123543f, -0.08441044f, 0.02689721f, -0.00945672f, 0.02296313f, -0.03080663f, 
    -0.08053032f, 0.17862679f, 0.13713421f, 0.23001865f, 0.07392763f, -0.02139418f, -0.33979368f, 0.05486647f, 
    0.09571727f, -0.02360028f, -0.02280974f, 0.01162670f, 0.03906860f, -0.05434824f, -0.23969942f, 0.00600368f, 
    0.06495110f, 0.14182504f, 0.05352644f, 0.09628291f, -0.12096625f, 0.13065287f, 0.00146806f, -0.03889721f, 
    -0.03997463f, -0.14161223f, -0.20263931f, -0.02793181f, -0.12937048f, 0.09383545f, 0.00696896f, 0.06704152f, 
    -0.01519757f, 0.02829567f, -0.04044851f, -0.06089197f, 0.04369576f, 0.01831815f, 0.01621269f, 0.02430846f, 
    0.18354023f, 0.06657074f, -0.10522864f, -0.13098204f, 0.04146152f, 0.17135502f, -0.09771296f, 0.06987001f, 
    -0.05037376f, -0.13340966f, -0.09693933f, -0.06381634f, 0.46640232f, -0.09131087f, -0.03332751f, -0.23406316f, 
    0.13051875f, -0.06055868f, 0.07494475f, -0.04011057f, -0.03890857f, -0.02303668f, -0.01738244f, -0.00850942f, 
    0.24565640f, 0.10253228f, -0.03148255f, -0.19322772f, 0.09831473f, 0.14645492f, -0.01016861f, -0.06775473f, 
    -0.02283490f, 0.02896588f, 0.02802879f, 0.03611230f, -0.04771302f, -0.04566356f, 0.05145295f, -0.05576127f, 
    0.00399270f, 0.01521641f, -0.09146197f, -0.14519303f, -0.11772008f, -0.07491475f, 0.00900159f, -0.06147962f, 
    -0.32715926f, -0.73610806f, -0.06666947f, -0.02384895f, 0.02861320f, 0.07767108f, 0.03599707f, -0.04688524f, 
    -0.00958220f, -0.03148434f, -0.03993443f, -0.00872570f, 0.04548427f, 0.02990669f, 0.05620604f, 0.04942432f, 
    0.00377835f, 0.06810056f, -0.00820669f, 0.01985991f, -0.03991163f, 0.03701572f, -0.04441495f, -0.32231274f, 
    -0.47717068f, -0.05879669f, 0.00474577f, 0.00958778f, -0.00650809f, 0.06421670f, 0.03082502f, 0.04112137f, 
    -0.03528685f, -0.00459453f, -0.02126705f, -0.00282525f, -0.37099823f, -0.19801717f, -0.25124642f, 0.25602669f, 
    0.03879715f, 0.03782235f, -0.02306354f, 0.05649047f, 0.02121447f, -0.01573895f, 0.01977335f, 0.01852513f, 
    0.21837300f, 0.12044585f, 0.03189303f, -0.16544789f, 0.04882202f, 0.19473374f, 0.11244625f, 0.16733479f, 
    0.01186013f, 0.03928383f, 0.05470249f, -0.02552656f, -0.05930947f, -0.16468649f, 0.03200317f, 0.00596205f, 
    0.05965310f, 0.14843260f, -0.00937036f, 0.02659745f, -0.01597732f, 0.09265450f, -0.00544080f, 0.04766198f, 
    0.01442260f, 0.18400240f, 0.06271292f, -0.08829185f, 0.05653506f, 0.16975251f, 0.04304272f, 0.08089225f, 
    0.00190251f, 0.01162013f, 0.07285251f, 0.05972806f, -0.13942856f, 0.08721723f, -0.24999562f, -0.12853822f, 
    -0.01694542f, -0.12181283f, -0.20166664f, -0.09057138f, -0.00485739f, 0.00026885f, 0.04094018f, 0.03148472f, 
    0.01534131f, 0.09509446f, 0.05274310f, 0.00050809f, 0.00943100f, -0.01679150f, -0.01472383f, 0.05230196f, 
    0.09119134f, 0.12234429f, -0.01418146f, -0.02253676f, 0.21278918f, 0.12081920f, 0.33122355f, 0.15335691f, 
    -0.06544710f, 0.06330431f, -0.06247446f, -0.03881351f, -0.03435205f, -0.01222270f, -0.00776629f, 0.07099008f, 
    0.10658525f, 0.13749976f, 0.06344607f, 0.20026807f, -0.06291164f, 0.03735720f, 0.01924887f, 0.10015547f, 
    0.21811694f, 0.06257501f, 0.07572190f, -0.03842892f, -0.04325127f, -0.05511881f, -0.02432188f, 0.03035978f, 
    0.15759872f, 0.03333967f, 0.02291626f, 0.04620298f, -0.07206530f, 0.03758769f, -0.01927560f, 0.05220609f, 
    -0.09016890f, -0.11564595f, -0.30151656f, -0.22614278f, -0.05080321f, -0.18924494f, 0.10698586f, 0.10431231f, 
    0.17803600f, -0.00352030f, -0.04950698f, -0.03237393f, -0.16682252f, -0.01080230f, 0.14875652f, 0.02427904f, 
    -0.00980046f, 0.05964017f, 0.02512096f, 0.03995242f, -0.02104451f, -0.00122267f, 0.05173798f, 0.02253756f, 
    -0.00037499f, -0.09920531f, 0.10338389f, -0.35743478f, -0.01433904f, -0.00554209f, -0.11827327f, 0.09930542f, 
    -0.01308317f, -0.04044619f, -0.09068793f, -0.08355576f, -0.06876484f, 0.07734616f, 0.03710547f, -0.00749982f, 
    0.00309664f, 0.02516223f, 0.01383595f, 0.01918112f, -0.04042016f, -0.00495713f, 0.00597749f, -0.02231797f, 
    0.07324538f, -0.33775625f, 0.20057808f, -0.37148818f, -0.00279277f, 0.12358469f, -0.08449156f, 0.14184414f, 
    0.07129946f, 0.17377043f, -0.09742896f, -0.02373316f, -0.30362535f, 0.25418669f, -0.21369661f, 0.05391182f, 
    0.04165912f, 0.01499161f, 0.09617186f, -0.01628636f, -0.01175968f, -0.07368723f, 0.16425024f, -0.03261419f, 
    -0.20479134f, -0.05637113f, -0.00342818f, -0.09510268f, -0.01474184f, 0.02117427f, 0.05840418f, 0.08240587f, 
    -0.10405713f, -0.20172207f, -0.09993827f, 0.10176282f, 0.53291684f, 0.29672256f, 0.07199118f, -0.09412016f, 
    0.04345119f, -0.14727919f, -0.05205956f, 0.05084576f, 0.11811251f, -0.04662246f, -0.00854913f, -0.07451008f, 
    -0.21351849f, -0.06484235f, 0.06426039f, 0.01592408f, -0.03444786f, 0.03035205f, 0.06294622f, -0.11595155f, 
    0.01558587f, -0.07751646f, -0.02523205f, -0.03473143f, 0.00048944f, -0.20148540f, -0.54041672f, -0.26881668f, 
    -0.05153069f, -0.02048227f, -0.08068734f, -0.21612404f, -0.09602974f, 0.05652802f, -0.09355152f, 0.04775328f, 
    -0.64726138f, -0.03277970f, -0.47060904f, 0.07908330f, 0.20151410f, -0.00258962f, 0.22188379f, -0.09780278f, 
    0.07743420f, 0.08608703f, -0.03087710f, -0.08602225f, -0.13859445f, -0.08516047f, 0.03471857f, -0.09425744f, 
    -0.07165784f, 0.06644791f, 0.07129777f, 0.05201297f, -0.14855567f, 0.00826915f, 0.10907042f, 0.04149580f, 
    0.68706167f, -0.25026125f, 0.20233142f, -0.17031647f, -0.00707975f, -0.09537207f, 0.13716580f, 0.00981719f, 
    0.06748808f, -0.03752689f, 0.04905489f, 0.20449178f, -0.09989922f, 0.29719624f, -0.09641640f, -0.23014812f, 
    -0.04733595f, 0.01778205f, -0.01033227f, 0.18687208f, -0.15477940f, 0.09515788f, 0.04835517f, -0.13518111f, 
    -0.27841085f, 0.06470415f, 0.05356964f, -0.11525798f, -0.05038437f, 0.04174542f, -0.07115632f, 0.08649669f, 
    -0.09161887f, -0.13662001f, 0.07231203f, 0.01125329f, -0.11027066f, -0.01620580f, -0.00233707f, -0.03986970f, 
    0.06105716f, -0.04279975f, 0.06026188f, 0.19089475f, 0.02829960f, -0.04471671f, 0.08658163f, -0.01552175f, 
    -0.30017865f, 0.02119274f, 0.05549039f, -0.10297197f, -0.07550000f, 0.03156825f, 0.03068572f, 0.15215641f, 
    -0.05898008f, -0.03512938f, 0.18180345f, -0.02749051f, -0.14775008f, -0.28515795f, 0.01012671f, -0.28606579f, 
    -0.04844437f, 0.00568177f, 0.01246656f, 0.13136479f, -0.08222689f, -0.09694462f, -0.16042574f, 0.08076686f, 
    0.00243432f, -0.07009526f, -0.03170855f, -0.01478469f, 0.00392235f, 0.09780581f, -0.09223041f, -0.09475762f, 
    0.28169391f, -0.16437851f, 0.18971449f, -0.11916142f, -0.30760127f, -0.01857185f, -0.26704508f, -0.27556056f, 
    0.00787149f, 0.09008864f, 0.06380887f, 0.09056578f, 0.01005920f, 0.03835632f, 0.09141666f, 0.04801067f, 
    -0.11289410f, 0.03817354f, 0.07638542f, -0.10718416f, 0.03724216f, 0.23293304f, -0.02298713f, -0.14531215f, 
    0.23076537f, 0.07905462f, -0.07888897f, 0.02814933f, -0.01118596f, 0.11119887f, 0.14057189f, 0.17751792f, 
    -0.04733161f, -0.02491302f, -0.03453796f, -0.11307426f, 0.01716318f, 0.00718565f, -0.00362512f, 0.04220097f, 
    -0.33955017f, -0.04973039f, 0.05219749f, -0.00351212f, 0.04814118f, 0.05165198f, -0.04575225f, 0.13562012f, 
    -0.15569904f, 0.02230653f, 0.00504170f, 0.00326343f, -0.09553816f, 0.30008572f, -0.01289930f, 0.12748955f, 
    -0.05145969f, 0.05028139f, -0.06661838f, -0.10752912f, -0.00166770f, 0.00472221f, -0.12049697f, 0.04220941f, 
    -0.08699583f, 0.04616532f, -0.02173628f, -0.11197279f, 0.13895236f, 0.03176639f, 0.07104123f, -0.02606932f, 
    -0.16218370f, -0.03039356f, 0.10915856f, 0.03050087f, -0.18188855f, 0.10766932f, 0.07813231f, 0.16246177f, 
    -0.00362490f, -0.03347024f, 0.02744663f, -0.07746325f, 0.03565599f, 0.08741051f, -0.14347865f, 0.15006733f, 
    0.22523241f, -0.07284259f, -0.04432008f, 0.11434735f, -0.07856387f, -0.01557915f, 0.08713771f, 0.03154017f, 
    -0.05776737f, 0.03453096f, 0.11636543f, -0.19772923f, -0.11311681f, -0.05971067f, 0.02269592f, -0.02909801f, 
    -0.01886606f, 0.14537254f, -0.01012788f, -0.38727960f, 0.02431677f, 0.03892051f, -0.01193318f, 0.00850304f, 
    0.05920368f, 0.07510778f, 0.13321498f, 0.11105785f, 0.00661913f, -0.03787146f, -0.04397541f, 0.00429155f, 
    0.03160100f, -0.06312684f, 0.04102171f, 0.06334730f, 0.02582932f, -0.10331504f, 0.17014346f, 0.17347935f, 
    0.00754122f, 0.01239087f, 0.04011671f, 0.03723281f, 0.24495578f, -0.05051186f, 0.00470482f, 0.11333719f, 
    0.18903024f, 0.00740859f, -0.03806689f, 0.00614254f, -0.03245137f, -0.01976217f, -0.06683248f, 0.03087933f, 
    -0.25278148f, -0.24545774f, 0.26907736f, -0.18508616f, 0.36558998f, -0.12196992f, -0.21595834f, -0.01576474f, 
    -0.03604982f, -0.04506137f, -0.07754557f, -0.05489640f, 0.10230885f, -0.26839885f, -0.06426513f, -0.04393776f, 
    -0.22726522f, -0.09812605f, 0.02773328f, 0.03724089f, 0.04959843f, 0.06952536f, 0.01170972f, 0.00820215f, 
    0.11176809f, -0.00743714f, 0.07730740f, -0.13672695f, -0.19249158f, -0.04636733f, -0.02279133f, 0.02910708f, 
    0.01294327f, 0.14552158f, -0.06783065f, -0.10383889f, -0.04966457f, -0.04386579f, -0.08587100f, 0.09757406f, 
    0.01104324f, -0.31279308f, -0.34314013f, 0.25687334f, -0.01166755f, 0.02046770f, 0.02722844f, 0.11550642f, 
    0.01612723f, -0.00871730f, -0.20767699f, 0.18498719f, 0.20397413f, -0.10718576f, -0.01087125f, -0.17010319f, 
    0.14454244f, 0.12234845f, -0.10248197f, -0.11943225f, 0.02363395f, -0.02891577f, -0.14388384f, 0.06086839f, 
    -0.01305401f, 0.01074748f, 0.05379152f, 0.21019420f, 0.10165362f, -0.01625783f, 0.11001519f, 0.14604138f, 
    -0.00310316f, 0.00744872f, 0.07309702f, -0.08762202f, 0.22248958f, -0.10153874f, -0.11161398f, -0.09835779f, 
    -0.05573425f, 0.04831063f, -0.02821649f, -0.29440981f, -0.00611891f, 0.00480140f, -0.07414690f, 0.09632183f, 
    0.28850731f, -0.00764549f, -0.19928183f, 0.05727142f, 0.07126309f, 0.03246829f, -0.00021119f, -0.01865865f, 
    -0.20506093f, -0.13451968f, -0.23684858f, -0.38070652f, 0.06210979f, 0.26727226f, 0.03694017f, 0.07479274f, 
    0.04187232f, 0.12633245f, 0.13817056f, -0.11431709f, -0.06255922f, 0.00012856f, -0.03657224f, -0.07004347f, 
    0.06019476f, 0.01580259f, 0.08479404f, 0.03513156f, 0.00335029f, -0.05119506f, -0.03695228f, -0.00131158f, 
    -0.41239473f, -0.13276495f, -0.28660813f, -0.20238687f, 0.15869898f, -0.00638589f, 0.35336870f, -0.00788523f, 
    0.14748605f, 0.10331377f, -0.05517488f, -0.03940540f, 0.01615058f, 0.02389888f, 0.06154848f, -0.06146439f, 
    0.11126988f, 0.07462379f, -0.15606537f, -0.03788225f, 0.10303444f, -0.19227293f, -0.15121381f, 0.00215379f, 
    0.05562201f, 0.00907736f, -0.01539799f, 0.03934533f, 0.17253278f, -0.38930374f, -0.01690445f, -0.14701441f, 
    -0.07093211f, 0.00041182f, 0.12719943f, -0.00358106f, -0.02932208f, -0.05825900f, 0.10010138f, 0.22682214f, 
    -0.23813337f, 0.04604270f, -0.12907055f, -0.06860472f, 0.00518670f, -0.02266315f, 0.04459651f, 0.00347504f, 
    -0.31062183f, -0.16001090f, -0.11691198f, -0.19499196f, 0.00444555f, -0.11324182f, -0.33382645f, -0.00181466f, 
    -0.02532419f, 0.02889293f, -0.01198671f, 0.03675498f, 0.04390428f, 0.11997402f, 0.10136045f, -0.10763982f, 
    -0.22805598f, -0.05454554f, 0.07200699f, -0.07537407f, -0.09809345f, 0.04629504f, -0.00594492f, 0.16197604f, 
    0.08669299f, 0.04150961f, -0.11319140f, 0.06199271f, 0.05885348f, -0.06891631f, 0.05703872f, 0.03064862f, 
    -0.05122343f, 0.09259126f, 0.15314272f, 0.04348875f, 0.05026415f, -0.07380486f, -0.00290404f, 0.02144738f, 
    -0.07857659f, 0.14636393f, 0.26200536f, 0.08083852f, 0.25573474f, -0.06734224f, 0.25549006f, 0.17650853f, 
    -0.00085430f, 0.01150723f, 0.01413869f, 0.00863470f, -0.15760234f, 0.04204443f, 0.03194605f, -0.26935911f, 
    -0.15911259f, 0.05588356f, 0.08252538f, 0.06401330f, -0.00916114f, -0.01512706f, 0.13958119f, 0.00467835f, 
    -0.10162642f, 0.20605589f, 0.06412559f, 0.10650515f, -0.04149277f, 0.07700590f, -0.22383113f, -0.18733108f, 
    -0.05042201f, 0.03130947f, 0.02377104f, -0.04150596f, -0.12614354f, -0.06983282f, 0.19466271f, -0.19749846f, 
    0.14072967f, -0.02043057f, -0.23249398f, -0.13422111f, 0.15119763f, -0.05596455f, -0.21381302f, 0.02897950f, 
    0.39536542f, 0.13723743f, 0.14036016f, -0.08402221f, 0.01238056f, -0.04740323f, 0.02337275f, 0.03829161f, 
    -0.04295118f, 0.07435032f, -0.08518139f, 0.08083773f, 0.02833646f, 0.02573076f, 0.08581623f, 0.07129122f, 
    -0.06066572f, 0.05851471f, 0.00065356f, -0.05404650f, -0.02090731f, 0.04110551f, -0.11210715f, 0.01158655f, 
    0.09427930f, 0.19338359f, 0.18675329f, 0.12066740f, -0.03401148f, 0.02840228f, -0.01459900f, -0.03102442f, 
    0.02215640f, 0.05093614f, 0.03285275f, 0.01761442f, 0.59253955f, 0.43343797f, 0.23691903f, 0.33894455f, 
    -0.02567620f, -0.00155436f, -0.00405063f, -0.01686521f, 0.01110054f, 0.01287684f, 0.02805596f, 0.12221657f, 
    0.33002779f, 0.25701666f, -0.08664947f, -0.14216980f, -0.12410922f, -0.09152623f, -0.18912901f, -0.07598422f, 
    -0.00696147f, -0.07523867f, -0.11896708f, -0.09907686f, 0.19911596f, -0.04207977f, -0.22922379f, -0.22142465f, 
    -0.05617998f, -0.00664718f, -0.02012781f, -0.02047596f, -0.00736564f, -0.04533905f, -0.08026402f, -0.02459282f, 
    0.07780619f, 0.13923596f, 0.02952289f, 0.01072419f, 0.14235471f, -0.04578390f, -0.33164102f, -0.24587665f, 
    0.04410733f, 0.04773627f, -0.02211132f, -0.14833730f, 0.10317595f, 0.15716340f, -0.04282490f, -0.13539623f, 
    -0.16455688f, 0.11219455f, -0.20805919f, -0.11419412f, -0.05391265f, -0.05288021f, 0.04647261f, 0.02416669f, 
    0.14562497f, -0.10058802f, -0.01498019f, 0.03926613f, 0.01016604f, -0.01507368f, 0.00815525f, -0.03970163f, 
    0.05552897f, 0.05508585f, -0.04325650f, 0.06632254f, -0.50789881f, -0.51093417f, -0.03766586f, -0.31701636f, 
    -0.01482635f, -0.10593819f, 0.04535477f, -0.04878971f, -0.02775168f, 0.03252906f, -0.01017895f, -0.00281178f, 
    0.11397830f, -0.05283566f, -0.13931368f, -0.06515829f, 0.03057927f, 0.05050305f, -0.03362195f, 0.14779033f, 
    -0.04411408f, -0.21905603f, -0.02254780f, -0.11918896f, -0.04438639f, -0.04301525f, -0.02518510f, 0.02878955f, 
    -0.03990374f, -0.06461377f, -0.03951346f, 0.05282902f, 0.03229464f, -0.08188338f, -0.04136488f, 0.00942585f, 
    -0.15978798f, 0.26673570f, -0.31204534f, -0.06654833f, 0.08444466f, -0.05210984f, 0.01019133f, 0.12133384f, 
    0.01795553f, 0.05299775f, -0.03641853f, -0.02567608f, -0.68343759f, -0.60244113f, -0.27587476f, -0.44163063f, 
    0.11787608f, 0.04628558f, 0.01471823f, -0.12917155f, -0.01650280f, -0.01221142f, -0.01103874f, -0.04083523f, 
    0.22778778f, 0.30428252f, 0.08729774f, 0.00726023f, -0.00347368f, -0.02033005f, 0.04131205f, -0.17081311f, 
    0.14666584f, -0.01389655f, -0.06590255f, 0.07801476f, -0.18503907f, 0.00947713f, 0.03618503f, -0.17620650f, 
    -0.02854394f, 0.04909832f, 0.03745541f, 0.11541814f, -0.01321549f, -0.00880831f, 0.02073048f, -0.03136657f, 
    0.07841339f, 0.24761684f, 0.08679143f, -0.05902658f, -0.02322626f, 0.08528197f, -0.18757801f, 0.05047850f, 
    0.01422730f, -0.03186382f, -0.10787998f, 0.07566024f, -0.14658582f, 0.04368242f, -0.37040833f, 0.20680782f, 
    0.02753204f, -0.03944148f, -0.03048877f, 0.12991905f, -0.03372015f, -0.03523556f, -0.04025661f, 0.04906176f, 
    0.09797332f, -0.12516190f, 0.05872645f, 0.09563755f, -0.01226549f, -0.02491380f, -0.07095505f, -0.08558339f, 
    0.21571472f, -0.01457799f, -0.08258232f, 0.11117671f, -0.37040174f, -0.00791105f, 0.45135909f, 0.19552697f, 
    0.00619691f, -0.08165459f, -0.02901303f, 0.05028495f, 0.00845074f, 0.03544046f, -0.06325149f, 0.04012245f, 
    -0.01166847f, -0.03615002f, 0.13130558f, -0.02295046f, 0.08190920f, -0.08050949f, 0.03352747f, -0.11831047f, 
    0.09114298f, 0.02159280f, 0.03548941f, 0.05063238f, -0.12453365f, 0.01359699f, 0.23853245f, -0.07944239f, 
    -0.01166940f, -0.01691507f, 0.08242235f, -0.06200768f, 0.01141572f, 0.01099569f, -0.01394610f, -0.04093335f, 
    -0.17559618f, -0.40807346f, -0.42838794f, 0.15023889f, -0.01816526f, 0.16569778f, -0.15075153f, 0.00285812f, 
    -0.04858445f, -0.09137214f, 0.02484392f, 0.00924177f, -0.04335115f, -0.02822338f, 0.12296887f, 0.09387879f, 
    0.02817980f, -0.15373963f, 0.05741028f, 0.09958579f, 0.06409656f, -0.03951930f, 0.05563299f, -0.05845977f, 
    -0.29826215f, 0.17491311f, -0.03756933f, -0.23429073f, 0.03714943f, -0.06639419f, 0.10933992f, -0.17147566f, 
    0.07267858f, -0.04410584f, 0.09972993f, 0.11425254f, -0.12422165f, -0.16108200f, 0.02876859f, 0.20717207f, 
    0.08156607f, 0.04725251f, -0.03944138f, 0.03830096f, -0.10701919f, 0.02153748f, 0.00731060f, 0.09142523f, 
    0.17129061f, -0.03636677f, -0.17045180f, 0.08087121f, -0.06898037f, -0.05251578f, -0.08697360f, -0.01972043f, 
    0.00577539f, 0.09099019f, 0.07735664f, -0.02820732f, 0.02707545f, 0.08520988f, -0.05492891f, 0.09128185f, 
    -0.03688424f, 0.00515245f, -0.02659388f, -0.02117937f, 0.02706821f, -0.01868455f, -0.03525233f, -0.03746169f, 
    -0.02230196f, -0.11683208f, -0.15260896f, 0.16360982f, -0.13681017f, -0.04689490f, 0.14911529f, -0.23038003f, 
    0.02782565f, 0.00177905f, 0.00589495f, 0.10846723f, -0.22078978f, -0.11404624f, 0.05002541f, -0.15602706f, 
    -0.03966764f, -0.06926256f, 0.04347618f, -0.08581467f, -0.04089046f, -0.01190975f, 0.00738468f, 0.03320618f, 
    -0.09263770f, 0.20434745f, -0.01910177f, 0.14865245f, -0.04062642f, 0.01553149f, 0.04062505f, -0.26014039f, 
    0.01794466f, 0.00857330f, 0.04228647f, 0.04850622f, 0.36741060f, 0.36664680f, -0.14874505f, 0.40575656f, 
    0.03350276f, 0.05348001f, 0.01213709f, -0.02430329f, -0.16331470f, -0.04849494f, -0.19588250f, 0.17003191f, 
    0.09320302f, -0.02468809f, 0.00758544f, -0.13729657f, 0.05751045f, 0.10095956f, -0.10188445f, 0.06029048f, 
    -0.00273567f, 0.06517067f, -0.22457281f, 0.12100580f, -0.30501899f, -0.28776464f, -0.31944153f, -0.24439269f, 
    -0.04256982f, 0.01601707f, 0.09817568f, -0.14393196f, 0.01911183f, 0.00499706f, -0.00947724f, -0.01439239f, 
    0.03372030f, -0.14686757f, -0.17474253f, 0.17300707f, -0.02973347f, 0.01513085f, 0.02715447f, 0.01985355f, 
    0.11114027f, -0.01556333f, -0.06328428f, 0.03890484f, 0.00192572f, 0.15177111f, -0.10910190f, 0.31159028f, 
    -0.00355869f, -0.00205909f, 0.12880655f, -0.03826842f, 0.01846889f, 0.02120336f, -0.05266590f, 0.04256476f, 
    -0.05197369f, 0.05582812f, -0.03063800f, 0.06731073f, -0.11931055f, 0.00641079f, -0.10472844f, -0.06719458f, 
    0.05751502f, 0.01457867f, 0.02216055f, 0.02694659f, -0.10210225f, -0.04310744f, -0.37338987f, 0.12338158f, 
    -0.06623819f, -0.01535556f, -0.02091182f, 0.12215786f, 0.06286699f, 0.06265624f, -0.11264525f, 0.21751219f, 
    -0.24132878f, -0.00747436f, 0.00205257f, 0.02442857f, -0.01434327f, 0.03585954f, -0.02279903f, -0.01407979f, 
    0.02769951f, -0.00656758f, -0.09856803f, 0.06189043f, -0.01123097f, 0.16388839f, -0.02794663f, 0.02338516f, 
    -0.03890449f, 0.10520557f, 0.06890244f, -0.22556834f, -0.00485752f, 0.17345807f, -0.01235367f, 0.01682302f, 
    -0.00533534f, -0.15966851f, 0.05026295f, 0.00126929f, -0.03798764f, -0.06826289f, 0.01722239f, 0.04256713f, 
    -0.06924129f, -0.09944498f, -0.05067982f, 0.12001356f, 0.03458382f, -0.22346370f, 0.07143030f, 0.13802500f, 
    -0.06384004f, 0.00257207f, 0.08929457f, 0.04984786f, 0.11234570f, 0.07942615f, -0.11699645f, -0.07868189f, 
    -0.12272728f, 0.00146520f, -0.04888403f, -0.05842350f, 0.01902795f, -0.01186720f, -0.04779336f, -0.03289731f, 
    0.15658908f, 0.06476075f, -0.04749318f, 0.11116832f, -0.08712015f, -0.25449201f, 0.20108517f, 0.07310943f, 
    -0.02319205f, -0.11427865f, 0.04359669f, 0.10845995f, 0.09431750f, 0.11691452f, -0.01750575f, 0.02385834f, 
    0.17086054f, -0.21625097f, -0.12979320f, 0.21320646f, 0.04606021f, 0.05254124f, -0.06736539f, 0.05395194f, 
    -0.19865575f, -0.20372599f, -0.13069232f, 0.11641230f, 0.29128754f, -0.08410527f, -0.07043178f, 0.17093849f, 
    0.09197911f, -0.07952325f, -0.09817717f, 0.12288260f, 0.22109307f, 0.06130119f, -0.04305120f, 0.06581382f, 
    0.00252303f, -0.12073999f, -0.21987188f, -0.06272922f, -0.00109307f, -0.01492231f, -0.05690587f, -0.04161029f, 
    0.05668357f, 0.09465537f, -0.22721331f, -0.01762685f, 0.15802087f, -0.12815304f, 0.10614264f, -0.43065670f, 
    -0.03457892f, -0.06397981f, -0.15790099f, 0.09961873f, -0.02823706f, 0.06181754f, -0.13063981f, 0.07563833f, 
    -0.06134005f, -0.17668778f, 0.01898630f, 0.01726815f, -0.00834462f, 0.08156139f, 0.08854982f, -0.10849784f, 
    0.00990314f, -0.11544611f, -0.00007101f, 0.01336662f, -0.06679277f, 0.03200988f, 0.03999661f, -0.06221499f, 
    -0.00851568f, 0.16491164f, -0.07798710f, 0.06561056f, 0.08581313f, -0.03499602f, 0.00674556f, 0.01010337f, 
    0.13077459f, -0.15498170f, 0.13298832f, 0.21929306f, 0.02193154f, -0.00262806f, 0.00199178f, 0.00250412f, 
    0.07292183f, 0.02744490f, 0.11221194f, 0.12046025f, -0.17562534f, -0.25341082f, -0.07535680f, -0.04645600f, 
    0.10851697f, 0.08165616f, -0.02292880f, 0.04914229f, 0.00947111f, -0.07521953f, -0.04135108f, 0.01119869f, 
    -0.06799317f, -0.00182414f, -0.25633588f, 0.04967637f, -0.03340589f, -0.00518902f, 0.02370408f, 0.04431743f, 
    -0.06355274f, 0.10894958f, -0.01667188f, 0.03377771f, 0.24694061f, -0.15184672f, 0.69925267f, 0.36593640f, 
    -0.09335057f, 0.06973229f, 0.04664319f, 0.01588923f, -0.02710790f, 0.01555213f, -0.06581306f, -0.02106386f, 
    -0.78190327f, 0.02536445f, -0.20344275f, -0.28887591f, -0.14753102f, -0.02927898f, -0.06718719f, -0.04563367f, 
    -0.01015416f, -0.00360181f, -0.00647518f, 0.00701215f, 0.01051548f, -0.30600381f, -0.05792582f, -0.14035624f, 
    -0.08229435f, -0.15893841f, -0.15172246f, -0.19446512f, 0.00386203f, -0.05353532f, -0.01833639f, -0.14453606f, 
    0.01682496f, 0.02940651f, -0.04528810f, 0.12455900f, -0.02862832f, -0.05037813f, -0.02762496f, -0.02045165f, 
    0.08648851f, 0.08642685f, 0.14380288f, 0.17211740f, -0.33831304f, 0.11114664f, 0.05290870f, 0.02463754f, 
    0.02784601f, -0.01331562f, 0.00246677f, 0.06070045f, 0.01389904f, -0.02215426f, 0.09578289f, -0.04026457f, 
    0.03591742f, 0.09348715f, 0.00942768f, -0.03692600f, 0.12668006f, 0.06722545f, -0.07539938f, -0.19676511f, 
    0.03498904f, -0.03014048f, -0.01530581f, 0.01770633f, 0.05060674f, -0.07726797f, -0.04005736f, -0.13871235f, 
    0.05704824f, 0.02303601f, -0.13058476f, 0.02806915f, -0.07426872f, 0.14041981f, -0.02007944f, -0.00054332f, 
    -0.43906140f, 0.08182090f, 0.06011636f, -0.02792929f, -0.01776755f, 0.01996017f, 0.00508566f, -0.06755297f, 
    -0.02784868f, 0.02253275f, -0.05182584f, -0.16397381f, -0.10290259f, 0.26052740f, -0.31117210f, -0.03658437f, 
    -0.01401161f, -0.11057244f, 0.13270617f, 0.02082448f, 0.02941773f, 0.08618504f, 0.04957866f, -0.09451516f, 
    0.01107646f, 0.12307678f, 0.08929580f, 0.44202349f, -0.02759436f, 0.01438627f, 0.00633369f, -0.02186310f, 
    0.04578026f, -0.01257553f, -0.01393329f, 0.03118948f, -0.03241830f, 0.09189488f, -0.00649603f, -0.08737820f, 
    0.10449509f, 0.16170110f, -0.06956244f, -0.24791726f, 0.01266866f, -0.01775819f, 0.19311522f, 0.09910183f, 
    -0.38798550f, -0.36011085f, -0.12229785f, 0.00922507f, -0.03924150f, 0.01149597f, 0.02491807f, -0.08409850f, 
    0.00221132f, -0.04493235f, -0.20700526f, 0.14584397f, -0.05170804f, 0.01940922f, -0.03043914f, -0.12010132f, 
    -0.06075152f, 0.00823074f, -0.07024167f, 0.00333595f, -0.09875452f, -0.07757525f, -0.05066509f, -0.18083286f, 
    -0.21876369f, -0.16248822f, 0.03550205f, 0.02665823f, -0.01850988f, -0.00868238f, 0.01332707f, 0.03740988f, 
    0.03970402f, -0.00171390f, -0.07932016f, 0.03248145f, -0.32889190f, 0.05184856f, 0.13076526f, -0.20444332f, 
    0.01969174f, -0.00629050f, 0.01249349f, 0.02789692f, -0.00776581f, 0.01916148f, 0.02812761f, -0.04602380f, 
    -0.17263038f, 0.38522181f, 0.38402814f, 0.37126407f, -0.07492930f, -0.02731198f, -0.03193623f, 0.04094911f, 
    0.06897104f, 0.06612653f, -0.00975203f, 0.02385288f, 0.12409531f, 0.46020487f, 0.22367381f, 0.25748667f, 
    -0.03725214f, -0.04744843f, 0.05512448f, -0.05965134f, -0.11623321f, -0.07635436f, 0.07468032f, -0.01893191f, 
    0.08279519f, 0.08180128f, 0.14148834f, 0.07195587f, 0.08505935f, 0.11771403f, 0.02556506f, -0.08458196f, 
    -0.01038281f, 0.03815609f, 0.04161932f, -0.01774414f, -0.48182282f, -0.05958380f, 0.14807089f, -0.18523394f, 
    -0.04801014f, 0.14326431f, -0.00065723f, 0.15936664f, 0.01761045f, -0.04741051f, 0.04044642f, -0.04247866f, 
    0.09940219f, -0.15702841f, -0.21294227f, -0.46729243f, 0.09584798f, 0.04146700f, -0.00216347f, -0.12156582f, 
    0.09418508f, 0.01559143f, -0.08867396f, 0.05197683f, 0.00153848f, -0.16739026f, -0.04613012f, 0.08725125f, 
    0.05047115f, 0.02811960f, -0.03273731f, 0.03102054f, -0.12004981f, 0.08613387f, -0.10327162f, 0.07042376f, 
    -0.37426093f, 0.38994822f, -0.34277365f, -0.37106666f, 0.00571069f, -0.04057593f, -0.03331867f, -0.14480411f, 
    -0.13500345f, -0.06653634f, -0.00609101f, -0.02194134f, 0.13649133f, 0.04436577f, -0.15021071f, -0.23592442f, 
    -0.03986486f, -0.23811115f, 0.00864165f, 0.00001321f, -0.11115892f, 0.15402497f, -0.00603777f, 0.00007359f, 
    -0.14305907f, 0.35471404f, -0.10919663f, 0.13363913f, -0.02000903f, 0.12378751f, 0.03616828f, -0.02442237f, 
    -0.10315254f, 0.01374122f, 0.02588985f, 0.19251421f, -0.01778734f, -0.11112471f, -0.02172941f, 0.22923328f, 
    0.09548161f, 0.11643969f, 0.14456470f, 0.13852856f, -0.00357900f, -0.01022969f, 0.08960519f, -0.14730084f, 
    0.03023797f, 0.02063776f, 0.12648956f, 0.39300430f, -0.02819682f, -0.00914534f, -0.08717839f, -0.05969252f, 
    -0.09071487f, -0.06892927f, -0.16128029f, 0.11142851f, 0.04468236f, -0.16644643f, 0.11668669f, -0.18299335f, 
    -0.25771099f, -0.06622592f, -0.04631219f, -0.17957014f, 0.07733532f, -0.01714080f, -0.02175616f, -0.02090946f, 
    -0.11249993f, 0.07120620f, -0.03552348f, 0.35601684f, -0.03084996f, -0.04571797f, -0.20618947f, -0.09456140f, 
    -0.11001070f, -0.01314681f, 0.15005380f, -0.00394730f, -0.49818975f, 0.21231879f, -0.15257943f, -0.60626107f, 
    -0.03618329f, -0.14495257f, -0.04082093f, -0.05934522f, -0.14135452f, 0.02104547f, -0.16297728f, 0.07611496f, 
    0.00668573f, -0.14861429f, -0.11361025f, 0.04494008f, 0.18260574f, 0.12397506f, 0.12266560f, 0.00829806f, 
    -0.02603063f, 0.18044659f, -0.33279979f, 0.09214709f, -0.27333862f, 0.04348365f, -0.02783039f, 0.04801724f, 
    0.10933640f, 0.03399227f, -0.03370893f, 0.00487485f, 0.03999588f, 0.10314710f, 0.02635950f, 0.06229763f, 
    0.02761668f, 0.64046383f, -0.07779959f, -0.35415265f, 0.16449401f, 0.08070493f, 0.00475265f, 0.03702452f, 
    -0.12753437f, 0.05136171f, -0.05021608f, 0.05797015f, 0.06385317f, -0.25875431f, 0.31546068f, 0.19466183f, 
    0.03522264f, -0.00240327f, -0.09636848f, -0.01506231f, 0.02239129f, 0.04097131f, 0.05441434f, -0.10317421f, 
    0.08199188f, 0.03959814f, -0.27530649f, -0.00381924f, 0.00859688f, 0.07422373f, -0.04827565f, 0.07950967f, 
    -0.07600675f, -0.01424040f, 0.04585075f, -0.10909104f, -0.10725568f, -0.07050639f, -0.11892691f, 0.18469781f, 
    0.11577256f, 0.14582488f, -0.01550381f, 0.14698996f, 0.01833373f, 0.11622737f, 0.06881580f, -0.09163889f, 
    -0.59558332f, -0.03391249f, 0.16696073f, 0.24200837f, -0.09522353f, -0.24182788f, 0.14866433f, -0.08084911f, 
    -0.03259256f, 0.16054492f, -0.11454513f, 0.08552280f, 0.29568580f, -0.20675912f, 0.07829306f, -0.21482992f, 
    0.11593951f, 0.00994339f, -0.05542866f, -0.09319026f, 0.09958483f, -0.05903532f, -0.06554871f, 0.02160164f, 
    0.33185145f, 0.23457715f, 0.06026119f, -0.18404432f, -0.04989039f, -0.18628621f, 0.14530699f, -0.17773074f, 
    -0.09695833f, 0.09997237f, -0.10762631f, 0.05405127f, -0.05167252f, 0.36789066f, -0.07533577f, -0.11702545f, 
    -0.02646441f, 0.11080794f, -0.18780346f, -0.00482596f, 0.14522752f, -0.17210890f, 0.10588349f, 0.10662272f, 
    0.24548253f, -0.10332360f, -0.14096430f, -0.03086150f, -0.14285891f, 0.04775079f, -0.10432331f, 0.20733106f, 
    -0.09729613f, -0.16078502f, 0.21032329f, -0.02663792f, 0.01194172f, 0.03630345f, -0.08809770f, 0.18771958f, 
    0.07086682f, 0.02924747f, 0.01648177f, 0.10796232f, 0.05135152f, -0.07416908f, 0.21874540f, -0.02319433f, 
    -0.22321989f, -0.04982441f, -0.05455014f, 0.23879099f, -0.04147413f, 0.06570702f, 0.00073953f, 0.00877409f, 
    -0.04086969f, -0.00780901f, 0.01803564f, 0.17762868f, 0.23701932f, -0.08592806f, -0.09859176f, 0.00332898f, 
    0.02873437f, -0.01331410f, -0.08937933f, 0.04341462f, -0.06443713f, 0.14681365f, -0.04139920f, 0.02918054f, 
    0.13585235f, -0.01567417f, 0.20082860f, -0.08940774f, -0.01050806f, -0.06285807f, -0.25731406f, -0.28336447f, 
    -0.02761821f, 0.05219189f, 0.03895794f, -0.14751557f, -0.06501098f, -0.24239519f, -0.10312023f, 0.12708570f, 
    0.07534540f, 0.12316395f, 0.09464134f, 0.06632940f, 0.09550842f, -0.03881696f, -0.01339224f, -0.09008761f, 
    0.56126326f, 0.01257808f, -0.23359770f, -0.40130770f, -0.24225307f, -0.02255679f, 0.11478718f, 0.07880791f, 
    -0.13026783f, 0.04337668f, -0.07240106f, 0.08023181f, -0.20060974f, 0.52672404f, -0.21430330f, 0.21216659f, 
    -0.10142010f, 0.02708353f, 0.15914910f, -0.04080827f, -0.06032005f, 0.14712970f, 0.04464133f, -0.00924506f, 
    -0.03748786f, -0.25390235f, -0.05471000f, 0.11100043f, 0.01156084f, 0.04594735f, -0.04444438f, -0.08240117f, 
    -0.03428654f, 0.19643930f, -0.29730394f, -0.09046078f, -0.13534708f, -0.13692322f, -0.13065581f, -0.29134116f, 
    -0.23703198f, -0.07539830f, -0.06994333f, 0.15011109f, -0.04724236f, 0.15112066f, -0.07364567f, -0.14732622f, 
    -0.48477161f, 0.19200164f, -0.31836632f, -0.04373109f, -0.20112841f, 0.09630326f, -0.01475616f, -0.19506350f, 
    -0.14416045f, -0.14189716f, 0.12889530f, -0.07171880f, 0.22860734f, -0.11344574f, 0.03704894f, 0.31091908f, 
    0.10036296f, -0.04680773f, -0.08150510f, 0.00292578f, 0.09631086f, -0.02145205f, -0.10050232f, -0.05019548f, 
    -0.52964401f, -0.34380662f, -0.22267899f, -0.04567784f, -0.10180897f, -0.05483677f, -0.08525518f, -0.04453630f, 
    -0.09799664f, 0.14586376f, -0.10999292f, 0.01236786f, -0.23342298f, 0.49792606f, -0.20071734f, -0.41969368f, 
    0.28893492f, 0.10683849f, -0.04072102f, 0.03137409f, -0.35976589f, 0.06300005f, -0.05681402f, -0.01543856f, 
    -0.56466639f, 0.33071706f, 0.05546884f, 0.36189458f, 0.00504054f, -0.07894120f, 0.07302380f, 0.06103042f, 
    0.06425096f, 0.05307743f, -0.04402773f, -0.02716986f, 0.41730082f, 0.24403967f, -0.37363139f, 0.21062684f, 
    0.13200769f, -0.13818049f, 0.05213283f, -0.05384849f, -0.05369693f, 0.08288540f, 0.07919163f, 0.00721489f, 
    0.35511884f, 0.05839727f, -0.02272825f, 0.18831983f, -0.05557037f, -0.01582165f, 0.12276323f, -0.20675962f, 
    -0.05929665f, -0.12975140f, 0.09340487f, -0.03379491f, 0.20898895f, -0.21060550f, -0.25194710f, -0.03496590f, 
    0.04217876f, -0.08022033f, 0.06769462f, -0.14919786f, -0.07247423f, -0.10723211f, -0.09196614f, 0.07393341f, 
    -0.31774497f, 0.08114046f, 0.10467312f, 0.14423046f, 0.04412086f, -0.13444424f, 0.06648842f, 0.00856173f, 
    0.02782008f, 0.17335379f, -0.04656807f, 0.09808013f, -0.02788429f, 0.02637634f, -0.18662022f, 0.14491892f, 
    -0.13412873f, -0.05935899f, -0.03993932f, -0.10915624f, -0.10086284f, -0.06121014f, 0.00352824f, 0.03103387f, 
    0.05285039f, -0.05711277f, -0.11523259f, 0.11586199f, -0.07397129f, 0.05401006f, -0.05321261f, -0.01731407f, 
    -0.07785414f, 0.04170620f, -0.02931668f, 0.10308169f, 0.00312460f, 0.05356525f, 0.01555758f, 0.11399701f, 
    -0.17935131f, -0.07836206f, -0.00936153f, -0.01069648f, -0.18867879f, 0.02927451f, 0.10620978f, -0.09919747f, 
    -0.15217519f, 0.08451702f, -0.21958481f, -0.11714699f, 0.00468614f, 0.06996971f, 0.01104339f, -0.01657431f, 
    -0.00552105f, -0.04798654f, -0.02165215f, -0.01715697f, 0.19731484f, -0.08565906f, -0.06570666f, 0.09289499f, 
    0.05842595f, -0.01366042f, 0.01625593f, -0.09096065f, 0.03815610f, 0.18223010f, -0.03400208f, 0.04486023f, 
    0.01327077f, 0.17045982f, -0.08721460f, -0.08182807f, 0.02546032f, -0.02204718f, -0.06327517f, 0.16006577f, 
    -0.13209574f, -0.08355370f, 0.00668763f, -0.07956778f, -0.07681193f, -0.15703836f, -0.00076893f, 0.23302242f, 
    0.09408069f, -0.05520245f, -0.04918473f, -0.12016609f, -0.11512537f, 0.01145734f, 0.00181302f, 0.03500655f, 
    -0.19741940f, -0.09408009f, -0.05154189f, 0.31608000f, -0.01233221f, -0.01547747f, 0.02151635f, 0.05571283f, 
    0.01469775f, 0.04982127f, -0.15833440f, 0.01437662f, -0.01691535f, 0.11215214f, 0.38768503f, 0.10814554f, 
    -0.00277135f, -0.08168889f, -0.17632812f, -0.04177085f, 0.06151813f, -0.03193511f, 0.18274498f, -0.08061576f, 
    0.00069697f, -0.01135107f, -0.14513409f, -0.02393512f, 0.11480974f, 0.00457577f, -0.06262094f, 0.01985976f, 
    0.03920820f, 0.14468032f, -0.06392477f, -0.04006208f, -0.04985695f, 0.16923025f, -0.12317432f, 0.31805277f, 
    -0.01503493f, 0.05748345f, -0.00190953f, -0.01824405f, -0.07040793f, -0.20386668f, -0.01234276f, 0.04268723f, 
    0.24274926f, -0.08032230f, 0.03935614f, 0.05462874f, 0.04276234f, -0.11268125f, 0.15282463f, 0.04625884f, 
    -0.08415154f, -0.02437843f, 0.08306725f, -0.09816528f, 0.77141494f, -0.03541995f, 0.28985763f, -0.18998781f, 
    -0.23710322f, 0.05701829f, -0.10599897f, -0.18753961f, 0.09696468f, 0.04501750f, -0.12139614f, -0.06740081f, 
    0.17858149f, -0.07190233f, 0.06552222f, 0.16668846f, 0.02257251f, -0.00709276f, -0.06667554f, 0.02091469f, 
    0.10253657f, -0.06747308f, -0.05768027f, -0.09969196f, -0.26890346f, 0.30052999f, -0.23009208f, 0.30314153f, 
    0.09309876f, -0.00246103f, -0.01632424f, 0.00647528f, -0.04089655f, -0.17649627f, 0.07542722f, 0.06234558f, 
    0.05315092f, -0.13567993f, -0.02818694f, 0.18270299f, 0.05623770f, -0.02977725f, -0.03107900f, -0.06167343f, 
    0.01468341f, 0.06503079f, 0.05219594f, 0.05984368f, -0.16191800f, 0.01893241f, 0.02214704f, 0.18415986f, 
    -0.24532875f, 0.11785603f, -0.10251034f, -0.06998789f, -0.00498812f, -0.13523103f, 0.15683092f, -0.14407252f, 
    -0.17002083f, -0.10176247f, 0.29509991f, -0.12041524f, -0.23857479f, -0.20518894f, -0.14352509f, 0.07109056f, 
    -0.14535871f, -0.05284948f, 0.02165436f, -0.09457950f, 0.16441822f, 0.00098637f, 0.12051059f, 0.04277973f, 
    0.25539869f, -0.01649484f, 0.08998868f, 0.15504129f, -0.11178711f, 0.15508842f, -0.04949731f, 0.02581165f, 
    -0.17130615f, -0.22020656f, -0.07808088f, -0.28942421f, -0.14329611f, -0.02661499f, -0.12702492f, 0.02483111f, 
    0.08633900f, 0.13734779f, 0.02918004f, 0.05203466f, -0.49328426f, 0.19289058f, -0.25362980f, -0.08551451f, 
    0.01201390f, -0.08568254f, 0.00901889f, -0.15664627f, -0.17294101f, 0.05838268f, 0.10184235f, 0.01720872f, 
    0.27463612f, -0.19198053f, 0.01947027f, 0.06363571f, 0.14369695f, 0.01854588f, 0.03488132f, -0.02984158f, 
    0.01837078f, 0.00295485f, 0.05205303f, 0.12866315f, 0.37077251f, -0.34187886f, 0.06402105f, 0.12874895f, 
    0.19207409f, 0.16743250f, 0.09360512f, 0.07565642f, -0.11152826f, -0.00573368f, -0.01642852f, 0.00614019f, 
    0.20249233f, -0.24988966f, 0.01137446f, 0.14602987f, -0.00147495f, -0.00165046f, 0.10735891f, -0.06099446f, 
    0.01431567f, -0.02241777f, 0.09895445f, 0.00854456f, -0.11504973f, 0.05138474f, 0.17347941f, 0.20472372f, 
    -0.06841512f, -0.09833672f, -0.09467140f, -0.16673467f, 0.06105337f, 0.01471928f, 0.08355155f, 0.02788025f, 
    -0.18623610f, -0.12389760f, -0.05615307f, -0.01333441f, 0.05434648f, 0.04330508f, 0.04433487f, -0.07176360f, 
    -0.14612225f, -0.12567745f, -0.01855054f, 0.06704691f, -0.01814568f, -0.09424355f, -0.00964367f, 0.10616051f, 
    -0.00607525f, -0.10202255f, -0.00643560f, -0.09131891f, 0.03590578f, 0.02946822f, 0.07701269f, -0.03387431f, 
    -0.03705244f, -0.38499585f, -0.17551970f, 0.11256759f, 0.04609618f, -0.01841752f, 0.05081161f, -0.08054389f, 
    -0.21383309f, -0.09227716f, -0.13559030f, 0.09985229f, 0.15895012f, 0.03662508f, -0.00469834f, 0.01282621f, 
    0.07483783f, 0.05041776f, 0.02453591f, -0.05837343f, -0.00206829f, -0.07084356f, -0.14089254f, -0.09827972f, 
    0.12557690f, -0.38959202f, 0.27355826f, 0.23530264f, 0.03088735f, 0.01771727f, 0.06178657f, 0.04937574f, 
    -0.08855595f, -0.04034101f, -0.02266435f, 0.04679678f, 0.17753872f, 0.23523028f, 0.23150982f, 0.32845303f, 
    -0.13737282f, -0.06117250f, -0.02935652f, 0.15274628f, 0.06728607f, 0.04414480f, 0.00111081f, 0.01227198f, 
    -0.13425259f, 0.17359118f, -0.21326870f, -0.03423739f, 0.16070096f, -0.05769623f, -0.08346286f, -0.06993780f, 
    0.00469342f, -0.22256957f, 0.08977556f, 0.11396302f, 0.01264789f, -0.07907739f, 0.04031904f, 0.13662498f, 
    -0.11877973f, -0.02516165f, 0.03190552f, 0.08623358f, 0.01221431f, -0.03448556f, 0.02298725f, -0.00460981f, 
    -0.13670531f, -0.12046880f, -0.12889920f, -0.02372294f, -0.01918443f, -0.08155253f, -0.06831460f, -0.02452947f, 
    -0.03354288f, -0.15412590f, 0.03162603f, -0.08250543f, 0.12613609f, -0.06660484f, -0.26575318f, 0.13717070f, 
    -0.12144469f, 0.01874372f, -0.07838824f, -0.04325124f, -0.31003582f, -0.13579436f, -0.15952329f, -0.15472220f, 
    0.04512569f, 0.14579788f, 0.05292257f, 0.21975276f, 0.14992218f, -0.06525220f, -0.05746944f, -0.09289293f, 
    0.11097573f, -0.04876195f, 0.14166600f, -0.03118821f, -0.19502927f, -0.12821922f, -0.06427457f, 0.06595062f, 
    -0.02739649f, 0.02024586f, -0.00925731f, -0.05195963f, -0.08940329f, -0.04109336f, -0.03653437f, 0.00978241f, 
    -0.53165734f, -0.30324638f, -0.15313022f, -0.28973332f, 0.01233548f, 0.05705423f, -0.00542191f, 0.09920100f, 
    -0.05662778f, -0.01536390f, 0.07066452f, -0.02797620f, 0.06482367f, 0.27548948f, 0.09406766f, -0.00871857f, 
    -0.03856139f, -0.02240457f, -0.04093083f, 0.13696441f, 0.06117273f, -0.06362612f, 0.07906842f, -0.06580987f, 
    -0.07108919f, 0.08005315f, 0.17809691f, 0.06314681f, -0.09801948f, -0.04534842f, -0.14538962f, -0.11034674f, 
    -0.21939385f, 0.01918011f, 0.11570271f, 0.06857417f, 0.23762016f, 0.06853384f, -0.03739666f, -0.06109274f, 
    -0.03365792f, -0.11727347f, -0.00474467f, -0.23658720f, 0.07428738f, -0.01627216f, 0.00012730f, 0.02499672f, 
    0.03297170f, -0.02429227f, -0.00111669f, -0.20189625f, 0.14432700f, -0.07325031f, -0.12946768f, 0.05193392f, 
    -0.13748841f, -0.05877219f, -0.12840343f, -0.19074945f, -0.00028338f, 0.18866210f, -0.29566550f, -0.03732470f, 
    0.00101227f, -0.04197745f, 0.04935833f, -0.13557407f, -0.05734816f, -0.10175348f, -0.11927399f, -0.01208860f, 
    -0.00197435f, -0.13918555f, -0.02269994f, 0.08402670f, -0.14127296f, -0.02015286f, -0.03743403f, -0.10488488f, 
    0.09361206f, 0.02728996f, -0.07229185f, -0.01289520f, 0.00760977f, -0.16637421f, 0.03733777f, 0.09126709f, 
    -0.08545806f, -0.05782911f, -0.07049797f, -0.36095515f, -0.00034233f, 0.00228040f, -0.06221363f, -0.04744974f, 
    -0.08976477f, -0.08170691f, 0.00535622f, -0.03387440f, -0.28044596f, 0.08369667f, 0.06421550f, 0.02095112f, 
    -0.00944045f, -0.03483047f, -0.14446627f, -0.01372684f, 0.05856148f, 0.19324766f, 0.13586292f, 0.18138281f, 
    0.04074627f, -0.00017173f, 0.04886454f, 0.01108190f, 0.21787238f, 0.07458130f, -0.06363691f, 0.15735993f, 
    -0.11106212f, -0.01227055f, 0.11683588f, 0.03776910f, 0.03511768f, 0.04359869f, 0.08955980f, -0.18140721f, 
    0.06821357f, 0.07345101f, 0.03994827f, 0.06001217f, 0.12753549f, 0.20450689f, -0.10460354f, 0.18600626f, 
    -0.04272148f, -0.12293249f, -0.00121288f, -0.00317407f, -0.02839985f, -0.24415095f, -0.14157425f, -0.02357320f, 
    0.01315180f, 0.00620845f, -0.13800718f, 0.05350660f, -0.17184342f, -0.07800009f, 0.08963833f, 0.13947523f, 
    -0.10824843f, -0.16795661f, -0.22263408f, -0.24239343f, 0.14500600f, 0.23685896f, 0.31860122f, 0.21789965f, 
    -0.17298552f, -0.01307261f, -0.00871875f, 0.12567152f, 0.03438012f, -0.00008935f, 0.02342809f, 0.03506953f, 
    -0.03007729f, -0.18031326f, -0.05851475f, -0.06870250f, -0.09029228f, 0.05519194f, -0.09326851f, 0.00702868f, 
    0.22276126f, -0.04180690f, 0.09950400f, 0.08239811f, 0.29610059f, -0.29873425f, 0.26755375f, -0.14602426f, 
    -0.00819803f, 0.01440045f, -0.15371281f, 0.03735973f, 0.05586350f, -0.07810269f, 0.02068340f, 0.00111104f, 
    0.00443655f, -0.02138234f, 0.02789705f, -0.04586245f, 0.02002599f, -0.06846713f, -0.00898199f, -0.06120917f, 
    0.12078180f, 0.01198311f, -0.07115479f, 0.00973021f, 0.13923512f, 0.08107448f, 0.07360747f, -0.34466898f, 
    0.00666858f, -0.01784249f, -0.04796864f, -0.00641219f, -0.05198943f, -0.07619263f, 0.03574904f, -0.12811735f, 
    0.19313294f, -0.19818665f, 0.14277886f, -0.02045561f, 0.10285535f, -0.03286818f, -0.06744701f, 0.10823094f, 
    0.08227982f, -0.14156152f, -0.18475203f, 0.07023647f, -0.05193559f, 0.07317831f, 0.03212819f, 0.07970414f, 
    -0.08503278f, -0.08135800f, -0.05002366f, -0.02809611f, -0.14125642f, -0.03682671f, 0.03501928f, 0.07158406f, 
    0.08923230f, -0.02721759f, -0.00691096f, -0.02182694f, 0.12018496f, 0.01625283f, 0.08142332f, 0.06301425f, 
    0.00629419f, 0.09052760f, 0.04052475f, 0.02095023f, 0.18545425f, -0.59925741f, 0.15406527f, 0.05154325f, 
    -0.20062461f, 0.04644210f, -0.05444232f, -0.01814321f, -0.00726768f, 0.01909070f, -0.08852358f, -0.17156594f, 
    0.23849374f, 0.07161779f, 0.01015384f, -0.06423637f, 0.05982143f, 0.02545100f, 0.04011887f, -0.01977235f, 
    0.24246496f, 0.16642088f, -0.11656245f, 0.48842916f, -0.14581203f, -0.10192448f, -0.03070872f, 0.00209442f, 
    0.02198104f, 0.23055758f, -0.11849876f, -0.14273082f, -0.09384813f, 0.03569021f, 0.17985727f, -0.03219425f, 
    -0.00768836f, 0.18428966f, -0.00843038f, 0.10312250f, 0.02630576f, -0.02221304f, -0.06673469f, 0.00659926f, 
    -0.05767739f, -0.13349703f, 0.01904815f, -0.03157533f, 0.04566298f, 0.11121368f, -0.03677778f, 0.05675976f, 
    -0.17575359f, -0.03766049f, -0.00682337f, -0.07219943f, 0.12998207f, 0.01839495f, 0.05258633f, -0.06842785f, 
    -0.02961698f, 0.05827468f, -0.00118307f, -0.21796253f, 0.12444755f, -0.02634310f, -0.04550912f, -0.12854119f, 
    -0.15981196f, 0.01873280f, 0.03521852f, -0.23853742f, -0.00213259f, -0.14049104f, -0.34840086f, -0.02293785f, 
    0.14460988f, -0.15943167f, 0.07967704f, 0.15307514f, 0.08292113f, 0.04385435f, 0.09833677f, -0.13030599f, 
    0.00314024f, 0.06950615f, 0.08931245f, 0.02177455f, -0.08935568f, 0.02953847f, -0.14514063f, -0.02119932f, 
    0.04287514f, -0.03115775f, 0.02991899f, -0.01961778f, 0.08771150f, 0.16947578f, -0.11723351f, -0.01753881f, 
    0.01313954f, -0.12502123f, -0.01766102f, -0.04787844f, 0.08882023f, 0.03011192f, -0.05567616f, -0.22031738f, 
    -0.01859382f, -0.08602650f, 0.06841592f, -0.00762303f, -0.05074126f, -0.06322642f, 0.00631356f, -0.04860224f, 
    0.11383855f, 0.25011542f, 0.08305205f, 0.19469678f, -0.04411262f, -0.06756528f, 0.11689369f, 0.09973620f, 
    -0.02313706f, 0.06628251f, -0.12146951f, -0.00037163f, 0.06625398f, -0.05019566f, -0.01543478f, 0.04492220f, 
    0.01596047f, -0.26744589f, 0.11217662f, -0.03445298f, 0.00187608f, -0.00709639f, 0.00864584f, -0.01828852f, 
    0.17237991f, 0.01057226f, 0.00135142f, 0.33984140f, 0.10211164f, 0.05879758f, -0.05052140f, 0.16311906f, 
    -0.17209291f, -0.13520224f, 0.12337317f, -0.12882389f, -0.00221364f, 0.00962984f, 0.02237182f, 0.05504480f, 
    0.09639306f, -0.04911792f, 0.18889961f, -0.05366613f, 0.06604998f, 0.04714745f, -0.00731261f, 0.03181025f, 
    0.04919621f, -0.09773093f, 0.08514901f, -0.07165401f, 0.14560479f, 0.13168465f, -0.29736513f, 0.09839803f, 
    0.05834584f, 0.16732365f, -0.16462404f, -0.06528903f, 0.05713197f, 0.08586065f, 0.00690497f, -0.19353008f, 
    0.12840536f, -0.02998167f, 0.04299048f, 0.05126668f, -0.08749318f, 0.02869399f, -0.05324189f, -0.06657720f, 
    0.07674133f, 0.10981096f, 0.18262596f, 0.27652428f, -0.14799160f, -0.15657610f, 0.26793393f, -0.06008619f, 
    -0.07014859f, 0.01766232f, 0.03602594f, -0.01024565f, 0.08401188f, -0.08298270f, -0.31256789f, 0.04521832f, 
    0.04168227f, -0.01037570f, 0.06936861f, 0.07439724f, 0.04790185f, 0.05850178f, -0.02537037f, 0.00088431f, 
    0.01574055f, -0.06989028f, 0.03368326f, 0.03436377f, 0.15518038f, 0.02458104f, -0.05046052f, 0.17918248f, 
    0.17210034f, -0.11444495f, -0.00385009f, -0.27611119f, -0.06785037f, -0.20082052f, 0.06770573f, 0.13481101f, 
    -0.17716448f, -0.08760942f, 0.08557354f, 0.11400025f, 0.02955615f, 0.00999743f, -0.11050219f, 0.02477991f, 
    -0.04886474f, 0.02284522f, -0.00272705f, 0.02642494f, -0.01379359f, -0.21299364f, 0.32082799f, 0.15469749f, 
    -0.13203534f, -0.02120424f, -0.07352003f, -0.02238597f, -0.03578663f, -0.05369176f, -0.02706925f, 0.00984776f, 
    -0.00561341f, 0.07811823f, 0.14683913f, 0.04548555f, -0.20684080f, -0.09362186f, -0.07438693f, -0.02058850f, 
    0.04034896f, -0.06352080f, 0.01028959f, -0.02911294f, -0.13058494f, 0.00610923f, 0.02026914f, 0.17391916f, 
    -0.01670590f, 0.05443787f, -0.18219930f, -0.00466738f, 0.08733165f, 0.23633620f, -0.15444727f, -0.06819899f, 
    -0.06714536f, -0.05392751f, 0.01412813f, 0.27250761f, -0.02002878f, 0.05942976f, 0.04935671f, 0.01204825f, 
    0.08105734f, -0.00073375f, -0.01555058f, -0.05194253f, 0.19028257f, 0.10021953f, 0.06013741f, 0.02073414f, 
    0.09777813f, -0.03992850f, 0.02616039f, 0.07053459f, 0.09311274f, -0.01068891f, 0.05556973f, -0.09732776f, 
    -0.02857203f, -0.16984704f, -0.10206523f, -0.00343911f, 0.01691202f, -0.00034131f, 0.07075620f, 0.07979620f, 
    0.07835995f, 0.02580638f, 0.01982581f, 0.06429884f, 0.10926323f, -0.59221196f, -0.26025778f, -0.31003073f, 
    0.06082676f, 0.05036118f, 0.01164355f, 0.05403830f, 0.04330510f, 0.10282560f, -0.01335423f, -0.05433343f, 
    -0.19636522f, -0.00844434f, 0.09436247f, 0.11794674f, -0.09758364f, -0.00188331f, 0.09388166f, 0.11722661f, 
    0.00586818f, 0.02038945f, -0.02275008f, -0.06324849f, 0.01342830f, 0.24478979f, 0.09680806f, 0.01867198f, 
    0.01252641f, -0.11919237f, 0.00379481f, 0.07808937f, 0.04307621f, -0.05503399f, -0.06449474f, 0.08932435f, 
    -0.10634401f, 0.03255356f, -0.06409614f, 0.09238053f, -0.04672101f, -0.01318955f, -0.08894874f, -0.08462657f, 
    -0.08417840f, 0.01764943f, -0.06203247f, 0.12494619f, 0.24268946f, -0.05224076f, 0.33173442f, 0.15122128f, 
    -0.17208213f, -0.19063541f, 0.21771842f, 0.09917819f, 0.01409815f, -0.00631715f, 0.00869884f, -0.04879205f, 
    -0.08931755f, -0.17976345f, 0.01667167f, 0.12303659f, -0.01671536f, -0.07543284f, 0.03206068f, 0.07784315f, 
    -0.04212849f, 0.03469545f, 0.19095789f, -0.03656043f, -0.11524871f, 0.24531503f, -0.03963744f, -0.08848193f, 
    0.20550381f, -0.00324658f, -0.00819604f, 0.12514924f, 0.00551023f, 0.01805807f, 0.10896071f, 0.02108935f, 
    -0.06501964f, -0.07860857f, 0.22141555f, -0.09025560f, 0.04929122f, -0.08737343f, -0.00273553f, 0.05945073f, 
    0.07284765f, 0.04617189f, -0.01956896f, 0.07253483f, 0.06353371f, 0.00930405f, 0.03733772f, -0.11435521f, 
    -0.20043230f, 0.17820722f, -0.08903799f, -0.01159845f, 0.11451019f, -0.12224515f, 0.03450265f, -0.04225496f, 
    -0.14595032f, 0.03608948f, 0.26884398f, -0.02936087f, -0.15954344f, -0.06926841f, -0.03720902f, -0.00373096f, 
    -0.04190065f, 0.03332140f, 0.00274304f, -0.01548854f, 0.04621972f, 0.07806852f, 0.08369669f, -0.06601530f, 
    0.18017180f, 0.07297583f, -0.01621997f, -0.08804522f, -0.00889896f, 0.03393312f, -0.01984384f, -0.02332108f, 
    -0.23088376f, -0.07033859f, -0.51265973f, -0.10748161f, -0.01946999f, 0.04425123f, 0.04207779f, 0.08132942f, 
    0.16670687f, -0.02111197f, 0.18995047f, -0.16012120f, -0.07769817f, -0.11447554f, 0.01054597f, 0.11778569f, 
    0.16373307f, 0.01965956f, -0.06780099f, 0.00929458f, 0.04733164f, 0.03381159f, 0.01550410f, 0.01467836f, 
    0.24651173f, -0.02524867f, -0.29501614f, 0.02838712f, 0.00182388f, -0.12849958f, 0.08827811f, -0.02008196f, 
    0.20830123f, -0.03323955f, -0.07587488f, 0.00258661f, -0.05487233f, -0.52033347f, 0.44408208f, 0.01459726f, 
    -0.11281554f, 0.04076089f, -0.04090291f, 0.06411041f, 0.25350192f, -0.03393565f, 0.05567957f, 0.17816903f, 
    0.09078077f, -0.00119056f, 0.09228705f, -0.09812796f, -0.08164112f, -0.01335941f, -0.02997980f, 0.08716792f, 
    -0.07484797f, 0.03765997f, 0.22593215f, -0.19305071f, -0.12476657f, -0.06334087f, 0.09778582f, -0.03240659f, 
    -0.16078624f, -0.05092614f, -0.05210770f, -0.08605902f, -0.05169372f, 0.06935585f, 0.00058191f, 0.15085688f, 
    0.36476174f, -0.05892539f, -0.09301323f, -0.00217094f, -0.06039186f, -0.03761255f, 0.00761169f, -0.00342128f, 
    -0.04526355f, -0.22728610f, -0.21541370f, -0.23505838f, 0.25289524f, 0.07880466f, -0.07427020f, 0.00337056f, 
    0.09148700f, 0.14493613f, 0.08131678f, 0.00825917f, 0.07598808f, -0.01202228f, 0.00790255f, -0.00174711f, 
    0.27503777f, -0.07435864f, 0.44109181f, -0.03028368f, -0.11290990f, -0.00059511f, -0.01635808f, 0.09430179f, 
    0.06700470f, -0.06690948f, -0.03027889f, 0.11314081f, -0.00668082f, 0.03144161f, -0.19916210f, -0.05738761f, 
    0.04244878f, 0.02186785f, -0.04627432f, -0.10158493f, 0.17764643f, 0.05057938f, -0.15141289f, 0.00863497f, 
    -0.10646944f, 0.09598406f, -0.56724226f, -0.04825844f, 0.02646124f, 0.21339907f, -0.09192391f, 0.02046313f, 
    0.03169315f, -0.15024805f, 0.09091799f, -0.09665845f, -0.22104052f, -0.21642682f, 0.10694268f, 0.05398912f, 
    -0.05489581f, -0.02033593f, -0.01330038f, 0.02322227f, 0.18761387f, 0.15564990f, 0.13151211f, -0.05539619f, 
    0.02650254f, -0.16418903f, 0.06864582f, 0.19143756f, 0.22662862f, -0.07189891f, -0.10834676f, 0.04588548f, 
    -0.03720180f, 0.02797659f, 0.00809685f, -0.08114219f, 0.04043544f, -0.12689339f, 0.10541476f, -0.00619242f, 
    0.09475306f, -0.05380011f, 0.12442536f, 0.10515530f, 0.06294103f, 0.15062657f, -0.04195710f, -0.00708068f, 
    -0.05849828f, -0.13349181f, 0.19550534f, 0.03256001f, 0.11257295f, -0.07049249f, 0.02900518f, -0.11099220f, 
    -0.07609327f, 0.19649720f, -0.10946574f, 0.09272731f, 0.21799788f, 0.19358036f, 0.06692676f, 0.02731939f, 
    0.13405223f, 0.04941232f, 0.00556057f, -0.19345318f, -0.24210051f, -0.02935181f, 0.00354513f, -0.24035987f, 
    0.27279410f, -0.16637939f, -0.02511572f, -0.12396730f, -0.03574142f, -0.01528552f, 0.00989794f, 0.12525308f, 
    -0.08009531f, -0.09289546f, -0.20585202f, -0.22211544f, -0.52861190f, -0.32218048f, 0.13492948f, 0.17570505f, 
    -0.06319840f, -0.00816023f, -0.04267502f, -0.10031104f, 0.11031758f, 0.03218539f, -0.08670361f, -0.02406024f, 
    0.11515199f, -0.12431731f, -0.16776949f, 0.18541670f, 0.23904102f, -0.15566827f, 0.02043432f, 0.06429680f, 
    -0.15928958f, -0.05025136f, 0.26305294f, 0.32453424f, 0.05434993f, 0.05845818f, 0.01626176f, -0.15081142f, 
    0.23936646f, 0.13560995f, -0.04480167f, -0.22419541f, -0.00002919f, -0.01487674f, 0.02504606f, 0.06654710f, 
    0.03214494f, -0.04925516f, 0.09999258f, 0.14351991f, 0.09473970f, -0.21026488f, 0.09213030f, -0.06292582f, 
    0.06705322f, -0.11243591f, 0.02019153f, 0.08723734f, 0.10629151f, -0.38773909f, 0.15447059f, 0.01009887f, 
    0.02719961f, 0.01183535f, -0.05720622f, 0.11401699f, -0.06013011f, 0.01707575f, 0.08671616f, -0.10058717f, 
    0.20096745f, -0.02543316f, -0.03253529f, 0.03588451f, -0.00650026f, 0.06036456f, 0.08811091f, 0.18526837f, 
    0.17396177f, 0.01292871f, 0.00746658f, -0.04732246f, 0.28150925f, -0.20917939f, -0.20651776f, 0.07053836f, 
    0.07966445f, 0.04306130f, -0.01030515f, 0.05683147f, -0.01526453f, -0.09335215f, 0.12011528f, 0.08564952f, 
    0.02871423f, 0.02994903f, -0.06724643f, -0.04934879f, 0.01906572f, -0.02707127f, -0.02865770f, 0.02224009f, 
    0.06361975f, 0.07250943f, -0.06631320f, 0.05094691f, 0.02702522f, -0.04730218f, -0.10912660f, -0.05030458f, 
    0.07885660f, -0.05807079f, -0.04039506f, 0.35990483f, -0.04839407f, -0.07883758f, 0.03903679f, 0.03087950f, 
    -0.05057922f, -0.04440254f, -0.07733782f, 0.05702300f, 0.03040501f, -0.05495799f, -0.06978211f, 0.03126168f, 
    -0.08407997f, -0.04418759f, 0.04570565f, -0.06045073f, -0.20687260f, 0.03225569f, 0.04336921f, 0.05046942f, 
    -0.01770893f, -0.12810135f, -0.00026072f, -0.05541468f, -0.00936446f, -0.00677103f, 0.01872155f, 0.12640350f, 
    0.07655135f, -0.11832779f, -0.11717043f, -0.01716638f, 0.05767074f, 0.01149109f, 0.06364201f, -0.01492791f, 
    -0.14680487f, -0.17161480f, -0.47223267f, -0.75572324f, -0.18016918f, 0.12181590f, -0.00464261f, -0.22262453f, 
    -0.01299189f, 0.02022517f, 0.12438083f, 0.26582903f, -0.04413082f, -0.10802430f, -0.17628594f, 0.11920104f, 
    -0.29289216f, -0.02052251f, 0.00027655f, -0.24645513f, -0.02600933f, -0.04829888f, 0.02343301f, 0.04757104f, 
    0.10666202f, 0.15612395f, -0.13387741f, 0.16021651f, -0.25232288f, -0.19136713f, 0.09591948f, -0.02926164f, 
    0.10611743f, -0.14716150f, 0.02531007f, 0.26697907f, -0.14203498f, 0.01836850f, 0.08007085f, -0.01259066f, 
    0.05127068f, 0.02251804f, 0.03331229f, -0.37711564f, -0.10660961f, 0.02340665f, -0.08201329f, -0.02007604f, 
    0.00860163f, -0.10919856f, 0.18295135f, -0.03710950f, -0.00139730f, 0.13214080f, -0.05832785f, 0.02480982f, 
    0.05830960f, -0.09092623f, 0.01149361f, 0.19681266f, 0.04133899f, -0.01375673f, 0.07004119f, 0.05518972f, 
    0.02139180f, 0.12459032f, 0.13718712f, -0.17078981f, 0.11701491f, -0.02094456f, 0.18110242f, -0.02504433f, 
    0.05094025f, 0.09024756f, -0.01792368f, 0.10352600f, -0.07707188f, -0.08402982f, -0.08009165f, 0.02522289f, 
    0.15444848f, -0.01417641f, -0.04315772f, 0.19369361f, -0.05330145f, -0.01336246f, 0.14117660f, 0.18906489f, 
    -0.36136696f, -0.11438995f, 0.27565944f, -0.10194966f, -0.00755891f, -0.00400199f, -0.03412357f, 0.10410152f, 
    -0.00857297f, -0.24748385f, -0.21817863f, -0.08541414f, -0.13847144f, -0.03742466f, 0.14021306f, 0.07283512f, 
    -0.04203559f, -0.04314449f, 0.14710678f, 0.15968023f, 0.07470274f, 0.03266892f, 0.11876459f, 0.13340119f, 
    -0.02416554f, -0.03681239f, -0.12219469f, 0.02784790f, 0.06397222f, 0.03619168f, 0.02014467f, -0.02444607f, 
    0.27609783f, -0.03190932f, 0.05263999f, -0.14087939f, -0.22097459f, 0.12892847f, -0.15180333f, -0.27221689f, 
    0.05511510f, 0.12296775f, -0.03889068f, 0.13751400f, 0.12236810f, -0.03785115f, -0.10020535f, -0.06121457f, 
    0.13678530f, 0.11733779f, 0.20627059f, -0.11200998f, -0.04057898f, 0.16372804f, 0.08570898f, 0.08234453f, 
    -0.02712624f, -0.00843584f, 0.05962220f, -0.01522047f, 0.07663453f, 0.17939465f, -0.35408568f, 0.11230804f, 
    0.08006671f, 0.00920000f, -0.03541314f, -0.00185129f, -0.05940471f, 0.09705564f, -0.07719987f, -0.15663773f, 
    0.01670882f, -0.18287049f, 0.05811129f, -0.03652878f, 0.04580726f, -0.01195118f, -0.01832185f, 0.08805879f, 
    0.11103693f, -0.40558776f, -0.19075380f, -0.27717662f, 0.20253521f, 0.03157800f, -0.07661546f, -0.30280471f, 
    0.05559652f, -0.05406132f, -0.01860366f, -0.15502198f, -0.09240392f, 0.09766693f, 0.18935993f, -0.00048774f, 
    0.14861177f, 0.19736607f, 0.02360642f, 0.00330467f, 0.08706989f, -0.14101647f, -0.06995620f, -0.09564387f, 
    0.04252810f, 0.01219127f, 0.06993343f, -0.02090050f, -0.32085985f, 0.02483257f, -0.04104055f, -0.00532988f, 
    0.03325310f, -0.27566361f, -0.16584526f, 0.37282163f, -0.01294551f, 0.09485110f, -0.07468345f, -0.13665323f, 
    0.12961505f, 0.20889013f, -0.14723481f, -0.07971264f, -0.19055191f, 0.03626700f, 0.00079865f, -0.16615398f, 
    0.08627543f, 0.10787190f, 0.07179908f, 0.10964736f, 0.18352389f, 0.09355974f, -0.00940151f, 0.02134106f, 
    0.06428484f, -0.05726894f, 0.10530223f, -0.00596260f, 0.01423244f, 0.14378458f, -0.10786480f, 0.03524873f, 
    -0.07600190f, -0.02131658f, -0.03329998f, -0.12114670f, 0.19473042f, 0.05058718f, 0.21227404f, 0.12947188f, 
    -0.01108585f, 0.02220824f, 0.03942041f, 0.04039139f, 0.46470028f, -0.01370278f, -0.13703945f, 0.18521176f, 
    -0.06854705f, -0.00455079f, 0.04265920f, 0.15492585f, -0.03109582f, -0.16588578f, 0.01339723f, 0.10048159f, 
    -0.38425523f, -0.13842960f, -0.25322551f, 0.03091151f, 0.00951331f, 0.06486911f, -0.04841879f, 0.13434000f, 
    0.02235314f, 0.07414021f, 0.13994582f, -0.14421298f, -0.13466313f, -0.18267702f, -0.04258865f, 0.09932213f, 
    0.06803276f, -0.03942705f, -0.04843098f, -0.06605837f, 0.08439735f, -0.16007926f, 0.09133875f, 0.27601635f, 
    -0.06278720f, -0.10872760f, 0.01040960f, 0.04594350f, 0.08917785f, 0.01657568f, -0.03389891f, 0.06074014f, 
    -0.00033604f, -0.08483580f, 0.01543352f, -0.04034225f, -0.41588944f, -0.28715432f, -0.07797538f, -0.12649491f, 
    -0.00490300f, 0.05895066f, 0.00863979f, 0.03340400f, 0.06498343f, -0.15159681f, -0.00919318f, -0.00512020f, 
    -0.39621255f, -0.13698035f, -0.05109529f, -0.07072242f, 0.04603758f, -0.02564100f, -0.03238594f, -0.07493405f, 
    -0.04320493f, -0.02219447f, 0.04826182f, 0.08465778f, -0.68107724f, -0.31890768f, -0.37983358f, -0.11787768f, 
    0.06923545f, 0.00441468f, -0.06048225f, -0.02268038f, 0.13821627f, -0.01178129f, 0.12226895f, -0.05620067f, 
    -0.00945111f, 0.03293581f, 0.01834049f, -0.11029814f, -0.07950316f, -0.11875168f, 0.10256115f, 0.16384465f, 
    -0.06036746f, -0.07840031f, 0.02809034f, -0.01136235f, -0.11146158f, -0.10986312f, -0.19009642f, 0.13040055f, 
    0.24904065f, -0.02288275f, -0.07033740f, 0.10815223f, 0.07696440f, -0.02249190f, -0.03083976f, 0.01869587f, 
    0.08789197f, 0.00208109f, -0.14264494f, 0.06560867f, 0.04624996f, -0.01007509f, 0.03798311f, 0.09057503f, 
    0.02291865f, -0.03651231f, 0.02574599f, 0.12902996f, -0.29877916f, -0.48032439f, -0.59193021f, -0.01822633f, 
    -0.08239098f, -0.07926609f, -0.05153150f, -0.28345227f, -0.04468992f, 0.03628162f, -0.02464030f, -0.02347650f, 
    0.03391227f, -0.06219064f, -0.09758933f, 0.13727483f, 0.05763494f, 0.03150538f, 0.13096926f, 0.01216390f, 
    0.05996255f, -0.06942052f, -0.07973898f, 0.09563208f, -0.08375508f, -0.11718792f, -0.00217409f, 0.06641720f, 
    -0.07712006f, -0.05878866f, -0.06774037f, -0.00214944f, -0.02676627f, -0.00226782f, -0.04338188f, -0.19327441f, 
    -0.23078658f, -0.49993932f, -0.08985435f, 0.31568497f, 0.11692581f, 0.08993626f, 0.00479422f, -0.07015006f, 
    -0.00289388f, 0.00985258f, 0.13783957f, 0.01902710f, -0.69837153f, -0.47359240f, -0.16185156f, -0.42623541f, 
    -0.09733204f, -0.26510656f, -0.33718848f, -0.24264392f, -0.01338653f, -0.08830687f, -0.03209453f, -0.02445225f, 
    0.48846418f, -0.01772682f, 0.06244328f, 0.22821173f, 0.04625929f, 0.00329570f, -0.08197899f, -0.12291940f, 
    0.05048310f, 0.13329610f, -0.01778585f, 0.00695747f, -0.12883657f, -0.03769441f, -0.19377218f, 0.08134980f, 
    -0.00633556f, 0.11064725f, 0.04419027f, 0.06232312f, -0.02746165f, -0.06223880f, 0.01425954f, -0.00404185f, 
    0.69762790f, 0.07878894f, -0.38106301f, 0.03987497f, -0.00645733f, -0.00921582f, 0.10482486f, 0.11948083f, 
    0.08769211f, 0.10528247f, -0.00130407f, -0.16823792f, -0.08734020f, -0.24442451f, -0.14044538f, 0.13341300f, 
    0.01024124f, -0.07695477f, 0.04768525f, 0.24583799f, 0.16075152f, 0.12411256f, 0.10406148f, -0.03176171f, 
    0.07173508f, -0.00951772f, -0.00010963f, -0.00647990f, -0.10108725f, 0.04100246f, -0.00404533f, -0.00138128f, 
    0.13578001f, 0.04012711f, 0.04147678f, 0.01097645f, 0.03443981f, -0.57299024f, -0.10419858f, 0.11521009f, 
    -0.07203846f, 0.06184350f, -0.02762117f, -0.06007130f, -0.05872504f, 0.03760021f, 0.08693726f, -0.09874633f, 
    -0.13117686f, 0.07121604f, -0.10597516f, 0.16280146f, -0.02435185f, 0.11685470f, -0.18578595f, 0.17266400f, 
    0.15803739f, -0.03132736f, 0.13718693f, -0.03694817f, -0.76177126f, -0.32718456f, 0.03680528f, -0.39285466f, 
    0.00589848f, 0.06691080f, 0.14477436f, -0.08888124f, 0.02095408f, 0.03631558f, 0.02645542f, 0.09310108f, 
    -0.09255707f, -0.85632992f, -0.11034207f, 0.01711797f, -0.18716258f, -0.13680467f, -0.01027583f, 0.02088830f, 
    -0.10418931f, 0.00926091f, -0.01579519f, 0.00361406f, -0.35083392f, 0.21595174f, 0.34804955f, -0.09121528f, 
    -0.06413504f, -0.11298260f, -0.08112013f, -0.08521643f, -0.04459357f, -0.00315424f, -0.02984712f, 0.03302488f, 
    0.09396822f, 0.10780573f, 0.14415002f, -0.13602524f, 0.11349371f, -0.04350517f, 0.14694373f, -0.16015825f, 
    0.03207102f, 0.00336020f, 0.04134991f, 0.02379531f, -0.12596364f, -0.03041073f, 0.23096485f, 0.32589972f, 
    -0.00890317f, 0.00388227f, 0.00929395f, 0.17242521f, 0.00062832f, 0.06096941f, 0.07987957f, 0.08588767f, 
    -0.05072424f, 0.00419386f, -0.06875730f, -0.12431555f, -0.07127389f, 0.20427138f, 0.08182030f, -0.16870381f, 
    0.05009468f, 0.04895702f, -0.04965978f, 0.08922046f, -0.19907913f, -0.09495392f, -0.06721235f, 0.14678800f, 
    -0.07969235f, 0.07096615f, -0.06571947f, -0.06239326f, -0.11486483f, -0.05042342f, 0.00871739f, 0.01863623f, 
    -0.16344555f, 0.15014288f, -0.13101192f, -0.00052088f, -0.00082149f, -0.02209263f, -0.30226788f, 0.08380935f, 
    0.01219196f, -0.07965291f, 0.07047281f, -0.06206766f, -0.35255668f, -0.24742998f, 0.13919143f, 0.07563869f, 
    -0.04139907f, 0.02515118f, -0.01066350f, 0.05168341f, 0.00562973f, -0.01575474f, 0.07102653f, -0.03443836f, 
    0.22533482f, 0.19649686f, -0.12566046f, -0.06637187f, -0.02934853f, 0.06711205f, -0.04799971f, 0.08080023f, 
    0.05752280f, 0.14980833f, -0.14036116f, 0.10333396f, -0.15797137f, -0.01973367f, 0.22428961f, 0.36356488f, 
    -0.04327453f, -0.04133765f, -0.11085650f, 0.02514141f, 0.03061265f, 0.06941835f, 0.18502769f, -0.11085901f, 
    0.04448197f, -0.09049618f, 0.13380164f, 0.22505979f, 0.06807273f, -0.16579597f, 0.11269892f, -0.02888706f, 
    -0.00189674f, 0.02106076f, -0.08082829f, -0.22793113f, -0.63609564f, -0.50176710f, -0.31474116f, -0.22739939f, 
    -0.22660431f, -0.11501984f, -0.22325985f, -0.21441051f, -0.00035751f, -0.00633333f, -0.00602568f, 0.00201930f, 
    -0.05424599f, -0.06944998f, -0.05103860f, -0.15266974f, 0.05749088f, 0.00462770f, -0.04926454f, -0.03410753f, 
    -0.01261544f, 0.01766567f, 0.06375617f, -0.05061835f, -0.29668862f, -0.00330754f, -0.19319302f, -0.08284873f, 
    0.06712623f, 0.09379180f, -0.12048675f, -0.13291511f, -0.03944093f, 0.04424774f, 0.02633573f, 0.01442105f, 
    0.01356241f, -0.00878030f, -0.00248648f, 0.07826409f, 0.02318073f, -0.10531648f, 0.06654949f, -0.08943346f, 
    0.00861081f, -0.08103769f, -0.08042154f, 0.01895806f, 0.05006725f, 0.23672070f, -0.10869098f, -0.14881191f, 
    -0.04438864f, 0.12516172f, -0.04072241f, -0.01667789f, -0.04931990f, 0.02270074f, 0.15101451f, -0.31191155f, 
    -0.06943023f, -0.04550873f, 0.02010416f, 0.06923806f, 0.12615654f, -0.06758809f, 0.02623005f, 0.05849445f, 
    0.05300806f, 0.02452285f, 0.04532533f, -0.08057035f, 0.19355071f, 0.07235350f, -0.05741182f, 0.16771232f, 
    -0.13939290f, 0.06374484f, 0.05860541f, 0.27558622f, 0.07356796f, -0.10246497f, 0.04094918f, -0.03599067f, 
    0.02960847f, -0.09085157f, -0.06226199f, -0.09130332f, 0.03888286f, -0.09565955f, 0.01678330f, 0.04391654f, 
    -0.13071315f, -0.11950106f, -0.05744468f, -0.22662461f, -0.24481148f, -0.03906145f, 0.32744557f, -0.11706408f, 
    -0.03128964f, -0.11459825f, -0.05912735f, 0.03085628f, -0.09408578f, 0.13437180f, 0.00617161f, 0.02385447f, 
    -0.01986888f, 0.03388128f, -0.07942329f, 0.03616415f, 0.00128765f, 0.00776542f, 0.12392633f, -0.06185748f, 
    0.23967756f, 0.04708992f, 0.24219573f, 0.10132963f, 0.10672291f, -0.00747755f, 0.08176972f, 0.06099061f, 
    0.07847810f, -0.02561635f, 0.00577417f, 0.14170361f, 0.03173355f, 0.15138933f, 0.05271612f, -0.01222810f, 
    -0.02788439f, 0.04797597f, 0.17829131f, -0.00289655f, 0.02625768f, -0.15546535f, 0.01209873f, 0.04430270f, 
    0.04847795f, 0.11078795f, 0.04719501f, 0.01794676f, -0.12943017f, 0.07305224f, 0.13122711f, 0.02587756f, 
    -0.02951638f, -0.06331166f, -0.15238519f, 0.24790746f, 0.03699827f, 0.11709969f, 0.05952059f, -0.02753346f, 
    -0.03301413f, 0.27935922f, 0.05722421f, 0.01845095f, 0.08782224f, 0.02290611f, 0.08433288f, 0.09594608f, 
    -0.00649570f, 0.05061478f, 0.12573725f, -0.06682547f, 0.06566378f, -0.27155039f, -0.03344914f, 0.14069630f, 
    -0.13235565f, -0.08407276f, 0.06832474f, 0.01293908f, -0.00944147f, 0.03100059f, 0.00654902f, -0.12066969f, 
    -0.33567354f, -0.48635510f, -0.36871263f, -0.21451604f, -0.00832727f, -0.12512308f, -0.22074902f, 0.01218786f, 
    -0.04479761f, 0.04139653f, -0.00723598f, -0.03324296f, 0.07603713f, 0.03027852f, 0.11813694f, -0.06346352f, 
    0.01825213f, 0.01751867f, 0.17828868f, -0.13739465f, 0.10687052f, 0.07133072f, -0.00496939f, -0.00153559f, 
    -0.02212266f, -0.09380151f, 0.09843695f, -0.08814050f, -0.05100781f, 0.00102117f, 0.06670611f, 0.10274927f, 
    0.12083708f, 0.18750176f, 0.13708620f, 0.17383234f, -0.27932003f, -0.31409225f, -0.46417186f, -0.04393069f, 
    -0.24441008f, -0.33986890f, -0.16809680f, 0.00978226f, -0.02341384f, 0.00824043f, -0.01209584f, -0.08243715f, 
    -0.18753643f, 0.11152086f, 0.10207175f, -0.09276386f, 0.02843184f, 0.04648764f, 0.03697930f, 0.02152958f, 
    0.11735389f, 0.06894049f, 0.13543984f, 0.06625634f, -0.68930417f, -0.10660481f, 0.11229531f, -0.20198901f, 
    0.00995543f, -0.08675480f, 0.11411911f, -0.04493434f, -0.08714507f, 0.02928865f, 0.07772709f, 0.07387231f, 
    -0.35702962f, -0.72591335f, -0.29115525f, 0.08014312f, 0.10732158f, -0.12505360f, 0.09498062f, -0.37508363f, 
    -0.02257081f, 0.02768404f, 0.02442908f, 0.04057932f, 0.29654616f, 0.14334583f, -0.16118278f, -0.21090843f, 
    0.13081864f, 0.06403145f, 0.24453577f, 0.05410469f, -0.00888732f, 0.02670738f, 0.02322556f, 0.12963542f, 
    -0.09384436f, 0.14009836f, -0.02737101f, -0.05140153f, -0.04256619f, 0.04424090f, -0.01892978f, 0.03957387f, 
    0.10825554f, 0.06732048f, 0.10722560f, 0.04417370f, -0.05169998f, 0.52096480f, 0.05524903f, -0.02584575f, 
    -0.02824334f, 0.04139357f, -0.05037519f, -0.09187219f, -0.02737536f, -0.03650920f, -0.13203113f, 0.15519410f, 
    -0.55782062f, -0.52874333f, -0.12458090f, -0.76490003f, -0.18659268f, -0.05970312f, 0.05192865f, -0.06519336f, 
    0.00412375f, 0.07931629f, 0.09128541f, -0.03583223f, -0.01585140f, -0.15261963f, 0.03010990f, 0.07884400f, 
    0.00595554f, 0.12233647f, -0.00711794f, 0.04432718f, -0.01630102f, -0.07421903f, 0.04563891f, 0.01474682f, 
    -0.24211864f, -0.42797810f, -0.04753572f, -0.13855010f, -0.06223064f, -0.03007234f, -0.13511053f, -0.04116449f, 
    -0.00446623f, -0.03017431f, 0.01737979f, -0.03364915f, -0.58501416f, -0.56330872f, -0.18945509f, 0.45074311f, 
    0.05075262f, 0.10237622f, -0.19356079f, -0.27721959f, 0.01738854f, -0.02077151f, 0.03292007f, 0.03980389f, 
    -0.54983693f, -0.19931513f, 0.21635866f, -0.16347767f, 0.07096474f, -0.12727411f, 0.12411665f, -0.15100561f, 
    0.02725496f, 0.01680991f, -0.01876683f, 0.04526134f, 0.50454968f, 0.19311495f, -0.35082754f, -0.05074346f, 
    -0.22860005f, -0.04139975f, 0.26430708f, 0.24221030f, 0.14085948f, 0.03156020f, 0.08595087f, -0.08946941f, 
    0.26185194f, 0.05233394f, -0.04953177f, -0.23857881f, -0.05316884f, -0.00694008f, 0.04681783f, 0.04395451f, 
    -0.05726833f, 0.04210339f, -0.01189547f, -0.23177430f, -0.04955109f, 0.00341709f, -0.04980562f, 0.14469960f, 
    -0.08160593f, -0.05152945f, 0.00640023f, 0.00342758f, -0.03103708f, -0.16634446f, 0.00367615f, 0.07433616f, 
    0.05349551f, 0.02732926f, -0.15702860f, -0.01259060f, -0.01238781f, -0.03246140f, 0.04831663f, 0.07180507f, 
    -0.04203562f, -0.01831709f, 0.02082479f, -0.11397297f, -0.03786197f, -0.14921837f, -0.05276232f, -0.16700269f, 
    -0.00843829f, 0.02718864f, 0.05285595f, -0.00012193f, -0.00178714f, 0.07928470f, -0.18777151f, -0.01707030f, 
    -0.42138705f, -0.40611702f, 0.10181413f, 0.46014643f, -0.06986287f, -0.00086434f, 0.03441068f, 0.05619060f, 
    -0.04855621f, 0.05431664f, 0.00925869f, -0.05380768f, -0.36323062f, 0.10960293f, 0.41844875f, 0.18868802f, 
    -0.01576657f, 0.00608712f, -0.06681886f, -0.08300380f, 0.01238463f, 0.07166031f, -0.03935229f, 0.17217541f, 
    -0.32961884f, -0.28746155f, -0.15494992f, 0.16403575f, -0.13538803f, 0.11264905f, 0.09869866f, 0.17799109f, 
    0.00346305f, 0.02572282f, 0.04353460f, -0.01018387f, -0.15529023f, -0.53155744f, -0.48672941f, -0.08588767f, 
    0.04028004f, 0.16400388f, 0.15232909f, 0.01027550f, -0.00900394f, 0.01494378f, -0.03509019f, 0.02245080f, 
    0.10022491f, -0.03910325f, -0.01799360f, -0.06413759f, -0.01441072f, -0.06194177f, 0.01413579f, -0.05464606f, 
    0.00656492f, 0.01277776f, -0.12322295f, -0.12200707f, -0.21700957f, -0.19792420f, -0.12960365f, -0.20951577f, 
    0.07655050f, -0.12936786f, 0.03621771f, 0.20599335f, 0.03694559f, 0.02694362f, -0.02917706f, -0.01561642f, 
    0.16100316f, -0.09263261f, 0.03257982f, -0.18378623f, 0.01979897f, 0.00070455f, -0.08964382f, -0.05544566f, 
    -0.03550342f, 0.07517199f, -0.08906315f, -0.19990136f, 0.01623810f, 0.01878127f, 0.05833197f, -0.08997999f, 
    -0.09148016f, 0.05260756f, 0.09335456f, 0.00747664f, 0.04696107f, -0.01959592f, 0.01375444f, 0.04464294f, 
    0.09825831f, -0.18728203f, 0.12037855f, -0.10733736f, -0.00215517f, -0.06466360f, -0.14445114f, 0.11770975f, 
    -0.12872671f, 0.00071432f, -0.01288770f, -0.02705657f, -0.47202107f, -0.29236004f, -0.15647407f, 0.25423729f, 
    0.10789260f, -0.04574006f, 0.02546752f, 0.06612873f, 0.00915063f, -0.00674431f, 0.05975723f, 0.03411157f, 
    -0.11556713f, 0.02990095f, 0.08995346f, 0.04043652f, -0.06286228f, 0.06480440f, 0.06819227f, 0.01717570f, 
    0.05339429f, 0.00830064f, -0.02322725f, -0.08342167f, 0.05489177f, -0.05871590f, 0.07555252f, -0.05958870f, 
    -0.00762689f, 0.00450923f, -0.01292510f, -0.07200477f, 0.03279455f, 0.07956586f, 0.04961932f, -0.02913862f, 
    -0.47460499f, -0.26641253f, -0.23432024f, 0.12066970f, -0.07327293f, -0.01791157f, 0.08685340f, -0.03656053f, 
    -0.09056797f, -0.02200799f, 0.15226896f, 0.00523313f, 0.36083952f, -0.30744192f, 0.34033537f, -0.44746420f, 
    0.01422955f, 0.13697203f, -0.06581198f, -0.05695989f, -0.04879081f, 0.07243045f, -0.00692866f, -0.20089410f, 
    -0.03251406f, -0.19596475f, -0.03175459f, 0.01412393f, 0.13672678f, 0.06739148f, 0.00917095f, 0.03824613f, 
    -0.00088640f, -0.01055987f, 0.07505768f, -0.02196633f, 0.00911599f, -0.51435506f, 0.10162095f, -0.32491666f, 
    -0.13594304f, 0.03720788f, -0.06358797f, 0.29565504f, -0.02142713f, 0.01435720f, -0.11460573f, -0.00622989f, 
    0.07555269f, -0.25392932f, 0.06744386f, -0.05333836f, 0.00947769f, -0.10234912f, 0.12922843f, -0.01474395f, 
    -0.06446289f, 0.09988847f, 0.02323348f, -0.02321942f, -0.30839190f, 0.38034168f, -0.04336972f, 0.05261826f, 
    0.02306393f, -0.22947127f, 0.00204820f, 0.00123732f, 0.10057376f, 0.04111883f, 0.03337532f, -0.04355675f, 
    0.39365619f, -0.64251232f, 0.44519791f, 0.43844131f, -0.02242194f, 0.13452703f, -0.05302343f, -0.02449108f, 
    0.05121784f, -0.13357741f, -0.02085133f, -0.11191822f, 0.08663876f, 0.14587830f, -0.15056112f, -0.01276453f, 
    0.05090839f, -0.01663121f, 0.03456106f, 0.03610514f, 0.02340719f, 0.04217740f, 0.00849885f, 0.07401536f, 
    -0.07242424f, 0.20030633f, 0.01388287f, 0.11897383f, -0.10659816f, 0.14185023f, 0.08755927f, -0.01696978f, 
    -0.18571152f, 0.03403497f, -0.02220229f, -0.20837599f, 0.33608907f, -0.42151788f, 0.07803508f, -0.26839030f, 
    -0.01052559f, 0.02914239f, -0.06519352f, -0.03506018f, -0.08300053f, 0.09709931f, 0.03573348f, -0.11125196f, 
    0.12514886f, 0.12416018f, -0.12030372f, 0.03806606f, 0.01221381f, -0.00117158f, 0.02138867f, -0.17887640f, 
    -0.00424861f, 0.01539155f, -0.03534261f, 0.09402674f, 0.10397199f, -0.07803977f, -0.01106041f, -0.10135321f, 
    -0.16324981f, -0.13602680f, -0.03259005f, -0.01900562f, 0.00364450f, 0.06959318f, 0.05083827f, -0.07196967f, 
    0.11509710f, -0.06358813f, 0.07937269f, 0.09967831f, -0.02244746f, -0.01638946f, -0.08316457f, 0.00629369f, 
    0.04814873f, 0.04154789f, -0.05354801f, -0.07514299f, -0.47755733f, 0.01885659f, -0.00263786f, 0.07027594f, 
    0.00877123f, 0.00521518f, 0.03582155f, 0.11140268f, 0.04648158f, -0.03404751f, 0.11391864f, 0.04951898f, 
    -0.51666969f, -0.26554853f, -0.07861811f, -0.25956404f, -0.15161887f, -0.03160087f, 0.12188451f, 0.06020029f, 
    -0.06416335f, 0.05205989f, 0.09933559f, 0.01836266f, 0.44578040f, -0.21884654f, -0.24025817f, -0.36210027f, 
    -0.00291967f, 0.00461751f, -0.08569250f, -0.03393316f, -0.08711307f, 0.05008352f, 0.05376818f, 0.03549913f, 
    -0.01250679f, 0.02011300f, 0.04204510f, -0.02038321f, -0.12056425f, 0.10290526f, -0.12259473f, -0.05518843f, 
    -0.14038166f, -0.02626146f, -0.01672282f, 0.02259190f, -0.33077881f, -0.20059429f, -0.09887585f, 0.09954840f, 
    0.10726123f, 0.08982518f, 0.08157557f, 0.13224207f, 0.06214256f, 0.00178827f, 0.03688055f, 0.04000773f, 
    0.26487774f, 0.00561382f, 0.00325573f, -0.02145974f, 0.03404089f, -0.06229315f, -0.04480415f, -0.13420328f, 
    -0.01816016f, 0.12435824f, 0.01669955f, -0.03110322f, 0.11503311f, -0.32379383f, 0.01607158f, -0.20970991f, 
    0.01597631f, -0.22532770f, 0.06823441f, -0.15805714f, 0.01142116f, -0.00080649f, 0.02819528f, -0.01416728f, 
    -0.04995979f, -0.01779860f, 0.12161712f, -0.00853962f, -0.16021045f, -0.12859175f, -0.16211353f, -0.07988332f, 
    0.01391283f, 0.03374936f, 0.01690794f, 0.01404058f, 0.00675180f, -0.07638372f, 0.04280982f, -0.02766629f, 
    0.12461459f, 0.00728919f, 0.00068519f, -0.02526083f, 0.00561283f, -0.02226610f, -0.02888542f, 0.11066481f, 
    -0.00852602f, 0.10746159f, 0.11452926f, -0.16058166f, -0.07203346f, 0.04221340f, 0.03104909f, 0.05006592f, 
    0.11401282f, -0.03540273f, 0.01709994f, 0.00441604f, -0.03372108f, 0.04441338f, -0.04766542f, -0.01829764f, 
    -0.04685438f, -0.05106666f, 0.05963296f, -0.24648471f, -0.02869828f, 0.11474287f, -0.00149996f, -0.01681860f, 
    0.05649535f, 0.03941549f, 0.01682790f, -0.09240395f, -0.00657842f, 0.02829490f, -0.03687230f, 0.01588422f, 
    0.02844413f, 0.04358749f, -0.03643431f, -0.07101632f, 0.33898747f, 0.18344733f, -0.22056483f, -0.37142456f, 
    0.01951694f, 0.06607533f, 0.02334387f, 0.04458767f, -0.07486116f, 0.02274095f, -0.09978770f, -0.17316224f, 
    0.08330137f, 0.04711895f, 0.05273793f, 0.05351610f, 0.03498875f, -0.10126320f, 0.02837156f, -0.02821554f, 
    0.03047740f, 0.16358124f, -0.02103868f, 0.00199985f, -0.17262530f, 0.03409556f, 0.19124572f, 0.06245618f, 
    0.07326553f, -0.20145856f, 0.01284016f, -0.02307626f, 0.01253457f, -0.06239710f, 0.09921193f, -0.02129833f, 
    0.23022552f, -0.05206230f, -0.05242329f, -0.05713835f, 0.00061137f, 0.00677168f, 0.05493465f, -0.02996104f, 
    -0.09109684f, 0.03696265f, 0.03459965f, 0.07349826f, 0.42648622f, -0.04182033f, -0.09068752f, -0.09502584f, 
    -0.00297828f, -0.06603604f, -0.04869573f, 0.02910749f, 0.00326117f, -0.05225191f, 0.02806048f, 0.02469705f, 
    -0.30298433f, -0.10407598f, 0.21145861f, 0.08876719f, 0.05297064f, -0.00180143f, 0.01129837f, -0.06793127f, 
    0.06920793f, -0.04308798f, -0.02283906f, -0.12806240f, -0.38544941f, 0.02796063f, 0.11507954f, 0.09739471f, 
    0.00350063f, -0.00749874f, 0.09950233f, 0.08732629f, 0.03938326f, 0.04554141f, 0.05017126f, 0.01528442f, 
    -0.28842461f, -0.39719477f, -0.09195381f, 0.23515964f, -0.07319465f, 0.12637573f, -0.08370862f, 0.00211108f, 
    0.03031451f, 0.03095330f, 0.01993768f, -0.04397125f, -0.09753585f, 0.08526858f, 0.14351337f, 0.10573188f, 
    -0.00797990f, -0.16438760f, 0.00527598f, -0.13979566f, 0.01340397f, 0.02285780f, 0.00118596f, 0.07216010f, 
    0.22554213f, -0.11336876f, -0.11759561f, -0.06819894f, -0.02404650f, -0.10508921f, -0.11099170f, 0.04819079f, 
    0.07305186f, 0.12817921f, 0.04863286f, 0.01341232f, 0.00323411f, -0.31463799f, -0.16154505f, 0.05718613f, 
    -0.12689796f, -0.08976689f, -0.26336911f, 0.02681289f, 0.05662380f, 0.02560179f, 0.03018275f, -0.03007619f, 
    0.24781948f, 0.01580656f, -0.07516336f, -0.00941168f, 0.04214133f, 0.03259780f, 0.01062588f, -0.01148552f, 
    0.05049541f, -0.03348126f, 0.11978863f, -0.07405739f, 0.28419611f, -0.57938957f, -0.27806777f, -0.46044391f, 
    -0.00304096f, -0.25864682f, 0.05608126f, 0.14427553f, 0.03265713f, 0.09218189f, -0.03353841f, 0.10796972f, 
    -0.37489322f, -0.45667905f, 0.64439923f, -0.25554022f, -0.10527086f, -0.09358510f, 0.03832947f, 0.10069277f, 
    -0.02715542f, -0.07081893f, 0.01979862f, -0.03139365f, -0.45110029f, 0.40833452f, 0.04734165f, 0.27278236f, 
    -0.02480030f, 0.04867886f, 0.11329053f, 0.06274716f, 0.04407734f, -0.04468638f, 0.05292044f, -0.01751541f, 
    0.28463784f, -0.37858438f, -0.07563154f, -0.16162978f, -0.01335756f, -0.04827416f, -0.04634748f, 0.04239007f, 
    0.14348805f, 0.06116785f, -0.01236603f, 0.02289908f, -0.04910368f, -0.33448967f, 0.12538505f, -0.16296421f, 
    0.03100316f, -0.02937095f, 0.03244526f, 0.02578813f, -0.17488129f, 0.04131323f, -0.02420480f, 0.08725876f, 
    -0.49762750f, 0.73772764f, -0.64504123f, 0.46698827f, -0.01624860f, -0.19917257f, 0.14612749f, -0.12148970f, 
    -0.09321026f, -0.04526220f, -0.26148400f, 0.07272086f, 0.09993614f, 0.07784158f, -0.02110236f, 0.01019726f, 
    0.00539265f, -0.03458378f, -0.15999246f, -0.07703525f, -0.00827305f, 0.00241828f, 0.06361766f, 0.05337934f, 
    -0.34140512f, 0.12612700f, -0.19445971f, 0.07501578f, 0.01856685f, -0.15256071f, 0.08104497f, 0.03338527f, 
    0.01143247f, -0.04636765f, 0.03515865f, 0.08513022f, -0.21737528f, -0.37881595f, 0.29097295f, -0.29193735f, 
    0.03090850f, -0.11462840f, 0.05947573f, 0.05792422f, -0.04320658f, 0.01996544f, 0.03026942f, -0.00890639f, 
    -0.22506255f, -0.21928874f, -0.17159103f, -0.30488348f, 0.06206436f, -0.07077470f, 0.04249959f, 0.05558596f, 
    0.03482804f, 0.01683440f, -0.01586270f, -0.02333353f, -0.10412280f, -0.01582470f, -0.24999765f, -0.05703259f, 
    -0.11812361f, -0.03196336f, 0.00477155f, -0.01360597f, -0.07493480f, 0.12499976f, -0.11732557f, 0.03664093f, 
    -0.04431484f, 0.16516913f, 0.11145140f, 0.10516018f, 0.00957182f, -0.00298644f, -0.05067976f, -0.03724948f, 
    0.03827462f, -0.06088413f, 0.00823348f, -0.14753854f, 0.08118277f, 0.01642813f, -0.08763315f, -0.03340905f, 
    -0.01108151f, 0.16746056f, 0.01556708f, 0.03425458f, -0.03741489f, -0.00674780f, -0.01091978f, -0.06510880f, 
    0.09598307f, -0.03628090f, 0.07339182f, -0.11414331f, -0.01054637f, 0.03320154f, -0.06647773f, -0.04325216f, 
    0.02960670f, 0.02103478f, -0.02539275f, -0.02742902f, 0.06580177f, -0.10857303f, 0.00966289f, -0.07986455f, 
    -0.00058192f, 0.03518611f, -0.02308518f, -0.00256418f, 0.02157721f, -0.09105201f, -0.01366596f, 0.02785679f, 
    0.14180134f, -0.48288575f, -0.44940525f, -0.45184973f, -0.00362290f, -0.03266173f, -0.18693843f, 0.18921579f, 
    0.04972943f, -0.01762881f, -0.02903299f, 0.00711268f, 0.40864310f, -0.26487437f, -0.14854267f, -0.22658509f, 
    -0.09569529f, -0.03539903f, -0.05509170f, 0.01656612f, 0.10941534f, 0.01311507f, -0.01539475f, 0.00248600f, 
    -0.14502820f, -0.09115302f, -0.20486194f, -0.13716571f, -0.00881634f, 0.17271370f, 0.09178347f, 0.12104315f, 
    0.00768651f, -0.06165727f, -0.02465544f, -0.02058187f, -0.06048413f, 0.01866280f, -0.01970140f, 0.00482662f, 
    0.05553182f, -0.16548142f, -0.11765727f, -0.04832818f, 0.05881625f, 0.05222058f, 0.00279277f, 0.04261889f, 
    0.08403981f, 0.10971190f, 0.05138918f, -0.06817130f, -0.05568354f, -0.00374143f, -0.02865316f, -0.00177049f, 
    0.01953835f, 0.03377465f, 0.03283407f, 0.02452056f, 0.06410753f, -0.16173987f, -0.43491331f, -0.03850371f, 
    -0.28429958f, 0.04815248f, 0.12051994f, -0.23047738f, 0.03607630f, -0.02195487f, 0.00852293f, 0.07641274f, 
    0.16338284f, 0.11592139f, -0.04469719f, -0.26184857f, -0.06376906f, -0.08394051f, 0.03200505f, -0.03233904f, 
    -0.02042997f, -0.04221435f, 0.05751133f, 0.04860281f, -0.01170784f, 0.01187321f, -0.03898967f, -0.10008401f, 
    0.06594925f, -0.04327191f, -0.08713446f, 0.03702635f, 0.06248226f, 0.21684198f, 0.05547774f, 0.12166802f, 
    0.38885358f, 0.44774488f, 0.09104559f, -0.28867185f, -0.04296568f, 0.00061493f, 0.02117807f, -0.30745846f, 
    0.00651616f, -0.02704286f, -0.02489669f, 0.04836611f, -0.31011268f, -0.44247004f, -0.28561017f, -0.16581663f, 
    -0.10029285f, 0.05908420f, 0.13202398f, -0.04397377f, -0.00208115f, 0.06192204f, 0.07451902f, 0.04888062f, 
    -0.52812135f, 0.13491531f, 0.20869318f, 0.37309381f, 0.00620403f, 0.13632958f, -0.10192182f, 0.04765697f, 
    -0.00293614f, 0.22154029f, -0.00832046f, -0.01247255f, 0.07127243f, 0.14421302f, 0.06570110f, -0.02102563f, 
    0.16049606f, -0.02860003f, -0.04932272f, -0.00006540f, 0.03274281f, 0.00396486f, 0.03851253f, 0.00339074f, 
    -0.77334481f, 0.15571778f, 0.09938379f, 0.21997593f, 0.03103120f, 0.12548047f, 0.07186249f, 0.08254069f, 
    -0.15178369f, 0.07230994f, -0.02551450f, 0.16529547f, 0.57050514f, -0.30317163f, -0.17994744f, -0.60434324f, 
    0.16645826f, -0.09871227f, -0.09625722f, 0.01678972f, 0.09089589f, 0.19778363f, 0.06244837f, 0.03956394f, 
    -0.03620935f, -0.10665537f, -0.11238898f, -0.00382792f, -0.02035798f, -0.06539729f, 0.01984269f, -0.00138624f, 
    -0.13813660f, -0.10439088f, -0.21852404f, -0.12149923f, 0.06952988f, -0.13112734f, -0.18844315f, -0.09027727f, 
    0.09981555f, -0.07334927f, 0.14528820f, -0.14406623f, 0.03350322f, -0.09932790f, 0.12239864f, 0.04338729f, 
    0.24061590f, -0.02321603f, 0.07138585f, -0.28002864f, -0.04799811f, -0.01466869f, -0.05690163f, 0.14597027f, 
    0.06256981f, -0.06930999f, -0.17544053f, -0.09564900f, -0.39284420f, 0.13399820f, 0.03340913f, 0.05962230f, 
    0.04925701f, 0.03153946f, -0.01336840f, 0.02334422f, 0.02514509f, -0.04429028f, -0.01302150f, -0.03235072f, 
    0.47214803f, -0.03833293f, -0.54567397f, -0.15434767f, 0.13438940f, -0.19885090f, 0.02607941f, 0.12785561f, 
    0.09027226f, 0.08531418f, 0.01558904f, 0.05826778f, -0.08300282f, -0.35985801f, -0.20067504f, 0.01627907f, 
    -0.02546262f, 0.10704818f, 0.14210129f, 0.04693090f, 0.01644582f, -0.02422852f, -0.02795012f, -0.04116829f, 
    -0.31657776f, 0.07625002f, 0.19983792f, 0.25166610f, -0.05986223f, 0.04044346f, -0.03198540f, -0.12653792f, 
    0.17038362f, -0.15193127f, -0.04013428f, 0.12860774f, -0.12594880f, -0.17950180f, -0.22637390f, 0.07109710f, 
    0.14959887f, 0.06287665f, 0.08340185f, -0.01556664f, 0.02577924f, -0.06824142f, 0.11225098f, 0.18676430f, 
    0.14771222f, 0.08838957f, -0.06337301f, 0.02720624f, 0.13468862f, 0.04770249f, 0.10329975f, 0.12810646f, 
    0.02677325f, -0.00149990f, -0.03980707f, 0.02918984f, 0.13413566f, 0.01735174f, -0.00302207f, -0.16837409f, 
    0.00483809f, -0.03083773f, -0.02804407f, 0.10229100f, 0.02120680f, 0.01175700f, 0.02051224f, 0.17773992f, 
    0.15208048f, -0.02838728f, -0.09758972f, -0.26235241f, 0.14562140f, -0.03092395f, 0.15268369f, -0.05781732f, 
    0.02223654f, 0.11785111f, 0.11176126f, 0.10969745f, -0.14436847f, -0.06794085f, -0.20021054f, -0.25833124f, 
    -0.01391071f, 0.01832572f, 0.07715749f, 0.04113019f, 0.07741241f, 0.00016191f, -0.26476136f, -0.19806293f, 
    -0.03077627f, -0.18027359f, -0.11505882f, -0.04609254f, 0.09996960f, 0.06246678f, 0.02463064f, 0.07436174f, 
    -0.22307856f, -0.30281076f, -0.11530919f, -0.14524697f, -0.04433422f, -0.32922843f, -0.32595971f, -0.00459131f, 
    0.02249774f, 0.07840364f, 0.08694813f, 0.10439160f, 0.09869400f, -0.00648611f, 0.07040843f, 0.01634507f, 
    -0.01580319f, 0.08660608f, -0.03515628f, 0.04322306f, 0.09980948f, -0.04926019f, -0.01781119f, 0.08294976f, 
    0.10542207f, 0.13707860f, 0.04831075f, -0.00401581f, -0.15243742f, -0.20139638f, -0.12707622f, -0.07109584f, 
    -0.04939269f, -0.04016454f, -0.02583196f, 0.05766179f, 0.00643355f, -0.03304696f, -0.00231791f, 0.02757357f, 
    0.11274061f, -0.02169907f, -0.02684725f, -0.20110463f, 0.13078293f, 0.05946404f, 0.07622527f, -0.03464220f, 
    -0.05368834f, 0.10194659f, -0.03539070f, 0.00780286f, 0.00201009f, 0.15427816f, -0.09803194f, -0.06642261f, 
    -0.00028953f, 0.08014470f, -0.01899900f, -0.20487057f, -0.04140169f, -0.06297237f, -0.08718296f, -0.04183652f, 
    -0.05629954f, -0.03121267f, -0.00709403f, -0.00407770f, 0.05580639f, 0.00278511f, 0.01968759f, 0.07647403f, 
    -0.02620703f, 0.01287935f, 0.07213075f, 0.10460316f, 0.27054569f, -0.02602334f, 0.07299653f, 0.04592775f, 
    0.05087685f, -0.03856926f, -0.02377280f, -0.00899457f, 0.06364518f, -0.01734677f, 0.01057014f, -0.08203819f, 
    -0.31097299f, -0.24696353f, -0.00276348f, -0.10768937f, 0.02466568f, 0.04249910f, 0.00107522f, -0.03834736f, 
    0.05652495f, 0.11355830f, 0.01210248f, 0.24146107f, -0.09323242f, -0.14542787f, -0.06965911f, -0.08171535f, 
    0.04426098f, -0.00086988f, 0.08182636f, 0.06620540f, -0.02711749f, -0.13798077f, 0.03131765f, -0.03514588f, 
    -0.12890895f, -0.03083504f, 0.03912015f, -0.18667750f, -0.08792977f, 0.00087612f, -0.00984858f, 0.01900711f, 
    0.01953137f, 0.00709377f, 0.05485007f, 0.08464652f, 0.00002484f, -0.14815332f, -0.27791125f, -0.24783380f, 
    -0.13411401f, -0.10258426f, 0.08876392f, 0.01800671f, 0.14739563f, 0.14709644f, 0.10361218f, 0.07525034f, 
    -0.27781275f, -0.14777707f, 0.05850030f, 0.04103052f, -0.02304276f, 0.02009272f, -0.04621124f, -0.08793097f, 
    -0.15871674f, -0.13682550f, -0.08458236f, -0.28291860f, -0.13971566f, -0.31020179f, 0.11548383f, -0.08067122f, 
    -0.24623844f, 0.02941078f, 0.03684695f, -0.11085148f, -0.02188960f, 0.04325991f, -0.06840830f, -0.09980493f, 
    -0.05348898f, -0.08225640f, -0.20110592f, -0.04917707f, 0.06728474f, 0.01543204f, -0.02222687f, 0.02735658f, 
    0.03598694f, 0.16194654f, 0.02372188f, 0.05893036f, -0.06254712f, -0.16444638f, -0.13541822f, -0.04621265f, 
    -0.14544962f, 0.09371215f, 0.07504535f, 0.06270929f, -0.08032731f, -0.03484568f, -0.10417740f, -0.15278438f, 
    0.28462246f, -0.00953994f, 0.06255357f, 0.01065290f, -0.03622584f, -0.02034128f, 0.04517782f, 0.00278560f, 
    0.06031339f, -0.01424210f, 0.14164306f, 0.10014006f, -0.37606385f, -0.12639688f, 0.30054191f, 0.28518966f, 
    -0.11683364f, 0.08926567f, 0.01239388f, -0.06999771f, 0.01004158f, 0.07436005f, -0.04194479f, 0.02953047f, 
    0.03952825f, -0.25238577f, -0.15569900f, -0.08964252f, 0.07286355f, -0.05213267f, -0.01052568f, 0.13368359f, 
    -0.00537212f, -0.00078314f, 0.03631220f, 0.09656239f, -0.26379359f, -0.04002442f, 0.09595083f, 0.16876617f, 
    -0.01022682f, 0.24056241f, -0.03419081f, 0.04348200f, -0.02677881f, -0.04286749f, -0.10789720f, 0.08266623f, 
    0.16745685f, 0.05403540f, -0.02289984f, 0.00229179f, -0.00017303f, 0.11915855f, 0.06674931f, 0.02097062f, 
    -0.01395049f, -0.15648812f, -0.03157858f, -0.21936215f, -0.11456560f, -0.41087079f, -0.22196762f, -0.08574056f, 
    0.12497531f, -0.04263289f, -0.02508763f, 0.05815075f, -0.02418449f, 0.03905807f, 0.01188776f, 0.14561708f, 
    -0.11632181f, -0.10920319f, -0.08102795f, -0.13730274f, -0.05425890f, -0.04121301f, -0.06146002f, 0.00413986f, 
    -0.03360451f, 0.15460601f, -0.12914144f, 0.00966139f, -0.53789335f, -0.56016362f, -0.39369422f, -0.01361794f, 
    0.07394528f, 0.23906200f, 0.16071521f, 0.08541660f, 0.01317003f, -0.08016676f, -0.03606327f, 0.01420168f, 
    0.00063305f, 0.01986553f, -0.13261548f, -0.34772423f, -0.06820689f, 0.03674552f, -0.02418593f, -0.36921749f, 
    0.02292054f, -0.01088606f, 0.01026742f, 0.09076970f, -0.50353730f, -0.06546201f, -0.00313544f, 0.12963006f, 
    -0.01322131f, 0.07656151f, -0.12928946f, 0.22469610f, -0.06073111f, -0.02862291f, 0.06788830f, 0.08939912f, 
    0.09054419f, -0.04629490f, -0.06351393f, -0.02877304f, 0.05115194f, 0.04539092f, 0.03856195f, 0.04281707f, 
    -0.27111602f, -0.14301035f, -0.19441973f, -0.46021241f, 0.16214168f, -0.17136046f, 0.05685305f, -0.07684379f, 
    0.03190193f, -0.00734727f, 0.08996403f, 0.00404609f, -0.15697816f, -0.00473619f, -0.07160454f, 0.05848913f, 
    -0.04004772f, -0.30990180f, -0.43550053f, 0.10588865f, 0.02828890f, 0.07983844f, 0.04895120f, 0.17850026f, 
    0.06541385f, 0.09441648f, 0.16180427f, -0.00177094f, -0.01553699f, -0.00369284f, -0.01845761f, -0.08741800f, 
    0.09635302f, -0.04641516f, 0.03615578f, -0.03537948f, 0.01471243f, 0.05043470f, -0.05915540f, -0.02258574f, 
    -0.04231072f, -0.27809781f, -0.21462899f, -0.08396193f, -0.06379209f, -0.08815347f, -0.03712582f, -0.00843502f, 
    -0.00383949f, 0.02541056f, 0.04684121f, 0.11704997f, 0.56787181f, 0.11658565f, -0.06877545f, -0.00913382f, 
    -0.10978280f, 0.11855415f, 0.01071016f, -0.13196042f, 0.06726553f, 0.03025299f, -0.00870163f, 0.05602469f, 
    0.09980888f, -0.38747773f, -0.38252911f, 0.06863657f, 0.05528373f, 0.03807386f, 0.09090003f, 0.06027542f, 
    -0.05053625f, -0.01114176f, -0.06239809f, -0.00090302f, -0.34967706f, -0.13826530f, 0.09854382f, 0.11920433f, 
    0.09342294f, 0.15284885f, -0.01838121f, 0.04511353f, -0.11919746f, -0.10288471f, 0.20760663f, -0.02372941f, 
    -0.53163218f, 0.19805074f, -0.10050961f, -0.00145452f, 0.13922288f, -0.01660188f, -0.08823069f, 0.04832641f, 
    0.04805990f, 0.04527107f, 0.10320472f, 0.14416111f, -0.25575957f, 0.03164741f, 0.03457180f, 0.13965695f, 
    -0.00545943f, -0.06945053f, -0.10938291f, -0.03936936f, 0.11695261f, 0.11752431f, 0.11307081f, 0.15441984f, 
    -0.00692564f, 0.05172376f, -0.01983322f, -0.27886742f, 0.00584761f, -0.05699731f, 0.01350318f, -0.03870466f, 
    -0.12981005f, -0.05951012f, -0.02684684f, -0.08656947f, -0.33177745f, -0.17836559f, 0.08495117f, -0.04658873f, 
    -0.06082800f, -0.08523206f, -0.02813674f, 0.02701388f, -0.01371235f, -0.07654501f, -0.03341196f, -0.06523513f, 
    0.03705609f, -0.12819344f, -0.44255397f, 0.32970881f, 0.16717209f, 0.06639860f, 0.16910085f, -0.06280653f, 
    0.00621193f, -0.03749761f, 0.00144372f, 0.07762903f, -0.37653378f, -0.22058380f, -0.10195581f, 0.02577297f, 
    -0.04217178f, 0.07449464f, 0.13537657f, 0.12722790f, 0.01263141f, 0.10059083f, -0.01107875f, -0.10733952f, 
    0.00581237f, -0.26227447f, -0.05449976f, 0.20652607f, 0.05766190f, 0.13951424f, 0.05864724f, -0.05914613f, 
    -0.00362766f, -0.05936684f, -0.06590414f, -0.22461864f, 0.11733747f, -0.01405146f, 0.13620172f, 0.02558400f, 
    0.04993865f, 0.11087344f, -0.02533129f, -0.16344449f, -0.03620788f, 0.06481640f, -0.04864067f, -0.01197600f, 
    -0.03858721f, -0.09755953f, 0.04976374f, 0.17713721f, 0.01306427f, 0.21928650f, 0.01985429f, -0.11396147f, 
    0.03935098f, -0.06461006f, -0.00553635f, -0.05647722f, -0.39061204f, 0.05194073f, 0.20995949f, -0.44313076f, 
    -0.11568297f, -0.06374621f, 0.02536104f, 0.04127365f, 0.05471013f, 0.04062372f, -0.00043766f, 0.01627465f, 
    0.00006816f, -0.33181632f, 0.25623262f, 0.11214388f, -0.00842534f, 0.02962246f, -0.15327512f, -0.12788467f, 
    -0.17642643f, 0.09852476f, 0.10159188f, -0.02897823f, 0.14219087f, -0.15312205f, 0.07158171f, -0.01378855f, 
    0.10295109f, 0.11656037f, -0.04735938f, 0.09852151f, -0.04693559f, -0.02448809f, -0.08205727f, -0.21353705f, 
    -0.28672114f, -0.48745364f, 0.10214612f, -0.12405811f, 0.04058957f, 0.21068272f, -0.16239461f, 0.07049003f, 
    0.04047325f, -0.01417358f, 0.06999373f, -0.01906024f, 0.12777565f, 0.32232109f, 0.07341628f, -0.36011353f, 
    -0.18925327f, -0.08962724f, 0.16002126f, 0.08607031f, -0.02515075f, 0.02609232f, 0.02916274f, 0.01456277f, 
    -0.12261222f, 0.27337939f, 0.13246188f, -0.50175345f, -0.11971390f, -0.00394709f, 0.12726113f, -0.05564468f, 
    -0.01507670f, 0.03082173f, -0.01743875f, 0.07951532f, -0.00675588f, -0.25335667f, -0.33650184f, 0.10840143f, 
    0.10233930f, 0.14532557f, 0.17145848f, -0.04321445f, -0.04295582f, -0.01730174f, -0.01904129f, -0.02624054f, 
    -0.22572380f, 0.38421306f, 0.59735370f, -0.71567017f, 0.03150684f, -0.25858504f, 0.08504002f, -0.15159453f, 
    -0.03427693f, 0.09590413f, -0.04574087f, 0.01634113f, 0.04320365f, -0.12818831f, 0.19116928f, 0.14641701f, 
    -0.03701763f, 0.06753555f, -0.08187649f, -0.25669378f, -0.12922962f, -0.00507968f, -0.13788508f, 0.07878289f, 
    0.06003536f, 0.10947624f, 0.09331550f, -0.01625409f, -0.09334578f, 0.01247297f, -0.03974049f, -0.12552220f, 
    -0.12248475f, 0.08566509f, -0.05114952f, 0.09977362f, -0.23748411f, -0.17667024f, 0.03155772f, -0.09572173f, 
    -0.02637993f, 0.12405612f, -0.09296087f, 0.08887324f, 0.02639721f, -0.01259124f, 0.03710962f, -0.00335796f, 
    -0.06689084f, 0.12688838f, 0.29960513f, 0.23018627f, 0.07316509f, -0.06103001f, -0.06666923f, 0.03482172f, 
    0.04113931f, -0.00513319f, 0.12000429f, -0.07652602f, -0.12572528f, 0.00312726f, -0.36324504f, 0.15165405f, 
    0.16240987f, -0.05362773f, 0.07579693f, 0.18849079f, 0.02364818f, 0.01331314f, -0.01932760f, -0.04169807f, 
    -0.35846016f, -0.51241112f, 0.09559190f, 0.14961122f, 0.03147884f, -0.21063940f, 0.08494948f, 0.06136825f, 
    0.02058219f, 0.04671564f, 0.03749195f, -0.00822595f, 0.21062645f, 0.14937720f, 0.02003886f, -0.09371575f, 
    0.18044038f, -0.08665131f, -0.21010789f, -0.01609856f, 0.08034765f, -0.08016814f, 0.04786111f, 0.01546179f, 
    -0.07660646f, -0.14791544f, 0.02495469f, -0.02970448f, 0.07977729f, 0.01486569f, -0.12894124f, 0.09581685f, 
    0.04250467f, 0.06341173f, -0.13923964f, -0.02749851f, 0.20521016f, -0.00288523f, 0.14188023f, 0.00080386f, 
    -0.06636574f, -0.06782828f, -0.09533015f, -0.33220714f, 0.11766107f, -0.10040648f, -0.08853470f, 0.08276065f, 
    -0.29343024f, 0.11950270f, -0.23795177f, 0.13532920f, 0.12838399f, -0.07885311f, 0.02488047f, 0.03009673f, 
    0.13503207f, -0.03085549f, -0.10073309f, 0.08557816f, 0.07091630f, -0.15399674f, -0.13159508f, 0.03583316f, 
    -0.00110811f, 0.08976513f, -0.07656214f, 0.11302771f, 0.00144566f, -0.10700662f, -0.03308153f, -0.05596850f, 
    0.15579066f, -0.16698471f, -0.04503170f, 0.10695872f, 0.20170875f, -0.26960629f, 0.07958799f, 0.02277898f, 
    0.01230806f, -0.12246365f, -0.08545738f, -0.05530052f, 0.14839952f, 0.10686933f, -0.15087990f, -0.17733774f, 
    -0.01423660f, -0.01933069f, 0.03557086f, 0.02253810f, 0.12807104f, 0.11308569f, -0.04682833f, 0.11457860f, 
    0.11824495f, 0.22835995f, 0.49179977f, -0.23724405f, -0.02227928f, -0.20660272f, -0.11926507f, -0.13724324f, 
    -0.15596031f, 0.11700831f, 0.09890597f, 0.10330297f, -0.16508146f, 0.25261122f, 0.33768225f, 0.04249791f, 
    -0.09967903f, -0.17182614f, -0.13207553f, -0.13470362f, -0.03447858f, -0.01861579f, -0.00646315f, 0.03469399f, 
    0.05439138f, 0.00425309f, -0.16641276f, -0.17216034f, -0.09940217f, -0.07774846f, -0.05109611f, 0.10943652f, 
    0.01301742f, 0.02101111f, 0.02331685f, -0.17024742f, 0.05167198f, 0.19432971f, 0.14209025f, -0.06420590f, 
    -0.11315300f, -0.09118145f, 0.17251372f, 0.21164015f, -0.07830311f, -0.03546156f, -0.00767966f, 0.01637493f, 
    -0.14221025f, 0.37966344f, -0.08361896f, 0.44440940f, -0.03780529f, 0.02172872f, -0.00441630f, -0.16757944f, 
    0.18371338f, -0.07654558f, -0.03255206f, -0.04347516f, -0.00574658f, -0.45372671f, -0.12658453f, -0.10536153f, 
    0.11727748f, 0.04226790f, 0.04395835f, 0.09341087f, 0.06053444f, 0.00266858f, 0.05676481f, 0.00713933f, 
    0.29862487f, 0.31381029f, -0.02266865f, -0.04864035f, 0.02045229f, 0.03883132f, -0.00246057f, -0.08307528f, 
    -0.01442128f, -0.01410366f, -0.04428919f, 0.00048601f, -0.19548349f, -0.17865017f, -0.11493360f, 0.10068209f, 
    0.10742348f, 0.00508000f, 0.11237839f, -0.13274181f, 0.08370241f, -0.05674402f, -0.20549576f, -0.37710315f, 
    0.24089134f, -0.24309401f, -0.05427530f, -0.00669916f, 0.03350220f, -0.06784885f, -0.06448261f, -0.11804558f, 
    0.00122834f, -0.09826897f, -0.03489741f, -0.11163933f, -0.04887173f, 0.12715285f, 0.32627863f, -0.29314744f, 
    0.01936371f, -0.30662137f, -0.00694572f, -0.09781859f, -0.07170684f, -0.01512139f, 0.10594621f, 0.00472965f, 
    -0.17236404f, -0.00410012f, 0.03464225f, -0.05808916f, 0.02861401f, 0.20120877f, 0.05350978f, -0.03641214f, 
    0.15572874f, -0.00224141f, -0.01057900f, -0.02999050f, 0.02940174f, 0.12154424f, 0.06385966f, 0.48637500f, 
    0.15337519f, 0.06386868f, -0.22454287f, 0.13162014f, -0.02069597f, -0.05931479f, -0.04232115f, -0.06298229f, 
    0.05402001f, -0.15547268f, 0.05845296f, -0.19760469f, -0.01967687f, 0.10072606f, 0.02840610f, 0.11844561f, 
    -0.02418055f, 0.02608270f, 0.23743205f, 0.30393016f, 0.14740787f, -0.15529259f, 0.32465145f, -0.39685199f, 
    0.03021500f, 0.00314819f, -0.11641940f, -0.03235542f, 0.07374495f, 0.20707780f, -0.00647934f, 0.07785875f, 
    0.01681638f, 0.23372003f, -0.07019543f, 0.11653054f, -0.10557476f, -0.06660309f, -0.08642028f, -0.17562589f, 
    0.00681158f, -0.06835223f, 0.03491225f, -0.03368970f, -0.23887634f, 0.14677934f, 0.22632794f, -0.17315902f, 
    -0.16841201f, 0.03062854f, -0.17587052f, -0.39621314f, 0.09820742f, -0.02854885f, 0.03893701f, 0.05761599f, 
    0.04754642f, -0.28577021f, 0.12530771f, -0.26747385f, 0.04149661f, -0.10024647f, 0.00462929f, 0.06062861f, 
    0.10972787f, 0.04427818f, -0.04942239f, 0.00245722f, -0.14604688f, 0.06446189f, 0.17034377f, -0.47697765f, 
    -0.00751666f, 0.08527128f, 0.09683791f, -0.05657078f, 0.01128722f, 0.06923559f, -0.10851079f, -0.13428646f, 
    -0.15192302f, 0.06889233f, -0.17776518f, 0.13085739f, -0.23617375f, -0.04261263f, -0.02110250f, 0.01670758f, 
    0.02910599f, 0.01186636f, 0.02734540f, -0.06751564f, 0.08257423f, -0.02555674f, -0.03558030f, -0.21409783f, 
    0.12621051f, -0.09739061f, 0.03082527f, 0.10233324f, 0.06718723f, -0.00384309f, -0.14446481f, -0.13624172f, 
    -0.05156766f, -0.04582448f, 0.12366106f, 0.10276263f, 0.01593148f, 0.06132906f, -0.05261426f, -0.02582558f, 
    0.00370798f, 0.06151439f, 0.03662071f, 0.02996905f, 0.00579168f, -0.15044852f, 0.01747250f, -0.06937255f, 
    -0.00547670f, -0.14755006f, -0.18082818f, 0.02226407f, -0.01694574f, -0.04886724f, -0.05875512f, 0.01162308f, 
    -0.17680970f, 0.05219566f, 0.22201569f, 0.20304750f, 0.01145599f, -0.02056297f, -0.02085592f, -0.07684591f, 
    0.07738348f, 0.00797335f, 0.08332679f, 0.13096595f, -0.08235455f, 0.00907780f, -0.32346654f, -0.19653134f, 
    -0.16277671f, -0.05967178f, -0.16417994f, 0.05488283f, 0.08136472f, -0.02088955f, 0.01928749f, 0.03050381f, 
    -0.04575463f, 0.01521964f, 0.07864588f, 0.02516276f, -0.07093393f, -0.07544629f, -0.00962107f, 0.32847559f, 
    0.05335075f, 0.13643320f, 0.05069061f, -0.04804576f, -0.60321891f, 0.50959635f, -0.18249956f, -0.25595433f, 
    -0.05469886f, -0.24370857f, 0.01344769f, 0.02232173f, 0.18246850f, -0.05116098f, -0.03634866f, -0.03876234f, 
    0.11593833f, 0.10466445f, 0.27007589f, 0.21475060f, -0.01156066f, -0.10411233f, -0.08411942f, -0.07911319f, 
    0.12201831f, 0.14727201f, 0.05900771f, 0.09025858f, 0.05664216f, -0.00417107f, 0.49136204f, -0.15297326f, 
    0.15232514f, -0.25814512f, 0.00491801f, -0.09026354f, 0.14657570f, -0.08626766f, 0.00323678f, 0.04031487f, 
    -0.56400883f, 0.05598672f, -0.36256474f, 0.23441075f, 0.10257021f, -0.05670508f, 0.07370837f, -0.11064550f, 
    0.08939285f, 0.08725268f, 0.04525508f, -0.03873745f, -0.14913578f, -0.18450028f, -0.26004606f, 0.09158292f, 
    -0.00242245f, 0.11455233f, 0.06886854f, -0.09537856f, 0.20533009f, -0.06743766f, -0.00978563f, 0.00280682f, 
    -0.16791272f, -0.25970671f, 0.18200371f, -0.28070441f, 0.03153125f, -0.12092329f, -0.05569649f, 0.06820250f, 
    -0.01399541f, 0.05567521f, 0.04166865f, 0.02732871f, -0.16246192f, -0.55568701f, 0.08786595f, -0.31025109f, 
    0.08284342f, -0.06302112f, -0.19046506f, 0.24735467f, 0.03742308f, -0.02828891f, -0.00266774f, -0.04374194f, 
    -0.12615526f, 0.00834782f, -0.17864053f, -0.30381262f, -0.19891439f, -0.00472117f, -0.01161222f, 0.16243050f, 
    0.10560862f, 0.02167519f, 0.00780373f, -0.02026704f, -0.31816056f, 0.24751310f, 0.06682017f, -0.17311209f, 
    -0.03942523f, -0.31447542f, 0.05799007f, -0.02828938f, -0.17305546f, 0.11551505f, -0.09684997f, 0.01940550f, 
    -0.09548813f, 0.03721763f, -0.46222255f, -0.02056749f, 0.11738197f, -0.02112936f, 0.10239513f, -0.08698316f, 
    0.10934087f, -0.09328897f, -0.00424378f, -0.08181983f, 0.12459993f, 0.09952163f, -0.13814868f, -0.20715141f, 
    0.00902479f, -0.03277896f, 0.07623413f, 0.02223881f, 0.08825155f, 0.02286705f, 0.00278476f, -0.09825584f, 
    -0.16192199f, -0.16255309f, -0.16025305f, 0.07869115f, -0.01318357f, 0.13173953f, 0.10110543f, -0.03033859f, 
    0.04033877f, 0.03155892f, 0.03440487f, 0.00518609f, 0.03884632f, -0.15373278f, -0.00227105f, 0.00940694f, 
    0.06883770f, -0.08728195f, 0.12494159f, -0.07850014f, 0.00900569f, 0.00278383f, -0.07631324f, -0.04886157f, 
    0.00667013f, -0.22021151f, 0.09531527f, -0.31077585f, -0.00835087f, -0.05070657f, -0.02233936f, -0.00577356f, 
    0.04019410f, -0.07430311f, 0.00845986f, 0.09958062f, 0.10231517f, 0.22828640f, 0.07270116f, -0.02290961f, 
    -0.02906731f, -0.09777818f, -0.16597886f, -0.12498471f, 0.03238751f, 0.02322686f, 0.05500155f, 0.07801557f, 
    -0.00840435f, -0.01410844f, 0.04501783f, -0.06688521f, -0.10493411f, -0.17117365f, -0.03891848f, -0.01160561f, 
    0.13778062f, 0.04350860f, 0.08336837f, 0.03918666f, 0.13607292f, -0.18832694f, -0.29238322f, 0.02594360f, 
    0.25297582f, 0.07802971f, 0.16601986f, 0.11520434f, 0.01604899f, -0.02712816f, 0.03244809f, -0.07374758f, 
    -0.07034998f, 0.14852645f, 0.32186371f, -0.11693914f, -0.14658536f, -0.19329208f, 0.10892978f, 0.12142980f, 
    -0.09602982f, 0.03798942f, 0.03048246f, 0.06338328f, 0.04738225f, -0.50996482f, 0.08616289f, 0.15868518f, 
    -0.14557409f, 0.03861078f, 0.00999049f, 0.25708458f, 0.06046730f, -0.01676733f, 0.05803801f, -0.02024038f, 
    -0.34210482f, 0.03432535f, -0.11755846f, -0.00189195f, 0.00859272f, 0.10978141f, -0.03787289f, 0.07102823f, 
    0.05137365f, 0.06516448f, -0.04100899f, -0.10302249f, -0.12435369f, 0.17328739f, -0.24948280f, 0.05653020f, 
    -0.03039373f, 0.08280420f, 0.02864179f, -0.09526537f, -0.02543596f, 0.13442992f, 0.13482419f, 0.23687308f, 
    -0.20782147f, -0.35893089f, -0.15915833f, 0.05560542f, -0.18031728f, 0.14893931f, -0.23079501f, -0.13292411f, 
    0.02781107f, -0.12667608f, -0.04378416f, 0.03339061f, -0.13800696f, -0.22580090f, -0.01849492f, 0.23283228f, 
    -0.09023517f, 0.05546683f, -0.05032168f, -0.12325098f, 0.11262636f, 0.08060948f, 0.12042224f, 0.10524007f, 
    0.20639975f, -0.26493725f, 0.19722666f, 0.15363315f, -0.01254527f, -0.10543685f, 0.04129913f, 0.03922490f, 
    -0.23236397f, -0.11493389f, -0.11488396f, -0.06504875f, -0.20618281f, 0.04193180f, -0.40063640f, -0.23311113f, 
    -0.18288730f, -0.01132310f, 0.06411344f, -0.09036424f, -0.01787029f, 0.08072869f, -0.03446243f, -0.01724561f, 
    0.04127488f, 0.16982900f, 0.15258309f, 0.08984412f, -0.08267426f, -0.06887755f, 0.19798532f, 0.05674533f, 
    -0.10634143f, -0.13197775f, 0.01968374f, 0.12501363f, -0.69327664f, 0.32811511f, -0.37674788f, 0.17557618f, 
    0.04849980f, 0.15545355f, 0.15648670f, -0.14494389f, 0.03018871f, 0.09127551f, -0.09606068f, -0.06517306f, 
    -0.31121859f, 0.04204968f, -0.08724711f, -0.18718213f, -0.01896282f, 0.22258857f, -0.00635980f, 0.08635803f, 
    -0.09957085f, -0.04025529f, -0.10183258f, -0.01302633f, -0.24909417f, -0.23284417f, -0.45216990f, 0.09334911f, 
    0.23665994f, 0.01197796f, -0.13770209f, -0.20741963f, -0.01048927f, 0.01308231f, -0.07010131f, -0.22834547f, 
    -0.49829870f, 0.14724670f, 0.00962984f, 0.28968731f, -0.02892387f, -0.03000724f, -0.01780872f, 0.00493804f, 
    0.02833845f, -0.00833657f, -0.04260243f, 0.02668887f, -0.13763280f, -0.12029174f, -0.20184433f, -0.00550155f, 
    -0.19878192f, 0.06710358f, 0.05840827f, 0.04026195f, -0.05546428f, 0.02891965f, -0.06012297f, -0.05731338f, 
    -0.55356336f, 0.17347871f, -0.01537743f, 0.04475558f, 0.06903145f, 0.12704577f, 0.12087513f, 0.06293225f, 
    -0.04124242f, 0.18641105f, -0.02381350f, 0.10293473f, 0.19273520f, -0.18695450f, 0.13903390f, 0.22959544f, 
    -0.04853158f, -0.03371038f, 0.02903790f, -0.00795291f, -0.07406616f, -0.02374067f, -0.00847890f, 0.00300868f, 
    -0.05238508f, -0.05538154f, 0.18664940f, 0.15170711f, 0.10414011f, 0.05446320f, -0.32328939f, 0.11179745f, 
    -0.09128673f, 0.01004460f, 0.05265611f, -0.12614070f, -0.08516944f, 0.25200164f, 0.13224214f, 0.02630728f, 
    -0.01666924f, -0.10168968f, 0.14568041f, -0.12841552f, -0.14598596f, 0.15515245f, 0.18793553f, 0.06324837f, 
    0.10453901f, 0.13958099f, 0.11092483f, -0.10101876f, -0.18320352f, -0.00271467f, -0.11195265f, 0.05901064f, 
    -0.13460469f, 0.02956035f, -0.03807699f, -0.00173570f, -0.10682239f, 0.12367983f, -0.01950323f, 0.02684210f, 
    0.04468517f, -0.02539622f, 0.15904601f, 0.10705899f, -0.08652222f, 0.11248562f, 0.02323206f, 0.07696152f, 
    -0.22939217f, 0.23649894f, -0.25035053f, -0.02117582f, 0.03523124f, 0.08231266f, 0.17773862f, 0.01825936f, 
    -0.04588544f, 0.12087338f, -0.07263256f, 0.04190505f, -0.16050619f, 0.04143696f, 0.17420480f, 0.01190984f, 
    0.10531943f, 0.12459722f, -0.07245042f, -0.06566577f, -0.03772328f, -0.05570934f, -0.21535686f, -0.30434734f, 
    -0.12945490f, 0.03624141f, -0.23513743f, -0.05247048f, 0.09850337f, -0.34000322f, 0.01470715f, 0.07258029f, 
    0.00519808f, -0.15827580f, -0.49050561f, -0.25764608f, 0.25445408f, 0.12424550f, 0.03419131f, -0.31388301f, 
    -0.06610498f, 0.03803340f, 0.09385285f, -0.05887930f, 0.02301971f, 0.00731133f, 0.12772943f, -0.02059886f, 
    0.02169465f, -0.03535927f, 0.08179906f, 0.29546505f, -0.08164638f, 0.24575794f, 0.21358979f, -0.02555348f, 
    0.02077852f, -0.06199008f, 0.12980703f, 0.28041559f, -0.26663139f, -0.05949891f, -0.11460044f, -0.05109528f, 
    0.09843811f, -0.04095593f, -0.07069959f, 0.05929294f, -0.06453413f, 0.06849473f, 0.07553928f, -0.01218086f, 
    0.13314061f, 0.07941779f, 0.00080788f, -0.18332152f, -0.08727778f, -0.00905189f, -0.00670338f, -0.00070505f, 
    0.01104791f, -0.08938563f, -0.05260012f, -0.04051476f, -0.44679683f, 0.46085292f, -0.04534592f, -0.01246917f, 
    -0.11468133f, 0.06840418f, -0.22829798f, 0.18323660f, -0.15198103f, -0.10079309f, 0.05092034f, -0.10756309f, 
    -0.23919442f, 0.15511331f, 0.01098807f, 0.20967594f, 0.10368039f, 0.08161078f, 0.00984591f, -0.02800902f, 
    -0.11400539f, 0.15365459f, 0.14334221f, 0.15552400f, -0.25278121f, 0.36836702f, 0.09837504f, 0.28369525f, 
    -0.21427368f, 0.11828045f, 0.03158474f, 0.05192452f, 0.02781066f, -0.22270031f, 0.03907967f, 0.10248393f, 
    -0.08212404f, 0.41128257f, 0.10405457f, 0.07309948f, 0.19534554f, -0.09347507f, -0.08569994f, 0.05038023f, 
    -0.01405842f, 0.15377693f, 0.05638899f, 0.06817535f, -0.34922874f, 0.06087749f, -0.03843714f, 0.08521966f, 
    -0.08964878f, 0.17993982f, 0.08851646f, 0.05505125f, 0.11251666f, 0.16901249f, 0.09386721f, 0.12385432f, 
    -0.34355211f, -0.13973258f, -0.24109460f, -0.28168464f, -0.18689208f, 0.05312062f, -0.00150388f, -0.06703346f, 
    -0.02250345f, -0.03708597f, 0.03585622f, 0.07368772f, 0.00478028f, 0.10779855f, 0.03707233f, -0.01650144f, 
    -0.08479056f, 0.03022080f, -0.00823365f, -0.01642403f, 0.06274191f, -0.01725569f, 0.11981872f, 0.12641950f, 
    -0.05428401f, 0.25535482f, 0.17684016f, -0.15901877f, 0.00632779f, -0.03622437f, -0.15274997f, 0.08967956f, 
    -0.31156871f, -0.12286427f, -0.29470721f, -0.41188517f, -0.14088702f, 0.37981328f, 0.04033611f, 0.10299074f, 
    0.01803924f, -0.00080687f, 0.06639990f, -0.03970450f, -0.05332704f, -0.14298512f, -0.17549904f, -0.14649042f, 
    0.25793386f, 0.03745639f, 0.08878580f, -0.21772739f, -0.09904554f, 0.06249528f, 0.15445709f, -0.00408555f, 
    0.00319649f, 0.16348410f, 0.05596222f, 0.12114415f, -0.04925165f, 0.15514196f, 0.10166217f, -0.19771358f, 
    0.11080014f, -0.11241367f, 0.14382763f, 0.23751202f, -0.27857277f, -0.04832096f, 0.05379241f, 0.01558013f, 
    -0.23779270f, 0.21434064f, 0.34816700f, -0.08735786f, -0.09098852f, 0.01543551f, 0.12144111f, 0.03454019f, 
    0.02115352f, -0.04444513f, 0.26728180f, 0.08734503f, 0.07919795f, 0.15086231f, 0.22878917f, 0.20117265f, 
    -0.05198074f, 0.01831860f, 0.10953984f, 0.12358139f, -0.12564914f, -0.19225961f, 0.12964326f, 0.03802961f, 
    -0.13330883f, 0.29601914f, -0.09472307f, 0.01938251f, 0.00792564f, 0.11143737f, 0.00597097f, 0.12264118f, 
    0.02092409f, 0.17550991f, -0.12010200f, 0.13127318f, -0.10880335f, 0.24863538f, 0.27614021f, 0.15885150f, 
    0.05588355f, 0.01030265f, -0.09088627f, 0.07643502f, -0.11266272f, -0.14225574f, 0.04794468f, -0.03663934f, 
    -0.14586923f, 0.27027518f, -0.11456332f, -0.11847855f, 0.02870594f, -0.03919555f, -0.03302014f, 0.10814422f, 
    -0.08141686f, -0.05392909f, -0.12078800f, -0.19995071f, -0.20962313f, 0.16807947f, -0.15104489f, -0.02796855f, 
    -0.07952248f, 0.06413668f, 0.07627633f, 0.15315180f, -0.10704073f, 0.05173268f, 0.07623968f, 0.13619681f, 
    0.23495486f, -0.04490982f, -0.01231802f, -0.30299982f, 0.00299536f, 0.04632433f, 0.06216528f, -0.01433309f, 
    -0.05269921f, -0.12822697f, -0.20204222f, -0.12499353f, 0.00299408f, 0.10175171f, -0.13868147f, 0.08174594f, 
    0.09012718f, 0.05227990f, -0.05572654f, 0.20629674f, -0.04088840f, 0.24446821f, -0.00077848f, -0.08530892f, 
    -0.28733364f, -0.10396520f, -0.46680143f, 0.19008613f, 0.08211787f, 0.31399921f, -0.16239710f, -0.16241184f, 
    0.07883132f, -0.03020762f, -0.06960876f, -0.07487882f, -0.00739204f, -0.51027918f, 0.08172684f, -0.01870395f, 
    -0.03271688f, -0.01823208f, 0.15854667f, -0.09325182f, -0.18884534f, -0.07966773f, -0.17834820f, 0.02413696f, 
    -0.18844861f, 0.18559821f, -0.11876706f, -0.19958563f, 0.00509413f, 0.09742329f, -0.02271447f, 0.02554445f, 
    -0.13945885f, -0.24905026f, -0.38132828f, -0.39311430f, 0.10570323f, 0.16949326f, 0.13436532f, 0.14917849f, 
    -0.14646748f, 0.12822849f, 0.16847953f, 0.09418855f, 0.07068149f, -0.05474457f, -0.02472816f, -0.07908462f, 
    0.18494144f, -0.41858527f, 0.15114053f, -0.04778212f, -0.04594737f, 0.10070504f, 0.06214382f, 0.14326215f, 
    0.03830278f, 0.05882355f, -0.08342120f, 0.07578587f, 0.11266584f, -0.12540954f, 0.13424107f, -0.21214761f, 
    -0.04033965f, -0.03358730f, 0.02969161f, -0.18498392f, -0.05931803f, 0.07968625f, -0.09199493f, 0.03430450f, 
    0.09160676f, -0.29103449f, -0.24751990f, 0.12342162f, -0.06171592f, 0.06684493f, 0.08682386f, 0.03133236f, 
    0.08399393f, 0.01526928f, -0.03832318f, 0.01704081f, -0.51185119f, 0.10153948f, -0.04293678f, 0.12035424f, 
    0.01745065f, 0.21954839f, -0.09340700f, 0.17369008f, -0.00706093f, 0.02180108f, -0.00664302f, 0.07312554f, 
    0.10477059f, -0.23406580f, 0.18964334f, 0.14275862f, 0.02689851f, -0.05258603f, 0.01364649f, 0.16385086f, 
    -0.00526979f, 0.05917613f, 0.01392834f, -0.02913795f, 0.00338511f, 0.10013486f, -0.04179341f, -0.03150634f, 
    -0.03975094f, -0.13337411f, 0.39053544f, -0.16760197f, 0.09406016f, 0.13363589f, -0.19629170f, 0.04807761f, 
    -0.16345850f, -0.06199985f, -0.16716726f, -0.07120922f, -0.01968301f, -0.17427069f, 0.05868603f, -0.00300821f, 
    -0.24665292f, 0.07881798f, -0.16473100f, 0.02474668f, 0.07886544f, -0.01089566f, 0.17637104f, -0.19161969f, 
    -0.19155812f, -0.07402457f, 0.01289746f, -0.00453814f, 0.20342198f, -0.03094874f, 0.16433404f, 0.00217045f, 
    -0.29598653f, 0.03276161f, -0.42881224f, -0.26299626f, -0.14546786f, -0.08758461f, -0.07559839f, -0.13344766f, 
    -0.06601895f, -0.04064525f, -0.10046478f, -0.11785173f, -0.17167923f, 0.16033192f, -0.53231466f, 0.09873015f, 
    -0.11706903f, 0.01700275f, -0.05613138f, 0.00541171f, -0.03850892f, -0.05742085f, -0.08591815f, -0.02918877f, 
    -0.13053887f, -0.08350263f, -0.04531375f, 0.05501764f, 0.04892816f, -0.00628501f, -0.12486897f, -0.19921780f, 
    -0.08298462f, 0.16535698f, 0.01748748f, -0.29454306f, 0.29612845f, 0.03930139f, 0.00518936f, -0.01345908f, 
    0.11873410f, -0.08952174f, -0.15673575f, -0.03378523f, -0.08959265f, 0.02592842f, -0.07802045f, -0.33144006f, 
    0.00387533f, -0.10655702f, 0.03517963f, -0.01226509f, 0.04159382f, 0.00615581f, -0.04011055f, -0.05796567f, 
    0.07963411f, 0.02982459f, -0.11014663f, -0.13168727f, -0.30294359f, -0.18909037f, -0.08809295f, -0.06711825f, 
    -0.06122274f, -0.05431622f, 0.03941830f, 0.04536022f, -0.08823933f, 0.02758769f, -0.00222373f, -0.01043440f, 
    -0.02147276f, 0.10734162f, 0.01447205f, -0.10208791f, 0.02551318f, 0.10017326f, -0.04411990f, -0.11668325f, 
    -0.00371400f, -0.05222380f, -0.00157518f, -0.01395496f, -0.17798690f, 0.12573326f, -0.11644772f, 0.14174975f, 
    -0.25858769f, 0.05971199f, -0.09136963f, -0.12203486f, 0.03623232f, 0.06963570f, -0.05257714f, -0.13765968f, 
    -0.32083985f, 0.14928348f, -0.28014630f, 0.08714605f, 0.03249007f, -0.04245146f, 0.01747730f, -0.11753199f, 
    0.06762429f, 0.07829277f, 0.05100752f, 0.16013277f, -0.25125194f, 0.17844316f, -0.14359538f, 0.06111658f, 
    -0.02925397f, -0.09275469f, 0.12652619f, -0.03410413f, -0.14242201f, -0.09106979f, -0.01959782f, -0.21076022f, 
    -0.46531075f, 0.10541338f, -0.08995165f, -0.02258307f, -0.09184414f, -0.00757030f, 0.06454352f, -0.26745242f, 
    0.00383366f, -0.00798063f, -0.00230450f, 0.05373632f, -0.21716182f, -0.21003914f, -0.19859187f, -0.03445258f, 
    -0.09041579f, -0.25194606f, -0.22592452f, -0.21080157f, 0.01220423f, 0.01045357f, -0.13327856f, -0.05445518f, 
    -0.09494285f, 0.02832716f, 0.10770062f, -0.04687106f, 0.03605170f, 0.11428301f, 0.19293152f, -0.19891168f, 
    -0.09937066f, 0.09352495f, 0.09872414f, 0.10328596f, 0.39043221f, 0.03422105f, 0.12676169f, 0.01360761f, 
    0.06025899f, -0.09555646f, -0.02547785f, -0.08227221f, -0.01872983f, -0.05806495f, -0.04935944f, -0.09784087f, 
    -0.18324324f, -0.16602319f, 0.17927074f, 0.01832153f, -0.01686602f, 0.12143896f, 0.02652095f, 0.09455126f, 
    -0.19667393f, 0.04219379f, 0.07953659f, -0.05107480f, -0.14816387f, -0.11620329f, 0.00772169f, 0.57413137f, 
    0.24428496f, -0.08660595f, 0.09232089f, -0.03024981f, -0.09821098f, 0.20377365f, 0.01195426f, -0.04656415f, 
    -0.13047780f, 0.03495644f, -0.26704389f, 0.11498814f, 0.02606881f, -0.16561560f, 0.16644311f, -0.09344241f, 
    0.11190659f, 0.11509614f, 0.00654449f, 0.05865032f, -0.11607265f, 0.22419885f, -0.13394392f, 0.20454903f, 
    -0.00855438f, 0.06986103f, 0.13522774f, -0.10171954f, -0.03402212f, 0.05677714f, 0.14497700f, 0.08711332f, 
    -0.08828766f, -0.03180794f, -0.22454551f, 0.27649212f, 0.06851454f, 0.17925847f, 0.02173552f, -0.09489468f, 
    -0.03996794f, 0.15347597f, 0.12640707f, 0.12242690f, 0.42622083f, -0.08238830f, 0.37287545f, -0.12152107f, 
    0.01359668f, 0.03695047f, -0.29021332f, 0.06978662f, 0.00529636f, 0.12827890f, 0.02546238f, -0.02480336f, 
    -0.14210545f, -0.66432047f, -0.43094549f, 0.11066967f, -0.10934311f, -0.09104328f, -0.06752683f, -0.03910424f, 
    0.05344630f, 0.05626015f, 0.26616627f, -0.03243671f, -0.17838989f, 0.02606279f, 0.11921518f, 0.19063269f, 
    -0.03340130f, -0.04489363f, 0.09542425f, -0.00819664f, -0.19760828f, -0.07214358f, -0.16154520f, -0.20446476f, 
    -0.11550324f, 0.20224743f, 0.05177991f, 0.29668689f, -0.10682666f, -0.12273050f, 0.09002959f, 0.22997820f, 
    -0.22184591f, 0.01312670f, 0.16302215f, 0.03767847f, -0.25853097f, 0.08749329f, -0.29651377f, 0.19467375f, 
    0.02202051f, -0.07250143f, 0.16016105f, -0.12342220f, 0.05054082f, -0.03874528f, -0.08361017f, -0.04734905f, 
    0.05738629f, -0.19956523f, 0.19276285f, -0.22578567f, 0.08919868f, 0.00336477f, 0.25361377f, 0.01857633f, 
    0.07662288f, 0.03535657f, 0.18812755f, 0.11854787f, -0.13554196f, 0.17127378f, 0.10372256f, 0.01790924f, 
    0.11161450f, 0.13336989f, 0.06782228f, -0.15057787f, 0.01100435f, -0.09469379f, -0.07290833f, 0.03517682f, 
    0.19473308f, -0.00846561f, -0.01678633f, 0.22058681f, 0.04518779f, 0.06379157f, -0.23114204f, 0.01198196f, 
    0.01597847f, -0.03132336f, -0.01758134f, -0.00208986f, -0.40331203f, -0.31972575f, -0.27276102f, 0.06240065f, 
    -0.08463248f, 0.02094243f, 0.01575949f, 0.02535853f, 0.07616245f, -0.03264670f, 0.14819664f, 0.13866176f, 
    -0.14694740f, -0.15200388f, -0.05343613f, -0.16385292f, 0.04594781f, 0.03148741f, 0.04833227f, 0.07936608f, 
    0.00797090f, 0.13337222f, 0.09726420f, -0.08564284f, -0.15397896f, -0.25639117f, 0.21976382f, -0.08934972f, 
    0.18648323f, -0.11473703f, 0.12145007f, -0.05827572f, 0.00144443f, 0.00915944f, 0.02442003f, -0.16393726f, 
    0.01314820f, 0.11037658f, -0.06142134f, 0.13490845f, -0.08335742f, -0.15864246f, 0.17204216f, -0.08712747f, 
    0.00600003f, -0.05688234f, 0.06889018f, -0.07276531f, -0.09138528f, -0.21009120f, 0.06492579f, -0.18526876f, 
    -0.05046751f, -0.15843028f, -0.13110076f, -0.17324418f, -0.02063173f, 0.01075629f, -0.03768831f, -0.04904259f, 
    0.02023184f, -0.14836192f, 0.04930836f, -0.10872321f, -0.00693973f, 0.19858816f, 0.00996659f, -0.06412311f, 
    -0.06164042f, -0.02404363f, 0.16516604f, -0.02569063f, 0.19157571f, 0.19662558f, 0.01737260f, 0.14914785f, 
    -0.05493237f, -0.00338497f, 0.07980771f, 0.18594974f, 0.14172138f, 0.09346180f, -0.06264438f, 0.05193701f, 
    -0.08387210f, -0.08253206f, 0.12344039f, 0.26084906f, -0.01168044f, -0.01666878f, 0.12404071f, -0.00674768f, 
    0.08355375f, -0.06906961f, -0.12382603f, -0.11324782f, 0.16613735f, 0.00997807f, 0.25874549f, 0.11411545f, 
    -0.04127877f, -0.12495703f, 0.05629602f, 0.17340398f, -0.04138919f, 0.04379332f, 0.07594468f, -0.04218175f, 
    -0.21569970f, -0.01930362f, 0.05180702f, 0.06180393f, -0.00503191f, 0.06853453f, -0.06339031f, 0.04975197f, 
    -0.21364325f, -0.08827800f, 0.17002898f, -0.03121707f, 0.07040211f, -0.06547134f, 0.17079966f, -0.10489809f, 
    -0.02416158f, -0.08798374f, -0.01619007f, 0.05769344f, 0.06062785f, -0.02981283f, -0.25989869f, -0.12843049f, 
    0.10961394f, 0.13640869f, -0.14803575f, 0.11245909f, -0.07029363f, 0.19159278f, -0.02143547f, 0.13120827f, 
    0.05317322f, 0.08232164f, -0.12647609f, -0.04324542f, -0.56080514f, -0.12773593f, -0.34590155f, 0.11072981f, 
    0.23525086f, 0.02292153f, -0.06517583f, 0.01882588f, -0.11394151f, -0.08338725f, 0.03353165f, -0.07090580f, 
    -0.06145700f, 0.20494521f, -0.10826034f, 0.12746345f, -0.06118320f, 0.02455533f, 0.04874763f, 0.19002815f, 
    0.19864078f, 0.18156947f, 0.08013137f, 0.14153565f, -0.63612694f, 0.35960960f, -0.26841739f, 0.28510481f, 
    0.14020966f, 0.07636861f, 0.03117339f, -0.01020330f, -0.23775753f, 0.16341347f, 0.14721714f, 0.04093355f, 
    -0.05027827f, -0.11865035f, -0.06606466f, -0.01413010f, 0.06975425f, -0.04732172f, 0.02035574f, 0.11171581f, 
    -0.09433788f, 0.02711103f, -0.06238617f, 0.06841440f, -0.09331144f, 0.11788861f, -0.22454596f, 0.02675525f, 
    -0.08716889f, 0.09394962f, -0.01178273f, -0.20720559f, 0.18430367f, 0.07627958f, 0.04299566f, -0.14949194f, 
    0.17511946f, -0.07229933f, -0.14306313f, 0.35464719f, -0.01262416f, 0.16519392f, 0.04496328f, 0.03851147f, 
    -0.15214507f, 0.15771261f, -0.00407682f, -0.00011746f, -0.08705725f, 0.31651732f, 0.05146689f, 0.29690063f, 
    0.02209502f, 0.00353128f, -0.00836390f, -0.03809000f, -0.15613268f, 0.11100744f, 0.07515378f, -0.04513355f, 
    0.16037518f, -0.08775949f, 0.21850103f, -0.11643559f, -0.06495855f, -0.24055444f, -0.15223549f, -0.22983149f, 
    0.04594497f, -0.07643545f, 0.06480127f, -0.03768334f, -0.05312815f, 0.17019372f, 0.06384212f, 0.22621490f, 
    -0.17152463f, 0.02221180f, 0.16145973f, 0.06172563f, -0.07050809f, 0.04876929f, 0.05767972f, -0.10478828f, 
    -0.42797521f, 0.16819549f, -0.22920585f, 0.02591829f, 0.09158505f, 0.03919936f, 0.05261001f, -0.05677583f, 
    0.04976007f, -0.04821601f, 0.16580607f, 0.05071767f, 0.05569172f, -0.17768781f, 0.02818123f, 0.14623648f, 
    0.00517857f, -0.08094529f, -0.17213017f, -0.18497191f, 0.01601755f, 0.01541452f, -0.00900020f, -0.27145630f, 
    0.00328143f, -0.02440191f, -0.06679760f, -0.07934261f, 0.08935977f, 0.06779559f, -0.10971715f, -0.00465787f, 
    0.11994290f, -0.00810065f, 0.07537808f, 0.02992678f, -0.41400591f, 0.24163446f, -0.27995515f, 0.10176225f, 
    -0.22237575f, -0.26140445f, 0.07246248f, -0.07897779f, -0.00208657f, -0.01360590f, -0.00836894f, 0.03798749f, 
    -0.35124314f, -0.23948848f, -0.13133167f, 0.47250983f, -0.17313193f, -0.11877690f, 0.05379920f, -0.21116547f, 
    0.08065793f, 0.07211210f, -0.06196175f, 0.03091991f, 0.43712485f, -0.39634237f, 0.58514428f, -0.34023821f, 
    0.12139399f, 0.11569851f, -0.18636774f, 0.06901153f, -0.01494501f, 0.00762951f, -0.00051291f, 0.26095021f, 
    0.04731845f, -0.19822446f, 0.09190753f, 0.00889909f, 0.06978513f, -0.08993600f, 0.05810628f, 0.00651636f, 
    -0.05356678f, 0.05572061f, 0.10751554f, 0.03083178f, -0.20171322f, -0.54169041f, -0.07226712f, 0.21576124f, 
    -0.02197547f, 0.14469364f, -0.04941406f, 0.08892106f, 0.00659596f, 0.06688892f, 0.12722947f, -0.07225990f, 
    -0.05453613f, -0.55025214f, 0.33765310f, -0.30117816f, -0.04460054f, 0.03430712f, -0.28061008f, -0.03376725f, 
    -0.03791251f, 0.06228510f, 0.10738818f, 0.10193806f, -0.04835616f, 0.05804288f, 0.04047133f, -0.12446138f, 
    -0.08822452f, 0.03357533f, 0.14174935f, 0.02294536f, -0.05348022f, 0.07520220f, -0.03535439f, -0.05899127f, 
    0.01346692f, -0.31051642f, 0.09307557f, -0.31898913f, -0.09097684f, -0.08315339f, -0.08153537f, -0.12066916f, 
    0.06919552f, 0.06567890f, 0.06311088f, -0.02315404f, -0.27488527f, 0.21501161f, 0.01506558f, 0.10225335f, 
    -0.07304944f, -0.02681434f, -0.05017897f, -0.03215993f, 0.00236686f, -0.07899300f, -0.05002341f, 0.07283670f, 
    0.19796225f, 0.03791648f, 0.06965458f, -0.26602486f, -0.10373431f, -0.11118487f, -0.02646116f, -0.07320459f, 
    0.07683028f, 0.03536228f, 0.07572591f, -0.10679921f, 0.24029820f, -0.34877032f, 0.25662518f, 0.07070234f, 
    0.24148652f, -0.10574205f, -0.11480359f, -0.00931783f, -0.02170432f, 0.00871109f, 0.11078039f, 0.11913842f, 
    0.36070240f, -0.13288665f, 0.17950246f, 0.04384030f, -0.00400586f, 0.05221158f, 0.00130900f, -0.06486242f, 
    -0.08412247f, -0.08162365f, 0.07633403f, 0.06626090f, -0.19079795f, -0.23459509f, -0.07783890f, -0.17450099f, 
    0.05884616f, -0.04433402f, -0.00158273f, -0.01294729f, -0.21218792f, -0.09596094f, -0.07105602f, -0.12943396f, 
    0.23452912f, 0.02836242f, 0.00620108f, -0.00957565f, 0.01750334f, 0.01018789f, 0.00356004f, 0.02497032f, 
    -0.06184388f, -0.01260797f, -0.02851753f, -0.05291826f, 0.13919532f, 0.12804508f, 0.09561371f, -0.10553934f, 
    -0.01807541f, -0.05146463f, 0.01549033f, 0.00611269f, -0.18051516f, 0.10379418f, 0.00597020f, -0.03426208f, 
    -0.03794627f, 0.25678584f, -0.07981306f, -0.37515387f, 0.13093969f, -0.02833575f, 0.06293253f, -0.05754004f, 
    -0.03136022f, 0.02555549f, 0.05821414f, 0.03486759f, -0.23135908f, -0.28184143f, -0.17147012f, -0.14461087f, 
    0.04807913f, -0.02471083f, 0.04346260f, -0.02227742f, -0.09215681f, -0.01775006f, -0.00560644f, -0.03624126f, 
    0.24045177f, 0.13751461f, 0.03787781f, -0.39382914f, -0.10571031f, -0.22119281f, 0.09838703f, 0.10852358f, 
    0.03878773f, 0.13889247f, 0.00959430f, 0.17443846f, 0.40586188f, 0.41391608f, 0.41769174f, -0.05958284f, 
    -0.10059886f, -0.11099876f, -0.09416112f, 0.02422438f, -0.17527503f, 0.03410667f, 0.00981125f, -0.04607011f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.11422954f, 0.10951655f, 0.02587986f, -0.06723093f, -0.10696578f, 0.04588051f, -0.02511125f, -0.09094871f, 
    0.05176419f, 0.03699739f, 0.01775742f, 0.00104570f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
