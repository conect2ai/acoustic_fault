#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.08896663f, 1.44662917f, 0.50043505f, -1.03961635f, 0.00385774f, -0.12370098f, -0.14299844f, 0.19786568f, 
    -0.65153646f, -0.17164166f, 0.68345296f, 0.80689436f, -0.21137759f, 0.13485268f, 0.00511316f, 0.10937981f, 
    -0.12411846f, -0.41252020f, 0.29108337f, 0.64191049f, 0.51049495f, 0.00542350f, -0.27287990f, 0.08855692f, 
    0.76279414f, 1.39979494f, 0.77117836f, 1.08576822f, -0.07735274f, 0.25537190f, -1.19156170f, -0.09011307f, 
    -0.69682056f, -0.56554955f, -0.86538684f, -0.05847854f, -0.06862586f, -0.41617531f, -0.03952936f, -0.23056689f, 
    -0.17486222f, -0.50290024f, -0.14312015f, -0.29769158f, -0.34503371f, -0.11564219f, 0.21559985f, 0.33227310f, 
    -0.23208037f, -0.31653485f, 0.96571648f, 1.01005352f, -1.76332366f, 1.03145528f, -0.84350163f, -0.26946154f, 
    -0.15949538f, 0.12490612f, 0.18101200f, -0.90481341f, -0.28702903f, 0.09466776f, 0.08807759f, 0.22490215f, 
    0.14777218f, -0.18325488f, -0.14565083f, -0.45794639f, -0.01040274f, 0.02907540f, 0.15938848f, -0.02356340f, 
    -0.35892645f, -0.13408086f, -0.11403845f, 0.51406389f, -0.28096566f, -1.16019499f, -0.92423606f, -0.91672528f, 
    0.48222855f, 0.84319800f, 0.91738105f, 0.62212569f, 0.77718014f, -0.07627131f, -0.41088015f, -0.22807375f, 
    -0.68878180f, -0.38418698f, -0.32408190f, 0.22781637f, 0.04799020f, -0.08944358f, -0.17799075f, -0.38807562f, 
    -0.15698764f, -0.59154427f, -0.34733659f, -0.17264971f, -1.60346484f, -0.48210335f, -0.30368626f, -0.15166977f, 
    -1.07679832f, 0.75211692f, 1.20671189f, -0.31983858f, 0.13787623f, 0.71624953f, -0.53547400f, -0.33031926f, 
    0.00053690f, -0.14759745f, 0.26351807f, -0.51848191f, -0.12476754f, -0.28763261f, -0.12965107f, -0.11545604f, 
    -0.15378124f, -0.27465805f, 0.08164696f, 0.08676834f, -0.15943526f, 0.36203042f, -0.62897170f, 0.94527221f, 
    1.44699681f, 1.14096296f, -1.21734416f, -0.75584859f, -0.59646738f, -0.84753364f, -0.09910066f, 0.32813355f, 
    0.34078473f, 0.27595010f, 0.64369309f, -0.03777897f, 0.05290465f, 0.27999565f, 0.39396366f, 0.38343909f, 
    0.11429185f, -0.10146224f, -0.00344065f, -0.16364038f, -0.19281071f, 0.48330477f, 0.92706430f, -0.87351900f, 
    0.00277535f, -1.45049500f, -0.65087408f, -0.11192477f, -0.71702462f, -0.06154371f, -0.33906206f, -0.48427355f, 
    0.51339972f, 0.28561184f, -0.23981006f, 0.30385667f, -0.18964995f, 0.54729623f, -0.03251733f, 0.24914289f, 
    0.10348919f, 0.24698777f, -0.50750977f, -0.13965292f, 0.28251976f, -0.08860648f, 0.14625618f, 1.96048605f, 
    0.66141218f, 0.75850058f, 0.19909653f, -0.78194994f, 0.66084164f, -0.58096141f, 0.47841603f, 1.27891564f, 
    -0.01126552f, -0.29991552f, -0.25662354f, 0.00781840f, -0.52077079f, -0.25550556f, 0.16912693f, -0.39432237f, 
    -0.00756769f, -0.01027088f, 0.00712255f, 0.19040139f, -0.02826327f, 0.12869500f, -0.22887821f, -0.10234238f, 
    1.55201042f, 1.02026117f, 0.09559630f, -0.49807447f, -0.22062063f, -0.58099157f, -0.50309545f, -0.72847426f, 
    0.35807812f, 0.71807951f, 0.02673128f, -0.13667235f, 0.59537178f, 0.03899980f, -0.25016430f, 0.21049461f, 
    -0.40536946f, 0.51417160f, 0.60940695f, 0.21583548f, 0.31606725f, 0.39970720f, -0.29276231f, 0.11363836f, 
    0.24784738f, 0.84413254f, -0.36778334f, -1.43480337f, -0.98438197f, 0.59258217f, 0.94377828f, -0.70489013f, 
    -0.48427984f, 0.41493788f, -0.19280203f, -1.02840519f, 0.02497290f, -0.14839931f, 0.35676557f, 0.19043188f, 
    -0.12748334f, -0.23721671f, -0.13367619f, 0.15690351f, -0.00459211f, 0.19837195f, 0.06877835f, -0.30337027f, 
    -0.05983921f, 0.08903570f, -1.46159530f, -1.29609191f, -0.33600149f, 0.54615378f, 0.56916600f, -0.08319820f, 
    1.42106616f, 1.34437418f, -0.24418165f, 0.13836966f, 0.10539524f, 0.01756311f, 0.34315270f, -0.01181816f, 
    0.54017496f, -0.26653901f, 0.13083801f, 0.11176883f, -0.07578155f, 0.20833226f, 0.25574750f, -0.09105100f, 
    0.09469200f, 0.21844006f, 0.19054794f, -0.71433824f, -0.75676513f, -0.60747659f, -0.55349064f, 0.40346348f, 
    -0.23938994f, -0.54404706f, 0.25455761f, -0.32837513f, -0.33888289f, 0.25598538f, -0.36314380f, 0.21418957f, 
    1.07977939f, 0.16862911f, 0.12213405f, 0.10578123f, 0.31452686f, 0.21519816f, 0.52601290f, 0.53647989f, 
    -0.68928277f, 0.70822078f, -0.38128120f, -0.22597183f, 1.62881398f, 0.82946318f, -0.06920549f, 1.11103678f, 
    1.16255951f, 0.78444302f, 0.97138262f, 0.64715368f, 0.64418507f, 0.61377382f, -0.47978082f, 0.12801632f, 
    -0.33524555f, 0.14097874f, -0.06843065f, 0.10567798f, -0.08320451f, -0.06637291f, 0.06663771f, 0.24529867f, 
    0.12486706f, -0.03130378f, 0.14969760f, -0.16822581f, 0.06678490f, -0.46174982f, -1.18998802f, -1.09226263f, 
    -0.72360921f, -0.58097535f, 0.06087322f, 0.99803573f, -0.70508605f, -0.60531998f, -0.01064775f, 0.09732578f, 
    0.55691200f, -0.44491228f, 0.14810364f, -0.00506040f, 0.07333413f, 0.19366695f, 0.63968199f, 0.17659335f, 
    0.09911844f, 0.22135065f, 0.27690294f, -0.42925248f, -0.09480779f, 0.32670867f, -1.48403323f, -0.46140778f, 
    -0.64753902f, -0.08043180f, -0.39494205f, 0.01420281f, -0.59066606f, 0.19139752f, 0.66876531f, -0.58875996f, 
    -0.18210766f, 0.32563928f, 0.09484316f, 0.63310963f, -0.38399470f, 0.10362649f, -0.25260913f, -0.41362864f, 
    0.02160468f, -0.39294669f, 0.27410668f, 0.44133103f, 0.55531114f, -0.18320210f, 0.45906186f, 0.82262570f, 
    -1.10890377f, -0.11066372f, -0.91865921f, 0.87561649f, 1.23626328f, -1.00629652f, 0.62591171f, -0.23286538f, 
    0.35469028f, 0.37441304f, 0.66016126f, 0.05327989f, 0.42528293f, -0.18902262f, -0.27052593f, 0.07012600f, 
    -0.09742544f, 0.16304801f, 0.05056377f, 0.12634178f, 0.20939560f, -0.23737231f, -0.12663384f, -0.18724483f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.24433282f, 0.49554241f, 0.19257511f, 0.13395651f, -0.07768166f, 0.40947199f, 0.50546712f, 0.36496109f, 
    0.20655398f, 0.38294625f, 0.36183801f, 0.27469474f, 0.24235667f, 0.34198499f, 0.37847930f, 0.30462590f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.42837682f, 0.22239482f, 0.43495616f, -0.45281720f, 0.07824888f, 0.11103536f, 0.22839281f, -0.09101714f, 
    0.03073084f, -0.12016387f, 0.10683595f, 0.04503940f, 0.29386440f, 0.27473977f, 0.00513973f, -0.08509779f, 
    -0.28402531f, -0.25396714f, -0.19460917f, 0.03245060f, -0.04859235f, -0.05204707f, -0.00945376f, -0.26860163f, 
    0.05667163f, 0.34717596f, 0.17809124f, -0.32098556f, -0.26782688f, 0.01522817f, -0.26047695f, 0.19391675f, 
    -0.07391953f, -0.20336011f, 0.06455828f, 0.19612664f, -0.05820746f, 0.12093353f, -0.00985453f, -0.63486850f, 
    0.43188244f, 0.30733800f, 0.17795278f, -0.09501640f, -0.09719379f, -0.01194596f, 0.09946221f, 0.17101419f, 
    0.81569874f, 0.19822991f, 0.22158918f, -0.17177528f, 0.06996071f, 0.11215066f, -0.16422811f, 0.11660637f, 
    0.12867408f, -0.14111617f, 0.03854650f, 0.07051326f, 0.09932695f, -0.14191088f, -0.15163313f, 0.34099391f, 
    -0.39373094f, -0.01264097f, 0.09099386f, -0.11764208f, -0.17735258f, 0.15706991f, -0.19781096f, -0.08633576f, 
    -0.19194756f, -0.04415004f, 0.36462709f, -0.42934611f, -0.17836240f, -0.02849173f, 0.20297867f, 0.01106046f, 
    -0.15925528f, -0.09039096f, -0.10270800f, -0.07522361f, 0.54751688f, -0.18666905f, -0.23393235f, 0.22558889f, 
    0.19100973f, -0.16270334f, -0.29192999f, -0.00061329f, 0.10314169f, -0.08155248f, -0.10136616f, -0.01402783f, 
    -0.03849281f, -0.04944937f, 0.00684797f, -0.39784807f, 0.07578199f, -0.04507918f, -0.04375494f, 0.09440243f, 
    -0.07703065f, -0.00197498f, 0.13384375f, 0.19206974f, 0.11625363f, -0.47749531f, 0.24413294f, -0.33009139f, 
    0.11030674f, -0.10385903f, 0.40199968f, -0.17232095f, -0.02804659f, 0.01196860f, 0.08008055f, 0.14917220f, 
    -0.48143303f, 0.34824404f, 0.13837859f, -0.17970012f, 0.02914635f, 0.05331636f, -0.40034556f, -0.00949992f, 
    -0.00029998f, -0.08147660f, -0.16211174f, 0.05422202f, -0.31209254f, 0.21359012f, -0.03862758f, -0.14835784f, 
    0.13436735f, 0.12466092f, 0.04608870f, 0.07816986f, 0.13463782f, -0.08537851f, -0.22051384f, -0.13265166f, 
    0.13347521f, 0.04792638f, 0.16618519f, 0.31623897f, -0.19031145f, 0.18612425f, -0.06720375f, 0.21099007f, 
    0.05927571f, 0.11569799f, -0.13424166f, -0.20358653f, -0.64136904f, -0.67376655f, 0.12700945f, -0.33984140f, 
    -0.14235933f, -0.20882235f, 0.07441738f, 0.10714447f, 0.05661610f, -0.14705977f, 0.03123492f, 0.08309670f, 
    -0.10891401f, 0.11837304f, -0.27242267f, -0.09831192f, -0.12517336f, -0.01669608f, -0.16021869f, 0.16547759f, 
    0.07392915f, -0.07118659f, 0.04538908f, -0.12871882f, 0.58005011f, -0.35629222f, 0.06281585f, -0.49458429f, 
    0.05124593f, 0.13841553f, -0.03968741f, -0.27068621f, -0.03159124f, 0.04020231f, 0.18173766f, -0.10175046f, 
    -0.29535300f, 0.20241302f, -0.23477459f, -0.41523561f, -0.17085591f, -0.04642447f, -0.05671491f, -0.04777880f, 
    -0.00223954f, 0.30889779f, -0.16124350f, 0.08365335f, 0.24648577f, -0.00522025f, -0.07318740f, 0.11484294f, 
    0.07410333f, -0.19285005f, 0.15643702f, 0.03970431f, 0.06640178f, -0.09671904f, -0.03299239f, 0.16325611f, 
    0.04412963f, -1.19934201f, -0.31760404f, -0.21714325f, -0.05397183f, -0.03666919f, -0.19198756f, 0.08161488f, 
    -0.22885562f, 0.09200653f, -0.25186834f, -0.00966402f, 0.34722173f, -0.33419886f, 0.16130246f, -0.49586508f, 
    0.29293403f, -0.12533043f, -0.12545393f, -0.07193568f, -0.02109363f, -0.02173508f, 0.00031451f, -0.14816482f, 
    -0.67787087f, -0.13091889f, -0.19466977f, -0.04560186f, -0.08123258f, -0.08426653f, -0.20600195f, -0.09689306f, 
    -0.05593013f, 0.05700612f, -0.15054372f, -0.06186461f, -0.23612027f, 0.02326764f, 0.09788039f, 0.18967679f, 
    -0.04205213f, 0.15928562f, -0.17480946f, 0.06517765f, 0.02604426f, -0.00043270f, 0.20726483f, -0.05800363f, 
    0.09611136f, -0.08065265f, -0.00453143f, 0.00501060f, 0.41298619f, 0.05128610f, 0.06174367f, 0.05146693f, 
    -0.16875571f, 0.28309241f, 0.05289745f, 0.07894637f, 0.05869991f, -0.13750240f, 0.18653195f, 0.16721685f, 
    -0.12075634f, -0.14913435f, 0.11436482f, 0.09834735f, 0.05345219f, -0.15063666f, 0.02506989f, -0.16953446f, 
    0.51445168f, -0.08896739f, 0.08438402f, -0.17486088f, 0.05340880f, -0.38759467f, 0.24059045f, 0.15892559f, 
    -0.01308790f, -0.04340230f, -0.11808275f, 0.02728689f, -0.01036219f, -0.57053262f, 0.34749284f, -0.67164797f, 
    -0.08280500f, -0.14598539f, -0.18069275f, -0.03479054f, -0.17118748f, -0.04564439f, 0.09416588f, -0.05430657f, 
    0.50430709f, 0.08206598f, -0.35289809f, 0.11062395f, -0.00757525f, 0.12934265f, -0.23394221f, -0.01294762f, 
    -0.04895603f, 0.06199171f, 0.10422387f, -0.01619599f, 0.18008424f, -0.14338993f, 0.00887056f, -0.07493852f, 
    -0.07507363f, -0.00726339f, 0.01854009f, -0.00582328f, -0.00225114f, 0.11550472f, 0.04506398f, 0.34513816f, 
    0.78736514f, 0.17217410f, 0.32233009f, 0.25480163f, -0.05609901f, -0.18917750f, -0.26466206f, 0.04058699f, 
    -0.14503153f, 0.22560392f, -0.00706196f, 0.18652913f, 0.40047100f, -0.01131956f, -0.38098755f, 0.08295757f, 
    0.09749139f, -0.14885449f, 0.14710543f, 0.01472570f, 0.09798675f, 0.05192322f, 0.06550086f, -0.06543665f, 
    -0.27795008f, -0.19870761f, -0.23013179f, -0.06386366f, -0.05721986f, 0.02004367f, -0.09619995f, 0.20219207f, 
    0.13531886f, -0.07466140f, -0.25268695f, -0.00814377f, 0.30445343f, -0.29724348f, 0.45087543f, -0.10937352f, 
    -0.11340688f, -0.03657129f, -0.02454898f, 0.35569000f, 0.10279652f, -0.16342533f, -0.01189834f, 0.08743442f, 
    0.04178162f, -0.07812564f, -0.14772686f, -0.04399988f, -0.06513152f, 0.15994579f, 0.14221472f, -0.30651632f, 
    0.00822964f, -0.06576943f, 0.07755552f, -0.04545382f, -0.55195862f, 0.58339196f, -0.35945144f, -0.30736539f, 
    0.23815337f, 0.00787882f, 0.03435401f, -0.26376987f, -0.08778476f, 0.20250830f, -0.04564539f, -0.03003967f, 
    0.16638915f, -0.49850500f, -0.76161206f, -0.42732924f, -0.00901431f, -0.14307703f, 0.07021836f, -0.20296967f, 
    0.13950865f, 0.16025524f, -0.06434848f, -0.07075454f, 0.12571582f, 0.19799867f, 0.21884789f, 0.45782024f, 
    -0.16400588f, -0.22020023f, 0.28350654f, 0.29018608f, -0.20955418f, -0.01477817f, -0.09292016f, -0.02919274f, 
    1.06665826f, -0.05660988f, -0.00075275f, 0.24923502f, -0.10511137f, -0.14780679f, -0.13932778f, 0.33585048f, 
    -0.04943329f, 0.08825528f, 0.05852125f, -0.10641680f, 0.32448414f, -0.03815951f, -0.32107905f, 0.24173559f, 
    0.02408488f, 0.19999953f, -0.08155801f, -0.13211830f, -0.28708312f, -0.01334312f, -0.13655375f, -0.19872485f, 
    -0.99893087f, -0.41697884f, 0.03421533f, -0.43269101f, 0.13359798f, -0.24349907f, -0.22379561f, -0.00203675f, 
    0.09029105f, 0.01972317f, 0.12493955f, -0.03701356f, 0.01925748f, 0.07152106f, -0.09287669f, 0.11281014f, 
    0.15788871f, -0.23525017f, 0.16717696f, 0.32835469f, -0.06396735f, 0.08830971f, 0.06718282f, -0.08381564f, 
    -0.21263656f, 0.16974272f, 0.30614674f, -0.28326565f, 0.12517321f, 0.05992329f, 0.20855053f, -0.01782474f, 
    -0.15141569f, 0.00526798f, 0.03229880f, -0.04214026f, -1.05200803f, -0.11184649f, -0.00092514f, -0.07576825f, 
    0.17476851f, 0.19729474f, -0.02661454f, -0.06031397f, -0.15279511f, -0.11325025f, -0.14941159f, 0.13967554f, 
    0.51555514f, -0.09325352f, 0.01978227f, 0.30892673f, -0.31018603f, -0.12259394f, -0.16795172f, -0.03107158f, 
    0.09419800f, -0.09657101f, 0.08995458f, 0.21695119f, -0.14780821f, 0.07429657f, -0.20687123f, 0.12659790f, 
    -0.23354429f, 0.28908315f, 0.17118938f, -0.10893947f, -0.23311849f, -0.08035908f, -0.17186023f, -0.03387893f, 
    0.53296930f, -0.32951963f, 0.05348985f, -0.19438140f, 0.22979106f, -0.14716573f, 0.14563139f, 0.06313610f, 
    -0.06432614f, 0.00031353f, 0.02815191f, 0.10499788f, 0.57382810f, -0.12079714f, 0.34379905f, -0.12361792f, 
    -0.07100079f, -0.21755898f, -0.07230867f, -0.16292314f, -0.02157494f, -0.09844662f, -0.01065438f, 0.06406289f, 
    -0.14482893f, 0.02037902f, -0.23192066f, -0.12093955f, -0.14762703f, -0.17832489f, -0.19874774f, -0.16681108f, 
    0.12742434f, 0.00653124f, -0.14988737f, 0.05655905f, -0.53675973f, 0.48594016f, 0.17160378f, -0.10742702f, 
    0.00753378f, -0.08628651f, -0.07061956f, 0.00642509f, 0.11907397f, -0.07914416f, -0.15713143f, -0.03381577f, 
    -0.03863886f, -0.28475600f, 0.10351966f, -0.16794451f, 0.10268521f, 0.02417645f, 0.03523645f, 0.11101261f, 
    -0.01826915f, 0.29692003f, -0.08860137f, -0.12621933f, -0.22889310f, 0.04067913f, -0.05909689f, 0.12987269f, 
    0.05591017f, 0.13860087f, -0.05557176f, 0.19811271f, 0.00306143f, 0.00001876f, 0.13560261f, -0.12361424f, 
    0.99317729f, -0.35136354f, 0.11285717f, 0.01066198f, -0.00778197f, 0.00157914f, 0.25388882f, 0.01102197f, 
    0.11942639f, -0.00756658f, 0.20547238f, 0.06204659f, -0.32230267f, -0.24610396f, -0.05765758f, -0.12970625f, 
    -0.32485440f, -0.01859361f, -0.15615715f, 0.22412823f, -0.03776851f, -0.03306268f, -0.01102180f, 0.10598540f, 
    -0.07396125f, 0.07142769f, -0.04429364f, -0.37795532f, -0.03589592f, -0.11874972f, 0.04058271f, 0.06176420f, 
    0.16219033f, -0.28012478f, 0.18273604f, -0.05777453f, -0.39561123f, -0.16533332f, 0.47617772f, 0.65807527f, 
    -0.02772176f, 0.13169293f, 0.19025938f, -0.19220802f, -0.12150554f, -0.12684406f, -0.09490690f, -0.10690090f, 
    0.14448814f, -0.34419063f, -0.14978237f, 0.09611088f, -0.03463459f, 0.09316129f, 0.05992267f, 0.15409650f, 
    0.21620546f, 0.08717284f, -0.05271217f, -0.07405367f, -0.14307317f, -0.82980299f, -0.23151939f, -0.25552401f, 
    -0.00192452f, 0.04025297f, -0.02540277f, -0.01934774f, 0.03032965f, 0.22061804f, -0.25163895f, 0.01945018f, 
    -0.12642320f, -0.14128873f, -0.31018266f, 0.09318120f, -0.03545379f, 0.22183184f, -0.09533530f, 0.07222585f, 
    -0.04116019f, 0.18344058f, -0.08882610f, 0.23004943f, 0.28119597f, 0.12697840f, 0.22563003f, 0.27468312f, 
    0.17014617f, -0.16327642f, -0.05480712f, -0.12134126f, 0.05731303f, 0.07900198f, 0.05484923f, -0.09874551f, 
    0.28612915f, -0.00176245f, 0.14102462f, 0.07366522f, 0.05288599f, -0.09424796f, 0.26327410f, 0.00491511f, 
    -0.16642447f, 0.01868070f, -0.19568458f, -0.06793350f, 0.08941944f, 0.10255366f, -0.01626404f, -0.18178831f, 
    -0.21972270f, 0.20983416f, 0.21518764f, 0.02317457f, -0.05886655f, -0.25676760f, 0.01421335f, -0.20713745f, 
    -1.07450211f, -0.96319944f, -0.62179393f, -0.37252787f, -0.05107183f, -0.10242195f, -0.16311954f, -0.08332603f, 
    -0.06720953f, -0.27038807f, 0.03749558f, 0.03338321f, -0.04832204f, -0.07389611f, -0.00719907f, -0.16916396f, 
    -0.18477084f, -0.16728087f, 0.06983104f, 0.12870815f, -0.12278373f, 0.18110110f, 0.00978264f, 0.22033003f, 
    0.21666194f, 0.38370830f, -0.05238511f, 0.02703719f, -0.04872217f, 0.03813473f, 0.18065916f, 0.10500846f, 
    0.08101040f, 0.03951249f, 0.22685961f, -0.18957928f, -0.10998920f, 0.37933668f, -0.90108955f, 0.34011266f, 
    0.00237244f, 0.23607704f, -0.14920065f, 0.00696871f, -0.11521965f, -0.24212702f, 0.00580848f, -0.01084359f, 
    -0.15675583f, -0.07658589f, -0.10414134f, -0.11249585f, -0.09887601f, -0.34564543f, 0.11384011f, -0.06799065f, 
    -0.05430529f, -0.29477960f, 0.04998596f, -0.38984022f, -0.12299452f, -0.19323029f, 0.65791601f, -0.00552902f, 
    -0.17473483f, -0.17140557f, -0.01940565f, -0.06550983f, 0.07794755f, -0.04479128f, 0.05927066f, 0.08801103f, 
    0.10908458f, 0.34129179f, -0.13928358f, -0.05467816f, 0.22890398f, 0.03025968f, 0.22387223f, -0.17156744f, 
    -0.07678880f, 0.03566199f, 0.13012455f, -0.09471681f, -0.61578524f, -0.22721314f, 0.18271858f, 0.32302940f, 
    -0.22778399f, 0.04055531f, -0.07836672f, 0.12357277f, 0.02580573f, 0.14111699f, 0.28995740f, 0.10312141f, 
    -0.47548637f, -0.28452551f, 0.08099188f, 0.21236013f, 0.09938163f, -0.18091083f, 0.08048008f, 0.13226481f, 
    0.03168312f, -0.06471834f, -0.09162297f, 0.13926113f, -0.37463903f, 0.00825011f, 0.26231351f, 0.17781988f, 
    0.17957427f, 0.08740642f, -0.04029101f, -0.08200516f, 0.28729722f, -0.10375807f, -0.18706766f, -0.11536945f, 
    0.30601579f, 0.17449334f, 0.29919574f, -0.02888234f, -0.04841007f, 0.12578990f, 0.11645486f, -0.07062417f, 
    0.15643612f, 0.10965910f, 0.14635555f, -0.04505609f, -0.23852441f, 0.34205526f, 0.21387224f, -0.22790192f, 
    -0.09228356f, -0.12191862f, 0.03363035f, -0.03560712f, -0.08394793f, -0.00182368f, 0.04637729f, 0.23070087f, 
    -0.11497593f, -0.75927669f, -0.05184238f, 0.15139841f, -0.20947373f, 0.04839512f, 0.00878869f, -0.09955214f, 
    0.25650164f, 0.00754265f, -0.15605715f, 0.00686218f, -0.11402214f, -0.05644629f, -0.54387558f, 0.16453227f, 
    -0.10422288f, 0.08229913f, 0.09685855f, -0.03572502f, 0.03237665f, -0.16782951f, 0.03939245f, -0.02682085f, 
    -0.82444721f, 0.29410043f, -0.13792980f, -0.04051094f, 0.03246934f, -0.04184810f, 0.18096885f, 0.15540214f, 
    -0.28431028f, -0.08085922f, 0.09257530f, -0.05562160f, 0.01733229f, 0.24120778f, -0.13269991f, 0.25026384f, 
    -0.00756535f, -0.16722248f, 0.12847184f, -0.00203066f, -0.00849311f, -0.30852973f, 0.25349817f, -0.06434213f, 
    0.41891697f, -0.05688397f, -0.19844271f, 0.29785272f, -0.06481866f, 0.02825989f, 0.27671039f, 0.11894614f, 
    -0.05785255f, -0.00207865f, 0.09627017f, -0.03714991f, -0.59532875f, 0.21425192f, 0.51368397f, 0.06765331f, 
    0.21335015f, 0.02789108f, -0.09746467f, 0.18318348f, 0.06470683f, 0.02521656f, -0.04585465f, 0.13031523f, 
    0.47575909f, -0.15753688f, -0.29008314f, -0.39300758f, 0.07069620f, 0.09414095f, -0.20089436f, 0.13222563f, 
    0.32387164f, -0.09470279f, -0.06668714f, -0.09221593f, -0.15957710f, -0.25314662f, -0.33628342f, -0.01815834f, 
    0.13406324f, -0.00759693f, -0.05122184f, -0.37232986f, -0.10840298f, -0.05730129f, -0.21729901f, -0.00496674f, 
    -0.00576952f, -0.04566638f, 0.02143109f, 0.44140595f, -0.21493946f, 0.19336724f, -0.06146382f, 0.01168744f, 
    -0.17836934f, 0.09240638f, -0.07216317f, 0.22994161f, 0.04364641f, -0.16436031f, 0.08019476f, 0.50040376f, 
    -0.16159053f, -0.01404511f, -0.05879320f, 0.01993642f, 0.05578138f, -0.18621340f, 0.11721788f, 0.04986905f, 
    -0.00688464f, 0.27953604f, 0.14238697f, -0.13798006f, -0.10344695f, 0.13615116f, -0.04477867f, -0.04649698f, 
    -0.28965980f, -0.09976972f, -0.21490099f, -0.15316509f, 0.47605857f, 0.16980092f, -0.31769714f, 0.07115766f, 
    -0.04646872f, -0.04377072f, -0.35786277f, -0.18444405f, 0.01971917f, -0.06710820f, -0.11973652f, -0.06917306f, 
    -1.09177911f, -0.11862140f, -0.47566912f, -0.23289272f, 0.18816021f, 0.04570793f, 0.05156725f, -0.12606291f, 
    0.09945737f, -0.08788227f, 0.09659594f, -0.26650059f, 0.30477899f, 0.07743955f, -0.08909970f, -0.13876195f, 
    -0.00500555f, -0.05526394f, 0.04763277f, 0.07966549f, -0.09056082f, -0.05821179f, 0.25056192f, 0.47222066f, 
    0.04093275f, -0.24948028f, -0.00106138f, 0.20141405f, -0.22555932f, -0.04111677f, -0.16393475f, 0.17660871f, 
    0.15216398f, -0.15831630f, -0.02661877f, 0.17954434f, 0.48918959f, -0.01040487f, 0.02682558f, 0.16550466f, 
    0.01720983f, -0.08686443f, -0.05691397f, -0.04274369f, -0.05132822f, 0.16054338f, -0.03146397f, 0.01418146f, 
    0.04771415f, -0.05499677f, -0.09452195f, -0.10782541f, -0.02494979f, -0.13914986f, 0.03842669f, -0.02159953f, 
    -0.04610817f, -0.09623122f, 0.39611459f, 0.04622902f, -0.01130436f, 0.02029342f, 0.04392321f, -0.31567985f, 
    0.10017627f, 0.13188279f, -0.08127363f, 0.04518374f, 0.10732669f, 0.17683175f, 0.27738395f, -0.06184622f, 
    -0.83322209f, 0.22173539f, -0.00557768f, -0.40657493f, 0.22874247f, 0.19697997f, 0.18676572f, 0.06346052f, 
    0.21637103f, -0.04037015f, -0.14820042f, -0.12713394f, -0.32351679f, -0.34517106f, -0.05486421f, 0.19988562f, 
    0.01768515f, -0.33539978f, -0.20915969f, -0.20702893f, -0.08064247f, 0.34930724f, 0.13780575f, 0.03267897f, 
    -0.17629492f, 0.04256815f, 0.42364293f, -0.31295571f, 0.07326272f, 0.02554876f, -0.10931402f, -0.14007969f, 
    0.17518060f, 0.03509028f, -0.01340807f, 0.04652457f, -0.22400340f, -0.19234136f, -0.61427122f, 0.12698944f, 
    0.16234893f, 0.02040333f, -0.05313166f, 0.03170465f, 0.11683752f, -0.10232812f, 0.08502034f, 0.23646554f, 
    -0.61933899f, -0.04563382f, -0.28321990f, 0.29038930f, 0.05029821f, 0.11693733f, 0.16937175f, 0.04129207f, 
    -0.29348046f, 0.10647911f, 0.06362583f, 0.08711763f, -0.61786491f, 0.07474263f, 0.17760240f, 0.13320161f, 
    0.01326417f, -0.14254735f, -0.21171081f, 0.01293597f, -0.00943687f, 0.04659379f, 0.10433316f, 0.08211682f, 
    -0.17440574f, 0.09774540f, -0.31775054f, 0.25097209f, 0.25949761f, 0.25187442f, -0.06062211f, 0.05158652f, 
    0.09856746f, -0.27071610f, -0.01133952f, -0.20544645f, -0.20782731f, 0.16255128f, -0.20824504f, -0.25354466f, 
    0.18407539f, -0.09610093f, -0.00178157f, 0.21169056f, -0.07260998f, 0.21453744f, 0.03977599f, 0.26839736f, 
    0.15805903f, 0.33703747f, 0.37263781f, 0.78784484f, 0.03728546f, 0.07876256f, -0.02326633f, -0.07609982f, 
    0.21569835f, -0.01127954f, 0.20109652f, -0.00917223f, -0.46039018f, -0.06774407f, -0.15328966f, 0.18595065f, 
    0.12104766f, -0.08938126f, -0.20149761f, -0.06717806f, 0.08429761f, 0.06553622f, 0.28320390f, 0.21817951f, 
    0.60852951f, -0.39441636f, 0.02772993f, -0.32008094f, -0.34353662f, 0.00166150f, -0.03529360f, -0.20851776f, 
    -0.06020494f, 0.01205692f, 0.16202696f, 0.17583691f, 0.61817950f, 0.32680058f, -0.00028094f, -0.58489555f, 
    0.00201239f, 0.08312294f, -0.08810666f, -0.01979286f, 0.07634808f, 0.07380801f, -0.29450715f, -0.05106839f, 
    -0.08732489f, 0.20123209f, -0.76911229f, 0.26801699f, 0.06278519f, -0.12729225f, -0.01789213f, -0.11516707f, 
    -0.13608959f, -0.04585375f, -0.04595993f, 0.13446987f, -0.83248085f, 0.18353577f, -0.07948975f, 0.32854304f, 
    -0.07075062f, 0.16337714f, 0.34972984f, 0.10572205f, -0.00968324f, -0.01077286f, -0.03770363f, 0.06713042f, 
    -0.13477726f, 0.29522830f, 0.15582715f, 0.28337216f, 0.15348189f, 0.20130919f, -0.06993385f, -0.13576727f, 
    -0.16371535f, -0.06760430f, -0.04604291f, -0.34635949f, -0.15837124f, -0.30634564f, -0.20194300f, -0.29836348f, 
    0.02223355f, 0.06482953f, 0.16638575f, 0.01138442f, 0.11596338f, 0.09342000f, -0.18594660f, -0.06289275f, 
    0.02172436f, -0.92452139f, 0.15301615f, -0.15429680f, -0.09785110f, -0.13219295f, 0.10779388f, 0.08031903f, 
    0.12542938f, -0.04699244f, -0.03961935f, 0.17781682f, -0.35605165f, 0.26876456f, 0.08948576f, -0.21555342f, 
    0.11366436f, 0.08271442f, -0.10011385f, 0.26491284f, -0.02063774f, 0.02669369f, 0.04794160f, -0.22443992f, 
    -0.46700215f, 0.03022578f, 0.35630599f, -0.31720132f, -0.20028263f, -0.04866851f, 0.00365064f, 0.35091022f, 
    -0.06258873f, -0.14640424f, 0.05551808f, -0.00848007f, -0.17031534f, 0.02485357f, -0.31421727f, 0.02022020f, 
    -0.00097683f, -0.00510388f, 0.14100865f, -0.17419532f, -0.36421463f, 0.28557187f, -0.12173869f, -0.17516044f, 
    -0.41395718f, -0.06779736f, 0.33333027f, -0.09930411f, 0.03169422f, -0.12788114f, 0.09238261f, -0.41955683f, 
    -0.21973398f, -0.00053763f, 0.01100809f, -0.16717754f, -0.05775782f, -0.30303133f, -0.09566476f, 0.13191207f, 
    -0.03427200f, 0.17447113f, 0.07767642f, -0.06404246f, -0.10994624f, -0.08891033f, -0.01626408f, -0.05612465f, 
    0.06538275f, -0.12450494f, 0.06439647f, 0.23463200f, 0.27012110f, -0.04221428f, 0.00998922f, -0.11741593f, 
    -0.02716319f, -0.23466611f, -0.18305299f, -0.20066926f, -0.14715698f, -0.89634389f, -0.22889182f, 0.33795953f, 
    -0.29019442f, -0.01835589f, -0.14511904f, -0.13375162f, -0.33037919f, -0.12256070f, -0.04031497f, -0.21664564f, 
    -0.49614599f, 0.53267050f, 0.12101330f, 0.03252577f, -0.37908533f, 0.17583831f, 0.13640070f, -0.08611274f, 
    0.01438566f, -0.11719257f, 0.03806325f, -0.13809277f, -0.06735437f, 0.39185432f, -0.01772005f, 0.00271507f, 
    -0.09243181f, 0.15807389f, 0.24959555f, 0.05128813f, -0.07088482f, 0.09156042f, -0.08444639f, -0.15483221f, 
    0.07750772f, 0.35677046f, 0.21935111f, 0.48111308f, 0.46388081f, 0.21506090f, 0.14425810f, 0.06439997f, 
    -0.09924135f, 0.09582601f, 0.09711357f, 0.07452320f, 0.40695447f, -0.29186699f, -0.12457602f, 0.01229046f, 
    -0.16186604f, -0.08472823f, -0.01819275f, -0.08947408f, -0.01217562f, -0.00687172f, -0.02869992f, -0.06234060f, 
    -0.23138058f, 0.20594680f, -0.19885218f, 0.35013902f, -0.18177567f, -0.00031828f, -0.28710264f, 0.06378549f, 
    -0.10389584f, -0.09046077f, -0.14334257f, -0.14602719f, 0.20183763f, 0.10852180f, -0.19882722f, -0.19251443f, 
    -0.17735247f, -0.14915438f, -0.13929206f, -0.10048525f, -0.11702600f, 0.06438921f, -0.00220509f, -0.09415045f, 
    -0.37308812f, 0.12968250f, -0.57851666f, -0.15737572f, 0.04935376f, -0.11433654f, -0.42517677f, 0.03028455f, 
    -0.03875388f, 0.16797183f, 0.09112318f, -0.08851200f, 0.39985844f, 0.41627225f, -0.24301678f, 0.11767267f, 
    -0.07408884f, 0.17515253f, -0.01016518f, -0.12829432f, -0.06261077f, -0.08841253f, -0.12001133f, -0.12057217f, 
    -0.04425224f, -0.37938148f, 0.23083304f, -0.07788869f, 0.01099717f, 0.14909129f, 0.02860225f, 0.07891218f, 
    -0.03860138f, 0.28431353f, 0.03168088f, -0.01949986f, -0.14463247f, 0.17311661f, 0.09899423f, 0.07734811f, 
    0.18763387f, -0.00626334f, -0.23266897f, -0.07553277f, 0.04159465f, -0.06597599f, -0.24162710f, -0.03327025f, 
    -0.64144176f, 0.39290991f, 0.06597158f, -0.16884513f, -0.07917878f, 0.08269900f, -0.06832850f, -0.23767465f, 
    0.01124622f, -0.01791552f, -0.04874058f, -0.19358847f, 0.22528659f, 0.38306057f, 0.43722355f, 0.18732348f, 
    -0.01125476f, 0.24147412f, -0.08489016f, 0.01453099f, -0.19711468f, 0.03272609f, -0.16948083f, -0.09308684f, 
    0.13859604f, 0.16372134f, 0.25052842f, 0.36152348f, 0.14056452f, -0.06568398f, 0.12353519f, -0.06449925f, 
    -0.09032106f, -0.04273801f, 0.08784053f, -0.06343589f, -0.43342257f, 0.03234303f, -0.29347795f, -0.15581471f, 
    -0.26750213f, -0.29268751f, -0.00421152f, -0.06172575f, -0.15745790f, 0.05623466f, -0.11016711f, 0.03297866f, 
    0.53898376f, 0.63831097f, -0.14557053f, 0.04307454f, -0.20975256f, -0.05045482f, -0.27327961f, -0.02017243f, 
    -0.00485943f, 0.00945433f, 0.00259322f, 0.43887118f, -0.27540255f, -0.67323619f, -0.16846395f, 0.12713698f, 
    -0.01512479f, 0.16991477f, 0.05264335f, -0.16661802f, 0.15854934f, 0.04222505f, 0.03239736f, -0.00862473f, 
    0.08854791f, -0.30673891f, -0.57862395f, -0.13222684f, 0.18941735f, -0.49866313f, -0.14075494f, 0.01511143f, 
    0.12882771f, 0.20338562f, -0.19858222f, -0.16116360f, 0.07872717f, 0.51276922f, -0.19230703f, 0.16363603f, 
    -0.29263657f, 0.20402519f, -0.43255448f, 0.06629876f, 0.06867386f, -0.12922187f, -0.11852154f, -0.15282328f, 
    -0.15835205f, -0.40314406f, 0.31564566f, -0.00110475f, -0.16576725f, -0.15304083f, 0.17501076f, 0.03652450f, 
    -0.11706185f, -0.11580268f, -0.07337019f, -0.36593074f, -0.13806489f, -0.52571571f, 0.07010096f, -0.14004879f, 
    0.06695708f, -0.18559843f, -0.09637506f, -0.16600600f, 0.14359426f, -0.09995632f, 0.09522550f, -0.01229755f, 
    -0.13170776f, 0.55464256f, -0.50935668f, -0.49961323f, -0.05671797f, 0.05823139f, -0.24931596f, -0.39695001f, 
    0.16698769f, -0.12174200f, 0.06311649f, -0.00452860f, 0.00477397f, 0.19481871f, -0.02328102f, 0.04466207f, 
    0.10948066f, 0.23216979f, -0.14636748f, -0.21177673f, 0.21954755f, 0.04207306f, 0.31251666f, -0.20234397f, 
    -0.16754867f, -0.00578970f, -0.69216335f, -0.12425759f, -0.09566466f, 0.00429648f, -0.22595732f, -0.06281678f, 
    0.16551480f, -0.00800652f, 0.19875410f, 0.10197045f, -0.38895267f, 0.13112989f, -0.00550303f, -0.10439505f, 
    -0.16911595f, 0.04542909f, -0.27353120f, 0.27688691f, 0.10665553f, 0.00791034f, 0.03288264f, -0.29450339f, 
    0.15525438f, -0.07793856f, 0.35375422f, 0.18115991f, -0.24001715f, 0.07099582f, 0.05226668f, -0.21887569f, 
    0.14276049f, 0.01335921f, -0.06009601f, 0.01060364f, -0.44291434f, -0.09326399f, 0.11244757f, -0.42349860f, 
    -0.06897900f, 0.25462434f, 0.03312739f, -0.28433344f, -0.04550813f, 0.10857834f, 0.09914937f, -0.17050450f, 
    0.56086588f, 0.10915295f, -0.02660046f, 0.44643494f, 0.02423760f, -0.05708710f, -0.19889154f, -0.21552965f, 
    -0.21430250f, 0.01917982f, 0.20466734f, -0.12670073f, -0.23254807f, 0.24580447f, 0.12341520f, -0.12937874f, 
    -0.13409089f, -0.00607506f, -0.02686613f, -0.08190804f, 0.21166247f, -0.26645997f, 0.07582704f, 0.21381240f, 
    -0.29570356f, -0.35645768f, 0.42517549f, -0.26631725f, 0.24577840f, 0.00265048f, -0.18268302f, 0.00915821f, 
    -0.08312917f, -0.14336948f, 0.07641892f, 0.42928651f, -0.11557849f, 0.48553666f, 0.06392524f, 0.06130018f, 
    -0.24955043f, -0.08529691f, -0.04001934f, 0.04044116f, 0.23696831f, 0.09498968f, 0.32623282f, 0.23094323f, 
    0.35492274f, -0.23678161f, 0.30482447f, -0.27890128f, -0.05707170f, -0.23307282f, -0.05935043f, -0.08155390f, 
    -0.02214189f, -0.04684002f, 0.20936146f, -0.14462572f, 0.02176983f, -0.32238254f, -0.07584027f, -0.44184276f, 
    -0.06261955f, 0.15969291f, -0.08905165f, -0.06644964f, -0.20270474f, 0.16793488f, 0.01039489f, -0.02308296f, 
    -1.31808972f, 0.03007471f, 0.17573167f, -0.16252947f, -0.06997693f, -0.10344678f, 0.12232238f, -0.23140828f, 
    0.12069266f, 0.05196165f, 0.04199970f, 0.12544119f, -0.13813397f, -0.00662013f, 0.19763432f, 0.07498311f, 
    0.08428822f, 0.09104672f, 0.30609119f, 0.33783394f, -0.03387105f, 0.18417323f, -0.16413321f, 0.20942587f, 
    -0.30378744f, -0.04953260f, 0.02556460f, -0.27834180f, 0.18025577f, 0.02932472f, 0.01979974f, -0.21624044f, 
    0.17299652f, 0.12273240f, -0.01460300f, 0.30833915f, -0.23110557f, 0.27022240f, -0.15701379f, -0.83500528f, 
    0.10976776f, -0.35841760f, 0.14524950f, -0.06024310f, 0.06426468f, 0.06033828f, -0.06021769f, -0.17564769f, 
    0.44640538f, -0.18060929f, -0.09457955f, 0.05230625f, -0.03076489f, 0.12282548f, 0.04861969f, 0.22920915f, 
    -0.03848917f, -0.13522504f, -0.04045483f, -0.03805678f, 0.46368033f, 0.07003732f, 0.24449933f, -0.09955947f, 
    -0.01318893f, -0.18369453f, -0.03519467f, 0.27343747f, 0.22977588f, -0.12473958f, -0.07025051f, -0.17467631f, 
    -0.10996042f, 0.04053937f, 0.46433222f, 0.04315208f, -0.20852353f, 0.02528827f, -0.05200144f, -0.10183936f, 
    -0.13744776f, 0.02711017f, -0.28300500f, 0.03646833f, -0.57811403f, 0.83001947f, 0.05366736f, 0.25304967f, 
    -0.06246550f, 0.00268268f, -0.00654293f, 0.09651899f, 0.10827956f, -0.13479358f, -0.03099955f, 0.27430129f, 
    0.53943479f, -0.36640069f, -0.53265679f, 0.18835299f, 0.18635593f, -0.18844369f, -0.09521410f, -0.09610095f, 
    0.04074725f, 0.04343907f, -0.05817819f, 0.02263235f, 0.09687957f, -0.38622987f, -0.07534115f, 0.01228695f, 
    -0.27429837f, -0.05437679f, -0.25539297f, 0.25893608f, 0.16924542f, -0.12381699f, -0.34516749f, -0.18741950f, 
    -0.87681955f, 0.51773691f, -0.44294134f, -0.16648500f, 0.15266982f, 0.15447937f, 0.12426706f, -0.17862444f, 
    0.02011780f, -0.06839088f, -0.00187690f, -0.03771231f, -0.68115205f, -0.25807041f, 0.09424572f, 0.09290916f, 
    0.13104856f, 0.11472522f, -0.13940793f, 0.01883483f, -0.06926491f, 0.26253265f, -0.04639322f, -0.22755018f, 
    -0.14999913f, -0.28451842f, 0.14545637f, 0.76072836f, 0.01994860f, -0.23735486f, 0.00889278f, 0.06701753f, 
    0.00020619f, 0.18241350f, -0.05266306f, 0.13884705f, 0.42439142f, 0.37093517f, -0.40906137f, -0.03116894f, 
    0.08482330f, 0.11026368f, 0.09835127f, 0.02140633f, -0.03054914f, 0.15301642f, 0.03396799f, -0.07902918f, 
    -0.34530550f, -0.05222285f, -0.08439482f, -0.07488237f, 0.09612145f, 0.07522117f, -0.17543726f, 0.01456433f, 
    0.18422958f, 0.25299072f, -0.17993043f, 0.24818614f, -0.54146808f, -0.10125528f, 0.24247123f, -0.47600785f, 
    0.07625160f, 0.05635400f, 0.18888111f, 0.18774906f, -0.01841211f, 0.13600659f, -0.10857963f, 0.11822261f, 
    -0.71886897f, -0.55491430f, 0.35353541f, 0.10754374f, 0.02306792f, 0.02241699f, -0.09743347f, 0.03152469f, 
    0.14887488f, 0.01076443f, -0.32635745f, 0.14791360f, 0.24854429f, -0.03853975f, -0.27112859f, -0.23446980f, 
    -0.21756378f, -0.15392043f, 0.03160267f, -0.41338789f, -0.01505779f, -0.36328432f, -0.15253560f, -0.24180093f, 
    0.38547158f, 0.25660333f, -0.33947340f, 0.25185013f, -0.31520554f, -0.31940678f, -0.09576058f, -0.22571561f, 
    -0.00740118f, 0.09898423f, -0.08373406f, 0.01689329f, -0.09620824f, -0.18379344f, -0.14624700f, -0.32402077f, 
    0.02193594f, 0.00139818f, -0.06131682f, 0.31812769f, -0.11756154f, 0.18305880f, 0.30079681f, 0.07380138f, 
    -0.00918187f, 0.03194537f, 0.42543432f, -0.05637434f, 0.40979928f, 0.14428414f, -0.12550674f, -0.21379706f, 
    -0.18814360f, -0.08930535f, 0.11408086f, 0.08700041f, -1.22200072f, -1.10739696f, -0.07767015f, -0.25494555f, 
    0.07219268f, 0.19844817f, -0.08198106f, -0.17307685f, 0.08057294f, -0.14726400f, -0.29656029f, 0.10539033f, 
    -0.72658277f, -0.43571216f, 0.25792283f, 0.45858464f, 0.21133955f, 0.22396801f, -0.03406663f, -0.01449897f, 
    0.11875194f, 0.23411697f, 0.16001675f, -0.05984387f, 0.00683550f, -0.15585850f, -0.03937103f, 0.28092349f, 
    0.17623366f, 0.04940028f, 0.13546045f, 0.23775464f, -0.07342591f, -0.02681084f, -0.03337330f, -0.11054280f, 
    0.41980040f, -0.10548036f, -0.23337658f, 0.02395955f, -0.19501700f, 0.04503556f, -0.21835975f, 0.19217034f, 
    0.05971778f, 0.13784118f, -0.07694490f, -0.02734698f, 0.53889018f, 0.09117664f, 0.06994668f, -0.15911423f, 
    0.22338851f, -0.16034974f, -0.27483770f, 0.12496687f, 0.11174881f, 0.33827275f, 0.14538498f, 0.24093769f, 
    -0.41489363f, -0.76841134f, -0.67657071f, -0.27682647f, -0.16133234f, 0.05328416f, -0.08011065f, 0.02607811f, 
    0.14654799f, 0.04037768f, 0.10643365f, 0.07922772f, 0.50799447f, 0.06657886f, -0.16830298f, -0.07968826f, 
    -0.08979914f, 0.16578835f, -0.18086690f, -0.05910825f, 0.07754523f, -0.14826049f, 0.01259485f, -0.11532262f, 
    0.55536777f, -0.17986347f, 0.17121029f, -0.34259650f, 0.00973651f, 0.21808797f, 0.29170439f, 0.37537533f, 
    -0.03395791f, 0.15346801f, -0.04782939f, 0.06312673f, -0.24828453f, 0.12813300f, 0.20731646f, -0.01401813f, 
    0.00321281f, -0.06470824f, 0.21774203f, 0.11184851f, 0.01699520f, 0.07436638f, 0.12897305f, 0.15111026f, 
    0.44522116f, -0.22202289f, -0.00286389f, 0.54783589f, 0.22087969f, 0.11192869f, -0.00522109f, 0.16017397f, 
    0.07784826f, 0.02189620f, 0.22758515f, -0.14257886f, 0.60407299f, 0.62301373f, -0.49341062f, -0.01216642f, 
    0.08370303f, 0.01456501f, 0.01649268f, -0.28138074f, 0.37884834f, 0.10069951f, -0.12787086f, -0.08650916f, 
    -0.44839132f, 0.35477117f, -0.01656283f, -0.18254457f, 0.08760318f, 0.11660959f, -0.01929133f, 0.08862839f, 
    0.11667211f, -0.07499393f, 0.13250586f, 0.03359132f, -0.12066816f, -0.09973206f, -0.07867400f, 0.06543560f, 
    -0.17380956f, -0.16704166f, 0.19825001f, 0.01892708f, 0.00795722f, 0.08849257f, 0.09811457f, -0.11543268f, 
    -0.06891133f, -0.31032604f, -0.01292507f, 0.11109623f, -0.05674358f, 0.27241620f, -0.00531940f, 0.34975821f, 
    -0.03602257f, 0.14442731f, -0.02475907f, 0.04519577f, -0.39671719f, -0.04151798f, -0.41704819f, 0.00888941f, 
    0.13238604f, -0.25662178f, -0.02231621f, 0.01332384f, -0.03348363f, 0.03318365f, -0.02881857f, 0.14300770f, 
    -0.04695119f, -0.24061656f, -0.12686436f, -0.10741700f, -0.08405907f, -0.40522793f, -0.07871204f, -0.17103805f, 
    -0.09884301f, -0.05767813f, -0.19529732f, -0.15233503f, -0.25071764f, 0.22137024f, -0.08663964f, -0.27085432f, 
    0.16805424f, 0.17733929f, -0.31651276f, 0.18935558f, -0.20801233f, -0.14795573f, 0.11289624f, -0.00755861f, 
    0.69697821f, 0.44184068f, -0.39603710f, 0.21246682f, 0.01374167f, -0.11464779f, -0.03609535f, -0.05900860f, 
    0.05991708f, 0.03591996f, -0.13601592f, 0.01949817f, 0.31325099f, 0.03662127f, -0.12318558f, 0.53603882f, 
    0.08219688f, -0.23175007f, -0.07893463f, -0.05567186f, 0.07862486f, 0.00298718f, -0.08364316f, -0.12474195f, 
    -0.70715439f, 0.19643576f, 0.23378716f, -0.25614172f, 0.02579078f, -0.13232630f, 0.00295394f, -0.17543112f, 
    -0.01514825f, 0.00641663f, 0.24349529f, -0.01847565f, 0.29356220f, -0.10003918f, 0.22000077f, 0.21197668f, 
    0.06300658f, 0.02543645f, 0.12378257f, -0.14187275f, 0.03934957f, -0.22483033f, -0.25410175f, 0.20782372f, 
    -0.55571735f, -0.52655131f, -0.30023402f, -0.34370044f, 0.29036558f, 0.11086699f, 0.26200977f, -0.01543646f, 
    0.08746950f, -0.06438947f, -0.10233945f, -0.09445848f, 0.14412683f, -0.15683520f, -0.24064215f, 0.16170143f, 
    -0.26827455f, 0.16563049f, 0.06815817f, -0.28990251f, -0.09301167f, -0.15075439f, -0.01319207f, -0.07081948f, 
    0.04008643f, 0.17361964f, -0.00828812f, -0.44961843f, -0.09457903f, 0.09735866f, 0.07275569f, -0.41048500f, 
    0.17219560f, -0.06157906f, 0.20178601f, 0.06090179f, 0.09306015f, -0.59355527f, 0.09692416f, 0.04323188f, 
    0.05299032f, -0.07698540f, 0.11231913f, 0.05832998f, -0.00750238f, 0.11728847f, -0.12969621f, -0.06747922f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.24433079f, 0.01632535f, -0.09790774f, 0.01493833f, 0.01532499f, -0.02615615f, -0.01419562f, -0.21929979f, 
    0.02550905f, 0.05251055f, 0.12716049f, 0.13171959f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
