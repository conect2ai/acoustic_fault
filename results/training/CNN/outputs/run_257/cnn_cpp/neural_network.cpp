#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.42595676f, -0.96044654f, 0.26490822f, 1.30834389f, 0.37981257f, 0.85714287f, 0.38436827f, 0.70620471f, 
    0.57991642f, 1.30364668f, 0.56660879f, 1.01464033f, 0.44721812f, 0.53573179f, -0.23129056f, 0.52761465f, 
    0.78454578f, -0.10265436f, 1.07404196f, 0.62380117f, -1.16376340f, -0.39606038f, 0.74421829f, -0.63394481f, 
    0.16800545f, 0.20865902f, 0.49010536f, 0.62057447f, 0.77639961f, 0.83096308f, 0.65744585f, 0.31492272f, 
    0.80151927f, 0.32027143f, -0.58050096f, -0.37759766f, -0.02708680f, -0.91841006f, -1.32695580f, -0.75018221f, 
    0.79404747f, 1.07674193f, -0.28777900f, 0.31497851f, 0.24457878f, 0.06420497f, -0.99519110f, 1.11781585f, 
    0.51015669f, 0.16266255f, 1.34937596f, -0.11595020f, -0.84452826f, 0.23789807f, 0.33859405f, 0.83695179f, 
    0.10751209f, -0.18475193f, -1.21150959f, -1.54179788f, 0.37950048f, -0.22264102f, -0.30955335f, 0.97130316f, 
    -0.70565730f, 0.65802181f, 0.96333224f, 0.46355754f, 0.19070750f, -0.69794697f, -0.23563161f, -0.40348285f, 
    0.90795147f, -0.76396030f, -0.78811842f, 0.04873962f, 0.04733866f, -0.63245255f, -0.32385972f, -0.05717732f, 
    -0.69247061f, 1.27978849f, 1.15114844f, 0.77963090f, -0.69606036f, 0.08266567f, -0.12764336f, 0.47835225f, 
    -0.32766649f, 0.37718463f, -1.12282097f, -0.69551533f, 1.53695834f, 0.74897534f, -0.00013475f, -0.46725038f, 
    0.66827303f, -0.17857091f, -0.28178826f, -1.27807605f, -0.32161155f, -0.38076890f, 0.39502528f, 1.25192773f, 
    0.98079813f, 0.14374238f, -0.52656013f, -0.10967150f, -0.07215525f, -0.89734966f, 0.14602301f, -0.70977771f, 
    0.90103829f, -1.37252724f, -0.31156993f, -0.61855823f, -0.20334734f, -0.63307577f, -0.87048441f, -1.07149518f, 
    -0.06786720f, 0.79323632f, 0.56370211f, -0.42929870f, -0.55833548f, -0.56365389f, 1.00688004f, -1.44800782f, 
    0.93842173f, -0.66123283f, -0.55875313f, -0.19867145f, -0.00211892f, -0.43689024f, -0.30752322f, -1.22929835f, 
    -0.46665049f, -0.24364302f, 0.88097835f, 0.92082202f, -0.20066230f, -0.31194448f, 0.20303038f, -0.54544938f, 
    0.37113020f, 1.15251064f, 0.88048214f, -0.16499634f, 0.80038410f, 0.46207762f, -0.46536240f, 0.55511153f, 
    0.20327620f, -0.42895225f, 0.53773439f, 1.42512047f, 0.56252098f, -0.36853912f, 0.29471183f, -0.18528201f, 
    0.26344451f, 0.17502593f, -1.18062985f, 1.41105866f, -0.48865566f, -0.19201575f, 0.29840350f, -0.63687748f, 
    -0.52400452f, 0.54900104f, 0.70075834f, -1.34515727f, 1.47684431f, -0.81532317f, 0.08759967f, 0.28051546f, 
    0.05860322f, 0.28477871f, -0.08783586f, -0.66825080f, -0.36195341f, -1.23493552f, -0.29092374f, -0.29165259f, 
    -1.05564833f, -0.17866592f, -0.83847344f, 0.24704821f, 0.46312505f, 0.63562846f, -0.95747215f, 0.10398237f, 
    -1.31331241f, 0.46194121f, 0.22420231f, 0.19758765f, 0.81899142f, 0.79803097f, 0.74012023f, 1.39827454f, 
    0.13817158f, 0.71131188f, -1.16057527f, -0.56331277f, -0.52816296f, -0.13044725f, 0.25731781f, 0.70571125f, 
    0.73933500f, 0.66667098f, 1.03702211f, 0.29441926f, -0.18357825f, 0.61106706f, 0.93127829f, 0.38286406f, 
    0.49706924f, 1.19788599f, -1.66783416f, -0.05848823f, -0.00854233f, 0.19559413f, 0.38215962f, -0.14333205f, 
    0.22605495f, -0.67934245f, 0.63868856f, 0.87827855f, -1.17125154f, 1.06665087f, 0.30289471f, 0.07932419f, 
    0.67720133f, 0.00849395f, -0.36276603f, 0.44190288f, 0.76635569f, 0.77461326f, 0.91934168f, 0.28909239f, 
    -0.28996718f, -0.89946687f, 0.48102221f, -1.47478008f, -1.10316622f, -1.29226935f, 0.11415914f, -0.87125188f, 
    0.20246315f, 0.06973179f, 0.29668245f, -0.30866349f, 0.51769203f, 0.59184432f, 0.56668240f, 0.29034686f, 
    -1.31391084f, -0.58926058f, 0.35323638f, 0.63217080f, 0.60644490f, 0.42488241f, -0.71158421f, -1.24541891f, 
    -0.42511421f, -1.21826613f, -0.47724655f, -0.01203406f, 0.20976724f, 0.41852954f, 1.14927328f, 0.68095654f, 
    0.83870602f, 0.04787038f, -0.24579115f, -0.39221579f, -0.69269276f, -0.26379305f, 0.13173012f, 0.77948034f, 
    0.73830795f, 0.47732908f, -1.05286455f, -1.13241637f, 0.44231501f, 0.09614891f, 0.34212250f, 0.37680674f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.21514121f, 0.55869043f, -0.08481348f, 0.26309863f, -0.55018103f, 0.03967717f, 0.04515964f, 0.08189353f, 
    0.30089885f, -0.00168264f, -0.44034722f, 0.25097337f, 0.43376076f, -0.00846356f, 0.06600749f, -0.12525558f, 
    0.65220273f, 0.35373345f, -0.04100432f, -0.05089454f, 0.34628013f, 0.02832882f, -0.03503821f, -0.25993592f, 
    0.08143831f, -0.58575279f, 0.17017455f, -0.30074227f, -0.15782991f, -0.06209322f, 0.40434116f, 0.32600400f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.04064773f, 0.00099001f, -0.03112810f, -0.01746497f, 0.02956503f, 0.02691677f, 0.04566439f, -0.07076077f, 
    -0.01756069f, -0.00135796f, -0.07241015f, 0.03347332f, -0.04947994f, 0.01619703f, 0.04312570f, -0.06858972f, 
    -0.05900228f, -0.02785756f, -0.02632643f, -0.00578627f, -0.00918049f, 0.01502475f, 0.00948034f, -0.03138695f, 
    -0.02478682f, -0.07175690f, 0.02151403f, -0.04321533f, 0.01281557f, 0.02098061f, -0.05040751f, -0.05746344f, 
    0.03525653f, 0.04175483f, -0.03591815f, -0.01549291f, -0.05787720f, -0.01145309f, -0.01557277f, 0.04952670f, 
    0.00243241f, -0.03264948f, -0.02308329f, 0.04148626f, -0.06520309f, 0.01217454f, -0.05414442f, 0.03343745f, 
    0.01212858f, -0.00176664f, 0.00750028f, 0.00793528f, -0.01494686f, -0.01339581f, -0.04341606f, 0.03137533f, 
    0.00448167f, -0.05081939f, 0.03786257f, -0.06423666f, -0.02470211f, 0.03901234f, -0.08140290f, 0.02051323f, 
    -0.07255346f, -0.00772892f, -0.03270311f, -0.07327022f, -0.00101234f, -0.02696779f, -0.03801975f, 0.00033892f, 
    -0.07782035f, -0.02876020f, -0.02675464f, 0.02342758f, 0.00364526f, -0.01673636f, -0.05032830f, -0.01952672f, 
    0.01116805f, -0.02254839f, 0.02675880f, -0.05051017f, -0.02415408f, -0.06885786f, -0.03728667f, 0.03488072f, 
    0.03873714f, -0.03892155f, -0.00424634f, 0.01056173f, -0.03828063f, -0.03753037f, 0.02880072f, 0.05033919f, 
    -0.01889416f, 0.00769344f, -0.01766928f, -0.04121890f, -0.04771692f, 0.02524115f, 0.01702118f, -0.05988237f, 
    -0.02365933f, -0.04878220f, -0.05741939f, -0.02607504f, -0.03286350f, -0.02093146f, 0.02451249f, -0.02821652f, 
    -0.01705675f, 0.03019615f, -0.04746955f, -0.02099057f, 0.00585465f, -0.05935752f, 0.04107629f, -0.05339331f, 
    -0.01341069f, -0.02071922f, 0.01650598f, 0.00912985f, 0.00884774f, -0.07231166f, -0.01716876f, 0.04660309f, 
    0.05613444f, -0.00659418f, 0.00814790f, -0.00115211f, -0.03814583f, -0.01431243f, -0.06757154f, 0.00535216f, 
    -0.06702412f, -0.00251777f, 0.00754967f, 0.03822095f, -0.03777241f, 0.04732311f, -0.04632173f, -0.04028815f, 
    -0.05920848f, -0.05480472f, 0.03197471f, -0.05350087f, -0.05710969f, -0.04162870f, -0.02635968f, -0.02857576f, 
    0.00743967f, -0.02547678f, -0.07500487f, -0.03441698f, -0.00178834f, -0.05717243f, 0.02893393f, -0.02890436f, 
    0.01514757f, 0.04294148f, 0.03849335f, -0.00119986f, -0.02994794f, 0.01854979f, -0.03311826f, -0.01677074f, 
    -0.03351987f, -0.01684078f, 0.04603355f, -0.06117155f, -0.00969810f, 0.03049812f, -0.04264300f, -0.03787111f, 
    -0.04241125f, 0.03700990f, -0.00613420f, -0.00811472f, 0.02804979f, -0.06270731f, -0.00655153f, -0.00208795f, 
    -0.02044883f, -0.04102211f, -0.01599599f, -0.05386952f, 0.03228489f, -0.04990258f, -0.07252318f, 0.03374967f, 
    0.03459837f, 0.03522643f, -0.06679427f, -0.00043124f, -0.00464094f, -0.06094865f, -0.02762553f, -0.05985455f, 
    0.03693077f, -0.05565735f, -0.01355416f, -0.08587234f, -0.04671583f, -0.00040580f, 0.00352078f, -0.05800343f, 
    0.00557701f, -0.00301265f, -0.03178894f, 0.02565804f, -0.01504220f, -0.03944752f, 0.00085629f, 0.00290253f, 
    -0.01083893f, -0.00489468f, 0.01830647f, -0.00814036f, -0.03362248f, -0.03304815f, -0.04838021f, 0.02754254f, 
    -0.04493271f, -0.05344331f, -0.03762437f, 0.05639815f, 0.01498561f, 0.00642710f, 0.00979615f, 0.01485210f, 
    0.01656047f, 0.01163808f, -0.04580892f, -0.07279415f, -0.00177059f, 0.04034782f, 0.01875588f, 0.04199087f, 
    0.02272736f, -0.05948383f, -0.03390779f, 0.01082537f, 0.00129584f, 0.03716920f, 0.02201449f, -0.01482420f, 
    -0.01046290f, 0.02880076f, -0.06050238f, -0.00832360f, -0.01152214f, -0.03913230f, -0.01590286f, -0.06320386f, 
    -0.03361892f, -0.01991776f, -0.05642071f, -0.02827093f, -0.01172812f, -0.04760156f, 0.01978721f, -0.07118180f, 
    -0.01256145f, 0.02996179f, -0.03543003f, 0.00766085f, 0.01772733f, 0.01619566f, -0.01689393f, -0.01789656f, 
    0.04942435f, 0.04359720f, -0.02983870f, -0.06951607f, 0.00538618f, 0.00304142f, 0.01579365f, -0.03172611f, 
    -0.06149964f, -0.01417302f, -0.03646351f, -0.06190395f, 0.00167944f, 0.01702420f, -0.03005478f, 0.01043626f, 
    -0.00261830f, 0.00287744f, -0.00681539f, 0.03576926f, 0.02589440f, 0.03323312f, 0.00429517f, 0.01263142f, 
    0.03243687f, -0.00347468f, -0.02654128f, -0.01673538f, 0.00286658f, -0.01054920f, -0.02796697f, -0.05923495f, 
    -0.00821517f, -0.01753377f, 0.00605999f, -0.04509002f, -0.05843851f, 0.04517046f, -0.03061471f, -0.00872899f, 
    0.00767372f, 0.05652938f, -0.00385483f, 0.03263716f, -0.01701169f, -0.00151539f, 0.04676028f, -0.02336526f, 
    -0.03768332f, -0.03694793f, -0.04770001f, -0.03834453f, 0.02068107f, -0.02242302f, -0.06816314f, -0.05741425f, 
    -0.00002156f, -0.01570735f, -0.03902651f, 0.00045683f, -0.05024827f, 0.00191307f, -0.06058357f, -0.00697896f, 
    -0.03770202f, 0.02798349f, 0.04731603f, -0.04209876f, -0.03140609f, -0.00544780f, -0.05074950f, 0.02689176f, 
    -0.00552992f, 0.02493782f, 0.02237623f, -0.00380708f, 0.00725924f, 0.03352237f, -0.05406627f, -0.03134700f, 
    0.00486262f, -0.02192287f, 0.01784986f, 0.04729118f, -0.02268871f, -0.00649455f, -0.02470361f, 0.03002881f, 
    -0.01246646f, 0.01264040f, -0.00283822f, 0.03027806f, -0.02728016f, -0.01923326f, 0.04176286f, 0.03606410f, 
    -0.07382189f, -0.02361207f, 0.00817840f, 0.04965530f, 0.04749898f, 0.01618295f, 0.00454307f, -0.04875986f, 
    0.01918288f, -0.04656589f, -0.00002219f, 0.02606943f, 0.04953938f, 0.00208302f, -0.05389689f, -0.01207318f, 
    -0.05051088f, 0.05051260f, 0.00071011f, -0.02492429f, -0.05275547f, 0.02280944f, 0.04211821f, -0.05783077f, 
    0.03430608f, -0.05804371f, -0.04496875f, -0.00933225f, -0.00683827f, -0.04772166f, -0.02405259f, -0.05807148f, 
    -0.04247864f, 0.00668202f, 0.02622119f, -0.05008494f, -0.03814531f, -0.05459196f, 0.02877564f, -0.04294163f, 
    -0.02514375f, -0.00321300f, 0.03208989f, -0.03042492f, -0.01814087f, 0.03281650f, -0.06814325f, 0.03996156f, 
    0.04576566f, -0.00070687f, -0.02136125f, 0.03232567f, 0.00712512f, -0.05408581f, -0.06376316f, -0.05855278f, 
    -0.03978196f, 0.01602244f, -0.01535527f, -0.01040520f, -0.04795999f, -0.01720925f, -0.00808195f, 0.00721144f, 
    0.01340198f, 0.04738366f, -0.04612646f, -0.02177474f, 0.00430375f, 0.01848647f, 0.01054625f, -0.00780242f, 
    -0.05419151f, 0.05106732f, 0.02690488f, -0.05428639f, 0.02349637f, 0.01939361f, 0.03532140f, 0.02632941f, 
    -0.01933854f, 0.03455801f, 0.03972134f, -0.04799588f, 0.04055738f, 0.02754801f, 0.00736968f, -0.01187089f, 
    0.03400487f, 0.01832793f, 0.01730096f, 0.05181845f, 0.05242641f, 0.01403160f, -0.02178094f, -0.01077954f, 
    0.00267517f, 0.02087446f, 0.01908223f, 0.05055534f, -0.04758015f, 0.03350876f, 0.03766926f, -0.06581975f, 
    0.01267210f, 0.00638583f, 0.04019664f, -0.06441160f, -0.01179951f, -0.00471662f, -0.05074887f, -0.06367279f, 
    0.04494133f, -0.05863539f, -0.05660377f, -0.04125074f, 0.04643390f, 0.02183825f, 0.00669388f, -0.03970618f, 
    -0.00963918f, 0.04798815f, -0.03501663f, -0.02432669f, 0.04180118f, -0.04821407f, -0.04412305f, 0.02552430f, 
    -0.00756369f, -0.01523637f, -0.06559519f, 0.02633282f, -0.01383073f, 0.02738310f, 0.01243092f, 0.04577610f, 
    0.00605407f, 0.03690916f, 0.04730216f, -0.02239791f, 0.02333189f, -0.03185084f, 0.02268725f, -0.02730983f, 
    -0.06071505f, 0.01761363f, -0.00480880f, 0.04232742f, -0.04447054f, 0.05326076f, 0.04560986f, -0.05894568f, 
    -0.02245061f, -0.05246185f, 0.02753018f, -0.05919989f, -0.00806158f, -0.05572619f, -0.05212145f, -0.03847722f, 
    0.00952892f, -0.06090467f, 0.01400219f, 0.01199571f, -0.02598825f, -0.05955920f, 0.00451760f, -0.06083763f, 
    -0.02902547f, -0.04164163f, -0.00307353f, -0.00972921f, 0.02996125f, 0.05871086f, -0.00744860f, 0.02915992f, 
    0.03355872f, -0.03118112f, -0.00333945f, 0.04870845f, -0.06346612f, -0.03134410f, -0.04443021f, -0.01741552f, 
    -0.02865896f, 0.00553122f, -0.01105849f, -0.02940734f, 0.02142454f, -0.04168380f, 0.02356061f, 0.02458052f, 
    -0.04010562f, 0.00547696f, -0.00721914f, 0.02079123f, 0.02157682f, 0.00355171f, -0.01295456f, 0.00874386f, 
    0.01062061f, -0.01430753f, 0.04696988f, -0.03478501f, -0.02161508f, 0.03688149f, -0.01617099f, -0.02147795f, 
    -0.36384717f, -0.20617583f, 0.02801025f, 0.28747186f, 0.20329817f, 0.08210225f, -0.13580492f, 0.14135849f, 
    -0.17239213f, 0.30440992f, -0.31996572f, -0.12831952f, -0.11312108f, -0.09822289f, 0.04540920f, 0.03042439f, 
    -0.05766176f, -0.05601283f, 0.28474909f, -0.01902185f, -0.40672931f, 0.08172915f, -0.02942692f, -0.02002920f, 
    -0.11373451f, -0.30558553f, -0.14617914f, -0.20347774f, -0.01274761f, -0.02138076f, 0.14354403f, 0.07487606f, 
    0.13083133f, -0.15970291f, 0.29342422f, -0.02427871f, -0.08582095f, 0.14977859f, 0.04073807f, -0.03532813f, 
    -0.17457789f, -0.28514054f, 0.10651322f, 0.19988127f, -0.04323791f, -0.07195060f, -0.36012769f, -0.13684611f, 
    0.07841136f, 0.01400339f, 0.00612963f, 0.01388708f, 0.08396604f, -0.18125628f, 0.43060040f, -0.30933344f, 
    0.07016414f, -0.02261264f, 0.02142670f, 0.00144144f, -0.13401809f, 0.35966355f, 0.05753515f, -0.70767951f, 
    -0.49824670f, -0.28581601f, 0.00537213f, 0.09528161f, 0.02314290f, -0.36975905f, 0.19109035f, -0.16684830f, 
    0.17181103f, 0.00696807f, -0.29427832f, -0.05525582f, 0.08640405f, -0.34131947f, -0.27097318f, -0.08766578f, 
    -0.14549874f, 0.33134443f, -0.02296968f, 0.11243494f, 0.29860979f, 0.23051876f, 0.00731987f, 0.03797730f, 
    0.08165733f, -0.01315760f, -0.36427724f, -0.02903903f, -0.09323591f, -0.15683219f, -0.01321200f, -0.13975261f, 
    -0.11601283f, 0.05076730f, 0.30838102f, -0.14004147f, 0.35150471f, 0.13892227f, -0.03542919f, 0.15930858f, 
    -0.14955397f, -0.13599382f, 0.18515699f, 0.14309488f, -0.20682037f, 0.30242303f, -0.02070979f, -0.03045302f, 
    -0.13436034f, 0.10611612f, -0.31256232f, 0.02522090f, -0.17999496f, 0.20126703f, 0.28944275f, 0.14636135f, 
    -0.09891053f, 0.09338536f, -0.17114630f, -0.28674644f, 0.09989808f, -0.03832887f, -0.19822305f, 0.19005238f, 
    0.00508612f, 0.32428187f, 0.10912720f, 0.17026339f, -0.10254610f, 0.15577342f, -0.01177087f, -0.10070056f, 
    0.29378423f, 0.11091281f, 0.03215223f, 0.12474026f, -0.03416616f, -0.23136306f, -0.14042540f, 0.23358054f, 
    0.33745593f, -0.15949245f, 0.12377582f, -0.16170336f, 0.22359248f, -0.08355432f, -0.10098041f, -0.01323405f, 
    0.00248723f, 0.11508010f, -0.31544301f, -0.00265868f, -0.13451740f, 0.10978918f, -0.00226493f, 0.05950514f, 
    0.03416955f, -0.09888789f, 0.21479471f, 0.04920950f, -0.03212244f, -0.09075483f, 0.04019468f, -0.25815219f, 
    -0.01690550f, -0.52614945f, -0.09231502f, -0.07638726f, -0.19335273f, -0.09197564f, -0.07219239f, 0.16353446f, 
    0.07554942f, -0.11765359f, 0.01004757f, -0.18054247f, 0.37252402f, 0.11170805f, -0.23027040f, 0.10335783f, 
    0.00878537f, 0.02021374f, -0.00457586f, 0.06203573f, -0.06826031f, -0.33299014f, 0.19213057f, -0.23495984f, 
    -0.04916187f, -0.24197634f, 0.05522073f, 0.15031931f, 0.18658967f, 0.04621229f, 0.68037891f, -0.26327392f, 
    0.11042580f, 0.22184382f, 0.04134215f, -0.09066125f, 0.18159452f, -0.17157453f, 0.23915035f, 0.37056038f, 
    -0.18566060f, 0.00330171f, -0.00633731f, -0.06105996f, 0.15978228f, 0.12647223f, 0.13251160f, 0.13126600f, 
    0.43133250f, 0.26288143f, -0.30401823f, -0.06870762f, 0.03461090f, -0.22550011f, -0.11061096f, 0.01598921f, 
    0.05749242f, 0.53667235f, -0.01446788f, 0.00630439f, -0.28415835f, 0.00378637f, -0.02040944f, -0.17762673f, 
    0.09934850f, 0.33146167f, -0.91920328f, -0.09541497f, 0.10236982f, -0.01880491f, 0.09354229f, -0.00213603f, 
    -0.02996651f, 0.03244404f, -0.26979756f, 0.06512803f, 0.35616174f, -0.22492181f, -0.10866474f, 0.06860127f, 
    0.00100667f, 0.13458364f, 0.12717956f, 0.15755828f, 0.35765967f, -0.36561283f, 0.27085137f, 0.45024955f, 
    -0.00390650f, 0.25218269f, 0.20635796f, 0.02439263f, -0.12602076f, 0.40753698f, 0.38472146f, -0.21700233f, 
    0.16517432f, -0.15288323f, -0.07052073f, 0.17479157f, 0.03079994f, -0.25284988f, -0.13175482f, -0.15483882f, 
    0.01558879f, -0.17662346f, 0.10465470f, 0.20078464f, 0.08254883f, 0.09872559f, 0.18635932f, 0.09147015f, 
    -0.24702670f, 0.01755759f, 0.06384367f, -0.08006387f, 0.22101094f, 0.23580952f, -0.02115420f, -0.10805558f, 
    -0.10963181f, -0.01132559f, 0.33541703f, -0.23144250f, 0.08476084f, -0.09254710f, 0.10635885f, -0.14625420f, 
    -0.03501241f, -0.03216612f, -0.08278072f, 0.27317071f, -0.05059713f, 0.11567737f, -0.14544636f, 0.11364654f, 
    -0.07727068f, 0.16258295f, 0.19213106f, -0.58328992f, 0.13798462f, -0.20611767f, 0.00055317f, -0.15628217f, 
    0.10534438f, 0.21532691f, 0.12188833f, 0.09184773f, -0.04799959f, 0.04170922f, -0.15603869f, 0.05107724f, 
    -0.01275019f, 0.02921507f, 0.29853907f, 0.00138806f, 0.30066592f, -0.61788666f, 0.26701063f, -0.02063337f, 
    -0.22568606f, -0.20159315f, 0.01330832f, 0.20865348f, 0.06798871f, -0.71513182f, 0.15129633f, 0.27154294f, 
    0.02428851f, 0.11217748f, -0.09759989f, 0.15978478f, -0.12855765f, -0.07680157f, -0.17821817f, -0.05692384f, 
    -0.28547886f, 0.12471869f, 0.14894940f, 0.13953735f, -0.06617208f, 0.07598829f, 0.09001157f, 0.06980830f, 
    0.14181367f, 0.19030753f, -0.12407246f, 0.39590350f, 0.03348830f, 0.09103774f, 0.10899191f, -0.06042687f, 
    -0.37353280f, -0.46310234f, 0.08353280f, 0.30847788f, 0.08480458f, 0.07598473f, -0.10548250f, 0.02805901f, 
    -0.11522067f, 0.28342283f, 0.11688845f, 0.04561138f, 0.04341123f, -0.11192357f, 0.16171399f, 0.05522789f, 
    -0.12842712f, 0.09907345f, -0.56465185f, 0.04998031f, -0.05586067f, 0.07033782f, -0.00484944f, -0.25844586f, 
    -0.10226855f, -0.02985068f, -0.03277227f, 0.38231903f, 0.06603732f, -0.15519410f, 0.40712804f, 0.02702417f, 
    -0.07602955f, 0.03890041f, 0.01883250f, -0.04668249f, -0.23239923f, -0.23499730f, -0.34056553f, 0.18223642f, 
    0.24204326f, 0.13309093f, -0.13985254f, -0.19494544f, -0.26138559f, 0.42432979f, -0.18825728f, 0.06913399f, 
    0.17707376f, -0.17772818f, -0.29811269f, -0.02241750f, -0.04175086f, -0.18664245f, -0.69968390f, 0.03999833f, 
    -0.14802445f, 0.27749959f, 0.01626656f, 0.23090859f, -0.00470725f, 0.16043727f, -0.11553012f, 0.28476366f, 
    -0.40954921f, -0.15470162f, 0.03949048f, 0.05304763f, -0.01676320f, 0.12236027f, 0.00353379f, -0.20652816f, 
    0.06781833f, 0.13658202f, -0.09543350f, 0.07369835f, 0.00492213f, -0.05213461f, 0.02313801f, 0.07917068f, 
    0.18245135f, 0.01290931f, -0.03111582f, -0.12253615f, 0.06375070f, 0.06227003f, 0.06369828f, -0.02875758f, 
    0.07807665f, 0.10502131f, -0.47017893f, 0.04083619f, -0.09931773f, 0.10520746f, 0.12671192f, 0.27722237f, 
    0.02861091f, -0.06975687f, 0.14047246f, -0.12075802f, -0.00784229f, -0.56181401f, 0.27518064f, -0.07083365f, 
    -0.00900816f, 0.07157452f, 0.11501259f, -0.04965169f, 0.08474177f, -0.03354084f, 0.04075362f, 0.12026008f, 
    0.03176917f, 0.24269618f, -0.09300685f, 0.16887179f, -0.04714923f, -0.51064092f, -0.27969876f, -0.15462442f, 
    0.14258058f, 0.16764662f, 0.13032423f, 0.26533598f, -0.10530595f, 0.01176928f, -0.03851306f, -0.04838651f, 
    0.07009075f, 0.02285286f, -0.05847612f, 0.23742804f, 0.07114644f, -0.07281568f, 0.21014071f, -0.34809452f, 
    -0.29435387f, 0.25863656f, -0.11416470f, 0.06693526f, -0.33687165f, 0.09832026f, -0.14456637f, 0.15782261f, 
    -0.11544215f, -0.13316661f, -0.09237552f, -0.11118528f, -0.08672303f, -0.11620881f, -0.17157593f, 0.14605241f, 
    0.10992344f, -0.04990924f, -0.14228779f, -0.58622783f, -0.22998558f, -0.05422996f, -0.14196856f, 0.23107891f, 
    0.06335101f, -0.00579361f, -0.14652441f, 0.23447071f, 0.18211643f, -0.21269734f, 0.22154249f, -0.08662613f, 
    -0.07703774f, 0.05162820f, -0.09376335f, 0.65774935f, 0.57932305f, -0.05157305f, 0.11162408f, 0.25581628f, 
    0.02594242f, -0.03727074f, -0.25684536f, 0.21896739f, -0.15684500f, -0.04629258f, -0.09329593f, -0.03033771f, 
    0.18128678f, 0.07211413f, 0.08332514f, -0.20894650f, 0.26569170f, -0.19148879f, -0.08576854f, 0.05739789f, 
    0.11316615f, 0.26288337f, 0.11489169f, 0.09289148f, -0.01684254f, 0.01391634f, 0.25198823f, 0.12686740f, 
    0.00123976f, 0.09052636f, -0.02188091f, 0.10062227f, 0.09164358f, -0.00512904f, 0.00825871f, 0.08782017f, 
    0.41524068f, -0.16355766f, 0.17977405f, -0.34100923f, 0.17459019f, 0.06338318f, -0.15282565f, 0.37241933f, 
    -0.00836824f, -0.04044633f, 0.02005252f, 0.03714737f, 0.02700715f, 0.00504377f, -0.02024858f, 0.03447339f, 
    0.02597691f, -0.00126423f, 0.00310658f, -0.06326298f, -0.03111533f, -0.05225430f, 0.00617457f, 0.00355943f, 
    0.01127767f, 0.05269400f, -0.06995644f, -0.03449892f, 0.01154042f, -0.04193222f, 0.00195813f, -0.00288058f, 
    0.02561440f, 0.04880311f, 0.01062332f, 0.04651572f, 0.02107873f, 0.01168918f, 0.04926481f, -0.01979626f, 
    -0.01386206f, 0.01218154f, -0.03024832f, 0.01135651f, 0.00310478f, -0.02896833f, -0.00511343f, -0.05825833f, 
    0.00785225f, 0.01664666f, -0.04279965f, 0.04527697f, -0.05085615f, -0.01113902f, 0.01601181f, -0.00695343f, 
    0.01481813f, 0.04578332f, 0.00508246f, 0.01202693f, -0.00670912f, 0.00658870f, -0.01667129f, 0.01624172f, 
    -0.00102753f, 0.00674322f, -0.04700350f, -0.04967829f, -0.06003885f, 0.05323695f, -0.04141541f, -0.06005475f, 
    -0.06199200f, 0.04453677f, 0.02820484f, 0.01037942f, 0.04329632f, 0.03352506f, 0.04771630f, 0.04054947f, 
    -0.03723934f, -0.02571571f, -0.02737049f, -0.03587425f, 0.01973606f, -0.03124639f, -0.01109855f, -0.02201349f, 
    -0.04289032f, 0.04242458f, 0.00161332f, 0.04994875f, -0.02688225f, -0.03613988f, -0.00181469f, -0.00120562f, 
    -0.01595109f, -0.01365030f, 0.04931138f, 0.03403008f, -0.00595623f, 0.04422425f, -0.02800391f, 0.01848385f, 
    -0.02310317f, -0.01966209f, -0.03409722f, -0.00611057f, 0.00910824f, 0.05513090f, 0.05486140f, 0.01919392f, 
    0.02965876f, 0.04318983f, -0.05002950f, 0.01596202f, -0.00880788f, -0.05700690f, 0.03666168f, 0.02084399f, 
    -0.05108276f, 0.03109461f, -0.02594711f, 0.00786069f, 0.03740536f, -0.03001840f, 0.01696262f, 0.00721270f, 
    -0.01346955f, -0.02505170f, -0.05442740f, -0.03188298f, 0.03014410f, -0.05063999f, 0.02141855f, -0.00092807f, 
    0.04708138f, -0.03840764f, -0.02017093f, 0.04609889f, -0.06312820f, 0.00445347f, -0.00901004f, -0.05364620f, 
    -0.04111619f, -0.04607463f, -0.04189930f, -0.02135983f, -0.06154933f, 0.03993317f, -0.02538091f, -0.03462414f, 
    0.01984265f, -0.03973119f, -0.01365494f, 0.01414998f, 0.04438752f, 0.04985263f, -0.05001709f, 0.03928120f, 
    0.02352669f, -0.03639655f, 0.03239732f, -0.06344616f, -0.05619738f, -0.03320422f, -0.06496929f, -0.01663906f, 
    -0.03091368f, -0.04886771f, -0.00966950f, 0.04516614f, -0.05989361f, -0.04188623f, -0.04977481f, -0.04900433f, 
    -0.02460611f, -0.00918157f, -0.04408524f, 0.02570372f, 0.04168373f, -0.04667345f, -0.02162245f, -0.03203137f, 
    -0.02399929f, 0.00519229f, -0.02623820f, -0.00574671f, -0.01142144f, -0.04621504f, 0.01248777f, -0.02547517f, 
    0.02797631f, -0.04921019f, -0.01459589f, -0.03196943f, 0.05121114f, 0.02438360f, -0.04040688f, -0.00346477f, 
    0.04730950f, 0.00314254f, -0.00171045f, 0.00727683f, -0.04351414f, -0.03947180f, 0.02537203f, -0.00223721f, 
    0.01728006f, 0.00470916f, -0.05968862f, -0.01256292f, -0.00389363f, -0.03652944f, 0.02620044f, -0.04586767f, 
    -0.03348558f, -0.03670868f, -0.03802367f, 0.02054564f, 0.00246772f, -0.04922101f, 0.01524479f, -0.04940074f, 
    0.00020948f, -0.03665316f, 0.04638326f, -0.06150114f, -0.06312287f, -0.05576513f, -0.00935918f, 0.01369284f, 
    -0.03263071f, -0.05502841f, 0.01849589f, -0.02192843f, 0.01636847f, -0.04905967f, 0.03791329f, 0.03362791f, 
    0.02306239f, 0.01342077f, 0.01257431f, 0.03975271f, -0.02512310f, -0.02975893f, -0.00788605f, 0.03717832f, 
    -0.02580483f, 0.02683939f, 0.02420329f, -0.01788107f, -0.05607739f, 0.04341806f, 0.02350907f, 0.05095284f, 
    0.05032614f, -0.06048856f, 0.03561164f, -0.04850686f, 0.02094425f, 0.03056907f, -0.02824103f, 0.05499611f, 
    0.02777090f, -0.00645747f, -0.05353985f, -0.05025034f, -0.01164250f, -0.02019766f, -0.05494175f, -0.04124044f, 
    -0.05229130f, 0.04563390f, 0.01582380f, -0.02599526f, -0.05594621f, 0.05393001f, 0.03697280f, 0.01629890f, 
    -0.05147021f, -0.02554150f, -0.05780736f, -0.05597309f, 0.00017041f, -0.00676576f, 0.01557376f, 0.01292022f, 
    0.02619338f, -0.00622838f, -0.04248653f, -0.03114245f, 0.04113407f, -0.02971976f, 0.01312729f, -0.01804317f, 
    -0.01185915f, -0.24466293f, 0.18156900f, -0.11660614f, 0.07327914f, 0.12647869f, 0.12918435f, -0.06912374f, 
    -0.04010760f, -0.07243549f, 0.08707251f, 0.21461387f, 0.10524701f, 0.05287180f, -0.19908771f, 0.06523978f, 
    0.21044105f, 0.17447962f, -0.23379564f, -0.00613860f, 0.17237197f, 0.01141037f, 0.09247045f, 0.04674102f, 
    0.13789688f, -0.41062796f, -0.22873951f, 0.00767534f, 0.05696932f, 0.02891260f, -0.07092470f, -0.06808370f, 
    -0.02973220f, 0.01950310f, -0.07044964f, 0.25512293f, -0.31662175f, -0.05686656f, 0.01680181f, 0.10527962f, 
    0.06740896f, -0.05309458f, -0.10524252f, -0.03090199f, -0.19778217f, 0.39577043f, -0.17010048f, -0.08448107f, 
    -0.04178087f, 0.21763089f, 0.07404945f, 0.14929368f, -0.00822945f, 0.27820414f, 0.31241626f, 0.23079409f, 
    -0.31297329f, 0.11658074f, 0.16508065f, 0.14664319f, -0.08051384f, -0.24154399f, 0.09911769f, 0.16750968f, 
    -0.25073758f, 0.06045832f, -0.09342509f, -0.00503914f, -0.01007911f, -0.06889343f, 0.07948771f, 0.24730840f, 
    -0.13894027f, -0.07317556f, 0.29007632f, 0.16672593f, 0.02141199f, 0.31851974f, -0.10450272f, -0.04853996f, 
    -0.01815423f, -0.02757325f, 0.27880797f, 0.15709969f, 0.24514726f, -0.08064990f, -0.10587978f, -0.07897341f, 
    0.07392141f, -0.08661336f, 0.38502446f, -0.43871859f, -0.32381666f, -0.35424876f, -0.10977090f, 0.16054885f, 
    0.10722765f, -0.14404958f, -0.23107424f, -0.24307504f, -0.05719524f, 0.00332431f, -0.04819667f, -0.17907287f, 
    -0.05119368f, 0.07084560f, 0.15554389f, 0.03362661f, 0.07472236f, 0.00191878f, -0.37946022f, -0.09462813f, 
    0.25458577f, 0.07768951f, 0.23236901f, 0.01883023f, 0.14889929f, -0.24769025f, -0.19510968f, 0.17739438f, 
    -0.03832478f, -0.20661129f, -0.27541187f, -0.12004148f, 0.12836096f, 0.21447492f, 0.14309986f, 0.05446230f, 
    -0.07381576f, 0.17262697f, -0.02343106f, 0.11286870f, -0.18436006f, 0.13985017f, -0.26605770f, -0.16808605f, 
    -0.29382247f, -0.16453029f, 0.11030947f, -0.13840126f, -0.12452141f, 0.12291652f, 0.02698054f, -0.00924990f, 
    -0.22051191f, 0.11849634f, 0.02257243f, -0.03486647f, -0.02382364f, -0.01164525f, 0.21382326f, 0.15843557f, 
    0.25327969f, -0.31260368f, 0.02796790f, -0.20023470f, -0.04877406f, -0.26938045f, 0.15285897f, 0.07518269f, 
    0.11025892f, 0.17388512f, -0.41080850f, -0.17019114f, 0.36470959f, 0.00032377f, 0.15117215f, -0.25082996f, 
    -0.07715552f, -0.15758668f, 0.02025984f, -0.64786714f, -0.07130083f, 0.41502666f, 0.14898811f, 0.16170533f, 
    -0.23301175f, -0.11821479f, -0.01550282f, 0.17380130f, -0.06073765f, -0.37963480f, 0.10133572f, -0.02941100f, 
    0.19891617f, -0.08684205f, 0.25062221f, 0.11263675f, -0.11459681f, 0.25221747f, 0.29740676f, 0.16897047f, 
    -0.17960204f, 0.18226233f, 0.06005100f, 0.03383898f, 0.06046137f, 0.22013150f, -0.18114956f, 0.04186939f, 
    0.07900880f, 0.08832970f, 0.25050697f, -0.12987718f, -0.04394848f, -0.20427164f, -0.05368057f, 0.09090500f, 
    -0.15250082f, -0.13005550f, -0.02731991f, -0.09877156f, -0.03044144f, -0.11282486f, 0.22935602f, 0.22728103f, 
    -0.42989671f, 0.13430585f, 0.17498538f, -0.00186465f, -0.12949033f, -0.12158771f, 0.14097521f, -0.03439452f, 
    0.09242743f, -0.24284910f, 0.12444673f, 0.13574888f, 0.08075860f, 0.00469044f, -0.08646894f, -0.20036301f, 
    0.11648044f, -0.00437607f, 0.18290275f, -0.48667648f, -0.14367135f, -0.15274167f, 0.04025768f, -0.14440276f, 
    0.11217736f, 0.10635667f, 0.15177239f, -0.31497365f, -0.11602208f, 0.04500397f, -0.22033477f, -0.08996094f, 
    -0.16090895f, 0.22500472f, 0.07611910f, 0.12456773f, 0.27099821f, 0.06730281f, -0.11373249f, -0.05544890f, 
    -0.12452219f, 0.15943041f, -0.06280948f, 0.25012460f, 0.07124060f, -0.05935518f, -0.03686815f, 0.18013388f, 
    -0.02693024f, 0.15680587f, 0.13236865f, 0.08209920f, -0.03642188f, -0.32387891f, -0.11138473f, 0.11355214f, 
    0.26186243f, 0.06159567f, 0.16693659f, -0.04208602f, 0.00898580f, -0.05404646f, -0.00794892f, 0.02855403f, 
    -0.02252124f, 0.15969361f, 0.04130532f, -0.15923221f, 0.19560929f, 0.16193949f, 0.19290212f, 0.05477734f, 
    0.19090711f, -0.14125367f, 0.07333977f, 0.10238813f, -0.08750667f, -0.05058356f, -0.23125732f, -0.05332458f, 
    -0.25710070f, -0.22195376f, 0.04960487f, 0.25936365f, -0.14822538f, 0.03780011f, 0.10199567f, -0.11312455f, 
    -0.02750542f, -0.10146394f, -0.12397873f, -0.03646000f, 0.26883838f, -0.05991505f, -0.13110524f, 0.11792379f, 
    0.28179654f, -0.01842462f, 0.16331762f, -0.08273440f, 0.14110675f, -0.08604220f, -0.00898231f, -0.05076306f, 
    0.23645523f, 0.07067746f, 0.04207356f, -0.19357157f, -0.06941598f, 0.02963622f, 0.30282903f, -0.09433010f, 
    0.11566855f, 0.13309488f, 0.16906744f, -0.29294473f, -0.00195967f, -0.25652513f, 0.05525403f, -0.37599671f, 
    -0.06593280f, 0.00511914f, 0.08968681f, -0.01287865f, -0.11479917f, -0.34272513f, 0.01550216f, -0.07022520f, 
    0.14571089f, 0.20979124f, 0.13340212f, -0.32972679f, 0.01416234f, -0.08957987f, -0.03712641f, -0.22666688f, 
    -0.03768306f, -0.32143280f, 0.05026756f, -0.15584269f, 0.05007581f, 0.11819502f, 0.10000436f, -0.05146539f, 
    0.22767454f, -0.14848815f, 0.42754772f, 0.05471820f, -0.27692059f, -0.22966366f, 0.10755198f, 0.11966360f, 
    0.03674386f, -0.08796261f, 0.04671870f, 0.10714229f, 0.11753321f, 0.04035683f, 0.04023325f, -0.00804753f, 
    0.02719038f, -0.10106108f, 0.27513039f, -0.42380655f, -0.60407579f, -0.08862025f, 0.19120876f, -0.02574108f, 
    0.07627976f, -0.26234177f, -0.31097671f, 0.10204065f, 0.10126999f, -0.01615259f, -0.03527775f, 0.11181682f, 
    0.12150960f, -0.01256485f, 0.00144796f, -0.05714400f, 0.02788605f, 0.13550846f, 0.05029153f, -0.11875305f, 
    -0.05175093f, -0.11998869f, 0.05546632f, 0.01607244f, 0.13429216f, -0.12393164f, 0.16916709f, 0.36524108f, 
    -0.19755188f, 0.16122718f, 0.03794369f, -0.01420624f, 0.42347056f, 0.47155669f, 0.53731877f, 0.06618107f, 
    0.00603220f, -0.16141115f, -0.00421828f, 0.14086707f, -0.05355360f, 0.11406854f, 0.04255182f, 0.23874392f, 
    -0.27292314f, 0.25453466f, -0.06636160f, -0.11619071f, 0.14471084f, 0.13882692f, 0.04223492f, 0.18821442f, 
    -0.17504504f, 0.18199727f, 0.17010446f, 0.16430846f, 0.18332446f, 0.17293337f, 0.16869557f, -0.14780764f, 
    0.06480732f, 0.14724308f, 0.06212340f, 0.08054902f, 0.08342118f, 0.15289953f, 0.07608406f, 0.22077751f, 
    -0.13694912f, -0.04813331f, 0.15899092f, 0.52914900f, 0.17547579f, -0.03721837f, -0.12363224f, -0.16927451f, 
    -0.07328238f, 0.08878937f, 0.23922466f, 0.64578396f, 0.36593825f, -0.31114766f, -0.36910820f, 0.15567628f, 
    0.19492103f, -0.13399455f, 0.07167415f, 0.24304226f, 0.16078702f, -0.15782934f, 0.22171356f, 0.09732279f, 
    -0.15678103f, -0.14558142f, 0.28241876f, -0.03223076f, 0.27128720f, 0.30050799f, -0.08718968f, -0.11145330f, 
    -0.07236034f, -0.05647356f, 0.05296060f, -0.20776545f, -0.03197810f, -0.07919878f, -0.10795820f, 0.38258943f, 
    -0.08150102f, -0.13135667f, 0.11633977f, 0.12243324f, -0.09592854f, 0.10971438f, 0.02881626f, -0.29271308f, 
    -0.03184324f, 0.24904042f, 0.00902972f, 0.10701785f, 0.03236382f, -0.22116889f, 0.07430465f, -0.08663074f, 
    -0.03945515f, 0.02045420f, 0.20095293f, 0.14494732f, 0.27943888f, -0.00894061f, 0.23389556f, 0.15085417f, 
    -0.14500503f, -0.00810734f, 0.35657313f, 0.03629677f, -0.05684754f, -0.15105565f, 0.19935304f, -0.25829154f, 
    -0.16028762f, 0.05759490f, -0.13662845f, -0.05572853f, -0.06885011f, 0.32939565f, -0.03403363f, 0.19311367f, 
    0.05147376f, 0.22923000f, 0.04313174f, 0.03556467f, -0.50383478f, 0.30012128f, 0.09857453f, 0.08578540f, 
    -0.08997625f, 0.13315409f, -0.32732636f, 0.01919190f, -0.38174826f, 0.20467506f, 0.19063504f, -0.01179946f, 
    0.00354943f, -0.30512607f, -0.16926676f, 0.09943667f, -0.39615148f, 0.17064331f, -0.45597175f, 0.21761222f, 
    -0.00921086f, -0.00029471f, 0.21181972f, 0.13055027f, 0.10940576f, 0.12047491f, 0.09160828f, 0.04840998f, 
    -0.19131827f, 0.03156095f, 0.20280112f, 0.05372328f, 0.16515476f, 0.03859863f, -0.07687125f, -0.63887781f, 
    0.02744351f, 0.04894940f, 0.03249487f, -0.02401162f, -0.24059851f, 0.00232037f, -0.00980135f, -0.27049124f, 
    0.02889927f, 0.00791106f, 0.03846766f, 0.02136154f, 0.02769974f, -0.06197732f, 0.02167063f, 0.00713700f, 
    0.02265699f, 0.03564847f, 0.02439518f, -0.03894056f, 0.01613463f, -0.02221713f, 0.04199360f, 0.03551108f, 
    0.01310674f, -0.02004010f, 0.01297199f, 0.03663243f, -0.01880391f, 0.00874742f, 0.00103211f, 0.01806766f, 
    -0.03075949f, 0.04830510f, 0.02383086f, 0.02045418f, 0.02440573f, -0.04462321f, -0.04914191f, -0.06279366f, 
    -0.00368505f, -0.06630211f, 0.04127214f, 0.03077060f, -0.06377427f, 0.01623965f, -0.03966468f, 0.00458288f, 
    -0.00809858f, -0.01849634f, -0.02345370f, 0.00789448f, -0.00177768f, -0.04021559f, -0.02907052f, 0.01321039f, 
    0.04160413f, -0.01202057f, 0.02459970f, -0.03421422f, -0.02127836f, 0.01767279f, 0.02704611f, 0.03026982f, 
    -0.05286837f, -0.01195248f, 0.02373836f, -0.02762513f, -0.02553296f, 0.01565848f, -0.00701054f, -0.05079679f, 
    0.00446155f, -0.02948635f, 0.01392290f, -0.05336887f, -0.02601303f, -0.04802250f, -0.06494207f, -0.03489679f, 
    -0.00742951f, -0.02854199f, -0.01961210f, -0.03491353f, 0.01989152f, 0.01845254f, -0.00618798f, -0.02422560f, 
    0.02233900f, 0.03086130f, -0.01428491f, 0.03403336f, 0.01470418f, -0.06601198f, -0.03694733f, -0.03014729f, 
    0.04391198f, 0.04093456f, -0.00180980f, 0.03862407f, 0.03249481f, -0.02617111f, -0.02752919f, -0.00343246f, 
    -0.02551065f, 0.00973484f, -0.04685793f, -0.02424219f, -0.06000515f, -0.00137897f, 0.03498900f, 0.03142453f, 
    -0.03273924f, 0.03532568f, -0.05037500f, 0.03397465f, -0.01987117f, -0.04004927f, -0.03171696f, -0.06520544f, 
    -0.04061299f, -0.06184098f, -0.03348214f, -0.03509222f, 0.04552505f, -0.04192137f, -0.05388628f, -0.05678843f, 
    -0.04221252f, 0.00050525f, 0.02191044f, -0.05548226f, 0.00768024f, 0.00724515f, -0.04367721f, -0.03615628f, 
    0.02565436f, 0.03634795f, 0.00067215f, -0.02222994f, -0.00046164f, -0.06281368f, 0.03456779f, -0.02105907f, 
    -0.02891917f, -0.05389229f, -0.01728830f, -0.00830206f, -0.02770471f, -0.05890641f, -0.05773489f, -0.03490947f, 
    0.02108173f, -0.01355812f, 0.02674350f, -0.05770031f, 0.04032369f, 0.01679040f, 0.03659628f, 0.01429384f, 
    -0.00706335f, -0.02386222f, -0.04421445f, -0.00997332f, 0.03045568f, 0.00530497f, -0.02511667f, 0.01465525f, 
    -0.06454780f, -0.01164348f, 0.00104288f, -0.04226646f, -0.01550654f, -0.04115678f, 0.01689583f, 0.00164765f, 
    -0.01238687f, -0.00462902f, -0.01697231f, -0.04378773f, 0.02273810f, 0.01239141f, -0.03437953f, 0.04199442f, 
    -0.06038303f, 0.02703858f, -0.01258867f, -0.00602261f, -0.01742335f, -0.01422047f, 0.04444630f, 0.00456111f, 
    -0.05566291f, 0.02765275f, -0.05914496f, -0.05350645f, -0.01019852f, -0.05790149f, -0.00993521f, 0.03712951f, 
    -0.04936172f, 0.04210259f, -0.03577214f, 0.04438316f, -0.01888947f, 0.03156067f, 0.02511619f, 0.01128199f, 
    -0.02826489f, 0.00180338f, -0.01748790f, 0.01994477f, 0.01690286f, -0.03159796f, 0.01695608f, 0.04705004f, 
    -0.04492960f, 0.02053928f, -0.02593736f, 0.02682642f, -0.03641340f, -0.02237458f, 0.00975000f, 0.00626185f, 
    -0.05130186f, -0.05420679f, 0.00026574f, -0.04797886f, -0.01395177f, 0.00085790f, -0.03432269f, -0.00493905f, 
    -0.06175131f, 0.03771233f, -0.00842477f, 0.04738759f, 0.02594037f, -0.02646370f, -0.02770450f, -0.02513416f, 
    0.00599811f, 0.01714654f, 0.04425026f, -0.00185498f, -0.04195049f, -0.03922137f, -0.06038157f, -0.03997803f, 
    0.04571528f, 0.02800411f, -0.04690343f, -0.04532450f, 0.01952435f, -0.03085141f, 0.03864855f, -0.01735603f, 
    -0.05554103f, 0.00277548f, -0.03955138f, 0.01231559f, 0.02259092f, -0.06500810f, -0.06309547f, -0.03351806f, 
    -0.04976726f, -0.01900858f, 0.00683570f, -0.04777870f, 0.03516101f, 0.02747756f, -0.00356274f, 0.01469588f, 
    -0.03313478f, -0.04654331f, -0.05253869f, -0.04883066f, 0.03152353f, -0.03471491f, -0.06295182f, -0.05922153f, 
    0.02935616f, -0.02534584f, -0.00564591f, -0.02072604f, -0.03541303f, 0.04050178f, -0.00569419f, -0.03238590f, 
    -0.05391716f, -0.05525468f, -0.05350632f, -0.05498451f, -0.06317465f, -0.06228924f, 0.03791131f, 0.01600354f, 
    -0.02870188f, -0.18343677f, -0.06276581f, 0.20259464f, 0.13920856f, 0.06864484f, -0.02743622f, -0.00626329f, 
    -0.40891472f, -0.13959152f, 0.20962940f, 0.17878771f, 0.17752212f, 0.05205483f, -0.12973094f, 0.01426992f, 
    0.10183068f, 0.16171436f, -0.34344658f, 0.04549091f, 0.08280752f, -0.05609029f, -0.14830630f, -0.21225369f, 
    -0.12892830f, 0.03214076f, -0.17125289f, -0.17084792f, 0.03980364f, 0.23637649f, 0.28322080f, 0.12287146f, 
    0.06818262f, 0.10617677f, -0.16232902f, 0.08861164f, -0.20999047f, -0.07887118f, 0.04677576f, 0.07542783f, 
    0.10241081f, 0.08447540f, -0.25467265f, -0.06573346f, 0.02828507f, 0.01461851f, -0.23462056f, -0.17466462f, 
    0.08595884f, 0.04584021f, 0.10183312f, -0.12416972f, -0.09353840f, -0.04107254f, 0.08529519f, 0.20594296f, 
    0.25798735f, -0.10436960f, 0.16063161f, -0.03443751f, 0.01777711f, 0.32356533f, 0.18460518f, -0.13533314f, 
    -0.03854995f, -0.19497959f, 0.31122831f, -0.00081096f, 0.14692576f, 0.11157832f, -0.12699100f, 0.06739142f, 
    0.18633848f, 0.02159637f, -0.11829620f, -0.16221440f, 0.14814255f, 0.00902744f, 0.07786818f, 0.21385066f, 
    0.29492140f, 0.09434779f, 0.39344880f, 0.46744049f, 0.16366401f, 0.02545127f, -0.08358742f, -0.05216389f, 
    0.02019629f, -0.20098257f, 0.30715200f, -0.46817875f, -0.28707650f, -0.02873921f, -0.26183912f, -0.36950302f, 
    -0.14833018f, -0.17966494f, 0.14936560f, -0.01209901f, -0.06762903f, -0.32859677f, 0.22640011f, 0.28011066f, 
    0.21772966f, -0.01368111f, -0.04567977f, 0.21495962f, -0.10081795f, -0.21931447f, -0.34264889f, 0.21125847f, 
    -0.00588133f, 0.18048961f, -0.06083106f, -0.08835762f, -0.07705091f, -0.12851270f, -0.18394996f, 0.02520131f, 
    0.14097326f, 0.24576090f, 0.17590620f, -0.29695585f, 0.00115668f, 0.23770019f, 0.10326754f, -0.09037666f, 
    -0.12279204f, -0.47491801f, -0.13629903f, -0.25240502f, 0.13020945f, 0.09599137f, 0.07158157f, 0.09956544f, 
    -0.53367537f, -0.38311657f, 0.22768584f, -0.02273769f, 0.22002475f, 0.12854639f, 0.04265798f, 0.04517736f, 
    0.15563250f, 0.21509203f, 0.18614151f, 0.26529077f, -0.06220584f, 0.22904043f, 0.12434784f, 0.05487209f, 
    -0.25034270f, 0.50017470f, -0.15018840f, -0.05342015f, -0.00893496f, 0.18559895f, 0.00092013f, -0.06007429f, 
    0.06892595f, 0.10170596f, -0.32453403f, 0.00219488f, 0.16754928f, 0.04375894f, 0.10245196f, -0.00448868f, 
    0.12918253f, -0.08311798f, -0.35190549f, 0.06126748f, -0.43994763f, 0.22362269f, -0.13918912f, 0.14342627f, 
    0.20481171f, -0.13822185f, 0.12697485f, 0.19192189f, 0.23121269f, 0.09447522f, -0.01129297f, 0.31395847f, 
    0.04282222f, 0.01841048f, 0.20788346f, -0.15476814f, 0.04873462f, 0.04195118f, -0.18853205f, -0.35535991f, 
    0.03596931f, -0.09542003f, 0.03275050f, -0.03227668f, 0.09855113f, -0.10801694f, -0.06978106f, 0.32225367f, 
    0.28474477f, 0.16059245f, 0.16619039f, -0.18824653f, 0.07859686f, -0.04188382f, 0.07553705f, -0.20499173f, 
    -0.37366176f, -0.35618278f, -0.23803535f, 0.01711593f, -0.09567546f, 0.09667192f, 0.04130669f, -0.08187416f, 
    0.00264224f, -0.29332560f, 0.37781337f, -0.24825336f, -0.03555018f, -0.17426810f, -0.09937835f, 0.07085151f, 
    -0.11221454f, -0.31905875f, -0.28600869f, 0.33593753f, 0.09867952f, 0.10928953f, 0.00325027f, -0.44640487f, 
    0.03569463f, -0.19191031f, 0.08033577f, -0.18274799f, -0.18812284f, 0.15681414f, 0.14873719f, -0.04950359f, 
    0.16604859f, -0.06068893f, -0.07884870f, -0.41076818f, -0.09349691f, -0.28386024f, 0.52050072f, -0.09683447f, 
    0.09362101f, -0.10985745f, -0.15004504f, -0.00212497f, -0.01050000f, -0.16646293f, 0.03489992f, -0.34844187f, 
    0.03612103f, -0.14435554f, -0.03091187f, 0.07804739f, -0.18916765f, -0.24815306f, -0.18811812f, -0.14595284f, 
    0.20043276f, 0.13924231f, -0.06367471f, 0.16126975f, -0.19153313f, 0.00308533f, 0.16992167f, 0.49689496f, 
    0.27223665f, 0.16565469f, 0.07903759f, -0.02647937f, 0.33626595f, 0.05956922f, 0.18475322f, -0.50458401f, 
    0.12277828f, 0.23036301f, 0.01160255f, -0.04998489f, 0.01611887f, 0.07694061f, 0.21634920f, -0.14195366f, 
    -0.00298764f, -0.04827936f, 0.01639853f, -0.02066173f, -0.00223699f, -0.05467714f, 0.01923977f, 0.02320878f, 
    -0.05394570f, -0.04557160f, -0.00806087f, -0.01974541f, -0.02025218f, 0.04621985f, -0.02926501f, -0.04139607f, 
    -0.03385243f, -0.02708800f, -0.03184117f, -0.03690655f, -0.03841339f, 0.04965739f, -0.00124520f, 0.01957336f, 
    0.02862698f, -0.06333698f, -0.00162954f, 0.05320444f, -0.04846950f, 0.01631189f, 0.01830999f, -0.01437056f, 
    -0.03430164f, 0.03938773f, -0.02116724f, -0.05951045f, 0.00739523f, -0.02266222f, 0.01330878f, -0.05821453f, 
    -0.01301202f, 0.02983831f, -0.05629120f, -0.03219176f, -0.05990071f, 0.02077707f, 0.03472567f, 0.02536316f, 
    -0.00817218f, 0.00565909f, -0.01938078f, -0.00053573f, 0.01773171f, 0.03415900f, -0.01456217f, 0.04775393f, 
    -0.06417620f, 0.02685593f, 0.01394756f, -0.05027397f, 0.05366104f, -0.01702125f, -0.04850810f, -0.06202709f, 
    -0.02415723f, -0.03120147f, 0.01106943f, -0.05661589f, -0.03098549f, 0.03371986f, -0.00910839f, -0.04176727f, 
    -0.04358941f, -0.00378064f, 0.02050027f, 0.04406701f, -0.02298527f, -0.03511278f, 0.01641448f, -0.01120979f, 
    -0.02727556f, -0.06388353f, -0.03819274f, -0.03375759f, -0.05035286f, -0.04121468f, -0.05444570f, 0.03299645f, 
    -0.03374762f, -0.03667685f, -0.00998793f, 0.03823987f, -0.06069858f, -0.05726434f, 0.00104710f, -0.03651275f, 
    -0.04804774f, -0.01770323f, -0.03961977f, -0.03040781f, -0.05710047f, -0.01914764f, 0.00747587f, -0.00463878f, 
    -0.06116547f, -0.00913356f, 0.00165299f, -0.02603011f, -0.03797743f, -0.05265545f, 0.02327104f, -0.02428841f, 
    0.02370828f, -0.00358910f, 0.00357623f, 0.02157598f, -0.04450463f, 0.01336140f, -0.05581250f, -0.05067030f, 
    0.01949969f, -0.03372822f, -0.05954894f, -0.01531213f, -0.06416544f, 0.03239519f, 0.05324093f, -0.02363981f, 
    -0.01238982f, 0.01553053f, -0.04773689f, -0.05037290f, 0.05158767f, -0.05003259f, 0.00357278f, -0.06152441f, 
    -0.01227008f, -0.03573771f, -0.01009532f, 0.01127094f, -0.00080622f, -0.05291479f, -0.05050142f, 0.01837184f, 
    0.03995678f, 0.00858530f, 0.03397650f, -0.02646951f, 0.04378369f, 0.00175902f, 0.02161786f, 0.03984843f, 
    -0.05941311f, -0.03009096f, 0.00763558f, 0.04705770f, -0.05089900f, 0.03100849f, 0.00072212f, -0.02369845f, 
    0.03262624f, 0.01557209f, -0.04438274f, 0.02198787f, -0.03680115f, 0.03506718f, 0.01719528f, 0.00861394f, 
    0.00131545f, -0.05242712f, 0.05669574f, 0.04598233f, -0.01851431f, 0.00243352f, -0.01079133f, 0.03222039f, 
    0.02979474f, -0.00412410f, -0.05209813f, 0.05104842f, -0.06081368f, -0.02837614f, -0.05210999f, 0.05027568f, 
    -0.04243550f, 0.04655136f, 0.02815802f, -0.00122743f, -0.01755427f, -0.02088699f, 0.03108434f, 0.02541330f, 
    -0.02018276f, -0.04271724f, 0.00586286f, -0.04787634f, 0.00014041f, 0.03118223f, -0.00379219f, 0.01684170f, 
    -0.01896250f, -0.06408779f, 0.04932873f, -0.00933815f, 0.02858419f, -0.00900433f, 0.04915453f, -0.00292955f, 
    -0.01706412f, -0.01726978f, -0.02571079f, -0.00465682f, 0.01524867f, 0.01624141f, 0.04451892f, 0.01200629f, 
    0.01440473f, -0.02650563f, -0.02650997f, 0.04222475f, -0.03008447f, 0.04400218f, -0.00335039f, -0.02648484f, 
    -0.04847206f, -0.04962878f, -0.03148736f, -0.00868628f, -0.00030158f, -0.01324573f, 0.04652445f, 0.02590299f, 
    0.02285039f, 0.00416044f, -0.06088451f, 0.03853481f, 0.01281531f, -0.02787787f, -0.02146774f, -0.05490433f, 
    0.03873806f, 0.00954179f, -0.05623772f, 0.04822091f, -0.06207647f, 0.01893121f, 0.01466294f, -0.04333526f, 
    -0.01284773f, 0.04141432f, -0.00729487f, 0.04723978f, 0.01537509f, -0.03203611f, -0.02702212f, 0.00735118f, 
    0.02273310f, -0.05946289f, -0.05918199f, -0.00215335f, -0.02565298f, 0.01369039f, -0.05757583f, -0.05474832f, 
    0.01087065f, -0.03684348f, -0.03311023f, -0.02345419f, -0.03388006f, -0.00033645f, 0.04723720f, -0.01498277f, 
    -0.00223048f, 0.00465469f, 0.00659682f, -0.04882083f, 0.05219322f, 0.01326854f, -0.00600783f, -0.01798191f, 
    -0.00363010f, -0.00624710f, -0.03218576f, 0.03735671f, -0.00394295f, -0.00071704f, -0.06384233f, 0.04721855f, 
    0.00977157f, -0.25239265f, -0.12623909f, -0.05732358f, 0.07981423f, 0.05869338f, 0.19824283f, -0.04623130f, 
    -0.09479109f, 0.02485389f, 0.03693992f, 0.09976144f, -0.01370426f, 0.05785041f, 0.01748923f, -0.04293666f, 
    -0.09023679f, 0.14194833f, 0.00926764f, 0.00302948f, 0.03228977f, 0.04822180f, -0.15200262f, -0.05572740f, 
    -0.02105160f, -0.03171508f, -0.09495333f, 0.35771409f, -0.25463960f, 0.17290138f, -0.10535254f, -0.14092119f, 
    -0.07568357f, 0.04161543f, 0.02964817f, 0.16829175f, 0.47725439f, -0.08579338f, 0.43360075f, 0.29048246f, 
    0.11240947f, -0.02691160f, -0.01771983f, 0.28764653f, 0.05806242f, 0.04123937f, -0.39710957f, -0.31861129f, 
    0.02959506f, -0.09512062f, -0.19306524f, -0.05539564f, 0.03856509f, 0.02697216f, -0.75196183f, -0.23470825f, 
    -0.43129939f, 0.05859188f, -0.15641001f, 0.11766540f, -0.03124472f, -0.01933693f, -0.23138261f, 0.20986027f, 
    0.08418828f, -0.13733034f, 0.03777454f, -0.20662944f, 0.12268944f, 0.18695776f, 0.11525430f, -0.16900016f, 
    0.09038869f, -0.13926680f, 0.25233883f, -0.16179202f, -0.29440096f, 0.08879368f, -0.32685223f, 0.09864871f, 
    -0.04758533f, -0.31538731f, -0.13044427f, 0.06769634f, -0.02946351f, 0.00966955f, 0.21032462f, -0.09725447f, 
    0.04028993f, 0.02964128f, 0.28782919f, 0.38261119f, -0.14272344f, -0.18442012f, 0.10970166f, -0.13655043f, 
    0.10995867f, 0.05124183f, 0.20390075f, 0.10864885f, -0.04165804f, 0.19887616f, 0.15067421f, 0.11472083f, 
    -0.28357345f, -0.00550560f, -0.16180764f, 0.22512190f, -0.20186383f, -0.05074394f, 0.17974149f, 0.09366260f, 
    -0.06369732f, 0.10359711f, -0.00997482f, -0.15501480f, -0.13699600f, 0.49876025f, 0.12876067f, 0.58178759f, 
    0.32775846f, 0.15221319f, -0.02605772f, 0.06945675f, -0.12269036f, 0.15922843f, 0.33643299f, 0.03329469f, 
    -0.40695634f, -0.26042527f, -0.19026506f, 0.20791565f, -0.27691475f, 0.03392374f, 0.01406153f, 0.10918344f, 
    0.17159414f, 0.33130082f, 0.30636427f, 0.21985896f, -0.05476657f, 0.08381052f, 0.13843958f, -0.01455263f, 
    0.02877093f, -0.19799426f, -0.00410748f, 0.10365175f, 0.06287526f, 0.09843148f, -0.03942810f, -0.17534460f, 
    -0.00773077f, 0.14177698f, 0.25955606f, -0.36796001f, -0.19020718f, -0.07880721f, -0.12099763f, -0.12780936f, 
    0.07156762f, -0.00715093f, -0.42830244f, -0.27391854f, 0.03139308f, -0.04772018f, -0.09944189f, 0.08092157f, 
    -0.07179534f, 0.01980081f, -0.02311918f, -0.39671075f, -0.32857907f, -0.03082991f, 0.33976790f, -0.08968274f, 
    0.01229013f, 0.04275034f, -0.00037833f, -0.09528269f, 0.25503463f, 0.22921549f, 0.02415878f, 0.04158008f, 
    -0.02407254f, 0.08037046f, -0.22721013f, -0.08474435f, -0.23655029f, 0.10458571f, -0.04619477f, 0.08178470f, 
    -0.28761917f, 0.07902376f, 0.09389018f, -0.19167627f, -0.04806894f, 0.05594913f, 0.08017365f, 0.21527068f, 
    0.03018590f, -0.10763571f, 0.08952136f, -0.22604042f, -0.19928606f, 0.08953317f, -0.02960313f, 0.26718724f, 
    0.22717926f, 0.09787663f, -0.03135731f, -0.06747884f, 0.04746376f, -0.00662936f, 0.00381448f, 0.15757363f, 
    -0.54557782f, 0.17952868f, 0.25623450f, -0.07893343f, -0.15242152f, -0.04826463f, 0.13839296f, 0.13746268f, 
    -0.01214891f, 0.19053541f, -0.19961809f, 0.11145803f, -0.09273581f, 0.16444261f, -0.20895739f, -0.14662041f, 
    -0.03497709f, -0.02484884f, 0.21785738f, -0.03328738f, -0.04764486f, 0.01830825f, -0.23432225f, -0.17303807f, 
    0.08933963f, 0.17223902f, 0.06066144f, 0.03767355f, 0.28927863f, 0.73040938f, 0.40750942f, 0.03551551f, 
    0.13426861f, 0.17624496f, 0.10408314f, -0.22049114f, -0.36694372f, 0.40634173f, -0.49559015f, -0.07430399f, 
    0.03260713f, 0.05400099f, -0.32636163f, 0.06781357f, 0.07794135f, 0.35853815f, 0.29231817f, 0.15354593f, 
    -0.21468043f, 0.20877129f, -0.04099773f, -0.04989721f, 0.06035994f, -0.16045058f, -0.02845770f, -0.07361323f, 
    0.01491071f, -0.08757310f, 0.11379977f, 0.06097905f, 0.06037979f, 0.04878831f, -0.06462831f, -0.22915919f, 
    0.24683551f, -0.24410515f, -0.29476252f, -0.24861869f, -0.00968595f, -0.03359317f, 0.05097710f, 0.08223283f, 
    0.49095547f, 0.26279369f, 0.25968131f, -0.07755728f, 0.05700088f, -0.12590078f, -0.04863941f, -0.01286681f, 
    0.02642168f, -0.15807272f, -0.01451337f, -0.11837089f, 0.08795489f, 0.12759981f, -0.06212271f, -0.06027394f, 
    0.11663381f, -0.03456553f, 0.31187645f, 0.15830615f, -0.17243087f, -0.18876418f, 0.17583296f, 0.14186740f, 
    -0.25658590f, 0.01031344f, -0.21539426f, -0.32999128f, -0.09390445f, 0.07733647f, 0.07989565f, -0.07049946f, 
    0.04925392f, 0.05334175f, -0.00268748f, 0.11934553f, 0.61312973f, -0.06916169f, 0.20539285f, -0.36974210f, 
    0.10174567f, -0.21839121f, -0.10033830f, 0.05445712f, 0.10174323f, 0.19083631f, 0.17852584f, 0.12265863f, 
    -0.19820420f, -0.06385386f, 0.00017434f, 0.03861945f, 0.03954482f, 0.00448544f, 0.42801061f, 0.06994582f, 
    0.01033142f, 0.12193733f, 0.27418315f, -0.15332866f, 0.04716295f, 0.25461081f, 0.12046075f, -0.22450060f, 
    -0.01452606f, -0.06430107f, -0.03216610f, 0.19400573f, 0.05438426f, 0.23103468f, -0.00404060f, 0.02522695f, 
    -0.02303489f, -0.05973623f, -0.20075436f, -0.03152377f, 0.29116294f, -0.02186738f, -0.07720253f, -0.21346734f, 
    -0.03044791f, -0.10203561f, 0.06796268f, -0.14755987f, 0.05331394f, -0.01039696f, 0.00168311f, 0.00540608f, 
    0.01595781f, -0.05426856f, -0.03063776f, -0.34500951f, 0.20805456f, -0.09584173f, 0.14947660f, -0.00492796f, 
    0.18782789f, -0.15795653f, 0.14660498f, 0.62608916f, 0.08582838f, 0.20699503f, -0.24174930f, -0.12620932f, 
    -0.01848358f, 0.09693784f, 0.09051229f, -0.04269746f, -0.23832685f, -0.13791561f, -0.37936440f, 0.11838183f, 
    0.04046905f, 0.11264338f, 0.07380110f, -0.18955724f, 0.18173522f, 0.26191950f, -0.31594965f, 0.08734970f, 
    -0.16321942f, -0.12381790f, 0.04766718f, -0.02103359f, -0.09947923f, 0.06542921f, 0.13039479f, 0.14235081f, 
    0.01023365f, 0.30131790f, 0.31048858f, -0.01970329f, 0.03010636f, -0.10113725f, 0.09503879f, 0.53384769f, 
    -0.15915781f, -0.08444127f, -0.14255358f, -0.36806059f, -0.14844076f, 0.09898759f, 0.10579469f, -0.02875398f, 
    -0.01436383f, -0.15220249f, 0.17371237f, -0.04514433f, 0.16516612f, 0.08900021f, -0.28910595f, -0.10656256f, 
    0.06494702f, 0.07962327f, -0.07110355f, 0.05308351f, 0.05417703f, 0.25356993f, 0.12975141f, -0.13951580f, 
    -0.03828486f, 0.08543179f, 0.12260263f, -0.18879870f, -0.51198334f, 0.00194591f, -0.18691348f, -0.16262983f, 
    -0.02368666f, 0.02438678f, -0.17526881f, -0.11516702f, -0.51532751f, -0.40380269f, -0.45863098f, 0.11299089f, 
    -0.28112289f, -0.07000767f, -0.12470585f, -0.12958784f, -0.15070978f, -0.17683849f, -0.15390423f, 0.02176198f, 
    -0.14145103f, -0.09094668f, 0.01106783f, 0.09522178f, 0.11211928f, 0.56180453f, 0.01052898f, -0.21458866f, 
    0.02679138f, 0.23477371f, -0.04339213f, -0.13743040f, 0.16732292f, -0.17899747f, -0.03029468f, -0.12103225f, 
    0.09400880f, 0.15268265f, 0.22567317f, -0.13327006f, -0.30409202f, 0.10985325f, -0.03297367f, -0.20765865f, 
    0.09797046f, -0.02955459f, -0.16940196f, -0.02949238f, -0.03455285f, -0.06315042f, 0.07221002f, 0.08948869f, 
    0.11429504f, -0.21839036f, -0.27171445f, -0.16515535f, -0.08820634f, -0.02341977f, -0.07508757f, 0.10967884f, 
    0.20898215f, 0.09739714f, -0.14616516f, -0.23442440f, -0.05430021f, 0.02833104f, -0.04720012f, -0.32708377f, 
    0.02880394f, 0.10040653f, 0.13908458f, 0.30314377f, 0.07090374f, -0.19170153f, -0.08935795f, 0.34220243f, 
    0.14138600f, 0.13683942f, -0.16946140f, -0.53569859f, -0.35063487f, 0.07816946f, -0.26304394f, -0.01541377f, 
    0.07542730f, 0.05550132f, -0.07001335f, 0.14036907f, 0.04102554f, 0.23915432f, -0.09084728f, 0.17406678f, 
    0.21083184f, -0.01891329f, -0.11463125f, -0.10310200f, -0.08830387f, -0.08047966f, -0.06431714f, -0.10438468f, 
    0.02282977f, -0.02201668f, 0.14713997f, -0.29769045f, 0.17311560f, -0.15775926f, -0.09752731f, -0.19146605f, 
    0.13803035f, 0.18733463f, 0.15647125f, -0.01175675f, -0.02661456f, -0.13795243f, -0.01285079f, 0.12047629f, 
    0.16469727f, -0.11010685f, 0.02940051f, 0.14872444f, 0.17094071f, 0.07680983f, -0.06375943f, 0.00870761f, 
    -0.03906647f, -0.01415712f, -0.00574231f, -0.04236961f, -0.04529156f, 0.00375743f, 0.04124207f, -0.00880855f, 
    -0.01288381f, -0.04375269f, -0.01765251f, 0.03091396f, -0.02321663f, 0.00108226f, -0.00833202f, -0.05795350f, 
    -0.03505867f, -0.01062049f, -0.03181128f, -0.05866443f, 0.06103025f, 0.01066227f, -0.03927908f, -0.02698153f, 
    0.04276769f, 0.00658254f, -0.02848388f, 0.03159483f, -0.05650241f, 0.03429778f, 0.03987634f, -0.06179857f, 
    -0.01744526f, 0.03177885f, -0.05044587f, 0.01734238f, 0.03286071f, -0.05923416f, -0.04335932f, -0.00059419f, 
    -0.05091754f, 0.00606755f, -0.02999800f, 0.03090753f, -0.05275546f, -0.00071768f, -0.04509114f, 0.04956356f, 
    -0.03412173f, -0.04052820f, 0.02851439f, -0.04518510f, -0.04001914f, -0.03821522f, 0.01844745f, 0.02352490f, 
    -0.02391987f, -0.01041971f, 0.03243759f, -0.05489724f, 0.01481935f, -0.05321554f, -0.01063727f, -0.00203365f, 
    -0.02506124f, 0.04121856f, 0.03776484f, 0.02067206f, -0.01675974f, 0.04929176f, 0.02463643f, -0.05210122f, 
    -0.03797007f, -0.02966383f, -0.02726195f, -0.04691453f, -0.05241273f, 0.00851312f, 0.01081261f, -0.05111074f, 
    -0.05496246f, -0.01841450f, -0.00078753f, -0.04331734f, 0.04600063f, 0.02723279f, 0.03906453f, -0.00203121f, 
    -0.03089537f, -0.01258801f, -0.02509975f, -0.00323046f, -0.01918097f, 0.00024693f, -0.00072600f, -0.01898053f, 
    -0.04217247f, -0.03277966f, 0.03904586f, 0.04859387f, 0.02274586f, 0.03781206f, 0.02094184f, 0.03445960f, 
    -0.02835434f, -0.03035558f, -0.05149733f, 0.00799737f, -0.04990595f, -0.05099825f, 0.04927346f, -0.03169699f, 
    0.00064684f, 0.01379207f, 0.03585707f, -0.02604526f, -0.06175232f, -0.00303425f, -0.05995141f, -0.02277428f, 
    0.01809709f, 0.05146989f, -0.05790172f, 0.02964418f, -0.02997001f, 0.03313337f, 0.03966330f, -0.06123878f, 
    0.00009590f, -0.00349077f, -0.04020083f, -0.01989844f, 0.00219146f, 0.03819896f, 0.03483443f, -0.04881386f, 
    -0.03446353f, -0.06288324f, -0.04880298f, -0.06314196f, 0.00932312f, 0.02233252f, -0.02709859f, -0.05492213f, 
    -0.02759462f, -0.06122374f, -0.04026344f, 0.00538330f, 0.03548057f, -0.05149123f, 0.03352534f, -0.04251339f, 
    0.04267206f, -0.00896146f, -0.06027389f, 0.03534897f, -0.02612046f, 0.00390162f, -0.03752892f, -0.05647514f, 
    0.01415389f, 0.00804875f, 0.02454058f, -0.01339790f, -0.04085895f, 0.00686691f, 0.02645341f, 0.02465759f, 
    0.04885517f, -0.00670735f, 0.03298298f, -0.00633951f, -0.00281221f, -0.02826719f, 0.02547614f, 0.03851142f, 
    0.04822632f, -0.02531032f, -0.01504061f, -0.04417923f, 0.02703703f, 0.03538009f, -0.04076194f, -0.02601843f, 
    -0.05698567f, -0.05757746f, 0.04572007f, -0.00198674f, 0.03637452f, 0.02640991f, -0.05738082f, -0.06218477f, 
    -0.05774594f, 0.04926657f, 0.03495527f, -0.00582064f, 0.03217042f, -0.04241532f, 0.01764796f, -0.05824888f, 
    0.02524011f, -0.00587119f, -0.03861329f, 0.03252408f, -0.00892219f, 0.00740361f, 0.01240444f, 0.02772989f, 
    0.03785055f, 0.00592489f, -0.01562902f, -0.04811691f, 0.03999901f, 0.03449202f, -0.02068339f, -0.04053107f, 
    -0.05756984f, -0.03545935f, 0.00183489f, 0.01242833f, 0.00757432f, -0.00710906f, -0.00219669f, -0.04416185f, 
    0.03955652f, -0.04937750f, -0.03448535f, 0.02625080f, 0.03796942f, 0.04710332f, 0.02468638f, 0.04287165f, 
    -0.02590484f, 0.01566262f, 0.04413291f, 0.01459428f, 0.02463232f, -0.01234445f, 0.01310698f, -0.05810093f, 
    -0.04704269f, -0.01167678f, -0.02736824f, 0.04861291f, -0.04307280f, -0.03100116f, 0.01529600f, -0.04081490f, 
    0.00868885f, 0.03160699f, 0.05047088f, 0.05172550f, 0.01670960f, 0.04250601f, 0.03847336f, 0.02849573f, 
    0.05236432f, -0.03029525f, 0.03092315f, 0.04669831f, 0.00080150f, -0.03172153f, 0.00129002f, 0.03710890f, 
    -0.00040912f, 0.00178301f, -0.05724819f, 0.01646360f, -0.02392639f, -0.04604943f, -0.04917042f, 0.02855590f, 
    0.04826205f, -0.05600720f, 0.03976127f, 0.01005082f, -0.00857992f, 0.03852137f, -0.02571349f, -0.01035746f, 
    -0.04077535f, 0.01190507f, -0.03566035f, -0.00010493f, -0.06178832f, 0.01499448f, 0.00245219f, 0.02487211f, 
    -0.00287422f, -0.01422065f, 0.01361041f, 0.01084105f, 0.05147146f, 0.00428332f, 0.01836770f, -0.02971776f, 
    0.00315926f, -0.04895496f, -0.07397068f, 0.00133429f, 0.01599913f, -0.06710263f, 0.01490613f, 0.03052841f, 
    0.00090145f, 0.02066181f, 0.00636258f, 0.02999137f, -0.03923598f, 0.02722296f, -0.01017858f, -0.07274624f, 
    0.02282606f, -0.08500510f, 0.02648462f, -0.05656181f, -0.02232393f, 0.04044866f, -0.03741106f, 0.01074042f, 
    -0.00216215f, -0.05539862f, 0.02051337f, -0.05058123f, 0.04593581f, 0.03360956f, -0.02323454f, -0.04532954f, 
    -0.03168458f, 0.01449773f, -0.01913911f, -0.00106948f, -0.03573249f, -0.06154845f, -0.00205903f, 0.03537587f, 
    -0.02301215f, 0.01308302f, -0.07779937f, 0.02123396f, 0.02992393f, 0.01618363f, 0.00533877f, 0.04353103f, 
    0.06258781f, 0.01939702f, -0.05976981f, 0.00430407f, 0.03143857f, -0.05739301f, -0.02636836f, 0.01458216f, 
    0.01997356f, -0.04475068f, 0.00240429f, 0.01084642f, -0.06372793f, -0.06163226f, 0.02211387f, -0.02338490f, 
    0.00527891f, -0.02741468f, 0.04767783f, 0.04600883f, -0.04886278f, -0.02274718f, -0.02627335f, -0.04104258f, 
    -0.03566960f, 0.02858936f, -0.01298122f, -0.02477810f, -0.04220363f, -0.01405940f, -0.04606106f, -0.06935649f, 
    0.01970198f, -0.00362382f, -0.01275254f, 0.00625090f, -0.03663126f, -0.07346271f, -0.02595554f, -0.00510347f, 
    0.03194962f, -0.03227407f, 0.04006321f, -0.04810262f, -0.02368321f, -0.03398586f, 0.01507241f, -0.06469408f, 
    -0.02722085f, -0.08351599f, 0.01358569f, -0.01795308f, -0.07612859f, -0.06382463f, -0.00022343f, -0.06134569f, 
    0.00535792f, -0.06191548f, -0.02528528f, 0.02671902f, 0.01098667f, 0.00779156f, -0.04436364f, -0.03237557f, 
    -0.02204369f, -0.06570791f, -0.01638020f, -0.01566856f, -0.00553270f, -0.03712157f, 0.03640351f, 0.00871802f, 
    0.01031304f, -0.02412987f, -0.02280764f, -0.01885072f, -0.03606864f, 0.05003743f, -0.00818178f, -0.03157200f, 
    -0.01523427f, 0.00713570f, 0.01768528f, -0.03381401f, -0.01186272f, -0.02377193f, -0.03705469f, -0.07805193f, 
    -0.06639208f, -0.07902519f, 0.03307549f, -0.02654082f, 0.03605471f, -0.03936128f, -0.06936870f, -0.04765384f, 
    -0.02630439f, -0.05460964f, -0.02771398f, -0.01472858f, -0.07579599f, -0.00635447f, -0.01088481f, -0.07133140f, 
    0.01596696f, 0.02546218f, 0.04932017f, -0.06412148f, 0.01201330f, 0.03754185f, -0.00081032f, 0.02771314f, 
    -0.05921427f, -0.02138518f, -0.00252708f, 0.00134021f, 0.03794188f, -0.00328847f, 0.00829595f, -0.01996324f, 
    -0.00999271f, 0.03841959f, -0.02950240f, -0.00385430f, -0.06776965f, -0.03873376f, -0.07314315f, -0.06866764f, 
    0.01297613f, -0.03730711f, -0.07007981f, -0.05133777f, -0.01792856f, -0.00205249f, -0.08467297f, -0.02523006f, 
    -0.02708985f, 0.00748609f, 0.01033862f, 0.02462868f, -0.01830498f, 0.00302267f, 0.02247081f, -0.04816337f, 
    0.01143244f, 0.03265160f, -0.01265248f, -0.09835623f, 0.02759507f, 0.00344384f, -0.06005668f, 0.03021310f, 
    -0.01862582f, 0.00205397f, 0.02990877f, -0.04382209f, -0.02340446f, -0.02928686f, -0.05263279f, 0.02322927f, 
    -0.00654377f, 0.03268696f, 0.01261110f, -0.01604805f, 0.03725599f, -0.06844104f, -0.06057727f, -0.07305016f, 
    -0.05617615f, -0.00638883f, 0.02669770f, -0.04033088f, -0.03091344f, 0.00063057f, -0.06568779f, 0.01927408f, 
    -0.06053070f, 0.03478167f, -0.03380432f, 0.02472326f, 0.04735822f, -0.05156422f, -0.07150736f, -0.04516640f, 
    -0.04612618f, -0.06340059f, 0.02357530f, 0.01589350f, -0.05606266f, -0.00544618f, -0.06610463f, 0.01588036f, 
    -0.00450590f, 0.01402677f, -0.08228918f, -0.05259714f, -0.01978823f, 0.00682439f, 0.01331170f, -0.02675785f, 
    -0.04702412f, 0.02358109f, -0.02296358f, -0.04263502f, -0.03487812f, -0.07140216f, -0.07237740f, 0.01335278f, 
    0.00481619f, 0.01153519f, -0.06129548f, -0.04727810f, -0.00806856f, -0.07906313f, -0.01064368f, -0.05408513f, 
    -0.00634951f, -0.05421728f, -0.02836588f, -0.10885639f, -0.05010189f, 0.01391576f, -0.05446577f, -0.05622761f, 
    -0.05254607f, -0.04233557f, -0.01029569f, -0.02376630f, -0.08010212f, -0.06201385f, -0.01177142f, -0.05921670f, 
    -0.02625053f, 0.01555401f, 0.02960173f, -0.05956822f, -0.02360922f, 0.03559814f, 0.00727649f, 0.00628091f, 
    -0.00509658f, 0.02692092f, -0.02296384f, 0.03972673f, -0.05742480f, -0.03800284f, -0.01683110f, 0.03082822f, 
    0.02987161f, -0.02493571f, 0.02094521f, -0.01636322f, -0.04324668f, 0.04429662f, -0.06054686f, -0.03917076f, 
    0.02951737f, -0.01369061f, -0.05573492f, -0.02540396f, -0.03790245f, 0.00758780f, -0.03826131f, -0.04559132f, 
    0.02744804f, -0.06421511f, -0.06155921f, -0.00639822f, -0.00917599f, -0.04962221f, 0.05315875f, -0.04233000f, 
    0.01886224f, -0.06415214f, -0.04947747f, 0.05062702f, 0.00591400f, -0.01562003f, 0.02955226f, -0.00014283f, 
    0.03544187f, 0.04273621f, -0.03623220f, -0.03864601f, -0.02063652f, 0.03360433f, -0.01011546f, -0.02605980f, 
    0.01018265f, -0.07004520f, 0.01817858f, -0.04783760f, 0.01548135f, 0.03398766f, -0.03579409f, 0.04378852f, 
    -0.06640927f, 0.04068412f, -0.01075823f, -0.01089726f, -0.03817804f, 0.01468242f, 0.02204390f, -0.00421410f, 
    0.00112075f, -0.05395336f, -0.03431572f, 0.04855712f, 0.01453967f, 0.03663196f, 0.03473144f, -0.05716393f, 
    0.00731169f, -0.06228071f, -0.05222487f, -0.01714801f, 0.00722208f, -0.02966518f, 0.01001044f, 0.01634786f, 
    0.04228835f, -0.02057118f, -0.06517246f, -0.05554330f, 0.03837736f, 0.00642682f, 0.04033921f, -0.06167625f, 
    -0.03333011f, 0.05354498f, 0.03389170f, -0.00272331f, -0.03642613f, 0.03180759f, 0.01199194f, 0.00711572f, 
    0.00348328f, -0.06867171f, -0.04872718f, -0.04876314f, 0.03393833f, 0.04501738f, -0.05660655f, 0.04010109f, 
    0.03511070f, 0.01494504f, 0.03583328f, -0.05845279f, 0.02818130f, -0.04198803f, 0.04154452f, -0.05461581f, 
    -0.03721062f, -0.00704983f, -0.04790634f, -0.02462552f, 0.01560805f, -0.02475088f, 0.03720710f, 0.01911683f, 
    0.03706472f, -0.01652515f, -0.05276684f, 0.04886480f, 0.02306901f, 0.00453604f, -0.00780956f, -0.05017773f, 
    -0.01550182f, -0.06921986f, -0.06236305f, 0.03930922f, 0.04294382f, 0.02914926f, -0.05936032f, 0.03562667f, 
    0.02466994f, 0.04215830f, 0.01277334f, 0.02779394f, -0.00909789f, -0.03485272f, 0.03308808f, -0.05455779f, 
    -0.03483120f, 0.01871594f, -0.03316323f, -0.02958615f, -0.03648154f, -0.00047768f, 0.04576087f, -0.04233377f, 
    0.00657115f, 0.02141212f, -0.01558945f, 0.00227326f, -0.04191392f, -0.00353124f, 0.03651875f, -0.01788066f, 
    0.02262242f, -0.03810090f, 0.00945123f, -0.06248526f, -0.03636593f, 0.02297252f, 0.02918017f, -0.02838558f, 
    0.03384113f, -0.05848579f, 0.04535604f, -0.06970258f, 0.02663238f, -0.00254119f, -0.05709347f, -0.04699675f, 
    -0.00514343f, 0.01802536f, 0.00485700f, -0.05037326f, -0.02487513f, -0.02538550f, -0.05891664f, -0.00997226f, 
    -0.00841143f, -0.05982626f, 0.00095735f, -0.05067372f, 0.02121942f, -0.01943410f, -0.06304174f, -0.01235836f, 
    -0.00893284f, -0.03801082f, -0.05085537f, -0.01093105f, -0.03055357f, -0.00645445f, -0.06349107f, -0.06865862f, 
    0.04568115f, -0.06674840f, -0.00111187f, -0.04604164f, 0.03544853f, -0.06866229f, 0.02121106f, -0.04169979f, 
    0.02428655f, -0.04779090f, -0.02233712f, -0.03144325f, 0.00209065f, 0.03267159f, 0.04710862f, -0.03507115f, 
    -0.04264431f, -0.02514619f, 0.00649915f, -0.05989721f, 0.02356791f, -0.05350011f, -0.01865036f, 0.04450678f, 
    -0.03511235f, -0.07153439f, -0.00896504f, 0.04783389f, 0.03003757f, -0.04429733f, 0.02880337f, 0.03294333f, 
    -0.01397732f, -0.00283533f, -0.00399567f, -0.01480681f, -0.05687044f, -0.00634036f, 0.03157884f, -0.04293134f, 
    -0.06079242f, -0.05350226f, 0.04711506f, -0.05169985f, 0.03169632f, 0.00056962f, 0.03581111f, 0.03076581f, 
    0.01841617f, 0.01302602f, -0.00065633f, -0.03372805f, -0.04613465f, -0.02846512f, -0.05085572f, 0.03764502f, 
    0.00005447f, -0.04404961f, -0.00392906f, -0.04727489f, -0.01229638f, 0.00544172f, -0.02723343f, 0.04210047f, 
    0.03326971f, -0.01164408f, 0.04872454f, -0.00062206f, 0.04783126f, 0.02591044f, -0.00057367f, 0.02860635f, 
    -0.04739699f, -0.05671605f, -0.04887747f, -0.06049688f, 0.02403658f, -0.02788342f, -0.06817979f, -0.06381126f, 
    0.04016277f, 0.04490162f, -0.06977829f, -0.05624843f, -0.04892236f, 0.03391284f, -0.03260385f, 0.03309245f, 
    -0.02647616f, -0.02558325f, -0.03953896f, 0.01706602f, 0.00318600f, 0.04496215f, -0.04738982f, 0.04861649f, 
    -0.04285010f, -0.03853173f, -0.01210287f, 0.00241788f, -0.01986759f, 0.00863951f, -0.02553733f, 0.03181373f, 
    0.00621043f, -0.04561404f, 0.03939819f, 0.06354779f, -0.03330877f, 0.03654953f, -0.03006220f, 0.00696742f, 
    -0.06475365f, -0.03394508f, 0.00467902f, -0.04504445f, -0.03579750f, -0.01606455f, -0.04565209f, -0.03965499f, 
    0.01016275f, -0.04299886f, 0.01150574f, 0.01881693f, 0.04510534f, -0.00599469f, -0.01824924f, -0.02221166f, 
    -0.01044229f, -0.00255246f, 0.04810107f, -0.04222045f, -0.00405365f, 0.01164878f, 0.03758727f, -0.02871547f, 
    -0.03714222f, 0.00650905f, -0.04883569f, 0.01719576f, -0.04132907f, 0.01568500f, -0.03968093f, 0.04704274f, 
    -0.02629377f, -0.03264852f, -0.04053834f, -0.04295252f, -0.01636957f, 0.04152230f, -0.07228915f, -0.02475305f, 
    -0.03888258f, 0.00473972f, 0.04901762f, -0.02848371f, 0.03676495f, 0.05434303f, -0.00303515f, 0.00826105f, 
    -0.00188587f, 0.03287301f, -0.00578866f, -0.00075544f, -0.03460184f, -0.04300608f, -0.02192467f, 0.04564232f, 
    0.02403751f, 0.02713296f, -0.05113256f, -0.04235834f, 0.05186912f, 0.04059353f, -0.04427739f, 0.02335951f, 
    -0.09259007f, 0.00827298f, 0.01216889f, -0.01824834f, -0.05035833f, -0.01901639f, 0.02157535f, -0.01420740f, 
    -0.05700091f, 0.00479375f, -0.04036711f, -0.00182650f, 0.02974592f, -0.03507337f, 0.00831496f, -0.04200431f, 
    0.00535266f, -0.03189505f, -0.04583138f, 0.01460191f, 0.00993118f, -0.03554624f, -0.07697314f, -0.05730301f, 
    0.01931059f, -0.01712463f, -0.04718146f, -0.05527614f, 0.04331508f, 0.01726416f, -0.00339449f, -0.00345857f, 
    -0.00738746f, 0.01810531f, -0.04694274f, -0.04905272f, 0.00268914f, -0.04410001f, 0.03602215f, -0.01405978f, 
    -0.07859518f, 0.03785872f, -0.02160247f, 0.03551760f, -0.00809976f, -0.04873830f, 0.02776290f, 0.01146923f, 
    0.03617984f, -0.01689781f, -0.04834941f, -0.00179255f, -0.05363041f, -0.01504291f, -0.00366673f, 0.04154572f, 
    -0.01508136f, 0.01510264f, -0.04077182f, -0.06287239f, -0.01359619f, -0.01720962f, -0.03153538f, -0.02875105f, 
    -0.05430807f, 0.04912082f, 0.04766579f, 0.02898637f, -0.03322939f, -0.02092259f, -0.07779641f, 0.03462683f, 
    -0.01467275f, 0.03829211f, 0.03244654f, -0.07045357f, -0.00967999f, 0.00624694f, 0.04044965f, -0.03610707f, 
    0.05470886f, 0.00689747f, 0.03407669f, 0.01443559f, 0.03889295f, -0.02066681f, 0.01660005f, 0.03381906f, 
    0.00965059f, 0.01566385f, -0.00108244f, -0.04443576f, 0.05235994f, 0.01980715f, 0.05182588f, -0.04642054f, 
    0.01163249f, 0.03222438f, 0.01166650f, 0.02474375f, 0.03107087f, -0.00764150f, 0.03206232f, -0.04929120f, 
    0.00517410f, 0.04426340f, -0.04210120f, 0.00940071f, -0.01468201f, -0.03561401f, -0.02522167f, 0.01924056f, 
    -0.01391683f, -0.05583327f, -0.03148891f, 0.03737321f, -0.01792968f, 0.03282793f, -0.01681379f, 0.02948658f, 
    -0.00033149f, 0.00840954f, -0.04056896f, -0.00304079f, 0.05147851f, -0.05621744f, -0.04873062f, 0.03427108f, 
    0.04479175f, -0.03319762f, 0.02801306f, 0.00013810f, 0.01652726f, 0.01873106f, 0.02199881f, 0.02369239f, 
    -0.05510969f, 0.05057542f, 0.00492465f, -0.05889816f, 0.03040394f, -0.04587489f, -0.05324680f, 0.00799182f, 
    0.04971699f, -0.00986107f, 0.01261487f, -0.07239862f, 0.00105683f, 0.05116260f, -0.05322858f, 0.00066868f, 
    -0.00914152f, 0.03891556f, -0.04558223f, -0.06318077f, -0.03572537f, 0.01335248f, 0.01663378f, 0.04420583f, 
    -0.03325678f, 0.02790858f, -0.05205346f, 0.04635031f, 0.00751460f, 0.04771337f, 0.02015907f, 0.02359423f, 
    -0.01236111f, -0.05044840f, 0.02498096f, -0.02464662f, 0.00330631f, 0.00812257f, -0.03288317f, -0.05265667f, 
    0.02611606f, 0.00169670f, -0.00017524f, -0.02684310f, -0.04715510f, -0.06190652f, -0.04039129f, -0.04643762f, 
    -0.06043844f, -0.05851445f, 0.03166555f, -0.02468702f, 0.00601683f, -0.02425775f, -0.05721540f, -0.04716657f, 
    0.03187617f, -0.02055436f, -0.04375797f, -0.06214553f, -0.05479479f, -0.01531725f, -0.05159230f, -0.00683930f, 
    -0.02009631f, -0.03420923f, 0.03194563f, -0.05889851f, -0.00126793f, 0.01106678f, 0.03579874f, -0.05018525f, 
    -0.02208594f, 0.04364067f, -0.05483002f, -0.04277101f, -0.00258784f, -0.01786185f, 0.02507034f, 0.00629307f, 
    -0.05253487f, 0.02800233f, 0.04200635f, -0.04556350f, -0.01790293f, -0.05363698f, 0.04302232f, -0.06233528f, 
    -0.05366646f, 0.02723031f, -0.05376744f, 0.03663567f, -0.05045434f, 0.01512080f, -0.05683684f, 0.05180245f, 
    0.04138379f, 0.02205701f, -0.00569433f, -0.03690979f, -0.00920634f, -0.02599318f, -0.01426044f, 0.03625516f, 
    -0.02581101f, 0.03801923f, -0.03470445f, -0.00603778f, 0.03636399f, -0.00235433f, -0.02846697f, 0.05459311f, 
    0.00263611f, -0.03599003f, -0.00292829f, 0.01297615f, -0.05583287f, -0.04921260f, -0.06267585f, 0.01313003f, 
    -0.06095025f, -0.01479314f, 0.01761699f, -0.03408119f, 0.04839376f, 0.05445535f, 0.01631610f, 0.03035964f, 
    -0.01727270f, -0.00990448f, 0.03029460f, -0.00335788f, 0.02797298f, -0.01026583f, -0.03797556f, -0.02849986f, 
    0.03033614f, 0.02440130f, -0.02273435f, -0.03133106f, 0.00393475f, 0.05140784f, -0.03341829f, 0.02696238f, 
    -0.00413047f, -0.06389859f, -0.00956441f, -0.00194552f, -0.04329319f, -0.02939562f, -0.00218278f, 0.00563782f, 
    -0.03522146f, 0.03987634f, 0.02633460f, -0.02706486f, -0.05535147f, 0.02553328f, 0.04276918f, -0.04351499f, 
    0.02649309f, -0.01740388f, -0.00240280f, 0.01681464f, -0.05298553f, 0.02979007f, -0.04449826f, -0.03101242f, 
    0.02988976f, -0.01898842f, 0.04859864f, 0.05174995f, 0.01360916f, -0.03995530f, 0.02791457f, -0.04589815f, 
    -0.01708605f, -0.03938249f, -0.02621472f, 0.05065129f, -0.04241722f, -0.05427864f, -0.05992822f, -0.03138588f, 
    -0.05577155f, 0.00844290f, -0.00418454f, -0.03899353f, 0.05434678f, -0.04692014f, -0.03829745f, -0.02652021f, 
    -0.03351424f, 0.02304680f, 0.00936063f, 0.03558822f, 0.03899654f, 0.00982030f, -0.04456604f, -0.01783346f, 
    -0.01154870f, -0.05330897f, -0.05257705f, 0.03776326f, 0.02700812f, -0.06472282f, 0.02415653f, -0.02331211f, 
    0.01927928f, 0.04136100f, 0.00563845f, 0.01073496f, 0.02796460f, 0.03180916f, -0.03095204f, -0.04583355f, 
    -0.01037754f, -0.01659348f, 0.02523480f, 0.00663306f, -0.00483927f, 0.01562862f, -0.05347047f, -0.01860803f, 
    -0.02704421f, -0.00239287f, 0.01006617f, -0.02506523f, -0.00307080f, 0.02527846f, 0.05183781f, -0.03274189f, 
    -0.01286943f, -0.03176361f, 0.01065822f, -0.04271951f, -0.05924014f, -0.06041768f, -0.01562661f, -0.03911596f, 
    -0.00270507f, -0.01182054f, 0.01392707f, 0.00303922f, -0.00580047f, -0.00510483f, -0.00533406f, -0.03432985f, 
    -0.00341560f, 0.01094889f, -0.03563474f, -0.02189866f, 0.03946728f, 0.02583798f, 0.04601925f, -0.03016669f, 
    0.03914613f, -0.05504252f, 0.01676634f, 0.01323840f, -0.00373361f, -0.04946283f, -0.04780344f, -0.02389264f, 
    -0.02407115f, 0.01613723f, 0.00565839f, -0.00644572f, -0.01080783f, -0.06996607f, -0.04761022f, -0.04921664f, 
    0.03346421f, -0.06936393f, 0.01508623f, -0.03634354f, 0.00176272f, -0.05086078f, -0.04769060f, -0.01276723f, 
    -0.01818460f, 0.03741430f, 0.05158865f, 0.00732575f, -0.03762434f, -0.01299368f, -0.01337379f, -0.04067512f, 
    0.02013633f, 0.00998939f, -0.02658198f, -0.00199650f, 0.03203059f, -0.03158871f, 0.02296996f, 0.03590964f, 
    -0.01689645f, 0.04540649f, 0.02442744f, 0.01174087f, 0.00990337f, -0.05286594f, -0.01938449f, 0.04227348f, 
    0.02903495f, -0.04676113f, -0.00777492f, 0.02974403f, 0.02281920f, 0.02331179f, 0.04025161f, 0.02316641f, 
    -0.00647623f, 0.03786884f, -0.03233159f, -0.02957273f, 0.01283743f, 0.00276039f, -0.05382835f, -0.03488377f, 
    0.04330058f, 0.00089050f, 0.02388621f, -0.04967282f, -0.04587714f, 0.02659388f, -0.01324470f, -0.06063718f, 
    -0.07017884f, -0.00582933f, 0.02786429f, -0.02383806f, 0.01926032f, -0.05111269f, 0.01803612f, 0.01390300f, 
    -0.02540449f, 0.04666321f, -0.05819016f, 0.04917263f, 0.04158440f, 0.00386575f, -0.03597746f, 0.03213413f, 
    -0.05374513f, 0.04126641f, 0.00498755f, 0.03463494f, -0.02069034f, 0.04210865f, -0.02148478f, 0.03996810f, 
    0.02888626f, 0.00782462f, 0.02801553f, -0.05495581f, -0.06372940f, -0.01967254f, 0.01473802f, 0.04507562f, 
    0.02910200f, 0.00566815f, -0.05324547f, -0.01096688f, 0.04380481f, -0.01542952f, -0.02019609f, -0.06364245f, 
    -0.04523953f, -0.02048528f, -0.02413743f, -0.05895888f, -0.01594692f, -0.02335483f, 0.02435347f, -0.04348673f, 
    0.00649744f, -0.05805696f, -0.03856860f, 0.03967927f, -0.06507979f, 0.04125547f, 0.00404135f, 0.00202073f, 
    -0.03171457f, -0.02559058f, -0.05308345f, 0.03676571f, 0.02447423f, -0.03370740f, 0.04791790f, -0.03804638f, 
    -0.04938611f, 0.02337645f, -0.02798532f, -0.04054591f, -0.04919607f, 0.04279276f, -0.04211877f, 0.01319760f, 
    -0.05432849f, 0.01580156f, -0.04773093f, 0.01554248f, -0.02654131f, -0.06905608f, 0.02897822f, -0.04990596f, 
    -0.03946463f, -0.06505945f, -0.01328125f, -0.00490371f, -0.04759037f, 0.00168360f, -0.05189782f, -0.04378857f, 
    -0.01740894f, -0.05064318f, 0.00060857f, -0.03896503f, -0.01407190f, -0.00553448f, -0.00263547f, 0.00164147f, 
    0.04703440f, -0.06415606f, 0.02979122f, -0.05046139f, -0.00969896f, -0.03850087f, -0.00112657f, -0.06898631f, 
    0.00520707f, 0.00682609f, -0.01485421f, -0.00747310f, -0.01786704f, -0.03420508f, -0.05571582f, -0.03705118f, 
    -0.03756200f, -0.03163962f, -0.01389162f, 0.00616266f, 0.00090054f, -0.04534897f, 0.01751712f, 0.04078344f, 
    0.04698458f, 0.00864482f, 0.03710378f, -0.03286119f, -0.06532148f, -0.06191607f, 0.00103398f, 0.00746274f, 
    0.02384855f, -0.02980608f, -0.02296945f, 0.03179437f, 0.04121267f, 0.04940735f, -0.03944368f, -0.02603206f, 
    0.01909893f, -0.03132873f, 0.05132248f, 0.00370431f, -0.01878951f, -0.06580942f, -0.02500972f, -0.00238889f, 
    0.01323777f, -0.03365545f, 0.01492073f, 0.02637578f, 0.02116425f, 0.01745473f, 0.02195309f, -0.06055262f, 
    -0.05017830f, 0.00920663f, 0.02249162f, -0.00791768f, 0.03452177f, 0.03604087f, -0.00097669f, 0.03852370f, 
    0.03800897f, -0.00272009f, 0.03021755f, -0.03660146f, -0.04176038f, -0.06447364f, -0.03487981f, -0.03463911f, 
    -0.02141216f, -0.00758677f, 0.03896760f, -0.02826244f, -0.00590870f, 0.02186552f, 0.04397677f, 0.02970247f, 
    -0.01622079f, -0.00949530f, -0.01119735f, 0.04194380f, -0.05607466f, -0.06165069f, -0.01961286f, -0.05175139f, 
    0.03465897f, -0.05266794f, 0.04221291f, 0.03498861f, 0.02058319f, 0.00949663f, 0.00455088f, 0.01834266f, 
    0.03683463f, -0.04452600f, -0.01903839f, 0.01392505f, -0.00503345f, -0.00200430f, 0.00825672f, 0.03783199f, 
    0.04782419f, -0.05076848f, -0.01984302f, -0.02965127f, -0.03110377f, 0.00953896f, 0.00548689f, -0.00290520f, 
    -0.06252097f, 0.01492514f, -0.01800595f, 0.00902395f, 0.03210885f, 0.03514994f, -0.03545331f, 0.04771030f, 
    -0.04643648f, -0.05302618f, 0.02166119f, 0.04896377f, -0.02710952f, 0.00411422f, -0.00899801f, 0.03007320f, 
    -0.01959524f, -0.03856372f, -0.01839279f, -0.03038557f, -0.03831272f, 0.00261662f, 0.00532514f, -0.06296451f, 
    0.04365390f, 0.02121498f, -0.05082075f, 0.04228146f, -0.01123220f, 0.00396288f, 0.00926911f, 0.00919252f, 
    0.01399450f, 0.03977723f, -0.04344055f, 0.01739791f, -0.06595044f, -0.01529503f, -0.04479731f, 0.02977034f, 
    0.03706874f, -0.02759458f, 0.00278851f, -0.00317931f, -0.02630051f, 0.03063405f, 0.03447211f, 0.00320383f, 
    -0.06592233f, 0.03648301f, -0.01403821f, -0.04321205f, -0.06171830f, -0.06503917f, -0.05425736f, -0.06027934f, 
    -0.00849145f, -0.01135098f, -0.04063862f, 0.01156842f, -0.06161558f, 0.02910124f, -0.02100445f, 0.04945200f, 
    -0.06667884f, 0.01873713f, 0.04697588f, -0.05776992f, -0.01805078f, 0.03841450f, 0.03981461f, 0.00327794f, 
    0.01367653f, -0.05215961f, 0.00700285f, 0.04374668f, -0.04353875f, 0.02626127f, -0.00908595f, -0.04192101f, 
    0.02687336f, -0.05921805f, -0.04347385f, -0.01112452f, 0.00369859f, -0.04051320f, -0.02166392f, 0.02981401f, 
    -0.06397191f, -0.02574201f, -0.00961577f, -0.05753400f, -0.04536357f, -0.03742404f, 0.02056448f, -0.02672190f, 
    -0.04131141f, -0.01707168f, -0.04353028f, -0.05759766f, 0.03330418f, 0.05138892f, -0.01322765f, -0.05692326f, 
    -0.02722897f, 0.02146460f, -0.04935562f, 0.04628018f, 0.05409645f, -0.05235417f, -0.05736135f, 0.01283261f, 
    0.02581925f, -0.02340391f, 0.00097977f, -0.03305074f, 0.05209079f, -0.00329508f, -0.04597054f, 0.02233377f, 
    0.00093781f, 0.04622720f, -0.05724497f, -0.06422275f, -0.01791218f, -0.03051259f, -0.04554087f, -0.01059382f, 
    -0.01702904f, -0.05323379f, 0.04024428f, 0.05402466f, -0.00731129f, 0.00623731f, 0.02139380f, 0.04626799f, 
    -0.06571519f, 0.03030804f, -0.06314774f, -0.05286271f, 0.02606452f, -0.01427574f, -0.03526315f, -0.05302806f, 
    -0.01305496f, -0.02383349f, -0.02511997f, 0.02744877f, -0.01830732f, -0.04515002f, -0.02157059f, -0.02341920f, 
    -0.03823306f, -0.00393840f, 0.03090802f, -0.03925734f, 0.04267081f, -0.02245938f, 0.02652454f, -0.06058069f, 
    -0.00054976f, -0.03161646f, -0.00690707f, -0.01079232f, -0.03239591f, 0.03835431f, 0.01295085f, 0.01290563f, 
    -0.01077662f, 0.04262570f, 0.03027697f, 0.04402769f, -0.02197921f, -0.00789151f, -0.05056124f, -0.01184566f, 
    -0.05681827f, -0.03067122f, -0.04639227f, -0.02650968f, -0.05345841f, -0.02449204f, 0.05780871f, 0.01340994f, 
    -0.03458581f, -0.06002425f, -0.02613562f, -0.01980062f, -0.02599773f, 0.00525851f, -0.03649102f, -0.04805944f, 
    -0.06286297f, -0.01433480f, 0.04244344f, -0.05254926f, -0.01061306f, 0.02556066f, -0.03480758f, -0.01289008f, 
    0.02056443f, 0.03239091f, 0.00708495f, 0.06165392f, 0.04279798f, -0.01453410f, 0.02604752f, 0.04808308f, 
    0.03365915f, 0.03541862f, 0.04399574f, 0.01347541f, -0.04714521f, -0.05888294f, -0.03466882f, -0.03637882f, 
    -0.06343276f, 0.01410229f, -0.00244583f, -0.01847948f, -0.02331524f, 0.05878561f, -0.01350416f, -0.03596387f, 
    -0.03596058f, 0.03120714f, 0.02117849f, 0.02729678f, 0.02108249f, 0.00260866f, -0.00654176f, -0.00620865f, 
    0.02431087f, -0.05298127f, 0.00677620f, -0.00870948f, -0.06791516f, -0.06657290f, -0.04092835f, 0.03016911f, 
    -0.05801969f, -0.02745697f, -0.01897978f, -0.02313844f, -0.04210344f, 0.00850572f, 0.00708025f, -0.06447504f, 
    -0.02830657f, -0.06195124f, 0.00354038f, -0.05702315f, -0.01565703f, 0.04926231f, 0.03887792f, -0.01096034f, 
    -0.03384322f, 0.00611007f, -0.01366534f, -0.00044302f, -0.04075353f, -0.01430157f, -0.04056520f, -0.04044852f, 
    -0.03139867f, -0.02317128f, 0.03639661f, -0.00059968f, 0.04769865f, -0.06741296f, -0.05339376f, -0.06858657f, 
    -0.03896718f, -0.00260601f, 0.04916178f, -0.01037772f, -0.01858108f, 0.04517312f, -0.03261474f, 0.04176965f, 
    -0.02152613f, 0.04613443f, 0.00529649f, -0.01923487f, 0.01774335f, 0.00882749f, -0.02100648f, -0.04597626f, 
    -0.01595235f, 0.00208648f, -0.04678041f, 0.02798286f, -0.00799281f, 0.04212362f, -0.04363950f, -0.04287016f, 
    -0.02121403f, -0.00889246f, -0.03407915f, 0.00474526f, 0.02913168f, -0.03383614f, -0.03164291f, -0.00580316f, 
    -0.04219077f, -0.01532489f, 0.00401383f, 0.03494167f, -0.01843231f, 0.05374421f, -0.06538799f, 0.05246412f, 
    -0.03080223f, -0.01653553f, 0.03034711f, -0.02259148f, -0.02684577f, 0.01194363f, 0.01430665f, -0.05424835f, 
    -0.02043664f, -0.04187183f, -0.05194306f, 0.06063711f, 0.01056561f, 0.02773594f, 0.05546772f, -0.06491943f, 
    -0.00994472f, -0.02227984f, -0.06656848f, 0.04631956f, 0.02086504f, -0.06143220f, -0.02081483f, 0.02348516f, 
    0.05711155f, -0.00603269f, -0.00647756f, -0.05931608f, -0.00914605f, -0.03220257f, 0.02027751f, -0.02381919f, 
    -0.04217332f, 0.00434025f, -0.00136206f, -0.01751959f, -0.01747242f, 0.00064262f, 0.04885937f, 0.03875563f, 
    -0.04063363f, 0.05289900f, -0.01912449f, -0.03558050f, -0.03153572f, -0.05918347f, 0.04736510f, -0.00461846f, 
    -0.02222411f, 0.04810924f, 0.02735829f, -0.07072946f, 0.01529547f, 0.03708939f, -0.01590403f, -0.01297716f, 
    0.00268687f, -0.00628935f, -0.01109417f, -0.01430272f, 0.00147938f, -0.01686585f, -0.05655033f, -0.04279603f, 
    0.04338376f, 0.05183237f, -0.01664296f, -0.04024922f, 0.05563297f, -0.04662777f, -0.04998403f, -0.04224321f, 
    -0.02103040f, 0.04199999f, -0.01787929f, 0.02325560f, 0.02544440f, 0.00534463f, -0.04064503f, -0.05721565f, 
    -0.05173254f, 0.03735290f, -0.05316741f, 0.03271874f, 0.00678314f, -0.03324093f, 0.00533309f, -0.04732259f, 
    0.01011872f, 0.02163660f, -0.05049808f, -0.03635101f, 0.00302448f, 0.03329841f, 0.03749422f, -0.04475528f, 
    -0.03170196f, 0.04125355f, 0.01143417f, -0.05493324f, 0.00445212f, -0.02713175f, -0.05932038f, -0.06131180f, 
    0.00886222f, -0.03816619f, 0.00767955f, 0.00528397f, 0.02491912f, 0.01317140f, -0.06702565f, 0.01308349f, 
    -0.05456203f, 0.01548754f, 0.04703742f, -0.02472431f, -0.00122273f, 0.03965815f, -0.06239625f, -0.00952710f, 
    -0.03184120f, 0.01129784f, -0.01695751f, 0.03364885f, 0.04642622f, -0.03185597f, -0.04430190f, -0.06904198f, 
    0.05277130f, -0.01477289f, 0.00650952f, 0.01958206f, 0.02031272f, 0.02532062f, 0.04590872f, 0.04800874f, 
    0.01187643f, -0.01192787f, -0.00497141f, -0.07417241f, 0.01524856f, -0.02877345f, 0.04146165f, 0.00892051f, 
    -0.04794905f, 0.02611783f, 0.05163867f, -0.00639561f, -0.05272437f, 0.01988724f, -0.05695825f, 0.00228385f, 
    -0.04509731f, -0.02633749f, 0.02580918f, -0.05029547f, 0.03154765f, 0.01776064f, 0.02887267f, -0.05334095f, 
    -0.04421335f, -0.00168636f, 0.01144272f, -0.06611154f, -0.01494487f, -0.07274191f, -0.00207233f, -0.04213832f, 
    -0.00598494f, -0.06836573f, -0.02410910f, -0.02798268f, 0.03084164f, -0.03675452f, -0.03919670f, -0.04894298f, 
    0.02037914f, 0.01741301f, 0.03478076f, -0.03572094f, -0.02512232f, 0.02766148f, -0.03786599f, 0.00909026f, 
    0.00971559f, 0.03357645f, -0.05594854f, 0.01707356f, 0.00552541f, -0.00030352f, -0.02910160f, -0.00303911f, 
    0.01060486f, 0.01499965f, 0.01052569f, 0.02702682f, -0.00377862f, -0.06161743f, 0.03272321f, 0.02877047f, 
    -0.06317388f, 0.00366736f, 0.01471584f, -0.01011523f, 0.01091415f, 0.00802208f, 0.00735577f, 0.03840455f, 
    0.02788516f, -0.00277488f, 0.00530472f, 0.03402681f, -0.03091233f, -0.06815464f, -0.02958822f, -0.02038013f, 
    -0.05673302f, -0.00476927f, -0.01210702f, 0.00173288f, -0.02190894f, -0.01135895f, -0.05284938f, -0.06534664f, 
    -0.06560381f, 0.01346922f, -0.02247278f, -0.06357142f, 0.00339870f, -0.00012597f, 0.02373371f, -0.03775065f, 
    0.04035738f, -0.02350924f, -0.01429224f, -0.02734238f, 0.02236909f, -0.04002489f, 0.03490998f, -0.04294924f, 
    -0.00522021f, 0.00086135f, -0.04872787f, 0.00483202f, 0.01270117f, 0.02555326f, 0.03175803f, -0.00742917f, 
    0.02395369f, 0.02414615f, -0.06593052f, -0.00307280f, 0.02711584f, -0.02261584f, -0.06454860f, -0.05512487f, 
    0.03192238f, 0.03669641f, -0.01048601f, 0.00161854f, -0.02022533f, 0.03421299f, -0.06889731f, 0.03945817f, 
    0.04480382f, -0.05234957f, 0.04547620f, -0.02605455f, 0.02591361f, 0.02664508f, -0.02224918f, -0.02861562f, 
    -0.05233236f, -0.01210430f, -0.05034126f, 0.00710800f, 0.00106371f, -0.03743466f, 0.02693594f, -0.05515860f, 
    -0.06851643f, 0.02465122f, -0.00154921f, 0.02511702f, -0.06432159f, -0.03610352f, -0.06254100f, -0.02698531f, 
    -0.04338995f, 0.00257203f, -0.01537288f, 0.04158064f, 0.04081602f, 0.03045521f, -0.05976544f, 0.03218369f, 
    0.03961259f, -0.02053645f, 0.05142152f, -0.02511953f, 0.03274528f, -0.02551058f, -0.05084615f, -0.01875691f, 
    -0.03950569f, 0.02439545f, 0.01917911f, -0.00644008f, -0.01079073f, 0.02794816f, -0.05804700f, 0.01916877f, 
    0.00693128f, -0.06433640f, -0.05331623f, 0.00160698f, -0.02587504f, -0.02885046f, -0.01047382f, 0.00043753f, 
    -0.01609515f, -0.03336888f, -0.01056287f, -0.02262096f, -0.06281484f, 0.00532256f, 0.01504303f, 0.02542445f, 
    -0.02511867f, -0.00411827f, 0.03816045f, -0.06736889f, -0.00772746f, 0.03862351f, -0.05326922f, -0.03141262f, 
    0.00314259f, -0.00070638f, 0.00691489f, 0.00814408f, -0.00061088f, 0.00699247f, -0.01263786f, -0.03756723f, 
    -0.02426064f, -0.05815645f, 0.03805895f, 0.02514197f, -0.00543245f, -0.02530578f, 0.04000866f, -0.02756581f, 
    -0.04167201f, 0.03325313f, -0.03794162f, -0.06809549f, -0.01799873f, 0.04074664f, -0.00670418f, -0.03813342f, 
    0.33501264f, 0.17110628f, -0.39855283f, 0.14633517f, 0.33838436f, 0.07112671f, 0.28494647f, -0.03378756f, 
    0.06558046f, -0.05010519f, 0.04967446f, -0.00213121f, 0.16207075f, 0.16259401f, 0.18592432f, 0.07587767f, 
    -0.14935678f, 0.02821906f, -0.51579654f, -0.05904482f, -0.08368249f, -0.44811538f, -0.06985053f, -0.10340917f, 
    -0.15029477f, 0.08984829f, 0.19412878f, -0.01651079f, 0.09529427f, -0.18137436f, -0.14101961f, 0.09416321f, 
    -0.01760868f, 0.22909346f, 0.09107666f, -0.01459739f, -0.40408590f, 0.04909761f, -0.69837105f, -0.20623279f, 
    0.11179566f, -0.20188358f, -0.06138195f, -0.01581065f, 0.23564002f, -0.06749850f, 0.14162475f, -0.21928683f, 
    0.11652689f, 0.09120893f, -0.14882721f, 0.02006747f, 0.00760315f, -0.11325020f, 0.01795571f, 0.19632234f, 
    0.18094748f, -0.22532965f, 0.07961251f, 0.02945394f, -0.10487141f, 0.15686794f, 0.06714417f, 0.24672583f, 
    0.27996442f, -0.01758705f, -0.29607734f, -0.29925168f, -0.07235908f, 0.13318056f, 0.18204948f, 0.19707023f, 
    0.20162375f, -0.09839456f, 0.38293666f, -0.00468535f, -0.13833280f, -0.22345747f, 0.07493713f, 0.01958894f, 
    0.13352713f, 0.25757483f, 0.08383811f, -0.21978424f, -0.32411557f, -0.21903849f, 0.08655641f, -0.14923468f, 
    -0.18838012f, 0.11506147f, -1.07662654f, -0.12359436f, 0.23589641f, 0.04601945f, 0.13031326f, 0.02113090f, 
    0.00326575f, 0.11574692f, 0.04302009f, 0.47046486f, 0.51893520f, -0.16231942f, 0.12257560f, 0.23239318f, 
    0.03935680f, -0.02487443f, -0.04446096f, -0.06116141f, -0.44634491f, -0.19528855f, -0.03073937f, 0.29491800f, 
    0.09592713f, 0.13932100f, -0.08058357f, 0.05525635f, -0.16521300f, 0.00878147f, 0.44236168f, -0.51067150f, 
    0.14681499f, 0.36706617f, 0.03906184f, -0.00808691f, -0.01012312f, -0.01270561f, -0.15149750f, -0.35175860f, 
    0.25118551f, 0.18004438f, 0.05081828f, -0.13845541f, 0.08416021f, -0.20706287f, -0.02074624f, 0.42489100f, 
    0.38229918f, 0.00317912f, 0.16675438f, 0.08052269f, 0.11011354f, 0.03677903f, -0.14512472f, 0.08128483f, 
    -0.27267641f, 0.08708573f, 0.14622240f, 0.07502846f, 0.17414682f, 0.01481059f, 0.04825695f, 0.06464042f, 
    0.09251074f, -0.38991389f, -0.09763560f, 0.22722058f, 0.11762980f, -0.14398144f, 0.10459402f, -0.28182378f, 
    0.11014136f, -0.01214972f, -0.09725938f, -0.14523336f, -0.13607538f, 0.11190545f, -0.07578224f, 0.04591741f, 
    0.16274275f, -0.31794167f, -0.17226690f, 0.77258706f, 0.20566203f, -0.10155158f, 0.00999049f, 0.18583852f, 
    -0.07763614f, -0.00635819f, 0.01644360f, -0.36531371f, -0.05214409f, -0.21199471f, 0.17380229f, 0.06806371f, 
    0.08596583f, 0.06411518f, 0.38935462f, 0.24806596f, 0.29616097f, -0.41208714f, -0.14815268f, -0.07467905f, 
    0.02671975f, -0.09971627f, -0.07429279f, 0.08304624f, 0.02993684f, -0.01494957f, 0.01807190f, 0.02696976f, 
    0.21951085f, -0.17417479f, 0.11852305f, -0.27137586f, 0.28023779f, -0.21071503f, 0.07488218f, -0.02827954f, 
    0.15518077f, -0.07762549f, 0.26453251f, -0.00917536f, 0.17609984f, 0.11498473f, 0.04886382f, 0.09864856f, 
    -0.37760180f, 0.26137924f, -0.01997556f, -0.58350587f, -0.15338837f, -0.03667898f, -0.15173964f, -0.02661617f, 
    0.03577119f, -0.49010441f, 0.18748355f, 0.03713733f, 0.15978111f, -0.05685824f, 0.15442984f, 0.01501988f, 
    -0.01569130f, 0.20391138f, 0.26080659f, 0.30905375f, 0.36505124f, 0.03788929f, -0.00964076f, -0.06321061f, 
    -0.08007781f, 0.01830332f, -0.03210362f, -0.61150706f, 0.03852907f, -0.11975323f, 0.09855461f, -0.00789605f, 
    0.16071102f, 0.28970757f, 0.14627473f, 0.03794290f, -0.19840890f, -0.02755720f, 0.07504988f, -0.46012840f, 
    0.14017607f, -0.11418523f, -0.06624866f, 0.01428182f, 0.29024309f, -0.16788398f, -0.01030008f, 0.27375352f, 
    -0.06197817f, -0.09328145f, -0.04591913f, -0.17389470f, 0.22394145f, 0.13484579f, 0.22222675f, 0.06331995f, 
    0.03564406f, -0.25869471f, -0.06192776f, 0.04808471f, 0.22167926f, -0.02760491f, 0.09320232f, -0.07055492f, 
    -0.28160045f, -0.16977753f, -0.13746385f, -0.22060528f, -0.08977499f, -0.05180082f, 0.02377673f, 0.11183488f, 
    0.04073645f, -0.04376608f, -0.02302804f, 0.02572047f, -0.04683793f, 0.04453855f, 0.00218824f, -0.03466520f, 
    0.00135887f, -0.03896382f, 0.02643763f, -0.01443186f, 0.04402405f, 0.00698410f, 0.00620568f, 0.00571807f, 
    -0.05894652f, 0.03731704f, 0.04066246f, 0.04620239f, -0.04896095f, -0.04297344f, -0.05557691f, 0.04981412f, 
    0.04929320f, -0.00369623f, -0.04521036f, 0.01291209f, -0.06489753f, -0.05656851f, -0.00122232f, -0.04596473f, 
    0.03432672f, 0.02752357f, -0.06232763f, 0.05196511f, -0.00763785f, -0.04591530f, 0.00033404f, 0.03700577f, 
    0.02590590f, -0.00411175f, -0.02213195f, -0.04267486f, 0.03946277f, -0.06241824f, -0.05702360f, -0.03746970f, 
    -0.00134977f, -0.05052300f, -0.00739307f, -0.04952138f, -0.04954953f, 0.00678836f, -0.04114886f, -0.05502803f, 
    -0.01875864f, 0.00039613f, 0.00920709f, -0.01012366f, -0.02838802f, 0.04825071f, -0.05524948f, -0.03711413f, 
    0.03872325f, 0.03867264f, 0.00851937f, 0.03545769f, -0.02001293f, 0.00738853f, 0.00417799f, 0.02742958f, 
    -0.00353990f, 0.03369505f, 0.02973632f, 0.02698615f, 0.01503995f, 0.02993628f, 0.02697306f, -0.03855001f, 
    -0.00681334f, 0.01387972f, -0.00644010f, 0.05113472f, -0.02954086f, -0.02275817f, 0.02905547f, 0.05071542f, 
    0.01245194f, -0.03640443f, -0.02754836f, -0.02160355f, -0.05398725f, -0.02917228f, 0.01731555f, -0.03042930f, 
    -0.02863866f, -0.01076514f, -0.05610794f, -0.00607944f, -0.03862631f, 0.02954134f, -0.02415079f, -0.04132216f, 
    0.00694760f, 0.02090582f, 0.00134937f, 0.00547670f, -0.00307319f, -0.02302359f, -0.00559132f, 0.01507016f, 
    0.00022604f, -0.03816716f, 0.02576411f, -0.00944858f, 0.04110260f, -0.02543677f, -0.02016438f, 0.01812668f, 
    -0.00692583f, 0.00306441f, 0.03094901f, -0.00123821f, 0.02980005f, -0.00620721f, -0.01178972f, -0.03410484f, 
    0.05522504f, 0.00175309f, -0.04526432f, -0.02552484f, -0.06133292f, 0.02451037f, 0.03115544f, -0.00335550f, 
    -0.02410180f, 0.03978705f, -0.02003707f, -0.04487845f, 0.04258887f, -0.00561265f, 0.04938781f, 0.03074376f, 
    -0.04514630f, -0.00654127f, 0.00486142f, 0.03093374f, -0.04057316f, 0.00273955f, -0.04832812f, -0.01939338f, 
    0.00594037f, -0.01535957f, -0.05608305f, -0.03011877f, 0.03955854f, -0.04610160f, -0.02484651f, -0.02779998f, 
    -0.00534428f, 0.01322033f, -0.04864721f, 0.04571149f, -0.01222206f, -0.00213104f, 0.04832875f, -0.01969088f, 
    -0.01312534f, -0.00715894f, -0.03610155f, -0.04026497f, 0.00285293f, 0.01192435f, -0.06569538f, 0.03763574f, 
    0.01654197f, -0.02814176f, 0.05533957f, 0.00553910f, 0.00130107f, -0.05774660f, -0.05589610f, 0.00494117f, 
    -0.01724308f, -0.03521905f, -0.06110889f, -0.03416223f, 0.00232531f, 0.03273426f, 0.03703130f, -0.02742001f, 
    -0.01955439f, -0.06226553f, 0.00118999f, -0.02842969f, -0.05480443f, 0.02151882f, 0.02955299f, 0.04760136f, 
    -0.05130645f, -0.01406527f, -0.05018650f, -0.02860752f, -0.05818919f, -0.04195861f, 0.05551531f, -0.00351823f, 
    0.01772136f, -0.04854495f, 0.01587193f, -0.05567278f, -0.04780680f, -0.02813997f, -0.05105627f, 0.04307646f, 
    0.04431750f, -0.03745283f, 0.02677159f, -0.05948807f, 0.04263893f, 0.02500973f, 0.01460674f, 0.01756133f, 
    0.03046188f, 0.01043181f, 0.01978500f, -0.03671964f, -0.01848073f, -0.02628308f, -0.03095719f, -0.03825505f, 
    -0.00826096f, 0.02362090f, -0.04628929f, 0.02740019f, 0.05107745f, -0.00948649f, 0.02490707f, -0.04707411f, 
    0.04485581f, 0.03815441f, -0.05137824f, 0.03257780f, -0.03915736f, 0.03626784f, 0.04662818f, 0.03361244f, 
    0.00600887f, -0.01008080f, 0.02790699f, -0.04198710f, -0.03064088f, -0.02976221f, 0.04137994f, -0.04929788f, 
    0.05031324f, 0.01527914f, -0.05007793f, 0.04816357f, -0.00278345f, 0.02580318f, -0.02480712f, -0.05884880f, 
    0.04802580f, -0.03752538f, -0.06436370f, 0.02919520f, 0.03462871f, -0.02426264f, 0.00475040f, 0.00937225f, 
    0.01702978f, 0.02056059f, -0.06107404f, 0.02772131f, 0.00025427f, -0.00134304f, 0.02911536f, 0.03797945f, 
    -0.02162636f, 0.01520186f, -0.00677925f, -0.01354024f, -0.05990119f, 0.04545931f, 0.00880137f, -0.03207549f, 
    -0.56366289f, 0.00823583f, 0.23715845f, -0.13418719f, 0.26013613f, 0.12823576f, -0.05350206f, -0.13495177f, 
    0.04723747f, 0.70521623f, 0.22025685f, 0.13412467f, -0.09268645f, -0.07172354f, -0.03593387f, 0.11011183f, 
    0.22869265f, -0.06443089f, -0.02224223f, -0.00462446f, 0.42018971f, 0.03544646f, 0.14937261f, -0.03154264f, 
    0.01986651f, -0.00318061f, 0.12955622f, 0.52231371f, -0.01425887f, 0.30076385f, 0.02380056f, 0.04431140f, 
    0.02496879f, 0.14652252f, 0.24794658f, 0.02730888f, -0.39036763f, -0.05179954f, -0.70788932f, 0.08781224f, 
    0.04583569f, 0.17143643f, -0.24112163f, 0.27874443f, -0.14864758f, -0.32630414f, 0.17573732f, 0.20372690f, 
    0.16401222f, 0.13406028f, 0.23277819f, 0.13984554f, -0.00566357f, 0.08495928f, 0.33957416f, 0.03309387f, 
    -0.24881995f, 0.21627617f, 0.12449443f, 0.10117637f, 0.09323642f, 0.07226996f, 0.15809985f, -0.27420574f, 
    0.01087514f, -0.01904233f, -0.09178389f, 0.20521595f, -0.00997494f, -0.18548140f, 0.13808841f, -0.06258751f, 
    -0.24571915f, -0.12730019f, -0.14710495f, 0.08497445f, 0.05215620f, 0.03950607f, 0.12813026f, 0.08797783f, 
    0.07235678f, 0.59485871f, 0.18095346f, 0.10640389f, -0.12775938f, 0.06027460f, 0.11620122f, 0.07484696f, 
    0.08071940f, 0.02837534f, -0.78234732f, -0.30073687f, 0.21704675f, -0.20945410f, -0.01098506f, -0.12608863f, 
    0.17233625f, 0.08307352f, -0.04722169f, -0.36689675f, 0.09725569f, -0.27051148f, 0.14607321f, -0.04303376f, 
    -0.02569650f, -0.01355636f, -0.17217910f, -0.19636612f, 0.19727595f, -0.18970069f, -0.27099714f, -0.03023913f, 
    0.14650136f, 0.11568103f, 0.03704825f, -0.08007921f, -0.09753899f, 0.22663099f, -0.04896866f, -0.64032465f, 
    -0.02936252f, -0.08905247f, 0.05859611f, -0.09231300f, -0.10721727f, -0.35311714f, 0.12886354f, -0.00207300f, 
    -0.06223304f, -0.15813079f, 0.16508661f, 0.09212948f, 0.01344334f, 0.12465696f, -0.10570325f, -0.12605029f, 
    -0.19091308f, -0.37840202f, 0.04395826f, -0.05278911f, 0.04008780f, -0.12376843f, -0.01457428f, -0.17132287f, 
    0.36650702f, -0.12008844f, -0.11370152f, -0.15294075f, -0.26743463f, -0.27385813f, -0.05637862f, -0.00081443f, 
    -0.13551591f, -0.27724701f, 0.09131509f, 0.39909616f, 0.04981794f, -0.07422150f, -0.08000679f, 0.03848442f, 
    -0.02044830f, -0.08443770f, -0.27741596f, -0.27600801f, 0.02022162f, -0.13951683f, -0.02421606f, 0.02367306f, 
    0.09805301f, -0.05752789f, -0.04648400f, -0.74371272f, -0.17576632f, 0.27152520f, 0.14985244f, -0.24751918f, 
    -0.32042825f, -0.18023378f, 0.21898450f, -0.08092058f, -0.27534804f, 0.06031615f, -0.10823423f, -0.08812210f, 
    0.09757123f, 0.04281467f, 0.03846365f, 0.11293013f, 0.00291311f, 0.30157626f, 0.14799023f, 0.17558776f, 
    0.23256539f, 0.10859365f, -0.08155922f, -0.01009383f, -0.00260449f, 0.05261953f, 0.46669656f, 0.18978710f, 
    -0.01878211f, 0.21568489f, 0.01995897f, -0.06208901f, 0.11234327f, 0.03035913f, 0.02244614f, 0.39608181f, 
    -0.02415165f, 0.14625400f, -0.00682579f, 0.16538706f, -0.15664130f, 0.04210712f, 0.01104973f, -0.16874889f, 
    0.16933675f, 0.11643399f, 0.41629621f, -0.14611907f, -0.05971257f, -0.01246021f, -0.04484000f, -0.05334135f, 
    -0.05256353f, -0.13606998f, -0.23071700f, -0.18310106f, -0.15977098f, 0.01497928f, -0.02113025f, -0.16849613f, 
    0.23029383f, 0.20204958f, -0.10262012f, 0.15377204f, 0.22668806f, -0.11811552f, 0.04550835f, -0.07066089f, 
    0.15217285f, 0.01459962f, 0.08321039f, 0.13188411f, 0.30723730f, -0.43180555f, -0.14500423f, 0.18167852f, 
    -0.11882671f, 0.20257032f, 0.23107181f, -0.05551682f, 0.19801852f, 0.06485864f, -0.02277335f, 0.01675330f, 
    0.06752215f, 0.21124692f, 0.12103769f, -0.09916490f, 0.04755094f, -0.35667640f, 0.08894961f, -0.19758201f, 
    0.10277740f, -0.09144758f, -0.02170951f, 0.04866657f, -0.09328964f, -0.03247555f, 0.22786641f, 0.30842933f, 
    0.00662112f, 0.01762860f, -0.01079041f, -0.02097600f, -0.08616803f, 0.12026215f, 0.08429319f, 0.69756740f, 
    0.29436547f, -0.16265863f, 0.15648441f, -0.15848118f, 0.16908798f, 0.20146404f, 0.04965088f, 0.24987850f, 
    0.06148576f, -0.01902438f, 0.04060809f, -0.18684432f, 0.06879350f, 0.09855334f, -0.14788993f, 0.05165846f, 
    0.10831141f, 0.14331685f, 0.13105136f, 0.14173551f, 0.33858994f, 0.04086751f, -0.03413863f, -0.02743505f, 
    -0.19299725f, 0.08420423f, 0.04427036f, -0.12195650f, -0.36427262f, 0.05791953f, -0.08395186f, -0.13056631f, 
    -0.23091666f, 0.05598641f, 0.01933204f, 0.38655022f, 0.08429377f, 0.23070073f, 0.24730802f, -0.03782694f, 
    -0.05386337f, 0.00897304f, -0.03377445f, 0.04903964f, -0.22465812f, 0.34609723f, 0.10790393f, 0.08448514f, 
    -0.30479798f, -0.06240725f, -0.01179521f, 0.08738016f, 0.08536803f, 0.23252741f, 0.21243329f, 0.14221539f, 
    -0.05274952f, -0.12361748f, -0.16307250f, -0.09516965f, 0.21664566f, -0.09649825f, -0.50120115f, -0.73091787f, 
    -0.31001532f, 0.07975715f, -0.07702993f, -0.01088275f, 0.23562536f, -0.17024192f, -0.02250219f, 0.27939776f, 
    0.03593551f, 0.34653294f, 0.01307558f, -0.01046091f, -0.11849201f, 0.30308253f, 0.07817542f, -0.13435544f, 
    0.12140880f, 0.41724971f, 0.23717745f, -0.09076405f, -0.07394645f, 0.21682429f, 0.13645566f, -0.23739918f, 
    -0.19539899f, -0.27628717f, -0.06853331f, 0.09340980f, 0.42221579f, -0.06674375f, 0.03302128f, -0.10871139f, 
    0.00320115f, -0.16321947f, 0.00120460f, -0.39264098f, -0.03777494f, -0.10033531f, -0.19105574f, 0.05585889f, 
    -0.01756091f, -0.27508351f, -0.00787842f, 0.16546272f, 0.04145664f, 0.20024697f, -0.30893975f, 0.12440617f, 
    0.01705111f, -0.20503230f, 0.04258777f, -0.12974741f, -0.33899295f, -0.08641363f, -0.25095350f, -0.02656857f, 
    0.16280189f, -0.03703623f, -0.04746084f, 0.03557751f, 0.02958139f, -0.10167055f, -0.01658485f, 0.29983747f, 
    0.01536518f, -0.33353579f, 0.13012812f, 0.10397992f, 0.27119428f, -0.05388232f, -0.73250687f, 0.02059178f, 
    -0.11726840f, 0.04569349f, 0.10535586f, 0.00010767f, 0.00086818f, 0.00095601f, 0.10088919f, -0.27419335f, 
    -0.13817818f, -0.04190600f, 0.07081773f, -0.05938428f, 0.21786538f, 0.03031886f, 0.13681401f, -0.09711024f, 
    0.14318998f, 0.08969377f, 0.32164305f, 0.02903362f, 0.03424974f, -0.05626067f, 0.08336698f, -0.07310645f, 
    -0.11497720f, 0.03252404f, 0.14885500f, 0.20252338f, -0.10474014f, -0.10052146f, -0.11774004f, 0.13805020f, 
    0.06494855f, 0.06914575f, -0.14197160f, -0.13934384f, -0.00569895f, 0.02121244f, -0.24516258f, -0.05225261f, 
    0.09663875f, -0.06469256f, -0.09280665f, -0.01784076f, -0.06611446f, -0.34004164f, -0.08768848f, -0.07834445f, 
    0.02894916f, -0.02205884f, 0.03008131f, -0.18272710f, 0.00831995f, -0.00037541f, -0.20654681f, 0.10777686f, 
    0.03309279f, -0.24802911f, 0.08229847f, 0.26265872f, 0.07652184f, -0.23837294f, 0.16474839f, -0.27664337f, 
    0.11985492f, -0.06233018f, 0.29270998f, -0.05309323f, 0.01012226f, 0.16202427f, -0.37644908f, -0.17072111f, 
    0.06229448f, 0.01568085f, 0.02505974f, -0.10612775f, 0.24160254f, -0.04735945f, 0.05392632f, 0.21143350f, 
    0.07633854f, 0.00468585f, 0.02869106f, -0.04027223f, 0.08605614f, 0.26575407f, -0.11026931f, 0.18083428f, 
    -0.11796240f, 0.16985376f, -0.37422144f, -0.05746538f, 0.05024064f, -0.24183699f, -0.02109839f, 0.00869829f, 
    0.12086519f, 0.00421983f, -0.17123383f, 0.11593345f, -0.32154387f, 0.34664759f, 0.10129722f, 0.26884404f, 
    -0.08019237f, -0.13543378f, 0.29228160f, 0.17068419f, 0.01804678f, -0.07201286f, -0.02850130f, 0.13814388f, 
    -0.08962565f, -0.07061992f, -0.23472309f, 0.01421916f, 0.26898295f, 0.44029525f, 0.00968819f, -0.08109531f, 
    -0.10398098f, 0.04751313f, 0.14715861f, -0.05311105f, 0.29480213f, -0.19006732f, 0.11278715f, 0.08621673f, 
    -0.02747000f, 0.01189557f, 0.06288509f, 0.03763806f, 0.17468032f, 0.07395623f, 0.39710927f, -0.06433866f, 
    -0.11564020f, -0.05509444f, 0.09309644f, 0.25392783f, 0.00200639f, 0.07343247f, -0.15805976f, -0.08177933f, 
    0.32336602f, 0.18742509f, 0.01610683f, -0.02346784f, -0.18213241f, 0.09532368f, 0.12646446f, -0.25819981f, 
    -0.16675036f, -0.15167923f, 0.38803709f, -0.17726295f, 0.10900229f, -0.13033706f, 0.05961146f, -0.18866822f, 
    -0.05689504f, -0.01970655f, -0.04143767f, 0.04088852f, -0.02024530f, 0.03572056f, -0.06110736f, 0.03159651f, 
    0.04291498f, -0.05720469f, -0.04142863f, 0.04520207f, -0.02324405f, -0.00006135f, -0.05087665f, 0.00376237f, 
    -0.00203327f, -0.02333159f, -0.04437512f, -0.03516614f, 0.02391395f, -0.05703555f, 0.04375446f, 0.01630849f, 
    0.00237210f, -0.02843513f, -0.00983901f, -0.04124253f, 0.03053912f, 0.02327541f, 0.04701251f, 0.02484494f, 
    -0.01310113f, -0.04994571f, -0.01713385f, -0.05448406f, 0.02434256f, 0.00101345f, 0.01801455f, 0.01653920f, 
    -0.00183213f, -0.03081378f, -0.06643941f, -0.06021056f, 0.04861952f, -0.05413471f, -0.06471009f, -0.04441837f, 
    0.00531320f, -0.01160616f, 0.01889174f, -0.02970953f, -0.00719129f, -0.05595125f, 0.03448833f, -0.05968865f, 
    0.05190552f, -0.02483375f, 0.00567134f, 0.04216161f, 0.02671611f, 0.01679592f, -0.01627244f, 0.04176944f, 
    0.04381712f, -0.00763690f, 0.02715684f, -0.00231852f, -0.05493404f, -0.05281151f, -0.06220414f, 0.02797501f, 
    -0.03470409f, -0.05209705f, -0.02541499f, -0.01972066f, -0.01425535f, -0.01347698f, -0.02716805f, -0.00972993f, 
    -0.03980226f, -0.01931850f, -0.04932745f, 0.03128753f, -0.03648512f, -0.06119959f, -0.01893340f, -0.01561964f, 
    -0.00846969f, -0.06250499f, 0.03950189f, -0.05699180f, -0.01159308f, 0.00111052f, 0.01268629f, -0.00296655f, 
    0.00550565f, 0.05591230f, 0.04568912f, -0.04294293f, -0.02770447f, -0.01983526f, 0.02996929f, 0.04455592f, 
    0.02156696f, 0.01215303f, 0.01783995f, -0.05970060f, -0.00248880f, -0.03417604f, 0.00366737f, 0.03957302f, 
    -0.05048068f, -0.02587000f, -0.00762821f, -0.00248434f, 0.01879417f, -0.01888939f, 0.03778882f, 0.01340168f, 
    -0.02986078f, 0.02371025f, -0.02150246f, -0.06102954f, -0.04320651f, -0.05983952f, -0.04669183f, 0.01448749f, 
    0.05116058f, 0.00446941f, -0.02780991f, 0.05214521f, 0.01751455f, 0.01018876f, 0.05065871f, -0.04474231f, 
    -0.06318913f, -0.01255693f, -0.00427499f, -0.00829164f, 0.04336191f, 0.03449088f, -0.01542296f, -0.04675657f, 
    0.02421629f, -0.03551861f, 0.00594553f, -0.05436132f, 0.01135043f, -0.01744071f, 0.02991119f, -0.01903404f, 
    -0.03450814f, -0.05827409f, -0.03510731f, -0.02508478f, -0.03650799f, 0.00825126f, 0.02687521f, 0.02996734f, 
    -0.03371055f, 0.00862756f, 0.02347454f, -0.03518006f, 0.02110798f, -0.02190293f, -0.00528456f, -0.00353761f, 
    -0.06132878f, -0.06409246f, 0.01567245f, 0.03219351f, -0.03814064f, -0.05356717f, -0.03357583f, -0.05724919f, 
    -0.00455992f, 0.02442795f, 0.03186272f, -0.00274315f, 0.00884038f, -0.00658819f, -0.02977215f, 0.01307134f, 
    -0.03658121f, -0.04089234f, -0.06336571f, 0.01669728f, -0.01456844f, -0.05251163f, -0.03668699f, 0.02431364f, 
    -0.04491484f, -0.02943102f, -0.04045291f, 0.01398209f, 0.04661262f, -0.05356997f, 0.02032438f, -0.01490332f, 
    0.01099744f, -0.00468792f, -0.06004423f, -0.01502845f, -0.00556105f, 0.00867701f, 0.02010984f, 0.00979972f, 
    0.02230711f, 0.03701982f, -0.05278349f, -0.02584480f, 0.02462914f, 0.03780339f, -0.02039481f, -0.06173781f, 
    0.02117866f, -0.06614942f, -0.02814311f, 0.00319795f, 0.04601868f, 0.03820559f, 0.03210825f, 0.03125837f, 
    0.00055181f, 0.04451470f, -0.04052949f, -0.01476108f, -0.06125262f, -0.00962284f, -0.02551121f, -0.03959155f, 
    0.01533414f, 0.04719940f, -0.04405113f, -0.05971663f, -0.04627109f, -0.02658409f, -0.03386050f, 0.02677394f, 
    -0.04929671f, -0.00094633f, -0.01115918f, 0.02361559f, 0.02865722f, 0.02693589f, 0.04317176f, 0.02733949f, 
    0.01754455f, -0.03651804f, -0.04591634f, 0.02724623f, -0.03180899f, -0.05678897f, 0.01672017f, -0.06314171f, 
    -0.01788147f, -0.04755142f, 0.04362051f, 0.02606819f, -0.02748377f, 0.01482781f, 0.01318124f, 0.04253794f, 
    -0.04619760f, 0.05031695f, 0.04896504f, -0.00151477f, 0.02539839f, -0.03785188f, -0.04979298f, -0.02079780f, 
    0.03172432f, -0.00740669f, -0.04205419f, -0.04071759f, -0.05118345f, -0.01014466f, 0.04083401f, -0.01552298f, 
    -0.00623920f, 0.00254379f, -0.02699608f, 0.00440177f, -0.04283582f, 0.05110488f, -0.05786046f, 0.03869244f, 
    0.31218040f, 0.03368725f, -0.22257365f, 0.06881429f, 0.18259850f, -0.10371076f, 0.14967902f, 0.12696439f, 
    -0.03185678f, -0.04654119f, -0.11119351f, 0.26793373f, -0.05895987f, -0.09377082f, -0.00367502f, -0.14930953f, 
    0.04991875f, -0.02203277f, 0.20028393f, -0.47663659f, -0.29300493f, -0.02833299f, 0.05005535f, -0.07074434f, 
    -0.15163481f, -0.15385193f, -0.10965551f, 0.07463524f, 0.24567124f, 0.03435986f, 0.00324299f, -0.08521984f, 
    0.06275355f, -0.19104406f, 0.17595531f, -0.14323075f, 0.13886169f, -0.09880549f, 0.09355914f, 0.09042091f, 
    -0.03198855f, 0.27770057f, -0.27675185f, 0.05813237f, 0.19124921f, -0.51630747f, 0.25793600f, -0.05979404f, 
    0.04848571f, -0.10065135f, -0.15026069f, 0.06654988f, -0.01894492f, -0.06707451f, 0.24399151f, -0.13549224f, 
    -0.04175227f, 0.09429344f, -0.10329882f, -0.05486153f, -0.05059116f, 0.22726144f, 0.13512568f, 0.44267023f, 
    -0.34005594f, 0.27511913f, 0.18947031f, 0.15320499f, -0.12698862f, 0.18591844f, 0.29562622f, 0.18183330f, 
    0.31766510f, -0.28469443f, -0.02434011f, 0.00181897f, -0.19928910f, -0.07337136f, -0.21290641f, -0.20644842f, 
    -0.35103324f, 0.14760751f, -0.08534009f, 0.06019896f, -0.18417247f, -0.16846022f, 0.01984964f, 0.29519844f, 
    -0.06780156f, -0.00867768f, -0.84705698f, 0.04568072f, 0.04128132f, -0.17507271f, -0.00221613f, -0.07898703f, 
    -0.11607797f, 0.06479041f, -0.02167956f, 0.26008743f, 0.37869793f, -0.29296768f, -0.11546983f, 0.16485608f, 
    -0.17410527f, -0.00758863f, 0.08399797f, -0.02973361f, 0.09095611f, -0.48420265f, -0.09556078f, -0.03800581f, 
    -0.01215148f, 0.35175484f, 0.16178595f, -0.00006673f, -0.07277038f, 0.08307252f, -0.16755466f, -0.08238620f, 
    0.01048119f, 0.11550810f, 0.11514923f, 0.21896365f, 0.03456515f, -0.00310587f, -0.11278272f, -0.00844369f, 
    0.17347766f, 0.25598112f, 0.33711764f, -0.23721631f, 0.27127939f, -0.00705582f, 0.00713636f, 0.15809290f, 
    -0.32730204f, -0.09862347f, 0.05025436f, 0.09496370f, -0.17780805f, 0.06721734f, -0.02585703f, 0.07933007f, 
    -0.07556510f, 0.48477328f, -0.11108668f, -0.07262772f, 0.26318592f, 0.07314222f, -0.01019770f, -0.05996856f, 
    0.03837240f, 0.23083928f, 0.18119736f, -0.09800794f, -0.03691048f, -0.09504376f, -0.04076575f, 0.00575261f, 
    0.17863791f, 0.18772359f, 0.47857910f, -0.11345638f, -0.24637231f, 0.08983943f, 0.04471589f, 0.01622182f, 
    0.28311142f, -0.05030700f, -0.05516728f, 0.60242051f, -0.52144271f, -0.45305446f, -0.05377318f, 0.15414448f, 
    0.26082486f, 0.07334935f, -0.01653538f, -0.20660847f, -0.61434710f, -0.16956633f, 0.19246224f, -0.19419377f, 
    0.08866263f, 0.05221713f, 0.09864185f, 0.10082761f, -0.03082276f, -0.06089422f, -0.35295635f, -0.03145252f, 
    -0.01947862f, 0.23842677f, 0.06896170f, -0.08406208f, 0.10896516f, 0.01034692f, -0.10410081f, -0.15533118f, 
    0.29465851f, -0.11735970f, -0.00334202f, -0.16608486f, 0.11671805f, 0.01998416f, 0.08197237f, -0.39877802f, 
    -0.04986219f, 0.17558753f, -0.10009184f, -0.12418094f, -0.11905705f, 0.04308895f, -0.07449572f, -0.14120789f, 
    0.14399862f, -0.54265052f, -0.07379691f, -0.11501981f, -0.10241349f, 0.03506143f, 0.07921947f, -0.16855685f, 
    0.14853255f, -0.86746180f, 0.03275013f, -0.23801136f, -0.02937320f, 0.17807777f, -0.09225406f, -0.13715468f, 
    -0.10186335f, 0.13549927f, -0.08653370f, 0.26945099f, 0.04211573f, -0.11225910f, -0.21003756f, 0.05368576f, 
    0.06863797f, 0.08139866f, -0.04153935f, -0.23411651f, 0.36004767f, 0.00600014f, 0.05358081f, -0.18303479f, 
    0.11106468f, -0.10981012f, -0.07136195f, 0.25949645f, -0.28676689f, 0.11054265f, 0.20397581f, -0.09330438f, 
    0.07051389f, -0.10594426f, 0.12761991f, -0.07103313f, -0.00729599f, -0.22523192f, 0.20927458f, -0.05358062f, 
    -0.27691585f, 0.13453722f, 0.04581820f, -0.00481660f, 0.06543276f, -0.13877161f, 0.08857438f, -0.00798726f, 
    0.19964603f, -0.08007652f, 0.09337268f, -0.10598769f, 0.13608070f, 0.05613381f, -0.04765837f, -0.14974749f, 
    0.00251779f, 0.04521602f, 0.07209983f, -0.13421497f, -0.07603528f, -0.00556706f, -0.07815558f, 0.11811198f, 
    0.02493507f, -0.03103671f, 0.03692566f, -0.02188125f, 0.00523065f, 0.04352558f, 0.04546084f, -0.05991916f, 
    -0.05279646f, -0.03182435f, -0.05390498f, -0.06152798f, 0.03780186f, -0.01315217f, 0.01448901f, -0.02029185f, 
    0.05198609f, -0.03236757f, -0.04151672f, 0.02491944f, -0.04234863f, -0.03635903f, -0.04104173f, 0.01753949f, 
    -0.06249589f, -0.03817051f, 0.02235502f, 0.00086681f, -0.03662945f, 0.02204329f, -0.05472920f, 0.02646711f, 
    -0.04026581f, 0.01494203f, -0.06332443f, -0.03549535f, -0.02289692f, -0.05268509f, 0.01181132f, -0.00768422f, 
    -0.04242659f, 0.04563358f, -0.02941766f, -0.00172650f, -0.00318026f, 0.03792047f, -0.02975551f, -0.05480621f, 
    0.02071990f, 0.05573575f, 0.00439748f, 0.00543971f, 0.01287268f, -0.02443757f, -0.01063384f, 0.04031433f, 
    -0.01018608f, 0.03826803f, -0.03300487f, -0.03716150f, -0.03757091f, -0.04175780f, -0.04684907f, -0.01830587f, 
    -0.01714509f, -0.01765834f, 0.01978132f, 0.04300142f, -0.05962384f, 0.01180386f, -0.01991915f, 0.03321487f, 
    -0.02679220f, 0.03288418f, -0.02981637f, 0.00576449f, 0.00109513f, -0.04125439f, -0.02887560f, -0.05378839f, 
    -0.02430796f, -0.05868747f, -0.01987897f, -0.01305177f, -0.00032308f, -0.02984430f, -0.06238735f, 0.03351853f, 
    0.02413672f, 0.00717505f, 0.05309603f, -0.02668500f, 0.01813641f, 0.00835389f, -0.04393169f, -0.03801435f, 
    -0.00557059f, 0.02335128f, -0.00934010f, -0.02519066f, -0.03028879f, 0.01781834f, 0.00810210f, 0.04366794f, 
    0.02125592f, 0.03191686f, 0.02849621f, 0.05042373f, -0.05098087f, -0.02254139f, -0.02792806f, -0.03460993f, 
    -0.01339760f, 0.02694974f, 0.01827196f, 0.00333340f, -0.02462097f, -0.00550830f, 0.01426449f, 0.00265810f, 
    -0.03912815f, 0.03611607f, -0.01700281f, -0.02535599f, 0.01670729f, 0.03956690f, -0.00203185f, 0.02891511f, 
    0.02998035f, 0.05199788f, 0.00848135f, -0.01077585f, -0.02461878f, -0.00019797f, -0.04135193f, -0.01737334f, 
    0.00199410f, 0.02454279f, 0.00097147f, 0.00930424f, 0.02163579f, -0.00695219f, 0.04278263f, -0.05242439f, 
    -0.05537098f, 0.00212215f, -0.05888797f, 0.05089414f, 0.02400966f, 0.04888152f, 0.02952910f, 0.04169067f, 
    -0.02628590f, -0.03776555f, -0.05963247f, -0.03621873f, -0.00545351f, 0.00337854f, -0.04363343f, 0.00518946f, 
    -0.01163446f, -0.02142752f, 0.01466319f, -0.00554200f, 0.04585650f, 0.01781089f, 0.03179478f, 0.02225613f, 
    0.01154769f, 0.02419098f, -0.00980954f, 0.00324899f, -0.02538693f, 0.01082736f, 0.03922248f, -0.01079915f, 
    -0.00710654f, -0.01510953f, 0.04489245f, -0.05772216f, 0.03323549f, -0.03138813f, 0.01018033f, 0.01291444f, 
    0.05506590f, -0.05424887f, 0.01263016f, -0.04005633f, -0.00559878f, 0.01201030f, -0.03878328f, -0.01883941f, 
    0.01956435f, -0.04793739f, 0.03729010f, 0.04698944f, -0.04493791f, 0.01110216f, 0.00682635f, 0.03166164f, 
    0.00984842f, 0.04959325f, -0.02569523f, 0.04753742f, -0.02924703f, 0.04169528f, 0.02535954f, 0.00690130f, 
    0.01402152f, -0.06429815f, -0.02631189f, -0.00470027f, -0.04082382f, -0.02954953f, -0.05892847f, -0.01131340f, 
    0.05775900f, 0.03897411f, -0.05311218f, 0.02191720f, -0.01554702f, -0.00490982f, -0.02806036f, 0.01873056f, 
    0.02122045f, 0.02982497f, -0.01161002f, 0.04034796f, 0.01406620f, -0.02989225f, 0.04501829f, 0.01754765f, 
    -0.00970185f, -0.06309636f, -0.02768945f, -0.02209466f, 0.00034456f, -0.01053730f, -0.05804183f, 0.04014631f, 
    0.00352163f, -0.05256070f, -0.02070042f, -0.04692921f, 0.03854657f, 0.01505840f, 0.02367257f, 0.04769129f, 
    -0.02039684f, -0.03477637f, -0.04812770f, -0.04726861f, -0.01408888f, -0.01105798f, 0.01121177f, -0.01879979f, 
    0.00881714f, -0.01509940f, -0.00541442f, 0.02095009f, -0.05007259f, -0.01883971f, -0.04210227f, -0.06135308f, 
    -0.00471704f, -0.02841336f, 0.03223331f, -0.02442537f, -0.05463902f, 0.04239807f, -0.02189779f, -0.02247727f, 
    -0.06260283f, -0.04642643f, 0.04838157f, 0.04385924f, -0.03847293f, 0.01854798f, -0.02488101f, 0.02338180f, 
    -0.04565452f, -0.04653058f, 0.00285243f, -0.04669461f, -0.02612065f, -0.02332710f, -0.01230218f, 0.00121140f, 
    0.03744540f, 0.02482756f, -0.05465117f, -0.04481214f, -0.05180927f, -0.05165131f, 0.03194677f, -0.02218536f, 
    0.02393621f, 0.03417636f, -0.03903666f, -0.01052075f, 0.00307768f, -0.00698424f, -0.00213312f, 0.02484652f, 
    0.02954692f, 0.05360509f, 0.00048029f, 0.02201463f, -0.04009054f, -0.05248504f, 0.01725462f, -0.01939627f, 
    0.00405869f, -0.00307914f, 0.03993639f, -0.05051342f, -0.02011737f, -0.04611905f, -0.04292878f, 0.05175132f, 
    -0.04347005f, 0.00149661f, -0.02842678f, -0.05120981f, 0.00260489f, 0.01875730f, 0.00570169f, -0.03784022f, 
    -0.06372165f, -0.06491805f, -0.05442490f, -0.00073979f, -0.05973336f, 0.01936968f, -0.00323004f, -0.02919905f, 
    0.03462909f, 0.02083125f, 0.01627453f, -0.01122119f, 0.01451398f, -0.01757103f, -0.03654425f, -0.02205503f, 
    -0.05673684f, -0.02358939f, -0.00195610f, -0.05931578f, -0.01238180f, 0.04562505f, 0.00316136f, 0.01714690f, 
    0.04827839f, 0.03071149f, -0.04351112f, 0.02650468f, 0.00661886f, -0.01780588f, 0.01140915f, 0.02834663f, 
    -0.05874260f, -0.01449790f, 0.04021112f, -0.01198231f, 0.01441607f, -0.04007788f, 0.03138947f, -0.05230214f, 
    0.02936055f, -0.05019195f, 0.03948813f, 0.04662579f, -0.04084144f, -0.04499188f, 0.02465806f, -0.04234803f, 
    0.01322323f, -0.04705744f, 0.04057458f, -0.03088866f, -0.04712746f, 0.04149902f, 0.01982561f, -0.00884658f, 
    0.02698109f, 0.01654920f, 0.05434622f, -0.01172627f, -0.01608308f, -0.00848377f, 0.00289685f, -0.01065567f, 
    -0.03804403f, -0.01411144f, 0.00150308f, 0.03403894f, 0.02549095f, -0.01806457f, -0.03888893f, 0.05078172f, 
    -0.00084532f, 0.00358183f, 0.00592595f, -0.05908899f, -0.00390495f, 0.04088258f, 0.02583356f, 0.00865410f, 
    0.04907230f, 0.00925227f, 0.02170954f, -0.04540460f, 0.00870769f, 0.02907514f, -0.04419580f, -0.04568920f, 
    -0.01115897f, 0.01198160f, -0.03421137f, 0.00459760f, 0.02448661f, 0.01940840f, -0.03782174f, -0.00237005f, 
    0.03114849f, -0.03935537f, 0.01846806f, -0.03294440f, -0.06316590f, -0.05181181f, -0.05603696f, 0.01047484f, 
    0.04621864f, -0.00292364f, -0.01076728f, -0.04627412f, -0.05297556f, -0.00363098f, -0.04493229f, 0.05136812f, 
    -0.06843022f, 0.03232962f, 0.03453133f, -0.01420736f, -0.06245904f, 0.00960754f, 0.03952027f, 0.03695169f, 
    0.01508823f, -0.04306816f, 0.00360236f, -0.04764336f, -0.02952280f, 0.04756187f, -0.03062036f, -0.06936901f, 
    -0.00040852f, -0.02172770f, -0.03200717f, 0.03636307f, 0.04295070f, 0.04176357f, 0.02904203f, -0.05542971f, 
    -0.04682188f, 0.02506662f, 0.05194048f, -0.02011933f, 0.00728249f, 0.04915685f, -0.02715177f, 0.00503005f, 
    -0.03569638f, 0.04890095f, 0.02768791f, -0.03967277f, -0.05520700f, 0.01211077f, -0.00339565f, 0.02212296f, 
    -0.03788802f, -0.03777656f, -0.03307394f, -0.03157134f, -0.03219744f, 0.04671181f, 0.05012941f, 0.02653370f, 
    -0.04041793f, 0.03014777f, -0.00430376f, 0.02742064f, -0.04041063f, 0.04830420f, 0.05196057f, -0.05487520f, 
    -0.00552401f, 0.01376901f, -0.02041139f, 0.02808794f, 0.01901817f, -0.03523462f, -0.01065737f, 0.01005240f, 
    -0.06051468f, 0.04487006f, 0.02336642f, 0.03930439f, -0.00428822f, 0.02243533f, 0.04600274f, -0.04600677f, 
    -0.03928048f, -0.01208096f, 0.00150820f, -0.01423557f, 0.03926141f, 0.00759759f, 0.04341272f, 0.03880411f, 
    -0.00861264f, -0.00992682f, 0.01068491f, 0.02722421f, -0.05839436f, -0.04176158f, 0.00362569f, -0.00342280f, 
    -0.05347366f, -0.05590854f, -0.01197836f, -0.00442457f, -0.00214307f, 0.00997993f, -0.04739825f, -0.01436588f, 
    0.04400307f, -0.04635061f, -0.05571185f, -0.03246343f, 0.03559029f, -0.01887094f, 0.02871778f, 0.03278402f, 
    -0.04351143f, -0.05481488f, -0.04587242f, -0.02043685f, -0.05664133f, 0.02365776f, 0.03387227f, -0.03706331f, 
    -0.01271484f, -0.06980802f, -0.03413766f, -0.03895865f, -0.05209413f, -0.03142786f, -0.05014025f, -0.00050739f, 
    0.04771256f, -0.02855996f, -0.02253657f, 0.04971549f, 0.02194391f, 0.04046280f, 0.04542443f, -0.04003797f, 
    0.04122065f, 0.04620181f, -0.06583758f, -0.01162159f, -0.02438267f, 0.05399121f, 0.02598267f, 0.02787586f, 
    0.30571750f, 0.02723170f, -0.07140145f, 0.20017089f, 0.20450333f, 0.23155975f, 0.09307063f, 0.05538684f, 
    0.26719958f, -0.92081386f, -0.57670915f, -0.31016433f, 0.11477533f, 0.11471346f, 0.11655080f, 0.42199886f, 
    0.24890240f, -0.12710878f, -0.29444641f, -0.36297941f, 0.09093249f, 0.15069556f, -0.00705650f, -0.01727993f, 
    -0.05788650f, 0.12445533f, 0.10807533f, -0.61660081f, -0.20111768f, -0.17733903f, 0.10835329f, 0.01988492f, 
    -0.00198340f, -0.13344762f, -0.00661124f, -0.16468973f, 0.14285623f, -0.02051527f, -0.15414570f, -0.11232542f, 
    -0.04897151f, -0.25626430f, 0.04797854f, 0.32816923f, 0.31897131f, 0.28970760f, -0.17169832f, -0.11677004f, 
    -0.02054266f, 0.06925417f, 0.00753609f, -0.02446624f, 0.38481393f, 0.06282227f, 0.41475198f, 0.20727882f, 
    0.07898597f, 0.22497413f, -0.06051689f, 0.12700559f, -0.17473662f, 0.12005985f, 0.00115073f, -0.35521480f, 
    0.08725335f, -0.29478139f, -0.04130904f, -0.00222829f, -0.20456162f, 0.20169154f, -0.06274753f, 0.08248314f, 
    0.06116192f, 0.06800381f, 0.33894429f, -0.00589623f, 0.04351601f, -0.11232921f, 0.05902840f, -0.00363446f, 
    -0.08050838f, -0.35665947f, -0.70382953f, 0.28175431f, 0.10095792f, 0.19666223f, -0.07790816f, -0.22061805f, 
    0.07811068f, -0.23190342f, -0.36728522f, -0.18686828f, 0.04902053f, -0.06782958f, -0.47106364f, -0.01484326f, 
    -0.29982516f, 0.07058175f, 0.23732926f, 0.17292096f, 0.35160956f, 0.05689547f, 0.08978111f, 0.01444286f, 
    0.14172275f, 0.04130708f, 0.09847309f, 0.13598569f, -0.12432325f, -0.05298477f, 0.05648816f, 0.02040089f, 
    0.04149568f, 0.18006460f, 0.21660772f, -0.09211527f, -0.13061354f, 0.23558310f, 0.35506400f, 0.19340916f, 
    -0.05276776f, -0.03671702f, 0.16559525f, 0.14293990f, 0.03226318f, 0.00383804f, 0.07065828f, -0.00569740f, 
    0.42310408f, -0.07935754f, 0.25655112f, -0.00949834f, 0.01175293f, 0.11491528f, -0.03855397f, 0.06740531f, 
    0.40429598f, 0.17246810f, 0.08320430f, -0.01647510f, 0.26872584f, -0.04451059f, -0.01472263f, 0.05635026f, 
    -0.61717987f, -0.03749147f, -0.30419853f, 0.05814941f, 0.17548321f, 0.12902205f, 0.17273791f, 0.13811551f, 
    -0.09668110f, -0.69839209f, -0.29494926f, -0.01010569f, 0.05118810f, 0.02764156f, 0.04501790f, 0.14862268f, 
    -0.00133780f, 0.13128766f, 0.34746701f, 0.00339114f, -0.12100891f, 0.06235166f, -0.04204427f, -0.01008897f, 
    0.10894290f, -0.03907507f, -0.03733145f, -0.18776511f, 0.23549062f, 0.12859192f, 0.48762411f, 0.12874906f, 
    -0.16948193f, -0.07546140f, -0.02581485f, -0.33700135f, 0.53248543f, -0.01550394f, 0.14587183f, 0.10687431f, 
    -0.03080550f, 0.02183646f, 0.07053290f, 0.23140389f, -0.02964576f, -0.23634796f, -0.08075212f, 0.14378211f, 
    -0.11992023f, -0.10260776f, -0.02029816f, 0.25354850f, -0.02665230f, -0.01153502f, 0.26575553f, -0.24664211f, 
    0.02165148f, 0.34380895f, -0.18541861f, 0.12603608f, -0.16848135f, 0.06392645f, -0.21297424f, -0.64572966f, 
    -0.49793181f, -0.38440612f, 0.04447338f, -0.02111805f, 0.28050283f, 0.24018328f, 0.07113021f, -0.11062622f, 
    -0.12383005f, 0.12006646f, -0.16348375f, -0.08762796f, 0.19094376f, -0.07400164f, 0.00913169f, 0.24436463f, 
    -0.05819380f, -0.72499114f, -0.09255865f, -0.35731110f, 0.01224773f, -0.12822485f, -0.14125726f, 0.19210088f, 
    0.20359130f, -0.08522208f, -0.18660662f, -0.06422330f, -0.39759603f, 0.10296119f, 0.15441707f, 0.07730067f, 
    0.04472767f, -0.01397763f, -0.12452847f, 0.01700946f, -0.04084111f, 0.19301900f, 0.06966654f, -0.18229763f, 
    0.01199146f, -0.13001463f, 0.08710009f, 0.05939199f, 0.04561632f, -0.22621223f, 0.11705582f, 0.01724638f, 
    -0.02419862f, 0.02008229f, -0.27196750f, 0.16321033f, -0.00465161f, 0.48717436f, 0.06881300f, 0.27972755f, 
    -0.20387039f, -0.10307448f, -0.12734646f, 0.06525134f, -0.04154233f, -0.17066354f, -0.69825053f, -0.59728026f, 
    0.09028166f, 0.09764197f, 0.21159613f, 0.25614941f, 0.02314898f, -0.06532843f, -0.10946897f, 0.21784489f, 
    -0.22571504f, 0.08572640f, 0.02408525f, -0.16081464f, 0.02711507f, 0.00971980f, 0.07152045f, -0.16702276f, 
    0.07603898f, 0.06642548f, 0.36900133f, -0.14078997f, 0.07416102f, 0.28541571f, -0.08294579f, 0.05800214f, 
    0.14230791f, 0.27373028f, 0.19992693f, -0.32381305f, 0.11471319f, -0.04900158f, 0.02044459f, -0.00248899f, 
    0.19380078f, 0.17960148f, 0.30024651f, 0.14883935f, -0.25936010f, 0.04571873f, 0.03229725f, -0.09369797f, 
    -0.12635642f, 0.10562889f, -0.10442860f, -0.12766695f, -0.02282884f, -0.18319732f, 0.07873224f, -0.02939686f, 
    -0.16363311f, -0.14591290f, 0.09471873f, -0.24629495f, -0.11176547f, 0.17464410f, 0.43689752f, -0.18332438f, 
    -0.02971127f, -0.04595320f, -0.01452665f, -0.00937666f, -0.06443706f, 0.01722693f, 0.23451583f, 0.05270544f, 
    0.08315143f, -0.11387773f, 0.02258131f, -0.04975692f, 0.02696334f, 0.05754861f, 0.49203011f, 0.06547860f, 
    -0.69599479f, -0.09598662f, -0.02327032f, -0.19289386f, 0.16362496f, 0.22044802f, 0.04094540f, 0.30319470f, 
    -0.06872620f, 0.05985354f, -0.06619589f, -0.02099003f, 0.16007626f, -0.04009440f, 0.19942111f, 0.10792845f, 
    0.50725818f, 0.14908431f, 0.08481035f, -0.03631977f, 0.14157830f, 0.22144118f, 0.08394516f, 0.12823263f, 
    0.27595153f, 0.00098713f, 0.11834501f, -0.21647437f, 0.06036152f, -0.12129524f, -0.18047053f, -0.18845120f, 
    0.04804100f, -0.08183326f, -0.15472864f, -0.24283326f, -0.16567767f, -0.03337985f, -0.09907104f, -0.06879041f, 
    0.14239322f, 0.07938580f, 0.12925227f, 0.08608755f, -0.20741779f, 0.33010912f, -0.05879044f, 0.05275513f, 
    0.01714796f, -0.09228727f, 0.08982140f, 0.13892475f, -0.08423826f, -0.27101004f, -0.22069210f, 0.19496037f, 
    -0.07770945f, 0.29576367f, -0.19156182f, -0.03314354f, 0.27324525f, -0.14009592f, -0.12143242f, 0.38731125f, 
    -0.02788442f, 0.12570161f, 0.01311634f, -0.21516192f, 0.10261736f, 0.16503324f, -0.18842092f, -0.10275888f, 
    -0.02269747f, 0.24027891f, 0.17434314f, 0.05043659f, 0.14281756f, 0.11074891f, 0.06979860f, -0.00113386f, 
    -0.35266933f, 0.25599563f, -0.31285226f, -0.11661667f, 0.00034129f, -0.05199104f, 0.05714664f, -0.09165202f, 
    -0.08170231f, 0.09647404f, -0.11597981f, 0.02488227f, -0.06353949f, -0.09574496f, -0.04688874f, -0.04152705f, 
    -0.00620004f, 0.06112836f, 0.08531898f, -0.22628453f, -0.05990114f, 0.12983504f, 0.20142405f, 0.20285252f, 
    -0.29535049f, 0.09606669f, -0.25119764f, -0.12297580f, -0.36785987f, 0.16644345f, -0.13817780f, 0.01588064f, 
    -0.06147449f, -0.18569000f, -0.02682287f, -0.51481628f, -0.04505946f, -0.63062674f, 0.02192132f, -0.12084328f, 
    -0.06785141f, -0.05940385f, 0.09552882f, -0.25425202f, -0.13953242f, -0.19837075f, 0.07786279f, 0.06130419f, 
    -0.14802179f, -0.10061088f, 0.04167881f, -0.26221696f, 0.12078141f, 0.31628290f, -0.12713712f, -0.07858701f, 
    0.21882409f, -0.02481627f, 0.19422300f, 0.16576558f, -0.00057326f, -0.04631456f, -0.25503021f, -0.04808511f, 
    -0.34824273f, -0.07802308f, 0.05104601f, -0.05760353f, 0.09867877f, -0.39124066f, 0.26204580f, 0.32923910f, 
    0.00610774f, -0.38078055f, -0.06747834f, 0.05266940f, 0.04779530f, 0.24698499f, -0.13731915f, 0.25444278f, 
    -0.16614205f, 0.11757189f, -0.39742067f, -0.03543212f, -0.03133817f, -0.02942913f, -0.06120896f, 0.20834878f, 
    -0.09704113f, 0.00492520f, 0.14789595f, -0.24891736f, 0.03094803f, 0.06562595f, 0.06926507f, 0.08858735f, 
    -0.23247316f, -0.00175614f, -0.06569140f, 0.08817161f, -0.02871647f, -0.02593889f, -0.02787953f, 0.07358973f, 
    -0.06559145f, 0.01635187f, 0.20657021f, -0.41986808f, -0.13006465f, 0.63611001f, 0.18177745f, -0.01620906f, 
    -0.19157878f, -0.10505646f, 0.21811718f, -0.10264321f, 0.22701998f, 0.16521943f, -0.28491378f, -0.01367642f, 
    0.16529018f, -0.21163920f, 0.39702642f, -0.15280332f, -0.13093954f, -0.15301995f, 0.25968975f, 0.05886523f, 
    0.27457681f, -0.11552469f, -0.24896295f, 0.06396256f, 0.18636470f, -0.11252464f, 0.03615807f, 0.04391923f, 
    -0.28173682f, 0.10623072f, -0.01489659f, 0.01870267f, -0.01032791f, -0.12207536f, -0.02393996f, 0.06299385f, 
    0.20668033f, -0.10326896f, 0.16200788f, -0.09900636f, -0.06043902f, 0.27790654f, 0.12187363f, -0.10861538f, 
    0.10998724f, 0.10516702f, -0.16896418f, 0.01356899f, -0.16536447f, 0.12032650f, 0.18375348f, 0.13708752f, 
    -0.23199353f, -0.54452384f, -0.04288881f, -0.03165877f, 0.23830546f, 0.00780675f, 0.10062481f, 0.06967396f, 
    -0.20876288f, 0.08432009f, -0.31493682f, -0.00307264f, -0.16046657f, 0.12177736f, -0.06685495f, 0.06560179f, 
    0.04693427f, 0.06266762f, 0.28367603f, -0.32753345f, -0.13876593f, -0.12190398f, -0.08182104f, 0.12983377f, 
    -0.07425812f, -0.05985704f, 0.22189692f, -0.05739243f, -0.04397854f, -0.05526317f, -0.23851612f, -0.12885076f, 
    0.15495630f, 0.17811963f, 0.18741043f, -0.15251410f, -0.03425391f, -0.05572554f, -0.17644224f, 0.02602731f, 
    -0.08980101f, -0.04287652f, -0.04067182f, 0.01760867f, 0.08248857f, -0.34424719f, 0.07035703f, 0.35679510f, 
    -0.28691119f, 0.16342120f, 0.24393436f, -0.06891595f, -0.02818919f, -0.05112457f, 0.24049135f, -0.12940831f, 
    -0.15746446f, -0.02866029f, -0.05692929f, 0.06689130f, -0.05201563f, 0.09847803f, 0.07043159f, -0.06694447f, 
    -0.07958870f, 0.16780083f, -0.06904983f, -0.21831851f, -0.06744814f, -0.02827197f, -0.00031151f, -0.04355315f, 
    0.14815092f, -0.43433040f, 0.36736646f, -0.09891734f, 0.09635478f, 0.04820213f, 0.03734947f, -0.05330852f, 
    -0.03623863f, 0.08441871f, 0.10050635f, -0.00125485f, -0.26976931f, -0.20702194f, 0.00191987f, 0.01978922f, 
    -0.01877417f, 0.08205756f, -0.04854796f, 0.22980276f, 0.19501069f, -0.02718259f, -0.01155837f, -0.33071536f, 
    -0.02088264f, 0.18998860f, 0.00394308f, -0.03109836f, 0.09136243f, 0.14053680f, 0.12017632f, -0.01087753f, 
    0.30510104f, 0.07540936f, -0.19931363f, -0.26303241f, 0.23777735f, 0.12375958f, 0.22780392f, -0.05610226f, 
    0.17534094f, 0.13443081f, 0.11481840f, -0.02592215f, -0.01334178f, 0.03307449f, 0.02528440f, 0.04987555f, 
    0.39367917f, -0.13353793f, 0.08548252f, -0.08723503f, 0.14479485f, 0.14993989f, 0.08730964f, 0.20961507f, 
    0.43539512f, -0.06167601f, 0.10906953f, -0.12782575f, 0.12997521f, 0.13171180f, 0.03177089f, -0.19137724f, 
    -0.38560405f, 0.10217445f, 0.02344759f, 0.06801356f, -0.14140160f, 0.05276537f, 0.14042090f, -0.08189584f, 
    0.08315796f, -0.19023801f, 0.08980265f, 0.11328559f, -0.04668047f, 0.07307695f, -0.10831237f, 0.03029215f, 
    -0.06526645f, 0.13461708f, 0.05777705f, 0.38330203f, 0.02837867f, 0.06142411f, -0.11844420f, -0.07059289f, 
    -0.10383897f, 0.43493840f, -0.09412108f, 0.18880233f, 0.06312621f, 0.11406001f, 0.01447248f, 0.09075516f, 
    0.01819386f, 0.13124673f, 0.08381997f, -0.04134283f, 0.36491713f, 0.17652272f, 0.14412984f, 0.14130054f, 
    -0.33264747f, -0.13380031f, 0.02934497f, -0.09619439f, -0.14347531f, 0.15203299f, 0.11059647f, -0.15715732f, 
    0.03393110f, -0.18429308f, 0.16059843f, -0.02512271f, 0.09482933f, -0.11995314f, -0.28934318f, 0.29067844f, 
    -0.19960119f, 0.09621125f, 0.29375091f, -0.01380713f, 0.06822541f, 0.20581473f, -0.00816995f, -0.46382362f, 
    0.07842505f, 0.07662933f, 0.35461453f, -0.17252123f, 0.10729820f, -0.01577641f, -0.10450651f, 0.05031836f, 
    -0.48161697f, -0.09488756f, -0.19238293f, -0.02264510f, -0.21444206f, -0.14236502f, -0.01474673f, 0.04043841f, 
    0.01987096f, -0.09057067f, 0.24545214f, 0.18444815f, -0.01868760f, -0.14496471f, 0.04979960f, -0.20460191f, 
    -0.05812842f, -0.08099327f, -0.09598675f, -0.19055907f, -0.10314997f, -0.14301933f, -0.01597086f, -0.06926595f, 
    0.10962518f, -0.04536984f, -0.14096908f, -0.17170344f, 0.16507438f, 0.14789020f, -0.02822091f, 0.02403454f, 
    0.18443805f, -0.05702297f, -0.04032078f, 0.04037530f, -0.22632293f, 0.12346371f, -0.07304458f, 0.10370094f, 
    0.14320052f, -0.03692794f, -0.39915931f, 0.24033339f, -0.02590546f, 0.25729740f, 0.14023192f, -0.22969139f, 
    0.09185207f, -0.27412793f, -0.37269500f, -0.06311271f, 0.13449036f, 0.19846573f, -0.66996896f, 0.22884618f, 
    -0.07488202f, 0.06209495f, 0.17637679f, 0.01757512f, 0.23663782f, -0.00664009f, 0.12156165f, -0.16847265f, 
    0.15179391f, -0.28500739f, 0.13430403f, 0.16783205f, -0.05169446f, -0.31922403f, 0.14958434f, -0.07643212f, 
    0.19972913f, 0.03557388f, -0.12448798f, 0.00447235f, -0.06954299f, 0.08159996f, -0.18758026f, -0.04334757f, 
    0.01926733f, 0.00631892f, 0.03140377f, 0.39652044f, -0.11755116f, 0.07426197f, 0.02543470f, -0.13621159f, 
    0.01882298f, -0.02821222f, -0.45564079f, 0.35527143f, 0.08104264f, 0.12946786f, -0.05775715f, -0.09564313f, 
    -0.02933205f, 0.07126684f, -0.03421456f, -0.07501416f, -0.03606650f, 0.34886852f, 0.01682299f, 0.16402309f, 
    -0.03979758f, 0.16931093f, 0.10795492f, -0.12706453f, -0.69468182f, -0.40271068f, -0.38673764f, -0.13075496f, 
    0.00017331f, -0.10789242f, -0.15458840f, 0.04214562f, -0.26745936f, 0.85450709f, 0.22242008f, -0.13641874f, 
    0.01503056f, -0.05419018f, -0.00407854f, 0.05890550f, 0.07101899f, -0.12783399f, 0.28232160f, -0.04327530f, 
    0.08791014f, -0.00635219f, -0.03576346f, 0.05814401f, 0.14166339f, 0.15526231f, 0.04545842f, 0.27450091f, 
    0.17613146f, -0.09010673f, 0.03326694f, -0.10910447f, 0.06026013f, 0.16212460f, -0.02041343f, 0.16574813f, 
    0.00889101f, 0.19428203f, -0.36839727f, 0.05946638f, -0.01859714f, 0.15036713f, 0.00830308f, 0.05823576f, 
    -0.01102445f, -0.08207147f, -0.00816545f, 0.10400736f, -0.17876287f, -0.01053566f, 0.16418785f, 0.00221489f, 
    -0.03172174f, 0.02420741f, 0.16381346f, -0.35359758f, -0.20943145f, 0.05181275f, 0.11711722f, 0.06630421f, 
    0.27901515f, -0.04042002f, -0.14556023f, 0.16546881f, -0.14556447f, -0.30614644f, 0.21574211f, -0.25082698f, 
    -0.17521320f, 0.01813470f, -0.03873320f, -0.11774977f, -0.05284414f, -0.13017423f, -0.03468313f, 0.27807900f, 
    0.16697277f, 0.08931390f, -0.16865475f, 0.29306531f, -0.04609084f, -0.12113341f, -0.02691297f, -0.28759342f, 
    0.09510494f, -0.07365979f, 0.00406872f, -0.00724168f, -0.08306303f, -0.26479471f, 0.25587651f, -0.12694959f, 
    -0.22727980f, -0.17913437f, -0.00345759f, 0.12106122f, 0.15193403f, -0.28596231f, 0.27770665f, -0.63280040f, 
    -0.34978768f, -0.07181192f, 0.17875695f, -0.06773660f, -0.34168127f, 0.14581485f, -0.27899632f, -0.04859656f, 
    0.15366186f, -0.18961306f, 0.09535517f, 0.24177168f, 0.03615353f, 0.05815009f, -0.21129665f, 0.24094348f, 
    -0.07833411f, -0.23476586f, -0.10650149f, 0.03152640f, 0.07292400f, 0.03986537f, -0.13214037f, 0.02063868f, 
    -0.05928964f, 0.00559484f, 0.49426502f, -0.68170649f, -0.10466541f, -0.11663496f, 0.07051781f, 0.47833258f, 
    -0.07226005f, 0.00680657f, 0.15854013f, -0.30509487f, -0.85654700f, -0.01001997f, -0.01197319f, 0.31071737f, 
    -0.17534620f, -0.22277839f, -0.06850847f, 0.04031146f, -0.13756037f, -0.15552451f, -0.12344945f, -0.04186930f, 
    -0.03954136f, 0.08412025f, -0.03372059f, 0.14968243f, 0.05928183f, -0.02940859f, 0.25672802f, -0.03530597f, 
    -0.11928100f, 0.16577931f, -0.30822769f, -0.17790201f, 0.03581338f, -0.06515064f, -0.34986621f, 0.10714134f, 
    0.05869551f, -0.13384858f, 0.18850388f, -0.18568447f, -0.03344775f, 0.02912401f, -0.06275419f, 0.12912649f, 
    0.26759091f, 0.05508385f, -0.01814348f, 0.01231161f, -0.11435820f, -0.02537713f, -0.16481645f, 0.07837340f, 
    -0.57971007f, 0.04227590f, 0.54516935f, 0.18696542f, -0.22950906f, -0.16689675f, -0.06607617f, 0.05844137f, 
    0.19849198f, 0.32992607f, -0.65389436f, -0.28107914f, -0.26536494f, -0.11329251f, 0.08910665f, 0.11331959f, 
    -0.23947521f, -0.02810038f, 0.18314466f, -0.01309907f, 0.21333452f, 0.01378772f, 0.08535603f, -0.14642644f, 
    0.18975820f, -0.03500013f, 0.04781661f, -0.87758690f, -0.32707667f, 0.16853093f, -0.20665745f, 0.27799818f, 
    -0.01320523f, 0.10352846f, 0.10061735f, 0.07809299f, 0.33881983f, 0.33064529f, -0.03783636f, -0.03953352f, 
    0.04269339f, -0.03454303f, 0.12548794f, 0.10295407f, 0.22553857f, -0.17429136f, 0.09540606f, -0.36781907f, 
    0.03671565f, 0.25746861f, -0.12635556f, -0.09833589f, -0.07914221f, 0.10977586f, -0.36105990f, 0.02907233f, 
    0.05880913f, -0.10677615f, 0.08770825f, -0.13407570f, -0.07596815f, 0.03950600f, 0.14118500f, 0.24911115f, 
    -0.04170375f, 0.12648343f, -0.02956007f, 0.18517159f, 0.18207407f, -0.09695758f, 0.10696496f, 0.29414901f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.00508046f, -0.06940603f, -0.15310371f, 0.22055604f, 0.04097705f, 0.15110858f, 0.04380376f, 0.00189560f, 
    0.21280792f, -0.03456753f, -0.20758264f, 0.08980490f, -0.05590124f, 0.00381986f, 0.04103087f, -0.05165278f, 
    0.02810064f, 0.03183199f, -0.01134217f, 0.00421317f, 0.04580953f, -0.05114068f, -0.04282197f, 0.06052244f, 
    -0.04073767f, 0.15667708f, -0.02806419f, -0.03550371f, 0.28629881f, 0.10484319f, 0.05966580f, 0.15529133f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.09486546f, 0.15778057f, -0.64684862f, -0.15099758f, -0.13819832f, -0.49253276f, 0.02000785f, 0.13620251f, 
    -0.15229757f, 0.13905880f, -0.12211744f, 0.08263355f, -0.03191441f, 0.14408213f, 0.08200936f, 0.04353109f, 
    -0.03024128f, 0.11506961f, 0.05686281f, -0.06522344f, 1.02387583f, 0.04621970f, 0.06258020f, -0.41765195f, 
    0.15014362f, 0.47827676f, 0.03422699f, -0.15264572f, -0.20458059f, -0.02526616f, 0.25013384f, -1.02099955f, 
    0.12648074f, 0.00149322f, -0.28626177f, 0.72951776f, -0.10208806f, -0.32466617f, -0.19576731f, -0.11977726f, 
    -0.26398620f, -0.12642270f, 0.21776320f, -0.00709623f, -0.16963598f, -0.06623078f, -0.13232392f, 0.10358732f, 
    -0.09551179f, 0.00801856f, -0.08946525f, -0.03053190f, 0.05614804f, -0.03839185f, -0.02114395f, 0.08211564f, 
    0.16788615f, 0.83084095f, -0.09733989f, -0.02980263f, -0.17073180f, -0.16788535f, -0.36832830f, 0.35803843f, 
    -0.01563062f, 0.13553265f, -0.22157328f, 0.05671968f, -0.11244521f, -0.35639507f, 0.29610592f, -0.04470104f, 
    -0.19118723f, 0.05656184f, -0.13047160f, 0.95385939f, -0.04770418f, -0.02537304f, 0.11218380f, 0.03584853f, 
    0.04316348f, -0.07232258f, 0.01147932f, -0.05307550f, -0.47984985f, 0.14242506f, 0.19973646f, -0.55128545f, 
    -0.12034149f, -0.24903516f, -0.08196601f, -0.09690296f, -0.70222771f, 0.46417984f, 0.14356804f, -0.19868407f, 
    -0.15338111f, -0.05315327f, 0.64698225f, -0.54551792f, -0.01560923f, 0.26062545f, 0.50412917f, -0.01619004f, 
    -0.40792203f, 0.12085620f, -0.87108469f, 0.19081418f, -0.07037456f, 0.13293026f, 0.14176291f, -0.07376407f, 
    0.13305022f, -0.09857457f, 0.05798704f, -0.09617157f, -0.31604475f, -0.09795503f, -0.51143938f, -0.45118931f, 
    -0.16812490f, 0.08986202f, -0.14604501f, 0.00256820f, 0.60217315f, -0.24334107f, -0.03100810f, -0.32116210f, 
    -0.16118005f, 0.16947804f, -0.40968299f, -0.21753569f, 0.09885462f, 0.15737984f, 0.49460444f, 0.08400625f, 
    0.62480640f, 0.05483773f, -0.07772394f, -0.36949274f, -0.15766315f, 0.01567651f, 0.03516901f, -0.10754697f, 
    0.15283941f, -0.10035961f, -0.11809395f, 0.06643223f, 0.04854929f, -0.17228650f, -0.56167966f, 0.26744398f, 
    0.01715713f, -0.00746476f, 0.08946817f, -0.10431553f, -0.16742687f, -0.02806737f, 0.17576444f, -0.90834790f, 
    0.07433385f, 0.14210697f, 0.01099088f, 0.36061436f, -0.15929793f, 0.03463104f, -0.27328092f, 0.09341409f, 
    0.00356107f, -0.07121627f, 0.13624997f, -0.93176514f, -0.17848720f, -0.00458556f, 0.11530467f, -0.15087636f, 
    0.08616118f, -0.00679012f, 0.03057434f, 0.06879655f, 0.58101648f, -0.12299101f, 0.31482944f, -0.01689288f, 
    -0.04829004f, -0.45705578f, -0.07315347f, 0.09010992f, -0.12761886f, -0.49677476f, -0.19608976f, 0.54489815f, 
    0.07964709f, 0.09028886f, -0.34350175f, -0.29334900f, 0.05662005f, 0.24289301f, -0.11714397f, 0.04595720f, 
    0.66423255f, 0.01449803f, -0.68383592f, -0.50039381f, 0.12402593f, -0.05106851f, -0.14332066f, 0.14613707f, 
    0.03974033f, 0.10717123f, -0.13005261f, 0.12946163f, -0.39188057f, -0.13296220f, 0.74209237f, -0.66796029f, 
    -0.00773671f, -0.10770629f, -0.03137483f, 0.16051847f, -0.34932515f, -0.48645216f, 0.52428633f, -0.30258262f, 
    -0.03317153f, -0.16180192f, 0.05790699f, -0.41790143f, 0.15059012f, -0.26115358f, 0.01045777f, 0.07880391f, 
    -0.20272730f, -0.02517796f, 0.98524123f, -0.18712097f, -0.03796387f, -0.00739402f, -0.06583842f, 0.03275436f, 
    0.05174082f, -0.01381198f, -0.08521836f, -0.11784807f, -0.24824090f, 0.02326215f, -0.12559204f, 0.43840358f, 
    -0.14820555f, -0.08856647f, 0.13746518f, 0.03037666f, -0.08145714f, -0.56327957f, 0.36172101f, -0.01214255f, 
    -0.14267859f, 0.06214433f, 0.25193772f, -0.10494202f, -0.00287442f, 0.25107175f, -0.73769218f, -0.14443725f, 
    -0.40352818f, -0.00900084f, 0.13180733f, -0.03709801f, -0.02061618f, 0.12812470f, 0.01367869f, 0.11138932f, 
    0.01861209f, -0.09556844f, -0.10535617f, 0.15137182f, -0.27144441f, -0.10229755f, 0.09735928f, 0.83166665f, 
    -0.02959175f, 0.50171447f, 0.07540423f, -0.09609887f, -0.25664482f, 0.61084253f, -0.50055188f, -0.01699170f, 
    -0.07034479f, -0.15818653f, -0.36917734f, -0.45711917f, 0.11491216f, 0.29622930f, 0.21010637f, -0.11644557f, 
    0.22651912f, 0.06252532f, 0.16836722f, -0.09550880f, -0.13599084f, 0.03600634f, 0.17859279f, 0.00739157f, 
    -0.15992369f, -0.02415129f, -0.11361837f, 0.01070698f, 0.32734925f, 0.14694978f, -0.44269496f, -0.51108718f, 
    -0.09373686f, -0.94221574f, 0.10905582f, -0.11542625f, 0.08320167f, 0.59908903f, -0.39585215f, 1.11561906f, 
    0.14369644f, 0.16536626f, -0.46048594f, 0.15569334f, -0.05059119f, 0.54474306f, -0.48304901f, -0.09753370f, 
    -0.58028328f, 0.16428725f, -0.31027979f, 0.44533527f, 0.15029125f, 0.06134892f, -0.00685829f, 0.05087402f, 
    -0.11277419f, -0.08631444f, -0.10972674f, -0.12174886f, -0.64356285f, -0.11824233f, 0.05877575f, 0.05768533f, 
    0.16718453f, -0.45916954f, -0.15219182f, -0.09396875f, 0.73474681f, -0.12054369f, 0.40936232f, -0.29979730f, 
    -0.14068860f, 0.11234400f, 0.77066475f, 0.39434227f, 0.08518165f, -0.45468557f, 0.29184774f, -0.09993423f, 
    0.03147940f, 0.04605473f, -0.82733929f, -0.05521176f, 0.02201639f, -0.02963280f, 0.07029117f, -0.09785242f, 
    -0.08413127f, -0.05364038f, -0.03809809f, 0.13059399f, -0.52313626f, 0.14648223f, 0.35514793f, -0.04731395f, 
    -0.08454082f, -0.93164271f, 0.10600097f, 0.03634185f, 0.09011453f, 0.12026546f, -0.69031131f, -0.80752784f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.10638137f, -0.15258065f, -0.10534874f, -0.06103556f, 0.00338640f, 0.04464699f, 0.02405849f, -0.47832701f, 
    -0.24752295f, 0.11093567f, 0.21943857f, 0.31943181f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
