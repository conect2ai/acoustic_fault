#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.87856263f, -0.65847117f, -0.40184748f, 0.51308554f, 0.51728123f, 0.55896735f, -0.24748489f, -0.08035433f, 
    0.34252551f, 0.45916772f, 0.51979017f, -0.02227917f, 0.16357605f, 0.08393333f, 0.10490834f, -0.46965665f, 
    0.05603343f, 0.83830345f, 0.41407591f, 0.43343267f, 0.59447753f, 0.17630537f, 0.14997749f, 0.50805837f, 
    -0.05881222f, -0.19654071f, -0.61823803f, -0.43584606f, -0.24698901f, -0.09707354f, 0.09903442f, -0.60341865f, 
    -0.99853760f, -0.21842134f, 0.68511552f, 0.08271822f, -0.53411001f, 0.83543968f, -0.56617719f, 0.29859689f, 
    0.34954324f, 0.40793926f, 0.05639422f, 0.52485842f, -0.09697647f, 0.57422030f, -1.36198807f, 0.39864042f, 
    0.16495314f, -0.03892634f, -0.05796102f, -0.09829286f, -0.27076128f, -0.23067302f, -0.62497687f, -0.59265894f, 
    0.12017766f, -0.03513202f, 0.02906251f, -0.41042954f, -0.19995159f, -0.09755787f, -0.60773897f, 0.08565905f, 
    -0.58706331f, -0.88640893f, -0.07692508f, 0.09307516f, -0.10602954f, 0.03090982f, -0.28651741f, -0.37723935f, 
    -0.70978469f, -0.16333000f, 0.55058664f, 1.06827033f, -0.22608306f, -0.37733245f, 0.06551780f, -0.18531929f, 
    -0.17376462f, 0.57605481f, 0.72487897f, -0.08812837f, 0.29659453f, -0.39069164f, -0.40605959f, -0.10906610f, 
    0.02898807f, 0.03534728f, 0.72197884f, -0.75381684f, -0.05072014f, -0.12635528f, -0.48249856f, -0.60060704f, 
    0.04491331f, -0.26365539f, 0.37237066f, -0.69203395f, -0.68700433f, 0.04609384f, 0.10041763f, -0.39424846f, 
    0.08865590f, 0.63561308f, 0.32257146f, 0.65090179f, -0.45801467f, 0.12432574f, 0.28209892f, 0.03923982f, 
    0.73051447f, 0.39412791f, -0.52584612f, -0.52714515f, -0.17403278f, 0.37923229f, 0.65017003f, -0.62196708f, 
    -0.52235353f, 1.07354236f, -0.38592970f, -0.14383666f, 0.08643061f, 0.01106398f, 0.37818643f, -0.14906906f, 
    0.72430855f, -1.01769316f, 0.46067604f, 0.27768418f, -0.13470428f, -0.22489946f, 0.31560373f, 0.28446326f, 
    0.36671352f, 0.69833791f, -0.95248431f, -0.51668370f, -0.33002874f, 0.13891186f, 0.41003475f, -0.00602162f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.28171417f, -0.20972732f, -0.23435734f, -0.10634392f, -0.43043178f, 0.22393833f, -0.10971940f, -0.29442593f, 
    0.34214163f, 0.39527902f, 0.22171091f, 0.25874886f, 0.02892288f, 0.03141811f, 0.29128182f, 0.09986575f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.08323747f, -0.59507000f, -0.57717401f, -0.06238086f, 0.09335308f, -0.05328781f, 0.04252378f, -0.06552138f, 
    -0.05376330f, 0.27396625f, -0.05487012f, 0.13306199f, -0.17142318f, -0.10057835f, -0.02768304f, 0.07971603f, 
    -0.00453117f, -0.12637512f, 0.18843755f, 0.21267213f, 0.04484553f, -0.07763854f, -0.04583234f, -0.21363088f, 
    0.00643039f, -0.15007332f, 0.00036072f, -0.31656760f, 0.40155116f, -0.46942887f, -0.12489090f, -0.20677368f, 
    -0.17763257f, -0.10422939f, 0.08273284f, 0.22477880f, 0.15717074f, -0.04378389f, -0.33591011f, -0.25265840f, 
    -0.06939611f, -0.20899901f, 0.04455908f, -0.00557913f, 0.12270014f, -0.16268796f, -0.37202850f, -0.70380235f, 
    0.14302535f, 0.27758607f, -0.01817995f, 0.18269503f, 0.05755227f, -0.09377107f, 0.04653303f, -0.59011841f, 
    -0.26187989f, -0.13096349f, -0.08581091f, 0.01012081f, 0.30804104f, -0.14016494f, 0.07325228f, -0.36451885f, 
    -0.90481764f, -0.24657749f, -0.27243409f, -0.02166348f, 0.05032105f, 0.05889330f, -0.11929394f, -0.01397514f, 
    0.00501112f, -0.10412754f, -0.14888823f, 0.14977516f, 0.21280000f, 0.10090546f, 0.16673689f, 0.05755687f, 
    -0.02990806f, 0.29440147f, 0.17040838f, 0.00376464f, -0.05711728f, 0.05867030f, 0.18413742f, 0.06809226f, 
    0.23507990f, 0.04956271f, -0.52489841f, 0.26165479f, 0.13205966f, -0.00198054f, 0.04402156f, -0.02941140f, 
    -0.00268280f, 0.02558282f, 0.06475829f, -0.54127192f, -0.35539335f, -0.26057312f, 0.01600730f, 0.21527158f, 
    0.30541602f, 0.14847150f, 0.00364127f, 0.02455878f, -0.04541743f, 0.07077429f, 0.02965847f, 0.01228815f, 
    -0.21180500f, -0.19464089f, -0.03466609f, -0.05728858f, 0.08905138f, 0.11091165f, 0.38981655f, 0.21652593f, 
    -0.02808157f, 0.16082384f, -0.01715042f, 0.13672709f, 0.14435285f, -0.06083409f, 0.26979396f, -0.14777018f, 
    0.00068106f, -0.09830822f, 0.15127331f, -0.13154785f, 0.12784205f, -0.04592001f, 0.01857966f, -0.18117127f, 
    -0.07241399f, 0.16933413f, -0.27342290f, 0.01820104f, -0.12723172f, 0.03473011f, -0.02637595f, 0.00244043f, 
    -0.38682911f, -0.18876602f, -0.34633866f, -0.15674494f, 0.03214149f, -0.02735776f, -0.08807953f, -0.02417213f, 
    -0.01184676f, 0.25333026f, 0.18695019f, 0.39903980f, -0.08120474f, -0.08394257f, -0.09665234f, 0.04799432f, 
    0.10636408f, 0.00853018f, -0.06020930f, -0.02222931f, 0.57285458f, -0.06030547f, 0.01186210f, 0.01064750f, 
    -0.07968558f, -0.05868586f, 0.03112496f, -0.39120311f, -0.08290283f, 0.00223250f, -0.15626933f, 0.02335379f, 
    -0.27208248f, 0.14006132f, -0.00906506f, 0.05634737f, -0.42882276f, 0.07958062f, -0.32209361f, 0.07071639f, 
    -0.03506250f, 0.09542305f, 0.08817200f, 0.15104365f, 0.17908217f, 0.31709439f, -0.27909666f, -0.30547604f, 
    0.10925336f, 0.04400779f, 0.21972413f, -0.00509175f, -0.24213390f, -0.18530844f, 0.27490392f, 0.21665944f, 
    0.21160257f, -0.21445777f, 0.05377854f, -0.02373844f, 0.06407157f, 0.08407501f, 0.21263005f, 0.04771202f, 
    -0.06076589f, -0.47765809f, -0.17471385f, -0.06867177f, -0.08177115f, 0.06115750f, -0.08512240f, 0.01284162f, 
    -0.53102189f, -0.17847610f, -0.19602992f, -0.05208391f, -0.05370012f, 0.16124028f, 0.02157698f, -0.06238452f, 
    0.06912261f, 0.38582030f, 0.18019104f, 0.30461651f, -0.01094478f, 0.02896358f, -0.03957516f, 0.08941145f, 
    0.15298775f, 0.10884643f, -0.00421544f, -0.26878002f, 0.22685766f, 0.03038915f, -0.26132900f, 0.05681966f, 
    0.02271168f, 0.01878656f, -0.01142072f, 0.15766895f, -0.31077009f, 0.11953939f, 0.10970237f, 0.14242487f, 
    0.10339665f, 0.17116971f, 0.09110352f, 0.05076558f, -0.42125937f, 0.15964518f, -0.25437003f, -0.00454132f, 
    -0.03204903f, -0.20535828f, -0.04260176f, -0.03311232f, -0.03354445f, 0.29735956f, -0.41879520f, -0.24796602f, 
    0.17161930f, -0.12055070f, -0.19475605f, -0.11365501f, 0.12288773f, -0.08138730f, 0.09867093f, 0.19601381f, 
    0.24058269f, 0.09213415f, -0.03364087f, 0.24482398f, -0.12181410f, -0.09484068f, 0.02737649f, 0.27712741f, 
    0.18424352f, 0.30128825f, -0.11098251f, -0.00477689f, 0.04608518f, 0.12854041f, 0.12635694f, 0.10817758f, 
    -0.03984867f, 0.00224048f, -0.03097143f, -0.04114389f, 0.00820930f, -0.01216806f, 0.02169842f, -0.08952845f, 
    -0.04310741f, 0.02210508f, 0.02817346f, -0.06417704f, 0.01697770f, 0.03584431f, -0.09110086f, -0.07510959f, 
    -0.00074502f, 0.02937052f, -0.00414544f, -0.05798861f, 0.03058837f, 0.02320380f, -0.09540806f, 0.03863815f, 
    -0.01984429f, -0.01622542f, 0.01570115f, -0.01969191f, 0.04116133f, -0.00441308f, 0.00425770f, -0.00475543f, 
    0.01248043f, 0.05392115f, 0.02337455f, -0.03603086f, -0.03675959f, -0.08868939f, -0.06633733f, -0.06185522f, 
    0.05215856f, -0.02349114f, -0.03700166f, -0.00695437f, 0.00144746f, -0.05377623f, -0.03386720f, -0.05497057f, 
    -0.04306865f, -0.02895036f, 0.06231218f, -0.06724819f, -0.03692087f, -0.06471857f, -0.07013985f, 0.02056711f, 
    0.01922914f, 0.00031182f, -0.06463978f, -0.05586505f, 0.01821164f, -0.08058871f, 0.05123611f, -0.03567063f, 
    0.06707716f, 0.01367353f, -0.02044534f, -0.02053056f, -0.08374866f, -0.05741183f, -0.07822523f, -0.02609870f, 
    0.03616583f, 0.01838216f, -0.02431453f, 0.01695039f, -0.04006435f, -0.00506894f, 0.03494422f, -0.03774714f, 
    0.03674678f, 0.01151634f, -0.05902759f, -0.01599574f, 0.01189318f, 0.06787594f, -0.08441051f, 0.00718205f, 
    0.01061883f, -0.03617252f, 0.01622717f, -0.01095545f, -0.06343694f, 0.05436675f, 0.01259481f, -0.10137682f, 
    0.06138558f, 0.01200917f, -0.08646058f, -0.01215541f, 0.02404216f, -0.04075440f, 0.01864750f, -0.02896447f, 
    -0.04025021f, 0.02370132f, -0.02620517f, -0.00788032f, 0.00180850f, -0.07365084f, 0.07634065f, 0.04209998f, 
    -0.06057777f, -0.03786959f, 0.02175697f, 0.01397624f, 0.00513761f, -0.08936609f, -0.02769190f, -0.00593456f, 
    -0.08592509f, 0.01677937f, -0.02189696f, -0.02688438f, 0.07359067f, -0.05446078f, -0.00711464f, -0.07778251f, 
    -0.09689404f, 0.05212725f, -0.09115763f, -0.10009507f, -0.04314466f, -0.00802038f, 0.04693592f, -0.07934172f, 
    -0.08384418f, 0.02954363f, -0.06985913f, -0.03361581f, -0.00525996f, -0.09230234f, 0.03123894f, 0.03667473f, 
    0.12144171f, -0.04075514f, -0.15567520f, 0.01115686f, -0.02160093f, 0.11711949f, 0.03492431f, -0.02516096f, 
    0.05087603f, 0.27100277f, -0.11182523f, -0.11520750f, 0.17708743f, 0.15929602f, -0.19835591f, 0.20552364f, 
    -0.04543572f, -0.10776126f, 0.31245217f, -0.03249496f, -0.15769991f, 0.03823848f, -0.02361727f, -0.06838962f, 
    0.03386138f, -0.10658611f, 0.00733698f, 0.08885428f, 0.15128803f, 0.28855768f, -0.07726690f, 0.04159696f, 
    -0.14761354f, -0.10552124f, 0.05432092f, 0.10524449f, -0.17118049f, -0.18269764f, -0.45190218f, -0.09110543f, 
    -0.23355983f, 0.28637022f, 0.18990682f, 0.06283868f, -0.02052000f, 0.52942306f, -0.37938854f, -0.10464039f, 
    -0.06416771f, -0.13463756f, 0.32000107f, 0.03053626f, -0.09137823f, -0.17331709f, 0.29640758f, 0.04130316f, 
    0.40111008f, 0.04571892f, 0.04640396f, 0.10430066f, 0.01745677f, -0.00325679f, -0.03942985f, 0.15554686f, 
    0.08967326f, 0.14621308f, 0.22116838f, 0.05025753f, 0.34383079f, 0.12259793f, 0.13415298f, -0.13325982f, 
    -0.10997029f, 0.04922698f, -0.27997008f, -0.14654870f, -0.20016050f, 0.19310465f, 0.03109026f, 0.09718692f, 
    0.03493682f, 0.37303838f, -0.37399295f, -0.65609062f, 0.07769381f, 0.11083772f, -0.08747111f, -0.04929503f, 
    0.00787554f, -0.06186561f, 0.07090003f, 0.11803626f, -0.16601682f, -0.06045817f, 0.14545262f, -0.18751398f, 
    0.14427058f, -0.03346379f, 0.05976114f, -0.00651456f, 0.15482856f, -0.04290556f, -0.00204768f, 0.20756258f, 
    0.04378353f, 0.06619195f, 0.02277861f, -0.01321854f, -0.38804033f, -0.13483787f, 0.33584860f, -0.04753631f, 
    0.00930570f, 0.04797531f, 0.09963409f, 0.14495641f, 0.03300992f, -0.31876305f, -0.71746224f, -0.65901089f, 
    0.08413607f, -0.04604481f, 0.07099784f, 0.15345873f, 0.15610923f, -0.05021355f, 0.01117238f, -0.40294701f, 
    -0.03588867f, -0.06943571f, 0.01169527f, -0.09641640f, -0.02284213f, 0.02689041f, -0.06434172f, 0.36624745f, 
    -0.12951028f, -0.27619675f, -0.01927684f, -0.02135495f, -0.32798332f, 0.03203112f, 0.04760356f, 0.05946837f, 
    -0.30264702f, 0.25702995f, 0.38974333f, 0.06144762f, -0.04168735f, 0.16559580f, 0.00082386f, 0.01135950f, 
    0.27372205f, -0.03544080f, -0.04092630f, -0.04730420f, 0.06700552f, -0.22022374f, 0.07067769f, -0.05861331f, 
    -0.12243871f, 0.02045510f, -0.14797337f, 0.04546738f, -0.10526863f, -0.03114441f, 0.00776512f, -0.05502693f, 
    0.07599100f, -0.07323043f, 0.18410265f, -0.47746903f, -0.57800364f, -0.68352014f, 0.25545663f, -0.10744355f, 
    -0.43304026f, 0.12113199f, -0.08882546f, 0.05341813f, 0.07861683f, -0.33112296f, -0.02603044f, 0.02198712f, 
    -0.02751729f, -0.14074339f, 0.01888406f, 0.09387259f, 0.23003307f, 0.09573378f, 0.00091794f, 0.34232074f, 
    -0.19478248f, 0.14434420f, 0.26548290f, 0.15106688f, -0.06690678f, 0.08014837f, -0.04618214f, -0.10427780f, 
    0.14946608f, -0.12121062f, -0.08322019f, -0.04021413f, -0.04419590f, 0.23750722f, 0.11672457f, -0.03431517f, 
    -0.23301452f, 0.39719918f, -0.00202272f, -0.26840669f, -0.12053082f, 0.06454752f, 0.15297823f, 0.07709953f, 
    0.00774680f, 0.12791175f, 0.19547838f, 0.05798010f, 0.13238116f, -0.01728044f, 0.12182522f, 0.19202831f, 
    0.08892553f, 0.21635377f, -0.02211382f, 0.14154467f, 0.17848605f, 0.01650533f, 0.22309709f, 0.16396537f, 
    0.02232284f, -0.10773817f, -0.18529770f, -0.06264986f, -0.01024711f, -0.10947838f, -0.07624799f, 0.03778853f, 
    0.28088361f, -0.08144201f, 0.12955827f, -0.47521976f, 0.21975304f, 0.06403165f, -0.17271240f, 0.03736281f, 
    0.07634625f, 0.06029221f, -0.07803518f, 0.01339875f, 0.05745800f, 0.02272403f, -0.22219400f, -0.18540093f, 
    -0.04891327f, -0.13557774f, 0.18732570f, -0.05380352f, 0.03536125f, 0.24257168f, -0.16764785f, -0.02508515f, 
    -0.01498458f, -0.04314215f, -0.01411865f, -0.01848383f, 0.16111085f, 0.05470764f, 0.08347685f, -0.30895969f, 
    -0.16073830f, 0.06736913f, -0.08179255f, 0.17508604f, 0.03499960f, -0.05099490f, 0.04270028f, 0.08174135f, 
    -0.58301789f, -0.50137746f, -0.20175917f, -0.13420877f, -0.05492355f, 0.00954398f, -0.05373796f, 0.06837301f, 
    0.19499421f, 0.24807300f, 0.21516261f, -0.25096279f, -0.20071599f, -0.11297007f, 0.14269784f, 0.09177427f, 
    0.10778747f, 0.03811714f, -0.06074207f, 0.20779960f, -0.31802166f, -0.07988444f, -0.06286924f, 0.09748911f, 
    0.14165539f, 0.05829782f, 0.06694179f, 0.15009433f, 0.08268780f, 0.15210846f, 0.08705758f, -0.13446653f, 
    0.26328990f, 0.28663686f, -0.07054313f, -0.52689868f, 0.02685438f, 0.08082164f, -0.15035051f, -0.34643880f, 
    -0.10446358f, 0.04162187f, -0.11802142f, -0.04485914f, 0.02882786f, 0.12825347f, -0.01774618f, -0.17725402f, 
    -0.17189334f, -0.27095172f, 0.14316873f, -0.11492260f, -0.04533963f, -0.40217704f, -0.49480653f, -0.25702667f, 
    0.07856390f, 0.18232527f, 0.05960843f, -0.07638878f, -0.04159839f, -0.09463816f, 0.08681711f, 0.01490567f, 
    0.04737438f, 0.03908044f, -0.30679068f, -0.05668690f, 0.09958589f, 0.13744111f, 0.13611244f, -0.31356803f, 
    0.47571865f, -0.27836722f, -0.12687641f, -0.04514374f, -0.00619102f, 0.02122360f, -0.01925261f, -0.08922716f, 
    -0.20474392f, 0.08012854f, -0.12381460f, 0.10354118f, -0.26803565f, 0.00835738f, 0.06920563f, 0.02385255f, 
    0.01977135f, -0.02225079f, -0.06398679f, 0.05979137f, 0.02096546f, 0.11139878f, 0.17067312f, 0.16861999f, 
    -0.16202988f, 0.16454673f, -0.05545399f, -0.11414795f, -0.33058232f, 0.08022954f, 0.28503725f, -0.23736796f, 
    0.03133824f, -0.02774066f, -0.10756244f, 0.02809752f, 0.45971948f, -0.02254525f, -0.14057942f, 0.15248714f, 
    0.04754933f, 0.02846074f, 0.02045125f, 0.08136206f, 0.01024105f, 0.21619657f, 0.47988787f, 0.07326743f, 
    -0.04198714f, -0.05268253f, 0.02937924f, 0.05619695f, 0.17026646f, -0.20652112f, 0.21012111f, -0.22527978f, 
    -0.07447062f, 0.24586520f, -0.05890754f, 0.04220210f, -0.10022097f, -0.03111264f, -0.18432541f, -0.40370688f, 
    -0.09470609f, -0.05921960f, 0.11922973f, 0.01865815f, 0.14975065f, 0.04353559f, 0.21948515f, -0.11440673f, 
    -0.86527205f, 0.12990680f, 0.05873704f, 0.18185538f, -0.07724705f, -0.09655933f, -0.04039178f, 0.04713578f, 
    -0.00159133f, -0.24639854f, -0.05270678f, 0.04262071f, 0.19381246f, 0.11720493f, -0.05785997f, 0.30139527f, 
    0.13309072f, -0.05210390f, 0.05562185f, 0.09140477f, 0.00422642f, 0.01717572f, -0.07978728f, 0.01065850f, 
    0.04849490f, -0.23473616f, 0.06716426f, 0.03330168f, -0.12605296f, 0.01729700f, 0.14389865f, -0.02849268f, 
    0.07618675f, -0.05488048f, -0.07249701f, 0.11643647f, 0.11692528f, 0.18889265f, 0.31023908f, -0.09027398f, 
    0.05560647f, -0.11291999f, -0.00576638f, -0.06271768f, -0.01941989f, -0.16468105f, 0.01490066f, 0.22316852f, 
    -0.02962823f, 0.17487682f, -0.39337385f, -0.16089049f, -0.05995087f, -0.54224312f, 0.52297819f, 0.01493221f, 
    -0.10286111f, -0.27337471f, 0.20447950f, -0.04444500f, 0.42027754f, 0.09070034f, 0.06662771f, 0.28021729f, 
    -0.11126667f, -0.01439186f, -0.03798872f, 0.21727079f, -0.06852131f, 0.11968943f, 0.09198970f, 0.06348337f, 
    0.26877707f, 0.43452671f, -0.17667207f, 0.20765576f, -0.11268396f, -0.08753457f, 0.15407136f, 0.26513860f, 
    -0.17224419f, 0.29361269f, -0.17907639f, 0.00365812f, 0.15140578f, 0.04678705f, 0.20814799f, 0.08265607f, 
    0.08985496f, -0.15965585f, -0.15848222f, 0.16060583f, -0.10682508f, -0.02306942f, -0.16981943f, 0.11162683f, 
    0.21111187f, -0.11396509f, -0.07268074f, 0.27043104f, 0.30064565f, -0.02768970f, -0.15395707f, 0.00381360f, 
    0.01684230f, -0.07097672f, -0.10905431f, 0.23179272f, -0.09967563f, -0.06336945f, 0.31823152f, 0.08371269f, 
    -0.03555069f, 0.18597981f, 0.09851091f, -0.46299645f, 0.30945712f, -0.01498592f, -0.46242306f, 0.13376018f, 
    0.04096400f, 0.07291965f, 0.05696128f, 0.08085705f, -0.01224128f, -0.03097114f, 0.10582682f, -0.06353574f, 
    0.00847810f, -0.09997078f, 0.03089373f, 0.07439314f, -0.04553713f, 0.08065116f, -0.37706727f, -0.19012827f, 
    -0.24318489f, -0.02097283f, 0.12568112f, -0.22905216f, 0.08357899f, 0.00582427f, -0.16884984f, 0.10508626f, 
    0.09385969f, 0.10374441f, -0.13539240f, 0.06087386f, 0.05327785f, -0.05218389f, -0.06632554f, -0.08176784f, 
    -0.03396636f, -0.07520502f, -0.01997653f, 0.06433078f, 0.10745034f, 0.02469216f, 0.08329967f, 0.01147063f, 
    0.20748627f, -0.28947592f, -0.20814987f, 0.05208607f, -0.13934061f, -0.00880898f, 0.14414324f, 0.24237119f, 
    0.05382660f, -0.11856265f, -0.45283657f, 0.05178322f, -0.10966950f, -0.16529407f, -0.14595351f, -0.01924700f, 
    -0.03485623f, -0.09261961f, -0.13010536f, 0.06598080f, 0.25498158f, 0.48655495f, -0.12734683f, 0.17469178f, 
    0.12266108f, 0.19499752f, 0.24938084f, 0.07525952f, -0.08912313f, -0.15815701f, -0.15871571f, 0.02153461f, 
    -0.10784072f, 0.04786703f, 0.16675520f, 0.33018506f, 0.21848138f, 0.41616613f, 0.17697679f, 0.32160905f, 
    -0.13098539f, -0.12750468f, 0.00944801f, -0.11799392f, -0.13405804f, -0.09534165f, -0.46454290f, -0.01636620f, 
    0.23493803f, 0.04563472f, -0.08114177f, -0.05610365f, 0.02910093f, 0.12802844f, -0.01635898f, -0.29257813f, 
    0.08515577f, 0.19300815f, -0.07334486f, -0.22232923f, -0.03133210f, -0.04696323f, -0.02526091f, -0.08653943f, 
    -0.40227628f, -0.10151175f, 0.36666754f, -0.01549620f, 0.06316734f, 0.02010167f, 0.14874195f, -0.27527878f, 
    -0.05435941f, 0.20692815f, -0.30082306f, -0.33583993f, 0.03976664f, 0.13440408f, 0.17627777f, 0.14057165f, 
    0.16831392f, -0.04300738f, 0.19533220f, 0.10583313f, 0.37012917f, 0.18401493f, 0.09331153f, 0.14169325f, 
    0.20215562f, -0.11349060f, -0.10716175f, 0.24701035f, -0.18927181f, 0.05776816f, 0.09200307f, -0.01901013f, 
    0.07204942f, 0.16199207f, 0.17905945f, 0.18553606f, -0.26678932f, 0.15900035f, -0.32848984f, -0.02191892f, 
    0.01454067f, -0.14496773f, 0.00263119f, -0.12199533f, -0.27317044f, 0.26746038f, -0.10923817f, -0.42215180f, 
    0.13714924f, -0.06451438f, 0.31546581f, 0.00029230f, -0.02054843f, -0.11261264f, -0.20135044f, -0.70348150f, 
    -0.53900856f, 0.28131387f, 0.07593226f, -0.00734103f, 0.21198957f, 0.09688788f, 0.07607988f, -0.13994654f, 
    -0.21956842f, -0.14700134f, 0.05279090f, -0.03804345f, 0.16571173f, -0.04763294f, 0.32790715f, -0.00806851f, 
    -0.07670134f, -0.01650872f, -0.08071143f, -0.02039207f, 0.06473564f, -0.01203081f, -0.02740389f, -0.06756686f, 
    -0.08609422f, -0.03130213f, 0.06242844f, -0.07389580f, 0.04291888f, 0.00500690f, -0.07855661f, -0.01190436f, 
    0.02660092f, -0.06841653f, -0.08631977f, -0.00451135f, -0.06455500f, -0.01330183f, -0.06400891f, 0.06671815f, 
    -0.08435751f, -0.04999174f, 0.02028486f, -0.08085600f, -0.02130054f, -0.01053200f, -0.04249102f, 0.00308199f, 
    0.06415660f, -0.07281864f, -0.05244612f, -0.07478362f, -0.02677045f, 0.07250005f, 0.00207765f, 0.01373565f, 
    -0.05777090f, 0.07248264f, 0.07682732f, -0.05427413f, 0.01575708f, -0.07685798f, -0.01288774f, -0.02778199f, 
    -0.08631462f, 0.02874103f, -0.08894487f, 0.06832305f, 0.04634108f, -0.07874767f, 0.02488103f, 0.02992985f, 
    -0.00933842f, 0.07051737f, -0.03873757f, 0.03550876f, -0.00054790f, 0.01416410f, -0.08281911f, -0.03505068f, 
    0.02770743f, -0.00183341f, -0.08066372f, 0.00865842f, -0.03412400f, -0.05482642f, -0.05017422f, -0.08450492f, 
    0.06889409f, -0.07009050f, -0.03585459f, 0.04209236f, -0.06144737f, 0.00716777f, 0.03854295f, -0.03448347f, 
    -0.08835555f, -0.02723401f, -0.02678025f, 0.02292565f, 0.05253001f, -0.03259382f, 0.01725288f, -0.00022995f, 
    0.03656888f, 0.07187828f, 0.02395359f, -0.00814687f, -0.06794198f, -0.04427293f, -0.07740629f, -0.06264697f, 
    -0.03658997f, -0.05348521f, 0.05511458f, 0.06501183f, -0.03052137f, -0.01894506f, -0.03461018f, 0.01239035f, 
    -0.06378250f, -0.00599739f, 0.06525850f, 0.03676019f, -0.01258135f, -0.05868704f, -0.05569370f, 0.04164005f, 
    0.02919629f, 0.07591077f, -0.01528167f, -0.00157933f, -0.06022340f, -0.02725750f, 0.00623414f, -0.01653275f, 
    -0.03679097f, -0.00061637f, -0.03520406f, -0.06270007f, 0.03486981f, 0.07368848f, 0.03014340f, 0.05377415f, 
    -0.05143544f, -0.05927292f, 0.02470096f, 0.00689276f, -0.05897739f, -0.05910148f, -0.06344105f, -0.02164122f, 
    -0.02312726f, -0.03212079f, 0.07172981f, -0.03623978f, 0.04716054f, 0.03946494f, -0.02167349f, -0.04138226f, 
    0.06113565f, -0.08776394f, -0.32649833f, 0.09455496f, -0.06467814f, -0.09342612f, -0.19824809f, -0.11405385f, 
    -0.05194116f, 0.17828567f, 0.08972222f, 0.08168539f, -0.23682091f, -0.02175524f, 0.02424094f, -0.17623180f, 
    -0.11246829f, -0.02716461f, -0.20466530f, 0.23418587f, 0.26068196f, -0.01381820f, 0.07823631f, -0.19516510f, 
    0.01970264f, 0.11511250f, 0.22035795f, -0.35948673f, 0.30824718f, 0.04499230f, -0.12072554f, 0.37880424f, 
    -0.14221632f, -0.09399872f, -0.06440127f, 0.03390615f, 0.06522343f, -0.06771559f, -0.37552363f, 0.07550650f, 
    -0.09700760f, 0.03779781f, -0.08935938f, -0.11500993f, -0.08812464f, -0.01317842f, -0.13241126f, 0.07551228f, 
    0.09668912f, 0.06583568f, -0.08272833f, 0.12087330f, 0.02275395f, 0.06305743f, 0.08059934f, -0.24788620f, 
    -0.05349065f, 0.10821643f, -0.04621774f, 0.12846307f, 0.07601861f, 0.05095838f, 0.07588226f, 0.19675335f, 
    -0.00932391f, -0.24422741f, -0.07703015f, 0.01446418f, 0.13572106f, 0.11649249f, 0.04733609f, -0.01638229f, 
    -0.44500855f, 0.04020910f, 0.22761695f, 0.13574775f, 0.04463935f, 0.20712905f, 0.17971537f, 0.01480903f, 
    0.08824914f, 0.45466280f, 0.18235241f, 0.14586850f, -0.07042143f, 0.13543569f, 0.00572992f, 0.10165640f, 
    -0.01950854f, 0.03843489f, 0.05455027f, 0.34761772f, -0.19120970f, 0.19409931f, 0.01637844f, 0.11541672f, 
    0.02226591f, -0.21634296f, -0.09568419f, 0.10024029f, -0.25727028f, -0.01891256f, 0.17180762f, 0.10471842f, 
    -0.18365185f, -0.13530739f, 0.09826129f, -0.26161754f, -0.03230407f, -0.41496038f, -0.31735033f, 0.02858246f, 
    -0.10297409f, 0.09377650f, -0.05803247f, 0.15888426f, 0.15571348f, 0.15075696f, 0.29532090f, 0.06573389f, 
    -0.14774652f, 0.20161895f, -0.05610767f, 0.20059913f, 0.11559106f, 0.17429572f, 0.21924576f, -0.01426268f, 
    0.49541369f, 0.13942190f, 0.02398189f, -0.10337593f, 0.21354719f, -0.06483047f, -0.41493922f, 0.27634200f, 
    -0.04670621f, 0.10290562f, 0.01133515f, -0.04875859f, -0.06040792f, -0.10070342f, 0.02321054f, -0.04788006f, 
    -0.12167621f, -0.02663641f, 0.09483188f, 0.13811301f, 0.25647414f, 0.10693987f, 0.15280411f, 0.31270269f, 
    0.02143127f, -0.09161256f, -0.26977652f, -0.68364698f, 0.10990356f, 0.06622067f, 0.01088769f, 0.06535002f, 
    -0.00973747f, -0.18841787f, -0.29561657f, -0.25907871f, -0.01595269f, 0.06028116f, 0.06112182f, -0.09518515f, 
    0.04936425f, -0.07950343f, 0.08915703f, 0.01307514f, 0.07070015f, 0.12589292f, -0.01194999f, 0.09412969f, 
    -0.01427079f, 0.05716901f, -0.13757432f, 0.14755712f, -0.20687063f, -0.17341471f, -0.17474745f, -0.33601126f, 
    -0.16965415f, -0.03646300f, -0.05496353f, -0.09971935f, 0.26424712f, 0.08513310f, 0.18480611f, 0.16153811f, 
    0.08695736f, 0.22295047f, -0.19718362f, 0.06276792f, 0.07169507f, -0.00784465f, 0.18972014f, 0.26011366f, 
    0.14504430f, 0.02826118f, -0.09411477f, -0.05168555f, 0.14030644f, -0.22106364f, -0.10583656f, 0.03909893f, 
    0.03867688f, 0.21352297f, -0.06195453f, -0.05943639f, 0.00248725f, 0.12405784f, 0.08656037f, -0.27305323f, 
    0.41103774f, 0.43881175f, 0.02038761f, 0.00318961f, 0.00145205f, 0.13869695f, 0.07093158f, 0.09822772f, 
    0.15016322f, -0.29982787f, 0.00598656f, -0.05209047f, 0.01713572f, -0.17164013f, 0.07171683f, -0.14683476f, 
    0.01935220f, 0.12458009f, -0.09068111f, 0.35908812f, -0.05792395f, -0.12549958f, 0.27751455f, 0.07602927f, 
    -0.07807627f, -0.11391918f, -0.16141872f, 0.25963372f, 0.24105150f, 0.26379493f, 0.12036886f, 0.09000906f, 
    0.16984798f, 0.09612493f, 0.09675474f, -0.00598580f, 0.01708410f, -0.12906837f, -0.03076894f, 0.11739674f, 
    -0.09974691f, -0.15156868f, 0.20519945f, 0.09762207f, 0.07382620f, -0.17330250f, -0.46172798f, -0.18615317f, 
    -0.06499803f, -0.18749237f, 0.12375353f, 0.00888239f, 0.17327863f, -0.03097381f, -0.50436443f, -0.10166491f, 
    0.05589451f, -0.14626558f, -0.00741179f, -0.18121411f, -0.02727502f, 0.39265579f, 0.04760328f, -0.21337408f, 
    -0.15511642f, -0.00064680f, -0.29143131f, -0.06245239f, -0.30588475f, -0.16175997f, -0.23324645f, 0.08250012f, 
    -0.06454363f, 0.03058589f, -0.02390071f, 0.09050739f, 0.11834081f, 0.03422969f, 0.04497973f, 0.03338595f, 
    -0.13072920f, -0.21105137f, -0.18155864f, -0.03570755f, -0.19298340f, 0.14175235f, -0.07708355f, 0.09743796f, 
    -0.08752889f, -0.00276407f, -0.15336841f, 0.10055900f, 0.22598283f, 0.03407663f, -0.01018511f, -0.04515184f, 
    -0.20754124f, 0.15449655f, -0.06300218f, -0.15081669f, -0.03066969f, 0.22000425f, -0.05313582f, -0.20102586f, 
    -0.05368628f, -0.00437229f, -0.15370214f, 0.11219329f, -0.06152904f, -0.11111075f, -0.36754864f, -0.10089054f, 
    -0.09979810f, -0.01616957f, 0.25153914f, 0.01754945f, 0.03090974f, 0.49558613f, -0.13005769f, -0.22580837f, 
    -0.00250077f, 0.06335378f, 0.03456673f, 0.04608490f, 0.06514499f, -0.05744585f, 0.08831634f, 0.17534596f, 
    -0.10589591f, -0.01346356f, -0.09398787f, -0.06205809f, 0.07227995f, -0.06762907f, 0.00098517f, 0.09293589f, 
    0.18241359f, 0.01427854f, -0.26169243f, 0.07721416f, -0.03922090f, 0.04202244f, -0.07636338f, -0.27647567f, 
    0.19630425f, 0.02350082f, 0.18339908f, -0.10449740f, 0.15904854f, 0.16615038f, 0.08909835f, 0.14160912f, 
    -0.12997955f, -0.76632589f, -0.08343881f, -0.04085359f, -0.13725071f, -0.16384369f, 0.15831804f, 0.10473206f, 
    0.15574428f, 0.13147296f, 0.40557438f, -0.35794827f, -0.43439761f, -0.09094396f, -0.06999356f, -0.01382848f, 
    0.21196271f, 0.12712066f, 0.17473608f, -0.08928944f, -0.42038083f, -0.11579253f, -0.05777992f, 0.22846809f, 
    -0.00666742f, -0.09018679f, 0.20301270f, 0.06789037f, -0.08633544f, 0.06101074f, 0.32080859f, -0.05093281f, 
    -0.01239806f, -0.07358163f, 0.07714729f, -0.14363065f, 0.05564429f, -0.84797871f, -0.39599720f, 0.09689590f, 
    -0.13658923f, -0.05197535f, -0.04521989f, -0.13959780f, -0.11340349f, 0.04906257f, 0.42170838f, -0.00996714f, 
    0.10742326f, 0.12793384f, 0.16956988f, 0.05424470f, 0.03381369f, 0.07819023f, 0.11352655f, 0.14918236f, 
    0.01547614f, -0.36404139f, 0.04020120f, -0.15968478f, 0.10919225f, -0.07581048f, -0.04404895f, 0.17184849f, 
    0.16297635f, -0.13534094f, -0.38842225f, -0.04299081f, -0.03024201f, -0.13159706f, 0.01506447f, 0.08510403f, 
    0.03839529f, -0.05268404f, 0.07020782f, 0.22582299f, -0.00937581f, -0.00204781f, -0.02117673f, 0.19381160f, 
    0.16331363f, 0.20894395f, -0.08594523f, -0.06842688f, 0.23498562f, 0.10916481f, -0.03530530f, -0.08958273f, 
    -0.10061618f, -0.45234078f, -0.16338764f, 0.28628805f, 0.57776797f, -0.01562640f, 0.01463664f, 0.22142933f, 
    -0.02171540f, 0.05740899f, 0.08567774f, -0.05507550f, 0.17315768f, -0.05625473f, 0.17351650f, 0.12711953f, 
    -0.07265088f, 0.09918707f, -0.12787025f, 0.16153429f, 0.09961309f, -0.13987793f, -0.04029621f, -0.17067638f, 
    -0.16661100f, -0.12520760f, 0.07224739f, -0.06895684f, -0.24797665f, -0.20102608f, 0.33056951f, 0.31790078f, 
    -0.25908244f, 0.05096366f, -0.11316691f, 0.00059012f, -0.03287035f, -0.10911283f, -0.02111471f, 0.23622073f, 
    0.20394199f, -0.30960786f, -0.15079618f, -0.02824092f, -0.18792874f, 0.07932509f, -0.16088217f, 0.02408887f, 
    0.24243370f, -0.03037816f, -0.13757761f, -0.11017493f, -0.03511503f, -0.03787949f, 0.08223690f, -0.07641686f, 
    -0.22324046f, -0.36247730f, -0.31316954f, 0.13174142f, -0.15103857f, -0.04708078f, 0.00226809f, -0.26025528f, 
    -0.10428365f, -0.02252947f, -0.00876263f, -0.00451290f, 0.09066804f, 0.11211646f, 0.13417342f, 0.13298212f, 
    0.01550728f, 0.00512228f, 0.05520596f, 0.28057456f, 0.11304300f, 0.02209193f, 0.07407075f, -0.18341064f, 
    -0.09053350f, 0.09890560f, 0.16020291f, 0.17620990f, -0.05975305f, 0.07227378f, 0.26307681f, 0.05483823f, 
    0.15390804f, -0.08302617f, -0.15494397f, -0.05104251f, -0.22035940f, -0.12413631f, -0.13891599f, 0.40245575f, 
    0.09097369f, 0.08398239f, -0.07097206f, -0.05160189f, 0.17655040f, 0.21022229f, -0.09240320f, 0.00541922f, 
    0.42976230f, 0.00898921f, -0.06665812f, -0.04977659f, -0.06272023f, 0.00387262f, 0.00067330f, -0.05828582f, 
    -0.17590316f, 0.30733430f, 0.03878371f, 0.08986636f, 0.01207433f, 0.01895040f, 0.16720319f, 0.22058618f, 
    0.20702431f, -0.19050159f, -0.46235564f, -0.06307680f, 0.03814108f, 0.09318592f, 0.09159791f, -0.10647781f, 
    0.11942624f, -0.19403462f, 0.11334356f, -0.00165931f, -0.00764689f, -0.21423432f, -0.05246237f, 0.09092165f, 
    0.14413850f, -0.17192113f, -0.23216508f, 0.40322250f, 0.07781373f, 0.00400977f, -0.00168450f, 0.10190540f, 
    -0.00726774f, -0.01361548f, 0.12939744f, -0.16199483f, -0.23023978f, -0.03415336f, 0.08335801f, 0.00507203f, 
    0.07539224f, 0.13671704f, 0.14125818f, -0.04296160f, -0.06317146f, -0.23670831f, -0.33231920f, -0.01546794f, 
    0.15166971f, 0.01750019f, 0.34597677f, -0.04819022f, -0.13084053f, 0.01016378f, -0.17341082f, 0.07440388f, 
    0.07153787f, -0.06760739f, -0.13156424f, 0.07999643f, 0.25976261f, -0.25140005f, 0.27685994f, -0.13538492f, 
    -0.30383575f, 0.12737437f, -0.12299532f, 0.13735457f, 0.07470839f, -0.00741102f, 0.06484761f, -0.06243235f, 
    -0.12604678f, 0.12481615f, 0.17753984f, -0.10407361f, 0.24677473f, -0.07503974f, -0.11445072f, 0.05455419f, 
    -0.00400718f, 0.01483139f, -0.35907328f, -0.10662433f, 0.08582869f, 0.18900630f, 0.08915679f, 0.05888037f, 
    0.00625627f, -0.06884564f, 0.23716064f, 0.35741287f, -0.06107536f, -0.14323351f, -0.02533987f, 0.06156948f, 
    0.09391721f, -0.07366738f, -0.09272739f, -0.08154221f, 0.14149718f, 0.11728579f, -0.02168804f, -0.05965201f, 
    -0.17611925f, 0.26071575f, -0.10203859f, 0.08778819f, -0.35825199f, -0.10497415f, 0.05423294f, 0.14894190f, 
    0.10921212f, -0.08711743f, -0.19082049f, -0.16907196f, -0.16193922f, -0.20140630f, 0.14479655f, 0.08291540f, 
    0.05715846f, 0.12524110f, 0.11628145f, 0.08126314f, 0.02482848f, -0.16758750f, 0.07364296f, 0.07552639f, 
    0.00264549f, 0.03745002f, 0.04661295f, 0.11989489f, 0.03902283f, 0.10442877f, 0.43911821f, 0.27840719f, 
    -0.27819011f, -0.00221660f, 0.07206120f, 0.01146229f, 0.01244605f, -0.18156368f, -0.19351894f, 0.39001697f, 
    0.17994638f, 0.08730556f, 0.13975155f, 0.11462191f, -0.03096101f, -0.05537867f, -0.12458637f, -0.29220945f, 
    -0.05614695f, 0.23161387f, 0.05656899f, -0.17394014f, -0.00510207f, -0.06781355f, 0.07012337f, -0.03126334f, 
    0.04559585f, -0.03788220f, -0.06834977f, 0.09487640f, 0.05043210f, -0.16373806f, 0.08190528f, -0.03278453f, 
    0.00481593f, 0.17424302f, -0.06078704f, 0.20532109f, 0.20424654f, 0.01708455f, -0.11496262f, -0.15029097f, 
    -0.04672506f, 0.21187419f, -0.05067971f, 0.32829830f, 0.44394836f, 0.33218476f, -0.19626462f, -0.07454147f, 
    -0.09786361f, -0.06035135f, -0.03984378f, 0.14803585f, 0.07168312f, 0.17480896f, 0.06635160f, -0.06207277f, 
    0.06003586f, 0.26028678f, 0.10118453f, 0.02249509f, -0.06590743f, -0.15509546f, -0.62594026f, -0.20743002f, 
    -0.09786674f, 0.11289725f, 0.24113759f, 0.15219581f, 0.12635820f, 0.07959620f, -0.05879984f, 0.01229393f, 
    0.16406743f, 0.08353090f, 0.06061995f, -0.15911843f, 0.02236760f, 0.17871806f, 0.16351353f, 0.04658725f, 
    -0.23589574f, 0.10317018f, 0.12151030f, -0.09463745f, -0.10412362f, 0.08031673f, -0.19863570f, 0.15171830f, 
    -0.51454008f, -0.59929472f, 0.22231761f, -0.16165628f, 0.20595226f, -0.39836511f, 0.02008102f, -0.14249627f, 
    0.03196556f, -0.08907679f, -0.19100404f, 0.20217775f, 0.08512655f, 0.01743834f, -0.10554609f, 0.08177830f, 
    0.04514858f, 0.09738334f, -0.05039816f, 0.33946657f, 0.02486449f, -0.02622736f, -0.13817924f, 0.35517359f, 
    -0.00036124f, -0.04121671f, -0.04506999f, 0.11545482f, 0.12857504f, 0.05721258f, -0.01801396f, -0.05444481f, 
    -0.04683664f, 0.15414803f, -0.04583895f, -0.01716576f, -0.35154924f, 0.34131727f, -0.18125203f, 0.01399134f, 
    -0.00778152f, -0.04804325f, 0.06874581f, -0.11057385f, 0.18491068f, -0.03316185f, 0.24210301f, 0.38217077f, 
    -0.01507181f, -0.14129093f, -0.17730673f, -0.00117226f, 0.02792219f, -0.00826956f, -0.28998441f, 0.07032736f, 
    -0.24918588f, -0.01568540f, 0.01358871f, -0.02406448f, -0.23372364f, -0.08542008f, 0.13332410f, -0.38467184f, 
    0.16800629f, 0.12344883f, -0.03977229f, 0.08052704f, -0.10900065f, 0.03668655f, 0.10657319f, -0.19904631f, 
    -0.18828036f, 0.17874627f, 0.07928014f, 0.12585746f, 0.26442000f, -0.16214103f, 0.04527622f, -0.08578739f, 
    0.07266851f, 0.20697629f, -0.05879262f, -0.00057553f, -0.14646395f, 0.18308567f, 0.13552491f, 0.12790257f, 
    -0.04021804f, -0.03641433f, 0.02337268f, -0.17915106f, -0.09494939f, 0.07272244f, -0.24377632f, -0.08761252f, 
    0.08121127f, 0.04406983f, -0.12236021f, -0.35744768f, -0.29159275f, 0.00479484f, 0.03996718f, -0.03566498f, 
    0.04626711f, 0.20736699f, -0.00719990f, -0.02704286f, -0.10031804f, 0.14195502f, -0.06561978f, -0.05690941f, 
    -0.12658323f, 0.28649354f, -0.03007048f, 0.07452973f, 0.27680331f, -0.03015414f, 0.14067608f, -0.10737749f, 
    0.24260481f, -0.02108356f, 0.03158557f, -0.09592780f, -0.15324484f, -0.20528424f, -0.33271655f, -0.26725096f, 
    -0.00964857f, -0.07846357f, 0.01954575f, -0.03348872f, 0.04775480f, -0.16012679f, -0.31447786f, -0.34018752f, 
    -0.20982842f, -0.02306136f, 0.03847702f, 0.03576084f, -0.13747394f, -0.01589106f, -0.00716041f, -0.04660062f, 
    0.02346309f, 0.15724762f, 0.08982132f, 0.00422619f, 0.05302131f, -0.08728684f, -0.03223032f, 0.07720876f, 
    0.01053387f, 0.08884545f, -0.08156067f, 0.04851356f, 0.08080703f, 0.17684412f, 0.05889988f, 0.01128560f, 
    0.26568961f, 0.02142744f, -0.20453058f, 0.04154317f, 0.23617043f, 0.05118515f, -0.01188059f, 0.08797772f, 
    -0.01706946f, -0.13407998f, 0.23081078f, 0.07921904f, 0.26436478f, -0.01528371f, -0.12971652f, -0.03940054f, 
    0.04099282f, 0.15314311f, 0.11972878f, 0.23354131f, -0.19587693f, -0.07402181f, -0.17296919f, 0.19977108f, 
    -0.12540662f, -0.21642134f, 0.06372390f, 0.01239671f, -0.10318869f, 0.12085652f, 0.10820632f, 0.50703472f, 
    0.04419963f, 0.07982710f, 0.12018204f, -0.09176745f, 0.07955443f, 0.00897456f, 0.03881448f, -0.09125251f, 
    0.14760575f, -0.05227990f, 0.13575043f, 0.00547929f, -0.00995971f, -0.06487416f, 0.04582442f, -0.72295642f, 
    -0.32850784f, 0.30045792f, -0.13381934f, 0.10583165f, -0.11337436f, -0.04491573f, 0.10013863f, 0.13274506f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.31706646f, 0.15664171f, -0.00293568f, -0.04115161f, 0.38330221f, -0.02991803f, 0.00241042f, 0.10498822f, 
    -0.04184762f, 0.11977761f, 0.20687266f, 0.26432562f, -0.11043051f, 0.04894690f, 0.06748538f, 0.23774475f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.73195463f, 0.02160027f, -0.23928319f, 0.29466441f, -0.46884900f, -0.22726837f, -0.09507179f, 0.10010369f, 
    0.17577194f, 0.04547008f, 0.18116419f, 0.83871257f, 0.58363223f, 0.17822906f, -0.64909005f, -0.22061904f, 
    0.52097833f, 0.26281020f, 0.07371408f, 0.57139993f, -0.08362202f, -0.03158484f, 0.04246812f, 0.12550609f, 
    0.21362153f, 0.46199232f, -0.06221333f, -0.12235710f, -0.10234219f, -0.59433603f, -0.09883868f, 0.24120113f, 
    -0.30280110f, -0.73068708f, -0.23090577f, 0.62508523f, -0.34307829f, 0.09156063f, -0.03881937f, -0.09437503f, 
    0.14463305f, -0.62320554f, 0.43600714f, 0.40528235f, 0.32849637f, 0.18531714f, -0.19498049f, -0.05045247f, 
    -0.61947358f, -0.33593658f, 0.00504988f, -0.41897696f, 0.24355991f, -0.13245861f, -0.06782123f, 0.31210396f, 
    0.24462201f, 0.48728517f, 0.09526007f, -0.08175362f, -0.11342689f, 0.45407766f, -0.73699468f, -0.16194314f, 
    0.33199999f, 0.04515788f, 0.00989726f, -0.42933458f, 0.08929322f, -0.17310001f, 0.22973345f, 0.11817846f, 
    -0.19288146f, -0.24042042f, 0.08709837f, 0.12761357f, 0.30880278f, -0.28933471f, -0.16796336f, 0.14461470f, 
    0.28689161f, 0.11130419f, 0.05624875f, -0.87960941f, -0.27101913f, -0.10033209f, -0.34923595f, -0.57325459f, 
    0.05075267f, 0.22762106f, 0.08519825f, -0.33391944f, -0.01756788f, 0.09396788f, 0.46927559f, -0.16975005f, 
    0.24830739f, -0.48571491f, 0.03247155f, -0.24093358f, 0.15665330f, 0.26683700f, -0.38661095f, 0.43819553f, 
    -0.06256365f, 0.15991679f, 0.06021607f, 0.41074494f, 0.04704237f, 0.48050448f, 0.08189677f, -0.21332301f, 
    0.51606345f, -0.21341732f, 0.17775597f, 0.40931335f, 0.03993094f, 0.26072067f, -0.06025704f, -0.14567830f, 
    0.02815339f, -0.14487599f, 0.24060677f, 0.45409983f, 0.21308298f, -0.20271850f, -0.13767762f, 0.08901540f, 
    -0.35583040f, 0.44410720f, 0.05143333f, 0.02419223f, 0.48033765f, -0.19866128f, -0.09725928f, 0.46958143f, 
    -0.03390286f, 0.26713815f, -0.23375072f, 0.18473849f, -0.30549145f, -0.09478463f, 0.05672075f, 0.15582864f, 
    -0.19465812f, -0.00971667f, 0.23457904f, 0.23605129f, -0.07459228f, 0.27408794f, -0.04709036f, -0.34373924f, 
    0.17672838f, 0.18417378f, 0.25748637f, 0.28132716f, -0.50530666f, 0.20544446f, 0.31333572f, -0.19440417f, 
    -0.55115646f, 0.39908767f, 0.19286467f, -0.07471038f, 0.31367394f, -0.28843269f, 0.15534411f, 0.14017509f, 
    0.07745617f, 0.14650652f, -0.18128581f, -0.04637370f, 0.02409342f, 0.09680884f, -0.05030495f, -0.16909289f, 
    0.10881330f, -0.42322028f, 0.03754573f, 0.00468255f, 0.41508397f, -0.29821458f, -0.38584268f, 0.38562050f, 
    0.24821651f, 0.12818371f, 0.21624057f, 0.55793566f, 0.08779940f, -0.21193691f, -0.68814969f, 0.17978674f, 
    -0.33549798f, -0.67346185f, 0.04796134f, 0.09119223f, -0.13583425f, 0.10165025f, 0.34620017f, -0.04905510f, 
    -0.09754577f, -0.53886932f, 0.27826580f, 0.41339618f, 0.21333259f, -0.15012190f, -0.61308068f, -0.05395082f, 
    -0.05021256f, -0.20086637f, -0.01832962f, -0.06589046f, -0.06974062f, -0.20470789f, -0.14902422f, 0.09067392f, 
    0.20417047f, -0.24902093f, -0.03333205f, -0.09166673f, 0.04940653f, -0.23344696f, 0.00763479f, -0.19078127f, 
    0.22835355f, 0.06550932f, -0.25345156f, 0.03342897f, 0.47936478f, -0.27447101f, 0.00912155f, 0.30040908f, 
    0.16269964f, 0.41741094f, -0.25969863f, -0.24417849f, 0.02221182f, -0.11308497f, -0.02826883f, 0.40869603f, 
    0.42385113f, -0.21886449f, 0.17713879f, 0.12806283f, -0.24597812f, 0.23576066f, 0.23297176f, -0.27886337f, 
    0.11983453f, 0.09582890f, 0.02224063f, -0.17887987f, 0.07771432f, 0.15145957f, 0.00327761f, 0.04136407f, 
    0.05817100f, 0.08222231f, 0.14004587f, 0.51249558f, -0.35727963f, 0.12387029f, -0.08329604f, -0.17998894f, 
    -0.18981904f, 0.13877055f, 0.59641546f, -0.07878789f, 0.26857635f, -0.00032838f, 0.17081514f, -0.01102754f, 
    -0.03513613f, -0.19792217f, 0.20430458f, 0.04642924f, -0.00580443f, -0.23916864f, -0.21574607f, -0.17067342f, 
    -0.18531683f, 0.04107385f, 0.15265191f, 0.09991821f, -0.10195752f, 0.10459208f, -0.26629248f, -0.10205977f, 
    0.63292253f, 0.15504551f, 0.07097894f, 0.48553434f, -0.10190118f, -0.30157334f, -0.20237771f, -0.05806006f, 
    -0.20109376f, 0.40808943f, 0.21547811f, -0.07652586f, 0.02239468f, -0.30362099f, 0.21640076f, 0.24604243f, 
    -0.28073317f, 0.03283697f, 0.20934474f, -0.36408436f, -0.11563600f, -0.15099274f, 0.22213429f, 0.22800824f, 
    0.10020173f, 0.11909103f, 0.38250265f, -0.42422622f, -0.31819496f, -0.28369895f, 0.31451356f, 0.18952720f, 
    0.01393354f, -0.09079611f, 0.07361075f, -0.03264150f, -0.03109762f, -0.17619944f, 0.01596168f, -0.18238461f, 
    -0.10700986f, 0.09933282f, 0.00619153f, 0.16719301f, -0.14931487f, -0.12846164f, -0.27150375f, -0.19638240f, 
    -0.14560312f, 0.11877920f, 0.06482521f, -0.05780023f, -0.50989264f, 0.17511870f, 0.10074770f, 0.16573633f, 
    0.15652937f, 0.24211442f, 0.35439605f, -0.18876715f, 0.19364446f, 0.29166555f, 0.21683277f, -0.60081208f, 
    -0.32585657f, -0.37395287f, 0.03851160f, -0.56518650f, 0.38170883f, -0.61827457f, 0.38908750f, -0.04563172f, 
    -0.00555936f, 0.12106845f, 0.18779403f, -0.02087757f, 0.06442365f, -0.13968526f, -0.45525050f, 0.55429900f, 
    0.24551772f, -0.13022968f, -0.11299872f, -0.30196702f, -0.06503540f, -0.04863551f, 0.27168339f, -0.16891789f, 
    -0.22529693f, 0.07593702f, 0.32614759f, 0.15111421f, 0.14175536f, -0.50936329f, -0.04502144f, 0.31229496f, 
    0.07879152f, -0.16524836f, 0.09604360f, -0.01840442f, 0.41753879f, 0.23454717f, -0.19781637f, 0.05941588f, 
    0.13342692f, -0.28007782f, -0.05709344f, 0.44313738f, -0.21275853f, 0.55694056f, -0.14936972f, 0.30636802f, 
    -0.37932283f, -0.35750157f, 0.22090207f, 0.24818972f, 0.11675404f, -0.17735104f, 0.27672598f, 0.21472621f, 
    -0.08277532f, -0.04470344f, 0.48935655f, 0.20017625f, -0.00693135f, -0.18113008f, -0.73003936f, -0.20035630f, 
    0.41074359f, 0.09126261f, 0.04040137f, -0.23756529f, -0.03703511f, -0.60690725f, -0.09412753f, 0.23336032f, 
    -0.05515220f, -0.14560750f, 0.13684882f, 0.81941032f, -0.26636019f, -0.00916542f, -0.11829008f, 0.29111344f, 
    0.04800261f, 0.16020192f, -0.21141192f, 0.22835833f, 0.33208203f, 0.35590714f, -0.03730952f, -0.08527187f, 
    0.12465835f, 0.09659147f, 0.10515172f, -0.48023993f, -0.39125630f, 0.16264330f, -0.01747237f, -0.03054139f, 
    0.35607505f, -0.08222482f, 0.20267013f, 0.24195819f, -0.47412878f, 0.19020829f, 0.14251924f, -0.20787288f, 
    -0.12387841f, 0.04453069f, 0.21022385f, 0.67048430f, 0.43021235f, 0.17851216f, -0.51550114f, -0.14646924f, 
    -0.05028804f, 0.31841406f, 0.10667551f, 0.15475713f, 0.40384793f, -0.28782618f, 0.23368084f, 0.26749715f, 
    0.17383260f, 0.48976344f, -0.31145677f, -0.32204780f, -0.54290628f, -0.09447829f, 0.14126013f, 0.00193888f, 
    -0.51253098f, -0.23990162f, -0.18312246f, -0.02253980f, -0.27928966f, -0.13085319f, 0.35817292f, 0.22786166f, 
    -0.10997351f, -0.09927007f, 0.47369176f, 0.46748844f, 0.42432955f, -0.21462189f, 0.14673622f, 0.01507326f, 
    0.06797792f, 0.46796694f, 0.24475160f, 0.15928878f, 0.03036530f, -0.64249372f, 0.14238426f, 0.37058580f, 
    0.19425103f, 0.18984307f, 0.36904979f, 0.24742267f, -0.40658709f, -0.11145775f, -0.66967618f, -0.11314575f, 
    0.20825265f, -0.23582545f, 0.02325243f, -0.09940856f, 0.04683353f, -0.08350951f, -0.03505272f, -0.05987479f, 
    0.22387326f, 0.06011964f, 0.05334860f, 0.01820081f, -0.15961015f, -0.26297021f, -0.14656951f, -0.22955973f, 
    0.07033169f, 0.05357141f, 0.08907038f, -0.43834066f, -0.35303786f, 0.21217333f, -0.47967148f, -0.42822748f, 
    -0.11212302f, -0.01254102f, -0.34542793f, -0.08406823f, -0.17637475f, 0.08674993f, 0.36805692f, -0.12712330f, 
    -0.15298380f, 0.29141334f, -0.07141360f, -0.49807408f, 0.02439033f, -0.10888705f, 0.37434116f, 0.28811619f, 
    -0.11467119f, 0.15250948f, -0.04300966f, -0.17986737f, -0.21461743f, 0.07302029f, 0.02552583f, 0.12240796f, 
    -0.31488609f, 0.15211254f, -0.00663925f, -0.07257292f, -0.03524010f, 0.26161829f, 0.19651249f, 0.27965125f, 
    0.02676759f, -0.10485306f, 0.52894831f, -0.38268349f, 0.08410040f, 0.14576212f, -0.22889218f, -0.30083191f, 
    0.10065130f, -0.34132701f, 0.18513748f, -0.21554068f, -0.12003419f, 0.01892574f, -0.08265787f, 0.13085948f, 
    -0.04258256f, -0.20283315f, 0.21386659f, 0.52966231f, 0.39907673f, 0.18298608f, 0.40464869f, 0.03401782f, 
    -0.07413371f, -0.09668060f, 0.08148116f, -0.04018610f, 0.24049312f, -0.20509161f, -0.20865363f, -0.11846279f, 
    -0.05731282f, 0.19432400f, -0.14394180f, 0.19982547f, -0.02800614f, -0.20309737f, -0.01642669f, -0.24880856f, 
    -0.74096948f, -0.04984204f, -0.00042305f, 0.08626191f, -0.30869818f, -0.01902570f, -0.02597784f, -0.32492140f, 
    0.14501932f, 0.01221753f, -0.24111857f, 0.14838980f, 0.10631861f, 0.47132418f, 0.38405210f, 0.19182286f, 
    0.18820809f, 0.42585853f, -0.14420292f, -0.17608602f, -0.20943357f, 0.01862253f, -0.23670718f, -0.15672192f, 
    -0.25282708f, 0.39029711f, 0.10242371f, 0.11510871f, -0.20539564f, -0.01625712f, 0.01394670f, -0.01632452f, 
    0.11395001f, 0.36083701f, -0.08630037f, 0.28147954f, 0.35726491f, -0.42116633f, -0.22679546f, -0.01061415f, 
    -0.19814233f, 0.15397860f, 0.05889266f, 0.56727284f, -0.12677385f, -0.05483566f, -0.42875609f, 0.18682343f, 
    0.25472704f, -0.33418807f, 0.02892137f, -0.10971060f, 0.56446862f, 0.19607812f, 0.33859536f, -0.13356538f, 
    0.17769530f, 0.39892158f, 0.03764314f, 0.19811827f, -0.64462245f, 0.47496778f, -0.66635197f, -0.25839543f, 
    0.07984684f, 0.54241711f, 0.25029552f, 0.78168774f, -0.02128409f, -0.21107121f, 0.11407808f, 0.30335945f, 
    0.05780992f, 0.06337697f, 0.23189819f, -0.22285956f, -0.27061424f, 0.12509979f, 0.16078122f, -0.44541702f, 
    -0.38554522f, -0.28779015f, 0.15816540f, -0.12896216f, -0.01132692f, -0.02942853f, 0.27935788f, -0.02129778f, 
    -0.13417584f, 0.32818577f, 0.39452684f, -0.30036503f, -0.16299209f, 0.33703151f, -0.12187330f, -0.75656861f, 
    -0.21672271f, -0.19588578f, -0.08521147f, 0.12880054f, 0.28429210f, 0.17009930f, 0.16285953f, 0.02350406f, 
    -0.06634162f, 0.12940767f, -0.16005369f, 0.29906827f, -0.59546757f, 0.45878735f, -0.63448483f, 0.00668172f, 
    -0.05530055f, -0.21260870f, 0.20712650f, -0.00314018f, -0.15535192f, -0.08149267f, 0.17214060f, -0.09507110f, 
    0.17031762f, 0.02782797f, -0.17949612f, 0.14793782f, -0.09598844f, -0.10426224f, 0.10991322f, -0.02968811f, 
    -0.25894040f, 0.13860239f, -0.21206290f, -0.31471798f, 0.14720275f, -0.18461648f, -0.32503587f, 0.26798263f, 
    0.18643971f, -0.18557706f, 0.19486126f, 0.44962835f, 0.10976627f, 0.07224844f, 0.18229406f, 0.18402793f, 
    -0.38052174f, -0.29380062f, -0.09926965f, -0.13823438f, -0.10240648f, -0.16687196f, 0.22991380f, 0.12886262f, 
    -0.07004073f, 0.31799561f, 0.36600727f, 0.32723495f, -0.31540120f, 0.12250751f, -0.28874847f, -0.49427176f, 
    -0.19822036f, -0.04109715f, 0.03940566f, -0.14364052f, -0.16579680f, 0.05967553f, 0.09928103f, -0.01754939f, 
    -0.18424633f, -0.19032407f, -0.17700322f, 0.00843195f, -0.13608378f, 0.20714204f, -0.23989819f, -0.14530325f, 
    0.43320134f, -0.03475440f, -0.04258503f, 0.48159924f, -0.32638425f, 0.17594466f, -0.36913714f, 0.18229783f, 
    -0.08316953f, -0.03778220f, 0.02615429f, 0.58612853f, 0.20920561f, 0.42189643f, -0.27132571f, -0.02472545f, 
    -0.15609398f, 0.00717363f, -0.07297188f, 0.43330210f, 0.45287356f, 0.33616135f, 0.07269052f, -0.13019411f, 
    -0.22818044f, 0.40655702f, 0.10142301f, -0.48899680f, -0.02207574f, -0.23028147f, -0.48885474f, -0.05110891f, 
    -0.11895303f, 0.36121786f, 0.13207024f, 0.01958990f, 0.07218860f, -0.22857147f, -0.21888025f, 0.42911366f, 
    -0.13096687f, 0.26578104f, -0.14934236f, 0.30077377f, 0.27389905f, 0.20039423f, 0.13858111f, -0.17310695f, 
    -0.46913713f, 0.22315691f, 0.10258882f, 0.13491875f, -0.28086865f, 0.38704398f, 0.05441718f, -0.19133766f, 
    -0.00983514f, -0.54617155f, 0.15037547f, 0.45832369f, 0.00154463f, -0.32887796f, 0.19448234f, 0.06077578f, 
    -0.10163461f, 0.06526520f, 0.15691295f, 0.07205426f, -0.11302269f, -0.13617586f, 0.00727554f, -0.34313783f, 
    0.03665059f, 0.05338697f, -0.39149904f, 0.37487656f, 0.14296803f, 0.48585209f, -0.05355411f, 0.13069493f, 
    0.00520304f, -0.15536408f, 0.02329171f, -0.05874592f, -0.08692937f, -0.22444719f, -0.13894282f, -0.03089013f, 
    0.08757600f, -0.05984592f, -0.14413439f, -0.14491951f, 0.18601578f, 0.06363724f, -0.03318416f, -0.10707053f, 
    -0.43034902f, 0.19707812f, -0.22030899f, 0.33097175f, -0.19852586f, -0.03723360f, 0.42690119f, -0.12348828f, 
    0.09519725f, 0.01653369f, 0.53074014f, -0.04031248f, -0.26185539f, 0.29162857f, 0.20526852f, -0.35688683f, 
    0.31010583f, -0.09085273f, 0.15465328f, -0.27733409f, 0.28388414f, 0.05048959f, 0.30942824f, -0.15181927f, 
    0.19401868f, 0.17990817f, -0.25148126f, 0.27209798f, -0.17015813f, 0.47290945f, 0.09602579f, -0.19031204f, 
    0.55343598f, 0.55516303f, -0.06318857f, -0.27728492f, -0.19005090f, -0.19318995f, -0.08885046f, 0.03654824f, 
    0.22052142f, 0.28330234f, 0.08105315f, 0.16942035f, -0.36484382f, 0.21290638f, -0.11049602f, -0.18377231f, 
    -0.08829364f, 0.21778820f, -0.22675002f, -0.11493916f, -0.13064662f, -0.39645454f, 0.28924853f, -0.06239053f, 
    -0.23391598f, -0.10792562f, 0.67220563f, 0.50953239f, 0.24430573f, -0.11415482f, 0.23033480f, -0.09576478f, 
    -0.00170245f, 0.00367554f, -0.03551463f, 0.00194298f, -0.34090266f, 0.00217033f, 0.42018294f, -0.07699262f, 
    -0.22044379f, 0.21403457f, 0.15913616f, -0.52044964f, 0.11735061f, -0.09304569f, 0.22576781f, -0.30915818f, 
    0.09380461f, -0.42696697f, -0.24466765f, 0.33038658f, -0.14449941f, 0.16472927f, 0.23726863f, 0.07076370f, 
    -0.16693993f, 0.38920975f, -0.07545294f, -0.67638201f, -0.25918648f, 0.19819376f, 0.39852446f, -0.30564862f, 
    -0.20914815f, -0.68905967f, -0.15640402f, -0.02260849f, 0.41491193f, 0.04383661f, 0.06711825f, -0.14542347f, 
    0.21300945f, 0.07644270f, 0.13040659f, 0.56045645f, -0.25861341f, -0.00772141f, -0.49682510f, 0.47512931f, 
    -0.43117425f, 0.00418777f, 0.15352333f, 0.21269555f, 0.30199799f, 0.10879054f, -0.05125721f, -0.12993726f, 
    0.07142204f, -0.13618691f, -0.04190708f, 0.15041950f, -0.21921460f, 0.53781295f, 0.18393230f, 0.19296016f, 
    0.40284306f, -0.24078310f, 0.15696134f, 0.45081159f, -0.33010656f, 0.39929858f, -0.09930027f, 0.20539507f, 
    -0.13834670f, 0.23859568f, 0.46131781f, -0.16197352f, 0.21554571f, -0.13321695f, 0.06622271f, -0.31591827f, 
    -0.12717655f, 0.31258357f, 0.17507538f, -0.60205930f, 0.10718673f, -0.63266444f, 0.29299173f, 0.14962995f, 
    0.17639458f, -0.38850367f, 0.18913217f, 0.18052827f, -0.18348731f, 0.17092267f, 0.53672099f, 0.13396789f, 
    0.46136960f, -0.03374470f, 0.16591923f, 0.09905560f, 0.33211121f, -0.01761548f, -0.22354917f, 0.29826432f, 
    -0.12474012f, 0.23054071f, -0.11317416f, -0.12533461f, -0.11070025f, -0.35329360f, 0.50243217f, 0.17136933f, 
    0.37412184f, -0.44671744f, -0.00400194f, -0.08785240f, -0.44040596f, 0.07851487f, 0.07328966f, 0.25817233f, 
    0.04223661f, 0.26898095f, 0.37068155f, 0.22113678f, 0.34927481f, 0.50062692f, -0.08676454f, -0.47580048f, 
    0.11324038f, 0.26817247f, -0.21618921f, -0.41856834f, -0.16437261f, -0.30523336f, 0.30380553f, 0.23391864f, 
    0.21148127f, 0.34344265f, -0.09665737f, 0.04166459f, -0.13927402f, -0.10227412f, 0.05028470f, 0.17352472f, 
    -0.14075111f, 0.08312310f, 0.10942259f, 0.08411808f, -0.50588596f, 0.26439339f, 0.39455596f, 0.15948598f, 
    0.18950744f, 0.23932308f, 0.23294851f, -0.14126660f, -0.03512678f, -0.08585159f, -0.35383517f, -0.39828628f, 
    -0.16052121f, -0.08156553f, -0.16225398f, 0.08970073f, -0.10013983f, -0.13027358f, -0.22031969f, 0.00001210f, 
    -0.15569869f, -0.01197577f, -0.21682870f, 0.10775104f, 0.03423509f, -0.16498756f, 0.12335861f, -0.23746952f, 
    -0.54885262f, 0.13979086f, 0.07761666f, -0.04538933f, -0.36037311f, 0.15044612f, -0.31813523f, -0.49068299f, 
    0.11648063f, 0.12314020f, -0.04286926f, 0.20144340f, 0.15775593f, 0.36997208f, 0.17654863f, -0.16460405f, 
    -0.61604863f, -0.58649343f, 0.07372829f, -0.30545196f, 0.42681080f, 0.14842728f, 0.13865148f, 0.43321070f, 
    -0.22264415f, 0.12277409f, -0.03234519f, 0.28368211f, -0.25752810f, 0.20288761f, -0.46102500f, -0.06421342f, 
    -0.39391249f, -0.33148840f, -0.19343510f, 0.50066912f, -0.16408753f, 0.03669349f, -0.10659938f, 0.16349785f, 
    -0.01134194f, -0.66605276f, 0.48086539f, 0.07733421f, 0.11280771f, -0.02031882f, 0.33996028f, -0.22496428f, 
    0.40714213f, 0.14215808f, 0.01595533f, 0.24009238f, -0.26649722f, 0.22577986f, -0.01263024f, 0.16990107f, 
    0.18972774f, 0.25292480f, -0.34564048f, 0.48514047f, 0.00614524f, 0.04399095f, -0.32985467f, -0.10031457f, 
    0.12191043f, -0.43086961f, 0.17460823f, -0.08651666f, 0.05530673f, -0.34494001f, 0.25489014f, 0.31769240f, 
    -0.15243106f, 0.26619765f, -0.07344656f, 0.06495750f, -0.54958725f, -0.26334685f, -0.00659273f, 0.40200725f, 
    -0.47169065f, -0.45833871f, -0.19176938f, -0.06551497f, 0.10605218f, 0.16817912f, -0.10114549f, 0.34120426f, 
    0.05524183f, 0.13085651f, 0.15750676f, 0.22113024f, -0.68962550f, 0.18133742f, -0.22139712f, 0.20025548f, 
    0.05275287f, 0.06714170f, 0.23053981f, -0.31593820f, 0.38007116f, -0.51268107f, 0.37987947f, -0.13712767f, 
    0.08052363f, -0.00328491f, -0.08448211f, -0.06901832f, -0.09349918f, -0.16021635f, 0.16027334f, 0.21519341f, 
    0.55717653f, -0.09380221f, 0.05495552f, 0.45386052f, -0.10966802f, -0.27726305f, -0.39795023f, 0.42850196f, 
    -0.02770112f, -0.11066346f, 0.09686871f, 0.29902914f, -0.02301804f, 0.11385480f, -0.41532892f, 0.32794556f, 
    -0.67145801f, -0.01617016f, 0.08930198f, -0.27534178f, 0.20898135f, -0.21665412f, 0.37261516f, 0.21775807f, 
    0.02728105f, 0.02812470f, 0.24185917f, -0.47530508f, 0.07251519f, 0.11021823f, 0.48678207f, 0.05985226f, 
    -0.23373602f, -0.11694531f, -0.03127899f, -0.59957027f, 0.11448435f, -0.62347740f, 0.05526638f, 0.17227240f, 
    -0.05116902f, -0.09514966f, 0.39063519f, 0.75845957f, 0.01391945f, -0.04702833f, -0.15679930f, 0.16771939f, 
    0.32612664f, 0.11179734f, -0.05443672f, 0.07473584f, -0.30143240f, -0.18573551f, -0.19095631f, 0.22634976f, 
    0.21438532f, 0.16995114f, 0.22075291f, 0.28984869f, 0.37458211f, 0.06898557f, -0.06737436f, 0.09020196f, 
    0.01986348f, 0.02669424f, -0.07028452f, -0.12075143f, -0.05976070f, -0.16973624f, 0.07341352f, -0.12802576f, 
    0.10985214f, -0.10726668f, -0.20641373f, 0.16477163f, 0.19039397f, -0.15095870f, 0.07205654f, -0.11090630f, 
    -0.39961794f, 0.13465409f, -0.15595463f, -0.13772565f, 0.05116862f, -0.18797325f, 0.16088524f, 0.46345142f, 
    -0.22586681f, -0.22236729f, 0.43066964f, -0.07598100f, 0.18396132f, -0.09236541f, -0.27931365f, -0.20171969f, 
    -0.44507527f, -0.08449560f, 0.21112303f, -0.32688609f, 0.00244042f, -0.13755496f, 0.08859972f, 0.08019727f, 
    -0.23447037f, -0.15512402f, 0.10656776f, -0.12319419f, 0.20232397f, 0.00654059f, -0.11023837f, 0.16238917f, 
    -0.03688772f, -0.03328830f, 0.00514276f, 0.10312521f, 0.25919554f, 0.38753885f, -0.07707178f, 0.39314216f, 
    0.05715501f, -0.01045547f, -0.13840874f, 0.47843778f, -0.27057427f, 0.55279124f, -0.20959732f, -0.35220790f, 
    -0.12348031f, -0.26967639f, 0.11217293f, -0.40528396f, 0.40412438f, 0.11446539f, 0.36745754f, -0.01131743f, 
    -0.15730605f, 0.14511958f, 0.02309715f, 0.47814366f, -0.12629238f, 0.39737889f, -0.49512842f, -0.29206946f, 
    -0.17598864f, -0.11650218f, 0.18805952f, 0.16949698f, -0.23778580f, 0.36480749f, 0.08549012f, -0.07973943f, 
    0.08973083f, 0.15906309f, 0.11728627f, 0.04466049f, -0.53275502f, 0.46564579f, 0.38658091f, -0.59090567f, 
    0.90717542f, -0.11566327f, 0.20868504f, 0.49379119f, -0.12806046f, -0.10554466f, -0.19288966f, 0.20738313f, 
    -0.19465500f, -0.17749657f, 0.12638213f, 0.51376677f, 0.09651656f, 0.00423089f, -0.51168442f, 0.05744172f, 
    -0.21837270f, 0.12773627f, 0.06458089f, -0.12821138f, 0.21038401f, -0.09726603f, -0.12220432f, 0.02334781f, 
    0.12416407f, -0.11477647f, -0.00825526f, -0.09827155f, -0.06281295f, -0.20470425f, -0.11831741f, -0.18109058f, 
    0.41797361f, -0.62252116f, -0.00187511f, 0.08192115f, 0.39608493f, 0.25679004f, -0.21666549f, 0.19761366f, 
    -0.15671515f, 0.08413483f, 0.30530715f, -0.12308431f, -0.13738848f, -0.07216740f, 0.19403169f, 0.27533254f, 
    0.28410497f, -0.09891379f, 0.15711573f, 0.21624044f, 0.16029967f, -0.01520364f, 0.18602788f, -0.33391300f, 
    0.14015271f, -0.01602871f, 0.22589229f, 0.56932884f, -0.27641174f, -0.08601710f, -0.25269294f, 0.18168131f, 
    0.32721078f, -0.60119116f, -0.12078502f, -0.23354533f, -0.10230692f, -0.33187151f, 0.32488269f, -0.09507579f, 
    0.23968250f, 0.30829427f, 0.26915506f, -0.15846866f, -0.66841948f, 0.46339941f, -0.43900824f, -0.06499859f, 
    -0.11915717f, -0.07334331f, -0.08814838f, -0.09113225f, -0.06370321f, -0.03612000f, 0.23960023f, 0.41422376f, 
    -0.02093459f, -0.12234639f, 0.34185964f, -0.55165601f, -0.09117922f, 0.09561156f, 0.34785718f, -0.33859357f, 
    0.46136516f, -0.07326119f, 0.20176217f, 0.53600055f, 0.31296510f, 0.10572200f, -0.41176587f, -0.22951643f, 
    0.09874851f, 0.26110372f, 0.34408289f, 0.11751393f, -0.04668912f, 0.36390540f, -0.23402545f, -0.05153999f, 
    0.71839041f, 0.04334764f, 0.03849991f, -0.13279988f, -0.42466143f, 0.15797363f, -0.24228834f, 0.08359499f, 
    -0.03931183f, 0.59003192f, 0.14946738f, -0.50443983f, -0.18213096f, 0.00439206f, -0.21893561f, 0.07010058f, 
    -0.16121939f, 0.26569626f, 0.18532467f, 0.03746881f, 0.33627677f, -0.12960482f, 0.31341103f, -0.58874005f, 
    0.15153648f, 0.05885453f, -0.55775642f, -0.03771776f, -0.06608072f, 0.31553996f, 0.03129232f, 0.09073310f, 
    -0.13365932f, -0.20444779f, 0.02386039f, -0.07417000f, -0.18667176f, 0.04187567f, 0.16030197f, -0.14015362f, 
    -0.14116210f, -0.06134042f, -0.19468004f, -0.21993119f, 0.16474073f, -0.06318685f, -0.24410811f, -0.18860462f, 
    0.16052830f, -0.76940924f, -0.02818639f, -0.31071660f, 0.33246872f, 0.23739278f, 0.52394551f, -0.22670504f, 
    -0.24187225f, 0.33532533f, 0.39049360f, -0.12898262f, -0.15555942f, 0.01157214f, -0.23982842f, -0.40213358f, 
    -0.02115604f, -0.38398561f, -0.13397206f, 0.25172216f, 0.26622081f, -0.02631919f, -0.26586279f, 0.41444981f, 
    -0.00646433f, -0.35189950f, 0.37993881f, -0.20178056f, 0.31634218f, -0.14591622f, 0.43842682f, -0.02894922f, 
    0.38671699f, -0.25848258f, 0.02362673f, 0.20576626f, 0.13057275f, -0.02676653f, -0.07236564f, 0.52604401f, 
    0.20328310f, 0.01387857f, -0.05733554f, 0.46974993f, -0.27226841f, -0.16802597f, -0.55176479f, 0.01684303f, 
    -0.35814598f, 0.07201347f, 0.11473044f, -0.25516894f, 0.54093164f, 0.12416878f, 0.06872553f, 0.21155640f, 
    0.12365214f, -0.02653630f, 0.09515149f, -0.01321760f, -0.28118369f, 0.04793762f, -0.02807310f, 0.13127618f, 
    -0.10292622f, -0.15879169f, 0.12560982f, 0.11926299f, -0.13544023f, -0.24772906f, 0.04147716f, -0.10197026f, 
    0.23945400f, -0.16335049f, -0.01895850f, -0.18541864f, 0.01807140f, -0.09459877f, -0.10937118f, 0.21750608f, 
    0.63063359f, 0.11609448f, 0.11126561f, 0.41068494f, -0.24074169f, -0.02355882f, -0.26224923f, 0.01957038f, 
    -0.13123374f, 0.30855638f, 0.02097317f, 0.12762938f, 0.24697220f, -0.27791628f, 0.16793777f, 0.01629014f, 
    -0.01505047f, 0.22990750f, 0.18832575f, 0.12165526f, -0.18086746f, -0.69740975f, 0.06068498f, -0.13700140f, 
    0.19072348f, 0.20618774f, -0.12186632f, 0.29534814f, 0.25730217f, 0.10968675f, 0.53044498f, 0.10587824f, 
    0.19271745f, -0.27727103f, -0.22751839f, 0.14088805f, 0.09460486f, 0.22600874f, -0.08031029f, 0.16058372f, 
    -0.04812217f, -0.04421151f, -0.05951824f, 0.46031412f, 0.00286631f, -0.15062106f, -0.47837782f, 0.26986229f, 
    -0.50571120f, -0.35399130f, -0.17144868f, 0.20899263f, 0.13532229f, 0.16317023f, 0.36111060f, 0.05073941f, 
    0.09387597f, -0.46524706f, 0.24546425f, -0.10702179f, 0.31760383f, -0.26192552f, -0.41852090f, 0.03776041f, 
    -0.18953381f, -0.59999478f, 0.13090423f, 0.16029695f, 0.62485695f, 0.06913402f, 0.21902740f, -0.23220113f, 
    0.06524113f, 0.12431462f, 0.26683319f, 0.47878322f, -0.35583979f, -0.13132089f, -0.59895772f, 0.29601321f, 
    0.25392652f, -0.40627655f, -0.15516704f, -0.18317451f, 0.42087415f, -0.46439010f, 0.17399907f, 0.52273816f, 
    0.05512310f, 0.24823421f, -0.15534519f, -0.13499963f, -0.35334656f, -0.37519655f, 0.01452472f, 0.42672491f, 
    0.45409429f, -0.34144855f, 0.11860070f, 0.06212621f, -0.40189695f, 0.36420161f, -0.07670409f, 0.32656965f, 
    -0.01749007f, 0.38287857f, -0.19212796f, 0.16890258f, -0.42767647f, 0.24179161f, 0.40627033f, -0.36892039f, 
    0.06042255f, 0.02682289f, -0.09796203f, -0.36356673f, -0.12128657f, -0.60248137f, -0.13634595f, 0.34921286f, 
    -0.01548028f, 0.09814088f, 0.01137748f, 0.08731469f, 0.11801599f, -0.03411226f, 0.49129653f, 0.21298875f, 
    -0.07094220f, 0.43250436f, 0.12875625f, 0.52854776f, 0.15593970f, 0.13587271f, -0.23480123f, -0.15117452f, 
    -0.14484629f, 0.14958382f, -0.17232254f, 0.04492071f, -0.23154972f, -0.19745436f, 0.07485081f, 0.27800271f, 
    -0.23513553f, -0.19687819f, -0.17447188f, -0.01947974f, 0.19622906f, -0.19277382f, 0.08701638f, -0.08266217f, 
    -0.09853870f, -0.19555771f, -0.23351707f, -0.12050080f, -0.14984500f, 0.08830353f, -0.19204462f, -0.21682586f, 
    0.54807669f, -0.24223776f, 0.08244876f, -0.17547862f, -0.23406428f, 0.01512813f, -0.38944289f, 0.09188437f, 
    0.21165538f, -0.13612162f, -0.00410546f, 0.41470113f, 0.19405073f, 0.25291592f, 0.45985445f, 0.27565351f, 
    0.51044828f, 0.37676129f, 0.12722674f, 0.33244842f, 0.00472415f, 0.11688970f, -0.16925605f, -0.01195811f, 
    -0.11968875f, 0.43522006f, 0.11313468f, -0.12590896f, -0.21971987f, -0.29461852f, -0.03269178f, -0.00051662f, 
    0.14991967f, -0.21400754f, 0.09255287f, -0.13670529f, -0.26167178f, -0.02551768f, 0.01549869f, -0.21217947f, 
    -0.23563018f, -0.21363133f, -0.08983608f, -0.14637581f, 0.03120713f, -0.14966883f, 0.02840718f, 0.11908906f, 
    0.34933341f, -0.00037312f, -0.09432320f, -0.00255378f, 0.20024003f, -0.00275868f, 0.04068760f, 0.15163751f, 
    0.06952568f, 0.35069767f, -0.10757180f, 0.10478324f, -0.26915723f, -0.11704598f, -0.08751293f, 0.22740062f, 
    0.34477031f, -0.20266251f, 0.21869147f, -0.54201448f, 0.06818622f, 0.19434263f, -0.00845155f, 0.28129867f, 
    0.07585815f, -0.08477014f, -0.36326900f, 0.55182910f, -0.16613953f, 0.18086724f, -0.01679906f, 0.18522288f, 
    0.04603147f, -0.35512918f, 0.16987932f, 0.36209950f, -0.01929894f, -0.25748056f, 0.33771086f, -0.08880847f, 
    0.19392225f, 0.46749076f, -0.11972516f, -0.45964569f, 0.31849813f, 0.27993479f, -0.26162270f, -0.34878889f, 
    0.47197983f, -0.26825923f, 0.00973142f, 0.33267930f, 0.16069557f, -0.18349528f, -0.22781542f, 0.18476912f, 
    -0.22317290f, -0.24762905f, 0.18833646f, 0.69870353f, 0.14993271f, 0.19192129f, -0.58748418f, -0.04354988f, 
    -0.72264123f, 0.33372295f, 0.19822055f, 0.22920977f, 0.21235287f, 0.07350479f, 0.05427847f, 0.13568018f, 
    -0.07539888f, 0.57908839f, 0.39136407f, -0.60099411f, -0.69849229f, 0.16649461f, -0.27465019f, -0.22441407f, 
    -0.00623346f, 0.27966294f, 0.07190264f, -0.05236533f, 0.23979105f, -0.83816695f, -0.09993877f, 0.25297439f, 
    -0.16904989f, 0.06871023f, 0.02189074f, 0.22421652f, -0.19068959f, -0.09907822f, 0.25519133f, 0.27090830f, 
    0.03814068f, 0.29955557f, 0.11650470f, -0.58757180f, -0.37675163f, -0.08620640f, -0.36176115f, -0.65652043f, 
    0.14962763f, 0.09263983f, -0.40696993f, -0.75505006f, -0.18551159f, 0.20894572f, 0.16825943f, -0.01738518f, 
    -0.25038576f, -0.07708485f, 0.13749281f, -0.30902871f, 0.41196933f, 0.32156950f, -0.01488620f, -0.02881913f, 
    0.19139655f, -0.28553528f, 0.38615373f, -0.16115554f, -0.27094239f, 0.28114954f, 0.06287681f, 0.06701132f, 
    -0.02038986f, 0.40695256f, 0.00287697f, -0.25125659f, 0.39908138f, -0.35273457f, 0.15810454f, -0.05872832f, 
    0.01231521f, 0.36906990f, -0.22215600f, -0.25550482f, -0.31711909f, 0.62585813f, 0.14266576f, -0.02430778f, 
    -0.05067987f, -0.07867210f, 0.11115766f, -0.28787017f, 0.11582785f, -0.57364178f, 0.14495225f, 0.32226142f, 
    0.02567513f, -0.41958213f, -0.03533374f, 0.76253492f, 0.10536347f, 0.22517608f, -0.39621386f, 0.02781718f, 
    0.06703919f, 0.09454209f, -0.03137406f, -0.29879177f, 0.56742406f, 0.24768916f, 0.32400218f, -0.14229411f, 
    0.03292805f, 0.10723278f, -0.11605641f, -0.24251822f, -0.40113300f, 0.01720412f, -0.47046229f, 0.22385177f, 
    0.01434315f, -0.35892472f, 0.00476574f, 0.17725445f, 0.23105484f, -0.38385168f, -0.33081892f, 0.21813911f, 
    -0.20915930f, 0.03845211f, 0.27983707f, -0.36724362f, 0.28918877f, -0.29485083f, -0.17298745f, 0.39081228f, 
    -0.16553536f, 0.08912346f, 0.02850753f, 0.21767338f, 0.11795881f, -0.21047178f, -0.02054545f, -0.09086103f, 
    0.11382121f, -0.12225456f, -0.21739244f, -0.21420845f, 0.21093972f, -0.06665889f, -0.09433068f, -0.19945154f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03581860f, -0.18801272f, -0.18127930f, 0.21883048f, 0.34369722f, -0.05510803f, -0.15308298f, -0.05858328f, 
    0.50016922f, 0.19244003f, 0.16082522f, 0.14160945f, -0.17142573f, -0.14211482f, 0.20095101f, -0.13224442f, 
    -0.07798757f, -0.21434337f, -0.05397255f, 0.15725426f, -0.22174847f, 0.01274433f, 0.24933919f, 0.15144344f, 
    0.38081259f, 0.14635646f, 0.57463264f, 0.25462314f, -0.33913258f, 0.37230721f, 0.22624370f, -0.07390658f, 
    0.11091496f, 0.55631703f, 0.16917333f, 0.28968641f, 0.00891270f, -0.09122039f, 0.11016324f, 0.17707822f, 
    0.15354684f, 0.17158762f, -0.08078332f, 0.11821949f, 0.29892433f, -0.24794492f, 0.11690032f, 0.29726699f, 
    0.12323938f, -0.25351033f, 0.18358031f, 0.14738020f, -0.25865749f, -0.01921943f, -0.06227094f, 0.09493548f, 
    0.21366291f, 0.25630689f, 0.55733699f, -0.42347026f, -0.13385168f, 0.41149309f, 0.14236039f, -0.14626193f, 
    -0.06878348f, 0.32144076f, -0.09003492f, 0.03308987f, -0.23211046f, -0.05882704f, 0.18350662f, 0.36735564f, 
    -0.02713823f, 0.00917446f, 0.21665564f, 0.26187408f, 0.44805419f, -0.04620605f, -0.09690299f, 0.18769439f, 
    0.00162984f, -0.07694218f, -0.07964767f, 0.26240087f, -0.05868343f, 0.33343607f, 0.01900840f, -0.06584021f, 
    -0.17100917f, -0.17803888f, -0.01076601f, 0.26636645f, 0.15280215f, 0.40915835f, 0.24081032f, -0.14648722f, 
    -0.26408458f, -0.11122606f, -0.10532542f, 0.01881876f, 0.38436159f, -0.26284060f, 0.35631636f, -0.14266248f, 
    0.00895504f, -0.27559444f, 0.25393310f, 0.32066211f, 0.17441210f, 0.12898172f, -0.38842309f, 0.09483324f, 
    0.16821206f, 0.06226595f, 0.09981392f, 0.23830955f, -0.00964622f, -0.19698074f, -0.22525692f, 0.23653951f, 
    0.30226138f, -0.02330076f, 0.39243603f, 0.17076589f, -0.01184536f, -0.05050194f, 0.29077649f, -0.18315957f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.15167342f, -0.03862429f, 0.30232763f, -0.41265333f, -0.29448274f, -0.02217575f, -0.23233162f, 0.16571920f, 
    -0.94657314f, 0.18396690f, -0.15942256f, -0.18561082f, 0.07680020f, -0.03435849f, -0.47181678f, 0.12626947f, 
    0.22259900f, -0.02278094f, 0.16835104f, -0.14791968f, -0.10391156f, -0.00578758f, -0.51580977f, 0.02556446f, 
    -0.06905379f, 0.13166317f, -0.81974000f, -0.07521151f, 0.25395289f, -0.51148379f, 0.07450442f, -0.07378192f, 
    0.01319923f, 0.00723371f, -0.38558012f, 0.02404930f, 0.02946879f, -0.01067415f, -0.24334492f, -0.71513546f, 
    0.00804138f, 0.03437377f, 0.12801561f, 0.10384990f, -0.19800368f, 0.07040588f, -0.21872286f, -0.03122459f, 
    -0.04320069f, 0.13137588f, 0.10148927f, -0.27522030f, -0.02728356f, -0.20302720f, 0.08143485f, 0.20827429f, 
    -0.16777897f, -1.02636874f, 0.11933351f, 0.09592080f, 0.15904841f, 0.05357892f, 0.07045856f, 0.19069819f, 
    -0.28720066f, -0.15751104f, 0.18516611f, -0.35696912f, 0.05663440f, 0.06280805f, -0.39521921f, -0.83043420f, 
    0.21221952f, -0.06013626f, -0.65134329f, -0.92667723f, -0.29259607f, -0.15443313f, 0.01319494f, -0.29861468f, 
    -0.02896804f, -0.04463401f, -0.06143595f, -0.03859122f, -0.38116318f, -0.29196587f, 0.13348162f, 0.12736183f, 
    0.01413521f, 0.12716147f, 0.24753501f, -0.68963540f, 0.02338159f, 0.56856155f, -0.33933225f, -0.13092364f, 
    -0.02241275f, 0.10399292f, 0.13871674f, -0.57862461f, -0.31174552f, -0.00963846f, 0.08848670f, 0.04258870f, 
    0.03174329f, 0.15697779f, 0.00263421f, -0.93283045f, -0.37751913f, -0.33892006f, -0.06800724f, -0.08357895f, 
    -0.01068396f, -0.28916731f, -0.09858745f, -0.29318690f, 0.16783743f, 0.52278483f, 0.16511856f, 0.06682672f, 
    -0.45822072f, -0.45727110f, -0.07244197f, -0.37252635f, -0.47469658f, 0.03854500f, 0.10479005f, 0.06856439f, 
    0.18888713f, 0.00435889f, 0.40226275f, -0.81485194f, -0.05225688f, 0.14158864f, 0.01802696f, 0.15819278f, 
    -0.09861623f, 0.33873370f, -0.25672323f, 0.16528231f, 0.35897344f, 0.07095010f, -0.16852996f, -0.05576352f, 
    0.05242544f, 0.02792885f, 0.05737456f, -0.14941165f, 0.03071302f, -0.10544911f, -0.15567496f, -0.01595551f, 
    0.07044440f, 0.02410521f, 0.23333651f, -0.01044585f, 0.10655198f, -0.22007373f, 0.03212148f, -0.02284344f, 
    -0.01494032f, 0.54827249f, -0.21068999f, -0.01068973f, 0.01885029f, -0.05724888f, -0.00645331f, 0.25387418f, 
    0.10215610f, -0.14053246f, -0.22069702f, -0.62799096f, 0.00982217f, 0.05683771f, 0.02665560f, -0.11556014f, 
    -0.03491212f, 0.18297291f, -0.05716610f, -0.05702570f, -0.14029062f, -0.21722363f, 0.03523008f, -0.01186047f, 
    -0.01638454f, 0.37153026f, 0.03311843f, -0.40324017f, -0.64908803f, 0.31565443f, -0.01013254f, 0.05274409f, 
    -0.18607076f, 0.05835308f, -0.15227620f, -0.16959040f, -0.11828882f, 0.07788134f, 0.01063306f, -0.20767777f, 
    0.30181867f, 0.08999871f, -0.04669456f, 0.02578295f, -0.15999839f, 0.31183785f, -0.23306718f, 0.02384257f, 
    0.01520356f, 0.01390982f, -0.12458587f, -0.05993153f, 0.03402457f, -0.19385217f, -0.10861199f, 0.52435768f, 
    0.06214988f, 0.07614593f, 0.30618879f, -0.10397524f, -0.18921334f, 0.27879953f, 0.34303302f, -0.18197212f, 
    -0.08251592f, -0.35546875f, 0.06754185f, 0.12729040f, -0.04252781f, 0.06740782f, 0.09122296f, -0.15275481f, 
    0.17831835f, 0.11631295f, 0.11351268f, -0.12829037f, 0.05722058f, -0.12575901f, -0.00798396f, -0.08645175f, 
    0.10696217f, 0.08816089f, -0.03051798f, 0.03568976f, 0.00006743f, -0.68606716f, 0.25716156f, -0.53510875f, 
    -0.07559741f, 0.05202176f, 0.03636590f, 0.00763226f, 0.00633137f, -0.00097151f, 0.11148559f, 0.04199777f, 
    -1.02408421f, -0.30150592f, -1.14064336f, 0.51038176f, 0.11026845f, -0.03115078f, -0.09162512f, 0.10519405f, 
    -0.10533600f, 0.12184882f, 0.02236575f, 0.27842310f, -0.15791571f, -0.08435481f, -0.09464386f, -0.12530547f, 
    -0.18556248f, 0.08665586f, -0.46267700f, 0.05617233f, -0.01915339f, -0.22551405f, 0.46318787f, 0.21840142f, 
    0.17609820f, 0.26005828f, 0.05481246f, -0.01148543f, -0.05256381f, -0.14903511f, -0.03952529f, 0.16819249f, 
    -0.00677193f, -0.03046062f, 0.00012951f, 0.09678482f, -0.00045722f, -0.01623845f, 0.11987074f, -0.34634963f, 
    0.04348940f, 0.25157776f, -0.93790752f, 0.16573878f, 0.09351582f, -0.00715859f, 0.06832454f, 0.39368567f, 
    0.04958738f, -0.19681028f, 0.12798081f, -0.37704408f, 0.18527442f, -0.02671665f, -0.02205907f, -0.11538516f, 
    -0.09408915f, -0.44892719f, -0.10618199f, -0.17932728f, -0.58546841f, 0.47939339f, 0.11064522f, -0.28866524f, 
    -0.08744708f, -0.00530347f, -0.21706286f, -0.20158243f, -0.15020786f, 0.03048435f, 0.14284037f, 0.30020037f, 
    -0.87567949f, -0.14367346f, 0.12163597f, 0.30832416f, 0.01123400f, -0.46375009f, -0.07173186f, 0.44601306f, 
    -0.20190942f, -0.06266857f, 0.13779388f, 0.17340039f, -0.03416453f, 0.19484708f, -0.29310900f, -0.67151463f, 
    -0.02724168f, 0.12768984f, 0.28649423f, 0.45127511f, -0.16230698f, -0.06411684f, -0.39214700f, -0.15661360f, 
    -0.02267819f, 0.32201633f, -0.18178989f, 0.08288333f, 0.14145726f, 0.05100414f, -0.22394098f, -0.66837806f, 
    0.12939449f, 0.11263223f, 0.50991994f, 0.03057773f, -0.80215383f, -0.18726955f, 0.05067912f, -0.02026668f, 
    0.06142817f, -0.45584384f, -0.02721035f, -0.01873177f, -0.02005350f, -0.69581658f, -0.11798045f, 0.26790273f, 
    -0.02428439f, -0.44367531f, 0.20613420f, -0.34273204f, -0.03719024f, -0.00100274f, 0.06545189f, -0.00642121f, 
    0.15801129f, -0.79595619f, 0.06025381f, 0.36557963f, 0.26376331f, -0.15187463f, -0.21120304f, -0.11795246f, 
    -0.46411106f, -0.12377795f, 0.00749643f, -0.27985358f, 0.45279628f, -0.00505397f, -0.42815095f, 0.13929406f, 
    -0.03120185f, -0.06536139f, -0.59151262f, 0.08070452f, -0.01544809f, 0.16646647f, 0.30363381f, 0.16840142f, 
    -0.18472743f, 0.09934369f, -0.18069749f, -0.44563323f, 0.36499003f, -0.20038418f, 0.23550738f, -0.01616186f, 
    -0.03232518f, -0.15107790f, 0.18649158f, 0.15340169f, 0.10382929f, -0.07631755f, -0.28571641f, -0.39264536f, 
    -0.55470347f, 0.18098500f, -0.13940297f, 0.38664487f, -0.06853894f, 0.00397418f, -0.12848967f, 0.29005635f, 
    -0.06633861f, -0.23373081f, -0.29420075f, -0.22476180f, 0.47019684f, 0.04022947f, 0.03351768f, 0.17160700f, 
    0.14428008f, -0.73045528f, 0.21091382f, 0.26486984f, 0.00380562f, -0.15688236f, -0.20843233f, -0.06855395f, 
    0.24070965f, -0.73410773f, 0.22729275f, 0.13463664f, 0.30192780f, -0.08229224f, -0.44841328f, 0.10465469f, 
    0.02726635f, 0.11538246f, -0.04890778f, -0.17757431f, 0.26228806f, -0.78803551f, 0.14682780f, 0.19268763f, 
    -0.03484010f, -0.05645332f, 0.19399656f, 0.24123654f, -0.01737666f, 0.39486504f, 0.11262714f, -0.32642412f, 
    -0.00895374f, -0.48018315f, 0.10326263f, 0.63896126f, 0.15433529f, -0.67112011f, -0.63085020f, -0.46618354f, 
    -0.04397609f, 0.31882760f, -0.12634955f, -0.25337720f, -0.08263552f, 0.02032308f, -0.42363080f, -0.14398924f, 
    -0.04281150f, 0.22565441f, -0.10985146f, -0.29776934f, -0.11327797f, -0.11364888f, -0.60275823f, -0.07560471f, 
    -0.30358791f, -1.05659997f, -0.09632450f, -0.19492918f, 0.37209091f, 0.10395978f, -0.07209940f, -0.12261994f, 
    -0.38230225f, 0.06380569f, 0.01884539f, 0.27049124f, 0.27335200f, -1.24057519f, -0.17358306f, 0.00813134f, 
    -0.19325529f, 0.04603264f, 0.04784101f, -0.73395455f, -0.17747891f, -0.20808570f, -0.08968022f, -0.03906151f, 
    -0.08896201f, 0.22066107f, 0.11436567f, -0.30379111f, -0.13270375f, -0.06607834f, -0.08266149f, -0.04192241f, 
    0.11487037f, -0.08565003f, 0.06027260f, 0.24208069f, -0.08776195f, 0.08539256f, -0.90558356f, -0.11703888f, 
    -0.31340429f, -0.14277855f, -0.18728620f, 0.16067256f, -0.12859136f, 0.15228939f, 0.01616729f, 0.09318579f, 
    -0.08445243f, -0.15556629f, 0.12033647f, 0.13436498f, 0.05214820f, -0.03131431f, 0.04023654f, 0.11768218f, 
    -0.46556205f, -0.32089010f, 0.16334632f, 0.10480263f, -0.19677903f, 0.05777242f, -0.00531196f, 0.12409099f, 
    0.05062809f, -0.02856831f, -0.02693122f, 0.03007159f, -0.17762007f, 0.10186750f, 0.06280993f, 0.21667191f, 
    -0.25857061f, -0.46502060f, 0.08090349f, 0.17932092f, 0.28890666f, -0.83925140f, 0.03509954f, 0.10008355f, 
    0.13066705f, 0.05388235f, 0.00788850f, 0.01228876f, 0.09871400f, 0.04082080f, 0.24143328f, -0.44633782f, 
    0.20027728f, -0.03716077f, 0.10092877f, 0.02824793f, -0.14772874f, -0.19828147f, 0.10129135f, -0.11413197f, 
    0.01925065f, 0.03728398f, 0.18158776f, -0.01979218f, 0.04563010f, -0.64289677f, 0.21456504f, -0.36485702f, 
    0.03856933f, -0.03008498f, -0.09880327f, 0.04890683f, 0.24896872f, -0.34666434f, -0.10014235f, 0.11501600f, 
    -0.07836606f, -0.06604507f, 0.10868147f, -0.22499959f, -0.06448130f, 0.04080237f, -0.05354597f, 0.04863739f, 
    -0.38102299f, -0.15185477f, -0.52113807f, -0.10216583f, 0.52872264f, 0.16546814f, 0.03374270f, -0.04649685f, 
    0.02371738f, 0.06671073f, -0.04989383f, -0.09746074f, -0.52348119f, -0.22291946f, -0.21571608f, 0.22646530f, 
    0.13569045f, -0.87934518f, 0.00888919f, -0.90297985f, -0.38595337f, 0.04488253f, -0.07122535f, 0.02179568f, 
    0.14947858f, 0.31300533f, -0.33576491f, -0.01446013f, 0.02528235f, -1.26640511f, -0.09663235f, -0.00381154f, 
    0.02080048f, -0.56884795f, 0.13596717f, 0.22264534f, -0.27303180f, -0.03884684f, 0.06652134f, 0.03173221f, 
    -0.03187066f, 0.02495178f, 0.15818954f, 0.10859775f, -0.04216403f, -0.06641682f, 0.08900444f, 0.01374891f, 
    -0.34981215f, 0.15364581f, -0.03867679f, -0.06542695f, -0.05247365f, 0.13044353f, 0.11248775f, 0.26373756f, 
    -0.00119228f, -1.13155019f, 0.01601765f, 0.11399817f, -0.09333398f, 0.02223032f, 0.18673500f, 0.02228261f, 
    0.21879297f, -0.76377332f, -0.05633059f, -0.26823631f, -0.23860927f, 0.01016171f, -0.04116074f, -0.08288098f, 
    -0.02265490f, -0.10556059f, 0.18371882f, 0.09759957f, -0.26672623f, 0.18813880f, -0.01294964f, -0.14271076f, 
    -0.12122324f, -0.06292316f, 0.00162830f, 0.14178817f, 0.05051273f, -0.14294082f, -0.23161829f, -0.01710524f, 
    -0.14831023f, 0.01622695f, -0.06007255f, 0.11717386f, 0.09079350f, -0.06229699f, 0.02888708f, -0.02035957f, 
    -0.10464005f, -0.00446541f, 0.10257216f, -0.00231024f, 0.00413980f, 0.22527249f, -0.01219746f, -0.02115628f, 
    0.05999799f, 0.04314689f, 0.12764764f, -0.03914454f, -0.13923891f, -0.16885531f, -0.45366573f, 0.14678232f, 
    -0.10352614f, 0.06686328f, -0.19534776f, -0.95126599f, 0.06628998f, 0.02661994f, -0.16347498f, 0.29243663f, 
    0.00753645f, -0.30088377f, 0.01419214f, 0.20404693f, -0.05100526f, 0.05783644f, 0.03269513f, -0.00336969f, 
    0.03550368f, -0.04255161f, -0.19921105f, 0.14094429f, -0.28027254f, 0.05496380f, -0.01150009f, 0.05581072f, 
    -0.45019141f, 0.16380537f, -0.03123108f, 0.05322324f, -0.57790238f, 0.14081343f, 0.09814597f, 0.13827132f, 
    0.06581309f, -0.42158291f, -0.20586029f, -0.25603756f, -0.09384532f, -0.26426649f, 0.27171224f, -0.07187796f, 
    -0.26313758f, -0.13521436f, -0.27950412f, 0.02292931f, 0.02074219f, 0.57802689f, -0.34518397f, 0.00700906f, 
    0.05071287f, -0.00315108f, 0.06012233f, -0.70745844f, -0.30594283f, -0.07649744f, 0.23889770f, 0.16724032f, 
    -0.31627506f, -0.02060696f, -0.37075990f, -0.04170168f, 0.04676874f, -0.60950696f, 0.43891501f, 0.05088614f, 
    0.22430380f, -1.04107547f, -0.51905107f, 0.23987457f, 0.04645846f, 0.24966703f, -0.48806581f, -0.77880907f, 
    0.00815105f, -0.24994887f, 0.11076874f, -0.28949219f, -0.25580490f, 0.06278951f, 0.27553299f, -0.34347421f, 
    0.12144814f, 0.28949928f, -0.72584951f, -0.60446244f, 0.39007139f, -0.03521859f, -0.22460876f, -0.94469994f, 
    0.00772107f, -0.26812863f, 0.14721085f, -0.44599125f, -0.10881818f, 0.21295926f, 0.06862746f, -0.18629824f, 
    0.22010414f, -0.41692802f, -0.81483316f, -0.32402447f, 0.02173077f, 0.78292626f, 0.29516345f, -0.55059499f, 
    0.00986906f, 0.03996543f, -0.89917535f, 0.07242721f, -0.52849329f, -0.05889750f, 0.18927783f, 0.46368092f, 
    -0.31603619f, 0.00089105f, 0.37290546f, 0.36987805f, 0.26387289f, -0.95096266f, -0.00471394f, -0.74723095f, 
    -0.42073941f, 0.01073668f, -0.52888584f, 0.02438663f, 0.08943631f, 0.25105602f, -0.26227748f, -0.00583790f, 
    0.06507915f, 0.12774865f, 0.36309049f, -0.08130885f, -0.32560921f, -0.03508796f, -0.20288666f, 0.33473542f, 
    -0.01283438f, 0.11679582f, -0.96953940f, 0.14318092f, 0.22081614f, 0.00007055f, -0.24367161f, 0.00595620f, 
    0.13883626f, -0.23756248f, 0.78347766f, 0.26904848f, -0.30799317f, -0.11679327f, 0.03199520f, 0.08224790f, 
    -0.05052448f, -0.19619900f, -0.01896587f, 0.09915094f, 0.16022414f, -0.01904558f, -0.55779189f, 0.04739273f, 
    -0.39560801f, 0.44744775f, 0.23282827f, 0.18193766f, -0.00548226f, 0.31749180f, -0.63111556f, -0.06959128f, 
    0.21943916f, 0.14431860f, -0.03406127f, -0.14364839f, 0.08709129f, -0.37921101f, 0.50011486f, 0.14926694f, 
    -0.58393949f, -0.17685820f, -0.28774458f, -0.85146636f, -0.21261156f, 0.07735705f, 0.08806883f, 0.18547207f, 
    0.01401487f, 0.00886681f, 0.18773307f, -0.29103383f, -0.00226199f, 0.08861699f, -0.16447280f, 0.04564165f, 
    -0.05954966f, -0.10814124f, -0.17902774f, -0.07323859f, 0.23907202f, -0.19388582f, -0.65362734f, -0.57909381f, 
    0.01210286f, -0.31407002f, -0.08174225f, -0.37531388f, 0.10164629f, 0.05099878f, -0.21907286f, -0.06506322f, 
    -0.34191617f, 0.16603763f, -0.72983062f, 0.37376574f, -0.13263297f, 0.04666775f, -0.06473685f, -0.04556765f, 
    0.03830068f, 0.24484301f, -0.01794641f, -0.13706096f, 0.03186813f, -0.00793927f, 0.05846528f, -0.49605760f, 
    0.02176404f, -0.38758713f, -0.48548183f, 0.03687919f, 0.44471943f, -0.10571878f, -0.21982417f, 0.23626046f, 
    -0.41338784f, 0.14888528f, 0.56203854f, -0.00335138f, 0.14200585f, 0.08480448f, 0.05536597f, -0.32390308f, 
    -0.13390210f, 0.20380989f, 0.22808193f, -0.18363203f, -0.19348000f, 0.30392712f, -0.55630285f, -0.68024355f, 
    0.16998696f, -0.03012262f, -0.42597622f, -0.22045679f, -0.06272619f, -0.05696831f, 0.13690013f, 0.27458191f, 
    0.01056258f, 0.31090453f, -0.20045353f, 0.40912136f, 0.16422623f, -0.07882784f, 0.26001301f, -0.13568364f, 
    -0.01669792f, 0.57097340f, -0.08710811f, 0.11250968f, -0.37864041f, -0.01005847f, 0.18101548f, 0.01745684f, 
    0.12936947f, -0.66236717f, -0.35717967f, 0.28326324f, 0.60037977f, 0.32430455f, -0.08268947f, -0.04362959f, 
    0.21791393f, -0.02776102f, -0.00909494f, 0.06395317f, 0.03681708f, 0.52192295f, 0.11344131f, -0.81572944f, 
    -0.37707537f, -0.32949069f, -0.38325241f, -0.46160972f, 0.03323996f, -0.14873554f, 0.11607462f, 0.01263960f, 
    0.47592410f, -0.31985274f, -0.70069903f, 0.27757663f, -0.05843976f, 0.23209879f, 0.46203381f, -0.03490991f, 
    0.16513692f, -0.42097628f, 0.06467933f, 0.25210372f, -0.85845798f, -0.05520486f, 0.04617604f, -0.18323457f, 
    -0.24194573f, 0.04885533f, -0.17373410f, -0.48448154f, 0.02862787f, -0.10997710f, -0.38523957f, -0.42058587f, 
    0.19396278f, -0.27008480f, 0.38135695f, -0.26578590f, 0.07343831f, -0.03048653f, 0.06192430f, -0.00076741f, 
    0.05997058f, 0.10112038f, 0.02656428f, -0.28629047f, 0.20402776f, -0.01347245f, 0.24152133f, -0.06646872f, 
    0.25925520f, -0.02694791f, -0.29466739f, -0.43132648f, 0.02797779f, 0.01057612f, 0.23168553f, -0.22499393f, 
    -0.02149017f, 0.41882110f, -0.46315455f, 0.39607725f, 0.28965652f, 0.20867564f, 0.03234696f, -0.84505641f, 
    0.11234786f, 0.32378924f, -0.17062554f, -0.32663670f, -0.20031492f, -0.15207900f, 0.13898705f, -0.38903654f, 
    0.13367568f, -0.07037242f, 0.21519780f, 0.00338291f, -0.56802142f, -0.04215463f, 0.12922466f, 0.21114211f, 
    -0.78581774f, 0.19875927f, -0.20890751f, 0.08057106f, -0.16686900f, 0.47191170f, -0.22440597f, 0.32389617f, 
    0.11863395f, -0.06482626f, -0.04122505f, -0.03728279f, 0.53534412f, 0.02654642f, 0.06321701f, 0.41568878f, 
    -0.05997737f, -0.24760705f, -0.18304478f, -0.09824772f, -0.45104575f, -0.02367940f, -0.25953710f, 0.04338081f, 
    -0.01326936f, -1.19511890f, -0.10107436f, 0.16420880f, -0.12223198f, -0.07839162f, -0.04665417f, 0.14701363f, 
    0.06798054f, -0.51297873f, -0.67262030f, -0.17668907f, 0.04882453f, 0.23122571f, -0.03993750f, -0.01972776f, 
    0.19716449f, -0.27168611f, 0.04447767f, 0.03701082f, 0.20642851f, -0.28340614f, 0.47507229f, -0.85401285f, 
    0.13609369f, -0.20334305f, -0.22015619f, 0.04968588f, 0.63319480f, -0.29760006f, -0.28631580f, -0.05448598f, 
    -0.90038794f, -0.44632009f, -0.48539746f, 0.33230349f, -0.34962654f, -0.54626554f, 0.44614658f, -0.25929835f, 
    0.09063216f, 0.28095967f, 0.05126223f, -0.04601159f, -0.29535076f, 0.01299480f, 0.01043253f, -0.11219446f, 
    -0.11430053f, -0.03479735f, -0.39573503f, -0.00865517f, 0.05977939f, 0.21108690f, -0.50271410f, -0.75514996f, 
    0.17464963f, -0.02548922f, -0.92065769f, 0.30421191f, -0.42962438f, 0.13996075f, -0.44166881f, -0.22790918f, 
    0.00698809f, -0.57194567f, 0.04850137f, 0.21723551f, -0.20627001f, 0.01554456f, -0.88687032f, 0.11661714f, 
    -0.30497274f, 0.12731864f, 0.12342279f, 0.41714561f, 0.18357313f, -0.11212473f, 0.04245298f, 0.07774240f, 
    0.00168679f, -0.01702550f, 0.24713112f, 0.05585221f, -0.43271559f, -0.13255414f, 0.03671437f, 0.13764213f, 
    0.04796765f, -0.10671351f, -0.49939284f, -0.13693483f, 0.29411030f, -0.25851688f, 0.17834064f, -0.00527834f, 
    -0.37261519f, 0.00571060f, -0.07671669f, -0.14263996f, 0.22508438f, 0.03774299f, -0.26003352f, 0.27731648f, 
    0.00222260f, -0.01679377f, -0.18614608f, 0.24509902f, -0.35759544f, -0.32032582f, -0.04483356f, -0.63333619f, 
    -0.25092772f, 0.00732104f, 0.00347681f, -0.04295474f, 0.38885561f, 0.09041772f, 0.51656008f, -1.15228570f, 
    -0.00377480f, 0.08956250f, -0.36796421f, -0.08574603f, 0.15107664f, 0.15952024f, 0.19220081f, -0.10716578f, 
    -0.01277418f, -0.01554993f, 0.04665976f, -0.05856022f, 0.18154283f, 0.07817212f, -0.16579379f, -0.68738955f, 
    -0.01100320f, 0.02381378f, -0.18698882f, -0.20482258f, 0.37556338f, -0.41334182f, 0.03383361f, -0.00439079f, 
    -0.02061793f, -0.04919747f, 0.03723349f, 0.06351385f, -0.09901132f, -0.08931225f, -0.19217028f, 0.44395947f, 
    -0.55343413f, -0.89361048f, 0.33476105f, 0.07601868f, -0.47516355f, -0.02890675f, -0.02248121f, 0.07089467f, 
    -0.30714706f, -0.72760558f, -0.57386565f, -0.43905589f, 0.31381148f, -0.10372818f, -0.02179277f, -0.10799162f, 
    0.02105142f, -0.10121119f, 0.04737261f, 0.00750594f, -0.31994301f, 0.06814638f, 0.10469939f, -0.20014088f, 
    0.05697380f, 0.07218682f, 0.07749045f, 0.32826182f, -0.03676208f, 0.07126929f, 0.28542486f, 0.28261080f, 
    -0.03777581f, -0.51644373f, 0.18097672f, -0.39262384f, -0.36609319f, -0.13043201f, 0.17407249f, -0.48047888f, 
    0.03625350f, -0.08158403f, 0.05212083f, -0.05719565f, 0.35250661f, -0.04597822f, 0.46910280f, -0.78943902f, 
    -0.04848917f, -0.41395307f, -0.68531668f, -0.51011902f, -0.44672775f, 0.05731530f, 0.37697333f, -0.84918720f, 
    -0.11994188f, -0.57319111f, -0.52049428f, 0.21566613f, -0.41345072f, -0.02042285f, -0.05504875f, -0.05296941f, 
    0.02977072f, -0.63425332f, 0.32262480f, -0.08716246f, -0.32192719f, 0.03324727f, 0.02742626f, -0.27327070f, 
    0.44899935f, 0.21500330f, -0.30318010f, 0.17399329f, -0.55395919f, -0.02676834f, 0.23646182f, -0.25935945f, 
    -0.11194020f, -0.81780010f, -0.03040651f, -0.18243261f, 0.40445104f, -0.28388888f, 0.33422652f, 0.27089649f, 
    0.16102979f, -0.03279373f, 0.14818704f, 0.32212675f, -0.58499330f, -0.18476814f, -0.09717778f, -0.63831252f, 
    0.00729461f, 0.10761511f, -0.69627249f, -0.56884921f, 0.19488880f, -0.19885077f, -0.32544702f, -0.18866447f, 
    -0.07787821f, -0.25817648f, 0.36311820f, -0.45485017f, 0.09587730f, 0.08343006f, 0.10402307f, 0.45002219f, 
    -0.31282860f, -0.34810665f, -0.45496413f, 0.12341247f, -0.64038301f, 0.45514646f, -0.97372967f, 0.04640161f, 
    0.37748292f, -0.59900004f, -0.01618996f, -0.02680110f, -0.35381502f, -0.57432783f, -0.39909768f, -0.64785260f, 
    0.46198800f, -0.56559336f, 0.16901051f, 0.14612257f, 0.15253118f, -0.22525975f, 0.34360960f, 0.05480109f, 
    -0.53241628f, 0.17322055f, -0.37242565f, -0.09816912f, -0.13048136f, -0.16418879f, -0.68290615f, -0.42950836f, 
    0.40683344f, -0.15976454f, 0.23052020f, -0.82544231f, -0.34052932f, -0.06022848f, 0.17063449f, -0.33582568f, 
    -0.27905765f, 0.08097356f, 0.10758742f, 0.18707705f, -0.07668837f, -0.32762563f, 0.01137672f, -0.06752107f, 
    -0.09354225f, -0.16496299f, 0.22701730f, -0.07932824f, -0.70678401f, 0.36040968f, 0.01903678f, 0.43093741f, 
    0.02078973f, -0.34720984f, 0.11775035f, -0.28571489f, -0.44487938f, -0.07828563f, -0.58948994f, 0.07844706f, 
    0.34700176f, 0.16421141f, 0.13331299f, -0.13926435f, 0.12149144f, -0.03158274f, 0.08034985f, 0.00508442f, 
    -0.00576553f, -0.56377053f, -0.07008080f, 0.05343136f, 0.06459341f, -0.17597555f, -0.03907934f, -0.00948444f, 
    0.03158965f, 0.07729870f, 0.03307085f, -0.24494889f, -0.12639727f, -0.64078230f, 0.01161708f, -0.78376412f, 
    0.22727880f, 0.13911176f, -0.33188298f, 0.22204149f, -0.16178216f, -0.04418065f, -0.82742685f, -0.43011180f, 
    -0.62393534f, -0.06599052f, 0.11556821f, -0.37610081f, 0.34141546f, -0.23938850f, 0.00323263f, 0.18051173f, 
    -0.12996483f, 0.01196176f, 0.03082899f, 0.09264880f, -0.25146571f, -0.06036702f, -0.19569118f, -0.62790203f, 
    -0.03202310f, -0.69227123f, 0.14164019f, 0.24056153f, -0.05843507f, -0.17421538f, -0.05831780f, 0.07895007f, 
    -0.03582713f, -0.39373663f, -0.66599882f, -0.16568348f, 0.07391969f, 0.08490812f, -0.03987483f, 0.30181500f, 
    -0.24174184f, -0.79662812f, -0.48670959f, 0.13544124f, -0.31727275f, 0.28802446f, 0.20926051f, -0.06179820f, 
    -0.23009616f, -0.05549647f, -0.01701018f, 0.17450768f, -0.37976977f, 0.09504015f, -1.01851189f, 0.09662694f, 
    0.65242392f, -0.27759597f, -0.28967652f, 0.32774907f, 0.06166332f, 0.00278539f, -0.12621696f, -0.00484039f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.24431987f, 0.16116770f, 0.00350056f, -0.05697099f, 0.01377521f, -0.04939428f, 0.04455960f, -0.24196447f, 
    -0.18217739f, -0.02850848f, 0.28508076f, 0.00890946f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
