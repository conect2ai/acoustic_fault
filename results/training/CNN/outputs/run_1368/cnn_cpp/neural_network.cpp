#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.55087149f, -0.85064274f, -1.15732920f, 0.07866541f, 0.92521304f, 0.27389312f, 0.09360152f, -0.08210626f, 
    0.01649816f, 0.21930496f, 0.02431124f, 0.05309449f, 0.28420094f, 0.04079323f, 0.18387116f, -0.02049142f, 
    0.21274824f, -0.00594039f, -0.74667984f, -0.75383025f, 0.10555749f, -0.32812852f, -0.10970914f, -0.23809217f, 
    0.10432819f, -0.67801881f, -0.70413882f, 0.37680104f, 0.23925805f, 0.07867030f, -0.59355825f, 0.15830535f, 
    -0.30228755f, -0.03060995f, 0.34707370f, 0.22467336f, -0.53114074f, -0.54359025f, 0.54324603f, -0.20054407f, 
    -0.39761573f, -0.51513499f, 0.39720637f, -0.40134335f, -0.40004188f, -0.65202332f, -0.37890929f, -0.51039642f, 
    -0.47893551f, -0.50130588f, -0.71854651f, 0.29155248f, 0.41065162f, 0.11830471f, 0.60988277f, -0.58380318f, 
    -0.35410944f, -1.02600396f, -0.76480103f, 0.37631533f, 0.07123347f, -0.16817842f, -0.47221148f, -0.07182346f, 
    0.25183493f, -0.00773729f, 0.37973699f, 0.17746970f, 0.21228036f, 0.32117146f, 0.35679668f, -0.58604902f, 
    0.16777062f, 0.81775445f, -0.85856104f, -0.16643763f, 0.38174593f, -0.39062175f, 0.34476307f, -0.01885489f, 
    -0.03096839f, 0.13975787f, -0.10519908f, 0.34269255f, -0.43844423f, -0.12220812f, 0.51221132f, 0.10359891f, 
    0.01489385f, -0.02750547f, -0.29002893f, -0.32514548f, -0.37695467f, 0.13262334f, -0.03059404f, 0.35752469f, 
    0.29358894f, 0.17363587f, -0.06543299f, 0.44096154f, 0.72574580f, 0.11331109f, -0.62645608f, 0.15497114f, 
    -0.28531733f, -0.19859889f, 0.06094075f, 0.16469513f, -0.21146561f, -0.88756549f, 0.95639819f, -0.94429809f, 
    -0.76257479f, -0.84531301f, 0.33960599f, 0.22365083f, 0.04492418f, 0.31545728f, 0.26530230f, 0.27021110f, 
    -0.03611825f, -0.38145363f, 0.29836959f, -0.02403429f, -0.12005717f, 0.28759637f, 0.49157292f, -0.74959749f, 
    0.12679160f, -0.55763590f, 0.26018405f, 0.42686471f, -0.06644414f, -0.11930731f, 0.20033585f, -0.20351568f, 
    0.10414169f, 0.23585784f, -0.56687236f, 0.43495950f, 0.00704784f, 0.16611011f, -0.53243351f, 0.48050329f, 
    -0.95129842f, -0.54105288f, -0.26619929f, 0.46062118f, 0.32129624f, 0.52949923f, -0.09384981f, -0.53957874f, 
    -0.50970095f, -0.48886684f, -0.85123777f, -0.19423144f, -0.19535555f, -0.88390362f, -0.65121496f, -0.30727771f, 
    0.17458977f, -0.08459973f, 0.68423104f, -0.01925626f, 0.14687304f, -0.15055262f, -0.38155085f, -0.41074514f, 
    -0.14595252f, 0.32703072f, 0.44242197f, 0.25638175f, 0.38678640f, 0.01330865f, 0.27032074f, 0.13834573f, 
    -0.24066310f, 0.25442189f, 0.22344854f, -0.41214964f, 0.42985955f, -0.54453486f, 0.47597456f, -0.33298153f, 
    -0.84409076f, 0.17761764f, 0.30377179f, -0.65981746f, -0.58311635f, -0.56600475f, 0.30096450f, 0.31569138f, 
    -0.21750788f, 0.31706044f, 0.40868375f, 0.29692703f, -0.44715461f, -0.33480513f, 0.40489823f, 0.77949148f, 
    0.64375401f, -0.73971826f, -0.44799265f, -0.37290546f, 0.43003452f, 0.11495157f, -0.03422993f, 0.26394343f, 
    0.49651858f, 0.42017841f, -0.31241703f, -0.06163110f, -0.15664445f, -0.09478895f, 0.13176872f, 0.02729096f, 
    -0.71740007f, 0.11263071f, 0.41516593f, -0.40229183f, -0.07793242f, -0.66427952f, -0.57202888f, -0.16543220f, 
    -0.62077588f, 0.35584366f, -0.04332465f, -0.11305188f, 0.47757906f, -0.07047414f, -0.06913207f, 0.11094598f, 
    0.14343403f, -0.17203023f, -0.34318778f, 0.13233207f, -0.05288350f, 0.07424532f, 0.12058510f, 0.36651683f, 
    -0.27618927f, 0.20688404f, 0.13417386f, -0.38381654f, -0.21639593f, 0.46357301f, -0.03025220f, -0.54622924f, 
    0.39190584f, -0.13662542f, 0.29459137f, 0.12433887f, -0.57878047f, 0.46055096f, 0.05103744f, -0.73997295f, 
    -0.16341943f, -0.49940726f, 0.64364660f, -0.69482082f, 0.04575707f, 0.50893301f, 0.10028560f, 0.13875419f, 
    -0.24931750f, 0.17598042f, 0.20567958f, -0.31584430f, 0.01582215f, -0.32925391f, 0.38061738f, -0.21523631f, 
    -0.46427995f, 0.07170417f, 0.36086783f, 0.79208606f, -0.68754804f, -0.47483170f, 0.16478926f, 0.27540275f, 
    0.05025323f, 0.04746721f, -0.12536967f, 0.09477152f, 0.40776303f, -0.27216160f, 0.01091110f, -0.19928320f, 
    0.65367955f, -0.50168550f, 0.44710329f, 0.11855844f, -0.67694741f, -0.41593128f, 0.14417024f, -0.04434493f, 
    0.31847805f, -0.92128187f, 0.35742003f, -0.33480385f, -0.06933591f, 0.44771910f, 0.41994974f, -0.02378731f, 
    0.28220764f, -0.24746606f, 0.62242329f, -0.76403391f, 0.19981506f, 0.28297305f, -0.15508795f, -0.02532611f, 
    -0.18574692f, -0.08257648f, 0.18877929f, -0.63063681f, -0.73013961f, -0.06205197f, -0.17108017f, 0.26590854f, 
    0.54673040f, 0.01457127f, -0.29228503f, -0.63261247f, -0.72533357f, -0.01522394f, -0.30603781f, -0.54908073f, 
    -0.23788644f, 0.77510661f, -0.41742802f, 0.00486047f, 0.57402033f, -0.91697228f, -0.77237397f, 0.07731439f, 
    0.72270745f, 0.37476006f, -0.56491756f, 0.00190719f, 0.06062270f, 0.39677417f, 0.66329747f, 0.02087973f, 
    -0.24204399f, 0.21872288f, 0.69466847f, -0.09471131f, -0.23799278f, -0.05944702f, -0.17672640f, 0.47917193f, 
    0.59080148f, 0.35424310f, -0.44623569f, -0.18564266f, 0.11986807f, -0.36547807f, -0.38123617f, 0.54070693f, 
    0.58800191f, 0.51238191f, -0.84666127f, -0.35299098f, 0.11232273f, -0.07552359f, 0.13839884f, 0.28360164f, 
    -0.13762538f, -0.93070185f, -0.55862904f, -0.52966857f, 0.53124386f, 0.01653325f, -0.62149340f, 0.02793892f, 
    -0.38450313f, -0.47764063f, -0.55877304f, -0.86055440f, -0.02656080f, 0.17131636f, 0.61595559f, 0.06365419f, 
    0.04644988f, 0.23012629f, 0.13235620f, -0.80003488f, 0.92927223f, -0.15178902f, -0.57992017f, 0.70376784f, 
    -0.03191731f, -0.07178193f, -0.00977993f, -0.17462283f, 0.09206604f, 0.50599825f, -0.77528340f, 0.36695156f, 
    0.07833275f, -0.03540146f, -0.44586468f, 0.06521769f, 0.38771558f, 0.17433622f, 0.12557994f, -0.29501253f, 
    0.07037349f, -0.06949462f, -0.20275654f, -0.67562288f, 0.67633092f, 0.41360730f, 0.52621454f, 0.10958916f, 
    -0.69995826f, -0.16265652f, 0.06490293f, 0.18715936f, 0.21304201f, -0.07830717f, 0.19645797f, 0.03870542f, 
    -0.50790948f, 0.18062752f, 1.02341831f, -0.60095549f, -0.39822948f, -0.22936109f, -0.34890184f, 0.12368678f, 
    -0.83651698f, -0.04030770f, -0.58635378f, -0.04416367f, 0.58564800f, 0.29879674f, 0.28048059f, 0.16143635f, 
    -0.02190393f, -0.66444355f, -0.26061043f, -0.46508834f, -0.43797970f, -0.89057744f, -0.01586899f, 0.03004795f, 
    0.45060885f, 0.20923784f, -0.54291850f, -0.41622937f, -0.65232503f, 0.05750119f, -0.65109926f, -0.67299813f, 
    -0.17325643f, -0.48700881f, -0.17910540f, -0.07826351f, -0.15526265f, -0.67940563f, 0.16379900f, 0.49355018f, 
    0.38230011f, -0.32883608f, 0.36115989f, 0.08912180f, -0.27657321f, -0.55061799f, 0.80923986f, -0.69681859f, 
    -0.69058448f, -0.16370726f, -0.11723627f, -0.15486006f, 0.44424683f, -0.69181901f, -0.11147616f, 0.78871936f, 
    -0.26146129f, 0.53099144f, -0.03088550f, -0.46700031f, 0.23144773f, 0.23357731f, 0.20247912f, -0.34915942f, 
    0.26147702f, 0.33188671f, -0.05598672f, 0.11546339f, -0.25051230f, 0.44334483f, -0.52176327f, 0.40749151f, 
    0.31082496f, 0.25690272f, 0.23530965f, -0.08094166f, 0.37774438f, 0.05481538f, -0.07934595f, -0.40121460f, 
    0.69894284f, -0.56078589f, -0.39620230f, 0.11993633f, -0.22676131f, -0.39748451f, 0.30506548f, 0.00716857f, 
    0.61239529f, 0.06776091f, -0.34567618f, -0.98281062f, 0.19172533f, 0.01663791f, -0.07927146f, -0.64212930f, 
    -0.47346932f, -0.21161269f, -0.05825273f, -0.23810723f, -0.43809941f, 0.59204835f, 0.42365769f, -0.27412733f, 
    0.06213621f, -0.37148350f, 0.30096352f, 0.50347078f, -0.49482232f, 0.08655702f, -0.01574111f, -0.30662173f, 
    0.43411013f, 0.08232073f, -0.36420673f, 0.17316253f, 0.58982491f, 0.72363400f, 0.04094745f, -0.65329760f, 
    -0.66716743f, -0.52173805f, -0.41819689f, -0.50215548f, -0.30941778f, -0.36655790f, -0.10241740f, 0.43129775f, 
    0.06854273f, 0.49875563f, -0.36215472f, -0.10835168f, 0.44659662f, -0.34782186f, -0.72853565f, 0.50128740f, 
    0.23630869f, -0.57453221f, 0.20677580f, 0.44459125f, 0.07721387f, 0.04949408f, -0.01229661f, -0.78784376f, 
    0.46999508f, 0.19048697f, -0.32398975f, -0.42115116f, 0.22189640f, 0.29870677f, 0.25297588f, 0.11127391f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.13770886f, 0.05239643f, -0.16947484f, 0.04556810f, 0.12555334f, -0.11305542f, 0.07318524f, 0.16270564f, 
    0.03087039f, 0.33270329f, 0.07860130f, 0.05635512f, -0.01012934f, -0.14126441f, -0.01060235f, 0.06257188f, 
    -0.18843029f, -0.37568203f, -0.03554178f, -0.07472175f, -0.12643026f, 0.21994008f, 0.21215701f, 0.05867597f, 
    0.04259685f, 0.04273196f, -0.20572776f, 0.15205860f, -0.04906252f, 0.13371266f, 0.11493583f, 0.34459892f, 
    -0.09028460f, 0.10978190f, 0.19906077f, 0.00959485f, 0.23787068f, -0.01510384f, 0.05426122f, -0.23922196f, 
    0.12278200f, -0.13712168f, 0.11574027f, 0.13439864f, -0.10263997f, -0.05845787f, 0.17211841f, 0.10030121f, 
    0.10704947f, 0.03059707f, -0.31226712f, 0.09378985f, 0.35888994f, 0.15708598f, 0.10603590f, -0.23188069f, 
    0.17539175f, -0.03885365f, 0.11639822f, 0.12916504f, -0.14216852f, 0.20974542f, 0.13039522f, 0.03682440f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.36107883f, 0.20646867f, -0.46683830f, 0.08409283f, -0.01240164f, 0.23108613f, 0.05970565f, 0.03789322f, 
    -0.08224373f, 0.07982091f, -0.01580535f, 0.00849265f, -0.21895315f, -0.00070396f, -0.00020805f, 0.01713377f, 
    0.08386165f, 0.00157575f, -0.01200170f, -0.00443904f, -0.02999065f, -0.05536005f, -0.02306763f, 0.02160786f, 
    -0.00465331f, 0.00720117f, -0.02113420f, 0.00069391f, 0.01190786f, 0.05056920f, -0.09963921f, -0.11323728f, 
    -0.09325725f, -0.18387492f, -0.12314101f, -0.05678320f, -0.06142426f, -0.00374295f, 0.03127055f, -0.01280863f, 
    0.33627453f, 0.17754105f, 0.12420464f, -0.36192709f, -0.00405957f, 0.12569006f, 0.16434400f, 0.05748311f, 
    0.01331279f, 0.04598640f, 0.02229358f, -0.01567154f, -0.00843332f, -0.05278590f, -0.04698581f, 0.01776099f, 
    -0.10676035f, -0.06827156f, -0.01562824f, 0.17843796f, -0.02462312f, -0.03337111f, -0.05020584f, -0.04842902f, 
    -0.07071589f, -0.07840918f, -0.13749588f, -0.09949403f, -0.03703269f, -0.00413140f, 0.00945223f, 0.02112295f, 
    0.01192100f, -0.04438147f, -0.03378981f, -0.03463186f, -0.07006342f, -0.07584667f, -0.14244656f, -0.03943728f, 
    0.32216913f, 0.19092804f, 0.07251690f, -0.42866346f, -0.00309823f, 0.04435530f, 0.12140551f, -0.06003266f, 
    -0.00066964f, 0.01546075f, -0.00849536f, 0.01337991f, -0.03078699f, -0.00810741f, -0.01310047f, -0.00362651f, 
    -0.05357107f, -0.07932140f, 0.01263534f, 0.06343929f, 0.27799684f, 0.29042476f, -0.03798850f, -0.30926624f, 
    -0.10539083f, 0.08888898f, 0.04975786f, 0.00504268f, 0.03795264f, 0.03809499f, 0.03199053f, 0.00798185f, 
    -0.02065786f, 0.04242888f, 0.02253450f, -0.00738213f, -0.02940729f, -0.04954493f, -0.04386308f, 0.02723436f, 
    0.15296455f, 0.24209298f, 0.03571161f, -0.40199775f, -0.17802225f, 0.05502411f, -0.07173499f, -0.08742929f, 
    -0.04369252f, 0.03728571f, -0.04328090f, -0.00860217f, -0.06123213f, -0.02195691f, 0.00233000f, -0.03092653f, 
    -0.05209355f, 0.00941120f, 0.12264844f, 0.03491215f, -0.07190934f, -0.03842947f, -0.01677605f, 0.04589442f, 
    0.00220910f, -0.00316537f, 0.00511608f, -0.02397005f, 0.01751914f, 0.03777582f, -0.09751655f, -0.09249905f, 
    -0.09090654f, -0.08388963f, -0.11026412f, -0.02277462f, -0.00330148f, 0.00343501f, -0.06700893f, 0.02508902f, 
    -0.03859569f, 0.00200461f, -0.09703624f, 0.13217659f, -0.06750860f, -0.00489952f, 0.04603328f, -0.07379775f, 
    -0.01280483f, 0.09177116f, -0.17224887f, 0.08883449f, -0.18091214f, -0.07478416f, -0.07921916f, -0.08313893f, 
    0.02088637f, -0.16950251f, -0.02734001f, -0.11932368f, -0.17511711f, -0.07860701f, 0.06276552f, -0.00642368f, 
    -0.00601115f, -0.02402180f, -0.01863334f, -0.01735748f, -0.00200339f, 0.01707038f, -0.02362916f, -0.02771030f, 
    -0.05944521f, 0.04118537f, -0.01785309f, 0.05530952f, -0.09960429f, -0.03854373f, -0.07189550f, -0.07145547f, 
    0.14732131f, 0.03139115f, -0.02598308f, 0.02057410f, 0.05890636f, 0.07920583f, 0.07249807f, 0.02343741f, 
    -0.00228246f, -0.09518673f, -0.03958207f, -0.06092757f, -0.04389982f, 0.03109592f, 0.02765144f, -0.00114782f, 
    0.00112697f, -0.05181286f, -0.00331086f, -0.01609716f, -0.28932536f, -0.25676185f, -0.17662686f, 0.06610406f, 
    -0.16715975f, 0.09699444f, 0.00109197f, -0.04826915f, -0.03250149f, 0.08113012f, 0.04394329f, 0.04594849f, 
    0.00540091f, 0.04977682f, 0.05960419f, 0.04594793f, 0.09024878f, -0.09674764f, -0.04895882f, -0.03881869f, 
    0.26550409f, 0.34384573f, 0.04197206f, -0.58577460f, -0.07205876f, -0.06343415f, 0.06238173f, -0.06995293f, 
    -0.01457578f, 0.11157297f, 0.07872641f, -0.02597875f, 0.01762064f, 0.00531663f, -0.04213431f, -0.00323450f, 
    -0.03282971f, -0.04535734f, 0.15376693f, -0.10969456f, -0.02027582f, -0.03442199f, -0.00880242f, 0.02997575f, 
    0.03959602f, 0.04558404f, 0.01621347f, 0.02385428f, 0.03351642f, 0.02694635f, 0.03377569f, 0.02212264f, 
    0.03347697f, 0.06132851f, 0.01404241f, -0.14083953f, -0.05262657f, -0.07399572f, -0.02463365f, -0.04200934f, 
    -0.07556472f, 0.04836945f, 0.03966326f, 0.02677342f, 0.06439740f, -0.00962309f, -0.09812906f, 0.02130031f, 
    0.03933775f, 0.00827317f, -0.08673020f, -0.00385246f, -0.14196308f, 0.06558565f, -0.00920092f, 0.08350784f, 
    0.02392601f, 0.00550838f, -0.05831379f, -0.08647590f, -0.27491006f, -0.08976410f, 0.34884578f, -0.10215196f, 
    0.11697166f, -0.05617991f, -0.25697291f, 0.13608330f, -0.01257048f, -0.00995428f, 0.00759529f, 0.07514858f, 
    0.01537195f, -0.05962066f, -0.07625064f, -0.17588818f, -0.25761092f, -0.05984048f, -0.13131583f, -0.34147570f, 
    0.39075911f, 0.08842760f, -0.01113987f, -0.18916884f, -0.02503780f, -0.12736444f, 0.10042819f, 0.07167445f, 
    0.05619986f, -0.09721761f, -0.00024824f, -0.01165509f, 0.03510133f, -0.03193416f, 0.03660983f, 0.02661554f, 
    0.05338500f, 0.11274726f, 0.05900981f, -0.00388255f, 0.37825546f, 0.31554449f, 0.01563939f, -0.35763705f, 
    0.01676864f, 0.15165882f, 0.10365979f, 0.18172994f, -0.12404740f, 0.14207397f, 0.00923708f, -0.05030264f, 
    0.01950325f, -0.01286596f, -0.05095762f, 0.00099271f, -0.05966675f, -0.06227871f, 0.10544412f, -0.01690836f, 
    0.04120860f, -0.04092374f, -0.11720472f, 0.01314984f, -0.05905619f, -0.08170792f, -0.02896116f, -0.31321216f, 
    -0.02570434f, -0.04347837f, 0.04663621f, 0.01776942f, -0.01578351f, 0.01349110f, 0.03752250f, -0.07960448f, 
    -0.00303931f, -0.08343171f, -0.10582086f, -0.08385611f, -0.13561778f, -0.12513176f, -0.19480716f, 0.03724079f, 
    0.00372930f, 0.00560165f, 0.01952003f, 0.04305593f, 0.02770622f, 0.03992354f, -0.00052075f, 0.00435567f, 
    -0.00070339f, 0.05893550f, 0.03451465f, -0.10821097f, -0.09500733f, 0.03658287f, -0.00270845f, 0.01070233f, 
    0.05049443f, 0.31214309f, 0.37549970f, -0.52445519f, 0.15917304f, -0.17998107f, -0.09571488f, -0.17023252f, 
    -0.14490396f, -0.07766104f, 0.02890024f, 0.00195899f, -0.03426866f, -0.00484719f, 0.01389835f, 0.00661598f, 
    -0.09219478f, 0.05522421f, 0.04736018f, 0.07606789f, -0.30900574f, -0.31937718f, 0.18921532f, -0.06292834f, 
    -0.03018148f, -0.02025380f, -0.02339840f, -0.01346930f, 0.06939283f, 0.00223226f, -0.03529220f, -0.03101845f, 
    -0.05105330f, 0.01360922f, 0.03316812f, -0.04476403f, -0.05076668f, 0.03712551f, -0.04210388f, 0.06006734f, 
    -0.06869330f, 0.00527795f, -0.06411972f, -0.08999256f, -0.04894081f, -0.03667842f, 0.01825450f, -0.19013177f, 
    -0.06145301f, -0.03910688f, 0.01001740f, 0.00827224f, 0.02834106f, 0.01903930f, 0.01821183f, 0.00095770f, 
    0.03715483f, -0.01005139f, -0.14115849f, -0.05067186f, -0.21132959f, -0.11373132f, -0.20995238f, 0.01692581f, 
    0.00785706f, 0.06583661f, 0.02292619f, -0.03355974f, 0.04105246f, 0.00235597f, -0.00221825f, 0.01841377f, 
    0.03219892f, 0.05571509f, 0.05511439f, 0.08563832f, 0.03788054f, -0.03833326f, -0.03721403f, -0.00801917f, 
    0.14522283f, 0.22136877f, 0.00007298f, -0.20208932f, -0.03357660f, -0.13369370f, -0.03079701f, -0.05753047f, 
    -0.03219055f, 0.02591286f, 0.00336721f, -0.04992026f, -0.06032836f, -0.01405700f, 0.00181933f, -0.01563680f, 
    -0.13733561f, -0.03917525f, 0.10614060f, 0.06829862f, -0.03952103f, -0.03515516f, -0.07636025f, 0.05176140f, 
    0.01967002f, -0.00008383f, -0.02611832f, -0.01849973f, 0.03272239f, 0.05717468f, -0.08736818f, -0.08967189f, 
    -0.02913794f, -0.01899016f, -0.04037307f, -0.03805546f, -0.04373462f, -0.05347766f, 0.00036148f, -0.00893428f, 
    -0.01993186f, -0.04403071f, 0.05670953f, 0.03037732f, 0.08535795f, 0.01638068f, 0.04233717f, 0.00352672f, 
    0.01057896f, 0.04774794f, -0.17982784f, -0.05009307f, 0.07005854f, -0.02266814f, 0.03574516f, 0.00013306f, 
    -0.00333172f, 0.00369169f, -0.02835672f, -0.02679126f, 0.00240902f, 0.00749485f, 0.23176901f, -0.06188881f, 
    0.03191055f, -0.10150648f, 0.04068756f, 0.04628048f, 0.00702216f, -0.06279877f, 0.07479561f, -0.13750228f, 
    -0.00806445f, -0.07217598f, -0.07223402f, -0.07330050f, -0.05065801f, -0.06745987f, -0.04580284f, -0.11169256f, 
    0.07999858f, 0.17590241f, 0.19277579f, -0.23928165f, -0.05292399f, -0.03009384f, 0.13624196f, -0.12850925f, 
    0.02438616f, 0.08883867f, -0.00894971f, 0.00011002f, 0.02493368f, -0.12336734f, -0.00835160f, -0.07926640f, 
    -0.01704800f, 0.01438836f, -0.01898695f, -0.01473150f, -0.26026934f, -0.08658084f, -0.10712953f, 0.07979479f, 
    0.24023592f, 0.02700638f, 0.01621982f, 0.01520259f, 0.01563008f, 0.04524339f, 0.01923338f, 0.03713435f, 
    0.02655333f, 0.01736988f, 0.04027540f, 0.04039724f, 0.07513412f, 0.03252709f, 0.01079541f, 0.00258274f, 
    0.04511956f, -0.25391164f, 0.24928878f, 0.09358663f, -0.06099551f, 0.02926346f, 0.06510585f, 0.00349225f, 
    0.06189673f, 0.04244620f, 0.10229530f, 0.08224101f, 0.05718577f, -0.00803618f, -0.04223530f, 0.00571415f, 
    0.05369828f, 0.00449386f, 0.03405238f, -0.14033079f, -0.32838327f, -0.16442332f, -0.05071671f, -0.10129660f, 
    -0.19842653f, 0.01533078f, 0.01149178f, -0.02174187f, 0.04367866f, 0.05357742f, 0.02307769f, 0.04186106f, 
    -0.02127567f, 0.00078073f, -0.02446493f, -0.05606304f, -0.00366681f, -0.03352629f, 0.02546661f, -0.03017499f, 
    0.02107720f, 0.08845097f, -0.03313235f, -0.18291080f, 0.01123844f, -0.15599154f, 0.10009187f, -0.12923507f, 
    -0.03180512f, -0.22556749f, 0.06700010f, 0.03487943f, 0.01279849f, 0.03510781f, -0.04739819f, -0.10998571f, 
    0.07459874f, -0.08080454f, -0.06817263f, -0.08447903f, -0.17750403f, -0.18482837f, 0.01455941f, 0.02274262f, 
    0.06690828f, 0.04778946f, 0.07924527f, 0.03947202f, 0.05952684f, 0.00614469f, -0.02384320f, -0.05568314f, 
    0.00738604f, 0.05051249f, -0.03485207f, -0.00501542f, 0.00553677f, 0.01486269f, -0.04681833f, 0.01947004f, 
    -0.22645682f, -0.23931457f, -0.04357449f, -0.07006358f, 0.04767427f, -0.06022301f, -0.01670320f, 0.01594741f, 
    -0.12431926f, -0.03240769f, -0.01156286f, -0.05365477f, -0.00951681f, -0.00892850f, -0.11020671f, -0.23170872f, 
    0.16513269f, -0.09583475f, -0.08175959f, -0.12228023f, 0.27601469f, -0.03926505f, 0.00058084f, -0.14910080f, 
    -0.04690372f, 0.00821575f, 0.05878655f, 0.16874021f, 0.09398916f, -0.00640938f, -0.00636552f, 0.01017637f, 
    -0.00878961f, 0.11803619f, -0.06582410f, 0.04356141f, 0.00460052f, 0.00130257f, 0.01370075f, 0.00419822f, 
    -0.04883654f, 0.15582204f, 0.17114095f, -0.01493710f, -0.06845423f, -0.09162258f, 0.08710439f, 0.03625004f, 
    -0.12181408f, -0.08744624f, -0.15078725f, -0.06538976f, 0.00668336f, -0.00421601f, 0.03020117f, -0.01348239f, 
    -0.05155549f, 0.01584500f, -0.08288007f, -0.03104975f, 0.45420170f, 0.25235462f, -0.25338247f, -0.09443463f, 
    0.03823173f, 0.01175367f, 0.08325398f, 0.08326603f, -0.09579318f, -0.07159322f, 0.02181598f, -0.13833940f, 
    -0.00859026f, 0.04022895f, 0.01256006f, -0.01528167f, 0.05754056f, 0.03994465f, -0.01283827f, -0.01084761f, 
    -0.25744128f, -0.09595353f, -0.19754335f, 0.01596192f, -0.03080143f, 0.03293492f, 0.01134394f, 0.03114968f, 
    0.02764519f, 0.07521534f, 0.05146012f, -0.00274936f, 0.02447410f, 0.03379591f, 0.02786233f, -0.13043894f, 
    0.00686475f, 0.03795098f, -0.02159545f, 0.05920330f, -0.40018359f, -0.13029484f, 0.18468401f, -0.02336245f, 
    -0.02499174f, 0.04823377f, -0.01752908f, -0.01183172f, 0.06234885f, 0.05521314f, 0.02834003f, 0.02954567f, 
    -0.01879063f, 0.08045805f, 0.05026630f, 0.14075330f, 0.07746230f, -0.07425719f, -0.01041023f, -0.09232575f, 
    -0.02460898f, -0.01907372f, -0.27217793f, -0.01141994f, -0.12799320f, -0.13979882f, -0.14254029f, -0.13385975f, 
    0.01115496f, 0.06180895f, -0.14398375f, -0.02735776f, -0.09847098f, -0.04026964f, -0.03332351f, -0.10374418f, 
    -0.09982786f, -0.02896080f, -0.07356602f, -0.01257098f, 0.32787123f, 0.18397765f, 0.01756565f, -0.18523160f, 
    -0.07815932f, 0.06799924f, 0.15127763f, 0.10137930f, 0.01071769f, 0.11968195f, 0.05076469f, -0.01633552f, 
    -0.05166816f, -0.03103415f, 0.02108568f, -0.04879271f, -0.05181485f, -0.06630103f, -0.14022431f, 0.05504020f, 
    0.14550857f, 0.15420949f, -0.12741457f, 0.01580907f, 0.07247657f, 0.07036143f, 0.04672181f, 0.10005484f, 
    -0.00661521f, -0.03300189f, -0.03932554f, -0.01968258f, -0.02525510f, 0.03288024f, -0.04065431f, -0.01499252f, 
    0.04942872f, -0.00260638f, -0.02004666f, -0.01062337f, -0.72516954f, -0.22953810f, 0.32205209f, 0.08432611f, 
    -0.21668403f, -0.12331416f, -0.07754727f, 0.00526818f, 0.00736601f, -0.01376525f, -0.01583910f, -0.03208803f, 
    -0.01820453f, -0.11105765f, -0.07911664f, -0.25015986f, 0.02184323f, -0.00559640f, -0.21382505f, -0.16566372f, 
    -0.19503969f, -0.17769617f, -0.05137767f, 0.11004071f, 0.02911875f, 0.05945197f, 0.04508167f, -0.07473171f, 
    -0.02043885f, 0.01940688f, -0.00117465f, -0.07138935f, 0.06954561f, 0.00964047f, 0.04761763f, 0.06052603f, 
    0.06720903f, -0.18875135f, 0.01061886f, -0.05655445f, 0.05352761f, -0.03814197f, -0.02080260f, 0.07006429f, 
    -0.10112914f, 0.03689082f, 0.15509216f, -0.14138363f, -0.07081094f, 0.03782365f, 0.00540235f, 0.08505499f, 
    0.04452129f, -0.04636284f, 0.09149881f, -0.08692891f, -0.02651986f, -0.17295144f, 0.00435495f, -0.08250783f, 
    -0.05764296f, -0.00837968f, -0.14912668f, 0.06598779f, 0.00974201f, 0.03215337f, -0.05568580f, -0.01803674f, 
    0.08656646f, 0.00854499f, -0.09735952f, -0.02932856f, -0.24341099f, -0.02409304f, -0.03667263f, -0.03801505f, 
    -0.01368088f, -0.05701917f, -0.03108274f, -0.11368082f, 0.26082420f, 0.10411720f, -0.30973399f, -0.15622763f, 
    -0.08803335f, -0.24432991f, -0.11777585f, -0.09260387f, -0.04310333f, -0.01911598f, -0.04980708f, 0.04046300f, 
    0.05473622f, 0.02829674f, -0.02966608f, -0.19134419f, 0.00084472f, -0.03414605f, -0.03026227f, -0.04505068f, 
    0.18362428f, 0.08415420f, -0.02201038f, 0.00941281f, 0.05975560f, 0.08588631f, 0.07470953f, 0.05997846f, 
    0.03266990f, -0.21632175f, -0.01539903f, -0.08712547f, -0.04921421f, 0.02543518f, 0.03809477f, -0.00332001f, 
    0.00500007f, -0.01257330f, -0.03473829f, -0.01869536f, 0.23380597f, 0.20626171f, 0.03861587f, -0.25831738f, 
    -0.16991504f, 0.05405455f, 0.08959319f, -0.01909917f, -0.03948423f, -0.06236680f, -0.01388733f, -0.04138360f, 
    0.02866325f, 0.02004523f, 0.02286830f, 0.00280256f, -0.04856593f, 0.01254631f, -0.03773291f, -0.05722982f, 
    0.30315071f, 0.19507068f, 0.04911823f, -0.21847868f, -0.00865131f, 0.12757167f, 0.18172947f, 0.16359255f, 
    -0.07548817f, 0.03958973f, -0.00946623f, 0.00900616f, -0.00455509f, -0.03033400f, 0.03940750f, -0.03514533f, 
    -0.09873959f, -0.03112512f, 0.01138103f, 0.05204324f, -0.06471305f, -0.15250565f, -0.15752809f, 0.09834184f, 
    0.04577951f, 0.05572965f, 0.04096781f, 0.03774824f, -0.01946960f, 0.05098590f, 0.03267621f, 0.00942937f, 
    -0.02004481f, -0.03006050f, 0.01604672f, -0.00057081f, 0.05374142f, -0.02561491f, -0.02427568f, 0.01560767f, 
    0.06744355f, 0.21732162f, 0.09020146f, -0.36031181f, 0.00976223f, -0.09265673f, -0.00299755f, -0.10196522f, 
    -0.05968788f, -0.06476713f, 0.00431052f, -0.06964841f, 0.00593192f, -0.09297952f, -0.11229731f, -0.04084386f, 
    -0.00672786f, 0.00424000f, 0.09445507f, -0.24674919f, -0.12793776f, -0.13839565f, 0.12989113f, -0.04528438f, 
    0.09559684f, -0.09350365f, -0.05216372f, 0.07651487f, 0.05132950f, 0.00529600f, -0.10414652f, -0.13759802f, 
    -0.05404686f, -0.24417451f, -0.24122293f, -0.06808942f, 0.06071720f, -0.02934098f, 0.02396721f, -0.04809164f, 
    -0.17507653f, -0.19162688f, -0.08492094f, -0.07530175f, 0.05422825f, -0.02092862f, -0.04358880f, 0.08668993f, 
    0.02873483f, 0.07123601f, -0.08999243f, 0.08042538f, 0.00946953f, -0.13862051f, -0.00727368f, -0.02619381f, 
    -0.08525465f, 0.03092643f, -0.07271543f, 0.02831860f, -0.07345681f, -0.07894902f, -0.16082138f, -0.02952367f, 
    -0.03134340f, 0.03259481f, 0.04588073f, 0.02057106f, 0.03185705f, 0.01622790f, 0.04908590f, 0.06248286f, 
    0.02519357f, 0.04139364f, 0.07302687f, -0.04034420f, -0.13596770f, 0.06978444f, 0.03637493f, -0.01915052f, 
    0.17845677f, 0.19543000f, -0.11042935f, -0.01969939f, 0.02262155f, -0.02993352f, 0.02894761f, 0.01137026f, 
    -0.03954909f, -0.15204695f, -0.04341789f, 0.10732704f, -0.03657275f, 0.00669105f, 0.01754750f, -0.07726661f, 
    -0.01855602f, -0.04702231f, -0.05031517f, -0.00503243f, 0.16068703f, 0.01344823f, 0.03953240f, -0.02807816f, 
    -0.07343020f, 0.06162128f, 0.13183799f, 0.09710107f, -0.05149920f, 0.04228864f, -0.04283312f, 0.01443858f, 
    0.03160340f, -0.01636884f, -0.05531697f, -0.01906553f, -0.08014119f, 0.02484987f, -0.00511272f, -0.05329281f, 
    0.04675919f, -0.09720723f, -0.30720839f, 0.03528727f, 0.05551196f, 0.02845111f, 0.02324278f, -0.02218945f, 
    -0.03866342f, 0.01147289f, 0.01017726f, -0.03059545f, -0.08813716f, -0.04410962f, -0.02541007f, -0.06296986f, 
    -0.00326942f, -0.02402817f, 0.02397805f, -0.02315342f, -0.23649749f, -0.18037401f, -0.08626101f, -0.16686855f, 
    0.02389956f, -0.02234058f, -0.00748724f, -0.01976836f, 0.02892992f, -0.03324512f, 0.07938679f, -0.00052036f, 
    -0.10336781f, -0.05952946f, -0.06347694f, -0.08065460f, 0.02163871f, 0.06340092f, 0.02900019f, -0.12806074f, 
    -0.29877889f, 0.40365842f, 0.22391170f, -0.13421829f, -0.22387464f, -0.09171248f, -0.13908985f, -0.20264718f, 
    0.02026318f, 0.03814281f, 0.02500019f, -0.01834541f, 0.00379554f, 0.07547987f, 0.03550060f, 0.12273603f, 
    0.05830356f, 0.12285852f, 0.09823506f, 0.17132841f, -0.18711358f, -0.17042422f, -0.16446489f, -0.09055201f, 
    0.00028430f, -0.06885231f, -0.05527182f, 0.06261216f, 0.04342025f, 0.02341258f, -0.15424134f, -0.06772856f, 
    -0.08811035f, -0.13254645f, -0.24345827f, -0.01476255f, -0.02845487f, -0.06467643f, -0.03202046f, 0.05357525f, 
    -0.10755372f, 0.00330549f, 0.18366277f, 0.02351350f, 0.04412353f, -0.06766033f, -0.00719495f, 0.08349705f, 
    0.04380666f, -0.02306609f, -0.07580267f, -0.05314540f, -0.16245660f, -0.04810203f, 0.00306537f, -0.04160929f, 
    -0.04734271f, 0.03239610f, -0.06451212f, -0.06909637f, 0.09144432f, 0.12248743f, 0.27724168f, -0.02470420f, 
    -0.00502773f, -0.07984556f, -0.03115779f, 0.12395622f, 0.02587494f, -0.14045957f, 0.08155615f, -0.06002035f, 
    -0.05849487f, -0.03137976f, 0.00883968f, -0.01190288f, 0.00665358f, -0.00645384f, -0.08057716f, 0.01034164f, 
    0.64180470f, -0.27575636f, -0.19438845f, 0.07447376f, -0.27026761f, -0.05687106f, 0.06670380f, 0.07736149f, 
    -0.14505440f, -0.05183955f, 0.09650058f, -0.20760585f, 0.06755160f, -0.16766523f, -0.03170062f, -0.03077125f, 
    -0.00452972f, -0.07255369f, -0.00859250f, -0.00286644f, 0.12880604f, -0.00512227f, 0.05157137f, 0.06407040f, 
    0.05566241f, 0.00215600f, -0.04413640f, -0.00291924f, -0.02800373f, -0.01913731f, 0.02381465f, 0.05372191f, 
    -0.00286127f, 0.02849505f, -0.00061274f, -0.09439815f, -0.08636008f, -0.01865140f, 0.01959695f, 0.00571589f, 
    0.06413645f, 0.16520780f, 0.09690391f, -0.09238431f, 0.21065627f, 0.06405980f, -0.07404102f, -0.04870209f, 
    0.11061308f, 0.03614796f, 0.01819802f, 0.00260916f, 0.02228271f, -0.13591333f, -0.03065361f, 0.05219219f, 
    0.02892319f, 0.07650990f, -0.02662423f, -0.07547442f, 0.06497548f, 0.01752702f, -0.00627427f, -0.05189231f, 
    -0.06099458f, -0.02347834f, 0.01197731f, -0.10596465f, 0.04058459f, 0.01451451f, 0.01199517f, -0.01913425f, 
    0.07501525f, 0.02349883f, 0.00473687f, -0.03351685f, 0.03791428f, -0.18923944f, 0.05563162f, 0.01639724f, 
    -0.04147309f, 0.07366019f, -0.18241031f, -0.24306084f, 0.20650662f, 0.06674580f, -0.05777324f, -0.03595124f, 
    0.16359022f, -0.02958399f, 0.04160513f, -0.02260110f, 0.08178191f, -0.02485859f, 0.08729194f, -0.01375785f, 
    0.02807678f, 0.14688514f, -0.12310013f, -0.13063020f, -0.16639966f, 0.12439986f, 0.04237250f, 0.25455225f, 
    0.12855165f, -0.03880651f, 0.11849184f, -0.02942310f, -0.00498548f, 0.04727286f, -0.02224177f, -0.01281247f, 
    -0.02320029f, 0.01662241f, -0.00042526f, 0.01616374f, 0.03597699f, 0.02678345f, -0.02578074f, -0.00534044f, 
    -0.22071435f, 0.25910476f, -0.11119446f, 0.10770187f, 0.13989976f, 0.12961985f, -0.03241647f, 0.11430808f, 
    -0.36571342f, 0.00804529f, -0.04629249f, 0.02115082f, -0.04367086f, 0.06863039f, -0.00181386f, 0.04174320f, 
    -0.06859732f, 0.00830366f, -0.27520272f, -0.14946991f, 0.10643522f, -0.01736441f, 0.04053008f, 0.06535155f, 
    0.01757683f, -0.00012291f, -0.00192720f, 0.02820706f, 0.02696601f, -0.03617281f, 0.06140567f, 0.01300430f, 
    0.01043380f, -0.02251221f, -0.00994771f, -0.11421458f, -0.06886689f, -0.04221208f, 0.01619615f, -0.03255507f, 
    -0.16433096f, -0.16489780f, -0.02544820f, -0.09115168f, -0.25655082f, -0.01080634f, -0.01500579f, -0.09279429f, 
    0.03080379f, 0.01584016f, 0.02303740f, 0.05254200f, 0.03817702f, 0.18434113f, -0.03404835f, 0.05658605f, 
    -0.04897312f, -0.09434504f, 0.05096762f, 0.06452588f, 0.03522453f, 0.00654915f, 0.09099298f, 0.02284154f, 
    0.05734941f, -0.02509191f, 0.07445579f, 0.02478448f, -0.01390112f, 0.03148990f, 0.06582449f, -0.00710821f, 
    -0.01427818f, 0.01576108f, 0.02255530f, -0.00714523f, 0.07328287f, 0.05551319f, 0.02356013f, 0.05425341f, 
    -0.04126005f, -0.06874570f, -0.13917431f, -0.00929803f, -0.09468699f, 0.01271906f, 0.02114239f, 0.02726742f, 
    0.02915129f, -0.05796881f, 0.01291979f, 0.11828456f, -0.04373528f, 0.04565601f, -0.01999597f, -0.01539581f, 
    -0.00782135f, 0.04221535f, 0.01016666f, 0.03386780f, 0.19191854f, 0.01579011f, -0.01231477f, -0.01442135f, 
    0.00434093f, -0.04015790f, -0.05355608f, -0.07943207f, 0.00191298f, -0.00617537f, -0.03539411f, -0.00850896f, 
    0.04352324f, 0.00172820f, -0.00311567f, 0.00188038f, 0.14366561f, -0.14867958f, 0.06563918f, 0.08135739f, 
    -0.34595388f, 0.25783268f, -0.18876541f, -0.29500988f, 0.18736187f, -0.15098335f, -0.13336177f, -0.23602545f, 
    0.21153063f, -0.02785498f, 0.00501690f, 0.04034302f, 0.03951440f, 0.00468985f, 0.06577404f, -0.02319087f, 
    -0.03621426f, 0.10786319f, -0.05733726f, -0.07779954f, 0.06664261f, 0.03206329f, 0.06047114f, -0.00958536f, 
    0.12460059f, -0.06682026f, -0.01917939f, -0.06202950f, -0.03301878f, -0.02474432f, 0.02204237f, 0.01209247f, 
    0.00825227f, 0.01859945f, -0.05430623f, -0.07682132f, 0.08625761f, 0.01920574f, 0.01815936f, 0.00600591f, 
    0.06784880f, -0.05003483f, 0.04365375f, 0.05818142f, -0.05047488f, -0.11080447f, 0.13039716f, 0.02232460f, 
    -0.13174960f, 0.08174708f, -0.02078545f, -0.05012640f, 0.10283902f, -0.09936261f, -0.14791007f, -0.15402670f, 
    0.02939088f, 0.04394618f, -0.00822611f, 0.02817288f, 0.04181542f, 0.07024646f, 0.04843164f, -0.14244148f, 
    0.20972434f, -0.19654231f, 0.06611081f, 0.13915454f, 0.05684539f, -0.02080334f, -0.06481832f, 0.01244578f, 
    0.03383857f, -0.12540932f, -0.01518652f, 0.17719507f, -0.08453374f, 0.20295250f, -0.06301656f, -0.03127820f, 
    -0.02896592f, 0.10851002f, 0.15059832f, -0.01072966f, -0.22581755f, 0.00997707f, -0.10629167f, 0.07683831f, 
    -0.07951549f, -0.11873106f, 0.11098890f, -0.01160731f, -0.09539358f, -0.17760277f, 0.05204896f, 0.14485931f, 
    -0.03718511f, -0.07620437f, 0.03312918f, -0.03966309f, -0.12640417f, 0.21461457f, -0.03512350f, 0.42118493f, 
    0.00740651f, -0.12877968f, 0.07266770f, -0.09889615f, 0.04506502f, -0.10590335f, 0.00415142f, -0.02841826f, 
    -0.01771888f, 0.01803475f, 0.01529451f, 0.01622663f, 0.05607629f, 0.03824515f, -0.15012883f, 0.12061688f, 
    -0.00416308f, 0.03388207f, -0.08362835f, -0.04652332f, -0.01525202f, 0.09774455f, -0.03166004f, -0.20633510f, 
    -0.09354267f, -0.00570061f, -0.06500917f, -0.02150155f, 0.01227645f, 0.08122817f, -0.03918468f, -0.02395668f, 
    0.06719673f, -0.07860360f, 0.10564259f, -0.02559124f, 0.16518176f, 0.04555738f, -0.00305702f, 0.14793128f, 
    0.05204665f, -0.02596143f, -0.00425784f, -0.01600648f, -0.03162869f, -0.05817630f, 0.00620522f, -0.03408321f, 
    -0.03414817f, -0.02957862f, 0.07036377f, -0.06247870f, 0.05704765f, -0.13738842f, 0.05154645f, -0.08293755f, 
    -0.45497948f, 0.19120775f, -0.39220700f, -0.32775268f, 0.06046474f, 0.12674977f, -0.04410518f, -0.18151985f, 
    0.01902943f, -0.09477983f, 0.01606479f, -0.03778887f, -0.04851665f, 0.00630740f, 0.00625374f, -0.05766189f, 
    -0.16239527f, -0.17806962f, -0.21164195f, -0.30921233f, -0.10911085f, -0.16772695f, 0.03074873f, -0.02881302f, 
    0.18221679f, 0.00113196f, 0.00343339f, 0.08248986f, -0.05471958f, 0.00708676f, 0.04368443f, 0.08964934f, 
    0.00263663f, 0.02196868f, 0.11785714f, 0.14403452f, -0.03729892f, 0.03913991f, 0.14442797f, -0.06185331f, 
    0.12383326f, -0.04542789f, 0.13108389f, -0.05585954f, 0.03792363f, -0.04298024f, -0.05234210f, -0.28606242f, 
    0.08662507f, -0.03108577f, -0.01284247f, -0.05821791f, -0.02512271f, 0.07064141f, -0.01499668f, 0.03096535f, 
    -0.05338376f, -0.10404716f, 0.08836559f, -0.01334702f, 0.16907246f, 0.04690462f, 0.01583744f, 0.02234146f, 
    0.09414680f, -0.02875431f, -0.04619243f, -0.06898902f, -0.01307404f, -0.03149504f, -0.02093469f, 0.01116392f, 
    0.01424758f, -0.00472030f, -0.01621974f, -0.00165272f, 0.16013776f, -0.07365031f, 0.07876032f, 0.03201928f, 
    -0.14682554f, -0.10429761f, -0.07131311f, -0.16197470f, 0.02824367f, 0.20696764f, -0.12653919f, -0.02671982f, 
    0.04435023f, 0.01746555f, 0.06775752f, 0.06004825f, 0.00756519f, -0.03641064f, 0.06064690f, -0.31194830f, 
    -0.26588073f, -0.28262687f, -0.20498195f, -0.40432855f, 0.19597171f, 0.01785273f, -0.03006322f, 0.07825162f, 
    0.00358083f, 0.00215950f, -0.00886084f, 0.00946468f, -0.00071976f, -0.06512812f, -0.00729432f, 0.11161111f, 
    -0.03575410f, -0.04460925f, -0.00571621f, -0.05532498f, -0.08586225f, -0.06527355f, 0.01225040f, 0.00148555f, 
    -0.05087410f, -0.05478796f, 0.01351577f, 0.04381191f, -0.00923818f, -0.04329742f, -0.04769815f, 0.00283093f, 
    -0.01949644f, -0.03194460f, 0.00652988f, 0.08141920f, -0.17176740f, -0.08538994f, 0.01402834f, -0.00677912f, 
    0.00019390f, -0.02612513f, -0.00522326f, -0.04159166f, -0.24309348f, 0.02354635f, -0.01885555f, -0.10376886f, 
    0.01627714f, 0.04438350f, -0.02724306f, 0.09179447f, 0.04716107f, 0.03141793f, -0.05354222f, 0.05346132f, 
    -0.00036276f, 0.03952864f, 0.01472173f, -0.12933308f, 0.13538429f, 0.04101717f, -0.00404277f, 0.08121549f, 
    -0.19778532f, 0.07509794f, -0.18225482f, -0.29757637f, 0.02323226f, -0.07157588f, -0.02668149f, -0.05938454f, 
    -0.10844482f, 0.04573189f, -0.03002780f, 0.05514158f, 0.00071303f, -0.01255328f, 0.03746698f, 0.03819100f, 
    -0.00548036f, 0.13836235f, -0.24652438f, -0.12135352f, 0.45478845f, 0.09378020f, 0.11861334f, 0.11703395f, 
    0.19075176f, -0.01682613f, 0.00022715f, 0.01890418f, -0.02855489f, 0.00353490f, -0.04460031f, 0.02409065f, 
    -0.01660412f, 0.02426059f, -0.00099469f, 0.02059148f, 0.02713710f, -0.05689370f, 0.10892199f, 0.01817269f, 
    0.64377302f, 0.08399652f, 0.41727662f, 0.24901485f, -0.04016584f, -0.02396606f, -0.00826035f, 0.03627563f, 
    -0.00167763f, -0.04589159f, -0.00090447f, -0.12950031f, -0.02700767f, -0.09191381f, -0.10880152f, 0.20342179f, 
    0.00439158f, -0.07717106f, -0.03425488f, -0.02774620f, 0.32339290f, 0.12322478f, 0.13915446f, 0.13334438f, 
    0.09312369f, -0.02638507f, 0.01248876f, -0.00321783f, -0.01340749f, 0.02917809f, 0.00517832f, 0.04823694f, 
    0.02516577f, 0.02962482f, 0.03110221f, 0.04999978f, 0.04497121f, 0.06809898f, 0.11227491f, 0.03534041f, 
    -0.30826500f, 0.15718544f, -0.13791044f, -0.21993423f, -0.08694341f, -0.02714059f, -0.04553342f, -0.09789303f, 
    -0.03174608f, 0.09333082f, -0.05974935f, -0.05207020f, 0.01236839f, 0.06021591f, 0.00311416f, 0.00281843f, 
    0.00505533f, 0.01246587f, 0.14528246f, 0.03022783f, -0.24376777f, -0.34971136f, 0.01525918f, -0.01008873f, 
    -0.06028757f, 0.01869638f, 0.01609090f, 0.00155626f, 0.00917119f, -0.11477558f, -0.01934906f, 0.03639296f, 
    -0.09154774f, 0.03544299f, -0.05115429f, -0.01974937f, 0.01564309f, -0.03258301f, 0.04242947f, 0.03216184f, 
    0.39973870f, 0.08166382f, -0.07564147f, -0.00752949f, -0.07105609f, -0.00854987f, 0.06208219f, -0.00179585f, 
    -0.01805036f, -0.03626076f, -0.16163956f, 0.07105731f, 0.12402658f, 0.13591975f, -0.09029680f, 0.17534687f, 
    0.18320894f, 0.08173782f, -0.03511460f, 0.05997623f, -0.22159706f, 0.13696639f, 0.01479090f, 0.00526912f, 
    -0.11558472f, 0.03037140f, -0.03589582f, 0.05930691f, 0.01527562f, 0.00935540f, 0.00652249f, -0.01580409f, 
    -0.01216794f, -0.09315243f, -0.03054575f, 0.10062139f, -0.00664714f, -0.06107864f, 0.03022440f, 0.00520233f, 
    -0.76613146f, -0.17825878f, -0.01221485f, 0.09711972f, -0.12314668f, -0.05625209f, -0.02321603f, 0.09549997f, 
    -0.18440263f, -0.10694693f, 0.04937971f, 0.05579796f, 0.00728665f, 0.05801585f, -0.00582239f, -0.00129585f, 
    0.08941790f, -0.00390400f, -0.04449716f, 0.01027884f, 0.09572883f, -0.02803203f, 0.12994447f, -0.03909950f, 
    0.10225629f, 0.07471844f, 0.04127455f, 0.16352358f, 0.10456662f, -0.23902233f, -0.03382931f, -0.10967643f, 
    0.08805563f, 0.02087112f, -0.05378672f, 0.02818679f, -0.00670779f, 0.00498290f, 0.00163093f, -0.06884310f, 
    0.50353217f, 0.00162831f, 0.04372514f, 0.11089619f, 0.04739246f, -0.05689238f, -0.03071283f, -0.03089513f, 
    -0.02542194f, -0.00377071f, -0.07843459f, 0.06166872f, 0.06977815f, -0.04405833f, 0.06340962f, 0.04518760f, 
    -0.06811952f, -0.11633895f, 0.09203179f, 0.02136589f, 0.24855632f, 0.12391181f, -0.04553660f, -0.00766780f, 
    0.09409073f, -0.03179440f, -0.07796040f, -0.01759911f, -0.09545888f, -0.07787568f, -0.00733409f, 0.01221426f, 
    -0.00390422f, 0.00650229f, -0.02910127f, 0.06470896f, 0.06932128f, -0.07362623f, 0.06302568f, 0.05561294f, 
    -0.03398814f, -0.16778710f, 0.05403448f, -0.00770103f, -0.29468355f, 0.01509529f, 0.05400030f, -0.09592616f, 
    0.02588465f, -0.02692907f, 0.06111502f, 0.02597536f, -0.06654346f, 0.18737370f, 0.03344070f, -0.01498598f, 
    -0.06333351f, 0.04057405f, 0.13025442f, -0.02223940f, 0.26821539f, 0.23069371f, 0.19933847f, -0.00586683f, 
    -0.05787349f, 0.10282677f, -0.10602771f, 0.01480884f, 0.22956993f, -0.11881751f, 0.07814574f, 0.00426036f, 
    0.01159278f, -0.10469780f, 0.02010482f, -0.00945878f, 0.03875865f, 0.01301201f, -0.06576307f, -0.01485916f, 
    0.05095086f, -0.15960482f, -0.10863446f, -0.04401112f, -0.06596754f, -0.02419825f, 0.01989655f, 0.11101354f, 
    0.01396092f, -0.00843268f, -0.01291921f, -0.03564909f, 0.05940071f, -0.01865443f, 0.00304654f, -0.00144000f, 
    -0.02037214f, -0.01250566f, 0.01318933f, -0.00979192f, -0.66510814f, -1.08447468f, 0.11734904f, -0.22728688f, 
    0.02193507f, -0.05112468f, -0.04215020f, -0.18105868f, -0.13151430f, 0.09889811f, 0.10898653f, 0.02576338f, 
    -0.01523256f, 0.09904438f, 0.01876996f, 0.15957186f, 0.06107044f, -0.16797256f, 0.13571545f, 0.17111319f, 
    0.05963092f, -0.05084177f, -0.03687328f, 0.00887368f, 0.02246314f, -0.00826659f, -0.03316928f, -0.00216003f, 
    0.03459090f, -0.07646269f, -0.06280096f, 0.11818007f, -0.02369214f, -0.04710830f, -0.04816519f, 0.01286900f, 
    0.05698544f, -0.08052008f, 0.07645780f, 0.03917290f, 0.00786187f, -0.08174520f, -0.16071495f, 0.01107799f, 
    -0.11413257f, 0.07766576f, -0.11780724f, 0.06440883f, -0.01215678f, 0.07265913f, -0.00967665f, 0.16500479f, 
    -0.02106747f, 0.06130268f, -0.00847013f, -0.12364332f, 0.13756754f, -0.12770469f, 0.14542386f, 0.11396960f, 
    0.06287248f, -0.06407003f, 0.07250636f, -0.02193758f, -0.09726473f, -0.00046322f, 0.02956543f, 0.03148413f, 
    0.01633914f, 0.01092756f, 0.16413106f, 0.08052838f, 0.05399176f, 0.05533164f, 0.00921301f, -0.10966034f, 
    0.00989170f, 0.04378412f, 0.00969150f, 0.00203018f, -0.05330038f, 0.05580995f, -0.16682123f, 0.01461716f, 
    -0.00837319f, 0.12319210f, 0.03532206f, 0.05506483f, 0.16371243f, -0.05746449f, 0.03884658f, 0.04213276f, 
    0.06407328f, -0.08943044f, 0.03816001f, 0.03441652f, 0.00636508f, -0.00875575f, -0.06226898f, 0.08328034f, 
    -0.20634879f, -0.39130113f, -0.11717957f, -0.02042518f, -0.04062141f, 0.01834930f, 0.05352786f, 0.01717418f, 
    -0.01342559f, -0.12768991f, -0.06065735f, 0.01656692f, 0.01875540f, 0.02455469f, -0.03909610f, 0.01922347f, 
    0.01027300f, -0.04095913f, -0.00113398f, 0.00108365f, -0.32703596f, 0.07896727f, -0.06027212f, 0.16064236f, 
    0.10240031f, -0.02371955f, 0.16560179f, -0.09249260f, 0.04607813f, 0.08005846f, -0.02375803f, -0.03091084f, 
    0.00774027f, -0.01233925f, 0.01760188f, -0.01935170f, -0.02169267f, -0.01246547f, -0.07963177f, 0.05251380f, 
    0.17817903f, 0.26108730f, 0.10049555f, 0.28808990f, -0.12301941f, 0.07467040f, -0.17036873f, 0.08122813f, 
    -0.18331471f, -0.07864669f, -0.03245577f, -0.00229973f, 0.03821423f, -0.04956702f, 0.03345353f, 0.00746002f, 
    0.02504955f, 0.05577080f, -0.06662314f, 0.12250665f, 0.20861845f, -0.24808556f, -0.05362588f, 0.03111698f, 
    -0.11538374f, -0.01303514f, 0.01344313f, 0.02214517f, -0.00026156f, -0.03724116f, -0.00970798f, 0.03932794f, 
    -0.06721834f, -0.09271114f, -0.04561424f, -0.03887079f, 0.01868455f, -0.09340017f, 0.02825657f, 0.02948057f, 
    -0.32095435f, 0.15021743f, -0.27538094f, -0.04715305f, 0.05469130f, -0.09873635f, -0.07451311f, 0.07963091f, 
    0.03176894f, 0.10055376f, -0.02722253f, 0.04883752f, 0.02933509f, 0.00801098f, 0.07241223f, 0.00331961f, 
    0.00260145f, 0.06646382f, -0.19683777f, 0.02771871f, -0.06373805f, -0.04160615f, 0.09664981f, 0.05760253f, 
    0.10745928f, -0.02804492f, -0.00199298f, 0.06304301f, -0.01078570f, 0.03959331f, 0.15492252f, 0.05828600f, 
    0.11260346f, 0.10754096f, -0.00911379f, -0.00590815f, 0.00760251f, 0.00735489f, -0.01609725f, -0.06621569f, 
    0.30352119f, -0.06942034f, -0.01203143f, 0.03135745f, 0.05053430f, -0.07630542f, 0.01314349f, -0.01355823f, 
    0.06472796f, -0.01649475f, 0.06705344f, 0.02639695f, 0.01356094f, 0.08136640f, 0.00537105f, -0.03942489f, 
    0.06037308f, -0.08353947f, -0.00237365f, -0.07122366f, 0.20983556f, 0.11542031f, 0.07733992f, 0.11269920f, 
    0.14967573f, -0.02109402f, -0.05534852f, -0.01382373f, -0.01802365f, -0.01462428f, -0.00685063f, -0.02098811f, 
    -0.00250509f, 0.03304228f, 0.04304131f, -0.04527122f, -0.03401480f, -0.00775192f, 0.02120908f, -0.09636100f, 
    0.03545296f, -0.05872823f, -0.17217465f, -0.09332915f, -0.11569780f, 0.08007757f, 0.10746516f, 0.11027266f, 
    -0.08540048f, -0.00587658f, 0.13723128f, 0.03004341f, 0.12001311f, 0.01208461f, 0.03058312f, -0.04931614f, 
    0.00218588f, 0.05822143f, 0.05054746f, -0.00864896f, 0.16227148f, 0.15861438f, 0.23865570f, 0.03473281f, 
    -0.27549979f, 0.07882667f, -0.03879315f, 0.07487807f, 0.01186341f, 0.02618835f, 0.03329229f, -0.01668181f, 
    0.00008016f, -0.06791422f, -0.00193929f, -0.05547866f, -0.03647523f, -0.15844357f, 0.00529350f, 0.02427271f, 
    0.16227338f, -0.18671663f, 0.06745510f, 0.02615264f, -0.02396946f, 0.00078830f, -0.01035499f, 0.04931141f, 
    0.06948256f, -0.15923721f, 0.03991764f, -0.01581446f, 0.09592353f, -0.15725230f, -0.06113273f, 0.04093406f, 
    -0.02729972f, -0.00626390f, 0.00159060f, -0.02237215f, 0.24634260f, 0.21988262f, 0.00000830f, 0.07040196f, 
    0.07384247f, -0.08964202f, 0.01920811f, 0.00160152f, -0.09947418f, 0.05079506f, 0.00721105f, -0.03246375f, 
    -0.02052365f, 0.06068766f, -0.06880788f, -0.06585398f, 0.03648551f, 0.01798687f, -0.10507476f, 0.06637622f, 
    -0.01202996f, -0.17143002f, -0.40181240f, -0.23116864f, -0.52614123f, -0.03086257f, -0.14452973f, -0.14708994f, 
    -0.11050224f, 0.01428455f, -0.03149869f, -0.03084686f, -0.01484783f, 0.00721822f, 0.01656603f, -0.01378758f, 
    -0.03907264f, -0.29482740f, -0.06285392f, -0.13157943f, 0.11402611f, -0.01450044f, 0.02707957f, 0.03235432f, 
    0.17182539f, -0.13080207f, 0.06843319f, 0.00090041f, 0.07704750f, -0.03267822f, 0.07970249f, 0.02276739f, 
    0.05447262f, 0.02155569f, 0.05631035f, -0.11801950f, -0.02941919f, 0.02580140f, -0.00120376f, -0.08997763f, 
    -0.08642241f, -0.21879929f, 0.05276097f, -0.04331213f, 0.02546141f, 0.02621735f, -0.03867155f, -0.04285616f, 
    0.00218394f, 0.02469153f, 0.06593453f, 0.04074924f, 0.00398028f, 0.09674533f, -0.07745194f, -0.06549478f, 
    0.05657891f, 0.01619942f, 0.08473133f, 0.04549077f, -0.33114707f, -0.18104726f, 0.01731094f, -0.08900464f, 
    -0.00707909f, 0.02499748f, 0.12194568f, 0.05725816f, 0.11782891f, 0.04400950f, -0.18143339f, 0.02484173f, 
    0.00252487f, 0.06842583f, 0.00175525f, -0.05045226f, -0.01390616f, -0.00228210f, 0.06068391f, 0.06915003f, 
    -0.15195580f, 0.38690013f, 0.74072802f, -0.09022568f, 0.20803288f, -0.07664003f, -0.06962751f, 0.08562038f, 
    -0.02452977f, -0.10604610f, 0.02678728f, -0.01078331f, 0.08080819f, -0.09465188f, 0.14234237f, 0.01852833f, 
    -0.00926153f, -0.06604818f, 0.03765607f, -0.06832941f, -0.03316715f, -0.00972294f, -0.05396321f, -0.05555467f, 
    0.05054416f, 0.02081392f, -0.02821386f, 0.03644643f, 0.04555824f, 0.04320912f, -0.05024675f, -0.07408676f, 
    -0.05951610f, 0.09894034f, 0.00112612f, 0.07450332f, -0.00859211f, 0.04574383f, 0.03293876f, -0.01706465f, 
    -0.13653122f, -0.20770444f, 0.07153007f, 0.16968346f, 0.15796065f, -0.00506663f, 0.05701951f, -0.04988375f, 
    0.09181901f, 0.00298556f, -0.00910974f, 0.01484478f, -0.01702224f, 0.02066646f, -0.02967826f, -0.07103390f, 
    0.02560161f, -0.02176971f, -0.18160991f, 0.09593530f, -0.15398495f, -0.06564975f, 0.12505558f, -0.03607977f, 
    0.03973648f, -0.06002163f, -0.00211237f, -0.25230208f, -0.06742533f, 0.02164859f, 0.02367132f, -0.01110972f, 
    -0.02269023f, 0.03054709f, -0.02247315f, 0.04909915f, -0.03002594f, -0.06146255f, -0.00848653f, 0.03013897f, 
    0.09358367f, -0.02038900f, -0.03857699f, 0.09415270f, 0.05950397f, 0.04359658f, 0.01493130f, -0.01940580f, 
    0.15712219f, 0.00764104f, 0.01420827f, -0.01048577f, -0.01131061f, 0.01062669f, -0.06707725f, -0.01045086f, 
    0.04440720f, 0.04947538f, -0.11668896f, -0.00979781f, -0.11561841f, -0.36206040f, -0.23126671f, 0.02065291f, 
    -0.32128966f, 0.01901046f, -0.03524426f, -0.06522515f, 0.02684934f, -0.19030394f, 0.03610649f, 0.02498667f, 
    -0.01130392f, 0.01137333f, -0.05391977f, -0.00357487f, 0.01575862f, -0.00334459f, 0.02666027f, 0.03649242f, 
    -0.52127081f, 0.35456559f, -0.32595295f, 0.22815986f, -0.25862274f, 0.05459778f, 0.19208741f, -0.05939119f, 
    -0.13126458f, 0.07684264f, 0.01647272f, 0.04592336f, -0.00878424f, 0.04985765f, -0.08259518f, -0.00635039f, 
    0.01422008f, -0.11006509f, -0.11312906f, 0.12980835f, 0.09179261f, -0.08082074f, 0.05391980f, -0.07327703f, 
    0.10138728f, -0.01038696f, -0.01608243f, 0.00403803f, 0.02896654f, 0.02379799f, 0.02879300f, -0.04946598f, 
    -0.08433692f, 0.09074122f, 0.01943080f, 0.10257491f, 0.03168175f, 0.01403962f, 0.02589431f, -0.04590850f, 
    0.18560560f, -0.15644862f, 0.08338358f, -0.10733323f, 0.04944506f, 0.01992848f, -0.12217423f, -0.29376411f, 
    -0.01607982f, -0.05633925f, 0.03958588f, -0.08926051f, -0.04147452f, 0.00888252f, 0.00175968f, 0.10970058f, 
    -0.05876242f, -0.16883753f, 0.11225376f, 0.03037724f, 0.01738512f, 0.05477237f, -0.06535404f, 0.06216430f, 
    0.05249122f, 0.00060204f, -0.04920903f, -0.01927784f, 0.01786844f, 0.04693003f, 0.05084153f, 0.01449518f, 
    0.01107681f, 0.03586419f, -0.05599285f, 0.00114006f, -0.03027759f, 0.08464903f, -0.03600329f, -0.04314147f, 
    0.01218366f, 0.12735271f, 0.13539553f, 0.05878293f, 0.13454233f, -0.05041866f, -0.03336564f, 0.05091947f, 
    0.04054278f, -0.15139450f, 0.00651951f, -0.01173533f, -0.13701154f, 0.05641862f, 0.05695793f, -0.00021194f, 
    -0.05444772f, 0.01131679f, -0.03936344f, -0.01335121f, -0.26486158f, -0.25995690f, 0.30983052f, -0.33899394f, 
    0.11528945f, -0.00189536f, -0.00813457f, -0.11418051f, 0.01005576f, 0.01960652f, -0.00002100f, 0.00352158f, 
    0.01712435f, 0.02562090f, 0.00311532f, 0.03738852f, -0.16814427f, -0.14848092f, 0.06736362f, 0.00554356f, 
    -0.29713544f, -0.81284511f, -0.57604337f, -0.07150953f, -0.45518875f, 0.08909759f, 0.02538865f, -0.14109550f, 
    0.07513135f, 0.01669551f, -0.04430846f, -0.02082273f, -0.05293293f, 0.02569613f, -0.13483545f, -0.00476714f, 
    0.01675544f, 0.02933883f, -0.10403064f, -0.07178959f, -0.14598890f, -0.02310922f, 0.02621794f, -0.03991041f, 
    0.01966349f, -0.02501005f, -0.01397914f, 0.03595642f, -0.02168599f, -0.00182942f, 0.00825192f, -0.04539867f, 
    0.01191094f, 0.01703520f, -0.01798625f, -0.21058521f, -0.12636006f, -0.05293303f, -0.00879011f, -0.02290373f, 
    -0.00771513f, 0.14468209f, 0.00868003f, 0.06539339f, 0.07907798f, -0.07225984f, 0.05799681f, 0.00369670f, 
    -0.07971669f, -0.05483337f, 0.05342575f, -0.00439881f, 0.04131991f, 0.01334824f, 0.01452321f, -0.00978002f, 
    -0.04407802f, -0.02471753f, 0.03793795f, -0.01632672f, 0.00244125f, -0.04833239f, -0.29497427f, -0.15833759f, 
    0.02897556f, 0.06137767f, -0.09149548f, 0.01753333f, -0.18705313f, 0.17911507f, -0.21420830f, 0.07687113f, 
    0.07526454f, -0.01164027f, 0.03023818f, 0.09403265f, 0.07325622f, -0.11953564f, 0.14756672f, 0.09522260f, 
    -0.22618510f, -0.08384299f, 0.41337073f, 0.25070888f, 0.32004106f, -0.11717887f, -0.05605410f, -0.10865860f, 
    0.02934065f, -0.07074821f, -0.00690277f, 0.02146758f, 0.03913882f, -0.05359969f, 0.07163793f, 0.02736907f, 
    0.07410812f, 0.06604040f, -0.06056349f, 0.03229831f, -0.26101878f, -0.70936823f, -0.49517894f, -0.10362918f, 
    -0.73988348f, -0.14047168f, -0.05704559f, -0.07192995f, -0.06606715f, -0.08045453f, -0.03232539f, -0.02036273f, 
    -0.03866470f, -0.02133674f, -0.02706233f, -0.06520341f, -0.00310766f, 0.01153434f, -0.07931787f, -0.02390040f, 
    -0.35211566f, 0.06158591f, 0.12412419f, -0.08635911f, 0.01024293f, -0.07204156f, 0.03237994f, -0.36916822f, 
    -0.15946090f, 0.02780988f, 0.00633654f, -0.02693769f, 0.00502906f, -0.00087884f, -0.02866912f, 0.03169644f, 
    -0.02646893f, 0.01826247f, -0.05628717f, -0.03412007f, 0.02822279f, -0.14544553f, 0.10530319f, -0.28792620f, 
    0.03968340f, 0.04589031f, -0.02500465f, -0.00240893f, 0.04906109f, 0.07957333f, 0.02939555f, -0.03005546f, 
    0.03105423f, 0.03155280f, -0.04993581f, 0.09295490f, -0.07437658f, -0.05215104f, 0.04354312f, -0.00508416f, 
    -0.38839164f, 0.08800646f, -0.13678604f, -0.01267441f, -0.36132240f, -0.04017488f, 0.02589371f, 0.00564355f, 
    -0.09025859f, 0.01418528f, 0.02161674f, 0.02735234f, -0.02336756f, 0.03882337f, -0.07174903f, -0.03013598f, 
    0.07493198f, 0.19532694f, -0.04430229f, 0.05096199f, 0.09840114f, -0.05773034f, -0.21264073f, -0.08642816f, 
    0.22723110f, 0.05487972f, -0.00993208f, 0.01047629f, 0.00836690f, -0.01436200f, 0.02391208f, 0.05950597f, 
    0.02231584f, 0.05614505f, -0.06316060f, 0.16463915f, 0.09405278f, 0.01690180f, 0.03590349f, -0.04914553f, 
    -0.29129142f, -0.11163363f, 0.26949406f, -0.21231107f, -0.00829758f, 0.02535003f, 0.07940627f, -0.08007974f, 
    -0.05332301f, 0.08238531f, 0.05200925f, -0.00729279f, 0.03328178f, 0.05407505f, -0.06570528f, 0.05162295f, 
    -0.07293848f, -0.09870581f, -0.08122110f, -0.03128728f, -0.25030372f, -0.06725547f, 0.27083698f, -0.30661190f, 
    0.10752110f, 0.02248626f, -0.01888951f, -0.05590288f, 0.00176679f, 0.08376464f, -0.00249805f, -0.02973383f, 
    0.00874022f, 0.03073819f, 0.01980747f, -0.06083617f, -0.08044795f, -0.09030718f, 0.00627241f, -0.05612115f, 
    0.17954163f, 0.10350641f, 0.02994832f, 0.05014414f, 0.06173881f, 0.05577619f, 0.00424201f, -0.03031645f, 
    0.06299604f, -0.01018319f, -0.00459483f, -0.01753805f, 0.00755333f, -0.02398861f, -0.00454081f, 0.02597274f, 
    0.10158060f, 0.10237369f, 0.06647540f, 0.12842643f, -0.09359689f, 0.00849258f, -0.03272385f, -0.07559311f, 
    0.03053560f, -0.01366578f, -0.04185434f, 0.00963165f, 0.05551232f, 0.03620908f, 0.00808479f, -0.04620621f, 
    -0.07056054f, 0.04856237f, -0.02590342f, 0.07446759f, -0.01437841f, 0.02282892f, 0.01908341f, -0.02441146f, 
    -0.08824538f, -0.06492333f, -0.02620981f, 0.05332615f, 0.07178254f, -0.00607051f, 0.00595283f, 0.07864217f, 
    0.03434198f, -0.03572806f, -0.13137501f, -0.02126629f, -0.02433299f, 0.03298892f, 0.03943651f, 0.01291793f, 
    0.00169014f, 0.01436327f, 0.00141511f, -0.05392361f, 0.21319602f, 0.09621168f, -0.13478777f, 0.03475535f, 
    0.09448782f, 0.01916496f, 0.00339773f, -0.00787782f, -0.03405241f, -0.00030504f, -0.08791368f, 0.03177181f, 
    -0.01080095f, 0.00813791f, -0.00145364f, -0.01897318f, -0.02900296f, 0.04150891f, -0.05076657f, 0.01206484f, 
    -0.15830591f, -0.34839860f, -0.20824531f, -0.23065567f, -0.18014233f, 0.15113612f, 0.06649598f, -0.04337426f, 
    -0.00755711f, 0.04168714f, -0.04975400f, -0.01576255f, -0.01467683f, 0.02369821f, -0.06243546f, 0.01885986f, 
    0.01214481f, -0.07817551f, 0.03588634f, 0.14743567f, -0.07568046f, -0.12086742f, -0.11209629f, -0.17666806f, 
    -0.24687247f, -0.04522159f, 0.00940161f, 0.00663272f, 0.01203043f, 0.07898746f, -0.01221288f, 0.00400649f, 
    -0.00177539f, 0.04824319f, 0.00021940f, 0.08599623f, 0.00441882f, 0.10894845f, 0.02195826f, -0.03933875f, 
    -0.25075990f, -0.06327106f, -0.00542937f, 0.14415950f, -0.01736331f, -0.02328123f, -0.02907432f, 0.03444958f, 
    -0.03114958f, 0.04568163f, 0.12763266f, -0.10214137f, -0.04038658f, -0.06206053f, -0.05533660f, -0.07596187f, 
    0.16605347f, 0.14219095f, 0.07873734f, -0.11557332f, 0.01692241f, -0.04434179f, -0.02494525f, -0.00480059f, 
    0.03859197f, 0.01038205f, 0.04101097f, -0.02133617f, -0.02111745f, 0.05308883f, 0.00756075f, 0.00170787f, 
    -0.00075670f, 0.08922143f, 0.02262547f, 0.01619959f, -0.04443522f, 0.08941538f, 0.03302602f, -0.04094543f, 
    -0.47407070f, 0.24945711f, -0.02286571f, -0.07519727f, -0.08453762f, 0.07153068f, -0.06487949f, -0.23917742f, 
    -0.30978569f, 0.04406465f, 0.01885112f, -0.00650967f, 0.08229782f, -0.01749254f, -0.09115440f, -0.08992264f, 
    -0.02856403f, 0.04507554f, -0.03401734f, -0.11193889f, 0.13001591f, 0.03593463f, 0.20902894f, 0.02751333f, 
    0.16315582f, -0.03880318f, -0.00897025f, 0.04697577f, 0.06136851f, -0.03213510f, 0.02578560f, -0.04494331f, 
    -0.15095532f, 0.02809646f, 0.03369398f, 0.06109532f, -0.01878032f, -0.03421224f, 0.03641028f, 0.00890244f, 
    -0.06161684f, 0.38927901f, -0.14213137f, 0.02357375f, -0.03306851f, 0.02963238f, -0.02196927f, -0.03989177f, 
    -0.06158314f, -0.00011753f, 0.03820172f, 0.01703755f, 0.06223769f, -0.09647577f, 0.00588054f, 0.03658134f, 
    -0.02632158f, 0.10309498f, 0.11569425f, 0.00328468f, -0.05827515f, 0.03945807f, 0.30307838f, 0.05131967f, 
    0.32679337f, 0.04677051f, 0.01856795f, -0.05826207f, 0.08814121f, 0.10831201f, 0.02268537f, 0.05242964f, 
    0.04689080f, -0.10333706f, 0.03169616f, 0.06877530f, 0.02770218f, 0.02744288f, 0.00067119f, 0.06298263f, 
    0.00662434f, 0.22764322f, -0.23609442f, 0.18995431f, 0.18964985f, -0.03831309f, 0.00482934f, 0.14544789f, 
    -0.11545002f, 0.00296593f, -0.00128199f, 0.01610208f, 0.06521945f, 0.00993576f, 0.07783301f, -0.01764358f, 
    -0.02302338f, 0.02793536f, -0.04387266f, -0.03547922f, 0.18101114f, -0.16592875f, 0.38204539f, 0.28694665f, 
    0.07577599f, 0.06083465f, -0.14114350f, -0.04090834f, 0.12474304f, -0.06560458f, 0.01115530f, 0.04719655f, 
    0.07826860f, -0.01510551f, 0.01574281f, -0.00373683f, -0.05977797f, -0.03031987f, 0.03267550f, -0.06017267f, 
    -0.20590706f, -0.06042573f, -0.08124447f, -0.21115641f, -0.02870154f, 0.01063295f, -0.00851909f, 0.00012874f, 
    -0.02671048f, 0.02695690f, -0.01699077f, -0.04000278f, -0.05822153f, -0.00881592f, -0.03241557f, 0.00178983f, 
    -0.02709083f, -0.15600048f, 0.13371044f, 0.00372211f, -0.46248606f, -0.14197113f, -0.01264837f, -0.25523630f, 
    0.00909663f, -0.02087040f, 0.02047496f, -0.02669147f, -0.01072433f, 0.02662443f, -0.01917547f, -0.01525838f, 
    0.00489967f, -0.03704686f, -0.00200016f, -0.06642009f, -0.08220248f, -0.01068676f, 0.00770194f, -0.03316672f, 
    -0.14438276f, 0.00734698f, 0.07136413f, 0.00111330f, -0.00261492f, -0.05673982f, -0.02449162f, -0.25529891f, 
    -0.11061617f, -0.01389455f, 0.03338744f, -0.01085349f, -0.01847644f, 0.07382738f, 0.02876271f, 0.11481025f, 
    0.01562622f, 0.00715267f, 0.03995292f, 0.04126723f, -0.16898352f, -0.29712060f, 0.35122252f, 0.36311609f, 
    0.02426576f, 0.04674458f, 0.03309739f, -0.08819399f, 0.13056548f, -0.14588313f, -0.03661402f, 0.03155942f, 
    -0.03593212f, 0.00763113f, -0.08203726f, 0.04081393f, 0.02409185f, -0.07370771f, -0.00617380f, 0.01592541f, 
    0.12657386f, 0.02157874f, 0.24456756f, 0.05525869f, 0.18505870f, -0.02959014f, -0.00096049f, 0.04412506f, 
    0.05931893f, -0.02590917f, -0.02488055f, 0.01953675f, 0.05350726f, -0.03868683f, 0.06886981f, 0.03398634f, 
    -0.03745769f, 0.00306239f, 0.00085224f, -0.02772337f, 0.66626197f, -0.41629210f, -0.11869879f, -0.35875496f, 
    0.09593873f, 0.12588933f, 0.01889046f, -0.09595830f, -0.01077096f, -0.03686705f, -0.00244126f, -0.04619306f, 
    0.08889645f, 0.02582183f, -0.02419059f, 0.12686390f, 0.07566463f, -0.15162702f, 0.20879804f, 0.06431391f, 
    0.09971949f, -0.05030891f, -0.01895959f, -0.00723836f, 0.01308093f, 0.02230320f, -0.08696554f, 0.02139587f, 
    -0.04319883f, -0.00345723f, -0.10350606f, -0.01791467f, -0.00269630f, 0.04496816f, -0.03244124f, -0.01725768f, 
    0.03639600f, 0.00090898f, 0.06992922f, -0.08673320f, -0.00888190f, -0.01023142f, -0.10787113f, -0.07915103f, 
    0.05750283f, 0.01158389f, -0.14470059f, -0.06925452f, -0.05360491f, -0.15552793f, -0.01896412f, 0.03625390f, 
    -0.00842062f, 0.07294735f, 0.02621234f, 0.02920670f, -0.08082052f, -0.04590312f, 0.06334197f, -0.08730414f, 
    -0.09369875f, 0.10601100f, 0.07105129f, 0.01941160f, 0.02351110f, 0.00574852f, -0.02407204f, -0.01658083f, 
    -0.02758521f, -0.01191137f, -0.08506378f, -0.08885622f, 0.04861691f, 0.03889306f, 0.03262844f, 0.01646063f, 
    -0.06155242f, 0.01706306f, -0.00410660f, -0.04004793f, -0.11253803f, 0.30911568f, -0.14067620f, 0.14327626f, 
    0.05881359f, 0.17420235f, -0.06073307f, -0.01269369f, -0.00327148f, -0.10769507f, -0.01303226f, 0.11273832f, 
    -0.04695105f, -0.10632312f, 0.09219781f, -0.08723740f, -0.01543119f, 0.13653311f, 0.08377259f, -0.05947387f, 
    0.04872121f, 0.09810757f, 0.33635250f, 0.03674071f, 0.24298407f, -0.07519370f, 0.00616820f, 0.03881352f, 
    0.05548406f, -0.06051987f, 0.00566653f, -0.01526890f, -0.00969760f, 0.03684173f, 0.07806426f, 0.04620577f, 
    0.00106223f, -0.02884281f, 0.00694407f, -0.00817045f, -0.10527651f, -0.01440983f, -0.38034171f, 0.22214127f, 
    -0.22876689f, 0.03531359f, 0.03313174f, 0.12980811f, -0.04235298f, -0.10865293f, -0.01456170f, 0.06662057f, 
    -0.00338609f, 0.02024789f, -0.01047360f, 0.00563095f, 0.01363614f, 0.01529730f, -0.09401461f, 0.06548465f, 
    -0.37693143f, -0.53729320f, -0.14635456f, 0.22550935f, -0.43851459f, -0.01413650f, -0.01928492f, -0.00415505f, 
    0.04334266f, -0.11335314f, -0.00040575f, 0.00415343f, 0.01691878f, 0.02250655f, -0.07089280f, -0.05775774f, 
    -0.00841542f, 0.02620921f, -0.04108126f, 0.08070413f, 0.03167135f, 0.10598960f, 0.25356248f, 0.08383086f, 
    0.09650830f, 0.01958397f, -0.04341920f, 0.09980828f, 0.02070050f, -0.08867681f, 0.02245858f, -0.08293439f, 
    -0.01249901f, 0.02748698f, 0.10185825f, 0.01492844f, -0.00839161f, 0.03580998f, 0.05779134f, -0.04620237f, 
    0.20277770f, -0.11151984f, -0.41139406f, 0.00879924f, -0.02292879f, 0.00622788f, 0.00697902f, -0.01097943f, 
    -0.08862773f, 0.15341768f, -0.02285492f, -0.01942575f, -0.00941841f, 0.00653296f, -0.06255610f, 0.01011051f, 
    0.02203492f, 0.06629043f, -0.13794971f, 0.03515293f, 0.50969231f, 0.10965915f, -0.18268242f, 0.03095204f, 
    0.10948135f, -0.03543455f, 0.07055906f, 0.01493754f, -0.01160603f, 0.10828904f, -0.22781204f, 0.09204340f, 
    0.04446665f, 0.05614853f, -0.04668908f, 0.03432433f, -0.05209063f, -0.01691890f, 0.03171497f, -0.01302657f, 
    0.00560278f, 0.00302311f, -0.17453760f, -0.06197798f, 0.03585917f, -0.02161262f, -0.01220878f, -0.04763041f, 
    0.01071164f, 0.02361291f, 0.06694350f, -0.03898330f, -0.20377225f, 0.10209531f, 0.03000801f, 0.13576835f, 
    0.07824409f, 0.06632075f, 0.01455710f, -0.01281411f, -0.18972190f, -0.26424336f, -0.11477735f, -0.17032193f, 
    0.00646210f, -0.00280466f, 0.00698533f, -0.01679894f, 0.02292041f, 0.00804289f, 0.03212222f, 0.01810043f, 
    -0.01886672f, 0.09695410f, -0.01907444f, 0.00597303f, -0.07713855f, 0.12114497f, 0.04314808f, -0.00184756f, 
    -0.10781287f, 0.08931078f, 0.00293511f, 0.06390963f, 0.01881934f, -0.02285631f, -0.11680207f, -0.11688991f, 
    -0.10672493f, -0.21335246f, 0.04106954f, 0.05704721f, 0.08683728f, 0.01249248f, -0.01678455f, 0.02359552f, 
    -0.02192031f, -0.05236956f, 0.07225007f, -0.04330518f, -0.03924307f, -0.05572944f, 0.36639181f, 0.19802856f, 
    0.08904039f, 0.02772173f, -0.02057581f, 0.04890912f, -0.09878262f, 0.01766682f, 0.04107742f, 0.01546980f, 
    -0.01256362f, -0.11835743f, -0.08376106f, 0.01391310f, 0.02133084f, -0.00859121f, 0.11377774f, 0.03347043f, 
    -0.03966352f, -0.09343326f, 0.28520867f, 0.02538681f, 0.04106980f, -0.02013324f, -0.01717790f, 0.10123075f, 
    0.05504442f, -0.07018672f, -0.02255350f, 0.02491793f, 0.00732625f, -0.07257520f, 0.02701223f, 0.00753126f, 
    -0.00692273f, -0.01311018f, 0.05119449f, -0.04701380f, -0.24201530f, 0.29383960f, -0.16885439f, 0.15085398f, 
    -0.08379515f, -0.00010828f, -0.04087891f, 0.04036836f, -0.09808377f, 0.07929146f, -0.05653862f, 0.03854869f, 
    0.06075216f, 0.09092518f, -0.10814784f, -0.03024223f, -0.03943334f, -0.02545073f, 0.02804883f, -0.05694631f, 
    -0.40233698f, -0.30777737f, 0.49191120f, -0.23396316f, -0.01480303f, -0.06985927f, 0.02561902f, -0.10801058f, 
    -0.00185101f, -0.04079269f, 0.02704786f, -0.01625614f, 0.01001603f, -0.00485790f, -0.00125001f, 0.00340142f, 
    0.02109509f, 0.09114303f, -0.01648395f, 0.08139503f, 0.24264215f, 0.03919559f, -0.12309206f, -0.02740141f, 
    0.08190935f, 0.02983225f, -0.04138681f, 0.02045023f, 0.02288388f, 0.06132781f, -0.07252477f, 0.04328796f, 
    -0.03466019f, -0.03845793f, -0.00325188f, 0.10919184f, -0.01298532f, -0.02593065f, 0.09183854f, -0.03077066f, 
    0.17519690f, 0.06816471f, -0.09119367f, -0.04468937f, 0.08097843f, -0.02615131f, 0.03834991f, -0.04377455f, 
    -0.02745162f, 0.04481544f, -0.02683820f, -0.00293690f, -0.02717039f, 0.04082112f, -0.01639549f, 0.06212896f, 
    0.00899741f, 0.00199839f, -0.01482933f, -0.00472618f, 0.12266597f, 0.10465156f, -0.15785514f, 0.02137984f, 
    0.04433403f, -0.04965562f, -0.00408953f, -0.17438549f, -0.12742336f, -0.03872906f, -0.02687206f, -0.05878763f, 
    -0.08772115f, 0.06470256f, -0.04371035f, 0.00317077f, -0.04039967f, -0.02575595f, -0.01992325f, 0.06338299f, 
    0.02415088f, 0.51658851f, -0.04943065f, 0.16199198f, 0.25154480f, 0.14407399f, -0.10677421f, -0.06174018f, 
    -0.18387456f, 0.07275189f, -0.10127495f, -0.00353300f, 0.09086035f, -0.01395940f, 0.06211764f, -0.04286314f, 
    -0.07234338f, 0.00982866f, 0.01246493f, -0.00315070f, -0.24989319f, -0.29502204f, -0.15055160f, -0.06636690f, 
    -0.12009914f, 0.06835257f, 0.00133942f, -0.08264397f, -0.08795682f, -0.04604982f, -0.00051206f, -0.01849292f, 
    -0.02300031f, 0.02965771f, -0.08163150f, -0.01569517f, 0.01375499f, 0.00046951f, -0.07630171f, -0.11653237f, 
    -0.13293321f, 0.05005410f, -0.04997684f, -0.13329905f, 0.16077317f, -0.02904630f, 0.11593267f, -0.04898727f, 
    0.03708704f, 0.08254664f, -0.04052878f, -0.01120851f, 0.00490848f, -0.03811045f, 0.02343273f, -0.04230480f, 
    0.04245105f, 0.08280413f, 0.00715036f, -0.04221456f, -0.08631839f, 0.07125706f, 0.17078778f, 0.06590670f, 
    0.07140826f, -0.05623975f, -0.05912391f, 0.09820952f, 0.03623982f, -0.01227807f, 0.04577472f, -0.01934121f, 
    -0.03335496f, 0.06483719f, 0.02679535f, -0.01767754f, -0.01554947f, -0.07323903f, 0.05798130f, -0.09444954f, 
    -0.10756934f, 0.05158307f, 0.05089836f, -0.01300921f, 0.17989658f, -0.02529799f, 0.03146616f, -0.10422898f, 
    0.02551362f, -0.03568083f, -0.00462124f, 0.00406454f, -0.05674435f, -0.09144339f, -0.05041317f, -0.09714690f, 
    -0.01030294f, 0.02282365f, -0.06176303f, -0.00426688f, 0.07365888f, -0.12029009f, -0.21665110f, 0.00380770f, 
    0.17019323f, 0.11135130f, 0.01510319f, 0.08730291f, 0.12011682f, 0.07495287f, 0.03601806f, 0.02282672f, 
    0.00847910f, 0.02464771f, -0.01981890f, -0.01501562f, -0.03156956f, 0.06033299f, -0.02232175f, 0.04708699f, 
    -0.11064472f, -0.05052701f, 0.04372773f, 0.06331855f, 0.10534431f, -0.10907736f, 0.02868764f, 0.08186302f, 
    0.03212362f, -0.08032628f, -0.04468940f, -0.02350545f, -0.12564014f, -0.03563964f, -0.03368788f, -0.04904218f, 
    -0.03945796f, 0.02177815f, -0.08869790f, 0.03393261f, -0.11612040f, -0.08762126f, -0.16275238f, 0.02074466f, 
    -0.28337365f, 0.10993071f, -0.03125279f, 0.03296731f, -0.05148586f, -0.10486895f, -0.09654687f, -0.03773525f, 
    0.08770633f, -0.08903132f, -0.10979851f, 0.00041197f, -0.09871572f, -0.15956694f, -0.00403990f, 0.01191086f, 
    -0.50845635f, 0.48524231f, -0.39887926f, 0.23192360f, 0.53217685f, -0.08884717f, 0.05097578f, -0.15281492f, 
    -0.00073795f, -0.06554245f, -0.03446729f, -0.08587756f, 0.09480680f, -0.19117887f, -0.08908556f, 0.05597942f, 
    0.05014204f, 0.07696689f, 0.10263500f, -0.01736109f, -0.17148708f, -0.06104537f, -0.03148928f, -0.19901735f, 
    -0.40094426f, 0.01012212f, -0.06725216f, -0.20755991f, -0.04801254f, -0.11377061f, -0.03577822f, 0.04900217f, 
    -0.08368900f, -0.06587102f, -0.00929056f, -0.03942420f, -0.01813787f, 0.01968251f, -0.02670819f, -0.09143694f, 
    -0.05238605f, -0.14126629f, -0.09203356f, -0.04584473f, 0.16426890f, 0.12068239f, -0.03619473f, -0.03550103f, 
    -0.08862544f, -0.01117760f, -0.10403562f, -0.01035447f, 0.06225920f, -0.01663510f, 0.04194018f, 0.06327572f, 
    0.01388357f, 0.08510876f, -0.03646969f, 0.00211975f, -0.45217177f, -0.11136959f, 0.53100622f, -0.02660664f, 
    0.20628354f, -0.13039559f, -0.18934186f, -0.00410913f, 0.10926904f, -0.06097049f, 0.05731157f, -0.00312120f, 
    -0.00993970f, 0.02332951f, 0.10311396f, -0.07270329f, 0.00581870f, -0.08091312f, 0.03012579f, -0.04078731f, 
    0.07716046f, -0.06811962f, -0.15255268f, 0.10653988f, 0.24955188f, 0.06085747f, 0.11961753f, -0.00891964f, 
    0.06298783f, 0.10075793f, 0.06191567f, -0.02543328f, -0.05320342f, -0.05280327f, -0.06666707f, 0.04826182f, 
    -0.06917884f, 0.18157285f, -0.31503460f, -0.03348701f, -0.16084906f, -0.31286544f, -0.13957243f, -0.23987272f, 
    -0.25040913f, -0.06993746f, 0.01261838f, -0.16893446f, -0.08388188f, -0.06454438f, 0.12436701f, 0.13723423f, 
    0.06264303f, -0.05975143f, 0.09407783f, 0.04506066f, 0.09181441f, 0.16958714f, -0.22456242f, -0.14227249f, 
    -0.70977002f, 0.59397966f, -0.08723967f, -0.24747413f, 0.02061859f, 0.14380862f, -0.13963076f, -0.04784722f, 
    0.09795277f, -0.10472733f, -0.00242957f, 0.01074647f, -0.08425760f, -0.17066680f, 0.00746003f, 0.05555554f, 
    -0.03671754f, 0.04385357f, 0.03281725f, -0.01696764f, 0.52685052f, 0.03892012f, -0.00791873f, -0.26272675f, 
    -0.51168281f, 0.09007805f, -0.01541677f, -0.04067359f, -0.00866654f, -0.03654590f, 0.34433201f, 0.12983216f, 
    0.29297873f, -0.27483085f, -0.32345527f, -0.03267607f, -0.05047937f, -0.16062000f, 0.14339483f, -0.04707349f, 
    0.09593509f, 0.16653055f, -0.08930068f, -0.12158706f, 0.22045137f, 0.22570199f, 0.08587780f, -0.01026026f, 
    0.05915779f, 0.00479073f, -0.13759908f, 0.05978660f, 0.13032724f, 0.07312289f, 0.11228678f, -0.07036370f, 
    0.06345677f, -0.01385029f, -0.01431572f, 0.03478053f, -0.15524310f, -0.08789693f, -0.23971981f, 0.00209024f, 
    0.20971747f, 0.02628889f, -0.05073409f, 0.00434163f, 0.05545757f, 0.03649949f, -0.05291072f, -0.00129874f, 
    -0.10466827f, -0.01465177f, -0.02966430f, -0.01977913f, 0.00639390f, 0.17520513f, -0.23746532f, 0.03042113f, 
    -0.21257767f, -0.04780096f, 0.18764459f, 0.15275417f, 0.14683081f, 0.03879794f, 0.00677750f, 0.23346668f, 
    -0.03709553f, 0.03424581f, 0.09345507f, 0.04897529f, -0.11592427f, 0.07422446f, 0.10733567f, -0.05329674f, 
    -0.04967462f, 0.10440624f, -0.04273042f, -0.10683405f, -0.30278641f, -0.10638789f, -0.17757429f, 0.02274958f, 
    -0.22805439f, -0.02975140f, -0.16969751f, -0.18175164f, 0.03482624f, 0.04895913f, 0.05053314f, -0.02139455f, 
    0.05139017f, -0.00533490f, -0.04036480f, 0.05658422f, -0.01954404f, -0.09618531f, -0.05564005f, -0.04282189f, 
    -0.35790920f, -0.18917008f, 0.14694622f, 0.00104421f, 0.17475036f, 0.03160509f, 0.07440406f, -0.04369253f, 
    -0.06307612f, 0.02861326f, -0.07207272f, 0.13367169f, -0.08977952f, 0.05015239f, -0.04134515f, 0.01637751f, 
    0.08925165f, 0.10559475f, -0.17232032f, -0.03513522f, 0.51518065f, 0.06247822f, -0.01240479f, -0.25357610f, 
    -0.37199816f, 0.10207254f, 0.07253738f, 0.08624101f, 0.04791212f, -0.01203601f, 0.02602681f, -0.08652963f, 
    0.06274071f, -0.02458305f, 0.00424785f, -0.13692446f, -0.08894849f, -0.15832391f, 0.04150148f, 0.07036352f, 
    -0.02427218f, -0.17142230f, 0.40500680f, -0.08574142f, 0.20338282f, -0.14575170f, 0.09919286f, -0.04112796f, 
    0.09507070f, 0.00019123f, 0.08258107f, 0.00670755f, -0.03244655f, 0.03611486f, 0.05374716f, -0.07309576f, 
    0.02424851f, 0.01615772f, 0.01597378f, 0.05334162f, -0.33873290f, -0.15620612f, 0.44566762f, -0.33835658f, 
    0.03825068f, -0.17896660f, -0.11526657f, -0.00526902f, -0.04486743f, -0.07724549f, 0.04465524f, -0.00780472f, 
    -0.03990408f, 0.04318431f, 0.10589997f, -0.00313790f, -0.00534507f, -0.07490545f, -0.05938770f, 0.03679311f, 
    0.18290322f, 0.15995288f, 0.00861685f, -0.12978701f, 0.13418083f, -0.05282799f, 0.10027412f, 0.07759911f, 
    -0.03634270f, 0.09496698f, -0.09764748f, 0.02711253f, 0.00612752f, -0.01038637f, -0.01376252f, 0.05515483f, 
    0.03729253f, 0.04502334f, -0.01703173f, 0.01676943f, -0.25843182f, -0.32155791f, -0.19941556f, 0.02413585f, 
    -0.11258215f, 0.00683505f, 0.11649402f, -0.02794033f, -0.17250890f, -0.00818563f, -0.05759498f, 0.02957440f, 
    0.05285863f, -0.01319502f, -0.12310883f, 0.04250461f, 0.02161371f, 0.02856151f, -0.04353942f, -0.07359719f, 
    0.00687735f, -0.08784829f, -0.20013998f, -0.04512886f, -0.14527410f, 0.22211131f, 0.05432501f, 0.11118693f, 
    0.01355899f, 0.03850700f, -0.05512525f, -0.00544362f, -0.07246103f, 0.06679048f, 0.06236976f, 0.11237112f, 
    0.08962923f, 0.06669404f, 0.00188674f, -0.06936228f, 0.02009863f, 0.19928372f, -0.24441589f, -0.25511560f, 
    0.04773622f, 0.00390521f, -0.04333195f, -0.11265534f, 0.09403266f, -0.12020076f, 0.03229680f, -0.00918846f, 
    -0.17424126f, -0.05509092f, -0.05336605f, 0.12195209f, -0.01876417f, 0.00148750f, -0.13371231f, -0.05756087f, 
    0.23200211f, -0.14537773f, 0.03058841f, -0.11798426f, 0.16441582f, 0.03652539f, 0.21025908f, 0.04864547f, 
    0.11170266f, 0.02669277f, -0.03260747f, 0.03649969f, 0.03245955f, -0.16097775f, -0.04803994f, -0.12876521f, 
    -0.05603296f, -0.01412988f, 0.15868846f, -0.00493280f, -0.44016087f, -0.05088105f, 0.41151261f, -0.10059897f, 
    -0.23355198f, -0.05037548f, -0.04985135f, 0.08528633f, 0.09152289f, -0.05811338f, 0.02340938f, 0.03496816f, 
    0.11652018f, 0.02223803f, -0.11500701f, -0.00971125f, -0.02564830f, -0.08657958f, 0.04136869f, -0.02884331f, 
    0.42736906f, 0.53241450f, -0.30420586f, 0.01316991f, -0.19440210f, 0.12153301f, 0.02390642f, -0.02154949f, 
    0.09586249f, 0.03221360f, 0.01790116f, -0.08025060f, 0.00276389f, -0.02570604f, 0.04834510f, -0.11609130f, 
    0.00457958f, -0.16424011f, -0.02409570f, 0.03801932f, 0.05885445f, -0.01382962f, 0.20038769f, -0.15885462f, 
    -0.29163826f, -0.03976440f, -0.00375522f, 0.03981067f, 0.07707911f, -0.05364603f, -0.00013531f, -0.01653448f, 
    -0.00711720f, -0.01779055f, -0.04298895f, -0.01303823f, -0.03522109f, -0.01468680f, -0.01506469f, -0.02471014f, 
    -0.41730395f, -0.17566457f, 0.07915703f, 0.16071978f, 0.18174572f, 0.04202081f, 0.06150075f, 0.08776243f, 
    -0.00783703f, 0.03838002f, 0.01061141f, 0.03313797f, -0.01550935f, -0.02342344f, 0.19936754f, 0.07086856f, 
    -0.09580276f, 0.12148306f, -0.07170538f, -0.19145352f, 0.51280963f, -0.05795787f, -0.22769614f, -0.00386297f, 
    0.10716933f, 0.15279776f, -0.07061204f, 0.07998673f, -0.15645349f, -0.11142915f, -0.24389218f, -0.05439913f, 
    -0.00483627f, 0.01386378f, -0.00510873f, 0.03606347f, 0.05855975f, 0.02249313f, -0.01188239f, 0.06292122f, 
    -0.92024136f, 0.35983574f, -0.12240060f, 0.06622899f, -0.03592044f, 0.04358941f, -0.11479156f, 0.02593046f, 
    -0.11922579f, 0.01889297f, -0.09530439f, -0.06171373f, -0.08894411f, -0.14344569f, 0.06569991f, 0.03060912f, 
    0.00056684f, 0.05622720f, -0.11233082f, -0.16505593f, -0.00409298f, 0.17161222f, -0.08239730f, -0.13398577f, 
    0.17423457f, 0.14728051f, 0.08728777f, -0.04405046f, 0.02306514f, -0.07046713f, -0.09982020f, 0.01655901f, 
    0.03834334f, 0.04036207f, 0.08632684f, -0.05758522f, 0.03672345f, 0.02307378f, -0.06656352f, 0.04543371f, 
    0.20213898f, -0.02484161f, -0.23822136f, 0.01023979f, 0.14295273f, -0.01378164f, -0.05447647f, 0.03706006f, 
    -0.00120437f, -0.09012178f, -0.03348067f, 0.13785234f, -0.00059238f, 0.06181067f, 0.05398742f, 0.01535677f, 
    -0.05723411f, -0.02182382f, -0.05454110f, -0.07952292f, -0.55270445f, 0.31899232f, -0.12151916f, -0.11625466f, 
    0.22381698f, 0.23244327f, 0.04164635f, -0.05269632f, 0.08881192f, -0.10350280f, -0.22376312f, 0.05657155f, 
    -0.05916199f, 0.11063067f, 0.01967781f, -0.08384113f, -0.02775959f, 0.01660719f, 0.22251007f, -0.11620030f, 
    -0.56633782f, 0.07980931f, -0.26776969f, 0.27598113f, -0.14589161f, 0.25361156f, 0.02563181f, 0.11094508f, 
    0.18595028f, 0.04312604f, 0.03867975f, -0.05399828f, 0.02046861f, -0.09282568f, -0.04811614f, -0.00631157f, 
    -0.02761147f, -0.14204721f, 0.06099795f, -0.04024059f, -0.19029179f, -0.15661399f, 0.18285067f, -0.22348392f, 
    -0.03120179f, -0.10782751f, -0.09690790f, -0.15712157f, -0.06419002f, -0.02984563f, 0.25024554f, 0.10448431f, 
    0.08625431f, 0.00496135f, 0.06012411f, -0.01124356f, 0.06895783f, -0.08559057f, -0.06700665f, -0.05837680f, 
    -0.04039761f, 0.27113506f, 0.22728203f, 0.37206995f, 0.29776174f, -0.00938929f, -0.04285043f, -0.06969551f, 
    0.00117588f, -0.10987814f, -0.05669196f, 0.01517047f, 0.04579750f, -0.05867494f, 0.04347948f, 0.04457785f, 
    0.07346930f, 0.00546532f, 0.03448135f, -0.00962212f, -0.02597649f, -0.01774511f, -0.18230066f, -0.04872731f, 
    0.27594408f, 0.03728878f, 0.04240273f, 0.05279531f, -0.04393154f, 0.00660793f, -0.05714057f, 0.07450309f, 
    0.00509267f, 0.07864785f, 0.09821148f, -0.04949132f, -0.03183196f, 0.05816390f, 0.07401417f, 0.07399277f, 
    -0.42849576f, 0.30904707f, -0.04221744f, -0.18316144f, 0.22837532f, 0.15491442f, -0.04434295f, -0.01868888f, 
    -0.06379458f, -0.07059486f, -0.17587429f, -0.01001095f, -0.02004339f, -0.01694199f, 0.03872414f, 0.01133187f, 
    -0.00374460f, -0.09324544f, 0.07466187f, 0.03192849f, 0.83753568f, 0.07249440f, -0.12318357f, -0.37852332f, 
    -0.22784367f, 0.05352274f, 0.08512823f, 0.03331179f, -0.17146917f, -0.04921244f, -0.22170889f, -0.23187278f, 
    0.16019140f, 0.01622219f, 0.03251727f, -0.03874520f, 0.03993312f, -0.22018141f, 0.03167521f, 0.14633811f, 
    0.20906667f, -0.29097816f, 0.09671374f, 0.19190164f, -0.08243646f, 0.18812770f, 0.19777168f, 0.02536650f, 
    -0.12713817f, 0.14883327f, 0.10577502f, -0.07201717f, -0.01196445f, -0.05378204f, -0.19919969f, -0.09290371f, 
    -0.12029417f, 0.24509126f, -0.09673918f, -0.21981625f, -0.22835107f, 0.02874996f, 0.15816228f, -0.16409832f, 
    0.23582815f, -0.01532011f, -0.01411755f, 0.05162378f, -0.06271707f, 0.05199629f, 0.03959168f, 0.01015637f, 
    0.01323056f, 0.11562227f, -0.03687483f, -0.15585513f, 0.01340271f, 0.29078880f, -0.28695619f, 0.01172552f, 
    -0.06813075f, 0.13479409f, -0.01823189f, 0.26884761f, 0.09143739f, -0.11630614f, -0.04217907f, -0.01796385f, 
    -0.15827809f, -0.01867875f, 0.01298439f, -0.01301660f, -0.01655355f, -0.10116902f, -0.06730703f, 0.05290521f, 
    0.02835962f, 0.06281529f, 0.00580467f, -0.04641834f, -0.41139382f, 0.20065270f, 0.04450863f, -0.14369337f, 
    0.14332625f, -0.01947416f, 0.01493417f, -0.00319894f, 0.02789061f, -0.00179934f, -0.23089583f, -0.04027933f, 
    -0.10980757f, -0.08328009f, 0.16534668f, -0.01286602f, -0.00720760f, 0.16667420f, -0.04575180f, -0.10281048f, 
    0.24255602f, -0.07819215f, -0.12911233f, -0.05680736f, 0.17963648f, 0.16636984f, -0.07952259f, 0.07374063f, 
    -0.21401079f, -0.03157314f, -0.16110463f, -0.00176706f, 0.02811822f, -0.03696475f, -0.03603615f, -0.02593015f, 
    -0.00998681f, -0.05822113f, 0.04626429f, 0.08796445f, 0.12093616f, -0.11941470f, -0.20902523f, -0.11919574f, 
    0.16937865f, 0.10408440f, 0.00307614f, 0.02813094f, 0.09965003f, -0.01965450f, 0.12042484f, 0.01233981f, 
    0.02560381f, 0.02598586f, 0.05433119f, -0.06780548f, -0.03826368f, 0.07402513f, -0.15226202f, 0.04440488f, 
    -0.02858585f, -0.11707188f, -0.22729161f, -0.00865008f, 0.26868558f, 0.04085026f, 0.00637294f, -0.03852824f, 
    -0.01853843f, 0.07553944f, -0.03836432f, 0.02754307f, -0.08832739f, -0.01397472f, -0.02892172f, -0.03505349f, 
    -0.01003392f, 0.06399764f, -0.01034370f, 0.02528659f, 0.21609350f, 0.00868767f, -0.08346024f, 0.07090756f, 
    0.06335149f, 0.15347527f, -0.02040282f, 0.00458033f, -0.09071819f, -0.06835342f, -0.09019174f, -0.00958058f, 
    -0.00908789f, 0.02069097f, -0.04489668f, -0.00341966f, -0.05651253f, 0.02912625f, 0.01591695f, -0.06093214f, 
    0.08073136f, -0.00643432f, -0.03263074f, -0.00953188f, 0.11414722f, 0.03719327f, -0.05609137f, -0.08329757f, 
    0.05323027f, -0.05738400f, 0.01487452f, -0.00265567f, -0.11514941f, -0.04442943f, -0.02334890f, 0.02100854f, 
    -0.05536196f, -0.02088878f, -0.20880818f, -0.00972291f, 0.15056269f, 0.74875003f, 0.01124795f, -0.38511157f, 
    -0.24033161f, -0.00826120f, -0.14685272f, -0.15150791f, -0.14762805f, -0.04544429f, -0.09036278f, -0.13924412f, 
    -0.03921764f, -0.06746742f, 0.14535958f, 0.05055175f, 0.10225145f, -0.10177484f, -0.09151668f, 0.03099287f, 
    -0.49940243f, 0.39292449f, -0.09516918f, -0.03059149f, -0.34919116f, 0.04401827f, 0.01477725f, 0.12202542f, 
    -0.02581159f, 0.07664450f, -0.09557448f, 0.03191717f, -0.01063377f, -0.02295952f, -0.17297995f, -0.03788658f, 
    -0.01041851f, 0.04296133f, 0.02314760f, -0.02825611f, -0.53196800f, -0.25488982f, -0.12171834f, -0.00833099f, 
    -0.14330414f, 0.16867135f, 0.05153289f, 0.06967185f, 0.10961610f, 0.12467432f, 0.02640386f, 0.10133062f, 
    0.05110479f, -0.00337795f, -0.07804356f, -0.07985879f, 0.02338133f, 0.07234417f, -0.16430859f, -0.14581500f, 
    -0.32892337f, 0.02778617f, -0.22263132f, 0.16811022f, 0.13675383f, 0.09538942f, -0.04664456f, 0.07491363f, 
    -0.00010623f, 0.04841625f, -0.00369757f, -0.06054548f, 0.01587554f, -0.05525097f, -0.11141569f, 0.16579911f, 
    0.06593604f, 0.08275205f, -0.01616428f, -0.16162263f, 0.05797105f, 0.04026441f, -0.23135738f, 0.12885067f, 
    0.18469265f, -0.04647056f, 0.01406882f, -0.10167378f, 0.09225609f, 0.02260690f, 0.04188622f, 0.09519397f, 
    0.00655576f, 0.04130420f, 0.00563750f, 0.00280451f, 0.00537350f, -0.00214238f, 0.06085162f, -0.04202078f, 
    -0.11844698f, 0.21382153f, -0.23353820f, -0.06037950f, 0.03467625f, 0.23241693f, 0.11386316f, -0.01487053f, 
    -0.11981558f, 0.03018652f, -0.03580017f, -0.04351895f, -0.02011359f, -0.06996697f, 0.03383624f, -0.00903876f, 
    -0.01872016f, 0.03684113f, 0.14364664f, -0.06686335f, -0.94292802f, 0.23599471f, 0.01672425f, -0.20256153f, 
    -0.05556953f, -0.02897037f, -0.07978397f, -0.21936023f, -0.04716624f, -0.14463644f, -0.09717757f, 0.02357345f, 
    -0.08249237f, -0.08183362f, 0.01483443f, -0.00213204f, 0.11889382f, 0.00554021f, -0.18351720f, -0.16342342f, 
    -0.04824406f, -0.44368985f, 0.32601985f, 0.10159019f, 0.40605193f, -0.24413683f, 0.06306598f, 0.07573630f, 
    0.16998334f, 0.08224976f, 0.07216845f, 0.04046788f, 0.02454502f, -0.01574999f, 0.12399492f, -0.05906934f, 
    0.04505843f, 0.05570923f, 0.09751030f, 0.04824861f, 0.00122309f, 0.60207021f, -0.19631557f, -0.18088537f, 
    -0.26576269f, -0.04864137f, -0.06641930f, -0.05068832f, -0.12371172f, 0.03774936f, -0.15351716f, -0.11986510f, 
    -0.05642554f, -0.07173207f, 0.04401106f, -0.06214070f, -0.00707310f, -0.01598930f, 0.06451553f, 0.04309333f, 
    0.61800563f, 0.29733378f, -0.05991656f, -0.16791403f, -0.25707799f, 0.03824449f, -0.11991920f, 0.04028976f, 
    -0.10508309f, -0.15829849f, -0.11146457f, -0.00114436f, 0.02092027f, -0.06505038f, 0.03549685f, 0.01359896f, 
    0.01336076f, -0.09622887f, -0.03173475f, 0.04577035f, 0.39545479f, 0.20776935f, -0.31181958f, -0.43151954f, 
    0.20660661f, 0.08407316f, -0.00289941f, 0.02438714f, 0.06794947f, -0.03983143f, 0.02129848f, 0.00987791f, 
    -0.02861135f, -0.01875310f, -0.00852765f, 0.08670899f, -0.06615843f, 0.04365565f, 0.09970039f, 0.01354237f, 
    -0.31523132f, -0.36359435f, 0.25417635f, 0.01240989f, 0.09816071f, -0.23526993f, -0.04411667f, -0.15201920f, 
    -0.03423880f, -0.15233448f, 0.04003890f, -0.09238952f, -0.10548702f, 0.07438736f, -0.00478139f, -0.00817383f, 
    0.07182648f, 0.02168806f, -0.03296345f, -0.08146118f, 0.05116963f, 0.01724403f, -0.03996191f, -0.02797842f, 
    -0.01237917f, 0.04836076f, 0.00938109f, 0.05210349f, 0.01690964f, 0.02231512f, 0.06764639f, 0.03050916f, 
    -0.06203169f, 0.00097871f, 0.04854013f, 0.07864892f, 0.04611816f, -0.06361603f, -0.01851449f, 0.02137655f, 
    -0.13779692f, -0.07665161f, -0.06244779f, 0.10283297f, -0.00433454f, -0.05071236f, -0.05820509f, 0.02829444f, 
    -0.19004621f, 0.00328582f, -0.02784448f, 0.02067074f, -0.03731016f, 0.09414295f, 0.04460381f, 0.13941023f, 
    0.09498465f, -0.04053886f, -0.00858861f, 0.20504817f, -0.04295549f, -0.00676127f, -0.01270488f, 0.01683161f, 
    0.03313758f, 0.07759207f, 0.05134996f, 0.06469148f, -0.05322546f, 0.07603428f, 0.03851191f, -0.01206721f, 
    0.00455528f, -0.08916972f, 0.02434797f, 0.03032845f, -0.05329367f, -0.03174732f, -0.08340939f, -0.06505732f, 
    -0.03086656f, -0.03709183f, -0.03764336f, 0.16258879f, -0.10271891f, -0.01076051f, -0.03750373f, -0.00138284f, 
    -0.18023632f, -0.02399401f, -0.05704778f, 0.05775182f, -0.07050847f, 0.03649022f, -0.03857782f, 0.03984438f, 
    0.01402911f, -0.12685700f, -0.05321114f, 0.15971921f, 0.11970127f, 0.14187707f, 0.26571950f, 0.22023474f, 
    0.21109433f, -0.11227164f, -0.08190627f, -0.08253522f, -0.09525893f, 0.10949045f, 0.05022146f, 0.04687619f, 
    0.01632319f, 0.02659451f, 0.01200800f, 0.02725514f, -0.02055916f, -0.07273921f, -0.01545572f, -0.09407484f, 
    0.02465049f, -0.10205287f, 0.10912062f, -0.15156107f, 0.07340986f, -0.06798110f, 0.10269264f, 0.15164280f, 
    0.06045144f, -0.07315870f, 0.02132183f, -0.10237361f, 0.02985468f, -0.06888405f, 0.01544176f, 0.02573471f, 
    0.06057538f, -0.03929737f, 0.02221253f, -0.02372206f, 0.02658635f, -0.00544134f, -0.06749351f, -0.05653344f, 
    -0.02561122f, 0.01765352f, -0.03039628f, 0.04997727f, 0.04541141f, 0.02981986f, -0.10935813f, -0.18181171f, 
    -0.00403545f, -0.09554710f, 0.03190125f, 0.07383134f, -0.00322847f, -0.02636777f, -0.00784046f, 0.03144335f, 
    0.03100058f, -0.01658543f, -0.07109171f, -0.08511434f, -0.18517894f, 0.12766571f, 0.01554022f, 0.14219271f, 
    -0.07411040f, 0.06499672f, -0.02331595f, -0.09178075f, 0.31257448f, -0.01755524f, -0.05117443f, -0.07800280f, 
    0.00448048f, -0.06210257f, -0.15559641f, 0.00941253f, -0.10078409f, -0.04653414f, -0.04378254f, -0.12979652f, 
    -0.03523550f, -0.04315096f, 0.00742699f, 0.00520829f, 0.04332688f, -0.01154606f, 0.04700334f, -0.03086798f, 
    0.05663118f, -0.03888233f, -0.00992170f, -0.00364908f, -0.13202693f, -0.06079846f, -0.01739564f, 0.04112604f, 
    0.11435364f, 0.07476080f, 0.07359733f, 0.00818747f, 0.04622409f, -0.09024674f, -0.02781512f, -0.03698809f, 
    -0.04163273f, 0.00547108f, 0.08784603f, 0.01664408f, -0.05871760f, -0.03973642f, 0.02487204f, 0.06759423f, 
    0.02450069f, 0.00815680f, -0.00759951f, -0.02565629f, 0.14236587f, 0.12524274f, -0.16948059f, 0.07298770f, 
    0.12572217f, 0.01728428f, 0.08416112f, 0.02871110f, 0.02879809f, 0.01146505f, 0.10198939f, -0.01026076f, 
    0.00876329f, -0.01890509f, 0.01000354f, -0.03136743f, -0.08424833f, 0.09497554f, -0.09499602f, 0.01902306f, 
    -0.01264463f, 0.08607275f, 0.31479347f, 0.36041415f, 0.19585845f, -0.05433827f, 0.10872219f, 0.04865153f, 
    -0.00565439f, 0.03566261f, -0.01956002f, 0.01710720f, 0.00418041f, -0.00473865f, 0.02491307f, -0.01383571f, 
    -0.02176006f, -0.17864165f, -0.02356759f, 0.03828190f, 0.01652948f, 0.04403536f, -0.04499986f, 0.01495628f, 
    0.05969504f, 0.00854997f, 0.04890199f, 0.05549803f, 0.01086554f, 0.04248249f, 0.04200393f, 0.00862086f, 
    0.01101229f, -0.01678439f, 0.07400046f, -0.03304264f, -0.07844048f, 0.03328054f, 0.02867227f, 0.04120293f, 
    -0.08602847f, -0.14560358f, -0.00155814f, -0.08767384f, 0.03350487f, 0.03001368f, 0.02254775f, 0.00769182f, 
    0.05610689f, -0.05430206f, -0.02019890f, -0.17252225f, -0.22065553f, 0.04727044f, 0.04666193f, 0.01325977f, 
    -0.04983748f, -0.03062342f, -0.04567926f, -0.11501077f, -0.33431578f, 0.11526100f, -0.14305080f, 0.20863333f, 
    -0.25957805f, 0.02645983f, 0.07597302f, -0.11604264f, 0.02770150f, -0.05669907f, 0.10992342f, -0.19978493f, 
    -0.14156792f, 0.10661741f, 0.23391014f, -0.06444155f, -0.02432006f, 0.03119091f, -0.15314433f, -0.35007453f, 
    -0.26903984f, -0.31754670f, 0.08283781f, 0.09354379f, 0.07434017f, -0.04523594f, -0.02160514f, 0.02587813f, 
    -0.12751104f, 0.10443516f, 0.02461996f, 0.06175113f, -0.09243940f, -0.08402115f, -0.08782789f, -0.01982690f, 
    0.04239000f, -0.05200281f, 0.05034913f, 0.04760416f, 0.06413107f, -0.00204526f, 0.31017488f, 0.13545661f, 
    0.11224074f, -0.14020668f, 0.11217120f, 0.01366418f, 0.02863144f, 0.09378126f, -0.03698276f, 0.02408407f, 
    -0.01004240f, 0.03466891f, 0.04217426f, -0.01764371f, -0.03131604f, -0.05427736f, 0.00347559f, -0.08072993f, 
    0.07459542f, -0.01217561f, 0.05939369f, -0.05338209f, 0.14851205f, 0.08861528f, 0.05636335f, 0.14070106f, 
    0.02567499f, 0.08849142f, 0.03305200f, 0.04033322f, -0.00225621f, -0.02586721f, 0.03044179f, 0.04913662f, 
    -0.07111347f, -0.09034467f, -0.06033295f, -0.08811459f, 0.02958692f, 0.03864313f, 0.00799994f, -0.04519501f, 
    -0.04433506f, 0.11293914f, 0.01126515f, 0.05863997f, 0.01386977f, 0.01324888f, 0.01229077f, -0.00716885f, 
    0.04400126f, 0.01215474f, 0.04489366f, 0.06461371f, 0.05163961f, -0.01464630f, -0.02669597f, 0.04457881f, 
    0.14123519f, -0.05926357f, -0.09887522f, -0.04032725f, -0.19250268f, -0.04336199f, -0.04715376f, 0.04503389f, 
    0.28265515f, 0.06030513f, -0.01560242f, -0.01801791f, 0.04411496f, 0.00109784f, 0.01673257f, 0.06789700f, 
    0.24167132f, -0.07986892f, 0.20530008f, 0.23603337f, 0.05786836f, -0.14625594f, -0.15945689f, -0.16280179f, 
    -0.42609566f, 0.01075612f, -0.04751505f, 0.01477218f, 0.00024513f, 0.04510099f, -0.01271429f, -0.05365719f, 
    0.04686826f, 0.03359485f, -0.13792023f, 0.00630094f, -0.05614975f, 0.05091173f, -0.06104312f, 0.11372347f, 
    -0.02001239f, 0.02294733f, -0.11290347f, 0.21345223f, 0.13806045f, 0.04571095f, -0.01017719f, 0.02757267f, 
    -0.01839632f, 0.06284026f, 0.08144300f, 0.01056786f, 0.02764932f, -0.01210877f, -0.01008339f, -0.09015492f, 
    0.04685885f, -0.05595504f, -0.02839825f, -0.01471982f, 0.11068145f, 0.00971188f, -0.12247933f, 0.13877334f, 
    0.15398711f, 0.02114081f, 0.05911286f, 0.03455113f, 0.02306715f, 0.01038172f, 0.07047091f, 0.00612097f, 
    0.02884960f, -0.01404987f, 0.04305400f, -0.01841246f, -0.01673611f, -0.05910179f, 0.01228681f, 0.00559371f, 
    -0.02538494f, -0.16786201f, -0.05196053f, 0.19586389f, 0.00525875f, 0.08801331f, 0.05433476f, 0.10292146f, 
    -0.13131027f, -0.05376999f, -0.02874554f, -0.02359629f, 0.00498753f, -0.01786545f, -0.03413424f, 0.09726249f, 
    0.17395632f, 0.17475511f, 0.11834347f, 0.26595685f, 0.02710426f, 0.00469103f, 0.00250117f, -0.06061709f, 
    -0.03190327f, 0.09404520f, 0.01137737f, 0.07310004f, -0.00553890f, 0.02699850f, 0.05713392f, 0.01360482f, 
    -0.11303602f, 0.01478230f, -0.03445927f, 0.07094863f, 0.06179617f, -0.06902280f, -0.06218464f, 0.03096324f, 
    0.06416221f, 0.09656936f, -0.03143917f, -0.01602375f, 0.00806959f, -0.00538744f, -0.02149863f, -0.01697430f, 
    0.09129572f, 0.06378537f, 0.02363533f, -0.05647962f, 0.02135652f, -0.09364203f, 0.01619650f, 0.03044686f, 
    -0.04302356f, 0.00371829f, -0.03243615f, 0.00874123f, -0.04040208f, -0.01235595f, 0.01029327f, 0.02300780f, 
    -0.13301089f, 0.04033302f, -0.08856372f, 0.00935852f, -0.00939096f, 0.06132862f, -0.12353730f, -0.02626681f, 
    0.02537370f, -0.01287739f, 0.02795356f, -0.03492030f, -0.17725182f, -0.01322959f, -0.00537935f, -0.13868822f, 
    0.00243496f, 0.19667131f, 0.08168435f, 0.36607367f, -0.11145158f, 0.07726881f, 0.00722056f, -0.19644764f, 
    0.04382871f, 0.05448826f, 0.04977077f, -0.03638680f, -0.04272918f, 0.05619964f, -0.04181965f, -0.03493334f, 
    0.04920011f, -0.27152938f, -0.14897661f, -0.10771745f, -0.13641220f, 0.08748969f, -0.20929335f, -0.11900100f, 
    -0.00580825f, 0.04065497f, 0.04501121f, 0.02875813f, 0.03120735f, 0.05044581f, 0.09298477f, -0.01034432f, 
    -0.02709941f, -0.00666604f, 0.04850165f, 0.05728986f, 0.06129908f, 0.12948360f, -0.10018334f, 0.12566166f, 
    -0.92661351f, -0.23245774f, -0.06630071f, -0.66155350f, -0.19308692f, 0.00301553f, 0.02403021f, -0.02655900f, 
    0.07715682f, 0.09306074f, -0.12949982f, -0.00415546f, 0.02559699f, 0.06405966f, -0.02583071f, -0.08788059f, 
    0.03628020f, 0.00500646f, -0.03004648f, 0.07886559f, -0.17557549f, 0.09425177f, -0.22646722f, -0.22438130f, 
    -0.08822805f, 0.07272424f, 0.02870382f, -0.01230374f, 0.03033839f, 0.01541863f, 0.01464503f, -0.00985678f, 
    -0.04676311f, -0.02554131f, 0.01890024f, -0.00598679f, 0.04639481f, -0.00253385f, -0.05259697f, 0.14510205f, 
    0.12771873f, -0.03602034f, 0.12875965f, -0.03722217f, 0.27145788f, 0.18073143f, 0.01779340f, 0.08471744f, 
    0.09168447f, 0.06857608f, 0.03437287f, 0.00326295f, -0.02620760f, -0.04734999f, 0.00972533f, 0.01963562f, 
    -0.12755194f, -0.14337508f, -0.20004177f, -0.11133393f, 0.14843726f, -0.16376214f, 0.00585744f, -0.05787883f, 
    0.00868259f, -0.10519741f, -0.05274152f, -0.00203726f, 0.04911632f, 0.08341140f, 0.02944272f, -0.03236583f, 
    0.00879993f, -0.16067809f, 0.03033391f, 0.02571456f, -0.05032993f, 0.02023843f, -0.08532353f, 0.05195558f, 
    0.11903623f, -0.32016110f, 0.04162682f, -0.27660593f, 0.11193594f, -0.01067322f, 0.03630726f, 0.05183498f, 
    0.03044584f, -0.08984844f, -0.00504981f, -0.05520575f, -0.14290403f, 0.01777041f, -0.05682176f, -0.16364583f, 
    -0.19984113f, -0.09472378f, -0.06422424f, -0.01872462f, -0.21449825f, -0.12414361f, 0.09198870f, -0.01206496f, 
    0.07811023f, -0.07414163f, -0.05751118f, -0.07417256f, -0.11863471f, 0.04001268f, 0.03246752f, 0.00664592f, 
    -0.09307590f, -0.06884895f, -0.03826722f, -0.08244520f, -0.00889078f, -0.01543772f, 0.03628021f, 0.04963868f, 
    0.10760973f, 0.02372696f, 0.14443474f, -0.04069196f, 0.10531282f, -0.09399283f, -0.06059264f, -0.04167262f, 
    0.17547332f, -0.13230915f, 0.04896138f, -0.03302810f, 0.00080062f, -0.04997742f, 0.04519966f, -0.11456882f, 
    -0.11697309f, -0.04634941f, -0.00304947f, -0.08097797f, 0.23067665f, -0.10957989f, 0.02272480f, 0.10667582f, 
    0.02182728f, -0.12388195f, -0.15746717f, -0.00053988f, -0.14997602f, 0.01869684f, -0.01576100f, 0.02342783f, 
    0.02416752f, 0.04358513f, 0.06922870f, 0.05593380f, -0.00017290f, 0.02656235f, -0.11400223f, -0.05807775f, 
    0.01476654f, 0.12437976f, -0.01534304f, -0.15429783f, -0.14435619f, 0.09334053f, 0.01569952f, 0.02911941f, 
    0.03645050f, 0.08250277f, 0.04770389f, 0.01196148f, 0.00431643f, 0.08388960f, -0.00499938f, -0.05782436f, 
    0.07785574f, 0.00637478f, -0.11071379f, 0.03183889f, 0.07166182f, 0.01743045f, -0.16477254f, 0.14374250f, 
    0.16855380f, -0.03794083f, 0.07467398f, 0.02562491f, 0.05153937f, -0.00122693f, 0.05642491f, 0.01335038f, 
    0.01557041f, -0.01652889f, 0.03637626f, -0.18309447f, -0.01683681f, 0.07937765f, -0.01955891f, -0.03903998f, 
    -0.17769992f, -0.06099211f, -0.12187777f, -0.11554638f, 0.00560657f, 0.04731701f, 0.01646544f, 0.19615635f, 
    -0.18972686f, 0.01189651f, 0.07084391f, -0.02869532f, 0.16488497f, -0.18528184f, -0.07324062f, -0.01706764f, 
    0.00492951f, -0.00992825f, -0.10131174f, -0.04842358f, -0.00856308f, -0.08484849f, 0.03983270f, 0.17018491f, 
    0.06305548f, -0.10423622f, -0.09820168f, -0.11125282f, -0.13210806f, -0.07113848f, -0.04244199f, 0.02657450f, 
    0.02229121f, 0.02689253f, -0.00070345f, 0.03715187f, 0.08720949f, -0.01727669f, 0.02161251f, 0.00161863f, 
    0.21131967f, -0.10193592f, 0.15249331f, 0.10287160f, 0.03640256f, -0.08994577f, -0.08468793f, -0.02033064f, 
    -0.07910993f, -0.03410781f, 0.09002117f, -0.05743947f, 0.00019826f, -0.02196962f, 0.05345878f, 0.01577394f, 
    0.03070019f, 0.03801378f, -0.04121277f, -0.07147209f, 0.43440419f, -0.17119659f, -0.25706637f, 0.09275599f, 
    -0.23105209f, 0.22200330f, -0.18995394f, 0.03456579f, 0.09645037f, -0.01138560f, 0.07081552f, -0.02373617f, 
    -0.08827395f, -0.04455635f, 0.08946726f, -0.03742954f, -0.07863837f, 0.08863173f, -0.38682070f, 0.06677415f, 
    0.00215484f, 0.10708511f, 0.03632301f, -0.12931310f, -0.09137602f, -0.04265246f, -0.00863115f, -0.09691998f, 
    0.02493882f, -0.01136782f, -0.02005780f, -0.18778929f, 0.15208264f, -0.01367127f, 0.10477304f, 0.04715464f, 
    -0.00689063f, -0.09962082f, -0.11040044f, 0.03682796f, 0.17811935f, 0.03917574f, 0.01029535f, -0.13260348f, 
    0.00227280f, 0.17268758f, -0.12031383f, 0.00585076f, 0.03798344f, 0.02091237f, -0.01287214f, 0.03344690f, 
    0.02956934f, -0.15891196f, -0.01228310f, 0.11566257f, -0.19461702f, -0.02887612f, -0.12254197f, -0.23584062f, 
    -0.05483143f, -0.12445182f, 0.03275862f, -0.07760772f, 0.01702858f, -0.01114293f, 0.01958355f, 0.02241960f, 
    -0.08208603f, 0.00257263f, -0.05608768f, -0.21484745f, 0.01933018f, -0.05776132f, -0.09769686f, 0.01621015f, 
    0.01172469f, -0.08775879f, -0.03434771f, -0.03750042f, 0.17617808f, -0.21206348f, 0.19995096f, -0.08457837f, 
    -0.07731701f, -0.03890948f, 0.01427405f, 0.11699409f, -0.23212814f, -0.20174466f, 0.04521915f, -0.05023084f, 
    -0.02635302f, -0.05516909f, -0.14889815f, -0.24867892f, -0.11676417f, -0.11449360f, -0.12098434f, -0.03361063f, 
    0.02707196f, -0.02146557f, 0.06895152f, 0.08038998f, 0.03012221f, -0.08141520f, -0.09198239f, -0.03429215f, 
    0.04247001f, 0.02337414f, 0.01238933f, -0.03067381f, -0.05124205f, -0.04254759f, 0.04173193f, 0.01731396f, 
    0.02387567f, 0.07897253f, -0.06738085f, -0.01292330f, 0.07860932f, 0.17387034f, 0.25850832f, 0.22526449f, 
    0.16500661f, -0.12280639f, -0.13934396f, 0.00163760f, 0.05110673f, 0.11950706f, 0.03805389f, 0.03172823f, 
    0.00804688f, 0.00356683f, 0.03637582f, -0.00360650f, -0.02396768f, -0.05398713f, 0.00952913f, -0.12622322f, 
    -0.03599691f, -0.03401986f, 0.19163850f, 0.06207857f, 0.04998009f, -0.11605101f, 0.06757913f, -0.12130436f, 
    0.11275835f, 0.03450352f, -0.00187063f, 0.03204341f, 0.02040576f, 0.05409721f, -0.01446689f, 0.05284478f, 
    0.07156011f, -0.07187481f, 0.00216251f, -0.05948524f, -0.04847558f, -0.02313559f, 0.10856328f, -0.06002676f, 
    0.00308908f, -0.09908246f, -0.01573968f, -0.01702324f, 0.07461628f, 0.06437401f, 0.04600639f, -0.07906677f, 
    -0.00527909f, -0.08682669f, 0.05824675f, 0.00420412f, -0.01362948f, 0.03323459f, -0.06737275f, -0.01005010f, 
    -0.06518298f, 0.03338854f, 0.09680167f, 0.20840856f, 0.09102291f, -0.14928722f, 0.08483665f, 0.02065250f, 
    0.00274645f, -0.00325519f, -0.03425382f, -0.03282307f, -0.03690672f, 0.02009486f, 0.04173433f, -0.06781970f, 
    -0.04904633f, -0.03097038f, 0.02246768f, -0.10375769f, 0.05880637f, -0.20616157f, -0.03054676f, 0.04632303f, 
    -0.10772821f, 0.00070583f, -0.09795386f, -0.02389742f, -0.10029557f, -0.03910743f, -0.09105811f, -0.03900628f, 
    -0.08662174f, -0.05213899f, 0.05361368f, -0.13157690f, -0.09905782f, 0.00170128f, -0.09303092f, -0.12379086f, 
    -0.03174596f, -0.18342206f, -0.05056632f, -0.04735953f, -0.17628160f, 0.02708513f, 0.01391867f, 0.01472428f, 
    0.00521215f, 0.06289817f, 0.07770311f, -0.02592992f, -0.09540991f, -0.01197626f, -0.03594854f, -0.01940340f, 
    0.01326692f, 0.02312242f, -0.01729613f, 0.06570446f, 0.03892033f, 0.05709986f, 0.05523380f, -0.04747706f, 
    -0.02302609f, 0.07993703f, 0.05706220f, 0.03234472f, 0.06990931f, 0.05929650f, 0.08257771f, 0.04766623f, 
    0.01160247f, 0.00390957f, 0.06903669f, 0.06355433f, -0.05117832f, -0.09460397f, -0.01280155f, 0.12519138f, 
    0.16548176f, -0.07658771f, 0.18508439f, -0.13339671f, 0.03485531f, 0.04807413f, -0.06175962f, -0.03251798f, 
    -0.11126832f, 0.03497491f, 0.08662104f, -0.07168712f, -0.02494020f, 0.02232092f, 0.06359342f, -0.02596978f, 
    -0.04086201f, -0.13454060f, -0.12729824f, -0.15656781f, -0.19212465f, -0.02727077f, 0.14802890f, -0.04630946f, 
    0.03653767f, -0.10668649f, 0.06598786f, -0.05910103f, -0.13138968f, -0.04236884f, 0.00124516f, -0.00801444f, 
    0.03425149f, 0.05395397f, 0.03452962f, -0.07013470f, 0.08471131f, -0.03285670f, -0.02464382f, 0.09015079f, 
    0.09535726f, -0.07042249f, 0.05046901f, -0.05431268f, -0.07341182f, -0.07175317f, -0.04910971f, -0.06753839f, 
    -0.04243569f, 0.03420185f, -0.01215074f, -0.03656286f, 0.06668888f, 0.07914049f, 0.03219796f, -0.00415155f, 
    0.06107144f, -0.00754896f, -0.08832058f, -0.03471612f, -0.06086257f, -0.31582531f, 0.00257389f, -0.22829291f, 
    -0.04115018f, -0.01068960f, 0.03073717f, 0.06391537f, 0.09398028f, -0.03291021f, -0.08003532f, -0.04222642f, 
    -0.04812515f, -0.08312091f, 0.07859509f, -0.13747893f, -0.10825175f, -0.01179208f, 0.02567560f, 0.04823095f, 
    0.20790546f, 0.29631716f, -0.19540228f, 0.20358066f, 0.23660538f, 0.01389819f, 0.11273214f, 0.06498432f, 
    0.15049039f, 0.17056540f, 0.02924850f, 0.01291460f, 0.01535425f, 0.01499563f, 0.01628804f, 0.13321097f, 
    0.14373890f, 0.11107313f, 0.13464820f, 0.17090622f, 0.07768092f, -0.29185545f, -0.04331766f, 0.14421231f, 
    -0.05163086f, 0.04744841f, -0.04490478f, -0.02636268f, -0.11600987f, -0.02934260f, -0.06501088f, -0.05516776f, 
    -0.04768815f, -0.00283325f, 0.00823816f, -0.03606242f, -0.08926507f, 0.04436090f, -0.16733061f, 0.04174377f, 
    0.01919852f, -0.06846583f, -0.04620416f, -0.06199353f, -0.07230547f, 0.05356480f, -0.00290892f, -0.08929732f, 
    0.00562388f, 0.01007219f, -0.01118413f, -0.11270450f, 0.04966566f, -0.00849767f, -0.04928683f, 0.08466106f, 
    -0.07535991f, -0.02854242f, -0.09991651f, 0.00413791f, 0.03672064f, 0.14137591f, 0.01943399f, 0.16502836f, 
    -0.05125717f, -0.03788127f, -0.02173870f, -0.13892183f, -0.09030047f, -0.01027041f, 0.04149494f, -0.01305293f, 
    0.18060318f, 0.01030667f, 0.01719855f, 0.01852910f, -0.05396422f, -0.03518872f, -0.17789185f, -0.11485307f, 
    -0.35785788f, -0.13968419f, -0.29634857f, -0.25346798f, -0.05005893f, 0.07455210f, -0.07111423f, 0.04523532f, 
    -0.12506893f, 0.18202697f, -0.04502931f, 0.11598855f, -0.08288790f, 0.07901108f, -0.06588218f, -0.04715630f, 
    -0.01926436f, 0.14935446f, 0.03093066f, 0.07144875f, -0.04499910f, -0.09770637f, -0.13357611f, -0.01629158f, 
    0.02760415f, -0.00902594f, 0.04302745f, -0.04375978f, -0.02609061f, 0.01872365f, 0.05906108f, -0.00854356f, 
    0.11344309f, 0.04224747f, 0.05066074f, -0.00034642f, 0.07674856f, 0.07573400f, 0.04265062f, -0.00097253f, 
    -0.04664694f, -0.02366414f, 0.13321064f, 0.19029635f, -0.19571292f, 0.01045302f, -0.02388719f, 0.15219527f, 
    -0.05811442f, -0.14630468f, 0.04199091f, -0.01036211f, -0.00277283f, 0.05314354f, 0.04202194f, -0.06425830f, 
    -0.06470073f, -0.11838735f, -0.13181019f, -0.37226275f, -0.01798761f, -0.02119966f, -0.05741982f, 0.10212836f, 
    0.09147169f, 0.07666332f, -0.05724949f, 0.07759729f, -0.05467014f, -0.02904430f, -0.07830919f, 0.01546325f, 
    -0.04257064f, -0.00331301f, -0.01319808f, 0.00954970f, 0.07749355f, 0.25917441f, -0.11388047f, -0.10097689f, 
    0.03732139f, 0.01912727f, 0.31123835f, 0.09316134f, -0.22686060f, 0.07542267f, 0.02112348f, 0.19145815f, 
    -0.04245576f, -0.03955647f, 0.02241944f, -0.00688363f, -0.00878420f, 0.05624991f, 0.02155668f, 0.00323120f, 
    -0.05940198f, 0.00412522f, 0.02455835f, -0.12911592f, -0.00428440f, -0.02070568f, 0.23770933f, -0.09507970f, 
    -0.17964835f, 0.17407277f, 0.12140037f, 0.16391528f, -0.03095247f, -0.15437387f, -0.00102064f, -0.05293462f, 
    -0.03114196f, 0.01255961f, 0.03156355f, 0.00647059f, 0.01084501f, 0.00702440f, 0.03273676f, 0.12741417f, 
    0.33579308f, -0.12016540f, 0.20343348f, 0.05718994f, -0.17678037f, -0.14298491f, 0.01751200f, -0.25750059f, 
    0.18497264f, 0.21468279f, 0.05248237f, 0.02404877f, 0.02379213f, 0.01688944f, -0.04704137f, -0.13075513f, 
    -0.04937752f, -0.01238143f, 0.04036103f, 0.02396639f, -0.08507981f, -0.00467141f, -0.18512224f, -0.11289660f, 
    0.10054318f, 0.05698400f, 0.00729728f, -0.13295832f, -0.03053282f, 0.05366353f, 0.15445930f, 0.12267751f, 
    -0.08654328f, 0.20638898f, 0.06557428f, -0.04263409f, 0.06001677f, 0.14879099f, 0.10347435f, -0.05125504f, 
    0.36464125f, 0.22496486f, 0.02486276f, -0.20605652f, 0.30609912f, 0.13606156f, -0.08612045f, 0.05453503f, 
    -0.20444295f, -0.07290161f, 0.03795170f, -0.09146045f, -0.31057054f, -0.04860082f, 0.02945115f, 0.02223928f, 
    0.05488440f, 0.14902169f, 0.07236025f, -0.06700220f, -0.03012654f, -0.17888556f, -0.16393442f, 0.13775253f, 
    0.01408734f, 0.09542552f, -0.15553625f, -0.06728986f, -0.00941281f, 0.04250911f, -0.08758905f, 0.05969654f, 
    0.03026426f, -0.00380949f, 0.07909057f, -0.04218709f, 0.03091206f, 0.02261657f, 0.00661750f, 0.03653641f, 
    -0.13907315f, -0.02477085f, -0.11120193f, -0.09140579f, -0.06094407f, 0.00816145f, -0.01453337f, -0.00206977f, 
    -0.02415884f, 0.09858467f, -0.02578088f, -0.11038076f, 0.05940276f, -0.06480643f, -0.08454430f, -0.04138985f, 
    0.01737200f, 0.02892231f, 0.03678530f, -0.01548409f, 0.06059178f, -0.17877223f, -0.27409235f, 0.15525036f, 
    0.07038513f, 0.10140090f, 0.09153758f, 0.07339414f, -0.08846097f, -0.04989913f, -0.00800746f, -0.00248463f, 
    0.00706645f, -0.01772835f, -0.03411167f, 0.03239614f, -0.01297138f, 0.23182750f, -0.05608600f, -0.09924913f, 
    0.12050607f, -0.22029501f, 0.39193344f, 0.06272653f, -0.57608896f, 0.06436499f, 0.06527041f, 0.06650026f, 
    -0.11892417f, -0.13189414f, 0.04510542f, -0.04064823f, -0.02553521f, 0.04061816f, 0.07604259f, -0.04446149f, 
    0.03125009f, 0.06311682f, 0.01724613f, 0.00478215f, -0.07078584f, -0.09203862f, 0.02191464f, 0.03262573f, 
    0.01635967f, 0.08072029f, 0.04652311f, 0.02147511f, 0.05302371f, 0.10171828f, -0.05835502f, -0.07047512f, 
    0.02054415f, -0.07991023f, -0.00321835f, 0.15375270f, -0.06893177f, 0.02528972f, -0.07123166f, 0.02958102f, 
    0.37394834f, -0.32245812f, 0.01245071f, -0.06603622f, -0.00106658f, 0.14685833f, -0.21899343f, -0.04874932f, 
    -0.01258863f, 0.04818243f, 0.10059054f, 0.03360675f, 0.06058070f, -0.00114163f, 0.08082925f, 0.04011229f, 
    0.04543120f, -0.05230290f, -0.08987231f, 0.22983406f, 0.03252472f, -0.25624850f, 0.06441324f, 0.12027089f, 
    0.08501181f, 0.04325840f, -0.21708660f, -0.35859281f, 0.00850449f, 0.10458611f, -0.03807916f, 0.00129843f, 
    0.05445828f, 0.22865665f, 0.05257793f, -0.02215498f, 0.19024779f, -0.01990084f, -0.02505106f, 0.42671674f, 
    -0.38031796f, 0.14707421f, -0.35861218f, -0.06440219f, -0.12452002f, -0.08899695f, -0.04191772f, 0.01869435f, 
    -0.13039032f, -0.15167795f, -0.06345214f, -0.04363486f, -0.11259186f, 0.04212898f, 0.05871982f, -0.22295833f, 
    -0.09318426f, 0.01302244f, -0.07988642f, -0.07226577f, 0.02000549f, -0.08545596f, 0.25968724f, -0.13227130f, 
    -0.18335478f, 0.26370278f, 0.01643454f, -0.02145171f, -0.03689037f, -0.02510887f, 0.09490397f, -0.00376926f, 
    0.05889881f, 0.06675097f, 0.06516979f, 0.03064384f, 0.06789935f, -0.08718628f, -0.00864228f, -0.02514653f, 
    -0.03781762f, -0.07320826f, -0.04468194f, 0.04275209f, 0.08931735f, -0.19373603f, 0.03806536f, 0.12896582f, 
    0.05522560f, -0.11682382f, -0.00164334f, -0.06752322f, -0.00331489f, -0.05891031f, 0.02087502f, 0.00151271f, 
    0.06048064f, 0.01756591f, -0.14019276f, 0.13772316f, -0.12569582f, -0.05107734f, -0.16484529f, -0.05084855f, 
    0.18064971f, 0.13426763f, 0.03222822f, -0.07609753f, -0.03129458f, -0.02802157f, 0.16336110f, 0.08995157f, 
    -0.01945256f, 0.02128283f, -0.05228807f, -0.03143259f, -0.10198868f, 0.07156508f, -0.02859212f, -0.00689972f, 
    0.43252397f, -0.15190977f, 0.10812636f, 0.17179634f, -0.22036082f, -0.00158821f, 0.01948775f, 0.06567086f, 
    -0.12175871f, 0.03190244f, 0.01818373f, 0.05704197f, 0.06022192f, 0.03423156f, -0.03151994f, -0.09603444f, 
    -0.29632241f, -0.00577134f, 0.06790306f, -0.04977580f, -0.13660693f, 0.25864255f, -0.04399299f, 0.15551333f, 
    -0.01580781f, -0.00751437f, -0.06702445f, -0.05566782f, -0.03588671f, -0.01793417f, -0.03023302f, -0.02666655f, 
    -0.10491697f, 0.03677423f, 0.03609280f, -0.02924542f, 0.03767928f, 0.04176553f, -0.15967599f, -0.13403270f, 
    -0.20317763f, 0.05834973f, -0.22296059f, 0.07005978f, -0.10054944f, 0.12604354f, -0.23806833f, 0.03153672f, 
    -0.01133506f, 0.03640335f, -0.03875981f, 0.06174544f, -0.02363890f, -0.03182827f, 0.00510335f, 0.09904633f, 
    0.02376934f, 0.25249356f, -0.11928205f, -0.01325682f, -0.21921153f, -0.21404448f, -0.14381112f, 0.17331867f, 
    0.01095434f, 0.07972990f, 0.01028853f, 0.03614972f, -0.01684199f, 0.01224379f, -0.01149554f, -0.02488387f, 
    0.00137434f, -0.00475028f, -0.02409537f, -0.00372948f, -0.08044340f, 0.16198321f, -0.07174655f, -0.03794962f, 
    -0.11955666f, 0.11247267f, 0.33209965f, 0.07952164f, -0.18993954f, -0.10736302f, -0.07412845f, -0.01639465f, 
    0.12737818f, -0.08875802f, -0.03276382f, -0.01939397f, 0.03753248f, 0.02988448f, -0.00568657f, 0.06436946f, 
    0.02290670f, -0.06896931f, -0.26498669f, -0.20171697f, -0.14544071f, -0.01377857f, -0.08277138f, -0.07727380f, 
    0.08390839f, 0.03023887f, 0.02788052f, -0.05098505f, -0.11975814f, -0.01874446f, 0.18085299f, -0.08791333f, 
    0.10004406f, -0.00638428f, 0.05867805f, -0.03614736f, -0.00772692f, 0.06190126f, 0.05175680f, -0.01457710f, 
    -0.01805207f, -0.07093492f, -0.13871221f, -0.03557997f, 0.01632241f, 0.05560711f, -0.00370924f, -0.11068313f, 
    -0.05975445f, 0.00698040f, 0.06711353f, -0.08891004f, 0.05440249f, 0.08064006f, -0.12643160f, -0.00847686f, 
    0.03877518f, 0.09164950f, -0.03004752f, 0.06903445f, 0.12659390f, -0.19854023f, 0.04427237f, 0.16171879f, 
    -0.05253248f, -0.03573726f, 0.07399486f, -0.10174879f, -0.03148926f, 0.10403781f, 0.10127497f, 0.00568214f, 
    0.05303213f, -0.06965287f, 0.06517286f, 0.12856936f, 0.01154276f, -0.01546817f, 0.02537213f, 0.07897905f, 
    0.06433474f, 0.13202621f, 0.23148577f, 0.09587839f, -0.08384625f, 0.08837421f, -0.14658162f, 0.22019614f, 
    0.03601136f, -0.09086078f, -0.01754369f, -0.05477577f, 0.04538041f, 0.08809640f, 0.06886283f, 0.07820639f, 
    -0.03237057f, 0.04824348f, -0.07293338f, 0.07550642f, -0.19413011f, -0.22879250f, -0.06005654f, 0.12811738f, 
    0.02394343f, 0.06156329f, -0.03453724f, -0.04357927f, 0.01786683f, -0.01185391f, 0.03925611f, -0.02032067f, 
    0.01665510f, 0.01163463f, 0.05815439f, -0.24694680f, -0.18971014f, 0.11275638f, 0.03349034f, -0.16878247f, 
    -0.14434940f, -0.18075626f, -0.26713753f, -0.18721889f, 0.23252940f, 0.02100104f, 0.02007810f, -0.07420561f, 
    -0.07276121f, -0.00065134f, 0.04522990f, 0.07664418f, -0.06658518f, -0.05672564f, 0.11305657f, -0.17223725f, 
    -0.09774750f, 0.05941462f, 0.06983147f, 0.08390801f, -0.07676073f, -0.20988473f, -0.14719750f, 0.12168531f, 
    0.17737348f, 0.00855347f, -0.05526799f, -0.04694273f, -0.03503003f, -0.00933959f, 0.04158175f, -0.01531551f, 
    0.01739319f, 0.00625900f, 0.05110317f, -0.12911411f, -0.10869531f, -0.00994906f, -0.03965809f, -0.10353274f, 
    0.06200443f, -0.17221788f, 0.10967658f, 0.00140220f, -0.04313738f, -0.12958945f, 0.03922499f, 0.02211595f, 
    -0.09212648f, -0.09800312f, 0.04434992f, -0.00796818f, -0.05187184f, -0.08939839f, -0.01337352f, -0.00216128f, 
    0.09419505f, 0.00412461f, 0.04291577f, 0.18389006f, -0.32470453f, 0.44528717f, -0.36800805f, 0.03161882f, 
    -0.03320765f, -0.00174741f, -0.02934905f, -0.00416033f, -0.02562713f, 0.04090890f, 0.11006352f, 0.00843104f, 
    0.04234632f, 0.03051235f, -0.03440845f, -0.05345928f, 0.02374251f, 0.11653708f, -0.06000388f, -0.07654066f, 
    0.09930949f, -0.14207979f, 0.18723784f, -0.02516812f, 0.02887877f, -0.05607934f, -0.02614080f, -0.12400965f, 
    -0.07656395f, 0.08176382f, 0.16238676f, 0.00494689f, -0.01809471f, -0.17572966f, 0.15939076f, 0.03506992f, 
    -0.19322661f, -0.07733994f, 0.20663005f, 0.09374379f, 0.00779126f, -0.04926930f, -0.14043535f, 0.03171780f, 
    -0.13536532f, -0.12827478f, 0.00251913f, 0.03487811f, -0.15976557f, -0.10770559f, 0.00015968f, -0.02215027f, 
    -0.05146990f, -0.01856395f, 0.13411444f, -0.19296934f, -0.03106798f, 0.04023907f, -0.10507840f, -0.12014519f, 
    0.07627609f, 0.06318824f, 0.04501951f, 0.06720226f, -0.18699394f, 0.20455623f, 0.07365023f, -0.05658707f, 
    0.01302052f, 0.23041785f, -0.03699370f, -0.01328912f, -0.05360634f, -0.00409790f, -0.10815768f, 0.10329270f, 
    0.02896279f, 0.00925733f, 0.00435585f, 0.15079454f, -0.54576933f, -0.15312606f, -0.00955283f, -0.28582150f, 
    -0.29312068f, -0.00661237f, 0.02007592f, -0.12484565f, -0.00098606f, 0.18510312f, 0.10119622f, 0.16990575f, 
    -0.06720472f, -0.07817737f, 0.01257356f, -0.03954142f, -0.02566525f, -0.04100090f, 0.02875212f, 0.16279443f, 
    -0.13788638f, 0.03149761f, -0.27945554f, -0.12458216f, 0.22114673f, -0.02478400f, -0.03054538f, -0.00687743f, 
    -0.05901817f, -0.03222556f, 0.15340586f, -0.07092277f, -0.09490222f, -0.02193559f, 0.03472487f, -0.10253363f, 
    -0.06383897f, 0.21723782f, 0.01767735f, -0.03908913f, -0.02813299f, -0.29753840f, -0.05281037f, 0.19227679f, 
    0.09289607f, 0.08414114f, 0.09451877f, 0.02214862f, 0.03535854f, 0.11167794f, -0.03168561f, -0.00319238f, 
    0.03086478f, -0.03187662f, 0.01433485f, -0.08593450f, -0.16969873f, 0.15831031f, -0.12912217f, 0.02477505f, 
    0.46801430f, 0.12878023f, -0.19830722f, -0.21584235f, 0.18356195f, 0.10761269f, -0.07124667f, 0.16296043f, 
    -0.14916568f, 0.02762165f, -0.04443888f, -0.02488894f, -0.06148318f, -0.09172777f, -0.11431415f, 0.10008426f, 
    0.09834455f, -0.02839142f, -0.06110577f, -0.09248609f, -0.37432340f, 0.02219254f, 0.08918051f, -0.10593979f, 
    -0.05762800f, 0.01957086f, 0.09247819f, 0.07222546f, -0.13727416f, 0.10029092f, -0.00748443f, -0.05731322f, 
    -0.01589734f, 0.09164029f, -0.02505744f, -0.04136696f, -0.06086883f, -0.06139204f, 0.04096997f, -0.06447159f, 
    -0.27167848f, -0.18681020f, -0.18535669f, -0.11812333f, -0.12992606f, 0.07865073f, 0.02533972f, -0.05366530f, 
    0.06268464f, 0.03869664f, 0.01055572f, 0.02864616f, -0.09222566f, 0.00240463f, -0.02860832f, -0.03824563f, 
    0.00012970f, 0.06555340f, 0.03619516f, 0.09228873f, -0.85019952f, 1.19452286f, -0.15971538f, 0.41724774f, 
    -0.01853525f, -0.10159991f, -0.10992813f, 0.05828157f, 0.15663442f, -0.10086988f, -0.06096158f, 0.02239526f, 
    -0.08454525f, 0.09969370f, -0.13907336f, 0.05564497f, -0.11014127f, 0.25683868f, 0.06550565f, -0.27793124f, 
    0.25149623f, 0.04849175f, -0.23072295f, -0.09016947f, -0.06701663f, -0.01005024f, 0.01157972f, 0.05992153f, 
    -0.19399124f, 0.13055268f, 0.11407392f, -0.08088673f, -0.20833731f, -0.20901242f, 0.02134060f, 0.00212287f, 
    -0.15870504f, 0.04056867f, -0.03145799f, 0.07993058f, 0.12840016f, 0.03908913f, 0.00325386f, 0.08080932f, 
    0.08979774f, -0.15021680f, 0.01895907f, 0.04547177f, -0.06300043f, -0.13166471f, -0.02262932f, -0.25813469f, 
    0.09269933f, -0.01174024f, -0.07352763f, 0.24988978f, -0.11670371f, -0.05158393f, -0.06258310f, 0.15118173f, 
    0.19398338f, -0.01240133f, -0.22413568f, -0.14148650f, 0.08672544f, 0.01362889f, 0.02771407f, -0.00293430f, 
    -0.04563732f, 0.06259520f, -0.02252916f, -0.00702571f, 0.02266594f, -0.04593362f, -0.01404108f, 0.14436616f, 
    0.11195552f, 0.01213225f, -0.02830290f, 0.16942437f, -0.04076957f, 0.05719555f, 0.12126652f, -0.14193477f, 
    -0.05492061f, -0.02362278f, 0.00897202f, -0.14602283f, -0.08856558f, 0.14335170f, 0.04488390f, -0.07497507f, 
    -0.06618941f, 0.10814366f, -0.06478292f, 0.16192895f, -0.11700881f, -0.09250647f, 0.13098571f, 0.05883903f, 
    -0.48125550f, 0.26424158f, -0.32801184f, -0.00718627f, -0.09500030f, 0.01984295f, -0.03235776f, 0.05227778f, 
    0.06681644f, 0.10708056f, 0.11023225f, -0.00068494f, -0.10979221f, 0.06023298f, -0.08496947f, -0.04636908f, 
    -0.01489977f, 0.12373038f, -0.04863444f, -0.00278874f, 0.05126850f, -0.02631112f, 0.21887210f, 0.01189775f, 
    -0.12176443f, 0.05038382f, 0.10326309f, 0.15263918f, -0.09740500f, -0.03246585f, 0.05260071f, 0.00213595f, 
    -0.04484776f, 0.01078272f, -0.00053585f, 0.03714629f, 0.06271519f, 0.02033290f, 0.04608454f, 0.14099714f, 
    -0.20329016f, 0.02782782f, 0.17617230f, -0.04330458f, -0.01934258f, 0.13950898f, 0.07588308f, 0.05838263f, 
    0.04884086f, 0.01443486f, 0.08210885f, 0.01562935f, 0.02483639f, 0.06272968f, 0.00544377f, 0.07492682f, 
    0.03983967f, -0.07280760f, -0.07066077f, -0.05219764f, -0.26387876f, 0.09389337f, -0.27792212f, -0.10156541f, 
    -0.00667949f, 0.07238176f, 0.00415226f, 0.00432057f, -0.09281612f, 0.01769965f, 0.01589888f, 0.01169272f, 
    0.03205243f, 0.07621028f, -0.05875948f, 0.01403236f, -0.00428992f, 0.15577646f, -0.07930464f, 0.04672585f, 
    0.11121009f, -0.08264044f, 0.30010727f, 0.08229771f, -0.34977353f, 0.09864648f, 0.05404800f, -0.08234125f, 
    0.03551897f, 0.03184111f, 0.08195327f, 0.07894740f, -0.04473218f, 0.04950889f, 0.02520999f, -0.05228291f, 
    0.02345992f, -0.04354682f, -0.03519001f, 0.17816795f, -0.28067076f, -0.41592583f, -0.14317030f, 0.12776864f, 
    -0.11124283f, 0.10936467f, -0.12471592f, -0.19699918f, 0.10624947f, -0.07188859f, -0.01555035f, -0.06589793f, 
    -0.04559273f, 0.04783460f, 0.05189509f, 0.15505752f, -0.00512610f, 0.12540273f, 0.05523976f, 0.24192752f, 
    -0.08416097f, -0.14636312f, 0.15242256f, -0.07871509f, 0.09574559f, 0.05462313f, -0.03498386f, -0.11578526f, 
    -0.05942732f, -0.00305208f, -0.06748242f, -0.01426687f, 0.06967519f, -0.08270449f, 0.06432433f, -0.12528391f, 
    -0.10912334f, -0.01626290f, 0.16885667f, -0.01065400f, -0.14117382f, -0.04031484f, -0.03225353f, 0.05110861f, 
    0.09576841f, 0.03574262f, 0.02449054f, -0.02896262f, 0.00872035f, 0.03406930f, 0.01144790f, -0.04368374f, 
    -0.00990634f, 0.02831984f, 0.02856221f, -0.00271209f, 0.05743786f, -0.01186487f, 0.02407812f, 0.01182238f, 
    0.01224109f, -0.04421843f, 0.03932149f, -0.13188878f, 0.01028136f, -0.08812972f, 0.07951260f, -0.08361475f, 
    -0.00512041f, 0.14352106f, -0.08186880f, -0.07765907f, -0.10111428f, 0.01786702f, -0.04915906f, 0.06956694f, 
    0.05894642f, -0.04041066f, 0.06415320f, 0.24255405f, -0.02734023f, 0.12465922f, -0.05492982f, -0.10596311f, 
    0.03493614f, 0.06412321f, -0.12937169f, -0.07846038f, -0.00564032f, 0.04718667f, 0.00211512f, -0.01672579f, 
    0.01003406f, -0.01913105f, -0.03648698f, 0.02086028f, -0.11776484f, -0.12639296f, -0.08717047f, -0.17260723f, 
    -0.29442462f, 0.13220888f, -0.37928084f, -0.24215500f, -0.05864831f, -0.01836506f, -0.00504427f, 0.02550439f, 
    -0.08255550f, 0.21861981f, 0.01175421f, 0.07641139f, -0.09251862f, 0.10740462f, -0.00495271f, -0.05314258f, 
    -0.04310623f, 0.08361219f, 0.00983298f, 0.15459092f, 0.19254778f, -0.29912049f, 0.10645190f, -0.14038233f, 
    0.00012265f, 0.12804651f, -0.04083735f, -0.05885234f, -0.05184157f, 0.07493647f, 0.04144992f, 0.09589274f, 
    0.17143671f, 0.01118290f, 0.09958928f, 0.13476008f, -0.04465251f, -0.05507142f, 0.10710905f, 0.11032736f, 
    0.29966605f, 0.06816378f, -0.07918255f, 0.09881251f, 0.01359198f, 0.16434947f, 0.09789155f, -0.00373973f, 
    0.04391333f, 0.01986192f, 0.05377705f, 0.04936036f, -0.01445331f, -0.02348912f, 0.01928542f, -0.18765368f, 
    -0.10844266f, -0.00028386f, -0.09433197f, -0.08198214f, -0.12949985f, -0.14680059f, 0.05748635f, -0.00436939f, 
    -0.19639565f, 0.13277602f, -0.15000890f, -0.03470988f, 0.06071781f, -0.07704235f, 0.12122115f, -0.04607690f, 
    -0.00394212f, 0.07079805f, 0.00186259f, 0.04410264f, 0.09041573f, 0.11612211f, 0.07439876f, 0.00881617f, 
    -0.26443747f, 0.12124267f, -0.15847735f, 0.18147928f, 0.00225028f, 0.02860283f, -0.11565566f, -0.07009520f, 
    -0.02169713f, 0.09297232f, -0.01569833f, -0.00753642f, -0.06307860f, -0.01632560f, -0.00272825f, 0.05211435f, 
    0.06869247f, 0.12787798f, -0.09049522f, 0.00769993f, -0.05662335f, 0.04239896f, 0.05077531f, 0.21231760f, 
    -0.14127386f, -0.06130413f, -0.15826732f, -0.00768992f, -0.02381260f, 0.09521952f, 0.05148449f, 0.00143440f, 
    -0.10528561f, -0.05001553f, 0.03467649f, 0.01474031f, 0.08267925f, 0.05831957f, 0.01172420f, 0.12304053f, 
    -0.77756977f, 0.82514769f, 0.07226453f, -0.09500054f, 0.34071586f, -0.15685442f, 0.09121781f, -0.14347884f, 
    0.09419732f, 0.04371578f, 0.21183154f, 0.05667518f, 0.09733609f, 0.00227195f, 0.01488122f, 0.05264963f, 
    -0.02950715f, -0.03442023f, 0.06320116f, -0.01163900f, -0.00224367f, 0.00098009f, -0.00325974f, -0.08069390f, 
    -0.04512855f, -0.00006404f, 0.02531869f, -0.00709691f, 0.00522691f, 0.04269363f, -0.08371819f, -0.09948629f, 
    -0.08242933f, -0.03946237f, -0.02586351f, 0.03507816f, -0.01205380f, -0.04784215f, -0.08395013f, -0.02283231f, 
    -0.26351988f, -0.23983011f, -0.49005044f, -0.15026966f, 0.03263318f, -0.12599546f, -0.04420187f, -0.00171172f, 
    -0.21289387f, -0.06336665f, -0.01991777f, -0.01812471f, 0.02961360f, -0.13607383f, -0.10311640f, -0.04094247f, 
    -0.02005884f, -0.05216224f, 0.18399803f, -0.01760813f, 0.15576719f, -0.08388144f, -0.14484638f, 0.03300409f, 
    0.10187624f, -0.03856197f, 0.04432803f, 0.07484394f, 0.01101295f, -0.02153092f, 0.03794189f, -0.01371400f, 
    -0.10178944f, 0.00190950f, 0.04985756f, -0.04540949f, -0.01442332f, 0.08713260f, -0.00598660f, -0.03292201f, 
    -0.35132954f, -0.41631231f, -0.18780252f, -0.02419033f, 0.13628137f, -0.07534648f, 0.03771138f, -0.05939623f, 
    -0.15248874f, -0.12832555f, -0.02277310f, -0.03504349f, 0.00980713f, -0.01455946f, -0.04098347f, -0.01617891f, 
    0.02793934f, 0.01569928f, 0.15023151f, 0.05743729f, -0.54257524f, -0.49315742f, -0.13067994f, -0.14977187f, 
    -0.26001495f, -0.25140372f, -0.11384766f, -0.10362434f, -0.10595288f, -0.25762063f, -0.00944639f, 0.00530100f, 
    -0.00327834f, -0.02396650f, 0.02005171f, 0.00752995f, 0.00768543f, 0.09436648f, 0.06786243f, -0.13775350f, 
    -0.10182186f, -0.20115489f, -0.63392556f, -0.27950200f, -0.16763709f, -0.12544285f, 0.07467592f, 0.03784052f, 
    0.08363590f, -0.09838313f, 0.08398303f, 0.01264093f, 0.02105852f, -0.08081675f, 0.03653192f, 0.02264420f, 
    0.04437852f, 0.00202350f, 0.14553775f, 0.02923343f, 0.01805497f, 0.03719268f, 0.04837865f, 0.01115202f, 
    -0.07073583f, 0.03964258f, -0.00771517f, 0.01554818f, -0.00330881f, 0.04389250f, 0.03277931f, 0.05043615f, 
    0.05003440f, 0.02270115f, -0.04240773f, 0.06256371f, 0.07147186f, -0.07623889f, -0.08051715f, 0.01793295f, 
    0.14590310f, 0.03178167f, 0.05780565f, -0.02848228f, -0.06501994f, -0.02549365f, -0.08106483f, 0.06929003f, 
    0.14808264f, -0.11347070f, 0.05890758f, 0.04074101f, 0.01789036f, -0.13042390f, 0.04811088f, -0.00412413f, 
    -0.11056771f, 0.05147398f, -0.12646618f, -0.12050000f, 0.12091277f, 0.08910594f, -0.08619368f, -0.00135840f, 
    0.00562269f, -0.00983670f, -0.01663878f, 0.02955692f, 0.03580198f, 0.12558456f, -0.09238525f, 0.05843381f, 
    0.00638981f, -0.00189311f, -0.01800380f, -0.07060577f, -0.00022105f, -0.15891579f, 0.03056097f, 0.01261763f, 
    -0.19008851f, 0.27573338f, 0.16170534f, 0.04101065f, 0.05136047f, -0.06394909f, -0.00094194f, -0.07360350f, 
    -0.05970379f, 0.06361768f, -0.08519182f, -0.00105243f, 0.08647210f, 0.03175272f, 0.03810149f, 0.04387974f, 
    0.01214033f, -0.04959272f, 0.00358263f, -0.04357069f, 0.16205512f, -0.28709257f, -0.15887307f, 0.00154450f, 
    0.07205711f, -0.00023932f, 0.05759848f, 0.18813094f, -0.01864886f, -0.08464708f, -0.00782045f, -0.03758873f, 
    -0.08674697f, -0.04555087f, -0.00478395f, -0.11330659f, -0.11569782f, 0.04782905f, 0.04204574f, 0.00806608f, 
    -0.69688451f, -0.91972464f, -0.67473280f, -0.29273304f, 0.34931624f, 0.00577270f, 0.10575630f, -0.16784650f, 
    -0.20654152f, -0.40588614f, -0.01930237f, 0.00194869f, -0.04149745f, -0.00314531f, 0.06299716f, -0.01785497f, 
    0.05787324f, 0.03980855f, 0.25542724f, -0.00037415f, 0.13322847f, -0.02824223f, -0.10483028f, -0.09651721f, 
    0.15537667f, -0.03943099f, 0.01325304f, 0.02800514f, 0.08353231f, 0.01587000f, -0.03052210f, -0.02424802f, 
    -0.16356885f, -0.04234603f, 0.00387344f, -0.10619563f, -0.19645774f, -0.23609847f, 0.03706186f, 0.01975240f, 
    -0.07612283f, 0.32791483f, -0.11310861f, -0.03990921f, 0.02681114f, -0.04631018f, -0.04110352f, -0.03756854f, 
    0.07863194f, 0.21052361f, 0.14574337f, 0.02784573f, -0.02452055f, 0.03096895f, -0.00991427f, 0.04461825f, 
    0.04530839f, -0.05979610f, -0.00511084f, -0.09048934f, 0.01997197f, -0.13017032f, -0.18499403f, 0.02006199f, 
    0.27517855f, -0.18857081f, 0.02878844f, 0.05141040f, -0.08168229f, 0.19630551f, 0.08874267f, 0.10846999f, 
    -0.14525636f, 0.07487947f, 0.03396766f, 0.00176193f, 0.10799521f, -0.08878513f, 0.00070450f, -0.09107607f, 
    -0.04389581f, -0.08416569f, 0.04908461f, -0.03540995f, 0.34991646f, -0.13071676f, -0.13918373f, -0.04495086f, 
    0.04950273f, 0.21074460f, -0.05405546f, 0.06106700f, 0.10315643f, 0.03000548f, -0.08459406f, 0.04499103f, 
    0.05376802f, -0.00631016f, 0.15147051f, 0.03211405f, -0.57268292f, -0.41315624f, -0.61854202f, -0.10592031f, 
    -0.16732074f, -0.04081506f, -0.09804694f, -0.15073459f, -0.11283357f, -0.27392277f, 0.00318681f, -0.01264912f, 
    0.00223538f, -0.01074629f, -0.00173536f, -0.01302014f, -0.02218502f, 0.09120928f, 0.11915632f, 0.10540005f, 
    0.17345679f, -0.09476489f, -0.23171179f, -0.02967004f, 0.04699149f, -0.06205541f, 0.05786035f, 0.12470866f, 
    0.06312932f, -0.10970844f, 0.00189008f, -0.01788743f, -0.12908027f, -0.03203125f, 0.02266730f, -0.03658516f, 
    -0.04505407f, 0.12981032f, -0.02679530f, -0.05755814f, 0.03748766f, -0.01147072f, -0.01543897f, -0.13677081f, 
    -0.12598211f, 0.04014266f, 0.01704083f, -0.00448997f, -0.05424099f, -0.00180944f, -0.04416773f, -0.08504658f, 
    0.00244223f, -0.10438120f, -0.01382861f, 0.01023430f, -0.01980678f, 0.02924060f, -0.02193286f, 0.03321918f, 
    -0.24301176f, 0.21863991f, -0.33585909f, -0.01794885f, -0.02878579f, 0.11625849f, 0.12336665f, 0.07787407f, 
    -0.09524854f, 0.02940821f, 0.01273430f, 0.00827447f, 0.05650573f, -0.01187689f, 0.02679307f, -0.03523137f, 
    0.03551354f, -0.01714005f, 0.20549372f, 0.06504247f, 0.04423622f, 0.08186037f, -0.06511634f, 0.11983375f, 
    -0.00814253f, 0.03718355f, -0.01345646f, -0.05242102f, -0.02010900f, 0.07716794f, -0.02934486f, 0.00121809f, 
    0.11799183f, 0.00255225f, -0.03918003f, -0.05901513f, 0.03196792f, -0.10460962f, 0.01221890f, 0.02701061f, 
    0.24739578f, -0.30065987f, -0.31615403f, -0.20169900f, 0.11927713f, -0.00957101f, 0.10638560f, 0.16775255f, 
    0.06406710f, 0.00467362f, -0.00359597f, 0.00618161f, -0.05460254f, -0.04895751f, 0.03723714f, -0.02965207f, 
    0.05638743f, -0.02152730f, 0.12172300f, 0.04124079f, 0.14043239f, -0.21722755f, -0.13291757f, -0.10627317f, 
    0.05576240f, -0.00614728f, 0.09415869f, 0.10051578f, -0.04788472f, -0.01068300f, -0.04024260f, -0.03214381f, 
    -0.08527735f, 0.00258305f, -0.01126873f, -0.10630421f, -0.03870194f, -0.14196841f, 0.04053464f, 0.02129929f, 
    0.05236755f, -0.18484934f, -0.22672084f, 0.04189203f, 0.08485457f, -0.17555010f, 0.03419402f, -0.05459597f, 
    -0.00025087f, -0.08847435f, 0.00553722f, -0.01640302f, 0.01294245f, 0.09467783f, 0.03767801f, -0.01825345f, 
    0.09050304f, 0.09744059f, 0.16981664f, 0.10180289f, 0.04692008f, -0.00213483f, 0.00095539f, -0.04416876f, 
    -0.06233744f, 0.02698828f, -0.00002222f, 0.02102397f, -0.06124109f, 0.03137825f, -0.04101992f, -0.14654367f, 
    0.02000710f, -0.01651873f, 0.03754095f, -0.00932801f, -0.03118464f, 0.04426950f, -0.08853474f, -0.03761156f, 
    -0.10478430f, 0.02489356f, 0.09982189f, -0.05584181f, 0.09931434f, 0.00555552f, 0.01956239f, -0.01171947f, 
    -0.02155773f, 0.04379680f, -0.03411086f, 0.03318787f, -0.04168616f, 0.09052284f, -0.00982255f, 0.01343832f, 
    0.00910888f, -0.01722820f, -0.05806869f, -0.00561930f, -0.04535553f, 0.00404017f, -0.01967595f, 0.06945413f, 
    0.07991794f, -0.06336557f, 0.05290832f, -0.05357589f, 0.03025480f, 0.04805230f, 0.06619300f, -0.00237926f, 
    0.02034774f, 0.09354386f, 0.04666856f, 0.02770495f, 0.02321276f, -0.05031962f, 0.05134737f, -0.05394043f, 
    -0.54890364f, -0.60773695f, -0.38993621f, 0.01167316f, 0.33459124f, -0.02517015f, -0.09319649f, 0.05492463f, 
    -0.07460798f, -0.21831504f, 0.02681913f, -0.01267848f, 0.03023514f, -0.00961525f, 0.07849254f, 0.00178708f, 
    0.01476907f, 0.03363432f, 0.13692093f, 0.04418501f, -0.08821983f, 0.01605375f, -0.00315202f, -0.25819904f, 
    -0.07298628f, -0.03022373f, 0.03174941f, 0.06678481f, -0.05793520f, -0.02065030f, -0.02985359f, -0.01935031f, 
    -0.01105926f, -0.00820942f, -0.01239121f, -0.04308872f, 0.10278580f, -0.17483549f, 0.00901446f, 0.10428137f, 
    -0.23100975f, 0.10706939f, -0.01004559f, -0.25044826f, 0.31938449f, -0.05369208f, -0.03225135f, -0.03525355f, 
    0.00752355f, -0.01129985f, 0.08178001f, 0.07180744f, 0.05857926f, 0.02887699f, -0.06494865f, 0.06166082f, 
    0.09825563f, 0.02075808f, 0.11715675f, 0.01347550f, -0.05468437f, 0.04746941f, -0.02127220f, -0.13151594f, 
    0.03523776f, 0.00907616f, 0.02700853f, 0.00809345f, -0.00256766f, 0.04797721f, -0.04098267f, -0.02408577f, 
    -0.00307729f, -0.02328639f, -0.02788488f, -0.02797342f, 0.06566548f, -0.16223890f, 0.00041284f, 0.06896154f, 
    0.17661127f, -0.12817478f, -0.11863670f, 0.05332490f, 0.14658485f, 0.02349188f, 0.13226241f, 0.06372301f, 
    0.13972783f, -0.05852676f, 0.06281469f, -0.02188706f, -0.09109647f, -0.03544835f, 0.09705682f, 0.01893115f, 
    0.01588169f, 0.15541130f, -0.08368610f, -0.04741391f, -0.26905605f, -0.00748134f, 0.29326302f, 0.11755180f, 
    0.15710600f, -0.02169008f, -0.04714296f, 0.00295068f, -0.03491555f, 0.09810155f, -0.02947229f, 0.03156313f, 
    0.04724666f, -0.00680130f, 0.11753667f, -0.01441505f, -0.00868926f, -0.01362045f, -0.01423998f, -0.04809579f, 
    -0.09390462f, 0.11943832f, 0.02833284f, 0.05976434f, 0.11681767f, -0.02408067f, 0.07016335f, 0.08730426f, 
    0.16467343f, 0.02215131f, 0.06566592f, -0.01959168f, -0.03311036f, 0.01243506f, 0.14573377f, 0.01192640f, 
    -0.04073523f, 0.00628711f, -0.06768027f, -0.03223752f, -0.05088025f, -0.00780183f, -0.01166619f, -0.03342304f, 
    0.24333830f, -0.17066254f, -0.10042671f, -0.01542038f, -0.03253396f, 0.08811242f, 0.05486987f, 0.02633748f, 
    0.09160968f, -0.04058344f, -0.08030295f, -0.01994396f, 0.05200396f, -0.03368205f, 0.13654345f, -0.05323690f, 
    -0.03095902f, 0.30228755f, -0.24090336f, -0.20602958f, 0.40868771f, -0.17062239f, 0.06583852f, 0.16143119f, 
    0.10662680f, 0.14785738f, -0.01553864f, 0.06655193f, -0.01476958f, 0.03304377f, 0.00725000f, 0.01813095f, 
    -0.02921738f, 0.01545452f, 0.06001935f, -0.07882252f, -0.36034316f, 0.14011511f, 0.40655616f, -0.03749941f, 
    -0.01199514f, 0.03412324f, -0.07796778f, -0.03280264f, -0.06329502f, 0.04136366f, 0.04552487f, 0.13974532f, 
    -0.01978881f, 0.06661144f, -0.02456548f, 0.02566682f, 0.03189932f, 0.00926145f, -0.02788887f, 0.02623431f, 
    -0.09736076f, -0.02106953f, 0.13219689f, 0.05339687f, -0.02696193f, -0.01579310f, -0.01372785f, -0.00524548f, 
    -0.02307527f, -0.06895924f, 0.02678172f, -0.04857574f, 0.02513148f, -0.03162552f, -0.01176854f, 0.00592807f, 
    -0.02858953f, -0.02697529f, -0.13973500f, 0.02818911f, 0.01760386f, -0.06087243f, -0.22828396f, -0.12051883f, 
    0.08894695f, -0.04074407f, 0.05555068f, 0.10361404f, 0.01582062f, -0.04107538f, -0.05440793f, -0.01532907f, 
    -0.06104096f, 0.01858322f, -0.01592632f, 0.02076706f, -0.10459881f, -0.09694996f, -0.00492606f, 0.04345141f, 
    0.34973389f, 0.06730473f, -0.09375649f, -0.07518137f, -0.07396641f, 0.06677914f, 0.05373537f, 0.02722654f, 
    0.15529290f, -0.11521568f, 0.08720944f, 0.00809730f, -0.04826575f, -0.16435838f, 0.06457214f, 0.03459571f, 
    -0.05396250f, 0.08069532f, -0.04546074f, 0.00714182f, -0.36759990f, -0.45780644f, -0.28745973f, -0.11139359f, 
    -0.20690617f, -0.04381822f, -0.13117072f, -0.02531826f, -0.00402433f, -0.08858350f, -0.04032029f, 0.01898589f, 
    -0.01997411f, -0.06760161f, -0.00076178f, -0.02662672f, 0.01307354f, 0.02991523f, -0.00884754f, -0.04360669f, 
    -0.30871797f, 0.27768624f, 0.36228630f, 0.03747185f, 0.11089671f, -0.07551352f, -0.03641019f, -0.06232269f, 
    -0.10522283f, 0.09114118f, -0.10216904f, 0.07134233f, 0.01460960f, 0.08870943f, 0.02086290f, 0.01197622f, 
    -0.02720352f, -0.05453810f, -0.01809294f, 0.00654227f, -0.31027305f, -0.07520712f, 0.36125499f, -0.13553277f, 
    0.18536052f, -0.10255326f, 0.02306827f, 0.13569584f, 0.07216076f, 0.08439898f, 0.04970885f, 0.07750008f, 
    0.14269532f, -0.08821127f, 0.15381168f, -0.05484216f, 0.00732076f, -0.01950078f, 0.02126783f, -0.06531082f, 
    0.01215609f, 0.06739006f, 0.06561956f, -0.11711596f, 0.08205397f, 0.05680289f, -0.02148476f, -0.01840181f, 
    0.02368270f, -0.07216068f, -0.10989802f, 0.10454096f, -0.03207074f, 0.14386806f, -0.00649919f, -0.00372341f, 
    -0.01715111f, 0.03897252f, -0.13866635f, 0.01761984f, -0.01942356f, 0.13547836f, -0.12317728f, -0.11348297f, 
    0.05279098f, 0.11999811f, -0.04027891f, -0.03959543f, 0.01871239f, -0.11384791f, -0.13366237f, -0.12693290f, 
    -0.05072423f, 0.07893910f, -0.02862614f, -0.10634718f, 0.02994967f, 0.09184799f, -0.29739627f, -0.11480364f, 
    0.12827352f, 0.17795049f, -0.12113121f, -0.02848641f, 0.03630188f, -0.03034166f, 0.01118421f, -0.00451675f, 
    0.04843959f, 0.01651324f, 0.06517532f, -0.02188542f, -0.02292117f, -0.07774299f, 0.01203239f, 0.02727406f, 
    -0.04662261f, -0.08463154f, -0.02730405f, -0.04636991f, -0.07964963f, -0.19900122f, 0.04507214f, 0.08457287f, 
    -0.02782733f, 0.05124434f, 0.05408707f, -0.04378402f, 0.14551201f, 0.06261983f, -0.00158248f, 0.02273610f, 
    0.01646558f, 0.11097965f, -0.03129338f, -0.05892636f, 0.03461695f, 0.11554231f, -0.04249792f, 0.13587311f, 
    -0.53881699f, 0.23851846f, 0.33449581f, -0.02747710f, 0.13620630f, -0.14564137f, -0.04558595f, -0.01935617f, 
    -0.07284746f, 0.12400483f, -0.04002564f, 0.06718684f, 0.09040535f, 0.02164054f, 0.08918735f, 0.01597521f, 
    -0.02493975f, -0.05284897f, 0.04686579f, -0.02727036f, -0.56003350f, -0.37457255f, -0.23787245f, -0.15752044f, 
    -0.23406175f, -0.20372213f, -0.09204889f, -0.13620105f, -0.08698567f, -0.07548960f, -0.00338192f, -0.01336643f, 
    -0.03192808f, 0.00705592f, -0.00970380f, -0.01925074f, -0.01100577f, 0.05440756f, 0.10748862f, -0.08874644f, 
    -0.37677059f, -0.35496476f, -0.63455856f, -0.08425530f, -0.19071938f, -0.15704137f, -0.17907649f, -0.11425359f, 
    -0.03301558f, -0.27748376f, -0.01665344f, 0.02117221f, 0.00882041f, 0.03188831f, -0.00871799f, 0.00863635f, 
    -0.03525259f, 0.06587803f, 0.06412561f, 0.01482282f, -0.14116281f, 0.19190551f, 0.16419774f, 0.02449210f, 
    0.19137399f, 0.02612503f, 0.04706090f, -0.02939456f, -0.09406622f, 0.01108146f, -0.02815088f, 0.06789984f, 
    0.01632683f, 0.07193622f, -0.02452390f, -0.01281110f, -0.04993061f, -0.03953945f, -0.01366214f, -0.01377366f, 
    -0.12422631f, -0.76173943f, -0.55227774f, -0.04971806f, 0.24875340f, 0.03058767f, 0.07285861f, -0.01016157f, 
    -0.00848984f, -0.12185583f, -0.03814434f, -0.03052314f, -0.05550184f, 0.03287875f, 0.03773863f, 0.02455481f, 
    0.05747067f, 0.00399525f, 0.15761511f, 0.01738953f, -0.12652680f, -0.07608702f, 0.06445367f, -0.09441873f, 
    0.04260436f, -0.03199660f, 0.06467827f, -0.03839283f, -0.04482400f, 0.09709331f, 0.00863971f, 0.02264328f, 
    -0.02236235f, 0.08374316f, -0.08467191f, -0.03582230f, 0.08563709f, -0.03291397f, 0.08877458f, 0.02368930f, 
    -0.02295319f, 0.04148712f, -0.00654219f, 0.03118995f, -0.02634034f, 0.06264556f, 0.07351874f, 0.03907183f, 
    -0.05257694f, 0.05455514f, -0.01441688f, -0.02168492f, 0.11081084f, 0.02281322f, -0.07330441f, 0.11998902f, 
    0.07993848f, -0.06942754f, -0.01274899f, -0.01886662f, -0.01661732f, 0.04244365f, -0.05811674f, -0.11065204f, 
    -0.09031594f, 0.00283363f, 0.04052252f, 0.01656228f, -0.03798778f, -0.03569883f, -0.04998083f, -0.04828832f, 
    -0.05858786f, -0.07601836f, -0.04549759f, -0.03522282f, -0.04628064f, -0.17232448f, 0.01382624f, 0.03258235f, 
    0.01061663f, 0.26814571f, -0.05560105f, 0.02064318f, 0.04308210f, -0.03062466f, -0.12720558f, -0.10847104f, 
    0.05579028f, -0.15298036f, -0.00906704f, -0.08035059f, -0.13250437f, 0.00615331f, 0.07503667f, 0.03095211f, 
    -0.04927433f, 0.12153853f, -0.19980216f, -0.08596008f, -0.21584481f, -0.38668522f, -0.34660089f, -0.09153239f, 
    0.28183854f, -0.00957478f, -0.00875808f, -0.04924113f, -0.00706430f, -0.12984788f, 0.01717941f, 0.01075737f, 
    0.01908348f, 0.10297970f, -0.03382324f, -0.09228298f, 0.00672972f, 0.15567531f, 0.01022153f, -0.02588808f, 
    -0.13229987f, 0.10835092f, 0.11806376f, -0.01074650f, 0.14477211f, 0.05289409f, -0.06017471f, 0.03326919f, 
    -0.02289679f, -0.03662377f, 0.11285304f, 0.06068357f, -0.00339838f, 0.19060752f, 0.07103907f, 0.04032473f, 
    0.01724452f, 0.00151067f, -0.07443788f, 0.02427898f, 0.02337403f, 0.24800378f, 0.01748099f, 0.05203541f, 
    0.08223201f, -0.01554465f, 0.00598099f, 0.03833150f, 0.12121449f, 0.11577959f, 0.03925391f, 0.01073193f, 
    0.06548312f, 0.00159348f, -0.01021555f, -0.02569363f, 0.08816236f, -0.21621208f, 0.00051753f, 0.07353485f, 
    -0.41423815f, -0.48267880f, -0.54176956f, -0.22503452f, -0.01749134f, -0.09819624f, 0.10589045f, 0.18007661f, 
    0.04799411f, -0.12787686f, -0.01270220f, -0.01164879f, 0.00542068f, -0.00687796f, 0.02175444f, -0.00007642f, 
    -0.02532772f, 0.11440792f, -0.00720880f, -0.07446900f, 0.01978720f, -0.05813976f, 0.08606805f, 0.08947643f, 
    -0.02571546f, 0.00152202f, 0.04868903f, 0.03315976f, -0.04365569f, 0.04413799f, 0.04285570f, 0.00173428f, 
    0.09151726f, -0.00893293f, -0.11998164f, 0.02686017f, 0.03119597f, -0.02435706f, -0.00698939f, -0.03006641f, 
    -0.08753375f, -0.00119862f, 0.02162033f, -0.02127662f, 0.06569755f, -0.04854148f, -0.02925444f, -0.00353161f, 
    0.00574047f, 0.09812915f, -0.01066577f, 0.06514350f, 0.10313962f, -0.06514546f, 0.17067769f, -0.03260587f, 
    -0.00910436f, -0.07214937f, 0.08046338f, -0.08103619f, -0.20774454f, -0.12380297f, 0.00146824f, -0.04817707f, 
    0.04253745f, -0.19929807f, -0.04489667f, -0.02110254f, -0.04498104f, 0.05629333f, 0.07594623f, -0.07895855f, 
    0.00538405f, -0.06266218f, 0.04284904f, -0.02449735f, -0.04225358f, -0.01148133f, 0.10038529f, -0.12797341f, 
    -0.15485591f, -0.66997600f, -0.22957803f, -0.19822420f, -0.24657497f, -0.06242973f, -0.23591980f, 0.17632158f, 
    0.00203937f, -0.11329160f, -0.12767617f, 0.08296070f, 0.06520316f, 0.08219061f, 0.04686228f, 0.02775902f, 
    0.05203342f, 0.07735839f, -0.00388827f, 0.01263156f, 0.00772090f, 0.06869323f, 0.04731988f, 0.00096500f, 
    -0.03488041f, -0.03373469f, -0.01639057f, -0.00769139f, -0.00604124f, -0.00914459f, -0.01859045f, -0.12242410f, 
    -0.06844331f, -0.09907732f, -0.12023611f, -0.00440391f, 0.01045754f, -0.01507878f, -0.00615942f, 0.01881324f, 
    0.30533290f, -0.38947684f, -0.11073432f, -0.11498075f, -0.09817564f, 0.01095913f, -0.02705163f, -0.10478123f, 
    0.14700849f, 0.07117848f, 0.01833637f, -0.01677074f, -0.08466072f, 0.00714841f, -0.00543258f, -0.04443723f, 
    0.02530697f, -0.09738217f, 0.15203388f, -0.00460317f, -0.13758139f, -0.01546945f, 0.06570450f, 0.01010860f, 
    -0.06044479f, -0.03626069f, -0.05754725f, 0.05504842f, -0.04218699f, -0.00200841f, 0.04328158f, 0.02256232f, 
    0.00589947f, 0.03040729f, -0.04500147f, 0.03271829f, -0.02710482f, -0.06891907f, -0.03515159f, 0.03411608f, 
    0.13222313f, -0.38283587f, 0.06508227f, 0.23026876f, 0.12172092f, -0.08327984f, 0.07862972f, -0.06255363f, 
    0.12136559f, 0.03522654f, -0.00969793f, 0.00239565f, -0.12111843f, -0.02282587f, 0.05803371f, -0.02416207f, 
    0.01048689f, -0.11597160f, 0.09628316f, 0.02555945f, 0.33911595f, -0.29895243f, -0.22615954f, -0.05592781f, 
    -0.02374086f, -0.02446624f, 0.01631908f, -0.03679962f, 0.02119387f, 0.10673571f, 0.03140692f, 0.00518082f, 
    -0.00097557f, -0.03803027f, 0.03516234f, 0.02329472f, 0.00112009f, -0.03218264f, -0.02277619f, -0.04627636f, 
    -0.43641764f, -0.29729763f, -0.27113408f, 0.27737185f, 0.11468855f, 0.14207964f, 0.00814036f, 0.15841845f, 
    -0.14535041f, -0.02212027f, 0.02338295f, 0.03983863f, -0.05890991f, -0.02462409f, 0.05927640f, 0.03281626f, 
    0.09536649f, 0.05568151f, 0.08606686f, -0.08126528f, 0.04965281f, 0.08860313f, 0.01500063f, -0.08190432f, 
    -0.03747338f, -0.00994389f, 0.02810057f, 0.04055347f, -0.04035057f, -0.05693595f, 0.01212349f, -0.14555088f, 
    -0.13703151f, -0.26845241f, -0.10959002f, 0.00646415f, -0.01003884f, -0.00007646f, -0.00499585f, -0.00220105f, 
    0.00309069f, 0.07865696f, 0.11181553f, 0.01329490f, 0.08271412f, -0.03958708f, -0.02906661f, -0.01391953f, 
    0.00261996f, -0.00639884f, 0.09551235f, -0.11641939f, 0.08341343f, -0.00098824f, -0.06477811f, 0.01593261f, 
    -0.06659935f, -0.00075482f, -0.09379626f, 0.04183732f, 0.04221525f, 0.02372178f, -0.01402843f, -0.00507930f, 
    -0.05002915f, 0.00129809f, 0.01187112f, -0.01725796f, -0.03634408f, -0.01683734f, -0.01370209f, 0.01416789f, 
    0.00878173f, -0.03524144f, -0.01210284f, -0.06644426f, -0.11095622f, 0.02508745f, 0.00003297f, 0.02381948f, 
    0.20711277f, 0.02040662f, -0.15167680f, -0.11000408f, -0.09801693f, 0.03642697f, -0.00999648f, 0.02579670f, 
    0.02617899f, 0.06147043f, -0.00424752f, 0.02701223f, 0.02375892f, -0.02097809f, -0.00210950f, 0.02938241f, 
    0.00900515f, -0.04901524f, 0.04913779f, -0.03924116f, -0.10676650f, 0.14523764f, -0.00524701f, 0.00026460f, 
    -0.11355089f, -0.06086433f, -0.04081121f, -0.01567030f, -0.00069468f, -0.00633894f, 0.04083031f, 0.02924234f, 
    0.00895169f, -0.00080165f, 0.01606390f, 0.01948853f, -0.14539757f, -0.02664660f, -0.02804356f, 0.04649173f, 
    -0.59995812f, -0.81750238f, 0.07150219f, 0.53575504f, 0.27058214f, 0.00779548f, 0.02607382f, 0.02052742f, 
    -0.04648773f, 0.06955863f, 0.07598174f, -0.02076820f, -0.06366044f, -0.05089292f, -0.01249062f, -0.00915199f, 
    0.05678337f, -0.12074202f, 0.06220260f, 0.01398918f, -0.01151161f, 0.07660523f, -0.03188547f, 0.03126719f, 
    -0.06792219f, 0.02894957f, -0.00869541f, -0.03431280f, -0.00008087f, -0.01680076f, 0.01975303f, 0.02102331f, 
    0.03156856f, -0.00029825f, 0.03245192f, -0.13334203f, -0.10567450f, 0.02316815f, 0.05453244f, -0.00347625f, 
    -0.01381591f, -0.03521360f, -0.12115679f, -0.00739703f, -0.08557650f, 0.04952270f, 0.02156109f, 0.04154673f, 
    -0.04554010f, -0.04282539f, -0.26421496f, 0.10005803f, -0.07037780f, 0.01915385f, -0.09643837f, 0.03460541f, 
    -0.01865698f, 0.02862116f, -0.02800909f, -0.02788478f, 0.09291270f, 0.13666417f, -0.15770833f, 0.00412426f, 
    -0.30741143f, 0.03625647f, 0.08597487f, 0.16955253f, -0.09128621f, -0.07602048f, -0.09337592f, -0.00534867f, 
    -0.02105974f, 0.04623959f, -0.05797860f, -0.04520470f, -0.08910698f, 0.05848429f, -0.01903731f, -0.10329319f, 
    0.45186582f, -0.35672602f, -0.40681437f, -0.43166918f, -0.22807495f, 0.06376114f, 0.00387468f, -0.01494485f, 
    0.18675241f, 0.00706387f, 0.06927045f, 0.05757723f, -0.03571760f, 0.09187531f, 0.00470017f, -0.04676159f, 
    -0.01026354f, -0.05462060f, 0.04811338f, 0.05172734f, -0.01959410f, -0.45887882f, 0.40561542f, 0.01843434f, 
    0.11835207f, -0.01484628f, 0.13240115f, -0.01570267f, 0.23272435f, 0.12863617f, -0.01598005f, 0.02037170f, 
    -0.05332973f, -0.08471850f, -0.03582540f, 0.01284731f, -0.01214586f, -0.04051732f, 0.21580376f, -0.08063369f, 
    -0.09090846f, 0.01712358f, 0.08480697f, 0.03672591f, -0.02893462f, -0.08092457f, -0.05814261f, 0.00917778f, 
    -0.01932084f, 0.01579037f, 0.05755728f, -0.00193338f, 0.05629626f, 0.00224013f, -0.06861313f, 0.03296108f, 
    0.01426912f, -0.09336923f, 0.00060309f, 0.05463600f, 0.00390060f, 0.06651600f, 0.12825707f, -0.02949996f, 
    -0.04926836f, -0.01607876f, -0.00623917f, -0.01430469f, 0.02043460f, 0.00280361f, 0.06337465f, -0.00292521f, 
    0.06678981f, -0.01033914f, 0.00163896f, 0.01380994f, -0.05381914f, 0.09993813f, 0.03657226f, -0.00482571f, 
    -0.03365074f, -0.09890267f, 0.32183877f, 0.17635532f, 0.05515944f, -0.02239178f, -0.00975246f, 0.01659380f, 
    -0.21060573f, -0.01182565f, 0.03885995f, 0.01705893f, 0.05020886f, 0.03567594f, 0.04700099f, 0.08074470f, 
    0.17087747f, -0.10579799f, 0.07990038f, -0.01698391f, 0.03297578f, 0.10399218f, 0.03823272f, 0.03688126f, 
    -0.21427944f, -0.04674450f, 0.06024765f, -0.00216051f, 0.03010178f, -0.04669382f, -0.06393774f, 0.04201780f, 
    -0.00518172f, -0.11454507f, -0.03919983f, -0.05376589f, -0.06170348f, -0.05594685f, -0.05846915f, -0.01614410f, 
    -0.12446775f, 0.02830876f, 0.02503255f, 0.07794762f, -0.11575504f, 0.03695863f, 0.06397843f, -0.04702194f, 
    0.02632371f, 0.00465502f, 0.03367576f, 0.02785306f, 0.04139452f, -0.02252977f, -0.02801180f, -0.00761828f, 
    0.00924573f, -0.05282186f, 0.02233729f, 0.00165759f, -0.04249507f, 0.11408027f, -0.02794415f, 0.00394133f, 
    -0.10861456f, -0.00278271f, -0.00512294f, -0.04774256f, -0.01751685f, -0.02603572f, 0.03086279f, 0.04133072f, 
    0.05279006f, 0.03410494f, 0.00546709f, -0.04739966f, -0.19138005f, 0.08049481f, 0.03301583f, -0.00127215f, 
    0.01578915f, -0.19251394f, -0.14991902f, 0.22277555f, -0.07769483f, 0.02104170f, -0.00069347f, -0.12335058f, 
    0.00902762f, 0.10826209f, -0.01874398f, -0.00771505f, -0.04610391f, 0.00309445f, -0.03963879f, -0.01240462f, 
    0.05407107f, 0.01645308f, 0.08076874f, 0.07390687f, -0.02090832f, 0.06037786f, 0.11567779f, -0.04913497f, 
    -0.01173615f, -0.03148226f, 0.00647518f, 0.03984885f, 0.00626190f, -0.02413815f, 0.00142712f, -0.05541661f, 
    -0.03888883f, -0.09775123f, -0.08605654f, -0.04455652f, 0.01865352f, -0.02918690f, 0.04633296f, -0.00544464f, 
    0.11567351f, 0.10344912f, -0.05131036f, -0.01633053f, -0.11806008f, 0.00222874f, 0.06564504f, 0.00096178f, 
    -0.01540905f, -0.00265547f, -0.03117555f, -0.08956738f, 0.04357463f, 0.04773512f, -0.05888434f, 0.02692675f, 
    -0.02187797f, 0.00335373f, 0.00521455f, -0.01343659f, 0.08699354f, 0.01176693f, -0.03097714f, 0.03236930f, 
    -0.03828998f, 0.02398476f, 0.02327576f, -0.02022589f, -0.04571534f, -0.03231277f, -0.00238428f, -0.01820933f, 
    0.06522700f, -0.08304001f, -0.02152978f, -0.00080476f, -0.03382812f, 0.00724073f, -0.03922250f, -0.09684861f, 
    -0.12289485f, -0.47182232f, 0.07988281f, 0.34080085f, -0.40713257f, -0.04950824f, 0.01354895f, -0.02877435f, 
    0.03299178f, 0.04890498f, 0.01556348f, -0.01987354f, -0.07680661f, 0.00771894f, -0.04419122f, -0.04092620f, 
    0.05118086f, -0.13957429f, -0.00643614f, -0.02530065f, 0.00214437f, 0.08575184f, -0.01305242f, 0.04196751f, 
    -0.14401335f, 0.01867070f, 0.05306524f, 0.05040723f, -0.05778017f, -0.03644757f, 0.02432400f, 0.05360132f, 
    0.01655610f, 0.01095621f, 0.00001689f, -0.00861574f, 0.01358572f, -0.05944498f, -0.01238130f, 0.05012107f, 
    -0.10305928f, 0.01802164f, -0.41074160f, 0.20187907f, -0.18080980f, 0.05046611f, 0.07175350f, 0.12180198f, 
    -0.01575537f, 0.03890602f, -0.08932628f, 0.03528643f, 0.00475036f, 0.10387544f, 0.04515569f, -0.04281950f, 
    -0.03509839f, -0.02847673f, 0.01852829f, 0.20638607f, -0.00393870f, 0.01406652f, -0.06602003f, 0.05512697f, 
    -0.09998213f, -0.00805357f, 0.05272902f, 0.02096904f, -0.04967220f, 0.00176273f, 0.02412045f, 0.02367405f, 
    0.03537945f, 0.02363419f, -0.02305899f, -0.05506610f, -0.05367989f, -0.09255169f, -0.02816849f, 0.00362017f, 
    -0.05432574f, -0.18320626f, 0.16779801f, 0.04980227f, 0.04992395f, -0.01496682f, -0.02011410f, -0.11161499f, 
    -0.13486919f, 0.02411700f, 0.05995135f, 0.01789094f, 0.00616542f, 0.02205280f, -0.00699935f, 0.10276975f, 
    0.00935887f, -0.08293416f, 0.01348362f, -0.02070537f, 0.35908177f, 0.21306619f, -0.12630861f, -0.10967962f, 
    -0.17608230f, -0.00022263f, -0.04336771f, -0.04003781f, -0.04842055f, -0.02494428f, -0.01160160f, -0.12916067f, 
    0.05347228f, -0.02732138f, -0.02335995f, 0.03060238f, -0.02175524f, 0.01942977f, -0.02016175f, -0.00333740f, 
    -0.08450830f, -0.16013588f, 0.12979281f, -0.11555051f, 0.15227178f, -0.01082158f, -0.04135735f, 0.00106589f, 
    -0.09506374f, 0.02490450f, 0.04720369f, -0.05540999f, -0.01315432f, 0.01797854f, -0.08032632f, -0.07138551f, 
    0.01202276f, 0.02385766f, -0.02970337f, -0.09713539f, 0.34049150f, -0.24931414f, -0.37905529f, -0.26848465f, 
    -0.16242495f, 0.02171026f, -0.08221569f, 0.03132462f, 0.06182994f, -0.01801061f, 0.02688853f, 0.04389167f, 
    -0.11072063f, -0.00814957f, -0.00730602f, -0.01456161f, -0.03535720f, 0.00315107f, 0.01040707f, 0.01940742f, 
    0.50394017f, -0.27161077f, -0.26517826f, -0.15781845f, -0.14308125f, 0.10992917f, -0.02211707f, 0.04119535f, 
    -0.06762338f, -0.09479351f, 0.03456235f, -0.05483986f, -0.00839454f, -0.00114153f, -0.08536613f, 0.01464968f, 
    -0.13237397f, 0.09751457f, -0.08726973f, -0.04352334f, 0.39884278f, -0.11615205f, -0.11150539f, -0.15138602f, 
    -0.04487015f, -0.11140175f, 0.13481957f, -0.10158093f, 0.07154817f, -0.12795639f, 0.10766391f, -0.00142274f, 
    0.05403635f, -0.01703195f, 0.04296869f, -0.03611567f, 0.04293232f, 0.02886871f, -0.00035798f, 0.06111721f, 
    -0.00903180f, 0.06254590f, 0.04669233f, 0.10244144f, 0.01632162f, 0.03059482f, 0.04155063f, 0.02539073f, 
    -0.02004789f, -0.03055721f, 0.05722126f, 0.04299466f, 0.06675734f, 0.04368448f, -0.01691863f, -0.00683926f, 
    0.04978620f, -0.12661809f, -0.01758336f, 0.02747962f, -0.01141174f, 0.10430794f, -0.10134966f, 0.06015770f, 
    -0.15810622f, 0.04065858f, 0.05277801f, -0.01123249f, -0.00716723f, -0.00482960f, 0.06912670f, 0.01183701f, 
    0.04030500f, 0.02712712f, -0.04030904f, -0.03903062f, 0.00535131f, -0.04200825f, 0.01557942f, 0.02473945f, 
    -0.18997483f, 0.01932870f, 0.04743894f, -0.01481776f, 0.11414147f, -0.03349151f, -0.06400527f, -0.00071920f, 
    -0.03333490f, 0.05622905f, 0.06196508f, 0.02858533f, 0.03441922f, -0.00338237f, 0.01007094f, -0.01046658f, 
    0.02682304f, -0.08978040f, -0.07059760f, 0.00040683f, 0.34205267f, -0.42109871f, -0.11505921f, -0.25640529f, 
    -0.20176491f, -0.09917250f, 0.06285770f, -0.11719421f, 0.20902744f, 0.11379943f, 0.01473230f, -0.00148682f, 
    0.00039340f, -0.03155967f, 0.02649642f, -0.11830161f, 0.02114845f, -0.09698652f, 0.06668154f, 0.01928955f, 
    0.27934080f, 0.00685784f, -0.19833128f, -0.13870014f, -0.13379368f, 0.03440668f, 0.00536778f, -0.04272828f, 
    0.00740228f, -0.09187654f, 0.07991628f, -0.00202854f, 0.08074123f, -0.01864434f, 0.02199340f, -0.00489288f, 
    0.01970549f, 0.01082085f, 0.03718948f, 0.00818007f, 0.46168372f, 0.46382427f, -0.34024894f, 0.10920548f, 
    -0.56126451f, -0.08121847f, 0.08839482f, 0.02976628f, -0.15641883f, -0.02494252f, -0.13714567f, 0.00818324f, 
    -0.03935946f, -0.13166152f, 0.02322312f, -0.10972780f, -0.11199736f, 0.05843698f, -0.21048160f, 0.06108909f, 
    0.01247635f, 0.09611478f, 0.08173832f, 0.02125903f, 0.03394505f, -0.07598112f, 0.06530170f, 0.03937745f, 
    -0.00456428f, -0.02162050f, -0.02542336f, -0.11929518f, 0.00546887f, -0.02631408f, 0.05117773f, -0.05408499f, 
    0.02867494f, 0.04743050f, -0.01767385f, 0.04136318f, -0.12289058f, 0.03242007f, 0.11619201f, -0.00197533f, 
    -0.00678546f, -0.27545536f, 0.20699428f, -0.01461439f, 0.01204738f, 0.06882619f, -0.04287805f, -0.10657398f, 
    0.05894709f, -0.06889399f, -0.12309028f, 0.04751199f, -0.02029296f, -0.10127369f, -0.11941867f, 0.09997561f, 
    -0.09506072f, 0.02172184f, -0.04396030f, 0.00943420f, 0.00801091f, 0.00281356f, 0.00109212f, -0.02053764f, 
    -0.00395317f, -0.02303540f, -0.15199491f, 0.05525696f, -0.03594875f, 0.02562098f, -0.06743731f, -0.01397291f, 
    -0.03063983f, -0.00875892f, -0.05031033f, 0.00726637f, 0.30596507f, -0.41027835f, 0.44024819f, -0.33877829f, 
    0.19082545f, -0.09912574f, 0.00306026f, -0.14706543f, 0.07800380f, -0.02521718f, 0.02145956f, 0.03020352f, 
    0.04680750f, -0.00888338f, -0.07842881f, -0.02285849f, -0.00075104f, 0.01638878f, 0.00359297f, -0.08329118f, 
    0.52208948f, 0.13875210f, -0.27502286f, -0.16963598f, -0.20117185f, 0.04463026f, -0.12670562f, -0.00372683f, 
    -0.06749129f, 0.03557088f, -0.00761868f, -0.00992267f, 0.08445943f, 0.00056717f, -0.00024608f, 0.02298316f, 
    0.02869513f, 0.00620003f, 0.01309974f, 0.00206997f, 0.36873698f, -0.35912386f, -0.24048626f, 0.10387875f, 
    -0.09217010f, 0.04163133f, 0.00396660f, -0.03231791f, 0.01681739f, 0.01585049f, 0.02363760f, 0.00629949f, 
    0.04652390f, -0.00583283f, 0.00135757f, 0.05906498f, -0.02034041f, 0.00491775f, -0.05801204f, -0.10419988f, 
    -0.10362594f, -0.28957495f, 0.20414849f, -0.15998197f, -0.05653713f, -0.00149506f, 0.09936944f, 0.04728720f, 
    0.16256171f, 0.11924994f, -0.00520850f, -0.03214316f, -0.02099659f, -0.07471482f, -0.05220186f, -0.00317952f, 
    0.01828603f, -0.01273964f, 0.06578279f, -0.13451245f, 0.08761796f, 0.04011404f, -0.08154187f, -0.00540862f, 
    -0.10042782f, -0.03724020f, 0.03039041f, -0.00423909f, -0.06269028f, -0.01760794f, -0.01874694f, -0.07178097f, 
    0.03648862f, 0.01204870f, -0.08687733f, -0.02384359f, 0.00637382f, -0.00220889f, 0.01589386f, 0.04056788f, 
    -0.23141637f, -0.27860409f, -0.06461433f, 0.34874317f, -0.05862991f, 0.00617722f, 0.01539317f, -0.01243126f, 
    -0.04765448f, -0.03305816f, 0.04214879f, -0.02782371f, -0.02097420f, -0.01192121f, -0.03481726f, 0.04524424f, 
    -0.00472303f, 0.02364118f, 0.01153565f, -0.05947241f, 0.18432817f, 0.20962217f, -0.18708304f, -0.01823327f, 
    -0.19087504f, 0.00405306f, 0.07650290f, 0.03051404f, -0.07027206f, -0.03711840f, -0.01906169f, 0.11161790f, 
    0.12609613f, -0.08335841f, -0.13639420f, -0.02840960f, -0.01777840f, 0.04231398f, -0.04364627f, -0.07881621f, 
    0.00713724f, -0.04103393f, 0.10458610f, -0.06273248f, -0.00169003f, 0.03159744f, 0.00323633f, 0.00894777f, 
    -0.01949217f, -0.04795229f, 0.00240407f, -0.03199389f, -0.10672740f, -0.13342209f, -0.03099798f, -0.06503743f, 
    -0.06883494f, -0.03743625f, 0.00319612f, -0.01131183f, 0.01813415f, 0.05513531f, 0.06371827f, 0.01565649f, 
    -0.03102191f, 0.02129432f, 0.04151228f, -0.01009195f, 0.00832747f, -0.04126640f, 0.05585803f, 0.04986557f, 
    0.03237769f, -0.02192085f, 0.00654926f, -0.02346507f, -0.06886022f, 0.00430272f, 0.05732921f, 0.02889983f, 
    -0.13048986f, -0.19519967f, 0.17582351f, -0.00475745f, 0.10770226f, -0.04307903f, 0.05833335f, 0.08514306f, 
    0.04310223f, 0.00787422f, -0.03121707f, 0.11880653f, -0.06503779f, 0.04615381f, 0.04154453f, 0.05653007f, 
    0.01613756f, -0.01675697f, -0.04823362f, -0.01578060f, -0.30210313f, -0.34079528f, -0.06958930f, -0.19358471f, 
    0.01153782f, 0.05846126f, -0.02757412f, 0.09660831f, 0.07815703f, -0.00361164f, -0.01292173f, 0.04161546f, 
    -0.00659231f, 0.00410479f, 0.03608474f, -0.04412505f, 0.00205717f, 0.05694984f, -0.01822302f, 0.03852610f, 
    0.05822922f, 0.05484071f, 0.03725545f, -0.06874143f, 0.03572782f, -0.06521127f, 0.02904530f, -0.01769269f, 
    -0.00574548f, -0.04671460f, 0.07239335f, -0.08463663f, 0.01900683f, 0.00923390f, 0.01769583f, -0.02203953f, 
    0.00996767f, -0.05507827f, 0.02230070f, 0.04547199f, 0.03658878f, -0.03104952f, 0.02010865f, 0.02145667f, 
    0.01349332f, 0.00985879f, 0.03910326f, 0.04237635f, -0.10976165f, -0.03352004f, -0.03819799f, -0.01852543f, 
    -0.00559409f, -0.04316537f, -0.03257620f, -0.00365594f, -0.07341439f, 0.06902710f, 0.02108688f, -0.04131752f, 
    -0.37397042f, 0.21733765f, -0.04028135f, 0.05922515f, -0.09366796f, 0.05258784f, -0.01193186f, -0.04611911f, 
    -0.07407305f, -0.03512193f, 0.01111496f, 0.00275935f, 0.06708772f, 0.00023105f, 0.00120956f, 0.11776693f, 
    0.16755122f, 0.05679144f, -0.10735550f, -0.10231800f, -0.00429082f, 0.02224360f, 0.02610832f, -0.06186860f, 
    -0.05918713f, 0.05900719f, -0.00949552f, 0.00034369f, -0.03007420f, -0.02316523f, -0.03141065f, 0.01104736f, 
    -0.12466763f, -0.20036954f, -0.08532620f, -0.06163691f, -0.00159581f, -0.07137544f, -0.03311943f, 0.00942580f, 
    0.18077455f, 0.14256418f, -0.09862151f, 0.00308900f, -0.18318456f, 0.07375491f, 0.00495952f, 0.05129705f, 
    -0.03964446f, -0.08007742f, -0.10945980f, -0.05578459f, -0.02627525f, 0.04712453f, -0.08923844f, -0.02295688f, 
    -0.01841042f, 0.03291972f, -0.05656686f, -0.04846581f, 0.37851673f, -0.00310980f, -0.16468437f, 0.12626325f, 
    -0.11547002f, 0.17176232f, 0.00738485f, 0.07094836f, -0.04503586f, 0.00106939f, 0.03465979f, 0.04891037f, 
    0.12201189f, -0.00001251f, 0.05925206f, 0.00755379f, 0.06171829f, 0.00504504f, -0.05930220f, -0.11904660f, 
    -0.33579072f, -1.14397275f, -0.06160386f, -0.25809121f, 0.27570844f, -0.13497613f, 0.23654850f, 0.10378411f, 
    0.14218742f, -0.03010402f, 0.01178988f, 0.00355964f, -0.06360741f, -0.00344432f, -0.01565450f, 0.01009108f, 
    -0.00402823f, -0.09137279f, -0.00807184f, -0.07001669f, -0.15334913f, 0.01586316f, 0.08787421f, -0.01762931f, 
    -0.08912174f, -0.04860725f, -0.02934627f, 0.00297809f, -0.03134274f, 0.03123831f, 0.02002692f, 0.01183265f, 
    0.05830231f, 0.10522687f, 0.10835598f, -0.00833979f, 0.02095353f, 0.00813340f, 0.02869186f, 0.06355717f, 
    -0.03135356f, 0.02095824f, -0.43317524f, -0.25509286f, -0.16330297f, -0.10375977f, -0.07039383f, -0.02934874f, 
    -0.01029051f, -0.09049866f, 0.00104470f, 0.01989105f, -0.01130535f, 0.11672056f, 0.10797746f, 0.07746918f, 
    0.02417079f, 0.07004683f, -0.18167163f, -0.17276944f, -0.01743034f, 0.04628624f, 0.00483642f, 0.06048536f, 
    -0.12481491f, -0.00215056f, 0.03215664f, -0.10561273f, -0.01621626f, -0.01693068f, -0.00156156f, 0.06969410f, 
    0.02518848f, 0.01229174f, 0.02540127f, 0.00729625f, 0.13644132f, 0.11520787f, 0.11223904f, 0.09620360f, 
    0.05811197f, 0.01541345f, -0.18597022f, -0.14649636f, -0.07703435f, -0.04006789f, -0.14515001f, 0.00408694f, 
    -0.06967077f, -0.12098963f, -0.01165923f, 0.07460798f, 0.04895946f, 0.07815204f, 0.05712488f, 0.04101108f, 
    0.03625504f, 0.02770697f, -0.04102324f, -0.12844704f, -0.13495518f, -0.38467458f, -0.45279452f, -0.18371882f, 
    -0.02100637f, -0.06537455f, -0.04981750f, 0.03523373f, 0.04949199f, -0.01549753f, -0.05172691f, -0.02761704f, 
    -0.00916350f, 0.01845877f, -0.00512862f, 0.01052165f, 0.00479942f, 0.07826795f, 0.08726407f, 0.10301646f, 
    0.36489818f, -0.06141981f, -0.35663518f, 0.12277421f, 0.08768765f, -0.01810669f, -0.05405084f, -0.02233185f, 
    -0.00998890f, -0.01846894f, 0.05056511f, -0.00913564f, 0.10857850f, 0.06646413f, -0.01501513f, 0.01499384f, 
    0.01921388f, 0.04933759f, -0.21982506f, -0.01275734f, -0.10220004f, 0.04202266f, 0.07923937f, -0.00592258f, 
    -0.03846987f, -0.06607562f, 0.01750898f, 0.01343044f, 0.00825373f, 0.02106263f, 0.04491198f, 0.04882562f, 
    0.07586700f, 0.08119798f, 0.12229478f, -0.02996184f, 0.00494390f, 0.01723930f, 0.06952330f, 0.08203680f, 
    -0.18190962f, -0.07305102f, -0.04165652f, 0.00658727f, 0.13711210f, -0.03140986f, 0.01446983f, 0.08247012f, 
    0.06695788f, -0.08532093f, 0.00101648f, 0.04543048f, 0.17015751f, -0.04970107f, 0.06678868f, -0.05437105f, 
    -0.05059794f, 0.04910247f, 0.14363265f, 0.02466171f, 0.04084647f, 0.20226136f, 0.01741830f, 0.00830675f, 
    -0.05147634f, -0.03021336f, 0.02051579f, 0.01542526f, -0.01292057f, -0.01701134f, 0.00094254f, -0.06128810f, 
    0.04272456f, 0.04087475f, 0.00565903f, 0.02331543f, 0.03404731f, 0.03297053f, 0.03289390f, -0.01487739f, 
    -0.07494494f, -0.21745214f, -0.21830295f, -0.11308684f, -0.01052487f, -0.02388497f, 0.00245847f, 0.11407341f, 
    0.04443623f, 0.09677201f, 0.04765923f, -0.05952227f, -0.05480258f, -0.08487190f, -0.02242144f, -0.02936644f, 
    0.05055832f, 0.05019375f, 0.05541485f, 0.02683510f, -0.36790529f, 0.16146339f, 0.13981293f, 0.09854932f, 
    -0.12384437f, 0.00040394f, 0.03339918f, -0.04292144f, 0.00854846f, -0.06464726f, -0.06386668f, 0.00050547f, 
    0.01942789f, 0.01644658f, -0.01013471f, 0.02943995f, 0.01185132f, -0.03973752f, -0.03428838f, -0.02454909f, 
    0.70299268f, -0.26340425f, -0.25087965f, -0.12484235f, -0.23535593f, 0.00496614f, -0.15795273f, -0.12308832f, 
    -0.01665174f, -0.11513853f, 0.01188908f, 0.02037450f, 0.08525442f, -0.01897564f, 0.07758742f, 0.01364958f, 
    0.06521314f, 0.04515621f, -0.02572130f, 0.03661017f, -0.14452685f, 0.07326390f, 0.01638691f, 0.10126420f, 
    -0.11249405f, 0.01873782f, -0.01006021f, -0.00016530f, -0.02803216f, -0.06278693f, -0.07002131f, -0.00010827f, 
    -0.02766228f, 0.05426596f, 0.02878612f, 0.07904633f, 0.06249342f, 0.03474659f, 0.01142359f, 0.03008340f, 
    0.16881968f, 0.01117465f, -0.12341335f, -0.04757413f, -0.06932912f, -0.03305688f, 0.04101339f, 0.01379661f, 
    -0.02052192f, 0.02339332f, 0.17598711f, 0.04593022f, -0.01462277f, 0.15306012f, -0.00761568f, 0.00195635f, 
    0.00163332f, -0.01340503f, 0.07319907f, -0.00304419f, 0.09221905f, 0.15993042f, -0.18511716f, -0.08754684f, 
    -0.10907863f, 0.01113841f, 0.07185633f, 0.08020984f, 0.11335330f, -0.00649015f, 0.03551953f, -0.00531690f, 
    -0.04097886f, 0.00041781f, 0.00925354f, 0.02205311f, 0.15579724f, -0.07111346f, 0.02767720f, 0.06862551f, 
    0.00657984f, -0.15317331f, -0.42290947f, -0.15445183f, 0.11110578f, -0.01662681f, 0.03761352f, 0.01923762f, 
    0.16468790f, 0.10959066f, -0.05312603f, -0.02114308f, 0.01130425f, -0.04930192f, -0.09995743f, 0.05592241f, 
    -0.07884671f, -0.01699593f, -0.12663330f, -0.10312763f, 0.10695583f, -0.34976444f, -0.52444911f, -0.29507402f, 
    -0.12549222f, -0.03871116f, -0.34378994f, -0.11611865f, -0.08216818f, -0.37468615f, -0.02328140f, -0.01755980f, 
    -0.03781861f, 0.00134212f, 0.09116706f, 0.03883747f, 0.02628755f, 0.08899686f, -0.07004937f, -0.12720513f, 
    0.11946910f, -0.03797059f, 0.04219168f, 0.09383608f, -0.16639100f, 0.02612631f, -0.05944067f, -0.17306331f, 
    -0.06552757f, -0.01839535f, 0.02646976f, 0.02731157f, 0.06060426f, 0.04864904f, 0.04048176f, -0.02067780f, 
    0.10200684f, 0.13828510f, 0.11734041f, 0.10215250f, -0.29249850f, 0.05895500f, 0.15788341f, 0.05935560f, 
    -0.09994766f, -0.06595939f, -0.04397086f, -0.00791867f, 0.03858026f, -0.01949926f, -0.09555678f, -0.03036125f, 
    -0.03154455f, -0.02964158f, 0.02881783f, -0.00170393f, 0.02516354f, 0.00028754f, -0.01277369f, 0.01597311f, 
    0.37740761f, 0.27150369f, 0.05133933f, 0.04047232f, -0.05338543f, 0.17520697f, -0.11165253f, 0.12300234f, 
    0.07376676f, 0.02525402f, -0.02573972f, -0.02163927f, 0.00218506f, -0.01828175f, -0.00275950f, -0.14490132f, 
    0.00101861f, 0.03482977f, -0.17134124f, -0.22784092f, 0.08595842f, 0.16072872f, 0.08491193f, -0.07646176f, 
    -0.06948363f, -0.03555641f, 0.02933273f, -0.04924249f, 0.02147824f, -0.02486023f, -0.06519407f, 0.05394205f, 
    0.00869684f, -0.06387874f, 0.07487119f, -0.07378172f, -0.07354527f, -0.09903309f, -0.02688396f, -0.05300455f, 
    -0.02564667f, 0.16016024f, 0.03801167f, 0.01885803f, -0.13849895f, 0.05788105f, -0.10023188f, 0.07470734f, 
    -0.07439166f, -0.15976006f, -0.02871772f, 0.02708613f, 0.06511551f, -0.02201642f, 0.02833049f, -0.10886758f, 
    0.04093650f, 0.16635297f, 0.10261010f, 0.01262234f, -0.18628839f, 0.19973761f, 0.17978273f, 0.07624687f, 
    -0.20315398f, -0.00741461f, -0.05657682f, -0.06043015f, 0.00780035f, -0.04680588f, -0.04411739f, -0.01911847f, 
    0.01025799f, -0.00321066f, -0.00617721f, 0.02470907f, 0.06095073f, -0.01766536f, -0.01068748f, -0.03472026f, 
    0.20278658f, 0.24446762f, 0.08107349f, -0.03259200f, -0.12045709f, 0.09666239f, -0.00748808f, -0.06406633f, 
    -0.00794674f, -0.02119287f, 0.06703322f, 0.00964351f, 0.02256827f, 0.02076973f, -0.01076214f, 0.06828282f, 
    -0.02727533f, -0.05075116f, -0.11279640f, -0.33163354f, -0.24171594f, -0.00741851f, 0.08416217f, 0.01066923f, 
    -0.04595896f, -0.05861435f, -0.05358924f, 0.03696083f, -0.00067726f, -0.00875787f, 0.01481433f, -0.01047557f, 
    0.04768494f, 0.08274345f, 0.09195340f, -0.05204067f, 0.08690663f, 0.03981439f, 0.01041057f, 0.08935815f, 
    -0.05101159f, -0.08433514f, -0.10744353f, -0.10709798f, -0.17399818f, -0.09179086f, 0.02222602f, 0.05592586f, 
    0.03903553f, 0.00252400f, 0.06751471f, 0.05157222f, 0.06184701f, 0.02271835f, 0.02775177f, 0.02866075f, 
    0.08505700f, 0.00821304f, 0.04641283f, 0.04027460f, 0.19770792f, -0.01620679f, -0.08509432f, -0.06364211f, 
    -0.09608756f, -0.01567131f, -0.00778924f, -0.05902148f, -0.02813940f, -0.01395450f, -0.03244447f, 0.00012747f, 
    0.03529603f, -0.00042503f, -0.02354603f, -0.01529467f, 0.13327175f, -0.04948801f, 0.15999733f, 0.03061542f, 
    0.29076800f, -0.02084562f, -0.16094321f, -0.20928523f, 0.09073492f, 0.06505793f, -0.06830812f, 0.06144942f, 
    -0.03187787f, -0.25611040f, -0.04075302f, 0.12092794f, 0.06232898f, 0.01836095f, 0.04410495f, 0.04418062f, 
    0.08650181f, 0.11314403f, 0.05961698f, -0.00570527f, -0.38285515f, 0.13610648f, 0.20850340f, 0.06254687f, 
    -0.11698949f, -0.05581449f, -0.05533447f, -0.10792401f, -0.03943446f, -0.01841630f, -0.04489186f, -0.04322073f, 
    -0.00306573f, -0.03594806f, 0.00363301f, -0.10343937f, -0.06351286f, -0.10036615f, -0.14668089f, -0.10230484f, 
    -0.14932694f, -0.36613646f, 0.19166589f, 0.05608426f, 0.14871888f, -0.02976929f, -0.01612230f, -0.04691971f, 
    -0.03313754f, -0.06655639f, 0.02726450f, -0.00515116f, -0.02711138f, 0.00481901f, 0.00798208f, -0.07507447f, 
    -0.11278647f, -0.05009006f, -0.04475969f, -0.30621591f, -0.20663394f, 0.12211722f, 0.16538671f, 0.03487442f, 
    -0.05048100f, -0.04032877f, -0.00909046f, -0.06209924f, -0.03108898f, -0.02992940f, -0.04334147f, -0.04475741f, 
    0.01714448f, -0.02091304f, -0.03827696f, -0.08639185f, -0.05251642f, -0.08669900f, -0.06019492f, -0.10526023f, 
    0.51175547f, -0.17050065f, 0.02494600f, 0.08112545f, -0.18492925f, -0.03149435f, -0.15991157f, -0.17229772f, 
    -0.05535682f, -0.04499096f, 0.04046126f, 0.09480236f, 0.03804149f, -0.04060831f, 0.03485685f, -0.01893569f, 
    0.03682311f, 0.08068173f, -0.05616646f, 0.13317733f, 0.05775059f, -0.18621080f, -0.07787593f, -0.11195658f, 
    -0.13017437f, -0.05999753f, 0.07389487f, 0.09183160f, 0.05371482f, 0.01595712f, 0.05481872f, 0.01915594f, 
    0.00815783f, -0.05255286f, -0.04342690f, -0.00045658f, -0.00002059f, 0.00453896f, 0.03835480f, -0.01192755f, 
    0.29901704f, -0.19722857f, -0.03487090f, 0.13432600f, 0.09704041f, 0.07987342f, 0.00751911f, 0.00351732f, 
    -0.01903777f, 0.05936923f, 0.00587868f, 0.08992593f, -0.05872947f, 0.07959019f, -0.00361468f, 0.01160521f, 
    -0.02398339f, -0.04926135f, -0.13663259f, 0.05823874f, 0.07244858f, -0.14382534f, -0.33409560f, -0.16364025f, 
    0.11752170f, 0.03100652f, 0.03895205f, 0.00056087f, 0.19280033f, 0.12452929f, -0.00222936f, -0.00752946f, 
    0.00914164f, 0.06881800f, -0.00467136f, 0.07574377f, -0.01642608f, 0.00818524f, -0.09040199f, -0.05774137f, 
    0.22612460f, -0.41155744f, -0.39720631f, -0.06866837f, 0.00086731f, 0.03965792f, 0.11296755f, 0.10207251f, 
    0.17895976f, 0.05663187f, 0.01497758f, -0.09634046f, -0.03833575f, -0.06811452f, -0.06670200f, 0.04097310f, 
    0.03822085f, -0.00701973f, 0.10688339f, -0.00038995f, -0.03200220f, -0.14725547f, -0.43121833f, -0.07922992f, 
    -0.08994163f, -0.10893475f, -0.04647889f, 0.09171665f, 0.07780647f, 0.17973022f, 0.11259795f, -0.03804702f, 
    -0.02245543f, -0.01637571f, -0.02177036f, -0.00591216f, 0.07310702f, -0.00568838f, 0.03078147f, 0.05292155f, 
    -0.43822780f, 0.03837313f, 0.21069074f, 0.06043443f, -0.09238869f, -0.12729399f, -0.00445267f, -0.10364149f, 
    -0.03063396f, -0.02121007f, -0.11608194f, -0.01721493f, 0.06137120f, 0.01585350f, 0.04620022f, -0.00393023f, 
    -0.04969845f, 0.02562865f, -0.05074818f, 0.01951066f, -0.30387664f, 0.13632914f, 0.10584706f, 0.13915284f, 
    -0.12916717f, 0.03055627f, -0.05687635f, -0.06053555f, -0.02829733f, -0.01669784f, -0.06553935f, -0.00143916f, 
    -0.04981598f, 0.01584022f, -0.05267296f, 0.06377421f, -0.01902851f, -0.03379085f, -0.02668682f, -0.01334601f, 
    -0.38063431f, -0.09118115f, 0.08719781f, 0.02374959f, 0.14646482f, -0.04021402f, -0.04212643f, 0.00415840f, 
    0.01805326f, -0.00239564f, -0.01143715f, -0.01169783f, 0.06391533f, 0.06174389f, -0.01412815f, -0.03227239f, 
    -0.01242637f, 0.06784873f, 0.12219860f, 0.06792855f, -0.08218078f, -0.13723171f, -0.49044088f, -0.25460416f, 
    -0.11417204f, 0.09011806f, -0.08704833f, 0.19003369f, -0.02248904f, -0.20716386f, -0.03671409f, -0.02816094f, 
    0.01099564f, 0.01844572f, 0.10010376f, 0.01187149f, 0.01123126f, 0.10158803f, 0.02136025f, 0.00965475f, 
    0.00020035f, -0.16979800f, -0.32226560f, -0.12862645f, -0.07669089f, -0.07100435f, 0.07875509f, 0.05369990f, 
    0.07412163f, 0.06899332f, 0.12364472f, -0.00022807f, -0.01843276f, -0.07378931f, -0.04072282f, -0.00674153f, 
    0.06420762f, 0.00197879f, 0.02642801f, -0.03573598f, 0.53695178f, 0.21745469f, -0.07082928f, -0.11012138f, 
    -0.16702639f, -0.08571880f, 0.20526458f, -0.12436205f, 0.13877159f, -0.21952002f, -0.00231030f, 0.14005837f, 
    -0.01014928f, -0.06478404f, 0.14299192f, -0.02857941f, -0.17332311f, -0.15750262f, 0.02804601f, -0.13677154f, 
    -0.25266412f, -0.18788555f, 0.00351389f, 0.07636174f, -0.06491262f, -0.06687739f, 0.00279831f, 0.07670829f, 
    0.08281134f, 0.00366361f, -0.05636761f, 0.05574294f, 0.07833142f, 0.09094785f, 0.14773852f, -0.00092728f, 
    0.06068807f, 0.00712851f, -0.00385554f, 0.05065797f, -0.13525620f, -0.12549183f, -0.00977639f, 0.07432603f, 
    -0.17120722f, 0.01131359f, -0.07187337f, 0.02338528f, 0.13419987f, 0.07540193f, -0.05547096f, 0.05995122f, 
    -0.00394700f, -0.01915921f, 0.09403443f, -0.01182556f, 0.27764401f, 0.13714284f, 0.20679936f, 0.12541956f, 
    -0.21307291f, -0.06649956f, 0.02538553f, -0.00440155f, 0.10958173f, 0.01120303f, 0.05251871f, -0.00849178f, 
    0.04850032f, -0.00367049f, 0.03145497f, 0.07778299f, 0.04668561f, 0.05667831f, 0.00156721f, 0.00098895f, 
    0.04044401f, 0.03179091f, 0.06111460f, 0.07036142f, 0.27427670f, -0.02363311f, -0.23179106f, 0.09192406f, 
    0.10986650f, 0.09320217f, -0.17046374f, 0.04183013f, 0.14383751f, 0.12734023f, 0.07393123f, 0.06889594f, 
    -0.00415185f, 0.05669256f, 0.04207552f, 0.09222253f, 0.06228902f, -0.07902100f, -0.12808920f, 0.01789173f, 
    0.01532958f, -0.40961879f, -0.27814266f, -0.22620273f, -0.03773088f, -0.08297177f, 0.15977803f, 0.09693206f, 
    0.10804374f, 0.08183388f, 0.04335878f, -0.01583739f, -0.06355239f, -0.11929397f, -0.07268208f, 0.00660398f, 
    -0.02795959f, 0.00284542f, 0.00846745f, -0.06124815f, 0.02328510f, -0.43457729f, -0.47884387f, -0.18020892f, 
    -0.04819036f, -0.02573478f, -0.01729184f, -0.04454519f, 0.09980901f, 0.06812344f, -0.05849705f, -0.05530576f, 
    -0.03154557f, -0.01869236f, 0.02919234f, 0.03316215f, 0.02619212f, 0.02286808f, 0.10998438f, 0.08631258f, 
    -0.07064939f, -0.33020788f, -0.43234438f, -0.28633967f, -0.16541284f, -0.15494341f, -0.33417541f, -0.03257827f, 
    -0.11595536f, -0.41105592f, 0.01073264f, -0.00473855f, -0.02876463f, 0.01517148f, 0.05911228f, 0.02242812f, 
    0.05260766f, 0.07874597f, -0.07487376f, -0.11587729f, -0.11298282f, -0.18604092f, -0.04538756f, -0.04235965f, 
    -0.03539504f, -0.06559376f, 0.06494182f, 0.08637828f, 0.08622950f, 0.02906349f, 0.09425092f, 0.03577083f, 
    -0.01265392f, -0.00218828f, 0.02163282f, 0.00825278f, 0.01687581f, -0.01534223f, 0.04611965f, 0.01190136f, 
    0.42354655f, 0.01570786f, -0.14752375f, -0.02037291f, -0.08043636f, 0.09445307f, -0.05248114f, 0.02994847f, 
    0.05894673f, -0.06484939f, 0.04276538f, 0.03031050f, 0.06996544f, 0.00741243f, 0.00204088f, 0.02650595f, 
    0.06670032f, 0.01738718f, 0.10528485f, 0.07201837f, 0.07189801f, 0.08499192f, -0.14811535f, -0.07306831f, 
    -0.28376007f, -0.01251251f, 0.11914745f, -0.00518291f, 0.11815725f, -0.05270769f, 0.14086193f, -0.00010929f, 
    -0.06881634f, -0.00287689f, 0.03107905f, 0.00771665f, 0.10081764f, -0.04516772f, 0.04326983f, 0.01101846f, 
    -0.03284097f, 0.11007281f, 0.09315147f, 0.09706856f, -0.07431781f, -0.03698324f, -0.00982144f, -0.06793991f, 
    0.00409847f, 0.03191667f, 0.04534332f, 0.03428878f, -0.03786587f, -0.01761090f, -0.02380327f, -0.06776581f, 
    0.00921522f, -0.04096123f, -0.07386679f, -0.05257767f, -0.31080833f, 0.11736632f, 0.10816552f, 0.00076102f, 
    -0.10166878f, -0.08221149f, -0.04275179f, -0.03712718f, -0.05681679f, -0.05753876f, -0.10060379f, -0.07415495f, 
    -0.03806375f, -0.05246385f, -0.05060108f, 0.00626826f, 0.06181383f, -0.01009012f, -0.06622774f, -0.00109649f, 
    0.09698521f, -0.22484654f, -0.13371699f, 0.05605439f, 0.06952548f, 0.02167496f, -0.09321667f, -0.07069191f, 
    -0.04508345f, 0.09914418f, -0.04969019f, 0.11438841f, -0.08710464f, -0.02424802f, -0.01253657f, -0.01854168f, 
    0.09733534f, 0.13711709f, 0.00893741f, 0.12920155f, 0.16440555f, -0.29258004f, -0.31923553f, -0.02642392f, 
    0.18464133f, -0.05007869f, 0.07929676f, 0.06156771f, 0.05796194f, 0.00337455f, -0.00917297f, -0.02042446f, 
    -0.04095907f, 0.02270539f, 0.05282394f, 0.09683617f, 0.01886630f, -0.05618367f, -0.05400884f, -0.18368866f, 
    -0.10037786f, -0.11770626f, -0.03493286f, 0.08143295f, -0.01828202f, -0.05485566f, -0.00451545f, 0.05081973f, 
    0.05318277f, 0.06287078f, 0.05928865f, 0.02326559f, -0.09301571f, -0.06087568f, 0.01279473f, 0.00453953f, 
    0.02084713f, 0.01158921f, 0.03464420f, -0.00388478f, 0.09652171f, 0.04646067f, 0.03226289f, 0.00583615f, 
    0.02499580f, 0.07368279f, 0.04176993f, -0.03049712f, -0.04870856f, 0.01859037f, 0.09880560f, 0.01745569f, 
    -0.02679428f, 0.06738617f, -0.08012105f, -0.06150015f, -0.05897612f, -0.04095970f, 0.01584730f, 0.04805398f, 
    -0.53250158f, 0.01558578f, 0.27205595f, 0.17998102f, -0.04702997f, 0.02865362f, -0.11450335f, -0.09020598f, 
    -0.07172129f, -0.17457783f, -0.09793096f, -0.06899226f, -0.03844181f, -0.03163844f, -0.05203687f, -0.06450029f, 
    -0.16078477f, -0.11762520f, -0.15535581f, -0.23239388f, 0.02248558f, 0.09409221f, 0.00723637f, 0.02101501f, 
    -0.14745365f, -0.00612048f, 0.08637378f, -0.00606050f, 0.05964515f, -0.06410629f, 0.04392912f, 0.04733110f, 
    0.00555164f, 0.07186989f, 0.09105016f, -0.09378432f, 0.08283746f, -0.01631795f, 0.03482353f, 0.00502606f, 
    0.21814068f, 0.03733440f, -0.10099228f, -0.13848393f, -0.07406340f, -0.07821286f, 0.13585871f, -0.04720284f, 
    0.04278148f, -0.08962183f, 0.08250413f, -0.03045116f, 0.04048234f, 0.03099182f, 0.04750464f, 0.07477664f, 
    0.00086866f, -0.02247320f, 0.10121974f, 0.00800990f, 0.43855929f, -0.18922912f, -0.17350230f, -0.12717503f, 
    -0.04272045f, -0.00533133f, -0.03609486f, -0.10195903f, -0.06629185f, -0.01415664f, 0.01770373f, 0.04434072f, 
    0.02880452f, -0.07868700f, -0.05230849f, -0.03777476f, 0.06443957f, 0.05491096f, 0.09017715f, 0.06717867f, 
    0.17748284f, -0.24763753f, 0.31613055f, -0.03849987f, -0.62554234f, 0.15955648f, -0.33507967f, -0.09187731f, 
    -0.00701396f, -0.07473759f, -0.10110394f, 0.05820918f, 0.00323401f, 0.13735278f, -0.08070266f, 0.04326155f, 
    0.02461527f, 0.01624550f, -0.03545301f, 0.11786073f, -0.03754349f, 0.02907770f, 0.02612497f, -0.04316204f, 
    0.12107249f, 0.01967208f, 0.03690547f, 0.03582668f, 0.00352042f, -0.05826702f, 0.04793016f, 0.08563755f, 
    0.06500322f, 0.00589659f, -0.10870794f, 0.06035031f, -0.03523656f, -0.01081070f, -0.01451704f, 0.01624146f, 
    -0.15366440f, 0.02717218f, 0.23311841f, 0.43036973f, -0.49635568f, 0.02637420f, -0.12943920f, -0.14158657f, 
    0.08139769f, 0.04273555f, 0.05917683f, 0.02165730f, 0.05027027f, 0.01652843f, -0.00584861f, -0.01506908f, 
    0.05801987f, 0.06500157f, 0.13603543f, 0.17541504f, 0.05072606f, 0.09947143f, -0.08211959f, -0.13259900f, 
    0.02290495f, 0.13882862f, 0.06163484f, 0.10702295f, 0.01425975f, -0.02069788f, 0.12792599f, -0.05040060f, 
    -0.02179025f, -0.00264509f, -0.07761420f, 0.07172497f, -0.01205821f, -0.07999066f, -0.02211187f, -0.02290316f, 
    -0.23305024f, -0.23541620f, -0.02282815f, 0.20491648f, -0.32874918f, -0.05091770f, -0.06460629f, -0.10794199f, 
    0.07255501f, 0.08615252f, 0.02169246f, -0.01601088f, 0.03432306f, 0.00698079f, 0.02713583f, 0.03102945f, 
    0.02450470f, -0.04513370f, 0.10637698f, 0.07312408f, -0.31459895f, -0.11494716f, 0.24155739f, 0.07731146f, 
    -0.15963180f, 0.02559221f, -0.12858491f, 0.03840271f, 0.07100453f, 0.16449133f, -0.02791848f, -0.01293404f, 
    0.01521367f, 0.01271439f, -0.06427725f, 0.01669876f, 0.03882158f, 0.02048674f, -0.09747024f, -0.08844804f, 
    0.08527470f, -0.27924231f, 0.02923480f, 0.07980841f, -0.06035993f, 0.00510329f, -0.34182566f, 0.10376809f, 
    -0.00631342f, 0.09242288f, -0.01041496f, 0.05933560f, 0.03003545f, -0.02224301f, 0.05600441f, 0.02633590f, 
    0.05668160f, -0.01912156f, 0.05753357f, 0.08446521f, 0.00242231f, 0.06206784f, 0.02092740f, 0.04765996f, 
    0.20512962f, -0.00670242f, 0.07207572f, -0.00835274f, -0.01864039f, -0.04853377f, 0.00242228f, 0.10076040f, 
    0.02158278f, -0.14233857f, 0.07602339f, 0.03853140f, 0.04819033f, -0.05429797f, -0.01092200f, 0.07132809f, 
    -0.14864409f, 0.39180639f, -0.02309076f, -0.39026862f, -0.06101540f, -0.01736315f, 0.09130712f, 0.03977922f, 
    -0.16265748f, 0.16866627f, -0.00476908f, 0.11301141f, -0.06375844f, -0.08546999f, 0.09119851f, 0.00454271f, 
    0.12565351f, -0.10709143f, -0.07256606f, -0.03835679f, -0.12379048f, 0.02651446f, -0.19267836f, 0.08068466f, 
    0.05476948f, -0.00175151f, 0.13043110f, 0.09583656f, 0.00165745f, -0.10983234f, 0.05173137f, -0.03323230f, 
    0.02198523f, -0.01136552f, -0.00995697f, 0.01343459f, 0.08273356f, -0.10648818f, 0.02737295f, 0.00291948f, 
    0.07075892f, 0.01769807f, 0.33030331f, 0.20433603f, -0.20051655f, 0.11150233f, -0.09325096f, -0.18922727f, 
    -0.10982117f, -0.08749618f, 0.02065185f, 0.05050913f, 0.10378859f, 0.04829692f, 0.06198064f, 0.03549622f, 
    -0.04525511f, -0.02736684f, -0.00777126f, 0.02099585f, -0.22688885f, 0.27733776f, -0.45541006f, -0.23507431f, 
    0.07812377f, 0.17097203f, 0.03445310f, 0.17700882f, -0.00007505f, 0.14582925f, 0.07052445f, 0.00449820f, 
    -0.00644642f, 0.05941256f, -0.03251221f, 0.03237066f, -0.00198437f, -0.04836653f, -0.05717684f, 0.01896473f, 
    0.19348405f, -0.05935521f, -0.56732273f, 0.14933704f, -0.24347025f, -0.05405973f, -0.11671550f, 0.01979832f, 
    -0.02042803f, 0.08076513f, -0.03024323f, -0.04971964f, 0.00216144f, -0.03159671f, -0.05645130f, 0.03187332f, 
    -0.01107054f, -0.05048048f, 0.00262684f, -0.03159180f, -0.15829386f, 0.04952552f, -0.30379975f, 0.03297013f, 
    -0.18232226f, 0.06720128f, -0.01216002f, 0.16970192f, -0.00853711f, -0.04363930f, 0.07012321f, -0.02255846f, 
    0.04173084f, -0.01446895f, -0.04181106f, 0.07241984f, 0.09884422f, 0.02599221f, -0.00516884f, 0.00181539f, 
    -0.43176749f, -0.14171064f, 0.17817712f, 0.04410280f, -0.04014837f, 0.14531261f, -0.13204364f, -0.00385097f, 
    -0.12647721f, -0.25842187f, -0.05185214f, 0.00124794f, 0.02839654f, -0.03100312f, 0.00570690f, -0.00133595f, 
    -0.07760213f, -0.11867550f, -0.02977568f, 0.00715865f, -0.52545500f, 0.07928176f, -0.32069939f, -0.05570667f, 
    -0.08297509f, 0.21926266f, -0.06314530f, -0.01698736f, 0.17521393f, -0.35614759f, 0.01692125f, 0.03098323f, 
    -0.14670596f, -0.07884385f, 0.05089311f, -0.21294287f, -0.21056733f, -0.12334628f, -0.05834974f, -0.06750694f, 
    -0.05806855f, 0.25971460f, 0.18976390f, 0.59511948f, -0.31644896f, 0.05358196f, -0.01508523f, -0.28674170f, 
    0.03339222f, -0.11092279f, 0.10991406f, -0.09742311f, 0.12003405f, -0.00006426f, 0.03453202f, 0.08832888f, 
    0.07738280f, 0.02905808f, 0.07949630f, 0.09454357f, -0.28070232f, -0.50045639f, 0.02278616f, 0.01767572f, 
    -0.09902120f, -0.17938717f, -0.32587984f, 0.14359693f, 0.06017212f, 0.14363067f, 0.02615965f, 0.03740134f, 
    0.04264162f, 0.01141945f, -0.02686547f, 0.00357594f, 0.04929871f, 0.03232303f, 0.10023584f, 0.02303439f, 
    0.07741381f, -0.02965810f, -0.14434399f, -0.01587378f, -0.05801284f, 0.18154088f, 0.06070636f, 0.15843141f, 
    -0.03035167f, -0.00400589f, -0.00138975f, -0.05869504f, -0.05698616f, -0.09084764f, -0.08183112f, 0.04416732f, 
    -0.07628552f, -0.03944952f, -0.03538170f, -0.03065578f, 0.03687037f, -0.12625235f, -0.17681853f, 0.01436147f, 
    0.16866280f, -0.14283720f, 0.11183391f, 0.11321864f, 0.02018997f, 0.04020644f, 0.05448552f, 0.08395825f, 
    -0.01898163f, -0.08442932f, 0.03336004f, 0.01773723f, 0.01808510f, 0.04320463f, -0.01841778f, 0.00363342f, 
    0.06953190f, -0.79316103f, -0.57430792f, -0.00927616f, -0.03081800f, -0.17339690f, 0.07016088f, 0.06951513f, 
    0.09888519f, -0.04878028f, -0.00391690f, 0.02537222f, -0.03170589f, -0.01357951f, -0.01256370f, 0.00131826f, 
    0.13822669f, -0.06663663f, 0.04575951f, 0.13556962f, -0.19842304f, 0.03267928f, -0.01017308f, 0.18105198f, 
    0.12005973f, -0.06582242f, 0.06137303f, 0.03280743f, -0.01009807f, -0.06181841f, 0.03495731f, 0.00968289f, 
    0.00240860f, -0.15011656f, 0.00771730f, -0.03602041f, 0.02754785f, -0.03839742f, 0.04794348f, 0.14121914f, 
    0.00418223f, 0.18562756f, -0.58223212f, 0.17839873f, -0.00186447f, -0.00527359f, 0.14548880f, 0.27030441f, 
    0.03418766f, 0.10767339f, 0.04891850f, -0.03359550f, -0.06262478f, -0.05642297f, -0.02914373f, 0.06586646f, 
    0.03402844f, -0.13449183f, 0.00349696f, -0.05678867f, -0.07500936f, 0.07878866f, -0.39420378f, 0.01375891f, 
    -0.00050409f, 0.11545838f, 0.09290507f, 0.21014811f, 0.00557286f, 0.09410884f, 0.08066151f, 0.00075547f, 
    0.00588835f, 0.01299330f, -0.05961715f, 0.03682365f, -0.03142868f, 0.00234224f, -0.01417309f, -0.00457124f, 
    -0.37754011f, -0.07927806f, -0.23816250f, 0.05263544f, -0.01577546f, 0.08122981f, 0.08335618f, 0.05817311f, 
    0.04311720f, 0.09136309f, 0.04638956f, 0.00981426f, 0.06522515f, 0.02582020f, -0.01240692f, 0.07668594f, 
    0.02352609f, 0.06524994f, 0.18785696f, 0.11887544f, 0.07009409f, -0.12963142f, 0.03223142f, -0.01566735f, 
    0.13747351f, -0.03288827f, 0.00295915f, 0.03297663f, 0.03315940f, -0.00721697f, -0.01120775f, 0.05505873f, 
    0.10852656f, -0.03611829f, 0.04154685f, 0.13492896f, 0.02457561f, -0.00719775f, -0.00108226f, -0.01446771f, 
    -0.03792527f, 0.23625802f, 0.09394398f, 0.12905163f, 0.09198762f, -0.02242947f, -0.09466518f, -0.12729527f, 
    -0.04497918f, -0.11055491f, 0.06319883f, 0.05868001f, 0.06964039f, 0.01066054f, -0.11350694f, 0.01159218f, 
    -0.04748456f, -0.09674578f, -0.01199183f, 0.00669429f, -0.06668403f, 0.03046192f, -0.04743862f, 0.07244821f, 
    -0.04637501f, -0.09881233f, 0.01114828f, -0.00779432f, -0.08714589f, -0.07461134f, 0.00467962f, 0.03349866f, 
    -0.01492895f, 0.00022905f, -0.03849634f, 0.07123996f, -0.06271396f, -0.10890225f, 0.05051085f, 0.01582496f, 
    -0.15864444f, -0.10916489f, -0.31204969f, -0.05995547f, -0.14251815f, 0.05929863f, -0.06542339f, 0.01628971f, 
    -0.00501879f, 0.13550168f, 0.01767672f, -0.02918010f, -0.04262598f, -0.06602529f, -0.04689881f, 0.06799368f, 
    -0.06007757f, 0.04790954f, 0.06512986f, -0.08782931f, -0.15641508f, -0.16620822f, -0.31375930f, -0.07072895f, 
    0.16615760f, 0.10267710f, 0.05183439f, 0.13136880f, 0.03360336f, -0.04465047f, 0.00724721f, -0.05139094f, 
    0.01364000f, 0.02049045f, -0.04270167f, 0.08283993f, 0.02647257f, -0.05326689f, 0.05519639f, 0.02998211f, 
    0.10209382f, 0.03256538f, -0.32673779f, 0.13455620f, -0.10704372f, 0.03402834f, -0.15456346f, 0.10873917f, 
    -0.00339122f, -0.04299321f, -0.09472816f, 0.13512103f, -0.06515563f, 0.04461636f, 0.01284118f, 0.07068779f, 
    -0.03695912f, 0.12499477f, -0.06055270f, 0.14378126f, -0.10635899f, 0.00810489f, -0.19528994f, 0.06842959f, 
    0.12696999f, 0.08389612f, 0.02161417f, 0.11059188f, 0.00323893f, -0.05103125f, -0.01404861f, -0.04542486f, 
    -0.00704444f, -0.01821435f, -0.00288161f, 0.08780515f, 0.06256435f, -0.02803633f, 0.02249595f, 0.03073947f, 
    0.28424698f, -0.27672243f, -0.34390086f, -0.01679091f, -0.18770941f, 0.12050890f, 0.00964826f, 0.09530671f, 
    -0.09428610f, 0.04132547f, -0.01461170f, -0.06511633f, -0.09765081f, -0.04508946f, -0.02764366f, 0.06953240f, 
    -0.04897351f, -0.08284268f, -0.13782071f, -0.02046410f, -0.07471184f, 0.21994221f, 0.10641633f, 0.22633471f, 
    -0.02593839f, 0.09139105f, -0.04619582f, -0.09961474f, -0.19127332f, -0.02359385f, 0.01065719f, 0.02788211f, 
    0.05633389f, 0.04237995f, 0.04897974f, 0.05828578f, 0.00940593f, -0.05875941f, 0.01804253f, 0.04273270f, 
    -0.12776044f, -0.26416281f, -0.02951840f, -0.17070642f, -0.06227262f, 0.05084191f, -0.01887169f, -0.00828261f, 
    -0.07872788f, -0.07878243f, 0.08535539f, -0.06147156f, -0.00327295f, 0.10332102f, -0.07996814f, 0.01994508f, 
    0.05015312f, -0.03717752f, -0.09083083f, 0.06119044f, -0.07503673f, 0.18383905f, 0.19649087f, 0.48901698f, 
    -0.32444647f, 0.06336182f, -0.11108150f, -0.13611130f, 0.06700613f, -0.11562147f, 0.02458827f, -0.01507599f, 
    0.10295565f, -0.01600229f, 0.09900518f, 0.08105734f, 0.00451303f, -0.04198875f, 0.02543428f, 0.04558357f, 
    -0.44135392f, 0.17003126f, -0.06286937f, 0.26703504f, -0.46323431f, 0.04765900f, -0.30105862f, -0.17172641f, 
    -0.11472969f, -0.09161563f, -0.02993941f, -0.00224197f, -0.04156170f, -0.00521914f, 0.00570823f, -0.11522128f, 
    -0.06739975f, 0.02739131f, 0.04474507f, -0.02052983f, -0.19583163f, -0.10113932f, -0.16946639f, 0.14195140f, 
    -0.09670791f, -0.26589024f, 0.21337855f, -0.28737754f, -0.13303974f, -0.11433677f, 0.08885297f, -0.13475473f, 
    0.03971872f, 0.05705846f, 0.08812783f, 0.05898282f, 0.01421718f, 0.02357596f, -0.06337677f, -0.06493191f, 
    -0.03741468f, -0.22178319f, -0.00892331f, -0.31618273f, 0.15178987f, 0.00737825f, -0.01348270f, 0.11250391f, 
    0.01504760f, 0.03050259f, -0.03635361f, 0.07300416f, -0.03521342f, -0.03951806f, -0.04597991f, 0.06553358f, 
    0.12778135f, -0.00247991f, -0.02573267f, 0.08379839f, -0.37041795f, 0.05924553f, -0.34556836f, -0.11578088f, 
    -0.08638083f, 0.12093183f, -0.08959755f, 0.12803787f, -0.03722971f, 0.05785745f, 0.02275907f, -0.03644583f, 
    -0.02544097f, 0.07557392f, -0.02962295f, -0.04706878f, 0.01015266f, 0.02666115f, -0.03140205f, 0.05360725f, 
    -0.04594998f, 0.18329333f, 0.19935268f, -0.43150985f, -0.01924026f, -0.12266564f, 0.01351812f, 0.03322209f, 
    0.11147884f, 0.10997780f, 0.02022801f, 0.03918399f, -0.04884894f, -0.12420213f, -0.06264351f, 0.06127832f, 
    0.11738247f, -0.08371859f, 0.01544343f, -0.03979348f, -0.14486037f, -0.24127226f, 0.05756540f, 0.16655332f, 
    -0.47125006f, -0.17173699f, 0.05721056f, -0.12909159f, 0.00269919f, 0.10656758f, 0.07364667f, -0.03075336f, 
    0.04938351f, 0.01705601f, 0.00315201f, -0.03970588f, 0.01736614f, 0.07890328f, 0.00356480f, -0.06446736f, 
    -0.04834466f, 0.05832238f, 0.09389235f, 0.28310597f, -0.12983251f, 0.03721104f, 0.02089035f, -0.24423932f, 
    -0.09635340f, -0.21365225f, 0.11273292f, 0.00832545f, 0.02763532f, 0.13321626f, 0.02021514f, 0.05914119f, 
    0.01841083f, -0.02754199f, 0.00205823f, -0.02072051f, -0.97684783f, -0.01651499f, -0.41662577f, -0.08104638f, 
    0.09237735f, 0.00143809f, -0.05797728f, -0.05676464f, -0.23449753f, 0.06735612f, 0.02602878f, -0.06938380f, 
    0.05587247f, 0.05333120f, 0.03886857f, 0.07685341f, 0.04301145f, -0.08655304f, 0.08707848f, 0.03131017f, 
    -0.17846280f, 0.19198671f, 0.02723990f, -0.03972052f, -0.01911860f, -0.07933044f, -0.11335663f, -0.10751019f, 
    -0.06097414f, -0.00859738f, 0.06583098f, 0.04285848f, 0.07567638f, 0.05552407f, -0.03615273f, -0.01731767f, 
    -0.02587013f, -0.01255005f, -0.07597674f, 0.04291752f, -0.18770888f, -0.00919416f, 0.12522413f, -0.22376829f, 
    -0.05240929f, -0.17678967f, -0.02002505f, 0.00245682f, -0.06413392f, -0.09939575f, 0.15745062f, -0.07115042f, 
    -0.01938416f, -0.01484387f, 0.03552688f, -0.05738230f, -0.18989664f, -0.04675877f, -0.09006570f, -0.09414475f, 
    -0.03245810f, 0.15159979f, 0.28951544f, -0.19866700f, -0.11794751f, 0.04838279f, -0.16173038f, 0.00385462f, 
    -0.01277572f, 0.04363862f, -0.01152971f, 0.05369693f, 0.01652046f, -0.04524536f, 0.03540478f, 0.02723410f, 
    -0.04972580f, -0.03664322f, -0.03994286f, 0.00402083f, 0.02747753f, -0.48783720f, -0.11185057f, -0.07805598f, 
    -0.12456104f, -0.20731983f, 0.16631316f, -0.04122576f, -0.00159668f, 0.04100430f, 0.08561350f, -0.03250937f, 
    0.02430740f, 0.08060589f, -0.01869055f, 0.10744654f, 0.10757189f, -0.03386106f, -0.08051580f, -0.08227235f, 
    0.00407754f, 0.10105450f, 0.25394511f, 0.28147864f, -0.28253463f, 0.18003967f, -0.10383663f, -0.20244864f, 
    -0.20687278f, -0.11906228f, 0.03150493f, -0.02820522f, 0.11744967f, 0.06868907f, 0.01519610f, 0.01499071f, 
    0.00386224f, 0.01430045f, 0.00277219f, 0.01119460f, -0.31006557f, -0.09160713f, 0.22827263f, 0.05062678f, 
    -0.15605311f, 0.03583289f, -0.22100797f, 0.06606122f, 0.08109872f, 0.10023681f, 0.00066745f, -0.00627071f, 
    0.00813418f, -0.05195096f, -0.03362087f, -0.01561112f, 0.00903165f, 0.00591742f, -0.03848489f, -0.07081632f, 
    0.03142975f, -0.33685225f, 0.18977678f, 0.01828117f, -0.20090194f, -0.16516018f, 0.00501849f, -0.08248467f, 
    0.06929872f, 0.16289026f, 0.05823935f, 0.01738155f, 0.02836203f, -0.00839246f, -0.03435046f, -0.04073512f, 
    0.02292921f, 0.04130188f, 0.10479828f, 0.01995672f, 0.09071390f, 0.16595194f, 0.16625461f, 0.01746558f, 
    -0.05621514f, -0.00424371f, -0.14565302f, -0.15210427f, 0.01124885f, -0.08375859f, -0.05068874f, 0.07600562f, 
    0.07867043f, 0.10665573f, 0.05309166f, 0.03661922f, 0.01133996f, 0.00989878f, -0.00546653f, 0.05037631f, 
    0.05671543f, 0.19274680f, -0.38472077f, 0.00828600f, -0.17058308f, 0.03421004f, -0.03828894f, 0.08555222f, 
    0.00901574f, 0.01408789f, 0.00222678f, -0.00106766f, 0.03852240f, -0.04095646f, -0.04417801f, -0.00705879f, 
    0.02616853f, 0.02319432f, 0.06806648f, -0.07040592f, -0.51755732f, 0.15281817f, -0.01403201f, 0.21276534f, 
    0.14762063f, -0.04414535f, 0.05734435f, -0.15880363f, 0.05541693f, -0.07793313f, 0.03492677f, 0.01784327f, 
    -0.03453408f, -0.05987990f, -0.05006042f, 0.10262684f, -0.09836441f, -0.04865856f, -0.07158664f, -0.03911973f, 
    -0.01578694f, 0.16024850f, -0.00856650f, -0.11841611f, 0.15130481f, 0.03080747f, 0.01506407f, -0.08371371f, 
    -0.01263378f, -0.12877454f, -0.05398530f, -0.00567785f, 0.02226875f, -0.06022743f, 0.02522860f, 0.07728360f, 
    -0.02247775f, 0.00496628f, -0.00004055f, 0.13134991f, -0.09100670f, -0.05755731f, -0.24194103f, -0.08903233f, 
    0.16264090f, -0.06565865f, 0.07363460f, 0.14577165f, 0.03887732f, -0.02446412f, -0.02889605f, -0.01704369f, 
    0.02305897f, -0.03556926f, -0.00600476f, 0.02808397f, 0.10282756f, 0.04811910f, 0.04854649f, 0.06251075f, 
    0.06821826f, 0.01862196f, 0.33864185f, -0.22876848f, -0.24123175f, 0.02221970f, 0.00536910f, 0.04466335f, 
    -0.02496365f, 0.07291185f, -0.02363938f, -0.10466243f, 0.02707743f, -0.04553708f, 0.03287795f, -0.01390519f, 
    -0.04333513f, -0.02533109f, -0.08716498f, -0.11228442f, 0.17065568f, -0.12511602f, -0.03143840f, 0.01470057f, 
    -0.36288831f, -0.07494775f, -0.05496361f, -0.01237366f, 0.12994730f, 0.02389943f, -0.02429690f, 0.02253454f, 
    0.03213767f, -0.00943745f, 0.06245692f, -0.00316630f, 0.08448594f, 0.14950760f, 0.01386063f, 0.09719200f, 
    0.18774569f, 0.08007040f, 0.07987546f, 0.13982072f, -0.07123021f, -0.09797040f, 0.01074521f, -0.13130929f, 
    -0.07834795f, -0.07309450f, 0.00699244f, -0.05817233f, 0.00360855f, 0.03607491f, -0.02134999f, 0.03607617f, 
    -0.00545353f, 0.02883363f, -0.11573263f, 0.00186221f, -0.08603545f, -0.15227918f, -0.20777357f, -0.20323600f, 
    -0.12131573f, 0.03025685f, -0.06740079f, 0.07939371f, 0.01604700f, -0.10953250f, -0.05164540f, 0.07143874f, 
    -0.00316286f, -0.09204163f, 0.07512971f, 0.04769656f, 0.06220649f, 0.07948507f, -0.06157114f, -0.00787150f, 
    -0.01654908f, 0.00509427f, -0.61919355f, 0.13464454f, 0.19980560f, 0.12555654f, 0.06105081f, 0.20289832f, 
    0.00421905f, 0.16317244f, 0.01819546f, 0.01297386f, -0.04020888f, -0.00237963f, -0.04726891f, -0.01711887f, 
    0.06700710f, 0.06874308f, -0.02723824f, 0.03308355f, -0.17738667f, -0.00649921f, 0.03352638f, -0.08303639f, 
    0.13028122f, -0.06978254f, 0.13065660f, -0.20701805f, -0.01089589f, 0.04444921f, 0.04450196f, 0.03033936f, 
    -0.04166028f, -0.03412025f, 0.00175951f, 0.14612740f, 0.03465430f, -0.10766367f, -0.04670586f, 0.04261585f, 
    -0.47244915f, 0.11915115f, -0.09622148f, 0.20035483f, 0.00782714f, 0.08486991f, -0.01517124f, -0.01406403f, 
    -0.10623038f, -0.11303258f, 0.05928143f, 0.06197957f, 0.03671919f, -0.06429520f, 0.03279575f, 0.00918273f, 
    -0.07701012f, -0.11066739f, 0.05709170f, 0.08325248f, -0.31813231f, 0.09797563f, -0.01420998f, 0.09848462f, 
    -0.13311793f, 0.05696243f, -0.03827711f, -0.06969754f, -0.09899555f, -0.04031492f, 0.06947804f, -0.03034137f, 
    0.05034748f, -0.04225410f, -0.04804739f, 0.07424689f, -0.04613528f, -0.10563485f, 0.01228578f, -0.08330628f, 
    -0.17515208f, 0.16918226f, 0.08943312f, 0.22638147f, 0.14921604f, -0.01085575f, -0.02339591f, 0.01833997f, 
    -0.01646113f, 0.02885023f, 0.04249276f, -0.03578833f, 0.01763703f, 0.04415606f, 0.01847088f, -0.07832889f, 
    -0.09891753f, 0.03790157f, -0.06328007f, -0.01358067f, -0.05070698f, -0.20014071f, -0.08720917f, 0.08000904f, 
    -0.10807946f, -0.00885272f, -0.06226553f, -0.07532063f, 0.00314759f, 0.04262221f, -0.04204008f, -0.01231492f, 
    0.01368919f, -0.02043718f, 0.01903341f, -0.01232282f, -0.00549867f, 0.02427147f, 0.07760247f, 0.04101397f, 
    -0.23589003f, 0.05954462f, -0.33996019f, -0.02173017f, 0.00880420f, 0.05478783f, -0.03262530f, 0.06163487f, 
    -0.04911281f, 0.01969770f, -0.05794549f, 0.03474406f, -0.01716196f, -0.00638932f, -0.00449071f, 0.00958157f, 
    -0.09954746f, 0.02775389f, -0.12535681f, -0.07991743f, -0.21943244f, -0.23542070f, 0.09093110f, 0.02706657f, 
    -0.03884248f, 0.00724851f, 0.00759492f, -0.01414730f, 0.04822974f, -0.04929222f, -0.13343565f, -0.00817790f, 
    0.03051539f, -0.05110011f, -0.07184430f, 0.01357080f, 0.05869775f, 0.08327561f, 0.07170320f, 0.09778950f, 
    -0.19358647f, 0.05631203f, -0.24419220f, -0.03541175f, 0.06342891f, 0.02894553f, -0.04781276f, 0.06984825f, 
    -0.09582809f, 0.11835065f, -0.08203678f, 0.02273387f, -0.07065175f, 0.03605236f, 0.01948409f, 0.08931197f, 
    -0.10110802f, -0.05176296f, -0.09680606f, -0.09851010f, -0.28479072f, 0.01972156f, -0.12940083f, -0.05752780f, 
    0.11350594f, -0.09945119f, -0.02907476f, -0.03778779f, -0.02832832f, -0.12922458f, -0.02867051f, 0.02094817f, 
    0.04194064f, 0.01429615f, 0.01600879f, 0.05207864f, 0.01511382f, -0.06772797f, 0.05524858f, 0.05140312f, 
    -0.31017390f, -0.00722651f, 0.06771381f, -0.08241241f, 0.02278868f, 0.04462122f, -0.04820675f, -0.16500859f, 
    0.06675871f, -0.10223341f, -0.03621262f, 0.06608318f, 0.04583810f, 0.00623163f, 0.08870277f, 0.05605607f, 
    -0.04450917f, -0.07060299f, -0.24260883f, -0.18521744f, 0.02630174f, -0.16915321f, 0.06477191f, -0.00879810f, 
    -0.14590536f, -0.02369573f, -0.02195605f, -0.04746263f, 0.00975965f, 0.03446969f, -0.06461986f, -0.00870048f, 
    0.01568562f, -0.05984572f, 0.08054182f, -0.04869405f, -0.05221060f, 0.01871955f, -0.02246747f, 0.00282357f, 
    0.10186317f, -0.11856017f, 0.22812858f, 0.32460153f, -0.03282734f, -0.15773396f, 0.01762333f, 0.27992728f, 
    -0.05384799f, -0.09427160f, 0.06023895f, -0.09663732f, -0.10028616f, 0.09743437f, 0.03280041f, -0.07514738f, 
    0.06382336f, 0.27086073f, -0.07889846f, 0.13267709f, -0.14067693f, -0.19647476f, 0.11685123f, -0.10695330f, 
    -0.02194603f, -0.01609805f, -0.07146654f, 0.08581524f, 0.08650724f, -0.02238719f, -0.05270424f, -0.03353124f, 
    0.04834777f, -0.02860060f, 0.02797458f, 0.10551926f, -0.04027199f, 0.09517689f, 0.02967574f, 0.00656115f, 
    -0.04273383f, -0.01566164f, 0.08349675f, 0.02031640f, 0.01384688f, -0.03304335f, 0.02065160f, -0.09898471f, 
    0.02599132f, 0.05640694f, 0.01597107f, -0.00000991f, -0.01042449f, -0.05769586f, -0.02069217f, -0.01189238f, 
    0.01695689f, 0.00618630f, 0.05814941f, 0.04462149f, -0.06467146f, -0.25305662f, 0.06792249f, 0.04345383f, 
    -0.11444255f, -0.12714450f, -0.04452470f, 0.05771725f, -0.02470328f, -0.12625968f, -0.06248116f, 0.04593879f, 
    -0.03787345f, -0.06582620f, -0.08680599f, 0.00108639f, 0.02134890f, 0.05324763f, -0.02779994f, -0.05256814f, 
    -0.58829832f, -0.00907005f, -0.28851995f, -0.08239440f, -0.02775058f, 0.06059860f, -0.15590008f, 0.17358005f, 
    0.07701203f, 0.19324274f, -0.08134513f, 0.15807012f, 0.00927747f, 0.06184589f, -0.01755618f, 0.09299645f, 
    -0.03070210f, -0.02420415f, -0.01364009f, -0.00420891f, -0.13909730f, -0.24091657f, -0.09359400f, 0.03930000f, 
    -0.18149513f, -0.07089909f, -0.17571847f, -0.07117304f, 0.06450713f, -0.01029969f, -0.12264787f, 0.04887457f, 
    -0.00537039f, -0.06354450f, -0.07404026f, 0.08562001f, -0.03487714f, 0.04451218f, 0.10471293f, 0.02142326f, 
    -0.56261063f, -0.09732902f, 0.14547201f, -0.07207574f, 0.06625853f, 0.02875141f, 0.04396973f, -0.05685183f, 
    0.31725347f, -0.02592509f, 0.06291001f, -0.06094363f, -0.03724501f, 0.02546044f, 0.09902008f, 0.02840134f, 
    -0.02806386f, 0.01912974f, 0.07084471f, -0.05462770f, 0.03537163f, -0.28442058f, 0.27808028f, 0.26118055f, 
    0.09828012f, -0.27808458f, 0.10118762f, -0.04755691f, -0.06215918f, -0.18984759f, -0.08654653f, -0.05046507f, 
    0.00265357f, 0.22121790f, -0.00838244f, -0.06049331f, 0.13922128f, 0.03441801f, -0.00328011f, 0.08906727f, 
    0.07682867f, 0.00509403f, 0.09783532f, -0.03351727f, -0.04162612f, 0.08332264f, 0.05439637f, -0.01384843f, 
    0.06865780f, 0.05223698f, -0.08605602f, 0.03226731f, -0.09297257f, -0.16244327f, -0.22890504f, 0.02496734f, 
    -0.13500550f, 0.05681697f, -0.10782740f, -0.08121570f, -0.36334395f, 0.07619960f, -0.61676973f, 0.09602803f, 
    0.01038031f, -0.08773620f, -0.12390603f, -0.12302488f, -0.06989993f, -0.03314938f, -0.00926726f, 0.09898511f, 
    0.05543651f, 0.03118233f, -0.01182303f, 0.03943170f, -0.03255698f, -0.20038392f, -0.01597433f, -0.12526317f, 
    -0.32024980f, -0.25505295f, -0.13405867f, 0.02759100f, -0.05222491f, 0.08107229f, -0.03292279f, -0.01066673f, 
    0.15104461f, 0.02687845f, -0.12508743f, -0.00900145f, 0.05833506f, -0.02714152f, -0.04632147f, 0.08204233f, 
    0.05952244f, 0.00528168f, 0.13768698f, 0.12822141f, 0.06290235f, -0.17977621f, 0.00268080f, -0.03944786f, 
    -0.22278130f, -0.05147839f, -0.10548982f, -0.01024837f, -0.05617325f, -0.06385507f, -0.04747897f, 0.01255379f, 
    -0.07014778f, 0.01545264f, 0.06745817f, -0.06531319f, 0.03429853f, -0.02230715f, -0.06449515f, 0.01227603f, 
    -0.23935722f, -0.05853144f, -0.12251464f, 0.09530303f, 0.09708052f, 0.05451814f, -0.04266248f, 0.04847240f, 
    0.13507141f, 0.09319124f, -0.05309584f, 0.02139649f, -0.05956512f, 0.03201264f, 0.00060190f, 0.11404535f, 
    -0.28312460f, -0.04601819f, -0.11082396f, 0.08090697f, 0.14416525f, -0.22226116f, 0.14130282f, 0.00244189f, 
    -0.03154487f, -0.01425477f, -0.01872688f, -0.01976273f, 0.00239838f, -0.03535575f, 0.00174152f, -0.02148346f, 
    -0.08034763f, 0.13763069f, -0.04243468f, -0.03765328f, -0.04183662f, 0.06831598f, -0.09003365f, -0.05794886f, 
    -0.13268153f, -0.25609809f, -0.20012026f, -0.07034217f, -0.02787702f, 0.01160058f, -0.09031440f, 0.15711467f, 
    -0.08443625f, -0.08390779f, -0.08628631f, 0.12337644f, -0.03365969f, -0.01891554f, 0.03252443f, 0.03562986f, 
    -0.06111696f, 0.02247234f, -0.02029732f, 0.09040841f, -0.06304900f, -0.34288028f, -0.06751611f, -0.07673795f, 
    -0.06987767f, -0.18716669f, -0.17943332f, 0.05782247f, -0.02278030f, -0.08053637f, -0.07917557f, 0.06720422f, 
    -0.03016131f, -0.08747926f, -0.00860905f, -0.01094551f, -0.08845265f, -0.03758046f, -0.00112822f, -0.00713591f, 
    0.02724427f, -0.01497903f, 0.01917146f, 0.09030595f, 0.07109988f, -0.02104070f, 0.07388274f, 0.03818770f, 
    -0.02936336f, -0.12792994f, -0.01073697f, -0.02221615f, 0.05321312f, -0.02378226f, 0.02811369f, 0.18935443f, 
    -0.15015890f, -0.22538266f, -0.21926072f, -0.24474347f, 0.00135750f, -0.15267475f, -0.21408817f, 0.14959793f, 
    -0.08367266f, -0.07020984f, 0.02822931f, -0.06661728f, -0.02954544f, 0.04971924f, -0.14243212f, 0.08636112f, 
    -0.08862706f, 0.03401164f, 0.08453596f, -0.11358736f, 0.02599012f, 0.01685874f, 0.08058435f, 0.08403739f, 
    0.14089869f, -0.18693013f, 0.15788244f, -0.06305388f, -0.05509391f, 0.05239010f, -0.00562879f, -0.12724464f, 
    0.02600668f, 0.04716936f, -0.04967621f, -0.02732825f, -0.04044073f, 0.01059420f, -0.12229393f, -0.00594417f, 
    -0.04387071f, 0.00634961f, 0.11343616f, -0.01847558f, -0.04107377f, -0.03518022f, 0.10475916f, 0.08149126f, 
    0.00206111f, -0.03707495f, 0.02603723f, 0.05794750f, 0.03676064f, -0.04170716f, -0.00347702f, -0.03018186f, 
    -0.02825606f, 0.06302044f, -0.04737732f, 0.03800631f, 0.03699649f, 0.07947443f, 0.08421516f, 0.04958193f, 
    -0.20051716f, -0.05522142f, 0.08394990f, 0.20062023f, 0.09519617f, -0.18537512f, 0.02243038f, 0.20087044f, 
    -0.14307262f, -0.11299906f, -0.00144715f, 0.07669954f, -0.00485712f, 0.13282639f, 0.05940500f, 0.07858478f, 
    -0.02609404f, 0.06001307f, -0.14068310f, -0.02090457f, -0.04876714f, -0.13913949f, 0.03834384f, 0.00004364f, 
    -0.01603419f, -0.07280307f, -0.02023502f, -0.00305078f, 0.01278372f, -0.13533904f, -0.09707566f, 0.05590876f, 
    0.05907286f, 0.01764566f, 0.02824714f, -0.00477261f, -0.02924845f, -0.08370936f, -0.12101530f, -0.08442697f, 
    -0.30254745f, 0.00830310f, 0.07476076f, -0.07533321f, -0.03856371f, -0.02927749f, 0.01037505f, -0.01813534f, 
    -0.00544401f, -0.06739714f, 0.11059374f, 0.02910356f, -0.09082064f, 0.14485618f, -0.02306446f, 0.05877487f, 
    -0.24746522f, -0.02997593f, -0.13558467f, -0.17340390f, -0.08703791f, -0.07126014f, 0.05039551f, 0.03427981f, 
    -0.02357491f, -0.01369050f, -0.04672519f, -0.01081945f, -0.01448702f, -0.11339863f, -0.03696750f, 0.05446574f, 
    0.02389050f, 0.01381952f, 0.00565051f, 0.08812162f, 0.00458162f, -0.03242631f, -0.05785558f, -0.11435521f, 
    -0.42686942f, -0.06743702f, -0.09268407f, 0.27609575f, -0.02420923f, 0.01647930f, -0.08580950f, 0.15062591f, 
    0.30420381f, 0.11694878f, -0.11936999f, 0.07694559f, 0.01623449f, -0.03281167f, -0.02027441f, 0.02859855f, 
    -0.05771307f, 0.02527148f, 0.24663217f, 0.28682485f, 0.29803681f, -0.14493403f, 0.14420766f, -0.15026008f, 
    -0.11323750f, -0.01164479f, 0.00233132f, -0.02248149f, 0.11542480f, 0.01225704f, 0.00208243f, 0.07367838f, 
    0.01764451f, -0.08924577f, -0.11309820f, -0.02184315f, 0.02527234f, 0.07583129f, 0.07740916f, -0.06307900f, 
    -0.30448008f, 0.18752986f, -0.03033206f, 0.20645498f, 0.07985459f, -0.02767703f, -0.08059303f, 0.00103909f, 
    0.29131377f, 0.08105839f, -0.09556726f, -0.00115709f, 0.02950072f, -0.07108828f, 0.04790977f, -0.11385890f, 
    0.05211755f, -0.08076996f, 0.21459411f, 0.14633663f, -0.10599114f, 0.01383804f, 0.12561499f, -0.04935369f, 
    -0.06139014f, 0.03883195f, 0.01473712f, -0.02638132f, 0.10956302f, 0.00620912f, -0.00220873f, -0.04711801f, 
    -0.04153065f, -0.09312315f, -0.17452237f, 0.00576626f, -0.10611511f, 0.06810717f, -0.10881822f, -0.08076873f, 
    0.01110019f, -0.05860612f, 0.21018493f, -0.00877975f, 0.14469765f, -0.02599707f, 0.07543108f, -0.03919280f, 
    0.12664546f, 0.02883632f, -0.00173249f, -0.02407647f, -0.05188283f, -0.00147768f, -0.06648632f, 0.04745709f, 
    0.05582549f, 0.07144921f, 0.10070273f, -0.01895474f, 0.12164315f, 0.16541877f, 0.07279414f, -0.01400686f, 
    0.15748213f, 0.15166517f, 0.01300399f, -0.01350958f, -0.06058001f, 0.10550325f, -0.19210264f, 0.11460154f, 
    0.02117738f, -0.05263969f, -0.02880030f, 0.01658164f, 0.02719175f, -0.10531258f, 0.01629311f, 0.06889752f, 
    -0.07260112f, -0.10501120f, 0.18211371f, -0.08856647f, -0.21032538f, -0.01043404f, -0.00555291f, -0.02732922f, 
    0.00692641f, -0.10132161f, -0.02562516f, 0.05718029f, -0.10795628f, 0.10045518f, -0.01822980f, -0.03619917f, 
    0.07786306f, 0.07353551f, -0.09549223f, -0.10852277f, 0.01628428f, -0.24232784f, -0.02585510f, 0.00523651f, 
    -0.07065149f, -0.25554603f, -0.14128578f, -0.03824662f, 0.02118921f, -0.07161388f, -0.12413591f, 0.02534996f, 
    -0.02542590f, 0.00539820f, -0.04295013f, 0.05525311f, -0.11746402f, 0.01037672f, 0.04176408f, -0.07703575f, 
    0.01660008f, -0.07901873f, 0.16711889f, 0.14513157f, -0.09489939f, 0.04846421f, 0.01308681f, 0.15146749f, 
    0.05336836f, -0.05284496f, -0.02436149f, -0.01690699f, 0.04684664f, 0.02535715f, 0.10692211f, -0.04317968f, 
    -0.09868588f, 0.17808492f, -0.05094444f, 0.06667194f, -0.19222902f, 0.04326550f, -0.36810344f, 0.02984793f, 
    0.08746792f, 0.02271563f, -0.08257231f, -0.06331021f, -0.07972828f, 0.03235252f, -0.00864909f, 0.03071683f, 
    -0.04604406f, -0.03376387f, -0.02949340f, 0.03756957f, 0.00546585f, 0.00571783f, -0.00905471f, -0.04393829f, 
    0.04568879f, 0.05057703f, 0.09941509f, -0.11953855f, -0.03266418f, 0.03502783f, 0.02569761f, -0.06140063f, 
    0.02089919f, 0.03201916f, -0.07353409f, 0.10161562f, -0.05248615f, -0.03213925f, -0.06407078f, -0.02781348f, 
    0.00057384f, -0.02836557f, 0.03819097f, -0.00822399f, 0.33083239f, -0.51161569f, 0.37306651f, 0.14089265f, 
    0.13801491f, -0.08590642f, 0.01052024f, 0.22093315f, 0.09169196f, -0.05526105f, -0.03591270f, 0.02802639f, 
    -0.22172165f, 0.00117222f, -0.01929959f, -0.07399205f, 0.16024847f, 0.15896779f, -0.07640747f, -0.04596791f, 
    0.02241221f, 0.01278013f, -0.19468004f, 0.06713334f, -0.09640774f, 0.05091472f, 0.06369647f, 0.11959993f, 
    -0.02976279f, 0.07812244f, -0.08587717f, 0.00626287f, -0.00449419f, 0.06190112f, -0.21105053f, 0.02880710f, 
    0.06032478f, 0.24233045f, 0.10109648f, -0.00390983f, -0.34896818f, 0.04636142f, 0.06478592f, 0.00654566f, 
    0.05060896f, 0.15571575f, 0.05996214f, -0.13432734f, -0.07822277f, 0.13388689f, -0.03986143f, -0.20862433f, 
    0.01795089f, -0.13030145f, -0.05600188f, -0.04511291f, 0.25970677f, 0.01184478f, 0.15163261f, -0.05456130f, 
    0.03587009f, -0.07343288f, -0.11720660f, 0.19906877f, 0.00071543f, -0.05944633f, 0.00393274f, 0.04552923f, 
    0.05397345f, 0.01826900f, 0.01112655f, -0.10763860f, 0.02203728f, 0.03591941f, 0.11994755f, -0.02929105f, 
    -0.03707436f, 0.09365634f, 0.06789047f, 0.11285034f, -0.12005832f, 0.08924457f, -0.12404548f, 0.22839616f, 
    0.25365895f, -0.00761026f, 0.10176170f, 0.04326473f, -0.04782799f, 0.03665616f, -0.11748833f, 0.00556186f, 
    -0.03393733f, -0.01620689f, 0.10480242f, -0.12376426f, 0.13117531f, -0.32950920f, 0.07288064f, 0.05252527f, 
    0.20454663f, -0.12002190f, 0.15001889f, 0.01073376f, 0.01750350f, -0.04299149f, -0.01625031f, -0.08351824f, 
    0.09591337f, 0.03347605f, -0.04486410f, 0.08216862f, -0.03133488f, -0.03461104f, -0.06433897f, -0.02697103f, 
    -0.01199610f, 0.07033034f, 0.04946349f, 0.01543852f, -0.21623598f, -0.01248104f, -0.02104570f, -0.09755599f, 
    0.11925966f, -0.08166046f, 0.02768938f, -0.09291862f, 0.07001524f, -0.09078070f, -0.08758196f, 0.10806306f, 
    0.01011054f, -0.00266039f, -0.00459253f, 0.06750189f, 0.02824717f, 0.01538587f, 0.12093122f, 0.02903695f, 
    -0.20166272f, 0.00005963f, -0.53357029f, -0.00951792f, 0.03853668f, -0.02886531f, -0.07297229f, -0.05114834f, 
    -0.20614317f, 0.01926630f, -0.02632783f, 0.08955245f, -0.01155059f, 0.04377515f, 0.00602375f, 0.05147356f, 
    0.00395828f, -0.14279442f, -0.03603300f, -0.10872530f, 0.01976617f, -0.03443753f, 0.08081932f, -0.06694683f, 
    -0.08341382f, 0.09002333f, 0.03502049f, -0.04554217f, 0.06509124f, 0.09477326f, -0.02551165f, -0.01783107f, 
    -0.04056624f, -0.01342052f, -0.08076435f, -0.04847475f, -0.04093680f, -0.00140379f, 0.02613332f, 0.00674345f, 
    -0.23091210f, -0.05302576f, 0.26575008f, 0.01213915f, 0.11433825f, -0.05438499f, -0.05029061f, 0.03862823f, 
    0.07416851f, 0.04246364f, -0.02339422f, 0.03194594f, 0.02987131f, 0.12113260f, -0.01488482f, 0.05625490f, 
    -0.00933654f, 0.00925835f, 0.07703474f, -0.01450757f, 0.24646986f, -0.24445614f, 0.25491735f, -0.11038334f, 
    -0.00876145f, -0.02507208f, -0.06212599f, 0.05061345f, 0.00943211f, 0.02050666f, -0.00901231f, -0.00792648f, 
    -0.09692157f, 0.09178128f, 0.00018781f, -0.05270625f, 0.05248957f, 0.08018237f, 0.04990486f, -0.03060498f, 
    0.01117815f, 0.02214951f, 0.16090854f, 0.19743252f, -0.06814700f, 0.02678900f, -0.04021044f, 0.06772817f, 
    -0.01161119f, -0.10661961f, -0.08655194f, -0.02179144f, 0.18858460f, 0.01539544f, 0.02503735f, -0.02388709f, 
    0.00632160f, -0.04211045f, 0.04989714f, -0.04539970f, 0.04213722f, -0.23678626f, -0.16825333f, -0.09593626f, 
    -0.26349312f, -0.04181496f, -0.09770775f, -0.11543559f, -0.08540281f, -0.03491274f, -0.08621456f, 0.03505865f, 
    -0.07799052f, -0.02030744f, -0.02690240f, 0.11781164f, -0.07172406f, -0.00754219f, -0.02394371f, 0.05849912f, 
    -0.26139605f, 0.12290543f, -0.07428312f, 0.23779930f, 0.10403527f, 0.03852129f, -0.00832559f, -0.09948832f, 
    0.20255549f, 0.04285919f, -0.05594286f, -0.09870410f, 0.01100178f, 0.01635346f, -0.00565291f, 0.09094336f, 
    0.05791689f, -0.22971034f, 0.18901630f, 0.23157884f, -0.15110700f, 0.02710001f, -0.28811169f, 0.01773715f, 
    -0.01654604f, -0.00834224f, -0.03973664f, 0.08995340f, -0.07181294f, 0.00387393f, 0.05389901f, 0.06592586f, 
    -0.02026271f, -0.00744493f, -0.06571071f, 0.05146869f, -0.02620603f, -0.08216017f, -0.09473106f, -0.12811713f, 
    0.09498070f, 0.01519885f, 0.02237341f, 0.11278569f, 0.02591421f, 0.09805298f, -0.01179016f, -0.00289248f, 
    -0.00920053f, 0.00842893f, -0.14222735f, 0.00530052f, -0.05166495f, 0.04595901f, -0.00899222f, -0.01581443f, 
    0.04704013f, -0.01020616f, 0.03318013f, 0.03722941f, -0.28720966f, 0.00523873f, 0.11294990f, 0.21021207f, 
    0.03680011f, -0.06719504f, -0.07939177f, -0.09102386f, 0.22732778f, 0.02002882f, -0.08757393f, -0.00374347f, 
    -0.04407062f, -0.04875045f, 0.08759378f, 0.11514358f, -0.13476990f, 0.02910123f, 0.06573935f, 0.08953722f, 
    -0.06073771f, -0.19311748f, -0.20457412f, -0.02375086f, 0.08870731f, -0.20154370f, -0.06266148f, 0.07185068f, 
    -0.18625538f, -0.17728944f, -0.00873268f, 0.06290774f, -0.04457561f, 0.04772756f, -0.04582181f, 0.03180256f, 
    -0.23642707f, -0.21901169f, -0.23892224f, -0.09448317f, 0.13435823f, -0.03026959f, 0.26973650f, -0.00589560f, 
    -0.07022173f, 0.10583939f, -0.09580713f, 0.10531162f, 0.02507807f, -0.06670772f, 0.00604069f, 0.03721808f, 
    0.11864747f, 0.06503871f, 0.06215933f, 0.03768013f, -0.00988604f, 0.02516375f, -0.03271253f, 0.01599009f, 
    0.20451812f, -0.30522564f, 0.17080891f, -0.10271681f, 0.00410253f, -0.09644694f, 0.01639559f, 0.06622185f, 
    0.01965197f, -0.01613482f, 0.03572448f, -0.01882859f, -0.07045195f, 0.03468640f, 0.12822646f, -0.06179243f, 
    0.06872355f, 0.07483049f, -0.00681136f, -0.00662025f, -0.07479141f, -0.09625364f, 0.09278610f, -0.08877770f, 
    0.11932115f, -0.17581704f, 0.05502519f, 0.09952694f, 0.08853044f, 0.03539318f, -0.06817912f, 0.08695833f, 
    -0.11376841f, 0.04526296f, 0.06142383f, 0.08882235f, 0.04973169f, 0.14125320f, 0.09739432f, 0.18028128f, 
    -0.82841676f, -0.21442014f, -0.49360481f, 0.44186506f, -0.22208004f, -0.09368578f, 0.22097997f, -0.17129387f, 
    0.29363170f, 0.00439664f, -0.20363595f, -0.02041764f, 0.02416910f, -0.11224656f, 0.03086604f, 0.04206869f, 
    -0.04713434f, 0.07362459f, -0.01342933f, 0.18555291f, -0.01396310f, 0.00114742f, -0.04293787f, -0.00940859f, 
    -0.06280842f, -0.04901035f, 0.05039328f, 0.06340752f, 0.06328956f, -0.00814546f, -0.13595620f, 0.00981535f, 
    0.01401655f, -0.03854833f, -0.03663426f, -0.01783089f, -0.00338276f, -0.02689426f, -0.12913576f, -0.12490316f, 
    0.03382958f, -0.17171127f, -0.24592841f, -0.06629786f, -0.00283476f, -0.12160292f, 0.01405615f, -0.01996618f, 
    -0.12938476f, -0.03947964f, 0.01547859f, -0.01168350f, 0.10325512f, 0.03399254f, -0.05045287f, 0.02192371f, 
    0.03063387f, 0.07684058f, 0.00269900f, 0.05674313f, 0.23344013f, 0.15142862f, 0.07366651f, 0.06810374f, 
    -0.05338407f, 0.00410898f, 0.07325862f, -0.00585613f, 0.03239827f, -0.07490616f, -0.12936485f, 0.05653145f, 
    -0.00814171f, 0.02619495f, 0.01451884f, -0.05523414f, -0.08928001f, -0.00766965f, 0.00879336f, 0.03547754f, 
    -0.06385879f, -0.22357301f, -0.13269192f, 0.13013063f, 0.04300185f, -0.14897376f, -0.13076501f, 0.06697389f, 
    -0.24436061f, 0.06983151f, 0.08948238f, 0.01952652f, 0.09710033f, -0.03893375f, -0.06980267f, 0.03642017f, 
    -0.03505868f, 0.06752496f, 0.05820288f, -0.00622181f, -0.05383901f, -0.22033568f, -0.26069871f, -0.11791582f, 
    -0.08789797f, -0.02760534f, -0.20620187f, -0.07401383f, -0.17337623f, -0.05085799f, 0.04271299f, 0.04560634f, 
    -0.00120080f, -0.03834954f, -0.01814621f, -0.00836307f, -0.03120732f, -0.04963318f, -0.05594674f, -0.03546075f, 
    0.09053480f, -0.42082119f, 0.26237464f, 0.04479335f, 0.18425564f, -0.05811615f, -0.04374069f, -0.05978751f, 
    0.06433740f, -0.34497592f, -0.04750083f, -0.07700051f, 0.06300152f, 0.02871690f, 0.02303219f, 0.05053406f, 
    -0.00441982f, 0.08098374f, 0.27391657f, -0.05203297f, -0.11876363f, 0.03375159f, -0.08831637f, 0.05440902f, 
    -0.02826096f, -0.03269986f, 0.04538150f, 0.03250520f, 0.02002412f, 0.03634018f, -0.10657103f, -0.00501433f, 
    0.08021703f, 0.10241587f, -0.00189630f, 0.01831216f, -0.03662069f, 0.06048302f, -0.09926533f, -0.08398286f, 
    -0.01162943f, -0.10569640f, -0.09264272f, 0.28534794f, 0.24077393f, -0.03156413f, 0.13494086f, -0.19736585f, 
    0.15249297f, 0.13780934f, -0.00047188f, 0.08768943f, -0.03894676f, 0.05272254f, 0.08178400f, 0.05218951f, 
    0.02076241f, -0.12184169f, -0.04041707f, -0.05522438f, 0.12642373f, 0.02665411f, 0.15672763f, -0.00665808f, 
    -0.00762665f, -0.00627961f, 0.05953314f, -0.00699982f, 0.06550097f, -0.08589382f, -0.04985930f, -0.06231387f, 
    0.00681689f, -0.03455117f, -0.02801113f, 0.11423296f, -0.00017527f, -0.01833922f, -0.13837655f, -0.04740573f, 
    -0.11766208f, -0.08478109f, -0.09631968f, 0.06203294f, -0.09564465f, 0.03696805f, -0.02142352f, -0.00719914f, 
    0.03711220f, -0.03655766f, -0.01697757f, 0.03163388f, 0.04103299f, -0.01378520f, -0.03569393f, 0.02130951f, 
    -0.06872682f, -0.02719170f, -0.05378526f, -0.06940202f, 0.35720560f, 0.05992479f, 0.25917032f, 0.03057283f, 
    -0.08966400f, -0.00568990f, 0.02609112f, -0.16813362f, 0.06537604f, -0.03269277f, -0.14509261f, 0.02903262f, 
    0.01965517f, -0.00452393f, -0.04445920f, -0.01067160f, 0.05618739f, -0.02076468f, 0.08635903f, 0.07965188f, 
    -0.39413375f, -0.28321818f, -0.05401650f, 0.04339185f, 0.02157775f, -0.04488200f, -0.41148233f, 0.19076471f, 
    -0.17451252f, -0.13583551f, 0.03906098f, 0.00123929f, 0.01605069f, -0.01270447f, -0.01181282f, 0.01247485f, 
    -0.05883073f, -0.02551192f, 0.04419057f, 0.01942934f, 0.27330050f, 0.00370702f, 0.22196609f, -0.13090071f, 
    -0.21180704f, 0.01019293f, 0.08160228f, -0.04613950f, 0.02071531f, -0.06435418f, -0.06323647f, 0.03029554f, 
    0.04318896f, -0.01705515f, -0.09375285f, -0.00215248f, 0.09772731f, -0.01030668f, -0.06632360f, -0.03201941f, 
    -0.13143896f, -0.05608280f, 0.10930190f, 0.08072120f, 0.04239654f, 0.06926729f, 0.15860702f, -0.02870990f, 
    0.13009469f, -0.15852596f, -0.11869710f, 0.00319095f, 0.00104066f, 0.01324417f, 0.06848609f, 0.14553165f, 
    0.04893932f, 0.01047183f, -0.04278564f, 0.04494676f, 0.11970817f, -0.01556577f, 0.18563178f, 0.17968528f, 
    0.16411127f, 0.22737578f, 0.11262403f, -0.20890574f, -0.03958960f, 0.05221392f, 0.08056431f, -0.12504965f, 
    0.02991108f, -0.13127665f, -0.16515543f, -0.16097215f, 0.10005102f, -0.00502975f, 0.31699800f, 0.00132538f, 
    -0.23504552f, -0.20607834f, -0.07857081f, -0.16279182f, -0.38109836f, 0.15208924f, 0.14040557f, -0.00500969f, 
    -0.21881285f, 0.12179174f, -0.05079251f, -0.06132408f, 0.17587602f, 0.22217827f, 0.03108400f, -0.06895206f, 
    0.09862942f, 0.09236591f, 0.06536331f, 0.10586176f, -0.03801439f, -0.21706684f, -0.20940599f, 0.05537197f, 
    -0.12317596f, 0.05500546f, -0.09085246f, -0.14437525f, -0.11347769f, 0.01481493f, -0.02346453f, -0.00532958f, 
    -0.01060003f, 0.00973158f, -0.07524086f, 0.01028358f, -0.02132313f, -0.01032149f, 0.00162938f, 0.03425532f, 
    0.25021076f, 0.22557469f, 0.21488585f, 0.15503879f, -0.18029021f, -0.10609395f, 0.03135287f, -0.00619273f, 
    0.05864989f, -0.00933371f, -0.08840881f, 0.03939573f, 0.02909337f, 0.06544846f, 0.06721614f, -0.10161842f, 
    -0.05645803f, 0.05441310f, 0.02333981f, 0.01252344f, -0.03594559f, 0.06130727f, 0.05898916f, 0.08793350f, 
    -0.05188379f, -0.09874992f, 0.03227360f, -0.05431812f, -0.01215703f, 0.04274394f, -0.12210579f, -0.05728119f, 
    0.01867966f, 0.03015655f, -0.08178596f, 0.05567067f, 0.04461829f, 0.08838119f, -0.10953000f, -0.04630063f, 
    0.26460797f, -0.33698279f, 0.44241822f, 0.29822239f, 0.07376714f, -0.11289270f, -0.07019775f, -0.06404685f, 
    0.01856163f, -0.04793150f, 0.03058107f, -0.13219616f, 0.04361110f, -0.03268423f, 0.00350763f, 0.08361734f, 
    -0.00767276f, 0.09088560f, -0.08623870f, -0.08680551f, -0.02106967f, -0.04967528f, -0.02667587f, -0.04566226f, 
    0.16513909f, 0.00871205f, 0.05174210f, 0.05998622f, 0.04979611f, 0.00446917f, 0.02616257f, -0.06855087f, 
    -0.01647504f, -0.01427398f, -0.04452706f, -0.02885385f, 0.10256386f, 0.08281042f, 0.09443197f, -0.07706845f, 
    0.27989846f, 0.13061237f, 0.36706871f, 0.00533785f, -0.11606485f, -0.00074647f, -0.00020061f, -0.03779650f, 
    -0.02766700f, -0.09495232f, -0.10541946f, -0.01643646f, 0.05366981f, -0.02670442f, 0.00255994f, -0.05490272f, 
    0.00509745f, -0.04013643f, -0.04046735f, 0.08766002f, 0.27117640f, 0.12555964f, 0.23446740f, -0.04632517f, 
    -0.19630201f, -0.00619459f, 0.02291632f, -0.04926399f, 0.00111390f, -0.02440528f, -0.09032167f, 0.02951291f, 
    0.00172065f, -0.01140603f, -0.03402948f, -0.05124972f, 0.05587707f, 0.05351398f, -0.03080543f, 0.08562040f, 
    -0.14553331f, -0.35629725f, -0.23566589f, -0.15511562f, 0.09531966f, -0.10632848f, -0.03826590f, 0.03901567f, 
    -0.16114971f, -0.00037831f, 0.01196065f, 0.08905880f, 0.01780899f, 0.00554228f, 0.07625736f, -0.01049823f, 
    0.07116697f, 0.09981810f, 0.05086929f, 0.02754458f, -0.12540212f, 0.05139657f, -0.05862541f, 0.12786800f, 
    -0.04027119f, -0.03905929f, 0.07277707f, 0.07226636f, 0.00798152f, 0.06167388f, -0.16393591f, -0.01418716f, 
    -0.01599769f, 0.05731640f, -0.11485554f, 0.00802389f, 0.06001932f, 0.02959990f, -0.07254759f, -0.11120584f, 
    -0.11356461f, -0.02752716f, -0.05164442f, -0.06895879f, 0.02953773f, -0.00174736f, 0.05468601f, 0.00361056f, 
    -0.00129284f, -0.02101693f, -0.06889147f, 0.06157867f, 0.03907573f, -0.06786815f, 0.08859225f, -0.04668375f, 
    -0.09917817f, -0.06050026f, -0.08602571f, -0.03914756f, 0.06485335f, -0.02136425f, 0.08713107f, -0.00414713f, 
    0.03965920f, 0.17166482f, 0.06689470f, 0.01979755f, 0.01391438f, -0.07817754f, 0.05741145f, -0.01541642f, 
    0.03570722f, 0.00686147f, -0.00688099f, 0.02455012f, -0.03535939f, -0.05111631f, -0.14026764f, -0.07635155f, 
    0.00882454f, -0.35217509f, -0.27782157f, 0.07296205f, 0.18443316f, -0.22848628f, -0.17335838f, -0.30832240f, 
    0.10384981f, -0.10498904f, 0.14879525f, -0.00432054f, 0.00321915f, -0.13065888f, -0.09707239f, -0.03429570f, 
    -0.00258060f, -0.04095909f, 0.21521789f, 0.05333897f, 0.19741116f, -0.11875755f, -0.04993005f, 0.01402765f, 
    -0.00615171f, -0.06028419f, 0.03603100f, -0.07407209f, 0.06867310f, -0.12223959f, -0.08022281f, -0.03599567f, 
    -0.04292260f, -0.06498141f, -0.05136523f, 0.16625781f, 0.04179002f, 0.11265748f, 0.01411915f, 0.01674086f, 
    0.02813569f, 0.03835969f, -0.01610342f, -0.12837756f, 0.04944586f, -0.07402811f, 0.08233820f, -0.07599212f, 
    0.07808032f, -0.06403183f, -0.18772781f, -0.10289261f, 0.09970788f, 0.04837963f, 0.10795929f, 0.10395996f, 
    -0.03255586f, -0.00841346f, -0.04783713f, 0.00106003f, 0.08768339f, -0.13792974f, -0.01979875f, -0.01752341f, 
    0.01535151f, -0.00996517f, 0.02307193f, -0.06089287f, 0.02600115f, -0.09433655f, -0.04810614f, -0.02805680f, 
    -0.02715600f, -0.05576093f, -0.02350774f, 0.11524286f, 0.01107858f, 0.07021038f, -0.06030997f, -0.02283788f, 
    0.12943116f, 0.25145492f, 0.18061419f, 0.18973698f, -0.31248963f, -0.02344294f, -0.15056428f, 0.15651836f, 
    0.00754168f, -0.08583797f, -0.11292010f, 0.01959986f, 0.03870332f, 0.11527429f, 0.04212962f, 0.00013764f, 
    -0.07565796f, -0.02785638f, 0.05113848f, -0.03016746f, -0.15466371f, 0.01759992f, -0.23366936f, -0.04990155f, 
    0.03235702f, 0.03568560f, 0.08212951f, -0.07302365f, -0.04035883f, 0.06936324f, -0.02621595f, 0.02930046f, 
    0.05059055f, 0.02308728f, -0.01456924f, 0.00578127f, -0.06298485f, 0.04631753f, -0.01894848f, 0.08802687f, 
    -0.21700715f, 0.11795566f, -0.00532719f, 0.22265913f, -0.34505615f, 0.01491916f, 0.00811167f, 0.07533222f, 
    0.06726655f, -0.06997760f, -0.03391400f, 0.03019057f, -0.00772607f, 0.02323875f, 0.06306602f, 0.13871402f, 
    0.05498718f, 0.07208148f, 0.06113188f, -0.10436969f, -0.00359062f, -0.18324222f, -0.00632510f, -0.11186713f, 
    -0.18538742f, -0.00331645f, 0.08516290f, -0.09220289f, -0.08995374f, 0.05115455f, 0.03067518f, -0.03609575f, 
    0.04461885f, 0.17112233f, -0.01778057f, -0.03235645f, 0.08493044f, 0.11367160f, 0.01194704f, 0.05197127f, 
    0.27723283f, -0.16294561f, 0.33156925f, -0.28905070f, 0.00712187f, 0.03399050f, 0.01960088f, -0.27010992f, 
    0.11148256f, 0.08662283f, 0.05377340f, 0.05646587f, 0.09643497f, -0.05856661f, 0.05146515f, 0.00866428f, 
    0.06519214f, -0.05504966f, 0.00724657f, -0.01077253f, -0.41183591f, -0.04168502f, -0.24254180f, 0.39013171f, 
    -0.15925193f, 0.13981004f, -0.06690369f, 0.01052732f, -0.19101870f, 0.06667401f, -0.10070331f, -0.17972045f, 
    -0.06220022f, -0.01286341f, -0.07507682f, 0.03027648f, -0.12764695f, 0.02015904f, 0.00787348f, -0.07199261f, 
    -0.07943385f, 0.01973563f, -0.25387660f, 0.05406125f, 0.08195497f, 0.01779629f, 0.09573136f, -0.03153888f, 
    0.04582606f, -0.04982919f, -0.16503642f, 0.01000921f, -0.02379197f, -0.03071813f, 0.00110431f, 0.11706185f, 
    -0.03413435f, -0.03188798f, -0.08409861f, -0.08064178f, 0.38136649f, -0.08096147f, 0.34626204f, -0.21008506f, 
    -0.07353602f, 0.07714428f, 0.00643677f, -0.13747574f, 0.06658272f, -0.07963118f, -0.08697146f, 0.01036524f, 
    -0.03735323f, -0.02935563f, -0.08587973f, -0.04232686f, 0.14790086f, -0.02105082f, 0.06858470f, 0.02405496f, 
    0.16681898f, -0.17283039f, -0.05769698f, 0.33907226f, 0.17425473f, -0.04745076f, 0.18574014f, -0.06514319f, 
    0.08941151f, 0.03762398f, -0.12522395f, -0.04970330f, -0.01660152f, 0.09189124f, 0.13722508f, -0.05919898f, 
    -0.03863978f, -0.01136180f, 0.02601382f, 0.02870482f, -0.14352396f, -0.02293245f, -0.16668910f, 0.05571207f, 
    -0.16066961f, -0.12509531f, -0.02720140f, 0.03534473f, -0.16259639f, 0.05095948f, -0.00424010f, 0.02773111f, 
    0.14132488f, -0.00449917f, -0.02793385f, 0.08145433f, 0.06665620f, 0.06774923f, 0.03637427f, 0.07030043f, 
    -0.28369689f, -0.03522798f, -0.22577360f, 0.12515998f, -0.22401726f, 0.07670068f, 0.02789839f, -0.00527841f, 
    -0.05487385f, 0.08924255f, -0.02610298f, -0.03661251f, -0.06012394f, 0.02923269f, -0.07662719f, -0.00996875f, 
    -0.09102920f, 0.02477937f, -0.08574178f, -0.01757227f, -0.06031721f, -0.23644421f, -0.31260201f, 0.14933039f, 
    0.46379253f, 0.13166253f, 0.13813652f, -0.08018348f, 0.08306759f, 0.13108636f, -0.06308682f, 0.03293018f, 
    0.05498881f, -0.03590746f, -0.12415426f, -0.03187660f, 0.02028589f, 0.04487843f, 0.09940916f, 0.05277046f, 
    -0.13124666f, -0.08053093f, 0.16101363f, 0.03210111f, 0.17994814f, -0.01345236f, 0.10227545f, -0.11944512f, 
    0.15999250f, 0.16811183f, -0.01412522f, 0.04285894f, -0.16861728f, 0.01971631f, -0.00354001f, -0.01430086f, 
    -0.03952147f, 0.01020317f, 0.03842974f, -0.14217104f, 0.12728451f, 0.06720056f, 0.21596250f, 0.21763307f, 
    0.19983801f, -0.14286044f, 0.14961153f, -0.01734533f, 0.12833041f, 0.01827083f, 0.06242479f, 0.14996634f, 
    -0.02250961f, -0.09715076f, 0.07984569f, -0.10443763f, -0.23373546f, 0.15669513f, -0.12210117f, -0.24947868f, 
    0.00302716f, -0.12847273f, 0.08573989f, 0.08931571f, -0.04278595f, -0.03004586f, 0.13867612f, 0.01979480f, 
    0.13392796f, -0.04957359f, -0.06576663f, 0.05044481f, 0.00372124f, -0.02240673f, 0.08491167f, -0.12936547f, 
    -0.05670970f, 0.07900479f, -0.06265557f, -0.09008866f, -0.25105247f, -0.03048449f, 0.07834395f, 0.29112750f, 
    -0.30152091f, 0.10458361f, -0.07711488f, 0.23416063f, -0.18982191f, 0.00899422f, 0.00415654f, -0.02045060f, 
    0.07189971f, -0.00680819f, -0.01068080f, 0.08075529f, 0.06296100f, 0.11096448f, 0.13787511f, -0.09509423f, 
    -0.32327086f, -0.01483583f, -0.26111853f, 0.13165031f, -0.11116073f, 0.01222612f, 0.06421116f, -0.03657481f, 
    0.00291740f, 0.05114235f, -0.00206428f, -0.03039899f, 0.02805160f, -0.03767717f, -0.06268449f, 0.00691036f, 
    -0.03607664f, 0.03196840f, 0.00336398f, 0.02661699f, -0.00388793f, -0.26201051f, 0.06527136f, -0.26977283f, 
    -0.01747478f, 0.02289511f, -0.11885661f, -0.15446021f, -0.08037970f, -0.04435626f, 0.02060511f, 0.01895265f, 
    -0.01984326f, -0.01901741f, -0.01157344f, 0.02454771f, -0.00836907f, 0.01926097f, 0.03094920f, -0.09917965f, 
    0.03274461f, -0.20616116f, -0.11348011f, -0.12469557f, -0.07905874f, -0.07099599f, -0.14025070f, -0.06126489f, 
    -0.06248313f, 0.02486224f, 0.00929831f, 0.01834068f, 0.05184740f, -0.06339132f, -0.08247454f, 0.05866585f, 
    -0.03180542f, 0.01771160f, -0.03063830f, 0.06029190f, -0.21683733f, 0.04574800f, -0.13430472f, 0.05218824f, 
    -0.01091914f, -0.02490890f, 0.04827672f, -0.12042449f, 0.06154244f, 0.00963106f, -0.08483366f, -0.02961531f, 
    0.03553869f, -0.00220200f, 0.04758900f, -0.03004698f, -0.10606383f, -0.00817966f, -0.07195154f, -0.01830266f, 
    0.01295929f, -0.23901053f, 0.17916171f, -0.09254970f, 0.13554941f, 0.05823828f, -0.20151277f, 0.02654261f, 
    -0.07300419f, -0.10898095f, 0.03271681f, -0.02013813f, 0.02345183f, 0.04333748f, -0.00675190f, -0.01881529f, 
    -0.02595053f, -0.04508995f, 0.02865246f, 0.01649587f, -0.14292918f, -0.03898866f, -0.10965801f, -0.12247431f, 
    0.26806575f, 0.12889044f, 0.13891870f, 0.10399709f, -0.14875688f, 0.07533401f, -0.03032108f, 0.10690949f, 
    0.07731061f, 0.03801341f, 0.14996606f, -0.07028928f, -0.04474902f, -0.01364425f, 0.03511539f, 0.02840849f, 
    -0.16931693f, -0.04151377f, -0.24247150f, 0.09551324f, -0.08158617f, 0.04342327f, -0.00710807f, -0.00615499f, 
    -0.01160030f, 0.05533577f, -0.00028160f, -0.15162951f, -0.04444158f, 0.17656653f, 0.01820241f, 0.07072499f, 
    -0.01397477f, 0.10865027f, -0.07090514f, 0.04059468f, 0.08551427f, -0.11811200f, 0.03184131f, -0.02006898f, 
    -0.22071773f, -0.05303633f, -0.04794591f, -0.02148492f, 0.01910548f, -0.00571236f, -0.12568259f, -0.07233711f, 
    -0.01086792f, -0.01774110f, -0.13983408f, 0.05360525f, 0.05410175f, 0.04128863f, -0.11855242f, -0.00384162f, 
    -0.18188584f, -0.15246385f, 0.03725477f, 0.24854669f, -0.06270611f, -0.16803630f, -0.07645030f, 0.02195214f, 
    0.10042374f, -0.04171643f, -0.00755646f, -0.02204034f, -0.03975509f, -0.07002535f, -0.01040653f, 0.00260628f, 
    -0.01591069f, 0.08591385f, -0.07916422f, -0.25740176f, -0.20171243f, -0.07263970f, -0.07551525f, -0.06800302f, 
    -0.06107083f, -0.05604809f, -0.03595430f, -0.01668426f, -0.06732390f, -0.05640684f, -0.03027626f, 0.02435794f, 
    0.04079069f, 0.04288851f, 0.04701517f, 0.15062387f, -0.00242469f, 0.09542238f, 0.09366343f, 0.17678267f, 
    -0.30378443f, 0.11911301f, -0.07948880f, 0.12481149f, -0.04714698f, 0.05991645f, 0.04919890f, -0.01992432f, 
    0.02699736f, 0.07708356f, -0.04239553f, 0.00197668f, 0.00920043f, -0.01128286f, -0.05767300f, 0.02472526f, 
    -0.04780838f, -0.02204185f, -0.00988968f, 0.01555157f, 0.03461323f, -0.20595384f, 0.10895871f, 0.17897303f, 
    -0.12874526f, -0.02605846f, 0.06159168f, -0.03831156f, 0.02055015f, -0.10863635f, -0.00811343f, -0.08968709f, 
    0.02351254f, 0.08021508f, 0.03436300f, 0.07136654f, 0.07239824f, 0.08428770f, -0.07085706f, -0.14847416f, 
    0.53130049f, -0.26939568f, 0.32360563f, 0.03568180f, -0.07385631f, -0.01058094f, -0.02516651f, -0.21306039f, 
    0.06343684f, -0.06728548f, -0.04627291f, 0.03069394f, -0.00036871f, -0.06015499f, -0.04267658f, -0.05196342f, 
    0.04242413f, -0.08658982f, 0.15754226f, 0.07543634f, -0.14774844f, 0.09895983f, -0.26075420f, 0.03084316f, 
    0.06705811f, 0.00927028f, 0.12021283f, 0.10422023f, -0.08925112f, 0.09228645f, 0.03791063f, 0.03539092f, 
    -0.04053186f, 0.10064539f, 0.05663142f, 0.06940357f, -0.02192843f, 0.08946590f, 0.02426086f, -0.07341853f, 
    -0.01377537f, -0.04665184f, 0.08085011f, -0.14084613f, 0.18156600f, 0.10089336f, 0.13490959f, 0.02558379f, 
    0.03502471f, 0.07487482f, -0.00583239f, 0.04649822f, -0.03485059f, -0.06252316f, -0.00864805f, 0.04145635f, 
    0.02595854f, 0.00950783f, -0.05997870f, -0.00674216f, -0.03671382f, -0.16187248f, -0.02865819f, -0.18049487f, 
    0.28950402f, 0.17858711f, 0.03458467f, -0.09285409f, -0.00426377f, -0.09883517f, 0.04488469f, 0.05984596f, 
    -0.08584143f, 0.00392980f, -0.00214446f, 0.08560748f, -0.05575930f, -0.02945289f, -0.22509022f, 0.01212883f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.14399195f, 0.09831639f, 0.04374158f, -0.05590304f, -0.05414522f, 0.02688670f, 0.00788460f, -0.09366578f, 
    0.01815232f, 0.05639787f, 0.00565474f, -0.01467331f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
