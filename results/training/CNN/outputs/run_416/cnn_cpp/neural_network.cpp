#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.21956468f, 0.11467128f, -0.61180103f, -0.50258470f, 0.23858739f, -0.38320971f, -0.20900311f, 0.68790263f, 
    -0.41443262f, 0.27610320f, -0.35864693f, 0.41918170f, -0.00364249f, -0.38693038f, 0.36356854f, -0.33086082f, 
    -0.36362502f, -0.23422752f, -0.29316735f, -0.43734950f, 0.13148864f, -0.21746565f, 0.40413511f, -0.29900119f, 
    0.19259182f, -0.64190018f, -0.88044173f, -0.45831388f, -0.19424629f, 0.08813731f, 0.50011706f, 0.13918172f, 
    0.36278653f, 0.22155161f, 0.35898423f, 0.24880989f, -0.16596340f, 0.18995568f, 0.46643397f, 0.42358175f, 
    0.06843820f, 0.29032323f, 0.13991672f, 0.02434089f, 0.04475448f, -0.10588911f, -0.32098287f, -0.10711889f, 
    -0.28366402f, -0.13995555f, -0.61232346f, -0.12002790f, 0.50119156f, 0.14289042f, 0.50222969f, -0.19184434f, 
    0.76235914f, 0.29205427f, -0.63656956f, -0.31130016f, 0.08543670f, 0.40217549f, 0.45961171f, 0.27827293f, 
    0.32837984f, -0.20632342f, 0.00756229f, 0.10960905f, 0.38184214f, 0.37375322f, 0.18971279f, 0.20765385f, 
    -0.29855660f, -0.11211742f, 0.22000659f, -1.03411198f, 0.52061331f, 1.09272611f, -0.08194174f, -0.20292261f, 
    0.17174728f, 0.00797301f, 0.63634944f, -0.17669299f, -0.74104083f, -0.23904462f, -0.00983319f, 0.44273359f, 
    -0.10851520f, -0.18570738f, -0.09398881f, 0.26733664f, 0.17313665f, -0.22754498f, 0.04755215f, -0.13925946f, 
    0.02497198f, -0.20233379f, 0.02194776f, -0.07700980f, -0.29618210f, -0.13321471f, 0.14027448f, -0.38916373f, 
    -0.49166271f, -0.78845286f, 0.65831113f, 0.39707297f, -0.22453053f, -0.19940905f, -0.52822745f, 0.46840814f, 
    -0.34715584f, -0.25950947f, -0.28899449f, 0.03888884f, -0.23758259f, -0.08945922f, -0.05898020f, 0.23763409f, 
    0.08984314f, -0.09093548f, 0.12172388f, -0.28146514f, 0.13238207f, 0.75888413f, 0.58234823f, -0.07030286f, 
    0.97208196f, 0.84025216f, 0.91382110f, 0.23541009f, -0.62515223f, -0.14544077f, -0.37565768f, -0.20748024f, 
    0.03862058f, -0.45736885f, 0.16766652f, -0.12913872f, 0.10363251f, -0.07264413f, 0.16816813f, -0.04087710f, 
    -0.09810679f, -0.08720459f, -0.04532808f, -0.10908484f, 0.04355650f, 0.21066378f, 0.47657651f, 0.71714973f, 
    -0.76583439f, -0.35909936f, -0.18032128f, 0.68587881f, -0.59176838f, -0.09045884f, -0.40584922f, 0.22608858f, 
    -0.07869426f, 0.18072043f, 0.05791479f, 0.38984829f, 0.17557314f, 0.10545675f, -0.20854639f, -0.20479059f, 
    -0.02551317f, -0.25767994f, 0.18030761f, 0.41693357f, 0.05314226f, -0.11304145f, 0.31220490f, 0.94096506f, 
    0.51464629f, 0.72527379f, -0.26441249f, 0.18267234f, -0.01411467f, -0.03964023f, -0.07917497f, 0.29653868f, 
    0.26695874f, 0.15550250f, 0.22692508f, -0.12040841f, 0.12597431f, 0.14327338f, 0.22494236f, 0.10146336f, 
    0.07047145f, -0.06232697f, -0.16834432f, 0.43042642f, -0.02741229f, 0.22426717f, 0.20582697f, 0.07935518f, 
    0.97967231f, 0.12933166f, 0.03030974f, -0.23167038f, 0.81736761f, 0.10989596f, 0.30479804f, 0.56326896f, 
    -0.27321273f, -0.35270983f, -0.35342467f, -0.06613680f, 0.05033641f, -0.05638029f, -0.11301462f, -0.19850528f, 
    0.23951678f, 0.27775997f, -0.07998584f, -0.19296291f, 0.36148214f, 0.10975647f, 0.33263221f, -0.07404250f, 
    -0.24207616f, 0.65236437f, 0.73921257f, 1.04981780f, -0.66780543f, -0.81533575f, -0.59413218f, 0.08533119f, 
    0.22787975f, -0.16604552f, 0.10748002f, 0.18077408f, 0.13320069f, -0.28243250f, -0.17913137f, -0.17272252f, 
    0.23979479f, -0.06699113f, -0.10367399f, 0.15989043f, -0.22600412f, 0.22901879f, 0.02515327f, -0.06180215f, 
    -0.07881975f, -0.17297743f, 0.18901426f, -0.15655950f, 0.55542684f, 1.04611599f, 0.02329435f, 0.14610071f, 
    0.39187580f, -0.26283732f, 0.59189993f, 0.09649996f, -0.52023149f, 0.20708899f, 0.06185294f, 0.33329648f, 
    -0.46860489f, 0.10019311f, 0.02125358f, 0.37597907f, 0.28333646f, -0.09384245f, 0.21513094f, -0.00401717f, 
    0.05684233f, 0.04201000f, 0.24530037f, -0.78682071f, 0.33601552f, 0.87052327f, -0.36738533f, 0.70864761f, 
    0.91116458f, 0.19371259f, -0.28472263f, 0.03797060f, -0.79481697f, -0.24975534f, 0.22957753f, -0.17211129f, 
    0.28059262f, -0.28524613f, -0.34319177f, -0.15425429f, -0.12529190f, 0.05173362f, 0.03415720f, -0.09367384f, 
    -0.13720855f, -0.10605445f, -0.06756553f, 0.04063636f, 0.51643586f, 0.94414234f, 0.83346778f, 0.47944272f, 
    0.19516610f, -0.15286987f, -0.62425196f, -0.46320283f, -0.31280997f, 0.05817988f, -0.10686308f, 0.35401231f, 
    -0.05640297f, -0.19916895f, 0.23501781f, 0.13479204f, -0.01545710f, 0.16688330f, -0.14454375f, 0.05108196f, 
    -0.13501567f, 0.27136862f, 0.22350100f, -0.26695693f, 0.09552968f, 1.00243866f, 0.60134286f, 0.63563818f, 
    -0.62097323f, -0.76534110f, -0.20480500f, -0.17875424f, -0.42170793f, 0.04489260f, 0.25847623f, 0.12312923f, 
    0.26281571f, -0.21718076f, 0.05349742f, 0.15843852f, -0.32524565f, -0.13209845f, 0.27626178f, 0.00407253f, 
    0.23640186f, 0.06674390f, 0.23562881f, -0.30948412f, -0.05322802f, 0.39592913f, 1.04801059f, -0.02397514f, 
    -0.86964625f, 0.94794500f, -0.22154477f, -0.33110413f, 0.39421642f, 0.09086507f, 0.37258434f, -0.37995413f, 
    -0.12306969f, -0.34338599f, 0.20374504f, -0.19871169f, -0.13473278f, -0.21221229f, -0.25187603f, -0.03297523f, 
    -0.13716200f, 0.05285377f, 0.38607135f, 0.15768820f, -0.00791088f, -0.21112150f, -0.12835595f, 0.82222283f, 
    0.25053987f, 0.65371197f, 0.79418743f, 0.70700014f, 0.53890055f, -0.13775985f, -0.56178170f, 0.19473225f, 
    0.13471839f, -0.45640397f, 0.11703500f, 0.11760093f, 0.18402942f, -0.08041367f, 0.08887960f, 0.27632946f, 
    -0.22380017f, 0.06855185f, 0.33321196f, 0.03330969f, 0.32853153f, -0.15505762f, -0.41977155f, -0.10820945f, 
    -0.20845257f, -0.06117736f, -0.75430351f, -0.14828363f, -0.04104717f, -0.18625370f, 0.21134764f, 0.48679945f, 
    0.69206566f, 0.47710028f, -0.44817567f, -0.27659675f, -0.27495950f, -0.48934478f, -0.31372219f, 0.39271000f, 
    -0.13639838f, -0.26160446f, -0.26060227f, -0.34146604f, 0.07358380f, 0.17306660f, -0.00714131f, -0.17854452f, 
    -0.04661882f, 0.25265032f, 0.61475432f, 0.75468689f, 0.85332900f, 0.69973093f, -0.16217807f, -0.01234383f, 
    -0.60465169f, 0.37414229f, -0.17009905f, 0.37741625f, -0.01813877f, -0.16435973f, -0.45286205f, -0.35377532f, 
    0.07227349f, 0.01595470f, -0.01788776f, -0.40260020f, 0.04620836f, 0.03099970f, 0.17943753f, -0.05438424f, 
    0.08601777f, -0.08602490f, 0.03201797f, 0.93009079f, -0.26930815f, -0.54533696f, -0.49929228f, 0.75533348f, 
    -0.53904939f, -0.68794233f, -0.33786851f, -0.29214153f, 0.31245917f, -0.38924533f, 0.09564617f, 0.23702978f, 
    -0.30056888f, -0.08853614f, -0.27995062f, -0.00592331f, -0.34194863f, -0.00083624f, -0.35360393f, 0.00616481f, 
    0.08144560f, -0.19676313f, -0.32273501f, 0.53059030f, -0.78528684f, -0.42788401f, -0.61743701f, -0.79541248f, 
    -0.01427493f, 0.20311961f, 0.24653538f, 0.50993043f, -0.55522543f, 0.45419413f, 0.29284394f, -0.46960494f, 
    0.37616310f, -0.02147833f, 0.25417668f, 0.16257986f, 0.06316386f, 0.10084057f, 0.21527366f, 0.00595476f, 
    0.09189060f, 0.14879976f, 0.04002659f, -0.14784127f, -0.34769279f, 0.05294171f, -0.70477033f, -0.77341300f, 
    -0.50702351f, 0.48766977f, -0.01393194f, 0.48651832f, 0.19784865f, 0.42156115f, -0.35403365f, -0.32206142f, 
    -0.09196724f, 0.02340250f, -0.22534744f, -0.14159884f, 0.29029217f, -0.11089943f, 0.13614145f, -0.19351690f, 
    -0.23109008f, -0.16617212f, -0.13997507f, 0.00254453f, 0.44997951f, -0.51636213f, -0.14844300f, -0.59034806f, 
    -0.67549467f, -0.16840322f, 0.47055587f, 0.75431484f, 0.20616613f, 0.44391111f, 0.58113170f, 0.31312227f, 
    0.11458190f, 0.31055430f, -0.16500953f, 0.27283043f, -0.04013678f, -0.32760379f, 0.14888674f, 0.00417775f, 
    -0.49212378f, -0.11176449f, -0.06751050f, -0.01765510f, 0.18393005f, 0.19525734f, 0.74669307f, -0.04269438f, 
    0.33845997f, 0.59348887f, 0.52772218f, -0.35733294f, 0.21562457f, 0.23304887f, -0.56589824f, -0.51867896f, 
    -0.06479473f, -0.26275054f, -0.26551533f, 0.08005788f, 0.34778726f, 0.26992074f, 0.16640587f, -0.00240170f, 
    0.39453927f, -0.00215138f, 0.27224737f, -0.28028440f, 0.06829876f, -0.13775598f, 0.04496689f, -0.27213606f, 
    0.61812985f, 0.40340465f, -0.64369011f, 0.63380665f, -0.43779352f, -0.60905915f, -0.51184261f, -0.93224889f, 
    -0.65942788f, 0.45351312f, 0.43325111f, 0.24169232f, 0.05518043f, 0.09678740f, -0.42821181f, 0.19723776f, 
    -0.26261392f, 0.04719579f, 0.46523464f, 0.23505233f, 0.21904252f, 0.02546676f, 0.22482246f, -0.01283417f, 
    -0.24069130f, -0.43377697f, -0.31315392f, 0.93123811f, 0.53568888f, 0.58382648f, 0.52713233f, -0.28871867f, 
    0.45301661f, 0.03212661f, 0.29473275f, 0.11890310f, -0.50105977f, 0.25609931f, 0.14000846f, 0.08092266f, 
    -0.19101515f, -0.06806236f, -0.26004076f, 0.17158917f, 0.18906549f, 0.29160723f, 0.03906074f, -0.08458462f, 
    0.06192567f, 0.91796410f, 0.63326794f, -0.80313927f, 0.42857987f, -0.54381943f, -0.18116194f, 0.35755029f, 
    0.21080415f, 0.58443564f, -0.25691801f, 0.07523707f, 0.14704189f, 0.37783918f, -0.06986195f, 0.00813601f, 
    0.07316289f, -0.28520989f, -0.08225446f, 0.04650408f, 0.00541985f, -0.21600747f, -0.31501320f, 0.00008385f, 
    -0.35957843f, -0.11036173f, -0.66037971f, -0.91811621f, -0.26477709f, 0.39000666f, 0.04307723f, 0.54953957f, 
    0.81301016f, 0.17922777f, 0.25890797f, 0.26765570f, 0.09936550f, -0.30010319f, 0.20611687f, 0.16551350f, 
    -0.30373567f, -0.00200657f, -0.14535815f, 0.36389422f, -0.07277201f, -0.22863854f, -0.19660604f, 0.07600839f, 
    -0.25932434f, -0.20948035f, -0.20570673f, -1.26866400f, 0.13200472f, 0.50159889f, -0.18005538f, 0.26502711f, 
    0.62381756f, -0.20485005f, -0.62237579f, 0.43248835f, -0.55531532f, -0.08457595f, 0.25798121f, -0.14726765f, 
    0.27483329f, -0.13156229f, -0.35337284f, 0.08691766f, -0.05097212f, -0.56847179f, -0.47352603f, 0.06238455f, 
    0.19833815f, -0.07154504f, 0.23427117f, -0.16683675f, 0.63219398f, -0.31699911f, -0.03639422f, -0.22753738f, 
    0.62003136f, 0.55039155f, 0.02280136f, -0.60896546f, -0.61885947f, 0.06685923f, 0.02421242f, 0.44134527f, 
    0.32953647f, 0.26277456f, -0.21873304f, -0.25598270f, -0.35472801f, 0.23373175f, 0.24129927f, -0.08346476f, 
    0.32339248f, -0.04767992f, -0.30487239f, 0.02074857f, 0.23859070f, 0.15798360f, 0.82661700f, 0.65345794f, 
    0.29441085f, -0.67086691f, -0.19330959f, 0.31747797f, 0.29863909f, -0.13772370f, 0.45391002f, 0.06534850f, 
    0.37410790f, 0.28870159f, 0.15002036f, 0.10560451f, 0.30433679f, -0.29314819f, 0.37935537f, 0.19499125f, 
    -0.17548034f, 0.01183990f, -0.06261714f, -0.30558181f, 0.11013362f, 0.34825730f, 0.94426280f, 0.86565977f, 
    -0.59799093f, -0.70353973f, -0.64782649f, 0.43107557f, -0.09953044f, -0.61704344f, 0.23700497f, -0.24879332f, 
    0.23866329f, 0.21988466f, 0.32554910f, 0.25545764f, -0.35608932f, 0.05504806f, -0.17158908f, -0.04194066f, 
    0.25774127f, 0.39657965f, -0.16085461f, 0.19444321f, 0.19545403f, 0.06238535f, 0.15741183f, -0.31936088f, 
    -0.45967382f, -0.72824913f, -0.58739036f, -0.41408509f, 0.33901164f, -0.54476225f, -0.22265151f, 0.44311771f, 
    -0.08791788f, -0.07366578f, -0.22154918f, -0.07806403f, -0.33783025f, -0.16489974f, 0.28027678f, 0.31293094f, 
    0.05975170f, 0.33197501f, 0.33970574f, 0.14018391f, -0.28871283f, 0.01089971f, 0.17859183f, 0.34750918f, 
    -0.82950109f, -0.41784585f, -0.06389188f, 0.22329369f, 0.63325095f, -0.87432450f, 0.42413837f, 0.33179304f, 
    -0.32765979f, -0.71300846f, 0.17840561f, -0.13511613f, 0.17907639f, 0.21497916f, 0.23372947f, 0.04443120f, 
    0.11617950f, -0.06555084f, -0.04611190f, 0.01349111f, 0.08832987f, -0.02851206f, 0.13627750f, 0.10770968f, 
    -0.18651108f, 0.12745227f, 0.51867044f, -0.03523133f, 0.67398530f, 0.70179284f, 0.08386799f, -0.10630514f, 
    0.55987895f, 0.44870165f, 0.46791053f, -0.16002159f, -0.17768945f, 0.52801663f, -0.00606890f, -0.23092686f, 
    0.10464389f, -0.19019371f, -0.28722173f, -0.24865213f, -0.27569124f, 0.14429627f, -0.16898154f, 0.22554111f, 
    0.42243460f, 0.13325712f, -0.38354960f, -0.60329646f, -0.59002626f, -0.13112624f, 0.24678712f, 0.34546399f, 
    0.33819008f, 0.55055934f, 0.00859889f, -0.38696945f, -0.42486200f, 0.15170176f, -0.46505916f, 0.01907424f, 
    -0.05329078f, -0.42439550f, 0.25837156f, 0.13616207f, -0.11199922f, -0.05877071f, 0.28175342f, 0.12578188f, 
    -0.29612041f, -0.35195661f, 0.16674437f, -0.22388926f, -0.22338879f, -0.51670951f, -0.66320974f, -0.30726451f, 
    0.21069507f, -0.18334106f, -0.64481676f, -0.16618247f, 0.41890001f, -0.41587752f, 0.27314690f, -0.25824034f, 
    0.17270814f, -0.12375443f, -0.05469434f, 0.13581416f, 0.17627770f, 0.33432221f, -0.26300547f, -0.21237132f, 
    0.10975420f, -0.04479007f, 0.07640331f, 0.09295491f, -0.76040047f, -0.51023614f, -0.33629641f, -0.68488228f, 
    -0.37988979f, 0.44790551f, 0.00727552f, -0.26176256f, -0.32336703f, 0.28250960f, -0.28476158f, -0.24899109f, 
    0.12491785f, -0.07027193f, 0.23156042f, -0.08117288f, 0.10691072f, -0.00957612f, -0.07260713f, -0.12062888f, 
    0.10204948f, 0.08045770f, 0.36248937f, 0.35520139f, 0.16231520f, -0.75334084f, -0.05974444f, 0.13035026f, 
    -0.47243813f, -0.17371832f, -0.49405915f, -0.27751976f, -0.29730803f, -0.38692775f, 0.28034645f, -0.23440108f, 
    0.15342404f, 0.14891626f, 0.60576844f, -0.16258471f, 0.22986241f, -0.13693178f, -0.26687863f, 0.23773234f, 
    0.00201971f, -0.13112065f, 0.01711089f, -0.00772566f, -0.10457633f, 0.15692259f, -0.00894714f, -0.14881575f, 
    0.19824995f, -0.03801774f, 0.39889672f, -0.28655618f, -0.03183974f, -0.35285142f, -0.21274996f, -0.01289209f, 
    0.36189789f, 0.00144245f, 0.36168751f, 0.11181734f, -0.14195473f, -0.02246861f, 0.32605597f, 0.40496501f, 
    -0.35543171f, 0.45274934f, -0.15761462f, -0.33781919f, -0.26050675f, -0.43556046f, 0.15217172f, 0.05798179f, 
    -0.45081601f, -0.36720866f, -0.66984254f, -0.42433083f, 0.05155002f, -0.50934166f, -0.13094698f, -0.36380905f, 
    -0.23257695f, 0.50279480f, -0.26243231f, 0.37107173f, -0.07294836f, -0.05135665f, -0.12472354f, 0.30172357f, 
    0.00259377f, 0.04079983f, -0.18853971f, 0.28321072f, -0.04013513f, 0.07241981f, 0.51201147f, -0.43068433f, 
    -0.11208476f, -0.02989077f, 0.20141746f, -0.54994166f, -0.56526947f, 0.56362420f, -0.30344900f, -0.01621807f, 
    -0.15823814f, -0.67369312f, 0.47427624f, -0.26718140f, 0.21335307f, 0.26959404f, 0.17005159f, 0.20819633f, 
    -0.00268534f, 0.49038681f, 0.37923819f, -0.32388026f, 0.09176003f, -0.41303769f, -0.07333582f, -0.31126463f, 
    -0.12687856f, 0.54707509f, -0.31615201f, -0.82046151f, 0.56181371f, -0.14710413f, -0.03781236f, 0.06528281f, 
    -0.28142926f, -0.13719183f, 0.02779246f, -0.09872320f, 0.38773292f, -0.26852235f, -0.09620909f, 0.13864473f, 
    0.27107447f, -0.18712740f, -0.63768023f, 0.21835524f, 0.67206103f, -0.00609167f, -0.48662400f, 0.52606821f, 
    -0.14771678f, -0.27226964f, 0.76147819f, 0.61788428f, 0.41285571f, 0.60481602f, 0.17544590f, 0.16336563f, 
    0.06669382f, -0.11791195f, -0.15553860f, 0.33373269f, -0.36207256f, 0.09786444f, -0.08704286f, -0.36284968f, 
    0.13666092f, -0.46705392f, -0.26182342f, -0.11651535f, -0.50205308f, -0.20294061f, 0.42612237f, -0.25772735f, 
    0.24659571f, 0.12957010f, 0.01798366f, 0.04182528f, 0.25482813f, -0.52628219f, -0.53579003f, 0.16734070f, 
    0.05801184f, -0.94334137f, -0.42331535f, -0.01895158f, -0.58064640f, -0.03918891f, -0.15002345f, 0.28495228f, 
    -0.09279487f, -0.26363173f, 0.10860421f, -0.00332670f, -0.23598537f, -0.24264170f, 0.10034380f, 0.21718612f, 
    0.05016213f, -0.00047990f, 0.31102657f, -0.26181269f, 0.93855143f, 0.54573721f, -0.02244919f, -0.43546689f, 
    -0.75676531f, -0.34300438f, 0.13318589f, -0.02359462f, -0.21096224f, 0.72397393f, 0.31088081f, -0.06841619f, 
    -0.07003511f, -0.02557821f, -0.00992877f, -0.23888956f, 0.23820937f, -0.22312607f, 0.03193791f, -0.01558475f, 
    0.10221690f, -0.02832848f, 0.06784695f, 0.23272957f, 0.13389996f, 0.57109749f, 0.49110538f, 0.15323219f, 
    0.30169365f, 0.13858323f, 0.66007173f, 0.09516887f, 0.54743385f, 0.50828350f, 0.64111906f, -0.23572043f, 
    0.03175040f, -0.06086353f, -0.65634072f, 0.15214305f, -0.35327774f, -0.16808650f, -0.06176168f, -0.00653292f, 
    0.14465661f, -0.09970745f, -0.32170746f, 0.00322107f, -0.14783598f, -0.16094306f, 0.27169523f, -0.78921139f, 
    -0.00429297f, 0.87648243f, 0.55997425f, -0.03961443f, 0.80556643f, 0.70722359f, -0.30812821f, 0.43145660f, 
    -0.17013387f, 0.14229122f, -0.18827653f, 0.03469146f, 0.07252901f, -0.22494978f, -0.11628354f, 0.30908448f, 
    -0.02039201f, -0.13146350f, 0.05017640f, -0.12608826f, 0.00694249f, -0.01742086f, 0.05296396f, 0.67971575f, 
    0.53947383f, 0.69795394f, 0.68487930f, 0.05914517f, -0.15253139f, 0.24460670f, -0.00897787f, -0.31886172f, 
    0.22589345f, -0.17138264f, 0.10836035f, -0.00477124f, 0.13383907f, 0.28769049f, -0.36953837f, 0.09434468f, 
    0.20754319f, -0.10522543f, -0.01153946f, 0.10384931f, 0.03964879f, -0.06041757f, 0.40136394f, 0.21847744f, 
    -0.89368099f, 0.03567597f, -0.17879850f, -0.22084115f, -0.80924934f, 0.61594993f, 0.81392312f, -0.21658736f, 
    0.49160507f, 0.46074566f, -0.32014102f, -0.12664160f, 0.11511331f, -0.41575357f, -0.39830014f, -0.06981640f, 
    -0.07209314f, -0.16137901f, -0.09469148f, 0.16992761f, 0.20023920f, -0.05816942f, 0.02436972f, -0.05684378f, 
    0.01674345f, 0.67992544f, 0.33935475f, -0.69508654f, -0.61558062f, -0.61836559f, -0.39706248f, -0.37281141f, 
    -0.29908580f, -0.14558925f, -0.32082441f, 0.01431100f, 0.19970252f, 0.17065291f, -0.12363360f, 0.08241647f, 
    -0.15366077f, -0.14485286f, -0.37656420f, -0.11916754f, -0.04617641f, 0.42464742f, 0.24797310f, 0.05510360f, 
    -0.10648417f, 0.15017128f, -0.13382858f, -0.60698801f, 0.37293783f, 0.50274789f, -0.72136152f, 0.54426706f, 
    -0.40862700f, 0.44631445f, -0.56454545f, 0.00654700f, -0.19311251f, -0.36526361f, -0.36163843f, -0.06759912f, 
    0.36548781f, 0.36127824f, 0.58587700f, 0.05838634f, -0.01455383f, 0.19001953f, -0.05584069f, 0.14371994f, 
    0.04438629f, -0.21845829f, -0.18114650f, 0.46944386f, 0.26274446f, 0.33718199f, 0.40858155f, 0.19041274f, 
    -0.79946262f, -0.70836258f, -0.36152571f, -0.12189449f, 0.04558211f, 0.52020246f, 0.46735078f, 0.35077763f, 
    0.39165238f, -0.05075756f, 0.00057879f, 0.03131289f, -0.16656810f, 0.38342997f, -0.29315865f, 0.21367408f, 
    -0.04229904f, -0.18323016f, 0.44041047f, -0.02616685f, -0.56898957f, -1.00160098f, 0.28022331f, 0.21683490f, 
    0.22029439f, 0.53040755f, 0.78447926f, -0.15048301f, 0.42594028f, 0.25494781f, -0.24248545f, -0.07446928f, 
    -0.49247363f, -0.03768576f, -0.12588814f, -0.10096338f, 0.15774542f, -0.30688989f, 0.21623394f, -0.03578958f, 
    -0.06939545f, -0.03459228f, -0.02015063f, -0.02527461f, -0.21546182f, -0.97986150f, -0.42118901f, -0.59393442f, 
    0.44545475f, -0.63956541f, 0.26293805f, 0.92019796f, -0.68547088f, -0.02004387f, 0.09564207f, 0.00837237f, 
    -0.08236571f, 0.18564379f, 0.06907859f, 0.28804508f, -0.03431984f, -0.18068352f, -0.08735560f, 0.04318003f, 
    -0.38135746f, -0.06801435f, -0.22740167f, -0.26363555f, -0.23125197f, -0.19592682f, 0.95896405f, 0.58024567f, 
    -0.07511537f, 0.68347275f, 0.24173006f, -0.27007607f, -0.47060028f, 0.01855429f, 0.19067274f, -0.01926622f, 
    -0.19073395f, 0.13394204f, 0.33242804f, 0.07251231f, -0.24335459f, 0.26983026f, -0.10353522f, 0.24134804f, 
    0.28931007f, 0.20371482f, 0.42989984f, -0.04205054f, 0.10852477f, 0.04545410f, 0.37495080f, -0.66946286f, 
    0.15901308f, -0.04400478f, 1.06295121f, -0.54317021f, -0.07356712f, 0.05828883f, 0.48928532f, 0.21151173f, 
    -0.12662479f, 0.14913517f, -0.13120857f, -0.13310717f, -0.08092603f, -0.00362096f, -0.37115270f, 0.16871314f, 
    -0.24670967f, 0.27534869f, -0.01146310f, 0.00496391f, -0.07065082f, -0.10364297f, -0.26771316f, -0.37228012f, 
    -0.45563322f, -0.34297785f, -0.47862625f, 0.79596514f, 0.47872013f, 0.44874862f, -0.26033178f, -0.09963258f, 
    0.08511496f, 0.00951808f, -0.17347035f, -0.04004501f, 0.16014177f, -0.23099041f, 0.36791143f, -0.00233645f, 
    -0.08009001f, 0.13965179f, 0.03648535f, 0.20045157f, 0.16888203f, 0.28456205f, -0.59856385f, 0.29994830f, 
    -0.11004992f, 0.82272667f, 0.26531810f, -0.57245320f, 0.86319560f, -0.29206914f, 0.00543587f, 0.17568706f, 
    -0.09711438f, 0.58437854f, 0.24604282f, -0.11564840f, 0.20393948f, -0.06489141f, 0.01052060f, -0.19206353f, 
    0.21143772f, 0.15570612f, -0.32772982f, -0.03739827f, -0.14425154f, -0.59680718f, -0.07186669f, -0.18646544f, 
    0.46494469f, 0.10436124f, -0.76722521f, 1.09251618f, 0.13548362f, -0.17925967f, 0.39429700f, -0.48364833f, 
    -0.10007062f, 0.54633653f, -0.06529687f, 0.08173876f, -0.18708335f, 0.09459898f, -0.39875677f, 0.37552357f, 
    -0.28351402f, 0.19642437f, -0.24706081f, -0.09048239f, -0.16177808f, -0.49913856f, 0.17936471f, 0.14686532f, 
    0.04254144f, -0.13356158f, -0.10067461f, -0.57426423f, -1.10861516f, -0.42902672f, 0.32863241f, -0.31753048f, 
    -0.60538971f, 0.36268151f, 0.72238737f, -0.89474386f, 0.00533961f, 0.27449116f, 0.17798367f, -0.01120066f, 
    -0.31312951f, 0.21571903f, -0.25065598f, -0.05629494f, 0.13398309f, 0.05518207f, -0.17493030f, -0.05430898f, 
    -0.26564300f, -0.06026100f, 0.34018955f, 0.09445567f, -0.12219858f, -0.10625802f, -0.51638788f, -0.15905839f, 
    0.05186188f, -0.20114268f, -0.15727308f, 0.37039948f, 0.34325084f, -0.37775403f, -0.52284276f, -0.40772602f, 
    -0.44545648f, 0.08190179f, 0.13170440f, 0.07877912f, -0.15965295f, 0.26305795f, 0.38766208f, 0.37469658f, 
    0.41529790f, -0.05874718f, 0.57640153f, -0.21334225f, -0.40013903f, -0.54789788f, 0.00263094f, -0.38090357f, 
    -0.07685414f, -0.18838006f, -0.61047447f, -0.01803906f, 0.39019832f, -0.38941178f, 0.07210234f, 0.49851865f, 
    0.41213095f, -0.36101449f, 0.18667750f, 0.43072134f, 0.28275210f, 0.14940056f, 0.28317773f, -0.38140738f, 
    0.28545979f, 0.18368155f, 0.22795768f, -0.08098505f, 0.03241180f, -0.13270004f, -0.62116110f, -0.61153591f, 
    -0.00629068f, -0.26501113f, -0.40193069f, -0.49148828f, 0.31279457f, 0.32734805f, -0.06777344f, 0.47868142f, 
    0.05853097f, -0.11977814f, 0.13333035f, 0.01274727f, -0.34534103f, -0.12610421f, 0.10495287f, -0.11495207f, 
    0.16660804f, 0.35269326f, 0.27991581f, 0.53848588f, -0.01280053f, 0.06125307f, 0.34272027f, -0.23328479f, 
    0.11538617f, -0.34134564f, 0.55391121f, 0.68558329f, -0.40582669f, -0.32606173f, -0.48323593f, -0.34789789f, 
    -0.30642235f, -0.42117146f, -0.16547178f, 0.27868426f, 0.03798289f, 0.35600078f, 0.36653703f, 0.19973752f, 
    0.20097111f, 0.24188352f, 0.23314199f, -0.02456320f, -0.07659246f, -0.30267033f, -0.30007315f, -0.30286929f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.07607716f, -0.03391567f, 0.10835364f, 0.02880473f, 0.13567108f, 0.01636975f, 0.11519535f, 0.27443439f, 
    0.18694673f, 0.09392945f, -0.02046403f, 0.06483474f, 0.03967353f, 0.17204292f, 0.16802260f, 0.18247260f, 
    0.17541920f, 0.09647869f, 0.21648781f, 0.09541818f, -0.13776717f, 0.00746758f, 0.09790865f, 0.19007573f, 
    0.19438338f, 0.15884931f, 0.01190701f, 0.10408615f, 0.15250018f, 0.25005394f, -0.03890035f, -0.01874300f, 
    0.20243642f, 0.01167566f, -0.02355299f, 0.19156763f, 0.21078676f, 0.27074277f, 0.19626452f, 0.29213348f, 
    0.24433064f, 0.30505043f, 0.18394999f, 0.32165056f, 0.12225170f, 0.10539747f, 0.11068202f, 0.32534909f, 
    0.03412716f, 0.33954406f, 0.00678822f, -0.03797606f, 0.00656450f, 0.09559502f, 0.20407502f, 0.22033520f, 
    0.24356534f, 0.04081328f, 0.03640219f, 0.30691501f, 0.06435744f, 0.33677664f, 0.10047408f, 0.06592117f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.15534931f, -0.15217161f, 0.00424859f, -0.11274145f, 0.04435031f, -0.18281345f, 0.00331953f, 0.04633893f, 
    0.02101700f, -0.01565520f, 0.08698141f, 0.00133105f, 0.01680850f, -0.02906050f, 0.08212622f, -0.11722910f, 
    0.09887315f, 0.09343109f, -0.09767653f, 0.00373783f, 0.09822510f, -0.05278649f, -0.04139978f, 0.02863438f, 
    -0.26190653f, 0.03736401f, -0.03653672f, 0.00182034f, -0.07572782f, 0.07525078f, 0.17116331f, 0.10597403f, 
    -0.01413561f, -0.09068168f, -0.03026747f, 0.00033709f, -0.46237913f, 0.14148082f, 0.18854263f, 0.22313908f, 
    -0.01942377f, -0.10513710f, 0.11074507f, 0.04647858f, -0.00667406f, -0.05205784f, -0.03484786f, -0.01259867f, 
    -0.23255251f, 0.00731893f, 0.05246606f, -0.11653506f, -0.02634159f, 0.10177743f, 0.03670758f, -0.03301900f, 
    0.09926875f, 0.04769780f, 0.14598902f, -0.06813406f, 0.09074190f, -0.08380538f, 0.05265046f, 0.20287478f, 
    -0.10289823f, -0.05299154f, 0.05949682f, 0.11533315f, -0.04212628f, -0.05477135f, 0.00674752f, -0.13088900f, 
    0.15858382f, -0.15416512f, 0.10620700f, -0.20660987f, -0.05193026f, -0.06788503f, 0.07490191f, -0.10571273f, 
    -0.03441996f, -0.01606994f, 0.01511131f, 0.01959414f, 0.12336122f, 0.01633382f, -0.09333550f, -0.28466555f, 
    -0.06570920f, -0.07971447f, 0.00446306f, -0.00549660f, 0.06704593f, 0.06812517f, 0.02039686f, -0.17169301f, 
    0.09879383f, 0.10530530f, 0.03477798f, -0.15993710f, -0.09339412f, 0.06994469f, -0.18250705f, -0.04925386f, 
    -0.06603130f, 0.02353384f, -0.00752450f, -0.06831435f, -0.24909101f, 0.21713209f, -0.10217772f, 0.00934872f, 
    -0.06176985f, -0.01078478f, -0.08653335f, -0.08417672f, 0.05448561f, 0.02311952f, -0.04040025f, -0.11674973f, 
    -0.03280300f, 0.11660004f, -0.21709804f, 0.30320668f, -0.02763870f, -0.01441924f, 0.07044414f, -0.00343193f, 
    -0.02854523f, 0.08122700f, -0.02800871f, 0.08950942f, -0.51582044f, -0.00718584f, 0.26481518f, -0.07668257f, 
    -0.07249737f, 0.01838007f, 0.08411530f, -0.08654724f, 0.02222360f, -0.02551441f, 0.12913711f, 0.05177325f, 
    0.03856647f, 0.09475052f, -0.09226096f, 0.01694506f, -0.18944265f, -0.10000928f, -0.03992870f, 0.06901238f, 
    0.00607061f, 0.02129783f, -0.04585027f, 0.04198145f, -0.06122672f, 0.15536529f, 0.12444055f, -0.10794321f, 
    -0.00699042f, -0.00456256f, -0.05153596f, -0.01102055f, -0.03733546f, -0.05456475f, -0.15219615f, 0.02216691f, 
    -0.00657537f, 0.11050484f, -0.16115366f, 0.25208426f, -0.08387785f, 0.11925936f, -0.12688006f, -0.05065411f, 
    0.03352272f, 0.11319624f, 0.02252761f, 0.05053846f, 0.21215568f, -0.12321413f, -0.07917196f, 0.13258532f, 
    -0.09525522f, -0.08842123f, -0.00506085f, 0.00082667f, -0.03261359f, 0.08117197f, -0.06859041f, 0.08932132f, 
    0.11035334f, 0.20849079f, -0.02399920f, -0.15752700f, -0.02449207f, -0.05080869f, 0.10143840f, -0.16091003f, 
    -0.01888160f, -0.01820414f, 0.11138103f, -0.03660857f, 0.01641528f, 0.08085202f, -0.02933495f, 0.10105392f, 
    -0.14818895f, -0.10390512f, -0.03212663f, 0.01584860f, 0.08024812f, 0.00340939f, -0.14270400f, -0.04792405f, 
    -0.01544085f, 0.14686975f, 0.02136352f, -0.19478974f, -0.21409877f, 0.05117945f, 0.04646826f, 0.05666470f, 
    -0.01395769f, -0.00865008f, -0.02336960f, -0.03906173f, -0.11361244f, 0.12873413f, 0.01169835f, -0.10728383f, 
    -0.07066503f, 0.07181040f, -0.02518220f, -0.01704108f, 0.07082921f, 0.01174732f, -0.03644801f, -0.06294789f, 
    0.30813959f, 0.03726626f, -0.05611048f, -0.29109317f, 0.16161923f, -0.02392177f, 0.08943564f, 0.07882695f, 
    0.05582765f, 0.02971235f, -0.08630116f, -0.00180004f, 0.22057270f, 0.05665703f, -0.00225641f, -0.26828712f, 
    0.06947532f, 0.00828066f, -0.01104644f, 0.02412025f, 0.06706864f, -0.00223061f, -0.05018241f, 0.04686824f, 
    0.13801639f, 0.15020098f, -0.09149113f, 0.12279095f, -0.14884655f, 0.05504987f, -0.00447044f, -0.01785314f, 
    0.05725318f, -0.05821448f, 0.02549256f, -0.02267155f, -0.24440135f, 0.14143123f, 0.19827668f, -0.09716704f, 
    0.02218835f, 0.13414189f, 0.01172171f, -0.03295413f, 0.07302351f, -0.21096352f, -0.06016843f, 0.06491133f, 
    -0.19307812f, 0.09905656f, 0.08707379f, 0.15356043f, -0.02688463f, 0.01852733f, -0.03237462f, -0.05664213f, 
    0.00784082f, 0.00966398f, 0.05547056f, 0.01493761f, -0.20611899f, 0.11788394f, -0.19013907f, -0.19994164f, 
    -0.11682393f, 0.01532534f, -0.06421094f, 0.06024745f, -0.01494290f, 0.00864675f, 0.06053056f, 0.14942145f, 
    0.01347058f, 0.13220498f, -0.01827065f, -0.05339138f, 0.07787380f, 0.05550365f, 0.06403715f, 0.00443875f, 
    0.04054338f, -0.05516501f, -0.10441504f, 0.02491007f, -0.36632198f, -0.06081824f, 0.14006707f, 0.04702275f, 
    0.11307002f, -0.05578853f, 0.02136148f, -0.11172485f, 0.00975375f, 0.11418340f, -0.02665393f, 0.02152028f, 
    0.00046441f, -0.17390274f, 0.14831324f, -0.21508284f, -0.03854053f, -0.10523148f, 0.09644990f, -0.04258248f, 
    -0.02285144f, 0.16454160f, -0.04882156f, 0.05070994f, -0.14462031f, 0.12584896f, -0.06832273f, 0.01447626f, 
    0.02424741f, 0.02448046f, 0.01401551f, -0.07714200f, -0.09199521f, 0.01673792f, -0.04519426f, -0.03567066f, 
    -0.15278497f, -0.03233872f, 0.10763014f, -0.32854706f, -0.11274895f, 0.09381203f, 0.00089629f, 0.07126784f, 
    0.05508071f, -0.13020259f, -0.02481779f, 0.06720279f, 0.18123324f, -0.14018543f, -0.08128761f, -0.27526373f, 
    0.08665224f, -0.06759036f, -0.00102579f, 0.12255694f, -0.05390964f, -0.04888969f, 0.01962396f, 0.03359839f, 
    -0.12572995f, 0.19513105f, -0.16311124f, 0.11135314f, -0.01715736f, -0.06265532f, -0.08376355f, -0.04181833f, 
    0.08064725f, -0.03625716f, -0.00028207f, -0.05925009f, 0.02326623f, 0.03592250f, 0.05513936f, 0.12896752f, 
    -0.03757635f, 0.06970115f, -0.09872129f, -0.07414897f, -0.06266119f, 0.04010802f, 0.08884303f, -0.02456989f, 
    -0.15173137f, 0.05655149f, 0.09098789f, -0.23393688f, 0.02810222f, 0.03580783f, 0.01466288f, 0.12767299f, 
    -0.01198119f, -0.06286206f, 0.10325675f, 0.02540391f, 0.03479660f, -0.30349031f, 0.18705559f, -0.23664655f, 
    -0.00056483f, -0.03621015f, 0.07768220f, -0.00052009f, -0.07528933f, 0.04883577f, -0.10520366f, -0.02521153f, 
    0.14089629f, 0.00613024f, 0.04521760f, -0.22361064f, 0.06189366f, 0.00868280f, -0.09966219f, 0.06975215f, 
    -0.02461668f, 0.00294336f, -0.05926739f, 0.05245166f, -0.33543772f, -0.11524888f, -0.06778245f, 0.07605980f, 
    0.00548284f, 0.08838341f, 0.02247868f, 0.07383025f, 0.04986570f, -0.01737626f, -0.18127437f, -0.04408596f, 
    0.00178993f, -0.14793357f, -0.01268982f, -0.03709541f, -0.05829731f, -0.03756162f, 0.02434250f, 0.00630918f, 
    0.00104014f, 0.10430600f, -0.15637539f, 0.00571658f, -0.39079323f, -0.30439693f, 0.16370401f, -0.00562638f, 
    0.02977893f, 0.13371374f, 0.02976044f, 0.00128923f, -0.02228681f, 0.03997651f, 0.05182991f, -0.07850319f, 
    -0.05800899f, 0.00798224f, -0.00469956f, -0.12706323f, -0.10857289f, -0.03682526f, -0.08726387f, -0.06330882f, 
    -0.00889277f, 0.09899957f, 0.08801737f, -0.00758015f, 0.00626942f, -0.07328262f, 0.03684948f, 0.00929366f, 
    -0.04109075f, 0.01143535f, -0.01353488f, 0.04270883f, -0.05983278f, -0.05785617f, 0.13164595f, -0.12274458f, 
    0.14669846f, -0.00988766f, -0.05680828f, 0.07894536f, -0.18330322f, -0.16130340f, 0.05067386f, 0.02117122f, 
    -0.12776610f, -0.01455469f, -0.02290435f, -0.03600345f, -0.09185319f, -0.18949570f, 0.21372460f, -0.04716668f, 
    -0.07436307f, 0.08314413f, -0.03672444f, -0.00659872f, 0.01762292f, 0.01475784f, 0.01431880f, -0.01639205f, 
    -0.24863084f, 0.02247224f, 0.02852391f, -0.26902756f, 0.04991370f, -0.04906340f, -0.02693548f, 0.00260529f, 
    -0.09826995f, -0.07315296f, -0.00922369f, -0.03515851f, 0.04250930f, -0.07417940f, -0.05747138f, 0.09429961f, 
    0.02570298f, 0.08967739f, 0.11368716f, -0.02397210f, -0.01025164f, 0.03393456f, -0.08254100f, 0.07501894f, 
    -0.22829908f, 0.03363895f, -0.18141252f, 0.22718325f, -0.19741037f, 0.08891717f, -0.02464029f, 0.02146933f, 
    -0.00424678f, -0.00141364f, -0.04896035f, 0.02101329f, 0.08270064f, 0.02690212f, -0.10762355f, 0.08186361f, 
    -0.14288932f, -0.18554711f, 0.00476617f, -0.03943153f, -0.05669196f, -0.06619256f, -0.08111492f, 0.00627426f, 
    0.55497372f, 0.22905670f, 0.02898309f, -0.11543494f, -0.01474788f, 0.09941120f, -0.02490341f, -0.00797250f, 
    -0.06960161f, 0.02382891f, -0.00727527f, 0.02230521f, -0.20256373f, -0.05783707f, 0.03308615f, -0.12749843f, 
    0.03170038f, 0.00916917f, 0.05929084f, 0.02203129f, 0.00342087f, -0.10602237f, 0.03360025f, 0.06054359f, 
    -0.01943029f, 0.08727033f, -0.01994217f, 0.22766413f, 0.02971065f, 0.15676039f, -0.00142645f, 0.06452491f, 
    0.01976939f, -0.07013404f, 0.08945647f, 0.02121383f, 0.09441157f, -0.02027639f, 0.14244214f, 0.11666016f, 
    0.03198924f, -0.05283427f, -0.03331216f, -0.05411498f, 0.08005513f, -0.03149132f, 0.12474816f, -0.01398531f, 
    -0.15509544f, 0.02255743f, 0.23041336f, 0.07138203f, 0.06331419f, 0.07259279f, 0.07095669f, -0.01692622f, 
    -0.10708227f, 0.06745455f, -0.07327006f, -0.01004818f, 0.55306351f, 0.12154134f, -0.00272068f, -0.08319251f, 
    -0.03788549f, -0.05317682f, -0.03442875f, 0.06751297f, 0.15343451f, -0.11187448f, -0.00835435f, 0.04209735f, 
    0.17723544f, -0.04888075f, 0.05410242f, -0.03979835f, -0.01122922f, -0.01253085f, -0.06666911f, 0.06689349f, 
    -0.06067596f, 0.00774206f, -0.04330020f, 0.04305424f, 0.05143543f, 0.06052824f, -0.08876078f, 0.20305663f, 
    0.03225831f, 0.10062248f, 0.06255212f, -0.08620079f, 0.03419822f, -0.13770662f, 0.04927141f, 0.05234835f, 
    -0.03672538f, -0.04399687f, 0.04094366f, 0.16682869f, -0.04248262f, 0.02215056f, 0.05691435f, -0.12237562f, 
    -0.00181275f, -0.09786578f, -0.08286168f, -0.03774378f, 0.11673118f, -0.10958783f, -0.09475370f, 0.17975497f, 
    -0.02253011f, -0.06426968f, -0.09992371f, 0.06548033f, 0.02392993f, -0.12597282f, 0.07200839f, -0.01926396f, 
    -0.19703470f, 0.08054904f, 0.14966863f, -0.06177278f, -0.04410730f, -0.10515311f, 0.10855823f, -0.13877784f, 
    0.01035897f, 0.02192071f, -0.00992998f, -0.06727461f, -0.48824325f, 0.01481545f, -0.16903059f, 0.08892893f, 
    0.05556189f, 0.01348941f, -0.12808032f, 0.02874249f, 0.14890380f, 0.07310116f, -0.10675738f, -0.00712707f, 
    -0.01202031f, 0.17056312f, -0.09193870f, 0.02309815f, -0.08724113f, 0.01537084f, 0.05633023f, 0.00245805f, 
    0.00557783f, -0.07323837f, 0.13272762f, -0.02710957f, -0.20972329f, 0.00168575f, -0.04323179f, 0.17470308f, 
    -0.00149041f, 0.00691982f, -0.05541002f, -0.08220536f, 0.00476057f, -0.10050137f, 0.06599776f, -0.01999192f, 
    -0.16095555f, 0.04037186f, -0.06198783f, -0.10664206f, -0.02654326f, 0.08129215f, 0.06852020f, 0.06190889f, 
    0.00397841f, -0.04258223f, -0.07179540f, -0.04110936f, 0.00581946f, 0.04656778f, 0.12523456f, 0.18323050f, 
    -0.03530089f, 0.07016783f, 0.06499222f, -0.08890287f, 0.07471994f, 0.01721426f, -0.03817781f, 0.02316381f, 
    0.05817631f, -0.00936171f, 0.10930473f, -0.37183800f, -0.02305219f, 0.07367424f, -0.18686959f, 0.03109946f, 
    0.01451846f, -0.11798429f, -0.17586794f, -0.34178463f, 0.17355676f, 0.13652886f, -0.02970684f, 0.04284124f, 
    -0.00440880f, 0.03557776f, 0.02935192f, 0.07137042f, -0.02094160f, 0.08206552f, -0.03137436f, 0.00551870f, 
    -0.09273248f, 0.12467740f, -0.04447848f, 0.05367818f, -0.00498292f, -0.00194370f, -0.14362794f, -0.10725518f, 
    0.02411527f, 0.09866287f, 0.03363652f, -0.07351837f, -0.13213456f, 0.07722392f, -0.15007925f, -0.08786644f, 
    -0.09943738f, 0.08464096f, -0.08386432f, -0.18675649f, -0.03643711f, -0.10518455f, 0.01475153f, -0.09896479f, 
    -0.25013384f, -0.03292404f, -0.19786665f, -0.22385278f, 0.08418078f, -0.15347300f, -0.02258139f, -0.01576073f, 
    -0.02010324f, -0.08389405f, -0.04452598f, -0.00092225f, 0.11223057f, -0.18233404f, 0.10805695f, 0.01131766f, 
    -0.03935622f, 0.11059469f, -0.09185619f, -0.03306215f, -0.08330116f, 0.02357163f, -0.05619546f, 0.00483670f, 
    0.01400887f, -0.20546871f, 0.01276048f, -0.34064901f, -0.08488072f, -0.15513787f, 0.04055820f, 0.04219090f, 
    0.02038276f, 0.01169373f, -0.06190092f, -0.04832280f, 0.10850032f, 0.07278580f, 0.12282016f, 0.08139198f, 
    -0.04322928f, -0.03518564f, -0.07219757f, 0.03859618f, 0.01643740f, -0.04886143f, -0.04865225f, 0.02357155f, 
    0.08336211f, -0.02338465f, -0.03678438f, 0.00689454f, 0.00379036f, -0.11357751f, 0.02795408f, 0.03745654f, 
    0.08292096f, 0.05701959f, 0.03445977f, 0.06429383f, -0.11832526f, 0.17240328f, -0.26296034f, -0.03667652f, 
    0.07860149f, -0.18030955f, -0.06163154f, 0.06497943f, -0.01875756f, -0.03846255f, -0.03370067f, 0.01953821f, 
    0.20339260f, -0.06314904f, -0.06270184f, 0.19033179f, -0.19140182f, -0.04588754f, -0.07235397f, -0.01524406f, 
    0.05837303f, -0.12431338f, 0.07115532f, -0.11236217f, 0.13889159f, 0.02616457f, -0.11925442f, -0.01073007f, 
    -0.05523200f, 0.03351133f, 0.02873405f, -0.04049898f, -0.13301632f, 0.09151973f, -0.09953083f, -0.03857403f, 
    0.16040070f, 0.07640942f, 0.02719252f, 0.14807154f, -0.03671344f, -0.07221374f, 0.06627672f, -0.06645774f, 
    0.05566911f, -0.05486080f, 0.12526803f, 0.00379521f, 0.12588337f, 0.02666781f, -0.12301049f, -0.20453370f, 
    -0.09858249f, -0.01033366f, 0.03314108f, 0.04522360f, -0.02909274f, 0.01536828f, 0.09037928f, -0.00931867f, 
    0.19904803f, -0.49940351f, 0.04860330f, 0.12101740f, -0.08056948f, 0.00408164f, 0.02870369f, 0.07062062f, 
    -0.01612085f, -0.05667055f, -0.10990960f, 0.02919186f, 0.18977410f, -0.09344998f, 0.11678123f, 0.06753035f, 
    -0.11606543f, -0.03034245f, 0.02449939f, -0.04635466f, -0.03768110f, 0.05631710f, 0.19996856f, -0.08928228f, 
    0.04591787f, -0.09592843f, 0.01196048f, -0.03349068f, 0.13582258f, -0.08759726f, -0.15754141f, -0.01738733f, 
    0.12568332f, -0.03109059f, -0.17750303f, 0.00827312f, 0.22187033f, -0.09382242f, 0.10769776f, 0.28653336f, 
    -0.12111740f, 0.05133321f, 0.14592208f, -0.03324486f, -0.07403474f, -0.15890658f, 0.02968748f, -0.16305010f, 
    -0.09376477f, -0.21787351f, 0.01510202f, -0.19400783f, -0.01030274f, -0.09209431f, 0.04420609f, -0.12012218f, 
    -0.05676933f, -0.02373490f, 0.04257418f, -0.05213588f, 0.20473877f, -0.35769916f, -0.20897569f, -0.10931678f, 
    0.05955411f, 0.06993166f, 0.13314900f, 0.08189814f, -0.05936721f, 0.06392206f, 0.03414238f, 0.05591718f, 
    -0.15537357f, -0.07084739f, 0.01227087f, -0.15620118f, 0.02965998f, -0.05885127f, -0.03284910f, 0.07799248f, 
    -0.02231861f, -0.02948326f, 0.02715720f, -0.11164253f, 0.08991777f, -0.17502140f, -0.07694511f, -0.15751268f, 
    0.02597466f, 0.03848999f, 0.00638080f, 0.07803415f, -0.00737668f, -0.14131075f, -0.04190126f, -0.01392151f, 
    0.03571047f, 0.05127685f, 0.03475557f, 0.11982368f, 0.01709765f, 0.01016876f, 0.00956973f, 0.02422823f, 
    0.05606364f, 0.15041547f, -0.07096032f, 0.12628859f, -0.14717104f, -0.09739502f, -0.10073541f, -0.11413994f, 
    0.06204623f, -0.01810360f, 0.04108683f, -0.00059038f, 0.03388125f, 0.21690725f, 0.13262267f, -0.07832202f, 
    0.27695176f, -0.12128538f, -0.10705862f, 0.04264398f, 0.08777788f, 0.08412477f, 0.01347136f, 0.04260989f, 
    -0.07697633f, 0.11655420f, -0.01781083f, -0.00473749f, 0.30557555f, -0.29280582f, 0.09907369f, 0.12246047f, 
    -0.01557649f, -0.13524266f, -0.05104651f, 0.14619726f, -0.07511011f, -0.01720081f, -0.06184208f, 0.03535761f, 
    0.11475599f, 0.13341758f, -0.16357274f, 0.05755187f, 0.08812113f, 0.02358665f, -0.13166755f, -0.01661690f, 
    -0.08692461f, 0.08126305f, -0.04193586f, -0.05759011f, -0.30340657f, 0.18295670f, -0.21407640f, -0.00582654f, 
    -0.06411092f, 0.00004853f, 0.06923875f, 0.06565081f, 0.01105074f, -0.16864325f, -0.07872298f, -0.11029267f, 
    0.21472096f, -0.00198775f, 0.05897292f, -0.06669168f, -0.12817770f, -0.05041920f, -0.11529347f, 0.02616850f, 
    0.02734567f, -0.06061098f, -0.04212073f, -0.09124167f, 0.00653207f, 0.15698849f, -0.04156122f, 0.01393380f, 
    -0.06595369f, -0.00343736f, -0.11383224f, 0.06396507f, -0.05311062f, 0.00670262f, 0.06046889f, 0.05893691f, 
    0.19683625f, -0.33844188f, 0.00709753f, -0.16478887f, 0.01651551f, -0.07706445f, 0.12958749f, -0.00701288f, 
    -0.17528801f, 0.14036787f, 0.08100708f, -0.05508534f, -0.08861560f, -0.00769565f, 0.09720261f, -0.20844705f, 
    -0.02254214f, 0.08771678f, 0.09277446f, 0.05380324f, 0.15820229f, 0.08455417f, 0.00648608f, 0.09720419f, 
    -0.00824021f, 0.01263249f, -0.01409275f, -0.02927421f, 0.07731839f, 0.05003141f, -0.09647295f, -0.01607470f, 
    -0.06413784f, -0.06684007f, 0.00643569f, -0.04349815f, 0.13159987f, 0.07207619f, 0.02814776f, 0.18550646f, 
    -0.02123835f, -0.00202258f, 0.05683981f, 0.06963000f, -0.03669317f, -0.03266791f, -0.15658602f, -0.05972178f, 
    0.11641251f, -0.01442839f, -0.07807996f, 0.02846980f, 0.07298344f, -0.02321248f, -0.13252103f, -0.05272629f, 
    0.06219274f, -0.03177847f, 0.06171464f, -0.15247372f, -0.07452467f, 0.07660992f, 0.00890230f, -0.08879980f, 
    0.05715515f, -0.04372351f, 0.10638183f, 0.09512438f, 0.03339586f, 0.03380630f, 0.09714608f, -0.16102079f, 
    -0.06559345f, 0.04821010f, 0.04725714f, -0.03792715f, 0.01196466f, -0.12495771f, 0.02222035f, 0.00189577f, 
    0.05108790f, -0.03061127f, 0.00698144f, 0.08983503f, -0.00812158f, 0.10523397f, 0.05917408f, -0.00643615f, 
    0.01868086f, -0.05880569f, 0.10115159f, -0.03308055f, -0.07113159f, 0.13117391f, -0.06393434f, -0.10030695f, 
    -0.06959499f, -0.00622156f, -0.01499441f, 0.04959017f, 0.09433882f, -0.01613325f, -0.06456773f, -0.19092229f, 
    0.01050608f, -0.04920757f, 0.18499239f, -0.01382501f, 0.09828812f, -0.03628951f, -0.00822744f, -0.04450997f, 
    0.01494216f, -0.04704773f, 0.13335530f, 0.00561574f, 0.17237484f, 0.02729307f, 0.03567668f, 0.12215003f, 
    -0.14551988f, 0.07181174f, 0.01062547f, 0.06622438f, 0.15917975f, 0.14662920f, 0.07534105f, 0.02372691f, 
    0.04375195f, 0.02288386f, -0.00215604f, 0.04750088f, 0.14191236f, -0.23085630f, -0.00577312f, -0.00059322f, 
    -0.07417286f, -0.05591628f, 0.02161212f, -0.05769588f, -0.20318086f, 0.12565103f, -0.10913507f, 0.16152017f, 
    0.20447563f, 0.14640430f, 0.15447618f, 0.18430944f, -0.13736746f, 0.06365106f, 0.06412497f, 0.03484815f, 
    -0.03449342f, -0.01824772f, 0.03025056f, 0.02486058f, -0.13413167f, -0.14441469f, -0.06135088f, -0.34823802f, 
    -0.11769240f, -0.12366508f, 0.19461022f, 0.01716308f, -0.01782022f, 0.01714254f, -0.05318413f, -0.04099166f, 
    0.40726763f, 0.04186729f, -0.05362300f, -0.13187818f, -0.05147741f, -0.02893037f, 0.02949754f, 0.00922060f, 
    -0.05907638f, 0.07033063f, -0.01810313f, -0.02962063f, 0.14516322f, 0.07998209f, 0.13221601f, 0.09500180f, 
    -0.04428862f, -0.04771418f, -0.02701457f, -0.02173577f, 0.11529247f, -0.00497578f, -0.00810078f, -0.00002242f, 
    0.19234572f, -0.02607619f, -0.02238171f, 0.15623814f, -0.01892724f, 0.09320163f, -0.00723347f, 0.09453613f, 
    0.05182310f, 0.08596371f, 0.16829424f, 0.02721961f, 0.09102343f, 0.13590004f, 0.08720761f, 0.21597748f, 
    -0.18168068f, 0.04334825f, 0.07644610f, 0.04486757f, 0.02165321f, -0.01692775f, 0.08418354f, 0.01027136f, 
    -0.35940212f, -0.22809149f, -0.09320363f, -0.06041848f, 0.04211200f, -0.12807213f, 0.00736455f, 0.02142057f, 
    0.04376862f, 0.03189665f, -0.05174579f, 0.05155835f, 0.12523240f, -0.28001872f, -0.02522661f, -0.29147238f, 
    -0.01468547f, 0.02197149f, 0.05161820f, 0.11015420f, -0.16747874f, -0.01111223f, -0.00390029f, -0.09462888f, 
    -0.22301947f, 0.07527991f, 0.04710861f, 0.26791185f, -0.00750399f, 0.04674121f, 0.05975353f, -0.03931556f, 
    0.14210239f, 0.11330654f, -0.12322820f, -0.00224898f, -0.25029361f, -0.01581698f, 0.00112434f, 0.03013679f, 
    -0.04107322f, -0.00880941f, 0.09500649f, 0.09406354f, 0.05934808f, 0.09317884f, -0.11971985f, 0.05874842f, 
    0.22301191f, -0.03572324f, -0.14982700f, 0.00280939f, 0.07917660f, 0.03562569f, -0.04276795f, -0.05366951f, 
    0.04807554f, 0.05360056f, -0.00729988f, -0.03893016f, -0.14736882f, -0.00637206f, -0.16800112f, 0.11516837f, 
    -0.08126096f, 0.03341191f, -0.11120849f, 0.05400626f, -0.13541052f, 0.06629616f, -0.03590141f, -0.01264886f, 
    0.13561034f, -0.13545972f, 0.07461344f, 0.24110894f, -0.08703974f, -0.04623575f, 0.00402528f, 0.10077953f, 
    0.04053709f, -0.02597610f, -0.09505598f, 0.03794490f, -0.12429339f, 0.06075559f, -0.19958177f, 0.13123889f, 
    0.04241513f, -0.10105642f, -0.11983778f, 0.03007787f, -0.04232520f, -0.05345190f, -0.08718297f, 0.02958963f, 
    0.14349294f, 0.16377746f, -0.29146701f, 0.00519509f, 0.04435767f, 0.02665601f, -0.15995787f, -0.01010552f, 
    -0.06017413f, 0.01721966f, 0.21438493f, 0.14204432f, 0.32382539f, -0.16100256f, -0.08639824f, 0.05310908f, 
    0.10771854f, -0.04171855f, -0.07991873f, -0.04787555f, 0.02249719f, -0.05896940f, 0.03299856f, 0.08221845f, 
    -0.03521367f, 0.11417329f, -0.11018723f, -0.14429818f, 0.10805564f, -0.00598121f, -0.08759460f, 0.01646326f, 
    0.09045445f, -0.02583115f, -0.10524960f, 0.01807720f, 0.18065266f, -0.02784074f, -0.05559678f, 0.23672433f, 
    -0.13670574f, -0.01103916f, -0.04252572f, -0.03027842f, -0.05960803f, -0.08611501f, 0.07398347f, 0.10765588f, 
    -0.04638984f, -0.12967673f, 0.04175755f, -0.22627886f, -0.04886427f, -0.09233247f, -0.00892983f, 0.10204946f, 
    0.14893492f, 0.07691629f, -0.08877298f, 0.10252515f, -0.09226285f, -0.00249847f, -0.14736214f, -0.05007350f, 
    0.01414811f, -0.04247455f, -0.14676560f, 0.03204940f, 0.05110575f, 0.02590207f, 0.05303603f, 0.08134416f, 
    -0.00605729f, -0.02204584f, -0.17800853f, -0.04061369f, -0.03831449f, -0.08074940f, -0.03079070f, 0.14264350f, 
    0.07770534f, 0.03191396f, -0.04274978f, 0.09553399f, 0.00581088f, -0.12926973f, -0.24067213f, -0.14497486f, 
    0.09712660f, -0.01701621f, -0.08319391f, 0.02720908f, -0.02609179f, -0.02440793f, 0.00350289f, 0.02449152f, 
    0.26601613f, -0.02064734f, -0.00946512f, 0.15426779f, 0.00109996f, 0.06818635f, 0.01848495f, -0.02443657f, 
    0.02157387f, 0.00330260f, -0.01954089f, 0.00214007f, 0.21676247f, 0.17767148f, 0.06123950f, 0.15265422f, 
    -0.11645848f, -0.05871408f, -0.06464950f, 0.05674285f, -0.03086200f, -0.02511938f, -0.11630758f, -0.04682372f, 
    0.27150598f, -0.00686237f, -0.00396660f, 0.07893686f, 0.01841456f, 0.02004194f, -0.01749429f, -0.03095325f, 
    0.04275628f, -0.07089144f, -0.13777496f, 0.02906666f, 0.17602764f, 0.09424395f, -0.16786180f, 0.03811662f, 
    -0.14413044f, 0.02285881f, 0.07063899f, 0.02309931f, 0.00056573f, 0.00577005f, -0.03979412f, -0.03513452f, 
    0.23462132f, 0.11236161f, -0.25106740f, 0.01519065f, -0.09106585f, -0.03476112f, -0.05625771f, 0.00541711f, 
    -0.03291088f, 0.05997244f, 0.00751384f, 0.02177962f, 0.17509523f, -0.31338507f, 0.07326847f, 0.02751641f, 
    0.15859605f, -0.05921239f, 0.00264268f, -0.03148964f, 0.09349409f, 0.04239506f, -0.04629038f, -0.07711001f, 
    -0.12903957f, 0.03361497f, -0.01524565f, -0.20542282f, 0.02857610f, -0.04582374f, 0.06246051f, 0.01023711f, 
    -0.05811114f, -0.02256526f, -0.03916238f, -0.00908002f, -0.03363305f, 0.06734341f, 0.01091196f, -0.05115103f, 
    0.11229909f, -0.03549411f, 0.05439056f, -0.02648536f, 0.01565796f, -0.02191672f, -0.00192414f, -0.05958253f, 
    -0.10985997f, 0.05416828f, 0.07152199f, -0.04172076f, 0.15812145f, -0.12697108f, 0.05093820f, -0.06452210f, 
    -0.01971000f, -0.03635385f, -0.06815352f, 0.04685082f, -0.16456309f, -0.00066410f, -0.11905689f, -0.12178744f, 
    -0.02125056f, -0.00673079f, 0.10980273f, -0.04151481f, -0.00698503f, -0.08159330f, -0.03334400f, -0.00489625f, 
    0.01124876f, -0.11901758f, -0.07140937f, -0.05043381f, -0.15224430f, 0.08133933f, -0.00975494f, 0.00309039f, 
    -0.05119539f, 0.14338151f, -0.10016162f, -0.02912324f, 0.20477758f, -0.16733499f, 0.02411825f, 0.07216441f, 
    0.05851616f, 0.03247070f, 0.00945657f, -0.04496945f, -0.00270123f, 0.04484350f, -0.03558680f, 0.09657818f, 
    -0.03927802f, 0.00261141f, -0.01446985f, -0.05097865f, -0.00266860f, 0.08282331f, -0.02545216f, -0.04172343f, 
    0.00055216f, 0.09152970f, -0.04719342f, -0.04171884f, -0.19499695f, -0.04018377f, 0.12734720f, -0.17217560f, 
    0.00353292f, 0.05550379f, 0.03130115f, -0.04785419f, 0.04111147f, -0.00984342f, 0.02125952f, -0.07407632f, 
    0.03914211f, 0.01376670f, -0.16637111f, 0.02695851f, -0.02680096f, -0.03276413f, -0.00803877f, 0.02088431f, 
    0.01958924f, 0.07777363f, 0.07558061f, 0.02858911f, -0.06292240f, -0.02741763f, 0.07062207f, 0.15420175f, 
    0.12010364f, 0.08282919f, 0.03565560f, -0.06471905f, 0.03146831f, -0.00947080f, -0.03148757f, -0.02330022f, 
    0.06923854f, -0.01485355f, -0.06459653f, 0.26923421f, -0.08230261f, 0.05090062f, 0.05677577f, 0.04075441f, 
    -0.02127164f, -0.00627375f, -0.01340930f, -0.00630883f, 0.15539755f, 0.00703237f, -0.19745082f, 0.08242647f, 
    0.02187308f, -0.00472117f, 0.01673431f, -0.12841958f, 0.01341232f, -0.02461871f, 0.06549976f, -0.04489840f, 
    -0.15038000f, 0.05331741f, -0.05185361f, -0.31101793f, 0.11440876f, 0.07839317f, 0.07822055f, 0.01357429f, 
    0.02903341f, 0.02865765f, -0.09113856f, -0.04193263f, -0.26027974f, -0.05944233f, 0.02173530f, 0.07176679f, 
    -0.12931323f, -0.05726674f, -0.01340755f, 0.09349976f, 0.00386793f, -0.09642255f, 0.00202746f, -0.02965315f, 
    0.01842305f, 0.19192424f, 0.15739562f, 0.32909256f, -0.02752468f, -0.13032527f, 0.03394283f, 0.06880313f, 
    -0.02328136f, 0.07390443f, -0.00827865f, 0.00580364f, 0.27176580f, 0.11102685f, 0.16140412f, 0.25754923f, 
    -0.09419021f, -0.10849943f, -0.03096639f, 0.11038569f, -0.04930241f, 0.03177064f, 0.02211685f, -0.06883386f, 
    -0.03981389f, -0.00138722f, -0.16828889f, -0.08969275f, 0.07773776f, -0.01021222f, -0.04659575f, 0.04097276f, 
    -0.02534961f, 0.03374736f, -0.04003780f, -0.06134066f, 0.04328724f, 0.07055553f, -0.13049099f, -0.05023886f, 
    0.14215825f, -0.03004634f, 0.06772437f, -0.10021953f, -0.08253770f, -0.02731300f, -0.07348502f, -0.14282534f, 
    0.14948373f, -0.22223997f, 0.04228019f, 0.05255715f, 0.00207225f, -0.02043871f, -0.06268670f, -0.02969901f, 
    0.07160597f, -0.02619786f, 0.02474546f, -0.00798312f, 0.13148224f, 0.03629731f, -0.17205763f, -0.00003207f, 
    0.02289171f, -0.03335182f, 0.05707838f, -0.02950637f, -0.03056150f, 0.11458574f, 0.09748612f, -0.09465309f, 
    0.24009013f, -0.13531743f, 0.17258546f, 0.02728955f, -0.13036180f, -0.05932725f, -0.03637572f, 0.11496963f, 
    0.06818248f, -0.00468623f, -0.04454957f, -0.00423097f, 0.30310193f, -0.07649077f, -0.16326015f, -0.08322875f, 
    -0.12068507f, -0.00568164f, -0.09029637f, -0.00172868f, -0.06077830f, -0.01418837f, -0.09185760f, 0.07062532f, 
    -0.25334713f, -0.04314254f, 0.03304422f, -0.09803072f, 0.06880102f, -0.00079639f, -0.00081433f, 0.06279388f, 
    -0.07440381f, 0.09359490f, -0.01841978f, -0.08121131f, 0.02333281f, 0.01050686f, -0.05120577f, -0.02371114f, 
    -0.06318815f, 0.11083789f, 0.05756555f, -0.04019625f, -0.07405245f, 0.00242281f, -0.03018793f, -0.07671457f, 
    -0.11710756f, 0.01058032f, -0.01730832f, -0.17682552f, 0.10725541f, -0.06521250f, 0.05106547f, -0.06218196f, 
    -0.10141774f, 0.02157650f, 0.08246203f, -0.10959312f, -0.36778057f, -0.08045332f, 0.06427096f, 0.18229215f, 
    -0.03628242f, -0.08670721f, -0.10840987f, 0.01149139f, -0.05482399f, -0.02775005f, 0.09574310f, -0.01852980f, 
    0.38462010f, 0.00423932f, -0.26443928f, -0.09935925f, 0.00225932f, 0.09487149f, -0.06585175f, -0.05666935f, 
    -0.03376923f, -0.06702746f, 0.02314062f, 0.05048374f, 0.08671142f, 0.00609527f, -0.06814894f, 0.06825654f, 
    0.00622068f, -0.00549196f, -0.00674896f, -0.03962123f, 0.00482800f, 0.10015731f, 0.06542329f, -0.06777804f, 
    0.12149105f, 0.10188574f, 0.04430180f, 0.07846853f, -0.10425986f, -0.04406210f, 0.08539177f, 0.04191585f, 
    0.08671819f, -0.03451863f, -0.10648444f, 0.07607014f, -0.07691305f, -0.25276682f, 0.00225256f, -0.18004100f, 
    -0.16876170f, -0.13213928f, -0.02611747f, 0.03725164f, 0.03594223f, -0.03301887f, -0.08332607f, 0.05556673f, 
    0.20123586f, -0.10592382f, 0.06973053f, -0.09284291f, -0.09301391f, -0.15460204f, -0.20297360f, -0.02789089f, 
    -0.00296028f, 0.03146460f, 0.00862705f, 0.02286371f, 0.12958865f, 0.06949532f, -0.19190238f, -0.10166764f, 
    -0.04203962f, 0.05457602f, -0.13217424f, 0.07513939f, -0.02802113f, -0.02313738f, -0.00228834f, 0.10246366f, 
    0.10831495f, -0.06356846f, 0.00880910f, 0.11073928f, -0.06640352f, -0.02845400f, 0.08657524f, -0.00909669f, 
    -0.07692674f, -0.07650552f, -0.11020831f, -0.00357028f, -0.22863472f, -0.21045096f, -0.02849550f, -0.16997398f, 
    -0.17779340f, 0.06996246f, -0.12149239f, -0.07027230f, 0.00085646f, -0.02487086f, -0.07756642f, -0.05503033f, 
    -0.14880055f, 0.02532661f, -0.05402080f, -0.03727637f, 0.06788333f, -0.07742925f, -0.00467244f, -0.05056617f, 
    -0.14513388f, -0.04339089f, -0.03449127f, -0.11091214f, -0.04510996f, -0.34734103f, 0.07196444f, -0.22533895f, 
    -0.06821621f, 0.02265227f, -0.02837486f, 0.05464956f, 0.00694947f, -0.09913518f, 0.09485649f, -0.01692390f, 
    0.00581004f, -0.03218745f, -0.06066085f, -0.19859885f, 0.13093050f, 0.07324005f, -0.01686035f, 0.00845661f, 
    0.02825991f, 0.09665404f, 0.09967282f, -0.04278951f, -0.35679010f, -0.02815980f, -0.05482731f, -0.21630074f, 
    0.04009958f, 0.01617548f, -0.00797285f, -0.08188097f, 0.02637656f, 0.07277375f, -0.00095582f, -0.03279004f, 
    -0.15936859f, 0.06613827f, 0.15294476f, -0.04601158f, -0.11082998f, -0.06970587f, 0.12425176f, -0.01085944f, 
    -0.10212058f, -0.08687027f, 0.02985477f, 0.01011335f, 0.05149012f, 0.08585277f, -0.01063091f, -0.03949494f, 
    -0.03179883f, -0.00705089f, 0.01234707f, 0.10122158f, -0.07242351f, 0.02968104f, 0.08589126f, 0.01935954f, 
    0.31667551f, -0.10970809f, 0.11082976f, 0.02435147f, 0.09534553f, -0.00173175f, -0.04641583f, 0.07375889f, 
    -0.00367466f, -0.02495822f, 0.08756377f, 0.02947195f, -0.05095695f, 0.11489490f, -0.07843450f, -0.08326335f, 
    0.05378403f, 0.06964380f, -0.02919550f, 0.04857434f, 0.00482300f, 0.08921178f, -0.06007467f, 0.00523532f, 
    0.32651484f, 0.07691565f, 0.09989352f, 0.14343221f, -0.01349730f, -0.05619830f, 0.03157046f, 0.03827041f, 
    0.02053242f, 0.09784299f, 0.06258713f, -0.05469444f, -0.20429164f, -0.00075438f, -0.00230584f, -0.19961765f, 
    0.02989359f, -0.09430706f, 0.01803705f, -0.14944953f, 0.01963101f, 0.03682870f, 0.03690225f, -0.00343141f, 
    -0.26554909f, 0.01968645f, -0.00534181f, -0.23588434f, -0.12959220f, 0.04423555f, -0.12345962f, 0.07740434f, 
    -0.00097001f, -0.22917542f, 0.04569582f, -0.08434904f, 0.02123957f, 0.09377892f, -0.07393342f, 0.03390731f, 
    -0.01042608f, 0.07079931f, -0.03157780f, 0.01026955f, -0.04150661f, -0.01277960f, -0.05518783f, -0.06311632f, 
    0.28904718f, -0.14985356f, 0.14120039f, 0.00568410f, -0.09831211f, 0.02164846f, 0.04207588f, -0.00444382f, 
    0.06255404f, -0.00474468f, 0.03204888f, 0.02101313f, 0.27575347f, -0.04667633f, 0.05210328f, -0.10618424f, 
    0.00002167f, -0.02071202f, 0.02772019f, 0.04499263f, 0.03914297f, -0.02447379f, 0.03853519f, -0.11278491f, 
    -0.04362947f, 0.12726328f, -0.06542475f, -0.03435585f, 0.09423187f, 0.00814461f, 0.06103126f, 0.00981840f, 
    -0.00302278f, 0.06578218f, -0.04106758f, -0.04816443f, -0.05184205f, -0.01688990f, -0.18440831f, -0.02000984f, 
    -0.00010047f, 0.08483470f, -0.07609152f, -0.04051103f, -0.08716504f, -0.00253749f, 0.07008716f, -0.00936257f, 
    -0.14640175f, -0.08653668f, 0.08571535f, 0.01688724f, 0.00585973f, -0.08702356f, -0.02583757f, 0.01260243f, 
    -0.02434210f, -0.09229495f, -0.09204994f, 0.05003304f, 0.12284271f, -0.04671006f, -0.05388717f, 0.03674258f, 
    0.01559445f, -0.04132591f, -0.00130767f, 0.09476475f, -0.08173002f, 0.08265024f, -0.00236153f, -0.13954358f, 
    0.16508599f, -0.03859270f, -0.14831172f, -0.11603507f, 0.00651057f, 0.07940018f, 0.10064360f, -0.04267517f, 
    -0.10854715f, 0.00800206f, 0.01494849f, -0.01557749f, 0.58990580f, -0.08892170f, -0.01363099f, 0.01400968f, 
    -0.11724804f, -0.10826469f, -0.09812907f, 0.00173393f, -0.01922163f, -0.01458859f, 0.00236256f, -0.07985621f, 
    -0.15994897f, -0.05073532f, -0.18440016f, 0.15366885f, -0.08990812f, 0.11604969f, 0.02690355f, -0.02347093f, 
    -0.01746025f, -0.07880655f, 0.01113535f, 0.08057231f, 0.20539245f, -0.05568940f, 0.07421298f, -0.07497168f, 
    -0.07207806f, 0.04555321f, 0.02628324f, 0.02004813f, -0.04537724f, -0.07324380f, -0.04061647f, -0.08836318f, 
    0.20928180f, -0.01649618f, 0.04264815f, 0.12753223f, -0.11477464f, -0.09035773f, 0.03183284f, -0.15994188f, 
    -0.02637436f, -0.05572538f, -0.03058322f, 0.06183881f, -0.03511376f, -0.14960404f, -0.04804146f, -0.12030797f, 
    -0.05063407f, 0.11984539f, -0.08850875f, -0.07527886f, -0.03811078f, -0.03749487f, -0.14377229f, 0.01206200f, 
    0.06276508f, 0.00598073f, 0.02127142f, 0.10717186f, 0.17294618f, -0.00909848f, 0.07741079f, -0.13483371f, 
    0.04999575f, 0.12356918f, -0.06471044f, 0.10587089f, 0.05361891f, -0.04047002f, -0.09256758f, -0.13099988f, 
    -0.05588617f, 0.00192342f, -0.11040815f, -0.02584770f, 0.06144468f, -0.01601352f, 0.02888994f, -0.04454839f, 
    -0.15682913f, 0.12080482f, 0.26538867f, -0.03914260f, 0.01771235f, -0.00925331f, -0.02496490f, 0.00192565f, 
    0.01514177f, -0.04623728f, -0.08496828f, 0.02517733f, -0.02351987f, 0.03955244f, 0.04921754f, -0.13585339f, 
    0.07589344f, -0.05772092f, 0.04662475f, 0.03325886f, -0.04251460f, 0.10159710f, -0.04557868f, -0.02585192f, 
    -0.09311586f, 0.23979867f, 0.05418860f, -0.02676491f, 0.05122751f, 0.03035706f, 0.03899659f, 0.02824177f, 
    -0.08328796f, 0.01735271f, 0.00865763f, 0.05956191f, 0.20771414f, -0.30006450f, -0.06882580f, 0.27379987f, 
    -0.10168675f, -0.05336803f, -0.04784885f, 0.03939526f, 0.00614609f, -0.13362198f, 0.07388917f, 0.05732703f, 
    0.16890082f, -0.02024443f, 0.02016103f, 0.16232507f, -0.09369427f, 0.03668852f, -0.11093731f, 0.07894930f, 
    -0.03887337f, -0.00954704f, -0.04187054f, -0.03831431f, -0.31496450f, -0.39040965f, -0.20474824f, -0.08126078f, 
    -0.09955528f, 0.00929059f, 0.05206556f, -0.09496586f, -0.07645456f, 0.02040466f, -0.02132204f, 0.02239264f, 
    -0.28554812f, -0.14751472f, 0.07554083f, -0.11880884f, 0.03347158f, 0.09736818f, -0.02721545f, -0.00775378f, 
    0.02840950f, -0.08659042f, -0.00962517f, 0.05960602f, -0.31214654f, 0.26016897f, -0.02371738f, 0.12488370f, 
    0.00467211f, 0.05337255f, 0.01667955f, -0.05798060f, -0.07703134f, 0.07026873f, 0.03332839f, -0.02664310f, 
    -0.10251150f, -0.12111662f, -0.16366827f, 0.05389984f, -0.00349717f, -0.14722753f, -0.00762751f, 0.03147127f, 
    0.00476189f, -0.03671154f, -0.03780443f, 0.03193346f, 0.38719150f, -0.06950018f, 0.15766661f, 0.07932299f, 
    0.01794868f, -0.07490249f, -0.00955922f, -0.00957887f, 0.04742319f, -0.09655148f, 0.03640327f, -0.03190941f, 
    0.05861460f, -0.52036178f, -0.29351774f, 0.22778371f, 0.07792732f, -0.03784659f, -0.04303977f, 0.03031313f, 
    -0.02992352f, -0.06150771f, -0.06663876f, -0.04981472f, -0.15593506f, -0.08297323f, -0.10577545f, -0.00427051f, 
    -0.04126912f, 0.00430702f, -0.02402959f, 0.04746488f, 0.03408056f, 0.08559693f, 0.01406612f, 0.01069195f, 
    0.20154791f, -0.16161060f, -0.07256731f, -0.11680180f, -0.00199104f, 0.07699233f, -0.01293737f, -0.06654195f, 
    -0.05990396f, 0.02253878f, -0.09473346f, 0.06820804f, -0.06932207f, -0.32594973f, -0.19946982f, 0.28960964f, 
    -0.06348076f, -0.00255685f, 0.01021973f, -0.11355603f, -0.01286493f, -0.02624318f, -0.09964754f, 0.04957549f, 
    -0.02731966f, 0.09770392f, -0.05621283f, -0.04822106f, -0.09385332f, 0.01385801f, -0.00087888f, -0.05106155f, 
    -0.08817763f, 0.10313985f, 0.02013229f, -0.08543437f, 0.06422179f, -0.13766542f, -0.11809763f, 0.15822181f, 
    -0.01053236f, 0.05029062f, 0.00695492f, -0.00970297f, -0.09732490f, 0.13140319f, 0.04179640f, -0.05263947f, 
    0.36005953f, 0.22447680f, -0.05988399f, 0.12889242f, -0.05678403f, 0.05597497f, -0.04958956f, 0.13082446f, 
    -0.01225245f, -0.04367687f, 0.01890219f, -0.03396287f, 0.12259097f, -0.14346474f, 0.00548514f, -0.04253143f, 
    -0.09985422f, -0.04071324f, -0.07253467f, 0.05725130f, 0.06360690f, -0.04259830f, 0.00641269f, 0.03457598f, 
    -0.09194426f, -0.01281575f, 0.02179965f, -0.07118753f, -0.10894380f, -0.06623775f, 0.07075887f, -0.00222791f, 
    0.00505072f, -0.00054910f, -0.06638110f, 0.02007275f, -0.09549303f, 0.14778480f, -0.03410538f, -0.13617234f, 
    -0.12950800f, -0.08078864f, 0.00602745f, -0.10477358f, -0.01921220f, -0.08085262f, 0.01591714f, 0.12692153f, 
    -0.24673931f, -0.14128773f, 0.22288378f, 0.07013082f, 0.07255978f, 0.01972179f, 0.04955138f, -0.05421457f, 
    -0.05473707f, -0.04764665f, 0.07980413f, -0.06117938f, 0.21194103f, 0.10394609f, 0.16501911f, 0.07581083f, 
    0.10662868f, 0.09595665f, -0.00173637f, 0.04886422f, -0.03199417f, -0.03726152f, -0.06591642f, -0.09512735f, 
    -0.05408822f, 0.11356600f, -0.09917171f, -0.00161894f, 0.03135504f, -0.02438652f, 0.06163744f, -0.09045181f, 
    -0.03811364f, -0.05238770f, 0.06500237f, -0.11293311f, 0.33066902f, -0.27309948f, -0.15534651f, -0.03751848f, 
    -0.04827198f, 0.01594307f, 0.05224341f, 0.04066191f, 0.01046891f, -0.01869510f, -0.00689315f, 0.06546916f, 
    -0.05445561f, -0.03495625f, -0.09068022f, 0.03942386f, -0.00472865f, -0.12385247f, 0.12969728f, 0.04768311f, 
    -0.01296793f, -0.07582621f, -0.01148530f, -0.05618886f, 0.44346496f, 0.07908507f, 0.06661966f, 0.04576179f, 
    0.00000120f, -0.03391463f, 0.00360723f, 0.09547639f, -0.10212660f, 0.12052824f, -0.03634869f, -0.01775058f, 
    -0.08854868f, 0.06227608f, 0.17448466f, 0.07790727f, -0.01311845f, 0.11385053f, 0.06152302f, -0.03962865f, 
    -0.09521636f, 0.05515468f, -0.01391369f, 0.07785454f, -0.42887324f, -0.21134749f, -0.03217856f, 0.07845559f, 
    -0.04947129f, -0.01760483f, 0.08338422f, 0.00510181f, -0.03116799f, -0.01059977f, -0.00067035f, 0.01625500f, 
    0.14588083f, -0.03858962f, -0.03383449f, 0.04206645f, -0.17179254f, 0.00733800f, -0.04947599f, 0.12514453f, 
    0.02309181f, 0.01191371f, -0.07975633f, 0.00179963f, 0.03246468f, -0.03896947f, -0.01704846f, -0.11520527f, 
    -0.07699314f, 0.00998328f, 0.01138818f, -0.02823892f, -0.10985397f, 0.03722210f, -0.07124922f, -0.05363275f, 
    -0.21826436f, 0.24862196f, 0.25956982f, 0.14543924f, -0.02841671f, -0.04364195f, 0.10388823f, -0.05166987f, 
    -0.02242246f, 0.00554147f, -0.04138764f, 0.03512047f, -0.20314001f, 0.02483329f, -0.19079071f, -0.10542075f, 
    -0.05434820f, -0.01646468f, -0.01718796f, -0.04837066f, 0.02772507f, -0.02176847f, -0.05941268f, 0.07564541f, 
    -0.09226109f, -0.02749814f, -0.03375333f, 0.03176650f, -0.11834630f, -0.07715819f, 0.08356361f, 0.02100365f, 
    -0.05292346f, -0.00300620f, 0.04300054f, 0.00140913f, 0.09167664f, 0.03655401f, 0.07754097f, -0.00091440f, 
    -0.13401653f, -0.08159367f, -0.01366056f, -0.08169911f, -0.03633760f, -0.07852565f, 0.05376976f, 0.18178035f, 
    0.15348302f, 0.04112802f, 0.01455513f, -0.13403361f, 0.00765041f, -0.12833914f, -0.00224410f, 0.01941671f, 
    -0.05105716f, -0.05582114f, -0.01720246f, -0.06410597f, 0.02585907f, 0.19171584f, 0.11769552f, 0.05771795f, 
    0.05108454f, -0.00230570f, -0.06172732f, -0.01762909f, -0.02734246f, -0.08518178f, 0.11986493f, 0.15315366f, 
    -0.09735726f, 0.10912927f, 0.09507976f, 0.08826718f, 0.02382127f, 0.00777908f, 0.11328516f, -0.06127753f, 
    0.04480220f, -0.03326415f, -0.05214579f, 0.05096580f, 0.07733045f, -0.09406313f, -0.01148873f, 0.12003121f, 
    -0.11253342f, -0.00248662f, 0.03256246f, 0.04167509f, -0.02553738f, 0.01266164f, -0.07170945f, -0.03946894f, 
    -0.03223266f, -0.00951295f, -0.05091202f, -0.01200411f, 0.07137111f, 0.07778405f, -0.03766130f, -0.00457843f, 
    0.01102686f, 0.00346683f, -0.02448411f, 0.03770724f, 0.11121840f, -0.04428345f, 0.05871303f, -0.14082855f, 
    0.06319505f, -0.07348027f, -0.06256779f, 0.05704064f, -0.03116289f, -0.02815258f, 0.09094327f, -0.11047673f, 
    -0.19223309f, -0.45506978f, -0.27524608f, -0.02039866f, -0.04117133f, -0.07401893f, 0.00313237f, -0.06370248f, 
    0.07291469f, 0.03690457f, 0.07143661f, 0.02696852f, 0.19314298f, 0.06719582f, 0.07854915f, 0.09337799f, 
    0.06318961f, -0.04015170f, 0.00860120f, 0.00246180f, -0.01131635f, 0.06873900f, 0.02326448f, -0.00462411f, 
    -0.24630979f, -0.22980981f, -0.13285543f, 0.02289057f, -0.11675208f, 0.13497490f, -0.12783834f, 0.09933975f, 
    0.04033910f, -0.00646314f, 0.03836827f, 0.04621405f, -0.43207982f, -0.12833770f, -0.26120791f, -0.09847075f, 
    -0.00951038f, -0.07033917f, -0.02642332f, -0.04568513f, 0.01768974f, 0.06258354f, 0.00298459f, 0.00477986f, 
    -0.30095658f, -0.04735731f, 0.17584585f, -0.11323130f, 0.05180857f, 0.07944481f, 0.05436246f, -0.09247981f, 
    0.02522952f, 0.02513353f, -0.14456294f, -0.01493127f, -0.40706614f, -0.55675107f, -0.16647714f, -0.02018174f, 
    -0.12326492f, -0.09883223f, -0.00427365f, -0.05649626f, -0.00335318f, -0.09364278f, 0.03043828f, 0.04307369f, 
    -0.18305621f, 0.07757248f, 0.01049961f, -0.18539982f, -0.03049246f, 0.01394905f, 0.01238739f, 0.06677391f, 
    -0.04623250f, -0.10201976f, 0.04441142f, 0.00059143f, 0.14247191f, -0.11128943f, 0.08383461f, 0.09630651f, 
    -0.05414529f, -0.01210772f, 0.02276010f, -0.02020245f, 0.06558309f, 0.07095256f, 0.00787881f, 0.02186175f, 
    0.25550765f, -0.11549756f, 0.01869022f, 0.02758802f, -0.00246004f, 0.05471420f, 0.19412868f, 0.06629374f, 
    -0.10192151f, 0.02771957f, 0.14879997f, 0.10269018f, -0.15300052f, -0.09092481f, -0.11214040f, 0.16320243f, 
    0.01278729f, 0.06434166f, 0.08884522f, -0.11987877f, -0.03096040f, -0.02188215f, -0.03296560f, -0.12400109f, 
    -0.11691464f, 0.00188540f, -0.05913422f, -0.03155281f, -0.08321579f, -0.09405418f, -0.03649320f, -0.02004228f, 
    0.04247121f, -0.11990191f, 0.15850396f, -0.07728839f, -0.04708224f, 0.02690478f, -0.11885671f, -0.02572219f, 
    0.06097675f, 0.06299102f, 0.08252711f, -0.06223918f, -0.06603520f, -0.01167793f, -0.03099413f, 0.06393057f, 
    0.22858417f, -0.24156816f, -0.22031517f, 0.00525051f, 0.00950878f, -0.04748283f, 0.01785110f, -0.06668024f, 
    0.02608390f, -0.10100378f, -0.03151165f, 0.03560693f, -0.00257914f, 0.11623616f, -0.09433900f, -0.06131930f, 
    -0.00528670f, 0.10195240f, 0.15424071f, 0.04589763f, -0.02279083f, 0.02802691f, 0.02683902f, -0.02027896f, 
    0.08697370f, 0.12520492f, -0.16337411f, 0.08384492f, 0.00784002f, -0.18598449f, 0.07826871f, -0.03574399f, 
    -0.03025202f, 0.03732293f, 0.00891740f, -0.05977261f, 0.23765533f, -0.22911397f, -0.09487683f, -0.06027958f, 
    -0.05048895f, 0.03297067f, 0.12272033f, -0.00089094f, 0.08992024f, -0.02621743f, -0.06647128f, -0.09149724f, 
    -0.01012589f, 0.17576730f, 0.08028589f, 0.12257261f, -0.06778499f, 0.07388441f, -0.01471488f, -0.00132170f, 
    0.03274881f, 0.08859260f, 0.02530848f, 0.04825368f, 0.20695937f, -0.04837900f, 0.13950202f, -0.15869899f, 
    0.04028735f, -0.12482495f, 0.09816615f, 0.01694957f, -0.04574985f, -0.00562878f, -0.08324444f, 0.05631237f, 
    -0.01318203f, -0.01261890f, 0.03023711f, -0.02835788f, -0.12055461f, -0.00855484f, 0.07562499f, 0.03522842f, 
    -0.00247862f, -0.06315314f, 0.12096080f, -0.04691270f, -0.07359736f, 0.03565969f, 0.10116532f, -0.05061772f, 
    -0.11053907f, -0.06669045f, -0.06231114f, -0.00601184f, 0.13492638f, 0.00454077f, -0.09800804f, -0.01573588f, 
    0.16058454f, 0.13241217f, 0.12171815f, -0.17614025f, -0.05954750f, -0.05993504f, -0.06774498f, -0.00146926f, 
    -0.10596795f, -0.16915445f, -0.00154638f, 0.06483681f, 0.17364804f, -0.00648947f, 0.12673445f, 0.16388772f, 
    0.09508722f, 0.08768903f, 0.13433914f, -0.09222142f, 0.01060170f, 0.02312862f, -0.04856003f, 0.01411806f, 
    0.12498919f, -0.00409054f, -0.15413541f, 0.07779610f, 0.02846173f, 0.06461401f, 0.08058156f, 0.09176976f, 
    -0.17907704f, -0.17076004f, 0.06440993f, 0.16338305f, -0.09218208f, 0.07530650f, -0.00423797f, 0.20575532f, 
    0.01455248f, -0.06100881f, 0.04486015f, 0.11579243f, 0.03623658f, -0.05253842f, 0.00002598f, -0.02012199f, 
    -0.40626410f, 0.03944765f, -0.00983401f, -0.05971159f, 0.02509153f, -0.01271342f, 0.05466115f, -0.02835612f, 
    -0.04267812f, 0.01044648f, 0.06239828f, -0.03522640f, 0.24499232f, 0.15297075f, -0.14973865f, -0.31619644f, 
    0.03881910f, 0.01665285f, 0.06227626f, -0.00404162f, -0.10553743f, 0.07180338f, -0.02581493f, 0.07978944f, 
    -0.14165840f, -0.03534838f, 0.20950012f, 0.05771353f, 0.02497572f, -0.06922461f, 0.01647038f, -0.04341738f, 
    -0.04315922f, 0.04059029f, -0.02309845f, 0.05528180f, 0.25211662f, 0.17646168f, -0.03248173f, -0.10408763f, 
    -0.04286368f, -0.02098956f, 0.06689570f, 0.06194769f, -0.04763812f, -0.03519886f, 0.00667372f, 0.08334770f, 
    -0.12449849f, -0.24822542f, -0.17446390f, 0.12770347f, 0.05585983f, -0.11446565f, -0.02583098f, -0.09161006f, 
    -0.04272566f, -0.02958595f, -0.06432747f, 0.03708866f, -0.07775581f, -0.19172379f, -0.04499535f, 0.02068819f, 
    -0.04878886f, -0.06738545f, 0.01265644f, -0.01274506f, 0.01809005f, 0.03908941f, -0.02773154f, 0.02099545f, 
    0.38688186f, -0.04852374f, 0.03039243f, -0.02175521f, 0.03318058f, 0.06943621f, -0.14150679f, -0.02674582f, 
    -0.06972014f, -0.02207007f, -0.03304699f, 0.02054787f, 0.01229147f, -0.30818531f, 0.16625482f, -0.18242702f, 
    -0.09702161f, -0.00197659f, 0.14396857f, 0.04966213f, 0.01132676f, 0.05352082f, 0.10558692f, -0.01569674f, 
    0.02836185f, 0.23864481f, -0.13951157f, 0.01025248f, 0.02168875f, 0.04415505f, -0.01733000f, -0.08453630f, 
    -0.06555776f, -0.05824870f, -0.07691877f, 0.05024328f, 0.26390573f, 0.37383655f, -0.35149312f, -0.31986770f, 
    0.02764648f, -0.04705016f, 0.02881122f, 0.04705906f, 0.02995023f, 0.01962257f, 0.00627044f, -0.00102293f, 
    -0.33346346f, -0.10279246f, 0.22720087f, 0.14553511f, -0.11635955f, 0.00126484f, -0.06013483f, 0.09099633f, 
    0.10664191f, -0.03324300f, 0.15349568f, 0.00092238f, -0.20345978f, -0.33674464f, 0.11961019f, -0.10130424f, 
    -0.06141871f, 0.03088456f, 0.03800658f, -0.01229891f, 0.06192853f, -0.04129474f, -0.00936117f, 0.00619125f, 
    0.26179475f, 0.13559194f, -0.00740250f, -0.06373232f, 0.00890141f, 0.09810026f, 0.02763712f, -0.06929495f, 
    -0.02445983f, -0.03487988f, 0.04096910f, -0.01206639f, -0.08175256f, 0.08873421f, -0.07031054f, 0.06581350f, 
    0.04088369f, 0.02580994f, 0.03089983f, 0.14607184f, 0.03613060f, -0.10288752f, -0.01002531f, 0.03171929f, 
    -0.01413048f, -0.11907954f, 0.05213554f, 0.16081890f, -0.07475501f, 0.05432793f, 0.07508457f, 0.12346237f, 
    -0.08868997f, 0.03874194f, 0.12434571f, 0.05781582f, -0.03020670f, 0.11897632f, 0.15495418f, 0.03857344f, 
    0.04336207f, -0.00458766f, -0.01588546f, 0.01639306f, 0.08510731f, 0.04280907f, 0.02009520f, -0.02283829f, 
    -0.02819941f, 0.05362223f, 0.04268642f, -0.02155883f, -0.04006086f, 0.04951540f, 0.06218769f, 0.01181558f, 
    -0.04275218f, 0.01947146f, 0.05589792f, 0.10845733f, -0.21618268f, 0.29078373f, 0.21768793f, 0.10654019f, 
    -0.13958257f, -0.02448110f, 0.02729999f, 0.02178787f, -0.00789953f, 0.07384350f, 0.10501643f, 0.04237295f, 
    -0.06757045f, -0.27336860f, -0.01757808f, 0.26250750f, 0.04914301f, -0.03391789f, -0.04805592f, -0.08346324f, 
    -0.03856152f, -0.00100736f, 0.10868236f, 0.13555992f, -0.23850195f, 0.08324008f, -0.08008263f, 0.10421645f, 
    0.07384463f, 0.02578107f, 0.07722370f, -0.01918303f, -0.09431222f, -0.08875961f, 0.02629321f, 0.02078464f, 
    0.04712413f, 0.07417016f, 0.10399175f, -0.06900773f, 0.09413167f, -0.04423251f, 0.00259521f, -0.03421920f, 
    0.03332472f, -0.02117842f, 0.05621665f, -0.12300742f, -0.34857732f, 0.04084098f, 0.15256302f, 0.10369827f, 
    -0.02126112f, -0.04142283f, 0.00760255f, -0.11769440f, 0.00918747f, -0.06051556f, -0.06474360f, -0.02966212f, 
    -0.07725735f, 0.02075824f, 0.02256049f, -0.23394747f, -0.01564462f, -0.01369436f, -0.02616761f, 0.00862574f, 
    0.00268586f, -0.15417765f, 0.04844508f, 0.02335887f, 0.11040556f, -0.02202410f, -0.15394127f, -0.07021601f, 
    -0.04262591f, 0.09036707f, -0.02082333f, -0.10367956f, 0.01245680f, -0.02517504f, 0.04350112f, -0.02459399f, 
    -0.53650546f, 0.08867580f, -0.02936334f, 0.07117562f, 0.00483244f, 0.10162233f, 0.11738943f, 0.05089092f, 
    0.08016665f, 0.07637480f, 0.05172640f, 0.09088497f, 0.26777902f, 0.23144434f, 0.07664573f, -0.36895356f, 
    -0.08509596f, 0.06639321f, -0.11139295f, -0.09648553f, 0.04732724f, -0.03638496f, -0.07847164f, 0.06937987f, 
    -0.28717875f, -0.09892659f, 0.00864910f, -0.11063459f, 0.04540218f, -0.03807451f, 0.01411814f, -0.02714306f, 
    0.06112245f, -0.11348608f, -0.05157339f, 0.05974768f, -0.20651397f, -0.20795228f, -0.03534033f, -0.20805411f, 
    0.04120753f, -0.09106094f, -0.00198102f, 0.06149300f, 0.06326301f, -0.02278768f, -0.04259849f, 0.00393182f, 
    -0.12942407f, -0.10566141f, -0.13441356f, -0.02901489f, -0.08365697f, -0.02823583f, 0.02944081f, -0.03164446f, 
    0.02641707f, -0.01552792f, -0.00308538f, -0.03439255f, -0.11820657f, -0.05629646f, 0.03305788f, 0.26442376f, 
    0.03811291f, -0.06957352f, 0.04394076f, 0.05693864f, -0.07835364f, -0.00306713f, 0.04560873f, -0.04476724f, 
    -0.35581684f, -0.00893420f, 0.01194065f, 0.04598297f, 0.04219620f, -0.11440984f, -0.04837890f, -0.00528099f, 
    -0.04536181f, -0.07335010f, 0.04066526f, 0.10325663f, 0.18512531f, -0.18975322f, 0.04763187f, 0.10894188f, 
    -0.05181751f, -0.05717193f, -0.03872242f, 0.09944605f, 0.00805422f, 0.11049521f, -0.02310549f, 0.02953470f, 
    -0.28004462f, -0.13638170f, -0.13848118f, -0.07517482f, 0.02888573f, -0.08541142f, 0.14716969f, -0.00391265f, 
    0.01183378f, 0.05953149f, 0.06882615f, 0.03978319f, 0.11260059f, 0.01144475f, 0.06924818f, 0.17870115f, 
    0.06082025f, -0.07205845f, 0.01498663f, 0.10398646f, 0.08595454f, 0.06687333f, -0.09242474f, 0.07752873f, 
    -0.08065841f, -0.17106161f, -0.03285728f, 0.03298840f, 0.02368386f, -0.00489056f, 0.02083626f, 0.08740050f, 
    0.00677948f, -0.02529498f, -0.13495654f, -0.01411334f, 0.19067775f, -0.07620870f, 0.00363734f, 0.09290240f, 
    -0.01187013f, -0.12271588f, -0.01386765f, 0.04192433f, 0.04050778f, -0.02926738f, 0.02414490f, 0.00814237f, 
    -0.13514325f, 0.02564199f, 0.00202507f, -0.00625625f, 0.03720810f, 0.00664029f, 0.00139977f, 0.03339101f, 
    0.03957852f, 0.02310887f, -0.13862993f, -0.06183876f, 0.11832660f, 0.06454945f, -0.05999598f, 0.06258648f, 
    0.11419306f, 0.03557958f, 0.04811357f, 0.06472189f, -0.10664290f, -0.01879329f, -0.09568042f, 0.12579086f, 
    0.15484668f, 0.17262277f, 0.15795323f, -0.11744552f, 0.01964195f, 0.08356753f, 0.05063154f, 0.08895848f, 
    -0.14517123f, -0.07570534f, -0.11188255f, 0.13911735f, -0.08648642f, 0.23399410f, -0.09496360f, 0.08292152f, 
    0.06718145f, 0.03784709f, 0.13309491f, -0.07720456f, 0.03636645f, -0.01521193f, -0.02226682f, -0.14574012f, 
    0.06746150f, -0.00357596f, 0.14347143f, 0.09383271f, 0.02439184f, 0.04803381f, -0.01066256f, -0.02023378f, 
    -0.01189086f, 0.00605270f, -0.06149301f, -0.03734132f, 0.02400955f, -0.01603905f, -0.07349133f, 0.07676315f, 
    -0.05708884f, 0.06447375f, -0.01270682f, -0.05361051f, -0.07247441f, -0.00438562f, 0.03561791f, 0.07837814f, 
    -0.30899721f, -0.25970623f, 0.05973433f, -0.04375142f, -0.05104756f, -0.03248762f, 0.01228297f, -0.09798210f, 
    0.10066615f, -0.02282589f, -0.01798486f, -0.13975967f, -0.07839336f, -0.16339795f, 0.06148593f, 0.07746737f, 
    -0.02558072f, 0.01018289f, 0.10248934f, 0.01671901f, -0.02067015f, -0.03200175f, 0.13257429f, 0.04770021f, 
    -0.39326391f, 0.14656828f, -0.09174887f, 0.07282555f, 0.04636545f, -0.10491052f, 0.05785925f, -0.02161383f, 
    -0.16430700f, -0.00268782f, -0.01046014f, 0.00545133f, -0.13025460f, 0.07917872f, 0.13229838f, 0.03551217f, 
    -0.05279389f, 0.00253771f, -0.07411321f, 0.00718501f, 0.11927590f, 0.02108242f, -0.00326327f, -0.02537951f, 
    -0.34405062f, 0.06333527f, 0.05518268f, 0.14663589f, 0.04333086f, 0.00878565f, -0.02165462f, 0.03716619f, 
    0.02046586f, 0.08285052f, 0.07824737f, -0.05207692f, 0.01069629f, -0.14069784f, -0.09731326f, -0.00551582f, 
    -0.09598599f, -0.03805744f, 0.02777946f, -0.00143437f, 0.01863178f, 0.01235903f, -0.01015049f, 0.00337015f, 
    -0.06952734f, -0.10445334f, 0.04019881f, -0.31503078f, -0.03970075f, 0.09151226f, -0.13409486f, -0.10100856f, 
    0.03681705f, 0.03450933f, 0.06106975f, 0.07399020f, -0.19311643f, -0.34003064f, 0.08055917f, 0.17378767f, 
    -0.16188051f, -0.02038856f, -0.06678667f, -0.13607629f, 0.08983110f, 0.00190981f, -0.01337478f, -0.09290428f, 
    -0.22540161f, 0.20465016f, -0.09738757f, -0.00383132f, -0.06678652f, -0.03837621f, -0.01075593f, 0.06203099f, 
    0.04096406f, 0.12505119f, -0.10264296f, 0.02924694f, -0.33920947f, -0.10819496f, 0.14717481f, -0.00501903f, 
    0.03782533f, -0.04716411f, 0.04207568f, -0.00982202f, 0.08941655f, 0.09384893f, -0.04761853f, 0.09007484f, 
    0.09009054f, -0.06698873f, 0.03154947f, 0.11926682f, -0.12957281f, 0.01795977f, 0.05669063f, -0.06147164f, 
    0.08324035f, -0.01935652f, 0.00829984f, -0.18949412f, -0.06743797f, -0.16341458f, 0.08560367f, -0.09210408f, 
    0.00513132f, 0.17210361f, 0.12821332f, -0.01765805f, -0.05217234f, -0.03091491f, 0.00370217f, -0.01042416f, 
    -0.02108387f, -0.15409833f, -0.10238751f, -0.05563244f, 0.06570426f, 0.11510523f, 0.00528768f, 0.04839662f, 
    0.06742078f, -0.17251347f, -0.05802684f, -0.09852485f, -0.03857663f, 0.08862314f, -0.08121514f, 0.07470280f, 
    -0.07760494f, 0.06000630f, 0.03515679f, 0.07355002f, -0.07822917f, 0.05073259f, -0.07864779f, -0.05545731f, 
    0.34059229f, -0.04950515f, -0.04703695f, 0.35717019f, -0.18988203f, 0.03028282f, 0.11647385f, -0.08966947f, 
    0.04248296f, -0.03573189f, -0.03274663f, -0.11318216f, -0.35189617f, -0.01048644f, -0.01733270f, -0.08469603f, 
    0.07534973f, -0.05190678f, 0.00496607f, 0.11896579f, -0.12067908f, 0.01767639f, -0.02348515f, -0.07298467f, 
    0.22695488f, -0.04934272f, -0.09377427f, -0.02633766f, 0.03574923f, -0.03063101f, 0.00875544f, -0.07179833f, 
    0.09796501f, -0.11184974f, -0.00317760f, 0.09557075f, 0.03144384f, 0.11168004f, -0.04525136f, -0.07405876f, 
    -0.04428860f, 0.00678877f, 0.03699851f, 0.07191437f, -0.02405977f, 0.02516331f, -0.11799331f, -0.05458461f, 
    -0.16271980f, -0.02083640f, 0.00554108f, 0.06898280f, 0.00652993f, 0.01394863f, 0.00708349f, 0.06929753f, 
    -0.11947837f, -0.06519618f, 0.09696718f, -0.14918590f, -0.05595902f, 0.07779329f, 0.05923447f, 0.20019665f, 
    0.06681809f, 0.03244379f, -0.01994951f, -0.01818846f, 0.17377821f, -0.00456634f, 0.01061156f, 0.01480274f, 
    -0.28552413f, -0.15773337f, 0.02835386f, -0.14408131f, -0.07003558f, 0.01405155f, 0.08302001f, -0.04030942f, 
    -0.00296356f, 0.03978165f, -0.03827031f, -0.05398192f, -0.50011808f, -0.23160981f, -0.21329954f, -0.05885551f, 
    0.09933012f, 0.05804227f, -0.05903773f, -0.20727137f, 0.14673325f, 0.05320903f, -0.01745616f, 0.07614458f, 
    0.01217123f, -0.04408648f, 0.05164058f, -0.07684395f, 0.13309620f, 0.02996377f, -0.06120428f, 0.03647964f, 
    -0.01366672f, 0.13533878f, 0.04928838f, 0.06016525f, -0.33615327f, -0.44666886f, 0.11818097f, 0.21480857f, 
    0.06876846f, 0.01009820f, -0.10001885f, -0.01205774f, 0.06771218f, 0.02053738f, 0.11218229f, 0.08063292f, 
    0.12998483f, -0.01197000f, -0.20192964f, 0.13720083f, -0.07379175f, -0.03894908f, -0.01183149f, 0.10459284f, 
    0.01676549f, 0.09166883f, -0.12235217f, 0.03429878f, -0.02488487f, 0.03624699f, 0.13139783f, -0.08062337f, 
    -0.02086866f, 0.03944574f, 0.08702496f, -0.09339631f, 0.00224317f, 0.01681877f, -0.00195641f, 0.19284955f, 
    -0.27138579f, 0.14754379f, 0.08901368f, 0.04639494f, -0.01378288f, 0.15250915f, 0.02982166f, 0.01094733f, 
    0.07959636f, 0.04765541f, 0.05206893f, -0.03689941f, 0.00545809f, 0.08175032f, -0.02027899f, 0.11176888f, 
    -0.07001679f, -0.00751134f, 0.00824859f, 0.06702853f, -0.00787650f, -0.04791312f, 0.00938285f, 0.07506684f, 
    0.00056961f, -0.00860682f, 0.25213215f, -0.00528034f, 0.03195786f, 0.01344816f, 0.15583560f, 0.03787958f, 
    0.13409500f, -0.05773125f, 0.08338352f, -0.10704397f, 0.05102786f, -0.09042971f, 0.00529997f, 0.02529744f, 
    -0.05525159f, -0.06508306f, -0.06028518f, 0.07393064f, -0.06158467f, 0.04682551f, -0.04948474f, 0.07147387f, 
    -0.09413432f, 0.06885933f, 0.08486742f, -0.00459119f, 0.30127159f, -0.03781939f, -0.06972782f, 0.02067965f, 
    0.05927857f, 0.00200192f, 0.05021090f, -0.03210503f, -0.22097500f, -0.13669710f, 0.36068109f, 0.09129004f, 
    0.03469708f, 0.07925080f, -0.00265909f, 0.00408553f, -0.01569267f, -0.02696262f, -0.05596190f, -0.02288961f, 
    0.04941917f, 0.08278642f, -0.00697137f, 0.03822799f, -0.10085420f, -0.06266919f, 0.11194085f, -0.00313924f, 
    -0.09709092f, 0.07003137f, -0.03795769f, 0.08087746f, -0.04139204f, -0.00005481f, -0.09879298f, 0.07702903f, 
    0.01544226f, -0.07413558f, 0.08070733f, -0.02071081f, -0.06317694f, 0.02677773f, 0.16876136f, -0.06536089f, 
    0.03011674f, 0.11181633f, 0.13949060f, -0.03301446f, -0.08332962f, -0.15614775f, -0.07581724f, 0.09523450f, 
    0.02788212f, -0.05026690f, -0.05125872f, -0.16462184f, 0.08898740f, 0.06226896f, 0.13086130f, 0.02469469f, 
    0.11371053f, -0.09007489f, -0.01748893f, -0.04080405f, -0.01283085f, 0.07301765f, -0.03101576f, 0.16421619f, 
    0.10428065f, 0.13989884f, -0.12896948f, -0.19523448f, 0.08182441f, 0.18706916f, 0.03249879f, -0.03820460f, 
    0.01334027f, -0.03626097f, -0.22065046f, -0.09991706f, -0.09889132f, -0.01384640f, 0.12757531f, 0.00824615f, 
    0.10269918f, -0.00976438f, -0.09197344f, 0.01762111f, 0.13533345f, 0.11707587f, -0.03235113f, 0.25593778f, 
    -0.19532216f, -0.05776683f, -0.00835060f, 0.16863684f, 0.06822947f, -0.02913832f, 0.11157256f, 0.01226551f, 
    -0.02399042f, -0.10033137f, -0.09191888f, -0.15885189f, -0.28041738f, -0.02298287f, -0.19493012f, 0.11532509f, 
    0.13635801f, -0.14801607f, 0.05471709f, -0.02142840f, 0.00564808f, 0.08958423f, -0.17488714f, 0.07941779f, 
    0.11888143f, 0.06168532f, -0.14360327f, -0.08919019f, 0.19769706f, 0.19986251f, -0.08022500f, -0.13791157f, 
    0.03617189f, -0.10800239f, -0.01093527f, 0.03019236f, -0.31398135f, -0.21727705f, -0.06860834f, -0.10577863f, 
    -0.03719350f, 0.02983459f, 0.10348423f, -0.12132319f, 0.15868662f, -0.01405649f, 0.09632721f, -0.02325971f, 
    -0.04484197f, 0.02108587f, 0.07816951f, 0.06533183f, -0.06538463f, -0.01587774f, -0.09041730f, -0.01551878f, 
    -0.03144573f, 0.01596025f, -0.00897921f, 0.04791125f, -0.01806444f, -0.01735923f, 0.10567649f, 0.24930193f, 
    -0.12894799f, -0.13479474f, 0.06308062f, 0.03118143f, -0.15488631f, 0.04140810f, 0.03584434f, 0.22416188f, 
    -0.24584775f, 0.11138268f, 0.03587674f, -0.21594693f, -0.02452553f, -0.00964251f, 0.05769175f, 0.01237628f, 
    0.08828284f, 0.06155637f, -0.08463881f, 0.02629003f, 0.23557878f, 0.22034369f, -0.03968297f, 0.03818059f, 
    -0.01281447f, -0.04366242f, -0.01430275f, -0.21041243f, -0.15307382f, -0.01385217f, -0.16343157f, -0.12343173f, 
    -0.31585172f, -0.01846023f, -0.10084463f, -0.11146114f, 0.01488638f, -0.04132184f, -0.10710769f, -0.30722326f, 
    -0.00104578f, -0.20057024f, 0.08794253f, -0.16244158f, -0.19375588f, -0.30164576f, 0.17133363f, 0.15028289f, 
    -0.02694009f, 0.01980310f, 0.01856368f, 0.08075813f, -0.07313463f, 0.08923758f, 0.00378725f, -0.04275295f, 
    0.07943166f, -0.17655842f, 0.10626365f, 0.16110058f, 0.00282976f, 0.03721724f, 0.08383007f, 0.15197000f, 
    -0.00451366f, 0.00258901f, 0.11191498f, 0.01014172f, 0.08850583f, -0.00322003f, -0.03259016f, -0.01464538f, 
    0.02268930f, 0.09543573f, -0.04231876f, 0.02323228f, 0.05017274f, -0.09382351f, 0.12076285f, -0.00380370f, 
    -0.00635844f, 0.14832926f, -0.11110855f, 0.08789808f, -0.03956783f, -0.09167765f, 0.04352834f, -0.02455042f, 
    0.02752096f, -0.09175957f, 0.00545065f, 0.00778661f, 0.03027907f, -0.03916391f, -0.09053389f, -0.04670720f, 
    0.25891533f, 0.15893042f, -0.02515539f, -0.20362431f, -0.00075669f, 0.06847965f, 0.06809189f, 0.04584648f, 
    -0.03700696f, -0.12182944f, -0.05819454f, -0.16324306f, 0.09384105f, -0.04822051f, 0.07035695f, 0.03343716f, 
    0.08806863f, 0.10227534f, 0.02811109f, 0.05785782f, -0.07390603f, 0.06340349f, 0.08920731f, -0.29279950f, 
    0.00626615f, 0.06551792f, 0.13304494f, -0.01604117f, 0.11529408f, -0.21432202f, -0.01752198f, -0.05831263f, 
    -0.07088458f, 0.09479027f, -0.14966413f, -0.11084091f, 0.12799498f, 0.10245530f, -0.11997298f, -0.05433927f, 
    0.09736265f, -0.05549208f, -0.16170834f, -0.11176891f, -0.02641049f, -0.03497616f, -0.17222451f, 0.01290674f, 
    0.12895085f, 0.13963033f, 0.03468972f, 0.05757312f, -0.01728396f, -0.07578439f, 0.12915324f, -0.00526604f, 
    -0.37867275f, -0.08511617f, -0.03808511f, 0.21828248f, -0.00580737f, 0.14096956f, 0.06463949f, 0.01189319f, 
    0.10251718f, 0.00289193f, 0.07348535f, -0.12295600f, -0.14438154f, -0.13951927f, -0.02059274f, 0.18437301f, 
    0.01770825f, 0.02692043f, -0.04808339f, -0.00160081f, -0.02593876f, -0.03615721f, 0.18625784f, 0.12586428f, 
    -0.05613232f, -0.08651002f, 0.05169066f, -0.04169625f, -0.06294802f, 0.04952012f, -0.04469958f, 0.06836594f, 
    -0.11441056f, -0.04584180f, 0.11399203f, 0.20227766f, -0.11316897f, -0.12825993f, 0.02544793f, 0.09909481f, 
    0.06791288f, -0.19055285f, -0.04324761f, 0.06979969f, 0.08836271f, -0.02109650f, 0.02730382f, 0.04772851f, 
    -0.16322303f, -0.12971516f, 0.00834135f, -0.05227452f, -0.01776090f, -0.07058495f, -0.01868225f, -0.00620005f, 
    0.26240176f, 0.00793864f, 0.11622338f, 0.01354096f, -0.03747650f, -0.13308673f, 0.05228093f, -0.04118320f, 
    0.08084164f, -0.04238707f, -0.10209457f, 0.00537970f, 0.03948561f, 0.01356008f, -0.14260806f, 0.00074714f, 
    -0.00362081f, -0.09847521f, 0.00773740f, -0.05917324f, -0.05831546f, 0.03664886f, -0.05193800f, 0.07700443f, 
    0.04748819f, -0.02117823f, -0.13746583f, -0.18563654f, -0.00985524f, -0.09682996f, 0.07125450f, 0.23619942f, 
    0.01486649f, 0.01647668f, 0.06620097f, 0.00047688f, 0.00386348f, -0.07509357f, -0.01612053f, 0.02200614f, 
    0.11899858f, -0.03568771f, -0.14693348f, -0.10500496f, 0.00798850f, -0.07383367f, -0.03036049f, 0.10241396f, 
    -0.00778798f, -0.02383606f, -0.02364499f, 0.00104044f, 0.27061769f, 0.09869029f, 0.12718448f, -0.14516144f, 
    -0.00228203f, -0.08162235f, -0.14317806f, -0.07955464f, -0.11562962f, -0.04346618f, -0.02097158f, -0.16492231f, 
    -0.23692679f, 0.35131651f, 0.19868211f, -0.33447620f, 0.05512790f, -0.02047804f, -0.06259754f, -0.03979505f, 
    -0.05431639f, -0.16561204f, -0.08553093f, -0.11286769f, 0.04697357f, -0.01967717f, 0.10312065f, -0.05828951f, 
    -0.04966819f, 0.13891634f, 0.02314569f, 0.06405485f, -0.16282770f, 0.06327458f, 0.12878816f, 0.01011344f, 
    -0.01624771f, -0.04377896f, -0.25786108f, -0.05736890f, -0.00544974f, 0.01086970f, -0.01320608f, -0.08547346f, 
    0.03529839f, -0.09961594f, 0.05350039f, -0.09181271f, 0.05712179f, 0.02130462f, 0.19026496f, 0.22484824f, 
    0.00518030f, -0.06134854f, -0.01535409f, 0.06291001f, -0.00796986f, 0.01066340f, -0.03208188f, -0.07134639f, 
    -0.10760625f, 0.05577359f, -0.06428213f, -0.03739179f, 0.08463880f, -0.17250365f, 0.00704009f, -0.00430853f, 
    0.07350678f, 0.16197233f, 0.02155552f, -0.02599674f, 0.08581999f, 0.13253103f, 0.03453990f, 0.00663441f, 
    -0.20313455f, -0.06176145f, 0.04933564f, -0.00328772f, -0.15487067f, -0.21428908f, 0.08390372f, 0.18474141f, 
    -0.18987837f, 0.27455640f, -0.09163014f, -0.01851656f, 0.09051910f, 0.05388980f, 0.01733600f, -0.15540077f, 
    -0.06195371f, 0.00212810f, -0.06733486f, -0.00040289f, -0.65997332f, 0.02718913f, -0.02891185f, -0.10977717f, 
    0.10415375f, -0.01062238f, -0.05082234f, -0.08642266f, -0.02916933f, -0.08867182f, 0.18185647f, -0.09664086f, 
    -0.01421992f, 0.09247950f, 0.09575221f, -0.12414593f, -0.05333535f, 0.01251660f, -0.00902099f, -0.02193964f, 
    0.04293519f, -0.06811229f, 0.12831552f, 0.09631590f, -0.00015033f, 0.20138614f, 0.05066084f, -0.18189009f, 
    0.10705515f, -0.08655117f, -0.10182246f, 0.09829707f, 0.04507012f, 0.14161727f, -0.05904431f, -0.09201024f, 
    -0.16815951f, 0.05622413f, 0.14235473f, -0.30175817f, -0.05994190f, 0.08262663f, -0.19504909f, 0.03583077f, 
    -0.08217508f, 0.23191904f, 0.05283175f, -0.04175430f, -0.00789773f, 0.09468067f, 0.06166026f, -0.18254031f, 
    -0.01688056f, 0.12776832f, 0.08722223f, -0.24706344f, -0.20970105f, -0.05895513f, -0.07631502f, 0.03693453f, 
    -0.01346707f, 0.09405538f, 0.02907460f, 0.27622619f, -0.11926208f, -0.09791335f, -0.12355654f, 0.14431474f, 
    0.04119048f, -0.10702217f, -0.04224768f, -0.01455235f, -0.27430603f, 0.12251963f, -0.15696006f, -0.15813701f, 
    0.05760043f, 0.00880907f, 0.10226491f, 0.13005008f, -0.02708916f, -0.09938470f, -0.00071975f, -0.07942288f, 
    0.04194386f, 0.05508619f, -0.03122371f, 0.06984339f, 0.11506826f, -0.03885004f, -0.01536034f, -0.03456210f, 
    -0.07116620f, 0.19863288f, -0.01587319f, -0.16236293f, -0.03094617f, -0.06220206f, 0.04771679f, -0.04727453f, 
    0.10033147f, -0.10190912f, 0.02794837f, 0.04795146f, 0.09565890f, 0.11037425f, -0.10185234f, 0.16409232f, 
    -0.26155624f, -0.22042248f, -0.22072481f, 0.13524787f, 0.17608742f, -0.00524657f, 0.06287583f, 0.00381799f, 
    0.04048851f, 0.12202571f, 0.12983476f, -0.07133488f, 0.07458038f, -0.01269328f, 0.01883109f, -0.33724147f, 
    -0.05738008f, -0.04936916f, 0.07533915f, -0.02700381f, -0.12778403f, 0.08949248f, 0.22655532f, 0.17048605f, 
    -0.17411411f, 0.08884172f, 0.02010685f, -0.04594601f, -0.03318692f, -0.06678853f, -0.02636227f, 0.02778006f, 
    0.01267643f, 0.02943116f, 0.13230735f, 0.11387954f, -0.34181160f, -0.23902294f, -0.01446349f, -0.13305987f, 
    -0.11711854f, 0.07647131f, 0.03113254f, 0.13984475f, -0.07524021f, 0.08642495f, -0.02910033f, 0.01331410f, 
    0.15701224f, -0.22249378f, -0.04897718f, 0.11193288f, -0.04978219f, 0.04299176f, -0.00038101f, 0.12245893f, 
    0.10401850f, -0.13320760f, -0.07806640f, -0.03156539f, 0.23620781f, -0.20026970f, 0.05447533f, -0.00662889f, 
    -0.05797099f, -0.09403738f, 0.00977850f, 0.02864800f, 0.10278773f, 0.03369380f, -0.07299277f, -0.06731970f, 
    0.13703087f, -0.36790252f, -0.12488645f, -0.06172074f, -0.04431905f, 0.00187345f, -0.00285833f, -0.12733434f, 
    -0.06026085f, -0.03202810f, 0.11898335f, -0.01494560f, -0.12194367f, -0.15407896f, -0.04491842f, -0.24837548f, 
    0.03119387f, -0.01032557f, -0.01611291f, 0.16643789f, 0.10475158f, 0.05260253f, -0.03077240f, -0.10865728f, 
    0.19037743f, 0.14954564f, -0.18166457f, 0.23392348f, -0.10211949f, 0.04667801f, -0.14620480f, 0.11892938f, 
    -0.02683035f, 0.04176255f, 0.06013418f, -0.13899447f, -0.32251588f, 0.19246651f, 0.08051971f, 0.18961897f, 
    -0.03152532f, -0.06022260f, 0.00090866f, 0.00612686f, -0.02907045f, 0.06835779f, 0.03676052f, -0.02355694f, 
    -0.06269707f, -0.03669138f, 0.00966454f, 0.10140551f, 0.03428632f, -0.03758439f, -0.02405367f, 0.09696243f, 
    -0.17716397f, 0.05899783f, 0.02007093f, 0.02390269f, -0.38387007f, 0.04051900f, -0.03939180f, 0.33692408f, 
    0.01770793f, 0.09442640f, -0.01083289f, 0.07697991f, -0.01542135f, -0.05054997f, 0.00188562f, -0.11194348f, 
    -0.01664345f, -0.07274906f, 0.13566738f, -0.12360422f, -0.02475488f, 0.09859294f, 0.06281556f, -0.09160364f, 
    0.01282035f, 0.06807276f, -0.02500589f, -0.12411937f, 0.17702724f, -0.34447208f, -0.19478768f, 0.12210206f, 
    -0.11167877f, 0.01269169f, -0.07046722f, 0.06813192f, 0.09713394f, 0.01724117f, -0.00902067f, 0.06784926f, 
    0.00230803f, 0.25250259f, -0.02078838f, -0.14431758f, 0.12828593f, 0.07745373f, 0.03000713f, 0.05388914f, 
    -0.01173951f, 0.06487572f, -0.06995160f, -0.03487742f, -0.31232613f, 0.08354475f, -0.04004742f, 0.32355061f, 
    -0.02284198f, -0.03476894f, -0.03709700f, 0.03983603f, 0.03177651f, -0.03204513f, -0.08284853f, -0.18882494f, 
    -0.14407565f, 0.09444264f, 0.02794178f, 0.03812502f, 0.09171673f, 0.04781915f, 0.13381417f, -0.01223811f, 
    -0.08818031f, -0.08000301f, 0.10517103f, 0.12842584f, -0.01802164f, 0.12713200f, 0.03599193f, -0.29296842f, 
    -0.15170187f, 0.06222280f, -0.02138229f, 0.05127313f, -0.02621885f, -0.06376117f, 0.09671241f, -0.25974017f, 
    -0.30969766f, -0.06641515f, 0.11445671f, -0.06044579f, -0.08607820f, -0.04647033f, -0.02248295f, -0.04494790f, 
    -0.08089297f, 0.00599165f, 0.17161375f, 0.10132467f, 0.14760044f, 0.27961746f, -0.00877111f, -0.35215166f, 
    -0.02000923f, 0.03261827f, 0.04422348f, -0.00108010f, -0.11447521f, -0.08704723f, 0.10840776f, 0.02526304f, 
    0.17982934f, -0.01900800f, -0.07444306f, 0.19450501f, -0.00065145f, 0.03932829f, -0.11039799f, 0.05035336f, 
    -0.04164808f, 0.09469069f, 0.02209778f, 0.18198989f, -0.18834436f, -0.02046641f, -0.11987215f, 0.05197621f, 
    0.11519188f, -0.01035645f, -0.05794916f, -0.21652457f, -0.07504320f, -0.13258298f, 0.08819651f, -0.05871826f, 
    -0.16557105f, 0.04735033f, -0.24586876f, -0.00798357f, -0.10936541f, -0.03009605f, 0.05393812f, -0.03808292f, 
    0.04130663f, -0.01419325f, -0.03127326f, 0.08375728f, -0.23345621f, -0.14933772f, -0.13203578f, -0.05479846f, 
    -0.01520484f, 0.06922160f, 0.02620548f, 0.01170770f, -0.14092582f, 0.13752252f, -0.03353417f, 0.10640938f, 
    0.16774838f, -0.05351417f, 0.08201449f, -0.26274472f, 0.01346932f, 0.10119945f, 0.03045755f, 0.05921710f, 
    -0.06826889f, -0.00969121f, 0.06815971f, -0.07126958f, 0.00667767f, -0.06891946f, -0.13924730f, -0.11546317f, 
    -0.00229149f, 0.11789805f, -0.05559441f, 0.07614423f, -0.01290461f, -0.14270826f, -0.01241067f, 0.00240779f, 
    0.14773045f, -0.25288022f, 0.00958364f, 0.03896533f, -0.02902623f, 0.00591081f, -0.02157504f, 0.05340229f, 
    -0.00932788f, -0.02603441f, 0.04772666f, -0.13261220f, -0.25881347f, 0.04468728f, 0.27998063f, 0.21303135f, 
    0.13122138f, 0.08763154f, 0.12732589f, 0.13304736f, 0.03897596f, 0.01583319f, 0.06962192f, 0.14872511f, 
    0.10286005f, -0.46876580f, -0.05371174f, -0.23269084f, -0.07018347f, -0.00478121f, 0.02983042f, 0.13836783f, 
    0.01935168f, 0.09687140f, 0.08825196f, 0.17307921f, 0.24977790f, -0.16170487f, -0.00448149f, -0.00860542f, 
    0.03184450f, 0.00306835f, -0.01910619f, 0.00596735f, -0.09714006f, 0.16652708f, 0.03813988f, 0.05385724f, 
    0.10951503f, -0.07914535f, -0.07476161f, -0.09288814f, 0.03477966f, 0.01322001f, -0.02833124f, -0.03513058f, 
    0.04554614f, -0.03248888f, 0.02718063f, -0.03725130f, 0.01794494f, 0.12984432f, 0.13156533f, 0.09173515f, 
    -0.03072384f, -0.17372984f, 0.04003944f, 0.01943830f, 0.07373419f, 0.01573689f, -0.15981124f, -0.15570830f, 
    -0.09100383f, -0.15929511f, -0.18300636f, 0.31729573f, 0.07293073f, 0.07236334f, -0.00827496f, -0.04882927f, 
    0.07721478f, 0.05346425f, -0.12927179f, 0.03573088f, -0.15840808f, -0.02945910f, -0.22380207f, -0.12932892f, 
    -0.20083185f, -0.14686397f, -0.04478787f, -0.09141223f, -0.06479221f, -0.03853852f, -0.02585064f, -0.06755948f, 
    0.14557530f, -0.02298757f, 0.01360146f, 0.05179441f, -0.03368540f, 0.10101134f, -0.02319841f, 0.00742438f, 
    -0.04534000f, 0.12292606f, -0.01434980f, -0.17662889f, -0.11011367f, -0.01009371f, 0.19484653f, -0.04494553f, 
    -0.12690587f, -0.08919117f, 0.07828099f, -0.03455604f, -0.08436523f, 0.04970909f, 0.02880986f, 0.02981899f, 
    -0.08006099f, -0.22243367f, 0.07212033f, 0.01646014f, -0.03826801f, 0.06164718f, 0.09462638f, 0.04573672f, 
    -0.06166519f, 0.12448033f, -0.01494273f, 0.10372979f, -0.03413782f, 0.07753584f, -0.15777636f, 0.00913187f, 
    -0.14970614f, 0.06314074f, -0.11961561f, -0.09148916f, -0.00165098f, 0.10038620f, 0.08889136f, 0.08650067f, 
    0.19007820f, 0.07353026f, -0.14409758f, -0.30580887f, -0.11958092f, 0.04925535f, -0.10991348f, -0.11922149f, 
    -0.13912861f, 0.09621205f, 0.06268008f, 0.03206815f, -0.04459465f, 0.11324463f, -0.09381605f, -0.07457962f, 
    0.03272101f, 0.05109373f, 0.10249712f, 0.03375093f, 0.05898973f, 0.03775531f, -0.01154208f, -0.15217622f, 
    0.21330383f, 0.12360658f, -0.02460553f, 0.01369946f, -0.10393094f, -0.00585561f, 0.07703153f, 0.03938304f, 
    0.06714339f, -0.07657158f, -0.05492523f, -0.10365701f, -0.06428248f, 0.04014609f, -0.20708646f, -0.17116326f, 
    -0.12091666f, 0.04027230f, -0.02032134f, 0.01318629f, -0.05740036f, 0.04456990f, -0.10445508f, -0.04082897f, 
    0.07600914f, -0.15128177f, -0.08001377f, 0.26829764f, -0.09898194f, -0.08233044f, 0.03759198f, -0.05801008f, 
    -0.22550026f, -0.02862733f, -0.17968774f, 0.00871264f, 0.11819533f, 0.15300083f, 0.06194629f, -0.05164197f, 
    -0.08246821f, 0.08347077f, 0.01102077f, 0.07766008f, -0.00074030f, -0.09179517f, 0.11581302f, 0.02668246f, 
    -0.11741295f, 0.18385114f, 0.06977804f, -0.07924093f, 0.00466824f, -0.07306910f, -0.12352049f, 0.00286912f, 
    -0.07500788f, 0.00014517f, 0.06615450f, 0.19992585f, -0.04667322f, -0.03365611f, -0.18292966f, -0.00489710f, 
    0.00530033f, -0.05220614f, -0.14172105f, -0.09899385f, -0.03269499f, -0.03036810f, 0.10162728f, 0.00661996f, 
    -0.22949412f, 0.14913781f, -0.06400703f, 0.25318855f, 0.09318949f, 0.05557494f, -0.15996276f, -0.01299242f, 
    0.05489818f, -0.02955296f, -0.03694844f, -0.04264054f, -0.20080130f, 0.10916512f, 0.00248145f, 0.11719863f, 
    -0.11005898f, -0.02290113f, 0.06344387f, 0.01105906f, 0.05600691f, -0.02216162f, -0.01924393f, 0.18559726f, 
    0.46227205f, -0.44817463f, 0.17246225f, -0.20541090f, -0.02119431f, 0.01356509f, 0.03075049f, 0.07416475f, 
    0.04540625f, 0.03837537f, 0.01861498f, 0.12975550f, -0.00898290f, 0.08832596f, 0.08504476f, -0.10569467f, 
    0.01872451f, -0.10054893f, -0.06150968f, 0.02427532f, -0.00678996f, 0.07352832f, -0.08447076f, 0.00748364f, 
    0.23509476f, -0.10044036f, -0.04104360f, -0.05254783f, -0.09698687f, 0.02726771f, 0.01889985f, -0.09781527f, 
    -0.01044051f, 0.07055447f, -0.02720547f, 0.17215645f, -0.05483052f, -0.09015370f, -0.23786804f, 0.12294164f, 
    0.05259032f, 0.00841379f, -0.03646147f, 0.02257968f, -0.00750347f, -0.08210178f, 0.04931621f, 0.03962580f, 
    -0.02829110f, -0.07048329f, 0.09369034f, -0.02115896f, 0.08222129f, 0.07017511f, -0.10429262f, 0.12531655f, 
    0.01292649f, -0.20538458f, -0.04317198f, -0.09719009f, 0.12059963f, 0.08135039f, 0.01669075f, -0.05738096f, 
    0.13635749f, 0.07556292f, -0.02242267f, 0.01120020f, 0.01083631f, 0.02445086f, -0.01486570f, -0.07861066f, 
    0.16926320f, -0.37080762f, -0.06416970f, 0.06190044f, -0.03141457f, 0.06237074f, -0.06109947f, 0.04209686f, 
    0.01105065f, 0.04051955f, 0.06471939f, 0.08385661f, 0.12658601f, 0.08409943f, 0.12382945f, 0.01112444f, 
    -0.08133153f, 0.05480487f, -0.00532408f, -0.07295787f, 0.00918901f, -0.00322427f, 0.07279719f, 0.02124379f, 
    -0.04263903f, 0.15597881f, 0.10325196f, -0.18513341f, 0.01417979f, 0.04434310f, 0.04900865f, -0.09626716f, 
    -0.04098836f, 0.00516739f, -0.00147779f, -0.12256687f, 0.23957630f, -0.16865373f, 0.22244948f, -0.02408903f, 
    0.00121731f, 0.05269695f, 0.05496349f, -0.03358173f, 0.11828380f, 0.01640734f, 0.04413117f, 0.03924518f, 
    0.07115609f, -0.16882306f, -0.03065877f, -0.07623860f, -0.05482594f, -0.00483468f, 0.03453869f, 0.00759315f, 
    0.07510069f, -0.14379479f, -0.08277547f, -0.07912596f, -0.13567628f, 0.14239444f, 0.20285325f, 0.06634677f, 
    -0.02307569f, 0.08571248f, -0.01154150f, 0.03578952f, 0.19712846f, 0.12348601f, 0.10044996f, -0.01840643f, 
    -0.08361507f, 0.06132737f, 0.05815694f, -0.27689195f, 0.04459919f, -0.10528284f, 0.11468728f, -0.04484303f, 
    -0.15080509f, 0.12578343f, 0.05176616f, 0.04606524f, 0.01839233f, -0.10247375f, 0.06255741f, -0.12647709f, 
    -0.05631299f, 0.02204693f, 0.10280878f, -0.04636063f, 0.10789128f, 0.08782967f, 0.00086835f, 0.01088213f, 
    -0.16730818f, -0.05169588f, 0.00301971f, -0.07558675f, 0.02300756f, 0.06006331f, -0.00022131f, 0.09183145f, 
    -0.08044273f, -0.11530174f, 0.04523522f, -0.00515230f, -0.15817468f, 0.03737907f, 0.03586357f, 0.06358044f, 
    -0.08460309f, 0.03264526f, 0.04991078f, -0.10823513f, -0.01401414f, -0.08730228f, 0.09117763f, -0.03298744f, 
    0.07068244f, -0.07993353f, -0.10316640f, -0.10350480f, -0.08522864f, -0.03297814f, -0.02248504f, -0.17195392f, 
    -0.02023830f, -0.07988218f, -0.02685715f, -0.00469979f, -0.05670420f, 0.22454259f, 0.02713938f, -0.11167409f, 
    -0.04611843f, 0.04690232f, -0.11395202f, 0.07854728f, -0.01236714f, -0.17809360f, -0.00466932f, -0.22005308f, 
    0.16572638f, -0.06055752f, 0.13823101f, 0.25863439f, -0.09247888f, -0.07329669f, -0.00178541f, 0.01677889f, 
    -0.03022168f, 0.01783150f, 0.09101326f, 0.00729092f, -0.11506891f, 0.07178453f, 0.05264117f, 0.06063648f, 
    0.08456177f, 0.03161779f, 0.07138030f, -0.12145131f, -0.06753411f, -0.01619304f, 0.00214767f, -0.06815726f, 
    0.11078933f, -0.20638743f, 0.03425020f, -0.03933561f, -0.01111542f, -0.02973439f, -0.00670658f, -0.04335726f, 
    0.02226526f, -0.00109897f, -0.10189279f, -0.01365374f, 0.18300408f, -0.18031679f, 0.08706978f, 0.16679217f, 
    0.15497632f, -0.05514494f, 0.03079259f, -0.02322350f, 0.00226548f, 0.04706660f, -0.07169735f, -0.11017448f, 
    0.22184898f, -0.08604518f, 0.15716583f, 0.07096463f, 0.06450972f, 0.06994875f, -0.00313352f, -0.01388718f, 
    -0.02975695f, -0.05270060f, -0.01121014f, -0.08771066f, -0.30783769f, 0.32495302f, 0.10817687f, -0.02475700f, 
    -0.07058860f, -0.06724879f, 0.02850859f, -0.03497333f, -0.01047627f, 0.05781947f, 0.02865183f, 0.01462888f, 
    -0.13161920f, 0.05942317f, 0.02208067f, -0.04192669f, -0.03394426f, -0.05699030f, -0.01702355f, -0.06020395f, 
    -0.07892633f, 0.04429685f, 0.02226247f, 0.07916382f, -0.19147798f, -0.07163765f, -0.15293002f, -0.18969421f, 
    0.09650824f, -0.08461533f, 0.06083339f, -0.01658446f, 0.00493634f, -0.06344516f, -0.00733951f, 0.00530952f, 
    -0.03648394f, -0.10114858f, -0.01853176f, -0.05307692f, -0.09502136f, -0.02604738f, 0.00472899f, -0.02497720f, 
    -0.06556004f, 0.01714201f, -0.00938264f, -0.09576572f, 0.00464736f, -0.41508201f, -0.05721925f, 0.03533295f, 
    0.01498155f, -0.03888308f, 0.06237594f, 0.01497876f, 0.00168008f, -0.07371684f, -0.06222049f, -0.08399693f, 
    -0.08400696f, 0.05424497f, -0.04289162f, -0.13252433f, 0.05369809f, -0.01919590f, 0.04386025f, -0.09138086f, 
    -0.02337681f, -0.01499208f, -0.04280907f, -0.11339512f, -0.11659928f, 0.11540939f, 0.04727186f, -0.09376734f, 
    0.02589315f, 0.02337490f, 0.08629002f, -0.08331072f, -0.03907472f, -0.03079400f, 0.02743689f, 0.03823472f, 
    -0.18881258f, -0.12477974f, -0.12315684f, -0.03251654f, 0.03582394f, -0.06252974f, -0.03669534f, -0.03579219f, 
    -0.11063248f, 0.05093708f, 0.01897833f, -0.05933810f, -0.10809190f, -0.10746193f, -0.24246477f, -0.02656418f, 
    0.06511961f, -0.07803224f, -0.03826694f, -0.05542666f, -0.02515640f, -0.03844031f, -0.01554248f, 0.00541870f, 
    0.02659437f, 0.19496845f, 0.02662724f, -0.14831527f, -0.08627301f, -0.00184493f, 0.05696318f, -0.03699168f, 
    -0.03792830f, -0.03650112f, -0.01008825f, -0.13454700f, -0.07561136f, 0.11823969f, -0.07283093f, -0.12567104f, 
    -0.06320246f, 0.06113613f, 0.01958585f, -0.03205397f, -0.07121541f, -0.00653709f, -0.04915281f, -0.02078932f, 
    0.02206634f, 0.07324554f, 0.05912098f, -0.02852016f, -0.00479284f, -0.01771795f, -0.00709419f, -0.05847037f, 
    -0.04055474f, -0.01216443f, -0.00128046f, -0.00913526f, -0.52348626f, -0.16251661f, -0.13358308f, -0.18424182f, 
    -0.01307286f, 0.01777800f, -0.02694317f, -0.07716106f, -0.05933999f, -0.01532838f, 0.03148528f, 0.02903277f, 
    -0.06194517f, 0.07757291f, -0.03889869f, 0.22918643f, -0.01779684f, -0.08360383f, -0.03143387f, 0.03836701f, 
    -0.05196791f, 0.03200346f, -0.02650678f, 0.02575238f, 0.08149530f, 0.18801300f, 0.01848395f, 0.09798566f, 
    -0.02112649f, 0.07535528f, -0.00375702f, -0.00595047f, -0.01187479f, -0.02939861f, -0.00914143f, -0.08431470f, 
    0.11585811f, 0.14227691f, 0.01845360f, 0.17882472f, 0.04580567f, 0.03673562f, 0.10236344f, 0.08045442f, 
    -0.01129195f, 0.03283738f, -0.01903496f, -0.02653429f, -0.12254849f, 0.14518437f, 0.05618584f, 0.06908825f, 
    -0.00169447f, -0.01300811f, 0.12796146f, -0.00235551f, 0.07834765f, 0.02568306f, 0.02068618f, -0.00885383f, 
    0.12718976f, -0.07591641f, -0.02783724f, 0.02139050f, -0.09621326f, -0.00464325f, 0.06330346f, -0.05792687f, 
    0.04595509f, 0.02434761f, -0.08664954f, -0.01105642f, 0.09637769f, -0.06303478f, 0.02958553f, 0.16322504f, 
    -0.06400931f, -0.09095964f, -0.06727866f, -0.02831965f, -0.06535795f, -0.08879727f, -0.03237452f, -0.05903473f, 
    -0.13525382f, 0.04552443f, 0.12797759f, -0.08858237f, -0.12580502f, -0.03875071f, -0.05411993f, -0.01659716f, 
    0.00245457f, -0.00750956f, 0.01480380f, -0.05381666f, -0.11550287f, 0.14348504f, -0.05004377f, -0.12842892f, 
    -0.17231882f, 0.04923627f, 0.02984865f, 0.04156881f, 0.06923898f, -0.04435536f, 0.07925621f, -0.07559457f, 
    -0.18343186f, 0.13646145f, 0.16294363f, -0.01881747f, 0.04738680f, 0.06200171f, -0.02137144f, -0.00707708f, 
    -0.01883407f, 0.02003775f, 0.05810014f, 0.01194645f, -0.04972088f, 0.06930378f, 0.11130545f, 0.06981546f, 
    0.14565730f, 0.05067226f, 0.06938072f, -0.06443706f, -0.06981636f, -0.00685918f, 0.10426674f, -0.08426263f, 
    -0.16953604f, -0.07035912f, -0.05226761f, 0.01228614f, -0.06716105f, -0.01985147f, -0.04222666f, -0.08518513f, 
    -0.07925504f, -0.01881933f, -0.06602186f, -0.04418829f, -0.00201540f, -0.03909434f, -0.02747569f, -0.17496447f, 
    0.02640371f, 0.00705016f, 0.02125771f, 0.00033206f, 0.00626174f, -0.09895066f, -0.07847941f, -0.03948514f, 
    -0.06349761f, 0.18465911f, -0.13264723f, 0.08119486f, -0.00232327f, -0.05894973f, -0.03911952f, 0.01254257f, 
    0.01352234f, 0.04320310f, 0.00335167f, -0.00631199f, 0.12606888f, 0.22185858f, 0.01316971f, 0.23632286f, 
    0.10296471f, 0.06453800f, 0.00251719f, 0.02847385f, -0.00508011f, -0.01127062f, 0.02659454f, -0.08184920f, 
    0.23814206f, -0.41340932f, 0.10156034f, -0.03943724f, -0.05016319f, 0.07440520f, -0.09555826f, 0.00432356f, 
    -0.09157072f, 0.03724729f, -0.04590973f, 0.02073037f, -0.14504077f, 0.01988925f, -0.02430522f, -0.16585173f, 
    0.05721017f, 0.03054396f, -0.03431600f, -0.06824531f, -0.07320739f, -0.03795148f, 0.00401101f, -0.03478488f, 
    0.10634553f, 0.05516962f, 0.12343877f, 0.09538039f, 0.01593629f, 0.04910814f, 0.02397665f, 0.07183935f, 
    0.01427466f, 0.07184581f, -0.02226849f, 0.05102915f, 0.00759092f, 0.09417515f, 0.04476345f, 0.15857127f, 
    0.07284287f, 0.10804066f, -0.00857555f, -0.03562034f, -0.04371021f, 0.00827052f, 0.00156505f, -0.03272292f, 
    0.06509745f, 0.13839208f, 0.09559610f, 0.21043362f, 0.10681182f, 0.08241159f, 0.07642533f, 0.00825993f, 
    -0.11713660f, 0.03125471f, 0.00220278f, -0.06726055f, 0.13549598f, -0.06946842f, 0.07790961f, 0.18677001f, 
    0.11661541f, -0.03166228f, -0.00808578f, -0.05282268f, -0.02118155f, 0.00568988f, -0.00868930f, -0.05357196f, 
    0.01419318f, -0.20900689f, 0.03466992f, 0.02567736f, -0.05391352f, -0.01244097f, -0.04027682f, 0.03216717f, 
    -0.05587960f, -0.03904409f, -0.06229047f, -0.06875440f, 0.00524363f, 0.10175586f, 0.09228720f, 0.15611380f, 
    0.04303346f, -0.06328102f, -0.02642554f, 0.02518591f, -0.05826902f, -0.03988678f, -0.05871747f, -0.09218910f, 
    0.02076484f, 0.10111130f, -0.09064771f, 0.06438230f, 0.05562484f, -0.08771805f, -0.04357672f, 0.02522011f, 
    0.01291659f, -0.03940750f, -0.03945097f, -0.11063975f, -0.05765709f, 0.04725762f, 0.01030455f, 0.01356010f, 
    -0.09780341f, 0.03517325f, -0.04791373f, 0.00104537f, 0.02556122f, 0.03463911f, -0.06996534f, -0.11018318f, 
    -0.20405589f, 0.04741070f, -0.09323422f, -0.16186835f, 0.03962264f, -0.10188860f, -0.02136721f, -0.08790967f, 
    -0.02201811f, -0.06401449f, -0.10595302f, 0.03415559f, 0.14876045f, 0.12202821f, -0.04611634f, 0.17158806f, 
    0.01961479f, -0.01293120f, -0.15022588f, -0.01384314f, -0.08643057f, -0.03756938f, -0.03362944f, -0.01467354f, 
    -0.16049790f, 0.04915103f, -0.07394301f, -0.24735142f, -0.01116682f, -0.06307025f, -0.02937602f, -0.09217373f, 
    0.00112576f, -0.02261872f, 0.04373086f, -0.03278188f, 0.01450347f, 0.08654742f, -0.06205203f, -0.10831953f, 
    -0.03745806f, 0.00757864f, -0.03506787f, -0.06351741f, -0.02099877f, -0.02033413f, -0.03510111f, -0.05914494f, 
    0.33800387f, -0.10537994f, 0.01413712f, -0.10918619f, -0.07481918f, -0.00379846f, -0.01344978f, -0.10200256f, 
    -0.04342524f, -0.02336052f, -0.13244963f, -0.07220874f, -0.03870817f, -0.01591481f, -0.12552215f, -0.17753541f, 
    0.03771182f, -0.05182540f, -0.02610541f, -0.00142160f, 0.06345657f, -0.04922244f, -0.03271057f, -0.01417821f, 
    -0.05082776f, 0.17892423f, 0.12667149f, 0.10171551f, 0.12194518f, -0.00140818f, 0.13284092f, 0.00238708f, 
    0.02024669f, -0.01692755f, 0.01110832f, -0.04380949f, -0.05911991f, 0.13185191f, -0.13303602f, 0.14867118f, 
    -0.03233183f, -0.01024369f, -0.07578264f, -0.07868271f, -0.01109803f, -0.01351725f, 0.06641029f, -0.00959906f, 
    0.12341160f, 0.00924778f, -0.15912193f, 0.19347966f, 0.02033865f, -0.02076431f, 0.02723100f, 0.03903798f, 
    -0.01645205f, -0.00127375f, 0.07076820f, -0.06411521f, 0.04674019f, -0.01776309f, -0.18419805f, -0.05825978f, 
    -0.01181275f, -0.09708173f, -0.03641284f, -0.04603477f, -0.05757554f, 0.02000934f, 0.09752644f, -0.05123734f, 
    -0.24098137f, 0.13681549f, 0.06365641f, -0.10555919f, 0.04594459f, 0.00502727f, 0.01402562f, -0.05974366f, 
    -0.01290606f, 0.02103310f, 0.08581200f, 0.04703970f, 0.03621100f, 0.12395268f, 0.08603524f, -0.01937377f, 
    0.09170990f, 0.02344433f, 0.04805867f, 0.06630321f, -0.03979225f, 0.03204384f, -0.07387888f, -0.09895763f, 
    -0.14329810f, 0.18080904f, -0.01520595f, -0.18667749f, -0.02575348f, -0.03284628f, -0.02125902f, -0.05017101f, 
    -0.11337936f, -0.03529171f, -0.00450484f, -0.01260346f, 0.15385556f, -0.15282761f, -0.04002848f, -0.08919565f, 
    0.00452598f, -0.02850578f, -0.03225554f, -0.12255833f, -0.00635905f, -0.03460965f, 0.08109916f, -0.11632647f, 
    -0.15043826f, 0.00836781f, 0.09097757f, -0.21754806f, 0.02595586f, -0.03201564f, 0.08940802f, -0.04257428f, 
    -0.00078099f, 0.04120972f, -0.03757058f, -0.08952816f, -0.14084743f, 0.14444920f, -0.05641928f, -0.19354731f, 
    -0.11636393f, -0.00224071f, -0.05668185f, 0.06457857f, -0.06214698f, 0.01004744f, -0.02978707f, -0.12881429f, 
    -0.09764862f, -0.21007025f, -0.03212237f, -0.03990100f, 0.08799183f, -0.01881758f, -0.02814660f, -0.11080125f, 
    -0.03427203f, -0.11121535f, -0.03235474f, -0.05870572f, 0.28259173f, -0.04683872f, 0.18750118f, 0.02311514f, 
    0.03940280f, 0.04112124f, 0.05286689f, -0.06169349f, -0.05171901f, 0.08967359f, -0.02363429f, -0.09031966f, 
    0.09555506f, 0.11276206f, 0.10392988f, -0.00515133f, -0.01444808f, 0.06868478f, 0.07939557f, -0.03236086f, 
    -0.07044242f, -0.00576035f, -0.01390986f, -0.10182451f, 0.14889468f, -0.06209480f, 0.05814791f, -0.02506682f, 
    0.02759749f, -0.00956893f, -0.00311182f, -0.08122589f, -0.05377743f, -0.00167224f, -0.03309310f, -0.04031159f, 
    0.09808050f, 0.14672993f, 0.14731716f, 0.16992481f, 0.12808765f, 0.06503344f, 0.01582362f, -0.06432986f, 
    -0.05108242f, -0.00957018f, -0.04981149f, -0.03432637f, -0.13012247f, 0.04612139f, 0.11018171f, -0.02330043f, 
    -0.04211687f, -0.05957162f, 0.02355013f, 0.01638699f, 0.04742229f, 0.00106752f, 0.00183669f, -0.03463430f, 
    -0.04290599f, 0.13650954f, -0.13945076f, 0.15984417f, 0.05657893f, 0.01144805f, -0.00072280f, -0.14691131f, 
    -0.00641057f, 0.03702094f, -0.15649813f, -0.04414619f, -0.15591724f, -0.03685318f, 0.23328292f, 0.02129310f, 
    -0.00840378f, -0.04295614f, -0.01389521f, -0.14840114f, -0.07052915f, 0.00764480f, 0.13097003f, -0.06767814f, 
    0.18173070f, -0.06853823f, -0.02887683f, 0.00468243f, 0.03598835f, 0.02784858f, -0.06023702f, 0.00063898f, 
    0.01890237f, 0.04416232f, 0.09938141f, 0.07134984f, 0.18610083f, -0.04251532f, 0.17736250f, -0.17416707f, 
    0.04391933f, -0.03474479f, -0.07239697f, 0.02194663f, -0.08649503f, -0.06858005f, 0.02042226f, 0.03642984f, 
    -0.02304275f, -0.07489223f, -0.08024424f, -0.05996120f, -0.05524100f, -0.02794991f, 0.02050864f, -0.04426610f, 
    0.04446758f, 0.05623623f, -0.11827632f, 0.07663291f, 0.15151067f, -0.02970001f, 0.12214141f, 0.21579288f, 
    -0.00598062f, 0.00372835f, -0.03836843f, -0.11396659f, 0.10834287f, -0.06208292f, 0.09333565f, 0.11655675f, 
    -0.00004247f, 0.19095382f, -0.11124776f, 0.00932286f, -0.00933884f, 0.02123424f, -0.07326795f, -0.02934685f, 
    0.09865131f, 0.03563095f, 0.02163675f, 0.01506005f, 0.10126701f, 0.00141296f, -0.09368613f, 0.03307270f, 
    0.02744487f, 0.09089005f, 0.08893446f, 0.05335217f, -0.01687937f, 0.01060747f, 0.03843016f, 0.03097194f, 
    0.04378142f, 0.06338041f, 0.02379674f, -0.02234985f, -0.03154764f, -0.03748157f, -0.02737314f, 0.00647228f, 
    0.08610205f, 0.04087184f, 0.00776669f, -0.04976866f, 0.25257370f, 0.06656882f, -0.21493883f, -0.14237659f, 
    0.06761020f, 0.08098757f, 0.07595710f, -0.00877488f, 0.02300260f, 0.08955003f, -0.09739211f, 0.06041884f, 
    0.17179327f, -0.16484442f, 0.17554031f, 0.06344313f, -0.01749014f, -0.03861373f, 0.00564247f, -0.02762613f, 
    -0.00818936f, -0.09858070f, 0.12483637f, 0.03940080f, 0.06711002f, -0.08176385f, -0.03662263f, 0.07450832f, 
    -0.02694923f, -0.02226892f, -0.09851985f, -0.08771569f, 0.06693783f, -0.02810390f, 0.01147974f, -0.09682751f, 
    -0.03772263f, -0.23618865f, -0.06006962f, 0.05572562f, 0.15175472f, 0.01640042f, 0.00495529f, -0.05030374f, 
    0.03934259f, -0.02345443f, 0.02968746f, 0.01083638f, 0.23021279f, -0.00011941f, -0.34364480f, -0.13523541f, 
    0.08811867f, 0.09522554f, -0.05873233f, -0.02310666f, -0.04336951f, -0.02469070f, -0.00295802f, 0.08465488f, 
    0.09399288f, -0.10155613f, -0.04811295f, -0.00954151f, -0.00965834f, -0.12405520f, -0.05893785f, 0.08739543f, 
    0.10995602f, 0.04980594f, -0.00163646f, -0.12487470f, -0.02471491f, -0.00318352f, 0.11995664f, 0.19720177f, 
    0.06875309f, -0.01032269f, 0.00513706f, 0.00612778f, 0.04907264f, 0.09298269f, 0.11550733f, -0.07791205f, 
    -0.00766916f, -0.00305432f, 0.02924469f, 0.10558639f, -0.04302975f, -0.02851752f, -0.04151984f, 0.07152515f, 
    0.01288406f, -0.03078379f, -0.22346459f, -0.00003903f, -0.14751887f, -0.18441556f, 0.04384679f, 0.22742283f, 
    0.17975572f, -0.00611580f, -0.04925376f, -0.00842123f, 0.09249106f, -0.02083120f, 0.01528453f, 0.03712080f, 
    -0.01059027f, 0.13108034f, -0.21820511f, -0.09379195f, 0.13502708f, -0.16785134f, -0.14712146f, 0.01436946f, 
    0.05779524f, -0.03910510f, 0.00084512f, -0.02068316f, 0.00341692f, 0.08718911f, 0.03383335f, -0.10583153f, 
    -0.00280420f, 0.04935596f, -0.15618697f, 0.03161726f, 0.03936122f, -0.00196094f, 0.03490881f, 0.02768429f, 
    -0.10158941f, 0.11104091f, 0.07326901f, -0.04117269f, -0.17354585f, 0.07805806f, 0.00091896f, -0.10000814f, 
    -0.01533169f, -0.16252324f, 0.01587122f, -0.13835038f, 0.04220909f, 0.09064256f, 0.08704963f, 0.19507298f, 
    0.00103836f, 0.00324612f, -0.01707912f, 0.03742184f, -0.11089460f, -0.00443699f, 0.04202162f, -0.00742510f, 
    -0.02060513f, -0.10659960f, -0.07304877f, 0.09361166f, 0.01817288f, -0.02096292f, 0.00063129f, 0.06589665f, 
    -0.03873166f, 0.04048620f, 0.09439643f, 0.11546287f, 0.08886360f, -0.01595840f, -0.11848758f, -0.18993805f, 
    0.00654782f, 0.00542182f, -0.04979550f, -0.00397293f, 0.06587149f, 0.10724156f, -0.00326615f, 0.03108180f, 
    0.08579165f, -0.11618885f, 0.03540052f, 0.10639706f, -0.00454611f, -0.07202702f, -0.06111654f, 0.09476634f, 
    -0.02582254f, 0.01632171f, -0.14647613f, 0.12079223f, 0.01943510f, -0.00519498f, -0.04660432f, 0.00002722f, 
    0.05861836f, -0.12046642f, -0.06435438f, -0.05411969f, -0.04563006f, 0.03218663f, 0.00275664f, -0.05454635f, 
    -0.10035568f, -0.22995092f, 0.26152611f, 0.04122944f, -0.03990938f, -0.08157616f, -0.08550590f, -0.07003509f, 
    -0.02020453f, -0.09864465f, -0.00753476f, -0.11041581f, -0.16821748f, -0.22554913f, 0.06628164f, -0.11903182f, 
    0.05212694f, -0.07260656f, -0.05068280f, 0.03364610f, 0.11100308f, 0.00365952f, -0.01995835f, -0.01774803f, 
    -0.04733143f, 0.05857178f, -0.20625494f, 0.04512487f, -0.09128557f, -0.01469821f, -0.05017579f, -0.04970653f, 
    -0.00294314f, -0.05616839f, 0.05667158f, 0.02335104f, 0.25060317f, -0.02389234f, -0.07420427f, 0.05941807f, 
    0.10620755f, -0.07487767f, -0.00237750f, -0.05859388f, -0.04367836f, 0.05596280f, 0.06641449f, -0.00858942f, 
    0.08119950f, 0.16469847f, -0.20920232f, -0.06742433f, 0.03057786f, -0.00983159f, -0.13751015f, -0.05313554f, 
    0.01611925f, 0.01815732f, 0.07732630f, 0.08155765f, -0.22372656f, 0.06021611f, 0.07036577f, -0.04643193f, 
    -0.18197627f, 0.08777440f, -0.14072894f, -0.07595161f, -0.00118560f, 0.04409338f, -0.03169817f, 0.06959509f, 
    -0.24985917f, -0.10421647f, 0.05172168f, -0.13800229f, -0.03155274f, 0.01281831f, 0.03558500f, -0.08350327f, 
    -0.01476424f, 0.08590039f, 0.03371560f, 0.08280050f, 0.22313738f, -0.08756768f, 0.07119691f, 0.06074488f, 
    0.03186103f, 0.02513136f, -0.05836715f, -0.02390960f, 0.00991541f, -0.05878905f, 0.00963270f, -0.07188454f, 
    -0.23909141f, 0.00170218f, 0.02546003f, -0.12832099f, -0.12872998f, 0.03214185f, -0.13807994f, 0.09766866f, 
    0.00598539f, -0.00929935f, -0.12417477f, 0.02038813f, -0.14060096f, 0.06190553f, -0.12650232f, -0.09666526f, 
    -0.03284977f, -0.01665033f, -0.02022162f, -0.03650311f, 0.03020240f, -0.10134865f, 0.02892707f, -0.01500728f, 
    -0.19624136f, -0.05593111f, 0.14396819f, -0.17200820f, -0.03081956f, 0.01425541f, 0.11997296f, -0.10922855f, 
    -0.01527129f, 0.05020780f, -0.06500621f, 0.00044371f, -0.18057914f, -0.10998986f, 0.06885949f, -0.19607326f, 
    0.04486287f, -0.03430024f, 0.06902361f, -0.08062136f, -0.00303805f, -0.07062490f, 0.20088145f, -0.04261697f, 
    0.01762000f, -0.02398835f, -0.17659906f, -0.19544010f, 0.06912380f, 0.05526993f, -0.12882230f, -0.01080844f, 
    -0.00595606f, 0.07450300f, 0.04013388f, -0.03781679f, -0.17726500f, 0.22264348f, 0.00764520f, -0.16327946f, 
    0.03722663f, -0.05489800f, 0.06742219f, -0.00369301f, -0.00462258f, -0.02858326f, 0.01808092f, 0.05366091f, 
    0.01674872f, 0.14095332f, -0.05980859f, -0.14882293f, 0.03452614f, -0.02194625f, -0.09622791f, -0.01009120f, 
    -0.04048719f, -0.00566545f, 0.08118974f, -0.00047851f, -0.07143610f, 0.07650172f, -0.19117138f, -0.07034182f, 
    -0.02520337f, -0.06771573f, -0.03725713f, -0.06816596f, -0.09578100f, 0.11857660f, -0.12539443f, 0.11347269f, 
    0.10766061f, -0.14354506f, 0.00150457f, 0.10463586f, 0.09645154f, 0.02363956f, -0.02423236f, -0.03691303f, 
    -0.00598619f, 0.00584969f, 0.02525822f, -0.18730253f, -0.19715959f, 0.10051535f, -0.15670604f, -0.18839930f, 
    -0.03103340f, -0.03472845f, -0.09156424f, 0.08507772f, 0.04308541f, -0.00660660f, 0.04032040f, 0.00280012f, 
    0.13851613f, 0.07970819f, -0.23607181f, 0.00932696f, 0.02283089f, 0.04207015f, 0.06809425f, 0.02801825f, 
    0.03358693f, -0.05847613f, -0.00200660f, 0.05429685f, 0.23042795f, 0.08980395f, 0.02909327f, 0.05059103f, 
    0.09194312f, -0.04218867f, -0.07608926f, -0.05062228f, -0.05394558f, 0.09388987f, -0.06372683f, -0.06138084f, 
    0.26074067f, 0.07526428f, 0.02073960f, 0.09029018f, -0.06768323f, -0.08670336f, 0.05012866f, -0.10702704f, 
    0.00273975f, 0.04500468f, -0.06469058f, -0.02599897f, 0.12764500f, -0.08131617f, -0.02605135f, 0.07329233f, 
    0.13181977f, 0.05015604f, 0.01328465f, -0.00627194f, -0.01373263f, -0.04777612f, 0.03119538f, -0.05758875f, 
    0.11842209f, -0.07311032f, 0.13242888f, 0.09797100f, -0.03339903f, 0.00379281f, -0.02365788f, 0.07307339f, 
    0.01593471f, -0.10457872f, -0.04297959f, -0.05640901f, -0.07105797f, 0.13249834f, -0.15730420f, -0.17531073f, 
    -0.03363955f, -0.02008535f, -0.07278799f, 0.06766652f, 0.10834121f, -0.00431975f, -0.03956733f, 0.06437992f, 
    -0.18445806f, -0.11893967f, -0.02595296f, -0.32216415f, -0.12885144f, -0.24160232f, 0.04391548f, -0.04372995f, 
    -0.01195760f, 0.12792933f, -0.08173763f, 0.13645442f, 0.09124379f, -0.08232141f, -0.07553928f, -0.10777701f, 
    0.08617029f, -0.04918372f, 0.02556531f, 0.00141234f, 0.01204560f, 0.03266140f, 0.06838249f, 0.03428334f, 
    0.05383878f, -0.07185531f, 0.10736657f, 0.10927430f, -0.14427643f, -0.10412972f, -0.10614847f, -0.06399138f, 
    0.00530641f, -0.12455661f, 0.01309795f, -0.03104370f, 0.12162194f, -0.18036602f, 0.13314651f, -0.03126949f, 
    0.01709853f, -0.10456918f, -0.05274066f, -0.03643612f, 0.02695926f, -0.02994541f, 0.01315212f, -0.06579711f, 
    0.00936251f, -0.23141317f, 0.02693861f, 0.03872861f, 0.05368923f, -0.00265245f, -0.01742685f, 0.02699891f, 
    0.02447523f, 0.04549096f, 0.10396732f, -0.00506923f, 0.06254058f, -0.16794884f, 0.09855393f, 0.03755457f, 
    -0.11583905f, -0.21225835f, -0.06514069f, 0.02109746f, -0.02452876f, 0.08275067f, -0.09910963f, -0.00740982f, 
    -0.18964827f, -0.06480860f, 0.03184126f, 0.11668798f, -0.06893498f, -0.03907773f, 0.03291817f, 0.08310834f, 
    -0.00746947f, 0.14229111f, -0.06618498f, -0.11324475f, 0.09057557f, -0.03837100f, 0.06651729f, 0.13604711f, 
    0.02652525f, -0.10610197f, -0.01437867f, -0.13206750f, 0.05350864f, -0.10572825f, -0.02729220f, 0.08489785f, 
    -0.13292161f, 0.04767056f, -0.09608021f, -0.01058273f, 0.11762624f, 0.06818241f, -0.10722869f, 0.00163965f, 
    -0.02398029f, -0.09849685f, 0.02933832f, 0.00215504f, -0.14474562f, -0.12702189f, 0.02507711f, -0.17737484f, 
    -0.03427852f, -0.05098405f, 0.06690107f, -0.19276528f, -0.00670334f, 0.03344667f, 0.03844825f, 0.06386555f, 
    -0.20972914f, -0.02524689f, -0.04609132f, -0.15452972f, 0.02470007f, -0.01141415f, 0.04751512f, 0.05002560f, 
    -0.07157785f, 0.03406191f, 0.06760307f, -0.07295434f, -0.04897210f, -0.03273608f, -0.07679442f, -0.05607538f, 
    0.03464225f, -0.03208174f, -0.02394780f, 0.02522073f, 0.02636594f, 0.11021074f, -0.09204330f, 0.10708768f, 
    -0.03115579f, -0.17100120f, 0.21461110f, 0.02159310f, -0.03268576f, 0.03808697f, 0.06201569f, -0.01909397f, 
    0.01736553f, -0.06445441f, -0.00207810f, -0.06682292f, -0.14341779f, -0.09665219f, -0.16673945f, -0.03038598f, 
    0.04609117f, -0.09415426f, -0.02758323f, -0.02958342f, 0.03476539f, 0.07100693f, 0.03005326f, -0.05240852f, 
    0.06156044f, -0.18028449f, -0.05067020f, -0.01126047f, -0.10610146f, -0.04789924f, 0.02872022f, 0.07877738f, 
    0.15860872f, 0.12074574f, 0.09684446f, 0.07440456f, 0.24454176f, -0.19366392f, -0.09907028f, -0.05657786f, 
    -0.02648894f, -0.04490157f, 0.06963702f, -0.00930656f, 0.05755917f, -0.17014061f, 0.03148440f, -0.01795955f, 
    0.16382650f, 0.04112450f, -0.16325572f, -0.19090396f, 0.05873996f, -0.04906164f, 0.03592993f, -0.04565531f, 
    -0.00795771f, -0.12528202f, -0.09631035f, 0.01692734f, 0.20181857f, 0.11157142f, 0.03259093f, 0.12190299f, 
    0.03182783f, -0.01684551f, -0.02517150f, 0.12176467f, 0.03307154f, -0.03440882f, -0.07181592f, 0.11523312f, 
    0.00626012f, -0.10552728f, 0.05080285f, 0.08652902f, 0.11166655f, 0.00275599f, 0.04527281f, 0.03429352f, 
    -0.06393362f, -0.05934012f, 0.08902321f, 0.01738497f, -0.55406612f, 0.46491027f, -0.33456933f, -0.19062914f, 
    0.16384821f, -0.06680858f, -0.00562970f, -0.06330140f, -0.12064806f, -0.01459686f, 0.01632405f, -0.14964792f, 
    -0.16242304f, 0.17512031f, 0.32197148f, -0.00643244f, 0.02513842f, 0.08651569f, 0.04376950f, -0.06910133f, 
    -0.03631337f, -0.08505597f, -0.00092872f, 0.08913558f, 0.16665140f, -0.00223923f, 0.18851307f, 0.01802980f, 
    0.04232802f, 0.15372372f, -0.16971445f, -0.07622490f, -0.14533363f, -0.00736516f, 0.04676189f, -0.12857725f, 
    -0.16575268f, 0.13413665f, -0.32273319f, 0.16941558f, -0.03871743f, 0.00878850f, -0.01562640f, 0.03103276f, 
    -0.03592543f, 0.07656184f, -0.03236399f, -0.01369242f, 0.45595062f, -0.22378981f, 0.26401007f, 0.04033340f, 
    0.01949298f, 0.07712942f, -0.03178281f, -0.04373110f, -0.03848292f, 0.08259051f, 0.04354072f, 0.04874757f, 
    -0.00822301f, 0.14567028f, 0.13929112f, -0.21651798f, 0.02544458f, -0.08178952f, 0.07182167f, 0.03943646f, 
    -0.05517621f, 0.00017705f, -0.15088813f, 0.08878791f, -0.13413876f, 0.02811158f, -0.16969921f, -0.03857214f, 
    0.12316996f, -0.15253352f, -0.03773548f, 0.00232227f, -0.06231111f, 0.01281117f, 0.05792848f, 0.00653345f, 
    -0.00449390f, -0.05309914f, 0.10908552f, -0.36597162f, 0.01737485f, 0.13436674f, -0.15605786f, 0.02285437f, 
    -0.07122777f, -0.01638367f, -0.11418380f, -0.14089048f, 0.38525578f, 0.09939241f, 0.13754658f, -0.07500477f, 
    0.00134234f, -0.01345437f, 0.04573157f, -0.04474779f, -0.06253711f, -0.01416260f, -0.04348743f, 0.06259388f, 
    -0.49738756f, 0.15684702f, 0.02653802f, -0.03251883f, 0.10135541f, -0.02303049f, 0.09667245f, -0.19999672f, 
    -0.08617924f, 0.03214682f, -0.00883721f, 0.13223180f, -0.19265540f, 0.25601426f, -0.08224422f, -0.32606941f, 
    0.06851897f, 0.08498133f, -0.01182028f, 0.02663428f, -0.04130097f, 0.00682697f, -0.12005807f, -0.03995425f, 
    0.12756781f, 0.00921633f, 0.02616381f, 0.03963414f, -0.00749104f, -0.09244975f, 0.01000168f, 0.09753928f, 
    -0.01646675f, 0.03384900f, 0.04155290f, 0.05237256f, -0.24125002f, -0.01591813f, -0.04526202f, -0.32589072f, 
    -0.09372454f, -0.01249131f, 0.00830800f, 0.03000629f, -0.04837421f, -0.00573472f, -0.04105262f, -0.11066061f, 
    -0.23187758f, -0.11811976f, 0.25226605f, -0.14474234f, -0.01839955f, 0.04862473f, -0.04823204f, -0.01815804f, 
    0.08921850f, -0.05869905f, 0.00235034f, -0.03163351f, 0.28657839f, -0.10577112f, -0.02113941f, 0.14449614f, 
    0.01143470f, 0.03189022f, 0.01407215f, 0.06889664f, -0.01741713f, -0.11276414f, -0.01746888f, -0.06301249f, 
    -0.16010588f, -0.07261250f, 0.20883632f, -0.13344786f, -0.01529469f, -0.08944470f, 0.05349290f, 0.17779353f, 
    0.06895579f, 0.08152512f, 0.07093114f, 0.03561370f, -0.03424825f, -0.22009750f, 0.23219909f, 0.09269094f, 
    -0.00259218f, -0.03084233f, -0.07372382f, 0.05050696f, 0.09509382f, 0.07983121f, -0.06550560f, -0.07248560f, 
    -0.02110460f, 0.03643959f, -0.13657621f, -0.01958951f, 0.06960678f, -0.05915838f, 0.12200151f, 0.03512910f, 
    -0.09164874f, -0.03139440f, -0.02543227f, -0.05165900f, 0.13384961f, -0.12964393f, -0.25966349f, -0.36133873f, 
    -0.07508391f, -0.00544733f, 0.01968502f, 0.04259323f, 0.06009427f, -0.03692453f, 0.07615420f, -0.04658524f, 
    -0.25006193f, 0.18760981f, -0.15174644f, 0.06765573f, 0.03907119f, 0.02988801f, 0.03741401f, -0.13362257f, 
    -0.03353458f, 0.04196519f, -0.09575399f, -0.01184167f, -0.31601620f, 0.05883330f, 0.14173496f, -0.00524416f, 
    0.02995836f, 0.02422614f, -0.00000510f, -0.04693749f, 0.07835736f, -0.00835404f, 0.01195528f, -0.08052812f, 
    0.15416741f, -0.11580785f, 0.00128058f, 0.11381223f, -0.02422258f, 0.02030423f, 0.06868762f, 0.05873298f, 
    0.05228840f, 0.08993606f, -0.04743128f, 0.10150835f, -0.19581498f, -0.03167243f, -0.30905682f, 0.18118039f, 
    -0.02621599f, -0.06739632f, 0.05063869f, -0.03913544f, 0.00892610f, -0.12815425f, 0.18301073f, -0.00892802f, 
    -0.19200818f, 0.45659509f, -0.29653132f, 0.02866890f, 0.06258951f, 0.08724856f, 0.02243293f, -0.03518715f, 
    -0.04497916f, 0.12420337f, 0.05074121f, -0.01990092f, 0.13694873f, -0.00940732f, 0.23545066f, 0.04374832f, 
    0.05112769f, 0.08846871f, 0.08120473f, -0.15452580f, -0.02735005f, 0.07718290f, -0.01107648f, 0.05680590f, 
    -0.06318737f, 0.27289662f, 0.39235255f, -0.08292165f, 0.05465097f, 0.02217683f, -0.06057120f, -0.01890559f, 
    0.04917007f, 0.00195925f, -0.04110963f, -0.04597652f, -0.06112797f, -0.20997475f, -0.00850758f, -0.02403324f, 
    0.07849656f, 0.00972344f, 0.00835100f, 0.07141281f, -0.05764178f, -0.06841899f, 0.03143137f, 0.01031196f, 
    0.24925461f, -0.13184993f, -0.15210493f, 0.14074935f, -0.15070081f, 0.05989933f, 0.10065557f, 0.05082832f, 
    0.05135081f, 0.00191993f, 0.02735324f, -0.06451469f, 0.01404402f, 0.02719994f, -0.19433561f, -0.11055538f, 
    -0.00833959f, 0.00402264f, -0.03622126f, -0.14177741f, 0.05374748f, -0.07047245f, 0.11400929f, 0.07060600f, 
    0.01119977f, 0.01401538f, -0.07201088f, 0.22799011f, 0.05538424f, -0.06557076f, 0.00357519f, -0.11036480f, 
    -0.10605042f, 0.08540639f, -0.07184127f, 0.04698414f, -0.31034556f, -0.09275515f, 0.16244067f, -0.15352891f, 
    0.10654787f, 0.04262397f, -0.04566857f, 0.00944144f, 0.05964710f, -0.07250430f, -0.07423349f, -0.04243740f, 
    -0.32066959f, -0.09764177f, -0.05140431f, -0.00141667f, 0.12548730f, -0.08092960f, -0.03290345f, -0.07371208f, 
    0.03558666f, -0.20811774f, 0.04754149f, 0.00259250f, -0.08396135f, -0.30591089f, -0.04376097f, -0.18890154f, 
    0.03693869f, 0.05879693f, -0.05138211f, -0.06638338f, 0.04780288f, -0.03681664f, -0.14633712f, 0.08811692f, 
    -0.08476505f, 0.02568820f, 0.01616275f, -0.16316013f, 0.07298991f, -0.03161852f, 0.03395864f, 0.04141746f, 
    0.05898335f, 0.11422013f, -0.09860191f, -0.00002569f, -0.07815393f, -0.07143573f, 0.03808038f, 0.12786490f, 
    0.07275283f, 0.09038970f, -0.06925667f, -0.01675098f, -0.04218444f, -0.01784539f, 0.11529752f, -0.09795433f, 
    0.22436011f, 0.02153613f, 0.12090310f, -0.10229005f, 0.02344956f, -0.02680269f, 0.03464156f, -0.07098036f, 
    0.14216267f, -0.05233306f, -0.02064549f, -0.21570976f, -0.44373593f, 0.24752542f, -0.01106619f, 0.10315342f, 
    0.07747145f, 0.12029736f, 0.00913848f, 0.01285192f, 0.09330037f, -0.05143656f, 0.17387217f, 0.06086601f, 
    -0.23923336f, 0.10494556f, -0.06127571f, -0.05984284f, 0.03031002f, 0.03578474f, 0.11537259f, -0.04024426f, 
    0.00173437f, 0.03688842f, 0.04791411f, 0.08517366f, -0.15932645f, -0.00013375f, 0.05101455f, 0.03125679f, 
    -0.02712910f, 0.04247143f, -0.03717599f, 0.04254317f, 0.00911435f, -0.03171800f, 0.08921184f, -0.03150367f, 
    0.15388484f, 0.07635029f, 0.16423754f, 0.21697006f, -0.06748983f, -0.02709397f, 0.08376784f, 0.03720273f, 
    -0.03991961f, 0.02471204f, -0.09831499f, 0.07530116f, -0.01774372f, 0.14597085f, -0.02648474f, 0.07113529f, 
    -0.00958581f, 0.06980653f, -0.04327845f, 0.01199990f, 0.08757090f, 0.10878233f, -0.03753028f, 0.02795051f, 
    -0.14785150f, -0.08610830f, -0.29288670f, -0.07489961f, 0.00453576f, -0.05521667f, 0.07882653f, -0.05124598f, 
    0.06285282f, 0.08752965f, -0.02479207f, -0.05584596f, -0.10781164f, 0.00210777f, -0.07887845f, -0.08443125f, 
    0.12240351f, 0.03382513f, 0.04948677f, -0.03903107f, -0.06782306f, -0.04825439f, -0.10711841f, -0.02741471f, 
    -0.08036918f, -0.11424016f, 0.04983231f, -0.01430256f, 0.04981087f, -0.02504093f, -0.01927278f, -0.00717707f, 
    0.02164368f, 0.02768493f, 0.00412838f, 0.07979253f, -0.14271556f, 0.07001092f, 0.14453565f, 0.01737801f, 
    -0.03161446f, 0.03591701f, -0.03474848f, -0.11824160f, -0.02738118f, -0.01387282f, 0.00834133f, 0.01902548f, 
    0.31591848f, 0.28522614f, -0.16614495f, -0.25203618f, 0.02629785f, -0.03040417f, 0.05380865f, -0.02448309f, 
    -0.21701352f, -0.06910997f, -0.01524639f, -0.03412275f, -0.08903041f, 0.09956259f, 0.07815668f, -0.28526402f, 
    -0.00213194f, 0.02692496f, -0.03389969f, 0.00546892f, -0.01692493f, 0.06098392f, -0.08658762f, -0.04414651f, 
    -0.03289765f, -0.22512344f, 0.04199658f, -0.05457086f, 0.13444291f, -0.04016357f, 0.05556599f, 0.01131663f, 
    -0.02114206f, -0.06135342f, 0.13384877f, 0.02427249f, -0.16173555f, -0.17786995f, -0.07202589f, 0.07176416f, 
    -0.06283646f, 0.04510044f, 0.01859120f, -0.07143765f, 0.03241561f, 0.05164629f, -0.17512898f, 0.09922604f, 
    -0.32610950f, 0.08554297f, -0.01153760f, -0.04784791f, -0.01008255f, 0.03427614f, -0.03249597f, -0.11288238f, 
    -0.06198006f, -0.02610516f, -0.06525001f, 0.00120260f, -0.00901354f, 0.15585558f, -0.15230294f, 0.21928377f, 
    -0.04013240f, 0.02871721f, -0.02918607f, -0.02594305f, 0.04563976f, -0.03509379f, 0.08634344f, 0.10869373f, 
    -0.14753518f, 0.06866581f, 0.00765411f, 0.08858292f, 0.06619360f, 0.03100384f, 0.08869045f, -0.05746974f, 
    -0.00630909f, 0.01557273f, 0.00349564f, 0.06406985f, -0.37235156f, 0.18002142f, 0.03387949f, -0.06695467f, 
    -0.03572583f, -0.08120576f, -0.06390063f, 0.01068533f, 0.19742598f, 0.05570433f, 0.02819773f, -0.01011451f, 
    0.21092989f, -0.47370747f, 0.12277038f, 0.01794470f, 0.00218589f, -0.08102118f, -0.06719358f, 0.03628614f, 
    -0.07138854f, 0.10341273f, -0.00203163f, 0.08678304f, -0.06763697f, 0.00618843f, -0.12924169f, 0.08433068f, 
    -0.02839311f, 0.07820138f, -0.04444206f, 0.01135653f, -0.06646034f, -0.01265119f, 0.02516768f, -0.02389269f, 
    -0.05405514f, 0.07478155f, -0.04109121f, 0.17522334f, -0.03285030f, 0.04916866f, -0.01647404f, -0.02162868f, 
    -0.06834700f, -0.06981201f, 0.05938783f, 0.01355516f, 0.02898049f, -0.29420531f, 0.09337657f, 0.04607079f, 
    -0.00178290f, 0.11770631f, 0.11135468f, -0.00904463f, 0.03541846f, -0.05744537f, -0.04630405f, -0.21014255f, 
    0.05208388f, -0.30327034f, 0.07469424f, -0.14332767f, 0.01258289f, 0.01169430f, -0.04528900f, -0.06149265f, 
    -0.12974319f, 0.15108930f, -0.07062154f, 0.14230968f, 0.13907693f, -0.08899219f, 0.00791328f, -0.04016127f, 
    -0.15295842f, -0.01464142f, 0.09371565f, 0.07155115f, 0.07625175f, 0.10426236f, -0.12346212f, 0.02807544f, 
    0.14799097f, 0.05755774f, 0.05502099f, -0.00464714f, -0.12839620f, 0.06077365f, -0.14656039f, 0.10059697f, 
    0.06268884f, 0.04478477f, -0.06060052f, -0.10893502f, 0.11568745f, 0.08974874f, -0.01514830f, -0.01205201f, 
    -0.08946910f, -0.17985000f, 0.05464084f, -0.05510641f, -0.14392748f, -0.07121766f, -0.06141464f, 0.06303680f, 
    -0.08526829f, 0.06065706f, -0.08239356f, -0.07225623f, -0.07865901f, 0.03998649f, 0.00402599f, 0.00840877f, 
    -0.03382297f, 0.13079278f, 0.09408848f, -0.07404280f, -0.23935501f, -0.00918966f, -0.10086714f, -0.07923668f, 
    0.04633806f, 0.06434799f, 0.01984511f, 0.00148601f, 0.06535055f, -0.06436357f, 0.02591253f, -0.05721658f, 
    0.14527296f, -0.01943705f, 0.01749508f, -0.09767892f, 0.00580605f, -0.00781462f, 0.04525491f, 0.04800342f, 
    0.11818442f, -0.04297758f, -0.05380383f, 0.00172905f, -0.40936780f, -0.12117309f, -0.19573909f, -0.22591478f, 
    0.00860233f, 0.00133981f, -0.05705407f, 0.04711911f, 0.06816237f, -0.00450646f, 0.05590082f, -0.06559821f, 
    -0.20285045f, -0.10263837f, -0.04696033f, 0.00901392f, 0.11100889f, 0.05741448f, 0.08294649f, 0.02163736f, 
    0.01599576f, 0.03621797f, 0.01550850f, 0.04328450f, -0.32050863f, -0.21652359f, 0.00132175f, 0.04246249f, 
    0.08653436f, 0.05171636f, -0.02951699f, 0.01455995f, -0.02137963f, 0.09715525f, 0.05706486f, 0.13171378f, 
    -0.09777499f, -0.09425175f, 0.02133449f, 0.01148688f, -0.11112569f, -0.05646914f, 0.01337655f, 0.04561584f, 
    -0.03679093f, 0.03454156f, 0.08151997f, 0.02946287f, -0.40045124f, -0.16851032f, 0.06966837f, 0.02042918f, 
    0.11410032f, 0.03979605f, -0.09746638f, -0.02153834f, -0.03755181f, -0.11189922f, -0.11379631f, 0.09542052f, 
    -0.18307637f, -0.14834027f, -0.01503811f, -0.17471638f, 0.01577404f, 0.06750233f, -0.05988622f, 0.07437751f, 
    -0.01697140f, 0.00054301f, 0.17456867f, 0.00915958f, -0.18371892f, 0.17027806f, -0.10061297f, -0.14784983f, 
    0.07230017f, 0.08218917f, -0.12082943f, 0.04982683f, 0.08796072f, -0.02551586f, -0.08457018f, -0.12927845f, 
    -0.34791559f, 0.00492283f, -0.03480953f, -0.20136878f, 0.06643544f, -0.01058544f, -0.02361143f, -0.13039766f, 
    -0.00005204f, 0.03746600f, 0.03215551f, 0.06388047f, -0.33534938f, -0.00208571f, 0.13693155f, 0.10733851f, 
    0.08563364f, 0.02393152f, 0.02557614f, 0.04297863f, 0.08327900f, 0.10298947f, -0.07511950f, 0.03936439f, 
    -0.36160940f, -0.29742306f, 0.13546462f, 0.00007898f, -0.05403778f, 0.03279658f, 0.03680210f, 0.02238803f, 
    0.15170124f, 0.06488745f, 0.01987642f, 0.09732813f, -0.47778609f, -0.33606201f, -0.14736991f, -0.33524799f, 
    0.08897188f, -0.10767823f, -0.04594039f, -0.06640502f, 0.09741516f, 0.02569334f, 0.05398661f, 0.03819682f, 
    0.06660254f, -0.14390559f, 0.01231497f, -0.05796058f, -0.11266649f, -0.00239839f, 0.02352390f, -0.01895821f, 
    0.04058062f, -0.08561019f, -0.07045590f, 0.05544212f, -0.28180876f, -0.05950304f, -0.14486186f, -0.29469571f, 
    0.10220210f, -0.06926304f, -0.05126089f, 0.07980489f, -0.01486865f, -0.15853494f, -0.03797841f, 0.09582708f, 
    -0.24880295f, 0.00050000f, -0.02191580f, -0.07020300f, 0.18956351f, -0.03417917f, -0.01807094f, -0.02648581f, 
    -0.02200492f, -0.02283059f, -0.09923608f, -0.16909793f, 0.01211395f, -0.10957092f, 0.12024520f, -0.17038602f, 
    -0.01976488f, -0.00289053f, 0.03761717f, -0.09117367f, 0.01215539f, 0.05663805f, 0.07640856f, 0.04473248f, 
    -0.00402992f, 0.12820007f, 0.00029610f, -0.08091835f, -0.23303923f, 0.03466278f, -0.01176886f, -0.14539178f, 
    0.03141545f, -0.02155438f, -0.15507641f, -0.15016502f, 0.17962338f, 0.03551511f, -0.06165168f, -0.01223709f, 
    -0.14533861f, -0.05350480f, 0.04496556f, 0.01569857f, 0.03009674f, -0.02886155f, -0.00942766f, -0.10402364f, 
    -0.29462591f, -0.21745293f, -0.07741866f, -0.07840789f, -0.04254771f, -0.02209397f, -0.06364448f, 0.05539232f, 
    -0.00721259f, 0.08583971f, 0.04208776f, 0.09613980f, 0.20338003f, 0.22887072f, -0.08696379f, -0.16934045f, 
    0.14751731f, 0.05026262f, -0.04554364f, 0.07135415f, 0.10785697f, 0.06553475f, 0.10250568f, 0.04219947f, 
    0.14631882f, -0.01989486f, -0.13610238f, 0.05940929f, 0.03459873f, -0.09771790f, 0.02172944f, 0.17625587f, 
    0.06739325f, 0.05847580f, -0.00336688f, 0.12423068f, -0.45279485f, -0.25711820f, 0.11877254f, -0.04275387f, 
    0.07394546f, -0.01739341f, -0.02653578f, -0.03808931f, 0.06451567f, -0.10778352f, -0.05587967f, 0.06929174f, 
    0.22879364f, 0.14005844f, -0.10955297f, 0.03764337f, 0.00964777f, -0.17376371f, -0.08348205f, -0.03958416f, 
    -0.05651050f, -0.05685865f, -0.10443307f, -0.01320577f, -0.06785892f, 0.18229166f, -0.16127931f, -0.02947477f, 
    0.11689432f, 0.06960983f, 0.02241737f, 0.04795116f, -0.00430157f, -0.08387169f, 0.02952803f, -0.06349348f, 
    0.09582382f, -0.05443580f, 0.04632718f, -0.04396061f, -0.04112315f, 0.06343701f, -0.01821359f, 0.12317514f, 
    0.07140657f, 0.05110144f, 0.12257068f, 0.00980304f, -0.37352487f, -0.06514188f, -0.14603680f, 0.04964554f, 
    0.04717102f, 0.04582202f, -0.19299568f, -0.03346481f, 0.03648342f, 0.02049422f, 0.02777143f, 0.01732348f, 
    -0.28895545f, -0.23314972f, 0.03913130f, -0.04572660f, 0.04520596f, 0.02739322f, -0.00511392f, 0.02915448f, 
    0.05969190f, -0.00986658f, 0.04307653f, -0.01610257f, 0.05607853f, 0.01035101f, 0.05885836f, -0.09081245f, 
    -0.02268400f, 0.07593456f, 0.00826646f, -0.04038369f, 0.10334873f, 0.03911469f, -0.03190885f, 0.01483834f, 
    0.12157521f, 0.01740462f, -0.06711915f, 0.05758337f, 0.02490081f, 0.05983878f, 0.05255385f, 0.05401376f, 
    0.03383537f, 0.01777538f, -0.05088755f, 0.08015843f, -0.21339709f, -0.16371165f, -0.26012862f, -0.09015220f, 
    -0.01138425f, -0.03086866f, -0.03134604f, -0.02368474f, 0.08959961f, -0.08059128f, -0.00530409f, 0.05797672f, 
    0.28779814f, 0.00752944f, 0.06698736f, -0.13544762f, -0.09123489f, -0.02878959f, -0.07393829f, 0.15279149f, 
    0.02623056f, -0.01622207f, -0.06148823f, -0.15130158f, 0.02537471f, 0.08370444f, -0.19015317f, 0.04083961f, 
    0.03427625f, 0.08196805f, 0.02699175f, -0.03374524f, -0.07599281f, -0.01238394f, -0.01418429f, -0.11951376f, 
    0.08340617f, 0.13548994f, -0.05595586f, 0.10172659f, -0.07391246f, 0.03117627f, -0.00903274f, -0.12954007f, 
    -0.00825618f, 0.13192706f, 0.02511851f, -0.02704279f, 0.20041238f, 0.05670640f, -0.04245532f, -0.01789471f, 
    -0.00110351f, -0.02061687f, 0.02347976f, 0.01473663f, 0.02787887f, 0.05261889f, 0.02728749f, -0.08087973f, 
    0.09697328f, 0.07917330f, 0.00580669f, -0.09122572f, 0.02922298f, -0.04872759f, -0.02038652f, 0.08348455f, 
    -0.08349868f, 0.06337391f, 0.15390494f, 0.08225216f, 0.06977831f, 0.16909401f, 0.07315619f, -0.04081168f, 
    0.07348794f, 0.09353248f, -0.04935084f, -0.05565736f, 0.05172819f, 0.04271178f, 0.01394458f, 0.02472300f, 
    0.07592428f, -0.03862155f, -0.01224178f, 0.01800878f, -0.08371430f, 0.00098067f, -0.02898490f, 0.05517514f, 
    -0.08591991f, -0.07534449f, 0.02152837f, 0.07210774f, 0.05715377f, -0.09879553f, -0.01667740f, 0.11636111f, 
    0.07224853f, 0.00663440f, 0.07870868f, -0.02793932f, 0.14954677f, 0.05850608f, -0.15922122f, 0.15791205f, 
    -0.28872937f, -0.15480293f, -0.02854987f, -0.04768849f, 0.09442635f, -0.00498676f, -0.01551207f, -0.03802596f, 
    0.04980591f, 0.07715195f, -0.00004616f, 0.00635124f, 0.14478876f, 0.04474614f, 0.05825977f, -0.02660367f, 
    0.05480510f, 0.05023071f, 0.04615553f, 0.03691564f, 0.03449551f, -0.04943981f, -0.03795891f, 0.01754477f, 
    -0.28401351f, -0.10751294f, 0.11104767f, 0.16421477f, 0.15335527f, 0.02581711f, 0.10205928f, -0.03710411f, 
    0.06018477f, 0.03310471f, 0.01932300f, 0.13497564f, -0.25685841f, -0.20363900f, -0.05849223f, -0.09356331f, 
    0.03532271f, 0.04291826f, -0.04580004f, -0.08429985f, -0.02038023f, -0.01552927f, -0.11057205f, 0.01571856f, 
    0.11595955f, -0.10145313f, -0.18969844f, 0.04150297f, -0.06334375f, -0.07704736f, -0.16692135f, 0.01907277f, 
    -0.04667998f, 0.04827808f, 0.07090452f, -0.09391391f, -0.40102750f, -0.14393979f, -0.03403964f, -0.04614546f, 
    0.08713076f, 0.05666259f, -0.00456044f, 0.00774468f, 0.10207649f, 0.10953536f, 0.05262579f, 0.01228480f, 
    0.14839835f, 0.08109211f, -0.04984136f, 0.00819987f, -0.18503982f, -0.11453472f, -0.04638382f, -0.03163345f, 
    0.07276576f, -0.00546039f, 0.01656900f, -0.04716399f, 0.00101564f, 0.05272596f, 0.12024276f, 0.07726043f, 
    0.09361259f, 0.05776309f, 0.00749577f, 0.10115912f, 0.00952797f, -0.05537552f, 0.03336262f, -0.00541774f, 
    -0.07449282f, -0.13793936f, 0.07140873f, 0.26900661f, 0.04079079f, -0.11778720f, -0.03244458f, -0.14420404f, 
    -0.05038333f, 0.09497422f, -0.04629169f, 0.06767565f, 0.06955110f, 0.01313727f, 0.08888768f, -0.07341213f, 
    0.09820464f, 0.00986356f, -0.00603425f, 0.06669524f, -0.03725153f, 0.05030798f, 0.02218313f, 0.07765207f, 
    0.19796596f, 0.06600535f, -0.04057659f, 0.03639494f, -0.02072994f, -0.03940519f, -0.04788667f, 0.03095972f, 
    0.04795890f, 0.02180126f, -0.21691936f, -0.01960853f, 0.15430182f, 0.08771717f, -0.04668944f, 0.15308732f, 
    -0.04236403f, -0.07451048f, 0.01371807f, 0.04993518f, -0.06427830f, -0.08782776f, -0.02113044f, -0.00661222f, 
    -0.27534238f, -0.28718734f, 0.03794597f, -0.08073625f, 0.03605663f, -0.07370281f, 0.04981722f, 0.08199117f, 
    0.08545308f, 0.22061488f, 0.09603642f, 0.11661796f, 0.00459214f, -0.15366958f, 0.10016745f, 0.02166805f, 
    0.01432022f, -0.20484120f, -0.04227697f, 0.01432630f, 0.07398207f, 0.00088901f, -0.03196356f, 0.05170881f, 
    0.34270251f, 0.02791629f, 0.09509405f, 0.05203709f, -0.02865335f, -0.00340554f, -0.00079264f, 0.09544136f, 
    0.07235102f, 0.01462225f, -0.00062325f, 0.14824642f, -0.39927137f, -0.31705257f, -0.09725040f, 0.05745992f, 
    0.03488368f, -0.03942087f, 0.01620468f, -0.10376537f, 0.09646724f, -0.16566901f, -0.07517425f, 0.15476538f, 
    -0.51073748f, 0.04584909f, -0.13608333f, -0.22815612f, 0.11253982f, 0.06478655f, -0.13842058f, 0.03134025f, 
    -0.06048700f, -0.06374118f, -0.11385829f, 0.05110259f, 0.05210215f, 0.03281352f, -0.02008153f, 0.03154781f, 
    0.02430479f, 0.16317947f, -0.01278291f, -0.05200658f, 0.02079799f, -0.04123890f, -0.00880044f, 0.09908742f, 
    0.05006489f, -0.18105221f, 0.07372842f, 0.05438891f, 0.04295068f, -0.07303364f, -0.00438133f, -0.03697193f, 
    0.08017074f, 0.20840670f, -0.02162595f, -0.03151469f, 0.05623612f, 0.04724147f, 0.05379410f, 0.01289735f, 
    0.12262639f, 0.01792514f, 0.04580859f, 0.03414135f, -0.02817860f, 0.06174247f, 0.10565567f, 0.20616235f, 
    0.12787250f, 0.08076202f, 0.00332237f, -0.03459168f, 0.03880852f, -0.01601803f, 0.00311461f, -0.03364740f, 
    0.13376150f, 0.12904711f, 0.03947624f, 0.02475466f, 0.14100571f, 0.00149323f, -0.05938903f, 0.05165413f, 
    -0.02188192f, -0.09564290f, -0.15937391f, 0.14592411f, -0.06434505f, 0.07275354f, 0.02886643f, -0.00619737f, 
    -0.31704685f, 0.25414038f, -0.18407483f, 0.06853602f, 0.08780184f, -0.00068378f, 0.03193597f, -0.04816675f, 
    -0.03856974f, -0.01747154f, 0.06314139f, 0.00357299f, 0.11381819f, -0.02641226f, 0.02459786f, -0.04048378f, 
    -0.04461254f, 0.03868726f, 0.01391588f, 0.04603769f, -0.01806497f, -0.02048446f, 0.09839799f, -0.09578745f, 
    -0.12731473f, -0.01599831f, 0.06242685f, 0.13096400f, -0.09835454f, -0.05620028f, 0.07188891f, 0.01103868f, 
    -0.04543956f, -0.05563120f, 0.08490696f, 0.05034427f, -0.36889780f, 0.04658742f, 0.10531230f, 0.06860886f, 
    -0.16669571f, 0.07801483f, -0.01705877f, -0.00953348f, -0.05393897f, -0.01352767f, -0.00358845f, -0.04652253f, 
    -0.22454882f, 0.26280543f, -0.03121511f, 0.09430468f, -0.14406700f, 0.02795822f, -0.07154281f, 0.01622439f, 
    0.07647755f, -0.04378599f, 0.02154411f, -0.07497245f, 0.10216188f, -0.31594902f, 0.00605963f, -0.03140835f, 
    -0.00952177f, 0.04596611f, 0.02983150f, -0.07413159f, -0.06134767f, 0.05552582f, 0.02884785f, -0.06399474f, 
    0.18763287f, -0.06418748f, -0.06354591f, 0.04472232f, 0.07826823f, -0.04126520f, -0.05198289f, -0.00695634f, 
    0.05027379f, -0.00906612f, 0.04924542f, -0.02150561f, 0.32277974f, 0.09880259f, -0.14601013f, -0.02563290f, 
    -0.06161978f, -0.02650857f, -0.00356843f, 0.02270409f, 0.01336512f, -0.03759306f, -0.01648046f, 0.00839360f, 
    -0.27437535f, 0.06695092f, 0.03898394f, 0.04461945f, 0.04457623f, 0.00773683f, 0.13343123f, -0.11251175f, 
    -0.00326740f, -0.02837505f, -0.01621953f, 0.03881595f, 0.39096761f, 0.14024657f, 0.02013518f, -0.12729111f, 
    -0.06229009f, -0.01513490f, 0.06001190f, 0.00093771f, 0.13463390f, 0.03762844f, 0.07180180f, 0.13540851f, 
    -0.09406015f, -0.21143432f, 0.08905698f, -0.41766688f, -0.07946649f, 0.08983658f, -0.00018406f, 0.08674498f, 
    0.00953279f, 0.00916192f, -0.13293993f, -0.08738326f, -0.24528855f, -0.04960438f, 0.19704409f, 0.16743013f, 
    -0.06330626f, 0.00838169f, -0.02680875f, 0.04180384f, 0.02366971f, 0.09316459f, 0.06737011f, 0.07354729f, 
    0.40400025f, 0.14091448f, -0.06404953f, -0.00278832f, -0.00957277f, -0.06233338f, 0.05516401f, -0.05321854f, 
    0.06125640f, -0.10558815f, 0.01253734f, -0.02974526f, 0.36219257f, 0.10278837f, 0.05652137f, 0.03155876f, 
    -0.08023512f, -0.03052460f, -0.06522318f, 0.02635772f, 0.12670359f, 0.02973170f, 0.04263110f, 0.07507320f, 
    -0.24962413f, 0.05818782f, 0.08377681f, -0.07527906f, 0.17845699f, 0.06835095f, -0.05361603f, -0.00480746f, 
    0.05315025f, 0.01494227f, 0.07647254f, -0.04365879f, 0.15840657f, -0.16074458f, -0.14454623f, -0.03191439f, 
    -0.02978460f, 0.01105506f, 0.05244991f, -0.03354419f, 0.03450543f, -0.00635227f, -0.05464702f, 0.00999541f, 
    -0.24051334f, 0.13164888f, -0.14069627f, -0.00491070f, 0.02250324f, -0.01477600f, 0.05409371f, -0.00947915f, 
    0.00345726f, 0.07591467f, 0.13937379f, -0.10787181f, 0.19873151f, -0.11774290f, -0.18382481f, -0.12699164f, 
    -0.06298689f, 0.05386719f, -0.05021895f, 0.04583940f, -0.01250765f, -0.01131683f, 0.01424564f, -0.02544998f, 
    0.23913191f, -0.30488038f, -0.16570888f, 0.13569760f, -0.00853679f, -0.00913184f, -0.04002722f, -0.14545977f, 
    0.13300033f, 0.05462314f, 0.03257183f, 0.11551163f, -0.05060053f, 0.00493473f, 0.10842606f, -0.19050027f, 
    0.09398571f, -0.07706243f, -0.08031871f, -0.02369071f, -0.03812622f, 0.02176500f, -0.10030500f, -0.22283258f, 
    0.00378939f, -0.17177780f, -0.03530895f, 0.07036177f, -0.08727163f, -0.06023380f, -0.10835773f, -0.08819332f, 
    -0.03953781f, -0.00386374f, 0.09202065f, -0.08031766f, -0.05762215f, -0.19826025f, 0.02318007f, 0.05541138f, 
    -0.01285172f, 0.01781485f, -0.10206458f, 0.05635618f, -0.02018842f, 0.06889546f, 0.00358306f, -0.12004765f, 
    -0.13210763f, -0.16255131f, -0.00429321f, -0.00026143f, 0.11776517f, -0.03173049f, 0.03927381f, -0.05165851f, 
    0.02662037f, -0.08449674f, -0.07769558f, -0.01936272f, 0.11814304f, -0.05180391f, -0.09319469f, 0.35767952f, 
    -0.07276110f, 0.01962896f, 0.03984133f, 0.09513681f, -0.00745390f, -0.07796887f, -0.03762954f, -0.11458912f, 
    0.06900383f, -0.06745023f, 0.07420143f, -0.07064499f, -0.07318608f, -0.02223862f, 0.08493453f, -0.04532866f, 
    -0.11247580f, -0.01738076f, -0.01945951f, 0.00238342f, -0.30131799f, 0.01021449f, -0.01106690f, -0.04641084f, 
    0.04098160f, 0.04424424f, -0.02978149f, 0.01375539f, 0.06127436f, 0.06456434f, 0.06424273f, -0.05906763f, 
    0.06745116f, 0.05227382f, 0.03047811f, -0.07695761f, 0.01973931f, 0.01677852f, 0.09760387f, 0.00580606f, 
    0.04286265f, -0.00001291f, -0.02603348f, 0.04918132f, -0.05129588f, -0.06484357f, 0.12076576f, 0.17367318f, 
    -0.06696609f, 0.06848636f, 0.10131751f, 0.04991735f, 0.07144388f, -0.01132229f, -0.04812529f, 0.07685029f, 
    0.12149828f, -0.03508800f, -0.14257202f, 0.21066715f, 0.03668300f, -0.06652733f, -0.00792480f, -0.05862009f, 
    -0.02732507f, -0.07287525f, -0.14917630f, 0.06175772f, 0.26793107f, -0.04539977f, 0.01221081f, -0.01903401f, 
    -0.10417134f, -0.10959637f, -0.01304691f, 0.06723434f, -0.00623222f, 0.06926110f, -0.04654963f, 0.01619171f, 
    0.21696180f, -0.12083821f, -0.13519372f, 0.09621479f, 0.03038842f, 0.05089327f, -0.13516675f, -0.08669490f, 
    0.06447190f, 0.00408058f, -0.08708479f, 0.02903778f, 0.22915840f, 0.00956616f, -0.08357217f, 0.00912233f, 
    -0.09683022f, -0.05943789f, -0.12000741f, -0.05092930f, 0.01824377f, -0.05398288f, -0.09059332f, -0.15483539f, 
    -0.36303258f, 0.12084028f, 0.13066836f, -0.14388056f, 0.09012850f, -0.02164076f, 0.01613161f, 0.01845579f, 
    0.01398647f, -0.03348046f, 0.02564992f, -0.00481747f, -0.34025827f, -0.11332027f, -0.07320803f, -0.10024370f, 
    0.12296096f, -0.04950622f, -0.00548137f, 0.14702791f, -0.02660476f, 0.09146501f, -0.07905638f, -0.00334349f, 
    -0.04456013f, -0.14562663f, 0.13803492f, 0.01378659f, -0.20174845f, -0.00472092f, -0.05766639f, -0.29931182f, 
    -0.02583395f, -0.02452393f, 0.14262295f, 0.12532105f, 0.13456196f, -0.10497523f, -0.16841038f, 0.05266965f, 
    -0.16486089f, -0.02275465f, -0.06600446f, -0.00275051f, 0.03304398f, 0.04493732f, -0.03047821f, -0.09378742f, 
    0.10297732f, -0.06231224f, -0.07530896f, -0.00138653f, -0.20472005f, -0.02846009f, 0.00212187f, 0.05031315f, 
    0.02076772f, 0.00922236f, -0.00168875f, 0.02743588f, -0.12948346f, 0.14876279f, -0.06157800f, -0.00492428f, 
    -0.14194536f, 0.01534455f, 0.04368125f, 0.11042521f, 0.09841885f, -0.01333812f, -0.10622360f, 0.08840791f, 
    0.08461118f, 0.08848745f, 0.02583973f, 0.18070935f, -0.02715742f, 0.03038595f, -0.06908759f, 0.03247730f, 
    0.00519302f, -0.03179600f, 0.03193560f, -0.04641352f, 0.07151888f, -0.05583154f, -0.09903747f, -0.06277383f, 
    -0.02819572f, -0.04302611f, -0.05357848f, -0.07073046f, -0.12894973f, -0.04680421f, -0.07880578f, -0.10933013f, 
    0.03588008f, -0.29265577f, -0.03334853f, 0.11308301f, -0.04147430f, 0.07428914f, 0.01308869f, -0.04207299f, 
    -0.02146456f, 0.00209770f, 0.01167071f, -0.07221959f, 0.05203243f, -0.02809390f, 0.03769812f, 0.07439087f, 
    0.08340181f, -0.04886901f, -0.09916829f, 0.02656419f, 0.05900273f, -0.04950272f, -0.02785180f, 0.02371491f, 
    0.28985661f, 0.11658405f, -0.14444755f, -0.14836292f, 0.06457042f, -0.05303907f, -0.03216952f, 0.04360605f, 
    0.09111878f, -0.06157393f, 0.11093810f, 0.02487936f, 0.18763222f, 0.04602086f, -0.06999746f, 0.10623128f, 
    0.12906668f, -0.03698097f, 0.02426209f, 0.03557059f, -0.00278325f, 0.10070413f, -0.01994056f, 0.03182789f, 
    0.23236413f, 0.15601087f, 0.02897815f, -0.00372775f, -0.00934902f, -0.03924966f, -0.03985451f, 0.00736743f, 
    0.05651403f, 0.10421647f, 0.06545285f, 0.06317110f, -0.27328128f, -0.31822592f, -0.05068457f, -0.25087881f, 
    0.05450362f, 0.06243689f, 0.06753547f, 0.15339324f, -0.03020913f, -0.09343662f, 0.08611001f, -0.00714051f, 
    -0.48670298f, -0.05356721f, -0.13001961f, -0.08084850f, 0.10668573f, -0.00220535f, 0.01938166f, -0.02997012f, 
    -0.00270781f, -0.15846795f, -0.03555831f, 0.10194913f, 0.24183889f, 0.00361693f, -0.06418028f, -0.11313021f, 
    0.04152801f, -0.08602695f, -0.06898681f, 0.01258564f, 0.05236391f, -0.04098871f, 0.01715992f, 0.00286566f, 
    -0.15673326f, -0.08064249f, -0.09410464f, -0.07955957f, -0.05323543f, 0.10898052f, -0.06032182f, 0.03253542f, 
    -0.06453656f, 0.00661549f, -0.08203737f, -0.00821412f, 0.03784941f, 0.25534800f, -0.09247421f, -0.01794170f, 
    0.11542955f, 0.07032896f, -0.05449048f, -0.19990021f, 0.04249559f, 0.02761759f, 0.01129886f, 0.05307201f, 
    0.01890437f, -0.21756090f, 0.22172005f, -0.04454171f, -0.12270916f, 0.04858587f, -0.04083936f, 0.08600342f, 
    0.01535236f, -0.11700702f, 0.01347864f, -0.12146255f, 0.17093585f, 0.11839768f, -0.17809054f, -0.13094155f, 
    0.11587628f, -0.04705259f, -0.04554608f, 0.05098439f, 0.00789159f, -0.00098856f, -0.08277895f, 0.03604525f, 
    -0.29105765f, -0.08567540f, -0.00093901f, -0.11250554f, -0.05908578f, -0.02877115f, 0.05233814f, 0.13212855f, 
    -0.10038026f, -0.04675577f, -0.02498593f, 0.04532534f, 0.20826964f, 0.05126273f, -0.09757928f, 0.05919160f, 
    0.04930503f, 0.04500906f, 0.01487396f, -0.03407270f, 0.05658777f, 0.01196763f, 0.05076979f, 0.03215846f, 
    0.01319963f, 0.18167399f, -0.14527446f, -0.04125314f, 0.13964145f, 0.05185182f, -0.01903955f, 0.02291811f, 
    0.01905083f, 0.00777999f, -0.08895162f, 0.00349730f, -0.19706883f, 0.00366278f, 0.07270147f, -0.16473879f, 
    -0.04599046f, -0.00857990f, 0.06244281f, -0.04962369f, -0.03799029f, 0.03900021f, -0.00149102f, -0.00543901f, 
    0.09758491f, -0.04219568f, 0.12908031f, 0.12841845f, -0.02985959f, -0.00904560f, -0.00037651f, -0.00467429f, 
    0.01633208f, 0.06741379f, -0.04098258f, 0.04818977f, -0.11968682f, 0.05712617f, 0.13686666f, -0.11062907f, 
    0.07527061f, -0.08394305f, 0.03110583f, 0.08430043f, -0.02951431f, 0.14985543f, -0.01559072f, 0.02958721f, 
    -0.25688195f, 0.06005653f, 0.03443961f, -0.16244709f, -0.03303482f, 0.07535711f, -0.01592407f, 0.14187038f, 
    0.06754142f, -0.04202520f, 0.10761517f, -0.01252627f, -0.28679520f, 0.15896609f, 0.04864154f, 0.09726150f, 
    0.03186594f, -0.09742309f, 0.02178590f, -0.05429014f, 0.02805476f, 0.03269318f, 0.05627901f, -0.09418450f, 
    -0.01918755f, 0.11465520f, 0.11483814f, 0.01555207f, 0.09543402f, -0.01833404f, -0.01021294f, -0.06123107f, 
    -0.04894603f, -0.07308746f, -0.09256958f, 0.04028025f, 0.09552284f, 0.16525890f, 0.00032510f, -0.10715108f, 
    -0.01970572f, 0.13407566f, 0.05767519f, -0.00168301f, -0.13566633f, -0.07775406f, 0.01536220f, -0.18851857f, 
    -0.14361615f, 0.22162798f, -0.07273515f, 0.03560412f, -0.15107118f, -0.03144262f, -0.07996106f, -0.01140403f, 
    0.05640614f, -0.00802237f, -0.04774589f, -0.11127780f, -0.21462412f, 0.05135554f, -0.10183474f, 0.04570575f, 
    0.07362860f, -0.04420787f, 0.02514921f, -0.06897266f, -0.07544180f, -0.09655183f, -0.02708113f, -0.11731044f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04235714f, 0.04790933f, -0.00926192f, -0.01242737f, 0.01772157f, 0.01037739f, 0.02508245f, -0.01977534f, 
    -0.04860997f, 0.02190470f, 0.04990800f, 0.01779238f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
