#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.79662418f, -0.61832678f, -0.56061918f, 0.34687838f, 0.67838937f, 0.56707627f, 0.03655840f, -0.24973229f, 
    -0.76890403f, -1.25416934f, -0.55300301f, -0.08214942f, -0.53483093f, -0.23312943f, -0.34495035f, 0.53206259f, 
    0.08169261f, -1.06582427f, 1.27186513f, 0.63504165f, 1.12790036f, -0.29767734f, 0.12164659f, 0.14689575f, 
    0.09795382f, 0.46041161f, -0.36975944f, 0.90894753f, 0.97933042f, 1.11606562f, 0.45519269f, -0.10756583f, 
    0.32151148f, 0.46637082f, -0.08769844f, -0.15714763f, 0.05401188f, 0.48710540f, 0.84496295f, -0.07381167f, 
    -0.74121732f, 0.38277107f, -0.72354627f, 0.52165359f, 0.65031713f, 0.62131310f, 1.00325048f, 0.78806645f, 
    -1.21680307f, -0.69475812f, -0.93888599f, 0.23389006f, -0.30715290f, 0.63611132f, 0.63057250f, -0.98189175f, 
    -0.90965569f, 1.02510822f, -0.54090965f, -0.00795612f, -0.46217978f, -0.06980275f, 0.03184878f, -0.10843458f, 
    -0.64153332f, 1.26673436f, -1.00274158f, -0.76230729f, -0.63612890f, 0.37164918f, -0.01831919f, -0.23019217f, 
    -1.14782798f, -0.77019751f, -0.30789313f, 0.77663958f, 1.16226447f, 0.59299129f, -0.05943359f, -0.43991122f, 
    0.08692639f, -1.21312284f, -0.95151734f, -0.97724217f, -0.46658936f, -0.32512015f, 0.36095700f, 0.12261499f, 
    0.36546424f, 0.03802391f, -0.69537562f, 0.87047857f, -0.72168201f, 0.46450335f, 1.02960575f, -0.18680397f, 
    -0.19331196f, -0.54006791f, -0.19614232f, -0.03868940f, -0.86997634f, -0.42377493f, 0.01179064f, -1.23927093f, 
    -0.85710377f, -0.07473405f, -0.59387577f, 0.34704128f, 0.89736980f, 0.71061444f, 0.72884172f, -0.98853582f, 
    0.94721150f, -0.03966067f, 0.22047512f, -0.39434558f, 0.13760303f, 0.30391097f, 0.01804907f, -0.41078743f, 
    0.24726154f, 1.13353884f, 0.43618506f, -0.36382654f, 0.92938304f, -0.08806639f, 0.98302972f, 0.84309691f, 
    -0.80267161f, -1.03883672f, -0.95673424f, -0.85600835f, 0.25483248f, 0.21317393f, -0.01237974f, -0.86090499f, 
    -0.36885545f, -0.77893418f, 0.40521100f, -0.64346719f, -0.66505402f, 0.66388875f, 0.56367093f, 0.22450438f, 
    1.02804136f, 0.25402579f, 0.89359343f, -0.00251209f, -0.36028692f, 1.03032517f, -0.45318273f, -0.45268840f, 
    -0.09833965f, -0.09060132f, -0.62759113f, 1.12648964f, 1.25684786f, -0.63527495f, -0.99591082f, 0.38897365f, 
    0.48135617f, 0.39857271f, -0.35302588f, 0.79972285f, -0.43953460f, 0.91206318f, -0.72525245f, -0.79935664f, 
    -0.40913334f, -0.65726668f, -0.92947179f, -0.60910821f, 0.09932601f, 0.50369954f, 0.32706094f, 0.29415846f, 
    0.34537831f, 0.95550472f, 0.37808424f, 0.72731102f, 1.04114509f, -0.78684890f, 0.08372501f, -0.78966355f, 
    0.81005657f, 0.29498729f, -0.02685092f, -0.22826864f, -0.38804787f, -1.04854035f, -0.89367336f, -0.79352951f, 
    -0.30056605f, -0.66475070f, 0.75322556f, 0.08259889f, -0.20387912f, 0.31626201f, -0.11925779f, -1.19989014f, 
    -0.76471931f, -0.85997492f, 0.08397917f, -0.23005554f, 0.28285813f, 0.70422274f, 0.79991484f, -0.29421151f, 
    -0.76720929f, 0.70845950f, 1.02438962f, 0.55466670f, 0.77193350f, -0.18902960f, -0.13112725f, 0.61556625f, 
    -0.48684368f, -1.14414656f, -0.56640142f, 0.36012232f, -0.02132305f, 0.72725803f, -0.52013606f, -0.08468582f, 
    -0.58989924f, -1.58319068f, 0.89145982f, 0.21562107f, -0.35588789f, 0.79389894f, 0.95136714f, -0.26315245f, 
    0.27199778f, 0.65179271f, 1.21129417f, 1.12515390f, -0.40009975f, 0.27483419f, 0.53777683f, 0.18712886f, 
    -0.10678414f, 0.68996185f, 0.49117219f, -0.86903697f, 0.91323137f, 1.13891149f, 1.02670157f, 1.15903091f, 
    0.16259497f, -0.20482045f, -0.57102895f, 0.00866322f, 1.31183124f, -1.14486480f, 0.20962651f, 0.97719097f, 
    0.37491879f, -0.69939852f, 0.24830879f, -0.17288683f, -0.01769233f, -1.24703288f, 0.93153918f, -0.52639973f, 
    -0.54284245f, 0.14004733f, -0.92283028f, 0.00572060f, -0.30484170f, 0.31229293f, 0.84911925f, 0.14050734f, 
    -0.29715386f, 0.47418705f, -0.83098799f, -0.71285003f, 0.53355354f, 0.62167621f, 0.44196975f, -0.03362087f, 
    -0.80153811f, -0.92705375f, -0.65672821f, 0.92586255f, -0.38166779f, 0.63388753f, -0.43274850f, -0.26467359f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.18784422f, -0.01214004f, 0.09343456f, 0.33202150f, 0.15243138f, 0.17694652f, -0.16844304f, 0.31538284f, 
    -0.09097419f, 0.02324909f, -0.22926323f, 0.20488314f, -0.06249245f, 0.21380967f, 0.16610375f, 0.04139009f, 
    0.39133021f, -0.20419198f, -0.31149065f, -0.20620623f, -0.25600207f, -0.14412382f, 0.20606282f, 0.05032972f, 
    -0.31146985f, -0.12589598f, 0.37055790f, -0.02459873f, -0.08870935f, 0.32566321f, 0.17535190f, 0.23858686f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.00815849f, 0.03570750f, 0.04021373f, -0.01636090f, -0.02456809f, -0.03180218f, -0.00971793f, 0.03755361f, 
    -0.03696708f, 0.00155075f, -0.04870189f, 0.04747566f, -0.03443552f, -0.03904700f, -0.06539658f, -0.02201255f, 
    -0.04251780f, -0.02082873f, -0.02021825f, 0.05614671f, 0.00928981f, 0.01818763f, -0.04012161f, 0.04489242f, 
    -0.00454845f, 0.04049383f, 0.02305855f, -0.05265832f, -0.01067357f, -0.02520243f, -0.03101923f, -0.03044347f, 
    -0.05764059f, 0.02301330f, -0.05927280f, -0.05245116f, -0.02112954f, 0.01111811f, 0.02316565f, -0.00075049f, 
    0.00907997f, -0.01773510f, -0.02232400f, -0.03801370f, 0.00117200f, -0.01513717f, 0.01215204f, 0.03664307f, 
    -0.03264026f, -0.01694842f, 0.05283183f, 0.00335195f, -0.02575744f, -0.00727972f, -0.02729005f, -0.01269026f, 
    -0.02282820f, 0.00732522f, 0.00553651f, -0.03625045f, -0.00636273f, -0.04510931f, 0.04175983f, 0.04167379f, 
    -0.02856420f, -0.04554566f, -0.06250772f, -0.06258023f, -0.02508619f, -0.00665528f, -0.03350288f, 0.02736251f, 
    -0.04222387f, -0.00487084f, -0.00308258f, -0.00141198f, -0.01910054f, 0.04211430f, -0.00117952f, -0.00904052f, 
    -0.03944910f, 0.03156558f, 0.01015628f, 0.02634397f, -0.05537026f, -0.06078603f, -0.06442586f, -0.03496826f, 
    -0.05698619f, 0.03414650f, 0.04142880f, -0.06650726f, -0.04345128f, -0.01016898f, 0.04642916f, 0.02593449f, 
    -0.05385011f, 0.01529520f, 0.01756909f, 0.00831115f, -0.01600024f, 0.02432644f, 0.02289380f, -0.06016599f, 
    -0.05015726f, 0.04230165f, -0.00223453f, -0.03554336f, 0.05467729f, 0.00147276f, -0.03362688f, -0.00263588f, 
    -0.03278704f, 0.02071675f, -0.04553580f, -0.03725474f, 0.01403311f, -0.00500855f, 0.01803905f, 0.01346562f, 
    0.04221544f, -0.01943028f, 0.00356146f, 0.03397712f, 0.04410905f, 0.03680880f, 0.00534996f, 0.02796448f, 
    -0.04254083f, -0.05044812f, -0.05520874f, -0.01854642f, -0.04085358f, -0.00453267f, 0.00930649f, 0.00155166f, 
    0.01608392f, 0.00454179f, -0.04683076f, 0.02725232f, -0.04659265f, -0.04371845f, 0.01168942f, -0.03449351f, 
    0.00394783f, 0.05406571f, -0.04761790f, -0.02442496f, -0.06815362f, 0.04330497f, -0.05515362f, -0.00956864f, 
    -0.04386228f, -0.00389002f, -0.00480384f, 0.03476507f, -0.05658799f, -0.00628122f, -0.06295925f, -0.03397639f, 
    0.00636029f, -0.01695617f, 0.01394425f, 0.04312975f, -0.05970516f, 0.03800991f, -0.06686285f, -0.02956675f, 
    0.03556429f, 0.04783202f, -0.05581100f, 0.02081964f, 0.03652418f, 0.00728462f, -0.03849588f, 0.00996316f, 
    0.04349419f, -0.01149981f, 0.00510734f, 0.01874756f, -0.03863772f, 0.02755456f, 0.00474273f, -0.03298083f, 
    -0.00473046f, 0.00756991f, -0.00469206f, -0.04399731f, -0.00026729f, -0.00550437f, 0.02859084f, -0.00505522f, 
    0.03724838f, -0.05654030f, 0.03371618f, -0.03091186f, 0.02000653f, 0.01759271f, -0.00609477f, 0.04805494f, 
    -0.05511719f, -0.00920010f, -0.01470247f, -0.04302437f, 0.02396222f, 0.00759122f, 0.02744392f, -0.01714904f, 
    -0.04781256f, 0.02244431f, 0.02239536f, 0.00104289f, -0.03987499f, -0.05877845f, -0.02189004f, -0.05745854f, 
    0.04564199f, -0.00720448f, -0.01367787f, 0.01510535f, 0.01433218f, 0.02438283f, 0.02695771f, 0.00973589f, 
    0.04803836f, -0.02268848f, -0.00997938f, 0.00453838f, -0.00497417f, 0.01378939f, 0.01533572f, 0.01767041f, 
    -0.01054227f, -0.05169023f, -0.00703730f, -0.03200445f, -0.00264204f, -0.03609445f, -0.00324560f, 0.01654411f, 
    0.02201607f, -0.00343733f, 0.03543395f, 0.00311010f, -0.01070558f, -0.04462997f, -0.05968305f, -0.01172326f, 
    0.01361569f, -0.04956108f, 0.00350269f, 0.04585528f, 0.01563871f, -0.04263951f, 0.04054907f, 0.04527630f, 
    0.02396286f, 0.00917498f, -0.00692562f, 0.02811651f, -0.05699578f, 0.02422428f, 0.02786981f, -0.01427571f, 
    0.02784281f, -0.03728796f, 0.00102433f, -0.05346529f, 0.03046120f, 0.00342782f, -0.01064689f, 0.05171328f, 
    0.01307581f, -0.05459585f, -0.03799223f, -0.00985950f, 0.04232411f, 0.04541191f, 0.03802425f, -0.01450018f, 
    0.00925305f, -0.04400701f, -0.06096791f, -0.05578959f, 0.00726835f, -0.05465619f, -0.03418454f, 0.04900972f, 
    0.12089016f, -0.07960330f, 0.12785032f, 0.12194845f, -0.05819871f, 0.00945197f, -0.02090068f, 0.02647742f, 
    -0.05389135f, -0.08427594f, -0.35903290f, -0.05894811f, 0.08365545f, 0.07576299f, -0.07950226f, -0.10415507f, 
    0.24022876f, 0.16279358f, -0.06789759f, 0.11676721f, 0.01404461f, 0.12274960f, -0.00773805f, 0.10785186f, 
    0.05812556f, 0.01137660f, -0.19933589f, 0.07120442f, -0.00517780f, 0.15268557f, -0.10854328f, 0.06495067f, 
    0.00122997f, 0.06552096f, 0.05734900f, -0.04258236f, 0.06446619f, 0.14036258f, -0.19601268f, -0.06360077f, 
    0.20389602f, 0.08388423f, -0.00571491f, -0.13598998f, 0.01467558f, 0.00021571f, 0.14507371f, -0.15377373f, 
    0.18310064f, 0.05908892f, -0.09056177f, -0.03864557f, -0.15189135f, -0.07825854f, 0.05948022f, -0.08855689f, 
    0.11220302f, 0.02770312f, -0.01848906f, 0.05108826f, -0.12687072f, -0.12780541f, 0.00362961f, -0.23259851f, 
    -0.06543031f, -0.26524508f, 0.22582799f, -0.02826464f, -0.17295465f, 0.10041339f, -0.06613324f, 0.09447177f, 
    0.22694694f, -0.04768943f, 0.26665094f, 0.03974869f, -0.18594708f, 0.17312695f, 0.06316468f, -0.06842925f, 
    -0.07244676f, 0.04450445f, 0.03970899f, 0.24143468f, -0.37338376f, 0.00291116f, -0.11006083f, -0.01107441f, 
    0.05973325f, 0.23550951f, -0.05147790f, -0.00060284f, -0.06437718f, 0.17360359f, -0.08093496f, 0.19997425f, 
    0.18839388f, -0.08857758f, 0.24887750f, 0.07888129f, 0.06744264f, -0.08943349f, 0.00091940f, 0.03653705f, 
    -0.02295022f, -0.06387033f, 0.05822284f, -0.03269776f, 0.17020591f, 0.07128721f, -0.16663219f, 0.06905148f, 
    -0.20840843f, 0.20633639f, -0.04130763f, 0.16510153f, -0.19995724f, 0.18955015f, 0.14525792f, 0.28216684f, 
    -0.01560741f, 0.01750326f, -0.14957440f, 0.05098370f, 0.12384944f, 0.00947553f, 0.00270737f, 0.04395047f, 
    -0.22462334f, -0.00369006f, -0.07899800f, -0.10634923f, 0.05236851f, 0.05467624f, -0.11229474f, -0.05516951f, 
    -0.12900908f, 0.16019325f, 0.15784164f, -0.06647032f, 0.05276627f, -0.07821436f, -0.06533510f, 0.01285272f, 
    -0.15851864f, 0.02106353f, -0.13579054f, 0.15158102f, -0.11319633f, 0.01252844f, 0.08294106f, 0.14220583f, 
    -0.08209358f, 0.38347593f, -0.25173217f, -0.18691716f, -0.20985775f, -0.01413676f, -0.17435989f, -0.08957140f, 
    -0.14776391f, -0.04882780f, -0.19855151f, -0.35429183f, -0.40616390f, -0.10608668f, 0.07001634f, -0.13721161f, 
    0.08967319f, -0.18889265f, -0.25038633f, 0.19409111f, 0.04851216f, 0.15691188f, -0.09869532f, -0.04374289f, 
    -0.02752592f, -0.37848505f, -0.12642638f, -0.07014550f, 0.19376925f, -0.00662923f, -0.32254958f, 0.25174075f, 
    0.03676442f, 0.08528806f, -0.10849250f, -0.19912943f, 0.03295451f, 0.11974019f, 0.15548268f, 0.23293269f, 
    -0.25322613f, 0.02919268f, -0.20816107f, -0.04928676f, -0.05718172f, 0.31886309f, 0.40382749f, -0.05933969f, 
    -0.05359547f, -0.00585593f, 0.16786996f, 0.00977632f, 0.00236247f, 0.00198569f, -0.00841912f, 0.10279968f, 
    0.04621883f, 0.18826233f, -0.12562484f, 0.14643872f, -0.21510293f, 0.06894756f, 0.00499128f, 0.00067517f, 
    -0.13324116f, -0.09184103f, 0.44883618f, 0.22978516f, -0.12210608f, -0.03179108f, -0.01536812f, 0.04186382f, 
    0.13639157f, 0.39187318f, 0.05425828f, 0.00853511f, -0.38512579f, -0.02033336f, 0.27463654f, -0.05969870f, 
    0.14399391f, -0.12107370f, 0.27605870f, 0.05951366f, 0.11946692f, -0.09315270f, -0.18874748f, 0.16052845f, 
    -0.31479213f, 0.06027223f, -0.04569644f, 0.21722622f, 0.02365887f, -0.10147332f, -0.06444110f, 0.05860456f, 
    0.12914680f, -0.05492753f, 0.03460236f, -0.05256494f, 0.19405961f, -0.11827056f, -0.20613205f, 0.06312078f, 
    0.00110621f, -0.08520734f, 0.09801503f, -0.04309405f, -0.02445751f, 0.04164396f, 0.24199912f, -0.41961506f, 
    0.23731667f, 0.01753236f, -0.14958006f, 0.20124207f, 0.03780323f, -0.00375726f, 0.18893237f, 0.09524596f, 
    0.02373504f, 0.06692659f, -0.03591149f, -0.01234739f, -0.15331280f, -0.10912802f, 0.01611476f, 0.42160746f, 
    -0.25453267f, 0.01661550f, -0.03917539f, 0.15710238f, -0.01042051f, 0.05631635f, -0.18198054f, 0.26863375f, 
    -0.02251910f, -0.33805314f, -0.32001305f, -0.03363308f, 0.17329356f, 0.07456288f, -0.00484305f, 0.00696193f, 
    -0.08405885f, -0.08165940f, -0.04005116f, -0.07509970f, 0.04377413f, 0.02405602f, -0.12608802f, -0.12126150f, 
    0.27288511f, -0.13870342f, 0.38878521f, 0.33304572f, 0.28137514f, 0.18560612f, 0.11783482f, 0.07188597f, 
    0.13523176f, 0.05734968f, 0.08465542f, 0.43028140f, 0.31456754f, 0.25190109f, 0.35562688f, 0.19986130f, 
    0.22352915f, 0.09106250f, 0.15354620f, 0.05656659f, 0.19814688f, 0.11309393f, -0.14568476f, -0.08233979f, 
    0.01355561f, 0.20467818f, 0.10835541f, 0.19856927f, 0.14596100f, 0.57936686f, 0.26351002f, -0.08445051f, 
    -0.03228956f, -0.00292552f, 0.03007441f, 0.20697765f, -0.16138931f, 0.15477364f, -0.53198451f, -0.11606795f, 
    -0.52502328f, -0.06371673f, 0.05907924f, 0.06948504f, -0.06719847f, 0.03877537f, 0.08534615f, 0.05633315f, 
    0.24808432f, -0.04153511f, -0.17163900f, -0.06765912f, 0.30363023f, -0.21783409f, -0.02736781f, 0.10509681f, 
    -0.42453083f, -0.59102631f, -0.11613005f, 0.14277020f, 0.22893767f, 0.10470928f, -0.09263696f, -0.18969171f, 
    -0.14096032f, -0.16860214f, 0.24342786f, -0.33598360f, 0.22676197f, 0.19586478f, -0.04950970f, -0.17395450f, 
    0.18769632f, -0.10881026f, -0.55043560f, -0.40081441f, 0.52028638f, -0.01065846f, 0.06251658f, 0.23706850f, 
    -0.10463739f, 0.17885654f, -0.07308207f, 0.09610815f, -0.05161592f, -0.54728478f, -0.15801473f, 0.02979774f, 
    -0.07407949f, 0.13013808f, 0.04011783f, 0.06974109f, 0.38024542f, 0.36939916f, 0.29082704f, 0.13110463f, 
    0.14094165f, 0.20241041f, 0.05881969f, -0.04165424f, 0.15676692f, -0.34858477f, -0.01516362f, 0.43861461f, 
    0.03053709f, 0.00120627f, 0.07162216f, 0.02510830f, 0.02193855f, -0.14523339f, 0.26651362f, -0.13642114f, 
    -0.17506132f, -0.12404971f, -0.11625779f, -0.07240759f, 0.13247643f, -0.05911103f, 0.00538071f, 0.06493358f, 
    0.10908405f, -0.01006453f, -0.00571255f, -0.07314754f, -0.19814613f, 0.08329622f, 0.09350098f, -0.12424926f, 
    0.06148453f, 0.41046941f, 0.17995016f, 0.23062806f, 0.25221291f, 0.27702191f, -0.02740790f, -0.12156473f, 
    0.09383847f, -0.01017434f, -0.27866679f, -0.21528780f, 0.04346645f, -0.10999411f, 0.22105154f, 0.13723189f, 
    -0.00851629f, 0.13595201f, -0.19694626f, 0.00002888f, -0.08548216f, -0.07540456f, 0.07981287f, -0.20027201f, 
    -0.04663657f, 0.13270430f, -0.02654836f, -0.28604698f, -0.12668706f, -0.09588598f, -0.06498963f, -0.05074929f, 
    -0.00197239f, 0.04341240f, -0.07430755f, -0.04064879f, 0.27391961f, -0.26579881f, -0.07407146f, -0.14756645f, 
    0.11352050f, 0.15467927f, -0.05371034f, -0.00440997f, 0.01912508f, -0.39537355f, 0.04742683f, -0.19524537f, 
    0.13262358f, 0.15137488f, -0.01713665f, -0.04530028f, -0.04403740f, -0.02101619f, -0.09027962f, 0.22760510f, 
    -0.41753390f, 0.01125384f, 0.05514234f, 0.11300504f, 0.03261327f, -0.12824503f, -0.03556096f, -0.19661771f, 
    -0.38278294f, 0.32894748f, 0.11537225f, 0.21231875f, 0.19093524f, 0.05717948f, -0.27500430f, -0.06249110f, 
    0.01102623f, -0.05951586f, -0.46134740f, -0.02623989f, 0.04077296f, -0.01660987f, -0.16656287f, -0.09312218f, 
    -0.16790026f, -0.31524622f, -0.37455845f, -0.00014581f, -0.15412098f, 0.13668172f, -0.03970182f, 0.10607566f, 
    -0.19040000f, 0.05434757f, 0.11334816f, 0.47787902f, 0.30885890f, 0.07463703f, 0.08339203f, -0.18039052f, 
    -0.13393694f, 0.07308737f, 0.21376558f, -0.10593628f, -0.17825820f, -0.08284499f, 0.07558490f, 0.08523417f, 
    0.10254872f, -0.01403888f, -0.08962915f, -0.23952776f, -0.08984242f, -0.28017348f, -0.23428591f, 0.03673843f, 
    0.13174230f, 0.25778449f, 0.03987654f, 0.08594031f, 0.11708225f, 0.00859037f, -0.06848978f, 0.18122758f, 
    -0.19281541f, -0.11146355f, -0.18583529f, 0.11564609f, -0.05908510f, 0.10975755f, 0.18216775f, 0.12226896f, 
    -0.15068585f, 0.07089499f, 0.15388526f, -0.03612691f, 0.06579899f, 0.01256005f, -0.07107216f, 0.08809503f, 
    -0.26370868f, -0.10531980f, 0.20104939f, -0.00132660f, -0.02929724f, 0.22591677f, 0.18391034f, -0.07976540f, 
    -0.21787183f, -0.03154035f, 0.23600236f, -0.07235207f, -0.03731732f, 0.17957981f, -0.11684580f, 0.19934496f, 
    0.02450302f, -0.23066592f, -0.09762125f, 0.25066435f, 0.00144714f, 0.04488064f, 0.00768859f, -0.00124667f, 
    -0.05331917f, 0.12083644f, 0.14112127f, -0.18240200f, -0.34542367f, 0.16621010f, 0.03685226f, 0.08780035f, 
    -0.02337142f, -0.13800563f, -0.34092170f, -0.09415325f, -0.20844330f, -0.04832054f, -0.03648770f, 0.00293366f, 
    -0.01860743f, 0.03524148f, -0.20978335f, -0.17576508f, -0.10310008f, -0.08428318f, -0.08337491f, 0.20176853f, 
    0.12096345f, -0.03269146f, -0.00539496f, -0.21093749f, -0.28749844f, -0.00156058f, 0.20367247f, -0.12093586f, 
    0.09222218f, 0.12891409f, -0.27817893f, -0.00599800f, 0.04460625f, 0.04746408f, -0.12580255f, 0.16509460f, 
    0.45063359f, -0.10689903f, 0.09143163f, 0.07024926f, -0.01890924f, 0.18557838f, -0.02771177f, 0.01848725f, 
    0.11390291f, 0.04179352f, 0.14859396f, 0.08552945f, -0.27340892f, -0.04223982f, 0.13002980f, -0.01465187f, 
    -0.19747989f, -0.13334818f, 0.23592559f, 0.00178411f, -0.08382711f, 0.22979450f, -0.15650444f, 0.15525609f, 
    -0.03914110f, -0.05751677f, -0.01162757f, 0.20382194f, 0.00819007f, -0.03771151f, 0.03847033f, -0.04875066f, 
    -0.16450438f, 0.03068325f, 0.17059238f, -0.01294098f, 0.18199642f, -0.02470468f, 0.04553027f, 0.07939417f, 
    -0.00178623f, 0.08777046f, 0.02790470f, 0.12895873f, 0.15773317f, 0.27611762f, 0.06463600f, 0.09127842f, 
    0.03505475f, -0.00348432f, 0.03804339f, -0.15720885f, -0.06788462f, 0.01500728f, 0.00206216f, 0.08696696f, 
    0.09354965f, 0.01723669f, 0.03024424f, 0.01447044f, 0.01206991f, -0.07808059f, 0.12834847f, 0.08993742f, 
    -0.00164276f, 0.14439034f, -0.12498558f, -0.06762111f, 0.09326351f, -0.10526416f, 0.01635527f, 0.28332734f, 
    -0.12642884f, 0.07546470f, -0.09187317f, -0.15417521f, 0.18038414f, 0.10103297f, 0.08655103f, 0.09977942f, 
    0.00247832f, 0.08402964f, 0.11485432f, 0.04819049f, -0.05907661f, 0.14699945f, -0.11477969f, -0.06464396f, 
    0.01549655f, 0.07795680f, -0.33054504f, -0.09562676f, 0.18937676f, -0.01307338f, 0.09908833f, 0.06741908f, 
    -0.35545635f, -0.02707748f, 0.00031370f, -0.00623587f, -0.01030106f, 0.01137733f, -0.07792693f, -0.05154561f, 
    0.15404028f, -0.26941052f, 0.25752449f, 0.17143281f, -0.13060930f, 0.00197201f, -0.06992490f, 0.22331072f, 
    0.09630247f, 0.12543219f, 0.11040885f, 0.12187514f, 0.20422816f, 0.04867290f, 0.18545365f, -0.07761472f, 
    -0.08712161f, -0.16420045f, -0.15805626f, 0.03607333f, -0.19749378f, 0.30342549f, 0.17329744f, -0.24911180f, 
    0.12822784f, 0.21700503f, -0.07486366f, 0.15870112f, 0.12941600f, -0.11130697f, -0.06024770f, 0.10127568f, 
    0.08288554f, 0.13996372f, -0.09826496f, -0.09078828f, -0.07524414f, 0.03434819f, 0.00643210f, 0.08101672f, 
    -0.00719513f, 0.20850642f, 0.01844325f, -0.12611617f, -0.00167839f, 0.04751953f, -0.01239379f, 0.07137754f, 
    -0.17949820f, -0.10988430f, -0.01622562f, -0.01238295f, 0.17284137f, 0.07474689f, 0.05268706f, -0.29160807f, 
    -0.13278390f, -0.17105179f, 0.31755713f, -0.10713316f, -0.11068255f, 0.26144058f, 0.00879635f, 0.08423475f, 
    0.10656771f, 0.01553547f, 0.26123610f, 0.14296509f, -0.08991320f, 0.00159694f, 0.05830825f, 0.11358333f, 
    0.04345568f, -0.22090201f, 0.06779706f, -0.21930940f, -0.04037709f, 0.01363772f, 0.06491785f, -0.04482021f, 
    0.07423110f, -0.10883620f, -0.05301083f, 0.02570313f, -0.07861219f, 0.00392891f, 0.02063994f, -0.04683411f, 
    0.36923510f, 0.04612268f, -0.11905263f, -0.24643129f, 0.10348579f, 0.24116290f, -0.00271292f, -0.40770307f, 
    -0.04868201f, 0.10809502f, -0.06926247f, 0.23866278f, -0.39175612f, 0.00936940f, 0.04505878f, 0.04431291f, 
    -0.11106142f, 0.05546903f, -0.10377254f, 0.01179842f, -0.11638589f, 0.19295540f, 0.10164068f, 0.08422580f, 
    -0.11235114f, -0.03407646f, -0.08963758f, -0.10272717f, 0.02779097f, 0.03631161f, 0.03524812f, -0.02008330f, 
    0.15670936f, 0.04513180f, -0.29158610f, 0.05397470f, 0.05629267f, -0.19259034f, -0.02383335f, 0.12578818f, 
    -0.01363543f, -0.06535714f, 0.26345798f, 0.00124420f, 0.09964644f, -0.17035981f, 0.07168306f, 0.04842726f, 
    0.14178522f, -0.09459133f, 0.12678877f, -0.04331402f, 0.12534823f, 0.03293889f, 0.16959126f, 0.04886730f, 
    -0.00100501f, -0.20500709f, 0.32418394f, 0.07582542f, -0.12152530f, 0.01624296f, -0.12076522f, 0.05498125f, 
    0.23919398f, -0.06681223f, 0.15424226f, 0.49693584f, -0.04150135f, -0.21602233f, 0.07065632f, -0.03199529f, 
    -0.07648057f, 0.14411600f, -0.03542281f, 0.10523971f, -0.03574471f, -0.13150243f, -0.23204760f, -0.12128543f, 
    0.04197795f, 0.11606930f, 0.09547482f, -0.02482349f, -0.02520364f, 0.21242435f, -0.04605145f, -0.20370805f, 
    0.04292586f, 0.05169084f, 0.17693461f, 0.05914693f, -0.06957228f, -0.09380243f, 0.37968123f, 0.01096200f, 
    0.06151652f, -0.02996721f, -0.00814076f, 0.09833252f, 0.11218236f, -0.00306944f, 0.24388675f, -0.19789642f, 
    -0.14935908f, -0.20657980f, 0.23960108f, 0.11412162f, 0.08767419f, 0.03241673f, -0.02062984f, -0.08372103f, 
    -0.29901224f, -0.21357848f, 0.30525562f, -0.00659994f, 0.22709832f, -0.05750274f, -0.03080316f, 0.14311644f, 
    0.19448365f, 0.19498061f, 0.22838211f, 0.15945983f, 0.09671646f, 0.11494548f, 0.02074675f, 0.00465507f, 
    0.06419381f, -0.08054953f, -0.38123414f, -0.29065582f, -0.05512067f, 0.15897535f, 0.16299184f, -0.04997048f, 
    -0.31599209f, -0.06002578f, 0.30068445f, 0.20819505f, -0.05142643f, 0.04601799f, -0.18088433f, -0.14191690f, 
    -0.12558711f, 0.04063645f, 0.11591607f, -0.13948652f, -0.02191366f, -0.03293077f, -0.28485423f, 0.11796813f, 
    -0.05237526f, 0.12340930f, -0.09044202f, -0.12802888f, 0.22859116f, -0.15369131f, -0.09892698f, 0.20168278f, 
    0.04491174f, -0.23317070f, 0.07638346f, -0.03251378f, -0.03601093f, -0.12694730f, 0.22645774f, 0.24671286f, 
    0.05544442f, 0.03864055f, -0.23454262f, -0.02070735f, 0.00932629f, -0.09070549f, -0.16025579f, -0.28974932f, 
    0.04359300f, 0.23614848f, 0.10152745f, -0.13791186f, 0.01729686f, 0.13019073f, 0.09237511f, -0.11861439f, 
    -0.22335093f, -0.02485483f, -0.13998134f, 0.14821662f, -0.11272021f, -0.01594439f, 0.19464399f, -0.05229462f, 
    0.05631831f, 0.17201853f, -0.20528731f, -0.27130610f, -0.13732450f, 0.11186089f, 0.03355843f, -0.03889056f, 
    -0.11895511f, -0.25295681f, -0.07792577f, -0.16362651f, 0.01139308f, 0.05055454f, -0.20604597f, 0.14358665f, 
    0.07132465f, -0.13837402f, 0.06178371f, -0.02323391f, 0.17075579f, 0.09235109f, 0.13344139f, 0.04070584f, 
    0.20156157f, -0.31728491f, 0.00549970f, -0.15572390f, -0.23356600f, -0.08818465f, -0.02834265f, 0.04678935f, 
    0.15328462f, 0.11999824f, 0.07907877f, 0.23319915f, 0.06870034f, 0.24799106f, 0.23050341f, 0.16293524f, 
    0.03444329f, 0.02043062f, -0.01102206f, 0.19378819f, 0.40735313f, -0.24608688f, -0.13604225f, -0.07172059f, 
    0.14856957f, -0.06207504f, -0.15123163f, 0.18271956f, -0.09735844f, -0.07746666f, -0.08780660f, -0.25128859f, 
    -0.32380819f, -0.17266546f, 0.26266858f, 0.06840151f, -0.18912780f, -0.01721026f, -0.00615850f, 0.10399195f, 
    0.30730289f, 0.24866571f, 0.15593831f, 0.03124889f, -0.17112467f, -0.26071888f, -0.02289475f, 0.08795889f, 
    0.07652255f, -0.29287979f, 0.11157991f, 0.21854444f, 0.23346253f, 0.01867630f, 0.02785674f, -0.23820530f, 
    -0.05911829f, 0.09125510f, 0.06465796f, 0.23345716f, 0.19037025f, 0.05545247f, 0.12762038f, -0.19580570f, 
    0.09471977f, -0.17234606f, 0.02515005f, -0.30048746f, 0.02414337f, -0.35781488f, -0.00306600f, 0.09620111f, 
    -0.14216393f, -0.08260949f, 0.20278575f, 0.28437412f, 0.24967863f, -0.32318610f, -0.14374439f, 0.11541019f, 
    0.17723314f, -0.00616363f, 0.14520419f, 0.03735970f, -0.14950196f, -0.65787643f, 0.05486368f, 0.09279721f, 
    0.07404074f, 0.11458465f, -0.06784380f, -0.13135001f, -0.03296912f, -0.04853478f, 0.07838857f, -0.07435241f, 
    0.05242088f, 0.09194952f, -0.07895057f, -0.15292998f, -0.10029779f, -0.05693749f, 0.00964293f, 0.20608264f, 
    0.05722170f, 0.10508858f, 0.06399205f, -0.01243753f, -0.08702580f, -0.12338317f, 0.03856362f, -0.11423759f, 
    -0.06908929f, 0.00311083f, 0.02839247f, -0.02975056f, -0.04227550f, -0.07696974f, -0.00736257f, -0.03780570f, 
    -0.00381473f, -0.03233206f, -0.04295561f, -0.05339611f, 0.01302860f, 0.05051890f, -0.03937411f, -0.00430711f, 
    -0.04378542f, 0.00431354f, -0.05187453f, -0.05296848f, -0.02150646f, -0.00608813f, -0.03409161f, 0.00914645f, 
    -0.01174327f, 0.02621693f, -0.05244371f, -0.05546786f, -0.04140079f, -0.01081557f, 0.03944416f, -0.00454103f, 
    -0.05002978f, -0.03399020f, -0.05645723f, 0.02294033f, -0.01575154f, -0.00884250f, 0.02756837f, -0.04061080f, 
    -0.06293652f, -0.05989054f, -0.03268012f, -0.06808421f, 0.00392953f, -0.01378865f, 0.01613014f, -0.03697021f, 
    -0.05049587f, 0.00754736f, 0.03172625f, -0.02735854f, -0.02927247f, 0.02998424f, 0.03168882f, -0.01440285f, 
    0.03497623f, 0.02527904f, 0.00066823f, -0.08239748f, 0.02735452f, -0.05931556f, 0.02146523f, 0.05782943f, 
    0.01573214f, -0.03335768f, -0.03425364f, -0.00264111f, -0.05962422f, -0.05346833f, -0.06228159f, -0.02335631f, 
    0.01095346f, -0.00512111f, -0.01588902f, -0.04005570f, -0.04985633f, -0.00675360f, -0.06018310f, -0.01175932f, 
    -0.02753342f, -0.06145360f, -0.07490113f, 0.02387496f, -0.06669015f, -0.06843859f, -0.01313679f, -0.02340909f, 
    -0.06702754f, 0.04054226f, 0.04059283f, 0.04252731f, -0.07962257f, 0.02639463f, -0.06041224f, 0.03733752f, 
    -0.01997561f, -0.07229488f, -0.07732411f, -0.03769912f, -0.09098727f, 0.00814003f, -0.03255481f, -0.08512607f, 
    -0.04978196f, -0.05506927f, 0.02087847f, 0.04938805f, -0.02029911f, -0.03280696f, -0.05091792f, -0.00312727f, 
    -0.03240739f, 0.05169877f, -0.02034320f, -0.05011888f, -0.06270775f, -0.02068888f, -0.06332669f, -0.06127599f, 
    -0.05340200f, -0.07618260f, 0.01860779f, -0.05368590f, -0.01728345f, -0.02555024f, -0.06137287f, 0.06483869f, 
    -0.02909890f, -0.03554332f, 0.01084321f, -0.06824341f, -0.00448197f, 0.00804163f, -0.03661314f, 0.00881829f, 
    0.01130263f, -0.00963684f, -0.04295119f, -0.06056468f, -0.02377618f, 0.04319438f, -0.01270530f, -0.02832959f, 
    -0.01481815f, -0.05605255f, 0.01120277f, -0.06977022f, 0.05134069f, -0.04647902f, 0.02945825f, 0.02701846f, 
    -0.02247733f, 0.01485564f, 0.01768615f, 0.04240362f, -0.02660684f, -0.08566951f, -0.06877211f, 0.03952431f, 
    0.01467453f, -0.03747344f, -0.06301817f, -0.03926976f, 0.03163606f, 0.00754270f, -0.04493092f, 0.02113329f, 
    0.02920363f, -0.03829122f, -0.01200865f, 0.02899513f, 0.02085821f, -0.05294978f, -0.03481016f, 0.00614056f, 
    -0.05385777f, -0.07215934f, 0.00664881f, -0.03681177f, -0.07859752f, 0.00986953f, -0.09058246f, -0.01966641f, 
    -0.04929941f, -0.00178462f, -0.01914395f, 0.01226176f, -0.00692698f, -0.01695926f, 0.01891203f, -0.02948496f, 
    -0.03055869f, -0.05495791f, -0.09159656f, -0.02394209f, -0.00196793f, 0.05122863f, 0.00143414f, -0.00847314f, 
    0.00480318f, 0.01240136f, 0.01887701f, -0.03609405f, -0.07033265f, -0.05799754f, -0.03771127f, 0.02758109f, 
    -0.00356348f, -0.05026785f, -0.05722689f, 0.02225251f, 0.03608033f, -0.06081440f, -0.00458996f, -0.00582743f, 
    0.00114032f, 0.07437451f, -0.05245314f, -0.06959070f, 0.00296898f, -0.05774080f, 0.01819456f, -0.00079725f, 
    0.01391326f, -0.01639412f, -0.02107357f, -0.07425034f, -0.07350635f, 0.01686684f, -0.02530513f, -0.03882734f, 
    0.02690330f, -0.08476445f, -0.06418925f, -0.00127415f, -0.05038780f, -0.02361184f, 0.03715819f, -0.06057414f, 
    -0.02393038f, 0.00195698f, 0.00870786f, -0.07926758f, 0.02373296f, -0.01260732f, -0.04354675f, -0.03430402f, 
    0.03015487f, 0.01432626f, -0.07757884f, -0.03902053f, 0.00426252f, -0.02329868f, -0.00205005f, -0.05682510f, 
    -0.02705649f, -0.00257246f, 0.01539661f, -0.05932533f, -0.03120319f, -0.03303084f, -0.04647198f, -0.02539583f, 
    0.03062678f, -0.06278326f, 0.01052784f, 0.04649040f, -0.06833109f, 0.01310060f, 0.04007701f, 0.04778241f, 
    -0.01564181f, -0.04564327f, -0.01848305f, -0.05807356f, -0.06035830f, -0.06826714f, 0.03814948f, 0.05188739f, 
    0.02191605f, 0.02723395f, -0.03097912f, -0.03103661f, -0.04770500f, -0.05619851f, -0.05166059f, -0.00560557f, 
    0.04147809f, 0.10169826f, 0.07678867f, 0.07504745f, 0.11267024f, -0.00964603f, 0.06774303f, 0.16836675f, 
    0.23228973f, 0.10181580f, -0.00510951f, -0.01800756f, -0.22993618f, -0.04475347f, 0.07341451f, 0.12497216f, 
    0.09215308f, 0.05899908f, -0.28002867f, -0.22175770f, -0.26774099f, -0.03466321f, 0.27407327f, 0.22463304f, 
    0.08628247f, -0.05901527f, -0.10933970f, -0.47644567f, -0.26556751f, -0.35262775f, 0.08573534f, 0.07605763f, 
    0.19460115f, 0.19299810f, -0.00883505f, -0.06738126f, -0.29373565f, -0.22397815f, 0.14864865f, 0.11972033f, 
    0.03172327f, 0.09874377f, 0.01452458f, 0.10433193f, 0.17013550f, 0.06209087f, -0.17316133f, 0.08752537f, 
    -0.05057088f, -0.16582286f, 0.04499824f, -0.00182860f, 0.20447728f, 0.05451672f, 0.15038107f, -0.23674105f, 
    -0.00681688f, -0.00312392f, -0.17434311f, -0.15320814f, -0.16042309f, 0.28395674f, -0.09844069f, 0.31672382f, 
    -0.13663271f, 0.20023882f, 0.01748498f, -0.10316062f, -0.15435268f, -0.21668215f, 0.07770805f, 0.23406407f, 
    -0.09994902f, 0.25268698f, 0.04189431f, 0.24758208f, 0.13049318f, 0.01129287f, 0.08232286f, 0.19256657f, 
    0.13868086f, 0.15085742f, -0.20476320f, -0.12156908f, 0.00924325f, -0.14112911f, -0.04944720f, 0.16936290f, 
    0.15716249f, -0.04481824f, -0.51786619f, 0.39085555f, -0.02170433f, 0.18021822f, -0.08458935f, 0.07888745f, 
    -0.08546884f, 0.26728889f, 0.10522249f, 0.39532176f, -0.30046901f, 0.05816497f, -0.16162796f, -0.04897672f, 
    0.05131401f, 0.00879540f, 0.10239254f, -0.07330232f, -0.12049754f, 0.00955896f, -0.20930135f, -0.03232844f, 
    -0.03137716f, 0.21127699f, 0.27909935f, -0.06903850f, -0.18911324f, -0.12642935f, 0.04938148f, 0.22103041f, 
    0.31966332f, 0.16749738f, -0.22975124f, 0.15305196f, 0.08946126f, -0.16102143f, 0.22566171f, -0.13335031f, 
    0.01220094f, -0.25772235f, -0.12377932f, -0.04967298f, 0.14610711f, 0.18312919f, 0.08260369f, 0.10491745f, 
    -0.13160740f, 0.23901719f, -0.11090564f, -0.04660890f, 0.09109174f, 0.27996758f, 0.03385327f, -0.09590325f, 
    -0.00603508f, -0.05489274f, -0.36846304f, -0.15383489f, 0.23189513f, 0.29646915f, 0.12889069f, -0.20698063f, 
    0.00430600f, -0.36369646f, -0.30990291f, 0.24246535f, 0.06391806f, -0.11519955f, 0.11139410f, -0.00782219f, 
    0.24635141f, 0.02556932f, 0.10828419f, 0.04188596f, 0.40478957f, 0.03511546f, -0.10858268f, 0.19627045f, 
    -0.10572442f, 0.15605131f, -0.09567901f, 0.00883880f, 0.21620528f, 0.11473557f, 0.37504616f, -0.02802130f, 
    0.29842225f, 0.20569332f, -0.22197707f, 0.01276465f, -0.08254524f, 0.00111463f, 0.22405794f, -0.01885685f, 
    0.20308684f, -0.16345868f, 0.30211893f, -0.13968784f, -0.09588171f, 0.16944653f, -0.15298368f, -0.02777832f, 
    -0.06338832f, 0.01558483f, -0.16440594f, 0.10715888f, 0.19547747f, -0.08959278f, 0.07860892f, -0.16059074f, 
    0.08312930f, -0.04956825f, 0.04752725f, 0.13338321f, 0.20003328f, 0.02640227f, 0.13857509f, -0.26606899f, 
    -0.11816341f, -0.01889699f, 0.22165875f, 0.10613439f, 0.15294395f, 0.11870240f, -0.11017129f, -0.14256464f, 
    0.24618325f, 0.02990971f, 0.15184997f, 0.01406030f, 0.03909674f, 0.12059803f, -0.19041692f, 0.08846875f, 
    0.01698185f, -0.04909712f, 0.04116587f, -0.16740708f, 0.10796765f, -0.02416763f, 0.02397554f, 0.29399264f, 
    -0.01302379f, 0.06637675f, -0.33089957f, 0.06050731f, 0.17502497f, 0.17070168f, 0.19378245f, 0.11444278f, 
    -0.02806948f, -0.07280527f, 0.03762494f, -0.11191965f, -0.05290576f, -0.10370350f, 0.32105225f, 0.08250835f, 
    0.28595504f, 0.02524191f, 0.03349420f, -0.32661062f, -0.41710979f, -0.29906705f, -0.15608548f, 0.07614253f, 
    -0.10325418f, -0.09345990f, 0.01960305f, 0.05340289f, -0.07641597f, 0.13339096f, 0.04429384f, 0.17574894f, 
    -0.13431548f, -0.23241535f, 0.08728988f, -0.02465470f, 0.08842215f, -0.04817674f, 0.07593472f, -0.22899848f, 
    0.28538701f, -0.27611569f, -0.08299477f, 0.06927205f, 0.02953843f, 0.10157994f, 0.00053569f, -0.08001198f, 
    -0.06364123f, 0.06114780f, -0.15153138f, -0.03757100f, -0.01199317f, 0.03674555f, 0.02618397f, 0.01780977f, 
    0.02325745f, 0.05081197f, 0.02320909f, -0.05316184f, 0.04189178f, -0.06210664f, -0.05696861f, 0.04277786f, 
    -0.02105057f, -0.04845713f, -0.05814508f, -0.04402022f, -0.04460553f, -0.00865942f, 0.04391221f, -0.02103728f, 
    -0.02925974f, 0.03293918f, -0.05956119f, 0.01412791f, -0.01974856f, -0.02548016f, -0.00049559f, -0.01034126f, 
    -0.04149866f, 0.03865310f, -0.04588476f, 0.02136960f, 0.00245272f, -0.01333729f, -0.01417422f, -0.00637902f, 
    0.02603070f, 0.00541871f, 0.01630743f, 0.00690686f, -0.02085662f, -0.03311569f, -0.05031417f, 0.05196344f, 
    -0.05258422f, -0.03756546f, -0.03392484f, -0.04113589f, -0.03473189f, -0.01144746f, 0.04373254f, -0.05912597f, 
    -0.05772996f, -0.02793809f, -0.05370823f, -0.06132353f, -0.01733378f, 0.01953216f, -0.00134386f, 0.03683446f, 
    -0.01207104f, 0.02973578f, -0.03102138f, 0.01567868f, -0.01693602f, 0.00807102f, 0.04381727f, 0.00750794f, 
    0.02975104f, 0.04456312f, -0.03001551f, 0.03474510f, -0.02894262f, -0.02115276f, -0.00491363f, -0.06079724f, 
    0.00789354f, -0.05960407f, 0.01988651f, 0.03907333f, -0.00403421f, -0.03755323f, 0.02678904f, -0.03940648f, 
    0.01260408f, -0.03204651f, 0.03846541f, -0.02975962f, -0.02194275f, -0.01789780f, 0.00442527f, -0.03786247f, 
    0.02917259f, -0.00189256f, 0.02243712f, 0.05178222f, -0.01393891f, -0.01402814f, -0.02158858f, -0.03173644f, 
    -0.05295596f, 0.03053091f, 0.03155431f, 0.05127466f, -0.05617181f, -0.03987018f, -0.02518713f, 0.01736429f, 
    0.02920619f, 0.03516364f, -0.05364670f, 0.02695572f, 0.03103824f, 0.04130248f, -0.02697171f, -0.05063338f, 
    -0.00705521f, -0.03515744f, 0.04605688f, -0.04685050f, 0.04747076f, -0.00227892f, -0.05880760f, -0.03054317f, 
    0.02191611f, 0.02611383f, -0.05022212f, -0.00174344f, -0.00102156f, 0.04305576f, -0.02515091f, -0.05746597f, 
    0.01377426f, 0.02360582f, -0.00408604f, -0.02522022f, 0.01862104f, 0.05247616f, -0.05450121f, -0.05395116f, 
    -0.00504884f, -0.03329689f, 0.04680280f, 0.03929082f, -0.00380097f, -0.02542201f, -0.04768969f, 0.00907253f, 
    -0.01241070f, -0.06206141f, -0.06054569f, -0.01929935f, -0.01959153f, -0.00527598f, -0.02803859f, -0.05428833f, 
    0.02944998f, 0.03497300f, -0.03442025f, -0.04612111f, -0.05051049f, -0.04863171f, -0.06083051f, -0.02528641f, 
    -0.02520583f, 0.02330748f, -0.05424564f, 0.05343101f, -0.03899080f, 0.04506546f, -0.01593654f, 0.02188560f, 
    -0.03253365f, -0.01537826f, 0.05734236f, -0.00284413f, -0.02263333f, -0.02059672f, 0.01644661f, -0.00778942f, 
    -0.00966929f, -0.04839911f, -0.06180827f, 0.01800339f, -0.04384296f, -0.01598526f, -0.00033566f, -0.04412399f, 
    0.03586290f, 0.02767061f, -0.01910225f, -0.05543317f, 0.00223498f, 0.00212177f, 0.01628973f, 0.04061935f, 
    -0.04371699f, -0.05589387f, -0.05981047f, 0.03382904f, 0.02665334f, 0.00000129f, -0.00095673f, 0.04017663f, 
    -0.04866917f, 0.04515599f, -0.04119768f, -0.04773225f, 0.02644539f, 0.00959959f, 0.03219258f, 0.03444973f, 
    -0.05796121f, 0.02484875f, 0.05157929f, -0.03354219f, -0.02189036f, -0.02378107f, 0.03377770f, -0.05839074f, 
    -0.05690556f, -0.04035309f, 0.02183042f, 0.02173753f, -0.00165571f, 0.01727875f, 0.01484567f, -0.04450545f, 
    -0.05233739f, -0.03808636f, -0.03866431f, -0.01347973f, 0.04696152f, -0.03069075f, -0.04936457f, 0.03928659f, 
    0.01672839f, -0.03909874f, -0.04295524f, 0.03737571f, -0.05804178f, -0.00329159f, -0.04231084f, -0.02088753f, 
    0.00823472f, 0.02984431f, 0.01697623f, -0.02574334f, -0.03676154f, -0.03606182f, 0.04806982f, -0.00155279f, 
    0.04323140f, -0.01046848f, -0.01220051f, -0.05268932f, 0.00418347f, 0.00955486f, -0.03287608f, -0.05037943f, 
    0.03684879f, 0.03123782f, -0.04784364f, -0.01994441f, 0.04989747f, -0.05829853f, -0.05912811f, 0.01023146f, 
    0.02131488f, -0.03915307f, 0.02743054f, 0.01902750f, -0.01928356f, 0.01566030f, -0.04134930f, -0.05149907f, 
    0.00725576f, -0.05380543f, 0.02969380f, 0.01152669f, 0.02411428f, -0.00966952f, 0.01921683f, 0.00006526f, 
    0.03022393f, 0.01914783f, -0.01182105f, -0.05697609f, 0.02191774f, 0.01450673f, -0.02945013f, 0.00518617f, 
    0.03682375f, 0.15354106f, 0.07826845f, -0.08065993f, 0.01215578f, 0.13747415f, 0.02430393f, -0.00505847f, 
    -0.02729385f, 0.02909152f, 0.05521470f, 0.13214694f, 0.05784740f, 0.19165935f, 0.04064842f, 0.09114800f, 
    -0.07100325f, -0.10022344f, -0.02283953f, -0.19687440f, -0.16031043f, 0.05599005f, 0.10464200f, -0.06105290f, 
    0.11809485f, -0.08971465f, -0.05456992f, -0.08997256f, -0.02556656f, 0.17384990f, 0.08134435f, 0.11756493f, 
    -0.08033255f, -0.13657677f, -0.10986425f, 0.04041113f, -0.37903991f, 0.02624547f, -0.01243412f, 0.22866027f, 
    -0.17119859f, 0.02762048f, 0.00086535f, 0.11076687f, 0.12761669f, 0.19186608f, -0.11587919f, -0.10109963f, 
    0.03128723f, -0.02451352f, -0.14940196f, 0.00794346f, 0.01113891f, 0.00319470f, -0.15353161f, 0.27715480f, 
    0.31313694f, -0.02734874f, 0.03338487f, -0.11536048f, 0.15837672f, -0.18456542f, 0.30969387f, 0.21130188f, 
    -0.07977936f, 0.00661989f, 0.00883340f, -0.02288301f, -0.03343579f, -0.15904273f, -0.17276683f, 0.08420357f, 
    0.32711798f, 0.16378944f, 0.20482627f, -0.34804848f, -0.08375053f, 0.09608045f, 0.11914507f, 0.06719947f, 
    -0.05970286f, -0.14176784f, 0.20205599f, 0.11083277f, -0.01900351f, 0.04647835f, 0.01382613f, -0.11770163f, 
    0.02734360f, -0.01188805f, 0.28523415f, -0.18811087f, -0.32405981f, -0.03865351f, -0.01140345f, -0.05954075f, 
    0.00839519f, -0.05431917f, -0.03013710f, -0.12716766f, -0.04996783f, -0.11444918f, -0.03993359f, -0.15535690f, 
    -0.19176981f, 0.00279349f, 0.14631219f, -0.21208210f, -0.09837969f, -0.35876042f, -0.25366464f, -0.02544302f, 
    0.05316007f, -0.05292143f, 0.05911604f, 0.02972959f, 0.08436495f, 0.36385700f, -0.20374525f, -0.07946921f, 
    -0.08661512f, -0.10011163f, -0.05745476f, -0.21234642f, 0.09229378f, -0.02636989f, 0.34079283f, 0.25447965f, 
    -0.36565733f, 0.04769542f, 0.06817857f, -0.09160442f, 0.06973920f, 0.10160077f, -0.12913033f, -0.01204525f, 
    -0.00856107f, 0.13238411f, -0.21269050f, -0.29915386f, -0.00723468f, -0.03040267f, 0.18298267f, 0.05282166f, 
    -0.33485913f, 0.02599540f, 0.13086194f, -0.16219519f, 0.13080743f, 0.15355372f, -0.11015173f, 0.23190887f, 
    -0.29538989f, -0.13982677f, -0.00278186f, 0.13520281f, -0.04003184f, 0.00290208f, -0.00592524f, -0.06998032f, 
    -0.03757037f, 0.03954251f, -0.55886990f, -0.10584867f, -0.09592346f, 0.04011886f, -0.00711836f, -0.05201456f, 
    -0.02710038f, -0.04224557f, 0.18941763f, 0.19201954f, 0.20504732f, 0.24974340f, -0.00878821f, -0.07791214f, 
    -0.14521061f, -0.20423378f, 0.03539312f, 0.23174760f, -0.13952555f, -0.30000046f, -0.09122998f, -0.23178777f, 
    0.24113522f, -0.03555867f, 0.18139622f, -0.14259323f, -0.10522285f, -0.36845329f, 0.06843503f, 0.22469832f, 
    0.11425090f, 0.11206419f, -0.08088516f, 0.08734401f, 0.15585732f, -0.01772517f, 0.08827549f, 0.33759102f, 
    -0.00548079f, -0.01350255f, -0.03769222f, 0.07125081f, -0.23099194f, 0.09503611f, 0.02196234f, 0.11761869f, 
    0.20961384f, 0.09239289f, -0.18679681f, -0.00869856f, -0.03814176f, -0.04513220f, 0.02459759f, -0.09977456f, 
    0.05736357f, 0.18192682f, 0.24571513f, -0.00988940f, 0.13294156f, -0.00839398f, -0.08427013f, 0.26586667f, 
    0.09484334f, 0.12769906f, 0.20882401f, 0.37801176f, -0.02679111f, -0.14560524f, -0.03957752f, 0.02359430f, 
    0.14658199f, 0.13802993f, -0.07019868f, 0.01999636f, -0.10251826f, 0.20795518f, -0.00640788f, -0.00187818f, 
    -0.04408315f, -0.00695171f, 0.09342302f, 0.21620311f, 0.13652632f, -0.06732589f, -0.22303644f, 0.05277886f, 
    0.04098710f, 0.17052077f, 0.03597897f, -0.02015192f, -0.40902388f, 0.21700832f, -0.00420826f, -0.33673495f, 
    -0.01034147f, -0.13164350f, 0.02891285f, -0.09406723f, 0.04182639f, -0.25655091f, -0.31681874f, -0.24982019f, 
    0.02452352f, -0.11630864f, -0.12008852f, 0.28982401f, 0.16769235f, 0.03346054f, -0.01649855f, 0.03964270f, 
    -0.18435395f, 0.01905729f, 0.13743837f, -0.03536920f, 0.16778952f, 0.17836393f, 0.17583613f, -0.05035978f, 
    0.25289693f, 0.02285839f, -0.00639992f, -0.01094159f, -0.19265814f, 0.01019426f, 0.01985249f, -0.02801997f, 
    0.02943416f, 0.34990484f, -0.20239735f, -0.03100849f, 0.06046077f, -0.04943205f, 0.00256913f, -0.04481700f, 
    -0.01589708f, -0.51910233f, 0.02607590f, -0.38079068f, -0.06216392f, -0.22563937f, 0.06946479f, -0.12888305f, 
    -0.08562844f, 0.06906854f, 0.36666381f, 0.14366087f, -0.20935564f, 0.01961422f, -0.31265980f, -0.10232901f, 
    0.02955062f, 0.08336825f, 0.02590618f, 0.28982916f, -0.02161111f, 0.06397051f, 0.03767691f, -0.10310397f, 
    0.07316834f, -0.08041955f, 0.16859148f, 0.01742969f, -0.16920669f, 0.29744458f, -0.10792748f, 0.10533052f, 
    -0.03189139f, -0.07814137f, 0.06465433f, -0.17637144f, 0.14926641f, 0.14018410f, 0.04746515f, -0.09877704f, 
    0.11240914f, -0.06918098f, 0.04007432f, -0.16913763f, 0.08898284f, 0.08016847f, 0.44587159f, -0.19706933f, 
    0.02879332f, -0.07937909f, 0.18598524f, -0.00206149f, -0.01377950f, -0.16209640f, -0.14678174f, -0.26492330f, 
    -0.26551706f, -0.13661709f, -0.05383689f, 0.04465485f, -0.04258267f, 0.02249777f, 0.06946953f, 0.10331916f, 
    -0.03642314f, 0.42031616f, -0.14718738f, 0.01882399f, 0.08129337f, -0.02497860f, -0.02693247f, 0.00141767f, 
    -0.17386122f, -0.12803906f, 0.27853554f, -0.11806101f, -0.16223085f, -0.23481873f, -0.01307830f, 0.02197831f, 
    0.01680660f, 0.18669079f, 0.52662826f, -0.38014850f, -0.07140699f, -0.28353870f, 0.09627293f, -0.14982760f, 
    0.01671963f, -0.03179791f, -0.26988387f, -0.57276005f, -0.06811572f, -0.01278054f, -0.07369242f, 0.05997001f, 
    0.05735456f, 0.09307691f, 0.01467786f, 0.09307490f, 0.02956728f, 0.30970302f, -0.17327015f, -0.01612436f, 
    -0.15621205f, -0.02410227f, 0.19134744f, 0.08304744f, 0.06299576f, -0.02500712f, -0.08851293f, -0.11589608f, 
    0.11390366f, -0.08698811f, -0.00053291f, -0.12938064f, 0.02506455f, 0.04361505f, 0.32392195f, -0.28380832f, 
    0.07113644f, 0.10631924f, 0.03229036f, 0.12295082f, -0.01405424f, -0.09398235f, -0.09383728f, -0.13960458f, 
    -0.05967453f, -0.26448151f, 0.09548965f, 0.06438699f, 0.01611927f, -0.04515142f, -0.07821588f, 0.05729485f, 
    0.09072071f, 0.09693021f, -0.01489257f, 0.18009336f, -0.15719037f, -0.03170534f, 0.04585350f, 0.03025826f, 
    -0.04270228f, -0.44562453f, -0.08867092f, 0.18058167f, -0.01188913f, -0.00979172f, 0.02703889f, -0.17299153f, 
    0.08200409f, 0.07500467f, -0.21989034f, -0.37510505f, -0.14002444f, -0.10523839f, -0.13333754f, 0.11296505f, 
    0.15972637f, 0.20847130f, -0.22686484f, -0.30440053f, -0.08476158f, -0.07115521f, -0.33008954f, 0.16004568f, 
    -0.03686183f, -0.01438656f, 0.02366469f, 0.05587716f, -0.24314065f, -0.34076208f, -0.24782257f, -0.02096800f, 
    -0.03803568f, 0.09932544f, 0.05538125f, 0.12776265f, 0.01021140f, -0.25683510f, 0.59937835f, -0.09890453f, 
    -0.03689486f, -0.12796591f, 0.09005237f, 0.04273795f, 0.12636982f, 0.22767094f, -0.17013247f, -0.01542895f, 
    -0.09088783f, 0.07832128f, 0.13964257f, 0.15298398f, 0.10618135f, 0.03615884f, -0.07808815f, -0.51133066f, 
    0.24493383f, -0.17232406f, 0.04459175f, 0.34529549f, -0.09366476f, 0.01446398f, -0.03370328f, -0.02284537f, 
    0.14445278f, 0.13448609f, -0.15115590f, 0.14408118f, 0.12947738f, -0.07845125f, 0.27225143f, 0.07984098f, 
    -0.05899994f, -0.29217085f, 0.33163679f, -0.29858154f, 0.14574175f, -0.07526845f, 0.07597042f, -0.03354208f, 
    0.04420279f, 0.09730944f, 0.17670926f, 0.24683838f, -0.05568513f, 0.09574568f, -0.09451818f, 0.02472910f, 
    0.06183539f, 0.04361691f, 0.19607376f, 0.04119467f, -0.00778275f, 0.25834423f, -0.15556923f, 0.07438750f, 
    -0.29721484f, -0.12758006f, 0.13247742f, 0.17551692f, 0.29023674f, -0.29410014f, 0.07888468f, -0.00367752f, 
    -0.14148290f, -0.00381850f, 0.05160102f, 0.32414725f, -0.04285312f, 0.13374090f, -0.09547728f, -0.38196650f, 
    0.09620150f, 0.07443955f, 0.13520522f, 0.15173391f, 0.04002166f, -0.10141186f, -0.00064985f, -0.11655197f, 
    0.30913895f, 0.21266082f, -0.03484625f, 0.03421934f, 0.11298524f, 0.09767865f, 0.25037190f, 0.38031593f, 
    0.10531465f, -0.21426871f, -0.07511811f, 0.11549845f, 0.13573721f, -0.00945305f, 0.04910636f, -0.21230707f, 
    0.02129480f, 0.01702379f, -0.00714034f, 0.04778855f, 0.04697078f, 0.00002526f, -0.00025367f, 0.00721591f, 
    0.03304133f, -0.03292159f, 0.01172245f, 0.06062343f, -0.03928639f, -0.04669048f, 0.02462446f, 0.00366101f, 
    0.02468391f, -0.03323216f, -0.03987231f, 0.05220101f, 0.03935046f, -0.03350404f, -0.00260674f, 0.02727223f, 
    0.00578200f, 0.00001969f, 0.04120043f, -0.00485739f, 0.02096117f, 0.01587072f, -0.05640632f, 0.01252990f, 
    -0.05089099f, -0.02159582f, -0.03702939f, -0.02035140f, -0.04567584f, -0.02099326f, 0.00388953f, -0.05655767f, 
    0.03400816f, -0.01664875f, -0.06275910f, 0.00830383f, -0.04148783f, 0.03207565f, -0.02829443f, 0.02665312f, 
    0.02623972f, -0.00005309f, -0.04170878f, 0.03544847f, -0.00003515f, 0.04179518f, -0.01300895f, -0.02530605f, 
    -0.06555540f, -0.05229773f, -0.01912862f, -0.04200080f, -0.02882641f, -0.02061612f, 0.02913645f, 0.01403622f, 
    0.01388890f, 0.05180822f, 0.00480595f, 0.03791044f, -0.02918652f, -0.04182930f, 0.04700187f, 0.03536486f, 
    0.01967054f, 0.00035287f, 0.01119601f, 0.02046051f, -0.00335339f, -0.00298226f, 0.01549196f, -0.01221083f, 
    0.00342352f, -0.04571157f, 0.03568843f, 0.01458995f, -0.02657033f, -0.00246509f, 0.01730653f, -0.06232380f, 
    -0.06167685f, -0.00716863f, -0.01192505f, 0.02457291f, 0.03895780f, -0.01240273f, 0.02803248f, 0.00090394f, 
    -0.03475567f, -0.00826638f, -0.01160341f, -0.04886656f, -0.05811047f, -0.06169440f, 0.04166516f, 0.02552963f, 
    -0.00776436f, -0.02831081f, 0.00282922f, -0.01791255f, 0.00836156f, 0.03972679f, -0.00176696f, -0.04496674f, 
    0.03190575f, 0.01343224f, 0.03622901f, -0.01881032f, -0.01525057f, 0.04287009f, -0.02994334f, -0.05601631f, 
    -0.02746912f, 0.04700152f, 0.00211981f, -0.00268905f, 0.05817432f, -0.05010742f, 0.05199223f, 0.00008649f, 
    -0.01073863f, -0.01325892f, -0.05389771f, -0.03926584f, -0.04965359f, -0.00107010f, -0.05841450f, 0.04991601f, 
    0.01323141f, -0.00208049f, -0.01997709f, 0.05382514f, 0.05083634f, 0.01156342f, 0.00295529f, 0.03937682f, 
    -0.05069470f, -0.00881749f, 0.05414338f, 0.02282627f, -0.04072955f, 0.03257466f, 0.00449941f, -0.01785431f, 
    0.01702170f, -0.02755408f, -0.06429301f, -0.05546739f, 0.01268528f, -0.05710432f, -0.05659899f, -0.02676833f, 
    0.05709531f, 0.02474689f, 0.05137660f, -0.00710585f, -0.02003686f, -0.04513678f, 0.02987527f, -0.03029218f, 
    0.01950866f, -0.01993924f, 0.02929561f, -0.06466425f, -0.06694603f, -0.02631079f, -0.02422120f, -0.01993880f, 
    -0.01876632f, -0.01786007f, -0.00157420f, -0.06465606f, -0.02832007f, -0.03403714f, -0.01616563f, 0.00034188f, 
    0.01633473f, -0.03324786f, 0.00750043f, -0.03292726f, -0.01740133f, 0.02960749f, -0.03349622f, 0.05568868f, 
    -0.00979391f, -0.04805245f, -0.04226157f, -0.04088642f, 0.00373538f, 0.04042897f, -0.04425858f, -0.03355759f, 
    0.04035291f, -0.04756495f, 0.02638427f, -0.04947426f, -0.02669966f, -0.06048416f, -0.03104952f, -0.04490488f, 
    0.02500860f, 0.02627337f, -0.06123052f, 0.01867842f, -0.05851561f, 0.01400836f, 0.02430364f, 0.00831680f, 
    0.00646735f, 0.03635645f, -0.02170638f, -0.02574551f, -0.03655645f, -0.02617875f, -0.05789062f, 0.02960390f, 
    0.05076635f, 0.00481631f, -0.03795408f, -0.01854158f, 0.01250801f, -0.02015026f, 0.03590393f, -0.04333753f, 
    -0.03817990f, 0.02835440f, -0.01205694f, 0.02039396f, -0.05654535f, -0.03781191f, 0.04419421f, 0.01153440f, 
    0.05373796f, 0.01739342f, 0.00849519f, -0.06055147f, -0.06255231f, -0.06020983f, 0.03810880f, 0.01431716f, 
    -0.06389070f, -0.01813732f, 0.00392078f, -0.05272657f, 0.01916358f, 0.04795966f, -0.05716131f, 0.00485655f, 
    0.02810645f, 0.02401180f, 0.02025281f, 0.02609535f, -0.02020891f, -0.02330103f, 0.00605141f, -0.01711236f, 
    0.01587384f, -0.02665116f, -0.05655622f, 0.04374074f, -0.05445321f, 0.02520469f, -0.00941531f, -0.04526158f, 
    0.03401817f, -0.05112594f, 0.03905769f, -0.06347837f, -0.03530430f, -0.01674029f, -0.00219904f, 0.02696587f, 
    0.00012817f, -0.05087432f, -0.05139624f, 0.02836921f, 0.00351785f, -0.01824258f, -0.03121940f, -0.01294287f, 
    0.15627114f, 0.16947146f, 0.09027181f, -0.08510140f, 0.03834767f, 0.14400627f, 0.06278885f, 0.19427165f, 
    -0.06299448f, 0.33625314f, -0.07614622f, 0.14850089f, -0.08389710f, 0.13650694f, 0.09119853f, 0.02423222f, 
    -0.11718182f, 0.06779177f, 0.14477129f, 0.22136600f, 0.28739738f, -0.01711545f, 0.03664608f, -0.05478044f, 
    0.14040282f, -0.00707268f, -0.07690463f, 0.33956143f, 0.25140169f, 0.10981402f, -0.10577343f, 0.10366608f, 
    -0.10771879f, 0.01901288f, -0.08488655f, 0.00284027f, -0.05031217f, 0.00822355f, -0.10018108f, -0.09482867f, 
    -0.03260313f, -0.01666099f, -0.04314651f, 0.09142812f, 0.06169221f, -0.61346120f, -0.16749869f, -0.35252765f, 
    -0.02855271f, -0.08010304f, -0.07025807f, -0.11084230f, -0.02559673f, -0.04472330f, 0.18587112f, 0.06256469f, 
    0.20638403f, -0.01902258f, -0.07293108f, 0.11213488f, 0.03544991f, -0.05727639f, -0.11842918f, -0.43552813f, 
    -0.30776787f, -0.26738316f, -0.08848903f, 0.12063406f, -0.00510489f, -0.03590931f, -0.04601811f, 0.19704208f, 
    0.28594786f, 0.17948924f, 0.18313551f, -0.14767775f, 0.02288342f, 0.25434902f, -0.00102535f, -0.13210605f, 
    0.17334665f, 0.34621301f, 0.11828872f, 0.26351604f, 0.05109470f, -0.01102343f, -0.14338982f, -0.15485030f, 
    0.01341031f, -0.02619556f, -0.07186046f, 0.16659589f, -0.15511425f, 0.19062521f, 0.04358737f, -0.10680173f, 
    0.02332515f, 0.12055848f, 0.24172848f, -0.25919878f, 0.03058450f, -0.19286323f, -0.01466993f, -0.19589505f, 
    -0.13872732f, 0.09685018f, 0.15706220f, 0.01894332f, 0.04364669f, -0.01452401f, -0.13229869f, 0.12318108f, 
    0.06172870f, 0.09017532f, 0.09666254f, -0.11958375f, 0.02025776f, -0.11707473f, 0.14995642f, -0.09557005f, 
    0.12768511f, 0.06606835f, -0.00761365f, -0.09656543f, 0.16282365f, -0.23126654f, -0.72830409f, -0.22657414f, 
    -0.23694320f, -0.19899747f, -0.19659972f, -0.11318774f, -0.10085860f, 0.08667591f, -0.06013362f, 0.01810385f, 
    -0.12651256f, 0.22061105f, 0.21261887f, 0.03590141f, 0.16727617f, 0.07874538f, 0.08655237f, 0.00768731f, 
    0.02341002f, -0.12273818f, -0.06856113f, 0.01870113f, 0.05763059f, -0.07927319f, 0.19321410f, 0.18312892f, 
    0.21322104f, 0.17224947f, -0.26352766f, -0.23964794f, -0.13782176f, 0.25556239f, -0.15889591f, 0.05491685f, 
    -0.14071459f, 0.04422060f, -0.36407846f, -0.04417815f, -0.23018971f, 0.06014470f, 0.04291199f, -0.12726550f, 
    0.19373079f, 0.20665346f, 0.13535470f, 0.15102313f, 0.11068313f, 0.13835874f, -0.14539760f, -0.04135039f, 
    -0.00724289f, -0.07681542f, -0.18185817f, 0.18462390f, -0.35763943f, -0.08144925f, -0.27562103f, -0.02705947f, 
    0.13109308f, 0.05573741f, -0.08854424f, -0.16333228f, 0.16145059f, 0.29275388f, 0.18075171f, 0.40125844f, 
    -0.06332622f, 0.03208564f, -0.09718690f, 0.14529362f, -0.01367393f, -0.10246171f, -0.08626694f, -0.08594179f, 
    -0.06804964f, 0.13192366f, -0.15993063f, 0.01913785f, -0.05240378f, 0.11110995f, 0.06392429f, 0.19511427f, 
    0.00574951f, -0.05366983f, -0.02833031f, 0.07163139f, 0.07725492f, 0.03236379f, -0.00880484f, 0.15002564f, 
    0.24847819f, 0.25349617f, 0.46843541f, 0.08715769f, 0.10367618f, 0.20358273f, 0.12268643f, 0.18685035f, 
    -0.03173213f, 0.33569044f, -0.05078255f, 0.08021829f, 0.13570914f, -0.01469167f, -0.13620871f, -0.01674286f, 
    -0.14342488f, 0.05442678f, 0.34569460f, 0.05301470f, -0.08930039f, -0.05712864f, 0.04596696f, -0.21602674f, 
    -0.00677090f, 0.12509449f, 0.04190803f, 0.30513063f, 0.12968796f, 0.00533778f, -0.05674856f, 0.07937615f, 
    -0.24036846f, 0.06509035f, 0.28427407f, 0.06308304f, 0.01144800f, -0.16412838f, 0.01845677f, 0.18453895f, 
    -0.01908711f, 0.01837419f, 0.05747471f, -0.05360222f, -0.03728978f, -0.27783036f, -0.04310552f, -0.18639925f, 
    0.05461356f, -0.00220512f, -0.01983001f, -0.12290361f, -0.18874350f, 0.04025681f, -0.27328363f, 0.04522671f, 
    -0.23858093f, -0.20478411f, 0.02010932f, -0.01090164f, -0.05460213f, 0.08788966f, -0.14210674f, 0.12056030f, 
    0.14930429f, 0.04535846f, -0.08276568f, -0.07363803f, 0.05376998f, -0.10788281f, -0.19921814f, 0.01719901f, 
    -0.15142928f, 0.15041614f, -0.16240893f, 0.14393234f, 0.21653792f, 0.26321876f, -0.09351833f, -0.11060880f, 
    0.13935600f, -0.20104933f, -0.11992981f, -0.25982234f, 0.20650558f, 0.07673785f, -0.12282357f, -0.10045309f, 
    0.08393846f, 0.11260634f, 0.04019579f, 0.33296725f, 0.48306337f, 0.17365651f, -0.07280722f, 0.10631868f, 
    0.07962374f, 0.07139090f, 0.03814575f, 0.13155314f, 0.23391229f, 0.45998481f, 0.11913346f, 0.04813979f, 
    0.06498986f, 0.14249305f, 0.08791206f, 0.06325720f, -0.09438290f, -0.03055893f, 0.12660122f, 0.04662245f, 
    0.07070342f, -0.01442783f, 0.16829877f, 0.06148364f, -0.23861843f, 0.08381347f, 0.30474964f, 0.43663436f, 
    -0.32898194f, 0.07356262f, -0.28820273f, 0.22490011f, 0.04539519f, -0.14565362f, -0.23641510f, -0.54950392f, 
    -0.13505998f, 0.03729971f, -0.00041502f, 0.02869374f, -0.20119075f, 0.15514100f, 0.10630465f, -0.03260313f, 
    -0.20943855f, 0.05768464f, 0.10094130f, -0.02580750f, -0.42893240f, -0.09180404f, 0.09384142f, 0.09809667f, 
    -0.21373856f, 0.01267674f, 0.13419046f, 0.24404286f, 0.17218305f, 0.21721658f, -0.03974238f, -0.19967969f, 
    0.03078034f, -0.39488980f, 0.04189369f, -0.06091623f, 0.21228313f, 0.05647755f, 0.00269674f, 0.11709891f, 
    0.07979994f, -0.13344093f, 0.37659198f, -0.03919790f, 0.21596538f, 0.19267459f, 0.04218936f, 0.10198506f, 
    -0.12609206f, -0.13837861f, 0.13975634f, 0.07649259f, -0.18846522f, -0.09695622f, 0.23869295f, 0.14820069f, 
    -0.14346333f, 0.17309941f, 0.24861379f, 0.28201431f, -0.15820286f, 0.18632871f, 0.40389884f, -0.11795698f, 
    0.05308357f, -0.02942145f, 0.03753392f, -0.06085787f, -0.00866658f, -0.65352380f, -0.05865983f, 0.10234224f, 
    0.23358135f, 0.05884423f, 0.10025547f, -0.12606895f, -0.13631247f, -0.13443048f, -0.01381898f, -0.10917649f, 
    0.17172693f, -0.06240056f, 0.01218942f, -0.14678198f, -0.00095558f, 0.21983168f, 0.23063305f, -0.04949829f, 
    -0.23118027f, -0.03928414f, 0.31040299f, 0.24300466f, -0.10586423f, 0.06997924f, -0.06835511f, 0.02064316f, 
    0.26333022f, 0.06054281f, 0.05095836f, 0.14239208f, 0.12852131f, -0.01900120f, 0.06467369f, 0.16525120f, 
    0.08647738f, -0.43169966f, -0.27133942f, -0.05149313f, 0.08477092f, 0.07523222f, -0.26980224f, 0.05881679f, 
    -0.09863914f, -0.14140004f, 0.14108366f, -0.11454013f, 0.25184900f, -0.02533005f, 0.01637813f, -0.01544841f, 
    0.25604826f, 0.25480050f, 0.46523911f, -0.29414847f, -0.17245966f, -0.07540181f, 0.24481197f, 0.03370726f, 
    0.09617186f, -0.25348014f, -0.09625152f, -0.27167553f, 0.09630036f, -0.26244175f, -0.00214519f, -0.10342211f, 
    -0.16003160f, -0.15323022f, -0.02832359f, 0.08348552f, 0.24608259f, -0.47298992f, -0.18602972f, -0.51677191f, 
    0.09597512f, 0.09934208f, -0.08688631f, 0.24129365f, 0.02828581f, -0.12579617f, -0.30066350f, 0.11127301f, 
    -0.01696585f, 0.35457480f, 0.04085948f, 0.07194580f, 0.11968525f, -0.04650720f, -0.10375524f, -0.52399176f, 
    -0.13607898f, -0.17077489f, 0.35291100f, 0.01870215f, 0.05047070f, 0.18907933f, -0.12442527f, -0.08912791f, 
    -0.48787206f, 0.00795742f, -0.49831823f, -0.05318302f, -0.00366384f, 0.09520379f, -0.06321266f, -0.23321988f, 
    0.08138738f, 0.00123855f, -0.33039719f, 0.09400778f, -0.15041542f, 0.09405208f, 0.04012490f, -0.00951782f, 
    -0.25137141f, -0.09507524f, 0.09859089f, -0.14487834f, 0.12924755f, 0.09168623f, -0.02004264f, -0.04979695f, 
    -0.03634660f, -0.32333630f, -0.24328731f, 0.58778113f, -0.08247208f, 0.15486564f, 0.16304158f, -0.06192573f, 
    0.20585430f, 0.12847270f, -0.06898689f, 0.06539779f, -0.01910685f, -0.48804227f, -0.07259896f, -0.43727952f, 
    -0.11479840f, -0.06890564f, -0.05077760f, 0.05866459f, 0.03410625f, -0.10379307f, 0.16518593f, -0.04443483f, 
    0.03914341f, 0.03139331f, -0.08973777f, 0.16182092f, 0.17122506f, -0.11970148f, 0.08822361f, -0.28015321f, 
    0.04156617f, -0.04358662f, -0.03164727f, -0.00339416f, -0.09128789f, 0.07896061f, 0.07741237f, -0.35309535f, 
    -0.12638535f, 0.07564771f, 0.11293875f, 0.12443853f, 0.02326802f, 0.04002387f, 0.01628747f, 0.14695817f, 
    -0.01274319f, 0.05279997f, 0.00532030f, -0.01537048f, 0.00416541f, 0.03482806f, 0.00908048f, 0.02166358f, 
    0.03608144f, 0.01421383f, 0.01600504f, 0.05121017f, 0.02371300f, -0.06202705f, -0.02491031f, 0.03006412f, 
    -0.01895721f, 0.04250490f, 0.02163616f, -0.01573854f, -0.07636348f, 0.00663161f, -0.00310071f, -0.05950658f, 
    0.01498717f, -0.00736090f, -0.01739743f, 0.01527428f, 0.01361873f, -0.05509635f, -0.05944015f, -0.03511124f, 
    -0.02632177f, -0.02258080f, -0.02735625f, 0.02900022f, 0.01267132f, 0.04105722f, 0.00203612f, 0.02181885f, 
    0.04751340f, -0.00940993f, -0.00309432f, -0.05625165f, -0.04697289f, -0.05215519f, 0.02918653f, 0.03165479f, 
    -0.07053397f, 0.04422000f, -0.02338595f, -0.04325428f, 0.04071229f, -0.02517201f, 0.05329512f, -0.01600703f, 
    0.01684623f, 0.02342514f, -0.04988736f, -0.01831627f, 0.02677853f, 0.01663636f, 0.00849172f, -0.02653425f, 
    0.05251235f, -0.01356971f, 0.05088333f, 0.00160657f, 0.04746941f, -0.04049852f, -0.00375186f, -0.01265867f, 
    0.04805713f, 0.04552092f, -0.06450894f, -0.01532658f, 0.05191807f, 0.04862442f, -0.03450545f, 0.00078661f, 
    0.01234589f, -0.06690035f, 0.03053761f, -0.03016793f, 0.05197305f, -0.03768084f, 0.02870782f, -0.00006548f, 
    -0.00013784f, -0.02215946f, 0.00418032f, 0.02519513f, 0.00760960f, -0.02225901f, 0.00838462f, -0.02882762f, 
    0.02058998f, 0.00100993f, -0.03037504f, 0.03079453f, 0.01925040f, -0.06671252f, -0.03147053f, 0.02136004f, 
    0.02487009f, -0.03361251f, -0.02119119f, -0.05719917f, 0.04699294f, 0.00977170f, 0.04911483f, -0.01681265f, 
    -0.00908963f, 0.00897953f, 0.01077287f, 0.00206585f, -0.01606165f, 0.03865442f, 0.02890570f, -0.01743333f, 
    -0.05836459f, 0.00232691f, -0.04879970f, -0.05770550f, -0.06717520f, -0.02422006f, 0.04146874f, -0.02102466f, 
    -0.01333542f, -0.05779407f, 0.04624890f, 0.03958710f, -0.02939736f, -0.04290340f, -0.02024994f, 0.00723538f, 
    -0.00299225f, -0.06932442f, -0.02257242f, 0.03164031f, -0.02757583f, 0.02544523f, 0.00904518f, -0.01769076f, 
    0.04054640f, -0.06193362f, -0.04042781f, 0.05003126f, -0.02254458f, -0.00181233f, -0.07395888f, 0.05298545f, 
    -0.04414527f, 0.02798972f, -0.02646733f, 0.04019734f, 0.00898717f, 0.00515794f, -0.05026239f, 0.04581241f, 
    -0.01483381f, -0.03840650f, 0.03751796f, 0.02272888f, -0.02604068f, 0.03002407f, -0.07865223f, -0.04630221f, 
    0.01607842f, 0.02902436f, -0.01221434f, 0.00557224f, -0.04052529f, 0.03196845f, 0.01909287f, -0.04375283f, 
    -0.06009326f, -0.04695130f, -0.03928244f, 0.04710173f, -0.00244349f, -0.05329287f, 0.01664894f, 0.01562688f, 
    0.04371826f, -0.05942627f, 0.00718135f, -0.02730851f, -0.05442443f, -0.06412318f, -0.06460697f, -0.02311329f, 
    0.01157828f, -0.06063462f, -0.01312835f, -0.03795119f, 0.01958812f, -0.03293625f, -0.02712234f, 0.00485969f, 
    -0.00206793f, 0.00468680f, -0.06373762f, -0.05728015f, -0.01131170f, -0.01217807f, -0.00990135f, -0.04778760f, 
    0.01384433f, 0.02422828f, -0.05046965f, 0.01345504f, -0.02709362f, 0.01421653f, 0.01195109f, 0.00422257f, 
    -0.02229895f, -0.00116691f, -0.01726083f, -0.01507293f, -0.00556950f, -0.01433805f, 0.04173121f, 0.05745428f, 
    0.00992428f, -0.06298363f, 0.03785702f, -0.01171873f, -0.03013835f, 0.02155021f, -0.04827719f, -0.03878076f, 
    -0.03158175f, -0.01872694f, 0.02128539f, 0.02196170f, -0.02878052f, -0.02761064f, 0.01785167f, 0.00718562f, 
    -0.04813439f, 0.01178095f, -0.00739477f, -0.00986796f, -0.04953640f, -0.01568754f, -0.01642184f, 0.02260052f, 
    0.05612367f, -0.05285397f, 0.03536838f, -0.00917051f, -0.05199931f, -0.02301323f, 0.02822774f, 0.03585818f, 
    -0.04019096f, -0.01035353f, -0.06271537f, -0.04993279f, 0.00568080f, -0.05105866f, 0.01875924f, 0.02568001f, 
    0.02498437f, 0.01244391f, 0.03713062f, -0.05197528f, -0.03870517f, 0.04121548f, 0.02241443f, 0.02045321f, 
    -0.02813820f, -0.01934331f, -0.04108420f, 0.04655943f, 0.03067102f, -0.01537955f, -0.03981258f, -0.05804845f, 
    -0.03886762f, -0.00798842f, 0.03041781f, 0.03378437f, -0.04972853f, 0.04697613f, -0.00085690f, 0.01584939f, 
    0.06715232f, 0.03210157f, 0.09740784f, 0.15955265f, -0.05095072f, 0.05794904f, 0.03067512f, 0.12107746f, 
    0.08740814f, 0.00610323f, 0.22465955f, 0.26027960f, -0.01545796f, -0.00149015f, -0.05713227f, -0.06303719f, 
    0.09972692f, 0.03006933f, -0.40695134f, -0.00748169f, 0.15681481f, -0.09032395f, -0.05748830f, 0.07951407f, 
    -0.17982401f, 0.14316256f, 0.03407924f, -0.34531090f, -0.13057137f, -0.08971554f, 0.01692476f, 0.04739146f, 
    0.03968662f, -0.00173313f, 0.14557473f, 0.00367012f, 0.16623646f, -0.27785540f, -0.11621676f, -0.03582703f, 
    0.01665804f, -0.29967558f, -0.14206968f, 0.07733264f, 0.10942127f, -0.18544407f, -0.22730038f, 0.03265548f, 
    -0.12954377f, 0.06484669f, 0.27542019f, -0.22055835f, -0.01598115f, -0.19352722f, 0.20574272f, 0.31216970f, 
    -0.27288955f, 0.10090369f, 0.01619234f, -0.04384669f, -0.06106954f, -0.20186844f, -0.01449635f, 0.05177195f, 
    0.08587151f, 0.08115997f, 0.04140048f, -0.09372427f, -0.02033779f, -0.14423899f, 0.10263101f, 0.09886833f, 
    0.05212626f, 0.10649594f, 0.30094460f, -0.03350499f, -0.03111351f, 0.04662835f, 0.02660912f, 0.12654203f, 
    0.05460755f, -0.01568239f, 0.03913018f, 0.27186778f, -0.03745129f, -0.02742321f, -0.00988796f, 0.07751044f, 
    0.10775523f, 0.08306596f, 0.35699981f, 0.05879588f, 0.07608007f, 0.10433792f, -0.08849195f, 0.05534222f, 
    0.14661860f, 0.06224103f, 0.06484663f, 0.27226087f, 0.09685662f, -0.03835680f, 0.10551019f, -0.00308970f, 
    -0.06540176f, -0.05111586f, -0.00718117f, -0.28026998f, -0.54250264f, -0.22409160f, -0.11076006f, 0.01820974f, 
    -0.02929660f, 0.15541546f, -0.05611179f, -0.12660807f, -0.06045965f, -0.14707489f, 0.07085953f, -0.16418815f, 
    0.01838438f, 0.02434250f, -0.19367348f, 0.05949584f, -0.09607632f, 0.07219663f, 0.14121388f, -0.13603716f, 
    0.00174123f, -0.13605863f, -0.11170559f, -0.10985219f, -0.13748941f, 0.01353931f, -0.44912866f, 0.01104538f, 
    0.14507131f, 0.13948956f, -0.04592677f, 0.08543584f, -0.05791951f, -0.01639900f, 0.18408197f, -0.22034487f, 
    0.05735287f, -0.25182319f, -0.14545834f, -0.14385583f, 0.17487915f, -0.26512775f, 0.13075659f, -0.18133864f, 
    0.16636007f, -0.21650015f, -0.22739404f, 0.00012024f, -0.12569879f, 0.15245911f, 0.03232771f, 0.02360990f, 
    0.25414088f, -0.18144076f, 0.57270610f, -0.03407682f, 0.25788981f, 0.05367007f, 0.02523306f, 0.10674480f, 
    -0.25121993f, 0.08188976f, -0.31317726f, -0.15516143f, -0.20073329f, 0.15905730f, -0.08592707f, 0.02256521f, 
    -0.07175723f, 0.03812411f, 0.13587576f, 0.05535120f, 0.08981229f, 0.18490855f, 0.19541989f, 0.11596923f, 
    0.03046897f, -0.12317462f, -0.12616095f, -0.06408607f, 0.22835152f, 0.18677773f, 0.15275054f, 0.01836023f, 
    -0.07121173f, 0.07153664f, 0.11298458f, -0.03911875f, 0.16937952f, -0.18151385f, -0.05133959f, 0.06986332f, 
    0.35631010f, -0.11887281f, -0.01930294f, -0.13643594f, -0.04132207f, 0.05911578f, 0.00491292f, 0.12104727f, 
    -0.27853054f, 0.03896804f, -0.03886848f, 0.10541680f, -0.44349658f, 0.17354307f, 0.14146215f, 0.08528288f, 
    0.30301118f, 0.10650102f, 0.17325224f, 0.19387275f, 0.22120155f, 0.08419595f, 0.14941031f, 0.21950270f, 
    0.27311698f, -0.18234262f, 0.04813758f, -0.05237349f, -0.08410750f, -0.18794718f, 0.06924300f, -0.01062406f, 
    0.05106980f, 0.07658475f, -0.02603141f, -0.04692112f, -0.11987247f, -0.26524153f, -0.06001603f, -0.14339864f, 
    -0.06578935f, -0.04032401f, 0.10774601f, -0.26197326f, 0.15798445f, 0.14631249f, -0.04557060f, -0.10626332f, 
    -0.09549152f, 0.32141206f, -0.00012305f, 0.13262095f, 0.07303003f, -0.09993631f, -0.14723115f, 0.00368585f, 
    0.10809138f, -0.06331042f, -0.10466695f, -0.05840810f, 0.35399914f, 0.29350677f, 0.12898621f, -0.02015760f, 
    -0.07689844f, -0.22980028f, 0.16757363f, -0.20588361f, -0.14192083f, -0.23679855f, 0.04585357f, 0.12574950f, 
    -0.04970378f, 0.02091817f, -0.16991891f, 0.16639398f, -0.07230246f, -0.01659069f, -0.20138276f, 0.05454518f, 
    -0.03151926f, 0.26526165f, -0.05913565f, 0.03354536f, -0.00603236f, -0.10580174f, -0.16356887f, -0.49628291f, 
    0.08571868f, 0.17047077f, -0.44897276f, 0.04834164f, 0.02269697f, 0.04201500f, -0.06099039f, 0.13979152f, 
    -0.06973526f, -0.19421048f, -0.01966390f, -0.16941796f, 0.04732573f, 0.16522826f, 0.32184908f, 0.02840091f, 
    0.07022879f, -0.31404853f, -0.01109604f, -0.01909103f, 0.27451667f, 0.11120147f, 0.00512429f, -0.11278602f, 
    0.19950144f, -0.09169139f, -0.03248778f, 0.06951696f, 0.19542694f, 0.15977433f, 0.15242828f, 0.12868284f, 
    -0.22333717f, 0.07888033f, 0.00234883f, 0.03571621f, 0.13378192f, -0.06073068f, -0.08329367f, -0.06495839f, 
    -0.17260845f, 0.05260183f, 0.20521376f, 0.03931334f, 0.11903206f, 0.11784526f, 0.18973300f, 0.11051950f, 
    0.01464146f, -0.13602199f, 0.22482380f, 0.07552053f, -0.01766559f, 0.04085139f, -0.12232943f, -0.25364494f, 
    -0.09407867f, 0.18013059f, -0.02681432f, -0.12017586f, 0.05019755f, -0.26115096f, -0.08607230f, -0.07858644f, 
    -0.17478056f, -0.09003892f, 0.14936306f, 0.27022734f, 0.04271220f, 0.16873041f, -0.18088892f, 0.15384240f, 
    -0.25816187f, 0.04300798f, -0.31965503f, 0.03947300f, 0.09134534f, -0.00762060f, -0.13116774f, -0.01424193f, 
    -0.12437087f, -0.02309418f, 0.19890413f, -0.03430071f, 0.20923239f, 0.27639204f, 0.14103389f, 0.02575941f, 
    0.05606643f, -0.20259707f, -0.45784315f, -0.14581226f, -0.25347936f, 0.17541093f, 0.16394803f, -0.17149901f, 
    -0.15333475f, 0.08901005f, 0.03266512f, 0.20034586f, -0.02339150f, 0.02905608f, 0.11734058f, 0.11495177f, 
    0.11800493f, 0.03702212f, -0.05980317f, -0.05071180f, -0.13406458f, 0.10018137f, 0.26884577f, 0.08734373f, 
    -0.24441659f, -0.15483862f, 0.08301014f, -0.04000103f, 0.02457942f, 0.05828088f, -0.00859846f, -0.01614498f, 
    0.17618337f, -0.15000387f, -0.10850092f, 0.15426634f, -0.07007496f, -0.11014175f, -0.04939763f, -0.02059418f, 
    -0.21931377f, 0.05275204f, 0.02467678f, 0.32315695f, 0.14783931f, -0.17709540f, -0.12352908f, -0.23513307f, 
    -0.15892470f, 0.29417071f, 0.28593251f, 0.22493468f, -0.01315867f, 0.11640232f, -0.16345398f, 0.16699152f, 
    0.04986882f, 0.12915166f, 0.11651190f, 0.18385214f, -0.09762028f, 0.09421904f, 0.10173699f, 0.00573841f, 
    -0.05907055f, -0.01285660f, -0.16372772f, -0.15485238f, -0.15410660f, -0.16164683f, 0.12859298f, 0.03618095f, 
    -0.19655199f, 0.05587158f, -0.18806961f, -0.07990989f, -0.13162540f, 0.00750063f, 0.10285717f, -0.00749702f, 
    -0.10258279f, 0.15095057f, -0.10120462f, 0.01818798f, -0.02319691f, -0.14169218f, 0.01473605f, 0.02054362f, 
    -0.15805861f, 0.03773487f, 0.17539848f, 0.05931641f, -0.33738142f, -0.10589327f, -0.22599331f, 0.08291969f, 
    -0.10417875f, 0.19536112f, 0.08260222f, -0.24556808f, -0.18600164f, -0.04519188f, 0.28662065f, 0.06613133f, 
    0.31811032f, 0.13446853f, 0.21851212f, 0.10322668f, -0.08825132f, -0.21134198f, -0.35119802f, -0.14535508f, 
    -0.14283103f, 0.10273945f, 0.22979209f, 0.20277764f, 0.11429312f, -0.16511631f, -0.09454588f, 0.07958348f, 
    0.09478667f, -0.25955719f, 0.00449331f, 0.09132934f, 0.06709979f, -0.04624618f, -0.09512439f, -0.05684271f, 
    0.18133411f, 0.29034156f, -0.39704370f, 0.14021260f, -0.01352726f, -0.13875456f, -0.17403427f, -0.16926359f, 
    -0.12329918f, 0.09883410f, -0.08766633f, -0.23488101f, -0.02953327f, 0.17279224f, -0.09705579f, 0.07126957f, 
    -0.14955039f, -0.05270645f, -0.04060952f, 0.22972409f, 0.05571680f, 0.28698832f, -0.08691660f, -0.27363241f, 
    0.17078020f, 0.12904987f, 0.11228520f, 0.06075007f, 0.06745877f, -0.08639587f, 0.22860299f, 0.20084423f, 
    -0.37585837f, -0.07964172f, 0.03886443f, -0.04917789f, 0.05988360f, -0.15793352f, -0.37431544f, 0.02161561f, 
    0.14177293f, -0.01677665f, -0.05207617f, -0.04909953f, 0.27155378f, -0.34741747f, -0.16011487f, 0.08933829f, 
    0.11517733f, 0.41233271f, 0.22848000f, 0.22850819f, -0.03306310f, -0.14093497f, -0.20055512f, 0.09106016f, 
    -0.04618798f, 0.13047102f, -0.06199444f, 0.17277761f, 0.06051351f, 0.08026223f, -0.06040433f, -0.08486222f, 
    -0.09332863f, -0.30309296f, 0.06637982f, -0.02688181f, 0.26269093f, -0.02434903f, 0.16882715f, -0.12537371f, 
    -0.01335502f, -0.05936500f, -0.03326425f, -0.00596135f, -0.04335428f, -0.06702450f, 0.02403439f, 0.01017168f, 
    -0.06278922f, -0.02695725f, 0.02086887f, 0.01281428f, -0.06110693f, -0.00548996f, -0.05979937f, 0.02396224f, 
    -0.05784073f, 0.04991094f, 0.04151320f, 0.02063183f, -0.04277136f, 0.01743286f, -0.02415928f, -0.03791360f, 
    -0.05533972f, -0.01351350f, 0.01972193f, -0.00839878f, -0.03161300f, -0.02536205f, -0.06498604f, 0.02388097f, 
    0.03934855f, -0.05501173f, 0.04885295f, 0.03538654f, -0.00105485f, -0.03469336f, -0.03827715f, -0.02881911f, 
    -0.02478909f, -0.05991431f, -0.05508501f, -0.03861758f, -0.05164516f, -0.00048725f, -0.01985200f, -0.00076328f, 
    -0.00932201f, 0.03053786f, -0.03277137f, -0.04374038f, 0.01441677f, -0.02144033f, 0.05056982f, -0.00676439f, 
    -0.04314794f, -0.03855524f, -0.01817510f, -0.00437570f, -0.05331858f, -0.03123709f, 0.01760485f, -0.03945665f, 
    0.00052249f, -0.06707413f, 0.03568386f, 0.03827636f, -0.06605977f, -0.05637239f, 0.01051379f, 0.01211189f, 
    -0.03044418f, -0.01427367f, 0.04977084f, 0.04091772f, -0.02164376f, -0.06478187f, 0.00301721f, 0.02257784f, 
    0.00116086f, -0.02780820f, 0.03661382f, -0.01692725f, 0.02862840f, -0.06052491f, 0.02683404f, -0.04615131f, 
    0.03325940f, 0.00024024f, 0.04493092f, 0.04042719f, 0.02821227f, -0.03102119f, -0.02891153f, -0.03105564f, 
    0.04471070f, -0.02390735f, 0.02541484f, -0.02786747f, -0.05435427f, 0.03520208f, 0.01953621f, -0.01610769f, 
    -0.04432784f, -0.03604694f, 0.03235934f, -0.01706091f, -0.00717736f, -0.00441773f, 0.01769331f, 0.04461492f, 
    -0.04176724f, 0.02048204f, 0.01968011f, 0.03098149f, -0.05003086f, -0.02740988f, -0.04236061f, -0.02833456f, 
    -0.02870777f, 0.02478479f, 0.03297256f, -0.03375263f, 0.04253331f, 0.02662443f, -0.00760260f, -0.00179201f, 
    -0.06415772f, -0.06756772f, -0.04337480f, 0.01144705f, 0.03230438f, 0.02646888f, -0.04241392f, -0.01430587f, 
    0.01248945f, 0.01676623f, 0.03249069f, -0.00625273f, -0.02940096f, -0.06375103f, -0.02438163f, -0.06174204f, 
    -0.01228177f, -0.04803166f, -0.01468055f, -0.02776654f, -0.03968795f, -0.05699630f, -0.05131061f, 0.00238281f, 
    0.02999927f, 0.04398238f, -0.00279950f, -0.04163564f, 0.04855987f, -0.02373367f, -0.02935765f, 0.01118056f, 
    -0.02572349f, -0.00066585f, 0.02917030f, 0.04010160f, 0.02958748f, -0.02686883f, -0.04176200f, 0.01631474f, 
    -0.05653698f, 0.04608561f, 0.05165568f, -0.02291141f, -0.03730110f, -0.00256371f, -0.00469889f, -0.02511282f, 
    -0.00379001f, -0.04328173f, 0.01400979f, -0.04522698f, -0.04275433f, -0.05665452f, 0.03559896f, -0.02619181f, 
    -0.00783754f, -0.04386294f, 0.04539778f, -0.02493832f, 0.02178429f, 0.04026589f, -0.06309842f, 0.00007177f, 
    -0.06119527f, 0.02563606f, 0.04607393f, 0.03980946f, 0.03026663f, 0.04846032f, -0.04357155f, 0.04438783f, 
    -0.03629120f, -0.02760351f, -0.05876851f, 0.03179211f, 0.02550322f, 0.01109474f, -0.00801196f, 0.04885472f, 
    0.04346538f, -0.04356560f, 0.00877339f, 0.03593612f, -0.04358169f, -0.00159345f, -0.03125789f, 0.02917073f, 
    -0.00188405f, 0.04826554f, 0.04356819f, -0.03480975f, 0.01096775f, -0.04612007f, -0.00317748f, -0.03971326f, 
    -0.00007693f, -0.05889419f, 0.01785622f, -0.04949085f, -0.05968679f, 0.00793253f, 0.01781125f, 0.03938180f, 
    0.01752575f, -0.02650571f, -0.03869634f, -0.02832771f, -0.04208650f, -0.04724750f, -0.04380714f, -0.05264435f, 
    -0.04251884f, -0.06829276f, -0.03856960f, 0.03770475f, 0.03348897f, -0.01091509f, 0.04000689f, 0.04386227f, 
    0.02572101f, 0.02569321f, -0.03567852f, 0.02332396f, 0.04381508f, 0.03008942f, 0.04492817f, -0.05906069f, 
    0.00222380f, 0.03933371f, -0.05654152f, 0.04867999f, -0.04350394f, -0.03218985f, 0.00714283f, -0.03746903f, 
    -0.05520743f, -0.04523160f, 0.00931298f, -0.01841384f, -0.05450339f, -0.01005988f, 0.01467775f, 0.01077371f, 
    -0.00448014f, 0.00634232f, -0.02172636f, 0.00152482f, 0.04219339f, -0.02757061f, 0.01637131f, 0.04570874f, 
    -0.06594560f, -0.01402720f, 0.02725300f, 0.00121726f, -0.02454440f, -0.01308314f, -0.00151278f, -0.00216833f, 
    0.21444166f, 0.29503521f, 0.18845290f, 0.30314121f, -0.05234968f, 0.02553552f, 0.05514275f, 0.03490123f, 
    0.23058574f, 0.23038998f, 0.13337128f, 0.24332406f, 0.13350515f, -0.16580838f, 0.10872558f, 0.00590512f, 
    -0.05533912f, -0.25940400f, -0.10547164f, -0.03139023f, -0.08326367f, -0.11158100f, -0.00096099f, 0.05877320f, 
    0.07687303f, 0.06897843f, -0.10549004f, -0.15377678f, -0.01484293f, -0.13288958f, 0.12824677f, 0.00682034f, 
    -0.09810749f, -0.12512884f, -0.14616929f, 0.13725644f, 0.12866317f, -0.06328717f, -0.01178306f, -0.33585548f, 
    -0.03431664f, -0.08373508f, -0.20738824f, 0.03524258f, -0.09307235f, -0.28000268f, 0.18688567f, 0.03345459f, 
    -0.38172373f, -0.17602934f, -0.07514834f, -0.07749882f, -0.08753171f, 0.17110239f, 0.54680347f, 0.11234523f, 
    0.04619854f, -0.16084553f, 0.06580935f, -0.03645080f, 0.23585926f, 0.07039400f, 0.12633058f, 0.26274344f, 
    -0.07044697f, 0.10367177f, -0.19446382f, -0.12616672f, -0.00857155f, 0.06021216f, -0.03753347f, -0.02801459f, 
    0.21704465f, 0.28197822f, 0.08716269f, 0.19698159f, 0.03406397f, 0.09563252f, 0.07902873f, -0.08389728f, 
    0.17864987f, 0.04373288f, -0.06324657f, 0.11541776f, 0.29878736f, 0.02832996f, 0.01956828f, -0.12846030f, 
    -0.05314193f, 0.03514955f, -0.04852096f, 0.25781170f, 0.28749785f, 0.16221835f, 0.06321598f, 0.20160611f, 
    0.01314833f, 0.14877105f, 0.09269327f, -0.02751081f, 0.01398896f, -0.23001510f, -0.03749561f, -0.06072492f, 
    -0.02016192f, 0.05400341f, 0.02956006f, 0.00674405f, 0.02332721f, -0.11760232f, -0.04108109f, -0.29673272f, 
    0.07971435f, 0.04375928f, -0.10572556f, 0.00521037f, -0.20753421f, -0.25202250f, 0.05096000f, -0.12742111f, 
    0.03718241f, 0.04029424f, -0.09030732f, -0.00916796f, 0.09058277f, 0.02527080f, -0.33910102f, 0.11891581f, 
    0.19538058f, -0.37770703f, -0.18209708f, 0.02493256f, -0.05501747f, 0.12236858f, 0.13561189f, -0.55085343f, 
    0.06020907f, 0.07783397f, -0.06983513f, -0.13424179f, 0.02787758f, 0.01892922f, 0.18558238f, 0.08588100f, 
    0.05468895f, -0.02825054f, -0.12167823f, -0.13208832f, 0.01146560f, -0.03695494f, -0.07346950f, -0.00026914f, 
    -0.11921372f, -0.22877014f, 0.10692393f, -0.30024990f, 0.05467551f, -0.07958663f, 0.10597758f, 0.04047428f, 
    0.24360591f, -0.13871092f, 0.21687107f, 0.40542248f, 0.17348534f, -0.07904030f, 0.03766851f, 0.15707864f, 
    0.01997369f, -0.08083288f, 0.14764453f, 0.09436727f, 0.05716758f, -0.07699521f, -0.02930859f, -0.11301854f, 
    0.03250523f, -0.33047578f, -0.02947138f, -0.12507409f, 0.30901331f, -0.15202224f, 0.06740338f, -0.38583115f, 
    -0.02942914f, -0.09120420f, -0.05444055f, 0.07221384f, 0.00949022f, -0.03924782f, 0.08478165f, 0.16249420f, 
    0.23072113f, 0.02895983f, -0.09347688f, 0.41738319f, -0.02095531f, 0.09897047f, 0.08720285f, -0.21146606f, 
    0.03118018f, -0.12114875f, -0.07512171f, 0.12294219f, -0.12079974f, 0.15252201f, -0.11436945f, 0.15604928f, 
    0.02211071f, -0.11694819f, -0.12785023f, 0.01847685f, 0.05670600f, 0.12900458f, -0.17239325f, -0.04359298f, 
    0.35243064f, 0.33035660f, 0.30259454f, 0.18299651f, 0.14576212f, -0.10804927f, 0.14095294f, 0.00905448f, 
    0.05672705f, 0.07027507f, -0.17096016f, 0.14379378f, -0.05890532f, 0.03118142f, -0.28133154f, -0.01264113f, 
    0.06729777f, -0.01330121f, -0.53347391f, 0.36755973f, 0.01072030f, 0.16659248f, -0.00445366f, 0.07952911f, 
    0.00428530f, -0.01671501f, -0.13986339f, 0.21341357f, 0.28386083f, 0.23651707f, 0.00259268f, 0.11196583f, 
    -0.17683688f, -0.13457496f, -0.06072729f, 0.12486455f, -0.08731443f, 0.12023088f, -0.23499703f, -0.08449160f, 
    0.02102027f, 0.09914974f, 0.09515993f, 0.03447370f, -0.10202214f, -0.36291748f, -0.23455119f, 0.24423717f, 
    0.05326419f, -0.04863645f, 0.02838243f, 0.02936117f, 0.05617642f, -0.04263404f, -0.23966900f, 0.05944893f, 
    0.01764979f, -0.31187496f, -0.08814467f, -0.20739746f, 0.03424906f, -0.10693209f, -0.13379416f, 0.04187175f, 
    0.08952937f, 0.10197134f, 0.14338334f, 0.28642935f, -0.06821434f, -0.16063750f, -0.04054150f, -0.08098399f, 
    0.23407511f, 0.13969845f, -0.33786392f, -0.08792562f, 0.02900628f, -0.02114980f, 0.17086932f, 0.09417550f, 
    -0.13308397f, -0.21864204f, -0.44162613f, -0.08428058f, -0.04124593f, -0.11337233f, 0.25826603f, -0.02108148f, 
    0.20743224f, 0.02847154f, -0.09379052f, 0.03112197f, 0.16144185f, -0.19173972f, -0.01225470f, 0.05085319f, 
    -0.09180292f, 0.00299317f, -0.23086376f, -0.31644061f, 0.00265954f, 0.18036520f, -0.08437485f, 0.15198280f, 
    0.00884924f, 0.04185429f, 0.08450337f, -0.08523735f, -0.02125368f, 0.18232504f, 0.02905386f, -0.08999594f, 
    -0.19988973f, -0.06550587f, -0.01169836f, -0.07536106f, 0.23405288f, 0.09607831f, 0.16008505f, -0.03261700f, 
    -0.13775314f, -0.15112075f, 0.03900753f, -0.03596379f, -0.10280176f, 0.08218125f, 0.08393320f, -0.32374758f, 
    0.20234691f, -0.10107158f, -0.03777307f, -0.09988488f, 0.08919058f, -0.14781059f, -0.05739575f, -0.25472745f, 
    -0.01957057f, 0.04496161f, 0.07535308f, 0.11474073f, 0.09159255f, 0.01419370f, -0.06804246f, 0.20035382f, 
    0.43051752f, 0.29076648f, -0.27566347f, -0.15382893f, -0.01561798f, 0.04020468f, 0.15955818f, -0.00264065f, 
    -0.02682268f, 0.22284138f, -0.32560292f, 0.08829003f, -0.03266611f, -0.03172638f, 0.09593052f, -0.02309916f, 
    0.01475201f, -0.01569079f, 0.37577438f, 0.06584229f, -0.03531324f, -0.27558368f, -0.03556681f, 0.07378064f, 
    -0.08504201f, 0.09122978f, -0.03179574f, -0.23475158f, -0.02747337f, 0.13366902f, 0.07625566f, 0.07916611f, 
    -0.03466844f, -0.04106227f, 0.16648567f, 0.12040798f, -0.02863384f, 0.20109022f, -0.22785194f, -0.20832160f, 
    -0.21638912f, 0.13850713f, -0.12609383f, 0.01758799f, -0.00043971f, 0.32541057f, 0.04443278f, -0.14021617f, 
    -0.11523611f, -0.05469996f, 0.05640545f, 0.00209467f, -0.10743944f, 0.03838877f, 0.03770491f, 0.01974658f, 
    0.17921145f, 0.03380768f, -0.10605367f, -0.00796713f, 0.25280949f, 0.02170495f, -0.04239428f, 0.06478451f, 
    -0.22336335f, -0.02205950f, 0.05146582f, 0.12451077f, 0.02787261f, 0.12056634f, 0.07201749f, 0.00127208f, 
    -0.17628166f, -0.06033414f, 0.00173681f, 0.03946513f, -0.03925742f, 0.10722187f, 0.12938555f, 0.07737563f, 
    -0.13481075f, -0.02660469f, -0.07213160f, 0.12621701f, -0.18656868f, 0.24167530f, 0.01981034f, 0.26346162f, 
    0.04799847f, 0.10922601f, 0.18651311f, -0.24282591f, 0.01944347f, -0.18855304f, 0.11262134f, 0.00748694f, 
    -0.18181017f, 0.12521686f, -0.11336583f, 0.02883088f, 0.03520348f, 0.01282311f, -0.16009551f, 0.13741453f, 
    -0.09696924f, -0.06932169f, -0.21122321f, -0.07853528f, -0.30509269f, 0.04275234f, -0.05704512f, -0.02449065f, 
    -0.00585897f, 0.05206668f, 0.06848497f, -0.00338656f, 0.08227668f, 0.33057562f, -0.03054231f, 0.07657164f, 
    -0.03745731f, 0.13234986f, 0.04622872f, -0.16207467f, -0.07789665f, 0.04758545f, 0.14954178f, -0.34476134f, 
    0.17195913f, 0.02515571f, 0.19961882f, -0.06971045f, 0.14386095f, -0.00357788f, -0.20682463f, -0.01890477f, 
    0.17001921f, -0.00640616f, 0.22544762f, 0.03002792f, 0.01781680f, 0.12571602f, 0.04219433f, 0.02426666f, 
    0.13882071f, -0.08954728f, 0.03622333f, -0.06037966f, -0.01363087f, 0.03468311f, 0.03532954f, 0.11562125f, 
    0.04891548f, 0.27765939f, 0.24958055f, -0.76116651f, 0.06654212f, -0.04846854f, 0.09287059f, -0.10716124f, 
    -0.25741094f, 0.02855851f, 0.19227301f, 0.27719769f, -0.01860545f, -0.12079560f, -0.17358695f, 0.13773462f, 
    -0.09743481f, -0.16876756f, 0.12674528f, -0.03392092f, 0.20068653f, 0.34905544f, -0.26222000f, 0.04065156f, 
    -0.07338500f, 0.05287033f, 0.01629009f, -0.02968893f, -0.02756943f, -0.56860906f, 0.11714127f, 0.08970507f, 
    0.09082006f, 0.08082811f, 0.06751644f, 0.01711373f, -0.21954365f, -0.16559097f, 0.14111073f, -0.22908339f, 
    0.00391469f, 0.07510500f, 0.18061814f, 0.00635115f, -0.06355269f, 0.10850958f, -0.43871170f, -0.05054095f, 
    0.20980254f, 0.04007134f, -0.31648684f, 0.05089678f, 0.10865657f, -0.00188457f, -0.08485454f, 0.23474638f, 
    -0.40884122f, 0.32871899f, 0.04706318f, 0.08122100f, -0.08785731f, -0.05029485f, 0.01969912f, 0.11506920f, 
    -0.05579726f, -0.06343719f, 0.01204100f, 0.00082150f, -0.03093426f, -0.00647916f, -0.05742277f, 0.03526966f, 
    0.04215112f, 0.04614338f, -0.05384620f, 0.00859467f, -0.02344402f, -0.01816157f, -0.03197103f, -0.02477928f, 
    -0.01186013f, -0.05070544f, 0.04544410f, 0.05450768f, 0.04655888f, 0.00835901f, 0.00155853f, -0.07258570f, 
    0.01463785f, 0.04266327f, 0.02961099f, 0.04681434f, -0.03697030f, -0.00464433f, -0.00822031f, 0.03065616f, 
    -0.03439674f, 0.04011104f, -0.01127584f, -0.04013629f, -0.05391759f, 0.03782877f, 0.04197101f, 0.03128534f, 
    -0.02273211f, -0.02628731f, -0.02423753f, -0.02129647f, -0.04501593f, -0.03153420f, 0.02271659f, -0.04984482f, 
    0.02152118f, 0.03141377f, -0.00530065f, 0.02745088f, 0.01187368f, 0.01767449f, -0.03277646f, -0.06143429f, 
    0.03067162f, 0.03105192f, 0.02408424f, -0.03985302f, 0.01863203f, -0.04178701f, 0.04362856f, 0.02135939f, 
    -0.03484984f, 0.01606386f, -0.04123218f, -0.06151029f, -0.02098507f, 0.01911532f, -0.05399762f, -0.00835154f, 
    -0.01130401f, 0.03911581f, -0.00003175f, -0.00044476f, -0.03708572f, -0.05015634f, 0.01372166f, -0.00775371f, 
    0.05138292f, -0.02714323f, -0.04803539f, 0.01385138f, -0.03540771f, 0.04458099f, -0.04148258f, -0.02289618f, 
    0.04549811f, -0.00576678f, 0.00909667f, 0.00546977f, -0.05716739f, 0.04679024f, 0.03414493f, 0.04273264f, 
    0.04955015f, 0.01254720f, -0.04201422f, -0.04891678f, -0.03604046f, 0.00659566f, -0.01055554f, -0.00177210f, 
    0.00022114f, -0.07052171f, 0.03562479f, -0.02112888f, -0.00852385f, -0.00672758f, -0.03712081f, 0.02024528f, 
    0.01057497f, -0.06115227f, 0.01709177f, -0.01104896f, -0.00044705f, -0.00411797f, -0.00798469f, -0.06662770f, 
    0.03931961f, -0.03902802f, -0.00627086f, 0.03940962f, -0.05683703f, -0.02173733f, -0.05797995f, 0.01985056f, 
    0.00391216f, -0.03657857f, -0.02377796f, -0.03247111f, -0.02546918f, 0.03113477f, -0.01825823f, -0.04882685f, 
    -0.03023983f, 0.03181693f, 0.01627355f, -0.01886453f, 0.00878045f, -0.05396543f, 0.01217313f, -0.03902762f, 
    -0.05236582f, 0.03235198f, -0.03823946f, 0.02521010f, -0.03101650f, 0.03541159f, -0.01724996f, 0.04388532f, 
    0.04490858f, -0.02541924f, 0.00804926f, -0.01693255f, 0.03071319f, 0.01109312f, 0.01560719f, -0.02986507f, 
    0.02917279f, -0.02850421f, -0.02004382f, 0.03578944f, 0.03218828f, 0.02713409f, -0.03823851f, 0.01296390f, 
    -0.05050189f, 0.01908403f, -0.04214348f, -0.02834022f, -0.02900611f, 0.03702138f, -0.00114264f, 0.02117894f, 
    0.00387329f, -0.05667309f, 0.00331844f, -0.02166171f, 0.00582923f, 0.01739389f, 0.01132883f, 0.03679444f, 
    -0.01915189f, 0.02196627f, -0.01166520f, -0.05237594f, 0.03730377f, 0.00315648f, -0.00380423f, -0.03602832f, 
    -0.00271325f, -0.02275119f, -0.05282625f, 0.01231597f, 0.03316150f, -0.00447502f, 0.02591464f, 0.02444329f, 
    -0.03658978f, 0.03488617f, 0.04159316f, -0.04357699f, -0.06708608f, 0.02882452f, -0.04937024f, 0.05285549f, 
    0.00350370f, -0.05345149f, 0.04412134f, 0.03880531f, -0.04811359f, -0.02164630f, -0.04672188f, 0.03358089f, 
    -0.00497695f, -0.02701470f, 0.01796933f, -0.02732390f, 0.00620092f, -0.03882769f, -0.00994597f, 0.00969869f, 
    -0.02625936f, -0.03185017f, -0.03424771f, 0.00002845f, -0.04627401f, 0.00261050f, -0.04218639f, 0.01881257f, 
    -0.03183519f, 0.00551828f, -0.02275959f, 0.00888538f, 0.03250739f, -0.00021833f, -0.00401797f, -0.06166676f, 
    -0.00663099f, -0.02388284f, 0.04241291f, 0.03992701f, 0.00341071f, -0.04240519f, 0.02307863f, 0.00225680f, 
    -0.04443324f, -0.05837957f, 0.02258736f, 0.01867543f, 0.02465358f, -0.05455275f, -0.04725181f, 0.00464665f, 
    0.02957762f, 0.02556826f, -0.04333494f, 0.00815470f, 0.05137629f, -0.05074141f, 0.03442029f, 0.03723336f, 
    0.01693765f, -0.03273089f, -0.00075278f, -0.04975884f, 0.04634554f, -0.00926720f, -0.07071479f, -0.00820710f, 
    -0.05278917f, -0.00995995f, -0.01956161f, -0.00244364f, -0.02303471f, -0.01165093f, -0.04160651f, 0.03633473f, 
    0.04297086f, 0.00003164f, 0.05058593f, -0.05921977f, 0.01351580f, -0.03328739f, 0.01224207f, -0.03934837f, 
    0.09514160f, 0.05084796f, 0.14101714f, 0.16030604f, 0.11577742f, 0.02648492f, -0.00002205f, -0.03200933f, 
    -0.00203007f, -0.10018919f, -0.20975088f, -0.29242837f, -0.03468684f, -0.21775866f, 0.28857854f, 0.03235286f, 
    -0.03891255f, -0.13296187f, -0.22764204f, 0.18157795f, -0.34206554f, -0.04028005f, -0.04165519f, -0.00987439f, 
    -0.09310790f, 0.23247068f, 0.03241880f, -0.21129571f, -0.09996089f, -0.13521333f, -0.10238363f, -0.19955358f, 
    0.05942884f, -0.04291683f, -0.09745098f, 0.12532133f, -0.17662790f, -0.07113605f, -0.10534545f, 0.18816189f, 
    0.04148394f, 0.14606160f, -0.12148856f, 0.09675857f, 0.12803994f, -0.13680893f, 0.23378611f, -0.15824823f, 
    -0.00060258f, 0.23774020f, -0.03025129f, -0.14341155f, -0.10787518f, -0.03563928f, -0.18966743f, -0.18535724f, 
    0.08073726f, -0.05427658f, -0.04971874f, 0.00886302f, 0.02468643f, 0.13824549f, -0.35722759f, 0.16105126f, 
    0.00566148f, -0.24619816f, 0.05729565f, 0.27485546f, -0.08352996f, -0.01563915f, -0.00137685f, 0.00553969f, 
    0.30931914f, 0.30382669f, 0.31950927f, -0.14151764f, -0.12113899f, -0.03213119f, 0.06975041f, -0.16722989f, 
    -0.07320940f, 0.25889423f, -0.05248374f, -0.17998137f, -0.10483550f, -0.31398776f, -0.03228893f, -0.04342467f, 
    -0.10514359f, -0.00692549f, 0.43542188f, -0.05986406f, -0.05746057f, -0.16245332f, 0.03057171f, -0.24001519f, 
    -0.05831781f, -0.03473891f, -0.20451157f, -0.24611247f, -0.29013893f, -0.20933941f, -0.00596449f, 0.22695316f, 
    0.01322838f, 0.00468417f, -0.08671674f, 0.12161686f, -0.12112574f, 0.22261359f, -0.23900491f, -0.08037760f, 
    -0.09759980f, 0.02205909f, 0.01899659f, 0.16941491f, 0.13142891f, 0.32749704f, 0.10593190f, 0.03315264f, 
    -0.03985013f, 0.04321335f, -0.01648057f, 0.08963817f, 0.16873014f, -0.05377520f, 0.13159074f, -0.18362707f, 
    0.23049790f, -0.02213761f, 0.20204863f, 0.05359907f, -0.07703794f, -0.05034787f, -0.24138680f, 0.03418554f, 
    -0.10194803f, 0.06185354f, -0.09002210f, -0.01737736f, -0.05046962f, 0.14375778f, 0.00913470f, 0.00310974f, 
    -0.09113750f, 0.14900097f, -0.23685668f, -0.02285325f, -0.06565657f, 0.01251050f, -0.02804024f, 0.03416558f, 
    0.23788711f, 0.08530892f, -0.21464907f, -0.03862344f, -0.10495623f, 0.03866290f, -0.08800735f, 0.17989151f, 
    0.03200768f, -0.00748342f, -0.38986188f, -0.24565837f, 0.07830685f, 0.06968135f, 0.14639139f, 0.08397143f, 
    -0.09341630f, 0.12481459f, -0.10002811f, 0.20943940f, 0.08173801f, 0.00346375f, -0.27282375f, 0.04876427f, 
    0.21150409f, 0.25091439f, 0.13928306f, -0.07850473f, -0.30007032f, 0.13248858f, -0.27748242f, 0.17997697f, 
    -0.09968382f, 0.01774000f, -0.15336071f, 0.10640134f, -0.04639987f, 0.07154486f, 0.05882115f, -0.26037082f, 
    0.00048931f, 0.07738025f, -0.11834559f, -0.06445955f, -0.15073350f, 0.17393956f, 0.50822270f, -0.18064874f, 
    0.03504610f, -0.11245306f, -0.17976913f, 0.10584895f, 0.08622467f, 0.06279301f, -0.05402153f, -0.09648436f, 
    0.39206323f, 0.35382637f, -0.09559873f, -0.06698835f, -0.14997040f, 0.11681598f, -0.06079509f, 0.06910527f, 
    0.03557855f, 0.15223466f, -0.02437906f, 0.09308896f, 0.16545631f, -0.07319815f, 0.03755576f, 0.05004412f, 
    -0.01601131f, 0.37310648f, 0.33880669f, -0.02040461f, -0.05251639f, -0.34507781f, -0.04640634f, -0.07085499f, 
    0.07429855f, 0.11805221f, 0.39549413f, -0.05692556f, -0.12783276f, -0.04646066f, -0.18532674f, 0.04056560f, 
    -0.10047715f, 0.04669583f, -0.02462466f, 0.33844569f, 0.07247357f, 0.06969581f, 0.02210164f, -0.02277100f, 
    0.13394450f, -0.05751837f, 0.08621761f, 0.22931430f, -0.38725203f, -0.09710449f, 0.12828082f, 0.02436759f, 
    0.04117281f, 0.04572437f, 0.09271584f, 0.04803012f, 0.12928440f, -0.16736381f, -0.06383433f, -0.45096520f, 
    0.06644925f, 0.09356500f, 0.05092805f, 0.04890911f, 0.04683397f, -0.08824262f, -0.21816041f, -0.27103460f, 
    0.14524254f, 0.27969015f, 0.07416730f, 0.11866339f, 0.07095935f, 0.03344234f, 0.00745906f, 0.38868806f, 
    -0.21609837f, 0.16363299f, -0.08107004f, 0.03463558f, 0.13275801f, -0.12890014f, 0.07750146f, 0.01597248f, 
    -0.01179589f, -0.06223985f, 0.01316386f, 0.02307623f, -0.02538576f, -0.03017670f, -0.03137252f, 0.00617917f, 
    -0.03558879f, 0.03186483f, -0.01114140f, -0.04192325f, -0.00741644f, -0.04305441f, -0.00592558f, -0.04186232f, 
    -0.05118639f, -0.01504580f, 0.03426171f, 0.01433406f, -0.01313746f, -0.03662515f, -0.02910599f, -0.00761741f, 
    -0.01510998f, -0.00751189f, -0.02280821f, -0.02572172f, -0.00237654f, 0.00150041f, 0.00835022f, -0.01456441f, 
    0.00295690f, 0.01493340f, -0.05297072f, -0.06199915f, -0.03338468f, 0.03351539f, 0.03359058f, -0.02232778f, 
    -0.04856675f, -0.04089179f, 0.04242368f, -0.04259562f, -0.04917198f, -0.06557615f, -0.06060658f, 0.00127946f, 
    0.03170640f, 0.03885865f, -0.01200619f, 0.02099228f, 0.03340631f, 0.03980177f, -0.02236186f, 0.03114140f, 
    -0.01084823f, 0.02377978f, -0.03942759f, 0.01144460f, -0.05646398f, 0.01525765f, -0.05626704f, -0.00152632f, 
    0.04248387f, 0.03731573f, 0.02667622f, 0.00555379f, -0.02432910f, 0.02748830f, -0.05339526f, -0.01934188f, 
    0.00427949f, 0.01034858f, 0.00942565f, -0.04647599f, -0.02409317f, 0.01232710f, 0.01715461f, -0.02954129f, 
    -0.01418100f, 0.01445689f, 0.00814479f, -0.04240671f, -0.00157892f, 0.02632070f, 0.02716660f, -0.05618842f, 
    0.04092098f, -0.01118085f, -0.04337487f, 0.02463064f, -0.04425513f, 0.01597101f, 0.01379582f, -0.00420454f, 
    0.01895501f, 0.02915187f, 0.02685614f, 0.01399271f, -0.01018482f, 0.04644022f, -0.00646246f, 0.01659399f, 
    0.04950619f, -0.06708585f, -0.06621971f, -0.04857787f, -0.06116104f, 0.01166556f, -0.02285098f, 0.01044021f, 
    -0.03454023f, -0.00458417f, -0.03348716f, -0.05694859f, -0.05458884f, -0.06744280f, -0.04764531f, -0.02790076f, 
    0.03076013f, 0.04868256f, -0.04460391f, 0.04967475f, 0.02931584f, -0.03006935f, -0.05193214f, -0.01906053f, 
    0.04713499f, -0.05561443f, 0.04238574f, 0.00577246f, -0.04810024f, -0.05137148f, -0.03013006f, 0.02984263f, 
    -0.02588350f, -0.00158276f, -0.03437344f, -0.02840203f, 0.04453005f, -0.02912229f, 0.01018519f, -0.01546394f, 
    0.00348690f, 0.00500265f, 0.02675450f, -0.02683683f, 0.03148242f, 0.03033420f, -0.04069024f, -0.03926104f, 
    0.01303302f, 0.01959135f, 0.04448577f, -0.01380819f, -0.05674821f, -0.02138588f, 0.02074925f, 0.04538933f, 
    -0.00960900f, 0.03238375f, 0.03955135f, -0.01297927f, 0.03335132f, -0.05371753f, -0.06090694f, 0.00822855f, 
    0.04519075f, -0.05657396f, 0.01282350f, -0.00020805f, 0.00413344f, 0.01260550f, -0.04636483f, -0.00445551f, 
    -0.01423255f, -0.03417393f, -0.03886902f, 0.04274901f, 0.01713894f, -0.05652779f, 0.03071187f, 0.03541706f, 
    -0.00565121f, 0.00213602f, -0.04848491f, 0.00647550f, 0.00336266f, -0.03491359f, -0.00020092f, -0.04479918f, 
    -0.04013529f, -0.04899499f, 0.01589691f, -0.02210910f, -0.04415976f, 0.01281049f, -0.06129962f, 0.02321608f, 
    -0.06146387f, -0.05475011f, -0.01569371f, -0.01268280f, 0.00797400f, 0.04597873f, 0.02869742f, 0.02940392f, 
    -0.02307963f, 0.02278327f, -0.05162731f, -0.05502859f, 0.00005435f, 0.01614223f, 0.01446295f, -0.02898013f, 
    -0.02952976f, 0.05575691f, -0.02249867f, 0.00627971f, -0.04705136f, -0.02987234f, 0.00695542f, 0.04071063f, 
    0.01197477f, -0.05205522f, -0.01267524f, -0.01260342f, 0.00846049f, 0.02883475f, -0.01295683f, -0.00367855f, 
    -0.01163536f, 0.04284800f, 0.00364808f, 0.02922238f, 0.02358443f, -0.03228149f, 0.03423566f, 0.04192130f, 
    0.02192019f, 0.01220579f, 0.02481465f, -0.03705979f, 0.02317828f, -0.01906381f, 0.03433412f, -0.04324645f, 
    -0.05117819f, -0.06328272f, -0.05257303f, 0.04556993f, -0.05318271f, 0.04446198f, -0.05580801f, 0.04513472f, 
    0.02369954f, 0.01601161f, -0.05108649f, -0.06087859f, 0.02075122f, 0.04557111f, 0.00119655f, 0.03273033f, 
    0.01534448f, -0.02202849f, -0.01618613f, -0.00552969f, 0.03161537f, 0.01935337f, 0.04279869f, 0.03566893f, 
    0.01500028f, -0.02412998f, -0.05019479f, -0.04094388f, -0.04681334f, -0.01326908f, 0.01110360f, 0.00258433f, 
    -0.01346630f, 0.04050931f, -0.06010582f, 0.04604433f, -0.03775113f, 0.00790235f, -0.05893377f, -0.01469209f, 
    0.05083879f, 0.02074283f, -0.37079000f, 0.03942062f, -0.02957716f, -0.09182915f, 0.27089775f, -0.11537100f, 
    -0.08186559f, -0.36314955f, -0.65917689f, 0.00394002f, -0.15834908f, 0.29354563f, 0.15520786f, 0.17933741f, 
    -0.00804313f, -0.24178793f, -0.01232723f, -0.00416519f, 0.07136982f, 0.02616861f, 0.00633487f, 0.26248363f, 
    0.07890467f, 0.15365224f, 0.05249611f, -0.06902452f, 0.20172901f, 0.09528710f, 0.02701168f, -0.11287958f, 
    0.06350908f, -0.01261394f, 0.10050770f, 0.04017982f, 0.02860435f, 0.04956505f, -0.01644221f, -0.00048502f, 
    -0.03471939f, -0.12199986f, 0.12886569f, 0.15203798f, -0.00089180f, 0.15281598f, -0.06884994f, 0.11081491f, 
    -0.03992203f, -0.15730977f, 0.24762256f, -0.16245371f, 0.28070077f, 0.27098057f, -0.11763404f, -0.02753341f, 
    0.07569303f, 0.09792452f, -0.04164011f, -0.02118688f, -0.08538313f, 0.10557049f, -0.00533532f, 0.15050942f, 
    -0.25174490f, 0.14682971f, 0.00276561f, 0.22041477f, 0.21555123f, -0.18225469f, -0.05774636f, 0.05945987f, 
    -0.05536804f, 0.12916592f, -0.39527148f, 0.03598096f, -0.05667399f, -0.22696272f, 0.06020958f, -0.05207035f, 
    -0.00292714f, -0.78612626f, -0.28198785f, -0.00110946f, 0.13923231f, 0.13610111f, 0.02321993f, 0.13264705f, 
    0.00824009f, -0.05768301f, 0.11555400f, 0.00818414f, -0.18417801f, -0.16556615f, -0.04846459f, -0.13935797f, 
    0.51348788f, -0.09369318f, 0.18515040f, -0.16448013f, -0.15984848f, 0.06164132f, 0.14546840f, 0.14689825f, 
    -0.01142926f, 0.12980837f, 0.27978766f, -0.10691090f, -0.16720977f, 0.06267260f, -0.11056766f, -0.02121102f, 
    -0.13221107f, -0.13903552f, -0.13449667f, 0.30935547f, 0.16143729f, -0.00236840f, -0.01206810f, -0.09537900f, 
    -0.07807855f, -0.24631704f, 0.04748268f, -0.00332737f, 0.08610234f, 0.21498436f, -0.23826568f, -0.10256070f, 
    0.19108815f, -0.10786367f, 0.12048929f, 0.27642778f, -0.17625044f, -0.11776420f, 0.08346187f, -0.23954490f, 
    -0.20401499f, -0.02230248f, 0.13893707f, 0.14923044f, -0.09188228f, 0.22311807f, 0.04799855f, -0.27334008f, 
    0.06893811f, 0.02462038f, 0.16392078f, -0.01135357f, -0.12424868f, -0.05900296f, 0.17988822f, 0.14409071f, 
    0.08716452f, -0.36139703f, -0.30694810f, 0.13784871f, 0.18754198f, 0.05511855f, 0.10742151f, 0.08140350f, 
    0.08562772f, -0.00585672f, -0.26252556f, -0.07124065f, 0.19466217f, 0.06416664f, -0.00606334f, 0.03609966f, 
    0.10026566f, 0.23992859f, -0.20545928f, -0.15337506f, -0.13463192f, -0.17602307f, -0.26503950f, 0.09979267f, 
    0.12047511f, -0.09683108f, 0.20879783f, 0.01866373f, -0.08424403f, -0.25542271f, -0.27447996f, -0.04437112f, 
    0.22190671f, -0.31324404f, -0.13147476f, -0.11908406f, 0.15283817f, -0.56627452f, -0.09672210f, 0.08480563f, 
    0.28990468f, 0.15663974f, -0.05875424f, 0.09084056f, -0.02472044f, 0.16081148f, -0.44757059f, -0.33063728f, 
    0.13714519f, -0.01700154f, 0.01988757f, 0.10147657f, 0.02339734f, -0.10724017f, -0.12398343f, 0.05779489f, 
    0.25099939f, -0.12171783f, 0.06833255f, -0.11644901f, -0.23727816f, 0.05086643f, 0.08484716f, 0.06339009f, 
    -0.03411011f, 0.06350347f, -0.25824568f, 0.23906711f, -0.05463893f, -0.19420716f, 0.00769535f, -0.03039945f, 
    0.06749185f, 0.06673846f, -0.14449824f, -0.26654309f, 0.04883821f, 0.05307708f, -0.08822465f, 0.07462981f, 
    -0.02149510f, 0.22117835f, -0.13810210f, 0.02423863f, -0.11632718f, 0.11523582f, 0.13641937f, 0.05185069f, 
    -0.11131613f, 0.08092078f, 0.16365124f, 0.08270755f, 0.17501734f, 0.38773265f, -0.09653507f, -0.07011893f, 
    -0.37491441f, 0.01779265f, 0.19027776f, 0.08568801f, -0.05584216f, -0.07854550f, 0.17970005f, 0.07904704f, 
    0.09601874f, -0.17040631f, -0.05342445f, 0.17737257f, 0.21790019f, -0.08683380f, -0.21152605f, -0.02020360f, 
    0.04790102f, 0.06208082f, 0.25987706f, -0.07778206f, -0.11962321f, -0.17073031f, -0.11689199f, 0.03227710f, 
    0.28948620f, -0.01820818f, 0.21364768f, 0.13322100f, 0.01157898f, -0.07802422f, 0.11800708f, -0.20119087f, 
    -0.09473143f, 0.07855855f, -0.00667308f, 0.09322871f, 0.15120350f, 0.04270052f, 0.07575615f, -0.35707939f, 
    0.32935473f, 0.15938517f, 0.01035626f, 0.07398555f, 0.12153917f, -0.21822539f, 0.25125906f, -0.04403485f, 
    -0.04198283f, 0.17195964f, 0.29241449f, -0.02050643f, 0.16304338f, -0.08681925f, -0.15870678f, -0.07013556f, 
    -0.13186404f, 0.09502696f, -0.26375037f, -0.05920888f, 0.25259027f, 0.07129855f, -0.05253713f, -0.03842846f, 
    -0.00379399f, -0.26514766f, 0.06824149f, -0.04032056f, -0.08302344f, 0.04843830f, 0.16016370f, -0.17420000f, 
    -0.00843939f, -0.17681876f, 0.13427252f, 0.07317124f, 0.04829330f, -0.00062819f, -0.02739589f, -0.11706289f, 
    -0.09963568f, 0.03222331f, 0.13829683f, 0.19361745f, 0.07435163f, -0.42268264f, -0.38752347f, -0.10897083f, 
    0.02787844f, 0.12750410f, 0.32056120f, -0.15298405f, -0.07564981f, -0.22000012f, 0.32831231f, 0.21073496f, 
    -0.24834071f, -0.06497714f, 0.00662570f, 0.19068038f, 0.09553578f, -0.04467648f, -0.28125292f, -0.22686419f, 
    -0.16111782f, -0.00800722f, -0.13219510f, 0.05532458f, 0.15817866f, -0.27960846f, 0.02250079f, -0.04090419f, 
    0.24569106f, 0.28901434f, 0.04535058f, 0.07218493f, 0.17766330f, -0.14401318f, 0.13153291f, 0.08177038f, 
    -0.06208299f, 0.05556366f, 0.39762780f, 0.10604423f, -0.00779816f, -0.16573128f, -0.12901580f, 0.07304057f, 
    -0.04793548f, 0.17039308f, 0.07039782f, -0.15168886f, -0.02329485f, 0.07887493f, 0.07873887f, 0.01747943f, 
    0.19444981f, 0.02902251f, -0.11621113f, -0.05429576f, 0.06792557f, -0.10849775f, -0.13984279f, 0.04826822f, 
    0.07868075f, -0.03086451f, -0.14783064f, -0.04175905f, -0.45563707f, -0.25950208f, -0.20120126f, 0.20084077f, 
    -0.05072672f, -0.11672646f, -0.05854404f, -0.04767666f, -0.04644273f, 0.19879833f, -0.07562842f, 0.08627072f, 
    -0.09033275f, -0.09501690f, -0.35753757f, 0.15125664f, -0.03276706f, -0.09216930f, 0.13827965f, -0.42462915f, 
    -0.13168037f, -0.00136493f, -0.04784996f, 0.20838742f, -0.06105053f, -0.31346020f, -0.17224513f, 0.06287010f, 
    0.27380362f, -0.00457532f, 0.11665618f, -0.18130867f, 0.11557879f, -0.01873049f, 0.06844968f, -0.01519653f, 
    -0.08910109f, -0.14026858f, 0.21567328f, 0.10824165f, -0.04207444f, -0.01337222f, -0.08895065f, -0.08454658f, 
    0.17102587f, -0.27259368f, -0.01226249f, -0.07587793f, -0.04035787f, 0.03966882f, 0.01221554f, 0.04149400f, 
    0.24076329f, -0.08519371f, -0.02418103f, -0.13419497f, -0.03766908f, -0.08534931f, -0.07915127f, 0.15805344f, 
    -0.25507465f, -0.05359851f, 0.07834274f, -0.10552084f, 0.14555293f, 0.01881389f, -0.08664723f, -0.10614870f, 
    -0.20571063f, -0.08446881f, 0.11339286f, -0.03427919f, 0.23500988f, -0.05439835f, -0.08149449f, 0.21773435f, 
    0.18258177f, -0.02952606f, -0.05830418f, -0.09651901f, 0.04998276f, -0.00024294f, 0.57791460f, -0.00307730f, 
    0.05631412f, -0.06665660f, 0.20328678f, 0.00315967f, 0.01193898f, -0.08136043f, -0.00047874f, 0.22824828f, 
    0.09111148f, -0.08694934f, -0.15061967f, 0.01175319f, -0.02755677f, -0.04180829f, 0.04711023f, -0.05759897f, 
    -0.03946512f, 0.12751488f, -0.03074214f, 0.04138130f, -0.06415979f, 0.04164872f, 0.04071018f, -0.06465185f, 
    0.42688072f, 0.35790384f, 0.17902832f, 0.24539404f, 0.29155678f, -0.18447249f, 0.21371830f, 0.12597603f, 
    -0.02653618f, -0.25657901f, 0.22367799f, 0.09571789f, 0.02161947f, -0.06341450f, -0.18112642f, 0.01906777f, 
    -0.07683451f, 0.00760237f, 0.19557273f, -0.11364121f, -0.06496879f, 0.01539942f, -0.30404872f, -0.23066406f, 
    0.13219412f, -0.04672965f, 0.06582312f, -0.13976388f, 0.04013348f, -0.17009039f, -0.03534473f, -0.09118465f, 
    -0.07940779f, 0.06480899f, 0.08768033f, 0.10997785f, 0.33280694f, 0.15123770f, -0.01760477f, -0.07350345f, 
    -0.03225780f, -0.17609592f, 0.30496681f, 0.02257480f, 0.04185861f, -0.15128990f, 0.02783001f, 0.19864669f, 
    -0.01553133f, 0.01352778f, 0.15123662f, -0.13190728f, -0.08987265f, -0.09914794f, 0.32085139f, -0.19504343f, 
    -0.04631171f, 0.12054235f, -0.03777647f, 0.12193379f, 0.06304297f, -0.16563523f, -0.08615513f, 0.17027235f, 
    0.08257154f, -0.17735171f, 0.10272427f, 0.05966048f, -0.07848060f, 0.09364881f, 0.00486040f, -0.42918214f, 
    0.02657624f, 0.12308850f, -0.20955555f, 0.00846240f, -0.01776715f, -0.01479706f, 0.05162730f, -0.14516695f, 
    0.00307301f, -0.49280980f, -0.37178156f, 0.11935219f, -0.26378760f, 0.22264230f, 0.13019586f, 0.24676119f, 
    -0.07083865f, 0.10311555f, 0.06012588f, 0.05571232f, 0.23155238f, -0.08557497f, 0.15079883f, -0.12299610f, 
    -0.30445188f, -0.05219789f, 0.08555037f, -0.01463261f, 0.20107029f, 0.07090573f, -0.11149345f, 0.04187595f, 
    0.17932481f, -0.03446521f, -0.04001281f, -0.02630583f, -0.05195265f, 0.08250533f, -0.02367747f, 0.00021939f, 
    0.11467575f, -0.20784056f, -0.02876431f, 0.10033262f, -0.15149763f, 0.16578709f, 0.38632435f, -0.14749652f, 
    -0.14724167f, -0.03838489f, -0.06527556f, -0.05339304f, 0.02850636f, 0.06559584f, 0.35927308f, -0.22124450f, 
    0.11263868f, 0.23179232f, -0.03588236f, -0.16651033f, -0.02195880f, -0.01458741f, 0.09196644f, 0.32718116f, 
    0.07344513f, -0.31482503f, 0.00163152f, -0.01048172f, 0.03814432f, 0.12040731f, 0.22821999f, 0.19875552f, 
    0.29479554f, 0.10526223f, -0.16039298f, 0.17615953f, -0.04149226f, -0.12339476f, -0.04975988f, -0.06309068f, 
    -0.05939414f, -0.53764635f, -0.03203540f, -0.26503229f, -0.08162587f, 0.25652978f, -0.09442036f, -0.13601926f, 
    0.01735363f, -0.16458584f, 0.68310875f, -0.05261496f, -0.08409071f, 0.07509399f, 0.12715968f, 0.05654860f, 
    0.01810438f, 0.24786951f, -0.11413491f, -0.13006847f, -0.06176462f, -0.05511534f, -0.10435135f, 0.08375154f, 
    -0.16485623f, -0.10062239f, 0.00182919f, -0.02442133f, -0.00617684f, -0.00319590f, -0.08891109f, -0.03792458f, 
    -0.03988706f, -0.11935068f, -0.23690912f, -0.19469753f, 0.04503548f, -0.39215976f, -0.12148671f, -0.07168739f, 
    0.09075874f, -0.03703893f, -0.03954917f, 0.06593278f, -0.01963581f, 0.01775474f, 0.05203947f, 0.11212517f, 
    0.24273954f, 0.15990229f, -0.05399937f, 0.03013275f, -0.17374565f, 0.00564492f, 0.18391828f, -0.39964786f, 
    -0.18299846f, 0.19381054f, 0.03535049f, 0.10943603f, -0.14709900f, 0.01218845f, 0.01524260f, 0.06391149f, 
    0.28323355f, 0.00543847f, 0.03431543f, -0.12976280f, 0.13991393f, 0.09970797f, -0.14948498f, 0.02566073f, 
    0.06217448f, -0.11223012f, 0.14232668f, -0.33992356f, 0.07358261f, 0.00087116f, -0.00032121f, 0.00139511f, 
    0.08833168f, -0.00205377f, -0.45810798f, -0.03929244f, 0.27738032f, 0.02944453f, 0.12784378f, -0.24070270f, 
    -0.04117512f, 0.07343787f, -0.04763667f, -0.03397679f, -0.16559130f, 0.30882606f, -0.21590623f, -0.06214133f, 
    0.04971609f, -0.08649952f, -0.10772961f, -0.16382948f, 0.03802943f, -0.30115482f, -0.15216979f, -0.26087001f, 
    0.04762192f, -0.27131259f, 0.04884720f, 0.07418527f, 0.04560707f, -0.23993208f, 0.10468851f, -0.65823394f, 
    -0.09538729f, 0.18652163f, 0.06263380f, -0.01203857f, 0.18213193f, -0.18915583f, 0.03943887f, -0.18714322f, 
    -0.35147539f, -0.01260854f, 0.08400764f, -0.14192705f, -0.24525374f, 0.08817466f, -0.35031095f, 0.19292675f, 
    0.23577534f, 0.13945299f, 0.21057692f, 0.17207977f, 0.11946492f, -0.04678032f, 0.11478830f, 0.07032351f, 
    0.53269678f, 0.20942935f, -0.60728085f, -0.04291419f, 0.09468736f, 0.08200924f, -0.11848370f, -0.08629373f, 
    0.04480488f, 0.86126971f, -0.27116713f, -0.18825933f, 0.03821504f, -0.07175905f, -0.07190683f, 0.00051246f, 
    0.12238009f, -0.13406692f, -0.21636072f, 0.12871464f, 0.19961372f, 0.13971254f, 0.08619662f, 0.01329684f, 
    0.02189379f, 0.25319636f, 0.01242279f, 0.32681358f, -0.41862106f, 0.30454811f, -0.03678888f, 0.11014272f, 
    -0.05229000f, -0.09966543f, -0.07678752f, 0.14776942f, 0.28838021f, -0.27414137f, -0.27243632f, -0.07294243f, 
    0.11419771f, 0.15606520f, 0.13026717f, 0.30158415f, 0.14287128f, 0.37836340f, -0.37213773f, -0.15612510f, 
    -0.25116277f, 0.00492965f, 0.09500879f, -0.08620001f, -0.02289337f, -0.19571348f, -0.00083187f, 0.19681591f, 
    -0.24720111f, 0.15651621f, -0.04758678f, -0.09378818f, 0.02831505f, 0.07572924f, 0.08539306f, -0.23297742f, 
    0.28063610f, -0.02874115f, 0.18828262f, 0.20547701f, -0.15382208f, 0.02205483f, 0.13729332f, -0.07390375f, 
    0.12980540f, 0.02600198f, -0.02740386f, -0.07725540f, 0.12021284f, -0.02434770f, 0.15096350f, 0.04416247f, 
    -0.10496970f, -0.16439538f, -0.00136068f, -0.02730838f, 0.12756203f, 0.07231493f, 0.17208707f, -0.01598275f, 
    -0.03419104f, 0.14232105f, -0.26932546f, -0.12933998f, -0.33649033f, 0.03814396f, 0.15226910f, 0.04547541f, 
    -0.12558486f, 0.09531893f, -0.03884460f, -0.34954646f, -0.16864675f, -0.03390248f, 0.06630411f, -0.13131851f, 
    0.04422496f, 0.07520315f, -0.05664665f, 0.03282709f, -0.21616422f, -0.12019265f, -0.05353547f, 0.19935583f, 
    -0.00631430f, 0.03426315f, -0.07229692f, -0.01490394f, 0.26677930f, 0.24357648f, 0.33477512f, -0.06237184f, 
    0.03129619f, 0.00394066f, 0.06899658f, -0.19139367f, -0.15932930f, 0.00570242f, -0.26721290f, 0.16984358f, 
    -0.02553253f, 0.11163530f, -0.02538251f, -0.05057826f, 0.11923894f, 0.07349139f, -0.01221528f, 0.32284904f, 
    0.27448681f, -0.07826300f, 0.08100197f, 0.10711219f, 0.14126278f, -0.07006150f, -0.03139667f, -0.00671933f, 
    0.42880654f, 0.05714891f, -0.03959861f, -0.22532743f, 0.04261938f, -0.23262186f, 0.27288619f, -0.00430829f, 
    -0.11349523f, 0.09487933f, 0.09635746f, 0.09933428f, 0.11325063f, 0.15504493f, 0.07677042f, -0.16946827f, 
    0.02572594f, -0.01111987f, -0.02218320f, -0.34584564f, -0.17368101f, -0.05973038f, -0.00168988f, -0.06548401f, 
    0.10780637f, 0.07057582f, -0.18326123f, -0.03452235f, -0.00297516f, -0.22969772f, -0.18810296f, 0.16417740f, 
    0.18310210f, 0.02089982f, 0.17688647f, 0.02239988f, -0.12356436f, -0.40527546f, -0.17163622f, 0.09665459f, 
    -0.12965386f, 0.07212355f, -0.07757782f, -0.16064286f, 0.00660167f, 0.31256863f, 0.06160976f, 0.11821847f, 
    -0.14746526f, -0.16407487f, 0.08914609f, -0.02559987f, 0.19139291f, 0.05653286f, 0.01262931f, 0.21210530f, 
    0.01598761f, 0.17775393f, -0.11943829f, 0.34286729f, -0.00870217f, -0.09519854f, 0.04653849f, 0.20589826f, 
    0.07127611f, -0.12259880f, -0.06711274f, 0.06132634f, 0.06287210f, 0.12467614f, -0.20702836f, -0.20186934f, 
    -0.62665349f, -0.04855001f, 0.13146956f, 0.23280782f, -0.07693502f, -0.06853554f, -0.13437748f, -0.12806611f, 
    0.23457924f, 0.09409139f, -0.08838274f, -0.09070832f, -0.20838411f, 0.02999146f, -0.01067295f, 0.14948873f, 
    -0.03563545f, 0.24413826f, -0.32562116f, -0.38923883f, -0.08685509f, 0.22017618f, 0.18984012f, 0.26691791f, 
    -0.20219620f, -0.19022757f, -0.11573669f, 0.09854765f, 0.23453739f, -0.01513394f, -0.08155020f, 0.13049379f, 
    -0.01344883f, -0.03822861f, -0.13499656f, -0.07833619f, 0.03112461f, -0.27217850f, -0.05433998f, 0.12207276f, 
    -0.18758082f, -0.11822121f, 0.17108062f, 0.01183938f, -0.05159791f, 0.07086536f, 0.20813499f, -0.11345609f, 
    0.00727509f, 0.23734544f, 0.15428144f, -0.15138252f, 0.10931102f, 0.12929821f, 0.37188694f, -0.01074166f, 
    -0.04844216f, 0.08338332f, -0.12811203f, 0.11580622f, -0.09233280f, -0.04421282f, -0.18006653f, 0.22857994f, 
    0.39256680f, 0.16660574f, -0.05004601f, -0.09067570f, 0.02803466f, 0.18662646f, 0.01939087f, 0.10030381f, 
    0.21587063f, 0.34999892f, -0.09797638f, -0.17156646f, 0.10036572f, -0.31023592f, -0.06205823f, 0.14749190f, 
    -0.06291349f, 0.16372697f, -0.07918298f, -0.19860716f, -0.17237905f, 0.15430355f, -0.08625464f, -0.00623781f, 
    -0.07358029f, 0.20796549f, -0.30668503f, -0.27013320f, -0.01210097f, -0.07953008f, 0.05251523f, -0.13367204f, 
    -0.06542705f, -0.24239488f, 0.29499698f, -0.02533357f, -0.26529610f, -0.28050324f, 0.12689592f, -0.02039051f, 
    -0.01184747f, 0.14834955f, 0.02151027f, 0.07564478f, -0.57025468f, -0.13975488f, 0.06619363f, 0.28837845f, 
    0.19826113f, 0.12789385f, 0.11042595f, 0.05293175f, 0.10525876f, -0.06363443f, -0.17723684f, -0.40405709f, 
    0.20843527f, 0.14732282f, 0.07597198f, -0.02506090f, 0.11804315f, 0.17388928f, -0.13575156f, -0.14188099f, 
    0.07874699f, 0.05120540f, 0.15205984f, 0.21750908f, 0.08438633f, -0.02550412f, 0.07634665f, 0.21462151f, 
    -0.32128656f, 0.00762246f, 0.21884705f, 0.07698970f, 0.15831999f, 0.07676329f, -0.06324897f, -0.04281254f, 
    0.21161561f, -0.07975619f, -0.03800871f, -0.03002513f, 0.01683066f, 0.14151557f, 0.03119614f, 0.24361072f, 
    0.07343336f, 0.27887657f, -0.02359446f, 0.12119303f, 0.01386459f, -0.14576812f, 0.04075549f, 0.01084371f, 
    0.17515993f, -0.16187386f, -0.69446039f, 0.08130768f, 0.15805383f, -0.03066833f, 0.16758361f, 0.17588183f, 
    -0.06100386f, 0.09950586f, -0.12434802f, -0.55292088f, -0.13907839f, -0.07289028f, -0.00181829f, 0.15242338f, 
    0.00355938f, -0.13291669f, -0.07611623f, -0.09022089f, -0.13381577f, -0.09801914f, -0.14270525f, 0.32983580f, 
    0.04764650f, 0.11076209f, 0.02774881f, 0.28045303f, -0.03510881f, -0.41457012f, 0.38188234f, 0.03988909f, 
    0.33178118f, 0.16920345f, -0.02063567f, -0.14151378f, -0.18825506f, -0.09497256f, -0.07374126f, 0.15186341f, 
    0.04601039f, -0.07817195f, 0.00324672f, -0.24917041f, 0.00916997f, 0.00936847f, -0.08932418f, 0.41669556f, 
    0.29719666f, 0.20288390f, 0.05216365f, -0.02943878f, -0.14594419f, -0.06821673f, -0.23042901f, -0.00466487f, 
    0.28360492f, 0.05099816f, -0.05536908f, -0.02807287f, 0.04358785f, 0.06933928f, -0.05417667f, 0.10860620f, 
    0.21016851f, 0.17815073f, -0.11475668f, 0.27132881f, -0.26107463f, -0.31885350f, 0.20164254f, -0.03181116f, 
    0.07361678f, -0.02614108f, 0.39695433f, 0.06629880f, -0.12351275f, -0.13777851f, 0.13117830f, 0.10102460f, 
    -0.20771195f, 0.22436999f, 0.22973675f, 0.19288220f, 0.16014774f, -0.05360212f, -0.04662521f, -0.10783869f, 
    -0.17538530f, -0.15513837f, -0.04033899f, 0.00718683f, -0.61291569f, 0.11194550f, 0.01255539f, 0.00931398f, 
    0.18779933f, 0.17746721f, -0.10864995f, -0.25189179f, 0.00048652f, 0.12191562f, 0.07458740f, -0.06213973f, 
    -0.14610061f, 0.29937875f, -0.00386388f, 0.10852161f, -0.07176483f, 0.11465900f, -0.30953455f, -0.03752946f, 
    -0.07659655f, 0.03334664f, 0.15632133f, -0.09360860f, -0.17572322f, 0.34479272f, 0.04496456f, 0.42798486f, 
    0.17144866f, 0.07707410f, -0.15215786f, -0.03267153f, 0.22359501f, -0.07390282f, 0.00633731f, -0.09106921f, 
    -0.34734219f, -0.04755942f, 0.22124621f, -0.01392749f, 0.14208806f, 0.03440605f, 0.02001433f, -0.02942120f, 
    -0.06009704f, 0.18411480f, -0.03472299f, -0.33137158f, 0.06835822f, -0.24479903f, -0.18105972f, 0.07579295f, 
    0.02969282f, -0.10355466f, 0.33956143f, 0.17486304f, -0.05075872f, 0.20475386f, 0.04393351f, 0.04658883f, 
    0.04461401f, -0.17335929f, 0.02157693f, 0.08726523f, -0.00135536f, 0.05206371f, -0.26961288f, -0.13898577f, 
    -0.10103054f, 0.10051854f, -0.21863164f, 0.05177929f, -0.25573537f, 0.05505817f, -0.11766537f, -0.05954674f, 
    -0.05623630f, -0.01355692f, -0.10345785f, 0.00463017f, 0.05840947f, 0.11737225f, -0.18503542f, 0.32421929f, 
    -0.28966343f, -0.17397125f, 0.01931654f, -0.19541487f, -0.12329278f, -0.05712383f, 0.20504253f, 0.04212096f, 
    0.32906151f, 0.00263481f, -0.09188811f, -0.05869646f, 0.00548103f, 0.04737483f, -0.01445425f, 0.36239466f, 
    -0.02754069f, -0.15815449f, -0.11352275f, 0.17509399f, 0.03984598f, 0.03475012f, 0.06297170f, -0.09137145f, 
    0.28062308f, -0.03931335f, 0.29121950f, -0.00530458f, 0.08336923f, 0.20949656f, -0.17266370f, -0.05894527f, 
    -0.01684548f, -0.15631267f, 0.20005666f, -0.08611391f, -0.12812424f, 0.02356383f, -0.03372464f, 0.12456997f, 
    -0.06012242f, 0.08167395f, -0.45214719f, -0.18666829f, 0.02883428f, -0.09071911f, -0.05024096f, 0.08853296f, 
    0.20753436f, 0.17873828f, 0.00525813f, -0.11080145f, 0.20202048f, -0.20087583f, 0.03233289f, 0.10312071f, 
    -0.08721999f, -0.02692531f, 0.10007682f, -0.07874795f, 0.14789952f, 0.19188604f, -0.27616492f, 0.02799024f, 
    -0.02304911f, -0.08608922f, -0.04999663f, 0.15076461f, 0.07368608f, 0.46491709f, 0.29151338f, -0.21744575f, 
    0.10973367f, -0.08972955f, 0.09007155f, 0.11050930f, 0.01742703f, 0.03463980f, -0.20012946f, 0.16533478f, 
    -0.08593715f, -0.03715193f, 0.04849783f, -0.15260284f, -0.17583424f, 0.13932864f, 0.08287673f, -0.06051430f, 
    -0.04444288f, 0.28344390f, 0.11439929f, -0.09961295f, -0.08041450f, 0.02694757f, 0.02729369f, 0.04143105f, 
    0.26549506f, -0.04812172f, -0.28752097f, 0.05332057f, 0.09445254f, -0.03246229f, 0.11203258f, -0.03501333f, 
    -0.00286974f, 0.01322413f, -0.20905130f, -0.28252003f, -0.02993163f, -0.02232667f, 0.09056541f, 0.04614162f, 
    0.02154783f, -0.13820268f, 0.38504645f, 0.06769864f, 0.06748979f, 0.02604609f, -0.09287874f, 0.08279968f, 
    0.09362144f, 0.10072035f, -0.11257913f, 0.40074950f, 0.07393052f, 0.39892983f, -0.01004576f, 0.12952094f, 
    -0.08030764f, 0.00851577f, 0.18678802f, -0.06541726f, 0.07787328f, 0.20528948f, 0.03527821f, 0.04940407f, 
    0.08918910f, 0.01813344f, -0.01275232f, -0.00951318f, -0.03000048f, 0.24816993f, 0.07788796f, 0.00114705f, 
    0.10911176f, 0.04770209f, -0.03385617f, -0.10638423f, -0.00469145f, 0.12016331f, -0.52386212f, -0.22046579f, 
    -0.28712398f, -0.08434804f, 0.31090379f, -0.17381027f, 0.12784335f, -0.18379517f, -0.11663511f, -0.43785983f, 
    0.14144042f, -0.05592404f, -0.06452940f, -0.13529998f, 0.03510781f, -0.14891435f, -0.10280512f, 0.05435954f, 
    0.12903297f, 0.06878421f, -0.22888979f, 0.02771168f, -0.06768934f, 0.09729084f, 0.13539779f, 0.02943543f, 
    0.00490316f, 0.35928142f, 0.09209074f, 0.01609089f, -0.06999008f, 0.02863803f, 0.02011470f, -0.04228690f, 
    0.00882974f, 0.06416983f, 0.09917857f, -0.32074574f, -0.23282662f, -0.13932513f, -0.18971479f, -0.04042595f, 
    -0.27264014f, 0.03996062f, 0.00112277f, -0.39849272f, 0.15130639f, -0.47229943f, -0.02778728f, 0.00675215f, 
    0.04684344f, 0.03967745f, 0.19515111f, -0.02155392f, 0.43357578f, 0.44829991f, -0.05839902f, -0.06269407f, 
    0.24472979f, 0.08993427f, 0.09219452f, 0.01187543f, 0.04821395f, -0.03326186f, -0.00823308f, -0.10016178f, 
    0.02718806f, -0.00583758f, -0.02956520f, -0.11393555f, -0.04373083f, 0.06933682f, 0.36793092f, -0.16062452f, 
    -0.11211776f, 0.08822113f, -0.05225886f, -0.05306619f, 0.14392462f, -0.14224243f, 0.17724396f, -0.19207869f, 
    0.33983815f, -0.44876316f, -0.00555311f, 0.13701771f, -0.18559535f, 0.01472697f, 0.01206923f, 0.03555814f, 
    -0.13946240f, 0.18835160f, -0.08206946f, 0.10279138f, -0.14640212f, 0.03692285f, -0.06595120f, 0.10637777f, 
    0.15271446f, -0.30231026f, -0.14117284f, 0.25930172f, -0.08455686f, 0.19361290f, 0.08839387f, -0.12424452f, 
    0.12320053f, -0.08489142f, 0.03048345f, -0.13960782f, -0.28735319f, 0.07983556f, 0.13400845f, 0.21969637f, 
    0.02674387f, 0.01824121f, 0.05311617f, -0.28296643f, 0.02249875f, -0.10005073f, 0.01239054f, 0.07588776f, 
    -0.01053450f, -0.03426682f, -0.26889116f, 0.16361025f, 0.04800805f, -0.11462651f, -0.16977824f, -0.01847582f, 
    0.11915877f, 0.35260347f, 0.06363948f, -0.07899866f, 0.05122120f, 0.25269273f, 0.29337978f, -0.19493142f, 
    0.12432110f, -0.03836386f, 0.07293513f, -0.12964422f, -0.17138486f, 0.09810361f, 0.04804490f, 0.20000473f, 
    -0.03801465f, -0.06593755f, 0.23316735f, 0.02706950f, -0.01747786f, 0.07194986f, -0.11816590f, -0.51855659f, 
    0.00781361f, -0.00088618f, -0.11747558f, -0.10009249f, 0.07825449f, 0.15423492f, -0.13328879f, 0.09352189f, 
    0.09180738f, -0.08067867f, 0.00645314f, -0.03017130f, 0.11776215f, -0.06796043f, 0.10432173f, -0.01215317f, 
    -0.05944184f, -0.33111134f, 0.21287486f, -0.60988843f, 0.10305482f, 0.03514637f, -0.09052135f, 0.01379806f, 
    -0.18911749f, -0.24845941f, 0.38586411f, 0.13139041f, 0.09020640f, -0.09603433f, -0.10881241f, -0.09650038f, 
    -0.02317883f, -0.03912210f, 0.09586386f, -0.04656827f, 0.15442494f, 0.23671858f, -0.17584375f, 0.05669821f, 
    -0.06103897f, 0.07645608f, 0.10758267f, 0.11168736f, -0.24545062f, -0.35633600f, -0.14019896f, -0.05496981f, 
    0.05885042f, -0.14507280f, -0.06969303f, -0.00801222f, 0.03920408f, 0.18918256f, 0.09610289f, -0.26465470f, 
    -0.17478567f, 0.05110913f, 0.07962701f, -0.05858077f, 0.01954206f, 0.10417511f, -0.19680746f, -0.12205672f, 
    0.24270707f, -0.04792767f, 0.09231932f, -0.01608773f, 0.16009712f, -0.01034706f, 0.24380380f, 0.21067744f, 
    -0.36144298f, 0.01269273f, -0.13041788f, 0.16097821f, 0.13491660f, 0.10163655f, -0.04997921f, 0.07606665f, 
    -0.11759716f, -0.08350547f, 0.08947740f, -0.17720526f, -0.16372718f, -0.11147582f, -0.02282649f, -0.12350939f, 
    0.09607309f, -0.35479328f, 0.16220580f, -0.14381929f, -0.09620305f, -0.15256703f, 0.02435055f, 0.03878404f, 
    0.06686189f, 0.14571387f, 0.16494334f, -0.05706529f, -0.07189994f, 0.11807393f, 0.25425652f, 0.00209543f, 
    -0.03796044f, -0.00983158f, 0.08783860f, 0.32151601f, -0.37404788f, -0.05782304f, 0.16334002f, -0.03992360f, 
    0.04276175f, 0.08270784f, 0.23978144f, 0.03792875f, 0.02745403f, -0.18970849f, 0.00670060f, 0.02772869f, 
    -0.03023580f, -0.00693338f, 0.15870155f, 0.13348064f, 0.16917561f, 0.21292481f, 0.08491412f, 0.00382547f, 
    0.13815054f, 0.15023552f, 0.00566226f, 0.06018109f, 0.15718693f, -0.08324452f, 0.12552717f, 0.05040666f, 
    0.16016752f, 0.26625395f, -0.03426267f, -0.01161365f, -0.12492598f, -0.01098337f, -0.12775896f, 0.14863561f, 
    0.30803499f, 0.27370614f, -0.22553524f, 0.15985282f, 0.07677199f, -0.03951059f, 0.00187313f, 0.09926493f, 
    0.03676153f, 0.06263793f, 0.06656441f, -0.31673846f, -0.15231548f, -0.11067778f, -0.14088082f, -0.19598280f, 
    -0.06201228f, -0.03923512f, 0.13449249f, -0.14464815f, -0.03668904f, -0.06584667f, -0.12769431f, -0.19043264f, 
    0.01897471f, 0.15396075f, 0.18864892f, -0.05176792f, -0.17266262f, 0.00172340f, 0.02638119f, -0.01665781f, 
    -0.14293745f, 0.10710551f, -0.13118771f, 0.02255025f, 0.06971143f, -0.09571669f, 0.17519669f, -0.10982842f, 
    -0.02525795f, 0.22390144f, 0.20218277f, -0.21505912f, -0.30263618f, -0.04647378f, -0.26915303f, 0.19077158f, 
    0.16685595f, -0.05123192f, -0.15369736f, 0.06452011f, 0.03746465f, -0.04607003f, 0.14437298f, 0.01184136f, 
    0.07536833f, -0.01892217f, -0.07436404f, -0.05151090f, 0.00792032f, 0.01315067f, 0.25184521f, 0.19177635f, 
    -0.04586056f, 0.34463939f, 0.11163977f, -0.01687931f, 0.01661240f, -0.10686389f, -0.04345680f, -0.03521865f, 
    0.26512972f, -0.09947965f, -0.29416716f, -0.11053964f, -0.06876983f, -0.02273353f, 0.07985549f, 0.20769645f, 
    -0.28693363f, -0.22487350f, -0.34879875f, 0.03661372f, 0.09328968f, 0.20397772f, -0.06902575f, 0.15218435f, 
    0.10440499f, 0.15413137f, -0.09634966f, 0.16978553f, -0.04645562f, -0.12123424f, 0.07244631f, -0.17588525f, 
    0.07004681f, 0.07933620f, 0.31023520f, 0.16035442f, -0.02454975f, 0.15257701f, -0.15566273f, -0.09085851f, 
    0.01206279f, -0.15538108f, -0.13917944f, 0.23005511f, 0.17342828f, 0.05808199f, 0.26843262f, 0.26569405f, 
    0.15731108f, -0.06843191f, 0.09457743f, 0.09015216f, -0.13175178f, 0.46533200f, -0.23550174f, -0.01636510f, 
    -0.04316052f, 0.20330492f, -0.11144400f, -0.00067628f, 0.09364492f, -0.03734655f, -0.04176203f, -0.21513338f, 
    -0.06376142f, -0.09989897f, 0.02832292f, 0.04386421f, 0.10909627f, -0.02913035f, 0.01663005f, -0.04234207f, 
    -0.22964004f, -0.01562207f, -0.12291382f, -0.09355855f, 0.11614008f, 0.11055969f, 0.13124150f, 0.01291480f, 
    0.19426654f, -0.07133646f, -0.00864341f, -0.33644521f, 0.00777022f, -0.00731293f, -0.04467880f, -0.03504809f, 
    0.15147485f, 0.05923158f, 0.00472125f, -0.38554281f, -0.14282587f, -0.12904736f, -0.32515398f, 0.07615249f, 
    0.19953418f, 0.16121589f, 0.11670129f, 0.17098598f, -0.18333477f, -0.00079390f, 0.07725733f, -0.01081643f, 
    0.04537274f, 0.10394253f, 0.15800102f, -0.34410870f, -0.08502096f, 0.11234883f, 0.04705073f, 0.01271132f, 
    0.14171290f, -0.11095465f, 0.14515050f, 0.06854568f, 0.04034911f, -0.55819625f, 0.01607265f, -0.03613868f, 
    0.19475234f, -0.08107622f, 0.24252743f, 0.07338309f, -0.08908241f, 0.15819244f, 0.07750639f, -0.03075781f, 
    -0.09728476f, 0.05243743f, 0.01338123f, -0.08676985f, 0.09154148f, -0.14288318f, 0.05500313f, -0.21760869f, 
    -0.16177098f, 0.10558771f, -0.06864084f, -0.33176178f, -0.06764280f, -0.12125453f, 0.22799042f, 0.09138822f, 
    -0.10303134f, 0.12979285f, 0.03509534f, -0.00433167f, 0.09915443f, 0.24277557f, 0.02288510f, -0.02071206f, 
    -0.19254030f, -0.02462115f, -0.20372766f, -0.10002860f, -0.05257671f, 0.13304463f, -0.00354674f, 0.00260830f, 
    -0.11957446f, -0.33161190f, 0.37371972f, 0.09215124f, -0.02119112f, -0.04444722f, 0.07487611f, 0.00534710f, 
    0.18484539f, -0.07414683f, -0.39116618f, 0.15787658f, 0.05467820f, 0.08012561f, 0.08252617f, -0.00064779f, 
    0.12942958f, -0.09561980f, -0.14244321f, 0.39010531f, 0.05416153f, 0.16191271f, -0.00370624f, -0.15360481f, 
    0.07835599f, -0.02593606f, 0.06810953f, -0.06788161f, 0.19302520f, 0.09722623f, 0.12429561f, -0.01476642f, 
    0.01061186f, 0.01548844f, 0.03229852f, 0.05872916f, -0.10484203f, 0.07291748f, -0.05898391f, 0.07275099f, 
    0.04649414f, 0.01790000f, 0.10637295f, 0.11180113f, 0.12612082f, -0.13481990f, 0.20822021f, -0.22539078f, 
    0.29164150f, -0.00206566f, -0.04406317f, 0.20335598f, 0.14306526f, -0.11044123f, -0.11310723f, 0.29044241f, 
    0.37279928f, -0.16126558f, 0.04083545f, -0.03632184f, -0.13457160f, -0.14007874f, 0.05595098f, -0.18252535f, 
    0.29406220f, -0.37309119f, 0.18175611f, -0.03751459f, -0.03748297f, 0.08916925f, -0.13010439f, 0.03332835f, 
    -0.13357668f, -0.35917762f, 0.26395726f, -0.02406796f, 0.05508649f, -0.03160088f, -0.01357814f, -0.02724690f, 
    0.10449283f, -0.18452914f, -0.25318673f, 0.36236525f, 0.00604445f, 0.12095005f, 0.02595990f, -0.04134152f, 
    0.00065071f, 0.09320123f, -0.41174296f, -0.12294736f, -0.04766037f, 0.01902605f, -0.15315223f, 0.04304907f, 
    0.01570326f, 0.15726963f, 0.10038594f, 0.04514908f, -0.07555243f, 0.09897191f, 0.14550295f, 0.03621652f, 
    0.04807467f, 0.03277048f, -0.18835777f, 0.02071970f, -0.27087626f, 0.10944165f, -0.00408970f, -0.00927796f, 
    -0.00065747f, -0.21968029f, 0.18975122f, -0.01963920f, 0.14453608f, 0.11084662f, 0.27395850f, 0.10015725f, 
    -0.14808090f, -0.06848651f, 0.01001753f, 0.10042424f, 0.03898284f, 0.02161926f, -0.07325976f, -0.19469200f, 
    -0.18414363f, -0.00656424f, 0.00609269f, 0.05106736f, -0.08694079f, -0.01973598f, 0.02580262f, -0.42104721f, 
    -0.06707080f, 0.04942076f, -0.07607108f, 0.01955571f, 0.04458013f, 0.15009481f, 0.07681218f, 0.02414457f, 
    0.13922232f, 0.14060275f, 0.21654513f, 0.06321079f, 0.13884901f, 0.06431668f, -0.16138561f, 0.01728220f, 
    0.17247723f, 0.17098084f, -0.17810294f, -0.48607489f, -0.14929226f, -0.26484394f, 0.02788283f, -0.09042814f, 
    -0.07916963f, 0.27221867f, -0.03624972f, -0.15715961f, -0.55311358f, -0.19121620f, 0.02126434f, -0.00896424f, 
    -0.01615706f, 0.08203940f, 0.02834388f, 0.19751987f, -0.23848447f, 0.22112030f, -0.18466422f, -0.18730229f, 
    -0.12399970f, -0.02297335f, -0.00094142f, 0.15458870f, -0.18539153f, -0.13690239f, 0.18696021f, -0.17452155f, 
    0.15328552f, -0.36624178f, -0.18184096f, 0.07509285f, 0.27342710f, -0.08815147f, -0.24085940f, 0.21655901f, 
    -0.01293505f, 0.04335854f, 0.06379590f, -0.06240463f, 0.01195583f, 0.05861550f, -0.00598274f, -0.09762082f, 
    0.09127387f, -0.03303848f, 0.01735801f, 0.14609292f, 0.15380096f, -0.12250986f, -0.09774602f, 0.20244059f, 
    -0.44217783f, 0.05689004f, -0.05036709f, 0.05861803f, 0.17720398f, 0.22741018f, 0.05978632f, 0.03914304f, 
    -0.42906877f, -0.18738385f, 0.34382391f, 0.09113045f, -0.03739576f, 0.01227788f, -0.04488247f, -0.14643595f, 
    0.16266263f, 0.05732860f, -0.20768648f, 0.29264835f, 0.02884082f, 0.07600591f, -0.21948634f, 0.15306136f, 
    0.06419560f, 0.16018797f, 0.04559731f, -0.01623488f, 0.12828101f, -0.07420757f, -0.26251739f, -0.04909476f, 
    0.08327593f, -0.00421844f, -0.09963277f, 0.01558212f, -0.24522394f, -0.36638460f, 0.16612838f, -0.01109379f, 
    0.07809845f, 0.10841798f, -0.06405411f, 0.09097929f, 0.13156399f, -0.11147426f, -0.01528591f, -0.07375463f, 
    -0.13673906f, -0.18398547f, 0.07483293f, -0.05934761f, 0.16463833f, -0.34222141f, -0.01372318f, -0.19662568f, 
    0.25384739f, 0.15618218f, 0.09662218f, -0.04110635f, -0.01849041f, -0.06598128f, 0.33412787f, 0.15203540f, 
    -0.13431744f, 0.05146232f, -0.06643028f, 0.01970636f, -0.15104623f, 0.09778238f, 0.01193687f, -0.27670810f, 
    -0.19529562f, 0.05736729f, 0.12820882f, 0.07726967f, 0.05395950f, -0.06461111f, 0.25258705f, 0.07107130f, 
    0.00882235f, 0.21703340f, -0.06362857f, -0.16498314f, 0.10339210f, 0.14013085f, 0.01941952f, 0.08491615f, 
    0.11925543f, -0.31178391f, 0.35018715f, 0.02183055f, -0.10867029f, -0.14649242f, -0.08204779f, 0.05617799f, 
    0.03075835f, 0.17340967f, 0.05179207f, -0.73583543f, -0.05752226f, -0.01305129f, 0.13337170f, 0.13741690f, 
    0.02277068f, -0.09914273f, -0.10445196f, -0.39097783f, -0.55070591f, -0.10771405f, -0.03473677f, 0.13905965f, 
    0.07794938f, 0.15964310f, -0.14793773f, -0.06931108f, -0.41402906f, -0.42299730f, 0.12806484f, 0.08584758f, 
    0.11718654f, 0.08223468f, 0.22108373f, -0.04503002f, -0.23725109f, 0.11189419f, -0.26183829f, 0.13480665f, 
    0.26130587f, 0.08714550f, 0.03755049f, -0.00303346f, -0.11093068f, 0.17692810f, 0.33041820f, 0.14483851f, 
    0.04604972f, -0.10973424f, 0.38910264f, -0.16213413f, 0.31989253f, -0.19603223f, -0.01022830f, -0.05772052f, 
    0.23059280f, 0.16933770f, -0.11635973f, 0.12020601f, -0.16449304f, 0.05913205f, -0.17744623f, 0.27300432f, 
    -0.02561853f, 0.15182529f, 0.08806903f, -0.09258512f, -0.04780368f, 0.07521401f, 0.12288576f, 0.22388989f, 
    0.19980086f, -0.00057208f, 0.29498458f, -0.14189418f, -0.17614083f, -0.10148565f, -0.15619461f, -0.05487593f, 
    0.09970458f, 0.08284944f, 0.05605384f, -0.06725750f, -0.02935157f, -0.14570901f, -0.06025424f, 0.13366581f, 
    -0.00018505f, 0.00889569f, 0.15144269f, 0.15859762f, 0.23589168f, -0.10321793f, -0.07050752f, 0.14925693f, 
    -0.07748549f, 0.24540704f, -0.18100023f, -0.02549438f, 0.07648170f, -0.43868795f, 0.09191260f, 0.08734811f, 
    -0.01792007f, 0.11451870f, 0.03121693f, 0.09445474f, -0.04741091f, 0.04136446f, -0.02575687f, 0.03491018f, 
    0.02978775f, -0.20187607f, -0.10661609f, -0.05355619f, 0.12109040f, 0.08235598f, 0.44439909f, 0.09665706f, 
    -0.23467582f, 0.08767170f, -0.01314602f, -0.02393194f, 0.06041195f, 0.11937092f, 0.11744934f, 0.18364912f, 
    0.18894844f, -0.13137360f, 0.02003275f, -0.09481947f, -0.19748066f, -0.07109277f, 0.06872191f, 0.09486582f, 
    -0.25299472f, -0.54803699f, 0.05187231f, -0.05465233f, 0.09562757f, 0.09814346f, 0.05333973f, 0.04543760f, 
    -0.28515700f, 0.10787774f, -0.02702901f, -0.00846434f, 0.16498496f, -0.00544925f, -0.12522906f, -0.22219400f, 
    0.05113837f, 0.06016374f, 0.75734407f, -0.13010484f, 0.03793351f, 0.14835197f, -0.20149426f, 0.12022520f, 
    0.35932440f, 0.03640812f, 0.08351525f, 0.00430646f, 0.16107340f, 0.07181019f, 0.10337582f, 0.08497398f, 
    -0.07303605f, -0.06974968f, 0.04122950f, 0.18398175f, -0.04844959f, 0.25872755f, -0.07176128f, 0.01607938f, 
    0.23148417f, -0.06237733f, 0.29555929f, -0.04341083f, 0.13015260f, 0.12336850f, 0.14761911f, -0.29068410f, 
    -0.04361454f, -0.05582069f, -0.00926823f, -0.19685729f, -0.05348810f, 0.06402764f, 0.04836404f, 0.32131276f, 
    -0.00500432f, 0.09275769f, -0.17840847f, 0.04030521f, 0.04098290f, 0.12833555f, -0.05200172f, 0.36124048f, 
    0.02364684f, -0.01780839f, -0.18312517f, 0.01070237f, 0.06750783f, -0.16253923f, 0.21638958f, -0.22893888f, 
    0.12992364f, 0.23129548f, -0.21153927f, -0.14254673f, 0.04844988f, 0.22055040f, -0.07900907f, 0.00285073f, 
    0.10113113f, -0.02754773f, 0.27464601f, 0.13728529f, -0.10501277f, -0.19178575f, 0.12845668f, 0.09936868f, 
    0.06224559f, 0.07237212f, -0.17675489f, -0.46968925f, -0.03974920f, 0.05409410f, 0.14589007f, 0.07512698f, 
    0.00549964f, 0.07256949f, -0.07305613f, -0.30079904f, -0.13114093f, 0.18463536f, 0.00701299f, 0.00041314f, 
    0.01263777f, -0.08043217f, 0.02417725f, 0.08908615f, -0.30895042f, 0.00214326f, -0.16611658f, -0.29370901f, 
    0.05593766f, -0.00384639f, -0.14798702f, 0.07944332f, -0.06747233f, 0.09779600f, 0.11146034f, 0.09226792f, 
    0.10570262f, -0.08483164f, 0.06296988f, -0.12712792f, -0.10848945f, -0.01320791f, 0.38315284f, -0.17028573f, 
    -0.06121779f, -0.04617191f, -0.03535626f, -0.03318889f, 0.00561384f, 0.07266357f, 0.21338496f, 0.16596873f, 
    0.11099778f, -0.18772076f, -0.14994721f, 0.07265776f, -0.30140695f, 0.02503351f, -0.07900131f, 0.09602275f, 
    0.04181306f, -0.01282223f, -0.04577744f, 0.03411360f, -0.04472451f, 0.00212263f, -0.02650964f, -0.03851377f, 
    0.01338513f, -0.06004007f, 0.03877802f, 0.01978186f, 0.02739546f, -0.06200588f, -0.03818487f, -0.05924695f, 
    0.00301962f, -0.06350540f, -0.06090341f, 0.03184533f, 0.02033463f, 0.01243494f, 0.00125182f, 0.01115653f, 
    0.03149254f, 0.03834829f, -0.03584282f, -0.00078107f, 0.03612757f, -0.04113716f, -0.00144996f, 0.00356211f, 
    0.03660868f, -0.02657360f, -0.05490242f, 0.02095100f, 0.05052475f, -0.06265238f, 0.03898903f, -0.06678956f, 
    -0.04744547f, 0.02828647f, 0.05064972f, -0.04173204f, -0.06446869f, -0.04126550f, -0.03305300f, 0.03182567f, 
    -0.01043300f, -0.00023692f, 0.03049368f, 0.00930514f, 0.02333527f, -0.00273265f, -0.04024785f, 0.04198445f, 
    -0.00843855f, 0.00533774f, -0.00654912f, -0.01076791f, 0.04076833f, 0.02991867f, -0.02154334f, -0.04303511f, 
    0.03323402f, 0.04030987f, -0.00374506f, 0.01121691f, 0.04136877f, 0.01892374f, -0.01755248f, -0.01123012f, 
    0.04195485f, -0.05943958f, 0.03322652f, 0.04459806f, 0.02676899f, -0.03594672f, 0.02729764f, 0.00896797f, 
    -0.03754137f, 0.01187853f, 0.01632443f, -0.05577816f, 0.02431733f, -0.01739824f, -0.01786308f, -0.00227379f, 
    -0.04093700f, -0.02228464f, 0.03544668f, -0.06234621f, -0.05952901f, -0.04050148f, 0.02764502f, -0.04841142f, 
    0.03744488f, -0.01701697f, -0.04456877f, -0.03594208f, 0.03436052f, 0.02428087f, 0.02762784f, 0.01932961f, 
    -0.06284766f, -0.03130993f, -0.00085530f, 0.00261313f, -0.05373148f, -0.07019372f, -0.01785762f, 0.05032913f, 
    0.00842892f, -0.03053200f, 0.03967655f, 0.02439918f, -0.00713021f, 0.01799143f, 0.02027568f, -0.06494673f, 
    0.04652095f, 0.03244035f, -0.06021823f, 0.01066429f, 0.04963516f, 0.04642237f, -0.06018778f, -0.05485759f, 
    0.00537829f, -0.01518821f, -0.03088130f, -0.02698443f, 0.04982078f, 0.01051720f, 0.02865293f, -0.05476671f, 
    0.01271609f, -0.00066300f, -0.02717490f, -0.02340670f, -0.02635796f, 0.02174543f, -0.04636211f, -0.05865955f, 
    -0.05068439f, -0.01582239f, 0.01434546f, 0.00155671f, -0.06375349f, 0.00512024f, -0.02388201f, -0.00667755f, 
    0.00172619f, 0.04176085f, -0.02780855f, 0.04264685f, -0.01096089f, -0.02557652f, 0.03917737f, 0.04784508f, 
    -0.02328085f, -0.04070904f, 0.02325026f, -0.02171589f, -0.04272925f, -0.03737915f, -0.04356914f, -0.00771372f, 
    -0.04933795f, -0.06049394f, 0.01003435f, -0.04970715f, -0.00640521f, -0.01940167f, -0.02315884f, 0.01164651f, 
    0.04256860f, -0.05248894f, 0.01049232f, 0.03648620f, 0.01945694f, -0.06035926f, 0.04594664f, 0.00415481f, 
    -0.01079543f, 0.01976163f, -0.04843228f, -0.02728933f, -0.04719566f, -0.01148196f, -0.03854209f, 0.00093133f, 
    -0.02577902f, -0.04863739f, -0.01301839f, 0.00886840f, 0.03436552f, -0.02877699f, -0.02474648f, -0.00551249f, 
    0.00652415f, 0.00900369f, -0.03922058f, -0.04278348f, -0.00795709f, -0.03223415f, -0.01559496f, -0.01053998f, 
    -0.03315847f, -0.05832548f, -0.03772204f, -0.05805465f, 0.02472378f, -0.04411567f, 0.01939349f, 0.04655766f, 
    0.03826107f, -0.00400578f, 0.03225620f, -0.05129171f, 0.02966542f, -0.05143323f, 0.01217423f, -0.05667431f, 
    -0.06005878f, 0.04318933f, -0.03073674f, 0.03089740f, 0.01406451f, 0.02078632f, -0.00013890f, -0.04278866f, 
    0.02579509f, -0.05411737f, -0.04296112f, -0.01482415f, -0.00255453f, 0.02784838f, 0.02381920f, 0.02267193f, 
    -0.05901018f, -0.02818601f, -0.02292015f, 0.03599910f, -0.01540225f, -0.01994464f, -0.06398445f, 0.03682205f, 
    -0.03513975f, -0.06100090f, 0.03152512f, 0.04505106f, -0.02189895f, 0.03933445f, -0.03733502f, 0.03753474f, 
    -0.04084639f, 0.00965460f, -0.06206124f, 0.01170469f, 0.02745420f, 0.00348134f, -0.06488232f, 0.03139509f, 
    -0.01803504f, -0.05549796f, 0.00895343f, -0.01959167f, -0.04558565f, -0.04554406f, 0.00612517f, -0.01045688f, 
    -0.01905524f, -0.05461086f, -0.01409028f, 0.04749485f, 0.04991191f, 0.02866556f, -0.06271789f, -0.00393454f, 
    -0.06563698f, -0.05173596f, -0.00999896f, 0.02302101f, -0.05006939f, -0.01952299f, -0.03470554f, -0.01314517f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.05898309f, 0.05815849f, 0.12694086f, -0.09623010f, 0.09052750f, -0.05227903f, 0.09764893f, -0.05253235f, 
    -0.00860457f, -0.01144099f, 0.02435265f, 0.01875668f, 0.08421230f, -0.02975273f, -0.17419285f, 0.16676402f, 
    -0.02471380f, -0.06942095f, 0.04115730f, -0.02514692f, 0.13562405f, 0.04355484f, 0.17263478f, -0.02389156f, 
    0.03739045f, 0.18589464f, 0.07705726f, 0.02793583f, 0.11400313f, 0.10415179f, 0.02115064f, -0.01033628f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.16268745f, -0.36323565f, -0.56426352f, 0.14036086f, -0.40652382f, 0.10514911f, 0.09576626f, -0.17200245f, 
    0.14231175f, 0.70579219f, 0.09990297f, 0.19598919f, 0.22771725f, 0.00930573f, -0.03789235f, -0.25355360f, 
    -0.07471394f, 0.29727200f, 0.22914915f, 0.05726068f, 0.33068958f, 0.16509236f, 0.10879493f, -0.52113175f, 
    0.59286463f, -0.25284615f, -0.06829280f, -0.17599446f, -0.38222736f, -0.58175993f, 0.06759743f, 0.10421876f, 
    0.02323326f, 0.12977955f, 0.02308972f, -0.56320149f, -0.23649608f, -0.04441977f, -0.25460881f, 0.08378647f, 
    -0.37004861f, 0.58716935f, 0.12112606f, 0.17993413f, -0.35055691f, -0.08540838f, 0.40598285f, 0.37847266f, 
    -0.10995105f, -0.37124273f, 0.49846742f, 0.06940030f, 0.05535556f, -0.02682242f, 0.14464164f, 0.46368921f, 
    -0.21280089f, 0.04784690f, 0.08922624f, 0.50832003f, -0.52303988f, 0.19012782f, -0.35833317f, -0.13696648f, 
    -0.12301908f, 0.58664519f, -0.19471784f, 0.20473805f, -0.39616707f, 0.07085405f, -0.38403538f, -0.00528264f, 
    0.15871222f, -0.65334022f, 0.02821222f, 0.31532210f, -0.11369718f, -0.00184757f, -0.23668779f, -0.30617708f, 
    0.14576922f, -0.23931430f, 0.31232795f, -0.02449303f, 0.73116636f, 0.05760698f, -0.23295048f, -1.01077259f, 
    0.13802424f, 0.47274268f, 0.02023863f, 0.26266864f, 0.30860275f, -0.11217153f, -0.39068186f, 0.07444283f, 
    -0.15095770f, -0.15000141f, -0.16838472f, 0.31123292f, -0.42550194f, -0.03281227f, 0.20191655f, -0.12300239f, 
    -0.36699837f, -0.24563698f, 0.11684006f, -0.70864952f, -0.11730523f, -0.00131989f, 0.47129646f, -0.61286736f, 
    0.14827622f, -0.63062030f, 0.34132367f, -0.05176891f, -0.25251067f, -0.02526893f, -0.45339701f, 0.05639625f, 
    -0.22889654f, -0.05751466f, 0.33169416f, -0.14546962f, 0.33516836f, 0.08501091f, 0.63816226f, -0.16291119f, 
    0.07382120f, 0.32021597f, -0.19040476f, 0.22991660f, -0.02737555f, -0.15518688f, 0.11605106f, 0.04275550f, 
    -0.45357734f, -0.62706798f, 0.12660761f, 0.11938167f, 0.46066251f, -0.17097512f, -0.08683690f, 0.16256566f, 
    0.00513937f, 0.14476536f, -0.11298773f, 0.14725098f, 0.00477324f, 0.07860491f, -0.25144190f, -0.48622635f, 
    -0.76343310f, -0.41780993f, 0.46163544f, -0.04918570f, 0.02973250f, 0.38932592f, -0.14436539f, 0.04331122f, 
    0.16923830f, -0.66320223f, 0.33106312f, -0.56470424f, 0.15272853f, -0.10642097f, -0.07227982f, -0.07180583f, 
    -0.60668606f, -0.27748469f, -0.15637502f, 0.13245702f, 0.13468140f, 0.15134078f, 0.54340601f, 0.23957241f, 
    0.12021195f, 0.38281581f, 0.04273831f, 0.07922057f, -0.11546682f, -0.12661704f, 0.53883666f, 0.20736790f, 
    0.08915942f, 0.00872757f, -0.34353611f, 0.07058102f, 0.29450867f, -0.53682637f, -0.40638638f, -0.15574273f, 
    0.05155131f, -0.14820178f, 0.65886480f, 0.14247887f, -0.16743390f, 0.08393050f, -0.24068755f, 0.13415866f, 
    -0.00252305f, -0.20662300f, -0.12394547f, -0.74038082f, 0.42940575f, -0.11901945f, -0.47935686f, 0.08977570f, 
    0.01189098f, -0.11095990f, -0.30567759f, -0.01613115f, -0.61548108f, -0.09280767f, -0.21731006f, -0.33463058f, 
    0.07092514f, -0.26904565f, 0.06663252f, 0.45222357f, -0.54498845f, 0.02662330f, 0.27184737f, 0.11324640f, 
    -0.16527803f, -0.08246494f, -0.37721923f, 0.02667925f, 0.08958220f, -0.10612705f, 0.16219658f, -0.15091065f, 
    0.31664783f, -0.12556729f, 0.05883754f, 0.41608635f, -0.30084053f, 0.04442952f, 0.28635418f, -0.28186899f, 
    -0.13618965f, 0.61157215f, -0.49269652f, -0.06959743f, -0.28772795f, 0.16042355f, 0.03672874f, 0.28522688f, 
    -0.12977432f, -0.58541179f, 0.16400772f, 0.12975009f, -0.32919255f, -0.50030577f, 0.01490231f, -0.12061147f, 
    -0.07728234f, 0.13661036f, -0.05995845f, 0.04112414f, 0.34682623f, -0.01583795f, -0.68713987f, -0.08156822f, 
    0.62713820f, 0.44582066f, 0.01710573f, 0.24420317f, -0.09441529f, -0.05325117f, -0.02310268f, 0.00485040f, 
    -0.06161866f, -0.57623482f, -0.63088536f, 0.02395265f, 0.01463799f, 0.06822781f, 0.24346790f, 0.48581797f, 
    -0.24432114f, -0.00680250f, -0.74748516f, 0.13881628f, 0.05539082f, 0.45294973f, 0.06005860f, 0.04659113f, 
    -0.11303765f, -0.00225483f, 0.15911931f, 0.36888582f, 0.33374459f, -0.15567058f, -0.21316187f, -0.00800698f, 
    -0.30901569f, -0.65034294f, -0.16034411f, 0.07276694f, 0.00783952f, 0.11768114f, -0.06478022f, 0.13391034f, 
    0.08069411f, 0.19979121f, 0.05727577f, 0.03527293f, -0.48870286f, -0.11387706f, -0.12134197f, -0.11819502f, 
    1.02819085f, -0.13676511f, -0.35232362f, -0.97856730f, 0.15740377f, 0.66091973f, -0.14716646f, 0.16847962f, 
    0.14618555f, -0.12673922f, 0.07095393f, -0.41649091f, -0.09844977f, -0.00491842f, 0.15498897f, -0.02954662f, 
    0.30465508f, -0.27850875f, 0.05401846f, -0.52458566f, -0.71426922f, 0.09986673f, -0.20881382f, -0.06826979f, 
    0.07917792f, -0.13351592f, -0.34723759f, 0.16750214f, 0.43625137f, 0.15164901f, 0.01886266f, 0.12106919f, 
    -0.38535845f, 0.82775480f, 0.36228579f, -0.37038568f, 0.17087875f, 0.15642682f, -0.02291798f, 0.12820269f, 
    0.06402713f, 0.05409835f, 0.10054942f, 0.12952560f, 0.73745334f, -0.18289275f, 0.39044064f, -0.04795269f, 
    0.05674912f, 0.37737581f, 0.00583222f, -0.59022778f, -0.19814233f, 0.04207979f, -0.72416967f, 0.25642794f, 
    -0.04464760f, -0.26281062f, 0.01274216f, -0.08435635f, 0.16813289f, -0.16167025f, -0.84286582f, -0.19224855f, 
    -0.39873320f, -0.20003109f, -0.48890358f, 0.01198871f, 0.33289230f, -0.61476225f, 0.31329781f, -0.01819544f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.11635028f, -0.11172380f, -0.23721611f, -0.19557425f, 0.24238543f, 0.02601498f, -0.00020977f, -0.49677578f, 
    -0.17369640f, -0.06395811f, 0.22451781f, 0.23972975f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
