#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.62994152f, -0.16091107f, -0.09846686f, -0.01878052f, 0.37112838f, -0.02802699f, -0.28067520f, -0.42473921f, 
    -0.34645608f, -0.18489349f, 0.02667841f, -0.22717142f, 0.21444677f, -0.38503149f, -0.11621595f, -0.04785224f, 
    -0.14772464f, -0.18474235f, -0.07563413f, 0.00016839f, 0.28621143f, -0.24758068f, -0.22666423f, 0.09395887f, 
    -0.15694538f, -0.81414711f, -0.61162150f, -0.43005386f, -0.29219455f, -0.59371758f, 0.43467781f, 0.37031111f, 
    0.18990849f, 0.05281518f, 0.51832998f, 0.05829420f, 0.01761138f, 0.04964173f, 0.24788930f, -0.18060051f, 
    -0.11841577f, 0.04666831f, -0.00326751f, 0.01050246f, 0.33420053f, -0.12471484f, 0.00310261f, 0.05200609f, 
    0.10504664f, -0.27349249f, 0.85436016f, -0.43240261f, -0.31417233f, -0.33632046f, -0.50871539f, 0.49934307f, 
    -0.05850024f, -0.00621587f, 0.35975614f, 0.19908656f, 0.27421615f, -0.32471630f, -0.15621357f, -0.00740524f, 
    -0.00860585f, -0.17395724f, 0.34143031f, 0.01355104f, -0.11475798f, 0.01563080f, -0.06815679f, -0.02724884f, 
    -0.05619262f, -0.19132873f, 0.20070665f, -0.99183828f, 0.62643689f, 0.00430589f, -0.51783371f, -0.05497033f, 
    -0.22890767f, 0.01925172f, 0.38316748f, 0.54173779f, 0.22591224f, -0.23446932f, -0.25498998f, 0.15684023f, 
    0.00007037f, -0.05456000f, -0.02366304f, -0.22073676f, -0.14419226f, 0.23393849f, 0.09539977f, 0.03329383f, 
    -0.03351751f, 0.32258266f, -0.05128522f, -0.06458222f, -0.38542944f, -0.15484706f, -0.01473441f, -0.08443426f, 
    0.22891888f, 0.09129827f, 0.25211498f, 0.11645525f, 0.34939298f, 0.25116956f, -0.15334690f, -0.18981956f, 
    -0.19434366f, 0.11469472f, -0.12081917f, -0.03409229f, 0.33890337f, 0.08896798f, -0.47629428f, -0.29380435f, 
    0.05021484f, -0.01541652f, -0.16653015f, -0.02140527f, 0.12880814f, 0.40668628f, 0.67197067f, 0.10923943f, 
    -0.14330184f, -0.11550399f, -0.29300889f, 0.07567820f, 0.26407978f, -0.17245215f, -0.43547156f, -0.23650859f, 
    -0.01074255f, -0.20328663f, 0.00223122f, 0.38702977f, 0.16997747f, 0.32098508f, -0.12130019f, -0.39089680f, 
    -0.03656740f, 0.00606527f, 0.00172872f, -0.20017569f, -0.11678552f, -0.11315617f, -0.79234624f, 0.08343215f, 
    0.12571554f, 0.22746751f, 0.38452527f, 0.09131272f, 0.18618935f, 0.70341283f, -0.55353677f, -0.31463090f, 
    -0.34851867f, -0.00202350f, 0.01859656f, -0.00306730f, -0.00525708f, -0.20957130f, 0.04188449f, -0.06835922f, 
    0.09406803f, 0.15341528f, 0.09612148f, -0.39455760f, -0.03641761f, 0.47008532f, -0.08794105f, -0.88876963f, 
    -0.10750639f, -0.52372199f, -0.30138990f, 0.33053404f, -0.07153863f, 0.19009103f, 0.25977638f, -0.26274002f, 
    0.27610397f, -0.33500829f, -0.29535595f, -0.49699306f, -0.07913318f, 0.41404852f, 0.18578105f, -0.00679887f, 
    -0.45740694f, -0.05147794f, 0.16003153f, 0.09245110f, 0.02269791f, 0.23932202f, -0.22307958f, -0.52043808f, 
    -0.41825268f, -0.43826479f, -0.29209653f, -0.21226209f, 0.68071592f, 0.16110823f, 0.27234858f, 0.38613060f, 
    -0.19239557f, -0.28428218f, 0.47450531f, -0.05767738f, 0.32622203f, -0.38287610f, -0.06326140f, 0.18712975f, 
    -0.08626366f, -0.03187614f, 0.11608174f, -0.32325602f, -0.10644568f, 0.00912801f, -0.12405400f, -0.19223821f, 
    -0.01271191f, -0.00925544f, 0.11199653f, 0.13788830f, -0.08372978f, -0.26423502f, 0.29173130f, 0.16513896f, 
    -0.07483394f, -0.18574205f, 0.02029165f, -0.40679654f, 0.42106032f, -0.18924737f, -0.30476466f, 0.25962698f, 
    0.22901224f, 0.13800552f, -0.00113290f, -0.17737523f, 0.06868077f, -0.21730220f, -0.26822025f, 0.02745155f, 
    0.05170093f, 0.56576431f, -0.10289132f, -0.32546359f, -0.47252756f, -0.33887336f, -0.46277311f, 0.12931553f, 
    0.12987855f, 0.17733546f, -0.22656398f, 0.12075903f, -0.40352848f, -0.32184887f, -0.11902262f, -0.20375745f, 
    0.06701911f, -0.00414158f, 0.05582236f, -0.07397204f, -0.26346773f, 0.10426610f, -0.04693637f, -0.14085771f, 
    -0.15946852f, -0.01060799f, 0.05129796f, 0.10556377f, -0.10199340f, 0.07676958f, 0.34073284f, 0.04354687f, 
    -0.17281631f, -0.01738527f, 0.15640993f, 0.25579169f, -0.25847971f, -0.17948753f, -0.34371144f, 0.12714377f, 
    0.34876403f, -0.22278455f, 0.14866291f, -0.14993101f, 0.00293997f, 0.10478047f, -0.17520973f, 0.09091026f, 
    -0.04328729f, -0.32359129f, -0.16168405f, 0.09877524f, -0.38434970f, -0.42440695f, -0.10621852f, 0.06073223f, 
    -0.16561835f, 0.01007924f, -0.06538835f, 0.12005143f, 0.07052334f, -0.23335326f, 0.03907584f, 0.00816474f, 
    0.05202927f, 0.01264461f, -0.02461202f, -0.10720868f, 0.11153575f, -0.23491955f, -0.08831303f, 0.20792608f, 
    -0.04584122f, 0.14721620f, 0.13039811f, 0.16592808f, 0.32330829f, -0.24888821f, -0.44361824f, -0.53064460f, 
    -0.64990044f, -0.46649536f, 0.48100948f, 0.43112141f, 0.30751646f, -0.02010987f, 0.35004333f, -0.05456260f, 
    0.37019441f, -0.09302778f, -0.03158865f, 0.16193470f, -0.00128678f, 0.06828701f, 0.02131136f, -0.20338488f, 
    -0.20398553f, 0.07401389f, -0.20189394f, -0.03463534f, 0.02025582f, -0.00560230f, -0.50797057f, -0.67187428f, 
    -0.34106955f, 0.22388086f, 0.58689356f, -0.15788952f, -0.26563099f, -0.49403533f, -0.29436871f, -0.27326429f, 
    0.22009562f, -0.02333052f, -0.01302486f, -0.10702842f, -0.21726260f, -0.04941778f, -0.34982288f, 0.18716533f, 
    -0.13161208f, -0.12095752f, -0.03049853f, 0.03810320f, 0.23398730f, -0.28416055f, -0.23248105f, 0.21687816f, 
    -0.05200060f, 0.19281089f, -0.00065901f, -0.23176003f, -0.09410243f, 0.16635354f, 0.07933731f, 0.29362744f, 
    0.07948008f, 0.40306085f, -0.46484798f, -0.12518673f, 0.46404469f, -0.26174542f, -0.11288948f, -0.18138470f, 
    0.13040522f, 0.01216188f, 0.06603565f, 0.10173932f, 0.12829994f, 0.04214889f, -0.17707826f, 0.28901011f, 
    -0.26289636f, -0.03669153f, 0.44103324f, -0.02807932f, -0.42373684f, -0.28451109f, 0.00067590f, -0.47903079f, 
    -0.22195254f, -0.05586771f, 0.26515302f, 0.22879840f, -0.01374438f, -0.01447366f, 0.02578098f, 0.11807089f, 
    0.07791366f, 0.18318929f, -0.04006736f, 0.05097987f, -0.16188200f, -0.05550646f, -0.34014967f, -0.26519865f, 
    -0.23564298f, -0.59944105f, -0.59601063f, -0.09064117f, 0.25951400f, 0.37135011f, 0.31638980f, 0.03948978f, 
    0.11994478f, 0.23403750f, 0.55895913f, 0.13561153f, 0.16594641f, -0.12990454f, -0.19830970f, -0.06543162f, 
    -0.26660424f, 0.10111876f, 0.35778320f, -0.34327191f, -0.12427589f, -0.42368203f, 0.02721577f, 0.04745273f, 
    0.08146204f, 0.06311969f, -0.51486814f, 0.33851731f, -0.12286544f, -0.87055755f, -0.51915514f, 0.20136040f, 
    0.05975445f, 0.00633688f, 0.35058179f, -0.01657203f, 0.30388927f, -0.22934145f, 0.15784898f, -0.24940491f, 
    -0.05815819f, -0.25774589f, -0.20544021f, 0.10117828f, -0.13075215f, -0.25087297f, -0.06740175f, 0.30935058f, 
    0.07815649f, 0.00078224f, 0.10087385f, -0.20893469f, -0.24271636f, -0.15151460f, 0.17496604f, 0.22666270f, 
    -0.06084911f, -0.05216246f, 0.02907653f, -0.12616076f, 0.28007501f, -0.08134824f, -0.01244828f, -0.12488294f, 
    0.42239141f, -0.13964714f, -0.17802395f, 0.17576228f, -0.06096619f, -0.17987931f, -0.32540995f, -0.06728458f, 
    0.24769460f, 0.41725850f, 0.06404386f, 0.29088274f, -0.37565994f, 0.44661310f, 0.38172430f, -0.44438261f, 
    -0.02853415f, -0.23186013f, 0.17445046f, 0.14840248f, 0.32279757f, -0.54470795f, -0.28445318f, -0.00102539f, 
    0.32217792f, -0.32029450f, -0.19903858f, 0.37504762f, -0.22453724f, -0.11324316f, -0.20781469f, 0.14335024f, 
    -0.34864309f, 0.21952946f, -0.18886422f, 0.12802728f, 0.09670323f, -0.70509654f, -0.29152131f, -0.52616632f, 
    -0.29011995f, -0.37605676f, 0.71629524f, -0.11349654f, -0.10255075f, 0.11218693f, 0.39280269f, 0.30139914f, 
    0.11965498f, 0.19568235f, -0.08640712f, 0.11440827f, -0.15964060f, 0.08070946f, -0.17431641f, 0.04286330f, 
    -0.01862031f, 0.01714796f, 0.07544920f, 0.13667518f, -0.20517667f, 0.18209843f, 0.24239902f, 0.09709688f, 
    -0.13023932f, -0.22580647f, 0.15349704f, 0.12006158f, 0.06784394f, -0.02236810f, -0.16848008f, -0.23420472f, 
    0.29063118f, 0.18531710f, -0.23438279f, 0.25897413f, -0.27308765f, 0.26134613f, -0.30590394f, -0.17291038f, 
    -0.09857415f, 0.10498630f, -0.45143223f, 0.45514166f, 0.27533907f, -0.17047375f, 0.41704667f, -0.44241697f, 
    0.04176848f, 0.28878736f, 0.26286119f, -0.21846484f, 0.15420225f, 0.34187675f, 0.18112189f, -0.27764264f, 
    -0.51395804f, 0.04646261f, 0.44927016f, -0.43561199f, 0.23913997f, -0.35124099f, -0.00494656f, 0.33693802f, 
    0.10512578f, -0.42570418f, 0.20058863f, 0.28983313f, -0.29545936f, -0.05268834f, -0.08557061f, -0.00768870f, 
    -0.39188299f, -0.01242912f, 0.12477719f, 0.25013730f, 0.17407198f, 0.18936653f, -0.38507429f, 0.11355423f, 
    -0.10914686f, 0.31287506f, 0.04921405f, 0.11454388f, 0.21924143f, -0.18810311f, -0.28790373f, -0.03658730f, 
    0.02184866f, -0.23305859f, -0.07927803f, 0.23613428f, -0.04684109f, -0.20432752f, 0.10377955f, 0.03097380f, 
    -0.03700381f, 0.47604051f, 0.27030289f, 0.29571331f, 0.54272145f, 0.29195252f, -0.01805927f, 0.06848653f, 
    -0.10631908f, -0.39627969f, 0.12556973f, 0.04345515f, -0.00451335f, -0.05262875f, 0.12651263f, 0.06656376f, 
    -0.23128892f, -0.02568442f, -0.13018505f, -0.08177745f, 0.02031089f, 0.01298508f, -0.08974337f, 0.12303200f, 
    0.16897386f, -0.07046214f, 0.38197190f, 0.17056420f, -0.08908302f, -0.14238368f, -0.31469336f, -0.08773531f, 
    -0.21038195f, -0.11330908f, 0.18209292f, 0.27314639f, 0.38672170f, -0.10196263f, -0.29461139f, 0.06632531f, 
    0.38851821f, 0.09306414f, 0.10631054f, 0.05745648f, 0.00418680f, 0.01271330f, 0.26939040f, -0.16983680f, 
    0.14285991f, 0.21222624f, 0.00629820f, -0.09420931f, -0.40249431f, -0.42148927f, 0.36567611f, 0.34365568f, 
    -0.17144029f, 0.10193095f, -0.02094897f, -0.20865947f, -0.39404130f, -0.12190670f, -0.38481608f, -0.03715987f, 
    0.15991274f, 0.13090487f, 0.09656879f, -0.05149561f, -0.22689304f, -0.21082726f, -0.18789345f, -0.34561518f, 
    -0.02779766f, -0.07456397f, -0.23373020f, -0.20089540f, 0.02327401f, -0.30178967f, -0.29060930f, -0.35026899f, 
    -0.08817602f, -0.28581163f, -0.35997173f, -0.27917823f, -0.17045751f, 0.08456174f, 0.21357127f, 0.45970944f, 
    0.21780276f, -0.15719110f, -0.18031982f, 0.03280951f, 0.28511518f, -0.28654259f, -0.17441210f, -0.10897512f, 
    -0.22581063f, 0.09781432f, 0.01429422f, -0.25863078f, 0.09637285f, 0.23973036f, 0.12565424f, -0.55188084f, 
    -0.52713275f, 0.28755388f, -0.27441546f, 0.00032067f, 0.28959838f, -0.29572007f, -0.06948802f, 0.43382475f, 
    0.03274499f, 0.42566767f, -0.01607456f, -0.40771288f, -0.12631920f, -0.02127275f, -0.22728832f, -0.21089143f, 
    -0.34957013f, 0.33620512f, 0.04662376f, 0.21077961f, 0.06754970f, -0.01480642f, -0.29502270f, -0.13531230f, 
    -0.32417640f, -0.23662630f, -0.08163986f, -0.24426317f, -0.40101245f, -0.11155680f, -0.24709037f, -0.38573059f, 
    0.10492495f, 0.36240092f, -0.14293186f, 0.06650563f, 0.46366012f, 0.04316841f, 0.02860204f, 0.01119632f, 
    -0.16852491f, -0.10150041f, -0.04524248f, -0.04015347f, 0.03681749f, 0.03105277f, 0.27985579f, -0.03413568f, 
    -0.63373846f, -0.61780214f, -0.27722603f, 0.35946041f, -0.22182371f, 0.44727808f, 0.77264678f, -0.25095811f, 
    -0.28980577f, 0.15361214f, 0.01018079f, -0.12794699f, -0.04331714f, -0.18457395f, 0.12630486f, 0.03166290f, 
    -0.01912544f, 0.12468293f, 0.34924042f, -0.10128467f, -0.07247319f, 0.02594116f, -0.23589958f, -0.27270931f, 
    0.66046572f, -0.31802085f, -0.10837933f, -0.58795023f, -0.37750039f, 0.15286604f, -0.20779982f, 0.21998321f, 
    0.11462496f, -0.12748216f, 0.33563194f, 0.06952299f, 0.20809239f, -0.37879795f, -0.01551745f, -0.26825380f, 
    -0.05955198f, 0.01180653f, 0.20079118f, 0.05004210f, 0.20445788f, 0.20714699f, -0.11340010f, -0.23312131f, 
    -0.32476476f, 0.03481580f, 0.20410307f, 0.08862529f, 0.24882050f, 0.01526949f, -0.06790484f, -0.47949353f, 
    -0.19055307f, 0.28800398f, 0.15494886f, 0.18282215f, -0.31005552f, -0.07979476f, -0.07999229f, -0.03657300f, 
    -0.12847592f, 0.18809645f, -0.19616728f, 0.13207711f, -0.31894559f, 0.00441923f, 0.00304293f, -0.12943152f, 
    0.32340065f, 0.21107605f, 0.56335026f, 0.49699396f, 0.16879413f, -0.07017065f, 0.49560711f, -0.11803734f, 
    -0.09720337f, -0.42698556f, -0.49047968f, -0.44464985f, -0.12779427f, 0.00271837f, -0.03257022f, -0.27797976f, 
    -0.17943436f, -0.05773468f, 0.13012645f, 0.01701652f, -0.07174238f, -0.09937910f, -0.01634496f, 0.15604116f, 
    0.10384097f, 0.11166038f, -0.23174793f, 0.49011829f, 0.18609020f, 0.19537963f, 0.35292822f, -0.34222618f, 
    -0.34676272f, -0.30648488f, 0.12903905f, 0.36817157f, 0.17731822f, 0.00286705f, -0.19319649f, -0.13844740f, 
    -0.03918158f, -0.17022569f, -0.01018385f, 0.02831950f, -0.08881775f, 0.07361391f, 0.03786441f, -0.29914430f, 
    -0.14853802f, -0.14583707f, 0.06623700f, -0.10592363f, -0.65385139f, 0.59988302f, -0.02511083f, -0.73583692f, 
    -0.44510105f, 0.22896427f, -0.11534794f, 0.40396833f, 0.14599359f, 0.04928194f, -0.14751527f, -0.21624656f, 
    -0.04889386f, -0.19638202f, -0.06956829f, 0.22271444f, 0.07780893f, 0.05210966f, 0.04057243f, 0.00171957f, 
    -0.14085074f, 0.05306336f, -0.25749093f, -0.25980812f, -0.42790106f, -0.00696315f, -0.24952659f, -0.02765848f, 
    0.60823029f, -0.18698700f, -0.26445547f, -0.34706515f, -0.24029431f, -0.11531333f, -0.03431798f, 0.55540377f, 
    -0.29788807f, 0.01694725f, 0.15674728f, -0.27253938f, 0.21555240f, 0.22361945f, 0.13064818f, -0.24550846f, 
    -0.36458459f, -0.03467761f, 0.08660629f, 0.18050000f, 0.06038396f, 0.20458944f, -0.52948391f, -0.33754373f, 
    -0.17000671f, 0.07258239f, 0.20906101f, 0.11758148f, -0.08815978f, -0.33736977f, -0.14590192f, -0.04634340f, 
    -0.11068553f, -0.27552381f, -0.21343040f, -0.19051726f, -0.02628797f, -0.12074533f, 0.24028826f, 0.03011044f, 
    -0.21137393f, 0.00390941f, -0.02366319f, -0.21160161f, -0.20019254f, 0.02912917f, -0.07673309f, 0.27258670f, 
    0.10228500f, 0.31590205f, 0.20874144f, -0.35446298f, 0.09227593f, -0.24548732f, -0.44428474f, -0.66412276f, 
    -0.62010258f, 0.18584158f, -0.08941654f, -0.20800292f, -0.23487297f, -0.12841465f, -0.24432854f, -0.30937481f, 
    0.12180540f, -0.04810410f, 0.02785056f, -0.10544186f, 0.04852782f, -0.18119155f, -0.19191878f, -0.31659511f, 
    0.36049679f, 0.18952057f, -0.10655637f, -0.41422153f, 0.19055636f, -0.11679964f, 0.31394112f, 0.17664011f, 
    -0.14204174f, -0.35442561f, 0.04289253f, 0.27293515f, 0.16602296f, -0.22794870f, -0.16729653f, -0.30419591f, 
    -0.33013394f, 0.09043492f, 0.04855824f, 0.28774068f, 0.40234202f, 0.13682398f, -0.32564008f, -0.19225863f, 
    -0.16307709f, -0.51864141f, -0.42874923f, -0.13304934f, -0.17327492f, -0.22657278f, 0.57066548f, -0.08126815f, 
    -0.16105033f, -0.07966555f, 0.76233417f, 0.24165075f, -0.19175181f, 0.14973095f, 0.00188551f, 0.16923027f, 
    0.03403098f, -0.01190519f, 0.01210941f, -0.23534307f, -0.28152055f, 0.11334342f, -0.06773068f, 0.26754099f, 
    0.00936342f, 0.31458378f, -0.27447581f, 0.27700797f, 0.10585880f, 0.29368928f, 0.17197730f, -0.39304903f, 
    -0.09669796f, 0.28668529f, 0.01690417f, -0.00257092f, 0.44059855f, -0.12915556f, -0.03842894f, -0.13262275f, 
    -0.03717803f, -0.00853491f, 0.10198649f, -0.30082965f, -0.18841641f, -0.14785776f, 0.18343306f, -0.08160990f, 
    -0.03199079f, 0.16317244f, -0.02507524f, 1.30424070f, -0.82640326f, -0.56220096f, -0.33258611f, 0.02511356f, 
    0.38836166f, 0.14588302f, 0.24676847f, 0.09483391f, 0.20690884f, -0.14477959f, 0.45300218f, -0.32202640f, 
    -0.09588312f, -0.18191729f, 0.11038209f, -0.04316283f, 0.20420818f, -0.14128646f, -0.30563006f, 0.08375824f, 
    -0.00761356f, -0.06812568f, 0.04339035f, 0.16099818f, -0.55313593f, -0.14201827f, 0.24107723f, 0.57333571f, 
    0.35026166f, -0.22395997f, -0.39866504f, 0.37775525f, -0.30354953f, -0.39590001f, -0.03392740f, -0.17410924f, 
    -0.14970843f, 0.47564378f, -0.23223439f, 0.13106081f, 0.18856205f, 0.08936772f, -0.27963379f, 0.23620731f, 
    -0.29330358f, -0.01528122f, -0.11862702f, 0.01559270f, 0.24389458f, -0.50085992f, -0.52243280f, 0.19443835f, 
    0.46112040f, 0.51535714f, 0.30688918f, -0.03877978f, -0.14705254f, 0.12099619f, 0.34189606f, -0.03365029f, 
    0.18243189f, -0.22109503f, 0.02250813f, -0.00365859f, -0.16603631f, 0.06644312f, -0.11531932f, -0.12250876f, 
    -0.21705891f, -0.12089040f, -0.01479406f, -0.11973137f, -0.04984618f, -0.21855526f, 0.07695590f, -0.15490709f, 
    -0.38411453f, -0.15590519f, -0.20839703f, -0.04338595f, -0.51223224f, -0.23798998f, -0.06234217f, -0.55637914f, 
    0.48703253f, -0.13889666f, -0.01564986f, 0.34447211f, 0.30301681f, 0.10540865f, -0.03082987f, 0.06590520f, 
    0.18341230f, 0.11466777f, 0.09064400f, 0.12320732f, 0.17109352f, -0.09711878f, -0.04586884f, -0.33203536f, 
    0.19670790f, -0.32276934f, 0.25469041f, -0.38266650f, -0.10179625f, 0.00536186f, -0.33542734f, -0.31784293f, 
    0.47472271f, -0.23536311f, -0.10578230f, -0.16864909f, 0.14683323f, 0.11622110f, -0.07166590f, -0.20457681f, 
    -0.07534503f, -0.21415693f, -0.48206073f, 0.25231335f, -0.42691857f, 0.14498796f, -0.11595383f, 0.05597837f, 
    0.55555779f, -0.56856638f, -0.23837039f, 0.29906651f, -0.23028080f, 0.01314009f, 0.01252925f, -0.04139592f, 
    0.22210856f, 0.06747042f, -0.15710002f, 0.44107708f, -0.42831308f, 0.11136535f, -0.07623181f, -0.11898485f, 
    0.02206130f, -0.17807989f, 0.23009314f, 0.03495298f, 0.22503060f, -0.12953849f, -0.21180512f, 0.08086917f, 
    0.25010327f, -0.19652854f, -0.39918724f, 0.18497428f, 0.69987011f, -0.25563034f, 0.15685669f, 0.06601156f, 
    -0.42060000f, -0.14438993f, -0.14430009f, 0.24873157f, -0.12579359f, -0.14864470f, -0.07600135f, -0.15659572f, 
    0.18362862f, 0.18153200f, 0.06025732f, -0.22449571f, -0.02813967f, -0.03941904f, -0.05404908f, 0.09863012f, 
    0.08609845f, 0.12998959f, -0.17270543f, -0.35403413f, -0.54326141f, 0.17160051f, -0.06904775f, 0.10126290f, 
    0.70396036f, 0.21573512f, -0.07830011f, -0.66426748f, 0.03378051f, 0.08051988f, -0.23163360f, -0.00183509f, 
    -0.07242668f, -0.33253676f, -0.39259639f, -0.24735335f, 0.58631581f, -0.11126887f, 0.38287443f, 0.05444046f, 
    -0.09029905f, -0.13421698f, -0.20134318f, 0.40063795f, 0.30511859f, 0.25732332f, -0.22172146f, -0.36213800f, 
    0.14047094f, -0.01291413f, -0.41094801f, -0.18462259f, 0.34781051f, 0.06011261f, 0.19641170f, 0.05650087f, 
    -0.41454574f, 0.18053694f, -0.10913972f, -0.05595341f, 0.24251121f, 0.34206843f, -0.55491012f, 0.03268104f, 
    0.03037892f, 0.17221721f, 0.11987274f, -0.22221914f, 0.46819639f, -0.82738930f, -0.31216064f, -0.09127180f, 
    0.87040418f, 0.26122171f, 0.04330355f, 0.17783228f, 0.05320172f, -0.05020924f, -0.12047150f, -0.08403116f, 
    -0.08311602f, -0.11347529f, 0.52951205f, -0.20334792f, -0.11205460f, 0.06932992f, 0.03737425f, -0.32233182f, 
    0.01952516f, -0.01791012f, -0.14466980f, -0.04484067f, 0.15848336f, -0.22250842f, -0.34829044f, 0.30336675f, 
    0.32773086f, 0.10444058f, -0.17109446f, -0.09098294f, 0.08851423f, 0.32649890f, -0.12280105f, -0.11104865f, 
    -0.45600313f, -0.06859499f, 0.33916822f, 0.15980501f, 0.35308689f, 0.18833190f, -0.35256463f, -0.36181611f, 
    0.04364852f, 0.21374796f, -0.25605041f, -0.15946437f, 0.09438562f, 0.10041445f, 0.94895393f, 0.35027304f, 
    -0.13282590f, -0.63205826f, -0.83565140f, 0.44339296f, 0.44662428f, 0.05742878f, -0.49968278f, 0.00404944f, 
    -0.14860052f, 0.25922999f, -0.23138410f, 0.18245204f, -0.19856638f, 0.37962106f, -0.27460578f, 0.09907795f, 
    -0.03581680f, -0.14974427f, 0.16521433f, -0.10240170f, -0.33448997f, 0.10353406f, 0.31994480f, 0.41160524f, 
    -0.18362765f, -0.15414743f, -0.11879773f, 0.12921597f, 0.00194058f, 0.09963197f, -0.05611722f, 0.08666970f, 
    0.20457713f, -0.29910406f, 0.07406870f, 0.17101790f, -0.15542017f, 0.24209113f, -0.29862514f, 0.12561344f, 
    0.18674591f, -0.34894168f, 0.21281473f, -0.18344653f, 0.30330420f, 0.06450962f, -0.22185904f, -0.04439126f, 
    0.02190535f, -0.38267064f, -0.26209530f, -0.06063840f, -0.07708277f, -0.23211831f, -0.18007591f, -0.41300178f, 
    -0.08266314f, 0.16023858f, -0.03812124f, -0.38309741f, -0.19969046f, 0.00987490f, 0.03305010f, -0.19670676f, 
    -0.12458988f, -0.22747387f, -0.18301819f, -0.04360140f, -0.38045016f, -0.26813459f, -0.00028428f, 0.17874369f, 
    -0.37165958f, 0.40376353f, 0.27874547f, -0.23509651f, 0.14167620f, -0.06187048f, -0.21293536f, 0.09067336f, 
    -0.04657188f, -0.04694903f, -0.14788595f, 0.25598574f, -0.38895503f, 0.20119934f, 0.26190412f, -0.14405733f, 
    -0.00415645f, 0.08586822f, 0.10859827f, -0.09232533f, -0.02057382f, -0.15576144f, 0.21260425f, 0.16195111f, 
    0.21108451f, -0.09163493f, 0.68137062f, 0.15009288f, -0.05192821f, 0.20319478f, 0.09595137f, -0.10552876f, 
    0.26051858f, 0.11681674f, -0.14256743f, -0.07874621f, -0.04233409f, -0.06685055f, -0.04366371f, -0.15088676f, 
    -0.12561378f, -0.05667771f, 0.25933948f, 0.01091825f, 0.16047020f, -0.15813199f, 0.13740486f, -0.28757694f, 
    -0.37660062f, -0.38210091f, -0.43250862f, 0.71921265f, -0.59906226f, -0.56149787f, 0.26321447f, -0.24739888f, 
    0.14419860f, 0.24051018f, 0.10956141f, 0.10837026f, -0.35146391f, 0.10395771f, 0.22342506f, -0.04027252f, 
    -0.28655922f, 0.16377799f, 0.02235463f, -0.09067299f, -0.03024122f, -0.34495148f, 0.36258420f, -0.07400142f, 
    -0.19534624f, 0.06547628f, 0.35338542f, -0.00207869f, -0.69782835f, -0.19998634f, 0.73607427f, -0.28948015f, 
    0.35386661f, 0.09413476f, -0.47853884f, -0.49964011f, -0.13299924f, -0.02700946f, 0.16403721f, 0.42298630f, 
    -0.18150438f, 0.49875423f, -0.32571161f, 0.23745963f, -0.32834598f, -0.14510390f, 0.08823864f, -0.05594578f, 
    -0.03816851f, 0.17659743f, 0.01131493f, -0.08155122f, -0.00889448f, -0.36990613f, -0.50093836f, 0.13263206f, 
    0.72498429f, -0.29752183f, 0.24300422f, -0.47987989f, -0.53865176f, -0.37325624f, -0.12017159f, -0.19769251f, 
    0.00748727f, -0.07786766f, -0.16414611f, -0.00038241f, -0.05327231f, -0.19693397f, 0.10383899f, 0.03758573f, 
    -0.17385294f, 0.04039283f, -0.08886196f, -0.11953551f, 0.06624434f, -0.00729288f, 0.33272329f, -0.32366884f, 
    -0.11929753f, -0.38282311f, -0.61286694f, 0.55002207f, 0.22054821f, -0.03411524f, -0.25635743f, 0.27839059f, 
    0.06979951f, 0.28479302f, -0.26530179f, -0.24039821f, -0.03795149f, -0.48854950f, 0.04739796f, 0.09113416f, 
    -0.29254144f, -0.05636917f, -0.18202820f, 0.04807478f, 0.32557273f, 0.21669140f, -0.15456118f, -0.62470955f, 
    0.82219428f, -0.18479353f, -0.62807196f, 0.13392121f, 0.26638523f, -0.18755233f, -0.05656376f, -0.57197213f, 
    -0.35457352f, -0.08060255f, 0.10497805f, 0.02958168f, -0.14157337f, 0.24090759f, 0.16455686f, -0.52313191f, 
    -0.24286191f, 0.12257596f, -0.21195643f, -0.15529482f, 0.30630809f, -0.08289846f, 0.00892366f, 0.28836268f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.12327689f, 0.15323375f, -0.01192609f, 0.18278039f, -0.13581108f, -0.09734786f, -0.03524534f, -0.20872000f, 
    -0.17118856f, -0.19683866f, -0.20573053f, 0.04742152f, -0.14206207f, -0.00394555f, -0.08091467f, 0.09658775f, 
    -0.08232184f, 0.14289632f, -0.18932302f, -0.03124020f, 0.23748155f, 0.22386961f, 0.01510611f, 0.13174658f, 
    0.11831482f, -0.10679283f, -0.30499947f, -0.12095487f, -0.02921743f, 0.04450727f, -0.29187745f, -0.17078367f, 
    0.12881872f, 0.00118278f, 0.00774705f, -0.05942959f, -0.17770514f, 0.08643097f, -0.06421911f, -0.05592218f, 
    0.06453311f, 0.12912525f, 0.13635491f, 0.01480873f, 0.19002700f, -0.13348474f, -0.20710532f, -0.18467768f, 
    0.11232550f, 0.19419554f, -0.00206994f, 0.08071239f, 0.03137439f, 0.08525697f, 0.22298959f, -0.07887795f, 
    -0.06697054f, 0.05440075f, -0.12919568f, 0.12253741f, 0.08545907f, 0.03826108f, -0.10145847f, -0.03985585f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.03066908f, -0.07633236f, -0.08616478f, 0.03142648f, 0.06765042f, -0.00601528f, -0.00969226f, -0.05496442f, 
    -0.02965578f, 0.02595318f, 0.03831718f, 0.07836302f, -0.05481454f, 0.09472979f, 0.39425302f, 0.18297991f, 
    -0.05794049f, -0.01884707f, 0.05611441f, 0.17337681f, -0.11529055f, -0.02086374f, -0.01529155f, 0.04196639f, 
    -0.28478289f, 0.37527275f, 0.04499574f, 0.08689769f, 0.14847983f, 0.09134591f, 0.12225500f, 0.07078759f, 
    0.17831035f, 0.12313110f, -0.02844242f, 0.15310907f, 0.59818220f, 0.13937478f, -0.15350339f, 0.24526355f, 
    -0.09030462f, 0.04309276f, -0.04643276f, 0.16124919f, 0.01224492f, -0.08099300f, 0.16274337f, -0.02418402f, 
    -0.00167785f, -0.05949941f, 0.12934539f, -0.19688202f, -0.09577541f, 0.08204591f, -0.03868511f, 0.04453332f, 
    0.07790530f, 0.17413604f, 0.15002763f, 0.16683078f, -0.07546094f, -0.13743067f, 0.14367998f, 0.01782094f, 
    -0.10273597f, -0.02436458f, 0.00358429f, -0.03328728f, 0.06710109f, -0.08544016f, 0.10633063f, 0.07281598f, 
    0.36828974f, 0.31230551f, -0.55235118f, 0.09161822f, -0.00447831f, -0.09959873f, 0.05904303f, -0.00040910f, 
    -0.11260312f, 0.15688731f, -0.01475281f, -0.02426527f, 0.12317155f, -0.26012844f, -0.19880122f, -0.09943036f, 
    0.01454137f, -0.05124781f, 0.11309072f, 0.08913495f, -0.02685498f, -0.04109024f, 0.04336547f, 0.12282304f, 
    -0.02854929f, 0.42848334f, -0.12145752f, -0.36619326f, -0.05117662f, -0.04358016f, 0.11268106f, -0.00715925f, 
    0.06048053f, 0.12378401f, -0.09266334f, -0.12654079f, -0.02096522f, -0.20982818f, 0.14966170f, 0.06041683f, 
    -0.03302419f, -0.08819220f, -0.00639794f, -0.02861316f, -0.21638519f, -0.03367951f, 0.05261417f, -0.11841413f, 
    -0.20146562f, -0.13967109f, 0.00844826f, 0.21415058f, -0.09593866f, 0.02836794f, 0.06207575f, 0.00526298f, 
    -0.09386334f, -0.07787096f, 0.00608672f, 0.08063886f, 0.00908276f, 0.11740103f, -0.05796339f, -0.15447856f, 
    -0.07406295f, 0.02491658f, -0.03714105f, -0.10945324f, -0.06593794f, 0.01119963f, 0.13055789f, -0.02689835f, 
    -0.04841658f, -0.09546474f, -0.15446436f, 0.00664354f, -0.10037757f, -0.08448323f, 0.09036709f, -0.18024386f, 
    -0.10383248f, 0.03814468f, -0.02944344f, 0.03282064f, -0.01351646f, 0.04003669f, 0.27877447f, 0.26566920f, 
    -0.08532646f, 0.00544152f, 0.13388318f, 0.09371890f, 0.07096579f, 0.00755951f, 0.11426887f, 0.04467833f, 
    -0.01354333f, -0.00765043f, -0.05409641f, -0.04004452f, 0.01436438f, -0.00702212f, -0.05993762f, -0.00810216f, 
    -0.02578732f, -0.06630672f, 0.10320452f, -0.00559703f, -0.05176741f, 0.19145310f, -0.23361592f, -0.17197080f, 
    0.14500453f, -0.06605241f, -0.06301157f, -0.04473012f, -0.13219546f, -0.03612060f, 0.10839024f, -0.02357411f, 
    -0.05580257f, -0.21900310f, -0.02742865f, 0.06917585f, 0.25852385f, 0.16085410f, -0.02050605f, -0.13097066f, 
    0.05043682f, 0.10403243f, 0.12436720f, 0.03782264f, 0.13290906f, -0.04167083f, 0.12102204f, -0.26136559f, 
    0.01173822f, -0.05407145f, 0.00260978f, 0.18029429f, 0.10319543f, 0.13787602f, -0.00353052f, -0.04229622f, 
    -0.03708703f, 0.07268534f, 0.06517931f, 0.42881298f, 0.13101026f, -0.16669293f, 0.14254259f, 0.10867639f, 
    -0.02470762f, 0.02292103f, 0.07987768f, 0.05238915f, 0.06948423f, -0.11651605f, 0.02375022f, -0.10584039f, 
    -0.14179094f, 0.05249869f, -0.10624969f, 0.02611185f, -0.04988347f, 0.04273733f, -0.03788516f, 0.13927574f, 
    0.20104824f, 0.09576812f, -0.03256725f, -0.10083342f, -0.06317676f, 0.07315289f, -0.07136627f, -0.04541221f, 
    -0.05825537f, 0.11832314f, 0.06252383f, 0.00961209f, -0.00606536f, -0.03492734f, 0.14690709f, 0.11658022f, 
    0.04341366f, -0.05339538f, 0.00374018f, 0.07810670f, 0.01414543f, -0.03877435f, -0.04026926f, 0.10823321f, 
    -0.12339546f, -0.06535843f, -0.05265841f, -0.09784589f, 0.10045594f, -0.12027451f, 0.05043816f, -0.03685924f, 
    -0.05786784f, 0.01500842f, 0.02169877f, -0.04973125f, -0.01414888f, -0.06165778f, 0.02087870f, 0.26320764f, 
    0.02455585f, -0.07448066f, 0.09957023f, -0.18993777f, -0.06604797f, 0.08483336f, -0.15465692f, 0.07542260f, 
    0.25490490f, 0.02401127f, -0.09919684f, -0.03880848f, -0.03733938f, -0.00629964f, 0.02870213f, 0.08328608f, 
    0.19842875f, 0.11783039f, 0.06986258f, 0.04148382f, -0.35967553f, -0.06372500f, -0.10002742f, 0.06322140f, 
    -0.04235473f, -0.15808956f, -0.10096531f, -0.09730469f, -0.15350291f, -0.08424278f, -0.08118870f, 0.04916780f, 
    0.03843969f, -0.21108410f, -0.18535733f, -0.04727973f, -0.06023283f, -0.01431524f, -0.01292794f, 0.04911701f, 
    0.02421553f, -0.22047041f, -0.06026182f, 0.02690811f, 0.06703974f, -0.06793709f, -0.20011400f, 0.01590158f, 
    -0.03188937f, 0.05347982f, 0.04323655f, 0.05992821f, 0.06595679f, 0.02471894f, 0.04308643f, -0.00357582f, 
    0.02126451f, -0.15965836f, -0.19248480f, 0.05449354f, -0.06601343f, 0.08526841f, 0.07353691f, -0.08687939f, 
    -0.03251721f, -0.04041930f, -0.09053680f, 0.03725178f, 0.08448656f, 0.05439010f, -0.14137098f, -0.00507555f, 
    0.16975310f, -0.03279791f, 0.04836058f, -0.06567911f, -0.03975582f, 0.11785300f, 0.03122569f, -0.04340709f, 
    -0.01713458f, -0.20732845f, -0.20493035f, -0.00616215f, 0.01156346f, 0.07371283f, 0.02787970f, -0.14254360f, 
    0.01558254f, -0.07434712f, 0.04703487f, -0.02500253f, -0.04000203f, 0.24387132f, 0.06655640f, -0.06763339f, 
    -0.07620349f, 0.04803446f, 0.04426374f, 0.21813443f, 0.00694456f, -0.06971708f, -0.01066276f, -0.07866781f, 
    -0.04908755f, 0.22385252f, -0.19359402f, 0.14689445f, 0.06089102f, 0.11922953f, -0.07761282f, -0.03340382f, 
    0.05670935f, 0.00440313f, -0.00830903f, 0.24401945f, -0.09009927f, -0.05296564f, 0.03776978f, -0.28402901f, 
    -0.03668476f, -0.03808224f, -0.07675815f, 0.04049171f, -0.04160992f, -0.03492050f, -0.00028778f, -0.06852751f, 
    -0.32109189f, 0.00229162f, 0.22415684f, 0.15962847f, -0.01349197f, -0.00104253f, -0.07633542f, -0.04191878f, 
    -0.04542989f, -0.02657500f, -0.06363488f, -0.03497344f, -0.16907483f, 0.19594590f, -0.09085158f, -0.07480874f, 
    -0.17054556f, -0.03554466f, -0.01689202f, -0.08113434f, 0.00063783f, 0.03809277f, 0.01911732f, -0.02857040f, 
    0.28175968f, -0.09753882f, -0.08626282f, 0.19819389f, 0.09324460f, 0.05029502f, 0.15067263f, 0.06147930f, 
    -0.08806562f, -0.03893445f, 0.01498272f, 0.11299249f, -0.00078153f, -0.24609207f, 0.07305580f, -0.03507937f, 
    -0.03471285f, 0.03368849f, 0.02663959f, 0.02514964f, 0.02694422f, -0.05945794f, -0.05653962f, 0.01567912f, 
    -0.11684500f, -0.11862768f, -0.05104064f, -0.00278153f, 0.03480634f, 0.05131512f, -0.00542755f, -0.02480042f, 
    -0.05000481f, -0.01478018f, -0.02457513f, 0.05253979f, -0.26150450f, 0.02079454f, 0.16531517f, 0.13539898f, 
    0.21043642f, 0.14139600f, 0.01628992f, -0.08833731f, -0.05765116f, -0.02773660f, 0.05206606f, 0.05390555f, 
    0.03776908f, 0.01192292f, 0.12272478f, 0.02481495f, 0.12530491f, -0.07848590f, 0.06311274f, -0.15540716f, 
    -0.00815479f, 0.05624777f, -0.05449706f, -0.08694228f, 0.21829119f, -0.21051845f, 0.29319665f, 0.09961247f, 
    -0.00506604f, 0.01581013f, 0.04757184f, 0.16829133f, 0.12125764f, 0.03899693f, -0.06489420f, 0.03381425f, 
    0.17823981f, 0.06322257f, 0.00019946f, -0.16759636f, -0.02219182f, -0.13409412f, -0.05137980f, 0.07359819f, 
    -0.06607271f, -0.03795230f, -0.02848104f, -0.05025673f, -0.22080164f, 0.17164132f, -0.04383480f, -0.11186653f, 
    0.08142448f, 0.03754881f, 0.15680175f, -0.10404145f, 0.17110516f, 0.10630241f, 0.09573345f, 0.15972854f, 
    0.09337375f, 0.08542863f, -0.27563441f, 0.09692734f, -0.09095610f, -0.01941058f, 0.02788122f, -0.02886626f, 
    -0.06191177f, 0.06446295f, 0.07591619f, 0.08334389f, 0.14880122f, -0.04909509f, -0.03772890f, -0.19763856f, 
    -0.04893376f, -0.07244477f, -0.12751570f, 0.09572732f, 0.12101477f, 0.07381934f, 0.15438844f, 0.13172570f, 
    -0.28481147f, -0.23736225f, -0.10372315f, -0.15799527f, 0.05418607f, 0.04246269f, -0.14198183f, -0.01413883f, 
    0.05414313f, -0.08209541f, 0.01030804f, -0.00753589f, 0.15416847f, -0.20720378f, 0.04916847f, 0.10981897f, 
    0.04756617f, 0.05261456f, -0.02800912f, -0.03021840f, -0.05327233f, 0.13361682f, -0.10587760f, 0.08456903f, 
    -0.02617154f, 0.02204004f, -0.02636418f, 0.03393925f, 0.07933290f, 0.02017811f, 0.11226181f, -0.13281143f, 
    0.09040456f, -0.11598057f, 0.00501336f, 0.16852716f, -0.10262983f, -0.04580677f, 0.06441791f, 0.16508171f, 
    -0.02790341f, -0.00282997f, 0.01425805f, -0.02007553f, -0.05971667f, 0.06687189f, -0.04985648f, -0.01820750f, 
    -0.15464281f, 0.02718256f, 0.21421525f, -0.09475569f, -0.12718779f, -0.00278721f, 0.08549329f, -0.05153551f, 
    0.03071164f, 0.09506213f, 0.08384535f, -0.02613606f, 0.16535352f, -0.28628862f, -0.11577502f, -0.07889544f, 
    0.08320692f, -0.02525781f, -0.14507110f, 0.15237901f, 0.02142895f, -0.01202947f, 0.08666274f, -0.03369308f, 
    0.17186591f, 0.14728327f, 0.00893575f, -0.30039176f, 0.03758403f, -0.11843109f, -0.01984448f, 0.12832917f, 
    0.12626956f, 0.12818767f, 0.03678521f, -0.10031152f, 0.18816443f, 0.13824846f, -0.08175167f, -0.12409494f, 
    -0.19967195f, 0.15051220f, -0.11132043f, -0.03458802f, -0.04567280f, 0.03520966f, 0.08718231f, 0.06944891f, 
    -0.05292001f, 0.04742800f, 0.02203588f, 0.14452630f, 0.14570265f, -0.07477176f, 0.01653383f, -0.01961175f, 
    0.01235859f, 0.16136749f, 0.18016207f, -0.01835117f, -0.02684863f, -0.00429310f, -0.04166356f, -0.10750294f, 
    -0.03900347f, -0.08731022f, -0.03033797f, -0.01173106f, 0.05442411f, 0.02140733f, -0.03852038f, 0.08411524f, 
    -0.16568066f, -0.11105469f, -0.09721097f, -0.00987451f, 0.09330836f, 0.09045245f, 0.02151543f, -0.07833780f, 
    0.09284692f, -0.09006163f, 0.02640439f, -0.02314838f, -0.22229171f, -0.09645608f, -0.14139923f, -0.10857283f, 
    -0.07264891f, -0.11014769f, 0.01796503f, -0.00078819f, 0.00260816f, -0.11935814f, -0.00181595f, -0.07212552f, 
    -0.10143714f, -0.05998546f, 0.03323939f, 0.02679640f, -0.05743840f, -0.00953462f, 0.05374087f, -0.20205101f, 
    0.16304532f, 0.12899140f, 0.02765359f, 0.11525219f, -0.33893844f, 0.22147493f, -0.06014464f, -0.21900760f, 
    -0.15131474f, 0.07576938f, 0.06352389f, -0.15970829f, 0.19283240f, -0.04612745f, 0.01070697f, 0.00034559f, 
    0.23063980f, -0.19561332f, -0.05238465f, 0.06859561f, 0.16332066f, 0.10035609f, -0.21232687f, 0.03046531f, 
    -0.00009792f, 0.05539338f, 0.03775569f, -0.08984601f, -0.06428265f, 0.02461822f, 0.04074790f, 0.27876568f, 
    0.17367224f, -0.02020620f, 0.00140455f, -0.13760485f, -0.03905483f, -0.03027287f, 0.04219533f, -0.04176942f, 
    -0.20480402f, 0.02971073f, 0.15763903f, 0.26338047f, 0.02245547f, -0.04912126f, 0.00607464f, 0.01672491f, 
    0.13982140f, 0.05799965f, 0.13932031f, 0.06446265f, -0.01235654f, -0.10892560f, -0.02492657f, -0.01317886f, 
    0.29665551f, -0.18449847f, 0.07247879f, -0.22387515f, -0.01253417f, -0.00688392f, -0.01190586f, -0.06131646f, 
    -0.16240768f, -0.19598104f, 0.09575313f, 0.15186061f, 0.05531310f, 0.03870699f, 0.04211181f, 0.10306714f, 
    -0.09716189f, -0.03776167f, -0.14069016f, -0.02789399f, 0.20552379f, -0.21173432f, -0.20684128f, -0.24642253f, 
    -0.09608754f, -0.06397311f, -0.19315967f, -0.07480150f, -0.17464103f, -0.06986430f, -0.02865108f, -0.02460172f, 
    0.19752078f, -0.15335959f, 0.12890430f, -0.10673055f, 0.01934263f, -0.02618646f, 0.01628220f, 0.21696456f, 
    0.02627534f, -0.02284899f, 0.11670808f, -0.11171018f, 0.05137571f, -0.00936482f, -0.00605849f, -0.17228363f, 
    -0.02866969f, 0.10016637f, 0.12595306f, -0.04517113f, -0.02536289f, 0.00126434f, 0.05577203f, 0.14052808f, 
    0.28154036f, 0.18107699f, 0.11088550f, -0.12887174f, -0.02675045f, 0.02814082f, 0.05116459f, 0.06147671f, 
    -0.15205291f, 0.10541589f, -0.11641505f, -0.11065792f, 0.26183814f, 0.21015316f, -0.01712283f, 0.11727271f, 
    -0.08362987f, -0.15770820f, 0.14082421f, 0.09498411f, 0.10502723f, 0.12505968f, 0.01250631f, 0.03266657f, 
    -0.00722819f, 0.11866046f, -0.00583673f, 0.01070624f, -0.01669116f, 0.23407196f, 0.10720073f, -0.15478866f, 
    0.04406556f, 0.00724586f, 0.05137275f, -0.00025468f, 0.06536048f, -0.12523329f, -0.32660282f, -0.16994800f, 
    0.01000542f, 0.28966922f, -0.19488417f, 0.01195865f, -0.15657490f, -0.05731195f, 0.09601992f, 0.10662603f, 
    -0.15075374f, -0.12704623f, 0.12652987f, 0.26549071f, -0.01673305f, -0.02251713f, 0.02506594f, -0.02721417f, 
    -0.12387208f, 0.13451773f, -0.05541198f, 0.13587883f, 0.01907732f, 0.04350827f, -0.05027445f, 0.01207407f, 
    -0.01564962f, 0.06455871f, 0.08095103f, -0.05602808f, 0.11232457f, 0.07432345f, -0.12854271f, 0.00847228f, 
    -0.14516267f, -0.30623880f, -0.39039305f, -0.33359680f, 0.06044420f, 0.06097410f, 0.14131951f, 0.17756127f, 
    -0.07818698f, -0.05524289f, -0.13084191f, 0.18704221f, 0.16555561f, 0.01162012f, 0.09506359f, -0.01443633f, 
    0.02655819f, -0.00223102f, 0.01891726f, -0.08781078f, 0.11063081f, 0.11172532f, -0.05922791f, 0.14951372f, 
    -0.01291222f, -0.14311512f, 0.00412675f, -0.03408839f, 0.10284616f, -0.20497960f, -0.15558937f, -0.13663282f, 
    -0.17915489f, -0.03857775f, -0.03318506f, -0.00331842f, 0.07555921f, -0.27330950f, -0.28671202f, -0.27248472f, 
    -0.03277178f, -0.16377625f, -0.05668155f, 0.02239695f, -0.05631800f, 0.12616831f, 0.06844494f, 0.05369207f, 
    -0.15260206f, -0.17745496f, 0.01441637f, 0.13902771f, 0.01996996f, 0.10215458f, 0.12364753f, 0.20915371f, 
    -0.11827743f, -0.02047043f, -0.09558403f, 0.04507053f, 0.13249108f, 0.02951149f, 0.13366748f, 0.03152807f, 
    0.02891780f, 0.03915690f, 0.03507999f, -0.04201090f, 0.06634793f, -0.00621842f, -0.06226100f, -0.14101592f, 
    -0.21874748f, -0.17892642f, -0.08114360f, 0.09505935f, 0.06789339f, 0.07753276f, 0.08811317f, -0.01520427f, 
    0.07416818f, 0.03734635f, -0.04476812f, 0.07258052f, 0.28464428f, 0.05139863f, 0.21798085f, -0.10593627f, 
    0.05959493f, 0.06236772f, -0.03624486f, 0.04681648f, -0.19113342f, -0.13351806f, -0.08373902f, -0.03218704f, 
    -0.26388869f, -0.36533752f, -0.04491606f, -0.34569702f, -0.04641060f, -0.12083218f, 0.24286450f, 0.20192990f, 
    -0.07232910f, -0.12493265f, 0.07179496f, 0.03917847f, 0.11346904f, -0.01771114f, 0.09620025f, 0.00185511f, 
    -0.06203294f, 0.01864728f, 0.07167407f, 0.01220868f, -0.12474512f, -0.12598422f, -0.03018163f, -0.13476889f, 
    -0.27876332f, -0.02202769f, -0.01414990f, -0.07838517f, -0.05411543f, -0.08688079f, 0.07281463f, -0.11561256f, 
    -0.09914646f, 0.11065298f, -0.02693599f, -0.13064694f, 0.13588515f, -0.16877005f, -0.04867184f, -0.37357491f, 
    -0.01941012f, -0.08665869f, -0.13261481f, 0.04170467f, -0.01310557f, -0.02040627f, 0.11781998f, -0.03703161f, 
    -0.02782037f, 0.13918282f, 0.07901163f, 0.16091979f, 0.10312841f, 0.01293813f, 0.01646130f, 0.04600371f, 
    -0.09419382f, -0.01322998f, -0.08456712f, 0.03884806f, -0.08255733f, 0.00846868f, 0.14261624f, 0.15576825f, 
    -0.03333171f, 0.14939404f, 0.06554680f, -0.10694816f, -0.04070167f, -0.20012270f, 0.07346131f, 0.05752463f, 
    0.03548615f, 0.08152291f, 0.19205515f, -0.05703017f, 0.04676513f, 0.08664799f, -0.04399282f, 0.02125572f, 
    0.08901674f, 0.23135610f, 0.07130529f, 0.08269989f, 0.38216302f, 0.10529586f, 0.09716523f, 0.14827004f, 
    -0.03275282f, 0.08572445f, 0.04650564f, -0.00031477f, 0.05485845f, 0.02028297f, 0.05540502f, -0.00691906f, 
    0.14609945f, 0.03131154f, 0.00099374f, -0.02990427f, 0.04604898f, 0.04307226f, -0.00933775f, 0.03203637f, 
    -0.02146703f, 0.02146572f, -0.07378028f, -0.11298156f, -0.05947796f, -0.05737100f, -0.03160749f, 0.04982732f, 
    0.03754542f, -0.11824665f, 0.04532318f, -0.00241213f, -0.16325916f, 0.03130024f, 0.06951843f, 0.09542425f, 
    -0.47426984f, 0.36715198f, 0.33114004f, -0.23590389f, 0.02340474f, -0.01741164f, -0.10664164f, 0.11348212f, 
    -0.07623349f, -0.04289749f, 0.07523026f, -0.01765905f, -0.15235342f, 0.15659337f, 0.04468714f, 0.03684380f, 
    0.11509427f, 0.05157435f, -0.04192413f, 0.27952096f, 0.04882140f, -0.08507536f, 0.09038515f, 0.06796812f, 
    -0.10687070f, 0.00235565f, -0.07758801f, 0.02236716f, 0.00350672f, -0.21001749f, -0.01570284f, 0.15401460f, 
    -0.09144121f, -0.01946734f, -0.03833920f, -0.09826824f, -0.25464889f, -0.01741444f, -0.05617126f, 0.06524443f, 
    -0.03782862f, -0.09871089f, 0.14882900f, 0.01626270f, -0.13842241f, -0.08617590f, 0.10126344f, 0.22316685f, 
    0.09931874f, -0.02743573f, 0.13006753f, -0.20150216f, -0.03061247f, -0.00645849f, -0.02544425f, -0.13405330f, 
    -0.09595261f, 0.03138492f, 0.04099330f, 0.13661358f, 0.21719442f, 0.12123459f, 0.00344880f, 0.02401954f, 
    -0.08799770f, 0.08194717f, 0.04265147f, -0.05308192f, -0.07791781f, -0.04158857f, -0.06940563f, -0.02296419f, 
    0.47958705f, -0.00621777f, -0.02452569f, 0.07860596f, -0.02264593f, -0.01252680f, 0.10178266f, 0.02047055f, 
    -0.03514533f, -0.04907065f, 0.06483877f, 0.05100591f, 0.30009633f, 0.12914971f, 0.11340678f, 0.03621474f, 
    -0.03203186f, -0.02099835f, 0.03568397f, -0.00212627f, 0.06748667f, 0.14003234f, 0.16736162f, 0.04360455f, 
    -0.26115707f, -0.20621584f, 0.06637239f, -0.23823495f, -0.07305769f, -0.03284260f, 0.09445870f, 0.04090882f, 
    0.19489163f, -0.00853887f, 0.18769571f, 0.19272625f, -0.10097893f, -0.10337955f, 0.16936453f, -0.06677753f, 
    0.04703546f, 0.06327119f, -0.02964390f, -0.01727731f, -0.11732367f, 0.00372118f, -0.12161870f, -0.10244592f, 
    0.09908598f, -0.06893884f, -0.10986070f, -0.05466718f, -0.00624114f, 0.04425804f, 0.00681550f, 0.10483620f, 
    -0.10079070f, -0.06224942f, -0.13380092f, 0.12870198f, 0.34907535f, -0.13847587f, 0.09932101f, 0.16525877f, 
    -0.08867603f, 0.05919727f, 0.07275949f, 0.24164900f, -0.06483918f, -0.01318136f, 0.07968847f, 0.05735886f, 
    0.07510701f, 0.18590611f, 0.03915137f, 0.03875126f, 0.05687655f, -0.00300247f, 0.04168864f, 0.00871767f, 
    0.25256482f, 0.09305885f, 0.07873107f, 0.23758762f, 0.29350346f, 0.06373019f, -0.02989513f, -0.35914049f, 
    -0.04386966f, -0.14500912f, -0.03644181f, 0.06231835f, -0.01385393f, 0.11666349f, 0.10312740f, -0.18536459f, 
    0.18234892f, 0.18060486f, 0.15747580f, 0.04175241f, -0.06478120f, 0.04615939f, 0.00337482f, 0.02154112f, 
    0.01360393f, -0.00230239f, -0.08532282f, -0.06717672f, 0.20828214f, -0.12226371f, 0.05537394f, -0.00133965f, 
    0.11042152f, 0.01000879f, 0.01897069f, 0.07865499f, 0.09336073f, 0.15966123f, -0.00627055f, -0.14755578f, 
    -0.01083847f, -0.10989846f, -0.05296570f, -0.10175785f, 0.15728024f, 0.02721083f, 0.03981137f, 0.10226621f, 
    -0.11632925f, 0.09688563f, -0.03698085f, -0.05848264f, 0.10407669f, 0.02082825f, 0.15251397f, -0.05383658f, 
    -0.02878779f, 0.07819397f, 0.01720837f, 0.04275292f, 0.03256970f, 0.01202842f, 0.13357793f, -0.03725950f, 
    0.21598551f, -0.15177059f, 0.01640225f, -0.15707067f, -0.06645223f, -0.08592396f, -0.08481976f, 0.00367944f, 
    -0.10430641f, -0.08104178f, 0.03139497f, -0.04322530f, -0.09760093f, 0.03460567f, -0.18847451f, -0.00951186f, 
    -0.15999945f, -0.08389133f, -0.03311471f, -0.03141867f, 0.01314222f, 0.07161759f, 0.18954012f, 0.04603020f, 
    0.12292065f, -0.00775252f, -0.07141443f, -0.06303674f, -0.03866369f, 0.04674064f, 0.03392538f, -0.04899010f, 
    -0.00258892f, 0.01185751f, -0.09917016f, -0.05739218f, -0.03014099f, -0.20728712f, -0.11486818f, -0.17867632f, 
    -0.00783977f, 0.01184700f, -0.02778818f, -0.05981999f, -0.11072132f, 0.01485126f, -0.07880332f, -0.04179555f, 
    -0.02542554f, -0.11966711f, -0.17312461f, -0.04502629f, 0.10724729f, -0.19451486f, -0.04423508f, -0.01527150f, 
    -0.12425636f, 0.12799102f, 0.09817797f, 0.26377833f, 0.36396635f, 0.10930428f, -0.04700236f, -0.08139613f, 
    -0.12515588f, 0.12491121f, 0.21502602f, 0.04696457f, 0.10503397f, 0.05045937f, -0.01529234f, 0.04756365f, 
    0.15429436f, -0.00858554f, 0.05043952f, 0.05471643f, 0.09863406f, -0.00420295f, -0.02558554f, -0.13428138f, 
    0.08581524f, 0.10726847f, 0.06615023f, -0.02685525f, 0.12628202f, 0.26019159f, 0.20911108f, 0.06040005f, 
    -0.01978383f, 0.02202611f, 0.01500840f, -0.15952662f, -0.02053740f, 0.07696800f, 0.09750381f, 0.00696034f, 
    0.30182356f, 0.08226959f, -0.18084762f, 0.24328065f, 0.13069203f, -0.01846748f, 0.26045305f, 0.03388188f, 
    0.14291824f, 0.22989681f, -0.13280322f, 0.03336983f, 0.09540919f, 0.02879101f, 0.10842945f, -0.02216325f, 
    -0.02743016f, -0.03471593f, 0.02850169f, 0.09254453f, 0.10361602f, -0.07526048f, 0.05999744f, -0.10196427f, 
    0.11542966f, -0.00674005f, -0.05442748f, 0.09468506f, -0.08123557f, 0.08466177f, -0.07827025f, 0.20079425f, 
    -0.17530398f, -0.10008518f, 0.03714617f, 0.13746552f, 0.09727216f, 0.11894996f, 0.04106772f, 0.03015592f, 
    0.04504314f, -0.10610876f, 0.09449028f, -0.00282513f, -0.02821821f, -0.07149693f, -0.04579905f, -0.06805574f, 
    0.12040588f, 0.01515088f, 0.07259241f, 0.08687339f, 0.02436250f, -0.01910019f, 0.17320648f, 0.06646331f, 
    0.50694478f, 0.33970246f, 0.24419348f, 0.42481548f, 0.16215591f, -0.10926711f, -0.14781328f, -0.02615488f, 
    -0.01622098f, 0.02400958f, 0.09519226f, 0.07280800f, 0.05141174f, 0.08353868f, 0.11114076f, -0.02473296f, 
    -0.78889173f, -0.20763369f, 0.08605397f, -0.08224058f, -0.03093266f, 0.15755142f, 0.03038019f, -0.01872972f, 
    0.02998855f, 0.07463533f, 0.00035330f, 0.00719894f, -0.23554486f, -0.48417145f, 0.11509527f, 0.12361152f, 
    -0.03609340f, 0.08759646f, 0.02388019f, 0.14878365f, -0.02867547f, -0.05644348f, -0.10051239f, -0.06927571f, 
    0.04879089f, -0.25460550f, -0.18019150f, -0.18586886f, 0.06144492f, -0.08581574f, 0.15593913f, 0.11558214f, 
    -0.04771959f, 0.01950989f, 0.12361166f, 0.10024180f, -0.44523150f, 0.07615320f, 0.19485122f, 0.28886959f, 
    -0.10554066f, 0.00467123f, 0.08738910f, -0.11865182f, -0.09404240f, -0.07503632f, 0.00674347f, 0.13320947f, 
    0.04412048f, 0.16099221f, -0.02181850f, -0.19574670f, 0.08978593f, 0.09941325f, -0.00099376f, 0.04724769f, 
    0.04022121f, -0.01122703f, 0.06907674f, 0.02220917f, -0.13988870f, -0.20554526f, -0.02482372f, -0.02249163f, 
    0.17102173f, 0.07771537f, -0.01966904f, 0.01038788f, -0.04347605f, 0.01431772f, 0.05445499f, -0.00861813f, 
    -0.36240014f, -0.08260361f, -0.14916012f, 0.02235995f, 0.01170248f, 0.08047435f, -0.07007666f, -0.03412982f, 
    -0.02556459f, 0.12320782f, 0.06955388f, -0.02681687f, 0.54077333f, -0.08190633f, -0.08941283f, 0.07510876f, 
    0.02743183f, 0.02232652f, -0.02385228f, 0.06426492f, -0.01663010f, -0.03436506f, 0.09705956f, -0.04101039f, 
    0.23260117f, -0.07205444f, -0.06496076f, -0.01277807f, 0.06704299f, 0.03082767f, -0.02343632f, 0.02670233f, 
    -0.06489532f, -0.07758174f, 0.04188546f, -0.01336701f, -0.42073673f, -0.39635113f, 0.21940240f, 0.15564662f, 
    0.10506473f, 0.11119951f, 0.02269056f, -0.00646034f, -0.00990151f, 0.02170119f, -0.11511057f, -0.01400371f, 
    0.25636801f, 0.49549040f, -0.26043305f, -0.12535274f, -0.00123721f, 0.02340510f, -0.01556078f, -0.04206171f, 
    -0.12137500f, -0.11480565f, -0.07462108f, 0.10015792f, 0.27702761f, 0.15423252f, -0.09503002f, -0.14085242f, 
    0.10178372f, -0.08609566f, 0.16103482f, 0.10960657f, -0.02223806f, 0.01518642f, -0.03857619f, 0.02029940f, 
    -0.02716082f, 0.36675781f, -0.22558750f, -0.11774161f, 0.04118461f, 0.01460296f, 0.10259700f, -0.15572780f, 
    0.01008785f, 0.04836942f, 0.03678595f, 0.03492659f, -0.07540355f, -0.16359584f, -0.08001725f, -0.11341626f, 
    -0.00418715f, -0.14115880f, -0.05201490f, -0.03110627f, -0.07523038f, -0.14044377f, 0.07886838f, 0.06610382f, 
    0.08730099f, 0.02199147f, -0.08902126f, 0.02877175f, 0.12267138f, -0.06484751f, -0.07460778f, 0.05623585f, 
    -0.04760747f, 0.07338455f, 0.03452327f, -0.01662769f, 0.00210809f, -0.07991080f, 0.00596282f, 0.09022719f, 
    -0.04955348f, -0.03839076f, 0.02036954f, 0.09811796f, -0.12013971f, 0.04840273f, 0.02364337f, -0.15146804f, 
    -0.00440293f, 0.01999070f, -0.01704390f, -0.10361354f, 0.06245359f, 0.02549640f, -0.04130239f, 0.00916926f, 
    -0.01402623f, -0.03500743f, -0.00778459f, 0.00162706f, -0.19307089f, -0.06220229f, -0.10944214f, 0.13965282f, 
    0.13028567f, 0.10832423f, 0.07916818f, -0.01600483f, 0.00612630f, -0.01552752f, 0.00395472f, 0.02231568f, 
    0.08221748f, 0.20755759f, -0.11567153f, -0.07920427f, -0.00546784f, 0.09383232f, 0.04695714f, 0.00468418f, 
    0.10089722f, -0.05354652f, 0.01743208f, 0.08946833f, -0.24158435f, 0.00656246f, -0.20387219f, -0.02271867f, 
    0.00277337f, -0.03365624f, -0.08756121f, -0.18751238f, -0.03300928f, 0.10976175f, 0.15043655f, 0.05965307f, 
    0.00808550f, -0.01351316f, -0.00341567f, 0.06702078f, 0.08331070f, -0.05370558f, -0.02458967f, 0.01698743f, 
    0.06822543f, 0.07196186f, 0.04706407f, 0.05794261f, 0.03713134f, -0.00104015f, 0.12799111f, -0.41976878f, 
    0.11638873f, 0.05215976f, 0.02382871f, 0.00749351f, -0.02345666f, 0.04289850f, 0.10354619f, -0.08994867f, 
    0.30017638f, -0.16988173f, -0.10049144f, 0.22663400f, 0.02824046f, 0.09054597f, 0.01663203f, -0.02515531f, 
    0.09168281f, 0.01906849f, -0.02003095f, 0.12038752f, 0.00868645f, 0.02707542f, 0.03302592f, -0.07494780f, 
    -0.01404843f, -0.02344792f, -0.12410036f, -0.08414050f, 0.09881948f, 0.06836427f, -0.04704260f, 0.20982321f, 
    0.20227446f, 0.01667571f, 0.01497266f, 0.01144021f, -0.07679854f, 0.01189521f, -0.14232598f, 0.02410070f, 
    -0.01100881f, -0.02072206f, 0.07557208f, 0.08337290f, -0.06007729f, -0.21123603f, -0.07026844f, -0.04286062f, 
    0.08980427f, 0.00936488f, -0.01661107f, 0.01606960f, -0.03864780f, -0.00732660f, -0.03824741f, 0.06591120f, 
    -0.21929699f, 0.15170479f, -0.26941758f, 0.02566662f, 0.15595989f, 0.15041271f, -0.03462163f, -0.13530560f, 
    -0.01782448f, 0.02291725f, 0.08969574f, -0.07396483f, 0.11431164f, 0.14087760f, -0.21566570f, 0.00173697f, 
    0.11167333f, -0.02324622f, -0.02241113f, 0.01986868f, -0.07030574f, 0.08249333f, -0.05780577f, 0.06669167f, 
    -0.17932047f, -0.00089976f, 0.08186882f, -0.17161310f, -0.03639617f, 0.00207532f, -0.02180972f, 0.00400651f, 
    0.15381466f, -0.04730525f, 0.03350645f, -0.04080870f, -0.43649757f, -0.05198555f, -0.03018721f, -0.04487094f, 
    0.07322001f, -0.19492118f, -0.13511789f, 0.00026847f, -0.09057028f, -0.10987589f, -0.01717809f, 0.10054725f, 
    -0.22981535f, -0.21661708f, -0.19022916f, -0.15949719f, -0.16276290f, 0.08256609f, -0.02085882f, 0.06737914f, 
    0.05785637f, 0.01447816f, 0.07472900f, -0.02412324f, 0.09438315f, 0.06168566f, -0.14325631f, 0.01914803f, 
    -0.03997308f, 0.10718613f, 0.01195056f, 0.04743513f, 0.06919505f, 0.00645156f, -0.07688236f, -0.09766754f, 
    0.09487496f, -0.12010863f, -0.16024835f, -0.06108383f, 0.05919836f, 0.03065749f, 0.02501736f, -0.02269966f, 
    -0.13294379f, -0.09265298f, -0.11743761f, 0.04268567f, 0.08287770f, 0.12251534f, -0.10884583f, 0.07923080f, 
    0.13734469f, -0.00670893f, 0.10545407f, -0.14029151f, -0.07269713f, 0.11393014f, 0.09019259f, -0.02392585f, 
    0.11717211f, -0.10863345f, -0.15257449f, -0.08785745f, 0.24318467f, 0.13055751f, 0.08369771f, -0.07271020f, 
    -0.00759224f, -0.03956493f, -0.01782078f, 0.03446266f, 0.41739622f, 0.15886237f, -0.19969696f, -0.04124362f, 
    0.18426622f, 0.07183514f, 0.03406755f, 0.08007424f, -0.03803023f, -0.01942006f, -0.01517523f, 0.12155348f, 
    -0.17971118f, -0.06549866f, -0.25875404f, 0.19629449f, 0.02690818f, -0.00700608f, -0.01156382f, 0.06064284f, 
    -0.13160777f, -0.05565979f, 0.06043920f, 0.10976889f, 0.05642281f, -0.08602919f, 0.29186919f, -0.06515093f, 
    -0.06165050f, -0.08341973f, -0.00575111f, 0.02182463f, -0.01052408f, -0.07260280f, 0.07947123f, 0.06949518f, 
    -0.26394027f, 0.10144875f, 0.16596070f, 0.21291026f, 0.04202723f, -0.00250591f, -0.03097662f, 0.06592199f, 
    -0.03582023f, -0.05665467f, 0.01532676f, -0.02725505f, -0.19361445f, -0.03800640f, 0.16863085f, 0.01660017f, 
    -0.07817351f, -0.03723399f, -0.03745997f, 0.12247922f, 0.00372176f, 0.02009640f, -0.04197983f, 0.06090832f, 
    0.25975728f, -0.00300598f, -0.07331344f, 0.11832009f, 0.06081842f, 0.14736594f, 0.09075832f, 0.08223345f, 
    -0.06783596f, 0.03989741f, -0.03689715f, -0.00329686f, 0.15275900f, 0.00513931f, 0.14082631f, 0.06471935f, 
    -0.06639510f, 0.03181423f, 0.03311577f, -0.01579092f, -0.03963437f, -0.06955780f, 0.06646384f, 0.05987540f, 
    -0.01125389f, 0.05862973f, -0.05238954f, -0.02507483f, 0.04108496f, 0.07877566f, -0.00532259f, 0.07246335f, 
    0.00758920f, 0.08043074f, 0.00754449f, 0.03806772f, -0.09905238f, 0.08442477f, 0.02830934f, 0.14765801f, 
    0.01750643f, 0.19156893f, -0.02824163f, 0.03031863f, -0.01501932f, -0.02783206f, -0.05795150f, -0.01526534f, 
    -0.06139644f, -0.05133088f, 0.04151691f, 0.21399172f, 0.03348047f, -0.02856660f, -0.05485122f, -0.00104206f, 
    -0.04568849f, 0.09405738f, 0.11385878f, -0.14205264f, -0.07897115f, -0.28520006f, 0.06896492f, -0.13850236f, 
    0.03080003f, 0.09570968f, 0.04806594f, -0.11955173f, 0.04529588f, 0.11381110f, -0.09417816f, 0.11377279f, 
    0.14774165f, 0.01924895f, 0.23478755f, 0.05612470f, 0.02255556f, -0.05440371f, 0.02605521f, 0.05928234f, 
    -0.01056362f, 0.00523572f, 0.02875064f, 0.01049985f, -0.34387848f, 0.02005451f, -0.17574017f, -0.06357478f, 
    0.05055547f, -0.01675859f, 0.15719819f, -0.17616668f, 0.04227906f, 0.05435654f, 0.12594412f, -0.02537485f, 
    0.22860168f, 0.09754355f, 0.06836566f, 0.00899501f, -0.02830319f, -0.07940235f, -0.03762985f, 0.01351206f, 
    0.06860786f, 0.03486060f, 0.06402483f, 0.09000109f, -0.00006345f, 0.24227479f, 0.14573218f, -0.30639243f, 
    0.11661144f, -0.01388706f, -0.04194737f, -0.03156280f, 0.09620631f, 0.06355157f, 0.04184490f, 0.00041732f, 
    0.03957184f, -0.08769870f, -0.26089859f, -0.06154724f, 0.11546579f, 0.18660334f, 0.04601803f, 0.03832923f, 
    0.03491863f, -0.00336226f, 0.12574016f, -0.00866326f, 0.06327800f, 0.03536730f, 0.01362742f, -0.06419431f, 
    0.08805853f, 0.13795115f, 0.07175608f, 0.07749508f, -0.08498558f, 0.01024344f, -0.10670308f, 0.07394076f, 
    -0.33372974f, -0.09854460f, 0.03047574f, -0.08591267f, 0.03003506f, -0.10591906f, 0.14478661f, -0.13976580f, 
    0.01087453f, -0.00148263f, 0.11043469f, 0.06808111f, 0.03468493f, 0.13536653f, -0.00613275f, 0.15370886f, 
    -0.07083616f, -0.02650401f, 0.00330419f, -0.01338575f, -0.00190445f, -0.05341734f, 0.03952477f, 0.02329599f, 
    0.06722975f, 0.25832751f, -0.13892020f, -0.04096789f, -0.00801305f, 0.00965647f, 0.06301230f, 0.05680458f, 
    -0.07612351f, 0.05661109f, 0.18889454f, -0.05387533f, -0.32246473f, -0.03308177f, -0.13181829f, 0.11760337f, 
    -0.01743299f, 0.10275812f, -0.12993151f, 0.12226798f, 0.01338567f, 0.03348982f, 0.09423725f, 0.12246215f, 
    0.06848732f, 0.34367695f, 0.02891159f, -0.16411234f, 0.03385369f, -0.04731364f, -0.02749229f, -0.18018931f, 
    0.06557539f, 0.06726742f, 0.00996224f, -0.01850903f, -0.00162801f, 0.02611372f, 0.10512343f, -0.20701827f, 
    -0.02514622f, -0.00258483f, -0.01885710f, 0.12569132f, 0.00122818f, 0.08284435f, 0.02516429f, -0.03127391f, 
    -0.45304689f, 0.12595971f, -0.19292709f, 0.27174380f, -0.05328900f, 0.00213136f, -0.10460337f, -0.13592942f, 
    0.03324787f, 0.03417512f, 0.13431990f, -0.01367278f, -0.22106005f, -0.09222515f, -0.10835221f, 0.04491751f, 
    -0.02356666f, -0.17064670f, 0.01371058f, -0.04655046f, 0.13425048f, 0.09420817f, -0.00534817f, -0.09605805f, 
    -0.06308917f, -0.05458042f, 0.01095428f, -0.00102081f, 0.08662071f, 0.05622536f, 0.07550757f, -0.01010449f, 
    0.07065148f, 0.03572322f, -0.05988905f, 0.01165939f, -0.35056883f, -0.20528449f, -0.14258502f, 0.06460682f, 
    0.13828664f, 0.01925464f, -0.10668671f, -0.11335974f, 0.06364674f, 0.01360660f, 0.05636877f, 0.04659281f, 
    -0.19801047f, 0.03308728f, 0.07763044f, 0.18696062f, -0.05046895f, 0.01471382f, -0.03734601f, 0.01511003f, 
    0.03773668f, 0.11302889f, -0.16213126f, -0.16876452f, -0.37648192f, -0.07192829f, -0.13196859f, -0.12718569f, 
    0.00572089f, -0.08333140f, 0.07808844f, -0.05576244f, -0.07403292f, 0.03717713f, 0.04583823f, -0.16926555f, 
    0.27374870f, 0.10746719f, -0.16896796f, -0.20181425f, 0.02095584f, 0.09181695f, -0.11721779f, 0.07852219f, 
    -0.02268906f, -0.03149936f, -0.04268907f, 0.01977904f, -0.01104123f, 0.24606228f, 0.01706704f, 0.06849937f, 
    0.06442812f, -0.02451997f, -0.05275107f, -0.03528071f, 0.01221188f, 0.00772869f, -0.02273020f, 0.05121703f, 
    -0.12145400f, -0.17050254f, 0.00001422f, 0.09674137f, -0.01194242f, 0.01977840f, -0.02254405f, -0.05955714f, 
    0.11815470f, 0.08501614f, 0.03199217f, 0.04823793f, 0.12898453f, 0.18944724f, -0.10590680f, -0.07276220f, 
    0.12504198f, 0.09638675f, 0.06019988f, 0.00121381f, 0.04409130f, -0.04932644f, -0.07417875f, -0.08569285f, 
    -0.03522478f, 0.01887222f, -0.03691201f, -0.01327122f, -0.03078376f, -0.01497679f, -0.03762134f, -0.01743391f, 
    0.02263065f, 0.02418264f, 0.02948935f, 0.00611408f, 0.02199736f, 0.02981025f, 0.00738089f, -0.01762410f, 
    -0.02941134f, 0.02678926f, -0.01684874f, 0.01329960f, 0.02156323f, -0.00921893f, 0.00502676f, -0.02522977f, 
    0.00352996f, -0.03582731f, -0.00848227f, -0.00100645f, 0.02822747f, 0.00583834f, 0.02865346f, -0.01684207f, 
    0.01061329f, -0.02636896f, -0.00941291f, 0.00653054f, -0.02563638f, 0.01701047f, -0.03057415f, -0.01858479f, 
    -0.02897546f, -0.00913897f, 0.00653132f, 0.02202069f, 0.00858525f, -0.02971192f, -0.00834780f, -0.03246701f, 
    -0.03333774f, -0.02341226f, -0.01665753f, -0.03132531f, 0.01404366f, -0.01854397f, -0.02101405f, 0.01966842f, 
    -0.03154053f, 0.01337150f, 0.00409828f, -0.04045575f, 0.00799157f, -0.01145097f, 0.02154731f, -0.01908246f, 
    -0.03076462f, 0.02206345f, 0.02865243f, -0.02193334f, -0.03498311f, -0.00388275f, -0.02411772f, -0.03835064f, 
    -0.02451357f, -0.02376534f, -0.01220499f, 0.01268544f, -0.02486782f, -0.03163988f, -0.03880357f, 0.01398824f, 
    -0.03768550f, -0.03568196f, -0.01533189f, -0.00878206f, -0.00155298f, 0.02028606f, 0.02994517f, -0.03268792f, 
    -0.03815306f, -0.04202364f, -0.03787721f, 0.00907996f, -0.04108322f, -0.00101539f, -0.01543343f, 0.02596033f, 
    -0.02671468f, -0.02284713f, 0.02033366f, 0.02887041f, 0.02533379f, -0.04202308f, -0.01549192f, 0.00182814f, 
    -0.01958410f, 0.01313150f, -0.02918512f, 0.00717692f, 0.03017536f, -0.03825526f, 0.02104258f, -0.00841950f, 
    0.00863608f, -0.00368543f, -0.02133426f, 0.00524473f, -0.02941367f, -0.02477929f, -0.01365366f, -0.02162145f, 
    -0.00088188f, -0.02843406f, -0.00078609f, 0.02001640f, 0.03697725f, 0.01302416f, 0.00801203f, -0.00790162f, 
    0.00076039f, 0.01607665f, -0.00937808f, 0.01555558f, -0.00524832f, -0.00048174f, 0.01679538f, -0.02807649f, 
    0.00229423f, -0.04137573f, 0.02702159f, 0.01551326f, -0.03749222f, -0.02462953f, 0.00179697f, -0.00062866f, 
    -0.02821686f, -0.04093672f, -0.03617961f, -0.02203333f, 0.01088072f, -0.00003913f, -0.00196183f, 0.01141032f, 
    -0.01813495f, -0.00876660f, 0.00912895f, -0.03449269f, -0.01748335f, -0.02226879f, -0.01453125f, -0.00368807f, 
    -0.01007910f, -0.00975686f, -0.01646715f, 0.00333433f, -0.03548424f, 0.00682331f, 0.00171240f, 0.02956165f, 
    -0.02611717f, 0.02740841f, -0.01056924f, -0.02601172f, -0.00468299f, -0.02336880f, 0.01011850f, 0.00057718f, 
    0.02935464f, 0.00479084f, -0.01861217f, 0.00638180f, -0.01881099f, 0.01232037f, -0.02847836f, 0.02885644f, 
    -0.04061254f, 0.02082249f, -0.03197280f, 0.02841531f, -0.02669158f, -0.03427483f, -0.00751263f, -0.00954848f, 
    0.00940602f, -0.03565142f, -0.00267877f, -0.03629191f, -0.03316579f, -0.00289781f, -0.02766207f, -0.03712424f, 
    -0.03147799f, 0.00772691f, 0.02640571f, -0.00262769f, 0.01281244f, 0.01298318f, -0.01111237f, -0.00904230f, 
    -0.00294121f, 0.01305069f, -0.03580409f, -0.03797500f, -0.02807919f, -0.00223718f, -0.02992820f, -0.03367461f, 
    0.00866886f, 0.02881306f, -0.02659182f, -0.02118730f, -0.00185989f, 0.03809187f, -0.03697533f, 0.01404912f, 
    -0.00245193f, -0.00174650f, 0.01109537f, 0.00095897f, 0.00385968f, -0.01759472f, -0.01582367f, -0.00015786f, 
    0.00748651f, -0.00932915f, -0.01428490f, 0.00167224f, 0.02597600f, 0.02234821f, -0.01325769f, -0.02217608f, 
    -0.01332393f, -0.02864344f, -0.03671238f, -0.03032290f, -0.00767112f, 0.02421537f, 0.00393133f, -0.00302680f, 
    0.01056351f, 0.00800831f, -0.00805471f, 0.00525104f, 0.02381142f, 0.01138925f, 0.00117831f, 0.02245220f, 
    0.02642762f, 0.01383470f, -0.00527494f, 0.02786969f, -0.02335642f, 0.00322421f, 0.00726318f, -0.02868732f, 
    -0.03719264f, -0.03156491f, -0.00030644f, 0.01318183f, -0.01140954f, -0.01196886f, -0.03267621f, -0.03153799f, 
    -0.02270337f, 0.00187290f, 0.00004420f, -0.02957040f, -0.03268392f, 0.01389640f, -0.02109525f, -0.00994671f, 
    -0.00517933f, 0.02485151f, 0.03970548f, 0.02097771f, 0.01182756f, 0.02632538f, 0.03827011f, -0.00390723f, 
    -0.01682128f, -0.02544226f, 0.00667711f, -0.03964304f, -0.00899685f, 0.00261476f, -0.04066454f, -0.04158780f, 
    0.02139540f, 0.02041262f, 0.00912458f, -0.01235447f, 0.00242719f, -0.04130581f, 0.01637745f, -0.03668101f, 
    -0.01484452f, -0.00579909f, -0.01086797f, 0.02627915f, 0.00721001f, -0.02354749f, -0.02902085f, -0.03973622f, 
    -0.01911023f, -0.03019002f, -0.00445932f, 0.02531460f, -0.02208865f, 0.00430749f, -0.02478957f, -0.03968406f, 
    -0.01429542f, -0.00948100f, -0.03369053f, -0.01258743f, 0.01027437f, -0.01485984f, -0.02537885f, -0.02827597f, 
    0.01760426f, -0.02760988f, -0.00595251f, -0.03414983f, 0.02100314f, -0.01794057f, -0.01664037f, 0.01263192f, 
    -0.01757320f, 0.00355043f, 0.02503517f, -0.02381627f, 0.01505296f, -0.03872287f, 0.02653539f, 0.01766540f, 
    0.00772902f, 0.02553834f, -0.04165823f, -0.04163046f, -0.03508925f, 0.00693033f, 0.01271714f, 0.00522935f, 
    -0.03977567f, -0.00245091f, -0.02762428f, 0.01042533f, 0.02437877f, -0.00982677f, -0.02192906f, -0.04062838f, 
    -0.00094851f, 0.00740784f, -0.00884947f, 0.02783701f, 0.00146574f, 0.00747677f, 0.00387731f, -0.02845261f, 
    0.00373597f, 0.02811643f, 0.00015121f, -0.02552485f, 0.00752680f, -0.03162010f, 0.02059152f, -0.02794693f, 
    0.01401509f, -0.01890473f, -0.02275379f, -0.03776839f, -0.02383735f, 0.01731996f, 0.00633410f, 0.01028620f, 
    0.00722198f, -0.00887987f, -0.03198894f, -0.00835783f, -0.03158861f, 0.01314399f, 0.01192688f, -0.00784756f, 
    0.00734403f, -0.03542717f, -0.03372170f, -0.02814647f, -0.02026900f, 0.03327768f, 0.00696506f, -0.00633922f, 
    -0.00831256f, -0.03202688f, -0.03190421f, 0.02458533f, 0.01507478f, 0.02831346f, 0.00758113f, 0.02073525f, 
    -0.00737044f, -0.03240851f, 0.00894105f, 0.01759302f, -0.02245339f, 0.01984129f, -0.01244553f, 0.02242024f, 
    0.00770879f, 0.01255603f, -0.01063753f, 0.01970565f, 0.01238786f, -0.00161301f, -0.00401936f, -0.02468593f, 
    0.00099426f, -0.03002370f, 0.02195079f, -0.03225037f, -0.03635928f, 0.02598584f, -0.02382988f, -0.01851794f, 
    -0.03986829f, 0.01513674f, -0.00226323f, 0.01327663f, -0.03320834f, -0.00946618f, -0.01816108f, -0.01300314f, 
    0.01157959f, 0.02287844f, -0.02143160f, -0.02943853f, -0.02406844f, -0.02690943f, 0.00193829f, -0.02657649f, 
    -0.01710193f, 0.03003805f, -0.02356978f, -0.03898427f, 0.01357228f, -0.03207367f, -0.03231111f, -0.02491260f, 
    0.02967591f, 0.03412258f, -0.02042938f, 0.00311726f, 0.00430352f, 0.00394764f, 0.01076980f, -0.01182265f, 
    -0.00234279f, -0.01341111f, -0.03845726f, -0.03471517f, -0.02915697f, 0.02636566f, 0.02110624f, 0.00926219f, 
    0.01156714f, 0.00630470f, -0.03929997f, 0.02791778f, 0.00265325f, 0.01042511f, 0.01003768f, 0.01614348f, 
    0.01634274f, -0.03680060f, 0.01683974f, 0.03417828f, -0.03812259f, -0.01424262f, 0.01916827f, -0.02605468f, 
    -0.01888662f, 0.01145870f, -0.01313598f, 0.02445684f, 0.01787776f, 0.00743239f, -0.00665183f, -0.03370841f, 
    -0.03143833f, -0.00091001f, -0.02913520f, -0.00113265f, 0.02008867f, -0.02441870f, 0.01530694f, -0.01008883f, 
    -0.03487718f, 0.00827937f, -0.03278164f, -0.01155452f, 0.01811975f, 0.02665020f, 0.01995317f, -0.00759663f, 
    0.02509425f, -0.04101674f, -0.01161710f, -0.01758098f, -0.03595112f, 0.00825630f, -0.03345337f, 0.00812143f, 
    0.02822221f, 0.00612548f, 0.01469887f, 0.01840049f, 0.01907285f, -0.01934024f, -0.02474760f, 0.00768202f, 
    0.03862798f, -0.03703600f, 0.02656330f, 0.01490878f, -0.00122582f, -0.00616603f, 0.02053335f, 0.01541721f, 
    0.01169368f, 0.02314893f, -0.01477986f, -0.03492212f, 0.01753276f, -0.00284075f, -0.00980262f, 0.02833636f, 
    0.01234896f, -0.01955439f, -0.03347456f, -0.00733763f, 0.00407408f, -0.01966861f, -0.00002844f, 0.02906488f, 
    -0.02801860f, -0.02029795f, -0.03950826f, -0.00185800f, -0.00727838f, 0.02000767f, 0.01882306f, 0.00791654f, 
    0.00144873f, -0.02670472f, -0.01262289f, -0.00911523f, 0.00192998f, 0.00470286f, -0.02478619f, 0.01098190f, 
    -0.02345470f, -0.01579640f, -0.02850377f, -0.00636853f, -0.02993042f, -0.01962662f, 0.00426876f, -0.02942005f, 
    -0.02725372f, 0.02737787f, -0.00327355f, -0.00483068f, -0.03690750f, 0.01231253f, -0.01874555f, -0.03272326f, 
    -0.00098482f, 0.03563812f, -0.04167679f, -0.03939118f, 0.00128791f, -0.00002559f, -0.02777643f, 0.00249024f, 
    -0.03977106f, -0.01633387f, 0.01937052f, 0.02920402f, 0.02138729f, -0.03645413f, 0.00991306f, -0.00727996f, 
    0.02243089f, -0.00911028f, -0.01791257f, -0.00286500f, -0.00905822f, -0.03668419f, -0.01255659f, -0.03680851f, 
    0.01635796f, 0.02824817f, -0.02219685f, 0.01924729f, -0.02826095f, 0.01314446f, -0.02743471f, 0.01356278f, 
    0.00758082f, -0.01324517f, -0.00564009f, 0.02652434f, 0.01018932f, 0.00814246f, -0.02120977f, -0.01256009f, 
    0.02846030f, 0.00996555f, 0.02210932f, -0.00668274f, -0.02403183f, 0.00036001f, -0.01326177f, -0.03372723f, 
    0.01222424f, 0.02405660f, -0.03251201f, 0.02846815f, -0.01143743f, 0.00985712f, 0.02981365f, 0.01238778f, 
    0.01564413f, 0.02653632f, 0.00842721f, 0.00945278f, -0.01205609f, -0.02355437f, 0.01261424f, -0.03318042f, 
    0.01664924f, 0.00903483f, 0.01077583f, 0.00668253f, -0.01874562f, 0.00099763f, -0.01890503f, 0.01290021f, 
    -0.02920561f, -0.03493693f, 0.03995576f, 0.02114894f, -0.02066470f, 0.02050178f, -0.02916730f, -0.00121115f, 
    0.02347498f, -0.02441478f, -0.00925515f, -0.01432957f, 0.02636804f, -0.00372536f, 0.02949174f, -0.01183124f, 
    -0.02926338f, -0.00147772f, -0.02893844f, -0.01613237f, 0.00290722f, -0.01482932f, -0.03821420f, 0.02411653f, 
    -0.00105298f, 0.01999101f, -0.03098965f, -0.01438778f, -0.04044012f, -0.02277960f, 0.02254805f, -0.03618746f, 
    0.00381054f, 0.02735908f, 0.01246338f, 0.00629100f, 0.02714910f, 0.01586347f, -0.04120307f, 0.02440272f, 
    0.00980990f, 0.00091668f, -0.00017873f, 0.00358386f, 0.00192565f, 0.02720261f, 0.00419582f, 0.01380225f, 
    -0.03821494f, -0.01740405f, 0.01824066f, 0.00884323f, 0.01600878f, 0.00631791f, 0.02376742f, -0.01153884f, 
    -0.03194556f, -0.02095610f, -0.00239167f, 0.02148699f, 0.02682735f, 0.02894926f, -0.01596594f, -0.01957848f, 
    0.02794246f, -0.02694016f, -0.00820766f, -0.01922671f, 0.01280751f, 0.02216958f, -0.01437185f, -0.02404209f, 
    0.00900798f, -0.00880794f, -0.03101158f, 0.02967689f, 0.03548951f, 0.02915903f, -0.03097295f, -0.02737423f, 
    -0.02730210f, 0.00894028f, 0.00528578f, 0.00528942f, -0.03446345f, 0.00954918f, -0.01419197f, -0.03867790f, 
    0.00875416f, -0.02338294f, 0.01428148f, -0.01802603f, -0.02154367f, -0.00778703f, 0.00965864f, 0.02034390f, 
    0.00762564f, 0.01778126f, 0.00133194f, 0.03322165f, 0.02294075f, 0.01953952f, -0.00492277f, -0.02266577f, 
    0.00213929f, -0.01563610f, 0.00877762f, 0.02613457f, 0.01193239f, -0.01465219f, 0.01461135f, -0.01462419f, 
    -0.02781627f, 0.02945601f, -0.03309694f, 0.02526020f, 0.01197944f, 0.01506906f, -0.02129553f, -0.03112858f, 
    0.00901867f, -0.03901236f, 0.00432557f, -0.01004953f, 0.01224529f, 0.02629644f, 0.00297269f, 0.01943710f, 
    -0.02510662f, 0.02612206f, -0.01683684f, -0.01948551f, -0.02151594f, -0.00971648f, -0.02455484f, 0.01674150f, 
    -0.04232155f, -0.02032098f, -0.02560092f, 0.02880365f, -0.00001105f, -0.03687134f, -0.01007507f, -0.01734202f, 
    -0.01529784f, 0.02072994f, -0.03209864f, 0.00262882f, -0.01230418f, -0.01492387f, -0.01101596f, 0.00523634f, 
    -0.01845402f, 0.01748245f, -0.02487001f, -0.02746023f, -0.01562663f, -0.03233305f, 0.02133626f, -0.00690792f, 
    -0.01079980f, 0.00180210f, -0.00200184f, 0.02367586f, -0.01270209f, 0.00026751f, -0.02583817f, 0.02216749f, 
    -0.04046832f, -0.01350742f, -0.00644956f, -0.00007718f, -0.01633144f, 0.01564547f, -0.00645686f, -0.04301970f, 
    0.02795235f, 0.00135096f, 0.02210949f, 0.02756554f, -0.02965414f, -0.00857564f, 0.00867857f, -0.02275394f, 
    0.03743982f, 0.01838547f, -0.02047887f, -0.03460795f, -0.01905782f, -0.02816901f, -0.00606110f, -0.02668138f, 
    0.01157128f, -0.03530631f, -0.04122748f, 0.00416439f, -0.01987824f, -0.00822694f, 0.00957919f, -0.03246440f, 
    0.01699421f, -0.01745192f, 0.00489726f, -0.00462608f, 0.01248426f, 0.00379752f, 0.00366127f, 0.02050968f, 
    0.01202647f, 0.00397090f, -0.03081621f, -0.02650160f, 0.03719610f, 0.01063426f, -0.01696694f, 0.03177938f, 
    0.02582548f, -0.00450898f, 0.01995554f, 0.01487994f, -0.00330005f, 0.00616576f, -0.02658601f, -0.03306808f, 
    -0.02928712f, 0.03026561f, 0.00431931f, -0.01928263f, -0.03217750f, -0.03607225f, 0.02504728f, -0.02214720f, 
    -0.00996490f, -0.02465544f, -0.04026438f, 0.01495250f, 0.02520616f, -0.03641122f, -0.01948734f, 0.03057928f, 
    0.00208497f, 0.00570727f, -0.00855177f, 0.00001383f, 0.01854867f, 0.01852201f, -0.04250952f, 0.02534576f, 
    -0.02570199f, -0.01619859f, 0.00758274f, -0.02823759f, -0.01659756f, -0.03432261f, 0.02766687f, -0.01333528f, 
    -0.02431010f, -0.00366161f, -0.03832371f, 0.02672489f, 0.01848912f, -0.00070284f, 0.02181231f, -0.01435901f, 
    -0.01220538f, -0.00148579f, -0.03536288f, -0.02413729f, -0.00164261f, 0.00629893f, -0.04436761f, -0.00518982f, 
    0.01178070f, -0.02500981f, 0.03404328f, -0.01655256f, 0.01029649f, -0.01211486f, 0.02363191f, -0.02304910f, 
    0.00026096f, -0.00051417f, -0.03669005f, -0.02984933f, -0.00012739f, 0.03054724f, 0.01174795f, -0.02130733f, 
    -0.01966929f, -0.01084775f, -0.03804329f, 0.02437142f, 0.02169791f, 0.01532085f, 0.01023548f, 0.01948193f, 
    0.00421461f, 0.01526904f, -0.00975158f, -0.00995683f, -0.02073125f, -0.03296958f, 0.00706113f, -0.01603275f, 
    -0.01996441f, 0.00310749f, -0.00481916f, -0.00813315f, 0.02252530f, 0.00080378f, -0.02914055f, -0.02844106f, 
    -0.02778604f, 0.01217022f, 0.02221200f, -0.03846179f, -0.00232630f, 0.00103786f, -0.02687564f, 0.00098120f, 
    -0.02812364f, -0.01868831f, -0.01393179f, 0.00684892f, -0.02732255f, 0.02377534f, 0.01472095f, 0.00897028f, 
    0.01870634f, -0.03888369f, 0.04335917f, 0.01305392f, 0.02281190f, 0.02839516f, 0.03073073f, 0.01273448f, 
    -0.01202793f, 0.00624489f, 0.00892396f, 0.00608336f, -0.01711645f, 0.02343024f, -0.01539598f, 0.00186775f, 
    0.02268361f, 0.00420237f, 0.02440043f, -0.01827790f, -0.01318862f, -0.03420014f, -0.04172665f, -0.03322490f, 
    0.02746657f, 0.02018824f, -0.03392112f, -0.02586040f, -0.00044368f, -0.01197099f, -0.01938052f, 0.02591705f, 
    -0.00462202f, 0.01543249f, -0.00024196f, -0.02680169f, 0.02366167f, 0.01162399f, -0.03196672f, -0.02489128f, 
    0.02047671f, -0.00585857f, -0.00598626f, -0.03534495f, -0.00697772f, -0.01436421f, -0.00077165f, -0.03989830f, 
    -0.00657394f, -0.01621856f, 0.01129561f, 0.02743254f, -0.00249791f, 0.02645833f, 0.02376011f, 0.01487742f, 
    -0.02505529f, 0.02646318f, -0.01575491f, 0.00857013f, -0.01141597f, 0.02684827f, 0.01056505f, -0.03746212f, 
    0.02960451f, -0.02350307f, 0.01683597f, 0.00676546f, -0.03613415f, 0.02773768f, -0.03391297f, -0.02668840f, 
    0.01457959f, -0.03518154f, -0.00113672f, -0.04050393f, -0.03417641f, -0.03673368f, 0.01203495f, 0.00592236f, 
    -0.02175812f, 0.01628558f, -0.03251312f, 0.00943111f, -0.00149156f, -0.00455787f, 0.00470410f, -0.02892840f, 
    0.01325458f, 0.01955675f, -0.04013461f, 0.01674524f, -0.01730184f, 0.02565321f, -0.02425132f, 0.02819939f, 
    -0.01917564f, -0.01284694f, 0.00980678f, 0.02821634f, -0.03415142f, -0.03237014f, 0.01937360f, 0.01979055f, 
    0.01962216f, -0.00918675f, -0.02321969f, 0.02340130f, -0.03565217f, -0.00881358f, -0.00632496f, -0.01309265f, 
    -0.03436784f, -0.01488745f, -0.03163002f, 0.02382614f, -0.00303979f, 0.01379116f, -0.01774064f, -0.00677935f, 
    -0.02333988f, 0.02762909f, 0.02683356f, -0.03146632f, -0.02855646f, 0.01929075f, -0.02037177f, 0.00729057f, 
    0.02380513f, -0.01069138f, -0.02841148f, 0.02582127f, -0.01655435f, -0.02742627f, -0.01168486f, 0.01558631f, 
    -0.02134313f, -0.00459321f, 0.01399185f, 0.02202987f, -0.03368580f, -0.04399873f, 0.00533783f, -0.04148535f, 
    -0.00293456f, -0.00179307f, -0.04030511f, -0.00741751f, -0.00433580f, 0.00302718f, -0.02367232f, -0.02708731f, 
    -0.03656345f, -0.01719436f, 0.00366599f, 0.01304285f, 0.01571828f, -0.02431391f, -0.00905918f, -0.03914297f, 
    0.00330584f, 0.00675767f, 0.01698260f, -0.03491164f, 0.00395410f, -0.03863757f, -0.03169217f, -0.02219580f, 
    0.00627777f, 0.02247368f, -0.00961980f, -0.01589000f, -0.01623276f, -0.02071124f, 0.02403831f, -0.02914853f, 
    -0.01034483f, -0.00092861f, -0.00879485f, -0.01438782f, 0.00930139f, 0.01708681f, -0.02921256f, 0.00662586f, 
    0.00208403f, 0.00485369f, -0.00713597f, -0.01362602f, -0.00453855f, -0.00947978f, 0.00720911f, -0.00392915f, 
    -0.00722456f, -0.01288064f, 0.02170900f, -0.04252572f, 0.00502218f, -0.00631230f, -0.03815765f, 0.02778108f, 
    -0.00808391f, -0.01298675f, -0.02339640f, -0.02295785f, -0.03153237f, -0.02562308f, -0.02835951f, -0.02807322f, 
    0.00453375f, -0.01442063f, 0.00680316f, -0.03160702f, -0.00676120f, 0.02602713f, 0.00148381f, -0.02564730f, 
    -0.00096991f, -0.03945246f, 0.01129300f, 0.03505421f, -0.02773797f, 0.02362644f, -0.00363196f, -0.00232915f, 
    0.02716565f, -0.03733017f, 0.03185957f, 0.00266902f, -0.02425092f, 0.00391054f, 0.00132948f, -0.02174487f, 
    -0.01215022f, 0.01306739f, 0.01445321f, -0.00690701f, -0.01362175f, -0.00814391f, -0.01051202f, -0.03479434f, 
    0.01997936f, -0.00139651f, 0.00482670f, -0.02649231f, 0.01892164f, -0.01731759f, -0.01160469f, -0.02972927f, 
    -0.01394009f, 0.00406276f, 0.02386326f, -0.00094217f, -0.01048484f, -0.01473259f, -0.01695161f, -0.01269135f, 
    0.01347262f, -0.01065221f, -0.01457188f, -0.01738694f, -0.01531182f, 0.01268831f, -0.02948314f, 0.00001138f, 
    0.00381373f, -0.00598561f, -0.03464480f, -0.00681333f, 0.02784857f, 0.02011127f, 0.00762987f, 0.00594522f, 
    -0.04468992f, 0.01216602f, -0.01331820f, -0.00671284f, -0.03610859f, -0.03471218f, -0.01302803f, 0.01786050f, 
    -0.01678059f, 0.01719158f, 0.01409690f, 0.00267857f, -0.00984908f, -0.02415642f, 0.00016158f, 0.02100912f, 
    -0.03551675f, 0.01239098f, -0.03584929f, -0.01511932f, 0.00866401f, 0.01589296f, 0.02583072f, 0.01039637f, 
    0.00103183f, -0.03714653f, -0.00814243f, 0.00489397f, -0.01846828f, 0.02045846f, -0.03606471f, -0.04039680f, 
    -0.00889213f, -0.00732820f, 0.00953470f, 0.01215601f, 0.01891187f, -0.00778687f, 0.02020076f, 0.02595099f, 
    -0.03380500f, 0.02435491f, -0.04348143f, -0.03743403f, 0.00182864f, -0.00859463f, -0.02561997f, -0.01926043f, 
    0.00130163f, 0.02034646f, -0.03849050f, 0.00820150f, 0.02533645f, -0.02879516f, 0.00895911f, -0.01508670f, 
    -0.03921343f, 0.00030900f, 0.01536687f, 0.01550058f, -0.01243257f, -0.00771066f, -0.02891972f, 0.02857045f, 
    -0.03261523f, -0.00293285f, 0.00826425f, -0.02024067f, -0.00759721f, -0.00179411f, 0.00720262f, -0.04262907f, 
    0.02492297f, -0.01769866f, -0.00574691f, 0.01541652f, -0.01256801f, 0.03111674f, 0.01833785f, -0.02480327f, 
    -0.03318507f, 0.03086882f, -0.01925846f, 0.02516144f, -0.01406184f, -0.01699160f, 0.00673287f, -0.00038746f, 
    -0.02420916f, 0.00493315f, -0.00343506f, -0.01969234f, -0.01917030f, 0.01376866f, -0.03820173f, 0.01996022f, 
    0.02865929f, 0.00912411f, -0.03290693f, -0.00695129f, 0.02201984f, -0.03242286f, 0.00143023f, -0.00175772f, 
    0.00492848f, -0.01278808f, -0.01062425f, -0.00345221f, -0.02660903f, 0.01053557f, 0.02587310f, 0.01885643f, 
    -0.03169400f, 0.01175702f, -0.00725520f, -0.02161247f, -0.03404018f, 0.00796450f, 0.02144450f, 0.02273584f, 
    -0.00918424f, -0.02405773f, -0.03439512f, -0.01022905f, -0.00311579f, 0.01580628f, 0.00930103f, -0.01556416f, 
    0.00255447f, -0.01223176f, -0.02413462f, -0.01664459f, 0.01805091f, 0.00420190f, -0.03496508f, -0.03358826f, 
    -0.03806871f, 0.01246658f, -0.04042437f, 0.03126765f, -0.01397184f, 0.00782394f, 0.01932936f, -0.01711838f, 
    0.00647674f, 0.02026253f, 0.01851029f, -0.02686899f, 0.02045947f, -0.03193050f, -0.01109601f, -0.00018037f, 
    0.00462001f, 0.01422094f, -0.01496967f, 0.01399921f, -0.02057060f, 0.02344349f, -0.00906185f, 0.02043635f, 
    -0.03559144f, -0.02417593f, -0.02001335f, 0.02207010f, -0.02443157f, 0.00571428f, 0.01139226f, 0.00400066f, 
    0.01835131f, 0.00313942f, 0.01099904f, 0.00640002f, 0.00711186f, -0.00182352f, 0.02515383f, -0.00071910f, 
    -0.00186779f, -0.02767476f, -0.01621455f, -0.01099583f, -0.01722188f, -0.01309687f, 0.00198146f, -0.01331264f, 
    -0.00999007f, -0.03512619f, -0.03977019f, -0.01774757f, -0.01674174f, -0.02709321f, -0.02856812f, 0.02224414f, 
    -0.03789436f, 0.00599647f, -0.03110507f, 0.01122026f, 0.01641703f, -0.02645517f, -0.00569273f, 0.02505682f, 
    -0.02810745f, -0.03288141f, 0.02500620f, 0.00040938f, -0.01597507f, -0.00875098f, -0.03296644f, -0.01236755f, 
    0.01496597f, 0.02373476f, 0.00755502f, -0.01049712f, -0.00933226f, -0.00919619f, -0.03562207f, -0.01760445f, 
    0.00219529f, 0.00025046f, 0.01094520f, -0.02210213f, -0.02300783f, -0.02152485f, 0.01916554f, -0.00462249f, 
    -0.04134833f, -0.03471616f, 0.00667644f, -0.03127626f, 0.02384679f, -0.00329832f, -0.03510780f, -0.02449528f, 
    -0.00684616f, -0.01464833f, -0.01008580f, 0.00635543f, -0.00359133f, 0.02037781f, 0.00083985f, 0.02250022f, 
    -0.01998370f, -0.02062713f, 0.01338155f, 0.01880906f, -0.03762889f, 0.01113764f, 0.00626924f, 0.01033224f, 
    0.01663938f, -0.00208290f, 0.02907437f, 0.01016382f, -0.01902262f, 0.00462025f, 0.00810670f, -0.02251268f, 
    -0.01647791f, -0.03691091f, 0.01658856f, 0.03385865f, -0.03322840f, -0.04083368f, -0.03807410f, -0.02084832f, 
    -0.02916742f, 0.01212079f, -0.03627745f, 0.02753457f, -0.01446163f, -0.02074394f, 0.03016608f, 0.00112040f, 
    0.02090318f, 0.02505983f, -0.01806810f, -0.02029516f, 0.01087414f, -0.02607427f, 0.00054562f, -0.00217358f, 
    -0.01538970f, 0.02545724f, -0.00035155f, -0.01845883f, 0.00492873f, -0.00886266f, 0.02186950f, -0.02343063f, 
    -0.01593560f, -0.02090240f, -0.04244776f, 0.00775092f, 0.02717096f, 0.00003749f, 0.00811881f, -0.01367971f, 
    -0.01317983f, -0.00381899f, 0.01880535f, -0.02981065f, -0.03753499f, -0.02911897f, -0.01188879f, -0.02740172f, 
    0.00584624f, -0.01074267f, -0.03429138f, 0.02311281f, 0.01954032f, -0.01928531f, 0.02559943f, -0.00180425f, 
    -0.00984897f, 0.00243052f, -0.00781123f, 0.03093111f, 0.01323186f, 0.02613975f, 0.02424698f, -0.00156553f, 
    -0.01659906f, 0.00583108f, -0.02886199f, -0.02661838f, -0.02891418f, -0.02888295f, -0.00045311f, -0.02958103f, 
    0.00628157f, -0.00132648f, 0.00681471f, 0.02512089f, 0.01080377f, -0.02883946f, -0.00239608f, -0.03915286f, 
    0.00194428f, -0.01845730f, -0.02598637f, 0.02604032f, 0.01974446f, -0.03190576f, -0.03470599f, 0.02487496f, 
    -0.02685161f, 0.02732705f, 0.00530185f, 0.00506377f, 0.00313013f, 0.00254644f, 0.01744140f, -0.01355858f, 
    -0.02025268f, -0.03889710f, 0.01149785f, -0.01949185f, -0.03014510f, 0.00227587f, -0.00280959f, 0.01204412f, 
    0.01747110f, -0.03355370f, 0.02533729f, 0.00511303f, 0.00707787f, -0.03024374f, -0.02490903f, -0.01376705f, 
    -0.01454207f, 0.01884838f, 0.02820183f, -0.00826156f, 0.01592034f, 0.01245965f, -0.01319311f, 0.00220499f, 
    0.02064609f, -0.03770881f, -0.02388893f, -0.00450074f, -0.00357980f, 0.02201093f, 0.01023552f, 0.02519963f, 
    0.01611400f, 0.00622506f, -0.01052264f, -0.00967570f, -0.01869510f, -0.03189161f, -0.00978261f, 0.00948411f, 
    0.02443081f, -0.02017399f, 0.00051348f, -0.01560241f, 0.00888145f, 0.01484676f, 0.02798482f, 0.02712697f, 
    0.01762762f, -0.02891776f, -0.04083402f, 0.02440262f, 0.00839207f, 0.01854387f, -0.00648676f, -0.03532096f, 
    -0.01178102f, -0.00745065f, -0.01754200f, 0.02138634f, 0.01702792f, 0.01086462f, 0.00149233f, 0.01620137f, 
    -0.01067198f, -0.00719988f, -0.01032962f, -0.02777566f, -0.03207634f, -0.03128662f, 0.01128848f, 0.00196802f, 
    -0.00760633f, -0.00560770f, 0.00622248f, -0.03243987f, -0.02407544f, -0.03859750f, 0.02498972f, -0.01130637f, 
    -0.03681597f, -0.02163858f, 0.02365024f, -0.03137149f, 0.01263096f, 0.01402124f, -0.01252456f, 0.01462025f, 
    -0.03430705f, -0.02947018f, -0.03223972f, -0.03412411f, -0.03614689f, -0.01130812f, -0.00142529f, -0.01213309f, 
    0.00122577f, -0.03014372f, 0.02993249f, -0.02520266f, -0.03749388f, 0.01662089f, -0.03628275f, -0.00454106f, 
    -0.03519126f, -0.00672804f, 0.01934941f, -0.01021222f, 0.02738888f, -0.02817185f, -0.00763640f, 0.02432458f, 
    0.00578826f, 0.02545286f, 0.00762219f, 0.01463811f, -0.00230719f, 0.02542022f, 0.02124810f, -0.01731169f, 
    -0.03245155f, -0.02570479f, -0.02317859f, 0.00394250f, -0.00287740f, -0.03795381f, 0.01790315f, -0.03187247f, 
    -0.03209684f, 0.02448961f, -0.02582896f, -0.02684340f, -0.03506486f, -0.03109089f, -0.00925337f, -0.02704158f, 
    -0.00827442f, -0.02611705f, 0.00279405f, -0.03958693f, 0.00995921f, -0.01527828f, -0.01012220f, 0.01179095f, 
    -0.02690193f, -0.01871879f, -0.03641176f, 0.00545151f, -0.01600938f, 0.02940033f, -0.03277412f, 0.02637039f, 
    -0.02999626f, 0.00210918f, -0.00550591f, -0.03073411f, -0.02372703f, -0.01051787f, -0.00964737f, -0.03209766f, 
    -0.03761164f, 0.01881710f, 0.02311768f, -0.02976743f, -0.02627210f, 0.00761601f, 0.02020294f, -0.01607604f, 
    0.00669165f, -0.03411328f, 0.01948980f, 0.01047267f, -0.03736440f, -0.02774964f, -0.03810050f, -0.02691336f, 
    -0.03457857f, -0.02917127f, 0.01851327f, 0.00441485f, -0.00282902f, 0.01563021f, 0.00690848f, 0.00436319f, 
    0.01407788f, -0.03585376f, 0.01484412f, -0.01661511f, -0.02482005f, 0.01679449f, -0.01766898f, -0.04055592f, 
    -0.01677213f, 0.00140866f, -0.00555890f, -0.02471207f, -0.00879771f, -0.00652583f, -0.02777624f, -0.03086641f, 
    0.01867422f, 0.02374552f, -0.01636065f, -0.00751003f, 0.01355106f, 0.01846563f, -0.00439479f, 0.01720527f, 
    -0.03207405f, -0.02796510f, -0.02676017f, -0.01428062f, 0.01874500f, 0.02606507f, -0.01891107f, 0.00556360f, 
    0.01958339f, -0.03406431f, 0.00998526f, -0.02188575f, -0.00556334f, -0.02000759f, 0.00054980f, -0.03841495f, 
    -0.00856632f, 0.01236996f, 0.02713166f, -0.01509796f, -0.04241961f, -0.01256823f, -0.03714171f, -0.03849697f, 
    -0.00720373f, 0.00067033f, 0.00629641f, -0.03633301f, -0.04164908f, -0.04230302f, -0.01619301f, 0.01057835f, 
    0.01525760f, -0.02347075f, -0.03908334f, -0.03145860f, 0.02133998f, -0.03714191f, 0.02714516f, 0.02810876f, 
    -0.01709433f, 0.00331219f, -0.02633610f, -0.01962488f, -0.00135922f, 0.00456614f, -0.02842757f, 0.01645111f, 
    -0.02177860f, 0.00984548f, 0.00467928f, 0.01174695f, -0.00142007f, -0.02403660f, 0.00864138f, -0.02542461f, 
    0.01617368f, -0.03806964f, -0.02301048f, -0.00474242f, -0.02787616f, -0.01417141f, -0.04016288f, -0.03884777f, 
    -0.01792529f, 0.01303703f, -0.02024078f, 0.02973925f, -0.04275345f, -0.03353293f, 0.01037125f, 0.01775001f, 
    -0.04216751f, -0.02100087f, 0.02925113f, -0.00892643f, -0.01437462f, 0.01249149f, 0.02437032f, -0.02361355f, 
    0.00035641f, -0.01808051f, -0.02255778f, 0.02953029f, -0.04327388f, 0.02481153f, 0.02181471f, -0.01330153f, 
    0.01063650f, -0.01252584f, -0.02726283f, -0.00194631f, 0.01353178f, -0.03293113f, -0.00891145f, -0.02621978f, 
    -0.03666395f, -0.02238701f, -0.00447250f, 0.00477602f, -0.01873356f, 0.01343811f, -0.01312824f, -0.00996812f, 
    -0.03297954f, -0.00654804f, -0.00385913f, -0.03263387f, 0.00151168f, -0.04418634f, 0.01847365f, -0.01817918f, 
    -0.04388014f, 0.00547758f, 0.02775116f, 0.00968120f, 0.01111686f, -0.00354982f, -0.00910705f, -0.00780086f, 
    -0.03212904f, -0.01428840f, -0.03449423f, -0.03451976f, -0.01164518f, -0.00817792f, -0.03848062f, -0.02824937f, 
    -0.03032812f, 0.00056583f, 0.02029640f, -0.01157376f, -0.03669965f, -0.01523590f, 0.01988116f, -0.01009138f, 
    0.00905459f, 0.02011877f, 0.00020428f, -0.02629604f, 0.02228481f, -0.00691505f, 0.00970695f, 0.02158490f, 
    -0.04132466f, -0.00532768f, 0.01594332f, 0.00566146f, -0.02215644f, 0.00676701f, 0.00430095f, -0.04032734f, 
    -0.02535384f, -0.03954915f, 0.00572777f, -0.02592842f, -0.00652169f, 0.00768567f, -0.02368753f, -0.02763035f, 
    0.00384786f, 0.02733807f, 0.02361999f, 0.02712042f, -0.01249698f, -0.01518776f, -0.02565129f, 0.01471350f, 
    -0.00598579f, 0.00116235f, 0.02123495f, -0.01080267f, 0.02326636f, 0.01393412f, 0.00078565f, -0.01941884f, 
    0.00166509f, -0.03001195f, 0.01713057f, -0.02417158f, -0.00627037f, -0.00037064f, -0.02008907f, 0.02189327f, 
    -0.01438052f, 0.01126206f, -0.03714549f, 0.01428502f, -0.03309564f, 0.00047417f, -0.01812218f, -0.03382233f, 
    -0.00281494f, -0.01772583f, 0.00165571f, -0.02868070f, -0.04107742f, 0.00031299f, 0.01289713f, -0.00623527f, 
    -0.02104119f, -0.00735924f, 0.00211438f, -0.03391423f, 0.02261824f, -0.00451415f, 0.01525461f, -0.02985302f, 
    -0.04277302f, 0.01495047f, 0.01877048f, 0.00450022f, -0.00543020f, 0.01285733f, 0.02030146f, 0.01154412f, 
    -0.01313197f, 0.02844026f, -0.02258059f, 0.01149528f, -0.04162056f, -0.00935338f, -0.02365190f, -0.01131097f, 
    0.00100915f, -0.03953323f, 0.02217312f, 0.00810343f, 0.01570471f, -0.00877366f, -0.00305581f, -0.02808595f, 
    0.00885592f, 0.01451079f, 0.00470738f, -0.02977712f, 0.00117672f, -0.03723777f, -0.03118174f, -0.03871261f, 
    -0.01677756f, -0.03374768f, 0.02035685f, 0.02258675f, -0.04042433f, -0.02984007f, -0.04132247f, 0.01903876f, 
    -0.03906694f, -0.02712564f, -0.03278345f, 0.01354417f, -0.01081288f, 0.01808408f, -0.02557100f, -0.04129309f, 
    0.01445180f, -0.00968200f, 0.01715951f, -0.00717061f, 0.02534573f, -0.00771812f, -0.04203755f, 0.01119037f, 
    -0.01715986f, 0.00965499f, 0.02611247f, 0.00849865f, -0.00115873f, -0.00401050f, -0.02899627f, -0.03618618f, 
    -0.03107473f, -0.02668449f, 0.02445889f, -0.02265936f, -0.02102656f, -0.01923923f, -0.03273375f, 0.00772465f, 
    0.01665114f, -0.03846252f, -0.01829547f, -0.00059100f, 0.01307782f, 0.02569025f, -0.03224707f, -0.03740286f, 
    0.01527802f, 0.00670294f, 0.00576578f, 0.01610798f, -0.01931696f, -0.03429724f, -0.02041239f, -0.01800926f, 
    -0.01472008f, -0.03342963f, -0.03962964f, 0.01238785f, 0.01200368f, -0.01879765f, -0.02910582f, 0.01185186f, 
    -0.02247118f, -0.00448220f, -0.01561369f, -0.03137988f, -0.01866017f, -0.00337068f, -0.01059329f, -0.03654983f, 
    -0.03593601f, -0.01070958f, -0.03777340f, -0.03048336f, -0.00449964f, 0.00860368f, -0.00892636f, 0.00715460f, 
    0.02725139f, -0.03590348f, -0.03212864f, 0.00924345f, 0.00353631f, 0.01103580f, -0.01239474f, 0.02780382f, 
    0.01568278f, -0.00276133f, -0.00639900f, -0.00588041f, -0.01377238f, -0.00509786f, 0.00673691f, -0.03541368f, 
    0.00074519f, -0.01577358f, -0.02647824f, 0.02185726f, -0.04425086f, 0.00241470f, -0.03465000f, -0.03999692f, 
    -0.01227555f, 0.00720486f, -0.01129964f, 0.01010836f, -0.01060522f, -0.02402215f, -0.03317265f, -0.02040571f, 
    -0.01567644f, -0.01010693f, 0.00109420f, 0.00992854f, -0.02832595f, -0.00437196f, 0.01103824f, 0.01179811f, 
    0.02431611f, 0.02790504f, 0.02869775f, -0.01934245f, 0.02198761f, 0.02700234f, -0.00417535f, 0.00434594f, 
    -0.00385642f, -0.01445690f, -0.01909912f, -0.01151198f, 0.01481551f, 0.01582163f, -0.03616808f, 0.01620345f, 
    0.01440178f, 0.02500298f, -0.03113231f, 0.00769995f, -0.02365746f, 0.02372898f, -0.00547522f, -0.00360263f, 
    -0.01069594f, -0.01522815f, -0.01855536f, -0.03516738f, -0.03938849f, -0.01497945f, -0.03996978f, 0.00851769f, 
    0.01760685f, -0.02145883f, -0.01072011f, -0.01444555f, -0.01813327f, -0.01232862f, -0.00915127f, -0.02684016f, 
    0.02098895f, -0.02530388f, 0.00491622f, -0.00192602f, -0.01989918f, 0.01928496f, 0.01604962f, -0.02352202f, 
    -0.02166124f, -0.03379383f, 0.00934756f, -0.01409706f, 0.01236972f, -0.01725906f, -0.03891518f, -0.02173233f, 
    0.01510396f, 0.02183298f, 0.00795641f, 0.00304961f, -0.01598682f, 0.01234955f, -0.00878637f, 0.01745805f, 
    0.01930611f, 0.02694601f, 0.01273668f, -0.01138606f, -0.01481957f, 0.00395779f, 0.00754592f, 0.02046113f, 
    0.00115392f, 0.00317428f, 0.02233337f, -0.03292328f, -0.01380775f, 0.01427619f, -0.03345086f, -0.02774807f, 
    0.00271599f, 0.00276522f, -0.01284333f, -0.03150037f, -0.03809812f, 0.00998698f, 0.02601384f, -0.01829369f, 
    -0.02494049f, 0.01679385f, -0.02829036f, -0.02241862f, 0.00095655f, 0.01327846f, -0.00643589f, -0.01067235f, 
    0.00283036f, 0.01752228f, 0.00255814f, -0.02821668f, -0.01722787f, -0.01105856f, -0.01849691f, -0.00338502f, 
    -0.02749937f, -0.01996843f, 0.01602080f, 0.02566988f, -0.03295283f, -0.02648579f, 0.02854492f, -0.03045406f, 
    -0.02619250f, -0.02993395f, -0.03335544f, -0.00617074f, -0.01466068f, -0.01869732f, 0.02377475f, 0.00559509f, 
    0.00572806f, -0.01465501f, 0.02448019f, 0.01412276f, 0.01597917f, 0.02552084f, -0.02912311f, -0.02771416f, 
    -0.11283208f, 0.10805032f, -0.02627854f, -0.03179293f, -0.02663055f, 0.05950822f, 0.02841072f, 0.08621440f, 
    0.01696291f, 0.04046825f, -0.00322051f, 0.05692712f, 0.01085600f, -0.03654303f, 0.08130132f, 0.13180539f, 
    0.13156047f, 0.08162656f, 0.00997229f, 0.08890914f, 0.04447420f, -0.05733465f, 0.09867629f, 0.03079735f, 
    -0.25654143f, 0.05104191f, 0.16877021f, -0.10047146f, 0.03270015f, -0.00523431f, -0.11475624f, -0.13398519f, 
    -0.01088484f, 0.22532009f, -0.04373090f, 0.11499602f, 0.40798408f, 0.22504275f, -0.09378861f, 0.28499025f, 
    0.04992117f, 0.02422106f, -0.06401601f, -0.02058759f, -0.05100279f, -0.12458408f, 0.05118485f, 0.03721554f, 
    0.25000921f, -0.10408001f, -0.01759329f, 0.34775278f, 0.13686790f, -0.01406687f, -0.09054619f, -0.09468095f, 
    0.06588184f, -0.10433246f, 0.01135486f, 0.01282148f, -0.58299100f, -0.19146375f, 0.03965954f, 0.06371064f, 
    0.10361022f, 0.08636533f, -0.11662224f, -0.15130468f, 0.04493258f, -0.02182177f, -0.13446255f, 0.13570102f, 
    -0.10318219f, 0.35927585f, -0.28959060f, -0.16217351f, -0.05666695f, -0.09206276f, -0.05820583f, 0.05715066f, 
    0.16451068f, -0.03614668f, 0.01675177f, -0.06548236f, 0.16983123f, 0.10781227f, 0.11175548f, 0.31590346f, 
    0.13311146f, -0.13413186f, 0.09309323f, 0.08829001f, -0.01810358f, -0.07008196f, -0.04468857f, 0.04728328f, 
    -0.12159602f, 0.11250743f, -0.13747081f, 0.16636068f, 0.08386939f, -0.03177951f, -0.02878401f, -0.10595478f, 
    0.04075616f, 0.03641372f, -0.02442125f, 0.07507148f, -0.06141093f, -0.09588670f, -0.19005939f, -0.13076684f, 
    0.07176892f, -0.13089858f, -0.14061385f, 0.00379014f, 0.04406860f, -0.15199371f, -0.16037247f, -0.02315557f, 
    0.12101471f, 0.08611926f, 0.07916884f, 0.23645493f, 0.02506325f, -0.02663391f, -0.02050772f, 0.05203073f, 
    -0.03581642f, -0.00850966f, -0.00083304f, -0.07551721f, -0.00970394f, -0.06746859f, -0.06288233f, 0.13088225f, 
    0.00351375f, -0.02996556f, -0.05829325f, 0.08312807f, -0.04326465f, 0.04263759f, 0.08293285f, -0.09474524f, 
    -0.10530324f, 0.16121215f, -0.07607753f, -0.02748767f, -0.04883130f, 0.02339743f, -0.02033424f, 0.17026301f, 
    0.01692225f, -0.02855948f, -0.04062601f, -0.03693431f, -0.07444374f, 0.02717517f, 0.20690504f, 0.13212410f, 
    0.12189827f, 0.06405021f, 0.01628648f, -0.06458482f, -0.01956388f, 0.08216042f, -0.00613277f, 0.05486993f, 
    -0.02981967f, 0.24462779f, -0.06952593f, 0.01705925f, -0.00725750f, 0.03444850f, 0.09841912f, 0.08301905f, 
    0.09496427f, 0.06508969f, 0.00356964f, 0.16077761f, -0.25492445f, -0.01207487f, -0.24282531f, -0.08903181f, 
    0.07044665f, 0.07521313f, -0.06715731f, -0.13402382f, 0.07887197f, 0.08436338f, 0.05728717f, -0.00997284f, 
    0.01369237f, 0.12124443f, 0.06433142f, 0.04505313f, 0.03751595f, -0.00105797f, -0.00690042f, 0.14265539f, 
    -0.00185399f, 0.07050475f, -0.03005987f, 0.07959019f, 0.05053404f, -0.03367722f, 0.16627973f, -0.04888142f, 
    0.10428683f, -0.03001026f, -0.02328162f, -0.12294563f, 0.08675247f, 0.01004329f, -0.00845593f, -0.07244708f, 
    0.37514842f, 0.15207852f, -0.00365821f, 0.16954564f, 0.10588858f, 0.09232246f, -0.03674645f, -0.01163449f, 
    0.00973606f, 0.04499718f, -0.00003304f, 0.09029152f, 0.15173309f, -0.01999598f, 0.04009891f, -0.02127161f, 
    0.00806297f, -0.05708965f, -0.08656339f, -0.05107935f, 0.04986544f, -0.06165117f, 0.00755869f, 0.16890550f, 
    0.19799510f, 0.10242440f, -0.00049130f, 0.13659427f, -0.06719864f, -0.06933559f, -0.08721650f, 0.01931909f, 
    -0.04868561f, -0.06212034f, -0.03041071f, -0.00250061f, 0.13448827f, -0.12036216f, 0.09189816f, 0.07723396f, 
    0.10169421f, 0.05398728f, -0.00459513f, 0.02310483f, -0.07843036f, 0.01034725f, 0.00251444f, 0.09813688f, 
    -0.08119050f, 0.05235304f, -0.25543150f, -0.14705226f, 0.05501328f, 0.04512111f, -0.10767965f, -0.04768686f, 
    0.10150701f, 0.06645121f, -0.04310189f, -0.07541265f, 0.06120018f, 0.20507193f, -0.34680137f, -0.14593038f, 
    0.13419789f, 0.11406688f, 0.06455342f, 0.22339773f, 0.04380895f, 0.12350556f, -0.15804307f, 0.10053735f, 
    -0.22993363f, -0.09384287f, -0.19208984f, -0.01513640f, -0.04226421f, 0.09012176f, 0.03681038f, -0.05294812f, 
    0.18158662f, 0.09605251f, -0.03943228f, -0.07130142f, -0.33118114f, -0.13115564f, 0.05996869f, -0.10367817f, 
    -0.02536424f, -0.14965405f, -0.17196524f, -0.03684143f, -0.05062623f, -0.09188614f, 0.02333030f, -0.09739035f, 
    -0.35458148f, -0.05429795f, -0.05138994f, -0.21879789f, -0.04580077f, 0.09470099f, -0.09918452f, -0.09072836f, 
    0.03992762f, 0.04860112f, 0.05050821f, 0.01588166f, -0.03478754f, 0.09196198f, -0.00958866f, 0.13504945f, 
    0.09493943f, 0.02581711f, 0.00958987f, 0.05575161f, 0.06958937f, 0.08324836f, -0.04574855f, -0.07003640f, 
    0.07288333f, -0.03039551f, -0.01993318f, 0.19808821f, 0.00671231f, 0.06742398f, 0.10469514f, 0.14549084f, 
    -0.06233650f, -0.00436514f, -0.09260729f, 0.07861097f, 0.15090019f, 0.14144444f, 0.06831492f, 0.14472789f, 
    0.11706661f, -0.06316027f, 0.21334627f, -0.10539187f, 0.00361932f, 0.07585598f, 0.10622501f, 0.04393479f, 
    0.02532752f, -0.08705866f, 0.02627236f, 0.03591488f, 0.20239423f, 0.10182843f, 0.16855267f, 0.03134784f, 
    -0.03049222f, -0.03425661f, -0.04532002f, -0.01883734f, 0.11681467f, 0.16837637f, -0.04399434f, 0.03928366f, 
    0.26781714f, 0.00695956f, 0.06785472f, -0.02789044f, -0.01993632f, -0.06305616f, -0.08325152f, 0.08970048f, 
    -0.27370980f, 0.09126125f, -0.00538381f, 0.04795358f, 0.01744773f, 0.02255397f, -0.08732772f, 0.05957769f, 
    -0.07790708f, -0.08709943f, 0.06256896f, -0.02433578f, -0.19854338f, -0.19268402f, 0.18656091f, 0.10565678f, 
    -0.12721801f, -0.08555600f, -0.06164710f, -0.10121177f, -0.12557456f, -0.04470502f, 0.06821998f, 0.00472709f, 
    -0.23605457f, 0.02298793f, 0.15581067f, 0.11399577f, 0.02152055f, -0.16166769f, -0.03692054f, 0.07342195f, 
    -0.02650250f, 0.03050501f, 0.01470879f, -0.04747709f, -0.49157035f, -0.11122100f, -0.00229280f, -0.00969079f, 
    -0.10110240f, -0.12021673f, -0.03764438f, -0.09570732f, 0.10213499f, 0.00584948f, 0.05594141f, 0.04073055f, 
    0.23750317f, 0.12937221f, 0.00815871f, 0.16797790f, 0.07037268f, -0.00372647f, 0.04201373f, -0.06734541f, 
    -0.07722776f, -0.02217663f, -0.00988343f, 0.15280211f, 0.15415400f, 0.12794185f, 0.03043060f, 0.19541360f, 
    0.03130062f, -0.08978052f, -0.06895987f, 0.09505807f, -0.02988862f, -0.06130879f, 0.12568118f, 0.06675803f, 
    -0.05602501f, 0.08369135f, 0.07470232f, 0.14789873f, 0.01965180f, 0.05922126f, 0.02587921f, 0.09901226f, 
    0.07710819f, 0.04386936f, -0.01567108f, 0.05851489f, -0.06917940f, 0.16524144f, 0.10932355f, 0.12808390f, 
    -0.13046162f, 0.13243094f, 0.00105936f, 0.13572036f, 0.00137408f, 0.08164475f, -0.05956145f, -0.09856847f, 
    0.06444658f, 0.00550239f, 0.06508493f, -0.13220292f, 0.06323749f, 0.00945052f, 0.01621271f, 0.15634483f, 
    0.12200331f, 0.14196827f, -0.04241134f, -0.02809994f, 0.16953984f, -0.19821335f, 0.18026681f, 0.11651912f, 
    0.06617653f, 0.12646948f, -0.07260281f, -0.10572018f, -0.01896129f, 0.06041244f, -0.01957381f, 0.21135390f, 
    -0.12917146f, -0.05336253f, -0.04861608f, 0.28139973f, -0.00871411f, -0.03808838f, -0.07926904f, -0.09089185f, 
    0.06571550f, 0.02425624f, 0.01332795f, 0.00407769f, -0.00530594f, 0.06587941f, 0.41651517f, -0.24559499f, 
    0.02467798f, -0.02258830f, 0.00339149f, -0.24151994f, 0.02753679f, 0.07496152f, 0.14205815f, 0.12105242f, 
    0.01416715f, 0.14480349f, -0.09750931f, 0.08995809f, -0.09651534f, -0.06084374f, 0.04130343f, 0.02006022f, 
    0.07365552f, 0.06582202f, 0.05153834f, 0.01285249f, -0.09041310f, -0.00856529f, 0.07540017f, -0.04535642f, 
    -0.03918204f, -0.00120238f, -0.06541169f, -0.12441237f, 0.00539118f, 0.02763258f, -0.07397971f, 0.00722711f, 
    -0.01695775f, -0.03585707f, -0.04576311f, -0.06938894f, 0.02498007f, 0.07357773f, 0.08547147f, -0.00517848f, 
    -0.06396163f, -0.04731017f, 0.00652123f, -0.04012658f, 0.05450226f, -0.02194019f, 0.21621640f, 0.06507016f, 
    0.05212615f, 0.13106078f, -0.01470694f, 0.03559631f, -0.11291151f, -0.01523787f, -0.02696835f, 0.09761807f, 
    -0.13833068f, -0.03527680f, 0.06981532f, -0.19479424f, -0.00388916f, 0.00272762f, -0.13708331f, -0.11700452f, 
    -0.13868302f, 0.07379445f, 0.09231064f, -0.01701316f, -0.04978766f, 0.26276496f, 0.03290190f, 0.27074587f, 
    -0.04038648f, -0.00740885f, 0.00412891f, 0.08466418f, 0.05687179f, -0.05473259f, 0.05761495f, 0.04632391f, 
    0.04910199f, 0.20930861f, 0.00332714f, 0.10355046f, 0.07291658f, -0.02609670f, 0.04421450f, 0.21817985f, 
    0.04586161f, 0.01028230f, 0.15419734f, 0.02285246f, -0.30499223f, -0.02735326f, 0.16152313f, -0.05768827f, 
    0.12428630f, 0.11902729f, -0.23791683f, -0.08705281f, 0.08183080f, -0.01703412f, 0.12849014f, 0.16629103f, 
    0.07929108f, 0.21631379f, 0.32056519f, 0.03765325f, -0.04179631f, -0.03107732f, -0.03058480f, -0.15275149f, 
    -0.02408270f, 0.07352649f, -0.03722502f, -0.01317608f, -0.13241556f, 0.15010484f, -0.12785102f, 0.05758635f, 
    -0.03313458f, -0.11447619f, -0.02791072f, 0.05127806f, 0.11353162f, -0.01240082f, 0.03060071f, 0.00795964f, 
    -0.34809384f, 0.12679735f, 0.12174325f, -0.07038127f, -0.09591803f, 0.04134180f, -0.02281095f, -0.04408550f, 
    0.10840972f, 0.16579179f, 0.08746758f, 0.11443090f, -0.22047009f, -0.10048196f, -0.10179453f, -0.10688853f, 
    0.01977662f, -0.04613467f, -0.07644502f, -0.19380559f, 0.21172139f, 0.13983472f, -0.04531211f, -0.01461344f, 
    -0.05353248f, -0.06371683f, 0.09573447f, 0.12680915f, 0.05335203f, 0.02029277f, 0.17098996f, 0.02005130f, 
    0.06047360f, 0.08962028f, 0.03035968f, -0.01517817f, -0.24950053f, -0.16320774f, -0.15325695f, -0.12256084f, 
    0.12944944f, 0.01301846f, -0.18879589f, -0.14365020f, 0.02937029f, 0.02272137f, 0.04712960f, -0.01341919f, 
    -0.18206894f, 0.06540465f, 0.03632584f, -0.04331600f, -0.01062335f, 0.06173090f, -0.13049544f, -0.02013626f, 
    0.10041878f, 0.14835529f, 0.02087256f, -0.00334090f, -0.22077830f, 0.05793013f, 0.20200682f, -0.05988557f, 
    0.12124821f, -0.08327444f, 0.05021364f, -0.01883580f, -0.04631389f, 0.12295353f, 0.00206934f, -0.02783525f, 
    0.32924527f, 0.13574810f, -0.20085664f, 0.03652988f, 0.02270297f, 0.01540267f, -0.15141621f, 0.23833027f, 
    0.02200513f, -0.02985403f, -0.08757497f, -0.02560720f, 0.00543677f, 0.20037949f, 0.10155613f, 0.11889233f, 
    -0.07007655f, -0.09509899f, -0.01007353f, 0.09576821f, -0.01588514f, 0.03897603f, 0.04590512f, 0.03087492f, 
    -0.09737978f, -0.01507980f, 0.25846624f, -0.04892021f, -0.00807115f, 0.17202447f, 0.00698911f, -0.03422520f, 
    0.04959540f, 0.16515258f, 0.00816292f, 0.01559367f, 0.19514626f, 0.12052464f, 0.08347353f, -0.00535332f, 
    0.03943587f, 0.15380111f, -0.01705251f, 0.12581487f, -0.02673618f, -0.02556072f, -0.09079462f, -0.02146011f, 
    0.17297322f, 0.04914663f, -0.16004276f, 0.19454126f, 0.06227398f, 0.03876662f, 0.03352496f, -0.07185800f, 
    -0.01259443f, -0.06823830f, -0.07196263f, -0.10742710f, 0.50229865f, 0.12928075f, -0.07296148f, -0.08800733f, 
    0.07469479f, 0.02340815f, 0.15790342f, -0.02124126f, -0.08010195f, -0.06204095f, -0.06322323f, -0.05761832f, 
    0.03190447f, 0.02451222f, -0.29460537f, 0.05037474f, 0.02261024f, 0.05426410f, 0.05790703f, 0.06639714f, 
    -0.02211280f, 0.17388733f, -0.02145112f, -0.18353942f, 0.25287133f, 0.02063038f, 0.14334470f, -0.20384206f, 
    -0.04406008f, -0.11888612f, 0.06792174f, 0.03857885f, -0.12937790f, 0.05441854f, -0.03639130f, 0.02054292f, 
    0.12312680f, 0.18860821f, 0.05047036f, -0.10838412f, 0.03650239f, 0.04635923f, 0.03229073f, 0.09120007f, 
    -0.05638646f, 0.01190747f, -0.12799852f, -0.15256181f, -0.11437940f, -0.18286353f, 0.03012393f, -0.04376845f, 
    0.06536002f, -0.10056213f, 0.05018902f, -0.01555486f, -0.03618592f, 0.15475751f, 0.05383841f, 0.00646329f, 
    -0.16539003f, -0.45542261f, 0.35041308f, -0.04558685f, -0.12242987f, 0.02357975f, 0.13535878f, -0.08636773f, 
    -0.01433943f, 0.12421016f, 0.11891758f, 0.11872835f, 0.16239563f, -0.03021406f, 0.20113575f, -0.03649474f, 
    0.01618018f, 0.22011578f, -0.06444082f, -0.00106228f, -0.15736258f, 0.05323212f, -0.07361111f, 0.06774698f, 
    0.22931899f, -0.22994147f, -0.12282035f, 0.24613953f, 0.00235017f, 0.09769675f, 0.01006506f, 0.05706149f, 
    -0.07306632f, 0.04436522f, 0.08965921f, -0.06505312f, 0.16819069f, 0.00105732f, 0.02044616f, 0.13269775f, 
    -0.14574109f, 0.09287182f, 0.09674449f, -0.24972093f, -0.06219561f, 0.14917615f, 0.12016710f, -0.27428725f, 
    0.18352588f, 0.18823324f, 0.16554482f, 0.11696751f, 0.12746151f, 0.26935846f, 0.10730832f, -0.12949808f, 
    0.04883990f, 0.01660254f, -0.05863935f, -0.07955915f, -0.17391334f, -0.18603291f, 0.04519230f, -0.27239400f, 
    0.00282601f, 0.03453931f, -0.11426698f, 0.05905212f, 0.08616824f, 0.00513935f, -0.22192679f, 0.05267325f, 
    0.25292483f, 0.34738544f, 0.21644576f, 0.16585977f, -0.01707881f, -0.09052209f, 0.08108562f, 0.18028523f, 
    -0.11502747f, 0.01459103f, 0.06934559f, 0.04576132f, 0.36478972f, -0.07682480f, 0.02598554f, 0.08685473f, 
    0.07824161f, 0.08232422f, -0.07808714f, 0.17207123f, -0.00913885f, 0.11192907f, 0.02629338f, -0.12850642f, 
    0.08890405f, 0.00418340f, -0.13283248f, 0.16780697f, 0.11935360f, -0.01530980f, 0.01765670f, 0.09224050f, 
    0.06304988f, -0.11462466f, -0.22647825f, -0.04534496f, -0.13270812f, -0.01775242f, -0.05797870f, -0.06239735f, 
    -0.16435975f, 0.05814387f, 0.04843179f, 0.00626447f, 0.00123502f, 0.08139685f, -0.02197651f, -0.17014506f, 
    0.11024601f, 0.07111362f, 0.07350890f, 0.01721046f, 0.01101439f, 0.03107999f, 0.12388756f, 0.04995390f, 
    0.13764673f, 0.21487832f, -0.11609565f, 0.07269413f, 0.04147113f, 0.16088879f, -0.09096533f, -0.20035383f, 
    0.02881757f, 0.06230723f, 0.04290025f, -0.01049698f, -0.12647039f, 0.12165602f, -0.12868297f, -0.11211722f, 
    0.41384009f, 0.02373138f, 0.12585506f, 0.07488207f, 0.25651890f, 0.00340383f, 0.06828006f, -0.00624134f, 
    -0.13945059f, 0.01842158f, -0.08553385f, 0.12781119f, 0.02696200f, 0.32101920f, -0.00368974f, 0.06312034f, 
    0.10269050f, 0.06299852f, 0.22466655f, -0.08485500f, 0.01927538f, 0.13825743f, 0.06355356f, -0.04161036f, 
    0.04283593f, -0.00240359f, 0.17645068f, 0.06003593f, -0.16845410f, -0.06581263f, 0.05610305f, -0.07308509f, 
    -0.04922097f, 0.04330781f, -0.14282097f, -0.12205341f, 0.47041437f, 0.25386006f, -0.23069203f, 0.10986651f, 
    0.04426725f, 0.04278945f, 0.05541028f, 0.17617740f, -0.16085942f, -0.03569897f, 0.04657979f, -0.00368542f, 
    -0.02441068f, 0.02674695f, 0.08022304f, 0.13462807f, -0.12599233f, -0.18322508f, 0.19633240f, -0.14320928f, 
    -0.17364196f, 0.13049854f, -0.08386547f, 0.22907367f, -0.03098892f, -0.14664066f, 0.36120081f, -0.21144666f, 
    -0.10287507f, -0.04616996f, 0.11161529f, -0.02915884f, -0.06531633f, -0.19254993f, 0.00063122f, -0.11918014f, 
    -0.18440849f, 0.00509053f, -0.11620296f, 0.00033165f, -0.00475253f, 0.06468195f, 0.04631568f, -0.06283446f, 
    -0.15468913f, 0.04489325f, -0.01975440f, 0.02975572f, -0.31173274f, -0.42305672f, -0.20956641f, -0.21412785f, 
    -0.07849216f, 0.04054329f, -0.02610108f, -0.02103466f, 0.05975107f, 0.11567777f, 0.08604009f, 0.06712648f, 
    -0.07746094f, 0.02944833f, 0.04308358f, 0.02951727f, 0.04302329f, -0.07995124f, -0.01857383f, -0.14318727f, 
    -0.29162756f, 0.11537946f, -0.05981385f, 0.12772201f, 0.06348848f, 0.01726009f, 0.06236057f, -0.01248681f, 
    0.14306851f, 0.07508419f, -0.12612727f, -0.02311233f, -0.12324578f, 0.08552751f, 0.07926352f, 0.12510188f, 
    0.05253719f, 0.07004633f, -0.05199438f, 0.15778135f, 0.03365147f, 0.01323156f, -0.00869852f, 0.05747189f, 
    -0.06340737f, -0.01715438f, 0.01116352f, 0.02117761f, 0.04568410f, 0.08011696f, -0.02583685f, 0.42332897f, 
    -0.05473405f, 0.06517427f, 0.12248848f, 0.10359841f, 0.03376224f, -0.12615781f, 0.07183212f, 0.11805371f, 
    0.26953384f, 0.12310600f, 0.16661426f, 0.36327374f, 0.02940593f, 0.14813764f, 0.01586647f, 0.30264738f, 
    -0.15503488f, 0.11616767f, 0.01626837f, 0.00839888f, 0.09213728f, -0.09699147f, 0.15766270f, 0.10197021f, 
    0.18596625f, 0.02409684f, -0.12472530f, 0.00422471f, -0.14020553f, -0.12263095f, 0.03155902f, 0.17117514f, 
    -0.10587950f, -0.04858167f, 0.02611670f, 0.16220750f, 0.11031650f, -0.13776271f, 0.15218808f, 0.15853353f, 
    -0.01760834f, -0.12323198f, -0.16024007f, -0.13344388f, -0.30108842f, -0.00817848f, -0.14722244f, 0.08624916f, 
    -0.08191881f, 0.05199780f, -0.01562963f, -0.03139526f, 0.08461881f, -0.00344468f, 0.12301626f, 0.07789474f, 
    -0.30059385f, -0.53831530f, -0.33164018f, 0.02847124f, -0.10825231f, -0.24495086f, -0.04453185f, -0.05545587f, 
    0.03821352f, 0.03924744f, 0.01759162f, 0.12778147f, -0.29998219f, -0.03097387f, -0.01925240f, -0.30013821f, 
    -0.01027581f, 0.06488269f, -0.04244258f, -0.04278568f, 0.04381304f, 0.10294805f, 0.15275611f, 0.06282138f, 
    0.03582058f, -0.05494669f, 0.15742077f, 0.19083609f, 0.18097521f, -0.03468031f, 0.05154766f, -0.04690208f, 
    0.00872438f, 0.22017713f, -0.08112786f, -0.01275595f, -0.06153072f, 0.27859902f, -0.00566091f, 0.04004235f, 
    0.02303682f, 0.01883296f, 0.05577441f, 0.01230934f, -0.00474966f, -0.01705643f, -0.01790040f, 0.05731034f, 
    0.16786961f, 0.09043770f, -0.04838477f, 0.01187621f, 0.05964980f, 0.12296839f, 0.03549612f, 0.01024069f, 
    0.02666350f, 0.01716579f, -0.20643628f, -0.18195930f, 0.15680797f, -0.05157250f, -0.26945841f, -0.11990214f, 
    -0.17604630f, -0.11402861f, -0.01077070f, 0.19236027f, -0.01272292f, 0.02057605f, 0.02858300f, -0.01874691f, 
    -0.03727360f, 0.00292144f, 0.03609794f, -0.03237732f, -0.01909510f, -0.24017635f, -0.04641034f, 0.07151721f, 
    -0.15106337f, 0.06692842f, 0.04882901f, -0.24259838f, 0.43342188f, 0.27351761f, -0.27715215f, 0.01456857f, 
    -0.00017151f, -0.01205635f, 0.07891185f, 0.13000014f, -0.15821339f, -0.09921820f, 0.12579125f, 0.06550611f, 
    -0.36854297f, -0.26246631f, 0.21514982f, 0.04704825f, -0.04826610f, 0.05299689f, 0.07905518f, 0.04091192f, 
    0.03920748f, 0.07496239f, -0.01356845f, 0.17536095f, 0.28994948f, -0.01679784f, -0.17795289f, -0.07655288f, 
    -0.09521197f, 0.06264083f, -0.00866473f, 0.07067866f, -0.07157740f, 0.03856551f, -0.01005830f, 0.04789845f, 
    -0.09636102f, -0.03803024f, -0.02781644f, -0.22182041f, 0.07936954f, -0.13285744f, 0.07089978f, 0.11902979f, 
    -0.04458316f, 0.18858261f, -0.13857383f, 0.00124074f, -0.11945611f, 0.01610036f, -0.13904382f, -0.11383305f, 
    0.05280173f, 0.07751994f, 0.03895862f, -0.02863278f, -0.25106412f, -0.02729071f, -0.06102310f, -0.10270704f, 
    0.28134215f, 0.22772032f, 0.09084745f, 0.39444298f, -0.05563571f, 0.00715085f, 0.11951665f, 0.05205303f, 
    -0.03587365f, 0.08864012f, -0.01929332f, 0.02304912f, 0.02987839f, 0.09102025f, 0.09066664f, 0.17955826f, 
    -0.00897529f, 0.08952373f, 0.04977628f, -0.03245576f, -0.06346044f, -0.16119602f, 0.05595667f, -0.10847981f, 
    0.01343465f, 0.23488165f, -0.10684669f, -0.12117621f, -0.10279195f, 0.10241903f, -0.16331260f, -0.05050219f, 
    -0.19554207f, 0.10102560f, 0.11040910f, -0.18780057f, 0.14118554f, 0.10187723f, -0.10391644f, -0.10898430f, 
    0.09426362f, 0.05637924f, 0.07354757f, -0.04589390f, 0.03964329f, 0.05618163f, -0.06229258f, 0.06730587f, 
    0.15516104f, 0.00301020f, 0.00512113f, 0.17833705f, 0.10554155f, -0.19061549f, -0.13632172f, 0.00813595f, 
    -0.11483038f, -0.27120909f, -0.19026083f, 0.08388849f, -0.34485111f, -0.03605175f, 0.04133423f, -0.02145527f, 
    -0.04227733f, 0.05489531f, 0.11559316f, -0.14137258f, -0.08064699f, -0.16809571f, 0.04120835f, 0.00776309f, 
    -0.06331944f, 0.21634503f, -0.63064563f, 0.06666269f, -0.00589869f, 0.14033978f, -0.01921380f, 0.04029645f, 
    0.08136585f, -0.03804309f, -0.04753917f, -0.02866809f, -0.24806815f, -0.00029170f, -0.17563151f, -0.37704903f, 
    0.06033671f, -0.03932875f, 0.01559179f, -0.01423287f, 0.06002634f, 0.16811006f, -0.06086975f, -0.08781285f, 
    0.22308365f, -0.27949402f, 0.17979085f, 0.24655987f, -0.21904469f, 0.06066636f, 0.04098849f, -0.11403424f, 
    -0.14871974f, -0.03338077f, 0.11689274f, -0.17686222f, -0.05882934f, -0.05233185f, -0.00843501f, -0.02060212f, 
    0.00547630f, -0.01163423f, 0.00650739f, 0.04765761f, -0.10360471f, 0.06757839f, 0.06084892f, -0.13498177f, 
    0.08591674f, 0.19965298f, 0.04698075f, 0.05256263f, 0.04239246f, -0.03260657f, -0.05920219f, 0.00196732f, 
    -0.13266104f, 0.04308353f, 0.05935214f, -0.08293007f, -0.15318905f, -0.00031174f, 0.02057074f, -0.01466359f, 
    -0.31751162f, -0.02753107f, 0.07993095f, -0.09568428f, -0.08585165f, 0.05475038f, 0.06969676f, 0.06090454f, 
    -0.08867279f, -0.14021324f, -0.00724062f, -0.08649921f, -0.02052599f, -0.03624158f, -0.12457681f, 0.02822024f, 
    -0.07800888f, -0.07569750f, 0.20953377f, 0.05550996f, 0.19180416f, 0.09904784f, -0.01666296f, 0.05751055f, 
    -0.12454048f, -0.00995313f, 0.01177213f, -0.06118284f, -0.15585770f, 0.09156951f, 0.12299741f, -0.03417623f, 
    0.09775843f, 0.52260751f, -0.12394497f, 0.16807552f, -0.02674957f, 0.02698487f, 0.20358573f, 0.04265894f, 
    -0.03870723f, 0.06214669f, -0.03881620f, 0.08779544f, 0.06493680f, 0.03731386f, -0.06977018f, 0.00200555f, 
    0.00559901f, 0.09408955f, 0.01849547f, 0.07272635f, 0.06726599f, 0.02719052f, -0.03426374f, -0.10636703f, 
    0.35361490f, 0.12114535f, 0.05129704f, 0.11912590f, 0.05346959f, -0.05844015f, 0.09501774f, 0.07665665f, 
    -0.14372626f, -0.04778596f, -0.10163130f, 0.00747861f, 0.42814979f, -0.01781209f, 0.04722260f, 0.48361745f, 
    0.01006898f, 0.01119510f, 0.12964775f, 0.20937762f, -0.16480693f, 0.06837834f, 0.02260266f, 0.00945871f, 
    0.05376656f, -0.15791322f, 0.02099923f, 0.12227332f, 0.00157436f, -0.00419586f, -0.01178071f, -0.03951508f, 
    0.03530083f, 0.01055097f, 0.04667352f, 0.07469047f, 0.04992424f, 0.36368346f, 0.19367288f, 0.09356415f, 
    -0.01717642f, -0.13694049f, 0.18581894f, 0.14337412f, -0.04417157f, 0.13655083f, -0.01211243f, -0.05089444f, 
    0.00241591f, 0.37527770f, -0.01060556f, 0.12089924f, 0.03115076f, 0.05746315f, -0.06287415f, 0.05254491f, 
    0.03477079f, -0.09791476f, -0.02255145f, 0.15135942f, -0.03631018f, -0.00784729f, 0.14860594f, -0.07512514f, 
    0.01519872f, 0.04087391f, 0.15490466f, 0.07028075f, 0.00062755f, 0.19676088f, -0.17099999f, -0.01611457f, 
    -0.24375683f, -0.07197412f, 0.01702671f, -0.03845231f, 0.01092843f, -0.08986354f, 0.05358035f, -0.01032570f, 
    0.13772593f, -0.03465895f, 0.03527123f, 0.04033774f, 0.21541807f, 0.04803751f, -0.14055844f, -0.12079953f, 
    -0.01416630f, -0.14024428f, -0.04494125f, -0.16431944f, -0.07456025f, 0.02764292f, 0.16525130f, -0.06284525f, 
    -0.13901740f, -0.33938822f, 0.38249141f, 0.11684261f, 0.06264631f, 0.01641258f, -0.02342401f, 0.14541711f, 
    -0.08642092f, 0.12678662f, -0.05051417f, -0.09321157f, -0.28898135f, -0.15379332f, 0.21681891f, 0.05553329f, 
    0.03154204f, 0.10908272f, 0.09872512f, -0.07340226f, 0.08636490f, 0.05492127f, -0.11884858f, 0.15940608f, 
    0.19402614f, -0.25330988f, 0.09837388f, 0.12429268f, 0.02441620f, 0.07722922f, -0.08294116f, 0.06553856f, 
    0.21537331f, -0.06378690f, 0.13309306f, 0.00258890f, -0.00695117f, 0.01190580f, -0.10105176f, -0.02175931f, 
    0.02875831f, -0.04290430f, 0.00901165f, -0.00467290f, -0.20137809f, 0.02461868f, 0.05229424f, -0.22188550f, 
    -0.20989563f, 0.02913682f, 0.25780487f, 0.09408671f, -0.06483430f, 0.24315494f, 0.08938652f, -0.11758494f, 
    0.05760173f, 0.00644758f, -0.01024241f, -0.04586512f, -0.06310064f, 0.03092043f, 0.04854057f, -0.00893341f, 
    -0.13448879f, 0.00106066f, -0.13493668f, 0.02838060f, 0.11932475f, -0.03218840f, -0.00710622f, 0.18154994f, 
    0.11362800f, 0.10198300f, 0.00968552f, 0.15360488f, 0.00628883f, 0.12519227f, 0.08679459f, -0.06866162f, 
    -0.02842015f, -0.07491526f, -0.08757859f, -0.04322663f, 0.16367985f, 0.29737616f, 0.23689413f, 0.02264886f, 
    -0.10365477f, -0.05741094f, 0.00026031f, 0.09172482f, 0.10373880f, -0.02581768f, -0.01601133f, 0.01907676f, 
    -0.09448152f, -0.12041826f, 0.11671922f, 0.02486915f, 0.04444489f, -0.01513864f, -0.07789608f, -0.05808025f, 
    0.04716611f, 0.07464191f, 0.08778675f, 0.03154072f, -0.00345402f, -0.07394403f, -0.01408725f, 0.01159539f, 
    -0.10491155f, -0.06676466f, 0.00162167f, 0.10374369f, 0.13376686f, -0.00411420f, -0.08695594f, 0.01308559f, 
    0.14674170f, 0.08915787f, 0.02401283f, 0.04642214f, 0.12679556f, 0.11736293f, -0.03909750f, 0.00986707f, 
    -0.03619701f, 0.06625364f, 0.11520837f, -0.02690303f, -0.25061211f, -0.12292495f, -0.27563930f, 0.12481862f, 
    -0.06992389f, -0.06248989f, -0.01292848f, -0.03366011f, 0.00930245f, 0.10338061f, 0.01020566f, -0.08068544f, 
    0.07575402f, 0.23918918f, 0.20635879f, 0.00190400f, 0.00440550f, 0.02941223f, -0.02139293f, 0.04808288f, 
    -0.10064079f, -0.07083657f, -0.04848305f, -0.05684955f, -0.07985944f, 0.06342983f, -0.10156297f, 0.06495279f, 
    0.05330716f, 0.11211145f, 0.03202166f, -0.03467836f, -0.04939854f, -0.07009871f, -0.07182190f, -0.14795804f, 
    0.19377892f, 0.02360892f, 0.07519501f, -0.00808255f, -0.00343984f, -0.00404569f, 0.14085796f, 0.04320020f, 
    0.00957542f, -0.04476455f, -0.04662892f, -0.02011968f, 0.23625982f, 0.28089750f, 0.09862733f, 0.25178084f, 
    -0.06836437f, -0.02862293f, 0.03396842f, 0.16564640f, 0.01507362f, -0.00285992f, 0.05533309f, -0.08747374f, 
    0.13628921f, 0.00825277f, 0.05504062f, -0.17064573f, -0.08349217f, -0.07044834f, 0.12374917f, 0.06318204f, 
    0.03158875f, -0.08107717f, 0.01359788f, 0.01650375f, 0.03275530f, -0.10161151f, 0.38347381f, -0.07785948f, 
    -0.00466879f, -0.00347364f, 0.12356374f, 0.15291195f, -0.02909567f, 0.14212035f, 0.12578543f, -0.02021066f, 
    -0.06369957f, -0.02862460f, -0.08769666f, 0.17712095f, -0.01010462f, -0.01885324f, -0.00616839f, -0.07059502f, 
    -0.04984537f, 0.03227294f, 0.02087202f, 0.11537908f, -0.00823290f, 0.11767725f, -0.01442245f, 0.01665317f, 
    -0.07554948f, -0.00873172f, -0.01291248f, -0.02034729f, -0.01048728f, 0.01956735f, -0.03349983f, -0.06037638f, 
    -0.07169478f, -0.06407058f, 0.01004968f, 0.04070305f, 0.09791465f, -0.07154202f, 0.08910333f, 0.07043968f, 
    -0.13023201f, -0.03607791f, -0.21645579f, 0.04013370f, -0.01937700f, 0.06852669f, 0.16242746f, -0.01093823f, 
    0.13072051f, 0.04804451f, 0.02637655f, 0.09151271f, 0.05215152f, -0.00205024f, 0.13197201f, 0.22162589f, 
    0.05865340f, 0.09106382f, 0.10414304f, 0.15242383f, 0.07962867f, 0.09070676f, 0.11533351f, -0.07124727f, 
    0.14645867f, 0.10066449f, 0.01208335f, -0.05954138f, 0.04017971f, -0.17885594f, 0.13073578f, 0.08437170f, 
    -0.17920642f, 0.19597466f, -0.08632329f, 0.11509486f, -0.00526824f, -0.16193137f, 0.02440316f, -0.03367156f, 
    0.14274593f, 0.18337439f, 0.23928371f, 0.19512440f, -0.24494106f, 0.04424546f, -0.04979925f, 0.07697719f, 
    -0.03354752f, 0.03842674f, -0.03551180f, -0.00152827f, -0.22112660f, -0.12260003f, 0.28568393f, 0.01573622f, 
    -0.02303414f, 0.05015802f, -0.03628506f, 0.00675849f, -0.03103521f, 0.13987012f, 0.06307375f, 0.02001606f, 
    -0.00757541f, 0.04684181f, 0.07796291f, 0.04346109f, 0.11164461f, -0.05177619f, 0.10358065f, 0.15164369f, 
    0.26391590f, 0.11517108f, -0.02011765f, -0.02520091f, -0.17134058f, -0.09201364f, -0.07124653f, 0.16170752f, 
    0.01316751f, -0.08665352f, -0.06713760f, 0.01450827f, -0.04873061f, -0.00833348f, -0.08002567f, -0.10040636f, 
    0.20539318f, 0.16637906f, 0.04374788f, -0.12734899f, -0.02669614f, -0.00566464f, -0.07014479f, -0.00815180f, 
    0.00426609f, -0.04752894f, -0.03344168f, -0.09935515f, -0.06596345f, -0.14773436f, -0.07909496f, -0.03832329f, 
    -0.10891189f, -0.07555015f, -0.09186363f, 0.02639363f, 0.01707882f, -0.04828362f, 0.02583551f, 0.03841436f, 
    0.18831363f, 0.12362096f, 0.04110769f, 0.04238106f, 0.02771297f, -0.09313238f, 0.02028167f, -0.06226018f, 
    0.01757978f, 0.04528330f, 0.08859031f, 0.05342851f, -0.05468068f, 0.07995942f, 0.08072039f, 0.12408360f, 
    0.06083260f, -0.01246561f, 0.07790998f, 0.08942994f, -0.03921247f, -0.02461439f, -0.00305298f, -0.03563540f, 
    -0.07900382f, -0.04808211f, 0.08929311f, 0.00753945f, 0.05289720f, 0.09203269f, 0.04929622f, -0.05488896f, 
    -0.06264450f, 0.01643722f, 0.08161998f, -0.01210286f, 0.10935491f, 0.12157758f, -0.01660123f, -0.10189263f, 
    0.21871568f, -0.15574346f, 0.03141684f, -0.04161423f, 0.04992180f, -0.00119381f, -0.04191077f, -0.08731098f, 
    0.12043072f, 0.03382223f, -0.06139580f, 0.02871484f, 0.02137012f, 0.01084118f, 0.14165665f, 0.11476683f, 
    0.10180349f, -0.23890780f, -0.12834024f, 0.05107002f, -0.01293084f, 0.35819939f, 0.02410266f, 0.35890120f, 
    -0.01055031f, 0.01567351f, 0.09538011f, 0.07794381f, -0.05150706f, -0.12385277f, 0.06169383f, 0.09165012f, 
    -0.04747106f, -0.03446095f, -0.07566840f, 0.12679821f, -0.02843355f, -0.05942460f, -0.02718085f, -0.06178526f, 
    -0.03707038f, -0.13286270f, -0.05931249f, 0.08094169f, -0.15499097f, 0.31631863f, -0.15999520f, 0.12349100f, 
    -0.11989235f, 0.11064234f, -0.21715727f, 0.20316704f, 0.00429792f, -0.15082555f, 0.01170285f, 0.14166857f, 
    0.03878682f, 0.08651019f, 0.23956454f, 0.22753021f, -0.01359505f, 0.15558633f, 0.04728322f, 0.18340397f, 
    -0.03939266f, 0.04479212f, -0.04326048f, -0.11526065f, -0.29739007f, -0.17166668f, -0.26027596f, 0.16267376f, 
    0.00447703f, -0.12328071f, -0.04767953f, -0.02497052f, -0.01121462f, 0.09397893f, -0.04043808f, 0.18757741f, 
    -0.07202434f, 0.15336570f, 0.20412380f, 0.19486038f, -0.04888666f, -0.10390537f, 0.00607464f, -0.00817555f, 
    -0.00430946f, -0.00792071f, -0.11664235f, -0.01782903f, -0.04149441f, -0.00875585f, 0.02021572f, 0.12438768f, 
    0.06533053f, 0.01212746f, 0.17554948f, 0.10106567f, 0.07256665f, -0.05685509f, 0.05773823f, 0.08172815f, 
    -0.07332418f, 0.10920017f, -0.03597512f, 0.22118121f, 0.00748179f, 0.16084439f, -0.17277987f, 0.18524738f, 
    -0.07595433f, -0.00626475f, -0.06510278f, -0.03943829f, 0.00861944f, 0.07596563f, 0.14949721f, -0.01756866f, 
    0.07676953f, 0.08172765f, 0.06659202f, 0.09151214f, -0.02222614f, -0.03846604f, -0.05916666f, -0.04439187f, 
    -0.04443343f, 0.03841753f, 0.08331966f, 0.08638007f, -0.06551550f, 0.00954499f, 0.08613691f, 0.06210994f, 
    0.14607283f, 0.16569424f, -0.17053309f, -0.01519664f, -0.05566622f, 0.13793455f, 0.17189987f, 0.06815776f, 
    0.13407563f, 0.00134694f, 0.00111486f, -0.10024009f, -0.05973776f, 0.02992344f, 0.12620692f, -0.08484194f, 
    -0.28138059f, 0.07866431f, -0.24223234f, 0.19817482f, -0.03953293f, 0.09955489f, -0.06108860f, 0.16417421f, 
    0.12292484f, -0.02016686f, 0.04977307f, 0.12944596f, 0.07002188f, -0.05089799f, -0.21911447f, 0.02852633f, 
    -0.07461188f, 0.01241233f, -0.07185688f, 0.02495804f, 0.00620024f, -0.01244149f, -0.09861351f, 0.13935898f, 
    0.13344131f, 0.11109510f, 0.02598041f, -0.14442134f, 0.02789349f, -0.03915646f, -0.13656697f, 0.03689816f, 
    -0.05275469f, 0.07226706f, 0.03093097f, 0.06567533f, -0.02548738f, -0.02890005f, -0.00433730f, -0.07575267f, 
    0.00457370f, -0.02405755f, -0.03195695f, 0.02331462f, -0.08272609f, 0.09333561f, 0.18503158f, 0.12722871f, 
    -0.08349358f, 0.10826169f, 0.03309644f, 0.03817294f, 0.00897843f, 0.02988371f, 0.09446038f, -0.03087368f, 
    -0.03210290f, 0.08933886f, 0.12765595f, 0.02260994f, 0.14185065f, -0.09102039f, -0.05889565f, 0.05480395f, 
    -0.10589008f, 0.14044222f, 0.00861135f, 0.12674281f, -0.06195828f, -0.04396558f, -0.03018978f, -0.03860695f, 
    0.10790724f, -0.07532220f, -0.15094154f, -0.19536479f, -0.08140787f, -0.05798604f, -0.07755269f, 0.01300108f, 
    0.02464175f, -0.05069309f, 0.12111536f, 0.11925771f, 0.14416662f, 0.18921290f, 0.22148043f, 0.17502418f, 
    -0.04355330f, 0.05935489f, -0.11806618f, 0.09852914f, 0.01815684f, 0.15647656f, -0.00488652f, 0.09693754f, 
    0.09766691f, 0.25198832f, 0.21320844f, 0.21895456f, 0.13031583f, -0.08149479f, 0.16857956f, -0.06437629f, 
    0.06263341f, 0.02144474f, -0.02100302f, 0.08314851f, -0.07696000f, -0.04255926f, -0.06233483f, -0.02408308f, 
    0.01104775f, 0.01178681f, 0.09464897f, 0.03440995f, 0.00380274f, 0.01977012f, 0.03415902f, 0.06063645f, 
    -0.01224493f, 0.38720837f, 0.06174985f, -0.07299098f, 0.01503724f, -0.04736907f, -0.03224288f, -0.07362055f, 
    -0.10433488f, -0.03170543f, 0.00870071f, -0.00923062f, 0.18418418f, -0.09104301f, 0.03366011f, 0.08351802f, 
    0.02836291f, -0.08086323f, 0.01670207f, 0.13978194f, -0.04011135f, 0.05841813f, 0.05881568f, 0.01885250f, 
    0.10061136f, 0.31163329f, 0.00977227f, 0.03261489f, 0.05725238f, -0.06519911f, -0.02640908f, 0.10833624f, 
    0.03835049f, -0.01383597f, 0.00550454f, 0.00006801f, 0.18931064f, -0.04508089f, -0.20556048f, -0.08191600f, 
    -0.03036673f, 0.03453184f, -0.01193431f, 0.02440677f, 0.09935667f, -0.02592790f, 0.05636182f, 0.06031234f, 
    0.31362996f, -0.18298627f, -0.06335878f, -0.25868756f, -0.14233425f, -0.07995312f, -0.10770285f, -0.09856022f, 
    0.06483842f, 0.02441271f, 0.08449888f, -0.06423073f, -0.54981583f, 0.20507327f, -0.08287110f, 0.13667108f, 
    0.00399992f, -0.08084704f, 0.02750522f, -0.11254261f, 0.08065949f, -0.05080636f, -0.03268572f, 0.03068997f, 
    0.21184951f, 0.03353838f, 0.02229454f, 0.34251139f, 0.02049192f, -0.05377438f, -0.08265724f, -0.08294917f, 
    0.09677763f, 0.01724646f, -0.09971987f, -0.08665106f, -0.30893871f, -0.07682797f, -0.19439164f, 0.15829049f, 
    0.11280421f, 0.06397109f, -0.00245083f, -0.22036715f, 0.07291371f, 0.06821316f, -0.19791223f, 0.05027255f, 
    -0.28652483f, -0.13163689f, -0.06948472f, 0.04722603f, 0.01994595f, -0.12441640f, 0.01271798f, 0.06620742f, 
    0.12438482f, 0.04829562f, 0.13805753f, -0.07762272f, 0.01818930f, 0.20835002f, 0.24883652f, 0.34645921f, 
    0.16513990f, -0.04097503f, -0.15960521f, 0.01679257f, 0.03857868f, -0.00387644f, -0.13570438f, -0.09618723f, 
    -0.05958271f, -0.21756744f, -0.12190995f, 0.36274371f, 0.06809037f, -0.02860753f, -0.04733061f, -0.05892499f, 
    -0.05532333f, 0.03867541f, -0.01919544f, 0.14442888f, 0.13462104f, 0.04343713f, -0.16462398f, -0.13119759f, 
    0.13961700f, 0.01257245f, -0.06123179f, -0.00012593f, 0.16594769f, 0.00380318f, -0.08679701f, 0.13667691f, 
    0.41467452f, 0.28514895f, 0.24923231f, 0.08313607f, 0.18885173f, 0.03625300f, -0.06506990f, -0.05968802f, 
    0.07404316f, 0.00466797f, -0.10732227f, -0.04174416f, -0.11584108f, -0.04756586f, 0.02543828f, 0.17072077f, 
    0.05208833f, -0.05375371f, -0.05989754f, 0.04099685f, 0.09385408f, -0.08488408f, -0.18490370f, -0.06335745f, 
    -0.07302799f, 0.22304298f, 0.01357168f, 0.00319162f, 0.06363335f, 0.12898761f, 0.14970447f, 0.30825102f, 
    0.03618958f, -0.07252426f, 0.06841900f, 0.00163055f, 0.22379352f, -0.14022446f, -0.01937477f, -0.04872265f, 
    0.01782849f, 0.01001425f, -0.14216293f, -0.05121229f, 0.01001138f, -0.01331041f, -0.00441532f, -0.02444324f, 
    0.08518238f, 0.17286909f, 0.12289201f, -0.05390235f, 0.12076099f, -0.06492796f, 0.18569221f, 0.04728595f, 
    0.05778757f, -0.00657389f, -0.08053705f, -0.00628185f, -0.07066418f, -0.09390946f, -0.18735772f, -0.12622868f, 
    -0.03637836f, 0.05811743f, -0.01896711f, -0.04519530f, 0.23457475f, 0.07557826f, 0.00234504f, 0.04774251f, 
    0.07303792f, 0.17305622f, -0.00566309f, -0.23227951f, -0.03089164f, 0.00188960f, 0.07629798f, 0.21791160f, 
    -0.09102181f, 0.09630065f, 0.05343315f, 0.06715833f, 0.24886498f, -0.01903698f, 0.13149922f, 0.07890372f, 
    -0.03203635f, 0.00190817f, -0.09576833f, -0.15301792f, 0.08281549f, 0.02164750f, 0.01947283f, 0.00129406f, 
    0.06954067f, 0.20273270f, -0.13974231f, -0.20058893f, 0.01531194f, 0.27288374f, 0.03228021f, -0.03719950f, 
    0.05834147f, -0.04013938f, -0.02530353f, 0.06809524f, -0.03184079f, -0.07163134f, 0.04293427f, 0.07053782f, 
    0.10182501f, 0.08432902f, 0.16294040f, -0.02511105f, 0.10755580f, -0.07078023f, 0.12054553f, 0.08317950f, 
    -0.25182423f, 0.21363813f, -0.12395745f, 0.24404015f, 0.05368500f, 0.00908362f, 0.02153328f, -0.03369253f, 
    -0.02488641f, -0.06601465f, -0.17975433f, -0.06849079f, 0.18451205f, 0.06375073f, -0.04124804f, -0.16137071f, 
    -0.02169359f, 0.06721638f, -0.09357964f, 0.01347720f, -0.01000199f, 0.04857515f, 0.07371493f, 0.03847535f, 
    0.00099353f, 0.03933529f, -0.12433778f, 0.01085955f, 0.02143871f, 0.03395467f, 0.02003951f, -0.06967413f, 
    0.09155020f, 0.05422668f, -0.17275763f, 0.10573238f, 0.07746164f, -0.11904531f, -0.24208917f, -0.22266395f, 
    0.07945599f, 0.09454490f, 0.03193463f, 0.28694415f, 0.06604275f, 0.02874590f, -0.09514989f, 0.03237160f, 
    -0.14961113f, -0.05604239f, -0.06494129f, 0.06297182f, 0.01040093f, 0.00176727f, -0.06321256f, -0.04763005f, 
    -0.10597434f, -0.06636145f, 0.04924992f, -0.00884528f, -0.20830092f, -0.23707482f, 0.15736169f, 0.11079332f, 
    -0.00962237f, -0.03626316f, -0.07646888f, -0.12615947f, 0.03112641f, -0.10364626f, 0.01591471f, -0.13759486f, 
    -0.24837457f, -0.07920180f, 0.03746869f, -0.19585744f, 0.10000692f, 0.10074702f, 0.11484654f, -0.04046381f, 
    0.07918924f, 0.12418723f, 0.14673880f, 0.07338651f, 0.10636650f, 0.08499096f, 0.20544900f, -0.02085660f, 
    0.13031070f, 0.04447351f, 0.08337418f, -0.06178510f, -0.03546112f, 0.03244918f, -0.09315750f, -0.08705696f, 
    0.14191727f, 0.16314796f, 0.09345507f, 0.11522951f, 0.06642357f, 0.06067283f, -0.08548550f, 0.20600310f, 
    0.01365076f, -0.10092189f, 0.00994308f, 0.02617366f, 0.01014293f, 0.23898147f, 0.02802083f, 0.13734446f, 
    0.15671416f, -0.10042547f, 0.26372615f, 0.00216900f, -0.02412009f, -0.01760410f, 0.13666619f, 0.06116057f, 
    0.13574411f, 0.20352095f, 0.08160151f, 0.08900633f, 0.17261487f, 0.18120623f, 0.13056977f, 0.14194725f, 
    -0.05287688f, 0.04151498f, -0.00041404f, 0.02711814f, 0.11788145f, -0.09107738f, -0.24889529f, 0.07985161f, 
    0.09466949f, -0.08277431f, 0.17083548f, -0.01618252f, 0.00156102f, 0.04027075f, 0.08963860f, 0.18380776f, 
    -0.03456364f, -0.10268459f, 0.05582297f, -0.10459536f, 0.05497393f, -0.00652670f, -0.06205303f, 0.04350448f, 
    0.11409758f, -0.07122881f, 0.06914930f, -0.07491212f, -0.35357124f, -0.25132734f, 0.12260006f, 0.18775709f, 
    -0.04999857f, -0.06381007f, 0.01082672f, -0.02059357f, -0.01367447f, -0.08763418f, 0.00115835f, 0.10175718f, 
    -0.30354139f, -0.34822816f, -0.31518343f, 0.01704491f, 0.03887669f, -0.10173588f, 0.10677162f, 0.10692603f, 
    -0.01917636f, -0.02003860f, -0.05574702f, -0.04871419f, -0.25256291f, -0.09351953f, 0.03706754f, 0.05942932f, 
    0.03397024f, -0.00174436f, -0.10553499f, -0.07901631f, -0.00987399f, -0.07978872f, 0.00343616f, 0.07809821f, 
    -0.33808240f, 0.17574456f, 0.03196935f, 0.00220841f, -0.03997551f, 0.09774954f, -0.04305016f, -0.06525145f, 
    0.09849845f, 0.00742210f, -0.07577219f, -0.04109198f, 0.04101574f, 0.15695627f, 0.09850836f, -0.11721639f, 
    0.06240996f, 0.08039327f, 0.06760581f, 0.06106103f, 0.00892529f, -0.01862618f, 0.05040256f, 0.09827856f, 
    0.26022542f, 0.16207981f, 0.23220757f, 0.03479320f, 0.18710023f, 0.00318037f, 0.00095852f, 0.05329508f, 
    0.12699869f, -0.01337716f, -0.10382742f, -0.00649480f, 0.12262997f, 0.15451746f, -0.17315809f, -0.20854969f, 
    -0.15763898f, -0.05405306f, 0.06991539f, 0.34610492f, -0.04185914f, 0.01794022f, -0.01309384f, -0.09057964f, 
    0.04845528f, -0.01938776f, -0.11688176f, -0.07110336f, 0.07637815f, -0.17162152f, -0.09982555f, 0.14847156f, 
    0.03660286f, 0.06541175f, -0.01346773f, 0.02724011f, 0.25152609f, -0.16893961f, -0.02598985f, -0.11290531f, 
    -0.05865367f, 0.01550725f, -0.09413767f, -0.06769785f, 0.05226534f, -0.00163937f, 0.09918872f, 0.19301988f, 
    -0.33393428f, -0.17690361f, 0.12382985f, 0.33986869f, -0.02163574f, 0.01141352f, -0.02160009f, -0.08845999f, 
    -0.02347679f, 0.09685299f, -0.04521391f, 0.12460084f, 0.51592040f, -0.18071377f, 0.34118918f, -0.31710091f, 
    -0.12573037f, -0.19902964f, 0.00013002f, -0.12968268f, 0.03484049f, 0.06713358f, 0.00293739f, 0.02588654f, 
    -0.13826805f, -0.11750718f, -0.14765745f, -0.07597330f, 0.10420471f, -0.04792229f, 0.13242036f, 0.05302333f, 
    0.08613504f, -0.03858108f, -0.12000402f, -0.04909565f, 0.13318956f, -0.08778942f, 0.20205134f, 0.04993041f, 
    0.00290033f, -0.04615173f, -0.05887891f, -0.13295063f, -0.06473620f, -0.05678586f, -0.05354362f, -0.12133527f, 
    0.17261156f, 0.18749306f, 0.02529590f, -0.06034613f, 0.07011800f, 0.04748740f, 0.29820797f, 0.15883976f, 
    -0.09310061f, 0.03809028f, -0.04361995f, -0.02052833f, 0.04552343f, 0.09266473f, 0.34512755f, 0.01735422f, 
    0.08626065f, 0.10135445f, -0.08183090f, 0.05820559f, -0.05837930f, -0.09981480f, 0.10347935f, -0.08473054f, 
    0.04332025f, -0.06160313f, 0.07317877f, -0.35670185f, 0.03507320f, 0.06634559f, -0.00485307f, 0.01116838f, 
    -0.02924513f, 0.15914337f, 0.02589224f, 0.04490108f, 0.18402231f, 0.06715023f, 0.03549699f, -0.17381436f, 
    0.09185588f, 0.09830322f, 0.03136111f, 0.16507885f, 0.09808151f, -0.02144646f, 0.04154112f, 0.03315741f, 
    0.22684260f, 0.22965091f, -0.04993808f, -0.01242662f, 0.17168710f, -0.13820107f, 0.04118136f, 0.08883073f, 
    0.04890700f, 0.00145563f, -0.01774957f, 0.07329486f, -0.17743038f, 0.00106653f, 0.12432069f, -0.10646608f, 
    0.01635688f, 0.09911355f, -0.09834711f, -0.07815401f, 0.02384393f, -0.01744387f, 0.08548924f, 0.08708673f, 
    0.35033351f, -0.07445559f, 0.21394289f, 0.15061516f, -0.02543636f, -0.03406793f, -0.07408834f, -0.15462521f, 
    -0.05456397f, 0.00537297f, -0.07355667f, -0.08392434f, -0.23809256f, -0.07473440f, 0.03866873f, 0.18772291f, 
    0.12255277f, -0.14807890f, -0.04169529f, -0.08880015f, 0.05931373f, 0.04696545f, -0.07279749f, -0.01220309f, 
    0.28007412f, -0.12042146f, 0.11351851f, -0.27565280f, -0.12238152f, 0.02477730f, 0.10801016f, -0.09011259f, 
    -0.00948505f, 0.03970541f, -0.06726521f, 0.07572277f, 0.09788191f, -0.15290022f, -0.01539250f, -0.05889006f, 
    -0.06106897f, 0.03851329f, -0.01378874f, -0.27854347f, 0.26289073f, 0.06191242f, 0.07485760f, -0.00403570f, 
    0.25719818f, 0.14114103f, 0.27532348f, 0.04151423f, 0.09159448f, 0.00941294f, 0.09121441f, -0.00964089f, 
    -0.03092219f, 0.04917312f, -0.03585090f, -0.02326228f, -0.15583593f, -0.03156871f, -0.02438145f, -0.10236751f, 
    0.08485271f, 0.10974888f, -0.01724888f, -0.01973242f, 0.01271021f, 0.07340278f, -0.00210826f, -0.00360343f, 
    -0.09341184f, -0.10115250f, 0.02116219f, -0.09527835f, 0.01229362f, -0.02695497f, -0.08598501f, -0.04949175f, 
    -0.08239756f, -0.13885048f, 0.01308954f, -0.06792236f, 0.37433451f, -0.17445180f, 0.02112452f, -0.06179558f, 
    0.02821183f, -0.13403203f, 0.21143484f, -0.04271266f, -0.04638214f, 0.07412761f, 0.08972755f, 0.14870659f, 
    0.13322863f, 0.29020149f, -0.03910490f, 0.18414290f, -0.02060704f, -0.02417506f, -0.01277558f, 0.29328683f, 
    0.06506667f, -0.03766657f, -0.01904730f, 0.00531925f, 0.17489232f, 0.19318250f, 0.17875272f, -0.25463849f, 
    0.00785888f, 0.03725345f, -0.05355989f, 0.23696068f, 0.07244901f, 0.02530468f, 0.02699537f, 0.03810437f, 
    0.41603878f, -0.13038877f, 0.14955935f, -0.31101409f, -0.07231180f, 0.04166544f, 0.04050918f, 0.06655975f, 
    0.04949580f, -0.00596880f, -0.08572496f, -0.10850868f, 0.13928966f, 0.26730725f, -0.00431368f, 0.24620242f, 
    -0.08644117f, 0.22266108f, 0.08936065f, 0.19933215f, -0.05689871f, 0.01400419f, -0.05021644f, 0.07775786f, 
    0.06622638f, 0.20965971f, 0.16933712f, -0.07313240f, 0.07355563f, 0.00514910f, -0.01836074f, 0.18608537f, 
    0.04342709f, -0.06029543f, -0.02685051f, 0.04403234f, -0.13311069f, 0.14880811f, 0.18518396f, 0.18406045f, 
    0.04614798f, -0.07316779f, 0.06806234f, 0.13411096f, -0.08843627f, 0.01501731f, 0.03286408f, 0.04545195f, 
    -0.32234713f, 0.13363454f, 0.09487448f, 0.11669945f, -0.01838168f, 0.04193424f, -0.00133956f, 0.04803359f, 
    0.04522046f, -0.06845850f, 0.03002653f, 0.27004921f, 0.22465588f, -0.07367887f, -0.01726547f, 0.13546187f, 
    0.14198822f, 0.05665179f, -0.06944475f, 0.00220191f, 0.04638212f, -0.03697897f, 0.20032927f, -0.09945211f, 
    -0.17360938f, -0.28485349f, 0.03671950f, -0.13445482f, -0.00177864f, 0.02560455f, -0.00985316f, 0.03989518f, 
    0.09694178f, 0.06170364f, 0.21892315f, 0.09693013f, 0.07754783f, -0.16277497f, -0.26653475f, 0.00527647f, 
    -0.05009176f, 0.04659145f, -0.17887595f, 0.04618176f, 0.19304842f, 0.10362820f, 0.14601798f, 0.01855570f, 
    0.28908679f, 0.42944589f, -0.50116295f, 0.06138027f, -0.06174365f, -0.08527044f, 0.12820640f, -0.03699566f, 
    -0.22178257f, -0.00679736f, -0.13914110f, -0.01742242f, -0.01909413f, -0.02012928f, 0.00258036f, 0.09278011f, 
    0.09977257f, -0.05319869f, 0.24145232f, 0.04417790f, 0.05173521f, -0.03746316f, 0.04487231f, 0.22161843f, 
    -0.00374933f, 0.38596195f, -0.03373725f, -0.36547193f, 0.02578302f, -0.03968957f, -0.06547917f, -0.00959364f, 
    0.10001100f, 0.05151253f, 0.15871730f, 0.08441916f, -0.00204680f, -0.06495789f, -0.23614714f, -0.13209395f, 
    0.05367355f, -0.02161708f, 0.03276907f, -0.01320604f, -0.14322010f, -0.07503629f, -0.16892228f, 0.05757025f, 
    -0.14189592f, 0.06531405f, 0.14296654f, 0.06832451f, -0.03202732f, -0.09730975f, 0.01875943f, 0.04370909f, 
    -0.15874255f, -0.01486004f, -0.03021688f, 0.06692523f, 0.08940619f, -0.15356456f, -0.07364281f, -0.01316728f, 
    0.00983691f, -0.01304727f, 0.00434842f, 0.10496971f, -0.03663468f, 0.07478703f, 0.26695246f, -0.01329887f, 
    0.02846064f, -0.11630841f, -0.03067017f, 0.07175120f, 0.01816606f, 0.03850574f, 0.09092610f, -0.10253067f, 
    -0.08563209f, -0.14259961f, -0.29901415f, -0.19004801f, -0.12705436f, 0.22741349f, 0.08219441f, 0.10732551f, 
    -0.11144397f, -0.00299550f, 0.18080308f, 0.09001541f, 0.06907170f, -0.05873961f, 0.02731324f, 0.09130779f, 
    0.10153381f, 0.20925982f, 0.21242791f, -0.08838789f, 0.05952141f, 0.07833765f, 0.01135295f, 0.02170310f, 
    0.12273978f, -0.05965650f, 0.09050772f, 0.08315543f, 0.03384444f, -0.11990789f, -0.00229528f, 0.09489670f, 
    0.20200349f, -0.03158771f, -0.07210209f, -0.06264685f, 0.01562839f, -0.04559730f, 0.16316047f, 0.08654500f, 
    -0.04466263f, -0.00305922f, -0.01205399f, 0.21668428f, 0.17059493f, 0.01366419f, -0.03810519f, -0.07436553f, 
    0.14041416f, 0.08201896f, 0.17750072f, 0.14685711f, -0.25212193f, -0.21087219f, -0.09783615f, -0.23540488f, 
    0.16472472f, 0.01084287f, 0.11569262f, 0.10658175f, -0.00641577f, 0.05701888f, 0.07768690f, -0.09819835f, 
    -0.04605158f, 0.11077716f, 0.09219530f, 0.20241478f, -0.10456111f, -0.08759674f, -0.04463106f, 0.02868682f, 
    -0.03276404f, -0.05834818f, -0.04861397f, -0.04624686f, -0.08159106f, -0.17470859f, 0.10992203f, -0.00948027f, 
    -0.03035077f, 0.02025702f, -0.12266468f, -0.04378869f, -0.01181546f, -0.18387999f, -0.11358647f, -0.24567479f, 
    0.16424590f, -0.02978281f, -0.01395391f, -0.07095162f, 0.06510581f, 0.10592961f, -0.16036384f, -0.01863690f, 
    -0.08904121f, 0.00543861f, 0.13724561f, 0.08029057f, -0.04361347f, -0.00188219f, 0.17325787f, 0.16046700f, 
    -0.01904918f, -0.09783066f, 0.02432682f, 0.11867449f, 0.08052234f, -0.06424961f, -0.13733321f, 0.06367813f, 
    -0.14744282f, 0.19832753f, -0.12784700f, -0.18034127f, 0.07311039f, 0.08111975f, 0.01455377f, 0.03565887f, 
    0.04175178f, -0.25764117f, -0.04440065f, -0.18686961f, 0.03484495f, 0.08672283f, -0.10200696f, 0.16921410f, 
    0.01491059f, -0.06514519f, 0.07636985f, -0.10156500f, 0.02531689f, 0.10824944f, 0.09622845f, 0.14713036f, 
    -0.01103598f, -0.15095758f, 0.06203960f, -0.05611452f, 0.05095483f, -0.12563364f, 0.02008585f, 0.02160153f, 
    0.24827942f, 0.08567901f, 0.14228323f, 0.07344387f, -0.06305313f, 0.29817733f, -0.09074658f, -0.00053745f, 
    -0.03028448f, -0.32778895f, -0.03205936f, 0.17707461f, -0.16488679f, -0.09566668f, -0.07709360f, 0.11689895f, 
    0.03228022f, -0.21070357f, -0.09053871f, 0.12288032f, -0.00538657f, 0.17108886f, -0.01851887f, 0.12391990f, 
    0.08213390f, 0.04517478f, -0.15474990f, -0.08509165f, 0.10210274f, -0.00182063f, 0.03347120f, 0.11667660f, 
    -0.03286124f, -0.06678592f, -0.02201689f, -0.00322888f, 0.16615415f, 0.05085165f, 0.10259145f, 0.08857154f, 
    0.13173631f, 0.00367670f, 0.05241697f, 0.05506561f, 0.11867855f, 0.12411970f, 0.16278525f, -0.07785633f, 
    -0.07468747f, -0.04781948f, -0.09005148f, 0.08628621f, 0.15233937f, 0.05018781f, 0.07193088f, -0.14210629f, 
    0.05786373f, 0.04189528f, 0.01340702f, -0.05649530f, -0.09204236f, 0.01753705f, -0.04078127f, -0.18445575f, 
    0.19224644f, -0.11338984f, -0.04863064f, -0.01268661f, 0.02471332f, 0.01989585f, -0.02762232f, -0.20787425f, 
    -0.06353605f, -0.20891775f, -0.11171103f, -0.02132363f, 0.11813322f, 0.40898675f, 0.05394983f, -0.07651404f, 
    0.00401937f, 0.02906139f, 0.11618764f, 0.16088314f, 0.05330266f, -0.00169385f, 0.08038869f, 0.21546665f, 
    -0.05592259f, 0.10801652f, -0.30116069f, -0.00350771f, 0.03571543f, -0.00656469f, 0.04415555f, 0.00435693f, 
    0.00156658f, 0.10177580f, 0.20745876f, 0.31417578f, 0.16100720f, -0.15726572f, 0.29344627f, -0.03157640f, 
    0.04699059f, -0.04765808f, -0.18078157f, 0.17780137f, -0.08474431f, -0.12901981f, -0.10217133f, -0.11739317f, 
    0.20518081f, 0.35530204f, 0.27401528f, -0.03814091f, -0.14206259f, -0.09004995f, -0.09933262f, 0.19613802f, 
    -0.11643251f, -0.11511599f, -0.03432839f, -0.19909702f, 0.12541680f, -0.33657351f, -0.01059069f, 0.11426694f, 
    -0.16521989f, -0.11182411f, -0.05826883f, 0.19000961f, 0.14323209f, 0.08479615f, 0.01902663f, 0.10289153f, 
    0.18400180f, 0.12130603f, 0.01006790f, -0.08364959f, 0.06006535f, 0.10898048f, 0.06424671f, 0.11168279f, 
    0.03558154f, 0.00322292f, 0.10145757f, 0.31790626f, 0.06087769f, -0.09950499f, 0.36622062f, 0.09933593f, 
    -0.06866279f, -0.03053702f, 0.01227908f, -0.00357310f, 0.02218695f, -0.27154735f, -0.02483356f, -0.05911250f, 
    -0.13175629f, 0.00358210f, 0.17278053f, 0.10723592f, -0.09455294f, -0.03823332f, -0.02992441f, 0.06517114f, 
    0.01156554f, 0.08953372f, 0.02604843f, 0.09138111f, -0.09958609f, 0.37368265f, 0.23092255f, 0.14886171f, 
    0.13264495f, -0.04098814f, 0.07039296f, -0.05056075f, -0.01375957f, -0.00097250f, 0.00549853f, -0.08489212f, 
    -0.02965645f, 0.03134307f, -0.18189582f, 0.10903275f, -0.04442305f, 0.16575341f, -0.06030580f, 0.02556358f, 
    0.16186370f, 0.06934125f, 0.07570063f, -0.04191443f, -0.20908636f, -0.14213647f, 0.13130549f, 0.04524117f, 
    -0.06022079f, 0.01874532f, -0.02646723f, 0.02583528f, 0.11167684f, 0.00905606f, -0.15124224f, -0.03194050f, 
    0.26171729f, -0.04941543f, 0.05773022f, -0.00923940f, -0.00599790f, -0.11856365f, -0.06990676f, 0.11098240f, 
    -0.10260232f, -0.05209928f, 0.04453744f, -0.01761736f, -0.63198400f, 0.12536544f, -0.26281053f, 0.10765552f, 
    -0.01251385f, 0.12887706f, 0.13065226f, 0.04842671f, 0.12813093f, -0.07270826f, 0.06427593f, 0.07229818f, 
    0.32958755f, -0.12652196f, 0.14723489f, 0.18052177f, -0.01267061f, -0.04124802f, -0.06240944f, 0.05377322f, 
    0.13428065f, -0.07190915f, 0.13439997f, 0.07977798f, -0.23034725f, -0.21985707f, -0.14620641f, -0.09503806f, 
    0.19442290f, -0.13075064f, -0.13106054f, -0.03311425f, 0.25079882f, 0.21201779f, 0.15433149f, 0.20101291f, 
    -0.05216637f, -0.03956786f, 0.08693618f, -0.15417872f, 0.07619391f, 0.07959580f, -0.02676312f, 0.06845818f, 
    0.07178620f, -0.12116373f, -0.05027366f, -0.03666104f, 0.07351957f, 0.03004828f, 0.06685381f, 0.17775570f, 
    0.11309400f, -0.07530187f, -0.10032900f, 0.01798239f, 0.03130393f, 0.04032948f, -0.07403670f, 0.22096756f, 
    -0.32568696f, -0.20140806f, 0.05672159f, 0.22974010f, 0.06343826f, 0.07920498f, 0.10152361f, 0.07369351f, 
    0.05930768f, -0.04955155f, -0.26503709f, 0.10931833f, -0.07307476f, 0.09787203f, 0.10981620f, 0.16639134f, 
    -0.05536861f, -0.04425118f, 0.08159521f, -0.01248130f, -0.03252849f, -0.05985339f, -0.05933021f, -0.10352957f, 
    -0.03107911f, 0.32694638f, -0.01869648f, -0.10648346f, -0.02024047f, -0.01614606f, 0.10410807f, 0.00623832f, 
    -0.03635301f, 0.08092660f, 0.12914106f, 0.01487542f, 0.03002713f, 0.00695449f, -0.18319470f, -0.07584399f, 
    0.06602149f, -0.08277818f, -0.08766960f, 0.09850916f, 0.11026865f, 0.05712187f, 0.17758191f, -0.08828929f, 
    -0.17296343f, -0.17889987f, -0.07825369f, -0.08900427f, 0.10922984f, -0.15787101f, -0.04990730f, 0.03708833f, 
    0.12642831f, 0.08434364f, 0.01719219f, 0.04010933f, 0.14090757f, -0.25089943f, 0.05853469f, 0.07565705f, 
    -0.09858634f, 0.11392678f, -0.09085643f, 0.00716783f, 0.03381870f, 0.14642605f, 0.10038694f, 0.24533705f, 
    -0.26380217f, 0.29137421f, -0.24479695f, 0.01077659f, 0.05101238f, -0.00954808f, -0.10189288f, -0.02414913f, 
    0.08702628f, 0.00093421f, 0.08761700f, 0.09702092f, -0.11597148f, -0.20323937f, -0.21958853f, 0.14505143f, 
    -0.09174181f, 0.00787145f, 0.02799986f, 0.06363972f, 0.10034044f, 0.07341912f, 0.01750465f, -0.04917097f, 
    -0.06571264f, -0.04695474f, 0.06875983f, 0.11429659f, 0.03720877f, 0.04917547f, 0.04438964f, -0.02259707f, 
    0.06176377f, 0.03773290f, -0.06324217f, 0.09176303f, 0.03621576f, -0.20128903f, -0.03276314f, -0.05465431f, 
    0.02856417f, 0.00342968f, -0.05179108f, 0.12529437f, 0.07285271f, -0.23645739f, 0.03328268f, -0.11187553f, 
    -0.11279672f, -0.11588007f, -0.17273332f, -0.02305215f, 0.09850011f, 0.04930387f, 0.07261320f, -0.01395968f, 
    0.22514404f, 0.16426939f, 0.01407889f, 0.14698578f, -0.21093684f, -0.08071793f, -0.12791431f, -0.02236191f, 
    -0.15529372f, -0.02403627f, 0.19167106f, -0.04363711f, -0.04609185f, 0.09642056f, -0.08210845f, -0.12855180f, 
    0.15084489f, -0.12832004f, 0.07120915f, -0.07591036f, 0.12976572f, 0.07600643f, -0.16752696f, -0.07221752f, 
    0.09934402f, -0.13919371f, -0.00348599f, 0.00707523f, 0.03518851f, 0.32826778f, 0.19131224f, 0.18203661f, 
    0.13540699f, -0.15371411f, 0.03955256f, -0.00532306f, -0.03760865f, -0.02397194f, 0.02966272f, 0.00631052f, 
    -0.21479416f, 0.21621378f, 0.06975923f, 0.08360247f, -0.05845218f, -0.05120473f, -0.02093219f, -0.10615026f, 
    0.02680370f, 0.01189593f, 0.14112340f, 0.07074159f, -0.00515063f, 0.36058700f, -0.07289807f, -0.23250335f, 
    0.29107526f, 0.00705248f, -0.03454903f, -0.07108210f, -0.00445005f, -0.13593981f, -0.14610904f, -0.15778311f, 
    -0.01882575f, -0.01348724f, 0.02487344f, -0.02606021f, -0.00847866f, -0.00222246f, -0.03047387f, 0.01518672f, 
    -0.00601980f, -0.00397202f, -0.03193939f, -0.02864171f, -0.01693757f, 0.02518747f, 0.00487086f, 0.02474591f, 
    -0.00528078f, -0.01217493f, -0.01900947f, -0.00798035f, 0.01440447f, 0.01281322f, 0.01698804f, 0.02487788f, 
    -0.02029992f, -0.01449255f, 0.02464969f, 0.01886266f, 0.00217820f, 0.01411059f, -0.02437222f, -0.02543147f, 
    -0.03259983f, 0.01814952f, 0.00739758f, -0.03900102f, 0.00508523f, -0.00150259f, -0.00352041f, -0.02804664f, 
    -0.02126077f, -0.01445405f, -0.01332105f, -0.01800186f, -0.01346782f, -0.01684902f, -0.02558909f, -0.02645887f, 
    0.01466583f, 0.02482374f, 0.02769474f, -0.03872603f, 0.03744225f, 0.01202774f, 0.00266559f, -0.03694938f, 
    -0.01178106f, 0.01466058f, -0.03032347f, -0.03738189f, 0.01537494f, -0.00228740f, 0.00687607f, -0.03928610f, 
    0.02771911f, 0.02468576f, -0.03892453f, 0.00295114f, 0.00256919f, -0.03212923f, 0.02123708f, -0.03968256f, 
    -0.03744378f, -0.03839701f, 0.01025810f, -0.02204232f, 0.01869285f, -0.00112861f, -0.02353490f, 0.02236093f, 
    0.02602959f, 0.02483501f, -0.03821561f, 0.00380583f, -0.02882585f, -0.02651753f, 0.00304244f, 0.02039636f, 
    0.00617665f, -0.01130241f, 0.01466442f, 0.02761558f, -0.02453920f, 0.00493224f, 0.01414655f, -0.00819474f, 
    -0.00525495f, 0.01553440f, -0.02128681f, -0.00280467f, -0.03827978f, 0.02020492f, 0.01462554f, 0.02958321f, 
    0.02622945f, -0.00067913f, 0.01744961f, 0.01265822f, 0.01783667f, -0.01451034f, -0.03402434f, -0.00525795f, 
    0.01797665f, -0.03381503f, -0.01825757f, 0.00516003f, 0.01463263f, 0.01563147f, -0.02778461f, 0.02627755f, 
    0.00305099f, 0.00928827f, 0.00916907f, 0.01523478f, -0.02909357f, -0.00583999f, -0.01854466f, 0.00983968f, 
    0.01819532f, -0.02260684f, -0.01843611f, -0.03198392f, 0.01214846f, -0.01512854f, -0.00058391f, 0.00554604f, 
    0.01815075f, -0.03086671f, 0.01344504f, -0.01589246f, 0.00759267f, -0.03444201f, 0.01950010f, -0.02758569f, 
    -0.00064443f, -0.03825342f, -0.00575601f, -0.01135868f, 0.02920744f, 0.02353136f, 0.01779568f, -0.03161691f, 
    -0.00932111f, -0.03204171f, -0.02359679f, 0.00615564f, 0.02158812f, -0.04139531f, 0.00012141f, 0.01708239f, 
    -0.02332913f, 0.01447067f, -0.03240235f, -0.03007846f, 0.01087852f, 0.00466842f, -0.01407622f, -0.04099033f, 
    -0.02890669f, -0.03905408f, -0.03406642f, 0.00419124f, 0.00351925f, -0.03758844f, -0.00292878f, -0.04103580f, 
    -0.00296412f, 0.01153334f, -0.00061993f, 0.01882544f, 0.01841435f, 0.00256959f, 0.02303328f, -0.01046454f, 
    -0.02083045f, -0.00059298f, 0.01709612f, 0.00395481f, 0.02187468f, -0.00033611f, -0.03221787f, -0.02490162f, 
    -0.01432569f, 0.00957810f, -0.02147345f, -0.02016756f, -0.03060597f, -0.03898624f, 0.02867226f, -0.03052115f, 
    0.01270714f, -0.00410416f, -0.03290340f, 0.00881647f, 0.01292812f, 0.00492903f, 0.00137854f, 0.02964834f, 
    -0.00807115f, -0.02611271f, 0.02977318f, -0.03755032f, -0.03255467f, 0.02567405f, 0.00516540f, -0.02578845f, 
    0.00977803f, -0.00446123f, 0.01082264f, 0.00547189f, 0.02495331f, -0.00632029f, -0.03145852f, 0.00445693f, 
    0.02656341f, -0.00070150f, 0.01198313f, 0.00320804f, -0.01893139f, -0.01188991f, -0.00046333f, 0.00409519f, 
    -0.00683548f, 0.02619560f, 0.01139129f, -0.01168054f, -0.01086639f, 0.02251912f, 0.01987306f, -0.03893798f, 
    -0.02463171f, -0.03699712f, -0.02895121f, 0.02299380f, -0.00061356f, 0.02194146f, -0.02028582f, -0.03202305f, 
    -0.03972656f, 0.00759355f, -0.00956456f, 0.02301468f, 0.00910364f, 0.00055064f, -0.00072520f, 0.02092519f, 
    -0.03874812f, -0.00353763f, -0.01213722f, -0.00402144f, 0.01675130f, -0.03231527f, 0.01014599f, -0.00562011f, 
    -0.00684815f, 0.00436940f, 0.01841243f, 0.02406188f, -0.03899853f, 0.00028563f, -0.01307842f, 0.02681920f, 
    -0.02768448f, -0.03767807f, 0.00401880f, -0.03155075f, -0.00847771f, 0.02862552f, -0.02605399f, 0.02753085f, 
    -0.03923171f, 0.00561601f, 0.01321429f, -0.03614436f, -0.03899758f, 0.02086250f, -0.00160226f, 0.00187707f, 
    0.01492435f, -0.01244970f, -0.03382324f, 0.03087380f, -0.00829403f, -0.00931278f, 0.01435668f, 0.01705611f, 
    0.00389318f, 0.01718119f, -0.01107665f, -0.03543537f, -0.03201079f, 0.01468256f, -0.02852618f, -0.03685194f, 
    0.02027865f, -0.00879030f, -0.02227337f, -0.00437155f, 0.02942633f, -0.03940816f, 0.00891378f, 0.00789362f, 
    -0.02734571f, 0.01236207f, -0.00493486f, -0.01679972f, -0.00327400f, 0.00142594f, 0.01149426f, -0.02725073f, 
    -0.01668872f, -0.00614832f, -0.01562084f, 0.00093763f, 0.00549157f, 0.00678523f, -0.01875318f, 0.01325816f, 
    -0.01616953f, 0.01443482f, -0.00255795f, -0.00955740f, -0.01032744f, 0.02804113f, -0.01454144f, -0.02895221f, 
    -0.01424176f, 0.00923517f, 0.00149620f, 0.02947347f, -0.01441936f, 0.00894743f, -0.04149151f, 0.02195220f, 
    -0.00405181f, -0.00263256f, -0.03174143f, 0.02596851f, 0.02953448f, 0.02194039f, -0.03406167f, -0.03138475f, 
    -0.02651806f, 0.02078554f, -0.03594320f, -0.03036559f, -0.04061600f, 0.02768020f, -0.02026586f, -0.03019984f, 
    0.02407373f, -0.01004931f, -0.01476659f, 0.02356066f, -0.00641927f, 0.02377995f, -0.02615211f, 0.02446237f, 
    -0.01626177f, 0.00273954f, -0.01923990f, -0.02907331f, -0.03435701f, -0.02810552f, 0.01108888f, -0.00619895f, 
    -0.02326478f, -0.00502627f, 0.01777860f, 0.01292687f, 0.03308238f, 0.02304358f, -0.00419509f, 0.02511711f, 
    -0.01390317f, -0.01549534f, 0.02168536f, -0.03356616f, -0.01207253f, 0.02956416f, 0.00455934f, 0.01405024f, 
    -0.02670536f, -0.02978256f, 0.01348271f, 0.02256655f, -0.03450517f, 0.01614913f, -0.03372652f, 0.00446249f, 
    -0.01352316f, -0.00978541f, -0.02166382f, -0.02374947f, 0.02116553f, 0.02162416f, 0.01282913f, -0.02100787f, 
    -0.03006302f, 0.02111710f, 0.00533776f, -0.03176003f, -0.00668146f, 0.01184472f, -0.01227261f, -0.01186411f, 
    -0.03178573f, -0.01833224f, -0.03970974f, 0.00624307f, -0.04185054f, -0.01494891f, 0.00120932f, 0.01371389f, 
    0.00364316f, -0.01320020f, -0.01732148f, 0.01565368f, -0.02719758f, 0.02135187f, -0.01298791f, -0.02652123f, 
    0.01771508f, -0.02583487f, -0.04018418f, -0.01568022f, -0.02078936f, 0.01444371f, 0.01426463f, 0.00020715f, 
    0.02747886f, -0.00969907f, 0.02223720f, -0.00143172f, -0.01895845f, 0.02104343f, -0.01874223f, -0.00893208f, 
    0.02644118f, -0.02424357f, -0.03822929f, 0.02152736f, -0.03631522f, -0.01041400f, -0.01569397f, -0.02890694f, 
    -0.02609929f, -0.02521818f, 0.00911797f, -0.02205849f, 0.01328049f, 0.02397382f, 0.01166814f, 0.02648972f, 
    0.01283426f, -0.01854420f, 0.01071634f, -0.02604748f, -0.02470460f, 0.00054335f, -0.00906500f, -0.04073187f, 
    -0.03826214f, 0.02009474f, 0.02660345f, 0.02706805f, 0.02533456f, 0.01122150f, -0.04026353f, -0.02534953f, 
    0.01724551f, 0.00546401f, 0.02160865f, 0.02084965f, -0.02278730f, 0.01877289f, 0.00764278f, -0.01508046f, 
    0.01312719f, -0.01788545f, -0.01276971f, 0.00019538f, -0.03787084f, 0.02059699f, -0.03596278f, 0.00170196f, 
    -0.03803524f, -0.03787091f, -0.03970728f, 0.00368842f, -0.03058193f, -0.03361439f, 0.01280912f, -0.01032014f, 
    -0.03898181f, 0.00397369f, -0.01658558f, -0.03602903f, -0.02491221f, 0.02947679f, 0.01367207f, -0.03720827f, 
    0.02284577f, -0.04137753f, -0.03712407f, -0.01350749f, 0.00350528f, 0.00275041f, 0.02043274f, 0.01748519f, 
    -0.02427974f, 0.02085557f, 0.00181732f, 0.02084540f, -0.01701082f, -0.03729674f, 0.01114789f, 0.02679088f, 
    -0.01526183f, -0.00562155f, -0.03889079f, 0.00181100f, -0.01164891f, 0.01235619f, -0.01171561f, 0.00092141f, 
    -0.03978696f, -0.02131824f, 0.01433856f, -0.01585245f, 0.00634256f, -0.03277582f, 0.01337334f, -0.04085519f, 
    -0.01719310f, -0.01753577f, -0.01920159f, -0.01485553f, 0.02543489f, 0.02998439f, -0.02386069f, -0.00913731f, 
    -0.00306071f, 0.02778248f, 0.00338470f, -0.00448823f, -0.02154384f, -0.00837644f, -0.01424361f, -0.03155347f, 
    0.00239151f, -0.03205378f, -0.03300846f, 0.00271044f, -0.02815789f, -0.02180760f, -0.00409667f, -0.00072379f, 
    0.03178240f, -0.00460742f, 0.02327370f, -0.02786222f, 0.02608142f, 0.00009554f, 0.01394294f, -0.03960115f, 
    -0.04181635f, -0.02400092f, 0.00671011f, 0.01028458f, 0.02445146f, -0.03517777f, -0.02138738f, 0.01071311f, 
    -0.03841032f, -0.00362177f, 0.02273279f, 0.02720738f, -0.03222136f, -0.02639341f, -0.01696850f, -0.00018080f, 
    -0.02050060f, 0.02173329f, -0.00574801f, -0.04135817f, 0.01315900f, 0.02188604f, 0.02893714f, -0.04053230f, 
    0.01610539f, 0.00827415f, -0.02359283f, 0.02098540f, -0.02653411f, 0.00917421f, 0.01550784f, 0.00407230f, 
    0.00958182f, -0.01962762f, -0.04024489f, 0.00816994f, 0.02776902f, -0.00438940f, -0.04096653f, -0.04099985f, 
    0.02811755f, 0.02251662f, 0.02998601f, -0.02636376f, -0.02530888f, 0.00173887f, 0.02258988f, -0.02766837f, 
    0.00360967f, 0.02838290f, 0.01545989f, 0.01616782f, 0.00563700f, -0.00253081f, -0.03161069f, 0.01913414f, 
    -0.03773805f, 0.00257427f, -0.00904031f, -0.00015051f, 0.00219268f, 0.01507084f, 0.00755019f, 0.00444721f, 
    0.00795280f, 0.01274540f, 0.01044222f, -0.01540110f, -0.04010215f, 0.01681688f, 0.00371244f, -0.01371862f, 
    -0.01795428f, -0.03613157f, -0.02028164f, -0.03631862f, -0.01410675f, -0.00056087f, 0.02863211f, -0.00798562f, 
    0.00344143f, -0.03349587f, 0.01658783f, -0.02345590f, -0.00716422f, 0.01058161f, -0.00932455f, -0.02298693f, 
    -0.00698917f, 0.00363350f, 0.00030496f, -0.00461269f, -0.04190350f, 0.00696296f, -0.03105667f, -0.01180250f, 
    -0.02299207f, -0.00440992f, 0.01145796f, -0.01153420f, -0.03732832f, 0.00583813f, 0.01980807f, -0.01794871f, 
    0.02388395f, -0.02097704f, -0.02472643f, 0.01482757f, -0.03211986f, -0.03340362f, 0.02169848f, 0.02879591f, 
    0.02566999f, -0.01680993f, -0.01539283f, -0.01797419f, -0.02404351f, -0.01671569f, 0.00131138f, -0.02819328f, 
    0.03966160f, -0.03023551f, -0.00292497f, -0.02284482f, -0.01820365f, -0.01430643f, 0.01944804f, -0.01903537f, 
    0.00600841f, 0.01059657f, -0.01590613f, 0.00852780f, -0.02054725f, -0.02607258f, -0.00078557f, -0.00853442f, 
    0.00160157f, -0.01171214f, 0.00515117f, 0.01657753f, -0.03142956f, -0.00451158f, -0.02364413f, 0.02654113f, 
    -0.00145436f, -0.03129011f, -0.03926579f, -0.00907813f, -0.04141023f, 0.02292733f, -0.01247697f, -0.03575448f, 
    0.02159131f, 0.01971770f, -0.02221884f, 0.01846996f, 0.00071322f, 0.00692793f, 0.01124869f, 0.00224185f, 
    -0.02309591f, -0.02709012f, 0.00401031f, -0.00931951f, 0.02744028f, -0.03263670f, 0.02443729f, 0.00257003f, 
    -0.02505612f, -0.03734893f, 0.02560499f, -0.03162726f, 0.01483860f, 0.00981558f, -0.02008208f, 0.00136938f, 
    -0.00349601f, 0.02933053f, -0.01991667f, -0.03333569f, 0.01612263f, -0.03087919f, -0.02128050f, -0.04049177f, 
    0.00887076f, -0.01102447f, 0.00316426f, 0.01059744f, -0.04100104f, -0.03672873f, -0.03467230f, -0.02819812f, 
    -0.08706003f, -0.33597144f, -0.30562377f, 0.15666671f, 0.03283979f, 0.03227584f, 0.16365230f, -0.11522041f, 
    -0.04913596f, 0.12424612f, 0.04221750f, -0.01622325f, -0.08225689f, 0.16040245f, 0.24195135f, 0.12272686f, 
    -0.05742501f, 0.02040765f, 0.04177731f, -0.09328900f, -0.02770098f, -0.01615145f, -0.01379949f, -0.00820483f, 
    0.10667571f, 0.32352287f, 0.06962137f, 0.17079940f, 0.07077325f, 0.00271768f, 0.06635980f, -0.08614879f, 
    0.08517947f, 0.04614125f, 0.12820172f, 0.04991746f, -0.02797708f, 0.04704678f, 0.18110245f, 0.18079111f, 
    0.08558023f, 0.18770424f, -0.07618215f, -0.01488143f, 0.05372907f, 0.04727931f, 0.05087126f, 0.19876035f, 
    -0.09357952f, 0.06212021f, 0.17909376f, -0.03520961f, -0.05813472f, -0.02726112f, 0.00070520f, -0.01741139f, 
    0.00411061f, 0.20549661f, 0.13799036f, 0.22275372f, 0.25047490f, -0.11193325f, 0.06869023f, -0.18558420f, 
    -0.09298770f, -0.06675063f, 0.02152175f, 0.07537948f, 0.00966566f, 0.00262925f, -0.08097944f, 0.11761200f, 
    -0.33014137f, 0.06304879f, 0.02576458f, 0.02318350f, 0.30517942f, 0.00919398f, 0.02916959f, -0.05198367f, 
    0.10137390f, 0.10066174f, -0.00497544f, 0.16172168f, 0.12448070f, -0.13423918f, 0.02091415f, 0.11271853f, 
    -0.02412711f, 0.14853689f, -0.09619848f, -0.07542288f, 0.08419574f, 0.01212140f, 0.24227154f, -0.00258282f, 
    -0.17693961f, 0.15116964f, 0.02572475f, -0.15464658f, -0.05174014f, -0.06271820f, -0.03201859f, -0.01544112f, 
    0.03520023f, 0.19606754f, 0.01263577f, -0.08947614f, 0.10700873f, -0.04000567f, 0.09864156f, 0.10341004f, 
    -0.07627708f, 0.01654287f, -0.00913484f, 0.00552596f, -0.02907284f, -0.00437606f, -0.19426300f, -0.08560077f, 
    -0.00078814f, -0.01854132f, 0.04924635f, 0.10202909f, -0.00737007f, 0.17651202f, 0.21066466f, -0.01629178f, 
    0.03628823f, -0.04993324f, 0.01050168f, 0.07060505f, 0.01925560f, 0.16835161f, 0.05012641f, -0.07921641f, 
    -0.00893165f, -0.06123922f, 0.05516194f, -0.09643583f, 0.10714765f, 0.07248210f, 0.15255883f, 0.00157825f, 
    -0.16835336f, 0.04120192f, 0.02259200f, -0.02694292f, 0.11657926f, 0.01360421f, -0.00246257f, -0.07034938f, 
    -0.15154012f, -0.11304300f, -0.12299649f, -0.10854722f, -0.05985583f, 0.11625218f, 0.17550410f, 0.05010598f, 
    -0.05541661f, -0.01415808f, -0.00341169f, -0.10981560f, -0.07995017f, 0.12780260f, 0.07926704f, 0.08181606f, 
    -0.20151281f, -0.16543508f, -0.18550606f, 0.14700216f, -0.01526937f, -0.00585074f, -0.00511466f, -0.00440903f, 
    -0.00180405f, 0.06481002f, 0.12399951f, -0.10495020f, 0.00750037f, 0.05207089f, 0.06780679f, 0.03587960f, 
    0.13878670f, 0.01773525f, 0.06029559f, 0.02527732f, -0.00846139f, -0.07964083f, 0.10620200f, -0.09093407f, 
    -0.04042846f, -0.21844538f, -0.11736391f, -0.12922066f, -0.10886734f, 0.26022241f, 0.04809342f, 0.03050466f, 
    0.15623003f, 0.06306240f, 0.03749226f, 0.04456585f, -0.13844861f, 0.14413218f, -0.01714283f, 0.12468085f, 
    -0.00300216f, -0.05279250f, -0.06620554f, 0.12611140f, 0.10651656f, 0.17964067f, 0.02349669f, 0.15926553f, 
    -0.16279832f, 0.05142786f, 0.16942374f, 0.03182024f, 0.06267427f, -0.19067378f, -0.14390354f, 0.14547595f, 
    -0.15876754f, 0.12691499f, 0.04633996f, -0.19678132f, -0.12361107f, -0.04653325f, -0.02019651f, -0.00326207f, 
    0.11089972f, -0.06510837f, 0.04367893f, 0.12812328f, -0.08692416f, -0.07998325f, -0.01780196f, -0.08932441f, 
    0.19396362f, -0.20406941f, 0.21844140f, -0.21024054f, -0.00579986f, -0.04313925f, -0.02123587f, 0.03127993f, 
    -0.07172415f, 0.14759579f, 0.07174068f, -0.01097970f, -0.18427613f, 0.22706933f, 0.23339678f, 0.10264089f, 
    -0.00494622f, -0.00298459f, -0.00837743f, -0.04125076f, -0.10436989f, 0.08329889f, -0.02352210f, -0.01152698f, 
    0.21429133f, -0.12866497f, 0.12630312f, -0.08007865f, 0.09838611f, -0.02783476f, -0.08763164f, 0.12559308f, 
    -0.20775691f, 0.01155469f, 0.01480026f, -0.01284243f, -0.17453924f, -0.13125099f, 0.25934994f, 0.03578436f, 
    -0.00670271f, 0.08940182f, 0.24860083f, -0.15072168f, 0.03051566f, 0.03552926f, 0.00612732f, 0.07614633f, 
    0.07626177f, 0.15278681f, 0.01203578f, 0.04142700f, -0.06927016f, 0.05777284f, 0.02020132f, -0.01931896f, 
    0.09357379f, 0.12637517f, 0.17188595f, 0.17348413f, 0.05466244f, 0.06715973f, -0.08209214f, 0.05350979f, 
    -0.02621060f, -0.06465598f, 0.04298853f, -0.04300341f, -0.05903200f, -0.05222941f, -0.03481291f, 0.01612859f, 
    0.15906429f, 0.04844008f, 0.01072493f, 0.09757545f, -0.00626605f, 0.05795880f, 0.13467117f, -0.01009100f, 
    0.01552486f, -0.17252660f, 0.01593968f, -0.06823075f, -0.21009579f, -0.06877393f, -0.04566116f, 0.01904055f, 
    0.06523576f, 0.09203880f, 0.12673894f, 0.03637620f, 0.03937231f, 0.13722791f, 0.31664467f, 0.01368976f, 
    -0.16185917f, -0.04871767f, -0.23945473f, -0.05701405f, -0.08174635f, 0.01234068f, 0.01729453f, 0.02195559f, 
    0.02741558f, 0.15701431f, -0.10532177f, -0.05442243f, -0.03024065f, -0.04739629f, -0.07015492f, -0.17702991f, 
    -0.01942106f, 0.10977367f, -0.09846890f, 0.25154608f, -0.05893150f, 0.28757155f, -0.05836328f, -0.09226162f, 
    -0.36266598f, -0.20674480f, -0.10168696f, -0.23989041f, -0.19177714f, -0.01286546f, -0.07763873f, -0.07733624f, 
    -0.02586936f, -0.09071425f, -0.05848931f, -0.11116320f, -0.14836945f, 0.10079350f, 0.09283749f, -0.03267669f, 
    -0.03052876f, 0.14774546f, 0.00066949f, 0.00648000f, 0.18088657f, 0.12040934f, 0.03572055f, -0.16088864f, 
    0.06471153f, 0.21175618f, -0.05927552f, -0.03556764f, -0.08305705f, 0.15371294f, -0.05382562f, -0.04306906f, 
    0.03937018f, 0.15143102f, 0.01032528f, 0.12169440f, -0.13595900f, 0.13215810f, -0.14738774f, -0.16451590f, 
    -0.00942719f, -0.04173926f, 0.00039071f, 0.01767614f, -0.05272227f, -0.07467629f, -0.09277394f, -0.11769228f, 
    -0.06589565f, -0.23271023f, 0.08770576f, -0.11009604f, -0.05457162f, 0.09296169f, -0.05034331f, -0.15910144f, 
    -0.06332659f, -0.01014109f, -0.06169216f, -0.03380733f, -0.07675493f, 0.07987544f, -0.02957464f, 0.05874162f, 
    -0.12861277f, -0.10156439f, 0.01721201f, -0.06745403f, -0.04797668f, 0.04146868f, 0.10394639f, 0.00490955f, 
    0.17083693f, 0.04244790f, 0.13416816f, -0.06024816f, -0.01226899f, 0.05807548f, -0.02059320f, -0.00389296f, 
    0.00709416f, 0.23580670f, 0.15437789f, 0.13513632f, -0.18788598f, 0.04283296f, -0.26465204f, -0.28316870f, 
    -0.03365374f, -0.20153962f, 0.13209924f, 0.02353702f, -0.04686769f, 0.10079195f, -0.09567895f, -0.10619846f, 
    0.01423568f, -0.07794917f, -0.15953496f, -0.00569970f, 0.13158052f, 0.07130320f, 0.14967738f, -0.08601704f, 
    0.02111478f, 0.01149407f, 0.09324333f, 0.03680036f, -0.14527638f, -0.40990302f, -0.05936511f, -0.16951963f, 
    0.11730754f, 0.00735487f, -0.07552047f, -0.10626058f, -0.01379153f, 0.02632171f, 0.05433877f, 0.11881260f, 
    0.21337578f, 0.03311421f, 0.16402155f, -0.01238235f, 0.08784837f, 0.10373000f, 0.03664470f, -0.09274580f, 
    0.10546067f, 0.08735975f, -0.10266204f, 0.24417071f, -0.12558159f, 0.22492670f, 0.31126580f, 0.15359193f, 
    0.01624793f, -0.09258562f, -0.01182660f, 0.08672708f, -0.07640616f, 0.06862199f, 0.02628243f, -0.22125126f, 
    0.10665146f, 0.23697041f, -0.11609171f, -0.16636278f, 0.00316974f, -0.04240945f, 0.01551316f, -0.01284101f, 
    -0.08666788f, 0.00779014f, 0.02450442f, -0.07526986f, 0.36074680f, 0.30492193f, -0.13634869f, 0.21734512f, 
    0.08320223f, 0.03437909f, -0.04080516f, 0.02549770f, -0.08391223f, 0.24343690f, 0.21000667f, 0.18646100f, 
    -0.21621466f, 0.13557500f, -0.25473893f, 0.00079064f, 0.08540870f, 0.14491637f, 0.15488231f, 0.02461172f, 
    -0.04782709f, 0.05889779f, 0.01572697f, 0.09300423f, -0.08824205f, 0.10512021f, -0.14946473f, 0.06507622f, 
    -0.12210330f, 0.01572463f, -0.02423804f, 0.03918119f, 0.07781773f, 0.00212863f, 0.21990597f, 0.01774655f, 
    -0.21739210f, -0.14461415f, 0.04726621f, -0.09460028f, -0.11429564f, -0.09858863f, -0.13919799f, -0.17803535f, 
    -0.10180420f, -0.20160569f, -0.03673046f, -0.10462434f, -0.06755536f, -0.21604151f, -0.06366602f, -0.05921035f, 
    0.02526063f, -0.00304233f, 0.08100338f, -0.06807466f, 0.12934716f, 0.11775173f, 0.17070951f, 0.05969935f, 
    0.07026414f, 0.19428287f, -0.14572398f, 0.21755357f, 0.12687233f, -0.11097386f, 0.14562508f, -0.01140015f, 
    -0.01629866f, -0.08775928f, -0.03593717f, -0.00332276f, -0.22746761f, -0.00668040f, -0.11202727f, -0.02684712f, 
    -0.08503260f, -0.10241314f, 0.08592653f, -0.06150488f, -0.10578646f, 0.00413039f, -0.07682446f, -0.04843691f, 
    -0.07462400f, -0.20787372f, 0.30164874f, 0.19428080f, 0.05903387f, 0.09454302f, 0.03086552f, -0.00075592f, 
    0.07010669f, 0.01080427f, 0.21688522f, 0.02495270f, 0.35628489f, -0.20934723f, 0.13473420f, -0.10497539f, 
    -0.01078168f, 0.12299016f, 0.08414280f, 0.03210406f, 0.00818153f, 0.14976400f, -0.03274404f, -0.08328445f, 
    -0.05433328f, 0.39384624f, -0.04811845f, 0.22531171f, 0.00653973f, 0.03612372f, -0.02609669f, 0.07478316f, 
    0.00905450f, 0.11392103f, 0.30086708f, 0.10522843f, 0.03087701f, 0.39544353f, 0.05166379f, 0.03509938f, 
    -0.08443889f, -0.01634580f, 0.08967032f, -0.08496899f, 0.16438480f, 0.00060347f, 0.25460947f, 0.05473975f, 
    0.50946778f, -0.06211100f, 0.21640894f, -0.02980578f, 0.07460427f, -0.01751265f, 0.13927871f, 0.04921603f, 
    -0.18051587f, 0.20299135f, 0.21816804f, 0.00491805f, 0.07149604f, 0.13235801f, 0.02080112f, 0.02807468f, 
    0.06378473f, 0.02281515f, -0.03319067f, 0.15614817f, -0.01759463f, 0.11198279f, 0.01431119f, 0.25402936f, 
    -0.03951643f, -0.07892323f, -0.10374873f, -0.03100361f, 0.00989005f, 0.05626184f, 0.02775034f, -0.06880721f, 
    0.11592187f, 0.01827497f, 0.16000417f, 0.06455863f, 0.12052230f, 0.03735789f, -0.00806240f, -0.11250865f, 
    0.07266622f, -0.10073449f, 0.10127196f, 0.03871519f, -0.09518567f, -0.06555638f, -0.07431234f, -0.04824048f, 
    0.06987081f, 0.00995711f, -0.03769378f, -0.02718923f, -0.04420587f, 0.02732712f, 0.13775022f, -0.00129671f, 
    0.11645617f, 0.22201990f, 0.02750240f, 0.30657789f, 0.06257717f, 0.24980536f, 0.02794588f, 0.20852837f, 
    -0.11008198f, 0.04280329f, 0.09318356f, -0.01923176f, 0.21085736f, -0.09808557f, 0.06939995f, -0.01302790f, 
    -0.23962416f, -0.40485829f, -0.11544601f, 0.09332675f, 0.00688700f, 0.02120947f, 0.01485573f, 0.05650957f, 
    0.09476367f, 0.00097092f, 0.05704162f, 0.01403672f, -0.24297352f, -0.19071391f, -0.48546314f, 0.16620827f, 
    0.01510696f, -0.11866889f, 0.16032121f, -0.06745230f, 0.02108713f, -0.02683712f, 0.05488246f, 0.00192742f, 
    -0.07160817f, 0.13215689f, -0.05608681f, 0.10791753f, 0.04481652f, -0.07364843f, -0.04502727f, 0.05681359f, 
    -0.10101601f, 0.12486239f, 0.16155098f, 0.09332649f, -0.20094091f, -0.55599469f, 0.14451401f, -0.14108016f, 
    0.06291878f, -0.17143251f, -0.10103887f, -0.10421821f, -0.06477660f, 0.09856925f, 0.00006306f, -0.01499065f, 
    -0.14306894f, -0.09351266f, 0.21978690f, 0.07777627f, 0.01575406f, -0.01723715f, 0.04937178f, -0.00164013f, 
    0.11342915f, 0.02327726f, -0.01979483f, 0.03274647f, -0.35295671f, 0.05214373f, -0.01494045f, -0.02956579f, 
    -0.03742495f, -0.03392911f, -0.01958059f, -0.01616923f, 0.02355337f, -0.03547840f, -0.00003257f, -0.01075684f, 
    0.46213725f, 0.14391057f, -0.16693032f, -0.14069402f, -0.03681648f, -0.06321952f, 0.01498218f, 0.06775028f, 
    0.06218293f, -0.09065731f, 0.09126980f, -0.04030577f, -0.83887100f, 0.16731432f, 0.12053129f, 0.17329773f, 
    -0.02325868f, -0.04712508f, 0.10138027f, 0.04735421f, 0.09367320f, 0.10957710f, -0.18812016f, 0.04131244f, 
    -0.15538630f, -0.10157979f, -0.00025544f, 0.10034090f, -0.03319795f, -0.14197138f, -0.02916853f, 0.01468431f, 
    0.12618528f, -0.02771089f, 0.01745176f, 0.04359830f, 0.16164131f, 0.02446224f, -0.22169042f, 0.03210535f, 
    0.01021147f, -0.06149117f, -0.02992716f, -0.08854453f, 0.03344538f, -0.06150475f, 0.10266647f, 0.02405085f, 
    -0.33766168f, -0.31537265f, 0.26755142f, 0.44108745f, -0.07114451f, 0.02185040f, -0.09773616f, 0.02963644f, 
    0.14288086f, 0.05303635f, 0.08101229f, -0.12989971f, -0.44954699f, 0.09487599f, 0.18071097f, 0.22194029f, 
    -0.05833394f, -0.07992932f, -0.07017454f, 0.18720621f, 0.06940752f, -0.07091506f, -0.08469090f, -0.15555608f, 
    -0.11846887f, -0.25213495f, 0.32036176f, 0.07472916f, -0.03957679f, -0.12936752f, -0.01643496f, 0.06490671f, 
    -0.02132047f, -0.16537654f, -0.18265420f, 0.13865891f, -0.01171794f, -0.06792621f, -0.18840291f, -0.01824037f, 
    0.10866755f, -0.06330828f, -0.10802034f, -0.02667291f, 0.04388876f, -0.03604943f, 0.01588537f, 0.19256972f, 
    0.00114388f, 0.10602510f, 0.17741060f, -0.01208788f, 0.03832270f, 0.02030048f, 0.00226202f, -0.04429379f, 
    0.01571241f, -0.07191763f, -0.10747123f, -0.11814933f, 0.03535547f, 0.15647410f, -0.11496989f, 0.09258019f, 
    -0.02707133f, 0.03173855f, -0.12505320f, -0.05773800f, 0.11718018f, 0.05872349f, 0.02837366f, 0.07989984f, 
    -0.14839786f, 0.06327505f, 0.05351510f, 0.19674897f, -0.01166999f, 0.12644590f, 0.05330409f, -0.03981002f, 
    -0.06691809f, -0.04330641f, -0.05474007f, -0.03842272f, 0.03961721f, 0.15535228f, 0.14356612f, -0.33667871f, 
    -0.09966403f, -0.16163510f, -0.11045308f, 0.09250261f, 0.06379808f, 0.01489379f, 0.09906296f, -0.08260956f, 
    -0.11083122f, -0.04055029f, 0.28887078f, 0.06054801f, 0.12973805f, -0.03443092f, 0.00538989f, 0.01650758f, 
    0.05545388f, 0.01292558f, -0.06918632f, 0.08497532f, 0.08717663f, 0.05123707f, 0.03461897f, 0.10558990f, 
    -0.05916879f, -0.06028838f, -0.02119623f, -0.07605918f, 0.14115088f, 0.05561021f, -0.00187669f, 0.13352852f, 
    -0.08913949f, -0.12984847f, 0.03227705f, -0.11378832f, 0.00918636f, 0.12543234f, -0.01065532f, 0.14641720f, 
    -0.14887561f, -0.17819086f, 0.00301715f, -0.08134490f, -0.07025904f, -0.17512418f, 0.02705739f, 0.35058701f, 
    -0.11984442f, -0.10440131f, -0.07126893f, 0.03703317f, 0.06581251f, -0.05871218f, 0.06204407f, 0.21046135f, 
    -0.23491944f, 0.22552042f, 0.11197827f, -0.17691228f, -0.12705167f, -0.10222289f, 0.15466507f, 0.00632432f, 
    -0.06260742f, -0.11821482f, -0.02945633f, -0.05071856f, -0.12949175f, 0.02255694f, 0.07234569f, 0.07108564f, 
    -0.06186906f, -0.01275605f, 0.05765778f, 0.01482765f, 0.01915406f, 0.02156338f, 0.03212999f, -0.03413190f, 
    -0.13338096f, 0.07024509f, 0.01638491f, 0.02796527f, 0.09377990f, -0.04186833f, 0.13589680f, -0.02256812f, 
    0.04664838f, 0.02284338f, -0.02141691f, 0.09664484f, -0.29761714f, 0.18043654f, 0.16593818f, 0.02816020f, 
    -0.04615849f, 0.01120505f, -0.00107538f, 0.14455815f, 0.00304601f, 0.06983180f, 0.08128691f, -0.06247802f, 
    0.25381976f, -0.14782500f, 0.05030088f, -0.10653108f, -0.03456419f, -0.04916064f, 0.04552294f, 0.02714559f, 
    0.09318309f, -0.02393490f, -0.04511818f, 0.18990971f, 0.13018568f, -0.14036584f, 0.15822421f, 0.01430231f, 
    0.12644310f, 0.09502176f, -0.16553622f, 0.06994976f, 0.19708009f, -0.00627692f, 0.28296661f, 0.01756642f, 
    -0.06048775f, -0.16202383f, 0.11175679f, 0.30479753f, 0.00472193f, -0.03586110f, -0.04205458f, 0.04463361f, 
    -0.04710500f, -0.06008955f, 0.09154653f, 0.08872072f, 0.10417920f, -0.01985604f, 0.05797366f, 0.24399382f, 
    0.02500102f, 0.02652472f, -0.02103962f, -0.04855689f, -0.00716518f, -0.06945971f, -0.04101265f, -0.07933635f, 
    0.02398144f, 0.08877079f, -0.10918520f, -0.05967885f, 0.08735453f, 0.05439993f, 0.09448685f, 0.04050458f, 
    0.03375302f, -0.03289730f, -0.03353982f, -0.13703151f, -0.12261410f, 0.06412283f, 0.19969186f, -0.01918915f, 
    0.14583126f, -0.02038533f, -0.00339478f, 0.06293029f, -0.04456988f, -0.02045056f, -0.15792693f, -0.08326431f, 
    -0.06160218f, 0.07487963f, 0.24862416f, 0.08896386f, 0.11750218f, 0.00965094f, 0.04120114f, 0.07534888f, 
    -0.00400422f, -0.11852642f, 0.07142887f, 0.00576035f, 0.03576525f, -0.06055704f, 0.10669441f, -0.16778021f, 
    -0.02496857f, -0.06339151f, -0.05480384f, 0.15907179f, 0.04951526f, -0.06437410f, -0.00042010f, 0.08937982f, 
    -0.16811143f, 0.21081614f, 0.17450541f, 0.04558730f, -0.07996738f, -0.04122707f, -0.00369445f, -0.02214223f, 
    -0.08467467f, -0.04974577f, -0.01996043f, 0.04098048f, -0.28411248f, -0.17314430f, 0.00343484f, -0.09341943f, 
    -0.08271790f, -0.12281109f, -0.07675186f, 0.08258068f, 0.03278859f, -0.10049878f, 0.03873971f, -0.11428222f, 
    0.21430950f, -0.00878864f, 0.04790283f, -0.10096836f, 0.00745967f, 0.01814925f, -0.00216744f, 0.09146583f, 
    0.17725959f, 0.06851827f, 0.06587595f, -0.13584790f, -0.09600235f, -0.02247994f, -0.17838073f, 0.09281635f, 
    -0.08917138f, -0.06902080f, 0.02373205f, -0.08094981f, -0.03989741f, -0.01660509f, -0.02592358f, 0.11351556f, 
    0.04172422f, -0.20257235f, -0.13263044f, -0.12776458f, 0.05501475f, 0.05074258f, 0.07301373f, -0.01636877f, 
    -0.02254280f, -0.10646349f, -0.01573836f, 0.03628219f, 0.11760027f, -0.02428238f, -0.13321176f, 0.09719705f, 
    -0.00941160f, -0.03315484f, -0.00178148f, -0.05840483f, 0.00893063f, -0.04585743f, -0.03847154f, -0.08757137f, 
    -0.34853703f, 0.09015851f, -0.06343720f, -0.21317513f, -0.01941045f, -0.15278746f, 0.05596619f, 0.07199103f, 
    -0.03244625f, -0.13467699f, -0.12596726f, -0.38320571f, 0.02052661f, 0.10412066f, -0.16542184f, -0.10921871f, 
    0.08555014f, 0.11492112f, 0.08814348f, -0.08817165f, 0.05296791f, -0.02754692f, -0.04394936f, 0.07981905f, 
    -0.00366628f, 0.01005463f, 0.14069860f, 0.10022109f, 0.08407011f, 0.02003643f, 0.01406780f, 0.01816140f, 
    0.03361832f, -0.02576165f, 0.02446996f, 0.08562575f, 0.15720184f, -0.12128697f, -0.01046634f, -0.08088793f, 
    0.13260703f, 0.00120424f, 0.06868116f, -0.02706555f, 0.00943156f, -0.10099568f, -0.07071684f, -0.07731875f, 
    0.10781874f, 0.04100628f, -0.15875956f, -0.22224438f, 0.08668411f, -0.04178961f, -0.01252419f, -0.05221012f, 
    0.17299730f, -0.00797708f, -0.03206583f, 0.21926424f, -0.25695878f, 0.16106342f, 0.14006270f, 0.05418738f, 
    -0.12454482f, -0.04973880f, 0.02696075f, 0.17305799f, -0.04563569f, 0.07644457f, 0.09126407f, 0.03708700f, 
    -0.08538055f, -0.00082542f, -0.16310032f, 0.17764018f, -0.10897623f, -0.04760811f, -0.02629318f, -0.05236967f, 
    -0.00712872f, -0.04311991f, 0.06301025f, 0.09454034f, 0.45067349f, 0.12019102f, 0.08921070f, -0.24051364f, 
    -0.01898706f, -0.07118466f, -0.14141990f, 0.07597743f, 0.16640948f, -0.06040097f, -0.07245816f, -0.11886662f, 
    -0.25370330f, -0.10526814f, 0.07775896f, 0.25416422f, 0.05823522f, 0.15700527f, 0.01426983f, 0.01006463f, 
    0.03640968f, -0.00876687f, -0.05329064f, 0.01306400f, -0.08908397f, -0.19972219f, 0.10402709f, 0.19649205f, 
    -0.06655035f, -0.08435980f, -0.05005868f, -0.00245048f, -0.03123602f, -0.06495745f, -0.03741184f, -0.01035730f, 
    -0.10813672f, 0.19396253f, 0.13738446f, 0.02792218f, 0.08861443f, -0.00932530f, 0.06916523f, -0.07639893f, 
    -0.10872497f, -0.03023396f, -0.12471260f, -0.04601786f, -0.04844000f, 0.06085087f, 0.10809691f, -0.05538733f, 
    0.02231014f, 0.00915506f, 0.06713676f, 0.18892124f, 0.11617345f, 0.00299397f, 0.03148086f, -0.05231235f, 
    0.07218358f, 0.03931839f, 0.05278981f, 0.07482135f, 0.07582258f, 0.12247567f, -0.07598478f, 0.04104234f, 
    0.04897571f, 0.00745615f, 0.07342163f, 0.07197718f, 0.05352810f, -0.04732602f, 0.07794328f, -0.13174446f, 
    0.10684144f, 0.14989020f, 0.01936722f, -0.01127384f, 0.09152907f, -0.02620205f, 0.01056567f, 0.10519180f, 
    -0.06008808f, 0.01929680f, 0.21607672f, -0.02956034f, 0.05405989f, 0.04940296f, -0.08009385f, 0.00552209f, 
    0.04718495f, 0.12226613f, -0.05167417f, 0.10578202f, 0.29090634f, 0.07554044f, -0.00878699f, -0.08751362f, 
    -0.00375839f, -0.02793822f, 0.07945225f, -0.03154370f, 0.06801622f, 0.07949749f, 0.04057630f, -0.00013554f, 
    0.03559763f, -0.12352705f, 0.36355597f, 0.05866543f, -0.09279214f, -0.07779943f, 0.01709331f, 0.13508531f, 
    0.04936520f, 0.04194747f, 0.04162629f, 0.04869153f, 0.13553773f, -0.05734855f, -0.01883203f, 0.31560379f, 
    0.05166635f, -0.06136531f, -0.12044752f, -0.01119402f, 0.09519458f, -0.05282902f, -0.00539681f, 0.10939845f, 
    0.57612491f, 0.06467960f, -0.04870945f, -0.52778018f, 0.06469452f, -0.03832409f, 0.02531930f, -0.12744801f, 
    0.17226481f, -0.01670751f, -0.11723123f, 0.07795674f, 0.03399540f, 0.01085977f, -0.00636125f, 0.02456112f, 
    -0.01256322f, -0.02970087f, -0.02814388f, -0.01085836f, 0.00137294f, 0.01409992f, 0.20636924f, 0.18947051f, 
    0.05297820f, 0.08804270f, 0.09171765f, 0.04226413f, 0.03148613f, 0.03760489f, 0.02768513f, 0.10263841f, 
    0.04502809f, 0.06880092f, -0.00923962f, 0.09113964f, 0.17172231f, -0.04767704f, -0.11962911f, -0.01889165f, 
    0.00097101f, 0.09413639f, 0.07894012f, -0.06439019f, -0.01751039f, -0.01976955f, -0.02221105f, 0.07890490f, 
    0.09033137f, -0.09065387f, -0.02454664f, -0.19582728f, 0.04921546f, -0.01460305f, -0.01484491f, -0.04226763f, 
    0.05153314f, 0.00533891f, 0.10373230f, -0.22374769f, 0.34254980f, 0.10158492f, 0.03596887f, -0.10319173f, 
    0.06324136f, 0.03850742f, -0.13368654f, -0.04035380f, 0.13296571f, 0.03069066f, 0.11315490f, 0.10378721f, 
    -0.22798944f, -0.09808240f, 0.28005499f, 0.10036705f, 0.12675971f, 0.04631966f, 0.06836266f, 0.09386295f, 
    0.15478306f, -0.05223818f, -0.05468488f, 0.03827994f, -0.01704800f, -0.16544041f, 0.03896843f, -0.16823207f, 
    0.04835270f, 0.16073430f, -0.02193220f, 0.04280540f, 0.11659894f, 0.02347762f, 0.04638786f, 0.02242130f, 
    0.24060565f, 0.09931198f, 0.09851165f, -0.32561067f, -0.03917947f, -0.02386148f, -0.03079681f, 0.05194314f, 
    0.03933158f, 0.01160108f, 0.10253605f, -0.06841518f, -0.13297094f, 0.00635235f, 0.12886897f, -0.10935500f, 
    -0.13737193f, -0.03258591f, 0.12176066f, 0.05864757f, 0.06794339f, 0.01856767f, 0.02136801f, 0.12547605f, 
    0.21085389f, 0.07838824f, -0.06065721f, 0.01967376f, 0.01139281f, 0.05368529f, -0.03645845f, 0.14037661f, 
    -0.02464838f, -0.03255950f, 0.05617486f, 0.00402438f, 0.40979961f, 0.10786175f, 0.02982408f, -0.00301439f, 
    -0.11612561f, -0.08236898f, -0.02568755f, -0.03497813f, -0.03085091f, 0.02927222f, -0.09318608f, 0.12857585f, 
    -0.13324390f, -0.11498358f, 0.29934654f, 0.00127430f, -0.09853552f, 0.06208804f, -0.09854648f, -0.02583091f, 
    -0.00127174f, 0.01666519f, -0.00596332f, 0.04930299f, 0.35449988f, 0.10274426f, -0.03910934f, -0.04032113f, 
    0.01273773f, 0.01828227f, -0.02817032f, -0.04355559f, -0.08398668f, -0.06861547f, -0.04617511f, 0.09682642f, 
    0.12136837f, 0.13333650f, -0.01258826f, 0.05446646f, -0.08856168f, 0.07923955f, 0.04253341f, -0.11023308f, 
    0.01251467f, 0.06004906f, 0.02900053f, -0.02070256f, -0.12841351f, 0.27878416f, -0.07973385f, 0.22012237f, 
    -0.03105685f, -0.02713538f, 0.08213042f, 0.01345081f, 0.06676947f, 0.07552438f, 0.04696798f, -0.09320442f, 
    0.16959698f, 0.05884379f, -0.08885083f, -0.17372204f, -0.10209891f, -0.18817692f, 0.00345596f, 0.11125493f, 
    -0.07789581f, 0.01467264f, 0.04563866f, -0.03961140f, 0.19340096f, -0.11656029f, -0.12466194f, -0.14077924f, 
    0.10121243f, 0.15673050f, 0.04582553f, -0.11993662f, 0.09755139f, -0.01138645f, 0.09504332f, 0.17451304f, 
    0.25532362f, 0.03722778f, -0.06018324f, 0.17960367f, -0.04073061f, 0.02134569f, 0.00724992f, 0.08038927f, 
    0.12522033f, 0.00985173f, 0.20332360f, 0.00612999f, 0.12724485f, 0.17432857f, 0.07853676f, -0.18149188f, 
    -0.08679257f, -0.05252470f, 0.00271364f, 0.09059440f, -0.12314188f, 0.10311098f, -0.09108616f, -0.40256917f, 
    -0.03167829f, -0.02705557f, -0.07281728f, -0.07198076f, 0.03813156f, 0.01898462f, 0.04967111f, 0.07828633f, 
    0.07034840f, 0.06409678f, 0.05477244f, 0.12223086f, -0.00154971f, -0.07313091f, 0.17003061f, 0.05802735f, 
    0.04587619f, -0.06037030f, 0.08824896f, 0.04715028f, -0.08423115f, 0.02358564f, -0.09795493f, -0.00280822f, 
    0.06822416f, -0.12221829f, 0.01532905f, -0.23182657f, -0.06037687f, -0.18410420f, -0.04476183f, 0.03213518f, 
    -0.16261831f, -0.15646331f, -0.06521696f, -0.23958603f, 0.26173908f, 0.02795122f, 0.07159170f, 0.17528687f, 
    -0.00929189f, 0.02762411f, -0.04351386f, -0.19795455f, 0.00078970f, 0.05978629f, -0.04311596f, 0.15932654f, 
    0.19424862f, 0.00625763f, 0.04935032f, -0.02851469f, -0.01563406f, 0.00229959f, 0.01146525f, 0.04795773f, 
    -0.00346777f, 0.08186313f, 0.08420294f, 0.02221517f, -0.01186354f, -0.07282910f, 0.00134492f, -0.32153022f, 
    -0.03467370f, 0.05521255f, -0.03610260f, 0.02481323f, -0.08791263f, -0.14113338f, -0.25902796f, -0.26972637f, 
    0.09177978f, 0.14713119f, -0.01508084f, 0.05549748f, 0.04002857f, -0.09697252f, 0.14931118f, -0.04058779f, 
    0.13657351f, 0.31238043f, 0.08149228f, 0.22092484f, 0.21588896f, 0.11666679f, 0.21682565f, -0.18251100f, 
    0.01097302f, 0.00467897f, 0.06010881f, -0.16965553f, -0.01483755f, -0.00268807f, -0.10262269f, -0.23925669f, 
    0.15357016f, -0.03116899f, 0.00445235f, 0.04976907f, -0.00749466f, 0.17248407f, -0.00549711f, 0.05554040f, 
    0.05897699f, -0.17771016f, -0.06882160f, -0.04940572f, 0.07042345f, -0.05977568f, 0.01867702f, -0.09849652f, 
    0.05119444f, 0.15486974f, -0.14777489f, -0.27433905f, -0.27602792f, -0.30434352f, -0.18092373f, -0.31759974f, 
    -0.14027171f, 0.14308818f, -0.03444661f, 0.05145723f, 0.01550215f, 0.06190373f, -0.03490896f, 0.06834960f, 
    -0.02307467f, -0.12953573f, 0.03949270f, -0.21995182f, 0.50319016f, 0.07870916f, 0.00170463f, 0.03356751f, 
    -0.11320293f, -0.05750743f, -0.05511394f, -0.15484497f, 0.16401680f, -0.04398890f, -0.13421988f, -0.00300157f, 
    -0.26613486f, 0.13661262f, -0.00699961f, 0.10059986f, -0.01187080f, -0.00967427f, -0.15160494f, 0.07515953f, 
    -0.01312670f, -0.26337409f, -0.18721244f, -0.32993114f, 0.01592910f, -0.02864251f, -0.15398377f, -0.07644986f, 
    -0.05652525f, -0.00958765f, 0.07024089f, 0.17047603f, -0.16520377f, -0.03028150f, -0.19463035f, 0.06378862f, 
    0.09041955f, 0.10533987f, -0.00525789f, -0.10617922f, 0.10584005f, 0.10130180f, 0.01584366f, -0.03312947f, 
    0.04219639f, 0.12779115f, 0.08572912f, 0.12846082f, 0.13968977f, -0.05218200f, 0.02891901f, -0.01816225f, 
    0.05984808f, 0.03923389f, -0.04628667f, -0.20398331f, -0.11648481f, 0.02733344f, -0.06600061f, 0.05576607f, 
    -0.25811377f, -0.24464220f, 0.07754575f, -0.29930261f, -0.02428090f, 0.07614145f, 0.02035581f, -0.05780917f, 
    -0.15389127f, -0.10741450f, -0.10346416f, -0.05261644f, 0.16392244f, 0.00589498f, 0.02230499f, -0.03608372f, 
    0.03195219f, 0.07236897f, 0.09664541f, 0.01769979f, 0.05748416f, 0.16327372f, 0.19626360f, 0.23209566f, 
    0.21207891f, 0.17074867f, 0.02117606f, 0.03322078f, -0.08461243f, 0.01583394f, -0.05387997f, 0.02294917f, 
    0.15529960f, 0.09095726f, 0.03723428f, -0.02938225f, 0.02131624f, 0.17682537f, 0.06737827f, 0.15806381f, 
    0.03988552f, 0.02070173f, 0.10227574f, -0.21289554f, -0.02784558f, -0.15229826f, -0.07616016f, -0.17890741f, 
    0.29065597f, 0.03818443f, -0.05436976f, 0.03415413f, 0.02382432f, -0.04658800f, 0.03948249f, 0.13885859f, 
    0.00284342f, 0.03233283f, 0.07936413f, -0.05779728f, 0.03250876f, 0.03140362f, -0.06291414f, -0.05359323f, 
    0.01042898f, -0.00970097f, 0.15040113f, 0.14604020f, 0.07348212f, 0.10472368f, 0.09766948f, 0.11235464f, 
    -0.14173673f, -0.02754572f, 0.07404285f, 0.00001628f, 0.05582310f, -0.08279855f, 0.10088580f, 0.00311136f, 
    0.05179296f, 0.08779403f, -0.01407067f, 0.11920413f, -0.02505069f, -0.01675682f, 0.21388678f, 0.03845493f, 
    0.10062219f, 0.09481319f, -0.07294179f, -0.04937962f, -0.25991580f, -0.16799779f, -0.10714480f, -0.45611575f, 
    0.15578008f, 0.15039332f, 0.09055013f, 0.27086943f, 0.17016001f, 0.05165722f, -0.00084491f, 0.03918207f, 
    -0.14426798f, -0.11238667f, -0.06231480f, -0.27007589f, -0.09257812f, -0.13340572f, 0.01600709f, -0.00031231f, 
    -0.07435164f, 0.14155456f, -0.03634369f, 0.06345282f, -0.08531450f, 0.04097532f, 0.19541186f, 0.14328578f, 
    0.08372167f, -0.11607687f, -0.03201712f, 0.17726082f, -0.00612986f, 0.17385697f, 0.04092138f, -0.08042702f, 
    0.20344944f, 0.15029767f, 0.16131233f, 0.39487949f, -0.02285793f, -0.06156924f, 0.15910205f, 0.06354818f, 
    0.01729602f, 0.06433624f, 0.00417820f, 0.07953029f, -0.18832716f, -0.08347227f, -0.10890055f, -0.21616462f, 
    0.11271930f, -0.00570435f, -0.00767839f, -0.01665432f, 0.02769736f, 0.04296880f, -0.00605903f, 0.05152899f, 
    0.01387114f, 0.14374833f, 0.00893301f, 0.02538522f, 0.09843867f, 0.26015666f, 0.04579322f, 0.10858577f, 
    0.07448185f, -0.00247601f, 0.12352251f, 0.23322980f, -0.01696110f, 0.03074743f, -0.03688938f, 0.05683621f, 
    -0.07944147f, 0.11258838f, 0.06302126f, 0.10475928f, 0.16108358f, -0.01832769f, 0.08207990f, 0.14312162f, 
    0.17036860f, -0.01988323f, -0.06817470f, -0.12343553f, 0.49348786f, 0.03576111f, -0.02334996f, -0.01452147f, 
    -0.11301190f, 0.03451715f, -0.06783204f, -0.32891575f, 0.16100971f, -0.09435698f, -0.12342754f, 0.02337562f, 
    -0.06537318f, -0.10342745f, 0.22425638f, 0.03538109f, -0.01135794f, 0.04509628f, 0.00130343f, -0.19730397f, 
    -0.14061664f, -0.09545538f, -0.11116838f, -0.11300404f, -0.26831180f, -0.26420310f, 0.14188039f, 0.06857572f, 
    -0.07087079f, -0.13956907f, 0.09664010f, -0.14895308f, -0.02783865f, 0.04025684f, 0.05216230f, 0.04793336f, 
    0.14947292f, -0.01052279f, 0.02937564f, -0.13381720f, 0.03026014f, -0.05448505f, -0.01175114f, 0.05805472f, 
    -0.19554104f, 0.07222462f, -0.08390553f, -0.17325711f, 0.19448765f, 0.05407279f, 0.20930304f, -0.07416299f, 
    -0.07262547f, -0.00516380f, 0.02980499f, -0.10879489f, 0.14139378f, 0.22295848f, 0.11675723f, 0.16370985f, 
    0.23237737f, 0.00103726f, -0.02935873f, -0.10363530f, -0.06365518f, -0.00938966f, -0.01652042f, 0.15751405f, 
    0.01194525f, -0.11882443f, -0.00542464f, -0.17178078f, 0.11377354f, 0.06195081f, -0.04266131f, 0.12225944f, 
    -0.00685131f, 0.08001141f, 0.01416097f, -0.13550407f, -0.03752097f, -0.01147721f, 0.09702949f, 0.14271010f, 
    -0.14663315f, -0.13234690f, -0.01665387f, -0.53577024f, -0.01696927f, -0.11904006f, 0.05045363f, 0.04853495f, 
    -0.27631372f, -0.12885919f, -0.26832631f, -0.25798562f, 0.07295036f, -0.03078533f, -0.07799117f, -0.04435534f, 
    0.09609730f, 0.02273466f, 0.00725735f, 0.08205083f, -0.20336846f, 0.03708006f, -0.13111018f, -0.22066586f, 
    0.10392329f, -0.04625220f, -0.14634857f, 0.00832533f, 0.10909255f, -0.11313275f, 0.08086598f, 0.08471016f, 
    0.05464430f, -0.03160143f, -0.11094354f, 0.03987154f, 0.00285317f, 0.02874517f, -0.03782249f, 0.13731599f, 
    -0.00940207f, 0.09401263f, -0.00199295f, -0.12422244f, -0.06008645f, -0.09326077f, -0.17668518f, 0.14517842f, 
    0.18994074f, -0.25039050f, -0.09722240f, -0.00855016f, 0.03277204f, -0.05883253f, -0.01248633f, -0.39034989f, 
    0.02248402f, 0.01263556f, 0.00338361f, -0.05453434f, -0.10028522f, 0.07397889f, 0.10755265f, -0.03393635f, 
    -0.00910163f, -0.00154745f, 0.06863097f, -0.04502400f, -0.14107454f, 0.09245448f, -0.05424834f, 0.04126516f, 
    -0.28797281f, 0.07738447f, -0.02571176f, 0.36654118f, 0.09783828f, -0.05570903f, -0.02157532f, 0.14122842f, 
    -0.08997568f, 0.00600616f, -0.03133124f, 0.01447765f, 0.00354815f, -0.22776873f, 0.01778361f, -0.17101996f, 
    -0.10504864f, -0.05304006f, 0.06525171f, -0.21660642f, 0.22929308f, -0.13087687f, -0.10478795f, 0.03222977f, 
    0.08222163f, 0.09641367f, 0.04161001f, -0.01692967f, -0.00970175f, 0.03355954f, -0.04004142f, 0.02891726f, 
    0.01669325f, 0.00423983f, 0.11234992f, -0.01281577f, -0.28157994f, 0.04125497f, 0.18395987f, -0.02868777f, 
    0.01877479f, -0.03961057f, -0.08278990f, 0.17342424f, -0.17397988f, -0.24502197f, -0.13140510f, -0.48713824f, 
    -0.12993664f, -0.02081298f, -0.01861678f, 0.12443822f, 0.03578758f, 0.03376625f, 0.05649919f, 0.12834993f, 
    0.19607680f, 0.18123981f, 0.05802558f, 0.45349112f, 0.11358001f, -0.05975328f, -0.04339765f, -0.16647784f, 
    -0.01748230f, -0.14685108f, 0.04277025f, 0.03446783f, -0.13760757f, 0.03094824f, -0.15461744f, -0.05212285f, 
    0.10751489f, 0.25234321f, -0.08310524f, 0.03855988f, -0.01554370f, 0.06385971f, -0.04557213f, -0.09846542f, 
    -0.01126345f, 0.09690126f, -0.03139607f, -0.09395951f, 0.14822045f, 0.08758255f, 0.11686204f, -0.05585501f, 
    0.03289281f, -0.02472356f, 0.07837814f, 0.08862685f, -0.11024592f, 0.08052602f, -0.06673481f, -0.05477214f, 
    -0.05346381f, 0.05417596f, 0.08377871f, 0.18841018f, 0.02798542f, 0.03594280f, -0.03797426f, -0.15757354f, 
    0.03625324f, -0.04667543f, -0.18629584f, 0.02312865f, 0.14094318f, 0.22573225f, -0.16087025f, 0.18234110f, 
    0.03130533f, 0.00779853f, -0.00329767f, 0.03796040f, 0.00514201f, -0.05789081f, -0.12822916f, -0.10252128f, 
    -0.03092613f, -0.00392400f, 0.00210707f, -0.03274749f, 0.01988756f, 0.02835430f, -0.04030041f, 0.00111662f, 
    -0.00409359f, -0.01140021f, 0.00611878f, -0.03073541f, -0.03381019f, -0.03060925f, -0.00983925f, -0.03702219f, 
    0.01419752f, -0.00716845f, -0.03015831f, 0.01032582f, 0.02948152f, -0.00992202f, 0.01499625f, 0.00000137f, 
    0.01349864f, 0.02010019f, -0.03753082f, 0.00173841f, -0.02425228f, -0.01153033f, 0.02958163f, -0.00455773f, 
    -0.02761220f, -0.02464963f, -0.00634206f, -0.00972173f, -0.03766133f, 0.00970721f, -0.00086139f, 0.02384149f, 
    -0.00796271f, 0.00241212f, 0.01703211f, -0.00806667f, -0.00498688f, 0.00665254f, 0.00829187f, -0.04083874f, 
    -0.01093702f, 0.01180717f, 0.01030864f, -0.03947921f, 0.00152674f, 0.00786433f, 0.01791148f, 0.00916377f, 
    0.02382487f, 0.00274584f, -0.03334291f, -0.02379817f, 0.01229525f, -0.03481745f, -0.01550872f, -0.00899189f, 
    -0.01568656f, -0.02615602f, -0.01385364f, -0.00987802f, -0.01095340f, -0.00144104f, -0.03033803f, -0.01009654f, 
    0.02830139f, -0.01659408f, -0.02157626f, -0.01219990f, 0.00382541f, -0.02182502f, -0.01685532f, -0.03772748f, 
    -0.00710007f, -0.01710685f, -0.03742779f, -0.01143255f, -0.03147475f, 0.00795468f, -0.00780668f, -0.03857473f, 
    -0.03285851f, -0.01768885f, -0.01069727f, -0.03031550f, -0.02547941f, 0.01803788f, 0.00858470f, -0.02180810f, 
    -0.00438955f, -0.03652145f, -0.02976206f, 0.01850900f, -0.01676497f, -0.00466803f, 0.02385624f, -0.00853377f, 
    -0.00668833f, 0.01847485f, -0.02275290f, -0.00407510f, 0.01327871f, 0.02418282f, -0.01657227f, 0.02710756f, 
    -0.01818858f, -0.03384486f, 0.00026323f, -0.00663960f, 0.00854341f, 0.01278305f, 0.00405001f, -0.02977600f, 
    0.02242527f, -0.01186351f, 0.01092924f, 0.01819505f, 0.01644950f, -0.03320184f, -0.03935877f, -0.02385862f, 
    -0.01197634f, 0.01245818f, 0.01287368f, -0.00200610f, -0.00020973f, 0.00566658f, -0.00681924f, -0.03228827f, 
    -0.01234354f, -0.04104776f, 0.02715669f, -0.02033583f, 0.02131873f, -0.00506816f, -0.02030037f, -0.03437293f, 
    -0.00897877f, -0.02213917f, 0.00646276f, 0.00132124f, 0.00441506f, -0.03695721f, -0.00279476f, -0.01641689f, 
    0.01682905f, -0.00398696f, 0.02920241f, -0.02367494f, -0.00609525f, -0.00662034f, -0.01975309f, -0.02192212f, 
    0.00852329f, -0.00799031f, -0.01793415f, 0.00318648f, 0.01383522f, 0.02588369f, -0.01873027f, 0.00547150f, 
    0.01363254f, -0.02862101f, 0.01937726f, 0.00644342f, -0.03056524f, -0.01693647f, -0.01261123f, -0.04118213f, 
    -0.02626194f, -0.00957121f, 0.00548664f, 0.00763630f, -0.03854242f, -0.03812988f, -0.02075772f, -0.04110934f, 
    -0.02941698f, 0.02920583f, -0.03687832f, 0.02943714f, 0.00047194f, -0.00153797f, 0.01819852f, 0.02774484f, 
    -0.03745419f, -0.00222378f, -0.00564530f, -0.03637443f, -0.01506170f, 0.00137173f, 0.01611862f, 0.00735548f, 
    -0.03038696f, 0.00898341f, -0.01550558f, -0.00458408f, -0.02886963f, 0.02270498f, 0.00252837f, -0.03146696f, 
    0.00702689f, 0.01526992f, -0.03141049f, -0.01036965f, -0.03936799f, 0.00829571f, -0.01282613f, 0.00153585f, 
    -0.02509792f, -0.02962302f, -0.04119653f, -0.00136129f, -0.03969959f, 0.02535889f, -0.02191979f, 0.02738729f, 
    -0.01650524f, 0.01816027f, 0.00984804f, -0.04190678f, 0.02716690f, 0.01408675f, -0.03422372f, 0.01100501f, 
    0.01107088f, -0.02820798f, -0.00672927f, -0.03843580f, -0.03459517f, 0.01992915f, -0.00866611f, 0.01457010f, 
    0.00302460f, 0.00812898f, 0.00451694f, -0.03223990f, -0.00487997f, -0.03624384f, -0.00592796f, -0.01641082f, 
    -0.00887483f, 0.01687467f, 0.00682145f, -0.01132704f, -0.04046296f, -0.01519819f, -0.00540304f, 0.00445118f, 
    0.00809046f, 0.01304173f, -0.02252177f, -0.00513967f, -0.02904338f, -0.00754342f, 0.02031413f, 0.02200904f, 
    -0.00184751f, 0.02507188f, -0.02534380f, 0.01493089f, 0.00908197f, 0.00540760f, 0.01714030f, -0.02635913f, 
    -0.01031198f, -0.03270648f, 0.00529314f, -0.02988233f, 0.02321390f, 0.00881386f, 0.00969071f, 0.01419947f, 
    0.02856564f, -0.00817830f, 0.02058665f, -0.02579559f, -0.00992359f, 0.00536983f, 0.01743636f, -0.01910722f, 
    0.00572969f, -0.00073341f, -0.01932810f, -0.00928264f, -0.02699630f, -0.00441447f, 0.02544756f, 0.02173969f, 
    -0.01180855f, -0.03210922f, 0.01499989f, -0.00849755f, -0.02923461f, -0.01551131f, 0.02788127f, 0.00082589f, 
    -0.01254016f, -0.00170158f, -0.02710166f, 0.01271998f, 0.01523421f, -0.03707992f, -0.02713857f, 0.01690280f, 
    -0.04191579f, -0.00833316f, 0.00916129f, -0.03584546f, 0.00103642f, 0.02503689f, 0.01504048f, 0.02056915f, 
    0.00220345f, 0.01583139f, 0.00035072f, -0.03679439f, -0.02741440f, 0.01858238f, -0.01228903f, 0.00095597f, 
    -0.02645581f, 0.01049453f, 0.01969275f, 0.02925476f, -0.01740507f, -0.02579082f, 0.00759218f, -0.03270413f, 
    0.00976756f, -0.04139091f, -0.00444801f, 0.02791239f, 0.00614224f, 0.02553645f, 0.00271280f, -0.02280870f, 
    0.01997378f, -0.02218947f, 0.01351499f, -0.00596151f, -0.01070941f, -0.00360984f, -0.03537816f, -0.00704533f, 
    0.01795251f, -0.03006981f, -0.02685436f, 0.01275798f, 0.00524185f, -0.01003874f, -0.00546559f, 0.02772814f, 
    0.01956533f, -0.03847443f, 0.01024044f, 0.01662318f, -0.01645359f, -0.00002524f, -0.04123583f, 0.02603498f, 
    -0.01208565f, 0.02238003f, -0.02836371f, -0.01406712f, 0.02406096f, -0.01296459f, -0.00874593f, 0.00023145f, 
    0.00131087f, -0.01706547f, 0.02910144f, 0.02616686f, 0.01597423f, -0.02887318f, -0.00509332f, -0.02708010f, 
    -0.03094653f, -0.01429466f, 0.01984157f, 0.01687652f, 0.01427590f, -0.02891411f, -0.03101880f, -0.00141304f, 
    0.01010378f, -0.01853837f, -0.03548093f, 0.02034042f, 0.01542905f, 0.01576251f, 0.00189749f, -0.01697482f, 
    -0.01362108f, -0.02640595f, -0.00701775f, 0.00560103f, -0.03270406f, -0.01942500f, -0.01017431f, -0.01912485f, 
    0.00125351f, -0.03518424f, -0.02693379f, 0.02301072f, 0.02747606f, -0.04118959f, 0.00064271f, 0.00897958f, 
    0.01790354f, 0.02001191f, -0.03474383f, -0.02969460f, -0.03127253f, -0.03697194f, 0.02197726f, -0.00337052f, 
    -0.03680866f, -0.01659358f, -0.00263095f, 0.02826678f, 0.02050142f, 0.02504305f, -0.01082716f, 0.00144436f, 
    0.02382259f, 0.00992719f, 0.02333874f, -0.02144130f, -0.01856491f, -0.01629102f, -0.00970434f, -0.02951018f, 
    -0.01260565f, 0.02359422f, 0.00152793f, -0.04136873f, 0.00321078f, -0.03917868f, 0.00994847f, -0.00907343f, 
    0.01201665f, -0.01992767f, 0.02802293f, -0.00763570f, 0.02603741f, -0.02267297f, 0.00947931f, 0.02243186f, 
    0.02576805f, -0.02641296f, 0.02507367f, -0.00877515f, -0.01389160f, 0.00183434f, 0.01158509f, -0.02337852f, 
    0.00141837f, -0.03523828f, 0.00262795f, -0.01190461f, -0.00634568f, -0.00629396f, 0.00669498f, 0.00395670f, 
    -0.02819585f, -0.03135628f, -0.03971400f, 0.01170098f, -0.04053108f, -0.02562811f, -0.00954098f, 0.01218530f, 
    -0.02639169f, -0.03083911f, -0.03874446f, 0.00652432f, -0.03024757f, 0.00698359f, -0.02320527f, 0.01093818f, 
    -0.03078516f, -0.03064953f, 0.01338356f, -0.02718172f, -0.01015072f, 0.02964927f, -0.02427435f, 0.02845837f, 
    0.00465273f, 0.02790379f, 0.01822565f, -0.03749304f, -0.00403502f, 0.02677324f, 0.01597285f, 0.00082060f, 
    -0.00950344f, -0.01575929f, 0.00444576f, -0.00725551f, -0.02437910f, -0.03875643f, -0.02267840f, -0.03585905f, 
    0.00274873f, -0.03392589f, -0.01561957f, 0.00463156f, -0.00264761f, -0.02796014f, -0.03718570f, -0.00155034f, 
    -0.02454526f, 0.02671888f, -0.03356139f, 0.00633523f, -0.01640673f, 0.01561073f, 0.01934510f, -0.03613587f, 
    0.01962399f, 0.01054103f, 0.02398751f, 0.02742724f, 0.00615240f, 0.00893862f, -0.02501322f, -0.00084876f, 
    -0.03895855f, 0.00167798f, -0.00168836f, -0.00517118f, 0.01809466f, 0.02954268f, 0.01728481f, -0.01554920f, 
    -0.01583615f, -0.00900813f, -0.01050502f, -0.00357382f, 0.02875721f, 0.02405682f, 0.02863948f, -0.01361633f, 
    -0.03759584f, -0.03486850f, 0.01001576f, 0.00969850f, -0.02989382f, 0.00801360f, -0.03897966f, -0.02610134f, 
    -0.03308028f, -0.01613371f, -0.02961908f, -0.01626119f, 0.02355933f, -0.03675652f, -0.01081304f, -0.04002688f, 
    0.01692917f, -0.02125136f, 0.00225486f, -0.02133285f, -0.02550395f, -0.00119971f, -0.01333253f, -0.03461954f, 
    -0.03813662f, -0.01533413f, 0.00310298f, -0.01249459f, -0.01834207f, -0.03296722f, -0.03219324f, -0.01144644f, 
    0.01794180f, -0.03203449f, -0.03116401f, -0.03766925f, 0.00087859f, -0.01943144f, -0.03032662f, -0.02707352f, 
    -0.00104959f, 0.02082540f, 0.01178617f, -0.03958884f, -0.03995749f, 0.00087843f, -0.01371328f, -0.03315855f, 
    0.00085264f, 0.01590475f, 0.00564339f, -0.01135171f, 0.01643239f, -0.01371745f, -0.03809652f, -0.00368375f, 
    0.01398720f, -0.03901988f, -0.03806085f, 0.01889677f, 0.00825934f, 0.01482766f, -0.02716070f, -0.03978295f, 
    -0.00643549f, -0.00881846f, -0.00659241f, 0.01581651f, -0.01182885f, -0.02641835f, -0.00391303f, 0.02999794f, 
    0.00766636f, 0.01892996f, 0.02706851f, 0.00237151f, -0.00195839f, 0.01987410f, -0.02806149f, -0.03661081f, 
    -0.00321762f, -0.03248818f, 0.02502073f, -0.02338287f, 0.00162771f, -0.01067322f, -0.00560878f, 0.00516791f, 
    -0.03015211f, -0.00163973f, -0.01273768f, 0.00107598f, 0.02590999f, 0.02961406f, 0.01406067f, -0.00770053f, 
    -0.00152768f, -0.02092408f, 0.02303082f, -0.03065370f, -0.02026602f, -0.01141765f, -0.03786703f, 0.02998277f, 
    0.00105997f, 0.01652233f, -0.00033642f, -0.00898275f, 0.01807440f, 0.02229962f, -0.00410226f, -0.03850466f, 
    -0.01427411f, -0.01224749f, -0.02990967f, -0.00059216f, -0.00270269f, -0.02468377f, -0.00643462f, 0.00796802f, 
    -0.02975941f, -0.04025861f, 0.01493024f, -0.01549076f, -0.02299473f, 0.02426765f, -0.03862042f, 0.02259251f, 
    0.00875127f, 0.01999826f, -0.01513123f, -0.00449212f, -0.00427150f, -0.03869740f, 0.00175105f, -0.02226346f, 
    -0.03871089f, 0.02389329f, 0.02607945f, -0.04058278f, 0.01996773f, -0.02558321f, 0.01008113f, 0.00160890f, 
    0.01122531f, -0.03112291f, -0.00975213f, -0.01344195f, -0.03674094f, 0.01415559f, -0.02031616f, -0.03760680f, 
    0.02165216f, -0.02584182f, -0.01863052f, -0.02400289f, 0.00415089f, -0.01943602f, -0.03476733f, 0.00652897f, 
    0.00459128f, -0.03634055f, 0.02765695f, 0.00031188f, -0.01182798f, -0.02149251f, -0.04201528f, -0.03657628f, 
    -0.00876514f, 0.01001326f, -0.00674015f, -0.03963116f, 0.02528594f, 0.02516991f, -0.00515257f, -0.00960232f, 
    -0.03394134f, 0.01839800f, 0.01775395f, -0.01794799f, 0.01571673f, -0.03928265f, 0.00679548f, 0.00385704f, 
    -0.00806265f, -0.02033461f, 0.01288848f, -0.01087394f, 0.00105258f, 0.02116163f, 0.01586907f, -0.03987527f, 
    -0.02003797f, 0.02857663f, 0.01545329f, -0.03188616f, -0.03968504f, -0.02046357f, 0.01657128f, 0.00113719f, 
    -0.03002727f, 0.00258124f, 0.00119986f, -0.02373212f, 0.01237220f, -0.01417190f, -0.01407671f, 0.00209199f, 
    -0.02939694f, -0.03975011f, -0.00321433f, 0.01356281f, -0.00096912f, -0.00979208f, 0.02297730f, -0.02470145f, 
    0.01093890f, 0.02133120f, -0.03578573f, 0.01928090f, 0.01980323f, -0.02855079f, -0.02084934f, -0.03869384f, 
    -0.02332612f, -0.03143245f, 0.02003229f, 0.02720526f, 0.00318450f, 0.00396368f, -0.03487402f, -0.02754425f, 
    0.01869327f, 0.02271849f, 0.01265016f, 0.01115205f, 0.00993126f, 0.02613976f, -0.04093841f, -0.02684792f, 
    -0.00580063f, -0.02110497f, -0.01040513f, -0.01368461f, -0.02112044f, 0.01130828f, 0.01436218f, 0.00774102f, 
    -0.00167937f, -0.02351451f, -0.03736315f, -0.01709739f, -0.03084292f, -0.02649283f, 0.00897052f, -0.04196800f, 
    0.02176779f, 0.01240495f, 0.02972215f, 0.02844126f, 0.01774095f, -0.01927081f, -0.00659929f, 0.01541271f, 
    0.01742734f, -0.01108867f, 0.02129165f, 0.02051244f, -0.00715437f, -0.00433731f, 0.02994157f, 0.02986993f, 
    -0.00696906f, -0.00989253f, -0.00833553f, 0.00423753f, -0.02803746f, 0.02912384f, -0.03517977f, 0.00486000f, 
    -0.01590066f, -0.01413030f, -0.02811534f, -0.00219197f, -0.03260588f, 0.01513038f, -0.01031933f, -0.00994651f, 
    0.02776171f, 0.01078085f, -0.03492771f, 0.00684041f, -0.03639971f, 0.00371688f, -0.00757398f, -0.03532487f, 
    0.01550441f, -0.01897242f, -0.01882152f, -0.00868289f, -0.01098176f, -0.01877117f, 0.02906349f, 0.01091513f, 
    0.01873257f, 0.02570764f, 0.01118905f, 0.00073028f, -0.01290844f, -0.00336350f, 0.02708264f, 0.00570815f, 
    0.01178471f, -0.02571404f, -0.02760474f, -0.01845788f, -0.01220572f, 0.02266643f, -0.02408888f, -0.03860276f, 
    -0.02493097f, 0.01103604f, -0.00093379f, -0.02196676f, 0.01269854f, -0.00623263f, 0.00019484f, -0.04004368f, 
    -0.03058035f, 0.02430443f, -0.01007123f, -0.02609536f, 0.00679211f, 0.01270337f, 0.02021455f, -0.02079666f, 
    -0.00825165f, -0.00418127f, 0.02926725f, 0.02592042f, 0.01193325f, 0.00963804f, -0.03111675f, -0.00596322f, 
    0.02493800f, -0.01137584f, 0.01483027f, -0.02422702f, 0.00510045f, -0.01266194f, 0.02706172f, 0.01022528f, 
    -0.03901725f, -0.02442761f, -0.02749441f, -0.00305745f, 0.00300376f, -0.02507870f, 0.02840084f, -0.01970341f, 
    0.00675312f, -0.01898850f, -0.02907711f, 0.01202808f, -0.01255971f, 0.02948230f, -0.03526380f, 0.02501826f, 
    -0.01520029f, -0.03954302f, 0.01208349f, -0.01663308f, 0.02125602f, -0.03342089f, 0.00694099f, -0.00910816f, 
    -0.01952130f, -0.01091126f, -0.02281075f, 0.01036128f, -0.01600598f, -0.02481725f, 0.01384275f, 0.00681205f, 
    -0.00040985f, 0.02609460f, -0.02557481f, 0.02086116f, 0.01067971f, 0.00826166f, 0.00825494f, -0.02387128f, 
    -0.03624098f, 0.02426139f, -0.02972538f, -0.02927941f, 0.01494247f, -0.02562832f, -0.00716359f, 0.01420840f, 
    -0.01913165f, -0.00584759f, -0.03867162f, -0.03314057f, -0.02789258f, 0.00215691f, -0.00927555f, -0.00767512f, 
    -0.03403398f, 0.00670204f, -0.01136523f, -0.01202080f, 0.01370744f, -0.02592876f, 0.02927878f, 0.00115326f, 
    0.00488736f, -0.03358518f, 0.00713701f, -0.01132369f, 0.00841150f, -0.00244260f, -0.02327721f, -0.00225987f, 
    -0.02053736f, 0.02155424f, -0.00516669f, 0.02733511f, -0.00023738f, 0.01670157f, -0.01704591f, 0.02664830f, 
    -0.00538762f, 0.01252249f, -0.02429590f, -0.01162440f, -0.04104526f, 0.02204918f, 0.02021338f, 0.00551740f, 
    0.02824910f, 0.01705203f, -0.01959641f, 0.02467827f, 0.02614442f, 0.00686574f, -0.03848455f, -0.01616371f, 
    0.01636669f, -0.00228227f, 0.02341610f, 0.00603761f, -0.01712257f, -0.00454320f, 0.02996946f, -0.02886797f, 
    0.02164511f, 0.01812888f, -0.00196522f, 0.03002184f, -0.02703828f, -0.00709839f, -0.03212614f, -0.00015866f, 
    -0.02398515f, -0.02505945f, 0.01281441f, -0.02019212f, 0.02850247f, 0.02039319f, 0.02487496f, -0.00553563f, 
    -0.00380842f, -0.01195937f, -0.01494699f, -0.03688177f, -0.01257314f, 0.02067831f, 0.00432721f, 0.00176259f, 
    -0.02264957f, -0.01460229f, -0.02867580f, -0.01307761f, -0.02481924f, -0.03148114f, -0.01758790f, -0.00230619f, 
    -0.02163759f, -0.01746991f, -0.03017683f, -0.03967507f, -0.00972946f, -0.04179621f, -0.03477493f, -0.01772570f, 
    -0.01928814f, -0.00868182f, -0.02919300f, -0.03884422f, -0.03545922f, -0.03823548f, -0.01183966f, -0.02538888f, 
    -0.01142134f, -0.02222747f, -0.00449141f, -0.03315799f, 0.02681968f, 0.02240705f, -0.01113238f, 0.02993971f, 
    0.00687858f, -0.03508206f, -0.02656689f, 0.02018506f, -0.00389058f, 0.01215857f, 0.00696946f, -0.00141034f, 
    -0.03019283f, -0.00992684f, -0.01944431f, 0.01484276f, 0.00660128f, 0.00414455f, -0.03852069f, 0.02423903f, 
    -0.01989314f, -0.01564481f, -0.03708690f, -0.00060341f, -0.01227108f, -0.00973948f, 0.00988062f, 0.01261705f, 
    -0.02205798f, -0.02686633f, -0.00494684f, -0.00807235f, -0.01862571f, -0.03309427f, -0.00058119f, 0.02773132f, 
    0.00683141f, -0.03391740f, 0.00620855f, -0.00387846f, 0.02820977f, -0.04137625f, 0.01277335f, -0.01496213f, 
    -0.01794028f, -0.01279155f, 0.02365212f, 0.01210690f, -0.01904589f, -0.03560396f, -0.04133837f, -0.01111206f, 
    0.01417626f, 0.00331803f, -0.03965024f, 0.01733178f, -0.00207251f, -0.01548977f, -0.01466624f, -0.01224765f, 
    -0.02436760f, -0.01524523f, -0.02558447f, -0.02044315f, 0.01262282f, -0.01257409f, -0.02693868f, -0.01820943f, 
    -0.01820509f, 0.00652646f, 0.00587379f, 0.02596688f, -0.00535121f, 0.01904672f, 0.02545192f, 0.00836511f, 
    -0.00926225f, -0.01819478f, -0.00228944f, -0.01704119f, -0.03820125f, -0.04181721f, 0.00051861f, -0.03801924f, 
    0.02997572f, -0.00751420f, 0.00909752f, -0.01994739f, -0.00962389f, 0.00178620f, 0.00739718f, 0.00386794f, 
    0.01241118f, -0.01523019f, -0.03255802f, -0.02711392f, -0.02794926f, 0.00810984f, -0.01503153f, 0.00477180f, 
    -0.00243478f, -0.02560556f, -0.00421629f, -0.02640236f, -0.01042417f, 0.00999986f, 0.01189180f, -0.03388630f, 
    -0.00157660f, -0.00814542f, -0.00718431f, 0.00525736f, 0.00571360f, -0.01065909f, -0.02250510f, -0.02104261f, 
    -0.04189903f, 0.02067425f, -0.03032411f, 0.02911275f, -0.04181483f, -0.00066376f, 0.01241192f, -0.02552606f, 
    -0.01403720f, -0.02709728f, 0.02959125f, 0.00106910f, -0.00549334f, -0.03108736f, -0.03357629f, 0.02722344f, 
    0.00384748f, 0.02651122f, 0.00508991f, 0.01064345f, -0.00796921f, -0.03571122f, -0.03532683f, 0.00828809f, 
    0.00258272f, -0.02333001f, 0.02814605f, -0.00569558f, 0.02507081f, 0.00238809f, 0.02151508f, 0.01644381f, 
    -0.04104836f, 0.00151397f, 0.01609217f, -0.01269656f, 0.00290643f, 0.02141349f, 0.01111919f, 0.01499158f, 
    0.00075626f, -0.00694201f, -0.01172484f, -0.03193559f, -0.00041077f, 0.00824980f, 0.02241456f, -0.03172002f, 
    -0.02675553f, -0.00998141f, 0.02557925f, -0.03664432f, 0.02785929f, 0.00349485f, 0.00310987f, -0.01136288f, 
    -0.02266526f, -0.02386753f, -0.03833510f, 0.00061818f, -0.01016060f, 0.00415450f, -0.03310882f, 0.01019027f, 
    0.02690088f, 0.02624254f, 0.02412281f, -0.02492919f, 0.02011806f, -0.03335790f, -0.04026740f, 0.01108037f, 
    0.01578194f, 0.02947202f, -0.01945518f, 0.00560784f, -0.01723469f, 0.01847742f, 0.01458793f, -0.02475954f, 
    0.01866032f, 0.02805516f, 0.00359321f, -0.02540920f, 0.01065673f, -0.01549297f, -0.03179654f, -0.03140818f, 
    -0.02143169f, -0.00239277f, -0.00578367f, -0.00687698f, 0.02520871f, 0.00562366f, -0.00511487f, -0.03356349f, 
    0.00646923f, 0.01938637f, -0.02092714f, -0.02653455f, -0.03652958f, -0.03965222f, 0.01894730f, 0.02364901f, 
    -0.04194708f, -0.01204888f, -0.03287305f, -0.01014816f, -0.01841488f, -0.02545195f, -0.00498784f, 0.01773332f, 
    -0.03422399f, -0.02947873f, 0.01902990f, 0.00772166f, 0.00657890f, -0.04180062f, 0.01215820f, -0.04167533f, 
    0.01830089f, 0.02490821f, 0.00135216f, 0.00579322f, -0.02192724f, 0.01401206f, -0.02105181f, 0.01821706f, 
    -0.03558886f, 0.02765390f, -0.02068573f, 0.01560102f, -0.00717825f, -0.03755898f, -0.02662375f, -0.04038581f, 
    -0.04146606f, -0.00283911f, -0.02697502f, 0.01964298f, 0.02487594f, -0.00272970f, -0.02408599f, 0.00151090f, 
    0.02951875f, 0.01274564f, -0.00706621f, -0.03871026f, -0.00200661f, -0.02170221f, -0.04026734f, -0.00637125f, 
    0.01395481f, 0.00336136f, -0.04069354f, -0.00850600f, -0.01565051f, -0.02279538f, -0.00610176f, -0.03525134f, 
    -0.03709736f, -0.04007628f, 0.01196974f, -0.03089258f, -0.00529608f, -0.03356801f, 0.02956692f, 0.02736053f, 
    -0.03332661f, 0.00878285f, -0.02918239f, -0.02244050f, 0.01199618f, -0.03585661f, 0.02018662f, -0.03057096f, 
    -0.03756394f, 0.01605818f, -0.00030399f, -0.04001919f, 0.00742105f, 0.02098472f, -0.00612085f, 0.00697310f, 
    0.02930274f, -0.02064558f, 0.02411231f, -0.00262868f, -0.03423047f, -0.01767901f, 0.02462603f, 0.02924364f, 
    -0.01179016f, -0.01497426f, 0.00724456f, 0.02966745f, 0.00624023f, 0.02346178f, -0.01682157f, -0.02544543f, 
    -0.03925340f, -0.03252660f, 0.00190385f, 0.01926015f, -0.00945441f, -0.01404089f, -0.03731842f, 0.00300303f, 
    0.01847928f, -0.01626302f, 0.00347064f, -0.00820198f, -0.01004771f, -0.03616207f, -0.02187680f, -0.03757353f, 
    -0.02741117f, -0.03403749f, 0.00705629f, -0.01964202f, 0.01141449f, -0.00296325f, -0.03138452f, 0.01042968f, 
    0.01102125f, 0.03006074f, -0.03460886f, -0.00663176f, -0.01784302f, -0.04102492f, 0.00012993f, -0.03008701f, 
    0.00748700f, 0.00265705f, -0.01639953f, -0.02349316f, -0.01877563f, -0.01454528f, -0.02241723f, -0.02387954f, 
    0.01763705f, -0.00190917f, -0.02931410f, -0.02286131f, -0.02293999f, -0.01151087f, 0.02983555f, -0.03689170f, 
    -0.03512058f, -0.03512936f, 0.01430108f, -0.03552582f, -0.02180441f, 0.01854143f, 0.01330946f, 0.01525029f, 
    -0.02903069f, -0.02141858f, 0.00601818f, 0.00712630f, 0.00706060f, -0.00998745f, -0.00246304f, 0.00733895f, 
    0.01229621f, -0.03137764f, -0.00350040f, -0.02327012f, -0.02306530f, 0.00135243f, 0.00149811f, -0.02978137f, 
    0.01998160f, -0.02781662f, -0.00405589f, -0.03253689f, -0.01854331f, 0.00237681f, -0.00771248f, 0.00741915f, 
    -0.00625936f, 0.01924159f, -0.01441843f, 0.00461125f, -0.00933835f, -0.01526041f, 0.02582491f, -0.01860882f, 
    -0.03331656f, 0.00794676f, -0.01684762f, 0.02389988f, -0.01126476f, -0.00604940f, 0.02309553f, 0.00476049f, 
    0.01551586f, 0.02918614f, 0.00827588f, -0.03323643f, -0.04001220f, -0.03501123f, -0.03116817f, -0.03570829f, 
    -0.01985246f, -0.00856870f, -0.00591729f, -0.00688092f, -0.02582669f, -0.03232111f, 0.00420422f, 0.02132278f, 
    -0.02386471f, 0.00452087f, -0.00010213f, 0.02614696f, -0.02488123f, -0.03633942f, -0.02838959f, -0.03380508f, 
    -0.00041086f, -0.02525206f, -0.02978745f, -0.03659725f, -0.03548339f, 0.00811553f, 0.00474095f, -0.01834011f, 
    0.02739834f, -0.02237776f, -0.04008058f, 0.00689986f, -0.00587269f, -0.01674601f, -0.04039529f, 0.01736054f, 
    -0.01243831f, -0.02490620f, 0.01860415f, 0.01189254f, -0.00817484f, -0.00144108f, -0.00375167f, -0.03862141f, 
    -0.01753638f, -0.02017098f, -0.01785409f, 0.01943792f, 0.01238834f, -0.02874546f, 0.01052962f, 0.00580896f, 
    -0.01998277f, 0.00261550f, 0.02285244f, -0.02504911f, -0.02822843f, -0.01642251f, 0.00189869f, 0.00323060f, 
    0.13499869f, 0.20696814f, 0.05909785f, -0.15915447f, 0.06406126f, 0.07848018f, 0.02519538f, 0.03828678f, 
    0.01678966f, -0.09135240f, -0.06329715f, -0.04434678f, -0.11010198f, 0.07508504f, -0.10088420f, -0.11762848f, 
    0.15446725f, -0.03763761f, -0.03639149f, 0.04848190f, -0.10938362f, 0.07836553f, -0.04836302f, -0.11074328f, 
    -0.19290622f, -0.05188821f, -0.33040506f, 0.19608764f, -0.08310124f, 0.01911311f, -0.02706002f, 0.08151483f, 
    0.09457445f, -0.01800093f, 0.07084849f, -0.00537639f, 0.33104643f, -0.08666725f, 0.06354775f, -0.13311478f, 
    -0.03407282f, 0.00699504f, 0.08817516f, 0.05750827f, -0.00531418f, 0.06694504f, 0.02064780f, -0.02310293f, 
    -0.01704538f, -0.02255947f, 0.06381444f, -0.08140179f, -0.02867753f, 0.01247733f, 0.00447587f, 0.00911286f, 
    0.02928375f, -0.05922157f, 0.14381695f, 0.12588866f, 0.13427442f, -0.30243084f, 0.13816518f, 0.01504290f, 
    0.04612270f, -0.07265335f, -0.02751632f, 0.09018952f, -0.09054462f, 0.00670412f, 0.09246057f, -0.03711764f, 
    0.32405972f, 0.24567117f, 0.14951959f, 0.10253687f, -0.05468619f, 0.11075501f, 0.05658059f, 0.02909403f, 
    -0.09244687f, 0.00352647f, -0.06316525f, 0.10480121f, 0.22879171f, 0.20288609f, 0.00940656f, -0.20749648f, 
    0.08644015f, -0.02237211f, 0.28781772f, 0.10813466f, -0.07462040f, 0.04982945f, -0.07657788f, 0.00554371f, 
    0.28723529f, 0.26327291f, -0.10913797f, -0.17249042f, 0.00570277f, 0.00281497f, -0.04260994f, -0.04921453f, 
    0.02943582f, -0.04863042f, 0.12156886f, 0.10705091f, -0.07143454f, -0.13863854f, 0.04413051f, -0.01819373f, 
    -0.09166435f, -0.02626509f, -0.00885339f, -0.07496230f, -0.21085340f, -0.13916732f, 0.10969508f, 0.08102431f, 
    0.07448769f, 0.09221909f, -0.00526760f, -0.02921643f, 0.11359611f, 0.04625325f, -0.06963871f, -0.08101447f, 
    -0.07850584f, 0.02389786f, -0.12393727f, -0.05575974f, 0.05816457f, -0.00825515f, -0.02109786f, -0.03200067f, 
    -0.06116742f, -0.00767837f, -0.00357437f, 0.02791619f, -0.07302646f, 0.01999910f, 0.05063779f, 0.01338538f, 
    0.06329100f, 0.05296849f, 0.07688125f, -0.10253503f, 0.01320610f, 0.06549898f, 0.02376646f, -0.04027782f, 
    -0.08179723f, -0.02451524f, -0.10577828f, -0.04613437f, -0.04715310f, 0.14720076f, -0.23908353f, -0.06412774f, 
    -0.04675658f, -0.01391655f, -0.04385939f, 0.10331704f, 0.06910340f, -0.03454656f, -0.05324777f, -0.06288119f, 
    0.16370068f, 0.16551316f, -0.07547206f, -0.07656075f, 0.04989438f, 0.22088587f, -0.02787784f, 0.00346280f, 
    0.09775975f, -0.08284611f, -0.09483413f, 0.01590369f, -0.07483814f, -0.05109541f, 0.02409184f, 0.18263124f, 
    -0.12468324f, -0.13946664f, -0.00005727f, -0.10493100f, -0.03839057f, 0.07140397f, 0.10477958f, 0.24060448f, 
    -0.03394185f, -0.10406730f, -0.00340281f, -0.00553428f, 0.16155723f, -0.04141297f, -0.00438657f, 0.06490387f, 
    -0.03100710f, -0.02509809f, 0.10140780f, 0.07341520f, -0.17077070f, 0.00277823f, -0.07789037f, -0.09610865f, 
    -0.04448610f, 0.06562106f, 0.00904420f, -0.04232999f, 0.01616072f, 0.02655722f, 0.15557919f, -0.07065496f, 
    0.28618911f, -0.10063736f, 0.06904265f, 0.17332935f, -0.00823350f, 0.08444989f, 0.00547462f, -0.03597970f, 
    0.06415913f, -0.04712415f, -0.03835652f, 0.03954550f, -0.17722484f, 0.25173229f, 0.08553596f, -0.04378623f, 
    0.03069047f, 0.00275674f, -0.02562221f, -0.05756070f, 0.05312764f, 0.04960328f, 0.03874702f, -0.00113550f, 
    0.29386458f, -0.13982674f, 0.13481177f, -0.02861591f, -0.03174114f, 0.10876445f, -0.03774361f, 0.07985092f, 
    -0.00042581f, 0.00533012f, 0.00170294f, 0.19260773f, 0.02177230f, 0.08356961f, -0.07245523f, 0.00398533f, 
    0.03214238f, -0.01090106f, -0.03273929f, 0.04224893f, -0.04642184f, -0.00918279f, -0.02583136f, -0.15599835f, 
    -0.09400929f, 0.14962368f, -0.12079310f, 0.03500649f, -0.05089852f, 0.18047993f, 0.15457323f, -0.05437436f, 
    -0.01937162f, -0.02167608f, 0.00319442f, -0.01738882f, 0.13205366f, 0.02124001f, 0.03032924f, 0.02971175f, 
    0.15596032f, -0.08340716f, -0.01548136f, -0.07771496f, -0.11629612f, 0.13805504f, 0.10328013f, 0.03812216f, 
    -0.10485011f, 0.03747543f, 0.19007234f, -0.01456057f, -0.00225854f, -0.09272509f, -0.02235611f, 0.01311458f, 
    0.10288993f, -0.12447896f, 0.09694211f, -0.05066141f, -0.15781914f, 0.21281545f, 0.04072636f, 0.03324801f, 
    0.00708023f, -0.07025982f, -0.07311349f, 0.03379941f, -0.12575157f, -0.04916317f, -0.09165952f, -0.00840266f, 
    -0.02499321f, -0.12385444f, -0.09244097f, 0.01538867f, -0.13047422f, 0.06503537f, -0.01645607f, 0.12132689f, 
    -0.06234252f, -0.02735940f, -0.02414186f, -0.09078676f, 0.15122467f, 0.10026320f, -0.00299644f, -0.02932722f, 
    -0.09560665f, 0.07036614f, -0.05888173f, 0.03186484f, 0.12548104f, -0.02943326f, -0.02987524f, -0.01186169f, 
    0.16226904f, 0.01033798f, -0.07315277f, -0.00693906f, 0.20990123f, -0.00131805f, 0.03020940f, -0.03676094f, 
    -0.19529200f, -0.07896574f, -0.07146203f, 0.05041225f, 0.18220581f, 0.10960214f, -0.08010751f, 0.14195856f, 
    0.00071551f, 0.06647396f, 0.05885928f, 0.09232700f, -0.12732491f, -0.06865149f, 0.07920719f, 0.00359289f, 
    0.35069299f, 0.10072739f, -0.04758468f, -0.09506638f, 0.12755296f, 0.05246946f, -0.12317850f, -0.12724650f, 
    -0.01733630f, -0.02694369f, -0.02091196f, -0.04793822f, 0.32051769f, 0.09527157f, -0.16795512f, -0.10653402f, 
    0.28273669f, 0.06717402f, 0.08443369f, 0.09565438f, -0.08074813f, 0.14861786f, -0.01216185f, 0.14440897f, 
    -0.03492747f, -0.11972380f, -0.35035229f, 0.20278937f, -0.01120257f, -0.09506951f, 0.03991985f, 0.16767594f, 
    -0.06762270f, 0.01627400f, 0.09688331f, 0.05384887f, 0.05995269f, -0.05115632f, 0.21963516f, 0.06123162f, 
    -0.01153527f, -0.00855814f, -0.05172544f, -0.05575525f, 0.01317267f, -0.04525071f, 0.02038639f, -0.04511036f, 
    -0.03929187f, 0.14944054f, -0.07072718f, 0.00588408f, 0.01650008f, 0.04385100f, -0.07687151f, 0.10081524f, 
    -0.10902024f, -0.06543346f, -0.01803121f, -0.01505831f, 0.19097261f, -0.09508622f, 0.17761824f, 0.02799291f, 
    -0.05582107f, -0.06650567f, -0.04514017f, 0.05518814f, 0.04877443f, -0.05807024f, -0.13472071f, 0.01983751f, 
    0.25827673f, 0.00151511f, -0.10651007f, -0.11802309f, 0.13433543f, 0.10830350f, 0.16577782f, 0.19748524f, 
    -0.01853160f, -0.07922925f, -0.10108376f, 0.01325409f, 0.01173069f, 0.11024204f, 0.19618121f, 0.22434425f, 
    -0.03655168f, 0.14504279f, 0.12892823f, -0.10109621f, -0.05979254f, -0.07403581f, -0.00013967f, 0.15892226f, 
    0.05283611f, 0.03253424f, 0.01232441f, -0.06310439f, -0.06263939f, 0.14689474f, 0.01622993f, -0.02200053f, 
    -0.12407722f, -0.05632148f, 0.03215453f, -0.09800000f, -0.07364517f, 0.16462956f, -0.07474109f, -0.02604574f, 
    0.00178003f, 0.05521905f, 0.11668558f, -0.00103226f, 0.00639513f, -0.04378917f, -0.11391950f, -0.11839072f, 
    -0.00541368f, -0.08159547f, -0.15455975f, 0.29517314f, -0.09364851f, -0.04073884f, -0.00184761f, 0.02483670f, 
    0.01477049f, -0.06212405f, 0.03091619f, -0.14938003f, -0.16981462f, 0.10805901f, -0.03835718f, -0.02620766f, 
    -0.00740382f, -0.01770759f, 0.05900130f, 0.02163386f, 0.01333125f, -0.02709095f, -0.07395456f, 0.01565382f, 
    0.18522775f, -0.01672537f, 0.25774732f, 0.08345327f, -0.00241152f, -0.00345028f, 0.01762679f, 0.06738450f, 
    -0.07437935f, -0.02740659f, 0.02586990f, 0.08084818f, -0.40234494f, 0.18043214f, -0.36955273f, 0.23516978f, 
    -0.04833670f, 0.03297117f, 0.00203560f, 0.09813528f, 0.15301202f, -0.05334097f, 0.07238482f, -0.07359361f, 
    0.23652306f, 0.08549824f, 0.31092516f, 0.04473701f, 0.12422056f, 0.03970205f, 0.00903838f, 0.01747120f, 
    0.06164643f, 0.01988989f, 0.05424843f, 0.08674926f, -0.12741776f, 0.07661232f, -0.09780478f, -0.12735409f, 
    0.07525738f, -0.02305217f, 0.00337192f, -0.06277587f, 0.12386940f, 0.05068103f, 0.03398520f, 0.02452336f, 
    0.10716037f, 0.03480943f, -0.23451340f, 0.00803977f, 0.09652025f, 0.11933634f, 0.06878302f, 0.02017249f, 
    -0.00650032f, 0.04040340f, -0.01682862f, -0.02881953f, 0.06432192f, 0.09590285f, -0.00116831f, -0.06272487f, 
    0.17174736f, 0.08228879f, 0.10808097f, 0.17838606f, 0.02382627f, 0.00709670f, -0.16012321f, 0.04295817f, 
    -0.30087811f, -0.00077026f, 0.01970137f, 0.21922113f, 0.04868256f, -0.00350434f, 0.05256455f, -0.05864735f, 
    0.02006722f, 0.01592775f, 0.11304680f, 0.01124283f, -0.00535557f, 0.08841838f, 0.11116470f, 0.11862456f, 
    -0.00948789f, 0.10616007f, 0.05166480f, -0.06713545f, -0.04484229f, -0.06537639f, 0.06865937f, 0.03597805f, 
    0.16023768f, 0.36297101f, -0.14934534f, 0.00585551f, -0.03797011f, 0.08104987f, 0.14344411f, -0.03122392f, 
    -0.05789221f, 0.05770936f, -0.00258927f, -0.02862609f, -0.25088340f, 0.02640751f, -0.08454887f, 0.04920256f, 
    0.07649159f, -0.00601118f, -0.01938157f, 0.17540576f, -0.05016296f, 0.06686331f, 0.16621915f, 0.01594162f, 
    -0.15293527f, 0.49022222f, -0.08288512f, 0.03113573f, -0.00791995f, -0.00130143f, -0.05359986f, 0.01319076f, 
    0.18137217f, 0.06345683f, 0.07618751f, 0.07824962f, 0.05222077f, -0.18184003f, 0.23787303f, -0.07016604f, 
    0.00600494f, 0.07766587f, 0.01704090f, 0.08835643f, -0.05436307f, 0.02535902f, -0.08643851f, 0.12830187f, 
    -0.09466131f, 0.00074189f, -0.21523660f, 0.26647574f, -0.05084528f, 0.02780421f, -0.11585856f, -0.11238165f, 
    0.04871155f, -0.15076531f, -0.02881329f, 0.02446729f, -0.12908562f, -0.01165226f, -0.14041632f, 0.17237577f, 
    -0.07876182f, -0.06143980f, 0.01218302f, 0.13420656f, -0.01453672f, 0.11658657f, 0.15890285f, -0.09861606f, 
    -0.02824349f, 0.10324610f, -0.01614760f, -0.09937430f, 0.06951701f, 0.08907352f, 0.01571160f, -0.04841176f, 
    0.02178946f, 0.01697520f, -0.13077782f, -0.05115967f, -0.03723021f, -0.14992864f, -0.08398886f, 0.11258426f, 
    -0.01386548f, 0.09306642f, -0.00194198f, -0.00370801f, -0.11963119f, 0.02142391f, -0.01279308f, 0.12113868f, 
    -0.05894163f, -0.05735765f, -0.11321571f, -0.01035525f, -0.07238064f, -0.07155157f, -0.01696096f, 0.12584841f, 
    -0.10925672f, -0.05617047f, -0.12103584f, -0.28611252f, -0.12156000f, 0.04053124f, -0.15348743f, 0.16304849f, 
    -0.11636614f, 0.01947651f, 0.08146688f, 0.10954841f, -0.00687717f, 0.15824956f, 0.08052824f, -0.18551366f, 
    0.21090257f, 0.32171902f, 0.18510008f, -0.16573811f, 0.13537982f, 0.11978800f, 0.12024540f, 0.06430636f, 
    0.07163522f, -0.00509368f, 0.01903123f, 0.07290606f, 0.00629470f, 0.33291039f, 0.00455713f, 0.02666429f, 
    0.09678357f, 0.07740445f, -0.03442761f, -0.02168220f, 0.02821741f, -0.08137942f, -0.07115424f, 0.03489303f, 
    0.11345738f, 0.08836374f, -0.16509448f, 0.13616239f, -0.10132816f, -0.08405017f, -0.13325132f, -0.10455371f, 
    0.13286434f, 0.01481797f, 0.00647700f, 0.01674017f, 0.27148673f, 0.30325571f, -0.16284896f, -0.10315207f, 
    0.22213376f, 0.07145075f, 0.19883117f, 0.06449301f, 0.03599803f, 0.05559468f, -0.08210756f, -0.02271757f, 
    -0.25573894f, -0.11918991f, 0.23825391f, -0.04593595f, 0.01853204f, 0.08208735f, 0.02585770f, 0.05142071f, 
    0.13127780f, 0.05577786f, 0.07655719f, 0.09760191f, -0.13935485f, -0.17125674f, -0.28157514f, -0.17570558f, 
    -0.02512710f, 0.01127465f, 0.00231421f, 0.15993430f, 0.03804588f, 0.06502187f, 0.01034029f, -0.12163045f, 
    -0.14694361f, -0.20455006f, -0.05156251f, 0.04242046f, -0.06445432f, 0.00983391f, 0.01744852f, -0.15630108f, 
    -0.02541206f, -0.10572972f, 0.00665597f, 0.09295076f, 0.39031675f, -0.04353791f, -0.02138664f, -0.14725292f, 
    0.14581735f, 0.07989137f, 0.01036081f, -0.05147224f, -0.06302974f, 0.12240572f, 0.09203116f, -0.02578636f, 
    -0.08546255f, -0.11981399f, -0.07722131f, -0.12916291f, 0.00287881f, -0.04074146f, -0.02535472f, -0.09349804f, 
    0.09383067f, -0.09840841f, 0.10956807f, 0.19236434f, 0.15336922f, 0.09229302f, 0.28650850f, 0.02592154f, 
    -0.03722233f, 0.07407341f, 0.01766196f, 0.09358573f, -0.16705547f, -0.11134601f, 0.24410659f, 0.05818421f, 
    0.13748360f, 0.26299948f, 0.12098841f, -0.08139212f, 0.05102395f, 0.10163528f, -0.00826001f, 0.03481567f, 
    0.07261339f, -0.00180514f, -0.13483129f, 0.06972747f, -0.02030147f, 0.02145273f, -0.06262851f, 0.02150363f, 
    0.00793206f, -0.13022044f, 0.08763462f, -0.02500490f, 0.08747749f, 0.05908835f, -0.03208000f, 0.04668317f, 
    0.08593469f, 0.19410461f, 0.04465327f, -0.01670065f, -0.05599158f, -0.15574038f, -0.06522563f, 0.09675423f, 
    0.06025977f, -0.08197881f, 0.02738404f, 0.02662686f, -0.22797813f, -0.09364993f, 0.02137667f, 0.00356224f, 
    0.20024714f, -0.03672817f, -0.06461607f, 0.05958042f, 0.01580120f, 0.00852084f, -0.04961330f, 0.18638338f, 
    -0.22001728f, -0.17236514f, -0.11376109f, 0.01313801f, -0.03642146f, -0.11034723f, -0.02111397f, 0.05703357f, 
    -0.01899774f, 0.07870592f, 0.03461409f, 0.06913961f, 0.35627908f, 0.17299186f, 0.06992718f, 0.08217089f, 
    -0.07309006f, -0.01803069f, -0.02257212f, -0.03877754f, 0.03686683f, 0.13548873f, 0.21006142f, 0.11116478f, 
    -0.06687876f, -0.05340485f, 0.00491702f, -0.00917081f, 0.03986426f, 0.18361628f, -0.00201172f, 0.09044096f, 
    -0.01619305f, 0.07053146f, -0.11570310f, 0.01309248f, -0.34732547f, -0.02799700f, -0.25199273f, -0.19545373f, 
    -0.09802495f, -0.08201487f, 0.04406159f, 0.18282698f, 0.06886730f, 0.00406037f, 0.02725158f, 0.05909925f, 
    -0.14092988f, -0.06170725f, -0.04868579f, 0.11585940f, -0.10407775f, 0.09247151f, -0.04255781f, 0.04200847f, 
    0.08854789f, 0.07774457f, 0.10463686f, 0.10745592f, -0.01537468f, 0.02818341f, 0.24721044f, 0.25940984f, 
    -0.02365071f, -0.01225317f, 0.02770031f, -0.09721225f, -0.02375183f, 0.03884165f, 0.10278001f, 0.22467595f, 
    -0.16022009f, -0.10369729f, 0.03553974f, 0.14219750f, 0.05626286f, -0.00599707f, 0.05368782f, 0.03993199f, 
    -0.03873885f, -0.12703401f, -0.01686401f, -0.16097069f, -0.16025031f, 0.02081446f, -0.29719862f, -0.12536052f, 
    0.00178678f, -0.01053836f, -0.04071112f, -0.06777315f, 0.11709760f, -0.00362550f, 0.20698297f, 0.24854565f, 
    -0.12185754f, -0.09279570f, -0.00036550f, 0.06232751f, -0.11558428f, -0.06797729f, 0.11265055f, 0.02458843f, 
    -0.02432530f, 0.10963682f, 0.12312910f, 0.11981864f, -0.01701898f, 0.09511404f, -0.11194852f, -0.04247007f, 
    -0.01785069f, 0.01711730f, -0.13534895f, -0.05251846f, 0.11966778f, 0.03127428f, -0.00849503f, 0.04946674f, 
    0.34958592f, -0.04042423f, 0.23961833f, 0.05435722f, 0.14844380f, 0.03638997f, -0.02548022f, 0.01076067f, 
    0.03936062f, 0.08580433f, 0.18463026f, 0.26201460f, -0.08349540f, -0.20812082f, -0.11080766f, 0.14221328f, 
    -0.08932804f, -0.02204678f, 0.06971372f, 0.20265538f, -0.05165059f, 0.00221544f, 0.03360879f, -0.07068671f, 
    -0.03952109f, 0.06668705f, 0.05552614f, -0.12303544f, -0.02858267f, 0.17965734f, -0.04940525f, -0.06377333f, 
    0.07452867f, -0.07856046f, 0.08123922f, 0.03956406f, -0.02012926f, 0.38582891f, 0.20273975f, 0.10031947f, 
    0.18997622f, 0.02257726f, 0.11385810f, -0.00155808f, 0.09011472f, 0.14874426f, 0.21950194f, 0.12023187f, 
    0.20180431f, 0.09758535f, -0.00648254f, 0.02647388f, 0.00153492f, -0.06387994f, -0.04644219f, -0.07814267f, 
    0.16073918f, 0.02393928f, -0.00335133f, -0.01948342f, 0.28265643f, 0.35751450f, 0.07694445f, -0.19776495f, 
    -0.08933562f, -0.01364195f, -0.03746815f, 0.02747628f, -0.01567657f, -0.04142555f, -0.04099690f, -0.01632501f, 
    -0.05989973f, -0.01042070f, -0.03070105f, 0.00887059f, 0.06903517f, -0.03156898f, 0.03907913f, 0.07308687f, 
    -0.05578798f, -0.10821883f, -0.05294910f, -0.05758708f, -0.12311275f, 0.04264194f, -0.08192738f, 0.12669988f, 
    0.00864645f, 0.01010927f, -0.07724603f, 0.15829553f, 0.14947441f, -0.00154454f, 0.07609398f, -0.00988617f, 
    -0.11973930f, -0.22523579f, 0.02740599f, 0.05399825f, 0.10323474f, -0.01055000f, 0.08278955f, -0.01095036f, 
    0.02106238f, 0.04710504f, -0.00825716f, -0.00863851f, -0.05462893f, -0.22967830f, 0.10700162f, 0.01593811f, 
    -0.14815314f, -0.00313167f, 0.01147167f, 0.10983361f, -0.06686073f, 0.00243804f, 0.17465153f, -0.00770458f, 
    -0.20096405f, -0.06020971f, 0.00961644f, -0.02470347f, 0.01109368f, -0.07155132f, -0.03740922f, -0.01591029f, 
    0.08606123f, -0.08395800f, -0.12577395f, 0.02071427f, -0.09090538f, -0.02658673f, -0.08450373f, -0.17529109f, 
    0.06989677f, 0.08987699f, 0.05857214f, -0.07153831f, -0.09218024f, 0.00336575f, -0.12414008f, 0.01447022f, 
    -0.03895734f, -0.10090326f, -0.06324691f, 0.11885975f, -0.18115737f, 0.03760656f, 0.17614372f, 0.04834696f, 
    -0.02911433f, 0.06582237f, 0.13265553f, -0.01095611f, 0.38648498f, 0.15847355f, 0.09034078f, 0.06261767f, 
    0.04321454f, -0.06106580f, -0.08971909f, -0.11656276f, -0.01687424f, 0.06141555f, -0.01837286f, -0.03855738f, 
    0.34467247f, 0.39461020f, 0.29008776f, -0.12099086f, -0.05566826f, -0.04426357f, -0.12135178f, 0.00000966f, 
    -0.02551739f, -0.09149389f, 0.00322807f, -0.04266151f, 0.40594694f, 0.13348956f, 0.12223855f, 0.12205632f, 
    0.02214855f, -0.05373678f, -0.07695337f, -0.04036488f, 0.08009974f, 0.08401929f, -0.06675500f, -0.06222185f, 
    0.11746609f, -0.12665467f, -0.08565845f, -0.12105206f, 0.01309143f, -0.04187661f, 0.07303756f, 0.08930897f, 
    -0.10535490f, -0.12502490f, 0.01608974f, -0.14408931f, -0.00419422f, -0.00368633f, 0.02627191f, 0.40249789f, 
    -0.03446453f, -0.00299292f, 0.08412053f, 0.00442937f, 0.05292756f, -0.02071872f, 0.10609201f, 0.03730383f, 
    -0.20091899f, -0.06574086f, -0.03534970f, 0.03702988f, -0.03876194f, -0.03205720f, 0.05163485f, 0.02523312f, 
    0.09126287f, 0.06556404f, 0.14726615f, 0.10243240f, -0.07711934f, 0.08347059f, 0.23477413f, 0.08308381f, 
    0.10225507f, 0.05845994f, 0.01827880f, -0.10353864f, 0.04667418f, -0.05283082f, -0.03809962f, 0.08353516f, 
    0.00919135f, 0.08188049f, 0.24324636f, 0.12544759f, -0.16034108f, 0.21289198f, 0.06749407f, -0.13934404f, 
    -0.04034907f, 0.06923437f, 0.13332307f, 0.10641399f, -0.27935171f, 0.06060721f, -0.15460882f, 0.06544863f, 
    -0.05990342f, -0.05011053f, 0.02357784f, 0.04978427f, 0.04100781f, 0.02931345f, -0.00223639f, -0.02346590f, 
    0.42265338f, 0.20256983f, 0.00227560f, -0.02282344f, -0.03115530f, -0.07090709f, -0.08539288f, -0.00851897f, 
    -0.01284098f, -0.02070125f, 0.10736655f, -0.01404403f, -0.23460044f, -0.05823158f, -0.07066349f, 0.19749528f, 
    -0.02932839f, 0.08465050f, -0.07598887f, -0.00884142f, 0.03614555f, -0.12750281f, 0.13818917f, 0.12350997f, 
    0.08284930f, 0.29450989f, 0.16712080f, 0.11311866f, -0.01302958f, 0.11786530f, 0.01364996f, 0.04398810f, 
    0.14065573f, 0.00943366f, 0.16214263f, 0.03598096f, 0.01149415f, 0.12655033f, -0.24035789f, -0.09353701f, 
    0.02459746f, -0.02362112f, -0.05736782f, -0.07172269f, 0.08299591f, 0.03459881f, -0.05193061f, -0.00255514f, 
    -0.19144462f, -0.06164594f, -0.10327896f, 0.09339946f, 0.03739387f, 0.08391152f, 0.02216741f, -0.07182167f, 
    -0.08755542f, -0.03384838f, -0.09981914f, -0.04369996f, -0.18435529f, 0.00839696f, -0.05106840f, 0.00898095f, 
    0.13860363f, 0.03364209f, 0.12583563f, 0.16715072f, 0.20133200f, 0.18262956f, 0.03381136f, 0.09028549f, 
    0.01510507f, -0.16470371f, -0.02366052f, 0.34319341f, 0.08669091f, 0.04720708f, -0.01656414f, 0.08937308f, 
    0.07252192f, -0.09172346f, 0.10398170f, 0.05753272f, -0.19415444f, 0.08019662f, 0.15776692f, 0.35377678f, 
    -0.04274629f, 0.06026799f, 0.13754325f, -0.04080842f, 0.05405014f, -0.04651855f, 0.04838860f, -0.05903729f, 
    -0.08221269f, 0.05765404f, 0.00601840f, 0.12822580f, 0.01477609f, 0.23613933f, 0.07456493f, 0.20113216f, 
    0.16065578f, 0.08368959f, 0.26171207f, 0.04579821f, -0.20571321f, 0.23972641f, 0.19947594f, 0.08131594f, 
    0.05792772f, -0.01391902f, 0.00063656f, 0.12345994f, -0.02253065f, 0.22312912f, 0.11779957f, -0.01851177f, 
    -0.20566447f, 0.15045114f, -0.12167398f, -0.01878387f, -0.05169572f, -0.05285197f, 0.00350042f, 0.08823134f, 
    0.20397909f, 0.03907221f, 0.13365871f, 0.29910484f, 0.30674854f, 0.06616270f, 0.02722533f, 0.26602247f, 
    0.02025994f, -0.02134187f, 0.02256384f, 0.01860618f, 0.06265927f, 0.02262774f, 0.05486039f, 0.19414838f, 
    -0.29574811f, 0.25669989f, 0.25933316f, 0.26985654f, 0.06365270f, 0.07541128f, -0.08425733f, 0.17460199f, 
    0.05774275f, -0.04337262f, 0.05670739f, 0.22602892f, -0.08416819f, -0.03002158f, -0.10713556f, 0.06669334f, 
    -0.05432991f, 0.04603741f, -0.06404430f, 0.04923920f, -0.00124008f, 0.12373855f, 0.09808424f, 0.10701922f, 
    -0.13814077f, -0.12831348f, -0.06403518f, 0.08334058f, 0.05521845f, 0.05583068f, 0.07285155f, 0.04718602f, 
    0.29807597f, 0.10392732f, 0.03583745f, 0.06093402f, 0.13516608f, -0.04567773f, -0.00921411f, 0.07859740f, 
    0.08463974f, 0.08206484f, -0.07359684f, -0.07291394f, -0.00218890f, -0.04433649f, -0.00651606f, 0.04278041f, 
    0.07325398f, 0.15030211f, 0.04686649f, 0.02986116f, -0.09241900f, 0.04319623f, -0.00066515f, 0.00052037f, 
    -0.04723887f, 0.08507949f, 0.08357459f, -0.18215710f, -0.24474177f, 0.03481956f, 0.11019056f, 0.25168407f, 
    0.03680328f, 0.04430628f, 0.07326701f, 0.26965830f, 0.06632898f, 0.08648951f, 0.02404105f, -0.03826535f, 
    0.00496376f, -0.15493748f, 0.25392592f, -0.00883645f, 0.11394285f, 0.00104789f, 0.19654512f, -0.03685779f, 
    0.01063776f, 0.04649902f, 0.12504481f, 0.01460430f, -0.19227880f, -0.09764782f, 0.13765436f, 0.26382738f, 
    -0.04855388f, 0.08897877f, 0.05442462f, 0.00911276f, 0.05967000f, 0.01650195f, 0.02375899f, 0.10760518f, 
    -0.38487393f, 0.05305579f, -0.04586669f, 0.09291936f, -0.08384869f, 0.10666850f, 0.02226481f, -0.04080605f, 
    0.08144937f, 0.12764074f, 0.01691412f, 0.02810015f, -0.10824316f, -0.07662816f, 0.22328591f, -0.20344111f, 
    -0.00619515f, 0.07296606f, -0.00790329f, 0.15448496f, 0.11884352f, 0.06002636f, 0.12541594f, 0.08148910f, 
    0.02218151f, -0.01262145f, 0.00307515f, 0.02055563f, 0.02013183f, -0.02205303f, 0.02485265f, -0.00067354f, 
    0.01396737f, 0.02203204f, 0.00714724f, -0.02308368f, 0.01918545f, -0.03807002f, 0.02391401f, 0.02482399f, 
    0.02118862f, -0.03596057f, -0.03063232f, -0.03268326f, -0.02530336f, -0.00403958f, 0.02118725f, 0.00418276f, 
    -0.02079889f, -0.00187662f, 0.00869377f, 0.01613813f, 0.02187603f, -0.02392358f, 0.02556830f, 0.02609081f, 
    -0.02749096f, 0.01892675f, -0.01173123f, -0.00421978f, -0.04165409f, -0.01829110f, -0.00863061f, 0.00793962f, 
    0.02726540f, 0.00331587f, 0.01901990f, -0.02153254f, 0.02588889f, -0.04199293f, -0.01604513f, -0.00297851f, 
    -0.01241096f, -0.03895445f, 0.00210638f, -0.03660593f, -0.02536422f, -0.00252766f, -0.04042010f, 0.00097528f, 
    0.00767183f, -0.03454351f, -0.03825215f, -0.00471686f, -0.04173771f, 0.00716399f, 0.01608109f, -0.01157951f, 
    -0.04036452f, 0.01071958f, 0.01979901f, 0.02549599f, 0.00953032f, -0.01532570f, -0.02330426f, -0.01611109f, 
    -0.04375776f, -0.02649918f, -0.02221160f, -0.00292364f, -0.00681685f, 0.01359328f, 0.00951567f, 0.01527102f, 
    -0.00112504f, -0.02203695f, -0.01085264f, 0.01126534f, -0.00930646f, 0.02198439f, -0.01600267f, -0.03848349f, 
    0.01410157f, -0.00117824f, -0.00228579f, 0.01475077f, -0.01161867f, -0.00263531f, -0.03876289f, 0.00111691f, 
    0.01585061f, -0.03869727f, -0.02297851f, 0.01919952f, -0.00467802f, 0.01897945f, -0.01756677f, -0.03157314f, 
    -0.01241626f, -0.01658172f, -0.00721666f, -0.02964214f, -0.01287224f, 0.00950076f, 0.03495157f, -0.02357340f, 
    0.00822960f, -0.02117952f, 0.01633413f, -0.02103279f, -0.00410971f, -0.00147339f, 0.00250567f, -0.03639705f, 
    0.01416904f, 0.02077550f, 0.02556257f, 0.01012834f, -0.02480177f, 0.00975603f, 0.01308366f, -0.02449883f, 
    -0.01508124f, -0.01312829f, -0.02684890f, -0.00300482f, -0.00956414f, -0.02666628f, -0.00907927f, 0.01950373f, 
    -0.02976705f, -0.03793753f, -0.02634662f, 0.01216221f, -0.02791245f, 0.02505673f, 0.01069536f, 0.01751790f, 
    0.02299966f, 0.00397256f, -0.00231288f, 0.00351242f, -0.00925686f, -0.02709376f, -0.00527480f, -0.04040269f, 
    0.01389146f, 0.02363622f, -0.03720687f, 0.01854187f, 0.00168659f, -0.00431535f, -0.01024322f, 0.02348457f, 
    -0.04227529f, -0.03650999f, -0.01478208f, -0.03022389f, -0.01711410f, -0.01897027f, 0.01259649f, 0.01898511f, 
    0.02163586f, -0.02034372f, -0.02377324f, -0.02079234f, -0.03851107f, -0.04406584f, 0.00460642f, 0.01629091f, 
    -0.04353055f, -0.03082546f, 0.02352547f, -0.03988751f, 0.01062413f, -0.02115799f, -0.03616330f, -0.00367107f, 
    -0.00936109f, -0.03214122f, 0.01168227f, 0.00044278f, -0.02825913f, 0.02499057f, -0.02946214f, -0.02816475f, 
    -0.04090673f, 0.01206606f, 0.00435694f, 0.02740103f, -0.03158432f, 0.02855445f, -0.02080591f, -0.02181392f, 
    0.00997595f, 0.00388493f, -0.00491037f, -0.03323354f, -0.01855479f, 0.00196046f, -0.02044582f, 0.00060864f, 
    -0.01771371f, -0.01174367f, 0.00551814f, 0.00222203f, -0.02350597f, -0.00398923f, -0.01478515f, -0.03819647f, 
    -0.04012845f, 0.00328088f, 0.02721205f, -0.04237799f, 0.02530357f, 0.01889561f, -0.01120663f, -0.01069550f, 
    0.01254510f, -0.03016061f, -0.01321977f, 0.01925024f, 0.02404316f, 0.02132365f, 0.00113174f, -0.00324049f, 
    -0.03866287f, -0.01517262f, 0.00766819f, -0.00478868f, -0.02733685f, -0.00782637f, -0.01936632f, 0.02209749f, 
    0.02703874f, -0.00924264f, -0.00880936f, -0.02454441f, -0.02238172f, -0.03666656f, -0.04444098f, 0.02467140f, 
    0.02283373f, -0.00266252f, 0.01101670f, -0.03143870f, 0.02207200f, 0.02418838f, -0.02667195f, -0.03093651f, 
    0.00087231f, -0.01512987f, -0.02764468f, -0.01054988f, -0.01664891f, 0.01011236f, -0.00675774f, -0.02054751f, 
    0.02764612f, 0.01745925f, -0.03712558f, 0.02761019f, -0.01626119f, 0.01020315f, -0.03993674f, 0.00082628f, 
    -0.02705052f, -0.03323455f, -0.00365927f, -0.03180537f, -0.04010216f, -0.03117520f, -0.03023968f, -0.00992242f, 
    -0.02154063f, -0.01781918f, 0.00654637f, 0.02072702f, -0.02328005f, -0.04375170f, -0.01195207f, 0.01421387f, 
    -0.02329719f, 0.00121033f, -0.02687818f, 0.00113103f, -0.01052628f, -0.00491497f, -0.01512671f, 0.01305873f, 
    -0.02838679f, -0.03271874f, -0.01244141f, -0.03067939f, -0.00505974f, -0.03196541f, -0.00195882f, 0.02833651f, 
    -0.00356630f, -0.01646391f, -0.01327519f, 0.00537378f, -0.04182440f, -0.02347410f, -0.00412693f, 0.03060583f, 
    -0.00231352f, 0.01495914f, 0.01123235f, 0.00708883f, -0.00072207f, -0.03650545f, 0.01429147f, -0.00732905f, 
    -0.03061299f, -0.02939101f, -0.03874712f, -0.02036475f, 0.01143653f, -0.00982650f, -0.00225975f, -0.03236899f, 
    -0.00982043f, 0.00406002f, 0.01915275f, -0.04286841f, -0.02162623f, 0.00272729f, -0.03001763f, -0.03936151f, 
    0.02343996f, -0.04077158f, -0.02715012f, -0.01840368f, 0.02675318f, -0.01134567f, -0.00084370f, -0.03692717f, 
    -0.00537619f, -0.00971691f, -0.00748194f, -0.03877380f, -0.04161418f, -0.02131772f, -0.01043279f, 0.02183662f, 
    -0.03244933f, -0.04152784f, -0.02754381f, -0.02254045f, -0.03828931f, -0.00576120f, 0.01902200f, -0.02262761f, 
    -0.00029103f, -0.00064983f, 0.00971884f, 0.01563445f, 0.02357373f, 0.01147180f, -0.04036904f, 0.01175178f, 
    -0.02325383f, 0.02127020f, -0.00961459f, -0.03821088f, -0.00527898f, -0.00145698f, -0.01378246f, 0.01416457f, 
    -0.00227281f, -0.01511068f, -0.02611209f, 0.02605432f, 0.02482244f, -0.02434345f, -0.03446130f, -0.00788588f, 
    -0.04055439f, 0.00747095f, -0.01860374f, 0.01982496f, -0.04172080f, -0.02389585f, -0.01220566f, -0.04425292f, 
    -0.00877518f, -0.03742144f, 0.01480938f, -0.00436691f, 0.01614234f, -0.01577790f, 0.02630884f, 0.01833657f, 
    -0.03197030f, 0.01678579f, 0.00871594f, 0.01776737f, 0.02345588f, 0.01290913f, -0.03739474f, -0.00814502f, 
    0.00100393f, -0.03884493f, -0.02307738f, -0.00123509f, 0.02157376f, 0.00743083f, 0.00815051f, -0.01755007f, 
    -0.04212072f, 0.00057582f, 0.02152192f, 0.02502433f, -0.01928292f, 0.00050897f, 0.00105125f, -0.00296428f, 
    -0.03934659f, 0.02887459f, -0.00582960f, -0.01184965f, 0.00817532f, -0.01608354f, 0.01447819f, 0.01728364f, 
    -0.04372342f, -0.04254254f, 0.02444925f, -0.02853223f, 0.01453265f, -0.02065906f, 0.01094096f, -0.04034882f, 
    -0.00077106f, -0.01610351f, -0.02689704f, -0.01481826f, -0.00070514f, -0.01335999f, -0.03971239f, 0.02673789f, 
    0.00856454f, -0.01758406f, -0.00652875f, -0.02064014f, -0.00797834f, -0.00764445f, 0.00740925f, 0.00996210f, 
    -0.01453683f, -0.00253145f, -0.00805222f, -0.03354425f, -0.02511923f, -0.04100129f, -0.03780109f, -0.04049444f, 
    -0.00910432f, -0.02263346f, -0.01003159f, -0.03905835f, 0.00115266f, 0.01391893f, -0.02158305f, 0.01048513f, 
    0.00144692f, -0.00335350f, -0.01535164f, 0.02281546f, -0.00819682f, -0.02511026f, -0.01306962f, -0.01824124f, 
    0.00149122f, 0.00492847f, -0.02113384f, -0.02183587f, 0.01376732f, -0.02983001f, -0.00321167f, 0.02296430f, 
    -0.00083749f, 0.00488562f, -0.04282717f, 0.01260145f, -0.02448381f, 0.02565413f, -0.02234401f, 0.00135199f, 
    0.02128088f, 0.02472859f, -0.02552924f, -0.03362747f, 0.02400759f, -0.00603139f, 0.01449378f, 0.02761024f, 
    0.02078593f, 0.00451876f, -0.00677754f, -0.02812207f, -0.04115699f, 0.01741988f, 0.01103675f, -0.01054629f, 
    0.02457771f, -0.02496505f, -0.00022100f, -0.01913534f, 0.02113785f, 0.02422549f, -0.02922046f, -0.02689700f, 
    -0.00165457f, -0.02828022f, -0.03797401f, -0.00084051f, -0.04453983f, 0.01610069f, 0.01720161f, 0.01371252f, 
    0.00001933f, 0.00134463f, -0.00764016f, -0.00645229f, -0.02247650f, -0.02354102f, 0.02219247f, 0.00901374f, 
    -0.00407853f, -0.03864174f, 0.00788087f, -0.00583740f, -0.02315129f, -0.01879673f, 0.01867637f, -0.03315395f, 
    -0.03352136f, 0.01226504f, 0.00002353f, -0.01865977f, -0.03134214f, 0.00056575f, 0.02911476f, -0.01065086f, 
    -0.02082998f, -0.04339959f, -0.03715795f, -0.02716592f, -0.00625207f, -0.03649756f, -0.00178247f, -0.02893065f, 
    0.02991238f, -0.02161744f, -0.04049766f, -0.03010182f, -0.02683715f, 0.00801731f, -0.01961434f, 0.00030080f, 
    -0.03160108f, -0.01135423f, -0.00563161f, 0.02043959f, -0.03702774f, 0.01086781f, -0.02939910f, -0.04072640f, 
    -0.03652618f, 0.02110855f, -0.03041833f, -0.01039159f, -0.00257121f, -0.03334729f, 0.01857429f, 0.01821785f, 
    -0.03037691f, -0.02174606f, -0.02932902f, 0.01005760f, -0.02573739f, 0.01092611f, 0.02476761f, -0.04065315f, 
    0.02590724f, 0.01969464f, 0.00505246f, 0.01638306f, 0.02680530f, 0.01781959f, -0.04263628f, -0.04258936f, 
    0.00391796f, -0.03584583f, 0.02153472f, 0.00960854f, -0.00393995f, -0.03688511f, 0.01267521f, -0.02901929f, 
    0.01640911f, -0.03970589f, -0.00170615f, -0.03996039f, 0.00709110f, -0.00683751f, 0.02694918f, 0.01311833f, 
    -0.04185583f, 0.00024068f, -0.02887145f, 0.00660006f, 0.02737200f, -0.02663407f, -0.01254473f, -0.03816181f, 
    0.02351052f, -0.03039487f, -0.01081732f, 0.02776017f, -0.02480979f, 0.00807173f, -0.00405887f, -0.01256286f, 
    -0.04118452f, -0.00350746f, -0.02508982f, 0.00475668f, 0.01142236f, -0.03337209f, -0.04333881f, 0.02854744f, 
    0.02507489f, -0.04144055f, -0.03406804f, 0.00174947f, 0.02369753f, 0.00207236f, -0.03651136f, -0.03291334f, 
    0.00354710f, 0.02065213f, -0.02361833f, -0.02360526f, 0.01611402f, -0.03254528f, -0.02288620f, 0.01788519f, 
    -0.00427198f, 0.02550048f, 0.00061233f, 0.00346972f, 0.03390816f, 0.00241449f, -0.02760929f, 0.02798124f, 
    0.01109130f, -0.02150736f, 0.03216185f, 0.01011108f, 0.01947367f, -0.01773369f, -0.03222176f, -0.02521773f, 
    -0.04030778f, -0.01354799f, 0.02663552f, 0.01290304f, -0.03728646f, -0.00898823f, -0.04024373f, -0.01659757f, 
    0.02305611f, 0.00291026f, -0.03542805f, -0.02656633f, 0.00215414f, 0.02603046f, -0.01741450f, -0.00374677f, 
    -0.03968269f, -0.02493544f, 0.02647512f, -0.03867885f, -0.03121373f, -0.04084446f, -0.04125908f, 0.02464322f, 
    -0.03789794f, 0.01072875f, -0.04043830f, -0.01340802f, -0.01472773f, 0.01391716f, 0.02455990f, -0.03208537f, 
    -0.02784880f, -0.04040415f, -0.02509838f, -0.00467775f, 0.00258274f, -0.03818005f, -0.03633784f, -0.01520295f, 
    -0.00172273f, -0.00028570f, -0.03593565f, -0.02508329f, 0.03141473f, 0.02661582f, 0.01383413f, -0.03988673f, 
    -0.01926006f, -0.03074766f, 0.02009114f, 0.01697833f, 0.01910835f, 0.00035169f, 0.01001581f, -0.01246307f, 
    -0.00590495f, -0.01368159f, -0.01506023f, -0.00184723f, 0.02708953f, 0.02563831f, -0.00320995f, 0.00145468f, 
    -0.02122976f, 0.01816424f, -0.00464872f, 0.02553249f, -0.00238658f, -0.04001307f, 0.02559826f, -0.02082752f, 
    -0.04167908f, -0.02650188f, 0.01033851f, -0.01287397f, 0.01864601f, 0.02683769f, -0.01099981f, 0.02824903f, 
    0.00664017f, 0.01005208f, 0.01523235f, -0.02820560f, 0.01930872f, 0.02740420f, -0.01684093f, -0.00572128f, 
    -0.04116615f, 0.00862779f, -0.02702137f, -0.03599897f, -0.00384295f, -0.00273647f, 0.02742107f, -0.01571249f, 
    0.01199864f, -0.02488600f, -0.03810700f, 0.00211827f, -0.00361104f, -0.00843537f, -0.04308003f, -0.02944671f, 
    0.02485052f, -0.02974391f, 0.00497554f, -0.01625934f, 0.00047926f, 0.01742852f, -0.01475658f, -0.02533306f, 
    -0.01202490f, 0.01337587f, 0.00346505f, -0.03484924f, 0.00340550f, -0.03470499f, -0.01043195f, -0.01546896f, 
    -0.01281219f, 0.03419381f, -0.03073247f, 0.01003878f, 0.01189417f, -0.01338039f, 0.01910788f, -0.03288948f, 
    0.00266620f, -0.01838903f, 0.00927967f, -0.01183593f, 0.00493330f, 0.01875259f, -0.03517234f, 0.02444683f, 
    -0.02428419f, 0.02580910f, -0.03135436f, 0.02624312f, 0.00772971f, -0.01680834f, -0.02818466f, 0.00706625f, 
    -0.01127696f, -0.00813058f, 0.00457428f, 0.01189798f, 0.00794884f, -0.01820144f, 0.02648743f, -0.01272022f, 
    -0.01996818f, -0.02185130f, 0.02519793f, 0.01037711f, -0.03764014f, 0.02003668f, 0.00456934f, 0.01141372f, 
    -0.01730544f, 0.00833027f, 0.01975505f, 0.01934711f, 0.01605734f, -0.03185269f, 0.02588329f, -0.01135304f, 
    -0.00430921f, -0.03211666f, -0.02617983f, 0.00483259f, -0.02736800f, -0.00780289f, -0.00397105f, -0.00785973f, 
    -0.02607230f, 0.02033603f, 0.02195809f, -0.02110568f, -0.02127443f, -0.02600841f, -0.01834911f, -0.01814082f, 
    -0.00502674f, 0.01614049f, -0.00884507f, -0.01546349f, 0.01446004f, 0.02265893f, 0.00075625f, -0.01526991f, 
    -0.00410924f, 0.03205051f, 0.01389427f, -0.02881858f, -0.00467655f, -0.00976948f, -0.03106611f, -0.00672503f, 
    -0.02268911f, -0.03960426f, -0.03976619f, 0.00045307f, 0.02304411f, -0.01655201f, -0.01462611f, 0.00500737f, 
    0.01686534f, -0.03839938f, 0.02531489f, 0.01030833f, 0.01928490f, 0.01806178f, 0.01524283f, -0.03068474f, 
    -0.01790684f, 0.00180236f, -0.03855943f, -0.03621877f, -0.03932861f, -0.02123055f, -0.01909983f, 0.01123355f, 
    0.01109156f, 0.00160022f, 0.02599832f, -0.00129891f, -0.03511888f, 0.01044104f, -0.02518781f, 0.00472258f, 
    -0.01174688f, -0.00384200f, 0.01551283f, -0.00850654f, -0.00170046f, 0.01513834f, -0.02584905f, -0.03062330f, 
    -0.02538655f, -0.04045364f, -0.04037610f, -0.00989865f, -0.01010672f, -0.02717187f, 0.00877781f, 0.02706030f, 
    -0.00236434f, 0.01128045f, -0.02927093f, -0.03805974f, 0.01644135f, -0.02116573f, -0.04111147f, 0.01726060f, 
    0.02299671f, -0.00646642f, 0.02439670f, -0.00021291f, 0.01995999f, -0.00550939f, -0.01685315f, 0.02532882f, 
    0.00519853f, -0.03297259f, 0.02692332f, -0.00421855f, 0.01009682f, 0.02562097f, -0.03330561f, -0.02139399f, 
    0.01594763f, -0.01877005f, -0.02616311f, 0.01435214f, 0.02153123f, -0.02636146f, -0.03907525f, 0.01935025f, 
    0.01215633f, -0.01024451f, -0.00984063f, -0.00203852f, -0.00501259f, -0.00350590f, 0.00475955f, -0.03497387f, 
    0.01374250f, 0.01691725f, 0.01007941f, -0.02794427f, -0.02172500f, -0.01403330f, -0.01306045f, -0.02580764f, 
    -0.02776050f, 0.02813055f, -0.00771653f, 0.00275835f, 0.02369189f, -0.03471142f, -0.01713744f, 0.01097653f, 
    -0.03380500f, -0.02774770f, 0.00357579f, -0.00143823f, -0.02909518f, -0.00552409f, -0.00186920f, 0.02011117f, 
    -0.03362090f, -0.00266648f, 0.01979397f, -0.01527160f, 0.00339385f, 0.03668841f, -0.03133304f, -0.02579349f, 
    -0.01128800f, -0.04087157f, 0.02585873f, 0.01220952f, -0.03610278f, 0.00891931f, 0.01146420f, -0.04132373f, 
    -0.02319783f, 0.02523896f, -0.01656866f, -0.00081439f, 0.02121453f, 0.02720989f, 0.00561283f, -0.03668660f, 
    -0.04097588f, -0.02842200f, -0.00917157f, -0.01302776f, -0.01958463f, -0.01280426f, -0.01116693f, -0.02274621f, 
    -0.00409336f, 0.00053835f, -0.02480038f, 0.03147150f, 0.00262690f, -0.01482177f, 0.00269299f, 0.01200611f, 
    -0.01930285f, -0.00319542f, 0.00841439f, 0.01635495f, 0.01018182f, -0.04076865f, -0.00123994f, 0.02215838f, 
    0.01033785f, -0.00387754f, -0.03861996f, -0.00561540f, 0.00355209f, -0.01705990f, -0.01341256f, -0.00202635f, 
    0.02652936f, 0.00452208f, -0.02758999f, -0.03011435f, 0.00613611f, -0.03049024f, 0.01043379f, -0.02187655f, 
    0.01435535f, 0.00851738f, 0.02093496f, -0.03412539f, 0.00958432f, -0.03069746f, 0.01065911f, 0.02395361f, 
    0.00824689f, -0.01510308f, -0.01819907f, 0.00646938f, -0.01196701f, -0.01272891f, -0.01951864f, -0.03249590f, 
    0.00758215f, -0.02381737f, -0.00041821f, 0.02082548f, 0.00277536f, 0.02284638f, 0.02092519f, -0.03855861f, 
    0.03057589f, -0.04272242f, 0.01510393f, -0.01958050f, 0.02643078f, -0.01365246f, 0.02143463f, -0.02838635f, 
    -0.04039894f, 0.02527174f, 0.01802226f, 0.00676562f, -0.00311903f, 0.02508971f, -0.03841035f, -0.00835084f, 
    0.00831193f, 0.00295288f, 0.00907743f, 0.02801446f, -0.00332087f, -0.00823111f, 0.02870048f, -0.00299105f, 
    0.04081298f, -0.03853063f, 0.01744667f, 0.00670432f, -0.03239264f, -0.00666153f, -0.04059915f, -0.01633428f, 
    -0.01268217f, 0.01503461f, -0.03223569f, 0.01533866f, -0.02932126f, 0.01222012f, 0.00693501f, -0.03803555f, 
    0.00946092f, -0.01359846f, -0.02401029f, 0.00034833f, -0.01704489f, 0.02648689f, 0.00746843f, 0.00381454f, 
    0.00294401f, -0.04073170f, -0.01030953f, -0.02661871f, 0.00518226f, -0.01794453f, 0.00033462f, -0.03954542f, 
    -0.00960504f, -0.00892356f, -0.03434232f, -0.02950400f, -0.01905080f, -0.00934123f, 0.01383264f, 0.00326853f, 
    -0.02383609f, -0.03608396f, 0.00146212f, -0.03375667f, -0.02695884f, 0.02193116f, -0.00381984f, -0.02444652f, 
    -0.02631217f, 0.00039037f, -0.00534101f, 0.00393695f, 0.00334700f, -0.02137727f, 0.02014100f, -0.03187353f, 
    -0.03811685f, -0.04231705f, -0.02468182f, -0.01702433f, -0.02106207f, -0.03901490f, 0.02097825f, -0.03686487f, 
    -0.02070465f, 0.00079486f, -0.01462694f, -0.01687964f, 0.00021644f, 0.00050588f, -0.03586878f, -0.01304288f, 
    -0.00240413f, -0.00204223f, -0.01956521f, 0.00839171f, -0.03765121f, -0.00009869f, -0.01485868f, 0.01505809f, 
    -0.02091117f, -0.00967851f, 0.01786370f, -0.00232240f, 0.02503279f, -0.03412447f, -0.00287932f, -0.04191313f, 
    -0.04176566f, 0.00242986f, 0.02386370f, -0.03788168f, 0.00308701f, -0.00989370f, -0.03745103f, -0.01532059f, 
    -0.01595680f, 0.00328473f, -0.02264346f, 0.00173148f, -0.00725200f, -0.02295677f, -0.04139548f, -0.03841238f, 
    -0.02192846f, -0.03153443f, 0.02214464f, 0.01767673f, -0.03422991f, -0.03819967f, 0.00102952f, -0.00267420f, 
    -0.00928361f, 0.02734766f, 0.00669291f, -0.00366908f, -0.00997719f, 0.01166395f, 0.02215008f, -0.01340844f, 
    0.02925264f, -0.00252024f, -0.01223757f, 0.01969743f, 0.00418289f, 0.01085453f, 0.00569226f, -0.02555863f, 
    -0.00200997f, 0.02611425f, -0.02398856f, 0.01748778f, 0.00211240f, -0.02114045f, -0.01174920f, -0.02658787f, 
    0.02054146f, -0.01275725f, 0.01049923f, 0.03841383f, -0.03048183f, -0.04091531f, -0.03658340f, 0.02710089f, 
    -0.00789957f, -0.01061620f, -0.00241669f, 0.01659367f, 0.02097369f, 0.02075570f, 0.00565967f, -0.03568756f, 
    -0.04068346f, -0.00996863f, -0.01596384f, -0.00750971f, -0.01566749f, -0.00526924f, 0.01876070f, -0.01167124f, 
    0.00670112f, -0.00201549f, -0.01668337f, -0.02446557f, 0.01638367f, -0.04119197f, 0.02662615f, -0.03744181f, 
    -0.02182309f, -0.04040059f, 0.00740158f, 0.02418078f, 0.00903192f, -0.03336789f, 0.01635599f, 0.00875198f, 
    -0.00766353f, -0.03357648f, -0.02941032f, 0.00924699f, -0.03477696f, -0.04107856f, 0.00291617f, 0.01999995f, 
    0.00346721f, -0.02282496f, -0.01997259f, -0.02392793f, 0.01241529f, -0.03122628f, -0.00606734f, -0.03700850f, 
    -0.00958169f, -0.00387730f, 0.00343668f, 0.03881873f, -0.03714628f, 0.01664196f, 0.01958160f, -0.02667062f, 
    -0.02850392f, -0.01322826f, 0.00662921f, -0.01061198f, -0.02694255f, 0.00304698f, -0.03466227f, 0.00172792f, 
    0.01138871f, 0.01086278f, -0.01716675f, 0.00617320f, 0.02170837f, 0.03094054f, 0.00691623f, 0.02104436f, 
    0.01199512f, -0.04149342f, -0.02939645f, 0.01030436f, -0.02780340f, -0.00647470f, 0.01043170f, -0.00763613f, 
    -0.01642497f, -0.01525202f, 0.01660086f, -0.03538224f, 0.02442556f, -0.02610044f, 0.02006580f, -0.01342231f, 
    0.01562405f, 0.01401962f, 0.00590819f, -0.03627214f, -0.01173706f, -0.02544129f, 0.01706817f, 0.01749458f, 
    -0.02828145f, 0.02729817f, 0.00106234f, -0.04167827f, -0.01001026f, 0.00696902f, -0.04136042f, -0.02573163f, 
    -0.00089444f, -0.00572276f, -0.02082895f, -0.01134708f, 0.01510164f, -0.01134404f, -0.02962549f, 0.00442686f, 
    -0.02756362f, -0.04295082f, -0.03479248f, -0.03049759f, -0.01790913f, -0.01158888f, 0.02577451f, -0.01427280f, 
    -0.01629164f, 0.00837118f, 0.02242869f, -0.02170615f, -0.02288810f, -0.01505984f, 0.00026848f, 0.02441083f, 
    -0.02601384f, -0.03532249f, -0.01503971f, -0.01133225f, -0.00355203f, -0.01966977f, 0.00277230f, 0.01426897f, 
    0.00766962f, -0.02920651f, 0.02394007f, -0.02841736f, -0.02435829f, 0.02229241f, 0.00783699f, -0.03854362f, 
    0.02422151f, -0.01546505f, -0.02565245f, 0.02395897f, 0.02151286f, 0.02402078f, 0.00982754f, -0.03251511f, 
    -0.00604122f, 0.03155207f, -0.02045492f, -0.01232237f, 0.01565468f, 0.02806468f, 0.01154001f, -0.01004529f, 
    -0.01327976f, -0.02106172f, -0.03484826f, 0.01548777f, -0.03062359f, 0.01908226f, 0.00492082f, -0.02910597f, 
    0.01408287f, 0.01421776f, 0.01769693f, 0.00799557f, 0.01334352f, 0.00112407f, 0.00262028f, -0.03138562f, 
    0.01503472f, -0.03356924f, 0.01488993f, 0.01948209f, -0.00326345f, -0.03991557f, -0.01346559f, -0.02873213f, 
    -0.03330633f, -0.02948326f, 0.00620420f, -0.04069233f, 0.00397258f, -0.00832300f, -0.00915395f, -0.03913081f, 
    -0.03114875f, 0.00599761f, -0.01491406f, 0.00491886f, -0.01679201f, 0.02224876f, -0.03406839f, -0.01792553f, 
    0.01256808f, -0.00124789f, -0.02666138f, -0.02563418f, 0.00989288f, 0.01560975f, 0.01618803f, -0.02290872f, 
    0.00004267f, 0.00968497f, -0.03119317f, 0.02947685f, -0.01944048f, 0.00144950f, 0.00076138f, -0.00787613f, 
    -0.00853695f, 0.00653695f, 0.02533219f, 0.01159318f, -0.02599446f, -0.00287184f, 0.02505249f, 0.02417668f, 
    0.00824832f, -0.03116476f, -0.04148468f, 0.01283411f, -0.02347140f, 0.01630639f, -0.03139328f, -0.02562216f, 
    0.02141310f, -0.04017161f, -0.04177225f, -0.02120109f, -0.03797868f, -0.01960805f, -0.00874896f, 0.00771018f, 
    -0.01226645f, -0.01531504f, -0.04262579f, -0.03436790f, -0.03169448f, -0.04387524f, 0.01518485f, -0.01986454f, 
    -0.03899367f, 0.02491825f, 0.02502263f, 0.02853560f, -0.03022396f, -0.03075381f, -0.00203726f, -0.01333840f, 
    0.01077660f, -0.00365501f, -0.02953468f, -0.02976442f, -0.02169018f, -0.00686880f, -0.04390654f, -0.00641104f, 
    -0.02563522f, -0.04212965f, -0.03614215f, 0.01824325f, -0.01259998f, -0.02857496f, -0.02326133f, 0.02588920f, 
    0.01908343f, -0.03093776f, -0.02652689f, 0.01674656f, 0.00645076f, 0.01731457f, 0.00783074f, -0.03112730f, 
    -0.03360957f, 0.02623874f, -0.00610009f, 0.00346646f, -0.02679007f, -0.04155900f, 0.00756199f, 0.02370873f, 
    0.02462047f, -0.03324949f, -0.00340235f, -0.01370418f, -0.01157379f, 0.01273736f, -0.01104716f, 0.02875959f, 
    -0.20959847f, -0.18673222f, 0.09565805f, 0.02407038f, -0.11741052f, 0.00697257f, 0.04722165f, -0.04777842f, 
    0.14145692f, 0.08684994f, 0.03805129f, 0.00926426f, -0.06861360f, -0.07528934f, -0.15762539f, -0.08073990f, 
    0.08702740f, 0.06572385f, -0.01988158f, 0.13328467f, 0.10490794f, 0.00676797f, -0.00421052f, -0.04425119f, 
    0.10433469f, -0.26715788f, 0.11828097f, -0.02537307f, -0.00592300f, -0.07693982f, -0.17860760f, -0.14920907f, 
    -0.11462420f, -0.02333603f, -0.01752494f, -0.03974313f, 0.38960850f, -0.04614135f, -0.01960705f, -0.25322098f, 
    0.14035209f, 0.03247925f, 0.06289107f, -0.10197766f, -0.07155269f, 0.13650833f, 0.00804618f, 0.02997207f, 
    0.18404593f, 0.18787049f, -0.18105131f, -0.06846964f, -0.00451893f, -0.13760971f, -0.06627421f, -0.18685482f, 
    -0.02750432f, -0.22081682f, 0.00229421f, 0.09656418f, -0.09166853f, 0.24029678f, 0.25023359f, -0.00280994f, 
    -0.01278264f, 0.03390760f, 0.02407963f, 0.02677890f, -0.23290576f, -0.18974711f, 0.06522957f, -0.01239965f, 
    0.01315890f, 0.16627561f, 0.30235574f, -0.18119965f, 0.13851896f, 0.08544338f, -0.10880788f, 0.01524407f, 
    0.07418169f, -0.15428604f, -0.08141522f, 0.05518124f, -0.03904900f, 0.05391745f, -0.17979833f, -0.02082554f, 
    -0.03304241f, -0.01955573f, -0.06523911f, -0.10243787f, 0.06611130f, 0.01878319f, -0.02628045f, 0.02894541f, 
    0.03698151f, -0.12341540f, 0.02189547f, 0.18684553f, 0.01520860f, -0.07928813f, -0.01738165f, -0.09430511f, 
    0.06684240f, -0.10438365f, -0.04846811f, -0.01147635f, -0.25126252f, -0.05468483f, 0.00106158f, 0.09369102f, 
    0.18390734f, -0.07526223f, -0.03362197f, 0.15180677f, 0.15416889f, 0.00161353f, 0.01396515f, 0.08319977f, 
    -0.19454522f, -0.16699100f, -0.18815443f, -0.04436974f, -0.04860774f, -0.12632799f, -0.07401132f, -0.00035883f, 
    0.05730619f, 0.05646902f, 0.04791147f, 0.03938476f, 0.16221613f, 0.02262808f, 0.07809342f, 0.07130161f, 
    -0.03137108f, -0.00325684f, 0.04611159f, -0.03179142f, 0.03033868f, -0.03026131f, 0.09292412f, 0.09133358f, 
    -0.01951761f, -0.01172613f, -0.01096814f, 0.11122277f, 0.04021896f, 0.08538242f, -0.08238970f, 0.12978770f, 
    0.01662297f, 0.01365549f, -0.07939574f, 0.01021082f, -0.04445240f, -0.04217759f, -0.08662009f, -0.01372908f, 
    -0.01968045f, -0.08369117f, 0.00465968f, 0.07848565f, 0.01712190f, 0.03685771f, -0.01278016f, 0.01822574f, 
    -0.20802881f, -0.04528250f, -0.09709571f, 0.08388596f, -0.15331386f, 0.01407711f, -0.06598037f, 0.03189491f, 
    0.05103192f, 0.13588534f, 0.06940094f, 0.09263387f, -0.04553867f, -0.00138092f, 0.17809956f, 0.09846607f, 
    -0.01050601f, -0.02352793f, 0.06191682f, 0.02340995f, 0.05352841f, 0.06665850f, -0.00059454f, 0.06388222f, 
    -0.09357084f, 0.04219760f, 0.02881638f, 0.17830193f, -0.00599996f, -0.01627139f, -0.01216510f, 0.04367141f, 
    0.02567592f, -0.08089493f, -0.13135032f, -0.14170003f, 0.04075318f, 0.07250468f, -0.21860921f, -0.11132190f, 
    -0.05238266f, -0.00723939f, -0.04297575f, -0.11507879f, 0.17570536f, 0.01383882f, 0.18245150f, 0.24533775f, 
    0.14004119f, -0.11512224f, -0.04100925f, -0.01698897f, -0.03279633f, -0.04960406f, 0.06281859f, -0.07931077f, 
    -0.14721212f, 0.08416728f, 0.03689154f, -0.01699500f, 0.08006997f, -0.01899228f, -0.19267119f, -0.05818076f, 
    0.11034440f, 0.02424609f, -0.15650409f, 0.02313310f, 0.03006170f, 0.03200104f, -0.02076317f, 0.10208388f, 
    0.26209658f, -0.01912034f, 0.19732483f, 0.12248509f, 0.13877498f, -0.08003743f, 0.05771762f, 0.02836469f, 
    0.10932231f, 0.05755195f, 0.12695459f, 0.08023822f, 0.07681112f, -0.17968801f, -0.07607245f, 0.12767127f, 
    0.02778447f, 0.06508529f, 0.07395609f, 0.12577473f, -0.07601739f, 0.02649642f, 0.04906788f, -0.09999572f, 
    0.04249562f, -0.06634369f, -0.03428923f, -0.00313901f, 0.12196068f, 0.06731327f, -0.10109092f, 0.01506671f, 
    -0.00180824f, -0.01874350f, 0.19258474f, 0.02338802f, -0.13626181f, 0.34211081f, 0.03072910f, 0.03784511f, 
    0.00557992f, 0.11427425f, 0.09057029f, 0.08104300f, 0.09243671f, -0.00454087f, 0.04744718f, 0.02767424f, 
    0.11411887f, 0.01982190f, -0.10487519f, -0.12288791f, -0.08787565f, -0.04711167f, 0.02848909f, -0.04924729f, 
    0.04385683f, 0.01302157f, -0.14780475f, 0.09791891f, 0.24805300f, 0.16314720f, 0.10599317f, -0.23455799f, 
    -0.04103508f, 0.08855986f, 0.03747552f, -0.00200740f, -0.01092763f, -0.01501283f, 0.04068199f, -0.00092875f, 
    -0.06736540f, 0.03800737f, 0.04825604f, 0.01102103f, 0.15820527f, 0.01629584f, 0.06268235f, 0.12992328f, 
    -0.01508755f, -0.07404756f, 0.06153844f, -0.07125763f, -0.08751854f, 0.12087331f, -0.11478817f, 0.09470189f, 
    0.10894444f, 0.07284518f, -0.02198160f, 0.13303278f, 0.03412553f, 0.01294012f, 0.01218186f, 0.03050846f, 
    -0.15061869f, -0.12010361f, 0.07338099f, 0.09966116f, 0.01324097f, -0.02007944f, 0.09667011f, 0.04522456f, 
    0.03149272f, 0.08739926f, -0.03083148f, -0.03666405f, -0.05850980f, -0.21191356f, 0.11711847f, 0.08180011f, 
    -0.14936776f, 0.03130256f, -0.04249318f, 0.11179189f, -0.05079972f, -0.01420060f, 0.07570635f, 0.05232253f, 
    -0.12775779f, 0.00933564f, 0.06235932f, 0.10910280f, 0.10302769f, -0.02058468f, 0.09658626f, 0.15230721f, 
    0.10863116f, -0.04707722f, -0.09410968f, -0.01848961f, -0.17702842f, -0.25173131f, -0.07307681f, -0.03029601f, 
    0.07522399f, 0.05435951f, -0.09919395f, -0.19111437f, -0.06550439f, -0.09456062f, -0.10166399f, -0.06144396f, 
    -0.18221951f, -0.10034495f, 0.18955342f, 0.08395912f, -0.10982662f, 0.09910563f, 0.03029177f, 0.03150020f, 
    -0.11293662f, -0.04463272f, 0.01350396f, -0.16178030f, 0.21048857f, 0.11308718f, 0.04852827f, 0.15175962f, 
    0.00035031f, -0.04343495f, 0.01767634f, -0.11796022f, -0.07333389f, 0.04514842f, 0.00236503f, -0.01981214f, 
    0.27284613f, 0.40411267f, 0.31315750f, 0.13654183f, 0.02270303f, 0.05588510f, -0.03656999f, 0.07852598f, 
    -0.01369193f, -0.06174922f, -0.03914725f, -0.01426289f, 0.17819797f, -0.08096470f, -0.00679874f, -0.02056968f, 
    0.00421462f, -0.09006330f, 0.02126133f, -0.02844517f, 0.04942766f, 0.00750926f, -0.10038179f, -0.04627033f, 
    0.24351551f, -0.21805254f, -0.00261463f, 0.01585228f, 0.03697074f, -0.11829349f, 0.00168266f, -0.04860031f, 
    -0.04114864f, 0.00179215f, 0.07779417f, -0.04277109f, 0.14752385f, -0.01168303f, -0.05125441f, 0.44722712f, 
    -0.00215527f, 0.00946616f, 0.00054946f, 0.08000388f, 0.02854711f, 0.06573378f, 0.02918925f, 0.01376013f, 
    -0.17741334f, -0.03204473f, -0.05464818f, 0.00391670f, 0.03339060f, 0.00243658f, 0.04676311f, 0.00213258f, 
    0.08554422f, 0.09421962f, 0.04960655f, 0.02872788f, -0.01135027f, 0.02168119f, 0.19264403f, 0.19653736f, 
    0.10904808f, 0.06325354f, -0.03226488f, -0.07070830f, 0.04014536f, 0.02976146f, -0.11107175f, -0.00095565f, 
    -0.08905647f, 0.00393890f, 0.36462843f, 0.02124935f, -0.17678759f, 0.09358206f, 0.04300204f, 0.00915006f, 
    -0.06114930f, 0.05702716f, -0.01227094f, 0.09703714f, -0.08611439f, 0.02155990f, -0.23956570f, 0.08536830f, 
    0.01398618f, -0.01251520f, 0.02501487f, -0.06312518f, 0.06030696f, 0.01059273f, 0.02851495f, -0.07175682f, 
    0.29581460f, 0.20787975f, -0.02517309f, 0.02200253f, -0.06776973f, -0.02171342f, -0.04213683f, -0.04875559f, 
    0.06174767f, -0.01964885f, 0.03085576f, -0.01729946f, 0.12465808f, -0.33221108f, 0.15217458f, 0.07955732f, 
    -0.00341894f, 0.04962733f, -0.15324369f, -0.03287231f, -0.05478726f, -0.03106614f, 0.10522468f, 0.13441385f, 
    0.02144640f, 0.27749038f, 0.12188049f, 0.05893128f, -0.04592783f, 0.21320292f, 0.04580414f, 0.02148132f, 
    0.08998895f, -0.06394102f, 0.08623092f, -0.08477538f, -0.05729996f, 0.16747555f, -0.13927764f, -0.08957650f, 
    -0.09766100f, -0.03760499f, -0.10142799f, -0.15467602f, -0.00649588f, -0.00601285f, -0.05852002f, 0.09160582f, 
    0.02198989f, 0.00382916f, 0.13584536f, 0.20502494f, -0.01232616f, -0.04304375f, -0.06319200f, 0.02092554f, 
    -0.06162713f, -0.12309824f, -0.07980844f, -0.03836951f, -0.14189041f, -0.01645978f, -0.12502719f, 0.04910811f, 
    0.06255573f, 0.00666129f, 0.07491282f, 0.06441724f, 0.19854052f, 0.09127134f, 0.04884642f, 0.02641722f, 
    0.17453161f, -0.18377511f, -0.02864565f, 0.10192636f, 0.08970777f, 0.01829555f, 0.00989613f, 0.08986212f, 
    -0.01860445f, 0.02170145f, 0.05317812f, -0.01557949f, -0.10300704f, 0.16619386f, 0.12905172f, 0.35287771f, 
    0.03141810f, 0.05918106f, 0.06793708f, 0.09454045f, 0.01170450f, -0.01237539f, 0.03662552f, -0.02464141f, 
    0.00403266f, -0.09064844f, -0.06007168f, 0.16898434f, 0.02151901f, 0.10492163f, 0.02016716f, 0.21622585f, 
    0.09786642f, 0.05333292f, 0.19022141f, -0.00857240f, -0.24103042f, 0.28177336f, 0.09339608f, 0.24758987f, 
    -0.03020395f, 0.05064832f, 0.03188412f, -0.02001602f, -0.05420591f, 0.08685692f, -0.11317677f, 0.13359359f, 
    -0.00363212f, 0.14418080f, -0.09270773f, -0.05267902f, -0.04032896f, 0.00583779f, -0.01732803f, -0.06732996f, 
    0.07800134f, -0.18041793f, 0.07132775f, 0.27488920f, 0.18422541f, 0.24220087f, -0.02839209f, 0.00012637f, 
    -0.06473348f, -0.06549496f, 0.05853873f, 0.00778410f, 0.17775777f, -0.11468755f, 0.06804465f, 0.06859412f, 
    -0.43796813f, 0.09545430f, 0.25073081f, 0.39998555f, 0.02024546f, -0.03848550f, -0.10435415f, 0.20284139f, 
    -0.05012914f, 0.13400371f, 0.05150125f, 0.13826098f, -0.06356510f, 0.03528354f, -0.04349020f, -0.11063017f, 
    0.00200725f, -0.02925122f, -0.09721141f, 0.03026313f, 0.04445892f, 0.05277232f, 0.04040925f, 0.10360061f, 
    -0.11117236f, -0.11284687f, -0.06565474f, 0.05036910f, 0.03054642f, 0.04583421f, 0.03513388f, 0.08068033f, 
    0.22739270f, 0.11656006f, 0.07398300f, -0.03653789f, 0.06163407f, -0.04083579f, -0.02955621f, 0.12522982f, 
    0.25475147f, 0.03060963f, -0.05528283f, 0.00956465f, -0.00902270f, 0.02699001f, -0.00253513f, 0.04449221f, 
    -0.05059797f, 0.06633353f, 0.03765538f, -0.03869712f, -0.08906303f, 0.02984163f, -0.03278330f, 0.03428365f, 
    -0.03485293f, 0.05076325f, -0.10920910f, -0.08911213f, -0.10435666f, -0.12478749f, 0.30671504f, 0.26258758f, 
    0.19554444f, 0.02843747f, -0.08648923f, 0.24238738f, 0.06941700f, 0.04989658f, -0.01711102f, 0.08543772f, 
    0.01479389f, 0.03008581f, 0.16706474f, 0.00886276f, 0.03357117f, -0.06297369f, 0.12105713f, -0.03370330f, 
    -0.07202430f, 0.02938158f, -0.06482016f, 0.03773984f, -0.09895752f, -0.16679813f, 0.02769524f, 0.18560046f, 
    -0.13830999f, 0.06128355f, 0.02129979f, 0.04254838f, -0.02659179f, 0.06481714f, 0.01945297f, 0.07489645f, 
    -0.21140966f, -0.01081761f, 0.00326018f, 0.15943237f, -0.01673775f, 0.11088163f, 0.00600700f, -0.07638832f, 
    -0.02871980f, 0.11407211f, -0.05689170f, 0.04163921f, -0.03971602f, -0.20830794f, 0.21276334f, -0.08939919f, 
    -0.13932814f, 0.07751065f, -0.08064796f, 0.21562110f, 0.15505624f, 0.06357735f, 0.11913043f, 0.06426324f, 
    -0.03229532f, 0.03675621f, 0.17888685f, 0.04661741f, -0.00661981f, -0.00707461f, -0.09370829f, 0.04778911f, 
    0.11545573f, 0.03431755f, -0.00174163f, 0.05551396f, 0.11419591f, -0.05862654f, 0.01093568f, -0.03794142f, 
    -0.12187576f, -0.09564613f, -0.11043131f, 0.06731578f, 0.08869099f, -0.07819068f, -0.00137263f, 0.15299709f, 
    0.17582031f, -0.12814181f, 0.29572415f, -0.24888590f, -0.15090722f, -0.07065997f, -0.06606796f, -0.05183345f, 
    -0.08291741f, 0.07517289f, 0.07939675f, -0.00297126f, -0.04860688f, 0.17715330f, -0.19310310f, 0.13875091f, 
    0.12010034f, -0.07900816f, -0.04501635f, -0.03017383f, 0.05774759f, -0.08712503f, 0.02726077f, 0.03209936f, 
    0.30268967f, 0.19304150f, -0.07398292f, 0.02920261f, -0.11678825f, -0.10609238f, 0.00655227f, -0.04557981f, 
    0.10221899f, 0.08888932f, 0.08031417f, -0.04152980f, -0.20894593f, 0.18346822f, -0.29244646f, 0.18010649f, 
    -0.05941208f, 0.00418577f, 0.22706039f, 0.08147096f, 0.04252259f, 0.02027692f, 0.06229258f, -0.05926766f, 
    0.01547830f, 0.06517662f, -0.17060594f, 0.10514713f, 0.01665951f, -0.08497445f, -0.19212085f, -0.00196161f, 
    -0.00125663f, -0.00413973f, 0.04987720f, -0.06898537f, -0.07661672f, -0.02385966f, -0.26837790f, -0.02844755f, 
    0.10769890f, 0.04308148f, -0.09629732f, 0.05304420f, 0.16666360f, -0.17844972f, 0.06082561f, 0.10817992f, 
    -0.07922982f, 0.03459106f, 0.15873352f, 0.14915383f, -0.04016609f, -0.08284353f, -0.02379677f, 0.02847096f, 
    0.08983298f, 0.07086408f, -0.03710107f, -0.00056418f, -0.02078818f, 0.04253557f, -0.16570804f, -0.20946252f, 
    0.00205312f, -0.02794612f, 0.02804871f, 0.14381795f, 0.02534128f, 0.04025410f, 0.12406074f, -0.05712827f, 
    -0.15007903f, -0.13815233f, -0.19514424f, -0.18680386f, 0.10986203f, -0.07156844f, 0.11079378f, 0.14433464f, 
    0.00052763f, -0.00795537f, 0.02215829f, 0.12941825f, 0.02675425f, -0.08530506f, 0.08429816f, 0.04361330f, 
    0.15075505f, -0.12516603f, 0.09931996f, 0.00967462f, -0.11277515f, 0.06284004f, 0.00460035f, 0.10907085f, 
    -0.10067746f, -0.09033755f, 0.00376340f, 0.07679994f, -0.10472686f, -0.20490375f, -0.07222468f, -0.00424927f, 
    -0.02590081f, -0.15838802f, 0.04962366f, -0.07281830f, 0.16878818f, 0.01159376f, 0.12674446f, 0.02160543f, 
    -0.06902447f, -0.14034024f, -0.02268021f, -0.05724386f, 0.00842839f, 0.06222666f, 0.00115707f, 0.05629328f, 
    0.01170724f, -0.06508363f, 0.29151404f, -0.02232849f, 0.03757619f, 0.01066409f, 0.02132238f, 0.06748924f, 
    0.12467623f, -0.03330926f, 0.09318063f, 0.04988738f, 0.09237690f, -0.01259662f, -0.03962046f, -0.19037358f, 
    0.00245275f, 0.03346398f, 0.07815678f, 0.02368781f, -0.03022198f, 0.02556804f, -0.11448515f, -0.14353037f, 
    -0.12108327f, -0.04930976f, -0.03545469f, 0.22922906f, 0.04990963f, 0.00551902f, 0.14117174f, 0.02705383f, 
    0.11268704f, 0.19918209f, 0.02237305f, 0.15755598f, 0.36254239f, -0.02429245f, 0.23691092f, -0.08185124f, 
    -0.11782324f, 0.00505190f, -0.05013057f, -0.01364185f, 0.16576408f, -0.06112700f, -0.02046175f, -0.06214006f, 
    -0.03870256f, 0.01290248f, -0.07217009f, -0.09874797f, -0.06823508f, -0.08994235f, 0.19208202f, -0.02718623f, 
    0.06754477f, -0.13966994f, 0.03866972f, 0.07868280f, 0.24568994f, -0.19556415f, 0.13097624f, -0.01947044f, 
    -0.02033670f, 0.03763989f, -0.20118259f, -0.10450543f, -0.14471230f, -0.17457645f, 0.01131321f, -0.14131574f, 
    -0.33445606f, 0.27499339f, -0.17735100f, 0.22965029f, 0.17862581f, 0.00797494f, 0.02583542f, -0.04825715f, 
    0.01899296f, -0.07463666f, 0.08219170f, -0.11008159f, 0.14624797f, -0.05413114f, 0.20362638f, -0.06528693f, 
    -0.18933606f, -0.11569715f, -0.02289027f, 0.00394993f, 0.15232514f, -0.03581084f, -0.00377154f, 0.13344680f, 
    -0.13384666f, -0.08488093f, 0.13867231f, -0.02195387f, 0.03433953f, 0.00384280f, -0.11090448f, 0.06906214f, 
    0.11530855f, -0.18990250f, -0.06929220f, -0.23090400f, -0.14318757f, -0.00348043f, -0.13191003f, 0.24974449f, 
    -0.05102265f, 0.05566164f, -0.05185547f, 0.06090331f, -0.02197612f, 0.03078888f, 0.03769819f, 0.06015633f, 
    0.14028715f, -0.14395323f, 0.02813243f, 0.06116437f, -0.03011234f, 0.14292164f, -0.11205384f, -0.00868476f, 
    0.07997595f, 0.17898113f, 0.07404038f, 0.04235889f, 0.07141355f, -0.27189490f, 0.00753974f, 0.06698199f, 
    0.14028890f, 0.19069220f, 0.06582461f, -0.10437254f, -0.04292890f, 0.02075518f, -0.08912807f, 0.01919466f, 
    -0.02581137f, -0.01798603f, -0.25680473f, -0.20146485f, 0.13969439f, 0.12701908f, 0.01170057f, -0.03946586f, 
    -0.00164825f, 0.04932041f, 0.07784072f, -0.01985424f, 0.03046689f, 0.04313960f, -0.01737207f, 0.01380002f, 
    0.10894250f, -0.05032602f, 0.01825790f, 0.04727188f, 0.00288114f, 0.10130666f, 0.03257225f, 0.13170466f, 
    -0.04199127f, 0.06599513f, 0.25311953f, -0.03854817f, -0.13391216f, 0.01666601f, 0.01532781f, 0.14416385f, 
    0.11917941f, -0.03918755f, 0.07748048f, -0.08601724f, 0.01839549f, 0.20767891f, 0.21401168f, -0.02225391f, 
    0.09921517f, -0.15867424f, -0.10797776f, -0.09744132f, -0.01281763f, -0.08812338f, -0.07927801f, -0.05174676f, 
    0.11339269f, 0.06097523f, 0.01859191f, 0.16904598f, 0.10368681f, -0.06440184f, 0.18526451f, 0.17109017f, 
    -0.01662000f, -0.12347544f, 0.09522770f, -0.03966669f, -0.37716627f, 0.06430573f, 0.00534113f, -0.14596973f, 
    -0.10091273f, -0.07297374f, 0.08222496f, 0.18161625f, 0.08718345f, -0.02738771f, 0.12612467f, 0.06349195f, 
    0.01946636f, 0.07164562f, 0.22516340f, -0.32111236f, 0.05325056f, 0.04130144f, -0.00678519f, -0.08996374f, 
    0.00185856f, -0.01037717f, 0.06001266f, 0.08908046f, -0.02026746f, -0.07378911f, -0.06985839f, 0.11087303f, 
    -0.08273257f, 0.12112932f, 0.09166504f, -0.10765263f, -0.20571013f, -0.09446372f, 0.01729445f, -0.14901796f, 
    0.09452593f, -0.19252215f, 0.04445191f, 0.18783410f, 0.18935162f, 0.14990525f, 0.05718924f, 0.10412277f, 
    -0.08831674f, -0.17473197f, 0.00162541f, -0.16651365f, 0.02766101f, -0.08225680f, -0.19031273f, -0.03279699f, 
    -0.00625333f, 0.06048353f, 0.14358696f, 0.11056596f, -0.02031535f, 0.02069065f, 0.16641738f, 0.11053181f, 
    -0.13933778f, -0.16054873f, -0.22212759f, 0.06898589f, -0.02887718f, 0.04784001f, 0.12310332f, -0.01536399f, 
    0.28528613f, 0.03967012f, 0.10933148f, 0.22279213f, 0.15528360f, -0.24637820f, 0.01081023f, 0.15571116f, 
    0.02337587f, 0.16000266f, 0.02219008f, 0.05916150f, -0.06406401f, -0.10269853f, -0.08230947f, -0.12704197f, 
    -0.03124592f, -0.05318032f, 0.02588459f, 0.04666055f, 0.06627158f, -0.05951794f, -0.02256923f, 0.05812576f, 
    0.11991012f, 0.08457858f, 0.03325612f, 0.16431922f, 0.17571625f, 0.05420687f, 0.20863028f, 0.31983522f, 
    0.13631795f, 0.09766904f, 0.10318618f, 0.14399675f, 0.03082721f, -0.06427491f, 0.01493881f, 0.02597196f, 
    -0.22457843f, 0.12976901f, 0.17181696f, -0.22436708f, 0.11361899f, -0.04747115f, 0.09414820f, -0.04244534f, 
    0.14747301f, 0.09994984f, 0.00084474f, 0.04406874f, 0.37433699f, -0.08991887f, 0.09433139f, -0.10231057f, 
    -0.18330550f, -0.09212600f, 0.04684674f, -0.06550279f, 0.14292349f, 0.05053566f, -0.02247660f, -0.02496538f, 
    -0.11147320f, 0.00276237f, -0.00668213f, 0.03672440f, 0.00990451f, 0.02423409f, -0.03055269f, -0.20403139f, 
    -0.02538950f, 0.00519487f, 0.03426137f, -0.12910156f, 0.05759091f, -0.32518348f, 0.38029599f, -0.34562612f, 
    -0.07246038f, -0.23742057f, 0.07205411f, -0.01573879f, 0.02444214f, 0.05915783f, -0.00565710f, 0.01053060f, 
    -0.05982330f, -0.24713771f, -0.13258916f, 0.05809002f, 0.00558175f, -0.03277909f, 0.01518461f, -0.08866315f, 
    -0.09418347f, -0.01945266f, 0.02291567f, -0.14618017f, 0.19653133f, -0.10056396f, 0.28947523f, -0.01725404f, 
    -0.07065938f, 0.04372250f, -0.15731132f, -0.05199004f, 0.25957885f, 0.12426354f, 0.07417176f, 0.17077322f, 
    0.14926030f, 0.05476073f, 0.09013892f, -0.07865568f, 0.09050584f, 0.01127675f, -0.02866471f, 0.16211115f, 
    -0.09175991f, -0.18818241f, -0.01114194f, -0.07428300f, 0.10078979f, 0.11602222f, -0.03952687f, 0.05985713f, 
    -0.06993816f, -0.02470702f, -0.01041780f, -0.05020930f, 0.04512588f, -0.00212358f, -0.03208255f, 0.10180414f, 
    0.11626948f, -0.26236349f, 0.04156949f, -0.42951712f, 0.00929953f, 0.02418288f, 0.00199199f, -0.01035958f, 
    -0.18571691f, 0.04601057f, -0.15374754f, -0.11760961f, 0.03744488f, -0.10592157f, -0.02516065f, 0.05930416f, 
    0.05670901f, 0.06647242f, -0.00500470f, 0.05666243f, -0.02988388f, -0.10880712f, -0.01611550f, -0.12944753f, 
    -0.13247491f, 0.02943148f, 0.01723537f, -0.06599824f, 0.12418117f, -0.10350224f, -0.15264539f, 0.08441480f, 
    0.06028058f, 0.04673732f, -0.03557218f, 0.11356642f, 0.22668132f, -0.00057118f, -0.23739645f, 0.02864607f, 
    -0.09387930f, -0.03167553f, -0.01991791f, -0.10211273f, 0.03231195f, -0.08204521f, -0.11803802f, 0.21327488f, 
    0.21259531f, -0.33994338f, 0.22223909f, -0.33703330f, 0.03818031f, -0.26643032f, -0.10309307f, -0.12082558f, 
    0.05760167f, -0.03090932f, -0.00254964f, 0.02141279f, 0.01971913f, 0.07912785f, -0.15739039f, 0.14216535f, 
    0.05219224f, -0.00644128f, -0.16938399f, -0.15404198f, -0.07638402f, 0.00659476f, 0.00593936f, 0.07703647f, 
    -0.22038411f, 0.22656822f, -0.05859127f, 0.05368968f, 0.13155590f, -0.13569005f, 0.09197721f, 0.11381398f, 
    -0.02287510f, 0.18580450f, -0.09846311f, 0.09218383f, 0.14442462f, -0.12223312f, 0.05706524f, -0.37159610f, 
    -0.02318570f, -0.07116101f, 0.07910617f, -0.17167856f, 0.13830692f, -0.19743361f, 0.06354717f, 0.08071128f, 
    0.07395746f, -0.00086863f, 0.03671544f, 0.09639166f, 0.01334863f, 0.09051225f, 0.01662389f, 0.14531235f, 
    0.10403328f, 0.00087191f, -0.00520249f, 0.03652499f, -0.10355623f, -0.04891773f, -0.06786557f, -0.09605862f, 
    0.16498731f, -0.01965012f, -0.02881682f, 0.06779408f, -0.03096621f, -0.17439605f, 0.00780096f, -0.25091732f, 
    -0.15937240f, -0.13708501f, 0.01043700f, -0.01879033f, 0.12036533f, 0.09941791f, 0.18140669f, 0.00189777f, 
    0.19315368f, 0.17056134f, 0.01056101f, 0.33282754f, 0.12525292f, -0.07861596f, 0.00231989f, -0.49842146f, 
    0.09567323f, -0.12509696f, -0.19342043f, -0.02580296f, -0.15453248f, 0.02026269f, 0.03001896f, -0.12352230f, 
    -0.16434662f, 0.02728900f, 0.06712665f, 0.08325323f, -0.07093297f, 0.06294201f, -0.02323663f, -0.15767273f, 
    0.09160447f, 0.05483391f, -0.12577717f, -0.11177651f, 0.21383570f, -0.21019967f, 0.37803179f, 0.07171810f, 
    0.04549898f, 0.12608641f, -0.00036087f, 0.02261515f, 0.00351765f, 0.02961099f, -0.01361587f, -0.04341214f, 
    0.02269639f, -0.07408004f, 0.19223841f, 0.00855578f, 0.05329274f, 0.05270443f, -0.02860357f, -0.01407970f, 
    -0.01661555f, 0.01178295f, 0.09966089f, 0.06091827f, -0.17600040f, 0.31192559f, 0.02639885f, 0.08852453f, 
    -0.02927255f, 0.10389160f, 0.11898833f, -0.12035788f, 0.09860993f, -0.13408959f, -0.01134872f, 0.00548693f, 
    0.10936189f, 0.12662014f, -0.26535636f, 0.05615383f, 0.11983224f, 0.03424375f, 0.09189124f, -0.02914799f, 
    0.00860730f, 0.01233553f, 0.06336123f, -0.01670442f, 0.27988777f, -0.16777757f, -0.17729573f, -0.13852957f, 
    -0.00294716f, 0.16034389f, 0.05374002f, -0.03022163f, 0.01892427f, -0.01895750f, 0.08772323f, -0.04797711f, 
    0.21119748f, 0.05029506f, -0.17190373f, -0.07577974f, -0.02763326f, -0.12244665f, 0.02355650f, -0.11287916f, 
    0.07912994f, 0.12980384f, -0.02914263f, -0.08690914f, -0.29111075f, 0.19518498f, 0.06945645f, -0.03884809f, 
    -0.12760894f, 0.06177414f, -0.03004282f, 0.01905814f, 0.04693387f, 0.01992915f, -0.02689624f, 0.06483683f, 
    -0.06775636f, 0.00835713f, 0.13690479f, 0.23438282f, -0.02778213f, -0.05907081f, -0.02464318f, -0.06358281f, 
    -0.03561581f, -0.01660198f, -0.21623972f, -0.02069464f, -0.07292304f, -0.15898667f, 0.29326683f, 0.15260801f, 
    0.04065642f, -0.07787530f, 0.01556810f, -0.13688366f, 0.04889320f, 0.06222731f, -0.27550983f, 0.04806937f, 
    0.09043113f, -0.30135593f, -0.03946765f, 0.05087505f, 0.00956052f, -0.10202192f, 0.12819886f, -0.14525951f, 
    0.26452598f, 0.13509199f, 0.22821228f, -0.03206745f, 0.24840817f, 0.02716512f, 0.14876029f, 0.12020409f, 
    0.02310602f, 0.04654366f, -0.16507415f, 0.04273245f, -0.11904662f, 0.15965490f, -0.04975687f, -0.17097551f, 
    -0.01433082f, -0.10860633f, -0.30556232f, 0.11847249f, -0.02568863f, 0.04149989f, 0.10225721f, 0.04521731f, 
    -0.00423375f, -0.08072930f, -0.15747382f, -0.01290947f, 0.23587355f, -0.00233398f, 0.05713952f, 0.05559345f, 
    -0.00856735f, -0.02152185f, -0.17923239f, -0.07182284f, 0.12016377f, 0.00821080f, -0.05359326f, 0.04643073f, 
    0.34081849f, 0.16533907f, 0.10252007f, 0.10297798f, 0.07036229f, 0.11635829f, -0.04598426f, -0.12234014f, 
    0.09515548f, -0.04565142f, 0.03754678f, -0.00383754f, -0.02916158f, 0.28695580f, 0.11509482f, 0.15006152f, 
    -0.13802816f, -0.03770553f, -0.13109370f, -0.09967600f, 0.04124939f, -0.10839818f, -0.13434376f, -0.11035306f, 
    -0.11155257f, 0.03674840f, -0.12831844f, -0.06780664f, 0.05419722f, 0.14393510f, 0.16056512f, 0.10611466f, 
    -0.09137073f, -0.01453998f, 0.02963180f, 0.01616444f, 0.18359140f, -0.32618552f, -0.05388396f, 0.00462120f, 
    0.00512624f, 0.15308665f, -0.06242651f, -0.04300701f, 0.08348544f, 0.04345265f, 0.00669722f, -0.05393987f, 
    0.12919705f, 0.07867517f, -0.17740779f, -0.05541389f, 0.06472427f, -0.11725107f, 0.24808387f, 0.09871171f, 
    -0.01465919f, 0.08047049f, -0.04233939f, 0.02229859f, -0.05103214f, 0.11995348f, -0.11397371f, -0.22344212f, 
    -0.06222579f, 0.04353525f, -0.06325965f, 0.02195876f, -0.01341408f, 0.11406371f, 0.01811454f, -0.01359230f, 
    0.03696720f, -0.00436788f, -0.00786558f, -0.27142262f, 0.00651846f, -0.02182405f, 0.03516650f, 0.14958432f, 
    -0.00443188f, -0.04194663f, -0.05174972f, 0.00040531f, 0.23215246f, 0.09635753f, -0.00192374f, 0.05796915f, 
    -0.16882347f, -0.08149432f, -0.11996336f, -0.09133652f, 0.08439522f, -0.00328685f, -0.05188356f, 0.20623836f, 
    -0.07872365f, 0.07588402f, -0.15205050f, -0.06026877f, 0.15855396f, 0.27608728f, -0.00456323f, 0.09159293f, 
    0.00389986f, 0.08347378f, 0.01844558f, 0.01091134f, -0.19110438f, -0.08058808f, -0.11630591f, -0.03628315f, 
    0.07051510f, 0.08868730f, 0.20748146f, -0.11112362f, 0.03478223f, 0.08031815f, 0.07829792f, 0.18779469f, 
    0.03854406f, 0.07162548f, -0.06756859f, 0.13519074f, -0.10071406f, 0.04763833f, 0.11467160f, 0.05349967f, 
    0.05219027f, 0.09885455f, -0.10114329f, -0.03657310f, 0.04608440f, -0.04376493f, -0.18705460f, -0.05142191f, 
    0.04044678f, 0.14383592f, 0.01689126f, -0.00426456f, -0.06018722f, 0.07493102f, 0.04800359f, -0.04031158f, 
    0.10067056f, -0.14474888f, -0.09075463f, 0.06117854f, 0.00798187f, -0.06902730f, -0.02481769f, -0.12123972f, 
    -0.08946769f, 0.18391441f, -0.12633744f, 0.18806627f, 0.04459431f, -0.11716546f, -0.00538383f, -0.29123998f, 
    0.04434688f, 0.09261484f, 0.04866614f, 0.21755196f, 0.08909769f, -0.05259411f, -0.15055221f, 0.01736856f, 
    0.07052429f, 0.24465497f, -0.12998335f, 0.01897471f, -0.11007873f, 0.03222467f, -0.00936164f, -0.11206007f, 
    -0.04761791f, -0.06091778f, -0.01914383f, 0.05401372f, -0.03130470f, 0.15397136f, 0.11838105f, 0.19392745f, 
    -0.20073713f, -0.18721823f, -0.20085479f, -0.23473205f, 0.04514408f, -0.08091468f, 0.05515969f, -0.08870143f, 
    -0.27230105f, -0.03019927f, -0.01383469f, -0.12618363f, -0.06259933f, -0.04713757f, 0.14074928f, -0.11781154f, 
    -0.03524060f, -0.06918989f, 0.14319882f, 0.07378639f, 0.10628713f, 0.02187769f, -0.02172317f, -0.06320582f, 
    0.07724830f, 0.09159885f, 0.21515411f, 0.00118920f, -0.04107715f, 0.07948419f, -0.02979696f, -0.20040677f, 
    0.03889019f, 0.08192769f, -0.15446357f, 0.06184588f, 0.02709451f, 0.07716752f, -0.08640864f, 0.06220961f, 
    0.06187201f, -0.04930120f, -0.02677954f, 0.06692240f, -0.12055248f, 0.02531498f, -0.26297677f, 0.12887897f, 
    0.14872193f, 0.03776053f, 0.32769787f, 0.06746150f, -0.01787481f, 0.10543377f, 0.11237273f, 0.09779182f, 
    -0.07066305f, 0.05154032f, -0.07561125f, -0.08528552f, 0.08247086f, 0.19245350f, 0.00838221f, 0.04682155f, 
    -0.05773526f, 0.08099084f, -0.06941289f, 0.03841019f, 0.15530127f, -0.36163619f, -0.28781086f, 0.09153096f, 
    -0.05514641f, -0.01277459f, 0.03771335f, -0.09128653f, 0.05076940f, -0.01794767f, -0.03395636f, -0.07512461f, 
    -0.00361891f, -0.17912754f, -0.10801269f, 0.05698423f, 0.05635890f, 0.04664313f, -0.06555555f, 0.09898880f, 
    0.07416204f, 0.04758694f, -0.01016477f, -0.11421051f, -0.16003051f, 0.29362166f, 0.14215595f, -0.03191225f, 
    -0.11486427f, -0.15332590f, -0.05835224f, -0.08282072f, 0.01405387f, -0.01621850f, 0.05559212f, 0.13316688f, 
    -0.19939144f, -0.08555788f, -0.14210960f, 0.10147124f, -0.09386865f, -0.26058060f, 0.04011355f, -0.15782949f, 
    0.01154734f, 0.06485963f, -0.02167795f, 0.09408341f, -0.19404316f, 0.32940230f, 0.12348088f, -0.05134258f, 
    -0.05935443f, -0.10768912f, -0.08016367f, -0.23626103f, -0.09757940f, -0.09688560f, -0.00861244f, -0.06529215f, 
    -0.32510993f, 0.03374142f, 0.09478374f, 0.06871417f, 0.03151735f, 0.08037259f, -0.09541462f, -0.06444781f, 
    -0.12652338f, 0.03788590f, -0.16632330f, -0.31246558f, -0.07771306f, 0.13721162f, -0.15347458f, -0.32204324f, 
    0.16968411f, -0.00894107f, 0.07542574f, 0.03671535f, -0.01483178f, 0.18235417f, 0.04930725f, 0.09818895f, 
    0.23705643f, 0.07302241f, -0.00595923f, -0.11526405f, 0.21048883f, -0.01558732f, -0.00094130f, -0.06175772f, 
    0.10413049f, -0.00245185f, -0.03000090f, 0.01312331f, 0.02432040f, -0.04428875f, -0.29825294f, -0.38649723f, 
    -0.12212354f, -0.14195706f, -0.10183396f, 0.14848714f, -0.09116784f, 0.00925783f, 0.09118899f, 0.15539794f, 
    0.22246014f, -0.06553610f, 0.07274172f, 0.12293582f, 0.03411936f, -0.21220523f, -0.05656028f, 0.04311761f, 
    -0.10735294f, 0.07533545f, -0.05216927f, 0.04790051f, 0.13402876f, -0.20594569f, -0.12046448f, -0.15608580f, 
    0.07644515f, 0.11798128f, -0.05839640f, -0.00979913f, 0.06349624f, -0.01633569f, 0.09724944f, 0.05543574f, 
    -0.05382378f, 0.04700961f, 0.19552268f, 0.04858080f, -0.07550789f, -0.11691777f, 0.00165241f, -0.15368904f, 
    -0.06363551f, 0.12827997f, -0.00790554f, 0.17676750f, 0.71006316f, 0.25942320f, 0.14005323f, -0.16599670f, 
    -0.09529249f, -0.16721374f, -0.02181946f, -0.18474515f, 0.08938368f, 0.10136864f, -0.02463906f, 0.08609474f, 
    -0.10924833f, 0.19115812f, -0.25010929f, -0.17831072f, 0.07713912f, -0.09134476f, 0.14377750f, -0.00806879f, 
    -0.01061628f, 0.10128898f, -0.14532685f, -0.00217106f, 0.27593553f, 0.16357583f, 0.10395711f, -0.08613919f, 
    -0.23330133f, -0.01360610f, -0.04123831f, -0.06850310f, -0.23444381f, -0.26903221f, -0.11519392f, -0.21953653f, 
    0.02681250f, -0.07491028f, -0.17254123f, -0.07218257f, -0.01734051f, -0.00705115f, 0.18680537f, 0.10866589f, 
    -0.20834769f, -0.00312701f, -0.06059072f, -0.09413897f, -0.01666131f, -0.05282418f, 0.24590537f, -0.15308243f, 
    0.07557548f, 0.17884690f, 0.00256018f, 0.10925935f, -0.06124475f, 0.03998352f, 0.20724133f, -0.20038347f, 
    0.17658277f, 0.32113117f, -0.14617018f, -0.28722948f, 0.07617474f, -0.02694627f, 0.09701843f, -0.13957389f, 
    0.02889460f, 0.03880569f, 0.10744230f, 0.04198246f, 0.11868809f, 0.03301827f, -0.01593366f, -0.22856268f, 
    0.10391916f, 0.00723443f, 0.08578605f, 0.07824500f, 0.06769289f, 0.07851968f, 0.01813406f, 0.23102374f, 
    0.24694259f, -0.13599421f, 0.03566889f, 0.05225845f, 0.03075637f, -0.03420940f, 0.07031364f, 0.13638088f, 
    0.05163671f, -0.08242929f, 0.11904636f, -0.03651299f, 0.06428713f, -0.05404193f, 0.36478317f, -0.01369633f, 
    -0.04733534f, 0.13033392f, -0.06844012f, -0.00689089f, -0.00638203f, 0.06285582f, 0.07954777f, 0.02958493f, 
    0.50383753f, 0.18698291f, 0.07161086f, 0.14992887f, -0.21201216f, 0.14484051f, 0.01256828f, -0.21879579f, 
    -0.01287846f, 0.08369403f, -0.09603977f, -0.14735693f, -0.16300276f, 0.16585207f, 0.20857865f, 0.04004811f, 
    0.04921670f, -0.08906378f, 0.08790879f, -0.07127891f, 0.00262809f, -0.08561377f, 0.01654294f, -0.09982850f, 
    0.52238047f, -0.28444275f, 0.34543827f, 0.00936433f, -0.08023977f, 0.03751246f, 0.07387939f, 0.01272808f, 
    0.05863444f, -0.06101010f, 0.15257421f, 0.05070275f, 0.02925190f, 0.06894171f, -0.05895893f, 0.00773964f, 
    0.00626098f, -0.01985434f, -0.02962859f, -0.19287944f, 0.05744046f, 0.13102381f, -0.01823618f, -0.02378164f, 
    0.21669178f, 0.05927137f, 0.05026203f, -0.12596942f, 0.07943446f, -0.03993919f, 0.03578333f, -0.07650316f, 
    -0.06006971f, -0.06199715f, 0.05215074f, -0.02467561f, -0.17178875f, 0.13665216f, 0.05733401f, -0.05251365f, 
    -0.07023636f, -0.11262306f, 0.00778010f, -0.18933661f, -0.13932578f, 0.14438154f, 0.02154360f, 0.04124557f, 
    -0.00807531f, 0.02531825f, 0.10887869f, 0.13716818f, -0.09259877f, -0.05832065f, -0.19243507f, -0.11691541f, 
    -0.10197777f, -0.30792961f, -0.02855502f, -0.10179686f, 0.30908611f, 0.00576852f, -0.12737054f, 0.01438520f, 
    -0.00732622f, 0.00366927f, 0.23170197f, -0.02468674f, 0.19868709f, -0.02682986f, 0.00894905f, 0.24426788f, 
    0.14224675f, -0.12887938f, -0.12051791f, 0.12264392f, 0.03418602f, -0.00821045f, -0.03988496f, 0.46603173f, 
    -0.00205091f, 0.09818753f, 0.10149734f, -0.04787166f, -0.00177594f, 0.06613800f, -0.11108755f, -0.21098559f, 
    0.04435499f, 0.00243103f, -0.00740689f, 0.08198193f, 0.05985051f, 0.04340573f, 0.07188562f, 0.05940320f, 
    0.29047617f, -0.12414527f, 0.05487105f, -0.06081785f, -0.12448636f, 0.04933050f, 0.04151439f, 0.09535243f, 
    0.22846752f, -0.02898473f, -0.13198523f, -0.11483245f, 0.05300668f, -0.18042383f, -0.02430257f, 0.25577471f, 
    -0.03910221f, 0.04535296f, 0.01119975f, 0.09776846f, -0.17476329f, 0.08744751f, 0.00533416f, 0.11661298f, 
    -0.03715799f, 0.01376703f, -0.03064396f, 0.01637891f, 0.01111943f, -0.02559476f, 0.00342458f, 0.02142372f, 
    -0.03685098f, 0.02192140f, -0.01774374f, -0.02713823f, 0.01461610f, -0.01130060f, -0.03441957f, -0.01799604f, 
    0.00832395f, -0.02799030f, -0.02994495f, -0.00139189f, -0.00697462f, -0.01790500f, 0.01365254f, -0.03944051f, 
    -0.02528548f, 0.01437763f, -0.03298121f, -0.02746176f, -0.03782616f, 0.02627235f, 0.02341912f, 0.01671198f, 
    0.02675227f, -0.01797225f, -0.00307929f, -0.00997239f, 0.00293029f, 0.00368870f, -0.03366379f, -0.02617020f, 
    -0.03289850f, -0.01933717f, 0.02725504f, -0.02425688f, 0.00118908f, 0.02243135f, -0.03867758f, 0.02958354f, 
    0.02209927f, 0.02028417f, -0.01279130f, 0.02797689f, 0.01884563f, -0.03927910f, -0.01305145f, -0.00396064f, 
    -0.02386615f, -0.02234310f, 0.00965390f, -0.02535838f, -0.01023037f, -0.00921129f, -0.02493459f, 0.02963576f, 
    0.01555059f, -0.03825664f, -0.00215952f, -0.04086111f, 0.01216369f, -0.02981358f, -0.02247220f, -0.02147200f, 
    0.00113270f, 0.00764917f, 0.02763653f, -0.02050488f, -0.01981072f, -0.01871115f, -0.03441146f, 0.01148548f, 
    0.01337837f, 0.02785797f, -0.00214717f, -0.00632884f, 0.02365167f, -0.02444118f, 0.00966503f, -0.01357744f, 
    -0.01464872f, 0.02348686f, 0.02343244f, 0.02297857f, -0.02703937f, -0.03541951f, -0.03638576f, 0.00833484f, 
    -0.00144222f, -0.03034062f, 0.01789638f, 0.01748055f, -0.01483065f, -0.01012022f, 0.00558135f, 0.00997743f, 
    -0.02039047f, 0.00949353f, 0.02306530f, 0.00703918f, -0.02377769f, -0.01669980f, -0.01108722f, 0.02606999f, 
    0.02631617f, -0.03079350f, 0.00880072f, -0.03515018f, -0.00793045f, 0.02612561f, -0.00303600f, 0.00859200f, 
    -0.03692418f, -0.04188570f, 0.00507789f, -0.02931637f, -0.04171464f, -0.01277031f, -0.01350577f, -0.01901208f, 
    0.02510842f, -0.02361844f, -0.02063156f, 0.00010104f, -0.01984167f, -0.01199641f, 0.00619227f, 0.00520256f, 
    0.01927882f, -0.03299057f, 0.00347577f, -0.02386525f, -0.04174755f, 0.01169444f, 0.01502302f, 0.01889297f, 
    -0.01389995f, -0.02564945f, -0.02751612f, 0.02153867f, 0.00227107f, -0.00741954f, 0.01165231f, -0.02137187f, 
    -0.00991291f, 0.01275260f, -0.00593353f, -0.00935414f, -0.00548880f, -0.02289033f, -0.00141416f, 0.00067430f, 
    0.04121708f, -0.02687588f, -0.03774531f, -0.01087775f, -0.02249024f, -0.01478900f, 0.01878939f, 0.01272862f, 
    -0.03756577f, 0.02646021f, -0.03263322f, 0.00109464f, -0.01237608f, -0.02116023f, -0.02678764f, -0.02329534f, 
    -0.03393561f, 0.00221671f, -0.01172898f, -0.01925392f, 0.03007770f, -0.01851911f, 0.00295108f, -0.03111869f, 
    -0.02772156f, -0.00850312f, 0.01382020f, 0.02640407f, 0.00129595f, -0.03483073f, -0.01654344f, 0.01800473f, 
    0.03706380f, -0.03092879f, -0.02816196f, 0.01381878f, 0.00774263f, 0.02118809f, 0.02991567f, -0.01108385f, 
    0.02424412f, -0.02966417f, 0.00798539f, 0.02233746f, 0.00966366f, 0.01809480f, -0.00574924f, -0.02903143f, 
    -0.03232129f, -0.02935896f, -0.01466988f, -0.01198050f, -0.03655603f, -0.01280118f, -0.04138521f, -0.01761338f, 
    -0.03973156f, -0.01686283f, -0.00879308f, -0.01286303f, 0.02336938f, 0.01396475f, 0.00289947f, 0.00566186f, 
    -0.01779633f, -0.02135467f, 0.04081354f, 0.03289195f, 0.02554426f, -0.02806331f, 0.02336674f, -0.02959313f, 
    -0.01497588f, 0.00325567f, -0.01415120f, 0.01571314f, 0.02135323f, -0.02951542f, -0.01686317f, 0.00023623f, 
    -0.02221446f, 0.01557896f, -0.00650052f, 0.02126467f, 0.01529222f, 0.04035839f, 0.02944821f, -0.03419798f, 
    -0.03413702f, 0.02320896f, -0.02385949f, -0.02368961f, -0.00578734f, 0.01483580f, 0.02204918f, 0.01253106f, 
    -0.02939591f, 0.02738550f, -0.03774522f, -0.03878529f, -0.02523456f, -0.01381127f, -0.01726256f, -0.00392772f, 
    -0.00636131f, -0.01671379f, 0.00126987f, -0.01280437f, 0.00626042f, -0.03459134f, -0.02008124f, -0.02022935f, 
    -0.01236177f, 0.00310568f, -0.01528569f, -0.03927121f, -0.00906643f, 0.00819862f, 0.02346304f, -0.01310588f, 
    -0.00894482f, -0.01884938f, -0.01401747f, 0.00148375f, -0.02427381f, -0.03483739f, 0.00259101f, -0.03466048f, 
    -0.02373176f, -0.01111832f, -0.01374798f, 0.01417238f, -0.03083592f, -0.02444104f, -0.00800301f, -0.03270257f, 
    0.01819831f, 0.01648954f, 0.01343491f, 0.01860367f, -0.03603477f, -0.03940928f, -0.03090206f, -0.00251639f, 
    0.01290040f, 0.02743414f, -0.00277746f, -0.02396423f, -0.00119182f, -0.03725084f, -0.02996699f, 0.00754683f, 
    -0.02081219f, 0.00519607f, 0.00219267f, -0.00385114f, -0.01884512f, 0.00959420f, -0.00053942f, -0.01877076f, 
    -0.02938385f, -0.01667635f, -0.01895244f, 0.00879983f, 0.01357263f, 0.01505226f, -0.01498273f, -0.04177099f, 
    0.00683738f, -0.00132141f, -0.01372662f, 0.00396953f, -0.01938988f, 0.02465057f, 0.01847401f, 0.00419006f, 
    -0.00942933f, 0.02799163f, 0.02867583f, -0.03046986f, 0.01065135f, 0.01910537f, -0.01827555f, 0.02592206f, 
    0.02688056f, -0.01563923f, 0.00776926f, -0.01773153f, 0.01760071f, -0.01391639f, -0.03646517f, -0.01389399f, 
    -0.02920831f, -0.03296146f, 0.02636362f, -0.00869905f, 0.02334194f, -0.02988918f, 0.01434082f, -0.00251214f, 
    -0.00711496f, 0.02438924f, -0.03750239f, -0.00576288f, -0.03602164f, 0.02434155f, 0.03416670f, 0.02030826f, 
    0.00050297f, -0.00511026f, 0.02405646f, -0.03696932f, -0.01804533f, 0.01247911f, 0.00042368f, 0.02506797f, 
    -0.02730210f, -0.00450082f, -0.02688371f, 0.04187342f, -0.01160136f, -0.00700846f, -0.01994465f, -0.00679054f, 
    0.00286010f, -0.03317763f, -0.02328870f, -0.00802141f, 0.02726408f, 0.01488789f, 0.02874530f, 0.00754733f, 
    -0.03459790f, 0.01846793f, 0.02410201f, -0.00822327f, -0.01754719f, -0.03658080f, 0.00592220f, 0.02327341f, 
    -0.00397170f, 0.02944472f, -0.03899737f, -0.00562655f, 0.00982127f, 0.00174197f, -0.00063582f, 0.01755218f, 
    -0.03608045f, 0.00682429f, -0.02365370f, -0.02360551f, -0.03770148f, -0.02495727f, 0.02466434f, 0.01419052f, 
    0.00971055f, -0.00086859f, 0.02890206f, 0.00389527f, -0.01952106f, 0.02363956f, -0.00920033f, -0.02963061f, 
    0.00076111f, 0.02677426f, 0.01711793f, -0.03065866f, 0.01249666f, 0.00921279f, -0.03780795f, -0.00289237f, 
    -0.01534969f, 0.02809463f, -0.02644586f, 0.02107131f, 0.01081517f, 0.00529606f, 0.01596532f, -0.01516509f, 
    0.02847881f, -0.02341851f, 0.03040501f, 0.02014842f, -0.00634473f, 0.01791335f, -0.03477857f, 0.02811285f, 
    -0.01731588f, -0.03565809f, -0.01844127f, -0.03439455f, 0.00210044f, 0.02690984f, 0.01246336f, 0.00181629f, 
    -0.01825834f, -0.02346922f, -0.00258198f, -0.01511086f, 0.00828479f, 0.00371239f, -0.00640507f, 0.02759638f, 
    -0.00057595f, 0.02940571f, 0.01164846f, 0.00186825f, -0.03838663f, -0.02813467f, 0.00227708f, -0.00510536f, 
    -0.03423909f, 0.01059475f, -0.02054971f, 0.01111194f, -0.01625295f, 0.04034853f, 0.01575092f, -0.02498835f, 
    -0.00740784f, 0.00382332f, -0.00274896f, 0.00766650f, 0.00325776f, -0.02200586f, -0.02384417f, -0.00949642f, 
    -0.03505834f, -0.04146594f, -0.03310649f, -0.03762149f, -0.02092803f, 0.02354581f, 0.00972226f, 0.02092002f, 
    0.00334492f, 0.00492681f, -0.02077611f, -0.02352557f, -0.03254020f, 0.02931213f, 0.00210466f, 0.00168039f, 
    0.00040566f, -0.00830618f, -0.02130373f, 0.00746335f, 0.00761952f, 0.01436993f, 0.02976455f, -0.02325112f, 
    -0.00721366f, 0.02269280f, -0.04099208f, -0.00485215f, -0.03624956f, -0.03056963f, 0.02676879f, -0.02753207f, 
    0.02541979f, -0.03507984f, -0.03883282f, 0.01273366f, 0.02354795f, 0.02417558f, 0.03119864f, -0.01730353f, 
    -0.01338547f, -0.00211057f, -0.03298275f, 0.01914040f, 0.00148392f, -0.01105193f, 0.00994979f, -0.02720493f, 
    -0.02068320f, 0.01821831f, -0.03695652f, -0.03793940f, -0.01702221f, -0.03284555f, -0.04154008f, 0.01049891f, 
    0.02565957f, 0.02087546f, -0.00887612f, -0.00250117f, 0.01860464f, 0.01244133f, 0.00590652f, -0.03073450f, 
    -0.02165880f, -0.03360334f, -0.00370762f, 0.00864119f, -0.01180738f, -0.00920580f, -0.02845635f, -0.00983778f, 
    -0.04030546f, -0.03253503f, 0.01584696f, -0.01164695f, -0.00130982f, -0.03550477f, 0.02147703f, 0.01374342f, 
    0.01583657f, 0.00193944f, -0.00462321f, -0.01994716f, 0.01804343f, 0.02128613f, 0.01127627f, -0.01165108f, 
    -0.01483778f, 0.00625738f, -0.00700327f, -0.00418442f, 0.01697673f, -0.00087585f, 0.01509028f, 0.01798708f, 
    0.02487413f, 0.01244266f, 0.00882374f, 0.02508446f, 0.00595397f, -0.00606683f, -0.03297869f, 0.02521732f, 
    -0.03103439f, 0.02785398f, -0.01641374f, 0.02976623f, 0.02086338f, 0.02517053f, -0.03576883f, 0.01356607f, 
    -0.03657487f, 0.02235876f, 0.02510055f, -0.03578014f, -0.03469611f, -0.01071350f, 0.03147877f, -0.03726224f, 
    -0.01738425f, -0.00764277f, -0.00757431f, -0.03212604f, -0.00967235f, -0.01673299f, -0.01463068f, 0.00364799f, 
    0.00256928f, -0.04027783f, -0.01215386f, 0.00173414f, -0.00542129f, -0.03486317f, 0.00992438f, -0.01086424f, 
    0.01844852f, -0.03979448f, 0.02078946f, 0.01472111f, -0.01347188f, -0.02486220f, 0.00378790f, -0.03544107f, 
    -0.03014456f, 0.02347809f, -0.00863465f, -0.00036486f, -0.00196729f, 0.00663932f, 0.01019916f, 0.00526656f, 
    -0.02269666f, 0.01094284f, 0.00075462f, -0.03950348f, -0.01093353f, 0.03138152f, 0.02657016f, 0.01058928f, 
    0.02964239f, -0.01477297f, 0.00221621f, -0.00603640f, -0.04057353f, -0.01535639f, -0.03436136f, 0.01832832f, 
    -0.02349361f, 0.00814615f, -0.03457797f, -0.02265065f, -0.01165655f, -0.01922933f, 0.02652436f, 0.01722529f, 
    -0.00572959f, 0.02604604f, 0.01930002f, 0.00185830f, -0.00952272f, -0.02396021f, 0.00088892f, -0.03010266f, 
    0.00678240f, 0.00351038f, -0.00283718f, -0.03159804f, -0.02267218f, 0.02975276f, -0.01997804f, -0.00932945f, 
    -0.02613138f, -0.02589296f, -0.01493095f, -0.02522027f, 0.01554006f, -0.00039557f, -0.03605400f, 0.00269480f, 
    0.01886559f, 0.01631176f, 0.02606251f, 0.00024090f, 0.00409336f, 0.00343444f, -0.00212994f, 0.02713323f, 
    -0.01238214f, 0.02457120f, -0.03617629f, 0.01707617f, 0.01228765f, -0.02928549f, 0.01187773f, -0.04207047f, 
    0.01027473f, 0.01279970f, -0.02498631f, -0.04158824f, 0.02250552f, -0.01050163f, -0.01329042f, 0.02700848f, 
    -0.02953400f, -0.02936835f, 0.01849259f, 0.02946560f, -0.00726988f, -0.03770732f, -0.02968119f, 0.02661215f, 
    0.00988633f, -0.02287042f, 0.01327993f, 0.00956964f, 0.01952777f, -0.00481991f, -0.00357300f, -0.00975866f, 
    0.02837927f, -0.00651999f, -0.02713267f, -0.03955927f, -0.02463615f, -0.00891555f, 0.00232828f, -0.03526491f, 
    0.01493869f, -0.03728590f, 0.01353972f, -0.03670653f, 0.01371436f, 0.02624223f, -0.02435371f, 0.02150832f, 
    0.01062494f, -0.00197391f, 0.02200754f, 0.01567771f, -0.02260129f, 0.02782096f, 0.01650077f, -0.01212323f, 
    -0.00098387f, 0.02966297f, 0.02333235f, 0.01204717f, -0.02844215f, 0.00665519f, -0.01332104f, -0.01605117f, 
    -0.03747342f, -0.01376086f, 0.00101847f, 0.00987248f, -0.03853953f, 0.00774428f, -0.02250608f, -0.03696548f, 
    0.16671871f, 0.28024873f, 0.26596895f, -0.12285370f, -0.04152470f, -0.05660722f, -0.02356556f, 0.11945304f, 
    0.04324775f, 0.00771424f, 0.14238131f, 0.04679035f, -0.20120189f, -0.14516215f, -0.21671385f, -0.02176143f, 
    0.00614208f, 0.04905733f, 0.00423760f, 0.02931201f, 0.11887564f, -0.06881473f, -0.01799770f, 0.02262251f, 
    0.27000889f, -0.39832473f, 0.17126611f, -0.03881598f, -0.02785451f, -0.02193319f, -0.04539217f, 0.12827674f, 
    0.07005821f, -0.11469077f, 0.20553949f, 0.05964562f, -0.61856258f, -0.03645396f, -0.02114606f, 0.11427065f, 
    0.10296513f, -0.03252217f, -0.00863916f, 0.06305046f, 0.17393428f, 0.01913846f, 0.00634361f, -0.01206441f, 
    -0.01843715f, -0.02472260f, 0.03693441f, 0.16256432f, -0.05394744f, -0.06076865f, -0.04994618f, -0.01853275f, 
    0.16866139f, 0.21902770f, 0.15540177f, 0.08820532f, 0.00173808f, 0.22861303f, -0.34562701f, 0.02844356f, 
    0.04669341f, 0.11247931f, 0.16215198f, 0.13094860f, 0.05457600f, 0.02697365f, 0.02561706f, 0.03900348f, 
    0.22449723f, 0.10135324f, -0.06293411f, 0.21921237f, 0.04762254f, -0.06286563f, 0.00289734f, 0.14089184f, 
    0.06092876f, -0.06054638f, -0.01215608f, 0.03557744f, -0.12099567f, 0.18361627f, -0.03968208f, -0.06079965f, 
    -0.02398372f, -0.02316934f, 0.12085443f, 0.04615860f, 0.21285586f, -0.12340220f, 0.07531216f, -0.09017869f, 
    0.01931419f, 0.08195920f, 0.05483493f, -0.05837674f, -0.06253736f, -0.01990333f, 0.07233142f, 0.09709815f, 
    -0.05445486f, 0.00398134f, 0.04368789f, 0.12772526f, -0.14886683f, 0.05015999f, 0.00329559f, -0.05010978f, 
    0.13181791f, -0.03494795f, -0.12920290f, 0.10069271f, -0.03821963f, -0.13978131f, -0.07451541f, 0.34811905f, 
    0.13066635f, 0.01082545f, -0.12179329f, -0.24122792f, 0.06992370f, -0.14505097f, -0.01534881f, 0.05615412f, 
    -0.09066582f, -0.08279341f, -0.03720379f, 0.12255087f, -0.02722698f, -0.16989924f, 0.03713453f, 0.11861651f, 
    0.16908371f, 0.01901099f, 0.15517838f, 0.01833693f, -0.01745375f, -0.02346113f, 0.08898608f, 0.05038536f, 
    0.02435700f, -0.20166558f, -0.04203369f, -0.02519441f, 0.04999771f, -0.06049079f, 0.02222067f, -0.04232664f, 
    0.14741036f, -0.02586438f, -0.03987420f, 0.04875991f, -0.11528239f, -0.04546129f, -0.25102562f, -0.08012621f, 
    0.01074902f, 0.06088863f, 0.00776959f, -0.14312692f, 0.10457721f, -0.06259626f, 0.09073303f, 0.00673441f, 
    0.25408471f, 0.05033969f, 0.33636162f, -0.18746127f, 0.01662758f, -0.01847317f, 0.04899597f, -0.07265049f, 
    0.10153012f, 0.06235485f, 0.13691290f, -0.00929716f, 0.10998333f, -0.08305768f, 0.10297673f, 0.10884891f, 
    0.03039301f, -0.07163920f, -0.03146256f, -0.04926015f, -0.06196227f, -0.10015195f, -0.08156338f, 0.26215327f, 
    -0.00235424f, 0.05208962f, -0.05149566f, -0.08694652f, 0.05525355f, -0.02292096f, 0.03578990f, 0.03256620f, 
    -0.14574982f, -0.02451399f, 0.11651883f, -0.04686047f, 0.10561296f, -0.26977926f, 0.13907449f, 0.37949678f, 
    -0.12095654f, -0.02853264f, 0.00077418f, 0.03684327f, 0.16110386f, -0.13057189f, 0.07515089f, 0.07866113f, 
    -0.42636541f, 0.01975028f, -0.14167395f, -0.22367804f, -0.01614146f, 0.15424883f, 0.03685314f, -0.02086890f, 
    0.20292650f, 0.01399786f, 0.00764545f, 0.00831018f, -0.11045475f, -0.20075527f, 0.10339925f, 0.04266156f, 
    0.05999139f, -0.04640777f, -0.14933246f, 0.07548831f, 0.06050506f, -0.05387101f, 0.06755500f, 0.04789060f, 
    -0.37029511f, 0.09412787f, -0.17318718f, 0.09747431f, 0.33580986f, 0.05320939f, -0.04743129f, 0.05027774f, 
    0.13321310f, -0.09204081f, 0.12160423f, 0.22859208f, -0.26584083f, -0.00250557f, 0.11129502f, -0.16602947f, 
    -0.03517517f, -0.01176582f, 0.05567075f, -0.07579370f, 0.23864464f, 0.01722899f, 0.01844013f, -0.04496305f, 
    -0.01653445f, 0.07428828f, 0.02273352f, 0.02173621f, -0.05456528f, 0.13370961f, -0.08744554f, 0.04723993f, 
    0.14435725f, -0.07507852f, 0.01146712f, -0.07769264f, 0.06739658f, -0.18760900f, -0.22042285f, 0.17218918f, 
    0.08247511f, 0.11681387f, -0.05378587f, 0.07253055f, 0.03520968f, 0.06284913f, 0.00224766f, 0.07379238f, 
    0.13300370f, -0.05914355f, 0.18365301f, 0.11897723f, 0.03449411f, -0.01690810f, -0.09289382f, 0.08757084f, 
    0.08599089f, -0.00628823f, 0.23110077f, 0.00728063f, 0.12147650f, -0.02809299f, 0.04212470f, 0.18029633f, 
    0.18538581f, 0.10240344f, 0.09031308f, 0.09901593f, -0.06958497f, -0.07696345f, -0.05393250f, 0.01767285f, 
    0.00065120f, -0.07633827f, 0.01386466f, -0.02313016f, -0.03903071f, 0.13220148f, -0.01522107f, 0.04115644f, 
    -0.00982164f, -0.00112415f, 0.15417519f, -0.07408315f, 0.15919888f, -0.06291392f, 0.13910982f, -0.11274642f, 
    -0.04827231f, -0.05878226f, 0.12121531f, 0.01413333f, 0.14669305f, -0.14029221f, -0.06545202f, -0.04421920f, 
    0.12394121f, 0.15414718f, 0.25958475f, -0.22024104f, -0.02901283f, -0.07974009f, -0.03295720f, 0.02284690f, 
    0.00493347f, -0.03263640f, 0.07190157f, -0.05346941f, -0.03016693f, 0.12905303f, 0.02769618f, -0.26941904f, 
    0.03344890f, 0.02885247f, -0.07910071f, 0.04654415f, -0.05248458f, 0.02593632f, -0.03901581f, -0.12031294f, 
    0.11089864f, 0.14346141f, -0.01288696f, -0.01200351f, 0.02574345f, -0.06850722f, -0.03521103f, -0.15100239f, 
    0.13455349f, -0.05235809f, 0.01126874f, 0.07979460f, 0.13538221f, -0.10803292f, -0.22687949f, -0.04288655f, 
    -0.07790775f, 0.05861583f, 0.21702334f, 0.13499841f, 0.12095751f, 0.04403049f, 0.22317657f, -0.09139366f, 
    0.27356184f, -0.15901336f, 0.04763405f, -0.16165337f, 0.07741199f, 0.07533070f, -0.08433202f, -0.03193746f, 
    0.06805469f, 0.05117276f, 0.14422935f, -0.03404725f, 0.14284895f, -0.08533145f, 0.08634492f, 0.01615134f, 
    0.14856988f, 0.01325956f, -0.03535863f, 0.06747457f, 0.04637652f, 0.01717789f, 0.00690782f, 0.04024433f, 
    0.10309170f, 0.05259619f, -0.18541907f, -0.09752362f, 0.22782522f, 0.29885560f, 0.06288845f, 0.08838455f, 
    0.01255282f, -0.00429814f, 0.02240529f, -0.03499153f, 0.42469466f, -0.14877716f, 0.06141623f, 0.22734603f, 
    0.14520028f, 0.00589679f, 0.04495812f, 0.10232183f, 0.00657150f, -0.05224320f, -0.04778948f, 0.03751568f, 
    -0.47454345f, 0.11114042f, -0.15611655f, -0.30083108f, -0.14141114f, 0.12686355f, -0.06694632f, 0.12177063f, 
    0.10232558f, -0.09154908f, -0.01136023f, -0.07510792f, 0.01380181f, -0.11312878f, 0.18381508f, -0.12600273f, 
    -0.01286291f, 0.16161081f, -0.00691476f, 0.00956621f, 0.10112111f, 0.01177606f, 0.00530392f, -0.03680968f, 
    0.16180573f, 0.04892970f, 0.13582338f, -0.08658331f, -0.02043075f, -0.11333068f, -0.01670844f, 0.08666855f, 
    -0.01717010f, -0.08533904f, 0.13142119f, 0.08593329f, 0.09917822f, 0.04931933f, -0.05238819f, -0.03239948f, 
    0.06514559f, 0.05592571f, 0.16168720f, -0.05453577f, -0.02866675f, 0.00504761f, -0.02775664f, -0.00548924f, 
    -0.11646042f, -0.10440974f, -0.22049466f, 0.02850112f, 0.01472824f, 0.17114818f, -0.04062015f, -0.02043967f, 
    0.02420297f, -0.06090472f, 0.04435196f, 0.08137549f, -0.27193722f, -0.08761505f, 0.00187807f, -0.10968586f, 
    -0.06759344f, -0.01753787f, -0.05149797f, 0.04350589f, 0.16983578f, 0.11394670f, -0.04604438f, -0.05241226f, 
    -0.03225027f, 0.00624179f, 0.08436517f, 0.01516175f, 0.04321880f, 0.06797160f, -0.03630425f, 0.00295439f, 
    -0.04334920f, 0.06442131f, 0.07707225f, 0.04379708f, -0.10865043f, -0.42538914f, -0.02794620f, 0.06544843f, 
    -0.02902016f, -0.12956388f, 0.04941013f, 0.03092278f, 0.19569454f, -0.12330016f, -0.07289495f, -0.08219369f, 
    0.22851732f, -0.22325635f, 0.15456335f, 0.12116722f, 0.22280233f, -0.13063973f, 0.00643070f, 0.06823160f, 
    0.15166999f, -0.12662904f, 0.05961747f, 0.03541689f, 0.21914607f, -0.20830338f, 0.23918664f, 0.15521137f, 
    0.03886020f, -0.05198631f, 0.03756224f, 0.04185575f, 0.21937619f, 0.01258574f, 0.15655832f, 0.06518935f, 
    0.13997678f, 0.07823603f, 0.02961258f, -0.17372057f, 0.13778314f, 0.08077590f, 0.05829105f, -0.00804108f, 
    0.10091326f, 0.01673123f, -0.01432079f, 0.01933091f, 0.05724769f, 0.08441065f, 0.03275264f, -0.15678363f, 
    0.05562199f, -0.05932104f, -0.05228267f, 0.07567015f, 0.15216273f, -0.04356643f, -0.04761811f, 0.05915358f, 
    0.01568388f, -0.28110057f, 0.16783588f, -0.08599949f, 0.01874259f, -0.03258579f, 0.11154609f, 0.11547317f, 
    0.25923717f, -0.07403216f, -0.10348705f, 0.11641429f, 0.15166192f, -0.20416182f, 0.04243963f, -0.22841147f, 
    -0.01775614f, 0.04946531f, -0.01691507f, 0.00947130f, 0.05831067f, 0.05667801f, 0.12233730f, -0.13142459f, 
    -0.02334179f, -0.00164236f, -0.11504168f, -0.17817549f, -0.02595016f, 0.15078977f, 0.13477392f, -0.13233668f, 
    0.02986059f, 0.06168553f, -0.08019159f, 0.02800026f, 0.32270023f, 0.06141813f, -0.24459872f, 0.10422695f, 
    -0.07617979f, -0.13944948f, 0.07103261f, 0.19003659f, 0.08685442f, -0.02443595f, 0.01457734f, -0.00663069f, 
    0.06815187f, -0.67999411f, 0.37100902f, -0.14495935f, -0.04757839f, -0.09427310f, 0.04453828f, -0.03843720f, 
    -0.01523229f, 0.06587987f, 0.07859419f, 0.12269296f, 0.07316972f, -0.42346579f, 0.32857218f, 0.31048709f, 
    0.11223414f, 0.06251146f, 0.03925883f, 0.02090253f, -0.13392985f, 0.03427132f, -0.02712510f, 0.16436589f, 
    -0.04039595f, 0.13937896f, -0.30047199f, -0.17390925f, 0.08551647f, -0.11582510f, 0.04070627f, 0.08190275f, 
    -0.00976809f, -0.08175834f, -0.17026353f, 0.05519613f, 0.17353493f, -0.14497183f, -0.00987597f, 0.12935737f, 
    -0.08443430f, 0.04246284f, 0.08603661f, -0.09724254f, 0.07931706f, -0.21065356f, -0.03199608f, 0.00387726f, 
    0.24215794f, -0.00852700f, 0.10347111f, -0.08491788f, 0.04684121f, -0.03688929f, -0.03389238f, 0.07373616f, 
    0.02087929f, -0.07589983f, -0.10421609f, 0.06545355f, 0.02803540f, 0.03331003f, 0.07897530f, -0.03661357f, 
    0.22020248f, 0.01022601f, -0.07561462f, 0.10107404f, 0.00641377f, 0.03843707f, -0.09248310f, 0.03455520f, 
    -0.04229911f, -0.09678870f, -0.10306302f, 0.06908193f, 0.13057588f, 0.02639327f, 0.11686949f, 0.00830773f, 
    -0.08224393f, -0.10897576f, -0.18523648f, -0.18939260f, 0.25491723f, -0.30436361f, -0.16549253f, -0.14020988f, 
    -0.00966012f, -0.02212223f, 0.01347583f, -0.07965686f, 0.11612284f, -0.18732192f, 0.06591234f, -0.11197945f, 
    -0.11589862f, -0.19045796f, 0.24711643f, -0.11760593f, -0.04226094f, 0.06114679f, 0.03327628f, -0.09264243f, 
    0.20997870f, -0.02845250f, -0.09298062f, -0.10571294f, 0.31978479f, 0.07220671f, 0.20631193f, -0.25076216f, 
    0.08288646f, 0.02665308f, -0.00731914f, -0.00191452f, -0.02884501f, 0.05404271f, 0.09901449f, 0.04391827f, 
    0.05764366f, -0.09192347f, -0.10985720f, -0.09071764f, -0.03190894f, 0.08199472f, -0.13564728f, 0.00195743f, 
    0.19126774f, -0.09821668f, 0.26956692f, 0.03737043f, -0.25335303f, 0.38461581f, -0.11649710f, -0.19911730f, 
    0.06344124f, -0.02807091f, 0.07220104f, -0.09860381f, 0.16755559f, 0.01291063f, -0.03260609f, 0.02687186f, 
    0.20385019f, 0.21248893f, -0.04062888f, -0.04123068f, 0.09109762f, -0.11900808f, -0.04008687f, 0.02470808f, 
    0.08236214f, 0.00600955f, -0.00063658f, 0.00201271f, 0.14885256f, -0.19423884f, -0.25653353f, -0.10355534f, 
    -0.12554294f, 0.10509452f, 0.12172718f, -0.01241652f, -0.08952053f, -0.15965992f, 0.00554467f, -0.07569234f, 
    0.20702772f, -0.36959529f, -0.13985799f, -0.07311808f, -0.08220366f, -0.02208053f, -0.04622765f, 0.09676079f, 
    0.09251709f, 0.03121178f, 0.04482280f, 0.03573266f, -0.53135622f, 0.00965329f, 0.04533097f, -0.13646732f, 
    -0.15661198f, 0.14777708f, 0.03488444f, -0.00384776f, 0.09560069f, -0.04319920f, 0.01795782f, 0.05579611f, 
    -0.21533462f, -0.08777371f, 0.10578154f, -0.01646698f, -0.06322638f, 0.02466774f, -0.05715835f, 0.05026738f, 
    0.06159319f, 0.11125638f, -0.11341378f, -0.01024177f, -0.12567101f, 0.14260903f, 0.10530874f, 0.03683985f, 
    0.06110373f, -0.06929883f, -0.02217992f, 0.07247189f, 0.03186116f, 0.09577743f, -0.26333445f, 0.03392174f, 
    0.16563965f, -0.15426560f, -0.20233853f, 0.12716909f, -0.08357104f, -0.23901463f, 0.38271794f, -0.19661890f, 
    0.33031261f, 0.12504268f, 0.21232922f, -0.03073776f, 0.13532205f, -0.00757935f, 0.06372764f, 0.05273113f, 
    0.05252297f, 0.03870628f, -0.09055194f, -0.11740739f, 0.04922803f, 0.08198835f, -0.02538805f, -0.05913471f, 
    0.01267009f, -0.26504487f, -0.23095645f, -0.00899286f, -0.11364295f, 0.01353087f, 0.05724650f, 0.02422735f, 
    -0.02983150f, -0.03789525f, 0.05084617f, 0.05593968f, 0.11068121f, 0.14695220f, -0.04075047f, 0.11638180f, 
    0.16219424f, 0.03312749f, -0.10985948f, -0.12979136f, 0.09134001f, 0.00262002f, -0.28469700f, 0.21778952f, 
    0.30464932f, 0.16221841f, 0.09156298f, -0.01837480f, 0.03315077f, 0.01221298f, -0.10353436f, -0.05212948f, 
    -0.02793714f, -0.03154450f, -0.06106987f, 0.10150109f, 0.06738717f, 0.03955014f, 0.18134242f, 0.02526675f, 
    -0.00447263f, -0.03021736f, 0.00514689f, -0.02562298f, 0.10304456f, 0.01203298f, -0.02427290f, -0.00639660f, 
    -0.04551439f, -0.00720417f, 0.05257174f, 0.05321011f, 0.11964222f, 0.04141410f, 0.06787633f, -0.02275369f, 
    -0.08708894f, -0.03757155f, -0.05648765f, -0.01709472f, -0.10128720f, -0.35081863f, -0.33943683f, -0.05572368f, 
    -0.08335809f, 0.03453107f, -0.06587028f, -0.03294798f, 0.05316159f, -0.01626087f, -0.08779888f, -0.03348441f, 
    0.25935033f, 0.10095929f, 0.03112916f, -0.16255006f, 0.02522465f, -0.14610049f, 0.21786001f, -0.00242271f, 
    0.07482722f, 0.05463768f, -0.01585255f, -0.06173918f, 0.07371283f, 0.08364846f, 0.08098818f, -0.02838520f, 
    0.00842813f, 0.03935910f, -0.02484589f, 0.05288183f, 0.02061950f, 0.03214010f, 0.05966308f, 0.06352508f, 
    -0.02890504f, 0.07369271f, -0.04149057f, -0.09703401f, 0.04466328f, -0.02669346f, 0.05734507f, 0.09765986f, 
    0.00167529f, -0.01855060f, -0.00101690f, 0.01220823f, 0.13487126f, -0.00393854f, 0.00246379f, 0.03142050f, 
    -0.11606076f, 0.05289131f, 0.00994512f, 0.02886687f, 0.11404354f, -0.01944582f, -0.00472502f, 0.11430109f, 
    -0.35484377f, 0.09415746f, -0.20690924f, -0.06052619f, 0.06161685f, 0.23535232f, -0.03285654f, 0.14079946f, 
    -0.09822380f, -0.01659185f, -0.08849870f, -0.09734584f, -0.14633217f, -0.13273926f, 0.08908173f, -0.04565473f, 
    0.24064758f, 0.17124656f, 0.00738199f, 0.02947143f, -0.01429229f, -0.05340671f, 0.11654888f, 0.09088487f, 
    -0.17973010f, 0.08824385f, -0.13576481f, 0.09573027f, 0.01945530f, 0.03711426f, 0.00207734f, 0.02770398f, 
    0.05260110f, 0.11172760f, 0.08461226f, 0.10116782f, -0.09949148f, -0.10034448f, -0.26716244f, -0.13812843f, 
    -0.01079553f, 0.05984059f, 0.01266615f, 0.07563702f, -0.03218033f, -0.01648841f, -0.10929166f, -0.07728520f, 
    0.10609759f, 0.06927853f, 0.01623731f, 0.19130135f, -0.01809024f, 0.02165140f, -0.10177547f, -0.01028514f, 
    -0.12803775f, 0.13816698f, -0.14477678f, 0.19460721f, 0.03163156f, -0.14237465f, -0.11426337f, -0.12174428f, 
    -0.00620129f, 0.10991529f, 0.12570950f, 0.14752260f, 0.08439334f, -0.14808020f, -0.20393386f, 0.11573035f, 
    0.10387468f, 0.10560891f, 0.04106748f, -0.17584312f, -0.00146205f, 0.01317225f, 0.02930917f, 0.01756022f, 
    0.02086697f, 0.05024178f, 0.28325546f, 0.10133031f, 0.19390723f, 0.28910953f, 0.09827516f, 0.06552971f, 
    -0.10149693f, -0.11823195f, -0.01322966f, -0.04734537f, -0.04635078f, 0.02180521f, 0.11936358f, 0.03812884f, 
    -0.11883329f, -0.03739860f, 0.11900188f, -0.02755591f, -0.02629256f, 0.22467652f, 0.04210505f, 0.11788646f, 
    -0.10765345f, -0.01749995f, 0.15000032f, -0.00343060f, 0.21605375f, -0.09183751f, 0.14134152f, -0.08382501f, 
    0.15338814f, 0.03434212f, 0.16881289f, -0.00160648f, 0.01642341f, 0.05317757f, -0.01807566f, -0.11138012f, 
    0.12975088f, 0.06407504f, -0.07341945f, -0.03100515f, -0.00041938f, 0.07619442f, -0.17009081f, -0.03292004f, 
    0.01415639f, -0.01278026f, -0.01969792f, 0.05456996f, -0.08919267f, -0.04046856f, -0.15455271f, -0.06798089f, 
    0.14459987f, 0.15696101f, 0.18971756f, 0.16023400f, -0.11339368f, 0.13827643f, 0.07048079f, 0.01550990f, 
    0.05711960f, 0.06840152f, -0.06345015f, -0.01289010f, 0.04381499f, 0.04829670f, -0.07044250f, -0.10557207f, 
    -0.04783110f, 0.00497856f, -0.10749555f, 0.08355644f, 0.13698792f, -0.20687276f, -0.35073280f, 0.08292492f, 
    -0.13226473f, 0.04757765f, 0.25024140f, -0.00969061f, 0.03227502f, -0.07404937f, 0.12122317f, -0.04368624f, 
    0.08597741f, -0.21549040f, -0.12015651f, -0.01362501f, 0.04392352f, -0.00852996f, -0.08739097f, 0.06372672f, 
    0.03717548f, 0.11196265f, 0.07541312f, -0.10151336f, 0.06721855f, 0.29516381f, 0.20117991f, -0.02534862f, 
    -0.02947873f, -0.10216498f, -0.00556644f, 0.02268889f, -0.02986297f, -0.05342936f, 0.01277287f, 0.08692557f, 
    0.08083464f, 0.20536156f, -0.18060863f, -0.05068722f, -0.15802389f, -0.27696460f, 0.02415690f, -0.06704309f, 
    -0.09419747f, 0.02808448f, -0.00822512f, 0.04431064f, 0.06037504f, 0.01398162f, 0.22873548f, 0.02912273f, 
    0.01496719f, -0.06666107f, -0.01655222f, 0.00470397f, 0.00713058f, -0.05970908f, 0.06532384f, 0.08209085f, 
    -0.52411449f, 0.07707924f, 0.11471560f, -0.15155555f, -0.02590017f, 0.13741601f, -0.06006937f, -0.00771876f, 
    0.01025948f, -0.00348568f, -0.07852550f, -0.18324599f, -0.03292319f, 0.08448225f, 0.19481902f, -0.26729959f, 
    0.00920316f, -0.03350948f, -0.00908453f, 0.01125408f, -0.07419730f, 0.00772924f, 0.10096142f, -0.00721010f, 
    0.21859558f, 0.05591028f, 0.05803144f, -0.10236228f, 0.12744592f, -0.06518959f, -0.05419559f, -0.00754365f, 
    0.07821207f, 0.01169748f, -0.07273749f, 0.03984416f, 0.04776578f, 0.10624501f, -0.27490366f, -0.38268259f, 
    -0.15856786f, -0.15329649f, -0.11821353f, 0.09319463f, -0.14324418f, -0.02534838f, 0.03452700f, -0.02063073f, 
    0.13472065f, 0.03248148f, -0.12368125f, 0.17462392f, 0.02011642f, -0.06884376f, -0.15012401f, 0.08587725f, 
    0.02688066f, 0.01891861f, 0.04861072f, 0.13889517f, -0.04275625f, -0.10556515f, -0.27160025f, -0.10444683f, 
    -0.12787190f, 0.06695049f, -0.12396421f, 0.09072956f, 0.08326092f, -0.11496489f, -0.05865715f, -0.06111847f, 
    0.08103693f, 0.06307203f, 0.19270608f, -0.01364978f, -0.02215845f, -0.01801340f, 0.06198860f, -0.02140698f, 
    -0.01631633f, 0.11554733f, 0.04108633f, 0.22082369f, 0.54861683f, -0.12742516f, -0.09974019f, -0.03581987f, 
    -0.07567438f, -0.08803345f, 0.01707346f, -0.03402807f, 0.14084777f, 0.04273323f, -0.08387275f, 0.11208364f, 
    0.12923186f, -0.00285767f, -0.10594699f, -0.28323513f, 0.14868271f, -0.06905508f, 0.12686406f, -0.08142088f, 
    0.06579281f, 0.02360084f, -0.09805948f, 0.06884696f, 0.13939495f, 0.00212952f, 0.04265476f, -0.03902603f, 
    -0.03027304f, 0.07848506f, 0.06976452f, 0.01373654f, -0.12142791f, -0.00011089f, 0.02972556f, -0.05964644f, 
    0.14687245f, 0.02376410f, -0.02091870f, -0.03594051f, 0.01391944f, 0.00485709f, 0.20385092f, 0.09727648f, 
    -0.17618683f, -0.04678415f, 0.03967419f, -0.05379103f, -0.03985143f, 0.03061911f, 0.19338454f, -0.08778234f, 
    0.12548999f, 0.07139278f, -0.12658657f, 0.06228159f, 0.14544061f, -0.07502319f, 0.13840188f, -0.08911347f, 
    0.12386108f, 0.13721073f, -0.04709364f, -0.11432312f, 0.10299954f, -0.00513932f, 0.24246964f, 0.04004245f, 
    0.08973667f, 0.06013951f, -0.12747602f, 0.08563856f, 0.14062925f, -0.04895489f, -0.02353957f, -0.23139405f, 
    0.05145721f, -0.01428423f, 0.09997211f, 0.01393390f, 0.08541479f, 0.07129900f, -0.00324561f, 0.04365438f, 
    0.16093896f, -0.12582874f, -0.09723735f, -0.01494261f, 0.02793794f, -0.00178785f, 0.21329783f, 0.02947962f, 
    0.01660832f, -0.02388264f, 0.12900524f, -0.01893178f, 0.09080083f, 0.16576655f, 0.18347171f, 0.05342474f, 
    -0.02725134f, 0.00003506f, 0.07978345f, 0.07096698f, -0.03916445f, -0.07963696f, 0.17319199f, -0.09999049f, 
    0.47735858f, -0.27612606f, -0.01056672f, 0.10319835f, -0.06256999f, 0.02848001f, -0.02936408f, -0.11070285f, 
    0.02115057f, 0.14907341f, -0.10127475f, -0.09577543f, -0.04418177f, -0.12548326f, 0.29778087f, 0.11080772f, 
    0.07358288f, -0.01035505f, 0.15080354f, -0.09481192f, 0.15046027f, 0.13324219f, 0.07866487f, 0.10874053f, 
    0.29185250f, -0.02845957f, -0.02084283f, 0.08667430f, -0.03035861f, -0.03351163f, -0.01072095f, 0.02528116f, 
    0.05851743f, -0.09847263f, -0.06383312f, 0.09535716f, -0.00800185f, -0.06370863f, 0.03862169f, 0.08259775f, 
    -0.02575521f, 0.08753136f, 0.00197265f, 0.04193730f, 0.09744375f, 0.03479073f, -0.05990331f, 0.08231085f, 
    0.27392390f, 0.03942630f, 0.12950166f, -0.08289076f, 0.07314026f, -0.10408048f, 0.01774396f, -0.06221965f, 
    0.03856124f, -0.05737082f, -0.00651776f, 0.07773481f, -0.05993696f, 0.15034749f, 0.18393111f, 0.01181831f, 
    0.09941468f, -0.09305125f, -0.09653115f, -0.00885949f, -0.17304622f, 0.02362127f, 0.01345029f, -0.03696762f, 
    -0.10374613f, -0.07914592f, -0.04873260f, 0.07919853f, 0.01409868f, 0.02372556f, -0.03439645f, -0.02177412f, 
    0.10161338f, -0.12412019f, -0.09029362f, 0.05570689f, 0.43738025f, -0.22730599f, -0.16163468f, 0.04858463f, 
    -0.07173514f, -0.10584450f, 0.40414745f, -0.01686954f, 0.24810858f, 0.02028910f, -0.00791484f, 0.08571580f, 
    -0.00848897f, -0.29701126f, -0.04127965f, 0.03316795f, 0.03806774f, -0.02699365f, -0.06138486f, 0.24430175f, 
    0.12648700f, -0.13136137f, -0.02917713f, 0.03608128f, 0.19941653f, 0.18112154f, 0.08279601f, -0.24479623f, 
    0.05181748f, -0.09698020f, 0.01836676f, 0.00887642f, 0.04717506f, 0.05293071f, 0.05020140f, 0.00379930f, 
    0.19613920f, -0.17211407f, -0.08566622f, -0.10539240f, -0.18586299f, 0.00262404f, 0.04911452f, 0.13390988f, 
    0.19982077f, -0.02392985f, -0.04431045f, -0.03426866f, -0.12781928f, 0.13494660f, -0.13618957f, 0.15302451f, 
    -0.02348400f, 0.10340738f, -0.05339706f, 0.05412830f, -0.04005085f, 0.09975462f, -0.03807142f, 0.07067680f, 
    -0.17506580f, -0.30134085f, -0.05819999f, 0.15182225f, 0.03708905f, 0.05783536f, 0.01006763f, 0.01052044f, 
    0.08809319f, 0.11860189f, 0.09397928f, 0.04748539f, 0.04632294f, 0.36214280f, 0.42502654f, 0.19042540f, 
    -0.14397012f, -0.18552037f, -0.09769513f, 0.09855038f, 0.14653660f, 0.09382614f, 0.06896821f, 0.15790442f, 
    0.19859172f, 0.45450017f, 0.24448419f, -0.00259890f, -0.05241520f, -0.12576558f, -0.10102256f, -0.06115467f, 
    -0.07748400f, 0.05191946f, 0.01100839f, 0.05141855f, 0.00539391f, 0.23012955f, 0.09644835f, 0.26327211f, 
    0.04393665f, -0.11008696f, -0.03714579f, -0.03383594f, 0.11228070f, 0.03565973f, 0.06931753f, 0.06592001f, 
    0.24456784f, 0.23438847f, 0.07213892f, 0.11391419f, 0.06066842f, -0.09555548f, 0.02681191f, -0.07290123f, 
    0.05076918f, -0.00598079f, 0.08700205f, 0.00372900f, 0.01133761f, 0.00050907f, -0.33855003f, -0.05717159f, 
    -0.08320078f, -0.03874185f, 0.00317305f, -0.08881930f, 0.00688048f, -0.08050842f, -0.00802191f, 0.05281703f, 
    -0.31367010f, -0.04432754f, 0.07887500f, 0.06042316f, 0.08600679f, 0.13596685f, -0.12847571f, 0.15450069f, 
    -0.07643239f, 0.03048480f, 0.07867026f, -0.12156748f, -0.25557157f, -0.14014396f, -0.01853237f, 0.14398807f, 
    0.06590402f, 0.04290648f, -0.08422843f, 0.01031052f, 0.10092752f, -0.02834231f, 0.09889532f, 0.11170213f, 
    -0.02207832f, 0.05861568f, 0.34660643f, 0.17103590f, 0.06483141f, -0.07495262f, -0.16100045f, -0.05549338f, 
    0.11743897f, 0.09712098f, 0.00031039f, 0.07657946f, 0.06440827f, -0.07007223f, -0.16098861f, -0.11365257f, 
    -0.08304177f, 0.01972395f, 0.06168611f, 0.10815109f, 0.15022735f, 0.10699990f, -0.01309006f, -0.14704728f, 
    -0.20918807f, -0.11106011f, 0.02147385f, -0.02111278f, 0.03420397f, 0.10037155f, 0.11690420f, 0.06486814f, 
    0.11554394f, 0.11255009f, 0.01960535f, -0.03114410f, -0.08323165f, 0.01782909f, 0.04063206f, 0.06149658f, 
    0.04860952f, -0.01065072f, -0.00326573f, 0.07127889f, -0.01445413f, 0.03121926f, 0.01071399f, 0.10143895f, 
    -0.09521975f, 0.01531491f, 0.02022891f, 0.07210336f, -0.11807029f, -0.06372818f, -0.04676193f, -0.07900778f, 
    -0.01458987f, -0.05524438f, 0.04610091f, -0.07551232f, 0.35030892f, 0.46410316f, 0.49844944f, 0.11151032f, 
    -0.08061898f, -0.23484528f, -0.12184852f, 0.01253739f, 0.00241659f, 0.13233666f, 0.07256468f, 0.12033790f, 
    -0.24147280f, -0.17760222f, 0.06557296f, 0.08860055f, 0.09705354f, 0.05958273f, -0.08157010f, 0.01644333f, 
    -0.00054638f, 0.08738773f, 0.14119335f, 0.05045275f, -0.01783670f, -0.05702345f, -0.12712130f, -0.10688718f, 
    0.04750628f, 0.04531958f, 0.00904747f, 0.06043458f, 0.17303979f, -0.07920034f, -0.13271880f, -0.20094933f, 
    0.01764102f, -0.06605060f, -0.05133162f, 0.01642953f, -0.07889974f, 0.06731462f, 0.04951598f, -0.01980129f, 
    0.08077756f, 0.08514130f, -0.05044364f, 0.14561990f, 0.13382465f, 0.08477838f, 0.26704603f, 0.16450691f, 
    -0.00560975f, -0.08045865f, -0.06660394f, -0.04397538f, 0.03671138f, 0.04992802f, -0.00398881f, -0.09970665f, 
    0.13731688f, 0.13271822f, 0.25543401f, -0.07128792f, -0.11099182f, -0.29033959f, -0.04198587f, 0.01055145f, 
    0.03861565f, -0.03540519f, -0.00912300f, -0.09021641f, 0.20797452f, -0.07265019f, -0.03954514f, 0.07848033f, 
    -0.08923989f, 0.04532517f, 0.03269908f, 0.06447531f, -0.09459578f, -0.11691874f, -0.06405234f, -0.11101849f, 
    -0.09067056f, 0.11236761f, 0.00779277f, -0.02288976f, 0.16531403f, -0.06132837f, 0.02497857f, 0.02172828f, 
    -0.07683096f, -0.07721172f, -0.06166932f, -0.12332463f, 0.20270048f, 0.24154471f, 0.41434458f, 0.12992439f, 
    -0.10141847f, -0.14624222f, -0.13859402f, 0.00910027f, 0.11952896f, 0.02150550f, 0.06471523f, 0.09398668f, 
    0.10109937f, -0.15402824f, 0.10525040f, -0.16303369f, 0.09797987f, -0.05264930f, 0.00157247f, 0.19353315f, 
    0.07675572f, -0.16982548f, 0.03183466f, -0.14794606f, -0.08475901f, -0.06074567f, 0.06286701f, 0.19974695f, 
    0.01532001f, -0.02665442f, -0.05083221f, 0.06302334f, 0.05225218f, 0.09568535f, 0.09836613f, 0.09310371f, 
    -0.02444624f, -0.11579574f, 0.04277620f, 0.14463548f, 0.01167402f, 0.13523975f, -0.02561581f, -0.04135927f, 
    0.01480978f, 0.06537106f, -0.03221835f, 0.19326667f, -0.03775197f, -0.35814232f, -0.11888074f, -0.00108118f, 
    0.06685732f, 0.16417232f, 0.04277518f, -0.06111472f, -0.06812004f, -0.03975597f, -0.07717844f, -0.03572410f, 
    0.20345621f, 0.13211793f, -0.10620353f, -0.06316295f, 0.04058111f, -0.00805646f, 0.07537524f, -0.00950703f, 
    0.00489118f, -0.01371662f, -0.17917831f, -0.02812226f, -0.12816952f, 0.08031030f, -0.01666613f, 0.08306047f, 
    0.10188457f, 0.03179407f, 0.01964724f, 0.09813821f, 0.04007459f, 0.19400011f, 0.08927478f, 0.20207551f, 
    -0.05697055f, 0.08935893f, 0.12738259f, 0.05540932f, -0.08222160f, -0.03887568f, 0.08672213f, 0.09508225f, 
    0.12815402f, 0.09329545f, 0.02907681f, -0.03639610f, 0.08521801f, 0.02366480f, 0.16663904f, -0.09629166f, 
    -0.01168339f, -0.02205353f, -0.18825425f, -0.05294229f, 0.13383576f, -0.07017499f, -0.14201431f, -0.00204428f, 
    -0.10313765f, -0.06375281f, 0.15399647f, 0.02765772f, -0.09792566f, -0.14896789f, 0.10630909f, 0.12401963f, 
    -0.00490285f, 0.01016646f, 0.02722558f, -0.07840489f, -0.32492188f, 0.17740618f, 0.35445663f, -0.07176169f, 
    -0.03940199f, -0.16635461f, -0.19754788f, 0.07837527f, 0.08020964f, 0.08449093f, 0.02501590f, 0.06789044f, 
    0.04727946f, 0.33832344f, 0.26029390f, -0.15676303f, 0.06356830f, -0.03065733f, 0.05004695f, 0.00313472f, 
    0.17449971f, 0.09695818f, 0.04410011f, 0.09497696f, -0.20585959f, -0.17091516f, -0.29999420f, 0.03373953f, 
    -0.00343415f, 0.12086125f, 0.11090378f, -0.07485206f, -0.14246562f, -0.06054331f, -0.10755558f, -0.18389635f, 
    0.04032924f, -0.23153162f, 0.11430675f, 0.08302918f, 0.12302132f, 0.18317495f, 0.07676200f, -0.02539779f, 
    -0.00636441f, -0.11209658f, -0.04883053f, -0.08542711f, -0.10848885f, -0.07276530f, -0.26617914f, -0.04083040f, 
    -0.09423471f, 0.02803732f, 0.06381693f, -0.03455847f, -0.00309387f, 0.08200944f, 0.02631082f, 0.04484065f, 
    0.32145771f, 0.11283838f, 0.01774942f, 0.12955813f, 0.09697863f, -0.23184738f, 0.00441388f, -0.14775023f, 
    0.24258702f, 0.16118623f, 0.22093032f, 0.30851990f, 0.03416796f, -0.14264546f, -0.17942889f, 0.06013305f, 
    0.08934121f, 0.04788349f, 0.05417091f, 0.05534779f, 0.02714951f, -0.05569232f, -0.06799359f, -0.05349040f, 
    -0.17252260f, -0.09009614f, -0.11479848f, 0.06419924f, 0.07848154f, 0.14361705f, 0.05106328f, 0.02248267f, 
    0.05022477f, 0.11213192f, 0.04283694f, 0.07464673f, 0.05125234f, -0.19116968f, 0.21522315f, 0.18132505f, 
    0.28740889f, 0.11730570f, 0.08666693f, 0.00825680f, 0.10917998f, -0.02307030f, 0.00487276f, -0.04434084f, 
    -0.07459025f, 0.08678822f, 0.14093898f, -0.19587390f, 0.20249221f, -0.01702211f, 0.02080391f, 0.10745873f, 
    0.28139564f, 0.01403141f, -0.15267675f, 0.13370515f, 0.25484401f, 0.18973367f, 0.45707330f, 0.25971246f, 
    -0.11384816f, -0.12837704f, 0.00099237f, -0.09058925f, -0.04929891f, 0.05974481f, -0.01942270f, 0.01592503f, 
    -0.16241442f, 0.00237173f, -0.23556256f, 0.04748400f, -0.03403969f, 0.03460801f, -0.04792258f, -0.10884877f, 
    0.03004594f, -0.09514617f, -0.03661070f, -0.14070909f, 0.10428720f, 0.06755360f, 0.29816481f, -0.10045430f, 
    0.06081211f, -0.04908048f, -0.12461226f, 0.01983663f, -0.08511406f, 0.09996415f, 0.09626500f, 0.02495514f, 
    -0.30025685f, -0.11680161f, -0.06452905f, 0.22599961f, 0.02699529f, 0.21508022f, 0.05340989f, 0.00725443f, 
    -0.15457228f, 0.01113126f, 0.04112821f, -0.08298955f, -0.05764010f, -0.09992906f, 0.12463570f, 0.19712067f, 
    -0.03121753f, 0.05838444f, -0.12293441f, -0.05372116f, 0.18338329f, 0.07960971f, 0.10189212f, 0.17453694f, 
    -0.14933170f, 0.06255972f, 0.17667975f, -0.07459092f, -0.07583345f, -0.09987175f, -0.16848449f, -0.04679232f, 
    0.06502067f, -0.07448358f, -0.04727376f, -0.05720730f, 0.07327969f, -0.04640680f, -0.10495875f, 0.04751514f, 
    -0.03723594f, 0.03094523f, 0.13960654f, -0.04020669f, 0.04479587f, 0.06233001f, 0.02050916f, 0.14056790f, 
    0.06538598f, 0.01312374f, 0.05549847f, -0.05661796f, -0.04204584f, 0.02794138f, -0.18195015f, 0.05010777f, 
    -0.15983039f, -0.00517269f, -0.07820431f, -0.19102123f, -0.08599175f, -0.08339986f, -0.10199683f, 0.07081612f, 
    0.05191461f, 0.09313095f, 0.06682501f, 0.05161184f, -0.01425666f, -0.06550549f, -0.02094894f, -0.08648518f, 
    -0.13343373f, -0.01122313f, 0.22233441f, 0.07347587f, 0.12353695f, -0.06411409f, -0.24072827f, 0.10525472f, 
    0.19128582f, 0.10615356f, -0.05590386f, 0.05602564f, 0.28563568f, -0.13007307f, -0.26600125f, -0.13649705f, 
    0.11922552f, 0.03395556f, 0.07052222f, -0.19087999f, 0.05066596f, -0.05593365f, -0.09192260f, 0.17736559f, 
    -0.04785801f, 0.06601308f, 0.20248099f, 0.07189324f, 0.03790730f, -0.21103676f, -0.03691253f, 0.05271966f, 
    -0.04572075f, 0.01797428f, 0.13740848f, 0.04511842f, 0.01921016f, 0.26175165f, -0.29864442f, 0.05804678f, 
    -0.04247712f, -0.00663743f, -0.03637687f, -0.06383830f, 0.00968856f, 0.04765933f, 0.05355174f, 0.09494157f, 
    0.14524701f, 0.16805507f, 0.01732794f, -0.28843302f, 0.13239159f, -0.05369459f, 0.02174324f, 0.02079672f, 
    -0.02292541f, 0.16560978f, -0.01169959f, 0.00673533f, 0.16598842f, 0.04390816f, 0.08420809f, -0.27784702f, 
    0.05554445f, -0.09680346f, -0.02556969f, 0.03483460f, 0.06784359f, -0.02507413f, 0.11885159f, 0.25137335f, 
    -0.12813716f, -0.04896915f, -0.02879744f, 0.04175460f, 0.01573195f, 0.12511468f, 0.10761810f, 0.12878664f, 
    0.02019920f, 0.14657724f, 0.10716898f, 0.09344146f, 0.04102727f, -0.15923913f, -0.22525118f, -0.08072335f, 
    0.02141703f, 0.06465034f, 0.13914357f, 0.12084126f, 0.04249503f, -0.18637289f, -0.03257161f, -0.20336212f, 
    0.04672971f, -0.03126603f, -0.00710515f, -0.12940697f, 0.09685334f, 0.02242915f, 0.12134647f, -0.00294453f, 
    0.13484687f, 0.23529863f, 0.00674097f, 0.32757714f, 0.00909217f, 0.36624691f, 0.21603256f, -0.08016600f, 
    0.04834989f, -0.07585163f, -0.36563507f, -0.07110851f, -0.12994458f, -0.00315151f, 0.01274278f, 0.02432532f, 
    -0.07963398f, 0.13009778f, -0.04188653f, 0.14754929f, -0.02212158f, -0.02643930f, 0.01121495f, -0.21471113f, 
    0.08252854f, 0.00201210f, -0.00642807f, 0.01213897f, -0.13318971f, -0.29817590f, -0.09645924f, 0.10387311f, 
    0.05478371f, 0.05840059f, 0.01303185f, 0.04784810f, 0.03901298f, -0.03469383f, 0.03670363f, -0.03693961f, 
    0.00768996f, 0.20398480f, 0.26634684f, -0.09694915f, 0.03896203f, -0.07235648f, -0.05536292f, -0.07448448f, 
    -0.16900091f, 0.01345009f, -0.03699869f, 0.02487735f, -0.05216536f, -0.09426557f, 0.08829144f, -0.11956879f, 
    -0.06363175f, -0.06889178f, -0.05517319f, -0.08417769f, 0.07949597f, -0.09242454f, 0.02807717f, -0.08364481f, 
    -0.15582551f, 0.07043357f, 0.08947761f, -0.11313099f, 0.00366309f, 0.08955708f, 0.05114553f, 0.00901416f, 
    0.06931251f, 0.06226801f, 0.06697521f, 0.11628023f, -0.10982431f, -0.22296405f, 0.01967205f, -0.03405653f, 
    0.04296615f, 0.06689644f, -0.01784706f, 0.21300636f, 0.08965807f, -0.02876777f, -0.03079763f, -0.07541505f, 
    -0.14873317f, 0.01090205f, 0.06275172f, -0.05454610f, 0.02476940f, 0.02682170f, 0.07065275f, -0.09116440f, 
    0.05267135f, 0.05591127f, -0.01388984f, -0.02820680f, 0.60079396f, 0.11124922f, -0.09383100f, 0.14444910f, 
    -0.00821214f, 0.04153019f, -0.04878020f, 0.05215916f, -0.00007808f, -0.05686821f, 0.06034282f, 0.01660583f, 
    0.15353577f, -0.10392443f, 0.01005763f, -0.07151546f, -0.03616631f, -0.00333756f, -0.07891771f, -0.11594886f, 
    0.07187728f, -0.06027465f, 0.02594717f, 0.11695389f, -0.30150959f, -0.09861705f, 0.15128793f, -0.01562774f, 
    -0.01475186f, 0.08872147f, 0.12964471f, 0.00672668f, -0.15158367f, -0.17930160f, -0.00715661f, -0.00672388f, 
    0.34784824f, 0.47941625f, -0.33865628f, -0.04698109f, -0.05029760f, -0.05187447f, -0.04080411f, -0.07257544f, 
    -0.04297514f, 0.04506335f, -0.07747390f, 0.07653300f, 0.12645060f, 0.12730822f, -0.15521844f, 0.00142664f, 
    0.01045997f, -0.15601455f, 0.13671100f, 0.15279865f, -0.01868081f, 0.02305702f, 0.02514337f, -0.06468163f, 
    -0.00834340f, 0.33510044f, -0.06612228f, -0.07923109f, 0.00607124f, -0.07672971f, 0.02342220f, -0.09781443f, 
    -0.00132780f, -0.00137799f, -0.15587547f, -0.03371209f, -0.18248048f, -0.14798860f, 0.04581390f, -0.02915012f, 
    0.17531767f, -0.04103326f, 0.07635918f, 0.09433733f, 0.09481186f, -0.01396944f, 0.11250812f, 0.21476242f, 
    -0.03276910f, -0.07932311f, -0.14301082f, 0.08932061f, 0.00234992f, -0.17467202f, -0.04942152f, 0.10666630f, 
    -0.04780332f, -0.06313505f, 0.02728120f, 0.02056323f, 0.15556137f, 0.17002773f, -0.12780069f, 0.04596452f, 
    -0.03098732f, -0.02445389f, 0.02330141f, -0.15852888f, -0.19279884f, -0.02713871f, 0.02581990f, -0.09708802f, 
    0.03139343f, 0.00926425f, -0.07529964f, 0.02967676f, -0.05646390f, 0.05092038f, -0.04780685f, 0.14403915f, 
    0.13162941f, 0.12868086f, 0.03681893f, 0.08740792f, -0.22183561f, -0.13965860f, 0.00794086f, -0.01883654f, 
    -0.06435347f, 0.01158622f, 0.02967856f, 0.07107802f, 0.06144910f, -0.02783494f, -0.00148896f, -0.04870725f, 
    -0.04999283f, 0.10613120f, -0.03678323f, -0.00107181f, -0.07402025f, 0.00749504f, 0.05421605f, 0.06231706f, 
    0.09129007f, 0.00146136f, -0.00425395f, 0.13692431f, -0.09279404f, 0.13166076f, -0.04312937f, 0.00055616f, 
    -0.01163113f, -0.02021347f, -0.03974006f, -0.02829412f, -0.03010017f, 0.12287860f, 0.23047468f, 0.24372667f, 
    -0.17133772f, -0.10796225f, -0.04470415f, 0.06209752f, 0.11197058f, 0.06223029f, 0.09484494f, 0.04803624f, 
    -0.00798482f, -0.07474535f, -0.11626915f, -0.15923947f, 0.08988290f, 0.03789207f, 0.09996308f, -0.24885739f, 
    -0.03823883f, 0.01298706f, -0.03881327f, -0.01424605f, 0.18839885f, 0.02522359f, 0.18412988f, 0.16013528f, 
    0.04523581f, -0.06941886f, -0.09105553f, 0.11735374f, 0.01380467f, -0.06635990f, 0.24141608f, -0.02280989f, 
    -0.00596957f, 0.03796817f, 0.11917853f, 0.12952864f, 0.06687898f, 0.02278280f, -0.03702292f, -0.07629643f, 
    0.00700929f, -0.00582485f, 0.01645943f, 0.08707971f, 0.18723498f, 0.26091272f, 0.11905388f, 0.33186838f, 
    0.20313871f, 0.08781978f, 0.03850355f, 0.05265678f, 0.06884578f, 0.08472195f, -0.09531807f, 0.03636127f, 
    0.03041761f, 0.02159034f, 0.10277422f, 0.18409675f, -0.12482637f, -0.22390226f, 0.02449244f, 0.01715089f, 
    0.00058130f, -0.05190471f, 0.06397307f, 0.06819466f, -0.01593850f, 0.00619020f, 0.03900126f, 0.01581281f, 
    -0.17902529f, -0.03061497f, -0.08107278f, 0.01494291f, 0.02649993f, 0.14469203f, 0.12655930f, 0.02337038f, 
    0.10420537f, 0.13329966f, 0.15684564f, 0.09834810f, 0.04261235f, 0.24077524f, -0.00921649f, 0.13052084f, 
    0.15631957f, 0.01281271f, -0.04977661f, -0.02208062f, -0.00155197f, 0.02871673f, -0.03953727f, 0.03568982f, 
    0.15437698f, -0.01883355f, -0.04103508f, -0.06868758f, -0.08983056f, -0.10127822f, -0.06993504f, -0.01550469f, 
    0.10451415f, -0.01455489f, -0.06602245f, -0.12851709f, -0.22133613f, 0.02637925f, 0.01817854f, -0.17507684f, 
    -0.10150357f, -0.02290896f, -0.01628930f, -0.01393787f, -0.01036427f, -0.07180043f, -0.04122838f, -0.02067838f, 
    -0.08690339f, -0.06499025f, -0.07400530f, -0.10354809f, 0.07413998f, 0.02124948f, 0.09358250f, 0.14158145f, 
    0.11472914f, 0.02569596f, 0.13726352f, 0.09986887f, 0.00269912f, 0.02905249f, -0.20910074f, 0.05591224f, 
    0.02504859f, 0.13933477f, 0.09572993f, 0.10821647f, 0.07546531f, -0.00703589f, -0.12871772f, -0.20323922f, 
    -0.04618312f, -0.18590283f, -0.07253139f, -0.00549377f, 0.00126465f, 0.02876845f, 0.03655767f, 0.02247121f, 
    -0.11583457f, -0.03790839f, -0.10641217f, -0.02945739f, -0.02286086f, 0.02889950f, -0.07844815f, 0.06401923f, 
    0.09542760f, -0.15672070f, 0.09154040f, -0.03846005f, 0.06647837f, 0.00397351f, 0.09547786f, 0.09026467f, 
    -0.18138230f, -0.15661886f, -0.14802554f, -0.12230758f, 0.12961622f, 0.01543552f, 0.02652284f, -0.04823904f, 
    0.05676834f, -0.01997795f, -0.04197562f, -0.00881891f, 0.11820118f, 0.00172250f, -0.08986358f, -0.08821599f, 
    0.05098735f, 0.08555536f, 0.01418240f, 0.06126516f, -0.03751367f, -0.17137939f, -0.22807604f, -0.15174426f, 
    -0.14180133f, -0.06171165f, -0.13052388f, 0.07806679f, -0.13132720f, 0.08591200f, 0.04575859f, 0.04174585f, 
    -0.14975363f, -0.16895895f, -0.02237783f, 0.00819697f, 0.08983254f, -0.04749836f, 0.01787363f, -0.14993109f, 
    -0.07282665f, -0.00774049f, -0.05657828f, -0.04953504f, 0.04318398f, 0.06948949f, 0.09168713f, 0.07459897f, 
    -0.25794661f, 0.07271411f, 0.18301177f, -0.01160819f, -0.03086428f, -0.01607015f, -0.09125131f, -0.04716971f, 
    0.01217028f, -0.05628903f, -0.03177747f, 0.02882345f, -0.04725986f, 0.27466151f, -0.00286123f, -0.15178205f, 
    -0.00576145f, -0.07401955f, -0.10939849f, -0.11583778f, -0.12084033f, -0.00624628f, -0.17666364f, -0.08110435f, 
    0.11208989f, -0.02999482f, -0.08119842f, 0.06211404f, 0.05840419f, -0.01158763f, 0.13805269f, 0.12481893f, 
    -0.16159447f, -0.08842314f, -0.19623865f, -0.27356577f, 0.11394373f, -0.05945877f, -0.00903649f, 0.22191282f, 
    -0.06944156f, 0.04600639f, -0.05908798f, -0.02264057f, 0.12070196f, 0.01706606f, 0.06093238f, 0.13497074f, 
    -0.08166378f, 0.02722728f, -0.03737748f, 0.00995700f, 0.00100424f, 0.00605193f, -0.02106087f, 0.02349990f, 
    0.03870723f, -0.02882634f, 0.01010798f, 0.12711550f, -0.16729717f, -0.03094351f, 0.12585820f, 0.15583336f, 
    0.05373136f, 0.27087557f, -0.05954504f, -0.07317019f, 0.03067782f, -0.10057425f, -0.11991871f, -0.05004465f, 
    -0.08550312f, 0.03628264f, 0.27851278f, 0.05920164f, -0.08683860f, -0.00344539f, 0.00649130f, -0.11963966f, 
    -0.13828827f, 0.08345338f, 0.11192771f, -0.02034568f, -0.03691123f, -0.29747903f, 0.10267413f, -0.00743855f, 
    0.00545016f, 0.03566191f, 0.01122711f, 0.08640644f, 0.14722377f, 0.14807056f, 0.06692626f, 0.05508209f, 
    0.22016266f, 0.12240629f, -0.02383328f, -0.16965073f, -0.01536715f, -0.07456616f, -0.02293121f, -0.05240968f, 
    0.05611198f, 0.01379833f, -0.02222031f, -0.11349447f, -0.16330133f, -0.00920775f, 0.21277857f, -0.20449814f, 
    0.11142308f, -0.06896070f, 0.06171978f, -0.13236609f, 0.15790930f, 0.05955986f, 0.04959814f, 0.06477246f, 
    0.10041896f, 0.24328864f, -0.12260140f, 0.03902976f, -0.05484963f, 0.07705380f, 0.07126624f, -0.11763537f, 
    0.02906399f, -0.00279796f, 0.00284325f, 0.06640320f, 0.06836717f, -0.00678415f, -0.08355435f, -0.33612686f, 
    -0.08365086f, -0.00182371f, -0.06271896f, -0.07784414f, 0.08563653f, -0.09530566f, -0.06963925f, -0.09342021f, 
    -0.19717348f, -0.13701327f, -0.07603879f, 0.03383054f, 0.09138635f, 0.06488812f, 0.00137017f, -0.13133177f, 
    0.03039657f, 0.00423702f, 0.07425669f, 0.03726198f, -0.04135994f, -0.04476653f, 0.01531064f, -0.02812630f, 
    0.07667473f, 0.15669255f, 0.03162374f, 0.16794202f, -0.01206240f, 0.15170871f, -0.08965339f, -0.00595416f, 
    -0.00650358f, -0.08486576f, 0.10877034f, -0.01130195f, 0.14164874f, 0.05676274f, 0.08965354f, -0.11421403f, 
    0.07675651f, -0.00196323f, 0.24118225f, 0.12276324f, -0.04040479f, 0.11114933f, 0.08866105f, 0.27082986f, 
    -0.01742861f, 0.06503002f, -0.01606099f, 0.00072242f, 0.02648262f, 0.03704967f, 0.02507117f, 0.04130695f, 
    -0.04556247f, 0.21343885f, 0.06458004f, 0.01632024f, -0.09097654f, 0.11666939f, 0.05868778f, 0.02883451f, 
    0.05326844f, 0.03460035f, 0.26693472f, 0.00900404f, -0.20049223f, -0.02649119f, 0.07582881f, -0.02463946f, 
    -0.02786363f, 0.05261672f, -0.13243343f, 0.23699881f, 0.04960286f, 0.08265958f, 0.00584383f, 0.12078729f, 
    -0.02586205f, 0.25740623f, 0.15376623f, -0.36792094f, -0.06168366f, -0.01179466f, -0.00774322f, -0.06405579f, 
    0.09379464f, 0.04717660f, 0.09143296f, 0.08130470f, 0.18329202f, 0.07226048f, -0.08761395f, -0.07951470f, 
    -0.06548838f, 0.04306290f, -0.02879035f, 0.05590724f, -0.03195596f, -0.00127693f, 0.05909655f, 0.03096042f, 
    -0.34963307f, 0.18314421f, 0.18735850f, 0.20840627f, 0.03726732f, 0.00255069f, 0.07146471f, -0.01178080f, 
    0.13614272f, -0.00874707f, 0.04953338f, 0.03640502f, -0.11358427f, -0.03227157f, -0.05907111f, -0.06162156f, 
    -0.00807283f, -0.01310915f, 0.03035362f, 0.00586493f, -0.01214391f, 0.12387075f, 0.08684791f, 0.06366503f, 
    -0.13410704f, -0.07876181f, -0.03124034f, 0.04748162f, 0.12856929f, 0.02424788f, 0.04793907f, -0.01306472f, 
    0.17051563f, 0.02700559f, 0.02346190f, -0.05826505f, -0.11145176f, -0.00415489f, -0.10301275f, -0.03526966f, 
    0.10049999f, 0.10949398f, 0.06676222f, -0.02097608f, 0.16169439f, 0.10197276f, 0.04756119f, 0.10760543f, 
    -0.18142085f, -0.03469588f, 0.03640528f, -0.04146395f, -0.07596604f, -0.07922909f, 0.00449817f, -0.10184655f, 
    -0.23706476f, -0.00625209f, -0.14692107f, -0.34991702f, -0.39249989f, 0.13773251f, 0.03489561f, -0.03445119f, 
    0.04331704f, 0.13717166f, -0.00434805f, 0.07734214f, 0.07134671f, -0.01701386f, 0.00527960f, -0.10358574f, 
    0.22114483f, -0.12212116f, 0.06231213f, -0.06662939f, 0.07615574f, 0.05963544f, 0.03251787f, 0.08698333f, 
    -0.07317724f, 0.06060877f, 0.00695648f, 0.00317582f, -0.03781817f, 0.02622834f, 0.10423332f, 0.17143044f, 
    0.06671940f, 0.06891401f, -0.12061787f, -0.03170818f, 0.00842630f, 0.03274715f, 0.02398905f, 0.09259295f, 
    -0.20690542f, -0.18120603f, 0.05361164f, 0.04913353f, -0.09342007f, 0.12412343f, 0.01479729f, 0.06325878f, 
    0.22319645f, 0.10823502f, 0.07598046f, 0.00078101f, -0.04409277f, 0.00198162f, 0.05784987f, -0.14116549f, 
    0.09328878f, 0.05226929f, 0.06766468f, -0.00972791f, 0.11776229f, -0.01739070f, 0.03104539f, 0.06016709f, 
    0.02392763f, -0.01969455f, -0.00200449f, -0.02629936f, -0.02249195f, 0.02031032f, -0.02345943f, -0.00676815f, 
    0.02245571f, -0.04346557f, 0.01579696f, -0.00701520f, 0.01133226f, -0.03894659f, -0.00585595f, 0.01137703f, 
    -0.03403560f, -0.01546548f, -0.02185915f, 0.01791804f, 0.00113366f, -0.03379266f, 0.01386244f, 0.00585066f, 
    -0.01608409f, -0.00273690f, -0.01015146f, 0.03330416f, -0.01857517f, -0.00882321f, 0.01804578f, -0.03306849f, 
    -0.04046687f, 0.01564958f, -0.00622449f, 0.01873902f, 0.01544020f, -0.01217965f, -0.03749210f, 0.01441321f, 
    -0.01716476f, 0.01043132f, -0.00566439f, -0.03329973f, -0.01998487f, -0.00007371f, 0.01797329f, -0.01823055f, 
    0.01399094f, 0.00885301f, -0.00373050f, 0.00327986f, -0.00386550f, -0.01223617f, 0.00574869f, -0.02254475f, 
    0.02921418f, -0.00398788f, -0.01793770f, 0.01146611f, -0.01080306f, 0.01078310f, -0.00785746f, -0.03032028f, 
    0.00307349f, -0.03924569f, 0.01287686f, 0.02059560f, -0.02413626f, -0.01634211f, 0.00188210f, -0.00319733f, 
    0.00385049f, 0.01427318f, -0.00669813f, 0.00644582f, -0.01868428f, 0.01361799f, 0.02580879f, -0.02015804f, 
    -0.03155772f, 0.01575204f, 0.02605185f, 0.01099053f, 0.00962182f, 0.00312622f, -0.03123952f, 0.00208846f, 
    -0.01143902f, 0.01916742f, -0.02636286f, -0.00066691f, -0.03055545f, -0.01842168f, 0.01017135f, -0.01994791f, 
    -0.01720769f, -0.01880544f, 0.00862575f, -0.03336431f, 0.01464194f, 0.01940072f, -0.01689849f, 0.03351472f, 
    -0.01845657f, 0.01304080f, 0.00404914f, -0.00698047f, -0.00142431f, -0.03192949f, -0.00306419f, 0.01778191f, 
    0.02610990f, -0.03752289f, -0.03537549f, 0.00081913f, -0.01175449f, 0.00743961f, -0.00909051f, -0.01266277f, 
    -0.00992255f, 0.01012574f, -0.02021323f, -0.00911686f, -0.01532685f, 0.00794845f, 0.00454566f, 0.03228408f, 
    0.04402715f, -0.00909884f, -0.00277580f, 0.02841635f, -0.02113324f, 0.01915565f, 0.02440558f, -0.04200288f, 
    -0.02377365f, -0.00853640f, 0.02622413f, -0.00305151f, -0.02819800f, -0.00239345f, 0.02009294f, 0.00403675f, 
    0.02059945f, -0.01817532f, 0.00195346f, -0.00470988f, 0.02548475f, 0.00806602f, -0.00733292f, 0.01408578f, 
    0.00676372f, -0.01304169f, 0.00037271f, 0.02432426f, -0.01568122f, 0.02494310f, 0.03121103f, 0.01843578f, 
    -0.00741397f, -0.01465211f, -0.03475543f, 0.00358820f, -0.03422602f, 0.02133068f, -0.01242299f, 0.02387037f, 
    0.00481031f, 0.02378331f, 0.00440830f, -0.01092333f, -0.01369060f, -0.02859398f, -0.02662059f, 0.03631182f, 
    0.03100045f, -0.00304627f, -0.02794791f, -0.01090839f, 0.02870035f, -0.00964745f, 0.00645692f, 0.01087845f, 
    -0.03494077f, -0.01181557f, 0.00895892f, -0.03128431f, -0.02565988f, 0.00211334f, -0.01089625f, 0.02462057f, 
    -0.03464944f, -0.00895000f, -0.00253368f, 0.00424334f, 0.00557979f, -0.03447573f, 0.00166246f, -0.01133773f, 
    -0.02738355f, 0.01281836f, 0.02113355f, -0.01863726f, 0.02248935f, 0.01968234f, 0.00844351f, 0.02548233f, 
    0.00047782f, -0.04138735f, -0.01645917f, -0.02748843f, 0.01100767f, -0.00608557f, -0.04370401f, -0.03243914f, 
    -0.03569540f, 0.00154003f, 0.02473406f, 0.01089028f, 0.02946139f, -0.02032452f, -0.01600384f, 0.02492624f, 
    0.01575136f, -0.04154282f, 0.00559027f, 0.01300829f, -0.00348996f, -0.02382523f, 0.02828853f, -0.01872696f, 
    -0.03913636f, -0.00916959f, 0.02628568f, 0.02409659f, 0.00420652f, 0.00912095f, 0.00511545f, -0.02204791f, 
    -0.00883968f, -0.02064253f, 0.01844105f, -0.04064354f, -0.02872209f, 0.00035665f, 0.02821598f, -0.01339671f, 
    -0.00813377f, -0.03036531f, -0.01384555f, 0.01605977f, -0.00951543f, -0.03404903f, -0.03155202f, 0.01683461f, 
    -0.01181132f, 0.02338275f, -0.02677508f, 0.01300470f, -0.01265723f, -0.02487276f, -0.00639970f, -0.02247819f, 
    -0.00297778f, -0.04068216f, -0.02371258f, 0.02493318f, 0.00825673f, 0.02696403f, -0.00608264f, -0.04079136f, 
    -0.02129241f, 0.00740755f, -0.03829041f, 0.01691251f, 0.00492485f, 0.02700899f, -0.02867015f, -0.03190883f, 
    -0.03751202f, -0.01467146f, -0.02469843f, -0.00130550f, -0.02232173f, 0.01242896f, 0.00375082f, 0.01823745f, 
    0.02208362f, 0.01445020f, -0.01886259f, -0.03411419f, -0.03938194f, -0.02938755f, 0.02890262f, -0.03888697f, 
    -0.02849687f, -0.03069283f, 0.01722383f, 0.01082665f, -0.00542671f, 0.01502558f, -0.04363497f, 0.02319977f, 
    0.01560670f, -0.00455311f, 0.00706283f, -0.00662304f, -0.01042543f, -0.03278158f, -0.02331088f, -0.00062555f, 
    -0.03473255f, 0.02146638f, -0.02365212f, -0.00426385f, 0.01756369f, -0.01404216f, -0.03756846f, -0.03379997f, 
    -0.03877511f, -0.02345072f, -0.03722707f, -0.02142075f, -0.04324543f, 0.00543860f, 0.01220471f, -0.02606222f, 
    -0.02342397f, 0.01600266f, -0.02316606f, -0.01616871f, -0.01789432f, 0.01747454f, 0.03429962f, -0.00324292f, 
    0.03002994f, -0.04060919f, -0.00296414f, 0.02011996f, -0.01729995f, -0.01047124f, 0.01860066f, -0.00413158f, 
    -0.01721259f, -0.02812186f, 0.02262062f, 0.01961174f, -0.03939524f, 0.00066828f, -0.03953112f, -0.04281692f, 
    -0.02861443f, 0.01529002f, 0.01291567f, 0.02118108f, -0.01926933f, -0.02436247f, -0.01326001f, 0.00928254f, 
    -0.00698549f, -0.00806814f, 0.00082869f, -0.04196459f, 0.00384037f, -0.01763658f, 0.01187393f, 0.01910920f, 
    -0.03417263f, -0.00968063f, 0.01992333f, -0.01744835f, -0.02730118f, 0.02985845f, -0.00639127f, -0.01811598f, 
    0.01896568f, 0.02734210f, -0.02857423f, 0.02102385f, -0.03270783f, -0.00088004f, -0.00228503f, -0.00140892f, 
    0.00631017f, -0.03346030f, -0.00916512f, -0.01629349f, -0.03223820f, -0.03707998f, -0.00506021f, -0.01134975f, 
    -0.04449740f, 0.01327628f, 0.02759589f, -0.01766470f, -0.00506177f, -0.01340375f, -0.00449839f, 0.02732096f, 
    -0.03211769f, -0.02786742f, -0.02742437f, -0.03823223f, -0.01300491f, -0.03734580f, 0.01095816f, 0.02700393f, 
    0.01618905f, 0.01956073f, -0.00004408f, -0.02772142f, -0.00932689f, 0.03149630f, -0.00882296f, 0.00893356f, 
    -0.03613113f, 0.01877852f, 0.02171462f, 0.02401112f, 0.00819910f, 0.01248720f, -0.03849108f, -0.03519813f, 
    -0.03470159f, -0.01455718f, -0.02583902f, -0.03040507f, 0.01874288f, -0.01678303f, 0.00351943f, 0.01358056f, 
    0.00201603f, -0.02117005f, 0.01963451f, -0.03114906f, -0.00719553f, -0.00515311f, 0.02500565f, -0.02075599f, 
    -0.03478247f, -0.01743863f, -0.00960791f, -0.01131175f, -0.02240776f, -0.03492557f, -0.02177295f, -0.01001491f, 
    -0.03756027f, 0.02886405f, -0.02140413f, -0.03469696f, 0.00522363f, -0.02526333f, -0.03432016f, -0.01244232f, 
    -0.04304905f, 0.01522043f, -0.02358418f, -0.02894879f, 0.02457011f, 0.03782379f, 0.01974263f, 0.00967089f, 
    0.02800129f, 0.01784695f, 0.02641287f, -0.00474637f, 0.01759973f, -0.00383924f, -0.01230751f, -0.03161480f, 
    -0.03537339f, -0.01022255f, 0.00996668f, -0.02343052f, 0.02141425f, -0.00650648f, -0.00244834f, -0.01795493f, 
    0.01053996f, 0.01754404f, 0.02624180f, 0.01217789f, 0.01758241f, -0.00427236f, 0.01141769f, -0.03618844f, 
    0.01904881f, -0.02552617f, -0.02042977f, 0.02255548f, -0.03822610f, -0.04121446f, 0.00684140f, -0.02082060f, 
    0.01487305f, -0.03750587f, -0.00022026f, -0.02104163f, -0.00061111f, 0.00530932f, -0.00198494f, 0.01623435f, 
    0.02534189f, 0.02674193f, -0.04422746f, -0.00659771f, -0.02793651f, -0.01453072f, -0.02687253f, 0.00763428f, 
    -0.01497810f, 0.02614651f, 0.01699303f, -0.04350619f, -0.03131214f, 0.02120171f, -0.01870085f, -0.02235319f, 
    0.00849966f, 0.02750935f, 0.01805677f, -0.02239775f, -0.03556700f, -0.02277656f, 0.02894957f, 0.00088197f, 
    -0.02295365f, 0.00532491f, -0.02589930f, 0.00736132f, 0.00357171f, 0.01059420f, -0.00734742f, -0.03752821f, 
    0.02123588f, -0.00586853f, -0.00299165f, 0.00718128f, -0.02491630f, -0.02716867f, -0.03926717f, 0.00093992f, 
    0.02409302f, -0.02671952f, 0.00088401f, -0.00214519f, 0.02433358f, -0.02416123f, -0.01396758f, -0.00925243f, 
    -0.02905344f, 0.01290289f, -0.01980145f, -0.02231382f, 0.01803734f, -0.02183218f, -0.02904340f, 0.01430059f, 
    -0.01956753f, -0.01148599f, -0.03053923f, -0.01226947f, 0.00882089f, -0.02554031f, 0.02767717f, -0.04326300f, 
    0.02916384f, -0.00571870f, -0.02291693f, 0.02144609f, -0.02202267f, 0.01058366f, -0.03300048f, -0.01082262f, 
    0.02489528f, -0.03723566f, 0.01728899f, -0.02233828f, 0.00968170f, -0.03720801f, 0.00480890f, 0.02798540f, 
    0.02730689f, 0.02393905f, -0.02251782f, -0.03181259f, 0.00663974f, -0.02007283f, -0.01534752f, 0.01731376f, 
    -0.04154705f, -0.02838998f, -0.00279848f, -0.02261239f, -0.02204020f, 0.01130930f, -0.03669539f, -0.02530468f, 
    -0.01895672f, 0.00223453f, 0.00797673f, -0.00125419f, -0.00694907f, -0.00062229f, 0.01191312f, -0.02896504f, 
    -0.01469121f, -0.03528809f, 0.00177633f, 0.01817931f, 0.02442428f, -0.02754680f, -0.03012011f, -0.04177370f, 
    -0.02648924f, -0.01463744f, -0.00746264f, 0.00221202f, 0.02590979f, -0.02536176f, 0.00777957f, 0.00614772f, 
    -0.02085533f, -0.01284074f, -0.03329253f, 0.02232035f, 0.00658325f, -0.02506936f, -0.01127318f, -0.02481212f, 
    -0.03673152f, -0.03129901f, -0.03366747f, 0.02575523f, -0.04236642f, -0.00048338f, -0.02248582f, -0.00955058f, 
    0.02852998f, 0.00343157f, 0.01299886f, 0.00081474f, 0.00113365f, -0.00759822f, -0.00532288f, -0.02951892f, 
    0.02606443f, -0.01129470f, -0.02837222f, -0.01034930f, -0.02578812f, 0.00513637f, -0.02689681f, -0.00806520f, 
    0.02517912f, 0.01085426f, 0.00098805f, 0.00455485f, -0.02407230f, -0.02730893f, -0.00876613f, 0.00473484f, 
    -0.03837451f, -0.03277525f, -0.03024382f, -0.02193618f, -0.03011717f, -0.02863718f, 0.01706389f, -0.03759143f, 
    0.01689799f, -0.04018488f, 0.01480918f, 0.01146277f, -0.00639144f, -0.00664763f, 0.00081903f, 0.01378523f, 
    -0.00295083f, 0.02292019f, -0.01310196f, 0.04160933f, -0.02972675f, 0.01291751f, 0.01458325f, -0.00935825f, 
    -0.03791621f, 0.00239848f, -0.02293462f, -0.04315870f, -0.03329459f, 0.00366832f, 0.00792044f, -0.00422616f, 
    0.00680876f, 0.01656857f, -0.03748300f, -0.02647595f, 0.02864705f, 0.02172948f, -0.01650419f, -0.01413478f, 
    -0.00589879f, 0.01483839f, -0.00186099f, 0.00451802f, -0.01843792f, -0.00155397f, -0.02919526f, 0.00800660f, 
    0.01352410f, 0.00829648f, -0.03322874f, 0.00327794f, -0.02569613f, -0.01437726f, -0.03099858f, -0.02202826f, 
    0.00194778f, -0.01125297f, 0.00815662f, -0.03720625f, 0.01085116f, -0.01048547f, 0.00912285f, -0.01293605f, 
    -0.00256532f, 0.00547352f, -0.03745519f, -0.00655740f, 0.00590504f, -0.03457228f, 0.01884458f, 0.00305944f, 
    -0.00936018f, 0.00340856f, -0.00494734f, -0.03229479f, 0.01458942f, 0.00184592f, -0.03682176f, 0.01612982f, 
    -0.00132061f, 0.01220470f, -0.02588278f, 0.01835319f, 0.02695437f, -0.03243879f, -0.03228776f, -0.02340503f, 
    -0.02562324f, -0.02500244f, -0.02675586f, 0.02185773f, -0.03848749f, 0.00636090f, 0.00343932f, 0.00425793f, 
    0.02110317f, 0.00554118f, -0.03400941f, 0.00434571f, 0.02484623f, -0.01398492f, -0.01357993f, -0.02511114f, 
    -0.03484892f, 0.03158060f, -0.03043561f, -0.03423361f, 0.00411867f, -0.01134325f, -0.01542115f, -0.02596406f, 
    0.02895435f, -0.00878390f, -0.03247080f, -0.00230837f, 0.03132044f, 0.02629157f, -0.00339998f, 0.02832578f, 
    -0.04015102f, -0.00729195f, -0.00628331f, -0.02877371f, -0.03256748f, -0.04398447f, -0.00174013f, -0.04138841f, 
    -0.01523086f, -0.01468410f, -0.03393759f, -0.03506278f, -0.01193609f, 0.02560733f, 0.00116685f, -0.03535609f, 
    -0.03618000f, 0.01387968f, 0.00056045f, -0.02290039f, -0.01823752f, -0.01671237f, -0.01749818f, 0.02821799f, 
    0.00325519f, 0.01228748f, -0.03061269f, 0.02227606f, 0.02261392f, 0.00950139f, -0.01004756f, -0.02812484f, 
    -0.00072299f, 0.00914485f, 0.00725523f, -0.02793800f, 0.01435072f, 0.02675671f, 0.02283914f, 0.03592880f, 
    -0.03279481f, -0.00238537f, -0.03586207f, 0.01009636f, -0.01122466f, -0.00646143f, -0.04000505f, -0.02343896f, 
    -0.01490654f, 0.00885153f, 0.01798211f, 0.02062505f, -0.03094164f, -0.00381406f, -0.04066342f, -0.00205509f, 
    -0.03496552f, -0.01009872f, -0.01490550f, 0.01730043f, -0.00878549f, -0.02258922f, 0.02462396f, 0.00168571f, 
    0.03371163f, -0.03745674f, 0.02068884f, -0.03798040f, 0.00833191f, 0.00924123f, -0.04116979f, 0.01594722f, 
    -0.02096580f, -0.01488814f, 0.01159636f, -0.02475249f, 0.01136712f, -0.02774029f, -0.03891135f, 0.01356654f, 
    -0.04193156f, -0.01550896f, 0.00630812f, 0.03158562f, 0.01808899f, -0.03317755f, -0.01974081f, 0.01950569f, 
    -0.03154647f, 0.03092805f, 0.01602176f, -0.03848589f, -0.02975393f, 0.00045617f, -0.01941198f, -0.00767608f, 
    0.02684772f, 0.01484011f, -0.01408287f, -0.01569509f, -0.00102501f, -0.03186935f, -0.04009157f, 0.00468620f, 
    -0.03305186f, -0.00102162f, 0.02610065f, 0.01923501f, -0.01081723f, -0.00835236f, 0.00253635f, 0.00924368f, 
    -0.00150995f, -0.02956796f, -0.00820282f, 0.00156719f, -0.00955270f, -0.02688593f, 0.01966706f, -0.00723932f, 
    0.01703377f, -0.03292691f, 0.01677377f, -0.01043799f, -0.03747497f, -0.01476562f, 0.01679059f, -0.01617103f, 
    -0.00475518f, -0.03149082f, -0.00625847f, -0.03617839f, -0.03950962f, -0.00305591f, -0.03994869f, -0.03798957f, 
    -0.00189990f, -0.03884582f, 0.01796581f, 0.00824087f, 0.00890097f, -0.02942879f, 0.00853500f, 0.02443147f, 
    0.01019718f, -0.00653639f, -0.01211544f, 0.01375716f, -0.01883676f, -0.01619901f, 0.01964540f, -0.01294053f, 
    -0.01653678f, 0.00842586f, -0.01058881f, -0.00573635f, -0.01953207f, -0.01991175f, -0.01989608f, -0.00168329f, 
    0.02973523f, -0.02493697f, 0.01171563f, -0.02955592f, -0.02112986f, 0.01027174f, -0.00527349f, 0.00552822f, 
    -0.04150950f, -0.00995290f, 0.02214401f, 0.01251469f, -0.04137620f, 0.01384565f, -0.02728529f, -0.00265283f, 
    -0.00009960f, -0.01365579f, 0.02092756f, -0.01708905f, 0.02709970f, -0.01435128f, -0.02524664f, 0.02112931f, 
    -0.04247488f, -0.03422012f, 0.02291988f, -0.00672354f, 0.01430580f, -0.00036918f, 0.01819617f, 0.02394430f, 
    0.00778560f, 0.00051504f, -0.04229559f, 0.00789283f, 0.02198465f, -0.00942503f, -0.00636525f, -0.03655520f, 
    -0.02315612f, 0.02316553f, -0.00274793f, -0.03247336f, -0.03499193f, -0.01407618f, -0.02592743f, -0.03158703f, 
    0.00111669f, 0.01640467f, -0.03505067f, -0.03574510f, 0.01874861f, 0.01727428f, 0.02169031f, -0.00735522f, 
    0.00713915f, -0.02150351f, -0.01256029f, 0.00229721f, -0.03678768f, 0.02816498f, 0.00423476f, 0.00911960f, 
    0.02701246f, 0.00327929f, -0.01536952f, -0.02789633f, 0.01340092f, -0.00282528f, 0.01582641f, 0.02894324f, 
    0.00652516f, 0.02044730f, -0.03211799f, 0.00801815f, 0.00869857f, -0.00766431f, -0.00455245f, -0.01848827f, 
    -0.00780165f, -0.03589405f, 0.02794655f, -0.02573721f, 0.00610201f, 0.02366312f, 0.00302938f, -0.00131382f, 
    -0.03998771f, -0.01697296f, -0.03571473f, 0.01979069f, 0.01235355f, 0.01219880f, -0.02951788f, -0.00533673f, 
    0.02806597f, 0.02103396f, 0.02749726f, -0.02676975f, -0.02992140f, 0.00972192f, 0.01380680f, -0.03175493f, 
    0.00075328f, -0.04018784f, -0.00452467f, -0.02356946f, 0.01629477f, -0.00699239f, -0.02746683f, -0.00334941f, 
    -0.04408916f, -0.03730395f, -0.00672925f, -0.02481212f, 0.02426299f, -0.03314492f, -0.02998934f, -0.02695461f, 
    0.02174580f, 0.02179054f, 0.02434493f, 0.00438979f, 0.01906137f, -0.00191133f, 0.02304611f, 0.00299968f, 
    0.00407492f, -0.04405211f, -0.00364461f, 0.01265234f, -0.02324646f, 0.02066711f, 0.00984386f, 0.01308427f, 
    0.02683648f, -0.04115430f, 0.00541057f, -0.01684583f, 0.00654590f, 0.02362713f, 0.01235193f, -0.00056059f, 
    -0.01279891f, 0.02161549f, 0.01387913f, 0.02383358f, -0.02325774f, 0.00562220f, 0.00050324f, -0.03991262f, 
    -0.01809779f, -0.02161297f, 0.01671027f, -0.03618961f, -0.02550620f, 0.02708717f, -0.02822150f, -0.02638473f, 
    -0.00020284f, 0.01298022f, -0.01291764f, -0.03065534f, -0.01327142f, -0.01375713f, -0.01474998f, 0.02305536f, 
    -0.01982237f, 0.02284230f, 0.03077037f, 0.01422680f, -0.00381614f, -0.01987118f, 0.01436568f, 0.01104861f, 
    0.01433866f, 0.01957549f, -0.04358994f, -0.01604166f, -0.01878876f, 0.01536973f, -0.03163055f, 0.00551059f, 
    0.00302859f, -0.01228172f, 0.02117256f, 0.02053377f, -0.00707177f, 0.02575094f, 0.01271227f, -0.01845374f, 
    0.00923351f, 0.00153120f, -0.02789392f, 0.01125234f, 0.00734642f, -0.02632472f, 0.03291098f, -0.02834614f, 
    0.01528165f, -0.01418928f, 0.01176185f, -0.03627821f, -0.03506052f, 0.02454882f, -0.04187619f, 0.01303789f, 
    -0.02847343f, -0.00524234f, 0.01109817f, 0.01834086f, -0.03571246f, -0.01337126f, -0.02447980f, -0.03638398f, 
    -0.03670493f, 0.00689643f, 0.01396601f, -0.02503061f, 0.00385465f, -0.03042897f, -0.03433147f, 0.01574502f, 
    0.00187205f, 0.00262425f, -0.00277553f, -0.00147189f, 0.02390221f, 0.01845769f, 0.02998157f, -0.02074397f, 
    -0.01314419f, 0.02519131f, 0.00664794f, 0.02883206f, 0.02509392f, -0.03661154f, -0.02509251f, -0.00133115f, 
    -0.03505526f, 0.02212441f, -0.00976381f, -0.00129412f, -0.03260666f, 0.01514289f, -0.03945928f, 0.02061815f, 
    -0.02848876f, 0.00720158f, -0.03239375f, 0.01832569f, -0.00049859f, 0.02200471f, -0.03789609f, 0.00150785f, 
    -0.02100450f, 0.00142370f, -0.00964588f, -0.02956653f, 0.01209646f, 0.00687695f, 0.02604833f, 0.00693122f, 
    -0.03761744f, -0.03315912f, -0.01157775f, 0.00992348f, 0.00974967f, -0.01457996f, 0.02506970f, 0.02788322f, 
    0.02287877f, 0.01987159f, -0.02825201f, 0.02128093f, 0.00516260f, 0.03270666f, 0.00329199f, -0.02226529f, 
    0.01911073f, 0.00645819f, 0.01412707f, -0.00292834f, 0.00120385f, -0.02849043f, 0.00563039f, -0.00114260f, 
    -0.02021937f, 0.01082871f, -0.02085538f, 0.02516740f, 0.02233677f, 0.00176366f, -0.00118524f, -0.00923709f, 
    -0.03553323f, -0.02712731f, -0.01385693f, 0.01155210f, -0.02177086f, 0.02703449f, -0.02902750f, 0.02123063f, 
    -0.04162562f, 0.01305130f, 0.02468776f, -0.01767089f, -0.04079017f, -0.02234652f, 0.02216967f, 0.02549968f, 
    -0.00126936f, -0.00987453f, 0.00313536f, 0.01251610f, -0.01772042f, 0.02891451f, 0.01268214f, 0.00575389f, 
    0.00646923f, 0.03798551f, 0.01311253f, -0.02158262f, -0.00078913f, 0.01959615f, -0.01617750f, 0.02476297f, 
    -0.03649684f, 0.00093618f, -0.01375954f, -0.03095600f, 0.00079681f, 0.03015098f, -0.01671265f, -0.00034098f, 
    0.03206144f, -0.03216128f, -0.00712965f, 0.01162396f, 0.02376225f, -0.02389976f, 0.03012427f, -0.01715825f, 
    -0.03515649f, 0.00633326f, 0.01198973f, -0.02024157f, -0.00119310f, 0.01915271f, -0.03601896f, 0.00341042f, 
    -0.02052953f, -0.03102840f, -0.00058176f, -0.00984333f, -0.00782514f, 0.02235809f, -0.00255832f, 0.02404900f, 
    -0.03457506f, 0.02558978f, 0.01954114f, -0.01135239f, 0.00141837f, -0.02516769f, -0.03119478f, -0.02364857f, 
    0.01280926f, -0.02072144f, 0.02061674f, -0.00774510f, -0.00874446f, 0.00395800f, -0.03603624f, -0.03962420f, 
    0.00092707f, -0.03216768f, -0.02033488f, 0.02338975f, -0.00349533f, -0.03628552f, -0.03288971f, -0.00664848f, 
    -0.00696791f, -0.01294851f, -0.03151873f, 0.01842520f, 0.02075651f, -0.02158979f, 0.00099750f, -0.03765927f, 
    -0.02814954f, 0.02190471f, 0.03211856f, 0.00730800f, -0.00939225f, 0.01829197f, -0.01312043f, 0.01732490f, 
    0.02494354f, 0.00420431f, 0.01596688f, -0.02381815f, -0.03936975f, 0.00240722f, -0.00660200f, -0.01151319f, 
    0.01041175f, -0.01733240f, -0.03741643f, 0.01703846f, -0.03093732f, -0.04325422f, 0.00046098f, -0.02306588f, 
    -0.00261852f, 0.01829482f, -0.03223671f, 0.00268814f, 0.02251425f, -0.02830152f, 0.00276542f, 0.02403659f, 
    0.01480120f, -0.02559136f, -0.04233031f, -0.02256291f, 0.01535962f, -0.03561057f, -0.01197481f, 0.00388011f, 
    0.03050168f, -0.00803527f, 0.00744199f, -0.00757544f, 0.00504377f, -0.00950422f, -0.01552786f, -0.01091844f, 
    -0.02957385f, -0.02602241f, 0.01212229f, 0.00190511f, 0.00395092f, -0.03901515f, 0.02541156f, -0.03460745f, 
    -0.01177890f, -0.02585445f, -0.02952656f, -0.01161210f, -0.03983615f, -0.02794441f, -0.03556078f, 0.00582551f, 
    0.02124395f, 0.00667055f, 0.02684993f, 0.00818310f, 0.01941065f, -0.03073113f, -0.03390411f, 0.00295611f, 
    -0.01497564f, 0.03148646f, 0.01512950f, -0.00406534f, 0.02249805f, -0.03477873f, -0.03190264f, -0.01712680f, 
    0.00998175f, 0.00724867f, -0.03121625f, -0.02940774f, -0.04036273f, 0.01302376f, 0.02952951f, -0.02865968f, 
    -0.01877668f, -0.00912340f, -0.01650058f, -0.03194775f, -0.02334958f, -0.03324980f, -0.03325044f, -0.00909265f, 
    0.00769968f, -0.04097592f, -0.03381727f, -0.03872426f, 0.02724670f, -0.03578358f, -0.00991037f, -0.00779378f, 
    -0.03472902f, -0.00810708f, 0.02571160f, -0.01649356f, 0.02840756f, -0.03657771f, -0.00547396f, -0.02828219f, 
    -0.01067546f, -0.02590501f, -0.02429294f, -0.00572286f, 0.02233049f, 0.00982486f, 0.01015939f, -0.03420647f, 
    -0.03850067f, -0.02653139f, -0.01831715f, -0.02003260f, -0.04017343f, -0.03463710f, 0.01981953f, -0.01572636f, 
    -0.02773337f, -0.00339365f, 0.01013752f, -0.03514800f, -0.01836297f, 0.03187145f, -0.03203123f, 0.01621692f, 
    -0.02783303f, -0.04236579f, -0.02653656f, -0.04040883f, -0.01364009f, -0.00305948f, 0.02253948f, 0.02782555f, 
    0.01820873f, 0.00420852f, 0.00592522f, -0.01816760f, -0.00395849f, -0.01790518f, -0.00296144f, -0.02879182f, 
    -0.01018110f, 0.02403953f, -0.02122874f, -0.03334418f, 0.02308849f, 0.01142023f, -0.01383932f, -0.00981065f, 
    -0.03420649f, 0.02574690f, 0.01165052f, -0.01139510f, 0.00134775f, 0.01946406f, 0.01849777f, 0.00872662f, 
    0.02557377f, 0.01494255f, 0.01786932f, -0.01953372f, -0.03831936f, -0.01966242f, -0.03348703f, -0.03573086f, 
    0.00531380f, -0.01022537f, 0.02658388f, -0.00412718f, -0.01918423f, -0.02558665f, -0.02923603f, 0.01865370f, 
    -0.01212500f, -0.01267993f, -0.00419078f, 0.02300584f, -0.00954555f, -0.03717784f, -0.03970690f, -0.02077195f, 
    -0.00065596f, 0.02699918f, 0.02847804f, -0.02645938f, 0.01447981f, 0.00168642f, -0.01780895f, 0.01509815f, 
    0.05703246f, 0.11206521f, 0.17643033f, 0.08682470f, -0.04858698f, -0.07249737f, 0.01382750f, 0.02962164f, 
    0.06128073f, 0.01901296f, -0.00295332f, 0.13623039f, 0.04828902f, 0.02992124f, -0.11713042f, -0.04733652f, 
    0.09085383f, 0.10534894f, 0.16027068f, 0.06793981f, 0.01185716f, 0.00547373f, -0.04548753f, 0.04851298f, 
    0.33851728f, -0.38148624f, -0.03500925f, -0.17958258f, 0.00122299f, 0.06095036f, 0.03045341f, 0.05326138f, 
    0.03413885f, 0.00993478f, 0.11835770f, 0.01938195f, -0.48765209f, -0.10009929f, 0.06238333f, -0.16178963f, 
    0.08037291f, -0.00585185f, 0.11010775f, 0.05917926f, 0.10469898f, 0.13083857f, -0.04381597f, 0.05330999f, 
    -0.04086988f, 0.02475071f, -0.15613119f, -0.08114928f, 0.02378338f, -0.03002590f, 0.03640841f, 0.01804557f, 
    0.00309371f, 0.04971351f, 0.01905533f, -0.07746881f, 0.05936611f, 0.14307909f, -0.61238897f, 0.06011550f, 
    -0.02113453f, 0.02475066f, 0.11152700f, -0.11560331f, 0.15564443f, 0.12686059f, 0.19013682f, -0.03915431f, 
    -0.30022147f, -0.28612781f, 0.22579527f, -0.00456851f, 0.02916672f, -0.04744758f, -0.08110139f, 0.13739055f, 
    -0.01584668f, -0.09204601f, 0.06814417f, -0.02809330f, -0.22774924f, 0.10258585f, 0.05288114f, 0.09149233f, 
    -0.00003601f, 0.20515586f, -0.02952860f, 0.00807196f, 0.03531226f, -0.04605560f, 0.04541553f, 0.12442242f, 
    -0.00992946f, -0.16483042f, 0.05415773f, 0.08931167f, 0.05318747f, 0.05578367f, -0.04947104f, 0.00723188f, 
    -0.03817602f, 0.07350146f, 0.06178648f, -0.02542630f, 0.06603047f, 0.09115368f, -0.24051416f, -0.09787093f, 
    0.09542973f, -0.05424401f, 0.09647448f, 0.02132669f, 0.00958635f, -0.03957042f, -0.03222246f, -0.09077769f, 
    0.08784971f, 0.07103539f, 0.05050998f, -0.10812467f, 0.06801357f, 0.03591789f, 0.12373774f, 0.01184804f, 
    0.04516136f, -0.03097468f, 0.01732384f, 0.09923936f, -0.07495026f, -0.36782265f, -0.02193777f, -0.08228265f, 
    0.04276488f, -0.00961304f, 0.01830452f, -0.04056716f, 0.10078611f, -0.03037861f, -0.11488513f, 0.06983558f, 
    0.14599270f, 0.15175229f, 0.09784818f, 0.16684271f, 0.08314423f, -0.07298991f, 0.10036172f, -0.05914570f, 
    0.06148984f, -0.07921406f, -0.02914467f, -0.05929978f, 0.14885195f, 0.00747474f, -0.09974755f, -0.03592391f, 
    0.08115757f, 0.03828823f, 0.00618896f, 0.01075671f, 0.06084097f, 0.03468913f, 0.15222788f, 0.02229992f, 
    0.09945747f, -0.02356984f, 0.32062116f, 0.00247930f, -0.02192549f, -0.01486181f, -0.05628715f, 0.04529934f, 
    0.08774901f, 0.10550892f, 0.01552531f, 0.01792848f, 0.00215117f, -0.32563382f, -0.11789755f, -0.15798184f, 
    0.00015058f, -0.01294912f, 0.05924245f, 0.02056795f, 0.13158159f, -0.02997758f, -0.13508284f, 0.04091730f, 
    0.16475058f, 0.28406653f, 0.08174727f, 0.02210719f, -0.01095442f, 0.04205781f, 0.00736689f, -0.05843780f, 
    -0.04520775f, 0.02721599f, 0.13077092f, -0.00349567f, 0.01261355f, -0.23427986f, -0.09587593f, -0.07155024f, 
    0.01769628f, 0.00106915f, 0.01731621f, -0.07744480f, -0.06805888f, 0.05974329f, -0.02240416f, -0.01690193f, 
    -0.04761386f, 0.08315139f, 0.02734803f, -0.16840912f, 0.10342351f, 0.16118799f, 0.10449199f, -0.01734166f, 
    0.04919768f, -0.00008727f, 0.12427746f, 0.04743583f, 0.10332708f, 0.02420672f, 0.12051981f, 0.12303574f, 
    0.07715549f, 0.02216802f, 0.00852067f, 0.01557685f, -0.01782976f, -0.03685177f, 0.03142250f, -0.17531499f, 
    -0.35475171f, 0.07693599f, -0.09684101f, 0.10347520f, 0.11232246f, -0.08015669f, 0.09780179f, -0.03834083f, 
    0.05798830f, -0.11403074f, -0.10924722f, -0.01056413f, 0.07890145f, 0.17882787f, 0.05539327f, -0.04165711f, 
    0.02505769f, 0.04578764f, 0.05467857f, -0.03831697f, -0.02851166f, 0.01393218f, 0.04440338f, -0.00439088f, 
    0.06706955f, 0.07059401f, 0.04370400f, -0.04178134f, 0.09934179f, 0.01690661f, -0.02395566f, 0.13702664f, 
    0.11787917f, -0.07303353f, -0.11550848f, 0.00930778f, -0.04964542f, -0.05845512f, 0.03951450f, 0.03651382f, 
    -0.01346107f, 0.11900713f, 0.02358915f, 0.04883846f, -0.04717863f, 0.00989256f, 0.10389923f, -0.11088910f, 
    -0.21543565f, -0.39071918f, -0.02604652f, -0.02263945f, 0.05806118f, -0.04189290f, -0.01860729f, -0.06102222f, 
    -0.19735430f, -0.00301932f, 0.03541583f, 0.06459823f, -0.06066217f, -0.57862049f, -0.05886796f, -0.01809516f, 
    0.11024473f, 0.09553908f, 0.00514005f, -0.06178411f, -0.00653914f, 0.04358740f, 0.00528070f, -0.00646750f, 
    -0.01206896f, -0.09055050f, 0.04859038f, -0.11331403f, 0.12639695f, 0.02603001f, 0.04177039f, 0.13821009f, 
    0.14161244f, 0.10860110f, 0.05981090f, -0.10210537f, 0.09295730f, 0.05718112f, 0.21706517f, -0.03294346f, 
    0.04732975f, -0.00844170f, 0.00303182f, 0.10073273f, 0.05015697f, -0.03283973f, 0.05864097f, 0.14305753f, 
    0.15426284f, 0.36647448f, 0.33736587f, 0.08019428f, 0.07646020f, 0.06860258f, -0.03578300f, 0.01742638f, 
    0.07410490f, 0.02461487f, 0.09997579f, -0.04592950f, 0.03817225f, 0.07142784f, 0.22871108f, 0.02651992f, 
    -0.04269173f, 0.15537070f, -0.06163077f, 0.09772933f, -0.08101550f, -0.07204855f, -0.07342160f, -0.05677378f, 
    0.35050812f, 0.34397981f, 0.35598126f, 0.29073793f, -0.09099768f, -0.02228331f, 0.05140039f, 0.15242980f, 
    -0.01427917f, -0.05306647f, 0.05537554f, 0.00202758f, -0.13472997f, -0.03618372f, -0.04118547f, 0.05292210f, 
    0.03620471f, 0.15795238f, -0.01695561f, 0.05939416f, -0.08548800f, 0.02650772f, 0.18552005f, 0.08498878f, 
    0.07746737f, -0.06540229f, 0.12535819f, -0.16782121f, 0.10529892f, 0.00792690f, 0.02996930f, -0.00978667f, 
    0.09362205f, -0.02970993f, -0.01370183f, -0.10363340f, -0.06800091f, -0.25264725f, -0.09921443f, 0.21715602f, 
    -0.01194503f, -0.00358422f, -0.03591954f, 0.00531061f, 0.05474244f, -0.00785073f, -0.05660036f, -0.05001197f, 
    0.33615616f, -0.04450331f, -0.25301251f, -0.01499392f, 0.02737468f, 0.08750501f, 0.00653047f, 0.07528327f, 
    0.00547083f, -0.00999244f, 0.01072187f, -0.04195230f, 0.19763869f, -0.48421615f, -0.17422180f, -0.06951188f, 
    0.02052476f, 0.04767339f, -0.06575508f, -0.04320179f, 0.16183676f, -0.00683064f, 0.06653526f, 0.08362805f, 
    -0.24443769f, 0.10222587f, 0.07376958f, -0.05674130f, 0.02891702f, 0.16914156f, -0.00770602f, 0.08670042f, 
    0.00183806f, -0.03481316f, 0.02575161f, -0.02698519f, 0.17569718f, 0.14461789f, 0.36092710f, 0.08964934f, 
    -0.01564219f, 0.04514940f, -0.06369343f, 0.08710179f, 0.01158043f, -0.00913155f, -0.07022066f, -0.13457000f, 
    0.05180046f, 0.08184022f, 0.17365938f, 0.06000946f, 0.01176880f, 0.01732125f, 0.06383847f, 0.02127055f, 
    -0.02207814f, 0.01051963f, 0.06724786f, 0.06546036f, 0.28897199f, 0.16785659f, -0.00005529f, -0.03816655f, 
    0.01373160f, -0.01011321f, 0.03951888f, 0.07089984f, -0.00942857f, 0.05756989f, 0.05424043f, 0.02336032f, 
    -0.08154380f, 0.00762500f, -0.24677315f, -0.17932315f, 0.03401180f, -0.02741219f, 0.00716053f, -0.03149002f, 
    0.05456699f, -0.02383246f, -0.10459972f, 0.15560767f, 0.07617129f, 0.20212269f, -0.12041904f, -0.03493825f, 
    -0.00317916f, 0.03133900f, -0.00180937f, -0.00691164f, 0.02284166f, 0.00705840f, 0.13269596f, 0.01890055f, 
    -0.37801605f, -0.27993262f, -0.10323383f, 0.21780378f, 0.03920761f, 0.01590517f, -0.05929190f, -0.10484310f, 
    -0.01396711f, -0.02685345f, 0.01740741f, -0.04052012f, 0.18582541f, -0.57276517f, -0.20325986f, -0.14972568f, 
    -0.06940035f, 0.03497880f, 0.00818592f, 0.01974210f, 0.04394691f, 0.00260092f, -0.01669111f, -0.04863844f, 
    0.06882844f, -0.18095416f, 0.26250568f, 0.10723768f, 0.04063288f, -0.15332165f, -0.00878023f, 0.08620344f, 
    0.00627034f, -0.06137129f, -0.08749110f, -0.08209834f, -0.23456898f, -0.39890793f, -0.00291206f, -0.05237037f, 
    0.04133022f, -0.05624134f, 0.00537041f, -0.07779156f, -0.00737212f, 0.09521033f, 0.03125438f, 0.17912714f, 
    0.38040504f, 0.30992472f, 0.37109822f, 0.19788113f, 0.04872881f, -0.01604418f, -0.03032978f, 0.09898391f, 
    0.09267387f, 0.01353870f, -0.04759676f, -0.02298907f, -0.02587234f, 0.14563818f, 0.03767012f, 0.10234345f, 
    -0.00487665f, -0.07811357f, 0.06416249f, 0.08702552f, 0.06633925f, -0.04924192f, 0.20796889f, 0.09605797f, 
    0.07386772f, -0.17600466f, 0.02580569f, -0.21113761f, -0.00202798f, 0.04568914f, 0.03093989f, 0.02115110f, 
    0.02082759f, 0.12306917f, -0.17553687f, -0.05436886f, 0.21581382f, -0.00379587f, 0.17549825f, -0.05823979f, 
    0.09219174f, 0.02487019f, -0.03224898f, 0.08401573f, 0.03079553f, -0.05039957f, -0.04977620f, -0.11848803f, 
    -0.03404859f, 0.03075569f, -0.07680042f, -0.07134777f, 0.11455099f, 0.05676284f, -0.00026489f, -0.07497472f, 
    0.01369008f, 0.05682751f, -0.14863071f, 0.08068676f, -0.04616893f, -0.08831181f, -0.28764969f, 0.14001770f, 
    -0.09785868f, -0.00496238f, -0.05171514f, -0.17042775f, -0.01004381f, 0.02565374f, -0.01092223f, 0.07982457f, 
    -0.07005274f, -0.74199229f, -0.19800620f, -0.08588063f, -0.00874920f, -0.02933580f, -0.01701568f, -0.00964949f, 
    0.02821544f, -0.04928298f, -0.00710075f, 0.01504092f, -0.07614666f, -0.39093336f, 0.00106534f, 0.00080993f, 
    0.06119594f, -0.05973110f, -0.01078884f, -0.04628838f, 0.01786235f, 0.00398795f, -0.03569907f, 0.05520568f, 
    0.07487929f, -0.06280234f, -0.21084121f, -0.15445304f, -0.00101402f, -0.07760826f, 0.11138084f, -0.14342287f, 
    -0.02761756f, 0.02284433f, -0.06435165f, 0.02524396f, 0.07285938f, -0.29049104f, -0.07261008f, -0.17988798f, 
    0.02852137f, 0.00043511f, 0.03403914f, -0.08408920f, 0.03823640f, -0.07148233f, 0.06412484f, 0.00248468f, 
    0.15977749f, 0.10241637f, 0.14166540f, 0.11504675f, -0.02842841f, 0.05397617f, 0.04469017f, 0.18925881f, 
    0.02386420f, 0.09172932f, 0.06952152f, 0.11868376f, 0.12579507f, -0.02247189f, -0.09333320f, -0.05052004f, 
    0.09337483f, 0.09289562f, -0.09997003f, 0.10381530f, 0.05163509f, 0.00354971f, 0.03371006f, -0.04929233f, 
    -0.04739733f, -0.20102836f, -0.21796441f, -0.13591349f, 0.05367114f, -0.00787682f, -0.07359821f, -0.10721005f, 
    -0.03551278f, -0.02077732f, 0.06513474f, 0.12651494f, 0.38805184f, -0.29264024f, -0.02216214f, -0.06210173f, 
    0.10560938f, -0.00986833f, -0.11658189f, 0.01444895f, -0.07538856f, 0.02122114f, 0.17376798f, 0.08816680f, 
    -0.04559318f, 0.31205523f, 0.29198149f, 0.18829809f, -0.09671199f, -0.06600789f, 0.05505043f, -0.06248482f, 
    0.06339025f, 0.02583786f, 0.00700702f, -0.08053254f, 0.19248483f, -0.04194470f, 0.21320993f, -0.11103997f, 
    -0.03089219f, 0.05449116f, 0.01972726f, 0.05119725f, 0.00541069f, 0.00098377f, 0.07800113f, 0.03838961f, 
    0.25562418f, 0.03285678f, -0.11728102f, -0.08981062f, 0.04989737f, 0.16113734f, 0.04801077f, 0.03060000f, 
    -0.00390668f, 0.00108585f, 0.16414054f, 0.06088698f, 0.01240069f, 0.31135827f, 0.07492954f, 0.15828453f, 
    -0.03340891f, -0.02332781f, 0.14882207f, 0.19020286f, -0.01100493f, 0.03100703f, -0.01508068f, -0.00096796f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02744800f, 0.04424021f, -0.08030273f, 0.01216541f, -0.03327202f, -0.00355120f, 0.03780966f, -0.16210642f, 
    0.14229217f, 0.00757816f, 0.03022100f, -0.02418531f, 0.12215307f, 0.15950289f, -0.09755347f, -0.02892904f, 
    0.02510346f, -0.01887702f, 0.14683753f, 0.01057598f, -0.00475741f, 0.07538914f, 0.00281748f, 0.08324607f, 
    0.00758875f, 0.01934575f, 0.06767003f, 0.09625584f, 0.06751831f, -0.01449382f, -0.02570038f, 0.01846036f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.23658361f, -0.06516439f, -0.08772503f, -0.12075245f, -0.10349567f, 0.16653021f, -0.05541292f, 0.26439616f, 
    -0.10217495f, 0.16223729f, -0.11098037f, -0.17100911f, -0.26923215f, 0.09323648f, 0.08966730f, 0.02243679f, 
    -0.03726413f, -0.17213793f, 0.12725770f, -0.15033457f, -0.08119108f, -0.05808678f, -0.03231061f, -0.05198851f, 
    -0.04619640f, 0.29681230f, 0.21364707f, -0.11468740f, 0.00465456f, -0.04128884f, -0.06651567f, 0.16494861f, 
    0.16785547f, 0.39324719f, -0.22960867f, -0.10788192f, 0.08131912f, 0.06689836f, -0.20245703f, -0.32215577f, 
    -0.13282406f, -0.44951147f, 0.00513005f, 0.16897333f, 0.15626267f, 0.17117423f, 0.07729501f, 0.05976404f, 
    -0.11521009f, -0.09796700f, 0.15212953f, -0.11981419f, 0.02582194f, -0.05846551f, 0.27967620f, 0.19926754f, 
    0.03778204f, 0.20171314f, 0.08325188f, -0.13296463f, 0.11445362f, -0.13688183f, -0.15512516f, -0.33207732f, 
    -0.08414607f, -0.02386260f, -0.29039356f, -0.09815466f, 0.13170978f, -0.11119527f, -0.01302266f, 0.21837871f, 
    0.20366256f, 0.22778794f, -0.29803610f, 0.10272192f, -0.08579601f, 0.22944796f, -0.22063459f, -0.06320599f, 
    -0.07275859f, -0.08690902f, -0.03021166f, 0.17289776f, 0.11703950f, 0.14791127f, 0.07147107f, 0.42685395f, 
    -0.03663440f, -0.19347084f, -0.02701264f, 0.28673679f, 0.13661985f, 0.10750791f, -0.16839156f, -0.03514810f, 
    0.11819043f, 0.13435133f, 0.35824564f, 0.11065374f, 0.11167438f, -0.08369238f, 0.16090764f, 0.28357449f, 
    -0.10083412f, -0.00875425f, -0.04343024f, -0.14966241f, 0.08285022f, -0.57531607f, 0.64534968f, 0.00342388f, 
    0.07929615f, 0.22049311f, -0.00826869f, -0.08323627f, 0.15010108f, 0.06901801f, 0.25634453f, 0.07550381f, 
    -0.00483610f, -0.37623385f, -0.09155572f, 0.00429654f, -0.01769204f, -0.10860913f, -0.16162439f, -0.02407053f, 
    0.33610475f, -0.37144560f, 0.15488018f, 0.12560554f, -0.13257991f, -0.12426092f, 0.01855709f, -0.25353208f, 
    0.09917513f, -0.21833912f, 0.29080281f, 0.12788725f, 0.08222651f, -0.23198314f, -0.04426207f, -0.08828356f, 
    -0.12930900f, 0.14056411f, 0.22970130f, 0.14061809f, 0.06804863f, 0.21273547f, -0.12773788f, -0.14671406f, 
    0.15342581f, 0.19901644f, 0.16736688f, -0.12982370f, 0.28339383f, -0.09617545f, 0.05928376f, -0.42189500f, 
    0.49722049f, -0.07440295f, -0.07112761f, -0.02952153f, -0.13541508f, 0.02148642f, 0.15286779f, -0.19941957f, 
    0.02536068f, -0.10104895f, 0.32881433f, 0.01380857f, 0.33666804f, 0.03087935f, -0.05023977f, -0.01553259f, 
    0.10985567f, -0.00484801f, -0.12980036f, -0.07041943f, -0.13838190f, -0.18689846f, 0.12435924f, -0.11698753f, 
    -0.13279349f, -0.18403530f, -0.20253824f, 0.29676872f, -0.15820459f, -0.11823155f, -0.13268550f, -0.14706855f, 
    -0.04510318f, 0.06872693f, 0.22841060f, 0.10639362f, 0.03521111f, 0.07437579f, 0.16252448f, -0.28686640f, 
    -0.18089442f, 0.13913950f, 0.02284187f, 0.16917592f, 0.09638789f, 0.25235316f, -0.33767635f, -0.13799100f, 
    -0.13777286f, 0.09228622f, 0.04010348f, -0.17393124f, -0.11541608f, -0.08069856f, 0.37763396f, -0.26958731f, 
    0.11244924f, 0.25236234f, -0.31332359f, 0.25120729f, 0.27731317f, -0.16234295f, 0.09066218f, -0.02667375f, 
    0.35433620f, -0.36139193f, 0.16419683f, 0.04879076f, -0.06128256f, -0.05927281f, 0.19774409f, -0.07776871f, 
    0.08498589f, 0.22774203f, 0.09237549f, 0.06571367f, 0.02597404f, 0.10840452f, -0.07101904f, 0.10461728f, 
    0.07815018f, 0.07287794f, -0.15010606f, -0.03528673f, 0.04565077f, -0.01542590f, -0.08839639f, 0.38700926f, 
    0.08782515f, 0.28360566f, 0.19550110f, -0.16093671f, -0.05754679f, -0.14989072f, 0.13476881f, -0.11141215f, 
    0.20451275f, 0.34012353f, 0.04381642f, 0.03208511f, -0.13507530f, 0.04745269f, -0.33378446f, -0.01270143f, 
    -0.42780828f, -0.02639191f, -0.22844976f, -0.11587481f, -0.01964234f, -0.08037085f, 0.21393983f, -0.03419372f, 
    0.00289429f, -0.22031294f, 0.02343543f, 0.05518683f, -0.08657365f, -0.04493558f, 0.02881111f, 0.07462670f, 
    0.06220620f, -0.02735463f, 0.08092318f, -0.32287696f, -0.06615584f, -0.12314959f, -0.05488565f, -0.09421504f, 
    0.35636190f, -0.24104510f, 0.20949122f, -0.15425724f, -0.00905896f, -0.15044256f, 0.15821108f, 0.09735279f, 
    0.16297919f, -0.14187826f, 0.03052117f, -0.16259786f, 0.05576974f, -0.19406265f, -0.17900468f, -0.08852941f, 
    0.14000277f, 0.15284871f, 0.32433227f, 0.04188288f, -0.06084220f, 0.19144192f, -0.32841444f, 0.16451976f, 
    -0.16309915f, -0.54108036f, -0.10812719f, 0.12722871f, 0.06611302f, 0.00400119f, 0.04712182f, -0.22226083f, 
    -0.15877780f, 0.03484730f, -0.11976139f, -0.18111560f, 0.08872756f, 0.13775040f, -0.00643450f, -0.15903796f, 
    -0.07485353f, -0.13211775f, 0.18315987f, 0.06467447f, -0.04910145f, -0.22849157f, 0.02202798f, -0.13902508f, 
    0.06721321f, -0.14816730f, -0.06390528f, -0.06643232f, 0.04271799f, 0.01358633f, -0.07953008f, -0.14877416f, 
    0.07609658f, -0.15468326f, -0.11524591f, -0.16787501f, -0.08098724f, -0.11143680f, 0.15598604f, -0.11471472f, 
    0.02986082f, 0.09786406f, -0.30677128f, -0.04578284f, 0.05196942f, -0.13449155f, 0.20286205f, -0.14996229f, 
    -0.22252579f, 0.31856528f, 0.02714401f, -0.03811419f, 0.01331753f, 0.27663708f, -0.18964256f, 0.07325350f, 
    0.05397959f, -0.36378622f, 0.09862288f, 0.02801223f, 0.05329603f, 0.20570795f, 0.38261950f, 0.19312726f, 
    -0.13362135f, 0.26424399f, 0.28209099f, 0.03988316f, -0.07000708f, -0.16718327f, 0.00267733f, 0.23783091f, 
    0.13044439f, -0.11128569f, -0.06078326f, 0.02781665f, 0.15860642f, -0.02691105f, 0.20722465f, -0.00277148f, 
    0.27581185f, -0.24509387f, -0.04751028f, -0.05116891f, 0.16744520f, 0.06844760f, -0.07953563f, 0.09384464f, 
    0.12985741f, -0.00810269f, 0.19003700f, -0.00601256f, 0.02082787f, 0.20039895f, -0.03256860f, -0.31304708f, 
    -0.12460584f, -0.41236085f, -0.39511552f, 0.33892131f, 0.07123106f, 0.12761447f, -0.14333993f, -0.05062373f, 
    0.03861098f, 0.09814323f, 0.18337083f, 0.01184619f, -0.04600189f, -0.17091393f, -0.03708298f, -0.16847247f, 
    0.02314967f, 0.07299957f, 0.24069580f, -0.14489794f, -0.35766414f, -0.08137780f, 0.19174697f, -0.08172577f, 
    -0.17815705f, 0.33932877f, -0.12763429f, 0.07672185f, -0.07239334f, -0.00008248f, 0.24218094f, -0.15347448f, 
    -0.04226138f, 0.15293951f, -0.04798761f, 0.06275274f, -0.15273817f, 0.13655372f, 0.02116378f, 0.13136946f, 
    0.00019657f, -0.17387378f, 0.24740487f, 0.16017413f, 0.13609909f, 0.10384528f, 0.30680376f, 0.38691139f, 
    0.19242649f, 0.40118903f, 0.37349245f, 0.08392426f, -0.06273405f, -0.00699548f, 0.02594792f, 0.14718258f, 
    -0.07926571f, 0.25750974f, -0.20921725f, 0.12680027f, -0.07136666f, -0.06798754f, -0.12901203f, -0.03426139f, 
    0.14295265f, -0.07824856f, -0.16347493f, 0.05315307f, -0.18564591f, -0.10985970f, -0.02372201f, 0.20793292f, 
    -0.32944697f, 0.19539337f, -0.09254670f, -0.04610983f, 0.09353597f, -0.11341044f, -0.03599443f, -0.07246942f, 
    0.14368606f, -0.14459904f, 0.02126992f, -0.10288678f, 0.10353961f, 0.07699820f, -0.52053463f, -0.12302606f, 
    0.12717567f, 0.23059885f, 0.36679029f, 0.10220303f, 0.05608995f, 0.04711399f, -0.22297096f, 0.06222103f, 
    0.16504358f, 0.07065210f, 0.07239312f, -0.16658823f, -0.05606429f, -0.06299143f, 0.01622641f, 0.01756206f, 
    -0.22668874f, 0.26098961f, -0.16724877f, -0.02390972f, 0.04322623f, 0.03047685f, 0.12895571f, 0.21692418f, 
    0.15313692f, 0.24826537f, -0.04602785f, -0.01215558f, 0.19333884f, -0.10687629f, 0.05399351f, -0.09786456f, 
    0.03775466f, 0.04172129f, -0.27414870f, 0.12862054f, -0.16338007f, -0.17182112f, -0.28191122f, 0.35720778f, 
    0.18082350f, -0.16659553f, 0.09827723f, -0.00600163f, -0.31336683f, 0.01287161f, 0.17690924f, -0.01946688f, 
    -0.34434137f, -0.18394156f, 0.05449210f, 0.03139778f, -0.09485260f, -0.14361182f, 0.13198388f, -0.09085913f, 
    0.20730206f, -0.03780464f, 0.29258317f, -0.10318027f, -0.01821710f, 0.27831930f, -0.14917883f, -0.15543553f, 
    -0.16930522f, 0.29725865f, 0.12223447f, 0.05344410f, -0.17055272f, 0.03038003f, -0.20921722f, -0.34202334f, 
    0.06901570f, 0.07151696f, -0.25813702f, 0.08218184f, -0.09228250f, -0.07266751f, 0.17693169f, 0.10383887f, 
    0.54848158f, 0.01077240f, -0.09194496f, 0.15492414f, 0.10905813f, -0.12093607f, 0.02075628f, -0.50694352f, 
    -0.06660262f, -0.14023514f, 0.29329407f, -0.14853424f, 0.21092294f, 0.15147391f, 0.17623073f, -0.15527390f, 
    0.14577325f, -0.15161161f, 0.01561877f, -0.07918071f, -0.08226572f, -0.22672446f, 0.10671144f, 0.19221199f, 
    0.13980022f, -0.24731870f, 0.00614019f, 0.24758115f, 0.03766587f, 0.01288219f, 0.10475654f, -0.33659554f, 
    -0.10518735f, -0.03110927f, 0.05788005f, -0.08464079f, 0.00269717f, 0.03916053f, 0.09200385f, -0.15557671f, 
    0.06192740f, 0.14072524f, -0.00316610f, -0.10790189f, -0.14495990f, -0.15491621f, -0.02651263f, -0.14921479f, 
    0.08659068f, -0.07716540f, -0.07908763f, -0.07026851f, -0.06282493f, -0.19526342f, -0.07586730f, 0.08143943f, 
    0.00358585f, -0.04643179f, -0.05086611f, -0.10001973f, -0.13718756f, 0.17149730f, -0.13751520f, -0.14698790f, 
    0.15409191f, 0.03710826f, 0.18071325f, -0.02118930f, 0.07634021f, -0.15237851f, -0.04832956f, -0.27079934f, 
    -0.11992925f, 0.00983472f, -0.09628910f, -0.00304627f, 0.02702646f, -0.13450941f, 0.00584695f, 0.14039770f, 
    -0.07368173f, 0.00990341f, 0.13533264f, 0.01296844f, -0.11052604f, 0.13941687f, 0.22482175f, -0.14315630f, 
    -0.16497740f, -0.12744744f, -0.18801424f, -0.10594407f, -0.08495016f, 0.14651158f, 0.15589322f, -0.19303919f, 
    -0.13169990f, 0.09796347f, -0.19551173f, 0.00994786f, 0.02003196f, 0.16841421f, 0.04012595f, -0.18055283f, 
    0.24414133f, 0.07354908f, 0.23230352f, 0.11459691f, -0.15595794f, -0.04655510f, 0.22866799f, -0.04604273f, 
    0.10562655f, -0.06503136f, 0.14659186f, -0.13408110f, -0.12028586f, -0.16177204f, 0.25803345f, -0.23422149f, 
    -0.14729254f, 0.17805557f, 0.20887098f, 0.11291665f, -0.21069041f, -0.15189759f, -0.00996294f, 0.24339551f, 
    0.05691577f, -0.19561093f, 0.18830170f, -0.08855209f, 0.02205016f, 0.15080406f, 0.16364752f, 0.05066270f, 
    0.19830987f, 0.05457137f, 0.17816159f, -0.07173582f, -0.11911689f, -0.23529547f, 0.21402155f, 0.03304954f, 
    0.07813662f, -0.01615561f, -0.10744516f, -0.07249095f, 0.03102113f, -0.10160300f, -0.07127157f, -0.12562937f, 
    0.07326590f, -0.04200349f, 0.07508914f, -0.09479713f, -0.03928982f, 0.17171955f, 0.09447126f, 0.35058433f, 
    -0.08829678f, 0.09649655f, 0.21556963f, 0.01108711f, 0.09295525f, 0.00800877f, 0.18025284f, 0.03853690f, 
    -0.13612272f, 0.14133587f, 0.02270257f, -0.16017073f, -0.14385813f, -0.38761485f, 0.37427813f, -0.10993451f, 
    -0.02480685f, -0.17785104f, -0.02497672f, 0.06110802f, 0.01926753f, 0.04456479f, 0.34291685f, -0.03332502f, 
    0.09544962f, 0.00244065f, -0.03404209f, 0.21108879f, -0.05060293f, -0.07974198f, -0.02661518f, -0.06556944f, 
    0.00878651f, 0.10725272f, 0.23547198f, -0.04188919f, 0.11121885f, -0.00170517f, 0.14318109f, 0.07231145f, 
    0.05622917f, -0.07011681f, 0.33299932f, 0.01212120f, -0.29091838f, -0.22822973f, 0.34022725f, 0.00949056f, 
    -0.02627228f, -0.01402664f, 0.21006431f, 0.04873343f, -0.16907898f, 0.17700042f, 0.23883176f, -0.47626120f, 
    0.00894651f, -0.15796402f, -0.10106238f, -0.16434541f, 0.15341406f, -0.00570550f, -0.06279582f, 0.16271929f, 
    -0.47058940f, 0.18704681f, -0.25370392f, 0.04441202f, 0.10561349f, 0.04010784f, 0.15684044f, -0.21204014f, 
    -0.06886197f, 0.16532320f, 0.02394442f, -0.11802689f, 0.30816951f, 0.16623713f, 0.04561858f, 0.04747083f, 
    0.06248436f, -0.10558915f, 0.34523174f, 0.02909106f, -0.00853649f, 0.32962403f, -0.23277587f, 0.21565960f, 
    -0.02063600f, -0.30119717f, 0.06945672f, 0.04708414f, -0.05639421f, -0.14781339f, 0.14287317f, 0.12018291f, 
    0.27602893f, 0.26599422f, -0.30899894f, -0.12116575f, -0.08913609f, -0.17188162f, -0.17338590f, -0.05975420f, 
    0.12324435f, -0.18784451f, 0.15604806f, -0.00372895f, 0.22367160f, -0.09565045f, 0.19236450f, -0.07613559f, 
    0.03488016f, -0.05967886f, -0.17866191f, -0.15585735f, -0.13275252f, 0.05471585f, 0.12628533f, -0.19034232f, 
    0.01851030f, 0.14577730f, 0.10197603f, 0.29431048f, -0.24931237f, 0.00854653f, -0.04203284f, 0.09804691f, 
    -0.15505366f, -0.15304799f, 0.12802434f, -0.11501695f, -0.09362352f, 0.13341439f, 0.18832986f, 0.07832628f, 
    0.01028580f, 0.12209546f, -0.11177691f, -0.15230510f, -0.11742095f, 0.10751931f, -0.25171119f, 0.16313930f, 
    -0.08078545f, -0.08168993f, 0.19054078f, 0.09135237f, -0.16789515f, 0.32838109f, -0.17904639f, 0.33800951f, 
    -0.14016110f, 0.01928363f, 0.31827861f, -0.19657516f, 0.18789269f, -0.01577492f, -0.13076366f, 0.06357086f, 
    -0.07367663f, 0.31682402f, -0.23455782f, -0.05548219f, -0.10259532f, 0.10748797f, -0.08232821f, 0.18327762f, 
    0.01126486f, 0.30168682f, -0.11462087f, 0.16898338f, -0.29702520f, 0.28414881f, 0.16148600f, 0.06415000f, 
    -0.12421738f, 0.21414478f, -0.01869886f, -0.08685622f, -0.12042855f, 0.02885507f, 0.23304302f, 0.21562342f, 
    -0.00325480f, 0.02386577f, 0.27073511f, 0.01374225f, -0.20977154f, -0.15301627f, -0.10765065f, 0.28332642f, 
    0.40882155f, 0.14084953f, 0.31623301f, -0.04243031f, 0.08674169f, -0.10903060f, 0.11818748f, -0.02586811f, 
    -0.14514279f, 0.06382147f, 0.03848869f, 0.06159323f, -0.15382136f, -0.20292434f, -0.04347462f, 0.00305402f, 
    -0.15059200f, 0.20631060f, 0.11520523f, 0.10124353f, -0.07238938f, 0.03998671f, 0.08597292f, 0.28774750f, 
    -0.03909883f, -0.15133946f, 0.05535937f, -0.22215448f, 0.37764019f, -0.07082318f, -0.12966000f, -0.12778556f, 
    -0.02549980f, 0.08494660f, 0.05334618f, -0.08653289f, 0.04927978f, -0.09481085f, -0.24699026f, -0.29931346f, 
    -0.09183116f, -0.49995551f, 0.01877909f, -0.14698598f, 0.25006235f, -0.12684354f, -0.29882100f, -0.09910880f, 
    -0.03241126f, 0.37087443f, 0.18655653f, 0.03207194f, 0.00143868f, 0.30004254f, -0.24244137f, -0.26585338f, 
    0.07404248f, 0.09023417f, -0.00790740f, 0.10524801f, -0.20918280f, -0.11589264f, 0.02753542f, 0.16435242f, 
    0.13383344f, 0.20257074f, -0.35089946f, 0.03770540f, -0.15555713f, -0.00703551f, 0.01449624f, -0.01161015f, 
    0.21897699f, -0.17811787f, -0.09021079f, -0.00399550f, -0.00427307f, 0.04331394f, 0.08857237f, -0.11121101f, 
    0.07398421f, -0.25930586f, 0.03357793f, -0.13127913f, -0.04293482f, 0.17825665f, 0.38829756f, -0.36738926f, 
    0.06097193f, 0.00825825f, -0.38709170f, 0.26885828f, -0.03241313f, 0.11560454f, -0.10314158f, 0.15650149f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.18644218f, 0.00257101f, 0.11518361f, -0.10213155f, 0.10220373f, -0.00821398f, 0.27406272f, 0.20046115f, 
    0.14703363f, 0.07206874f, 0.12928112f, -0.02547932f, -0.01447873f, 0.10756078f, 0.08134580f, -0.03314092f, 
    -0.18832453f, -0.14527386f, 0.21917650f, -0.19686726f, -0.04946156f, -0.08292466f, -0.05846420f, -0.06280983f, 
    -0.27943522f, 0.24626943f, 0.03459984f, 0.04983371f, -0.19035199f, -0.21568215f, -0.30661109f, 0.15936282f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.00055576f, 0.00090717f, -0.14502375f, 0.23065105f, -0.13354427f, -0.23043585f, -0.35967231f, 0.12713616f, 
    -0.82707906f, -0.36305624f, 0.08744203f, -0.38008329f, -0.45079994f, 0.19660795f, 0.15927106f, -0.18147118f, 
    0.26170608f, 0.02866467f, 0.20294319f, 0.00267588f, 0.04049338f, 0.09358659f, 0.12160334f, 0.02411510f, 
    0.00091733f, -0.34916005f, -0.09699836f, -0.10678464f, 0.19305047f, -0.02518790f, -0.59597206f, -0.67752427f, 
    -0.06373038f, 0.23078182f, 0.22290409f, -0.35803956f, -0.26858267f, -0.27228096f, -0.24996336f, 0.05699908f, 
    0.02539101f, -0.03716554f, -0.04439703f, 0.07313039f, -0.21560219f, -0.58756828f, 0.13082772f, 0.10952044f, 
    0.40932095f, -0.18644096f, -0.13353503f, -0.07350816f, -0.07853323f, -0.12203875f, 0.00570846f, -0.26472262f, 
    -0.54309350f, 0.21575090f, 0.05375572f, 0.16494730f, 0.20960239f, 0.03131778f, -0.05712081f, -0.23531206f, 
    0.29960528f, -0.30542693f, 0.00791512f, -0.14402097f, 0.21138683f, 0.35086280f, -0.09136088f, 0.18300369f, 
    -0.33231664f, 0.21293257f, -0.13743925f, -0.12314115f, 0.09456694f, -0.29421875f, 0.14311765f, -0.36231586f, 
    -0.02316694f, 0.09897929f, 0.39982635f, 0.03972523f, -0.04099666f, 0.05642425f, -0.36375311f, -0.06772783f, 
    -0.31864601f, 0.00426270f, -0.03629194f, -0.02673615f, -0.28152013f, -0.12168826f, -0.52799797f, -0.15145007f, 
    -0.59886360f, -0.47589174f, -0.34521934f, 0.25221759f, -0.05504977f, 0.03777365f, -0.01834084f, -0.16049543f, 
    -0.55659848f, 0.36628053f, -0.14603019f, -0.29484081f, 0.00966291f, 0.01585786f, 0.20965412f, -0.23928748f, 
    -0.17899995f, -0.10394006f, -0.30587107f, -0.02475885f, -0.37407628f, -0.18008162f, 0.15853097f, 0.13079081f, 
    0.28859514f, -0.06138487f, -0.07879472f, -0.06429116f, -0.26314732f, 0.22722416f, -0.05479540f, -0.25418791f, 
    -0.06393158f, 0.06514382f, -0.11151631f, -0.04287836f, -0.20060836f, 0.09704717f, -0.23231177f, -0.02939542f, 
    0.08228592f, -0.08459257f, -0.16441248f, -0.12978837f, 0.04963600f, 0.05372879f, 0.08476333f, -0.05613587f, 
    -0.16935278f, 0.04084462f, -0.63647461f, -0.09292389f, -0.14145614f, 0.23176838f, 0.05157368f, -0.16211286f, 
    0.24691023f, -0.19102201f, 0.20302726f, -0.22134885f, 0.14444424f, -0.30642927f, -0.09770811f, 0.18407512f, 
    -0.01496716f, -0.16776279f, -0.06950340f, -0.49110949f, 0.07239637f, -0.28239280f, 0.31614015f, 0.11700799f, 
    -0.47639257f, -0.31080776f, 0.11874793f, 0.10632989f, -0.21942125f, -0.02815616f, 0.10633086f, 0.13956584f, 
    -0.39217150f, 0.26916412f, -0.25392985f, -0.06194436f, -0.10246663f, 0.08240275f, 0.00299787f, -0.26536536f, 
    0.01527230f, -0.05189874f, -0.27510709f, 0.10659047f, 0.12422264f, 0.10601188f, -0.14240476f, -0.26600912f, 
    0.06123563f, 0.23330790f, -0.25002199f, -0.26419863f, 0.07016078f, 0.37632304f, 0.23393665f, 0.01009819f, 
    -0.74517012f, -0.07310740f, 0.17256479f, -0.11016489f, 0.10886410f, -0.17818852f, -0.69746697f, -0.06754792f, 
    -0.34984466f, -0.03548055f, 0.28651068f, 0.00471922f, -0.12575658f, -0.19060043f, -0.32402298f, -0.29130024f, 
    -0.47578207f, -0.07457238f, 0.28242302f, -0.37928078f, -0.38265184f, -0.06558691f, 0.16996752f, 0.16996455f, 
    -0.06533535f, 0.18441825f, -0.11515900f, 0.34126654f, 0.05779544f, -0.37020379f, 0.07274723f, -0.21542098f, 
    -0.07282382f, -0.26696983f, -0.00625463f, -0.01075886f, -0.37248677f, 0.01153611f, -0.51716000f, -0.11010495f, 
    0.14578967f, -0.38452464f, 0.04323907f, -0.13311641f, -0.08495755f, 0.05848419f, -0.08351067f, 0.21806298f, 
    0.29759073f, 0.01823964f, -0.15591563f, -0.15369478f, 0.14039169f, 0.37311074f, -0.38874847f, 0.08038111f, 
    0.04094853f, -0.13052854f, -0.24625115f, 0.01170627f, 0.39219823f, -0.07001432f, -0.17984986f, 0.16475351f, 
    -0.24426888f, 0.23365682f, 0.09561392f, 0.04175908f, -0.22448304f, -0.55329835f, -0.40122002f, 0.04429841f, 
    -0.36117065f, -0.41525468f, -0.16840024f, -0.01027545f, -0.06614009f, -0.68366975f, -0.27128607f, -0.20752423f, 
    -0.10896771f, 0.06504034f, -0.48954463f, 0.37069526f, -0.37693706f, 0.33212265f, -0.03597095f, -0.02101122f, 
    -0.32208437f, -0.10031492f, 0.11063692f, 0.08441132f, -0.34174120f, 0.14252032f, 0.23139033f, -0.12048393f, 
    -1.18066549f, -0.62897652f, -0.01141511f, 0.22853756f, 0.05015450f, -0.19694164f, -0.14285411f, -0.38717434f, 
    0.04018603f, -0.07581778f, -0.10675059f, -0.19866294f, -0.11921165f, 0.03987649f, -0.35036257f, 0.36476544f, 
    -0.21812733f, 0.14622004f, 0.06318393f, -0.10253889f, -0.00777780f, -0.53208458f, -0.29953992f, 0.26664680f, 
    -0.54507858f, -0.49889365f, 0.46409252f, 0.08523197f, -0.12963636f, -0.41420874f, -0.10165233f, -0.26618019f, 
    -0.61278796f, 0.44720602f, -0.04851850f, -0.49105036f, 0.30544841f, -0.32462138f, 0.01137848f, 0.19076730f, 
    -0.09634026f, 0.19501173f, -0.24357408f, 0.10144841f, -0.16795720f, -0.61353713f, -0.47288904f, -0.41866839f, 
    -0.27159220f, 0.11327480f, -0.43704599f, 0.04776642f, 0.08709761f, 0.02463906f, -0.14316638f, -0.03310663f, 
    -0.62351072f, -0.02615312f, -0.58140457f, -0.25015658f, 0.23214196f, -0.18176858f, -0.13988709f, -0.42893738f, 
    -0.62957114f, 0.03712622f, -0.01185629f, -0.18339673f, 0.08067657f, -0.07164552f, -0.10908505f, 0.34677804f, 
    -0.21957868f, 0.23846765f, -0.26068708f, -0.12369027f, -0.08392367f, 0.16776270f, -0.10859086f, -0.19201587f, 
    0.11794180f, 0.30597216f, 0.04343705f, -0.06970414f, -0.24018979f, -0.29992193f, 0.38404164f, -0.00554780f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.45946097f, -0.12543818f, 0.15510975f, -0.07952856f, 0.11005583f, 0.10300908f, 0.20537639f, 0.02937084f, 
    -0.05956928f, -0.13400641f, 0.10291854f, -0.18824841f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
