#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.73556447f, -0.34423533f, -0.95319039f, -0.96249813f, -0.43054345f, 0.49985769f, 0.43451676f, -0.05684605f, 
    0.13760684f, 0.56738114f, 0.13857040f, 1.04089773f, -0.53248048f, -0.00971110f, -0.35891688f, -0.55608028f, 
    0.27493089f, -0.29009676f, -0.33657467f, -0.23262665f, 0.46005934f, -0.27280974f, 0.02504824f, 0.21449819f, 
    0.31358492f, -0.91746700f, -0.95090699f, -0.61538804f, 0.76047879f, 1.20295966f, -0.12142439f, -0.22929259f, 
    -0.38707286f, -0.21704295f, -0.04509816f, -0.33371156f, -0.36530784f, -0.16263522f, -0.04993899f, -0.42199105f, 
    0.07047970f, -0.17094883f, 0.01489488f, 0.18625009f, 0.22531292f, -0.09356447f, -0.35220650f, -0.38692707f, 
    -0.25885341f, -0.40164873f, 0.19983201f, -0.56981736f, 0.13607606f, 0.46369931f, 0.82545555f, 0.57795721f, 
    0.61709225f, 0.36222202f, 0.34081948f, 0.85591543f, 0.10476582f, 0.39273626f, -0.53247976f, -0.35148168f, 
    -0.15945292f, 0.10415521f, 0.03707333f, -0.25507516f, -0.21696706f, -0.38490629f, -0.42835727f, 0.35449511f, 
    0.02378212f, -0.10538807f, 0.15641768f, -1.28861856f, 0.69481516f, 0.08504800f, -0.77806681f, -0.07388984f, 
    -0.50959837f, -0.06952854f, 0.41838571f, 1.04852116f, 0.19974688f, -0.07946325f, -0.19829227f, 0.37776163f, 
    -0.50023204f, 0.14605670f, -0.08936504f, -0.30074492f, -0.33821279f, 0.10491544f, 0.56176132f, -0.02774595f, 
    0.28045195f, -0.09840235f, 0.01977170f, 0.02612811f, -0.76937801f, -0.86641830f, -0.85246527f, -0.31465670f, 
    -0.20869038f, 0.84020102f, 0.56790900f, 0.06452525f, -0.43742079f, -0.42308497f, -0.30433741f, -0.55935442f, 
    -0.34409529f, 0.39810160f, -0.03704591f, 0.06400488f, -0.13280545f, 0.27654427f, -0.45166337f, -0.43967986f, 
    -0.04996075f, 0.18934229f, 0.12554103f, 0.26129913f, -0.12203495f, 0.77640337f, 0.90886658f, 0.62012106f, 
    0.27297992f, 0.30057931f, -0.84489715f, -0.51495498f, -0.23104993f, 0.36876157f, 0.41735676f, 0.48938757f, 
    -0.16014479f, -0.09136523f, 0.28276584f, -0.22206298f, -0.12512265f, -0.11343379f, 0.11675689f, 0.03340100f, 
    -0.16403745f, -0.17743629f, 0.12442119f, -0.15715863f, 0.09258208f, 0.03930265f, -0.30368081f, -0.75423056f, 
    -0.55774099f, -0.33560389f, -0.79214430f, 0.54687995f, 0.54123431f, -0.23145646f, -0.29169130f, 0.25628793f, 
    -0.10166340f, -0.34730080f, -0.07846591f, -0.17578436f, 0.05810603f, 0.00787834f, 0.13248368f, -0.17818242f, 
    0.17092255f, 0.18408959f, -0.42818633f, -0.21816590f, -0.19031322f, -0.41750133f, -0.15094596f, 0.08803464f, 
    -0.60359704f, 0.64295387f, 0.78229570f, -0.41589391f, 0.48554099f, -0.18995333f, -0.67215925f, -0.92559165f, 
    -0.57259083f, 0.14825194f, -0.37848309f, -0.26752833f, -0.41920036f, -0.34462598f, -0.34924275f, -0.13744131f, 
    -0.01343618f, -0.03789677f, 0.27555594f, 0.16008170f, 0.00594141f, -0.16144598f, 0.05773000f, -0.05297672f, 
    0.58795857f, 0.24975030f, 0.51158875f, -0.44728708f, -0.08781479f, -0.19066496f, 0.12704977f, 0.19800840f, 
    -0.24837665f, -0.15651169f, -0.30038759f, 0.01347887f, 0.37798735f, -0.35016829f, -0.25973427f, 0.22873962f, 
    0.22474207f, -0.52447528f, 0.13712673f, 0.00494594f, -0.46263590f, 0.31509274f, 0.33374941f, 0.18697265f, 
    0.60374761f, -0.68892366f, -0.60674083f, -0.71304017f, -0.36945516f, 0.01560457f, -0.34137869f, -0.74290472f, 
    -0.61909819f, -0.78286737f, -0.31039131f, -0.01913042f, -0.38356349f, 0.03037385f, 0.64629722f, -0.64992177f, 
    -0.08312142f, -0.10734349f, 0.21975237f, 0.14977781f, -0.03502791f, -0.21384309f, 0.17787443f, 0.32709390f, 
    -0.43913093f, 0.01091592f, 0.78704995f, 0.87216592f, 0.83532798f, -1.06557119f, -1.41525781f, -0.36393008f, 
    0.37436381f, 0.21812733f, -0.09113312f, -0.24598445f, -0.03869212f, -0.16051823f, 0.87942207f, -0.35345238f, 
    -0.08690004f, 0.07935900f, 0.10100369f, -0.04413280f, -0.11246935f, 0.22965631f, 0.23994282f, 0.15010625f, 
    -0.19650678f, 0.02588854f, 0.09021909f, 0.78782398f, 0.42308331f, 0.25852689f, -0.34071422f, 0.16246933f, 
    0.51128423f, 0.25674665f, 0.32688415f, -0.47312024f, -0.14507248f, -0.31930730f, 0.30574751f, 0.19733869f, 
    -0.08774269f, -0.36533076f, 0.09734730f, 0.09775642f, -0.08007176f, -0.19963798f, -0.09196829f, 0.11078150f, 
    -0.29011762f, -0.40408295f, -0.55868262f, -0.47278264f, -0.96658951f, -0.98756230f, 0.13609846f, 0.05060595f, 
    0.21417801f, -0.83654201f, -1.06363630f, -0.15956222f, -0.00784887f, -0.47370675f, 0.63282013f, -0.07376426f, 
    0.12839581f, 0.39601961f, 0.36157376f, -0.04156426f, -0.45135006f, -0.21530035f, -0.32488418f, -0.23807742f, 
    -0.34448677f, -0.19589344f, 0.42832002f, -0.04251402f, -0.28175423f, 0.06410689f, 0.05431223f, 0.07172508f, 
    -0.00334002f, 0.30002084f, -0.11214367f, -0.26716924f, -0.22841804f, -0.15392871f, 0.71460259f, -0.00218383f, 
    0.68084329f, -0.26051107f, -0.39265606f, -0.09063892f, 0.45395318f, -0.01040256f, -0.19790699f, -0.03472764f, 
    0.03827624f, 0.02255837f, -0.47741523f, -0.07791883f, -0.22441369f, 0.45224631f, -0.53597325f, -0.88205385f, 
    -0.81824654f, -0.35918084f, -0.36170620f, 0.55355251f, 0.39768675f, 0.38153893f, 0.11988151f, 0.07398114f, 
    0.38075581f, 0.02648159f, -0.08924506f, 0.18574010f, 0.00339550f, 0.05677440f, -0.14661440f, -0.39843968f, 
    -0.20642360f, -0.47177249f, -0.39912400f, -0.18951097f, 0.24510463f, -0.23248832f, -0.48984319f, 0.34239867f, 
    1.07091808f, 0.80000585f, -0.35031286f, -0.74184996f, -0.82155257f, -0.53743064f, -0.22968918f, -0.29335013f, 
    -0.71133202f, 0.19318673f, 0.01627138f, -0.02570158f, 0.25457948f, 0.32320884f, 0.36226630f, 0.10314479f, 
    0.42735288f, 0.33140656f, -0.06418864f, -0.12915055f, 0.09573840f, -0.16512308f, -0.30726910f, -0.26049402f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.49495429f, 0.00417080f, 0.35419768f, 0.33155686f, 0.09374695f, 0.29213542f, 0.04996924f, 0.06251226f, 
    0.38356245f, 0.06359109f, 0.62002134f, 0.44174376f, 0.44574708f, 0.61596233f, -0.07292705f, 0.29758337f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.46386006f, -0.50087327f, -0.30489627f, 0.19025755f, -0.24883033f, 0.05434021f, 0.06845471f, 0.20381087f, 
    -0.00753958f, 0.16261137f, 0.06128506f, -0.07117610f, 0.27499887f, -0.33027744f, -0.15943721f, 0.00141264f, 
    0.17443438f, 0.20810014f, 0.31193000f, 0.12978862f, 0.00213084f, 0.10845952f, 0.05135445f, 0.09653482f, 
    0.34616914f, 0.10263821f, 0.12946585f, 0.07575294f, -0.02229324f, -0.00643277f, -0.13233602f, 0.02295716f, 
    0.13296902f, 0.19989757f, 0.14806582f, 0.13789402f, 0.02383584f, 0.22949374f, 0.04121321f, -0.05440812f, 
    -0.16731548f, 0.08772805f, 0.07936544f, -0.30806169f, -0.02621935f, 0.27705750f, -0.02753492f, 0.03286912f, 
    -0.11831893f, -0.84646678f, -0.72310877f, -0.72870040f, 0.13717860f, -0.14342932f, -0.00141621f, -0.05226098f, 
    -0.12378328f, 0.05652424f, 0.06124954f, -0.11312083f, 0.51755983f, 0.14686660f, 0.18076254f, 0.04606245f, 
    -0.14022850f, -0.12858504f, -0.13258666f, 0.06598988f, -0.03589414f, -0.08931397f, -0.02645344f, -0.04791452f, 
    -0.13674918f, -0.12084949f, -0.21272562f, -0.03178764f, -0.23489024f, -0.14750926f, 0.26868066f, 0.01446153f, 
    -0.08143801f, -0.14509887f, -0.22913982f, 0.02902221f, 0.27746117f, -0.08064267f, 0.05095047f, 0.25139919f, 
    0.16062208f, 0.11937253f, 0.14122561f, 0.14106454f, 0.05083352f, 0.02788706f, 0.00902350f, -0.10828390f, 
    0.09808508f, 0.09480068f, 0.00433296f, 0.08173990f, -0.02442098f, -0.13229050f, 0.02602456f, -0.03870046f, 
    -0.19558629f, -0.01171547f, -0.08723863f, 0.00516508f, 0.11146735f, -0.48477027f, -0.44940019f, -0.71040869f, 
    0.07825873f, 0.04689381f, -0.03882221f, -0.29624131f, -0.12344296f, -0.07939732f, -0.05843979f, 0.04059955f, 
    0.28073230f, -0.07009561f, -0.00300842f, 0.01470255f, 0.31979379f, -0.00825340f, 0.20444059f, -0.42555448f, 
    0.13215336f, 0.14925735f, 0.00452660f, 0.10549261f, 0.00594926f, 0.05036995f, 0.18159273f, 0.10125500f, 
    0.00172458f, 0.01926940f, 0.05836054f, 0.01849001f, 0.28358361f, 0.24876232f, 0.08069902f, 0.28246075f, 
    -0.28422871f, -0.36469805f, -0.01643752f, -0.02861813f, 0.15317747f, 0.25450402f, -0.09415361f, -0.02085105f, 
    -0.03203925f, -0.13991363f, 0.08193157f, 0.08064202f, 0.15905872f, 0.11573867f, 0.15046598f, 0.14338212f, 
    0.03129180f, 0.13463153f, 0.07313190f, 0.05403505f, 0.15193972f, 0.03450057f, 0.03345243f, 0.20799601f, 
    -0.09028923f, -0.26497370f, -0.26642346f, -0.40922949f, -0.13448809f, 0.04058378f, -0.01937484f, 0.07646748f, 
    0.00672806f, 0.03440690f, 0.18355988f, 0.09034113f, 0.05609341f, -0.13863924f, -0.09950608f, -0.04344044f, 
    0.00361732f, 0.15804593f, 0.07480453f, 0.01149852f, 0.11095443f, 0.09198271f, 0.17800099f, 0.08008221f, 
    0.28251392f, 0.04010978f, -0.14619574f, 0.05834222f, 0.04114523f, 0.09328154f, 0.06007412f, 0.06170009f, 
    -0.11504774f, 0.12421147f, -0.13314939f, -0.03287451f, 0.26943207f, 0.33151996f, -0.20624784f, 0.10327926f, 
    0.03991043f, 0.11840535f, 0.16591871f, -0.20322235f, -0.02282176f, -0.04085004f, -0.13927385f, 0.05120258f, 
    -0.23540989f, 0.04177181f, -0.40421730f, 0.23971565f, 0.15556128f, 0.14240220f, 0.26116315f, -0.46383551f, 
    -0.06681487f, 0.21978676f, 0.13418867f, -0.00623690f, 0.19075161f, -0.13444479f, 0.27989113f, -0.38963929f, 
    -0.04433829f, -0.08982675f, -0.11428538f, 0.06953932f, 0.13599850f, -0.13040124f, -0.02285697f, -0.15521754f, 
    0.43610731f, 0.28291982f, -0.03480903f, 0.08507432f, 0.24566263f, -0.05684451f, 0.09936583f, -0.17568339f, 
    -0.08343579f, -0.00010676f, -0.04649874f, 0.11369810f, -0.47349605f, -0.31940868f, -0.16615976f, -0.18478252f, 
    -0.05475244f, 0.21163824f, -0.03180195f, -0.00653988f, -0.11934060f, 0.20996046f, 0.06533916f, 0.20832734f, 
    0.33925337f, 0.17977934f, -0.05743077f, -0.02679220f, 0.17557164f, -0.06171750f, 0.21364492f, 0.00027418f, 
    0.06589582f, 0.04060112f, 0.02436661f, 0.07242540f, -0.05131422f, -0.11132430f, -0.22863129f, 0.30889761f, 
    -0.06668283f, 0.05694284f, 0.10170695f, 0.06513542f, -0.19951451f, 0.00723869f, 0.01906084f, 0.09154315f, 
    0.25787103f, -0.19353059f, -0.34118125f, 0.01845678f, -0.14278080f, 0.15847373f, -0.06064583f, 0.00722600f, 
    -0.24214889f, 0.03806527f, -0.00627721f, 0.12300201f, 0.42850485f, 0.33409414f, 0.06615912f, 0.15619209f, 
    0.17876858f, 0.16493605f, -0.02574276f, 0.05597756f, -0.13092534f, -0.03734139f, -0.06555521f, -0.02245079f, 
    0.08500034f, -0.81193066f, 0.17177369f, 0.12542260f, -0.15101583f, 0.06154436f, 0.11905833f, -0.05556177f, 
    0.05423429f, -0.08618701f, 0.07385273f, 0.13045970f, -0.31472379f, -0.10104326f, -0.19365612f, 0.30406371f, 
    0.01091006f, -0.02171423f, -0.07748428f, -0.05666457f, -0.15782608f, -0.01273741f, -0.06973274f, 0.02473591f, 
    0.18235768f, 0.40850446f, 0.20467132f, -0.23900333f, 0.02735807f, 0.15743972f, -0.12581716f, 0.30552387f, 
    -0.11817200f, -0.10128557f, -0.17482589f, -0.12196145f, -0.52710932f, 0.00367593f, -0.02236108f, -0.40514281f, 
    -0.16978028f, -0.28282088f, -0.12737207f, -0.52554053f, -0.10812520f, -0.11019509f, 0.15084885f, -0.14269337f, 
    0.34129596f, -0.05983920f, -0.33417019f, 0.20741555f, 0.13414617f, 0.17682801f, -0.04384762f, 0.05885923f, 
    -0.02749663f, 0.04813914f, 0.02258563f, 0.13960508f, 0.27796412f, -0.35305250f, 0.30331272f, -0.02609506f, 
    -0.10318124f, 0.33756572f, 0.16586800f, 0.20181222f, 0.10218885f, 0.01704367f, 0.12947227f, 0.27666223f, 
    -0.10965703f, 0.27812585f, 0.25223401f, -0.07628464f, 0.06603777f, 0.08168902f, -0.04150935f, 0.01217644f, 
    -0.16213557f, -0.05728505f, 0.20004235f, -0.03030189f, 0.03223738f, 0.01460663f, 0.23096901f, 0.16409594f, 
    0.06925578f, 0.21467850f, -0.04678165f, -0.07573497f, 0.06634659f, -0.00878627f, 0.12632374f, 0.17272069f, 
    -0.20093052f, 0.11316606f, -0.06600948f, 0.04830128f, -0.08413370f, -0.06744976f, -0.09678885f, -0.08005780f, 
    0.07532790f, 0.22230589f, 0.06140751f, 0.12565559f, -0.54111308f, 0.00137115f, 0.12779254f, -0.27069974f, 
    -0.00592317f, 0.12857608f, 0.13836239f, 0.19817732f, 0.33944899f, -0.19757886f, 0.06346196f, 0.00536737f, 
    -0.08516022f, 0.14681084f, -0.53341222f, 0.20544298f, -0.31230012f, 0.33304939f, 0.01629103f, 0.10001201f, 
    -0.06038792f, -0.13541700f, -0.03205008f, 0.08254113f, -0.04724794f, 0.27071798f, -0.26044434f, 0.19388896f, 
    0.09535344f, 0.01541132f, 0.25374630f, -0.08886519f, -0.10110472f, 0.11734635f, 0.08948921f, 0.03087933f, 
    0.04562650f, 0.11376303f, -0.09054057f, -0.03399400f, -0.04193741f, 0.09658322f, 0.03840956f, 0.02418831f, 
    -0.03550210f, -0.08959584f, 0.02911469f, 0.00410345f, 0.33092079f, -0.34950197f, -0.07534712f, -0.10987018f, 
    0.03137643f, 0.16957599f, -0.04307957f, 0.00537913f, -0.03627719f, -0.08629002f, -0.09960335f, -0.04868941f, 
    -0.34794563f, -0.11562405f, 0.09991202f, 0.02614195f, 0.14308743f, 0.06997208f, -0.02026542f, 0.05751726f, 
    0.09101557f, 0.09717805f, 0.19727524f, -0.00052644f, 0.27963403f, 0.34617174f, -0.15545763f, -0.16556755f, 
    -0.25412783f, -0.20792243f, 0.05132253f, 0.17003842f, -0.02440258f, 0.05246714f, 0.05428648f, 0.14644754f, 
    -0.54925245f, 0.15267363f, 0.14317782f, 0.01200345f, 0.09830070f, 0.16441835f, 0.03658757f, 0.18621258f, 
    0.00884106f, -0.16380155f, 0.03905043f, 0.03830681f, -0.27853727f, -0.12263327f, 0.04418182f, 0.01068086f, 
    -0.06782225f, 0.00019998f, -0.00923926f, -0.08737379f, 0.07281975f, 0.07416730f, -0.12838873f, 0.20512867f, 
    0.23753056f, 0.20024768f, 0.10482251f, -0.23824129f, 0.19019759f, -0.16481337f, 0.06550416f, 0.15855010f, 
    0.26907116f, 0.04763636f, 0.08074880f, 0.06548183f, -0.16855547f, -0.05022896f, -0.09692323f, 0.06222251f, 
    -0.01415232f, 0.06667926f, -0.08345688f, 0.22412704f, 0.01606066f, 0.11136325f, 0.08764876f, -0.27024376f, 
    -0.16961773f, 0.02073881f, -0.08980826f, 0.19206673f, 0.05738045f, -0.01875394f, -0.03813206f, -0.00859269f, 
    -0.05473665f, 0.03224861f, -0.03891986f, -0.13037927f, -0.05485043f, 0.41753286f, -0.03855455f, 0.13634014f, 
    0.29504952f, -0.12988701f, -0.00521583f, 0.01997292f, -0.13895135f, 0.04176911f, -0.09565392f, -0.16118929f, 
    -0.17540281f, 0.16603918f, 0.03895964f, 0.07039585f, -0.08363581f, 0.00399169f, -0.00687833f, 0.11898311f, 
    0.10531756f, -0.12799549f, -0.11056889f, -0.02212729f, -0.25944170f, -0.38377658f, 0.35755068f, 0.10708888f, 
    -0.08068398f, -0.03642512f, -0.11907417f, 0.01499545f, 0.01647304f, -0.00069053f, 0.11225036f, -0.08429023f, 
    0.32476109f, -0.14093547f, -0.22270688f, 0.15361388f, -0.09973611f, -0.01362602f, -0.04292440f, 0.10788453f, 
    0.05360798f, -0.19825877f, -0.04450026f, 0.05121936f, -0.58986312f, -0.08759374f, -0.19712746f, 0.12951732f, 
    0.08892304f, 0.23092394f, 0.06193980f, 0.16094242f, 0.12020846f, 0.24804118f, -0.17832112f, 0.13553560f, 
    -0.14906578f, -0.10217994f, 0.52622288f, -0.00370639f, 0.00251338f, -0.11390876f, 0.03043317f, -0.10532460f, 
    0.06500614f, -0.03721320f, 0.03309696f, -0.06655256f, 0.21087989f, -0.19608189f, 0.28926888f, 0.24244764f, 
    0.08754241f, 0.05953265f, 0.00128710f, -0.00917997f, -0.07308298f, -0.14397244f, -0.02440929f, -0.04551741f, 
    -0.22651476f, 0.11177123f, 0.27166250f, -0.04935459f, -0.16075179f, -0.06347392f, 0.04952621f, -0.01637694f, 
    0.01139253f, 0.05731208f, -0.01236473f, 0.09608970f, 0.24594490f, 0.09916361f, -0.08454533f, -0.28654370f, 
    0.13453375f, -0.12856521f, 0.11176653f, -0.11085214f, 0.11139484f, -0.07208718f, -0.01602622f, -0.05023805f, 
    0.27792862f, -0.14404587f, 0.07505314f, 0.03000101f, 0.06521780f, -0.08170013f, 0.08279253f, 0.03239873f, 
    -0.01461257f, -0.04397735f, -0.04002589f, -0.05458638f, -0.26097932f, -0.02749690f, 0.46019125f, 0.12824276f, 
    -0.06406233f, -0.05555279f, 0.00309165f, -0.16287914f, 0.04351356f, -0.07411564f, 0.04541001f, -0.06897990f, 
    0.39311200f, -0.06668666f, 0.01901166f, -0.28454384f, 0.24177898f, -0.03123475f, 0.00306995f, 0.07855207f, 
    0.10466580f, 0.15883596f, -0.07749496f, -0.06322237f, 0.29954660f, -0.11676931f, -0.17501004f, -0.15069443f, 
    0.02568399f, -0.02652131f, 0.02811616f, 0.11650154f, -0.06876689f, 0.15898420f, 0.30471250f, -0.10364723f, 
    -0.27457109f, -0.04198224f, 0.16614777f, 0.33299831f, -0.14377317f, -0.01794952f, 0.09840640f, -0.20244007f, 
    -0.00546272f, 0.00512121f, 0.04230385f, 0.10427469f, 0.22241774f, -0.11344747f, 0.11334426f, 0.15516464f, 
    -0.04950606f, 0.07545328f, -0.00564099f, 0.16543049f, 0.13119946f, 0.15314892f, 0.02606156f, 0.04999654f, 
    -0.30690408f, 0.14061511f, 0.32989961f, -0.17046036f, -0.13612731f, -0.12556709f, 0.06683271f, 0.14396471f, 
    0.10328383f, -0.04061285f, 0.03596780f, 0.18630549f, 0.03474527f, 0.04760684f, -0.00007145f, 0.05835424f, 
    0.10399915f, 0.06247868f, 0.03143145f, -0.17038704f, 0.25120738f, -0.02678441f, 0.01505970f, -0.09547894f, 
    0.39348677f, 0.06361707f, 0.38071433f, -0.23638308f, 0.15104015f, -0.11247184f, -0.03670618f, -0.05264430f, 
    0.23147674f, 0.02150220f, 0.08549955f, 0.20666003f, -0.13813196f, 0.27229255f, -0.08715773f, -0.07955989f, 
    -0.06177384f, -0.05681630f, -0.23527193f, 0.12055209f, -0.12681888f, -0.00406335f, -0.18697475f, -0.01867859f, 
    0.44028994f, 0.03502719f, 0.59987891f, -0.07201597f, -0.10616951f, -0.15936233f, 0.01986350f, -0.08540376f, 
    0.06239746f, -0.22203173f, -0.00753359f, -0.14033601f, 0.14401887f, 0.11625861f, -0.45815122f, 0.30932656f, 
    -0.14106084f, -0.04496712f, 0.00632406f, 0.06236164f, -0.01088691f, -0.06156605f, 0.06541086f, 0.27878574f, 
    -0.16385947f, 0.03375318f, -0.28500453f, -0.10396729f, 0.00820429f, -0.02793345f, -0.08580031f, 0.02380722f, 
    0.17250341f, 0.07859182f, 0.05588832f, -0.01053772f, -0.42342725f, -0.34356537f, -0.29522374f, 0.15766038f, 
    0.04018938f, -0.04801708f, 0.17619824f, -0.10104453f, 0.24570365f, 0.05331594f, 0.01054532f, 0.07143641f, 
    -0.14958550f, -0.11549895f, 0.25834325f, -0.26881522f, 0.07407864f, 0.17526335f, -0.25285846f, 0.04896827f, 
    -0.00320466f, -0.01995288f, 0.07394958f, -0.01230540f, 0.08449561f, 0.17387889f, 0.27809191f, -0.02164245f, 
    0.15088686f, 0.19833012f, -0.05329265f, 0.37694204f, 0.00375659f, 0.00284627f, -0.06388003f, -0.11370233f, 
    -0.29623044f, -0.11234105f, -0.30934381f, 0.12723136f, 0.28465685f, 0.03871690f, 0.13288589f, 0.10058362f, 
    0.21401778f, 0.01777237f, 0.06151511f, 0.11906391f, -0.44350237f, 0.01742194f, -0.11303626f, 0.10944924f, 
    0.02818984f, 0.01079760f, -0.04661283f, 0.24225338f, 0.00832571f, -0.03517990f, 0.06245530f, 0.08351549f, 
    -0.18479332f, 0.53172731f, -0.76676524f, 0.22134624f, -0.06622433f, 0.04520351f, 0.02771745f, 0.44373050f, 
    0.18644118f, 0.09119301f, 0.10375128f, -0.02115632f, -0.05667246f, 0.09234393f, 0.09550372f, 0.22764070f, 
    0.01439729f, -0.15143523f, -0.00156910f, -0.07471234f, 0.26595706f, -0.10404305f, -0.08250353f, -0.12867396f, 
    0.21652432f, 0.29894173f, -0.11561700f, 0.25146064f, 0.22715408f, 0.08378796f, 0.27817076f, 0.02383028f, 
    -0.13452922f, 0.05771158f, -0.09486171f, -0.16605276f, -0.11219631f, -0.16395661f, 0.07762060f, -0.14556275f, 
    0.17229947f, -0.11137405f, 0.03725013f, 0.13198517f, 0.07220267f, 0.03949600f, -0.04176819f, 0.04282026f, 
    0.32338792f, 0.11064325f, 0.39285028f, 0.20225418f, 0.14924027f, -0.08254460f, -0.01968998f, -0.10521085f, 
    0.30036440f, -0.02157071f, -0.05185554f, 0.03033393f, -0.26829559f, 0.19973549f, -0.53380984f, 0.08071434f, 
    -0.05085685f, 0.12355205f, 0.14094600f, 0.11152387f, 0.04990299f, 0.10448237f, 0.10315933f, 0.17395297f, 
    0.67031211f, -0.08764174f, -0.21877816f, -0.07035983f, 0.03141553f, 0.04214191f, -0.04860998f, 0.09079879f, 
    -0.12372870f, -0.04755302f, -0.17086072f, 0.00854252f, 0.05617470f, 0.00534328f, -0.28253284f, 0.05789163f, 
    0.08770490f, 0.44722515f, -0.20436987f, -0.03217966f, 0.03262215f, -0.13035254f, 0.08386709f, -0.05736212f, 
    0.01656847f, 0.01448328f, 0.09209432f, 0.06663685f, -0.06181402f, 0.13148445f, 0.07027397f, 0.00552614f, 
    -0.05682370f, 0.18937786f, -0.15052624f, -0.05247200f, 0.74390912f, 0.29548112f, 0.13086756f, -0.39607278f, 
    -0.01532584f, -0.14857203f, 0.10028131f, -0.09421197f, -0.03384249f, -0.02037835f, 0.01047389f, -0.19995019f, 
    0.36974153f, 0.06975659f, 0.11275187f, 0.40878722f, 0.02695917f, 0.01902295f, 0.13894768f, 0.26256454f, 
    -0.12093242f, -0.06810364f, -0.01130599f, -0.09106024f, -0.09259204f, 0.23628958f, 0.13741851f, -0.10989873f, 
    -0.07058515f, 0.06462269f, 0.05773314f, 0.05318965f, 0.04417684f, 0.09190135f, 0.09387054f, 0.07431534f, 
    0.19455503f, 0.02414415f, 0.15607481f, 0.36088705f, 0.10833304f, -0.08960470f, 0.10170454f, -0.14308819f, 
    0.00772304f, 0.04795297f, 0.07624117f, 0.06667636f, -0.09129108f, -0.24126653f, -0.09496035f, -0.13052158f, 
    -0.13684192f, -0.08762852f, -0.11055846f, 0.20999449f, -0.10955378f, 0.03683992f, -0.10150076f, -0.12169314f, 
    0.02438698f, 0.11063923f, 0.14350286f, -0.01612844f, -0.10581926f, -0.05688009f, 0.16856852f, -0.00777553f, 
    -0.04882824f, 0.02294241f, 0.08303277f, -0.16742256f, 0.08073658f, -0.03821428f, -0.12342165f, 0.19876434f, 
    -0.12644345f, -0.21566719f, -0.01807141f, 0.21650460f, -0.11174002f, -0.05013467f, -0.02872407f, -0.09886939f, 
    -0.24164397f, -0.09664030f, 0.43716472f, -0.03342623f, -0.21671198f, 0.25395274f, -0.18120077f, -0.02193978f, 
    -0.23578888f, 0.18717715f, 0.09659798f, -0.07166295f, -0.00622122f, 0.03744411f, 0.08272522f, 0.03664696f, 
    0.04217083f, -0.06942418f, -0.04253593f, 0.01853523f, 0.18908753f, 0.11757211f, -0.08137780f, 0.37230718f, 
    -0.14975809f, -0.09700219f, -0.11073110f, 0.07156271f, -0.10823798f, -0.02587317f, 0.05858780f, 0.38084108f, 
    -0.15367208f, -0.05779248f, 0.06620083f, -0.00194426f, -0.19158503f, 0.14104788f, 0.19616500f, -0.08486352f, 
    -0.14527559f, 0.17175466f, -0.08337897f, -0.28423288f, -0.03355362f, 0.07666045f, 0.06860000f, 0.15910976f, 
    0.57315171f, -0.09150128f, 0.11860781f, 0.43710977f, -0.00479005f, -0.13762663f, -0.01612817f, 0.01746565f, 
    -0.07935584f, 0.08322427f, 0.03048648f, 0.16748236f, 0.01666364f, 0.16998230f, 0.35112706f, 0.05837559f, 
    -0.03013391f, -0.08108913f, -0.05117254f, -0.08253570f, -0.03427451f, -0.01464504f, -0.07881140f, 0.05097055f, 
    0.00206128f, 0.05215998f, 0.01124320f, 0.05336199f, -0.08511998f, 0.05646025f, 0.01055411f, -0.05381589f, 
    0.03808211f, -0.06939393f, -0.07449953f, 0.02636969f, -0.06254434f, 0.02509906f, -0.00630890f, 0.01634632f, 
    0.04238794f, 0.04744082f, 0.02255636f, -0.03462237f, 0.02590188f, 0.03848486f, 0.00595244f, 0.02099989f, 
    0.05710689f, -0.02677803f, 0.05035061f, -0.03488192f, 0.02770920f, -0.05930471f, -0.00369041f, 0.03574624f, 
    -0.07885245f, 0.03982887f, 0.01258850f, -0.04450480f, -0.00312687f, -0.03910270f, -0.01781654f, -0.02998064f, 
    -0.02256794f, 0.04708245f, -0.07625105f, 0.00657618f, -0.04361897f, -0.03498888f, 0.03926495f, 0.03973227f, 
    0.01826502f, -0.00986872f, 0.00593750f, 0.00938510f, 0.02675476f, -0.07509667f, -0.03907571f, -0.02151597f, 
    -0.05647426f, 0.05766039f, -0.04274214f, 0.01717970f, -0.04281081f, -0.00126544f, 0.00414216f, -0.00794688f, 
    -0.01115206f, -0.06331313f, -0.03768799f, -0.04796557f, -0.05230382f, 0.05778095f, -0.00583659f, -0.00995755f, 
    -0.06040562f, -0.06238110f, -0.00769799f, -0.04473637f, -0.03307146f, -0.04744565f, -0.02303672f, 0.00764572f, 
    -0.07650550f, -0.00913523f, -0.01017796f, -0.06434375f, 0.00484897f, -0.05101864f, -0.07299311f, 0.00388684f, 
    -0.05163726f, 0.01314591f, -0.08002762f, 0.04137890f, -0.07198842f, -0.03803103f, -0.03655187f, 0.04848454f, 
    0.05796335f, -0.04471069f, -0.01770862f, 0.00525469f, -0.00798876f, -0.07938370f, 0.03682887f, -0.02863262f, 
    -0.02107148f, -0.06255767f, -0.01439532f, -0.04788037f, -0.07767006f, -0.00048565f, 0.00463336f, -0.07841362f, 
    0.01979406f, -0.01121737f, -0.01331650f, 0.04256015f, -0.06493741f, 0.05495028f, 0.03210381f, 0.03434142f, 
    -0.02689334f, 0.06189775f, 0.00929921f, 0.05305875f, -0.05712142f, 0.04380698f, -0.05704079f, 0.03938914f, 
    -0.02182481f, 0.03350259f, 0.02094671f, -0.02243726f, 0.01319791f, -0.00526288f, -0.01842015f, -0.00894746f, 
    0.06194525f, -0.01728774f, 0.02556142f, 0.04245162f, 0.00643036f, 0.04910133f, -0.05138538f, 0.04987105f, 
    0.05810362f, 0.03478137f, -0.02692347f, 0.02446154f, 0.02070312f, -0.03711953f, -0.05478158f, -0.06692827f, 
    -0.02630138f, -0.03247776f, 0.01736687f, -0.05419231f, -0.02378826f, 0.05007657f, 0.01703122f, -0.02073310f, 
    0.04177164f, 0.04318411f, -0.03351685f, -0.01617386f, -0.05113578f, -0.03936396f, -0.05681039f, -0.04836710f, 
    0.03137651f, 0.05790441f, -0.02634919f, -0.00112583f, -0.01373544f, -0.04873649f, -0.03020397f, -0.02616615f, 
    0.00974515f, -0.04402325f, 0.03037760f, -0.04555398f, -0.06801816f, -0.05868078f, -0.07245947f, 0.01747769f, 
    -0.01007392f, 0.02087285f, 0.03511913f, -0.04628309f, 0.05376511f, 0.05619064f, -0.05618056f, -0.02368418f, 
    0.01417800f, -0.06781001f, -0.04148730f, -0.05569235f, -0.03115407f, 0.02248800f, -0.01912497f, 0.03491329f, 
    0.01401527f, 0.02545859f, 0.00485488f, 0.05454947f, 0.02171611f, -0.05679259f, 0.03820019f, 0.02278449f, 
    -0.03196167f, 0.01093891f, -0.04088458f, 0.00025629f, -0.04776504f, 0.04892734f, -0.04443200f, 0.01132998f, 
    -0.01372515f, -0.05813252f, -0.02711683f, -0.03411308f, -0.00135047f, 0.05428332f, -0.07060318f, 0.01216803f, 
    -0.02175530f, -0.05642802f, 0.00312603f, 0.02787215f, -0.04268383f, 0.04612066f, -0.01943449f, -0.01647905f, 
    -0.02140805f, 0.01814840f, -0.02976731f, -0.07008296f, -0.07061141f, 0.04218666f, 0.04965170f, -0.00114049f, 
    0.04625964f, -0.07284761f, -0.02484868f, -0.00717159f, 0.01868283f, -0.06061074f, -0.07414799f, 0.06003211f, 
    -0.07848835f, -0.03710407f, -0.05704159f, -0.06577592f, -0.05936687f, 0.05646693f, -0.01149328f, -0.01269171f, 
    0.06675947f, 0.03193100f, 0.03790450f, -0.03923585f, 0.05975322f, -0.00374569f, -0.03306243f, 0.06328167f, 
    0.06323328f, -0.05718718f, -0.00855283f, 0.06258506f, 0.01719011f, -0.03317051f, 0.06960842f, -0.02966457f, 
    -0.06884248f, -0.01388651f, 0.02378728f, 0.06778295f, 0.01764702f, -0.06892019f, -0.02607625f, -0.00488279f, 
    0.05702331f, -0.05157945f, 0.00687872f, 0.04471489f, 0.03622632f, -0.07469998f, -0.04919109f, 0.02209783f, 
    -0.07251393f, 0.03580944f, -0.02795809f, 0.03756520f, -0.00306427f, 0.06771293f, -0.04197310f, 0.06651498f, 
    -0.02153313f, -0.03284083f, 0.03524822f, -0.05533091f, -0.06576031f, -0.07244563f, -0.06234444f, -0.02097506f, 
    -0.02275415f, -0.00111063f, 0.04864876f, -0.03304707f, -0.06022146f, -0.00607607f, -0.03869506f, -0.01267141f, 
    -0.06297632f, -0.05188319f, 0.02637330f, -0.06652018f, -0.03261636f, -0.04013885f, -0.02395082f, 0.01375830f, 
    0.03892590f, -0.04047167f, -0.01391909f, -0.00927964f, -0.00088360f, 0.03479024f, 0.03169765f, -0.05411755f, 
    -0.05100279f, 0.04923598f, -0.01452317f, -0.07213265f, -0.02614183f, 0.04440010f, -0.08012440f, 0.00931277f, 
    0.01284552f, -0.01083297f, -0.01809585f, 0.04913862f, 0.05515389f, 0.04141607f, -0.01516678f, -0.01836354f, 
    -0.06910320f, 0.06440632f, -0.02680961f, 0.02793836f, -0.03573956f, -0.07729218f, -0.02883257f, -0.07934329f, 
    0.05642564f, -0.01097569f, 0.00144586f, -0.06223033f, -0.00778905f, -0.08107449f, 0.00487810f, -0.04154164f, 
    0.05557964f, 0.06440169f, 0.03275882f, 0.03103281f, -0.06980631f, -0.08045948f, -0.04125907f, -0.05389262f, 
    -0.04394905f, -0.04220060f, 0.04406372f, -0.04374358f, -0.03436497f, -0.06980556f, 0.04922958f, 0.03014137f, 
    0.01979267f, 0.01043802f, 0.01510451f, 0.00349500f, 0.01731548f, 0.04878911f, -0.05065661f, 0.02888091f, 
    0.02976477f, -0.05208700f, 0.01652855f, -0.16130729f, -0.14720696f, 0.10868181f, 0.14186159f, 0.18221270f, 
    0.14119567f, -0.07989004f, 0.21422659f, 0.00913211f, 0.18007308f, -0.07834070f, 0.48705763f, -0.04308904f, 
    0.00294791f, 0.03141501f, 0.11919568f, 0.15456502f, -0.06692182f, -0.19110048f, -0.11506406f, -0.10962737f, 
    -0.05407049f, -0.31747976f, -0.18241873f, -0.33981150f, -0.13443226f, -0.04709366f, 0.01276758f, 0.04671914f, 
    0.36165136f, 0.10084984f, -0.06109178f, 0.03223501f, -0.79116893f, -0.00980937f, -0.01036510f, 0.04271090f, 
    0.14614856f, 0.00272668f, 0.14261433f, 0.16952850f, 0.24065961f, 0.12515754f, 0.00018457f, 0.08718477f, 
    0.15832929f, 0.13654195f, 0.07389951f, -0.07545508f, -0.02133663f, 0.08995304f, 0.11825402f, -0.00311877f, 
    0.19113745f, -0.08618185f, -0.04614192f, 0.00844890f, -0.27230233f, 0.06968014f, -0.19964434f, -0.00192456f, 
    0.04052411f, -0.13396479f, 0.02297353f, -0.00272201f, 0.01524727f, -0.03465502f, -0.00291201f, 0.03492624f, 
    0.28511530f, 0.13218528f, -0.00451496f, -0.06038183f, -0.09951775f, 0.09329033f, -0.12471317f, -0.01905122f, 
    -0.15001601f, -0.22637339f, -0.02080577f, -0.08995128f, 0.58462596f, 0.00183721f, 0.02196861f, -0.40715864f, 
    0.03493754f, -0.04882242f, -0.05266340f, -0.10296053f, -0.07966743f, 0.00286343f, -0.05224605f, 0.05139473f, 
    -0.11225612f, -0.18063413f, -0.03336758f, -0.00416563f, 0.14093226f, 0.04476811f, 0.16257232f, 0.10981410f, 
    0.27840060f, 0.24501054f, 0.05202190f, 0.32647642f, 0.12077340f, 0.25212362f, 0.31705225f, 0.03465844f, 
    -0.04260089f, 0.12536737f, 0.26439050f, 0.11182058f, -0.04619921f, -0.06163532f, -0.03789851f, -0.03465800f, 
    -0.14013530f, -0.03873460f, -0.08558489f, 0.00632440f, 0.17980339f, 0.35357615f, 0.16343637f, -0.00578150f, 
    0.05470039f, -0.00107004f, 0.15806827f, 0.18498357f, -0.41322541f, -0.51332557f, -0.34875813f, -0.04918312f, 
    0.03118125f, 0.04783927f, -0.11349814f, -0.04637793f, -0.28220996f, -0.05051261f, -0.06868537f, -0.26517296f, 
    0.25093225f, 0.13122030f, 0.24185406f, 0.02862211f, 0.03911911f, 0.04640629f, 0.16816247f, 0.04479347f, 
    0.06514756f, 0.00428601f, -0.12386651f, 0.03388178f, -0.04269300f, -0.04273333f, 0.08559627f, -0.08432632f, 
    0.09235505f, -0.16911215f, -0.03912146f, 0.39599681f, -0.01401163f, 0.04457029f, 0.04452549f, 0.04440011f, 
    0.15228418f, 0.09709202f, -0.15784828f, -0.07452307f, -0.01081418f, -0.10678478f, -0.03382639f, 0.01237325f, 
    0.06084418f, -0.19968751f, -0.17131899f, -0.20974422f, 0.01134081f, 0.29593849f, -0.29141691f, 0.05382866f, 
    0.15904757f, 0.03255602f, 0.08807610f, 0.11872919f, -0.16681398f, 0.18527372f, 0.02696686f, -0.04474309f, 
    0.04713592f, 0.11888447f, 0.14547622f, 0.53872919f, 0.18474634f, -0.04616708f, 0.00040149f, -0.00100617f, 
    -0.05850148f, 0.13420148f, 0.10449396f, 0.00349379f, -0.02276452f, 0.09860823f, -0.37230939f, 0.03448214f, 
    0.05614462f, 0.31610322f, -0.11896177f, 0.04189273f, -0.00035119f, 0.21339132f, 0.25616661f, 0.34052411f, 
    -0.25631160f, 0.30685377f, -0.25118554f, -0.42605925f, 0.10338484f, -0.03803063f, -0.13788190f, 0.05920550f, 
    -0.06401259f, 0.13307270f, 0.18924704f, 0.14265350f, 1.27111900f, -0.00609166f, 0.06250919f, -0.09827059f, 
    -0.08802263f, 0.11490241f, 0.21810605f, 0.12787491f, 0.12056686f, 0.06489766f, -0.02943961f, 0.09863585f, 
    -0.20206740f, -0.06872876f, -0.39973873f, 0.21945243f, -0.15006649f, -0.01600222f, 0.04886172f, 0.03180892f, 
    -0.08517779f, 0.13314325f, 0.04204546f, 0.17975433f, 0.20236687f, 0.09923158f, -0.08490849f, -0.27727079f, 
    -0.19758366f, 0.11532749f, 0.15421596f, -0.02125999f, -0.14865844f, 0.07691191f, 0.01115173f, -0.11669056f, 
    -0.49577615f, 0.04768713f, 0.03973870f, 0.22216024f, 0.14240719f, -0.02326643f, 0.31534550f, 0.11804826f, 
    -0.13848729f, 0.00073867f, 0.04800170f, 0.04757189f, -0.43318504f, -0.00544943f, 0.51161945f, 0.76961386f, 
    0.11090873f, 0.33018297f, 0.02888523f, -0.07568666f, 0.04306118f, -0.08236936f, -0.01859748f, -0.04720652f, 
    -0.17571199f, -0.06237539f, 0.06881654f, -0.10836191f, 0.00271246f, 0.02774681f, -0.13236600f, 0.06101163f, 
    -0.03742440f, 0.05414595f, 0.09201561f, -0.09326428f, -0.10503218f, -0.19199003f, -0.32297209f, 0.15402450f, 
    -0.16530980f, -0.03328599f, -0.26914778f, 0.01107077f, 0.01363462f, 0.05421892f, -0.12067573f, 0.11175127f, 
    -0.03307018f, 0.10126603f, 0.51262087f, 0.20104153f, 0.15064849f, 0.16912253f, 0.06289932f, 0.08130110f, 
    -0.05730707f, -0.03865938f, -0.01287216f, -0.13286687f, -0.26174313f, 0.07122369f, 0.15236273f, -0.25526381f, 
    -0.12787409f, -0.04340436f, 0.01334556f, -0.19460645f, 0.00632258f, 0.06234444f, -0.04562441f, 0.28473389f, 
    -0.09593872f, -0.10385625f, -0.10177450f, 0.26866075f, 0.21087982f, -0.03700431f, 0.18047060f, 0.11454436f, 
    -0.04438733f, -0.11945371f, -0.04831915f, 0.08013321f, -0.00587795f, 0.04716462f, -0.32347512f, 0.10004485f, 
    -0.30003285f, -0.01441528f, 0.15069203f, 0.09233478f, -0.05663116f, 0.11633395f, 0.02182292f, -0.31298485f, 
    -0.29637182f, 0.07208311f, 0.10708249f, 0.17524369f, -0.02039892f, -0.00907472f, -0.02713804f, 0.07289176f, 
    0.07659330f, -0.00014429f, -0.08153131f, -0.15339804f, 0.17853226f, -0.12677144f, 0.36042809f, 0.25634563f, 
    0.21752851f, -0.07854125f, 0.05525579f, 0.01379469f, 0.15368687f, 0.01521983f, -0.10990945f, -0.06909271f, 
    0.04939657f, 0.03490049f, -0.06257061f, -0.06627364f, 0.02677005f, -0.05203106f, 0.04738189f, -0.04817341f, 
    -0.05167016f, -0.07007138f, 0.02224153f, -0.06721677f, 0.00211735f, 0.03632594f, -0.04045917f, 0.04790978f, 
    0.03685537f, 0.04270639f, -0.05690721f, -0.04463740f, 0.02109876f, -0.06075365f, -0.04619057f, -0.01332096f, 
    -0.06481793f, -0.01082893f, -0.04726497f, 0.03175944f, -0.01611316f, -0.04327209f, -0.02044849f, -0.02653100f, 
    0.05794732f, -0.02478522f, -0.06577446f, 0.04552294f, -0.03931630f, -0.01016958f, 0.05089379f, 0.00843009f, 
    -0.03962075f, -0.06552486f, -0.05912084f, 0.03190847f, -0.02026029f, 0.03280517f, -0.06689910f, 0.01178064f, 
    -0.01687649f, 0.05426030f, 0.03363953f, -0.04626982f, -0.00650828f, -0.06470067f, -0.02547837f, -0.01780049f, 
    0.00126191f, -0.06113615f, -0.03079388f, -0.00972058f, -0.06324155f, 0.05885879f, -0.00203182f, 0.05542008f, 
    0.03716095f, -0.06325515f, -0.07215345f, -0.07259483f, 0.04004858f, 0.06576912f, -0.02362535f, -0.05532717f, 
    0.01965454f, -0.04199075f, 0.04328915f, 0.04306551f, -0.05565159f, 0.03843853f, 0.02526396f, -0.03583979f, 
    0.03254027f, 0.06077674f, -0.05124039f, 0.03079033f, -0.03257493f, 0.06260634f, 0.04117787f, -0.01127757f, 
    0.01291095f, -0.03939022f, -0.03668026f, -0.05420307f, 0.01396607f, 0.02681382f, -0.03882416f, 0.00893203f, 
    -0.01181334f, -0.02171572f, -0.00474436f, 0.03111531f, 0.00305527f, 0.03303925f, -0.07356761f, 0.02111797f, 
    -0.05899370f, -0.02778071f, -0.06165498f, 0.00161503f, 0.02108593f, -0.05262572f, -0.00121562f, 0.00164637f, 
    -0.06199255f, 0.02065465f, 0.04119166f, -0.04011753f, 0.05021127f, -0.06024309f, -0.01023783f, 0.06241383f, 
    -0.05882227f, -0.01092637f, -0.05665777f, -0.05758415f, 0.03493399f, -0.07559019f, -0.04647704f, 0.04174392f, 
    -0.06361210f, 0.01701713f, -0.04654532f, -0.00056194f, 0.01174216f, -0.05902776f, 0.06331138f, 0.01402881f, 
    -0.00453411f, 0.00228358f, -0.05769523f, -0.04701547f, -0.04491317f, -0.03514717f, -0.02354704f, 0.05700921f, 
    -0.01963163f, 0.03991612f, -0.01157163f, -0.05320307f, -0.07812335f, 0.02884358f, 0.03223228f, 0.03130155f, 
    -0.07574730f, -0.06820508f, -0.07453267f, -0.04541770f, 0.01532252f, 0.01098366f, 0.01771597f, -0.03412679f, 
    -0.04294048f, -0.02567614f, -0.07047578f, -0.03004790f, -0.00045153f, -0.00842277f, -0.00126374f, 0.05807353f, 
    -0.07846953f, -0.07161921f, -0.02991826f, 0.05647770f, 0.02123416f, 0.02146984f, -0.00012391f, 0.04114569f, 
    -0.03097037f, -0.05902243f, 0.01339159f, -0.07587770f, 0.02426802f, 0.02588778f, 0.04026387f, -0.05311673f, 
    0.00568094f, -0.06812327f, 0.06248187f, -0.04447233f, 0.02346304f, 0.01073441f, 0.02792919f, 0.05750716f, 
    -0.00125318f, 0.03532992f, 0.05444591f, -0.01612488f, -0.05624322f, -0.07005621f, 0.04225627f, -0.00904649f, 
    0.00335281f, 0.02424808f, -0.04553438f, -0.00368259f, -0.01731865f, 0.03075446f, -0.05423670f, 0.01211377f, 
    0.02459457f, 0.02782563f, 0.06315443f, -0.05458405f, 0.04398722f, 0.00572657f, 0.05232471f, 0.04388365f, 
    -0.04659339f, -0.01907922f, 0.04770711f, -0.04395458f, -0.02148292f, -0.00613971f, -0.07058207f, -0.03401054f, 
    -0.00747035f, -0.05341244f, -0.00953155f, -0.01282538f, -0.03003646f, -0.01934948f, 0.04537654f, -0.06294256f, 
    -0.01047238f, -0.07457481f, -0.03913035f, -0.07074423f, -0.02534884f, 0.04980794f, 0.06551114f, 0.00787731f, 
    -0.00569910f, 0.03979789f, 0.02169420f, -0.06505499f, 0.03330679f, 0.05394405f, 0.00923700f, 0.04824057f, 
    0.00064432f, 0.00419983f, 0.02043447f, 0.03854409f, -0.07113666f, -0.04795560f, 0.03768070f, -0.02914587f, 
    0.02034114f, 0.02280954f, 0.00216487f, 0.01592162f, -0.06299756f, -0.06378347f, -0.02374340f, -0.06082335f, 
    -0.01838384f, -0.05858475f, 0.00054305f, -0.02510853f, -0.07411204f, 0.02744095f, -0.04751919f, -0.08164463f, 
    0.00574202f, -0.02963162f, 0.01684133f, -0.04319976f, 0.01524819f, 0.01158819f, 0.01389737f, -0.00683395f, 
    0.05839171f, -0.01059681f, -0.07083945f, 0.04584483f, 0.05438218f, 0.03904198f, -0.02073970f, -0.00589167f, 
    0.00112833f, 0.03416637f, 0.03980590f, -0.07518085f, -0.01468213f, -0.02411513f, -0.06682698f, 0.03039318f, 
    -0.05443682f, -0.07122695f, 0.02267174f, -0.00682223f, 0.00725277f, 0.00045542f, -0.07603034f, -0.03219089f, 
    0.01634744f, 0.00179954f, -0.05432847f, -0.04727612f, 0.04532227f, -0.00023272f, -0.07475932f, -0.08115961f, 
    -0.04359455f, -0.03796889f, -0.03139374f, -0.05524652f, -0.04013461f, -0.01571297f, -0.01871091f, 0.01394576f, 
    -0.03371512f, -0.03355402f, -0.03842218f, -0.06824356f, -0.07375177f, -0.04298828f, 0.03539987f, 0.00716370f, 
    -0.02006005f, 0.03265574f, -0.00601050f, -0.01962437f, 0.02555563f, -0.01989363f, 0.05991664f, -0.06371298f, 
    0.01212616f, -0.07576265f, -0.01861811f, -0.05587218f, 0.02752398f, 0.01921244f, 0.04538431f, -0.00135984f, 
    -0.00632561f, 0.04035554f, -0.05049451f, -0.05891167f, 0.02478130f, -0.03819631f, 0.04543139f, 0.04405762f, 
    -0.00810263f, -0.03807965f, -0.05572759f, -0.02428026f, 0.03865251f, 0.05875142f, 0.02018250f, -0.04908955f, 
    -0.05819612f, -0.06099807f, -0.01990723f, -0.00848140f, -0.07622729f, -0.03042755f, 0.05383112f, 0.01857748f, 
    -0.06922199f, -0.04717311f, -0.02398534f, 0.04147803f, 0.06187845f, -0.06608198f, 0.03604291f, -0.01252759f, 
    -0.03695269f, -0.02604016f, 0.01971677f, 0.06178414f, -0.02592415f, -0.03367198f, -0.02829597f, -0.03848191f, 
    -0.11923813f, 0.00793162f, 0.25217530f, 0.00984084f, 0.00710568f, -0.02588526f, -0.13468221f, -0.04114896f, 
    -0.04660905f, 0.03583935f, -0.33964744f, 0.18900296f, -0.22976755f, -0.38290596f, -0.04779857f, 0.10690597f, 
    0.48048463f, -0.03495743f, 0.21689796f, 0.11316742f, 0.42124504f, 0.15867463f, 0.34537080f, -0.07305081f, 
    -0.20437863f, -0.26443881f, 0.16564354f, 0.37136430f, -0.08823350f, -0.10520089f, -0.11066954f, -0.09189085f, 
    -0.08051097f, 0.19502164f, 0.22622147f, 0.14546512f, 0.01737905f, 0.36078209f, -0.03873570f, 0.16424526f, 
    0.27724594f, 0.30545405f, -0.12717667f, -0.27991751f, 0.01898448f, 0.10788912f, -0.01461884f, -0.05331903f, 
    -0.13306651f, -0.07081385f, 0.55992365f, -0.02002835f, 0.12131403f, -0.12706056f, -0.11392944f, 0.00002533f, 
    0.00795829f, -0.06297790f, 0.13377513f, -0.03492263f, 0.31992343f, -0.02691067f, 0.07088474f, -0.10721824f, 
    0.05543387f, -0.00153582f, 0.08280421f, 0.16086188f, -0.14300318f, -0.11147228f, 0.01479790f, -0.09303281f, 
    0.32619128f, 0.14417475f, 0.26607761f, 0.14084505f, -0.23109859f, -0.14448519f, -0.07579225f, 0.01142176f, 
    0.38404521f, 0.14381938f, 0.08245126f, 0.06756235f, -0.37462664f, -0.08893230f, 0.06233820f, -0.57468957f, 
    0.11115798f, -0.04491695f, -0.05478247f, 0.00264246f, 0.01647880f, -0.01395021f, 0.04942163f, 0.00369005f, 
    0.03792236f, 0.00404260f, 0.01772340f, -0.22266251f, 0.09033246f, 0.02247750f, 0.19732004f, 0.20340502f, 
    -0.04539529f, 0.02102852f, -0.06547271f, -0.08176801f, -0.13848191f, -0.33368754f, 0.14337349f, 0.00118493f, 
    -0.04701093f, -0.10956658f, 0.05831612f, -0.17400682f, 0.12642625f, -0.05722965f, -0.03964043f, -0.14354454f, 
    0.13748424f, 0.24960086f, 0.02732051f, -0.25970775f, 0.12661363f, 0.04044810f, 0.35204950f, 0.28425682f, 
    0.03269128f, 0.11420920f, -0.02823366f, 0.26500332f, 0.15337567f, 0.04306757f, 0.11066710f, -0.14812832f, 
    0.04033225f, 0.05558118f, 0.06847831f, 0.08999211f, -0.01439976f, 0.40686226f, 0.45135897f, 0.26430726f, 
    -0.26828173f, -0.53517008f, -0.22032595f, 0.09040851f, 0.01571572f, -0.14773940f, -0.11678303f, -0.09632145f, 
    0.05243234f, -0.07772433f, 0.19943759f, 0.04089562f, 0.17688785f, -0.12997124f, 0.02584687f, 0.13161410f, 
    0.15198684f, 0.26894826f, 0.07334504f, 0.08434667f, 0.17113489f, 0.09718470f, 0.08242062f, -0.02797708f, 
    -0.22880101f, 0.05379880f, 0.50303435f, 0.00237909f, -0.21845762f, -0.04528901f, -0.02547840f, -0.10923280f, 
    -0.14177272f, 0.02344088f, 0.30540419f, 0.10008304f, -0.04013214f, -0.13985522f, -0.15687236f, -0.28772393f, 
    0.10081486f, 0.08118903f, 0.11674073f, -0.00629446f, 0.07519282f, 0.07955121f, 0.06115565f, 0.10040337f, 
    -0.26232326f, -0.14360180f, -0.10876099f, -0.26038319f, -0.05630527f, -0.03172716f, 0.08121806f, 0.10863408f, 
    0.11661768f, 0.15718685f, 0.03567709f, 0.08531816f, -0.11423533f, 0.27177200f, 0.02221779f, -0.00962496f, 
    0.35907963f, -0.24102788f, 0.25760341f, 0.10514191f, 0.09914450f, 0.00877269f, 0.01808834f, 0.01552568f, 
    -0.01129177f, 0.14822015f, 0.17720594f, 0.35838941f, -0.13657989f, -0.04408374f, -0.12486640f, -0.19660865f, 
    0.12509765f, 0.24849778f, 0.19629784f, 0.12599073f, -0.26021025f, -0.09275457f, -0.16422004f, -0.18762982f, 
    0.11290644f, 0.00455629f, -0.03533737f, -0.09914334f, -0.11979032f, 0.05663207f, 0.06209772f, 0.11836235f, 
    0.06692244f, 0.21976149f, -0.03692117f, 0.00990350f, 0.12818912f, 0.09272166f, 0.03337825f, 0.17278287f, 
    -0.05145681f, -0.06107425f, 0.01957216f, -0.00559679f, 0.48152900f, 0.16141975f, 0.00028441f, 0.02767627f, 
    0.13637334f, -0.05337247f, -0.12232959f, -0.09009892f, -0.08605315f, -0.17490359f, -0.03824396f, -0.09277092f, 
    0.35025349f, 0.01340269f, -0.09441077f, -0.25832465f, 0.01763408f, 0.03567032f, -0.17293596f, 0.06300522f, 
    0.02982445f, -0.01401218f, 0.10166384f, -0.03998649f, -0.22240192f, 0.15488571f, 0.05944807f, -0.01507529f, 
    -0.26499960f, 0.00307127f, -0.00576324f, 0.20287473f, 0.04462726f, -0.07439832f, -0.00162992f, 0.05033737f, 
    -0.03352113f, 0.12969632f, 0.01417842f, -0.02654854f, 0.16754983f, -0.10666459f, -0.01313411f, -0.12956774f, 
    0.19852903f, 0.22129224f, -0.09494141f, 0.23195527f, 0.20553733f, 0.05975536f, -0.02451314f, 0.04902553f, 
    0.21154329f, 0.06316228f, 0.06650414f, 0.01643840f, 0.01085175f, -0.10468762f, 0.07839137f, 0.00346298f, 
    -0.12685652f, 0.27587074f, -0.30317423f, 0.02156005f, 0.19446822f, -0.07733116f, 0.16446212f, 0.22916092f, 
    0.01111151f, 0.23075667f, 0.04010655f, 0.28589851f, -0.20359118f, 0.19414976f, 0.25384074f, 0.10313391f, 
    -0.02460451f, 0.08294211f, -0.12353949f, 0.01779908f, 0.09857664f, 0.12659363f, 0.05770997f, -0.15067054f, 
    0.16780040f, -0.07199844f, 0.06595776f, -0.14268900f, 0.10883763f, 0.08043589f, 0.13410299f, 0.08296690f, 
    0.10253617f, -0.07280213f, 0.06943043f, -0.06109438f, 0.11896246f, 0.10737289f, 0.16233195f, 0.04607325f, 
    0.21649416f, 0.08949827f, -0.15496616f, -0.12636691f, 0.16062854f, 0.01513621f, 0.00474164f, 0.18106768f, 
    -0.08662712f, -0.18891855f, -0.10215711f, -0.09801514f, 0.04221054f, 0.06385111f, -0.05524734f, 0.04285030f, 
    -0.14788753f, -0.06407537f, -0.02189009f, -0.07871687f, -0.16937456f, -0.08274793f, -0.06306113f, -0.24964194f, 
    -0.02506898f, 0.13690744f, 0.05877291f, 0.27673221f, -0.13301751f, 0.09892184f, -0.06208079f, -0.07289976f, 
    -0.02439200f, 0.06421219f, 0.00082217f, 0.01384505f, 0.00983291f, -0.02466254f, -0.03293979f, 0.01524017f, 
    -0.07111168f, 0.03657320f, -0.05018055f, 0.06096668f, -0.06243123f, -0.06856197f, -0.04958484f, -0.07110821f, 
    -0.06403238f, -0.00047461f, 0.02592197f, 0.00561510f, 0.01490436f, 0.00253665f, 0.02593620f, 0.06303059f, 
    -0.03278552f, 0.05220747f, -0.07572234f, -0.01694558f, -0.02201991f, -0.02198164f, 0.02140994f, 0.02031645f, 
    -0.03976410f, -0.02858405f, -0.01238615f, 0.03738775f, -0.05332674f, -0.00815501f, 0.06303517f, -0.06190383f, 
    -0.07325379f, 0.03094033f, 0.03847779f, 0.02037065f, -0.00561563f, -0.05972901f, 0.04809105f, -0.03739142f, 
    -0.04704114f, 0.06582808f, 0.03936424f, 0.04152225f, -0.02562629f, -0.02839409f, -0.01308695f, 0.01578830f, 
    -0.07057723f, -0.07686450f, 0.05650523f, -0.02617690f, -0.02559431f, -0.04234152f, -0.02279825f, -0.01718334f, 
    -0.07605109f, 0.01638014f, -0.06908270f, 0.06199552f, 0.05838781f, 0.04452845f, 0.03622166f, 0.01954648f, 
    -0.06436551f, -0.03114045f, 0.03907875f, -0.01422919f, -0.03985992f, -0.01158313f, 0.06285109f, -0.02972557f, 
    -0.00184525f, 0.02719672f, 0.02413872f, 0.00063437f, -0.04918490f, 0.05166461f, 0.02493766f, -0.06007907f, 
    0.02024548f, 0.02361023f, -0.06249993f, 0.04701367f, 0.00030657f, -0.06086561f, 0.02313917f, 0.00669806f, 
    -0.00930678f, 0.01316379f, -0.04778537f, -0.07727140f, -0.00887191f, 0.06162288f, -0.02497451f, -0.03941406f, 
    -0.05471824f, 0.05573823f, -0.00314407f, 0.06481268f, -0.01611767f, -0.06466553f, -0.06872682f, -0.05391163f, 
    -0.00199090f, -0.00362294f, -0.03188656f, -0.04273513f, 0.06516306f, -0.05276983f, 0.01687334f, 0.02016255f, 
    0.01299241f, -0.02339487f, -0.05855566f, 0.05614959f, 0.00643701f, -0.02139480f, 0.04835161f, -0.06474516f, 
    -0.02036559f, -0.06619953f, -0.01119366f, -0.02553117f, -0.03077092f, 0.01763905f, -0.06288194f, -0.06270201f, 
    -0.03034871f, -0.03100527f, 0.00798495f, -0.03022392f, 0.02595907f, -0.03316022f, -0.06187234f, -0.01416557f, 
    -0.04159415f, 0.04032830f, -0.05881263f, 0.00684329f, -0.06254587f, -0.06347620f, -0.00359669f, -0.05526159f, 
    0.05639291f, -0.06218223f, 0.03036016f, 0.01529583f, -0.05354374f, -0.07249020f, -0.06604127f, -0.02163448f, 
    0.02440701f, -0.07125907f, 0.03992265f, 0.02123622f, 0.05199547f, -0.00693768f, -0.01631037f, -0.06339831f, 
    -0.05540689f, -0.03395960f, 0.05755243f, -0.00014714f, -0.01045366f, -0.07364541f, 0.02795371f, 0.04913647f, 
    0.00191720f, -0.07102594f, 0.04783127f, 0.04336204f, 0.01672626f, 0.00567911f, -0.02729299f, -0.07505149f, 
    -0.02032051f, -0.00757840f, -0.04728342f, 0.03375313f, 0.06281272f, 0.00900187f, 0.00644807f, 0.06483724f, 
    0.35047653f, 0.21291929f, 0.46468660f, 0.05673932f, -0.07062426f, -0.19838230f, -0.09787460f, -0.12805854f, 
    -0.05601209f, -0.03630207f, -0.02186895f, -0.14127818f, -0.17456844f, -0.56832772f, 0.27748138f, 0.02972973f, 
    0.03372556f, 0.09762572f, -0.22295293f, 0.15975124f, 0.13700961f, 0.33973536f, 0.11198322f, 0.28584659f, 
    0.20713638f, -0.06690089f, 0.17665796f, -0.29412392f, -0.16729912f, -0.08130018f, -0.17390457f, 0.05017139f, 
    0.21782936f, -0.01344172f, 0.20762014f, -0.16549908f, -0.12737732f, 0.29085919f, -0.35245734f, 0.00174532f, 
    0.05650656f, 0.02578687f, -0.01848061f, -0.08322697f, 0.22050947f, -0.08298371f, -0.12575915f, 0.06590386f, 
    -0.27076837f, -0.11110850f, -0.13148524f, -0.03501813f, -0.19295889f, -0.13338995f, -0.06047354f, 0.07893586f, 
    0.08283388f, -0.06524843f, 0.01953457f, -0.04044629f, -0.10508982f, -0.32641339f, -0.27672333f, 0.08182446f, 
    0.10639498f, 0.16519415f, 0.19595118f, -0.04354385f, -0.05020201f, -0.04885496f, 0.10507382f, 0.05967515f, 
    -0.25116190f, -0.05674557f, 0.16409096f, -0.24306406f, -0.13552007f, 0.12993425f, 0.04034238f, 0.40991277f, 
    0.08673163f, -0.03109836f, 0.02460686f, 0.28143632f, 0.25301561f, -0.17856112f, 0.41387123f, -0.02160296f, 
    0.24631619f, 0.19360216f, -0.06421585f, 0.07636565f, -0.05974396f, 0.07174517f, -0.11535816f, -0.15724018f, 
    -0.42727801f, 0.06743535f, -0.25155288f, 0.03377683f, 0.28453937f, -0.04954518f, -0.10212741f, 0.05244653f, 
    -0.22303636f, -0.18075436f, -0.00109748f, -0.46238935f, -0.22237286f, 0.02552010f, 0.12474406f, 0.05926776f, 
    -0.11730971f, -0.10120740f, -0.20704162f, 0.19580631f, 0.07263543f, -0.09665895f, 0.00477966f, 0.08488660f, 
    -0.63357049f, 0.90446013f, -0.55662996f, -0.07931693f, 0.19763058f, 0.13380003f, 0.15667008f, 0.04385563f, 
    0.01443675f, -0.13722254f, -0.15712352f, -0.18054567f, -0.22669363f, -0.01875733f, -0.12636238f, -0.11041682f, 
    -0.03022069f, -0.03832717f, 0.24728331f, 0.06615467f, 0.23904219f, 0.35511780f, 0.15234774f, 0.29021823f, 
    0.17134133f, -0.01780307f, 0.11904014f, 0.54254127f, 0.02781768f, -0.11021546f, 0.09527630f, -0.01951435f, 
    0.29608458f, -0.04557195f, -0.12534556f, 0.02386638f, -0.18273175f, -0.32372162f, -0.02432779f, 0.07426818f, 
    -0.00677201f, 0.10677721f, 0.15450248f, 0.33588403f, 0.09198552f, 0.15045321f, 0.13117383f, -0.05892722f, 
    0.06359431f, 0.14859585f, 0.20580007f, 0.00896662f, -0.19560663f, -0.25889504f, 0.17640777f, 0.21337608f, 
    0.37182638f, 0.07501318f, 0.02962491f, 0.23684584f, -0.09193302f, 0.61691856f, -0.63832796f, 0.23117450f, 
    0.20224524f, 0.04431188f, 0.20014513f, -0.05660993f, 0.02917568f, 0.00687313f, 0.05290570f, -0.14635222f, 
    0.29315147f, 0.03124240f, 0.16041969f, -0.35682854f, -0.12237790f, -0.04673468f, -0.07174485f, 0.13279589f, 
    0.11239783f, -0.13554642f, 0.12159367f, -0.00521287f, -0.24649821f, -0.09337127f, 0.39373356f, 0.02130413f, 
    -0.02462533f, 0.20972906f, -0.22077228f, -0.11367955f, 0.07471086f, -0.01098520f, -0.15716699f, -0.25536531f, 
    0.34154043f, -0.00581566f, 0.33632967f, 0.14671557f, -0.12036560f, -0.10967354f, -0.05434274f, -0.09707915f, 
    0.15385830f, 0.02058159f, 0.00709261f, 0.19571300f, -0.84698218f, 0.11893099f, 0.01807423f, -0.28460672f, 
    -0.02867815f, -0.04341662f, 0.18014394f, -0.04097999f, 0.03842784f, -0.02434962f, -0.14372687f, 0.12284819f, 
    0.17430310f, 0.16989972f, 0.12999077f, 0.16404116f, -0.00401741f, 0.08352150f, 0.12614794f, 0.29347545f, 
    0.16051123f, 0.00530846f, 0.06335052f, -0.12302164f, -0.19909157f, 0.04108768f, -0.19464299f, 0.28064185f, 
    -0.07984954f, -0.11045550f, 0.01446465f, -0.13353358f, 0.03114476f, 0.04852851f, -0.04029787f, 0.10152534f, 
    0.15746696f, 0.03216495f, 0.17427333f, -0.11630516f, 0.01207498f, -0.07167225f, -0.31842276f, -0.05846522f, 
    0.13115636f, 0.05423937f, 0.03276567f, -0.27411446f, 0.44671676f, -0.45052719f, -0.14699104f, -0.31988806f, 
    -0.03496663f, 0.05344136f, -0.14227329f, 0.29646075f, 0.08323316f, -0.00201086f, -0.00947972f, 0.01160222f, 
    0.14955615f, -0.21182278f, -0.01495180f, -0.03793741f, 0.03287206f, -0.03862997f, 0.21195097f, 0.08775599f, 
    0.06781796f, -0.03695996f, -0.04277339f, 0.00734226f, 0.01977317f, 0.36896002f, 0.13048442f, 0.25111791f, 
    0.06815356f, -0.20131889f, 0.16539462f, 0.16396104f, 0.01047352f, 0.15056936f, 0.04652248f, -0.02052541f, 
    0.00223175f, -0.03274814f, 0.01057516f, -0.08962166f, -0.22749972f, 0.11377320f, 0.25033534f, 0.23259866f, 
    0.01986491f, -0.02232620f, 0.00771669f, 0.05695512f, 0.29360393f, 0.19332203f, 0.01920911f, 0.26963729f, 
    -0.07275915f, -0.13174972f, -0.08406434f, 0.01207609f, 0.20870645f, -0.04439362f, -0.11255001f, -0.04225673f, 
    -0.23753221f, 0.29648510f, 0.09811344f, 0.25309139f, 0.07110807f, 0.02273937f, 0.13008651f, 0.17430595f, 
    0.04192598f, 0.19969006f, -0.05185159f, 0.05110926f, -0.02262405f, 0.08729292f, 0.27804905f, -0.13024959f, 
    0.00113825f, 0.08250909f, -0.12072429f, 0.05637983f, 0.05322436f, -0.01690948f, 0.06799421f, 0.15058659f, 
    0.45833835f, -0.05949690f, -0.07768515f, 0.10373197f, 0.02342647f, -0.34609497f, -0.02394842f, 0.01193951f, 
    -0.07501765f, -0.13287751f, -0.13399209f, -0.10886525f, -0.22891134f, 0.19187030f, -0.28003326f, -0.01947264f, 
    -0.06267252f, -0.07403177f, 0.12322394f, -0.08659080f, -0.12648761f, -0.13208428f, -0.12929347f, -0.13295572f, 
    -0.09206624f, -0.27987200f, -0.37538067f, 0.14691734f, -0.07536391f, 0.09453852f, 0.28700382f, 0.07091992f, 
    0.20039716f, 0.00700444f, -0.14473355f, 0.15304291f, 0.11816089f, 0.16495235f, -0.31329799f, -0.08336248f, 
    0.14146510f, 0.07122522f, 0.13103147f, 0.03501047f, 0.13698359f, 0.04036885f, -0.06166537f, -0.04228744f, 
    -0.27296254f, 0.14495021f, -0.17483614f, -0.32192197f, -0.12536256f, 0.03616099f, -0.08784563f, -0.11933944f, 
    -0.01330783f, -0.03503834f, 0.04925053f, 0.12185098f, 1.04928744f, -0.03258034f, -0.45287117f, -0.09561832f, 
    0.23288918f, 0.16359712f, 0.03023028f, -0.01452581f, -0.23359054f, 0.28536206f, 0.03823599f, 0.01281703f, 
    -0.08976343f, -0.02886584f, 0.21903560f, 0.07020508f, 0.07555146f, 0.06392622f, 0.11702653f, 0.26919040f, 
    0.11562473f, -0.00333222f, 0.05852028f, 0.08073387f, 0.11470640f, 0.27903140f, 0.40932024f, -0.20520423f, 
    -0.12572637f, -0.20125487f, -0.20360976f, -0.09966617f, 0.04382384f, -0.07788315f, 0.09814963f, -0.04887342f, 
    0.01873970f, -0.12307765f, -0.05750532f, 0.28419808f, 0.16580580f, 0.14275244f, 0.06794031f, 0.05517313f, 
    0.07234932f, -0.12706828f, -0.11894727f, -0.04915605f, -0.16842528f, 0.62850243f, 0.16996869f, 0.13578595f, 
    -0.15123636f, -0.12766749f, 0.02906800f, 0.02984574f, -0.04792505f, 0.08041384f, 0.08271675f, 0.04692733f, 
    -0.17677222f, 0.12101340f, 0.14383556f, 0.02625615f, 0.00412957f, -0.02257332f, -0.10429916f, -0.05636385f, 
    0.11630315f, 0.03082516f, 0.07076026f, 0.16255671f, 0.07405867f, -0.34358585f, 0.01137865f, 0.10864310f, 
    0.12879486f, 0.06249219f, -0.04152497f, 0.10877042f, 0.09057637f, -0.02025219f, 0.01807990f, 0.05784755f, 
    -0.27337682f, 0.14217196f, 0.06916083f, 0.23309849f, 0.14954485f, 0.11097008f, -0.00736371f, 0.25610372f, 
    -0.11463956f, 0.08078054f, 0.09897041f, 0.12131397f, -0.06374986f, 0.19572790f, 0.06975357f, -0.00509324f, 
    -0.01704082f, 0.03808637f, -0.05919253f, -0.10040615f, 0.00068078f, -0.02573194f, 0.06796533f, -0.10252388f, 
    0.24085096f, -0.35082662f, -0.28749835f, 0.20147857f, 0.12335709f, 0.04247540f, 0.19473095f, 0.01393194f, 
    0.11340774f, 0.10267244f, 0.13559076f, 0.02416339f, 0.09927803f, 0.11209507f, 0.06029499f, -0.04503663f, 
    -0.02152824f, -0.04428657f, -0.10701346f, -0.20829278f, 0.01484292f, -0.05569487f, -0.04791151f, 0.03271773f, 
    -0.35949636f, -0.34474969f, -0.03780138f, -0.03151736f, -0.08030657f, 0.04459619f, 0.27861214f, 0.18530834f, 
    -0.07784541f, -0.00555117f, -0.07719231f, -0.04873014f, -0.30039185f, -0.08430584f, 0.44516265f, 0.17153589f, 
    0.13279553f, 0.11494960f, -0.02491522f, 0.17427486f, -0.03846342f, 0.00722071f, 0.01508344f, -0.03715904f, 
    0.05315442f, 0.12281922f, -0.33723170f, -0.46287152f, 0.15768875f, 0.04136416f, -0.16086234f, 0.03879978f, 
    -0.12004257f, 0.02750986f, -0.10029512f, -0.04787910f, 0.26652184f, 0.00565725f, 0.31987208f, -0.07877286f, 
    0.31328470f, 0.10969402f, 0.24316461f, 0.24318415f, -0.06673612f, 0.02564336f, 0.05909425f, 0.08798876f, 
    -0.28492194f, -0.03451847f, -0.12819420f, 0.21922742f, 0.01628637f, 0.03709629f, -0.07669026f, -0.32061324f, 
    0.15147130f, -0.02360904f, 0.06444759f, -0.16507845f, -0.05529510f, -0.41858715f, 0.28774413f, -0.67378390f, 
    0.13302463f, 0.00910584f, -0.19855113f, 0.07981857f, 0.13977453f, -0.18338352f, 0.01865736f, -0.01449628f, 
    0.19131409f, 0.14858103f, -0.21317257f, -0.06709365f, 0.03799492f, 0.10626984f, -0.06385443f, 0.09853718f, 
    -0.17984197f, -0.26361716f, -0.04874585f, 0.06574132f, 0.47731373f, 0.05693024f, 0.54878914f, 0.14533982f, 
    0.12718025f, 0.11683545f, -0.42087078f, 0.04677860f, -0.10294781f, -0.17570314f, -0.01449774f, -0.15084764f, 
    0.17160119f, 0.10032544f, -0.32446390f, -0.16291521f, 0.01903204f, -0.03066222f, 0.11204035f, 0.23673518f, 
    0.06557381f, 0.16754098f, -0.02264082f, 0.14184466f, 0.17149897f, 0.28235874f, 0.12027455f, 0.01957285f, 
    -0.07674915f, -0.00603855f, 0.25483504f, 0.22791229f, 0.02013023f, -0.01696005f, -0.01331452f, 0.07233779f, 
    0.08223535f, 0.31726667f, -0.10503367f, -0.05718629f, 0.03625453f, 0.15120029f, -0.24976110f, 0.11380070f, 
    -0.00086195f, -0.12924892f, 0.00788310f, 0.00200308f, 0.54784340f, 0.28108618f, 0.16697142f, -0.28995034f, 
    0.05044364f, 0.14642678f, 0.16566914f, 0.12313205f, 0.10361920f, -0.11318500f, 0.05109729f, -0.09635280f, 
    -0.58280730f, 0.05454334f, -0.02718740f, -0.22422408f, 0.25785470f, 0.15889545f, -0.01230277f, -0.05331304f, 
    0.02527732f, -0.05049228f, -0.11624365f, -0.08141422f, -0.06182959f, 0.13892968f, 0.00095921f, 0.18839486f, 
    0.11377672f, 0.09462474f, -0.06301373f, -0.09194346f, 0.13079801f, 0.12058283f, 0.28483295f, 0.03088047f, 
    0.41608787f, 0.02876765f, 0.43409982f, 0.12378822f, 0.18895914f, 0.13676438f, -0.03352395f, -0.15457314f, 
    0.15027872f, -0.06098779f, -0.13748272f, 0.07060139f, -0.07890509f, 0.13552059f, 0.03423190f, -0.04427918f, 
    -0.08130389f, -0.04039120f, -0.34757915f, -0.15462102f, -0.05286427f, 0.03574154f, 0.03416479f, -0.15971044f, 
    0.19132371f, 0.02730534f, -0.36353412f, 0.31049430f, 0.17393444f, 0.07399711f, -0.01992370f, -0.22963569f, 
    0.01339622f, -0.03127415f, 0.04734581f, 0.12596329f, -0.18188865f, 0.48066401f, -0.08681074f, 0.01646185f, 
    0.11695126f, -0.04562312f, 0.22233140f, 0.30297175f, -0.04958830f, 0.23665987f, 0.05560626f, -0.01330909f, 
    -0.15873531f, -0.17673369f, -0.23638608f, 0.22242437f, -0.12625505f, 0.20019829f, 0.29345903f, 0.14598998f, 
    0.18630758f, -0.06022028f, -0.05136418f, 0.06400028f, 0.18850705f, 0.38721436f, -0.32047373f, -0.08467245f, 
    0.00634010f, -0.03142409f, 0.13445348f, -0.17160380f, 0.07951850f, -0.25198755f, -0.17293257f, -0.07849721f, 
    -0.00668279f, 0.07889414f, -0.11251887f, -0.00534780f, -0.19124456f, -0.03486672f, 0.05838918f, -0.11011327f, 
    0.03098330f, 0.21261585f, -0.04692077f, 0.51721162f, 0.25417489f, 0.29310039f, -0.04513382f, 0.22601065f, 
    0.05032877f, 0.17064193f, 0.07094867f, 0.13118751f, -0.03413776f, 0.25734606f, 0.06412648f, -0.02369455f, 
    0.15792125f, 0.22324838f, 0.45917031f, 0.12835291f, 0.22463371f, 0.06450512f, 0.19815329f, 0.10113835f, 
    0.04169172f, -0.13901471f, -0.05040483f, 0.08507895f, -0.15546696f, 0.45237544f, 0.50458163f, 0.07371815f, 
    -0.06679190f, -0.23523912f, -0.16607785f, -0.06566821f, -0.19313349f, -0.07578170f, -0.08164510f, 0.06096229f, 
    0.35878927f, -0.00410401f, 0.17119548f, 0.39985150f, 0.26887488f, -0.02376630f, -0.00195355f, -0.08765804f, 
    0.11702254f, 0.12240564f, -0.03380657f, -0.30587730f, -0.05503492f, 0.61006373f, -0.43741357f, -0.09575050f, 
    0.04694044f, -0.12997241f, 0.13616753f, 0.06693511f, -0.11551251f, -0.05303006f, -0.10143628f, -0.08272213f, 
    0.03550262f, 0.02622712f, 0.16306496f, 0.10284983f, -0.01241777f, -0.05502111f, -0.15464155f, -0.11228959f, 
    0.13526665f, 0.09179056f, 0.04733083f, 0.12184639f, 0.19018151f, -0.03369872f, -0.16894123f, 0.00388418f, 
    0.18756817f, -0.06775039f, 0.12693992f, 0.01448621f, -0.22259806f, -0.06838761f, 0.12504682f, 0.01732870f, 
    0.09525627f, -0.25546134f, 0.38867971f, 0.19381446f, 0.06508674f, 0.12137049f, -0.09940369f, 0.32457194f, 
    0.01940092f, 0.21541001f, 0.22536261f, 0.12397938f, -0.03252421f, 0.00612010f, -0.04869438f, 0.07442266f, 
    -0.06878947f, -0.06963379f, -0.19565278f, -0.07410589f, -0.10317753f, -0.11641826f, -0.06218554f, -0.28669906f, 
    0.14316171f, -0.09464978f, -0.31780475f, -0.28919038f, -0.09970652f, 0.10530318f, 0.20656419f, 0.20528571f, 
    -0.03031301f, 0.17266427f, -0.00412232f, 0.10381606f, 0.02759205f, 0.25320661f, 0.23649284f, 0.09400551f, 
    0.02362166f, -0.10392193f, -0.16841979f, -0.11127824f, 0.03520601f, 0.04680648f, 0.00991356f, 0.14405651f, 
    -0.03243300f, -0.09670032f, 0.10309643f, -0.05816244f, -0.07687464f, 0.13394204f, 0.19401935f, 0.08746181f, 
    0.00268939f, -0.10713641f, -0.15144663f, -0.19893043f, -0.39994004f, -0.37934253f, 0.48304152f, 0.08529236f, 
    0.15318222f, 0.08858994f, -0.27190802f, -0.12907141f, 0.01853408f, 0.05652750f, 0.06667908f, -0.17126483f, 
    -0.20815121f, -0.28773934f, 0.16637473f, -0.02166555f, 0.00910666f, 0.03271678f, 0.14898589f, 0.22733781f, 
    0.37858605f, 0.03986555f, 0.22680417f, 0.13493185f, -0.26251453f, 0.10096876f, -0.08928277f, -0.06947684f, 
    0.05545708f, -0.05483296f, 0.03360723f, -0.02686184f, 0.07070370f, -0.05420453f, 0.02296240f, 0.06580888f, 
    0.14091058f, 0.14541957f, 0.22982629f, -0.21050192f, -0.17062175f, -0.13753790f, -0.19991222f, -0.20642601f, 
    0.02709521f, 0.03686110f, 0.16828981f, 0.25721702f, -0.17195609f, -0.08377559f, 0.00517077f, 0.04669444f, 
    -0.04234342f, -0.05240183f, 0.18922332f, -0.15988322f, 0.00644182f, 0.22537218f, 0.11841671f, 0.09858377f, 
    -0.03867064f, 0.28354231f, 0.15234745f, -0.03844030f, 0.31236976f, -0.04509455f, 0.24506071f, 0.35297075f, 
    0.03893202f, 0.08049113f, 0.06675489f, 0.07074139f, 0.37818575f, 0.29601419f, -0.27977747f, -0.35059112f, 
    -0.08024257f, -0.14682701f, -0.04741141f, -0.08175634f, -0.09475782f, -0.05559802f, -0.14358139f, -0.15261807f, 
    0.05527698f, 0.09213008f, 0.06694090f, 0.04323808f, 0.23167463f, 0.03462413f, -0.09403843f, -0.01079765f, 
    0.03940552f, -0.13573979f, -0.11798319f, -0.33580786f, -0.20880786f, -0.15509042f, 0.11296920f, 0.26527694f, 
    -0.09392087f, 0.04740990f, -0.22685975f, 0.00693178f, 0.08321137f, -0.02386944f, 0.04707992f, 0.12206028f, 
    0.14415264f, 0.00485071f, -0.03964180f, -0.11506711f, 0.11308149f, -0.08176740f, 0.09822490f, -0.22980680f, 
    0.11219264f, 0.15835993f, 0.02698729f, 0.19046041f, -0.28169614f, 0.09558158f, 0.03103736f, 0.23150139f, 
    0.24632037f, -0.10771939f, -0.01392667f, -0.09669853f, 0.00128963f, 0.04097147f, 0.01611547f, 0.12953119f, 
    0.38113645f, 0.07229856f, 0.00107698f, 0.18623401f, 0.04582193f, -0.01755862f, 0.36784735f, 0.30951560f, 
    -0.06312622f, 0.13869841f, 0.28862441f, 0.24617262f, 0.08677719f, 0.12899856f, 0.30859125f, -0.05434199f, 
    -0.00511873f, -0.14370526f, -0.12524161f, 0.02391461f, -0.20605944f, -0.04575910f, -0.20287283f, -0.23308998f, 
    -0.31829333f, -0.17066088f, -0.05055778f, 0.26585919f, -0.00456842f, 0.20136623f, 0.25474650f, 0.14503603f, 
    0.06689396f, -0.05419632f, -0.01198178f, 0.11275794f, 0.19535883f, 0.20018195f, 0.13245380f, 0.01998922f, 
    0.11947451f, -0.03583099f, 0.08271551f, -0.08609338f, 0.16792020f, -0.11536549f, 0.05239303f, 0.33351895f, 
    -0.07831073f, -0.21511954f, -0.26805016f, -0.15926230f, 0.07505892f, -0.02365898f, 0.00922600f, 0.32179090f, 
    -0.05699846f, -0.03496305f, -0.05929052f, -0.38908151f, -0.06704281f, -0.30199388f, -0.07610177f, -0.27021021f, 
    -0.00877737f, 0.18144478f, 0.18322949f, 0.10530581f, -0.23474473f, -0.08827867f, -0.12679955f, 0.08273949f, 
    0.04354953f, -0.04756579f, -0.08427621f, -0.02878873f, 0.03037820f, 0.00327564f, 0.03636275f, -0.07936476f, 
    -0.07168729f, -0.10205930f, -0.06119511f, 0.04173878f, -0.06200032f, 0.03301890f, 0.01458946f, -0.08184637f, 
    -0.00683615f, -0.02047035f, -0.00382028f, 0.02483509f, 0.00274948f, 0.03652750f, -0.02192979f, -0.04081563f, 
    -0.07560124f, -0.07770766f, -0.04263897f, -0.05559954f, 0.03686437f, -0.09009064f, -0.08391132f, -0.03287474f, 
    -0.06677100f, -0.01493126f, -0.03095340f, 0.02898770f, -0.09680806f, -0.04810872f, 0.04233900f, 0.00768602f, 
    -0.07340097f, -0.06761745f, -0.04734312f, -0.00753902f, -0.01693918f, 0.01941879f, -0.04284438f, -0.08280986f, 
    -0.01049793f, 0.00155607f, -0.03828736f, -0.05997265f, -0.02280529f, 0.00691992f, -0.09076446f, 0.01674139f, 
    0.00137330f, -0.02270683f, -0.02664202f, -0.02476619f, 0.00715270f, -0.05023395f, -0.05378305f, -0.07457592f, 
    0.02116551f, 0.03181417f, 0.02268755f, 0.01855031f, 0.04905844f, -0.02938844f, -0.00415871f, -0.07509284f, 
    -0.07787933f, 0.03969696f, -0.02250648f, 0.02403971f, -0.05573209f, -0.01414541f, -0.06840850f, -0.05210498f, 
    -0.07294128f, 0.02890459f, -0.02966665f, 0.00971766f, -0.04624853f, -0.04488922f, -0.00823889f, -0.09370920f, 
    0.04751039f, -0.06328800f, -0.03697198f, 0.01600037f, -0.00819070f, 0.03801699f, -0.04693908f, 0.01341966f, 
    -0.03027188f, -0.00213166f, 0.03119505f, -0.00624029f, 0.00776009f, 0.02018473f, -0.03246567f, -0.08696073f, 
    -0.03121906f, -0.02627782f, -0.04040739f, 0.01059993f, -0.01165432f, -0.06238551f, -0.01867171f, -0.05280071f, 
    -0.07273951f, -0.01250197f, 0.00572838f, -0.02575335f, -0.04853494f, 0.03313577f, -0.02832560f, 0.00611570f, 
    -0.06771451f, -0.00715458f, 0.02883795f, -0.02600781f, 0.02710250f, -0.06031483f, -0.01308134f, -0.06440886f, 
    -0.04861505f, -0.04449221f, -0.07994246f, -0.08517670f, 0.02343562f, 0.04766936f, -0.08451308f, -0.07340387f, 
    0.00291562f, -0.00699614f, 0.04029083f, -0.00387553f, -0.05557233f, 0.00807878f, -0.01296828f, -0.03534038f, 
    -0.06882919f, -0.08504219f, 0.03810890f, -0.06229992f, -0.02788002f, -0.08339766f, -0.06584267f, 0.03084557f, 
    0.00216010f, -0.01692433f, -0.09316798f, 0.02698089f, 0.04467216f, 0.02628242f, -0.04936966f, 0.03696895f, 
    -0.03483886f, -0.06932448f, 0.05012377f, -0.06810515f, -0.04539718f, -0.06178709f, -0.04631550f, -0.07225255f, 
    -0.05016509f, 0.00435473f, -0.07606316f, -0.04835954f, 0.03073434f, -0.02996797f, -0.07656688f, 0.05075125f, 
    -0.10134211f, -0.04329290f, 0.03141732f, -0.07684742f, 0.05039625f, -0.04008352f, -0.01613505f, -0.05179704f, 
    -0.06734913f, -0.07942614f, 0.01226351f, 0.00589253f, 0.02874309f, -0.01344657f, -0.01035468f, 0.00781732f, 
    -0.01896393f, 0.16307919f, 0.24349453f, 0.02560287f, -0.04055431f, 0.11751208f, -0.01981438f, 0.08732159f, 
    0.00347392f, -0.09204198f, 0.11897518f, -0.10822999f, 0.00409348f, -0.18621948f, 0.44325846f, -0.01587867f, 
    -0.13981317f, -0.04593735f, -0.06690838f, -0.04716558f, 0.08942237f, 0.00082807f, -0.04961845f, -0.03227638f, 
    0.24891059f, -0.00925180f, -0.04360005f, 0.09657693f, -0.12792343f, -0.06302211f, 0.01094761f, -0.06563797f, 
    0.07709906f, -0.14281982f, -0.09393936f, 0.07207734f, -1.29161739f, 0.02026918f, 0.20533916f, -0.01110913f, 
    -0.22227059f, -0.02589842f, -0.02084874f, 0.19390516f, 0.12552832f, -0.17188449f, -0.06851266f, 0.10013925f, 
    0.15792724f, 0.06758212f, -0.01973904f, -0.05412475f, 0.06465593f, 0.05091500f, 0.15315205f, -0.04254597f, 
    0.10488160f, 0.06151009f, -0.02605829f, -0.05424118f, -0.23456554f, -0.19742206f, -0.37968007f, 0.08732434f, 
    0.18406685f, 0.04450954f, 0.07504684f, -0.06207387f, -0.01768732f, -0.02619172f, -0.12211124f, 0.10359813f, 
    0.08546057f, 0.03736154f, 0.02124305f, -0.14032465f, -0.05932698f, 0.17802334f, -0.11369326f, -0.01098788f, 
    -0.03311069f, -0.03014736f, -0.01211379f, 0.03448020f, 0.52346253f, -0.37412956f, -0.18523532f, -0.13421473f, 
    0.19536665f, 0.03515138f, 0.13725646f, -0.07089860f, 0.06091232f, 0.09827758f, 0.02003575f, 0.07325725f, 
    -0.00164129f, -0.16751802f, -0.06056513f, 0.01365725f, -0.01367506f, 0.04117610f, 0.00949267f, 0.04693905f, 
    0.04101325f, 0.03297607f, -0.04969392f, -0.01155088f, 0.06281307f, 0.26782840f, 0.16918859f, 0.01485360f, 
    0.09338492f, 0.05465411f, 0.14958353f, 0.11503349f, 0.06198816f, 0.16514632f, 0.14045803f, 0.15449978f, 
    -0.02027859f, -0.16173829f, -0.16555752f, -0.24011691f, -0.02164629f, 0.06833697f, 0.07271512f, -0.05532204f, 
    -0.07843709f, -0.11145700f, 0.02853818f, 0.05801782f, 0.12285967f, -0.27289179f, -0.17429371f, -0.05416444f, 
    0.03055386f, 0.08982433f, 0.04950154f, 0.12324303f, -0.11448462f, -0.10941502f, -0.07698593f, -0.10503013f, 
    -0.01036688f, 0.22579435f, 0.16076915f, -0.04904517f, 0.05516488f, 0.03639456f, 0.14979433f, 0.14704938f, 
    0.21794178f, 0.13865890f, 0.08609766f, 0.13844524f, -0.09090353f, -0.05970417f, -0.03621879f, 0.04345559f, 
    0.09272598f, 0.06191813f, 0.02129345f, 0.28265136f, -0.00780972f, 0.00283953f, 0.03918136f, -0.01452061f, 
    0.18316570f, 0.22977020f, 0.10442094f, -0.03089193f, 0.17956805f, 0.06955063f, -0.01188947f, 0.03669066f, 
    0.16764167f, -0.10442341f, -0.09098183f, 0.09731584f, 0.12102477f, 0.17199072f, -0.28192964f, -0.12870136f, 
    0.12128023f, -0.05617680f, 0.03649021f, 0.04034112f, 0.02677037f, 0.12904134f, 0.07287357f, -0.05386736f, 
    -0.13099688f, -0.11741461f, 0.00769171f, 0.12072740f, -0.01441365f, 0.06088958f, 0.22915904f, 0.06829911f, 
    0.06525656f, 0.13178413f, 0.21273519f, 0.09017672f, 0.34700182f, 0.23480161f, 0.15051252f, -0.06061072f, 
    -0.11994413f, -0.21003614f, 0.33005154f, -0.00928592f, -0.14245442f, -0.08071523f, -0.31534830f, -0.07673374f, 
    0.02632101f, 0.05851736f, 0.00606197f, -0.24286848f, 0.06016953f, -0.05290066f, 0.06765762f, -0.01968992f, 
    0.32377741f, -0.10006772f, 0.08847357f, -0.00059980f, 0.18558621f, -0.06580695f, 0.06320203f, 0.32310706f, 
    -0.00185502f, -0.06047886f, -0.08995012f, 0.11432933f, -0.12803051f, -0.13490260f, 0.21743675f, 0.09231907f, 
    0.00328294f, 0.00972191f, -0.22216789f, -0.30684367f, 0.04211543f, 0.03271015f, 0.13318540f, 0.01169427f, 
    0.04907241f, 0.13028082f, -0.09204519f, 0.26477835f, -0.28620100f, 0.05837720f, -0.12623958f, -0.17242388f, 
    0.13743596f, -0.07540266f, -0.07121174f, 0.05224645f, -0.01028925f, 0.12097573f, 0.03055702f, 0.02089573f, 
    -0.02117760f, -0.14444959f, -0.20831923f, -0.13044402f, 0.03284613f, 0.14208817f, 0.16919099f, 0.15988746f, 
    -0.17701720f, 0.01317252f, -0.10001634f, -0.07871095f, 0.31613365f, 0.43719161f, -0.04688805f, -0.00142258f, 
    0.14678966f, 0.02887729f, 0.06921404f, -0.15703353f, 0.03298330f, -0.00214526f, 0.10262733f, 0.01625823f, 
    -0.17226204f, 0.09654226f, -0.14085507f, 0.14021891f, 0.06805793f, 0.15319917f, -0.04436571f, -0.04510967f, 
    0.06237024f, 0.07030665f, 0.02062373f, 0.20424125f, 0.20759408f, 0.13131072f, -0.02026310f, -0.21863119f, 
    0.17016074f, 0.34127119f, 0.09420825f, 0.06876729f, -0.07119040f, 0.07569911f, -0.14484753f, 0.12787476f, 
    0.05712246f, -0.19419399f, -0.14672375f, 0.40681237f, 0.03687692f, 0.16266085f, 0.14525495f, 0.09764645f, 
    0.07384693f, -0.20457759f, 0.15114632f, 0.05180621f, -0.13859192f, -0.04654856f, -0.12923220f, 0.14319701f, 
    -0.00067921f, 0.01512848f, -0.04524009f, -0.04332285f, -0.08748946f, -0.21874128f, -0.08637766f, -0.22099267f, 
    0.45711941f, 0.18809462f, -0.00952421f, -0.20313087f, 0.08040299f, 0.18360993f, 0.01491601f, -0.12642986f, 
    0.02329072f, -0.01830025f, -0.07524705f, -0.01725769f, 0.05629345f, 0.12966344f, -0.02741851f, 0.02134063f, 
    0.23647904f, -0.31742761f, -0.02301387f, 0.14055128f, -0.12303184f, -0.10130537f, -0.00742372f, -0.01194517f, 
    -0.05655350f, -0.07672539f, -0.42611751f, -0.29268581f, 0.13169855f, 0.13882788f, 0.02866716f, 0.02928524f, 
    0.24359810f, 0.00257714f, -0.00957387f, -0.05609677f, -0.15502632f, -0.09759781f, -0.09556128f, 0.10320617f, 
    0.10513352f, 0.18023045f, 0.10166994f, 0.21445572f, -0.07148143f, 0.08032866f, 0.09416322f, 0.04173690f, 
    0.16608711f, 0.33676717f, 0.25404406f, 0.27908003f, 0.18153457f, -0.15355083f, -0.10841681f, 0.10068293f, 
    -0.00560044f, 0.03517108f, 0.06767070f, 0.07392026f, -0.28647441f, -0.15234174f, -0.08986913f, 0.12073716f, 
    -0.00175219f, 0.05064334f, 0.04261282f, 0.13360709f, -0.02673707f, 0.28997567f, 0.16971155f, 0.26649860f, 
    -0.03121913f, 0.01891494f, -0.13839975f, 0.05086472f, 0.11660691f, 0.00145061f, -0.06230227f, 0.11834286f, 
    -0.13191943f, 0.14249985f, 0.07574917f, -0.04594468f, 0.10086536f, -0.11562896f, 0.19225059f, 0.07114724f, 
    0.14270347f, -0.01443101f, 0.04211222f, 0.03412892f, 0.15217750f, 0.03920166f, -0.05782294f, 0.05211834f, 
    -0.21308829f, -0.04638747f, -0.10170004f, 0.25138757f, -0.05986727f, -0.04075277f, 0.01943878f, -0.03912568f, 
    -0.20020533f, -0.08883670f, 0.06015056f, -0.02896673f, 0.25918034f, -0.26906571f, -0.32078370f, -0.04450278f, 
    -0.07189020f, 0.16513866f, 0.00525752f, -0.04611507f, -0.01222422f, -0.00519607f, -0.04032596f, -0.23329878f, 
    -0.23376402f, 0.13532194f, 0.11853425f, 0.07066887f, -0.01891708f, 0.05723026f, 0.05232295f, 0.01736917f, 
    0.06372456f, 0.02328704f, 0.02996277f, 0.15107463f, -0.35077876f, -0.49090624f, 0.24437524f, 0.43303499f, 
    0.25837073f, 0.08807487f, 0.09212599f, -0.05864897f, 0.06501299f, -0.09550271f, -0.14529811f, -0.03454823f, 
    0.16054983f, -0.17872269f, -0.06365103f, -0.08749236f, 0.03168621f, -0.07149462f, -0.06998158f, 0.06693112f, 
    -0.11495276f, -0.14322978f, -0.10963668f, -0.28264576f, -0.16519640f, -0.16174069f, 0.08769374f, 0.17917156f, 
    -0.15425892f, -0.13565280f, -0.09954266f, -0.21255122f, 0.01383955f, 0.06557260f, -0.03847469f, 0.02523973f, 
    0.39108574f, 0.07509524f, -0.03049061f, -0.40155157f, 0.17359965f, -0.00773040f, 0.04674625f, -0.14412725f, 
    0.03321436f, 0.09613485f, -0.10754714f, -0.19978496f, 0.18982358f, -0.13797674f, 0.10995041f, -0.34041473f, 
    -0.03543351f, 0.07451053f, 0.01788375f, -0.09724090f, 0.12163149f, 0.27775440f, 0.26929078f, 0.41430381f, 
    -0.44861650f, -0.00656741f, 0.10656202f, 0.19239247f, 0.16942729f, 0.05264077f, -0.04329367f, 0.12327187f, 
    -0.13971987f, -0.04847866f, 0.13238575f, 0.06878035f, 0.04547596f, -0.21352123f, -0.30438685f, 0.07470129f, 
    -0.07152120f, 0.07184663f, 0.18406911f, 0.24262516f, 0.12135338f, 0.14523071f, 0.07023484f, -0.04240115f, 
    -0.23307899f, 0.26808566f, 0.35785094f, 0.12484817f, 0.16435161f, -0.08345410f, -0.07450534f, -0.04162149f, 
    -0.04594098f, -0.03624291f, 0.17552449f, 0.14031190f, 0.31502312f, 0.06356457f, -0.08309066f, -0.02115695f, 
    -0.06809005f, 0.12548399f, 0.09571062f, -0.00525406f, 0.10174360f, 0.00717177f, -0.00786337f, 0.15742290f, 
    0.31183660f, 0.07077128f, 0.05940539f, -0.02178753f, 0.15272115f, -0.05317856f, 0.05692981f, 0.08003186f, 
    -0.15825148f, 0.13427922f, -0.15951025f, 0.13713601f, 0.00794463f, 0.10320486f, -0.03443379f, 0.22594906f, 
    0.16123523f, -0.05648213f, -0.05885746f, 0.06302414f, 0.03944943f, 0.04700639f, 0.06112728f, 0.11733059f, 
    0.06968263f, -0.25269517f, 0.08540995f, 0.00117788f, 0.21480195f, 0.02669738f, -0.01452434f, 0.08335704f, 
    -0.20424789f, 0.16549943f, -0.00683151f, 0.04554710f, 0.11743867f, -0.10881161f, -0.48014215f, 0.04712778f, 
    0.26974711f, 0.00200699f, -0.03651154f, -0.02881666f, -0.01409810f, -0.03576410f, -0.02583503f, 0.15978493f, 
    0.18954808f, 0.02549515f, 0.32337636f, 0.32735783f, 0.09619092f, 0.17783841f, 0.04880053f, 0.17112559f, 
    -0.01954205f, -0.19766174f, 0.10150707f, -0.15425467f, -0.61918259f, -0.45866483f, -0.11120114f, 0.06862716f, 
    0.15317135f, 0.03602350f, -0.04346475f, -0.00939315f, 0.16274700f, 0.03865135f, 0.19078596f, 0.06061461f, 
    0.12668805f, -0.08020359f, 0.12841585f, 0.17535999f, 0.00430695f, 0.03253253f, -0.00167487f, -0.05246062f, 
    0.14808747f, -0.15813287f, -0.04419440f, 0.23426358f, -0.42992112f, -0.11826461f, 0.13794553f, -0.03423401f, 
    -0.01179758f, -0.04045732f, -0.14568856f, 0.22206230f, -0.14841399f, -0.14287877f, -0.00715622f, 0.00211427f, 
    -0.16294102f, -0.08093804f, -0.23183511f, 0.02065753f, 0.12546904f, -0.08547968f, -0.12360112f, -0.01037795f, 
    -0.10450509f, -0.10511206f, -0.07310043f, -0.16726653f, -0.03508322f, -0.24718925f, 0.08014599f, 0.14658639f, 
    -0.08161916f, -0.09918320f, -0.02351034f, 0.05162887f, -0.02853370f, -0.16084717f, 0.01996888f, -0.09492279f, 
    -0.00825982f, 0.55606824f, -0.56136727f, -0.35933024f, -0.00886529f, -0.03833510f, -0.15401074f, -0.01583575f, 
    0.07378046f, 0.21340908f, -0.26592097f, -0.00256904f, -0.08082698f, -0.05206830f, -0.07744251f, -0.25351512f, 
    0.12196489f, -0.08681096f, -0.10247798f, -0.04711363f, 0.14751470f, 0.24427871f, 0.25979730f, 0.22861069f, 
    0.01718740f, 0.10435136f, 0.02478695f, -0.03741509f, 0.01411753f, -0.06160493f, -0.11241279f, 0.17507371f, 
    -0.13496117f, -0.01520112f, -0.03144553f, -0.07301203f, -0.17808153f, -0.35319641f, -0.11872283f, -0.26588550f, 
    -0.00640022f, -0.00640538f, -0.13360205f, -0.21962509f, 0.25803632f, 0.20896125f, 0.09191069f, 0.03823325f, 
    0.15738773f, 0.02841855f, 0.47199368f, 0.30053952f, 0.02162508f, -0.06635500f, 0.04659682f, -0.16474572f, 
    -0.18277733f, 0.05951386f, 0.27585518f, 0.42715269f, 0.16076343f, 0.36136451f, 0.09805155f, 0.13095543f, 
    -0.18485019f, 0.06126336f, -0.19533637f, -0.07298782f, 0.20412938f, -0.03988271f, -0.00678392f, 0.15520708f, 
    -0.00745449f, 0.42605022f, 0.60986745f, 0.46477246f, -0.02634480f, -0.03503297f, -0.04124118f, 0.12010733f, 
    0.03284588f, 0.13203853f, 0.03399690f, 0.07164432f, -0.49839497f, 0.05088065f, -0.44182587f, 0.37092844f, 
    0.05019953f, 0.07416131f, 0.19140035f, -0.01203165f, 0.03981612f, 0.08696250f, 0.15633206f, 0.05624292f, 
    0.01098048f, 0.05031870f, -0.08028268f, 0.28217897f, -0.01617799f, -0.15130019f, -0.20302755f, -0.00248066f, 
    -0.12544259f, 0.06502337f, 0.03268038f, 0.31098121f, 0.04878575f, 0.13162443f, 0.18933579f, 0.37994581f, 
    0.12273307f, 0.02313875f, 0.16183859f, -0.05526102f, 0.17463571f, 0.21317536f, 0.11335658f, 0.04348985f, 
    -0.12113439f, 0.08307484f, 0.60439575f, 0.21051337f, 0.06287009f, 0.00475487f, 0.06057045f, 0.00185700f, 
    -0.06956282f, -0.00752869f, -0.01489819f, -0.15684816f, 0.14577675f, 0.17178613f, 0.10630255f, 0.17026776f, 
    -0.12469553f, -0.02556158f, -0.05453991f, -0.05853797f, -0.12406060f, -0.12714258f, -0.14190863f, -0.10947403f, 
    -0.02230016f, 0.27290499f, 0.49953306f, 0.27179193f, 0.16238748f, 0.11955871f, 0.02471726f, -0.07683200f, 
    0.14714946f, 0.10675299f, 0.12622291f, -0.10647176f, -0.46277645f, -0.10251022f, -0.31470588f, 0.03819925f, 
    0.29534432f, -0.06565142f, 0.10957013f, -0.00723699f, 0.18417089f, -0.17168041f, -0.08951354f, 0.00214457f, 
    0.40147832f, -0.28205112f, 0.19683976f, -0.23065670f, -0.26891503f, -0.06403109f, 0.02955759f, -0.00893336f, 
    -0.20430171f, 0.09145799f, -0.06838910f, -0.11929192f, -0.45689595f, -0.15828937f, -0.09009638f, 0.11316504f, 
    0.06573081f, -0.25681609f, 0.11570650f, -0.28011936f, -0.02556678f, 0.10265903f, -0.10130513f, -0.09729782f, 
    0.75638217f, -0.31779227f, 0.55476290f, -0.23344892f, -0.04638426f, -0.02922324f, 0.19534513f, 0.07717948f, 
    -0.00440746f, 0.19472846f, 0.01614312f, 0.02265010f, 0.33623236f, 0.04176663f, 0.05682726f, -0.15295242f, 
    -0.10855561f, -0.06495906f, -0.09370597f, -0.08707709f, 0.01737906f, 0.02280510f, -0.01342567f, 0.01264281f, 
    -0.79457247f, -0.15591028f, -0.26045385f, -0.12934709f, 0.04704056f, -0.06159443f, -0.07452235f, 0.16556811f, 
    -0.13026267f, 0.09247587f, 0.12559706f, 0.04676011f, 0.03925076f, 0.14899650f, -0.01293178f, 0.22398677f, 
    -0.03590959f, 0.14896864f, 0.02762104f, 0.13212377f, 0.16875772f, 0.13840097f, 0.03231600f, 0.06430205f, 
    -0.15672408f, 0.29629278f, 0.51164979f, 0.02574844f, -0.02381853f, -0.04337421f, -0.01140366f, 0.26106605f, 
    -0.17297164f, 0.09237498f, 0.06768969f, -0.09258094f, 0.12847055f, -0.64572716f, 0.36278453f, -0.34430712f, 
    0.14718603f, 0.16790074f, -0.12672134f, -0.24032052f, 0.23962511f, -0.11754327f, -0.11693150f, 0.10607100f, 
    -0.03541221f, -0.06130525f, 0.04375897f, -0.00210202f, -0.06597403f, -0.05080277f, 0.00980413f, -0.01465246f, 
    -0.06348659f, -0.03725807f, 0.02559503f, -0.02180251f, 0.00380588f, 0.02305217f, 0.06209539f, -0.03684293f, 
    0.05914880f, -0.00916478f, -0.00985037f, -0.00724632f, -0.05562491f, 0.04357854f, -0.04251410f, -0.03539338f, 
    -0.05593667f, 0.00750620f, 0.00495515f, -0.05126247f, -0.05441042f, 0.02162868f, -0.06409550f, -0.01349360f, 
    -0.07076377f, 0.05353201f, -0.04622792f, 0.02633021f, 0.01656360f, -0.02712914f, -0.01328977f, -0.06069490f, 
    -0.00871518f, 0.00859629f, -0.07133468f, 0.03660668f, -0.00498199f, -0.06589144f, -0.05749800f, -0.02144795f, 
    -0.01538702f, -0.07151468f, 0.06126589f, 0.06030687f, 0.03502635f, -0.00015150f, -0.07094886f, -0.01170680f, 
    -0.02588073f, 0.00238219f, -0.03389783f, -0.06373266f, 0.04577412f, 0.04599397f, -0.00776809f, -0.07765210f, 
    -0.04756648f, -0.07090762f, -0.01408211f, -0.05371511f, 0.03854032f, -0.06354070f, -0.06265967f, -0.00120175f, 
    0.04401188f, 0.05287533f, -0.01196993f, -0.03164393f, 0.05680627f, -0.04811721f, -0.03672044f, 0.04191420f, 
    0.00079121f, 0.06729675f, -0.05864776f, 0.04621241f, -0.06016665f, 0.02110044f, 0.05877456f, 0.04204505f, 
    -0.06301077f, 0.01192247f, 0.02677022f, 0.04615204f, -0.05083002f, 0.03083522f, -0.05674431f, -0.03359319f, 
    0.06011825f, -0.07763884f, 0.05268753f, -0.00308994f, 0.03508123f, -0.00236288f, -0.03173249f, -0.02942115f, 
    -0.00988795f, 0.00702046f, -0.05109033f, 0.02393859f, -0.06219746f, 0.01431760f, 0.06784014f, -0.05272014f, 
    -0.06525411f, 0.00656421f, -0.07487652f, 0.05789765f, 0.06138225f, -0.06419837f, 0.03687652f, 0.02347638f, 
    -0.04970599f, -0.03511156f, 0.02112926f, -0.02440355f, -0.02959170f, -0.01431064f, 0.06399472f, 0.02832781f, 
    -0.02602111f, 0.04063722f, 0.00027347f, 0.02869003f, 0.02733717f, -0.05338651f, 0.04324905f, 0.03383406f, 
    0.00290360f, -0.07689266f, -0.04782608f, 0.02262470f, 0.04694668f, -0.01778612f, -0.07109883f, -0.01055758f, 
    0.01648780f, -0.05181900f, 0.04092517f, -0.05746542f, -0.04148268f, -0.06818856f, 0.04848717f, 0.05250102f, 
    0.06314042f, -0.06859147f, 0.01806582f, 0.04818213f, -0.02643498f, 0.02665648f, 0.01229802f, -0.05312376f, 
    -0.06230299f, -0.05514091f, -0.07188705f, -0.04075707f, -0.07538894f, 0.02869640f, -0.05661711f, -0.06226372f, 
    -0.01105264f, 0.03477823f, 0.05898973f, 0.05648058f, -0.03795072f, 0.00656271f, -0.04935685f, -0.02140137f, 
    -0.00044180f, 0.00471314f, -0.02080660f, 0.01694808f, -0.01984833f, -0.06933520f, 0.03651143f, 0.06095342f, 
    0.02534713f, -0.01815733f, -0.05785578f, 0.04003436f, 0.00162227f, 0.00862261f, 0.02892707f, -0.03863366f, 
    -0.14485694f, 0.16606465f, 0.33614862f, -0.00765415f, 0.07949369f, -0.33428866f, -0.09123154f, -0.05588266f, 
    0.08483892f, 0.03551880f, 0.11824517f, 0.16934285f, -0.29540369f, 0.25237396f, -0.20327418f, 0.01567739f, 
    0.15578648f, 0.02532032f, -0.03301692f, 0.26385713f, -0.18460418f, 0.01809091f, 0.08884004f, 0.12630548f, 
    -0.28191414f, 0.09882702f, 0.06573009f, -0.03749725f, 0.02228224f, -0.00597550f, -0.06629633f, -0.04670471f, 
    0.00977350f, -0.13779089f, 0.07883290f, -0.15714040f, 0.68560243f, -0.04748470f, 0.09094086f, 0.05238124f, 
    -0.04006129f, 0.04430623f, 0.04237292f, 0.14719090f, 0.00131385f, 0.19207561f, 0.22487691f, 0.07967932f, 
    -0.17480159f, 0.11129700f, -0.22068353f, 0.10489993f, -0.03014977f, -0.00855840f, -0.11920516f, 0.03926063f, 
    -0.06319535f, 0.04446296f, -0.04450786f, 0.03347286f, 0.12297515f, -0.20445824f, 0.03525835f, -0.19597876f, 
    -0.14842004f, 0.02467160f, 0.04772555f, 0.09077275f, 0.02838710f, -0.08615437f, 0.01495584f, -0.11772174f, 
    -0.19185829f, 0.02619641f, 0.09990551f, -0.17502680f, 0.02532838f, -0.04944998f, -0.07724451f, 0.20844333f, 
    0.00457086f, 0.17558205f, 0.12335433f, 0.01788033f, -0.54969943f, 0.29937312f, 0.40825713f, 0.32455119f, 
    0.04596117f, 0.19045843f, -0.00245077f, 0.07253299f, 0.11072158f, 0.03135476f, -0.04929887f, 0.02653797f, 
    -0.17835000f, 0.01344876f, -0.06569783f, -0.10393879f, -0.06050180f, 0.04139924f, 0.00556120f, 0.07187672f, 
    0.10535084f, 0.04100476f, 0.06828313f, 0.10095596f, -0.22653536f, 0.02304930f, -0.21603020f, 0.08137481f, 
    0.01399122f, -0.02938623f, -0.07958580f, 0.08094542f, 0.06245235f, -0.04702116f, -0.09600302f, -0.01169470f, 
    -0.18933158f, 0.31803554f, 0.18098933f, 0.09363341f, 0.13368827f, -0.22463585f, 0.07624386f, 0.15050842f, 
    -0.05114323f, 0.10902089f, 0.07651326f, -0.00327045f, -0.23602343f, 0.19904608f, 0.20209086f, -0.05627204f, 
    -0.06640168f, -0.01174900f, 0.07371657f, 0.02588777f, 0.15377840f, 0.00133911f, 0.22830161f, -0.06606580f, 
    0.00658158f, -0.11287850f, -0.04403456f, 0.32321718f, 0.21924111f, 0.00181096f, 0.09442089f, -0.07149869f, 
    -0.04476125f, -0.01519451f, -0.02894772f, -0.16407116f, -0.06920248f, 0.11207877f, -0.08939263f, 0.08794441f, 
    0.10876961f, 0.05697931f, -0.02104816f, 0.02634262f, 0.07160392f, 0.02998259f, -0.03398821f, 0.16154650f, 
    -0.25269046f, 0.07261230f, 0.10304644f, 0.11512928f, -0.11565913f, -0.11114488f, -0.08001678f, -0.02827515f, 
    0.04069392f, -0.02075007f, -0.15143977f, -0.16837429f, -0.14504321f, -0.11257381f, -0.03938520f, -0.16075526f, 
    0.10753202f, 0.00761642f, 0.22822957f, 0.19229744f, -0.15232524f, -0.01081466f, -0.03118623f, 0.06287337f, 
    -0.17484382f, 0.33036089f, -0.08638678f, -0.19165048f, 0.06568348f, -0.14597310f, 0.09792827f, 0.02554375f, 
    0.06361852f, -0.11142141f, -0.04574269f, -0.04801876f, -0.48535484f, 0.38608706f, 0.29697260f, -0.00642786f, 
    0.13318367f, -0.02927814f, -0.06935088f, 0.03894054f, -0.02763078f, 0.03869275f, -0.31870300f, -0.13329969f, 
    -0.24818267f, -0.42398420f, -0.36619705f, -0.01911304f, 0.04608493f, 0.01991669f, 0.07554867f, 0.03041050f, 
    0.09377845f, -0.02858888f, -0.02874476f, 0.10488883f, -0.17744569f, -0.36841896f, 0.14556126f, -0.09122898f, 
    0.14064373f, 0.03845436f, -0.04430518f, 0.24068847f, 0.25630116f, 0.31582567f, -0.16015752f, 0.10659596f, 
    -0.05932369f, 0.61376011f, 0.36302137f, 0.12660958f, 0.02436133f, -0.05294480f, 0.17123020f, -0.10100359f, 
    0.06552395f, -0.07594617f, 0.12351131f, -0.15414712f, -0.22823258f, -0.29087025f, 0.21461362f, 0.07279772f, 
    -0.18797171f, -0.07691450f, -0.22286929f, 0.01236289f, 0.08534624f, 0.02524276f, 0.04876872f, 0.16418748f, 
    0.10468630f, 0.35072821f, 0.07135136f, 0.12095725f, 0.12305341f, 0.11249088f, -0.21175097f, 0.02626866f, 
    -0.10778718f, 0.13656716f, -0.05676011f, 0.06176418f, 0.09185493f, 0.52254719f, 0.02195958f, 0.34382749f, 
    -0.08875576f, -0.27725509f, 0.22082005f, 0.18176471f, 0.02044046f, -0.02178926f, -0.04222289f, -0.02824590f, 
    0.29203930f, -0.13199218f, -0.13338067f, -0.16671734f, -0.04504450f, 0.05293838f, 0.03205689f, 0.04766398f, 
    0.08815024f, 0.01140457f, 0.08649374f, 0.12871672f, 0.14973521f, 0.25431588f, 0.39030537f, 0.15499209f, 
    0.20857185f, 0.15203150f, 0.12060282f, 0.14808270f, -0.04623500f, -0.00355692f, 0.02857371f, -0.03360268f, 
    0.27289712f, -0.18134961f, 0.25760636f, -0.11046263f, 0.17526822f, -0.07853828f, 0.12454941f, 0.00801916f, 
    0.07737187f, 0.09616175f, 0.20079096f, -0.04195205f, -0.00427556f, -0.19971468f, -0.21706489f, -0.06819171f, 
    -0.04204378f, -0.03298521f, 0.01620510f, 0.01483360f, 0.17632213f, -0.10204951f, 0.22925279f, -0.25949892f, 
    0.12910962f, 0.47841486f, 0.51974118f, 0.26356253f, -0.01785629f, -0.09535228f, 0.20167620f, -0.02067348f, 
    -0.01300220f, -0.05800608f, -0.30414242f, -0.08126800f, -0.16262367f, 0.03550560f, -0.12671396f, 0.01247683f, 
    -0.09142314f, 0.03161399f, -0.17905879f, -0.01740642f, 0.22654264f, 0.11515485f, 0.09688421f, 0.26379856f, 
    -0.16930243f, 0.00066231f, -0.20655245f, 0.17946315f, 0.08743836f, -0.16262609f, -0.06131806f, -0.00436408f, 
    0.00979193f, -0.13750853f, -0.13616194f, 0.17612004f, 0.22692966f, 0.16156326f, 0.18872251f, 0.07091264f, 
    -0.06417788f, 0.00689235f, 0.17314875f, 0.09749585f, -0.10401844f, 0.09884623f, 0.14351211f, 0.03071317f, 
    0.44960105f, 0.10067690f, -0.17522624f, 0.34139878f, 0.15182923f, 0.14729007f, 0.06953284f, 0.01681078f, 
    0.04035292f, -0.10006961f, -0.36090273f, 0.03407117f, 0.27523640f, -0.06691685f, -0.12077515f, 0.01765336f, 
    -0.01311139f, 0.12416374f, 0.04735869f, -0.14976066f, 0.10935342f, 0.15623525f, 0.10984019f, 0.00669083f, 
    0.12295571f, -0.04095788f, -0.26610580f, -0.03572095f, -0.22269304f, -0.06226691f, 0.14888278f, -0.08293892f, 
    -0.02396498f, 0.21664058f, -0.02336179f, 0.15970916f, 0.49564248f, 0.06654736f, -0.36868730f, 0.11736896f, 
    0.11643297f, 0.00095811f, -0.05733277f, -0.13138278f, 0.04810552f, -0.06354909f, -0.17843875f, -0.12363198f, 
    0.24163423f, -0.12784074f, 0.58751684f, 0.19367716f, 0.13692169f, 0.06518744f, -0.03538311f, 0.07092030f, 
    0.12181359f, -0.10485899f, 0.13933183f, -0.06372789f, -0.79114556f, -0.04932114f, 0.76275033f, -0.04784398f, 
    -0.05079957f, 0.08050448f, -0.34386504f, -0.08870145f, -0.04389130f, -0.19014809f, 0.01538735f, 0.02499522f, 
    0.14232264f, -0.03957143f, 0.19349696f, 0.28126168f, -0.00850982f, 0.08077116f, 0.14067635f, 0.03257282f, 
    0.27292243f, 0.13173282f, -0.05164710f, 0.16523205f, 0.03017368f, 0.28249928f, -0.33594513f, -0.18095696f, 
    0.04515106f, -0.32799551f, 0.08078808f, 0.10271245f, -0.09545369f, -0.06513114f, -0.08240341f, 0.03041876f, 
    0.06661068f, 0.00898643f, 0.18293871f, -0.05299082f, -0.20724493f, -0.01539325f, -0.23692843f, -0.10411321f, 
    -0.30071673f, -0.30294141f, -0.10819647f, -0.57176244f, 0.08416117f, -0.22757527f, 0.12072112f, 0.11918627f, 
    0.03363672f, -0.07324255f, -0.05031370f, -0.04875530f, 0.02573253f, -0.13530070f, -0.00247836f, -0.06343020f, 
    0.13232063f, -0.18119176f, 0.03487540f, -0.37440163f, 0.10776945f, -0.02256677f, -0.09635020f, 0.04977683f, 
    -0.09912229f, 0.05560559f, -0.08055118f, -0.04957284f, 0.44104844f, 0.15133870f, -0.16869195f, -0.13523412f, 
    -0.10429116f, -0.37075058f, -0.12014940f, 0.11117941f, -0.00764575f, 0.07934450f, 0.10549835f, 0.33597714f, 
    0.09760308f, 0.05780562f, -0.17602517f, 0.00308200f, -0.08067184f, 0.02110167f, -0.03470314f, 0.11611310f, 
    -0.12271388f, 0.08371273f, 0.16004382f, 0.04416798f, -0.14345498f, -0.30993697f, -0.00782812f, -0.29441458f, 
    -0.03804925f, -0.00897441f, -0.28177187f, -0.21026811f, 0.07900482f, 0.10430009f, 0.01445868f, -0.16957392f, 
    0.33600071f, 0.01406496f, 0.36818990f, 0.27520949f, 0.01158321f, 0.00324848f, 0.33940980f, 0.07764754f, 
    0.01419882f, -0.01551657f, 0.21740301f, 0.47619691f, -0.17411445f, -0.14374718f, 0.49182633f, 0.09612183f, 
    0.04826197f, 0.24200490f, -0.10181855f, -0.03974510f, 0.18379237f, -0.09062348f, 0.08059268f, 0.12332689f, 
    0.02246233f, 0.33684069f, 0.00789354f, 0.29067594f, 0.04962076f, -0.16730569f, -0.11142068f, -0.11889561f, 
    -0.07882059f, -0.10999969f, -0.10741287f, 0.12929972f, 0.10925089f, 0.16461696f, 0.12603542f, 0.07758633f, 
    0.02024072f, 0.19711044f, -0.12168071f, 0.03400997f, -0.03597741f, 0.32078978f, 0.11500216f, 0.39044264f, 
    0.17571160f, 0.12930697f, -0.15266179f, 0.00235554f, -0.04483658f, -0.12112141f, -0.21765135f, -0.02693883f, 
    0.00880076f, 0.00581379f, -0.01204004f, 0.01242254f, 0.22283642f, -0.29340219f, -0.06590571f, -0.10096548f, 
    -0.07550722f, -0.01704859f, -0.26187620f, 0.17543520f, 0.09673509f, -0.06143215f, -0.14235748f, -0.13972878f, 
    -0.14287488f, -0.03421604f, -0.18059391f, 0.13149038f, -0.04289903f, 0.08040889f, -0.04688222f, -0.17217214f, 
    -0.14963107f, -0.20857915f, -0.11460612f, 0.16283251f, -0.22933385f, -0.23834088f, 0.14160971f, 0.36358580f, 
    0.19411866f, 0.32568178f, -0.08561598f, -0.14380480f, -0.09418993f, -0.09081835f, 0.02951474f, 0.13126329f, 
    -0.39229280f, 0.03438139f, -0.31988084f, 0.07112326f, 0.17195995f, 0.09852491f, -0.09012748f, 0.17566390f, 
    0.02461129f, 0.15691407f, -0.08039824f, 0.33395544f, 0.10824800f, 0.16520287f, 0.44886276f, 0.78673029f, 
    0.24256782f, 0.12984337f, 0.37049356f, 0.13343361f, 0.06643359f, -0.06364778f, -0.23841794f, -0.07773075f, 
    -0.34218323f, -0.04469023f, -0.42084301f, 0.32009131f, 0.36492631f, 0.01455212f, -0.39430180f, -0.08898162f, 
    -0.09092363f, -0.31134114f, -0.02666449f, -0.41749936f, 0.04052152f, 0.04425378f, 0.03156627f, -0.11216176f, 
    -0.00847714f, 0.08596977f, -0.12154609f, 0.24061257f, 0.10776963f, -0.05660427f, 0.10645710f, 0.11099710f, 
    -0.29388282f, 0.04262945f, -0.37854144f, -0.00663579f, 0.34356761f, -0.02903713f, 0.08431774f, -0.08192783f, 
    -0.00826824f, -0.13892314f, -0.27471241f, -0.28055745f, -0.26320207f, -0.42697671f, -0.03722689f, -0.06929675f, 
    0.18734707f, 0.08496486f, 0.04828602f, -0.10165147f, 0.30223215f, 0.07501683f, 0.29794392f, 0.32856411f, 
    0.34331959f, 0.19931705f, 0.17741582f, 0.02278298f, -0.03479601f, -0.08693328f, -0.09172206f, -0.10267749f, 
    0.10676070f, -0.05365749f, -0.08779974f, 0.02108451f, -0.40896615f, -0.43879232f, -0.55748636f, -0.07702165f, 
    -0.12355674f, -0.05067843f, -0.15439968f, 0.13266131f, 0.13170835f, -0.03670077f, 0.13168021f, 0.10013705f, 
    0.02294888f, 0.24024235f, 0.15524681f, 0.22170466f, 0.07875632f, 0.07317369f, 0.06920485f, -0.02617230f, 
    0.25876194f, -0.02455985f, 0.04323382f, 0.42396370f, 0.24819797f, 0.31312266f, 0.11611433f, 0.50707078f, 
    0.05022443f, 0.08662144f, 0.08476304f, 0.12775427f, 0.07804748f, 0.03464892f, 0.05173773f, 0.01806226f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.19609568f, -0.25087598f, 0.14342229f, 0.27169541f, 0.06191385f, -0.13833873f, -0.04843412f, 0.03764907f, 
    0.22702667f, 0.02300005f, -0.01745528f, -0.00787733f, 0.23316339f, 0.11262034f, 0.00975490f, 0.05530725f, 
    0.25540328f, 0.08718812f, -0.13961637f, 0.15022305f, 0.27473173f, 0.00308816f, 0.11440344f, 0.03712407f, 
    0.06442476f, -0.00506485f, 0.34234208f, 0.02761421f, 0.03757719f, 0.17685384f, -0.07506924f, -0.16136570f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.46036676f, 0.41664717f, 0.18190378f, -0.24759930f, -0.12470193f, 0.17539333f, -0.04268211f, -0.10615873f, 
    0.22301070f, -0.53564209f, -0.01171259f, -0.01684361f, -0.31875154f, -0.16420472f, -0.04186185f, -0.41655019f, 
    -0.00213995f, -0.49926165f, 0.43105170f, -0.02263044f, -0.63404644f, -0.07592464f, 0.23543240f, 0.37104285f, 
    -0.37038246f, -0.03614325f, -0.29691076f, -0.08696204f, -0.71926624f, 0.16537063f, 0.24989776f, 0.09749259f, 
    0.35641667f, 0.12599838f, -0.28453577f, 0.19718525f, -0.19931695f, 0.19560754f, 0.02229488f, 0.12049192f, 
    0.19675530f, -0.68330914f, -0.13285112f, -0.12143391f, 0.07443290f, 0.16020177f, -0.07062940f, -0.98852736f, 
    0.40111533f, 0.01409938f, -0.28044313f, 0.19382700f, 0.32252011f, 0.16797227f, 0.14896938f, -0.13184838f, 
    -0.14014910f, 0.17073207f, 0.26658514f, -0.11031783f, -0.50716716f, 0.18362448f, 0.32596636f, -0.93955851f, 
    -0.50329268f, -1.37839139f, -0.24727641f, 0.29884675f, 0.25992358f, 0.22240904f, 0.10251788f, 0.05803464f, 
    -0.25062680f, -0.23515889f, 0.03517910f, 0.04638347f, 0.17426951f, -0.25267854f, -0.15533766f, 0.20726737f, 
    -0.05731557f, 0.05210010f, -0.61532819f, 0.24711320f, -0.26304862f, 0.08957278f, -0.03809980f, -0.17713088f, 
    -0.14661773f, 0.13350154f, 0.45924857f, -0.12028728f, 0.09840591f, 0.08087008f, 0.77217740f, -0.20886791f, 
    -0.29618150f, 0.18208598f, -0.25633407f, -0.60231149f, 0.09451498f, 0.25890750f, -0.05975823f, -0.04481613f, 
    -0.35131493f, 0.43453157f, 0.14340711f, 0.12870774f, -0.38112146f, -0.07353494f, -0.06823552f, -0.43424687f, 
    -0.50519007f, 0.26471967f, -0.05012837f, 0.04397098f, -0.11822783f, 0.16837041f, -0.37602556f, -0.07096749f, 
    0.11647579f, 0.25781465f, -0.01579898f, 0.16479543f, 0.20862903f, 0.14967224f, 0.25491425f, 0.31592524f, 
    0.26551911f, -0.16451196f, 0.10579647f, 0.33386621f, 0.09400834f, 0.18862893f, -0.16947740f, -0.10837562f, 
    0.18116234f, 0.22833909f, -0.09107072f, -0.04124339f, -0.38727838f, -0.66626537f, -0.16052492f, 0.42788938f, 
    0.12114754f, -0.24545567f, -0.10323565f, -0.32554924f, -0.34564966f, 0.02579919f, 0.23186223f, -0.17679469f, 
    0.26166391f, 0.10677236f, -0.23781842f, 0.12051474f, -0.33207193f, 0.09415466f, 0.23829092f, 0.32789767f, 
    -0.11242688f, -0.11751522f, 0.00556057f, 0.15395984f, 0.20392120f, -0.51317132f, 0.04733681f, 0.15214400f, 
    0.43390939f, -0.46068400f, 0.00547543f, 0.03541853f, -0.19639385f, 0.21436203f, -0.08548781f, 0.03899757f, 
    0.14773597f, -0.06319758f, 0.09719541f, -0.11208418f, 0.15659845f, 0.14294159f, 0.17437662f, 0.27300516f, 
    -0.21275917f, -0.17477348f, -0.28041613f, -0.05210130f, 0.15336962f, 0.28634527f, -0.54303628f, -0.05602629f, 
    0.26466647f, -0.28177863f, -0.39685956f, 0.19681923f, 0.09827758f, -0.42383271f, 0.16477704f, 0.01516405f, 
    -0.51997942f, 0.30065635f, -0.10524400f, -0.16197701f, 0.26047781f, -0.16648221f, 0.08917663f, 0.20820588f, 
    -0.65117198f, -0.53120071f, -0.95327395f, -0.50769389f, 0.22528182f, -0.00599118f, 0.07708963f, 0.10108224f, 
    0.51683265f, -0.35900703f, 0.50434077f, -0.09361769f, 0.06507286f, -0.80850697f, -0.28183994f, 0.04182230f, 
    0.22246003f, -0.27549413f, -0.64672899f, -0.19114468f, 0.31631866f, 0.28568825f, -0.12877695f, -0.09768855f, 
    -0.66109502f, -0.03618098f, 0.13059545f, -0.03448743f, -0.09452640f, 0.09968482f, 0.11811264f, 0.56571001f, 
    0.07848229f, 0.27346167f, 0.32398859f, -0.31777969f, 0.20899889f, 0.03255781f, -0.41287023f, 0.23950402f, 
    -0.47159037f, -0.47984135f, -0.93144470f, -0.06286014f, 0.15346420f, -0.65986520f, 0.14163239f, -0.28814220f, 
    -0.01086979f, -0.69951707f, 0.48868665f, -0.47403759f, -0.09207519f, -0.06871378f, 0.14373411f, 0.12414105f, 
    0.29622722f, 0.39064679f, -0.05256288f, 0.01224263f, 0.01269115f, 0.19346792f, -0.13057952f, -0.12895386f, 
    -0.27469838f, 0.46917677f, -0.31671578f, 0.39451259f, 0.19931538f, 0.12581381f, -0.21553200f, 0.19326758f, 
    -0.74031729f, -0.72702217f, -0.27915245f, -0.06893788f, -0.04308870f, -0.49154350f, -0.57146370f, -0.48903126f, 
    -0.14381494f, -0.54324931f, 0.40220657f, -0.25034770f, 0.37147561f, 0.11287964f, 0.11651760f, 0.08910821f, 
    -0.03969488f, -0.23994106f, -0.10191083f, 0.00417989f, 0.15988669f, 0.19647932f, 0.01065662f, 0.47623095f, 
    0.26098382f, -0.60744464f, 0.09317802f, -0.82103300f, -0.09649890f, -0.01139160f, 0.26042014f, -0.57891744f, 
    0.27848166f, 0.48406428f, -0.11750782f, 0.02120598f, 0.11945605f, -0.34589645f, -0.17809698f, 0.05137099f, 
    -0.56134230f, 0.24866845f, 0.19785656f, -0.45998380f, 0.02725714f, 0.38743359f, -0.02035975f, -0.04355088f, 
    -0.00546393f, 0.42470607f, 0.13588749f, -0.02271525f, -0.35205966f, -0.23477398f, 0.02086061f, -0.46513280f, 
    0.53491116f, -0.29828310f, -0.75839281f, 0.04602252f, 0.34042847f, 0.02020973f, 0.05546107f, -0.10622841f, 
    -0.16135415f, -0.90106058f, 0.50174230f, 0.09904400f, 0.29505533f, 0.08778191f, -0.64250708f, -0.68530649f, 
    0.20011163f, -0.13432913f, -0.00775916f, 0.24443774f, -0.97994804f, 0.05581759f, 0.13470079f, -0.09295856f, 
    -0.30234337f, 0.40115771f, 0.15850508f, 0.03282469f, 0.28738460f, 0.11991994f, 0.05907829f, -0.37026560f, 
    -0.60672033f, 0.16983014f, 0.59488642f, -0.10487081f, -0.02257943f, -0.10738327f, -0.29986593f, -0.53088367f, 
    0.23173709f, -0.43948388f, 0.24893555f, 0.06912011f, 0.25329912f, 0.21147473f, -0.50897413f, -0.15999590f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.15082364f, 0.23366421f, -0.00352149f, -0.29344407f, -0.09748312f, 0.24356025f, 0.17679912f, -0.17509893f, 
    0.20340915f, -0.06174425f, 0.19652079f, -0.14448826f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
