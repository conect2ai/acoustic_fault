#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.01898932f, -0.52565342f, -0.39393932f, -0.65023851f, -0.98302931f, -0.67617166f, -0.57269764f, -0.26331043f, 
    0.48089629f, 1.19334209f, 0.89639050f, -0.58669436f, -0.18053947f, -0.82574010f, -0.15974584f, -0.23252532f, 
    0.19293612f, 0.05860465f, 0.98392642f, 0.88101977f, -0.37178090f, 0.41821423f, 0.13767032f, -0.49327558f, 
    0.43970335f, 0.26849809f, 0.12886934f, 0.73759496f, 0.46315807f, -1.23535693f, -0.59346855f, 0.57207060f, 
    0.65205657f, 0.47185427f, -0.48508975f, 0.35234323f, 0.36692166f, -1.25755382f, -0.49558103f, -0.90729016f, 
    0.67014474f, 0.75024772f, -0.09086201f, -0.19426847f, -0.43610042f, 0.18755983f, 0.20620064f, 0.75892001f, 
    -1.00323045f, -0.89400190f, -0.83016115f, 0.11475956f, 0.60316163f, -0.28148043f, 0.61751848f, 0.40239307f, 
    -0.34802255f, 0.59853870f, 0.58646494f, 0.42270949f, 0.61720037f, -0.00950755f, -0.50237733f, 0.95369202f, 
    0.52134234f, 0.82476944f, 0.11971056f, -0.72972834f, 0.48786020f, 0.28726897f, 0.01260814f, 0.52765542f, 
    -0.41747797f, -0.77954388f, -0.96483880f, 0.50725597f, -0.66329300f, -0.64892536f, -0.47138116f, -0.40845311f, 
    0.29160562f, -0.67406535f, -0.83580762f, -0.89876235f, -0.08661745f, 1.03449810f, -0.83630347f, 0.06716426f, 
    0.04525325f, 0.15512832f, -0.96115464f, 1.14926589f, 1.21965432f, 0.63497454f, 0.36455706f, 0.32427138f, 
    0.17666326f, -0.33728686f, -0.23710382f, -0.81289321f, -1.16082609f, -0.87531078f, 0.58652866f, 0.77639133f, 
    0.81026989f, -0.32141653f, 0.05672711f, -0.12803794f, 0.66518390f, 1.09988034f, -0.52560586f, 0.29033846f, 
    0.90558505f, -0.81843078f, 0.04158125f, -0.53026932f, -0.08277699f, 1.31478941f, -0.85996008f, -0.89697820f, 
    0.39391467f, -0.21527141f, -0.32385400f, -0.20341791f, 0.25922465f, 0.26017451f, -1.21939027f, 0.96861070f, 
    0.21874636f, -0.53796554f, 1.30991101f, 0.10428452f, -0.51477939f, 0.02472780f, -0.05414880f, 0.89697349f, 
    1.13184023f, 0.88824028f, -0.16623075f, 0.36792746f, 0.28780985f, -0.09246110f, 0.11745692f, -0.38950032f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.13690144f, -0.11539056f, 0.19149695f, -0.01620940f, -0.11240842f, 0.07811668f, 0.21239147f, 0.04553086f, 
    0.16450110f, 0.27742010f, 0.04761491f, 0.29426023f, 0.05578914f, 0.26082152f, -0.11125959f, 0.45477661f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.04680320f, 0.19379419f, -0.13546334f, -0.01152322f, 0.07584868f, -0.08416873f, -0.12281487f, -0.01578861f, 
    0.00906403f, -0.06645657f, 0.05277188f, 0.14223221f, -0.00140627f, 0.06639673f, -0.13233976f, -0.07769176f, 
    -0.06454569f, 0.07885649f, -0.04077432f, 0.04331392f, 0.04323870f, 0.39602265f, -0.11886548f, -0.05767277f, 
    0.37531462f, 0.21693788f, -0.04959108f, 0.00497694f, -0.00429402f, -0.10812557f, -0.00373929f, 0.02914716f, 
    0.09565382f, 0.02065348f, 0.03224864f, 0.05272184f, 0.01163393f, -0.10449640f, -0.06630029f, -0.11862931f, 
    0.12578683f, -0.02442200f, 0.04952074f, -0.06544171f, 0.12967783f, 0.19465949f, -0.05141642f, 0.13805580f, 
    -0.16261443f, -0.06122515f, 0.04763098f, 0.08860291f, 0.03020493f, 0.00679679f, 0.01960602f, 0.03686462f, 
    -0.00161713f, -0.11930966f, 0.11712965f, 0.10072342f, 0.02238437f, 0.20989753f, 0.21659233f, 0.11509738f, 
    -0.07476166f, -0.07960465f, 0.12599887f, 0.03978869f, -0.02492605f, 0.17258108f, -0.02610969f, 0.03005638f, 
    -0.03283994f, 0.06784791f, 0.05499884f, -0.00883856f, -0.00835773f, 0.15110768f, 0.03080136f, -0.00225427f, 
    -0.01682729f, 0.24439998f, -0.08207818f, 0.23789468f, -0.09278136f, -0.01848286f, 0.07100604f, 0.13333708f, 
    0.05450141f, -0.07114176f, 0.09633218f, 0.18630892f, -0.18513314f, -0.00637677f, -0.08264392f, -0.10078962f, 
    -0.11767752f, -0.05997178f, 0.04060209f, -0.05971946f, 0.37147069f, 0.09580024f, -0.14734121f, 0.07610026f, 
    0.37841976f, -0.07004663f, -0.04527784f, 0.06582107f, 0.04739363f, -0.08281510f, 0.03554177f, -0.10134687f, 
    -0.01103278f, -0.03429307f, 0.16878511f, 0.00888224f, 0.21940552f, -0.08072665f, -0.00669395f, -0.02293085f, 
    -0.04200438f, 0.06009718f, 0.22517231f, -0.12900268f, -0.12473340f, 0.07410216f, -0.08957616f, 0.05687002f, 
    -0.02914193f, 0.01261663f, -0.02379799f, -0.01084472f, -0.06210707f, 0.06354654f, -0.11036239f, 0.03757716f, 
    -0.10970855f, 0.00788033f, 0.10519643f, 0.09645019f, 0.11384033f, -0.14767411f, -0.15783499f, -0.16839077f, 
    -0.12227552f, 0.07582604f, -0.05279575f, 0.21774787f, 0.03029231f, -0.04374755f, 0.08285584f, -0.06235347f, 
    -0.06947011f, -0.07439064f, 0.09339942f, 0.11931272f, -0.10648696f, 0.07493433f, -0.19147064f, 0.15360330f, 
    0.12877676f, 0.14117783f, -0.04107079f, 0.22574422f, -0.05098897f, -0.03443999f, -0.01751884f, -0.01562618f, 
    0.09278516f, 0.08867234f, -0.06307396f, 0.06402066f, 0.09575941f, 0.09351087f, -0.07174938f, -0.11136101f, 
    -0.04634655f, 0.02493134f, -0.06257693f, -0.06635465f, 0.09218404f, -0.07838874f, 0.17039803f, 0.01857180f, 
    0.09070687f, -0.05783388f, -0.01049210f, 0.04872441f, 0.02034778f, 0.09576999f, -0.03405444f, -0.01106067f, 
    -0.01148839f, -0.07239409f, -0.01070403f, 0.05863579f, 0.19009018f, -0.10896565f, -0.04401991f, -0.01553475f, 
    -0.33543950f, -0.35972294f, 0.08651763f, -0.03560569f, -0.32739121f, 0.17139387f, 0.10493257f, -0.09927199f, 
    -0.00964698f, -0.01301575f, -0.00659815f, 0.00223344f, 0.02866678f, 0.06744120f, 0.05728260f, 0.05731566f, 
    0.03390688f, 0.01574709f, 0.05174939f, 0.03204520f, 0.24484268f, 0.27906469f, 0.18793267f, 0.22878258f, 
    -0.03445736f, -0.02519019f, -0.00026741f, -0.03601738f, 0.00591749f, -0.04084876f, 0.03353637f, -0.01992789f, 
    0.04918012f, -0.08335789f, -0.12014264f, -0.02228402f, -0.06807341f, 0.06744811f, 0.01014643f, 0.05930617f, 
    0.27521276f, -0.08539825f, -0.16951856f, -0.21036223f, -0.10872784f, -0.06832096f, -0.05152452f, 0.09406190f, 
    -0.09002608f, 0.10495294f, 0.05457778f, -0.02157817f, -0.03249891f, 0.02411411f, -0.08023521f, -0.10432158f, 
    0.07740033f, -0.06726450f, -0.00414358f, -0.06342570f, -0.11008392f, 0.07229988f, 0.13722166f, 0.09876915f, 
    0.07637107f, 0.17192620f, -0.15020435f, -0.15037087f, -0.01961776f, 0.24006678f, 0.05509609f, 0.19253665f, 
    -0.09800339f, 0.05410035f, 0.13794239f, -0.00394300f, 0.04475874f, -0.03939024f, -0.03771256f, -0.08439384f, 
    -0.18382959f, 0.22827618f, -0.13173129f, 0.00177623f, -0.23876852f, 0.00604491f, -0.09198374f, -0.09653758f, 
    0.15014781f, 0.00655103f, 0.03889375f, -0.01105842f, 0.09680559f, 0.06517823f, -0.07560711f, 0.14438036f, 
    -0.01596827f, -0.07958777f, -0.18203640f, -0.01719256f, 0.37550136f, -0.31817642f, -0.26978183f, -0.25304762f, 
    -0.23667152f, 0.00159566f, 0.16848999f, 0.06774671f, -0.05449368f, -0.05047223f, -0.06241462f, -0.01843546f, 
    0.03453352f, 0.01538040f, 0.02683270f, -0.04040771f, -0.03526914f, 0.08479739f, -0.04966289f, 0.07306390f, 
    0.06494895f, -0.05216290f, -0.00035132f, 0.04578913f, -0.04667046f, -0.00395820f, -0.00216564f, 0.03666306f, 
    0.05071151f, -0.02519836f, -0.04023377f, -0.04977549f, -0.01832731f, -0.02694719f, 0.04654092f, -0.01699525f, 
    -0.04738218f, -0.04806196f, 0.04607415f, 0.02072984f, 0.02898494f, -0.01328520f, 0.04935151f, 0.01907851f, 
    -0.01267643f, 0.03935969f, -0.04914248f, 0.01016444f, 0.03158873f, -0.05598115f, -0.05213303f, -0.00869471f, 
    0.01355475f, 0.04171933f, -0.00079859f, -0.04897613f, -0.04378186f, 0.04335285f, -0.01545168f, 0.04832303f, 
    -0.00297844f, -0.05007902f, 0.04979108f, 0.00726273f, -0.05765959f, 0.03498122f, 0.04828957f, 0.04547967f, 
    -0.00377060f, -0.01069674f, 0.00771561f, -0.02965668f, 0.01739568f, -0.06000565f, 0.03050809f, 0.03855957f, 
    0.04554291f, -0.04861749f, -0.03973901f, -0.01475461f, 0.02573482f, -0.05208616f, -0.01515546f, 0.04554058f, 
    -0.02097015f, 0.00638414f, 0.04632861f, -0.05505249f, -0.04834018f, -0.00472978f, 0.01319130f, -0.05519817f, 
    -0.01392074f, -0.01897543f, -0.05312849f, -0.04257632f, -0.03193086f, -0.01553336f, 0.01456017f, 0.03549509f, 
    -0.02846113f, 0.02198690f, -0.05181678f, -0.05976097f, -0.03212423f, -0.02559157f, 0.02493946f, 0.03923025f, 
    -0.03408685f, 0.02383979f, 0.00564524f, -0.02266577f, 0.00659612f, -0.06132295f, -0.01792252f, 0.03025814f, 
    0.04573174f, -0.05200749f, -0.01667915f, -0.04892239f, -0.01865011f, -0.04596145f, -0.04119449f, 0.03066573f, 
    0.02604368f, -0.05835623f, 0.04300576f, -0.00971947f, -0.02488447f, 0.01243612f, 0.04149833f, -0.04239565f, 
    -0.02975231f, 0.02572078f, 0.00321631f, -0.04851454f, 0.02873155f, -0.02984089f, -0.00876713f, -0.00244529f, 
    0.00280408f, 0.00686675f, 0.05119681f, -0.00254111f, -0.01569474f, -0.01382434f, -0.04968099f, -0.00643839f, 
    -0.04439713f, -0.03659356f, -0.00288226f, -0.02246422f, 0.02819874f, 0.01934066f, -0.00436310f, 0.00059107f, 
    0.01883661f, -0.04077680f, -0.05545213f, -0.01690358f, -0.03097764f, 0.00086298f, -0.02722426f, 0.03999491f, 
    -0.05476051f, -0.04475215f, 0.03202065f, -0.04724203f, -0.03720403f, -0.00283068f, -0.05213035f, -0.03406231f, 
    0.03798153f, -0.00549343f, -0.05951492f, -0.00590221f, -0.01363288f, 0.02358616f, -0.04826888f, -0.00768127f, 
    -0.01462511f, -0.04252391f, -0.00519884f, -0.02968719f, -0.05387663f, -0.05451348f, -0.03925631f, -0.00517938f, 
    0.02300636f, -0.00042458f, -0.04822745f, -0.04144311f, 0.01614026f, -0.03876281f, 0.00805925f, 0.03170960f, 
    0.03444570f, 0.03523808f, -0.02561764f, -0.05355739f, -0.03034107f, -0.01516968f, -0.05254322f, -0.05508813f, 
    0.01881045f, -0.01116860f, -0.05103854f, 0.00384791f, -0.04955643f, 0.01185773f, -0.01937250f, -0.03087715f, 
    0.01788074f, 0.03591245f, -0.03461646f, 0.02568126f, -0.04897209f, 0.03972333f, -0.00107477f, 0.03061999f, 
    0.00353945f, -0.05190362f, -0.05522012f, -0.04353030f, -0.02290555f, 0.03330512f, 0.02010235f, 0.00478917f, 
    -0.05925914f, -0.00667999f, -0.01268760f, 0.04052239f, -0.02786951f, -0.01581721f, -0.03330731f, -0.03589782f, 
    -0.01873236f, -0.02505657f, -0.05706218f, 0.02833947f, -0.01238603f, 0.02087273f, -0.04082396f, 0.00299320f, 
    0.02840884f, 0.00884248f, 0.03264869f, 0.00799026f, 0.04074224f, -0.00046654f, -0.01982854f, -0.00203255f, 
    0.03517842f, -0.00143422f, 0.03376136f, 0.03099179f, 0.04839893f, -0.00634525f, -0.05798287f, 0.02145432f, 
    -0.04741202f, -0.04049654f, -0.04126643f, -0.01579391f, -0.03688205f, -0.00015201f, -0.05712180f, 0.02005787f, 
    0.03819450f, -0.04753475f, -0.04092886f, 0.01808759f, -0.04323543f, 0.00708295f, -0.04319876f, 0.02916408f, 
    0.03157861f, -0.03241705f, 0.03399643f, -0.00435231f, 0.02808955f, -0.00035816f, -0.04991820f, -0.02376986f, 
    -0.03095917f, -0.03114688f, 0.02065680f, 0.04556964f, 0.02317828f, 0.00883825f, 0.02857714f, -0.01845992f, 
    0.04206114f, -0.02808039f, 0.03241149f, 0.00571407f, 0.01457512f, 0.00561085f, 0.01334086f, 0.00762107f, 
    -0.05914526f, -0.04378304f, -0.01276201f, -0.05960479f, 0.00894637f, 0.05722954f, -0.02650890f, 0.01305735f, 
    -0.02012535f, -0.01697661f, 0.00594130f, -0.02685280f, 0.01701983f, 0.01952398f, -0.00742052f, -0.01403730f, 
    -0.05127579f, -0.04184274f, 0.04674513f, 0.04149961f, 0.03321349f, -0.04940291f, 0.04114380f, 0.00346003f, 
    -0.02085559f, 0.01390493f, 0.04703459f, -0.03429636f, 0.00480752f, -0.00009892f, -0.03221070f, 0.04613897f, 
    0.02983676f, -0.03682376f, -0.02066197f, 0.04143354f, 0.03497922f, 0.03068933f, -0.05425673f, 0.04950703f, 
    0.03991346f, -0.05983743f, 0.02847836f, -0.05357086f, -0.05557047f, -0.00394283f, -0.06415316f, 0.03502851f, 
    -0.02785968f, -0.05691751f, -0.02639304f, -0.05392923f, -0.05393064f, -0.00544735f, -0.06037512f, 0.03902111f, 
    -0.01033971f, -0.04876147f, -0.04704221f, -0.01529599f, -0.03677749f, -0.02511112f, -0.04576243f, 0.02943894f, 
    -0.05726020f, 0.03706296f, 0.00237589f, -0.01882122f, -0.01915772f, -0.00692437f, -0.00062436f, -0.03353282f, 
    0.01144029f, -0.05297712f, -0.04255293f, 0.03441789f, -0.01910796f, -0.00549887f, 0.02011872f, 0.00453202f, 
    -0.02760423f, 0.01440077f, -0.02468217f, -0.05363781f, 0.01863812f, 0.04135126f, 0.02159906f, -0.05253271f, 
    -0.03064041f, -0.00239106f, 0.04398529f, 0.00491999f, -0.06254206f, -0.04732285f, -0.01516194f, 0.02318349f, 
    0.02024013f, -0.05635083f, -0.06237017f, -0.01300953f, -0.00327374f, 0.00633597f, -0.01130490f, 0.00056509f, 
    0.02895344f, 0.04699646f, -0.04493690f, -0.02325672f, -0.05732019f, -0.03457741f, 0.01248833f, 0.04520870f, 
    0.04572622f, 0.00962065f, 0.00222992f, -0.02824637f, 0.03840302f, 0.03930055f, -0.00059877f, -0.01176595f, 
    -0.01001355f, -0.02489810f, 0.00646981f, 0.00975237f, 0.04471092f, 0.00608730f, 0.03746650f, 0.03736477f, 
    -0.05343691f, -0.06136032f, -0.01169463f, -0.03156461f, 0.02429549f, 0.04470773f, -0.00027073f, 0.02308417f, 
    -0.04882259f, 0.03446744f, 0.03850740f, -0.01657408f, 0.00002153f, 0.04585734f, -0.00763214f, -0.03104114f, 
    -0.03346923f, 0.00156015f, -0.04654843f, 0.01976262f, 0.01885178f, -0.00273968f, 0.04025738f, 0.01184015f, 
    0.02204776f, 0.04416336f, 0.03710594f, -0.02546390f, -0.03958450f, 0.01936708f, -0.01828472f, 0.03407625f, 
    -0.04219454f, 0.02139993f, -0.03159135f, -0.04618205f, 0.02623531f, 0.00529433f, 0.02603584f, -0.05229907f, 
    -0.03376136f, 0.00471125f, 0.03703342f, -0.05043383f, -0.05831942f, -0.01737732f, 0.02000034f, -0.06152096f, 
    0.01091048f, -0.05776092f, 0.03484056f, -0.02739760f, 0.03261994f, -0.00644924f, 0.00785108f, 0.04232479f, 
    0.01667298f, -0.00713530f, -0.00266069f, 0.04533431f, 0.01459833f, 0.01716416f, -0.01795443f, -0.03020172f, 
    0.03537448f, 0.01783377f, 0.02625397f, 0.02343034f, -0.00346051f, -0.03862582f, -0.03476355f, -0.05535128f, 
    0.04388576f, -0.05670479f, 0.00832682f, -0.00316281f, 0.04075585f, 0.01830472f, -0.01152002f, -0.01057776f, 
    0.00176445f, 0.03516099f, -0.03381983f, -0.02544058f, -0.01688418f, 0.03570738f, -0.01648377f, -0.01561424f, 
    0.00536912f, -0.01864381f, -0.03201144f, -0.04982699f, -0.04701894f, -0.04129274f, -0.02836958f, -0.04805611f, 
    -0.04932187f, 0.04370028f, -0.05282724f, -0.05870118f, 0.03150702f, 0.02451475f, -0.05267889f, -0.03225206f, 
    0.01116407f, -0.00489422f, 0.02889661f, 0.04518256f, 0.04319710f, -0.04552122f, -0.02367939f, -0.04732484f, 
    -0.03975650f, -0.04180790f, 0.00496433f, -0.04276742f, 0.03696301f, -0.01045708f, -0.00067986f, 0.01468955f, 
    -0.06144353f, -0.04614347f, -0.02244600f, 0.03169724f, -0.02281444f, 0.04257384f, -0.03497959f, -0.02710007f, 
    -0.04920468f, -0.00516080f, 0.03415945f, -0.03016510f, 0.03990415f, -0.00571862f, -0.04069416f, -0.04174798f, 
    -0.05172421f, -0.04920717f, -0.02680132f, 0.04093819f, 0.02365031f, -0.01693969f, 0.00289326f, -0.05246652f, 
    -0.04811134f, 0.01357601f, 0.03542563f, -0.00648532f, -0.04801194f, -0.05703353f, 0.03257933f, 0.01552489f, 
    -0.00354156f, -0.04533025f, -0.04431609f, -0.03835882f, 0.02151568f, -0.03824390f, 0.00892605f, -0.05859533f, 
    -0.02992744f, -0.01763977f, -0.04213553f, -0.00689389f, -0.04311020f, -0.00422933f, -0.05297779f, 0.04329174f, 
    -0.00431131f, -0.04254842f, -0.01661285f, -0.03962900f, 0.03704906f, -0.00952442f, -0.00904902f, -0.00830321f, 
    0.04113763f, 0.03274748f, 0.02681969f, 0.04665886f, -0.00711104f, 0.00045735f, 0.04495037f, -0.00708220f, 
    -0.06141824f, -0.03654714f, 0.00163345f, 0.00760224f, -0.00991312f, 0.01780557f, -0.02267634f, 0.00661864f, 
    -0.01808008f, 0.00834025f, -0.06353736f, 0.01254705f, 0.02659175f, -0.05303646f, -0.05094370f, 0.04255250f, 
    -0.05792886f, -0.05095632f, -0.04629483f, 0.02387265f, 0.00839119f, -0.06232133f, -0.04845475f, -0.05228579f, 
    0.02826975f, -0.00847739f, -0.01459994f, -0.06256596f, 0.03498998f, 0.04164619f, 0.02521387f, 0.02766053f, 
    0.02119796f, 0.01731219f, -0.04192236f, -0.00924635f, 0.01109500f, -0.06187650f, -0.06109614f, 0.02353695f, 
    -0.01275092f, -0.05120604f, -0.04952092f, -0.01152727f, -0.03476924f, -0.00177205f, 0.00078954f, 0.03187123f, 
    0.34325454f, 0.22559430f, -0.01878275f, 0.19391364f, 0.22085041f, 0.13545008f, -0.04342143f, -0.16472514f, 
    -0.05087264f, 0.09467554f, 0.25757685f, 0.11287066f, 0.06624674f, -0.16015778f, -0.19121446f, 0.12954229f, 
    -0.05010038f, -0.00767534f, 0.06499636f, 0.10622994f, -0.25407907f, 0.21537720f, -0.04739141f, 0.23348916f, 
    -0.06425750f, 0.01186391f, 0.01724004f, -0.04127983f, -0.11313430f, 0.09340432f, -0.12686805f, 0.05523990f, 
    0.05718609f, 0.11359299f, 0.05686717f, -0.00046999f, -0.07865149f, 0.00749446f, -0.06765486f, 0.17784961f, 
    -0.33672565f, -0.04450597f, -0.05866499f, 0.14903659f, -0.12172685f, 0.08356820f, 0.11909524f, -0.12206865f, 
    0.07671602f, 0.05371927f, 0.07839825f, -0.12472364f, -0.06405362f, 0.04202018f, 0.02820890f, 0.05994069f, 
    0.05828763f, 0.05444650f, 0.11613126f, 0.10337126f, -0.30490136f, 0.09552052f, 0.02839581f, 0.13153903f, 
    0.11575470f, 0.13208856f, 0.07127781f, 0.02309850f, -0.18486692f, 0.00007187f, 0.02371265f, 0.09164541f, 
    0.05706763f, -0.04612600f, -0.11666762f, 0.05777697f, 0.11964467f, 0.11666571f, -0.00939672f, 0.01203002f, 
    -0.22578223f, 0.22389199f, 0.03228363f, -0.07311739f, 0.23774661f, 0.27656803f, -0.11712293f, 0.12688366f, 
    0.02845527f, -0.12587012f, -0.07148390f, 0.13100867f, 0.02946983f, -0.17093994f, 0.08408085f, -0.05716469f, 
    0.10554180f, 0.03306335f, 0.13253601f, 0.14788757f, 0.15983909f, -0.07621694f, -0.02056232f, 0.26091012f, 
    0.24225095f, -0.11418485f, -0.01113566f, -0.06311640f, 0.01217644f, 0.04407020f, -0.01354011f, -0.11158042f, 
    -0.10879501f, 0.04980750f, 0.14867988f, 0.04884801f, -0.07635832f, -0.03276897f, -0.00907343f, -0.04455873f, 
    -0.18905954f, 0.04409312f, -0.08763019f, 0.04641666f, -0.23597081f, 0.12957124f, 0.04123000f, 0.03724484f, 
    0.04617935f, 0.07033470f, 0.01033889f, 0.06914475f, -0.08577321f, -0.07140345f, 0.12141842f, 0.18077913f, 
    -0.03295937f, 0.15085123f, 0.12664337f, 0.00408269f, -0.22138594f, -0.22441678f, -0.09204347f, 0.11134713f, 
    -0.25573739f, 0.01526187f, 0.16920604f, -0.03033552f, 0.11843286f, 0.10036354f, -0.01904851f, -0.05643081f, 
    -0.02091695f, -0.06198722f, 0.07831316f, -0.06265888f, -0.00384840f, 0.01471505f, 0.08071314f, -0.03857850f, 
    0.10563619f, 0.23076873f, -0.07181254f, -0.01033183f, 0.09370707f, -0.14626980f, 0.06917082f, -0.06320542f, 
    -0.01776738f, 0.24048464f, 0.12416478f, 0.22682248f, 0.04989913f, -0.11174978f, -0.01070569f, 0.01884085f, 
    0.05951013f, 0.08396163f, 0.15622307f, 0.11264156f, -0.42258480f, 0.14668150f, 0.25064948f, -0.06476598f, 
    0.10029254f, 0.05387088f, 0.05183169f, 0.05833917f, -0.07028010f, -0.18255147f, -0.02651738f, -0.05130624f, 
    0.11120624f, 0.02051241f, -0.06995466f, -0.07445849f, 0.03199848f, -0.12232836f, 0.02446364f, 0.03575600f, 
    0.05034581f, -0.13058093f, -0.08644065f, 0.14532314f, -0.30699253f, 0.08344457f, -0.00833228f, -0.03450028f, 
    0.04686280f, -0.00726846f, -0.04889941f, 0.03081989f, -0.08697591f, -0.03203773f, -0.03662951f, -0.09788930f, 
    -0.00094691f, 0.14015363f, 0.06671304f, 0.04469166f, -0.24823742f, -0.06111545f, -0.00544675f, -0.07179686f, 
    0.26194561f, -0.03719714f, -0.02461912f, 0.15710552f, 0.02347508f, -0.10294008f, -0.07878100f, 0.07127445f, 
    0.09975569f, -0.03219380f, 0.04481017f, -0.02726531f, -0.10001805f, -0.08379681f, 0.01315991f, -0.00400908f, 
    -0.45719925f, -0.03605170f, 0.04865020f, 0.13315627f, -0.27972341f, 0.19728363f, 0.03447516f, 0.02618233f, 
    0.02956502f, 0.01468424f, 0.12782431f, 0.08965805f, 0.00412251f, -0.03035281f, -0.02219545f, 0.15611854f, 
    0.05891942f, -0.00545635f, 0.07293343f, 0.05517361f, -0.11981421f, 0.39292553f, -0.23794343f, 0.03815401f, 
    0.22704346f, -0.03305020f, -0.02587311f, -0.07926680f, 0.02745781f, 0.14411068f, 0.11395343f, -0.03556207f, 
    -0.00077214f, 0.00499829f, 0.03831889f, -0.16133271f, -0.13652743f, 0.12627110f, -0.01616175f, -0.02518965f, 
    -0.17298436f, -0.16247986f, 0.10468799f, 0.25631252f, -0.11551253f, 0.06427618f, -0.01024257f, 0.07625403f, 
    0.05880472f, 0.06058738f, -0.01200519f, 0.07281330f, -0.07847331f, 0.02333034f, 0.02141023f, -0.05856450f, 
    0.06864635f, 0.04793730f, -0.10946014f, 0.05248990f, -0.16251513f, -0.25143379f, -0.05338906f, -0.07881734f, 
    -0.39495260f, -0.02143176f, 0.06094207f, -0.04571557f, -0.06205335f, -0.02792265f, 0.03762234f, 0.06645958f, 
    0.08840214f, 0.05957930f, 0.08721404f, -0.03389643f, -0.10519657f, 0.04287555f, 0.08382117f, -0.01212911f, 
    -0.43674767f, -0.22431025f, -0.08427431f, -0.12038182f, -0.15442245f, 0.07185459f, 0.05736994f, -0.07111514f, 
    0.17218873f, 0.00722200f, 0.13076943f, -0.02400180f, 0.10829363f, -0.00659495f, 0.13442165f, 0.01883902f, 
    0.02945782f, -0.00121259f, 0.03132171f, -0.03725594f, 0.15203284f, 0.40100768f, -0.02609885f, -0.15339090f, 
    -0.01439321f, 0.05289028f, 0.13570099f, -0.17087007f, 0.03121055f, -0.00054708f, 0.22026603f, -0.00028643f, 
    -0.01375929f, -0.04943730f, -0.00266398f, 0.05061375f, 0.11011312f, 0.24111959f, 0.18676841f, 0.11767505f, 
    0.09262910f, 0.35642347f, -0.10720752f, 0.03337285f, 0.08786390f, 0.03955891f, 0.23048389f, -0.08495617f, 
    0.03426250f, -0.05716157f, 0.11160769f, 0.08699968f, -0.01053822f, 0.03925978f, -0.02351888f, 0.08052628f, 
    -0.11213174f, 0.14392705f, 0.00311084f, 0.03753770f, -0.71041995f, 0.31463858f, 0.00599343f, 0.08317862f, 
    0.04880956f, 0.07617664f, -0.11153855f, 0.05083939f, 0.17630841f, -0.02084880f, 0.03839037f, -0.02458090f, 
    0.19687311f, 0.01259476f, 0.08824980f, -0.08769200f, -0.03334390f, -0.20254938f, -0.02080959f, -0.07703802f, 
    0.17047034f, 0.23226991f, 0.11494619f, -0.26617786f, 0.01479398f, -0.03897336f, -0.07898138f, 0.01242288f, 
    0.00117664f, 0.09405806f, -0.01874409f, -0.07519707f, 0.17901452f, -0.00468602f, 0.08718263f, 0.10074878f, 
    -0.01603135f, -0.09956523f, 0.03448277f, -0.06965555f, -0.03608493f, -0.17878421f, -0.06557941f, -0.37238267f, 
    -0.26484722f, 0.07746919f, -0.08783675f, -0.14270355f, 0.01966750f, -0.06394908f, 0.07442470f, 0.24492823f, 
    -0.05463553f, -0.06245437f, -0.28010178f, 0.15264978f, -0.12780859f, 0.06233327f, 0.16974163f, 0.06503131f, 
    -0.02264042f, 0.00922699f, -0.11416727f, 0.06155690f, 0.19888385f, 0.01576754f, 0.08141657f, 0.04787434f, 
    0.08333081f, 0.01581291f, 0.01135586f, 0.04613150f, -0.00594178f, 0.06013619f, 0.05580794f, -0.13979584f, 
    -0.15772906f, -0.05390963f, -0.10643527f, -0.12227071f, -0.01913993f, 0.22999135f, -0.04198997f, -0.21581683f, 
    -0.07631389f, -0.05400015f, -0.11297082f, -0.20959608f, 0.01733698f, -0.06125949f, -0.10439923f, 0.04741025f, 
    0.16924876f, -0.04210592f, -0.06213157f, -0.16666541f, 0.11313721f, 0.02975296f, 0.07115005f, -0.06193031f, 
    0.05308419f, -0.26207671f, 0.36088341f, -0.13756233f, -0.03572648f, 0.01178587f, 0.02747107f, -0.10277529f, 
    -0.08751106f, -0.15742168f, -0.05629743f, -0.15783806f, -0.12266095f, 0.09491891f, 0.05010590f, 0.00824892f, 
    0.01620186f, 0.14566299f, -0.04797829f, -0.07313276f, 0.33278260f, 0.24070346f, 0.45803186f, -0.15202920f, 
    -0.01680809f, -0.06791008f, 0.03056896f, -0.06924455f, -0.21508972f, -0.10547531f, 0.06455259f, 0.03373598f, 
    -0.06117997f, -0.03609377f, 0.02273588f, -0.02254144f, -0.04699938f, 0.17643200f, -0.05333654f, 0.04565068f, 
    0.46889433f, -0.15004401f, 0.09150551f, 0.20048799f, 0.42777988f, -0.19505534f, -0.13919540f, -0.02506515f, 
    0.01027039f, 0.00872654f, 0.13821471f, -0.02768712f, -0.08712618f, 0.11974005f, -0.06972046f, 0.03544925f, 
    -0.10284389f, -0.01884052f, -0.10375017f, -0.05996114f, 0.01329041f, -0.07410526f, 0.44011301f, -0.07103973f, 
    0.15579802f, -0.14477177f, 0.00933929f, -0.09036047f, 0.07127097f, -0.07728255f, 0.02208244f, 0.02278641f, 
    0.00582742f, 0.16155142f, -0.02617779f, -0.06682929f, 0.02475150f, -0.06390975f, 0.03192110f, -0.04685197f, 
    0.07984705f, 0.11967060f, 0.02793289f, 0.31735563f, 0.05333999f, 0.09199701f, 0.18554527f, 0.02330112f, 
    0.11186677f, -0.02144738f, 0.00684547f, 0.12704715f, -0.09093652f, -0.07528822f, -0.05541188f, 0.15535326f, 
    -0.11696369f, 0.09024993f, -0.02528180f, -0.16367728f, -0.02991816f, -0.08350676f, -0.05261861f, -0.13494384f, 
    0.11064074f, -0.11373968f, 0.18866734f, 0.12087025f, -0.09654833f, -0.13670532f, -0.23555498f, 0.02506169f, 
    -0.08731537f, -0.02504637f, 0.02743758f, -0.00161144f, 0.10628531f, 0.11678131f, 0.04216257f, 0.07193202f, 
    0.77845424f, -0.28480995f, 0.28296366f, 0.04335592f, 0.19851622f, 0.14019158f, 0.05822933f, -0.01149018f, 
    -0.12891755f, 0.01337152f, -0.16191088f, -0.00342998f, -0.01469730f, -0.04599838f, 0.06874800f, 0.09102644f, 
    0.15179305f, -0.01047058f, 0.17587970f, -0.02534962f, 0.05052637f, 0.34751609f, 0.00642257f, 0.03261588f, 
    0.15421341f, -0.04249024f, -0.17161125f, -0.10455380f, 0.07768390f, 0.00562397f, 0.00943299f, -0.04862588f, 
    -0.04825240f, -0.03777475f, -0.03564991f, 0.00945170f, 0.06629554f, -0.12939139f, 0.05733726f, -0.05655636f, 
    -0.33606362f, -0.16678415f, -0.19441776f, -0.32520917f, -0.26040882f, -0.14680310f, 0.10945619f, -0.00778967f, 
    0.19381750f, -0.01650617f, 0.13702716f, 0.01286900f, -0.05535244f, -0.01129059f, 0.14300202f, -0.05304957f, 
    0.03634784f, -0.08526829f, -0.07014935f, 0.23864670f, -0.25462207f, -0.20102662f, -0.00014103f, -0.19047599f, 
    -0.04096324f, 0.18334918f, 0.02721635f, -0.06858318f, 0.11188183f, -0.04475985f, 0.03912143f, 0.01897094f, 
    0.04140072f, -0.13642347f, 0.00973718f, -0.00931039f, 0.01033154f, -0.02850577f, 0.07016420f, -0.14811026f, 
    0.08868957f, -0.06794224f, 0.24681973f, -0.11579527f, 0.15319000f, 0.04753167f, 0.05196237f, 0.07480014f, 
    -0.01830317f, 0.00402307f, -0.03649491f, -0.02298926f, 0.07963078f, 0.00813938f, -0.01631202f, 0.08706989f, 
    -0.01009728f, 0.03164043f, 0.06562451f, 0.00524368f, 0.12572256f, -0.04407620f, 0.04158382f, -0.09022216f, 
    -0.15558349f, 0.04251964f, -0.03338872f, 0.03201827f, -0.03413915f, -0.12659805f, -0.02385976f, 0.12868465f, 
    0.07546175f, 0.05048695f, 0.04640714f, 0.02823654f, -0.03043659f, 0.12460939f, 0.03522050f, 0.02209631f, 
    -0.05613544f, 0.24172994f, -0.06820978f, 0.09778731f, -0.18640701f, -0.00732874f, -0.02461662f, -0.05619360f, 
    0.02724697f, 0.26100343f, 0.11141401f, -0.02884458f, 0.04097328f, 0.13238493f, -0.00545155f, 0.00671301f, 
    -0.02334095f, 0.05735338f, -0.14163449f, -0.22122720f, 0.03932822f, -0.31480980f, -0.10059135f, -0.60844642f, 
    -0.23208928f, -0.07900774f, 0.07395981f, -0.08498167f, 0.03304915f, 0.04664114f, 0.00859361f, -0.01902516f, 
    0.14094986f, -0.14148372f, 0.03264049f, -0.06859400f, 0.08142478f, -0.12467599f, -0.17215382f, 0.04025565f, 
    0.04677530f, 0.07777829f, 0.17920510f, 0.08933286f, 0.03937396f, 0.04336279f, 0.02404924f, 0.01023958f, 
    -0.06519910f, 0.03230058f, 0.07825079f, -0.07461665f, 0.03601466f, 0.09254789f, -0.04249343f, -0.01114176f, 
    -0.07675938f, -0.03457749f, 0.02147605f, 0.12605484f, 0.14770100f, 0.03747187f, -0.01986619f, -0.26972577f, 
    0.11934354f, 0.08699426f, -0.11705153f, -0.13286924f, -0.08449052f, -0.05034679f, 0.01583793f, -0.00929162f, 
    0.01078019f, 0.06886440f, 0.01758178f, -0.06856184f, -0.12712137f, -0.01902571f, -0.12198450f, 0.04135399f, 
    0.11384054f, -0.25584352f, 0.22531031f, 0.05636464f, -0.13247195f, 0.15796188f, -0.12298828f, -0.02976434f, 
    -0.01412185f, 0.02759841f, 0.09990295f, -0.15441467f, 0.12126674f, 0.01301881f, 0.04524882f, -0.01736207f, 
    -0.14030217f, -0.17822602f, -0.09280895f, -0.03344276f, 0.48601970f, -0.10713735f, 0.04409880f, 0.12326234f, 
    -0.15653825f, -0.06172005f, 0.03067453f, -0.05123600f, 0.09829813f, 0.19504808f, 0.01480549f, 0.01599655f, 
    -0.01534694f, -0.09400308f, -0.10028947f, 0.08118385f, -0.08639196f, -0.01059010f, -0.05415311f, -0.17490283f, 
    -0.03973732f, 0.21870957f, 0.08912588f, -0.01547951f, 0.44483247f, 0.05249401f, 0.20253730f, -0.09644213f, 
    -0.02460485f, -0.01805536f, -0.01636937f, 0.11373597f, -0.08579739f, 0.16872305f, -0.04033952f, 0.20370844f, 
    -0.00031409f, -0.08191632f, 0.03328963f, 0.05084873f, 0.29285753f, 0.21225913f, 0.36176509f, 0.37945580f, 
    0.10852471f, -0.05549870f, -0.14565244f, -0.09085243f, 0.00862991f, 0.14389953f, 0.10653406f, -0.07928109f, 
    -0.01937607f, -0.10967949f, -0.04467722f, -0.02174656f, -0.11216177f, -0.04266801f, -0.09818151f, 0.02255216f, 
    0.14171501f, -0.14198773f, 0.09794948f, 0.05406016f, 0.10640229f, 0.09976564f, -0.00471336f, 0.02961712f, 
    0.05834110f, -0.06614204f, 0.04834111f, -0.04728355f, -0.07926620f, -0.11831350f, 0.06822991f, -0.11684375f, 
    0.11051839f, 0.09367370f, 0.07379614f, -0.10219259f, -0.17085455f, -0.02145463f, 0.11205495f, -0.00407321f, 
    -0.41206253f, 0.13728261f, 0.01795902f, 0.00759286f, -0.07163153f, 0.08033828f, 0.10864849f, 0.14686458f, 
    0.02685373f, 0.00660534f, 0.14966160f, 0.04470506f, 0.08220300f, 0.04211055f, 0.01088838f, 0.04662889f, 
    0.32634240f, 0.04817056f, 0.02367252f, -0.06098733f, 0.21997590f, -0.18310474f, -0.00375825f, -0.04194327f, 
    0.05738679f, -0.00490068f, -0.00116678f, 0.11989064f, 0.05444898f, 0.10256576f, 0.11416637f, 0.07418268f, 
    0.08441899f, -0.15722194f, -0.14858691f, -0.06107358f, 0.37669307f, -0.19895373f, 0.09201348f, -0.03625835f, 
    0.27626404f, 0.15306073f, 0.00923149f, -0.06644522f, -0.09058812f, 0.09965875f, -0.06731848f, -0.02442924f, 
    -0.17717135f, -0.15163277f, -0.08656654f, 0.05052488f, -0.01006845f, 0.04478087f, 0.03709237f, -0.05140465f, 
    -0.04073562f, -0.03127064f, -0.01532786f, -0.04532650f, -0.04700724f, -0.00320795f, -0.03662878f, -0.00820706f, 
    -0.01004478f, 0.02981219f, 0.03780965f, 0.00465874f, -0.00207530f, -0.04034258f, -0.03161998f, -0.01412160f, 
    0.04042477f, -0.03214472f, -0.00838162f, 0.00298732f, 0.01406539f, 0.02676725f, -0.05295475f, 0.01047239f, 
    0.03299803f, 0.03474156f, -0.01846995f, 0.02596831f, -0.00588992f, -0.05432987f, -0.00346549f, 0.00855462f, 
    -0.02587635f, 0.03792675f, -0.02300572f, -0.03484416f, -0.03660158f, 0.03033677f, -0.04721574f, -0.04263639f, 
    -0.00027009f, -0.04513180f, 0.04275264f, -0.00471744f, -0.05977223f, 0.04099562f, -0.00455213f, -0.03483946f, 
    -0.05656485f, 0.02774232f, -0.06185482f, 0.02425424f, 0.04205294f, -0.05805484f, -0.01401979f, -0.01476328f, 
    -0.01061739f, -0.00851119f, -0.02599787f, -0.03922729f, -0.04652486f, -0.03137128f, -0.01401808f, -0.02780599f, 
    -0.00929922f, -0.04110945f, 0.02713589f, 0.01034366f, -0.00753657f, -0.01323932f, -0.03778279f, 0.04636422f, 
    -0.03485681f, -0.05102871f, -0.01276837f, -0.02771005f, 0.03603685f, -0.03986570f, 0.02147852f, 0.00901307f, 
    0.02249822f, 0.01875646f, 0.04338178f, -0.00712990f, -0.00873962f, -0.03562625f, -0.05589911f, -0.01121224f, 
    -0.05511274f, -0.00545483f, -0.01783721f, -0.00305012f, 0.03187142f, -0.00423036f, 0.02867926f, 0.04038376f, 
    0.01147580f, 0.01169008f, 0.03699652f, -0.01157961f, -0.00946340f, 0.04039090f, -0.03586362f, 0.04501878f, 
    0.04550152f, 0.03845510f, 0.04732151f, 0.02656555f, -0.05236861f, -0.04839944f, -0.03666335f, 0.03095111f, 
    -0.05753552f, 0.01997832f, 0.03630238f, -0.03406677f, 0.02781153f, 0.02055999f, -0.03053883f, -0.03141130f, 
    -0.00061497f, 0.00240144f, -0.05504916f, -0.04014014f, -0.01522350f, 0.02571605f, -0.02281255f, -0.01208774f, 
    0.03509442f, 0.01259103f, -0.03208533f, 0.04844901f, 0.04593087f, -0.03189303f, 0.01816204f, 0.02875681f, 
    -0.05652035f, -0.04059663f, 0.04293679f, 0.03414463f, -0.00510149f, -0.05643925f, -0.05614277f, -0.05268739f, 
    -0.01164239f, -0.00918230f, 0.04444259f, 0.01780540f, 0.01195038f, -0.04016148f, -0.04166013f, -0.06096867f, 
    0.02726109f, 0.04149866f, -0.03381624f, -0.05441691f, 0.05020684f, 0.01151862f, 0.01993451f, 0.00897342f, 
    0.00439522f, -0.03798819f, -0.00638251f, 0.02847400f, -0.01180385f, -0.03912516f, -0.04262729f, -0.05699787f, 
    -0.05537504f, -0.04644567f, 0.03927395f, 0.02792807f, 0.03816078f, 0.01507019f, -0.00941375f, -0.04413368f, 
    0.02463795f, -0.02918638f, -0.01291246f, -0.00558442f, 0.02900972f, -0.05857671f, 0.04614942f, -0.03921350f, 
    0.00094783f, -0.01036384f, -0.01026280f, 0.04371704f, -0.06015201f, -0.05990075f, 0.03938752f, -0.00745919f, 
    0.00900215f, -0.02157406f, -0.05386682f, -0.04259269f, 0.01216098f, 0.00010997f, -0.00579298f, -0.02672182f, 
    0.01822843f, 0.03361133f, 0.02079461f, 0.01074496f, -0.04603939f, -0.04809833f, -0.05678862f, 0.03428822f, 
    0.03746348f, 0.03486582f, -0.00441277f, -0.00988855f, 0.00975967f, 0.04252739f, -0.02520042f, -0.05470418f, 
    -0.00027367f, 0.00472221f, 0.00693003f, -0.02990495f, -0.03847506f, -0.05386290f, -0.05417928f, 0.04250382f, 
    -0.01579693f, -0.01041621f, -0.01666190f, -0.00735868f, -0.05917178f, 0.00178383f, 0.01071880f, -0.06179415f, 
    0.00765860f, -0.00867063f, 0.00953898f, 0.03638770f, 0.02335932f, -0.05398723f, -0.00511494f, -0.03152949f, 
    0.00761290f, 0.00658463f, 0.01185252f, 0.04583531f, 0.01331300f, 0.01731257f, -0.06140483f, 0.02320747f, 
    0.04505583f, -0.06334507f, 0.03218594f, 0.02289167f, 0.04454434f, -0.05268187f, -0.01043255f, -0.00495714f, 
    -0.03029636f, 0.02432966f, 0.04861244f, 0.00283826f, -0.03685028f, -0.03697946f, 0.04508983f, -0.04910723f, 
    -0.02169404f, -0.00053583f, 0.01037436f, -0.03362679f, 0.02536070f, -0.04817884f, -0.03196643f, 0.04160769f, 
    -0.03526793f, -0.05263515f, 0.01089560f, 0.00847688f, 0.02201563f, 0.03048962f, 0.01820022f, 0.01565502f, 
    -0.03346178f, 0.01193260f, -0.03414359f, -0.05283773f, -0.00295186f, 0.01586894f, 0.03552517f, -0.05259643f, 
    0.00569083f, 0.04814957f, 0.03681491f, 0.04688708f, 0.01038413f, -0.02982985f, -0.05154747f, -0.02345810f, 
    -0.05358507f, 0.00408371f, 0.01535256f, -0.05253789f, 0.01089100f, 0.03666127f, -0.05337048f, 0.01127041f, 
    0.02434484f, 0.02224870f, -0.03551926f, -0.00809170f, -0.01568501f, 0.03961134f, -0.03482661f, 0.01756726f, 
    0.00188954f, -0.05886016f, -0.06045964f, -0.01026847f, -0.01859328f, 0.00911694f, -0.00849779f, -0.05897563f, 
    0.11222356f, -0.10267308f, 0.33596960f, 0.37241414f, -0.04962363f, 0.08779190f, 0.12524569f, -0.02638857f, 
    0.02750260f, 0.08278004f, 0.18604171f, 0.08679342f, 0.03496609f, 0.11951020f, -0.04121990f, 0.07498872f, 
    -0.01561677f, 0.03153533f, 0.06622198f, 0.07964810f, -0.06002322f, -0.13466389f, 0.12183060f, 0.24612632f, 
    0.07558712f, -0.26880854f, -0.06321087f, -0.04743022f, -0.00518128f, 0.11930078f, 0.09310363f, -0.05919990f, 
    0.06700307f, -0.04031112f, 0.10851294f, 0.11351666f, 0.06834982f, -0.00274629f, 0.03034084f, 0.10954148f, 
    -0.20831960f, 0.05005147f, -0.18155110f, 0.15498479f, 0.24360853f, -0.05503299f, 0.10697906f, -0.07347098f, 
    0.05708788f, 0.02056493f, 0.03135981f, -0.16211534f, -0.13442786f, 0.04124289f, 0.02472450f, 0.13091052f, 
    0.17490554f, 0.00589161f, 0.10900066f, -0.00037531f, -0.16279358f, 0.18351987f, -0.18118288f, -0.07529138f, 
    0.10645418f, -0.00582206f, -0.10841036f, -0.04017707f, -0.11449791f, 0.02233244f, 0.02232239f, -0.09111343f, 
    0.08755919f, 0.04359462f, -0.00691067f, 0.03449331f, 0.02598243f, -0.05121697f, -0.05651078f, -0.20595314f, 
    -0.78536171f, 0.40593219f, -0.07067100f, 0.01498572f, -0.20777451f, 0.16510445f, 0.06427027f, -0.07410709f, 
    0.11293726f, 0.02318917f, -0.11647618f, 0.05142059f, -0.10988600f, -0.02507346f, 0.17294559f, -0.08521067f, 
    0.05978122f, 0.17975223f, 0.14945449f, 0.08554226f, -0.05667969f, 0.01757541f, 0.22092459f, 0.39069656f, 
    0.15878212f, -0.04013779f, 0.08422139f, 0.06010874f, 0.01410947f, 0.08538337f, 0.01690105f, 0.06302182f, 
    0.01340892f, 0.04281880f, 0.13403474f, -0.07953805f, -0.05996335f, 0.13116063f, 0.06046145f, -0.13281991f, 
    -0.06842132f, 0.29216251f, -0.16455534f, -0.03424288f, 0.00702674f, 0.02920200f, 0.05938866f, -0.03463513f, 
    -0.03706112f, -0.06613230f, -0.12139726f, -0.01776223f, -0.06797788f, -0.05250717f, 0.08921798f, 0.12433479f, 
    0.18747383f, 0.14495954f, 0.11809821f, -0.08813567f, 0.26838276f, -0.29343086f, 0.00492053f, 0.05981940f, 
    -0.02939245f, 0.06652401f, 0.05355194f, -0.10896873f, -0.02550006f, -0.11946099f, 0.05614373f, -0.03916894f, 
    -0.11785343f, -0.04506757f, 0.02272097f, -0.05648882f, 0.06444958f, -0.03563340f, 0.13341376f, 0.09443716f, 
    -0.20122942f, -0.15513895f, -0.16000465f, -0.05090977f, -0.12945220f, -0.01393069f, 0.11769188f, 0.01057294f, 
    0.17417532f, 0.19306737f, 0.10489253f, 0.13779685f, 0.01708321f, -0.05040346f, 0.07492620f, 0.04247922f, 
    -0.00540141f, 0.17529897f, 0.07925984f, 0.09192402f, -0.55035436f, 0.31064263f, 0.07703913f, -0.10803083f, 
    -0.14172433f, 0.08253529f, -0.01729947f, 0.09540422f, 0.02692883f, -0.14396302f, 0.12510654f, 0.07119215f, 
    -0.02763855f, 0.05723544f, 0.08055038f, -0.14816821f, 0.07851075f, 0.03988282f, -0.02219260f, 0.08982600f, 
    -0.09046811f, 0.06349102f, 0.19174005f, 0.17450233f, -0.11750867f, 0.01530589f, -0.29486105f, 0.05774956f, 
    0.03285329f, -0.01789192f, 0.07014890f, 0.06744450f, 0.00461246f, -0.04281696f, -0.09814596f, -0.08730952f, 
    0.15961260f, 0.02463111f, 0.10096406f, 0.01442107f, -0.53966868f, 0.32751492f, -0.14432295f, -0.09182796f, 
    0.04879663f, 0.12907989f, -0.01476745f, 0.23328425f, 0.05493583f, -0.10513462f, -0.06681263f, 0.07906290f, 
    0.00087221f, -0.05722064f, 0.10280164f, 0.15375468f, 0.00559713f, 0.09326973f, 0.17687008f, 0.00442822f, 
    0.02967091f, 0.00796487f, -0.04951493f, 0.19188026f, 0.15164202f, -0.03840821f, -0.02958130f, 0.02621127f, 
    -0.00458423f, -0.01418130f, 0.23924173f, 0.08576898f, 0.01925403f, 0.02100756f, -0.02947025f, -0.01211849f, 
    0.08420674f, -0.09708868f, 0.10725050f, 0.09071006f, -0.07203270f, 0.38800135f, -0.21069203f, 0.26815060f, 
    -0.16966991f, -0.10684705f, -0.02902786f, 0.10710359f, 0.07713363f, -0.11333279f, 0.09882887f, -0.00324948f, 
    0.15916775f, 0.17426001f, 0.00616334f, -0.01049775f, -0.11722371f, 0.02621124f, 0.01506097f, 0.11142974f, 
    0.03188036f, 0.27496198f, 0.28286636f, 0.11392109f, 0.12451145f, -0.07742234f, -0.02102367f, 0.08360799f, 
    -0.02982095f, -0.01167335f, 0.11546021f, -0.02733446f, -0.10147518f, 0.02352905f, 0.03593428f, 0.05197571f, 
    0.09597904f, -0.06548714f, 0.36191797f, -0.08935590f, -0.10325362f, -0.23822302f, 0.05295697f, 0.04465637f, 
    0.20069185f, -0.11203630f, 0.03676281f, -0.12825766f, -0.00237297f, -0.10899330f, 0.01965676f, 0.11841489f, 
    0.13327278f, -0.00088129f, 0.08098195f, 0.10041760f, 0.06242057f, 0.03938912f, 0.10852332f, 0.00861848f, 
    -0.39167780f, 0.13557395f, -0.28270757f, -0.26537955f, -0.18922502f, -0.01194535f, -0.03480372f, -0.00728518f, 
    0.06986775f, 0.00885854f, 0.15249021f, 0.05912685f, -0.01392508f, -0.07321083f, 0.01504207f, 0.01793302f, 
    0.02512855f, 0.28763261f, 0.11065680f, 0.04727340f, 0.02721026f, 0.38451621f, -0.10015514f, 0.05554051f, 
    -0.29147479f, 0.32341233f, 0.24515529f, 0.12086602f, -0.08691275f, 0.02311524f, 0.15002480f, 0.07566752f, 
    0.02082291f, -0.03211567f, -0.03686596f, -0.04024484f, 0.09445575f, 0.27715310f, -0.11297671f, 0.07394651f, 
    0.43427998f, 0.16165799f, 0.04062606f, 0.10167474f, -0.16974080f, 0.17814241f, 0.14707203f, 0.13037015f, 
    -0.08540707f, 0.10144687f, 0.06151540f, 0.09332209f, 0.10990264f, -0.08783392f, -0.05299474f, 0.04005601f, 
    -0.11882636f, 0.10299993f, -0.19902585f, 0.09115302f, -0.42305428f, 0.20345728f, 0.08916269f, 0.41572344f, 
    -0.25581428f, 0.13976695f, -0.01564443f, 0.21564357f, 0.14063518f, 0.13479471f, 0.05405227f, -0.00378559f, 
    0.09706371f, 0.07038824f, -0.05683838f, -0.10065450f, 0.10849036f, -0.17707247f, 0.12598081f, 0.13822247f, 
    0.50799227f, 0.03282701f, -0.20503888f, 0.14811151f, 0.07302961f, 0.09300612f, -0.16694586f, 0.23575951f, 
    0.11360139f, 0.15968767f, -0.05047016f, -0.05483862f, 0.21977298f, 0.08254801f, 0.16612250f, 0.09485522f, 
    0.06499273f, -0.12341006f, 0.09632398f, 0.02963993f, 0.18376443f, 0.27092171f, 0.08192661f, -0.38702554f, 
    -0.17059246f, 0.09004096f, 0.20504905f, -0.03411033f, -0.05491431f, -0.10875004f, 0.04233018f, -0.00544559f, 
    -0.08960518f, -0.17793731f, -0.15773346f, 0.25535876f, 0.03839843f, 0.05304123f, 0.22551198f, 0.02612937f, 
    0.02568697f, -0.12330993f, 0.04688848f, 0.16816193f, 0.08413913f, 0.23709369f, 0.00019056f, 0.10452090f, 
    0.24111609f, 0.16223043f, 0.09405375f, 0.02022153f, 0.23000929f, 0.01988159f, -0.02584193f, 0.00786669f, 
    -0.15494266f, -0.27159974f, -0.21214755f, -0.03630949f, -0.19835308f, 0.39833146f, -0.07152551f, 0.11872765f, 
    0.02862269f, 0.11512385f, 0.08266895f, 0.11271687f, 0.14197339f, -0.00362146f, -0.15399456f, 0.07819327f, 
    -0.02451928f, -0.17802319f, -0.08314880f, 0.06654219f, 0.05869041f, -0.15186855f, -0.09471386f, -0.22573872f, 
    0.02355160f, -0.25789660f, 0.05933285f, -0.29705632f, 0.08472873f, -0.20144266f, -0.12375256f, -0.22305924f, 
    0.00038323f, -0.01691736f, -0.04425282f, -0.01576805f, -0.12700669f, 0.13856860f, -0.00708142f, -0.14753452f, 
    -0.06622849f, 0.15922768f, 0.12618019f, 0.13841747f, 0.47226086f, -0.37839779f, 0.04490414f, -0.17690757f, 
    0.29990262f, -0.14861649f, 0.02140574f, -0.14733419f, -0.13700503f, -0.12530154f, 0.00652517f, -0.14866889f, 
    0.05398904f, -0.01375583f, 0.01257392f, 0.07190357f, -0.08092844f, 0.10603615f, 0.04911097f, 0.10661598f, 
    0.54659086f, -0.24292071f, -0.37317643f, 0.12389397f, 0.19975987f, -0.10024187f, 0.09109537f, -0.05454247f, 
    0.20009379f, -0.02005518f, 0.05690853f, -0.01647444f, 0.03344100f, 0.08457165f, 0.08083686f, 0.10274291f, 
    0.01173148f, -0.23639198f, -0.04789497f, -0.15322621f, 0.03119916f, -0.46942073f, 0.19083618f, 0.11191782f, 
    0.40874609f, -0.13131239f, -0.12701656f, -0.11844635f, 0.05257651f, 0.10842634f, 0.02571472f, -0.11217391f, 
    -0.03142712f, 0.08603534f, -0.06330027f, -0.14385869f, -0.09923224f, -0.21171153f, -0.08686082f, -0.10308170f, 
    0.16216408f, -0.11752265f, 0.04501111f, 0.13424323f, -0.38129762f, 0.27939656f, 0.16365837f, 0.09386062f, 
    0.07943016f, 0.07529011f, -0.11351384f, -0.02034085f, 0.00082132f, -0.01640831f, 0.03891349f, 0.18542169f, 
    -0.15161195f, 0.10698178f, -0.14282449f, -0.09417149f, -0.25682402f, 0.11503995f, -0.08769930f, -0.31713405f, 
    -0.05705702f, 0.19226255f, -0.05021470f, -0.02836282f, -0.05317206f, -0.01404807f, -0.01635123f, -0.04652724f, 
    -0.23611917f, -0.01926465f, 0.01915252f, 0.01398807f, 0.09434129f, 0.24273090f, -0.07358302f, 0.16749759f, 
    0.46936452f, -0.29657784f, -0.38602543f, 0.02541841f, -0.14812262f, 0.06181249f, -0.09890333f, -0.02031039f, 
    0.05519009f, 0.06678554f, -0.23565757f, -0.06906781f, 0.10312799f, -0.02410513f, 0.06481582f, 0.06219440f, 
    0.11595872f, -0.08872505f, 0.02415474f, 0.07582349f, -0.12885919f, 0.27989516f, 0.08190972f, 0.20808530f, 
    -0.09616393f, 0.19633085f, 0.13466083f, 0.11638819f, 0.07981101f, 0.03438139f, -0.00127124f, -0.00865860f, 
    -0.02146992f, -0.09107231f, 0.02487884f, -0.00979371f, -0.03337464f, -0.25075534f, -0.11768600f, -0.02958947f, 
    0.15258969f, 0.13852380f, 0.06946348f, 0.10403076f, -0.08822716f, -0.06918032f, 0.09730463f, 0.10448650f, 
    -0.10991091f, -0.03111378f, 0.16870356f, 0.00646304f, -0.05098578f, -0.12849414f, -0.02369260f, -0.01531354f, 
    0.07569102f, 0.07099231f, 0.11574151f, 0.07177499f, 0.09739846f, -0.19903812f, -0.17265645f, 0.18011332f, 
    -0.19404262f, -0.18231013f, 0.01882195f, 0.01425373f, -0.07347929f, 0.11640608f, 0.06173773f, 0.13279225f, 
    -0.07082543f, -0.11586596f, 0.15140630f, -0.03095023f, -0.00190948f, 0.07062603f, 0.02758890f, 0.17091186f, 
    0.04598950f, -0.00538188f, -0.14284524f, 0.02084930f, -0.13899769f, -0.03800061f, -0.01658404f, -0.08944294f, 
    0.05260701f, 0.08482977f, 0.01558707f, -0.07977814f, -0.02919466f, 0.00328673f, 0.06455794f, -0.01646040f, 
    0.01189597f, -0.03258041f, -0.09535570f, -0.02550120f, 0.58731019f, -0.08208322f, -0.45483458f, -0.25700995f, 
    -0.25405896f, 0.03021469f, -0.02400099f, 0.00729060f, -0.15318888f, -0.01066425f, 0.00512035f, 0.01561427f, 
    -0.01799312f, -0.08738843f, -0.03105005f, 0.05161861f, -0.17521182f, -0.12052817f, 0.08207113f, 0.03550509f, 
    -0.40802723f, 0.19182996f, 0.32561401f, -0.08984254f, 0.13686576f, 0.09376925f, -0.14737976f, 0.09329623f, 
    0.09912577f, 0.19928934f, -0.05843741f, -0.01095202f, 0.11382292f, -0.02597511f, 0.09719507f, 0.03539371f, 
    0.13204673f, 0.06718312f, 0.14922705f, -0.14675654f, -0.28247392f, -0.25035122f, 0.03202865f, 0.30106288f, 
    -0.06808913f, 0.05364840f, 0.04889543f, -0.04080423f, -0.10695039f, -0.09145825f, 0.06459185f, 0.09190256f, 
    -0.04830853f, 0.03850914f, -0.14571390f, 0.03837355f, -0.18640976f, 0.14542888f, 0.00876282f, 0.03585577f, 
    -0.19944993f, -0.16305269f, -0.21712957f, 0.09221274f, -0.13897784f, -0.16125779f, 0.11066117f, -0.03874262f, 
    0.05468715f, 0.06197179f, 0.04570360f, -0.04162670f, 0.21183118f, 0.10620185f, 0.00522738f, 0.04043071f, 
    -0.02289140f, -0.12192763f, -0.06657305f, -0.00992493f, 0.11294150f, -0.16379066f, -0.08451344f, 0.06903238f, 
    0.30323887f, 0.00497467f, 0.06513949f, -0.22633666f, -0.03334041f, 0.00945152f, 0.07511634f, 0.23298937f, 
    0.03504289f, -0.05211664f, -0.04213893f, -0.32981014f, 0.09555364f, -0.12478008f, 0.11514033f, -0.16338861f, 
    0.03321354f, 0.18430272f, 0.09304556f, -0.04129853f, 0.06912593f, -0.01867507f, -0.20888662f, 0.01702915f, 
    0.09704126f, -0.03050745f, 0.02857564f, -0.00082265f, -0.07841684f, -0.04198471f, -0.00121925f, 0.06654768f, 
    -0.03416621f, 0.10228483f, 0.09502136f, 0.11028435f, -0.18139017f, 0.18986776f, 0.26230979f, 0.00757101f, 
    0.07549839f, 0.07501923f, 0.03468074f, -0.10959425f, -0.03247761f, -0.04335884f, -0.01864496f, -0.02580536f, 
    0.00428575f, 0.10897606f, -0.00735942f, 0.09943024f, -0.07748607f, 0.07412940f, 0.19457355f, -0.06823505f, 
    0.57240725f, 0.29133588f, -0.27583474f, -0.05655228f, 0.22395952f, -0.02440580f, 0.09771685f, 0.11055742f, 
    0.16099823f, -0.02924113f, -0.00868373f, 0.01984468f, -0.01855873f, 0.05839311f, -0.01018787f, 0.01705658f, 
    -0.01832321f, -0.14827040f, -0.01417768f, 0.01206542f, -0.39197418f, -0.12779975f, 0.13265471f, 0.17135449f, 
    0.36112741f, 0.07865017f, -0.10947273f, 0.02138763f, -0.10523549f, 0.14030594f, -0.03455177f, 0.05644239f, 
    0.07057467f, 0.07746118f, 0.07768156f, -0.01335266f, 0.00825531f, 0.04202890f, 0.10500894f, -0.02921266f, 
    0.04446297f, 0.07538243f, -0.19247010f, 0.20326830f, -0.16656655f, 0.13348378f, -0.08009806f, 0.04503371f, 
    0.04415215f, 0.08037838f, -0.17481366f, -0.05807301f, 0.06350375f, -0.02718977f, 0.04277521f, -0.01518393f, 
    0.16037115f, -0.09109238f, 0.00091850f, -0.02578834f, 0.15372792f, 0.53886819f, -0.19407041f, 0.03089228f, 
    -0.43599790f, -0.09730776f, -0.01798145f, -0.00816123f, -0.03814860f, -0.17541245f, 0.07598019f, -0.05824308f, 
    -0.03211149f, 0.01624100f, -0.13249436f, -0.01446583f, 0.06924997f, 0.15583107f, 0.05359111f, 0.00699260f, 
    -0.28823924f, 0.25185758f, 0.12255706f, 0.09261423f, -0.09461360f, 0.09103239f, -0.16622111f, 0.15201767f, 
    -0.07736905f, -0.07540701f, 0.00317505f, -0.10648226f, -0.13781449f, 0.13853931f, -0.01703383f, -0.01206391f, 
    0.06491239f, -0.09049700f, 0.05419266f, -0.13786711f, 0.12614384f, -0.11861020f, 0.10450511f, 0.16703452f, 
    0.09894416f, 0.02158794f, -0.14378375f, 0.09774673f, 0.05643245f, -0.00118364f, 0.19422649f, -0.00992441f, 
    0.06049325f, -0.17562009f, -0.00686758f, 0.06608646f, 0.09071497f, -0.06057493f, -0.01521744f, -0.03586099f, 
    0.13639486f, -0.06451114f, 0.23936564f, 0.32694104f, 0.00147704f, -0.03158575f, 0.19987418f, 0.07296664f, 
    0.16855542f, -0.03848042f, -0.17409644f, -0.01635730f, -0.15491554f, 0.04824644f, 0.05330398f, 0.05540076f, 
    0.09621278f, -0.03867134f, 0.12861036f, 0.09690112f, 0.24337961f, -0.35692167f, 0.08846743f, 0.01616866f, 
    0.31369200f, -0.00785620f, -0.00786444f, -0.01092390f, 0.09729208f, -0.00548654f, 0.11131588f, 0.09762437f, 
    -0.04014519f, 0.01447527f, -0.03938068f, 0.01315618f, 0.07934830f, 0.02510336f, -0.03933433f, 0.00093603f, 
    -0.04131850f, -0.18899165f, -0.07657050f, -0.12759574f, 0.13958700f, -0.07984336f, -0.10262452f, 0.03039723f, 
    0.16467835f, -0.06223570f, 0.13265800f, 0.10911238f, 0.05812693f, 0.01802009f, -0.03317051f, -0.03100711f, 
    0.00188726f, 0.10408613f, -0.09998664f, -0.04635916f, 0.18279843f, -0.37438717f, -0.10518835f, -0.21917953f, 
    0.07391947f, -0.03871122f, 0.07250244f, 0.09718953f, 0.12862967f, -0.11441576f, -0.06388798f, 0.00530204f, 
    0.00036020f, 0.04531994f, 0.12077430f, -0.09802889f, 0.00285518f, -0.00191579f, -0.08981419f, -0.00048814f, 
    0.16260837f, -0.18039137f, 0.15594326f, 0.19726808f, -0.06234935f, -0.30951035f, 0.00667029f, -0.08355497f, 
    0.01147784f, 0.05775463f, -0.10150100f, 0.01968913f, 0.13790058f, -0.01211763f, 0.00596338f, 0.03239274f, 
    0.08286145f, -0.01981323f, -0.02044387f, 0.09510002f, -0.15699972f, 0.05940905f, 0.10123759f, 0.41718453f, 
    -0.11545613f, 0.17131965f, 0.07179475f, -0.08213857f, 0.02426500f, 0.11951123f, 0.00254134f, 0.12748238f, 
    0.03844569f, -0.15771931f, -0.17768757f, 0.00018048f, -0.07873596f, -0.02957261f, 0.08557386f, 0.04582057f, 
    -0.16639869f, -0.42709318f, 0.04954440f, -0.15580362f, 0.11568858f, -0.10957857f, 0.13675407f, 0.10867044f, 
    0.08383009f, 0.00170479f, 0.04823964f, 0.06012685f, -0.04619208f, 0.14852555f, 0.00387151f, -0.09171928f, 
    0.02208858f, 0.01218164f, -0.09439103f, 0.06453028f, -0.00042719f, -0.25197181f, 0.00772761f, -0.20655985f, 
    0.15519907f, -0.02313519f, -0.19968875f, -0.12514068f, -0.00444421f, 0.01505410f, 0.06657496f, 0.11966337f, 
    0.04077305f, 0.06681153f, 0.08866012f, -0.03266387f, 0.08510037f, -0.14173450f, 0.00720633f, 0.03078697f, 
    0.34100029f, -0.05549617f, -0.02023076f, 0.27486837f, 0.10230508f, 0.05345872f, -0.11055586f, 0.12580590f, 
    0.08254822f, -0.20001535f, -0.06368592f, -0.22279829f, -0.08354224f, 0.10291030f, 0.00453511f, 0.13881983f, 
    -0.06043504f, 0.10431851f, -0.11858084f, -0.02685136f, 0.55038846f, 0.38631546f, -0.13096328f, 0.09265332f, 
    -0.34899530f, 0.03567410f, -0.13980882f, 0.07913329f, 0.13622221f, 0.08184952f, -0.07715112f, 0.12589799f, 
    -0.06825717f, 0.01230636f, 0.06824587f, 0.03747230f, 0.06351774f, 0.32827482f, 0.06939179f, 0.08130350f, 
    -0.05853746f, 0.17332663f, -0.03498734f, -0.23878764f, 0.44501758f, -0.01543392f, 0.10883711f, 0.07984886f, 
    -0.05262078f, 0.07959678f, -0.03725667f, 0.03060027f, 0.08170651f, 0.01902363f, -0.02106080f, 0.06382934f, 
    -0.07370859f, -0.10452414f, -0.00545959f, 0.06193624f, 0.36800572f, 0.14270778f, 0.07991954f, -0.02161541f, 
    -0.50326437f, -0.02497633f, -0.03293352f, -0.02400481f, 0.08325227f, -0.01982835f, -0.01684414f, 0.03900411f, 
    0.13995497f, 0.17027880f, 0.05107637f, 0.07118540f, 0.06304189f, 0.10301364f, -0.12066682f, 0.02884992f, 
    0.08791637f, 0.13421524f, -0.06791066f, -0.05201415f, 0.13886654f, -0.12822244f, 0.13776477f, 0.12259433f, 
    0.05201874f, 0.08850782f, -0.02864088f, 0.00765782f, 0.05692919f, 0.02244334f, -0.02154953f, -0.08438449f, 
    0.05739304f, 0.14196356f, -0.18618082f, 0.00161452f, 0.26562876f, -0.33926541f, 0.08537726f, -0.04366694f, 
    0.00837081f, 0.04661191f, 0.03619156f, 0.14013810f, -0.02758119f, -0.06679716f, -0.14837676f, 0.07774831f, 
    -0.02906069f, -0.11202219f, 0.00141065f, 0.12364267f, 0.04838680f, 0.13500158f, -0.06885837f, 0.10015149f, 
    -0.17308149f, 0.43981034f, 0.10492978f, -0.18008727f, 0.14152624f, 0.01948848f, 0.02834730f, 0.04420936f, 
    0.13813782f, -0.15454938f, -0.10490575f, -0.03751843f, 0.15356161f, 0.04170806f, 0.11787906f, 0.05821062f, 
    0.06632406f, 0.00483272f, -0.02060449f, -0.00902041f, -0.24465135f, -0.02974352f, -0.07275889f, -0.25331986f, 
    0.14750811f, -0.03936241f, -0.16776879f, 0.04347222f, 0.07248663f, -0.00150628f, 0.11071493f, 0.01612424f, 
    0.07761820f, -0.07643609f, 0.03120730f, 0.10582604f, 0.12087091f, -0.17342803f, -0.05741578f, 0.04980420f, 
    -0.05667396f, -0.08908031f, 0.06002114f, -0.05147040f, 0.13340037f, -0.09926981f, 0.14199354f, 0.23217465f, 
    -0.01216707f, 0.03507964f, -0.24736227f, -0.14339192f, -0.03528794f, 0.06975121f, 0.18970272f, 0.06847098f, 
    0.00829568f, 0.14205365f, 0.02747303f, 0.13393778f, 0.18980674f, -0.31342524f, 0.16688384f, 0.07788024f, 
    -0.34001505f, -0.02230967f, -0.00350611f, 0.09460799f, 0.11641451f, 0.08574677f, -0.01359497f, -0.03187865f, 
    -0.09218252f, 0.06975890f, 0.00471015f, -0.22096749f, 0.01250519f, 0.09182367f, -0.01552474f, 0.02866492f, 
    0.19292301f, -0.02598451f, 0.17488137f, 0.03282338f, -0.19336602f, -0.02923012f, -0.00850892f, -0.01026321f, 
    0.07191324f, 0.10795821f, -0.14629292f, 0.04971284f, 0.01532870f, -0.07925573f, 0.02295353f, -0.08797444f, 
    -0.05678795f, -0.04163516f, -0.18879843f, -0.06579963f, 0.42451319f, -0.59242713f, 0.11412108f, 0.10204794f, 
    -0.15273608f, -0.03337200f, -0.10161955f, -0.09551282f, 0.15285487f, -0.04141218f, 0.01140266f, 0.04794097f, 
    -0.17546387f, 0.06371461f, -0.07497001f, 0.04102433f, 0.09903620f, -0.02870907f, -0.00206620f, 0.06529089f, 
    0.21556893f, -0.58989722f, -0.01127212f, 0.20535944f, 0.03601492f, -0.08976620f, -0.05194470f, 0.00874802f, 
    -0.03554784f, -0.01751829f, -0.06624227f, -0.09775460f, 0.22126165f, 0.20323542f, -0.03400261f, 0.17936075f, 
    0.03433463f, -0.07406555f, -0.10828789f, 0.09750365f, -0.48560432f, 0.14555061f, 0.06322458f, -0.13435923f, 
    -0.27676556f, 0.08295692f, 0.07515524f, 0.10861018f, 0.06840003f, 0.16553223f, 0.04106672f, -0.04145197f, 
    -0.05679191f, -0.03075896f, -0.08004099f, -0.09164736f, -0.00691731f, 0.02761999f, 0.08940159f, 0.10121653f, 
    0.02648739f, -0.09121620f, 0.13189824f, 0.15249798f, 0.09753963f, -0.03304431f, -0.00027503f, -0.05851982f, 
    0.03498346f, -0.03281598f, 0.03685967f, 0.11593952f, 0.21490334f, -0.01600717f, -0.09014430f, 0.01875803f, 
    0.06814606f, -0.17771615f, -0.14461647f, 0.10810993f, 0.32922933f, 0.17500637f, 0.21801037f, 0.30499464f, 
    -0.08252392f, -0.10743848f, -0.03781447f, 0.24731952f, -0.00341074f, 0.08830026f, 0.03958226f, -0.06508118f, 
    -0.02650518f, 0.05841801f, -0.04525017f, 0.15470025f, -0.01750716f, -0.14478703f, -0.04212624f, -0.16079040f, 
    -0.10392693f, -0.02096575f, -0.10193566f, -0.05077433f, 0.12560017f, 0.06582564f, 0.01447252f, 0.07579548f, 
    0.04281600f, -0.05189130f, -0.00267269f, 0.03662696f, -0.04585566f, 0.06354295f, 0.17072731f, 0.13068584f, 
    0.11047008f, -0.08031636f, 0.08574578f, 0.09543765f, -0.04186562f, -0.22778708f, -0.57282180f, 0.22887519f, 
    0.21996148f, 0.14038862f, 0.00650283f, -0.00102223f, 0.01422931f, 0.19616629f, -0.03554482f, 0.11013303f, 
    -0.00303179f, 0.02771419f, 0.14732465f, 0.07117217f, -0.10490686f, 0.08794832f, 0.05639356f, 0.04166502f, 
    0.01540843f, 0.12638029f, -0.03074090f, -0.07156021f, 0.07454912f, -0.03206470f, 0.15523198f, 0.01756850f, 
    -0.00926261f, -0.00635285f, 0.05284283f, -0.08791732f, 0.14225115f, -0.04434995f, 0.00237139f, 0.10951485f, 
    0.03802860f, -0.02321322f, -0.04631737f, -0.02805248f, 0.10622281f, -0.30697417f, -0.44415981f, -0.10021111f, 
    -0.28075042f, 0.25374207f, 0.03715845f, -0.12710260f, -0.10147515f, 0.24668913f, 0.09734939f, 0.10152608f, 
    0.12789840f, 0.16774817f, 0.10548134f, 0.15645170f, 0.01293626f, -0.02294080f, -0.09866906f, 0.06385829f, 
    -0.01382569f, 0.12241037f, 0.21522082f, -0.03027903f, 0.15044272f, -0.10239232f, 0.03682651f, 0.01086709f, 
    0.14841288f, 0.07288560f, -0.17797033f, -0.04891602f, 0.04877061f, -0.01139895f, 0.04629902f, 0.05569710f, 
    0.12258556f, 0.08768484f, -0.08016164f, 0.19764724f, 0.32660195f, -0.26066700f, 0.10223506f, 0.06907426f, 
    0.02313568f, 0.06952152f, 0.17364140f, 0.01304706f, 0.09438144f, -0.02173146f, -0.00082160f, -0.09621319f, 
    -0.00916939f, -0.11864982f, 0.10578006f, 0.08462460f, -0.06944297f, 0.00618343f, -0.10777845f, -0.05096044f, 
    -0.17718761f, -0.25467685f, -0.04089372f, -0.20135999f, 0.13875942f, -0.03369544f, 0.08693211f, 0.20349184f, 
    0.08736781f, -0.12366269f, -0.00037953f, -0.07574994f, 0.15338890f, 0.06506488f, -0.00706317f, -0.06859890f, 
    0.04146251f, 0.13334379f, 0.04275832f, 0.07929207f, 0.01270811f, 0.38270733f, 0.28328791f, 0.30154949f, 
    0.01598020f, 0.01957950f, 0.09769561f, 0.22183357f, 0.13602732f, 0.06316289f, 0.07486598f, -0.01100710f, 
    0.02845120f, -0.00564749f, -0.07721040f, 0.08520058f, 0.00499866f, -0.06980787f, 0.00128378f, -0.08721136f, 
    -0.08723649f, -0.21042904f, 0.04735352f, -0.04426467f, -0.04129316f, -0.00652055f, 0.02051291f, 0.17577985f, 
    -0.07718626f, 0.05881064f, -0.06107759f, -0.02883969f, 0.05879620f, 0.06625473f, 0.00406481f, -0.12822668f, 
    -0.05666489f, -0.05913604f, 0.03640318f, -0.23295546f, 0.31585559f, -0.30004615f, 0.09375038f, -0.01551398f, 
    -0.03413619f, -0.26100272f, -0.25864455f, 0.07641461f, 0.02472157f, -0.04208780f, -0.06711015f, -0.01742700f, 
    -0.03997281f, 0.02051057f, 0.05362135f, -0.02964988f, 0.00337604f, -0.08908334f, -0.00923358f, -0.08463816f, 
    0.35516208f, -0.17887864f, 0.09472299f, 0.02215269f, 0.08068030f, -0.13380864f, -0.20656556f, 0.08731654f, 
    -0.03362172f, 0.07770564f, -0.08933307f, -0.06376328f, -0.16645691f, -0.00320593f, 0.11006933f, 0.01794609f, 
    0.08889731f, -0.18825552f, 0.05187576f, -0.09186585f, 0.53792185f, 0.15259425f, -0.08986100f, -0.07314337f, 
    -0.10740045f, -0.01724114f, -0.19293118f, -0.10254688f, -0.09606814f, -0.01843930f, -0.00502019f, -0.07140255f, 
    -0.08833522f, 0.02649963f, 0.09190804f, -0.01731373f, -0.22358915f, 0.07113171f, -0.02662565f, 0.05606240f, 
    -0.08518902f, 0.04191386f, 0.08594581f, -0.05260507f, 0.00571725f, 0.09027208f, 0.06132233f, -0.02622004f, 
    -0.00333179f, -0.03693882f, 0.09099863f, 0.08625001f, -0.15694650f, 0.05205192f, -0.16046365f, 0.04715631f, 
    -0.11049563f, 0.02073351f, 0.05195691f, -0.09814017f, -0.21548183f, -0.01520646f, -0.09104691f, 0.29740381f, 
    0.05297485f, -0.08380482f, 0.07664504f, 0.10995071f, 0.03390084f, -0.02399867f, 0.00214378f, -0.08565924f, 
    0.00676750f, 0.22936036f, 0.20674004f, -0.16813935f, -0.07490888f, -0.06621554f, -0.16427194f, 0.03389309f, 
    0.23843174f, 0.11025038f, 0.01209406f, 0.01451918f, 0.07230198f, -0.09357820f, -0.00525133f, -0.08281483f, 
    -0.14662886f, -0.04866030f, 0.02012371f, -0.02341289f, -0.00535668f, -0.00088961f, 0.06228057f, 0.18303448f, 
    0.11339250f, 0.03248725f, 0.14057410f, -0.03003713f, 0.06109520f, 0.35510164f, 0.31933695f, 0.36040652f, 
    0.39248893f, -0.14165322f, -0.04856578f, -0.05990453f, 0.00239825f, 0.08759471f, 0.03672041f, -0.01251017f, 
    -0.01588139f, -0.03736770f, -0.02087281f, -0.12279506f, 0.11353880f, 0.09368901f, 0.05043823f, 0.00074620f, 
    -0.27034420f, 0.03397162f, -0.04223821f, -0.21133548f, -0.08719817f, 0.04049998f, 0.11052898f, 0.12815915f, 
    0.15766363f, 0.07304502f, 0.15126009f, 0.13700610f, 0.04387195f, -0.00080067f, 0.06645876f, -0.02190230f, 
    0.07162897f, -0.08578289f, 0.01587155f, 0.05352109f, -0.36679009f, -0.12844427f, -0.07658758f, -0.13631296f, 
    0.00607109f, 0.21991038f, 0.25246197f, 0.04616168f, 0.20126469f, 0.03709897f, 0.08255127f, -0.00352199f, 
    -0.01082495f, 0.11258158f, 0.09873011f, -0.00851143f, -0.01051667f, -0.14417532f, -0.03702005f, -0.09600027f, 
    0.30019712f, 0.37852088f, 0.12457360f, 0.24043228f, -0.17397979f, -0.01409875f, -0.03869990f, 0.14020938f, 
    -0.07036108f, 0.05015862f, -0.06805354f, 0.05201978f, 0.02312796f, -0.15423957f, -0.07567215f, 0.00108631f, 
    0.12490673f, 0.14661603f, 0.05202422f, 0.06210537f, -0.40871251f, 0.24531491f, -0.16573697f, -0.03204616f, 
    0.07986577f, 0.16225521f, 0.20543478f, 0.04349415f, 0.00344816f, 0.07881147f, 0.12898789f, -0.01352436f, 
    -0.02383371f, -0.01851383f, 0.13946235f, 0.16784200f, 0.21200401f, -0.01608472f, 0.09312849f, -0.03422059f, 
    0.35792619f, -0.08328370f, -0.03637619f, -0.21412511f, 0.45672965f, -0.16173816f, -0.28263861f, 0.04706450f, 
    -0.13111304f, 0.07117849f, -0.04256365f, 0.06026280f, 0.10879709f, 0.10400497f, 0.07429375f, -0.11940964f, 
    0.05416084f, -0.18916529f, 0.11967053f, -0.00644723f, 0.11739115f, -0.40326428f, 0.11886074f, -0.09196728f, 
    -0.19132866f, -0.13879108f, -0.09373258f, 0.01932753f, 0.02796176f, -0.00920176f, 0.20867303f, 0.06324721f, 
    0.06165326f, 0.06609475f, -0.18449064f, -0.03302485f, -0.08703529f, -0.10846563f, 0.01339829f, -0.04289436f, 
    -0.40156773f, 0.32841375f, -0.02579145f, -0.08471473f, -0.03116843f, -0.02502339f, 0.10206658f, 0.06758805f, 
    -0.02804283f, -0.03711908f, 0.14878458f, -0.04945518f, -0.09906859f, 0.00151220f, -0.06939966f, -0.01100183f, 
    -0.16475573f, 0.02194168f, 0.07803436f, -0.27910045f, 0.19604106f, 0.35861668f, 0.09717596f, 0.28782862f, 
    0.50687075f, -0.17022564f, -0.04663645f, 0.18082066f, 0.10400316f, 0.03580916f, 0.06411452f, 0.00952588f, 
    0.03005109f, 0.07071235f, -0.04418140f, 0.05649849f, 0.04662265f, 0.11914074f, 0.04719273f, 0.01737908f, 
    0.06456806f, 0.12941939f, -0.09267946f, -0.24715337f, -0.10448505f, -0.02481149f, -0.02468121f, 0.19844383f, 
    -0.01858094f, 0.18548864f, -0.02499334f, 0.04079098f, 0.09797094f, -0.09636215f, 0.05816620f, -0.03830213f, 
    -0.00128520f, -0.11974589f, 0.03531182f, -0.03291799f, -0.16796239f, -0.40008724f, -0.14855738f, 0.14511448f, 
    -0.21294363f, 0.05502242f, 0.04658793f, 0.17735645f, -0.03296889f, -0.07754478f, -0.03472172f, 0.06257395f, 
    -0.02563493f, 0.09557457f, 0.01065977f, -0.00012988f, -0.01886448f, -0.06924869f, -0.12937586f, 0.03427912f, 
    0.09395226f, -0.36773977f, -0.14189066f, 0.17847325f, -0.29277897f, 0.08708140f, -0.00055680f, 0.04470583f, 
    -0.04285195f, 0.11547339f, -0.00159576f, 0.03723364f, -0.00450040f, -0.01108449f, 0.10883512f, 0.00836350f, 
    0.08144307f, -0.14975803f, 0.05045571f, -0.02456991f, 0.33592677f, -0.11090207f, -0.17644560f, 0.16608778f, 
    0.06791038f, 0.22101650f, 0.09790011f, 0.01928027f, -0.11277629f, -0.05598641f, 0.05803996f, 0.00946942f, 
    -0.13000533f, -0.03766677f, 0.07676421f, -0.02365187f, -0.04099221f, 0.17924151f, 0.17795423f, 0.26890349f, 
    0.20316355f, -0.41861996f, 0.05444353f, 0.00758926f, 0.28438246f, 0.12256996f, -0.21730775f, 0.10842345f, 
    -0.03619009f, -0.10887690f, 0.17758170f, 0.02395578f, -0.04359219f, 0.04386047f, -0.02872418f, -0.02231562f, 
    0.07508605f, 0.02700182f, -0.05268046f, 0.15687476f, 0.04014524f, 0.23330291f, -0.04182663f, -0.08061796f, 
    -0.09778915f, 0.11567011f, 0.11359777f, 0.09542236f, 0.07473420f, -0.09904990f, -0.05912714f, 0.02841462f, 
    -0.01635240f, 0.20938182f, 0.05682533f, 0.02515739f, 0.00884841f, -0.03912202f, -0.25240386f, 0.07061642f, 
    0.20786546f, -0.02276585f, -0.08339343f, 0.15039447f, 0.05118633f, -0.07469164f, -0.03341539f, 0.05907491f, 
    -0.03119230f, 0.13901430f, 0.20601018f, -0.00299464f, 0.08837771f, 0.04693723f, -0.03824918f, 0.04400934f, 
    0.12286782f, 0.04970986f, 0.08249311f, 0.06383228f, -0.48993421f, 0.24588339f, 0.22456032f, 0.41397837f, 
    0.27648544f, 0.08178426f, 0.14240365f, -0.01658786f, 0.07750338f, 0.11560796f, -0.03541916f, 0.14633818f, 
    -0.06245799f, 0.00970750f, 0.08760251f, 0.00231991f, 0.02941312f, 0.11477587f, 0.02576018f, -0.11035321f, 
    -0.01921450f, 0.12252683f, -0.10811710f, -0.22109835f, 0.00063814f, -0.05879485f, -0.12630209f, 0.02997012f, 
    0.02462817f, 0.01711522f, 0.15828727f, 0.10731491f, 0.06332581f, -0.10525835f, 0.02554457f, -0.06201083f, 
    0.13660491f, -0.21174538f, 0.12094798f, 0.10077381f, 0.19981872f, -0.23947501f, -0.19145103f, 0.02199945f, 
    -0.00037457f, 0.05533755f, 0.03875162f, 0.03814868f, -0.00855340f, -0.02053124f, 0.07982418f, -0.04995203f, 
    0.09460916f, 0.16821267f, 0.06046262f, 0.16391808f, -0.00293890f, -0.17737165f, -0.01353879f, 0.01701252f, 
    0.21645261f, 0.28596976f, -0.29586229f, -0.00742982f, -0.00763358f, 0.11503125f, 0.09962636f, -0.00400988f, 
    0.01685383f, 0.10351688f, -0.01462810f, 0.05081132f, -0.04727089f, -0.06587607f, 0.09744079f, 0.02735977f, 
    0.06586411f, 0.12535226f, 0.05101399f, 0.07473299f, 0.02691111f, -0.23561463f, -0.06730757f, 0.00898667f, 
    0.20007136f, -0.12922721f, -0.11472655f, -0.08672043f, -0.00699995f, 0.06865904f, 0.11058430f, 0.00001826f, 
    -0.11520082f, -0.02680609f, 0.04615878f, -0.03287421f, 0.10151929f, -0.07257897f, -0.00260536f, -0.00306100f, 
    -0.01686854f, -0.12674402f, -0.07514445f, 0.01979579f, -0.26002511f, 0.02268527f, -0.03651188f, -0.00278957f, 
    -0.09254838f, 0.04186673f, -0.11629178f, -0.08783430f, 0.17695093f, 0.02436888f, 0.09630360f, -0.02688713f, 
    -0.00138602f, -0.06138147f, 0.12355528f, -0.07292780f, -0.06001369f, -0.29193130f, -0.03025456f, -0.20192640f, 
    -0.07808283f, 0.00535825f, -0.02563228f, 0.01871300f, 0.04639063f, 0.11068999f, 0.29213664f, -0.13239248f, 
    0.07022132f, 0.09000086f, -0.21631855f, 0.01975937f, -0.02541644f, -0.09905637f, 0.19420627f, 0.03837284f, 
    -0.56241423f, -0.04120811f, -0.41864839f, 0.01475336f, 0.02396506f, -0.01095160f, -0.03753626f, -0.03705974f, 
    -0.03607120f, 0.09929065f, -0.00937278f, 0.07127314f, -0.02479516f, -0.03831248f, 0.07437538f, -0.07638676f, 
    -0.04312969f, 0.16369922f, -0.08591193f, -0.10589772f, -0.25233114f, 0.36398995f, 0.03094452f, 0.22539261f, 
    0.07185135f, 0.17961933f, 0.07494481f, 0.14654778f, 0.07303355f, 0.18499023f, 0.04161815f, 0.00427441f, 
    -0.04335168f, 0.18383375f, -0.03179328f, -0.03180377f, 0.01550129f, 0.12768428f, 0.00009083f, 0.08704577f, 
    0.13380291f, 0.13944203f, -0.12403107f, -0.09603791f, 0.16477282f, -0.13234523f, -0.07009277f, 0.09733492f, 
    0.07113732f, 0.05481646f, -0.22353020f, -0.03304730f, 0.01330026f, 0.01121896f, -0.02105316f, -0.11380466f, 
    0.04332082f, -0.15919112f, 0.01757790f, -0.06484737f, 0.29288605f, 0.00757010f, -0.04446030f, -0.05535179f, 
    0.25788477f, 0.14625947f, -0.01317308f, -0.07829150f, 0.07450330f, -0.07099410f, 0.08383587f, 0.14057176f, 
    -0.04935456f, 0.11801713f, -0.02824929f, 0.00324049f, -0.02452528f, -0.22745390f, -0.07003707f, -0.10389698f, 
    0.22674981f, -0.28692010f, 0.07067698f, -0.08477458f, -0.02780130f, 0.01599842f, -0.17832746f, 0.05346808f, 
    -0.02382193f, -0.03804199f, 0.08130641f, 0.16507497f, -0.03944555f, 0.04801682f, 0.04299437f, -0.06278851f, 
    0.03942395f, -0.05978136f, -0.04645162f, -0.00062461f, 0.28689015f, -0.12287553f, 0.00440112f, -0.06089418f, 
    0.10662688f, 0.02649220f, 0.24499519f, -0.06728546f, -0.02631015f, -0.00591385f, 0.02002765f, 0.06724060f, 
    -0.15484208f, -0.03235901f, 0.18464406f, -0.07866900f, 0.02678743f, 0.10966831f, -0.02974891f, 0.25236541f, 
    0.14660496f, -0.33203477f, 0.30325308f, -0.07957353f, 0.19494329f, -0.17482689f, -0.01386649f, 0.01371934f, 
    -0.03448743f, 0.00800674f, 0.14704847f, -0.00807318f, -0.00547732f, -0.03164182f, -0.08197051f, 0.02023019f, 
    0.06173948f, 0.01205053f, -0.03368398f, 0.00868919f, 0.04718137f, -0.05363594f, -0.24325402f, 0.18343656f, 
    0.07653978f, 0.17718793f, -0.03283716f, -0.00621146f, 0.10851757f, 0.00146061f, -0.05953835f, 0.03221820f, 
    0.00087909f, 0.17680044f, -0.02730710f, 0.09662531f, 0.00406056f, -0.09615918f, -0.11637080f, 0.16616610f, 
    0.02663615f, -0.31754068f, 0.06775174f, 0.03330534f, 0.01424496f, -0.16550770f, 0.05715368f, 0.11497446f, 
    -0.02763478f, 0.16416174f, 0.08512521f, 0.01658211f, -0.05907520f, 0.03789043f, -0.09125166f, -0.04060439f, 
    0.05325384f, -0.07713760f, -0.02769256f, 0.08128563f, -0.03952637f, 0.14180712f, 0.08648277f, -0.09049314f, 
    0.35098299f, -0.06890152f, -0.20593560f, -0.08419237f, -0.01843270f, 0.15510999f, 0.09777158f, 0.12232845f, 
    0.09028552f, 0.10972795f, 0.07845201f, 0.05396586f, 0.13039152f, 0.10385543f, -0.02552299f, 0.05896014f, 
    0.33495650f, 0.27685341f, -0.05238483f, 0.16647287f, 0.08525408f, 0.00336799f, -0.11661364f, 0.28121573f, 
    0.03828984f, -0.11735280f, 0.04530756f, -0.18908258f, 0.05843282f, 0.03695919f, -0.08689738f, -0.01485771f, 
    0.14067498f, -0.23431145f, -0.09270260f, -0.03188648f, 0.43537936f, 0.12726183f, -0.09883178f, 0.09658024f, 
    -0.19694103f, 0.10454301f, 0.07777479f, 0.16398428f, 0.04762151f, 0.04318055f, -0.06152761f, -0.08272703f, 
    0.00586840f, 0.00340454f, -0.00892514f, 0.21850580f, 0.04419914f, 0.05132122f, -0.05598254f, -0.08190593f, 
    -0.00523206f, 0.11250830f, -0.07120837f, -0.13524899f, 0.25032195f, 0.04515351f, 0.20968366f, -0.03383408f, 
    -0.03873098f, 0.13534376f, -0.14315727f, 0.05800742f, 0.06595919f, -0.03653333f, 0.02468919f, 0.17743582f, 
    -0.07668324f, 0.12030794f, 0.07916393f, 0.06268235f, 0.29211146f, 0.00466376f, 0.14416909f, 0.05300358f, 
    -0.32416505f, -0.08056825f, 0.05718190f, -0.05812747f, -0.07645880f, 0.00530690f, 0.06114218f, 0.06333961f, 
    -0.04044312f, 0.03653055f, -0.13064933f, 0.01135199f, 0.12313445f, 0.00813955f, -0.06739881f, 0.05347173f, 
    0.15805781f, -0.01812686f, -0.13379888f, -0.00144638f, -0.12962902f, -0.15335549f, 0.00280526f, 0.06975973f, 
    -0.02398442f, 0.04601683f, -0.16007702f, -0.04440051f, 0.07736661f, 0.01643639f, 0.08266125f, -0.03725440f, 
    0.04025836f, -0.04275256f, 0.09205113f, -0.12162319f, 0.19696467f, -0.58509499f, 0.14823869f, -0.09170005f, 
    0.16263306f, 0.02784120f, 0.02212420f, -0.00157018f, -0.00593593f, 0.11123623f, 0.04942072f, 0.13414718f, 
    -0.02884528f, -0.01129390f, -0.12104744f, 0.13616197f, 0.15743558f, -0.08205275f, 0.04912740f, -0.00622658f, 
    -0.77718502f, 0.27312574f, -0.21713513f, -0.21481663f, -0.06089591f, 0.03198346f, 0.14187087f, -0.12145548f, 
    -0.00367803f, -0.02389843f, -0.16741389f, 0.04723608f, 0.07844730f, -0.03950912f, 0.05631979f, 0.01011432f, 
    0.02226222f, 0.10497351f, -0.19060884f, -0.09752253f, 0.19441102f, 0.30428019f, -0.12489376f, -0.03289331f, 
    0.11969336f, 0.03201677f, -0.09165324f, 0.09422047f, 0.07209344f, 0.10403543f, 0.19565161f, -0.07258324f, 
    -0.02167757f, 0.12894258f, -0.07251226f, 0.04080622f, 0.07965757f, 0.02491340f, -0.09260859f, 0.11586625f, 
    -0.15590957f, -0.10934792f, 0.27354482f, 0.00750130f, -0.23896210f, -0.12253136f, 0.03910298f, 0.06284546f, 
    -0.08927418f, -0.03454681f, -0.15767382f, -0.01735245f, -0.07266751f, 0.07474247f, 0.13713990f, 0.10709628f, 
    -0.07016095f, 0.01698378f, -0.10238972f, -0.03814529f, -0.04993024f, -0.36261904f, 0.17909548f, -0.15417899f, 
    0.11727084f, -0.02417007f, -0.07795067f, 0.06644233f, 0.08132884f, -0.09244247f, 0.03850147f, -0.07611758f, 
    -0.01433037f, -0.00880975f, 0.08852983f, 0.08616705f, 0.00289559f, 0.01799930f, 0.11524882f, -0.19905418f, 
    0.11207248f, 0.08887422f, -0.01767750f, -0.13697487f, 0.27046660f, 0.02767799f, -0.06413110f, 0.17129153f, 
    -0.06245951f, -0.03827021f, -0.03870942f, -0.00744690f, 0.01147532f, -0.03539082f, 0.04004504f, 0.07100774f, 
    -0.03651167f, 0.02083826f, 0.13698530f, 0.06485212f, 0.30107287f, -0.14139643f, 0.01932880f, 0.00388815f, 
    -0.13913186f, -0.19226708f, -0.18074740f, -0.03278562f, 0.17243804f, -0.05501927f, -0.08908387f, 0.01577813f, 
    0.09769284f, 0.15982156f, 0.09602069f, -0.01165198f, 0.01783161f, -0.00072596f, 0.05148471f, -0.03590077f, 
    -0.01447670f, -0.22180647f, -0.13355851f, 0.27540234f, -0.26600862f, -0.13930064f, 0.09394314f, 0.00962841f, 
    0.07730515f, 0.01065165f, 0.05713716f, 0.08592378f, -0.20938590f, -0.00916427f, 0.07544160f, -0.02287543f, 
    -0.14121899f, 0.09364701f, -0.02289794f, -0.04402670f, -0.04022595f, 0.24280652f, 0.08270811f, -0.07881954f, 
    -0.03954868f, 0.01098006f, 0.10786815f, -0.01203621f, -0.00683450f, 0.07354672f, 0.03372499f, 0.00121902f, 
    -0.02218488f, -0.11369197f, -0.05458418f, -0.11055373f, 0.25322813f, -0.01347628f, -0.01226802f, -0.15741955f, 
    0.22983474f, 0.29385430f, 0.07404214f, -0.14408886f, 0.16512075f, 0.03286220f, -0.07599611f, -0.02442507f, 
    -0.06991132f, -0.10328259f, -0.05870326f, -0.02101892f, -0.05136001f, 0.08808234f, 0.06395310f, -0.01371122f, 
    0.09205227f, 0.12411504f, 0.08569485f, 0.11090974f, 0.40580192f, -0.21642070f, -0.08382209f, 0.00942460f, 
    0.04365889f, 0.10240669f, 0.08531152f, 0.18512164f, -0.11586525f, -0.17195742f, 0.06209202f, -0.08680455f, 
    -0.09065118f, 0.03837411f, -0.05673027f, 0.12740223f, 0.01409848f, 0.09304858f, -0.12813002f, 0.13353355f, 
    -0.30458191f, -0.11202312f, 0.02252421f, 0.02281936f, -0.22763185f, 0.10367124f, 0.04035577f, 0.02700203f, 
    0.11019385f, -0.00899496f, -0.00881518f, 0.06712719f, 0.00869801f, -0.04972801f, 0.15317769f, -0.02642822f, 
    -0.07259624f, 0.01070021f, -0.18887968f, -0.13210346f, 0.00496709f, -0.19689246f, -0.20287812f, 0.26258042f, 
    -0.12958886f, -0.04683917f, -0.13057964f, -0.08856265f, 0.13552810f, 0.19214079f, 0.04982730f, 0.12836260f, 
    -0.08011572f, -0.03093635f, 0.11499987f, 0.02714983f, 0.05842502f, -0.02967026f, 0.09952815f, 0.02976512f, 
    -0.42474428f, 0.04204506f, 0.24573316f, -0.10694370f, 0.07507098f, 0.15330721f, -0.07620689f, 0.01842647f, 
    -0.01530707f, -0.00546251f, 0.10324383f, -0.01033360f, 0.10304893f, 0.09149842f, 0.02542643f, -0.05762448f, 
    0.13541409f, -0.03533446f, 0.05371173f, 0.08581505f, 0.27478591f, 0.16555598f, -0.08397906f, 0.11807247f, 
    -0.20536363f, -0.03571796f, -0.12043434f, -0.04836470f, 0.04972550f, 0.08995090f, 0.05095300f, -0.06057748f, 
    0.06086812f, -0.09860975f, 0.11557927f, 0.09951422f, 0.06035314f, 0.06016582f, 0.03638760f, 0.07443204f, 
    0.33658853f, -0.01325115f, -0.05621121f, -0.21103145f, 0.52148205f, 0.03493573f, -0.04786606f, -0.11048654f, 
    -0.11936033f, 0.02058397f, 0.14976284f, 0.01472391f, 0.04281708f, 0.05943514f, 0.10032383f, -0.10859279f, 
    0.01456324f, 0.06301998f, 0.05526914f, 0.14350402f, -0.00916226f, 0.12691686f, 0.33817378f, 0.18331923f, 
    -0.27232823f, 0.03499521f, 0.00426983f, 0.10707799f, 0.08589083f, -0.04816559f, -0.03440925f, 0.12802984f, 
    0.06976346f, -0.00632038f, 0.15406758f, 0.04179529f, -0.02088724f, -0.16675225f, -0.02685587f, 0.05031782f, 
    0.35669985f, 0.35505766f, -0.03158754f, -0.08562641f, 0.32400128f, -0.09619521f, -0.04974646f, -0.13710205f, 
    0.11489658f, -0.03608818f, 0.20933385f, -0.01934626f, 0.09676183f, -0.14855410f, -0.00436278f, 0.09349586f, 
    -0.02407830f, -0.13423112f, 0.30206984f, 0.06311813f, 0.06080178f, -0.32525688f, -0.06575327f, -0.06378903f, 
    0.40480822f, 0.16037069f, 0.20818977f, -0.08348162f, -0.07198435f, -0.13863295f, -0.15852247f, -0.02949238f, 
    -0.02012319f, 0.06914207f, 0.04517761f, 0.05231212f, -0.00436620f, 0.10286178f, 0.01491255f, -0.05767548f, 
    -0.06269190f, 0.00033362f, -0.04559388f, -0.04541429f, -0.04603852f, -0.02115384f, 0.04083687f, 0.03663082f, 
    -0.03454597f, -0.04272534f, -0.05785364f, -0.01179018f, -0.05807026f, -0.05189663f, -0.05291586f, 0.03512309f, 
    -0.00062810f, -0.04308459f, -0.03364931f, 0.00577405f, 0.02889631f, 0.01658782f, -0.01593035f, -0.00764961f, 
    0.03895431f, -0.00340799f, 0.03728457f, -0.01767651f, -0.04083180f, -0.01883843f, 0.01765834f, 0.00786028f, 
    -0.02287445f, 0.01155853f, 0.01004568f, 0.01466971f, 0.04725777f, -0.03851299f, 0.02851242f, 0.04134150f, 
    0.04172054f, -0.03384959f, -0.02489600f, 0.02030306f, -0.05799259f, -0.01212178f, -0.00269275f, -0.03452323f, 
    0.00382172f, -0.00829693f, 0.03288275f, -0.00030773f, -0.06249735f, -0.00064712f, 0.01889452f, -0.06116663f, 
    -0.04220123f, -0.00112753f, 0.02460571f, -0.01131423f, 0.00790526f, -0.03662007f, 0.04907237f, 0.04619419f, 
    0.02737544f, 0.02345156f, -0.02745847f, 0.02562346f, 0.04234065f, -0.02998818f, -0.05663861f, -0.05498631f, 
    0.01307190f, -0.01682779f, 0.00500534f, -0.01472518f, 0.00357496f, -0.03310794f, -0.02698016f, 0.01610418f, 
    0.01101923f, 0.00862168f, -0.05945279f, 0.02165294f, 0.02522557f, -0.04051949f, 0.02506057f, -0.00423602f, 
    0.00339151f, -0.01502887f, -0.05073505f, 0.00048889f, 0.01874814f, 0.00677212f, 0.02098597f, -0.04177462f, 
    -0.03650036f, -0.01885735f, -0.06103894f, -0.01433275f, 0.02410873f, -0.01352650f, 0.04361887f, 0.01134800f, 
    0.04550508f, 0.03634262f, -0.01108622f, -0.00544839f, -0.05237542f, -0.05654575f, 0.00648394f, -0.03399865f, 
    -0.06414477f, -0.04909953f, -0.02783922f, 0.03462665f, -0.01888661f, 0.03653771f, -0.01779817f, -0.06042937f, 
    0.00513651f, -0.03600625f, 0.03431627f, 0.04465986f, -0.03736676f, 0.00287033f, -0.01240297f, 0.02100793f, 
    0.03728637f, 0.01158414f, 0.01861562f, -0.04165673f, -0.00307678f, -0.05648474f, 0.02149882f, -0.00868424f, 
    -0.04314630f, -0.01599563f, -0.03477724f, 0.04580148f, -0.03899414f, -0.05359253f, 0.00197381f, -0.06196295f, 
    -0.02019047f, -0.00762189f, 0.00951437f, -0.01614578f, 0.03537447f, -0.05883503f, 0.02439401f, -0.01868118f, 
    -0.02728012f, 0.04094362f, 0.04551484f, -0.00196467f, 0.05029567f, -0.03252174f, -0.03317755f, -0.00352863f, 
    -0.06097279f, -0.06185037f, -0.02645314f, 0.04418167f, 0.02559258f, 0.04743423f, -0.02370518f, 0.01176996f, 
    0.03483744f, -0.01362415f, 0.02335216f, -0.03131872f, -0.01872005f, -0.01275805f, -0.05678886f, -0.06317219f, 
    -0.02240446f, 0.00093732f, -0.00730026f, -0.01200353f, 0.04179583f, -0.02375435f, -0.01440426f, 0.02018975f, 
    0.00387556f, 0.02356610f, -0.05983474f, -0.01213173f, -0.03239276f, -0.02700134f, 0.03911785f, 0.01776703f, 
    -0.04415473f, 0.03629293f, 0.02907685f, -0.04039408f, -0.06453060f, -0.03789475f, -0.05882903f, -0.03277696f, 
    -0.02655592f, -0.05859745f, 0.02916231f, 0.02138259f, -0.05849645f, -0.03383091f, -0.00942187f, 0.01637849f, 
    -0.05817588f, 0.03822705f, -0.04800678f, 0.02013358f, 0.01652640f, 0.01270951f, -0.03948523f, -0.05814384f, 
    0.03404049f, -0.03635442f, -0.01387354f, -0.00909360f, -0.02243657f, -0.05470271f, -0.02227174f, -0.04218702f, 
    0.02875052f, -0.05467334f, 0.00181876f, 0.00126921f, 0.03759182f, 0.00641138f, 0.03843466f, 0.03279397f, 
    -0.00510448f, -0.01372624f, 0.04326601f, 0.03395637f, 0.03398186f, -0.03372365f, -0.03700328f, 0.01022726f, 
    -0.02638532f, -0.02419010f, -0.05797884f, -0.04179094f, -0.06299934f, -0.02206618f, -0.05106481f, -0.04424614f, 
    -0.01716034f, -0.03368298f, 0.01174069f, 0.03223316f, -0.05414380f, -0.00132372f, -0.04295945f, 0.01483434f, 
    -0.03900449f, -0.01679503f, -0.05659220f, 0.01246232f, -0.00018354f, -0.00081572f, -0.05918266f, 0.00704654f, 
    -0.05617412f, 0.04012193f, -0.05007627f, -0.01188627f, -0.00495480f, -0.03995384f, 0.03209141f, -0.02782173f, 
    -0.02147749f, -0.05625001f, -0.05976753f, 0.03869720f, 0.03720228f, -0.01935010f, 0.00705983f, -0.00949778f, 
    0.03456911f, -0.02552865f, -0.00431237f, -0.00788547f, 0.04591149f, 0.01470635f, 0.03051059f, -0.04805648f, 
    0.04822526f, 0.01058677f, -0.04705482f, -0.04590783f, -0.03588428f, -0.00500735f, -0.05551818f, 0.03264266f, 
    0.02372522f, 0.00614962f, 0.03685907f, 0.04358349f, -0.04249420f, -0.00713512f, 0.00071454f, -0.04995882f, 
    0.01246604f, -0.05925979f, 0.01257644f, 0.03158157f, 0.01475856f, 0.02581670f, -0.00055410f, -0.00756835f, 
    -0.02278930f, 0.00855074f, 0.00127366f, -0.05938010f, 0.00730419f, -0.02918405f, 0.01070845f, -0.00339251f, 
    0.03939620f, -0.13368002f, 0.03651401f, 0.02224109f, 0.14840195f, 0.07309149f, 0.04096086f, -0.01190300f, 
    -0.05615174f, -0.15623733f, 0.08282481f, 0.00283581f, 0.05017914f, -0.03160091f, 0.04841116f, 0.00803124f, 
    0.11073717f, -0.03017091f, -0.06423719f, -0.03407692f, -0.45621234f, -0.17292254f, 0.15177469f, 0.01186208f, 
    -0.28419268f, -0.10384243f, -0.15420039f, 0.15815863f, -0.14304203f, 0.01644189f, -0.27156055f, -0.03957620f, 
    0.09196971f, -0.08254634f, -0.12610650f, 0.09792215f, 0.02256415f, 0.03340410f, 0.05128901f, -0.10188012f, 
    -0.35375091f, 0.04398114f, 0.17392100f, -0.22366633f, 0.00076051f, 0.03094657f, 0.09299196f, 0.04841269f, 
    0.00283017f, 0.04937895f, -0.02508808f, -0.13975511f, 0.07926032f, -0.07723400f, 0.02980689f, 0.19597267f, 
    0.04365490f, -0.00484703f, 0.09337088f, 0.01293463f, 0.23869896f, -0.00099126f, 0.10056643f, -0.10182386f, 
    -0.07378194f, 0.04384081f, -0.15053523f, 0.04344985f, -0.05121730f, -0.04204439f, 0.01799056f, 0.05584461f, 
    0.06968737f, -0.01354410f, -0.03944745f, 0.12849045f, 0.03297275f, 0.07492635f, -0.04815403f, -0.05099268f, 
    0.20152782f, 0.23230757f, -0.24660465f, 0.00729818f, -0.02893646f, 0.05495741f, 0.10238582f, -0.11820190f, 
    0.02069634f, -0.06506170f, -0.04644699f, 0.01450277f, 0.05224495f, 0.01355990f, -0.07529141f, -0.02229064f, 
    0.05220349f, 0.09533579f, 0.03599888f, -0.08715711f, 0.01861051f, -0.18902032f, 0.34366843f, -0.15009785f, 
    -0.21516190f, -0.28608832f, -0.09535296f, 0.00319987f, -0.14980304f, -0.04067464f, -0.05400757f, -0.05986299f, 
    0.18023893f, 0.06617478f, 0.13004139f, -0.08221674f, 0.08716451f, -0.06071590f, -0.08494040f, 0.02472002f, 
    -0.03877566f, 0.38339147f, 0.08627489f, -0.10262635f, -0.01532997f, 0.04749611f, -0.00773244f, 0.03510563f, 
    -0.06054937f, -0.09585917f, 0.03307749f, 0.02766644f, 0.07897272f, 0.00027358f, 0.15032989f, 0.17289485f, 
    0.06749079f, 0.10640875f, 0.11572032f, 0.10586684f, -0.38523862f, 0.08536938f, 0.10096692f, -0.00100456f, 
    -0.20953120f, -0.04809557f, 0.12404110f, -0.04388295f, -0.03642913f, 0.08753902f, 0.05974103f, -0.10730416f, 
    -0.11205814f, 0.12781662f, 0.00520982f, 0.04189480f, -0.07403649f, -0.10343064f, 0.03715764f, 0.14594327f, 
    -0.33208293f, 0.00543958f, 0.15888928f, 0.15432474f, 0.04829818f, 0.16776177f, 0.16208872f, 0.05605288f, 
    -0.01991859f, 0.17236772f, 0.08274896f, 0.17428562f, 0.01752008f, -0.07097950f, 0.00875672f, 0.11996167f, 
    0.05793593f, 0.07440609f, 0.01364546f, 0.05134107f, -0.36168957f, -0.16656162f, 0.02543373f, 0.08108945f, 
    0.19310990f, 0.10691853f, 0.17483924f, -0.08299770f, 0.10677073f, 0.16939200f, 0.07311970f, -0.00810362f, 
    0.00799010f, -0.08194563f, -0.03313956f, -0.07081412f, 0.03479146f, -0.07592735f, 0.08674725f, 0.01790754f, 
    -0.07576568f, 0.27895886f, -0.10704162f, -0.00654279f, -0.32768402f, 0.12708697f, 0.17588872f, 0.00948332f, 
    -0.01467572f, 0.03797757f, -0.04881513f, -0.07537843f, -0.04472641f, 0.02768551f, 0.08662570f, -0.10401476f, 
    0.02142200f, -0.00426536f, -0.09631462f, 0.01955263f, -0.12907895f, 0.18270075f, -0.05615126f, 0.28259984f, 
    0.41786224f, 0.19745846f, 0.10951753f, 0.04727630f, 0.12668911f, 0.10431755f, 0.11130224f, -0.10664237f, 
    -0.08182528f, -0.04354241f, -0.08022638f, 0.06988183f, -0.00790889f, 0.06930718f, 0.05720268f, -0.06864011f, 
    -0.41616130f, -0.10943477f, 0.42236137f, -0.17366064f, 0.19308646f, 0.13716903f, -0.11166165f, -0.03734105f, 
    -0.02506724f, -0.02409899f, 0.27765790f, 0.04638291f, 0.05454405f, -0.09219063f, 0.12582341f, -0.07699423f, 
    0.04430460f, 0.05086805f, -0.00575291f, 0.03594140f, -0.30679396f, 0.13380279f, -0.17307851f, 0.14604972f, 
    -0.17645159f, 0.00287622f, 0.03996282f, 0.09483808f, -0.05617184f, 0.03417073f, -0.01979302f, 0.01445151f, 
    0.08240163f, 0.09222236f, 0.08370564f, -0.00316781f, -0.01569739f, 0.02236845f, 0.09188008f, -0.02975033f, 
    0.66307527f, -0.35051307f, 0.06458999f, 0.06707531f, 0.12798557f, 0.01015998f, -0.02824679f, 0.12662707f, 
    -0.03270457f, 0.09673055f, 0.27693132f, 0.08715577f, 0.06709250f, 0.09772115f, 0.07883110f, -0.05753180f, 
    -0.06480799f, -0.04517774f, -0.27935702f, -0.00361227f, -0.11323472f, -0.23677939f, 0.27658719f, -0.03225777f, 
    -0.17679287f, 0.02464054f, 0.25190741f, 0.01223671f, -0.06191604f, 0.00245305f, -0.00811611f, 0.02389470f, 
    0.03282114f, -0.05513940f, 0.02496519f, 0.06309351f, 0.03110050f, 0.07244316f, 0.07189663f, -0.07820123f, 
    0.22197831f, 0.01052874f, -0.03667023f, 0.35289729f, 0.24890025f, 0.02639412f, -0.00384717f, -0.03825088f, 
    0.00318510f, -0.10281444f, 0.15574089f, 0.03324703f, -0.04214690f, -0.03455691f, -0.16080883f, -0.07270546f, 
    0.02104783f, 0.18854913f, 0.17523968f, 0.11119645f, 0.23103356f, 0.35876936f, 0.05026316f, 0.26728192f, 
    -0.01983305f, -0.16771737f, -0.08664776f, 0.10205444f, -0.09462063f, 0.08146991f, -0.17341621f, 0.06825148f, 
    0.00895762f, 0.00267210f, 0.08542451f, -0.03252338f, 0.00877013f, 0.01828058f, -0.07794558f, 0.14128281f, 
    0.03880598f, 0.11325119f, 0.29836705f, 0.01811528f, 0.02687601f, -0.05039816f, -0.00126069f, -0.08200573f, 
    0.06034963f, -0.00831151f, 0.00909495f, -0.04412283f, -0.12121143f, 0.02189379f, -0.02833299f, 0.06705280f, 
    0.05919216f, -0.08642148f, -0.06673335f, 0.10484052f, 0.18652652f, 0.16708671f, 0.01787552f, -0.05510032f, 
    -0.11284652f, -0.00596612f, -0.01573713f, 0.00522330f, -0.15620710f, 0.05220995f, 0.02302790f, -0.00426145f, 
    -0.03148928f, -0.06276086f, -0.13880889f, 0.10062780f, -0.06932080f, -0.03323277f, -0.10329634f, -0.21289404f, 
    -0.52208507f, 0.48795000f, -0.04040330f, 0.05614784f, -0.06597929f, 0.18903673f, 0.08020043f, 0.02956753f, 
    0.07657397f, 0.01997359f, -0.14203176f, 0.00967936f, 0.21983916f, 0.09973330f, -0.00468994f, 0.06887833f, 
    0.08177105f, -0.00887133f, 0.18033721f, -0.14195667f, 0.01927555f, -0.30172935f, 0.00323103f, 0.42920902f, 
    0.22144958f, -0.29577708f, -0.06172742f, -0.02169768f, -0.11267322f, -0.02908558f, -0.00519903f, -0.12220576f, 
    -0.03430994f, 0.00611121f, 0.17585675f, 0.04180530f, -0.25006387f, -0.00097836f, 0.19117215f, 0.06620866f, 
    -0.38962832f, -0.19345991f, 0.12326685f, -0.03227630f, -0.20334332f, 0.04426334f, 0.11347105f, 0.07985334f, 
    0.00317691f, 0.02102356f, 0.00421974f, -0.02674638f, 0.05351522f, -0.04064559f, 0.02682770f, 0.18500458f, 
    -0.06164052f, -0.16523753f, -0.02586696f, -0.00042452f, 0.32964084f, -0.04738614f, 0.00181528f, -0.04439278f, 
    0.01066398f, -0.18252917f, 0.06930181f, -0.06066740f, 0.09585723f, 0.09428462f, 0.15052733f, -0.03669392f, 
    -0.11430925f, -0.06038589f, 0.03641184f, -0.08581563f, -0.04221733f, -0.16812818f, 0.05495638f, -0.01751013f, 
    0.11671025f, -0.01827382f, -0.04068005f, 0.24458434f, 0.14896125f, -0.04504367f, 0.07711770f, -0.02099811f, 
    0.09953130f, 0.07695126f, 0.03128674f, 0.05674688f, 0.01568906f, 0.07288744f, 0.06690055f, 0.06285226f, 
    -0.05280106f, 0.22171092f, 0.00297260f, 0.08734597f, -0.50771040f, 0.18462516f, 0.15730548f, -0.09614625f, 
    0.15654822f, 0.19528592f, 0.19567905f, 0.01356223f, 0.05195632f, -0.13183209f, -0.06166156f, -0.06396309f, 
    0.08091813f, 0.12771253f, -0.03838263f, -0.12844463f, -0.07695158f, 0.08379103f, 0.06177761f, -0.04898094f, 
    0.28307086f, 0.04903708f, -0.01552199f, 0.07734861f, -0.24430101f, -0.06409479f, 0.11665467f, 0.12389727f, 
    -0.04772916f, -0.01296083f, -0.14160657f, -0.00216442f, 0.03529532f, -0.06968005f, -0.01411623f, 0.03208160f, 
    -0.03623164f, -0.11249962f, -0.03187788f, 0.02181191f, -0.47623920f, 0.17701109f, -0.26947713f, 0.04885528f, 
    0.19868457f, 0.33590409f, 0.15304539f, 0.07816253f, 0.00070593f, 0.00574668f, 0.02854119f, 0.12191629f, 
    0.18075319f, 0.06338735f, 0.00857936f, 0.12113152f, 0.01468063f, -0.01733846f, 0.03377494f, -0.08300930f, 
    -0.05087663f, -0.03930744f, 0.28752357f, -0.05570741f, -0.08192735f, 0.00738505f, -0.00123615f, 0.18328436f, 
    0.08344638f, -0.03056324f, -0.02780459f, 0.04488061f, -0.00839456f, 0.00137069f, -0.14133763f, -0.03360765f, 
    0.20411500f, -0.00762073f, -0.17053460f, 0.06310697f, 0.15432240f, 0.14890471f, -0.38474387f, 0.16520467f, 
    -0.08671450f, 0.13942391f, -0.09996834f, 0.02722894f, -0.03380364f, 0.01134042f, 0.01537851f, 0.03628998f, 
    -0.07334258f, 0.02952492f, 0.04862848f, -0.15519376f, 0.03255192f, 0.17664547f, -0.15847349f, -0.11816701f, 
    -0.16234262f, 0.16436660f, 0.34984294f, -0.02604453f, -0.29545933f, 0.12853561f, -0.05482974f, 0.21356234f, 
    0.05965020f, -0.10172892f, 0.02583572f, -0.09507164f, 0.03258713f, 0.23973355f, -0.15256549f, 0.00197673f, 
    -0.07971209f, -0.02574465f, -0.15277907f, -0.08037707f, 0.49067238f, -0.12755269f, 0.26347157f, -0.02433459f, 
    -0.16995364f, -0.16838567f, 0.01437185f, 0.16313076f, 0.04441224f, 0.04940018f, 0.16537440f, 0.07436454f, 
    0.10428978f, -0.19412206f, 0.07119308f, 0.16297550f, 0.06339254f, -0.10298841f, -0.00123184f, 0.11029582f, 
    0.16370623f, 0.00633273f, -0.03334223f, 0.16430479f, -0.02193354f, 0.24759026f, -0.04111530f, -0.00733313f, 
    0.04563001f, 0.13686310f, 0.04551941f, 0.02972230f, 0.00444138f, 0.14469299f, -0.13779147f, 0.05170478f, 
    -0.10561727f, 0.11752016f, 0.17313540f, -0.10484275f, 0.20785925f, 0.31807867f, 0.12596227f, -0.05381962f, 
    0.33602852f, 0.21957481f, 0.10285238f, 0.16252874f, -0.01452407f, -0.00912408f, -0.03721628f, -0.03648483f, 
    0.08061971f, 0.04759453f, -0.08442222f, 0.20161629f, -0.01088908f, 0.10419567f, -0.05045010f, 0.03238511f, 
    0.04998212f, -0.08930682f, -0.02848235f, -0.00196529f, 0.11026534f, 0.05246285f, 0.07614445f, 0.17854138f, 
    0.11430909f, 0.01458358f, 0.13331662f, 0.06664240f, 0.06423691f, 0.06290674f, -0.13691154f, 0.14625804f, 
    0.00557700f, 0.06020553f, 0.00637496f, 0.08194425f, -0.64713979f, 0.14665000f, 0.22878002f, 0.28638858f, 
    0.16562620f, -0.01744777f, 0.01317945f, 0.16196562f, 0.15546499f, 0.20103560f, -0.06817863f, -0.10500594f, 
    0.05291745f, 0.11576048f, 0.02258807f, -0.03424904f, 0.18796934f, 0.10082156f, 0.07653301f, -0.13404381f, 
    0.18588668f, 0.21823049f, -0.17618711f, 0.17071958f, -0.13701747f, 0.00459326f, 0.09493282f, 0.10684139f, 
    0.08286837f, -0.14952059f, -0.07927679f, 0.17611197f, 0.01255001f, 0.07579926f, 0.06552316f, 0.00755093f, 
    -0.05769976f, -0.04184072f, -0.02011845f, 0.22403385f, 0.43861213f, 0.51658642f, -0.02465740f, 0.28628650f, 
    0.36755323f, 0.17021506f, 0.14713924f, 0.04720619f, 0.06456098f, 0.10284444f, -0.05455611f, -0.05073761f, 
    -0.11298793f, -0.00484102f, 0.02740600f, 0.10557047f, 0.19974674f, -0.00521653f, 0.20484181f, -0.08821155f, 
    -0.02884013f, -0.06194806f, 0.15994023f, -0.22401991f, -0.02334215f, 0.09215538f, -0.09529959f, 0.08292125f, 
    0.13179359f, 0.11943834f, -0.02209377f, -0.02193576f, -0.13323334f, 0.01825802f, -0.00798209f, -0.05653907f, 
    -0.01266831f, 0.11168772f, 0.02411975f, -0.13383630f, -0.17492615f, -0.19743374f, -0.13773344f, 0.04459362f, 
    -0.13972391f, 0.09958124f, 0.05910097f, 0.18634154f, 0.06525145f, -0.04415920f, -0.11243957f, -0.18075639f, 
    -0.06216201f, -0.10816274f, 0.15507755f, 0.13416070f, -0.03307681f, 0.01567331f, -0.10660063f, 0.12339006f, 
    0.24499400f, -0.20117588f, -0.33182004f, -0.00490916f, -0.03488383f, -0.14305687f, 0.07774963f, -0.12497213f, 
    0.01323572f, 0.10360521f, -0.02847557f, 0.07061672f, 0.10252234f, 0.13966121f, 0.03627877f, -0.02345385f, 
    0.03596996f, 0.22536518f, -0.06430089f, 0.01256120f, 0.19530991f, 0.07005053f, 0.03078259f, -0.15831220f, 
    -0.02178323f, -0.13640931f, -0.05565294f, 0.07317527f, 0.04846442f, -0.08840488f, 0.11222110f, 0.01616956f, 
    0.06498335f, -0.02111686f, 0.02406047f, -0.09875956f, 0.09736398f, 0.13958736f, 0.06306031f, 0.09274134f, 
    -0.27197224f, -0.28074262f, 0.24392994f, 0.14429152f, -0.20646486f, -0.02633381f, -0.14880785f, 0.09534715f, 
    0.00609325f, 0.07351678f, 0.03287149f, 0.03997587f, 0.03841471f, -0.00256783f, -0.03426633f, -0.03335849f, 
    0.07260118f, 0.04641517f, -0.03453083f, -0.06324449f, 0.12554140f, 0.23938097f, 0.02609825f, -0.21279810f, 
    -0.18749246f, -0.09319827f, 0.03527773f, 0.04322058f, 0.14253801f, -0.23571305f, -0.09565740f, 0.05746369f, 
    0.11275122f, 0.05984503f, 0.05081187f, -0.03145650f, 0.00756296f, -0.02720477f, 0.07999963f, 0.09749873f, 
    0.22857510f, -0.15149710f, 0.06661491f, -0.06192531f, -0.00872462f, -0.00545351f, 0.10095611f, 0.11756241f, 
    0.06681535f, 0.10745337f, 0.06737995f, 0.04726914f, 0.03435345f, 0.11081280f, -0.02555300f, 0.14212295f, 
    -0.09396340f, 0.20568906f, -0.00940861f, -0.02747003f, -0.00073155f, -0.34167361f, 0.01038175f, 0.03193714f, 
    0.26209769f, 0.10012715f, -0.11601949f, 0.05286257f, 0.08913589f, 0.18293788f, -0.03462368f, 0.09082081f, 
    0.04618823f, -0.03306662f, 0.02921469f, 0.01411953f, -0.09159241f, 0.14873308f, 0.03451613f, -0.03133659f, 
    0.07191528f, 0.30243731f, 0.18247627f, 0.04248851f, -0.15481117f, -0.00661271f, -0.01312673f, -0.11361460f, 
    0.31538704f, 0.02119917f, 0.01983929f, 0.12024723f, 0.06468891f, 0.01171482f, -0.00601518f, 0.11464863f, 
    0.00481774f, -0.00967813f, 0.06808361f, 0.11012359f, -0.23882523f, -0.08941084f, -0.21795718f, -0.30876917f, 
    -0.09907933f, 0.00646243f, -0.01002864f, 0.06172070f, 0.00250945f, -0.06809502f, -0.07886638f, 0.05579799f, 
    0.11422209f, 0.06670256f, 0.17238015f, 0.03501601f, -0.04012091f, 0.00722109f, -0.03527630f, 0.05333615f, 
    0.01427471f, 0.01355380f, -0.00937527f, -0.02311866f, 0.03421277f, 0.03202997f, 0.04041756f, 0.00775322f, 
    -0.02095859f, 0.04200892f, -0.03421268f, -0.05487313f, -0.00287492f, -0.01459325f, 0.00153338f, -0.00934737f, 
    -0.02150434f, 0.02434932f, -0.04295598f, -0.00083106f, 0.00545706f, -0.00092885f, -0.06025345f, 0.03789955f, 
    0.01929388f, 0.02785956f, 0.04031838f, -0.03603965f, -0.00778778f, 0.00965174f, -0.04238783f, 0.04214892f, 
    0.02847157f, -0.01075910f, 0.00135525f, 0.00746693f, -0.01775459f, -0.03292545f, 0.01046479f, -0.06264941f, 
    -0.00155619f, -0.01374002f, 0.02268339f, 0.01555524f, -0.01633288f, -0.06433890f, -0.04886115f, -0.02048038f, 
    -0.00392492f, 0.00029694f, 0.04033785f, 0.03820015f, 0.03867919f, -0.05579036f, 0.02549626f, 0.03622342f, 
    0.02100566f, -0.01388699f, 0.00189251f, 0.03250339f, -0.03380358f, 0.03241628f, 0.03610855f, -0.05370472f, 
    -0.02411856f, -0.03468581f, 0.01514554f, 0.04163759f, -0.02814546f, 0.02703346f, 0.03749450f, 0.02214934f, 
    -0.02603660f, 0.04488456f, -0.02181025f, 0.04278639f, 0.03782752f, -0.03795051f, 0.04141253f, 0.00294760f, 
    -0.00616251f, 0.02961710f, -0.01539472f, 0.04313578f, -0.02489990f, -0.05931680f, -0.06395954f, -0.02832937f, 
    0.00029184f, -0.03911334f, -0.04710086f, -0.01622712f, -0.00996323f, -0.01187242f, -0.03502570f, -0.05535343f, 
    0.03925815f, -0.00048787f, -0.01018168f, -0.04873208f, -0.01457799f, -0.05812030f, -0.06277719f, -0.02900146f, 
    -0.05586989f, -0.02738020f, 0.01983572f, 0.03964638f, 0.03261684f, 0.01880746f, -0.01505719f, 0.03796329f, 
    0.02735713f, -0.02407715f, 0.01572845f, -0.00480063f, -0.02018757f, -0.03075386f, -0.02032319f, -0.00664704f, 
    0.01063630f, 0.02641699f, 0.01428958f, -0.04123521f, -0.06177082f, 0.00919803f, -0.06412880f, -0.00603668f, 
    -0.00833988f, -0.03939729f, -0.05183308f, 0.03526302f, -0.03039951f, -0.02070565f, -0.03890402f, -0.05845634f, 
    -0.00697521f, -0.00202206f, -0.02187679f, -0.01218821f, 0.01303438f, -0.01926459f, 0.01806635f, 0.00364365f, 
    -0.05251660f, 0.01344312f, -0.02849689f, -0.00428706f, 0.00490296f, -0.05927256f, 0.01144471f, 0.03887960f, 
    0.02665638f, -0.01002357f, 0.02494453f, -0.02515035f, -0.04929219f, 0.00819459f, 0.01176562f, 0.00933551f, 
    0.04133210f, 0.00197089f, -0.00544316f, 0.04084326f, 0.00783125f, -0.06355231f, -0.05560068f, 0.00795123f, 
    -0.04651068f, -0.04110003f, 0.01402674f, 0.02282091f, -0.05019577f, 0.03946324f, 0.02041617f, 0.01691963f, 
    0.03659718f, -0.05509830f, 0.02449821f, -0.04426986f, 0.04368971f, -0.03663619f, -0.01803580f, -0.06345122f, 
    -0.06393244f, 0.03253445f, -0.01088693f, 0.03440115f, -0.05586343f, -0.02649206f, 0.01100856f, 0.00081761f, 
    -0.02497781f, -0.06371900f, -0.05820133f, -0.06242627f, -0.04947978f, 0.00916602f, -0.01248099f, -0.01954787f, 
    -0.01682859f, 0.02989070f, -0.06256551f, -0.04469477f, -0.02509786f, -0.00089667f, -0.05177901f, 0.01742222f, 
    0.04217183f, 0.01812380f, 0.03390823f, -0.04908824f, 0.03095623f, -0.02449106f, 0.00496606f, 0.00707603f, 
    -0.00372538f, 0.01212521f, 0.04445627f, -0.06009978f, -0.00759165f, 0.03407436f, 0.04085670f, 0.02955205f, 
    -0.01850758f, 0.03514474f, -0.04708045f, 0.03944720f, -0.04306303f, 0.04154658f, 0.04408891f, -0.01982218f, 
    0.01850053f, 0.01660694f, -0.02774215f, 0.04186935f, -0.01389387f, -0.01678310f, -0.01930909f, 0.03661695f, 
    0.04209031f, -0.01356902f, 0.04248245f, 0.04581283f, 0.03415215f, 0.00837943f, -0.02870543f, -0.01234335f, 
    -0.05108495f, 0.01129056f, -0.04986107f, -0.02800449f, -0.01067969f, 0.00297962f, 0.04731320f, -0.03602482f, 
    -0.02305630f, -0.04849600f, 0.00528683f, -0.00018246f, -0.04373167f, -0.05518934f, -0.02745118f, 0.02693404f, 
    0.02571396f, -0.03080933f, -0.02951874f, 0.00391306f, -0.06252506f, -0.04534055f, -0.05097367f, 0.03299252f, 
    -0.03977188f, -0.03963779f, -0.03561281f, 0.00401601f, -0.03406314f, -0.06425551f, -0.04209850f, 0.03456777f, 
    0.03807671f, 0.03778952f, -0.02330105f, 0.01773911f, -0.04359850f, -0.03859225f, -0.05494538f, 0.03011296f, 
    0.02126579f, 0.03546989f, -0.03542242f, -0.04464190f, -0.03520904f, -0.01806118f, 0.00606701f, -0.00058525f, 
    -0.01604759f, -0.03514245f, -0.04640487f, -0.00143381f, -0.03910576f, -0.00607363f, -0.01433184f, -0.04123023f, 
    -0.02635736f, 0.04396234f, -0.00205681f, 0.00932949f, -0.03513724f, -0.04722081f, -0.02401248f, -0.05447961f, 
    -0.02863954f, 0.01764430f, -0.01849812f, -0.05330940f, 0.00736432f, -0.01181813f, 0.02458487f, -0.02194087f, 
    -0.14695659f, -0.18945178f, 0.03103552f, -0.03644049f, 0.12001095f, 0.14352231f, 0.03827822f, 0.06189588f, 
    0.08379295f, 0.10473406f, -0.12215430f, -0.10057086f, 0.07653771f, 0.13798441f, 0.14474063f, 0.07303797f, 
    0.05639978f, -0.28470859f, -0.00927048f, -0.16710062f, -0.05715808f, -0.23048504f, 0.34740809f, 0.01151802f, 
    -0.03633277f, -0.06687507f, -0.13973109f, -0.14029597f, 0.02845990f, -0.07623287f, 0.01182967f, -0.12421876f, 
    0.04680141f, 0.19162184f, -0.09600818f, -0.07109512f, 0.03873225f, -0.16252552f, -0.02767123f, -0.12101090f, 
    -0.02249719f, -0.14797328f, -0.05264410f, -0.01219890f, 0.01061242f, 0.00556589f, 0.05295459f, 0.00080956f, 
    0.04336518f, -0.00606602f, 0.09223434f, 0.08038460f, 0.05372125f, -0.02051047f, -0.04060483f, 0.08473517f, 
    0.01950314f, -0.02263307f, 0.01796347f, -0.10457615f, -0.26456046f, 0.02677286f, 0.15862122f, 0.08491557f, 
    0.39784873f, 0.04839772f, -0.03143683f, -0.08899022f, 0.07175063f, -0.13885403f, 0.02481706f, -0.06096534f, 
    0.12436254f, 0.06990682f, 0.16556133f, 0.01079132f, 0.15971692f, 0.02056781f, -0.06140698f, -0.04160585f, 
    0.09685860f, -0.23390007f, -0.09307704f, -0.27258307f, 0.15388446f, -0.05617655f, 0.06066272f, -0.05676415f, 
    -0.14381994f, -0.16935183f, 0.07102072f, -0.10581356f, -0.02099215f, -0.04187087f, -0.04906341f, -0.03197156f, 
    -0.02011050f, -0.06355097f, -0.11654967f, 0.11609174f, 0.05404810f, -0.11811539f, 0.21770751f, -0.24487269f, 
    -0.26276594f, 0.00279806f, -0.14594477f, -0.00266665f, 0.09047206f, 0.10592389f, 0.06951661f, 0.13306379f, 
    0.05570407f, 0.20868161f, 0.05024783f, -0.06772280f, 0.00867746f, -0.15812077f, -0.03563342f, 0.06821187f, 
    0.27393222f, 0.02370384f, -0.22156721f, 0.05465727f, 0.27370825f, -0.01779124f, 0.06098877f, 0.09634886f, 
    0.00921640f, -0.01444878f, 0.12955500f, 0.15338239f, -0.11864945f, -0.13091515f, 0.07270451f, -0.09349050f, 
    0.18636245f, 0.15278436f, 0.01992244f, 0.02936608f, -0.20909470f, 0.31720489f, 0.35632801f, -0.06339917f, 
    -0.12679954f, -0.02740015f, -0.04093824f, -0.14315647f, -0.02167936f, 0.26322654f, -0.00624738f, -0.01626791f, 
    0.07496087f, 0.18378147f, 0.10109595f, 0.22406098f, 0.02774444f, 0.01113485f, 0.00060574f, 0.04062598f, 
    0.02488700f, -0.10652082f, 0.02794392f, 0.01333549f, 0.02503751f, 0.15895933f, 0.25504088f, 0.25527522f, 
    -0.03473976f, -0.03042335f, 0.11236873f, 0.06409919f, 0.04451847f, -0.01373875f, -0.01130589f, 0.09950280f, 
    0.10474983f, -0.21122395f, 0.01757511f, 0.06712246f, 0.04856484f, 0.03914869f, -0.29890651f, 0.11269717f, 
    -0.12490001f, 0.06476662f, 0.16126351f, 0.13204737f, -0.00420961f, 0.04237937f, 0.00233960f, 0.04559576f, 
    -0.10523751f, -0.10130773f, 0.05018768f, 0.00051612f, -0.00267474f, -0.05482395f, -0.13262309f, 0.11222485f, 
    -0.30366176f, 0.18766120f, 0.08954339f, 0.00573201f, 0.14913854f, -0.09068702f, -0.13203512f, -0.01785647f, 
    -0.14083251f, 0.14475204f, -0.04363092f, 0.02789692f, 0.09429201f, -0.04989585f, 0.10663433f, 0.01456643f, 
    -0.01876776f, 0.19494331f, -0.06371589f, -0.02188407f, 0.07439345f, 0.18178555f, -0.17925578f, -0.23498528f, 
    -0.31577379f, 0.07808793f, 0.16085699f, 0.00848889f, 0.17263213f, -0.11479069f, 0.16785224f, 0.07155367f, 
    -0.08245534f, 0.07852080f, 0.00570057f, 0.05966923f, 0.17109896f, -0.10089166f, -0.06563052f, 0.05644095f, 
    -0.17566733f, -0.05129205f, 0.11247446f, 0.13602237f, 0.19618623f, -0.15544987f, 0.09201169f, -0.00890226f, 
    0.02011021f, -0.08245073f, 0.26512685f, -0.02326360f, 0.09835312f, -0.07152899f, 0.01620209f, 0.00476102f, 
    0.02605888f, -0.05585021f, 0.10295269f, -0.01397302f, 0.06062449f, -0.70382416f, 0.07370455f, -0.04416111f, 
    0.27829096f, -0.00226967f, 0.11944109f, 0.25420788f, -0.06255630f, 0.07925288f, -0.02650862f, -0.01445717f, 
    0.07317396f, 0.01871347f, -0.00742758f, 0.05640759f, 0.05962624f, -0.13275529f, 0.16129528f, 0.08454863f, 
    0.13142441f, -0.41437289f, -0.09365405f, -0.01846271f, 0.38518196f, -0.00537803f, 0.24248594f, -0.03512175f, 
    -0.01062674f, 0.08314651f, 0.06146082f, 0.09672244f, 0.09845837f, -0.20336130f, 0.15943743f, 0.05543450f, 
    -0.00428443f, 0.17312586f, -0.08770737f, 0.03987568f, -0.07700024f, 0.53789228f, 0.13071868f, 0.08127116f, 
    0.12143717f, -0.05019720f, -0.08804006f, -0.15440074f, 0.07073469f, 0.17008780f, -0.01380290f, 0.07511534f, 
    0.01026056f, 0.22557616f, 0.00453929f, -0.02011783f, 0.13519219f, 0.03409187f, 0.06595285f, -0.02751963f, 
    -0.04334224f, -0.01342688f, -0.04545898f, 0.04959672f, -0.01970365f, 0.00909891f, -0.01097282f, -0.05442587f, 
    0.01374243f, -0.02781516f, 0.01332470f, -0.01053667f, 0.01087081f, 0.01215330f, -0.03980711f, -0.04846431f, 
    0.03971408f, -0.01319735f, -0.04498233f, 0.01322736f, -0.02955043f, -0.00589047f, 0.03310972f, 0.02281371f, 
    -0.06388423f, 0.00958556f, 0.02659576f, -0.03797062f, 0.00862734f, -0.02231784f, -0.06079949f, 0.00673050f, 
    -0.04689390f, -0.02239089f, -0.00331537f, -0.00653541f, 0.05372299f, -0.01336882f, -0.04158277f, 0.05352874f, 
    0.02384949f, -0.02190320f, 0.04209605f, -0.01297434f, -0.04566556f, 0.03124930f, 0.03751994f, 0.03821336f, 
    -0.01476017f, -0.02182920f, -0.01369534f, -0.01349353f, -0.05674560f, -0.00889937f, 0.00171627f, 0.01049736f, 
    0.03113889f, -0.05828456f, 0.00360444f, 0.04549825f, -0.02905194f, -0.03432062f, 0.03547212f, -0.03494418f, 
    0.00924002f, -0.01612801f, -0.03065904f, -0.01581860f, -0.03994062f, -0.03200831f, -0.02779000f, 0.03868143f, 
    0.04458881f, -0.05974301f, 0.00200093f, -0.03360363f, 0.01875676f, -0.05304355f, 0.02652953f, -0.06212721f, 
    -0.03947908f, 0.03933092f, 0.05207901f, -0.05408882f, 0.00146516f, 0.01925617f, 0.02485330f, -0.05057928f, 
    0.01185639f, 0.01199858f, 0.03022300f, 0.02683290f, -0.03961036f, -0.01292927f, 0.03633936f, 0.01941595f, 
    -0.02046677f, 0.03461549f, -0.02072239f, -0.01797680f, -0.05420927f, -0.01223298f, -0.04757041f, -0.05837307f, 
    -0.05100086f, -0.03131340f, -0.03948770f, 0.05312117f, -0.04534948f, -0.04636832f, -0.03398187f, 0.05817395f, 
    -0.01251518f, -0.04897035f, 0.04388419f, -0.02137594f, -0.02806229f, 0.01708190f, 0.04141793f, 0.00399991f, 
    0.04755231f, -0.00286116f, 0.02218221f, 0.00775800f, -0.00616924f, 0.03853503f, 0.00610322f, -0.03869652f, 
    0.02417675f, 0.04277604f, 0.02024594f, -0.06200877f, -0.03730820f, 0.02326576f, 0.01963620f, -0.04316589f, 
    0.02074922f, 0.00455791f, 0.01566777f, 0.01349266f, -0.02535200f, 0.03121558f, 0.00677997f, -0.03855926f, 
    -0.01081554f, 0.04247143f, 0.02004207f, -0.00438317f, 0.02926017f, -0.00888407f, 0.00254251f, -0.03835972f, 
    0.02223974f, -0.02331365f, -0.05353097f, 0.00157760f, 0.02129696f, -0.01366902f, 0.02465979f, 0.01434503f, 
    0.03118560f, -0.06217115f, -0.01677378f, 0.00533810f, -0.03883593f, -0.04343611f, -0.03805653f, -0.00359744f, 
    0.03406473f, -0.05295363f, -0.01963868f, 0.01010770f, -0.00673028f, 0.02276628f, -0.05238039f, 0.03944323f, 
    -0.04236981f, -0.04665178f, 0.02401922f, -0.03116281f, 0.02280830f, 0.04270271f, 0.01907604f, -0.05297131f, 
    -0.02930907f, -0.00841697f, 0.04053960f, -0.04456017f, -0.04603378f, 0.01993814f, 0.00172389f, 0.04935303f, 
    -0.02553771f, -0.05366025f, 0.04990072f, -0.00082789f, -0.03537282f, -0.01906629f, -0.05143966f, 0.01780101f, 
    0.01841082f, -0.01272526f, -0.00717206f, -0.04688646f, -0.04692943f, -0.01209984f, -0.03443046f, 0.02152496f, 
    -0.02976806f, -0.01599138f, 0.03100260f, -0.05158832f, 0.02615634f, 0.03466674f, -0.01099830f, -0.02929963f, 
    -0.03741187f, -0.06317472f, -0.04912749f, 0.02075510f, -0.01843797f, -0.05277479f, -0.05859967f, 0.03604184f, 
    0.03590621f, -0.04759828f, 0.02790096f, 0.01864296f, 0.04078280f, 0.04001804f, 0.00248427f, 0.03148386f, 
    -0.00543496f, -0.04950120f, -0.02349925f, -0.05714345f, -0.03886028f, -0.02139638f, -0.04777149f, -0.05387682f, 
    -0.05024380f, -0.01598963f, 0.05371600f, -0.03843780f, 0.01383825f, -0.03841313f, -0.05509662f, -0.05389680f, 
    0.03654469f, -0.04776383f, -0.06274297f, 0.02193757f, -0.00608652f, -0.00847383f, -0.04956365f, -0.00489207f, 
    -0.03385326f, 0.03358001f, -0.03927995f, 0.05349842f, -0.01988264f, 0.03874756f, -0.04139217f, -0.02114621f, 
    -0.03892195f, 0.02118498f, -0.05014055f, 0.04843670f, 0.00301889f, -0.02083724f, -0.00584422f, -0.06226534f, 
    0.03481204f, -0.00290508f, -0.05101257f, -0.01986333f, 0.01646855f, -0.03740446f, -0.01271544f, 0.04635213f, 
    -0.03422102f, -0.03949190f, 0.04418150f, 0.01008475f, -0.00157334f, -0.00945134f, 0.04733977f, 0.01282687f, 
    -0.02333788f, -0.04017557f, -0.01180140f, -0.03688815f, -0.04452824f, -0.04060020f, -0.04202195f, 0.00779999f, 
    0.05677778f, -0.04853150f, 0.03737194f, -0.00811907f, 0.00454223f, 0.04614330f, -0.00317423f, -0.00076801f, 
    0.01437571f, 0.03153440f, -0.03511959f, -0.04269590f, -0.04280347f, -0.03758669f, -0.01048077f, -0.04613062f, 
    -0.01000797f, -0.03752949f, -0.00155956f, -0.05147636f, 0.02355538f, 0.00131371f, 0.01968210f, 0.02545742f, 
    0.63710207f, 0.51724845f, 0.19891004f, -0.09609325f, 0.21353319f, 0.08657351f, 0.14626190f, -0.02495465f, 
    -0.19891657f, 0.17563538f, -0.04852280f, -0.07686213f, 0.10725000f, -0.07003418f, -0.04154856f, 0.20673014f, 
    0.02217990f, 0.11520889f, -0.11525119f, 0.14644778f, -0.45469150f, 0.03238192f, -0.15341404f, -0.04372885f, 
    -0.14553665f, 0.12582751f, 0.22138983f, 0.04475072f, -0.03074661f, 0.02585087f, -0.01883257f, -0.00141581f, 
    -0.03363165f, -0.02904123f, -0.13052377f, -0.14739865f, -0.00958037f, -0.05020443f, 0.04589668f, -0.04230495f, 
    -0.64107841f, 0.27697849f, -0.12150496f, 0.02326358f, -0.25463307f, 0.02522873f, -0.09348393f, -0.06221868f, 
    0.04822045f, -0.04518249f, -0.00479235f, 0.07808368f, -0.00017024f, 0.00894723f, -0.09988492f, -0.08057490f, 
    0.07796207f, 0.05719686f, 0.04206947f, 0.06621971f, 0.22791871f, -0.37856868f, -0.08904847f, -0.06115479f, 
    0.19014889f, 0.03025269f, 0.06866049f, -0.01471255f, 0.08067492f, -0.09589056f, 0.05347153f, 0.16580033f, 
    -0.11844062f, 0.04392609f, -0.17307658f, -0.12481427f, 0.21600942f, 0.17181867f, 0.15517770f, 0.19053553f, 
    0.63399726f, -0.25792798f, 0.26983866f, 0.07656594f, 0.37882704f, -0.14932449f, 0.05508170f, 0.21040073f, 
    0.17828310f, -0.06978770f, -0.08450285f, 0.06362780f, -0.01178115f, 0.10343724f, 0.06603801f, -0.06868550f, 
    0.14865267f, 0.00056404f, -0.03566543f, -0.01631895f, -0.00947229f, 0.20451291f, 0.10915224f, -0.13226786f, 
    -0.14930575f, 0.24121383f, 0.16953157f, 0.02884668f, -0.12248877f, 0.14532882f, -0.15656520f, -0.03538845f, 
    0.00576791f, 0.00488960f, -0.19110797f, 0.03848514f, 0.23189177f, -0.11335526f, -0.11586913f, -0.04355012f, 
    -0.16358097f, 0.23343949f, -0.09256408f, 0.05307388f, -0.06967837f, -0.11465251f, -0.14020072f, -0.20321134f, 
    0.07580883f, -0.08170556f, 0.07966412f, 0.14227438f, 0.10338138f, 0.01639290f, -0.00385544f, -0.00588735f, 
    0.06610484f, -0.03210163f, -0.02078042f, 0.14843330f, -0.55087763f, -0.29539701f, -0.22093745f, 0.18032931f, 
    -0.13674165f, 0.02865405f, 0.15493083f, 0.14182791f, -0.12352952f, 0.03184768f, -0.15481508f, -0.14274359f, 
    -0.07953253f, 0.01850922f, 0.01600960f, 0.24715571f, 0.05497450f, 0.00442770f, -0.01627326f, -0.06497372f, 
    0.04340304f, 0.57371682f, 0.21551019f, 0.02778452f, 0.24103257f, 0.14366549f, -0.00491536f, 0.09444238f, 
    -0.12194464f, 0.07944522f, -0.12852542f, -0.02879506f, 0.03699600f, -0.09718224f, -0.05901807f, 0.00036187f, 
    0.05998255f, 0.02415564f, 0.13124573f, -0.05849345f, 0.09028750f, 0.21823689f, 0.23890477f, 0.10733715f, 
    0.30228603f, -0.04691141f, 0.11528058f, -0.03101676f, -0.04584367f, 0.19706480f, 0.06483797f, 0.05198959f, 
    -0.00738433f, 0.06219240f, -0.00928667f, 0.01721960f, 0.02573957f, 0.05636216f, 0.12012766f, 0.03121382f, 
    -0.22996081f, -0.12626171f, -0.03451645f, -0.03921944f, -0.08991516f, 0.16136841f, -0.03093646f, -0.12825029f, 
    0.07100000f, -0.04870248f, 0.01481442f, -0.00019564f, -0.06623831f, -0.00317382f, 0.11450064f, -0.00226133f, 
    -0.11977968f, 0.00767813f, 0.10291775f, -0.01659011f, 0.50304538f, -0.17889190f, 0.37890196f, 0.11989554f, 
    0.24331123f, -0.15303500f, -0.02407737f, 0.03298283f, -0.05073893f, 0.14421442f, -0.04692084f, 0.02637449f, 
    0.05593827f, 0.04077731f, -0.04128526f, -0.12086052f, -0.00658255f, 0.06183954f, 0.02019065f, -0.24300878f, 
    -0.67014271f, 0.19886774f, -0.15094636f, 0.08881420f, -0.17518345f, 0.22352393f, -0.02316974f, -0.15957980f, 
    0.08365843f, -0.03944726f, -0.06641630f, -0.07000899f, 0.02977233f, 0.09459470f, 0.01391436f, 0.00682809f, 
    -0.18334347f, 0.01124816f, 0.02630461f, 0.15000518f, 0.08427593f, 0.68246549f, 0.00932043f, 0.04123541f, 
    0.14761233f, -0.08453862f, 0.22294793f, -0.12850834f, -0.02977524f, 0.02462976f, 0.18702824f, -0.10343429f, 
    0.07211672f, -0.02018063f, 0.00655175f, -0.03121790f, 0.02110674f, 0.13812344f, 0.03573684f, 0.08931942f, 
    0.39461115f, -0.41250378f, 0.04576281f, 0.32039505f, 0.07231500f, -0.01287688f, -0.02884330f, -0.05112746f, 
    0.06848907f, -0.03177807f, 0.12014793f, 0.12100988f, -0.05807392f, 0.10144928f, -0.08372220f, -0.00216070f, 
    0.06912278f, -0.06986509f, -0.05958784f, 0.17202172f, -0.72013485f, -0.39518791f, -0.14480142f, -0.02344188f, 
    -0.31780422f, 0.17803155f, 0.03138654f, 0.01138934f, -0.10368351f, -0.08629733f, -0.18697266f, -0.06673933f, 
    -0.15882124f, 0.11532872f, -0.04736880f, -0.01451455f, 0.07313190f, 0.04574580f, -0.07189266f, -0.07098665f, 
    -0.02033226f, 0.06248169f, -0.03481729f, -0.09471022f, -0.07719508f, -0.13996240f, -0.00669416f, 0.03640283f, 
    0.03049719f, -0.21881714f, 0.18805110f, 0.10526463f, -0.10317618f, -0.14337495f, 0.05627969f, 0.06827341f, 
    0.16208759f, -0.05695579f, -0.08149122f, 0.24870098f, -0.36687163f, -0.34423038f, -0.12243583f, 0.05949759f, 
    -0.04349022f, 0.09704948f, 0.01405104f, 0.03566242f, -0.18010481f, -0.09776209f, 0.11980570f, 0.09674725f, 
    -0.01868358f, -0.06738520f, 0.08855673f, -0.00333140f, 0.03944477f, -0.11654685f, 0.00901404f, 0.00389092f, 
    -0.07517848f, -0.17436458f, -0.08109280f, -0.00718305f, 0.03256939f, 0.02743336f, 0.05942239f, 0.04577548f, 
    -0.06111945f, -0.03377384f, 0.06043354f, 0.05477227f, 0.05026447f, 0.05351120f, 0.09881660f, 0.07104927f, 
    0.00186411f, 0.07328656f, 0.05536918f, -0.01322994f, 0.25721332f, -0.04062831f, -0.36357647f, -0.13021985f, 
    -0.17428114f, 0.12916286f, 0.14990534f, 0.16168591f, -0.11543488f, 0.03257286f, 0.04154156f, 0.06500866f, 
    0.09396378f, 0.01253527f, 0.09452806f, 0.03621219f, -0.03180974f, 0.03616794f, 0.06513049f, 0.13078988f, 
    -0.52952796f, 0.19397281f, -0.06228214f, 0.09390738f, 0.12816714f, 0.08375417f, -0.09422015f, 0.15782532f, 
    0.04017558f, 0.18926038f, 0.08376380f, -0.04989991f, 0.00881730f, -0.05213057f, 0.10944895f, -0.09267935f, 
    0.16930990f, 0.16269633f, 0.13225563f, -0.10693639f, 0.23469281f, -0.10774092f, 0.20050935f, -0.19798063f, 
    -0.15198563f, -0.05837255f, 0.07142433f, -0.03881463f, -0.11869531f, -0.08500288f, 0.10206194f, 0.04246740f, 
    0.17859764f, -0.00836189f, 0.07925157f, 0.18786573f, -0.05947510f, 0.02177287f, -0.05427966f, 0.11656895f, 
    -0.09082182f, -0.04655576f, -0.04983841f, 0.09077678f, -0.06602247f, 0.08316896f, 0.16596058f, 0.18866715f, 
    0.01773481f, 0.14316767f, 0.00355542f, -0.12998059f, 0.10588317f, 0.07198336f, -0.03606252f, 0.07747692f, 
    0.01523402f, -0.02389457f, 0.01879293f, 0.10005402f, 0.02336380f, -0.31684572f, -0.12068626f, -0.19298641f, 
    0.10908004f, 0.05603413f, 0.08094984f, -0.22377624f, -0.07281566f, -0.02853156f, 0.22270761f, 0.27498600f, 
    -0.07158919f, 0.11009435f, 0.10025497f, -0.06736368f, 0.06874638f, 0.01122539f, 0.01387735f, 0.06906558f, 
    0.21461098f, 0.01316696f, 0.10827733f, -0.02459939f, -0.07752305f, 0.09363754f, -0.19015834f, -0.04283031f, 
    -0.05455540f, -0.03220096f, 0.13932881f, 0.07686233f, -0.02645972f, 0.06598590f, 0.04947080f, -0.00735401f, 
    -0.19209616f, -0.05457410f, 0.06436646f, 0.06717969f, 0.23650390f, 0.04606488f, 0.09151557f, 0.19934401f, 
    -0.11773153f, -0.03764423f, -0.10391024f, 0.01839827f, -0.03744065f, 0.10814572f, -0.05343196f, -0.02060115f, 
    -0.00082072f, -0.05761930f, -0.03848541f, 0.11902864f, 0.08449958f, 0.04017141f, 0.04743554f, 0.04580943f, 
    0.00854867f, 0.32142419f, -0.40272751f, -0.20604232f, 0.29042953f, 0.15833025f, 0.25284067f, -0.14459264f, 
    0.13869283f, 0.06067580f, -0.08866765f, 0.05246809f, -0.07366517f, 0.16578148f, 0.02613881f, -0.02133334f, 
    0.06236162f, -0.07538522f, 0.07120288f, 0.12611119f, -0.03617231f, 0.11064947f, 0.18709072f, 0.38312384f, 
    0.37447128f, -0.04403003f, -0.29593059f, 0.02224776f, 0.02481214f, 0.11824428f, 0.04348284f, -0.08823147f, 
    -0.02319431f, -0.04054466f, 0.08810022f, -0.08979031f, -0.04893136f, 0.02357656f, 0.06227992f, 0.05620767f, 
    -0.00591385f, -0.13700703f, -0.13400945f, 0.09151468f, -0.26229736f, 0.18886885f, 0.06350194f, -0.03119612f, 
    -0.02087475f, -0.03508324f, 0.02181725f, -0.04722912f, 0.04568446f, -0.04190464f, 0.07006461f, -0.13256311f, 
    0.10033963f, -0.07809692f, -0.00492807f, -0.14555971f, -0.30344436f, 0.58105129f, -0.15030418f, 0.11457138f, 
    -0.27234602f, 0.09140861f, -0.04323926f, -0.00388845f, -0.10452391f, 0.00430265f, 0.21604723f, -0.02086956f, 
    -0.05283268f, 0.10442540f, 0.03691738f, -0.00584606f, 0.16348200f, -0.02046294f, 0.05265212f, 0.11522073f, 
    -0.10577416f, 0.17681630f, -0.24683341f, 0.08789385f, -0.01010517f, -0.10599827f, -0.17218934f, -0.00329533f, 
    -0.02207933f, 0.14363450f, 0.02747535f, 0.00861868f, 0.01117685f, -0.06653281f, 0.28384942f, -0.04508979f, 
    0.12044486f, -0.07222100f, -0.12117226f, 0.04645948f, 0.11841882f, -0.44922253f, -0.07158142f, 0.00217918f, 
    -0.10956113f, 0.21163608f, 0.09601851f, -0.03186903f, -0.06467298f, 0.12768216f, 0.12519279f, 0.06465442f, 
    0.02039533f, 0.02105808f, -0.00775909f, -0.05114336f, -0.04424371f, 0.05246692f, 0.01414255f, 0.07736869f, 
    0.18919396f, 0.36767223f, -0.10086790f, -0.04814735f, 0.08604442f, 0.03442743f, -0.12276273f, -0.02424479f, 
    -0.16224356f, 0.13892536f, 0.05482943f, 0.00539427f, 0.06976242f, -0.11349401f, -0.19718039f, 0.04876693f, 
    -0.06072960f, 0.12380742f, 0.01149291f, -0.05727020f, 0.09138049f, 0.15190448f, -0.17526691f, 0.21601705f, 
    0.03653184f, 0.09369408f, 0.18827341f, -0.04995603f, -0.04360226f, 0.01657378f, 0.09998861f, 0.09293264f, 
    -0.04654416f, 0.08194242f, 0.05610288f, 0.11010855f, -0.08738001f, -0.01970246f, -0.17052025f, 0.12684762f, 
    -0.03147870f, 0.02513251f, -0.14155394f, 0.29213566f, -0.22272959f, -0.01268374f, -0.08682821f, -0.10093098f, 
    0.02384305f, -0.03072466f, -0.05722971f, -0.04959355f, -0.08434003f, 0.05044492f, 0.02894382f, -0.07109794f, 
    0.07151874f, -0.16475257f, 0.10440104f, -0.06574379f, 0.09654225f, 0.17310202f, -0.21144028f, 0.04003027f, 
    0.04005364f, 0.12050638f, 0.14451747f, -0.06617145f, -0.19338748f, 0.06106514f, 0.03264857f, 0.04609767f, 
    -0.07529027f, -0.05139937f, -0.18986480f, -0.04071356f, 0.01809619f, 0.04713526f, 0.06399675f, 0.13569210f, 
    0.04211520f, -0.02821970f, 0.30265552f, -0.05861936f, 0.24423625f, 0.15246141f, -0.00830307f, 0.12468579f, 
    0.05766273f, -0.01414867f, -0.06534663f, 0.12297770f, 0.00474717f, 0.04104669f, 0.03786029f, -0.01766612f, 
    0.06522400f, 0.00126421f, -0.00203293f, 0.20737652f, -0.06615516f, 0.15386604f, -0.26042706f, 0.27578172f, 
    0.45322636f, 0.17432927f, 0.09656122f, 0.10208447f, -0.01379448f, -0.08909713f, -0.06146585f, -0.10344934f, 
    -0.06554312f, 0.07382645f, 0.03064856f, 0.07065821f, 0.02402423f, 0.11889490f, -0.13067374f, -0.05120637f, 
    -0.11214725f, 0.07215603f, -0.17613818f, 0.12726644f, -0.14527071f, -0.09724462f, -0.00675144f, -0.12578718f, 
    -0.06260313f, 0.09950928f, 0.04556668f, -0.07050209f, -0.00284101f, -0.00996818f, -0.05407349f, 0.06231791f, 
    0.02093702f, -0.03343153f, 0.13644372f, -0.08396723f, -0.16541496f, -0.03020569f, -0.03723091f, 0.33340320f, 
    0.37288338f, 0.10340124f, 0.09354559f, 0.09210726f, 0.07565843f, -0.06182951f, -0.16766359f, 0.03752752f, 
    0.06825607f, -0.14315069f, 0.01706715f, -0.02035597f, 0.06008911f, 0.24533224f, 0.01153090f, -0.03652716f, 
    0.06134386f, 0.39211819f, -0.08863290f, -0.04551569f, -0.05681784f, -0.20970632f, -0.09163550f, -0.10530952f, 
    0.09141966f, 0.13014536f, -0.00924554f, 0.01936929f, 0.07154005f, -0.08773246f, -0.02662581f, -0.03149550f, 
    0.11865930f, -0.00592029f, 0.11919674f, -0.00160179f, -0.19415016f, 0.14941067f, 0.34713271f, -0.11381370f, 
    -0.03353619f, -0.08141819f, -0.00689524f, -0.01955362f, 0.01299713f, -0.13042887f, 0.01650527f, -0.15366207f, 
    0.18325411f, 0.08235161f, -0.03609199f, 0.02789603f, 0.00996922f, -0.05078199f, 0.00842663f, -0.12524815f, 
    0.23345649f, -0.03600475f, 0.14956619f, 0.13545942f, -0.06373902f, 0.07411422f, -0.02125676f, -0.01357949f, 
    0.05471032f, 0.06003352f, -0.05617872f, 0.08723586f, 0.00883500f, -0.10245253f, 0.00289788f, 0.07105763f, 
    0.04148694f, 0.09354199f, 0.13116701f, 0.00263658f, -0.06699882f, -0.19183214f, 0.16333689f, -0.15338589f, 
    0.16121636f, -0.19764465f, 0.04047611f, 0.07520772f, -0.04613082f, 0.00078597f, -0.01873746f, -0.01811286f, 
    -0.00684464f, -0.06411270f, 0.05071205f, -0.09265311f, 0.11283594f, 0.06038380f, -0.04063075f, 0.02799908f, 
    -0.00832149f, 0.07063439f, -0.25394771f, 0.14109811f, -0.28177688f, -0.01108078f, -0.00168746f, -0.02351540f, 
    -0.04182939f, 0.09038606f, -0.15094543f, -0.01231775f, 0.14063028f, 0.16262399f, -0.06465120f, 0.13148691f, 
    0.05539825f, -0.20511340f, 0.19181924f, -0.04880891f, 0.15591840f, 0.31275252f, -0.02066929f, -0.04476491f, 
    0.10577033f, -0.14376603f, 0.04328583f, -0.18148080f, 0.08203744f, 0.09430344f, 0.14211568f, -0.05813461f, 
    -0.01533420f, -0.00797992f, -0.12209016f, -0.05257755f, -0.00348647f, 0.08312871f, -0.02480111f, -0.00841777f, 
    -0.55409825f, 0.27226934f, -0.01106343f, 0.15967900f, -0.16145673f, 0.00703205f, -0.05205736f, -0.10942737f, 
    0.01708524f, 0.05088116f, -0.01812052f, 0.03301570f, -0.07580408f, 0.19406471f, -0.11228748f, -0.04012686f, 
    0.02514037f, -0.09946761f, 0.03064546f, -0.04319471f, -0.18948545f, 0.00167172f, -0.20391107f, 0.12791602f, 
    -0.00086342f, 0.08886116f, -0.06295116f, 0.13608482f, -0.02416311f, -0.05237680f, 0.04780009f, 0.01627169f, 
    -0.04520589f, 0.18909396f, -0.02502382f, 0.03904679f, -0.02303261f, 0.07254677f, 0.04198142f, 0.04246569f, 
    0.05315632f, 0.00046832f, 0.01924850f, 0.27092949f, 0.18004408f, -0.04363386f, 0.08292606f, -0.08486001f, 
    0.11544427f, -0.08094070f, 0.04851296f, 0.00970936f, -0.10773979f, -0.11738078f, 0.05037301f, 0.04164879f, 
    0.08111845f, 0.10801508f, 0.05509163f, 0.18767481f, -0.24281481f, 0.20343807f, 0.06552845f, 0.01196876f, 
    -0.33466440f, -0.02126693f, 0.06565080f, 0.10024057f, -0.00755885f, 0.15456130f, -0.10332711f, -0.03265415f, 
    0.03077083f, -0.04701376f, 0.00960854f, -0.05840326f, 0.07966888f, 0.19768289f, 0.06866153f, 0.15324381f, 
    -0.32765493f, 0.23647784f, 0.22558457f, -0.07620542f, -0.03775651f, 0.02366937f, 0.13141938f, -0.06505322f, 
    0.12249057f, 0.06044568f, -0.00265027f, 0.03847975f, 0.04767166f, -0.06939611f, 0.03399287f, 0.08282965f, 
    -0.05195015f, 0.17427091f, -0.11498737f, 0.10759321f, -0.07573733f, -0.17925940f, 0.24499589f, -0.08579647f, 
    -0.05898474f, -0.00733464f, -0.03625223f, 0.04458263f, 0.00755940f, -0.05625397f, -0.02996465f, 0.00466488f, 
    0.12570894f, -0.10133806f, -0.11780679f, 0.03502369f, 0.14966586f, -0.10686161f, -0.07455417f, -0.14333840f, 
    0.06140181f, 0.18713348f, -0.09559228f, 0.06637386f, 0.02868085f, 0.03227769f, -0.04148294f, -0.00702922f, 
    0.03373492f, 0.08799036f, -0.23089759f, -0.10165657f, 0.31569153f, 0.06624680f, 0.10601050f, 0.05548406f, 
    0.09728599f, 0.00185939f, 0.10941267f, -0.04856319f, -0.01731559f, -0.35783407f, 0.28168350f, -0.11841388f, 
    -0.23904048f, -0.15122660f, -0.03859962f, -0.11454074f, -0.08386397f, 0.13557793f, -0.02952910f, 0.08003981f, 
    0.05412764f, -0.17106380f, -0.02738222f, 0.07015596f, -0.08203940f, 0.02171366f, 0.22212167f, 0.11628252f, 
    -0.29889411f, -0.13268447f, 0.12760179f, 0.01415454f, -0.11121453f, 0.11245327f, 0.19094783f, 0.07097084f, 
    0.16607852f, -0.00329352f, 0.00873124f, 0.15341130f, 0.11134038f, 0.03910434f, 0.01931502f, 0.10236853f, 
    -0.15816116f, -0.04040519f, -0.14229929f, -0.00614753f, 0.07796146f, -0.08383756f, -0.09542038f, -0.27290240f, 
    -0.36661011f, -0.02145392f, 0.07215643f, -0.05101415f, 0.03290460f, 0.04916602f, 0.13039745f, -0.00651344f, 
    0.03697676f, 0.04300676f, -0.06695291f, 0.02066435f, -0.09999520f, -0.30168977f, -0.00046649f, -0.08871245f, 
    0.11286297f, -0.06513143f, 0.17147848f, 0.21859045f, 0.18561417f, 0.04657416f, 0.03918305f, -0.01537321f, 
    -0.07409472f, -0.03220182f, -0.00044948f, -0.08655870f, -0.11767687f, 0.13142130f, 0.10421886f, 0.15890229f, 
    -0.09506604f, 0.17660165f, 0.09300771f, 0.05197873f, -0.10440632f, 0.02261935f, 0.10971861f, 0.15044221f, 
    0.34751427f, 0.03151021f, 0.11764279f, -0.04589489f, -0.01180781f, 0.05834843f, -0.09714521f, 0.04009386f, 
    0.03380721f, 0.00098223f, -0.03349792f, -0.03318613f, -0.10236751f, 0.21699977f, 0.03809972f, 0.07848140f, 
    0.20485908f, -0.06430075f, -0.14287396f, -0.09862222f, 0.02821479f, 0.01554860f, 0.18308298f, 0.06177719f, 
    -0.00237680f, 0.06801730f, -0.06471626f, -0.06352052f, -0.05342273f, 0.04414087f, 0.01488947f, 0.05017158f, 
    -0.04762536f, -0.17785387f, -0.04185464f, -0.05256115f, -0.13802984f, -0.11431500f, 0.03273035f, 0.27896711f, 
    0.30578291f, 0.19489790f, -0.00477815f, 0.00080303f, -0.00522163f, 0.08447671f, -0.03444760f, 0.03090308f, 
    0.11420515f, 0.12592641f, -0.07502292f, -0.01160400f, -0.10220118f, -0.03112705f, -0.03248968f, -0.06226355f, 
    -0.49728888f, 0.12024492f, 0.36919215f, 0.01920162f, -0.15214278f, 0.14769705f, 0.15693268f, 0.03067465f, 
    0.17262478f, 0.01006380f, 0.02212101f, -0.02591920f, -0.18768115f, -0.03560529f, -0.08443560f, 0.03099934f, 
    0.08603895f, 0.16761313f, -0.24377275f, 0.09137508f, -0.13443631f, 0.38226908f, -0.29032049f, 0.21172248f, 
    0.02563007f, 0.15595797f, 0.11780199f, 0.08978037f, -0.09629115f, -0.13222866f, -0.18535347f, -0.00499747f, 
    -0.12580037f, -0.03568547f, 0.23610921f, -0.02361695f, 0.06608435f, 0.20937079f, -0.12937815f, -0.00122619f, 
    0.70922858f, -0.50764430f, 0.32805014f, 0.06350145f, 0.01631063f, 0.16002408f, -0.06844553f, 0.11191492f, 
    0.03031097f, -0.01246142f, 0.02696942f, 0.05063584f, 0.02300751f, 0.17388032f, 0.05709786f, -0.00174714f, 
    0.09180448f, 0.05576371f, -0.17733182f, 0.17669334f, 0.04238634f, -0.20511352f, 0.28967628f, -0.14057401f, 
    -0.40235388f, -0.00758748f, 0.05774362f, 0.02685519f, 0.00378487f, 0.03804355f, 0.12898842f, 0.05274102f, 
    0.05544815f, -0.26022384f, 0.02237202f, 0.07503652f, -0.03778600f, -0.21001351f, 0.02757525f, -0.04958104f, 
    0.04038815f, -0.00654082f, -0.00523681f, -0.03367070f, -0.04489004f, 0.00696016f, 0.02496725f, 0.00854854f, 
    -0.02416149f, 0.01655801f, -0.01424560f, 0.02529763f, -0.01176313f, 0.03317799f, -0.04605632f, -0.05792745f, 
    -0.03663851f, -0.02642707f, 0.03998633f, -0.01897386f, -0.05973355f, -0.00205657f, -0.04815711f, -0.06117542f, 
    0.03268516f, -0.01912192f, 0.03048729f, -0.05014339f, 0.01302615f, 0.03654404f, -0.02934504f, 0.04557538f, 
    -0.06392881f, -0.05480366f, -0.05109717f, -0.03853053f, -0.03150671f, 0.02917361f, -0.00400683f, 0.00600595f, 
    0.00235173f, 0.02469151f, -0.04437266f, 0.00850800f, -0.01673650f, -0.01220721f, 0.03415317f, -0.04845022f, 
    -0.05758568f, -0.01372343f, -0.02433972f, 0.04135256f, 0.01604346f, -0.01703545f, 0.01846565f, -0.01587728f, 
    -0.02326929f, -0.02863240f, -0.02379404f, -0.03285897f, 0.02476650f, -0.06295315f, -0.01181468f, 0.03492457f, 
    -0.05556262f, -0.05083992f, 0.02361025f, -0.02897683f, 0.01967238f, -0.02915785f, 0.00635922f, -0.00487784f, 
    -0.03257196f, -0.03243155f, -0.06537784f, 0.02078504f, 0.04359307f, 0.02347973f, 0.01457780f, -0.01852567f, 
    0.02342908f, -0.01402460f, -0.02056164f, -0.04355929f, -0.03666629f, -0.06289143f, -0.03251182f, -0.06183992f, 
    0.02465143f, -0.02744487f, -0.06231359f, -0.04591799f, 0.02666408f, -0.00131404f, -0.07018949f, -0.03974777f, 
    -0.01943203f, -0.03528627f, 0.01818477f, 0.00157624f, 0.01516407f, -0.00729129f, -0.00790360f, -0.04551380f, 
    -0.02628712f, -0.03020563f, -0.00760400f, 0.03351715f, 0.00479867f, -0.00920764f, 0.01619243f, -0.01213092f, 
    -0.06528904f, -0.06850622f, -0.07260458f, -0.06461979f, -0.07057422f, 0.00000460f, 0.02709536f, -0.06257398f, 
    0.02901372f, -0.04238389f, -0.00378121f, -0.04528528f, -0.02359230f, -0.00741203f, -0.00487847f, -0.03806842f, 
    -0.02919384f, 0.02037571f, -0.03067527f, 0.04429439f, -0.03843312f, 0.03428179f, 0.03288054f, 0.00414372f, 
    0.00189896f, -0.07208706f, 0.03261222f, -0.00456934f, 0.01573820f, -0.05810402f, 0.02263372f, -0.06052618f, 
    0.02952811f, -0.01094083f, 0.04363285f, 0.01617863f, 0.02139415f, 0.00908614f, -0.01000752f, -0.02727203f, 
    -0.00746883f, -0.03519046f, 0.02379126f, -0.03866765f, 0.04701561f, -0.07444282f, -0.01794694f, -0.04684701f, 
    -0.04341007f, 0.03881510f, -0.05364900f, -0.01497651f, -0.05667356f, 0.02838957f, -0.03196093f, -0.02373770f, 
    0.02927106f, 0.01310742f, 0.04956713f, -0.00321389f, -0.07155325f, -0.02594047f, -0.06391145f, -0.00905830f, 
    -0.06342092f, 0.01311780f, 0.03855367f, -0.04083142f, -0.01264648f, -0.01849318f, 0.02285811f, 0.02102600f, 
    0.01398943f, -0.01264311f, -0.05955289f, 0.02162463f, 0.00588354f, -0.00245090f, 0.01338388f, 0.01661463f, 
    0.00856185f, 0.03671218f, -0.01826063f, -0.05512088f, 0.03688944f, 0.03951695f, 0.01477805f, -0.05405481f, 
    -0.06330301f, 0.01463268f, -0.03558184f, -0.00899972f, -0.03924255f, -0.02882603f, 0.02353120f, 0.02641070f, 
    -0.04250738f, -0.00135873f, 0.03560638f, -0.04558925f, -0.02665154f, 0.00352898f, -0.00191635f, 0.00722581f, 
    -0.00004041f, 0.01467043f, 0.02629204f, -0.06000091f, 0.03907048f, 0.04097368f, 0.01481315f, -0.05714057f, 
    -0.02688743f, -0.06013636f, 0.02712583f, 0.04525456f, 0.01482700f, -0.00088399f, 0.03833766f, -0.03744043f, 
    0.03022337f, -0.06900556f, -0.03312782f, 0.02362048f, -0.03221636f, 0.00249084f, -0.02292076f, -0.03954615f, 
    -0.00123734f, 0.00023129f, -0.06734189f, -0.01514756f, -0.00245011f, -0.02245962f, -0.01233441f, -0.04253811f, 
    0.03347447f, -0.04794289f, 0.01833428f, -0.03159461f, -0.04663558f, 0.02050357f, -0.00596396f, -0.01821129f, 
    -0.00299183f, -0.01354805f, 0.02943415f, 0.02003781f, -0.02869583f, 0.04548651f, -0.07038996f, -0.04837834f, 
    -0.02784306f, -0.00091687f, -0.04153502f, 0.01694287f, -0.01810564f, -0.02622912f, 0.05214161f, -0.02923064f, 
    -0.01128786f, 0.03104438f, -0.06230963f, -0.03984072f, -0.00932054f, -0.01450131f, -0.05055032f, -0.05930425f, 
    -0.04347393f, -0.00719409f, 0.00789974f, -0.04593142f, -0.02556790f, 0.04299738f, 0.05384707f, 0.02453232f, 
    0.04162754f, -0.02857324f, -0.06284574f, -0.03758204f, -0.00681395f, 0.02587247f, 0.00243030f, -0.02334796f, 
    0.00271492f, 0.01011121f, 0.03655015f, 0.01616993f, -0.03164891f, 0.00062872f, 0.04147638f, 0.02425821f, 
    -0.05861036f, 0.04462313f, -0.02122313f, -0.05490882f, 0.01003044f, 0.03412689f, 0.02567649f, -0.02661306f, 
    -0.01823534f, -0.02454186f, -0.01855164f, 0.02154520f, -0.01197021f, -0.06123595f, -0.03842076f, 0.00591060f, 
    -0.24183172f, 0.15825617f, -0.32549387f, -0.23795623f, 0.24058737f, -0.05833119f, -0.25886828f, 0.01317394f, 
    0.01087965f, 0.00821939f, 0.01558914f, -0.04333512f, 0.22153217f, 0.08403707f, 0.00955677f, 0.02005258f, 
    0.02489268f, 0.07558835f, -0.06049814f, 0.17539027f, 0.14006029f, 0.62030703f, -0.12028585f, 0.01453468f, 
    0.12450539f, 0.16784321f, -0.02118488f, -0.24390176f, 0.08253637f, -0.15643080f, 0.06705688f, -0.05681800f, 
    0.01192979f, 0.17810230f, 0.09798253f, -0.14860755f, -0.02871625f, -0.16954325f, -0.00892307f, -0.01484913f, 
    0.31674752f, 0.22995605f, 0.01899590f, 0.25336781f, -0.03539592f, 0.12479345f, 0.11001532f, -0.10750070f, 
    -0.14070001f, -0.00716762f, -0.06333490f, -0.04931782f, 0.02866403f, -0.02403474f, 0.04739775f, -0.05125209f, 
    0.02406664f, -0.09473496f, 0.00084961f, 0.08215209f, -0.26539949f, 0.31714851f, 0.23277883f, 0.26507667f, 
    0.13495864f, 0.00632310f, 0.09564149f, -0.16496301f, 0.04709632f, 0.10897405f, -0.02630563f, 0.01204120f, 
    0.03504831f, 0.06968334f, 0.01584672f, 0.05696388f, 0.13668181f, 0.02222858f, 0.07028808f, 0.07540832f, 
    -0.41635278f, 0.02354904f, -0.15926419f, -0.16351189f, 0.01073923f, 0.21659118f, 0.05729336f, 0.11013305f, 
    -0.08437292f, -0.06702598f, 0.17290375f, -0.06534521f, -0.18550777f, 0.04784150f, -0.08110044f, -0.00413199f, 
    -0.12398373f, -0.11517442f, -0.00746694f, -0.02121630f, 0.20166390f, -0.10396972f, -0.29213554f, -0.47944939f, 
    0.18995976f, -0.00527210f, -0.17743781f, 0.04424585f, 0.18223529f, 0.01314196f, 0.10196408f, -0.01550307f, 
    0.06496903f, 0.24207133f, 0.19490865f, 0.02510501f, 0.07767509f, 0.00434590f, -0.06012277f, -0.00215875f, 
    0.20626009f, 0.18273249f, -0.06414789f, 0.22667693f, -0.00765449f, 0.22612739f, 0.07404562f, -0.03836123f, 
    -0.15854548f, 0.03638521f, -0.00294302f, 0.16797316f, -0.10232226f, -0.18355106f, 0.01971282f, -0.10487220f, 
    -0.02889376f, -0.00134099f, 0.09679972f, 0.03361019f, 0.65083152f, 0.22411856f, -0.03809662f, -0.09950949f, 
    -0.26202655f, 0.03662042f, -0.00573246f, 0.13579392f, 0.06009416f, 0.18342872f, 0.09014342f, -0.00334006f, 
    0.05027538f, 0.07286076f, 0.02802706f, 0.31740355f, 0.04943612f, 0.19517002f, -0.01976310f, 0.01200992f, 
    -0.00916452f, 0.08833348f, 0.05023616f, -0.09019691f, -0.02668350f, 0.01738108f, 0.15467265f, 0.01045415f, 
    -0.07727490f, 0.06111471f, 0.00145446f, 0.05991764f, 0.10626893f, -0.02672994f, 0.06960796f, -0.00379351f, 
    0.10867555f, -0.05877803f, -0.03259624f, -0.02441303f, -0.23405364f, -0.11012686f, -0.13347843f, 0.03793653f, 
    0.05927783f, 0.05247457f, 0.05092987f, 0.07046360f, -0.15028779f, -0.05655823f, -0.04139403f, -0.00981787f, 
    0.06664058f, -0.08978004f, -0.02433371f, 0.09150091f, 0.04634704f, -0.25108984f, -0.11674646f, 0.02629052f, 
    -0.28176829f, -0.47980866f, 0.20752412f, 0.13501905f, -0.13055588f, 0.06863181f, 0.01083360f, -0.18176705f, 
    -0.08830203f, -0.03199600f, 0.03362884f, 0.01028403f, 0.08911575f, 0.00754042f, 0.00795738f, 0.16888666f, 
    0.04620940f, 0.14466549f, 0.03065698f, -0.06358579f, -0.05125602f, -0.08477703f, -0.07386690f, -0.15678686f, 
    -0.16436221f, 0.14271058f, 0.22097726f, 0.06057001f, -0.16937903f, -0.04117898f, 0.02746975f, 0.06955779f, 
    -0.08329282f, -0.07917775f, -0.05734736f, 0.04426241f, 0.04267054f, -0.03583971f, -0.07593445f, 0.06794239f, 
    0.17253484f, 0.07155936f, -0.12939775f, 0.08155963f, -0.06687966f, 0.01115247f, 0.17344534f, -0.05226358f, 
    -0.07348102f, -0.08631108f, 0.14788663f, 0.08183441f, -0.00856997f, 0.02990598f, -0.01063504f, 0.11448445f, 
    0.03545782f, -0.04136214f, 0.17601639f, 0.11663712f, 0.10375638f, 0.12959972f, 0.12801838f, 0.05767480f, 
    0.36126933f, 0.17675847f, -0.09670388f, -0.03691385f, 0.01536100f, 0.16868930f, 0.15509829f, 0.12736553f, 
    0.02010578f, 0.08553349f, 0.08250630f, -0.07880871f, 0.06539009f, -0.08797687f, 0.03570548f, -0.10320596f, 
    -0.20531519f, -0.47082570f, -0.13705735f, 0.17521581f, -0.01406776f, 0.01309716f, 0.05243708f, -0.11539558f, 
    -0.01011054f, 0.05627230f, -0.07630212f, 0.05264881f, 0.05371949f, -0.15304653f, -0.07133300f, 0.04691336f, 
    -0.04044295f, 0.10436348f, 0.05266012f, 0.10868841f, 0.67589903f, 0.18091695f, -0.09475323f, 0.15441443f, 
    -0.16121307f, -0.02214652f, 0.18829113f, -0.19635527f, -0.08042897f, 0.06148932f, -0.06044571f, 0.03920188f, 
    -0.03108832f, 0.11150564f, 0.05331256f, -0.06763819f, -0.03145772f, 0.13815045f, 0.03888160f, -0.00003134f, 
    -0.02673442f, 0.01979862f, 0.03997367f, -0.05495311f, -0.00268131f, 0.01952826f, 0.02081128f, -0.01147445f, 
    -0.00011175f, 0.00088154f, 0.02155544f, 0.03163893f, 0.05253300f, -0.00512657f, 0.00283555f, 0.00626821f, 
    0.04822121f, -0.04878278f, 0.04308800f, -0.05326767f, 0.04937076f, 0.04667102f, -0.02849666f, -0.05150123f, 
    -0.02230576f, -0.01359227f, 0.02561426f, -0.00054177f, 0.02970971f, 0.03065268f, -0.04362625f, -0.04629365f, 
    -0.02838819f, -0.02690774f, 0.05352861f, 0.04324229f, -0.03987478f, -0.01515319f, -0.02036765f, -0.00723268f, 
    0.02067547f, -0.04603102f, 0.00389510f, -0.01337334f, 0.04856450f, 0.05036557f, 0.00145407f, -0.00942672f, 
    -0.05257576f, -0.01338142f, -0.03986103f, -0.02879386f, 0.03248110f, 0.04076807f, -0.00980278f, 0.04949831f, 
    -0.04410394f, 0.00764654f, -0.04739943f, -0.02320364f, -0.01013488f, 0.03681839f, 0.00176679f, 0.01507103f, 
    -0.00141266f, -0.02925756f, -0.02435407f, -0.04422899f, 0.00083939f, -0.01200127f, -0.00607078f, -0.03757521f, 
    0.03724060f, -0.03755634f, -0.04363273f, -0.02683194f, 0.03193020f, -0.04897730f, -0.05327370f, 0.01243284f, 
    0.02192134f, -0.00544466f, -0.03810453f, -0.02732239f, 0.02757776f, -0.05237496f, -0.01893073f, -0.04724329f, 
    0.03822828f, -0.03976487f, 0.04351449f, -0.03610734f, 0.01228775f, -0.04823579f, -0.02961238f, -0.05224415f, 
    -0.03097395f, 0.01083836f, -0.01291289f, 0.02406058f, -0.03851854f, -0.00518233f, -0.02974449f, 0.00556113f, 
    -0.00538775f, -0.02495932f, 0.04319591f, 0.00483669f, -0.00385181f, -0.02683637f, 0.04086913f, -0.01586919f, 
    0.01824670f, 0.04942881f, 0.03901240f, 0.02444918f, -0.00813755f, 0.05581224f, 0.03285221f, 0.05491179f, 
    -0.01693027f, -0.01204679f, -0.04119800f, -0.01003909f, -0.02413050f, 0.00353879f, -0.03715626f, 0.04236129f, 
    0.04964334f, -0.02773492f, 0.02093063f, -0.03290937f, -0.00167016f, -0.02705772f, -0.03749797f, -0.00361723f, 
    0.04754388f, 0.04936023f, -0.01776680f, 0.02718412f, -0.05140600f, 0.04259986f, 0.04520631f, 0.04464915f, 
    0.02214234f, 0.04868900f, -0.01877170f, -0.04505555f, 0.04852371f, 0.02933627f, -0.05246916f, 0.01060687f, 
    -0.01736641f, -0.01331443f, -0.05340334f, 0.02123855f, -0.03256593f, 0.01043360f, 0.01870538f, -0.00187222f, 
    -0.00512097f, -0.02515445f, -0.00400638f, 0.03775230f, -0.03335347f, -0.04901976f, 0.04476624f, -0.03335431f, 
    0.00716805f, 0.04785660f, 0.04501453f, -0.04654449f, -0.03449778f, -0.00675171f, -0.02463226f, -0.02135245f, 
    0.01349888f, 0.04065214f, 0.00080040f, -0.01333586f, 0.03832830f, 0.01583806f, -0.01688170f, -0.02611918f, 
    0.01956401f, 0.02392177f, -0.02697297f, -0.01324613f, -0.01383520f, 0.01827396f, -0.02837227f, -0.02779510f, 
    -0.00030347f, 0.03857585f, 0.04191185f, -0.03250161f, -0.01814101f, -0.04740570f, -0.03213471f, -0.00516657f, 
    0.01972359f, 0.03468945f, 0.03181863f, 0.00814158f, -0.03391438f, 0.01419037f, -0.02743702f, -0.04472864f, 
    -0.03732321f, -0.02731116f, -0.03681750f, 0.03126974f, -0.03889019f, -0.02517027f, -0.02552664f, 0.00509656f, 
    -0.00236216f, -0.05472168f, -0.01174845f, -0.03598136f, -0.00352888f, -0.03408653f, -0.04135456f, -0.00454863f, 
    0.02872357f, -0.04872788f, 0.02634134f, -0.00388373f, -0.03660366f, -0.04826419f, -0.03574979f, -0.00739514f, 
    -0.01021583f, -0.01430029f, 0.02096552f, 0.00895448f, 0.04054559f, -0.04130301f, 0.03477821f, -0.02133745f, 
    0.05589110f, 0.02082382f, -0.05581519f, -0.03019399f, -0.02048436f, -0.02807413f, 0.03827510f, -0.02974026f, 
    -0.00504624f, -0.03172033f, -0.01064384f, 0.04542923f, -0.04197792f, -0.04304258f, -0.03423023f, -0.02948382f, 
    -0.00213435f, 0.05081835f, -0.02045339f, -0.00972800f, 0.03578115f, -0.05115043f, 0.01525952f, -0.00040886f, 
    -0.01513395f, 0.05092639f, 0.01954328f, 0.02515182f, -0.02438095f, -0.01816788f, -0.01524735f, -0.05441621f, 
    -0.05578231f, 0.00597111f, 0.00273479f, 0.00063878f, 0.03224301f, -0.04220793f, 0.02699736f, 0.01883868f, 
    0.05386912f, -0.00289647f, -0.01610970f, -0.01734737f, 0.03191025f, 0.04573675f, -0.05124423f, -0.01491206f, 
    0.01716711f, -0.01334130f, 0.04298654f, 0.01724170f, -0.04189156f, 0.03417736f, -0.04331924f, 0.03645037f, 
    -0.00544050f, 0.00970298f, -0.00022094f, 0.00693327f, -0.00140904f, -0.00295704f, -0.00227562f, 0.04625959f, 
    -0.00515983f, -0.02128432f, -0.01005395f, -0.02846747f, 0.01047207f, -0.04823586f, 0.04166341f, -0.03814768f, 
    -0.05236255f, 0.01110928f, 0.01553783f, -0.05129933f, -0.04192356f, 0.04613652f, 0.02718446f, -0.01646460f, 
    -0.49244484f, -0.25888398f, -0.16858485f, -0.47741681f, -0.20843732f, -0.00353920f, 0.03932422f, 0.09376707f, 
    -0.11286086f, 0.06505297f, -0.17832416f, 0.01975184f, 0.07140404f, 0.09961852f, 0.12983200f, -0.03851223f, 
    -0.03588109f, 0.12992208f, 0.03274495f, -0.10637224f, -0.02208164f, -0.22679915f, -0.10242576f, -0.33991829f, 
    -0.18345360f, 0.05935722f, -0.08435627f, 0.11527260f, 0.06509411f, -0.07099812f, -0.21608602f, 0.08339031f, 
    0.16103241f, 0.08604447f, -0.11195538f, 0.11151268f, -0.07232545f, -0.02291817f, 0.02909609f, -0.18282112f, 
    0.28643548f, 0.10248703f, 0.12143996f, -0.14149486f, -0.04043382f, 0.07994022f, -0.10338128f, 0.15861991f, 
    -0.09814257f, -0.06643804f, -0.16806389f, 0.11200209f, -0.00042294f, 0.00457429f, 0.02913392f, 0.00549473f, 
    -0.12780973f, -0.07645883f, -0.02589817f, 0.00727329f, 0.46062720f, -0.03415079f, 0.12875514f, -0.07058297f, 
    -0.26269841f, -0.00149334f, -0.11611068f, -0.04280209f, 0.05935568f, 0.03496899f, 0.10454773f, -0.00136197f, 
    -0.00590453f, 0.06585823f, 0.01408218f, 0.01357451f, -0.12981486f, 0.04620983f, -0.12939984f, 0.22188027f, 
    0.61552179f, -0.20352612f, 0.19261903f, -0.08472798f, -0.10290144f, -0.22985299f, -0.05790936f, -0.11506199f, 
    -0.02408440f, 0.12965156f, 0.08851891f, 0.15391877f, -0.09216927f, 0.16551133f, -0.08990901f, 0.13017151f, 
    -0.16261342f, 0.09550914f, -0.07707481f, -0.08351013f, -0.31674758f, -0.14566289f, -0.23575126f, -0.35861173f, 
    -0.22371060f, 0.10461335f, -0.00730042f, 0.03387334f, 0.02838943f, -0.15836993f, -0.12176686f, -0.03862317f, 
    0.16054511f, -0.02480278f, -0.00216966f, 0.00587556f, 0.16741282f, -0.09191668f, -0.13237748f, 0.09342321f, 
    0.40493086f, 0.29588282f, 0.23770754f, 0.00400671f, 0.16575144f, -0.04700366f, -0.16641809f, 0.05980478f, 
    -0.02640172f, -0.10089389f, 0.09298805f, -0.03913095f, 0.07338895f, 0.12420312f, 0.02318952f, 0.07787252f, 
    -0.02238817f, -0.03544142f, -0.02966788f, 0.09342727f, -0.14142531f, 0.42862344f, 0.14639077f, 0.17732880f, 
    0.17425574f, 0.01510530f, 0.05649821f, 0.03289344f, 0.00145066f, 0.08208388f, -0.09335045f, 0.10630821f, 
    0.01556998f, 0.07269499f, -0.08801880f, -0.04470019f, -0.06829936f, -0.01129037f, 0.00235658f, 0.09018481f, 
    -0.47238028f, 0.04585895f, 0.15309791f, -0.23221223f, -0.06166733f, 0.00800054f, -0.02938662f, -0.06672795f, 
    0.01761115f, 0.02762743f, -0.00866915f, 0.00060681f, 0.02869180f, 0.09422114f, 0.10913853f, -0.14627300f, 
    0.16164000f, -0.02904832f, 0.03085711f, -0.11472613f, 0.10611366f, -0.24064077f, 0.08906008f, -0.07599659f, 
    -0.01306019f, 0.00818328f, 0.07380921f, -0.08689600f, 0.28934476f, 0.16779347f, 0.02342339f, -0.02628504f, 
    -0.05171277f, 0.11352105f, 0.10774090f, 0.04052152f, 0.12200691f, -0.08114751f, 0.04498576f, 0.00979572f, 
    0.30715856f, 0.19860816f, 0.24274369f, 0.09910142f, -0.01680274f, 0.03809796f, 0.07692075f, 0.04786770f, 
    -0.02243293f, -0.01804197f, -0.02649133f, 0.03940479f, -0.02732283f, -0.06732661f, 0.05144857f, 0.07503060f, 
    -0.07981272f, 0.05107697f, -0.03429316f, -0.06962653f, 0.29510626f, 0.08302086f, 0.24258730f, 0.17049232f, 
    0.11847737f, -0.10262068f, -0.06115984f, -0.24320409f, 0.02612085f, 0.11003657f, 0.09099235f, -0.02904009f, 
    -0.12338082f, 0.05908345f, 0.10647920f, 0.03305309f, 0.08383568f, 0.04737044f, 0.00617918f, -0.09101462f, 
    0.22471865f, 0.10368196f, 0.06273758f, -0.25113821f, 0.32022861f, -0.01516494f, -0.23668891f, -0.04121091f, 
    -0.07311359f, -0.00900929f, -0.02375220f, -0.09844040f, 0.09793819f, 0.06341772f, 0.01697468f, -0.14265400f, 
    -0.07465521f, -0.02324923f, 0.04462959f, -0.08196575f, -0.02432486f, -0.38051814f, 0.18617967f, -0.16175713f, 
    -0.26469791f, -0.09558170f, 0.20466100f, 0.03677590f, 0.02719026f, -0.02053766f, 0.00467759f, -0.03173152f, 
    0.01921157f, 0.06049866f, -0.10531153f, 0.00516411f, -0.01531743f, 0.01334943f, -0.02971823f, -0.04100922f, 
    0.22738484f, -0.07148114f, -0.13181145f, -0.09876014f, 0.00815913f, 0.03507257f, 0.16757831f, -0.01048192f, 
    -0.14962161f, 0.05967820f, 0.17178817f, -0.05572481f, 0.05834960f, -0.03717408f, -0.03583639f, 0.05549002f, 
    -0.10339565f, 0.06657907f, -0.08830338f, -0.00722979f, 0.08366469f, 0.29486436f, 0.10639150f, 0.24832307f, 
    0.34178579f, 0.02030305f, 0.04623315f, 0.14934525f, 0.05252912f, 0.01869890f, -0.08314201f, -0.00531997f, 
    -0.05161892f, 0.04799614f, -0.16130085f, -0.09660888f, -0.03293125f, 0.07552592f, -0.07658383f, -0.05464907f, 
    -0.04695322f, 0.03455539f, -0.01270330f, -0.01150299f, -0.00414992f, -0.03821407f, 0.02608381f, -0.00770802f, 
    0.03097035f, -0.04419229f, 0.00230459f, -0.05442117f, 0.02316547f, 0.05063598f, 0.04388372f, 0.02212306f, 
    -0.00355084f, -0.02592567f, -0.00265165f, -0.05974524f, 0.05245804f, 0.04769796f, 0.04616555f, 0.00615684f, 
    0.04542060f, -0.03918008f, 0.02482745f, 0.05013177f, -0.05212217f, -0.00520953f, -0.03467970f, 0.00994053f, 
    -0.04560247f, 0.02053512f, -0.01932359f, 0.03473331f, -0.01937657f, 0.00475957f, 0.04382666f, -0.04478407f, 
    0.00831195f, 0.00965832f, -0.03285358f, 0.03933879f, 0.04658220f, 0.05575348f, 0.01981116f, -0.04263520f, 
    -0.05978610f, 0.04721846f, 0.03707856f, -0.01830415f, -0.03377132f, -0.03789386f, -0.01681495f, -0.02052621f, 
    0.00699109f, 0.01059140f, 0.03093824f, -0.00860620f, -0.00534676f, -0.02497437f, -0.01648958f, -0.03824823f, 
    0.03317432f, -0.00497623f, 0.02942724f, -0.00792983f, -0.03830943f, 0.04121276f, -0.05859525f, -0.02962802f, 
    -0.05657582f, 0.01732448f, -0.00579644f, -0.06048708f, -0.05776722f, 0.04303951f, 0.04513976f, 0.03293739f, 
    0.03319126f, -0.02190776f, -0.00532376f, -0.04401244f, -0.05252630f, -0.00989119f, 0.04887502f, -0.02114924f, 
    -0.03656567f, 0.01082303f, 0.01705472f, 0.01454715f, 0.00163975f, 0.01434784f, -0.06050126f, 0.02834073f, 
    0.03512946f, -0.03295982f, 0.02660358f, -0.01558717f, -0.01488117f, -0.00170514f, 0.02097625f, 0.04318885f, 
    -0.03733555f, 0.04040633f, -0.00676899f, 0.01501186f, -0.05641596f, -0.04723009f, -0.05496554f, 0.00633356f, 
    -0.04855602f, -0.02362944f, 0.04945739f, -0.03170355f, -0.02609684f, -0.01773233f, -0.00977727f, 0.00856162f, 
    -0.00519716f, 0.03913327f, 0.05030688f, 0.00717700f, 0.00672461f, -0.04414782f, 0.03516111f, -0.02892775f, 
    0.00461430f, 0.01337294f, 0.01234711f, 0.02690386f, -0.04970160f, -0.04781525f, -0.01259859f, -0.05372336f, 
    -0.00120300f, -0.00848930f, -0.03400024f, 0.03840330f, -0.03317091f, -0.02574722f, -0.01414777f, 0.01407298f, 
    -0.03950006f, 0.02855812f, -0.02374616f, -0.01057551f, -0.05341741f, -0.01446099f, 0.00140076f, 0.03503596f, 
    -0.04679680f, 0.03937161f, -0.00938903f, 0.03799380f, -0.05283296f, -0.04337627f, -0.04591289f, -0.00410199f, 
    0.04724675f, -0.00244073f, 0.02778884f, 0.01821239f, -0.03384527f, -0.02709036f, -0.05379694f, 0.01875480f, 
    -0.03132676f, -0.00622537f, -0.04917649f, 0.04520182f, 0.00448165f, 0.01566040f, -0.04509034f, 0.02987191f, 
    0.04319339f, -0.00877996f, 0.00651886f, 0.02963992f, -0.03924809f, -0.01105873f, -0.00326490f, 0.04579733f, 
    -0.03918587f, 0.04332680f, 0.00682662f, -0.00845838f, 0.03225255f, -0.05646574f, 0.01025435f, -0.02661332f, 
    -0.02840381f, -0.00792178f, 0.01511865f, -0.03458978f, -0.02053244f, 0.01893748f, -0.01216225f, -0.03225029f, 
    -0.02684891f, -0.03352902f, -0.04779000f, 0.04613081f, 0.03080857f, -0.00874792f, 0.03700024f, 0.00398758f, 
    0.02020563f, -0.02948754f, -0.01507136f, -0.05116258f, 0.03947341f, -0.05085426f, 0.02409307f, -0.01195263f, 
    -0.01950068f, -0.04744177f, -0.01934099f, 0.03673073f, -0.05387291f, -0.01922718f, -0.03187376f, -0.02050049f, 
    -0.03513589f, -0.04766979f, 0.01734115f, -0.03262296f, 0.00452304f, 0.00074376f, -0.03153040f, -0.03132121f, 
    0.00657917f, -0.04444405f, -0.06223924f, -0.01584967f, -0.05719288f, -0.04184796f, -0.04220306f, -0.04044920f, 
    -0.03982332f, -0.00708491f, 0.04134612f, 0.01281293f, -0.01290878f, -0.04111710f, -0.00245210f, 0.00376516f, 
    -0.01250331f, -0.01662388f, -0.00839383f, 0.04802236f, 0.00529696f, -0.00522282f, 0.04392137f, -0.00235377f, 
    0.00287562f, -0.05793402f, -0.06162518f, 0.05437496f, 0.01458156f, -0.06156015f, -0.03382936f, -0.00588598f, 
    0.04500873f, -0.01090786f, -0.04765594f, -0.04368538f, -0.00435030f, 0.04327645f, -0.04573872f, -0.05254626f, 
    -0.02626237f, 0.00908153f, -0.02949657f, 0.02976910f, 0.01072379f, -0.02588151f, -0.01846592f, -0.01207536f, 
    -0.03224885f, -0.02534771f, 0.00365704f, -0.02836584f, 0.01783011f, -0.05394237f, -0.00611171f, -0.04847921f, 
    0.02232456f, 0.01924952f, 0.03534795f, 0.03768462f, -0.00403555f, -0.04979598f, -0.00297809f, -0.03205483f, 
    0.00902226f, 0.01872181f, 0.03303658f, -0.02795104f, -0.00749577f, -0.05101965f, -0.03936129f, 0.01388473f, 
    -0.01944167f, -0.04413711f, 0.01005163f, 0.04117796f, 0.03941350f, 0.03741793f, -0.02780567f, -0.04142051f, 
    0.01851534f, 0.01831698f, 0.01748646f, 0.03017475f, 0.04739470f, -0.03813658f, 0.01575837f, -0.05405143f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00441898f, -0.04383105f, 0.00028679f, 0.05334750f, -0.10959223f, -0.09435688f, 0.01125508f, 0.08554624f, 
    0.01250073f, 0.01242642f, 0.06555777f, 0.05066376f, -0.02430394f, 0.10154902f, 0.05229456f, 0.00927372f, 
    -0.01438211f, 0.05629277f, 0.03445794f, -0.03675130f, -0.01756014f, 0.14141668f, 0.00862276f, 0.02210691f, 
    0.08912359f, -0.04226667f, -0.03985428f, -0.05663553f, 0.09577755f, 0.03516605f, 0.00296438f, 0.01868272f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.10927249f, -0.15689540f, -0.10326723f, -0.38097131f, 0.42372993f, -0.07521622f, 0.01714733f, 0.24968153f, 
    -0.36642179f, -0.34797725f, 0.40412065f, -0.10379514f, 0.08530423f, -0.51437908f, -0.01280145f, 0.14917323f, 
    -0.14619774f, -0.14233913f, 0.08846597f, 0.31873634f, -0.08874518f, 0.30836251f, 0.04494274f, -0.93075734f, 
    -0.44538498f, -0.41825867f, -0.01078770f, 0.13976093f, -0.04916084f, -0.07130580f, -0.10289197f, -0.13101135f, 
    -0.08417336f, 0.16312627f, 0.04161983f, -0.62561411f, -0.34039035f, 0.00787515f, 0.08157206f, -0.27824306f, 
    -0.38219830f, -0.07529171f, 0.16454990f, 0.38592857f, 0.28597450f, 0.28177333f, 0.43041426f, 0.07738703f, 
    -0.15240021f, -0.09658974f, -0.19561964f, -0.19998224f, 0.09166721f, 0.19856369f, 0.01487584f, -0.00047981f, 
    -0.21829256f, -0.00980577f, -0.26304832f, 0.12477638f, 0.10747647f, 0.06246679f, 0.29867679f, -0.10167394f, 
    0.15830483f, 0.07001608f, 0.13799082f, -0.41541454f, 0.08294601f, 0.25629935f, -0.03985380f, -0.33401975f, 
    0.55946022f, -0.24884339f, -0.03084584f, -0.17751648f, 0.01859496f, 0.22944015f, -0.24185860f, 0.10821694f, 
    -0.04846945f, 0.32789230f, -0.31907839f, 0.24209727f, -0.11390281f, -0.23783319f, 0.12238845f, -0.01178917f, 
    0.01983787f, -0.15630765f, -0.04116238f, -0.02714428f, -0.66732520f, -0.12043826f, 0.52940762f, 0.13606082f, 
    0.06267007f, -0.08299107f, 0.01812265f, -0.01342564f, -0.44296771f, -0.67184478f, -0.17723691f, 0.26467258f, 
    -0.33745950f, 0.26647055f, 0.33012718f, 0.08316153f, -0.17705540f, -0.09360570f, -0.06744676f, 0.31926909f, 
    -0.16148688f, -0.70039803f, -0.05242445f, 0.30976614f, 0.00300673f, -0.50058085f, 0.01170424f, 0.22413656f, 
    -0.01413056f, 0.43197784f, -0.18910047f, 0.16111867f, -0.33890137f, -0.15815267f, -0.83332288f, -0.09977993f, 
    -0.37444291f, 0.09944953f, 0.06516006f, 0.11534722f, -0.21830018f, 0.02746980f, 0.12213431f, 0.24326347f, 
    -0.15620050f, 0.65836972f, 0.05098607f, -0.00256819f, 0.22657542f, 0.09906264f, -0.21426938f, -0.25636697f, 
    -0.14167753f, 0.33908868f, 0.40948978f, -0.25741774f, 0.12304004f, -0.09738290f, 0.08114316f, -0.14141709f, 
    0.24778770f, 0.00277559f, 0.20238991f, -0.04241305f, -0.42776310f, 0.07680251f, -0.06809581f, -0.03901543f, 
    0.12897009f, 0.08640143f, 0.01699442f, 0.25730065f, -0.35161242f, -0.50290024f, 0.11442807f, 0.27603480f, 
    -0.33348513f, -0.54165107f, -0.37027484f, -0.05606169f, 0.28110105f, 0.05221888f, -0.35892546f, -0.04066760f, 
    0.09921155f, 0.27691832f, 0.19573276f, 0.23435302f, -0.10813344f, 0.15155530f, 0.05535527f, -0.28443781f, 
    -0.38211504f, 0.13556205f, -0.17501652f, 0.11987673f, 0.39571723f, 0.01949117f, -0.03548844f, 0.02016994f, 
    -0.73507833f, 0.03537860f, 0.03858912f, 0.08574868f, 0.43036583f, -0.78739470f, 0.02496249f, -0.09134127f, 
    0.63700885f, -0.03875166f, -0.04414211f, 0.25511533f, -0.17751384f, 0.29485324f, -0.19324364f, -0.48269269f, 
    0.01203303f, -0.20454498f, -0.13369732f, 0.08232651f, 0.08733927f, 0.25230509f, 0.09376770f, 0.16307130f, 
    -0.40943685f, 0.17040783f, 0.10021254f, -0.02692874f, 0.08219235f, 0.12658961f, -0.15322457f, 0.04588106f, 
    0.22898711f, -0.12242659f, -0.01393225f, 0.22028106f, 0.09399574f, 0.19619185f, -0.07216567f, -0.20465694f, 
    -0.30969468f, 0.01810303f, 0.01975929f, -0.47653058f, -0.44377688f, -0.42772496f, 0.02492186f, -0.38303238f, 
    0.09004845f, 0.21771611f, 0.14432999f, -0.03072663f, -0.17224212f, -0.29623616f, 0.14102682f, 0.53247976f, 
    -0.19037150f, 0.32333595f, 0.25638404f, 0.16154802f, -0.11296258f, 0.07143085f, 0.29240885f, -0.03616754f, 
    -0.18962404f, -0.16411731f, 0.00329812f, -0.23114696f, 0.41841909f, 0.30612797f, -0.02365965f, 0.17579603f, 
    0.08633117f, 0.37938523f, -0.38799414f, -0.51746285f, 0.13217360f, 0.19673534f, -0.18040870f, 0.12652393f, 
    0.01077405f, -0.10031553f, -0.53639138f, -0.47166952f, -0.08680875f, -0.03199083f, 0.01419741f, 0.00689987f, 
    0.40322262f, 0.23589504f, -0.41584069f, -0.10710890f, 0.34677309f, 0.15632392f, 0.12966739f, -0.13460407f, 
    -0.05101795f, -0.05904764f, 0.15626711f, -0.12272754f, 0.09081405f, 0.31854486f, 0.00529755f, 0.00628843f, 
    0.24551666f, -0.23353560f, -0.06242342f, 0.23261033f, -0.51780248f, -0.45112243f, -0.77279484f, 0.24302562f, 
    -0.11331774f, 0.44371390f, 0.03459979f, -0.03845683f, -0.13791458f, 0.00377528f, 0.06839005f, 0.27608117f, 
    0.07771405f, -0.69622892f, 0.50520772f, 0.05478348f, 0.19085591f, -0.03105839f, -0.14021523f, -0.10912154f, 
    0.08457416f, 0.06779647f, 0.12063170f, 0.14891846f, -0.52388620f, 0.13181195f, 0.11333788f, -0.03075027f, 
    -0.35649487f, -0.67985034f, 0.20769520f, -0.32246980f, -0.65272290f, 0.34360752f, 0.15787759f, 0.00995013f, 
    0.08776222f, 0.18584350f, -0.58019793f, 0.20059235f, 0.02942851f, 0.35731983f, -0.05286154f, 0.35347083f, 
    0.35965520f, -0.06331870f, -0.14845608f, 0.07328893f, -0.16921002f, 0.11714866f, -0.31102020f, 0.09303775f, 
    0.37726891f, 0.10464238f, -0.04369722f, 0.06790172f, 0.00798866f, 0.16550054f, 0.14466877f, -0.18299544f, 
    0.30735058f, -0.01659460f, 0.06765364f, -0.21912472f, -0.34787643f, -0.00906733f, 0.31357315f, -0.42182705f, 
    0.15638125f, -0.60510659f, 0.22194090f, 0.21990111f, 0.04611793f, -0.18177386f, -0.06439798f, -0.44465923f, 
    0.17494543f, 0.15021305f, -0.00350688f, -0.13266392f, 0.44807059f, -0.05760117f, -0.75469035f, 0.04273729f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.04626031f, -0.07274086f, -0.27468374f, -0.00449733f, -0.12315902f, 0.18496111f, -0.08085217f, -0.18665324f, 
    -0.10028420f, -0.08903924f, 0.18461506f, 0.01586572f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
