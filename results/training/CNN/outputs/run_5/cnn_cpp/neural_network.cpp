#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.02507818f, -0.60971820f, 0.76759523f, 0.60838336f, -1.26373637f, 0.79740763f, 0.97877342f, -0.03555072f, 
    0.43009868f, -0.29823571f, 0.81460488f, 1.22681808f, 1.08668995f, 0.35813496f, 0.10719741f, -0.65256810f, 
    0.68492270f, 0.05636412f, 1.59821725f, -0.39170045f, 0.02939282f, 0.14518417f, -0.02208284f, -0.67700011f, 
    -0.03452884f, 0.37920749f, 0.68913484f, 1.71850348f, -0.25242087f, -1.38736200f, 0.44600433f, 0.53980649f, 
    -0.27161473f, -0.35855636f, -0.45554569f, 0.50360620f, -1.70338964f, 1.80234420f, 0.25088981f, 0.11230082f, 
    1.00048292f, -0.72409064f, -0.27781561f, -0.45829785f, 0.25511304f, 0.60052806f, -1.05052006f, -1.28838301f, 
    -1.11739862f, 0.89988309f, 1.33437181f, 0.34274319f, -0.18653096f, -0.25088981f, 1.19035065f, 0.64018857f, 
    0.27986681f, 0.47563770f, -0.19035548f, -1.52464128f, -0.76896781f, 0.07477853f, -0.82695234f, -1.05867720f, 
    -1.41847837f, -1.42632782f, -1.17348123f, 0.44833672f, -0.25967035f, 0.08009270f, -0.03149633f, 0.43593118f, 
    -0.76927727f, -1.26407409f, -0.30503005f, -0.83022028f, -1.40687859f, -0.88162321f, 0.65822595f, 0.24339285f, 
    -0.68509102f, 1.75030482f, 1.44165504f, 0.90376705f, -1.01434994f, -1.04017329f, -0.37052184f, 0.79628599f, 
    0.34075400f, 0.04869284f, 0.83045799f, 0.58685267f, -1.11032438f, 1.17672753f, 1.03121448f, -0.64423680f, 
    0.94221103f, 0.10867820f, -0.49382272f, 0.71052742f, 1.82062173f, 1.41200924f, -0.18540633f, 0.76341671f, 
    0.36195561f, -0.19472577f, 0.10648606f, -0.52823317f, -1.16332567f, -1.35828090f, -1.11914158f, 1.09142423f, 
    0.89658284f, -0.40226442f, -0.54354000f, -0.43321812f, 0.29516464f, -0.96165168f, -1.94472873f, 0.69375724f, 
    0.75587064f, 1.14621878f, 0.82325560f, -0.15099938f, 0.24132013f, -0.24400610f, 1.43776250f, -0.37787890f, 
    1.01695466f, 0.49955177f, 0.94607979f, 0.81581807f, 0.08558870f, -0.16756399f, 0.30888838f, -1.11250007f, 
    1.07915580f, -0.25773698f, 0.24853107f, 1.46386361f, 1.04080606f, 0.03850757f, 0.07026435f, -0.88643819f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.07325425f, 0.29837549f, 0.06244286f, 0.23439126f, -0.08029923f, -0.12014834f, 0.02253643f, 0.28681424f, 
    0.47658387f, 0.39669538f, 0.37026227f, 0.24663089f, 0.12049781f, 0.30080539f, 0.44665924f, -0.14801334f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05332726f, -0.53585905f, -0.14950183f, 0.02130187f, -0.17924055f, -0.05169219f, 0.21238162f, -0.06609769f, 
    -0.25976807f, 0.12877280f, -0.06558702f, 0.06982377f, 0.03875429f, 0.09441891f, 0.09184229f, -0.02370406f, 
    -0.11284600f, 0.03127493f, 0.07712120f, -0.07622295f, -0.48997089f, 0.06665283f, 0.28015143f, 0.26815307f, 
    0.00329827f, -0.01322238f, -0.26235801f, 0.08784643f, -0.07867680f, 0.07361276f, 0.02130663f, -0.05862823f, 
    0.03876438f, 0.05011502f, -0.15569413f, 0.00998194f, -0.12264802f, -0.07596821f, -0.15952550f, -0.08977920f, 
    0.23184954f, -0.18459482f, 0.12844250f, -0.03067609f, 0.03086071f, -0.03397481f, -0.20429565f, 0.00331563f, 
    0.05585939f, 0.02162552f, -0.19432792f, 0.13749047f, -0.03587489f, 0.04573884f, -0.04680820f, -0.01564650f, 
    -0.18058714f, -0.28461787f, 0.10775226f, -0.01201589f, -0.21540655f, -0.40949190f, 0.28037155f, 0.08983134f, 
    0.47510356f, -0.16649574f, -0.03879410f, -0.06082670f, -0.06406672f, -0.19122402f, -0.17608963f, 0.14708199f, 
    0.11908308f, -0.03300240f, -0.10797198f, 0.02779077f, 0.00657405f, -0.07879008f, -0.07362197f, 0.05051504f, 
    0.64964336f, 0.05795830f, 0.26534906f, -0.14487757f, 0.21410966f, -0.17016189f, -0.23582023f, 0.07874186f, 
    -0.24317174f, -0.08018962f, -0.00433380f, 0.00776326f, 0.01717316f, 0.05874995f, 0.00770278f, -0.06886742f, 
    -0.26481968f, 0.19088832f, -0.07877930f, -0.00774314f, -0.50353819f, 0.44245091f, -0.18289471f, 0.02287647f, 
    -0.11893739f, -0.07690216f, 0.02682656f, -0.12752296f, -0.05514498f, 0.00105130f, 0.05176809f, -0.12574790f, 
    0.04845268f, 0.04457385f, 0.08470268f, 0.02632688f, -0.04579320f, -0.12793244f, -0.03238849f, -0.09152307f, 
    0.26278302f, -0.01685761f, 0.19368346f, -0.07470271f, 0.21334800f, 0.06407511f, -0.38150057f, -0.03438407f, 
    0.13771458f, 0.11007000f, 0.05634051f, 0.07062633f, -0.06757504f, 0.06950102f, -0.04030762f, -0.00557821f, 
    0.04908694f, -0.01868571f, -0.04512290f, -0.11438889f, -0.22613852f, -0.00775254f, -0.03023767f, 0.10695663f, 
    -0.36727402f, 0.11460672f, -0.22288969f, 0.22826223f, 0.17046961f, -0.06735638f, 0.13009219f, 0.12510622f, 
    -0.03087532f, 0.03829293f, 0.12371711f, -0.14720216f, -0.22380146f, -0.01418035f, 0.03786878f, 0.06341403f, 
    -0.37029362f, -0.97912961f, -0.06616689f, 0.40381539f, -0.14726204f, -0.05945136f, -0.13971639f, 0.06976861f, 
    -0.02145421f, -0.01782103f, -0.08266523f, -0.06713097f, -0.16802377f, -0.16835043f, -0.11495052f, 0.15921068f, 
    0.06065663f, -0.01209647f, 0.05603172f, -0.03712586f, 0.22808971f, 0.22660047f, -0.05338474f, -0.24023554f, 
    0.26812655f, -0.33837354f, -0.19407126f, -0.15839927f, 0.08372912f, 0.00080270f, 0.04118804f, -0.08907636f, 
    0.06439015f, -0.06417513f, 0.00979266f, -0.01057728f, -0.11333624f, 0.10337750f, 0.13500370f, 0.07010522f, 
    0.06397712f, 0.07638650f, 0.08296321f, -0.15474361f, 0.29983088f, -0.19583574f, -0.07684287f, 0.06857258f, 
    0.09613822f, -0.08370295f, 0.03741821f, 0.16076216f, 0.09694967f, 0.03253738f, 0.07843126f, 0.00268433f, 
    -0.05425918f, 0.15859522f, -0.07169775f, -0.09901662f, -0.09745088f, 0.14144082f, -0.01347214f, -0.17402850f, 
    0.44702396f, -0.17279804f, -0.29303163f, 0.01930399f, 0.06048123f, 0.00413542f, -0.02511436f, -0.06148112f, 
    -0.02196101f, -0.14976951f, 0.04160813f, 0.14542803f, 0.16031854f, -0.14481819f, -0.07156894f, 0.02183015f, 
    0.38637581f, -0.00153424f, -0.12562601f, -0.06655832f, -0.61176461f, 0.15779024f, 0.18844584f, 0.07194535f, 
    -0.07085854f, -0.22905438f, 0.02511792f, -0.10784525f, 0.01797666f, 0.03603737f, 0.06946992f, 0.01845902f, 
    0.08043725f, 0.15076658f, -0.14559641f, 0.06393766f, -0.51245266f, 0.32017505f, 0.36041573f, -0.05969319f, 
    -0.62706023f, 0.05611058f, 0.17661306f, 0.12684414f, 0.22967517f, -0.14704765f, -0.00052259f, 0.02209814f, 
    -0.03480394f, -0.02826561f, -0.07000732f, -0.01498974f, 0.10472097f, -0.00542663f, 0.01096367f, 0.09731977f, 
    0.13771139f, -0.05237423f, -0.16643441f, -0.15563168f, -0.13655788f, 0.02778336f, -0.20270444f, 0.02374290f, 
    0.00354745f, -0.02813381f, -0.10847691f, -0.01142985f, -0.15049873f, -0.07329505f, 0.00632497f, -0.15969561f, 
    0.01288397f, -0.01348340f, -0.06355862f, 0.19728635f, 0.20821670f, 0.30436888f, 0.33450672f, -0.22827284f, 
    0.20769039f, 0.24725541f, 0.03057659f, 0.05673119f, -0.02612481f, -0.11998585f, -0.22608753f, -0.09063648f, 
    -0.25189969f, -0.05094861f, 0.00044772f, 0.05601479f, 0.15950513f, -0.19365311f, 0.17817768f, -0.14259498f, 
    -0.36264333f, 0.32641870f, 0.26058468f, 0.05246830f, -0.08065812f, 0.03790061f, -0.15628630f, -0.02845021f, 
    0.12336926f, 0.09371398f, 0.24725655f, 0.04991050f, -0.06221341f, -0.04052338f, -0.16344874f, -0.00623540f, 
    0.14692849f, -0.03480980f, 0.12444956f, 0.13991192f, 0.33533046f, 0.44082344f, -0.08433795f, 0.02414482f, 
    0.19910552f, -0.11033433f, 0.19051078f, -0.04230230f, -0.11633359f, 0.13723898f, -0.07745422f, 0.08271454f, 
    0.05025926f, 0.04376714f, -0.03415707f, -0.08256090f, -0.07243079f, 0.07668316f, 0.03775980f, 0.20985368f, 
    0.38153952f, -0.39188039f, 0.17155237f, -0.10053864f, -0.21571760f, -0.04828476f, -0.17074613f, -0.05637563f, 
    -0.10623331f, 0.04525679f, 0.14345708f, -0.03202927f, 0.07447650f, -0.14513689f, 0.11016468f, -0.06277698f, 
    0.01975497f, -0.19092947f, -0.09209552f, -0.08747078f, 0.38543007f, -0.93340492f, 0.10132176f, -0.36498702f, 
    -0.18550341f, -0.08126505f, -0.09780499f, -0.17518802f, -0.06124282f, 0.00913176f, -0.00022284f, -0.11910186f, 
    -0.16638649f, 0.02927691f, 0.03689248f, -0.05781098f, -0.05614046f, -0.20007658f, 0.21572417f, -0.01923586f, 
    -0.67238671f, -0.03495680f, -0.20022245f, -0.22825986f, 0.26949167f, -0.13987473f, 0.08770096f, 0.04097351f, 
    -0.03608052f, 0.00396013f, 0.03241244f, -0.05103746f, 0.11804629f, -0.07779784f, -0.00998765f, 0.18104433f, 
    -0.03948006f, -0.03525417f, 0.01772283f, -0.11779620f, 0.47221211f, -0.78872991f, -0.01539297f, 0.07870989f, 
    -0.05397887f, -0.26958010f, 0.08877456f, -0.09575686f, 0.06095031f, -0.08527177f, 0.08228516f, -0.01946164f, 
    -0.01273071f, 0.06294011f, -0.05697659f, -0.04442239f, -0.11338567f, 0.05830523f, -0.05681843f, 0.03969408f, 
    0.25021851f, -0.33222833f, 0.00399982f, -0.14748116f, 0.25843641f, -0.09567759f, -0.09547207f, -0.03855948f, 
    -0.03673014f, -0.01933325f, -0.06470110f, -0.24268997f, 0.15102753f, -0.08578570f, 0.13474807f, -0.21085891f, 
    0.01612957f, -0.14066865f, 0.02030860f, 0.13961561f, 0.27837491f, -0.21947838f, -0.18111609f, -0.01335208f, 
    -0.04711935f, -0.08385455f, -0.02570549f, 0.08362281f, 0.18113421f, 0.21175149f, -0.03257278f, -0.13910353f, 
    0.04253071f, 0.01738550f, 0.08020111f, 0.17864384f, -0.02056097f, -0.06542847f, -0.32049724f, -0.17971073f, 
    -0.19166782f, 0.01389996f, -0.17761408f, -0.24498162f, -0.33952770f, 0.17895649f, 0.05933344f, -0.05264770f, 
    0.20038354f, 0.07313176f, -0.16131094f, -0.13883997f, 0.13521656f, 0.25993299f, -0.10423024f, -0.09090648f, 
    0.11548621f, -0.35827211f, -0.38872603f, -0.11855686f, 0.29156578f, -0.04322987f, 0.00713628f, 0.06539055f, 
    0.02277618f, -0.01600744f, -0.12202454f, 0.06927104f, 0.00724440f, 0.04662155f, -0.01248475f, 0.09826959f, 
    0.00603173f, 0.23857599f, -0.04241240f, -0.01086604f, 0.00572560f, -0.08025596f, -0.14159660f, -0.11819376f, 
    0.30980369f, -0.61041915f, -0.09888759f, -0.06875385f, 0.01481700f, -0.16446078f, -0.06960461f, -0.07998887f, 
    -0.05008767f, 0.01009729f, -0.18158577f, -0.15282550f, -0.18528938f, -0.04761070f, -0.11498757f, -0.02257460f, 
    -0.00686758f, -0.21056013f, 0.01164355f, 0.02402877f, 0.33682516f, 0.55909425f, 0.02593829f, 0.14949560f, 
    0.35124132f, -0.01646385f, -0.00683781f, 0.05001827f, 0.08768369f, 0.05656759f, -0.12673682f, -0.09905023f, 
    0.16254322f, 0.20020524f, -0.09875607f, 0.02668802f, 0.06725218f, 0.05347006f, -0.11638917f, -0.02672886f, 
    -0.11312607f, 0.05145333f, -0.23602964f, -0.03016388f, -0.45373726f, 0.08594158f, -0.06027689f, -0.10145997f, 
    0.06680987f, 0.13056827f, -0.01143157f, 0.05656645f, 0.06575295f, -0.22560917f, -0.09551898f, 0.14438863f, 
    0.10154565f, -0.12370162f, 0.06361970f, -0.12082936f, 0.23021814f, -0.05499489f, -0.09331427f, 0.06847364f, 
    -0.34259191f, -0.01206086f, 0.08662476f, -0.01412078f, -0.10510164f, 0.13882586f, -0.07902531f, -0.00182769f, 
    -0.15141805f, 0.03626223f, -0.00833574f, -0.00542537f, 0.14028336f, 0.03218073f, -0.10544576f, 0.02591886f, 
    0.41152063f, 0.16714904f, 0.15757068f, 0.24317952f, 0.10236670f, -0.01923846f, -0.11722549f, -0.02983403f, 
    -0.02331401f, 0.18991581f, 0.22620948f, 0.07558564f, -0.01327188f, -0.04588171f, -0.15037526f, -0.02467799f, 
    -0.05428563f, 0.11037376f, 0.07830761f, 0.02580906f, -0.65062475f, 0.18831716f, -0.17709206f, -0.10724773f, 
    0.18708155f, -0.05520920f, 0.07757696f, -0.20395578f, -0.13708980f, 0.01749969f, 0.33362696f, 0.05189494f, 
    -0.09638985f, 0.04530609f, 0.09439582f, 0.00178734f, 0.00540622f, 0.07857012f, -0.04814490f, 0.11007366f, 
    -0.35402483f, 0.33558014f, 0.10422476f, 0.13327499f, -0.12578282f, -0.14182636f, 0.03156278f, -0.17226747f, 
    -0.09295969f, -0.05793118f, -0.03476977f, 0.01511381f, 0.03359283f, 0.00598332f, 0.14386730f, 0.07309984f, 
    -0.05166174f, -0.00104795f, -0.03170875f, 0.09652548f, 0.21023473f, -0.15771112f, -0.02066323f, 0.20870483f, 
    -0.02241025f, -0.15585268f, -0.04850464f, 0.03449089f, -0.05635319f, -0.02145258f, -0.10313466f, 0.25145587f, 
    0.05549137f, -0.01526149f, 0.12425845f, -0.12268112f, -0.08754119f, -0.06703641f, 0.01350757f, 0.06352859f, 
    -0.35745192f, 0.04878941f, 0.16045991f, -0.43526152f, -0.16360731f, -0.01162435f, 0.07955126f, 0.02631130f, 
    0.08580576f, -0.02132328f, -0.17168950f, 0.05117805f, -0.11833535f, -0.13059863f, 0.02874242f, 0.08674996f, 
    -0.03890004f, 0.12033291f, -0.00528462f, -0.01522963f, -0.17149714f, -0.27496940f, 0.13350230f, -0.21977639f, 
    -0.39809299f, -0.20807999f, -0.26973799f, 0.17618731f, -0.00514691f, 0.19793910f, -0.22935970f, -0.06514218f, 
    -0.01000514f, 0.12335736f, -0.14226769f, -0.00064401f, -0.04008134f, 0.07852317f, -0.01087387f, 0.07030905f, 
    0.26022288f, -0.08294382f, -0.16386847f, -0.36514196f, -0.20766076f, 0.06120390f, 0.12157020f, 0.07802678f, 
    -0.10007130f, 0.09380875f, -0.10570426f, 0.07248221f, 0.01461748f, 0.02609190f, 0.07350961f, -0.12033246f, 
    -0.13249868f, -0.04341672f, -0.10201646f, -0.01074224f, 0.67670178f, 0.02844422f, 0.08812857f, 0.35845730f, 
    -0.36268169f, -0.16285843f, -0.21780390f, 0.08034211f, 0.09885048f, 0.18671797f, 0.03192900f, 0.02463829f, 
    0.16909808f, 0.06052741f, 0.00190483f, 0.09066660f, -0.07712254f, -0.12130609f, 0.08442868f, 0.13816161f, 
    -0.08393984f, -0.31090903f, 0.04802425f, -0.36406055f, 0.07098500f, 0.22510535f, 0.14319681f, 0.03655784f, 
    -0.07439228f, 0.04826651f, 0.12227403f, 0.12590741f, -0.07426055f, -0.23893122f, -0.02500948f, 0.03838833f, 
    0.05028778f, -0.00755525f, -0.23005886f, -0.11284757f, 0.90402895f, -0.65048146f, -0.27021065f, 0.00553619f, 
    -0.35337192f, -0.29200861f, 0.04816590f, -0.18105716f, -0.12186245f, 0.09383643f, -0.00030546f, -0.05363356f, 
    0.01903284f, -0.06067843f, -0.05291073f, -0.05905155f, 0.11060525f, 0.08618056f, 0.04318371f, 0.04972009f, 
    -0.05460004f, -0.61403501f, -0.13354073f, -0.23753490f, -0.68380624f, -0.12711026f, 0.05757195f, -0.06707613f, 
    0.05893481f, 0.01713264f, -0.05089580f, -0.04654500f, 0.15624833f, -0.07853595f, -0.00270655f, 0.07219496f, 
    -0.05055517f, -0.02085244f, 0.05705120f, -0.22184643f, -0.20197400f, 0.28468692f, -0.10373108f, -0.15079463f, 
    0.06309287f, 0.15042478f, 0.07440709f, 0.13144375f, -0.05650950f, -0.18605170f, -0.26699615f, 0.14316648f, 
    -0.03642819f, -0.12239527f, 0.00494268f, -0.05393877f, 0.04563520f, 0.06002638f, -0.01987061f, 0.00427244f, 
    0.41267449f, -0.38528442f, 0.24994694f, -0.30844799f, 0.04627051f, 0.13614015f, -0.16235006f, 0.03733095f, 
    -0.13722602f, 0.11472348f, 0.05996889f, -0.07645863f, 0.00523727f, 0.10280854f, 0.01278083f, -0.07472542f, 
    -0.28126237f, 0.03857671f, -0.06576413f, -0.03669088f, -0.04586971f, -0.05133643f, -0.16209359f, -0.11105639f, 
    0.02106521f, 0.08981222f, -0.03297836f, 0.15311891f, 0.02859067f, -0.11157199f, -0.05053936f, 0.05745088f, 
    -0.01412097f, 0.05239099f, -0.04024739f, -0.06053828f, -0.01618006f, 0.03053917f, -0.18924546f, -0.05014712f, 
    0.28838372f, -0.30831134f, 0.31182200f, 0.16771071f, 0.40525779f, -0.10212655f, -0.22075963f, -0.31409609f, 
    0.05497985f, 0.13721484f, 0.20329648f, -0.02856839f, -0.12516235f, 0.03098491f, 0.00666222f, -0.17725290f, 
    -0.09320796f, -0.09611554f, 0.01215105f, -0.07154006f, 0.34236184f, -0.20623636f, 0.25945970f, -0.01881454f, 
    0.26689497f, -0.26638150f, -0.00246557f, 0.02077003f, -0.00197445f, 0.01446110f, 0.06682552f, -0.03954713f, 
    -0.14502309f, -0.27017826f, 0.03887832f, 0.10128203f, -0.13820960f, -0.04750181f, 0.10641448f, 0.04667866f, 
    -0.43462366f, 0.14526187f, 0.18802062f, -0.16389115f, -0.00512329f, 0.12083501f, -0.10211954f, 0.09178528f, 
    0.14597838f, 0.04171985f, -0.22597702f, -0.00139463f, -0.03588511f, -0.00862368f, -0.04895125f, -0.07138991f, 
    -0.06085204f, -0.00680946f, 0.12406791f, 0.03625990f, 0.61045521f, 0.10241168f, 0.04068331f, -0.05388185f, 
    0.10482667f, -0.00054848f, -0.00840675f, -0.00938215f, 0.13232526f, 0.08800080f, -0.01645485f, -0.22843480f, 
    0.12228569f, -0.11167482f, -0.09773415f, 0.00881651f, -0.20446242f, -0.27973434f, -0.02951835f, -0.08229756f, 
    0.35685095f, 0.24341840f, -0.12118406f, 0.12445173f, 0.09891865f, 0.07014371f, 0.17770159f, 0.08988214f, 
    -0.23801042f, -0.09206177f, -0.11500895f, 0.17960586f, 0.20784779f, -0.00689528f, -0.15577935f, 0.03970370f, 
    0.11910323f, -0.04345518f, -0.04296283f, -0.06493690f, -0.24092923f, -0.69991511f, -0.23783799f, -0.06593924f, 
    -0.01750732f, -0.04323233f, -0.05168603f, 0.02016577f, 0.05133050f, -0.24964006f, 0.00485120f, -0.11232974f, 
    -0.10721077f, -0.06734042f, -0.08255797f, 0.06866940f, -0.04725727f, 0.09693836f, 0.03878206f, -0.00828951f, 
    0.02445946f, -0.05798852f, 0.08864292f, 0.15797703f, -0.02549583f, 0.02979380f, -0.00619781f, -0.02422343f, 
    0.19229567f, -0.00816659f, 0.04584006f, -0.06454046f, -0.12114409f, 0.09046347f, -0.01496497f, -0.00370898f, 
    -0.07931674f, 0.02900965f, -0.03588632f, -0.02934985f, 0.18137342f, 0.23501082f, 0.27045479f, 0.22697771f, 
    -0.27445751f, 0.03776909f, 0.18046439f, 0.06941278f, -0.09521340f, 0.20621035f, 0.02670763f, 0.06216244f, 
    -0.06765429f, 0.04872036f, -0.06246262f, -0.02894138f, -0.01493734f, -0.09311824f, -0.01958652f, 0.01966136f, 
    0.70560867f, 0.59233063f, -0.16983849f, 0.08374165f, 0.09886070f, 0.07273016f, 0.02706148f, -0.20091055f, 
    0.20712419f, -0.01233865f, -0.08588777f, -0.06118752f, -0.10022594f, -0.00107242f, -0.07556596f, -0.16104993f, 
    0.00882064f, -0.07254215f, 0.27012965f, 0.12247942f, 0.07022312f, -0.50971401f, -0.02294060f, 0.03159595f, 
    -0.21813364f, 0.06912847f, -0.11424565f, 0.15502909f, -0.01679989f, 0.04429903f, -0.10041648f, 0.14146721f, 
    -0.15106727f, 0.04456975f, 0.05841648f, -0.01187798f, 0.04321282f, -0.03483457f, -0.10949448f, -0.01663389f, 
    0.23810489f, -0.39276320f, -0.17672735f, 0.19301961f, 0.17599854f, 0.10422053f, 0.01565457f, 0.04520273f, 
    -0.16127624f, 0.08286114f, -0.00757152f, -0.08111575f, -0.04341702f, 0.05575201f, -0.11181020f, 0.15335990f, 
    0.09916564f, 0.23352048f, 0.04462713f, 0.03264739f, 0.01687194f, 0.18203062f, 0.08201984f, 0.11705191f, 
    -0.09639032f, -0.13326921f, -0.17964521f, -0.04156873f, -0.07959906f, 0.06266318f, -0.10711350f, 0.02734050f, 
    -0.00628124f, -0.07938300f, 0.14105722f, 0.04530780f, 0.11220441f, 0.16267617f, 0.09852555f, 0.02051906f, 
    0.02336605f, 0.53536826f, 0.28332958f, 0.15195683f, -0.03164524f, -0.08929730f, 0.05604453f, -0.01043475f, 
    -0.03392391f, 0.06980311f, -0.03436776f, -0.06893758f, 0.04156997f, -0.09849595f, -0.00727743f, -0.04529246f, 
    0.06905203f, 0.17428769f, 0.21102384f, -0.02409392f, -0.22724771f, -0.86774778f, -0.49967316f, 0.18710005f, 
    0.45797282f, -0.06231694f, 0.22373688f, 0.09492891f, -0.00883102f, -0.09877060f, -0.01396723f, 0.05116510f, 
    0.01960453f, -0.30361244f, 0.03807395f, -0.00089617f, -0.02354845f, -0.06822348f, 0.06652515f, -0.07233080f, 
    0.09889031f, 0.07541654f, -0.40486062f, 0.16805680f, -0.00303621f, -0.04791846f, -0.08638717f, 0.02379859f, 
    0.02097450f, -0.03046525f, -0.13299960f, -0.07500321f, 0.06865055f, 0.06306650f, 0.12910163f, -0.10901798f, 
    0.07004953f, 0.06830221f, -0.04552349f, 0.00298448f, -0.61309355f, -0.40892065f, -0.32656148f, -0.05262296f, 
    0.11490671f, -0.16984886f, 0.03508490f, -0.07775839f, -0.02091110f, 0.01623200f, -0.09507734f, -0.07928845f, 
    0.20450935f, -0.04531514f, 0.13441047f, 0.02825330f, -0.09614290f, -0.09428538f, 0.04775850f, 0.03709529f, 
    0.06840429f, 0.17448704f, -0.25791493f, 0.06480417f, -0.17250799f, -0.11260541f, -0.29549474f, 0.06094629f, 
    0.08782879f, -0.00022434f, 0.03085726f, 0.06595473f, 0.13182251f, -0.00003331f, 0.06498244f, -0.12438224f, 
    -0.04450028f, 0.03353076f, -0.00473392f, -0.03446469f, 0.30793253f, -0.30193037f, 0.20890577f, -0.23744330f, 
    -0.20273773f, -0.12976806f, -0.24135546f, -0.11035780f, -0.07596577f, -0.06903665f, 0.13448547f, -0.08429824f, 
    0.01938484f, 0.00547935f, 0.04882238f, -0.07833758f, -0.05782894f, -0.09237451f, 0.13796654f, 0.07203267f, 
    -0.57325542f, -0.88343763f, -0.33396691f, -0.21555606f, -0.34059060f, -0.15206885f, -0.00539259f, -0.12771045f, 
    0.02745344f, -0.06808221f, -0.15470196f, 0.02001445f, 0.11483031f, 0.09322663f, 0.11909899f, 0.07484644f, 
    -0.06072298f, -0.02358387f, -0.09785877f, 0.09492856f, -1.25075841f, 0.54215169f, 0.18350853f, -0.40493819f, 
    -0.27159965f, -0.18000975f, -0.14151004f, 0.12170432f, 0.06945727f, -0.07083400f, -0.00841310f, 0.03420235f, 
    -0.19051895f, -0.03796907f, -0.01385545f, -0.13909651f, 0.15000710f, -0.09102169f, 0.25721228f, 0.18279864f, 
    0.28297359f, -0.11069352f, -0.00595292f, -0.18057267f, 0.27942365f, 0.18680269f, -0.09541767f, -0.08768724f, 
    0.04289789f, -0.17543882f, -0.17416450f, -0.07952230f, -0.12384249f, 0.11061169f, -0.04149380f, -0.05470352f, 
    -0.31014282f, -0.29088071f, -0.19804831f, -0.08649731f, 0.11942731f, 0.30098024f, -0.31634024f, -0.38328791f, 
    0.10294817f, 0.04995018f, -0.03770025f, -0.07318670f, 0.02766831f, -0.07876223f, 0.07609751f, 0.00130763f, 
    0.10720702f, 0.00302788f, 0.11026055f, 0.10936225f, 0.07820880f, -0.02704833f, -0.07077528f, -0.02463793f, 
    -0.04831849f, 0.11152086f, -0.07527858f, 0.07773027f, -0.13860135f, -0.11764877f, 0.08707827f, -0.11772788f, 
    0.01668792f, -0.19402455f, 0.06269541f, -0.09781279f, 0.00399533f, 0.02684062f, -0.03686886f, -0.22593194f, 
    0.03912254f, 0.05048909f, -0.06763688f, 0.12929471f, 0.45070049f, 0.25599664f, -0.48681399f, 0.05062093f, 
    -0.38765728f, 0.05690011f, -0.02200146f, 0.04428586f, -0.12980381f, -0.16002269f, -0.20699075f, -0.07516072f, 
    0.13126490f, 0.00003595f, 0.07540724f, 0.01506870f, -0.09960460f, 0.08334518f, 0.01226068f, 0.03112474f, 
    -0.15383571f, 0.37295508f, -0.12624522f, -0.09822848f, -0.12636025f, 0.04747030f, 0.11136213f, 0.21194388f, 
    -0.03069874f, -0.14722070f, 0.14953476f, 0.04013094f, -0.12207458f, -0.09656580f, -0.05095980f, -0.19405723f, 
    0.24480426f, -0.08958658f, -0.09402075f, -0.02591192f, -0.25781447f, 0.20215273f, -0.16696578f, -0.12536635f, 
    0.04571826f, -0.04093892f, -0.01936028f, -0.05996974f, -0.10574941f, 0.18364403f, -0.04852419f, -0.06732388f, 
    0.03236918f, 0.02779797f, -0.09340344f, -0.02848175f, 0.06416775f, 0.09090325f, 0.04590817f, -0.19905049f, 
    0.09658305f, 0.33615071f, 0.25377250f, 0.13848981f, -0.23789145f, -0.06811916f, 0.06747758f, -0.09227289f, 
    0.06604119f, 0.06010546f, 0.11998262f, 0.01061469f, 0.03700593f, 0.13817896f, 0.01557006f, 0.00145811f, 
    0.01057068f, -0.10452308f, -0.13820630f, 0.09603159f, -0.10640264f, -0.01004924f, -0.13095206f, 0.11356311f, 
    0.10177786f, 0.12976280f, -0.01086102f, 0.07518721f, 0.17971526f, 0.09508657f, -0.03929411f, 0.04203001f, 
    0.03679934f, -0.07597285f, 0.03547265f, 0.05706808f, -0.09907465f, 0.07532925f, 0.09564647f, -0.19325373f, 
    -0.00064245f, -0.06576148f, -0.06363256f, 0.08166078f, 0.08358984f, -0.02235353f, 0.06766382f, -0.00271206f, 
    0.12493004f, -0.00342127f, 0.15701379f, 0.14221314f, 0.02141969f, -0.02181390f, 0.14694141f, -0.07777263f, 
    -0.07823956f, 0.14685591f, 0.04563215f, 0.10213542f, -0.35412034f, -0.89919257f, 0.37486592f, 0.29807797f, 
    0.00141405f, -0.30770129f, 0.00139256f, -0.03821665f, -0.15852490f, 0.03010452f, 0.12839918f, 0.01598266f, 
    -0.11514146f, -0.21679200f, 0.06652047f, -0.14303435f, -0.15589269f, 0.02009164f, 0.08536357f, 0.05620582f, 
    -0.33646935f, -0.20730157f, -0.04112281f, 0.00685472f, -0.17880140f, -0.13262908f, 0.05107673f, -0.00016155f, 
    -0.09405985f, -0.13634898f, 0.03311165f, -0.00619519f, -0.02255957f, -0.05428273f, 0.14531277f, 0.03152012f, 
    -0.00370741f, -0.03206675f, -0.16973345f, 0.11801618f, -0.22648783f, 0.05290752f, 0.15797921f, 0.03813683f, 
    -0.04500255f, -0.06296443f, -0.09994990f, 0.14311436f, 0.18898892f, 0.18309352f, 0.08546808f, 0.03663408f, 
    -0.00570672f, -0.10838866f, -0.05737652f, 0.13366394f, -0.02148813f, 0.00064483f, -0.04288372f, 0.08786535f, 
    -1.02325463f, -0.15648383f, -0.21113619f, 0.00405586f, 0.20154625f, -0.03645847f, 0.06804566f, -0.08078755f, 
    0.13015467f, -0.01739498f, 0.07654124f, 0.01375893f, 0.01435044f, 0.14969391f, -0.10495191f, 0.01781780f, 
    -0.12924670f, 0.18343872f, 0.20399155f, 0.13274708f, -0.64504188f, 0.15142260f, -0.19606057f, -0.03496592f, 
    0.29305878f, 0.02507311f, -0.05121669f, -0.16137043f, 0.16479270f, 0.03136418f, -0.02235208f, 0.01298512f, 
    -0.04397051f, 0.05705712f, 0.06235294f, 0.04435229f, 0.12581675f, -0.06776027f, 0.02770567f, -0.19886477f, 
    -0.24869585f, 0.23275636f, 0.01964048f, -0.26177245f, -0.07677616f, 0.04717003f, 0.20104179f, -0.13372840f, 
    0.22257255f, 0.08570589f, 0.10606836f, -0.10719465f, 0.22077717f, 0.12076651f, 0.11681509f, 0.08680855f, 
    0.12074872f, -0.11443457f, -0.12469061f, 0.00830450f, 0.22385578f, -0.32937762f, 0.03710870f, 0.24995045f, 
    0.25184038f, -0.10725056f, -0.00755511f, 0.27562431f, 0.00322502f, 0.04913948f, -0.07380651f, -0.03750172f, 
    0.16744123f, 0.05152351f, -0.18345800f, -0.11729553f, -0.07214797f, 0.04418387f, -0.03051675f, -0.27151832f, 
    -0.05767560f, -0.46000680f, -0.08116047f, 0.23037013f, -0.09626386f, 0.01251143f, 0.10937797f, -0.02239916f, 
    0.14112225f, 0.02042792f, 0.14792989f, 0.01316844f, 0.06691529f, 0.01627638f, 0.05842507f, 0.07859624f, 
    0.10661377f, 0.05194326f, -0.29415640f, 0.07510158f, -0.16314787f, -0.23112434f, 0.37622181f, 0.11795691f, 
    -0.17823365f, 0.05033125f, -0.10205561f, -0.18567875f, 0.07687420f, -0.09611804f, -0.08860802f, -0.18119980f, 
    -0.15312032f, -0.04093404f, -0.00500252f, 0.06592440f, 0.02976828f, 0.16028246f, 0.18562378f, -0.09269785f, 
    0.00600834f, 0.02925297f, 0.12920262f, 0.30967852f, 0.41178489f, -0.01048772f, 0.00866772f, 0.33662894f, 
    0.11903551f, 0.07463030f, 0.02349774f, -0.25454605f, -0.09946512f, 0.04570109f, -0.07530851f, 0.12516902f, 
    -0.07804471f, -0.16979256f, 0.06724776f, -0.03576635f, -0.09623992f, 0.10119066f, -0.09224184f, 0.01249458f, 
    0.14395985f, -0.07671849f, -0.06436698f, -0.17580342f, 0.10392565f, -0.02258128f, 0.19793503f, -0.00641584f, 
    0.04664797f, 0.06581801f, -0.09837661f, -0.11699319f, -0.04893425f, -0.06040377f, -0.06077720f, -0.06722306f, 
    -0.42032552f, -0.10008088f, 0.38459560f, 0.25265759f, -0.51974136f, -0.16354199f, -0.11485279f, -0.10838407f, 
    -0.03648615f, 0.15878613f, 0.01128420f, 0.02652976f, 0.14861467f, 0.04265727f, 0.02021063f, -0.18032126f, 
    -0.12282854f, -0.10259584f, -0.00447145f, 0.13156939f, -0.56259060f, -0.02820734f, -0.18177681f, -0.29969168f, 
    0.00083475f, 0.16509734f, 0.01618322f, -0.08507678f, -0.03395499f, -0.17912245f, 0.00183803f, 0.04695799f, 
    -0.22549483f, -0.00918431f, -0.05003759f, -0.11582937f, -0.00330022f, 0.04084980f, -0.01450695f, 0.03888196f, 
    -0.14344655f, -0.29178679f, 0.02780371f, 0.07103578f, 0.23918150f, -0.10316400f, -0.03296506f, 0.07238138f, 
    -0.09364912f, -0.18009208f, -0.02596465f, 0.11322065f, 0.00676255f, -0.04835154f, 0.08097489f, -0.16258682f, 
    -0.19528419f, 0.02168385f, -0.01422522f, -0.06736328f, -0.88142610f, -0.31064585f, -0.26550713f, -0.06043518f, 
    -0.00754943f, 0.24067366f, 0.12845545f, -0.06372262f, 0.02343165f, -0.03473843f, 0.02473773f, 0.00056788f, 
    0.07543997f, -0.01096214f, -0.17974362f, -0.20954345f, 0.06395734f, -0.16172618f, -0.33709010f, 0.09985308f, 
    0.06462269f, 0.05162951f, -0.14975831f, 0.11657412f, 0.37644213f, 0.16944942f, -0.09183627f, -0.05711138f, 
    0.03139513f, 0.10505728f, -0.00242252f, -0.00433972f, 0.15561377f, 0.19306527f, 0.27229524f, -0.00666615f, 
    0.01315814f, -0.00355178f, -0.31295779f, -0.02553997f, 0.17754263f, 0.23609386f, 0.09075676f, 0.23603466f, 
    0.06231087f, -0.23572554f, -0.13103217f, -0.08261370f, 0.05485798f, 0.09769136f, -0.03380867f, -0.24193446f, 
    0.05470424f, 0.14687395f, 0.14432400f, 0.01992107f, 0.10405714f, -0.02062972f, 0.01253719f, 0.08688548f, 
    -0.08775835f, 0.18640867f, 0.16302715f, -0.16450264f, 0.09618866f, 0.15932408f, -0.17837358f, -0.07191978f, 
    0.06518289f, -0.06397162f, 0.04134688f, 0.01611908f, 0.02625063f, -0.09685990f, -0.07303927f, -0.11039439f, 
    0.11156674f, -0.18350446f, 0.16089109f, -0.00454296f, 0.05709967f, -0.17979753f, 0.00015035f, 0.04474960f, 
    -0.32036847f, -0.10209458f, 0.11355682f, -0.19784592f, -0.00809633f, 0.00254440f, -0.06362635f, 0.17531373f, 
    0.08753330f, 0.01072845f, 0.08412343f, -0.12478442f, -0.08106390f, 0.14753748f, 0.10384638f, -0.01050369f, 
    -0.63270247f, 0.05631982f, -0.37465376f, -0.32281744f, -0.01347133f, 0.13620241f, 0.34090161f, 0.10075607f, 
    -0.06271794f, -0.08269651f, 0.02974152f, -0.02647534f, 0.03248163f, -0.18107919f, 0.13942640f, -0.01709648f, 
    0.18255004f, -0.27093992f, -0.00577742f, -0.04731040f, -0.57267439f, 0.35545188f, -0.14400010f, -0.01486347f, 
    -0.16116770f, 0.19611682f, -0.03589890f, 0.17359655f, -0.09478991f, -0.14917246f, -0.00025191f, -0.05780916f, 
    0.02214390f, -0.19046919f, -0.09737366f, 0.09157691f, -0.03955146f, 0.03921523f, 0.08231912f, 0.01753193f, 
    0.11678323f, 0.30643296f, 0.26072773f, 0.16081554f, 0.18078870f, -0.22209340f, 0.11864042f, -0.00636131f, 
    -0.12103031f, -0.09746463f, -0.14692949f, 0.05082897f, -0.22039114f, -0.05199439f, 0.07495590f, 0.13160057f, 
    -0.10515054f, 0.06351477f, 0.08473218f, 0.07482662f, 0.08060836f, 0.22819957f, -0.06348954f, -0.05901894f, 
    -0.02458981f, 0.11462539f, 0.01078425f, 0.03593792f, -0.06308871f, -0.06439812f, 0.25656351f, 0.03379565f, 
    -0.09833641f, 0.03402488f, 0.09512249f, 0.00093978f, 0.03748578f, 0.19957428f, -0.03594561f, 0.11451276f, 
    -0.29858133f, -0.37772048f, -0.04142636f, 0.13217409f, 0.02892980f, -0.04588120f, 0.10057286f, 0.26192024f, 
    -0.13989718f, -0.06233183f, -0.19380017f, -0.06318764f, -0.15853192f, -0.03226184f, 0.12237344f, -0.12440650f, 
    -0.04781865f, 0.09522326f, 0.11501084f, -0.18757562f, 0.03540047f, 0.00217118f, -0.34020340f, 0.37038067f, 
    -0.13728315f, -0.15312009f, 0.07844675f, 0.12806812f, 0.02520016f, 0.11402057f, 0.02456268f, 0.04280505f, 
    0.08217304f, 0.11935160f, 0.07381255f, 0.05386739f, -0.01167205f, -0.12418331f, -0.18881369f, -0.06810667f, 
    -0.14669576f, -0.04545576f, -0.03257998f, -0.13974425f, 0.12880103f, -0.08389627f, 0.10197020f, -0.12971213f, 
    -0.08171310f, 0.11156705f, -0.04594814f, 0.01715481f, 0.09811486f, -0.05325025f, -0.08126266f, 0.08736590f, 
    0.01023470f, 0.25317088f, -0.08646058f, 0.01476581f, -0.35595432f, -0.41330150f, -0.15280846f, 0.03021769f, 
    0.33318830f, -0.08059262f, 0.16226676f, 0.07288886f, -0.04813603f, -0.02482648f, -0.02698622f, -0.11326183f, 
    0.01959987f, 0.00961825f, -0.32970315f, 0.07601732f, 0.01558470f, 0.08508346f, 0.03825369f, -0.05484530f, 
    0.36941332f, -0.11895151f, 0.13530207f, 0.04191707f, 0.30106804f, 0.17979348f, 0.11425649f, 0.15987061f, 
    0.03934758f, -0.02442243f, -0.19076531f, 0.00814921f, -0.29453370f, -0.01970978f, -0.18557446f, 0.05932005f, 
    0.09564076f, 0.20383103f, 0.14901447f, 0.19038294f, -0.04059510f, -0.24428722f, 0.07769778f, -0.14794575f, 
    0.29763651f, 0.25220305f, -0.09587553f, 0.01119812f, 0.08441956f, -0.04883664f, -0.02301479f, -0.00581921f, 
    0.15523794f, 0.08148547f, -0.02213845f, 0.05567969f, 0.10912418f, -0.16563159f, 0.06463408f, 0.14867187f, 
    -0.30643222f, 0.26830807f, -0.01477831f, -0.05322189f, -0.49466512f, 0.02672455f, 0.17697537f, 0.13232583f, 
    0.11978473f, -0.02407330f, -0.04415876f, -0.14357705f, -0.06769657f, -0.02469561f, 0.00420901f, 0.11105568f, 
    0.03255336f, 0.08743494f, -0.04848561f, 0.29013431f, -0.54682720f, 0.11154690f, -0.12271182f, -0.48519704f, 
    0.19196323f, -0.01077241f, 0.04501538f, 0.08027047f, -0.28610563f, -0.03806296f, -0.04935230f, -0.22630642f, 
    0.14531603f, 0.01562744f, -0.01904923f, -0.02981252f, -0.03735400f, 0.07249711f, 0.21778762f, -0.06210805f, 
    -0.00630090f, 0.07611580f, -0.39791498f, -0.25827655f, 0.03282043f, -0.00434091f, 0.01610298f, -0.04504046f, 
    -0.13142233f, 0.03401530f, -0.01590672f, -0.16749614f, -0.21272302f, -0.18249327f, -0.04267590f, -0.02650787f, 
    -0.15619797f, 0.28273115f, 0.14676975f, 0.08237275f, -0.45764542f, 0.62290776f, 0.03828888f, 0.02605336f, 
    -0.48618817f, 0.10266774f, -0.02713369f, 0.00464872f, 0.06968950f, -0.03204441f, -0.03332062f, 0.06553894f, 
    -0.06819662f, -0.02787408f, -0.32401225f, 0.10226248f, -0.07484773f, -0.04311597f, 0.06635541f, -0.02170773f, 
    -0.09492175f, -0.05618934f, -0.22209558f, 0.30864054f, 0.06885179f, 0.06665634f, 0.19398822f, -0.12740542f, 
    0.26272941f, 0.17222987f, -0.15733820f, 0.22974379f, 0.02817093f, -0.13276801f, 0.05976378f, -0.08646110f, 
    0.01513959f, 0.19286563f, -0.28015241f, -0.06138639f, -0.25498843f, 0.53536642f, 0.25326079f, 0.27775988f, 
    -0.62952310f, 0.00403745f, -0.22195703f, 0.10736871f, -0.01100485f, 0.01318406f, 0.12899098f, 0.01352159f, 
    -0.14143169f, 0.10984462f, -0.07733319f, -0.10828711f, -0.15320762f, -0.17696220f, -0.02582961f, -0.22349171f, 
    0.53579390f, -0.31795421f, 0.12850001f, -0.46540004f, 0.15967427f, -0.25168636f, -0.12441747f, -0.11950129f, 
    -0.12474032f, -0.03375858f, 0.06253701f, 0.19201173f, -0.03491416f, 0.13458396f, 0.12615392f, 0.12752607f, 
    0.10734412f, -0.07686755f, -0.03459996f, 0.14387111f, 0.42280900f, -1.00692928f, -0.14902151f, 0.12207533f, 
    -0.05519304f, 0.01964247f, 0.04727837f, 0.02905197f, 0.00372674f, -0.06460802f, -0.05093006f, 0.13855271f, 
    0.08150992f, 0.06873673f, 0.16817653f, -0.07061300f, -0.02025290f, 0.04515487f, -0.21316347f, 0.04331790f, 
    0.09355648f, -0.12757890f, 0.09878436f, 0.22909695f, 0.36256552f, 0.02125711f, -0.07297322f, -0.02410615f, 
    -0.01051972f, -0.04982906f, -0.11111403f, 0.02912696f, 0.20956230f, 0.11083743f, 0.02809509f, -0.05983616f, 
    0.03695446f, -0.23626086f, -0.10829756f, -0.21897151f, -0.18188070f, -0.60257089f, 0.07881629f, -0.06254005f, 
    -0.49064118f, -0.06004981f, -0.03067374f, 0.02318166f, -0.05669075f, 0.00070226f, -0.12595369f, -0.01526948f, 
    0.23371303f, -0.05328695f, 0.07397281f, 0.09775149f, -0.09073498f, 0.09450978f, -0.05102353f, -0.10412175f, 
    -0.08882982f, 0.05216242f, -0.39963642f, -0.01406168f, 0.07444876f, 0.13386486f, -0.18300764f, -0.04018405f, 
    0.11495569f, -0.00820378f, -0.02232206f, -0.00767119f, -0.19339654f, -0.05912657f, 0.14535096f, -0.13534549f, 
    -0.22632980f, 0.05535574f, 0.05948246f, -0.18263556f, 0.14413600f, -0.17240858f, -0.15847237f, -0.26236194f, 
    -0.10003790f, 0.12486248f, -0.08590461f, 0.06690000f, -0.04580661f, -0.21642333f, 0.00639225f, 0.15638271f, 
    -0.01395859f, -0.14578746f, -0.23157020f, 0.07359117f, 0.00752568f, -0.01622632f, -0.00289311f, -0.00419549f, 
    -0.11545762f, 0.28523037f, -0.33950824f, 0.14979890f, 0.04570368f, -0.19361517f, 0.06052999f, -0.09160110f, 
    0.02317887f, 0.00192012f, -0.19700103f, -0.00017530f, -0.03923279f, 0.05447728f, -0.04598609f, -0.02687522f, 
    0.01912801f, -0.04797983f, -0.13530847f, 0.00194773f, -0.15944132f, 0.24619499f, -0.00187625f, -0.06865881f, 
    0.28681836f, -0.12160269f, 0.28613028f, -0.04628222f, -0.11466724f, 0.02728424f, -0.17415315f, 0.00847782f, 
    -0.05618331f, -0.12970394f, -0.06395398f, -0.08001839f, -0.00186220f, 0.20551626f, -0.11726265f, 0.04393945f, 
    -0.06794022f, -0.15450120f, 0.07537291f, 0.18609817f, -0.24028505f, 0.21281438f, -0.11150648f, -0.08685326f, 
    0.15657182f, 0.08481306f, -0.21199401f, 0.05468175f, 0.04321289f, 0.02855770f, -0.17962493f, 0.16773443f, 
    0.02537430f, 0.01657767f, -0.15205126f, -0.00963422f, 0.39393979f, 0.10585588f, 0.49396554f, -0.34725884f, 
    0.26973066f, -0.27166680f, 0.14142112f, -0.16349770f, -0.06344169f, 0.13845757f, 0.04942039f, 0.17609954f, 
    -0.05653699f, -0.09277602f, -0.00093994f, 0.09187821f, 0.05132227f, 0.01940929f, 0.09359755f, -0.11046270f, 
    -0.17137837f, 0.12306482f, -0.45321393f, 0.31951341f, 0.18643519f, -0.05395985f, -0.22431149f, 0.11144821f, 
    0.00134936f, -0.01567046f, -0.05613996f, -0.05534846f, 0.06316117f, 0.10601726f, -0.13942592f, -0.02979095f, 
    -0.13637568f, -0.11533982f, 0.01642866f, -0.12873836f, 0.28134120f, 0.21046625f, 0.44260687f, -0.05211599f, 
    0.29243189f, 0.10568216f, 0.12915950f, -0.13177200f, -0.08840049f, -0.01503903f, -0.09519595f, -0.00815171f, 
    -0.03941466f, -0.13414314f, -0.12024804f, 0.00417797f, -0.08222011f, 0.09117993f, 0.17580789f, -0.10984382f, 
    0.20482010f, 0.05445916f, 0.19621450f, 0.20700103f, 0.36798301f, 0.02528305f, 0.04998556f, -0.04929157f, 
    -0.18068507f, -0.11432860f, -0.10028772f, 0.01417990f, -0.11368737f, -0.20122580f, -0.16567661f, -0.09723155f, 
    0.02832138f, -0.02381583f, 0.09267721f, 0.07541414f, -0.51744610f, -0.17702743f, -0.61284590f, -0.20102678f, 
    -0.21018788f, -0.08141673f, -0.15367487f, -0.12422671f, -0.01952922f, -0.06645264f, -0.12251531f, -0.08418376f, 
    0.09044535f, -0.16790700f, -0.13430652f, -0.17986399f, 0.02420748f, 0.07140902f, 0.04016075f, 0.16993931f, 
    -0.67468071f, 0.22626044f, -0.03078211f, -0.03002241f, 0.04226563f, -0.21694092f, -0.12497446f, -0.06120568f, 
    -0.04902283f, -0.08232798f, 0.22830027f, -0.10325267f, -0.08366992f, 0.02634050f, -0.07895092f, -0.00897466f, 
    -0.06253854f, 0.06247081f, 0.00054466f, -0.07852253f, 0.02709278f, -0.78057879f, -0.09367334f, -0.30469820f, 
    -0.38674626f, 0.04579676f, -0.17796284f, 0.01310949f, -0.08443108f, -0.13169315f, -0.05411931f, -0.16161582f, 
    -0.22679698f, 0.17668331f, -0.05152510f, 0.02075685f, 0.11529423f, -0.01574079f, -0.02223062f, -0.04675978f, 
    -0.11170278f, 0.30227664f, 0.36429909f, 0.25604349f, 0.31339961f, 0.15528779f, 0.24719213f, 0.10332899f, 
    0.00520463f, -0.05195221f, -0.09478737f, 0.01488537f, 0.01703039f, -0.04915340f, -0.14587957f, -0.06192996f, 
    0.12169705f, 0.03275375f, 0.03229481f, -0.10632791f, 0.11180220f, 0.02245839f, 0.16336733f, 0.00146159f, 
    0.39009532f, 0.19806847f, 0.15255246f, -0.08364897f, -0.03066038f, -0.04045587f, 0.12857926f, 0.03269996f, 
    0.08020549f, -0.03672645f, 0.02598231f, -0.16253830f, -0.02398797f, -0.07483604f, -0.01313801f, 0.00116106f, 
    -0.19323689f, -0.03335540f, -0.18070373f, -0.23303066f, -0.02465610f, -0.16459115f, -0.08283103f, 0.05260857f, 
    -0.04421574f, -0.09825601f, 0.10773841f, -0.07330118f, 0.01742633f, 0.00683351f, -0.04422092f, -0.00077378f, 
    -0.10861993f, 0.01823447f, 0.00876352f, -0.03971534f, 0.31370944f, -0.18585263f, 0.08999708f, -0.05413549f, 
    -0.37048081f, 0.15997797f, -0.12081864f, -0.03080942f, -0.19356927f, -0.01777526f, 0.02635956f, 0.11558752f, 
    -0.08808208f, 0.12449393f, -0.12243125f, 0.04269296f, 0.04566144f, -0.02408086f, -0.02787755f, -0.12959096f, 
    -0.09773326f, 0.20702054f, 0.01685563f, -0.03080139f, -0.00710342f, 0.03526688f, -0.22183774f, 0.09692204f, 
    -0.05042611f, -0.09720838f, 0.13819548f, -0.00193243f, 0.11050981f, 0.13170727f, -0.12292075f, 0.06172038f, 
    -0.03618286f, 0.07514732f, -0.10018120f, -0.01308436f, 0.26567280f, -0.10542998f, -0.05496681f, -0.03827630f, 
    0.05540359f, -0.09982059f, -0.12784684f, -0.03436181f, -0.01982665f, 0.00768460f, -0.05769904f, 0.01932760f, 
    0.06063925f, -0.21857873f, 0.11643834f, -0.02054008f, -0.14482346f, 0.11063065f, 0.05016204f, -0.00904397f, 
    0.04305713f, 0.03630972f, -0.12381196f, 0.00241656f, -0.19522311f, -0.18119988f, 0.05657183f, -0.10742105f, 
    -0.19515045f, -0.02255552f, 0.07408080f, 0.09700007f, 0.17948306f, 0.14665775f, -0.00331572f, -0.06729020f, 
    0.06084142f, -0.22555135f, 0.12403067f, 0.05795808f, -0.04763234f, 0.27687824f, -0.14282493f, 0.04284205f, 
    -0.41260034f, -0.35179797f, -0.13248952f, -0.00780570f, -0.11003376f, -0.06188865f, 0.22555578f, -0.04939618f, 
    -0.09325459f, -0.09659570f, -0.00800891f, -0.12704621f, -0.13899173f, -0.32650340f, 0.21205322f, -0.01206067f, 
    -0.20618299f, 0.23551153f, -0.45535555f, 0.09457070f, -0.05717276f, 0.10621334f, -0.02641266f, -0.19444944f, 
    -0.03966290f, 0.13532585f, 0.05630146f, -0.05167047f, 0.07490498f, -0.09862577f, 0.00804867f, -0.03809144f, 
    0.03352184f, -0.09021784f, 0.20095418f, -0.08167548f, -0.33591142f, 0.41278100f, -0.05963570f, -0.26626828f, 
    -0.05403006f, -0.06703503f, -0.09215700f, -0.03388304f, 0.10432631f, -0.02684727f, 0.09378484f, -0.03798806f, 
    -0.28621727f, 0.05992540f, 0.07746774f, -0.01664929f, 0.01007884f, 0.12289929f, 0.13089061f, 0.19007646f, 
    -0.10648365f, -0.25557160f, -0.09478772f, 0.13328941f, 0.18218301f, -0.07878575f, 0.13145472f, -0.16412035f, 
    -0.17474174f, -0.01340201f, 0.03722332f, -0.01797503f, 0.33324742f, 0.06220431f, 0.22617343f, -0.05541166f, 
    0.00530995f, -0.02634026f, 0.12277167f, -0.33850256f, -0.40169641f, 0.07584159f, 0.26615313f, -0.32522911f, 
    -0.15084688f, -0.07054273f, 0.02768864f, -0.03465372f, -0.17632249f, -0.24570870f, -0.04546628f, 0.00846222f, 
    0.01797121f, 0.10945009f, -0.06564446f, 0.08719097f, 0.02841802f, -0.17826341f, -0.44237667f, -0.06941958f, 
    -0.39726791f, -0.24211641f, 0.35027531f, -0.44622397f, -0.36118945f, 0.00853251f, -0.11305650f, -0.12107636f, 
    0.00598144f, -0.09840915f, 0.01237658f, 0.08839691f, -0.10598030f, 0.12752190f, -0.04157259f, -0.01884466f, 
    0.00692963f, -0.06746515f, -0.64332348f, -0.01466035f, 0.04021175f, -0.02117355f, -0.26679158f, -0.04026673f, 
    0.03081473f, 0.28920850f, 0.04054254f, -0.08424376f, 0.01549093f, -0.08304996f, -0.01699619f, 0.01963818f, 
    0.04008364f, 0.12256005f, -0.02797498f, 0.00721852f, 0.10413592f, 0.17380920f, 0.09710933f, -0.19044144f, 
    0.20881392f, 0.23908944f, -0.39581394f, 0.13022435f, -0.14186855f, -0.04151049f, 0.14218320f, -0.11724086f, 
    0.00151542f, 0.02460977f, 0.04466157f, -0.05275201f, 0.03902784f, 0.16630132f, -0.01683334f, 0.12144643f, 
    -0.04949814f, -0.06165394f, 0.18404900f, -0.07281264f, 0.20040704f, -0.17750280f, -0.01256904f, 0.37970152f, 
    0.28981647f, 0.14592604f, 0.07393579f, -0.19192751f, -0.05358766f, -0.06981948f, -0.04717051f, -0.02060089f, 
    0.05472909f, -0.00323432f, 0.15095645f, -0.04793871f, 0.06462689f, 0.12867761f, 0.13273378f, -0.12034148f, 
    -0.29116854f, -0.25509200f, 0.36510727f, -0.03158984f, 0.05250045f, -0.01128613f, -0.21864972f, 0.07884129f, 
    -0.14523940f, -0.01432950f, -0.00475894f, 0.01850396f, -0.06302836f, -0.14696607f, -0.11287894f, 0.04131858f, 
    -0.03906294f, -0.22460562f, 0.02227274f, 0.00908926f, -0.00871696f, -0.14536975f, 0.23932239f, 0.08765908f, 
    0.25464749f, -0.23015627f, -0.11635894f, -0.02189285f, -0.21970232f, 0.02936016f, 0.07127090f, -0.06187632f, 
    0.02333281f, -0.07827939f, 0.05247596f, 0.09286666f, -0.08356361f, -0.00609402f, 0.16063711f, 0.15311101f, 
    0.19660746f, 0.24836203f, 0.01114819f, 0.07985235f, 0.13540354f, 0.05387166f, -0.14015515f, -0.19415191f, 
    -0.18055604f, -0.09499846f, 0.19003865f, -0.05401322f, -0.08925711f, -0.10152454f, -0.17141144f, -0.06085407f, 
    0.01851167f, 0.12231221f, 0.09113046f, -0.13284646f, 0.17186809f, 0.11145470f, -0.06946690f, 0.19892241f, 
    0.19460775f, -0.22783467f, -0.20804971f, -0.10137355f, -0.32960263f, 0.06874380f, -0.13409264f, -0.08873776f, 
    -0.19511658f, 0.06556323f, 0.02517247f, 0.18643430f, -0.09562791f, 0.04590628f, 0.03814339f, 0.06366175f, 
    0.42915767f, 0.15785263f, -0.39706108f, -0.30877176f, -0.24436976f, -0.16257405f, -0.08265731f, 0.15421443f, 
    0.25859329f, -0.08312713f, -0.10206099f, -0.01300424f, 0.05749617f, -0.04010219f, 0.03333591f, -0.05331075f, 
    0.11136499f, -0.17298618f, 0.12928604f, 0.16721682f, -0.16159193f, -0.07297696f, 0.19557261f, -0.13765514f, 
    0.06110670f, 0.21222271f, -0.05855187f, -0.06043666f, 0.16552417f, -0.16907515f, -0.07473721f, 0.05636487f, 
    0.09123857f, 0.01441854f, -0.17938954f, -0.12006842f, 0.07772599f, -0.33095852f, 0.17769054f, -0.12463911f, 
    -0.25708950f, 0.29007310f, -0.26919788f, -0.31120530f, -0.23250507f, 0.07436363f, 0.17015283f, 0.08551211f, 
    0.09177615f, -0.19128169f, -0.13479429f, 0.10530802f, -0.00739019f, 0.02354621f, 0.15106180f, 0.00972619f, 
    0.11541191f, 0.05013606f, -0.00146392f, -0.05850669f, -0.90498281f, 0.45540005f, 0.21808733f, 0.04355019f, 
    -0.02551846f, 0.25438234f, 0.00146894f, 0.05417819f, 0.11084516f, 0.05870625f, 0.00544291f, 0.00832661f, 
    0.13092376f, 0.02225081f, 0.26534185f, 0.20216697f, 0.09861742f, 0.24408525f, -0.25996459f, 0.09528140f, 
    0.31186813f, -0.61111248f, 0.09506454f, -0.21298410f, 0.18698995f, -0.03302445f, -0.00131701f, -0.07204670f, 
    0.15612474f, -0.23307137f, 0.08960026f, -0.15986001f, 0.04423448f, 0.08739864f, 0.05458052f, 0.07963777f, 
    -0.05485303f, 0.03969136f, -0.18572688f, -0.09167443f, -0.19018668f, -0.06755217f, -0.15301952f, 0.39729008f, 
    -0.14059632f, -0.06007729f, 0.07443856f, -0.01589279f, 0.04429388f, 0.02655694f, -0.07184662f, 0.02042367f, 
    0.11838055f, 0.00374044f, 0.15709582f, 0.12113286f, -0.06698379f, 0.02427607f, -0.21094272f, -0.09328114f, 
    -0.53024143f, 0.42482620f, -0.04509882f, -0.39026970f, -0.22199662f, -0.13167639f, 0.09243502f, -0.25322998f, 
    0.07251875f, 0.11403634f, -0.19844241f, 0.24182385f, -0.06497637f, 0.05613820f, 0.01196974f, 0.17116806f, 
    0.02814711f, 0.17380527f, 0.18575309f, -0.10169473f, 0.05295905f, -0.47488782f, -0.08876848f, 0.29027659f, 
    0.09506039f, -0.16748500f, 0.05624230f, -0.13522570f, -0.14703639f, 0.05625487f, -0.01693898f, 0.16652286f, 
    -0.32342118f, 0.00010661f, 0.01323426f, -0.11883631f, 0.15114798f, 0.10223024f, 0.10863588f, 0.15265466f, 
    0.07463386f, -0.29222789f, -0.07621918f, 0.05174356f, -0.12898056f, -0.07640678f, 0.09888634f, 0.18977642f, 
    -0.14451730f, -0.08478886f, 0.14082810f, 0.15862811f, 0.03696618f, -0.11364300f, -0.09424354f, 0.02376436f, 
    0.02102713f, -0.11709458f, 0.23504494f, 0.10928515f, -0.12586486f, -0.10740218f, 0.33961806f, -0.43791825f, 
    -0.89387143f, -0.07738301f, 0.02897617f, 0.08230747f, -0.05364378f, 0.05792722f, -0.10054103f, -0.03730006f, 
    -0.11710679f, -0.20767769f, -0.06798101f, -0.11681209f, 0.04800690f, -0.06090092f, -0.07196579f, 0.02431398f, 
    -0.67449242f, 0.42351976f, 0.48977542f, 0.11377846f, 0.24172708f, 0.22277178f, 0.15748324f, -0.05034903f, 
    -0.00376831f, -0.03925597f, -0.04462662f, 0.10379610f, -0.02152061f, 0.12618349f, -0.04370048f, 0.06091274f, 
    -0.00512217f, 0.09636685f, -0.09747666f, 0.06905320f, 0.23926398f, -0.59619242f, 0.47916365f, -0.10754985f, 
    -0.12357104f, 0.04959375f, 0.23541047f, -0.19137134f, -0.10778717f, -0.18495484f, -0.11326648f, 0.09936500f, 
    -0.14815485f, -0.02485907f, 0.04196544f, -0.12078982f, 0.02243513f, -0.21254680f, 0.02151544f, 0.00773176f, 
    0.01707022f, -0.29647017f, 0.01510113f, 0.28512436f, 0.09875102f, 0.14981663f, -0.14859945f, 0.02001793f, 
    0.05521217f, 0.23257828f, -0.14509414f, 0.01372686f, -0.00256722f, 0.17291653f, -0.07130364f, -0.12632789f, 
    -0.30043510f, 0.12838927f, 0.05556482f, -0.01826747f, 0.50241131f, -0.05530881f, -0.01308597f, -0.03146060f, 
    0.00261752f, 0.14140698f, -0.12865697f, 0.07255173f, -0.17330946f, 0.14915748f, -0.04413022f, 0.10123531f, 
    0.13356346f, 0.17257474f, -0.04750833f, -0.07946075f, 0.00326701f, -0.11415470f, -0.05859415f, -0.07113192f, 
    0.18741624f, -0.30686513f, -0.27887222f, 0.18635917f, -0.36588228f, 0.06321706f, 0.04819329f, 0.08099721f, 
    -0.05525884f, -0.13802208f, -0.07200892f, 0.09899149f, -0.11914025f, -0.10939518f, -0.20718324f, -0.06251781f, 
    0.01875055f, -0.12269603f, 0.03957424f, -0.14840655f, 0.11187442f, -0.57581371f, -0.05415554f, 0.18071654f, 
    -0.11070234f, 0.00251287f, -0.09203357f, 0.01368818f, 0.12492364f, 0.12030294f, -0.17789075f, 0.01498015f, 
    0.02219037f, -0.04303315f, -0.00736428f, -0.15112846f, 0.04997786f, -0.21539231f, -0.10702908f, 0.29409426f, 
    -0.25507221f, 0.04607879f, 0.25890538f, 0.03025065f, 0.06372659f, -0.03364809f, 0.04386275f, 0.06262675f, 
    0.08705956f, 0.21239272f, -0.21855721f, 0.02951368f, 0.05318763f, -0.06453988f, -0.01823504f, 0.20585793f, 
    0.24325807f, 0.23194672f, 0.28697777f, 0.21365806f, -0.76437044f, 0.00091119f, -0.10260314f, -0.20836227f, 
    -0.06454548f, 0.10507459f, 0.09024835f, -0.08941502f, -0.09912256f, 0.11576515f, 0.06554326f, -0.02468863f, 
    -0.00737130f, -0.09386378f, 0.02842162f, -0.07079206f, 0.17479961f, 0.23715495f, 0.12707047f, 0.17369026f, 
    -0.53441006f, -0.59620875f, 0.07429196f, 0.01306299f, -0.09442761f, 0.18243620f, -0.00355051f, 0.09812130f, 
    -0.06407931f, 0.17246649f, 0.21740477f, 0.05319190f, 0.08588920f, 0.03228544f, -0.00167370f, 0.03364977f, 
    0.13661379f, -0.02840176f, -0.04678774f, -0.03695549f, -0.35171303f, -0.27573028f, -0.08288705f, 0.00423968f, 
    0.11839586f, 0.04700461f, 0.14646974f, 0.14079534f, 0.07514011f, 0.03600775f, 0.12031312f, -0.08776095f, 
    0.10715988f, -0.16659273f, 0.10567964f, -0.01161411f, 0.02213261f, -0.07001077f, 0.14871214f, 0.00874806f, 
    -0.73904854f, -0.06444371f, -0.58437991f, -0.01473615f, 0.10122592f, 0.07747818f, 0.05443941f, -0.22945161f, 
    -0.04256828f, 0.07040519f, 0.10953732f, -0.07498652f, 0.08242643f, -0.20735586f, 0.35854429f, -0.00749026f, 
    0.00718632f, 0.02479717f, -0.05871814f, -0.14763819f, 0.19275033f, -0.22850552f, -0.02500822f, -0.08898951f, 
    0.41268465f, -0.15855663f, 0.03755798f, 0.00521804f, -0.07861203f, -0.18227175f, 0.04230016f, -0.07440661f, 
    -0.01566617f, -0.13023686f, 0.00114764f, -0.20617022f, 0.12045926f, 0.01490662f, -0.06595741f, 0.12583447f, 
    -0.82059705f, -0.44963220f, 0.29791769f, -0.29225326f, -0.33120459f, 0.03363938f, 0.08788912f, -0.07954353f, 
    -0.17518161f, 0.08628430f, 0.09430898f, -0.07103822f, 0.02587551f, 0.01318112f, -0.11752868f, -0.08236360f, 
    -0.09642453f, -0.14981948f, 0.01531524f, -0.07878325f, 0.25050351f, -0.06755705f, -0.04122725f, 0.03269739f, 
    -0.22406594f, 0.05934475f, 0.13240844f, -0.05798431f, 0.01497246f, 0.05403739f, 0.01692881f, 0.08811596f, 
    -0.03549185f, 0.05192347f, -0.01515826f, -0.00544435f, 0.05888254f, -0.24935947f, -0.28793651f, 0.00445269f, 
    0.57533950f, 0.28486472f, 0.13063914f, -0.23715471f, -0.09487709f, 0.20632850f, -0.02552538f, 0.22548902f, 
    0.02439753f, 0.01451956f, -0.00130114f, -0.17547637f, -0.07460620f, 0.09091118f, -0.07124519f, 0.05852000f, 
    0.06842419f, -0.17317168f, -0.02598667f, 0.04204549f, -0.61404538f, -0.16970739f, 0.00040796f, -0.25525472f, 
    -0.10058077f, 0.24566369f, 0.03209902f, -0.07798544f, -0.11936802f, -0.04430636f, 0.01247944f, 0.14582272f, 
    0.07486559f, 0.35283583f, -0.03005254f, 0.03139871f, 0.10275146f, -0.04434047f, -0.14498527f, -0.03643371f, 
    -0.09034577f, -0.08922985f, -0.17335330f, 0.05575464f, -0.18349586f, 0.01629677f, -0.04592292f, 0.10504737f, 
    0.14059071f, 0.07625399f, 0.27971020f, 0.05438206f, -0.03183058f, 0.03523735f, 0.08583827f, 0.08267407f, 
    0.09758083f, 0.07451890f, 0.29474008f, -0.01036541f, -1.07341838f, -0.69107038f, -0.57082510f, -0.23982364f, 
    -0.36142042f, 0.07964066f, 0.13038342f, -0.18714575f, -0.16472673f, 0.07166588f, -0.11211184f, -0.11461350f, 
    -0.06819274f, 0.10158166f, 0.00719343f, -0.04710571f, -0.08940398f, 0.06315240f, -0.01136694f, 0.07783455f, 
    0.50309169f, 0.26600564f, -0.23402664f, 0.25033215f, -0.26326716f, -0.17981941f, -0.22218864f, 0.15150130f, 
    0.02436907f, -0.04110679f, -0.04456285f, 0.07316479f, -0.00380370f, -0.19564927f, -0.10881716f, 0.04103598f, 
    0.01191155f, -0.05370530f, -0.05669403f, -0.11784549f, 0.24430512f, 0.24740505f, -0.19110839f, 0.04939337f, 
    -0.04982525f, -0.17974451f, -0.05513064f, -0.01343095f, 0.10087664f, 0.02627138f, 0.03576064f, 0.08116354f, 
    -0.00801777f, -0.19509245f, 0.04042505f, -0.13902327f, 0.01245696f, 0.26021105f, -0.15089989f, 0.11697543f, 
    -0.25658533f, -0.40704793f, -0.05099265f, -0.06949595f, 0.00618484f, 0.01389587f, 0.07574023f, -0.05172672f, 
    -0.17922565f, -0.06221369f, 0.09465288f, 0.01548357f, 0.05842469f, -0.02064974f, 0.07653823f, -0.16337676f, 
    0.08920176f, 0.19153818f, 0.05250518f, 0.20318870f, 0.04188690f, 0.10381833f, -0.30432391f, -0.03403400f, 
    -0.09236591f, -0.03808690f, 0.13116536f, -0.26811725f, 0.01559255f, 0.09963259f, 0.01858937f, 0.10643332f, 
    -0.13899550f, 0.02841550f, 0.19335869f, -0.08718890f, 0.09853996f, 0.11775666f, -0.08370331f, -0.03667742f, 
    -0.07096350f, -0.13928819f, 0.10449031f, -0.24435955f, 0.09081665f, -0.03162136f, -0.02079505f, -0.03228906f, 
    0.02542278f, 0.13454814f, 0.10348277f, -0.03054957f, -0.01251146f, -0.02577897f, -0.03885716f, 0.03944030f, 
    -0.01717863f, 0.05835356f, 0.06827506f, -0.34632331f, -0.06702826f, -0.04550024f, 0.17135596f, 0.03344461f, 
    -0.01452652f, -0.08788148f, 0.15926720f, 0.11440200f, 0.04338272f, 0.07223327f, -0.02064897f, 0.01801341f, 
    -0.12162815f, -0.03986849f, 0.06625291f, 0.13362530f, 0.02975491f, -0.11139064f, 0.07532323f, 0.01568564f, 
    0.14294435f, 0.14796422f, -0.04385896f, 0.18334147f, 0.05930974f, 0.37272495f, -0.18887575f, -0.14659870f, 
    0.05942692f, 0.01798478f, 0.20880975f, 0.17042597f, -0.06703521f, 0.02345253f, 0.03045989f, -0.05559251f, 
    0.11822900f, 0.27455607f, -0.08441405f, 0.04051542f, 0.01559393f, 0.01327793f, -0.02166993f, 0.29131532f, 
    -0.01658824f, 0.25932962f, 0.14276554f, -0.00888362f, 0.00417303f, 0.12635154f, -0.06062168f, 0.03417297f, 
    -0.14914683f, 0.09002539f, 0.23806797f, -0.17187181f, 0.16772333f, 0.08274180f, -0.16427404f, -0.01916735f, 
    -0.37942013f, 0.05251921f, -0.24618629f, 0.12742642f, -0.14233039f, -0.09721785f, 0.12077989f, -0.19322106f, 
    -0.03456106f, 0.00183977f, 0.02713277f, -0.06571645f, 0.12641753f, 0.20673662f, 0.05924701f, 0.13844919f, 
    0.05856530f, -0.10658900f, -0.08255231f, -0.05768616f, -0.73392159f, 0.43494511f, 0.14113605f, 0.12781386f, 
    -0.16913015f, 0.31994998f, 0.00522062f, 0.05439162f, -0.07830939f, 0.09662384f, 0.02077763f, -0.10243056f, 
    0.04380879f, -0.22222567f, -0.07823246f, 0.02533706f, 0.08690013f, -0.23768371f, 0.00293164f, -0.06597424f, 
    0.52334338f, 0.03335112f, -0.56287962f, -0.01928861f, -0.21172602f, 0.01403002f, -0.13721555f, 0.14145604f, 
    -0.07312978f, -0.11660698f, 0.09735778f, -0.00528217f, -0.04355338f, -0.04580193f, -0.18765281f, 0.02567090f, 
    0.08748492f, -0.01826440f, 0.04613762f, -0.09620450f, 0.06083259f, 0.36082074f, 0.03311957f, -0.23776276f, 
    0.01239691f, -0.19113939f, -0.30299789f, -0.05679972f, -0.22774829f, -0.32118654f, 0.13440649f, -0.00258927f, 
    0.13910095f, -0.14970437f, -0.01525761f, 0.17010336f, 0.13441181f, 0.07178729f, 0.19197148f, -0.05481674f, 
    -0.08412222f, 0.15635975f, -0.35184100f, -0.42354342f, 0.23328269f, -0.16684106f, -0.15579616f, 0.05054457f, 
    -0.02532132f, -0.07286173f, -0.05598257f, -0.02606832f, -0.09331515f, -0.00283730f, 0.08463354f, 0.22375888f, 
    -0.02556054f, -0.07524075f, 0.32745320f, 0.01978412f, 0.83730167f, 0.33870766f, -0.51142412f, -0.14748310f, 
    0.11978321f, 0.22274272f, 0.08514746f, 0.02404406f, 0.12163154f, -0.00487156f, 0.22024609f, 0.17249106f, 
    -0.02660830f, -0.00391146f, 0.06190398f, 0.02156323f, -0.04241224f, -0.01817651f, 0.08362610f, 0.15210930f, 
    0.28909943f, -0.46398869f, 0.15547064f, 0.11475927f, -0.30109766f, 0.02371689f, 0.15817998f, 0.08899201f, 
    -0.12902421f, 0.08804221f, 0.00678150f, -0.08187364f, 0.11799162f, -0.01916202f, -0.23166479f, -0.01973118f, 
    -0.14460362f, -0.08537923f, -0.14036743f, -0.14544976f, 0.62240714f, -0.19844924f, -0.39592060f, -0.13469082f, 
    -0.53985035f, -0.17701264f, -0.03330478f, 0.05878578f, 0.06420088f, 0.04530248f, 0.08421033f, -0.13714799f, 
    0.09177805f, -0.08486666f, 0.13797742f, -0.10363557f, -0.11999910f, -0.16278534f, 0.01814327f, 0.13202439f, 
    0.41696605f, -0.15848038f, 0.17183088f, 0.00269021f, -0.01252503f, -0.09610176f, 0.04753184f, 0.15155315f, 
    -0.14286125f, -0.20982759f, -0.04263902f, -0.18259595f, -0.06500663f, 0.21101595f, -0.09717828f, -0.05104825f, 
    -0.10228964f, -0.10930724f, -0.15329574f, -0.03313718f, -0.69054198f, 0.06374580f, -0.15598820f, 0.06185110f, 
    0.20091021f, -0.11814629f, 0.10616165f, -0.11573855f, 0.05292293f, 0.03397807f, -0.08236286f, -0.04518304f, 
    0.08933771f, 0.01939610f, 0.04851630f, -0.09587612f, -0.20019510f, 0.04825785f, -0.22538456f, -0.18446960f, 
    -0.70998532f, -0.37226173f, -0.29721144f, -0.17968166f, -0.21579850f, 0.18199982f, -0.02281426f, 0.23287657f, 
    -0.00603592f, 0.20127019f, 0.01209188f, 0.07982944f, -0.06237510f, 0.06306869f, -0.01031865f, -0.02763351f, 
    -0.05880873f, -0.02892102f, -0.10747541f, -0.16848986f, -0.51249534f, -0.17626055f, -0.18929411f, -0.16758445f, 
    -0.30069414f, -0.00974004f, 0.01190869f, -0.08450100f, 0.11740308f, 0.02378582f, -0.12777124f, 0.17530264f, 
    0.23042017f, -0.06814645f, -0.01665026f, -0.09943656f, -0.02194581f, -0.11162639f, -0.30652097f, -0.10895949f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.16117834f, 0.02246070f, -0.03767386f, 0.06526705f, 0.05006983f, -0.03508287f, 0.02431523f, -0.14830522f, 
    -0.07359359f, -0.03051973f, 0.15121353f, 0.03546760f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
