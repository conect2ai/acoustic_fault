#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.70841336f, -0.77734375f, -0.11417340f, 0.26773334f, 0.36959523f, 0.21110523f, 0.08206310f, -0.15236710f, 
    -0.01194641f, 0.86221415f, 0.52373946f, -0.76859486f, -0.07723347f, -0.30402595f, 0.04397107f, -0.08256028f, 
    0.10911609f, -0.02218809f, -0.02300246f, -0.19643953f, -0.37199304f, -0.54824215f, -0.40707493f, -0.59896964f, 
    0.48690417f, 0.47424212f, 0.14912435f, 0.61138022f, -1.14637589f, 0.22327188f, -0.15926704f, -0.25426540f, 
    0.36830407f, -0.12986562f, -0.15138946f, -0.08386464f, 0.52381891f, 0.14689329f, -0.15823196f, 0.25577763f, 
    0.24892786f, 0.04550623f, 0.06651618f, 0.44125342f, 0.06779715f, -0.69238514f, -0.11389541f, -0.81974691f, 
    0.49235433f, 0.10214274f, 0.65355486f, 0.09110165f, 0.38063541f, 0.15834959f, 0.11510091f, -0.12815358f, 
    -0.23358354f, -0.15106276f, 0.86321115f, -0.86268383f, 0.36147752f, -0.16924144f, 0.34653810f, 0.09128234f, 
    -0.20951316f, -0.73918891f, 0.45449492f, -0.54884827f, -0.21818642f, -0.46274874f, -0.17609981f, 0.00548043f, 
    -0.13602473f, 0.23165181f, 0.31937402f, 0.32111073f, -0.08437273f, 0.03938473f, 0.08678471f, -0.38233292f, 
    -0.41601089f, -0.52245790f, -0.05619770f, 0.17070584f, 0.20461032f, 0.63744503f, 0.36868393f, 0.16507019f, 
    0.03323182f, 0.22883023f, -0.55195802f, 0.02953412f, -0.66099238f, -0.20974283f, 0.83836740f, -0.56667107f, 
    0.07316977f, -0.24152577f, -0.39169455f, 0.20281933f, -0.47304425f, 0.21931916f, -0.18601424f, -0.35557625f, 
    -0.60222149f, -0.42829597f, -0.32013130f, -0.24254322f, -0.05415849f, 0.07002980f, -0.11981515f, -0.61129034f, 
    0.41047752f, 0.09469863f, -0.34615049f, -0.22376445f, 0.75669199f, 0.68165183f, 0.51136363f, 0.63627923f, 
    0.02546292f, -0.02388599f, 0.24503171f, 0.23167898f, 0.14158167f, 0.19491069f, 0.12601234f, -0.60141450f, 
    -0.34964707f, -0.46850750f, 0.47805944f, -0.14361434f, -0.06728135f, -0.30675703f, -0.51417422f, 0.71375030f, 
    -0.90788633f, -0.85341102f, 0.15064880f, 0.52952540f, -0.01494188f, 0.13924199f, 0.34755766f, -0.02890698f, 
    0.41301042f, 0.51273286f, 0.52901250f, -0.15021227f, -0.63461983f, -0.41478205f, 0.04509955f, -0.03965697f, 
    0.21883005f, 0.47898236f, 0.47128218f, 0.55881381f, 0.04950132f, 0.50531721f, 0.03419096f, -0.07358464f, 
    -0.42867205f, -0.31146780f, 0.13323019f, -0.14402433f, -0.53253114f, 0.50299752f, 0.15746239f, 0.80301529f, 
    -0.46546453f, -0.36755043f, -0.30565229f, -0.74904740f, -0.08376748f, -0.00080851f, -0.17491347f, -0.46221676f, 
    -0.24936377f, -0.19028097f, 0.17114605f, 0.21328087f, 0.69004190f, 0.01909923f, -0.04255617f, -0.18208979f, 
    0.27113912f, 0.19373691f, -0.23674245f, 0.69660813f, -0.47036484f, 0.20787740f, 0.53731418f, -0.43694818f, 
    -0.36271322f, 0.30825561f, 0.05890033f, 0.40987828f, 0.05541049f, 0.14611585f, 0.20002802f, 0.19735068f, 
    -0.17066009f, -0.07618927f, -0.18891469f, 0.33256093f, 0.74637520f, -0.53620958f, -0.11116226f, -0.22727865f, 
    -0.24344489f, 0.65693647f, 0.48448265f, 0.45783415f, -0.19247456f, 0.12426033f, -0.01644237f, -0.05122402f, 
    -0.61939162f, 0.05542615f, 0.41968793f, -0.42920333f, -0.37072769f, -0.12677063f, -0.06801341f, 0.60478812f, 
    -0.62617141f, 0.62568277f, -0.15113528f, -0.06766636f, -0.47008383f, 0.02007709f, -0.21579875f, -0.24267499f, 
    0.24865556f, 0.44612285f, -0.21394472f, 0.19401596f, 0.65996021f, -0.02740491f, 0.25755635f, -0.07180144f, 
    -0.51422727f, -0.22470197f, -0.13865685f, -0.34958732f, 0.84713304f, -0.30892619f, 0.05495638f, 0.40263790f, 
    0.21994849f, -0.10957032f, 0.61095446f, -0.47404593f, 0.02591433f, 0.06032460f, -0.04271661f, -0.52981603f, 
    -0.51823074f, -0.51042694f, 0.13273942f, 0.50190473f, 0.40458539f, 0.26673970f, 0.24493186f, -0.72496247f, 
    0.29012337f, -0.06323154f, -0.20705323f, -0.30294421f, 0.30962840f, -0.60756773f, 0.00559378f, 0.28247780f, 
    0.00604235f, 0.33802485f, 0.37235990f, 0.03306748f, 0.08263028f, 0.39031467f, 0.29436013f, 0.64759457f, 
    -0.97999579f, 0.59387368f, -0.29319581f, -0.11789964f, 0.32584986f, -0.20667987f, 0.21028273f, 0.13262127f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.11439926f, 0.10422492f, -0.26359671f, 0.18657421f, 0.27031636f, -0.04795662f, 0.04094170f, -0.17933030f, 
    0.30309609f, 0.12421128f, -0.05927407f, -0.18953142f, -0.20673439f, -0.12503535f, -0.11103892f, 0.00849311f, 
    0.22125062f, -0.35392970f, -0.04865881f, -0.42115185f, -0.31278080f, 0.38485107f, -0.11641217f, 0.19175531f, 
    -0.14448383f, -0.03108234f, 0.16190098f, -0.18966548f, 0.21760038f, 0.35065597f, -0.31998247f, 0.05810304f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.31160492f, -0.01882295f, -0.16397925f, -0.15894517f, -0.04548726f, -0.16093592f, -0.08169442f, -0.00430141f, 
    0.01035906f, 0.43244588f, 0.12435564f, -0.06187232f, -0.02290242f, 0.10445087f, 0.11032526f, 0.10842174f, 
    -0.03561484f, 0.13508941f, -0.21937342f, 0.04444088f, -0.04346912f, -0.14242522f, 0.00671065f, -0.15672323f, 
    -0.02576566f, 0.08833064f, -0.05378863f, 0.25334638f, -0.05632463f, 0.08621129f, 0.08348735f, 0.00883525f, 
    0.20062663f, -0.00654035f, -0.12938790f, 0.07190422f, 0.07171502f, -0.06900496f, 0.09972045f, 0.00549778f, 
    0.11983384f, -0.01166214f, 0.01496542f, 0.01486617f, 0.13601732f, -0.13701503f, 0.13331608f, -0.27213979f, 
    -0.00509916f, -0.04358141f, -0.11030270f, 0.05394873f, 0.06240296f, -0.05773164f, -0.26727441f, -0.23548764f, 
    0.53242660f, -0.09510697f, -0.00806635f, -0.11595178f, 0.08265821f, 0.02352988f, -0.04437306f, -0.16182138f, 
    0.12641083f, -0.00517096f, -0.21540050f, 0.11564308f, 0.05590736f, 0.05386662f, -0.15038766f, -0.09298119f, 
    -0.00487681f, 0.11529720f, 0.16542026f, 0.04049378f, -0.02319081f, 0.02471167f, 0.01666431f, 0.00140952f, 
    0.08924280f, 0.01299916f, 0.01356412f, -0.03622952f, 0.08897690f, -0.03729818f, -0.02048470f, 0.00638635f, 
    0.16102707f, 0.17260423f, -0.26949167f, -0.01872259f, 0.37311462f, 0.03024422f, 0.16797981f, 0.05805206f, 
    -0.02459539f, 0.06488959f, 0.14057380f, 0.07912534f, -0.00754845f, -0.00643664f, -0.10660809f, 0.04636708f, 
    0.05324971f, -0.01222615f, 0.03247350f, -0.05177995f, -0.32267773f, 0.12235413f, 0.16521659f, -0.04181612f, 
    -0.07081137f, -0.01832604f, 0.19633293f, -0.05371594f, -0.01524430f, 0.16382293f, 0.16437814f, -0.01308193f, 
    -0.04283053f, -0.16645472f, -0.03804712f, 0.04036595f, -0.00897183f, -0.15387514f, -0.06547174f, -0.16170478f, 
    0.05491433f, -0.03414798f, 0.07664783f, -0.01373378f, -0.03654161f, -0.01330684f, 0.04079042f, -0.14499862f, 
    -0.36137953f, 0.14383057f, 0.06472807f, 0.13541469f, 0.29375929f, 0.03937078f, -0.04600643f, -0.02626440f, 
    0.20596138f, 0.12488423f, 0.03377035f, -0.05669656f, -0.03230732f, -0.05816105f, 0.21381570f, 0.11658975f, 
    0.07390638f, -0.03991859f, -0.07425899f, 0.07553011f, -0.01196915f, -0.14289558f, -0.23784736f, 0.04328519f, 
    -0.04312650f, -0.04050804f, -0.30345437f, -0.09735176f, -0.33447841f, -0.04455242f, -0.04559107f, -0.06180339f, 
    -0.21159177f, -0.09799991f, 0.00079271f, -0.09447551f, -0.07249766f, 0.08194725f, -0.25679886f, -0.22026908f, 
    -0.10713993f, 0.04202322f, -0.05686780f, 0.15213415f, -0.04817145f, -0.22625214f, 0.43474641f, 0.01790721f, 
    -0.06101946f, 0.10992819f, 0.05507945f, 0.02365756f, 0.10616292f, 0.09610904f, -0.02092327f, -0.11796184f, 
    0.09794010f, 0.06588585f, 0.11267933f, -0.02667597f, 0.16919281f, -0.00514034f, -0.04737220f, 0.04771006f, 
    0.32435745f, -0.04868846f, -0.09124819f, 0.14527771f, -0.13210034f, 0.10791755f, -0.04389404f, 0.02354532f, 
    -0.07228228f, -0.03359981f, 0.10116028f, -0.03870842f, -0.18925531f, 0.09372164f, -0.13638829f, 0.06551778f, 
    -0.29890591f, -0.21958454f, 0.29154772f, -0.16168921f, -0.08439777f, -0.13697472f, 0.04916665f, -0.05229822f, 
    0.19447799f, -0.03602084f, 0.16284366f, 0.11267192f, 0.07843050f, -0.09204781f, -0.01281475f, 0.00437912f, 
    0.00689314f, 0.01126311f, -0.00672549f, -0.04874222f, 0.18228792f, -0.01840357f, -0.06185254f, -0.11648897f, 
    0.00917375f, -0.16841365f, -0.11773231f, 0.33275694f, -0.15305394f, 0.05529503f, 0.12502803f, -0.02135491f, 
    -0.03737197f, -0.00161117f, -0.14139669f, 0.10655262f, -0.11218724f, -0.01516050f, 0.16199876f, 0.01210377f, 
    -0.06686188f, -0.06804016f, 0.13610709f, 0.05283548f, 0.02587422f, 0.21498235f, 0.13606942f, 0.22481184f, 
    0.10396437f, 0.11573339f, 0.10177754f, 0.03946767f, -0.12585230f, 0.08850919f, 0.03783473f, 0.01672691f, 
    -0.12036187f, -0.04662877f, 0.01235534f, -0.02019624f, -0.05620096f, 0.08538008f, 0.09792820f, 0.43131891f, 
    -0.11192261f, 0.15169150f, 0.10524652f, -0.02242761f, 0.21380447f, 0.17142060f, -0.05525705f, 0.06479955f, 
    -0.05822750f, -0.02603123f, 0.01775583f, -0.00687088f, 0.04009613f, 0.04999632f, 0.03677996f, -0.05130289f, 
    0.00525258f, -0.05075150f, -0.01666512f, 0.00273738f, 0.04965727f, 0.01056024f, -0.04908715f, 0.01537458f, 
    -0.00712292f, -0.03773963f, -0.01429374f, 0.02864671f, -0.06882990f, 0.01560423f, 0.05093873f, -0.03560840f, 
    -0.01562023f, -0.03154955f, 0.03366532f, -0.00227399f, -0.00272772f, 0.02336898f, 0.05400625f, 0.03290619f, 
    -0.06323282f, -0.03027397f, -0.04837225f, -0.03057244f, -0.03439147f, 0.02885803f, 0.02801559f, 0.02617307f, 
    -0.03710871f, 0.03134352f, 0.05342985f, -0.04628271f, 0.03415473f, -0.01308623f, -0.06273888f, -0.02525553f, 
    -0.05713984f, -0.06257269f, -0.01311302f, 0.03685126f, -0.02189079f, -0.05285201f, 0.04559880f, -0.01510131f, 
    -0.03607688f, 0.00352333f, -0.03401315f, 0.00576656f, -0.05070996f, -0.04407910f, -0.03591418f, 0.03505374f, 
    -0.03665639f, -0.00337330f, 0.01739287f, -0.01856141f, -0.05759084f, -0.00148158f, 0.03208915f, -0.02235595f, 
    0.03798498f, 0.03585909f, -0.01868138f, -0.01752842f, -0.01368961f, 0.00964799f, -0.05279643f, -0.01368248f, 
    -0.02270997f, 0.05068000f, -0.05719043f, -0.05755458f, -0.01201734f, -0.06367836f, -0.06015326f, 0.01064032f, 
    0.00707674f, -0.00815183f, 0.04609716f, 0.03955846f, -0.00877565f, -0.03664357f, 0.04971532f, 0.02011810f, 
    -0.03081242f, 0.00733136f, -0.00704077f, -0.04546297f, -0.04094341f, -0.01844427f, -0.04746942f, -0.05079550f, 
    -0.04018812f, 0.02690673f, -0.04592984f, -0.00855497f, -0.05370609f, 0.03421961f, -0.03687095f, -0.02864897f, 
    0.02396015f, -0.03979976f, 0.02649663f, -0.04606678f, 0.05290286f, 0.02575645f, -0.05411687f, 0.03200993f, 
    -0.06390826f, 0.03148181f, 0.04198939f, -0.04174098f, 0.03881201f, -0.03935683f, 0.02845532f, 0.03545555f, 
    -0.04129734f, -0.00415030f, -0.01394400f, 0.04229657f, 0.05916877f, -0.03163381f, -0.05271919f, 0.00607681f, 
    -0.01639927f, 0.01481050f, -0.01596203f, 0.00467320f, 0.03931208f, 0.05279107f, 0.05006889f, -0.00389351f, 
    0.00454375f, -0.02342976f, 0.02535845f, -0.00437285f, -0.02815040f, -0.02298662f, -0.02103201f, -0.02453776f, 
    0.03769315f, 0.01024302f, -0.01275416f, -0.04607626f, -0.05815673f, -0.03535781f, 0.04018453f, 0.02766371f, 
    -0.02531702f, -0.06045015f, -0.05565944f, 0.03483922f, 0.01833409f, 0.03712483f, 0.02845326f, -0.00356283f, 
    -0.03026654f, -0.03249367f, 0.02724004f, -0.01306170f, 0.00836558f, -0.04717137f, -0.05133810f, 0.05123012f, 
    0.04821892f, 0.03273210f, 0.01244514f, 0.01726376f, -0.00031603f, -0.02116034f, -0.01361148f, -0.04774117f, 
    0.01287721f, 0.00233413f, 0.02658554f, -0.01279089f, -0.01775222f, -0.01262099f, 0.04606788f, 0.01332151f, 
    -0.00463222f, -0.01129767f, -0.02912898f, -0.02780878f, 0.02962214f, -0.02139493f, -0.02071825f, -0.06116724f, 
    0.01755507f, -0.00097662f, -0.01156823f, -0.02958353f, -0.05384680f, -0.05984010f, 0.05371200f, -0.06140119f, 
    -0.00999962f, -0.05335815f, -0.01371701f, 0.00440986f, 0.00964191f, 0.02913918f, 0.01935791f, -0.01180896f, 
    0.03455344f, -0.01008731f, 0.03346267f, -0.04213317f, -0.04724541f, 0.00293194f, 0.04122611f, -0.05726732f, 
    0.01991908f, 0.05657478f, 0.04407464f, -0.00888293f, 0.05488178f, -0.01684023f, -0.02317990f, -0.01433888f, 
    -0.04832510f, -0.04364282f, -0.00724351f, -0.05043330f, 0.05570253f, 0.03973045f, -0.00377118f, -0.02362571f, 
    0.02997284f, 0.03982607f, -0.02998629f, 0.03186078f, 0.00721701f, -0.01932419f, 0.05171480f, -0.02857421f, 
    0.01081297f, -0.02720341f, 0.00672858f, 0.02517398f, -0.05473964f, -0.01012298f, -0.06867146f, 0.01952147f, 
    0.02559747f, -0.01885488f, -0.01260351f, -0.05241439f, 0.00302464f, -0.03562145f, 0.03887010f, -0.02080865f, 
    -0.03245572f, -0.00907110f, 0.04838974f, 0.05296285f, 0.00809312f, -0.05674595f, -0.05026453f, 0.05367552f, 
    0.01933159f, 0.00909183f, -0.06241222f, 0.00240532f, -0.03973641f, -0.06035697f, -0.01520989f, 0.00212809f, 
    0.02560724f, -0.00706047f, -0.05614970f, -0.02721724f, -0.00111539f, -0.04791325f, 0.01693551f, -0.03741122f, 
    -0.06630515f, -0.01839466f, 0.03242566f, -0.06779993f, -0.03215725f, -0.07690314f, -0.05141847f, -0.00453554f, 
    0.01618151f, -0.01104105f, -0.05067949f, -0.02181078f, 0.04325192f, -0.07302476f, -0.07254957f, 0.03213414f, 
    -0.02096529f, 0.02065936f, 0.05684448f, 0.00656514f, 0.00037910f, 0.00631462f, -0.01715056f, -0.03657064f, 
    0.03259517f, 0.01818188f, -0.02469801f, -0.05686308f, -0.04737486f, -0.07401400f, -0.07434292f, -0.04355221f, 
    -0.01852373f, 0.00465200f, -0.06782289f, -0.05693058f, -0.04993076f, 0.01163671f, -0.01490049f, 0.02483248f, 
    0.01720841f, 0.00374900f, -0.03968479f, 0.01080170f, -0.04001016f, 0.01426876f, 0.00593636f, -0.00111985f, 
    0.03381627f, -0.04940718f, 0.00191365f, 0.03244676f, 0.03651607f, 0.05690582f, -0.02560754f, -0.05380523f, 
    -0.07282081f, -0.02425318f, -0.00355062f, 0.00948763f, 0.04405002f, 0.00535931f, -0.07901944f, 0.02963802f, 
    -0.05729206f, 0.02571846f, -0.00936900f, -0.05122673f, -0.02089717f, 0.00826255f, -0.00901685f, -0.08417564f, 
    -0.03309824f, -0.05664407f, -0.06439300f, 0.03291148f, -0.05363927f, -0.03375260f, 0.02622608f, 0.02388402f, 
    0.04363396f, -0.04548414f, -0.05842583f, 0.02687663f, 0.00884706f, -0.04996337f, -0.02431690f, -0.01599476f, 
    0.04567324f, 0.02477559f, 0.00973882f, -0.03276427f, 0.02794568f, 0.01331733f, -0.06391753f, -0.06614731f, 
    -0.07703467f, -0.06332531f, -0.08067729f, -0.08252209f, 0.02659546f, -0.04694047f, -0.06595653f, -0.06148376f, 
    -0.03201582f, 0.02397216f, 0.01257367f, -0.03878621f, -0.07812686f, -0.00351420f, 0.02056621f, -0.05240172f, 
    -0.00050721f, 0.03448677f, -0.08892393f, -0.07475462f, -0.01143774f, -0.06251801f, -0.00418278f, 0.02634128f, 
    0.05091289f, 0.00143580f, 0.00874869f, -0.03379819f, -0.02613685f, 0.05502274f, -0.06255852f, 0.01291979f, 
    -0.05176184f, -0.00733986f, -0.09056813f, -0.04013946f, -0.03405941f, -0.08148206f, 0.01538851f, -0.01935594f, 
    0.01344167f, -0.04187007f, -0.07396100f, 0.01971493f, -0.03744946f, 0.00748017f, 0.01005777f, 0.01483541f, 
    0.00415520f, -0.05760777f, -0.08236074f, -0.00523852f, 0.00334892f, 0.03159919f, -0.07711226f, -0.01305579f, 
    -0.01774108f, 0.01478750f, -0.01386395f, 0.00588454f, -0.02686517f, 0.00278077f, -0.00017576f, -0.03931537f, 
    -0.05234250f, 0.02791477f, 0.04638129f, -0.02633154f, -0.01133569f, -0.05129819f, 0.02969555f, 0.03973532f, 
    -0.03827456f, 0.04421775f, 0.03589382f, -0.06130185f, -0.07714490f, -0.04493990f, 0.01144619f, -0.04717510f, 
    0.02668421f, -0.04924428f, -0.06103439f, -0.00743310f, 0.03226552f, -0.05025376f, 0.00027520f, -0.01025299f, 
    -0.04317291f, -0.05431563f, -0.00842811f, -0.00840993f, -0.03591442f, 0.04903806f, -0.03737973f, -0.06985722f, 
    0.02531929f, -0.02088596f, 0.03180684f, 0.04044512f, -0.03946595f, 0.02197462f, -0.06256866f, -0.07913972f, 
    -0.03798236f, 0.00769443f, -0.03590305f, -0.06576353f, -0.05613628f, -0.04424722f, -0.01670820f, 0.02577101f, 
    0.02225884f, 0.01600586f, -0.00296993f, -0.03155615f, 0.00404077f, 0.03382898f, -0.04137225f, 0.04253426f, 
    0.01625669f, -0.07133181f, -0.02158443f, -0.03228307f, -0.00276570f, -0.05185121f, -0.02878411f, -0.07795137f, 
    0.02354302f, -0.02346606f, 0.01219052f, -0.08142459f, 0.01655319f, -0.03591719f, -0.05894287f, -0.06387015f, 
    -0.01886897f, 0.00588245f, -0.04878859f, -0.08360155f, -0.08440141f, -0.06164119f, 0.04274487f, -0.04972573f, 
    0.03173557f, -0.03166480f, 0.05473715f, 0.00635737f, -0.04483192f, -0.00480389f, -0.02449184f, 0.01431902f, 
    0.00808904f, 0.03681171f, -0.03567518f, 0.01180666f, -0.03707359f, -0.01979934f, 0.01515313f, -0.05803377f, 
    -0.02361213f, 0.02300229f, 0.01405404f, -0.01330730f, -0.09493203f, -0.00826264f, 0.01212366f, -0.07377989f, 
    -0.01859903f, 0.02153773f, 0.02601987f, -0.04750035f, 0.01173963f, -0.06150336f, -0.01806874f, 0.02458476f, 
    -0.04807551f, 0.00669622f, -0.02481830f, 0.04049156f, 0.02611442f, 0.05209824f, -0.02960605f, -0.03081078f, 
    -0.05577638f, -0.03792840f, 0.00683180f, -0.04251363f, 0.03239002f, -0.03236122f, 0.04815688f, -0.03694613f, 
    -0.21173875f, -0.06633147f, -0.02960661f, 0.07929146f, -0.30219898f, -0.08445635f, -0.12115343f, -0.06350100f, 
    0.03917398f, 0.08635782f, -0.15850072f, 0.02736746f, -0.03448108f, -0.04287535f, 0.16783831f, -0.14864540f, 
    -0.08442173f, 0.15001243f, -0.04557274f, 0.13476668f, 0.07863025f, -0.08809851f, -0.06278292f, 0.10371062f, 
    0.12804970f, 0.19672687f, 0.08187193f, 0.18929026f, -0.10300277f, -0.06599727f, 0.16332021f, 0.03723379f, 
    0.09535669f, -0.04468811f, 0.11956177f, -0.07527222f, 0.09093650f, -0.01600966f, 0.18128790f, 0.08971546f, 
    0.03414039f, 0.02224400f, -0.01559959f, -0.00211182f, 0.14342414f, -0.09678847f, -0.14917082f, -0.04845010f, 
    0.10862210f, -0.03074938f, -0.07312918f, -0.01722087f, -0.06141474f, 0.12949395f, 0.25111061f, -0.00766431f, 
    -0.00741913f, 0.02364828f, 0.02144253f, 0.10243386f, 0.16955501f, 0.03235860f, 0.09422828f, 0.17381880f, 
    -0.06917026f, -0.15652607f, -0.07387673f, 0.06135381f, -0.05961275f, 0.02314686f, -0.01129768f, 0.05713564f, 
    -0.14868702f, -0.08098766f, 0.04626772f, -0.05459099f, -0.01358129f, 0.06293016f, -0.02546543f, -0.14653315f, 
    -0.24452300f, -0.03698333f, 0.00393504f, 0.06277842f, 0.13819720f, 0.00586744f, -0.09123047f, -0.02482640f, 
    0.02099372f, -0.00167931f, 0.07592641f, 0.07254528f, 0.09754445f, 0.10347895f, -0.22540565f, -0.11180250f, 
    -0.05540492f, -0.00210536f, -0.04383465f, -0.10716237f, -0.26350266f, -0.18570229f, 0.12353968f, 0.09680321f, 
    0.17255855f, -0.11825968f, -0.02245839f, -0.07949240f, -0.15574110f, 0.10609220f, 0.03569991f, -0.08310956f, 
    0.09400951f, 0.01055233f, 0.32337081f, -0.15258382f, 0.04795044f, -0.09310071f, 0.00064486f, 0.10242414f, 
    -0.05740166f, -0.04307143f, 0.01077477f, 0.01097680f, -0.00422490f, 0.13619553f, 0.01380200f, -0.23168659f, 
    -0.05429499f, -0.12160345f, -0.17038664f, -0.09474183f, -0.10060142f, 0.05683406f, -0.07226738f, 0.34604511f, 
    -0.19571488f, 0.09561195f, -0.04623600f, 0.09062596f, 0.02540055f, -0.03518766f, -0.12039806f, 0.02061514f, 
    -0.05107373f, -0.20796913f, -0.07625791f, 0.07190911f, -0.01981909f, 0.09297094f, 0.01922402f, 0.08917297f, 
    0.08413092f, -0.16428155f, -0.07009226f, 0.05421504f, -0.15689281f, 0.02926533f, -0.00194349f, 0.01823600f, 
    0.05041341f, -0.19054183f, 0.09091567f, 0.03493116f, -0.07713993f, 0.02253531f, -0.15872264f, -0.00255976f, 
    0.00020554f, -0.18293524f, -0.20246601f, -0.35643169f, -0.08985860f, 0.14187148f, -0.01505604f, 0.02725662f, 
    0.09456585f, 0.13903704f, 0.22634543f, -0.12377710f, 0.01654514f, -0.04414537f, 0.09654430f, 0.02166533f, 
    -0.10385257f, -0.16693127f, -0.14307973f, -0.09451353f, 0.07792543f, -0.03992651f, 0.09313733f, 0.06998721f, 
    0.11222775f, 0.00167560f, 0.09297144f, 0.01467719f, 0.11914150f, 0.10905685f, -0.02802641f, 0.02998499f, 
    -0.00538779f, 0.00579037f, -0.01559298f, 0.04738721f, -0.22743781f, -0.10821044f, -0.09709030f, -0.11144034f, 
    0.04776709f, 0.26994950f, 0.10783583f, -0.11797808f, -0.17249873f, -0.05484021f, -0.06169401f, -0.07356424f, 
    -0.14094633f, -0.14000089f, -0.35626918f, 0.00373574f, 0.10959649f, 0.07454361f, 0.10622233f, 0.05439467f, 
    0.01397625f, 0.08388111f, -0.13647731f, -0.10842798f, 0.15633410f, 0.17809652f, 0.07198720f, -0.01399186f, 
    -0.07941086f, 0.21354653f, -0.27813211f, -0.07272805f, 0.10023944f, -0.03849894f, 0.04758620f, 0.06912457f, 
    -0.00349176f, -0.12366451f, -0.14100897f, 0.02506024f, -0.03448943f, 0.06363683f, 0.27763706f, -0.02726044f, 
    0.00082365f, -0.09377558f, -0.08884808f, 0.06466261f, 0.05221462f, 0.04086804f, -0.17885555f, 0.08505000f, 
    0.08405021f, 0.07916266f, 0.09087478f, 0.15373209f, 0.24600461f, 0.23567566f, -0.09353477f, -0.00364422f, 
    -0.01519799f, 0.19348341f, 0.23266108f, 0.05367076f, 0.02440988f, -0.02540315f, -0.08610610f, -0.09237844f, 
    0.05812925f, 0.12250569f, -0.05343922f, -0.05720955f, -0.07527118f, -0.09063327f, 0.04173786f, 0.18105274f, 
    0.06011271f, 0.26181963f, 0.20524621f, 0.04392700f, -0.06576507f, -0.06388633f, -0.00317260f, 0.11766952f, 
    0.19168350f, 0.04661357f, -0.01146039f, -0.18031196f, -0.04779499f, 0.18584777f, 0.03857750f, -0.01169233f, 
    0.05010978f, -0.04029182f, 0.02235458f, 0.05008120f, -0.06504825f, 0.03089269f, -0.09673005f, 0.09882221f, 
    0.10230629f, 0.04190041f, 0.03331626f, -0.10872747f, 0.05140753f, 0.05986815f, 0.13418339f, 0.07463130f, 
    0.05321717f, -0.25254992f, -0.26557872f, -0.21961620f, -0.04095854f, 0.04794689f, -0.00299974f, -0.08790987f, 
    0.09357516f, -0.00650956f, 0.09213190f, 0.21413456f, -0.01063070f, -0.03561584f, -0.03276112f, 0.07677835f, 
    0.06316538f, 0.10012707f, 0.00893765f, -0.07304971f, -0.04959275f, 0.18848898f, 0.11370336f, 0.10280954f, 
    -0.00461078f, -0.05571523f, -0.05052012f, -0.08274052f, -0.16443035f, -0.06131761f, 0.10178263f, 0.19962484f, 
    -0.14935443f, 0.19526014f, -0.06068730f, -0.00816389f, -0.05420663f, -0.13388655f, -0.05776879f, -0.01224384f, 
    -0.08871867f, 0.08238799f, -0.02727826f, 0.06110536f, -0.14977415f, -0.06026278f, 0.00641491f, 0.09756033f, 
    0.06352037f, 0.10842538f, -0.02130508f, 0.05503747f, 0.08737203f, -0.02504130f, 0.16295514f, 0.22017896f, 
    -0.06859944f, 0.00181112f, 0.05088411f, 0.01971978f, -0.01564575f, -0.02730749f, 0.12320822f, -0.02542011f, 
    -0.13174465f, -0.27993903f, -0.00131397f, -0.08429378f, -0.22720256f, -0.04111246f, -0.08310300f, -0.00748541f, 
    0.11376189f, 0.04405426f, 0.28170145f, -0.08642022f, -0.01387510f, 0.14522852f, 0.19959682f, 0.17390834f, 
    -0.07115059f, -0.03614721f, 0.12914217f, 0.13612002f, -0.31816941f, 0.20552857f, -0.18446699f, 0.00794886f, 
    0.20083597f, 0.02563947f, -0.03736166f, -0.19183891f, -0.26581234f, 0.00458667f, 0.02953352f, -0.10400267f, 
    0.06698111f, 0.03760803f, 0.05285259f, 0.03320418f, 0.13504378f, -0.01232800f, 0.04030168f, -0.06679533f, 
    -0.06890973f, -0.04358977f, 0.01341083f, 0.14733388f, 0.05044923f, 0.02784862f, 0.31678987f, -0.08515196f, 
    0.12105868f, 0.32386199f, -0.00023461f, -0.06075691f, 0.00918435f, -0.07404155f, -0.13863775f, 0.08745423f, 
    0.08293510f, 0.07131062f, -0.16155776f, 0.05433869f, -0.05177937f, 0.00725511f, -0.05015454f, 0.00297645f, 
    0.05288741f, 0.03248579f, 0.10397127f, -0.19666043f, 0.06029338f, 0.03577179f, 0.00194538f, 0.19883043f, 
    0.12588488f, 0.15264638f, 0.04370787f, 0.01217875f, -0.10873037f, -0.00272753f, -0.02786793f, 0.13454281f, 
    -0.00404844f, 0.20955276f, -0.03306451f, 0.09185786f, -0.01987932f, 0.06000239f, 0.10707259f, -0.03079177f, 
    -0.06416588f, 0.02932937f, -0.05989021f, -0.14422460f, 0.01491018f, -0.02776545f, -0.02727782f, 0.12998481f, 
    -0.04994449f, 0.15760639f, 0.20807487f, -0.13974053f, 0.11740429f, 0.02559971f, 0.13185792f, 0.00945594f, 
    0.10685290f, 0.05626401f, -0.05428649f, 0.11667306f, -0.18228592f, -0.18390676f, 0.02334918f, -0.18506715f, 
    -0.10723294f, -0.06214343f, 0.12711209f, 0.10535099f, 0.11826564f, 0.11340889f, -0.15619737f, 0.03920849f, 
    0.04779771f, -0.24527398f, 0.01333319f, 0.06538343f, -0.00318431f, -0.07064962f, 0.00531176f, 0.13149786f, 
    0.09216872f, 0.09139649f, -0.07427554f, 0.09995128f, 0.08165438f, 0.07571716f, -0.06706242f, 0.02948436f, 
    -0.03350722f, -0.04443606f, 0.05089212f, -0.00416216f, -0.05167289f, 0.29644713f, 0.09641314f, 0.07325368f, 
    -0.22720970f, 0.01322894f, 0.13994092f, 0.16738816f, -0.20420931f, -0.03478977f, -0.00049310f, 0.02838086f, 
    0.13942081f, 0.20872480f, 0.10521916f, 0.03008436f, -0.03568345f, -0.06492338f, 0.00608841f, 0.01891357f, 
    0.21832353f, 0.00058456f, -0.08569264f, -0.13716090f, -0.00071961f, 0.00377065f, 0.02844570f, 0.10557391f, 
    0.02999621f, 0.02421037f, -0.10583574f, -0.29040492f, -0.25448951f, -0.08469446f, -0.01494480f, 0.01618680f, 
    -0.05822107f, -0.03787434f, 0.10561442f, 0.13861078f, 0.01994763f, 0.16611646f, 0.00044541f, -0.05009364f, 
    -0.02420991f, 0.01854624f, 0.02688074f, 0.06751166f, -0.04910580f, -0.06335326f, -0.03078197f, 0.03150281f, 
    0.02628400f, -0.15535748f, -0.03469814f, 0.08858878f, -0.04216047f, -0.02448153f, -0.03410641f, 0.02704170f, 
    0.30313027f, -0.22760808f, -0.40575796f, -0.14232910f, 0.06934055f, 0.00591081f, -0.04499497f, -0.12325452f, 
    0.07854994f, -0.59592313f, -0.17004189f, -0.24111892f, -0.05250945f, -0.14481422f, 0.17879707f, 0.02048558f, 
    -0.03531419f, 0.05599640f, -0.08942541f, -0.28179115f, -0.22614489f, -0.03294053f, 0.01246026f, 0.01155271f, 
    0.00024063f, 0.02492186f, -0.09178493f, 0.45007607f, -0.09175441f, -0.13839354f, 0.10682554f, 0.02549076f, 
    0.12569275f, 0.05538224f, 0.15064991f, -0.02989153f, -0.19179659f, 0.15400001f, 0.12171445f, -0.02397744f, 
    0.03483823f, 0.04859535f, 0.03725532f, 0.18641719f, -0.04953093f, 0.03878392f, -0.32385755f, -0.38283855f, 
    0.06194348f, 0.09290789f, 0.07739101f, 0.15413742f, -0.00649448f, -0.04899643f, -0.29151276f, -0.27838752f, 
    0.30824858f, 0.07320093f, 0.05441902f, -0.19185480f, 0.18405849f, -0.03215703f, 0.00317976f, -0.13665874f, 
    -0.10514703f, -0.23223881f, 0.05394782f, -0.17303050f, 0.03253616f, 0.01339085f, 0.04819941f, 0.05613673f, 
    -0.16476150f, 0.07040650f, 0.14112078f, 0.00287684f, -0.05226818f, -0.00404901f, 0.24514332f, 0.14675081f, 
    0.14926217f, -0.15832983f, -0.00209015f, -0.21318887f, -0.06275610f, 0.08356708f, 0.08771384f, 0.07332271f, 
    0.06115433f, 0.08227317f, 0.19369999f, -0.21460074f, -0.15933599f, -0.12338279f, 0.26380077f, 0.16104703f, 
    0.02238714f, -0.02811446f, 0.11911475f, 0.25201786f, 0.08238631f, 0.00498342f, -0.09389023f, -0.20736481f, 
    -0.11317703f, 0.07976015f, 0.11674678f, -0.04022991f, -0.09444825f, -0.16928984f, 0.05592304f, 0.00464187f, 
    0.01387114f, -0.03002636f, -0.06979004f, -0.23071060f, -0.11979772f, 0.04996677f, 0.27355254f, 0.10364193f, 
    0.00249674f, 0.09366444f, -0.15645286f, -0.06676926f, -0.11651529f, -0.09438493f, 0.16407502f, -0.16961336f, 
    -0.12559810f, -0.13241117f, 0.03985384f, -0.00717236f, 0.09139237f, -0.01309320f, 0.08016655f, -0.19722542f, 
    -0.31555474f, -0.23987056f, -0.06514183f, 0.09022114f, 0.01300475f, 0.11922999f, 0.01463410f, -0.06472941f, 
    0.12867764f, 0.12189504f, 0.27597556f, 0.13123289f, -0.02018885f, 0.02642614f, 0.11478633f, 0.11421949f, 
    -0.03526312f, -0.44465432f, -0.01175269f, 0.10004448f, -0.04760991f, 0.01586796f, -0.08696959f, -0.01551377f, 
    -0.16365670f, 0.04257050f, -0.56866759f, -0.36792278f, 0.05003729f, 0.00022023f, 0.01244154f, -0.09237859f, 
    -0.00519085f, -0.13200331f, 0.15160877f, 0.25869921f, -0.15896872f, -0.31047899f, -0.01332155f, -0.03116675f, 
    -0.12962011f, 0.01448614f, -0.02152675f, -0.04824990f, -0.31983817f, -0.03534335f, 0.15365925f, -0.11370652f, 
    0.01489696f, -0.21171878f, -0.10802878f, -0.10094998f, 0.06058694f, -0.01534522f, 0.13641892f, 0.00463593f, 
    0.02893783f, 0.10692166f, -0.00984415f, 0.03539420f, 0.10026738f, -0.07396724f, -0.25424710f, 0.08364034f, 
    -0.08616287f, 0.11907762f, 0.03601817f, -0.09529331f, 0.03868794f, 0.10208328f, -0.02385953f, -0.31041220f, 
    -0.05794446f, -0.32253477f, -0.05019123f, 0.07971716f, 0.02589355f, 0.16042855f, -0.07158459f, -0.00140111f, 
    0.40607107f, -0.16867837f, -0.02632245f, 0.02421598f, -0.07934449f, -0.18384564f, 0.11452803f, 0.12448927f, 
    0.10561278f, 0.15949604f, -0.00564930f, 0.04384124f, 0.07949124f, -0.03368346f, -0.11269616f, 0.02982112f, 
    0.04369113f, 0.01534224f, -0.04090621f, 0.08068018f, 0.13624711f, 0.02807429f, 0.03102500f, 0.09967047f, 
    -0.03797002f, 0.04325783f, 0.06582878f, -0.05646144f, -0.23361094f, 0.02139818f, -0.11211608f, 0.18788576f, 
    -0.23241676f, -0.01562837f, 0.13660951f, 0.08828452f, 0.10735019f, -0.17377669f, -0.00941261f, -0.07701854f, 
    0.02374348f, 0.02591835f, 0.07460666f, -0.00902576f, 0.07304277f, -0.17797437f, 0.03073515f, 0.13311146f, 
    0.24200547f, 0.01527666f, 0.08980034f, 0.08722736f, 0.09358335f, 0.19766815f, -0.09472205f, 0.10169709f, 
    -0.02952855f, -0.29074726f, -0.03587699f, 0.00045930f, 0.00503792f, 0.09626387f, 0.06198880f, 0.59831142f, 
    -0.04407766f, -0.32485542f, 0.12481090f, -0.02208368f, -0.06736103f, 0.13023044f, 0.00298630f, -0.18580414f, 
    0.02305656f, -0.12383031f, -0.06043363f, 0.00041749f, 0.06044182f, -0.05966811f, 0.17577210f, -0.05068533f, 
    -0.00007061f, 0.13819005f, 0.03923221f, -0.12389333f, 0.06444206f, 0.11074672f, 0.13582693f, 0.02343054f, 
    -0.00224792f, 0.00518115f, -0.17141393f, -0.00911557f, 0.02467365f, -0.22066666f, 0.07317809f, -0.06886863f, 
    -0.08532459f, 0.03663664f, 0.06693344f, 0.41671088f, 0.11101791f, -0.08401268f, -0.05609349f, 0.11842541f, 
    -0.03913303f, 0.13683413f, 0.03024232f, 0.05327914f, -0.03460819f, -0.23244548f, -0.14732024f, -0.12916751f, 
    0.03383542f, 0.11034402f, -0.03639791f, -0.00698348f, 0.05847983f, -0.35866335f, -0.02328522f, -0.24168129f, 
    -0.12248657f, 0.15214242f, 0.05444407f, 0.04698800f, -0.07447576f, -0.08339512f, -0.30264267f, -0.00799613f, 
    0.01216876f, -0.08067545f, 0.07853227f, 0.14293712f, -0.12274249f, 0.15587941f, 0.12567440f, 0.13835496f, 
    0.15318140f, -0.00184211f, 0.03781587f, 0.19656225f, 0.06040429f, 0.14165592f, 0.03294901f, -0.05269976f, 
    -0.03787215f, 0.05874106f, 0.01136130f, 0.02852556f, -0.06623062f, -0.07938529f, 0.11450551f, 0.05605587f, 
    0.10643358f, -0.21860141f, -0.35830489f, -0.04357359f, -0.07286862f, 0.00562928f, 0.02658488f, 0.03065108f, 
    0.03970577f, 0.14323208f, -0.06875448f, 0.08545404f, 0.14023653f, 0.17189583f, 0.09652326f, -0.01944260f, 
    0.07991879f, 0.04915128f, -0.07925443f, 0.02966264f, 0.09235273f, -0.12176326f, -0.13525507f, -0.07209402f, 
    -0.11946027f, 0.07286534f, 0.07399244f, -0.02115491f, -0.27701303f, -0.21858308f, 0.02706227f, 0.06121444f, 
    0.06738497f, 0.15232088f, 0.13280472f, 0.06706135f, 0.32660732f, -0.53239286f, -0.20852146f, -0.12379978f, 
    0.08147208f, -0.16065489f, -0.13452961f, -0.11909047f, -0.00008611f, 0.10228772f, 0.01952191f, 0.17483379f, 
    0.09866624f, 0.07960205f, -0.10810092f, -0.05042156f, 0.12777260f, -0.03882201f, -0.05101620f, 0.24603832f, 
    -0.21555243f, -0.26474914f, -0.06170538f, 0.12252423f, -0.10495286f, 0.04414531f, -0.04209647f, 0.07209102f, 
    -0.15863954f, -0.24005830f, -0.27611005f, -0.05901124f, -0.13332672f, -0.00985681f, 0.02964293f, 0.03341413f, 
    0.22913817f, -0.19831058f, -0.04835043f, 0.08390456f, -0.08055514f, -0.05805625f, -0.12542801f, 0.08191605f, 
    0.02205482f, 0.00407550f, 0.07946312f, 0.10036875f, 0.05033492f, 0.05844810f, -0.12237724f, -0.23973945f, 
    0.09268904f, 0.11462945f, -0.05491905f, -0.28033945f, 0.05140598f, 0.26005092f, -0.21440108f, -0.17207231f, 
    0.08539415f, -0.04409394f, 0.15003358f, 0.09447298f, -0.02533117f, -0.27076659f, 0.06807131f, -0.11752464f, 
    0.18641078f, 0.04473057f, -0.07547344f, 0.01052529f, 0.06790745f, -0.07939495f, -0.26189685f, 0.22273803f, 
    0.13796082f, 0.11265515f, 0.09921240f, 0.05065631f, 0.07786345f, 0.15300302f, -0.03126638f, 0.15987831f, 
    0.07053294f, 0.02634044f, -0.07816976f, 0.12623534f, -0.16295016f, -0.05932312f, -0.04648355f, -0.08611339f, 
    -0.11200597f, 0.29454362f, -0.00710753f, -0.02162629f, -0.10528918f, -0.03237095f, 0.04365262f, 0.02871135f, 
    -0.15724629f, -0.03365740f, 0.07771674f, -0.21951818f, -0.08095055f, 0.08547511f, -0.07369767f, 0.02341320f, 
    0.16658166f, 0.06918661f, -0.17987268f, -0.12626988f, 0.02051242f, 0.02556809f, 0.04329580f, -0.05634954f, 
    -0.18328606f, 0.19163650f, -0.29906473f, -0.10786395f, -0.04110577f, -0.03360952f, -0.12378556f, -0.09627271f, 
    0.25154221f, 0.11481380f, 0.01855019f, -0.25174898f, -0.13362534f, 0.19880676f, -0.16271664f, -0.11971434f, 
    -0.08076455f, -0.02471212f, 0.05581024f, 0.10112157f, -0.00255407f, -0.03622047f, -0.14753288f, -0.04880401f, 
    -0.07603186f, -0.01984925f, 0.01860548f, 0.13650276f, 0.17056519f, 0.16474809f, 0.20073937f, 0.02205379f, 
    -0.00829719f, 0.17129919f, -0.01580315f, 0.10361788f, 0.17502701f, 0.03748618f, -0.01276500f, -0.08720423f, 
    -0.11508160f, -0.36927360f, -0.19237250f, -0.05907499f, -0.03780931f, -0.00701699f, -0.05337253f, 0.35189238f, 
    0.00080828f, -0.27713844f, -0.21979421f, 0.25601017f, 0.00243200f, 0.06744693f, 0.02176792f, 0.09435008f, 
    0.52636087f, 0.08629435f, -0.05908421f, 0.05294803f, 0.06856066f, 0.16305402f, 0.00816010f, 0.05055362f, 
    0.02045257f, -0.39679816f, 0.25200579f, -0.17892371f, 0.03632731f, -0.10768272f, -0.05492671f, 0.05776147f, 
    0.13397506f, -0.08730564f, 0.10360655f, 0.23311724f, 0.04915901f, -0.03028871f, -0.13348503f, -0.02139039f, 
    0.04874303f, 0.00233556f, -0.01476105f, 0.16941275f, 0.12337851f, 0.07304809f, -0.00629319f, -0.00579959f, 
    -0.10116050f, -0.09666953f, -0.06107567f, -0.11040191f, 0.11504634f, 0.01231233f, -0.17659560f, -0.00861704f, 
    -0.09184106f, 0.03191436f, -0.02902185f, 0.06004081f, -0.00907190f, -0.12558328f, -0.29489440f, -0.28315386f, 
    0.05918872f, 0.15177453f, 0.14017424f, -0.07967135f, 0.13932142f, -0.03544524f, -0.09681083f, -0.06867877f, 
    -0.03216047f, -0.04851353f, -0.04611966f, 0.21942139f, 0.00101566f, 0.06627381f, 0.06336616f, 0.26304874f, 
    0.17330402f, -0.02404414f, 0.02482934f, 0.11090930f, 0.13186632f, -0.04615845f, 0.04216477f, 0.01540976f, 
    -0.19618830f, 0.13376532f, 0.02484419f, 0.10004918f, -0.03259243f, -0.04144092f, 0.05687307f, 0.04994716f, 
    0.00633050f, -0.07478783f, -0.33789775f, -0.27563751f, -0.02638054f, 0.00242304f, 0.04115433f, 0.05558702f, 
    0.12352785f, 0.01771206f, 0.34313589f, -0.05330777f, 0.02543858f, -0.10066816f, 0.02588495f, 0.26587200f, 
    0.12729064f, -0.05715877f, -0.06994648f, 0.08464237f, 0.06681740f, 0.00628080f, -0.12807144f, -0.07485750f, 
    -0.00406497f, -0.02834101f, -0.07835465f, -0.05192771f, 0.12637329f, -0.08955871f, 0.09195462f, 0.10716645f, 
    -0.10055504f, 0.19680315f, 0.14324652f, 0.11069894f, -0.00353552f, 0.00916571f, -0.18214503f, -0.15654401f, 
    0.13313542f, -0.03912905f, -0.01245705f, 0.00937463f, 0.08396256f, -0.03614425f, 0.31145763f, 0.02396927f, 
    0.22729538f, -0.13745505f, 0.02931199f, 0.20574513f, 0.01442400f, 0.01051995f, -0.03070702f, 0.49334198f, 
    -0.01316796f, -0.65268427f, 0.03195843f, 0.04734112f, 0.19855061f, 0.09415779f, 0.04672340f, 0.02781061f, 
    -0.35175434f, -0.10894743f, -0.08319822f, -0.02357053f, -0.16190840f, -0.23762180f, 0.03830133f, 0.09074648f, 
    0.00444469f, -0.03827034f, -0.15536965f, -0.07037528f, 0.18623640f, 0.10954303f, 0.09577221f, 0.08023675f, 
    -0.10275416f, 0.05347727f, 0.63488096f, -0.15259846f, 0.19680423f, 0.02860928f, 0.02925623f, 0.09356950f, 
    0.01767812f, 0.00359908f, -0.10447164f, 0.24537072f, 0.33007288f, 0.03249521f, -0.07584816f, -0.11472470f, 
    -0.08166143f, 0.01493439f, 0.00433255f, 0.00500421f, 0.03129413f, -0.22039334f, 0.11249913f, 0.03232059f, 
    -0.00283661f, 0.06970012f, -0.10433065f, 0.08390182f, 0.03287025f, -0.08707885f, -0.05430658f, -0.12524299f, 
    0.02621214f, -0.00708808f, 0.03695635f, -0.05107081f, 0.02637964f, -0.05673409f, 0.00641891f, -0.05877006f, 
    -0.31392750f, 0.02247570f, -0.01494284f, 0.09110084f, -0.09230433f, 0.00909677f, 0.13819216f, 0.10357843f, 
    -0.30700117f, -0.00091063f, 0.09922742f, 0.02524942f, 0.00743310f, 0.02659718f, -0.03850419f, 0.11947457f, 
    0.04035151f, 0.09342785f, 0.07813904f, -0.07772467f, 0.01066095f, -0.11738045f, -0.05252926f, -0.04717170f, 
    0.06034385f, -0.20080756f, 0.13774110f, 0.00901114f, -0.00952597f, -0.14549261f, -0.02554182f, 0.05249820f, 
    0.15524793f, -0.11094571f, -0.24800967f, -0.21461217f, -0.01010112f, 0.08404118f, -0.00254111f, -0.05906820f, 
    0.12589483f, 0.04575603f, -0.04432255f, -0.27448064f, -0.38485882f, -0.31810483f, 0.07355417f, -0.17740934f, 
    -0.01569647f, -0.11165517f, -0.00077121f, 0.20368659f, 0.11533438f, 0.09719899f, 0.00201248f, -0.07345774f, 
    -0.15092234f, -0.10317109f, -0.02272166f, -0.01613211f, 0.02267240f, 0.11650071f, 0.03164634f, 0.09009093f, 
    0.00809646f, -0.02396193f, -0.02446781f, 0.00195531f, -0.11349346f, -0.01339342f, 0.10963199f, -0.06153803f, 
    -0.13345142f, 0.10072004f, -0.03599434f, 0.17942543f, -0.12107459f, -0.00517815f, 0.01160586f, -0.29599047f, 
    -0.24157672f, -0.19075595f, -0.02613807f, 0.18376942f, 0.02733917f, -0.09959659f, 0.04173065f, -0.08418610f, 
    -0.15583214f, -0.04989862f, 0.16735978f, -0.05490458f, -0.09526054f, 0.09355976f, 0.03016270f, -0.02846038f, 
    -0.05783192f, 0.44781849f, 0.10521266f, 0.13778886f, -0.07629470f, 0.00367600f, 0.07444599f, 0.00223665f, 
    -0.05968807f, -0.10800743f, -0.10351408f, -0.18111612f, 0.20069474f, 0.02977414f, -0.11532415f, 0.07619337f, 
    0.02055275f, 0.08604412f, -0.19584502f, 0.20340349f, 0.13655242f, 0.12482698f, -0.07672146f, 0.14031507f, 
    -0.02356835f, -0.01587276f, 0.11379904f, -0.07534125f, -0.15094149f, -0.11036871f, -0.01618514f, 0.14035794f, 
    0.09476192f, -0.00748508f, 0.14916068f, 0.03976156f, 0.17693529f, -0.16188256f, 0.09953244f, -0.23431951f, 
    -0.01345764f, -0.00790163f, 0.11335476f, 0.16192272f, 0.11838187f, 0.06524813f, -0.21122368f, -0.16472204f, 
    0.17087023f, -0.06206549f, 0.06879520f, 0.04226067f, 0.06179440f, 0.20464583f, 0.22287281f, 0.00704001f, 
    0.03099130f, 0.04888282f, 0.03702793f, 0.01841746f, -0.05834085f, 0.26229122f, 0.02031115f, -0.08754471f, 
    -0.00182859f, 0.15929160f, 0.07565933f, 0.02422295f, 0.12757218f, 0.05860014f, 0.05885073f, -0.19342951f, 
    -0.09288297f, 0.04731841f, -0.26620096f, -0.29205477f, 0.17930546f, 0.09853456f, -0.09313776f, -0.05097825f, 
    0.16552998f, 0.19590296f, -0.09816772f, 0.08398739f, 0.20106544f, 0.05928463f, -0.10423724f, 0.12045417f, 
    0.07185777f, -0.09092407f, 0.05067203f, -0.18767507f, -0.13983868f, 0.11743145f, -0.07545163f, 0.15876198f, 
    -0.02928118f, 0.16256344f, -0.08090860f, -0.29860851f, 0.17524891f, -0.45529538f, -0.40736935f, -0.18388410f, 
    0.22067520f, -0.09446863f, 0.11064516f, 0.05456215f, -0.10211454f, -0.19468740f, -0.13975649f, 0.00822047f, 
    -0.07166743f, -0.04522793f, -0.03251051f, 0.22461873f, 0.08088835f, 0.03004739f, -0.10642846f, 0.05843674f, 
    0.12997662f, 0.03143413f, 0.03761376f, -0.12570633f, -0.01324460f, -0.06792822f, 0.06357029f, -0.01681880f, 
    -0.08568065f, 0.21029945f, -0.16108665f, 0.02271550f, -0.00703052f, 0.01856636f, 0.05582228f, 0.10632968f, 
    -0.13001242f, -0.14812593f, 0.13011244f, -0.14272128f, 0.01675966f, 0.17340012f, -0.01306542f, 0.14881040f, 
    -0.05573213f, -0.16425681f, -0.12716243f, 0.03128881f, -0.16209505f, -0.17972095f, -0.19089837f, 0.13495630f, 
    -0.10730723f, -0.28295416f, 0.12081115f, -0.13941368f, -0.24817263f, -0.00940157f, -0.16845985f, -0.04105224f, 
    0.05526031f, -0.10567024f, -0.08381415f, -0.14532019f, -0.32689118f, 0.03855117f, -0.04447208f, -0.00596752f, 
    -0.07449346f, 0.11814876f, 0.13840537f, -0.20825893f, -0.05912950f, -0.35426813f, -0.10944209f, -0.08932448f, 
    0.05365486f, -0.01916371f, -0.15203691f, 0.09855745f, 0.11062553f, -0.06042268f, 0.03038375f, -0.10948425f, 
    0.05871959f, -0.05064723f, 0.14793107f, 0.11535917f, 0.12110942f, 0.07026731f, -0.19906200f, -0.05062348f, 
    -0.09774781f, -0.13967553f, 0.08174706f, 0.09036060f, -0.00426516f, -0.02980166f, 0.02092024f, 0.04151030f, 
    -0.01247813f, -0.03841635f, 0.15604751f, -0.09479284f, -0.05867281f, 0.03826604f, 0.01270797f, 0.09521924f, 
    -0.00669485f, -0.33458355f, 0.10536597f, -0.03744993f, 0.08903294f, -0.05455777f, 0.02328628f, 0.10751613f, 
    0.00633900f, 0.12917459f, -0.19843353f, -0.04953900f, -0.16742390f, 0.08037232f, 0.13227226f, -0.04252698f, 
    -0.01822115f, -0.14105089f, 0.07607158f, -0.05193322f, 0.11912163f, -0.04514284f, 0.06740131f, 0.01452798f, 
    0.05791961f, -0.05681134f, -0.27541280f, -0.13669120f, -0.29799932f, -0.42495593f, 0.15918376f, -0.13217968f, 
    -0.17575058f, 0.05274870f, 0.01605305f, -0.00704822f, 0.13381858f, -0.07081828f, 0.15348214f, 0.08727428f, 
    0.02619459f, 0.06922350f, -0.01199249f, 0.08261051f, 0.11095418f, 0.13418044f, 0.05636724f, 0.15189691f, 
    0.07093797f, 0.02081870f, 0.12875919f, 0.14225383f, -0.01553820f, -0.08041026f, -0.24557178f, -0.19203936f, 
    -0.21283540f, 0.14824729f, -0.01689368f, -0.00556500f, 0.17862238f, -0.01532110f, 0.02547934f, 0.52716982f, 
    -0.22340669f, -0.13783543f, 0.01058563f, 0.05202280f, 0.00858228f, 0.05930290f, 0.02393612f, 0.16580772f, 
    -0.10641638f, 0.29295450f, 0.01907228f, -0.05046127f, 0.08016571f, -0.04901614f, 0.09117656f, -0.12517135f, 
    -0.22044004f, -0.34433576f, 0.02011629f, 0.05410663f, -0.04554977f, -0.00145471f, -0.06027363f, -0.10829856f, 
    0.06182956f, -0.07319687f, -0.10750953f, -0.06325840f, -0.05879979f, -0.05989305f, 0.12408900f, -0.03900930f, 
    -0.35173121f, -0.07466492f, 0.07066753f, 0.12435675f, -0.02974811f, -0.08759815f, -0.21987356f, 0.10471568f, 
    -0.07603931f, 0.01142874f, 0.18761818f, 0.05354872f, 0.03628613f, 0.07776644f, 0.15314206f, 0.06756166f, 
    0.00204907f, 0.00340903f, 0.04399029f, 0.04130518f, 0.05759438f, -0.22300160f, -0.09108321f, 0.00384000f, 
    0.02990694f, 0.11003456f, 0.18204330f, 0.00510042f, -0.11299903f, -0.09065069f, 0.04452082f, -0.01958727f, 
    0.08664491f, 0.01366946f, 0.09138553f, 0.19387278f, 0.03947160f, 0.04976072f, 0.02707560f, 0.17376991f, 
    -0.00181764f, 0.07096952f, -0.09439880f, 0.06491918f, -0.28066054f, -0.14654796f, -0.10632566f, 0.05814794f, 
    -0.05055678f, 0.12882149f, 0.03012359f, 0.06157534f, -0.06205873f, 0.05566119f, -0.03998866f, 0.00414793f, 
    -0.07558244f, 0.04019855f, 0.01923714f, 0.05223951f, 0.06802424f, 0.02785299f, -0.01433273f, 0.07404374f, 
    -0.09160102f, 0.06927194f, 0.12715054f, 0.22188456f, 0.30907041f, -0.10938024f, 0.16557476f, -0.09929505f, 
    0.12626137f, -0.08850133f, -0.25413677f, 0.04756276f, 0.03147747f, -0.08498759f, -0.00957253f, 0.04327859f, 
    -0.29077554f, -0.05706481f, -0.14300376f, -0.11708941f, -0.12578458f, -0.10551770f, 0.21089862f, 0.21425048f, 
    -0.03380423f, -0.13490725f, -0.08190364f, 0.16420494f, 0.18203804f, 0.14390098f, 0.13178477f, 0.03380833f, 
    -0.00000895f, -0.03316128f, -0.03940224f, 0.12447138f, -0.06713802f, 0.07636765f, -0.02580662f, 0.20162416f, 
    0.24052283f, -0.22105731f, 0.08835047f, -0.06762610f, -0.07962756f, -0.18481018f, -0.23041403f, 0.12239936f, 
    -0.14642686f, 0.04172166f, -0.06651098f, 0.04022170f, 0.07640694f, -0.17445172f, -0.11626396f, 0.00526198f, 
    -0.08426464f, -0.06200249f, -0.19529450f, 0.04946391f, -0.09516577f, 0.03102650f, -0.01311089f, 0.06327423f, 
    -0.01134720f, 0.06532545f, 0.18563418f, 0.05139929f, -0.03804586f, -0.12461422f, -0.10198530f, -0.05077160f, 
    -0.04288862f, 0.00598023f, 0.08319056f, 0.08601845f, -0.06877664f, -0.03559435f, 0.01931244f, -0.00835674f, 
    -0.17173834f, -0.15851986f, -0.23524401f, 0.31321543f, -0.12316157f, 0.27576393f, -0.10400961f, -0.18748744f, 
    -0.04550265f, -0.07810476f, -0.05472834f, 0.00047522f, 0.05595186f, 0.11322228f, 0.16336720f, 0.10506482f, 
    -0.01397250f, -0.07389896f, 0.03774855f, -0.18424019f, 0.02523732f, 0.00941507f, -0.02209914f, 0.18978626f, 
    0.07270761f, -0.02708886f, -0.03619754f, 0.05587939f, -0.03347139f, 0.03848904f, -0.03154687f, 0.11346352f, 
    0.04085308f, -0.13074009f, 0.01509152f, 0.12229194f, -0.10504911f, -0.11782987f, -0.01853113f, 0.06597523f, 
    -0.06394240f, 0.05595114f, -0.03213814f, -0.01374942f, 0.03858820f, 0.11694165f, 0.12748085f, -0.05649521f, 
    0.18297452f, -0.10349616f, -0.04453401f, -0.02653654f, 0.00182543f, 0.13444275f, -0.15666063f, -0.51952326f, 
    0.12198955f, -0.00142097f, -0.36429349f, -0.30137765f, 0.21259923f, -0.01824043f, -0.16977616f, -0.00627309f, 
    0.17270945f, 0.08512471f, -0.06273904f, 0.11390886f, -0.02962517f, 0.01856324f, -0.01548591f, 0.02438540f, 
    0.07826199f, 0.05261141f, -0.06881403f, 0.19659264f, 0.00099401f, 0.08725912f, 0.03410886f, -0.08736409f, 
    -0.01135898f, 0.26263440f, -0.18188122f, -0.08407488f, -0.12398386f, -0.20225622f, -0.33687523f, 0.15240641f, 
    0.10888951f, -0.03750959f, -0.00217934f, 0.07560838f, 0.14069970f, 0.03321029f, -0.05365439f, 0.01201160f, 
    0.13906799f, 0.06786291f, 0.18025178f, -0.11121802f, 0.09584464f, -0.10674369f, 0.15399338f, 0.06981289f, 
    0.07938661f, -0.01582867f, -0.07265367f, 0.01478166f, 0.08945584f, -0.14377730f, -0.12409427f, 0.26271558f, 
    -0.19356219f, 0.04320211f, 0.10649320f, 0.10879685f, -0.05139037f, 0.08994242f, 0.22652099f, 0.25301114f, 
    -0.37908980f, 0.20315623f, 0.18761829f, 0.01527836f, 0.15218739f, -0.03394158f, -0.08092774f, 0.01269335f, 
    -0.06342690f, 0.53197443f, -0.14113444f, 0.00580261f, 0.01534420f, 0.13141283f, -0.08139477f, 0.05890165f, 
    -0.02178539f, -0.01751080f, -0.15246421f, -0.11043838f, -0.38498124f, -0.09236225f, 0.05002609f, -0.14164233f, 
    -0.04240274f, 0.00851565f, 0.01959562f, 0.13559593f, -0.07053947f, -0.01380756f, 0.08768887f, -0.05176341f, 
    -0.00935183f, 0.09517328f, -0.07755225f, -0.04922261f, 0.16866769f, 0.03810854f, 0.03247759f, -0.03349018f, 
    0.04845162f, 0.01425551f, 0.01025049f, 0.09222110f, 0.03534808f, -0.34304798f, 0.28478470f, 0.33886233f, 
    0.02120003f, 0.11349168f, -0.11424098f, 0.01288827f, -0.07852121f, 0.02311953f, -0.41541740f, -0.23842131f, 
    0.13266701f, -0.00757587f, -0.08577242f, -0.22841151f, -0.02305391f, 0.01263511f, 0.10566835f, -0.09358545f, 
    0.15712929f, -0.06391600f, -0.04812926f, -0.01302928f, -0.09081358f, 0.10177080f, 0.08242351f, -0.07430150f, 
    0.03394125f, -0.02588534f, -0.10652495f, -0.05128727f, -0.13232914f, 0.09868872f, 0.11339992f, -0.04824461f, 
    0.04475371f, -0.14686856f, 0.01285233f, -0.07031950f, 0.08768456f, 0.13402422f, 0.14340909f, 0.06582340f, 
    0.07407544f, 0.12373233f, -0.23454529f, 0.09370926f, 0.23896666f, 0.08608362f, 0.07622841f, 0.01004121f, 
    -0.12998080f, -0.00753219f, 0.09328931f, -0.06956430f, -0.06453515f, -0.31002566f, -0.03658988f, -0.06327788f, 
    0.01961227f, 0.11019053f, 0.01723764f, -0.00453502f, -0.07288560f, -0.29775593f, 0.02553661f, 0.16414167f, 
    0.05009632f, -0.08794897f, 0.12833741f, 0.06365415f, -0.00914166f, 0.36994603f, 0.01466898f, 0.02665459f, 
    -0.09079655f, -0.17211606f, -0.03654100f, -0.05745097f, 0.02827469f, -0.11764289f, -0.04347984f, -0.13654910f, 
    -0.04001526f, 0.15062372f, 0.08514633f, -0.09872924f, 0.03395614f, -0.07842083f, 0.02263572f, -0.23157716f, 
    0.13897528f, 0.05134339f, -0.15156400f, 0.03870987f, -0.09254187f, 0.00792806f, -0.11340624f, -0.00076931f, 
    0.31335640f, 0.00053669f, 0.02248359f, 0.05462354f, 0.11142511f, 0.01212837f, 0.02807072f, 0.07887886f, 
    0.03016838f, 0.15590197f, 0.08813027f, -0.07552975f, -0.14425418f, -0.26505098f, -0.07130373f, -0.10450461f, 
    0.12435224f, -0.05832610f, -0.04988977f, 0.06209521f, -0.01497171f, -0.01212154f, -0.02069466f, -0.20883974f, 
    -0.14695662f, -0.01846324f, 0.10261761f, 0.00925266f, 0.13610475f, 0.00636679f, -0.03972233f, 0.04572874f, 
    -0.15146826f, 0.04454495f, -0.01926984f, 0.01417455f, 0.25792763f, -0.02032111f, -0.08432378f, -0.05969414f, 
    -0.10649255f, 0.00089639f, -0.11623637f, -0.05954103f, 0.01803868f, 0.34204262f, -0.09920844f, -0.01511437f, 
    -0.04565437f, -0.06963509f, 0.06982663f, 0.00358875f, 0.11006014f, 0.00683066f, 0.17506315f, -0.00723507f, 
    0.03008996f, -0.19381556f, -0.16376799f, -0.00748936f, 0.08572609f, -0.05268799f, 0.25470442f, -0.06541333f, 
    -0.14074850f, -0.12246729f, 0.05535212f, 0.04373286f, 0.24322937f, 0.08750648f, 0.07369601f, 0.06368487f, 
    -0.09005960f, -0.27996853f, 0.09690239f, -0.03083697f, -0.01645753f, -0.03862945f, 0.02031564f, -0.14081512f, 
    0.14883307f, 0.26041290f, -0.13583928f, -0.19383740f, 0.20432608f, 0.06670064f, -0.18261844f, -0.03458552f, 
    0.09621079f, -0.04138763f, 0.10260939f, 0.09486424f, -0.09412640f, -0.14470844f, -0.13742574f, 0.00940463f, 
    -0.13136607f, 0.09502470f, -0.05461669f, 0.08781862f, -0.17213042f, -0.03996089f, 0.01902679f, 0.02970989f, 
    0.09063271f, 0.08640236f, 0.05685728f, 0.05989175f, 0.00090231f, -0.22589351f, -0.19976418f, -0.02030183f, 
    0.02834031f, -0.08797279f, 0.15900780f, 0.08783545f, 0.06814953f, 0.09190358f, 0.06542528f, 0.01912761f, 
    0.09507495f, -0.07976110f, -0.08414134f, -0.00081419f, -0.01419461f, 0.11781557f, -0.00544302f, -0.07681560f, 
    0.05193884f, -0.05589991f, -0.00404569f, 0.16328530f, 0.04060227f, 0.01803627f, 0.08656378f, 0.26163059f, 
    -0.06695768f, -0.11238559f, 0.02107826f, 0.01716607f, 0.23369515f, 0.00351620f, -0.09108934f, -0.11075149f, 
    -0.01276653f, 0.02644901f, 0.26534775f, -0.03371925f, -0.25245267f, -0.04025665f, -0.07905717f, -0.02878418f, 
    0.02019114f, 0.14821105f, -0.39163697f, -0.61981940f, -0.04562053f, 0.16534126f, 0.00140376f, -0.05306478f, 
    0.02392436f, -0.05689007f, 0.12186052f, 0.46136028f, 0.14712983f, -0.08597361f, -0.07943787f, 0.06061374f, 
    -0.05430606f, -0.02115748f, 0.02759872f, -0.10351481f, -0.10809014f, -0.21784414f, -0.06211043f, 0.17709096f, 
    0.19661069f, 0.10909943f, 0.06057848f, 0.10799786f, -0.05829022f, 0.06913546f, -0.09987335f, 0.01943663f, 
    -0.04165782f, 0.04806611f, 0.17136388f, -0.01021248f, 0.08545167f, 0.17037815f, 0.16781853f, -0.11618975f, 
    -0.10432615f, -0.34663838f, -0.02425284f, 0.00656055f, -0.00752343f, -0.05123818f, 0.01482232f, 0.17549679f, 
    -0.41370985f, 0.15485600f, -0.11206645f, -0.17720833f, 0.04754516f, -0.00530239f, 0.15680599f, -0.19280289f, 
    0.18515310f, -0.15341534f, -0.01525155f, 0.06023612f, 0.12233204f, -0.02405815f, -0.04565977f, -0.06854560f, 
    0.02174771f, -0.07312985f, 0.19683363f, 0.05678071f, 0.02937907f, -0.01045403f, -0.04693545f, 0.04767499f, 
    0.00180441f, 0.10093884f, 0.05476562f, 0.23327641f, -0.14133513f, -0.24810429f, -0.05475608f, 0.09882973f, 
    0.04302896f, 0.05728237f, -0.15875626f, 0.09474862f, -0.11184528f, -0.12617108f, -0.19650643f, 0.01625778f, 
    0.00744624f, 0.04010765f, -0.13052164f, 0.15367666f, 0.09828317f, -0.00320450f, 0.05006457f, 0.02490490f, 
    0.11022692f, 0.15171474f, 0.08257253f, -0.14561428f, 0.06779593f, 0.05170552f, 0.05858802f, -0.16245015f, 
    -0.09932403f, -0.06345807f, 0.17421538f, -0.10767847f, 0.25907871f, -0.17144546f, -0.15459847f, 0.15780310f, 
    -0.01411214f, 0.09688582f, -0.08098976f, 0.06421081f, -0.02863154f, 0.02159538f, -0.12757903f, -0.10440814f, 
    -0.17088173f, -0.16014872f, -0.07104604f, 0.11968201f, 0.02710129f, -0.01796178f, -0.02625755f, -0.28713802f, 
    0.14832142f, -0.27809015f, 0.04738709f, 0.04337047f, 0.06617528f, 0.12642099f, -0.00742018f, 0.09033878f, 
    0.16313422f, -0.44465804f, 0.07827971f, 0.07193920f, 0.11234441f, -0.13244615f, 0.02828186f, -0.04363987f, 
    -0.03065529f, -0.08893395f, -0.01251447f, 0.07727274f, 0.00166171f, 0.04276112f, -0.15926753f, 0.13740329f, 
    -0.13079967f, 0.18120787f, -0.06408483f, 0.03050876f, -0.19276696f, -0.38037032f, 0.01951906f, -0.06629600f, 
    -0.04175015f, -0.10336547f, -0.09889969f, -0.00049509f, 0.21317622f, 0.19525976f, -0.02193860f, 0.03512898f, 
    -0.08641492f, 0.10017051f, -0.10319524f, -0.01481689f, -0.26842117f, 0.07242025f, -0.10768872f, 0.08744544f, 
    0.02762055f, -0.16308734f, 0.19319814f, -0.07366828f, -0.11620795f, 0.22176409f, -0.01145944f, -0.24300382f, 
    -0.04333845f, 0.13911562f, 0.10069552f, 0.13241048f, 0.06824934f, 0.15502404f, -0.28264144f, 0.16387711f, 
    -0.13515021f, -0.04468240f, -0.02295283f, -0.16283643f, -0.07177282f, -0.09313575f, 0.09795053f, -0.18457451f, 
    0.09972078f, 0.09220394f, 0.00244136f, -0.30401722f, 0.11560553f, 0.12987350f, -0.12623608f, -0.07523613f, 
    -0.10784840f, 0.06628746f, 0.23579516f, -0.12519291f, 0.16852047f, -0.02829955f, 0.10872389f, 0.09890427f, 
    -0.17385517f, 0.15900777f, 0.01746252f, -0.35133415f, -0.00777376f, 0.15274821f, -0.04153791f, 0.05126171f, 
    0.02721074f, -0.02604591f, -0.15468259f, -0.16778255f, 0.05076554f, 0.03588297f, -0.03068988f, 0.01983077f, 
    -0.03416775f, 0.07846185f, 0.13699718f, 0.04232961f, 0.03762966f, -0.22903834f, -0.12713769f, 0.03173506f, 
    -0.17903006f, -0.08630510f, 0.05764755f, 0.09929607f, 0.25001928f, 0.31047425f, 0.04163299f, 0.11000108f, 
    0.08170323f, -0.03745945f, 0.10667777f, 0.13143264f, 0.01340752f, -0.28228045f, 0.00979799f, -0.18838261f, 
    0.07779771f, 0.26582268f, 0.16462985f, 0.08059070f, -0.00323642f, -0.06061193f, 0.03550119f, 0.03900270f, 
    0.04941763f, -0.08485380f, -0.21563813f, -0.00174138f, 0.07538243f, 0.11988840f, 0.09642390f, -0.45340291f, 
    -0.00915854f, -0.15330939f, 0.10537883f, 0.01892980f, -0.13272446f, 0.11018141f, -0.02713799f, -0.03402098f, 
    -0.25481203f, -0.19868618f, 0.34825715f, 0.09586669f, 0.09837462f, 0.10499036f, 0.08077005f, 0.09916699f, 
    0.04041677f, 0.24209589f, 0.27730224f, 0.30433971f, 0.09168387f, 0.04708745f, 0.03422226f, 0.12644167f, 
    0.03853067f, 0.14061278f, 0.14313115f, 0.00188685f, 0.03289305f, 0.19363157f, 0.01181194f, -0.00439477f, 
    0.08747943f, 0.00418614f, -0.18710613f, -0.09986595f, 0.43614933f, 0.24122103f, 0.13431771f, 0.02939580f, 
    -0.02843676f, 0.11300665f, 0.02890352f, 0.06654122f, 0.08556499f, 0.10290986f, -0.05288148f, -0.02963672f, 
    -0.01190151f, -0.01144668f, -0.09713675f, -0.01880442f, -0.18637429f, -0.26910186f, -0.36459792f, 0.18788306f, 
    0.07443320f, -0.01541792f, -0.10161108f, -0.02498194f, 0.12726873f, 0.01734792f, -0.07912936f, 0.08529569f, 
    -0.17827529f, 0.06571257f, 0.06315822f, 0.06855558f, -0.15445653f, -0.04478388f, -0.22608232f, 0.24026701f, 
    0.15877078f, 0.13034256f, 0.10435695f, 0.02458529f, 0.03677536f, -0.01378355f, 0.09659034f, -0.00062230f, 
    0.12420139f, 0.18798076f, -0.01511309f, 0.10365254f, 0.05084121f, -0.01146964f, 0.08666349f, -0.06605662f, 
    0.04857859f, 0.05393029f, -0.15980335f, 0.00051861f, 0.08655538f, 0.03480160f, -0.04685365f, -0.10546461f, 
    -0.02161929f, -0.17695782f, 0.17369312f, -0.06899396f, -0.01784842f, 0.12919012f, 0.17171654f, 0.03606841f, 
    0.01357573f, 0.07634217f, 0.16813858f, -0.00837200f, 0.28113076f, 0.34124282f, 0.10443071f, 0.07531434f, 
    0.05950684f, 0.01221067f, 0.04867343f, 0.00601880f, -0.10613309f, 0.28700474f, -0.02361424f, 0.06569164f, 
    0.10972153f, 0.11321501f, -0.11596894f, -0.03071601f, -0.31063244f, 0.10385380f, 0.16950214f, -0.13397750f, 
    -0.12488011f, -0.00022442f, -0.05266258f, -0.08346201f, -0.12481581f, -0.08262459f, 0.02483280f, 0.30325907f, 
    0.13135822f, 0.11997007f, 0.09837936f, 0.10002857f, 0.03670070f, -0.04367291f, 0.18276581f, -0.02334815f, 
    0.13036488f, 0.30325171f, -0.05548308f, 0.05828138f, 0.00458211f, -0.01745945f, 0.00775990f, 0.04839346f, 
    0.18925966f, 0.10273536f, 0.19153202f, -0.07181067f, -0.02884035f, -0.04693464f, 0.08815019f, 0.12244706f, 
    -0.05026205f, 0.08017838f, 0.12844130f, -0.00267262f, 0.01820366f, -0.09751824f, -0.06984563f, 0.02869887f, 
    -0.06398630f, -0.05374924f, -0.19226557f, -0.16536455f, -0.26810667f, -0.03851934f, 0.13991709f, 0.05226690f, 
    0.18934168f, 0.19296585f, -0.07778852f, 0.35940358f, 0.19686048f, 0.25052404f, 0.21953997f, -0.17644988f, 
    0.10118571f, -0.13072938f, -0.06551807f, -0.23353730f, 0.00545258f, 0.14953244f, -0.14043669f, -0.15155409f, 
    -0.07649036f, -0.03885315f, 0.15046403f, -0.08128059f, 0.13236228f, -0.09459851f, 0.16233400f, -0.02846106f, 
    0.05081029f, -0.03456065f, 0.01234751f, -0.08689083f, -0.05403331f, -0.07971276f, 0.03395686f, -0.04672354f, 
    -0.02023754f, 0.06198887f, 0.21091259f, 0.03202908f, 0.12511955f, 0.11381964f, 0.08685203f, 0.11840755f, 
    0.01969805f, -0.11870781f, 0.13965841f, 0.11251646f, 0.15283033f, 0.06300028f, 0.09410323f, 0.16176818f, 
    0.30772543f, 0.25330904f, -0.03959268f, 0.01814589f, -0.01283152f, -0.10676466f, -0.10445625f, -0.05319566f, 
    0.03884698f, -0.19658868f, 0.15600426f, 0.15629709f, 0.12554207f, 0.07757231f, 0.00966150f, 0.15706435f, 
    0.10327441f, -0.07349692f, 0.19674911f, 0.19377129f, -0.05677547f, 0.04550116f, -0.00839836f, -0.10414457f, 
    0.11168545f, -0.03608713f, 0.18089695f, -0.03128808f, -0.10192636f, -0.25627607f, -0.09031143f, -0.01239436f, 
    0.06836433f, -0.18495768f, 0.01167434f, 0.01657869f, 0.10089326f, -0.00590945f, 0.06498528f, 0.09238759f, 
    -0.08105513f, 0.08900098f, -0.08057895f, -0.07621160f, -0.31106219f, 0.15420714f, 0.11624832f, 0.11677509f, 
    -0.01127189f, 0.00520562f, 0.06156442f, 0.03641832f, 0.05204368f, 0.22278109f, -0.15617189f, -0.11568086f, 
    -0.05710659f, 0.06461589f, 0.02924261f, -0.01938886f, -0.21669345f, -0.03798826f, -0.30269277f, -0.06579741f, 
    0.25377703f, -0.10610750f, 0.15770261f, 0.08403388f, -0.14488582f, 0.00146887f, 0.00126251f, -0.23951298f, 
    0.03926016f, -0.04018668f, 0.02244804f, -0.00691418f, -0.00675193f, 0.00661364f, -0.06402765f, -0.02592504f, 
    0.03672073f, -0.00343230f, 0.03057881f, 0.04003569f, 0.02494908f, 0.03568459f, 0.03480438f, -0.00394392f, 
    0.04160340f, -0.03746317f, -0.05855121f, -0.04551718f, 0.02667742f, -0.02024519f, 0.04254415f, -0.00112292f, 
    -0.04795215f, -0.01311929f, -0.03398142f, -0.02720622f, -0.06750312f, 0.03670212f, -0.00249995f, 0.01685857f, 
    -0.03024763f, -0.03334645f, -0.05678788f, -0.05921158f, -0.03356780f, -0.00659661f, -0.05818740f, 0.03887610f, 
    -0.02717826f, 0.02919046f, -0.05475118f, 0.02140759f, -0.03384476f, -0.05461383f, -0.03253507f, 0.03099722f, 
    -0.03601379f, 0.03454018f, 0.02183241f, -0.03504509f, -0.03388509f, -0.01477755f, -0.00976907f, -0.00532443f, 
    0.04933945f, -0.05504671f, -0.04764828f, -0.00909438f, -0.02387039f, -0.05331111f, -0.02507494f, 0.01833239f, 
    -0.02312705f, -0.03842672f, -0.03420959f, 0.02766929f, 0.01840938f, 0.04433649f, -0.03709328f, 0.02217141f, 
    0.01688739f, 0.03526650f, -0.00301251f, -0.01358699f, 0.03677593f, 0.00874144f, -0.05807816f, 0.01256948f, 
    0.00898179f, 0.03860215f, 0.03588882f, -0.05918417f, -0.04423426f, -0.06543350f, 0.03779453f, 0.04474185f, 
    -0.02712717f, -0.03738657f, -0.01211223f, -0.01140237f, -0.06270748f, -0.05072178f, 0.01519249f, -0.03648562f, 
    -0.01683832f, -0.00005619f, 0.02218362f, 0.00604037f, 0.01362915f, -0.05415614f, 0.02851796f, 0.01976954f, 
    0.01858672f, 0.04895885f, -0.03258626f, -0.00605379f, -0.04592266f, -0.00731588f, 0.01349542f, 0.02746511f, 
    0.03550725f, -0.03701562f, 0.04762498f, 0.03916545f, -0.00307460f, -0.06383555f, 0.01378027f, -0.03924138f, 
    -0.06499611f, 0.01150488f, -0.00687780f, 0.01048649f, -0.04043026f, -0.06279024f, 0.03230129f, -0.03948043f, 
    -0.01567500f, -0.03005204f, -0.05957986f, 0.02356032f, 0.00510959f, 0.01175428f, -0.03884799f, 0.02660358f, 
    0.00267052f, 0.02907833f, -0.04613064f, -0.00784696f, 0.02542264f, 0.03617139f, 0.00656170f, 0.00280086f, 
    -0.03518865f, -0.01950016f, -0.06226032f, 0.02152846f, 0.03260520f, -0.03842009f, 0.02512083f, 0.04568220f, 
    0.04033343f, 0.01274864f, -0.03779241f, -0.03317131f, -0.01800968f, 0.00852213f, 0.02440038f, 0.00175884f, 
    0.00958641f, -0.00544639f, -0.00216629f, 0.04181034f, -0.00676655f, -0.00144169f, -0.04894737f, 0.01431458f, 
    0.00189079f, 0.02848843f, 0.01712005f, -0.04759391f, -0.05585165f, 0.04744447f, 0.03199499f, 0.03901970f, 
    0.01423315f, 0.04468284f, -0.03999569f, 0.02964050f, 0.01015219f, -0.00372127f, 0.02944358f, -0.06173921f, 
    -0.01275811f, -0.06435617f, -0.04330859f, 0.01408007f, 0.04478294f, 0.00563680f, 0.00326054f, 0.01742232f, 
    0.00123035f, 0.01325657f, 0.00695390f, 0.04386521f, -0.01596970f, -0.01034354f, -0.03140256f, 0.03207647f, 
    -0.04368096f, -0.00212345f, -0.06415318f, 0.02590686f, -0.02829179f, 0.01412303f, 0.01824176f, -0.01589739f, 
    -0.06773169f, -0.02874578f, 0.01961527f, -0.05390409f, -0.00452183f, -0.05581145f, 0.02844827f, 0.03416055f, 
    -0.06118917f, -0.01298677f, 0.03675720f, 0.03966647f, -0.02105816f, -0.02988850f, -0.01102947f, -0.00605363f, 
    -0.05135013f, -0.01198205f, -0.02417644f, -0.01436944f, -0.01524589f, 0.03706237f, 0.04767268f, -0.03135166f, 
    0.02930322f, 0.01021569f, 0.01570492f, -0.06401686f, -0.06556510f, 0.01201453f, 0.04509860f, 0.01433882f, 
    -0.01532782f, 0.00069620f, -0.06697386f, -0.01923403f, 0.02802711f, 0.03019199f, -0.00881041f, -0.01156576f, 
    0.03062542f, 0.00441658f, 0.01723043f, -0.03769810f, -0.04939996f, -0.02006214f, 0.00611855f, -0.04090018f, 
    0.04309633f, 0.00546916f, -0.06401689f, 0.00098321f, -0.04323916f, 0.04168529f, 0.04512695f, 0.01470834f, 
    0.01400688f, -0.04767798f, 0.00032986f, 0.02864164f, 0.04341083f, -0.02372422f, 0.02326808f, -0.03680583f, 
    -0.01763874f, -0.03235866f, -0.02322960f, 0.01009543f, 0.01058706f, -0.00065471f, 0.04712118f, -0.02423916f, 
    -0.00348879f, -0.03286980f, 0.05138239f, 0.04775514f, -0.04807939f, 0.04256217f, 0.01181657f, 0.00499548f, 
    0.15508880f, -0.45081598f, -0.62255323f, -0.23716146f, -0.09687471f, 0.07127809f, 0.18812385f, -0.00707200f, 
    0.00143388f, 0.10866615f, -0.16500980f, -0.17332409f, 0.09027673f, -0.00741961f, 0.12082478f, 0.06745640f, 
    -0.07105016f, 0.22668363f, 0.06907604f, -0.10413533f, -0.22372252f, -0.08218301f, -0.03848787f, 0.04647417f, 
    0.12635845f, -0.19554806f, -0.08255303f, -0.14081247f, -0.34696645f, -0.21367146f, 0.06255190f, 0.11891082f, 
    -0.00581564f, 0.06382050f, 0.17908674f, -0.15590219f, 0.11489226f, 0.06624032f, 0.04744954f, -0.10123911f, 
    -0.25531361f, -0.03840185f, 0.16487367f, 0.01856118f, 0.07444616f, 0.16086702f, -0.44579867f, -0.53358018f, 
    0.01959359f, 0.18027161f, -0.01532955f, 0.05695095f, -0.01710577f, -0.04744011f, 0.07274491f, 0.23321424f, 
    0.25023469f, -0.04243956f, -0.01500488f, 0.06369551f, 0.13263533f, 0.03699164f, -0.09082279f, -0.07558354f, 
    -0.42564648f, 0.00266224f, -0.04440930f, 0.02308178f, -0.02016047f, 0.06376664f, 0.09052559f, 0.09389976f, 
    0.04467873f, 0.06170637f, 0.08077379f, -0.02154517f, -0.04561381f, -0.00921085f, 0.11608545f, -0.08937755f, 
    0.02559520f, 0.09707804f, 0.02251356f, -0.13644947f, -0.16496573f, -0.15661013f, -0.04443956f, 0.13276206f, 
    -0.04869361f, -0.00347408f, -0.34602308f, -0.25458777f, -0.29007468f, -0.09878140f, -0.11608293f, 0.11621457f, 
    -0.01282523f, 0.01264959f, -0.02528008f, -0.13738011f, 0.08607884f, 0.06319090f, -0.01812733f, -0.03681570f, 
    0.03700735f, 0.15651163f, 0.03635398f, 0.05116102f, -0.20696610f, -0.03381218f, 0.16638322f, -0.00826135f, 
    0.16675092f, -0.06915346f, -0.19862080f, 0.16611832f, -0.12493179f, 0.14767882f, 0.04419088f, 0.05503785f, 
    -0.01402295f, -0.06430069f, -0.08137493f, -0.06215540f, 0.06513365f, -0.00681169f, -0.42360100f, -0.19076243f, 
    -0.19531047f, -0.07988775f, 0.03875408f, 0.10345852f, -0.00204503f, 0.09784120f, 0.04043633f, -0.14671187f, 
    -0.21210925f, 0.08777846f, -0.07344014f, 0.17237207f, 0.30887708f, 0.06324377f, -0.00283424f, -0.00540882f, 
    -0.03048632f, -0.15694854f, 0.01390269f, 0.04123489f, 0.01999852f, -0.00635363f, 0.08977105f, 0.16254219f, 
    0.14082827f, 0.19161275f, 0.04653542f, 0.02183795f, 0.03877293f, -0.00071299f, -0.04290320f, 0.04149333f, 
    -0.15864103f, 0.00884449f, 0.12146105f, -0.00319613f, 0.00186010f, -0.03320857f, -0.15704477f, -0.14907573f, 
    0.03542477f, 0.02175550f, 0.14139389f, 0.17635269f, -0.23512886f, -0.15729095f, -0.08579520f, -0.09713665f, 
    -0.08238783f, -0.02856028f, -0.12246008f, 0.03195108f, 0.20298134f, 0.06856396f, 0.13843201f, -0.08931544f, 
    -0.05060013f, -0.08129652f, 0.23866336f, 0.03501179f, 0.09575839f, 0.12645094f, 0.04032684f, -0.06246639f, 
    0.08243543f, -0.00390352f, 0.05799501f, 0.06822103f, -0.09276698f, 0.07980420f, 0.21398085f, 0.06825469f, 
    0.07512596f, 0.02423179f, -0.05343115f, -0.32807568f, 0.01833810f, 0.16934921f, 0.06704593f, 0.08743457f, 
    0.05509333f, -0.10666180f, -0.17968068f, -0.30801973f, -0.05939078f, 0.06216392f, -0.04265084f, -0.10851470f, 
    0.04975666f, -0.18083842f, 0.15331157f, -0.06312013f, -0.12658611f, -0.07247798f, 0.13131125f, 0.14033240f, 
    0.07356934f, -0.28942379f, 0.05651921f, 0.23207901f, 0.02591120f, 0.07339120f, -0.00277455f, 0.02529765f, 
    -0.04085483f, 0.14651309f, 0.05947301f, 0.03352958f, -0.02520032f, 0.05720178f, -0.07915274f, 0.00624803f, 
    0.01139017f, -0.22048429f, -0.07572458f, 0.32795531f, 0.18040319f, -0.03123074f, -0.25082484f, -0.34915927f, 
    -0.23104402f, 0.05115041f, 0.03361758f, -0.06496285f, -0.44779769f, -0.02280419f, 0.11766131f, -0.01097115f, 
    -0.02297632f, -0.02821687f, 0.10476194f, -0.00815530f, 0.18862338f, -0.12082510f, 0.05897949f, 0.09960959f, 
    0.00674453f, 0.03281474f, -0.04223181f, 0.08611093f, -0.07401074f, -0.00781380f, 0.19710459f, 0.06499632f, 
    -0.04341268f, -0.32166228f, -0.25355190f, -0.03472648f, 0.05346211f, 0.00455708f, 0.02119063f, 0.04651950f, 
    -0.16516791f, -0.03438426f, -0.05657810f, 0.12867336f, -0.01960495f, -0.09739610f, 0.13836415f, -0.16113946f, 
    -0.35701737f, -0.08728525f, 0.10011178f, 0.11470988f, 0.07367660f, -0.12877427f, 0.07938919f, -0.01853622f, 
    0.14477886f, 0.29744542f, 0.22383104f, -0.20565818f, 0.09461302f, 0.08443700f, -0.10221016f, 0.06189169f, 
    0.01142754f, -0.03958421f, 0.26790527f, 0.05045447f, 0.20313028f, -0.03428482f, -0.03445363f, 0.13531645f, 
    -0.01331076f, -0.20935783f, -0.18237445f, 0.28353977f, 0.15358351f, -0.16823806f, 0.08886318f, 0.15027933f, 
    -0.05764759f, 0.04927766f, 0.22395033f, -0.08609159f, -0.03816735f, 0.00368971f, -0.24601553f, 0.04915627f, 
    0.03283980f, -0.00318275f, -0.00184714f, 0.05322716f, 0.03574765f, -0.19590610f, 0.22755499f, -0.01662133f, 
    0.10500307f, 0.11334641f, 0.02274011f, 0.03420406f, 0.06034478f, 0.07355800f, -0.33459532f, -0.04906261f, 
    0.07584386f, -0.15355465f, 0.10955106f, 0.17783357f, 0.10876660f, -0.10779193f, -0.10651422f, -0.08051584f, 
    0.33172202f, 0.13851632f, -0.02732705f, -0.00982660f, -0.07946108f, 0.03187066f, -0.08228093f, -0.07332685f, 
    -0.02421155f, 0.06258062f, -0.01091731f, 0.03503513f, 0.04012324f, 0.06282080f, 0.02585236f, -0.11408329f, 
    0.12063597f, 0.11740437f, -0.04761605f, -0.07304891f, 0.05941469f, -0.01677134f, -0.04172081f, 0.04466457f, 
    0.07150813f, -0.01182588f, -0.30244935f, 0.12168935f, 0.19716147f, -0.06997465f, 0.00583882f, 0.20020166f, 
    0.16005754f, 0.03037311f, 0.01514848f, 0.07024915f, 0.15317547f, 0.18162885f, 0.01523647f, 0.04559289f, 
    -0.05683134f, 0.09591685f, -0.22285485f, -0.23082338f, -0.12337418f, -0.26495817f, -0.21013497f, 0.01795662f, 
    0.19961186f, -0.06664401f, 0.07830348f, -0.00745419f, -0.30250174f, -0.30552134f, -0.18037879f, -0.11954665f, 
    0.06781580f, 0.01120036f, -0.10060962f, -0.07798035f, -0.10618509f, -0.06716210f, -0.05197068f, -0.04056783f, 
    0.05988129f, -0.10597251f, 0.02545282f, 0.02038445f, 0.01606886f, -0.02532903f, -0.19795148f, -0.13628055f, 
    -0.02615035f, 0.04850182f, -0.05656309f, 0.12343936f, -0.05304950f, 0.00056535f, -0.04163475f, 0.10431040f, 
    -0.15908942f, -0.13767399f, -0.15654857f, -0.00255746f, 0.01766724f, -0.10649162f, -0.03116308f, 0.07538245f, 
    0.02483084f, -0.13025175f, -0.10109643f, -0.01371534f, 0.16463168f, -0.09111441f, -0.01452220f, 0.02507992f, 
    -0.11396929f, -0.10130388f, -0.19349149f, -0.02684384f, -0.38470635f, 0.14987303f, 0.03503286f, -0.03928034f, 
    0.01085597f, 0.19572586f, 0.03492052f, 0.02373768f, -0.11401942f, 0.32114756f, 0.09635834f, -0.01600790f, 
    -0.04411210f, 0.14921935f, 0.01977073f, -0.15838353f, -0.23660319f, -0.10618941f, -0.11717540f, 0.25328556f, 
    -0.03259919f, -0.01488302f, 0.18247062f, 0.16970025f, -0.07705689f, 0.13176726f, -0.14589347f, -0.16936280f, 
    -0.06536354f, 0.00047769f, 0.16897845f, -0.01123922f, 0.13216430f, 0.00581964f, 0.05228961f, -0.07326815f, 
    -0.16822346f, 0.14288437f, -0.01334001f, 0.09073392f, 0.11454322f, 0.23615076f, 0.03847164f, 0.07179791f, 
    0.05375836f, 0.05208345f, 0.08847580f, 0.05004418f, -0.02880413f, 0.17299688f, -0.11419901f, -0.00761030f, 
    0.02126315f, -0.01693863f, 0.30200827f, -0.03477462f, 0.07410349f, -0.07858226f, -0.02098365f, -0.17629287f, 
    0.09123749f, -0.20845136f, 0.07228881f, 0.05394045f, 0.06667223f, 0.14888382f, -0.04357944f, -0.04045527f, 
    -0.06384294f, -0.15862626f, 0.01146133f, -0.21538027f, -0.03682577f, 0.06141561f, 0.03443461f, 0.14211892f, 
    -0.08056096f, -0.00131018f, -0.11964429f, -0.07842642f, -0.07660400f, -0.29679149f, -0.14538339f, -0.08603304f, 
    -0.06144851f, -0.03989065f, 0.09582045f, 0.03564117f, 0.17016488f, 0.06445171f, 0.19015215f, -0.05214653f, 
    0.10308585f, 0.04682277f, -0.14324829f, -0.20027904f, -0.12104032f, 0.01322635f, 0.10618071f, 0.07398901f, 
    0.02549996f, 0.15726577f, -0.03197493f, 0.18354219f, -0.14076267f, 0.00078630f, 0.01886596f, -0.15938890f, 
    -0.12355410f, 0.03416034f, 0.05868252f, -0.01010082f, 0.06710428f, -0.05877965f, -0.11255862f, 0.38721016f, 
    -0.06648070f, -0.46054026f, 0.09032752f, -0.04382444f, -0.02924882f, 0.15748861f, 0.16562541f, -0.13941883f, 
    -0.26357746f, 0.09513953f, 0.10556829f, -0.20358741f, -0.00255364f, -0.20415834f, 0.00720626f, 0.10528855f, 
    0.14706728f, 0.11146946f, 0.05174145f, 0.17792055f, 0.02298540f, -0.10547423f, 0.10057739f, -0.05149963f, 
    0.20353018f, -0.06153702f, -0.14950751f, -0.13784005f, 0.06317149f, -0.00988282f, 0.02923042f, -0.35918605f, 
    -0.16040452f, -0.09842571f, -0.14038883f, -0.08676776f, 0.09100153f, 0.29255474f, 0.04874243f, 0.04790582f, 
    -0.01382645f, 0.00194732f, 0.20450260f, 0.07270896f, 0.05275578f, 0.02893833f, 0.09694026f, -0.03989110f, 
    0.07604644f, 0.04590305f, 0.04474242f, 0.07358132f, 0.03494205f, -0.31187904f, 0.17954046f, 0.15329123f, 
    -0.10771960f, -0.13179535f, -0.07955886f, -0.04454986f, -0.12484680f, -0.03245885f, 0.01302979f, -0.00024742f, 
    0.23490848f, -0.08082074f, -0.15934671f, -0.07146820f, 0.17496745f, 0.13332164f, 0.01202951f, -0.11672705f, 
    -0.23047179f, 0.03930942f, 0.01817012f, -0.10306092f, -0.19026466f, -0.04008891f, 0.14060090f, 0.14082187f, 
    0.04364533f, 0.08606871f, -0.07015324f, -0.01300537f, 0.13260512f, 0.10625592f, 0.04068530f, 0.07733466f, 
    0.09612153f, 0.04670088f, 0.08776693f, -0.00946755f, -0.06735802f, -0.00128597f, -0.01435220f, -0.09722704f, 
    -0.03473772f, 0.00219712f, 0.01387199f, -0.09666613f, 0.17072947f, -0.09803202f, 0.11883488f, -0.06677286f, 
    0.18261248f, 0.13225292f, 0.21415102f, -0.10673833f, 0.00279538f, 0.18771839f, -0.08128019f, -0.03023379f, 
    -0.24643098f, 0.05252196f, 0.01507993f, 0.01550374f, -0.12790139f, 0.23231359f, -0.11357459f, -0.10262913f, 
    -0.08057038f, -0.07479183f, 0.21919790f, -0.21804166f, 0.00951553f, 0.02889986f, -0.02004893f, 0.03812689f, 
    -0.01157507f, 0.06938639f, -0.03511471f, -0.01581619f, 0.01397999f, -0.11011045f, 0.00429360f, -0.20726298f, 
    0.22175996f, -0.02708957f, 0.09946974f, -0.10194947f, 0.15003999f, 0.20270783f, 0.21582803f, -0.13069423f, 
    0.15843388f, 0.35124254f, -0.05271883f, -0.17043027f, 0.16576460f, -0.07508577f, 0.01566985f, -0.04943313f, 
    0.05475512f, 0.05757229f, 0.00169378f, -0.04611029f, 0.09895405f, 0.06397449f, -0.05838995f, 0.05646564f, 
    0.03249680f, -0.06230955f, -0.09329175f, -0.07456524f, -0.03599612f, -0.02447015f, 0.04215288f, -0.00882150f, 
    -0.09261996f, -0.22567183f, -0.03145137f, -0.12603623f, -0.16612650f, -0.10991714f, -0.19154857f, -0.01825221f, 
    0.09972064f, 0.02300764f, 0.03858542f, -0.12559277f, 0.03420991f, -0.02168325f, -0.02532819f, -0.09473325f, 
    -0.33504781f, -0.10354315f, -0.03633979f, 0.10239976f, 0.00225312f, -0.12884757f, 0.16736735f, -0.07149673f, 
    0.08561792f, 0.10014775f, 0.14964703f, -0.09113298f, -0.12851062f, 0.10049399f, 0.09987640f, 0.04035705f, 
    -0.06226658f, 0.10163026f, 0.06158615f, -0.07957581f, 0.09656952f, -0.05321540f, -0.03412573f, 0.14955735f, 
    0.23458643f, -0.10566570f, 0.04643892f, 0.02096679f, 0.00101229f, 0.18014480f, -0.03027678f, 0.02263721f, 
    0.02237287f, -0.05389160f, 0.04736035f, 0.05223295f, -0.06869701f, -0.00456428f, -0.02825545f, 0.03353922f, 
    -0.22634132f, -0.01370018f, 0.01799705f, -0.23845221f, 0.02447386f, -0.52317172f, 0.03358308f, -0.07202391f, 
    0.15290880f, 0.01757491f, 0.09355476f, 0.19556959f, -0.04746122f, -0.12952423f, -0.06969070f, -0.06699532f, 
    0.04820377f, 0.00634995f, -0.07959446f, 0.13734351f, -0.16357288f, -0.03398204f, 0.06546823f, 0.10729202f, 
    0.10483176f, -0.04738854f, -0.07668514f, 0.11152452f, -0.01837660f, 0.02902067f, -0.07992251f, 0.04924885f, 
    -0.04319166f, 0.18284783f, -0.01303842f, -0.07185898f, -0.10752223f, -0.01392573f, 0.09359138f, 0.05736796f, 
    -0.17662404f, -0.21677269f, 0.00940916f, -0.09025045f, -0.06545754f, 0.04758172f, -0.02798204f, 0.22812341f, 
    0.11422260f, 0.25611529f, 0.18387690f, 0.10489251f, 0.27117544f, 0.16530049f, 0.00234336f, -0.04524079f, 
    -0.09718512f, 0.04965357f, 0.00846399f, -0.03226098f, 0.05800365f, 0.02155071f, -0.05879842f, -0.13018221f, 
    0.12544107f, 0.03467673f, -0.14655656f, 0.05596301f, 0.04687314f, -0.14771272f, 0.00068161f, -0.08918747f, 
    0.32802898f, -0.13111371f, -0.12529115f, -0.10243668f, 0.08681958f, 0.15227443f, -0.01797247f, -0.09885095f, 
    -0.00189746f, 0.08941835f, 0.03691853f, -0.90071279f, -0.13145238f, 0.00757568f, 0.02378315f, 0.10031742f, 
    0.05061381f, -0.00338617f, 0.29325712f, 0.27027211f, 0.13345267f, -0.06125326f, -0.02108803f, -0.10241148f, 
    0.10733204f, 0.15149467f, 0.00336378f, 0.42943165f, -0.17425817f, -0.03157136f, 0.00151270f, 0.06174610f, 
    0.16637181f, 0.07682054f, 0.06027433f, -0.10395121f, 0.07676648f, -0.09020843f, -0.32440370f, -0.04166342f, 
    0.04792830f, 0.09055533f, 0.07127375f, 0.12565288f, -0.01173769f, 0.19633031f, -0.12582017f, -0.19697160f, 
    -0.08146390f, 0.10911281f, 0.13723567f, -0.05725123f, -0.10962599f, 0.07618010f, -0.40817487f, -0.02557720f, 
    0.10032794f, -0.10605882f, -0.11907499f, -0.00725484f, 0.18952416f, -0.03040784f, 0.06826097f, 0.03401490f, 
    0.17561382f, 0.17924416f, -0.03969478f, -0.04792643f, 0.10168538f, -0.04608513f, -0.08614685f, 0.19878587f, 
    -0.05449458f, -0.01205046f, -0.03606773f, 0.00333331f, -0.14165227f, 0.00547448f, 0.06498981f, -0.08175195f, 
    -0.04814750f, -0.13143127f, -0.22114071f, 0.00377595f, -0.21598276f, -0.04812900f, 0.13507037f, 0.10927429f, 
    -0.00496318f, 0.08414973f, -0.02956299f, -0.01298924f, 0.00974135f, 0.00364992f, 0.02803566f, 0.17942809f, 
    0.15269966f, 0.01629339f, 0.02273417f, 0.31944320f, 0.13343287f, 0.06934809f, -0.01500878f, 0.03540323f, 
    0.04836475f, 0.08945727f, -0.13749300f, 0.05688730f, -0.33917180f, 0.09915164f, 0.22725905f, 0.14428994f, 
    0.12210839f, -0.11948729f, 0.06394010f, -0.00997737f, 0.16695154f, -0.14721179f, -0.11552304f, 0.31391162f, 
    0.19751681f, 0.03263707f, 0.07764263f, 0.01576051f, -0.08122841f, 0.02158832f, 0.20434453f, -0.13265057f, 
    0.12681364f, 0.06485229f, -0.00182381f, 0.07935032f, 0.09126886f, 0.03632034f, -0.05110686f, 0.28220060f, 
    -0.27026054f, -0.54722792f, 0.00250783f, -0.09381929f, 0.01763011f, 0.04853729f, 0.00207612f, -0.07625701f, 
    -0.13113080f, -0.25209931f, -0.17923823f, 0.03265352f, 0.19161178f, 0.08032710f, -0.02003289f, -0.02666685f, 
    0.09479219f, 0.26986548f, -0.10397854f, 0.01990603f, -0.07531902f, -0.19770119f, -0.06074854f, -0.03290468f, 
    0.06798925f, -0.06000166f, -0.03856329f, -0.45193589f, -0.10157713f, -0.13409859f, -0.13721620f, -0.08892474f, 
    0.03383846f, 0.13060841f, 0.03734750f, 0.06614461f, 0.22253142f, 0.30237839f, -0.23176041f, 0.02290361f, 
    -0.03312400f, 0.11784805f, 0.05556349f, 0.11322096f, -0.12436575f, -0.15078112f, -0.07631128f, 0.05572576f, 
    -0.01849727f, 0.04217057f, -0.13168190f, 0.03536639f, -0.24847145f, -0.05375597f, -0.34783369f, -0.28418484f, 
    0.02382086f, 0.00743674f, 0.09079171f, 0.12708955f, 0.10245494f, 0.04678392f, -0.18755460f, -0.15310220f, 
    -0.10063242f, 0.00240611f, -0.03370365f, 0.11822869f, 0.03921458f, 0.11456460f, -0.05769450f, -0.20431910f, 
    -0.34524232f, -0.07162239f, -0.19502732f, -0.22535762f, 0.12720706f, 0.07942192f, 0.10803343f, -0.06172214f, 
    -0.10606387f, 0.11643240f, 0.33485112f, -0.22663677f, 0.10872559f, -0.16552518f, 0.02710671f, 0.06178930f, 
    0.06106149f, -0.00853054f, 0.11295004f, 0.02405069f, 0.03572007f, -0.00403310f, 0.01735745f, -0.03685489f, 
    0.08743820f, -0.03441159f, -0.35833988f, -0.25153220f, -0.13446400f, -0.04256656f, -0.16669698f, 0.02974215f, 
    0.09148458f, 0.06433463f, -0.20247486f, -0.04629204f, -0.51386118f, -0.50675702f, -0.13377112f, -0.15803555f, 
    0.00258472f, 0.18286404f, 0.24463139f, 0.06330857f, 0.09566522f, 0.15710293f, 0.02395884f, -0.11100098f, 
    0.00581295f, -0.14089046f, 0.02026377f, -0.00191694f, 0.10930666f, -0.03899197f, 0.06707106f, -0.11385972f, 
    0.02179474f, 0.02341323f, 0.01285658f, 0.09628560f, -0.09476765f, -0.04276555f, 0.08339954f, -0.26866010f, 
    -0.07062098f, -0.08108725f, 0.09957691f, 0.04554050f, 0.12911747f, 0.03032669f, 0.00773534f, -0.05701758f, 
    -0.45736843f, 0.03022565f, -0.07499776f, 0.18807660f, 0.27796158f, -0.01235235f, -0.05169383f, 0.01976731f, 
    0.08533766f, -0.03467549f, -0.10863630f, 0.02616266f, 0.03292283f, 0.19788709f, 0.03710561f, -0.02024410f, 
    -0.02785788f, -0.09890926f, 0.03670378f, 0.04047042f, 0.06640474f, 0.03914182f, 0.09786199f, -0.10308298f, 
    -0.04466749f, 0.16739820f, -0.03017650f, -0.14747661f, -0.03989882f, 0.10664210f, 0.05067910f, 0.06987033f, 
    -0.07616731f, 0.05828102f, -0.01515919f, 0.26026264f, -0.10986838f, 0.09849091f, 0.20347354f, -0.00605859f, 
    0.09024096f, 0.01026469f, 0.01096269f, 0.08573896f, -0.11758313f, 0.02523092f, 0.03963025f, 0.05611937f, 
    0.04822696f, -0.09061453f, -0.11616953f, 0.12127943f, -0.07417634f, 0.06253254f, -0.11982168f, -0.15773940f, 
    -0.05051430f, -0.00577183f, -0.01873242f, 0.02319552f, -0.16556484f, -0.08734386f, 0.01632919f, -0.00109654f, 
    -0.07960308f, 0.04031012f, 0.12959918f, 0.00224977f, 0.05186439f, 0.16790041f, -0.14729348f, -0.01372961f, 
    -0.12033180f, -0.02230313f, 0.04375352f, -0.04719201f, 0.18960910f, -0.07341518f, 0.00085748f, 0.05458761f, 
    0.10409195f, 0.13353302f, 0.07504813f, -0.09831782f, -0.00823570f, 0.12457472f, 0.00332952f, 0.09571036f, 
    -0.25057074f, 0.05727217f, -0.00074788f, -0.37184629f, -0.05925186f, 0.00530148f, 0.12161260f, -0.11819498f, 
    -0.09660507f, -0.33880541f, 0.14031851f, -0.05173314f, -0.03291724f, -0.15380606f, 0.04746005f, 0.12226322f, 
    -0.08040529f, 0.02731036f, 0.21455191f, 0.02492446f, 0.01296446f, 0.17846186f, 0.10677036f, -0.05663923f, 
    0.08479281f, 0.06904286f, -0.03652905f, 0.11417750f, 0.06166172f, 0.10180116f, 0.04454483f, 0.10386150f, 
    0.06693625f, 0.01705916f, 0.25694019f, 0.01534856f, 0.00167360f, 0.04575423f, 0.30871883f, 0.03696044f, 
    -0.19813621f, -0.08303858f, -0.18486403f, -0.25728622f, 0.07614326f, -0.05833763f, 0.08729754f, 0.04035665f, 
    0.14176939f, -0.06227230f, 0.05231820f, 0.07163434f, 0.02080381f, -0.01943518f, 0.05391265f, -0.16690487f, 
    -0.03396910f, 0.11378073f, 0.04412553f, 0.15912861f, 0.13532555f, -0.01091025f, -0.04431639f, 0.01984709f, 
    0.26670527f, 0.22595449f, -0.09105181f, 0.10497448f, -0.09540750f, -0.12134766f, -0.09102379f, -0.01389221f, 
    0.09631032f, -0.09472691f, 0.22266032f, -0.02340293f, -0.12870425f, -0.06118601f, -0.17411572f, -0.11092117f, 
    -0.02526081f, -0.14061375f, -0.21344239f, -0.33019808f, -0.01368759f, 0.00976318f, 0.26504290f, 0.04412865f, 
    -0.01020221f, 0.05300202f, -0.04055425f, -0.05037234f, -0.13005872f, -0.07262116f, 0.12563860f, 0.09472939f, 
    0.01013459f, -0.00660314f, -0.04301643f, 0.04866124f, -0.17063333f, -0.00773099f, -0.00203937f, 0.13037252f, 
    -0.05867120f, -0.16804273f, -0.08534614f, -0.08494187f, -0.07228657f, -0.13737449f, 0.09068326f, 0.08349797f, 
    0.16720819f, 0.03114148f, -0.10998230f, -0.19211006f, 0.05751777f, -0.02080519f, 0.02601767f, 0.18033120f, 
    0.21079825f, 0.15627401f, 0.10304669f, 0.00658333f, 0.01394282f, 0.06474984f, 0.09782352f, 0.10231175f, 
    -0.02265262f, -0.32375127f, -0.01229638f, 0.10885546f, 0.08686844f, -0.19259287f, -0.07107782f, -0.01438389f, 
    0.01753989f, -0.00439922f, -0.11267328f, 0.06237924f, 0.05016457f, 0.13543415f, -0.07225482f, -0.01553010f, 
    0.13510181f, -0.08832844f, 0.05135977f, 0.06769239f, -0.03146988f, 0.16809946f, -0.07837599f, 0.05545321f, 
    0.06434035f, -0.02735217f, -0.02025629f, -0.00562157f, -0.04350989f, -0.17913537f, -0.02005360f, -0.10413554f, 
    0.00536849f, -0.11313226f, -0.20229624f, -0.15121590f, 0.03087180f, -0.03445151f, 0.13847888f, 0.19444178f, 
    -0.18827736f, -0.05085923f, -0.00803851f, -0.15183736f, -0.10184041f, -0.06203890f, -0.07850517f, 0.11795627f, 
    0.13210325f, -0.01351227f, -0.16253176f, 0.09799730f, 0.00449762f, -0.04823865f, 0.01658010f, 0.15864243f, 
    0.13844188f, -0.00513911f, 0.10288026f, 0.12131529f, 0.02851916f, 0.06704855f, -0.26660615f, 0.01756357f, 
    -0.06909260f, -0.15039635f, -0.03229785f, -0.16613469f, -0.11710957f, -0.06410235f, -0.00199260f, 0.34845498f, 
    -0.29463944f, 0.05165332f, 0.02649252f, -0.12462774f, -0.07847630f, -0.08945148f, -0.07115824f, -0.16727395f, 
    -0.02025161f, -0.01697175f, -0.04039437f, -0.05638891f, 0.01890124f, -0.02512486f, 0.02615255f, -0.04862754f, 
    0.02336965f, 0.02892352f, 0.01001087f, 0.05267471f, 0.04283747f, 0.05057280f, -0.05564800f, 0.03986202f, 
    0.03512022f, -0.01342333f, 0.04006753f, -0.00881701f, 0.01259525f, -0.05763057f, 0.03069337f, -0.02636239f, 
    -0.00261925f, -0.05776370f, 0.05006203f, 0.01847862f, -0.00623338f, 0.00521922f, 0.04611595f, -0.01736320f, 
    -0.06038845f, -0.04383735f, 0.00905483f, 0.04360908f, 0.01855935f, -0.01033221f, 0.00093359f, 0.03482549f, 
    -0.02055790f, 0.00531226f, -0.03936820f, -0.01741854f, 0.02392288f, -0.01238245f, 0.02370821f, -0.01294924f, 
    -0.02762895f, -0.02552009f, -0.00322834f, -0.02729577f, 0.01978046f, 0.02099322f, -0.02706004f, -0.03020240f, 
    0.03863913f, -0.02560308f, 0.01954715f, -0.03259911f, 0.04403340f, -0.03374729f, -0.04976051f, 0.01331373f, 
    -0.03843314f, 0.05268831f, -0.05500542f, 0.00926978f, 0.02943579f, -0.00783247f, -0.05120900f, 0.04611670f, 
    -0.05469792f, -0.00902362f, -0.02730663f, 0.05479503f, 0.03343076f, -0.05318164f, -0.02176678f, -0.00374030f, 
    -0.01952863f, 0.04732798f, -0.01471055f, -0.02164692f, 0.04089246f, -0.00031777f, -0.06363381f, 0.00070791f, 
    0.00000634f, 0.02317095f, -0.03873773f, -0.03172990f, -0.00223128f, -0.05973496f, -0.03229475f, 0.01679878f, 
    -0.03708918f, 0.01204556f, -0.05818941f, -0.03389768f, -0.01805172f, -0.06158141f, 0.00847143f, -0.01643371f, 
    -0.04203845f, -0.04260529f, -0.00041147f, 0.05837247f, 0.01986014f, 0.00938949f, -0.05562771f, 0.05652928f, 
    -0.03642913f, 0.00713613f, -0.00168680f, 0.00612618f, 0.02996717f, -0.05800793f, -0.05390704f, 0.00364954f, 
    0.00276888f, -0.05110197f, 0.02761003f, -0.02226872f, -0.02808006f, 0.02377489f, 0.01584837f, 0.05673859f, 
    -0.03711311f, 0.02494933f, -0.00443901f, -0.02343459f, 0.00997968f, 0.05562540f, -0.04937454f, 0.04153595f, 
    -0.02000891f, -0.01181369f, 0.02719207f, 0.03846671f, 0.00413424f, 0.02724399f, 0.03306243f, -0.00999893f, 
    -0.06623148f, 0.00638885f, -0.05144755f, -0.03660972f, 0.00984250f, -0.01958456f, -0.03313915f, 0.00314857f, 
    -0.05299327f, -0.04890185f, -0.02649146f, -0.00682918f, -0.04087866f, -0.02621590f, -0.00126190f, -0.00345744f, 
    -0.04418435f, -0.02417805f, -0.02678445f, -0.01867384f, 0.01583499f, 0.02403691f, 0.03904872f, -0.03557318f, 
    -0.02336606f, 0.01767303f, -0.06683476f, -0.01204938f, 0.04410803f, -0.04253288f, -0.04366657f, -0.04645242f, 
    0.03014909f, 0.03587675f, 0.00651146f, -0.02760033f, -0.02658824f, 0.02236993f, -0.04137296f, -0.01118365f, 
    -0.04347518f, -0.02212603f, -0.05553702f, -0.01134677f, 0.00434259f, 0.02683956f, 0.01954220f, 0.03161231f, 
    0.02630331f, 0.01441425f, -0.01805075f, 0.04936723f, 0.00309434f, -0.04341246f, 0.00175601f, -0.03464320f, 
    -0.00193765f, -0.01620661f, -0.00428892f, -0.04228330f, 0.04853636f, -0.03556386f, 0.01766825f, 0.02484360f, 
    -0.04217553f, 0.04234445f, 0.03567401f, 0.04082421f, -0.00792953f, -0.01292757f, -0.05289999f, 0.01733164f, 
    0.01011619f, -0.00748138f, -0.01578456f, 0.01308938f, 0.02989465f, 0.00434277f, 0.05827618f, 0.03892135f, 
    0.01138881f, 0.00152786f, 0.03993331f, 0.01448067f, 0.05818144f, -0.05543273f, -0.06639569f, 0.01719230f, 
    -0.00897295f, 0.04753217f, -0.05912779f, 0.02954426f, -0.05034452f, -0.01097036f, -0.05612467f, 0.01450960f, 
    -0.05688597f, 0.04429481f, -0.04287818f, 0.00364753f, -0.04004119f, -0.02117706f, -0.04624941f, 0.01086610f, 
    0.03437480f, 0.03146445f, 0.01878688f, -0.06573016f, 0.02083055f, -0.03850758f, 0.03314182f, 0.01587574f, 
    -0.03718776f, 0.03799950f, 0.01409846f, -0.02884742f, -0.03223707f, -0.00827146f, -0.03876932f, 0.00662945f, 
    -0.06456081f, 0.05447071f, 0.01053154f, -0.03626712f, -0.05659531f, -0.01896521f, -0.05415640f, 0.00555450f, 
    -0.03607202f, 0.02722019f, -0.03639917f, -0.01547983f, 0.03945300f, -0.02435472f, -0.06919461f, -0.00937126f, 
    -0.05742450f, -0.03739595f, -0.06542637f, 0.00181288f, 0.01709778f, -0.05876123f, -0.03525780f, -0.02113874f, 
    -0.20010862f, 0.31487331f, 0.24746652f, 0.06070574f, -0.10617165f, -0.09866591f, 0.01170192f, -0.07251033f, 
    -0.17457078f, -0.23934551f, 0.11491438f, -0.01337587f, -0.05228341f, -0.11443193f, -0.03298680f, 0.08414873f, 
    -0.04010754f, -0.20052101f, 0.13375971f, 0.05786606f, -0.06916431f, -0.03523420f, -0.13611484f, 0.02121576f, 
    0.17068072f, 0.00073093f, 0.09532394f, 0.04859278f, -0.01941676f, -0.50248176f, 0.08637985f, -0.11218233f, 
    0.09820358f, 0.07030036f, 0.13758332f, -0.07207649f, 0.07730253f, 0.04348460f, 0.14174582f, 0.05832490f, 
    -0.03945416f, -0.02393295f, -0.02867076f, 0.01946169f, 0.02934009f, -0.05453672f, -0.02665245f, 0.06418268f, 
    -0.09167973f, -0.00420629f, -0.06919743f, -0.00678258f, -0.03194575f, -0.00665095f, 0.16147938f, -0.19084853f, 
    0.01942995f, -0.16768311f, 0.19376101f, 0.17611849f, 0.05347219f, 0.04383083f, -0.02824834f, 0.22857386f, 
    0.27264392f, -0.29447782f, -0.12513435f, -0.16165635f, 0.01041579f, 0.02464033f, -0.04556883f, 0.22414169f, 
    0.10187168f, -0.05091761f, 0.13800979f, 0.12108175f, 0.01485777f, 0.18266001f, 0.11434847f, -0.07321762f, 
    0.11113025f, 0.09192930f, 0.08105347f, 0.19884068f, -0.15707310f, 0.01950956f, 0.00592446f, -0.00331168f, 
    -0.05757900f, -0.09154870f, 0.10244931f, 0.10530470f, -0.11983231f, -0.04005585f, -0.02835413f, -0.18711719f, 
    -0.05494244f, -0.27477190f, -0.23083358f, -0.03040988f, -0.13996831f, -0.64534640f, 0.01016750f, -0.10907049f, 
    0.01119150f, -0.02147701f, 0.07980428f, 0.00247905f, -0.08086205f, -0.16238773f, -0.06374601f, -0.14088580f, 
    -0.14743790f, -0.02283743f, 0.09926657f, 0.02498343f, 0.14681725f, 0.05562459f, 0.02463692f, 0.09171396f, 
    -0.03757223f, 0.01240710f, 0.10146910f, 0.00751321f, 0.01713639f, 0.05608004f, 0.04969126f, 0.01941289f, 
    -0.00170124f, -0.08091755f, -0.12240293f, 0.01365653f, -0.00025828f, -0.05187421f, -0.02970467f, 0.32007161f, 
    -0.02086849f, -0.15831541f, -0.04981039f, -0.15213519f, 0.08075808f, 0.08793531f, -0.10645089f, -0.06703187f, 
    -0.09612603f, -0.03667797f, 0.10826057f, 0.10144696f, -0.04851167f, 0.18864943f, 0.00447238f, -0.15701388f, 
    -0.02224611f, 0.14222193f, 0.03197384f, 0.09760486f, 0.00735289f, 0.05747401f, 0.06334952f, -0.06136528f, 
    0.01359038f, 0.09916353f, 0.07248325f, -0.01080830f, 0.16863565f, -0.03554567f, 0.06510226f, -0.08640471f, 
    0.10902599f, -0.10865220f, -0.19140819f, -0.08553882f, -0.05802300f, 0.30933776f, -0.04223442f, -0.10120214f, 
    0.01819208f, 0.05719967f, 0.08587256f, 0.05073018f, 0.03838495f, 0.16213824f, 0.11767515f, 0.08215764f, 
    -0.08311112f, -0.20434837f, -0.15198496f, 0.03105039f, 0.01731910f, -0.09381789f, 0.12193921f, 0.07881667f, 
    0.09248235f, -0.01242540f, 0.01792568f, 0.08761583f, 0.03943112f, -0.03039045f, -0.05698887f, -0.01745570f, 
    0.05208568f, 0.17196658f, -0.05845153f, -0.03988109f, -0.11228015f, 0.20561773f, -0.29779807f, 0.11359768f, 
    -0.03999594f, 0.21611741f, -0.18643525f, 0.05990618f, 0.02186483f, -0.03935810f, -0.14629230f, 0.03084501f, 
    -0.04725736f, -0.00978863f, 0.18347652f, -0.07203061f, -0.27501336f, -0.10610164f, 0.05905443f, 0.02589441f, 
    0.11869933f, -0.10838176f, -0.22159776f, -0.19514793f, -0.09374814f, -0.03221456f, 0.01453758f, 0.14578789f, 
    -0.09255472f, -0.00832379f, 0.13629401f, 0.11871019f, 0.16298525f, 0.10531498f, 0.07661847f, 0.01415850f, 
    0.08409736f, -0.01532186f, 0.04873851f, -0.01019180f, 0.00395816f, 0.00434813f, 0.03770116f, -0.05383527f, 
    -0.17622724f, -0.03129614f, -0.20605767f, 0.01871372f, 0.05215022f, 0.03588566f, 0.02135489f, 0.04261597f, 
    0.00732673f, 0.17601520f, 0.25594759f, -0.03028188f, 0.12800597f, 0.13036078f, -0.22799447f, -0.38275820f, 
    -0.13261519f, -0.09564301f, 0.05078392f, 0.14487068f, 0.11644752f, 0.02975024f, 0.10476684f, -0.04061891f, 
    0.14378056f, -0.01102696f, -0.03849594f, 0.05329246f, -0.07712346f, -0.00092142f, 0.03008832f, 0.19370772f, 
    -0.02316408f, -0.03736365f, 0.09923858f, -0.14272079f, -0.05307900f, 0.19107172f, 0.13079385f, -0.19042060f, 
    0.01721517f, 0.04579609f, -0.01092047f, -0.03441361f, 0.02310604f, 0.00990081f, -0.04006847f, 0.00932421f, 
    0.03977953f, -0.04981131f, -0.05785342f, -0.05281373f, -0.02964183f, -0.03271560f, 0.05130717f, 0.01853088f, 
    -0.02925777f, 0.03190447f, 0.00127900f, -0.05031357f, -0.00887280f, 0.04587551f, 0.03600418f, -0.01112823f, 
    0.02344870f, 0.04247863f, 0.01117938f, -0.02932274f, 0.04647795f, -0.00061771f, 0.00237443f, 0.00766983f, 
    -0.00728122f, -0.02268565f, 0.04740100f, -0.03507544f, -0.05570567f, 0.01843034f, -0.05921917f, 0.05734328f, 
    -0.03381963f, -0.03956213f, -0.04110137f, -0.03766797f, -0.00828648f, 0.04074358f, 0.00374631f, 0.03797104f, 
    -0.01305160f, 0.00366403f, -0.04012829f, -0.02490804f, 0.04246432f, -0.04973249f, -0.04660812f, -0.04003578f, 
    -0.03012798f, -0.06192987f, 0.03787773f, 0.05337972f, -0.02745531f, -0.04125310f, -0.01288242f, 0.04348851f, 
    0.02397405f, 0.03802798f, -0.03686685f, -0.03764029f, 0.03783558f, -0.00806505f, -0.04119540f, 0.02618973f, 
    0.04322352f, 0.04232617f, 0.02972910f, -0.04638533f, 0.00381657f, -0.01407786f, -0.02636031f, -0.04506873f, 
    0.04844774f, 0.03116971f, 0.04807460f, -0.01888453f, 0.04280509f, -0.01365570f, -0.02087087f, 0.00085493f, 
    -0.05114041f, -0.02913815f, -0.00737390f, -0.05566347f, -0.06295501f, 0.01953382f, -0.01407227f, 0.03319575f, 
    0.01721074f, 0.00601770f, -0.03899951f, -0.03705315f, 0.02619205f, -0.05573797f, 0.00085117f, -0.05175007f, 
    0.04075795f, 0.00937172f, 0.00587421f, -0.06381752f, -0.03128602f, 0.04037217f, -0.06248977f, -0.03136436f, 
    -0.01557641f, -0.05207006f, 0.02261449f, 0.01321579f, -0.01643935f, 0.02431367f, -0.00900879f, -0.01296437f, 
    0.02384318f, 0.04554938f, -0.00625559f, -0.00263368f, 0.03871408f, 0.00763508f, -0.01508225f, -0.02905485f, 
    0.00090410f, -0.05753519f, 0.03912396f, 0.02498000f, 0.01420875f, -0.04740559f, 0.01788240f, 0.04187410f, 
    0.01661363f, -0.05528612f, 0.04911185f, -0.04034574f, 0.03920651f, -0.04138671f, -0.04010528f, -0.00311208f, 
    0.02581011f, 0.04182439f, -0.02641693f, -0.06213670f, -0.02062862f, -0.04711115f, -0.01241801f, 0.02830764f, 
    -0.03624153f, -0.02646414f, -0.04799836f, -0.01911763f, -0.03285412f, 0.00144890f, 0.01091219f, 0.03861995f, 
    -0.04297385f, -0.05550989f, -0.01604861f, -0.01669724f, -0.04736380f, 0.01041951f, -0.05288569f, 0.03993561f, 
    0.05824849f, -0.01558908f, -0.05213048f, -0.02588181f, 0.01808807f, -0.05356120f, -0.00765013f, -0.01315743f, 
    0.04619957f, -0.00172542f, -0.04699370f, 0.00483457f, -0.04888553f, -0.03727441f, 0.03234218f, -0.02074480f, 
    0.04626700f, -0.03018318f, -0.02408479f, -0.05706604f, -0.00445297f, 0.02421752f, 0.02562695f, -0.05876657f, 
    0.04410990f, 0.02181782f, 0.02035554f, -0.04704851f, 0.01625242f, -0.03896494f, 0.00534012f, 0.04663863f, 
    -0.03037830f, 0.00577950f, 0.04187977f, 0.02393491f, -0.03229971f, 0.03869830f, 0.00090853f, 0.01139397f, 
    0.00313611f, 0.04650082f, -0.01177872f, -0.03106003f, -0.06056424f, -0.05669112f, 0.04409655f, 0.01546365f, 
    0.01065202f, -0.02602618f, -0.02309307f, 0.02025311f, 0.00689312f, -0.04575799f, -0.02765135f, -0.00163762f, 
    -0.02070472f, 0.04238277f, 0.03768674f, -0.01063769f, -0.01371696f, -0.03121311f, -0.01984761f, 0.00225420f, 
    -0.05593834f, -0.03626862f, -0.03000278f, -0.03201945f, 0.02111089f, 0.01452154f, -0.06137979f, -0.02575446f, 
    -0.03047180f, -0.05233848f, 0.00769637f, 0.02674426f, -0.01801453f, 0.00436178f, 0.04858204f, -0.02644908f, 
    -0.00500611f, -0.01910228f, 0.02625472f, 0.05657094f, 0.02929955f, -0.03735697f, -0.06008717f, 0.03432442f, 
    0.02455466f, 0.03419986f, -0.06117902f, -0.02545452f, 0.04291888f, 0.01807649f, -0.06304865f, -0.06683331f, 
    -0.04391047f, 0.03825955f, 0.01826030f, 0.03904939f, -0.00213534f, -0.00462527f, 0.00192567f, -0.02285283f, 
    0.04313029f, -0.02295326f, -0.03552738f, 0.05579577f, -0.01774661f, -0.01712922f, 0.00093912f, -0.03043059f, 
    0.05364953f, -0.01698388f, -0.03797572f, 0.03757049f, -0.00845513f, -0.06545842f, 0.01205676f, 0.03447541f, 
    -0.21095683f, -0.57101816f, -0.12423898f, -0.15928885f, -0.06255694f, -0.06212908f, -0.07911012f, -0.21048369f, 
    -0.00100644f, 0.33263004f, -0.08288183f, -0.13436227f, -0.04948359f, 0.07885787f, 0.00672014f, -0.05533149f, 
    -0.00254395f, 0.03392547f, -0.27336687f, -0.18858863f, -0.09576468f, -0.04201191f, 0.01850117f, -0.11722761f, 
    0.07560318f, 0.06469475f, 0.03780739f, 0.04313447f, -0.34716827f, 0.06797745f, 0.08595300f, 0.02695750f, 
    -0.12063242f, 0.06405869f, -0.02776071f, -0.03496647f, 0.21547605f, 0.14402153f, 0.02121557f, -0.08486162f, 
    0.12697552f, 0.00270954f, 0.06504279f, 0.13024667f, -0.13536476f, -0.30984423f, -0.51329577f, -0.11215980f, 
    -0.03620677f, -0.02782094f, 0.04840526f, -0.05011249f, -0.12450919f, -0.09348502f, -0.15545082f, 0.15012805f, 
    -0.11769313f, -0.03348048f, 0.00717488f, 0.09360812f, 0.17523459f, -0.03445474f, -0.12795056f, -0.24949308f, 
    0.06260376f, -0.25619757f, 0.05403676f, -0.03196483f, 0.11081551f, 0.02608615f, -0.04013132f, 0.00271896f, 
    0.03803456f, 0.19380891f, 0.07854538f, 0.03970246f, -0.00681004f, 0.04352921f, 0.09112164f, 0.09832609f, 
    0.21080101f, 0.11768049f, -0.12961072f, -0.14079675f, -0.09490506f, 0.02910415f, -0.06053112f, -0.08121940f, 
    -0.05700337f, 0.00761993f, -0.48184639f, -0.12010840f, -0.28692159f, -0.05126821f, 0.13402344f, 0.04876446f, 
    0.04515750f, -0.04956210f, -0.01120888f, 0.05111485f, 0.02991765f, -0.01826837f, 0.04542260f, -0.10413729f, 
    0.14702068f, 0.06705675f, -0.01523508f, 0.00067116f, -0.00792064f, -0.06429622f, 0.18051142f, 0.15482131f, 
    0.06890417f, -0.24202235f, 0.17467241f, 0.17187524f, -0.07712656f, 0.21078463f, 0.08326067f, 0.11202119f, 
    -0.13474022f, -0.06733058f, -0.08594584f, 0.06740349f, 0.06927183f, -0.01446548f, -0.25695631f, -0.23363087f, 
    -0.31983694f, 0.00135226f, 0.08271658f, 0.14869742f, 0.08681564f, -0.09018288f, -0.09296723f, -0.39487353f, 
    -0.17460085f, -0.26807600f, -0.16291292f, 0.29277042f, -0.03592350f, 0.06044967f, 0.07817440f, -0.10176778f, 
    0.37275878f, 0.14146847f, 0.19649962f, -0.04896499f, -0.10889728f, -0.11117810f, 0.04486714f, 0.03222545f, 
    0.19673243f, 0.14596413f, 0.13246171f, 0.20461994f, -0.10262461f, -0.05545752f, -0.11540523f, 0.02861733f, 
    0.08422038f, 0.16799636f, -0.07955357f, -0.34813073f, -0.00085041f, 0.04140494f, 0.09151736f, -0.06248226f, 
    -0.26130331f, -0.11383402f, -0.01425934f, 0.07943576f, -0.09329460f, -0.02141990f, -0.22703104f, -0.14399512f, 
    -0.12170321f, -0.07885258f, -0.02383661f, -0.04491711f, 0.07426028f, 0.05978812f, 0.06793884f, -0.10449029f, 
    0.08463528f, -0.19859268f, 0.04649750f, 0.08337057f, 0.09611530f, 0.07581482f, -0.02124672f, 0.05025771f, 
    -0.02157584f, 0.05203716f, 0.05891911f, 0.06375812f, 0.20430934f, -0.04837963f, -0.03425434f, 0.10320181f, 
    -0.08717286f, -0.10218418f, -0.12668446f, -0.12331899f, -0.01606799f, 0.15178713f, 0.21590281f, 0.13828109f, 
    -0.06518129f, -0.07986706f, -0.02317342f, 0.06552529f, 0.03361505f, -0.03738612f, -0.08433934f, -0.05155559f, 
    -0.23502037f, -0.17077015f, 0.31471714f, -0.12280226f, -0.03043336f, -0.09015958f, 0.02764778f, 0.17000565f, 
    0.01802184f, 0.12283634f, 0.19043155f, -0.02374817f, -0.00431565f, 0.10087372f, -0.02333308f, -0.03443909f, 
    0.04479398f, 0.06040937f, 0.18391891f, 0.10527377f, 0.17504190f, 0.02651541f, 0.00554837f, -0.01028110f, 
    0.00112147f, 0.08792922f, 0.05703424f, 0.10903969f, 0.06456161f, -0.13026197f, -0.19892366f, -0.01377361f, 
    -0.28621757f, -0.09665024f, -0.09458406f, -0.09601420f, -0.34868523f, 0.05203191f, -0.02828110f, -0.01278518f, 
    -0.00585542f, -0.09885250f, 0.08875487f, 0.20987149f, 0.02933064f, 0.16486619f, 0.07475097f, -0.15270853f, 
    0.02707035f, -0.00734813f, -0.01517581f, 0.01806339f, -0.02790505f, 0.00992707f, 0.13684279f, 0.00751134f, 
    -0.04208560f, -0.13196439f, 0.05251292f, 0.04157179f, 0.01911356f, -0.05912781f, -0.08362447f, 0.03665745f, 
    -0.10522740f, 0.03611080f, 0.10805798f, 0.20795543f, -0.04220486f, 0.03361746f, -0.02010481f, 0.02693862f, 
    -0.23211370f, 0.22435951f, 0.21671727f, -0.20721333f, 0.03452470f, 0.03568444f, -0.00256263f, 0.02010399f, 
    0.05774976f, 0.36896330f, 0.12832975f, -0.41631445f, 0.13799711f, 0.14109993f, -0.05409818f, 0.07487136f, 
    -0.06314979f, -0.05102044f, -0.43680525f, -0.35689592f, -0.20028597f, -0.00499182f, 0.03298453f, -0.07431809f, 
    -0.05934038f, -0.04501986f, 0.03264055f, 0.02813248f, -0.17899852f, -0.20149748f, 0.13681601f, 0.14894815f, 
    -0.02405621f, 0.12282881f, -0.12344676f, 0.07039610f, 0.09762932f, 0.01791932f, -0.13125749f, -0.12801373f, 
    -0.04291684f, 0.02734050f, 0.02067559f, 0.01392954f, 0.16524905f, 0.22746955f, 0.42362654f, 0.19424859f, 
    -0.08244172f, 0.07972211f, 0.19644982f, 0.20081817f, 0.05672330f, 0.19404404f, -0.15053318f, 0.17606768f, 
    0.24743386f, -0.03195175f, -0.06742548f, 0.03167945f, 0.16391397f, 0.10616288f, -0.07211258f, -0.33377904f, 
    0.18235756f, -0.32091576f, 0.07001945f, -0.07020483f, -0.02753165f, 0.01885571f, -0.08760396f, -0.10346144f, 
    0.14047515f, 0.14427628f, -0.04671502f, -0.05652962f, 0.04995613f, -0.00230501f, 0.03232881f, 0.08654276f, 
    -0.07458187f, 0.11118492f, 0.22749266f, -0.06367750f, -0.18768716f, -0.07230459f, 0.13164546f, 0.08957414f, 
    0.15433067f, 0.18038173f, -0.37510660f, -0.09585513f, 0.02770586f, -0.08875541f, -0.14925878f, 0.11988554f, 
    -0.03468302f, 0.06765810f, 0.00311070f, -0.07466515f, -0.13798060f, -0.08849766f, -0.00787476f, -0.04853585f, 
    -0.07660726f, 0.18038677f, 0.00047026f, -0.06547696f, -0.29795864f, -0.74473095f, -0.49821144f, -0.05555185f, 
    -0.09359005f, -0.12954350f, 0.09582293f, -0.02505195f, 0.12180990f, -0.00670389f, 0.03237947f, -0.10196949f, 
    -0.12794864f, -0.15082261f, -0.11605518f, -0.11481453f, -0.17463781f, 0.01434018f, -0.09554238f, -0.23795870f, 
    -0.09283455f, 0.07994200f, -0.06701036f, -0.12449954f, 0.01284730f, 0.10657176f, -0.06736083f, 0.18166707f, 
    0.32662439f, 0.05449828f, -0.18582870f, 0.23396772f, -0.10086901f, -0.06178883f, 0.18088493f, -0.01520196f, 
    -0.36286548f, -0.12095173f, -0.00198623f, 0.10546057f, -0.05874138f, -0.08008929f, 0.04612835f, 0.04870398f, 
    0.00337301f, 0.05014326f, 0.08323162f, -0.13710824f, 0.03245491f, 0.04290441f, 0.04146152f, -0.11603091f, 
    -0.14790490f, 0.02787138f, -0.08228789f, 0.14058627f, -0.04486367f, -0.02531329f, 0.00833908f, 0.31030542f, 
    -0.05945094f, -0.06196401f, -0.06844003f, -0.30125877f, -0.35351822f, -0.16393933f, -0.10586848f, -0.02042175f, 
    -0.14094992f, 0.07222957f, -0.09391540f, 0.09284015f, -0.07157879f, 0.01092897f, -0.16750595f, -0.05528336f, 
    0.10545244f, -0.18226050f, 0.08732928f, 0.02571879f, 0.06984453f, -0.02208711f, -0.04106101f, -0.09221456f, 
    0.07239466f, -0.05290394f, 0.10288711f, 0.16439678f, -0.01333917f, 0.01338269f, 0.12694047f, 0.20766212f, 
    -0.07232392f, 0.24860626f, -0.16370834f, 0.08861665f, 0.03178234f, 0.08756269f, -0.04431311f, 0.11179886f, 
    0.07747411f, -0.05598364f, -0.07938162f, -0.11269291f, 0.02976998f, 0.10381641f, 0.01918823f, 0.14892489f, 
    -0.29200414f, -0.17034210f, 0.15782639f, -0.06005416f, 0.00749607f, -0.17544690f, 0.12045664f, -0.12084088f, 
    0.10398965f, -0.03891604f, -0.31010205f, 0.01417092f, 0.01246841f, -0.08079729f, -0.06725476f, 0.18228742f, 
    -0.11446054f, 0.02889412f, 0.07048402f, 0.08026386f, -0.04937143f, 0.04342244f, -0.03075557f, -0.01346717f, 
    -0.24807827f, -0.00600288f, 0.06450137f, 0.16962563f, 0.15677007f, 0.00727746f, -0.17474194f, 0.07329642f, 
    0.11655685f, 0.13585491f, -0.05616376f, 0.19046186f, -0.26758713f, -0.20254384f, 0.06136897f, -0.00131768f, 
    -0.01439719f, -0.09562395f, 0.00617161f, -0.08011873f, 0.00518353f, -0.11792519f, 0.14256229f, 0.16536684f, 
    0.11548291f, -0.02879229f, 0.09785981f, 0.02826928f, 0.05677437f, 0.03576079f, -0.01422914f, -0.00258444f, 
    -0.13691449f, -0.19798422f, -0.09717535f, -0.03675817f, 0.14437638f, 0.10667443f, 0.14917827f, 0.32168028f, 
    -0.44483006f, -0.31862521f, -0.10421585f, 0.16815349f, 0.07129537f, 0.00543464f, -0.12086414f, 0.06091925f, 
    0.29357550f, -0.05912461f, -0.19325100f, -0.03336012f, -0.01081252f, -0.15796322f, 0.01165053f, 0.04550962f, 
    -0.02519988f, -0.22929266f, -0.23992887f, 0.10317804f, 0.03026173f, 0.04848851f, 0.12386826f, -0.13335174f, 
    0.06452481f, 0.04068007f, -0.02372443f, -0.24912395f, -0.07416210f, 0.01403266f, -0.00264724f, 0.06019896f, 
    -0.01585004f, 0.13069877f, 0.13365996f, 0.17026138f, 0.16505396f, -0.07678989f, -0.03475010f, 0.08082068f, 
    0.11578070f, -0.07151897f, 0.01909107f, -0.12707503f, -0.28120145f, -0.02306379f, -0.08229585f, -0.10538103f, 
    0.01581096f, 0.16037378f, -0.04842442f, 0.01339282f, 0.13186736f, -0.00890549f, 0.19231236f, -0.01912376f, 
    0.09921073f, -0.11597247f, 0.04967914f, 0.07198108f, 0.02974878f, 0.06939883f, -0.00917715f, 0.27797207f, 
    0.29417345f, -0.05674971f, -0.03193534f, 0.05274825f, 0.11581851f, 0.02054733f, 0.18521295f, 0.17270604f, 
    -0.23158433f, -0.05893712f, -0.04818253f, 0.18787791f, -0.14331239f, 0.05018883f, 0.06521361f, -0.04566138f, 
    -0.13946220f, -0.06324796f, 0.04621392f, 0.04362679f, 0.04010407f, -0.09931871f, -0.08232642f, -0.22474028f, 
    -0.17552224f, -0.05315179f, -0.02809570f, -0.01867969f, 0.04893531f, 0.15701361f, 0.06865091f, 0.00999896f, 
    0.09919506f, 0.01289909f, 0.12527446f, 0.34771436f, 0.14235500f, -0.09276414f, -0.00517429f, -0.02814047f, 
    -0.07871390f, -0.13766751f, -0.00534412f, 0.04033280f, -0.17694037f, -0.13964733f, 0.04726535f, 0.02650383f, 
    -0.00894737f, -0.01873714f, 0.00394947f, -0.27385777f, -0.06547592f, 0.38317183f, 0.15780245f, 0.06093673f, 
    0.09754454f, -0.06649268f, 0.16871078f, -0.05512078f, 0.15982202f, -0.37824249f, -0.09725834f, 0.00476243f, 
    -0.15881120f, 0.09479590f, -0.14056636f, -0.08125372f, -0.02218401f, 0.02308641f, 0.03113930f, 0.06816746f, 
    0.13768977f, -0.10960374f, 0.04791966f, -0.07981279f, 0.00503758f, 0.04956672f, -0.10050134f, 0.24814992f, 
    -0.01205650f, -0.13994379f, -0.04681152f, -0.05936854f, -0.02170994f, -0.04723680f, 0.07797304f, 0.05586364f, 
    -0.39930606f, 0.06981919f, 0.20475924f, -0.13431476f, 0.14803009f, 0.02209702f, -0.00509456f, 0.01768850f, 
    0.06563014f, -0.25341445f, -0.08049942f, -0.03963764f, 0.08959267f, 0.02225547f, -0.01935645f, -0.03103357f, 
    -0.14724101f, -0.22260597f, -0.02240173f, 0.10604025f, 0.08309170f, 0.10618982f, 0.06495484f, -0.17296247f, 
    -0.09360834f, -0.22044234f, 0.07241551f, 0.28474969f, -0.06342689f, -0.08986013f, -0.01869107f, 0.15051511f, 
    0.11436351f, 0.08846679f, -0.02903112f, -0.14743555f, -0.08391464f, 0.13455740f, 0.22403209f, 0.01136379f, 
    0.06029702f, 0.15256533f, -0.03150204f, 0.15180774f, 0.09839977f, -0.27953255f, -0.02082828f, 0.18761615f, 
    -0.00918774f, 0.12239267f, 0.09691148f, -0.06211958f, 0.00941249f, 0.15652788f, -0.05920118f, 0.22648163f, 
    0.16035146f, -0.02725322f, -0.06626259f, -0.00424714f, -0.03868010f, -0.00734387f, 0.08409777f, 0.04593605f, 
    0.02954762f, 0.06256244f, 0.07615808f, 0.28231761f, -0.10306612f, -0.10870376f, 0.08388709f, -0.05182596f, 
    0.29627681f, 0.18204132f, -0.09068555f, 0.11304133f, -0.09137897f, 0.05063784f, 0.00486099f, 0.05822122f, 
    0.02684117f, -0.00165721f, -0.00262124f, 0.01374598f, -0.07007007f, 0.07458934f, 0.03872202f, 0.00811424f, 
    -0.06442265f, 0.07132110f, -0.09907442f, 0.02956753f, 0.04297728f, 0.02025691f, 0.02787982f, 0.01388610f, 
    -0.00066947f, 0.01738658f, -0.21323127f, -0.09981307f, 0.23679735f, 0.02488361f, 0.12764961f, 0.03565113f, 
    -0.08543366f, 0.00017238f, -0.08210563f, 0.14141129f, -0.18009634f, -0.14173004f, 0.00459363f, 0.09382213f, 
    0.13152012f, 0.08668589f, 0.07017910f, 0.02848316f, 0.15534742f, 0.05176434f, 0.05482760f, 0.23833033f, 
    -0.00445530f, 0.13253883f, -0.07795958f, 0.02715921f, -0.02161018f, 0.00826827f, -0.13058518f, -0.01297227f, 
    -0.13075922f, -0.23042642f, -0.09670275f, -0.12233871f, -0.07855508f, 0.00462204f, -0.02086610f, 0.13636723f, 
    0.31437287f, -0.15623774f, 0.02438973f, 0.13126986f, 0.05804619f, -0.01093128f, 0.21913791f, 0.08310279f, 
    -0.04141409f, 0.02577670f, -0.06361721f, 0.01251244f, -0.04647081f, 0.03180592f, -0.04041360f, -0.01402575f, 
    -0.02484937f, 0.02373357f, -0.01089078f, 0.00771627f, -0.01999237f, 0.01524246f, -0.01152879f, 0.03149762f, 
    0.02537010f, -0.01288915f, 0.00522930f, -0.05588732f, 0.00240470f, -0.02339828f, -0.06330052f, 0.01761156f, 
    -0.04708608f, 0.01288784f, -0.05992509f, -0.01422323f, 0.03461516f, -0.01597757f, 0.01841772f, 0.01058395f, 
    -0.02391315f, 0.02897293f, -0.00464741f, 0.04193985f, 0.03204788f, -0.05095214f, 0.00096033f, -0.00601995f, 
    -0.01784533f, 0.04258091f, 0.04053717f, 0.01097557f, 0.02075296f, -0.00387312f, 0.02337676f, 0.02083682f, 
    -0.04372368f, -0.03175079f, -0.06270570f, -0.00465700f, -0.00128367f, -0.04909041f, -0.00603901f, -0.04330983f, 
    -0.00279967f, -0.04579903f, -0.04910975f, -0.02432064f, -0.04018530f, -0.04772355f, 0.01585209f, -0.04050292f, 
    -0.00826345f, -0.00077985f, -0.04258668f, -0.03013955f, 0.02050242f, 0.02340555f, -0.06579097f, -0.04779189f, 
    0.03404029f, 0.03011773f, -0.00378710f, -0.04486299f, -0.05108538f, -0.03219774f, -0.03613926f, 0.02825038f, 
    -0.04656180f, -0.00466650f, 0.03727943f, 0.04535316f, -0.01692431f, -0.04929498f, 0.04168348f, -0.04301127f, 
    -0.01318932f, -0.03507112f, 0.02157920f, -0.00414789f, 0.02451502f, 0.04556490f, -0.02816674f, -0.04988455f, 
    -0.05070536f, 0.03383401f, 0.04307809f, -0.01263078f, -0.03893325f, 0.01961362f, 0.04597376f, 0.02852599f, 
    0.02103690f, -0.02910803f, 0.02155888f, -0.00777292f, -0.06517158f, -0.05736040f, -0.05737324f, 0.04941690f, 
    -0.05347227f, -0.03667605f, -0.03552924f, -0.05532445f, 0.04074269f, 0.04354083f, -0.04462541f, 0.01312163f, 
    -0.04672444f, -0.01300949f, 0.01114671f, -0.01996957f, -0.04917327f, -0.02351071f, -0.04790268f, 0.00194794f, 
    -0.06336990f, 0.04598446f, -0.02582857f, -0.03282978f, 0.00544387f, -0.01458051f, 0.00355633f, -0.03363941f, 
    -0.06151472f, -0.00866812f, -0.05274678f, 0.04495632f, 0.00140662f, -0.03481626f, 0.04496261f, 0.04210492f, 
    0.00411630f, -0.02672542f, 0.04222492f, 0.02027893f, -0.05264970f, -0.05512804f, 0.01098091f, -0.05341567f, 
    0.00287101f, 0.00654746f, 0.04936796f, -0.04282309f, 0.03802061f, 0.01428208f, 0.01130335f, -0.04468559f, 
    0.04883435f, -0.03195106f, 0.04101440f, 0.03232370f, -0.03802500f, -0.05101129f, -0.04855724f, 0.04469773f, 
    -0.06454269f, -0.02627167f, 0.00862022f, -0.04184509f, -0.02176690f, 0.01159331f, -0.05601289f, -0.02635563f, 
    0.01006376f, 0.03828517f, 0.00022826f, -0.01045627f, -0.00504121f, 0.00159348f, -0.00116824f, -0.01093001f, 
    -0.01482330f, 0.02500129f, -0.00520599f, -0.06993960f, -0.01530596f, 0.01166474f, -0.04485919f, 0.04110973f, 
    -0.00472170f, 0.01310952f, -0.05900886f, -0.04657245f, 0.03871125f, 0.00411915f, 0.01025350f, -0.06652541f, 
    -0.00639153f, 0.04849246f, 0.02455078f, -0.06282122f, 0.02649472f, -0.05164739f, 0.04628813f, 0.02683913f, 
    0.04075928f, 0.00681368f, 0.02619988f, 0.00938874f, -0.03711707f, -0.00005947f, 0.01472830f, 0.03097884f, 
    0.04716796f, -0.02302353f, -0.02223612f, -0.05231582f, 0.00140452f, 0.03054527f, -0.01287426f, -0.03899586f, 
    -0.01824790f, -0.03375672f, -0.02291582f, -0.04229635f, -0.05983740f, 0.01718086f, -0.02939869f, -0.00926644f, 
    -0.05389891f, 0.02787638f, -0.00206371f, -0.04303524f, 0.00185700f, -0.02366782f, 0.01327049f, -0.01466382f, 
    -0.01654004f, 0.04564622f, 0.03116090f, 0.04036690f, -0.04440778f, -0.05354540f, 0.02882552f, 0.04885466f, 
    -0.05190475f, 0.01518097f, 0.01924185f, -0.00594986f, 0.03434844f, -0.00151492f, -0.00906187f, -0.05038971f, 
    0.01318514f, -0.05337105f, -0.01078984f, -0.03186963f, 0.00870930f, 0.01269763f, 0.04420533f, -0.04474770f, 
    -0.00725229f, -0.01031626f, -0.06860865f, 0.01017784f, -0.02085476f, 0.03824542f, -0.05392862f, 0.04756479f, 
    -0.02672320f, -0.03918887f, -0.01058294f, 0.02471921f, -0.04260129f, 0.04937319f, -0.03318585f, -0.05530374f, 
    -0.00063180f, -0.05299812f, 0.02371113f, -0.01956052f, -0.03533112f, 0.01814693f, 0.00702534f, -0.03924287f, 
    0.16598777f, -0.01347480f, 0.05325324f, -0.00438271f, 0.01666027f, -0.00143242f, 0.02144439f, -0.03825832f, 
    -0.00139516f, -0.31890765f, -0.22715758f, -0.33737090f, 0.16296400f, -0.05470752f, -0.10415098f, 0.07212616f, 
    0.03483897f, 0.04885973f, 0.20597951f, 0.19607010f, 0.21649113f, -0.10464160f, -0.09249954f, 0.05828859f, 
    0.12146231f, 0.09389158f, -0.03269568f, -0.13335790f, -0.02202301f, -0.21300595f, 0.00878389f, -0.03748808f, 
    0.25112274f, 0.05344778f, 0.00639930f, 0.02844444f, -0.20156458f, -0.03464760f, -0.18764696f, 0.03853528f, 
    -0.10192905f, -0.01466849f, 0.13726412f, 0.08596323f, -0.00694663f, 0.17244935f, 0.10541369f, 0.15168905f, 
    0.04447033f, -0.13039598f, 0.08518213f, 0.02652185f, 0.03233753f, -0.17154466f, -0.20176370f, 0.37213492f, 
    0.35283846f, -0.02113558f, -0.14989781f, -0.22275980f, 0.06006813f, 0.13966478f, 0.18035930f, 0.02732714f, 
    0.16897473f, 0.18846640f, -0.00811349f, -0.03981088f, -0.10652868f, 0.06333593f, 0.02688621f, -0.08951575f, 
    -0.17265519f, -0.24063756f, 0.08621030f, -0.07288922f, -0.14729384f, -0.15272859f, 0.06716961f, -0.02076644f, 
    0.02180427f, 0.04317810f, 0.21809122f, -0.04350154f, -0.11750634f, 0.12181200f, -0.09762879f, 0.08580769f, 
    -0.16131195f, 0.11491537f, -0.06202403f, 0.15985453f, 0.19435927f, -0.08772508f, -0.18432283f, -0.11032948f, 
    0.01338499f, 0.01748037f, 0.07862083f, 0.20356537f, 0.13106608f, 0.10539930f, 0.11308104f, -0.16671315f, 
    -0.02579921f, 0.13489190f, -0.11991809f, 0.03455415f, -0.33739296f, 0.16892491f, -0.13412292f, 0.13345052f, 
    -0.00632151f, -0.09877678f, 0.01868244f, -0.07075653f, 0.17960884f, -0.13915117f, -0.12527522f, -0.04395410f, 
    0.03559121f, -0.00243302f, -0.02038061f, 0.17214900f, 0.03065879f, -0.01999487f, 0.08048639f, -0.02455789f, 
    -0.09512095f, 0.08733570f, -0.06809848f, 0.05279531f, -0.01074619f, -0.14000075f, 0.14977628f, -0.17270322f, 
    0.28184474f, 0.13766631f, -0.00100891f, -0.23393790f, -0.02353454f, 0.02290053f, -0.02483702f, -0.00850360f, 
    -0.16803189f, -0.09542993f, 0.17933424f, 0.05047158f, -0.00296666f, -0.06839602f, 0.04811465f, 0.00721977f, 
    -0.04254383f, -0.08983637f, 0.01484420f, 0.02028031f, 0.00465461f, -0.13146301f, -0.05084180f, 0.11870515f, 
    -0.00936556f, 0.13898727f, -0.13122217f, 0.22236155f, 0.08688525f, 0.13642201f, -0.01638517f, 0.00901839f, 
    0.08869482f, -0.08364587f, 0.19717181f, 0.17579125f, 0.31655777f, 0.17283818f, -0.07845018f, 0.04754001f, 
    -0.09561452f, 0.14737046f, 0.03645250f, -0.01479635f, -0.15020469f, 0.34302872f, -0.09785035f, -0.09592451f, 
    -0.00928428f, -0.15288208f, 0.10117542f, 0.11599847f, -0.23382761f, -0.27939680f, -0.08058312f, 0.00505656f, 
    0.08010260f, 0.20721132f, 0.13626418f, -0.01041666f, 0.09118469f, 0.11646918f, -0.25474191f, 0.28295803f, 
    0.11065103f, -0.14958225f, -0.00944513f, -0.00734272f, -0.08534275f, 0.01853954f, 0.09041286f, 0.03511006f, 
    0.18117519f, -0.17727630f, -0.18941677f, 0.01877440f, -0.05451927f, 0.06724817f, -0.02002198f, -0.01855258f, 
    0.27032217f, 0.33080354f, 0.52132446f, -0.05563834f, 0.03551545f, -0.28064093f, 0.10086116f, 0.19588959f, 
    0.06035188f, -0.24836296f, 0.10503843f, 0.05968302f, 0.04432184f, -0.14183743f, 0.10480362f, -0.05798946f, 
    0.02059968f, -0.15653354f, -0.30446258f, -0.11968797f, -0.11817469f, -0.08733819f, -0.01364394f, 0.00661747f, 
    -0.04261665f, -0.14262034f, 0.04369574f, -0.10895089f, 0.48142362f, -0.17129466f, -0.04397487f, 0.27461138f, 
    0.14269100f, -0.09931515f, 0.19141054f, -0.09697831f, 0.01893706f, 0.06913033f, 0.13611321f, 0.07686231f, 
    -0.05191171f, 0.05815695f, 0.08437134f, 0.09218299f, -0.05236302f, -0.09512970f, 0.15227023f, -0.01947075f, 
    0.09712453f, 0.13182460f, -0.18378724f, -0.11414635f, 0.15003014f, 0.00839944f, 0.08280536f, -0.01808373f, 
    0.00031511f, -0.00515611f, -0.14091557f, 0.05823120f, 0.10206132f, -0.01580766f, 0.07224443f, -0.41137883f, 
    0.04857681f, -0.57822192f, -0.05412710f, -0.12094766f, 0.25663039f, 0.03685759f, 0.07226080f, -0.18320239f, 
    -0.01404799f, 0.07535431f, 0.24471591f, -0.27016279f, -0.01403167f, -0.10569962f, -0.23342034f, 0.01062056f, 
    -0.02548102f, 0.02711153f, 0.25457910f, 0.03339100f, 0.07714903f, -0.05119582f, -0.03624922f, -0.09403712f, 
    -0.05465289f, 0.06878019f, -0.46844047f, -0.45800003f, -0.26546368f, 0.08616883f, 0.09411646f, -0.06019770f, 
    0.11305863f, 0.04764062f, -0.01156107f, 0.24325517f, 0.04698206f, -0.18175752f, 0.00234876f, -0.00549165f, 
    0.14718536f, 0.03510216f, 0.05330205f, 0.09310590f, -0.05359316f, 0.15210918f, 0.02100271f, 0.03736084f, 
    -0.01796933f, 0.01857440f, 0.00811392f, 0.03542256f, 0.15796700f, -0.26425576f, 0.24795134f, 0.35001987f, 
    -0.05212063f, 0.04217478f, 0.08204790f, -0.08720420f, -0.02844697f, -0.11997531f, -0.15835637f, -0.32439312f, 
    0.07718070f, 0.05480341f, 0.18520018f, -0.14762121f, 0.20829122f, 0.08170900f, 0.22248569f, 0.05658808f, 
    -0.13894203f, -0.05584953f, -0.00595497f, -0.24805813f, -0.18683796f, -0.06244788f, 0.13666999f, 0.16764426f, 
    0.00891680f, 0.03089973f, 0.10369243f, 0.05275812f, 0.01426127f, 0.06113967f, 0.06607480f, 0.14301179f, 
    0.16991647f, -0.03298914f, -0.07575612f, -0.04479434f, 0.00184551f, 0.11072339f, 0.03147095f, -0.07077886f, 
    -0.03567911f, 0.08613520f, -0.03960655f, -0.15674722f, 0.08074138f, -0.09415794f, -0.05713535f, 0.15666196f, 
    0.06209476f, 0.07891376f, 0.09275727f, -0.07000071f, -0.18283500f, -0.04778127f, -0.18555090f, -0.01349703f, 
    -0.09735906f, 0.10007490f, 0.17298107f, 0.02539467f, -0.28187889f, -0.44968876f, -0.47641379f, 0.02130211f, 
    0.11880074f, -0.12116134f, 0.08014111f, -0.13130945f, 0.22378916f, -0.10694392f, -0.02396319f, -0.01674981f, 
    -0.08157990f, -0.19566292f, -0.16665159f, 0.01403871f, -0.08851594f, -0.08569015f, 0.06260892f, -0.15901054f, 
    -0.04867466f, -0.05501929f, -0.10303738f, 0.07792833f, 0.07387425f, 0.11241911f, 0.04572220f, 0.03154514f, 
    0.22393724f, 0.05583313f, -0.15259498f, -0.04579673f, 0.00352292f, 0.05019885f, -0.02250553f, -0.03001598f, 
    -0.20650001f, -0.10608941f, 0.07418643f, 0.04023667f, 0.12137437f, -0.07435435f, 0.06814177f, 0.08913293f, 
    0.10263571f, -0.44838309f, -0.11980586f, -0.12803945f, -0.01456246f, -0.09410277f, -0.05529876f, 0.01231096f, 
    -0.02122969f, -0.08645375f, -0.36135948f, -0.13916114f, 0.11453201f, -0.10521819f, -0.10530826f, -0.07056396f, 
    -0.05690941f, -0.00000938f, 0.11786610f, 0.16959564f, -0.27043259f, -0.31095636f, 0.01235224f, -0.02078736f, 
    -0.21240826f, -0.00344521f, -0.12743315f, 0.11006745f, -0.24284655f, -0.08075870f, -0.22559808f, -0.04675489f, 
    -0.06062006f, -0.13537611f, -0.02071491f, 0.03750526f, 0.12073149f, 0.18123780f, 0.06968358f, 0.03247461f, 
    -0.02663655f, 0.04639051f, 0.02815457f, 0.11005460f, 0.15683623f, 0.10865157f, 0.22992517f, -0.01294818f, 
    -0.14256082f, 0.12913302f, 0.00989608f, -0.01023410f, 0.10689569f, 0.16619727f, 0.16069044f, 0.21874307f, 
    0.00883908f, -0.01450379f, 0.14373206f, 0.04498842f, 0.07599653f, 0.06169509f, 0.00688802f, 0.07393251f, 
    0.22542842f, -0.20080724f, -0.25552616f, 0.07050771f, 0.05392572f, -0.00072144f, 0.05596406f, 0.03915204f, 
    -0.00394450f, -0.03498233f, -0.15718365f, -0.35892099f, 0.11387157f, 0.08100460f, -0.18837151f, 0.09534703f, 
    0.10589115f, -0.06992408f, -0.04282190f, 0.12303898f, 0.01163189f, -0.05740780f, -0.04478329f, -0.05529177f, 
    0.01348834f, 0.06541199f, 0.15300205f, 0.19975473f, -0.29435617f, 0.02728887f, -0.02171653f, -0.22914675f, 
    0.00470834f, 0.06117810f, 0.05749006f, -0.00910338f, -0.24752906f, -0.28588897f, -0.12650403f, 0.14099371f, 
    0.18533911f, -0.08899973f, 0.07612978f, 0.06951589f, 0.07414703f, 0.10637216f, -0.01190229f, 0.15584987f, 
    0.14175786f, 0.12204162f, 0.15730751f, 0.08730546f, 0.08442350f, 0.13383341f, -0.17464322f, -0.17532848f, 
    -0.07410498f, -0.02619530f, -0.10574605f, -0.01422097f, 0.01402067f, -0.04266988f, -0.08307419f, 0.19845703f, 
    0.01907528f, -0.44758773f, -0.14229991f, -0.03111411f, 0.07558186f, 0.07100751f, 0.09664237f, -0.13704778f, 
    -0.03939172f, -0.05932350f, -0.05667710f, -0.06218633f, -0.02000624f, -0.03136364f, -0.01243809f, -0.04586313f, 
    0.00191567f, 0.00895793f, 0.01769196f, 0.00055368f, -0.00187807f, -0.03247522f, -0.05852783f, -0.00077960f, 
    0.00775058f, -0.05951508f, 0.01720673f, -0.02280214f, -0.01066404f, 0.02481401f, 0.00082230f, -0.06377680f, 
    -0.01724301f, -0.01073621f, -0.00866318f, -0.01792277f, -0.05399391f, -0.06532517f, -0.06385762f, -0.07660381f, 
    -0.05180668f, -0.02638958f, -0.04712030f, -0.05091695f, -0.03204202f, -0.01948565f, -0.01325062f, -0.02168659f, 
    -0.06349119f, -0.00764586f, -0.03550018f, 0.03219938f, -0.04415826f, -0.08942695f, -0.02051972f, -0.02823465f, 
    0.04862826f, 0.00003574f, -0.01692702f, 0.00159447f, -0.04246500f, -0.02244388f, -0.04945032f, -0.00464587f, 
    0.02588662f, -0.07137880f, -0.01820147f, 0.01561729f, -0.01592934f, -0.05761329f, -0.07458588f, -0.01606730f, 
    -0.05047571f, 0.00433085f, -0.00804587f, -0.02846602f, -0.03221042f, -0.05068681f, -0.03296614f, 0.02856768f, 
    -0.01367069f, 0.02686637f, -0.06470640f, -0.06758095f, -0.00384564f, -0.04659939f, 0.00898405f, 0.01645475f, 
    -0.05215270f, -0.00611505f, 0.01296957f, 0.01587275f, 0.00491404f, -0.04998142f, -0.04883097f, -0.01500468f, 
    -0.02493664f, 0.00254795f, -0.00519916f, 0.01874691f, 0.01482507f, -0.07124326f, -0.07178973f, 0.01157953f, 
    -0.04433295f, 0.02119636f, -0.09220259f, 0.04213500f, -0.03503039f, -0.01506702f, 0.00050574f, 0.00773999f, 
    -0.08159859f, -0.00300133f, -0.01624605f, 0.01866503f, -0.00205226f, -0.00198189f, 0.02151538f, -0.00728548f, 
    -0.09470267f, -0.06939017f, 0.02155233f, -0.02832217f, 0.01737042f, -0.03328481f, -0.00242517f, -0.06820082f, 
    -0.08198594f, -0.03397116f, -0.07908954f, -0.02947040f, -0.06481894f, -0.05438198f, -0.05313116f, 0.04503687f, 
    -0.00632311f, -0.08090472f, -0.00709954f, -0.01870901f, -0.00902198f, -0.07461118f, 0.00618920f, -0.02999915f, 
    -0.01255655f, -0.05697395f, 0.02502271f, -0.07952724f, -0.01824907f, -0.02360446f, -0.06838899f, -0.07020186f, 
    0.00541081f, -0.04089644f, -0.04743109f, -0.07252691f, -0.04033715f, -0.04456781f, -0.01458078f, -0.00886331f, 
    -0.01733788f, -0.07245002f, 0.03316363f, 0.02005397f, 0.00821352f, 0.00621318f, -0.01477731f, -0.01673560f, 
    -0.02258744f, -0.02029150f, -0.01535618f, 0.03323774f, -0.04275206f, -0.02770582f, 0.01296120f, -0.00523802f, 
    -0.04268305f, -0.06083267f, -0.07192311f, -0.04375776f, 0.00672512f, -0.05345775f, -0.06033840f, -0.08252359f, 
    -0.06827537f, -0.00644499f, -0.01264525f, -0.03955726f, 0.00892118f, -0.00909722f, -0.05128117f, -0.02674332f, 
    -0.04612322f, 0.01956134f, 0.01956650f, -0.03776578f, -0.00221586f, 0.02486312f, 0.01180862f, -0.02001105f, 
    -0.07713363f, -0.07285244f, -0.06822875f, -0.04557344f, 0.00452115f, 0.01483058f, -0.06639428f, 0.00262753f, 
    -0.01567052f, -0.07456342f, -0.03112171f, 0.04109100f, -0.00976321f, -0.02349654f, -0.04645464f, -0.07529879f, 
    -0.04225824f, -0.05396559f, -0.00008637f, 0.00318128f, -0.02870750f, 0.02502132f, 0.01014196f, -0.01945427f, 
    0.03408134f, -0.02057515f, -0.00813954f, -0.02722174f, -0.08290495f, -0.06479280f, -0.06099541f, -0.04816731f, 
    0.02532133f, 0.00366841f, -0.05180748f, -0.06035765f, 0.02350146f, -0.04234460f, -0.01439254f, -0.02104577f, 
    -0.01576854f, 0.01172317f, -0.04802466f, -0.04744031f, -0.02192627f, -0.00224810f, -0.01306835f, -0.04690925f, 
    -0.02896818f, -0.03491014f, -0.00624890f, -0.05322615f, -0.04589017f, -0.03610377f, -0.07398816f, -0.01101970f, 
    -0.02596035f, -0.05333805f, -0.00949086f, -0.07430065f, -0.00825876f, -0.05542124f, -0.01699392f, -0.03923905f, 
    -0.05749025f, -0.06582604f, -0.01962036f, -0.04739452f, -0.02170764f, -0.03424797f, -0.07942150f, -0.03350990f, 
    -0.07729165f, -0.04527793f, -0.03577556f, 0.03199674f, -0.07274153f, -0.07370892f, -0.04992495f, -0.06858286f, 
    -0.07347699f, -0.03196494f, 0.03162951f, -0.04935131f, -0.05763532f, -0.01470834f, -0.05121028f, 0.00541939f, 
    -0.01849793f, 0.01520244f, -0.04338771f, -0.00133635f, 0.00876425f, -0.02176670f, -0.04032402f, 0.01290891f, 
    -0.03130277f, 0.05725491f, -0.39623645f, -0.18826544f, -0.05735343f, -0.36659816f, 0.14293863f, 0.00046932f, 
    -0.18829128f, 0.33693027f, 0.09622142f, -0.19791536f, 0.07984433f, -0.03774317f, 0.16995409f, 0.27798256f, 
    -0.01389853f, -0.04444661f, -0.01362420f, 0.24250640f, -0.11660361f, 0.08802170f, -0.07893872f, 0.05197289f, 
    -0.05683828f, -0.05761277f, -0.02980284f, -0.05442097f, -0.18654987f, -0.48390004f, -0.02161574f, 0.21784638f, 
    0.07752748f, -0.04994458f, 0.05281887f, -0.10068122f, 0.01519929f, 0.11142641f, 0.07306774f, 0.08287810f, 
    -0.13814095f, -0.08869001f, 0.03508954f, 0.07233999f, 0.10530932f, -0.04243504f, -0.02923038f, -0.22306599f, 
    -0.13953887f, -0.09514883f, -0.09094981f, -0.01826513f, 0.00197623f, 0.07059514f, -0.06207631f, 0.04219365f, 
    0.11146081f, -0.02581975f, 0.09658802f, 0.04715674f, 0.10347971f, 0.11326816f, 0.01461229f, -0.04308475f, 
    -0.27643585f, -0.08394687f, -0.11506242f, -0.04631018f, -0.15963510f, -0.20658842f, 0.06167138f, 0.13204858f, 
    -0.05117622f, 0.05861447f, 0.08227437f, 0.05774195f, 0.04966283f, -0.02095728f, 0.01949226f, 0.07254958f, 
    0.25974301f, 0.00868356f, 0.09648567f, 0.03020976f, -0.11155828f, 0.12429696f, -0.07794728f, 0.14986868f, 
    -0.00957521f, -0.13965590f, -0.29864374f, -0.08903050f, -0.33466768f, -0.26270697f, 0.01506392f, -0.25016445f, 
    0.11103437f, -0.15892485f, 0.11830389f, -0.06968755f, -0.61091256f, -0.42525741f, 0.02747316f, 0.08009388f, 
    -0.03210458f, 0.00607265f, 0.01245234f, -0.02674091f, 0.14985487f, -0.07166421f, -0.17519598f, 0.15119626f, 
    0.09578571f, 0.03957662f, 0.23175737f, -0.13836934f, 0.12446859f, 0.16536976f, 0.01023878f, -0.03381628f, 
    -0.04539998f, -0.02902100f, -0.08085468f, 0.15323089f, -0.02684619f, 0.06988459f, -0.46392053f, -0.07671533f, 
    -0.45569611f, -0.08022198f, 0.18832296f, -0.11475743f, 0.07400503f, -0.17272818f, 0.12166363f, -0.18363592f, 
    0.05621864f, -0.09167188f, -0.00412190f, 0.04520635f, -0.00722593f, 0.11163189f, 0.03784960f, -0.07276551f, 
    0.12916112f, -0.30027550f, -0.12362240f, 0.08134241f, 0.14860170f, 0.01187987f, 0.16910945f, -0.06768135f, 
    0.10233167f, -0.02970019f, -0.02048634f, -0.03832707f, -0.10062799f, -0.01924696f, -0.09029413f, 0.08552488f, 
    -0.06230623f, 0.09282141f, -0.16300508f, -0.08390143f, -0.13010164f, 0.06045307f, -0.03422552f, -0.03144759f, 
    0.00104698f, 0.03190405f, 0.04819146f, -0.03864146f, 0.05882053f, 0.03755559f, 0.05658193f, -0.05505757f, 
    -0.02884177f, -0.05585786f, -0.11524472f, -0.04915569f, 0.02685127f, 0.02593366f, 0.01490305f, -0.17406991f, 
    -0.05424120f, 0.00030999f, 0.04278385f, 0.02899185f, 0.02373747f, 0.04160998f, -0.02747742f, -0.03797620f, 
    0.03991243f, 0.03329615f, 0.20716310f, 0.04097115f, 0.05240560f, -0.02636833f, 0.22139598f, 0.11071555f, 
    0.10447756f, 0.08806662f, 0.07644682f, 0.01380384f, -0.13065238f, 0.36705518f, -0.00102600f, 0.08932000f, 
    0.04051508f, 0.00139331f, 0.04622155f, 0.13475853f, -0.00452955f, 0.13686304f, 0.11506873f, -0.03824767f, 
    -0.28564227f, -0.21952482f, -0.08230735f, -0.03513046f, -0.16857493f, 0.07692727f, -0.09984713f, 0.11389982f, 
    -0.20246327f, 0.16794819f, -0.11997586f, -0.08742264f, 0.09940896f, 0.10930303f, 0.12083444f, 0.22154513f, 
    -0.10044052f, -0.00505303f, -0.01322319f, 0.06122226f, -0.06951306f, -0.01549884f, 0.06095193f, -0.10178778f, 
    0.03462741f, -0.06300618f, 0.12408827f, -0.03644028f, 0.05772825f, 0.08721194f, -0.07726309f, -0.08851884f, 
    -0.07466719f, 0.14520235f, -0.20113735f, 0.08723997f, -0.26095739f, -0.20903897f, -0.16122426f, 0.14372684f, 
    0.00509192f, 0.15184689f, 0.01155327f, -0.00673243f, 0.04076801f, -0.00963738f, -0.21850994f, 0.01610942f, 
    0.11382120f, 0.04275486f, 0.09757864f, -0.12775137f, 0.20625453f, 0.15020168f, -0.07406123f, 0.02446194f, 
    -0.03736835f, -0.03794479f, -0.05881885f, 0.00069055f, 0.06399538f, -0.04147265f, -0.07549711f, 0.11967050f, 
    0.05695428f, -0.35131553f, 0.12607008f, 0.12018873f, 0.21572538f, 0.05452301f, 0.03188293f, 0.00434290f, 
    0.46869487f, 0.12903537f, -0.41347572f, -0.02669821f, -0.05652833f, -0.06715805f, 0.02142012f, 0.00658973f, 
    -0.04650794f, 0.07229806f, -0.22434491f, 0.03523387f, 0.07558647f, -0.07374110f, 0.27835190f, -0.02063386f, 
    -0.00100902f, 0.09204745f, 0.06828479f, 0.18923803f, -0.12619548f, -0.04789108f, -0.01371090f, 0.09793086f, 
    -0.06790773f, -0.01996237f, 0.01594451f, -0.07169273f, -0.10150466f, -0.12951601f, 0.00549328f, -0.05616894f, 
    0.14911768f, 0.06416061f, 0.05853476f, -0.11802027f, 0.03487355f, 0.02042905f, 0.09531437f, -0.05669004f, 
    0.01067519f, -0.00715558f, -0.05262462f, -0.05412724f, -0.07969018f, 0.27268741f, 0.01428351f, -0.47442174f, 
    -0.04722791f, -0.08208483f, -0.10668976f, 0.03819597f, 0.03934940f, -0.09750152f, -0.02309741f, 0.16525613f, 
    0.26671511f, -0.24124730f, 0.09198695f, 0.03200024f, 0.03443491f, 0.06477251f, -0.21857727f, 0.05267837f, 
    -0.01273057f, 0.11150917f, -0.02166803f, 0.03247557f, -0.05361237f, -0.03603953f, -0.11170845f, 0.20597613f, 
    -0.03075273f, -0.10167846f, 0.06697227f, -0.02337694f, 0.04728537f, -0.12190151f, -0.00625636f, -0.03912841f, 
    0.05748813f, 0.04753773f, 0.18754005f, -0.02061583f, -0.04420098f, -0.13099979f, -0.06954964f, -0.01916773f, 
    -0.13293727f, -0.15754579f, 0.15605295f, 0.03661034f, -0.01338538f, 0.08738527f, -0.13762723f, 0.01621938f, 
    -0.09003431f, -0.10783157f, -0.03472498f, -0.09491373f, -0.14918785f, -0.06669105f, -0.00878474f, 0.09250911f, 
    -0.04558064f, -0.07213923f, -0.02207427f, -0.02650854f, 0.25494552f, 0.28586748f, -0.16005155f, 0.04204351f, 
    0.12535898f, 0.03130105f, 0.00274633f, 0.03086022f, -0.24637794f, 0.01183394f, -0.03072920f, 0.07603861f, 
    0.16044754f, 0.07683951f, -0.07233185f, -0.01400998f, 0.04079370f, 0.04604244f, -0.04276642f, -0.01295486f, 
    0.16622902f, 0.09052494f, 0.02921473f, 0.02097550f, -0.19443312f, 0.12651721f, -0.01836972f, 0.05669462f, 
    -0.13157932f, 0.07620928f, 0.04103702f, -0.06069351f, 0.11807526f, -0.08040094f, 0.11508299f, -0.20025754f, 
    -0.37158197f, -0.10696706f, 0.18104963f, 0.07833730f, 0.06326742f, 0.04792886f, -0.03410929f, -0.01725814f, 
    0.28028128f, 0.07717378f, -0.01619631f, -0.10931458f, -0.07474606f, -0.00354022f, -0.00583292f, 0.02216510f, 
    0.05047643f, -0.08974691f, 0.06532964f, 0.16593333f, 0.00739552f, 0.00783443f, -0.11004639f, -0.07205442f, 
    -0.12183102f, 0.01458781f, 0.29743013f, 0.22309677f, 0.03003040f, 0.19206427f, -0.05710994f, 0.07397303f, 
    -0.09730338f, 0.01262948f, 0.00155799f, -0.07535805f, 0.09432317f, -0.06051623f, 0.04810782f, -0.06885739f, 
    0.02366935f, -0.00396395f, 0.02955229f, 0.12819123f, -0.10690407f, -0.01239535f, 0.02617260f, 0.10366648f, 
    0.09931555f, 0.03709116f, -0.00262747f, -0.11312409f, -0.06395756f, -0.05992417f, -0.01778469f, 0.10629524f, 
    0.30672184f, -0.15096135f, -0.10054258f, -0.00906260f, -0.14428203f, 0.11767914f, 0.02059031f, 0.07131798f, 
    0.16503045f, 0.06438656f, -0.15113601f, -0.01210738f, -0.30673057f, 0.02838245f, 0.01794728f, -0.08606566f, 
    -0.02900115f, -0.13976665f, 0.24369393f, 0.01589327f, -0.02160334f, 0.02454452f, 0.06810455f, 0.02232939f, 
    0.05736111f, 0.00210770f, -0.23610918f, 0.06404804f, -0.16817208f, 0.05013191f, 0.15740080f, 0.07331268f, 
    -0.09613071f, 0.02912571f, -0.01624441f, 0.07455229f, -0.03425490f, 0.13896330f, 0.09967175f, -0.00488157f, 
    -0.01296652f, -0.06554325f, -0.04574736f, 0.08142646f, 0.29869568f, 0.06779962f, 0.08482081f, -0.22196065f, 
    -0.09050895f, 0.13588592f, -0.25455159f, -0.15218906f, -0.25858495f, -0.21192653f, 0.15132123f, 0.10290448f, 
    0.05447257f, 0.06994548f, -0.03824564f, -0.04887156f, 0.18234108f, 0.05054040f, 0.05741836f, 0.00774306f, 
    0.08225098f, -0.13352503f, -0.03437587f, -0.10326736f, -0.20144252f, 0.05400307f, -0.00167403f, 0.07383006f, 
    0.01995061f, -0.02473588f, -0.02039511f, -0.06352665f, -0.00387715f, -0.16448793f, -0.16000406f, 0.12500928f, 
    0.01952474f, -0.00043975f, -0.25011182f, 0.22987396f, 0.22807296f, 0.10559299f, 0.17330797f, -0.01951211f, 
    -0.01982588f, -0.03221819f, -0.02469063f, -0.03243103f, -0.05660974f, -0.06641082f, -0.01584557f, 0.01528635f, 
    -0.03913571f, -0.05363952f, -0.03521837f, -0.02178275f, -0.05964686f, -0.03867823f, -0.03586406f, 0.02269688f, 
    -0.01740233f, -0.06554019f, 0.03394110f, 0.00587667f, -0.00625162f, 0.02674734f, -0.05533652f, -0.06498296f, 
    -0.03467423f, -0.00036339f, 0.02672657f, 0.04695597f, 0.03282160f, 0.01538213f, 0.00280183f, -0.00729569f, 
    -0.04550988f, -0.04952257f, 0.03555875f, -0.03140035f, 0.00854532f, 0.01030941f, 0.00142949f, -0.01810334f, 
    0.02084626f, 0.00656065f, -0.02074702f, 0.00807273f, -0.05330619f, -0.05804535f, 0.01180403f, -0.02006637f, 
    -0.05591103f, -0.05444833f, 0.02205396f, -0.02748101f, 0.03424487f, -0.06882493f, -0.01730383f, -0.01007819f, 
    -0.06448071f, 0.01145472f, -0.01314116f, -0.05542952f, -0.03436394f, -0.02738374f, 0.04588853f, -0.03178667f, 
    0.03118077f, 0.03755682f, 0.00945538f, 0.04788304f, 0.03761742f, 0.03477830f, 0.02457188f, -0.05498296f, 
    0.03099633f, 0.01335781f, -0.00587585f, -0.06897777f, -0.03810746f, -0.05989109f, -0.01498340f, 0.03955602f, 
    0.04593567f, 0.02525768f, -0.00982269f, -0.02552668f, -0.06411629f, -0.02140993f, -0.05550775f, 0.03846955f, 
    -0.01812100f, 0.03170916f, 0.00516369f, 0.00778153f, -0.01238305f, -0.00636644f, 0.03010044f, -0.03572991f, 
    0.01888374f, -0.03497814f, 0.02838050f, 0.01238182f, 0.00215966f, 0.03449951f, -0.06588508f, 0.02402071f, 
    0.02296205f, -0.00527578f, -0.03595021f, 0.05577051f, 0.05082460f, -0.00562614f, 0.03042067f, 0.02036707f, 
    -0.01514894f, -0.01225622f, -0.05730653f, -0.02008261f, -0.03953065f, 0.02098755f, 0.01449942f, -0.06276847f, 
    -0.00015229f, -0.02886155f, -0.04087584f, 0.04946790f, 0.03655280f, -0.04922277f, -0.05051978f, 0.02763947f, 
    -0.00793689f, -0.01389312f, 0.04619023f, -0.04669008f, 0.02907287f, 0.00784080f, -0.03447769f, -0.03240803f, 
    0.01020463f, -0.01907962f, 0.00481846f, -0.03134038f, -0.00328483f, 0.04133851f, 0.04927041f, -0.00288389f, 
    0.01332211f, 0.03743106f, -0.06699592f, -0.05459798f, -0.04403067f, -0.02715892f, -0.06221567f, -0.01826626f, 
    -0.04122075f, -0.00838725f, 0.01668199f, -0.00374612f, -0.03962319f, 0.05017975f, 0.02134766f, 0.00693538f, 
    0.02526602f, -0.04737061f, 0.01832942f, -0.00264409f, -0.05083526f, -0.03907725f, -0.02122534f, -0.05860571f, 
    0.01787016f, 0.01556447f, -0.00934298f, 0.01733638f, 0.02306604f, 0.01285605f, -0.03935825f, -0.00603291f, 
    0.04519039f, -0.02968949f, 0.00442073f, -0.04467812f, 0.05296759f, 0.02754379f, 0.03022513f, -0.03826807f, 
    -0.03207814f, -0.03948982f, -0.05769563f, -0.06167941f, -0.04850062f, -0.05821908f, -0.06400906f, -0.05635563f, 
    -0.06216637f, 0.02504627f, 0.03139848f, -0.04831607f, -0.05878964f, -0.05721840f, 0.03608652f, -0.02269216f, 
    -0.03045957f, -0.05247039f, -0.05687189f, 0.03247967f, -0.04761574f, 0.00406863f, 0.02049212f, -0.00743600f, 
    -0.01398499f, -0.05477779f, -0.03687846f, -0.06437030f, 0.02654698f, 0.04773938f, -0.04761200f, 0.00505298f, 
    -0.00109156f, -0.03867627f, -0.03021114f, -0.04291525f, -0.00549387f, 0.01300475f, -0.06202092f, 0.04226097f, 
    -0.00104665f, -0.00847944f, 0.01984000f, -0.03502180f, -0.04421753f, -0.01487474f, -0.03551911f, 0.03302311f, 
    -0.06736054f, 0.02079094f, -0.02828923f, -0.01651874f, -0.03510515f, 0.02644325f, 0.00908650f, -0.03923742f, 
    -0.02624834f, 0.00247487f, -0.00641423f, 0.01166496f, 0.01637184f, 0.04136128f, 0.05582196f, -0.03112096f, 
    0.00600920f, 0.00330643f, 0.04507576f, 0.01578307f, 0.01038902f, 0.01933427f, -0.00002669f, -0.00056208f, 
    -0.01326462f, -0.04279233f, 0.04697996f, 0.03143438f, 0.00514289f, 0.00773694f, 0.03655156f, 0.03432445f, 
    -0.04705194f, -0.00705146f, -0.00177042f, 0.03345926f, 0.01198430f, -0.03031042f, 0.00466825f, 0.04407227f, 
    -0.00383750f, -0.04969948f, 0.03104962f, 0.04843810f, -0.06417897f, 0.05308536f, -0.04521038f, -0.04977630f, 
    -0.01365413f, -0.00783722f, -0.05790126f, 0.03208561f, -0.00120220f, 0.01470270f, 0.01643605f, -0.06872852f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.16996093f, 0.02111678f, -0.01898200f, 0.08565723f, -0.05820958f, 0.22295913f, 0.13208042f, -0.01909168f, 
    0.16492629f, 0.10176635f, -0.02608547f, 0.12622020f, 0.12483008f, -0.03079855f, 0.05852071f, 0.12325806f, 
    0.19396803f, 0.02186555f, -0.00391963f, 0.05334901f, 0.19385609f, -0.05930177f, 0.21329765f, 0.10454877f, 
    -0.04526421f, -0.06629127f, 0.01699052f, 0.19624601f, -0.05107509f, 0.14723454f, -0.02727613f, -0.04444818f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.02670777f, -0.12480930f, -0.02280843f, -0.09510650f, 0.00343178f, -0.62608600f, 0.32487077f, 0.10157277f, 
    0.05037341f, 0.07907181f, -0.22804868f, 0.07567564f, 0.14513630f, -0.20048280f, -0.37753668f, 0.22451758f, 
    -0.01934674f, 0.24837659f, -0.16817202f, -0.15210262f, -0.04479937f, -0.13040766f, -0.39661235f, -0.14378937f, 
    0.32793567f, -0.02655116f, 0.33856368f, 0.27375329f, -0.09239238f, -0.14797007f, -0.11712984f, -0.14169191f, 
    0.13342728f, 0.09851269f, -0.01453512f, -0.11041262f, -0.03313609f, 0.63527530f, 0.09994487f, -0.23747464f, 
    -0.02799942f, 0.08500461f, 0.32500181f, -0.36381716f, -0.13018516f, -0.10153929f, -0.41198865f, 0.01371561f, 
    0.15232874f, -0.21304175f, -0.10971195f, -0.01628004f, -0.06046150f, -0.09410477f, -0.12592192f, 0.14890228f, 
    0.35561451f, 0.10399104f, 0.05106851f, 0.34592879f, 0.05944354f, -0.11057226f, -0.36220038f, 0.10382489f, 
    0.06770790f, 0.15083438f, -0.12967123f, 0.08612003f, -0.06810138f, -0.24209937f, 0.26951933f, 0.22135028f, 
    0.00492186f, 0.06452002f, -0.11993911f, 0.26163766f, 0.03016605f, -0.00426183f, 0.12565272f, -0.14287814f, 
    0.07479332f, 0.32357821f, 0.10315020f, -0.17393996f, -0.16753957f, 0.11788157f, 0.41950804f, -0.15225759f, 
    -0.14578526f, -0.08247597f, -0.07275634f, -0.05360340f, 0.09431442f, 0.16795419f, 0.18249510f, -0.02156460f, 
    -0.03233663f, 0.05053242f, -0.02412279f, 0.25002581f, -0.07430321f, 0.16361147f, 0.15952662f, -0.01503839f, 
    0.35471967f, 0.19792646f, -0.17259409f, 0.38172436f, 0.03332513f, 0.15514675f, -0.02040417f, -0.22296903f, 
    -0.09978753f, -0.35355133f, 0.02710205f, 0.02550532f, 0.14993112f, -0.13855937f, -0.15027052f, -0.12045465f, 
    -0.09019560f, -0.14873317f, -0.03830689f, 0.42688560f, 0.05871984f, 0.13791706f, -0.08942728f, -0.02932646f, 
    -0.11049149f, 0.04444601f, 0.15203159f, -0.03531326f, 0.03556613f, -0.19181587f, 0.23196031f, -0.10188939f, 
    0.37681198f, -0.02310876f, 0.02335242f, 0.32333121f, 0.30259725f, -0.08199893f, -0.32654679f, 0.40143898f, 
    -0.17647627f, 0.06254420f, -0.05495124f, -0.00288340f, 0.19468388f, -0.16593836f, -0.00381061f, 0.13085526f, 
    -0.29061136f, 0.10294744f, -0.36163434f, 0.19678144f, -0.07462509f, 0.19223773f, -0.23935741f, 0.11433159f, 
    0.27491155f, -0.17056306f, -0.09453471f, -0.01989794f, -0.16464710f, 0.21360624f, 0.28950620f, 0.06660414f, 
    0.27376211f, 0.20866258f, 0.14189170f, 0.13570492f, -0.15690419f, 0.06691920f, 0.17340522f, 0.12389496f, 
    0.13083281f, 0.03395093f, 0.15684147f, -0.06437309f, -0.11701944f, -0.11897513f, 0.46836251f, -0.14565381f, 
    -0.22762167f, 0.13264936f, -0.03960837f, -0.21765175f, -0.15812433f, 0.19846727f, 0.17041431f, -0.15133944f, 
    0.12960669f, -0.15569289f, 0.15382576f, 0.01194234f, 0.07290942f, -0.00065264f, -0.26475561f, -0.05489644f, 
    0.15100643f, -0.13012767f, -0.38037708f, 0.05044153f, 0.30311894f, -0.06850186f, -0.43122017f, 0.23749490f, 
    0.15894417f, -0.35211462f, 0.07988881f, 0.07612109f, -0.22515191f, 0.18265019f, -0.33255577f, -0.02317077f, 
    0.03223088f, -0.12256268f, 0.08684357f, 0.40161753f, 0.05966336f, -0.31770411f, -0.64106560f, -0.12450213f, 
    0.15490876f, -0.10548893f, 0.02445745f, 0.24829857f, -0.09412885f, 0.40688896f, 0.02877464f, -0.11486146f, 
    0.06449562f, -0.15882835f, 0.23803863f, 0.16744912f, 0.21674138f, -0.05865063f, -0.00770381f, 0.06864993f, 
    -0.05328267f, -0.04902757f, 0.03455502f, 0.00292376f, -0.22877197f, 0.16282834f, 0.16475131f, 0.09917244f, 
    -0.23895273f, 0.10699832f, -0.29775503f, 0.14073923f, 0.08962364f, 0.14221977f, 0.05281379f, 0.16863583f, 
    -0.07669687f, 0.00329505f, 0.05288090f, -0.47256318f, 0.15592989f, 0.49425071f, -0.19003816f, -0.13143072f, 
    -0.11235604f, 0.14667009f, 0.11057251f, -0.09812183f, 0.27374178f, 0.13205318f, -0.36971259f, 0.08136890f, 
    0.03561044f, -0.12120143f, 0.42997184f, -0.04129045f, -0.20964654f, 0.05746184f, -0.08066015f, -0.13828574f, 
    -0.12300993f, 0.00562955f, -0.00921093f, 0.38667709f, -0.05233499f, 0.20542881f, -0.08055563f, 0.13814598f, 
    -0.27547833f, -0.04256229f, 0.12402777f, 0.13728264f, 0.17242341f, 0.53679842f, -0.31656894f, 0.24848251f, 
    0.05962107f, -0.16430356f, -0.43303531f, 0.41887632f, 0.28018481f, -0.10145567f, -0.10658052f, -0.01302840f, 
    0.02215049f, 0.24568751f, 0.10694957f, 0.06026359f, 0.10720082f, 0.05565841f, 0.18069348f, -0.43488416f, 
    -0.01074725f, -0.08814697f, 0.17120938f, -0.23700435f, 0.12500755f, 0.02415834f, -0.11516229f, 0.11301073f, 
    0.19289926f, -0.09321033f, -0.14740753f, 0.03377779f, -0.31452915f, 0.12349318f, 0.26531485f, -0.05821574f, 
    0.42517623f, 0.09359372f, 0.43641111f, -0.09445394f, 0.06260997f, -0.11031877f, -0.28407103f, 0.28241783f, 
    0.00544937f, -0.00226918f, 0.07096407f, -0.14975648f, -0.14351234f, -0.15696473f, -0.08727650f, 0.21511672f, 
    -0.14617121f, -0.10000476f, -0.23055708f, 0.23066577f, 0.18172958f, -0.03197743f, -0.24220903f, -0.08153012f, 
    0.04875943f, -0.17080921f, 0.12324028f, 0.10704448f, 0.13646983f, 0.69246733f, 0.00452812f, 0.06322557f, 
    -0.12084006f, -0.06411810f, 0.26324618f, -0.15349588f, -0.02185428f, -0.16554992f, -0.03959260f, 0.02286267f, 
    0.15439820f, -0.18978973f, 0.30986300f, 0.12092315f, -0.02020996f, -0.09063565f, -0.38975388f, 0.07637733f, 
    -0.12619276f, -0.01997748f, -0.15125200f, 0.33200040f, -0.12637863f, -0.18122275f, -0.11472671f, -0.12337061f, 
    0.01572699f, 0.00265063f, 0.14347783f, -0.01834439f, 0.11760629f, -0.45089135f, 0.28325033f, 0.24878566f, 
    0.20206955f, 0.03094382f, -0.18455066f, -0.11187898f, 0.21536548f, 0.16659598f, -0.11949852f, 0.20765460f, 
    -0.12906334f, 0.15392858f, -0.38015580f, -0.17538045f, 0.18243660f, 0.00411654f, -0.10745957f, -0.00100469f, 
    0.02357997f, -0.01576370f, -0.02508679f, -0.06716912f, 0.16651207f, 0.14468539f, 0.17621469f, -0.12697937f, 
    0.33167794f, -0.10419312f, 0.06715512f, 0.17102139f, -0.06592709f, 0.07059853f, -0.11041714f, -0.40078709f, 
    0.20563962f, -0.21947888f, -0.30345544f, 0.33137923f, 0.07641448f, -0.08312998f, -0.13741396f, 0.26909882f, 
    0.15131994f, 0.13122255f, 0.09194338f, 0.04709881f, -0.38267139f, 0.11505027f, 0.12236815f, 0.15658247f, 
    -0.23487516f, -0.11780834f, 0.33209437f, -0.18030734f, -0.09150976f, -0.29201201f, -0.33066508f, -0.17202961f, 
    0.18569425f, -0.01407625f, 0.02719839f, 0.03090806f, 0.06075720f, -0.14749125f, -0.32832053f, 0.01910269f, 
    -0.21308170f, -0.24634047f, 0.21710701f, 0.11163884f, 0.21594639f, -0.07604586f, -0.08078507f, -0.21403499f, 
    0.03969025f, -0.19171152f, 0.06923616f, 0.02961115f, -0.28472254f, -0.15894650f, 0.28394419f, 0.23041151f, 
    -0.36690825f, 0.11604795f, 0.06551877f, 0.14063609f, -0.11684764f, 0.20245834f, 0.23832802f, -0.08502882f, 
    0.00862746f, 0.14659365f, -0.16157636f, 0.08043628f, -0.03119276f, 0.15467639f, -0.16173837f, -0.07167973f, 
    -0.00285103f, 0.17361425f, -0.13305752f, 0.05656775f, -0.16641650f, -0.04602028f, -0.06380805f, -0.03654787f, 
    -0.01707846f, -0.02360022f, -0.10307319f, -0.13075502f, -0.13352074f, -0.02935374f, -0.00969429f, 0.00109230f, 
    0.00174349f, -0.06244154f, -0.18153428f, -0.13165717f, -0.12670790f, -0.20550555f, -0.03913791f, 0.12023971f, 
    0.03488132f, -0.08802582f, 0.14387365f, -0.06149675f, -0.04701839f, -0.16594289f, 0.35096031f, -0.18011636f, 
    -0.03734161f, 0.25132817f, -0.27027225f, -0.01429430f, -0.13177653f, 0.02398274f, 0.23928687f, 0.11084935f, 
    -0.10789933f, -0.05860861f, 0.09425787f, 0.02060890f, 0.06221690f, 0.10043896f, 0.13212501f, 0.07259192f, 
    0.20611382f, 0.07989755f, 0.35546756f, -0.11946708f, 0.04757634f, 0.15627226f, 0.21040452f, 0.05576064f, 
    0.19299322f, 0.07526615f, -0.12739144f, -0.22446060f, -0.21605402f, -0.01680379f, -0.26716688f, 0.32869866f, 
    -0.29975060f, 0.23133530f, 0.05446663f, -0.24989556f, -0.13667408f, 0.16310988f, -0.14774473f, 0.20034727f, 
    -0.06359558f, -0.14056666f, 0.02972645f, 0.01609269f, 0.17072503f, -0.09465092f, -0.12030814f, 0.18348898f, 
    -0.11513051f, 0.12720096f, 0.13087010f, -0.08910226f, 0.08432102f, 0.17966299f, -0.09665073f, 0.16251265f, 
    0.39059767f, -0.06248838f, 0.07481620f, -0.17902248f, 0.15210256f, 0.69235915f, -0.19078971f, -0.17230436f, 
    -0.01137044f, 0.01591704f, -0.00959601f, 0.08549192f, 0.14293402f, 0.12923630f, -0.31061712f, -0.09616488f, 
    0.14262402f, -0.13792221f, -0.19233188f, 0.07405189f, -0.27352321f, 0.01216070f, 0.08960499f, -0.19753869f, 
    0.23314467f, -0.07129560f, 0.21174562f, 0.28045359f, 0.00696115f, -0.35947093f, -0.42044207f, 0.11106919f, 
    0.26827845f, -0.09027866f, 0.06883834f, 0.06844804f, -0.10925592f, 0.06382414f, 0.31442016f, -0.38252467f, 
    0.32741487f, -0.02209016f, 0.04800014f, 0.08805710f, 0.08460965f, -0.16130881f, 0.04227079f, 0.02119464f, 
    0.28603813f, 0.09739291f, 0.44689745f, 0.05767912f, -0.04003878f, 0.04493489f, -0.12729841f, 0.13025093f, 
    -0.19920859f, -0.03842644f, -0.24282458f, 0.31509617f, 0.09472363f, 0.08106365f, -0.25186339f, 0.05924387f, 
    0.38437569f, -0.03931155f, 0.11763502f, 0.17649822f, -0.12730601f, 0.22817028f, -0.26866096f, 0.07252750f, 
    -0.04759509f, 0.24227896f, 0.15824708f, 0.07933217f, 0.29106960f, -0.12059505f, -0.18386160f, -0.21936300f, 
    0.13017897f, 0.03757982f, -0.12045722f, 0.06133917f, 0.03546952f, -0.12298302f, 0.25328615f, -0.05005688f, 
    -0.25552151f, -0.11587989f, -0.29433030f, -0.31845945f, -0.11891198f, -0.03560273f, -0.01515343f, 0.06487500f, 
    0.09122903f, -0.08018130f, -0.13701461f, 0.08242137f, 0.05238644f, -0.34136662f, 0.23242071f, -0.19613232f, 
    0.40961012f, 0.14158688f, -0.30822119f, 0.08507618f, 0.15744358f, -0.01617970f, -0.22602206f, 0.02402771f, 
    0.24842229f, -0.41406459f, 0.10409576f, 0.15975694f, 0.03081924f, -0.04583484f, 0.23785430f, 0.05396636f, 
    0.10881342f, -0.11524533f, -0.02405209f, -0.22383542f, 0.13536456f, 0.10834903f, -0.07390036f, -0.13334930f, 
    -0.25801185f, -0.09199050f, -0.11118989f, 0.06441627f, 0.24057992f, 0.20087798f, -0.02684816f, 0.01196634f, 
    0.03417385f, -0.14159331f, 0.04391406f, 0.25947484f, 0.18404560f, -0.00404222f, -0.10527548f, 0.07791504f, 
    0.17704621f, -0.04919055f, 0.45985070f, 0.13824666f, 0.04862140f, 0.16431671f, -0.19370829f, 0.20683101f, 
    -0.38210976f, -0.10821286f, -0.26676413f, 0.16776302f, 0.02768399f, -0.00850232f, -0.16804239f, 0.09459335f, 
    0.26983002f, -0.14347798f, -0.10000521f, 0.02752718f, 0.02110746f, 0.06785571f, 0.12984474f, 0.32161835f, 
    -0.01557054f, 0.22411753f, -0.02581048f, 0.01023559f, -0.10846136f, 0.06317795f, 0.12656063f, 0.39791968f, 
    0.03544898f, 0.38358188f, -0.02736631f, 0.16643827f, -0.03718042f, 0.13498753f, 0.31293115f, -0.13770965f, 
    0.03486937f, -0.08560178f, 0.23581761f, -0.39250949f, 0.01065242f, -0.25071523f, 0.18956265f, 0.16820590f, 
    0.45275852f, 0.17351586f, -0.09202927f, 0.25158587f, -0.20081063f, 0.01452112f, 0.28197077f, 0.04569287f, 
    -0.13212986f, -0.28441733f, 0.35420984f, 0.18963262f, -0.16417940f, -0.08036577f, -0.11201721f, 0.12624718f, 
    -0.01738257f, 0.29014170f, -0.13338619f, -0.10514634f, 0.00976233f, -0.02819014f, 0.41965708f, 0.13771197f, 
    0.08467605f, 0.18089594f, 0.07606971f, -0.21982507f, -0.15113735f, -0.22659379f, 0.01992108f, -0.03448938f, 
    -0.04181142f, -0.17990306f, 0.13552000f, -0.14967521f, 0.15903878f, 0.49153742f, -0.18750970f, 0.05802853f, 
    -0.22425582f, -0.34696418f, -0.43912995f, 0.24437821f, 0.10674832f, -0.12789857f, -0.02380033f, 0.04568090f, 
    0.03435345f, 0.15730648f, -0.00545051f, -0.12313150f, 0.08436757f, -0.05044170f, 0.09096293f, -0.32984355f, 
    0.31143811f, 0.11014476f, 0.33582863f, -0.17533174f, 0.13952036f, -0.16717784f, 0.13656598f, 0.05622569f, 
    0.00664259f, -0.03518167f, -0.08258888f, 0.21218570f, -0.20639002f, -0.38107169f, 0.27540913f, 0.23788527f, 
    0.33747837f, 0.07401551f, -0.02909455f, -0.16270831f, -0.03700675f, -0.12532234f, -0.00979770f, -0.11461601f, 
    0.28310585f, 0.16371292f, -0.11223947f, 0.15386413f, -0.04969428f, -0.15820877f, 0.19211084f, -0.33047178f, 
    0.07811933f, 0.02144590f, -0.07424253f, -0.10041603f, 0.04893822f, 0.26836103f, 0.06994854f, 0.13545735f, 
    0.33146435f, -0.05255032f, -0.09889978f, -0.14961325f, -0.17615478f, -0.16743101f, -0.01574104f, 0.15958880f, 
    -0.08488785f, 0.00705109f, 0.48732305f, 0.02672130f, -0.10647526f, -0.07574122f, -0.20767161f, -0.08547813f, 
    0.31139433f, 0.28881863f, -0.01213420f, 0.16724217f, -0.17708822f, 0.12634340f, -0.03374670f, 0.02723831f, 
    0.09542756f, -0.00969133f, 0.09994639f, 0.23712562f, -0.02602845f, 0.24915396f, -0.06232384f, -0.04689587f, 
    -0.06636482f, 0.07011785f, -0.17129052f, -0.11501899f, 0.09365472f, -0.06136581f, -0.10770439f, 0.04558449f, 
    0.07609273f, -0.24033211f, -0.29193732f, 0.22334406f, 0.19042876f, 0.08506259f, -0.19924134f, 0.12673880f, 
    0.01689467f, -0.17419781f, 0.15049158f, -0.01741337f, 0.09346001f, -0.05493477f, -0.18573932f, -0.46338981f, 
    0.17482325f, -0.10975643f, -0.02144617f, 0.05194163f, 0.09970523f, -0.04335345f, -0.08031663f, 0.07464556f, 
    -0.00625989f, -0.14061320f, -0.05633993f, 0.17235743f, 0.08454931f, 0.45944130f, -0.02083514f, -0.26346257f, 
    0.12417256f, 0.05208690f, 0.07612257f, 0.09301062f, 0.24696942f, -0.06397729f, -0.22462937f, 0.21236947f, 
    0.13551390f, -0.42417002f, 0.31413338f, 0.14759324f, -0.07243954f, 0.03619281f, -0.41294357f, 0.04630663f, 
    0.11517494f, -0.01674613f, -0.18341364f, 0.22859192f, -0.16472512f, -0.21829687f, -0.26860741f, -0.12936871f, 
    -0.06779081f, -0.00774233f, -0.13397399f, 0.18377368f, -0.18173957f, -0.07057398f, 0.06725105f, -0.23163633f, 
    -0.12698075f, -0.23467001f, -0.12178393f, 0.14972918f, 0.20790717f, 0.01125901f, 0.10361801f, 0.05361272f, 
    -0.11078127f, -0.26644456f, -0.06288388f, -0.17770307f, -0.12288044f, 0.00729167f, -0.00583229f, 0.09943776f, 
    -0.07465177f, 0.11798825f, 0.11857971f, 0.06881602f, 0.05368942f, 0.21815303f, -0.10301498f, 0.09927244f, 
    0.14787140f, -0.03276934f, -0.05968726f, -0.38617089f, -0.02647027f, 0.03003230f, -0.02679230f, 0.29170752f, 
    0.03345773f, -0.20935918f, -0.01522343f, 0.17618790f, 0.12104093f, -0.08938794f, -0.05440757f, 0.10714753f, 
    -0.24650598f, 0.31330004f, -0.10296166f, -0.13492249f, -0.03023255f, -0.07346581f, -0.02118174f, -0.43769822f, 
    -0.07425959f, 0.05794545f, 0.21513724f, -0.22187293f, -0.14695889f, 0.02092827f, 0.19348699f, 0.05536716f, 
    -0.31394109f, -0.15932204f, -0.16163768f, -0.16158530f, 0.14918679f, 0.21215324f, 0.02234280f, 0.44042245f, 
    -0.06047899f, 0.07538286f, -0.08467163f, -0.25201693f, 0.16351537f, -0.08138230f, -0.22436944f, -0.20789571f, 
    0.16119702f, 0.16009402f, -0.36136422f, -0.07915713f, 0.16829084f, -0.08476016f, -0.34527853f, -0.51491201f, 
    0.04141597f, -0.05574886f, -0.11780743f, 0.18558452f, 0.00029290f, -0.18856077f, 0.21417421f, 0.07920650f, 
    0.01312133f, 0.09334646f, -0.01315279f, 0.12398123f, -0.04094683f, 0.60085088f, 0.15777609f, 0.25169703f, 
    0.03193470f, 0.13593802f, -0.07837269f, 0.35405627f, -0.03762238f, -0.09198765f, 0.12136118f, -0.08946449f, 
    -0.17092580f, 0.19751124f, 0.09903518f, 0.07715362f, -0.19912675f, -0.00725014f, 0.26800889f, 0.03034202f, 
    -0.15600887f, -0.16438831f, -0.12997140f, 0.14566055f, -0.11921415f, 0.06793159f, 0.06964279f, 0.11754592f, 
    -0.20263030f, 0.12517303f, -0.15976493f, 0.01661713f, 0.12158789f, -0.36642829f, 0.19499606f, 0.27502006f, 
    0.06718297f, -0.02530214f, -0.23405093f, -0.06393062f, 0.31659174f, 0.05830804f, 0.04491459f, 0.20406520f, 
    -0.20121880f, 0.12760189f, 0.23656934f, 0.14952426f, 0.04913334f, -0.06694915f, 0.17552407f, 0.10209912f, 
    -0.08792266f, 0.14986534f, 0.05254609f, -0.00239770f, 0.12424337f, 0.10677714f, 0.01642658f, 0.04365502f, 
    -0.38285467f, 0.08959766f, 0.06112698f, 0.12864055f, 0.07153961f, -0.26048928f, 0.22461170f, 0.25440389f, 
    0.01058246f, 0.51406980f, -0.14542034f, -0.05166893f, -0.01899584f, 0.02067357f, -0.04443743f, -0.08825450f, 
    -0.00518027f, -0.15076728f, -0.05910627f, -0.10874102f, 0.10649811f, -0.04182362f, -0.28956258f, -0.14977048f, 
    0.19666091f, 0.11779014f, -0.01676289f, -0.16636965f, 0.09535387f, 0.08049408f, 0.09792750f, -0.01571906f, 
    0.29097986f, 0.14948499f, -0.11270486f, 0.06831519f, -0.20142861f, 0.47539458f, -0.04973190f, -0.06842739f, 
    0.18817411f, 0.37095386f, -0.09750729f, -0.35996035f, -0.09788972f, 0.11357547f, -0.10636014f, 0.05193501f, 
    0.14509210f, -0.54531550f, -0.01563202f, -0.05060644f, 0.16334142f, 0.00120898f, 0.25232565f, -0.25034991f, 
    -0.27757835f, 0.16586013f, -0.31405023f, 0.17067572f, -0.10741012f, 0.23740661f, -0.05979352f, -0.13276984f, 
    -0.01385707f, 0.11644256f, -0.10148197f, -0.00089567f, -0.14142804f, -0.02270969f, 0.03306533f, 0.29336792f, 
    -0.12793551f, 0.10950289f, 0.20659290f, 0.12893668f, -0.09991692f, -0.03626468f, -0.40907937f, 0.10634664f, 
    -0.15812977f, 0.42503348f, -0.10767262f, 0.16797480f, 0.21426663f, -0.14802323f, -0.19238493f, -0.13480090f, 
    0.01655542f, -0.00315681f, 0.07879291f, -0.00595646f, -0.08135757f, 0.14091696f, 0.11575684f, -0.07520881f, 
    0.22945307f, -0.16788541f, -0.09386306f, 0.17794695f, -0.24756432f, 0.34446585f, 0.27552408f, 0.00730601f, 
    0.21343821f, 0.13232768f, 0.00618797f, -0.05712937f, -0.07063527f, 0.02072967f, -0.00805729f, 0.26119056f, 
    -0.22330305f, 0.26398057f, -0.29601166f, -0.02041636f, -0.00892245f, -0.02043840f, -0.03373902f, 0.11273452f, 
    -0.01391558f, -0.03444128f, 0.02624887f, 0.38910404f, 0.11229904f, 0.11915499f, -0.59721124f, 0.04012104f, 
    -0.06832284f, 0.03017921f, -0.03699604f, 0.10745715f, -0.10571314f, 0.32410946f, 0.36127326f, 0.11760615f, 
    -0.00629093f, 0.02314951f, -0.16507295f, 0.10839659f, -0.11574801f, 0.00686880f, 0.18605976f, 0.06337649f, 
    -0.15263131f, 0.38201746f, 0.05505373f, 0.12119906f, -0.09010728f, 0.04447677f, 0.20644809f, -0.10841884f, 
    0.05365923f, 0.00043906f, 0.31812811f, -0.03397619f, 0.13551328f, -0.06105093f, 0.11446050f, -0.08037847f, 
    0.19691952f, 0.06002094f, -0.11513138f, 0.04761851f, -0.18008195f, 0.28190738f, 0.32918856f, -0.17613602f, 
    0.53684926f, 0.13971186f, -0.14197110f, -0.10326668f, -0.18672718f, -0.13434485f, -0.12388421f, 0.55255777f, 
    -0.12601472f, 0.05715503f, -0.10217670f, 0.04063830f, -0.13592435f, -0.05537590f, -0.13858637f, -0.08863419f, 
    0.28812996f, -0.09735100f, 0.21486188f, 0.31852439f, -0.04699099f, -0.31329906f, -0.36919600f, 0.08293474f, 
    0.07118690f, 0.01096032f, -0.07762853f, -0.00215383f, -0.03583535f, 0.52326626f, 0.09822208f, -0.03668091f, 
    0.01223098f, 0.18511198f, 0.21338038f, 0.21702904f, 0.09928307f, 0.13028193f, -0.21493766f, 0.27834731f, 
    -0.07524597f, 0.12327944f, 0.10331737f, -0.03429047f, 0.06835692f, 0.10267910f, 0.13509707f, -0.14282759f, 
    -0.04970799f, -0.01309473f, -0.37610164f, 0.08693789f, 0.02556995f, 0.00776058f, -0.05039132f, -0.12575379f, 
    -0.06050227f, -0.07412164f, -0.18484493f, 0.00945336f, 0.14557055f, 0.01018383f, 0.02270630f, 0.31192824f, 
    -0.10954407f, 0.14289641f, -0.12574358f, 0.32466903f, 0.31977355f, -0.14553113f, -0.18793656f, 0.34184220f, 
    -0.03064995f, 0.17862582f, -0.23568584f, 0.06081517f, 0.23883650f, 0.02164629f, -0.11187785f, 0.05452488f, 
    0.01161744f, 0.03359750f, 0.11457419f, -0.25790301f, -0.00008027f, -0.29795194f, -0.30248874f, 0.03484269f, 
    0.18043435f, -0.00204971f, 0.05592878f, 0.06178772f, 0.11199392f, -0.34199703f, 0.02202260f, -0.33643883f, 
    0.24025020f, 0.08484778f, 0.02941074f, 0.10481969f, -0.02166960f, 0.10909347f, -0.22529691f, -0.09157262f, 
    0.38262349f, -0.24858937f, 0.24751990f, -0.09058565f, -0.12190311f, 0.03484963f, -0.34561577f, 0.17117691f, 
    0.09684965f, -0.10473273f, 0.31369841f, 0.24836503f, -0.07544033f, -0.16861267f, -0.00505911f, 0.04578236f, 
    -0.01528237f, -0.16496986f, 0.02169619f, -0.00145021f, -0.05838371f, 0.27418011f, -0.02876403f, 0.25382069f, 
    -0.20253702f, -0.03504408f, 0.10672920f, -0.06037780f, 0.20776367f, -0.08709902f, 0.17652227f, 0.13515186f, 
    -0.21993504f, 0.06197525f, -0.24394052f, -0.00489380f, -0.16140607f, -0.09867549f, 0.17208910f, -0.13151203f, 
    0.01747118f, 0.12512051f, -0.19486642f, 0.04724206f, 0.16612010f, -0.11873032f, 0.29817322f, 0.10089117f, 
    0.14762549f, -0.04481172f, 0.11387673f, 0.08301156f, 0.04064943f, 0.00239563f, -0.08928788f, 0.22280289f, 
    -0.02238651f, 0.06729045f, -0.28371349f, -0.04493412f, 0.08892624f, -0.02823116f, -0.04274098f, 0.07709453f, 
    -0.12371906f, -0.18326852f, -0.07354009f, 0.01626449f, -0.01946944f, -0.08411247f, 0.31414813f, -0.22181244f, 
    0.12371939f, -0.10389023f, 0.15133414f, -0.18445127f, 0.05999603f, 0.18954377f, 0.21257877f, -0.11189854f, 
    -0.06221742f, -0.08204912f, -0.00101377f, 0.11961203f, -0.10478327f, 0.18337941f, 0.02580089f, 0.11287346f, 
    -0.15002598f, -0.03120042f, -0.28106049f, -0.18095151f, -0.14457212f, 0.16187087f, -0.03593477f, -0.11252031f, 
    -0.16647032f, -0.04479702f, -0.12390243f, 0.16290890f, 0.00198763f, 0.00948812f, 0.04778649f, 0.04609716f, 
    0.10754928f, 0.14553165f, -0.10444638f, 0.12307736f, -0.08194683f, -0.17248732f, -0.08119582f, -0.02468334f, 
    0.20927861f, -0.15512726f, 0.07139596f, 0.21509509f, -0.39837399f, -0.23779958f, 0.21586534f, 0.21992455f, 
    0.07778063f, 0.07663414f, -0.05109497f, 0.00109463f, 0.04194396f, 0.00555033f, -0.01107133f, -0.02944038f, 
    -0.08761197f, 0.07967418f, 0.00771016f, 0.04198284f, -0.12396234f, 0.11840846f, 0.39535457f, -0.01184948f, 
    0.30003127f, 0.10880915f, -0.10251075f, -0.18780063f, -0.06092095f, 0.05157629f, 0.20913506f, -0.07008267f, 
    -0.02948082f, -0.12332353f, -0.01990558f, -0.14152658f, -0.18574120f, 0.02447967f, -0.01009532f, 0.08505936f, 
    -0.03586263f, -0.08328713f, -0.21176925f, -0.09242950f, -0.08929817f, -0.16852634f, 0.10298390f, -0.20273219f, 
    0.03637175f, -0.15887634f, -0.00935919f, -0.13181025f, -0.13395548f, 0.01733245f, -0.06139144f, -0.00935397f, 
    0.01445463f, 0.07661588f, 0.10768253f, 0.14852318f, -0.00607486f, -0.20447427f, -0.21831425f, -0.01791249f, 
    0.21018566f, 0.11932389f, -0.06966483f, 0.31517664f, -0.08623951f, -0.13180305f, 0.25319824f, -0.28295311f, 
    0.20660540f, -0.25359026f, -0.22090754f, 0.42123809f, -0.13296869f, 0.17048874f, 0.01803741f, 0.07320955f, 
    0.12769020f, 0.05865853f, 0.09587975f, 0.01225334f, -0.13511825f, 0.12878227f, -0.32859567f, -0.03869580f, 
    -0.06991229f, 0.09968460f, 0.18305895f, -0.08255141f, -0.13588059f, 0.02770799f, -0.25198385f, 0.14006671f, 
    0.20966020f, 0.06037879f, -0.00112435f, -0.33262727f, -0.09310567f, 0.19685395f, -0.01539918f, 0.36743960f, 
    -0.15440899f, -0.14934918f, -0.17246267f, -0.14001757f, 0.10814724f, -0.07115910f, 0.34229982f, 0.19286907f, 
    -0.14921831f, 0.27671832f, -0.15048650f, 0.04309480f, -0.46580535f, -0.14809076f, 0.20119916f, -0.18600199f, 
    0.22427563f, -0.08942867f, 0.26265657f, -0.05237327f, 0.05691883f, -0.00087151f, 0.42513272f, 0.01226200f, 
    0.12676425f, -0.00249512f, -0.18689960f, -0.31128776f, 0.21469769f, 0.02399113f, -0.27301463f, -0.04856016f, 
    -0.07988735f, -0.01395576f, -0.23062222f, 0.04487356f, 0.14616147f, -0.15233141f, -0.30610740f, 0.05993665f, 
    0.15270732f, -0.37202603f, 0.31166217f, -0.12229075f, -0.07627624f, -0.09463611f, -0.36184704f, 0.11660199f, 
    0.07511028f, -0.02732170f, 0.44591638f, 0.07035811f, -0.13892092f, 0.13701954f, -0.04224815f, 0.11193688f, 
    0.04773045f, 0.14209186f, -0.10582857f, 0.22401100f, -0.31951144f, 0.35860521f, 0.33932367f, 0.16099258f, 
    0.19050467f, 0.16477844f, 0.10887642f, 0.04996934f, -0.13064513f, -0.03141697f, -0.07664374f, -0.08300888f, 
    0.00138247f, 0.17756975f, -0.19038156f, 0.01171653f, 0.11408395f, 0.06999607f, 0.28542894f, -0.15339369f, 
    0.02712822f, -0.10652973f, 0.22096422f, -0.15208039f, -0.11432787f, 0.09638532f, -0.20348625f, -0.04378908f, 
    0.15665878f, 0.12346334f, 0.12922977f, -0.19519264f, -0.04609401f, 0.04686388f, -0.27248019f, 0.45115775f, 
    -0.18944272f, -0.13516745f, 0.06149551f, -0.22163479f, -0.09036203f, 0.16282535f, -0.00269209f, -0.20664541f, 
    0.11154652f, 0.10252144f, 0.02995252f, -0.16954497f, -0.11481765f, 0.02727904f, 0.19267580f, 0.10157831f, 
    0.13727994f, 0.06048650f, -0.09443825f, 0.13437127f, 0.08500388f, -0.25999910f, 0.12062673f, 0.14593932f, 
    0.00752265f, -0.08769646f, 0.05612461f, -0.30068815f, -0.14413564f, 0.22624423f, -0.01727427f, 0.12565051f, 
    -0.16915071f, 0.22241443f, -0.27520549f, -0.38370597f, 0.18039890f, -0.11977382f, 0.13641052f, -0.15839644f, 
    0.00132221f, -0.29882202f, 0.26385996f, -0.09859226f, -0.42898113f, -0.11846128f, 0.08834150f, 0.12379366f, 
    0.05719831f, 0.03646912f, 0.30025664f, 0.25069076f, 0.17110664f, 0.46939158f, 0.12849952f, -0.14223759f, 
    0.10760985f, 0.02737110f, 0.07628562f, 0.29993206f, -0.21952461f, 0.06860327f, -0.07718432f, 0.08661229f, 
    0.13120146f, -0.44022039f, -0.26545450f, 0.53519875f, -0.02821145f, 0.11311265f, 0.13712764f, 0.34098700f, 
    0.11002088f, 0.27585298f, 0.09456164f, 0.00565716f, -0.04714409f, 0.14389631f, -0.28004074f, -0.16151936f, 
    -0.01052013f, 0.15020828f, 0.16520336f, 0.07909521f, -0.05211436f, -0.06520567f, -0.21942401f, -0.04066040f, 
    0.09105519f, 0.10098450f, 0.05330012f, 0.16347772f, 0.06665586f, 0.30775839f, 0.13772041f, -0.47823825f, 
    0.00682309f, -0.15646407f, 0.36694983f, -0.12625511f, 0.17028190f, 0.15228754f, -0.02764996f, -0.29762399f, 
    0.26539594f, -0.18845858f, 0.15968020f, 0.17759532f, -0.21703236f, 0.15526976f, -0.34425676f, 0.06434344f, 
    0.04856822f, 0.11936023f, -0.10521074f, 0.26014784f, -0.03205059f, -0.05815436f, -0.06058590f, -0.04314085f, 
    0.21960522f, 0.16111068f, 0.13840492f, -0.23509350f, 0.14315352f, -0.02547796f, 0.03597054f, -0.18452160f, 
    -0.39868352f, -0.24297781f, 0.17703058f, 0.16244173f, 0.04430118f, -0.16382276f, 0.02835306f, -0.13137548f, 
    0.01953565f, 0.10291830f, 0.30189371f, 0.02700645f, -0.01247229f, 0.05705360f, -0.13103604f, 0.16136964f, 
    -0.12509938f, -0.06012918f, 0.42854983f, 0.30458540f, -0.15056773f, -0.01802104f, 0.04680084f, -0.16659443f, 
    0.03341737f, 0.04905814f, -0.06154634f, 0.12896681f, -0.09027242f, 0.30290863f, 0.10152736f, 0.15639059f, 
    0.04116764f, 0.34641317f, 0.03870271f, 0.26320755f, -0.13273226f, 0.09539676f, 0.18616526f, 0.01460475f, 
    -0.18955034f, 0.07492642f, -0.06246924f, -0.05733798f, -0.00613813f, 0.11700826f, 0.37538362f, 0.05414505f, 
    -0.05450099f, -0.16546868f, -0.18975437f, -0.27661777f, -0.15692487f, 0.16618313f, 0.17190665f, 0.12305617f, 
    -0.14465497f, 0.01211083f, -0.17399596f, 0.00066952f, -0.18753965f, -0.19491950f, -0.12479494f, 0.12102000f, 
    0.08744243f, -0.02552672f, -0.18124153f, 0.09896400f, 0.00129429f, -0.16173203f, -0.03399222f, -0.15363047f, 
    -0.19784644f, -0.06397995f, 0.18638432f, 0.09351855f, 0.04738375f, -0.13175052f, 0.11324525f, -0.10637110f, 
    -0.06043364f, 0.11672744f, -0.17216600f, 0.04526294f, -0.12868787f, 0.00562598f, -0.02231941f, -0.16278301f, 
    0.06404369f, 0.04458987f, 0.03170051f, -0.16978680f, -0.14352670f, -0.28482231f, 0.48349357f, 0.06940970f, 
    -0.01205452f, 0.13648903f, -0.20917591f, 0.06393889f, 0.01797853f, 0.03461146f, 0.00513710f, 0.51619852f, 
    -0.13746583f, 0.35365954f, -0.06835368f, 0.10148609f, 0.14057115f, 0.09641973f, 0.22951877f, 0.28109112f, 
    0.10920718f, 0.14056651f, 0.15599842f, -0.05107531f, 0.11906749f, 0.10190713f, -0.04461753f, 0.13737290f, 
    0.19322433f, -0.00029724f, -0.10861343f, 0.17192031f, 0.02963591f, -0.00722615f, -0.04591840f, 0.19202217f, 
    0.18159528f, 0.01030129f, 0.05967863f, -0.10765371f, 0.18018606f, -0.09875986f, -0.24708350f, -0.02962751f, 
    0.17446916f, -0.03088907f, 0.00895930f, 0.08539149f, -0.08183166f, -0.00605286f, 0.35215586f, -0.13408946f, 
    -0.11959796f, 0.09723938f, -0.34432447f, 0.29515910f, -0.10088740f, 0.13916527f, -0.11727229f, -0.11506893f, 
    -0.05512398f, 0.13316908f, -0.08786727f, 0.16767259f, -0.09338390f, 0.51353472f, 0.13463932f, -0.13465573f, 
    -0.06726947f, 0.21035714f, 0.07943783f, -0.03390906f, -0.23101392f, 0.00175299f, -0.23150134f, -0.15424295f, 
    0.14476912f, -0.61251527f, -0.12070745f, 0.07086310f, -0.06663378f, 0.05790123f, -0.27110639f, 0.07823674f, 
    0.36914530f, 0.16787627f, 0.35138962f, 0.32639548f, -0.01721172f, -0.05960815f, -0.05339657f, 0.15687571f, 
    -0.18982971f, 0.12848592f, 0.08208610f, -0.23138836f, 0.11969018f, -0.07879189f, 0.07350567f, 0.23204847f, 
    -0.08198170f, 0.12003855f, -0.06428172f, 0.07731922f, 0.26845232f, -0.03581780f, 0.08842535f, 0.41485950f, 
    -0.27596539f, 0.42514065f, 0.09911868f, -0.02106965f, 0.14199957f, 0.09383436f, 0.06852273f, 0.20044276f, 
    -0.16955115f, 0.17125954f, 0.06734638f, -0.05186902f, -0.07331374f, 0.22661756f, 0.13568866f, 0.07405341f, 
    -0.37765783f, -0.14245605f, 0.11534598f, -0.06930937f, -0.07052469f, 0.11879417f, 0.02968215f, 0.31662375f, 
    -0.17702790f, -0.02441740f, 0.08571667f, -0.14772169f, 0.08152425f, 0.05509997f, -0.09768908f, 0.09321944f, 
    -0.22280611f, 0.24703725f, -0.47801587f, -0.13486412f, -0.48886222f, -0.13363618f, 0.09587847f, -0.25504348f, 
    -0.05814744f, 0.07652669f, 0.08403756f, 0.08993149f, 0.04951268f, -0.14865443f, 0.09860350f, -0.08264218f, 
    -0.00791814f, -0.07497363f, 0.11868053f, 0.04085484f, -0.11341752f, 0.53589839f, 0.08661260f, 0.11922087f, 
    -0.19764683f, 0.03104685f, -0.03879416f, 0.07456705f, -0.02530930f, 0.14342019f, 0.05346407f, 0.28132647f, 
    -0.16050176f, 0.29315165f, 0.03217387f, -0.06903242f, -0.00229921f, 0.15329739f, 0.23263389f, 0.17125805f, 
    -0.10570429f, -0.14170504f, 0.38704690f, -0.20536861f, 0.13411245f, 0.05230667f, 0.03468722f, 0.16325569f, 
    0.21528606f, -0.07198995f, 0.07011567f, 0.17078418f, 0.02705991f, -0.30643335f, 0.29620054f, -0.29023078f, 
    0.34622663f, -0.01337616f, -0.21794678f, 0.08249758f, -0.22409965f, -0.08249553f, -0.06519003f, 0.23935322f, 
    0.06571903f, -0.10176800f, 0.21347520f, -0.17715050f, 0.07195482f, -0.07788736f, -0.05141981f, -0.27858788f, 
    -0.04285972f, 0.12970991f, 0.31876507f, 0.09633077f, 0.04194601f, 0.07673167f, -0.11921411f, 0.04045960f, 
    -0.00235984f, -0.00455598f, -0.02005222f, -0.07015479f, -0.05994080f, -0.01321926f, -0.14202183f, -0.08522306f, 
    -0.19865176f, -0.09287875f, -0.07576208f, 0.14154418f, -0.03801211f, 0.15448955f, -0.13613620f, 0.03182191f, 
    0.04642994f, 0.11341183f, -0.19662647f, 0.06969474f, 0.15845419f, -0.10501129f, -0.07356610f, -0.09414138f, 
    -0.05262538f, 0.07143567f, -0.15494248f, 0.02717877f, -0.08105853f, -0.13193013f, -0.10782376f, -0.07677153f, 
    0.23744473f, -0.15442505f, 0.05624706f, -0.02483184f, -0.23756762f, -0.06258019f, 0.48957467f, 0.00790988f, 
    0.31096590f, -0.11814331f, 0.06186898f, -0.09027287f, -0.11344645f, 0.04072667f, -0.00060159f, 0.00450207f, 
    0.06760550f, 0.18166675f, -0.03041648f, 0.16196154f, -0.08988656f, -0.05881592f, 0.21822275f, -0.13062763f, 
    0.15467516f, -0.03394214f, -0.07123917f, -0.14237417f, -0.16192546f, 0.16782328f, 0.15454279f, -0.17054969f, 
    0.11871240f, -0.12278013f, -0.00576059f, -0.48737457f, 0.41219145f, -0.08187077f, 0.00523459f, -0.33426893f, 
    0.04099145f, -0.09251161f, 0.01996071f, -0.26030272f, 0.39307976f, -0.16044886f, -0.60884631f, 0.00152115f, 
    0.32309255f, -0.13953021f, 0.27532059f, 0.03788013f, -0.37274265f, 0.00548686f, -0.23549658f, 0.05421454f, 
    -0.31013471f, 0.17936952f, -0.09295006f, 0.42420071f, 0.06954985f, 0.20049469f, -0.28705266f, 0.17499605f, 
    0.24841756f, 0.04135334f, 0.08991417f, 0.00091716f, -0.15802777f, 0.14023262f, 0.01502453f, -0.29328945f, 
    0.02516653f, -0.16301684f, -0.20937119f, 0.50222147f, 0.05098872f, -0.16832018f, 0.19753265f, -0.14602146f, 
    0.03571250f, 0.25783521f, 0.17992412f, -0.16090223f, -0.23937993f, -0.13783385f, -0.09360243f, 0.03813619f, 
    0.12755573f, 0.16585924f, 0.01283290f, -0.21099995f, -0.17149396f, -0.10065784f, 0.16471499f, 0.04622485f, 
    0.28360161f, -0.00035071f, -0.10448486f, -0.18722716f, 0.17987260f, 0.45132706f, -0.28718597f, 0.24500448f, 
    -0.02100695f, -0.15979886f, 0.25768694f, -0.36386481f, 0.20440377f, 0.16737185f, 0.16953383f, -0.09815903f, 
    -0.08861236f, 0.13405304f, -0.03365230f, -0.02501660f, -0.72367918f, -0.03704442f, 0.34383258f, -0.43791476f, 
    0.17827782f, 0.11214435f, -0.10907816f, 0.04948884f, -0.15244995f, -0.22085531f, 0.12206224f, -0.09560244f, 
    -0.04299821f, -0.11856014f, 0.16493814f, 0.17182267f, -0.07061359f, -0.44527131f, 0.33465078f, 0.16872548f, 
    0.03954441f, -0.11961180f, -0.11195580f, 0.07436047f, 0.05753650f, 0.06166491f, 0.00367791f, 0.08290102f, 
    -0.04123767f, 0.24171048f, 0.05140176f, 0.17257938f, 0.07814656f, 0.12928596f, 0.14878553f, -0.11506709f, 
    0.33062622f, -0.16567744f, 0.31002316f, -0.24638927f, 0.06723346f, 0.01910117f, 0.17726731f, -0.07796399f, 
    -0.22779718f, 0.08963832f, -0.07251534f, -0.06325435f, -0.06007287f, 0.05142685f, 0.19714659f, 0.44496247f, 
    -0.03468856f, 0.17743410f, -0.27492028f, -0.20203653f, 0.14352071f, -0.15467083f, 0.35091677f, -0.05251946f, 
    -0.17629047f, 0.23310539f, -0.03731850f, 0.16018103f, 0.03819994f, 0.02470562f, -0.00868343f, -0.61186403f, 
    0.22858512f, 0.05624001f, 0.18307318f, 0.05816134f, 0.05237117f, 0.19152273f, 0.20361580f, 0.11293995f, 
    0.20944640f, 0.16788080f, 0.17162487f, 0.24465612f, 0.19579656f, 0.17847753f, -0.04580909f, 0.02323003f, 
    0.20648977f, -0.17319085f, 0.30178499f, 0.15050578f, 0.12228248f, -0.08225670f, -0.23060898f, -0.06133544f, 
    0.00329943f, -0.06534221f, 0.14558601f, -0.09095731f, 0.03299790f, -0.02463278f, -0.14971578f, -0.06874426f, 
    -0.02398001f, -0.06256840f, -0.13171229f, -0.32607144f, -0.01088826f, 0.03630619f, -0.27472231f, -0.11227445f, 
    0.17738491f, -0.05279138f, -0.03940045f, -0.25463870f, 0.37808001f, 0.22437212f, -0.25547945f, 0.18699268f, 
    -0.12102065f, -0.44099626f, 0.02248343f, 0.02474474f, 0.31279999f, -0.03155607f, -0.65929681f, 0.32765886f, 
    -0.02923094f, 0.14219806f, -0.17439625f, 0.12710442f, -0.32117987f, -0.04955273f, -0.17994425f, -0.21880838f, 
    0.14939000f, -0.01773916f, 0.06803264f, 0.15581107f, -0.09232494f, -0.46590003f, -0.28642389f, 0.07538717f, 
    0.26085973f, 0.06036140f, -0.15496734f, 0.27578065f, -0.24220684f, 0.08222357f, 0.08277951f, 0.19313712f, 
    0.33810011f, 0.24573117f, 0.20797746f, -0.35376966f, -0.11273092f, -0.14845933f, -0.07173068f, -0.08595771f, 
    0.11612049f, -0.25667390f, -0.17022443f, -0.03662561f, -0.12610598f, -0.07869001f, 0.38198087f, -0.46572125f, 
    0.45216191f, -0.05265447f, 0.04832141f, -0.00515044f, -0.16855523f, 0.10433183f, -0.05548992f, 0.07828955f, 
    -0.26609066f, 0.02678506f, 0.03027580f, 0.22944196f, -0.16236229f, -0.02037466f, 0.00477505f, 0.28571963f, 
    0.18216966f, 0.36552420f, -0.38091803f, 0.00316110f, 0.03863735f, -0.12389554f, -0.05426070f, 0.13734639f, 
    -0.02143219f, -0.32084346f, 0.10561546f, 0.03464159f, 0.01081256f, 0.10106410f, -0.24315733f, -0.25457224f, 
    0.24444190f, 0.08582159f, -0.10077515f, 0.09093285f, 0.06023945f, 0.01002806f, 0.15955973f, 0.09785257f, 
    -0.18920243f, -0.14653243f, -0.10592565f, 0.05974076f, 0.10006899f, -0.16067910f, -0.09632463f, -0.20706277f, 
    0.07458209f, -0.18915837f, -0.11731192f, -0.09808897f, -0.16031501f, 0.05587393f, 0.03759863f, -0.18469788f, 
    0.00118470f, -0.05916244f, 0.11994933f, -0.11619658f, -0.04433377f, 0.09502443f, 0.20660631f, 0.00560442f, 
    0.01863281f, -0.11499135f, -0.14261915f, -0.02919563f, 0.01389276f, -0.21808948f, 0.10659201f, 0.13619180f, 
    0.38065147f, -0.14291631f, -0.07397316f, 0.13656490f, -0.31968009f, 0.15938962f, 0.16164036f, -0.21577595f, 
    0.00725453f, -0.19582087f, -0.14449239f, 0.28566253f, -0.13389921f, -0.15039034f, 0.07845432f, 0.00406614f, 
    -0.12977946f, 0.22019681f, 0.15294774f, -0.07169864f, -0.02981081f, -0.07090335f, 0.11138003f, 0.02076726f, 
    0.26337436f, -0.06930252f, 0.30173793f, -0.06715965f, -0.09531546f, -0.12613986f, 0.16748965f, -0.08339565f, 
    -0.07421863f, -0.16669577f, 0.08326856f, -0.12938611f, 0.11534975f, -0.13525970f, -0.11560177f, 0.11054728f, 
    -0.07761727f, -0.00705315f, -0.10384822f, -0.08449213f, -0.14097881f, 0.02332658f, -0.01512472f, -0.01872762f, 
    -0.11961693f, 0.12659028f, -0.06290078f, 0.14080091f, -0.07255570f, -0.13647279f, -0.12060750f, 0.05268832f, 
    0.02169830f, 0.13154556f, -0.11348981f, 0.00984017f, -0.18277693f, -0.01871109f, -0.15362900f, 0.12302098f, 
    0.15812805f, 0.08044734f, 0.09667926f, -0.00602394f, -0.16762358f, -0.05807053f, 0.28452468f, -0.06780021f, 
    -0.02584943f, -0.07173249f, 0.29161805f, 0.15438433f, -0.11088385f, 0.15552661f, 0.02108013f, 0.03483101f, 
    0.02977979f, 0.38341096f, 0.20481637f, -0.05994498f, -0.07288759f, -0.00711446f, 0.27193502f, -0.06887519f, 
    -0.11530337f, -0.09067746f, 0.08398557f, 0.17534430f, 0.01057787f, 0.22505611f, -0.00034392f, 0.02892634f, 
    0.41193944f, -0.02389204f, 0.11817415f, 0.12206040f, -0.15375318f, 0.32016671f, -0.09446124f, -0.35164091f, 
    -0.02632168f, -0.03785060f, 0.30988836f, 0.30707836f, 0.14902478f, 0.07630459f, -0.24288066f, 0.14604485f, 
    0.05879981f, -0.07957736f, 0.10843857f, 0.14248164f, -0.34832555f, 0.10040472f, -0.16288844f, 0.19912590f, 
    -0.07157388f, 0.16003780f, 0.14643893f, -0.14094242f, 0.18462130f, -0.05390271f, -0.09019246f, 0.08201379f, 
    -0.09058321f, -0.07585510f, -0.15490797f, 0.05520962f, 0.02957122f, -0.06874862f, 0.11344618f, -0.10365543f, 
    -0.09993092f, 0.04158911f, -0.09439955f, 0.11458951f, -0.17328495f, 0.14541590f, 0.00437831f, 0.01232722f, 
    0.06712069f, -0.00140331f, -0.18435881f, -0.10017054f, -0.03666316f, 0.16368265f, 0.15663338f, -0.20211971f, 
    -0.10181950f, -0.10903996f, -0.07420787f, -0.09630261f, 0.17244914f, -0.18855019f, -0.16357239f, -0.05188827f, 
    0.10349972f, 0.02189059f, 0.06443670f, -0.30244583f, -0.09960606f, -0.31771401f, 0.15713125f, 0.18960392f, 
    -0.14960198f, -0.31312370f, -0.01447425f, -0.18394922f, 0.09363489f, -0.02799148f, 0.08107456f, -0.01308111f, 
    -0.05795084f, 0.30110589f, 0.03977754f, 0.14586212f, -0.06239836f, 0.07314129f, 0.07187707f, 0.20579582f, 
    0.15329665f, 0.15268682f, 0.13990864f, 0.31077611f, 0.04346112f, 0.23390575f, 0.33726531f, 0.05683361f, 
    0.28379524f, 0.03358536f, -0.03692560f, 0.15964068f, -0.04436065f, 0.18178698f, -0.06843775f, -0.13054301f, 
    0.35819376f, 0.02112123f, 0.23019947f, -0.01053429f, -0.03056363f, -0.02786567f, -0.14726053f, 0.00752723f, 
    0.32465163f, -0.41520801f, 0.19598557f, -0.04562063f, -0.13758631f, 0.01653983f, 0.28697598f, 0.05272042f, 
    0.35486215f, 0.12440614f, 0.18594123f, -0.11029300f, -0.03189615f, -0.05395143f, 0.05649171f, -0.06580975f, 
    0.24046455f, 0.04715719f, 0.04263882f, 0.07882180f, -0.04023561f, -0.43593809f, 0.13501918f, -0.00816294f, 
    -0.06720489f, -0.18198292f, -0.19874948f, -0.05023921f, -0.01973766f, -0.11755522f, 0.01121194f, 0.15295827f, 
    -0.06897439f, 0.16255371f, -0.16309537f, 0.08335356f, -0.02951276f, -0.04766534f, 0.36726031f, -0.02047102f, 
    0.26468515f, -0.10617290f, 0.22648448f, -0.03936733f, 0.09740499f, 0.05527523f, 0.20902473f, 0.07780080f, 
    0.23026849f, -0.10501162f, -0.11447564f, -0.14976114f, -0.01650868f, 0.09670477f, -0.03915066f, 0.11619424f, 
    0.20836383f, 0.34772336f, 0.02955855f, -0.08744910f, 0.08185845f, 0.11335519f, -0.17717609f, -0.07132638f, 
    -0.17389324f, 0.11928418f, 0.13459657f, -0.00804455f, 0.16736060f, 0.06531089f, 0.15904951f, -0.07870102f, 
    -0.33086285f, -0.15223514f, 0.10013946f, -0.41570070f, -0.16898303f, 0.10254435f, -0.25794870f, -0.15330079f, 
    0.30824912f, -0.13928257f, -0.02250776f, 0.20811793f, -0.08978383f, -0.44364136f, 0.06849010f, -0.32081658f, 
    0.27770790f, -0.05680346f, 0.05562515f, 0.32096818f, -0.10111985f, -0.15818232f, 0.25404853f, -0.11093648f, 
    0.21787210f, 0.02059887f, 0.18078545f, -0.01369790f, -0.19719236f, -0.10852518f, 0.31208602f, -0.16200298f, 
    -0.09522960f, 0.03154137f, 0.37919447f, -0.12485636f, -0.04738108f, 0.26026624f, 0.20907563f, -0.13344450f, 
    -0.22333993f, 0.08808296f, -0.11890655f, -0.01129586f, -0.16592513f, -0.22577922f, 0.37677720f, -0.27989072f, 
    0.46503043f, 0.35341212f, -0.01506185f, -0.15371880f, 0.16899753f, 0.01551299f, -0.26057482f, 0.04936673f, 
    0.21514046f, -0.36248478f, 0.10544216f, -0.08072883f, 0.23545627f, -0.10798640f, -0.15579602f, 0.03332205f, 
    -0.06886520f, -0.00598390f, 0.06449331f, 0.22720446f, -0.14160408f, 0.02305382f, -0.00595494f, -0.03793119f, 
    -0.00554881f, -0.14634930f, 0.14134307f, -0.21521719f, 0.06022463f, -0.32041493f, 0.10205605f, -0.20367798f, 
    0.28738385f, -0.12492940f, 0.10495557f, -0.22266461f, 0.02594923f, 0.01194330f, 0.00783260f, -0.12727551f, 
    0.00650036f, -0.31447616f, 0.04593857f, 0.16014013f, 0.11936945f, -0.11284459f, -0.14007582f, 0.20654294f, 
    0.02880726f, 0.06852836f, -0.06764359f, 0.20269710f, -0.01657693f, 0.08048941f, 0.01006414f, 0.06391656f, 
    0.13613658f, -0.02935755f, -0.13134366f, -0.57832563f, 0.03640722f, -0.21673878f, 0.13007221f, -0.16262642f, 
    -0.10198725f, -0.36049184f, 0.16756983f, -0.58440745f, 0.30816668f, -0.14895663f, 0.05908144f, 0.05828417f, 
    0.03001500f, -0.08417379f, 0.07440767f, 0.17047134f, -0.55576235f, 0.05680348f, -0.07497299f, 0.14739256f, 
    0.20096591f, 0.08192956f, -0.01265723f, 0.35258588f, 0.02355922f, 0.19003826f, -0.04625921f, -0.11458465f, 
    0.17726538f, -0.04457772f, 0.07255811f, -0.26472193f, 0.19579257f, -0.07154742f, -0.17340378f, -0.02894178f, 
    0.00161535f, 0.03896951f, 0.06070372f, -0.03659181f, 0.13971663f, 0.08782566f, 0.11855985f, -0.08910963f, 
    0.13971759f, 0.20024444f, 0.03627583f, 0.10562966f, -0.02335831f, -0.17216590f, 0.20280498f, -0.01517059f, 
    -0.22632720f, 0.05358297f, 0.07421459f, -0.09379630f, -0.16981025f, -0.00927139f, 0.11185151f, 0.09379628f, 
    0.06719349f, 0.12870599f, -0.11124989f, 0.20182191f, 0.10920124f, -0.20013800f, 0.04857225f, -0.01819256f, 
    -0.16482441f, -0.05778720f, -0.14499719f, -0.05361635f, -0.02889766f, -0.13736440f, -0.17292170f, -0.10103151f, 
    -0.20050545f, -0.18604450f, 0.03971020f, 0.17068535f, -0.15018924f, 0.06401451f, -0.00055252f, 0.05018853f, 
    0.00098106f, 0.10630362f, 0.07557379f, 0.14826480f, 0.15869325f, -0.07715030f, 0.14182623f, 0.07139832f, 
    -0.14732692f, -0.00851258f, 0.14619134f, 0.26935747f, -0.10810224f, 0.35295773f, 0.22135520f, 0.32028553f, 
    0.00913413f, 0.35618117f, 0.15271354f, -0.09277801f, 0.03987663f, -0.14581269f, -0.12357640f, -0.18748190f, 
    0.13992584f, -0.17157122f, -0.05829185f, -0.15173702f, -0.22239229f, 0.09573971f, 0.10325483f, -0.24428950f, 
    0.33273849f, 0.03513079f, -0.17723024f, 0.30587736f, 0.06338141f, 0.24451678f, -0.07365241f, -0.08223336f, 
    -0.02969320f, -0.02800857f, 0.15360950f, 0.35549217f, -0.20538016f, 0.31634825f, 0.29291841f, -0.00899123f, 
    0.44298792f, 0.14742900f, 0.09482199f, 0.28631681f, -0.25858641f, 0.00659302f, -0.02180910f, 0.12853481f, 
    -0.19163333f, -0.01544934f, -0.20046793f, -0.00622610f, -0.10280869f, 0.16605948f, 0.00679044f, 0.14645970f, 
    0.28289059f, -0.03277054f, -0.06768881f, 0.13910784f, 0.02722546f, 0.02751492f, -0.17331220f, -0.13862370f, 
    -0.17269287f, 0.06662104f, -0.09496525f, -0.06934550f, 0.23468438f, 0.15920565f, 0.05077117f, 0.32321611f, 
    0.00110874f, -0.26424438f, -0.22649300f, 0.32329571f, 0.06300678f, 0.03342380f, -0.02698116f, 0.28416452f, 
    0.00787261f, 0.58016735f, 0.08154634f, -0.11956233f, 0.13816698f, -0.08280930f, -0.06358733f, -0.01612237f, 
    0.03832312f, -0.06394789f, -0.12181609f, -0.01210618f, -0.04593717f, -0.25072470f, -0.18744464f, -0.10677796f, 
    -0.10614265f, 0.09854981f, 0.02581796f, 0.03627243f, -0.08491490f, -0.13436541f, -0.10047574f, -0.07773677f, 
    -0.13697374f, -0.08411432f, -0.03939105f, 0.11980467f, -0.04794329f, 0.03668580f, -0.08006109f, -0.11316000f, 
    -0.16370474f, 0.03622490f, -0.07113897f, -0.15929319f, 0.00088734f, -0.11557825f, 0.10189798f, 0.08849396f, 
    -0.11897506f, -0.11024422f, -0.04818661f, 0.09288823f, -0.12416754f, -0.10365810f, 0.04942546f, -0.01022595f, 
    -0.05571223f, -0.06207751f, -0.07429664f, -0.16510111f, 0.27233246f, 0.33258894f, -0.20992407f, -0.02159357f, 
    0.05545964f, -0.15630011f, 0.08946159f, -0.17426912f, 0.11764503f, -0.14190127f, 0.03805963f, -0.12187875f, 
    0.22832386f, -0.29162693f, 0.11865623f, 0.12092862f, -0.15963498f, -0.13835184f, -0.41514587f, -0.08616354f, 
    0.04724501f, -0.03640573f, -0.09978217f, 0.35575294f, -0.05074415f, -0.03774894f, 0.01800713f, -0.02067137f, 
    0.19654052f, 0.09094645f, -0.14809644f, 0.05714541f, -0.06101517f, 0.05472859f, 0.22658138f, 0.07889281f, 
    0.32446417f, 0.28888923f, 0.06805787f, -0.60043991f, 0.11692954f, -0.08868866f, -0.15407936f, 0.01467629f, 
    0.20063917f, -0.21831493f, -0.26737067f, 0.03881369f, -0.19607469f, 0.12302022f, 0.37974870f, -0.20942676f, 
    0.41553193f, -0.02107573f, -0.25491253f, -0.12794623f, 0.14486384f, -0.29039338f, 0.11360911f, -0.02161451f, 
    0.16460864f, 0.06847292f, 0.02161076f, 0.09730439f, -0.21344341f, -0.04553698f, 0.26987484f, -0.18727286f, 
    0.29728857f, 0.08949916f, 0.12001822f, -0.27848834f, -0.07648737f, -0.07888730f, -0.36207750f, 0.31459311f, 
    0.01265663f, -0.10362568f, -0.04867884f, 0.10166766f, -0.03857544f, -0.10333034f, -0.41286898f, 0.17427942f, 
    0.13640557f, 0.17343013f, 0.14227156f, 0.33126017f, 0.03017436f, -0.40336710f, -0.61901915f, -0.12046779f, 
    0.14847299f, -0.11677671f, -0.01039447f, 0.28846461f, -0.30531201f, -0.10151326f, 0.31153744f, 0.23974051f, 
    0.50570220f, 0.20537259f, 0.31246516f, -0.17126992f, 0.06475575f, 0.07573780f, -0.08630119f, 0.05181745f, 
    -0.02484954f, 0.02020251f, -0.26234022f, 0.13050552f, 0.00212811f, -0.01478764f, 0.16058876f, -0.35151756f, 
    0.16126353f, 0.04075604f, -0.42265114f, 0.07178386f, 0.03337487f, 0.01961637f, 0.05760574f, 0.07842494f, 
    0.16292626f, -0.09560660f, 0.14107761f, 0.26250732f, 0.08897228f, 0.57061946f, -0.03506918f, 0.09136229f, 
    0.08593962f, 0.39799976f, 0.20820887f, 0.06525785f, -0.00272363f, 0.12908068f, -0.15540059f, 0.07071513f, 
    0.10416667f, -0.22055808f, 0.05925243f, 0.01487303f, 0.02208871f, 0.11694912f, -0.08615312f, -0.48777556f, 
    -0.17111437f, -0.06658727f, -0.17647605f, -0.23360607f, -0.10018989f, 0.09895121f, -0.10823136f, -0.12764055f, 
    -0.03937704f, -0.12146603f, 0.11253643f, -0.21924108f, 0.12452693f, -0.33808333f, -0.22569405f, 0.00658715f, 
    0.14282838f, -0.21074198f, 0.14404555f, 0.08886866f, 0.39857614f, -0.05767507f, -0.29673916f, 0.03670011f, 
    0.09369289f, -0.01630986f, 0.24314231f, -0.12029021f, 0.10608761f, -0.14323090f, -0.40852517f, 0.17034096f, 
    -0.27765551f, 0.03238274f, 0.25523472f, 0.29402202f, -0.03049272f, 0.14069849f, -0.19401102f, -0.13918883f, 
    -0.21638404f, 0.12361178f, 0.00860618f, -0.08383981f, -0.10052726f, -0.09755456f, -0.01170408f, 0.03957614f, 
    0.06363005f, 0.06187838f, 0.00690815f, -0.07919292f, 0.27987921f, 0.00707083f, -0.25971583f, 0.25933358f, 
    0.05515318f, -0.22269444f, 0.26321805f, 0.14693934f, -0.18566403f, 0.00270973f, -0.47543940f, 0.25252455f, 
    0.09529180f, -0.15194605f, -0.21569262f, 0.56745034f, 0.10959572f, 0.22742629f, -0.36828017f, -0.04718822f, 
    0.16237679f, 0.02054046f, -0.15553986f, -0.12106961f, 0.11313738f, 0.26364857f, -0.35202026f, 0.20965005f, 
    -0.20394604f, -0.29413638f, -0.17474280f, 0.54365510f, 0.22944279f, -0.00738419f, -0.07107606f, 0.21708778f, 
    0.05893846f, 0.34320772f, 0.12608422f, 0.08056913f, -0.27803215f, -0.08888677f, 0.09176168f, -0.13125972f, 
    -0.27457047f, -0.10518526f, 0.27055773f, -0.02751371f, 0.08394176f, -0.15179893f, 0.12264176f, -0.14662549f, 
    0.00959022f, -0.09003481f, 0.11524624f, 0.09561498f, 0.16902664f, 0.04669307f, -0.05308463f, 0.12197458f, 
    -0.23512396f, -0.00510679f, -0.36508739f, 0.33350798f, 0.01871163f, -0.17237803f, 0.09304553f, 0.20579922f, 
    -0.06817447f, 0.20270318f, 0.03686390f, 0.15659507f, -0.05233524f, -0.14550994f, 0.01866601f, 0.12849763f, 
    -0.34420571f, -0.00201779f, 0.30887711f, 0.03464336f, -0.13595776f, -0.16082700f, 0.19155736f, -0.09091955f, 
    0.17205405f, 0.06009631f, 0.03314843f, -0.10462219f, 0.01490277f, -0.28068265f, 0.16532679f, 0.21840975f, 
    0.26134977f, 0.05627842f, 0.10384541f, -0.33728519f, 0.04288296f, -0.02069231f, -0.26342142f, 0.20658812f, 
    0.12155264f, -0.25304279f, -0.01521203f, -0.15086375f, 0.15495770f, -0.14131068f, -0.02008079f, -0.07690565f, 
    0.14761694f, -0.01893921f, -0.38025522f, 0.16239600f, 0.05556610f, -0.12889108f, 0.17385131f, -0.12458467f, 
    0.06959250f, -0.10619280f, -0.08447497f, -0.16920267f, -0.13218266f, 0.14216062f, -0.11918511f, -0.07814264f, 
    -0.11012866f, 0.02908829f, -0.20574978f, -0.15658660f, 0.03201038f, 0.02268826f, 0.03738108f, 0.06260609f, 
    -0.18422590f, 0.07542653f, 0.02564869f, -0.14574720f, 0.08569712f, -0.11422782f, -0.07655639f, -0.13694383f, 
    -0.15358348f, 0.08301007f, -0.05906453f, -0.12028115f, -0.07335682f, -0.14425226f, -0.17315730f, -0.15175807f, 
    -0.14240673f, -0.06516268f, 0.02088464f, 0.16720022f, 0.12264044f, 0.13423797f, 0.17642318f, -0.19191673f, 
    -0.20495935f, -0.15081602f, 0.19803159f, 0.01207997f, 0.02273657f, 0.16070484f, -0.04996358f, 0.04784659f, 
    -0.15765771f, 0.08766752f, 0.10930979f, -0.12133321f, 0.07410163f, 0.16434644f, 0.15127407f, -0.10909953f, 
    -0.11801820f, -0.14059456f, -0.10306752f, 0.22280703f, -0.02747805f, -0.04546856f, 0.05333949f, 0.15597333f, 
    0.30589062f, -0.11151175f, -0.09531111f, -0.06450135f, 0.04355624f, 0.02912571f, -0.23974919f, -0.16354477f, 
    -0.20030932f, -0.34007737f, 0.14183547f, -0.10343275f, 0.26592705f, 0.18442799f, 0.09750395f, -0.00523387f, 
    -0.05803225f, -0.27621555f, 0.05933397f, 0.05526213f, -0.40189356f, 0.15257201f, 0.43254983f, -0.12226043f, 
    0.07382441f, -0.17554404f, -0.11868392f, -0.11297902f, 0.09501436f, 0.12522161f, 0.22748163f, -0.01827041f, 
    -0.06137931f, 0.15567750f, 0.09381729f, -0.16614737f, 0.15795772f, -0.39943391f, -0.13629027f, 0.28267685f, 
    0.22487438f, -0.11149643f, -0.07359879f, 0.07324294f, 0.25805888f, 0.05045423f, 0.01821909f, 0.06849888f, 
    -0.00008449f, 0.29613814f, 0.07667398f, 0.02699633f, 0.09499062f, 0.04871894f, 0.22097421f, -0.19330627f, 
    -0.15485236f, 0.16500497f, 0.02510747f, -0.22057709f, -0.03924220f, 0.13668080f, 0.03788597f, -0.02574752f, 
    0.15415405f, 0.05431121f, -0.10221755f, 0.03099308f, -0.02809803f, -0.05027778f, -0.12877044f, 0.10954361f, 
    -0.10321055f, 0.02545451f, -0.17995130f, -0.11347372f, -0.07859851f, -0.14950100f, -0.12674439f, -0.06963696f, 
    -0.20740044f, 0.05334847f, 0.18169826f, 0.02660629f, -0.09875762f, -0.15185532f, -0.03660228f, 0.05884110f, 
    -0.06666850f, -0.06452642f, 0.04317185f, -0.00855044f, 0.09588318f, -0.11807981f, -0.02916761f, -0.11192637f, 
    0.32597584f, -0.13501501f, -0.01653071f, 0.03773207f, 0.18055721f, 0.11480755f, 0.08647332f, -0.22317490f, 
    0.14947422f, -0.32160068f, -0.01785463f, 0.35552552f, 0.19152427f, 0.11427239f, -0.53868765f, 0.47175163f, 
    0.01870297f, 0.19124676f, 0.08574206f, 0.08916131f, -0.36461672f, -0.12487954f, 0.09111109f, -0.14474376f, 
    -0.30367711f, -0.00073849f, -0.06170195f, 0.30398819f, 0.08299627f, -0.53115773f, -0.65624130f, -0.09088005f, 
    -0.32182986f, 0.11598531f, 0.14044364f, 0.16111152f, 0.04239055f, -0.26107493f, 0.10766302f, 0.30881378f, 
    0.12092787f, -0.18750535f, 0.12704843f, -0.06736591f, 0.22465163f, 0.02258647f, -0.16568525f, -0.06821302f, 
    -0.01129176f, 0.12833659f, -0.16596942f, 0.11152436f, -0.13110991f, 0.16985853f, -0.00630247f, 0.20910522f, 
    0.21605265f, 0.01431427f, -0.30579019f, -0.02713284f, 0.07655910f, 0.19271497f, 0.04127840f, 0.06369014f, 
    -0.06956550f, -0.02546327f, -0.04367892f, -0.18721566f, -0.18856889f, 0.11553074f, 0.44596753f, 0.39648476f, 
    0.21829931f, 0.04081403f, -0.16089864f, -0.07098939f, -0.08135504f, 0.03964764f, -0.06253658f, 0.35038477f, 
    -0.03269154f, 0.25627935f, -0.12933345f, -0.06601304f, 0.20973673f, -0.00072709f, 0.16611123f, -0.21287511f, 
    0.24804293f, -0.04618451f, -0.02358573f, 0.24859488f, -0.09967694f, 0.08027545f, 0.13635851f, 0.18148454f, 
    -0.01848708f, 0.05218265f, -0.12014549f, -0.22672747f, 0.27549219f, 0.16673532f, -0.24801511f, -0.23000969f, 
    -0.08125217f, 0.10776175f, -0.10542896f, 0.36276901f, 0.37016702f, 0.13481328f, -0.06665809f, 0.06014774f, 
    -0.07706143f, 0.06421541f, 0.43594578f, 0.17543289f, -0.26603061f, -0.11751270f, 0.03959987f, -0.32629162f, 
    -0.36854169f, -0.11477657f, 0.18024242f, -0.08132233f, -0.19562243f, -0.03258177f, 0.03038520f, 0.12470261f, 
    0.19092141f, 0.09682725f, 0.13953100f, 0.06975309f, 0.20168094f, -0.04788046f, -0.22480094f, -0.10027476f, 
    0.01926300f, -0.12095480f, 0.12620667f, -0.05206210f, 0.23473433f, -0.04197844f, -0.20259096f, -0.05794009f, 
    0.21589026f, -0.14583454f, 0.11461738f, 0.14360680f, -0.09380554f, -0.11184366f, -0.28951779f, -0.06578514f, 
    -0.13920020f, -0.12016959f, 0.14025074f, -0.32837743f, 0.06990194f, -0.12439230f, -0.06111433f, -0.05361622f, 
    0.03318929f, 0.01017404f, -0.14640759f, -0.08717103f, -0.16389546f, 0.08510882f, 0.02604626f, -0.15026963f, 
    -0.03233176f, 0.05354262f, -0.16669679f, 0.13835254f, -0.02902214f, -0.08509501f, 0.08746813f, 0.00801794f, 
    -0.00261377f, -0.14559262f, -0.11222453f, 0.14566891f, 0.19738883f, 0.13321391f, -0.05999503f, -0.03022075f, 
    0.16724899f, 0.01767529f, 0.18488707f, 0.00148317f, 0.03276268f, -0.08004976f, -0.00936838f, 0.15575464f, 
    -0.26559988f, 0.16202688f, -0.06918307f, 0.14428274f, 0.06803662f, -0.38172823f, 0.14684066f, 0.12541096f, 
    0.35055828f, 0.09559663f, -0.26322269f, 0.05004992f, 0.28973198f, -0.06371415f, -0.14091022f, 0.21413873f, 
    -0.03647861f, 0.14242616f, 0.14543408f, -0.11709160f, 0.11865930f, -0.11522272f, 0.03981964f, 0.00603179f, 
    -0.07508056f, -0.05182958f, -0.24915010f, 0.00560967f, 0.00420184f, 0.14219707f, -0.11579792f, -0.00184958f, 
    0.35794023f, -0.13709924f, 0.01813603f, 0.17379978f, -0.13869630f, -0.18590313f, 0.25829589f, -0.26992336f, 
    0.10971759f, -0.27791399f, -0.20397173f, 0.21978433f, -0.17089114f, -0.11333821f, 0.04482573f, 0.19046399f, 
    0.05555878f, 0.16860279f, -0.02197635f, 0.08775572f, -0.11219542f, 0.11341703f, -0.14290074f, 0.10439587f, 
    -0.01951252f, 0.15700614f, 0.23218334f, -0.03220375f, -0.04389035f, -0.24842966f, -0.21713643f, 0.06491684f, 
    -0.11620218f, -0.08150076f, -0.05966020f, 0.02635322f, 0.07193291f, 0.36184713f, -0.13066939f, 0.08139132f, 
    0.04224178f, 0.12401324f, -0.21896382f, 0.06068292f, 0.04392552f, 0.01931813f, 0.10691969f, 0.03023076f, 
    0.17946360f, -0.39557624f, 0.24133314f, -0.03490300f, -0.01269676f, 0.15108709f, 0.08391102f, -0.18688349f, 
    0.12789913f, 0.10225032f, -0.03991649f, 0.27079809f, -0.00579799f, 0.14428137f, -0.01640281f, 0.07422480f, 
    -0.13450439f, -0.07009938f, -0.01295114f, 0.03254967f, -0.10082960f, 0.04514381f, -0.12293480f, 0.07251543f, 
    0.08066079f, -0.16433889f, -0.09436195f, 0.12033761f, -0.14087874f, -0.17557725f, -0.07081418f, -0.03990592f, 
    0.10225995f, 0.01111638f, 0.04816955f, 0.01007721f, 0.03406287f, 0.01648283f, -0.16676006f, -0.02135154f, 
    -0.14554136f, -0.04920402f, -0.18556558f, 0.14573243f, 0.12220173f, -0.00825436f, -0.03840982f, 0.14424978f, 
    0.24616621f, 0.08439722f, -0.11751153f, -0.15510187f, 0.05726498f, -0.29918781f, 0.25738695f, 0.27165312f, 
    0.03152309f, -0.22972307f, 0.20337491f, -0.18655583f, 0.04116589f, -0.06133219f, -0.10001977f, 0.08559014f, 
    0.09283845f, 0.28741792f, -0.13236482f, -0.05680408f, 0.14190623f, 0.05774880f, -0.04588554f, 0.07182121f, 
    0.06637836f, 0.06208239f, -0.40754548f, 0.21330088f, -0.12285553f, -0.06033101f, 0.00854519f, -0.16425127f, 
    -0.09838700f, -0.06793349f, 0.15469876f, -0.17178069f, 0.03480946f, 0.04401743f, 0.32953602f, 0.16652818f, 
    0.29144952f, 0.00452465f, 0.28696656f, 0.25597885f, -0.21584797f, -0.01619374f, 0.05507309f, 0.00035786f, 
    -0.01695294f, 0.28862163f, 0.16594243f, -0.15205076f, 0.04974537f, -0.02852451f, 0.02585951f, 0.00614584f, 
    0.01486431f, -0.10097333f, -0.14148559f, 0.06771503f, -0.11019886f, 0.11644760f, -0.17824888f, 0.01726914f, 
    0.08306511f, 0.18672182f, -0.09510940f, -0.26223856f, -0.15998189f, 0.13239914f, 0.35561463f, -0.00786836f, 
    -0.12963088f, 0.02354463f, 0.15269095f, -0.21439195f, -0.03814254f, -0.10852722f, 0.09039211f, 0.02825347f, 
    0.05128233f, 0.11584651f, 0.17018060f, 0.02778166f, -0.02636359f, -0.11200903f, 0.10127535f, 0.23098278f, 
    0.09928214f, 0.16000003f, -0.04670564f, 0.23735408f, -0.11019609f, 0.17341635f, 0.02782130f, 0.15339352f, 
    0.03248310f, -0.03299256f, 0.13682400f, -0.06463879f, -0.23939951f, -0.20084377f, 0.45461321f, 0.15721516f, 
    0.33763316f, 0.19115600f, -0.13582970f, 0.11350850f, -0.04630347f, -0.07205812f, 0.09515020f, 0.42026684f, 
    -0.14576063f, 0.20794047f, -0.13676599f, -0.08983217f, -0.06197182f, 0.09423392f, -0.08526046f, 0.06112931f, 
    0.25432432f, 0.07764515f, 0.03427688f, 0.09104859f, 0.00481842f, -0.11564977f, -0.17283358f, 0.05670713f, 
    0.18979587f, -0.15715341f, 0.13534166f, -0.20850384f, 0.26727813f, -0.14141995f, -0.21369219f, -0.27200249f, 
    0.10613120f, -0.10668808f, 0.13154495f, 0.22838973f, 0.23758335f, 0.08921060f, -0.33559483f, 0.24086033f, 
    0.26273894f, -0.06323859f, 0.17616029f, 0.08603002f, -0.22153538f, -0.14032549f, -0.09954114f, -0.15939039f, 
    -0.28109521f, 0.02243411f, -0.04744153f, -0.01063488f, -0.12001334f, -0.04808025f, -0.03604912f, 0.10252218f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02866448f, 0.04359258f, 0.18474342f, 0.30110344f, 0.29826617f, -0.03503897f, 0.11018649f, 0.14672183f, 
    0.11842396f, -0.04314508f, 0.04340414f, -0.10821559f, 0.03418876f, -0.05331376f, 0.04363782f, 0.09023680f, 
    -0.04816529f, 0.12172457f, -0.04991850f, 0.23475204f, 0.11642769f, 0.25929973f, 0.17798726f, 0.18755023f, 
    0.01942964f, 0.12782121f, 0.41335106f, 0.21859446f, 0.19596559f, 0.17844462f, 0.07648382f, -0.07733674f, 
    0.17532378f, -0.06934251f, 0.21156871f, 0.00459679f, 0.22528505f, 0.00359381f, 0.19934350f, 0.04603574f, 
    0.30324343f, -0.17867276f, 0.06975993f, 0.19287854f, -0.22010732f, 0.09701492f, -0.18169986f, 0.01862015f, 
    -0.20464459f, 0.25254756f, -0.28695256f, 0.10423616f, -0.14917320f, -0.11057899f, 0.10171434f, -0.00993733f, 
    0.07413241f, 0.01201556f, -0.10744644f, -0.18474559f, 0.11734620f, 0.27749345f, -0.11612579f, -0.10537525f, 
    -0.02955246f, -0.06624426f, 0.13377731f, -0.06059920f, -0.10474285f, 0.24362044f, 0.20403156f, 0.09674194f, 
    0.00133478f, 0.11825854f, 0.28946185f, 0.35033166f, 0.11432024f, 0.15010315f, 0.06659414f, 0.07182459f, 
    0.10025627f, 0.11258280f, 0.07245841f, -0.14702460f, -0.23778275f, 0.19940101f, -0.02592565f, 0.03163001f, 
    0.09401528f, 0.29112947f, 0.08144869f, 0.19686534f, -0.16548668f, -0.01731813f, 0.18520096f, -0.02539566f, 
    0.09765632f, 0.15786457f, 0.23094864f, 0.09712841f, 0.18302578f, 0.04629838f, -0.01708739f, 0.18992029f, 
    0.16353749f, 0.15427537f, 0.12469760f, 0.13428371f, -0.01561043f, -0.20808475f, -0.14852645f, 0.03222410f, 
    -0.13294873f, 0.06251246f, 0.01777962f, -0.01060949f, 0.06127839f, 0.19557682f, -0.04809451f, 0.09031008f, 
    0.09983052f, -0.04524833f, -0.00766578f, -0.03097603f, -0.12778667f, -0.00790003f, 0.25353512f, 0.19151947f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.09733208f, -0.05985244f, 0.07518154f, -0.02015088f, -0.21952899f, -0.32789883f, -0.25515556f, -0.10503202f, 
    -0.14541519f, 0.18932842f, -0.43706220f, -0.12744243f, 0.13582206f, -0.43406382f, 0.01093349f, 0.02199506f, 
    -0.06720552f, -0.20059009f, -0.04195628f, -0.25424343f, -0.17890400f, -0.41559029f, -0.03766391f, 0.01740093f, 
    -0.01768942f, 0.15297572f, -0.06276355f, 0.16843763f, -0.01517137f, -0.62328523f, -0.01944434f, 0.21891578f, 
    0.43860415f, 0.11818046f, 0.03031877f, -0.09517459f, -0.07256916f, 0.23024583f, 0.03962276f, 0.16899288f, 
    -0.07652093f, -0.04641317f, 0.05693693f, -0.43048328f, 0.31556341f, -0.00613031f, 0.01810624f, -0.03129296f, 
    -0.00522616f, -0.23016509f, 0.21821083f, -0.23672087f, -0.01940140f, -0.09898058f, -0.05666397f, 0.07218727f, 
    -0.15161334f, 0.09102765f, 0.04785159f, 0.00315277f, 0.05020280f, -0.08582624f, -0.10510726f, 0.16418780f, 
    0.38022912f, 0.18366973f, -0.47588092f, -0.04109208f, -0.17655075f, -0.49330127f, -0.10779935f, 0.26823500f, 
    0.02680744f, 0.28520572f, -0.12765989f, 0.18095426f, -0.27409980f, -0.27743974f, -0.01469134f, -0.09811176f, 
    -0.03581661f, -0.04207086f, -0.44618568f, -0.02871707f, 0.22181877f, -0.55865508f, 0.04559387f, -0.16408896f, 
    -0.35689020f, -0.75187904f, 0.08533370f, -0.07781063f, -0.01336907f, -0.02750592f, 0.09912915f, -0.19524089f, 
    0.14430507f, -0.00525292f, -0.12963587f, -0.28025472f, -0.33740175f, -0.21362086f, -0.41992024f, 0.07606830f, 
    -0.13283980f, 0.17927338f, 0.14989178f, -0.32070032f, -0.05764998f, -0.03715188f, -0.32551545f, 0.03620129f, 
    0.04883431f, -0.06090733f, 0.12493564f, 0.13972321f, -0.11312995f, -0.15830430f, -0.00295401f, -0.01847686f, 
    -0.13347140f, -0.15018472f, 0.07658076f, 0.11035821f, 0.05000972f, 0.00114572f, 0.01096897f, -0.36875057f, 
    0.11595049f, -0.49142674f, 0.13115788f, 0.09703843f, 0.08891308f, 0.09210554f, -0.42666143f, -0.07520677f, 
    -0.38541651f, -0.18463281f, 0.08371127f, -0.17763254f, 0.11123545f, -0.61761349f, -0.02292288f, -0.01687812f, 
    0.00937427f, -0.16080202f, -0.61786354f, 0.04066231f, 0.00796558f, 0.10583111f, -0.08692774f, 0.04382119f, 
    0.01366660f, -0.29044527f, 0.47621390f, -0.04505270f, -0.03731903f, -0.27610606f, -0.01102076f, 0.03472858f, 
    0.12585258f, 0.00029450f, 0.06166029f, 0.22342302f, 0.19382265f, 0.11847532f, 0.07585303f, 0.09962979f, 
    0.10853219f, 0.02575617f, -0.01757688f, -0.15335210f, -0.02032867f, 0.07715137f, -0.10918553f, 0.18605234f, 
    -0.13522874f, 0.00295210f, -0.09091717f, -0.71207786f, 0.12574624f, 0.06843995f, 0.04053013f, -0.07260267f, 
    -0.12151777f, -0.15103815f, 0.01053692f, -0.03840073f, 0.14290245f, 0.10950240f, -0.14376570f, -0.00456632f, 
    -0.40252310f, -0.07963053f, 0.10953809f, 0.03521934f, 0.23256811f, -0.76366860f, -0.23643900f, -0.57081008f, 
    0.11457705f, 0.21734101f, 0.03975612f, -0.37823442f, 0.17095906f, 0.22189572f, -0.17956872f, -0.03794787f, 
    -0.03786131f, 0.03140994f, -0.36139238f, 0.02348823f, 0.08736861f, -0.00306281f, 0.06420039f, 0.04997965f, 
    -0.02250952f, 0.11871035f, 0.05047720f, -0.30852142f, -0.06832487f, -0.01206501f, 0.09157518f, 0.12497547f, 
    0.01494842f, 0.00468530f, -0.16058010f, 0.17419407f, -0.03558350f, 0.37404770f, 0.07051216f, -0.26397622f, 
    -0.12771006f, -0.62095344f, -0.09698911f, 0.13816732f, 0.01799443f, -0.06756721f, 0.22696649f, 0.07572605f, 
    -0.03076101f, -0.37175599f, 0.23071842f, 0.21584830f, -0.51138943f, -0.24714179f, -0.07714912f, 0.13948134f, 
    -0.10216705f, -0.02046937f, 0.06923833f, 0.08189949f, 0.09495017f, 0.02025534f, 0.20615207f, -0.50651133f, 
    0.14778754f, 0.31645867f, -0.25227705f, 0.11619060f, 0.28377143f, -0.19932026f, 0.24036518f, -0.10542705f, 
    0.11012637f, -0.83786553f, 0.13943261f, 0.10910425f, 0.05812311f, -0.14500786f, -0.24084687f, -0.01309426f, 
    0.08191331f, -0.07835972f, 0.14544192f, 0.05221823f, -0.70517343f, -0.00996883f, 0.10706835f, -0.16029124f, 
    -0.21572530f, -0.66974366f, -0.44070700f, -0.05542282f, -0.03430575f, 0.20758390f, -0.15712707f, -0.24080704f, 
    -0.17498842f, -0.12328338f, -0.07114831f, 0.15375800f, -0.08970474f, -0.51378882f, 0.15203755f, -0.26844737f, 
    0.17045654f, -0.03310313f, -0.00639485f, 0.11446904f, -0.19725801f, -0.33686525f, -0.11922868f, -0.39737305f, 
    0.02011274f, -0.17846623f, -0.43961912f, 0.01015259f, -0.54552698f, -0.02409541f, -0.11753638f, -0.28837121f, 
    -0.03048008f, -0.03868356f, 0.12333116f, -0.08759911f, 0.08455617f, 0.04252719f, 0.08784460f, -0.00583543f, 
    -0.21284127f, -0.18782437f, 0.10899451f, 0.01546865f, -0.16610487f, 0.42152968f, -0.47392359f, -0.24042580f, 
    -0.20885211f, -0.73143601f, -0.02389757f, 0.25118184f, -0.21052003f, -0.40900484f, -0.04301934f, -0.34606713f, 
    0.06464229f, -0.14932702f, -0.13066171f, -0.04999906f, -0.08113587f, -0.05714019f, -0.05084580f, -0.33163425f, 
    -0.29180321f, 0.24187694f, 0.15854988f, 0.32665554f, -0.05853086f, -0.06688917f, -0.18877476f, 0.06444477f, 
    -0.08817598f, -0.02926396f, 0.08128081f, 0.04694086f, 0.34320050f, -0.06663024f, -0.37412402f, 0.14992681f, 
    0.32766518f, -0.35384968f, -0.08279793f, 0.13689618f, -0.02925607f, -0.02541186f, -0.59648663f, -0.07696349f, 
    -0.08170393f, 0.32387143f, -0.05140005f, -0.03445184f, -0.22565399f, -0.04691930f, -0.00785302f, 0.03160558f, 
    -0.06265821f, -0.00827322f, -0.00720371f, 0.11801454f, 0.08251371f, 0.06257260f, -0.03285265f, 0.11358725f, 
    -0.02647448f, -0.09037793f, -0.16452202f, 0.22598611f, -0.00492547f, -0.28428382f, 0.20092960f, -0.24690059f, 
    0.15960018f, 0.23921716f, -0.19476070f, 0.03382371f, 0.05760437f, -0.21110567f, -0.85525250f, 0.00344554f, 
    -0.18068072f, -0.21614675f, 0.15951113f, -0.23050210f, -0.53041911f, 0.04267978f, 0.04841975f, -0.02288383f, 
    -0.57200128f, 0.16572051f, -0.18850720f, -0.52821219f, 0.19771929f, 0.09608617f, -0.23881881f, -0.00364970f, 
    0.22835132f, -0.09422179f, 0.11066386f, 0.22604381f, -0.29420969f, -0.13295884f, -0.21200950f, -0.10350554f, 
    0.04412207f, 0.04020911f, 0.14075261f, -0.11304559f, 0.19922571f, 0.18226695f, -0.05193733f, -0.19684035f, 
    0.02125435f, -0.20406754f, 0.02045861f, 0.16359280f, -0.11288214f, -0.79958302f, 0.20065244f, -0.02384715f, 
    -0.26401442f, -0.17742005f, 0.19103786f, -0.03070370f, -0.05831810f, -0.13284805f, 0.03837512f, 0.06519371f, 
    0.15155979f, -0.04351944f, -0.21346293f, 0.04360716f, -0.30963305f, 0.09836527f, -0.32021758f, 0.22254750f, 
    -0.02214091f, 0.10437407f, -0.03232358f, 0.12359369f, 0.04163904f, 0.36149985f, -0.03978195f, -0.32318702f, 
    -0.04360292f, -0.53091002f, -0.23340067f, 0.05655161f, -0.10136943f, -0.03156929f, -0.09521344f, -0.15286750f, 
    -0.41173697f, 0.02069191f, -0.58146912f, 0.24168286f, -0.09288368f, -0.29570061f, 0.14487945f, -0.14476806f, 
    0.05345980f, -0.02303725f, 0.32255945f, 0.16531803f, -0.10345879f, -0.08063672f, 0.15692413f, 0.08918689f, 
    0.15650685f, -0.02029000f, 0.01601496f, 0.00450008f, -0.02935916f, -0.08815021f, -0.52064437f, 0.08953739f, 
    -0.02040743f, -0.04412320f, 0.04798341f, 0.08165742f, 0.12747157f, 0.09662861f, 0.04643765f, 0.09810966f, 
    -0.33753601f, 0.20932710f, -0.01847523f, -0.06861731f, -0.35031196f, -0.21898635f, 0.03937865f, 0.07764854f, 
    0.09166038f, -0.54261482f, -0.03787208f, -0.41594341f, -0.05448247f, 0.05719677f, -0.05031306f, -0.23232418f, 
    -0.04159061f, 0.11451163f, -0.16408092f, -0.08623526f, -0.02671013f, 0.40161106f, 0.03258732f, -0.03765995f, 
    0.05957672f, 0.32381326f, 0.05987822f, -0.03209733f, 0.10395774f, -0.01800513f, -0.04328550f, 0.11400408f, 
    0.01997336f, 0.20845160f, -0.20251389f, -0.13583125f, 0.07042915f, -0.09798191f, -0.12115864f, 0.15762450f, 
    -0.45450106f, -0.07933528f, 0.03348527f, -0.22001666f, 0.09174252f, 0.03532833f, -0.06893127f, 0.11398339f, 
    0.10013413f, 0.00751164f, 0.07881694f, 0.01617339f, -0.39840284f, -0.04731975f, 0.00428927f, -0.30067635f, 
    -0.04256482f, 0.17054127f, 0.00016600f, 0.24442922f, 0.00974201f, 0.10463982f, -0.17259516f, 0.07836201f, 
    -0.23683295f, 0.10297525f, 0.01312465f, -0.01798854f, 0.11497261f, -0.51739526f, -0.06245849f, 0.08234300f, 
    -0.26405251f, 0.15770578f, 0.24353208f, -0.03974425f, -0.04416516f, -0.14486799f, 0.16101831f, -0.21127750f, 
    -0.00043105f, -0.04682962f, -0.05178868f, 0.06430417f, -0.64572006f, -0.42224112f, 0.10916937f, 0.01777729f, 
    0.03686361f, 0.06731262f, -0.02980844f, -0.00132287f, 0.03306874f, -0.02380858f, 0.09877791f, 0.16513723f, 
    0.10792968f, -0.13841435f, 0.00540056f, -0.08676389f, 0.09201884f, -0.12127355f, -0.71445304f, -0.33712634f, 
    0.12954447f, 0.04523301f, -0.22685996f, -0.38465592f, -0.03402572f, -0.60035092f, -0.24306084f, 0.12753452f, 
    -0.21318676f, 0.08265537f, 0.12611824f, -0.18252812f, 0.06201113f, -0.03519565f, -0.57969117f, 0.08312605f, 
    0.01919494f, 0.14812696f, -0.18602331f, 0.02703238f, 0.22041373f, 0.11122875f, -0.03651563f, 0.01710837f, 
    0.15174380f, -0.06387513f, -0.03621123f, -0.07510489f, -0.07763515f, 0.01189001f, 0.02266765f, 0.12938578f, 
    0.01418823f, 0.07814428f, -0.02083985f, -0.13262177f, 0.19703068f, 0.01142098f, -0.03507196f, 0.15523629f, 
    -0.38713676f, -0.15707058f, 0.23606956f, -0.01468345f, 0.01760079f, 0.28858453f, 0.05369810f, -0.07563601f, 
    -0.21815030f, 0.14534877f, -0.06831865f, 0.03216124f, 0.14494403f, -0.04903219f, 0.07747111f, 0.05176241f, 
    0.23127800f, -0.19929658f, -0.08541111f, -0.01868234f, -0.12331455f, 0.04283747f, 0.10469066f, -0.04272503f, 
    -0.65147245f, 0.01263541f, 0.02049629f, -0.30060062f, -0.64515978f, 0.02529860f, 0.23559909f, -0.02870389f, 
    0.19713444f, 0.16593102f, 0.13074283f, -0.10030262f, 0.14137551f, -0.11858418f, -0.13177659f, 0.11856720f, 
    -0.00994176f, 0.13203344f, -0.03444611f, -0.39618900f, 0.09528916f, 0.02808442f, -0.49582499f, 0.11627623f, 
    -0.08658610f, -0.08674318f, -0.02740147f, -0.01400381f, 0.10831723f, -0.03765015f, -0.28952697f, 0.05244785f, 
    0.24905357f, 0.05429288f, -0.04410324f, -0.04308873f, 0.07536697f, -0.70947683f, 0.22084433f, -0.04362873f, 
    -0.03292447f, -0.29585600f, 0.14103693f, -0.07593638f, -0.11820066f, -0.05400537f, -0.07122070f, 0.04552802f, 
    0.03592134f, 0.01078030f, 0.16666856f, -0.03674106f, -0.04296140f, -0.03913035f, -0.00967219f, -0.17847474f, 
    -0.09411518f, -0.08822746f, -0.06133307f, -0.17477819f, -0.04523670f, -0.01234447f, -0.10566478f, 0.07136200f, 
    0.05892675f, 0.05178108f, -0.19767386f, 0.00314628f, 0.21374293f, 0.18298489f, -0.00304636f, 0.08548614f, 
    0.02978473f, -0.05873308f, -0.01744475f, 0.10939350f, -0.01774584f, 0.04722710f, 0.16038418f, 0.05554786f, 
    -0.09741917f, 0.20669818f, 0.03439493f, 0.06154372f, -0.16116479f, 0.02535564f, -0.00974389f, 0.09595808f, 
    0.20824094f, -0.12359757f, -0.02912513f, 0.13004491f, 0.06827889f, -0.03366984f, 0.17932841f, -0.08921298f, 
    -0.86512625f, 0.10826577f, -0.05208088f, -0.08306765f, 0.02974567f, -0.09041689f, -0.10902640f, 0.08008576f, 
    0.32024851f, -0.61312401f, 0.16139922f, 0.17920274f, -0.19800904f, -0.22455168f, 0.20648505f, 0.00083254f, 
    -0.13477360f, -0.45588732f, -0.24169278f, 0.21382223f, -0.28815663f, -0.00154663f, 0.21004596f, -0.44849357f, 
    -0.17414229f, -0.73271394f, -0.14013569f, 0.22697200f, -0.47335482f, 0.11368221f, 0.00153182f, 0.00867851f, 
    -0.37709489f, -0.05019767f, -0.03433677f, -0.19472730f, -0.35071617f, -0.18897338f, -0.52432829f, -0.35935584f, 
    -0.82944065f, -0.00216633f, -0.48941937f, 0.18003915f, -0.43829319f, -0.37484077f, -0.04055298f, -0.13594714f, 
    -0.08718649f, -0.32000858f, -0.39285657f, 0.18993658f, -0.36932686f, 0.00643025f, 0.21915309f, -0.72326720f, 
    0.22246960f, 0.20887096f, -0.29406443f, -0.05081033f, -0.14349855f, 0.09832973f, -0.07929232f, -0.08615364f, 
    -0.07895956f, -0.32535627f, -0.46178895f, -0.04856209f, -0.07641719f, 0.46881008f, 0.00049361f, -0.37946036f, 
    -0.19669648f, -0.34530228f, -0.02006367f, -0.56863892f, -0.28495657f, -0.41841626f, -0.09909323f, -0.12425774f, 
    0.09145562f, 0.12000667f, 0.09780423f, -0.00995755f, 0.17868595f, 0.06236729f, -0.05653973f, -0.42715147f, 
    0.01416655f, 0.16776553f, 0.15503594f, 0.41070887f, 0.02771215f, -0.18725684f, 0.17142202f, -0.22724879f, 
    -0.49264863f, 0.05851784f, 0.27666155f, -0.18208855f, -0.29558930f, -0.27111480f, -0.13818404f, 0.30357134f, 
    0.36299488f, -0.21159258f, -0.20278457f, 0.04666803f, -0.05129904f, 0.03475176f, 0.03993464f, -0.05363848f, 
    -0.02541608f, -0.61211729f, 0.08171377f, -0.63824385f, 0.09657756f, 0.06606461f, 0.05658539f, -0.03408889f, 
    -0.18254077f, 0.10217966f, 0.01368659f, 0.07181041f, 0.06578050f, 0.21880269f, -0.76361501f, 0.20807238f, 
    -0.57480884f, -0.20109870f, 0.19762224f, -0.14778592f, -0.22473343f, 0.19865978f, -0.13225012f, 0.07886913f, 
    0.05196724f, -0.13277631f, -0.20574056f, -0.20196703f, -0.05271263f, 0.34985724f, 0.16972420f, -0.03290547f, 
    0.15546991f, 0.00444790f, 0.03133569f, -0.03075705f, -0.21220443f, -0.00715786f, -0.09871206f, 0.14166601f, 
    0.04718966f, 0.23086824f, -0.34560525f, -0.07832061f, 0.00588696f, -0.41362333f, 0.10620311f, 0.03677408f, 
    -0.18330081f, 0.10876844f, -0.00368865f, -0.00534109f, -0.20863265f, -0.37128210f, -0.47202745f, 0.18604276f, 
    -0.37568644f, -0.10771476f, -0.54404074f, -0.23235452f, 0.18317537f, 0.14202832f, -0.06407744f, 0.18784755f, 
    -0.08358386f, -0.17853555f, 0.61607325f, 0.14436662f, -0.03752718f, -0.13640310f, 0.33261645f, 0.00025327f, 
    -0.16928889f, 0.10282280f, 0.09808797f, -0.01363904f, 0.11977662f, -0.18994671f, -0.13302176f, 0.10395345f, 
    -0.06706830f, 0.13684288f, -0.12430965f, 0.04015199f, 0.07865025f, -0.05880700f, 0.31747493f, 0.24938394f, 
    -0.01555191f, 0.10174668f, -0.46305794f, -0.38623282f, -0.07646756f, -0.18762583f, 0.00032053f, 0.24236704f, 
    0.01698626f, 0.08948609f, -0.00302955f, 0.02153409f, 0.14636086f, 0.04355005f, 0.08887791f, -0.15473801f, 
    0.20058948f, -0.31611806f, -0.02375004f, 0.28862393f, 0.13631988f, -0.03980032f, -0.12544206f, 0.05366324f, 
    -0.44463351f, -0.02676396f, -0.15530100f, -0.23735799f, -0.08100380f, -0.29826286f, -0.43787879f, -0.32397443f, 
    -0.40736160f, 0.27699807f, 0.03232893f, -0.12210089f, -0.03679341f, 0.01144719f, 0.19597720f, 0.08384671f, 
    0.05920051f, -0.29174539f, -0.48547259f, -0.08324742f, 0.19048825f, -0.30731940f, -0.11660088f, -0.09221620f, 
    -0.06914993f, 0.05427000f, 0.04018945f, -0.16067202f, 0.00138820f, 0.11235860f, -0.40333763f, -0.11481996f, 
    -0.38700053f, 0.33202302f, -0.08058624f, 0.17424490f, -0.25910786f, 0.08552688f, -0.09299224f, 0.13850939f, 
    0.20948520f, 0.10449155f, 0.14741565f, 0.22925299f, -0.45492283f, -0.39728346f, -0.08178799f, -0.00182429f, 
    -0.12268119f, -0.05010244f, 0.23824781f, 0.06885107f, 0.05513313f, -0.03209145f, -0.03924132f, -0.05159039f, 
    0.09999149f, -0.03961899f, -0.32029265f, -0.00971402f, -0.15695907f, 0.24408145f, -0.29282680f, -0.05030882f, 
    -0.28142112f, 0.26009169f, -0.28125298f, -0.14697300f, 0.19444834f, -0.54397941f, 0.30054599f, 0.12409237f, 
    0.20678990f, 0.23105727f, -0.11159090f, -0.06576361f, 0.02446100f, -0.08996481f, 0.05991612f, 0.01453430f, 
    -0.02932345f, -0.01809982f, -0.08983126f, -0.36743614f, 0.22810097f, -0.21506466f, 0.03597985f, 0.08810551f, 
    0.08194748f, -0.03307408f, 0.00821620f, 0.06347831f, -0.15081070f, 0.00572466f, 0.26387918f, -0.22360043f, 
    -0.04501611f, 0.17952390f, -0.01371629f, -0.06503133f, -0.05863513f, -0.42171812f, 0.03643527f, 0.15169671f, 
    -0.20418239f, -0.16082813f, 0.10865292f, -0.28255779f, 0.14758945f, -0.10712920f, -0.04810579f, 0.10947812f, 
    -0.05495702f, 0.06056969f, 0.12628415f, -0.14301647f, -0.30874652f, 0.15107076f, -0.15760301f, 0.10306058f, 
    -0.14290638f, -0.06629822f, -0.18604793f, -0.48159471f, -0.17370924f, 0.09617756f, 0.19773486f, 0.30640009f, 
    0.07636067f, 0.04413198f, 0.04000916f, -0.03325608f, -0.03574330f, 0.12241425f, 0.27086774f, -0.68920457f, 
    -0.18679053f, -0.24848191f, -0.14560165f, -0.18154243f, 0.05619479f, -0.12265795f, -0.17035095f, -0.37873933f, 
    0.05218732f, -0.26227343f, -0.13345951f, -0.02831482f, 0.04444445f, -0.28563324f, 0.09410072f, -0.25853053f, 
    -0.23336016f, 0.10602774f, -0.08695430f, -0.52970105f, 0.06032736f, 0.09513943f, -0.09025425f, -0.38000256f, 
    -0.12029104f, -0.79078978f, 0.12819557f, 0.35178250f, 0.28187415f, -0.04515830f, 0.20781025f, 0.10814509f, 
    0.04691200f, 0.25154665f, -0.09240394f, -0.01461761f, -0.06064619f, 0.35565853f, 0.08708807f, -0.04640893f, 
    -0.20393312f, -0.05195373f, -0.05484246f, 0.12762240f, 0.24035695f, 0.11101885f, 0.23684315f, -0.15853551f, 
    -0.25691414f, -0.24467877f, 0.11658787f, -0.12121142f, 0.21022828f, 0.11339606f, 0.13102660f, -0.41675502f, 
    -0.43769297f, 0.08726241f, 0.02370493f, -0.38733286f, -0.02151944f, -0.41326448f, -0.31373245f, -0.27970052f, 
    -0.30737552f, -0.01223604f, -0.01556041f, 0.10397477f, -0.25801164f, -0.05438827f, -0.12209189f, -0.16615699f, 
    0.03833082f, 0.38987139f, -0.65500671f, 0.02266799f, -0.32996282f, -0.05733281f, -0.08508850f, 0.32193446f, 
    0.00657353f, -0.00776190f, -0.04303792f, -0.01861619f, -0.16891830f, 0.09095526f, -0.23978208f, -0.04452880f, 
    -0.10520166f, -0.23128071f, 0.10417337f, -0.07011135f, -0.37627965f, 0.12290282f, 0.24350646f, -0.62950814f, 
    -0.09687520f, -0.83928066f, 0.14028424f, 0.09702085f, -0.49108383f, -0.24011388f, -0.10238197f, -0.06229852f, 
    0.03122800f, -0.04751738f, 0.00111462f, 0.02065179f, -0.28896657f, 0.00162697f, -0.14965521f, 0.21703601f, 
    0.21595207f, 0.07201237f, -0.10890171f, -0.46890420f, 0.02382836f, -0.07279325f, -0.10779363f, -0.00490343f, 
    0.02183665f, -0.03136568f, 0.02805578f, -0.42647412f, -0.17042691f, -0.19091611f, 0.14678122f, 0.18347554f, 
    0.04478842f, 0.34664252f, 0.12433169f, -0.21307614f, -0.00268869f, -0.22857071f, -0.33603033f, 0.15352225f, 
    0.00984414f, 0.25415719f, -0.01964734f, -0.29146603f, 0.33808112f, 0.10275177f, 0.03622980f, 0.19393452f, 
    0.12751721f, 0.06263938f, -0.02953072f, -0.29127172f, 0.00441065f, -0.20642047f, -0.11496526f, 0.25931498f, 
    0.14186990f, 0.08056527f, -0.14370368f, 0.07856751f, -0.62400877f, -0.16846323f, 0.01390212f, -0.18458696f, 
    -0.42747846f, -0.28061885f, -0.10697755f, -0.19316511f, 0.02002923f, 0.25465369f, 0.04105606f, 0.01801493f, 
    0.15789516f, -0.01746584f, 0.07936545f, -0.08006223f, -0.66332549f, 0.11739513f, -0.38038850f, 0.01795433f, 
    0.16541182f, 0.10901960f, 0.18278973f, 0.13227350f, -0.05559361f, 0.02149099f, 0.19101101f, -0.36344671f, 
    -0.03147249f, -0.36149195f, -0.18982245f, 0.08376834f, -0.51438069f, -0.22625168f, 0.01898786f, 0.03597797f, 
    0.12498615f, -0.58836752f, -0.09429248f, 0.34111893f, 0.08111466f, 0.10093530f, -0.06441446f, 0.14434746f, 
    0.10965724f, 0.27955982f, -0.02380544f, 0.22645921f, 0.08533046f, -0.17458285f, 0.29255593f, 0.10484763f, 
    0.03153165f, 0.12178583f, -0.83966202f, 0.01051302f, 0.05126020f, -0.30868822f, 0.23316571f, -0.38549948f, 
    -0.04276008f, -0.06086128f, 0.28215095f, -0.01068043f, -0.00940975f, -0.44417286f, 0.23419680f, -0.09783605f, 
    0.19998498f, -0.16363032f, 0.04422591f, -0.20725615f, 0.20348030f, -0.00454716f, -0.12987147f, 0.27877191f, 
    -0.08352897f, -0.10476527f, 0.08643018f, 0.04097968f, -0.06459627f, 0.19537218f, 0.20730731f, -0.15948853f, 
    0.21717499f, 0.19732326f, 0.04304551f, 0.19804315f, -0.38544068f, 0.23396914f, 0.07854366f, 0.02447287f, 
    -0.55585045f, -0.10157022f, -0.07520681f, 0.11302444f, 0.25455552f, -0.05145408f, -0.16769435f, 0.02393592f, 
    -0.14093052f, -0.36003858f, -0.02164726f, -0.07198424f, 0.08277697f, 0.09685148f, -0.17109603f, -0.29146755f, 
    -0.10833279f, -0.45736063f, -0.22391157f, -0.07521976f, -0.58084911f, 0.16628641f, 0.11685631f, -0.17994212f, 
    0.27954087f, -0.08146701f, 0.06731242f, -0.23836829f, -0.43480974f, -0.06237498f, 0.05849945f, -0.40703505f, 
    -0.21222261f, 0.11038338f, 0.01358655f, -0.23450674f, -0.29714119f, 0.11777840f, -0.06062756f, -0.02234135f, 
    0.00039846f, -0.02798526f, 0.03829144f, 0.08614931f, -0.11251297f, 0.00852689f, 0.02258541f, 0.03383651f, 
    -0.36032182f, 0.12293856f, 0.32327354f, -0.01782546f, 0.25226262f, 0.00413770f, -0.12164924f, 0.04719365f, 
    0.06174083f, 0.06652262f, 0.31168374f, 0.22119653f, 0.03823170f, -0.06148306f, -0.11024650f, 0.08648640f, 
    0.01901961f, -0.08458880f, -0.52276444f, 0.21477741f, 0.11860505f, 0.17893411f, -0.74199718f, -0.39887217f, 
    -0.24626797f, 0.03546736f, -0.15571286f, 0.11138562f, 0.04150691f, 0.03011047f, -0.10353369f, 0.09277941f, 
    -0.01994017f, -0.19283202f, -0.13036948f, -0.01007743f, -0.10478772f, 0.16899382f, -0.17076710f, -0.30501819f, 
    0.06337006f, -0.10223112f, -0.06096992f, 0.04599292f, -0.61453313f, 0.17526400f, 0.06111498f, -0.54024166f, 
    -0.00380049f, -0.45809171f, -0.09632146f, -0.10092874f, 0.06536233f, 0.21142283f, -0.01157653f, 0.53435946f, 
    -0.24488120f, -0.18101914f, 0.13470002f, 0.24095254f, 0.36250114f, -0.12534243f, -0.01169690f, -0.07703009f, 
    -0.00725406f, -0.06254061f, 0.08547559f, 0.00675784f, -0.25351921f, 0.16682988f, -0.04376123f, -0.11497603f, 
    0.00541243f, -0.08092877f, -0.09174144f, -0.01166530f, 0.07214766f, -0.02011913f, 0.13856257f, -0.32805544f, 
    -0.06397445f, 0.01558616f, 0.17892024f, 0.32372797f, -0.14498305f, 0.25212502f, 0.27503526f, -0.21942966f, 
    -0.56153190f, -0.02458599f, -0.32940254f, 0.20553012f, 0.00897614f, -0.19515015f, 0.24441019f, -0.02849133f, 
    -0.00980671f, 0.25177857f, -0.18621731f, -0.10566450f, 0.04535525f, 0.19165212f, -0.03257551f, -0.29049700f, 
    -0.24788004f, -0.00226552f, -0.06391781f, 0.17135549f, -0.01602426f, -0.11271786f, -0.54712367f, 0.31657919f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.07434019f, 0.18246184f, -0.00453762f, -0.01132180f, -0.04206081f, -0.10457591f, 0.03089539f, -0.15367536f, 
    -0.11724484f, 0.21568982f, 0.09750988f, -0.10719764f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
