#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.17376354f, -1.03553200f, -1.21338534f, -0.62698877f, -0.12524398f, -0.21299776f, -0.68667817f, -0.57909030f, 
    -0.63047665f, -0.20168613f, -0.41336918f, -0.34630159f, -0.01229851f, -0.29163024f, -0.60263872f, -0.15484394f, 
    -0.21107590f, -0.24835388f, 0.30979133f, -0.20665684f, -0.04943642f, 0.01424338f, -0.48251715f, -0.00922189f, 
    0.14884575f, -0.48601738f, -0.80846977f, -0.14768209f, 0.52225691f, 0.35462311f, 0.66346776f, 0.50655913f, 
    0.20529176f, 0.43808028f, 0.39940494f, -0.38667557f, 0.21201001f, -0.06085943f, 0.05063339f, -0.29665580f, 
    -0.12040909f, -0.09809883f, -0.22611699f, 0.43746844f, -0.38698092f, 0.14919481f, 0.13594596f, 0.25791529f, 
    0.05130895f, 0.14789136f, 0.22272673f, -0.18649641f, -0.78423780f, 0.21792786f, 0.67338580f, 0.43381456f, 
    0.86284286f, 0.18294050f, -0.65722805f, 0.16431297f, -0.17239916f, 0.34858468f, -0.43679452f, -0.50189769f, 
    -0.17041883f, -0.14653911f, 0.09124070f, 0.02650963f, 0.10543269f, -0.15080634f, 0.36758360f, -0.07719564f, 
    -0.25427738f, -0.20139444f, -0.22702548f, -1.25829625f, -0.14473632f, -0.73312724f, -0.86486191f, -0.60849339f, 
    0.11260138f, -0.24309693f, -0.35718915f, 0.12381668f, 0.43814600f, -0.34504744f, -0.39223820f, -0.32463080f, 
    -0.57943612f, -0.32269725f, 0.37322497f, 0.24801451f, -0.25649691f, -0.00541971f, 0.12449834f, -0.04747819f, 
    -0.14678176f, -0.35052776f, -0.06357566f, -0.11954278f, 0.59362900f, 0.55580717f, 0.18071128f, -0.15188143f, 
    0.24392459f, 0.19764061f, 0.23817059f, 0.24791957f, -0.09145936f, -0.07525638f, 0.15991864f, -0.00091782f, 
    -0.31926611f, -0.02216003f, -0.32024571f, 0.15654890f, -0.28501236f, 0.02161595f, -0.22769046f, -0.35189256f, 
    0.15336120f, 0.39401790f, 0.18278490f, -0.44900465f, -0.42954490f, 0.15717372f, 0.72922641f, 0.76750410f, 
    -1.04612935f, -0.94652975f, -0.25736552f, 0.45338777f, -0.20420030f, 0.39928484f, -0.11006389f, -0.45353925f, 
    0.62562323f, -0.23316482f, -0.05747953f, 0.02765300f, 0.05204879f, 0.16979711f, -0.34021810f, -0.01544506f, 
    0.12282773f, -0.11275782f, 0.30401573f, 0.09373251f, -0.18989234f, 0.23598710f, 0.33331180f, 0.38011357f, 
    0.16712770f, -0.15145294f, -0.35071334f, -0.60129720f, -0.10955425f, 0.41408235f, 0.18312091f, 0.13981865f, 
    -0.00399031f, 0.16840585f, -0.05172478f, 0.23067157f, -0.02992621f, -0.20382790f, -0.16007261f, -0.39775354f, 
    0.17048940f, 0.00824241f, 0.19925340f, -0.29884771f, -0.21081845f, 0.44732288f, 0.03970770f, -0.63309580f, 
    -0.33319062f, 0.13772173f, -0.62269282f, -0.20097324f, 0.02400948f, -0.32230517f, 0.70347703f, -0.56250775f, 
    -0.79206556f, -0.27711558f, 0.48468989f, -0.04400958f, 0.07669078f, -0.23902346f, -0.24838959f, -0.46077821f, 
    -0.50788778f, 0.05441029f, -0.20019931f, -0.03745395f, 0.18865305f, 0.01759219f, -0.15098119f, 0.22412974f, 
    -1.35378015f, 0.21963878f, 0.43562245f, -1.08184707f, -0.68552387f, 0.19214042f, -0.06761372f, 0.28167000f, 
    0.79627889f, 0.84357327f, 0.15519272f, -0.02197818f, -0.04723471f, -0.32730427f, 0.03963993f, -0.10969078f, 
    -0.23314458f, 0.03012574f, -0.04463321f, -0.00138501f, 0.04768676f, 0.19175652f, 0.23805133f, -0.06283121f, 
    -0.05089671f, 0.10665690f, 0.07716864f, -0.12160797f, -0.12159766f, -0.32556111f, 0.40066195f, -0.30697212f, 
    -0.28966060f, 0.55490220f, -0.65534836f, 0.22373912f, 0.01757550f, 0.35520294f, 0.33579633f, 0.11026762f, 
    -0.15856029f, -0.26307240f, 0.17362659f, 0.01684889f, 0.16196954f, -0.14600493f, 0.15626140f, -0.05877037f, 
    -0.30555007f, 0.39010945f, -0.58770823f, -0.15860382f, -0.48618081f, -0.50265312f, -0.52897209f, 0.16204801f, 
    -0.02038730f, -0.07097451f, 0.27920410f, 0.55932623f, -0.10378991f, 0.21575208f, 0.32465678f, 0.43257821f, 
    0.23764220f, 0.04684034f, 0.21745302f, -0.23656118f, 0.12867603f, -0.03131373f, -0.02843740f, -0.30226204f, 
    0.21971938f, -0.37311023f, -0.06747168f, -0.55530709f, 0.18079999f, -0.30644435f, -0.66942823f, 0.34121487f, 
    0.07437406f, -0.60502201f, -0.97500819f, -0.68382639f, -0.22503339f, -0.36903578f, -0.47779530f, -0.06679940f, 
    0.16472131f, -0.33582467f, 0.08626240f, -0.40006560f, -0.43621355f, -0.26053020f, -0.35465714f, -0.31636003f, 
    -0.28499624f, -0.63362139f, -0.75598663f, -0.47607788f, 0.69658566f, -0.04004590f, -0.17525658f, -0.09432361f, 
    0.04022563f, 0.22949824f, -0.13415453f, 0.04654352f, -0.15287237f, 0.18598007f, -0.47020379f, 0.06797701f, 
    -0.07716733f, -0.51003027f, 0.10204303f, 0.03509149f, 0.08032518f, -0.22259162f, -0.19850817f, -0.18413991f, 
    -0.60442227f, -0.62377346f, -0.60491568f, -0.82285136f, -0.88674349f, 0.69064903f, -0.90280527f, -1.05283880f, 
    -1.02784574f, -0.32638642f, -0.39105958f, -0.42886010f, 0.18361601f, -0.16367182f, 0.07752006f, 0.42298830f, 
    0.36549062f, 0.62171382f, 0.11326985f, 0.27349800f, -0.14586264f, -0.32937697f, -0.14936252f, -0.14866742f, 
    0.11212938f, 0.44749591f, -0.12640148f, 0.04119241f, -0.06738324f, 0.02185245f, -0.43591923f, -1.31592262f, 
    -0.99471158f, -0.10947038f, 0.26607156f, -0.09316789f, 0.23492719f, 0.29040489f, 0.06708363f, -0.46956134f, 
    0.38250661f, 0.45695493f, -0.12350935f, -0.18891887f, -0.37848803f, 0.08167119f, 0.06848181f, -0.08446532f, 
    -0.21764107f, -0.56468683f, -0.26424941f, 0.07095266f, 0.27454314f, -0.34747404f, -0.50303048f, -0.33570981f, 
    0.95376539f, -0.84698284f, -0.46696985f, -0.69619483f, -0.17616421f, -0.31677863f, 0.42018360f, 0.40156901f, 
    0.55830133f, -0.18657936f, -0.12067074f, 0.15035363f, 0.35849416f, -0.32307002f, 0.09583035f, -0.13422322f, 
    -0.17447670f, 0.17168033f, -0.03717098f, -0.18431073f, 0.00449933f, -0.00865879f, -0.25768748f, -0.12394448f, 
    0.46945530f, 0.95417577f, 0.43844366f, -0.03285056f, -0.40935466f, -0.76280153f, -0.30289504f, 0.17282771f, 
    -0.14551093f, -0.54633194f, 0.04019331f, 0.35094294f, -0.14292382f, 0.36735448f, 0.19255242f, 0.04683018f, 
    -0.23995304f, -0.11223636f, 0.08663476f, 0.10943174f, -0.00334708f, -0.08339647f, -0.23090233f, -0.14823407f, 
    -0.18611385f, -0.54801369f, -0.45161542f, 0.00896177f, 0.72595942f, 0.63476068f, -0.34920293f, -0.35036439f, 
    -0.49906141f, -0.25859678f, 0.15431306f, 0.50611347f, -0.14395975f, -0.17599259f, 0.08735119f, 0.45755994f, 
    -0.20065819f, -0.24024741f, 0.00323958f, 0.22682589f, 0.05229608f, -0.21553227f, -0.17759581f, 0.19772638f, 
    -0.04254222f, 0.17680962f, -0.39649966f, -0.81499535f, 0.08686261f, 1.59972131f, -0.43920338f, -0.19291155f, 
    -0.66691124f, -0.67599684f, -0.33626804f, -0.37366092f, -0.18255931f, 0.00401403f, -0.25002053f, -0.11415523f, 
    0.04004350f, -0.14779341f, -0.15506664f, -0.05955792f, -0.12212809f, -0.27791452f, 0.16492507f, 0.04444370f, 
    -0.17836344f, -0.10419773f, -0.07754258f, -0.35000101f, -0.56175727f, 0.32945627f, 0.06079852f, 0.67699081f, 
    0.05009935f, 0.16808012f, -0.05811050f, -0.09338653f, 0.24377911f, -0.65170199f, -0.14019017f, 0.55348760f, 
    -0.37993565f, 0.45486787f, -0.31014612f, -0.33041874f, -0.21511388f, -0.25393686f, -0.31707814f, -0.33965775f, 
    -0.57593101f, 0.15644583f, -0.01554174f, -0.31153509f, 0.25445455f, -0.19736773f, -0.16481782f, 0.46598846f, 
    -0.39390185f, 0.03890026f, -0.21336059f, -0.58379769f, -0.62230760f, -0.23081109f, 0.33411711f, 0.46354449f, 
    0.13999026f, -0.31953502f, -0.13534299f, 0.04975560f, 0.41795522f, 0.18483402f, -0.04814522f, 0.43836969f, 
    -0.07002113f, -0.47378391f, -0.09736971f, -0.11777465f, -0.36556211f, -0.13458630f, 0.17029452f, 0.05102484f, 
    -0.39433345f, 0.04329817f, -0.33268815f, 0.03918920f, 0.18581326f, 0.00767553f, 0.00120353f, -0.30404153f, 
    0.38865206f, 0.24227831f, -0.40338945f, 0.23254561f, -0.46939793f, -0.22443628f, 0.02717084f, -0.18462642f, 
    0.05209162f, 0.22472535f, 0.28556395f, 0.15679820f, 0.15320690f, 0.12150095f, -1.28130031f, -0.93901896f, 
    -0.52047634f, 0.08428284f, -0.35571921f, 0.87557763f, 0.10941967f, -0.28176302f, 0.20697361f, 0.79841745f, 
    0.08014231f, -0.34010392f, 0.05373992f, 0.21735561f, 0.11856256f, -0.09018032f, 0.15374139f, -0.11079583f, 
    -0.13307507f, -0.16770905f, 0.01171089f, 0.07691147f, 0.35056821f, 0.01813766f, 0.25803080f, 0.10896352f, 
    0.45765644f, 0.19549407f, 0.42470306f, -0.78976017f, -0.26564357f, -0.07450426f, -0.09436125f, -0.16950342f, 
    -0.19334160f, 0.42831919f, -0.22218603f, 0.06167536f, -0.01952168f, 0.26554987f, -0.40991533f, 0.04323038f, 
    -0.12809314f, 0.19243979f, -0.08266363f, 0.12478616f, 0.22190122f, -0.29513669f, -0.39863721f, -0.42592081f, 
    -0.13960153f, -0.43087938f, -0.11045878f, 0.06426358f, -0.75382394f, -0.25362411f, -1.05846226f, -0.96589524f, 
    -0.63295776f, -0.98100257f, 0.71018773f, 0.00821690f, 0.11588754f, 0.77194899f, 0.02865282f, 0.03721774f, 
    0.16362984f, -0.11230035f, -0.19774210f, -0.61509550f, -0.20956291f, 0.09450910f, -0.07484806f, 0.35161734f, 
    0.05362757f, 0.16939078f, -0.44229031f, 0.11015662f, 0.21850534f, 0.36050239f, -0.51181859f, 0.14814198f, 
    0.61515009f, 0.22240725f, -0.53672117f, -0.18319184f, -0.38542968f, 0.36092469f, -0.29421040f, 0.23442912f, 
    0.17812555f, -0.14757009f, -0.00298107f, -0.21185026f, -0.02131740f, 0.07502893f, -0.27150351f, -0.07346459f, 
    0.32010028f, -0.13570300f, 1.42951810f, -0.51791114f, -0.19539517f, -0.69457793f, -1.26929772f, 0.99684596f, 
    0.54080093f, 0.18177179f, -0.30260608f, 0.08977437f, -0.28790203f, 0.01111317f, -0.09998115f, -0.02438052f, 
    0.25778046f, 0.08878969f, -0.04749872f, 0.34135777f, -0.23364240f, -0.22320572f, -0.04891895f, 0.02579004f, 
    0.08249961f, 0.09217188f, -0.04406729f, -0.32354271f, 0.08392872f, 0.00300955f, 0.39568865f, 0.26055878f, 
    -0.52312058f, -0.59436953f, -0.10099594f, 0.79020697f, 0.23696366f, 0.46348563f, -0.54483670f, -0.34701073f, 
    -0.07040070f, 0.33847523f, 0.06437247f, 0.26045337f, -0.26591119f, -0.47373033f, 0.32063556f, -0.12771016f, 
    -0.22191499f, 0.00555996f, 0.26747522f, 0.10223331f, -0.89831406f, 0.38980055f, -0.35684136f, -0.98789275f, 
    -0.68620127f, 0.19761327f, 0.30290806f, 0.23384461f, -0.04389494f, 0.50777721f, 0.04361116f, 0.08038259f, 
    -0.15354215f, -0.39294294f, -0.14435086f, 0.03233973f, 0.06620642f, -0.08807916f, 0.17815605f, 0.08053514f, 
    -0.09698950f, -0.14422429f, -0.38493595f, -0.28969368f, -0.37406316f, -0.02110291f, 0.13825257f, 0.44336817f, 
    0.06975707f, -0.76921529f, -0.93486571f, -1.03116000f, 0.45395681f, 0.05900158f, -0.09379081f, 0.62594104f, 
    0.00295664f, 0.28609025f, 0.62506574f, -0.23243144f, -0.41482195f, 0.32134885f, -0.08841541f, -0.48940325f, 
    -0.52973354f, -0.00428629f, 0.14132985f, 0.10113081f, -0.26989982f, 0.14148653f, -0.64165252f, -0.35405970f, 
    0.32673806f, -0.75296348f, 0.08619457f, -0.31067362f, -0.45130447f, 0.00013197f, 0.63543969f, 0.56474811f, 
    -0.55675000f, -0.33283547f, -0.51170427f, -0.30509374f, 0.27793890f, 0.12970209f, 0.28774127f, 0.03210963f, 
    0.26686165f, 0.14250176f, 0.18948098f, -0.06579635f, 0.07497660f, -0.04764169f, -0.14583135f, -0.36771396f, 
    -0.27631429f, -0.33929709f, -0.25560492f, -0.65765667f, -0.85184968f, -0.37204510f, -0.51029563f, -0.65078044f, 
    -0.59621656f, 0.36354706f, -0.31700557f, 0.36214933f, -0.33385822f, -0.09229956f, 0.22962476f, 0.04782086f, 
    0.09713690f, -0.09201896f, -0.05513860f, 0.14013763f, -0.11183516f, 0.11274844f, 0.39280385f, 0.58274001f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.29270741f, 0.44397992f, 0.42692095f, -0.17052110f, 0.17974643f, 0.41413549f, 0.55789179f, 0.55985212f, 
    0.12297269f, 0.23509854f, 0.14320359f, -0.30280590f, 0.08763839f, 0.76448590f, 0.12537073f, 0.37929022f, 
    0.03231216f, 0.58983219f, 0.40618312f, 0.11780111f, 0.15671758f, 0.34728992f, 0.15369940f, 0.09840475f, 
    -0.11208414f, 0.42937988f, 0.43572059f, 0.48489887f, 0.13438049f, 0.31073797f, 0.21782669f, 0.04846146f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.43730062f, 0.14372784f, -0.08304440f, -0.06385111f, 0.26422098f, 0.08305510f, 0.07969018f, -0.01881209f, 
    -0.04356052f, -0.08675932f, -0.06551396f, -0.08569540f, 0.17999353f, 0.14760748f, -0.18418811f, -0.01990643f, 
    0.05806607f, -0.01517691f, 0.07452314f, 0.00396238f, -0.12447899f, -0.09575803f, -0.25409031f, -0.14669850f, 
    0.08646142f, -0.21057847f, -0.39456913f, -0.06210933f, -0.02249493f, 0.05728355f, 0.10207894f, -0.11175992f, 
    -0.13683930f, -0.00789588f, -0.09331089f, 0.04381873f, 0.33145237f, 0.34859601f, 0.06541190f, -0.07098696f, 
    0.09152622f, 0.25637501f, 0.08461354f, 0.04669062f, 0.01523485f, -0.00096675f, 0.06930387f, -0.06580703f, 
    -0.42597461f, -0.49335662f, -0.36565918f, 0.25613260f, 0.00194018f, 0.04515718f, 0.04045874f, 0.04886008f, 
    -0.01719246f, -0.00668941f, -0.14131521f, 0.01253817f, -0.06692071f, -0.44313875f, 0.06687834f, -0.11038823f, 
    -0.35473868f, -0.00788753f, -0.19558239f, -0.08505421f, -0.19800976f, -0.13665882f, -0.07612168f, -0.25923058f, 
    -0.39134541f, -0.57469833f, 0.10239226f, 0.02854580f, -0.06098204f, 0.03372010f, -0.09837871f, 0.01205873f, 
    -0.08753994f, -0.08575933f, -0.10182164f, -0.11133965f, 0.20205320f, 0.06527195f, -0.06793430f, -0.13169006f, 
    -0.05842277f, -0.02268117f, -0.00851329f, -0.04356107f, -0.10916170f, -0.13518000f, -0.20693700f, -0.17378080f, 
    -0.30338863f, -0.30883086f, 0.31361032f, -0.12002235f, -0.01160271f, 0.18607090f, -0.01367222f, 0.27094954f, 
    0.13186118f, 0.00137695f, -0.03760520f, -0.14726698f, 0.15416242f, -0.00334414f, -0.13463661f, 0.04661901f, 
    -0.09654665f, -0.00691178f, -0.02202000f, -0.07252464f, -0.11454590f, -0.08118145f, -0.03498646f, -0.04051649f, 
    0.24462928f, 0.03787256f, 0.07992581f, 0.02427077f, 0.10145900f, 0.13432291f, -0.03817464f, -0.02676089f, 
    -0.08199951f, 0.01818243f, 0.02481275f, -0.04080699f, 0.31362399f, 0.26577359f, -0.11592455f, 0.04248757f, 
    -0.29441032f, 0.03344043f, -0.11897961f, -0.08340022f, -0.18722616f, -0.21777253f, 0.13572067f, 0.09653112f, 
    -0.34645766f, -0.08365107f, -0.10610330f, 0.17852834f, 0.03408269f, -0.02508589f, 0.02924612f, -0.03270660f, 
    -0.06306940f, 0.01344170f, 0.18293644f, 0.05298141f, 0.25940317f, 0.23790899f, -0.31451952f, -0.20387028f, 
    0.07653839f, -0.06681582f, -0.23339976f, -0.18583257f, -0.12994318f, -0.07348502f, 0.03900164f, -0.01910494f, 
    0.50545257f, 0.00906645f, -0.27430871f, -0.12556903f, 0.11451190f, 0.06982982f, 0.10673713f, -0.13832362f, 
    -0.22691046f, -0.02378128f, -0.02627162f, 0.16985506f, -0.39724430f, -0.22925173f, -0.00777660f, 0.00758552f, 
    0.02834038f, 0.03239328f, -0.09983845f, -0.18564820f, 0.08341721f, -0.18048409f, -0.08217736f, 0.11672381f, 
    -0.02031241f, -0.10838141f, 0.05705613f, 0.05297515f, -0.15541348f, -0.10760566f, -0.15572323f, 0.01505193f, 
    0.01992591f, 0.18163770f, -0.01017645f, 0.13417378f, 0.08848188f, 0.24578820f, 0.12039650f, -0.34545222f, 
    -0.08173350f, 0.01939082f, -0.16783747f, -0.20638713f, 0.14460164f, 0.02429280f, -0.00364387f, -0.03598922f, 
    0.35627732f, 0.05339813f, 0.02020957f, -0.51141638f, 0.01659451f, 0.08271889f, 0.00901640f, 0.08197298f, 
    -0.01487072f, -0.11836195f, -0.08128463f, -0.05227388f, -0.00499419f, 0.18263993f, 0.01406469f, 0.11345287f, 
    0.03496503f, -0.03146803f, 0.01011437f, 0.03801781f, 0.02472671f, -0.01374628f, 0.07058936f, 0.16566919f, 
    0.18534277f, 0.06270429f, -0.06159470f, -0.11496376f, -0.00518010f, -0.20192032f, -0.06285334f, -0.05486618f, 
    0.03664254f, 0.14326827f, 0.03249931f, 0.02689157f, -0.12544113f, -0.00902418f, -0.01855835f, 0.04937325f, 
    -0.07734216f, 0.05232548f, -0.06212642f, -0.04293765f, -0.02276324f, -0.13805448f, -0.05825758f, -0.13740343f, 
    0.54002476f, 0.17016906f, 0.05863459f, -0.16987422f, 0.11738990f, 0.10470299f, -0.02104111f, -0.11589919f, 
    -0.02026846f, 0.06073091f, -0.01623813f, -0.00037468f, -0.27094591f, -0.28003076f, 0.01694634f, -0.02466676f, 
    -0.14734550f, -0.10161055f, 0.09437313f, -0.03148051f, -0.02901142f, -0.04194462f, -0.01118166f, 0.16179383f, 
    0.38340551f, 0.16382284f, -0.23742712f, -0.32879475f, 0.15740776f, 0.01462549f, -0.03755089f, 0.09614239f, 
    0.04966073f, 0.06916530f, 0.06594173f, 0.00090950f, -0.16647153f, -0.90523052f, 0.16683322f, -0.01360298f, 
    -0.05911616f, 0.07406987f, -0.00804846f, -0.06861264f, 0.00909352f, -0.15788884f, 0.06311618f, -0.01646599f, 
    -0.06359834f, -0.62534118f, -0.40138024f, 0.17111175f, -0.03107278f, -0.03155818f, -0.19711880f, -0.16746001f, 
    -0.09777225f, -0.12589748f, -0.07833106f, 0.02888562f, -0.44153085f, 0.18001074f, 0.27506045f, -0.53946757f, 
    -0.08734945f, 0.07804455f, -0.01475704f, -0.00000880f, -0.09205596f, -0.15062021f, -0.15124510f, -0.06110953f, 
    -0.03684347f, 0.05800387f, -0.08418723f, -0.00441512f, 0.10710679f, 0.23013937f, -0.05060894f, -0.03519010f, 
    0.04161203f, 0.15899278f, 0.03816640f, 0.00994499f, 0.00489191f, 0.01076158f, 0.32161599f, -0.41383046f, 
    -0.14689015f, -0.05306852f, -0.05304834f, 0.01806144f, 0.00790234f, -0.11014580f, -0.18523821f, -0.19389139f, 
    0.05429612f, 0.34430602f, 0.24650300f, -0.24010338f, -0.02536412f, 0.26685697f, -0.02935709f, -0.01198472f, 
    0.07905377f, 0.06043587f, 0.04357950f, -0.18815801f, 0.30169174f, 0.13111323f, -0.15952310f, -0.31580272f, 
    0.02242214f, 0.01046891f, 0.04641982f, 0.07988256f, 0.05449768f, -0.02493277f, -0.03358736f, -0.01535736f, 
    0.19125448f, 0.28324667f, 0.12027163f, 0.53008240f, 0.02292467f, 0.11500602f, -0.04029024f, -0.53086311f, 
    0.07632473f, -0.00393194f, -0.11472699f, -0.04777613f, 0.09444462f, 0.01443300f, -0.02323230f, 0.13879193f, 
    -0.12626232f, 0.03968259f, 0.06505857f, 0.01419361f, -0.08338046f, -0.01471595f, -0.06467798f, 0.08015984f, 
    0.56771284f, -0.17733249f, 0.02789901f, 0.11464480f, -0.09794790f, 0.01663146f, -0.13883318f, 0.11484204f, 
    0.18957366f, -0.17451319f, -0.02192554f, 0.14193055f, 0.40982074f, 0.30506819f, 0.07455071f, 0.18123540f, 
    0.17677179f, 0.11815697f, -0.39320666f, -0.34518674f, -0.00033398f, -0.04217334f, -0.06016419f, -0.12068031f, 
    0.62916452f, 0.22309974f, 0.35697693f, 0.32132608f, -0.02647586f, -0.03729255f, 0.00181069f, 0.07554723f, 
    -0.06998388f, 0.01505390f, -0.03821156f, 0.18552594f, 0.41280782f, -0.12263426f, 0.11479505f, -0.25318673f, 
    0.03567895f, -0.07184992f, -0.06345197f, -0.01586231f, -0.04530291f, 0.23835570f, -0.14695850f, -0.04421889f, 
    0.28092277f, -0.06990954f, 0.13242100f, -0.08288051f, 0.06239217f, 0.09416652f, 0.07438018f, 0.06346498f, 
    0.15857264f, -0.12172838f, 0.15423475f, 0.23020999f, -0.29502952f, -0.00489168f, -0.02136316f, 0.06118866f, 
    -0.17366534f, 0.06476853f, 0.12439556f, 0.21196863f, 0.00242746f, 0.12554863f, -0.01767511f, 0.08199830f, 
    -0.45141968f, 0.26959997f, -0.05069581f, -0.48694274f, -0.05034396f, 0.09725660f, -0.18631029f, 0.06070166f, 
    -0.23841222f, 0.04939042f, -0.07614993f, 0.00143917f, -0.05768504f, -0.10614949f, -0.07391266f, -0.00959123f, 
    0.11661570f, 0.00376072f, -0.05695114f, 0.06378497f, 0.08909821f, 0.03490411f, 0.06945844f, 0.04946439f, 
    -0.28912506f, -0.06923322f, -0.03544920f, -0.03768070f, 0.05168439f, 0.05188370f, -0.03518637f, 0.02623615f, 
    0.06958330f, -0.00329503f, 0.01787206f, -0.08161598f, 0.23686868f, -0.02400450f, -0.20128079f, 0.24301724f, 
    0.23548250f, -0.19360428f, 0.08379927f, 0.26660508f, -0.19909279f, 0.11498675f, 0.04653969f, -0.09949711f, 
    0.16474831f, -0.01574817f, 0.07885978f, -0.03329188f, 0.00006326f, 0.03265731f, -0.08133619f, -0.01187746f, 
    -0.40764931f, -0.13785726f, -0.25489703f, -0.11378977f, -0.21215634f, -0.21263793f, -0.06798978f, 0.13619678f, 
    0.12190340f, 0.32163745f, 0.08140950f, -0.25638556f, 0.07854713f, 0.08827954f, 0.08431505f, 0.02798491f, 
    -0.37640849f, -0.09315673f, -0.17030919f, -0.05627481f, -0.13753378f, 0.04945064f, 0.05634478f, 0.19518682f, 
    -0.05142921f, -0.02431292f, -0.05731361f, 0.12560210f, -0.75889057f, -0.04715148f, 0.04909134f, -0.11196784f, 
    0.07168937f, 0.15248339f, -0.07357012f, -0.21879968f, -0.00612076f, -0.10448698f, -0.00002064f, 0.07456791f, 
    0.08259580f, 0.00640619f, 0.03827060f, -0.21564686f, 0.03239654f, -0.05607513f, -0.04348142f, 0.04662214f, 
    0.03811952f, -0.07269383f, 0.00634919f, -0.08943817f, -0.23098408f, 0.09757294f, -0.17840406f, 0.01441345f, 
    0.10262855f, 0.11895113f, -0.09054137f, 0.29317409f, -0.09044802f, 0.04588175f, 0.05257729f, 0.07423571f, 
    -0.48554265f, 0.06430081f, -0.08362976f, -0.34589031f, -0.04943934f, -0.27194595f, 0.04159614f, 0.23957226f, 
    -0.01834553f, -0.08528595f, 0.05165223f, -0.14776017f, 0.12324675f, -0.27537513f, 0.04351844f, -0.02003567f, 
    -0.01344012f, 0.02703147f, 0.02630414f, 0.01271740f, -0.03383037f, -0.10754827f, -0.08017016f, -0.90355819f, 
    -0.07567994f, 0.05382681f, -0.06407460f, -0.15247408f, -0.17494495f, -0.06957752f, 0.04247083f, 0.01476914f, 
    0.15859798f, -0.24668825f, -0.07672466f, 0.13006243f, -0.04178765f, 0.10011932f, 0.04055759f, 0.10419126f, 
    0.16496409f, 0.16714793f, -0.04434376f, 0.07642474f, -0.00420302f, 0.07144275f, -0.04921225f, 0.09889245f, 
    -0.01213334f, 0.16457373f, 0.06291995f, -0.27361846f, 0.04047414f, -0.05258438f, -0.01156720f, 0.02618892f, 
    -0.05839990f, -0.05773986f, 0.12311377f, -0.20948350f, 0.03588197f, -0.02750108f, 0.01883342f, -0.29706126f, 
    0.03098948f, -0.09534994f, -0.09335900f, -0.00146160f, -0.08363456f, 0.05040910f, 0.09208455f, -0.25010878f, 
    -0.19164717f, 0.00558200f, 0.12247902f, 0.08081623f, -0.09766002f, -0.34105584f, 0.19974750f, 0.13081151f, 
    -0.04332095f, -0.06377865f, 0.06041009f, 0.06021994f, 0.10768323f, 0.09838969f, 0.18943162f, 0.27415472f, 
    -0.11787569f, -0.01716536f, 0.07999589f, -0.06976259f, 0.15986708f, 0.11444019f, 0.03374744f, 0.06643761f, 
    1.12137270f, -0.29241097f, -0.08046550f, -0.21335615f, -0.03126129f, -0.04983751f, 0.06213567f, -0.06139421f, 
    -0.08839880f, 0.08252843f, 0.05006059f, -0.20365378f, -0.39666742f, 0.24108458f, 0.03495147f, 0.15827857f, 
    0.17874597f, 0.01471436f, 0.04143120f, -0.09029089f, 0.02818687f, 0.03413012f, -0.12105296f, 0.08359502f, 
    0.17879216f, -0.04633486f, 0.02118517f, -0.11265454f, 0.03618034f, 0.07312746f, -0.40843356f, -0.33032900f, 
    0.06264731f, -0.06158699f, -0.13962372f, -0.04358927f, -0.90261513f, -0.28845483f, -0.28669116f, -0.55521971f, 
    -0.13530678f, 0.03366303f, 0.19764610f, 0.12291509f, 0.16889286f, -0.07995836f, -0.04635265f, 0.10492007f, 
    -0.21055661f, 0.16605972f, 0.05398927f, -0.24643502f, 0.13895155f, -0.10775338f, -0.22504312f, -0.11191195f, 
    -0.06885348f, -0.07992988f, -0.09501884f, -0.05269245f, 0.02421651f, 0.16191010f, 0.13545391f, -0.05036072f, 
    -0.05951959f, 0.03423512f, -0.05009608f, -0.17796034f, 0.00677444f, -0.04147510f, -0.06520983f, 0.02446549f, 
    -0.59624016f, -0.25305963f, -0.05277225f, 0.09704179f, -0.07647199f, 0.09390697f, 0.12016065f, 0.07550634f, 
    0.00063352f, -0.00978948f, 0.12723829f, -0.11153589f, -0.25071597f, -0.10082240f, 0.18156454f, 0.04888745f, 
    -0.09559179f, 0.01707285f, 0.01957062f, -0.00058548f, 0.00079070f, -0.28561759f, 0.16396129f, -0.25234562f, 
    0.07487010f, -0.50431484f, 0.11555792f, -0.10818487f, 0.01163476f, -0.07207318f, 0.02306927f, -0.00633756f, 
    0.07620320f, -0.02903403f, -0.08986158f, 0.01003034f, 0.10152863f, 0.32943010f, 0.14694934f, 0.64682871f, 
    0.02196519f, -0.04938790f, 0.09809097f, -0.02071948f, 0.01689694f, 0.01631015f, -0.10052520f, 0.06032185f, 
    0.13046241f, -0.40258735f, -0.06537381f, -0.38658684f, 0.02414034f, -0.05385927f, 0.01812309f, 0.00972131f, 
    -0.03370468f, -0.09415367f, -0.11574724f, 0.11398681f, 0.19971871f, -0.07062782f, -0.02681952f, -0.19010402f, 
    -0.06065847f, -0.12151036f, -0.25054252f, 0.20878337f, -0.01553183f, 0.05317410f, -0.15228052f, 0.17779739f, 
    -0.21376166f, 0.11330210f, -0.00376512f, 0.09499429f, -0.04619127f, -0.05599366f, 0.01108794f, -0.01413693f, 
    -0.04630448f, -0.01343645f, -0.05334675f, 0.05553105f, 0.31345710f, 0.27631354f, -0.00592392f, -0.05379966f, 
    0.12167931f, 0.15578768f, 0.17105794f, -0.00688151f, -0.03646500f, -0.07681394f, -0.09939778f, -0.17504010f, 
    0.61839294f, 0.68948376f, -0.06672960f, 0.41295117f, 0.05539031f, 0.09163927f, -0.06263200f, 0.06648954f, 
    -0.02966640f, 0.03074788f, -0.04847829f, 0.19483420f, -0.17548923f, -0.02064938f, -0.05004561f, -0.07236063f, 
    0.02430058f, -0.13609444f, -0.03423068f, 0.01008020f, -0.20383711f, 0.09150290f, 0.00053292f, 0.03028444f, 
    0.19824156f, 0.08723715f, 0.06135039f, 0.27784336f, -0.13007779f, 0.01256100f, 0.16567028f, -0.15379527f, 
    -0.07682054f, 0.02185489f, 0.07532596f, 0.08707059f, -0.29193330f, -0.36720172f, 0.04150103f, -0.19821855f, 
    0.04489202f, 0.01710997f, -0.13420583f, -0.23778385f, -0.13656689f, 0.01277064f, -0.05407336f, -0.08436839f, 
    0.00563766f, 0.04603122f, -0.09962033f, 0.01649626f, -0.02184904f, 0.02509611f, -0.01335574f, -0.06893285f, 
    0.14670263f, 0.25240597f, 0.05969432f, 0.16147469f, -0.25152311f, 0.14709520f, -0.09486231f, 0.27296576f, 
    -0.14825357f, 0.07387524f, 0.06462973f, -0.05986772f, 0.05672400f, 0.02354032f, -0.03878840f, -0.03906519f, 
    -0.06154902f, 0.31747782f, 0.46491411f, -0.20794193f, -0.08040054f, -0.05472374f, 0.10653519f, -0.00662144f, 
    -0.03256655f, -0.07974087f, -0.02325737f, 0.04097388f, 0.46470448f, 0.26533046f, -0.09153623f, 0.32636344f, 
    0.00356902f, 0.05060728f, 0.15303265f, -0.12838641f, 0.05324556f, -0.04524045f, 0.10315903f, 0.00656182f, 
    -0.14534946f, -0.08439729f, 0.06063322f, -0.07555560f, -0.17788120f, -0.10582000f, -0.24741296f, -0.14573866f, 
    0.04672583f, 0.00344904f, -0.11511972f, 0.09354936f, -0.06802166f, 0.04949150f, -0.10574473f, 0.01688851f, 
    0.03178893f, 0.01455431f, -0.22102389f, -0.02555655f, -0.02414520f, 0.01002833f, 0.04897321f, -0.05294162f, 
    -0.38070774f, 0.52553302f, -0.12061518f, 0.06104911f, 0.00753765f, -0.17587322f, 0.04732551f, -0.02561840f, 
    -0.00768209f, -0.02794982f, 0.01907066f, -0.03670268f, 0.08579243f, -0.27699429f, -0.22995104f, 0.03321152f, 
    0.00123882f, 0.02927969f, 0.02193726f, -0.02184065f, -0.08517616f, 0.11498810f, 0.21148299f, -0.23495886f, 
    -0.01932712f, -0.02308334f, -0.07389086f, -0.17278647f, 0.03944600f, -0.02759473f, -0.08676726f, -0.04643822f, 
    0.04535720f, 0.18056017f, 0.00431559f, 0.00482715f, 0.08909079f, -0.13014419f, -0.01534495f, 0.01233839f, 
    -0.13413240f, -0.00009102f, -0.10707732f, 0.00078175f, -0.06556089f, -0.00995014f, -0.08204725f, -0.05681672f, 
    -0.11088073f, -0.22477777f, 0.61818719f, 0.60754418f, -0.05697864f, 0.06823789f, 0.01687838f, 0.08635955f, 
    0.01595568f, -0.00012140f, -0.04550040f, 0.03862068f, -0.09264433f, 0.08114292f, 0.01728823f, -0.14780721f, 
    0.04693221f, -0.11138702f, -0.13513464f, -0.02234059f, 0.11888878f, 0.06961778f, -0.05536638f, 0.13012613f, 
    -1.08248031f, -0.70483994f, -0.25802356f, -0.65279216f, 0.03568489f, -0.08627389f, -0.02959647f, -0.09828354f, 
    0.01309829f, -0.05939765f, -0.01011848f, 0.04710779f, 0.34115529f, -0.17466760f, -0.44312498f, 0.19750479f, 
    -0.03419469f, -0.09274700f, 0.12324505f, -0.08271383f, -0.07282674f, 0.04740131f, 0.02182113f, -0.06840158f, 
    -0.48272452f, 0.47103739f, 0.54155231f, -0.17271104f, 0.00539747f, 0.05556628f, -0.10176225f, -0.09451285f, 
    0.04471030f, 0.00576783f, -0.06198986f, -0.03638453f, -0.16975462f, -0.17264712f, -0.17659260f, 0.13671945f, 
    0.06663366f, -0.04446918f, 0.03553862f, 0.02764427f, -0.08400477f, 0.14986229f, -0.20367992f, 0.19349004f, 
    0.28423604f, 0.17927615f, 0.09836134f, 0.21497898f, -0.07377778f, -0.02900258f, 0.12819549f, -0.04224421f, 
    0.04855925f, 0.06000542f, 0.02261918f, 0.14092460f, -0.44203702f, -0.22780134f, -0.56294560f, -0.14566047f, 
    -0.00428250f, -0.00995313f, -0.05377953f, -0.27740389f, 0.10540810f, -0.07030371f, -0.00072821f, 0.06724551f, 
    -0.00903894f, 0.03767700f, -0.07103066f, 0.42713678f, 0.06874231f, 0.02542523f, -0.13547418f, 0.08739873f, 
    0.01379661f, 0.03324660f, -0.02381693f, -0.10372352f, -0.48529571f, -0.48714411f, -0.17226940f, -0.33456784f, 
    -0.06214998f, -0.01638211f, 0.07431592f, -0.14480481f, -0.08433975f, -0.03618416f, -0.04264282f, 0.01012519f, 
    -0.13151281f, 0.00372378f, -0.23319431f, 0.16978946f, 0.06514251f, -0.06154612f, -0.02074569f, -0.00038864f, 
    -0.09124441f, 0.12323990f, -0.09385522f, -0.03192222f, -0.31869915f, 0.39545900f, -0.20907387f, -0.64075059f, 
    0.19806729f, 0.29004669f, 0.14914152f, 0.02495768f, -0.34346992f, -0.07037299f, 0.10064991f, 0.04948653f, 
    0.61186951f, 0.63777381f, -0.54446030f, -0.02890558f, -0.00917369f, -0.13566159f, 0.09245671f, -0.02132888f, 
    -0.16724177f, 0.00481708f, -0.02405945f, -0.01008906f, 0.22358693f, -0.31089169f, -0.07490525f, 0.13655443f, 
    0.04446215f, -0.10628878f, 0.01883092f, -0.09823665f, 0.04415328f, 0.11457656f, -0.06199265f, 0.26033658f, 
    -0.36549866f, -0.10902533f, 0.05229365f, -0.02032820f, 0.08405158f, 0.12393226f, -0.24452242f, 0.00513937f, 
    -0.08087631f, 0.04361479f, 0.15153944f, 0.04319766f, 0.46017116f, -0.03734813f, 0.13196480f, 0.26631334f, 
    -0.31748778f, -0.08369576f, -0.42255184f, -0.17498180f, -0.10675652f, -0.20690326f, -0.11060660f, 0.14999151f, 
    -0.34788403f, 0.00695463f, -0.18502668f, 0.03303528f, -0.26238427f, -0.31292433f, -0.01313826f, -0.19279045f, 
    -0.21236075f, -0.04237296f, -0.09824136f, -0.12737437f, -0.01529491f, -0.01658551f, -0.16914076f, 0.12969397f, 
    0.04688867f, 0.04228359f, -0.09066214f, 0.02994637f, -0.03710141f, -0.04862933f, 0.16509038f, -0.10228465f, 
    1.25042987f, -0.03780241f, 0.14000992f, 0.18270850f, 0.15595461f, 0.00724901f, -0.00468147f, -0.09916902f, 
    -0.05684768f, 0.00364976f, 0.00175332f, 0.01625273f, -0.30616504f, -0.68437338f, -0.29772836f, 0.00817490f, 
    0.04531581f, 0.41291380f, -0.26326603f, 0.25989410f, -0.12830636f, -0.08097801f, -0.16751705f, -0.30367616f, 
    -0.13609679f, -0.15240797f, -0.05894206f, 0.17952897f, 0.01535453f, 0.07295437f, 0.02392609f, -0.00674668f, 
    -0.03006987f, -0.07359290f, -0.14693214f, 0.02005341f, 0.03285088f, -0.08873181f, 0.05069647f, 0.15519896f, 
    -0.02094384f, 0.05086074f, 0.04042894f, 0.10964219f, -0.01755711f, 0.09487172f, 0.04666703f, 0.02041061f, 
    -0.20693178f, 0.08035058f, -0.08942473f, 0.06918599f, -0.07721516f, -0.00281091f, 0.01312970f, 0.05996921f, 
    0.17787647f, 0.14375822f, -0.18248475f, -0.06366893f, -0.25922352f, -0.02249583f, -0.14529003f, 0.29153362f, 
    0.02826255f, 0.05657522f, 0.09960487f, 0.06931138f, -0.09593634f, 0.02528932f, 0.02490003f, -0.06805511f, 
    -0.15994705f, 0.10872783f, -0.12005574f, -0.01936339f, 0.08547121f, 0.00592325f, 0.05979444f, -0.03093823f, 
    -0.19091903f, 0.11754190f, 0.05127715f, 0.11789084f, 0.19175884f, -0.09780224f, -0.07797739f, 0.17519900f, 
    -0.06973499f, 0.12043335f, -0.08884077f, -0.12566471f, -0.09453551f, -0.07883816f, 0.12850548f, -0.08090542f, 
    -0.18112269f, -0.28073215f, 0.69787467f, 0.03215668f, -0.04671357f, -0.15079531f, -0.03064609f, 0.17755443f, 
    0.14341599f, -0.10028652f, 0.18179360f, -0.11608554f, 0.10358046f, 0.19347960f, -0.33729279f, -0.09355590f, 
    -0.02683994f, 0.11384231f, -0.02534349f, -0.01867658f, -0.04740652f, -0.21901889f, 0.19003832f, 0.10306336f, 
    -0.11355038f, 0.27436101f, -0.12250891f, 0.45282498f, 0.04928499f, -0.20114301f, -0.06982129f, -0.01606040f, 
    -0.03979556f, 0.05900708f, -0.04570169f, 0.00292911f, -0.33019286f, 0.42451361f, -0.44530258f, -0.35017809f, 
    -0.09912315f, 0.02209582f, -0.06191882f, -0.11846533f, -0.03541487f, -0.04210626f, -0.16136596f, -0.02887989f, 
    -0.21438701f, 0.12995601f, -0.01837624f, 0.40233168f, -0.01442646f, 0.07320322f, 0.24791920f, -0.11373103f, 
    0.07050953f, -0.00804136f, -0.11222931f, 0.12736151f, 0.20192462f, 0.02935212f, 0.06796160f, -0.04587856f, 
    -0.03071027f, -0.21449083f, -0.18255733f, -0.05517822f, -0.01597112f, 0.09948581f, -0.09930165f, 0.02416577f, 
    -0.27764514f, -0.27267170f, -0.05924611f, 0.01473407f, 0.16078056f, 0.12993807f, 0.03696259f, -0.07949758f, 
    -0.21975720f, 0.09388825f, 0.11334094f, 0.11084383f, -0.08634764f, -0.10647836f, 0.36089495f, 0.09216972f, 
    -0.16473792f, 0.01101878f, 0.00099423f, 0.02663137f, 0.09847713f, -0.12530179f, -0.08256165f, -0.00702669f, 
    0.00314358f, -0.25194314f, 0.05422693f, 0.23311333f, 0.09732781f, 0.10990115f, 0.03837638f, 0.20339486f, 
    0.00481038f, 0.08430681f, 0.05532375f, -0.10465012f, -0.36814693f, 0.71216595f, -0.64982748f, -0.36594722f, 
    0.03965719f, -0.27257788f, -0.17864716f, -0.03930371f, -0.20713966f, 0.05421904f, -0.06478440f, -0.24563824f, 
    -1.09251297f, -0.48269561f, 0.02079884f, 0.33953351f, -0.00804654f, 0.06576431f, 0.04037123f, 0.07296133f, 
    0.00782714f, 0.03944105f, 0.16010952f, -0.00760528f, 0.27477458f, -0.19888239f, 0.04923589f, -0.62931687f, 
    -0.23715030f, -0.15879087f, -0.28408846f, -0.21297941f, 0.04697358f, 0.02989183f, 0.00805686f, -0.13151543f, 
    0.38122272f, -0.18765712f, 0.00302693f, 0.28745702f, 0.13915426f, -0.08880414f, 0.07671770f, -0.16281886f, 
    -0.06886820f, -0.00758621f, 0.05129504f, 0.10991262f, 0.16611896f, -0.08900606f, 0.07201040f, -0.12804078f, 
    0.14087108f, 0.13459168f, -0.04266192f, -0.00419190f, -0.00184657f, 0.08256713f, -0.05823557f, -0.05887948f, 
    0.71248740f, -0.30509359f, -0.00224764f, -0.00744515f, 0.05942796f, 0.02290712f, -0.03968656f, -0.05973586f, 
    -0.13115461f, -0.03655965f, -0.03941757f, 0.25036368f, 0.09258600f, -0.10761475f, -0.05057351f, 0.16722471f, 
    -0.00471526f, 0.03735766f, -0.01577311f, -0.02510949f, 0.04384928f, 0.08965506f, -0.01627796f, -0.26210251f, 
    -0.16093697f, -0.08454233f, 0.16173452f, 0.02879985f, -0.21985136f, 0.18008877f, -0.20303382f, 0.00956335f, 
    -0.02941518f, -0.05469016f, 0.08167866f, 0.01615830f, 0.16788235f, -0.03331902f, 0.09014206f, 0.07092010f, 
    -0.03385539f, 0.18070407f, 0.00789018f, 0.13140623f, 0.13732032f, -0.02337895f, -0.31736913f, -0.10723478f, 
    -0.71227747f, -0.45197594f, -0.20090540f, -0.10119855f, 0.13996375f, 0.07914074f, -0.01173870f, -0.01620717f, 
    0.06878214f, 0.02057754f, -0.03827050f, -0.03708584f, -0.18887520f, -0.20779023f, -0.00847818f, 0.04566244f, 
    -0.11104862f, 0.02860944f, -0.04860203f, 0.03579408f, 0.03761166f, 0.00001586f, 0.01292908f, 0.00150251f, 
    0.17863956f, -0.14099775f, -0.52621233f, -0.27207127f, 0.09188881f, 0.01481364f, 0.07544618f, 0.02609010f, 
    0.13478895f, -0.14090884f, 0.05191174f, 0.05676153f, -0.07336848f, 0.08702368f, -0.22889152f, -0.16372597f, 
    0.37439209f, -0.20276953f, -0.01988908f, -0.18420348f, -0.07384327f, -0.12651291f, 0.04062340f, -0.34524494f, 
    -0.39719015f, 0.01688594f, -0.13279103f, -0.11904225f, 0.07677046f, 0.05452169f, -0.12644833f, 0.01663096f, 
    -0.09738018f, 0.07642185f, -0.17946747f, -0.10437215f, 0.09458407f, -0.06338572f, 0.10602359f, 0.02689167f, 
    -0.02521893f, -0.15521574f, 0.02621765f, -0.13754971f, 0.03979802f, -0.08664129f, -0.03131079f, -0.05907982f, 
    -0.19501431f, 0.18876602f, -0.31785518f, 0.03099422f, -0.02505355f, -0.08170295f, -0.00463693f, -0.07384140f, 
    -0.09523208f, -0.20304045f, 0.06124295f, -0.01828452f, 0.05919691f, -0.01423760f, 0.18644318f, -0.08725075f, 
    0.12104452f, -0.07909282f, 0.00044538f, 0.02747674f, -0.10459185f, -0.02527278f, -0.05727296f, 0.00037540f, 
    0.09602905f, 0.14076227f, 0.10395925f, 0.06804650f, -0.11824979f, -0.14312485f, -0.03765245f, 0.08319060f, 
    0.09666123f, -0.05343391f, -0.00431467f, 0.05681649f, 0.13048953f, 0.15389173f, 0.19222373f, 0.16243693f, 
    0.12184643f, -0.06234307f, -0.02491069f, -0.04017310f, 0.15069030f, 0.03420158f, -0.10402282f, 0.19843099f, 
    0.10347994f, -0.01681141f, -0.04466099f, -0.08956530f, 0.06783541f, -0.04917357f, 0.03420908f, -0.07105893f, 
    0.12872083f, 0.14924803f, 0.14689930f, 0.42245844f, 0.17624877f, 0.00300108f, 0.21712850f, 0.02918713f, 
    -0.13317548f, -0.00544260f, 0.00033887f, -0.09440069f, 0.07781263f, -0.06136461f, -0.03559759f, 0.03020650f, 
    -0.02147176f, -0.22507922f, 0.15025492f, 0.18781850f, -0.18598914f, -0.08359474f, -0.21392378f, -0.22024460f, 
    0.15094310f, -0.07742086f, 0.04351868f, -0.06036076f, -0.09882470f, 0.03795296f, 0.07283451f, 0.00857318f, 
    -0.06196112f, -0.03109941f, -0.09388674f, 0.12050754f, 0.06577328f, -0.07313182f, -0.10009857f, 0.00540406f, 
    0.08430704f, 0.22051898f, -0.15710430f, 0.30582672f, 0.12593454f, 0.19627756f, 0.01500527f, -0.08594996f, 
    0.19006446f, 0.14663498f, 0.00177081f, 0.01644130f, -0.16936794f, -0.08472884f, 0.09320397f, 0.25231445f, 
    -0.13051796f, -0.37329498f, -0.10258273f, -0.02351549f, -0.39194515f, -0.02259284f, -0.15132461f, 0.00542998f, 
    0.10247864f, -0.20688921f, 0.21255946f, 0.06430759f, 0.10123711f, 0.13852535f, 0.02459156f, -0.12951596f, 
    -0.10522041f, -0.03734176f, -0.10088029f, 0.03678127f, -0.09403066f, -0.18656467f, 0.15225123f, -0.10839509f, 
    -0.00459392f, -0.09212521f, 0.03313828f, -0.04056093f, -0.03988583f, -0.10941026f, 0.13231596f, 0.25641504f, 
    0.19721431f, 0.04973510f, 0.11221604f, 0.22921966f, 0.27993566f, -0.12767056f, -0.10584781f, 0.00259921f, 
    -0.05271777f, 0.09484954f, 0.09385443f, -0.13786568f, -0.01306672f, 0.07734167f, -0.00173155f, -0.00483730f, 
    0.22026005f, -0.04524696f, 0.06933074f, -0.00465620f, -0.01125475f, -0.14911252f, -0.24337238f, -0.17269804f, 
    0.27158934f, 0.13831501f, -0.15997216f, 0.18221717f, -0.24016763f, -0.08887959f, 0.06285695f, -0.04438490f, 
    0.05934175f, 0.02618225f, -0.00358586f, 0.08164521f, -0.02176878f, 0.06329809f, -0.03857698f, 0.26017371f, 
    0.23320739f, -0.01570469f, -0.11204978f, -0.23256955f, 0.06929443f, 0.16945978f, 0.06148806f, 0.20066927f, 
    0.20384723f, 0.31084815f, 0.32691050f, 0.27669209f, 0.04988690f, 0.04502415f, -0.07184146f, 0.13934548f, 
    0.05493147f, 0.04092920f, -0.06111695f, -0.04905358f, -0.30877727f, -0.34023365f, 0.19194327f, -0.65913486f, 
    0.00537239f, 0.06338980f, -0.03941356f, 0.08674623f, 0.05213947f, -0.03489322f, -0.21716151f, -0.06840026f, 
    -0.39435166f, 0.29658175f, -0.12115750f, -0.04605341f, 0.08726614f, -0.15423518f, -0.09438384f, -0.10403766f, 
    -0.10916377f, 0.01204327f, 0.00586752f, 0.17738345f, -0.26478961f, -0.18873693f, -0.15081860f, -0.07291415f, 
    -0.26028049f, -0.01658987f, 0.03259085f, 0.13253291f, -0.16835451f, -0.12112062f, -0.00998896f, -0.02238288f, 
    -0.03447464f, -0.12266710f, 0.00594213f, 0.06877048f, -0.01588540f, -0.09013601f, -0.05038818f, 0.11120924f, 
    -0.05041700f, -0.00589556f, 0.04552616f, 0.13555066f, -0.08262394f, 0.15135148f, 0.22784153f, 0.30210334f, 
    -0.19919948f, 0.05106997f, -0.39064500f, -0.18168959f, -0.11348180f, -0.06472106f, 0.09725167f, -0.04730297f, 
    -0.67864001f, -0.13561933f, -0.24409337f, 0.01845513f, -0.21777946f, -0.04276544f, 0.04552507f, -0.15859717f, 
    0.00964553f, 0.03950937f, 0.04023723f, 0.00551812f, -0.02870879f, 0.22194339f, 0.17986612f, 0.21826707f, 
    -0.13507429f, -0.04992447f, 0.01224537f, 0.05717990f, 0.03035751f, 0.00119247f, -0.02295630f, -0.02028640f, 
    0.09985606f, 0.01123025f, 0.23802914f, -0.26989201f, 0.03426592f, -0.07351001f, -0.14765280f, 0.03419986f, 
    0.07134251f, -0.05961527f, 0.02961508f, 0.21625842f, -0.31341958f, -0.36197859f, 0.35235608f, 0.04478811f, 
    -0.03163750f, -0.14191474f, -0.07826663f, -0.16201156f, 0.20432390f, 0.05892514f, 0.08019032f, 0.06664041f, 
    -0.50471693f, 0.34014782f, 0.03480748f, -0.26331562f, 0.03841932f, -0.02852230f, 0.01456869f, 0.17597894f, 
    -0.10104526f, -0.17855458f, 0.16330294f, -0.11677189f, -0.29390267f, 0.13145223f, 0.11793559f, -0.20769751f, 
    0.00708237f, -0.20831423f, -0.01257721f, 0.09854983f, -0.08660582f, -0.09227270f, 0.03396347f, 0.13556753f, 
    -0.48676839f, -0.03681473f, -0.49677923f, -0.05278996f, -0.00429822f, 0.01807057f, -0.04739320f, -0.02545798f, 
    0.08296216f, 0.08279286f, 0.07258521f, -0.16036043f, -0.45804444f, 0.12745099f, -0.45893165f, 0.25346667f, 
    0.21907209f, -0.05578625f, 0.15814100f, 0.26475701f, 0.26373208f, -0.16638480f, 0.16273797f, 0.25632760f, 
    -0.04521339f, 0.02300425f, -0.20177935f, 0.30993250f, 0.02770491f, -0.01511875f, -0.10797669f, 0.03721941f, 
    0.03923648f, 0.23606583f, -0.06178922f, -0.14498226f, 0.09491155f, 0.25055802f, 0.08642074f, 0.00608771f, 
    0.16930754f, 0.11560044f, -0.01174343f, -0.12607372f, 0.11650226f, 0.13133574f, 0.09325905f, 0.03137439f, 
    -1.15921974f, -0.46864581f, -0.13390747f, -0.03814099f, -0.05835987f, -0.19265461f, -0.03512067f, 0.08768335f, 
    0.17251925f, 0.02737183f, -0.04987151f, 0.03487104f, 0.07173651f, 0.15136738f, -0.12837763f, 0.11789099f, 
    -0.06552051f, 0.23139471f, 0.27677450f, -0.14341439f, 0.09173029f, -0.01699959f, -0.05437132f, 0.11706385f, 
    -0.10288507f, -0.16078265f, 0.00947016f, -0.16689596f, 0.04140622f, -0.05686538f, 0.01780132f, 0.11260145f, 
    -0.02170353f, -0.02306905f, 0.04403284f, -0.10399216f, -0.34823319f, 0.10847256f, 0.25168887f, -0.24877253f, 
    -0.13511644f, 0.09254695f, -0.09150822f, -0.09221163f, 0.16990180f, -0.23286520f, -0.14086150f, -0.12743901f, 
    0.03560362f, -0.19505997f, -0.04965056f, -0.02178900f, 0.01080277f, 0.07836945f, 0.06291419f, 0.05648464f, 
    -0.05328679f, -0.51432395f, -0.23008430f, -0.68543369f, 0.25388721f, -0.14833529f, 0.14084215f, -0.17668797f, 
    0.16204652f, 0.06425948f, -0.13918318f, 0.21764490f, 0.03410374f, -0.01614797f, 0.00258992f, 0.00338797f, 
    0.07892951f, 0.15572600f, -0.01027715f, -0.13526504f, 0.18670972f, 0.00240153f, 0.02449570f, -0.09617401f, 
    0.10362067f, -0.19082229f, -0.03876533f, -0.11318273f, 0.39199594f, -0.14329645f, -0.02451406f, -0.01230669f, 
    0.03921278f, -0.05966251f, 0.00625991f, 0.00390082f, -0.04270495f, 0.04842429f, 0.04908071f, -0.13703980f, 
    -0.09471180f, -0.06479894f, -0.34861648f, 0.24499884f, 0.04894982f, -0.05166348f, -0.06162331f, -0.02961989f, 
    -0.30157253f, 0.09771119f, -0.12679385f, -0.10194644f, 0.12565193f, 0.03443942f, 0.31928477f, -0.12085975f, 
    0.00761661f, 0.06409946f, 0.24529369f, 0.04584464f, 0.13310491f, -0.05548247f, -0.11677127f, 0.12367007f, 
    0.34407079f, 0.08264584f, 0.23232494f, -0.01010773f, 0.02328056f, 0.21075445f, -0.02327896f, 0.07675143f, 
    0.10725851f, -0.02449377f, -0.00382254f, 0.03458149f, 0.11056099f, -0.27647018f, 0.36632314f, 0.25671643f, 
    -0.03542667f, 0.02432022f, 0.00303579f, 0.01204478f, 0.03750991f, 0.12136699f, -0.18391228f, -0.10380057f, 
    0.16747490f, -0.10253359f, 0.06192819f, -0.25404036f, 0.15699674f, -0.06998922f, -0.12092716f, 0.14534967f, 
    -0.27469474f, -0.02321386f, 0.19961740f, -0.06629696f, -0.04034057f, -0.15335123f, -0.15064514f, -0.00159139f, 
    -0.13137498f, -0.03457985f, -0.13848320f, -0.12005748f, 0.04982167f, 0.03671597f, 0.22627200f, 0.00009100f, 
    -0.66505492f, -0.46850720f, -0.09667239f, -0.28073218f, -0.06518227f, 0.07509894f, -0.12796377f, 0.01234853f, 
    0.20177066f, -0.14591099f, -0.11750959f, 0.04537972f, 0.14108482f, -0.08036183f, -0.26568341f, 0.18460499f, 
    0.14234240f, 0.17658637f, 0.00793865f, 0.13290636f, -0.22303557f, -0.19856584f, 0.01252603f, -0.15171126f, 
    0.10130379f, 0.09672350f, 0.09270450f, -0.22558373f, 0.05135922f, 0.33674952f, -0.15326396f, -0.28792289f, 
    0.09646481f, -0.08686813f, 0.01062418f, 0.02609924f, 0.29899913f, -0.29098403f, 0.04420590f, 0.15442052f, 
    0.08934452f, 0.01953071f, -0.07637982f, 0.04897324f, -0.06879204f, -0.12399551f, 0.12839095f, 0.02661287f, 
    -0.01145194f, -0.21834540f, -0.58055598f, -0.57455045f, 0.06123706f, 0.14630474f, -0.09026939f, 0.14660446f, 
    0.37640062f, -0.06211672f, -0.20234066f, -0.33049238f, -0.02991467f, -0.26759765f, 0.12357134f, 0.31330442f, 
    0.08218642f, 0.02369021f, -0.12279768f, 0.05504365f, 0.04285833f, 0.10379501f, 0.24560860f, 0.02244691f, 
    -0.39272428f, 0.15466209f, -0.26691920f, -0.19045995f, -0.08412456f, -0.08299673f, 0.08876754f, 0.28472248f, 
    -0.08036560f, -0.22156964f, 0.00715159f, 0.00254937f, 0.39662918f, 0.00988933f, -0.03329147f, 0.34783217f, 
    0.14026980f, 0.02246912f, -0.00387497f, -0.14248912f, -0.16112046f, 0.12910704f, -0.07075954f, -0.15138444f, 
    -0.06881578f, -0.17661147f, 0.21243943f, 0.06466708f, -0.05873960f, -0.05581012f, -0.16915023f, 0.33073887f, 
    -0.12321917f, -0.03905836f, 0.00190662f, 0.04932510f, 0.11728508f, 0.10140279f, 0.13787772f, 0.01017007f, 
    0.28765428f, 0.35678312f, 0.12268980f, 0.10394062f, 0.02421745f, -0.04362925f, 0.03615008f, 0.14489353f, 
    -0.60144180f, -0.77756065f, -0.51972735f, 0.05604935f, -0.22560675f, -0.20365569f, 0.06514512f, -0.13671592f, 
    -0.00003940f, 0.11840144f, -0.10483116f, -0.03380167f, -0.13821559f, 0.02872873f, 0.15340398f, 0.01199016f, 
    0.00343675f, -0.11996043f, -0.09597148f, 0.04470588f, -0.10427362f, 0.20895541f, 0.01103497f, 0.12217782f, 
    -0.03232027f, 0.02248832f, 0.07693547f, 0.16004834f, 0.05596661f, 0.00923743f, 0.02626069f, -0.06776419f, 
    -0.01033558f, 0.14365239f, 0.04804561f, 0.00242803f, -0.77180839f, -0.75258094f, -0.03244336f, 0.10911983f, 
    -0.23328182f, -0.02591219f, 0.11350272f, 0.08629312f, 0.00514755f, 0.07667068f, 0.02408569f, -0.07459402f, 
    -0.15984924f, -0.09082334f, -0.12124354f, -0.29687363f, 0.13946702f, -0.04030579f, -0.12167627f, -0.01563358f, 
    -0.06346029f, -0.05879010f, -0.06213757f, -0.42594948f, 0.25472304f, -0.18867511f, 0.27544224f, 0.13069814f, 
    0.17552787f, -0.02471327f, 0.14883710f, -0.24554807f, 0.01575664f, -0.13439594f, 0.00742331f, -0.13682917f, 
    0.24401611f, 0.02459520f, -0.17976779f, -0.07768784f, -0.02314933f, -0.09415465f, 0.19352818f, 0.01791991f, 
    0.01193796f, 0.04432501f, -0.01256363f, -0.17780910f, -0.92426908f, -0.41703093f, 0.34741664f, -0.39363045f, 
    -0.04331904f, -0.19506806f, -0.14341377f, -0.32784417f, -0.16946158f, 0.05984145f, -0.01766846f, 0.02632614f, 
    -0.06030285f, -0.07667737f, 0.30808735f, 0.59253836f, 0.02142094f, -0.03308478f, -0.24456961f, -0.02898123f, 
    -0.08203761f, 0.12222029f, 0.11599855f, -0.01869131f, 0.01391553f, 0.08945833f, 0.16082369f, 0.06958609f, 
    -0.01448707f, -0.27570403f, 0.06946355f, -0.17845728f, -0.03377694f, -0.32376704f, -0.04840488f, 0.10443598f, 
    0.00902942f, 0.29108310f, 0.02595663f, -0.02209306f, -0.03356970f, -0.00910277f, -0.09469935f, 0.05154432f, 
    0.05363552f, 0.04178083f, 0.02065122f, 0.07543222f, -0.32391903f, -0.76756012f, -0.44399759f, 0.06604113f, 
    -0.16179226f, -0.15439057f, 0.23975058f, -0.17179039f, 0.04706592f, 0.03496525f, 0.08520241f, 0.14575824f, 
    0.11247556f, 0.09914794f, -0.04809838f, -0.04181254f, -0.03352104f, 0.04696486f, 0.10414947f, 0.11497005f, 
    0.06961825f, 0.18744841f, 0.38123214f, 0.23471859f, 0.38518098f, 0.69821811f, -0.18625323f, -0.20455846f, 
    -0.16213982f, -0.12493549f, -0.19646281f, 0.25528246f, 0.01779620f, -0.06656911f, -0.08569206f, 0.02044385f, 
    -0.42684397f, 0.18755458f, 0.15288675f, -0.29057342f, -0.20664108f, 0.14481324f, -0.11881044f, 0.03823857f, 
    -0.08436249f, 0.17502227f, 0.05461631f, -0.17918521f, 0.41725722f, 0.31891200f, 0.02104203f, 0.08793174f, 
    -0.01100276f, 0.03483136f, -0.13698153f, 0.20919624f, 0.00963321f, 0.17192917f, -0.02724068f, 0.11047704f, 
    0.23585096f, -0.07724282f, -0.11825243f, -0.22885117f, -0.12066898f, -0.01632466f, 0.21731588f, 0.03274402f, 
    0.05424716f, -0.08814587f, 0.05815718f, -0.01874201f, -0.39493641f, -0.53956956f, -0.13602565f, 0.22182173f, 
    0.00471612f, 0.04992692f, 0.21612051f, 0.12413290f, -0.00428598f, -0.15866438f, 0.03012594f, -0.08320558f, 
    -0.56977266f, -0.97202319f, -0.88675243f, 0.22578357f, 0.10612470f, 0.10710360f, -0.02928817f, -0.31182745f, 
    -0.00802564f, 0.04364594f, 0.07059163f, 0.06994759f, 0.11830129f, 0.02879021f, 0.00429913f, -0.16396731f, 
    -0.05312882f, -0.04349685f, 0.01429616f, 0.18601575f, 0.02156077f, 0.07896142f, 0.32376906f, 0.37758195f, 
    -0.11960301f, -0.18331909f, 0.03528731f, 0.04605748f, -0.17622709f, 0.20378233f, 0.08353918f, -0.36559758f, 
    0.06844880f, 0.01862703f, -0.02799229f, 0.01804309f, -0.04930761f, 0.04469899f, 0.00245606f, -0.14270738f, 
    -0.04476531f, -0.15426710f, 0.08684114f, -0.06142041f, -0.07258917f, -0.09049151f, -0.05340013f, -0.00000988f, 
    -0.73341990f, -0.01057987f, 0.44026586f, -0.00137269f, -0.10670830f, -0.17687272f, -0.04173927f, 0.03703239f, 
    -0.03542954f, 0.09842942f, -0.02741422f, 0.00575225f, 0.18233442f, -0.22088923f, -0.06819988f, -0.07063974f, 
    -0.10217523f, 0.15075219f, 0.18988350f, -0.09016390f, 0.02549863f, -0.00518061f, 0.14181052f, 0.12497184f, 
    -0.68161565f, -0.97927654f, -0.23754445f, -0.31181219f, -0.00367381f, -0.18423888f, -0.22388341f, -0.47010431f, 
    0.04581150f, -0.00436136f, 0.02070668f, -0.05941484f, -0.09144083f, 0.03125753f, -0.07265440f, 0.00574532f, 
    0.00433175f, 0.05332152f, -0.13442214f, 0.08870768f, 0.01010932f, 0.01154297f, 0.02940343f, -0.06946664f, 
    0.62757587f, 0.41212234f, 0.08928400f, 0.07175038f, 0.09733301f, -0.05794970f, 0.18023261f, 0.05954736f, 
    0.09467779f, -0.04095912f, 0.20854455f, 0.23243704f, 0.11612403f, -0.00342179f, -0.28295541f, 0.27472991f, 
    -0.00564496f, 0.13126105f, 0.03396453f, 0.24220523f, -0.02847358f, -0.10450762f, 0.18812223f, -0.25146022f, 
    0.01654661f, -0.02521691f, 0.14375557f, 0.17435911f, -0.05732668f, 0.17240532f, 0.12789318f, 0.01244297f, 
    -0.00313196f, 0.13612026f, -0.03335843f, -0.05754273f, 0.43527904f, 0.07647392f, -0.50148243f, -0.62693596f, 
    -0.10353585f, 0.00541671f, -0.00856409f, 0.09929647f, 0.03884018f, 0.04763301f, -0.09242541f, -0.13519484f, 
    -0.07639077f, -0.34989023f, -0.69597089f, 0.31292433f, -0.06920582f, 0.01775043f, 0.34602806f, 0.24853346f, 
    0.07346254f, 0.00440483f, 0.03636186f, -0.04340748f, -0.85983175f, -0.71364933f, -0.60408169f, -0.40501192f, 
    -0.37571663f, -0.41443455f, -0.16893730f, -0.38259163f, -0.06685597f, -0.01956545f, -0.09577633f, -0.10538226f, 
    -0.48815212f, -0.57039642f, 0.14685360f, -0.05471212f, -0.14669561f, 0.03775075f, 0.10063279f, 0.25129691f, 
    -0.06707777f, -0.06641325f, -0.07570481f, -0.05946451f, 0.26767173f, 0.07776171f, -0.13194527f, -0.24633776f, 
    0.01710649f, 0.01473513f, 0.07111371f, 0.05371156f, -0.08602367f, -0.26657698f, -0.05645171f, -0.27480939f, 
    0.01808137f, -0.00909660f, 0.08933604f, 0.01198641f, 0.11834935f, -0.02330198f, -0.01277476f, -0.12797812f, 
    -0.01324115f, 0.01341752f, 0.05170028f, -0.16533831f, -0.10715733f, -0.54362601f, -0.32192779f, -0.29619488f, 
    0.00716624f, 0.08834822f, 0.08646514f, 0.11725924f, 0.07328743f, -0.02302948f, -0.14619334f, 0.02033409f, 
    -0.07456775f, 0.03492711f, 0.00986726f, -0.05027796f, 0.01843204f, -0.02759199f, 0.05615116f, -0.05832485f, 
    0.08973456f, -0.03490307f, -0.05287724f, -0.02109690f, -0.49415749f, 0.57957810f, -0.18733250f, 0.11336177f, 
    -0.20421235f, 0.21711439f, 0.07021118f, -0.00433982f, 0.06085006f, 0.03750227f, 0.12654883f, -0.19989543f, 
    -0.10867240f, 0.00947346f, -0.18265270f, 0.00666116f, -0.04291768f, 0.00703218f, -0.05532848f, -0.00137677f, 
    -0.01396421f, 0.10005702f, -0.13427779f, -0.06602385f, -0.40618122f, 0.61319095f, -0.29540324f, 0.46089819f, 
    0.08415147f, -0.12695597f, -0.11444563f, -0.00005526f, -0.00209009f, -0.10607183f, -0.03622450f, 0.05982435f, 
    0.76081622f, -0.61339217f, -0.06261992f, -0.34682882f, -0.01869546f, 0.15722401f, -0.19088884f, -0.01384575f, 
    0.12156238f, -0.02180868f, 0.07264227f, -0.01406779f, 0.03225812f, 0.02920471f, 0.06217983f, -0.08143491f, 
    0.01687243f, -0.01491971f, 0.01033617f, -0.00338722f, -0.22191787f, 0.01064848f, 0.06539932f, 0.05507010f, 
    0.29047731f, -0.20075440f, -0.09142107f, -0.18569972f, -0.06339420f, 0.08628358f, -0.01184181f, -0.03548621f, 
    0.18983771f, 0.08958545f, -0.02758848f, -0.02072475f, 0.04899669f, -0.10789124f, 0.13578095f, -0.02710623f, 
    -0.15270643f, -0.00440443f, 0.09035306f, -0.02665968f, 0.06467433f, -0.03055913f, 0.07273457f, 0.02461243f, 
    0.00059513f, 0.12712570f, 0.06577647f, 0.01922719f, -0.00388955f, -0.04182787f, -0.04563961f, -0.03583719f, 
    -0.06761184f, 0.02177665f, 0.14497599f, -0.12726150f, -0.89692098f, -0.66801661f, -0.44433475f, 0.04338504f, 
    -0.06205266f, -0.11062521f, 0.16204880f, -0.08516235f, -0.10537045f, 0.06630587f, -0.01816236f, 0.02075434f, 
    0.21697958f, -0.43579704f, -0.37497881f, -0.06504748f, -0.03075933f, 0.04393789f, 0.18202640f, 0.06211694f, 
    0.12761143f, 0.04088985f, 0.07100660f, -0.09394239f, 0.02326262f, -0.16118072f, -0.23882566f, -0.04942959f, 
    -0.07165575f, -0.08802759f, 0.03811021f, 0.03036230f, -0.07535989f, -0.00364784f, -0.01715677f, -0.03730831f, 
    -0.00235823f, 0.12373839f, -0.27317712f, -0.01291519f, 0.05882895f, -0.04760042f, 0.16895323f, 0.03138493f, 
    0.01051524f, 0.10619977f, 0.03293178f, 0.06524836f, 0.27602035f, -0.45718986f, -0.10991833f, -0.03768661f, 
    0.03927427f, 0.12004410f, 0.04764325f, -0.14763694f, 0.01312404f, 0.01938432f, 0.04215368f, -0.10957187f, 
    -0.20893157f, -0.58348614f, 0.64191800f, 0.17556840f, -0.12712625f, -0.05093975f, -0.08007154f, -0.05523098f, 
    -0.02400588f, 0.03299193f, -0.11832862f, 0.00277341f, 0.29029012f, 0.03189551f, -0.30496120f, -0.11275665f, 
    0.05138617f, -0.04800576f, -0.04405015f, -0.03933439f, 0.12174813f, -0.02054534f, 0.17948967f, -0.10448005f, 
    -0.05737600f, 0.07904670f, 0.04288934f, -0.01822777f, 0.14317860f, 0.04556266f, 0.04803139f, 0.07038354f, 
    -0.07230856f, -0.20081098f, 0.02518702f, 0.05242961f, 0.06091795f, 0.03704652f, -0.00002296f, 0.09246429f, 
    -0.09017254f, -0.20321400f, 0.13092878f, -0.06196510f, -0.04408937f, -0.01604392f, 0.01185149f, -0.02884815f, 
    0.93002307f, -0.40596405f, -0.30829522f, -0.59902650f, -0.20997488f, -0.09549736f, -0.31579128f, 0.08883603f, 
    0.06504719f, 0.11184929f, 0.09325082f, 0.08423501f, 0.04419800f, 0.02461435f, 0.00880055f, -0.00038069f, 
    0.03613304f, 0.02473853f, 0.04654018f, 0.04704075f, 0.16266128f, 0.07144144f, -0.00439302f, 0.02562828f, 
    -0.78880000f, -0.61257190f, 0.44553363f, 0.57550317f, 0.01075758f, 0.03266438f, 0.06012714f, 0.21970960f, 
    0.04381903f, 0.03602465f, -0.01349673f, 0.03716035f, 0.02922476f, -0.04477097f, -0.35876235f, 0.06552409f, 
    0.03368923f, -0.03008309f, 0.01287582f, -0.07278184f, 0.02130774f, 0.04474529f, -0.13756254f, -0.07300488f, 
    -0.22504331f, 0.13375449f, 0.07986715f, 0.32881507f, -0.05974679f, 0.10270923f, 0.13694228f, 0.09592573f, 
    -0.13053124f, -0.16994600f, -0.03440906f, -0.04735692f, 0.20736961f, -0.19625109f, 0.15672907f, -0.20733011f, 
    -0.08059857f, 0.03808577f, -0.03494889f, -0.09806105f, -0.08006839f, -0.02615836f, -0.07466728f, -0.11602131f, 
    -0.08790267f, -0.31128865f, -0.28860742f, -0.08837523f, 0.10968151f, -0.07412241f, 0.14415266f, -0.01572713f, 
    0.10600987f, -0.10102917f, -0.09520072f, 0.03222663f, -0.53239578f, -0.56236941f, -0.06217757f, 0.59766924f, 
    0.02039970f, 0.05765866f, 0.02684635f, 0.00865679f, -0.01366070f, -0.16180865f, 0.03922953f, -0.01195291f, 
    0.12605838f, -0.22248170f, -0.30456966f, -0.25391600f, -0.01122458f, 0.31241044f, -0.24309124f, -0.06276266f, 
    0.07976276f, 0.01220384f, -0.10462390f, -0.01250675f, -0.52035093f, -0.42121732f, -0.27309003f, 0.46000180f, 
    -0.01174486f, -0.12224806f, -0.17920879f, 0.10454471f, 0.00273486f, 0.06315950f, -0.04208294f, -0.02505211f, 
    0.20696405f, -0.58541042f, -0.64776427f, -0.58391219f, -0.17402202f, -0.19371210f, 0.17421357f, -0.31773415f, 
    0.04347582f, -0.04954144f, 0.08759417f, 0.07432174f, -0.03395722f, -0.10305334f, -0.07898018f, -0.13742699f, 
    -0.10218477f, -0.07051875f, -0.04424733f, -0.08506801f, 0.14328229f, 0.14239328f, 0.27186921f, 0.21431607f, 
    0.13244063f, -0.03970937f, 0.16455495f, -0.21502018f, -0.23095377f, -0.07084769f, 0.04778991f, -0.15557830f, 
    -0.10371316f, -0.01285352f, -0.05465105f, -0.02326377f, 0.10725538f, -0.36440110f, -0.56379962f, 0.09975640f, 
    -0.04077786f, 0.01195314f, 0.20800111f, -0.05704881f, -0.10730685f, -0.12738994f, 0.08395540f, -0.04373803f, 
    -0.61715806f, 0.16211091f, 0.00755618f, -0.18946509f, -0.05741286f, -0.04168852f, -0.01172520f, -0.05487469f, 
    -0.11771429f, -0.02116788f, -0.13581197f, -0.01096431f, -0.52413881f, 0.11585624f, 0.13521826f, 0.35290107f, 
    0.08266269f, 0.13831760f, -0.18500149f, 0.09640558f, 0.05995634f, 0.10974123f, 0.16388114f, 0.23824844f, 
    -0.03186573f, 0.14551784f, 0.11518256f, -0.00330134f, 0.05293071f, 0.06467232f, 0.03411673f, 0.02002901f, 
    0.10613476f, -0.14439766f, 0.22991490f, 0.15753596f, 0.06495363f, -0.57031906f, -0.54851872f, 0.25173676f, 
    0.03580088f, 0.07469738f, 0.26667896f, 0.29999167f, 0.08441654f, 0.17138353f, 0.15321967f, 0.06651445f, 
    -0.50543952f, -0.26033312f, -0.46285975f, 0.32371205f, 0.12968484f, 0.11169818f, 0.07097477f, 0.11967303f, 
    0.05112382f, 0.16777024f, 0.07681840f, -0.06526245f, -0.20884751f, -0.01207365f, 0.09752838f, -0.08142376f, 
    -0.06368817f, -0.00926090f, 0.01411606f, 0.06409477f, -0.02949482f, 0.12470125f, -0.17354205f, 0.08119468f, 
    -0.23021260f, -0.49667770f, -0.13215080f, -0.15297697f, 0.04773489f, 0.14124273f, 0.07864259f, 0.07243168f, 
    -0.10378524f, -0.06046844f, -0.22904614f, -0.21896951f, -0.08857692f, 0.00684356f, 0.01993230f, -0.32072231f, 
    0.02786274f, 0.02912665f, 0.04829490f, 0.04100743f, 0.11104211f, 0.07882281f, -0.09709454f, -0.20154065f, 
    -0.22660856f, -0.10253088f, -0.00121139f, 0.02833214f, -0.04344931f, -0.02931333f, -0.02223977f, -0.06572120f, 
    -0.03549458f, -0.16290607f, -0.12935147f, -0.42545566f, 0.28010884f, -0.79366988f, -0.45857641f, 0.00815828f, 
    0.10777633f, 0.03741499f, 0.07982980f, 0.13424473f, -0.18749586f, -0.03643959f, 0.04029913f, -0.00926096f, 
    0.21888696f, -0.19658102f, -0.43295440f, -0.19679034f, -0.02098385f, 0.11490893f, 0.14450647f, 0.11759309f, 
    -0.04852548f, -0.08774000f, -0.32451981f, -0.08873854f, -0.26293880f, -0.04698227f, -0.03288880f, 0.16139759f, 
    0.08899710f, 0.13148685f, 0.01653728f, 0.29572678f, -0.22311954f, 0.07682682f, 0.06389365f, 0.04165840f, 
    -0.35329461f, -0.11032860f, 0.09753954f, 0.01171596f, 0.02640366f, 0.06443578f, -0.29402813f, 0.02000963f, 
    -0.18155752f, -0.28036484f, 0.00690219f, -0.23438014f, 0.57333213f, 0.17601341f, 0.02596038f, -0.20958060f, 
    -0.18508446f, -0.19381940f, -0.01829108f, -0.21549043f, 0.06167541f, 0.07372309f, 0.09816881f, 0.07976994f, 
    0.73331553f, -0.26263413f, -0.03467140f, -0.38754386f, -0.02572526f, -0.01722323f, 0.05353912f, -0.13937756f, 
    0.03245530f, 0.14201519f, 0.08395510f, 0.09986322f, 0.23895942f, -0.06136782f, -0.24612044f, -0.23325843f, 
    -0.00897998f, 0.03207282f, -0.03876376f, 0.07852008f, 0.25205579f, 0.01885379f, -0.07572185f, -0.04307789f, 
    -0.22640908f, 0.01450204f, -0.11897931f, 0.24621151f, 0.18352865f, -0.02788117f, -0.03234187f, -0.05904150f, 
    0.02258130f, -0.18787013f, -0.17651328f, -0.13562410f, -0.03632164f, -0.04356792f, -0.09124978f, -0.00552706f, 
    0.10953017f, 0.11801283f, 0.06098848f, -0.07541000f, 0.06331249f, 0.05066468f, 0.14517359f, 0.15548307f, 
    -0.31965628f, -0.71748161f, -0.64381075f, -0.27739671f, 0.07491646f, 0.13372663f, 0.15161210f, 0.19394566f, 
    0.08534871f, 0.01857684f, -0.08483288f, 0.04059800f, -0.11971203f, -0.07258803f, 0.00929622f, 0.10057916f, 
    -0.14368621f, 0.05600794f, -0.22785263f, 0.09318934f, -0.39943901f, 0.25668100f, -0.19817039f, -0.41948253f, 
    -0.28125280f, -0.51012939f, -0.16209483f, -0.11980341f, -0.05182705f, -0.10222135f, -0.06739291f, 0.04882625f, 
    0.08806609f, -0.02219199f, 0.00936825f, 0.02637232f, 0.13579491f, -0.06755271f, 0.02458363f, -0.02869398f, 
    -0.05439435f, 0.03023342f, 0.04844822f, -0.09340008f, 0.02616705f, -0.10186862f, -0.05723040f, 0.03553243f, 
    -1.05690861f, -0.40462056f, 0.44709051f, 0.44110087f, -0.03381568f, 0.11194233f, -0.11937213f, 0.04256703f, 
    0.24784127f, 0.17894343f, 0.03656799f, 0.18112428f, 0.52705938f, 0.31443161f, -0.03053563f, -0.35543057f, 
    0.16485327f, -0.14984402f, 0.12947796f, -0.03489638f, 0.08502087f, -0.07827644f, 0.16647351f, 0.11635979f, 
    -0.21035835f, -0.31892580f, 0.00999152f, 0.28704977f, 0.05656373f, 0.21837281f, -0.00929391f, 0.31109080f, 
    -0.24113998f, -0.07466467f, -0.37387249f, -0.52830398f, 0.23611282f, 0.42912292f, -0.39196265f, -0.07857238f, 
    0.20907947f, 0.07106765f, -0.00744153f, 0.28413072f, -0.02276363f, 0.14390461f, 0.21995816f, 0.14354554f, 
    0.15773989f, 0.07517861f, -0.32161951f, -0.00380096f, 0.23166873f, 0.16657688f, 0.10018262f, -0.02031258f, 
    0.06184524f, -0.08363336f, 0.11263561f, -0.07944495f, -0.28299043f, -0.44966576f, -0.14273012f, 0.16612452f, 
    -0.07475592f, -0.06673889f, -0.11272181f, -0.08471930f, 0.09216238f, 0.01297241f, 0.01522684f, 0.07871647f, 
    -0.29826531f, 0.18426305f, 0.40097123f, -0.18174200f, -0.17103665f, -0.13450232f, 0.07448249f, 0.16830805f, 
    0.02539793f, 0.10694051f, 0.07023096f, -0.01157227f, 0.20405121f, 0.07015228f, 0.14893287f, 0.31584790f, 
    0.10316908f, 0.04492275f, -0.26718155f, 0.11158930f, -0.05351551f, -0.12993298f, 0.00479758f, 0.11216907f, 
    0.14069980f, -0.47009429f, 0.34038380f, -0.28533030f, -0.09569191f, 0.05383667f, -0.15592445f, 0.05636332f, 
    0.01716703f, 0.06710833f, -0.07522709f, 0.10497275f, -0.60940295f, 0.12700842f, 0.23035786f, -0.38573879f, 
    -0.10522779f, -0.07258020f, 0.04587421f, -0.02819553f, 0.11412413f, 0.08080072f, 0.08119047f, -0.02780934f, 
    -0.08078569f, -0.02313644f, -0.09668978f, 0.07548209f, 0.00952867f, 0.05184510f, 0.11562069f, -0.00575967f, 
    0.10343791f, 0.14420295f, 0.05868670f, -0.09421240f, -0.62898850f, 0.38296628f, -0.65463930f, -0.96489859f, 
    -0.12488680f, -0.01544880f, 0.11088311f, 0.10559667f, -0.08482295f, -0.05233729f, -0.09965683f, -0.12307318f, 
    -0.22792390f, 0.35971680f, -0.17407730f, 0.00784824f, 0.11753011f, -0.06656564f, 0.06740166f, -0.15598330f, 
    0.19176672f, -0.06773371f, -0.00923546f, -0.05728103f, -0.53436661f, 0.19671378f, -0.43153101f, -0.15286981f, 
    -0.08321408f, -0.22726080f, -0.17465030f, 0.15399504f, 0.04935563f, -0.10177316f, 0.03183386f, -0.00290868f, 
    -0.34659863f, 0.18435951f, 0.15215051f, -0.14677316f, -0.29860985f, -0.16643268f, -0.06818125f, -0.32018477f, 
    0.16938317f, -0.06609580f, -0.09186869f, 0.13242444f, 0.34337246f, 0.35544574f, -0.14674129f, -0.05355228f, 
    0.03766252f, -0.21257323f, -0.00176747f, 0.02950036f, 0.12328272f, 0.05110822f, 0.02187326f, 0.02530007f, 
    0.21223147f, 0.27485737f, 0.19353311f, -0.09062500f, -0.24550420f, -0.21634801f, -0.22239226f, -0.19354224f, 
    0.04081328f, 0.12136582f, 0.07315544f, 0.13075428f, -0.33577248f, -0.25108799f, 0.06707375f, -0.07344089f, 
    0.05030052f, 0.19290401f, -0.02156288f, 0.07570297f, 0.14471537f, 0.14681694f, -0.02660220f, 0.01959049f, 
    0.07039313f, -0.11954623f, 0.10493282f, -0.10780609f, 0.04138816f, 0.02500069f, 0.04571135f, -0.01708222f, 
    0.15034327f, 0.04322856f, 0.22174178f, 0.28370941f, 0.00387445f, 0.39100784f, 0.75793070f, -0.61073804f, 
    0.14209700f, -0.39355472f, 0.04999912f, -0.21614824f, -0.14162609f, 0.06029661f, 0.06532510f, -0.01145485f, 
    -0.22513893f, -0.05691665f, 0.24690790f, 0.44620800f, 0.20537356f, -0.05025598f, -0.30491370f, 0.00041340f, 
    0.23053136f, 0.15618290f, -0.03740402f, 0.03424891f, -0.29500464f, 0.35224578f, 0.00149781f, -0.29501545f, 
    -0.02854966f, -0.40349576f, 0.06574582f, -0.27746278f, -0.04698126f, 0.13528503f, -0.00879790f, 0.12605658f, 
    -0.15638721f, 0.35919380f, -0.46854854f, 0.05556796f, 0.07378656f, -0.01312352f, 0.27509612f, 0.13283657f, 
    0.06645593f, -0.08854621f, -0.05289146f, -0.10495608f, 0.21161275f, -0.82771629f, 0.24539261f, -0.15867531f, 
    0.15941665f, -0.03887935f, -0.02969905f, -0.16762301f, -0.19704591f, -0.01936493f, -0.02255994f, -0.17889774f, 
    0.05980672f, -0.82287765f, -0.04945607f, -0.08731502f, -0.05648061f, -0.02902165f, -0.09890177f, 0.21005158f, 
    -0.07006750f, 0.01380055f, 0.04220998f, -0.08110601f, -0.29438406f, -0.09836936f, 0.09014597f, 0.21248826f, 
    0.00808306f, 0.00003651f, -0.13598266f, -0.15635070f, -0.16806178f, -0.11311308f, 0.07970771f, 0.18267556f, 
    0.16943316f, 0.10952881f, 0.09365123f, -0.34759539f, -0.25353071f, 0.10284619f, 0.09167519f, 0.28100494f, 
    0.08473153f, -0.00107979f, -0.03867808f, 0.00955216f, -0.23312904f, 0.09637228f, -0.05859615f, -0.14107172f, 
    0.07960618f, -0.02129955f, 0.10962389f, -0.02191065f, 0.16992259f, -0.04945547f, -0.17754877f, 0.00661881f, 
    0.33858675f, 0.17621277f, 0.20419627f, 0.06052596f, -0.01887983f, 0.15088795f, -0.25858790f, -0.09339081f, 
    0.03234807f, -0.07214107f, 0.01569448f, 0.00543120f, 0.08196010f, 0.27887911f, -0.14021727f, -0.11814426f, 
    -0.01636971f, 0.00849798f, 0.07954805f, 0.02046597f, 0.13477714f, -0.04500360f, -0.09918850f, 0.03432754f, 
    0.08687331f, 0.21950403f, -0.33738065f, -0.01006561f, -0.23905142f, 0.00914394f, 0.13708910f, 0.34306759f, 
    -0.05032096f, 0.06760994f, -0.00635072f, -0.16560929f, -0.51420969f, 0.26910102f, -0.16848513f, 0.06485205f, 
    0.24861129f, -0.15567170f, 0.01789421f, 0.03731091f, 0.02162838f, -0.00805102f, -0.06003379f, -0.13330723f, 
    0.04259479f, -0.13188924f, 0.02482713f, -0.64670199f, -0.10335438f, 0.00678467f, -0.12092781f, -0.12513006f, 
    -0.06009552f, 0.00501562f, 0.10749073f, 0.16597177f, -0.21850237f, -0.08084045f, -0.13007963f, 0.02372457f, 
    0.08419000f, -0.01152632f, 0.04841591f, -0.19766493f, 0.06978366f, -0.07723929f, -0.07775000f, -0.01118836f, 
    -0.26575759f, 0.27138874f, 0.30602098f, -0.39581054f, -0.10263766f, -0.22812060f, -0.00147736f, -0.21867011f, 
    0.09056384f, 0.05917331f, 0.14039122f, 0.11160135f, 0.15575069f, 0.70968831f, -0.69669807f, 0.20295413f, 
    -0.13534647f, -0.22312427f, 0.03911138f, 0.02900818f, 0.17640837f, -0.05393885f, 0.02051435f, -0.04096165f, 
    0.17786869f, 0.12039225f, 0.23176053f, 0.08147839f, -0.15679461f, -0.22198170f, -0.14577974f, -0.37343735f, 
    0.11470839f, 0.08793646f, 0.03270781f, 0.08790004f, -0.40792409f, 0.15399562f, -0.13329512f, -0.33276302f, 
    -0.01544432f, -0.04849819f, 0.07508091f, 0.30066660f, -0.06846967f, -0.04560450f, 0.00012211f, -0.12079669f, 
    -0.20865367f, -0.20158087f, -0.60419661f, -0.03004923f, 0.01058586f, -0.02239401f, 0.01671055f, 0.00060668f, 
    0.11656873f, 0.00776522f, -0.01958411f, -0.10956396f, -0.49634957f, 0.26465395f, 0.00541204f, -0.10578915f, 
    0.02263399f, -0.12613478f, -0.04757323f, -0.25892475f, 0.15378638f, 0.26496002f, 0.01371268f, 0.06566728f, 
    -0.17474905f, 0.15281942f, 0.26403600f, 0.00683133f, 0.07883543f, -0.05375724f, -0.15872651f, -0.03789013f, 
    -0.06944246f, -0.15844308f, -0.19785835f, -0.15699312f, 0.03585218f, -0.38471085f, -0.04676393f, -0.01353871f, 
    -0.03965272f, -0.06188222f, -0.16067645f, 0.03432939f, -0.12087450f, 0.08312724f, -0.04934649f, -0.23910192f, 
    -0.18139306f, -0.36941075f, -0.24422683f, 0.04543684f, -0.18999985f, -0.33259097f, -0.02432442f, -0.12265890f, 
    -0.05771695f, 0.02539733f, -0.15294228f, 0.16356154f, 0.44090435f, 0.02926563f, 0.53962100f, 0.34453341f, 
    -0.22499883f, 0.04651768f, 0.27496392f, -0.02992695f, -0.01306430f, 0.08106369f, 0.23897332f, 0.25116304f, 
    -0.22059953f, -0.19938046f, 0.20977746f, -0.36825201f, 0.00843445f, 0.07007740f, -0.17818695f, -0.02840777f, 
    0.08461455f, 0.02875128f, 0.24524042f, 0.02645981f, 0.41434035f, -0.04165299f, 0.26804960f, 0.36597314f, 
    -0.14717147f, 0.21682860f, 0.14279100f, 0.14745544f, 0.06194773f, 0.04052528f, 0.06902626f, 0.01349387f, 
    0.55639768f, -0.00380272f, 0.16862494f, -0.35640502f, -0.16598338f, -0.14111206f, 0.12354267f, -0.14062978f, 
    -0.12765417f, 0.01936726f, -0.14808188f, 0.08365119f, -0.19973874f, 0.35164338f, -0.05150687f, 0.10590114f, 
    -0.08109556f, 0.02141399f, 0.07675485f, -0.13670374f, 0.07354435f, 0.04818282f, 0.09309006f, 0.05142452f, 
    -0.11718389f, 0.12270376f, -0.10382769f, -0.08608604f, 0.21332347f, -0.35272163f, 0.10741540f, 0.16701433f, 
    -0.18708967f, 0.02113764f, -0.09427956f, -0.11584135f, 0.22394529f, 0.06673072f, -0.50801766f, 0.02734855f, 
    -0.09213032f, 0.09636792f, 0.14553070f, -0.04488593f, 0.24263161f, -0.10081486f, -0.25309899f, -0.13472869f, 
    -0.28213173f, 0.34261426f, 0.10324042f, -0.04889103f, -0.00283946f, -0.15247601f, -0.17356308f, 0.00907311f, 
    -0.14179085f, -0.22572504f, -0.38044569f, -0.33038181f, -0.24504550f, 0.10252258f, 0.04290778f, 0.28918055f, 
    -0.03322584f, 0.12264761f, 0.01135983f, 0.11600143f, 0.06297921f, -0.10405347f, 0.05068279f, -0.10172234f, 
    -0.27709284f, 0.12667158f, -0.08500651f, 0.18285292f, 0.00883884f, -0.16427818f, -0.23407619f, 0.11476456f, 
    -0.09162531f, -0.12848501f, -0.25799698f, -0.17057440f, 0.08252521f, 0.19037367f, 0.11217501f, 0.06657702f, 
    0.02651609f, -0.22301051f, 0.29062131f, -0.06762613f, 0.19368877f, 0.12416513f, -0.45920908f, -0.16611494f, 
    -0.07073735f, -0.40509149f, 0.24200243f, -0.28032821f, -0.01485091f, -0.12615450f, 0.13070145f, -0.04577444f, 
    -0.24683981f, -0.01558390f, -0.16733181f, -0.42108646f, -0.66311663f, -0.06026303f, -0.21855317f, 0.18941607f, 
    -0.01534427f, 0.06083772f, 0.14228944f, -0.05992105f, 0.12339851f, 0.02701393f, -0.05843563f, 0.01446878f, 
    -0.41987044f, 0.00048312f, -0.37496981f, 0.17585655f, -0.07562716f, 0.31646118f, -0.00833341f, -0.01133756f, 
    0.06759477f, -0.02488641f, -0.02042866f, 0.17958088f, -0.62079042f, 0.45237201f, 0.12915926f, 0.01670015f, 
    -0.24006882f, 0.09846733f, 0.03493863f, 0.21520653f, -0.03004158f, -0.15745074f, -0.33449697f, 0.13886803f, 
    -0.20028062f, -0.30043766f, -0.07535779f, -0.01449195f, 0.05689265f, 0.37670350f, -0.25385657f, -0.13939419f, 
    -0.19783098f, -0.00578368f, 0.00529896f, -0.13774806f, 0.00051064f, -0.04858373f, 0.23312248f, -0.06165107f, 
    -0.29449934f, 0.15634389f, 0.19468774f, 0.11774624f, 0.06216545f, 0.14445689f, 0.35159606f, 0.25879908f, 
    -0.28969532f, 0.27383471f, -0.24813832f, 0.11437799f, 0.13190685f, -0.03073931f, 0.17430757f, 0.16093256f, 
    -0.15364569f, 0.20527968f, 0.00888213f, 0.08350411f, 0.27940029f, -0.53013575f, 0.33853814f, 0.17814368f, 
    -0.23083641f, 0.12129189f, 0.17027986f, -0.09652684f, -0.29744205f, -0.09169341f, -0.24524020f, -0.10112385f, 
    -0.22106364f, 0.13007466f, -0.44269729f, 0.12013934f, -0.05129319f, -0.00204811f, 0.12514973f, -0.34046492f, 
    0.04309684f, 0.15169640f, 0.06024880f, 0.11772295f, -0.52823800f, 0.28465033f, 0.15642750f, -0.21144922f, 
    -0.33611694f, 0.11460033f, -0.47101837f, 0.28026199f, -0.01102618f, -0.08997347f, 0.12447629f, 0.24261738f, 
    -0.09962828f, 0.25949514f, -0.01693782f, 0.56342214f, 0.05599855f, 0.01207693f, -0.01165326f, 0.15135916f, 
    -0.20822947f, 0.08810762f, -0.19563733f, -0.24811369f, -0.26982605f, 0.07596347f, -0.50076628f, -0.06269726f, 
    -0.17282949f, 0.06477419f, 0.22020991f, -0.05958943f, -0.08817873f, 0.05880309f, -0.04901554f, 0.15676345f, 
    0.33139503f, -0.06286820f, 0.17482625f, -0.01052199f, 0.17170040f, -0.13709262f, 0.01610767f, -0.00702086f, 
    -0.11229041f, -0.00593762f, -0.27099058f, -0.43816653f, -0.34277990f, 0.01555632f, 0.02300032f, 0.02097010f, 
    -0.02665135f, -0.00242333f, 0.17488131f, -0.04121050f, -0.19535147f, 0.14433877f, -0.03865608f, 0.12849586f, 
    -0.26657054f, 0.10297100f, -0.23533827f, 0.08119176f, -0.04628332f, -0.12465373f, 0.27567047f, -0.14552143f, 
    0.04274492f, 0.05748439f, 0.04300003f, -0.15894070f, -0.07821714f, -0.41710436f, 0.23736404f, 0.25292286f, 
    -0.18262179f, 0.16341521f, 0.02903689f, 0.01693310f, 0.06314630f, -0.00962486f, 0.17981094f, 0.24238549f, 
    -0.15421516f, -0.18979004f, 0.03450150f, -0.07883874f, 0.14227483f, -0.27253565f, -0.08499875f, 0.17895524f, 
    -0.04726398f, 0.17317018f, 0.06289703f, -0.16408850f, -0.45247984f, -0.11810520f, -0.71016675f, 0.22135068f, 
    0.27105668f, 0.00948258f, -0.13140361f, -0.09514545f, 0.01039118f, -0.04945124f, -0.03598272f, 0.02403948f, 
    -0.49510625f, 0.36722088f, -0.57635820f, 0.35267064f, -0.10993492f, 0.22956878f, 0.11096988f, -0.10248764f, 
    0.11677261f, 0.16933087f, 0.16359442f, 0.16142021f, -0.21696131f, 0.15675125f, 0.13287060f, -0.53691179f, 
    -0.07139453f, -0.14286435f, 0.22532541f, 0.17849112f, 0.08218420f, 0.15035133f, 0.07672354f, -0.04194332f, 
    0.29256067f, 0.18793002f, 0.32033876f, 0.12776721f, -0.13420199f, 0.28214192f, -0.28601149f, 0.03923597f, 
    -0.00374932f, -0.07918523f, 0.28987473f, 0.04860670f, -0.11754051f, -0.36217439f, 0.41134685f, -0.01009363f, 
    0.21212359f, 0.30217832f, 0.23907486f, -0.20843221f, 0.04830882f, 0.03702397f, -0.05218532f, -0.08310598f, 
    0.41753343f, -0.17199305f, 0.22181234f, 0.06260940f, 0.02053007f, 0.04940154f, 0.16766670f, 0.08457375f, 
    -0.26660869f, 0.10290386f, 0.03656542f, 0.16532651f, 0.00524043f, -0.54156345f, 0.74763596f, -0.34094459f, 
    -0.02095228f, -0.09296417f, -0.10771070f, -0.05564708f, -0.01586558f, -0.12515050f, -0.06662522f, 0.06989003f, 
    -0.32355478f, -0.21952707f, -0.18293145f, -0.28315213f, 0.11956264f, -0.05196761f, 0.29970372f, -0.24264354f, 
    -0.00888865f, 0.00124684f, -0.03650138f, -0.24268284f, 0.08365960f, -0.43795314f, 0.29917035f, 0.27787057f, 
    0.08861527f, 0.10631143f, -0.28537366f, 0.01995324f, 0.19764715f, -0.04892701f, -0.04425334f, -0.01009221f, 
    -0.05260815f, 0.06619897f, -0.10654810f, -0.05864643f, 0.00244648f, -0.02710878f, -0.02056285f, -0.16738795f, 
    0.16915576f, -0.05489661f, -0.01271811f, 0.08032263f, -0.50501871f, -0.37678263f, -0.09619099f, -0.18023892f, 
    -0.09517257f, -0.03572514f, -0.21356286f, -0.11607762f, 0.00829229f, 0.10223259f, 0.08972041f, 0.08758774f, 
    -0.13831037f, 0.09475957f, -0.06334300f, 0.00415001f, -0.02426204f, 0.01157684f, -0.00755877f, 0.08919071f, 
    -0.00655998f, 0.31325611f, -0.11815814f, 0.08814788f, -0.29678640f, -0.50686097f, 0.08589219f, -0.15325284f, 
    -0.10848522f, -0.19574273f, 0.04028374f, -0.10379469f, -0.00107357f, 0.05938827f, -0.10094868f, -0.17323343f, 
    -0.21427158f, -0.11302396f, 0.06544544f, 0.20332177f, 0.03478422f, 0.14257206f, 0.01306340f, -0.00630894f, 
    0.04648388f, 0.14821452f, 0.10238024f, -0.02212879f, 0.29681703f, -0.39266619f, 0.19077893f, -0.55759203f, 
    0.12278070f, 0.02003067f, -0.14475316f, 0.17786407f, 0.09182845f, 0.05251243f, 0.06827518f, -0.10244878f, 
    0.47313985f, -0.10119964f, 0.51933771f, -0.11006608f, 0.00498672f, 0.13634826f, -0.19005267f, -0.01278136f, 
    -0.01700446f, -0.13998674f, 0.07462006f, 0.31612870f, 0.00253703f, 0.24790642f, -0.21590029f, 0.26687017f, 
    -0.08504070f, -0.07501446f, -0.14041825f, -0.08305258f, 0.22351639f, 0.01210819f, 0.08749279f, -0.09003351f, 
    -0.33017272f, 0.08826561f, -0.05661542f, 0.24389213f, -0.14071587f, -0.47050440f, 0.24236447f, 0.07826759f, 
    0.08782428f, 0.01140764f, 0.08184741f, 0.06919749f, -0.31339934f, -0.08014776f, -0.17795086f, 0.06772606f, 
    0.07569302f, -0.02010956f, -0.00253757f, -0.06395051f, -0.00093509f, 0.04837674f, -0.15936311f, 0.25071537f, 
    -0.21541998f, -0.05691009f, -0.02659517f, 0.13289887f, -0.50957596f, -0.21255855f, 0.20086826f, -0.11554244f, 
    -0.02671240f, 0.05072675f, -0.05110254f, -0.07287928f, 0.14973022f, 0.09571357f, 0.14467968f, -0.04530368f, 
    -0.04405632f, 0.16623278f, -0.04337540f, 0.07709198f, -0.17807548f, 0.04494013f, -0.07207429f, -0.15422395f, 
    -0.61338311f, 0.35489243f, -0.21373849f, 0.43571302f, 0.12228505f, -0.24154149f, -0.00443262f, 0.01786431f, 
    -0.12638140f, -0.23637478f, -0.16152693f, -0.11323354f, -0.18108389f, 0.42249280f, -0.00132314f, 0.17252922f, 
    -0.05794458f, -0.09568764f, -0.02557870f, 0.05144541f, 0.23430553f, -0.12961315f, 0.03431405f, 0.26786923f, 
    -0.22994515f, -0.20462972f, 0.05919795f, 0.28874230f, -0.15251262f, -0.27288371f, -0.17950161f, -0.39627519f, 
    -0.00763411f, -0.02861950f, -0.00663422f, 0.05573599f, 0.31525749f, 0.04598069f, 0.22910787f, -0.14158553f, 
    0.04676943f, -0.07078698f, -0.01921141f, 0.11834808f, -0.07054185f, 0.04660475f, 0.07231018f, 0.17822045f, 
    -0.86476177f, 0.23011969f, 0.04774693f, 0.04175189f, -0.17062832f, -0.00383171f, 0.16747867f, 0.00968914f, 
    -0.27308151f, -0.04815849f, -0.22256517f, -0.04065386f, 0.45791608f, -0.07189968f, 0.08163556f, 0.25396600f, 
    -0.05314220f, -0.05210678f, -0.02583711f, 0.12326875f, 0.08660029f, -0.00156116f, -0.02274667f, -0.11030908f, 
    -0.02840476f, 0.24623190f, -0.17794687f, -0.41586232f, -0.22348753f, -0.00641958f, 0.01368305f, 0.00321850f, 
    0.01132868f, 0.12383437f, 0.11383032f, 0.07537239f, 0.20192052f, -0.57422787f, 0.57707536f, 0.21169683f, 
    0.24774554f, 0.03077895f, 0.26142716f, 0.07874922f, -0.05982734f, -0.00964090f, 0.19068217f, 0.12952588f, 
    0.24404001f, -0.08279494f, 0.24041879f, -0.26982817f, 0.22439604f, -0.09792438f, 0.24863368f, -0.24980800f, 
    -0.03567184f, 0.07904720f, 0.10419263f, 0.06180391f, 0.18137681f, -0.04057030f, 0.00508347f, -0.02791959f, 
    -0.02686649f, -0.23019019f, -0.27935097f, -0.01067535f, -0.05847165f, -0.12263310f, -0.12456154f, -0.20585702f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.23743086f, 0.11957125f, 0.04634494f, -0.10699669f, -0.05355680f, 0.10982292f, 0.03734103f, -0.12732835f, 
    0.06058775f, -0.02514991f, 0.04348911f, -0.03668517f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
