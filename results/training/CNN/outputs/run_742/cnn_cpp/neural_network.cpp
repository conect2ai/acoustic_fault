#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.15240738f, -0.42780328f, 0.49460310f, 0.52327162f, -0.17065096f, -0.73266709f, 0.41400570f, -0.17158356f, 
    -0.36479339f, -0.53468388f, 0.10183342f, -0.18693730f, 0.21049392f, 0.48415989f, -0.15526928f, -0.08955508f, 
    0.14050743f, 0.16589820f, 0.02878978f, -0.36933732f, -0.34171915f, 0.00722300f, -0.22560284f, 0.05553238f, 
    0.27787638f, 0.03689915f, 0.38103312f, 0.52942711f, 0.23145419f, 0.73399192f, -0.58961743f, 0.46318302f, 
    0.35689855f, 0.19670324f, 0.45866299f, -0.27795717f, 0.11378355f, -0.16729710f, -0.44468281f, -0.12544395f, 
    0.03963060f, -0.01066669f, -0.09842024f, 0.41046348f, 0.32377172f, 0.16368510f, 0.46863773f, -0.00715400f, 
    0.15726547f, 0.33074194f, -1.09105742f, 0.64963329f, 0.34262797f, -0.41872710f, -0.03956617f, 0.68663961f, 
    0.62348121f, 0.47382042f, 0.60495704f, 0.42155093f, -0.18846479f, 0.01302037f, -0.10557845f, -0.17880036f, 
    -0.28919789f, 0.13329357f, -0.07215261f, -0.19471912f, -0.14659709f, 0.00129132f, -0.09460727f, -0.00489304f, 
    -0.01672708f, 0.08646886f, 0.00102716f, -1.07542801f, 0.63541865f, 0.84250027f, -0.56607234f, 0.86330193f, 
    0.43802723f, 0.15432252f, -0.28553760f, -0.48813251f, -0.64057422f, -0.20326760f, 0.04914754f, 0.41065320f, 
    0.09201556f, -0.26169872f, -0.27572131f, -0.00262895f, -0.16416839f, 0.03899490f, 0.27844650f, 0.05925941f, 
    -0.15955187f, -0.19147529f, -0.13868079f, -0.11478780f, -0.17032561f, -0.71940315f, -0.07842411f, 0.87602782f, 
    0.69819492f, -0.95246023f, -0.39517424f, 0.05840475f, -0.68366587f, 0.09794389f, 0.31854007f, 0.32837909f, 
    -0.13871369f, 0.05556068f, 0.20826741f, -0.06761476f, 0.19267784f, 0.31845772f, 0.33088705f, -0.21274224f, 
    0.02805343f, 0.09143264f, -0.25926650f, 0.08348123f, -0.00140583f, 0.70785850f, 0.65832084f, 0.40813139f, 
    -0.01455027f, 0.73305154f, 0.27072835f, -0.03609011f, 0.34672958f, 0.31265420f, -0.03850157f, -0.54124558f, 
    0.23846765f, 0.25974783f, 0.14239742f, 0.11244284f, 0.30716497f, 0.38098264f, 0.24238452f, -0.24956815f, 
    -0.03707882f, 0.38082364f, 0.21160954f, 0.09651572f, 0.00945442f, 0.38842747f, -0.40852571f, -0.68662477f, 
    -0.58696276f, -0.53334683f, -0.41904923f, -0.47865480f, 0.31252113f, 0.21689786f, 0.00152607f, -0.03584735f, 
    0.32140142f, -0.29241511f, 0.23827834f, -0.11112674f, 0.01366735f, -0.11413473f, 0.06112405f, 0.08655814f, 
    -0.39262030f, 0.33672366f, 0.11075892f, 0.04338804f, -0.14116362f, -0.11226135f, 0.18912360f, -0.37309775f, 
    -0.53549325f, -0.01835180f, -0.38650790f, -0.59066385f, -0.32508510f, -0.54223007f, 0.03993460f, 0.05887993f, 
    -0.43418127f, 0.11980325f, 0.52972335f, -0.43835190f, 0.13343537f, -0.18234088f, -0.00072272f, -0.09838136f, 
    -0.19904542f, -0.08044726f, 0.04955695f, 0.27438620f, -0.04600511f, 0.30476579f, 0.03140726f, 0.28184029f, 
    -0.33105618f, 0.26546293f, -0.28609747f, -0.49926969f, -0.06344084f, -0.43816546f, -0.22944748f, 0.14323543f, 
    0.07484796f, -0.19198018f, 0.05935903f, 0.60221922f, 0.35094607f, -0.14704224f, -0.45715573f, -0.23997253f, 
    0.06021745f, 0.10586803f, 0.30522346f, 0.14164500f, -0.53113115f, 0.07804407f, -0.12269434f, -0.19377625f, 
    -0.30555677f, -0.76126546f, 0.05028370f, -0.29833448f, -0.15337293f, -0.83776897f, 0.74891776f, 0.71222550f, 
    -0.23151779f, 0.26292619f, 0.70866549f, -0.25925338f, -0.24315840f, -0.32764134f, -0.45481181f, -0.24630326f, 
    -0.06459189f, 0.27260599f, -0.09740084f, -0.02984015f, -0.12704401f, -0.18062162f, -0.26523393f, -0.08773539f, 
    -0.05977168f, 0.07056926f, 0.75053352f, 0.54012042f, 0.77628636f, -0.31347939f, 0.12946881f, 0.26305714f, 
    -0.47517437f, 0.06481744f, 0.34611377f, 0.30075532f, -0.42550200f, 0.17847073f, -0.09651257f, -0.24581450f, 
    -0.27335078f, -0.49814248f, -0.06016066f, -0.26273668f, -0.68162358f, -0.05675296f, 0.01408486f, -0.12796414f, 
    0.10725097f, 0.03192684f, -0.07632802f, -0.51241213f, -0.47154230f, 0.76986843f, 0.04660359f, -0.54503208f, 
    -0.53474885f, 0.47888315f, 0.62938756f, -0.21910901f, 0.24105343f, -0.57496464f, 0.33115825f, -0.27517393f, 
    0.07403024f, -0.10666607f, -0.23197147f, 0.04473205f, -0.25599557f, 0.16129521f, -0.36871532f, 0.22205687f, 
    -0.12091632f, -0.19077452f, -0.06647322f, -0.51211280f, -0.90877938f, -0.60732836f, 0.48764646f, 0.38377714f, 
    0.06099832f, 0.55126417f, 0.45621914f, -0.33220091f, 0.45847157f, -0.08217427f, -0.24779749f, 0.28635669f, 
    -0.28987360f, 0.47060832f, -0.26525015f, -0.05622549f, -0.02900435f, -0.12159166f, -0.06220864f, 0.02425028f, 
    0.02598065f, 0.14394987f, 0.36728945f, 0.04161146f, -0.23868659f, 0.38057339f, 0.00970678f, 0.64924365f, 
    0.47407520f, -0.05508604f, -0.34170371f, 0.21340962f, -0.83332938f, -0.25657287f, 0.00463969f, -0.10844028f, 
    0.30728254f, -0.31389487f, 0.43701228f, -0.17554322f, -0.32071766f, -0.27773494f, -0.51456344f, -0.25073752f, 
    -0.32349026f, -0.14689746f, 0.33310634f, 0.04346785f, -0.34487489f, -0.11225170f, 0.91433257f, 0.82191616f, 
    0.84742689f, -0.06696337f, -0.50230300f, -0.95455569f, -0.33319449f, -0.41240150f, -0.01940195f, -0.32992870f, 
    0.28292885f, 0.25672528f, -0.37669846f, 0.18302582f, 0.06435890f, 0.13481982f, -0.25490466f, 0.29347169f, 
    0.15309080f, -0.07646286f, -0.08247454f, 0.33316493f, -0.12205660f, 0.02008008f, 0.11722829f, -0.04272474f, 
    0.51992548f, -0.24682905f, -0.02400627f, -0.48291484f, -0.61551827f, -0.13409343f, -0.46534923f, -0.22788279f, 
    -0.58849299f, -0.45065808f, -0.08242688f, -0.03010285f, -0.20812476f, -0.42373446f, -0.66395372f, -0.07866146f, 
    -0.17751330f, -0.35196555f, -0.31981188f, 0.23003292f, 0.05614888f, 0.31659114f, -0.14626528f, -0.03478085f, 
    -0.83381438f, 0.28030252f, 0.59868824f, -0.54477406f, -0.17775238f, 0.69615197f, -0.26427874f, 0.39092988f, 
    0.23194812f, -0.21090379f, -0.00753650f, -0.35611343f, -0.05425474f, 0.02519929f, 0.09695669f, 0.03726870f, 
    -0.23908964f, -0.08524270f, 0.11122725f, -0.28172275f, 0.39172459f, 0.65324795f, 0.38815561f, 0.50223571f, 
    -0.11975542f, -0.47978163f, 0.55384725f, -0.02672327f, 0.10552711f, 0.28119040f, -0.22118455f, 0.78676331f, 
    0.15437663f, -0.41090363f, 0.45476267f, -0.47101519f, 0.25667208f, 0.23396826f, 0.06830194f, 0.24969095f, 
    -0.11837932f, -0.30070204f, -0.01237230f, -0.25291359f, -0.24397843f, -0.27847463f, -0.07824979f, -0.31278673f, 
    -0.06072232f, -0.28934386f, 0.33598700f, -0.75287741f, -0.82072151f, 0.20071940f, 0.71219224f, 0.30383480f, 
    0.28677344f, -0.28485245f, 0.33000031f, 0.16316491f, -0.19127494f, 0.26495215f, 0.05273825f, 0.00200395f, 
    0.11251903f, -0.24131271f, -0.48477080f, -0.09695365f, -0.31695351f, -0.36460695f, 0.07396836f, 0.10439711f, 
    -0.04313181f, -0.16881831f, 0.05650101f, 0.84260678f, 0.79702318f, 0.28648892f, 0.32504177f, 0.61723030f, 
    -0.14968398f, -0.19871262f, -0.53472239f, 0.14310701f, 0.05289710f, 0.07143547f, 0.16863206f, -0.08342496f, 
    -0.03023487f, -0.42476889f, -0.05747711f, 0.00895069f, -0.16840826f, -0.23885611f, -0.22121297f, 0.05485016f, 
    0.43040961f, 0.26261029f, -0.04353375f, 0.03629316f, 0.48765498f, 0.51359975f, 0.38898396f, -0.07774880f, 
    0.22181907f, 0.09113645f, -0.69990450f, -0.76403224f, -0.23146904f, -0.44204259f, -0.05221686f, 0.23920628f, 
    0.10140511f, 0.00332809f, 0.02875598f, 0.54024112f, 0.39289001f, -0.16896032f, -0.17586920f, -0.55281782f, 
    0.27264562f, -0.21043654f, 0.00431749f, 0.12030768f, -0.22303534f, 0.81685168f, 0.43983397f, 0.08967186f, 
    -1.00713348f, -0.48153406f, 0.35211998f, -0.20248115f, 0.02754277f, -0.46987072f, -0.45024318f, 0.37431255f, 
    0.22718629f, 0.22221947f, 0.32302102f, -0.26982653f, 0.12900749f, 0.26801404f, -0.12505452f, -0.08573477f, 
    0.18690050f, -0.20122790f, -0.08884647f, -0.05919311f, -0.09240718f, 0.30022520f, -0.20474240f, 0.69850016f, 
    0.85580516f, 0.08419108f, 0.63154548f, -0.81380868f, -0.03104028f, -0.67573828f, -0.66096634f, -0.30282962f, 
    0.18959908f, 0.15312135f, 0.32555261f, 0.32131043f, -0.18071286f, 0.05021913f, 0.03199117f, 0.20071322f, 
    -0.01014564f, -0.04623516f, 0.07753517f, -0.22270663f, -0.01948892f, 0.00717343f, -0.15985475f, -0.44852573f, 
    -0.90265781f, -0.66334742f, -0.18466988f, -0.25432497f, -0.53970194f, -0.31510127f, -0.20690711f, -0.14746743f, 
    0.29066637f, 0.40915045f, 0.40821430f, 0.32615149f, 0.24987255f, -0.08986194f, -0.17393236f, 0.08468297f, 
    0.11257719f, -0.27861837f, 0.12541173f, 0.07770595f, -0.14601877f, -0.13330348f, 0.32756245f, 0.01907714f, 
    0.43407089f, 0.92905223f, -0.71962887f, -0.25486019f, -0.66368335f, 0.75307035f, -0.43508738f, -0.35466623f, 
    -0.27990481f, 0.13782442f, 0.28493279f, 0.12335847f, 0.32026055f, 0.51127720f, -0.25553891f, 0.00496302f, 
    -0.32817513f, -0.02077341f, -0.16498910f, -0.19194932f, 0.03440633f, 0.22178021f, 0.02439872f, 0.02256081f, 
    0.06169916f, -0.09045787f, -0.39793342f, 0.28996754f, -0.66913009f, 0.80716312f, 0.38837144f, 0.64794707f, 
    -0.46295309f, -0.47978273f, -0.31733137f, 0.17339733f, 0.17545487f, 0.08647769f, -0.21740489f, -0.19017819f, 
    -0.04392040f, -0.18088694f, -0.02434138f, -0.45500144f, 0.06348345f, 0.12095112f, -0.00889220f, 0.28211340f, 
    0.20135380f, -0.10729525f, 0.85730559f, 0.68699473f, 0.23734939f, 0.38748431f, -0.03187349f, -0.06547231f, 
    0.29669878f, -0.12132619f, 0.28794435f, 0.21447335f, 0.21902345f, -0.18000610f, -0.02156665f, -0.19981942f, 
    -0.22264506f, 0.13636611f, 0.27004996f, 0.19044313f, 0.09144513f, 0.50205207f, -0.41228172f, -0.31943178f, 
    -0.58306932f, -0.25011751f, 0.47223115f, -0.62917584f, -1.33748174f, -0.28168923f, 0.49309468f, 0.14567855f, 
    -0.28139958f, 1.04339159f, 0.28033650f, -0.08818046f, -0.23957200f, 0.18791144f, 0.07795391f, -0.24832699f, 
    -0.11269686f, 0.17086791f, -0.30319223f, -0.10760898f, -0.03684236f, -0.00238574f, -0.20421888f, -0.06138745f, 
    0.29935414f, 0.03336528f, 0.13279022f, 0.08147538f, 0.04349488f, -0.86923212f, 0.26427242f, 0.42442957f, 
    0.16234936f, -0.88807714f, 0.37913489f, 0.23494640f, 0.32166573f, -0.42416498f, 0.19892208f, 0.03518794f, 
    0.19265194f, -0.00074804f, -0.13517903f, 0.09138462f, 0.11846807f, -0.05366815f, 0.12407061f, -0.27521950f, 
    -0.09256757f, -0.34891042f, -0.20288999f, 0.22602955f, 0.06135226f, 0.60317892f, -0.38223970f, -0.48365670f, 
    -0.12425255f, -0.38460904f, -0.39853993f, -0.53412169f, 0.12022658f, -0.08221915f, -0.62974066f, -0.31071600f, 
    -0.13534221f, 0.32294303f, -0.09212617f, -0.49253395f, -0.20160271f, -0.25002512f, 0.04417839f, 0.30636674f, 
    -0.10764064f, -0.01308138f, 0.10593207f, -0.13692421f, -0.09345302f, 0.05346101f, 0.86405665f, 0.74078643f, 
    0.24484456f, 0.79871494f, -0.22059481f, -0.02082997f, -0.13410273f, -0.32884347f, -0.00334357f, -0.08767589f, 
    -0.25452173f, -0.17980349f, -0.10665084f, 0.41871864f, -0.00057789f, -0.34169811f, -0.27658889f, 0.07415369f, 
    0.03956986f, 0.07274383f, -0.21021423f, -0.15185097f, -0.20547044f, 0.24165294f, 0.09309200f, -0.42877614f, 
    -0.12920560f, -0.58143699f, -0.83079892f, -0.45030046f, 0.33102402f, 0.53880322f, 0.33457965f, 0.02068011f, 
    0.52064192f, -0.39411420f, 0.20336589f, -0.22916023f, 0.04632829f, -0.36484301f, 0.16721509f, 0.14504741f, 
    -0.04164645f, 0.11379594f, 0.19407916f, 0.12480308f, -0.08405717f, 0.01992609f, -0.35213891f, 0.01253149f, 
    0.44516477f, 0.29548579f, -0.67053932f, -0.69093436f, 0.66448134f, 0.71925402f, -0.43831477f, 0.53662902f, 
    0.30451286f, 0.43889546f, -0.44975269f, -0.23514292f, -0.39490145f, -0.28842688f, -0.13683385f, 0.04274199f, 
    -0.20486853f, -0.22778034f, -0.21690558f, 0.08452808f, -0.14765407f, -0.21270002f, -0.38451126f, 0.03290616f, 
    -0.38591453f, -1.18103433f, 0.07179246f, -0.10621671f, -0.37984887f, -0.16107716f, 0.75797153f, -0.04586693f, 
    -0.47381207f, 0.58863962f, 0.20235221f, 0.21249810f, -0.44320557f, 0.05689976f, 0.01555107f, 0.37078142f, 
    -0.27856070f, -0.37466133f, -0.04280500f, -0.19060509f, -0.47266760f, -0.07773476f, -0.17279643f, 0.20826031f, 
    0.27030560f, -0.05680889f, -0.53452283f, 0.70322263f, -0.37800184f, -0.75849110f, -0.54877025f, 0.54684335f, 
    0.44946110f, -0.16963452f, 0.04535702f, 0.37555128f, -0.32961741f, 0.07064056f, 0.21184573f, -0.26207998f, 
    0.37535733f, -0.04857399f, -0.08306768f, 0.29342115f, 0.16815566f, -0.13717315f, 0.13905250f, -0.34407112f, 
    0.20128785f, 0.14056467f, 0.32584536f, -0.80541909f, -0.28561702f, 0.33286563f, 0.82986057f, -0.56881636f, 
    -0.07775918f, -0.14141616f, 0.34839508f, 0.35810322f, -0.09932302f, 0.12405722f, -0.11864723f, 0.00949630f, 
    0.36717626f, -0.08681855f, -0.02104508f, 0.11281393f, -0.09915026f, -0.34750164f, -0.16304037f, -0.05462543f, 
    0.08889641f, -0.17414555f, -0.00527521f, 0.29735032f, 1.00529850f, -0.35272056f, 0.45623052f, 0.93928164f, 
    0.77940834f, 0.10197263f, 0.53248900f, -0.03598604f, 0.13930960f, 0.00893679f, -0.36476132f, 0.01454035f, 
    -0.05264741f, -0.07196804f, -0.06809656f, -0.32130724f, -0.07140774f, 0.16205913f, 0.22325373f, -0.05980892f, 
    0.35280317f, 0.35383505f, 0.11318124f, -0.03301753f, 0.12054080f, 0.18586445f, -0.49348170f, 0.10572474f, 
    -0.87967712f, 0.52323472f, -0.32840776f, 0.19165380f, -0.21930018f, -0.37846327f, -0.37360325f, 0.05253083f, 
    -0.05643804f, 0.33662814f, 0.36102259f, 0.00121900f, 0.25042346f, -0.07957086f, -0.13226329f, -0.03289551f, 
    -0.00661662f, 0.16072457f, 0.01201332f, -0.06553641f, 0.04974767f, -0.08531162f, -0.59643233f, -0.33251521f, 
    -0.27851993f, -0.55708027f, -0.68135315f, 0.01839537f, -0.22945113f, -0.51229930f, 0.07433871f, 0.07170889f, 
    0.07038673f, 0.02686937f, 0.02746252f, 0.32787153f, -0.27649438f, 0.24955976f, 0.36469322f, 0.31916884f, 
    0.09045481f, 0.28123698f, 0.04319975f, -0.03792585f, -0.04647652f, -0.18920167f, 0.44000053f, 0.82495499f, 
    0.33149928f, -0.85772449f, -0.59920204f, -0.43095517f, -0.14106601f, -0.03559094f, -0.12510785f, 0.24928734f, 
    0.34420395f, -0.18171519f, -0.17516710f, 0.45747566f, -0.02443850f, -0.27815467f, 0.09241221f, 0.20042916f, 
    0.08044581f, 0.16351794f, 0.34287626f, 0.05560249f, -0.13414453f, 0.02550318f, -0.27053037f, 0.33157808f, 
    -0.84470594f, 0.74974483f, 0.05137520f, -0.51992655f, 0.38115716f, -0.71165061f, -0.01906406f, -0.03465090f, 
    0.11665341f, 0.14707592f, -0.17982836f, -0.00542549f, -0.29717764f, -0.16236079f, -0.47951698f, -0.30714998f, 
    -0.12248886f, 0.23066700f, -0.26236328f, 0.09518652f, -0.12467629f, 0.04211111f, -0.17293905f, -0.16684499f, 
    0.09872828f, 0.26584205f, 0.86350322f, 0.76050335f, -0.36915773f, 0.06556674f, -0.23122261f, 0.77507859f, 
    -0.16238460f, -0.01442072f, 0.39210236f, 0.22483581f, 0.13537060f, 0.09293891f, -0.18808611f, 0.16592091f, 
    0.17342210f, -0.29320514f, -0.04039220f, -0.07609195f, 0.03465820f, 0.02957432f, 0.35290098f, -0.13194691f, 
    -0.15593956f, 0.38464606f, -0.74416697f, 0.50871527f, -0.56044209f, -0.19670303f, 0.34170383f, -0.11858208f, 
    0.43089247f, 0.82833147f, 0.17760313f, 0.54734015f, 0.16377446f, -0.43031636f, -0.29776174f, -0.35604680f, 
    0.42289436f, 0.19305632f, 0.11677228f, -0.44713187f, 0.24348502f, -0.12690732f, -0.13882834f, -0.12616952f, 
    0.09254520f, -0.04902267f, -0.19762090f, -0.13795169f, -0.26673687f, -0.69819522f, 0.71016395f, 0.23399206f, 
    0.58899581f, 0.56453216f, 0.07635815f, 0.31363630f, -0.57070160f, 0.02748385f, 0.16741019f, 0.07355681f, 
    0.25298670f, 0.17900611f, -0.26523858f, -0.34024087f, -0.37928817f, -0.22826247f, 0.07707449f, -0.03451488f, 
    -0.28526306f, 0.36057624f, -0.02697585f, -0.33038783f, 0.75261980f, 0.49138337f, -0.49957132f, -0.42547712f, 
    -0.39713526f, -0.24207887f, -0.58710009f, -0.25626031f, -0.40450093f, 0.12658043f, 0.03951737f, -0.29555765f, 
    -0.06722201f, 0.31691292f, -0.36226630f, 0.23224291f, -0.08361505f, -0.59766400f, -0.23084912f, 0.10802526f, 
    -0.22264212f, 0.30466208f, 0.23049982f, 0.16250965f, -0.22205484f, -0.35741180f, -0.18208356f, 0.07803696f, 
    0.08717060f, 0.40182483f, -0.42650011f, -0.57522351f, -0.80481070f, -0.19297801f, -0.18196000f, 0.03289054f, 
    0.21871251f, 0.32781899f, -0.06165621f, -0.21788681f, 0.31585360f, -0.39122307f, 0.35508782f, 0.11718632f, 
    0.43995345f, -0.31114313f, 0.04352408f, 0.02587842f, -0.11289024f, 0.34742364f, -0.50723755f, 0.28876743f, 
    0.58916587f, -0.18098842f, 0.14532581f, 0.39958408f, 0.58243364f, 0.39681751f, 0.05184222f, -0.25559589f, 
    0.27494803f, 0.13318554f, -0.09867341f, -0.00477641f, -0.11760027f, 0.45218834f, 0.21802418f, 0.11553664f, 
    -0.08433846f, -0.17457408f, 0.32238516f, 0.28607890f, -0.34346682f, -0.27814236f, -0.04111182f, -0.37748539f, 
    -0.54904896f, 0.00103172f, -0.21380191f, -0.06920948f, -0.21951781f, -0.51615715f, -0.07555427f, 0.17446159f, 
    -0.55500782f, 0.23911119f, 0.16378568f, 0.15398979f, 0.34806207f, 0.21290664f, -0.14181873f, -0.23240565f, 
    -0.05613649f, 0.30832165f, 0.33192787f, 0.59318614f, 0.48278323f, -0.15015671f, -0.01231970f, -0.27225408f, 
    -0.40758905f, 0.07933968f, 0.43664041f, 0.31412694f, 0.30237409f, -0.52789319f, -0.09711341f, 0.56361580f, 
    0.18272509f, 0.23183794f, -0.29673597f, -0.02564714f, 0.17131148f, 0.03924411f, 0.41996476f, 0.24201974f, 
    -0.38386750f, 0.64984524f, -0.41684163f, -0.43196213f, -0.21268146f, 0.23326281f, -0.10248661f, -0.30071142f, 
    0.08382541f, 0.87943041f, 0.23581032f, -0.75013077f, 0.96908122f, -0.67329955f, 0.07198200f, -0.01543633f, 
    0.29007617f, -0.15040399f, -0.26414388f, -0.09993538f, -0.09171402f, 0.29230890f, -0.46721706f, 0.32813764f, 
    0.17519264f, -0.44164672f, 0.28251025f, 0.00200953f, 0.27243194f, 0.14136072f, -0.06405924f, 0.22440512f, 
    -0.04751847f, -0.45309240f, -0.38806716f, 0.13475741f, -0.08119993f, -0.62246078f, 0.09757664f, 0.12472809f, 
    0.13956597f, -0.23984060f, -0.05059927f, -0.66580474f, 0.03784350f, 0.12969252f, 0.48370022f, -0.34771800f, 
    -0.45132765f, -0.44487584f, 0.13038656f, 0.05183560f, -0.36710554f, -0.67123413f, 0.21792486f, -0.32852522f, 
    0.13199860f, 0.23074093f, 0.14624311f, 1.00199497f, -0.25690505f, -0.55631632f, 0.79958385f, 0.27386475f, 
    -0.82547319f, 0.21535778f, -0.22847071f, -0.05055267f, 0.23464486f, 0.16246212f, -0.13289174f, 0.07398979f, 
    -0.03448768f, -0.05974302f, 0.16470921f, 0.11494834f, 0.20813763f, 0.17343856f, 0.12956937f, -0.25278452f, 
    0.06964669f, -0.03224701f, -0.01985401f, -0.00212978f, -0.41532707f, -0.72711438f, -0.72000718f, 0.05155951f, 
    -0.24644585f, 0.62074244f, -0.12757340f, -0.02904753f, -0.01065984f, 0.06125654f, -0.28282747f, -0.10945754f, 
    0.15625778f, 0.09981906f, -0.37510791f, -0.37069961f, 0.07139920f, 0.26029077f, 0.03250819f, 0.12594137f, 
    0.08269149f, 0.09275836f, 0.15056655f, -0.08016333f, -0.05460954f, 1.02505291f, 0.67644900f, -0.95383269f, 
    0.30298582f, -0.34358129f, -0.31027177f, 0.40394834f, 0.32516503f, 0.67781574f, 0.36194366f, 0.11564972f, 
    -0.07829844f, 0.08266484f, -0.24547556f, 0.06867437f, -0.15882699f, -0.20465516f, -0.12413192f, -0.19532691f, 
    -0.01995827f, 0.07555206f, 0.18864056f, -0.17812185f, 0.22416937f, -0.10700446f, 0.27620581f, -0.49989298f, 
    -0.60647404f, -0.37704322f, 0.77106273f, 0.64654928f, 0.02568358f, 0.36459365f, 0.43853110f, 0.29705164f, 
    -0.05808373f, -0.23129050f, -0.34527543f, -0.28072482f, -0.09020504f, -0.28597993f, 0.26831591f, 0.22234376f, 
    0.35954824f, -0.34769431f, -0.07363412f, -0.12692770f, -0.07931514f, -0.07924752f, -0.26827669f, 0.64611965f, 
    0.15833072f, 0.55503416f, 0.79741561f, 0.88921916f, 0.29893574f, -0.13806157f, -0.27561602f, 0.19663253f, 
    0.15925294f, 0.09237389f, 0.21277751f, -0.08333758f, 0.02387955f, -0.00700948f, -0.17329958f, 0.17972690f, 
    0.01042217f, 0.16258411f, 0.33239597f, 0.42336968f, 0.19869752f, 0.19448927f, -0.37706140f, -0.00024685f, 
    0.68472457f, -0.03372893f, -0.74179775f, -0.62073976f, -0.71350157f, 0.27201882f, 0.70003313f, 0.54213309f, 
    0.42094302f, 0.19293542f, 0.23602381f, 0.20797980f, -0.40138701f, -0.06563035f, 0.19573933f, 0.03327518f, 
    -0.06510460f, 0.05481093f, 0.04686577f, -0.13677730f, -0.27680820f, -0.18089798f, 0.15101381f, -0.24119180f, 
    -0.10150865f, 0.54675996f, -0.15176830f, 0.50939602f, -0.39576802f, 0.45593655f, 0.54778898f, -0.32680449f, 
    0.16307671f, -0.65996391f, 0.15579495f, 0.27588010f, 0.26195523f, 0.15685669f, 0.20016304f, -0.44290376f, 
    -0.23429492f, -0.09632406f, 0.18404661f, 0.40554833f, 0.00489239f, 0.07956205f, 0.15909693f, 0.27494922f, 
    -0.00101630f, 0.19685632f, -0.66880333f, -0.71250820f, -0.96500951f, -0.52598643f, 0.04608455f, -0.55681068f, 
    0.64062601f, 0.45409629f, 0.09903251f, 0.55423969f, 0.22309788f, -0.24259304f, 0.32779279f, -0.05313532f, 
    0.21534941f, 0.07088875f, -0.09458467f, 0.16142096f, -0.11167002f, -0.14710845f, 0.28000647f, 0.21854730f, 
    -0.08484409f, 0.14408934f, -0.12483057f, 0.83875018f, 0.47423974f, 0.22030607f, 1.09347165f, 0.69043636f, 
    0.35779405f, 0.24409130f, 0.01781558f, 0.08726454f, -0.04289734f, -0.21842803f, 0.13012321f, -0.00650312f, 
    0.31897020f, -0.33564565f, 0.16275254f, -0.12422045f, 0.31788972f, 0.12239860f, -0.27132159f, 0.05874572f, 
    -0.39577246f, -0.02424846f, 0.11788030f, 0.16963544f, 0.94086969f, 0.35539919f, -0.68122220f, -0.08751391f, 
    0.60562164f, 0.27665886f, -0.21077839f, 0.03432282f, -0.29271650f, -0.21778177f, -0.22236028f, 0.00459539f, 
    0.24992128f, 0.49778086f, 0.07909407f, 0.11608122f, -0.17310664f, 0.20438090f, 0.19259536f, 0.46383971f, 
    0.46646625f, 0.12057219f, 0.03701733f, -0.31289285f, 0.04474244f, 0.93728888f, -0.30805275f, -0.31527275f, 
    -0.98031318f, -0.47344768f, 0.19922985f, -0.07567326f, 0.33619541f, 0.47302556f, 0.29271895f, -0.07410759f, 
    0.13548753f, -0.24043079f, -0.10288867f, -0.00413157f, 0.06087159f, 0.02316352f, 0.21913466f, 0.25778350f, 
    0.17796347f, 0.12870061f, 0.09943600f, -0.30237421f, 0.13934243f, -0.20289442f, 0.50568765f, 0.72228771f, 
    -0.19597711f, 0.39875841f, 0.82883704f, 0.15452100f, 0.26781896f, 0.49694625f, 0.27104607f, 0.36686930f, 
    0.20059308f, 0.15096059f, -0.04763398f, 0.01987701f, 0.10859828f, 0.35231969f, -0.20136984f, -0.08457459f, 
    -0.10239337f, -0.00173735f, 0.00557331f, -0.43953186f, 0.19598499f, 0.01608982f, 0.12559770f, 0.36329031f, 
    0.12714864f, 0.59443033f, 0.77881455f, -0.16978607f, -0.58568919f, 0.16832711f, 0.08306375f, -0.04436285f, 
    0.48818699f, 0.29033682f, 0.33062139f, -0.10376034f, 0.42589077f, 0.14751972f, -0.24160823f, -0.07552125f, 
    -0.16455621f, -0.08852078f, -0.25520131f, 0.27577931f, -0.18252456f, -0.05903709f, 0.27987620f, -0.41309801f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.10704000f, 0.34535077f, -0.04856045f, 0.03289698f, 0.28542972f, 0.12509227f, 0.20337909f, 0.19733541f, 
    0.14292923f, -0.15710269f, 0.24003522f, 0.05148792f, 0.11490708f, 0.17523533f, 0.10710142f, 0.28631654f, 
    0.15889277f, 0.13673995f, 0.12797827f, 0.09508109f, 0.15155463f, 0.19902495f, 0.19506864f, 0.16176207f, 
    -0.11340127f, 0.03750348f, 0.01508471f, 0.13410658f, 0.18079795f, 0.15561841f, 0.17172056f, 0.07074869f, 
    -0.09551910f, 0.07437965f, 0.15307112f, 0.23989062f, 0.18544626f, 0.21878675f, 0.19461092f, 0.12361412f, 
    0.16225655f, -0.04910262f, 0.05534897f, 0.10411566f, 0.25346434f, 0.27802077f, 0.06809183f, 0.11183123f, 
    0.06930850f, 0.14286560f, 0.24243426f, -0.02367865f, 0.23507681f, 0.16780519f, -0.02690220f, 0.20799640f, 
    0.31944776f, 0.19795258f, 0.10948072f, 0.23617001f, 0.15162182f, 0.05281797f, 0.08311606f, 0.16641785f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.16516708f, 0.04868327f, -0.02329097f, 0.28381705f, -0.13363357f, -0.14306469f, 0.14355038f, -0.07348463f, 
    -0.02693243f, 0.04834563f, 0.01192220f, -0.06717373f, -0.00644610f, -0.02283654f, 0.03462265f, -0.04290441f, 
    -0.12819232f, 0.00560170f, -0.07069697f, -0.02789797f, -0.09377115f, -0.06115309f, -0.09335382f, 0.10035824f, 
    0.34988162f, 0.05054070f, 0.12749164f, 0.07264805f, -0.00376338f, 0.01328706f, 0.08844274f, -0.15841961f, 
    -0.03897722f, -0.06051543f, -0.04184322f, -0.04460709f, -0.57930273f, -0.02570696f, 0.16639625f, -0.09089853f, 
    0.01967285f, 0.09034205f, 0.01720951f, -0.01275592f, 0.12560296f, -0.13983369f, -0.00040357f, 0.07513032f, 
    0.01364842f, -0.15658182f, -0.09265554f, 0.21637136f, -0.08901097f, 0.02381190f, 0.03160725f, -0.04332945f, 
    -0.01711732f, -0.05211136f, -0.06830262f, 0.06593678f, 0.09845181f, -0.01513460f, -0.00239532f, -0.22061475f, 
    -0.05374254f, -0.03344098f, 0.00879836f, 0.00312641f, -0.03963388f, 0.09121713f, 0.01664219f, -0.06080293f, 
    -0.19821160f, 0.02516404f, -0.09565362f, -0.07776923f, -0.06928716f, 0.05757704f, 0.00680012f, 0.01484607f, 
    -0.02423539f, -0.02437518f, -0.06149669f, 0.03443997f, -0.15989889f, -0.10344677f, 0.05134718f, 0.00783684f, 
    -0.06727283f, 0.07329442f, 0.05705354f, 0.01540346f, 0.05431622f, 0.01403095f, 0.03243096f, -0.13000187f, 
    -0.18245117f, -0.01004397f, -0.00365313f, -0.10119810f, 0.08609515f, -0.01058825f, 0.00954678f, -0.05021429f, 
    0.03888859f, -0.02396442f, -0.10001506f, -0.12102029f, 0.49719879f, 0.22563486f, 0.13451321f, -0.09585616f, 
    -0.00956602f, 0.02267030f, -0.05735646f, 0.04450155f, 0.05872614f, 0.04289680f, -0.00473419f, 0.05542386f, 
    0.05614945f, 0.00519264f, -0.00811885f, -0.05845138f, -0.07327247f, -0.16089858f, 0.05344031f, -0.01749321f, 
    -0.03750621f, -0.10299333f, 0.01260305f, -0.00740990f, -0.33142382f, -0.06752469f, -0.12516777f, 0.27683961f, 
    0.00523805f, 0.07128790f, 0.10881651f, 0.05577945f, 0.04723622f, -0.04541457f, -0.03027971f, -0.04383490f, 
    -0.35182729f, -0.03418935f, 0.10795391f, 0.09679558f, 0.01153858f, -0.02738980f, -0.00663914f, 0.02725254f, 
    -0.05316578f, 0.06844661f, 0.06042783f, -0.04032516f, 0.06736817f, 0.04526787f, -0.09578725f, 0.09480366f, 
    -0.03341602f, -0.04257537f, -0.07551086f, 0.06703672f, -0.11159445f, 0.12350343f, -0.07156019f, -0.00228490f, 
    0.01600075f, 0.17196125f, -0.02835178f, -0.01822224f, -0.14823145f, -0.04934407f, -0.15731435f, 0.07281001f, 
    0.00077155f, 0.03260559f, -0.08419958f, -0.01029470f, 0.01086554f, 0.05152154f, -0.03118401f, 0.04989813f, 
    -0.00045757f, 0.02223929f, -0.01234192f, -0.17032292f, -0.04350230f, -0.03818460f, -0.05828905f, 0.08170667f, 
    0.01312571f, -0.04628326f, 0.13474269f, -0.05191768f, -0.06878411f, 0.12267229f, 0.00631161f, -0.12504371f, 
    0.01059313f, 0.04140359f, 0.09194726f, -0.02113769f, 0.03524111f, 0.01952130f, 0.05421454f, -0.05064841f, 
    -0.07908980f, -0.13810876f, 0.02625531f, -0.00028505f, 0.15396094f, 0.03382336f, 0.02070976f, -0.05130522f, 
    -0.05715914f, 0.07672025f, 0.00459786f, 0.10706641f, -0.05087255f, -0.12521000f, 0.13018282f, -0.10858982f, 
    -0.09950626f, 0.06858502f, 0.10698496f, -0.11467400f, 0.16600451f, 0.01896131f, 0.09873527f, -0.03244907f, 
    -0.07162731f, -0.07108441f, -0.04390747f, 0.07705951f, 0.01631194f, 0.00274545f, -0.01134196f, -0.05541257f, 
    -0.08387055f, -0.08715498f, 0.05687040f, -0.04811955f, -0.04832162f, -0.08466183f, 0.10610887f, 0.03432351f, 
    -0.01334596f, 0.02201226f, 0.04170440f, -0.04806093f, -0.40334189f, 0.13897099f, 0.12932409f, -0.28929004f, 
    -0.10293160f, 0.00370802f, 0.03085263f, 0.11862803f, -0.05631675f, -0.03974002f, -0.09879206f, 0.05641707f, 
    -0.09427215f, 0.06085505f, 0.02689581f, -0.06081577f, -0.09681934f, -0.13914268f, -0.01254464f, 0.04092241f, 
    0.03511188f, -0.06978576f, -0.02509220f, -0.02588263f, -0.23582926f, -0.36133921f, -0.15327008f, 0.08866008f, 
    -0.10207527f, 0.01791997f, -0.02996817f, -0.00286864f, -0.00817803f, -0.02345405f, 0.00547577f, -0.07403791f, 
    0.05521526f, -0.02105476f, 0.04893347f, -0.19530950f, -0.15879950f, -0.00334140f, 0.02279497f, -0.04460932f, 
    -0.04182691f, 0.02240778f, -0.03157632f, 0.10029097f, -0.42813432f, -0.06344063f, 0.27570009f, -0.38720840f, 
    -0.11864860f, 0.03607467f, -0.03288801f, -0.00805313f, -0.11877014f, -0.01105813f, 0.07696997f, -0.05244090f, 
    0.09180761f, 0.05149043f, 0.03820566f, 0.03848574f, -0.02896428f, 0.03593251f, 0.05685807f, 0.13149187f, 
    0.19292213f, 0.06009208f, 0.04626853f, -0.05127672f, -0.29642984f, 0.22230937f, -0.06074831f, 0.03200500f, 
    0.13054664f, 0.02268759f, 0.06387319f, 0.05836516f, 0.01612888f, -0.06518652f, -0.11889786f, 0.04664910f, 
    0.16259860f, 0.03269632f, -0.14538021f, 0.16941202f, -0.03298938f, -0.15018223f, 0.10643758f, -0.02778730f, 
    0.15220284f, 0.03418214f, 0.04435885f, -0.00610559f, -0.09723160f, -0.18021907f, 0.07008847f, 0.02330093f, 
    0.02426844f, 0.02824877f, 0.03440290f, -0.09131044f, 0.03991628f, 0.00074595f, 0.02856090f, 0.07149801f, 
    0.14243235f, 0.09473310f, -0.04816326f, 0.10469946f, -0.13389137f, -0.09698906f, -0.00576113f, 0.03158396f, 
    -0.00149513f, -0.03639556f, 0.01559364f, 0.00570220f, 0.14505775f, 0.00878528f, -0.09381709f, -0.30354494f, 
    0.06818224f, -0.03281584f, 0.06859969f, 0.02185563f, 0.09208628f, -0.03205945f, -0.01097649f, 0.07693461f, 
    0.34163472f, -0.09068482f, 0.18642992f, -0.14583901f, -0.05652653f, 0.07974631f, 0.13329248f, 0.04513091f, 
    -0.02748802f, -0.08461951f, -0.06001157f, -0.00770708f, 0.40784183f, -0.00647546f, 0.00769943f, -0.07033687f, 
    0.11070636f, -0.06312950f, 0.01728190f, -0.02315032f, 0.00645418f, -0.05096286f, -0.00958665f, 0.04468563f, 
    0.35976046f, 0.03061827f, -0.01977887f, -0.21536645f, 0.07791974f, -0.00850282f, 0.02939818f, 0.04593346f, 
    0.00425941f, -0.09690629f, -0.00484923f, 0.07291824f, -0.10240812f, 0.02397257f, -0.13681504f, 0.22474618f, 
    -0.09266392f, 0.04993640f, 0.07517116f, 0.00115369f, -0.00850378f, -0.01072602f, -0.00113201f, 0.13387106f, 
    0.22169155f, -0.08189108f, -0.11546250f, 0.25416255f, -0.13544862f, -0.06807282f, 0.05556238f, 0.00306498f, 
    -0.13715540f, 0.04737336f, -0.07794316f, 0.01592148f, -0.28166664f, 0.02442908f, 0.09036958f, -0.23514663f, 
    -0.02234963f, 0.01383553f, -0.07952461f, 0.04366898f, 0.01966064f, -0.08783225f, 0.01921139f, -0.05155412f, 
    -0.01438454f, -0.08457144f, -0.03739509f, -0.12417357f, 0.03295726f, 0.00737658f, 0.03793243f, 0.13446392f, 
    0.00497690f, -0.00182518f, -0.16129124f, 0.01791931f, -0.15768822f, -0.01311277f, 0.06316712f, -0.37873495f, 
    0.04446016f, -0.06533438f, 0.08205509f, 0.09323654f, 0.03305364f, 0.03664729f, 0.05470587f, 0.05356406f, 
    -0.06985742f, -0.05059520f, 0.08560723f, 0.01430622f, 0.04891687f, -0.03812312f, 0.04015728f, -0.01085638f, 
    -0.01958038f, 0.02572384f, 0.00466379f, -0.02617986f, 0.04581644f, 0.01988120f, 0.12572087f, -0.11869512f, 
    0.05843454f, -0.07648991f, 0.05175118f, -0.00644171f, -0.02034961f, 0.02431386f, -0.05347931f, -0.04557678f, 
    0.12049358f, 0.15020448f, 0.11836963f, -0.08333956f, 0.07497646f, 0.04358191f, 0.07100215f, -0.13035835f, 
    -0.09556406f, 0.01958043f, -0.02343419f, -0.06087540f, -0.03328850f, 0.15829040f, -0.11281489f, 0.01684784f, 
    -0.07386294f, 0.12383047f, -0.10884862f, -0.09172203f, 0.03124041f, -0.03326058f, -0.01005483f, -0.05106576f, 
    -0.00488260f, -0.11377323f, 0.05154423f, -0.17318781f, -0.07044257f, 0.05075045f, -0.06336474f, 0.12735626f, 
    -0.07924584f, -0.03144687f, 0.04831325f, -0.12036484f, -0.05091895f, -0.21897136f, 0.04862293f, 0.07699744f, 
    -0.09724947f, 0.00013930f, -0.05889509f, 0.09536219f, 0.05761060f, 0.05091783f, -0.08135944f, 0.01452407f, 
    -0.15814936f, -0.06167219f, 0.16769999f, -0.00703037f, -0.08321428f, -0.00215995f, 0.11352547f, -0.06512067f, 
    -0.05006436f, -0.05344099f, 0.03781027f, 0.04401597f, -0.11169253f, -0.14301217f, 0.02313849f, 0.08051502f, 
    0.00294840f, 0.02798151f, 0.04985914f, -0.05344122f, 0.04794105f, -0.17231990f, 0.10259736f, -0.07825408f, 
    -0.12885968f, 0.03013119f, -0.12623943f, 0.12563720f, -0.00401117f, 0.02858392f, 0.07698620f, 0.11543848f, 
    -0.06178644f, 0.00971796f, -0.16081879f, -0.03571789f, -0.01503830f, 0.03711532f, -0.10236198f, 0.04423354f, 
    -0.19588374f, 0.05993922f, -0.16766571f, -0.07111970f, -0.08960967f, 0.00592393f, -0.01256345f, -0.02032623f, 
    -0.10232351f, 0.05196026f, -0.00115969f, -0.15481111f, -0.04341339f, -0.05257191f, 0.05878212f, -0.07507359f, 
    -0.02831200f, 0.00191756f, -0.06944882f, 0.00920681f, 0.22779803f, -0.13150714f, -0.00030116f, 0.35425472f, 
    -0.13842560f, 0.07489516f, -0.03983798f, 0.09483232f, 0.04680698f, -0.02684557f, 0.07655365f, -0.03875854f, 
    0.04693012f, -0.03410119f, -0.07589038f, -0.11408253f, 0.09717338f, 0.00861540f, 0.06265362f, 0.02441410f, 
    -0.08838477f, -0.04386492f, -0.04728685f, 0.01123235f, -0.25287652f, 0.13792287f, -0.07290670f, -0.03598888f, 
    -0.02568800f, -0.06780470f, 0.02194847f, 0.01476372f, -0.01510474f, 0.04292972f, 0.09599545f, 0.06020095f, 
    0.11246745f, 0.08352599f, 0.22844705f, -0.00354800f, 0.13884635f, 0.15227179f, 0.08174630f, 0.01062265f, 
    -0.01577671f, 0.03952243f, 0.02150094f, 0.08455004f, 0.11240829f, -0.09915192f, -0.06425887f, 0.17910740f, 
    -0.04374211f, -0.01673861f, -0.02008665f, -0.06442051f, 0.01583123f, 0.00521678f, -0.05982778f, -0.03040577f, 
    0.00347060f, 0.02397024f, -0.06063975f, -0.34891269f, -0.07274954f, 0.00874891f, 0.02928248f, -0.14188835f, 
    -0.02187034f, -0.02193087f, 0.00865697f, -0.03526436f, -0.00180829f, -0.01419770f, 0.08804504f, -0.30606762f, 
    -0.00548068f, -0.04699117f, -0.01653314f, -0.02879914f, 0.05795054f, 0.10718474f, -0.06340013f, -0.07035579f, 
    -0.21136200f, 0.24833979f, -0.06585553f, -0.21953069f, 0.10251460f, -0.05272082f, -0.05729969f, 0.00378515f, 
    0.03248369f, -0.03207031f, -0.00569735f, 0.07836587f, 0.03708813f, 0.02206880f, -0.05967506f, 0.21195269f, 
    -0.15119615f, -0.02363124f, 0.01466318f, 0.02755278f, -0.03375240f, 0.06866189f, 0.02733715f, -0.07853759f, 
    0.19303598f, 0.03314210f, 0.07761105f, -0.25164023f, -0.05020882f, 0.06188330f, -0.03094371f, 0.06625151f, 
    0.05343429f, -0.05204942f, -0.02071139f, 0.03858634f, 0.17335862f, -0.11793054f, -0.08203832f, -0.41143477f, 
    0.18415996f, -0.01742519f, -0.08998822f, -0.09823299f, -0.24188386f, 0.02178816f, -0.01515070f, 0.11493902f, 
    -0.05742035f, 0.02937410f, 0.21123400f, 0.03924580f, -0.16445640f, 0.03095668f, 0.05914420f, 0.03881323f, 
    0.00219725f, 0.02161663f, 0.06202848f, -0.17259565f, 0.07688347f, -0.08995180f, -0.19756028f, 0.19865523f, 
    -0.03745761f, -0.05228765f, 0.01057507f, -0.14075974f, -0.04644504f, 0.01943270f, 0.09290469f, -0.09134404f, 
    -0.29497173f, -0.06413593f, -0.11573784f, -0.04055899f, -0.05830619f, 0.06425878f, -0.06349660f, -0.00324079f, 
    0.15559305f, -0.07710941f, 0.04649155f, -0.03201473f, 0.11442872f, 0.15403149f, 0.02246255f, 0.19236073f, 
    0.04700154f, 0.03915408f, -0.01212506f, 0.02758732f, 0.09364523f, 0.04256864f, -0.02067265f, -0.03661274f, 
    -0.49588206f, 0.06291261f, -0.01213553f, -0.06424607f, 0.04800227f, 0.06672008f, -0.01743547f, -0.08443978f, 
    0.10199648f, 0.08637318f, 0.07725219f, -0.05794615f, 0.16970474f, -0.00100283f, -0.28184900f, -0.13454401f, 
    -0.06139321f, -0.00150525f, 0.04176873f, -0.08422198f, -0.14299069f, 0.07810345f, 0.01994150f, -0.10609702f, 
    -0.20353314f, -0.13404314f, 0.00532889f, 0.05545969f, -0.03701903f, 0.02905796f, -0.07342518f, 0.06678315f, 
    -0.11133187f, -0.02022247f, 0.08573962f, 0.06388409f, 0.16084784f, 0.10145019f, -0.02488119f, 0.10532633f, 
    -0.13779484f, -0.04923829f, 0.00136791f, 0.04842393f, -0.00520466f, -0.10133108f, 0.01489799f, -0.04862487f, 
    0.16680421f, 0.01399214f, -0.01355191f, 0.03122417f, 0.06608135f, 0.01176281f, 0.01318749f, 0.04801295f, 
    0.01800463f, -0.08306648f, 0.05250283f, 0.04182121f, -0.09592444f, -0.09833957f, -0.04448884f, -0.04021603f, 
    -0.00486012f, 0.05222875f, 0.02894869f, 0.08940178f, 0.03757333f, -0.02420239f, 0.01453822f, 0.13767137f, 
    0.04751062f, -0.12283497f, -0.10919514f, -0.11814523f, 0.00872761f, -0.07044889f, 0.02363573f, -0.03742041f, 
    -0.00320493f, -0.06805017f, 0.10028043f, 0.00130705f, -0.39594901f, -0.20143586f, -0.12798673f, -0.04536371f, 
    0.04733089f, -0.13341123f, 0.01284432f, -0.17157060f, 0.04310336f, 0.02998829f, -0.00001477f, -0.06229620f, 
    0.05162914f, 0.14070833f, 0.08167358f, 0.03824417f, -0.07605475f, 0.06954271f, 0.07010080f, -0.03190060f, 
    -0.02482950f, -0.07293905f, -0.00672570f, -0.21808445f, -0.23603696f, 0.08946112f, -0.07750937f, 0.09917063f, 
    0.04237567f, -0.04400562f, -0.10811689f, -0.11369523f, -0.01138876f, 0.00533519f, -0.06323822f, -0.06715088f, 
    0.10752534f, -0.00947507f, -0.22201228f, 0.06969597f, -0.01137188f, 0.04811225f, -0.01611631f, -0.12853338f, 
    0.01259666f, -0.05236187f, 0.00025044f, 0.08314975f, 0.06103417f, 0.02205980f, -0.00352354f, -0.02048338f, 
    -0.12044467f, 0.04954614f, 0.07490471f, -0.03228193f, 0.09659840f, -0.11248992f, -0.07436600f, -0.16043459f, 
    0.09322821f, 0.00709554f, -0.12487686f, 0.03071178f, 0.06401486f, -0.02566916f, 0.04961130f, 0.03152807f, 
    0.00260395f, 0.03484477f, -0.02958830f, 0.15289970f, -0.06926172f, -0.15933019f, -0.27143189f, -0.33412313f, 
    -0.04430572f, -0.02810360f, 0.01491045f, 0.13812055f, -0.04098988f, -0.15332446f, 0.05058122f, -0.02421412f, 
    -0.30431676f, 0.01563121f, -0.06934077f, 0.00380942f, 0.15347418f, -0.11694678f, -0.04472354f, -0.14565173f, 
    0.15623373f, 0.13693863f, -0.00501856f, 0.02982255f, 0.02802998f, 0.11470942f, 0.01270092f, 0.00472856f, 
    0.03797477f, 0.13137256f, 0.01765841f, -0.03056198f, -0.08861300f, 0.02084105f, -0.00146643f, -0.06394841f, 
    0.25746676f, -0.15140815f, -0.02405384f, -0.10564028f, -0.01065256f, 0.09404128f, -0.15675238f, -0.01643222f, 
    -0.13511683f, -0.01531685f, -0.06299753f, -0.13257596f, 0.22049201f, -0.02987530f, 0.10010477f, 0.12000252f, 
    0.01406187f, -0.03859432f, 0.07753901f, 0.02534596f, -0.10510264f, -0.04896516f, 0.00568005f, -0.02427273f, 
    -0.03451661f, 0.04726804f, 0.07814884f, -0.00239411f, -0.13116528f, 0.06708377f, 0.01932965f, 0.07773386f, 
    0.13718008f, -0.02015275f, -0.07735306f, 0.12682623f, 0.19739419f, -0.00397752f, -0.01439335f, -0.14567736f, 
    -0.02095527f, -0.08245839f, 0.06283413f, -0.10548253f, -0.17342961f, 0.08753273f, 0.17085445f, 0.05321171f, 
    -0.01096182f, 0.07074983f, -0.07159165f, -0.10588821f, 0.04459537f, -0.00723812f, 0.01359661f, -0.03337216f, 
    0.04729291f, 0.00668056f, 0.07784642f, 0.03557793f, 0.09495284f, -0.03467875f, 0.03392427f, -0.00119327f, 
    0.05881757f, 0.02225677f, 0.07123966f, 0.06077144f, -0.00563608f, -0.06698351f, 0.09379519f, 0.02419403f, 
    0.05294766f, -0.18254516f, -0.03463862f, -0.17954192f, 0.00251700f, -0.04728968f, 0.08812736f, 0.09728183f, 
    0.07753974f, -0.00889081f, -0.09175050f, -0.13686505f, 0.09196115f, -0.17273678f, -0.13542230f, -0.19854099f, 
    0.01617153f, 0.02680363f, 0.09349093f, -0.02199529f, 0.08822000f, -0.05102867f, -0.13581523f, -0.07277121f, 
    0.26984677f, 0.03294948f, 0.01760952f, 0.06406651f, -0.05385757f, -0.00921609f, -0.08938962f, -0.06197400f, 
    -0.19227909f, -0.08742561f, -0.03259493f, -0.01507065f, 0.29832166f, -0.07012916f, -0.14219216f, 0.09875128f, 
    -0.07451016f, 0.03433637f, -0.01887264f, -0.04224341f, 0.04426574f, -0.02369456f, -0.06043339f, 0.02352332f, 
    -0.23016512f, -0.18682352f, -0.03777609f, 0.16168256f, -0.11196950f, 0.06292009f, -0.15585989f, -0.05389632f, 
    0.03265675f, -0.10663880f, -0.05823963f, 0.02323591f, -0.01691006f, -0.27190214f, -0.00638448f, -0.11321812f, 
    -0.05657300f, -0.04267373f, -0.03866014f, 0.09209429f, -0.03067096f, -0.02751776f, 0.02693116f, -0.07175913f, 
    0.06174231f, -0.09248898f, -0.04847497f, 0.14559758f, -0.10466079f, -0.04736411f, 0.00052604f, 0.05344648f, 
    0.00468029f, -0.02111891f, -0.04278674f, 0.00193602f, -0.16013588f, -0.03632828f, 0.02115555f, -0.21248583f, 
    0.05332465f, -0.02450024f, 0.00268030f, 0.06894938f, 0.09614176f, 0.10091029f, -0.03779452f, -0.05572713f, 
    -0.09552091f, -0.13139510f, 0.13721192f, -0.16499028f, 0.05512305f, 0.01333863f, -0.09970786f, -0.04504080f, 
    0.12157627f, -0.05558040f, 0.03664457f, -0.05069145f, -0.32173315f, 0.06384183f, -0.06236086f, -0.11942934f, 
    0.09338141f, -0.02481428f, -0.12381980f, 0.00686601f, -0.00606408f, -0.02033404f, -0.17957594f, 0.05383854f, 
    -0.21205200f, -0.00345861f, 0.01606439f, -0.22133169f, -0.00160304f, -0.03807083f, -0.02887992f, 0.15043783f, 
    -0.01651838f, 0.03519526f, 0.07550425f, 0.02266064f, -0.21063921f, 0.20878951f, -0.11195584f, 0.08808459f, 
    -0.04023299f, 0.01740331f, -0.08040958f, 0.09695022f, -0.06630480f, -0.02287084f, -0.00415819f, -0.02385016f, 
    0.25595781f, -0.02219579f, 0.06911344f, 0.25908339f, -0.12433471f, 0.06139179f, -0.03028498f, 0.04321450f, 
    0.06635625f, -0.03453404f, 0.11727683f, 0.02969823f, 0.05458957f, -0.04717014f, 0.08135753f, -0.10754644f, 
    0.13108280f, 0.04767456f, 0.05207815f, -0.10282978f, 0.06333329f, 0.06043458f, -0.09044493f, 0.02855396f, 
    -0.16529796f, 0.07506583f, 0.05897424f, -0.02045436f, 0.01606716f, 0.08355717f, 0.19102989f, 0.18379551f, 
    0.06313349f, 0.11768175f, 0.10448498f, 0.04508954f, 0.26615298f, -0.25895008f, 0.05150673f, -0.37684199f, 
    -0.02041051f, -0.18993647f, 0.03687424f, 0.08536428f, -0.13929611f, -0.03284330f, 0.08399974f, -0.09246821f, 
    -0.03580969f, 0.12497804f, -0.21190560f, -0.38510090f, -0.04306366f, 0.11093872f, -0.01624870f, 0.07111646f, 
    0.00234791f, -0.20116407f, -0.05915825f, -0.12759198f, -0.03438999f, 0.22621143f, -0.03448826f, -0.01863112f, 
    -0.07659438f, -0.05224710f, 0.09011385f, -0.00473919f, 0.06086754f, -0.06337570f, 0.01341514f, 0.03084284f, 
    0.22983700f, 0.02622808f, -0.04156630f, -0.16137119f, 0.00493285f, 0.04822554f, -0.13364893f, 0.04657237f, 
    0.16127144f, 0.03856167f, -0.02036267f, 0.01448008f, 0.16021267f, -0.13473323f, -0.02159766f, 0.12466706f, 
    -0.02202295f, 0.04545067f, -0.05532801f, 0.08532161f, -0.16368763f, 0.10377683f, -0.02927931f, 0.05674267f, 
    0.07924727f, -0.04565903f, -0.01786621f, -0.19521372f, 0.01218053f, -0.11256308f, 0.08482918f, 0.01741420f, 
    -0.15323833f, 0.08400044f, -0.04704907f, 0.03682942f, -0.06671623f, -0.12085947f, 0.09980360f, -0.17709889f, 
    0.08156130f, 0.02211450f, 0.02821099f, -0.04574488f, 0.02491326f, 0.00768966f, 0.00778634f, 0.01711424f, 
    -0.17786616f, 0.03222133f, -0.00783155f, -0.03882168f, -0.12320647f, 0.06703187f, -0.11348076f, 0.05242797f, 
    0.02613044f, -0.02597131f, 0.00982989f, 0.01238779f, -0.17684674f, -0.02489080f, -0.03065635f, -0.01196237f, 
    -0.00697965f, -0.05751740f, -0.01872743f, -0.01642863f, -0.06344987f, 0.10216564f, -0.00476437f, 0.01618125f, 
    0.00578167f, 0.05043605f, -0.03632724f, 0.00613286f, 0.16525798f, 0.06589171f, 0.00862120f, -0.05536842f, 
    -0.18907420f, -0.10855439f, 0.04356838f, 0.12177133f, 0.08292478f, -0.28032011f, 0.06953312f, 0.23398851f, 
    -0.04745117f, -0.04250633f, 0.12390053f, 0.05258800f, 0.01551577f, 0.04726021f, -0.06643529f, 0.25154230f, 
    0.03706321f, -0.15807080f, -0.12221657f, -0.18214151f, 0.07243571f, 0.02036454f, 0.03325310f, 0.09096993f, 
    0.07885157f, -0.25671458f, -0.00123690f, 0.02981843f, 0.38816902f, -0.29645193f, -0.12407358f, -0.00422493f, 
    -0.14694792f, -0.11074135f, -0.02401453f, 0.00439797f, -0.01506724f, 0.04199132f, -0.02256672f, 0.06701642f, 
    0.07213189f, -0.05069138f, -0.12839800f, 0.02358565f, 0.07896207f, -0.11175366f, 0.02534488f, 0.08281986f, 
    0.11299378f, -0.01590686f, 0.04590873f, -0.01930343f, 0.43420598f, -0.16077533f, 0.03839369f, -0.00329618f, 
    0.03331133f, -0.08296354f, -0.10159494f, 0.05745741f, -0.01936029f, -0.10160621f, -0.21288286f, 0.05643861f, 
    0.12293649f, -0.10948519f, 0.10010581f, -0.06463926f, 0.07558110f, -0.05529838f, -0.25218734f, 0.04904026f, 
    0.16307321f, -0.04533096f, -0.01076781f, -0.06692412f, 0.14233920f, -0.01248812f, 0.13035004f, 0.23861048f, 
    -0.07479117f, -0.05503325f, 0.00319612f, -0.00553440f, -0.10937256f, -0.00302978f, 0.06120226f, -0.01073046f, 
    0.27346992f, -0.25723407f, 0.01849487f, -0.17096901f, 0.00459707f, -0.10246019f, -0.04648522f, 0.12226383f, 
    -0.16922040f, -0.03075562f, 0.00160097f, 0.07057942f, 0.14179865f, 0.10630681f, -0.00456271f, 0.03452485f, 
    -0.12208354f, 0.02257662f, 0.05427378f, 0.07125883f, -0.04250135f, -0.04303067f, 0.10037072f, 0.04486367f, 
    0.40756097f, -0.05584187f, -0.06496584f, -0.03039515f, -0.02571629f, -0.00745569f, 0.01846377f, 0.11714549f, 
    0.07456306f, -0.01955785f, -0.00770306f, -0.00418956f, 0.27474910f, 0.06152009f, 0.10641313f, 0.19856161f, 
    0.01086322f, 0.00668043f, -0.09654823f, 0.00903471f, 0.04995475f, -0.10848182f, -0.02972897f, 0.08115450f, 
    0.12627582f, -0.21243584f, 0.09622037f, -0.04918671f, -0.16165327f, -0.14304075f, -0.02534535f, 0.01509132f, 
    -0.04822992f, 0.07881459f, -0.07755571f, 0.04730288f, 0.17321491f, -0.26879129f, 0.12752113f, -0.19064648f, 
    0.08418489f, 0.00469424f, 0.08879022f, 0.01291255f, 0.03217865f, 0.04053693f, 0.02028931f, 0.00675813f, 
    0.22473831f, 0.06180919f, 0.07005259f, 0.11562602f, -0.01989586f, -0.07956952f, -0.08491784f, -0.02637013f, 
    -0.01949002f, 0.07058392f, -0.08090007f, 0.11528128f, 0.02722527f, 0.09074039f, 0.08692506f, 0.16786967f, 
    -0.04445305f, 0.03938865f, -0.02676688f, -0.00227641f, 0.02909713f, -0.05475077f, -0.04275713f, 0.05358908f, 
    0.12155288f, 0.05079357f, -0.32920289f, -0.02518464f, -0.05290729f, 0.01619906f, 0.00674936f, -0.02328416f, 
    -0.05942606f, 0.11314008f, -0.09784462f, -0.03255571f, 0.12643418f, -0.02373643f, -0.07091958f, 0.06373873f, 
    0.03835320f, 0.03945690f, 0.02032453f, -0.14133559f, 0.00631497f, -0.03676872f, 0.01140735f, 0.07579842f, 
    0.33443546f, 0.13577808f, -0.00462603f, 0.11326728f, -0.03560812f, -0.00217700f, 0.01673649f, 0.09764345f, 
    -0.08493571f, 0.07126256f, -0.00792926f, 0.00862405f, 0.23005764f, -0.07328042f, -0.05013156f, 0.08407485f, 
    0.01357155f, -0.04375713f, 0.09460805f, -0.15282592f, -0.05474404f, 0.08537710f, -0.01299561f, 0.09735443f, 
    0.39791220f, -0.20691575f, -0.03255790f, 0.03764654f, 0.01830418f, -0.02078663f, 0.04486408f, -0.01696202f, 
    -0.05897611f, -0.02559186f, 0.04314647f, -0.12084288f, -0.08452665f, -0.00598968f, 0.00501576f, 0.03327774f, 
    0.18300052f, -0.06107033f, 0.03783406f, -0.12140246f, -0.02450180f, -0.00890987f, -0.05678964f, 0.00638500f, 
    0.17243256f, -0.01077275f, 0.04040436f, 0.09546616f, -0.27331778f, -0.11973423f, -0.03321947f, 0.03590638f, 
    -0.03739274f, 0.02726827f, -0.01190683f, -0.07995848f, -0.38987619f, -0.12902638f, 0.10619401f, -0.20599724f, 
    0.01042033f, 0.01685206f, -0.08184691f, 0.00048724f, 0.03063684f, -0.08972778f, 0.03404627f, 0.00452810f, 
    -0.15995894f, 0.10306078f, 0.02093040f, -0.04459723f, -0.00368841f, -0.00105505f, 0.02573035f, -0.03185815f, 
    -0.05719328f, 0.00662434f, 0.03120168f, -0.08940548f, 0.37497181f, -0.00089752f, 0.18122025f, 0.06260947f, 
    0.06037232f, 0.07475647f, 0.03937022f, 0.13118619f, -0.04218404f, 0.10371202f, 0.04167589f, -0.08017322f, 
    -0.07205247f, 0.05467148f, -0.03569061f, -0.03242028f, 0.02978901f, 0.00794225f, 0.06746981f, -0.07172211f, 
    0.02250444f, 0.12509020f, 0.03085331f, 0.00467333f, 0.25578716f, 0.03834164f, -0.30064660f, -0.02941407f, 
    -0.21323411f, -0.03351071f, 0.19847210f, 0.07674915f, -0.01066163f, 0.04305495f, -0.04676969f, -0.06619833f, 
    0.34834939f, -0.13983838f, -0.02095497f, 0.00594227f, -0.09198076f, -0.01831014f, -0.10524136f, -0.03259477f, 
    -0.01547598f, 0.04948041f, -0.01574728f, -0.03236073f, -0.03438707f, 0.00998048f, -0.08233073f, -0.17364959f, 
    -0.01053858f, 0.05471069f, -0.00593297f, -0.04174833f, -0.02593018f, 0.10867350f, -0.08115246f, -0.03246647f, 
    -0.23342061f, 0.07397962f, -0.06616649f, -0.15636510f, -0.01962031f, 0.11027460f, 0.06413872f, -0.09538555f, 
    -0.00015820f, 0.00351556f, -0.06197186f, -0.07165517f, -0.19018853f, 0.10420974f, -0.23351675f, -0.29724583f, 
    -0.02649335f, -0.01314884f, 0.02755282f, -0.08397436f, -0.03544939f, 0.03478464f, 0.00817600f, 0.02941615f, 
    0.08260641f, 0.11666556f, 0.00070639f, 0.02901527f, -0.15941373f, 0.02424450f, -0.06110350f, -0.03379981f, 
    -0.04749981f, 0.00247929f, 0.01685010f, 0.01531366f, 0.11347517f, -0.06024059f, -0.03836266f, -0.13365516f, 
    0.10117845f, 0.05128679f, -0.01934647f, -0.00359053f, 0.00220644f, -0.03948900f, 0.03392658f, -0.05474612f, 
    0.02998296f, -0.17630178f, 0.05271889f, -0.01137675f, -0.00936926f, 0.02028499f, 0.00053632f, -0.06892677f, 
    -0.02709348f, 0.05190847f, -0.05412197f, 0.04197214f, 0.10460580f, 0.05211065f, 0.03227115f, -0.04385911f, 
    0.08686282f, -0.09634255f, 0.06877325f, -0.10482239f, 0.05668126f, 0.05362030f, 0.06529594f, -0.03114512f, 
    -0.09155718f, -0.05633147f, -0.08285666f, -0.08509914f, 0.10443441f, 0.07433537f, 0.02464357f, -0.13836110f, 
    -0.00333558f, -0.01153475f, -0.08195104f, -0.20181151f, -0.51262760f, 0.01443731f, -0.00849280f, -0.14756359f, 
    0.10238383f, -0.02495540f, 0.09685091f, -0.05566221f, -0.08754868f, 0.07047839f, -0.08893155f, -0.07418478f, 
    0.19213796f, 0.09505122f, -0.26322889f, 0.04539171f, 0.15134236f, 0.02544614f, -0.04624206f, -0.08452758f, 
    -0.04778125f, -0.02569735f, -0.11935019f, -0.08199240f, 0.31523776f, -0.08099528f, 0.13051395f, -0.13654667f, 
    -0.13396898f, -0.01742007f, -0.10029093f, 0.01976011f, -0.04103057f, 0.03108267f, -0.04937373f, -0.14163889f, 
    0.03989250f, 0.10572596f, 0.02256208f, -0.28249267f, 0.03506393f, -0.06200707f, 0.05991858f, 0.03599833f, 
    -0.07846001f, 0.03322462f, -0.05294016f, -0.05919496f, -0.00137248f, -0.26916322f, -0.03464264f, -0.13886455f, 
    0.07153606f, 0.00448646f, -0.00973331f, -0.02615191f, -0.04298504f, 0.00738938f, 0.01175854f, 0.07030704f, 
    0.12885104f, -0.01392002f, -0.00023775f, -0.06181586f, -0.06717588f, -0.02432246f, 0.10475215f, 0.03930601f, 
    -0.13015783f, -0.08851752f, 0.02806470f, -0.02526009f, 0.40434322f, -0.14752740f, 0.01727123f, 0.01357011f, 
    -0.17362741f, -0.00385841f, -0.08262318f, -0.02320803f, 0.10538353f, -0.01017301f, 0.05179811f, -0.01988936f, 
    0.27923203f, -0.04314143f, -0.16856995f, -0.02988006f, -0.06059827f, -0.00391862f, -0.03401183f, -0.02009103f, 
    -0.03892002f, -0.01808513f, -0.01917317f, -0.12731309f, -0.28298667f, -0.04724597f, -0.30484223f, -0.07063027f, 
    -0.06269319f, -0.02259525f, 0.02573652f, 0.02879422f, -0.02319199f, 0.09782709f, -0.01090844f, -0.00955705f, 
    0.01859295f, -0.02780389f, -0.10279068f, -0.13939193f, 0.06028049f, 0.05705251f, 0.06720985f, 0.00983168f, 
    -0.07334372f, 0.10367574f, -0.01127620f, -0.01908719f, 0.28397888f, 0.19358125f, 0.06364444f, 0.17537934f, 
    -0.12921833f, -0.11578710f, 0.04261705f, 0.06538434f, -0.05474815f, 0.01777072f, 0.03170308f, 0.07110190f, 
    -0.05454741f, 0.06859065f, 0.04764161f, 0.06422599f, 0.06880327f, -0.02343722f, 0.15476961f, 0.02558240f, 
    -0.03807908f, 0.00514977f, 0.00373730f, 0.01050151f, 0.25311422f, 0.09017068f, 0.02448457f, 0.06878881f, 
    -0.03147031f, -0.04393488f, -0.05494330f, 0.00729444f, -0.10688337f, 0.10469233f, -0.01767904f, 0.02017838f, 
    0.10551852f, 0.10752340f, -0.00514481f, 0.05650023f, 0.02767299f, -0.02597502f, -0.01810753f, 0.07750387f, 
    -0.03749991f, 0.04269563f, 0.01141394f, -0.02794405f, 0.07511932f, 0.03958556f, -0.15671498f, -0.02514994f, 
    -0.03251001f, -0.03751580f, -0.08728293f, -0.08814861f, 0.02690962f, 0.03010115f, 0.00396878f, -0.08859514f, 
    -0.20653194f, 0.08726344f, 0.06832840f, -0.04701755f, 0.07208304f, 0.01597799f, -0.00507280f, -0.00826059f, 
    -0.00364672f, 0.02583163f, -0.08282731f, 0.01502049f, 0.09981471f, -0.13723065f, -0.11515613f, -0.19671614f, 
    0.06832591f, -0.01713844f, 0.00926397f, -0.01346455f, -0.05723672f, -0.05094598f, -0.09680684f, -0.04340751f, 
    -0.03517615f, -0.02719415f, -0.03961259f, -0.10885310f, -0.07213826f, -0.15247850f, -0.16517113f, -0.09803104f, 
    -0.06208541f, 0.02411618f, 0.00676869f, -0.08373949f, -0.11128139f, 0.03773759f, -0.01675993f, -0.02518284f, 
    -0.03426424f, 0.00395836f, 0.05706772f, -0.06138924f, -0.10195319f, -0.00349192f, 0.06103685f, 0.02529135f, 
    0.16485547f, -0.28121302f, -0.33370534f, -0.08106802f, 0.06632786f, 0.03144049f, 0.04436688f, -0.16829300f, 
    -0.02571903f, -0.00701850f, -0.01909724f, 0.10141325f, 0.15954348f, -0.08146292f, -0.08412294f, -0.09976672f, 
    -0.02456614f, 0.05153644f, 0.00627563f, -0.04925418f, 0.05657700f, 0.00023007f, 0.03670283f, -0.03403018f, 
    0.06871887f, 0.01257580f, 0.01332311f, 0.16816576f, -0.04138653f, 0.05129848f, 0.03217917f, 0.04907566f, 
    -0.04300252f, -0.00433041f, 0.10817986f, -0.01357652f, 0.09872909f, -0.09614660f, -0.05621964f, -0.08180460f, 
    -0.00799532f, -0.06809148f, -0.02539934f, 0.00236006f, 0.04304115f, -0.07316528f, -0.06093471f, -0.02917305f, 
    -0.27678886f, 0.00378553f, -0.06024130f, -0.11476526f, 0.02434546f, 0.06498060f, 0.06316929f, -0.02291222f, 
    -0.06444783f, 0.01111658f, 0.00945390f, -0.00305167f, -0.01901617f, -0.10787098f, -0.19609760f, -0.01388710f, 
    -0.01598549f, -0.04164043f, 0.04570835f, -0.01623785f, -0.11423063f, 0.04534604f, 0.00554018f, -0.04763608f, 
    0.20925447f, 0.02274312f, 0.00138816f, -0.01847942f, -0.04611794f, -0.05287129f, 0.01587015f, -0.01854914f, 
    0.00553876f, -0.04617266f, -0.10290499f, 0.00569178f, -0.24048702f, -0.01786225f, -0.04379875f, 0.00282837f, 
    -0.07163582f, 0.04209022f, 0.05161944f, 0.03397753f, 0.03909845f, -0.08604147f, -0.11696613f, 0.02161351f, 
    0.09990693f, -0.07962219f, -0.07003149f, -0.00593577f, -0.09763148f, -0.02068823f, -0.02850583f, -0.07745657f, 
    0.05151136f, 0.03777833f, -0.10275392f, 0.00149982f, 0.07668692f, -0.07801266f, -0.00428554f, -0.04811904f, 
    -0.06359161f, 0.03697681f, 0.02818704f, 0.08297891f, -0.06846506f, -0.10024879f, 0.07147506f, -0.01506896f, 
    -0.08464582f, -0.03311156f, -0.09800477f, -0.11905655f, 0.06804989f, 0.00503125f, -0.10809772f, -0.00693407f, 
    -0.06732711f, 0.07200912f, -0.13091099f, -0.05701046f, 0.34155813f, -0.03514776f, -0.03770288f, -0.14050651f, 
    0.06028043f, 0.02275329f, 0.02093752f, 0.13425465f, -0.10734050f, 0.00255846f, -0.09667011f, -0.04106363f, 
    -0.10825559f, 0.01215083f, 0.11752178f, 0.02910009f, -0.13208097f, -0.05773123f, -0.13849273f, -0.06214356f, 
    -0.00231057f, -0.06250842f, -0.02748646f, -0.00808109f, 0.20263594f, -0.05401070f, -0.03286344f, 0.06305591f, 
    0.02558879f, -0.07767889f, 0.08753268f, 0.08304904f, -0.07889818f, -0.01453735f, 0.09266857f, -0.06420857f, 
    -0.12960376f, 0.07962773f, 0.05741035f, 0.18598792f, -0.04073498f, 0.13215448f, 0.03295860f, -0.00058175f, 
    -0.04137873f, -0.00033878f, -0.12778439f, 0.01140808f, -0.03172077f, -0.01055543f, 0.00172223f, 0.05351070f, 
    -0.00265892f, 0.03875216f, -0.03780418f, -0.05632802f, 0.04678011f, 0.00499108f, 0.00003559f, 0.01372590f, 
    0.04550977f, 0.06334222f, 0.08784153f, 0.09965812f, -0.07286355f, -0.13212143f, 0.09561516f, 0.13484007f, 
    -0.04775098f, -0.01271870f, 0.09936527f, -0.05131047f, -0.16743027f, 0.04616513f, -0.00720281f, 0.01623701f, 
    0.01321731f, -0.06638151f, 0.03389294f, -0.02022286f, -0.16341302f, 0.02046797f, -0.07072299f, -0.00732859f, 
    0.20713803f, 0.00443977f, 0.09587839f, 0.23439384f, -0.10486716f, -0.08557153f, -0.04473173f, -0.02582835f, 
    0.00212971f, -0.05007500f, -0.04895688f, 0.02265267f, 0.05308567f, -0.09946032f, 0.07137462f, -0.02992512f, 
    0.12164932f, 0.03396402f, 0.01598000f, 0.03701910f, -0.10274164f, 0.07361707f, -0.01983675f, -0.07491514f, 
    -0.12812009f, -0.10939067f, 0.04000018f, -0.20356607f, 0.04027588f, -0.02452585f, 0.06503695f, -0.07607298f, 
    -0.00581831f, -0.01136150f, -0.05405463f, -0.02695251f, -0.24486417f, 0.12012968f, 0.12231266f, 0.08277323f, 
    -0.06167364f, -0.09148515f, 0.10367455f, 0.09242240f, -0.05251927f, -0.05847158f, -0.03994209f, -0.01079292f, 
    0.19064914f, -0.18471771f, -0.06418618f, -0.11098223f, -0.01427468f, -0.01459055f, 0.08372165f, -0.04673414f, 
    0.06386247f, -0.02654388f, 0.10154468f, 0.00110052f, 0.01875355f, 0.08612525f, -0.07821865f, -0.00016008f, 
    -0.07147510f, 0.05716464f, 0.03096422f, -0.04114467f, 0.03440689f, 0.05026871f, 0.09506664f, -0.04897026f, 
    -0.25177056f, 0.08632949f, 0.14466698f, 0.08149872f, 0.04843466f, 0.04800075f, 0.09242599f, -0.07965095f, 
    -0.07877437f, -0.03633329f, -0.07561120f, 0.06938820f, -0.47654539f, -0.01691139f, -0.04385898f, -0.00999998f, 
    0.02124028f, -0.00183206f, -0.03172270f, -0.03288451f, -0.05093888f, -0.02189088f, -0.01020743f, 0.02402580f, 
    -0.32864845f, 0.09764189f, -0.02825233f, -0.24899080f, -0.00588212f, -0.08125713f, -0.11604851f, 0.06302112f, 
    -0.04968970f, -0.04564893f, -0.03359959f, -0.12409520f, 0.36085927f, 0.10868288f, 0.22264799f, 0.08361360f, 
    0.08710268f, 0.04064777f, -0.00018244f, 0.11445584f, 0.09671352f, -0.04157912f, -0.10326071f, -0.00400113f, 
    -0.07469003f, 0.04464781f, 0.21075407f, 0.17562774f, 0.00174226f, 0.04698860f, 0.09170490f, -0.03639007f, 
    -0.02097210f, -0.05151887f, -0.02346263f, -0.04494505f, -0.21958074f, -0.54952163f, -0.24898857f, -0.12382794f, 
    -0.08978985f, -0.10585538f, -0.03957215f, -0.07428294f, 0.03844946f, -0.04951285f, -0.05498112f, 0.02818766f, 
    0.03079279f, -0.04664430f, -0.13125312f, -0.00016364f, -0.09219462f, -0.08626729f, 0.00859451f, -0.01728449f, 
    -0.05957095f, -0.03966793f, 0.01854409f, 0.11882609f, 0.09081519f, 0.06819889f, 0.07398098f, 0.10394878f, 
    -0.09205831f, -0.11364804f, -0.01521136f, -0.00986697f, 0.04429536f, 0.01821824f, -0.00443413f, 0.00458307f, 
    -0.15258531f, 0.13489117f, -0.03410074f, -0.00694959f, -0.07234449f, 0.15630659f, 0.01572679f, 0.10492934f, 
    0.04988124f, 0.04192009f, -0.10356591f, 0.15250710f, -0.35828203f, 0.03984400f, -0.06008731f, -0.19565606f, 
    -0.05933557f, 0.10539470f, 0.01020938f, 0.00404779f, 0.01276728f, -0.07141034f, 0.04050912f, -0.05534391f, 
    -0.08804528f, -0.25633189f, -0.28814399f, 0.01236354f, -0.01035061f, 0.00303693f, 0.10298889f, -0.02302596f, 
    0.03309100f, 0.10871998f, -0.04759810f, 0.07773009f, 0.07650386f, 0.33064744f, 0.21630214f, -0.15357369f, 
    -0.06318776f, 0.10160472f, -0.05180679f, 0.04007303f, -0.02468491f, 0.03958533f, -0.03814508f, 0.05637641f, 
    0.06695002f, 0.02717520f, 0.02276854f, 0.00047272f, -0.02437939f, -0.07478534f, -0.06359226f, 0.05395583f, 
    -0.01587030f, -0.01278653f, 0.17660978f, -0.14318307f, -0.07764445f, 0.12247439f, 0.02253720f, 0.14387049f, 
    -0.05433993f, 0.03239727f, -0.06073146f, -0.06647203f, 0.04174948f, 0.06565233f, 0.13365772f, 0.13899831f, 
    -0.24473441f, -0.01437525f, -0.25273028f, 0.11377356f, 0.00993181f, 0.03754385f, 0.03799967f, 0.02417305f, 
    0.02533339f, -0.01687917f, 0.07390922f, -0.16572443f, 0.09983004f, 0.13181137f, -0.01551010f, -0.01219857f, 
    -0.00779277f, -0.01758116f, -0.01938760f, -0.00096693f, -0.01281180f, 0.12546162f, -0.10322948f, 0.07509353f, 
    -0.06248746f, 0.13033243f, 0.05805230f, -0.05128100f, 0.05141791f, -0.02173329f, 0.08359359f, 0.02870283f, 
    0.06344248f, -0.00842704f, -0.00381065f, -0.09108561f, -0.28133494f, 0.06875494f, 0.05569790f, -0.00701970f, 
    0.08477175f, -0.00637360f, -0.04308579f, 0.05716202f, -0.00176391f, 0.03832928f, -0.02807488f, 0.07336091f, 
    0.22422548f, 0.13296703f, -0.10337119f, 0.15652069f, 0.01574673f, 0.06534544f, 0.01726816f, -0.10003785f, 
    -0.00086632f, 0.03918765f, 0.08194062f, -0.01800226f, 0.04646648f, -0.29735792f, -0.19355969f, 0.08922232f, 
    -0.01042936f, 0.06840149f, -0.10214744f, -0.04135696f, -0.01077127f, -0.00866325f, 0.01189110f, -0.07588488f, 
    0.23113838f, -0.25544107f, -0.00749003f, 0.11447433f, -0.00323769f, 0.06447611f, -0.00844468f, -0.03873863f, 
    0.03858201f, 0.03540276f, -0.03071268f, -0.06985205f, 0.01571300f, -0.12706879f, -0.05277482f, -0.04336869f, 
    -0.09649257f, -0.05503378f, 0.00449222f, 0.21339060f, 0.05860726f, 0.05630628f, -0.09992811f, -0.00438085f, 
    -0.10842890f, 0.08560099f, 0.17529836f, 0.22144420f, 0.06743893f, 0.07454924f, 0.11794228f, -0.08971131f, 
    -0.05899727f, -0.03758200f, -0.10327473f, -0.09262448f, 0.05960647f, 0.11399868f, -0.03297383f, 0.07788201f, 
    -0.10186789f, -0.04456357f, -0.03775024f, -0.01954746f, -0.05043230f, 0.03354533f, 0.02675232f, -0.04277400f, 
    0.25923797f, 0.11668233f, -0.11721949f, 0.20533217f, -0.09578159f, -0.00764918f, -0.04472720f, 0.08382311f, 
    0.07743269f, 0.02393371f, -0.05675900f, 0.00044066f, -0.03673701f, 0.10052703f, 0.24492000f, 0.21021771f, 
    0.09464383f, -0.06835056f, 0.02202372f, 0.16153918f, 0.02727923f, 0.00252830f, -0.04912701f, -0.00453383f, 
    -0.14199682f, -0.21576451f, -0.35097250f, -0.09125841f, -0.14532484f, 0.00609807f, 0.04154449f, 0.12119165f, 
    0.00905669f, 0.07821508f, 0.10933056f, -0.02416546f, 0.06742261f, 0.13077766f, 0.03795046f, 0.10159232f, 
    -0.06809269f, -0.07964052f, 0.03008077f, -0.00053617f, -0.04506454f, -0.04868688f, 0.01181993f, 0.02434970f, 
    -0.03810051f, 0.14752331f, 0.08736158f, 0.12921618f, 0.00087031f, -0.10662053f, 0.04952896f, 0.05315587f, 
    -0.10676336f, 0.06767849f, -0.13599120f, 0.04559599f, 0.22274703f, 0.00232413f, 0.08623952f, 0.05482907f, 
    0.00471647f, 0.06100158f, 0.00957468f, 0.04084654f, 0.05883243f, -0.00231069f, -0.13073342f, 0.04522779f, 
    0.06119449f, -0.28210288f, -0.16339533f, 0.05525863f, -0.02550135f, -0.04613629f, 0.02871091f, -0.01323632f, 
    -0.02302617f, -0.03043159f, 0.05088024f, 0.04947167f, -0.16290534f, 0.00192490f, -0.05111869f, -0.07784076f, 
    0.00155222f, -0.07121631f, 0.01688740f, 0.01067468f, -0.12444206f, -0.06427336f, 0.00074352f, -0.04957778f, 
    -0.19767287f, 0.14960331f, -0.17820640f, 0.11573047f, -0.07769626f, -0.05876641f, 0.02622768f, -0.05702759f, 
    0.00105344f, 0.08909146f, 0.09582283f, -0.07862980f, 0.12231025f, 0.18084209f, -0.05546425f, -0.07178948f, 
    0.03043541f, -0.08475813f, 0.00643909f, 0.02417106f, 0.02829642f, -0.07085364f, -0.00175241f, 0.00816973f, 
    -0.18107991f, 0.10291289f, 0.07150824f, -0.18582731f, 0.01012600f, 0.02444860f, -0.00423090f, 0.05068539f, 
    -0.03590989f, -0.11035655f, -0.05659198f, 0.10997214f, 0.08507916f, 0.10050846f, 0.01417295f, -0.09184059f, 
    -0.00664022f, 0.01103388f, 0.08990879f, 0.00454270f, -0.05321333f, -0.00300368f, 0.06483280f, -0.04602110f, 
    -0.38257772f, -0.31606618f, -0.04537653f, 0.06626899f, -0.02918659f, 0.04038670f, -0.08408884f, -0.04215193f, 
    -0.00807457f, 0.02728715f, -0.00200883f, 0.05848891f, -0.09361972f, 0.04753592f, 0.06696029f, 0.21246429f, 
    -0.00918509f, -0.05469532f, 0.01659806f, 0.02818731f, 0.02187269f, 0.03539414f, -0.07435217f, 0.03877364f, 
    0.00207405f, 0.01760237f, 0.00964219f, -0.20805237f, -0.04351087f, -0.04145340f, 0.02000197f, -0.10080148f, 
    0.02285066f, -0.05354580f, -0.04352200f, 0.01134231f, -0.00110410f, -0.08817137f, 0.00297523f, -0.00067996f, 
    -0.05957230f, 0.08277155f, -0.06988405f, -0.11023784f, 0.03795492f, 0.07535392f, -0.08198944f, 0.09784044f, 
    0.00726782f, 0.25815961f, 0.08627074f, 0.01428775f, 0.02620947f, 0.04856199f, 0.01261457f, -0.00191392f, 
    -0.04808372f, -0.00038914f, -0.04542276f, 0.08272670f, -0.50602591f, -0.14027096f, 0.04166129f, -0.06945827f, 
    0.03130880f, 0.04901203f, -0.03707723f, -0.01572597f, 0.03785748f, -0.10801724f, -0.01252497f, -0.03245695f, 
    -0.44846526f, 0.16903217f, -0.03718012f, -0.21226163f, -0.04056307f, -0.02720984f, -0.00238577f, -0.00894234f, 
    0.03473757f, -0.09362718f, -0.04656778f, -0.04331274f, 0.12959896f, 0.03730870f, -0.05962918f, -0.07376787f, 
    0.08746079f, 0.04028708f, 0.03246077f, -0.04497861f, 0.01517972f, -0.08638130f, 0.12482710f, -0.02467616f, 
    0.10053778f, -0.02688722f, 0.04388841f, 0.01806895f, -0.06159327f, 0.09416314f, -0.09470052f, 0.06292614f, 
    0.07446012f, 0.04648345f, 0.08157367f, 0.02541506f, 0.07575064f, 0.12859249f, 0.10442672f, 0.13732451f, 
    0.10580303f, 0.02434009f, 0.01306032f, -0.02072673f, 0.00126073f, -0.01279926f, -0.09381089f, -0.04348973f, 
    -0.35150823f, -0.00287166f, 0.13775599f, 0.02795475f, -0.04694960f, -0.03943537f, 0.03611457f, 0.02232431f, 
    0.00843558f, -0.00652770f, -0.02444912f, -0.01680963f, 0.05007732f, 0.08309825f, 0.05257829f, 0.01168746f, 
    -0.13121060f, 0.11720292f, -0.04920571f, 0.00044351f, -0.04469033f, -0.05239734f, 0.12678407f, 0.03845988f, 
    -0.10894687f, -0.04110238f, 0.12041822f, -0.01467035f, -0.07377826f, -0.07405306f, -0.06662600f, 0.00594154f, 
    0.00551142f, 0.05596042f, -0.10399782f, -0.03820056f, 0.35797819f, -0.24016269f, -0.11564118f, -0.07244762f, 
    -0.03715000f, 0.04861325f, -0.01658369f, -0.00774756f, -0.00246482f, -0.01410144f, 0.06911141f, 0.03013059f, 
    0.07885566f, 0.14180161f, 0.11425966f, -0.10631389f, -0.05526833f, -0.07416959f, 0.03313215f, -0.02698266f, 
    -0.02635272f, 0.10298460f, -0.08963618f, 0.06326298f, 0.15044013f, -0.16179290f, 0.24370930f, -0.14127892f, 
    -0.07947529f, 0.04280034f, 0.13966526f, -0.09361464f, -0.01839023f, 0.00526340f, -0.00063007f, -0.01507073f, 
    0.12661920f, -0.00593351f, -0.13911945f, -0.03955809f, -0.05366341f, -0.06779884f, 0.04075057f, 0.13475986f, 
    -0.06103700f, -0.03128782f, -0.01379118f, 0.02825368f, 0.21459506f, -0.36055908f, -0.06402353f, -0.04585197f, 
    -0.03713955f, 0.07646631f, 0.03614405f, 0.02385318f, -0.09851300f, -0.02189514f, 0.00250552f, -0.02699853f, 
    -0.07608333f, 0.06572048f, -0.04961624f, -0.12421516f, -0.13540061f, -0.01561883f, 0.00579025f, -0.00558288f, 
    -0.04719258f, 0.01890122f, 0.01796756f, 0.08074541f, -0.28455567f, -0.19342680f, -0.08652393f, 0.21477336f, 
    0.01892205f, 0.03614182f, 0.02515038f, -0.11139474f, 0.02443460f, -0.04288418f, -0.02807985f, -0.00871637f, 
    0.00174821f, -0.29243380f, -0.07475304f, -0.00247445f, -0.07216357f, 0.03077166f, -0.02204846f, 0.09138747f, 
    -0.06524830f, -0.00469174f, 0.02240242f, 0.06575328f, -0.03646940f, -0.15651514f, -0.06942428f, 0.07804619f, 
    0.13156454f, 0.02581426f, 0.03661386f, -0.02383177f, -0.00505160f, -0.03496449f, -0.02816208f, 0.00330310f, 
    -0.04978042f, 0.05767626f, -0.02849953f, 0.01029918f, -0.05137645f, -0.10723712f, 0.01755098f, -0.04567001f, 
    -0.12015430f, -0.04403676f, -0.10448118f, 0.00690526f, -0.16283111f, -0.25875604f, -0.08765958f, 0.08848868f, 
    -0.03956026f, -0.03671717f, 0.07705905f, -0.04416291f, 0.03620794f, -0.11101598f, 0.06022510f, 0.05675168f, 
    0.01542256f, -0.05122123f, -0.07429217f, -0.00315853f, 0.00921935f, 0.14833815f, 0.02816591f, 0.01077443f, 
    0.01282707f, -0.07900519f, 0.03270703f, -0.04144073f, -0.12775320f, -0.08105490f, -0.00929478f, -0.09805754f, 
    -0.15236284f, 0.06242048f, 0.04674482f, 0.04471057f, -0.00056537f, 0.01866457f, -0.03200403f, 0.05665433f, 
    -0.37545115f, -0.05167029f, -0.11445838f, -0.27101830f, -0.06052200f, -0.01056258f, 0.02448212f, 0.10164385f, 
    0.02632653f, -0.03882303f, 0.00829612f, -0.01633456f, -0.50990260f, -0.01751958f, -0.05542292f, 0.05936520f, 
    -0.14309341f, 0.00140078f, 0.07974855f, -0.03911643f, -0.00643480f, 0.01993303f, -0.02586523f, 0.02715166f, 
    -0.09425136f, -0.05806319f, 0.13863713f, -0.05432022f, 0.05130187f, 0.07069449f, -0.03268962f, -0.05135281f, 
    0.02855125f, -0.00206765f, -0.11451252f, 0.06154793f, -0.00166467f, 0.07757927f, -0.08222400f, -0.02792306f, 
    -0.04991433f, -0.12449261f, 0.09880523f, -0.03432393f, -0.00760725f, 0.01137690f, 0.02993604f, -0.14980616f, 
    0.22833750f, 0.12758684f, -0.00903266f, 0.13160022f, 0.02041651f, 0.04076193f, 0.08889528f, 0.12661931f, 
    0.01277184f, 0.05525510f, 0.07955498f, 0.07976449f, -0.14956264f, 0.34872985f, -0.16987661f, -0.20375252f, 
    0.01970904f, -0.08119440f, 0.06078456f, 0.08407053f, 0.02932657f, 0.01343784f, -0.05339875f, 0.09423160f, 
    -0.28192642f, -0.10987850f, -0.00549585f, 0.15706626f, 0.04313128f, -0.06592257f, -0.03612917f, -0.03840442f, 
    0.18192786f, 0.11279784f, -0.08856747f, -0.07937106f, 0.20182817f, -0.13548866f, -0.05310427f, 0.06962462f, 
    -0.12621956f, -0.03793891f, 0.07348012f, -0.06058763f, 0.00949789f, 0.07625570f, -0.06305136f, 0.00181740f, 
    -0.10177526f, 0.01564947f, 0.08400307f, 0.01422647f, 0.09635175f, 0.02088377f, 0.09581634f, 0.07849800f, 
    -0.01179392f, -0.03024172f, 0.01041270f, -0.02159242f, 0.15060467f, -0.00677804f, -0.01384809f, -0.06751132f, 
    -0.01689973f, -0.03670212f, -0.02288844f, 0.05899400f, -0.05889897f, 0.02885160f, 0.01615924f, 0.05871033f, 
    0.16714521f, -0.07514317f, 0.13096578f, -0.02158676f, -0.01975256f, -0.01042098f, 0.11310445f, 0.01570191f, 
    0.04045058f, 0.07128133f, 0.03116281f, -0.00160494f, -0.29206219f, -0.15580982f, 0.18274052f, 0.22102669f, 
    0.02831618f, -0.06343862f, -0.05115921f, 0.14687923f, -0.17495613f, 0.05875144f, 0.11199782f, 0.10243634f, 
    -0.04929915f, -0.10826410f, 0.13224122f, -0.02459879f, 0.01856854f, 0.03503792f, -0.00505966f, 0.07452428f, 
    -0.02758193f, 0.05900371f, -0.01416992f, 0.06398904f, -0.02341025f, 0.00863144f, 0.14279725f, -0.16527364f, 
    0.02199470f, 0.06339749f, 0.03733759f, 0.06078157f, -0.09711399f, -0.00103900f, 0.08089761f, 0.07754972f, 
    0.00755968f, 0.27804783f, -0.11119194f, -0.24095961f, -0.02050586f, 0.02997110f, -0.11823821f, 0.02605242f, 
    0.08021448f, 0.01418777f, -0.15659359f, 0.01308455f, -0.23621489f, 0.11964376f, 0.14174639f, 0.05599221f, 
    0.04467486f, -0.03926348f, -0.18145745f, 0.03040209f, -0.02408365f, 0.02577935f, 0.02168134f, 0.09564374f, 
    -0.26882371f, -0.30829918f, 0.24453121f, 0.09714606f, -0.11759843f, -0.06279123f, 0.13305119f, -0.14160617f, 
    0.06052071f, 0.00833397f, 0.02580936f, -0.05266504f, 0.01492883f, -0.11726150f, 0.13336411f, 0.04235324f, 
    0.04415857f, -0.01326655f, 0.01508616f, -0.02386609f, 0.03476753f, 0.01665137f, -0.01385050f, 0.11417553f, 
    0.41166121f, 0.04458476f, -0.13454667f, -0.16208579f, 0.07275803f, -0.03262435f, -0.02342980f, 0.00303056f, 
    -0.10439796f, -0.21155614f, -0.10666746f, -0.01135718f, -0.27592692f, 0.07424279f, 0.04604276f, 0.10804795f, 
    -0.04772846f, -0.04866051f, 0.14161400f, -0.00788359f, -0.02363100f, -0.04562780f, -0.10426401f, 0.07650857f, 
    -0.09131136f, 0.01202618f, -0.14374855f, 0.02180506f, 0.04025683f, -0.02832639f, 0.05931676f, -0.02070190f, 
    -0.09195282f, -0.08699560f, 0.05684055f, 0.06232461f, -0.09463298f, -0.06175393f, 0.17141008f, 0.16121621f, 
    -0.22173227f, 0.04005069f, -0.05028209f, 0.07359142f, 0.04963298f, 0.04278849f, -0.12093221f, 0.12246981f, 
    -0.06377306f, 0.02034633f, 0.18883090f, 0.11538789f, -0.18603177f, 0.04947433f, -0.02384968f, -0.05824298f, 
    0.01432356f, -0.00789349f, -0.09173646f, 0.12865376f, 0.02746479f, -0.08946879f, 0.12911774f, -0.04108964f, 
    -0.09368393f, 0.07445649f, 0.02999651f, -0.02744570f, 0.01182157f, -0.00375612f, 0.06415484f, -0.06753322f, 
    -0.43296942f, -0.00596906f, 0.16551727f, 0.14905822f, -0.11352225f, -0.00733818f, -0.05644685f, 0.01120380f, 
    0.05446985f, -0.00629660f, -0.12256156f, -0.02191296f, 0.02588225f, 0.03159795f, -0.00261232f, 0.10132687f, 
    0.12311595f, 0.08635005f, -0.03675137f, 0.12653443f, 0.06141209f, 0.10398763f, -0.03159958f, 0.01454490f, 
    -0.14855942f, -0.25710967f, -0.14784464f, 0.04373864f, -0.04997219f, -0.02218507f, -0.03003785f, -0.05929927f, 
    -0.03870529f, -0.08563311f, 0.05325932f, 0.05947015f, -0.24090391f, 0.13806841f, -0.10729673f, -0.43824837f, 
    0.10519526f, 0.00608383f, -0.09148559f, -0.10538366f, 0.00107371f, -0.13396600f, -0.00483289f, 0.04970677f, 
    -0.11430616f, -0.04478917f, -0.00928017f, -0.04264291f, -0.02735657f, -0.04197749f, 0.09277745f, 0.09012859f, 
    -0.05128488f, -0.10544042f, -0.03289085f, -0.14623666f, -0.86799735f, -0.00916036f, -0.00512289f, -0.16701451f, 
    0.02322829f, 0.04974277f, -0.00997983f, 0.05733819f, -0.06804158f, 0.00215835f, -0.02952781f, 0.05901181f, 
    -0.17767338f, -0.03694865f, -0.07583462f, 0.00045569f, -0.01223727f, -0.10604499f, 0.07496063f, 0.09581709f, 
    -0.04879330f, -0.04806163f, 0.00701909f, 0.01057062f, 0.00740536f, 0.10240044f, 0.00491491f, 0.03008930f, 
    -0.16092369f, -0.02911433f, 0.05595614f, 0.00698260f, -0.10904511f, 0.03667092f, 0.06425276f, 0.08247725f, 
    0.00198616f, 0.15096037f, 0.19358544f, -0.00139690f, -0.05314550f, 0.08031882f, -0.00497664f, -0.02624413f, 
    0.09381313f, -0.08134954f, 0.07205740f, 0.00722102f, -0.07887971f, -0.04990532f, 0.13596562f, 0.26534006f, 
    0.05932363f, 0.03669439f, 0.00010548f, 0.03147700f, -0.06917221f, 0.02206323f, -0.04807876f, -0.02946985f, 
    0.01704957f, -0.38799027f, -0.25884247f, 0.21720521f, 0.04732833f, -0.03101136f, 0.08173858f, -0.03894321f, 
    -0.04621021f, -0.00847178f, 0.05415916f, 0.03776577f, 0.13358352f, 0.11352251f, -0.12527774f, -0.08225444f, 
    -0.04351481f, 0.07707622f, 0.05403363f, 0.01149117f, -0.03241083f, -0.04614039f, 0.01906883f, -0.04343773f, 
    -0.16949297f, -0.13666728f, 0.11535238f, 0.09295978f, 0.05947749f, -0.11117586f, 0.09753086f, -0.05874166f, 
    0.03876613f, -0.01969148f, -0.12923789f, 0.05956897f, 0.09378698f, -0.22238660f, -0.05087809f, -0.13555090f, 
    -0.00414470f, 0.04591244f, -0.05229568f, -0.05003212f, -0.04446978f, -0.11894905f, -0.09314909f, 0.04750001f, 
    0.13958408f, 0.21564411f, 0.00508259f, 0.02853996f, -0.02400385f, 0.00047430f, 0.04803055f, 0.03390413f, 
    -0.04584596f, -0.01229048f, -0.07863942f, 0.00026722f, -0.07844384f, -0.02904144f, 0.02050709f, -0.00319909f, 
    -0.02769400f, -0.09111395f, 0.03332648f, 0.00453450f, 0.11272189f, -0.07848752f, -0.02703154f, -0.03810431f, 
    0.22783521f, 0.04753523f, 0.11958010f, 0.13558465f, 0.04122091f, -0.00611280f, 0.05535505f, 0.11392555f, 
    -0.00141877f, 0.08935516f, 0.01390265f, 0.01398814f, 0.08276640f, -0.19231874f, 0.00732413f, 0.17897202f, 
    -0.14418271f, -0.01746519f, 0.13316542f, 0.00932044f, 0.00807143f, 0.06631869f, -0.03336466f, -0.07884210f, 
    0.12842754f, 0.11623689f, 0.05564718f, 0.04238988f, -0.05149128f, -0.02787060f, -0.00452374f, -0.03371611f, 
    -0.00768002f, 0.07620364f, -0.02387771f, 0.04935350f, -0.40595001f, 0.12439121f, -0.07852626f, -0.04904280f, 
    -0.09117397f, -0.02175182f, 0.05574593f, 0.01016550f, -0.07539794f, 0.02421518f, -0.08825029f, -0.08893441f, 
    0.07768723f, -0.16256635f, -0.02467378f, 0.19459838f, -0.10320187f, 0.05066907f, 0.03573085f, 0.01399325f, 
    -0.03678614f, 0.07839356f, 0.14969319f, 0.11380208f, -0.08614649f, 0.03429000f, -0.20592752f, -0.20132406f, 
    0.05943450f, -0.04336033f, 0.01068189f, 0.00786991f, 0.04212197f, -0.09181370f, 0.06105298f, 0.09665742f, 
    -0.02895887f, -0.09715267f, -0.06583913f, 0.02134596f, -0.15623540f, -0.05771121f, 0.09150368f, -0.01863577f, 
    -0.04143624f, 0.09530734f, -0.09227458f, 0.01928777f, -0.13204172f, -0.00097524f, 0.06872690f, 0.04840059f, 
    0.07715914f, 0.07181253f, 0.07668138f, 0.07479666f, 0.06806201f, -0.04830313f, 0.04085710f, 0.05914854f, 
    0.14198759f, 0.13724062f, -0.13985090f, -0.05873878f, 0.05104512f, -0.02158324f, 0.14264509f, -0.01408384f, 
    0.01183736f, 0.06568376f, -0.06688818f, 0.00796773f, -0.01233634f, 0.03361703f, -0.08884650f, 0.03410669f, 
    0.06347315f, 0.03823498f, 0.03748071f, 0.03193970f, -0.03885419f, -0.18799977f, 0.01471440f, -0.01516765f, 
    0.15671369f, -0.05217243f, 0.00761466f, 0.08858632f, -0.08263361f, -0.09416521f, 0.21111754f, -0.09885082f, 
    0.03868316f, 0.09369880f, -0.16314258f, 0.02800356f, 0.16291131f, 0.17667714f, -0.10070499f, -0.13593103f, 
    0.03779281f, 0.01300353f, -0.10872461f, -0.15787528f, -0.01731993f, 0.03514902f, -0.07031833f, -0.18216608f, 
    0.08857737f, 0.08961089f, 0.05090434f, -0.15287606f, 0.03866161f, -0.05091490f, 0.04366336f, 0.06558619f, 
    -0.02058180f, 0.09844356f, -0.04130085f, 0.07038294f, -0.06803897f, 0.09737562f, -0.07436440f, 0.05747513f, 
    0.02544972f, 0.10236983f, 0.03111175f, -0.12057663f, 0.05639891f, -0.06440948f, 0.03676191f, -0.08697125f, 
    -0.25538972f, 0.00501879f, -0.05844931f, 0.11343082f, -0.00091069f, 0.02941782f, 0.02004530f, 0.01929469f, 
    -0.00859147f, 0.09767558f, 0.01372009f, 0.02663055f, 0.11500005f, -0.12760627f, -0.02921598f, 0.01335061f, 
    -0.03329017f, 0.06688751f, -0.10380369f, -0.11951509f, -0.04850898f, -0.04013068f, 0.02725087f, -0.02715088f, 
    -0.23833789f, -0.21460567f, -0.22427270f, 0.12856896f, 0.08332300f, -0.01017982f, 0.10189488f, -0.13637671f, 
    -0.04707157f, -0.00483156f, -0.01116607f, -0.00713961f, -0.05278411f, 0.02610595f, -0.02587045f, 0.08325721f, 
    0.07318342f, 0.03758241f, 0.05081942f, 0.05747116f, 0.03925956f, -0.11247519f, -0.06604574f, 0.01197857f, 
    -0.32663482f, 0.11281893f, 0.14191397f, 0.08886527f, -0.05170505f, 0.04646924f, 0.03829389f, -0.02163672f, 
    0.05819310f, 0.05814541f, 0.00752999f, 0.05889146f, -0.17874408f, -0.05322684f, -0.05603733f, -0.03320212f, 
    -0.00525212f, 0.00129381f, -0.13407342f, -0.06044835f, 0.02999889f, -0.09661900f, -0.06156628f, -0.06242920f, 
    -0.15881407f, 0.04008434f, -0.04511932f, 0.11357299f, -0.02013076f, 0.00991841f, -0.00284105f, 0.04477594f, 
    0.04238547f, -0.13753048f, 0.08317128f, -0.06383195f, 0.20849058f, 0.10755949f, -0.14911681f, -0.04913891f, 
    -0.09107908f, -0.03369506f, 0.07685526f, 0.06418196f, -0.11934832f, 0.08945926f, 0.00880918f, -0.00227392f, 
    0.25920340f, -0.05563179f, -0.17866375f, 0.09007339f, -0.05442625f, -0.03743341f, 0.06026250f, -0.12284566f, 
    -0.05535926f, -0.16196764f, 0.11048991f, -0.07676916f, -0.17237172f, 0.01772730f, 0.10905743f, -0.00962150f, 
    -0.06398509f, 0.04027255f, 0.01557674f, -0.09903765f, 0.09523121f, -0.01791518f, 0.04607268f, -0.00625086f, 
    0.18007930f, -0.20049678f, -0.22426791f, 0.13651812f, -0.09687547f, -0.03281277f, 0.06600604f, 0.08806775f, 
    -0.07607979f, 0.02290053f, 0.03481462f, 0.00433497f, -0.36035061f, -0.14927845f, 0.08070415f, 0.00698584f, 
    -0.01277480f, -0.01453976f, 0.04421650f, 0.07135003f, -0.08947698f, 0.12098135f, -0.00707228f, 0.06158097f, 
    0.02557479f, 0.04193785f, -0.06004584f, 0.07308436f, 0.04635398f, 0.02997746f, -0.07392501f, 0.01214939f, 
    -0.04488657f, -0.16456828f, 0.13191305f, 0.07712520f, -0.05077192f, -0.02163094f, 0.12428915f, -0.26856673f, 
    -0.14616583f, 0.00990664f, -0.02223410f, 0.06480376f, 0.07713601f, 0.14447734f, 0.13635528f, -0.07204870f, 
    -0.04377482f, -0.07713976f, 0.18386631f, 0.00609369f, 0.05146785f, -0.12857725f, -0.02080230f, -0.13649373f, 
    0.10278525f, -0.03861124f, -0.04075499f, 0.00201652f, -0.20121664f, -0.26489872f, 0.19074085f, 0.12940264f, 
    0.12224856f, 0.01589262f, -0.00526078f, -0.01387963f, -0.06566443f, 0.06860823f, 0.05756561f, -0.06263235f, 
    0.09153844f, 0.05669134f, -0.09097014f, -0.37868127f, 0.06232439f, -0.01210121f, -0.04026277f, -0.07866953f, 
    -0.00413704f, 0.00490129f, 0.07696165f, 0.07944205f, 0.11523444f, 0.02626208f, 0.27428481f, 0.05626514f, 
    0.14743634f, -0.02622162f, 0.09828614f, 0.06985247f, 0.06508908f, 0.02598202f, 0.08643582f, 0.10909612f, 
    -0.43555462f, -0.23857684f, -0.24983647f, 0.11520288f, 0.11978982f, 0.00786826f, 0.03533994f, -0.07086294f, 
    0.06600982f, 0.15511401f, -0.06423423f, 0.08134194f, -0.13042299f, -0.05930576f, -0.14991927f, 0.13564335f, 
    0.12967378f, -0.16958305f, 0.06158874f, -0.06672928f, -0.03691531f, 0.07461143f, -0.23057318f, 0.07148396f, 
    -0.01598554f, -0.01756275f, -0.09717896f, 0.03078623f, -0.04864268f, -0.02791478f, -0.07161870f, -0.02371756f, 
    0.01661052f, -0.07699382f, -0.01821045f, 0.21696107f, 0.01696665f, 0.20551212f, -0.21990290f, -0.11253069f, 
    0.13341986f, 0.13067897f, 0.03467244f, -0.12124057f, -0.06713129f, -0.14608145f, -0.06740440f, -0.07149186f, 
    0.06108116f, -0.14147244f, 0.03305053f, 0.20151655f, -0.01040863f, -0.07059325f, -0.05145727f, -0.01307050f, 
    -0.05381627f, -0.14986449f, -0.16263171f, -0.13873872f, -0.05914398f, 0.08992019f, -0.22350919f, -0.03074929f, 
    0.04729229f, -0.16211534f, -0.06526548f, 0.09391598f, 0.02613160f, -0.02909273f, -0.06462651f, -0.15096062f, 
    -0.35014674f, -0.01487866f, 0.15347268f, -0.03000867f, 0.08537154f, -0.02338620f, 0.16471484f, -0.08468893f, 
    -0.00172802f, 0.05173254f, -0.13999377f, -0.03156782f, -0.00645370f, -0.08265879f, 0.10406324f, 0.18864696f, 
    0.04650651f, 0.05735010f, 0.11201625f, 0.03583395f, -0.02365160f, -0.04032002f, -0.18594784f, -0.04559042f, 
    0.01649992f, 0.09117322f, -0.08723821f, 0.12699898f, -0.24223208f, 0.01907292f, 0.01682797f, 0.02537622f, 
    -0.14118341f, -0.09151776f, 0.18207504f, 0.02596125f, 0.00691764f, 0.12570177f, 0.05461127f, 0.22116797f, 
    0.12052730f, -0.01996174f, 0.04712764f, 0.18323514f, 0.02270154f, -0.01357195f, -0.01363826f, -0.25662795f, 
    -0.21694525f, -0.20293330f, 0.09814133f, 0.13100669f, -0.09441072f, -0.06483252f, 0.12651137f, 0.18952949f, 
    0.10659689f, -0.00162011f, -0.10149418f, -0.14645049f, -0.05869910f, -0.11215676f, 0.07234865f, -0.07196076f, 
    -0.00559100f, 0.06862863f, -0.00213697f, 0.01025417f, -0.04858843f, -0.03399331f, 0.08275121f, -0.08280257f, 
    -0.33482870f, -0.06769928f, -0.09452359f, -0.30621439f, -0.03369411f, 0.09121227f, -0.10041740f, 0.10797196f, 
    0.06437082f, -0.06166100f, 0.03051211f, -0.03161488f, -0.11385813f, -0.05609580f, 0.00506576f, 0.11345655f, 
    -0.00548630f, -0.11352334f, 0.00025819f, -0.02646118f, 0.01703075f, -0.06910142f, -0.10929628f, 0.04968855f, 
    0.06009021f, 0.06515943f, 0.04551210f, 0.15186122f, 0.04639823f, -0.08781298f, -0.03686965f, -0.04799099f, 
    -0.05224033f, -0.03245156f, 0.09388865f, 0.10540149f, -0.11508884f, 0.11091332f, 0.06940461f, 0.17448401f, 
    -0.02421838f, -0.06189511f, -0.00198116f, 0.04070535f, 0.01689761f, -0.01245103f, -0.14040613f, 0.03901045f, 
    0.23759213f, -0.07548989f, 0.01436982f, 0.15233442f, -0.06522626f, 0.00341938f, 0.09744254f, 0.01093598f, 
    -0.12561528f, 0.07354000f, 0.08694481f, 0.19237018f, -0.41178378f, -0.16436462f, -0.09897365f, 0.07166954f, 
    0.05334246f, -0.02207870f, 0.08995686f, 0.02644624f, 0.01267729f, 0.07487217f, 0.09855087f, 0.18406861f, 
    -0.24811411f, 0.16539441f, -0.03410497f, 0.02667616f, -0.09749817f, 0.04993463f, 0.05139061f, -0.02622409f, 
    -0.01328076f, -0.18650392f, 0.09194937f, -0.06033496f, 0.01582541f, -0.02174892f, 0.25604579f, 0.20942084f, 
    0.02362191f, -0.00673683f, 0.06847532f, 0.09649518f, 0.07183551f, 0.07164373f, -0.08726555f, 0.05313900f, 
    0.04091478f, 0.04161389f, 0.10984489f, 0.07975546f, -0.05382402f, 0.08678668f, -0.01312418f, -0.13574401f, 
    -0.11180389f, 0.03675157f, 0.08381314f, 0.21766911f, -0.50504392f, 0.14396800f, -0.20006797f, -0.30542213f, 
    0.13431396f, 0.04114059f, -0.00269253f, 0.07032306f, 0.01652228f, -0.05037953f, -0.01689277f, -0.13538240f, 
    -0.17499267f, 0.07560345f, 0.00492559f, -0.12572856f, 0.04036358f, 0.04988086f, 0.00170701f, -0.02174658f, 
    0.06029710f, -0.06353233f, 0.04884495f, -0.02384236f, 0.09022752f, -0.02081590f, 0.05965628f, 0.11184396f, 
    0.03373080f, -0.03102193f, -0.03690496f, 0.05296307f, 0.01444237f, -0.13824683f, 0.07823106f, -0.14101586f, 
    0.07352259f, 0.00201766f, -0.00841755f, 0.03973890f, 0.05684958f, 0.01190786f, 0.02607360f, -0.04298400f, 
    -0.18108106f, -0.01049474f, 0.04682186f, -0.02533151f, 0.08911151f, -0.14352024f, -0.23578793f, 0.00098639f, 
    0.03786658f, 0.09877839f, -0.08055375f, -0.03786592f, 0.05390309f, 0.02129130f, 0.05027602f, -0.00880382f, 
    0.23696078f, 0.11826032f, 0.18582715f, -0.17804204f, 0.10778338f, -0.14424829f, -0.25449359f, -0.13491550f, 
    -0.10248721f, 0.04640871f, -0.14730310f, -0.20398831f, -0.26834339f, -0.29003704f, -0.10685276f, -0.03638972f, 
    -0.05235538f, 0.01954527f, 0.26316166f, 0.08226209f, 0.04756351f, -0.00076356f, 0.02616799f, -0.12755859f, 
    -0.17083335f, -0.13309769f, -0.07865234f, 0.06332623f, -0.02646847f, 0.10378268f, 0.05069957f, -0.12898432f, 
    0.00329856f, 0.02553355f, 0.16615221f, -0.08421565f, -0.20808573f, -0.08457720f, 0.01790195f, -0.04374256f, 
    0.06669907f, -0.01097320f, 0.02730120f, -0.00149920f, 0.03316850f, -0.01580345f, 0.06973927f, 0.04382189f, 
    -0.17081359f, 0.03554510f, 0.16361663f, -0.19646630f, 0.03878508f, -0.05588640f, -0.07638626f, 0.01019052f, 
    0.14228016f, 0.04564565f, 0.03654527f, -0.09919190f, 0.07373600f, -0.08027712f, 0.06141296f, 0.01561005f, 
    -0.00309974f, 0.09466822f, -0.04831257f, 0.13367905f, -0.08100120f, 0.14189453f, 0.08964797f, 0.12982236f, 
    -0.19041565f, -0.08184545f, -0.00925950f, 0.08182920f, 0.10557532f, 0.00821341f, -0.12238926f, -0.23612964f, 
    0.06045019f, -0.13082993f, 0.12303261f, 0.09876096f, 0.05533208f, 0.06468805f, -0.04977902f, -0.02756730f, 
    -0.05065343f, 0.09711853f, -0.20147057f, 0.01965714f, -0.02978326f, -0.11309897f, 0.00175007f, 0.05703651f, 
    0.05972435f, -0.05679911f, 0.06198573f, 0.21697594f, -0.01378929f, -0.07478794f, -0.07027885f, 0.02559453f, 
    0.01007022f, -0.00016732f, 0.03128719f, -0.05111754f, 0.03444863f, -0.18145475f, 0.02640343f, 0.08874398f, 
    0.00085583f, 0.00805964f, -0.08223149f, 0.01765460f, 0.02030201f, 0.15051445f, 0.09643766f, 0.05538765f, 
    -0.15344545f, 0.19900669f, 0.01498849f, -0.06578733f, 0.05897097f, -0.07582996f, 0.07900760f, -0.21167654f, 
    0.00036514f, 0.07031839f, -0.14674811f, 0.08005548f, -0.25690481f, 0.18375535f, 0.13510387f, -0.27028301f, 
    0.02894470f, -0.00375164f, 0.05641003f, 0.10169897f, 0.00366666f, 0.01823206f, -0.05366587f, -0.00788076f, 
    0.06119779f, 0.09844961f, 0.19982173f, 0.07465772f, 0.06884711f, -0.05754130f, 0.02049902f, -0.06466513f, 
    0.08943655f, -0.03661857f, -0.08704606f, -0.09913272f, 0.12901999f, -0.06487942f, -0.17882819f, 0.01106103f, 
    -0.03179103f, 0.01206044f, -0.10981388f, -0.07269286f, -0.05544375f, 0.01183496f, 0.18042541f, 0.20087019f, 
    -0.01526625f, 0.00299203f, 0.04846730f, 0.07261319f, 0.10328408f, -0.00133462f, -0.06225365f, -0.04046514f, 
    0.10609528f, 0.01466314f, -0.05782203f, 0.07909792f, -0.05778565f, -0.17931917f, -0.01647769f, 0.03233252f, 
    0.04332706f, -0.06446659f, -0.14720175f, 0.10234692f, -0.03460656f, 0.31740758f, -0.02121763f, 0.06380902f, 
    0.10561749f, 0.11578340f, 0.07150351f, -0.09334400f, -0.08051370f, 0.00445610f, -0.10870666f, 0.04215375f, 
    0.06742404f, -0.12832300f, 0.10517980f, -0.04054325f, 0.14029036f, 0.12125435f, 0.03111122f, -0.10442497f, 
    -0.01864421f, -0.07917272f, -0.13332720f, 0.04224906f, -0.11430641f, 0.05142428f, -0.08178323f, -0.22233337f, 
    -0.28825140f, 0.00534236f, 0.16622335f, 0.24270271f, 0.05641816f, 0.09198947f, -0.02175328f, -0.02065970f, 
    0.04893503f, -0.11459910f, 0.11957163f, -0.11696734f, -0.23676945f, -0.15076919f, 0.17328271f, -0.06490184f, 
    -0.04280288f, -0.11166163f, -0.07482753f, -0.02455620f, 0.03477795f, 0.02784492f, 0.07871405f, 0.13084587f, 
    -0.14488414f, 0.03191455f, -0.06566299f, 0.00828807f, 0.11270735f, 0.09897710f, 0.07776131f, -0.01525258f, 
    -0.03752746f, 0.02774313f, 0.21213640f, -0.22330821f, 0.16432080f, 0.10573443f, -0.03747405f, -0.08454600f, 
    -0.11188676f, -0.03055291f, -0.03267647f, -0.09703038f, -0.08811611f, -0.00388191f, 0.03569054f, -0.09326879f, 
    0.09940740f, 0.11859507f, -0.00216489f, -0.22076058f, 0.04524483f, -0.00306766f, -0.11346856f, -0.02327301f, 
    0.05603708f, -0.16735663f, -0.05196715f, -0.04950475f, -0.02518307f, 0.00929660f, 0.10702948f, -0.22308864f, 
    0.12309680f, -0.04408788f, -0.03938496f, 0.04681096f, 0.03061908f, 0.12090507f, -0.02668384f, 0.11936165f, 
    0.04580592f, -0.11089089f, -0.24793929f, 0.10990480f, 0.01907045f, -0.13067710f, -0.04613424f, -0.12748398f, 
    0.03602581f, 0.04757393f, -0.09624509f, 0.12126247f, -0.04640317f, -0.08220987f, 0.21141075f, 0.11675147f, 
    -0.09334174f, 0.01497273f, 0.05856377f, 0.06818487f, 0.10732805f, -0.03799689f, 0.09402544f, 0.00560491f, 
    -0.56499207f, -0.22918642f, -0.13289957f, -0.17637385f, 0.18573344f, 0.06965148f, 0.07914581f, -0.05412572f, 
    -0.02595118f, 0.04132112f, -0.02895468f, -0.00975453f, -0.03877723f, -0.01702799f, 0.18757457f, -0.08016343f, 
    0.06128220f, 0.09403528f, 0.03271026f, -0.08413690f, 0.11006008f, -0.12726428f, -0.01625277f, 0.09154076f, 
    -0.07282955f, 0.04956004f, 0.09801314f, 0.09185500f, 0.03088098f, -0.17923857f, 0.08409975f, 0.00618441f, 
    0.04874369f, 0.14832848f, 0.05247227f, 0.14459331f, 0.04940066f, -0.19635379f, -0.17613551f, 0.05526266f, 
    -0.06728598f, -0.10393078f, -0.13285252f, -0.04771522f, 0.15568499f, -0.01123418f, 0.01745473f, -0.01021152f, 
    -0.02666876f, 0.08075824f, 0.11045139f, -0.15138106f, -0.01025665f, 0.04707636f, 0.02715793f, -0.08124615f, 
    0.02156487f, -0.10278854f, -0.08468940f, 0.10808111f, 0.10123928f, 0.02748945f, 0.04519364f, -0.14669220f, 
    0.06703237f, -0.05477766f, -0.02141928f, 0.19085218f, -0.09408388f, -0.04498043f, -0.00461490f, -0.06652356f, 
    0.17459151f, 0.02836607f, 0.02297958f, -0.25263032f, 0.10236734f, -0.03701280f, 0.09368717f, 0.02808771f, 
    0.07224102f, 0.08990627f, 0.02366021f, -0.00391156f, -0.01139097f, 0.03235259f, 0.12301680f, 0.01347788f, 
    0.06185067f, 0.09513691f, 0.07365403f, -0.03653853f, -0.11625679f, -0.16405928f, -0.03109282f, 0.09101101f, 
    0.04312233f, -0.32516885f, -0.13293229f, 0.11699753f, -0.11032277f, 0.01224921f, 0.13493617f, 0.01413564f, 
    -0.10701303f, 0.02736262f, -0.05354040f, 0.02092461f, 0.20459186f, -0.21965404f, -0.07399794f, 0.02635694f, 
    -0.04124780f, 0.00923019f, 0.01344983f, 0.02239085f, 0.13119665f, -0.08078518f, -0.11428875f, 0.11308694f, 
    0.24128282f, 0.06662837f, -0.07713044f, -0.10371874f, -0.06908502f, 0.06781962f, 0.08009320f, 0.07066279f, 
    0.05557840f, -0.01016883f, -0.16439690f, -0.02900367f, -0.32840747f, 0.12413644f, 0.11249582f, 0.01290724f, 
    -0.09838384f, 0.03949512f, -0.04653235f, -0.11392698f, -0.09429891f, 0.05990040f, -0.02585061f, -0.24058419f, 
    -0.10209921f, 0.10601383f, -0.20807950f, -0.13503675f, 0.02685914f, -0.01669713f, -0.10073279f, -0.14880505f, 
    0.09678663f, -0.03029866f, 0.10024244f, -0.05119947f, -0.21424858f, 0.02552224f, -0.14181603f, -0.12703800f, 
    0.05516515f, 0.00523794f, 0.00456709f, -0.16558112f, -0.04247818f, -0.04196553f, 0.08387534f, -0.09646359f, 
    -0.30039421f, -0.12546010f, -0.00847581f, 0.09705856f, 0.04487560f, 0.01192815f, 0.10059743f, 0.04685520f, 
    0.06178914f, -0.05377854f, -0.00513446f, 0.07240913f, 0.14096795f, -0.16466138f, -0.15683493f, 0.06135480f, 
    -0.16485882f, 0.02842789f, -0.04034062f, -0.04034998f, 0.06228974f, 0.07693990f, 0.00931392f, 0.09331389f, 
    -0.39949188f, 0.24119383f, -0.01872060f, 0.15326664f, -0.20529509f, 0.01620981f, 0.01395990f, 0.03040945f, 
    0.00671750f, 0.13316004f, 0.11979969f, 0.11514489f, 0.10261279f, -0.23532440f, -0.00240218f, 0.00511216f, 
    0.05769457f, -0.02061138f, 0.02320470f, -0.08058736f, 0.02353671f, -0.04535241f, 0.10868043f, 0.14604148f, 
    0.22636792f, -0.29731008f, -0.07345841f, 0.09050982f, -0.01888906f, 0.06767544f, -0.00014495f, 0.03402670f, 
    -0.05255156f, -0.00339041f, 0.02857815f, 0.01714793f, 0.08344790f, 0.05509174f, -0.07617782f, -0.24062452f, 
    -0.00981722f, -0.06560079f, -0.01972738f, 0.06414779f, -0.03732570f, 0.01614750f, 0.20177664f, 0.01219643f, 
    -0.20647563f, 0.06760124f, 0.07192924f, 0.05538381f, 0.15342382f, -0.04347921f, 0.02647988f, 0.08660886f, 
    0.00413046f, 0.01119620f, -0.14120206f, 0.03126987f, -0.06463127f, -0.06390432f, -0.03142714f, 0.00773869f, 
    0.09653004f, -0.05891206f, -0.03862480f, -0.04917017f, -0.07308787f, -0.01685514f, -0.00492415f, 0.06828817f, 
    0.15764211f, 0.01228998f, -0.03145693f, 0.09003346f, -0.01871177f, -0.04467175f, -0.14927381f, -0.10300335f, 
    -0.25882819f, 0.02414224f, -0.00604720f, 0.02044149f, -0.11788099f, 0.01399640f, 0.02290577f, 0.02705405f, 
    -0.01705295f, -0.07919588f, -0.03131718f, -0.03376972f, -0.00590054f, 0.02763075f, 0.00138501f, 0.13835303f, 
    0.03571731f, -0.16843368f, 0.17052329f, -0.11173429f, -0.02421304f, -0.00125346f, 0.11058438f, 0.04270802f, 
    -0.01095763f, -0.01574236f, -0.02098715f, 0.10536351f, -0.17951860f, 0.17809613f, 0.01570744f, -0.15427698f, 
    -0.03716601f, 0.08339287f, -0.06553177f, 0.08372223f, -0.03215398f, 0.08276068f, 0.08993887f, 0.04482392f, 
    0.04396074f, 0.07432121f, -0.15649013f, -0.08913371f, 0.04820597f, 0.02226212f, 0.05807683f, 0.05277417f, 
    -0.08487246f, 0.03553360f, 0.10615949f, -0.06941200f, 0.06185543f, -0.23868248f, -0.26711902f, 0.17931673f, 
    -0.04758019f, 0.05219425f, -0.05926357f, -0.07280873f, -0.04239780f, -0.08276993f, -0.09818266f, -0.12029040f, 
    0.09789974f, 0.10064982f, 0.11617173f, -0.28058201f, 0.05375467f, 0.01424718f, -0.02605015f, 0.02189071f, 
    0.02976446f, -0.08198429f, -0.10881202f, -0.01696413f, -0.14724055f, 0.07201196f, -0.11986513f, -0.15707017f, 
    -0.02783714f, -0.00299978f, -0.00625351f, -0.08024445f, 0.02073280f, -0.03736342f, -0.13685019f, -0.04074603f, 
    0.25429255f, 0.12467802f, -0.05686569f, 0.37242731f, 0.03108012f, 0.04269785f, -0.10008852f, 0.09510528f, 
    -0.07761223f, 0.12725437f, -0.08238709f, 0.05652154f, 0.28002021f, -0.13971327f, -0.11278541f, 0.12059002f, 
    0.01825972f, 0.02656065f, -0.00825582f, 0.07642674f, -0.03627830f, 0.00852927f, -0.00499611f, 0.11814341f, 
    -0.06311929f, 0.25655496f, 0.07960602f, 0.00990258f, -0.00334647f, -0.14469868f, 0.03237768f, 0.05529737f, 
    0.11103048f, -0.12136701f, -0.15940580f, -0.23689501f, 0.48903850f, -0.22918905f, 0.10062493f, -0.02001932f, 
    0.10019512f, 0.06324780f, 0.14207992f, -0.03703381f, 0.04311953f, -0.01531043f, 0.16843216f, 0.09756150f, 
    0.23582003f, 0.03744311f, 0.08882333f, -0.10291249f, -0.03030266f, 0.07995902f, 0.03611461f, 0.02297953f, 
    0.05507286f, 0.09513582f, 0.00843782f, -0.03961188f, -0.18880957f, -0.16880170f, -0.16320480f, -0.07897558f, 
    0.09120988f, 0.07494323f, 0.06936480f, -0.02076040f, 0.01650012f, -0.05633002f, -0.02730622f, 0.19609568f, 
    -0.14594412f, 0.19859979f, 0.07689313f, -0.12596625f, -0.02677735f, -0.05663082f, 0.06548942f, 0.03535400f, 
    0.03494037f, 0.04100589f, -0.09473902f, 0.01828825f, -0.16416787f, -0.09479874f, -0.19679634f, -0.01144127f, 
    -0.01144735f, -0.07680211f, 0.02492958f, -0.06745822f, 0.00214985f, -0.05306163f, 0.01669706f, 0.16649318f, 
    -0.45417482f, -0.12083101f, 0.01752134f, 0.01948484f, -0.06445146f, 0.11941426f, 0.05405303f, 0.10095870f, 
    0.06322537f, 0.10238312f, 0.02608570f, 0.18509533f, 0.18656985f, -0.07751764f, 0.08657466f, -0.15114006f, 
    -0.09363426f, 0.06059019f, -0.11825778f, -0.08342661f, -0.19325219f, 0.15560399f, 0.05958051f, 0.11667133f, 
    0.11451050f, 0.00939604f, -0.21345294f, 0.24207550f, -0.13606216f, -0.01824822f, 0.01079922f, -0.04564568f, 
    -0.06193113f, -0.00334225f, -0.07027761f, -0.03937187f, 0.12985782f, -0.13070557f, 0.07032806f, -0.17686968f, 
    -0.01924905f, 0.02862393f, 0.05411970f, 0.02606703f, 0.08205436f, 0.00002105f, 0.03878236f, -0.07487252f, 
    0.26583666f, -0.10556447f, 0.07060450f, -0.23528372f, 0.06136676f, -0.00972804f, 0.04421142f, 0.06391669f, 
    -0.06597400f, 0.04488440f, 0.03823635f, -0.02698428f, 0.06554692f, 0.12115739f, 0.07952245f, 0.04893523f, 
    -0.02749022f, 0.03842299f, -0.10942373f, -0.02114664f, 0.05979320f, -0.12083920f, 0.03434075f, -0.05660518f, 
    -0.02781349f, -0.02305782f, -0.29318362f, -0.04887941f, -0.09042556f, -0.12094753f, -0.00252629f, -0.04840071f, 
    0.00467538f, 0.03994979f, -0.12483519f, -0.11899824f, -0.13210888f, -0.04668860f, -0.12458112f, 0.27052203f, 
    0.15191381f, 0.05296079f, 0.06242393f, -0.05553947f, 0.10508360f, -0.01844878f, 0.01608213f, -0.09542563f, 
    -0.10350938f, -0.04514821f, -0.09223546f, -0.08555844f, 0.07599737f, 0.02671880f, 0.04220203f, -0.07563163f, 
    -0.04972085f, -0.04981193f, -0.09521304f, 0.11100436f, -0.16780388f, 0.13815004f, 0.09039725f, 0.20506977f, 
    0.06850991f, -0.10531400f, 0.06194993f, -0.01510110f, 0.01785330f, -0.17882338f, 0.02364463f, -0.12648080f, 
    -0.35372370f, -0.21901217f, 0.02139669f, 0.02579451f, 0.07896730f, -0.09695813f, 0.02518001f, -0.03762912f, 
    -0.03275388f, -0.08694544f, 0.08340318f, -0.01422811f, 0.04769255f, -0.08854266f, 0.15601863f, 0.13645840f, 
    -0.05826059f, -0.07322057f, 0.04288824f, -0.15973677f, 0.12173321f, -0.05028417f, -0.10960831f, -0.04247534f, 
    -0.12433305f, -0.02142439f, -0.20580618f, 0.12195621f, 0.08274195f, 0.08908285f, -0.16575491f, 0.01512756f, 
    0.05521530f, 0.04769061f, 0.06447899f, -0.05084513f, 0.11275466f, 0.08227625f, -0.08533172f, 0.00930600f, 
    -0.05011754f, 0.04079688f, 0.04276730f, -0.03105959f, -0.00963255f, -0.10986929f, -0.13063282f, -0.03426448f, 
    0.02414180f, -0.10403529f, -0.05204453f, 0.06963311f, -0.02173476f, 0.03086845f, 0.04782755f, -0.08085532f, 
    -0.15079534f, 0.04889251f, 0.07699142f, -0.19708881f, -0.12950259f, 0.02692696f, -0.03266538f, -0.15369712f, 
    0.06727672f, 0.10744824f, 0.06386073f, -0.07768270f, 0.05817081f, -0.23389937f, -0.00325367f, -0.04714894f, 
    -0.09888241f, 0.01832848f, 0.16581908f, -0.16827571f, 0.11428685f, 0.01466439f, -0.00315404f, 0.05894291f, 
    0.04191745f, 0.06382118f, 0.06903948f, 0.07124877f, -0.10451030f, 0.02872138f, 0.23659630f, 0.07069980f, 
    -0.10577177f, 0.06933314f, 0.03999496f, 0.07042630f, 0.01658312f, -0.04049717f, -0.04226075f, 0.05918159f, 
    0.12315136f, -0.16590223f, -0.23172988f, 0.07240838f, -0.09213340f, -0.07700378f, -0.07709677f, -0.07029468f, 
    -0.07184300f, 0.22615036f, -0.09493278f, 0.00278344f, 0.13517174f, 0.30332261f, -0.00529696f, -0.11140665f, 
    -0.05225908f, 0.11584496f, 0.04892085f, 0.12664154f, -0.16815157f, -0.00265996f, -0.07419465f, -0.10894545f, 
    -0.12078697f, 0.10051163f, 0.07409653f, -0.23410353f, -0.13470225f, 0.06130910f, -0.00021672f, -0.08026717f, 
    0.03519047f, 0.03062830f, -0.08911102f, 0.14296505f, -0.51760191f, 0.14571548f, 0.09727648f, 0.18264405f, 
    0.10550977f, 0.08911227f, 0.03589816f, 0.01671251f, -0.02053330f, 0.00190204f, -0.02376859f, -0.00927833f, 
    -0.15790737f, -0.18046589f, 0.01194590f, -0.21261281f, -0.05525736f, -0.03379038f, 0.04920376f, 0.10784528f, 
    -0.02138587f, 0.12968989f, 0.05906484f, 0.07795532f, 0.20706272f, 0.18498054f, 0.09030627f, -0.35946420f, 
    -0.19775231f, -0.04449604f, -0.04231412f, 0.02392312f, 0.06106372f, -0.08829497f, 0.02420330f, -0.05812160f, 
    -0.21902023f, -0.13713932f, -0.17939742f, 0.11126807f, 0.04561768f, 0.00926849f, -0.05985426f, -0.05412928f, 
    0.02742121f, -0.00837084f, 0.10333774f, -0.00595702f, 0.10075437f, 0.05912965f, -0.01308507f, 0.13052531f, 
    0.03952441f, 0.12512276f, -0.03408182f, -0.03890791f, -0.03388847f, -0.02055822f, -0.06757249f, -0.08185366f, 
    -0.45971361f, -0.13167596f, 0.03391446f, -0.26899397f, -0.06325877f, 0.00919108f, 0.06167530f, -0.09455861f, 
    -0.00013661f, -0.07018497f, 0.06088378f, 0.08280964f, 0.00735467f, 0.01334180f, 0.10237918f, -0.29868165f, 
    -0.08633959f, 0.01064386f, 0.05097202f, 0.13440450f, 0.00779065f, 0.04513336f, -0.00424536f, -0.06620792f, 
    0.06786970f, -0.12778221f, 0.03337330f, -0.06882006f, 0.05291763f, 0.11922164f, -0.03057023f, -0.02959047f, 
    0.11298285f, -0.15416591f, 0.02889360f, -0.08710666f, -0.26139328f, -0.03174199f, -0.14776237f, 0.15243511f, 
    0.07086676f, 0.01112481f, 0.12609549f, 0.00435657f, -0.03569536f, -0.02980364f, -0.04030295f, -0.19487479f, 
    -0.22663611f, 0.11702134f, 0.17264749f, -0.11019436f, 0.00027226f, -0.05969021f, 0.07093544f, 0.09697466f, 
    0.01030259f, 0.00788341f, 0.09571148f, -0.00539868f, 0.18021722f, 0.12200272f, 0.08581799f, -0.01831917f, 
    -0.04660401f, -0.05185746f, -0.06125545f, -0.05464142f, 0.05165499f, 0.01683920f, -0.01494301f, 0.13743079f, 
    0.23864363f, -0.25044808f, 0.13151222f, 0.01182578f, -0.10287465f, -0.06559852f, 0.02157662f, -0.09024546f, 
    0.04717619f, 0.02651226f, -0.01340083f, -0.02334366f, 0.00449148f, -0.13841501f, -0.03721378f, -0.10005930f, 
    0.04159498f, -0.02747896f, -0.05286027f, -0.02661451f, -0.00456008f, 0.04494950f, -0.01608264f, 0.01294254f, 
    -0.18369704f, 0.08907294f, -0.01151835f, -0.00726809f, 0.02853780f, -0.06357751f, -0.00648305f, -0.05521175f, 
    0.03880028f, 0.04391118f, 0.02950159f, -0.00538182f, 0.05718740f, -0.07094913f, 0.11826342f, 0.20822507f, 
    -0.04706974f, -0.04407389f, 0.00238096f, -0.05035589f, -0.03217467f, -0.03531523f, -0.05141428f, -0.01951255f, 
    0.18107335f, -0.09105019f, 0.03833491f, -0.14078224f, -0.01860008f, -0.02626114f, 0.03229435f, -0.03645629f, 
    0.01809852f, 0.00594962f, 0.01240167f, -0.08071563f, 0.02900212f, 0.08326074f, -0.05977339f, -0.00510018f, 
    0.00822258f, 0.00420665f, -0.00065734f, -0.04884014f, -0.04063369f, -0.01900169f, 0.03705296f, -0.01109926f, 
    0.14405461f, 0.17474546f, 0.15492785f, 0.08223134f, 0.04336305f, 0.06201952f, 0.05447938f, 0.00168495f, 
    -0.03048090f, 0.04720861f, -0.03210751f, -0.00813851f, 0.12333047f, 0.06971938f, 0.13619490f, 0.24942565f, 
    0.06344954f, 0.06330272f, -0.04549308f, 0.00700846f, -0.07178273f, -0.02107595f, -0.02953714f, -0.04004059f, 
    0.16468923f, -0.02044861f, 0.06740893f, 0.06795684f, 0.09940415f, -0.01104477f, -0.12257565f, -0.01691429f, 
    0.00518253f, 0.03516861f, -0.09567803f, -0.13239473f, -0.01958338f, 0.24107185f, 0.11364746f, 0.11848710f, 
    0.14270695f, 0.02168027f, 0.07073816f, 0.10272124f, 0.02580319f, 0.02918403f, 0.05169963f, 0.00503891f, 
    0.11375348f, -0.12335776f, -0.12640609f, -0.12795350f, 0.03145820f, -0.01701762f, -0.00723145f, -0.01138005f, 
    -0.07361772f, 0.02519301f, 0.02453549f, -0.02874224f, 0.15453021f, -0.16203003f, 0.13542232f, 0.04643791f, 
    0.15805374f, 0.03667144f, -0.00326696f, -0.01300531f, 0.06435530f, -0.05103546f, -0.00151452f, -0.01925233f, 
    -0.13604608f, 0.07716353f, 0.07711083f, -0.00615005f, 0.03931915f, 0.03505294f, -0.05430334f, -0.00223537f, 
    -0.02857833f, 0.01111073f, -0.01887300f, -0.02244782f, 0.03775444f, -0.17898025f, -0.01341647f, 0.00650530f, 
    -0.01674565f, -0.01936211f, -0.04305318f, 0.00815213f, -0.12249032f, -0.02135643f, 0.03096821f, -0.01659878f, 
    -0.05815269f, -0.28974977f, -0.07196391f, 0.06714845f, 0.01695622f, -0.04294111f, -0.00233292f, -0.02777823f, 
    -0.05697316f, 0.00328460f, -0.00966429f, -0.03623679f, 0.05115337f, -0.02690733f, 0.01053283f, 0.13919923f, 
    -0.07668963f, -0.01694126f, -0.05441671f, -0.09367077f, -0.08136203f, -0.03037496f, 0.00374847f, 0.00280145f, 
    0.10588492f, 0.07877345f, -0.08437184f, 0.04101793f, -0.02491923f, 0.03137052f, 0.01883051f, 0.00157540f, 
    -0.13055642f, -0.05528666f, 0.04326532f, 0.01027081f, 0.04131861f, -0.10755572f, 0.03268266f, -0.05201167f, 
    -0.00055422f, -0.03716066f, -0.02411398f, -0.03447321f, -0.03943766f, -0.00738272f, -0.08615404f, -0.00840316f, 
    -0.04301492f, 0.03146567f, 0.09652930f, 0.00401817f, -0.03148797f, -0.03257488f, -0.03630143f, -0.03596717f, 
    -0.04214596f, 0.05444913f, -0.08603730f, -0.00784677f, -0.38474983f, 0.04839770f, -0.09280966f, -0.01679955f, 
    0.00549562f, -0.00777022f, -0.10844707f, -0.05302768f, -0.12614012f, 0.00415846f, 0.00392428f, 0.00963215f, 
    -0.23397958f, 0.00636912f, -0.13007712f, 0.04806570f, 0.01840520f, -0.09135067f, -0.01512293f, 0.03160395f, 
    -0.03074043f, 0.05981544f, 0.08378386f, 0.04939446f, -0.10126108f, -0.00986192f, -0.03897244f, 0.06866969f, 
    -0.00033241f, -0.07727907f, -0.08939707f, 0.03120676f, 0.01220531f, -0.05439006f, -0.07063504f, -0.03190642f, 
    -0.02587044f, -0.36281618f, 0.13556668f, 0.08367033f, -0.04466738f, -0.06002644f, -0.00720148f, 0.03129415f, 
    -0.01702418f, 0.03225690f, -0.04487812f, -0.08737611f, 0.16904572f, 0.15542777f, 0.13591585f, 0.05550053f, 
    -0.01994307f, 0.03756373f, -0.00987554f, -0.03005977f, 0.04641318f, 0.02484019f, -0.01409764f, -0.00917662f, 
    -0.23196410f, 0.12589195f, 0.08178940f, 0.05742873f, -0.09413989f, -0.07010304f, 0.00784180f, -0.01197328f, 
    0.01627079f, 0.04715592f, -0.00245535f, 0.07524280f, 0.05764529f, 0.02336953f, 0.09067951f, 0.08526854f, 
    -0.10671595f, 0.03894395f, 0.00827197f, -0.07792126f, 0.05061510f, 0.02938578f, -0.03743954f, 0.00632526f, 
    -0.24546927f, -0.01263028f, 0.07199586f, -0.07466090f, -0.11319238f, -0.01336645f, 0.03823973f, -0.06369977f, 
    0.00567262f, -0.03418606f, -0.04294016f, 0.01300880f, 0.15137953f, -0.00687720f, 0.24943763f, -0.09396198f, 
    -0.01012766f, 0.01541942f, -0.01210880f, 0.04859097f, -0.04749941f, 0.07993408f, -0.00213103f, -0.03484347f, 
    0.25261340f, -0.16215067f, -0.01427793f, -0.18079944f, -0.08269579f, 0.02128514f, -0.04224294f, -0.10730450f, 
    -0.03635764f, 0.01453383f, 0.00306217f, -0.08358769f, 0.14042220f, 0.17879079f, 0.07069896f, 0.11515434f, 
    -0.08964004f, -0.00119758f, -0.01333722f, 0.00368042f, -0.07516939f, 0.00302783f, -0.10499778f, -0.06250177f, 
    -0.11190529f, 0.15134253f, -0.00280207f, -0.04531529f, -0.06572451f, -0.05818604f, 0.01532091f, -0.02697314f, 
    -0.04412585f, 0.01606541f, 0.04318067f, -0.04657394f, 0.11488109f, 0.12587185f, 0.16261744f, 0.16549721f, 
    0.04912986f, 0.03383595f, 0.06903559f, -0.04718488f, 0.07981537f, -0.03536255f, -0.06838835f, -0.07592012f, 
    0.27923885f, 0.10973144f, -0.11260297f, 0.06765005f, -0.01582211f, -0.04838322f, 0.00695889f, -0.02646590f, 
    -0.00679809f, -0.07275691f, -0.01445504f, -0.04755114f, -0.21089326f, 0.13743296f, 0.02940882f, 0.10850024f, 
    0.06744477f, 0.00282103f, 0.02878950f, -0.00543165f, -0.02176489f, 0.01015190f, 0.05990995f, 0.00409593f, 
    0.12642357f, 0.04175713f, -0.03035741f, 0.08745745f, 0.04202639f, -0.07942747f, 0.06060016f, -0.02018857f, 
    0.02414239f, 0.02148390f, -0.00923277f, 0.01215013f, 0.07755030f, -0.09935836f, 0.05955352f, 0.07730091f, 
    0.03713204f, -0.02078926f, -0.02949176f, -0.10217986f, -0.03294144f, 0.03254833f, -0.01766889f, -0.04767223f, 
    -0.02161753f, -0.00046759f, -0.23771374f, -0.01898860f, -0.05891221f, -0.02900600f, 0.01740338f, -0.09245256f, 
    -0.07077489f, -0.05232723f, -0.04548338f, -0.07602563f, 0.01377877f, -0.09601535f, 0.01870311f, 0.09737594f, 
    -0.08557326f, 0.00525228f, -0.02434099f, 0.01628117f, -0.00524966f, -0.09602863f, 0.01579442f, -0.05241549f, 
    0.08243239f, 0.20792522f, 0.11252411f, 0.27825803f, 0.15285185f, 0.07081543f, 0.05129497f, -0.01252844f, 
    -0.06186166f, -0.01987923f, -0.03200179f, -0.06471649f, 0.02749413f, 0.15541168f, -0.03874281f, 0.01196331f, 
    0.02859354f, 0.00505847f, -0.08136909f, 0.00355363f, 0.01040180f, 0.07375838f, -0.06125862f, -0.09382740f, 
    0.01451478f, -0.16441698f, 0.19280729f, 0.10956654f, 0.05629129f, -0.02471088f, -0.06072751f, -0.03128358f, 
    -0.03056224f, -0.00064962f, -0.04993217f, -0.09361982f, 0.18428135f, -0.16452637f, 0.00236852f, -0.00914858f, 
    0.03896013f, 0.04053372f, -0.00771691f, -0.02146872f, -0.00112540f, -0.10262731f, -0.04007510f, -0.07309766f, 
    -0.08220541f, -0.07644055f, 0.01961643f, -0.01393942f, -0.00424676f, -0.05394671f, -0.04344238f, -0.01393035f, 
    -0.00544478f, -0.08056410f, 0.02066078f, -0.04731752f, -0.10400683f, -0.03796647f, -0.05727510f, -0.13793735f, 
    -0.05639096f, -0.09739430f, 0.00305601f, 0.04952810f, -0.06525332f, 0.00951396f, -0.00617291f, -0.00487571f, 
    -0.14461648f, 0.01851645f, 0.00396425f, 0.12361418f, -0.06285588f, -0.01986315f, -0.12532476f, -0.00178838f, 
    -0.02394994f, 0.05247488f, 0.04838925f, -0.00846446f, -0.02959236f, -0.06421904f, -0.02741932f, 0.06327595f, 
    -0.01392636f, -0.01391263f, -0.01919506f, -0.01133983f, -0.02072800f, 0.00331769f, -0.02252167f, -0.06529488f, 
    0.04085689f, -0.05544364f, 0.08535468f, -0.03906740f, 0.03450404f, 0.02509361f, -0.01682797f, -0.05456303f, 
    -0.01612634f, -0.03936039f, 0.00935548f, 0.01624446f, 0.09982608f, 0.08422101f, 0.04019015f, 0.05636556f, 
    -0.03278637f, -0.07425954f, 0.05417926f, -0.02593073f, -0.03907122f, -0.06382328f, -0.08438100f, -0.09176927f, 
    -0.01059426f, -0.15678126f, -0.13793576f, -0.15283808f, 0.03494826f, 0.01393313f, -0.05161831f, -0.05734536f, 
    -0.08382603f, -0.08495808f, -0.04120227f, -0.04039387f, -0.09169365f, 0.21538064f, 0.09394627f, -0.07168230f, 
    -0.08394723f, -0.02163780f, 0.01790990f, 0.01849831f, -0.05774847f, 0.00195480f, 0.00268255f, -0.05296292f, 
    0.07254705f, 0.03532000f, 0.04219244f, 0.13852744f, 0.04734135f, -0.07189175f, -0.04539417f, 0.00987492f, 
    -0.06958666f, 0.04168674f, 0.03046750f, -0.06397658f, 0.03052081f, 0.33346352f, -0.10232029f, -0.18185920f, 
    -0.01866647f, -0.04899503f, -0.04172505f, 0.04876919f, -0.08598983f, -0.01913431f, -0.04282643f, -0.14574452f, 
    0.06606309f, 0.14953814f, 0.12434920f, 0.13614962f, -0.00333396f, 0.10746555f, 0.01202454f, -0.00920662f, 
    -0.08966634f, 0.04223366f, -0.03404588f, -0.06588984f, -0.23962899f, 0.11553898f, -0.09196279f, -0.15758502f, 
    -0.03783792f, 0.05494222f, -0.07918032f, -0.08435927f, 0.08660794f, 0.00077418f, 0.06868470f, -0.06686591f, 
    -0.01584909f, 0.12684305f, -0.07439552f, -0.03216768f, -0.02027652f, 0.04519731f, 0.03708610f, -0.12086794f, 
    -0.13357216f, 0.09448913f, -0.01186365f, 0.01659234f, -0.25145650f, 0.02648593f, -0.16149543f, -0.18450309f, 
    -0.05810173f, 0.03314845f, -0.01400547f, -0.08397076f, -0.10254966f, -0.06461378f, 0.01261523f, -0.11030664f, 
    -0.11284740f, 0.12014496f, -0.04973137f, 0.01008816f, -0.00217473f, 0.02759824f, -0.04836723f, -0.00054180f, 
    0.05175851f, 0.00277746f, -0.05114025f, -0.04070633f, -0.18286283f, -0.05453464f, -0.21261448f, -0.05939635f, 
    0.02841396f, -0.13251232f, 0.00752587f, -0.05828973f, -0.11879146f, -0.00661911f, -0.04481830f, -0.03169378f, 
    -0.03035923f, 0.11113411f, 0.13849901f, 0.07770122f, 0.03117565f, 0.07371753f, 0.06892364f, -0.03284505f, 
    -0.01275007f, 0.01905998f, -0.01095875f, -0.03281363f, -0.33533967f, 0.12967983f, -0.05448763f, -0.10857178f, 
    -0.06151770f, -0.01502416f, -0.04832169f, -0.08585270f, -0.07566599f, -0.02837042f, -0.04211724f, -0.03308397f, 
    -0.13450798f, 0.09564387f, -0.04926135f, -0.04408594f, 0.01506168f, -0.01076743f, -0.01142882f, -0.06960442f, 
    -0.11801137f, -0.02803285f, -0.01901354f, -0.02079364f, 0.04306220f, 0.15111564f, -0.10442407f, 0.10525557f, 
    -0.03444239f, -0.01738543f, -0.02810591f, 0.03941479f, 0.01280500f, -0.01966374f, -0.01725072f, -0.11300118f, 
    -0.18853766f, 0.12244794f, 0.03005193f, 0.02965414f, 0.04451674f, 0.02518369f, -0.07385053f, -0.04185142f, 
    -0.00996020f, -0.03910295f, 0.01865492f, -0.03101072f, 0.13858198f, -0.01467273f, -0.13845195f, -0.27790660f, 
    -0.00931061f, 0.05067350f, -0.00028170f, -0.02159416f, -0.04427977f, -0.07845186f, 0.03878231f, -0.01592579f, 
    -0.03566555f, -0.30243924f, -0.20389774f, 0.01830245f, 0.07966439f, -0.00481859f, -0.00954679f, -0.02403318f, 
    0.01590406f, -0.01946922f, 0.06608655f, 0.01476687f, 0.14286789f, 0.00072849f, 0.03853922f, 0.10878884f, 
    0.04880094f, -0.06173761f, -0.02379777f, 0.01122478f, 0.03020222f, 0.07029985f, -0.01597404f, 0.04438465f, 
    0.17193106f, 0.03479034f, 0.06407581f, 0.04559099f, -0.08209039f, -0.10353553f, -0.02767691f, -0.02990462f, 
    0.03178200f, -0.10811105f, -0.06328893f, 0.03228304f, 0.11642628f, -0.05415970f, 0.06211179f, -0.14493707f, 
    -0.00090249f, -0.05905383f, -0.15872547f, 0.00881789f, -0.00595703f, -0.01259393f, 0.00212663f, -0.18790345f, 
    -0.15466991f, -0.05964398f, -0.06455869f, -0.08942932f, -0.04400679f, -0.05784974f, -0.02133323f, 0.01393975f, 
    0.04153118f, -0.04067855f, 0.01549543f, 0.12133424f, 0.06855661f, 0.04012828f, 0.01594050f, 0.04997255f, 
    0.05514470f, 0.04652341f, -0.10038152f, -0.00940297f, 0.06675973f, -0.00014769f, 0.06574865f, 0.07218733f, 
    -0.11392365f, 0.02166279f, 0.14681208f, -0.20626539f, 0.07928640f, 0.06151387f, -0.03007460f, 0.05415851f, 
    -0.05898404f, 0.03324768f, -0.04603926f, -0.01543082f, -0.03727494f, -0.08042035f, 0.12539694f, -0.17425270f, 
    -0.00004886f, 0.05386702f, 0.05460255f, 0.00839583f, -0.03913467f, 0.02356989f, -0.02765526f, 0.14257650f, 
    -0.04383044f, 0.07042883f, -0.02272032f, -0.10056280f, 0.07287688f, -0.05104839f, -0.11069322f, 0.07535145f, 
    -0.00671817f, 0.03120392f, 0.05502101f, 0.07540350f, 0.08536122f, -0.03748563f, 0.05070030f, 0.06515276f, 
    -0.10070912f, -0.04456151f, -0.06170124f, -0.01564320f, 0.03993319f, -0.21940662f, -0.17423534f, -0.00114819f, 
    0.07715381f, -0.13487630f, -0.04105317f, -0.07950980f, 0.07028789f, -0.07634694f, -0.07174757f, 0.02616951f, 
    0.02804809f, -0.01061076f, -0.05822106f, -0.02477625f, -0.00216940f, -0.21025622f, 0.06934018f, -0.08533736f, 
    0.00632560f, -0.02385650f, 0.10862048f, 0.02559390f, 0.04851874f, 0.01382884f, 0.11835475f, 0.04306141f, 
    -0.03407869f, -0.23941649f, 0.12139652f, 0.02958296f, -0.03283295f, -0.03511489f, 0.07732265f, -0.04727967f, 
    0.04509842f, -0.04735301f, 0.03056688f, 0.00964683f, -0.04957540f, -0.16486080f, -0.14784834f, 0.05087624f, 
    0.06360713f, -0.04541864f, -0.00596198f, -0.02062258f, 0.06082435f, -0.10208907f, 0.15215817f, -0.12658320f, 
    0.09084793f, -0.18006884f, -0.20782347f, -0.13347484f, 0.15012915f, 0.06860480f, -0.04464543f, 0.00142518f, 
    0.04408161f, 0.06807946f, 0.09184030f, 0.08589831f, -0.12233537f, -0.09615929f, -0.09516372f, -0.21799915f, 
    -0.03858516f, -0.07555618f, -0.02389324f, -0.04676186f, 0.09676629f, 0.02199879f, -0.06323935f, -0.19802940f, 
    0.02078507f, 0.11068116f, -0.02470324f, -0.05663019f, 0.03290947f, -0.05446059f, 0.15190126f, 0.07598069f, 
    0.11193606f, 0.00796393f, -0.00427976f, -0.03471603f, 0.07366975f, 0.09606896f, -0.09533219f, 0.11176781f, 
    0.01028232f, -0.02644028f, -0.04886685f, -0.17352934f, 0.00331577f, 0.00626528f, -0.02989164f, -0.20112653f, 
    -0.08137003f, 0.10235421f, 0.09858622f, 0.09365075f, -0.01527180f, 0.04049888f, -0.08960882f, 0.06159589f, 
    0.04429811f, -0.06052816f, -0.00254465f, -0.04693353f, -0.11551810f, -0.02961656f, 0.04239212f, 0.17434147f, 
    0.11614126f, 0.09330112f, 0.02669289f, 0.00679070f, -0.03994611f, -0.07031292f, 0.02226662f, -0.05588968f, 
    -0.08465037f, -0.20197517f, -0.23597409f, -0.14932568f, 0.01605887f, -0.00475796f, -0.02019460f, 0.04483197f, 
    0.04946012f, 0.01015180f, -0.03458717f, 0.05074044f, 0.19158626f, 0.29273522f, -0.21213157f, -0.16978192f, 
    -0.03514960f, -0.00382961f, -0.10379017f, -0.03321983f, 0.08401764f, 0.00696344f, 0.01068975f, 0.08150966f, 
    -0.13022010f, -0.09430671f, -0.21246475f, 0.05689148f, 0.03252465f, 0.02438403f, -0.02622529f, -0.01012952f, 
    0.07018093f, 0.04130734f, 0.15747106f, -0.02332158f, -0.06066730f, 0.09154176f, 0.13525914f, -0.08379307f, 
    -0.03292426f, -0.08637927f, -0.01617195f, -0.05004976f, 0.02956910f, -0.03566428f, 0.09442801f, 0.09206259f, 
    0.09171087f, 0.21786186f, -0.07893248f, -0.09754599f, 0.02015898f, -0.06753969f, -0.11370868f, -0.03617792f, 
    0.03524465f, -0.02436556f, 0.14673857f, -0.03518781f, -0.00932494f, 0.00797016f, -0.24325792f, -0.01394849f, 
    -0.03578123f, -0.15476584f, 0.02438093f, -0.05664928f, -0.01373894f, 0.02756085f, -0.10084145f, -0.02506493f, 
    0.08280123f, -0.07140807f, -0.09321819f, 0.18403707f, 0.09679899f, 0.04483694f, -0.07888924f, -0.14257252f, 
    -0.08104599f, 0.04505231f, 0.08488329f, 0.10111211f, -0.11295803f, -0.17892446f, 0.12540534f, -0.03828404f, 
    -0.04053463f, 0.03218871f, -0.06167514f, -0.01996334f, 0.04830014f, 0.01060334f, -0.13050230f, 0.02124089f, 
    -0.17012618f, -0.17864545f, 0.08582086f, -0.09092250f, 0.04149336f, -0.02794310f, -0.01629853f, 0.00241266f, 
    -0.01625533f, -0.00337282f, 0.01149428f, 0.11992129f, -0.20621413f, -0.07106479f, -0.10529579f, -0.20581524f, 
    -0.02706856f, 0.00843729f, -0.08654404f, 0.11248650f, 0.05772733f, -0.01800742f, 0.11786678f, -0.09976457f, 
    -0.01500996f, -0.30544850f, 0.04512974f, 0.22180067f, 0.06192354f, -0.01819355f, -0.03849947f, -0.07375190f, 
    -0.02509797f, 0.03888818f, 0.08360601f, -0.21715017f, -0.06414058f, 0.06848836f, 0.06243436f, 0.08712316f, 
    -0.01648690f, -0.05870102f, 0.04555133f, -0.02673456f, -0.05081716f, -0.05068133f, 0.08048143f, 0.02393828f, 
    0.00892159f, 0.15754950f, -0.04459915f, -0.02961393f, -0.13740017f, -0.02676163f, -0.10874566f, -0.06336899f, 
    -0.00367716f, 0.07567942f, -0.09755237f, -0.00712542f, -0.08452782f, -0.12402530f, 0.16596848f, 0.03727121f, 
    0.00077135f, 0.00304086f, 0.08586559f, -0.07942556f, 0.05821452f, 0.04925321f, 0.03796256f, -0.11029626f, 
    0.10877053f, 0.08757292f, -0.09717242f, 0.06078978f, -0.04764167f, -0.01553431f, 0.06640944f, -0.03212699f, 
    -0.08182710f, 0.03594466f, 0.06151605f, -0.07049892f, -0.00112015f, -0.24497819f, 0.11736938f, -0.04816967f, 
    -0.03583786f, -0.09306233f, -0.04663094f, 0.02056488f, -0.09859127f, -0.04794411f, 0.02593424f, -0.00915135f, 
    0.10331258f, -0.01266667f, 0.05076534f, 0.18461166f, 0.06122488f, -0.00179795f, -0.01978732f, -0.06304613f, 
    0.01108242f, 0.00457038f, 0.08013959f, -0.02748740f, -0.17837808f, 0.10002814f, -0.25044200f, -0.15018961f, 
    -0.03340783f, -0.07564038f, -0.11156738f, -0.02696058f, 0.02973261f, 0.03090283f, 0.04578773f, -0.06277122f, 
    -0.02877474f, -0.19287920f, 0.16877970f, -0.15026374f, -0.07043798f, -0.02649571f, -0.01262484f, -0.14258800f, 
    0.01390197f, 0.00134748f, 0.05756130f, 0.02329699f, -0.19902867f, 0.16351090f, -0.19368914f, -0.09210341f, 
    -0.03994569f, 0.06201483f, -0.18404505f, -0.00170498f, 0.09775024f, 0.04740307f, 0.07703990f, 0.04423119f, 
    -0.13475385f, 0.04228136f, 0.01669230f, -0.16895907f, -0.01544336f, -0.00049925f, -0.15471132f, 0.02139758f, 
    0.04998440f, -0.02226446f, 0.09370803f, 0.00572152f, 0.21262404f, 0.06687821f, -0.21835379f, 0.06634208f, 
    0.05003017f, 0.00748970f, -0.07851993f, 0.01069748f, -0.07890621f, 0.01449800f, 0.05630607f, 0.05249297f, 
    0.11841550f, 0.05990420f, 0.04550565f, 0.16154309f, -0.06840486f, -0.02247855f, 0.03692996f, -0.10650158f, 
    -0.03093479f, 0.01955215f, -0.17381664f, -0.05939415f, 0.08397090f, -0.20904642f, 0.02001769f, 0.06304897f, 
    -0.05630630f, -0.04225913f, -0.00877757f, -0.04734512f, -0.02698758f, 0.02706596f, 0.02703282f, -0.11184679f, 
    -0.08649039f, 0.06348921f, -0.18447079f, -0.10674494f, -0.00709875f, -0.03625909f, 0.06798699f, -0.03515299f, 
    0.07057417f, -0.06521840f, -0.03494857f, 0.04457962f, -0.14078625f, -0.15072431f, -0.05384327f, -0.26103446f, 
    -0.06653170f, -0.00351241f, -0.00676108f, -0.04654797f, -0.01865384f, 0.05274016f, 0.00514015f, 0.02408592f, 
    0.11189047f, 0.00037500f, -0.02291518f, 0.05211890f, 0.02531555f, -0.06752146f, -0.11180893f, 0.02231872f, 
    -0.04365202f, 0.00075205f, 0.03104439f, -0.01613051f, -0.12505303f, -0.03873304f, 0.04982371f, -0.15615357f, 
    -0.06630082f, -0.02172752f, -0.14663498f, 0.15909277f, -0.00142596f, 0.08881890f, 0.04628842f, 0.03829888f, 
    0.14995888f, -0.12590349f, 0.02633856f, -0.02184970f, 0.00050352f, -0.02123735f, -0.05399238f, 0.01898045f, 
    0.10806450f, 0.03094080f, -0.00997191f, -0.26282811f, 0.09724934f, -0.04596999f, -0.16419052f, -0.11087640f, 
    0.06153212f, -0.12560424f, -0.03600904f, -0.00300704f, 0.14299184f, 0.10117962f, 0.02395785f, -0.05655766f, 
    0.03002699f, 0.05059913f, -0.00318310f, -0.12308808f, 0.05493910f, 0.01665843f, -0.00951719f, 0.00386683f, 
    -0.04253919f, -0.04524055f, 0.01618462f, 0.01184068f, -0.14956605f, 0.08718532f, -0.13506471f, 0.03654439f, 
    0.01616805f, -0.12043076f, -0.08258650f, -0.08156284f, 0.10258546f, 0.00472112f, 0.04418889f, 0.09641008f, 
    -0.25301832f, -0.10881244f, 0.27378798f, -0.12497716f, -0.00171979f, -0.13387607f, -0.05487873f, -0.00122037f, 
    0.04570669f, 0.00182243f, 0.02643491f, -0.12849732f, 0.03498042f, 0.03563256f, -0.11144375f, -0.01138204f, 
    0.02847753f, -0.04917848f, -0.08876326f, 0.01444979f, -0.00460446f, 0.00121222f, -0.03942124f, -0.05671318f, 
    -0.03906425f, 0.07501556f, 0.10976237f, 0.08105231f, -0.12482661f, -0.00515984f, -0.03565468f, -0.02056238f, 
    -0.02381387f, -0.07608600f, 0.04749920f, -0.05423025f, -0.00958427f, 0.00073538f, 0.07246173f, 0.18731627f, 
    0.01706444f, -0.03349015f, -0.03264666f, 0.00612185f, 0.05003232f, 0.09766785f, 0.04550431f, -0.01415478f, 
    0.09065543f, 0.22335160f, -0.06860116f, 0.07885208f, 0.05857449f, 0.01100416f, -0.00725015f, -0.08200982f, 
    0.07768404f, -0.03148242f, -0.01292237f, -0.00162600f, 0.06124530f, 0.08514786f, 0.00359553f, 0.02547026f, 
    0.01096677f, 0.02898863f, 0.01931720f, -0.06205497f, 0.08961380f, 0.00781374f, 0.06214622f, 0.03991525f, 
    -0.21273156f, 0.00942589f, 0.17784418f, 0.03770325f, -0.03302466f, 0.05576511f, -0.02921980f, -0.03053382f, 
    -0.03412196f, 0.03192015f, 0.09400645f, -0.11776042f, 0.18848325f, -0.09498917f, 0.08442528f, 0.14080882f, 
    0.04417629f, -0.03830955f, -0.01418706f, -0.04291326f, -0.05766399f, -0.12443149f, 0.14571150f, -0.02754484f, 
    -0.07715189f, 0.03365124f, -0.11018339f, 0.01410970f, -0.04459575f, 0.09423577f, -0.12436175f, 0.03745929f, 
    0.06138295f, 0.00496067f, 0.06957135f, -0.03195540f, -0.04430596f, 0.28983328f, -0.05621324f, 0.08963818f, 
    -0.20218249f, 0.11311216f, -0.05948390f, 0.05555149f, 0.05464339f, -0.04971758f, 0.04307139f, 0.02750828f, 
    0.09622999f, 0.07979807f, -0.03635904f, 0.13217030f, 0.14204343f, -0.07258490f, -0.05883380f, -0.12587732f, 
    -0.10661183f, 0.03233988f, -0.03880906f, 0.01827015f, 0.06721097f, -0.10992453f, -0.04913311f, -0.02250121f, 
    0.03389480f, 0.02677632f, -0.03282574f, 0.06559997f, 0.09939978f, -0.03189664f, 0.07910204f, -0.15435444f, 
    0.00896096f, 0.05930431f, -0.04987321f, -0.04269707f, -0.10373740f, -0.14946789f, -0.09375280f, 0.17650460f, 
    -0.02096957f, 0.04550957f, -0.04517596f, 0.04445668f, 0.12620661f, -0.26401430f, 0.11381458f, 0.07985743f, 
    0.11377258f, -0.06788082f, -0.04705226f, -0.13265064f, -0.00723289f, -0.13995253f, -0.02964196f, -0.04082734f, 
    -0.00584834f, -0.24799600f, -0.02407250f, -0.08669046f, 0.05731821f, 0.09041965f, -0.04006702f, -0.05332456f, 
    -0.06730896f, -0.07255210f, 0.14127971f, -0.01946634f, 0.21732536f, -0.08916586f, -0.16963534f, -0.15331700f, 
    -0.00176869f, -0.02527626f, -0.00786571f, 0.06276024f, -0.08984247f, -0.08219106f, 0.07383637f, -0.02436505f, 
    -0.19025649f, 0.02536656f, -0.00197874f, -0.09679227f, -0.00400179f, 0.02710190f, 0.09047665f, -0.03437658f, 
    0.05929692f, 0.02786967f, 0.10545126f, -0.14616254f, -0.03661712f, 0.19686185f, -0.19616795f, -0.11242496f, 
    0.01465081f, 0.07812078f, -0.02142987f, 0.01754632f, -0.07741558f, -0.12163153f, -0.06694227f, -0.09964109f, 
    -0.02144334f, -0.25147402f, 0.02319897f, 0.12548232f, -0.03446642f, -0.00556677f, -0.03645210f, 0.08319198f, 
    -0.14625479f, 0.01969793f, -0.14459629f, -0.02359052f, 0.16090590f, -0.09712391f, -0.06673768f, 0.12541407f, 
    -0.03076481f, 0.01151357f, 0.00580202f, 0.03631908f, -0.01284566f, -0.01482564f, -0.01063150f, -0.05586268f, 
    0.05291245f, -0.21462232f, 0.10067669f, 0.04203861f, -0.05286027f, 0.04389806f, -0.05804321f, 0.13266893f, 
    -0.09938068f, 0.13326615f, -0.00719204f, -0.05557439f, -0.31124708f, -0.21453099f, 0.06616253f, -0.12600462f, 
    0.05416371f, 0.02020752f, 0.01503620f, 0.04978862f, 0.12332623f, 0.06580546f, 0.03246495f, 0.03547097f, 
    0.19175223f, 0.04710706f, 0.04302957f, -0.15696457f, -0.00865462f, 0.10125415f, -0.02757985f, -0.00051933f, 
    0.05231218f, 0.02325479f, 0.02042327f, 0.00528247f, 0.16853638f, -0.24046478f, 0.06832254f, 0.03254624f, 
    -0.09533580f, 0.02079700f, 0.02896195f, -0.08636237f, -0.09999660f, -0.03357809f, -0.07044380f, 0.04055758f, 
    -0.00235852f, -0.03066048f, 0.12781379f, 0.03635427f, 0.07303167f, -0.10591940f, -0.02352382f, -0.06494229f, 
    0.03016974f, -0.02181649f, 0.03852705f, 0.06415518f, -0.16948001f, 0.04000144f, -0.03270055f, -0.27065703f, 
    -0.10277636f, 0.10338770f, 0.00876684f, -0.02133995f, -0.02398884f, 0.03700610f, 0.03087316f, 0.09489510f, 
    0.20661640f, -0.09679308f, 0.25028855f, -0.24314469f, 0.05638389f, 0.09559451f, -0.09718536f, -0.07411364f, 
    -0.08590708f, 0.01990114f, -0.04461486f, -0.14027290f, -0.04895873f, -0.07548649f, 0.02413213f, 0.01329325f, 
    -0.15366597f, 0.01282557f, -0.02100273f, -0.01803860f, 0.00486419f, 0.04325103f, 0.02873614f, 0.14270978f, 
    -0.02888079f, -0.14829352f, 0.06164855f, -0.06590627f, 0.12460279f, -0.00398785f, -0.00510870f, -0.03313213f, 
    0.00972904f, -0.05400572f, 0.07309874f, 0.14130624f, 0.47367015f, -0.25043029f, -0.01690796f, -0.01676765f, 
    -0.05240235f, 0.05778593f, -0.05288488f, 0.10123710f, 0.04678767f, 0.10985696f, 0.00005732f, 0.02508062f, 
    -0.32798350f, 0.27826878f, -0.06957345f, 0.12639852f, 0.09599434f, -0.04717961f, 0.00039308f, -0.07044743f, 
    0.08507750f, 0.06088291f, -0.04139267f, 0.07941590f, -0.22323640f, 0.12861621f, -0.03807856f, -0.32786268f, 
    -0.01892675f, 0.09585161f, -0.02379160f, -0.09736120f, -0.03180564f, -0.13722169f, -0.02991212f, -0.03981597f, 
    -0.00545864f, 0.10689475f, 0.11620495f, -0.28786156f, 0.03726516f, 0.11412521f, -0.16816266f, -0.02621088f, 
    -0.07455619f, 0.03046366f, 0.08026475f, -0.11389747f, 0.15709217f, 0.17746665f, 0.13546269f, -0.00739868f, 
    0.05950418f, 0.11057748f, -0.00245450f, 0.09715165f, 0.08473632f, -0.05243273f, 0.05839481f, -0.01264482f, 
    0.01044589f, -0.05487339f, -0.09905335f, -0.48045689f, -0.02420136f, -0.00650998f, -0.07055471f, 0.07032727f, 
    0.03292957f, -0.01310460f, -0.02855470f, -0.08337831f, -0.29663774f, -0.30927360f, 0.01371556f, 0.03812231f, 
    0.05455449f, 0.03206493f, -0.00128334f, -0.14415474f, -0.03605737f, 0.01020944f, -0.22084258f, -0.12306032f, 
    -0.19122200f, 0.06623495f, 0.46040726f, -0.09598834f, 0.05757234f, 0.02204791f, 0.04285093f, -0.17895500f, 
    0.00645763f, 0.00477588f, 0.05864763f, 0.04536467f, -0.11859746f, 0.05021103f, -0.25915349f, 0.14703740f, 
    0.00821564f, -0.00142081f, -0.17059290f, 0.01160472f, 0.04638729f, 0.06734971f, 0.11318453f, -0.18118523f, 
    -0.20964003f, 0.01503920f, 0.10482842f, 0.07005408f, 0.08181337f, -0.00779722f, -0.04739955f, 0.04528685f, 
    0.14659315f, 0.14895725f, -0.11332429f, -0.00742983f, -0.03579102f, -0.14124006f, -0.07117756f, 0.24154629f, 
    -0.05867154f, 0.03365612f, -0.05882307f, -0.02937875f, -0.00818344f, -0.02075986f, -0.00000409f, -0.01337328f, 
    0.06421033f, -0.11344837f, 0.03885991f, 0.17556688f, 0.09372718f, -0.07965560f, 0.02352483f, 0.04146496f, 
    0.05967349f, 0.06163556f, -0.05253046f, 0.06410857f, -0.05890053f, 0.06026346f, -0.06754389f, 0.09365661f, 
    0.06684939f, 0.02736351f, -0.01037982f, -0.07181823f, -0.05919488f, 0.04640337f, -0.14383121f, 0.03366342f, 
    -0.26958907f, 0.01187052f, -0.02511165f, -0.10483918f, 0.15985510f, 0.02863038f, 0.02297379f, -0.02784276f, 
    0.01971383f, -0.04101061f, -0.08082771f, -0.00439970f, -0.20513394f, -0.22546929f, 0.10862701f, -0.13271464f, 
    0.07242627f, 0.08775943f, -0.08656064f, 0.04403112f, -0.02204880f, -0.03262143f, 0.05245101f, -0.04781520f, 
    0.00097884f, 0.34687674f, -0.14675401f, 0.08779529f, -0.18362968f, 0.04013329f, -0.00656162f, 0.08795727f, 
    0.11560231f, 0.08174224f, 0.18638726f, 0.05406606f, -0.38916710f, -0.15955985f, -0.01415635f, 0.10763571f, 
    0.05590855f, -0.08361168f, -0.00668613f, 0.00399796f, 0.14475124f, -0.05360790f, 0.10351206f, 0.06714496f, 
    0.08305612f, -0.14051756f, 0.29222399f, -0.03251066f, 0.04647813f, 0.03664019f, 0.00245115f, 0.03201980f, 
    0.00352597f, -0.04796624f, -0.02926511f, 0.02920728f, 0.13611004f, 0.10034425f, -0.04378317f, 0.18331765f, 
    -0.08584494f, -0.11219896f, -0.00818902f, 0.00292090f, 0.06209602f, 0.14800604f, -0.00327997f, 0.03433124f, 
    -0.25459135f, 0.18388438f, -0.31797975f, -0.19395937f, 0.05930919f, -0.06245545f, 0.12802219f, -0.13365380f, 
    -0.10838932f, -0.08209883f, -0.09389825f, 0.05904172f, -0.00554103f, -0.11615010f, -0.31119260f, 0.23054293f, 
    -0.05973729f, 0.08219156f, -0.01801647f, -0.12728125f, -0.13674808f, -0.00179689f, 0.07799970f, -0.00589863f, 
    -0.15610996f, -0.22983193f, -0.05194557f, -0.10642421f, 0.12528685f, 0.02653985f, -0.00960457f, 0.13831078f, 
    -0.15946309f, -0.01493615f, -0.06573882f, 0.01098919f, -0.17692807f, 0.08212510f, 0.26785955f, -0.05318169f, 
    -0.00807945f, 0.05873046f, -0.02538090f, 0.05578225f, -0.04955842f, 0.08437002f, -0.11321139f, 0.08711816f, 
    0.04487257f, -0.47281086f, 0.09265376f, -0.02236490f, -0.18783540f, -0.02897686f, 0.09382077f, 0.07349692f, 
    -0.03613167f, 0.14067248f, 0.17555468f, -0.03524398f, 0.24764940f, -0.26312545f, 0.23170818f, -0.11952566f, 
    0.17428122f, -0.00208762f, -0.04633541f, -0.10954610f, -0.08199070f, 0.13257100f, 0.04109601f, 0.03806481f, 
    0.21561764f, -0.29436466f, -0.22260706f, -0.01548561f, 0.03441407f, -0.04774008f, -0.03529371f, 0.17531464f, 
    0.00544865f, -0.07329530f, 0.16808198f, -0.10966308f, -0.09623901f, 0.08787248f, -0.02558423f, 0.31415552f, 
    0.02590335f, 0.13948768f, -0.11489717f, 0.09767820f, -0.08964650f, 0.11209326f, 0.09690966f, -0.01377885f, 
    -0.05068459f, 0.07452516f, 0.11798243f, 0.07686564f, 0.00286487f, 0.08502132f, 0.00049999f, -0.09203372f, 
    0.04592391f, -0.17137535f, 0.09226212f, 0.03839038f, -0.12999365f, 0.10446085f, 0.08100142f, -0.13334975f, 
    -0.01750583f, -0.04256115f, -0.00272650f, 0.04092899f, 0.04097661f, 0.13178958f, -0.17935604f, -0.10186721f, 
    0.06923515f, 0.06044023f, 0.00989221f, 0.10653787f, -0.00179548f, 0.01885373f, 0.03549113f, -0.00899523f, 
    -0.05542004f, -0.00372732f, 0.04616604f, 0.04814320f, 0.13242233f, -0.17866364f, -0.14679453f, 0.04563287f, 
    -0.09216537f, -0.05941061f, 0.07633629f, -0.16361067f, 0.10071073f, 0.00507102f, -0.08495180f, -0.03005875f, 
    0.06154227f, -0.11303934f, -0.04911882f, 0.16391334f, -0.02891720f, 0.03593982f, -0.11696773f, -0.04262636f, 
    -0.03119507f, 0.05621339f, -0.02865963f, 0.01886891f, -0.46982169f, 0.20152842f, -0.01669767f, -0.11428660f, 
    0.07290722f, 0.04320724f, 0.12165181f, 0.04994576f, -0.01483701f, -0.05853105f, 0.09589034f, 0.03533605f, 
    -0.11591862f, -0.14165343f, -0.12802024f, 0.09749473f, 0.02073425f, 0.07978164f, -0.04139595f, -0.00341872f, 
    0.04926467f, 0.01948023f, 0.14467610f, 0.09698233f, -0.49726480f, 0.07504773f, 0.04575613f, -0.08054703f, 
    0.03034849f, -0.09834130f, 0.02046590f, -0.10691997f, -0.11425001f, 0.00499582f, 0.02752484f, 0.09248003f, 
    -0.03299088f, -0.09731027f, 0.11706150f, 0.01559554f, 0.07635032f, 0.00111322f, -0.10995571f, -0.04933094f, 
    0.00422385f, -0.06904375f, -0.10531275f, 0.10990673f, -0.12390453f, 0.19123991f, 0.27851814f, -0.10203436f, 
    0.12417962f, 0.02845173f, 0.06542525f, -0.06716983f, 0.08130170f, 0.09204096f, 0.01995369f, 0.02083970f, 
    0.04064513f, 0.24983327f, -0.10582785f, 0.02980620f, 0.01445736f, 0.05762634f, 0.04691051f, 0.01092544f, 
    -0.04208925f, 0.05892381f, 0.14643894f, -0.00959902f, -0.15245132f, 0.19964807f, -0.11052625f, -0.19400924f, 
    0.10512712f, 0.05001174f, 0.07796732f, -0.02613683f, -0.03227984f, -0.05864063f, -0.08872942f, -0.15045308f, 
    -0.06395229f, 0.14980024f, 0.20041047f, 0.11881057f, 0.00015528f, 0.08263401f, -0.01099984f, 0.13639410f, 
    0.03102119f, 0.01106207f, 0.06162415f, -0.07213978f, 0.12585557f, 0.15976664f, -0.24760769f, -0.21106188f, 
    0.04180046f, 0.04461296f, 0.02219203f, 0.01067926f, -0.10879860f, 0.03099669f, -0.08945138f, 0.01087624f, 
    0.15766832f, -0.34903488f, -0.01991399f, 0.03992641f, -0.02511284f, -0.04478874f, -0.16779904f, -0.00477666f, 
    -0.06880303f, 0.04659648f, -0.12834005f, -0.02240886f, -0.35284662f, 0.23406975f, -0.18748946f, -0.01717895f, 
    0.12040976f, -0.11140374f, -0.02199896f, -0.10911536f, 0.01366251f, 0.06706158f, -0.07304761f, 0.04951527f, 
    -0.30193731f, 0.26332474f, -0.08336063f, 0.05560331f, 0.03209908f, 0.12413374f, 0.02481744f, 0.06545090f, 
    -0.12667520f, -0.01482580f, -0.13366385f, -0.05281233f, 0.22861969f, 0.16924708f, 0.10291450f, 0.21661691f, 
    -0.01414432f, 0.03243993f, -0.03848852f, 0.08675724f, -0.12550779f, 0.02095788f, -0.04675439f, 0.04715795f, 
    -0.11380963f, 0.06991193f, -0.09544270f, -0.08149049f, 0.05767983f, -0.00301583f, -0.04383878f, -0.06954968f, 
    0.04011895f, -0.00947322f, 0.13141878f, -0.07785552f, -0.05295051f, -0.03159177f, 0.17195292f, -0.13438070f, 
    0.02470808f, 0.00086742f, -0.00396991f, -0.10880816f, 0.12799655f, -0.04688653f, -0.03687564f, -0.02043518f, 
    -0.07443430f, 0.00647528f, 0.14914079f, -0.01105712f, 0.02105508f, 0.08421717f, -0.00527666f, 0.03858826f, 
    -0.00804971f, 0.04369331f, 0.07621317f, -0.07900207f, -0.29019180f, 0.06307331f, -0.10917710f, -0.06073129f, 
    0.02084738f, 0.04484672f, 0.00924466f, 0.02936440f, 0.07384834f, 0.12612596f, 0.03531069f, 0.14158876f, 
    -0.01120706f, 0.15184075f, -0.12178939f, -0.11724281f, -0.00356634f, 0.01263632f, -0.09782150f, 0.02575844f, 
    -0.02775898f, -0.01246242f, -0.02584088f, 0.01364006f, -0.23311365f, 0.20627835f, -0.19246733f, -0.23774646f, 
    0.05381688f, -0.00562713f, -0.09302688f, 0.06389745f, 0.09511322f, 0.03131770f, -0.02172927f, 0.01038461f, 
    0.15196575f, 0.16295761f, -0.08145152f, -0.07875320f, 0.00491277f, 0.00485019f, 0.01651070f, 0.09472031f, 
    -0.04679792f, 0.02000769f, 0.04495278f, 0.13550639f, -0.43928924f, -0.25299001f, -0.00806004f, -0.09613740f, 
    0.06410535f, 0.04052993f, -0.01838446f, 0.05810697f, -0.00507520f, 0.08316706f, 0.08664323f, 0.14380336f, 
    0.18335013f, 0.05639100f, 0.07771427f, -0.12927011f, 0.00804289f, 0.02057160f, -0.06209752f, -0.05877553f, 
    0.06108201f, -0.01662057f, -0.04165853f, -0.05555746f, 0.13385896f, 0.10800270f, 0.00703798f, -0.16720305f, 
    0.08025457f, 0.09880599f, 0.02107708f, 0.01817236f, 0.07534015f, 0.05681456f, -0.03012077f, -0.04809893f, 
    0.16163327f, 0.07454521f, -0.01481472f, -0.06033943f, 0.02363179f, -0.11737167f, -0.06776860f, -0.12887581f, 
    -0.03962990f, -0.06363741f, 0.11304562f, -0.13008125f, 0.06138645f, 0.16307503f, -0.12407025f, 0.02197917f, 
    -0.16825657f, -0.07350396f, -0.01949552f, -0.17712519f, -0.01147283f, -0.11844567f, -0.06111889f, -0.09688923f, 
    -0.26427490f, -0.12930274f, 0.03813586f, -0.10929961f, 0.06921537f, 0.08231218f, -0.12235026f, -0.01222946f, 
    -0.00861481f, -0.10122168f, -0.15638481f, -0.04189280f, 0.05472055f, -0.15255105f, -0.13294134f, 0.07864735f, 
    -0.10657438f, -0.00311303f, -0.01828352f, -0.05361514f, -0.08091550f, 0.00194929f, -0.03804326f, -0.10980500f, 
    0.09341944f, 0.13594133f, -0.08900943f, 0.03738680f, -0.06360789f, -0.01562906f, 0.06294861f, 0.08886436f, 
    0.07969853f, -0.03476989f, 0.02497359f, 0.00219969f, -0.10214564f, -0.03044078f, 0.10149390f, 0.01756771f, 
    0.12355224f, -0.07311343f, 0.08756848f, 0.06531275f, 0.00427224f, -0.10936518f, -0.08268999f, -0.19021419f, 
    -0.24003133f, 0.00966530f, 0.18167759f, -0.05377267f, 0.10778142f, 0.05078577f, -0.02001048f, -0.01475054f, 
    -0.07533065f, 0.06489810f, -0.03257441f, 0.13577868f, 0.00034451f, 0.07941706f, 0.25260189f, 0.10636200f, 
    0.02730206f, 0.03064990f, 0.02995474f, 0.08348656f, -0.01732869f, -0.04611261f, 0.05681197f, -0.07420203f, 
    -0.09194570f, -0.03052312f, -0.05563047f, -0.06636960f, 0.04952688f, -0.03457038f, 0.00389175f, -0.05504012f, 
    0.09459784f, 0.27279592f, 0.09436909f, 0.16028804f, -0.19443662f, -0.00283353f, -0.07657509f, 0.11831409f, 
    -0.02498659f, -0.03221456f, -0.11068146f, -0.13190736f, 0.05342706f, -0.03553766f, -0.05062548f, -0.10778022f, 
    0.14847985f, -0.05639446f, -0.01945397f, 0.15396783f, 0.03553145f, -0.16474794f, 0.00795867f, 0.12502567f, 
    -0.01006064f, -0.07331749f, 0.01930194f, 0.00609887f, -0.25370213f, -0.23564199f, -0.10085674f, -0.18925413f, 
    0.07213140f, -0.02540237f, 0.07024636f, 0.00129677f, 0.07671260f, 0.05837401f, -0.01221453f, 0.03093523f, 
    -0.09157291f, 0.03202745f, 0.04560986f, -0.13647850f, 0.09866942f, -0.07470194f, -0.03357221f, 0.06389485f, 
    -0.05768795f, -0.07785104f, 0.07648443f, 0.08094041f, -0.12372427f, -0.11371983f, 0.07459394f, -0.02587324f, 
    0.12670092f, 0.02348334f, 0.00092784f, -0.04572428f, 0.02986231f, 0.01190953f, 0.06547119f, 0.05605304f, 
    0.04495662f, 0.03466897f, -0.13431665f, -0.25729755f, 0.05514256f, 0.02372782f, -0.04125808f, 0.08529444f, 
    0.03720942f, 0.08554789f, 0.14531757f, -0.02498071f, 0.21809328f, 0.09356488f, 0.00980930f, -0.09796024f, 
    0.04606238f, -0.00002450f, 0.09276129f, -0.06367271f, 0.01349240f, -0.11158523f, 0.04724053f, 0.08044435f, 
    -0.36958706f, -0.16638559f, -0.18276158f, -0.04163850f, 0.06915013f, -0.00669759f, 0.11070538f, 0.07588027f, 
    -0.00120319f, -0.04599052f, 0.04785678f, -0.02362996f, 0.16954237f, 0.17877425f, 0.01901325f, -0.11971049f, 
    -0.12308945f, -0.08030086f, -0.03650083f, -0.10620865f, 0.09551954f, -0.08884034f, 0.04265491f, -0.00449462f, 
    -0.50853080f, -0.29783827f, -0.01002970f, -0.06604673f, 0.12596518f, 0.04233056f, -0.20153464f, -0.13521689f, 
    0.08092430f, 0.02998629f, -0.01437821f, 0.13862647f, 0.35093847f, -0.04746203f, -0.14916667f, 0.15144756f, 
    -0.08155138f, -0.06376111f, -0.04005800f, 0.04754611f, -0.04626383f, 0.05577504f, -0.14326955f, 0.03741166f, 
    -0.06150026f, 0.02611722f, 0.00051035f, -0.07532085f, 0.05315374f, 0.12714760f, -0.01951448f, 0.07733721f, 
    -0.03084892f, -0.00647160f, 0.00997797f, 0.01108625f, -0.07797425f, -0.02031155f, 0.12703091f, -0.06123319f, 
    0.05796904f, 0.09035128f, -0.07201409f, -0.05837363f, 0.01555557f, -0.05348684f, 0.08085670f, -0.06576246f, 
    -0.51599509f, -0.32285854f, 0.20960002f, -0.13509983f, 0.04373292f, -0.01457098f, -0.03989938f, -0.04648143f, 
    0.12414293f, 0.06584430f, -0.13145670f, -0.06005368f, 0.10384583f, 0.03473473f, 0.00721591f, -0.00660492f, 
    -0.19757289f, 0.03552307f, -0.01961687f, 0.02598485f, -0.02377734f, -0.01215636f, -0.03653079f, 0.02730923f, 
    -0.17144528f, -0.16725139f, -0.05233160f, -0.14998989f, -0.00695944f, -0.04578205f, -0.01499346f, 0.03700437f, 
    0.00385936f, -0.13447133f, -0.28446379f, -0.02928488f, 0.06413703f, 0.11575703f, -0.09840827f, 0.06085694f, 
    0.00316588f, -0.05694249f, 0.00822331f, -0.04062093f, -0.02391312f, 0.03522490f, -0.10018198f, -0.05295542f, 
    -0.00834139f, 0.04752610f, -0.06101692f, 0.05601948f, -0.11099717f, 0.01724446f, -0.05903232f, 0.00412410f, 
    0.06427681f, 0.08331048f, 0.06462851f, -0.11746421f, 0.03665603f, 0.00097335f, -0.02868769f, 0.08062586f, 
    0.01423112f, 0.03201942f, -0.01825661f, 0.06062935f, 0.01782173f, 0.03846912f, 0.00345056f, 0.02575543f, 
    -0.19828810f, -0.21405317f, -0.10207325f, -0.18032026f, -0.07007988f, 0.01375885f, 0.04327711f, 0.03697149f, 
    0.06223025f, 0.11682731f, 0.15327407f, -0.02094075f, 0.16213046f, 0.07710214f, 0.02415027f, -0.12389486f, 
    -0.00262088f, -0.03520913f, 0.02266750f, 0.07016107f, -0.02138476f, 0.02173165f, 0.03104313f, 0.03882634f, 
    0.10473116f, 0.11223159f, -0.01841060f, 0.02520808f, -0.06213645f, 0.03823012f, 0.00632624f, 0.00608008f, 
    0.01614928f, 0.07844110f, 0.07632280f, -0.01262224f, -0.32966706f, -0.15507640f, 0.03123090f, 0.02102615f, 
    0.06038986f, 0.07877154f, 0.03711627f, -0.01416219f, 0.00545559f, -0.07705848f, 0.12195892f, 0.05120925f, 
    -0.11099070f, 0.19192675f, -0.08253650f, -0.04603936f, 0.10180361f, -0.08366712f, 0.03275640f, 0.02348956f, 
    0.04143484f, 0.10937828f, -0.11496923f, -0.08254090f, -0.35556215f, -0.00854707f, -0.19532631f, -0.07508362f, 
    -0.00204970f, 0.11963881f, -0.13737655f, 0.02879786f, 0.04864896f, 0.09230842f, -0.04084980f, 0.19751465f, 
    0.07570923f, 0.06058308f, -0.00465490f, -0.00028435f, 0.02740760f, 0.08294989f, -0.03937478f, -0.06328339f, 
    -0.08009893f, 0.09416607f, -0.11742543f, 0.14175105f, 0.11177299f, -0.05261977f, 0.05568690f, 0.19922708f, 
    -0.09907324f, -0.07617916f, -0.00245536f, 0.02277288f, 0.02296834f, 0.01191209f, -0.18719548f, -0.05167194f, 
    -0.07441018f, -0.04080358f, 0.07121479f, 0.16065018f, 0.10883603f, 0.06713471f, 0.12541530f, -0.04627824f, 
    0.07422955f, -0.03398301f, -0.08047708f, -0.03828898f, 0.29353786f, 0.23358271f, -0.01078103f, -0.02870888f, 
    0.01436309f, -0.02317034f, 0.02522924f, 0.04137132f, -0.04690576f, 0.06386334f, 0.11741541f, -0.00875312f, 
    0.00807426f, -0.00590357f, -0.21417379f, -0.12265496f, 0.03913033f, -0.01124236f, -0.04484501f, 0.08173885f, 
    0.00300943f, 0.07895818f, 0.05901961f, 0.07550879f, 0.26580554f, 0.08216839f, -0.01418160f, -0.06975380f, 
    0.01827399f, -0.02887538f, 0.04709814f, 0.02234300f, 0.09682434f, 0.21563655f, 0.09200057f, 0.08928767f, 
    -0.04978976f, 0.14453268f, -0.11114847f, 0.01752337f, 0.05323794f, 0.02089207f, 0.03372476f, 0.01114461f, 
    0.01858766f, 0.06137444f, 0.07699344f, -0.00658833f, -0.40871596f, -0.34103185f, 0.07776000f, 0.11761739f, 
    0.03585586f, 0.05819349f, -0.01543550f, 0.00168455f, 0.06156450f, 0.04677986f, -0.08487752f, 0.14395164f, 
    0.08568481f, 0.06530418f, -0.04368018f, 0.00187196f, -0.09534355f, -0.01063696f, -0.04845351f, 0.03939391f, 
    0.04878432f, -0.19197695f, 0.12209849f, -0.09517422f, -0.46131036f, -0.47143918f, -0.09710911f, 0.05098783f, 
    0.08507043f, 0.05943919f, -0.05470488f, 0.00389263f, -0.04759875f, 0.02509278f, -0.01637490f, 0.01039533f, 
    0.10684957f, 0.12391574f, -0.03112614f, 0.13810140f, -0.09346659f, -0.01367376f, 0.01598911f, -0.03601611f, 
    0.08914754f, 0.04849975f, 0.05478149f, -0.05685532f, -0.41934556f, -0.31813079f, -0.02613761f, 0.02482053f, 
    0.03423343f, 0.06758452f, 0.09216831f, -0.04985332f, 0.05549810f, 0.00523550f, 0.00660217f, 0.04385863f, 
    0.12366176f, -0.05471465f, -0.03774064f, 0.05378308f, -0.00101741f, -0.15657927f, -0.01159210f, 0.03899311f, 
    -0.00630259f, -0.04859705f, -0.04524953f, -0.10192161f, -0.30564916f, -0.15996483f, -0.08018954f, -0.27289769f, 
    0.06582066f, -0.04847474f, 0.01425184f, 0.05190123f, 0.07161981f, 0.10744715f, 0.11006569f, 0.12812592f, 
    0.06221631f, 0.00603331f, 0.03723528f, -0.13166121f, -0.03356775f, 0.03215140f, 0.10230614f, -0.00639097f, 
    0.10531792f, -0.10188831f, -0.00846581f, -0.08787527f, -0.03978774f, -0.07114769f, 0.17909615f, -0.03090443f, 
    -0.03336021f, 0.01866317f, -0.04885176f, 0.10536274f, 0.10953373f, 0.10299943f, 0.14708917f, 0.07279772f, 
    0.27486733f, -0.05965469f, 0.01631855f, -0.05350358f, -0.09290120f, 0.01092735f, 0.08081043f, 0.00563351f, 
    0.01270629f, 0.12887855f, 0.08139182f, 0.05414492f, -0.53511488f, -0.32819736f, -0.18455498f, -0.17654563f, 
    -0.02106989f, -0.00787912f, -0.05162768f, -0.04117585f, 0.09978891f, -0.01264502f, 0.05130079f, -0.00419162f, 
    -0.15990655f, -0.33382058f, 0.06234565f, 0.02321647f, -0.01181756f, -0.08412069f, -0.06146262f, 0.12230905f, 
    0.08071710f, 0.16899714f, 0.04572908f, 0.09053288f, -0.04793366f, -0.20596798f, 0.02785076f, 0.11938088f, 
    0.01202482f, 0.04563882f, -0.05913591f, -0.11411233f, 0.10681678f, -0.00677326f, 0.04275658f, -0.05181623f, 
    -0.12490598f, -0.11793546f, -0.20854543f, 0.01517335f, 0.03449898f, 0.04442374f, -0.02373686f, -0.09064146f, 
    0.00313308f, 0.04374922f, -0.05587414f, 0.09790790f, -0.23029855f, -0.02527755f, -0.02344826f, 0.13608131f, 
    0.11822618f, 0.10969052f, 0.00900598f, -0.06905661f, -0.11505020f, -0.03409679f, -0.04400751f, 0.02958044f, 
    -0.06447744f, 0.15626571f, -0.01369702f, -0.03321381f, 0.08932617f, -0.00544125f, 0.00096967f, 0.01716463f, 
    -0.02674993f, 0.05430358f, -0.03283568f, -0.00264440f, -0.04947117f, 0.02898218f, -0.23768340f, -0.14113334f, 
    0.04213446f, 0.00313501f, -0.02455315f, 0.12841356f, 0.02270165f, -0.06480515f, -0.04978869f, -0.12030353f, 
    -0.52965099f, -0.06955723f, -0.11429901f, -0.08847763f, -0.02428285f, 0.12421536f, -0.07573014f, 0.11631490f, 
    -0.03543711f, -0.03012035f, -0.08512325f, -0.08104244f, -0.24630590f, -0.02935222f, 0.20287912f, 0.31441095f, 
    -0.11085238f, 0.04273502f, 0.07032493f, -0.05911931f, 0.01975551f, -0.01663066f, 0.11298709f, 0.06921036f, 
    -0.25664026f, 0.12209368f, -0.07388970f, -0.04057904f, 0.06513130f, -0.07169852f, -0.03798877f, -0.05186774f, 
    -0.12819217f, -0.07164951f, -0.06282804f, 0.03634610f, 0.00558235f, 0.01946774f, -0.14703037f, 0.05434123f, 
    0.00945608f, 0.05796914f, 0.01158764f, 0.11248866f, 0.08654568f, -0.02232108f, -0.05737707f, -0.02570657f, 
    -0.00279869f, 0.10615234f, 0.11221848f, 0.00257931f, -0.12517348f, 0.03616520f, -0.04618099f, -0.16566052f, 
    -0.00620627f, -0.00561645f, 0.03763256f, -0.15044548f, -0.14039248f, 0.06401473f, -0.01355651f, -0.12190728f, 
    -0.14456254f, 0.02571546f, -0.12759873f, -0.06963515f, 0.08864592f, 0.01269574f, 0.01029745f, -0.12139376f, 
    -0.09430704f, 0.11604902f, -0.02435522f, 0.04474095f, -0.06038903f, -0.00777481f, -0.02836023f, -0.14445300f, 
    0.01648310f, -0.03930636f, -0.06614783f, -0.19536527f, -0.06768876f, -0.12102667f, -0.05501437f, -0.06010035f, 
    -0.17109695f, 0.01434569f, 0.00317769f, 0.07624234f, -0.15940407f, -0.04093381f, -0.10676415f, -0.05363012f, 
    0.23533730f, 0.07544336f, -0.14417265f, 0.00417694f, 0.11449964f, -0.01638949f, -0.10145939f, 0.04103036f, 
    0.09161866f, 0.05270312f, 0.09865800f, 0.09765727f, -0.54207134f, 0.14211850f, 0.01798975f, -0.08273804f, 
    -0.09637665f, 0.00764098f, -0.07933808f, 0.02592175f, 0.14375462f, 0.14108196f, 0.02880577f, 0.01867851f, 
    -0.10769225f, 0.04315069f, 0.10503127f, -0.06530370f, -0.04747233f, 0.06844850f, -0.02229363f, 0.00772167f, 
    -0.06419393f, 0.02801622f, -0.03703270f, 0.10877183f, 0.29988667f, -0.05013046f, -0.07376605f, -0.04983323f, 
    -0.00078421f, -0.04571654f, 0.09188630f, 0.03376932f, 0.07682990f, 0.07343076f, 0.02816805f, 0.03707906f, 
    0.46791127f, 0.16603275f, -0.08293376f, -0.07498773f, -0.03749487f, -0.01087164f, 0.04597063f, -0.03669267f, 
    0.16930437f, -0.04365582f, -0.00118132f, 0.02343098f, 0.03250449f, 0.17236359f, -0.05318591f, -0.01322972f, 
    -0.13190867f, 0.05104918f, -0.03555825f, -0.14039525f, 0.00937100f, 0.02979114f, 0.04401769f, -0.08831557f, 
    -0.18308538f, -0.10527351f, -0.01189637f, 0.06756307f, -0.17386860f, 0.15299489f, -0.09236860f, 0.05766807f, 
    0.00198844f, -0.04247099f, 0.01780321f, -0.11419259f, -0.01043367f, 0.01871052f, -0.10255161f, -0.02528138f, 
    0.02555973f, -0.06526328f, 0.05110625f, 0.09596133f, -0.00975777f, -0.04513633f, 0.07732805f, 0.02222202f, 
    0.14063726f, -0.04280452f, -0.01608517f, 0.06812707f, 0.09913098f, -0.07990242f, 0.00944814f, -0.08704364f, 
    0.13428214f, 0.03734051f, 0.02226859f, 0.06232502f, 0.36714542f, 0.13832687f, -0.28941709f, 0.06380089f, 
    0.05108611f, -0.07604025f, 0.02478073f, -0.04276780f, 0.10922354f, 0.05532594f, 0.08909281f, -0.00475732f, 
    0.19901218f, 0.03884848f, -0.11981644f, 0.06711613f, -0.12003837f, 0.03041197f, 0.09179943f, 0.03722905f, 
    0.02695546f, -0.04795488f, -0.08466014f, -0.03614942f, 0.14781398f, -0.33551919f, -0.08995754f, 0.13215433f, 
    0.02080056f, -0.00350602f, 0.04339994f, -0.08063273f, 0.03568013f, 0.01631988f, -0.03491459f, -0.00188433f, 
    0.15057957f, -0.06342825f, -0.21417074f, 0.17753635f, -0.02963881f, 0.00162366f, 0.00948674f, 0.07717510f, 
    0.03675409f, -0.07321661f, 0.02729221f, 0.07492871f, -0.00396031f, 0.13024007f, -0.13041316f, -0.19168247f, 
    -0.05372995f, -0.04483842f, 0.00957526f, -0.04656510f, 0.00364611f, -0.04488565f, -0.06539719f, -0.14917308f, 
    0.23404363f, -0.27423835f, -0.11510822f, -0.02806684f, 0.15841496f, -0.03388662f, -0.10627360f, -0.02243148f, 
    0.10374371f, 0.07306539f, -0.01206994f, 0.06525613f, 0.03745375f, -0.03008334f, -0.04123181f, 0.33519638f, 
    -0.02988118f, -0.01827181f, 0.07095566f, -0.08639174f, -0.12622674f, 0.05542552f, 0.14482135f, -0.00191655f, 
    0.11211391f, -0.04630100f, -0.01853246f, -0.14574918f, 0.03958925f, -0.11264105f, -0.01847666f, 0.03784657f, 
    -0.03489509f, 0.01525166f, -0.06129558f, -0.02644194f, -0.21921507f, 0.09127613f, 0.09051818f, -0.04504655f, 
    0.03313326f, -0.13619187f, -0.04742869f, -0.01908412f, 0.01332365f, -0.00068393f, 0.12681775f, -0.05872613f, 
    -0.23151116f, 0.20152958f, 0.01598693f, -0.19918253f, 0.02755786f, -0.01058806f, 0.04361567f, 0.01972610f, 
    -0.06677447f, 0.11866186f, -0.00748098f, -0.01483848f, -0.17496186f, 0.21446462f, -0.01470619f, 0.00531204f, 
    0.04064070f, -0.08421286f, -0.07389968f, -0.07445659f, 0.00479301f, 0.06822369f, 0.03699984f, -0.09043214f, 
    0.28292000f, 0.05992649f, -0.14640786f, -0.05931307f, 0.05947215f, -0.02494208f, -0.09314084f, -0.00028180f, 
    0.11010627f, -0.00456362f, 0.00831378f, 0.04090939f, 0.03453670f, 0.02874381f, -0.10157564f, 0.09116963f, 
    -0.08469044f, 0.06843337f, -0.01589062f, -0.10389806f, -0.06157265f, -0.01783268f, -0.02872537f, -0.09219930f, 
    0.03270082f, -0.05074245f, -0.06893349f, 0.12859713f, 0.09474239f, -0.02411882f, 0.01510985f, -0.01990008f, 
    -0.01632247f, 0.02458178f, 0.03578795f, 0.05139077f, 0.03848155f, -0.31965077f, 0.01381369f, 0.16884944f, 
    -0.15433112f, 0.14091988f, -0.01271780f, 0.03877866f, 0.03379012f, 0.03646154f, 0.00895524f, 0.11310740f, 
    -0.02688424f, -0.08434150f, -0.12580696f, 0.12164946f, -0.04334524f, 0.05000300f, -0.09220490f, -0.01323607f, 
    0.01234109f, 0.01596465f, -0.00072664f, -0.08788845f, -0.12082664f, 0.13297077f, 0.08005757f, -0.16370921f, 
    0.05163340f, 0.00995267f, -0.04112281f, 0.01561725f, -0.03023743f, 0.09750985f, 0.01112508f, -0.07509064f, 
    -0.17233112f, -0.21928006f, 0.00643678f, -0.22900933f, 0.16418441f, 0.07913127f, -0.02744471f, -0.02081217f, 
    0.00179034f, -0.08311807f, -0.11248600f, 0.05757136f, 0.05462142f, 0.02743564f, 0.00924441f, 0.15298894f, 
    0.03635029f, -0.08421370f, 0.08814694f, 0.13706160f, -0.05338676f, 0.08967523f, -0.01568077f, 0.07444696f, 
    0.14710633f, -0.08144169f, -0.06083820f, 0.02468518f, -0.24434318f, 0.01719311f, -0.06995558f, -0.12318692f, 
    0.03482373f, -0.05727154f, -0.08442828f, -0.15004551f, 0.11809730f, 0.21221668f, -0.11068013f, 0.10878615f, 
    -0.00998391f, -0.03359380f, -0.01386333f, -0.02239110f, -0.00443529f, 0.06983294f, -0.06561625f, -0.01770996f, 
    -0.12622321f, 0.05831566f, -0.04638251f, 0.12108466f, -0.08795513f, 0.04019706f, 0.01071554f, 0.08834952f, 
    0.09904289f, 0.00172283f, 0.06223794f, 0.04708908f, 0.40467575f, 0.04808032f, -0.17954454f, 0.06026927f, 
    -0.06970465f, -0.03892434f, 0.06374422f, 0.07833768f, 0.02303751f, -0.03349008f, 0.10648105f, -0.09370734f, 
    -0.31405491f, -0.06273456f, -0.00070244f, 0.03590579f, -0.09225518f, 0.04315573f, 0.03626988f, 0.12909858f, 
    -0.17548303f, 0.06404091f, -0.05508380f, -0.15466776f, -0.06730314f, -0.25304091f, 0.13032889f, -0.00469239f, 
    0.07716058f, -0.04718699f, -0.00053580f, -0.04097331f, -0.08294339f, -0.02981451f, 0.11663596f, 0.12584022f, 
    0.25385442f, 0.05402616f, -0.05637118f, -0.01075380f, 0.00385317f, -0.07427140f, -0.06581543f, 0.01318147f, 
    0.03270071f, 0.11056037f, 0.06330235f, 0.05198768f, -0.08914172f, -0.01115684f, -0.08714784f, 0.09147371f, 
    -0.02566674f, -0.04313039f, -0.04047649f, 0.07072802f, -0.01579373f, -0.04973692f, -0.06329355f, -0.05948689f, 
    -0.11848843f, -0.08457267f, 0.12448297f, -0.09895056f, -0.02319625f, 0.02864235f, -0.08775380f, 0.04799844f, 
    -0.03103578f, -0.01432552f, 0.10096136f, -0.01372569f, 0.02129619f, 0.08943311f, 0.04455087f, 0.04654033f, 
    -0.02379403f, 0.07088886f, -0.05264025f, -0.05572338f, -0.06625637f, -0.21510132f, -0.14495704f, -0.08489934f, 
    -0.37346154f, 0.09478669f, -0.00310342f, -0.12150698f, -0.13272817f, -0.06808348f, 0.03692434f, 0.09810438f, 
    0.02918850f, -0.14688580f, -0.01138926f, 0.07977213f, -0.30050495f, -0.11091474f, -0.01979556f, 0.13810897f, 
    0.20431891f, -0.05360757f, 0.03214443f, -0.06984459f, 0.07599649f, -0.02323170f, 0.07402399f, -0.06095887f, 
    0.01806584f, -0.10193671f, 0.03806546f, 0.16529150f, -0.07372960f, 0.03943326f, 0.02632148f, -0.14715397f, 
    -0.04345588f, 0.05578809f, -0.06527102f, -0.01344173f, -0.22851783f, 0.15606701f, -0.04155937f, -0.04000115f, 
    0.22867021f, -0.00611124f, -0.00966147f, 0.00166122f, 0.06409506f, 0.01275805f, -0.02847827f, -0.05568460f, 
    0.23423304f, -0.08228529f, 0.00690762f, -0.01699678f, -0.07155062f, -0.01625485f, -0.02495830f, -0.04560269f, 
    0.03695232f, -0.05034978f, -0.07601483f, 0.10088859f, -0.24835925f, 0.13460349f, -0.08069113f, -0.02209715f, 
    0.07415732f, 0.04226236f, -0.02851536f, 0.16914131f, 0.02303892f, 0.02984136f, 0.07598219f, -0.01214380f, 
    -0.04260547f, -0.10869912f, -0.06774513f, 0.07675853f, -0.05000133f, 0.02160069f, 0.03121072f, 0.06333926f, 
    -0.11951279f, 0.08744564f, -0.01310115f, -0.04225875f, 0.23652767f, -0.08717687f, -0.13639843f, -0.06440175f, 
    0.01153405f, 0.03043726f, 0.04617210f, 0.09134227f, -0.00417240f, -0.01128429f, 0.03791252f, 0.02371261f, 
    -0.06688401f, -0.03930789f, 0.08415683f, 0.03367953f, 0.13701631f, 0.04013926f, 0.00962302f, -0.01552052f, 
    -0.02200335f, 0.03083587f, 0.01262411f, -0.09671050f, 0.13693184f, -0.06459320f, -0.20040208f, 0.15815894f, 
    -0.03450102f, -0.08159434f, 0.05601802f, -0.01826132f, 0.01552991f, 0.00066752f, -0.02469822f, 0.02478465f, 
    0.03580202f, 0.16011100f, -0.01810217f, 0.08478247f, 0.01441041f, 0.01439333f, 0.00571441f, -0.01449967f, 
    0.03081552f, -0.01823937f, 0.07925128f, -0.07099637f, -0.00551121f, -0.28828254f, -0.08158991f, -0.20558926f, 
    0.00630989f, -0.01762393f, -0.04558603f, -0.01784153f, -0.03507545f, -0.00301026f, -0.05004087f, -0.00131397f, 
    -0.05771336f, 0.13124721f, -0.03112868f, 0.17982878f, 0.08870845f, -0.04306006f, 0.01855274f, -0.08040068f, 
    0.00451298f, -0.07747588f, -0.08651590f, 0.00211356f, -0.08158860f, 0.14494887f, 0.00052150f, -0.05558565f, 
    0.03479043f, -0.07954265f, -0.06897884f, -0.04650289f, -0.11763372f, 0.05987484f, -0.09174062f, 0.03964232f, 
    -0.17599560f, -0.04525845f, -0.19773756f, -0.01910429f, 0.13051014f, 0.07039172f, 0.00948448f, 0.05286647f, 
    0.04133282f, 0.04613091f, -0.04930902f, -0.10121838f, 0.24725471f, 0.13622849f, -0.16855900f, -0.19876496f, 
    0.10222850f, -0.03112847f, -0.01685689f, 0.08876993f, -0.02742167f, 0.01237274f, 0.08200753f, 0.00948951f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.08266675f, 0.01571154f, -0.03674567f, -0.01352766f, -0.02158283f, -0.01640370f, -0.00730606f, -0.03715009f, 
    -0.02229911f, -0.00442172f, 0.08383744f, -0.01731762f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
