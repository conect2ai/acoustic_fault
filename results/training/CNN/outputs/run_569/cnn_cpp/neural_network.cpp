#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.48791763f, 0.60285974f, 0.01915246f, 0.44448709f, 0.26118678f, 0.31206971f, 0.20166978f, 0.30012947f, 
    0.37770516f, 0.35513142f, -0.55024052f, -0.36292374f, 0.04339694f, -0.76101512f, -0.09665994f, -0.33695665f, 
    -0.04799584f, -0.28986993f, -0.36589444f, -0.05002213f, -0.20004310f, -0.12701690f, -0.00381642f, -0.00497556f, 
    -0.25818467f, -0.49423635f, -0.70473409f, -0.68127602f, -0.18302956f, -0.09129986f, 0.50510675f, 0.60840935f, 
    -0.20602497f, 0.41746023f, 0.50063401f, 0.09754553f, -0.16527070f, 0.23466393f, -0.02145224f, -0.12836774f, 
    -0.10859540f, -0.02710504f, 0.28494427f, 0.08563467f, -0.16138336f, -0.12254386f, -0.35602158f, -0.17196198f, 
    -0.20799696f, 0.05155520f, -0.08626512f, 0.95185810f, -0.13906281f, 0.52450001f, -0.56085551f, 0.48144203f, 
    0.09557253f, -0.81804675f, 0.10134888f, -0.47455561f, 0.09097733f, 0.04773042f, -0.11486103f, 0.07590639f, 
    0.03652196f, -0.16045982f, -0.09934312f, 0.11602461f, 0.02364307f, -0.04057349f, -0.12629564f, -0.22801220f, 
    -0.17343098f, -0.19917865f, -0.11820904f, 0.70695645f, -0.06225723f, -0.39368916f, -0.64092857f, -0.60344046f, 
    0.37348786f, 0.28267193f, -0.06658774f, -0.28897545f, -0.21768600f, 0.43266317f, 0.36150065f, -0.02473533f, 
    0.05806188f, 0.28681791f, -0.06762083f, 0.10291684f, -0.10276257f, -0.15408178f, 0.14478511f, 0.08769809f, 
    0.19367136f, 0.30192894f, 0.42841902f, -0.03014096f, -1.10891676f, 0.74931926f, 0.38802844f, -0.69018418f, 
    -0.27572602f, 0.51311123f, 0.46385065f, -0.24708918f, 0.28612846f, 0.07279274f, -0.05963534f, 0.05373842f, 
    0.09730839f, 0.18242319f, 0.06998878f, -0.22076823f, -0.11384114f, -0.03022610f, -0.12490495f, -0.10563360f, 
    0.00219457f, 0.03858490f, 0.21963789f, 0.15150174f, -0.00814354f, -0.14805245f, -0.87579727f, 0.00329118f, 
    0.64243644f, 0.41778335f, -0.76215917f, -0.45624658f, -0.03350335f, -0.45013884f, -0.26375428f, 0.20587656f, 
    0.08551525f, -0.24521223f, 0.16109625f, -0.02998075f, 0.07505331f, 0.18790060f, 0.37014639f, 0.00140382f, 
    0.08454348f, -0.21691269f, -0.09059091f, -0.09435885f, -0.01767861f, -0.14781335f, 0.28836584f, -0.67838323f, 
    -0.59052783f, 0.29237962f, -0.13064474f, -0.79181355f, -0.24412785f, -0.32579345f, -0.28753421f, -0.19307719f, 
    -0.46830922f, 0.21279380f, 0.12101159f, 0.24808729f, -0.32184857f, 0.05398615f, 0.04693936f, -0.14973229f, 
    -0.15290502f, -0.10327555f, -0.07762574f, -0.12641287f, 0.23755965f, 0.18799300f, 0.05292800f, 0.06766111f, 
    0.06544255f, 0.12011727f, -0.37329409f, 0.33715433f, -0.42209768f, -0.56100798f, -0.75747621f, -0.44882885f, 
    -0.35192621f, -0.21097003f, 0.06935868f, 0.27513835f, -0.00332981f, 0.08167829f, -0.30031675f, 0.02191998f, 
    -0.16845326f, 0.00246405f, 0.60974020f, 0.11384327f, 0.19098935f, 0.09135811f, -0.00461279f, -0.24563299f, 
    0.21408728f, -0.41340220f, 0.59776682f, 0.95970643f, 0.71543610f, 0.14831810f, 0.52362221f, -0.18556896f, 
    0.32886270f, 0.36807814f, -0.07570616f, -0.01259976f, -0.08546360f, -0.02576103f, -0.12441099f, -0.08408135f, 
    0.07566181f, -0.07731023f, 0.00942685f, 0.01634373f, 0.05915827f, 0.09116824f, 0.01341528f, -0.08841869f, 
    0.13622706f, -0.47021532f, 0.46142691f, 0.40033314f, -0.05488646f, 0.42636004f, -0.25802833f, 0.58587795f, 
    0.43215439f, -0.24337810f, -0.07386281f, 0.02328074f, -0.00771152f, 0.31627014f, 0.18096146f, 0.23431954f, 
    0.33579004f, 0.17225689f, -0.09777263f, 0.04646156f, 0.14349565f, 0.19187741f, -0.04648707f, 0.15452902f, 
    -0.05022010f, 0.34204596f, 0.94012439f, 0.60327220f, 0.40166798f, 0.54727906f, 0.52184278f, 0.28850770f, 
    -0.27821213f, -0.46546796f, 0.28494522f, 0.03516089f, 0.31076223f, 0.27869427f, -0.10303662f, 0.27167356f, 
    0.03084467f, 0.13667879f, -0.00119181f, 0.12139071f, -0.01730239f, 0.16415872f, 0.06479929f, 0.14055559f, 
    -0.09595133f, -0.01827135f, 0.39974755f, -0.52196801f, -0.77256399f, -0.60316890f, -0.34277913f, -0.37120205f, 
    -0.13374807f, 0.57351243f, 0.65196639f, -0.19976111f, 0.40278998f, -0.23351324f, -0.06962822f, -0.29470041f, 
    -0.31697452f, 0.05171198f, -0.11278719f, 0.15295742f, -0.00218761f, 0.06113958f, -0.04097207f, 0.08632281f, 
    0.03162679f, 0.13880222f, 0.21466449f, 0.08335800f, -0.02281901f, 0.94293350f, -0.13496186f, -0.23728393f, 
    0.86852336f, 0.39750719f, 0.01551692f, -0.19499110f, -0.09429295f, 0.24658787f, 0.33541733f, -0.39683968f, 
    -0.14112321f, -0.05892267f, -0.06506034f, -0.04896375f, 0.02583030f, -0.18733487f, 0.06274804f, -0.03034098f, 
    0.05862910f, 0.09391889f, 0.05151280f, 0.15439846f, 0.10200056f, 0.22151729f, -0.67761868f, 0.28227836f, 
    -0.16555858f, -0.40896165f, 0.60339218f, 0.20357271f, 0.76918310f, 0.40426347f, -0.28448027f, 0.03495989f, 
    -0.17383753f, -0.03490678f, 0.23732448f, -0.25404888f, -0.14516875f, -0.05332965f, -0.07749211f, -0.31435183f, 
    0.03729957f, -0.06156598f, -0.07066511f, 0.15711540f, -0.23134653f, 0.09215891f, 0.87258869f, 0.34000537f, 
    0.41419080f, 0.51706028f, 0.41176903f, 0.33704203f, -0.00261118f, -0.39047858f, -0.65239882f, -0.31806129f, 
    -0.12692839f, 0.00488292f, 0.11634176f, 0.17774563f, -0.40568155f, -0.18987319f, 0.11017173f, 0.19040494f, 
    0.01617311f, -0.29899061f, -0.13028181f, 0.03215372f, -0.08563973f, -0.18935046f, -0.06720532f, 0.74020994f, 
    0.49107075f, -0.68941551f, -0.78477770f, -0.62989831f, 0.03462602f, -0.35806856f, -0.24591701f, -0.16081043f, 
    0.10286114f, -0.08904104f, -0.24532041f, -0.15364285f, -0.24721408f, -0.32718349f, -0.10564612f, -0.14899401f, 
    -0.14735074f, -0.14076303f, -0.28423873f, 0.15897517f, 0.02449796f, 0.08001886f, -0.04230207f, 0.12737609f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.17465001f, 0.10814933f, 0.00091900f, 0.12294618f, -0.05598503f, 0.28946418f, 0.18953939f, 0.38577312f, 
    0.22361016f, 0.18739048f, 0.25863007f, 0.00581832f, -0.01993120f, 0.14642967f, 0.00637750f, 0.10928184f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01685240f, -0.01711258f, -0.05838495f, -0.05188414f, 0.00582762f, -0.02273881f, -0.04141611f, -0.02483772f, 
    -0.02449801f, -0.03942477f, -0.02246580f, -0.02216778f, -0.01422414f, -0.02422682f, 0.06001768f, 0.05129262f, 
    -0.01839757f, -0.06610107f, -0.00494032f, 0.05096706f, 0.05699937f, -0.06249844f, -0.00458084f, -0.05837181f, 
    0.01680583f, -0.04638140f, 0.02667156f, 0.00214165f, 0.02374242f, -0.01768407f, 0.00388189f, 0.02479086f, 
    0.05313934f, 0.05371566f, -0.00248803f, -0.06470438f, -0.01809323f, -0.02077639f, -0.06725596f, 0.04836780f, 
    0.01286944f, 0.03394551f, -0.04089496f, 0.02853042f, 0.00446485f, 0.04795145f, 0.02914386f, -0.02275864f, 
    0.06484421f, -0.01678030f, 0.03039855f, -0.06628413f, -0.01947648f, -0.03846477f, 0.03444132f, -0.02121002f, 
    -0.06540152f, -0.07234456f, -0.06380726f, -0.06366493f, -0.04754001f, -0.04050570f, -0.04212024f, 0.05455218f, 
    0.00711859f, -0.03761049f, 0.01239196f, 0.05769511f, -0.05346986f, -0.03166710f, 0.04677324f, -0.04553485f, 
    -0.05167775f, -0.00298480f, -0.05938006f, -0.02582122f, -0.03496177f, 0.05167299f, 0.00384247f, -0.01369721f, 
    0.05751867f, 0.04416236f, 0.04845561f, -0.01380189f, -0.01671514f, 0.05640354f, -0.01631228f, -0.06070124f, 
    0.01684867f, -0.04711522f, -0.06040033f, -0.05583250f, -0.07669812f, -0.05095540f, -0.02456396f, -0.03283373f, 
    0.05553499f, 0.03495411f, 0.04648266f, -0.05389890f, -0.04645119f, -0.07128907f, 0.00940568f, 0.06148101f, 
    0.03031818f, 0.00576957f, -0.00764818f, -0.05119868f, 0.00151541f, 0.04355406f, -0.05392366f, -0.06228737f, 
    -0.04917669f, 0.05823807f, 0.00282999f, 0.05646506f, 0.00312483f, -0.01970061f, -0.03236668f, -0.02357885f, 
    -0.02376135f, -0.06995215f, 0.02982900f, -0.04703425f, -0.03687396f, -0.00145983f, -0.02276426f, 0.01264502f, 
    -0.03973427f, -0.03785050f, -0.05312394f, 0.02000936f, 0.03550659f, -0.05118018f, 0.04986415f, -0.05249149f, 
    -0.04874681f, 0.04005614f, 0.04983141f, 0.03315356f, -0.03747129f, 0.04612862f, 0.00403875f, 0.05205943f, 
    0.04188840f, -0.07315882f, 0.02432738f, -0.06602192f, 0.01354666f, 0.04799540f, -0.07246567f, -0.03400796f, 
    -0.07287951f, -0.02515878f, -0.02494464f, 0.06561397f, -0.03350662f, -0.00505520f, 0.05410625f, 0.05357694f, 
    -0.06597468f, 0.06380662f, -0.04603552f, -0.05394198f, -0.03953910f, -0.02321419f, -0.05287607f, -0.05026637f, 
    0.05167832f, 0.00445563f, -0.06149863f, 0.03016910f, -0.01220761f, 0.03770802f, 0.02289824f, -0.05443153f, 
    -0.00640232f, -0.05459425f, -0.04252412f, -0.00247113f, -0.05696686f, 0.03201862f, -0.01860311f, -0.04946059f, 
    0.05210797f, 0.05848296f, 0.03971111f, -0.00801512f, -0.03952464f, 0.04962228f, 0.00311853f, 0.01807265f, 
    0.02313474f, 0.09723446f, 0.00974782f, -0.01027860f, -0.10188300f, 0.04208400f, 0.05768693f, -0.01710693f, 
    -0.06405438f, 0.03676697f, -0.01489116f, 0.01631112f, 0.22456145f, -0.11295007f, -0.16601841f, -0.12237100f, 
    0.10834803f, 0.03471626f, 0.03258990f, 0.00647126f, -0.00885823f, -0.12241886f, 0.01238883f, 0.02748679f, 
    -0.14176957f, 0.08448155f, 0.12336428f, 0.06120082f, 0.05466027f, 0.04245636f, 0.00003775f, 0.09535262f, 
    -0.02838320f, -0.05820724f, -0.05710097f, 0.01930540f, -0.11722881f, -0.10012275f, 0.13642967f, 0.05074933f, 
    0.10991233f, 0.07368708f, -0.00662563f, 0.08724322f, 0.04184743f, -0.02937810f, -0.06966716f, 0.00613269f, 
    -0.34504288f, -0.30899811f, 0.12451083f, -0.05376131f, -0.13112216f, 0.06867629f, 0.05170479f, -0.08972361f, 
    -0.06118814f, -0.04636290f, 0.15606444f, -0.03220750f, 0.14977591f, 0.15494320f, -0.17393436f, 0.03914389f, 
    0.02956718f, 0.05511538f, -0.04474655f, 0.08729347f, 0.02074974f, 0.01429155f, 0.13476200f, 0.11464832f, 
    -0.10240859f, -0.19075845f, -0.01244545f, 0.08792929f, 0.07832173f, -0.00631379f, 0.07932840f, 0.06564607f, 
    -0.00139396f, -0.03893268f, 0.08612287f, 0.06308827f, 0.13428643f, 0.04304253f, 0.09493645f, 0.00137613f, 
    -0.02653597f, 0.07391928f, 0.03776388f, 0.05553016f, -0.17359656f, -0.02488232f, 0.08671652f, 0.11733858f, 
    0.06516977f, -0.07388055f, 0.15461402f, -0.03002828f, 0.08584388f, -0.02177296f, -0.00196760f, -0.03264926f, 
    0.04406385f, 0.08483788f, 0.01892667f, 0.01885708f, -0.05349570f, 0.13482574f, -0.00372935f, -0.06993829f, 
    0.10771734f, 0.13544843f, 0.06675769f, -0.00987793f, 0.04596556f, 0.07138684f, 0.09632094f, 0.10480160f, 
    0.13223062f, 0.02221370f, 0.09241857f, -0.10083658f, 0.08560355f, -0.02278673f, 0.12036105f, 0.05509562f, 
    0.01477994f, 0.15418231f, -0.01370947f, 0.09399983f, 0.10289808f, 0.06036076f, -0.17157471f, -0.26457107f, 
    0.08242568f, -0.00154011f, -0.10471229f, 0.06239554f, 0.08604053f, 0.02629490f, -0.04775563f, -0.06625278f, 
    -0.01033400f, -0.20054388f, 0.27373284f, -0.16429880f, -0.05606351f, 0.05614918f, 0.10888018f, -0.00173221f, 
    -0.06018870f, 0.05258967f, -0.10607909f, 0.02043491f, 0.13313438f, -0.03825920f, -0.01459667f, -0.00635440f, 
    0.04206438f, -0.02435145f, 0.02676031f, 0.06053953f, -0.03087445f, -0.05926317f, -0.04450338f, 0.01846154f, 
    0.16806972f, -0.05668122f, -0.01368256f, -0.13002984f, -0.00666784f, -0.10381556f, 0.05844149f, 0.06267915f, 
    0.00629880f, -0.04834814f, -0.03397963f, -0.06721166f, 0.04935932f, 0.01529256f, 0.15941671f, -0.16181016f, 
    0.08018664f, 0.05990707f, 0.05585907f, 0.10534880f, 0.03010282f, -0.09617446f, -0.04398618f, -0.01637724f, 
    0.24646142f, 0.12416800f, 0.09116882f, 0.01422118f, -0.08317780f, 0.00076120f, -0.09900627f, -0.09359682f, 
    -0.04984077f, 0.08984538f, 0.01271914f, 0.03667196f, -0.28649065f, -0.11484703f, -0.09412374f, 0.05027110f, 
    0.12270561f, 0.13101247f, -0.02731084f, -0.00963266f, -0.02946781f, -0.10846511f, 0.00778309f, -0.04269405f, 
    0.01064892f, 0.26097146f, 0.19264190f, -0.17359290f, -0.08989114f, 0.05374790f, -0.16495951f, -0.13064380f, 
    0.02191689f, -0.05877383f, 0.04793250f, -0.02981177f, -0.24063408f, 0.14611018f, 0.07351425f, -0.01309410f, 
    0.16947295f, 0.08467637f, 0.06039226f, -0.05017214f, -0.04223731f, -0.03001826f, -0.02096168f, 0.06458730f, 
    0.07244753f, -0.41502768f, 0.01079686f, 0.06197382f, 0.02982026f, 0.03242124f, 0.24405630f, 0.02140803f, 
    0.05841136f, -0.04818198f, 0.05634526f, -0.04048172f, -0.04788147f, 0.01319348f, -0.06549170f, -0.06947450f, 
    -0.09316409f, -0.12610081f, -0.01964375f, 0.06172870f, 0.02957129f, 0.05035324f, 0.04914689f, 0.07340328f, 
    -0.25981608f, -0.07604603f, -0.09819141f, 0.13682601f, 0.01746673f, -0.09580931f, 0.01762935f, -0.01839193f, 
    -0.02228863f, 0.03533341f, 0.08099020f, 0.09194952f, -0.11175866f, -0.05589651f, 0.02762987f, 0.00674103f, 
    -0.05366241f, -0.02569220f, 0.06772519f, 0.02612165f, -0.12211563f, -0.05137590f, -0.05704090f, 0.07845115f, 
    0.02275836f, 0.21882306f, 0.17315046f, 0.09101582f, 0.05389224f, -0.14873618f, 0.07744409f, 0.06468481f, 
    0.24236092f, -0.01017844f, -0.06550935f, 0.05459140f, 0.20709303f, 0.05401021f, 0.04593751f, 0.10513067f, 
    0.12155219f, 0.06339373f, 0.10576960f, -0.03669541f, 0.11629263f, 0.02001376f, 0.04742806f, 0.00413558f, 
    0.19820222f, 0.19647351f, 0.10404510f, 0.07718079f, 0.08902325f, 0.14545105f, 0.09224994f, -0.04426902f, 
    0.05504404f, -0.02500256f, -0.02397549f, 0.07713884f, -0.45186809f, 0.00297101f, -0.23542516f, -0.09829829f, 
    0.19562300f, 0.04632661f, -0.01559424f, 0.21379109f, -0.02258218f, -0.15104498f, -0.07997228f, 0.00533645f, 
    0.07413122f, -0.09581775f, 0.26762494f, 0.01749007f, 0.00065189f, -0.02342004f, 0.02588447f, -0.02946892f, 
    -0.02080734f, 0.12055026f, 0.12256330f, -0.08066611f, -0.05104572f, 0.21915883f, -0.06975310f, -0.05121788f, 
    0.10776275f, 0.05017897f, 0.07864482f, -0.01789421f, -0.04910257f, -0.03819808f, -0.13235301f, 0.12427234f, 
    0.28002810f, 0.37039211f, 0.07052005f, 0.11814858f, 0.02582084f, -0.01260050f, 0.00657566f, -0.04630438f, 
    0.08327635f, 0.09135732f, 0.09898016f, 0.09729927f, -0.11382016f, 0.01711328f, -0.02688721f, -0.08023530f, 
    -0.04547497f, 0.00082453f, 0.09427703f, 0.09496677f, -0.03089315f, -0.04507630f, 0.01314083f, -0.03761319f, 
    -0.12524073f, -0.01259616f, -0.06392504f, -0.20869046f, -0.01025817f, -0.08011871f, 0.08296475f, -0.06748291f, 
    -0.05275267f, 0.02542531f, -0.10347697f, 0.05810089f, 0.21019609f, -0.08306807f, 0.03144047f, -0.25827658f, 
    -0.06437585f, 0.01234768f, -0.05008028f, -0.03303223f, 0.10214487f, -0.05770138f, 0.03024479f, 0.08007367f, 
    0.62808990f, 0.00430166f, -0.04587932f, 0.30156162f, -0.04043636f, -0.08815672f, -0.10755333f, -0.06268861f, 
    0.04386544f, 0.02220261f, 0.09753449f, 0.05484887f, 0.03012518f, 0.04576670f, -0.06496208f, -0.07459844f, 
    -0.17432165f, -0.03260776f, 0.10010409f, -0.02971693f, 0.02603862f, -0.01412914f, -0.12407172f, -0.05306959f, 
    0.09858359f, -0.08683714f, 0.09929582f, 0.27837536f, 0.01627085f, 0.08979924f, -0.05513626f, 0.10739023f, 
    -0.00607607f, 0.04207545f, 0.09942014f, 0.06965853f, 0.12367756f, -0.06241834f, -0.01221655f, -0.12866797f, 
    -0.01219056f, 0.02304527f, 0.09927881f, -0.07503158f, -0.11615998f, -0.09646646f, -0.00241695f, -0.10208777f, 
    0.03574636f, -0.11021928f, -0.01088625f, -0.06222682f, -0.04719730f, 0.03281805f, 0.06323392f, 0.04240016f, 
    0.13816504f, -0.12481616f, 0.02135430f, -0.01800128f, 0.17976551f, 0.10613806f, 0.02465909f, 0.04130910f, 
    -0.02237735f, -0.09776612f, 0.01132762f, 0.15115516f, -0.03489786f, -0.02098718f, 0.03080291f, 0.03158216f, 
    0.24610394f, -0.41055948f, 0.12782100f, -0.02782182f, -0.03276435f, -0.04877434f, -0.02673151f, -0.11830235f, 
    -0.06141295f, 0.05371432f, 0.05047591f, 0.03153791f, -0.14680003f, 0.05622863f, 0.09923539f, 0.00334856f, 
    0.12194818f, 0.12631814f, -0.01224843f, 0.03554682f, 0.07201012f, 0.06599768f, -0.09926063f, -0.09471180f, 
    0.02885728f, -0.02814935f, -0.09763312f, -0.01427142f, 0.11063918f, 0.08878465f, 0.08073713f, 0.00979674f, 
    -0.07157529f, 0.03965301f, -0.01939063f, -0.03811251f, 0.15271302f, 0.01828652f, 0.09049790f, -0.12457782f, 
    0.06154895f, -0.04843114f, 0.03672916f, 0.02893933f, 0.15413977f, -0.03381807f, -0.01156709f, 0.02952680f, 
    -0.03378423f, -0.00587182f, 0.23147106f, 0.11792485f, 0.14280973f, 0.00632764f, -0.04479823f, -0.02557610f, 
    0.04165880f, 0.12485290f, -0.06308473f, 0.02581965f, -0.11234092f, -0.07454274f, -0.03895249f, 0.11991815f, 
    0.04185712f, 0.04439485f, 0.04627255f, -0.06410201f, -0.05431644f, 0.04989640f, 0.06877029f, -0.09146986f, 
    0.14671510f, -0.16970755f, -0.01451260f, 0.19083722f, 0.01026151f, 0.10687740f, 0.08878405f, -0.15019031f, 
    0.16562250f, 0.08325899f, 0.02825815f, 0.12897420f, 0.08756677f, 0.28828025f, -0.19102718f, 0.08156979f, 
    0.07413551f, 0.13032818f, -0.16816667f, 0.04085376f, 0.03689832f, 0.07426978f, 0.09802754f, -0.04800911f, 
    -0.33827284f, 0.04610449f, -0.04950944f, -0.18467569f, -0.13603714f, -0.05140777f, 0.00651376f, 0.01336162f, 
    -0.06366823f, 0.09873740f, -0.00231268f, 0.14886825f, 0.01905180f, 0.06230557f, -0.04116806f, -0.12744050f, 
    -0.11564266f, 0.13060032f, -0.01737777f, 0.00011328f, 0.00682480f, -0.01818551f, 0.04895526f, -0.05527402f, 
    0.15188919f, 0.34074560f, 0.18566045f, 0.27315840f, -0.01622161f, 0.05017040f, 0.06400895f, 0.09523742f, 
    -0.01223912f, 0.05414539f, 0.02272714f, 0.06385083f, -0.18277948f, 0.10858987f, 0.04674553f, 0.21965797f, 
    0.07261086f, -0.12113850f, -0.03392905f, 0.08615133f, -0.05828228f, 0.10877363f, 0.00553828f, -0.12384362f, 
    0.19750938f, -0.14441948f, 0.22513415f, 0.23011087f, -0.03418005f, 0.15506989f, 0.06217052f, 0.07485691f, 
    -0.13898668f, 0.03374476f, 0.00548619f, 0.06994713f, 0.22812283f, 0.17305267f, 0.10100286f, -0.13305695f, 
    0.07562105f, -0.01651402f, 0.13528752f, -0.03683744f, -0.02288775f, -0.04002940f, 0.04342522f, -0.11934587f, 
    0.10797828f, 0.07784913f, 0.15098108f, 0.17793569f, 0.05203145f, -0.03402225f, -0.01118336f, -0.11999616f, 
    0.08905013f, 0.07247381f, 0.02567182f, -0.06713787f, 0.13704765f, 0.00457148f, 0.06431296f, 0.21780331f, 
    -0.14143768f, -0.00937668f, -0.00604305f, 0.03561040f, -0.03107429f, -0.21084590f, 0.05540301f, 0.09491574f, 
    -0.03258555f, -0.12238951f, 0.10770728f, -0.24077389f, 0.01590071f, 0.00938819f, 0.02069797f, -0.00865707f, 
    -0.06543819f, 0.05403280f, -0.11792784f, 0.00966201f, -0.21710265f, -0.13125610f, 0.19687027f, 0.06268539f, 
    0.10628213f, 0.04882656f, 0.02873348f, 0.06311135f, -0.02230753f, 0.02423094f, -0.10858773f, -0.03589164f, 
    -0.10129710f, 0.14368699f, -0.19695230f, -0.13894838f, -0.03926051f, -0.08787511f, 0.04837399f, 0.03990739f, 
    0.01031056f, 0.06588490f, -0.02999153f, 0.03416532f, -0.12931968f, 0.03553118f, 0.05958658f, -0.20930183f, 
    0.13595593f, -0.01909067f, -0.02284240f, 0.02765919f, -0.06343614f, -0.00442373f, -0.01371421f, 0.05010815f, 
    -0.24701798f, 0.07621443f, 0.17151889f, 0.02773263f, 0.07502109f, 0.00994975f, 0.03187367f, 0.16890924f, 
    0.03770847f, -0.03517705f, 0.01903759f, -0.03367495f, 0.01264052f, -0.03513343f, -0.10723196f, 0.12951307f, 
    -0.01360512f, 0.15244211f, 0.01641148f, -0.07581540f, -0.00395526f, 0.00060844f, -0.03047763f, 0.15253408f, 
    0.05011552f, -0.04971132f, 0.10053458f, 0.02328685f, 0.06725346f, -0.06944567f, 0.13407592f, -0.01447901f, 
    0.04517659f, 0.08936609f, 0.00139192f, 0.10142827f, 0.06164824f, 0.02449572f, -0.16204017f, 0.30212900f, 
    0.08018994f, 0.07394479f, -0.01251634f, 0.08276049f, 0.10942186f, 0.13498148f, 0.06157075f, -0.03876258f, 
    -0.04046157f, 0.00261022f, 0.00638933f, 0.11379184f, 0.06167113f, -0.05812277f, -0.02149034f, 0.10491259f, 
    -0.00128407f, -0.00154340f, 0.06584385f, 0.08350972f, -0.34416482f, -0.08775742f, -0.07311004f, 0.02964727f, 
    -0.07035739f, 0.02221489f, 0.02555621f, -0.20251170f, 0.00513263f, 0.00184047f, 0.08963499f, 0.03754400f, 
    0.01550984f, 0.29883546f, 0.23015046f, -0.17021102f, 0.03087037f, 0.14633885f, -0.03049167f, 0.01846993f, 
    0.04674328f, -0.07856929f, 0.09268549f, 0.05420173f, -0.03237969f, 0.06304239f, 0.00226028f, 0.15362719f, 
    0.11757489f, -0.08009338f, 0.09965966f, 0.06856545f, -0.00453677f, 0.08864640f, 0.02140009f, 0.01808153f, 
    -0.08517808f, -0.09684154f, 0.04658011f, -0.05076712f, -0.02295407f, -0.03570146f, -0.01673361f, 0.10310622f, 
    0.04961272f, 0.01779544f, -0.06977113f, -0.00724256f, -0.20069492f, 0.13013528f, 0.06179595f, -0.18855764f, 
    0.09614043f, -0.02539858f, 0.05669470f, -0.00130071f, 0.11895644f, -0.00366745f, -0.06359436f, 0.11059802f, 
    -0.23608008f, 0.14494185f, 0.03810216f, 0.18980736f, 0.17057909f, -0.03711693f, 0.05747753f, -0.10942911f, 
    0.01552953f, 0.08104822f, 0.02543204f, 0.02566844f, 0.08438496f, -0.01249318f, 0.20386480f, 0.15116021f, 
    0.00385491f, 0.01351691f, 0.09565471f, -0.02297427f, 0.04174158f, 0.06991541f, -0.05795596f, 0.12361740f, 
    -0.09155257f, 0.18660054f, 0.02178510f, -0.08993863f, 0.09059046f, -0.10743548f, -0.03025221f, 0.12462825f, 
    0.15775351f, 0.07753871f, -0.07037499f, -0.08053398f, 0.00097444f, -0.04598487f, 0.12764470f, 0.10461970f, 
    0.03045041f, 0.02014782f, 0.09092511f, 0.01463857f, -0.09666535f, 0.04217755f, 0.06917519f, -0.06087201f, 
    0.00410078f, 0.02881268f, 0.00113655f, -0.04131937f, 0.00135731f, 0.05098829f, 0.04929677f, -0.02223087f, 
    0.08838709f, -0.07183920f, -0.01832328f, 0.07601293f, -0.54006135f, -0.01170204f, -0.12312701f, -0.09016667f, 
    0.02255268f, 0.07181121f, 0.08865080f, 0.09254009f, -0.09503289f, -0.05391655f, -0.03269843f, 0.01998182f, 
    -0.04532943f, 0.05012002f, -0.08043936f, 0.08235964f, 0.06977615f, -0.01782500f, -0.01279386f, 0.10864061f, 
    0.06367923f, -0.10465859f, 0.07007252f, -0.06274883f, 0.02390365f, -0.04131194f, -0.11932176f, -0.03108593f, 
    0.03709502f, 0.11760984f, -0.00912999f, -0.10905769f, -0.09461506f, 0.03304369f, -0.04965324f, 0.11413553f, 
    0.06801170f, 0.12471411f, 0.05292548f, -0.01904534f, 0.11219395f, 0.05742765f, 0.00881186f, -0.00899798f, 
    0.01694456f, -0.12073211f, 0.07528154f, 0.11664631f, -0.07610442f, -0.06167286f, -0.06428856f, 0.09153280f, 
    0.02838250f, 0.11456989f, 0.00653555f, 0.07538012f, -0.02336223f, -0.04605974f, -0.02663109f, -0.07453670f, 
    -0.05981002f, -0.07953800f, -0.07015795f, -0.06220932f, -0.00909017f, -0.06662642f, -0.03882362f, 0.01599687f, 
    -0.01772488f, -0.03262378f, 0.01446742f, -0.02218174f, 0.00494803f, -0.01114327f, 0.03235113f, 0.00450161f, 
    0.00102660f, 0.05943295f, 0.03187276f, 0.03912415f, -0.00352220f, -0.03530832f, -0.00703226f, 0.02872471f, 
    0.00747246f, 0.01767508f, -0.01219089f, 0.00477883f, -0.03253803f, 0.03214698f, -0.06150179f, -0.02250296f, 
    0.02545084f, -0.01389798f, 0.01419663f, -0.00790593f, 0.05038911f, 0.05637514f, 0.05508972f, -0.02950573f, 
    0.04255564f, -0.01959392f, 0.04030116f, -0.06917775f, -0.05832366f, -0.07958946f, -0.06945048f, -0.01079771f, 
    -0.06683879f, -0.04688398f, 0.04848215f, -0.06412912f, -0.03874123f, -0.02802222f, 0.00464020f, 0.03617867f, 
    -0.00549996f, -0.04262036f, -0.01230634f, 0.04561201f, -0.06299847f, -0.03804312f, 0.04378043f, 0.06872793f, 
    -0.01303790f, 0.06450147f, -0.03198421f, -0.07237080f, 0.06329588f, 0.04567987f, 0.02936747f, -0.00354544f, 
    -0.03813884f, 0.04983211f, 0.01199599f, -0.01637905f, 0.02285030f, 0.03674757f, -0.03015844f, -0.02100557f, 
    0.03021658f, -0.01398381f, -0.05396612f, -0.00465780f, -0.00073953f, 0.00657791f, 0.00237896f, -0.05796955f, 
    0.00761596f, 0.02308350f, -0.06318362f, 0.05075909f, -0.02656275f, 0.04851799f, 0.05124086f, -0.03975209f, 
    -0.00075551f, -0.05024234f, -0.01480198f, -0.01054226f, 0.05299787f, -0.01423761f, -0.04414387f, 0.00163128f, 
    0.01076973f, 0.02083364f, 0.00428228f, 0.04863007f, -0.02752715f, 0.05269570f, -0.00000711f, 0.03730832f, 
    0.00868123f, -0.01757290f, -0.06241887f, -0.06546509f, -0.06177381f, -0.01767676f, -0.02976281f, -0.00015383f, 
    -0.02669744f, -0.04273756f, -0.02500896f, 0.02955052f, 0.00008763f, -0.03139428f, -0.03080312f, -0.07015751f, 
    -0.06613373f, 0.00091134f, -0.04690547f, -0.05709713f, 0.03832409f, -0.04721601f, -0.07943521f, -0.02004888f, 
    -0.04743117f, -0.00277142f, -0.04844142f, 0.00829462f, 0.04646630f, -0.01604296f, -0.03307423f, -0.00226914f, 
    0.02884065f, -0.04130772f, -0.00291074f, 0.02870303f, -0.01686331f, 0.00387388f, -0.02298268f, -0.04428599f, 
    -0.01897250f, -0.01735278f, 0.04699532f, 0.01718204f, 0.04808887f, -0.07431272f, 0.05924092f, -0.06516851f, 
    0.07055687f, -0.00972717f, 0.03433356f, 0.00405366f, -0.05319821f, 0.02916779f, -0.03675324f, 0.03151203f, 
    0.00520599f, -0.02909594f, -0.03754068f, 0.01898932f, -0.03510360f, -0.07234064f, -0.00852115f, -0.00352956f, 
    0.04807501f, 0.01440082f, 0.05107293f, 0.02488242f, -0.04468314f, 0.03196825f, -0.06114982f, -0.00529468f, 
    0.03776793f, -0.05389031f, 0.06365895f, -0.04059954f, -0.05489467f, -0.02558617f, -0.06004918f, 0.04558059f, 
    -0.09886348f, 0.13405930f, -0.12074970f, -0.07944556f, -0.11265696f, 0.03417683f, 0.03850678f, 0.00321125f, 
    -0.03689286f, -0.06526930f, -0.03961897f, -0.00302433f, 0.08587566f, -0.06753869f, -0.12709990f, -0.20490110f, 
    0.03751741f, 0.09720892f, -0.00886257f, -0.10818651f, -0.02940793f, -0.16657650f, 0.04037942f, 0.00997320f, 
    -0.22991762f, 0.15335880f, 0.31008530f, 0.17601596f, -0.07755527f, 0.13647126f, 0.10866509f, 0.07335144f, 
    -0.00678748f, 0.10925267f, 0.01035805f, 0.04169483f, -0.27600944f, -0.07778124f, 0.13678697f, 0.12677151f, 
    0.00274989f, -0.02995387f, 0.06158034f, -0.00000050f, 0.06324654f, 0.10865653f, 0.05182553f, -0.02411471f, 
    -0.21981953f, -0.43228444f, 0.07968951f, 0.10410009f, -0.09067544f, 0.06149226f, 0.08834488f, -0.04484406f, 
    0.00171177f, 0.00955922f, 0.09011447f, -0.12685096f, 0.22256869f, 0.15806781f, -0.24250223f, -0.14969921f, 
    -0.00276143f, 0.06846980f, -0.01991930f, 0.02214102f, 0.03443617f, -0.01794454f, 0.15573989f, 0.04777751f, 
    -0.07745884f, -0.17504218f, -0.01964245f, 0.17870596f, 0.10435623f, 0.07697356f, -0.00072251f, -0.04468975f, 
    0.09058116f, -0.00580058f, 0.06599750f, -0.02906138f, 0.28602156f, -0.01793730f, 0.18190899f, 0.04735574f, 
    -0.09458461f, 0.02002961f, 0.04578074f, 0.02199266f, -0.11615827f, -0.04795155f, 0.05706070f, 0.13397272f, 
    -0.11958953f, 0.11019245f, 0.04856131f, -0.19806774f, 0.08594816f, -0.04978174f, 0.00205162f, -0.01097521f, 
    0.10106912f, 0.12326872f, -0.00672043f, 0.09572616f, -0.14054050f, 0.01761602f, 0.16125017f, 0.03547588f, 
    0.05761661f, 0.12851776f, -0.00250448f, 0.06864264f, 0.11507506f, 0.08698954f, 0.05386204f, 0.05107781f, 
    0.00684014f, 0.12696484f, -0.06372336f, -0.18587162f, 0.03720832f, -0.03868066f, 0.07161131f, 0.03089648f, 
    0.01777737f, 0.05706360f, 0.03465603f, 0.04253182f, -0.02328323f, 0.20053062f, -0.16739333f, -0.33871809f, 
    -0.05019635f, 0.06450529f, -0.09765021f, 0.09751248f, -0.05584463f, 0.01085351f, -0.11796068f, 0.01566233f, 
    -0.21796261f, -0.05300320f, 0.17376104f, -0.14769414f, 0.04305503f, 0.08407498f, 0.16714698f, 0.16749339f, 
    0.08370645f, 0.03809059f, -0.02979228f, 0.09342527f, 0.14366174f, -0.06043143f, 0.01370671f, 0.12978128f, 
    -0.06115564f, 0.01304135f, 0.02634165f, -0.03416486f, 0.02954283f, 0.03559101f, -0.16377477f, 0.08722370f, 
    0.10204966f, 0.04371280f, 0.02042164f, -0.16319881f, 0.02850061f, -0.02593664f, 0.03480725f, -0.06740928f, 
    0.03156708f, 0.13365376f, -0.02088118f, 0.07700676f, 0.00233285f, -0.00128363f, 0.11363369f, 0.09468166f, 
    0.16898666f, 0.11950811f, -0.06379479f, 0.00403037f, 0.00889380f, -0.05828900f, -0.03903305f, -0.04647780f, 
    -0.04392858f, 0.31983396f, 0.13072403f, -0.16056250f, -0.09257293f, 0.00121087f, -0.00556470f, 0.16954191f, 
    -0.03773779f, 0.02448691f, 0.00269106f, 0.18746622f, -0.41346100f, -0.67858255f, -0.28308004f, -0.26470664f, 
    -0.10991512f, -0.14630890f, -0.12329686f, 0.04090521f, -0.02020772f, 0.08079133f, 0.05554937f, 0.00244609f, 
    0.00853135f, -0.04697472f, 0.34357032f, 0.28530589f, 0.01850829f, -0.03093090f, -0.02642201f, -0.05182730f, 
    -0.00795094f, -0.08858123f, 0.00437644f, 0.04661375f, -0.17138115f, 0.03573962f, -0.00719603f, 0.31695330f, 
    0.09106492f, 0.01633388f, -0.11898642f, 0.11850113f, 0.06555559f, 0.04137096f, -0.02426017f, -0.03701825f, 
    -0.18611512f, -0.22097051f, -0.16460715f, 0.27048224f, -0.26788941f, 0.06330609f, 0.05498239f, 0.00231266f, 
    -0.05703355f, 0.00206630f, 0.02152586f, -0.16139339f, 0.15380070f, 0.15191551f, -0.08869577f, -0.26098680f, 
    0.08762807f, 0.07203054f, 0.02615364f, -0.10704626f, 0.03148627f, 0.19404963f, 0.15217857f, 0.10247616f, 
    -0.18800522f, -0.05380172f, -0.27131462f, -0.32220480f, 0.08186717f, 0.05048786f, -0.00006061f, -0.08034311f, 
    0.00090970f, -0.03282540f, -0.02286181f, -0.07015349f, 0.05959047f, 0.02231875f, -0.03485031f, -0.00301297f, 
    -0.10525798f, 0.19698942f, -0.00192070f, 0.09206556f, -0.00800045f, 0.09164976f, 0.05063352f, 0.17569901f, 
    0.40511984f, 0.20435902f, 0.41836786f, -0.32335573f, 0.02494554f, 0.11792713f, -0.03479082f, 0.01517737f, 
    0.15861900f, 0.05429700f, 0.10954788f, 0.06626388f, 0.25433579f, -0.03637658f, 0.16518024f, 0.19291928f, 
    0.08788664f, 0.13527332f, -0.03698641f, 0.00977206f, 0.07208993f, -0.03301224f, 0.03250712f, -0.00247426f, 
    -0.10979411f, 0.42237514f, 0.21079838f, 0.07370150f, 0.00722713f, -0.02792600f, -0.09042162f, -0.11665897f, 
    0.02482907f, 0.12398601f, 0.02592364f, 0.09223117f, -0.26610586f, -0.57010674f, -0.31550738f, -0.28326210f, 
    0.01751428f, -0.05615398f, 0.04464064f, -0.05854390f, 0.00369319f, -0.03792763f, 0.03817481f, -0.10058713f, 
    -0.09408823f, 0.03647670f, 0.12729786f, 0.05135610f, -0.00642729f, -0.03948962f, -0.07908747f, 0.07530436f, 
    -0.00714348f, -0.18143222f, -0.06550200f, -0.06292643f, -0.04694691f, -0.01652182f, -0.00091167f, 0.08624487f, 
    -0.07755642f, -0.03612453f, -0.03119040f, -0.09580562f, 0.13359274f, 0.04038420f, 0.02508120f, 0.09480671f, 
    -0.11366276f, 0.17441596f, 0.20923513f, -0.07056460f, 0.10279825f, -0.17608908f, -0.04227540f, -0.07213229f, 
    0.08258325f, -0.02658321f, -0.08754884f, 0.09134632f, -0.25522465f, -0.13818249f, -0.08729057f, 0.17248513f, 
    0.09745854f, 0.03299601f, 0.00685352f, 0.16642943f, 0.03971822f, -0.01646867f, 0.03698555f, -0.06377109f, 
    0.02704656f, 0.04743753f, 0.01645291f, 0.04764729f, 0.01520705f, -0.02684650f, 0.05439929f, -0.08065827f, 
    0.01563730f, -0.03121217f, -0.05471731f, 0.00242142f, 0.00349990f, -0.01245671f, 0.01429266f, -0.06368678f, 
    0.05508966f, 0.05519750f, 0.02739068f, -0.00737921f, -0.00246506f, -0.06371026f, -0.03150647f, 0.03397291f, 
    0.02436722f, -0.04931224f, -0.04450487f, -0.07951932f, 0.00353839f, 0.01729488f, -0.03690924f, 0.03996237f, 
    -0.01430126f, -0.07132749f, -0.04933622f, -0.05619716f, 0.00711155f, -0.04235465f, 0.05466070f, -0.05745017f, 
    -0.00031236f, -0.03901419f, 0.01774543f, -0.03640530f, 0.01050360f, -0.04506031f, -0.04453089f, 0.01407577f, 
    -0.05640977f, 0.02304572f, -0.07818305f, -0.06904036f, 0.05594265f, -0.05371543f, -0.05247122f, -0.00783231f, 
    -0.04050955f, 0.05362494f, -0.06420787f, 0.01765469f, 0.00418164f, -0.06446686f, -0.06163071f, 0.05077829f, 
    -0.03395133f, -0.04174526f, 0.03278647f, -0.07017560f, -0.03809848f, 0.04146994f, -0.05604458f, -0.07453256f, 
    0.03842021f, -0.03601437f, -0.06347157f, -0.05554590f, -0.02917417f, -0.05699449f, -0.06107305f, 0.01391494f, 
    -0.01270071f, 0.01145621f, -0.06368821f, 0.04019706f, -0.05323463f, -0.05166939f, 0.00729630f, -0.00830817f, 
    -0.05909934f, -0.03738475f, -0.05907295f, 0.05325055f, 0.01598435f, -0.07351086f, 0.00270628f, 0.02907293f, 
    0.04073100f, 0.04272944f, -0.01015104f, -0.03484414f, 0.02715245f, 0.03411512f, -0.05832319f, 0.03729032f, 
    -0.06317641f, -0.02903494f, 0.06074988f, 0.06338272f, -0.07228199f, -0.07458477f, -0.01145311f, 0.00487613f, 
    0.04209700f, -0.03851887f, -0.00472487f, -0.08146988f, -0.07804956f, -0.05481006f, 0.05000117f, 0.04050370f, 
    0.00629634f, 0.00771934f, 0.05363671f, -0.03825866f, -0.00009696f, 0.05380674f, 0.02405013f, 0.01942342f, 
    0.03561092f, -0.08133278f, -0.02914436f, -0.00868616f, 0.04119443f, -0.04220599f, -0.03705940f, 0.00843084f, 
    -0.06825028f, 0.01891811f, -0.01523817f, -0.00959271f, -0.04667388f, 0.04632800f, -0.07586555f, -0.05657461f, 
    0.02214895f, 0.01772110f, -0.02643354f, -0.02508246f, -0.05550058f, 0.01654297f, -0.05523057f, -0.00117855f, 
    -0.06402709f, -0.05208649f, -0.06861429f, 0.01345330f, 0.04289410f, -0.06147196f, 0.06034347f, 0.00396128f, 
    -0.03840281f, -0.02327586f, 0.04106330f, -0.05966312f, -0.05609949f, 0.03209704f, 0.01276249f, -0.03673475f, 
    -0.02731000f, -0.03370327f, 0.03062093f, 0.03375721f, -0.04834459f, -0.01644195f, -0.06206580f, 0.02979502f, 
    0.04317064f, 0.02885108f, -0.02323896f, -0.01204529f, -0.07096419f, 0.04057954f, 0.01023096f, -0.01825893f, 
    0.00472304f, -0.00131570f, 0.01906840f, -0.04976058f, 0.02215528f, -0.02768923f, 0.00141809f, 0.00490364f, 
    0.19051968f, -0.02396241f, -0.09252675f, 0.00148201f, -0.10553242f, 0.03133330f, -0.04439513f, -0.19796614f, 
    -0.06497513f, 0.07401985f, -0.03826103f, -0.09274442f, 0.08515518f, 0.25003234f, 0.06636670f, -0.26892513f, 
    0.23123352f, 0.08238436f, 0.14674020f, 0.13523103f, 0.07674888f, 0.07606859f, 0.12982681f, -0.02102568f, 
    -0.07264194f, 0.16909781f, -0.12012164f, 0.20900805f, -0.17188661f, -0.04686576f, 0.03982763f, -0.02000233f, 
    -0.00360883f, -0.00542651f, -0.00370670f, -0.03572593f, -0.08189520f, 0.08929209f, 0.02704076f, 0.08261355f, 
    -0.09851640f, -0.01143483f, 0.05466615f, -0.00518248f, 0.06467751f, -0.14386186f, -0.05491900f, 0.07448875f, 
    0.15048268f, -0.08669973f, 0.31081513f, -0.07242856f, 0.13133238f, -0.02266359f, -0.03253653f, -0.11942755f, 
    0.02750644f, -0.20355882f, 0.05601696f, 0.07980119f, 0.06708629f, -0.03881751f, 0.16668311f, 0.15512474f, 
    -0.04739190f, 0.01292091f, 0.02259530f, -0.10447114f, 0.09446462f, -0.02583391f, 0.12277558f, 0.04164787f, 
    0.15276827f, 0.04390726f, 0.24710609f, 0.10587658f, -0.26571244f, -0.01670224f, 0.07287889f, 0.05761196f, 
    -0.07334704f, 0.07165754f, 0.08894596f, 0.03677239f, 0.02642289f, -0.04403034f, 0.07156973f, -0.18998389f, 
    -0.08925262f, 0.11023173f, -0.09164365f, -0.10670009f, -0.01447998f, -0.04864828f, 0.04020911f, 0.05969023f, 
    -0.36513159f, -0.10629517f, 0.11433045f, 0.10323770f, -0.04142883f, -0.26421121f, -0.08930866f, -0.10013975f, 
    -0.14168413f, 0.13542697f, 0.01656994f, -0.05075220f, -0.08819234f, -0.14595276f, 0.02221126f, 0.04871974f, 
    -0.04477618f, -0.07501788f, -0.14311765f, 0.01557208f, 0.13525169f, 0.12892525f, -0.02761955f, -0.08401367f, 
    -0.10214751f, -0.15420349f, 0.03065830f, 0.01018258f, -0.03114117f, -0.14231440f, -0.07784554f, -0.12967052f, 
    -0.00097894f, 0.00043484f, -0.11197954f, 0.01246757f, 0.29802698f, 0.07750762f, 0.02738619f, -0.08521323f, 
    0.15352824f, 0.24174379f, 0.04549339f, -0.00942873f, 0.05666322f, 0.12833515f, 0.10821892f, 0.14288554f, 
    0.12763765f, 0.04282984f, 0.29927769f, -0.38245091f, -0.11572183f, -0.08647738f, -0.17320330f, 0.05652667f, 
    0.11040990f, -0.11516697f, 0.02235455f, -0.04702008f, 0.51371008f, 0.09095500f, -0.11647198f, -0.00132560f, 
    -0.01133666f, 0.02649451f, -0.07881365f, 0.04421385f, 0.00417611f, 0.00401361f, -0.04326473f, -0.06144841f, 
    -0.12836111f, -0.00733075f, 0.02205501f, 0.30035716f, -0.24577589f, 0.07398692f, -0.08455198f, -0.04816909f, 
    -0.05255839f, -0.03077361f, -0.08825494f, 0.07843655f, -0.09544044f, 0.14248255f, 0.20713489f, -0.16938864f, 
    0.05271357f, 0.03689831f, -0.17306885f, 0.10336421f, 0.02422286f, 0.03501315f, 0.03778623f, 0.07896689f, 
    -0.33908996f, 0.11096058f, -0.06683052f, -0.16207898f, -0.15109478f, -0.02473452f, -0.04697884f, 0.09048005f, 
    -0.03583041f, 0.04661562f, 0.01163557f, 0.13857806f, 0.04582304f, 0.04016136f, 0.01014819f, -0.17458238f, 
    -0.11519518f, 0.09285747f, 0.07200057f, -0.00056936f, 0.10122977f, -0.00643930f, 0.02198236f, 0.03974970f, 
    0.10821457f, 0.24516012f, 0.22157146f, 0.19256988f, -0.11528658f, 0.08061646f, 0.11328941f, -0.00772288f, 
    0.02181647f, 0.12229049f, 0.03830397f, 0.09478822f, -0.12508149f, 0.01195201f, 0.08724494f, 0.13130787f, 
    0.11895911f, -0.10117982f, -0.04688799f, 0.05603622f, -0.03003690f, -0.06881278f, -0.00272715f, -0.07773227f, 
    0.18476273f, -0.21134390f, 0.22118552f, 0.19773236f, 0.03056202f, 0.15546881f, -0.00040609f, 0.04655531f, 
    -0.03950855f, -0.03737457f, 0.10378697f, 0.10364783f, 0.20735234f, 0.15408815f, -0.06099372f, -0.05452587f, 
    -0.03693798f, 0.05248557f, 0.10925339f, 0.02048986f, -0.04914157f, -0.06353983f, -0.08066081f, -0.14477360f, 
    0.00658955f, 0.07663792f, 0.11589296f, 0.18956588f, 0.11847350f, 0.04069304f, -0.06434079f, -0.11276028f, 
    -0.03298930f, 0.12771587f, 0.02293790f, -0.08065704f, 0.17778821f, 0.03926909f, -0.07959730f, 0.17103155f, 
    -0.02921935f, 0.05355756f, -0.01156484f, 0.09247202f, -0.02457047f, -0.24419275f, 0.02865585f, 0.10981626f, 
    -0.00506346f, -0.03926327f, -0.01961182f, -0.16095717f, 0.06629886f, -0.01511060f, 0.00015193f, -0.00599000f, 
    0.00651957f, 0.06226923f, -0.07270914f, 0.05407727f, -0.02508469f, -0.11148901f, 0.24150135f, 0.03676467f, 
    0.01249531f, -0.04353241f, 0.10301429f, -0.04247945f, -0.01037938f, -0.10324686f, -0.09995318f, -0.12869184f, 
    0.01410921f, 0.23548780f, -0.09025525f, -0.09675869f, 0.04784579f, -0.12989259f, -0.01971447f, 0.04200044f, 
    -0.03221367f, 0.05622307f, -0.10026003f, -0.01428840f, -0.12931460f, 0.09489703f, 0.07271400f, -0.18342981f, 
    0.16359919f, 0.08017867f, -0.10038284f, 0.08218432f, -0.15833925f, 0.08517374f, 0.05568861f, 0.02047735f, 
    -0.23766623f, -0.01048582f, 0.20072736f, 0.00023689f, 0.09667796f, 0.00871725f, 0.06699960f, 0.04808725f, 
    -0.01447115f, 0.05123045f, -0.05434029f, -0.04445368f, 0.16882932f, 0.00559160f, 0.01044988f, 0.08041842f, 
    0.07932522f, 0.04954874f, 0.10816838f, -0.03515380f, -0.01270273f, 0.08665495f, -0.07048006f, 0.15305807f, 
    0.09257735f, 0.06484199f, -0.07265825f, -0.09555841f, -0.00686073f, -0.04761720f, 0.04752662f, 0.04638373f, 
    -0.04608113f, 0.06841252f, -0.00947351f, 0.05578865f, 0.08759402f, 0.03795452f, -0.09299181f, 0.14045919f, 
    0.09754334f, 0.04892206f, -0.04693126f, -0.03580524f, -0.00094258f, 0.03272577f, 0.10517637f, -0.01101343f, 
    -0.15047409f, -0.17753272f, -0.08312009f, 0.16849358f, 0.02547463f, -0.11827518f, 0.12901169f, -0.02357065f, 
    0.02226800f, -0.10934019f, -0.04927772f, 0.07990756f, -0.13792366f, -0.04171770f, -0.15850656f, -0.12506050f, 
    -0.11451498f, -0.10049684f, 0.00329308f, -0.24767800f, 0.09453298f, -0.04201850f, 0.11992460f, 0.02850338f, 
    0.48180053f, 0.12469897f, 0.01305353f, 0.08131479f, 0.04961594f, 0.16120075f, -0.12315634f, -0.01195017f, 
    0.11070006f, 0.04629932f, 0.13980706f, 0.07529082f, 0.18001969f, 0.02169942f, -0.15762445f, -0.06500240f, 
    0.02870243f, 0.06548306f, 0.18397492f, -0.05227301f, -0.01047205f, 0.02386418f, -0.04653683f, 0.06324615f, 
    -0.09039923f, -0.00536148f, 0.02661077f, -0.06824768f, -0.17732982f, 0.00198112f, 0.01896525f, 0.10278772f, 
    0.10037327f, 0.02809833f, 0.00615978f, 0.02353469f, -0.26801047f, 0.04072059f, 0.13016731f, 0.01228582f, 
    0.05470347f, -0.01460437f, 0.21280080f, -0.05471146f, 0.00019664f, 0.03299588f, 0.07226832f, 0.12587452f, 
    -0.08482661f, -0.02225284f, 0.07859658f, 0.11576396f, 0.21583717f, -0.09096215f, 0.09248924f, 0.04760481f, 
    0.03940413f, -0.09498490f, 0.10168803f, 0.13402043f, 0.18612397f, -0.00497623f, 0.19413212f, 0.07476790f, 
    0.00601085f, 0.07598040f, -0.03005644f, 0.10570724f, 0.06073367f, 0.08087518f, -0.04122308f, 0.14660253f, 
    0.08588356f, -0.03021632f, 0.04328474f, 0.19192460f, -0.03343407f, -0.14356104f, 0.03521357f, 0.08872682f, 
    0.09891219f, 0.01930228f, 0.14312248f, 0.01552597f, -0.34204409f, 0.12072739f, 0.22147596f, 0.07212486f, 
    0.10095280f, -0.01255869f, -0.03839883f, 0.14556904f, 0.05654038f, 0.04305870f, 0.04348814f, -0.04722333f, 
    0.03105208f, -0.19018783f, 0.10474639f, 0.06123250f, -0.11387920f, 0.08121442f, 0.11588021f, 0.04058147f, 
    0.18488857f, -0.09715778f, 0.00331504f, -0.01199379f, -0.45164636f, -0.01505767f, -0.11843948f, -0.31268269f, 
    -0.07821157f, -0.05963686f, 0.03901006f, -0.08381713f, -0.00384537f, -0.14715096f, -0.08389912f, 0.02118661f, 
    0.10881768f, 0.09984803f, -0.05481185f, 0.09225847f, 0.04925963f, 0.06774797f, -0.01287817f, 0.12952863f, 
    0.08809437f, 0.01883151f, -0.00064425f, -0.07441973f, -0.06521524f, 0.01349544f, -0.01141394f, 0.00371503f, 
    -0.01833941f, 0.19999084f, 0.03682582f, -0.05851466f, -0.12617692f, 0.12785281f, -0.12050232f, 0.03334532f, 
    0.22067805f, -0.15084028f, 0.08930661f, 0.25226977f, -0.08141124f, 0.02497755f, 0.09801068f, 0.02761887f, 
    0.11471368f, -0.18513571f, 0.22460049f, 0.04548972f, -0.02414410f, 0.07655942f, -0.09250794f, -0.04970117f, 
    0.00704178f, 0.26153219f, -0.04696742f, 0.11552090f, 0.01108425f, 0.09499389f, -0.08132485f, 0.03039922f, 
    -0.07822168f, -0.12003564f, -0.11546357f, -0.03145508f, -0.10625964f, -0.02636760f, -0.04557577f, -0.09876309f, 
    0.04185678f, 0.12440817f, 0.13156009f, 0.12557037f, 0.05288550f, 0.00557882f, -0.07641653f, -0.20957595f, 
    -0.04779220f, -0.12632743f, 0.10159207f, 0.21678151f, 0.16151461f, 0.13194452f, -0.08112088f, 0.00321653f, 
    0.20836651f, 0.24963756f, -0.13183486f, 0.17537628f, -0.16646864f, 0.12091591f, 0.09521117f, 0.01290976f, 
    -0.12931184f, 0.23047374f, 0.10722198f, 0.06687406f, -0.10650186f, -0.07418629f, 0.16488568f, 0.17390350f, 
    -0.19564277f, -0.10693496f, -0.06453145f, 0.07823102f, -0.03462608f, -0.12568486f, 0.05473759f, 0.04826333f, 
    0.02974796f, -0.04340558f, 0.37098467f, 0.00279505f, -0.15956458f, 0.11592079f, -0.08683182f, 0.02896628f, 
    0.01066455f, -0.16005225f, 0.04168360f, 0.11022031f, 0.01917800f, -0.08270018f, 0.04729611f, 0.06117271f, 
    -0.03318860f, 0.03459506f, 0.03597506f, -0.14852467f, -0.00056784f, 0.00589318f, 0.03708093f, -0.03440784f, 
    0.04720597f, -0.02018708f, 0.23219061f, 0.23886469f, -0.06698813f, 0.04656891f, -0.06039339f, 0.00992414f, 
    0.01235440f, 0.09421740f, 0.00842463f, 0.10040020f, -0.05414754f, -0.16205554f, 0.05813903f, 0.15336105f, 
    -0.08058458f, 0.07506716f, -0.10431895f, -0.04426304f, -0.05775600f, -0.13745873f, -0.00559242f, 0.13536838f, 
    -0.29344061f, 0.02531293f, 0.07795873f, -0.06944080f, 0.15264139f, -0.13380922f, -0.13768357f, -0.15172477f, 
    -0.11565340f, 0.15609159f, -0.13676594f, 0.06468938f, 0.04027322f, 0.08033883f, 0.08458544f, 0.01140735f, 
    0.16059117f, -0.03171361f, -0.02476545f, -0.05955091f, 0.08320549f, -0.05167953f, -0.14171594f, -0.15203981f, 
    0.18215111f, 0.11551534f, -0.03046975f, 0.02490312f, 0.05758289f, -0.16687633f, 0.05038429f, -0.09742305f, 
    -0.08117819f, -0.20074235f, 0.00221361f, -0.06574681f, -0.02126899f, 0.06046210f, 0.04840313f, -0.26248631f, 
    0.02820620f, 0.04675714f, -0.00465152f, 0.12763762f, 0.00051875f, 0.09505438f, 0.01198148f, 0.05825862f, 
    0.23967226f, -0.04900679f, 0.31226709f, -0.22582801f, -0.19413172f, -0.11012808f, -0.08519513f, 0.04034372f, 
    0.02153550f, -0.09162411f, 0.01177830f, -0.12443505f, 0.20407085f, 0.13310252f, -0.07622927f, -0.00078970f, 
    0.10318191f, -0.00450948f, -0.01623523f, -0.03783196f, 0.09108018f, 0.08368020f, 0.01054105f, 0.07807870f, 
    -0.01235088f, -0.05828942f, -0.00842292f, 0.31212297f, -0.07740568f, 0.13304427f, 0.10133386f, 0.02883110f, 
    -0.00760613f, -0.00174084f, -0.08457453f, 0.16451561f, 0.17269798f, 0.06282604f, 0.13386650f, -0.12427790f, 
    -0.06753489f, 0.01003191f, 0.00496717f, -0.00958610f, 0.05003070f, 0.09784053f, 0.07465435f, 0.18176796f, 
    0.02165592f, 0.00014586f, -0.00972511f, 0.07090299f, 0.16779673f, 0.02459301f, -0.00384752f, 0.05731042f, 
    -0.05437304f, -0.02545992f, 0.04644018f, 0.02550154f, 0.30041054f, -0.22485124f, 0.05977428f, -0.13323431f, 
    -0.01883141f, -0.08576056f, 0.01034950f, 0.06858719f, -0.00281953f, 0.09098734f, -0.01632660f, 0.02599781f, 
    -0.00758227f, -0.29748741f, 0.08477637f, 0.02455606f, 0.08100301f, -0.06265888f, -0.05074121f, -0.00957150f, 
    0.07212442f, -0.08118536f, 0.04325361f, 0.13109082f, 0.19441631f, -0.08933444f, -0.02330302f, -0.01170804f, 
    0.17851153f, 0.06083275f, 0.02316031f, -0.08055143f, 0.11907363f, -0.02037859f, 0.04896192f, -0.03020319f, 
    -0.40452018f, -0.00968130f, -0.10872081f, -0.03393618f, -0.04426055f, 0.01885320f, -0.05257520f, -0.03514889f, 
    -0.01948606f, 0.08028387f, 0.11759755f, 0.07644007f, -0.02656212f, 0.04438053f, -0.12255196f, 0.03577116f, 
    -0.00150376f, -0.06187415f, 0.00807070f, 0.15571845f, 0.05546505f, -0.01039980f, 0.02404371f, 0.05492797f, 
    -0.12898624f, -0.11449315f, -0.12414367f, -0.20563515f, -0.05352111f, -0.07500048f, -0.03263250f, 0.06356584f, 
    0.02575510f, -0.10797095f, 0.09822769f, -0.00886081f, -0.04046507f, 0.14786941f, -0.00235774f, -0.12629506f, 
    0.14498782f, 0.03882927f, -0.01346258f, 0.01335670f, 0.09172694f, 0.09222263f, 0.01217617f, 0.00901374f, 
    0.46334675f, -0.09896480f, 0.07750536f, 0.06402963f, 0.08785316f, 0.10833880f, -0.00042649f, 0.02759055f, 
    0.05981796f, 0.03277859f, 0.11945402f, -0.02905745f, 0.24096768f, 0.11088853f, -0.15814599f, -0.02514846f, 
    0.07888190f, 0.05399316f, -0.02352727f, 0.07270086f, 0.12756111f, 0.00038030f, 0.13845310f, 0.04881954f, 
    0.14524516f, 0.06647689f, 0.13137829f, -0.00211272f, 0.05806263f, 0.05901277f, 0.02763324f, -0.02958088f, 
    -0.04356303f, 0.10463745f, 0.03568417f, -0.00347125f, 0.29669541f, -0.17383161f, -0.08198278f, -0.07237083f, 
    -0.12365799f, 0.05767189f, -0.05714685f, -0.05677612f, 0.10731766f, 0.08027580f, 0.00165041f, -0.01795339f, 
    -0.00001136f, -0.13202842f, -0.16745749f, -0.01429488f, -0.01818981f, 0.06604096f, -0.00241805f, -0.05157937f, 
    -0.02083465f, 0.05294364f, -0.03751287f, -0.08076798f, 0.21912968f, -0.12553173f, 0.06515326f, -0.03406355f, 
    0.05270766f, 0.03590687f, -0.00089730f, 0.17912282f, 0.11449967f, -0.00598319f, 0.16693455f, -0.06637437f, 
    0.05124040f, 0.06636674f, -0.17071258f, -0.36066958f, 0.02825988f, -0.09913290f, 0.00725848f, -0.05448434f, 
    0.02005122f, -0.06837086f, 0.03195201f, -0.07793195f, 0.12957965f, 0.16365345f, 0.14888886f, -0.02638997f, 
    0.00074809f, 0.02865150f, -0.04749706f, -0.00113284f, -0.00336583f, -0.01672683f, -0.01378259f, 0.00076338f, 
    0.12897663f, 0.16593705f, 0.03945743f, -0.15787309f, -0.03283494f, -0.00534186f, -0.00832324f, 0.06614133f, 
    0.03422097f, 0.00268530f, 0.00759951f, 0.06570563f, -0.29054859f, -0.05526825f, -0.09958370f, 0.11381237f, 
    0.10381190f, 0.11463318f, -0.08582797f, -0.10673047f, -0.03841057f, -0.06417524f, 0.04656566f, -0.05320142f, 
    -0.17323871f, 0.01838523f, 0.10012412f, 0.03385108f, 0.01476440f, -0.06146053f, 0.10310332f, 0.00587961f, 
    -0.04859271f, 0.05797942f, -0.01995453f, 0.04150967f, -0.02429898f, 0.00431448f, -0.00106315f, 0.14418523f, 
    0.01118167f, -0.03235841f, -0.05621045f, 0.05363301f, 0.03355396f, 0.11123569f, -0.09257825f, -0.14262621f, 
    -0.00784277f, 0.03887315f, -0.01701294f, 0.15449758f, 0.04907473f, 0.06065018f, 0.00040966f, -0.07173674f, 
    -0.08114284f, 0.01032308f, -0.09439058f, -0.10141607f, 0.17985466f, -0.08792215f, 0.10838060f, -0.06018047f, 
    0.02723646f, 0.10711545f, -0.12352315f, 0.01221350f, 0.03685481f, 0.07134133f, 0.10411511f, -0.05046346f, 
    0.16572417f, -0.01424434f, -0.02873430f, -0.04731599f, 0.01106562f, -0.03253552f, -0.08291577f, -0.15043089f, 
    -0.09855214f, 0.02784297f, 0.07627643f, -0.09781796f, 0.01420212f, -0.06706776f, -0.03697059f, 0.16107374f, 
    -0.06290368f, -0.07006814f, 0.07173619f, -0.09100155f, -0.20092015f, -0.03512740f, 0.01286321f, 0.08691060f, 
    0.06612136f, 0.02717977f, 0.11161574f, -0.12215070f, 0.02451948f, 0.06031053f, 0.00912489f, -0.07554449f, 
    0.09482707f, 0.01559917f, 0.08624775f, -0.08996784f, 0.09872852f, -0.03846952f, -0.07164913f, 0.06096845f, 
    0.05133459f, 0.04543693f, -0.01899409f, -0.05080523f, 0.09591074f, 0.05295457f, -0.04003937f, -0.04530447f, 
    -0.06067900f, 0.18360342f, -0.07988939f, -0.07639018f, -0.05118265f, 0.02726308f, 0.04364613f, -0.04935584f, 
    0.02749846f, 0.07869463f, -0.03792436f, 0.03186587f, 0.08323175f, -0.03223809f, -0.03490433f, 0.15446334f, 
    0.13323462f, 0.00601079f, 0.01152074f, -0.04720753f, -0.03410674f, -0.00597901f, -0.03956016f, -0.08893716f, 
    -0.10039768f, -0.02575856f, 0.06249525f, 0.11282685f, -0.10040281f, -0.04159919f, 0.13386293f, -0.12592635f, 
    0.00296717f, 0.06212571f, 0.00492036f, -0.01073000f, -0.26003125f, -0.03872192f, -0.15996572f, 0.10619294f, 
    -0.04491281f, -0.02090755f, -0.09052401f, -0.20121391f, 0.12281889f, 0.00423173f, -0.03738987f, 0.10901830f, 
    0.13868496f, 0.02920268f, 0.18528214f, 0.05729130f, 0.00976093f, -0.02487276f, 0.05723238f, 0.07037452f, 
    0.02096992f, -0.02950440f, -0.00328541f, 0.12744121f, 0.14907092f, -0.11489604f, -0.12370200f, 0.29970470f, 
    0.05651040f, 0.03639405f, -0.04865025f, 0.11962888f, -0.02231355f, 0.05178102f, 0.04505828f, -0.03760058f, 
    0.07597159f, 0.09512944f, 0.08452811f, -0.21691403f, 0.04669356f, -0.01493311f, 0.04536565f, 0.11786479f, 
    -0.02328164f, 0.02369056f, 0.08602428f, 0.05070884f, -0.21203355f, -0.20070674f, -0.07529667f, -0.00069822f, 
    -0.08291875f, 0.10385440f, -0.00134622f, -0.10401915f, 0.09958646f, -0.04202422f, 0.06378680f, 0.05182514f, 
    0.10101365f, -0.01378299f, 0.23912185f, -0.04561377f, 0.08513255f, -0.01970339f, -0.09307647f, 0.03021135f, 
    -0.04676339f, -0.04566379f, 0.14285736f, 0.02880354f, 0.14022236f, 0.22802866f, -0.17779164f, 0.02835420f, 
    0.12245626f, -0.11774666f, 0.04948713f, 0.12092213f, 0.06998902f, 0.08269492f, -0.11634788f, -0.04787112f, 
    -0.18729624f, -0.17314421f, -0.04589455f, 0.13621794f, -0.00649397f, -0.09036494f, -0.04397349f, 0.05946914f, 
    -0.02974753f, -0.01756212f, -0.09754664f, -0.06627771f, -0.15037236f, 0.09596519f, 0.10095618f, -0.26541054f, 
    0.16749351f, -0.05577214f, -0.05841852f, -0.00184819f, 0.07241882f, 0.03700302f, -0.02138573f, 0.03576322f, 
    -0.05813851f, 0.09180913f, -0.14786291f, -0.04150034f, 0.10384047f, -0.03140337f, -0.05651181f, -0.00670426f, 
    0.13803855f, -0.04640182f, 0.05556609f, 0.06719721f, 0.00486131f, 0.07611658f, -0.04938597f, 0.27105889f, 
    0.04337075f, -0.08895832f, 0.03196219f, 0.06407329f, -0.02778141f, 0.01808052f, 0.04554521f, 0.06295862f, 
    0.11885790f, 0.03487707f, 0.10048657f, -0.28706539f, -0.02978619f, -0.03753214f, 0.03851512f, 0.14879413f, 
    0.18009146f, 0.02331819f, 0.01606639f, -0.13292292f, 0.01122963f, -0.00590385f, 0.11852281f, 0.14687374f, 
    0.07569869f, -0.00993284f, -0.05011179f, 0.02938688f, -0.04910774f, -0.03614547f, 0.06318021f, -0.01746831f, 
    0.10811603f, 0.25458992f, -0.04068838f, -0.02208909f, 0.03074523f, 0.03761062f, 0.01725742f, -0.12374305f, 
    -0.00324998f, -0.11357901f, 0.05868233f, -0.01634499f, -0.30111647f, -0.03252592f, -0.08515432f, 0.18936948f, 
    0.08309331f, 0.00898780f, 0.08844683f, 0.01668031f, 0.00620089f, -0.04471694f, -0.00549641f, -0.05743387f, 
    -0.19314083f, 0.01633099f, -0.17051226f, 0.28548968f, 0.03349979f, 0.00217314f, -0.02588655f, -0.05279087f, 
    -0.01718384f, 0.00469888f, 0.05935492f, 0.03763474f, -0.33386880f, -0.11743002f, -0.09647559f, 0.17950717f, 
    -0.00927972f, 0.00261944f, 0.00709070f, -0.00383433f, 0.01330883f, -0.10295490f, 0.12566386f, 0.02129469f, 
    0.19651441f, 0.07978846f, 0.02098557f, -0.01318182f, 0.01944960f, 0.02142382f, 0.04549976f, -0.10784026f, 
    0.05225636f, -0.10345270f, 0.04783660f, 0.04007551f, 0.30050015f, 0.13733867f, -0.32026920f, 0.30538628f, 
    0.14186648f, 0.11811877f, -0.04524614f, 0.08716412f, 0.08010565f, 0.06843592f, 0.01756626f, -0.08576151f, 
    0.08251002f, -0.00169621f, 0.01484722f, -0.09092978f, 0.08281044f, -0.07694166f, -0.04858520f, 0.06482907f, 
    0.10878989f, 0.13491537f, 0.16773084f, 0.08096423f, 0.17897049f, 0.00218265f, 0.13963866f, 0.13710880f, 
    -0.00735722f, -0.00473892f, 0.12789716f, 0.24560751f, 0.04659462f, 0.03574445f, -0.12022488f, 0.01768876f, 
    -0.14942487f, -0.10148580f, -0.05001222f, -0.25771049f, -0.02050481f, 0.01129045f, 0.12254673f, -0.01655927f, 
    -0.04450756f, -0.02726539f, -0.03780921f, -0.02933127f, -0.18372236f, -0.07497091f, 0.09405068f, -0.09097312f, 
    0.19395062f, 0.01914360f, -0.06407039f, 0.06858034f, -0.07147476f, -0.17042120f, 0.04855192f, -0.19122525f, 
    0.32113728f, 0.13871554f, -0.07367647f, -0.04394399f, 0.07927061f, 0.16245872f, -0.05826378f, 0.03132110f, 
    0.10414215f, 0.00199880f, 0.02202817f, -0.04529674f, 0.07977694f, 0.02697356f, -0.07336070f, 0.09133676f, 
    0.06827061f, -0.02348164f, -0.07545566f, 0.06547800f, -0.03492980f, -0.08891165f, -0.13654178f, -0.02360202f, 
    0.12003469f, 0.20363159f, -0.12828459f, 0.09121685f, -0.00064388f, -0.01879545f, -0.13163112f, -0.01165953f, 
    -0.15008964f, 0.08725598f, -0.06142797f, -0.09817542f, -0.14301255f, 0.07237172f, -0.14295493f, 0.13560013f, 
    0.10805369f, -0.00020906f, -0.06211440f, -0.10483417f, 0.00402110f, -0.10263431f, 0.00135021f, -0.05639338f, 
    0.04867019f, 0.03261891f, -0.07156264f, -0.03869390f, 0.06209578f, 0.07337828f, -0.02100093f, 0.01164229f, 
    0.00457471f, 0.07648689f, -0.16705757f, 0.15381008f, 0.06645439f, -0.07837506f, -0.16211043f, -0.03922743f, 
    -0.04980323f, 0.04027496f, 0.03409258f, 0.02261920f, -0.02802430f, -0.06690443f, -0.02541228f, -0.09389986f, 
    0.16727342f, 0.12867545f, 0.04958839f, 0.10842638f, 0.06358002f, -0.08335828f, 0.05130647f, -0.07147980f, 
    0.07211792f, -0.02980361f, -0.03960520f, -0.07287924f, 0.11692812f, 0.16497052f, 0.04666076f, 0.38597959f, 
    -0.06524374f, 0.04977477f, -0.10434574f, -0.00114339f, -0.08151288f, -0.11121706f, 0.13761021f, 0.02770274f, 
    0.18904142f, -0.08512868f, 0.00409616f, -0.04792880f, 0.14835650f, -0.01068078f, -0.00355028f, -0.18236615f, 
    -0.06595066f, 0.08988847f, 0.10791970f, -0.00712464f, -0.10832322f, 0.09743197f, 0.03629233f, 0.04963394f, 
    0.06284647f, -0.06672102f, 0.03229184f, 0.08945863f, 0.04069625f, -0.06178666f, -0.01224125f, 0.01495164f, 
    -0.02196404f, 0.28188765f, -0.01150595f, -0.10712691f, 0.08137417f, -0.08590402f, -0.15004797f, -0.07303400f, 
    -0.13695182f, 0.20037054f, -0.09107753f, 0.09900798f, -0.04558936f, -0.06931876f, 0.13577075f, 0.11092950f, 
    0.01378564f, -0.23045883f, 0.07035157f, -0.18329534f, -0.19628741f, 0.04177797f, 0.08505331f, 0.20942953f, 
    -0.24049835f, 0.05960477f, -0.05869883f, -0.10614208f, 0.04435026f, -0.05368299f, -0.04345939f, -0.03028903f, 
    0.14060169f, -0.00160001f, 0.06597298f, 0.17726970f, -0.11408698f, -0.07595923f, 0.12990209f, 0.01328540f, 
    -0.02229519f, 0.03468893f, -0.07867029f, -0.04035248f, 0.02717369f, 0.16499045f, 0.03974759f, 0.18148783f, 
    0.03992559f, -0.01326870f, 0.10010000f, -0.01424515f, 0.08199736f, -0.04874221f, -0.02127412f, -0.03591890f, 
    0.10803896f, -0.02282150f, 0.04747149f, 0.04925037f, 0.19153078f, 0.15157925f, -0.01948336f, 0.08349899f, 
    0.09849472f, 0.06208989f, -0.08431370f, 0.10710523f, -0.02212924f, 0.09417605f, -0.04265752f, 0.02635235f, 
    0.08256489f, 0.11011989f, -0.08021452f, 0.12201833f, 0.11886650f, -0.01611876f, -0.10474982f, 0.04115603f, 
    0.07246986f, -0.01603500f, -0.02140456f, 0.16362259f, -0.09607533f, 0.10397593f, 0.21724413f, -0.04388460f, 
    0.09995920f, -0.08831020f, 0.06853793f, 0.02365419f, 0.11608821f, 0.10128916f, -0.09017920f, -0.12099954f, 
    -0.14638858f, 0.32164869f, -0.01919394f, -0.03971616f, 0.04215830f, 0.05269109f, 0.01891242f, -0.04013222f, 
    -0.06784306f, 0.10537601f, -0.00410042f, 0.00247777f, -0.03157453f, -0.00664764f, -0.04240085f, 0.14781065f, 
    -0.02533684f, 0.05380412f, -0.08566119f, 0.12272344f, 0.19989367f, -0.08396272f, -0.07036624f, -0.01710758f, 
    -0.05112154f, 0.14585522f, -0.00797703f, -0.11246769f, 0.17348501f, -0.04910265f, -0.01405386f, 0.04211412f, 
    0.05692924f, -0.12510607f, 0.00414694f, 0.02532564f, 0.15589452f, -0.20071854f, 0.02345101f, 0.12970060f, 
    0.01783496f, -0.11584942f, -0.00117627f, 0.01983859f, -0.05557990f, -0.00680301f, -0.01697533f, -0.05636026f, 
    -0.15266725f, 0.13970329f, -0.05332895f, -0.11874255f, -0.02461726f, -0.02402266f, -0.05574019f, -0.01114671f, 
    0.01844395f, -0.10420888f, -0.04295347f, -0.09237207f, -0.21873307f, -0.21609081f, 0.21515566f, 0.14081760f, 
    0.05552398f, 0.03683229f, 0.06061221f, 0.01300700f, -0.02507199f, 0.08705561f, 0.02574714f, -0.08832213f, 
    -0.20363198f, 0.16430539f, -0.19168068f, 0.13378043f, 0.07728899f, 0.02122726f, -0.11331078f, 0.08069490f, 
    -0.07200239f, -0.13401243f, 0.00780840f, -0.11720833f, 0.13297752f, -0.04570353f, 0.04164654f, 0.11336260f, 
    0.06171433f, 0.07248911f, 0.02482850f, -0.03123481f, -0.03107978f, -0.04983422f, 0.16313575f, 0.02973555f, 
    -0.11338542f, 0.05923323f, -0.17664647f, -0.13200426f, 0.05709922f, -0.05019259f, -0.05338385f, -0.09853532f, 
    0.01231024f, 0.03330736f, 0.10032845f, 0.06917402f, 0.10102532f, 0.15561369f, -0.05065183f, 0.33069670f, 
    -0.09548485f, 0.09996055f, -0.10150710f, -0.10272492f, 0.00404023f, 0.14976360f, 0.06892905f, 0.11451253f, 
    0.25511613f, -0.08080137f, 0.09844770f, 0.03620496f, 0.16849414f, 0.10695998f, 0.05263210f, 0.03462154f, 
    0.01938520f, -0.09007437f, 0.04162646f, 0.10208181f, -0.29274744f, -0.09782158f, 0.13494556f, 0.21787211f, 
    -0.10052052f, -0.20283335f, -0.07976394f, 0.17755497f, 0.06712566f, -0.01896521f, 0.09951362f, -0.00961394f, 
    -0.02042255f, -0.08366950f, 0.06158806f, -0.22706316f, 0.01640571f, 0.09887660f, -0.00703804f, 0.05794208f, 
    -0.11221880f, 0.07326639f, 0.15991850f, 0.04991873f, 0.26106212f, 0.25418845f, 0.08840999f, -0.18610252f, 
    -0.09700925f, 0.01492567f, -0.01512258f, 0.10841528f, 0.11743725f, -0.01955701f, 0.01353373f, 0.06137659f, 
    0.04866808f, 0.12850715f, 0.09130968f, -0.20648952f, -0.05729093f, -0.11411176f, -0.03247048f, 0.05798038f, 
    0.06012691f, -0.06803185f, 0.00834688f, -0.04123441f, -0.37073484f, -0.32758424f, -0.28021124f, -0.00045635f, 
    0.15168597f, -0.08114676f, -0.10578129f, 0.07511270f, 0.21083446f, 0.13011004f, 0.23975419f, 0.17136256f, 
    -0.59668034f, -0.34299493f, -0.19958171f, -0.12849186f, -0.01609713f, 0.05331171f, -0.04674419f, 0.07010363f, 
    0.04955138f, -0.07147647f, 0.04281770f, 0.22902624f, -0.51113009f, -0.51602238f, -0.07729301f, 0.06299135f, 
    0.04755343f, 0.10748826f, 0.07647349f, -0.05434648f, 0.04518079f, 0.28178760f, 0.04293250f, -0.03330569f, 
    0.00555992f, 0.17296156f, -0.07457896f, 0.14647315f, 0.17280246f, 0.04740952f, -0.00579363f, -0.10489149f, 
    0.06426290f, 0.08008198f, -0.04796551f, -0.03193286f, 0.46179724f, 0.06827423f, -0.22151132f, 0.12047148f, 
    0.07102981f, -0.09370951f, -0.03559376f, 0.00206655f, -0.06337377f, 0.00125770f, 0.03547447f, 0.11579970f, 
    0.14341299f, 0.22586238f, 0.09821840f, 0.06136700f, 0.15089646f, 0.20362078f, 0.06508233f, -0.12316229f, 
    -0.12786891f, -0.05758990f, 0.06571743f, -0.01772972f, -0.10105909f, -0.20296183f, -0.15255234f, 0.30327240f, 
    -0.27529138f, -0.20358647f, -0.15117788f, 0.09489034f, 0.09725136f, -0.03720572f, 0.00413226f, -0.07380787f, 
    0.10790255f, 0.07547131f, -0.05416690f, 0.10083469f, 0.00295075f, -0.01492891f, -0.06670991f, -0.05077003f, 
    0.08386584f, -0.08616854f, 0.09264483f, 0.14343701f, 0.12278698f, 0.12837827f, 0.12414080f, 0.05312096f, 
    0.05635693f, -0.07420135f, 0.08522680f, 0.16484532f, -0.06473069f, -0.10071740f, 0.05813329f, 0.06447180f, 
    -0.33939719f, 0.09591594f, -0.02359124f, 0.07489651f, 0.22865692f, -0.02781923f, -0.06310749f, 0.03291733f, 
    0.07859338f, -0.09895743f, 0.06424076f, -0.02437915f, -0.18903832f, -0.14081471f, 0.22052746f, -0.24385814f, 
    -0.04346618f, -0.07722104f, -0.03869223f, 0.12015205f, -0.04960253f, -0.08421021f, -0.02402520f, 0.05675870f, 
    -0.02316782f, -0.01006761f, -0.05300521f, -0.01371418f, 0.03432072f, -0.02316375f, -0.02393279f, -0.00989275f, 
    0.06216593f, -0.03242982f, 0.02937409f, -0.07033354f, 0.00344588f, 0.01891465f, -0.01084851f, 0.05994175f, 
    -0.05775423f, -0.06843955f, -0.01308176f, 0.02571452f, -0.05801713f, 0.03043998f, 0.03087616f, -0.01860703f, 
    -0.05159741f, 0.04964630f, 0.05684896f, -0.01839072f, -0.03619044f, 0.04901672f, 0.04443663f, -0.03269054f, 
    0.03624901f, 0.01766474f, 0.01413100f, -0.02177024f, 0.02663432f, -0.05647974f, 0.05286222f, 0.05197337f, 
    -0.07125556f, -0.03887647f, 0.04570017f, 0.03925675f, -0.01543632f, -0.03625761f, -0.03975410f, -0.02906852f, 
    -0.07459591f, 0.02280947f, -0.03627372f, -0.04775425f, -0.01296200f, 0.06044096f, -0.07141754f, 0.00428816f, 
    0.06044566f, -0.05695680f, 0.03545285f, 0.00271677f, 0.04636272f, -0.04396368f, -0.05583864f, -0.03596816f, 
    0.05466829f, 0.03802490f, -0.05778008f, -0.03208413f, -0.04189788f, -0.00417216f, 0.05415720f, -0.06359012f, 
    0.00498817f, -0.07218959f, -0.00722594f, -0.05971395f, 0.04513697f, -0.04520268f, -0.06924831f, -0.01537064f, 
    0.01418303f, -0.00718812f, -0.02132419f, -0.02415413f, -0.06111108f, 0.04913669f, 0.01062689f, 0.06121647f, 
    -0.06514926f, -0.01254735f, 0.01996992f, -0.03404003f, 0.04037802f, -0.02117688f, 0.05206607f, -0.02502918f, 
    -0.05979943f, -0.03292511f, -0.02711457f, -0.05510101f, 0.03588610f, -0.01361275f, -0.01581293f, -0.05407904f, 
    0.04727725f, -0.06197611f, -0.01436257f, -0.07393616f, 0.05007167f, -0.00617085f, -0.01932490f, 0.06277949f, 
    0.02576901f, -0.00533404f, -0.06383926f, 0.03579310f, -0.07171395f, -0.04087453f, -0.00806386f, -0.00865293f, 
    0.02969266f, 0.03426394f, -0.03700076f, 0.01600580f, 0.02509713f, 0.03014623f, -0.03569076f, 0.04371571f, 
    0.00510212f, -0.06450751f, 0.04578253f, -0.00701727f, -0.02332065f, 0.04285115f, 0.00229846f, 0.03037487f, 
    -0.05028801f, 0.00393214f, -0.02497651f, 0.02989228f, 0.04899051f, -0.06046449f, -0.02858426f, 0.04343504f, 
    0.00491868f, -0.03509546f, -0.05711788f, -0.04293655f, 0.01559230f, 0.06051171f, -0.00327319f, -0.04410279f, 
    -0.07425562f, -0.02636488f, -0.02188612f, 0.03555371f, -0.00750260f, 0.01596271f, -0.02699631f, 0.00895021f, 
    -0.00820787f, -0.05172195f, 0.01925160f, -0.00327592f, -0.00087774f, -0.02136252f, 0.01724090f, -0.01902037f, 
    -0.01457471f, 0.02800132f, -0.00075441f, 0.02175945f, -0.00551150f, -0.03559559f, -0.01846781f, 0.02971916f, 
    -0.04481107f, -0.01198447f, -0.01151541f, -0.03177221f, -0.02696944f, 0.02352899f, -0.07093313f, -0.03833072f, 
    -0.07592371f, -0.06572109f, -0.00223716f, 0.02124406f, 0.05498101f, -0.03778106f, -0.02088050f, 0.05072048f, 
    -0.14659388f, 0.06941933f, -0.00805117f, 0.01072882f, 0.08291718f, 0.00827368f, 0.14560157f, 0.03134229f, 
    0.03249092f, 0.08495502f, -0.01393143f, 0.14552408f, 0.30717713f, -0.14150892f, 0.05425894f, -0.11310533f, 
    -0.08609219f, 0.01065707f, 0.10347687f, 0.02760445f, 0.03273128f, 0.05185346f, -0.11761953f, 0.03751954f, 
    -0.12254206f, -0.00931174f, 0.18936156f, 0.11062536f, -0.10547978f, -0.01286647f, -0.05598941f, -0.09557790f, 
    0.06821515f, -0.04900724f, -0.09444079f, 0.01696069f, -0.02998767f, 0.11380299f, 0.02683810f, -0.00238900f, 
    -0.01892537f, 0.07678889f, 0.09595348f, -0.14062111f, 0.00242254f, 0.04067678f, 0.01167636f, 0.07535330f, 
    0.20372453f, -0.19096228f, -0.08698662f, -0.09410674f, 0.08256269f, -0.04389178f, 0.04595435f, -0.02670821f, 
    0.05948464f, -0.07055146f, 0.15403986f, 0.04080382f, 0.29213524f, 0.03823395f, -0.25229195f, -0.01219483f, 
    -0.18173242f, -0.09142007f, 0.04914174f, 0.13828260f, 0.05806431f, -0.03343384f, 0.03647252f, 0.06857970f, 
    -0.12484495f, -0.09678639f, 0.00346420f, -0.02896558f, -0.10522690f, 0.03587565f, 0.00457947f, 0.00563302f, 
    -0.03477382f, 0.00012585f, 0.13190807f, -0.01977784f, 0.00772281f, -0.00382926f, -0.03133735f, -0.31659997f, 
    0.05108631f, 0.09691906f, -0.09775610f, 0.08365781f, -0.00472203f, -0.02348951f, -0.10230941f, -0.01970640f, 
    0.11164440f, -0.01588932f, 0.00150962f, 0.17598103f, -0.00104096f, -0.01353923f, 0.00326996f, 0.09768434f, 
    0.02849131f, 0.00239677f, -0.01304435f, -0.00864562f, 0.19530083f, -0.13666430f, 0.01131346f, -0.08959094f, 
    0.12700623f, 0.16501507f, -0.00016588f, -0.05871855f, 0.03323130f, 0.03320743f, 0.05071266f, -0.00928161f, 
    -0.15265590f, 0.17461951f, 0.03054613f, -0.17329185f, 0.02370028f, 0.10130686f, 0.01945597f, 0.04909331f, 
    0.02062587f, 0.11049940f, -0.00607816f, 0.02208066f, 0.10014170f, -0.09726173f, -0.10144914f, -0.28535306f, 
    -0.00301703f, 0.05174062f, -0.16495222f, -0.05070680f, 0.12723355f, -0.05327092f, -0.04510140f, -0.01894505f, 
    -0.20024714f, -0.05665215f, 0.18509299f, -0.26856962f, 0.04686234f, 0.07075147f, 0.08159312f, 0.00784859f, 
    0.09768544f, 0.00441344f, 0.06786934f, 0.01297082f, 0.49438110f, -0.01914828f, 0.08067083f, -0.02611894f, 
    0.11871270f, 0.03872126f, 0.10165538f, 0.09663754f, 0.07010040f, 0.07393344f, -0.09250449f, 0.02295874f, 
    -0.00542057f, 0.21243036f, -0.23103005f, -0.36461791f, 0.05925612f, -0.02462269f, 0.07995015f, 0.04564863f, 
    0.04697278f, 0.04463124f, 0.03217547f, -0.04409746f, -0.17660570f, 0.13809708f, 0.19547175f, -0.15790582f, 
    -0.07596806f, -0.04924815f, -0.01750353f, -0.06154627f, 0.04226095f, -0.01765700f, 0.04177883f, 0.11671362f, 
    -0.06597278f, 0.01449466f, 0.06537928f, -0.07788025f, 0.02555220f, 0.03660929f, -0.01426108f, -0.03906181f, 
    -0.01753771f, 0.06570755f, -0.06165593f, 0.05213824f, 0.02627412f, -0.02320376f, -0.04000802f, -0.01317931f, 
    -0.07024952f, 0.03920507f, -0.05224352f, 0.02690938f, -0.02264251f, 0.02976152f, 0.00241861f, -0.04614056f, 
    -0.02049139f, 0.01300577f, 0.04497006f, 0.04572167f, -0.01908118f, 0.01025221f, -0.00345742f, -0.03977097f, 
    0.01410518f, -0.03389229f, 0.00318527f, 0.03909110f, -0.06286297f, -0.02094839f, 0.01278374f, 0.00615294f, 
    0.01677632f, 0.03088376f, 0.00681959f, -0.03603331f, -0.07424141f, -0.05835370f, 0.02769090f, -0.04304235f, 
    -0.05613120f, -0.01298409f, -0.04958453f, -0.04997898f, -0.03967987f, -0.05253497f, -0.04048882f, -0.06343433f, 
    0.05539352f, 0.06023568f, 0.02021318f, -0.00059545f, 0.00582148f, 0.01727592f, 0.01069326f, -0.03015387f, 
    -0.05210309f, 0.01888093f, 0.03022909f, -0.03986880f, -0.01198342f, -0.03160831f, -0.04089902f, -0.00646453f, 
    -0.03164318f, 0.01031344f, -0.01669873f, 0.02229975f, -0.03604715f, 0.02533224f, -0.06783593f, 0.03831149f, 
    -0.00776916f, 0.00858784f, -0.00967970f, -0.00247997f, 0.06124067f, 0.00086760f, 0.05914624f, -0.04055244f, 
    -0.00967872f, 0.03251914f, -0.07319316f, 0.02450754f, 0.01024310f, -0.00754154f, 0.01715715f, 0.05239734f, 
    -0.05541736f, -0.01525283f, 0.01413330f, -0.07020549f, -0.02307382f, 0.01346221f, -0.07191580f, -0.02842807f, 
    -0.05724032f, 0.03631676f, 0.03317248f, -0.05914034f, 0.02830872f, 0.05315939f, -0.02479354f, -0.00817437f, 
    -0.07793099f, 0.02076146f, -0.03139969f, -0.07546564f, 0.02770638f, -0.03315717f, -0.06649686f, -0.05810499f, 
    -0.06405666f, 0.05684237f, -0.02124762f, 0.04434136f, -0.03798006f, 0.02676301f, 0.02931843f, -0.03079826f, 
    0.03316785f, -0.03524375f, -0.06886170f, -0.07732326f, 0.05322705f, 0.02356240f, 0.04221996f, -0.00493875f, 
    -0.05797986f, 0.01012509f, 0.04694781f, 0.01450517f, 0.02384468f, 0.03596841f, 0.06035098f, -0.04451204f, 
    0.03138573f, -0.02484869f, 0.06311075f, -0.02524338f, -0.00126057f, 0.00526910f, 0.00837795f, -0.02042292f, 
    -0.05209307f, -0.01574682f, -0.05036990f, -0.02695685f, -0.00941012f, 0.03212890f, 0.04990174f, -0.05476945f, 
    -0.02435839f, -0.00844348f, -0.06761483f, 0.01081820f, 0.05028937f, -0.01880322f, -0.04746581f, 0.03383656f, 
    -0.03865326f, -0.04312036f, -0.03084986f, -0.01376134f, -0.04104509f, -0.04393174f, -0.00350800f, -0.07292958f, 
    0.02581658f, 0.04425129f, -0.00897818f, -0.02508765f, 0.03472847f, -0.02303625f, 0.01068173f, -0.01876284f, 
    -0.00532929f, 0.00503120f, -0.07290537f, -0.07748982f, 0.02944463f, -0.02037994f, -0.03289482f, -0.05811552f, 
    0.13688265f, 0.01112086f, 0.04098222f, 0.17217106f, 0.01398330f, 0.12391463f, 0.01702676f, -0.01284498f, 
    -0.05158479f, 0.04548731f, 0.11524687f, 0.04630069f, 0.17999220f, -0.13168032f, -0.18225434f, -0.05170614f, 
    0.10898932f, -0.15615807f, 0.07682909f, 0.16430055f, 0.00351638f, 0.04622001f, -0.02047896f, -0.04518065f, 
    0.26705807f, 0.07284630f, -0.11472849f, -0.11849921f, -0.00303274f, 0.13314973f, 0.10823067f, 0.06284644f, 
    -0.11137823f, 0.06110981f, -0.01399324f, 0.06181905f, -0.00734469f, -0.27466831f, 0.12048842f, -0.10704786f, 
    0.05714041f, -0.06826048f, -0.06092022f, 0.13419928f, -0.04970073f, -0.09055417f, -0.04041853f, -0.03322636f, 
    -0.24234150f, -0.13008638f, 0.08811130f, -0.14964253f, -0.09402005f, 0.07951474f, 0.06273852f, -0.07400753f, 
    -0.03791529f, -0.03681094f, -0.03592082f, -0.05090714f, 0.01793402f, -0.06436986f, -0.05304563f, 0.16053097f, 
    0.10706457f, 0.12343772f, -0.05897070f, -0.06651057f, 0.00227404f, -0.09137724f, 0.00832774f, 0.04838186f, 
    0.04940175f, -0.23742671f, 0.03927165f, 0.19057642f, 0.04108190f, -0.03216177f, -0.05816564f, 0.10264783f, 
    -0.07459728f, 0.04886112f, 0.05850418f, 0.00389191f, -0.03301749f, 0.00046719f, 0.07730312f, 0.08557545f, 
    0.00673418f, 0.10687175f, 0.10983244f, -0.02214954f, -0.07813066f, -0.03102491f, 0.05697672f, -0.00488989f, 
    0.11274137f, -0.03056769f, 0.00428763f, 0.14539123f, -0.02532935f, 0.17652833f, 0.09428836f, 0.05432663f, 
    -0.01801178f, 0.02026665f, 0.04443218f, 0.03704171f, -0.11929168f, 0.13511072f, -0.04174668f, -0.13054289f, 
    0.05270998f, 0.01134875f, 0.12004921f, -0.00608031f, 0.07043910f, -0.11674669f, -0.04063357f, -0.02742988f, 
    0.40123078f, -0.06597174f, 0.11955526f, 0.17282890f, -0.06546587f, -0.05147829f, 0.10453942f, 0.05697744f, 
    -0.01019444f, -0.00175631f, -0.00667403f, 0.02448660f, 0.08089297f, 0.06481444f, -0.03683455f, -0.06099191f, 
    0.02615478f, 0.06679074f, 0.02405745f, 0.08522115f, 0.07815887f, -0.12342986f, -0.01415424f, 0.02519821f, 
    0.38134953f, -0.09019362f, 0.12342398f, -0.13193108f, -0.20549785f, -0.05678621f, 0.16508156f, -0.07397871f, 
    -0.13288100f, 0.09097602f, -0.02510501f, 0.04506399f, -0.22606473f, 0.00897502f, -0.07517845f, 0.01240526f, 
    0.04014612f, 0.00854907f, -0.03118524f, 0.02354814f, -0.03531078f, 0.03985341f, 0.08383006f, -0.04204568f, 
    0.30044222f, 0.07010499f, 0.24454698f, 0.17235234f, -0.05536212f, 0.01463204f, -0.01984536f, 0.03827731f, 
    0.09466220f, 0.01272645f, -0.03873930f, 0.03659636f, 0.16558491f, -0.19532254f, 0.13826698f, -0.27159694f, 
    -0.00801501f, 0.04360740f, 0.17531219f, 0.13765325f, -0.06127283f, 0.03761512f, 0.09709433f, 0.02444239f, 
    0.27649975f, 0.13585508f, 0.14723936f, 0.03544590f, 0.07455006f, 0.04683276f, 0.02607558f, 0.04234985f, 
    -0.01705603f, 0.10100669f, -0.05935614f, -0.09995321f, 0.10069017f, -0.06741440f, 0.02921552f, -0.15054627f, 
    0.06494322f, 0.10666341f, -0.14299902f, -0.08651984f, -0.00478824f, -0.05035527f, 0.00090791f, -0.00769977f, 
    0.21220252f, -0.17958817f, -0.00932068f, 0.11798065f, -0.06012278f, -0.06756187f, -0.15135629f, -0.02825236f, 
    0.06395702f, -0.00380812f, -0.01947686f, 0.03903865f, 0.23365594f, 0.20999394f, -0.04067945f, -0.10521016f, 
    -0.08659377f, 0.05259832f, 0.00163319f, -0.07072014f, 0.03108456f, 0.04709857f, -0.10808758f, -0.03354396f, 
    -0.13007356f, -0.11597981f, 0.01968537f, 0.07883217f, 0.03105295f, -0.01283994f, 0.05961107f, -0.10176080f, 
    -0.02498739f, 0.07607605f, 0.04755942f, -0.11665233f, 0.02253353f, -0.01504915f, -0.09682921f, 0.02095603f, 
    0.01577516f, 0.05745706f, -0.08100497f, -0.02140844f, -0.11455386f, 0.02329735f, 0.03031013f, 0.05675226f, 
    -0.10975193f, -0.20789222f, -0.10753257f, -0.24590553f, -0.03284027f, -0.03961334f, 0.01130026f, 0.10358981f, 
    0.10947692f, -0.03516015f, 0.09589597f, 0.03935803f, -0.03883415f, -0.06522212f, -0.04756492f, -0.18105371f, 
    -0.06749430f, -0.05963527f, 0.00003406f, 0.01818942f, -0.10782971f, 0.00535097f, 0.07426327f, -0.00227069f, 
    0.46755904f, -0.15706661f, 0.13866718f, 0.16990490f, -0.00730633f, 0.02732953f, -0.04735014f, 0.00167141f, 
    0.11286962f, -0.04805580f, 0.07067473f, -0.05006092f, 0.06895728f, 0.05065516f, 0.07159616f, 0.05089455f, 
    0.06526271f, 0.10489699f, -0.10531735f, -0.01652235f, 0.09696524f, -0.00818368f, -0.06609831f, 0.06599692f, 
    0.17584699f, 0.16843216f, 0.09526794f, 0.00290732f, -0.06932076f, 0.10639469f, -0.02493208f, 0.05585339f, 
    -0.06867451f, 0.06371462f, 0.09512107f, -0.01571110f, 0.22685610f, -0.02575868f, 0.00470539f, -0.14914413f, 
    -0.00384329f, 0.01914395f, 0.08593427f, -0.05696075f, 0.10261799f, -0.04186153f, 0.00287942f, 0.05185018f, 
    -0.01456992f, 0.00099673f, 0.25448263f, 0.11919617f, -0.11630438f, -0.09442991f, 0.11607240f, -0.00182660f, 
    -0.00543116f, 0.13820681f, -0.00952960f, 0.05114053f, -0.06435478f, 0.06978678f, -0.00281375f, 0.05528681f, 
    -0.05151027f, 0.06931046f, 0.07741196f, -0.07583821f, -0.08539202f, 0.03718707f, 0.00475004f, 0.09652393f, 
    0.16149804f, 0.01843988f, 0.06830316f, 0.12039123f, -0.00188038f, -0.06323544f, 0.03276552f, -0.03529765f, 
    0.12863418f, -0.02508190f, 0.00065052f, -0.10618385f, -0.05638408f, 0.12007780f, -0.11515009f, -0.17638803f, 
    0.17703392f, 0.00780080f, -0.03890568f, 0.17442717f, 0.13901290f, -0.03208189f, -0.01537690f, -0.04439663f, 
    -0.02515923f, -0.13388211f, 0.05074745f, 0.00596026f, -0.00374733f, -0.07166116f, 0.00175002f, -0.02561162f, 
    -0.00395396f, 0.07653090f, 0.02637848f, 0.09662919f, -0.21548274f, 0.25293186f, 0.18984607f, 0.13802922f, 
    0.12877725f, 0.08898849f, -0.01290328f, 0.05061980f, -0.03220455f, -0.04479353f, 0.04841174f, 0.03248093f, 
    0.00730302f, 0.21133655f, 0.04230357f, -0.19736430f, -0.11392090f, 0.15007398f, 0.05640716f, -0.00450662f, 
    -0.01242531f, 0.02467641f, 0.00170606f, -0.01579514f, -0.13488612f, 0.14179152f, 0.07216650f, -0.05830868f, 
    0.04571796f, -0.08596576f, -0.03212165f, -0.06030784f, 0.06731872f, -0.11109916f, -0.02358860f, -0.06762651f, 
    0.74672610f, 0.24325496f, 0.05798271f, -0.20710479f, 0.10485030f, 0.06020272f, 0.05712235f, 0.08883034f, 
    0.10965016f, -0.00395668f, -0.06260770f, 0.06527780f, -0.04175518f, -0.15097022f, 0.07726607f, 0.08978911f, 
    -0.03838896f, -0.19879276f, 0.02154667f, 0.05053210f, 0.00053921f, 0.08413941f, -0.07069361f, -0.13553286f, 
    0.28823572f, 0.08302339f, 0.10055619f, 0.19665475f, -0.04644314f, -0.13414665f, -0.07167548f, -0.17043945f, 
    -0.15182769f, 0.23577248f, -0.12811869f, -0.02299915f, -0.07754286f, -0.14774051f, 0.06689211f, 0.02786077f, 
    -0.01050196f, 0.00966721f, 0.03867237f, -0.11612377f, 0.12068729f, -0.14734522f, -0.01978756f, -0.00062722f, 
    -0.19523919f, 0.20022331f, -0.19146377f, 0.13309582f, 0.01532501f, -0.16935216f, 0.02972031f, 0.02221113f, 
    0.03315593f, -0.04358041f, -0.02555961f, -0.04947887f, 0.03703698f, 0.06575665f, 0.01296466f, 0.10844476f, 
    -0.06811377f, -0.07048067f, 0.06761500f, -0.04434837f, 0.05299826f, -0.00351366f, -0.04005270f, -0.08859931f, 
    0.08320618f, 0.12097017f, 0.06496805f, 0.06080098f, 0.01646243f, -0.08205486f, -0.01756536f, -0.01610117f, 
    0.18931240f, -0.15718974f, -0.13556704f, -0.12239728f, -0.20802420f, 0.12236696f, 0.11680122f, 0.12895361f, 
    0.16778469f, 0.08090267f, -0.02762433f, 0.04756221f, -0.15754445f, -0.17327914f, 0.07061371f, 0.00955599f, 
    0.15620856f, 0.05087784f, 0.09552599f, -0.08317966f, 0.11757153f, -0.12087908f, -0.11787131f, 0.09043194f, 
    0.06867045f, 0.03600502f, 0.07536399f, -0.01288426f, 0.01059445f, 0.08855141f, -0.26390690f, -0.09038460f, 
    0.01468709f, 0.02126554f, 0.08599755f, -0.14411637f, 0.01582829f, -0.04337535f, -0.05683898f, 0.11070667f, 
    0.10017353f, 0.22385885f, 0.17477889f, 0.17867267f, 0.02549051f, -0.03222309f, -0.04955290f, -0.02761513f, 
    -0.06981035f, -0.02840791f, 0.13464816f, 0.19282800f, -0.18770264f, -0.29932255f, -0.08650663f, 0.10235098f, 
    -0.04783742f, -0.03523734f, 0.09662691f, -0.01883624f, -0.03440364f, 0.17943615f, 0.12291013f, 0.05476576f, 
    -0.28917181f, -0.01294699f, -0.02813767f, -0.14466441f, -0.02891008f, 0.00325058f, -0.01207102f, 0.11933159f, 
    0.13478518f, 0.05764558f, -0.05378554f, 0.00155638f, 0.17862141f, 0.21249057f, -0.02621047f, -0.09079862f, 
    -0.05018755f, -0.03946734f, -0.01646671f, -0.03196680f, -0.00410322f, -0.08222277f, 0.07519884f, 0.07666808f, 
    -0.00793737f, 0.18994753f, 0.02503078f, 0.02482684f, -0.09696827f, -0.02851740f, 0.08833582f, -0.01172122f, 
    0.05307282f, 0.11617120f, 0.06367820f, -0.01129669f, -0.24337649f, -0.03934489f, -0.03456107f, -0.00465369f, 
    -0.03246988f, 0.05010948f, 0.12783110f, -0.11724041f, -0.11395568f, 0.04834854f, 0.04678446f, -0.05255242f, 
    0.10814345f, 0.01914524f, -0.04033533f, 0.07619342f, 0.03528808f, 0.14911208f, 0.03238427f, 0.06168280f, 
    0.07576973f, -0.05317349f, 0.02007795f, 0.11950834f, -0.05990210f, 0.07962701f, 0.01566611f, 0.04055801f, 
    0.13563758f, 0.02053116f, 0.07451636f, -0.02431949f, -0.06753406f, -0.15608720f, 0.07184836f, 0.00102805f, 
    0.08421803f, 0.05517681f, 0.00276273f, 0.21737114f, 0.18247685f, -0.00356009f, 0.09393671f, 0.03365394f, 
    0.03146457f, 0.10317551f, 0.01134164f, -0.10930452f, 0.16926998f, 0.07470384f, -0.14886963f, 0.36943325f, 
    -0.04621486f, -0.13929713f, 0.06480195f, 0.08045609f, 0.06223010f, -0.03751316f, -0.14297354f, 0.10381196f, 
    -0.08284210f, 0.11867671f, -0.09868527f, -0.00127065f, 0.01558306f, -0.07885099f, -0.00645851f, 0.04242087f, 
    -0.06083553f, 0.01840672f, -0.12753969f, -0.00713089f, -0.51669776f, 0.05599695f, 0.18613899f, 0.00533528f, 
    -0.04396988f, 0.00248834f, -0.04756344f, 0.10495979f, -0.12449419f, 0.04001622f, -0.02044013f, -0.05517711f, 
    0.03541005f, -0.33376336f, -0.26057571f, 0.11491248f, 0.04025538f, -0.10016838f, 0.01114566f, 0.04238422f, 
    0.03432402f, 0.06444497f, 0.08078906f, 0.01171326f, -0.19607337f, 0.22114320f, 0.06428865f, -0.13549058f, 
    -0.00604529f, -0.01606489f, 0.04641063f, 0.03311085f, -0.10352650f, 0.11359730f, 0.06225154f, 0.10578456f, 
    -0.08704561f, 0.01440431f, 0.03534754f, 0.24088593f, 0.17698897f, 0.00634515f, -0.00355840f, 0.09867056f, 
    0.06548221f, 0.01751292f, 0.03957347f, 0.03470694f, -0.12140820f, -0.02142647f, -0.06046371f, -0.07649740f, 
    -0.06005033f, 0.05453817f, -0.04858932f, -0.05493414f, 0.05918254f, 0.00784462f, -0.00178822f, -0.03086836f, 
    0.13010243f, -0.13318644f, -0.10248014f, 0.13834542f, -0.09360837f, 0.07506239f, 0.06942208f, -0.09696630f, 
    0.08220325f, 0.11123769f, 0.02574037f, 0.05809037f, -0.01013004f, 0.10033394f, -0.16739222f, 0.22876854f, 
    -0.03707266f, -0.03367373f, -0.00111656f, -0.08212566f, 0.05259234f, 0.12918346f, -0.01683083f, -0.00536375f, 
    0.17297840f, -0.04857878f, 0.08485213f, 0.03684496f, 0.07496101f, 0.04920397f, -0.04574307f, -0.04106944f, 
    0.06349863f, 0.07933999f, 0.08680222f, -0.04333531f, 0.19138062f, -0.05513152f, 0.08446585f, 0.03008848f, 
    0.23783125f, 0.08641973f, 0.06047643f, 0.11234318f, 0.01511243f, 0.03794684f, -0.03652823f, 0.00002489f, 
    0.02255288f, -0.08433896f, -0.22729737f, 0.04027137f, -0.06307106f, 0.01290111f, -0.08107544f, 0.11114553f, 
    0.01584464f, 0.02033272f, 0.07087312f, 0.09771595f, 0.21858793f, -0.00832056f, 0.02900768f, 0.08296549f, 
    0.11728285f, -0.03653064f, 0.02397888f, -0.02730652f, -0.01112761f, 0.11102802f, -0.06036178f, -0.03329714f, 
    -0.44005072f, -0.10147765f, 0.09421954f, -0.00204819f, 0.03321264f, 0.10377306f, -0.01693239f, 0.01361008f, 
    0.18741564f, -0.10928731f, 0.08356375f, -0.00467673f, -0.30919749f, -0.00440396f, -0.03036936f, 0.14050169f, 
    0.09629424f, -0.02247837f, -0.00834139f, 0.01161356f, 0.11322082f, -0.07587309f, 0.10871173f, 0.06038415f, 
    -0.17179194f, 0.07497752f, 0.01674942f, -0.03247788f, -0.07465181f, -0.01753634f, 0.03199498f, 0.18688987f, 
    -0.04477790f, -0.06175937f, -0.05410564f, 0.10735116f, -0.12049025f, 0.00009783f, -0.21952878f, 0.07588300f, 
    -0.09706165f, -0.07987035f, 0.04152730f, -0.00438377f, 0.03997062f, 0.02401361f, -0.01472254f, -0.05716628f, 
    0.05977102f, 0.10711545f, -0.00542577f, 0.12521265f, 0.12820110f, 0.09328572f, 0.03261060f, -0.01623010f, 
    -0.13662861f, -0.07844783f, 0.01494775f, 0.03804792f, 0.09258835f, 0.16195437f, -0.04253880f, -0.08839232f, 
    -0.04779444f, -0.02706453f, -0.09100397f, -0.05576179f, 0.05461208f, 0.00980654f, 0.02428649f, 0.00588860f, 
    0.24630214f, 0.00985778f, 0.07039086f, 0.07237403f, 0.13614608f, -0.00629818f, -0.05986263f, -0.08310831f, 
    -0.13283427f, -0.10245170f, 0.02378057f, -0.08959577f, 0.02957568f, 0.04779670f, 0.02495548f, 0.11521222f, 
    0.02817489f, 0.01551060f, 0.09299035f, 0.03665789f, 0.13897939f, 0.11860966f, 0.13133918f, -0.09846297f, 
    0.10910534f, -0.13062201f, 0.06530774f, 0.08689318f, -0.08232857f, 0.00619011f, -0.04722344f, 0.06393093f, 
    -0.11894020f, -0.05034740f, -0.07029288f, -0.03323735f, 0.08176705f, -0.09621318f, -0.00799762f, -0.09239610f, 
    0.05671733f, -0.06323656f, -0.14105806f, 0.06781860f, -0.03607364f, 0.00859894f, 0.13047609f, -0.12021817f, 
    0.09342457f, -0.01600104f, -0.22477604f, 0.18175456f, -0.07621825f, -0.06931676f, 0.06342591f, -0.02225151f, 
    0.10228742f, -0.09327658f, -0.06635495f, -0.10166567f, 0.34080571f, 0.27121228f, 0.08332259f, -0.26958919f, 
    -0.09787719f, -0.10568485f, -0.02819593f, 0.04586619f, -0.00331891f, 0.02727327f, -0.00238201f, -0.00807430f, 
    0.05891988f, -0.01935234f, -0.00298060f, -0.15165882f, -0.04277951f, -0.04545414f, 0.04112685f, 0.14906654f, 
    -0.00687208f, 0.14095163f, 0.11663397f, -0.04871426f, -0.09916107f, -0.02426787f, 0.10163126f, 0.16375211f, 
    -0.06573040f, 0.00306779f, 0.00820789f, 0.10272299f, 0.06948251f, 0.07436761f, -0.02111371f, -0.09024790f, 
    0.44134369f, 0.04061429f, -0.05217654f, -0.14088044f, 0.02560196f, -0.02436284f, 0.14194608f, -0.03162019f, 
    -0.08703040f, -0.01783617f, 0.06709172f, 0.03474626f, -0.11505536f, -0.03802982f, 0.03412134f, 0.00107500f, 
    -0.04433909f, -0.04424419f, -0.05921338f, 0.11944333f, -0.02055713f, -0.12915227f, 0.05783782f, -0.08205669f, 
    0.49750483f, 0.15517716f, 0.04960620f, 0.07897424f, 0.01603768f, 0.12660284f, 0.07509821f, 0.10933337f, 
    -0.02620660f, 0.00356552f, -0.06029136f, 0.03254430f, 0.08167561f, -0.14992161f, 0.02815703f, -0.05789346f, 
    0.04145901f, 0.05970893f, 0.06570962f, -0.04743460f, -0.04582191f, -0.11226581f, -0.14632915f, -0.07377154f, 
    0.03316917f, 0.13475409f, -0.08510606f, -0.00530062f, 0.06456780f, -0.02681291f, -0.08703800f, -0.05671323f, 
    0.06355959f, 0.19766752f, -0.09093540f, -0.12837732f, -0.15046121f, 0.05110949f, -0.11391670f, 0.20871192f, 
    -0.03407644f, -0.01554564f, 0.02056262f, -0.00199787f, -0.00454944f, -0.11175612f, -0.02797834f, -0.12820725f, 
    -0.00920829f, -0.12514836f, -0.02842759f, -0.00040892f, 0.02235984f, 0.07128834f, 0.04273959f, -0.02715178f, 
    0.08976997f, 0.03081367f, -0.22723852f, 0.02425752f, 0.04032594f, -0.03007731f, 0.02146264f, 0.09685081f, 
    -0.02061495f, -0.10448242f, 0.06139633f, -0.05722244f, -0.16655748f, -0.05143652f, -0.14743333f, -0.13606147f, 
    0.15340881f, 0.13452625f, -0.09329350f, 0.12605582f, 0.06442533f, 0.02246022f, -0.01651510f, -0.02575375f, 
    -0.01718919f, -0.03569226f, -0.10487331f, 0.03412169f, -0.07109455f, 0.12400676f, 0.09219633f, 0.25998226f, 
    0.03066972f, -0.11294667f, 0.07009733f, 0.00064360f, -0.13889548f, 0.04844372f, 0.04763079f, 0.05538503f, 
    0.19182619f, -0.03883233f, 0.11347733f, 0.17950580f, 0.08474390f, -0.03812011f, 0.09212259f, -0.10625430f, 
    0.00413171f, 0.08961349f, 0.09764621f, 0.05831801f, -0.36626035f, 0.06772772f, -0.03163945f, 0.08081323f, 
    0.11223900f, -0.06470609f, -0.04598923f, -0.02204351f, -0.03622745f, 0.10616762f, -0.01627797f, -0.03712808f, 
    0.14706083f, 0.07222198f, 0.05367805f, 0.10705228f, 0.10255613f, 0.05742160f, 0.05575450f, 0.03919337f, 
    0.00861557f, 0.12833920f, 0.01112872f, 0.09244503f, 0.01389508f, -0.08703923f, -0.26987424f, 0.19766712f, 
    -0.05649979f, -0.14211309f, 0.11638505f, -0.10268349f, -0.00820504f, 0.17665713f, 0.06394412f, 0.11280288f, 
    -0.01087148f, -0.11400394f, -0.08766428f, -0.15763547f, 0.16978474f, -0.07419062f, 0.08208609f, -0.01305571f, 
    -0.00006460f, 0.01179146f, -0.08110473f, -0.06333744f, 0.25318137f, 0.07456680f, 0.01846708f, 0.03010275f, 
    -0.11840278f, 0.11133647f, 0.00755062f, -0.11925817f, -0.00652640f, -0.14310682f, 0.00391334f, -0.00754865f, 
    0.39761847f, -0.07245563f, -0.12328694f, -0.07565989f, 0.05187274f, -0.09510013f, -0.17451629f, -0.05881805f, 
    0.19502708f, 0.11329482f, 0.11272913f, 0.03519310f, 0.06702130f, 0.09375864f, -0.14262475f, -0.19245228f, 
    0.05231803f, 0.02950109f, 0.18388775f, -0.09288441f, 0.08443523f, 0.09346921f, 0.06185941f, 0.03303735f, 
    -0.13958970f, -0.17993151f, -0.13353094f, 0.17466253f, 0.07302504f, 0.03962888f, -0.08564308f, 0.06298801f, 
    0.09633829f, 0.00790593f, 0.03112638f, 0.03693582f, -0.20881455f, 0.01689557f, -0.16280767f, -0.11839412f, 
    0.07551142f, -0.02860426f, 0.03287233f, -0.00394965f, -0.13246383f, -0.04123501f, 0.08699740f, 0.08899952f, 
    -0.16117159f, -0.07259558f, -0.13513361f, -0.05245468f, 0.07323559f, -0.10122883f, 0.11865281f, 0.06008139f, 
    0.14629433f, -0.02736784f, 0.14792834f, 0.04322984f, 0.17978646f, 0.16459340f, -0.02968020f, 0.11030549f, 
    0.00661084f, -0.09131036f, 0.09362632f, 0.10841042f, 0.06837329f, 0.14314789f, 0.06977566f, -0.03952264f, 
    0.30548760f, -0.27098778f, -0.07522540f, 0.13959415f, -0.03202227f, -0.13254105f, -0.03740574f, 0.09176652f, 
    -0.03565329f, 0.06033267f, -0.01044928f, -0.03853009f, -0.24955669f, 0.23149635f, 0.06809543f, -0.03810344f, 
    0.04276233f, 0.14687470f, -0.14947146f, 0.02111770f, -0.05574177f, -0.00182901f, 0.11491223f, 0.04728247f, 
    0.27342367f, -0.28928059f, -0.14125484f, 0.12682354f, 0.11435193f, 0.02686084f, 0.06392801f, 0.02948109f, 
    -0.00051663f, 0.06966510f, 0.11692557f, 0.04345218f, -0.26910517f, 0.10712253f, -0.06912799f, 0.02202437f, 
    -0.02986422f, -0.02648281f, 0.13630015f, -0.03136782f, 0.09055428f, -0.01425716f, -0.09629218f, 0.02704385f, 
    -0.04454219f, -0.05188057f, 0.04738882f, 0.20116527f, 0.20560306f, 0.09076977f, -0.01640370f, 0.00155902f, 
    0.13410892f, 0.19343115f, 0.15529659f, 0.03829572f, -0.30486014f, -0.05263165f, 0.06944599f, 0.03028023f, 
    -0.00114447f, -0.05197364f, -0.04036081f, 0.02953663f, -0.13908057f, 0.07724453f, -0.01240860f, -0.11179606f, 
    0.22042096f, -0.05886564f, -0.10557584f, 0.08730022f, 0.02292766f, 0.10110985f, 0.04370644f, -0.15972114f, 
    0.16771944f, 0.07855567f, 0.13077162f, 0.01977970f, 0.05191831f, 0.35739613f, -0.21814750f, -0.05924867f, 
    0.15985171f, -0.02584276f, -0.13690197f, -0.06086922f, 0.08470318f, 0.08229177f, 0.07727388f, -0.02360160f, 
    -0.17397720f, 0.01348053f, -0.11161030f, -0.18639882f, -0.06246183f, 0.02974358f, -0.06794380f, 0.02824165f, 
    -0.03499436f, 0.05883243f, -0.10638621f, -0.01136219f, -0.11447930f, 0.15663438f, 0.02125218f, -0.10729877f, 
    -0.16314170f, 0.17347412f, 0.08229503f, -0.26510274f, 0.04942824f, -0.05058693f, 0.09335262f, -0.04075082f, 
    -0.23084667f, 0.19949634f, 0.27050453f, 0.09101516f, 0.06406830f, 0.01418933f, 0.08548811f, 0.03825326f, 
    0.06208891f, 0.06043290f, 0.07254495f, -0.00466528f, -0.04465210f, 0.17234123f, -0.10403445f, 0.05077479f, 
    -0.19978264f, 0.06514689f, -0.03716657f, 0.10456648f, 0.03532311f, 0.05856116f, -0.07139073f, -0.03741405f, 
    0.08462083f, 0.16760559f, 0.02960922f, 0.06912040f, -0.02871143f, -0.06331308f, 0.05625055f, -0.04372669f, 
    -0.12180490f, 0.02274460f, -0.08855161f, -0.02023321f, 0.19912751f, 0.23218539f, 0.18223301f, -0.18953095f, 
    0.08931615f, -0.00975639f, 0.02270778f, 0.06343076f, 0.07893968f, 0.08184252f, 0.01599115f, -0.06942524f, 
    0.15974052f, 0.15446793f, 0.13478723f, 0.17886829f, 0.13612720f, 0.03662875f, -0.01455757f, -0.09649248f, 
    0.04153479f, 0.00564664f, 0.05271541f, -0.02458232f, 0.33855590f, 0.05741213f, 0.19949099f, -0.00791263f, 
    0.00452436f, -0.00817995f, 0.09938712f, 0.03621937f, 0.09867674f, 0.04419723f, 0.02049873f, 0.11828665f, 
    -0.23101033f, 0.01449386f, -0.00809190f, -0.29020482f, -0.09589606f, -0.08394300f, -0.11367390f, -0.02010688f, 
    0.10705530f, -0.03498248f, 0.06981879f, -0.00836982f, -0.18602063f, -0.10785036f, 0.06831506f, 0.10337327f, 
    -0.03305809f, 0.02726543f, 0.04265266f, 0.10167205f, -0.08626924f, 0.05599598f, 0.09370494f, -0.00983377f, 
    -0.37774798f, -0.01749912f, -0.14514481f, -0.16782166f, 0.00420656f, -0.00643890f, 0.03374603f, 0.01354408f, 
    0.02794899f, 0.13355924f, 0.02522322f, 0.14502835f, 0.07738925f, -0.03222042f, 0.08052539f, -0.03475088f, 
    0.07782608f, 0.03926649f, 0.14260146f, 0.02091404f, -0.08158737f, -0.02083065f, 0.07665814f, 0.01697446f, 
    -0.38294566f, 0.17721447f, 0.01688691f, 0.10888153f, 0.13256411f, 0.04409060f, -0.03363051f, 0.11415047f, 
    0.08470500f, -0.01932224f, -0.04435775f, 0.03866347f, 0.08047434f, -0.02129165f, -0.04306291f, -0.01355291f, 
    -0.07644855f, 0.16186965f, 0.05443244f, -0.04304591f, -0.00436053f, 0.04673741f, -0.12659626f, 0.12427596f, 
    -0.16616802f, -0.20268700f, 0.14547269f, 0.01922487f, -0.03884225f, -0.06009225f, -0.00626529f, -0.09449250f, 
    0.04661610f, -0.01278958f, 0.08834266f, 0.07713475f, -0.20256869f, -0.10408482f, -0.14248203f, 0.38772967f, 
    0.06980408f, 0.09356290f, -0.06352855f, 0.02228786f, 0.04632224f, -0.03128095f, -0.06945433f, -0.12531181f, 
    -0.00158036f, 0.01840499f, 0.03582898f, 0.05042579f, 0.06627685f, 0.02620335f, -0.04631002f, 0.04576441f, 
    -0.06351819f, 0.02924583f, -0.03636958f, -0.01815180f, -0.06307319f, -0.06189322f, 0.03978601f, -0.04636009f, 
    0.03795046f, -0.05330670f, 0.05801763f, -0.07672072f, -0.02642776f, -0.04117885f, 0.04713339f, 0.04077934f, 
    0.01872864f, -0.02795723f, -0.00554534f, 0.03678119f, 0.03286975f, -0.00135952f, 0.01576953f, -0.02109285f, 
    0.02475890f, 0.04032972f, 0.02735737f, 0.05635167f, -0.04601057f, -0.06490348f, -0.01942557f, -0.02994641f, 
    -0.03107717f, -0.04438353f, -0.06335368f, -0.07335824f, 0.04900087f, -0.07024194f, -0.07831737f, -0.05491038f, 
    -0.01037670f, 0.00370312f, -0.02489030f, -0.04580869f, 0.01494955f, 0.06602304f, -0.03004999f, 0.04832743f, 
    0.05550717f, 0.05005934f, -0.06987572f, 0.00510977f, -0.04706511f, 0.03654748f, 0.00997413f, 0.03248470f, 
    -0.02440921f, -0.03371496f, -0.03863490f, 0.01086035f, -0.04808155f, 0.05016047f, 0.02880985f, -0.05448999f, 
    -0.07110403f, 0.05893676f, 0.01182516f, -0.08599227f, -0.05291364f, -0.07749091f, 0.03445449f, -0.08082410f, 
    0.06223262f, 0.03634324f, -0.07050280f, -0.02424074f, -0.02053269f, 0.05087446f, 0.03145776f, -0.02318460f, 
    -0.03291314f, -0.08550250f, -0.05380011f, -0.07163338f, 0.00989870f, -0.02139031f, -0.01627511f, 0.00500839f, 
    0.05316172f, 0.06677558f, -0.02755936f, -0.02702894f, 0.02274968f, 0.04810642f, 0.04673278f, 0.00618554f, 
    -0.00415392f, 0.04249328f, -0.07038592f, 0.02061348f, 0.01021891f, -0.02247905f, 0.03552896f, 0.04107929f, 
    0.02759253f, 0.05157256f, -0.03760112f, 0.03946410f, -0.05488493f, 0.04072671f, 0.04018582f, -0.05786156f, 
    -0.03731391f, -0.00621399f, -0.06202241f, -0.02572539f, -0.06334040f, -0.04111868f, -0.07734996f, 0.00537182f, 
    -0.07647931f, -0.03912295f, -0.06809057f, 0.05229591f, -0.04703169f, 0.00791912f, -0.05616809f, 0.04506994f, 
    0.01017333f, 0.00904571f, 0.04120241f, -0.00357159f, 0.06211182f, -0.04821149f, 0.00666450f, -0.03437934f, 
    -0.00162310f, -0.04361302f, -0.01083383f, -0.01487463f, 0.05315817f, 0.01806001f, -0.07293613f, 0.04121741f, 
    -0.06332888f, -0.00915495f, -0.05565718f, -0.05709190f, -0.03811872f, 0.00955237f, -0.06904618f, -0.02584459f, 
    0.00079373f, 0.03649324f, 0.03771979f, -0.00467392f, 0.03473883f, -0.01286594f, -0.00998612f, -0.07804076f, 
    0.06030675f, 0.02628252f, -0.05446638f, -0.03218977f, -0.04894374f, -0.03913572f, -0.03922107f, -0.03807122f, 
    -0.05832044f, -0.07536424f, 0.06202763f, -0.04463099f, -0.07230712f, -0.03179100f, 0.02809288f, 0.04202633f, 
    -0.04093315f, -0.07000858f, -0.05209517f, 0.00597332f, -0.00572865f, -0.03068694f, 0.04536772f, -0.05484499f, 
    -0.00313581f, 0.11141711f, 0.00639311f, -0.19862644f, -0.11080614f, -0.10273821f, -0.01140043f, 0.05732724f, 
    -0.05854688f, 0.03297904f, 0.05260185f, 0.02125039f, -0.35796237f, -0.06901682f, 0.07444081f, 0.06560493f, 
    -0.06601331f, 0.00593240f, -0.01621092f, 0.00451645f, 0.22537921f, 0.00313763f, 0.06468947f, 0.02703282f, 
    -0.14223583f, 0.11619290f, 0.34220815f, 0.14511831f, 0.00608949f, 0.05633942f, 0.13848804f, -0.06457276f, 
    0.01490094f, 0.05613203f, 0.02420508f, 0.04542835f, -0.21262436f, 0.19153033f, 0.08853634f, 0.27060962f, 
    0.03665917f, -0.05805410f, -0.13233520f, 0.13624455f, -0.07628047f, -0.02017094f, 0.05356343f, -0.03031268f, 
    0.25821164f, -0.00525932f, 0.15328719f, 0.05732092f, -0.02356802f, -0.09543809f, -0.07033686f, -0.04940275f, 
    -0.12128425f, 0.00708203f, -0.06303327f, 0.07165699f, 0.25206161f, 0.12189052f, 0.03793334f, -0.15665479f, 
    0.01799908f, 0.09610033f, -0.03030789f, -0.03181441f, 0.15093994f, 0.13971758f, 0.02491780f, -0.06688295f, 
    0.04138245f, 0.15112332f, 0.06794338f, -0.11011668f, 0.01153063f, 0.14452675f, -0.02407121f, -0.02278528f, 
    -0.07309379f, 0.00177122f, 0.07054866f, -0.07411613f, 0.01520382f, -0.02114406f, 0.13326183f, -0.03449760f, 
    0.08042806f, 0.12645625f, -0.02879479f, -0.07770855f, -0.13411999f, -0.16807348f, 0.05908366f, 0.12880325f, 
    -0.22916618f, 0.15825479f, 0.01585389f, -0.24008061f, 0.15206014f, -0.07765196f, -0.09163060f, -0.00355279f, 
    0.00661719f, 0.03749479f, -0.10088373f, -0.02481443f, 0.29083109f, -0.30881348f, -0.07743009f, 0.09579100f, 
    0.16074789f, -0.03904948f, 0.09261405f, -0.07774079f, -0.00125299f, 0.04957925f, -0.05461120f, -0.00845877f, 
    -0.22869150f, 0.43022075f, -0.11611272f, -0.30582196f, 0.09570965f, 0.02864316f, -0.06956181f, -0.00245427f, 
    -0.07493383f, -0.08796161f, -0.08405520f, -0.00306457f, 0.01297295f, -0.19418597f, 0.06120880f, -0.02259587f, 
    0.10843685f, 0.02258201f, -0.03399304f, 0.04123139f, -0.06787040f, 0.02188474f, 0.09205857f, -0.01213573f, 
    -0.17624496f, 0.16293046f, -0.07363916f, -0.13008066f, 0.10025550f, -0.06311211f, 0.04869522f, -0.04843124f, 
    -0.05249433f, -0.11076832f, 0.01846073f, 0.00182607f, 0.28643605f, 0.09148080f, 0.03994125f, 0.10150190f, 
    0.02345258f, 0.01664216f, 0.02976575f, 0.06087030f, 0.05776550f, 0.14075989f, -0.10416152f, 0.14048809f, 
    -0.32602111f, 0.11536803f, 0.00291009f, -0.05054400f, 0.08322683f, 0.03497670f, -0.06861824f, 0.16464308f, 
    -0.07769976f, 0.05179190f, -0.11481091f, 0.05625628f, -0.10564306f, 0.01619622f, 0.10650234f, 0.25985122f, 
    0.11250123f, -0.01403841f, 0.07763217f, -0.04816290f, -0.09056038f, 0.07232291f, 0.04137405f, 0.04208658f, 
    -0.33064517f, -0.19750157f, -0.01066260f, -0.08339138f, 0.09078450f, 0.00284179f, -0.05425396f, 0.14461312f, 
    0.15232830f, 0.00058970f, 0.15094078f, 0.12482240f, 0.09248462f, 0.15877661f, 0.03286130f, 0.14035060f, 
    -0.15006438f, -0.00171661f, 0.08099765f, 0.07372887f, -0.04773671f, 0.04865836f, -0.00970808f, 0.00698165f, 
    -0.06354194f, -0.06656399f, -0.09026244f, -0.02457523f, 0.11450962f, 0.15242895f, 0.12816547f, 0.01227406f, 
    0.08600775f, 0.02271562f, 0.12444054f, -0.03182996f, 0.16468948f, -0.15322694f, 0.03778523f, -0.05435019f, 
    0.08315054f, 0.01871996f, -0.07593085f, -0.01318360f, -0.00332612f, 0.13398954f, 0.00633778f, -0.08431354f, 
    -0.01854068f, 0.34034082f, -0.31500611f, -0.04995179f, -0.10159342f, 0.12610884f, -0.09920447f, 0.17147881f, 
    0.04873584f, 0.11385629f, -0.18368310f, 0.00386548f, -0.01012004f, 0.16570140f, 0.30177397f, 0.06540035f, 
    0.14355457f, -0.08246050f, 0.02652244f, 0.08535266f, -0.13461730f, -0.04223009f, 0.02388909f, -0.01701619f, 
    0.24516262f, 0.17784949f, 0.13001357f, -0.07202889f, 0.05981587f, 0.07598849f, -0.05784696f, 0.02288390f, 
    -0.07069390f, 0.04383665f, 0.07655986f, -0.02747868f, 0.11304330f, 0.14310472f, 0.04948126f, 0.11113733f, 
    0.08648601f, 0.04346342f, -0.00592397f, 0.15236764f, 0.22686718f, 0.04434411f, -0.00736673f, 0.04813606f, 
    -0.00605593f, -0.00262736f, -0.23681897f, -0.16961329f, 0.09486348f, -0.05472861f, -0.16250834f, 0.04905351f, 
    -0.04463770f, -0.09273186f, 0.14203371f, -0.02204151f, -0.25574765f, -0.09998458f, -0.06593784f, -0.10011633f, 
    0.02973724f, -0.03750387f, -0.00406958f, 0.13543525f, -0.06661754f, 0.02844174f, -0.05033812f, -0.07512050f, 
    -0.15879637f, -0.15733169f, -0.06406138f, 0.00772039f, -0.04629726f, -0.07746148f, -0.05455258f, -0.00305346f, 
    0.06372440f, 0.02764007f, -0.01201818f, -0.06978305f, 0.01436969f, -0.12903896f, 0.26905012f, 0.30748329f, 
    -0.11361336f, -0.08091967f, -0.09645947f, -0.08843187f, -0.05547193f, 0.09853447f, 0.01739716f, -0.04337718f, 
    -0.14168549f, 0.03101888f, -0.43688986f, 0.14841360f, 0.11712127f, 0.11139225f, -0.03943835f, -0.06637780f, 
    0.02872043f, -0.03107321f, 0.11827270f, 0.06156277f, -0.13820760f, -0.21491320f, 0.16859126f, -0.06447499f, 
    0.07357346f, 0.04220339f, -0.00628167f, 0.19075467f, 0.06880192f, 0.00867524f, 0.04039859f, -0.04671318f, 
    -0.12802929f, -0.16168231f, -0.15974551f, -0.22099866f, 0.17362939f, 0.13232005f, -0.10795458f, -0.07127981f, 
    0.03550811f, 0.06006180f, 0.11664761f, -0.04832982f, 0.03449357f, -0.04070020f, 0.07005583f, 0.33647165f, 
    -0.04347554f, 0.03105182f, 0.08767269f, -0.10527513f, -0.03633984f, 0.13755433f, -0.04185299f, 0.10873844f, 
    -0.05532985f, 0.03344843f, 0.05998448f, -0.06025608f, -0.02308582f, 0.03574359f, 0.03509543f, 0.03705031f, 
    -0.07897727f, -0.05329721f, 0.01249141f, -0.00772498f, 0.05127216f, 0.01307364f, -0.07598881f, -0.00599101f, 
    0.02059096f, 0.04566043f, -0.04388339f, 0.04906346f, 0.02773843f, 0.00928087f, -0.07563593f, -0.01449017f, 
    -0.05405834f, -0.03918823f, -0.01007549f, -0.01606570f, -0.00595023f, -0.01317035f, -0.01779540f, -0.07046755f, 
    0.03355575f, 0.01742990f, -0.04140386f, -0.01457679f, 0.01117535f, -0.01376328f, -0.07261823f, -0.06646967f, 
    -0.04453769f, -0.06642181f, -0.03675265f, 0.04069649f, -0.03237997f, 0.00836930f, -0.05408863f, 0.04025052f, 
    0.02785552f, -0.01492259f, 0.03754266f, -0.00666186f, -0.07078609f, 0.03058537f, 0.04214262f, -0.02462363f, 
    0.03158874f, 0.05489286f, -0.05987530f, 0.01102034f, -0.07060820f, -0.01888237f, -0.02807751f, -0.03262490f, 
    0.00106044f, 0.01303904f, 0.00164112f, 0.02416399f, 0.04005550f, -0.06420901f, -0.03680204f, 0.05209292f, 
    -0.01508649f, 0.03249172f, 0.02298784f, -0.01150875f, -0.03630237f, 0.05313839f, -0.00479753f, 0.01632719f, 
    -0.03313029f, -0.04467104f, 0.03573641f, 0.05117962f, -0.03456751f, 0.00032521f, -0.03944204f, 0.00170675f, 
    0.06563596f, -0.06963962f, -0.04331052f, 0.00726674f, 0.03863490f, 0.00470502f, -0.01845351f, -0.07197955f, 
    0.02845029f, 0.04516749f, -0.07583681f, -0.02816319f, -0.06100409f, -0.07590117f, -0.02132042f, -0.04026763f, 
    -0.06819445f, -0.04407090f, -0.04245346f, -0.01527942f, 0.00470603f, -0.04861165f, -0.02048757f, 0.02561697f, 
    -0.06738562f, -0.07528099f, 0.04865257f, -0.02981923f, 0.02684241f, -0.04823872f, -0.07921977f, -0.07084423f, 
    -0.00351013f, -0.06935292f, -0.06068237f, 0.03307706f, -0.02101129f, 0.02697628f, -0.02432409f, -0.01218735f, 
    0.05870143f, -0.07077844f, -0.04164004f, -0.01894350f, 0.02102961f, -0.01410697f, 0.02971532f, 0.03642064f, 
    -0.02375750f, 0.04543454f, -0.03696586f, -0.06971654f, -0.02000026f, 0.01543833f, 0.02559882f, 0.04454587f, 
    -0.05824468f, 0.05109442f, -0.02743147f, 0.05438986f, -0.07250073f, 0.02205708f, 0.02918806f, 0.05217114f, 
    -0.00721542f, -0.07671999f, -0.02341143f, 0.04520857f, -0.03141643f, -0.07979939f, 0.02161335f, 0.03970593f, 
    -0.06713711f, -0.02715033f, 0.01074320f, 0.00941439f, -0.07585742f, 0.05709580f, 0.02791668f, -0.00761838f, 
    -0.03232414f, 0.00116627f, 0.00454568f, 0.03862946f, -0.06837743f, 0.03578750f, 0.04089887f, 0.04981051f, 
    -0.03124986f, -0.02588614f, 0.04198441f, 0.01128375f, 0.04332986f, -0.00491553f, 0.00857866f, 0.02172562f, 
    -0.04825711f, 0.02857937f, -0.02652522f, 0.03413415f, -0.05665972f, -0.01169389f, -0.05736697f, -0.00132518f, 
    -0.25121504f, 0.08314870f, -0.00097937f, -0.09358270f, -0.00644375f, 0.14213608f, 0.03999853f, 0.01791673f, 
    0.03315035f, -0.00024049f, 0.13955696f, 0.14204174f, 0.25979963f, -0.19172186f, -0.12379681f, -0.16094981f, 
    -0.06786806f, -0.13802740f, 0.03128707f, 0.18825018f, -0.01432186f, 0.05566730f, -0.04066558f, 0.06305263f, 
    0.09929223f, 0.17495868f, 0.08795058f, 0.10807925f, -0.08059196f, 0.14648949f, 0.13777401f, 0.05121756f, 
    0.00908697f, 0.11213175f, 0.00505516f, 0.13850595f, -0.05000923f, -0.25804159f, 0.17627355f, 0.07810830f, 
    0.10194594f, -0.05703521f, -0.09049505f, 0.20169996f, -0.11074965f, 0.01559550f, 0.03188987f, -0.13287453f, 
    -0.22545417f, -0.11147307f, 0.20543177f, 0.07214453f, -0.07886629f, 0.11256397f, 0.03634762f, 0.11174244f, 
    -0.05765921f, -0.04473215f, 0.05611470f, 0.04584861f, 0.03994636f, 0.12918146f, -0.02595612f, 0.00625889f, 
    0.17759836f, 0.00180288f, 0.00521265f, -0.07278796f, -0.04862250f, -0.14953680f, -0.00532940f, -0.01435249f, 
    -0.17525835f, -0.00078406f, -0.07863523f, 0.15397611f, 0.14432795f, 0.00845581f, -0.07793644f, -0.04420928f, 
    -0.00932893f, 0.14735292f, -0.02624088f, -0.07731287f, 0.18268520f, 0.07879846f, -0.04275185f, 0.22066118f, 
    -0.05611672f, 0.02623276f, 0.11854486f, 0.02860365f, -0.04247930f, -0.16697551f, -0.02095876f, 0.12881543f, 
    0.03547180f, 0.10076512f, 0.07360218f, -0.21750517f, 0.09804033f, 0.07122932f, 0.10641479f, 0.02513904f, 
    -0.00961220f, 0.13677581f, -0.12109480f, 0.13872425f, -0.09464867f, -0.00388618f, 0.12595631f, -0.08552980f, 
    0.01090345f, 0.01515966f, 0.12830482f, 0.02587101f, 0.00966428f, -0.11184444f, -0.01102008f, -0.13226451f, 
    0.30724797f, 0.09282773f, -0.07104042f, -0.04111524f, 0.09829585f, -0.11869198f, 0.02351469f, -0.03419980f, 
    -0.08392562f, -0.04267752f, -0.05594248f, -0.10127963f, -0.16186973f, -0.01433609f, -0.17055580f, -0.20884088f, 
    -0.02288741f, 0.03992892f, -0.00165442f, 0.07963458f, -0.11579244f, -0.02966913f, 0.05902788f, -0.05244169f, 
    0.10182288f, -0.14361998f, 0.18157397f, -0.03900774f, 0.05086334f, 0.13633107f, 0.09995173f, 0.11068013f, 
    -0.08609421f, 0.02617569f, -0.12879772f, -0.03839028f, 0.06253842f, -0.01964743f, 0.03345256f, 0.10191844f, 
    0.08741692f, 0.02986754f, 0.05621316f, -0.03103884f, 0.02240213f, 0.07390875f, 0.09264502f, 0.03554307f, 
    0.18655649f, -0.02698650f, -0.16652337f, -0.17604902f, 0.05064407f, 0.06766576f, 0.00999939f, -0.02913942f, 
    -0.06847287f, 0.01109869f, -0.15668607f, 0.11951037f, 0.22553785f, -0.00275370f, 0.03641600f, 0.04406664f, 
    -0.04429324f, 0.06814621f, 0.06598198f, -0.05430949f, 0.05634016f, 0.08917230f, 0.03223712f, 0.06257148f, 
    -0.05635671f, -0.10329690f, -0.04760506f, 0.04156168f, -0.04417539f, 0.02541216f, -0.02108923f, 0.04725803f, 
    0.00382986f, 0.03768781f, -0.03730931f, -0.02292401f, -0.23737046f, 0.32751256f, -0.05049118f, 0.14232199f, 
    0.03442411f, 0.02758876f, 0.09862317f, -0.05540407f, -0.10602399f, -0.03947572f, 0.12660250f, -0.04385325f, 
    -0.44020736f, 0.21772844f, 0.01586991f, -0.06425274f, -0.03094346f, 0.03472850f, 0.04537482f, -0.01849798f, 
    -0.01417193f, 0.01199812f, 0.03097215f, -0.09742837f, -0.03739534f, 0.14311951f, -0.06636170f, -0.01457281f, 
    -0.05263053f, 0.03738228f, 0.05947873f, -0.04874653f, 0.07316881f, 0.07101808f, 0.12364883f, 0.16402607f, 
    0.02990412f, 0.21211542f, -0.09802569f, 0.05348466f, 0.04502267f, -0.06957449f, 0.08718248f, -0.00125354f, 
    -0.03859692f, -0.01496224f, -0.04522975f, -0.03832764f, -0.22915804f, 0.10514799f, 0.11547334f, 0.00994872f, 
    0.05324687f, -0.03206499f, 0.09162511f, -0.03609737f, 0.09455691f, 0.02316309f, 0.02605240f, 0.09423386f, 
    0.07735544f, 0.15234587f, 0.14259595f, 0.26801947f, 0.02268295f, 0.00931905f, 0.08572358f, -0.03250903f, 
    -0.07628685f, 0.00399083f, 0.06411316f, 0.10902397f, 0.20306136f, -0.05103080f, 0.11337717f, 0.12078688f, 
    -0.06901370f, -0.11917607f, -0.02598431f, -0.04292644f, 0.20941840f, 0.01000693f, -0.04003135f, 0.04953806f, 
    -0.28429180f, 0.28423378f, -0.20032005f, 0.09183205f, -0.11317503f, -0.20897543f, -0.08568146f, 0.09380415f, 
    0.00672974f, 0.03945546f, -0.00489067f, -0.03253855f, -0.13039190f, 0.08824304f, 0.11145120f, 0.09198151f, 
    -0.09805700f, -0.02095135f, -0.01984524f, 0.04906913f, -0.10453495f, 0.12688541f, 0.17027934f, 0.05363604f, 
    -0.22604287f, -0.19376312f, -0.12676243f, 0.09627146f, -0.04933421f, 0.07462476f, -0.03186736f, 0.07076100f, 
    0.09044080f, 0.07411376f, 0.11908676f, 0.08935959f, -0.11856417f, 0.05300231f, 0.07262642f, 0.03813579f, 
    0.05925089f, -0.01131323f, 0.07308252f, 0.03693265f, 0.04815002f, 0.10944898f, -0.06056395f, 0.10982491f, 
    -0.14036833f, 0.06942689f, -0.07957957f, 0.10276103f, 0.01848167f, -0.01130171f, -0.04957367f, 0.04931819f, 
    0.15181838f, 0.05132213f, 0.08317190f, 0.10126055f, 0.15901193f, 0.01905587f, -0.02287741f, -0.12249215f, 
    -0.07978791f, 0.12082468f, -0.03147709f, -0.08928350f, 0.10587870f, 0.08048840f, -0.04761523f, -0.01118564f, 
    -0.09458176f, 0.00654320f, 0.05316507f, 0.09090962f, -0.09190742f, 0.01119746f, -0.05306043f, -0.04932610f, 
    0.00639039f, -0.02355281f, 0.15655583f, -0.01489954f, -0.19177368f, -0.08885947f, -0.00892928f, 0.12771733f, 
    0.01032327f, -0.03267278f, 0.02470028f, -0.05870021f, 0.01625235f, -0.10396717f, -0.08010984f, -0.05668282f, 
    0.21743771f, -0.01367017f, 0.03508292f, -0.01696523f, 0.01235245f, 0.11463106f, 0.05765471f, -0.04061590f, 
    0.03711901f, -0.08764032f, 0.02244310f, -0.10536876f, -0.10568065f, 0.09781021f, -0.16266727f, 0.14177822f, 
    0.00815762f, 0.02735730f, 0.01679469f, -0.02625497f, -0.04585394f, -0.12065647f, 0.12968513f, -0.08343499f, 
    -0.38205671f, -0.01767889f, 0.02822924f, -0.17914823f, 0.13722830f, 0.02783682f, 0.06983047f, 0.00358875f, 
    -0.06391647f, -0.03654338f, -0.00612221f, -0.09910896f, -0.14449315f, -0.10898189f, 0.14622143f, -0.06628143f, 
    0.03236166f, 0.01050274f, 0.00807670f, 0.00897548f, 0.14367798f, 0.01843861f, 0.04638881f, 0.11163997f, 
    -0.40450835f, -0.00303578f, -0.01524390f, -0.17253350f, 0.00662040f, -0.00512415f, 0.00696125f, -0.07785355f, 
    0.01407246f, 0.03329829f, -0.02371356f, -0.06953774f, -0.00951090f, 0.07338674f, -0.07964579f, 0.08329795f, 
    -0.01561385f, -0.02884390f, -0.15409847f, -0.06170219f, 0.02041941f, 0.10667015f, 0.07066968f, 0.11866309f, 
    0.01888392f, -0.05609909f, -0.05641299f, 0.16102974f, 0.12062714f, 0.03097167f, 0.00096677f, 0.07224274f, 
    -0.03240176f, -0.02589517f, 0.05325078f, 0.04980169f, 0.02975507f, 0.04146608f, 0.14231616f, 0.06323354f, 
    0.05197971f, -0.00197822f, 0.16948722f, -0.05922828f, -0.01235951f, 0.14687780f, 0.08396226f, 0.13252018f, 
    -0.21700160f, 0.19672839f, 0.04959061f, -0.04487678f, 0.06749572f, 0.09041027f, -0.04682059f, 0.11776601f, 
    0.09237397f, 0.01756026f, 0.03801188f, 0.07806340f, -0.02814093f, 0.14378196f, -0.07009845f, -0.10660857f, 
    0.05396648f, 0.05420957f, 0.05619215f, 0.00590086f, 0.00815207f, 0.01507656f, 0.10188912f, 0.16487715f, 
    0.04364432f, -0.07705071f, 0.03561101f, -0.02242072f, -0.01740871f, 0.11139645f, 0.03010207f, 0.05050959f, 
    -0.01088035f, 0.03173697f, -0.01870701f, 0.14479347f, 0.11625239f, 0.11767641f, -0.20797886f, 0.04448114f, 
    -0.01901260f, -0.05025095f, -0.01134759f, 0.13942941f, 0.08264101f, -0.07191871f, 0.02830639f, -0.07997102f, 
    0.03075754f, -0.04536127f, 0.01595870f, -0.03977613f, -0.05943348f, -0.08340836f, 0.04587430f, -0.10764471f, 
    0.03845155f, 0.06014313f, -0.00483489f, 0.04528446f, -0.11061373f, 0.05891973f, -0.03581912f, 0.00428679f, 
    -0.07968980f, -0.02875664f, 0.05421107f, 0.05514570f, 0.07426175f, 0.02038440f, 0.05189383f, 0.07433206f, 
    -0.11754140f, 0.02170671f, 0.15830600f, 0.09357565f, 0.07561450f, 0.10515638f, -0.00775510f, -0.04509302f, 
    -0.03883538f, -0.03795692f, -0.00668079f, -0.09381520f, -0.04803586f, -0.15952548f, 0.14619809f, -0.06539661f, 
    -0.00087409f, 0.10063355f, 0.09970522f, 0.09468820f, 0.01351349f, -0.07233074f, 0.03156076f, -0.05089402f, 
    0.04736820f, -0.05238855f, 0.03895386f, -0.03741209f, -0.04540521f, 0.02328429f, -0.02019601f, -0.06949884f, 
    0.03207728f, 0.04435966f, -0.00957896f, -0.05535031f, 0.01444648f, -0.05969650f, -0.06445412f, -0.05339124f, 
    0.02114895f, -0.02804775f, -0.00754997f, -0.01903068f, -0.06142774f, 0.01264276f, 0.04328189f, -0.07143074f, 
    -0.03543820f, 0.05084562f, 0.01249901f, -0.07216727f, -0.00506642f, 0.00282017f, 0.04403557f, -0.00214458f, 
    0.00479697f, 0.03223912f, -0.05660897f, 0.00148177f, -0.08029646f, 0.05931060f, -0.07475931f, -0.00447011f, 
    0.03151324f, -0.07277200f, -0.02650075f, 0.01471213f, -0.03819745f, -0.01392668f, -0.05869430f, 0.00262122f, 
    0.03396572f, -0.07486873f, -0.00681550f, -0.03502269f, 0.03251518f, -0.02287278f, -0.01490449f, -0.05635507f, 
    0.00405577f, -0.06207957f, -0.05795763f, -0.06007418f, -0.07007099f, -0.03478735f, 0.00611925f, 0.01530569f, 
    0.05444585f, -0.02510639f, -0.00867541f, 0.02551060f, -0.02030755f, 0.04634234f, -0.03937909f, -0.05784892f, 
    -0.02158759f, -0.06315828f, -0.03773588f, 0.05956245f, -0.05876878f, 0.03538876f, 0.00137710f, -0.04899401f, 
    0.05967902f, -0.02751959f, 0.04920985f, -0.01394893f, -0.00192304f, 0.01170703f, -0.02868506f, 0.00146129f, 
    -0.05053111f, 0.05454671f, -0.03614042f, -0.05946722f, 0.05707671f, 0.03333715f, 0.03169476f, 0.03077200f, 
    0.01887847f, 0.04222685f, -0.00001135f, -0.01068467f, 0.04893887f, -0.05055754f, 0.05942388f, -0.01839330f, 
    -0.03951272f, -0.02430196f, -0.01086118f, 0.03909626f, -0.02693914f, -0.00459178f, -0.06629393f, 0.00173914f, 
    0.04520793f, -0.06550274f, 0.03667938f, 0.03345198f, 0.04629657f, -0.05124062f, 0.02370282f, -0.06611122f, 
    0.03635440f, -0.03681176f, 0.01085099f, 0.02706946f, -0.06814013f, -0.04144726f, -0.01758714f, 0.03606213f, 
    -0.00230547f, 0.03102234f, -0.03394909f, -0.00414561f, -0.01929097f, 0.05588118f, -0.03768560f, 0.04182599f, 
    -0.03390288f, -0.03553847f, -0.01185577f, -0.05072006f, 0.02114825f, 0.04014634f, 0.05296959f, -0.03145880f, 
    -0.03722942f, -0.01828104f, -0.02426880f, -0.02983266f, 0.01412056f, -0.07809367f, -0.06194319f, 0.01261918f, 
    0.02706915f, 0.04564330f, -0.00966352f, 0.02069658f, -0.05094100f, 0.00991203f, -0.06523245f, 0.02475568f, 
    -0.03288342f, 0.00744018f, 0.01700754f, -0.04205800f, -0.01598790f, -0.06704293f, 0.00440510f, 0.04931474f, 
    0.06131893f, -0.00864620f, 0.03739486f, -0.01158859f, -0.06344347f, 0.03411902f, 0.00482449f, 0.01300866f, 
    -0.03388997f, 0.06594606f, 0.04612224f, -0.07393501f, 0.04135095f, 0.02484541f, 0.04790195f, 0.01233711f, 
    0.02663300f, 0.03083903f, -0.06108240f, -0.05220179f, -0.02649796f, -0.03025940f, -0.05494330f, -0.06860103f, 
    -0.07718717f, -0.03105943f, -0.04947448f, -0.06294321f, 0.02667869f, -0.03983176f, -0.00708510f, 0.03527876f, 
    -0.06517047f, 0.01562380f, 0.04862159f, -0.00193429f, -0.00638690f, -0.04244207f, -0.05451701f, 0.00156214f, 
    0.04461101f, -0.05337317f, 0.01675759f, -0.06696838f, -0.01121730f, 0.03060953f, 0.02510979f, -0.03522253f, 
    -0.02064513f, -0.01790065f, -0.05550081f, -0.00115652f, -0.07022861f, 0.04166379f, -0.00566157f, -0.07671820f, 
    -0.01320974f, -0.04420161f, -0.07653984f, -0.01910422f, -0.03633261f, 0.02758047f, 0.01198925f, -0.02054140f, 
    0.05544309f, 0.05749627f, -0.03306146f, -0.00545467f, -0.07692733f, -0.07686637f, 0.01127113f, -0.07054741f, 
    0.01142970f, -0.01391009f, 0.06270202f, 0.02254705f, -0.00360203f, 0.05475359f, 0.01405529f, 0.04048733f, 
    0.03292048f, 0.04982973f, -0.03469464f, 0.00455902f, -0.07429289f, 0.04720820f, 0.02520836f, -0.03754028f, 
    0.02400390f, 0.06431220f, -0.07390866f, -0.04882717f, -0.05281931f, -0.04489296f, -0.01021135f, -0.02348389f, 
    -0.02836652f, -0.06835967f, 0.02802992f, 0.01719190f, -0.05068700f, 0.00730342f, -0.04155866f, 0.01124300f, 
    0.02889849f, -0.02261326f, -0.07504658f, 0.04871881f, 0.03977926f, 0.04835429f, -0.00215863f, -0.07628439f, 
    -0.06523608f, -0.02233259f, 0.00346802f, 0.01746253f, 0.00069528f, 0.02418209f, -0.05043905f, 0.01030896f, 
    -0.05379084f, -0.00637190f, 0.06441253f, -0.05717342f, -0.03880451f, -0.07460552f, -0.06534448f, -0.04206995f, 
    -0.04167670f, 0.05813790f, -0.02537750f, 0.06597892f, -0.06182308f, 0.03208812f, -0.00310025f, -0.06317501f, 
    0.03449526f, 0.06659929f, 0.05276722f, -0.00057448f, 0.02649342f, 0.00956859f, -0.02857074f, -0.04948535f, 
    0.02673418f, -0.00852504f, 0.00170497f, 0.02203253f, -0.04361103f, 0.01326991f, -0.02944394f, 0.04356493f, 
    -0.04214638f, 0.00080622f, 0.03658132f, -0.06568164f, -0.01564480f, 0.06055774f, -0.02259494f, 0.04371094f, 
    0.00012976f, -0.02801579f, 0.03835494f, 0.02179382f, 0.06570312f, 0.06398713f, -0.01022260f, -0.04506770f, 
    0.02791355f, -0.03075729f, 0.03818573f, -0.04683918f, -0.02206858f, -0.05354861f, 0.05673083f, -0.05763260f, 
    -0.05259762f, -0.01000276f, -0.05361988f, -0.00443692f, 0.03398015f, -0.00979031f, -0.04638216f, 0.04105918f, 
    0.04420170f, -0.02082876f, 0.05578595f, -0.06533823f, 0.06341536f, -0.05228774f, 0.06124350f, -0.06542484f, 
    0.00504889f, -0.07249934f, 0.03295227f, 0.06648373f, -0.04706789f, 0.05957888f, 0.03443052f, -0.07749327f, 
    -0.02395242f, -0.00959662f, 0.01736305f, 0.04304690f, 0.04126341f, 0.06129863f, -0.03807415f, -0.06364319f, 
    0.04722928f, -0.00072391f, 0.03563265f, -0.05868843f, -0.07039449f, -0.01051183f, -0.06719539f, -0.05345510f, 
    -0.03107374f, -0.01513364f, -0.01532722f, -0.06061525f, -0.05130769f, -0.06278486f, -0.05385803f, -0.05893140f, 
    -0.02481871f, 0.06227539f, -0.04215069f, -0.06073747f, -0.05355871f, -0.01665399f, 0.07067923f, -0.03644230f, 
    -0.07676962f, 0.04277603f, -0.00650970f, 0.01721501f, 0.04388966f, 0.00176411f, -0.06761464f, -0.01146967f, 
    -0.04250265f, -0.04528939f, -0.06970818f, 0.00475792f, -0.03840625f, -0.04128687f, -0.01111681f, -0.00534879f, 
    -0.01588456f, 0.03154841f, 0.00839228f, -0.02063484f, -0.04390642f, 0.04884766f, 0.01476880f, -0.00431683f, 
    0.05645374f, -0.02143201f, -0.06597461f, 0.00493101f, -0.04708340f, 0.01164994f, 0.06981207f, -0.00069082f, 
    0.00511925f, 0.00109034f, -0.01837710f, 0.00079617f, 0.05064967f, -0.02887493f, 0.02938700f, -0.05381121f, 
    0.01858952f, 0.00300430f, -0.04221900f, 0.01196907f, -0.06454253f, 0.04502385f, -0.00742721f, -0.05285052f, 
    -0.05432156f, -0.02214210f, -0.06667299f, 0.01749401f, -0.01713579f, -0.03353580f, -0.05746391f, -0.06503434f, 
    0.00877928f, 0.05601651f, 0.02810348f, 0.02564324f, -0.05450593f, 0.05548142f, -0.04426676f, -0.03036994f, 
    0.00477644f, 0.01362234f, -0.00344333f, 0.04057279f, 0.00304127f, 0.01602649f, -0.01211651f, 0.01497342f, 
    0.05913580f, 0.05733223f, -0.01484297f, -0.00665607f, -0.03767080f, -0.03997299f, -0.01367642f, -0.02966624f, 
    -0.03397547f, 0.03844322f, 0.01271239f, -0.06286672f, 0.04416909f, 0.00620712f, 0.01924327f, -0.01820183f, 
    0.05944499f, -0.02668223f, -0.08687764f, -0.02545100f, -0.01079521f, 0.04780649f, -0.06272936f, -0.05240205f, 
    -0.02203101f, 0.04574196f, 0.03378202f, 0.04781934f, 0.01049011f, 0.00005397f, 0.04490498f, 0.01055401f, 
    -0.08163810f, -0.05576018f, -0.03429111f, 0.04790652f, -0.01839901f, -0.07066346f, 0.04111288f, 0.03453095f, 
    0.06358942f, -0.01480237f, 0.00925145f, -0.05443077f, 0.02063415f, -0.05629772f, -0.00297059f, -0.06676504f, 
    -0.04991561f, -0.06373146f, -0.00201877f, -0.06692230f, -0.00352219f, 0.04205840f, 0.00745185f, -0.05082372f, 
    -0.04975407f, -0.06793991f, 0.04801382f, -0.00790388f, 0.03406102f, -0.00125217f, -0.04551988f, -0.00413409f, 
    -0.02144286f, -0.03333017f, -0.00144610f, 0.00710411f, 0.03955008f, -0.05431861f, -0.03769603f, -0.02034577f, 
    -0.01632801f, -0.01907125f, 0.06183141f, -0.07111535f, 0.03721889f, 0.06620242f, 0.04973034f, 0.04828754f, 
    0.04258111f, -0.02412627f, 0.04392889f, -0.04506977f, -0.03762982f, -0.03260916f, -0.07107480f, -0.02243093f, 
    0.01251054f, 0.04422963f, 0.02380361f, -0.05217728f, 0.00569213f, 0.04502195f, -0.02352795f, -0.02232465f, 
    -0.07046411f, 0.00486852f, -0.05359491f, 0.04292128f, 0.05650283f, 0.04264602f, -0.00973482f, -0.05370016f, 
    -0.08637308f, 0.00529096f, -0.07644116f, -0.26730359f, 0.07356843f, -0.02257730f, -0.02074841f, 0.14236717f, 
    0.04882777f, -0.00616201f, 0.06920124f, 0.08048611f, 0.13991064f, -0.19860171f, 0.18433930f, 0.02288833f, 
    -0.03305328f, -0.07604254f, -0.00360867f, -0.05655366f, 0.11077212f, -0.19449137f, -0.01927927f, -0.05907813f, 
    -0.03704901f, -0.02599329f, 0.22842057f, -0.19388387f, 0.11381096f, 0.01132085f, 0.06233846f, -0.10513404f, 
    0.05708837f, 0.01875108f, -0.03887834f, -0.04211627f, -0.18004206f, 0.04065852f, 0.13050942f, 0.00386801f, 
    0.08876133f, -0.16233917f, 0.06800741f, 0.06751666f, 0.07545418f, -0.02263746f, 0.09528232f, -0.00554903f, 
    0.01731648f, -0.28306761f, -0.00707197f, 0.07562835f, 0.01807164f, 0.08738298f, -0.18165673f, 0.02694256f, 
    0.01404567f, 0.05131343f, 0.02674979f, -0.04091905f, 0.20755842f, 0.21018469f, -0.17184533f, -0.13010867f, 
    0.06074615f, -0.03436058f, -0.13044743f, 0.01965638f, 0.06552086f, -0.00774594f, 0.04332004f, 0.02739819f, 
    -0.23853855f, 0.09470214f, -0.20039877f, -0.12247537f, 0.08910953f, 0.05240365f, -0.01752993f, -0.06109475f, 
    0.12548251f, -0.07329947f, -0.02817922f, -0.05172641f, 0.07050262f, 0.14723581f, -0.00122360f, 0.17878252f, 
    0.13821790f, 0.08258673f, 0.07738350f, 0.14660563f, -0.05514339f, 0.01192951f, 0.05165681f, 0.13190341f, 
    -0.03682390f, -0.08836118f, 0.06317014f, -0.29230586f, 0.14608699f, -0.05084416f, -0.03809904f, 0.01376184f, 
    0.08880549f, 0.04130546f, -0.04464224f, 0.11893825f, 0.20370162f, -0.03613355f, -0.03004664f, 0.15411001f, 
    0.07325538f, 0.01528542f, 0.01361563f, 0.07382546f, -0.03718487f, 0.00294794f, 0.13947834f, 0.00130367f, 
    0.06763422f, 0.15652777f, -0.18541515f, -0.14752553f, 0.17631294f, 0.11939534f, 0.08575981f, -0.10250303f, 
    0.00013790f, -0.02207234f, 0.04686440f, 0.05222164f, 0.10328463f, 0.13996539f, -0.15764777f, 0.26534206f, 
    -0.09546683f, -0.13855878f, -0.12756468f, 0.06497854f, -0.05243809f, 0.03555817f, -0.06757933f, -0.06125697f, 
    -0.05553324f, -0.20075290f, -0.14508083f, 0.15043095f, 0.15636578f, 0.00699100f, 0.08683287f, -0.12557437f, 
    0.05868711f, -0.01343778f, 0.05659339f, -0.05330250f, -0.03358561f, -0.01189071f, 0.18662395f, 0.21887478f, 
    -0.02982062f, -0.04957806f, 0.02282623f, 0.21235695f, -0.03540443f, 0.01275882f, -0.01568739f, -0.00560536f, 
    -0.16681275f, -0.01972377f, -0.17226785f, -0.24663320f, 0.17849925f, -0.03043916f, 0.01085563f, -0.02184801f, 
    -0.03900700f, 0.08976605f, 0.03849128f, 0.01197543f, -0.05493043f, 0.10771783f, 0.07785138f, 0.15627602f, 
    0.00690836f, 0.01898463f, -0.10134593f, -0.08853219f, 0.05295876f, 0.01354440f, 0.05110443f, 0.08209661f, 
    0.20934467f, -0.20045732f, -0.01709725f, 0.20675923f, 0.03715136f, 0.09403362f, 0.13790201f, 0.03311578f, 
    0.05908284f, 0.05501358f, -0.08052011f, -0.04621175f, 0.08835799f, 0.09203893f, -0.06746813f, 0.04557786f, 
    0.09680772f, -0.04507915f, 0.01472535f, -0.02489565f, -0.01455129f, 0.02540797f, -0.00776513f, 0.01998562f, 
    0.41201401f, -0.13438365f, -0.24499415f, 0.07668266f, 0.02204719f, 0.00369938f, -0.07836268f, 0.10272041f, 
    -0.00904956f, 0.04120893f, -0.01060880f, -0.05889922f, 0.15314257f, -0.11971458f, -0.00739683f, -0.13579841f, 
    -0.06247510f, 0.02530384f, 0.04087073f, -0.05876639f, -0.02749113f, -0.01660342f, 0.01359453f, 0.11126570f, 
    -0.07233761f, 0.23131797f, -0.06667169f, -0.18738377f, 0.02713524f, -0.01388226f, 0.10893146f, -0.03443027f, 
    0.00815622f, 0.03261565f, -0.02412099f, 0.01351306f, -0.08812799f, -0.25487956f, 0.16916443f, 0.23246571f, 
    0.04882548f, 0.05430812f, 0.07717565f, -0.02793026f, -0.10967816f, 0.04295190f, 0.02540492f, -0.00959969f, 
    0.18734404f, -0.23833428f, 0.12168405f, -0.07577454f, -0.11281007f, -0.03090511f, -0.06361781f, 0.09180492f, 
    -0.02276885f, 0.01755420f, -0.06309447f, 0.09054356f, -0.03583008f, -0.01245255f, 0.07163206f, -0.04116713f, 
    0.05568670f, 0.09678339f, -0.07603813f, -0.03649240f, -0.02264017f, 0.04458601f, 0.01032310f, -0.03573957f, 
    0.09071565f, -0.12174983f, 0.04173929f, 0.31523004f, -0.03049209f, 0.00552244f, -0.01519060f, -0.00095811f, 
    0.04204258f, -0.00684519f, 0.20857495f, -0.01739925f, -0.07331070f, 0.12314764f, 0.07796167f, -0.06302481f, 
    -0.00973038f, -0.03432452f, 0.00087116f, 0.05302141f, 0.03431175f, 0.01306927f, -0.07896528f, -0.00059167f, 
    0.11557510f, -0.33194849f, 0.20088929f, 0.29010299f, 0.01268356f, 0.03864676f, 0.00957370f, -0.02388393f, 
    0.03249288f, 0.00712266f, 0.12088258f, 0.00468385f, 0.19144151f, -0.09622814f, 0.03858738f, -0.03761969f, 
    -0.09471285f, -0.08529651f, 0.08199669f, 0.00415195f, 0.10103318f, -0.03402236f, -0.08264039f, 0.06863970f, 
    0.36802107f, 0.13866957f, 0.11214624f, -0.04725952f, -0.13077821f, 0.00361416f, 0.03684495f, -0.06816474f, 
    0.00745874f, 0.00490254f, -0.02111074f, 0.07846894f, -0.15316831f, 0.08618510f, -0.02009098f, -0.12575583f, 
    -0.00060501f, -0.04531520f, 0.00627993f, -0.04027605f, -0.04114110f, -0.02562495f, 0.05897013f, -0.00665695f, 
    0.05842487f, -0.21317491f, 0.22226043f, 0.34199679f, -0.08732757f, 0.18562184f, 0.10048006f, -0.00825322f, 
    -0.00140648f, -0.09116491f, 0.04723261f, 0.02514779f, -0.05040940f, -0.13996184f, -0.03754001f, -0.26146814f, 
    0.00076817f, 0.04008273f, 0.03912061f, 0.14467812f, 0.04553628f, -0.04051691f, -0.07580729f, 0.02409500f, 
    -0.16504245f, 0.01801549f, 0.02233323f, -0.20494254f, 0.15906750f, -0.13068950f, -0.00354615f, 0.05988190f, 
    0.03414418f, -0.06490079f, -0.18053116f, 0.09999293f, 0.21867800f, 0.01267861f, 0.05987441f, -0.04088565f, 
    -0.15399550f, 0.12134641f, 0.08226858f, -0.12433808f, 0.01319599f, -0.05913309f, -0.11714403f, 0.10227535f, 
    0.12389351f, -0.13702217f, 0.21673423f, 0.08433110f, 0.10378502f, -0.10010714f, -0.18219085f, -0.10443813f, 
    0.04720837f, -0.04280954f, 0.01863950f, -0.03295275f, 0.11529043f, 0.06779275f, -0.09217297f, 0.00903138f, 
    -0.00438125f, 0.02252731f, 0.12169812f, 0.04820391f, 0.13210562f, 0.14229903f, 0.00785287f, -0.04126719f, 
    -0.08461574f, -0.00868816f, -0.19501223f, 0.23513213f, 0.02137710f, 0.04612861f, -0.14617331f, 0.10987000f, 
    0.00719731f, 0.00732935f, 0.06764880f, 0.05925896f, 0.12479146f, 0.22051172f, 0.05769847f, -0.24926989f, 
    0.12716264f, -0.02920771f, 0.10855825f, 0.04218714f, -0.03517287f, 0.06905098f, -0.05920423f, 0.02572028f, 
    0.04447820f, 0.10031117f, -0.20341165f, -0.19646586f, 0.19246426f, 0.06731746f, 0.11496937f, -0.02140791f, 
    0.21330969f, -0.04905319f, 0.08346552f, -0.04706137f, 0.19618341f, 0.18996780f, -0.12234668f, 0.05691210f, 
    0.10610223f, -0.09211232f, 0.06988716f, 0.13026325f, 0.08463760f, 0.10460924f, 0.15525351f, 0.03910352f, 
    0.24603242f, -0.27918929f, -0.05698004f, -0.16217712f, 0.06035255f, -0.02577645f, -0.04602358f, 0.05038894f, 
    -0.08269975f, -0.02932671f, -0.06838711f, 0.02603417f, -0.01316398f, -0.07941717f, -0.04649263f, 0.13610475f, 
    0.02923279f, -0.03214318f, -0.02254982f, 0.08864262f, -0.00068573f, 0.06866044f, 0.02679422f, -0.02621173f, 
    -0.05785581f, -0.01854127f, -0.06654805f, -0.10989770f, 0.18867433f, 0.05817981f, -0.01876403f, -0.01428295f, 
    -0.07268622f, 0.06134303f, 0.00963162f, 0.04082153f, 0.09454491f, 0.01045343f, 0.05286442f, 0.02153406f, 
    -0.18991834f, 0.03891625f, 0.06085298f, -0.01069280f, -0.03256105f, 0.15544921f, 0.04245924f, -0.08776709f, 
    -0.38047442f, -0.02402540f, -0.20026356f, 0.21787733f, 0.25462899f, -0.03116594f, -0.13762102f, -0.00792760f, 
    -0.05673441f, -0.00531005f, -0.02048164f, 0.06126455f, -0.04166101f, -0.11532099f, 0.15065125f, 0.02359449f, 
    -0.01446210f, 0.07899410f, 0.08697837f, 0.09666756f, -0.00469376f, 0.03353493f, 0.09533825f, -0.03804934f, 
    -0.14980403f, -0.16723563f, -0.19355980f, -0.24361959f, 0.05186320f, -0.04166422f, 0.02461824f, -0.15353347f, 
    0.03654745f, 0.03439884f, 0.17189544f, -0.05342957f, -0.08718678f, 0.30180866f, -0.03883807f, 0.37671050f, 
    0.16270751f, 0.12054960f, -0.18378009f, -0.08216856f, 0.15900321f, 0.00795223f, -0.00338835f, -0.05129544f, 
    -0.16884787f, 0.13114612f, -0.01120703f, 0.20361434f, -0.05459395f, 0.08717785f, 0.10710739f, 0.06877411f, 
    -0.04217485f, 0.00024316f, 0.02039217f, 0.24716157f, 0.23373640f, -0.13930123f, -0.08842879f, -0.18429907f, 
    -0.04100389f, -0.01724840f, -0.01408673f, 0.12404034f, 0.02127423f, 0.21368010f, -0.00870669f, 0.14705448f, 
    0.00983290f, -0.09849941f, 0.03598186f, 0.17638822f, 0.04795219f, 0.07911719f, 0.03144370f, 0.08398232f, 
    0.11121599f, 0.03843462f, -0.07544351f, 0.01114922f, 0.16259995f, -0.27217013f, -0.04312772f, -0.06932411f, 
    0.14781004f, 0.18465592f, -0.12599178f, -0.07589308f, -0.16373202f, -0.05641976f, -0.01666512f, -0.06378721f, 
    -0.09881188f, -0.04907872f, 0.00920505f, 0.01861547f, -0.13126090f, 0.00161714f, 0.05674768f, -0.03910186f, 
    -0.01614503f, 0.11912310f, 0.14642978f, -0.00113550f, 0.14102077f, 0.12408360f, 0.05050235f, 0.08126467f, 
    0.04560846f, -0.00899217f, 0.09930439f, 0.17117631f, 0.01251453f, -0.00290042f, -0.07959292f, -0.06127057f, 
    0.06427312f, 0.04322538f, -0.03816401f, -0.00593114f, -0.02379507f, 0.03812125f, -0.08198778f, 0.01012616f, 
    -0.09880942f, 0.07908123f, -0.01983693f, -0.02252473f, 0.12530246f, 0.07810413f, 0.06809617f, -0.27647075f, 
    0.03960653f, 0.14527653f, -0.08140206f, 0.08806021f, 0.03051754f, -0.07371724f, 0.04369415f, -0.02229499f, 
    0.35709631f, 0.01626249f, 0.08158986f, 0.07055081f, -0.00593128f, -0.01196015f, -0.04314785f, 0.03832094f, 
    -0.03548711f, -0.02718453f, 0.18689704f, 0.01008631f, -0.16713041f, -0.00819012f, 0.05744363f, -0.08123963f, 
    -0.13236593f, 0.06231921f, -0.00144375f, 0.02278800f, 0.15810002f, -0.05434674f, -0.03105337f, -0.13529357f, 
    -0.09150982f, 0.04938233f, 0.27163890f, 0.02198633f, -0.21496440f, -0.13883919f, -0.02906108f, 0.14734167f, 
    0.02063169f, 0.03790127f, 0.02072279f, -0.07127040f, 0.03848445f, -0.27874640f, 0.02950325f, -0.33713961f, 
    -0.00984618f, 0.08109315f, -0.09436870f, -0.04577783f, -0.01979171f, -0.00559568f, -0.02392224f, 0.05708830f, 
    -0.06249768f, 0.02014546f, 0.03422294f, -0.19093929f, -0.07985660f, 0.12655631f, -0.00330026f, 0.08500244f, 
    0.00006568f, -0.04167571f, -0.02143085f, -0.06665719f, 0.26025188f, -0.12049992f, 0.08083680f, -0.01712657f, 
    0.02870678f, 0.13107854f, 0.15150397f, -0.00289598f, 0.03055662f, 0.02611913f, -0.01156784f, 0.08094536f, 
    0.16980517f, 0.00658249f, -0.08066098f, -0.19518237f, -0.02601325f, -0.05001413f, 0.02217618f, 0.04831628f, 
    -0.12377228f, 0.00812797f, -0.11623264f, 0.07198422f, 0.10292583f, -0.07126696f, 0.01940778f, -0.07685203f, 
    -0.02271722f, 0.01087934f, 0.12183158f, 0.01280652f, -0.05124813f, 0.03960506f, -0.02723890f, 0.10126282f, 
    0.35967034f, 0.13546127f, 0.08141249f, -0.02799518f, 0.03627558f, 0.08160137f, 0.03665720f, -0.10190804f, 
    -0.03837556f, 0.06673726f, -0.12917559f, -0.16134216f, 0.23355977f, -0.00277467f, 0.03284069f, -0.07097609f, 
    0.10188843f, 0.14713678f, -0.02591909f, 0.01638156f, -0.04638604f, -0.07338879f, 0.03208493f, -0.09679608f, 
    -0.02027045f, -0.22591671f, -0.02235657f, 0.03782379f, 0.07959048f, -0.08192125f, 0.01626289f, -0.00018195f, 
    0.07949996f, -0.10221142f, -0.05682122f, -0.06875978f, 0.12031802f, -0.00422327f, 0.06691752f, -0.03123145f, 
    -0.15643096f, 0.02882491f, -0.04734495f, -0.05625612f, 0.12632291f, 0.02906951f, -0.05822485f, 0.01264046f, 
    -0.29177535f, 0.02670784f, -0.02933579f, 0.08765852f, 0.10816866f, -0.01342568f, 0.05237269f, -0.04017033f, 
    -0.06151826f, 0.00799481f, -0.00244721f, -0.09730793f, 0.19333273f, -0.01987538f, -0.08832495f, 0.03900764f, 
    -0.01447258f, 0.05877332f, -0.17233843f, 0.04619617f, -0.14343369f, 0.05831324f, 0.14094679f, -0.02071122f, 
    0.12308005f, -0.09995852f, 0.01579609f, -0.15470149f, -0.12567696f, 0.06260116f, 0.02247217f, 0.05697482f, 
    0.01724430f, -0.12046688f, 0.12730877f, 0.02748689f, -0.05616932f, 0.08522986f, -0.06982236f, -0.09480510f, 
    -0.03983687f, -0.08322362f, -0.01419935f, 0.00424132f, -0.19003843f, 0.13924059f, 0.13468310f, -0.00433705f, 
    0.22478642f, -0.16928512f, 0.15809140f, 0.02883617f, -0.05175750f, 0.15715162f, -0.04956428f, -0.08274884f, 
    -0.03891303f, 0.04891593f, 0.13510187f, 0.02084742f, 0.12001936f, -0.00103584f, -0.21654278f, -0.11548103f, 
    -0.01716357f, 0.08153810f, -0.05153210f, -0.03855501f, 0.06905928f, 0.01476385f, -0.08967987f, 0.05184213f, 
    0.02316700f, -0.00991665f, -0.02546510f, -0.08395077f, 0.13944502f, 0.00984667f, 0.04362559f, -0.01351180f, 
    -0.12906043f, 0.06487176f, 0.06703351f, 0.11663714f, 0.49974623f, 0.17701387f, 0.05558376f, 0.18102655f, 
    -0.04083736f, 0.02513963f, 0.04931420f, 0.05454532f, 0.05157128f, 0.02644083f, 0.00806039f, 0.05138617f, 
    -0.03474026f, 0.01035653f, 0.13066630f, -0.07075632f, -0.01530717f, 0.00925029f, 0.07223018f, -0.15619777f, 
    0.08412321f, 0.12063611f, -0.12899883f, 0.08099867f, 0.00767102f, 0.09329478f, -0.05493727f, 0.11257622f, 
    -0.07542914f, -0.13090633f, 0.00390569f, 0.08837542f, 0.01895217f, -0.08154758f, 0.07091870f, -0.08551294f, 
    -0.03161856f, -0.04286995f, 0.11487148f, 0.11453231f, -0.04718374f, -0.09577299f, -0.01495071f, 0.01918755f, 
    0.08796281f, -0.04835846f, -0.05185380f, -0.14096095f, 0.10044662f, 0.22365488f, 0.05402821f, -0.10086272f, 
    0.09884208f, 0.01177054f, -0.12672168f, -0.01742253f, 0.03870634f, -0.10602511f, 0.09201660f, -0.03487603f, 
    -0.00801759f, -0.00735312f, -0.05950102f, -0.04023109f, -0.03269643f, -0.00853598f, 0.00937900f, -0.06895497f, 
    0.04845696f, -0.02555973f, 0.06256998f, -0.06203984f, 0.01658614f, 0.00014719f, 0.00085418f, -0.01494240f, 
    -0.06982921f, -0.04553716f, 0.04318388f, -0.03116935f, -0.04906742f, 0.06358781f, 0.04365434f, -0.03858901f, 
    -0.07150728f, -0.05303119f, -0.06585077f, -0.02220885f, -0.07471667f, -0.03997371f, -0.06940663f, 0.01445939f, 
    -0.03974563f, -0.01068354f, 0.00747118f, 0.05817766f, -0.06695203f, 0.02961912f, -0.00495897f, 0.01381191f, 
    -0.03958143f, -0.03702108f, 0.00971598f, -0.02726518f, 0.02083719f, -0.05879835f, 0.06391428f, 0.02856754f, 
    0.01585873f, 0.01111382f, -0.00592458f, 0.06029791f, -0.00994173f, -0.05660904f, 0.05369854f, 0.05308120f, 
    0.05377785f, 0.05086545f, -0.04377982f, 0.05056709f, -0.03879410f, -0.05788402f, 0.02982302f, 0.05576662f, 
    0.01639764f, -0.07597040f, 0.03143081f, 0.01638797f, 0.02253087f, -0.07656340f, 0.02059750f, 0.05465956f, 
    0.02750687f, -0.04001803f, -0.00111818f, -0.07347031f, 0.01995395f, 0.00221980f, 0.04114664f, -0.01075546f, 
    0.00064940f, -0.03161775f, 0.00697923f, -0.06366406f, -0.06148144f, -0.01014771f, -0.06332170f, -0.01163185f, 
    -0.00628664f, 0.00745692f, 0.04433943f, -0.05269029f, 0.00056491f, 0.00709461f, -0.00842140f, -0.02253558f, 
    0.01675880f, 0.00553620f, -0.04524316f, -0.07415856f, -0.00703978f, -0.00967357f, 0.02120913f, 0.00563277f, 
    -0.00618789f, 0.05991733f, 0.02713999f, 0.01878377f, -0.02305243f, -0.07521179f, -0.02513455f, -0.01442698f, 
    -0.03959984f, 0.01929889f, -0.02004689f, -0.00918735f, -0.05873346f, 0.04814313f, -0.01676683f, -0.04393699f, 
    0.03605781f, 0.05037384f, -0.06879396f, 0.01473287f, -0.06567914f, 0.04387250f, -0.01951121f, -0.04860088f, 
    -0.05480412f, -0.04854256f, 0.06666645f, -0.05134676f, 0.04009880f, -0.07697235f, 0.05083201f, 0.05402357f, 
    0.04588746f, -0.07405021f, -0.06069397f, -0.04773365f, -0.02779157f, -0.04498610f, -0.07094684f, -0.05769037f, 
    0.04546048f, 0.06572675f, -0.00961250f, 0.00146107f, -0.05137813f, -0.06978043f, -0.05627394f, -0.03156165f, 
    -0.00987682f, 0.04459941f, 0.03578142f, 0.01987226f, 0.05298624f, -0.01488503f, 0.02076072f, -0.05030756f, 
    -0.04023680f, 0.06687331f, -0.02162337f, -0.05197348f, -0.00726638f, -0.03606293f, 0.03372279f, 0.02617029f, 
    -0.05647605f, -0.05107097f, 0.01448475f, 0.00381911f, -0.03227182f, -0.00399594f, -0.00618195f, 0.03307048f, 
    -0.07604022f, 0.05634115f, -0.00868239f, -0.02161985f, -0.03116342f, -0.05013776f, -0.03753391f, -0.06494129f, 
    -0.03173251f, -0.02779214f, -0.00386188f, 0.02181732f, -0.00949786f, -0.05875424f, 0.00711017f, -0.01235268f, 
    -0.11628662f, 0.04280668f, 0.02846773f, 0.12812330f, 0.07998736f, 0.02033842f, 0.05578941f, -0.09393419f, 
    0.08468846f, -0.02253858f, 0.16875082f, 0.13712135f, -0.06301099f, -0.27653030f, -0.00928042f, -0.11527007f, 
    0.06730650f, -0.07862315f, 0.03154984f, 0.18909933f, 0.06615025f, 0.19953856f, -0.06249255f, 0.09745908f, 
    0.36098272f, -0.07257120f, 0.06366925f, 0.08587116f, -0.00341994f, 0.07240294f, -0.02238826f, 0.08902746f, 
    -0.00670769f, -0.00945366f, 0.06992684f, 0.11787754f, 0.26111755f, -0.01459710f, 0.00256697f, 0.03758066f, 
    0.05646734f, 0.06416082f, -0.07172596f, 0.02225044f, -0.15298660f, -0.14964621f, 0.05112365f, -0.06727500f, 
    0.13733737f, 0.01427535f, 0.16323574f, -0.04185346f, -0.04927310f, -0.05304047f, -0.02713046f, -0.00111589f, 
    0.03156701f, 0.04299869f, 0.00014489f, 0.13229044f, -0.15549648f, 0.02109699f, 0.11198266f, 0.07466994f, 
    -0.00112154f, -0.02727666f, 0.18999013f, 0.09133884f, 0.02636943f, 0.05922358f, -0.01002113f, -0.03554147f, 
    -0.18184121f, 0.10659107f, -0.05265348f, 0.02115864f, 0.04052268f, -0.05057615f, -0.01911354f, 0.04086365f, 
    -0.05334954f, -0.00379460f, -0.01012383f, 0.03456937f, -0.08047562f, 0.03349106f, -0.14839433f, -0.14255433f, 
    -0.01446114f, 0.10810769f, -0.10557457f, 0.11943890f, 0.06504741f, -0.11117405f, -0.05699303f, -0.08932006f, 
    0.29459196f, 0.00806244f, 0.05723836f, 0.18680458f, 0.09882054f, 0.02035936f, 0.03339297f, 0.00868853f, 
    0.00776099f, -0.09308653f, 0.02178564f, -0.00905752f, 0.14405453f, -0.09670029f, -0.02330710f, -0.12582339f, 
    -0.02554120f, -0.05729797f, 0.06856331f, -0.06613794f, 0.07174399f, -0.07650634f, -0.05679348f, -0.09048473f, 
    0.09843286f, 0.23035535f, 0.22930279f, 0.04860329f, -0.14530621f, -0.00404224f, -0.11125156f, 0.04813337f, 
    -0.00093241f, -0.11307938f, -0.05103417f, -0.15559003f, -0.21128514f, -0.21835130f, 0.02671472f, -0.15088686f, 
    0.04953361f, 0.12410900f, -0.03791572f, -0.02723779f, -0.04912071f, -0.01586744f, 0.10117684f, 0.04000578f, 
    0.10488684f, 0.05243635f, 0.00756265f, -0.12778069f, -0.05590983f, 0.00850241f, -0.05746206f, -0.02971046f, 
    -0.02735814f, -0.14247108f, 0.00646477f, -0.18524580f, 0.19806275f, -0.07469531f, 0.03878775f, 0.04546380f, 
    0.19295977f, 0.13283011f, -0.04578298f, 0.04217051f, -0.03615744f, 0.05464267f, 0.09538043f, -0.04489522f, 
    0.10236965f, 0.11626908f, -0.19535184f, -0.19253090f, -0.00681213f, 0.01371401f, -0.05526524f, 0.08976509f, 
    -0.03345575f, 0.03932526f, -0.02087638f, 0.10111314f, 0.22872348f, 0.17300645f, -0.04362222f, -0.07494774f, 
    -0.06283333f, -0.01768760f, 0.06344866f, 0.08699507f, -0.03272978f, 0.12874418f, 0.09595242f, 0.14493139f, 
    0.22807880f, 0.01276599f, -0.03336871f, 0.07476445f, 0.15261655f, -0.05896310f, 0.07474783f, -0.04456980f, 
    0.01669793f, 0.00262205f, -0.04381542f, -0.09341834f, 0.33144125f, -0.05696709f, 0.06926709f, 0.04235163f, 
    -0.00799781f, -0.03055599f, -0.02862193f, -0.00300448f, -0.03665547f, -0.01383887f, -0.03609210f, 0.00787050f, 
    0.34571573f, -0.36327183f, -0.16470057f, -0.03821456f, 0.04324100f, -0.14738159f, -0.07447094f, -0.03423240f, 
    0.06295097f, 0.05107496f, 0.00305172f, 0.09602138f, 0.25220037f, -0.05289021f, -0.04622177f, -0.17502247f, 
    -0.00101040f, 0.04133043f, -0.00233406f, -0.11907577f, 0.09432840f, 0.10381330f, 0.02795982f, 0.01070119f, 
    -0.32693583f, 0.05064690f, -0.13392115f, -0.01759972f, 0.02030139f, 0.08542701f, -0.03988915f, 0.00703066f, 
    0.06939368f, 0.02736023f, -0.05576795f, -0.01314923f, -0.14884961f, -0.13163227f, -0.06311905f, 0.18823680f, 
    0.06568748f, 0.05379111f, -0.05808987f, -0.02045668f, -0.07920371f, 0.04966425f, 0.06809394f, 0.02971645f, 
    0.13307965f, -0.22642115f, -0.04760591f, -0.21134710f, -0.11673713f, -0.06942344f, -0.01837025f, 0.08715882f, 
    0.09263308f, -0.07991742f, 0.00608878f, 0.05700023f, -0.04969765f, 0.11514228f, -0.08876578f, -0.01140724f, 
    0.11714526f, -0.02420928f, 0.03248005f, 0.04113481f, 0.00435997f, 0.18181805f, 0.08107074f, -0.11024806f, 
    0.27981538f, -0.17629087f, 0.06679160f, 0.18954034f, 0.03058431f, 0.11117668f, -0.00229031f, -0.04820880f, 
    0.06224325f, 0.04273532f, 0.16498423f, 0.03011893f, -0.07545772f, 0.10877164f, -0.03389129f, 0.02153894f, 
    0.00093705f, 0.00747111f, -0.09928574f, 0.11279397f, -0.01220804f, 0.02290334f, -0.02722914f, 0.03511452f, 
    0.20376295f, -0.22214814f, 0.02108446f, 0.21631469f, 0.02246831f, -0.00023005f, -0.02066413f, 0.03205453f, 
    -0.03089369f, 0.07743782f, 0.01257721f, 0.10769159f, 0.22394346f, -0.00611994f, 0.00942420f, 0.16497229f, 
    -0.02789856f, -0.07148004f, 0.06157061f, -0.09753647f, 0.10390302f, 0.00146628f, -0.06362177f, 0.03216054f, 
    0.13317302f, 0.02158389f, -0.02480749f, 0.10423710f, 0.01314935f, -0.01262475f, -0.02258085f, -0.06866639f, 
    0.05532736f, 0.16161385f, 0.07685380f, 0.09540758f, -0.14452723f, 0.04158146f, 0.07834227f, -0.00227626f, 
    -0.11446358f, 0.02114907f, 0.02065568f, 0.02781036f, 0.00659280f, 0.03897801f, 0.21291035f, -0.15732352f, 
    0.09466784f, -0.14033504f, -0.07400785f, 0.09482221f, -0.00065092f, 0.09413359f, 0.05823017f, -0.11624301f, 
    0.10593262f, 0.03547959f, 0.15558101f, -0.11275496f, 0.15591516f, 0.11805166f, -0.04798693f, -0.26236084f, 
    0.01505839f, -0.06812144f, -0.04686523f, 0.07213539f, 0.07283924f, 0.03526622f, 0.03588169f, -0.06768457f, 
    0.04882230f, -0.04034780f, -0.05142560f, 0.02306652f, -0.01986659f, -0.05675155f, -0.01672873f, 0.04729058f, 
    0.01495245f, 0.02452809f, -0.05672175f, -0.06491211f, 0.02655108f, -0.01233092f, -0.01106267f, -0.06212547f, 
    -0.07342444f, -0.01194355f, -0.05538762f, 0.00090664f, 0.01276737f, 0.02531072f, 0.00812566f, -0.03299930f, 
    -0.05282331f, -0.05181275f, -0.03074293f, 0.03999963f, 0.04386213f, 0.05690311f, 0.01448264f, 0.00372394f, 
    -0.06305411f, 0.06080376f, 0.01122702f, -0.04264565f, -0.00870781f, 0.02187317f, 0.02321746f, -0.07158712f, 
    -0.01431359f, -0.03524860f, -0.00515438f, -0.06393367f, -0.02244137f, -0.03917126f, -0.00909829f, 0.03081716f, 
    0.06329288f, -0.03279772f, -0.04856060f, 0.02006128f, -0.01330737f, 0.04155869f, -0.05928613f, -0.04024485f, 
    -0.04963879f, -0.06321381f, 0.04276102f, 0.01194963f, -0.04618242f, -0.06061982f, 0.02796394f, -0.04217299f, 
    -0.06695700f, -0.04023490f, -0.02720054f, -0.03579628f, 0.03713238f, 0.05492641f, -0.04519553f, -0.07250464f, 
    -0.03645210f, 0.04703353f, -0.02674213f, 0.03537378f, 0.02194837f, 0.05162690f, -0.01281128f, -0.00095141f, 
    -0.04906169f, 0.00765979f, -0.02194123f, -0.01899575f, -0.00123042f, 0.01686414f, 0.03257801f, 0.05952828f, 
    -0.00981784f, -0.06126825f, -0.01443693f, -0.02123900f, -0.00967656f, 0.04132175f, 0.04228383f, -0.06251561f, 
    -0.06426603f, 0.00878448f, -0.00113172f, 0.06389585f, 0.03521701f, 0.02591351f, 0.06356014f, 0.04068347f, 
    -0.01968562f, -0.07202461f, -0.06939372f, -0.06973092f, -0.06816330f, 0.02059467f, 0.02423844f, -0.03310172f, 
    -0.06331927f, -0.03037380f, 0.04829315f, 0.02753452f, -0.04995195f, -0.05711452f, 0.05890756f, -0.03773336f, 
    0.01354649f, -0.03902631f, -0.02481619f, 0.02395184f, 0.03531711f, -0.03292369f, 0.03355001f, -0.01967139f, 
    0.00503449f, 0.00629972f, 0.02810401f, -0.06442183f, -0.07419141f, -0.02144978f, -0.06132432f, 0.04688527f, 
    -0.03807976f, 0.04125471f, -0.03799365f, 0.03545797f, -0.03224511f, 0.00116140f, -0.01110396f, -0.07266825f, 
    -0.03714928f, 0.06397241f, -0.05726479f, 0.05542009f, -0.07498801f, -0.00876460f, -0.03905776f, 0.03189304f, 
    0.01203458f, 0.02748162f, -0.03771645f, 0.01753649f, 0.00908506f, 0.05089070f, -0.00632317f, -0.03761575f, 
    -0.00746296f, 0.06341119f, 0.02793586f, -0.02641283f, 0.01163732f, -0.01513123f, -0.06511859f, 0.01421832f, 
    0.02284103f, 0.01920214f, -0.03462755f, -0.07339592f, 0.04444666f, -0.07671473f, -0.03616137f, -0.03033914f, 
    0.03305005f, 0.05934822f, -0.06639770f, -0.03727896f, 0.00728392f, -0.02449737f, 0.01284682f, -0.03654315f, 
    -0.03140247f, -0.02934586f, 0.01207248f, 0.01632000f, -0.07729010f, 0.02509291f, -0.04473122f, -0.05463130f, 
    0.00112608f, 0.04196022f, -0.02957870f, 0.05039972f, 0.01429567f, -0.06272362f, -0.04779959f, 0.00047846f, 
    -0.07949543f, 0.01827228f, -0.02236711f, -0.05455346f, -0.04337098f, -0.03379764f, 0.04535844f, -0.03073640f, 
    -0.05237279f, -0.01586737f, -0.04579444f, -0.02881524f, -0.07690447f, 0.03584692f, 0.05987142f, 0.01347791f, 
    0.01238826f, 0.05606950f, -0.07173169f, -0.04759275f, 0.02493800f, -0.02642856f, -0.00353333f, -0.01113958f, 
    -0.01595390f, -0.06625357f, -0.01104500f, 0.03400312f, 0.01764476f, 0.05167198f, 0.04855145f, -0.05739391f, 
    0.03698814f, 0.00291338f, -0.06983718f, 0.05055962f, 0.03770851f, -0.07451891f, -0.04483682f, -0.02157935f, 
    0.03644789f, 0.03240112f, -0.06529006f, -0.04346463f, -0.07520089f, -0.04941034f, -0.01283567f, 0.00898587f, 
    0.04456731f, 0.04557999f, 0.01242316f, 0.05587782f, 0.00146284f, 0.04862808f, 0.06395313f, -0.02084170f, 
    -0.03056259f, -0.01517946f, -0.07211982f, 0.01430776f, 0.00702537f, -0.04633405f, 0.06091861f, 0.01144268f, 
    -0.00959357f, 0.02395760f, 0.00639848f, 0.06948701f, 0.00760896f, 0.04030649f, -0.04657978f, 0.02510660f, 
    -0.05377334f, 0.02677239f, -0.00583223f, 0.05385885f, -0.02217989f, 0.02740759f, -0.06210197f, 0.04351747f, 
    -0.05625831f, 0.03117642f, -0.06950764f, -0.07709315f, -0.07386488f, 0.00612708f, -0.04950907f, -0.02246325f, 
    0.05654117f, 0.04050433f, -0.05780009f, 0.04847948f, 0.03733251f, 0.00842277f, -0.06591794f, -0.05015192f, 
    0.04797674f, 0.06151542f, 0.00464492f, 0.00422589f, 0.05377165f, -0.06176347f, -0.03565930f, -0.00064558f, 
    -0.01999696f, 0.03248763f, 0.05628874f, -0.06872822f, 0.05858679f, -0.01935110f, -0.03604393f, -0.03708155f, 
    -0.08571884f, -0.07503858f, 0.01389860f, 0.00744377f, -0.07127023f, -0.01889365f, 0.03145692f, -0.01170127f, 
    -0.03800533f, 0.00277664f, 0.00329430f, -0.01416836f, -0.04263153f, -0.07259108f, 0.02378311f, -0.01189484f, 
    -0.05895881f, 0.02952871f, -0.03586955f, -0.07409139f, -0.03837422f, 0.05641766f, 0.02452525f, -0.00171762f, 
    0.05256417f, 0.04588592f, 0.05781442f, -0.03439542f, 0.00625445f, -0.05385523f, -0.01576507f, -0.01821782f, 
    -0.06176151f, -0.05884251f, 0.05715834f, 0.01405802f, -0.01065664f, -0.07290506f, -0.08520079f, -0.03128479f, 
    -0.01470173f, -0.06466758f, -0.03807586f, -0.06287001f, 0.01217189f, 0.05651091f, -0.06829689f, 0.05720178f, 
    -0.01732863f, 0.03957754f, 0.06186119f, 0.03824024f, 0.02307505f, -0.02101488f, -0.06812271f, 0.07024632f, 
    -0.07119562f, -0.06715240f, 0.00465120f, -0.05766134f, 0.05493872f, -0.02728858f, -0.05389271f, -0.01951087f, 
    -0.02264836f, -0.06860816f, -0.01832919f, -0.06058551f, 0.03955859f, 0.03661903f, -0.06330239f, 0.03065090f, 
    0.02832201f, -0.13676970f, 0.17413747f, 0.18664782f, 0.01423578f, 0.12459943f, -0.03738186f, 0.03640906f, 
    0.05024879f, 0.07871047f, 0.05990881f, -0.01140109f, -0.16626878f, 0.08298121f, 0.08112971f, 0.16519225f, 
    0.03774987f, -0.03054085f, -0.05588144f, 0.00486695f, -0.03365762f, 0.15387686f, 0.10845715f, 0.04759096f, 
    0.11340839f, 0.05803933f, -0.20930159f, -0.08041451f, 0.01025263f, -0.02750617f, 0.09483322f, 0.13878381f, 
    -0.10891199f, 0.01388560f, 0.07841368f, -0.00509584f, 0.30481523f, -0.00921153f, -0.06480259f, -0.03800482f, 
    0.13289799f, 0.05426555f, -0.02022089f, 0.11100017f, 0.02373313f, -0.01581650f, -0.01204020f, 0.05885051f, 
    -0.09553018f, 0.31825724f, 0.03834087f, -0.11167992f, 0.09169870f, 0.01802421f, 0.08691543f, -0.06046095f, 
    0.03272133f, 0.09204523f, -0.08229142f, 0.00166897f, -0.41383189f, -0.18230104f, 0.26384982f, 0.10804756f, 
    0.09943058f, 0.02888539f, 0.07011575f, -0.00940323f, 0.03773293f, 0.03840930f, -0.06039817f, 0.01189216f, 
    -0.01850164f, 0.06737093f, 0.13983059f, 0.14801285f, 0.00081488f, -0.11568459f, -0.10047122f, 0.11119578f, 
    -0.03043612f, 0.00863984f, -0.04134756f, 0.01849108f, -0.18539579f, -0.12136700f, -0.00300215f, 0.03278290f, 
    -0.05115983f, 0.08360225f, -0.06053509f, -0.06080480f, 0.08183268f, 0.04997738f, -0.01038011f, -0.03175979f, 
    0.04041566f, 0.10432231f, -0.16344289f, 0.28534001f, -0.07615878f, 0.06148913f, 0.01048151f, 0.00123239f, 
    -0.09252301f, -0.02677444f, -0.02887470f, 0.04053193f, -0.05912972f, 0.17828062f, -0.00898420f, -0.07738914f, 
    -0.07651949f, -0.12066270f, -0.00221885f, 0.00491900f, -0.05808795f, -0.07028978f, 0.04623589f, -0.05203250f, 
    0.08433947f, -0.13174789f, 0.09615699f, 0.31043616f, -0.19062619f, -0.10825773f, -0.06870125f, -0.06414833f, 
    -0.01952552f, -0.04973006f, 0.01859275f, -0.07042208f, -0.20207775f, 0.00385865f, 0.19906533f, 0.14753401f, 
    0.07579547f, 0.02189456f, -0.01633726f, -0.12373312f, 0.04898354f, -0.04571610f, 0.06601121f, 0.11431399f, 
    0.27392560f, 0.02702350f, -0.18658550f, 0.13563338f, -0.06077994f, 0.05383486f, -0.17228155f, 0.06668445f, 
    -0.12091126f, -0.13203454f, 0.00400162f, -0.10144393f, -0.16608028f, 0.03975940f, -0.13670380f, -0.08745088f, 
    0.05923844f, 0.04844755f, -0.04052838f, -0.05010803f, -0.08032725f, -0.04123751f, 0.19641936f, 0.03690303f, 
    0.18855017f, 0.01428876f, 0.05773017f, 0.26288676f, -0.10687833f, 0.12989238f, 0.05751394f, -0.04413800f, 
    -0.02146954f, -0.05640510f, 0.05005781f, 0.04346986f, 0.18655802f, -0.07936132f, -0.19682930f, -0.08888805f, 
    -0.11578812f, 0.02118295f, 0.12495422f, 0.09448148f, -0.08725976f, 0.11253418f, -0.04985625f, 0.04382269f, 
    -0.04219586f, -0.06039974f, -0.12897280f, -0.01292461f, 0.00728703f, 0.10665137f, 0.02283866f, -0.00231946f, 
    0.09355120f, -0.06347922f, -0.03265383f, -0.06648327f, 0.45961130f, -0.01677362f, 0.02121330f, -0.12187754f, 
    0.02978771f, -0.16477729f, 0.08857415f, 0.16679198f, -0.11232538f, 0.01869455f, -0.12752107f, -0.03562524f, 
    -0.14185013f, -0.14598723f, -0.11022910f, -0.03092797f, 0.07320705f, 0.07582743f, -0.00684971f, -0.04802305f, 
    0.02182676f, 0.04165908f, -0.11555477f, 0.09369558f, 0.00685391f, -0.18488613f, 0.04942634f, -0.07324654f, 
    -0.03923827f, -0.02018973f, -0.09960132f, 0.04333738f, 0.00665414f, 0.01074827f, -0.00426121f, 0.02270893f, 
    -0.21648052f, 0.10982882f, -0.07852740f, -0.16273846f, -0.01065691f, 0.08568716f, -0.11548281f, -0.13444933f, 
    0.01587463f, 0.00576221f, 0.09625984f, 0.00408321f, 0.16323745f, 0.07752167f, -0.01104233f, 0.31096599f, 
    0.00921206f, 0.02023960f, -0.01156791f, 0.07558593f, -0.01103569f, -0.04433632f, 0.01773572f, -0.02380118f, 
    0.03870437f, -0.16177070f, 0.04964385f, 0.02793037f, -0.08960468f, -0.00504884f, -0.01605897f, 0.12791163f, 
    0.02469730f, -0.04050137f, 0.07668442f, -0.03873319f, 0.00421133f, 0.17697361f, -0.03044359f, 0.06748227f, 
    0.01149455f, 0.11289012f, -0.08053230f, 0.04377525f, -0.04998117f, -0.01142402f, 0.03262430f, -0.03625432f, 
    0.05417538f, -0.09948647f, -0.00710551f, 0.09490824f, 0.15455158f, 0.13948283f, -0.02764347f, 0.03298470f, 
    -0.07110678f, 0.00322476f, 0.17507054f, 0.11777709f, 0.07176170f, 0.14617714f, -0.13834850f, -0.18750465f, 
    -0.00489597f, 0.14318618f, 0.02203828f, 0.08539885f, 0.10498297f, -0.00839127f, -0.01794473f, 0.05739081f, 
    0.10982174f, -0.22680651f, -0.00801178f, 0.07701831f, 0.20071696f, -0.03996777f, 0.06359655f, 0.04192670f, 
    -0.06966029f, 0.00958498f, 0.10840693f, 0.04587586f, 0.51230842f, 0.05323664f, -0.07911502f, -0.10572487f, 
    -0.11097734f, 0.07087793f, -0.04311815f, -0.05324568f, -0.03572233f, 0.07160187f, -0.01890885f, 0.02046298f, 
    0.18570945f, -0.13043083f, -0.04014960f, -0.16272771f, -0.01196964f, 0.16245966f, 0.07658878f, -0.07251050f, 
    0.00115736f, 0.01871847f, -0.02820833f, 0.03432827f, 0.13323072f, -0.02051076f, 0.15241523f, -0.16700228f, 
    0.10983860f, -0.14919044f, -0.04227297f, 0.23557609f, 0.01039279f, -0.03997701f, 0.08668443f, -0.10597053f, 
    -0.15523145f, -0.17149183f, -0.06365776f, -0.08889594f, 0.06460446f, 0.10135576f, 0.07024114f, -0.05809412f, 
    -0.05587409f, -0.03942738f, 0.00954278f, -0.00112477f, 0.10659133f, 0.04180449f, 0.42172590f, -0.19194838f, 
    -0.07733265f, -0.04128912f, -0.00120094f, -0.03450850f, 0.01679818f, -0.04568378f, 0.06103655f, 0.10523527f, 
    -0.00930835f, 0.03211183f, -0.04450657f, -0.16108967f, -0.02587611f, -0.00792506f, -0.09857015f, 0.03456204f, 
    -0.09544649f, -0.09397272f, -0.00916590f, -0.07702918f, -0.24653414f, 0.16638735f, 0.00114501f, 0.03990397f, 
    0.01429283f, 0.08600160f, 0.04010125f, -0.10161559f, 0.03792858f, -0.12803751f, 0.10981848f, 0.00059314f, 
    -0.40868598f, 0.07848575f, 0.22380856f, 0.00451142f, 0.06391026f, 0.03383205f, 0.06509285f, 0.05090726f, 
    -0.04474810f, -0.07142994f, 0.00624193f, -0.11191612f, -0.15410048f, 0.13517393f, -0.00246895f, 0.18453148f, 
    -0.02536587f, -0.02924711f, -0.05619261f, 0.08392035f, 0.06885614f, 0.10215260f, -0.00571844f, 0.00065295f, 
    -0.00611039f, -0.05120131f, -0.01353355f, 0.02517001f, 0.06327093f, -0.07686804f, 0.05366195f, -0.12358726f, 
    -0.04550559f, 0.00641929f, 0.05111939f, -0.11491257f, 0.31183243f, 0.17139809f, 0.00244016f, -0.09691340f, 
    0.03572270f, -0.01153830f, -0.00266743f, -0.00872594f, 0.06039434f, 0.17460336f, 0.15495048f, 0.14272113f, 
    0.16907345f, 0.02035084f, 0.01659481f, 0.06874724f, 0.06228278f, 0.17527680f, -0.06870185f, -0.11749651f, 
    0.01741179f, -0.00389500f, 0.10754023f, -0.01492291f, 0.13180873f, 0.08276052f, 0.22397776f, -0.10940730f, 
    0.02049757f, 0.05621864f, 0.10395504f, -0.06995629f, -0.10265476f, 0.07373708f, 0.06516196f, 0.19740713f, 
    -0.24378003f, 0.18604453f, 0.03504930f, -0.25143915f, 0.01215267f, -0.03803990f, -0.08616691f, 0.01498981f, 
    0.04279742f, 0.06312165f, 0.08039121f, -0.07812892f, 0.21220048f, -0.20389508f, -0.11256213f, 0.12042236f, 
    0.14147238f, 0.07581633f, 0.02267501f, 0.08805905f, 0.02696328f, 0.09663411f, 0.10692436f, 0.17268707f, 
    -0.38363656f, 0.17630224f, -0.17605267f, -0.18915686f, 0.02724477f, 0.08931431f, 0.06137649f, 0.00697059f, 
    0.01933555f, 0.02597288f, -0.00311970f, 0.02585417f, 0.33315566f, 0.00476833f, -0.06681692f, -0.00488212f, 
    0.07605064f, 0.08217463f, 0.00898291f, 0.02422341f, -0.06391279f, 0.01768447f, 0.01023019f, -0.03344496f, 
    -0.27752674f, 0.09217232f, -0.06669365f, -0.07481660f, 0.00173750f, -0.13493937f, -0.02618509f, 0.02799945f, 
    0.00905384f, 0.00765043f, 0.03016115f, 0.05561277f, 0.35025179f, 0.11572954f, 0.00323073f, 0.16713271f, 
    -0.18025529f, 0.00171871f, 0.10273807f, 0.09272015f, 0.15879866f, 0.07015457f, -0.03826381f, 0.15089281f, 
    -0.38671023f, 0.01349232f, 0.17327459f, -0.11753786f, 0.07510711f, -0.00308318f, 0.02937460f, 0.03861940f, 
    -0.01797289f, -0.07527707f, 0.01026027f, -0.01384458f, -0.18602699f, -0.09096834f, 0.09347200f, 0.21046557f, 
    0.04562027f, 0.12367949f, 0.01614673f, 0.08761001f, -0.05799919f, -0.19571592f, -0.07766704f, -0.06892327f, 
    -0.00373812f, -0.00408072f, -0.04105867f, -0.00996209f, -0.03923431f, -0.06897613f, -0.06419434f, -0.02967591f, 
    0.04531113f, 0.04786121f, -0.03279094f, 0.02388061f, -0.02352774f, -0.02069835f, -0.04452951f, -0.07031731f, 
    -0.00663077f, 0.03218112f, -0.05801202f, -0.06808465f, -0.00814691f, -0.05599383f, -0.04539578f, 0.03418901f, 
    0.02774135f, 0.03926282f, -0.02329173f, -0.01793604f, 0.04099003f, 0.01705089f, 0.02427622f, -0.02100751f, 
    -0.06696276f, 0.00534045f, -0.07465912f, -0.07566148f, 0.00909117f, 0.01145606f, -0.01698663f, -0.05622527f, 
    0.02444670f, -0.06744553f, -0.02576414f, -0.01942110f, 0.05807507f, 0.00070772f, 0.07177671f, 0.04560593f, 
    0.01340077f, 0.05041775f, -0.05063881f, 0.06298093f, -0.03276960f, -0.04187317f, -0.07800847f, -0.00380284f, 
    -0.04251213f, -0.05880747f, 0.06052276f, -0.02829767f, 0.04847898f, -0.02771586f, -0.03571496f, -0.04334707f, 
    -0.03530800f, 0.01382391f, 0.04861261f, -0.04465644f, 0.01815074f, 0.04527260f, -0.05329804f, 0.03319155f, 
    0.02617064f, 0.02527132f, 0.03136807f, -0.06477083f, 0.06622585f, -0.02778896f, 0.05946191f, -0.03713150f, 
    0.01582298f, -0.01610733f, 0.06031452f, -0.03259073f, -0.04019058f, -0.02621734f, -0.01442847f, -0.05599339f, 
    0.01666940f, -0.00821528f, 0.02820065f, -0.02628461f, 0.04415075f, -0.02740818f, 0.05009980f, 0.05658124f, 
    -0.01141005f, 0.06208417f, -0.05128649f, -0.01288664f, -0.07192868f, -0.05327134f, -0.07603657f, -0.03489980f, 
    0.02660160f, 0.05854151f, -0.04118465f, -0.01627631f, 0.00210041f, 0.06401634f, 0.01784442f, 0.06087879f, 
    0.01145525f, 0.05109685f, -0.02790661f, 0.02383919f, -0.07653167f, -0.05233967f, -0.00238192f, 0.05759132f, 
    -0.06543349f, -0.05387611f, 0.03407470f, 0.01292122f, 0.01050283f, -0.04206721f, -0.03218460f, 0.02655244f, 
    -0.01634852f, 0.05068238f, 0.02478798f, 0.03202382f, -0.04154003f, -0.03097539f, -0.00956341f, 0.00109855f, 
    0.02438598f, 0.05554819f, 0.07329085f, 0.06522913f, -0.05193985f, 0.02272130f, -0.05394095f, -0.03402513f, 
    0.06301988f, 0.03666205f, -0.07539685f, -0.05317855f, -0.04631221f, -0.05883009f, 0.05395158f, -0.08067787f, 
    -0.01331744f, -0.08055132f, -0.02153867f, 0.01581845f, -0.02308416f, -0.02552966f, -0.03904396f, 0.05216275f, 
    0.04535035f, -0.04750550f, 0.05275505f, -0.03870277f, 0.06362955f, 0.01142251f, -0.07123104f, -0.05226459f, 
    -0.06880771f, 0.06471173f, -0.02535856f, -0.07219001f, -0.05558122f, -0.07232776f, -0.05161506f, 0.06469624f, 
    -0.04598003f, 0.03377421f, -0.06328882f, 0.04678775f, 0.03881322f, -0.02509622f, -0.05332223f, -0.05050806f, 
    -0.06025491f, -0.00777938f, -0.03903596f, -0.02881642f, -0.05164327f, -0.02060677f, -0.00820746f, -0.02000301f, 
    0.12972185f, 0.09755463f, 0.08452495f, 0.08911711f, -0.10688619f, 0.08968701f, -0.01135291f, -0.06452537f, 
    -0.03613609f, -0.06287430f, -0.09364615f, 0.15237536f, -0.06630881f, 0.17109311f, 0.27733266f, 0.25465006f, 
    -0.02580624f, 0.02398410f, -0.16224477f, 0.15129755f, 0.11404690f, 0.16362476f, 0.13712230f, -0.00219915f, 
    -0.08588562f, -0.02629131f, -0.22126317f, 0.08022649f, -0.10988650f, -0.12014365f, 0.07869969f, 0.00690292f, 
    0.06445819f, 0.00530744f, 0.12474803f, 0.10510851f, 0.33988854f, 0.15423493f, 0.06651628f, 0.13604821f, 
    0.00163805f, -0.03355283f, -0.08066737f, -0.06375014f, 0.01031430f, -0.05497040f, -0.03909359f, 0.15038052f, 
    0.07820450f, 0.16038030f, 0.12735884f, 0.02030435f, 0.13060267f, -0.14949659f, 0.06184494f, -0.11797610f, 
    0.02777510f, -0.07085337f, 0.20690353f, 0.08493479f, -0.04084953f, -0.20599027f, -0.03488209f, 0.01788353f, 
    -0.05469324f, 0.00178911f, -0.05358766f, -0.01430995f, 0.06723481f, -0.03582589f, 0.11107793f, -0.01637896f, 
    0.12774959f, -0.07039109f, 0.06232056f, -0.06723285f, -0.26997244f, 0.09239457f, 0.03672477f, 0.03268871f, 
    -0.07088738f, -0.03780231f, 0.12556016f, 0.05346061f, -0.20016909f, -0.18216091f, -0.26520219f, -0.04974364f, 
    -0.03415962f, -0.02010857f, 0.01272708f, 0.03514834f, -0.08644056f, -0.04463412f, -0.09292118f, -0.06347605f, 
    -0.03154446f, -0.07197965f, -0.02194500f, 0.03299192f, 0.03947203f, 0.14237055f, -0.02030620f, -0.13995330f, 
    -0.01625669f, -0.17299786f, -0.03119849f, 0.01317326f, 0.16254446f, -0.21868415f, 0.07949573f, 0.00230303f, 
    0.11272665f, -0.04002211f, 0.00449143f, -0.05562540f, -0.06123295f, -0.10200381f, -0.17487039f, 0.05769308f, 
    -0.07926460f, 0.27244052f, 0.14543317f, 0.03479390f, -0.04384554f, -0.08650460f, -0.17222050f, -0.03936796f, 
    -0.19766295f, -0.13525769f, -0.03468492f, -0.12254018f, 0.18684268f, -0.06389860f, 0.31766891f, 0.22652315f, 
    0.14576238f, 0.03612703f, -0.08863471f, -0.08674541f, 0.05445984f, 0.11596962f, 0.16285180f, 0.09466998f, 
    -0.00621628f, -0.06385510f, 0.01198459f, -0.10045169f, -0.11754069f, -0.04006571f, 0.00145750f, -0.00259633f, 
    -0.10488580f, -0.12583409f, 0.03531260f, -0.06635272f, 0.20009872f, -0.01385145f, 0.08331197f, 0.10368720f, 
    0.03214250f, -0.07387022f, -0.10217451f, -0.14457306f, 0.01304888f, 0.10696553f, 0.06852091f, 0.06237384f, 
    -0.03171313f, 0.05242978f, -0.10477325f, 0.16186045f, 0.03506082f, -0.00797082f, -0.11234033f, 0.08401839f, 
    -0.16287275f, 0.01541447f, 0.03849241f, -0.07526055f, 0.18049681f, 0.16985513f, -0.08006568f, -0.08311380f, 
    -0.09276755f, -0.04953699f, 0.00663671f, 0.07912571f, 0.06606779f, 0.12043615f, 0.05027990f, -0.10642418f, 
    0.01599389f, -0.23302168f, 0.03799521f, 0.09146442f, 0.06705501f, 0.02226708f, 0.03826164f, -0.05055334f, 
    0.12964298f, -0.02039570f, 0.03108636f, 0.00182635f, 0.13762821f, 0.14633918f, 0.13071670f, 0.14039846f, 
    -0.10918620f, -0.13204868f, 0.07359303f, 0.04367346f, -0.01157491f, 0.02700625f, 0.04134668f, -0.08309571f, 
    0.16116050f, -0.21059403f, -0.29093558f, -0.06130690f, 0.15373857f, 0.02629991f, 0.05132717f, 0.01726269f, 
    0.02658504f, -0.00421304f, 0.02290078f, -0.10998987f, 0.02475783f, -0.13188724f, -0.08529017f, -0.22375776f, 
    -0.16613294f, 0.09468084f, -0.00254018f, 0.00050346f, 0.05881078f, -0.07455505f, 0.14089739f, 0.02726139f, 
    0.13196921f, 0.46383891f, -0.25748089f, -0.18925378f, 0.04787768f, -0.04735036f, -0.14130473f, -0.01966479f, 
    0.02649500f, 0.11063807f, -0.06189499f, -0.03059188f, 0.08045826f, -0.13452202f, 0.24924079f, 0.21601275f, 
    0.07520494f, 0.05346100f, -0.00306203f, 0.02233901f, -0.13702047f, 0.02031208f, 0.01212512f, 0.04001157f, 
    0.27456006f, 0.01901207f, 0.12959774f, -0.01876212f, -0.04393677f, 0.11834937f, -0.01080137f, 0.09047177f, 
    0.05677413f, 0.02711593f, 0.02936066f, 0.00612121f, 0.04553188f, 0.16143112f, 0.12574136f, -0.06542539f, 
    0.09538770f, 0.02145462f, -0.09893459f, -0.00589433f, 0.24078535f, 0.14176603f, 0.02603967f, -0.11321822f, 
    -0.07979926f, -0.01412188f, -0.17193659f, 0.19054569f, -0.05162912f, -0.01825859f, -0.10969711f, 0.06122376f, 
    0.02502840f, 0.02198931f, 0.03583478f, 0.07826547f, -0.18247573f, 0.17612672f, -0.05611758f, -0.04995461f, 
    -0.01295365f, -0.07082745f, -0.00746113f, 0.08200651f, -0.03904055f, 0.08015880f, 0.05024498f, 0.12438601f, 
    -0.17314145f, -0.35019943f, -0.05720604f, 0.14007540f, 0.10661288f, 0.02006127f, 0.01498433f, 0.03317358f, 
    0.08870240f, 0.05298995f, 0.05427971f, 0.11780908f, 0.23572494f, -0.11180741f, 0.15851726f, 0.20070364f, 
    -0.20065166f, -0.03169165f, 0.09944730f, -0.01522459f, 0.06078700f, 0.05206616f, -0.05400987f, 0.01252921f, 
    0.21413840f, 0.18560234f, -0.14419673f, 0.13264367f, 0.16830803f, 0.03823057f, -0.02280206f, -0.01482404f, 
    0.08876693f, 0.07661414f, 0.12332103f, 0.03619383f, -0.06456267f, 0.09296849f, 0.11658628f, -0.14161415f, 
    0.02049929f, -0.02946690f, -0.07147712f, 0.15395330f, -0.01844317f, 0.10825574f, 0.02854964f, -0.15237103f, 
    -0.21579826f, -0.17756392f, 0.04094671f, 0.24591203f, 0.09130964f, 0.11103277f, 0.02207367f, 0.01032357f, 
    -0.07936878f, -0.01594288f, 0.05816579f, 0.01675970f, -0.15040830f, -0.16903619f, 0.04685814f, -0.00510864f, 
    -0.09518323f, -0.06112492f, 0.12224446f, -0.09815937f, -0.00671203f, -0.01271486f, -0.09722241f, 0.07690521f, 
    0.20969488f, -0.07881779f, 0.19209369f, 0.22553051f, 0.16210166f, -0.01279844f, -0.04855834f, -0.02367243f, 
    0.04326684f, -0.00098153f, -0.03627999f, -0.08937390f, -0.19277140f, 0.27563679f, 0.12645006f, 0.20597020f, 
    -0.04491051f, 0.04928232f, -0.07178325f, -0.05011097f, 0.05659663f, -0.00367025f, 0.07085723f, -0.09352490f, 
    -0.08134541f, -0.17665441f, -0.12939647f, -0.22012347f, 0.06574062f, 0.01858712f, -0.13807014f, -0.00897779f, 
    -0.12363008f, -0.14550887f, -0.04521540f, -0.02405107f, 0.10973091f, 0.07103997f, -0.10971560f, -0.13633291f, 
    -0.06004792f, 0.02606982f, -0.00136167f, 0.06806795f, 0.14679004f, -0.01285001f, -0.02051888f, 0.17762685f, 
    0.17255718f, 0.39971390f, -0.03101474f, 0.06697857f, 0.00745463f, -0.01377753f, 0.03529749f, -0.01524329f, 
    0.08341201f, -0.02360795f, -0.11887401f, -0.10902412f, -0.32659343f, -0.26432869f, -0.00860670f, -0.08054519f, 
    0.04443518f, -0.11010663f, -0.01266800f, -0.01756245f, -0.00606580f, 0.12581947f, 0.11966524f, 0.01872600f, 
    -0.05485552f, -0.03691897f, -0.06207716f, -0.27965304f, -0.07573808f, -0.06173384f, -0.01008300f, -0.03427353f, 
    -0.07417434f, 0.11969232f, -0.00239503f, 0.09271003f, -0.29835030f, -0.31619534f, -0.12969957f, -0.01152191f, 
    0.03710357f, -0.02598408f, -0.01943454f, -0.14070207f, 0.07157791f, 0.22424632f, 0.06139802f, 0.02755970f, 
    0.07058519f, 0.11367370f, 0.04505351f, 0.25108793f, 0.04149053f, 0.03421085f, 0.02197585f, 0.09490933f, 
    0.01366391f, 0.08774348f, 0.14666872f, -0.12629072f, 0.15103355f, 0.08860240f, -0.09733470f, 0.18534170f, 
    0.01752305f, -0.12283496f, -0.07740445f, 0.02709592f, -0.00224071f, 0.04593223f, 0.04724639f, 0.16339706f, 
    -0.04173640f, -0.04579901f, 0.06762044f, 0.23085451f, 0.16715059f, 0.12416287f, -0.00343477f, -0.11338692f, 
    -0.07036147f, 0.03489983f, 0.04458013f, 0.10798424f, 0.12779850f, 0.06962802f, 0.13373761f, 0.28321975f, 
    0.01049606f, -0.11299509f, 0.05649844f, -0.04235013f, -0.01975358f, 0.01211858f, -0.05651445f, 0.05085775f, 
    0.13195108f, 0.21101134f, 0.02175950f, 0.24903966f, 0.00012157f, -0.08023659f, -0.00466998f, -0.08530215f, 
    0.19371741f, 0.02451636f, 0.03380534f, 0.11057060f, -0.11876442f, 0.28493348f, 0.09174331f, 0.00974093f, 
    -0.21161915f, -0.02650977f, -0.00211346f, -0.09103785f, -0.16716768f, 0.04490183f, 0.03674588f, 0.02136184f, 
    -0.31027719f, -0.03279544f, 0.11773192f, 0.28917328f, 0.07463460f, 0.05339899f, -0.02525951f, -0.00046228f, 
    -0.03123037f, -0.12890978f, 0.07623562f, 0.11501806f, -0.29724520f, -0.15793717f, -0.12887082f, -0.14707038f, 
    0.09115877f, -0.00841268f, -0.07955443f, 0.03987313f, 0.01456857f, -0.10687657f, -0.07979175f, -0.01109173f, 
    -0.28977108f, -0.17797086f, -0.06776852f, 0.19456801f, 0.07256990f, 0.08548618f, 0.05841972f, 0.06130737f, 
    0.11353926f, -0.07203464f, 0.13143316f, 0.03672873f, 0.24996398f, -0.01109871f, -0.18483192f, -0.06496783f, 
    -0.00657096f, -0.10884161f, 0.07710289f, -0.02865219f, -0.06293799f, 0.05764103f, -0.00373978f, 0.11775295f, 
    0.07410493f, 0.01754254f, 0.04695461f, 0.00470375f, 0.09138923f, 0.08142735f, 0.05932464f, 0.06000452f, 
    0.03833871f, 0.06504734f, 0.04716475f, 0.01214541f, 0.08259064f, -0.27317914f, -0.00873446f, -0.08348189f, 
    0.29059803f, 0.08221748f, 0.02133189f, -0.08133366f, -0.07752413f, 0.00228310f, 0.00118265f, 0.01797273f, 
    -0.19221269f, 0.10660567f, -0.17267156f, -0.09469369f, -0.13794824f, 0.08835012f, -0.03416142f, 0.07206755f, 
    -0.06293242f, 0.12206756f, 0.03888844f, -0.02882374f, -0.25367650f, 0.15156674f, 0.14453326f, 0.00796831f, 
    0.15802136f, 0.02011721f, 0.00831565f, 0.09013238f, -0.02506904f, -0.00997455f, -0.12475971f, -0.09083416f, 
    0.03778473f, 0.14067121f, -0.08185474f, 0.16568105f, 0.09649137f, -0.07815858f, -0.06660392f, 0.08907338f, 
    -0.04112042f, 0.08300814f, 0.01018626f, -0.03960545f, 0.14953426f, 0.09963360f, -0.02697583f, 0.08168346f, 
    0.05879521f, 0.05994326f, -0.03900311f, 0.05125118f, 0.13470973f, 0.00188137f, 0.03641322f, -0.01970151f, 
    0.19754589f, 0.13161232f, -0.09824336f, 0.14679874f, -0.00951635f, 0.02244124f, 0.03071812f, 0.08329760f, 
    -0.08881356f, -0.00381449f, 0.03567245f, 0.09648547f, -0.33671182f, 0.15017374f, 0.10201330f, -0.02206999f, 
    -0.08723649f, -0.05700539f, 0.09432103f, 0.15288609f, -0.01002179f, -0.03881252f, 0.09952684f, -0.10571302f, 
    0.14302835f, -0.23498192f, 0.19083656f, 0.16198912f, -0.01284973f, -0.10128253f, 0.00397388f, 0.11183939f, 
    0.10309298f, -0.02932755f, -0.02980748f, -0.02893529f, -0.27969965f, -0.06043385f, -0.02106956f, -0.02309746f, 
    -0.05991259f, 0.02419666f, -0.05931288f, -0.07747407f, -0.01611124f, -0.07126752f, 0.10682121f, 0.04296105f, 
    0.07336460f, -0.01222229f, -0.22852038f, 0.07783876f, 0.03632591f, 0.03680079f, 0.01972993f, 0.02894557f, 
    -0.05906888f, 0.03872510f, 0.08646454f, 0.02822209f, -0.13390264f, -0.19833159f, 0.02997574f, -0.04246691f, 
    -0.02861536f, 0.06211118f, -0.02828821f, 0.01038312f, 0.01681587f, 0.04714509f, 0.08518405f, 0.06693369f, 
    0.29373118f, -0.04146736f, -0.01973444f, -0.14734443f, 0.01407260f, 0.05796914f, -0.01790905f, 0.02737850f, 
    0.06790823f, -0.05487361f, 0.07189585f, 0.06103298f, 0.11380230f, -0.13631302f, -0.01451622f, 0.00379830f, 
    -0.08709286f, 0.06129785f, 0.16594635f, 0.03550894f, -0.07514893f, 0.12102348f, 0.02197070f, 0.14590175f, 
    0.03616782f, -0.05693473f, 0.03992159f, -0.03938964f, 0.05203333f, 0.00123391f, -0.01054856f, -0.07924094f, 
    -0.07629164f, 0.04452024f, -0.03208779f, -0.03961532f, -0.01768749f, 0.06442975f, -0.00388727f, -0.05861555f, 
    0.00999940f, 0.00886138f, -0.00477054f, 0.03131707f, 0.01332837f, 0.04195539f, -0.06621668f, -0.04557447f, 
    -0.03197447f, 0.05738024f, -0.04915978f, -0.04725814f, 0.00975322f, 0.04645480f, 0.00724264f, -0.02021612f, 
    -0.00886054f, -0.07004841f, -0.03791442f, -0.03316950f, 0.04327438f, 0.03942355f, -0.07736792f, -0.00012155f, 
    0.00663599f, 0.03512377f, -0.01938301f, -0.03238495f, -0.01700917f, 0.01533754f, -0.07003544f, -0.06454276f, 
    0.06372367f, -0.07580300f, 0.03815038f, 0.05999306f, -0.01578864f, -0.04024126f, -0.02812621f, -0.01938363f, 
    -0.04035097f, 0.03698619f, -0.04512815f, 0.02402327f, -0.05639394f, -0.04007230f, 0.02433907f, -0.07438030f, 
    0.02721925f, 0.06469025f, -0.04157156f, 0.05815220f, 0.05844139f, 0.00263054f, 0.05248838f, -0.02659341f, 
    0.03092179f, 0.05607939f, 0.02722154f, 0.00105805f, 0.05424939f, 0.01719784f, -0.07763767f, 0.03034522f, 
    -0.03336752f, -0.04598795f, -0.05286282f, 0.04187184f, 0.01686726f, 0.00291130f, 0.02666136f, -0.06421934f, 
    -0.07419781f, -0.05731069f, 0.05453232f, 0.01371841f, -0.01160092f, -0.04943067f, -0.00363825f, 0.04021593f, 
    0.04873744f, -0.04976672f, 0.00802378f, -0.04462717f, -0.00599797f, -0.07583508f, 0.02317003f, 0.03014490f, 
    0.05075197f, 0.00807483f, -0.02378760f, -0.03396238f, -0.08022196f, 0.05864151f, -0.03173558f, -0.06928103f, 
    0.04925624f, -0.00647011f, -0.04462216f, -0.07468002f, 0.03735953f, 0.03928937f, -0.06673112f, -0.05005885f, 
    0.04998112f, 0.00191374f, -0.02992335f, -0.05742730f, 0.05213265f, -0.04260649f, -0.01309941f, -0.07124262f, 
    -0.06412016f, -0.06902496f, 0.01396234f, 0.05800927f, -0.01433704f, -0.05320597f, -0.02357171f, 0.00448168f, 
    -0.07078157f, 0.00994123f, 0.05374744f, -0.02818600f, -0.05246203f, -0.03760692f, -0.01467102f, -0.01314169f, 
    0.00831734f, 0.04366427f, -0.06233827f, -0.07414360f, -0.06799160f, -0.02535423f, -0.04383093f, -0.03540390f, 
    0.02231699f, -0.04689124f, -0.04118327f, 0.01546746f, -0.01601022f, -0.04154683f, -0.00663442f, -0.07153004f, 
    -0.06908973f, 0.03383136f, 0.02488662f, -0.00169055f, -0.01075013f, -0.07321583f, 0.05462438f, 0.00736465f, 
    0.03541114f, -0.06535128f, -0.04507851f, -0.03084678f, -0.05414024f, -0.02203263f, 0.00187345f, 0.03532141f, 
    0.00405823f, -0.03079358f, 0.02433096f, -0.00014071f, -0.01795542f, -0.04297452f, 0.00578108f, -0.05085651f, 
    0.00750087f, 0.04743172f, 0.05011484f, -0.00891054f, 0.04532317f, -0.00997293f, -0.02420510f, 0.03300478f, 
    -0.01694209f, 0.04796262f, 0.06483035f, -0.11278902f, -0.01627905f, -0.02792688f, 0.00023797f, -0.00822719f, 
    0.00891757f, 0.05643319f, 0.12939291f, 0.04801106f, -0.20893940f, -0.23473324f, -0.14526030f, -0.07536738f, 
    -0.00570882f, 0.05766069f, 0.02305136f, -0.13184544f, 0.11433779f, -0.02678923f, 0.05580115f, 0.04373766f, 
    0.17281654f, 0.10062554f, 0.13931133f, -0.03041580f, 0.13496983f, 0.15274043f, 0.00594876f, -0.04550315f, 
    -0.06986786f, -0.02590278f, 0.10778414f, 0.01702444f, 0.11007790f, 0.06365209f, -0.03874769f, 0.25384760f, 
    0.07627920f, -0.08486427f, -0.04633883f, 0.19095039f, 0.05788193f, 0.03612151f, 0.03089354f, -0.09192681f, 
    -0.29037297f, -0.33015692f, 0.16369015f, 0.11173363f, -0.12371100f, 0.04828558f, -0.08239569f, 0.08195008f, 
    -0.03445365f, -0.11486597f, -0.08674347f, 0.04039677f, -0.15753677f, 0.23270437f, 0.06882859f, -0.16076203f, 
    0.11835263f, -0.01029442f, -0.00025929f, -0.03171653f, 0.15060426f, 0.02859228f, 0.07981087f, 0.09985057f, 
    -0.34929401f, 0.20445970f, -0.08916534f, 0.07714663f, 0.20972674f, -0.07297528f, 0.05100742f, 0.04708904f, 
    -0.00932379f, 0.03461079f, 0.00671884f, -0.00097745f, 0.08172324f, -0.02723471f, 0.07056069f, 0.34282738f, 
    -0.04561169f, -0.09099323f, 0.08138450f, -0.01360397f, -0.08080844f, 0.05363923f, -0.00419261f, 0.17406818f, 
    -0.05911399f, 0.03413663f, 0.01019679f, -0.32874718f, 0.17677256f, -0.03494452f, 0.07099635f, 0.00931905f, 
    0.10763390f, 0.07415252f, -0.04284354f, -0.01377120f, -0.01649907f, 0.05499303f, 0.14173810f, 0.12595490f, 
    0.09452015f, -0.03073955f, 0.03161131f, -0.01183605f, -0.14057051f, -0.00058083f, -0.03948126f, -0.07962206f, 
    0.19935632f, 0.16836874f, -0.13018630f, -0.10415760f, 0.04545844f, 0.01676279f, 0.02254946f, -0.02858495f, 
    0.01691610f, -0.04600908f, -0.03539779f, -0.01591914f, -0.32739985f, 0.06439384f, -0.21622384f, -0.03194227f, 
    -0.01167096f, 0.04160097f, 0.01092795f, 0.03732850f, -0.06825718f, -0.05169721f, 0.00490740f, -0.03563356f, 
    -0.06293094f, -0.12407400f, -0.06238237f, 0.20580971f, 0.06797116f, 0.05283355f, -0.08686124f, 0.01666480f, 
    -0.12225459f, -0.11417726f, 0.05381600f, -0.02237193f, -0.10990943f, -0.03053953f, -0.01797912f, 0.16287054f, 
    0.09958697f, -0.01820062f, -0.05922471f, 0.06259410f, -0.10559085f, -0.02288209f, 0.13979895f, 0.10814970f, 
    0.11419476f, 0.02785565f, -0.02785980f, 0.03753442f, 0.15192334f, -0.01534664f, 0.06177217f, -0.12461361f, 
    0.15255459f, -0.10145894f, 0.01857339f, 0.05146215f, 0.23485929f, 0.10548684f, -0.05700891f, 0.21676542f, 
    -0.01123226f, 0.17749885f, -0.10726975f, -0.03558590f, 0.05048073f, 0.17670184f, 0.02492812f, -0.03203588f, 
    -0.05276290f, 0.03811362f, 0.05492924f, 0.05213798f, -0.04136899f, -0.07584221f, 0.04021690f, -0.00858164f, 
    0.01863244f, -0.06942873f, -0.03161249f, -0.02775137f, 0.01571832f, -0.06705909f, 0.05508848f, -0.05386792f, 
    -0.07428933f, 0.03839405f, -0.02758505f, 0.05167847f, -0.03193333f, 0.03426944f, -0.07331482f, 0.06063271f, 
    0.01659948f, 0.05004156f, -0.05081799f, 0.02667996f, -0.06101519f, -0.04320898f, 0.00493884f, 0.01826785f, 
    -0.01297528f, -0.02888916f, -0.02934688f, -0.03270149f, 0.00568439f, -0.05492149f, -0.02766142f, -0.02603416f, 
    0.02433048f, 0.05460714f, -0.05853841f, 0.00765997f, -0.03259596f, 0.00230449f, 0.01263347f, 0.00328518f, 
    0.01466445f, -0.06585135f, -0.06858975f, 0.00964989f, -0.04178059f, 0.03989443f, 0.02912278f, -0.02641744f, 
    0.00852203f, -0.03807814f, -0.00783877f, 0.00040770f, -0.03964948f, -0.00994347f, -0.02311068f, 0.06085865f, 
    -0.06753409f, -0.01800192f, 0.06852153f, -0.06002765f, 0.03813416f, 0.00742854f, -0.06196248f, -0.06247501f, 
    0.06164957f, -0.00228968f, -0.07022353f, 0.01297147f, -0.03922407f, -0.02579987f, -0.00823375f, 0.04232789f, 
    -0.00648924f, -0.04945320f, 0.02330967f, -0.03766321f, 0.00896231f, -0.04198298f, -0.02390758f, 0.03716375f, 
    0.04237850f, 0.04633290f, -0.03321733f, 0.00566634f, -0.07328209f, 0.05303885f, -0.05458373f, -0.06388242f, 
    -0.00874349f, -0.04445755f, -0.01272022f, -0.02686633f, 0.01847706f, -0.03144254f, 0.02098241f, 0.06351086f, 
    -0.03510978f, 0.01826884f, -0.01576864f, 0.03670327f, 0.03653049f, 0.03145974f, -0.01307454f, 0.04416571f, 
    0.05830096f, -0.04909547f, -0.04545004f, 0.00549378f, -0.03352696f, -0.07016291f, 0.03347089f, 0.00170849f, 
    0.01245731f, -0.01152867f, -0.07008994f, 0.01966712f, -0.01061819f, 0.04139392f, -0.00106536f, -0.07190922f, 
    -0.03950855f, -0.03640248f, 0.05859973f, -0.02926878f, -0.05047392f, 0.00610578f, 0.05027889f, -0.06917827f, 
    -0.01293637f, -0.01315731f, -0.02167973f, -0.04406242f, 0.00104889f, -0.00744055f, -0.03425679f, -0.03389315f, 
    -0.06332461f, 0.00817437f, -0.07623186f, 0.01806523f, -0.01796579f, 0.04534034f, -0.07629013f, -0.03844125f, 
    0.06153617f, -0.04899566f, 0.04954598f, 0.00539475f, -0.06186344f, -0.05209242f, -0.06669370f, 0.02546418f, 
    0.00230081f, 0.04839194f, -0.00291035f, 0.01093154f, 0.01558764f, 0.01771134f, -0.07546058f, 0.03079792f, 
    0.06728271f, 0.05129726f, -0.02359394f, 0.03065853f, 0.05794735f, -0.01524343f, -0.03887137f, 0.03213052f, 
    -0.00374979f, -0.03594668f, -0.06365914f, -0.05900776f, -0.00718565f, -0.01711966f, 0.03947947f, -0.00452942f, 
    -0.00154043f, 0.04417909f, 0.06259044f, 0.05974816f, -0.04832823f, 0.04742577f, -0.01680374f, -0.06973765f, 
    -0.07140198f, -0.22316565f, -0.06544560f, 0.10250749f, 0.13221779f, 0.04457858f, 0.09425001f, -0.02161082f, 
    0.06232587f, -0.07277609f, 0.04298899f, 0.01171286f, 0.08567470f, 0.05285002f, -0.01866758f, 0.11590316f, 
    -0.01694222f, -0.24037156f, 0.10620616f, 0.18631268f, 0.03637328f, 0.05864051f, 0.02951275f, -0.00120817f, 
    -0.18777469f, -0.07367712f, -0.08648620f, -0.00709163f, 0.13005611f, 0.18398443f, 0.07252112f, -0.00826664f, 
    -0.02239982f, 0.02395432f, 0.00462124f, 0.01783466f, -0.13514091f, -0.14931007f, 0.02585398f, -0.08731296f, 
    -0.05199600f, -0.05285939f, 0.08707710f, 0.13818830f, -0.00839992f, -0.13035336f, 0.12428203f, 0.01817157f, 
    0.09861393f, 0.27824071f, -0.04581058f, -0.26402006f, -0.00908783f, 0.09351368f, -0.11457480f, 0.06653447f, 
    -0.00268764f, 0.07546408f, 0.00864473f, 0.09542186f, 0.01625072f, -0.03802662f, 0.17454647f, 0.14653032f, 
    0.07673691f, 0.04392302f, 0.10442581f, 0.10604122f, -0.05502933f, 0.00769024f, -0.00136290f, 0.00820300f, 
    0.14180233f, 0.13880688f, 0.09628502f, 0.09293690f, 0.03450590f, 0.05493198f, 0.04076804f, 0.06455679f, 
    -0.00997170f, 0.04061874f, -0.05968840f, 0.04622623f, 0.02950126f, 0.17835957f, 0.07869846f, -0.00928466f, 
    0.18731330f, 0.13603555f, -0.01374012f, -0.01409387f, 0.22812548f, 0.09477597f, -0.08568063f, -0.02626964f, 
    -0.39330551f, 0.07555999f, -0.17157224f, 0.03086747f, 0.17916240f, -0.05555981f, -0.07533678f, 0.07091530f, 
    -0.02759269f, 0.11077236f, 0.12061615f, 0.08027407f, -0.00549459f, 0.06394312f, -0.14241761f, -0.02254706f, 
    -0.00564601f, -0.05330960f, 0.02333198f, 0.05683791f, 0.00684751f, 0.09347951f, 0.06346651f, 0.04541211f, 
    -0.05062293f, -0.28061262f, -0.08490323f, 0.02235373f, 0.04327281f, 0.04971079f, -0.01089727f, -0.01006871f, 
    0.06892673f, -0.08480069f, 0.00001186f, 0.01014241f, 0.11615775f, -0.05570128f, 0.02433617f, 0.17849740f, 
    -0.23947187f, -0.03280313f, 0.02540527f, 0.01172297f, -0.12251768f, -0.00898670f, 0.02061352f, -0.04147214f, 
    0.21456105f, -0.03032824f, -0.17408447f, -0.06417859f, 0.06439398f, 0.09890739f, -0.07645973f, -0.05537045f, 
    -0.04561457f, 0.00881152f, 0.02727893f, 0.03281834f, 0.04077146f, 0.06259649f, 0.17142943f, -0.08317436f, 
    0.08581287f, -0.16161320f, -0.03237146f, 0.19698985f, 0.13647023f, 0.07503942f, 0.07812348f, -0.16101712f, 
    -0.42538914f, -0.17650914f, 0.04295358f, 0.10403900f, 0.17102176f, 0.08034328f, 0.02871699f, 0.06474975f, 
    -0.06150731f, 0.01311418f, 0.00927137f, 0.01118758f, -0.20669439f, -0.20937856f, 0.32576281f, -0.04650961f, 
    -0.21268734f, 0.03966514f, 0.18432739f, -0.13623761f, -0.08826499f, 0.06850460f, -0.05724769f, 0.13328958f, 
    0.00261520f, 0.04194300f, -0.00043860f, -0.06405757f, -0.05197074f, -0.00260142f, -0.07564198f, 0.01568001f, 
    0.00854055f, 0.00948676f, 0.04084707f, 0.01636497f, 0.04988446f, 0.02697293f, -0.02437404f, -0.05476370f, 
    -0.05805862f, -0.05866974f, -0.07687747f, -0.01612362f, 0.02781489f, -0.01224593f, 0.03951875f, 0.00306521f, 
    0.04389629f, -0.05388152f, -0.01992626f, 0.06327676f, -0.05532785f, -0.02378873f, 0.01607113f, 0.05790275f, 
    0.02679554f, -0.04544772f, 0.04483470f, 0.00267069f, -0.00085552f, 0.03672925f, 0.03854946f, 0.02328713f, 
    -0.03491767f, -0.07105299f, 0.04437475f, -0.06186526f, -0.07775608f, -0.01996608f, -0.02431345f, 0.03720040f, 
    -0.06737362f, 0.02029108f, 0.03145081f, -0.01600441f, 0.01376495f, -0.04094042f, -0.03663802f, 0.04470398f, 
    -0.07407324f, 0.01973552f, 0.02871362f, -0.05143655f, -0.05640416f, -0.05612390f, -0.01397043f, 0.03980777f, 
    -0.06350026f, -0.04386787f, -0.05300955f, -0.00774070f, -0.06643600f, -0.06329022f, -0.04242091f, -0.07962378f, 
    -0.05078622f, -0.05299613f, 0.06839767f, 0.05270018f, -0.01532307f, -0.04662807f, 0.01107502f, -0.03667429f, 
    0.02904371f, -0.05858321f, 0.03472998f, 0.03758464f, 0.04431342f, 0.04971715f, -0.02805316f, -0.00525613f, 
    -0.03676827f, 0.04617582f, 0.00777980f, 0.01205977f, 0.00818870f, -0.06960524f, -0.03176530f, -0.03646570f, 
    -0.00791253f, -0.07306585f, 0.05325346f, 0.02318499f, 0.05794403f, 0.00996088f, 0.02896517f, 0.06025139f, 
    0.01976724f, 0.01302422f, -0.00852500f, 0.02378831f, -0.07491165f, 0.05628579f, 0.06183856f, -0.06808142f, 
    0.04262269f, 0.01172955f, -0.01471184f, -0.00207392f, -0.00891961f, -0.03058859f, -0.01199425f, -0.02419774f, 
    0.02532209f, 0.02314655f, 0.02437099f, -0.01646953f, -0.03878492f, -0.05812230f, -0.03281400f, -0.01396076f, 
    -0.01500343f, 0.04836345f, -0.05608980f, 0.01957134f, -0.03844969f, 0.05627086f, -0.05018596f, -0.00553112f, 
    -0.01528209f, 0.06096702f, -0.02272712f, 0.02394754f, 0.01944610f, -0.02948728f, 0.03583628f, -0.00535518f, 
    -0.04943984f, 0.03062270f, -0.07552253f, -0.04688285f, 0.02139355f, -0.01402183f, 0.00085047f, 0.01385909f, 
    0.03863477f, 0.02320321f, -0.01409993f, -0.03600329f, 0.03447703f, 0.06008916f, -0.05433054f, -0.04661996f, 
    -0.04524197f, -0.00673560f, 0.03867472f, 0.01387795f, -0.00335090f, -0.01936403f, -0.04951736f, 0.03524504f, 
    -0.00390799f, 0.05103375f, 0.00630234f, -0.04529392f, 0.01344550f, 0.03964758f, -0.00269261f, 0.03937136f, 
    -0.05529941f, -0.07553950f, -0.03449751f, -0.07397659f, -0.02044966f, -0.02913207f, -0.04878407f, 0.03306778f, 
    0.05448288f, -0.07531153f, 0.02207279f, 0.03674051f, -0.04705369f, -0.06745656f, 0.05049034f, -0.03471015f, 
    -0.24779390f, 0.10218065f, -0.08972036f, 0.12076006f, -0.08506538f, -0.04097947f, 0.04164964f, 0.08530810f, 
    0.04887537f, 0.09685347f, 0.05577849f, 0.16167432f, -0.07942830f, 0.00446030f, 0.14249896f, -0.00178694f, 
    -0.02956352f, -0.01369774f, 0.07786330f, 0.10907709f, 0.10228930f, 0.14683723f, -0.00559903f, 0.10759217f, 
    -0.04510332f, 0.15537761f, 0.11495168f, 0.03712463f, -0.00276843f, 0.00671329f, 0.15499368f, -0.06418079f, 
    0.09998105f, 0.07313359f, 0.04228892f, -0.03556949f, -0.16344501f, 0.00783042f, 0.04863040f, 0.04887201f, 
    0.05233341f, 0.13884276f, -0.01407473f, 0.02170968f, -0.15499878f, -0.02567553f, 0.06352378f, -0.04702980f, 
    0.54775673f, 0.09440604f, 0.05346116f, -0.00181187f, 0.11435325f, 0.05543807f, 0.05235731f, -0.00071857f, 
    -0.03924999f, 0.03499985f, -0.02234041f, 0.06006934f, 0.12844424f, 0.06092387f, 0.00675796f, 0.02357395f, 
    0.05447444f, -0.07889570f, 0.10583055f, 0.03186188f, 0.05721283f, -0.01448012f, -0.13721542f, -0.09821873f, 
    -0.05980920f, 0.28042877f, 0.05857433f, 0.12801325f, 0.10343345f, 0.06686560f, 0.00918952f, 0.00222630f, 
    -0.12895261f, 0.05092143f, 0.03245971f, -0.10682636f, -0.06846601f, -0.06984813f, -0.05644184f, -0.06244547f, 
    0.04759410f, 0.14042591f, -0.00862565f, 0.00394290f, 0.06484486f, -0.16191113f, -0.11162388f, 0.05041553f, 
    -0.06482524f, 0.17166993f, -0.03395035f, -0.01624937f, -0.04734562f, -0.11055196f, -0.05949602f, 0.01206732f, 
    -0.11785707f, 0.01941701f, -0.10751452f, 0.03585871f, 0.06252192f, -0.21278076f, 0.08908350f, -0.01983461f, 
    -0.09567468f, -0.01170289f, 0.14225020f, -0.02245552f, -0.06529863f, -0.04267591f, -0.01222488f, -0.11983753f, 
    -0.15501668f, 0.20756371f, 0.02651195f, 0.03440730f, -0.10059023f, -0.04190887f, -0.12507045f, -0.01303319f, 
    0.08542217f, -0.02451907f, 0.02392650f, -0.11477802f, -0.26387209f, -0.19088586f, 0.07870855f, -0.01478001f, 
    0.07840351f, 0.06137049f, -0.08338284f, 0.00232585f, -0.06939656f, -0.01609760f, 0.09005025f, 0.06142039f, 
    -0.12338487f, 0.01619902f, -0.00900884f, -0.04854997f, 0.01504516f, 0.09169734f, -0.09746931f, 0.08421824f, 
    0.04746656f, 0.00838944f, 0.06837159f, -0.05887359f, 0.27135843f, -0.07923240f, 0.07376262f, 0.00740692f, 
    0.07383539f, 0.15057617f, 0.09596756f, 0.05906431f, -0.02956184f, 0.04860125f, -0.08405378f, 0.14546385f, 
    -0.04506494f, 0.13771595f, -0.08193851f, -0.25943387f, 0.03452257f, 0.00077540f, -0.03322098f, 0.04292696f, 
    -0.16206595f, 0.13037115f, -0.02551023f, 0.05576460f, -0.19495089f, -0.09095560f, -0.11982086f, 0.12775449f, 
    -0.08565335f, -0.04449097f, 0.10492340f, -0.07784766f, -0.01284962f, 0.12908895f, 0.06995109f, 0.14752725f, 
    0.43973252f, 0.11406089f, 0.23645969f, 0.15836121f, 0.06937276f, -0.04094193f, -0.03292011f, 0.05597073f, 
    -0.07368048f, -0.04944829f, -0.05802689f, -0.10557035f, -0.00880988f, -0.11155599f, -0.00739173f, 0.05554388f, 
    0.11697210f, 0.09409436f, -0.06812824f, -0.14817324f, -0.02884236f, -0.03334353f, 0.03496038f, 0.01646650f, 
    -0.07111071f, -0.13879880f, 0.11675869f, -0.15348925f, 0.08669566f, -0.03083428f, -0.18879639f, -0.01170271f, 
    0.00860554f, -0.03903164f, 0.06150172f, 0.06992021f, 0.11932283f, 0.09497229f, 0.01360135f, -0.13338126f, 
    0.06623271f, 0.08429621f, 0.04334692f, 0.00458640f, 0.13936520f, 0.06450639f, -0.03225823f, 0.05061879f, 
    -0.26995158f, -0.17412230f, -0.11923485f, -0.10452916f, 0.00002509f, -0.12390829f, 0.09839746f, -0.07853943f, 
    0.08903802f, 0.04088756f, 0.03539591f, -0.12449156f, -0.26517048f, -0.06325880f, -0.07826933f, -0.03583013f, 
    0.11168704f, 0.04627065f, -0.05362568f, 0.01217697f, 0.08355980f, 0.01040129f, 0.03742112f, 0.15656625f, 
    -0.16384818f, -0.02526056f, -0.12843560f, -0.12343776f, 0.02828478f, -0.07031652f, 0.07189929f, 0.09014358f, 
    -0.02718848f, -0.01982260f, 0.11437260f, 0.05392168f, -0.14149407f, -0.07773752f, -0.00094376f, -0.04953987f, 
    0.05351300f, -0.00842096f, 0.04412918f, -0.01419645f, -0.05101444f, 0.16960250f, 0.09850614f, -0.02711456f, 
    0.22938266f, 0.08499303f, 0.11976883f, 0.04590584f, 0.02431150f, 0.01061895f, 0.03213541f, 0.02067090f, 
    0.10252500f, 0.01612164f, 0.02911521f, 0.00710974f, 0.26436841f, 0.12900737f, -0.16256061f, 0.00913776f, 
    0.11461914f, 0.12126093f, 0.02550540f, -0.00658106f, -0.02741344f, 0.00714827f, 0.17804056f, 0.14354755f, 
    0.27828902f, 0.01860798f, 0.09212656f, 0.14225765f, -0.02826572f, 0.05594819f, 0.00813325f, 0.02019719f, 
    0.03576301f, -0.01191903f, 0.09804376f, 0.13429910f, 0.01575386f, 0.08221132f, -0.25713152f, 0.12615526f, 
    0.05295881f, 0.06829520f, 0.00056672f, 0.11841050f, 0.07718638f, -0.04245569f, -0.06067407f, 0.00295901f, 
    0.03934059f, -0.06051121f, -0.03650894f, 0.12362372f, 0.00263055f, -0.06042225f, -0.02094962f, -0.16098884f, 
    -0.04152720f, 0.10291442f, 0.02497856f, 0.09476174f, -0.14706913f, 0.10757943f, -0.07680748f, 0.05020949f, 
    -0.04548426f, 0.04054875f, 0.02898898f, 0.02246657f, -0.03324489f, -0.06815470f, 0.05749708f, 0.05321284f, 
    0.22411771f, 0.18333119f, 0.12383883f, 0.03083614f, 0.03786530f, -0.06330090f, -0.01599775f, 0.00463084f, 
    0.00750749f, -0.04972598f, -0.00493875f, -0.12698762f, -0.00214842f, 0.02331518f, -0.07750290f, -0.09239192f, 
    0.03493519f, 0.03014529f, 0.05623708f, 0.11188903f, 0.00512129f, -0.15029983f, -0.01948612f, -0.06311083f, 
    -0.13170625f, -0.10577954f, -0.03151557f, 0.04338191f, 0.05759693f, -0.10442201f, -0.05518673f, 0.07705379f, 
    0.02698663f, -0.02087885f, -0.04625887f, -0.02732556f, 0.13890798f, 0.24397868f, 0.13692878f, 0.14462130f, 
    -0.13373187f, -0.00658883f, 0.11947772f, -0.00165309f, -0.04533150f, -0.05254815f, -0.03300633f, -0.07437290f, 
    -0.02408503f, 0.08142478f, -0.15596843f, -0.07513256f, 0.06217618f, 0.02880850f, 0.13225514f, -0.10830851f, 
    -0.00314345f, 0.10710967f, -0.09873637f, -0.04253276f, -0.27803963f, -0.07152124f, 0.03436800f, -0.19959541f, 
    -0.03079912f, 0.04510979f, 0.10739729f, -0.13109539f, 0.05763631f, -0.06012125f, 0.05644722f, -0.02667258f, 
    0.56075591f, 0.27092382f, -0.05149763f, 0.00163977f, 0.10416286f, 0.01298275f, -0.01474562f, 0.04620665f, 
    0.09303246f, -0.00580076f, -0.03496101f, 0.05075678f, 0.11855874f, -0.10426199f, 0.04804533f, 0.14675398f, 
    -0.03083658f, -0.00146230f, -0.02074250f, 0.02421719f, -0.02842630f, -0.04014523f, -0.00637365f, -0.00153147f, 
    0.31343359f, -0.02164648f, 0.11123604f, 0.13185155f, 0.04310465f, 0.11947415f, 0.06623351f, -0.09089775f, 
    -0.01826725f, 0.07482912f, 0.04898682f, 0.01795391f, 0.02704422f, -0.04059810f, 0.05564500f, 0.03307530f, 
    0.01016991f, -0.04946169f, 0.03065157f, 0.05936025f, 0.13731934f, 0.08610396f, -0.07077412f, -0.00480338f, 
    -0.24732824f, -0.05010705f, -0.16228057f, 0.15492828f, -0.13449684f, 0.01974987f, -0.05656249f, 0.06399844f, 
    -0.00463758f, 0.06125613f, 0.01401774f, 0.11645514f, -0.26455498f, 0.00661232f, 0.04510230f, 0.07324339f, 
    -0.11129551f, 0.01126578f, -0.01845709f, 0.03473618f, -0.04148583f, 0.12742499f, 0.00751103f, 0.02491542f, 
    -0.16627590f, -0.24655655f, -0.12652162f, 0.03878434f, -0.02750778f, 0.00436241f, 0.03136150f, 0.08014908f, 
    0.19257544f, 0.04504371f, 0.01700422f, 0.08446365f, 0.01680974f, 0.13311310f, 0.20878886f, 0.08642057f, 
    -0.10547556f, -0.02087506f, -0.04080395f, 0.02143151f, -0.06025883f, 0.07406536f, 0.04012972f, 0.10541718f, 
    0.09070400f, 0.10692494f, 0.05998861f, 0.10699446f, 0.17935258f, 0.01296824f, 0.10259943f, 0.11172809f, 
    0.21440074f, 0.04406223f, 0.07643110f, 0.09239729f, -0.07376556f, 0.15156242f, 0.02306037f, -0.19015682f, 
    0.00017930f, 0.03844636f, 0.07996672f, 0.01732124f, -0.00057291f, 0.14824218f, -0.06588585f, -0.03459835f, 
    -0.22462407f, -0.06911564f, 0.11354360f, 0.07952635f, 0.00413126f, 0.03581914f, 0.00819860f, 0.01605823f, 
    -0.02465569f, 0.08532675f, 0.01429748f, 0.06691533f, -0.33331713f, -0.04008107f, -0.07353969f, 0.09854725f, 
    -0.00660506f, -0.04260036f, 0.05290028f, -0.03547467f, -0.04177901f, -0.06905052f, 0.01738721f, 0.01289395f, 
    -0.02739267f, -0.04689136f, -0.04404021f, -0.06692511f, 0.00794968f, -0.10058727f, 0.01899485f, 0.04486230f, 
    -0.04269597f, -0.01251878f, 0.16789323f, 0.05200065f, -0.09714111f, -0.18519323f, -0.00737983f, 0.11238696f, 
    -0.15884525f, 0.02155157f, -0.00534007f, -0.05817885f, 0.11095376f, -0.03620478f, 0.11928565f, -0.07056060f, 
    0.47977325f, 0.06641756f, -0.05607978f, -0.17149270f, 0.12259392f, 0.08632368f, 0.03222084f, -0.06742529f, 
    -0.05795450f, 0.02511244f, 0.06300453f, 0.02053472f, 0.00036716f, 0.07032149f, -0.13273698f, 0.05888579f, 
    -0.03591750f, -0.17476790f, 0.04384048f, 0.20267317f, 0.00916219f, -0.06434567f, -0.04221863f, -0.10676879f, 
    0.16777773f, 0.22212850f, -0.01530147f, 0.06282268f, -0.06130895f, 0.08498075f, -0.00860750f, 0.17444165f, 
    0.02318455f, -0.03493555f, -0.11039731f, 0.04306197f, -0.12237900f, -0.05734837f, 0.20874929f, -0.10239240f, 
    0.03762773f, 0.09268413f, -0.00717805f, -0.11260757f, 0.06537238f, 0.03186500f, -0.05953147f, -0.11499397f, 
    -0.02529468f, 0.26588160f, -0.07931237f, -0.14065090f, 0.12301450f, 0.00247244f, -0.02133803f, -0.04350654f, 
    0.08647720f, 0.07550602f, -0.13595723f, 0.01078807f, 0.00313023f, 0.03077642f, 0.01380356f, 0.24403913f, 
    0.05165628f, 0.03883312f, 0.09766578f, -0.00999418f, 0.01722542f, 0.01751301f, 0.01033548f, 0.01026267f, 
    -0.11949281f, -0.04112821f, 0.01944132f, -0.12747242f, 0.09323614f, 0.01491247f, 0.08132375f, 0.08898458f, 
    0.05762959f, -0.00928590f, -0.12549612f, -0.03083391f, -0.01041892f, -0.00675532f, -0.00305524f, 0.16682816f, 
    0.03299832f, -0.19909702f, 0.00882377f, -0.01038130f, -0.12264258f, -0.05015413f, -0.05252044f, -0.11018330f, 
    0.12496419f, 0.17116110f, -0.05016228f, 0.08315160f, 0.07187614f, 0.01325589f, -0.02116371f, -0.05975541f, 
    -0.03736394f, -0.16543090f, -0.10429531f, -0.03070732f, -0.26861748f, -0.01258067f, 0.06531461f, 0.28533804f, 
    -0.00141834f, -0.03304780f, 0.13327251f, 0.09004664f, -0.15932059f, -0.06160145f, 0.01097783f, 0.02383813f, 
    0.14336593f, 0.09440677f, -0.11587827f, 0.28122520f, 0.15262038f, 0.00413365f, -0.01890616f, -0.11212590f, 
    0.00109460f, -0.05731927f, 0.06559687f, -0.05612890f, -0.37564635f, -0.05020205f, 0.00349317f, 0.07205282f, 
    0.07550600f, -0.00778965f, -0.08738796f, -0.09929129f, -0.07979656f, 0.12337990f, 0.09467258f, -0.00156639f, 
    0.13428736f, 0.01976116f, 0.10374653f, 0.10909243f, 0.10228351f, 0.15392895f, 0.06080482f, 0.01574540f, 
    0.07028189f, -0.04799232f, 0.11829589f, 0.00860352f, 0.26455587f, 0.01037175f, -0.22615798f, 0.25013733f, 
    -0.00950226f, 0.01694901f, 0.03353432f, -0.03014615f, 0.00093961f, 0.18726446f, 0.09123172f, 0.08268544f, 
    0.22501567f, 0.04372426f, 0.03238305f, 0.16544704f, -0.00370777f, -0.06606537f, -0.13626643f, -0.16242330f, 
    0.08716517f, 0.08249253f, 0.15269858f, 0.10344168f, 0.07347433f, -0.09016187f, -0.18054493f, -0.08429255f, 
    0.21581197f, 0.03431415f, 0.13424708f, 0.25746432f, -0.03322123f, 0.13932104f, -0.04605575f, 0.00828433f, 
    -0.39418304f, 0.07592265f, -0.02520400f, -0.25606367f, -0.06033986f, 0.09084266f, -0.11349633f, -0.06387295f, 
    -0.05441386f, -0.00790315f, 0.00028937f, 0.11474494f, -0.26366779f, -0.20486663f, 0.05804747f, -0.00923751f, 
    0.12287863f, 0.15315603f, 0.01255473f, -0.09893345f, -0.02615854f, -0.05813856f, -0.00473831f, 0.09796519f, 
    -0.25741944f, -0.23948933f, 0.13336109f, -0.30458745f, -0.07015903f, 0.08560075f, -0.00024280f, 0.00563231f, 
    0.10695250f, 0.00768564f, 0.03974386f, 0.10325447f, -0.15358709f, -0.20709452f, -0.03549071f, 0.22719932f, 
    -0.09836281f, 0.03506195f, -0.06881868f, -0.05189805f, 0.10155657f, 0.03244454f, 0.01546457f, 0.07569413f, 
    -0.22667584f, -0.04232097f, 0.08590541f, 0.28822449f, -0.18420941f, -0.09182243f, -0.00782932f, 0.08263128f, 
    0.00363693f, 0.06486917f, 0.07130580f, 0.04977285f, -0.11146288f, 0.00281424f, 0.06399489f, 0.00000847f, 
    -0.06038349f, 0.11160318f, -0.04353305f, -0.13693637f, 0.03880582f, 0.15400064f, 0.07800027f, -0.00398307f, 
    -0.10117567f, 0.24360813f, -0.03437171f, 0.22861178f, -0.03439522f, -0.04842544f, -0.06404863f, 0.02785754f, 
    -0.04148736f, 0.02954255f, 0.04787351f, 0.19871581f, 0.04418371f, 0.12270594f, -0.16931948f, 0.00353569f, 
    -0.09027997f, 0.06965195f, -0.06735745f, 0.05731420f, 0.08883515f, 0.05203866f, 0.16244277f, 0.10791181f, 
    0.27434045f, -0.19780637f, 0.31819901f, 0.12923183f, -0.04128264f, -0.09394726f, 0.05384077f, -0.04129863f, 
    -0.00859796f, 0.07245753f, 0.11758494f, 0.12755446f, -0.05696203f, 0.14328973f, -0.25866517f, 0.06059575f, 
    0.08053973f, 0.17987078f, -0.00488888f, 0.15437806f, 0.17771392f, 0.02597511f, -0.00604636f, 0.05575738f, 
    0.13780390f, -0.12995782f, 0.25106215f, -0.43603238f, -0.19820988f, -0.08414831f, 0.02833243f, 0.07488000f, 
    -0.05503205f, 0.11292004f, -0.00135294f, -0.08038418f, 0.11206575f, 0.16860783f, -0.15891977f, -0.20051943f, 
    0.07803614f, 0.08029980f, -0.05869618f, 0.18664236f, 0.07487689f, -0.05375624f, 0.00525672f, 0.14758292f, 
    0.10098760f, 0.17393669f, -0.01914248f, -0.04138248f, -0.06217624f, -0.02593681f, -0.13079673f, -0.06355027f, 
    0.03765288f, 0.11804260f, 0.06026151f, 0.06847748f, -0.03501735f, -0.07661148f, 0.35391393f, -0.37048450f, 
    -0.07492794f, -0.05346480f, 0.02008751f, -0.12320127f, -0.11507498f, -0.06885587f, 0.05587273f, 0.05512826f, 
    -0.29447532f, 0.01027467f, -0.05646768f, -0.04410033f, 0.05684106f, -0.04079899f, 0.09128610f, 0.14498629f, 
    0.13065667f, 0.05307185f, 0.08432531f, 0.12258924f, 0.32084891f, 0.04274603f, 0.00915861f, -0.00808690f, 
    -0.16528365f, -0.01995854f, 0.02498373f, 0.14910626f, -0.06339628f, 0.17994832f, -0.05260807f, 0.02882778f, 
    0.30118924f, -0.03692159f, 0.05080073f, 0.16910599f, 0.00913329f, 0.00429321f, 0.04659163f, 0.06352392f, 
    0.01791434f, 0.06727001f, -0.03228593f, 0.08338271f, -0.12116307f, -0.13178366f, 0.06652468f, -0.08645446f, 
    0.08071049f, 0.12546957f, -0.03142003f, -0.05767559f, -0.07021073f, -0.06609411f, -0.02096861f, -0.05269526f, 
    0.49039194f, 0.36693460f, -0.05181971f, 0.07263425f, 0.04401260f, 0.12574144f, 0.02620392f, 0.07756542f, 
    -0.11808887f, 0.15553622f, -0.04519340f, 0.03416024f, 0.13016327f, 0.03489170f, 0.09629682f, 0.15163881f, 
    -0.00939267f, -0.01560370f, 0.07859988f, 0.02673766f, -0.14912902f, -0.05688124f, -0.15683156f, -0.12589316f, 
    0.18477447f, 0.10281448f, -0.04827049f, -0.03080981f, 0.00279160f, 0.08139751f, -0.09381909f, -0.01702954f, 
    0.02388138f, 0.17123599f, -0.02468105f, -0.18264082f, 0.07497926f, 0.04803365f, -0.06515621f, -0.01992861f, 
    -0.00549611f, 0.08787412f, -0.09505540f, 0.01995360f, 0.06001921f, -0.15711214f, 0.04375229f, -0.03729852f, 
    0.10846269f, -0.23598506f, -0.09458332f, 0.12544715f, -0.12149189f, 0.01238480f, 0.05915606f, -0.02425910f, 
    -0.03658792f, 0.02825235f, 0.01666456f, 0.04289241f, -0.20001493f, -0.01859777f, 0.11206637f, -0.06106583f, 
    -0.13899876f, -0.02739027f, 0.02383173f, 0.05629299f, -0.02390492f, -0.08564495f, -0.03375107f, -0.03822596f, 
    -0.04949481f, 0.00245228f, 0.02060570f, 0.00080287f, -0.08236641f, -0.12506312f, 0.04368558f, 0.02326251f, 
    0.12267701f, 0.15774249f, -0.01091883f, -0.13900968f, 0.13202724f, -0.11117914f, 0.23192604f, -0.03567929f, 
    0.02700411f, -0.09689334f, -0.04859485f, -0.10577270f, -0.08702154f, 0.07738205f, 0.08614651f, 0.05127922f, 
    -0.05176638f, 0.08084686f, 0.03516351f, 0.01967079f, 0.23212245f, 0.05546784f, 0.06003419f, -0.01178728f, 
    -0.02636746f, 0.11229081f, 0.06310082f, 0.04571647f, -0.17847671f, -0.10448124f, 0.06691132f, 0.02990821f, 
    0.02102228f, 0.06172075f, 0.04856909f, -0.02698470f, 0.01205147f, -0.00997995f, -0.05361888f, 0.02321309f, 
    -0.01470805f, -0.07805242f, -0.02702260f, -0.14675122f, 0.02238247f, -0.01199758f, -0.04011048f, 0.00722414f, 
    -0.11925238f, 0.08878258f, 0.05822900f, -0.03816764f, -0.02710466f, -0.11469768f, -0.11011806f, 0.28479543f, 
    -0.00597767f, 0.02386278f, 0.08296847f, -0.08017871f, -0.02812936f, 0.09714516f, 0.03612579f, 0.12493734f, 
    0.02342982f, 0.01786415f, 0.00445562f, -0.04335456f, 0.06232823f, -0.00757049f, 0.03706548f, -0.07547882f, 
    0.04439598f, -0.03649281f, -0.03440118f, 0.01885656f, -0.02822026f, -0.04380557f, -0.02919792f, -0.04028931f, 
    0.01979761f, 0.03574773f, 0.04069616f, -0.05451842f, -0.03839238f, -0.06526140f, 0.02901463f, -0.07107061f, 
    0.05520413f, 0.04210304f, -0.07450181f, -0.01329653f, -0.07283315f, -0.04161781f, -0.00107601f, -0.04549723f, 
    -0.01261684f, 0.06366588f, -0.02565881f, -0.05556489f, 0.04210532f, -0.07227517f, -0.03620179f, -0.00987860f, 
    -0.00581642f, -0.06051206f, -0.04389132f, -0.01395068f, 0.03828769f, -0.04198727f, -0.07580749f, -0.01851265f, 
    -0.03781574f, 0.06365628f, -0.02836934f, -0.00739461f, -0.01143657f, -0.07376749f, -0.04132172f, -0.03417942f, 
    0.05561718f, -0.04686094f, -0.04205475f, 0.03881708f, 0.03824224f, -0.07090923f, -0.03475744f, -0.05573458f, 
    -0.02859945f, 0.03501233f, 0.04009888f, -0.02895061f, 0.06420721f, -0.04432980f, -0.00433264f, 0.02260331f, 
    -0.00533435f, -0.00677534f, 0.03810438f, 0.04495261f, 0.03145507f, -0.05093522f, -0.06335640f, -0.02757380f, 
    -0.07138538f, -0.03417328f, 0.00876261f, -0.01915107f, -0.02833869f, 0.01675230f, -0.00553104f, -0.02642481f, 
    -0.07319562f, 0.02656744f, -0.01128105f, 0.05772658f, 0.06185753f, 0.00696435f, -0.06180250f, 0.06090156f, 
    -0.03672930f, 0.07101039f, 0.03602808f, -0.06998957f, 0.00664889f, -0.04132465f, -0.06578034f, -0.07262159f, 
    -0.00461300f, -0.06778496f, 0.00256047f, 0.02197492f, -0.06046668f, 0.06895796f, -0.04169156f, -0.06383619f, 
    -0.02479172f, -0.04180788f, -0.02511226f, 0.02812710f, 0.01946189f, 0.01994276f, -0.02404656f, -0.01172949f, 
    0.04981211f, -0.01429699f, -0.06425056f, 0.03992540f, -0.02799757f, 0.06730980f, -0.06100819f, 0.03662815f, 
    0.05099737f, 0.01433464f, -0.05308488f, -0.06927413f, 0.04481247f, 0.02732370f, 0.05837207f, -0.03097554f, 
    0.06486528f, -0.07220892f, 0.05739567f, -0.02281750f, -0.04881933f, -0.05568390f, -0.01793526f, -0.03954775f, 
    -0.01445160f, -0.06590915f, -0.03760983f, -0.06508126f, 0.06098781f, 0.00514864f, -0.06439810f, 0.00453828f, 
    -0.01946828f, 0.00821642f, 0.06113457f, -0.04124674f, 0.00837557f, 0.06448267f, -0.05979498f, 0.05013718f, 
    -0.07640045f, 0.04520301f, -0.02054553f, -0.07716356f, -0.07551177f, -0.02898130f, 0.03410947f, -0.00051820f, 
    -0.04865823f, 0.04129527f, -0.05511290f, -0.06196435f, 0.00957782f, 0.00890246f, 0.05615465f, -0.06047229f, 
    0.05245602f, -0.01362962f, 0.05282769f, -0.04921757f, -0.04563217f, 0.02918767f, -0.05519710f, 0.04180391f, 
    0.03709827f, -0.01843248f, 0.06178283f, -0.04457559f, -0.00349125f, -0.06490066f, 0.00563548f, 0.05668878f, 
    0.04232652f, -0.09104510f, 0.05429501f, -0.15778784f, 0.14288260f, -0.09422874f, -0.03026753f, 0.04900564f, 
    0.05632701f, -0.09007465f, -0.02386736f, -0.11197883f, 0.12790166f, 0.12256059f, -0.02475444f, 0.23568559f, 
    -0.02632890f, 0.00576718f, -0.00634247f, -0.13468111f, 0.04823017f, -0.06468591f, 0.05610709f, -0.03837385f, 
    -0.01436665f, -0.13021339f, -0.01853090f, -0.21328762f, 0.14352982f, -0.04123049f, -0.08946529f, -0.08837102f, 
    0.03391128f, -0.05545654f, 0.02802633f, -0.00095128f, 0.04739126f, -0.03330874f, -0.04857291f, -0.13411528f, 
    -0.08141123f, -0.10877433f, 0.01257993f, 0.06447682f, 0.13434769f, 0.06039952f, 0.00720718f, -0.01312231f, 
    -0.17087702f, 0.21105951f, -0.27174789f, -0.00062014f, 0.03908699f, 0.09334612f, -0.02563498f, 0.07285547f, 
    0.00770544f, 0.07843590f, -0.10491543f, -0.03247551f, -0.08439542f, 0.09207073f, 0.11281400f, -0.03121497f, 
    0.17512648f, -0.05016143f, -0.11946413f, 0.04922453f, -0.09619292f, 0.04348147f, -0.04128347f, 0.08787219f, 
    0.15741554f, 0.05971367f, -0.04418461f, -0.10866697f, 0.04011221f, -0.00864591f, 0.04852511f, 0.03452165f, 
    0.10323297f, -0.05857007f, -0.03755805f, 0.02903123f, 0.12177505f, 0.03083868f, 0.02029599f, 0.35163096f, 
    0.10040592f, -0.05268551f, 0.06122044f, -0.00262706f, 0.08569691f, 0.27526286f, 0.04450785f, 0.08061311f, 
    -0.08733552f, -0.04561201f, -0.18481457f, -0.09964171f, 0.05392883f, 0.00412807f, -0.04842809f, 0.05089761f, 
    0.08874942f, 0.01759259f, 0.07186247f, -0.01780061f, -0.11597320f, 0.10878552f, -0.06830224f, 0.10461752f, 
    -0.04329793f, -0.01989801f, -0.08483775f, 0.17828520f, -0.03043956f, 0.11378479f, 0.12872900f, 0.06326500f, 
    0.09056929f, -0.22893836f, -0.08924941f, 0.08695878f, 0.19880624f, 0.06948221f, 0.11600089f, -0.06262838f, 
    0.11396789f, 0.00900355f, 0.08547067f, 0.14155637f, 0.13031968f, 0.14773481f, 0.03841978f, 0.32496390f, 
    -0.17475379f, -0.09869974f, 0.06678583f, 0.00053168f, 0.03568381f, 0.00621474f, -0.04878082f, -0.01554335f, 
    0.03590307f, -0.00734013f, -0.20802571f, 0.34836048f, 0.15832390f, 0.02757243f, -0.00918450f, -0.03890073f, 
    0.08079407f, 0.06586944f, -0.01041787f, 0.04195113f, -0.28549096f, 0.04244298f, -0.05451688f, -0.00760660f, 
    -0.14676599f, -0.12098944f, -0.04368005f, 0.12319987f, -0.01285492f, 0.05100551f, 0.03784901f, -0.11792771f, 
    -0.09561699f, -0.10434651f, 0.12731501f, 0.10678982f, 0.13426335f, 0.09200065f, 0.05165613f, -0.12187190f, 
    0.04251780f, -0.08420783f, 0.14280279f, 0.00632622f, -0.02559650f, -0.01121970f, 0.01846363f, 0.11651596f, 
    0.04555196f, 0.03999189f, 0.02212200f, -0.02222857f, 0.02524619f, 0.05916826f, 0.01049157f, -0.07938496f, 
    0.14048088f, 0.03219108f, 0.25273895f, 0.18900061f, -0.03986488f, 0.09496192f, -0.07890918f, 0.00850296f, 
    -0.01703116f, 0.03509912f, 0.00989946f, 0.07951934f, -0.45974657f, -0.03811547f, -0.15413444f, 0.02565899f, 
    -0.00002730f, 0.17924334f, -0.11017397f, -0.11428649f, -0.01226324f, 0.04341618f, 0.08225901f, 0.00026112f, 
    -0.13285249f, 0.06222888f, 0.09402230f, -0.02144733f, 0.10103896f, -0.05497847f, -0.00168274f, 0.11746195f, 
    -0.07697516f, -0.09746812f, 0.08569971f, 0.07519640f, -0.02563341f, -0.02595806f, -0.08612788f, 0.07497025f, 
    0.13218114f, 0.19583312f, -0.07751445f, -0.03961980f, -0.03123175f, 0.12401429f, -0.13324150f, -0.08463462f, 
    -0.15073872f, 0.15083508f, -0.12725630f, 0.06132454f, 0.00611499f, -0.16473992f, 0.14857231f, -0.09199896f, 
    -0.03924279f, 0.00835780f, -0.07531838f, -0.11517323f, -0.14076963f, 0.02494507f, 0.16679814f, -0.06121520f, 
    0.08332141f, 0.03715558f, 0.03354143f, 0.02698350f, -0.00418417f, 0.14458705f, -0.06960857f, 0.00783266f, 
    0.15486723f, -0.06831201f, 0.12256417f, 0.07790669f, 0.03505773f, 0.02048596f, -0.00410636f, -0.01918851f, 
    -0.02681398f, 0.03110803f, 0.01269063f, -0.03157948f, -0.10593799f, -0.09661873f, 0.15967335f, 0.08786579f, 
    -0.01519403f, -0.07941359f, 0.10822828f, -0.10962312f, -0.05772981f, -0.00316846f, 0.08706563f, 0.11356562f, 
    0.20760144f, 0.28388733f, 0.16051318f, 0.08216967f, -0.09437571f, 0.05283681f, 0.06159457f, 0.04091034f, 
    0.17446107f, 0.00335055f, 0.18755201f, -0.07125692f, -0.05306472f, 0.04627535f, 0.15090632f, -0.10472047f, 
    -0.07877088f, -0.03587363f, 0.08536762f, -0.04374121f, 0.02750542f, 0.01330392f, 0.01521882f, -0.10584175f, 
    -0.07379573f, 0.10848276f, 0.17545332f, 0.02959752f, -0.15407875f, 0.01906238f, -0.03008955f, -0.02345727f, 
    0.13379581f, -0.03713470f, -0.05618279f, 0.01379574f, -0.35604936f, -0.02932845f, -0.09018595f, -0.06511134f, 
    0.13548529f, 0.10346226f, 0.09548254f, 0.04737095f, -0.04648711f, -0.08567613f, 0.03548307f, 0.08716375f, 
    -0.10521498f, 0.11127517f, -0.06204915f, 0.11338007f, -0.01017507f, -0.04666519f, -0.00728309f, 0.01165337f, 
    0.00988447f, -0.02353748f, 0.10637359f, -0.04126395f, -0.41804281f, -0.00007403f, -0.32268792f, -0.09443361f, 
    -0.06644532f, 0.19097185f, 0.06165937f, -0.11809035f, -0.09509875f, -0.05260362f, -0.09455539f, 0.10637292f, 
    0.26133859f, 0.14238231f, 0.30657208f, 0.14627059f, -0.07776748f, 0.02143139f, -0.01367452f, 0.00864779f, 
    0.09861309f, -0.09375958f, 0.08961614f, 0.10605410f, -0.05407088f, -0.34188491f, -0.30259222f, 0.21787059f, 
    -0.02833395f, 0.06529620f, 0.13988057f, 0.05400787f, -0.02174606f, -0.10627463f, 0.03570709f, -0.09070117f, 
    0.02856380f, 0.08530460f, -0.04130801f, 0.11609142f, -0.06324013f, 0.02455905f, -0.01160089f, -0.17285965f, 
    -0.01464324f, 0.08915446f, 0.00820031f, 0.11218960f, 0.04930244f, -0.02743731f, -0.00878223f, -0.18769847f, 
    0.19228961f, 0.09949774f, -0.02966181f, 0.05749911f, 0.02478162f, 0.04907453f, -0.00672620f, 0.00312191f, 
    0.09150197f, 0.07642854f, 0.00866051f, 0.26940009f, -0.07261394f, -0.06991561f, -0.01650693f, 0.04023015f, 
    -0.03692330f, 0.05879629f, 0.08869955f, -0.06372380f, 0.34364665f, 0.14442948f, -0.14568222f, 0.16442928f, 
    -0.07519105f, 0.00866240f, -0.00166482f, 0.04504735f, 0.00938392f, 0.09796467f, -0.06352350f, -0.01929699f, 
    -0.29785559f, -0.18149987f, 0.25993168f, 0.03324331f, -0.05226752f, -0.03996618f, 0.04677031f, -0.04467088f, 
    0.14647956f, 0.02134763f, 0.12847613f, 0.03711075f, -0.06035903f, 0.00419907f, 0.02715909f, 0.10744686f, 
    -0.06138100f, -0.00841678f, 0.11507000f, 0.02137761f, -0.03830196f, -0.02168407f, 0.16557918f, 0.06343350f, 
    -0.04612086f, -0.16197421f, 0.20732479f, -0.01782890f, -0.09570207f, 0.05049612f, -0.03634286f, 0.09570348f, 
    -0.06110695f, -0.15027425f, 0.03591888f, -0.04297062f, -0.01246789f, -0.08342796f, -0.03788571f, -0.24765746f, 
    -0.06020684f, -0.00911934f, 0.02547399f, 0.03189332f, -0.02538864f, 0.04428357f, -0.03873838f, -0.12129362f, 
    0.06427153f, -0.02174071f, 0.15543318f, 0.21556170f, 0.03143327f, 0.02812519f, -0.08810437f, -0.09001938f, 
    -0.12906240f, -0.05819087f, 0.08176029f, 0.00125939f, 0.12053497f, -0.00013957f, 0.02589163f, -0.10507035f, 
    0.13433141f, 0.09767131f, -0.06416138f, -0.09877265f, 0.08014630f, 0.04088907f, -0.16161874f, -0.02863054f, 
    -0.01626172f, 0.11253970f, 0.05704166f, 0.01650012f, 0.02906000f, 0.02549822f, 0.01477936f, -0.02221881f, 
    -0.13235492f, -0.01225243f, 0.00469340f, -0.14010833f, 0.22980627f, -0.04831600f, 0.04413029f, -0.24874984f, 
    0.09274466f, 0.11304171f, 0.09541698f, 0.06959974f, 0.11669549f, 0.03874538f, 0.02972701f, -0.11390688f, 
    -0.17403562f, 0.07556490f, 0.08230444f, -0.09022955f, -0.11570859f, 0.02052723f, -0.15145507f, -0.03628219f, 
    -0.08827150f, -0.01083718f, -0.07348827f, -0.15488555f, 0.45508078f, -0.01812386f, 0.00602808f, 0.09120582f, 
    0.01445862f, 0.00471035f, -0.06156914f, -0.00423701f, 0.13807350f, 0.01078555f, 0.13019405f, 0.02312191f, 
    0.01713813f, -0.09940086f, -0.22007684f, 0.04543473f, -0.01300478f, 0.02764055f, 0.04761487f, 0.08119950f, 
    0.02111688f, -0.06118826f, 0.06515174f, -0.07962433f, 0.24562374f, 0.35282174f, 0.07774968f, -0.32758719f, 
    -0.05962300f, 0.06014040f, -0.08376125f, 0.14152510f, -0.06075589f, 0.09378427f, -0.00299581f, -0.07923797f, 
    -0.18355037f, 0.04190920f, -0.02401629f, 0.15041377f, -0.10115337f, 0.06813592f, 0.05862123f, -0.01776116f, 
    -0.03321406f, -0.02583448f, 0.10356977f, 0.14031573f, -0.10811392f, 0.02975456f, -0.18237212f, -0.14912586f, 
    0.03311145f, -0.08584040f, 0.03171966f, -0.00396215f, 0.07398323f, 0.05848569f, 0.05691921f, 0.01671365f, 
    -0.17657845f, 0.24017718f, 0.09736791f, 0.14345868f, -0.01455891f, 0.10650142f, 0.00759917f, 0.14672799f, 
    -0.02217942f, -0.03679535f, -0.02113025f, 0.07429930f, 0.08913207f, -0.19233902f, -0.00579168f, 0.04015969f, 
    0.18812199f, 0.09156279f, -0.09548537f, 0.11402305f, -0.02415380f, 0.05689513f, -0.05634839f, 0.03171261f, 
    -0.19414285f, 0.01359238f, 0.05702437f, -0.06813779f, -0.17231601f, -0.01868148f, 0.13277520f, -0.05089165f, 
    -0.05684204f, 0.06978956f, -0.02406516f, 0.01482571f, -0.10427675f, 0.17407343f, 0.22343095f, 0.05104823f, 
    0.05966810f, -0.03527453f, 0.00139688f, 0.08149859f, 0.00972129f, -0.00817088f, 0.02107557f, -0.03431616f, 
    0.04828367f, 0.02843998f, 0.15620443f, 0.32908171f, 0.18641938f, 0.02270241f, -0.04649696f, -0.02709401f, 
    -0.08717257f, 0.04964545f, 0.02808184f, -0.03613945f, 0.16476148f, -0.07360424f, 0.31297019f, -0.01064304f, 
    -0.03737503f, 0.11643986f, 0.02983103f, -0.05064869f, 0.02924642f, -0.07473158f, -0.00704100f, 0.14484893f, 
    0.03673773f, 0.23735064f, 0.01034711f, -0.01357645f, -0.02705063f, -0.06470259f, 0.05069610f, -0.01695812f, 
    0.07595902f, 0.00314291f, 0.18952040f, 0.06402285f, -0.30850610f, 0.01649490f, 0.06364466f, 0.01692728f, 
    -0.01104601f, 0.04183020f, 0.03875724f, 0.05315987f, 0.10423192f, 0.07401899f, 0.02960642f, -0.00444835f, 
    -0.03839814f, -0.12933418f, 0.10525271f, -0.03420777f, -0.18312180f, -0.01874655f, 0.07434797f, 0.12396997f, 
    0.14148535f, 0.07716181f, -0.01628951f, 0.00465636f, -0.21728772f, -0.13227101f, -0.03129514f, -0.26496831f, 
    0.09003165f, 0.01658493f, -0.00468160f, -0.07636603f, -0.00367255f, 0.01073587f, 0.02820961f, 0.03047518f, 
    -0.05486880f, 0.14396520f, 0.07899434f, -0.19514053f, -0.13774499f, 0.08918472f, -0.01520559f, 0.08003712f, 
    0.06335072f, -0.03162570f, -0.04044723f, -0.02300547f, 0.08609489f, -0.09166960f, -0.05443780f, -0.11648881f, 
    -0.03638825f, 0.11810727f, 0.02163784f, -0.07754816f, 0.05562276f, 0.06745470f, -0.09695369f, 0.21966155f, 
    0.19744341f, 0.09270037f, 0.21253905f, 0.03613044f, -0.09214167f, -0.03388011f, 0.02589464f, 0.06509808f, 
    -0.04548405f, -0.08954680f, 0.07949274f, 0.09971678f, -0.01688307f, -0.28694123f, 0.02201000f, 0.02123665f, 
    -0.00539530f, 0.07854424f, 0.16697450f, 0.09321321f, -0.03280526f, -0.11867328f, -0.08349364f, -0.05717129f, 
    -0.11162661f, -0.04000008f, -0.23675294f, -0.11345822f, 0.03561666f, -0.19713897f, -0.03427746f, 0.01624524f, 
    0.19558884f, -0.04685086f, 0.12605724f, 0.05705920f, 0.08213655f, -0.08141186f, 0.14339212f, -0.01817022f, 
    0.02789365f, -0.02293917f, 0.13844751f, 0.16223435f, 0.01384129f, -0.01287490f, 0.10768395f, -0.07970621f, 
    0.00431314f, 0.14731362f, -0.02113647f, 0.04257973f, 0.14829171f, 0.10883581f, -0.07151716f, -0.16237105f, 
    0.02647647f, 0.19043453f, 0.11645290f, -0.03585351f, -0.12764774f, 0.13083945f, -0.01122004f, 0.00351396f, 
    0.04277713f, -0.13369009f, 0.06956447f, 0.12546803f, 0.06821302f, 0.03816056f, 0.09701979f, -0.01985065f, 
    0.33992279f, 0.07174558f, -0.03256520f, -0.09708239f, 0.13046739f, -0.01504757f, -0.16881269f, 0.05263327f, 
    0.09539408f, -0.12463611f, 0.08780551f, 0.09687860f, 0.15973461f, 0.11676732f, -0.04438303f, 0.00544271f, 
    0.05754273f, 0.01045022f, 0.14025605f, 0.14938383f, -0.11015390f, 0.02808286f, 0.05585437f, -0.04564905f, 
    -0.09355246f, 0.18329544f, -0.05061602f, 0.06249709f, 0.07792974f, 0.07138739f, 0.09886453f, 0.01366775f, 
    -0.14186949f, -0.11845782f, 0.12552603f, 0.00782914f, 0.19644612f, 0.09841775f, -0.12699473f, 0.03056361f, 
    0.08844185f, 0.11585676f, 0.06065808f, 0.11286910f, 0.00920947f, -0.06381937f, -0.07367723f, 0.03433703f, 
    -0.28688008f, -0.02898600f, -0.15756874f, -0.12212392f, 0.12007183f, -0.16340627f, -0.15351363f, -0.15418215f, 
    -0.13241050f, -0.00756704f, 0.01031597f, 0.14891249f, 0.06083241f, -0.07063612f, 0.01394688f, 0.02578490f, 
    0.07072564f, 0.00428844f, -0.06604595f, 0.01675122f, 0.03008690f, 0.02131183f, -0.12656115f, 0.05983016f, 
    -0.06319151f, 0.12754638f, -0.03992553f, 0.01887246f, 0.23254023f, 0.12655935f, 0.00591247f, -0.05402693f, 
    -0.10024697f, -0.14550914f, 0.09439055f, -0.08768290f, -0.07060637f, -0.06714364f, -0.02550083f, -0.03811483f, 
    -0.16199888f, -0.02886235f, -0.05115661f, 0.00502770f, -0.16904375f, -0.04727065f, 0.01574373f, -0.08075316f, 
    -0.00101041f, -0.04183449f, -0.15106176f, 0.06315468f, 0.10040757f, -0.00495885f, -0.26280963f, -0.00871016f, 
    0.13928956f, 0.00646011f, 0.08739192f, 0.00503751f, 0.34058574f, -0.00218526f, 0.32868829f, -0.05431795f, 
    0.10600223f, -0.09141282f, 0.02142435f, 0.20573218f, 0.00662678f, 0.02661605f, 0.06358396f, 0.02743072f, 
    -0.33182740f, -0.03503212f, -0.16103394f, 0.12346238f, 0.23908600f, 0.03185758f, 0.02674683f, -0.03286347f, 
    -0.19398692f, 0.11281496f, 0.11029451f, -0.00815076f, -0.18147980f, 0.27014977f, 0.16669804f, 0.05135550f, 
    -0.01689925f, 0.04538373f, 0.00063521f, -0.03800185f, -0.01841228f, 0.12300681f, 0.09871294f, 0.23409168f, 
    -0.01441422f, 0.02511845f, -0.07676536f, -0.03690211f, -0.01546908f, -0.00218092f, -0.00378375f, -0.03238824f, 
    -0.04594342f, -0.08774514f, 0.02598240f, -0.00225746f, 0.03963874f, 0.00871385f, -0.02515709f, 0.04853488f, 
    0.02836806f, 0.07218607f, 0.04814564f, 0.05405570f, 0.06703407f, 0.03642676f, -0.03826991f, -0.01396063f, 
    -0.03327834f, -0.00803818f, 0.01740880f, 0.06302375f, 0.04977309f, -0.07238176f, 0.01462288f, -0.03029714f, 
    0.06561953f, -0.06297887f, -0.02648861f, 0.00038742f, -0.04087479f, 0.06259627f, -0.03294355f, -0.02823160f, 
    -0.00344072f, 0.05881709f, -0.04485086f, 0.01485402f, -0.03627433f, -0.07566600f, 0.01068847f, -0.05424377f, 
    -0.06382014f, 0.00707711f, 0.00785253f, -0.07724071f, -0.00350110f, 0.04911549f, 0.02194553f, -0.05310749f, 
    -0.04312838f, 0.00174942f, 0.03989204f, 0.03931447f, -0.08818363f, -0.01795329f, -0.04274744f, 0.01397090f, 
    -0.01227786f, 0.03504765f, -0.06171525f, 0.00818366f, -0.07127980f, -0.04185125f, 0.00036781f, -0.06297898f, 
    -0.07479292f, -0.08282991f, -0.03945173f, -0.00892443f, -0.04088438f, -0.06765719f, 0.01942638f, -0.02200660f, 
    -0.03431830f, 0.05543822f, 0.03209404f, -0.05793565f, -0.05759672f, -0.00461528f, 0.05410920f, 0.02686746f, 
    0.00030675f, 0.05563985f, 0.00037032f, -0.05682782f, 0.06157228f, 0.04472258f, 0.01778068f, 0.04848674f, 
    0.04281971f, -0.03713764f, -0.06856154f, 0.03079503f, 0.06427997f, -0.04063012f, -0.05874472f, 0.06078164f, 
    -0.04266231f, -0.00731792f, -0.06694777f, -0.02786772f, -0.01081746f, -0.05541233f, -0.02261093f, -0.00800153f, 
    -0.00232268f, -0.03111369f, -0.05607695f, -0.03898083f, 0.03811898f, 0.02219463f, 0.01716888f, -0.00915352f, 
    0.02006129f, -0.07450988f, -0.06915807f, -0.01676278f, -0.06476077f, -0.06583104f, -0.00995823f, -0.06499382f, 
    -0.05217371f, -0.02163718f, -0.02431307f, -0.04831405f, -0.06647368f, 0.02883083f, -0.04781359f, 0.01401103f, 
    -0.02686719f, 0.04383688f, -0.04169630f, -0.00262155f, 0.04873950f, -0.05787306f, -0.06262151f, 0.01687013f, 
    -0.02132298f, 0.00759765f, 0.02323813f, 0.05276186f, 0.04565546f, -0.07834247f, -0.03342633f, -0.04972698f, 
    -0.05720398f, -0.02462627f, 0.02825969f, 0.00062647f, -0.04276077f, -0.01215930f, 0.00361778f, -0.06662530f, 
    0.03629383f, -0.03968879f, 0.03179541f, 0.04674213f, 0.04980855f, 0.03549342f, -0.02595530f, 0.05677032f, 
    0.02393915f, -0.06961673f, -0.01872789f, -0.01397280f, -0.02941896f, -0.07296546f, 0.04757586f, -0.02911425f, 
    0.02666860f, -0.04772754f, -0.07120088f, 0.00526148f, -0.06453168f, 0.04657536f, -0.01301231f, 0.02006958f, 
    -0.02526970f, -0.04311126f, 0.03342487f, -0.00368818f, 0.03777309f, 0.01585154f, 0.03868439f, -0.04632999f, 
    0.03792077f, 0.05986506f, -0.01360027f, 0.01161907f, -0.03038640f, -0.06487582f, -0.00268556f, -0.05074875f, 
    -0.06850268f, -0.05036031f, -0.04694988f, 0.00290155f, -0.01881708f, 0.04823301f, 0.01331763f, 0.06522910f, 
    -0.02979308f, 0.01681954f, -0.03093556f, -0.01567924f, 0.04554278f, -0.02957371f, -0.06842437f, 0.06455048f, 
    -0.05688433f, -0.07524782f, -0.01643906f, -0.04603518f, 0.00039797f, 0.05760659f, 0.04959640f, 0.03616321f, 
    -0.06273585f, 0.02844636f, 0.05986551f, 0.02760618f, -0.02521071f, 0.06219669f, 0.00514582f, -0.00947972f, 
    -0.06865679f, -0.03955521f, 0.02862079f, -0.02196011f, 0.01680161f, -0.05130741f, -0.05399134f, -0.03448971f, 
    -0.00260023f, -0.07253815f, -0.02073874f, -0.05479899f, 0.00527953f, -0.00073307f, 0.06586726f, 0.03914304f, 
    -0.06683926f, 0.03349873f, -0.05975676f, 0.01417939f, 0.04716745f, 0.03840905f, -0.04227646f, -0.05481703f, 
    0.04646999f, -0.02768869f, 0.00871297f, -0.00651943f, 0.02188263f, -0.01329596f, -0.04978670f, 0.01133436f, 
    -0.06824373f, 0.05650530f, -0.04935156f, 0.06154615f, -0.06568902f, 0.03589284f, -0.05834159f, -0.04599391f, 
    -0.02092704f, -0.01656742f, -0.07550374f, -0.03975404f, 0.00495951f, -0.04278905f, -0.04100462f, 0.04476204f, 
    0.01399052f, -0.05947573f, -0.02115006f, -0.04615084f, 0.04625960f, 0.01921529f, -0.01891281f, 0.04016509f, 
    -0.00942992f, -0.00168316f, -0.03473431f, -0.00425265f, 0.04614880f, -0.01585606f, 0.01733870f, -0.03716726f, 
    -0.02682459f, 0.03377543f, 0.07044655f, -0.04979374f, -0.03596358f, 0.03357277f, 0.02938499f, -0.04251646f, 
    -0.00978495f, -0.06742605f, -0.04991455f, -0.06043452f, -0.06703919f, -0.06229948f, 0.04848431f, -0.01683859f, 
    0.05615070f, 0.03226615f, -0.04923285f, -0.01359839f, -0.02429544f, 0.02318615f, -0.02346232f, -0.07566242f, 
    0.01058996f, -0.03882089f, -0.02133385f, -0.06836034f, -0.07679215f, 0.04212617f, 0.04931530f, 0.01155724f, 
    0.04278836f, -0.01702843f, -0.02160111f, 0.04506404f, 0.03523384f, 0.02124435f, -0.05050193f, 0.04334495f, 
    -0.07707323f, 0.00779483f, -0.02153094f, 0.01351018f, -0.02345091f, -0.00632297f, -0.03045061f, -0.04423629f, 
    0.03939368f, -0.03893699f, -0.00321740f, 0.00596240f, -0.05466861f, -0.07368335f, 0.04883732f, -0.01928663f, 
    0.03071496f, 0.00731893f, -0.03156775f, -0.06657305f, 0.06600803f, -0.03933727f, 0.03405952f, -0.06119151f, 
    -0.03439615f, 0.00372849f, -0.00332265f, 0.02049346f, 0.05564096f, -0.00014387f, 0.04266839f, 0.06370783f, 
    -0.05978863f, 0.04623344f, -0.01349604f, -0.01464096f, -0.02279591f, -0.06631065f, -0.03584462f, 0.00435804f, 
    0.02163787f, 0.02321507f, -0.00659242f, -0.03229169f, -0.06388863f, -0.06628269f, -0.05606532f, -0.03606532f, 
    -0.06009164f, 0.04425800f, 0.03957371f, 0.01529898f, -0.03208897f, 0.06501978f, -0.00577036f, 0.03776182f, 
    0.00727511f, -0.01337292f, 0.00091080f, -0.05835727f, 0.03595485f, -0.06791831f, 0.02966095f, -0.04996213f, 
    -0.01912671f, -0.00945349f, 0.00897452f, -0.04103785f, -0.06543206f, -0.06657632f, 0.04487487f, 0.02231454f, 
    -0.01326946f, -0.05136605f, 0.03402044f, -0.01558100f, 0.06111110f, -0.04349689f, -0.04573872f, -0.05590657f, 
    -0.06967391f, -0.06906093f, 0.00114447f, -0.04013566f, -0.06163858f, -0.05528233f, 0.03280699f, -0.00805445f, 
    -0.07141203f, 0.06844637f, -0.01999579f, 0.00288157f, 0.02755633f, 0.00185421f, -0.02352281f, -0.06748834f, 
    -0.03841376f, -0.00175601f, 0.03789988f, 0.05356857f, 0.01962320f, -0.06559056f, 0.02868724f, 0.01576615f, 
    -0.06821156f, -0.06369475f, -0.03663929f, -0.02357282f, 0.02890294f, -0.04025988f, 0.00673652f, 0.01200158f, 
    -0.06223519f, -0.02997119f, 0.05017058f, 0.01414942f, 0.02472984f, -0.01141989f, -0.00004148f, -0.06874225f, 
    0.06154057f, -0.03096875f, 0.04569393f, -0.03042939f, 0.07216410f, 0.06353837f, -0.07122114f, 0.05267216f, 
    -0.06157830f, 0.05609854f, -0.04300955f, -0.07023453f, 0.03866167f, -0.02783868f, -0.05546951f, 0.04676054f, 
    0.05919358f, -0.06037776f, -0.03164814f, -0.03959085f, -0.06279051f, 0.02092014f, 0.07103340f, -0.02594602f, 
    0.03798362f, -0.04399494f, -0.03360432f, 0.07102536f, -0.03857897f, -0.00047607f, 0.03587461f, -0.02645164f, 
    -0.01807647f, -0.00053095f, -0.07176759f, 0.00001922f, 0.03469861f, 0.06259195f, -0.05209342f, -0.05518777f, 
    0.01450178f, 0.05508513f, 0.01285643f, -0.06949910f, 0.01638927f, -0.00468520f, -0.00160594f, 0.06886816f, 
    -0.00019378f, -0.06180117f, -0.02250156f, -0.02656623f, -0.04616212f, -0.05880206f, 0.05833201f, -0.06083814f, 
    0.06925742f, -0.01376240f, -0.05757723f, 0.03040376f, 0.06687211f, 0.01787713f, -0.04761175f, -0.03592733f, 
    -0.03998000f, -0.02400895f, -0.03645178f, 0.04699516f, 0.02805791f, 0.03867613f, -0.02645501f, -0.05132578f, 
    -0.05155380f, 0.04269365f, -0.04267307f, -0.06829265f, 0.04400131f, -0.05821642f, -0.00709778f, 0.01097725f, 
    -0.02049359f, 0.06527721f, -0.02978117f, -0.05799063f, 0.03364128f, -0.01373280f, -0.00622639f, -0.03972061f, 
    0.03720013f, 0.06262380f, -0.03921359f, -0.02319885f, 0.03057269f, 0.03493957f, -0.02363120f, 0.00996013f, 
    -0.06672144f, 0.06368062f, -0.04757876f, -0.00747593f, 0.03496581f, -0.05312443f, -0.06692815f, 0.05011244f, 
    0.05534161f, 0.06417564f, -0.04596069f, -0.05630594f, -0.04924888f, -0.07029606f, -0.03259820f, -0.06638093f, 
    0.06606075f, -0.05205480f, 0.04804453f, -0.03887800f, -0.04070069f, -0.02629589f, -0.05543800f, -0.01918398f, 
    -0.20263267f, -0.01754565f, -0.04863936f, -0.06812939f, -0.14115588f, -0.06578162f, -0.03181738f, -0.03255159f, 
    0.09336436f, 0.00818188f, 0.02281550f, 0.03344217f, -0.13210888f, 0.00265112f, 0.04117428f, -0.06108416f, 
    -0.15104894f, -0.02417981f, -0.00170903f, 0.03813272f, 0.14475407f, 0.09746845f, 0.02250576f, -0.01417282f, 
    -0.01289390f, 0.07610752f, 0.17837349f, 0.14082007f, 0.08103731f, 0.11486254f, 0.18509826f, 0.02771521f, 
    -0.00498514f, -0.04732450f, 0.01896145f, -0.02147923f, -0.14260095f, 0.11779761f, 0.03987386f, 0.13438630f, 
    -0.06316101f, -0.01909430f, -0.09224267f, 0.14027727f, -0.02621371f, -0.03260587f, 0.12097120f, 0.05831860f, 
    0.39889640f, 0.15595824f, 0.08393795f, -0.03422820f, -0.10675728f, -0.04188583f, -0.07178374f, -0.03416120f, 
    -0.03817069f, -0.02310321f, -0.02509753f, 0.04416270f, 0.39532909f, 0.04160965f, 0.21311098f, 0.01265786f, 
    -0.04538694f, 0.03009162f, 0.06766580f, -0.01215276f, 0.03122752f, 0.12583283f, 0.02056439f, 0.03905939f, 
    0.13948369f, 0.14989619f, 0.16220246f, 0.02236084f, -0.02000695f, 0.09754288f, -0.04082604f, -0.10048887f, 
    -0.02519702f, 0.02363248f, 0.03009658f, -0.00804477f, 0.04160000f, 0.08434895f, 0.19236916f, -0.19219494f, 
    -0.01810900f, 0.12719333f, -0.00562207f, -0.01234722f, 0.06090720f, -0.19510865f, 0.01324680f, 0.15872473f, 
    -0.34379265f, -0.01267303f, 0.03665340f, -0.12542194f, 0.06222812f, -0.01117128f, -0.00462700f, 0.06041960f, 
    0.09054980f, 0.03923715f, 0.09131747f, -0.01451756f, 0.17831020f, -0.14821185f, -0.01391848f, 0.17799039f, 
    0.08995342f, -0.09827725f, 0.13093159f, 0.05800398f, -0.02328867f, 0.05970405f, -0.03867758f, -0.06139087f, 
    -0.33510065f, 0.24974281f, -0.15521364f, -0.11271991f, 0.00613011f, 0.03500936f, 0.06019297f, 0.02566412f, 
    0.01041948f, -0.05895746f, -0.00508520f, 0.01721557f, 0.09713268f, -0.25461867f, 0.03639798f, -0.06568801f, 
    -0.05722671f, -0.00025955f, 0.04343051f, 0.04864650f, -0.13328114f, -0.00299862f, -0.04615590f, -0.01967982f, 
    -0.05747166f, 0.16890782f, -0.01778179f, -0.12361765f, 0.09795541f, -0.09476075f, -0.05093404f, 0.03648148f, 
    0.04959303f, -0.06109733f, 0.07174353f, 0.07364393f, 0.37475726f, 0.02655853f, 0.02415904f, 0.07192614f, 
    -0.06757812f, 0.05696355f, 0.02260042f, -0.00643556f, 0.08058505f, 0.12255647f, -0.14582808f, 0.09146169f, 
    -0.38020650f, -0.10451234f, 0.09453437f, 0.01787229f, 0.09074055f, -0.04192530f, -0.04166258f, 0.11282340f, 
    -0.06894992f, -0.04485441f, 0.02882083f, 0.07776400f, -0.28402850f, -0.23096965f, 0.12356990f, 0.18417928f, 
    -0.06235352f, 0.11639936f, -0.01043643f, 0.03097528f, 0.02161430f, 0.01831443f, 0.05514709f, 0.04001533f, 
    0.02823805f, -0.00033567f, -0.05960049f, 0.03877075f, -0.06797946f, -0.06662786f, -0.00958552f, -0.05102495f, 
    -0.02668832f, -0.06743511f, 0.04214863f, 0.00382726f, 0.04258076f, -0.05481124f, -0.01766740f, 0.02128665f, 
    0.00873819f, -0.00554100f, -0.02340379f, -0.06161601f, -0.03851085f, 0.02266108f, 0.04022456f, -0.06381774f, 
    -0.04800528f, -0.03178884f, -0.05352981f, -0.07276454f, 0.02668099f, 0.06272690f, -0.07671010f, -0.03581552f, 
    -0.03327063f, 0.01280962f, 0.03704010f, -0.04472412f, 0.00774209f, -0.03789003f, 0.03769938f, 0.02345600f, 
    -0.06367078f, -0.05511704f, 0.01741766f, -0.06369809f, 0.03522890f, -0.05574282f, -0.02807328f, -0.04558853f, 
    0.01332327f, -0.03331944f, 0.05268348f, -0.00920433f, 0.01829628f, -0.05479855f, 0.01151688f, -0.04076207f, 
    -0.03052586f, -0.03192860f, 0.04069864f, 0.05770404f, 0.01248918f, -0.07491884f, 0.02724543f, -0.03175911f, 
    0.03641585f, -0.06019280f, -0.07421201f, 0.04778095f, 0.00523858f, -0.06440344f, -0.07118513f, -0.05567187f, 
    -0.06044868f, 0.04343631f, -0.04087767f, 0.00255122f, 0.04239013f, -0.02931328f, -0.06391836f, 0.01683467f, 
    -0.04684439f, -0.06489796f, 0.01768579f, -0.03480521f, 0.04732914f, -0.03125308f, 0.02987265f, -0.05748005f, 
    -0.00611810f, 0.05645946f, 0.02065863f, 0.06451301f, -0.03762629f, 0.03437117f, -0.06748026f, -0.06777510f, 
    -0.07188873f, -0.01534962f, -0.06149074f, -0.02240208f, 0.04106663f, -0.07382139f, 0.00579478f, 0.00160603f, 
    0.00104831f, -0.03504036f, 0.01086906f, -0.00355149f, 0.01248312f, 0.06183891f, 0.03743198f, 0.03311579f, 
    0.00141808f, -0.04033915f, -0.06248040f, -0.02831418f, 0.06120971f, -0.02514543f, -0.02483294f, -0.02862517f, 
    -0.02778111f, -0.06559300f, 0.02361515f, -0.03720082f, 0.00647721f, 0.02416269f, -0.01748521f, 0.00199542f, 
    0.00114170f, -0.05492232f, 0.00801757f, 0.03750231f, 0.01606617f, 0.03836329f, 0.01436308f, 0.01993539f, 
    -0.07544179f, -0.05928177f, 0.05227239f, 0.03991891f, -0.02358632f, -0.04837263f, -0.02942107f, 0.00240142f, 
    -0.03319831f, 0.02566349f, -0.01773476f, -0.03491078f, -0.02905213f, 0.01713489f, -0.02161253f, 0.06027026f, 
    0.02025867f, 0.02650807f, -0.00537993f, -0.01397563f, -0.02376489f, 0.03043939f, -0.03729897f, -0.02556060f, 
    -0.02279472f, 0.03606359f, -0.02528381f, 0.01415661f, 0.00567761f, -0.01525763f, 0.02753711f, 0.02866995f, 
    -0.00798445f, -0.03312575f, 0.06113039f, 0.04103295f, -0.07036269f, 0.06034648f, 0.05137859f, -0.00956515f, 
    -0.03218406f, -0.04813635f, 0.01450727f, -0.01602647f, -0.03099363f, 0.05888681f, -0.04228779f, 0.01543330f, 
    0.00247541f, 0.02332656f, -0.04189620f, -0.07075441f, 0.05502918f, -0.03739648f, -0.01084036f, 0.05194809f, 
    0.00749538f, 0.03106783f, 0.03947950f, -0.07169460f, -0.00244153f, 0.05922622f, 0.04734770f, -0.02016193f, 
    -0.06360264f, 0.00337012f, 0.03548703f, -0.01665057f, -0.00312750f, -0.04829842f, 0.06403166f, 0.03526166f, 
    0.05940375f, -0.02331670f, 0.01359784f, -0.06017275f, -0.01916700f, 0.00782661f, 0.02057450f, 0.00144951f, 
    -0.02638278f, -0.01679317f, -0.01198430f, -0.00936338f, -0.05575572f, 0.02064788f, 0.04923443f, -0.06038203f, 
    0.01733885f, 0.01336900f, -0.07682217f, -0.05632292f, 0.03514861f, 0.04266529f, 0.00279079f, -0.06896067f, 
    0.05350110f, -0.05434151f, -0.04875522f, 0.03272982f, -0.01730365f, 0.03203887f, -0.01077154f, -0.06842794f, 
    -0.04156854f, 0.01721194f, 0.00983274f, 0.00927743f, -0.02533937f, -0.02800094f, -0.00106507f, -0.00145829f, 
    -0.00143548f, -0.04862224f, -0.07546346f, -0.03755477f, -0.07138214f, 0.05685223f, 0.00548355f, -0.03019998f, 
    -0.05037286f, 0.03566424f, 0.01131538f, -0.05958902f, -0.01068120f, -0.05969898f, 0.03979890f, 0.01404960f, 
    0.01473665f, -0.05244984f, -0.06606656f, 0.04933827f, 0.00734272f, -0.00864268f, -0.06121984f, -0.06265962f, 
    -0.06163365f, 0.01554454f, -0.02749048f, -0.04543148f, -0.06488948f, 0.05790002f, 0.02137285f, -0.02660560f, 
    -0.01066106f, -0.06560133f, -0.01364869f, 0.01451890f, -0.02364276f, 0.00727139f, -0.00104307f, 0.05353976f, 
    0.03177713f, 0.04211953f, 0.01341136f, -0.01371287f, 0.01225901f, -0.01066766f, -0.08038592f, 0.06130959f, 
    0.01187347f, 0.04159579f, 0.05589613f, 0.07399598f, -0.03047152f, -0.07965811f, 0.01997506f, 0.03890993f, 
    -0.01980614f, -0.04332408f, -0.03854928f, -0.07172997f, 0.00757361f, -0.05302737f, -0.00298460f, -0.03534691f, 
    -0.05162772f, -0.07719439f, -0.07172482f, 0.06183437f, 0.05756513f, 0.04995275f, -0.07642782f, -0.04572996f, 
    0.02069050f, 0.01825731f, -0.01416356f, 0.03853137f, 0.01846482f, -0.02640763f, -0.05255705f, -0.06932865f, 
    -0.04397652f, -0.06760860f, 0.00902427f, -0.06461854f, 0.01585001f, -0.02727453f, 0.03321072f, -0.06022357f, 
    0.01781240f, 0.03196433f, 0.05501274f, 0.03842918f, 0.01414856f, -0.06773870f, 0.05634850f, -0.07354061f, 
    -0.07270052f, -0.00950416f, -0.04306958f, 0.00558525f, -0.02160615f, 0.06022912f, -0.04859153f, -0.04708296f, 
    0.03442235f, -0.05514330f, 0.02089374f, 0.05743123f, -0.04036529f, -0.01980036f, 0.03983031f, 0.06081985f, 
    0.03178715f, -0.02707930f, -0.07248291f, -0.04639222f, -0.04246079f, 0.05701419f, 0.06392620f, 0.00051590f, 
    -0.01779800f, 0.03665657f, -0.00452187f, -0.03628612f, 0.01912135f, -0.01682111f, 0.04990364f, 0.04663606f, 
    -0.04595169f, -0.06763218f, -0.01500314f, 0.02476835f, -0.02511336f, -0.06170483f, 0.00866849f, 0.00830106f, 
    0.00853510f, -0.05547814f, -0.05716188f, -0.05785757f, -0.03227912f, -0.05504853f, -0.07310410f, -0.02745466f, 
    -0.07796916f, -0.05054234f, -0.06643045f, -0.06482050f, 0.02412478f, 0.06714115f, 0.02067763f, -0.01488574f, 
    -0.00453578f, 0.02325490f, -0.08096751f, 0.02863694f, -0.03879882f, 0.00280169f, -0.05696626f, 0.02162517f, 
    0.04857014f, 0.05963299f, -0.05089392f, -0.00474154f, -0.03875343f, -0.04290936f, -0.05260196f, -0.01000545f, 
    -0.07163034f, -0.02291121f, -0.06255848f, -0.03518932f, -0.05584211f, 0.05740247f, 0.03355793f, -0.06432013f, 
    -0.02685318f, -0.02762283f, 0.02791477f, -0.01016783f, 0.02992413f, 0.06089390f, -0.08307944f, 0.04305938f, 
    0.04369367f, 0.00820396f, -0.01690418f, -0.02546260f, -0.02869560f, -0.03361549f, 0.04746872f, 0.04000812f, 
    0.03027939f, -0.04191421f, -0.00721120f, -0.01064028f, 0.01457394f, -0.07010454f, 0.02975763f, -0.02370455f, 
    -0.01683580f, -0.00621929f, 0.03729856f, 0.00285404f, -0.09145192f, 0.04589699f, -0.03030753f, -0.07839138f, 
    0.01152137f, -0.07531773f, -0.06522376f, -0.00130422f, -0.02777486f, -0.02540431f, 0.01964098f, -0.01373688f, 
    -0.03800077f, 0.03461892f, 0.05929462f, -0.05677704f, -0.05665347f, 0.01017480f, -0.03546770f, 0.06523869f, 
    -0.08610585f, -0.02029235f, 0.01934307f, -0.08501901f, -0.03859392f, -0.05365615f, 0.03514046f, 0.02648637f, 
    -0.01580923f, -0.07579034f, 0.00104294f, 0.07344729f, -0.02221078f, -0.04553906f, -0.05415157f, 0.05150254f, 
    0.00990262f, -0.05156866f, 0.00570708f, -0.02018178f, -0.04247407f, 0.00215474f, -0.01997527f, 0.00120517f, 
    -0.09087218f, -0.04682102f, 0.00709000f, -0.01240365f, -0.04277923f, 0.01061812f, 0.05622723f, -0.02523741f, 
    -0.07055635f, -0.00510172f, 0.00415118f, -0.05333452f, -0.01513015f, -0.00863420f, -0.08842195f, -0.02372657f, 
    0.05271725f, 0.04275534f, -0.04344744f, -0.02833935f, -0.01994185f, -0.00638222f, -0.01217681f, -0.01227915f, 
    -0.06059959f, 0.03329855f, 0.04405548f, -0.02946573f, 0.00250601f, -0.04090684f, 0.03215216f, 0.06538498f, 
    0.04095374f, 0.01834497f, -0.06396510f, -0.01991719f, 0.02804384f, -0.04850168f, -0.02789553f, -0.07954007f, 
    -0.06737404f, -0.05970312f, -0.01476936f, 0.01517923f, 0.04191091f, -0.00188225f, 0.00951052f, -0.02047162f, 
    0.05316154f, -0.01380714f, -0.08034220f, 0.05729060f, -0.03979364f, -0.02553380f, 0.05630941f, 0.05578489f, 
    0.02687772f, 0.00032007f, -0.04056367f, -0.00095553f, 0.06050901f, -0.04694247f, 0.01748915f, -0.03940235f, 
    -0.04455289f, -0.05895988f, 0.02324009f, -0.07433326f, 0.05237113f, 0.03308956f, 0.01988764f, -0.03290286f, 
    0.05309903f, -0.00967474f, 0.06257211f, 0.00072425f, -0.05167846f, 0.04325157f, -0.08402158f, -0.03384197f, 
    0.19053330f, 0.06393252f, 0.02131638f, -0.02593531f, 0.02892734f, -0.00000429f, 0.06691721f, 0.03114218f, 
    -0.04487012f, 0.00298317f, -0.01477469f, 0.03416381f, 0.18344454f, -0.30218652f, 0.03148787f, 0.01897250f, 
    0.09873740f, 0.04946267f, 0.01376213f, 0.09552784f, 0.01902980f, -0.03511126f, -0.03364534f, -0.00959764f, 
    0.08317268f, -0.19505228f, 0.15173699f, -0.06865860f, 0.06496155f, -0.02496840f, -0.04078212f, -0.05558981f, 
    0.08129803f, -0.05399068f, -0.05572668f, 0.05727123f, 0.04408621f, 0.04796286f, 0.08070522f, 0.01439487f, 
    0.16053365f, 0.00605147f, 0.00148075f, -0.04266266f, 0.01949124f, -0.06965672f, 0.11472283f, -0.06058720f, 
    -0.28249699f, -0.41605395f, -0.01951997f, 0.10356720f, -0.02370373f, -0.03044329f, -0.04648241f, 0.07621510f, 
    0.01466111f, -0.02112948f, 0.06177890f, -0.01020586f, 0.15203637f, 0.08904945f, -0.25396535f, -0.10127622f, 
    -0.02702199f, 0.07199982f, -0.04650588f, 0.03003470f, 0.03361706f, 0.05215839f, 0.06848217f, 0.12689309f, 
    -0.25171804f, -0.05495512f, -0.18497582f, -0.16924420f, 0.00079799f, -0.03271741f, 0.07446942f, -0.01292885f, 
    0.07722356f, -0.03073495f, 0.09888020f, -0.01558538f, 0.06396829f, 0.10094532f, -0.07427853f, -0.06238369f, 
    0.12624696f, 0.03731262f, 0.05201698f, 0.10804524f, -0.03902056f, 0.02833915f, 0.13773593f, 0.05907312f, 
    0.13221315f, -0.13985986f, 0.22010590f, -0.08720241f, 0.16256036f, 0.09842462f, -0.03567510f, 0.08289552f, 
    0.00238495f, 0.06700052f, 0.02219945f, 0.00575700f, 0.22223629f, -0.05787396f, -0.13941434f, 0.01856038f, 
    0.11892232f, 0.04352559f, -0.00590527f, -0.08245058f, -0.03978726f, -0.08113050f, 0.01060742f, -0.02236797f, 
    0.28278121f, 0.20977318f, 0.03429279f, -0.12447204f, 0.14327359f, 0.08864491f, 0.07011077f, -0.05437398f, 
    -0.04517208f, 0.03734659f, -0.03408185f, 0.06562717f, -0.01225581f, 0.05946676f, -0.25550011f, 0.06834298f, 
    -0.01440488f, 0.03733359f, -0.08085479f, 0.02326163f, 0.09308934f, -0.03601774f, -0.04040240f, -0.13392882f, 
    -0.01727714f, -0.15905131f, 0.08802316f, -0.01437446f, 0.02108679f, 0.00145552f, 0.03844262f, -0.17425914f, 
    -0.03202964f, 0.12030380f, 0.01549872f, -0.00809080f, 0.04827439f, 0.04065681f, 0.18824230f, 0.19899729f, 
    0.02298911f, -0.07522135f, 0.01503266f, 0.21722466f, 0.04983150f, 0.03110060f, 0.13225390f, -0.02718342f, 
    0.09606709f, 0.15079980f, -0.12904075f, -0.22916351f, 0.06640641f, -0.02248831f, -0.05320690f, -0.06799153f, 
    0.02905111f, 0.00576770f, -0.04143930f, -0.09338852f, 0.18530965f, 0.21944749f, 0.19852442f, -0.04799108f, 
    0.13532841f, 0.03373536f, -0.03844192f, 0.03181140f, 0.00959241f, -0.03945374f, 0.09127637f, -0.03070001f, 
    0.01412705f, 0.15060173f, 0.24507058f, 0.34133971f, 0.14140342f, 0.10373487f, -0.02889707f, -0.01682022f, 
    0.00721307f, 0.04075699f, 0.02965931f, 0.14666370f, 0.06725319f, 0.02641221f, 0.27228907f, 0.09967533f, 
    0.17355348f, 0.04346026f, 0.05857567f, 0.21941656f, -0.01246132f, 0.19421099f, -0.06346327f, 0.16195548f, 
    -0.10161053f, -0.10075807f, 0.07288202f, -0.15899418f, -0.03493750f, -0.06809102f, 0.02207387f, -0.04503585f, 
    0.03879569f, -0.02732466f, -0.08007457f, 0.02113977f, 0.21574460f, 0.15209787f, 0.04174028f, -0.04780418f, 
    0.10010599f, 0.10955050f, -0.05402799f, -0.14276215f, -0.03355092f, -0.00838578f, 0.01744483f, -0.04151646f, 
    0.29249382f, 0.01196880f, 0.06965823f, -0.10510527f, 0.05807498f, -0.01120555f, 0.15505557f, 0.04214428f, 
    0.11212616f, 0.00498017f, 0.04633208f, -0.00599892f, -0.26419219f, -0.09408906f, -0.10217593f, 0.09826488f, 
    0.00997311f, -0.04765272f, -0.06912871f, -0.02690082f, 0.17350090f, -0.04153976f, -0.00558542f, -0.02909624f, 
    -0.24824163f, 0.18310067f, -0.03668175f, -0.03882987f, -0.09320606f, -0.05297480f, 0.00644877f, -0.01012392f, 
    -0.17147811f, 0.10523419f, -0.09584273f, -0.12688449f, -0.21743874f, -0.12995224f, -0.09971380f, -0.15215594f, 
    -0.04490713f, 0.08485886f, -0.14969595f, -0.01648057f, 0.09264841f, -0.03213107f, -0.04594792f, -0.09844986f, 
    0.28570727f, 0.13410406f, 0.03043539f, 0.24591842f, -0.01810685f, 0.06332368f, -0.01368826f, -0.03004646f, 
    -0.07360341f, -0.13491005f, -0.07611012f, 0.02696143f, 0.31096885f, -0.06314756f, -0.05444996f, 0.00028395f, 
    -0.16772805f, 0.02346224f, -0.00162172f, -0.10717579f, 0.04415344f, -0.02757140f, 0.00819948f, 0.00442425f, 
    0.07126492f, 0.23708685f, 0.22689193f, 0.17965057f, -0.08268916f, 0.04178537f, -0.02535402f, 0.04758640f, 
    0.03828879f, -0.06276491f, 0.03933592f, -0.10349761f, -0.08163702f, 0.02675303f, 0.13949187f, 0.12371864f, 
    0.13445808f, 0.03411876f, -0.02628469f, -0.05786302f, -0.01697820f, 0.01764771f, 0.13510101f, -0.02338090f, 
    0.05785634f, -0.03051929f, -0.03938310f, -0.03193844f, -0.04968560f, 0.04153229f, -0.01245669f, -0.06307399f, 
    -0.16690902f, -0.05044568f, 0.00432724f, -0.13059840f, 0.23266549f, 0.10938182f, -0.05142396f, -0.09642980f, 
    0.13469423f, 0.05158541f, 0.08478807f, 0.08710392f, 0.04576576f, -0.06279996f, 0.05789549f, 0.02735546f, 
    0.14027558f, 0.39224666f, -0.19032744f, -0.13512479f, -0.01598795f, -0.13750020f, -0.09947613f, 0.10636333f, 
    -0.12776585f, 0.06743845f, 0.00118946f, 0.02601322f, 0.08795001f, 0.02229333f, -0.08492059f, -0.23320146f, 
    -0.07286552f, -0.12061367f, -0.05453955f, -0.04039501f, -0.12119700f, -0.05779268f, 0.01186666f, 0.08975598f, 
    -0.05565621f, 0.04069070f, -0.05286925f, 0.00123932f, 0.04634899f, -0.05101621f, 0.04862686f, -0.00491376f, 
    0.05256503f, -0.02652429f, 0.06384355f, 0.01482923f, -0.06788609f, -0.08848120f, 0.04100890f, 0.05506573f, 
    -0.01831478f, -0.00421249f, -0.05449225f, -0.06969057f, -0.01391626f, 0.03818841f, 0.05053294f, -0.00529736f, 
    0.04624202f, -0.02671353f, 0.05400315f, -0.07385852f, 0.01090999f, 0.00359408f, -0.05499078f, -0.00144210f, 
    0.03553732f, -0.04059396f, -0.01806510f, 0.00710232f, -0.00781293f, -0.01149113f, 0.02161427f, -0.08308914f, 
    0.07096956f, -0.06390515f, 0.02163618f, 0.03413493f, -0.05663158f, -0.00485930f, -0.05703332f, -0.07035039f, 
    -0.04429679f, 0.00129855f, -0.01400611f, 0.00370009f, -0.07048410f, 0.00700411f, -0.05381228f, 0.02437430f, 
    0.03757029f, 0.03147332f, 0.05723105f, 0.01097891f, -0.02558072f, -0.04643694f, 0.02097301f, -0.06809112f, 
    -0.05419520f, 0.04127813f, -0.01605338f, -0.06917999f, -0.07996725f, 0.02899208f, -0.05680276f, 0.04134319f, 
    -0.03036270f, 0.03190051f, -0.03582842f, -0.02775975f, -0.03409012f, 0.03056537f, 0.00132675f, 0.02192537f, 
    -0.04279283f, -0.06015299f, -0.04334327f, -0.03938769f, -0.06930754f, -0.05243643f, 0.02581724f, 0.05336591f, 
    0.03868473f, -0.02705982f, -0.09171259f, -0.05008348f, -0.00684998f, -0.02484355f, -0.01264811f, 0.05253766f, 
    -0.05308679f, -0.03491811f, -0.04651721f, 0.04672109f, -0.01996105f, -0.03525233f, -0.02059899f, 0.02899331f, 
    0.00097281f, 0.02977584f, -0.03346554f, -0.03682133f, 0.00230501f, -0.06256577f, -0.08072823f, -0.07250726f, 
    0.02891364f, -0.00733660f, -0.00312725f, -0.05707550f, 0.04476215f, 0.06439499f, -0.00947878f, -0.05745761f, 
    -0.08437540f, 0.00646845f, -0.03842206f, -0.00183948f, 0.02961325f, 0.01824056f, 0.02778981f, -0.07619724f, 
    0.04967787f, 0.03169247f, -0.07384506f, -0.08598728f, 0.03939392f, 0.02747059f, -0.03637667f, 0.04465272f, 
    -0.05058397f, -0.01517360f, -0.06863447f, -0.02086995f, -0.00763945f, -0.07399731f, 0.03102484f, -0.05014758f, 
    0.04077070f, -0.05156693f, -0.03249071f, -0.06336398f, 0.00124611f, 0.01885442f, -0.02868505f, -0.02699370f, 
    0.05813032f, -0.07198303f, 0.04783177f, -0.07304133f, -0.10522094f, -0.02106945f, -0.07270457f, -0.00993193f, 
    0.05158581f, -0.03395298f, -0.06259550f, 0.03063485f, -0.05456814f, 0.07271967f, -0.01641127f, 0.01654939f, 
    -0.02008303f, 0.02082706f, -0.00990646f, -0.03398181f, 0.04178954f, 0.04078624f, -0.01116055f, -0.00473135f, 
    -0.02913174f, -0.03350751f, 0.01486015f, -0.08555607f, -0.02889178f, -0.02040527f, 0.04357598f, 0.00161771f, 
    -0.02376451f, -0.08819227f, -0.00408432f, 0.02474877f, -0.02695462f, 0.00749699f, -0.04247336f, 0.04869378f, 
    -0.08104207f, 0.03649428f, -0.05299223f, 0.02178456f, -0.02882264f, 0.01043613f, -0.05000566f, -0.04133265f, 
    -0.01027244f, -0.03732881f, 0.04486978f, 0.00583220f, 0.03674548f, -0.02678568f, 0.03547950f, -0.05062817f, 
    -0.04242754f, -0.01902188f, -0.05138124f, -0.07112415f, -0.06330830f, 0.03795604f, -0.02305941f, 0.00141617f, 
    -0.07259059f, -0.01052593f, 0.02992691f, -0.04300750f, 0.03813158f, 0.00682840f, 0.03620916f, 0.02594498f, 
    -0.08035232f, -0.04623722f, 0.03833458f, 0.01949322f, -0.02973315f, -0.06660874f, 0.04611679f, -0.00206405f, 
    0.00194862f, -0.00385347f, -0.02507871f, 0.01757885f, -0.04960054f, -0.04150161f, -0.00644635f, -0.04019118f, 
    0.00601564f, 0.04493941f, -0.02823041f, -0.05153378f, -0.07094291f, -0.05933299f, 0.05189585f, -0.05854316f, 
    0.00393832f, -0.05248570f, -0.05044137f, 0.05749091f, 0.06061032f, -0.06865442f, -0.07256096f, 0.05903826f, 
    -0.07240667f, 0.02326075f, -0.06794613f, 0.04268068f, 0.03841059f, 0.00757072f, -0.01544470f, -0.04641900f, 
    0.06534473f, 0.00863103f, -0.06590489f, -0.07443393f, -0.01268291f, 0.02329439f, -0.05444636f, -0.07460117f, 
    0.05651620f, 0.03800197f, -0.01914720f, 0.04290889f, -0.00850813f, 0.00514034f, 0.06023581f, -0.05542387f, 
    -0.03398892f, 0.02739251f, -0.00830995f, -0.00217588f, -0.02890978f, -0.04382012f, -0.06973895f, 0.01642969f, 
    0.01714106f, -0.05091623f, 0.03983971f, 0.05446734f, -0.02488814f, -0.01625988f, -0.05888803f, -0.03572983f, 
    0.04587543f, 0.03371954f, -0.05137277f, -0.04586562f, -0.02426968f, -0.07328680f, -0.01691901f, 0.05784997f, 
    -0.06350555f, 0.02485650f, -0.01824378f, -0.07762268f, -0.02062874f, -0.05516142f, 0.05107910f, 0.00262289f, 
    -0.00312343f, -0.00127541f, -0.07856309f, -0.05384011f, -0.01333813f, -0.06202973f, -0.07486205f, 0.00310014f, 
    -0.07427060f, 0.05449774f, 0.04440014f, -0.07467251f, -0.00408495f, 0.03772650f, 0.06070688f, -0.01216966f, 
    0.05195780f, -0.07309042f, 0.05671628f, -0.04753060f, 0.06105186f, -0.05554704f, -0.06695223f, 0.04658279f, 
    -0.02879596f, -0.05144138f, -0.05810443f, 0.03756645f, -0.01760990f, 0.05335436f, 0.05701431f, -0.03023863f, 
    0.00905402f, -0.07635711f, 0.02445903f, -0.06968267f, -0.07335319f, 0.04436681f, 0.00160696f, -0.02416093f, 
    0.06540348f, -0.07093138f, 0.03399963f, -0.04362585f, 0.04028184f, -0.02833462f, 0.03358889f, 0.00556303f, 
    0.00197701f, -0.01305643f, 0.02027201f, 0.03825988f, 0.00557226f, -0.03298442f, 0.05923837f, -0.04651797f, 
    -0.02661246f, -0.01215687f, -0.07751381f, 0.06387878f, -0.02850971f, 0.00806045f, 0.04978617f, -0.03100056f, 
    -0.02911533f, 0.00192279f, 0.01338408f, 0.02422734f, -0.07904036f, 0.03144208f, 0.04896010f, 0.01138425f, 
    -0.06059593f, -0.10824619f, 0.04705124f, -0.03855342f, 0.03917632f, 0.04333836f, -0.04336822f, -0.01805980f, 
    0.02312628f, -0.07817222f, -0.00754626f, -0.03053281f, 0.14681900f, -0.07273549f, -0.13590699f, -0.03552432f, 
    0.04321372f, -0.06477294f, -0.02344675f, -0.11033110f, -0.07807069f, -0.10093024f, 0.01457111f, -0.03702876f, 
    -0.15006219f, -0.00990219f, 0.04010700f, -0.14552066f, 0.15613781f, -0.05092517f, -0.11471579f, 0.12401623f, 
    0.05513696f, 0.02617368f, 0.13934742f, 0.02791096f, 0.17288519f, -0.10495227f, -0.01838030f, 0.06192090f, 
    0.15167062f, -0.10968624f, 0.10268780f, 0.05364029f, 0.00453167f, 0.20503268f, -0.05084504f, 0.05257281f, 
    -0.56231976f, -0.08054603f, 0.05923689f, -0.00460289f, -0.06679834f, -0.03655681f, -0.06637871f, -0.01183708f, 
    0.05215371f, -0.03083591f, 0.04628300f, 0.06150817f, -0.26871595f, 0.20987721f, -0.04154997f, -0.07831103f, 
    0.17254981f, -0.01319265f, 0.00559520f, 0.05075354f, 0.02986318f, -0.07326674f, 0.03314663f, 0.14119948f, 
    -0.10080739f, 0.06140354f, -0.06738463f, 0.03836039f, 0.08540439f, -0.08955028f, 0.00330061f, 0.16884951f, 
    0.09074993f, -0.03734258f, -0.00867914f, 0.02804571f, 0.24626920f, 0.00044761f, -0.00560001f, 0.27962181f, 
    0.06462676f, 0.02114414f, 0.07594129f, 0.06075915f, 0.03228395f, 0.15316837f, 0.00092688f, 0.09145023f, 
    0.03493385f, 0.16285144f, -0.03527535f, -0.12117670f, 0.14874105f, 0.01422087f, 0.02474268f, 0.10860554f, 
    0.06564453f, 0.00213773f, 0.09751078f, 0.03818555f, -0.16821565f, 0.14097318f, -0.03698201f, -0.01673303f, 
    0.01635685f, 0.09320077f, -0.06227805f, 0.15448366f, 0.01492888f, 0.00099759f, 0.10807586f, -0.01818136f, 
    0.19866823f, -0.20836471f, -0.04326115f, -0.00312744f, 0.10504597f, 0.09331428f, 0.02715210f, 0.00290973f, 
    -0.04177489f, -0.04625035f, 0.01687471f, 0.08711047f, -0.12578873f, 0.10388932f, -0.09455599f, -0.01979335f, 
    -0.02541055f, -0.00543910f, 0.00642988f, 0.04487497f, 0.05546824f, 0.03133466f, -0.00887117f, -0.13573939f, 
    -0.04593773f, -0.16590011f, -0.16686915f, 0.15824461f, 0.06049236f, 0.03051691f, -0.09402257f, -0.01303412f, 
    -0.05188723f, -0.02620238f, -0.02141393f, -0.01179360f, -0.08119135f, -0.04467651f, 0.07551380f, 0.02611230f, 
    -0.00111115f, 0.01316784f, -0.03834087f, 0.07021156f, 0.05307719f, -0.03972135f, 0.13984852f, -0.01433739f, 
    0.12504464f, 0.02684955f, -0.05377895f, -0.11667719f, -0.05283474f, -0.03432940f, -0.07695955f, -0.11455138f, 
    0.16457550f, -0.06233228f, 0.05938265f, -0.10884739f, 0.25310156f, 0.04995942f, 0.05526268f, 0.05316775f, 
    -0.03267297f, 0.07826719f, -0.09253646f, 0.02174753f, 0.08479110f, -0.00453234f, 0.01432948f, 0.07115432f, 
    0.21432614f, 0.06861986f, 0.11471502f, 0.17776163f, 0.09088735f, 0.12513867f, -0.01986514f, 0.00683125f, 
    0.06480473f, 0.01133354f, -0.02369495f, -0.04777607f, 0.37748930f, 0.13047445f, 0.04089592f, 0.05757468f, 
    0.01427730f, -0.03804595f, -0.01547516f, 0.10711123f, 0.00472852f, -0.02805069f, -0.00617398f, -0.07029200f, 
    -0.16025525f, -0.35540682f, -0.11301792f, -0.15653297f, 0.09292351f, -0.04122235f, -0.02068354f, -0.11428183f, 
    0.05135280f, -0.09156051f, -0.11343833f, 0.05061738f, 0.16164185f, 0.00831856f, -0.04770815f, -0.25131798f, 
    0.06186822f, 0.01937728f, -0.01469961f, -0.07817701f, 0.03934723f, 0.11419800f, 0.01175512f, 0.00980086f, 
    -0.11224071f, 0.13509993f, -0.14706992f, -0.06652050f, 0.07706636f, -0.02217632f, -0.00573955f, -0.10100739f, 
    0.04817649f, 0.15279783f, 0.04227398f, 0.00346311f, -0.04003235f, -0.03478263f, -0.21957670f, 0.03409617f, 
    0.09405912f, 0.00067505f, -0.25062397f, 0.04611728f, -0.00673195f, 0.05643658f, -0.00115902f, 0.11739958f, 
    -0.01169179f, -0.15994076f, -0.15934330f, -0.23792128f, 0.00045683f, 0.06896625f, 0.07985319f, 0.11248681f, 
    -0.05188866f, -0.06928087f, 0.05949489f, 0.00059440f, -0.09678972f, 0.02088805f, -0.18139622f, -0.10460146f, 
    0.04172655f, -0.01925946f, 0.01535638f, 0.06196710f, -0.00475548f, 0.10868285f, 0.06015443f, -0.07557629f, 
    0.25156885f, -0.08279588f, -0.00627013f, 0.16183349f, -0.03458177f, 0.06542851f, -0.02149763f, 0.08569654f, 
    0.05574224f, 0.02889303f, 0.08248680f, -0.04261199f, 0.10373545f, 0.09455615f, -0.16998596f, -0.06670735f, 
    -0.13024595f, 0.09747605f, -0.01058538f, 0.00391440f, 0.08966744f, 0.03079718f, 0.11870212f, 0.06898060f, 
    0.11224996f, -0.11784381f, 0.19660695f, 0.07321721f, 0.12208732f, 0.02489656f, -0.04175391f, 0.01884538f, 
    0.01811709f, 0.08438156f, -0.01241688f, 0.10948153f, 0.36046061f, 0.12020775f, -0.04835569f, 0.12560456f, 
    -0.20206738f, -0.09900010f, -0.06002135f, -0.01590521f, 0.20544808f, 0.05404368f, 0.01191039f, 0.01377378f, 
    0.09332303f, -0.06207776f, 0.00016956f, 0.16946568f, 0.08415556f, 0.05387254f, 0.06390908f, -0.14771716f, 
    0.00515360f, 0.03534181f, 0.02739772f, 0.05946914f, -0.05788152f, 0.08493690f, 0.09309224f, -0.07470864f, 
    -0.06715523f, -0.04979278f, 0.05000227f, 0.18757938f, 0.06588131f, -0.07076030f, 0.07991084f, -0.08929116f, 
    -0.05290280f, -0.01517232f, -0.12319739f, -0.19051257f, 0.05131098f, 0.00240060f, -0.05333701f, -0.01186056f, 
    -0.05301853f, 0.06316769f, -0.05245102f, -0.09324366f, 0.06530171f, 0.07333518f, 0.08544005f, -0.27197400f, 
    0.00348917f, -0.06295470f, 0.02856856f, -0.00906448f, -0.01502614f, -0.10324601f, 0.02039351f, 0.01733306f, 
    -0.00529388f, 0.05353159f, -0.09756880f, -0.08692916f, -0.08193327f, -0.01716628f, -0.06448956f, 0.06708430f, 
    0.00520849f, 0.10176317f, 0.13148215f, 0.19908006f, 0.00607654f, -0.15743893f, 0.25237301f, 0.03681629f, 
    -0.05545047f, 0.01519653f, 0.10408902f, 0.16051921f, 0.07820705f, 0.10499690f, -0.04024649f, 0.06958714f, 
    -0.15216763f, -0.00351285f, 0.27891338f, -0.14092927f, 0.05689808f, 0.10009834f, 0.09194249f, -0.05221352f, 
    0.03361174f, -0.03677803f, -0.04822234f, 0.00170001f, -0.23603192f, 0.12905136f, 0.16919473f, 0.01867032f, 
    0.10810645f, -0.07377259f, -0.19946934f, 0.00820682f, 0.13246474f, -0.09870329f, 0.04498340f, -0.10365058f, 
    0.46671036f, -0.02642792f, -0.01778848f, -0.05868312f, 0.02720850f, 0.07177985f, -0.02958185f, 0.13242914f, 
    -0.03156151f, 0.07065390f, -0.00358266f, 0.01991350f, 0.41816390f, 0.10727701f, -0.13534425f, -0.09402362f, 
    -0.04852284f, 0.00672478f, -0.08202213f, 0.03642311f, -0.06769668f, 0.09976897f, -0.05369566f, -0.12545550f, 
    0.01156538f, 0.16512083f, -0.19758901f, -0.01004020f, -0.04339234f, -0.00282858f, -0.09621241f, -0.20772797f, 
    -0.13770455f, 0.04960262f, -0.06493308f, -0.07443717f, -0.05032912f, 0.06737761f, -0.03400323f, -0.10896561f, 
    -0.02173305f, 0.13022536f, -0.08481452f, 0.03747294f, -0.01794184f, -0.15718696f, -0.04036396f, 0.11882028f, 
    0.07570705f, -0.00195240f, 0.05319897f, -0.17692836f, 0.04475753f, -0.00703147f, -0.00640237f, 0.01185146f, 
    0.06315297f, -0.05698790f, 0.01858610f, -0.00990233f, 0.32368842f, -0.10991838f, -0.13787471f, 0.16987562f, 
    -0.02609832f, 0.00339615f, 0.08755391f, -0.08250672f, 0.08582327f, 0.00948458f, -0.00890771f, -0.12394852f, 
    -0.10965425f, 0.32487905f, -0.00120369f, -0.19707042f, 0.14580429f, -0.00281039f, 0.01320353f, -0.06455303f, 
    0.05060613f, 0.01084569f, 0.01395078f, -0.16302739f, 0.18031292f, -0.03505563f, -0.02582293f, 0.20520537f, 
    -0.06019271f, 0.07737357f, -0.01824781f, 0.02449728f, -0.13365220f, -0.11887585f, 0.01610933f, -0.03042100f, 
    0.02207914f, -0.03703177f, 0.02518374f, -0.10277383f, 0.14437871f, -0.03243430f, 0.05051582f, -0.02820501f, 
    0.06879075f, 0.02963151f, 0.04710693f, -0.05052208f, 0.24595377f, 0.05558051f, 0.05950311f, 0.15202715f, 
    0.04021841f, -0.02601393f, 0.10434138f, 0.09530298f, 0.05051231f, -0.02535823f, -0.05415394f, 0.05302458f, 
    -0.23846041f, 0.23218553f, 0.03201184f, -0.31571370f, 0.19194190f, -0.04901118f, -0.10958086f, 0.07953662f, 
    -0.17886040f, 0.16671947f, -0.14342900f, 0.06830896f, -0.13980226f, -0.21627873f, -0.00930597f, 0.17638330f, 
    0.08235031f, -0.01562212f, 0.10673682f, -0.01402508f, -0.00589752f, 0.06815711f, 0.10999148f, 0.05972448f, 
    0.12875302f, -0.13774027f, -0.18645833f, -0.13624224f, -0.03876217f, 0.01177896f, -0.10950075f, -0.11163898f, 
    -0.05525739f, -0.11285250f, 0.07616581f, -0.10366534f, 0.15793097f, 0.12664598f, 0.07961906f, 0.11946642f, 
    0.10466725f, 0.04800167f, 0.06045629f, 0.07203685f, 0.01104931f, -0.03790732f, -0.08978018f, -0.02058626f, 
    0.23520295f, -0.04952626f, -0.16904037f, 0.07690361f, -0.01606363f, -0.08769155f, -0.11761649f, 0.00274603f, 
    0.05165428f, -0.05780613f, 0.03442367f, -0.03720438f, 0.29809505f, -0.00814351f, 0.06256155f, 0.12717277f, 
    0.00814275f, -0.10781106f, 0.07526737f, 0.05431709f, 0.11842389f, -0.00255254f, -0.01509420f, 0.08444977f, 
    -0.23074019f, -0.11595844f, 0.25593042f, 0.11313549f, 0.14654401f, -0.06173040f, -0.12607141f, 0.01945567f, 
    0.06829192f, -0.11937754f, 0.07794944f, 0.09480539f, -0.10518395f, 0.08230044f, 0.17287885f, -0.07789209f, 
    0.00686296f, -0.03377488f, -0.09722146f, 0.07357230f, -0.02244830f, -0.06979980f, 0.01085666f, -0.04067882f, 
    -0.03316040f, 0.14651309f, 0.15547647f, -0.01559705f, -0.08617560f, 0.02010779f, -0.04639501f, 0.07135318f, 
    -0.00284506f, -0.11684050f, -0.02114784f, 0.04675290f, 0.19755341f, 0.08924702f, -0.00803976f, 0.29006749f, 
    -0.06731966f, -0.12129687f, -0.11474700f, -0.08922353f, -0.06311373f, 0.11877864f, -0.07608654f, -0.00237586f, 
    -0.31712881f, -0.23024121f, -0.04505948f, -0.17709987f, 0.16038577f, 0.01863912f, -0.04706641f, 0.05779888f, 
    -0.00868649f, 0.02278567f, 0.03929227f, -0.12095351f, -0.00939467f, -0.12218362f, 0.09245261f, 0.08842921f, 
    0.12331462f, -0.03275264f, 0.01367780f, 0.10311134f, -0.07440192f, 0.02714711f, -0.12206616f, 0.14906421f, 
    0.06959833f, -0.11233564f, -0.19090547f, -0.01398618f, 0.24870662f, -0.00411916f, -0.01465857f, -0.03093296f, 
    0.02351739f, -0.02815520f, 0.11317302f, -0.08399280f, 0.27895835f, 0.21357279f, 0.12856553f, 0.23010087f, 
    0.04408252f, 0.08931561f, 0.12669906f, 0.14865653f, 0.11614455f, 0.09922922f, -0.12184038f, -0.08174906f, 
    0.05444550f, 0.03242808f, -0.15519913f, 0.05767979f, 0.00246068f, -0.03820056f, 0.00798928f, -0.01233087f, 
    -0.10247178f, -0.11122249f, -0.10226635f, -0.00179315f, 0.16995192f, -0.09026239f, 0.03447281f, 0.09473920f, 
    0.03752720f, -0.01485592f, -0.12468258f, 0.15541959f, 0.01122070f, -0.08818266f, 0.08789626f, -0.07147075f, 
    -0.00153316f, -0.17990375f, -0.15031835f, 0.28105494f, 0.06900503f, 0.09093456f, -0.00229987f, 0.00138608f, 
    0.08419422f, -0.14057548f, -0.00137595f, -0.08766506f, 0.32493114f, 0.39093247f, 0.14753576f, -0.07791000f, 
    0.02871178f, 0.01802643f, -0.13344578f, -0.14277670f, 0.15141709f, 0.02389520f, -0.04082927f, -0.05460164f, 
    -0.20127220f, 0.07654297f, -0.10619027f, -0.10928272f, 0.03243310f, -0.09215377f, -0.00156249f, 0.04907171f, 
    0.03390842f, 0.02692562f, 0.13725489f, 0.05414630f, -0.07504176f, -0.08722410f, 0.12165519f, 0.07755802f, 
    -0.08315762f, -0.00371981f, 0.03471785f, 0.08175089f, 0.08547147f, 0.08885280f, 0.02586992f, 0.01609328f, 
    0.10709864f, -0.01234532f, 0.01866679f, 0.06721241f, 0.01042277f, 0.11621434f, 0.07720013f, 0.03873426f, 
    0.00257088f, 0.09217843f, 0.08185285f, 0.10636430f, 0.01315492f, -0.03052780f, 0.10250580f, 0.13675360f, 
    -0.04328069f, -0.10543094f, -0.15337607f, 0.17389241f, -0.03531534f, 0.00486640f, 0.12788139f, -0.08161768f, 
    0.37699893f, 0.19922562f, 0.01126298f, 0.09947553f, 0.02400166f, 0.05279130f, -0.15136163f, 0.15256965f, 
    -0.05663003f, -0.04737251f, -0.00175704f, 0.18531975f, 0.12877762f, 0.01100199f, 0.18100980f, 0.07549267f, 
    0.06383928f, 0.02560085f, 0.09546049f, 0.03184153f, 0.06246850f, 0.00294075f, -0.14465956f, -0.05966867f, 
    0.02769004f, 0.33745852f, -0.04388266f, -0.06739260f, -0.00417118f, 0.10114629f, 0.02824884f, -0.07141104f, 
    -0.05395562f, 0.00628939f, -0.11394187f, -0.07299125f, 0.06987560f, 0.09098465f, -0.11811352f, 0.08848590f, 
    0.01854798f, 0.08477114f, -0.03557299f, 0.05258286f, -0.02327733f, -0.09207147f, -0.01419605f, -0.00995567f, 
    -0.25996771f, -0.07188880f, -0.03598874f, -0.27171937f, 0.08233637f, 0.04974007f, -0.04976789f, -0.06448287f, 
    -0.04677047f, -0.04176227f, -0.02853700f, 0.08720757f, 0.17723541f, -0.17693895f, 0.05562572f, 0.04502860f, 
    -0.04618395f, -0.17449808f, 0.12013893f, 0.01876422f, -0.04492937f, -0.03129360f, -0.08490952f, -0.05326792f, 
    -0.15096891f, 0.30481482f, -0.11533175f, -0.06578250f, 0.01712088f, -0.06334167f, 0.00929849f, -0.08512935f, 
    -0.06775577f, -0.06211942f, -0.00111367f, -0.16061158f, 0.06169199f, -0.17781755f, 0.20053515f, 0.21087740f, 
    -0.04567982f, 0.05980776f, -0.03613149f, -0.09706608f, -0.11161881f, -0.03363180f, 0.04142236f, -0.05215546f, 
    -0.02456195f, 0.01953699f, -0.21208017f, 0.01576565f, 0.13761407f, 0.05481802f, -0.02260920f, 0.06137353f, 
    -0.07336008f, -0.02616179f, 0.02886244f, -0.00607950f, 0.16028023f, 0.02616995f, 0.10659067f, 0.05926150f, 
    0.10873739f, 0.05410134f, -0.08352218f, 0.13700750f, 0.07898224f, 0.07263812f, 0.00655025f, -0.03765526f, 
    -0.20005932f, -0.01255598f, -0.17195611f, -0.09574988f, 0.04697780f, -0.02682769f, -0.05673237f, -0.02655110f, 
    -0.06777441f, 0.06722804f, -0.06614547f, 0.00832494f, 0.03955471f, 0.02679205f, -0.01419022f, 0.27720058f, 
    -0.04317217f, -0.06325639f, -0.03964167f, -0.13120231f, 0.01854474f, 0.14013650f, 0.13250290f, 0.20040549f, 
    0.09834309f, 0.07129617f, -0.02206851f, 0.11539568f, 0.04430023f, -0.01332241f, 0.03924136f, -0.04498585f, 
    -0.00671282f, 0.06935132f, -0.16314475f, 0.00979487f, -0.00334852f, -0.07596868f, -0.01010618f, -0.05044191f, 
    0.00826104f, 0.09003041f, -0.05689361f, 0.03554438f, 0.05644693f, 0.05341768f, 0.08663527f, 0.03585466f, 
    -0.00422559f, -0.09201559f, 0.14963196f, 0.08521466f, -0.01389664f, -0.03298276f, -0.19482939f, -0.11332355f, 
    0.13152456f, 0.02616047f, -0.10630608f, -0.05809793f, 0.06159491f, 0.23180354f, 0.05258804f, -0.02206897f, 
    0.08821883f, 0.17537352f, 0.12070642f, -0.21875116f, 0.00632523f, -0.08333386f, 0.09963867f, 0.02218816f, 
    0.22849087f, -0.16031496f, -0.11525781f, 0.04898722f, 0.05246633f, -0.08207747f, 0.12960532f, -0.08780403f, 
    0.12785618f, 0.00888763f, 0.11765371f, -0.01047743f, 0.14266245f, -0.01124986f, -0.16296695f, 0.01014863f, 
    -0.14754748f, -0.04552154f, -0.03084390f, 0.04543866f, -0.01381192f, 0.11368899f, 0.08109754f, 0.09086040f, 
    0.01090127f, -0.13767642f, -0.04325932f, -0.11450717f, 0.02169204f, -0.01528365f, 0.09051511f, -0.02811268f, 
    0.02394667f, -0.07987110f, 0.08496046f, 0.09687580f, -0.11661620f, -0.01711014f, 0.18325628f, -0.33577281f, 
    0.02278755f, 0.11608122f, 0.02346919f, 0.05450143f, -0.04599285f, 0.08967407f, 0.00902657f, 0.05425746f, 
    0.19486053f, -0.05614493f, 0.07213649f, 0.19667734f, -0.14430773f, -0.02134067f, -0.00181847f, 0.00034641f, 
    0.06534042f, -0.00648639f, 0.16084418f, 0.00026714f, 0.23850255f, 0.02336534f, -0.06270976f, 0.02804113f, 
    0.01417551f, 0.10347691f, -0.04231186f, -0.06350106f, 0.08873836f, 0.00443647f, 0.06854501f, 0.08296226f, 
    -0.13204525f, -0.00018855f, 0.14585736f, -0.04077640f, -0.06412727f, 0.08292407f, 0.09224597f, 0.10304505f, 
    0.01854496f, 0.04905586f, 0.04133439f, 0.07453384f, -0.02872237f, -0.09353824f, -0.09342953f, -0.14560856f, 
    -0.04345678f, 0.04494625f, 0.00111150f, 0.03420295f, 0.06720477f, -0.05494285f, -0.06936273f, 0.02414824f, 
    -0.02601828f, -0.00634508f, 0.16102423f, -0.09631181f, 0.00004910f, -0.09687021f, 0.01398160f, -0.07629691f, 
    0.16957602f, 0.13162498f, 0.08110537f, 0.02730114f, 0.14130780f, 0.06039590f, 0.14367931f, 0.05653393f, 
    -0.04265511f, 0.02830477f, 0.06790842f, 0.03139560f, 0.00542372f, 0.04756885f, -0.11936055f, 0.00674341f, 
    0.01041071f, 0.08933039f, 0.07382909f, -0.07033137f, 0.01037384f, 0.01649135f, 0.00728061f, 0.02258895f, 
    0.05001593f, 0.03557867f, 0.04939256f, -0.10975566f, -0.17242678f, 0.06263474f, 0.08124928f, -0.16636799f, 
    0.16054024f, 0.03759748f, -0.05341730f, 0.07060588f, 0.05631803f, -0.20854804f, 0.06686145f, -0.06441114f, 
    -0.00581721f, -0.07364682f, -0.05365374f, 0.03966417f, 0.03966867f, 0.04901642f, 0.00747102f, 0.08341504f, 
    0.07190796f, 0.00918532f, 0.08902443f, 0.05216717f, 0.27350473f, -0.07892164f, -0.09430948f, 0.00826066f, 
    0.06994192f, -0.14980546f, 0.04292623f, 0.09591451f, -0.07999640f, -0.02979522f, -0.05652491f, 0.05077237f, 
    0.13240460f, -0.16657484f, -0.19783191f, -0.02408918f, 0.08345751f, 0.13898391f, -0.11898616f, 0.07490411f, 
    0.08292613f, 0.01320702f, 0.05675945f, 0.03816279f, 0.07058614f, -0.25986546f, 0.08967090f, -0.11576752f, 
    0.17140159f, -0.01227965f, 0.00405468f, 0.00805688f, -0.09096536f, -0.04425669f, -0.01534880f, -0.01892435f, 
    -0.45966023f, 0.06596516f, -0.11727460f, -0.13801332f, -0.09222905f, 0.02300204f, -0.02842565f, 0.03756391f, 
    0.08847181f, 0.07176240f, 0.07110125f, 0.01442531f, -0.16493677f, 0.04000746f, -0.02488347f, 0.12547664f, 
    0.16034348f, 0.11103782f, -0.02969954f, 0.04349809f, -0.00705584f, -0.09899810f, -0.01714099f, 0.03962803f, 
    0.03504284f, -0.02075251f, -0.09212625f, -0.04924059f, 0.03732923f, -0.02096009f, -0.08542646f, 0.15964828f, 
    0.02145137f, -0.08070090f, 0.05081226f, -0.00219042f, 0.03552833f, 0.24562570f, 0.09625205f, 0.14414534f, 
    0.05715533f, 0.10668637f, 0.09684180f, 0.01552058f, 0.07036402f, 0.04695863f, 0.02173288f, -0.00247225f, 
    0.26636884f, -0.03577133f, -0.07558981f, 0.03480130f, 0.03327055f, 0.14031097f, -0.03220002f, 0.05105902f, 
    -0.02767808f, 0.05139238f, 0.03065859f, 0.07411332f, -0.18129772f, 0.14388607f, -0.14446901f, -0.14479378f, 
    -0.08943900f, 0.08032613f, -0.03091182f, 0.10130423f, 0.06805781f, -0.08566751f, 0.06425035f, 0.03417860f, 
    0.31259772f, -0.19113946f, 0.08848201f, 0.20352060f, 0.03066654f, -0.08400325f, 0.06187527f, 0.04016075f, 
    0.02719712f, 0.07322751f, -0.02156716f, -0.09673293f, 0.10284737f, -0.00049628f, -0.12757181f, 0.02131758f, 
    -0.12655997f, -0.05166322f, -0.07749270f, -0.06489776f, -0.04883474f, -0.07589962f, 0.04521160f, -0.06072354f, 
    0.32395354f, -0.14419471f, -0.18632269f, 0.01428640f, -0.05188321f, 0.12464264f, 0.03486023f, -0.08164075f, 
    -0.16165909f, 0.09792402f, -0.09969791f, 0.04770872f, -0.24793814f, -0.04362374f, 0.10250587f, -0.04713622f, 
    -0.01919923f, -0.02354815f, 0.02831349f, 0.16163442f, -0.05378859f, 0.05849217f, 0.12586455f, -0.09813331f, 
    0.23273312f, -0.05216905f, -0.00092916f, -0.09629858f, 0.07283201f, 0.00164541f, 0.00783568f, -0.06994862f, 
    0.00401229f, 0.01773280f, 0.01960718f, -0.07974344f, 0.18025026f, 0.00509031f, 0.22903889f, 0.00625226f, 
    -0.07903368f, 0.06794965f, 0.12199863f, -0.00906337f, -0.03436944f, 0.03015813f, 0.08283902f, 0.03728677f, 
    -0.27454734f, 0.09391272f, 0.02265565f, 0.05904116f, 0.02634864f, -0.04475509f, 0.08485679f, 0.05420534f, 
    -0.00470293f, 0.10450119f, 0.18612780f, 0.13193803f, 0.20960082f, -0.22770330f, -0.04483839f, -0.10626945f, 
    -0.04903124f, -0.09323958f, 0.10534328f, 0.15819837f, 0.03552362f, 0.09025580f, -0.11989655f, 0.04825677f, 
    0.19568853f, 0.09083676f, 0.04782027f, -0.07179520f, 0.04286759f, 0.00060878f, 0.11649498f, 0.02825712f, 
    0.08672626f, 0.06138060f, -0.03584965f, 0.16025183f, -0.12203486f, -0.13834663f, 0.11791144f, -0.02480452f, 
    0.24294236f, 0.06522092f, -0.07539079f, 0.08041825f, -0.13233319f, -0.03123700f, 0.09902515f, -0.16212556f, 
    -0.03103241f, -0.17685264f, 0.10296687f, 0.06311145f, -0.10374390f, 0.20131572f, 0.05869642f, 0.10289074f, 
    -0.09490634f, 0.09179495f, -0.00684832f, 0.01273823f, -0.12666114f, 0.13039866f, -0.04607186f, -0.07243330f, 
    0.07001967f, 0.04047388f, 0.05167264f, 0.05325609f, -0.02697219f, -0.09721513f, -0.13213997f, -0.01016319f, 
    -0.13383722f, 0.02725565f, -0.15599471f, 0.04231561f, 0.17070504f, 0.02188216f, 0.02176183f, -0.00497378f, 
    0.01160187f, 0.05370785f, 0.04766025f, -0.19473468f, 0.08746049f, 0.01717314f, -0.04680974f, 0.17781353f, 
    -0.00808372f, 0.08456961f, 0.09928340f, 0.16684093f, 0.08800212f, -0.14448589f, 0.05344589f, -0.03962429f, 
    0.22152624f, 0.00957321f, -0.02729918f, -0.06266849f, 0.08225780f, -0.01767166f, 0.07843605f, 0.04251154f, 
    -0.02449012f, -0.01804575f, -0.14184940f, 0.11877577f, -0.26714689f, 0.08855157f, 0.09482765f, -0.13099587f, 
    0.02427818f, 0.02597932f, 0.06991665f, 0.03463010f, -0.07723407f, -0.12664464f, 0.07613411f, -0.16038121f, 
    0.38566419f, 0.10496125f, 0.07841877f, 0.05051829f, 0.02322287f, -0.13862740f, 0.01796604f, 0.04233776f, 
    0.10128670f, 0.02062279f, -0.09432518f, -0.12752078f, -0.23517865f, 0.05281527f, -0.12557063f, -0.13547046f, 
    -0.04150925f, -0.06807513f, -0.10034520f, 0.05430545f, -0.02960134f, -0.10030735f, 0.06242289f, -0.00721823f, 
    0.16311106f, -0.23002064f, 0.06630412f, -0.10471229f, 0.06133623f, 0.14114846f, 0.11659517f, 0.01781067f, 
    -0.08033821f, 0.13218275f, -0.02102549f, -0.09870914f, -0.21269526f, -0.14988180f, 0.00147273f, 0.08263572f, 
    0.09559496f, 0.11837327f, 0.02286268f, -0.02129839f, -0.00976806f, 0.06558826f, 0.02035032f, 0.10042603f, 
    0.41785523f, 0.15943891f, -0.15745525f, -0.24087936f, 0.03517339f, -0.07014433f, -0.00003056f, 0.04217789f, 
    0.07573529f, 0.12223551f, -0.07794291f, 0.15536873f, 0.23430425f, -0.01913631f, -0.08757075f, 0.06707709f, 
    0.05984166f, -0.01468646f, 0.18599643f, -0.03225033f, -0.01848885f, 0.11086758f, 0.12482685f, 0.15279454f, 
    -0.12003168f, 0.11849293f, -0.04539717f, -0.00842663f, 0.02569177f, -0.01949011f, -0.05456092f, 0.05642270f, 
    0.11305053f, 0.09455523f, 0.11405449f, 0.13340780f, -0.05717597f, 0.02771201f, 0.00856831f, 0.11386632f, 
    0.01394381f, 0.08871283f, -0.05462653f, 0.01742505f, -0.01762955f, 0.08282432f, -0.00379627f, -0.02148050f, 
    -0.16557077f, 0.28163257f, 0.12302548f, -0.02281909f, -0.07709090f, -0.02289700f, 0.15634789f, -0.03452200f, 
    0.06297564f, 0.04772684f, 0.05666967f, 0.01528342f, -0.21495144f, 0.02281761f, 0.02618684f, 0.03467996f, 
    0.14741740f, 0.05208804f, 0.01614582f, 0.02097290f, -0.11303361f, -0.04288751f, 0.02257969f, -0.05803071f, 
    0.25731471f, -0.13268863f, 0.07556099f, 0.11853290f, -0.00322875f, 0.09208807f, 0.09743416f, 0.05693290f, 
    -0.03072992f, -0.07740837f, -0.01189750f, 0.09980300f, -0.04283323f, 0.09128693f, -0.17985658f, -0.01444127f, 
    -0.00852216f, -0.08092920f, 0.05160516f, 0.02595180f, 0.09856303f, -0.11378490f, -0.06923081f, -0.09738290f, 
    -0.08071695f, 0.16259585f, -0.03163961f, 0.16662005f, 0.12284995f, -0.06907609f, -0.01306015f, -0.02491768f, 
    -0.07438929f, 0.13880733f, -0.07648347f, -0.01914790f, -0.09468152f, -0.06178005f, -0.19664033f, 0.24039277f, 
    -0.08177301f, -0.05446154f, 0.07392479f, 0.08733968f, 0.04750710f, -0.12851541f, -0.08513680f, 0.08799296f, 
    -0.10357311f, 0.23781404f, -0.06919765f, -0.06162997f, -0.05677351f, 0.04730540f, -0.01783134f, 0.08684537f, 
    -0.11743230f, 0.00369093f, -0.15177520f, 0.09121898f, -0.06363195f, -0.01367701f, 0.07961104f, 0.02348292f, 
    -0.06562670f, -0.05865735f, 0.05798048f, 0.00388798f, -0.08788955f, -0.02299700f, 0.05311488f, -0.07160711f, 
    0.12427888f, 0.10338026f, -0.02088871f, -0.05355987f, -0.08166113f, -0.07528886f, -0.06832830f, -0.00830382f, 
    0.04390264f, 0.02008952f, -0.13727093f, -0.02222918f, -0.38594824f, 0.21071613f, 0.14142957f, 0.00462632f, 
    0.11376816f, 0.02396903f, -0.07050817f, -0.01989376f, -0.11727576f, 0.08715481f, 0.18417983f, 0.04928293f, 
    0.02107195f, -0.11646277f, 0.07028694f, 0.07248719f, 0.04910490f, 0.12216578f, -0.02545687f, 0.12190080f, 
    -0.04507250f, -0.04246035f, 0.04702895f, -0.04374086f, -0.06169113f, 0.02116098f, -0.00324648f, 0.02067964f, 
    0.08206050f, 0.11947223f, 0.00928529f, -0.00613057f, -0.05944037f, 0.07181454f, -0.06709858f, 0.14760093f, 
    0.20291288f, 0.26716036f, -0.16876642f, -0.22759318f, 0.06169239f, -0.11604091f, -0.00913210f, 0.01768453f, 
    0.04968952f, 0.21936904f, -0.04584539f, 0.03387060f, 0.05455255f, 0.04789399f, -0.14678143f, 0.18359147f, 
    0.02600821f, -0.02555578f, 0.05652017f, -0.11274447f, -0.09752440f, 0.06240177f, 0.13528495f, 0.04888837f, 
    -0.02908400f, -0.06214590f, -0.05297631f, -0.00768587f, 0.01466747f, -0.02755300f, 0.04023762f, 0.03762098f, 
    -0.04202686f, -0.04443825f, 0.00552880f, 0.04755668f, 0.02042242f, -0.01373635f, -0.00564047f, 0.00124169f, 
    0.04507613f, -0.06605977f, -0.06335729f, 0.06652139f, 0.02045025f, 0.04686004f, -0.05582086f, 0.03432800f, 
    0.00697888f, 0.00342668f, -0.07179450f, 0.04817509f, -0.06008868f, -0.05445331f, 0.02954799f, 0.05376498f, 
    0.04927900f, -0.01655159f, 0.00557052f, 0.06601779f, 0.04007529f, -0.03420617f, -0.04021567f, -0.04122765f, 
    -0.05954680f, -0.01364827f, 0.06361903f, -0.05808176f, -0.04951976f, -0.02993759f, -0.02514640f, -0.05323100f, 
    -0.01665234f, -0.03433910f, 0.00099583f, 0.04830503f, -0.01029174f, -0.00935772f, -0.04399191f, -0.06305791f, 
    -0.02850045f, 0.01792819f, -0.05500628f, 0.03968539f, 0.02190745f, -0.02856413f, -0.06684060f, 0.06191187f, 
    0.00307458f, 0.00940200f, 0.00241476f, 0.03771388f, -0.00705572f, -0.05538822f, -0.04402518f, -0.00248326f, 
    -0.04213015f, 0.06537942f, 0.03348029f, 0.03842307f, 0.05977394f, 0.06829103f, 0.03748329f, 0.02557990f, 
    -0.05608612f, 0.06914257f, 0.02742638f, -0.03625644f, 0.01087711f, -0.00762371f, 0.06203318f, -0.01303461f, 
    -0.01694007f, 0.00278212f, -0.02938255f, 0.01855092f, 0.00437246f, -0.03409817f, 0.06307723f, 0.00312081f, 
    -0.05620398f, -0.03019270f, 0.05058542f, 0.02436631f, 0.03101938f, -0.03970504f, -0.00566820f, 0.02228053f, 
    0.02081740f, -0.04188140f, -0.03064160f, -0.01556430f, -0.01428930f, -0.07090988f, -0.02765618f, -0.02456289f, 
    -0.04276137f, 0.00184544f, -0.02123126f, 0.02255107f, 0.05659433f, -0.05090089f, -0.06473818f, -0.02052237f, 
    0.05630519f, -0.01288683f, -0.03652671f, 0.01644962f, 0.02817998f, -0.04628729f, 0.05657827f, 0.05835171f, 
    -0.03734747f, -0.06500316f, -0.01587576f, 0.01228610f, -0.02884341f, 0.01924993f, -0.05210371f, 0.05489901f, 
    0.05836627f, 0.05189182f, -0.04190662f, -0.04901856f, -0.05907207f, 0.03987782f, -0.06226439f, -0.05718955f, 
    -0.06456015f, -0.03772873f, -0.02672780f, 0.06172346f, -0.01794468f, -0.06125626f, -0.06495441f, 0.00798930f, 
    -0.06828674f, -0.00475590f, 0.05788322f, 0.05876340f, -0.06051876f, -0.03464108f, 0.03545231f, 0.03782059f, 
    -0.05182124f, -0.04507455f, -0.04654398f, -0.02194001f, -0.04860570f, -0.02132882f, -0.00248726f, -0.01831073f, 
    -0.01281096f, -0.05518482f, -0.04672814f, -0.03591124f, -0.06954642f, -0.07193282f, -0.03907162f, -0.01903483f, 
    0.05312975f, -0.06165721f, -0.04765863f, -0.01405630f, -0.03230438f, -0.00959879f, -0.03047953f, 0.05140072f, 
    0.01245560f, 0.02321822f, 0.04968963f, -0.04468998f, 0.05132608f, -0.06260821f, -0.04604225f, -0.06987014f, 
    -0.07691699f, 0.03088107f, 0.02804317f, 0.00675211f, -0.01692439f, 0.04458401f, 0.01770970f, -0.01592332f, 
    0.00436682f, 0.00439552f, -0.05767942f, -0.02126721f, 0.00561991f, -0.06670939f, 0.05591261f, 0.04328345f, 
    0.04530311f, -0.01852591f, -0.04195508f, -0.05824688f, 0.02231783f, -0.04447251f, -0.07697681f, 0.02331974f, 
    -0.06333112f, 0.02680328f, 0.02748963f, 0.04130034f, -0.06835856f, 0.04205497f, 0.04944840f, -0.04994512f, 
    -0.06151855f, 0.04910446f, 0.04106690f, 0.03071563f, -0.04620425f, -0.04090343f, 0.00602432f, 0.05806164f, 
    -0.07725925f, 0.05301321f, -0.01066183f, 0.01967165f, -0.01606837f, 0.02380340f, 0.03711235f, 0.05470408f, 
    -0.05044815f, -0.02917137f, 0.01086107f, -0.02259976f, 0.03471533f, -0.01979951f, -0.06356334f, -0.03235989f, 
    0.03445838f, 0.03209716f, -0.01857024f, 0.02245165f, -0.05329162f, -0.07460580f, -0.02594940f, 0.02226111f, 
    0.00594211f, -0.04731103f, -0.04375012f, -0.00394938f, 0.01489281f, -0.02435700f, -0.03137784f, -0.04979288f, 
    0.04785977f, -0.00976915f, -0.04222012f, -0.03987096f, -0.04828838f, -0.01615762f, 0.00367331f, -0.03785068f, 
    -0.07974347f, 0.05762152f, -0.04353158f, -0.06238882f, 0.02081317f, 0.03721292f, -0.06312350f, -0.05866774f, 
    -0.02125297f, -0.05214406f, 0.00835369f, -0.04663946f, -0.00924715f, 0.02357432f, -0.06562969f, -0.06956738f, 
    0.04077386f, -0.03015129f, -0.06775671f, 0.01218758f, -0.05062172f, 0.06027218f, -0.03002076f, 0.00609881f, 
    0.02941036f, -0.00640612f, 0.03715738f, -0.05232914f, -0.06540711f, 0.04858904f, 0.03881684f, -0.04400561f, 
    -0.03113328f, -0.00078028f, 0.01029705f, -0.05554703f, 0.02656591f, 0.02054973f, -0.00267106f, 0.02325825f, 
    -0.03443474f, 0.00706515f, -0.03676946f, 0.06333449f, 0.01646861f, -0.05178731f, -0.01839303f, 0.05779808f, 
    -0.03511664f, 0.01098323f, 0.05662375f, 0.05755612f, 0.02620052f, 0.06631094f, -0.04135156f, -0.00437221f, 
    -0.07086812f, -0.04729333f, -0.07049301f, 0.02268483f, -0.03810330f, -0.07256249f, 0.04121058f, 0.00731576f, 
    -0.05319771f, -0.04724509f, 0.00547548f, -0.02104807f, -0.03576613f, 0.05629033f, -0.05373781f, -0.04677650f, 
    0.00976520f, -0.06476104f, -0.06876493f, 0.00397419f, 0.02426118f, -0.04157908f, 0.04250176f, -0.03609643f, 
    -0.07665764f, 0.05963107f, -0.00427186f, 0.01472967f, -0.01472786f, 0.02413179f, 0.01315417f, -0.03029917f, 
    -0.05042295f, -0.02300062f, 0.06680500f, 0.02067997f, 0.02867914f, -0.04913617f, 0.03667946f, -0.07334246f, 
    -0.05121887f, -0.00647367f, -0.00235956f, 0.00521775f, -0.04319898f, 0.01923716f, -0.00269271f, -0.03373587f, 
    -0.03918006f, -0.02137435f, -0.00060448f, 0.05939143f, -0.04643979f, -0.07795715f, -0.05639505f, 0.03071980f, 
    0.08609337f, 0.00963702f, 0.06960768f, 0.00087753f, 0.03379807f, 0.05687668f, 0.01490114f, 0.01652109f, 
    0.03210721f, 0.11481276f, 0.09838898f, 0.04073269f, -0.07548981f, -0.04435150f, 0.20410141f, 0.11323385f, 
    0.11220706f, 0.00602283f, 0.02155033f, 0.17562573f, -0.03049084f, 0.16233344f, 0.07635440f, 0.00710607f, 
    0.15959026f, 0.19689992f, -0.03936341f, -0.08572261f, -0.12583622f, 0.08059612f, 0.08266138f, -0.04092187f, 
    -0.07251064f, 0.05600246f, 0.07262075f, -0.00312686f, -0.04494996f, 0.12389833f, 0.12098889f, 0.04493139f, 
    0.06962283f, -0.04836008f, 0.01306019f, 0.04077590f, -0.18254849f, -0.06999887f, 0.07822002f, -0.05066613f, 
    0.51145828f, -0.08042645f, 0.08821681f, 0.03916153f, 0.08640694f, 0.04003931f, 0.11212717f, 0.01247689f, 
    0.10322887f, -0.03159758f, 0.05558199f, 0.19071011f, -0.10150334f, -0.20232028f, -0.10903226f, 0.05881891f, 
    -0.08992656f, 0.04211912f, 0.10390376f, -0.03683212f, 0.07570781f, -0.11599009f, 0.01072075f, -0.04902755f, 
    -0.20357069f, 0.17093147f, -0.00210838f, 0.07988772f, -0.08115996f, -0.01352498f, 0.02506010f, -0.01056845f, 
    -0.07250916f, 0.12532365f, -0.05344219f, 0.05362545f, -0.21353485f, -0.08077710f, -0.13435051f, -0.01621274f, 
    -0.09371937f, 0.01171030f, -0.06645886f, -0.04263899f, 0.06736613f, -0.13411607f, -0.07646292f, -0.13896334f, 
    -0.16217831f, 0.15635471f, -0.12937801f, 0.03463994f, -0.03189546f, 0.00120472f, -0.01997669f, -0.05661584f, 
    -0.07906479f, -0.05179145f, -0.12423202f, 0.05896119f, 0.21701512f, -0.04272234f, 0.00868495f, 0.05508944f, 
    0.06075113f, -0.02458389f, 0.04070813f, -0.02007541f, 0.02054672f, -0.13469790f, -0.02108551f, -0.04713846f, 
    0.16722848f, 0.26945496f, -0.02262386f, 0.07623208f, -0.05523789f, -0.07483132f, -0.03358602f, 0.07253203f, 
    0.04447012f, -0.12893455f, -0.10785150f, -0.08489321f, -0.32577682f, 0.09363684f, 0.15846258f, 0.19038652f, 
    0.07641947f, 0.00555255f, 0.02329566f, 0.02269752f, -0.04897616f, -0.04283067f, 0.04965860f, 0.05017469f, 
    0.12187401f, -0.05184358f, 0.05724105f, -0.03887011f, -0.01499633f, 0.04544367f, 0.02481080f, 0.02461108f, 
    -0.11763772f, -0.07709239f, 0.07795441f, -0.05984230f, -0.01972718f, 0.08003717f, 0.00499476f, 0.07823216f, 
    0.22701037f, 0.06797390f, -0.01043744f, 0.00591245f, -0.05406251f, 0.04663488f, 0.01143786f, 0.07431341f, 
    0.16363682f, 0.21517681f, -0.14328241f, -0.08898155f, 0.07854549f, -0.02840167f, 0.03675796f, 0.03211756f, 
    -0.10554984f, 0.09244604f, -0.02141653f, 0.15377934f, 0.06380726f, 0.07793856f, 0.00899625f, -0.09957737f, 
    -0.15394776f, -0.05947182f, 0.00874747f, 0.02919912f, -0.09425697f, 0.18866181f, 0.02471611f, 0.10884106f, 
    -0.28074563f, -0.05316626f, 0.05455939f, 0.01618298f, 0.06362894f, 0.10541707f, 0.06652317f, 0.07193326f, 
    0.02385065f, 0.07893678f, 0.05749524f, 0.08562195f, 0.13626903f, -0.12529288f, -0.08937609f, 0.02092887f, 
    -0.11288515f, -0.13623331f, 0.01063870f, 0.06233363f, 0.02162456f, 0.08630317f, -0.00370728f, 0.03699882f, 
    0.59766203f, -0.08096863f, -0.21457225f, -0.00305736f, 0.14396639f, 0.03083053f, 0.01161803f, 0.07642522f, 
    0.00524048f, 0.03257303f, 0.04775027f, 0.09875456f, 0.23895770f, -0.26239833f, -0.05374645f, -0.04074869f, 
    0.07080480f, -0.03477978f, 0.00775720f, 0.11177145f, -0.17186961f, 0.07961735f, -0.07193556f, -0.10678162f, 
    -0.14094874f, 0.18999133f, -0.02404065f, -0.06286728f, -0.01807105f, 0.08284605f, -0.07717167f, 0.18345140f, 
    -0.05221110f, 0.03948605f, -0.12316543f, 0.13704222f, -0.19917779f, -0.06878871f, 0.20262574f, 0.09773025f, 
    0.11908796f, 0.05158036f, 0.14161484f, 0.06425161f, -0.03957238f, -0.13416384f, -0.11230202f, -0.12516201f, 
    0.14070624f, 0.06390499f, 0.10063077f, 0.02474291f, 0.00985349f, -0.07449882f, -0.04980468f, 0.05303667f, 
    0.04550791f, 0.14478508f, -0.07232492f, -0.03334900f, -0.04055068f, 0.11712402f, -0.05299186f, 0.15639137f, 
    0.02418215f, 0.09648590f, 0.00101912f, 0.02011325f, 0.08284901f, -0.03520101f, 0.06316508f, -0.10111745f, 
    0.23353991f, -0.07880099f, -0.16173196f, 0.05457651f, -0.01592625f, 0.01222602f, 0.09259442f, -0.04745096f, 
    -0.09409828f, -0.01072379f, 0.07957270f, -0.01505881f, -0.38309556f, 0.15973562f, 0.19568203f, 0.01685087f, 
    -0.10375956f, -0.02626309f, 0.00580916f, 0.01680030f, -0.00003071f, -0.17446373f, -0.04408744f, -0.14223920f, 
    0.26205516f, -0.19184686f, 0.06900669f, 0.27660465f, -0.06617165f, -0.05266477f, -0.01233505f, 0.02623367f, 
    0.10113465f, -0.04112571f, -0.10915218f, -0.08997185f, -0.11779292f, -0.06481612f, -0.01460976f, -0.02863819f, 
    0.04740995f, -0.06911620f, 0.06496932f, -0.08539688f, 0.05659127f, -0.03716616f, 0.02908709f, 0.08548360f, 
    0.30735764f, 0.09663025f, -0.19689280f, -0.02990347f, -0.04880873f, 0.07297263f, 0.03252243f, 0.06612242f, 
    -0.02604005f, -0.03800265f, -0.03480535f, 0.01817064f, -0.37403485f, -0.05693506f, -0.09184347f, 0.04281512f, 
    0.05468421f, 0.03102125f, -0.04143585f, -0.07214878f, -0.00982175f, 0.09865395f, 0.07059195f, -0.05639016f, 
    0.33433694f, -0.13613541f, 0.05957589f, 0.09665757f, 0.02631898f, 0.14503916f, -0.00055129f, -0.04328736f, 
    0.02903388f, 0.03716625f, 0.08743359f, 0.09516592f, 0.24882284f, -0.11949773f, -0.11442652f, 0.10352428f, 
    0.00138329f, 0.06548954f, 0.12630042f, 0.08242822f, 0.02539181f, 0.21396655f, 0.05822736f, 0.01608239f, 
    0.02147573f, -0.02437405f, -0.07979601f, -0.04095658f, -0.02635317f, -0.06702486f, -0.00516868f, 0.03210806f, 
    0.03214538f, -0.04013775f, -0.01296566f, -0.07129757f, 0.04607487f, -0.04401285f, -0.00346811f, -0.01791451f, 
    0.06045884f, -0.02271595f, -0.05126468f, -0.07497628f, -0.09425831f, 0.00382260f, 0.03530454f, -0.04366784f, 
    -0.01480946f, -0.02578052f, -0.09478509f, 0.00999933f, 0.02136900f, -0.04628817f, 0.00982696f, -0.03553873f, 
    -0.05945575f, 0.02091931f, 0.01059320f, -0.04866181f, 0.01172630f, -0.00962075f, 0.01797557f, -0.01015567f, 
    -0.02662423f, 0.01403578f, -0.03338711f, 0.02534120f, -0.06158204f, -0.07106590f, -0.07895552f, -0.01590081f, 
    0.03828916f, -0.00876128f, -0.01476568f, -0.01958306f, -0.01965867f, -0.02081807f, 0.02815221f, -0.04761306f, 
    0.00935379f, 0.05176621f, -0.02499362f, -0.07686876f, 0.06314694f, -0.01316547f, 0.03699854f, 0.01052543f, 
    -0.08295926f, -0.00918116f, -0.03198186f, -0.03315685f, -0.08737427f, 0.02855459f, -0.04694472f, -0.07742417f, 
    0.01301535f, -0.06194028f, -0.06628868f, -0.00554014f, -0.06926156f, -0.04038142f, 0.01142525f, 0.01326140f, 
    0.05442913f, -0.01252811f, -0.06137871f, -0.07046542f, -0.03140890f, -0.04472504f, 0.06044118f, 0.07717765f, 
    0.04469856f, 0.01363982f, -0.07827623f, -0.04681826f, 0.04733569f, -0.03382257f, 0.05551738f, 0.01472806f, 
    -0.06500876f, 0.01082809f, 0.02274108f, -0.06653548f, 0.02399504f, -0.03565986f, 0.02457155f, 0.06804479f, 
    -0.03913054f, -0.05646609f, -0.05030766f, -0.06415727f, 0.00730254f, -0.03992945f, 0.06254557f, 0.07500091f, 
    -0.04820080f, 0.01525131f, 0.02785697f, 0.04154109f, -0.05027463f, -0.04048595f, -0.05280902f, 0.04114759f, 
    0.01242017f, -0.06417154f, 0.03498326f, 0.05583705f, 0.06093543f, 0.08002857f, 0.05199095f, 0.04593598f, 
    -0.04182691f, 0.04105636f, 0.04244172f, -0.01140679f, -0.03830744f, -0.06118365f, 0.05636334f, 0.00690478f, 
    0.01506682f, -0.05951237f, -0.04596959f, -0.08478988f, 0.06867854f, -0.04053553f, 0.01700978f, -0.00086875f, 
    -0.06241353f, -0.05996813f, -0.01591588f, -0.01276174f, -0.06968939f, 0.03920272f, -0.00097751f, -0.02936938f, 
    -0.06299556f, -0.03563927f, -0.03577821f, 0.01601705f, 0.03878785f, 0.04592282f, 0.01201729f, -0.05085631f, 
    -0.03184773f, 0.02158401f, 0.05694979f, -0.03154022f, -0.00397177f, -0.07200641f, -0.02383233f, -0.02139112f, 
    0.02095817f, -0.00284964f, -0.06835505f, -0.00902868f, 0.00556267f, -0.00669457f, 0.00556411f, 0.01777045f, 
    -0.04389035f, -0.02038783f, -0.02978741f, -0.05427219f, 0.06265658f, 0.05930045f, -0.01865239f, -0.06640169f, 
    -0.07922268f, 0.02742349f, -0.09531893f, -0.02572243f, -0.02081680f, -0.04456420f, 0.03877123f, -0.11582828f, 
    0.38407671f, 0.10682957f, -0.00429640f, -0.06976373f, 0.02561919f, -0.05659448f, -0.02338614f, -0.06402911f, 
    -0.08500799f, 0.02922553f, -0.04596092f, -0.08060069f, 0.26234233f, 0.08455896f, 0.02661268f, -0.11660174f, 
    0.02909999f, 0.16223750f, -0.03627146f, 0.02115738f, -0.00018392f, -0.06430548f, 0.15054645f, -0.13158424f, 
    0.19673328f, 0.02418264f, 0.00975703f, -0.05465684f, -0.04947438f, -0.08888596f, -0.10298946f, -0.07334285f, 
    0.00662205f, 0.05583451f, -0.07443580f, 0.08053620f, -0.25380328f, 0.05923184f, 0.04482853f, -0.06519198f, 
    -0.08308189f, 0.00794687f, 0.11054569f, -0.12239431f, -0.02676213f, 0.06315634f, 0.00374739f, -0.07347208f, 
    0.12458856f, -0.28349766f, 0.07956862f, -0.08983365f, 0.11816686f, 0.01705291f, -0.07399090f, 0.03325151f, 
    -0.07064421f, -0.01574988f, 0.04240877f, -0.11700943f, 0.23888347f, -0.16807307f, -0.33612067f, 0.08615961f, 
    -0.02105742f, 0.17806984f, -0.06295674f, -0.05790455f, -0.00073851f, -0.04402184f, 0.15688317f, 0.09614152f, 
    0.12677106f, -0.35562259f, 0.06060950f, 0.02416865f, -0.04246087f, 0.06686570f, 0.12048258f, 0.03521626f, 
    0.07743353f, 0.02636599f, 0.18400630f, -0.00634173f, -0.07563715f, 0.04565788f, -0.07836116f, -0.03053097f, 
    -0.09556507f, -0.01863599f, -0.01416213f, 0.02441208f, -0.04457413f, 0.09794108f, -0.01301987f, -0.07408326f, 
    0.03937180f, -0.09776499f, 0.09152990f, 0.20846236f, -0.13576193f, -0.11397240f, -0.04491198f, -0.23503290f, 
    -0.01118862f, 0.08672612f, -0.06401900f, -0.09174411f, 0.04490974f, 0.04837601f, -0.01985548f, 0.04352044f, 
    0.04522544f, 0.05366040f, -0.08535539f, 0.01057593f, -0.02200720f, 0.04258863f, -0.12714422f, 0.12831943f, 
    0.06617226f, -0.17247437f, 0.04225890f, 0.04491419f, -0.00811409f, -0.10534310f, 0.00167113f, -0.05306209f, 
    -0.10932569f, 0.17060171f, 0.00828761f, 0.13800502f, 0.21499798f, 0.34261262f, -0.08807278f, -0.03851574f, 
    -0.07481989f, -0.00396834f, 0.05354871f, 0.09900666f, 0.16575353f, -0.00916608f, -0.10700344f, 0.11260260f, 
    0.18712407f, -0.07117124f, 0.38651860f, -0.13021080f, -0.03157534f, -0.16069475f, 0.09447692f, -0.10361525f, 
    0.13386735f, 0.17914042f, -0.04681076f, 0.08314520f, 0.01204897f, 0.11686047f, 0.04127836f, -0.01088270f, 
    -0.08684433f, -0.05692961f, -0.04085771f, 0.01753286f, 0.03645870f, 0.11569972f, 0.00548094f, -0.00648232f, 
    0.14924158f, 0.01002665f, 0.17498921f, 0.23998144f, -0.10148878f, 0.05619744f, 0.02259745f, -0.09417289f, 
    0.11641071f, 0.09877247f, 0.00860526f, -0.07599555f, -0.09438771f, 0.11805880f, 0.02577210f, -0.12391592f, 
    0.16274752f, -0.01847512f, -0.06271069f, 0.12735566f, 0.09204598f, -0.07115388f, 0.06183450f, -0.07945341f, 
    0.13909799f, 0.08828552f, 0.05255929f, -0.00342443f, -0.04786782f, -0.02851790f, -0.02327493f, -0.01108916f, 
    -0.07307031f, -0.00177773f, 0.04076103f, 0.07564586f, -0.22062171f, -0.29622412f, -0.19121975f, 0.02664436f, 
    0.10324399f, 0.12473658f, -0.05792686f, -0.06109264f, -0.06014068f, -0.07906289f, 0.01892105f, -0.13485771f, 
    -0.11730404f, -0.17668794f, 0.13045280f, 0.10033824f, 0.06105023f, 0.06481848f, -0.10734817f, -0.01621301f, 
    -0.03684585f, -0.11270995f, 0.01234270f, 0.04219399f, -0.02051128f, 0.00273291f, -0.05758467f, -0.04716148f, 
    0.10186197f, 0.11595666f, 0.01732314f, 0.01025475f, 0.05386500f, 0.09112245f, 0.00516910f, 0.04739069f, 
    -0.75060165f, -0.16648284f, -0.21292859f, 0.12897201f, -0.09505583f, -0.07620667f, 0.15560311f, -0.01209402f, 
    0.01383430f, 0.10261083f, -0.03582695f, -0.10685517f, -0.11667452f, 0.12938133f, 0.12446986f, -0.15267283f, 
    0.00707505f, 0.05512578f, -0.10462388f, 0.09269571f, 0.07100670f, 0.05104212f, 0.00609949f, 0.18679143f, 
    -0.19981001f, -0.01136996f, -0.03537417f, -0.08862323f, 0.05577414f, -0.03755688f, -0.07587782f, 0.01187473f, 
    0.11248564f, -0.09465603f, 0.05242289f, -0.01889036f, 0.05937148f, 0.11626755f, -0.01317877f, 0.18074276f, 
    -0.01310064f, -0.07448277f, 0.11817993f, 0.13950419f, 0.04360247f, 0.24029802f, 0.11156203f, 0.09188908f, 
    0.25864369f, 0.08263368f, 0.17952177f, -0.10810734f, -0.00582972f, 0.01455999f, -0.02692711f, 0.08468968f, 
    0.14730467f, 0.08043284f, 0.21113171f, 0.06954028f, 0.20787896f, 0.16873968f, -0.02008195f, 0.00333506f, 
    0.09910199f, 0.10781193f, 0.03136590f, 0.10598265f, -0.03282958f, 0.10723356f, 0.06391466f, 0.05170830f, 
    0.19404575f, 0.13856006f, 0.14937842f, -0.01726839f, -0.09215824f, -0.01424825f, -0.02207307f, -0.11362416f, 
    -0.02190524f, -0.00860973f, 0.10187329f, 0.10710438f, -0.04766604f, -0.14749630f, -0.29420921f, 0.03133951f, 
    0.03132153f, 0.05818787f, 0.03148726f, 0.02884908f, 0.00006590f, -0.00791806f, -0.16076788f, -0.08881974f, 
    0.01633553f, -0.03601765f, -0.09050225f, 0.23100543f, -0.03729225f, -0.10868392f, 0.05514180f, -0.11381411f, 
    0.00762737f, 0.03585026f, 0.01943594f, -0.02134408f, -0.22412133f, 0.02259336f, -0.05850043f, 0.09580971f, 
    -0.05434490f, 0.01830551f, -0.06147075f, 0.01646698f, -0.00940937f, -0.03347415f, 0.01352881f, 0.02874828f, 
    0.07608690f, 0.02208528f, 0.17540863f, 0.01657917f, -0.00863374f, -0.07556043f, -0.07425480f, -0.09777921f, 
    0.17729035f, -0.02950573f, 0.09645253f, -0.00984515f, 0.15856774f, 0.10323291f, 0.04091840f, 0.03290376f, 
    0.00094387f, 0.18436581f, 0.04183832f, 0.02206771f, -0.01673178f, -0.12640518f, 0.03538026f, -0.11815495f, 
    0.19329783f, -0.00353150f, 0.00749088f, -0.13338104f, -0.01216147f, -0.05612293f, -0.16042705f, -0.15328100f, 
    0.07844749f, -0.06986255f, -0.06805474f, -0.03502503f, -0.04711533f, 0.23999491f, 0.10618602f, 0.09925000f, 
    0.13189818f, 0.06940147f, -0.02756647f, -0.00387271f, 0.05742352f, -0.17682201f, 0.00530355f, -0.06279127f, 
    -0.29581493f, 0.01699469f, -0.10062401f, 0.00314551f, -0.05523091f, 0.03753225f, -0.08631934f, -0.03236198f, 
    -0.05158844f, 0.05286156f, -0.03975103f, -0.10298745f, -0.04289638f, 0.21799915f, 0.02654908f, 0.06935681f, 
    -0.03598273f, -0.04307116f, 0.11904436f, 0.12187642f, 0.16790742f, 0.10358197f, 0.10675647f, 0.12751192f, 
    -0.25076002f, -0.19821963f, 0.14730750f, -0.04182492f, 0.11268352f, -0.06675483f, 0.00445989f, -0.00182163f, 
    0.13999532f, -0.11626412f, 0.11608425f, 0.05372045f, -0.04625860f, 0.02665704f, -0.13417624f, -0.13154642f, 
    -0.03391525f, -0.07529090f, -0.11967526f, -0.06793957f, 0.10359529f, 0.10538957f, 0.22533990f, 0.09729828f, 
    -0.24605134f, -0.02311040f, 0.07826742f, 0.06580690f, -0.06462093f, 0.02864650f, 0.08555521f, 0.12214930f, 
    0.01099138f, -0.08211932f, 0.15895784f, 0.11241093f, 0.03198228f, -0.01936423f, -0.06893823f, 0.04285508f, 
    -0.01067260f, -0.12089355f, 0.07469464f, -0.03806750f, 0.11144441f, 0.24965104f, -0.09281316f, 0.07986420f, 
    -0.37521204f, 0.06221053f, -0.02927517f, -0.09008158f, 0.10635038f, -0.01006643f, -0.05395785f, 0.02593420f, 
    0.00932986f, 0.06605402f, -0.02776624f, 0.01626174f, 0.15552032f, -0.03515900f, -0.02542129f, 0.02952331f, 
    0.08245009f, 0.05785641f, -0.11328909f, -0.03923075f, -0.04227078f, 0.09110387f, 0.12255318f, 0.25156829f, 
    0.00784864f, 0.04641621f, -0.16773835f, -0.04526205f, 0.25490707f, 0.16307265f, 0.11000755f, -0.05056631f, 
    -0.10421298f, -0.01350628f, 0.03088437f, 0.15440841f, 0.07164834f, 0.26284400f, -0.04979936f, 0.10246481f, 
    -0.06301130f, 0.00426075f, 0.01928598f, 0.07174946f, 0.09458759f, 0.02677273f, -0.09827089f, -0.07145460f, 
    -0.05732448f, -0.02469860f, -0.03841789f, 0.11969872f, -0.04445780f, -0.07670976f, -0.13302815f, 0.01738281f, 
    0.08135016f, -0.02172601f, -0.05664899f, 0.06641496f, 0.39705771f, 0.12597680f, 0.12207397f, 0.03201091f, 
    -0.02125831f, -0.09499504f, -0.04750976f, 0.09723596f, 0.01080093f, 0.09278672f, 0.08623414f, -0.01770702f, 
    -0.23980865f, -0.06255653f, -0.21921398f, 0.16641259f, -0.04298137f, -0.01608361f, 0.06357454f, -0.09181464f, 
    0.06139686f, -0.09490420f, 0.11290570f, -0.02820546f, -0.08214714f, 0.32135880f, 0.23336688f, -0.20748670f, 
    0.03314870f, -0.01515603f, -0.21392725f, 0.08062892f, 0.11025129f, -0.12497894f, -0.01547203f, 0.03372603f, 
    0.06243293f, -0.01245895f, -0.00927541f, -0.09466890f, -0.03532764f, 0.00339582f, -0.06517250f, -0.07046857f, 
    0.04461215f, 0.00758110f, 0.15980588f, -0.09577306f, 0.01493439f, 0.47798949f, 0.00458739f, -0.00703046f, 
    0.01366437f, 0.11246921f, 0.13090511f, -0.01293727f, 0.12267410f, -0.03044708f, -0.03365333f, 0.07435878f, 
    -0.11446427f, 0.33631042f, -0.00910379f, -0.05512372f, -0.15568992f, 0.04730263f, 0.04924273f, -0.12495583f, 
    -0.13472909f, -0.00281037f, -0.05729298f, 0.00153097f, -0.36545688f, -0.00483969f, 0.06885735f, -0.10290532f, 
    0.01277348f, -0.06607962f, -0.04721067f, -0.19021983f, 0.02565158f, 0.09922623f, -0.04050878f, -0.05672096f, 
    0.65986675f, 0.02936161f, -0.10239651f, 0.00590295f, 0.12087919f, -0.09442785f, 0.11362864f, -0.05214595f, 
    -0.14261854f, -0.04628523f, -0.06201071f, 0.09092769f, 0.10138769f, -0.02184264f, 0.00192878f, 0.21208462f, 
    0.12901586f, -0.06102176f, -0.16546728f, 0.08826384f, -0.10812714f, -0.06668912f, -0.06461605f, 0.11968835f, 
    0.35892576f, 0.02037213f, 0.20288779f, 0.27267772f, 0.07723935f, -0.07942292f, -0.06846096f, 0.10034202f, 
    -0.04542768f, 0.12522206f, 0.01442103f, -0.02785604f, 0.04883273f, -0.00706277f, 0.21949361f, 0.05156128f, 
    -0.00462534f, -0.03501037f, -0.03601773f, -0.04558724f, 0.06812891f, -0.10951709f, -0.01360578f, 0.02279070f, 
    -0.24772826f, 0.11261955f, -0.15488681f, 0.10653346f, 0.02234652f, -0.05054515f, -0.08056814f, -0.10385431f, 
    -0.07015783f, -0.08942656f, -0.10040283f, -0.01098641f, -0.14830570f, -0.01469076f, 0.07359683f, -0.08494050f, 
    -0.11258183f, 0.00608056f, -0.14564359f, -0.08141804f, -0.05766091f, 0.01349137f, -0.07180443f, -0.08874499f, 
    0.05874440f, -0.26863593f, -0.07520926f, 0.04341534f, 0.07264511f, -0.10804752f, -0.06895852f, -0.10542860f, 
    0.06073293f, -0.08354043f, -0.20241089f, -0.03717597f, -0.04843871f, 0.45894036f, 0.04554779f, -0.14120565f, 
    0.13254493f, 0.02046101f, 0.04148649f, 0.02077360f, 0.07144233f, 0.08623043f, 0.11616307f, -0.00994492f, 
    0.00928997f, -0.01753413f, 0.17572957f, 0.00088945f, 0.16841857f, -0.15287669f, -0.00231138f, 0.08429825f, 
    0.01420163f, -0.03044406f, -0.01242905f, 0.03183389f, -0.01867524f, 0.15545069f, -0.17658739f, -0.27600741f, 
    -0.03096187f, 0.01110700f, 0.01790183f, -0.05556332f, 0.05212685f, -0.08709539f, -0.10384326f, 0.09252010f, 
    0.21806923f, 0.15707642f, 0.19608365f, 0.19709703f, 0.04727598f, 0.09435631f, -0.01584829f, -0.08048289f, 
    0.02261643f, 0.09282716f, 0.05128101f, 0.02485016f, -0.14028612f, -0.05053323f, 0.05811112f, 0.22373201f, 
    0.07577775f, 0.01967791f, 0.25595137f, -0.07523321f, -0.08383579f, 0.04888109f, 0.07429270f, 0.09790100f, 
    -0.01514165f, 0.04901483f, 0.04152572f, -0.07408863f, 0.04483679f, -0.05011544f, -0.00740035f, 0.00301226f, 
    -0.00214100f, -0.05739488f, -0.02163542f, -0.05738096f, -0.03783776f, 0.03800937f, -0.02372297f, -0.05673571f, 
    0.04945925f, 0.03921479f, -0.04371793f, 0.03448341f, -0.07724950f, 0.05598596f, 0.00053855f, 0.04272898f, 
    0.01700017f, -0.06729244f, -0.04946787f, 0.00271521f, -0.05588914f, -0.05995561f, -0.00246549f, 0.03912210f, 
    0.02523246f, -0.05304445f, 0.03559869f, -0.03274973f, -0.02182911f, -0.02011242f, -0.02021222f, 0.00564194f, 
    0.05377392f, -0.02286583f, 0.04177508f, -0.05997014f, -0.01156212f, 0.04828773f, -0.06384412f, 0.02279141f, 
    -0.06459100f, 0.00824591f, -0.05699416f, 0.02458602f, -0.05163014f, -0.04155547f, -0.02607865f, 0.02538550f, 
    -0.06317257f, 0.01703897f, 0.01425077f, 0.02143005f, -0.03575426f, 0.03360438f, 0.02412990f, -0.03116246f, 
    -0.03584674f, -0.01554719f, 0.01827952f, 0.04397290f, 0.03882682f, -0.04817543f, -0.07145084f, -0.06701365f, 
    -0.06091189f, 0.02505641f, -0.04173573f, -0.05699404f, 0.00989088f, -0.01997843f, 0.03804649f, 0.03826199f, 
    -0.06860322f, -0.02869673f, -0.04692280f, 0.04347166f, -0.01199861f, -0.03087652f, 0.02763765f, -0.06329087f, 
    -0.02348133f, -0.07406811f, -0.07473862f, 0.04869159f, -0.01903841f, 0.02685867f, 0.01302259f, 0.02136294f, 
    0.01139412f, 0.05209847f, -0.06182756f, -0.04466688f, -0.03817419f, -0.02327982f, -0.07339921f, 0.03984798f, 
    0.02956540f, -0.04285710f, 0.05855263f, -0.07333767f, -0.06871650f, -0.07475191f, -0.00368123f, -0.04525841f, 
    -0.02103266f, 0.04835683f, 0.00050969f, 0.05151771f, 0.01789724f, 0.00334722f, 0.05934680f, -0.02002042f, 
    -0.00670600f, -0.02857774f, -0.04020973f, -0.07074580f, 0.05266899f, -0.01323994f, 0.02148020f, -0.06051682f, 
    -0.01862140f, -0.03268674f, 0.03113683f, 0.00621508f, 0.06008328f, -0.02735925f, 0.03751412f, -0.00878827f, 
    -0.05238092f, 0.05943782f, -0.01855553f, 0.02522135f, 0.01883105f, -0.02434138f, 0.05039884f, 0.03774985f, 
    0.03883755f, -0.03946166f, -0.01819629f, 0.00754287f, 0.00302361f, 0.00168612f, 0.05574541f, 0.02623738f, 
    -0.02725016f, 0.05145903f, -0.06661505f, 0.02310490f, 0.01065777f, -0.04789405f, -0.02496391f, 0.02278751f, 
    -0.04221249f, 0.01745537f, 0.04732744f, -0.00008557f, -0.03694118f, -0.04772570f, -0.07408316f, -0.01808210f, 
    0.02330280f, -0.03285103f, 0.01908112f, 0.04487519f, -0.02085570f, 0.01512848f, 0.05868653f, -0.03537227f, 
    0.01587701f, 0.01546853f, 0.02398500f, -0.04727664f, 0.03366429f, 0.00513410f, -0.07185578f, 0.02010267f, 
    0.03663109f, -0.02895563f, -0.07168824f, -0.04942674f, -0.05671621f, -0.05702569f, -0.05062959f, 0.00116584f, 
    -0.07633389f, -0.07094607f, -0.12119249f, -0.28243983f, 0.04984910f, 0.16524228f, -0.03845377f, 0.03874055f, 
    0.15453389f, 0.13034129f, 0.00757313f, 0.07665458f, -0.14455204f, 0.28313065f, 0.16702834f, 0.20716248f, 
    0.01916640f, 0.10322027f, 0.10778148f, 0.13141055f, 0.05588717f, 0.10309537f, -0.01005384f, 0.05057540f, 
    -0.52283603f, 0.02100537f, -0.00475080f, -0.31843144f, -0.07650968f, -0.08835557f, 0.01049985f, -0.01692957f, 
    0.10320868f, -0.00099197f, 0.22562012f, -0.05856235f, 0.04148749f, -0.06323394f, 0.06051652f, 0.13530184f, 
    0.04635267f, 0.02473110f, 0.03499350f, 0.08612935f, -0.03513167f, 0.05046275f, 0.06671390f, 0.04541879f, 
    -0.06047967f, 0.05977403f, -0.11888094f, 0.02547282f, 0.13627048f, 0.05979929f, -0.07124904f, 0.02735860f, 
    0.10831240f, 0.05554736f, 0.01617177f, -0.01249569f, 0.04951859f, 0.20431948f, 0.21572030f, 0.01475670f, 
    0.23345888f, -0.03629694f, -0.02084047f, 0.08738934f, 0.03644120f, -0.07565190f, 0.06817248f, 0.08806796f, 
    0.31775585f, 0.17848589f, 0.07630732f, 0.16280773f, 0.17491664f, 0.04490439f, 0.11828104f, 0.06778549f, 
    -0.14492223f, -0.08070213f, 0.14007874f, 0.09277888f, 0.07262494f, 0.21818860f, 0.09083523f, 0.13073441f, 
    0.06573307f, 0.10432394f, 0.06590406f, 0.03728815f, 0.03289542f, -0.00327904f, -0.23659934f, -0.00268701f, 
    -0.39500186f, 0.20456865f, -0.48814583f, -0.34436369f, 0.13240075f, -0.03458850f, -0.06245926f, 0.08263589f, 
    -0.00606646f, -0.07864032f, 0.04704571f, 0.19344749f, -0.22695790f, -0.13794498f, -0.16208859f, -0.23288120f, 
    -0.03192138f, -0.00196104f, -0.10000958f, -0.01775571f, -0.04918791f, -0.05936973f, -0.12994267f, 0.12960944f, 
    -0.30828586f, -0.12048122f, -0.03919403f, -0.18038619f, -0.02887302f, -0.12282296f, -0.04237516f, -0.04188761f, 
    -0.10793902f, -0.01566056f, 0.02831655f, -0.03447519f, -0.04523767f, 0.00374724f, 0.29183882f, 0.31661001f, 
    -0.06222921f, 0.09715251f, -0.00533477f, 0.04891442f, -0.03989241f, 0.04336840f, 0.14177972f, 0.03993662f, 
    -0.16547830f, -0.05644534f, -0.32301745f, -0.02598101f, 0.00766241f, 0.01308884f, 0.00638599f, 0.00320341f, 
    -0.05479478f, 0.05791391f, 0.02594994f, -0.03748316f, -0.38624233f, -0.20985034f, 0.02292192f, 0.00840681f, 
    -0.06860744f, 0.01408806f, 0.01182116f, 0.06860435f, 0.03520751f, -0.01793564f, -0.10609053f, 0.04306016f, 
    -0.07491148f, 0.05079873f, -0.13655448f, -0.18345976f, -0.00558523f, -0.06171264f, -0.07086990f, -0.02096450f, 
    -0.00634031f, 0.01104491f, 0.19592388f, -0.15264091f, -0.06381749f, -0.11990542f, 0.04763779f, 0.33971468f, 
    -0.22622426f, 0.04353461f, 0.16866298f, -0.10967167f, -0.11288473f, 0.02788125f, 0.05856841f, -0.00938583f, 
    0.24167407f, 0.03024707f, 0.15474616f, 0.24588443f, -0.00625060f, 0.15756451f, -0.06569487f, -0.14922503f, 
    -0.11424528f, 0.02541047f, -0.07741699f, -0.16077188f, -0.35439247f, 0.15827705f, -0.11731183f, 0.02286686f, 
    0.13116917f, 0.02683827f, -0.05349179f, -0.14589743f, 0.08277716f, -0.09182306f, 0.15755300f, -0.06348950f, 
    -0.13397492f, 0.16312701f, -0.10050669f, -0.07765420f, 0.03655642f, 0.11801040f, 0.04094988f, 0.13454196f, 
    -0.03615148f, 0.00524543f, 0.03364229f, -0.10729354f, 0.08894010f, 0.16130988f, 0.01760894f, 0.10422990f, 
    -0.09597775f, -0.02017236f, 0.07883038f, 0.08249367f, 0.06314592f, 0.09687478f, -0.11220003f, 0.18452398f, 
    -0.25888070f, -0.06746818f, 0.17511474f, -0.18525891f, -0.06399303f, -0.18407302f, 0.15807289f, -0.05526665f, 
    0.01784381f, -0.08352908f, -0.11862861f, -0.09468585f, -0.26680028f, -0.08741833f, 0.04911255f, 0.13516423f, 
    -0.02964492f, 0.01810786f, -0.03251762f, -0.00398754f, 0.16237320f, 0.06835326f, 0.14239573f, 0.11226174f, 
    0.02716758f, -0.10050836f, 0.15925799f, 0.14017160f, -0.01137456f, -0.07281986f, -0.01474304f, 0.06479821f, 
    0.02300438f, -0.08590081f, 0.08729095f, 0.23134461f, 0.02445299f, -0.15401106f, 0.25455850f, 0.04134690f, 
    -0.00631761f, -0.06295990f, 0.09824208f, -0.16354294f, -0.11983252f, 0.10918377f, -0.04979983f, 0.12836784f, 
    -0.18569152f, 0.21627329f, 0.07575058f, 0.10972224f, -0.07145279f, -0.00797391f, 0.02228245f, -0.08470624f, 
    0.06626745f, 0.03868161f, 0.09292133f, -0.11677939f, 0.01578487f, 0.04112582f, 0.04120931f, -0.05056073f, 
    0.11552645f, -0.04988579f, -0.03455468f, -0.00443084f, 0.11200284f, 0.10705217f, -0.02930781f, 0.03019162f, 
    0.00614080f, -0.06792163f, 0.03014310f, -0.03127078f, -0.08146907f, 0.12460697f, 0.08062969f, -0.03789263f, 
    -0.02786741f, -0.14866930f, 0.07405058f, 0.06599966f, -0.05107965f, 0.00819280f, -0.05764517f, -0.15989572f, 
    0.14716060f, 0.09474340f, 0.07189982f, 0.11823163f, 0.05498889f, -0.00061925f, -0.01647075f, 0.10538603f, 
    0.10301809f, 0.13788849f, 0.02375929f, -0.11075817f, -0.14267498f, -0.13197093f, -0.04824001f, 0.09584165f, 
    0.00405674f, 0.02420855f, -0.01471326f, 0.06001059f, 0.08340095f, 0.17037578f, -0.14408740f, 0.00098873f, 
    -0.12691644f, 0.02295075f, -0.02664397f, -0.07144850f, 0.01400278f, 0.05470532f, 0.05192994f, 0.07854377f, 
    0.12992886f, 0.03083174f, 0.25064868f, 0.29605606f, -0.10092483f, 0.03826988f, 0.04703867f, 0.08534644f, 
    0.08549597f, -0.24737583f, 0.08564311f, 0.06669825f, 0.04182841f, -0.15468054f, 0.02725279f, -0.16464074f, 
    -0.05738728f, 0.11005317f, 0.01353474f, 0.10099769f, -0.06762069f, -0.07411259f, -0.04822022f, -0.11046709f, 
    0.11597738f, -0.05491307f, 0.07917053f, 0.13926227f, -0.02948374f, 0.13975644f, 0.00101789f, 0.05139148f, 
    -0.01005279f, 0.05008438f, -0.01667016f, -0.00076229f, 0.22269936f, -0.19043535f, -0.10083051f, 0.00929478f, 
    0.06684140f, -0.11370607f, -0.00397621f, 0.17487705f, -0.07706409f, 0.16958672f, -0.00965736f, 0.12715228f, 
    0.15102591f, -0.32264653f, -0.04485676f, -0.01471223f, 0.12376500f, 0.04181862f, -0.00085071f, 0.03936650f, 
    -0.07837903f, -0.04351201f, -0.01864638f, 0.02004455f, 0.10878301f, -0.28737235f, 0.07371800f, -0.08558386f, 
    0.03687179f, 0.08347723f, -0.05588223f, 0.01800899f, -0.10603584f, 0.02103984f, -0.07433964f, -0.05714988f, 
    -0.16408129f, 0.03235795f, -0.02617607f, -0.20515634f, -0.02975923f, -0.02752667f, -0.02761413f, -0.04345259f, 
    0.02376539f, 0.01527669f, -0.05215665f, -0.08001329f, 0.11021499f, -0.00555189f, 0.12461343f, 0.24139775f, 
    -0.02515848f, 0.01273460f, -0.01762590f, 0.06487130f, -0.02666814f, -0.07582617f, 0.05843885f, -0.05747555f, 
    0.18832016f, -0.15967974f, -0.00298317f, -0.03428653f, -0.11840412f, -0.05588824f, -0.09738961f, 0.05112543f, 
    0.05720448f, -0.01341949f, -0.01324894f, -0.05350454f, -0.03718932f, 0.19243811f, 0.12117876f, -0.23498058f, 
    0.14039670f, 0.14318936f, 0.04275799f, 0.00422617f, -0.05171909f, 0.00286106f, 0.01230347f, -0.14624150f, 
    0.06615591f, -0.12352669f, 0.06443166f, 0.02505819f, 0.09956518f, 0.12294993f, 0.06561761f, 0.08016980f, 
    -0.00838097f, -0.02799397f, 0.16339821f, 0.03095539f, 0.10241742f, 0.11185996f, -0.10252023f, -0.13012512f, 
    0.05725463f, -0.02523415f, 0.08381568f, 0.01498168f, 0.09513210f, -0.01972126f, 0.01674490f, 0.05976880f, 
    0.04615469f, -0.04301815f, 0.19697779f, 0.16594270f, 0.01294956f, -0.09349316f, -0.03837052f, -0.03781951f, 
    -0.00253322f, 0.04154807f, 0.03292049f, -0.03695742f, 0.36240989f, -0.16155416f, -0.04107988f, -0.05003557f, 
    -0.08222013f, -0.06291697f, -0.03676989f, -0.02705616f, 0.09143535f, -0.02962014f, 0.02971633f, 0.06297486f, 
    0.29457954f, 0.02639490f, -0.05957915f, -0.18165390f, -0.07400734f, -0.04764514f, 0.10859867f, 0.00130657f, 
    -0.06302547f, -0.01290386f, -0.07354805f, 0.02368168f, 0.01219742f, 0.01612749f, 0.01301625f, 0.03576998f, 
    -0.00034732f, -0.04136358f, -0.01750480f, 0.08711211f, -0.03284115f, 0.01140295f, 0.08976846f, -0.08813896f, 
    -0.03488920f, -0.09544944f, 0.21288635f, 0.01932842f, 0.08541282f, 0.10792083f, -0.01270058f, 0.01178668f, 
    -0.00755725f, 0.00546725f, -0.10764626f, -0.04924547f, 0.05687583f, -0.23461109f, 0.18634504f, -0.07708295f, 
    -0.03754640f, 0.06100415f, 0.20000963f, 0.07133357f, -0.03043086f, -0.07304844f, -0.05505587f, 0.01682151f, 
    -0.06901119f, 0.04105676f, -0.00094957f, -0.02778384f, -0.02712234f, -0.04806415f, 0.01137651f, 0.02535172f, 
    -0.02985933f, 0.05622227f, -0.00054083f, -0.03130914f, -0.07513249f, -0.02123584f, -0.01108721f, -0.05419301f, 
    -0.02654328f, 0.01553756f, -0.01332665f, -0.06331492f, 0.02973031f, -0.00853781f, 0.02341237f, -0.04105125f, 
    0.03344677f, -0.03960412f, 0.01410232f, 0.01386043f, 0.04481877f, -0.01958575f, -0.04377728f, -0.07838746f, 
    0.03510715f, -0.07191176f, -0.04139442f, -0.01762192f, -0.06154225f, -0.05237713f, 0.00694581f, 0.03772528f, 
    0.04131191f, -0.02195011f, 0.04181637f, -0.06179705f, -0.02117825f, 0.01879196f, -0.02308778f, 0.03613693f, 
    -0.01486862f, -0.05575616f, -0.01160761f, -0.06031678f, -0.02837298f, -0.00484466f, 0.03088458f, 0.05450840f, 
    -0.06223114f, 0.03638795f, 0.03723992f, -0.04980693f, 0.06437560f, 0.05365590f, -0.05870792f, -0.04257476f, 
    -0.05798050f, -0.06849330f, -0.05403137f, 0.05897047f, 0.01515984f, 0.04509177f, 0.04238250f, 0.01589671f, 
    0.03837674f, 0.05183838f, -0.05463103f, -0.03408044f, 0.02125221f, 0.00562890f, -0.07773558f, 0.06040902f, 
    -0.05470720f, -0.00690925f, -0.06633991f, -0.03136362f, -0.00025893f, -0.02559768f, -0.02299447f, 0.00665553f, 
    0.02318452f, -0.02751351f, 0.00930535f, 0.01579934f, -0.06335956f, -0.01612652f, -0.04914425f, -0.06374417f, 
    -0.04595858f, 0.05572595f, -0.01841369f, -0.01236079f, 0.04169772f, -0.03176704f, -0.07053208f, 0.03658453f, 
    0.05708242f, 0.03158484f, -0.05963442f, 0.00490623f, 0.05058309f, -0.04694629f, 0.03071447f, -0.04893082f, 
    -0.03876315f, -0.07108380f, 0.04944890f, -0.05483161f, -0.06087210f, -0.05200166f, -0.04596065f, 0.05011905f, 
    -0.02194767f, -0.07243165f, 0.02091246f, 0.03315056f, 0.03854410f, 0.01291614f, -0.01341943f, -0.01317367f, 
    -0.04054108f, 0.02557732f, 0.04334993f, 0.04709290f, -0.07493644f, 0.05700588f, 0.02952217f, 0.03939409f, 
    -0.00958540f, 0.00566093f, -0.03811391f, -0.06156793f, -0.01754266f, 0.04397983f, -0.05070406f, -0.03967175f, 
    0.00933119f, 0.05296234f, -0.00071425f, 0.05780345f, 0.01238633f, -0.05544704f, -0.06082401f, 0.04290551f, 
    -0.05584233f, -0.02080756f, 0.01759419f, 0.04118708f, 0.00479136f, -0.05862324f, -0.02494372f, 0.00275001f, 
    0.00678324f, -0.00614330f, -0.05052054f, 0.03687581f, 0.04612547f, -0.01460293f, -0.00595132f, -0.06456130f, 
    -0.06250919f, 0.05029118f, 0.05152175f, -0.00472955f, 0.05871427f, -0.01770544f, -0.07926320f, -0.01360901f, 
    -0.04452755f, -0.02358453f, -0.06741270f, 0.02542322f, -0.04319022f, -0.01837262f, 0.05317255f, 0.03366016f, 
    -0.06985275f, -0.02038934f, 0.02751362f, -0.06380237f, 0.00166678f, -0.06962341f, 0.03975170f, -0.00787445f, 
    0.02116951f, -0.04947463f, -0.13555911f, 0.14524753f, -0.02976855f, 0.18884300f, -0.04456721f, -0.04733786f, 
    0.09355042f, 0.04544381f, -0.06663274f, 0.06028471f, 0.36420894f, -0.01925994f, -0.16678596f, -0.07567951f, 
    -0.00755016f, -0.09689907f, 0.09632338f, 0.13802132f, 0.03399957f, 0.09239369f, -0.07944236f, 0.03475068f, 
    0.12928562f, -0.08341936f, -0.07204959f, 0.03690185f, 0.05297516f, 0.06485756f, 0.12656514f, 0.11839814f, 
    0.01480397f, 0.04597124f, -0.02597715f, -0.04910225f, -0.14351834f, -0.25605646f, -0.02943697f, -0.35084599f, 
    -0.06612224f, 0.03326806f, -0.12264571f, -0.08761762f, -0.02320228f, -0.09681156f, 0.06129060f, -0.01720876f, 
    0.12297560f, 0.16705902f, -0.08167528f, -0.35644323f, -0.07865760f, 0.14849220f, -0.21468158f, 0.09339743f, 
    -0.03906734f, 0.00824447f, 0.02246981f, 0.00259352f, 0.18808703f, -0.15604958f, 0.00920145f, 0.29784548f, 
    0.01777960f, 0.08443815f, 0.13456047f, 0.10757368f, -0.02964273f, -0.02286262f, 0.02097061f, 0.02384600f, 
    0.34066942f, -0.26040035f, 0.15078691f, 0.02132770f, -0.11933193f, 0.00166831f, -0.05188077f, -0.05954771f, 
    0.02191412f, 0.11078073f, -0.00672363f, -0.00028841f, 0.04735205f, 0.08731025f, 0.10241956f, -0.09532563f, 
    0.08020564f, 0.16479005f, 0.02512722f, 0.01580735f, 0.12433153f, -0.05094433f, 0.18917260f, 0.05803557f, 
    0.19888978f, -0.12902674f, -0.03052159f, 0.23758884f, -0.10654573f, -0.04682602f, 0.01935445f, -0.08908923f, 
    -0.14152515f, -0.01824902f, 0.00095357f, -0.01083590f, -0.20079850f, 0.13418421f, -0.13048677f, 0.04765683f, 
    0.01112458f, -0.07023449f, -0.13188916f, 0.16133839f, -0.01919012f, -0.12241766f, -0.12037905f, 0.04970894f, 
    0.02458078f, -0.31249082f, 0.14774272f, 0.18518928f, -0.07461860f, -0.25701007f, 0.08605485f, -0.07059430f, 
    0.11637625f, 0.13773501f, 0.07105655f, 0.06424517f, 0.40832892f, 0.02953207f, 0.04287718f, -0.08328778f, 
    -0.11747973f, 0.07658880f, -0.02213588f, -0.02519881f, 0.11015122f, -0.07314573f, -0.04491264f, 0.21785371f, 
    0.16855335f, -0.02135398f, 0.22311053f, -0.22951305f, -0.15349284f, -0.11871438f, -0.01309175f, -0.08947326f, 
    0.07901102f, -0.04437339f, 0.08145996f, 0.06143111f, -0.06558656f, 0.13523073f, -0.08395451f, -0.06171078f, 
    -0.05518689f, 0.02278623f, 0.04662399f, 0.00941079f, 0.00396639f, 0.08623450f, -0.05130163f, 0.01109088f, 
    -0.03555040f, -0.06938696f, 0.23884267f, 0.10938000f, -0.16291054f, 0.05594958f, -0.01437337f, -0.00852235f, 
    -0.02461893f, 0.08428380f, -0.08242989f, -0.00799533f, -0.03662524f, -0.33804682f, 0.15434271f, -0.17264771f, 
    0.04900531f, 0.00535491f, 0.19717900f, -0.02638674f, 0.01006163f, -0.09411917f, 0.06113761f, 0.12459260f, 
    -0.04879094f, -0.07612349f, 0.00960766f, -0.00445730f, -0.06891460f, 0.05533999f, 0.03972980f, 0.05529973f, 
    -0.03799561f, -0.02297849f, 0.01381605f, -0.07569740f, -0.07799258f, -0.05023282f, 0.02403850f, 0.06343064f, 
    -0.04478162f, 0.03803378f, 0.06090486f, -0.05025792f, -0.04401802f, -0.02749555f, -0.02014198f, 0.04417132f, 
    -0.04745944f, -0.08043978f, -0.05582643f, 0.02589304f, 0.00560480f, -0.02653595f, 0.05537890f, -0.01309032f, 
    -0.05112877f, 0.05530662f, -0.04906951f, 0.01031288f, -0.06111381f, 0.01647961f, 0.01086445f, 0.04033894f, 
    -0.05182907f, 0.05649849f, -0.05291649f, -0.00059801f, -0.03169686f, -0.08307876f, 0.04508274f, -0.04791328f, 
    -0.00240859f, -0.03331380f, -0.04418429f, 0.00534656f, 0.01414245f, -0.02859124f, -0.07751235f, -0.06680885f, 
    0.00190289f, -0.05078359f, 0.03900559f, -0.04020832f, 0.00151920f, 0.00875971f, 0.04748090f, -0.00409149f, 
    -0.00411122f, 0.01327411f, -0.04697001f, 0.01230223f, -0.02836630f, -0.04790365f, -0.04940744f, 0.04126834f, 
    0.04735412f, 0.05741940f, 0.01800890f, 0.03258848f, -0.08492643f, 0.03794517f, 0.03734977f, 0.06622577f, 
    0.02636902f, 0.02570496f, -0.05725204f, -0.05797199f, -0.01502199f, -0.06908036f, -0.00519926f, 0.04597597f, 
    -0.06985296f, 0.05567213f, -0.02853463f, 0.01838862f, -0.06832716f, -0.06600901f, -0.05025611f, -0.06249606f, 
    0.02735798f, -0.01228234f, -0.01532736f, -0.06259479f, -0.08203742f, -0.01380901f, 0.03363409f, 0.03420860f, 
    0.02975581f, 0.03807460f, -0.04827212f, 0.05732959f, 0.01899924f, 0.03716766f, -0.03545840f, -0.06108749f, 
    0.00030326f, -0.03678668f, -0.00802257f, -0.06451848f, -0.06573724f, -0.07979909f, 0.04786447f, 0.01151560f, 
    -0.03711276f, 0.05289598f, -0.06428508f, -0.07349376f, 0.02207135f, 0.03240173f, 0.05605168f, 0.01384610f, 
    -0.07293700f, 0.06399034f, -0.01889583f, -0.00905879f, 0.01408742f, -0.06219764f, 0.01116850f, 0.04283677f, 
    -0.08416156f, 0.03184948f, -0.00422785f, -0.03418781f, 0.00125439f, -0.07713524f, -0.03856074f, 0.01058790f, 
    0.00179943f, 0.01443574f, -0.01855075f, -0.02051202f, -0.04218819f, 0.05322060f, -0.00345809f, -0.08075744f, 
    0.05677389f, -0.02751072f, -0.03928568f, -0.03989507f, 0.05351003f, 0.00687072f, 0.03249329f, 0.01041456f, 
    -0.00658890f, 0.00671593f, -0.00728724f, 0.02737384f, -0.04755298f, -0.04582748f, -0.04341872f, -0.05386982f, 
    0.05628039f, -0.01608489f, -0.03511391f, 0.03170199f, 0.06103424f, -0.05785952f, 0.05090670f, 0.04766833f, 
    -0.06535840f, -0.00527588f, 0.05303910f, -0.00772386f, 0.01460072f, -0.01695106f, -0.03808104f, 0.02543103f, 
    -0.02460351f, -0.07249402f, -0.06098811f, -0.05941444f, -0.03117658f, 0.06587983f, 0.04736596f, 0.00283462f, 
    0.20383057f, 0.09390721f, 0.05383468f, -0.01842074f, -0.09238968f, 0.01405656f, -0.08668736f, -0.09332795f, 
    -0.07857608f, 0.07642698f, -0.02464281f, -0.03054694f, -0.13173814f, 0.39636943f, 0.09148181f, 0.20193727f, 
    0.16977476f, 0.02102033f, 0.14838457f, 0.03984287f, -0.07304044f, 0.06943262f, 0.06476121f, -0.07964158f, 
    -0.38925666f, 0.17194888f, -0.09140217f, -0.05035627f, -0.06252246f, -0.05201153f, 0.01288369f, 0.00708336f, 
    -0.08179904f, 0.08298068f, 0.01096333f, 0.02655748f, -0.25265494f, 0.03800103f, 0.06894209f, -0.02295844f, 
    -0.10369283f, 0.02393873f, 0.14628021f, 0.03099537f, -0.00714984f, 0.10560371f, 0.02446085f, 0.00481604f, 
    0.21287128f, 0.03677338f, 0.04540212f, 0.00703635f, 0.11402545f, 0.01932884f, 0.13463522f, -0.13745606f, 
    0.06877565f, -0.08476930f, -0.00408215f, -0.01250081f, 0.01955506f, -0.20261936f, 0.04206130f, 0.13521494f, 
    0.00468124f, -0.06193895f, -0.02314902f, -0.00164610f, 0.08161942f, -0.02039683f, 0.15524793f, 0.12572478f, 
    0.09750583f, 0.11430957f, 0.15433711f, 0.14854686f, 0.03208742f, -0.05203432f, 0.03914805f, 0.06012097f, 
    -0.17667988f, 0.18690822f, 0.06782199f, -0.00340335f, -0.09755292f, -0.09315159f, -0.06035008f, 0.05155703f, 
    -0.08085500f, -0.01946408f, -0.09294824f, -0.02577486f, 0.05189841f, -0.01186104f, -0.09971751f, 0.00397424f, 
    -0.31629226f, 0.18002187f, -0.18447945f, 0.08592108f, -0.04693539f, 0.00498775f, 0.01963160f, -0.01822164f, 
    -0.04462733f, -0.03596131f, -0.13856734f, -0.02404743f, -0.06355329f, -0.10380882f, -0.05968421f, -0.04274886f, 
    -0.10458377f, 0.02105247f, -0.01551559f, -0.08252747f, 0.06307969f, 0.02434352f, -0.06903305f, 0.05168185f, 
    -0.23713717f, -0.09236906f, -0.06676959f, -0.05418972f, -0.09289970f, -0.09753517f, 0.01202921f, 0.08666079f, 
    -0.03462192f, -0.00963405f, -0.00790809f, 0.06305031f, 0.04195609f, 0.19117524f, 0.14416569f, 0.04322432f, 
    0.12362581f, 0.13957869f, 0.13328990f, 0.16944368f, -0.02150903f, 0.05020206f, 0.12410950f, -0.02504640f, 
    0.05657509f, 0.06432565f, 0.22087458f, -0.00154970f, 0.01241865f, -0.06933925f, -0.06293266f, 0.09195542f, 
    0.02369336f, 0.01387472f, 0.07522643f, 0.04563345f, 0.09812403f, 0.14683257f, -0.08562574f, -0.20018850f, 
    -0.04168069f, -0.01178534f, -0.00645828f, -0.07902592f, 0.11292225f, 0.06559335f, 0.02111382f, -0.01976142f, 
    -0.13196912f, 0.14445846f, -0.02833251f, 0.04762491f, -0.11460327f, -0.10427415f, 0.04075772f, 0.09574886f, 
    -0.10304964f, 0.11532205f, 0.00564261f, -0.06146935f, -0.18538357f, -0.03591205f, 0.12162116f, -0.10146882f, 
    -0.06004637f, -0.12058678f, 0.04843490f, -0.05737247f, -0.05559496f, 0.05830755f, 0.03540700f, 0.07369853f, 
    0.14958632f, 0.06441575f, -0.01246811f, 0.05411850f, -0.00675330f, -0.08851874f, -0.08258347f, -0.20793338f, 
    -0.10024004f, -0.07061456f, -0.02657399f, -0.06642891f, 0.04470288f, 0.26674131f, -0.05019999f, 0.08249458f, 
    0.33238620f, 0.24376148f, 0.00630713f, -0.02199268f, -0.00052919f, -0.17689772f, -0.04775691f, -0.04750849f, 
    -0.49713722f, 0.08711363f, -0.05989138f, -0.02802816f, -0.00966876f, -0.08995912f, -0.01294261f, -0.01546117f, 
    -0.10471254f, 0.05324855f, 0.01784306f, -0.06522865f, 0.06405168f, 0.03147900f, 0.01398544f, 0.23605584f, 
    -0.07830548f, -0.04275405f, 0.01058697f, 0.06335551f, 0.08508354f, 0.01834200f, -0.01279312f, 0.04357766f, 
    -0.43813294f, -0.18162535f, 0.08563466f, -0.06760945f, 0.12480479f, -0.04054378f, 0.00627629f, -0.11117023f, 
    -0.00741535f, -0.10295787f, 0.03190918f, -0.09838166f, 0.04417464f, 0.15109582f, 0.04520963f, 0.00273061f, 
    0.02213697f, -0.02171740f, -0.06824073f, -0.02902630f, 0.25143412f, 0.13561518f, 0.14076117f, 0.13287033f, 
    0.06347031f, 0.11926121f, 0.19920701f, 0.11238062f, -0.09426586f, 0.17477153f, 0.07617163f, 0.02029460f, 
    0.12036479f, -0.05913973f, 0.06636176f, -0.00488943f, 0.19405541f, 0.04279182f, -0.01167179f, 0.06563222f, 
    0.08432163f, -0.05649626f, -0.02136307f, -0.05847733f, 0.08094578f, 0.19379471f, -0.08061543f, 0.08235378f, 
    -0.36358777f, 0.05331676f, 0.08861118f, -0.07371279f, 0.06108481f, -0.13116978f, -0.05648581f, -0.03979992f, 
    -0.00558991f, 0.04778115f, -0.02463630f, -0.09280258f, -0.13116774f, 0.05085550f, -0.03467200f, -0.08464791f, 
    0.06099527f, 0.08304925f, -0.06333099f, 0.04159745f, 0.10206302f, 0.06650717f, 0.13260391f, 0.09531894f, 
    -0.10093290f, -0.08808543f, -0.14738713f, -0.09481972f, 0.00710392f, 0.00571453f, -0.06408916f, -0.16336979f, 
    0.00528884f, -0.06726402f, -0.00025165f, 0.03739016f, 0.23408981f, 0.29655185f, -0.01563572f, 0.02240841f, 
    0.17716156f, 0.21775545f, 0.11836080f, 0.03311326f, 0.12041223f, 0.15706670f, 0.01634827f, 0.02403508f, 
    -0.04875055f, -0.09697820f, -0.02779144f, -0.05190830f, -0.05833153f, -0.10425717f, -0.02835836f, -0.14933370f, 
    0.03659704f, -0.04076840f, -0.12673338f, -0.03673508f, 0.25675210f, 0.09345085f, 0.05031621f, -0.12767136f, 
    0.06944646f, -0.02518756f, -0.06258600f, 0.09932315f, 0.05203030f, 0.04996836f, 0.05812005f, -0.16999750f, 
    -0.09908829f, -0.07133368f, 0.00801998f, 0.20270658f, -0.11225305f, -0.03809986f, -0.05405650f, -0.09278774f, 
    -0.04588387f, -0.02457544f, -0.08251516f, -0.04406118f, 0.05281213f, 0.14558400f, 0.21411051f, -0.13066350f, 
    -0.03668001f, 0.08370237f, -0.03132812f, -0.04391238f, 0.02685499f, -0.11131135f, 0.02932966f, -0.02956256f, 
    -0.07914368f, 0.00273820f, -0.04483190f, 0.06104225f, -0.01590067f, -0.00253029f, 0.04534191f, 0.00117010f, 
    -0.04106721f, -0.00036132f, -0.04137596f, 0.14583160f, 0.30472228f, -0.11125687f, 0.03484700f, -0.03506023f, 
    -0.17398597f, -0.01876278f, 0.02419609f, 0.03047056f, -0.00486936f, 0.08830593f, -0.02504797f, 0.11204891f, 
    -0.02402542f, -0.12748832f, 0.11580791f, 0.02771352f, 0.01041298f, -0.08868609f, 0.03744510f, -0.08148529f, 
    0.11886903f, 0.02817230f, -0.13859336f, 0.05902478f, -0.08341143f, 0.03900964f, 0.04207101f, -0.18152164f, 
    -0.06729279f, 0.08052706f, -0.08368228f, -0.11612152f, 0.02386886f, -0.10222783f, -0.01645767f, 0.01339622f, 
    0.35773650f, 0.28168416f, -0.21001571f, -0.06852159f, 0.06200442f, -0.05567133f, -0.03097883f, 0.00471092f, 
    -0.05130530f, 0.04726591f, 0.04247065f, 0.03382645f, 0.31566134f, -0.05004644f, -0.05257107f, 0.04080052f, 
    -0.09008323f, 0.08312047f, 0.06480878f, 0.19708094f, -0.09500444f, 0.08455347f, -0.17993376f, -0.08456795f, 
    0.14307867f, -0.04580016f, -0.17576233f, -0.13571732f, 0.03650784f, 0.13412514f, -0.06400791f, -0.00177933f, 
    0.01019803f, 0.04903201f, -0.07909337f, 0.02029148f, -0.09926783f, 0.05286115f, -0.00252939f, -0.36629853f, 
    0.17407824f, 0.11584945f, -0.01929140f, 0.03094156f, 0.04472564f, -0.07158690f, 0.06427360f, -0.04261181f, 
    0.32515305f, -0.06895052f, 0.09343429f, 0.20485467f, -0.00866083f, 0.01222333f, -0.01032979f, -0.01730586f, 
    -0.03888922f, -0.02320084f, 0.08789510f, 0.00884401f, 0.01537591f, -0.04229058f, -0.05177766f, -0.03581322f, 
    -0.06868413f, -0.01062618f, 0.06177856f, -0.02989687f, 0.06107648f, -0.03596045f, 0.03037371f, -0.00541542f, 
    -0.14015374f, 0.05974638f, 0.20499986f, 0.01797762f, -0.09788217f, -0.01413814f, -0.02951235f, 0.09333375f, 
    0.00837195f, 0.16581376f, -0.01093591f, -0.06335303f, 0.37521166f, -0.08125768f, -0.00361333f, 0.01399123f, 
    -0.03104392f, -0.08966969f, -0.13645428f, -0.04953514f, -0.01042201f, -0.08215240f, -0.02559565f, 0.12847145f, 
    -0.05688122f, 0.12729126f, -0.04167235f, -0.03163878f, 0.10898691f, 0.03693657f, 0.12045056f, -0.08555094f, 
    0.03741664f, 0.12728192f, 0.07803248f, 0.03589579f, 0.24565549f, -0.01513444f, 0.14038418f, 0.03822133f, 
    -0.00783169f, 0.04518010f, 0.13887505f, 0.06995919f, 0.02479379f, 0.01836940f, 0.00662545f, -0.04460713f, 
    -0.14400023f, 0.08484194f, 0.12310359f, -0.26141933f, 0.08292960f, 0.00693466f, -0.00959068f, 0.05526790f, 
    -0.17529012f, 0.07034504f, -0.02419582f, -0.06438951f, -0.21929473f, -0.10225656f, -0.00324351f, 0.10134830f, 
    0.04160970f, -0.05611162f, -0.02951101f, 0.03796150f, -0.13166517f, -0.11856108f, -0.04490196f, 0.00109503f, 
    -0.21760046f, -0.09737740f, -0.23962997f, 0.00140866f, -0.04013382f, 0.04596983f, 0.10149760f, -0.02280254f, 
    0.12234787f, -0.03078704f, -0.01920000f, 0.16273412f, 0.34150118f, -0.06274753f, 0.05874146f, -0.22158474f, 
    -0.11959628f, -0.07970292f, 0.10877082f, 0.07385151f, 0.10204177f, 0.12852539f, -0.08811379f, 0.09441257f, 
    -0.17602746f, 0.00583808f, 0.01550609f, 0.09376383f, -0.02039565f, -0.00102587f, 0.11797028f, -0.00204107f, 
    0.07724387f, 0.12920055f, -0.06740718f, 0.00864872f, 0.01118109f, 0.07138104f, 0.12690495f, 0.13171838f, 
    -0.10138714f, -0.02431002f, -0.00624305f, -0.05867791f, -0.01162130f, -0.00374256f, 0.06191477f, 0.06008131f, 
    0.16997212f, 0.14922179f, 0.06604038f, -0.08637686f, 0.12472469f, -0.07910761f, -0.18978226f, -0.09522737f, 
    -0.03865328f, 0.00793598f, 0.09358222f, 0.16807897f, 0.20755015f, -0.08899105f, -0.00200165f, 0.20147026f, 
    -0.05487873f, -0.01580937f, 0.08147439f, 0.09546900f, 0.14761642f, 0.04938487f, 0.05190898f, -0.09956609f, 
    0.03812561f, 0.03695683f, 0.17915550f, 0.08270895f, -0.07715532f, 0.13375132f, 0.06055253f, 0.04464179f, 
    0.00322209f, 0.01946090f, 0.03059848f, 0.02465533f, 0.03852100f, 0.07759264f, 0.03844927f, -0.24709879f, 
    0.02879128f, 0.10255527f, -0.08619960f, 0.13664420f, 0.06854435f, -0.01143859f, -0.00893357f, -0.06050609f, 
    -0.23284765f, -0.11262326f, 0.03183021f, -0.06764991f, 0.13101912f, -0.06571963f, -0.01898593f, -0.08028705f, 
    -0.05469216f, -0.00088558f, 0.14461811f, 0.06397533f, 0.17793919f, -0.20109493f, -0.07594357f, -0.01806844f, 
    0.04460433f, -0.02509040f, -0.02793959f, 0.04750101f, 0.09067298f, 0.01286476f, 0.05080486f, 0.08618819f, 
    -0.31456992f, 0.18110877f, -0.07816966f, -0.21481322f, 0.19712622f, -0.02074595f, 0.03253063f, -0.08886099f, 
    -0.11159816f, 0.05223396f, 0.17306398f, -0.07453447f, 0.50107026f, -0.25099295f, 0.06519158f, -0.18031037f, 
    -0.08873611f, 0.10478996f, -0.10478942f, 0.01682720f, -0.05922660f, 0.03082403f, 0.09825183f, 0.00659933f, 
    -0.04774914f, 0.09747201f, -0.06429087f, -0.35403708f, -0.00643420f, 0.07491495f, -0.08587084f, 0.08285362f, 
    0.05895459f, -0.07250808f, 0.08624547f, -0.07797450f, 0.57567579f, -0.03592408f, 0.16106148f, -0.01849716f, 
    -0.01510427f, -0.06762606f, -0.03241882f, 0.18583710f, 0.09057581f, 0.02141510f, 0.11664588f, -0.02313680f, 
    -0.46165749f, -0.11582600f, -0.21073835f, -0.18701696f, 0.12561934f, -0.00507376f, 0.04576086f, 0.09009601f, 
    -0.04229848f, 0.06272015f, -0.10772465f, -0.00005878f, -0.11461580f, 0.07864110f, 0.27104822f, 0.01472418f, 
    -0.09318065f, 0.05019936f, -0.00100264f, -0.13924994f, -0.03003011f, 0.08729395f, 0.06689629f, 0.05179250f, 
    0.27502340f, -0.02126365f, 0.03198078f, -0.13881589f, -0.14281195f, -0.06037856f, -0.12186133f, 0.07273611f, 
    0.02952311f, 0.09973451f, -0.04638793f, -0.17259568f, -0.18609665f, 0.08470167f, -0.06993240f, 0.14915723f, 
    0.16908424f, 0.17813455f, 0.04117141f, -0.11778469f, 0.00985582f, -0.08977055f, 0.16266286f, 0.01540067f, 
    -0.48475209f, -0.04798674f, -0.01882291f, -0.16263004f, -0.00924929f, 0.06091026f, 0.06415530f, 0.00134764f, 
    -0.06310568f, -0.02248664f, 0.02295851f, -0.15545635f, -0.20494314f, -0.13654949f, -0.00286761f, 0.30332971f, 
    0.07253601f, 0.00144049f, 0.10163102f, -0.00562550f, -0.08759534f, 0.18000247f, 0.15879792f, 0.08402147f, 
    -0.38036424f, -0.16096491f, -0.10458492f, -0.00559079f, 0.10603394f, -0.00087957f, 0.00450876f, -0.09402872f, 
    0.16998567f, 0.12984221f, -0.06529782f, 0.06947055f, 0.21632707f, 0.15102340f, 0.23549031f, 0.07702775f, 
    0.11269256f, 0.00130418f, 0.00879978f, -0.02391171f, 0.02169363f, 0.04057479f, 0.00265372f, 0.05110779f, 
    0.29221508f, 0.21141036f, 0.15454324f, 0.06379426f, 0.13131285f, 0.06514639f, 0.17561126f, -0.01883111f, 
    -0.15667243f, -0.05442168f, 0.09973122f, 0.06178757f, 0.35512200f, 0.16078341f, 0.09367073f, 0.06500615f, 
    0.07506222f, -0.02932086f, 0.14863561f, 0.04512667f, -0.12319709f, 0.05496542f, -0.15637636f, 0.05859620f, 
    -0.46260864f, 0.29929161f, -0.09501520f, -0.17976192f, -0.02534472f, 0.03096503f, -0.08977872f, 0.15860370f, 
    0.06120259f, -0.09506564f, -0.08145545f, -0.12401347f, -0.18600027f, -0.14259559f, -0.14578144f, -0.18889871f, 
    -0.00925951f, -0.05194129f, -0.00686365f, -0.11298039f, -0.02589425f, -0.00039018f, 0.02244932f, 0.13675995f, 
    -0.19588780f, -0.09764687f, -0.17914174f, -0.17852671f, -0.13777108f, -0.07727618f, -0.19698654f, 0.00820123f, 
    -0.01692896f, -0.09783833f, -0.06233953f, 0.06255288f, 0.07624740f, 0.17745662f, 0.04507406f, 0.23291501f, 
    0.25356522f, 0.14711647f, 0.16048846f, 0.16341870f, -0.01127760f, -0.00981276f, 0.03820914f, 0.10167687f, 
    -0.09420668f, -0.06642248f, -0.28539875f, 0.10248809f, -0.10464972f, -0.08639883f, -0.14344138f, 0.04798912f, 
    -0.09143779f, 0.02622749f, -0.11193550f, -0.02086267f, -0.20372191f, -0.09118417f, -0.11059374f, -0.00544380f, 
    -0.02004449f, -0.07365113f, -0.13028660f, 0.08544333f, 0.09923760f, 0.00907990f, 0.07887217f, -0.07937024f, 
    0.07458794f, 0.07742429f, 0.09033072f, 0.11423282f, -0.12932919f, -0.05172962f, 0.07104518f, 0.09773376f, 
    -0.09270727f, -0.10563415f, 0.01484349f, -0.15560980f, 0.07026429f, 0.07611567f, 0.07125237f, 0.21863617f, 
    -0.09674912f, -0.02087644f, 0.20072700f, -0.11037534f, -0.19656183f, 0.10913360f, 0.01491664f, -0.04455272f, 
    0.19689164f, 0.11163197f, 0.16881335f, -0.10955033f, 0.05944780f, -0.02978425f, -0.04419774f, -0.02775780f, 
    -0.12315511f, -0.10147088f, -0.17501019f, -0.06839965f, 0.16244131f, 0.21100107f, -0.11974183f, -0.14342821f, 
    0.02261853f, 0.16173635f, -0.07239018f, -0.17330471f, 0.03074605f, -0.03841955f, -0.02772056f, 0.10741507f, 
    -0.28751478f, -0.15784086f, 0.14968786f, 0.11095017f, 0.03387254f, -0.16680719f, -0.04776851f, -0.02793317f, 
    0.06630651f, -0.22104312f, -0.11739463f, 0.07223818f, 0.12121051f, 0.06361804f, -0.07697164f, -0.13097498f, 
    -0.04249550f, 0.14353752f, 0.04376969f, -0.12357528f, 0.22551519f, 0.21207960f, -0.10604502f, 0.11344538f, 
    -0.37130386f, -0.01192286f, -0.21879166f, 0.19963600f, 0.02994474f, -0.05311935f, 0.14002386f, -0.20351058f, 
    0.03550053f, 0.05743917f, 0.04492234f, -0.05474098f, 0.12438936f, 0.03884205f, -0.03026088f, -0.04244321f, 
    0.09935644f, -0.00833458f, -0.08170849f, 0.10493151f, -0.09815673f, 0.17236719f, -0.00710952f, 0.10354990f, 
    0.20147093f, -0.09280930f, -0.04146051f, -0.08027255f, 0.07909279f, -0.03904203f, 0.09276174f, 0.07485335f, 
    0.16151927f, -0.06393228f, 0.02097602f, 0.01333888f, 0.20463105f, 0.04605409f, 0.16412057f, -0.02736274f, 
    -0.01914023f, -0.02810608f, 0.07821625f, 0.07130698f, -0.10622619f, 0.06511858f, 0.01324429f, 0.03089168f, 
    0.43869880f, -0.09547474f, 0.13970853f, -0.12458824f, -0.02445920f, 0.03471080f, -0.01262903f, 0.07349995f, 
    0.06230411f, 0.01040534f, 0.16804762f, -0.01419532f, 0.01126791f, 0.02090678f, -0.12247445f, 0.03544055f, 
    -0.02661731f, 0.12357339f, -0.10284849f, -0.02991646f, 0.09666733f, 0.06659642f, 0.10518508f, 0.07211237f, 
    -0.09999784f, -0.06646703f, 0.04578843f, -0.11236399f, 0.00369925f, 0.09834608f, -0.04272827f, 0.08368374f, 
    -0.01268811f, 0.10501509f, 0.07251339f, 0.15674430f, 0.29934192f, 0.02932883f, -0.01986573f, -0.13711068f, 
    -0.00824849f, 0.09044911f, 0.00777841f, 0.05491184f, 0.19058760f, -0.00080272f, -0.01259295f, 0.03352116f, 
    -0.31809661f, -0.00137144f, 0.11511295f, 0.04704503f, 0.02412327f, -0.07572243f, 0.07181244f, 0.01144463f, 
    0.08999085f, 0.18722901f, 0.00489230f, 0.17796995f, -0.00166222f, -0.03893548f, -0.09730816f, 0.02315296f, 
    -0.26146060f, 0.08224797f, 0.07171753f, -0.02691526f, 0.05009521f, -0.05063947f, -0.03282866f, 0.10998538f, 
    0.01081712f, -0.07363704f, 0.26030198f, -0.02479732f, 0.00438575f, -0.01608658f, -0.03165456f, -0.11764083f, 
    -0.01837979f, -0.16977112f, -0.00637070f, -0.14645538f, -0.10492215f, 0.07185357f, -0.17011254f, -0.00816035f, 
    0.18942130f, -0.00796562f, -0.00408927f, 0.00259713f, 0.04195539f, -0.12881519f, -0.05019641f, -0.11162416f, 
    0.08764665f, 0.08512781f, 0.04161094f, 0.01547383f, 0.12419324f, -0.02261060f, 0.07090060f, 0.11707185f, 
    0.04565120f, 0.00217132f, -0.00246770f, 0.04991830f, -0.05636103f, -0.13357958f, 0.20729633f, 0.15994528f, 
    -0.03361956f, 0.11029110f, 0.01169932f, 0.05888751f, 0.00078723f, 0.17254077f, -0.04035169f, 0.09833363f, 
    -0.15150553f, -0.28917950f, 0.27520448f, -0.13599865f, 0.12010637f, -0.10610531f, -0.12410596f, -0.11762708f, 
    0.19032373f, -0.01581027f, -0.08148136f, 0.02320685f, 0.08800402f, 0.17021324f, 0.01024001f, -0.11634926f, 
    0.23202454f, 0.10770691f, -0.07311907f, -0.04968725f, 0.12254348f, -0.02544101f, -0.07072287f, 0.10597656f, 
    0.30134767f, -0.04342160f, -0.11968686f, 0.06534355f, 0.02158586f, -0.02004741f, -0.04190813f, 0.00425252f, 
    0.07161196f, 0.13583528f, 0.00189888f, -0.06656462f, 0.07103688f, 0.13631293f, -0.05958417f, -0.21441728f, 
    0.04933104f, -0.12191081f, -0.03137488f, 0.17076851f, 0.05144180f, 0.09034479f, -0.00244352f, 0.04139950f, 
    -0.19567792f, 0.10595407f, -0.33274230f, -0.23125634f, 0.06934191f, -0.00999686f, 0.01204014f, -0.04820569f, 
    -0.01897824f, 0.00010598f, -0.05387644f, -0.08824982f, -0.10099306f, 0.05247604f, -0.04019567f, -0.24182288f, 
    0.05976685f, 0.14190763f, 0.00556505f, 0.01290193f, 0.00025284f, 0.01277993f, 0.06552020f, -0.02661006f, 
    0.31940311f, 0.13577718f, 0.11935002f, 0.00692871f, 0.10679161f, -0.01487895f, -0.01713430f, 0.00521035f, 
    0.02990510f, -0.05025583f, -0.00029407f, 0.03877782f, 0.40892208f, -0.09614108f, -0.16385224f, 0.09842931f, 
    -0.05287582f, 0.10165458f, -0.01941258f, 0.00164415f, 0.06805427f, 0.03765978f, 0.13199341f, -0.10687280f, 
    -0.21336079f, 0.35562092f, 0.16140753f, -0.00176822f, 0.11408812f, 0.08155131f, -0.10126147f, -0.03083340f, 
    0.00389830f, -0.01030249f, -0.04700802f, 0.05094166f, -0.08589423f, -0.15516116f, -0.12311646f, 0.37584901f, 
    -0.04018968f, -0.09980845f, -0.06098386f, 0.08158194f, 0.03515746f, -0.02170482f, 0.03795512f, 0.05416816f, 
    -0.10906721f, 0.00236314f, -0.20569207f, 0.20674951f, 0.18516487f, -0.01935975f, -0.04013711f, -0.18159369f, 
    -0.04719905f, -0.00691537f, 0.04627551f, -0.01508021f, 0.10795048f, -0.01668558f, 0.11444663f, 0.03217406f, 
    0.00379544f, 0.03194050f, 0.10660870f, 0.17364544f, 0.10067570f, -0.01882334f, 0.00687282f, 0.14618865f, 
    -0.11913605f, 0.24411289f, -0.06905188f, -0.29715130f, 0.15244526f, -0.05790147f, -0.11981699f, 0.03385513f, 
    -0.11703277f, 0.12748168f, -0.04451315f, -0.05271125f, -0.13700096f, 0.07305548f, -0.04829287f, 0.15294623f, 
    -0.00442609f, 0.02316592f, -0.01887034f, -0.04392329f, -0.08952622f, -0.01301314f, 0.10796721f, 0.00022649f, 
    0.30366650f, 0.13456178f, 0.07712518f, -0.03154268f, -0.09843814f, -0.01522886f, -0.00897210f, -0.04670662f, 
    -0.14314367f, -0.07457105f, -0.07148926f, -0.06363312f, -0.07522786f, 0.18961903f, -0.18781085f, -0.18241720f, 
    0.15901124f, 0.09246520f, -0.15154518f, -0.12307864f, -0.02390670f, -0.15248175f, 0.08160528f, -0.07740581f, 
    0.00820580f, -0.00054691f, -0.01298627f, 0.10420315f, -0.06978657f, -0.00001596f, 0.01284401f, 0.06675243f, 
    -0.11178622f, -0.06766520f, -0.13018255f, -0.05447946f, -0.09833536f, 0.03150180f, -0.00659288f, 0.07234456f, 
    -0.12368945f, -0.01425345f, 0.02046943f, 0.00634388f, 0.03871554f, 0.07263616f, -0.09723742f, 0.00382665f, 
    -0.16074261f, -0.14313376f, 0.12028164f, 0.02166144f, -0.04775217f, -0.02709713f, 0.18260410f, -0.12564100f, 
    0.01525619f, 0.05074634f, -0.00306906f, -0.10925695f, 0.11650605f, -0.11104281f, -0.22481118f, -0.00230949f, 
    0.01168106f, 0.12850143f, 0.01543038f, -0.12387639f, -0.00365654f, -0.01965435f, 0.13757345f, 0.08832686f, 
    0.05044562f, -0.33473274f, 0.09724440f, 0.02218746f, -0.02034538f, 0.08224303f, 0.09430256f, 0.03492760f, 
    0.10941892f, -0.10557457f, 0.06729951f, -0.00853307f, -0.01578264f, -0.08857099f, 0.05740431f, 0.02744726f, 
    0.04355755f, -0.01552248f, 0.11151677f, 0.03242481f, -0.14505832f, -0.01417381f, 0.05377786f, 0.03906564f, 
    0.22733423f, 0.01822785f, 0.15462813f, 0.03060328f, -0.13122974f, 0.11162300f, -0.04727977f, 0.00960771f, 
    0.05943705f, 0.12995040f, 0.08000600f, -0.04959739f, -0.07558011f, 0.03848686f, -0.00966195f, 0.03426038f, 
    -0.02405846f, 0.13435459f, -0.03538470f, 0.03639878f, 0.04967596f, -0.01432407f, -0.01814331f, 0.19014768f, 
    0.17158160f, -0.00933423f, -0.07552885f, -0.01399614f, -0.05994008f, 0.06114776f, 0.13326919f, -0.02741992f, 
    -0.07298935f, 0.01715303f, 0.03074858f, 0.21664624f, 0.10917075f, 0.18839298f, -0.21011192f, -0.26724568f, 
    0.12067014f, 0.08543418f, 0.07651760f, 0.10033302f, 0.09198730f, 0.00688624f, -0.07663260f, 0.10903447f, 
    0.00955937f, 0.09782342f, 0.30985025f, -0.04887329f, -0.15094642f, -0.07265840f, 0.22651480f, -0.08308572f, 
    0.04171096f, 0.18235613f, -0.04100144f, 0.12090020f, -0.11425462f, 0.09126975f, -0.14879397f, 0.04655248f, 
    -0.11912700f, -0.01621081f, 0.04410588f, -0.11105233f, -0.11317654f, -0.04198124f, -0.05759818f, 0.15151720f, 
    0.27030447f, 0.01243776f, 0.25925475f, 0.22653069f, -0.08848589f, 0.02657642f, 0.03384174f, 0.05202254f, 
    0.07113010f, -0.16338706f, 0.01662329f, -0.00251490f, 0.01839898f, -0.08364484f, -0.15643068f, -0.06527814f, 
    0.12137443f, 0.07536102f, -0.01762788f, 0.08461650f, -0.03179711f, -0.17900486f, -0.06104874f, -0.22481985f, 
    -0.03601093f, 0.01545533f, -0.04854919f, -0.14554952f, -0.05030699f, -0.01171504f, -0.00937058f, 0.06145769f, 
    -0.08038945f, 0.02225843f, -0.08140770f, -0.10615797f, 0.07756262f, 0.28979537f, -0.11846507f, -0.15618895f, 
    -0.13317342f, 0.06503967f, -0.00598511f, -0.18949738f, -0.05641250f, -0.09852772f, -0.00071200f, -0.02655867f, 
    0.33721602f, 0.09914088f, -0.06898420f, 0.26886344f, -0.11867149f, -0.10805266f, -0.01979868f, 0.10919245f, 
    0.02355872f, 0.08458255f, 0.01094273f, -0.00229941f, -0.06102391f, 0.11386023f, -0.03632106f, -0.07671545f, 
    -0.09244350f, -0.04455757f, 0.12516898f, -0.01322475f, -0.03945114f, 0.00611049f, -0.09346857f, -0.01610802f, 
    0.27722025f, 0.06656936f, 0.05908274f, 0.17391057f, 0.02128636f, 0.05237289f, 0.06731278f, -0.04352912f, 
    -0.06538484f, 0.07235252f, -0.00658424f, -0.03738533f, 0.21206275f, -0.13646068f, -0.00764057f, 0.06791993f, 
    -0.09346256f, 0.13019899f, 0.00239477f, -0.03833077f, -0.04613065f, 0.00805427f, -0.03112991f, -0.04757695f, 
    0.27457237f, -0.27067840f, 0.19504048f, 0.02110106f, 0.00177577f, -0.07237544f, -0.02813763f, -0.02792405f, 
    0.18234964f, 0.00429458f, 0.00631370f, -0.04488248f, 0.09799180f, -0.06076997f, 0.13580774f, -0.01036327f, 
    -0.04750349f, -0.06665315f, -0.05598624f, -0.02320898f, -0.05421518f, -0.18908449f, -0.01438885f, 0.07448044f, 
    0.19300650f, -0.25120842f, 0.05141459f, 0.21488908f, -0.19201095f, 0.03529557f, 0.10901925f, -0.10010193f, 
    0.03024889f, 0.08038332f, -0.06008435f, -0.07879872f, -0.25639114f, 0.01049343f, 0.20522673f, -0.01727504f, 
    0.07647618f, 0.11487371f, -0.11526000f, 0.06701319f, 0.04692804f, 0.04864311f, -0.03143680f, -0.08726940f, 
    -0.00200142f, -0.02020576f, -0.11378749f, 0.05398096f, -0.05152509f, 0.01569477f, 0.00838031f, 0.10658649f, 
    0.04721053f, 0.10408359f, 0.03298173f, 0.06167391f, 0.17851518f, 0.20350568f, 0.20533720f, -0.21950252f, 
    0.04400086f, -0.03873774f, 0.04053036f, 0.02755059f, 0.08911440f, -0.03534845f, -0.08116349f, 0.03599216f, 
    -0.02142073f, 0.13535839f, 0.26580158f, 0.02688288f, 0.01374804f, -0.06206860f, 0.10143692f, 0.02406155f, 
    0.17317693f, 0.20728192f, -0.07202479f, 0.10465604f, -0.16164282f, 0.08104499f, -0.07831217f, 0.00026373f, 
    -0.11498047f, 0.13016550f, 0.06498117f, -0.15437339f, 0.01268534f, -0.02751401f, -0.03481758f, 0.03586336f, 
    0.14159989f, -0.08900815f, 0.16320528f, 0.28294837f, -0.04470398f, 0.06259874f, 0.20330787f, -0.00088256f, 
    0.09881239f, 0.07891778f, 0.00024392f, 0.15807377f, -0.12938312f, 0.05731445f, -0.12518507f, -0.00089589f, 
    0.17980826f, 0.02089858f, -0.07665751f, 0.02612480f, 0.03573123f, -0.05290338f, 0.08569518f, -0.11532075f, 
    0.31839442f, 0.05161647f, -0.01623982f, -0.13508259f, 0.06901027f, -0.13984808f, -0.04709333f, -0.10667150f, 
    -0.08076541f, 0.13722178f, -0.02485859f, -0.14649627f, -0.14016488f, 0.01924571f, 0.12991649f, 0.09996058f, 
    0.03520920f, 0.15592422f, -0.02000899f, -0.01052399f, 0.08724239f, -0.09027477f, 0.01340056f, -0.11088046f, 
    0.30381152f, 0.01600307f, -0.02748531f, -0.00858112f, -0.08693410f, 0.04742694f, -0.11452347f, -0.09312922f, 
    0.03397397f, 0.07447650f, 0.01348907f, 0.00598538f, -0.07752685f, 0.23771808f, -0.09347665f, 0.04032790f, 
    -0.12084439f, -0.13681498f, 0.13152218f, 0.03871388f, 0.06322011f, -0.01018146f, 0.12390961f, -0.01160718f, 
    0.06310191f, -0.42233071f, 0.11850810f, 0.08051839f, 0.04953194f, -0.03435064f, 0.10636709f, -0.01209686f, 
    0.10879256f, -0.09005194f, 0.03119603f, 0.05839505f, -0.20274171f, -0.17099583f, -0.24016620f, -0.07059737f, 
    -0.09423351f, 0.06407346f, -0.07330018f, -0.14590035f, 0.05748165f, -0.08231696f, 0.19762963f, 0.11678895f, 
    -0.26271230f, -0.10052979f, -0.10395602f, -0.04329259f, -0.02776685f, -0.02535995f, 0.09882058f, -0.00366627f, 
    0.08059520f, -0.12081575f, 0.10224632f, 0.17420104f, -0.15149012f, -0.01906420f, -0.13608405f, 0.17152984f, 
    -0.06791177f, -0.12589391f, 0.03071138f, -0.05602292f, -0.05851896f, 0.07223319f, -0.04500692f, 0.05603502f, 
    -0.16087063f, 0.04727417f, 0.08425790f, 0.00992631f, 0.12792207f, 0.04098401f, 0.07876071f, -0.01138544f, 
    0.16694580f, 0.08813751f, -0.09577067f, 0.07320635f, 0.30912796f, 0.08624219f, 0.07200512f, 0.02850651f, 
    0.08068254f, 0.12192746f, 0.01290961f, -0.07354183f, 0.02574816f, 0.04559696f, -0.01253774f, 0.01460627f, 
    0.25457436f, 0.16907319f, -0.10270331f, 0.00957209f, 0.19122440f, 0.20148955f, 0.09600093f, -0.12975760f, 
    -0.14419052f, -0.00855322f, 0.02822678f, 0.08006147f, -0.24651583f, 0.20887731f, -0.10974438f, 0.11619818f, 
    -0.02741122f, 0.04488909f, 0.06535738f, 0.09317842f, 0.07183636f, -0.03428583f, -0.01955204f, -0.07387916f, 
    0.11308392f, -0.03677770f, 0.26556486f, 0.11978897f, -0.02260118f, 0.00585193f, -0.05310777f, -0.04758280f, 
    0.05855274f, -0.00891125f, 0.08986748f, -0.06525482f, -0.00132413f, 0.12762327f, 0.06709643f, 0.00065280f, 
    0.04205218f, -0.11280179f, -0.03853701f, 0.04768902f, -0.02328353f, 0.02509788f, 0.01656751f, -0.05211586f, 
    0.07274064f, 0.11211282f, -0.12730333f, 0.18955824f, 0.06773662f, 0.05178736f, 0.06035097f, -0.09309135f, 
    0.13516833f, 0.01144334f, 0.06189898f, 0.06106725f, 0.04677594f, 0.31660178f, 0.00356704f, -0.23491126f, 
    -0.00607676f, -0.07120983f, -0.17782351f, 0.09672643f, 0.11598854f, 0.00126280f, 0.12250759f, -0.10912842f, 
    -0.14080815f, 0.01193224f, 0.06066819f, 0.10265885f, -0.03782716f, -0.00883876f, -0.03179620f, 0.06420688f, 
    0.01820566f, -0.00965778f, 0.11405835f, 0.13650794f, -0.46735999f, -0.15188150f, -0.08279561f, -0.06416984f, 
    -0.01210621f, 0.11513795f, 0.00495326f, -0.09097546f, 0.10195237f, 0.05241022f, 0.09764415f, 0.12063492f, 
    0.08314238f, 0.25504506f, 0.08311912f, 0.09826548f, -0.00904836f, 0.06073757f, -0.07481954f, -0.01883498f, 
    0.00478477f, -0.06369195f, 0.04451529f, -0.01106848f, 0.18417826f, 0.31211925f, -0.08692783f, 0.12972952f, 
    0.03702023f, 0.02980715f, -0.01165414f, 0.06785494f, 0.04559251f, -0.01451976f, -0.11637892f, 0.10222767f, 
    0.22436477f, -0.02693027f, 0.05309071f, 0.02973351f, -0.00785634f, -0.11301599f, 0.03947547f, 0.01600890f, 
    0.02738906f, 0.03688383f, -0.16255157f, -0.01581445f, -0.18136488f, 0.05254811f, 0.12849924f, -0.07849032f, 
    -0.00125918f, -0.04654156f, 0.04849069f, 0.02287012f, 0.02072686f, 0.10412437f, -0.05469565f, 0.01461236f, 
    -0.17370239f, 0.15037601f, 0.07262452f, 0.06068894f, 0.04207122f, -0.08706245f, 0.05234099f, -0.02762992f, 
    -0.05778851f, 0.06791160f, 0.02123373f, 0.05489469f, -0.10074001f, -0.06331350f, 0.18155678f, -0.13655005f, 
    0.02494832f, 0.06492162f, 0.06636550f, 0.01120145f, 0.03273721f, -0.04760332f, 0.01779258f, 0.19963944f, 
    -0.06446293f, 0.14417730f, 0.03562162f, 0.04384375f, -0.04130430f, -0.13717034f, -0.00667990f, 0.06278373f, 
    0.18930650f, -0.00864599f, 0.09342056f, -0.04822125f, 0.07575933f, -0.13917725f, 0.14019069f, 0.10675171f, 
    0.03929021f, -0.11721472f, 0.03162234f, -0.04853419f, 0.02926295f, 0.02129238f, 0.06199927f, -0.06749301f, 
    -0.13353394f, 0.25165901f, 0.10134850f, 0.04998868f, -0.03889029f, 0.10019027f, -0.06133781f, 0.05250163f, 
    0.01711244f, -0.13041420f, 0.04224951f, -0.08652069f, -0.45917961f, -0.24906145f, -0.06274434f, -0.16366996f, 
    0.15489721f, 0.05478397f, 0.10071865f, 0.07003146f, -0.03768539f, -0.08178055f, -0.01699868f, -0.01249017f, 
    -0.09947866f, 0.10018954f, -0.07614187f, 0.12451337f, 0.02030792f, -0.01647627f, -0.06304032f, -0.01329100f, 
    -0.02082415f, -0.11696718f, 0.10477829f, -0.04362366f, 0.06177719f, 0.00143067f, -0.06109580f, 0.01940895f, 
    0.00146564f, 0.12876564f, 0.02920059f, -0.15228343f, -0.03934749f, 0.04695381f, -0.02824789f, 0.11198159f, 
    0.03547402f, 0.17734219f, -0.00154361f, 0.04445618f, 0.07263263f, 0.03821147f, 0.02984493f, 0.09256069f, 
    -0.01665128f, -0.03907037f, 0.14476614f, 0.04454586f, -0.12382253f, -0.07288249f, -0.22085914f, 0.10039993f, 
    -0.01874511f, 0.16718006f, -0.04544840f, 0.15325059f, 0.03613413f, 0.05680130f, -0.01941537f, -0.03679942f, 
    0.05400339f, 0.02478083f, 0.07100713f, 0.11625008f, -0.02909484f, 0.01046383f, 0.03622293f, -0.01320069f, 
    -0.08745160f, -0.05387161f, -0.02098474f, -0.15532368f, 0.04264393f, -0.01598981f, -0.14363587f, -0.08204118f, 
    0.04848938f, 0.05377938f, 0.02158283f, -0.18422878f, 0.02265943f, -0.07561892f, 0.08044147f, 0.02758976f, 
    0.23995647f, 0.01073553f, -0.18425682f, 0.06978854f, 0.07302479f, -0.00454340f, -0.12939478f, 0.07979561f, 
    0.02760331f, 0.01643956f, 0.03486652f, -0.00583202f, 0.08601768f, -0.07987660f, 0.03065799f, 0.04745581f, 
    -0.07016965f, 0.00592625f, 0.13088074f, -0.02107660f, -0.04584243f, 0.03014510f, -0.04289446f, 0.05881825f, 
    -0.39792100f, -0.20366465f, 0.06198897f, -0.05165532f, -0.05909664f, 0.05504340f, 0.04813575f, -0.00298090f, 
    0.03223479f, 0.03048425f, -0.04141672f, 0.00252772f, -0.24653234f, -0.02696296f, 0.02490020f, 0.00619211f, 
    0.05301810f, 0.09849983f, -0.03839598f, -0.10516628f, 0.00391204f, -0.04010376f, 0.03317901f, 0.07678212f, 
    0.01388351f, -0.25413328f, 0.03065199f, 0.11806396f, 0.05354002f, 0.00111524f, 0.06235076f, 0.12392652f, 
    0.09928966f, -0.07202926f, 0.01498800f, 0.14679626f, 0.12984122f, 0.08680447f, 0.10863639f, 0.12484080f, 
    -0.01856005f, -0.12342337f, 0.02114902f, 0.04194159f, -0.03432204f, 0.12125765f, 0.06965427f, 0.03974621f, 
    0.15027975f, -0.06896447f, 0.10347028f, 0.04458459f, -0.02555433f, 0.02048017f, 0.11160040f, -0.04368082f, 
    0.03000115f, 0.10804628f, 0.06880626f, 0.02966898f, -0.27125373f, 0.27457741f, 0.14224578f, -0.01556304f, 
    0.05121614f, 0.01592420f, 0.00703342f, 0.10767663f, 0.03757973f, -0.05963663f, -0.03935903f, 0.05659549f, 
    0.36522502f, -0.28382140f, 0.04720543f, 0.20312774f, 0.02277838f, 0.04818895f, 0.02143754f, -0.02425863f, 
    0.10915653f, 0.03693518f, 0.04980463f, 0.04333900f, -0.07004604f, 0.19233544f, -0.07273963f, -0.21813773f, 
    0.03880601f, -0.02821984f, 0.01332140f, 0.05203437f, 0.12625755f, -0.01429381f, -0.05801088f, 0.09565523f, 
    0.19727512f, -0.05372983f, 0.13545299f, -0.02677643f, -0.15683363f, -0.01272903f, 0.01388780f, 0.02393178f, 
    0.04482076f, 0.03204316f, -0.11260175f, 0.00434900f, -0.23618083f, 0.04570452f, -0.10808318f, -0.05622577f, 
    -0.05522878f, 0.00821620f, 0.01775024f, -0.04170112f, -0.11992466f, -0.04803735f, 0.03842341f, -0.03315824f, 
    0.38842699f, -0.04712281f, 0.20167953f, 0.30922034f, -0.08536678f, 0.04223798f, 0.02064546f, 0.03217497f, 
    0.15926480f, -0.07610973f, 0.14123490f, -0.00515298f, 0.21881437f, -0.02182364f, -0.10889265f, -0.12443081f, 
    0.12516877f, 0.08694086f, -0.04068309f, 0.19390854f, 0.03791206f, 0.02474941f, -0.02898408f, -0.13447960f, 
    0.01395592f, 0.02615008f, -0.04049815f, -0.02656217f, 0.05488474f, -0.06707781f, -0.02970046f, -0.03922257f, 
    0.00642992f, -0.02990029f, 0.06318013f, -0.04234882f, -0.00063524f, 0.03892642f, 0.06038246f, 0.00244056f, 
    -0.01655718f, 0.02653848f, 0.05013924f, 0.03678998f, -0.01166952f, -0.01405636f, -0.04801476f, -0.05480505f, 
    -0.03077430f, -0.02934681f, 0.05903521f, -0.06841530f, 0.00648135f, -0.07254523f, 0.02895741f, -0.02649589f, 
    0.02713731f, 0.04338188f, -0.01044278f, 0.02521878f, 0.02605428f, 0.05574755f, -0.03831468f, -0.07628008f, 
    0.00053337f, 0.02118604f, -0.05507726f, -0.01555304f, -0.06647986f, -0.04460347f, 0.05155493f, 0.01053152f, 
    -0.06021332f, -0.06774871f, -0.06071081f, 0.00794559f, 0.01942257f, -0.04512918f, -0.07087670f, -0.06255544f, 
    -0.06751067f, -0.01940929f, -0.01519516f, 0.00029456f, -0.07270569f, 0.06063531f, 0.00650743f, 0.02836714f, 
    -0.01234288f, -0.00870424f, 0.05596737f, 0.02904383f, 0.00201254f, -0.03390249f, 0.00712796f, 0.00097470f, 
    0.05731109f, -0.05606461f, -0.06156798f, 0.04195147f, 0.01572418f, 0.02219185f, 0.04226706f, -0.06123304f, 
    -0.06989089f, 0.01808525f, -0.06501288f, -0.00847102f, -0.07607783f, 0.05913910f, -0.06850374f, -0.03144307f, 
    -0.05190020f, 0.02691232f, -0.04131497f, 0.00709721f, -0.03670706f, -0.00799358f, 0.01712398f, 0.05105060f, 
    -0.00033744f, -0.01348887f, -0.01377553f, -0.05741889f, 0.00635042f, 0.04159614f, 0.01613726f, 0.00687475f, 
    -0.01285962f, -0.00779737f, 0.05969273f, 0.04618913f, -0.04929196f, -0.02979736f, -0.05546886f, -0.01182684f, 
    -0.07244866f, -0.06913077f, -0.06267079f, -0.05409741f, 0.05483915f, 0.01321456f, -0.02526189f, 0.04332428f, 
    0.03990007f, -0.07786275f, -0.01353739f, -0.02352291f, -0.04317749f, -0.00877680f, 0.04716081f, -0.01055364f, 
    -0.06872296f, 0.05840566f, -0.05443015f, -0.00838415f, 0.03885803f, 0.05476634f, -0.00979844f, -0.04294107f, 
    0.02723940f, -0.01268954f, 0.03506897f, -0.07601185f, 0.02092011f, 0.03451728f, 0.02505225f, -0.04801418f, 
    -0.03572062f, -0.04926646f, -0.05955076f, 0.06925740f, -0.05610803f, -0.00678412f, 0.01300522f, 0.03967443f, 
    -0.07766829f, 0.04341521f, 0.01386726f, 0.00920940f, 0.00539401f, -0.07453260f, 0.06124177f, -0.07777672f, 
    0.00163722f, -0.01515852f, 0.00157045f, 0.02083169f, -0.04573588f, -0.01096269f, 0.03316044f, -0.01120434f, 
    -0.04857212f, 0.04239972f, 0.06199133f, -0.07279658f, -0.00387328f, 0.05107002f, 0.04621768f, -0.02784436f, 
    -0.02274992f, 0.04139691f, 0.00598894f, -0.01734206f, -0.07917885f, -0.03697523f, 0.04747270f, -0.01910368f, 
    -0.07082781f, 0.03932371f, 0.03897393f, 0.01180461f, -0.06245508f, 0.00331089f, 0.03027987f, -0.07998308f, 
    -0.07760781f, 0.05751184f, -0.04151603f, -0.02110255f, -0.01115972f, 0.00130688f, -0.05612761f, -0.08103865f, 
    -0.04287039f, -0.00271589f, 0.04713253f, -0.05608765f, 0.03854275f, -0.04701036f, -0.01328749f, -0.06009901f, 
    -0.02118867f, 0.05254434f, -0.00196286f, -0.02365943f, -0.03887230f, -0.04612773f, 0.04186665f, 0.01994550f, 
    -0.02540541f, -0.01448869f, 0.03466174f, -0.05809182f, 0.01179571f, 0.02280634f, -0.04333763f, 0.00445218f, 
    -0.05039381f, 0.02629220f, -0.00597431f, 0.01774570f, -0.08147567f, -0.06543424f, 0.02715101f, -0.01176603f, 
    -0.02587670f, 0.05289834f, 0.05777388f, -0.03646813f, 0.04115882f, -0.06159152f, -0.00198730f, 0.04835985f, 
    -0.00816442f, 0.05159388f, 0.02912968f, 0.02278786f, 0.05708259f, -0.06058324f, 0.06236432f, -0.05393460f, 
    -0.00393345f, -0.04816945f, -0.07618482f, -0.04027162f, 0.05372294f, 0.05112010f, -0.04777939f, 0.03486247f, 
    0.02761617f, -0.02704542f, -0.04180692f, -0.03758543f, -0.02611746f, 0.06165472f, -0.00558406f, -0.04352596f, 
    0.04169342f, 0.04062691f, -0.01266841f, -0.07551414f, 0.04394617f, -0.05187479f, 0.05931833f, 0.03199905f, 
    0.05526290f, 0.05927795f, -0.04910397f, -0.03278267f, 0.01365584f, -0.03208591f, 0.01838946f, -0.03857777f, 
    0.00862216f, 0.06139782f, -0.05512933f, -0.07580021f, -0.03406480f, -0.01831169f, 0.03254265f, 0.06021438f, 
    0.01404546f, -0.00315143f, -0.06354342f, -0.02975127f, 0.04542164f, -0.03824989f, 0.00264628f, -0.04282312f, 
    0.04795615f, -0.07679617f, -0.03741438f, 0.00976827f, -0.04176380f, 0.04708580f, -0.06340190f, 0.00143722f, 
    -0.04055015f, 0.04970980f, 0.05943241f, 0.04673270f, 0.00887538f, -0.06210626f, -0.04197465f, 0.04780005f, 
    0.02467295f, 0.03729152f, -0.06674428f, -0.02620638f, 0.00733265f, -0.01356773f, -0.01781937f, 0.02723021f, 
    0.01848508f, -0.07417455f, 0.04960861f, 0.01854738f, 0.00984101f, 0.01310596f, -0.06045417f, -0.03943294f, 
    -0.04949858f, 0.01247727f, -0.07443766f, 0.05188318f, 0.05647330f, 0.04147646f, -0.06408374f, 0.02771601f, 
    -0.04414826f, -0.04375054f, -0.02126080f, -0.06297240f, 0.02966230f, 0.04199808f, -0.05091187f, -0.07764686f, 
    -0.02332073f, 0.01075089f, 0.01694097f, -0.03071031f, -0.02433803f, -0.04593826f, -0.07997800f, -0.01625286f, 
    0.02931244f, -0.02365967f, -0.00958018f, -0.03981868f, 0.05804492f, 0.00784058f, -0.06283569f, -0.04669262f, 
    0.04999245f, 0.01662090f, -0.02951473f, 0.02688267f, 0.05624221f, -0.01147659f, 0.02802620f, -0.04599621f, 
    -0.06845960f, -0.00369934f, -0.07784136f, -0.05424706f, -0.02567801f, -0.06375924f, -0.00811682f, -0.04766363f, 
    0.05507036f, 0.00382697f, -0.04751274f, -0.02622759f, 0.04318419f, -0.06623937f, -0.02414802f, -0.06157655f, 
    -0.00563710f, 0.00367647f, 0.08865438f, 0.24401343f, -0.02461785f, 0.11222585f, -0.03070083f, 0.06985547f, 
    -0.02729043f, -0.01021400f, 0.10685897f, 0.14845772f, -0.14475435f, -0.02711615f, 0.04816480f, 0.08421875f, 
    0.07473236f, -0.14553645f, -0.01115338f, 0.12715895f, 0.02485427f, 0.21915935f, 0.04947424f, 0.12977928f, 
    -0.04329921f, 0.05191171f, 0.04802261f, -0.06512591f, 0.00785702f, 0.04257552f, 0.12579863f, 0.04011641f, 
    -0.05053510f, 0.00894774f, 0.00080520f, -0.03517978f, 0.05536083f, -0.22088000f, 0.09648798f, -0.06204484f, 
    0.19453928f, 0.12415225f, -0.14194918f, 0.04667413f, -0.15301217f, -0.13982399f, -0.04727979f, 0.00969274f, 
    0.31257719f, 0.21175328f, -0.10806549f, -0.23078912f, -0.08384944f, 0.07917219f, 0.14142464f, 0.01241274f, 
    -0.04641029f, 0.11781485f, -0.06432256f, 0.03527283f, -0.00076279f, -0.02303664f, 0.09929156f, 0.14933534f, 
    0.07838298f, 0.03601378f, -0.01735722f, 0.12118889f, 0.08337218f, -0.01015099f, -0.09362898f, -0.06553251f, 
    0.14995818f, 0.01880443f, 0.06866693f, 0.11193543f, 0.05199686f, -0.04612156f, -0.05081433f, -0.09797991f, 
    -0.14627461f, 0.17455694f, -0.09774327f, -0.02949373f, -0.15888664f, -0.06186297f, 0.08741008f, -0.12619017f, 
    0.00775765f, 0.11617971f, -0.06846351f, -0.10035151f, -0.02931605f, -0.13531597f, 0.04462019f, 0.00628416f, 
    0.10688387f, 0.17278856f, -0.01799918f, 0.05845543f, -0.05137583f, 0.14030725f, 0.10190508f, -0.03207247f, 
    0.04497465f, -0.04827245f, -0.01565234f, 0.04132942f, -0.04311170f, 0.06133080f, -0.02032703f, -0.02456196f, 
    -0.04776318f, -0.04466743f, 0.12438628f, 0.06731000f, -0.00592610f, -0.11335242f, 0.00930700f, -0.11464240f, 
    0.05324070f, -0.00469911f, 0.26529193f, 0.04537970f, -0.16645861f, -0.05936026f, -0.02968257f, 0.06590185f, 
    0.08850182f, -0.06987315f, -0.00730259f, -0.11286114f, -0.08557777f, -0.06518260f, 0.06456354f, 0.04067725f, 
    0.04857035f, 0.08931969f, -0.04648371f, 0.04176018f, -0.07864130f, -0.09664793f, 0.08511592f, 0.15250817f, 
    0.19510180f, 0.04919242f, -0.14530028f, -0.08488660f, -0.08405386f, 0.02310490f, -0.01672978f, 0.04491788f, 
    -0.11567894f, -0.05710041f, 0.06526259f, 0.00185566f, -0.16511862f, 0.05996544f, -0.12131545f, -0.08934401f, 
    0.07043118f, 0.11980240f, -0.02697580f, -0.07110042f, 0.02256662f, 0.03609524f, -0.04119126f, 0.01037435f, 
    0.07088053f, 0.24131635f, 0.07425065f, -0.20451672f, 0.01594117f, -0.03562186f, -0.06117604f, 0.15469530f, 
    -0.06907875f, -0.01725126f, -0.02344739f, -0.01365594f, 0.01072306f, -0.40087613f, 0.03589159f, -0.05560425f, 
    -0.13591841f, -0.05839518f, 0.30497941f, -0.07887012f, -0.14398386f, 0.05108568f, -0.00494724f, 0.08352423f, 
    -0.12886295f, 0.08841400f, -0.01885842f, -0.08812426f, -0.09996802f, 0.08693988f, -0.00202274f, 0.00602935f, 
    -0.02455030f, -0.00997899f, 0.03890045f, 0.12311694f, -0.28857055f, 0.08531971f, -0.06734809f, 0.02478584f, 
    0.12384307f, 0.07885355f, 0.15920566f, 0.07171276f, 0.15111290f, 0.00618290f, 0.06980055f, -0.05676494f, 
    -0.16063699f, 0.26221448f, 0.10370982f, 0.05161398f, 0.05569427f, 0.11394003f, 0.07630923f, 0.05120558f, 
    -0.01078033f, 0.02520420f, -0.00329497f, -0.06623153f, -0.25165361f, -0.10995042f, -0.03096416f, 0.25699890f, 
    -0.03231477f, -0.03330164f, -0.20095947f, 0.23417185f, 0.08521558f, 0.02626174f, 0.00078575f, -0.00280468f, 
    0.20909443f, -0.12962595f, 0.05994949f, -0.09374362f, 0.10501520f, -0.14183418f, -0.06387725f, 0.05043833f, 
    -0.05165838f, 0.01614700f, 0.00138216f, 0.06376918f, 0.17197885f, 0.08934808f, 0.13184807f, 0.12302006f, 
    -0.02361850f, -0.04306426f, -0.02524074f, -0.07544141f, 0.06044138f, 0.19667998f, 0.03428125f, -0.08291939f, 
    0.20704037f, 0.16796313f, 0.17040174f, 0.23493069f, 0.15160771f, 0.07285588f, -0.02712312f, -0.05062037f, 
    0.05856482f, 0.11732566f, 0.09190075f, -0.00928847f, 0.23986626f, -0.00455305f, 0.17994097f, -0.00956088f, 
    0.01600908f, 0.11812727f, 0.09933337f, -0.07866009f, 0.00805188f, -0.00598176f, -0.12803435f, 0.15719418f, 
    -0.37406254f, 0.18378542f, -0.06249432f, -0.08243664f, -0.06027181f, -0.13933592f, -0.04113116f, -0.10213832f, 
    0.00354215f, -0.03483704f, -0.09119484f, 0.00069370f, -0.07428139f, -0.17391586f, 0.00926234f, -0.00619401f, 
    -0.06261768f, -0.12648305f, 0.04099118f, 0.04543092f, -0.04664264f, 0.08560707f, -0.01837775f, -0.08991104f, 
    -0.27546617f, 0.02729202f, -0.06583481f, -0.16222180f, 0.04454041f, -0.02197333f, -0.00266534f, -0.10398405f, 
    -0.10791447f, -0.16045046f, 0.03499851f, 0.03912098f, -0.16726094f, -0.01724352f, 0.09079036f, -0.05316710f, 
    0.18635391f, 0.17459613f, 0.09387979f, 0.14925620f, -0.10766584f, -0.04517587f, 0.03898687f, 0.01209107f, 
    -0.27359718f, 0.02537341f, 0.05500226f, -0.03116884f, 0.01156427f, 0.01146391f, -0.06201968f, 0.07192587f, 
    0.04301734f, -0.08377340f, -0.07828452f, -0.03068555f, -0.12540878f, 0.03573132f, -0.04762232f, -0.07472717f, 
    0.04820811f, 0.09531539f, 0.01163114f, 0.01928586f, 0.03198959f, 0.01506615f, -0.10651099f, 0.04664382f, 
    -0.12724890f, 0.00378557f, 0.11032043f, 0.22202834f, 0.03178678f, 0.07978021f, -0.05207855f, 0.05724143f, 
    -0.01616202f, -0.07030599f, 0.04105634f, 0.13867624f, -0.04263953f, -0.09816255f, 0.04135690f, 0.20858008f, 
    -0.02914037f, 0.13063656f, -0.02146662f, -0.01404211f, 0.02093262f, 0.11881077f, -0.15070954f, 0.12600066f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06676352f, 0.01350976f, 0.02960301f, -0.02463220f, -0.04759594f, 0.01666228f, -0.00608926f, 0.03007815f, 
    0.10246883f, 0.02485034f, -0.07847606f, -0.01669353f, 0.05828501f, 0.00971380f, 0.08412661f, -0.00462962f, 
    0.05018930f, -0.03762765f, 0.04364030f, 0.12043504f, -0.03605856f, 0.02210063f, 0.01096154f, 0.04991355f, 
    -0.03288965f, -0.03988648f, -0.04299258f, 0.05409648f, -0.11444012f, -0.00999308f, 0.09382088f, -0.03282896f, 
    -0.03844887f, 0.09976228f, 0.03916902f, 0.08250140f, 0.05153190f, 0.11626889f, -0.04395514f, -0.02890822f, 
    0.04614970f, 0.10110828f, 0.04118266f, 0.00350240f, 0.07447769f, -0.03036540f, 0.05300600f, 0.01343289f, 
    0.02025233f, -0.03440252f, 0.05777826f, -0.05954889f, -0.01184832f, 0.12002499f, -0.04560313f, -0.15406592f, 
    0.09165384f, 0.04764433f, 0.08935617f, -0.00648921f, 0.02439716f, -0.04462361f, 0.07231393f, -0.05221292f, 
    -0.06360105f, 0.11056327f, 0.00169184f, -0.02553209f, -0.04427353f, -0.10161314f, 0.00036283f, 0.11029413f, 
    0.02144000f, 0.04481004f, 0.10833119f, 0.09138760f, 0.01520550f, -0.03208165f, -0.06811675f, -0.04333277f, 
    -0.01551544f, -0.06760065f, -0.03269768f, 0.08009103f, 0.00940544f, 0.00094731f, 0.02377588f, 0.16768602f, 
    0.07933929f, 0.00078478f, 0.00727682f, -0.08188375f, 0.06181888f, 0.14982139f, 0.01639687f, 0.05079906f, 
    -0.06076667f, 0.01328052f, -0.11921839f, -0.03530829f, -0.08299985f, -0.05627171f, 0.17164345f, 0.10985041f, 
    0.02510723f, 0.03324475f, 0.04445168f, -0.03130219f, 0.00459383f, -0.04755707f, 0.02761384f, 0.01207927f, 
    -0.03627323f, 0.09585448f, -0.05040526f, 0.06179364f, 0.03728645f, 0.08637440f, 0.09339708f, -0.08074478f, 
    -0.11816210f, -0.07501360f, 0.01204837f, 0.04966965f, -0.00477555f, 0.00405584f, 0.05251109f, 0.07639323f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.02323618f, 0.14700039f, 0.13393460f, 0.06233929f, 0.04682190f, -0.06741895f, -0.06202401f, 0.15544823f, 
    -0.72286069f, 0.07271727f, 0.34756270f, 0.10252972f, 0.02417356f, 0.18264982f, -0.11642352f, -0.21311732f, 
    -0.44586125f, 0.05630086f, -0.41147855f, -0.44803268f, 0.07417886f, 0.18465993f, -0.05841563f, 0.18238090f, 
    0.00871198f, 0.19507386f, 0.16508956f, 0.00144786f, -0.07223587f, 0.00858033f, -0.21836273f, 0.01556665f, 
    -0.28012255f, -0.31653264f, 0.02860775f, 0.05575909f, 0.04840351f, -0.04327342f, -0.06327109f, -0.04657926f, 
    -0.09391177f, -0.25083339f, 0.09427834f, -0.42081565f, 0.14785548f, -0.06019001f, 0.00488213f, 0.00731692f, 
    -0.04985427f, 0.02058847f, -0.00768127f, -0.05114828f, 0.04613255f, -0.16780224f, -0.02940691f, 0.04511339f, 
    -0.07242895f, -0.19213356f, 0.02370271f, -0.01973660f, -0.34363428f, -0.01808565f, -0.12722126f, 0.04385537f, 
    0.04735136f, -0.06731920f, 0.18158224f, -0.37286395f, 0.32585204f, 0.08804769f, -0.04170050f, -0.32075638f, 
    -0.09250509f, 0.13657472f, 0.12214184f, -0.08400857f, 0.03514156f, 0.05039727f, 0.02480848f, -0.15097252f, 
    0.04685042f, -0.04506130f, 0.00969043f, -0.07637041f, 0.10538596f, 0.03785075f, -0.00141546f, -0.18945253f, 
    -0.01458905f, -0.09641746f, -0.43618101f, -0.33547223f, 0.08159880f, -0.02089156f, 0.08109647f, 0.13543417f, 
    -0.06226083f, -0.00023243f, 0.13229300f, -0.07679573f, 0.02326568f, 0.31646857f, -0.24275684f, -0.05950727f, 
    0.33676013f, -0.01090672f, -0.22242025f, 0.03170360f, -0.04823569f, 0.06190908f, 0.30864415f, -0.02992848f, 
    0.21653797f, -0.04387388f, 0.04814890f, -0.08973508f, -0.50751561f, -0.07583079f, -0.25808388f, 0.21845528f, 
    0.23366375f, 0.02167105f, -0.14784135f, 0.12723558f, 0.01005782f, -0.04823240f, 0.02239093f, -0.03741951f, 
    0.06863769f, 0.10314904f, 0.00312288f, -0.05728756f, -0.26021358f, -0.06688263f, -0.02113399f, -0.10100115f, 
    0.17403701f, 0.07749408f, -0.08850539f, -0.23328803f, -0.02793876f, -0.12562475f, 0.21414627f, 0.03251444f, 
    0.01855633f, -0.10333684f, -0.14474510f, 0.05598084f, -0.08061600f, -0.08361421f, 0.01438833f, 0.23786484f, 
    0.10909240f, -0.39771384f, -0.33179528f, 0.23457524f, -0.21433800f, -0.06486056f, -0.43907753f, 0.03485483f, 
    -0.31240755f, 0.03404468f, -0.07104793f, -0.01630166f, -0.19622688f, 0.13440382f, 0.07671361f, -0.08734797f, 
    -0.00599193f, -0.20379888f, 0.21248265f, -0.18792085f, 0.14583744f, 0.18094185f, 0.05486717f, 0.07327857f, 
    0.19492857f, 0.02422511f, 0.02949464f, 0.20211494f, 0.20123960f, -0.10131598f, -0.00095117f, 0.15856025f, 
    -0.00739021f, 0.02118618f, 0.07304288f, 0.07985590f, -0.08538917f, 0.01826641f, -0.08751392f, -0.05140816f, 
    -0.39341712f, 0.18723351f, -0.27860844f, -0.12179861f, 0.25712782f, -0.14905712f, 0.01886387f, -0.00427525f, 
    0.17264135f, 0.17531405f, 0.07869365f, -0.58515441f, 0.03120838f, -0.02301584f, 0.06851976f, -0.25547418f, 
    -0.07714800f, 0.00419991f, 0.06245304f, 0.07445552f, 0.10483442f, -0.03366187f, 0.07811493f, 0.11628810f, 
    0.18653464f, -0.29364845f, 0.23017626f, -0.22096759f, -0.01468982f, 0.21917702f, -0.02982874f, -0.24213021f, 
    0.00703901f, -0.01790557f, -0.12103397f, 0.12083257f, 0.00195221f, -0.00415690f, 0.25034899f, -0.05998033f, 
    -0.59269905f, -0.08833525f, 0.10498060f, 0.16945609f, 0.24757417f, 0.03658126f, 0.23865180f, 0.01679274f, 
    -0.16837704f, 0.05890169f, -0.01224805f, -0.08352245f, -0.02442816f, 0.14774105f, -0.05272981f, 0.17840974f, 
    -0.07990326f, -0.04045865f, -0.09427170f, 0.18945113f, 0.04841767f, 0.08337947f, 0.07582001f, -0.53169286f, 
    -0.01176058f, -0.07089021f, -0.06106841f, 0.04807673f, -0.19686373f, -0.24594297f, 0.06460714f, -0.14886436f, 
    -0.34141403f, 0.03633369f, -0.09349795f, -0.13804676f, -0.32864115f, -0.13595034f, 0.00454690f, 0.06621514f, 
    -0.14453731f, 0.34399599f, -0.29867944f, 0.11994703f, -0.03800758f, 0.01911579f, -0.01966922f, 0.14998841f, 
    0.00836511f, 0.05197194f, -0.29752517f, -0.22063297f, 0.35663250f, -0.09695628f, -0.31561145f, 0.07476459f, 
    0.07538160f, -0.03334401f, 0.03815807f, -0.12277112f, -0.45880792f, 0.06942212f, -0.01308006f, 0.05843525f, 
    0.02280651f, 0.23312254f, 0.12212870f, -0.02271732f, -0.22408693f, 0.21531856f, 0.06281782f, -0.11723609f, 
    0.12929428f, -0.08503581f, -0.03814415f, -0.27400979f, 0.16013810f, 0.02884324f, -0.00245196f, -0.07106131f, 
    0.22162716f, 0.13081636f, -0.28141862f, -0.01957084f, -0.41180077f, 0.02545931f, 0.17845242f, 0.01375635f, 
    -0.09185284f, 0.04870165f, 0.18569778f, 0.18180302f, -0.11159822f, 0.15401547f, 0.06083452f, 0.13016413f, 
    -0.38936299f, -0.36987481f, -0.38666850f, 0.07270158f, -0.02791888f, 0.00751669f, -0.01144713f, 0.10293402f, 
    -0.03171701f, -0.06622640f, 0.03542104f, 0.15472618f, -0.06286618f, 0.06576513f, -0.06353881f, -0.46148795f, 
    0.18489201f, 0.28664926f, -0.15570885f, 0.12710422f, 0.04672825f, 0.04804027f, -0.05333072f, -0.17035440f, 
    -0.07613492f, 0.05680395f, 0.06905720f, -0.14024732f, 0.02013275f, 0.24918023f, -0.06579135f, -0.12851889f, 
    0.12006376f, 0.01615704f, -0.15082127f, -0.26287293f, 0.21093167f, -0.06585202f, 0.25151736f, 0.00419689f, 
    -0.04968889f, -0.42433223f, 0.25513792f, 0.02710362f, -0.37197343f, -0.11948577f, 0.13676926f, 0.03201709f, 
    0.02804945f, 0.07051629f, -0.32198271f, -0.14628169f, 0.04440211f, 0.01441874f, 0.05773603f, -0.13924082f, 
    0.01704166f, -0.17284144f, -0.57708073f, 0.18127476f, 0.14502604f, -0.01233887f, 0.04910317f, -0.09061595f, 
    -0.21270539f, 0.04768039f, 0.18118118f, 0.04439731f, 0.21382111f, 0.32166663f, -0.27329996f, -0.17369680f, 
    -0.15322587f, -0.28733668f, 0.02463664f, -0.23984456f, -0.05693439f, -0.39321497f, 0.04972207f, 0.06304940f, 
    -0.27093419f, 0.01857295f, 0.08849237f, -0.04127537f, 0.02114485f, -0.12971374f, 0.09076815f, 0.05123567f, 
    -0.02046333f, 0.13385798f, 0.07121586f, 0.07271718f, 0.02046797f, -0.14079377f, 0.07695101f, 0.02741971f, 
    -0.06089006f, -0.23407851f, 0.28077829f, -0.07703923f, 0.03196522f, -0.22955306f, 0.04461858f, 0.10348286f, 
    -0.00540970f, 0.06825843f, -0.05719031f, 0.17330378f, 0.07800939f, -0.04622895f, -0.00508440f, -0.06445731f, 
    0.23448406f, -0.06628897f, 0.07134482f, -0.08348358f, -0.00524064f, 0.06488077f, 0.23922966f, 0.08761697f, 
    -0.01659275f, -0.49670079f, 0.11764497f, 0.21862610f, -0.42002946f, 0.14049669f, -0.07055981f, 0.00117650f, 
    -0.26003179f, 0.11388842f, 0.14016634f, 0.17638375f, 0.01556523f, -0.08447193f, 0.07517681f, 0.26987216f, 
    -0.03713867f, -0.01592063f, 0.02407848f, -0.39159644f, -0.48569271f, 0.06863537f, -0.00533515f, -0.08918751f, 
    -0.50987965f, -0.32541806f, 0.18521887f, 0.16288061f, -0.23259622f, -0.01824750f, -0.12291320f, -0.18795186f, 
    -0.08356109f, 0.00645536f, -0.04567874f, 0.31469458f, 0.02932617f, -0.25092453f, -0.35648048f, -0.04837240f, 
    0.03106005f, 0.08175772f, -0.12431193f, 0.12307350f, 0.12916741f, 0.03776335f, 0.21324794f, -0.06550417f, 
    -0.13093536f, -0.03338237f, -0.21121231f, 0.17601696f, -0.16406269f, -0.37681922f, -0.68706965f, -0.20127776f, 
    0.12293623f, -0.20504303f, 0.04628988f, 0.08985972f, -0.05543751f, -0.05095563f, -0.00585253f, 0.13932942f, 
    -0.03030427f, -0.20230810f, 0.11956725f, -0.38952243f, -0.08775628f, 0.18801725f, 0.07655512f, -0.14566951f, 
    -0.38962233f, 0.06174940f, -0.32015580f, -0.07023913f, 0.04022890f, -0.14834869f, -0.23643516f, 0.00605032f, 
    0.09287164f, 0.16038357f, 0.06668009f, 0.16548868f, 0.02670525f, -0.29366544f, -0.02550906f, 0.01734177f, 
    -0.23725446f, 0.38785899f, 0.06537937f, -0.08503294f, 0.13117395f, -0.19138582f, 0.03958569f, -0.07678943f, 
    -0.03065505f, 0.15180962f, -0.01571181f, -0.04924110f, 0.21752262f, 0.07362688f, -0.06600303f, -0.06534125f, 
    -0.05484644f, -0.11612109f, -0.02168512f, -0.16248444f, -0.09310291f, -0.38040251f, 0.06978373f, 0.00427978f, 
    -0.19873862f, -0.01764099f, -0.02398415f, 0.29019880f, -0.35088626f, -0.03228792f, 0.08856937f, -0.01480298f, 
    0.03879441f, 0.30341265f, 0.15191367f, 0.04998688f, 0.02956551f, -0.06813405f, 0.06801266f, 0.06147020f, 
    0.13190538f, 0.04696580f, 0.11009848f, 0.19889618f, 0.08353481f, -0.01690346f, 0.04035728f, 0.06230956f, 
    0.31094769f, -0.37173599f, 0.12605885f, -0.10471639f, 0.03741460f, -0.07143155f, -0.02076484f, -0.01831125f, 
    -0.01202184f, -0.05235515f, 0.05925633f, -0.19105616f, 0.18306474f, 0.05733970f, -0.01476969f, -0.00806804f, 
    -0.05091665f, -0.00783886f, -0.22650982f, -0.01624320f, -0.10435089f, -0.01419626f, 0.02577037f, 0.18769084f, 
    0.02364987f, 0.04974340f, 0.17521141f, 0.05011204f, -0.10655081f, -0.36361921f, -0.04096986f, -0.14189544f, 
    0.25433069f, 0.05275534f, 0.41690633f, 0.11193423f, -0.12814611f, 0.03968925f, -0.15020697f, -0.02805544f, 
    0.12197319f, -0.09074403f, -0.05846655f, -0.38373807f, 0.31793225f, -0.25689960f, 0.04005009f, -0.14894512f, 
    -0.18073900f, -0.09568948f, 0.16499601f, -0.03996478f, 0.07965057f, -0.03290772f, 0.24458078f, 0.16366772f, 
    -0.05752907f, 0.15271668f, 0.18900988f, 0.09093428f, 0.12829806f, 0.17167678f, 0.00332660f, 0.22600956f, 
    0.23316656f, 0.01245394f, 0.07231534f, 0.05337044f, 0.08712666f, 0.04292558f, -0.15875936f, 0.18849374f, 
    0.22772799f, -0.28732836f, -0.21755847f, 0.27447134f, 0.00458851f, -0.14694507f, 0.02696124f, 0.07637037f, 
    0.03411833f, -0.13963497f, 0.03796319f, -0.08458444f, -0.04826403f, 0.05372395f, 0.10940463f, 0.01491210f, 
    0.08021692f, -0.51033580f, 0.02463969f, 0.03675304f, 0.02190832f, 0.17977829f, -0.06158985f, 0.00788954f, 
    0.04002849f, 0.12818439f, -0.07296287f, -0.05563467f, -0.24252203f, 0.03733411f, -0.00151985f, -0.18802136f, 
    -0.11326659f, 0.07381688f, 0.06123327f, -0.21633980f, -0.25322822f, 0.17150643f, -0.03564032f, -0.40348366f, 
    -0.23073830f, 0.03374882f, -0.17986670f, 0.01636068f, 0.24029011f, -0.00569317f, -0.23723397f, 0.00475705f, 
    -0.27577311f, 0.11919756f, -0.13041669f, 0.07738642f, -0.07946701f, -0.32989714f, -0.07049037f, 0.06547243f, 
    0.12938571f, 0.00571659f, 0.07638425f, -0.15998659f, -0.00384345f, -0.07582583f, 0.01579699f, 0.00768392f, 
    0.02488788f, 0.04178460f, -0.00382991f, 0.08211382f, -0.29292685f, 0.04034443f, -0.06123128f, 0.09676055f, 
    -0.18117954f, -0.15513772f, 0.10856702f, -0.30291620f, -0.01174324f, -0.09683061f, -0.04411786f, -0.03532076f, 
    0.04780772f, -0.02171588f, -0.10085790f, -0.22933249f, -0.02551001f, 0.14573193f, 0.18487951f, 0.22615889f, 
    0.18446872f, -0.07923013f, -0.61780739f, 0.25091958f, -0.18896009f, 0.04909204f, -0.26666051f, -0.04785198f, 
    -0.02403060f, 0.28451917f, -0.37804583f, -0.36818719f, 0.19790304f, 0.08851540f, -0.15697661f, 0.32892790f, 
    0.11558942f, 0.23242538f, 0.06315211f, 0.20140579f, 0.06108223f, -0.08433562f, -0.22916001f, 0.08317252f, 
    -0.08165752f, 0.01090188f, 0.05314361f, 0.20726882f, 0.25720197f, 0.09369765f, 0.00727954f, 0.11359593f, 
    0.36248422f, 0.02007391f, -0.43064335f, 0.22871457f, 0.06684392f, -0.15738468f, 0.06896307f, 0.13607536f, 
    0.20851044f, -0.09272367f, 0.13589038f, -0.68086517f, 0.01164579f, 0.15926124f, -0.04689461f, -0.06970405f, 
    0.06126372f, -0.00012098f, -0.08217264f, -0.36953554f, 0.04141300f, -0.09735879f, 0.16466475f, 0.08163945f, 
    0.16473743f, 0.07170235f, 0.01164680f, 0.08882841f, -0.20404278f, -0.21718957f, 0.02993420f, -0.05604983f, 
    -0.06586774f, 0.03897222f, -0.14595455f, 0.15505123f, 0.30182919f, -0.13436598f, 0.05992284f, 0.16840944f, 
    -0.15836617f, -0.04079045f, -0.05738801f, -0.20568374f, -0.39234570f, 0.07365662f, 0.07877153f, 0.00391587f, 
    -0.24770576f, -0.47257000f, 0.04770166f, 0.03483616f, 0.05932396f, -0.08330341f, -0.38649631f, -0.00752562f, 
    0.20321135f, -0.07197957f, -0.14917111f, 0.10513580f, -0.36246708f, 0.28819025f, 0.07775068f, -0.21481302f, 
    0.19000572f, -0.00092917f, 0.14079084f, -0.11973340f, 0.03599869f, 0.03541892f, 0.00393202f, 0.16838565f, 
    0.03777846f, -0.02192053f, 0.02184208f, 0.04352006f, 0.00226065f, 0.05887387f, -0.00573862f, -0.13628995f, 
    -0.25852743f, 0.22466432f, -0.59011185f, 0.08428361f, 0.06073162f, -0.08634341f, 0.12637681f, 0.07067503f, 
    0.03733246f, 0.03917959f, -0.01908527f, 0.09081902f, -0.03471983f, -0.23979113f, 0.06642295f, -0.58127040f, 
    -0.18317500f, 0.05630024f, -0.33866996f, -0.19864887f, -0.03930508f, -0.04129732f, -0.04832326f, 0.06561930f, 
    -0.47908831f, -0.62915236f, 0.28293073f, 0.04196044f, -0.55406982f, 0.08869001f, 0.17181194f, -0.00472531f, 
    0.12396002f, -0.20770317f, 0.19319333f, -0.05736407f, 0.06489187f, -0.03129184f, 0.05940040f, -0.00249932f, 
    -0.07074703f, -0.25182024f, -0.28920770f, 0.01684531f, 0.16085915f, -0.25816953f, -0.00770094f, -0.10409046f, 
    -0.16665585f, 0.04653811f, 0.23674645f, 0.10059083f, -0.48040426f, 0.05409103f, -0.17378806f, 0.25624046f, 
    0.00047591f, 0.07895960f, 0.11651506f, 0.09515233f, -0.02666617f, -0.12478197f, 0.08122343f, -0.35034475f, 
    0.05738886f, 0.18969889f, 0.06409927f, 0.03549319f, 0.06508166f, -0.34725371f, 0.21375766f, -0.06560642f, 
    0.19297731f, 0.08058064f, -0.07842004f, -0.21843812f, 0.14619708f, -0.11541565f, 0.04685433f, -0.05268877f, 
    0.01369339f, -0.14069442f, -0.16868548f, 0.03845670f, -0.24745443f, 0.16213842f, 0.04171290f, -0.23585856f, 
    -0.10152366f, -0.08523989f, 0.09175864f, -0.00142436f, -0.04188886f, 0.19461299f, 0.02310352f, 0.27346215f, 
    -0.01281320f, 0.25116286f, -0.36536652f, -0.05410128f, -0.15732366f, 0.01206983f, -0.14914170f, 0.05048818f, 
    0.04681384f, -0.14887348f, 0.12741786f, -0.04301507f, -0.33884341f, 0.10541072f, -0.00714886f, 0.03282555f, 
    0.07766088f, 0.07399080f, -0.14260331f, -0.05349649f, -0.04037422f, 0.05014735f, 0.00478299f, 0.10679925f, 
    0.00030678f, -0.00497157f, -0.08231319f, -0.33467045f, 0.09055369f, -0.06646945f, -0.00803967f, -0.18571272f, 
    0.06428473f, 0.07687796f, 0.14820127f, 0.18850696f, -0.19401604f, -0.43726000f, -0.38624722f, 0.07759508f, 
    -0.01427885f, 0.07449475f, 0.04729074f, -0.32404634f, 0.03195659f, 0.02958698f, -0.27567264f, 0.12868275f, 
    0.23938830f, 0.03454019f, 0.23393972f, -0.01496020f, -0.29005131f, 0.03143279f, -0.16139069f, -0.07295109f, 
    0.29187486f, 0.15509640f, -0.00420171f, 0.11930943f, 0.19543661f, 0.10993781f, -0.04615544f, 0.08850519f, 
    0.15249954f, -0.08147626f, -0.16026182f, -0.26527235f, -0.05423322f, -0.07658143f, -0.13942716f, 0.18232949f, 
    0.03589630f, -0.27928108f, 0.13666178f, 0.21260932f, -0.30021071f, -0.00053250f, -0.05277671f, -0.40013215f, 
    -0.20370799f, -0.04984366f, 0.03877563f, -0.35467765f, 0.15483527f, -0.42553180f, 0.10445576f, -0.26118523f, 
    0.10545301f, -0.37135640f, 0.09766543f, 0.20870250f, 0.06457324f, 0.10319532f, 0.03480523f, -0.34284872f, 
    0.19816381f, -0.03098363f, -0.18100385f, 0.16783741f, -0.05465716f, 0.34098455f, -0.16888829f, -0.09572934f, 
    -0.21558547f, -0.10963433f, -0.04940391f, -0.58940947f, 0.02042929f, -0.23876593f, 0.05826893f, 0.01049086f, 
    -0.06718814f, -0.13719989f, 0.16820523f, 0.17223811f, -0.27549899f, 0.05329092f, -0.00499799f, 0.10715715f, 
    0.24919932f, -0.00897604f, -0.08367293f, 0.12498701f, -0.14932629f, -0.17806597f, 0.04065095f, 0.14118183f, 
    0.10630678f, 0.25043669f, -0.21748033f, 0.05462997f, -0.12179550f, -0.02002688f, -0.14132544f, 0.00610900f, 
    -0.12417535f, 0.18739511f, 0.00562332f, 0.10693821f, -0.26146930f, -0.18795814f, -0.01137301f, 0.06854171f, 
    -0.08151585f, 0.19078241f, -0.37366372f, 0.22439229f, -0.02101753f, 0.01384698f, -0.03998028f, -0.15497902f, 
    0.04224667f, -0.02649088f, 0.02279628f, 0.05216572f, 0.20394747f, -0.03841544f, 0.00255326f, -0.05466709f, 
    0.14706708f, -0.32968143f, 0.11468753f, -0.12684850f, 0.18514651f, -0.17825992f, -0.31460601f, -0.25816977f, 
    0.03795610f, -0.01735579f, 0.08477283f, -0.16220891f, -0.02744778f, 0.09903269f, 0.00834847f, 0.20045075f, 
    -0.38295826f, -0.01213805f, -0.15480115f, 0.03144145f, -0.21050198f, -0.08723290f, -0.47720167f, -0.06599253f, 
    -0.06609221f, -0.04643831f, -0.00780570f, -0.09077640f, -0.23775485f, -0.00486161f, 0.19481863f, -0.10746410f, 
    0.00028055f, 0.29805312f, 0.14870051f, 0.02160484f, 0.01744857f, -0.01228666f, -0.37026399f, -0.14823224f, 
    0.02901844f, 0.07667784f, 0.10230413f, -0.23647340f, -0.02801239f, 0.08104145f, 0.00451599f, 0.09997101f, 
    0.11244534f, -0.07519633f, 0.19866601f, 0.10120645f, -0.17425837f, 0.14747046f, 0.12495430f, -0.08211481f, 
    -0.03368609f, 0.07473370f, 0.14924955f, 0.32583633f, -0.01698005f, 0.33662981f, 0.04885368f, -0.08062485f, 
    -0.19857377f, -0.09962737f, -0.25599158f, 0.13831614f, -0.17390829f, -0.46124601f, -0.06790167f, 0.01077905f, 
    0.29405844f, -0.14578333f, 0.00738053f, 0.10345303f, -0.08460984f, -0.01130646f, -0.03798194f, 0.05780981f, 
    0.05172801f, 0.16000727f, -0.34439310f, -0.04091989f, 0.08418304f, -0.08670726f, -0.06301907f, 0.18151161f, 
    -0.36598983f, 0.00532690f, -0.02742178f, -0.27995110f, 0.08943262f, 0.17134571f, -0.07234465f, 0.17735216f, 
    -0.27543834f, -0.42680854f, -0.18518637f, 0.00209190f, 0.11856244f, 0.01202846f, 0.02570589f, -0.05463585f, 
    0.17087020f, -0.04226438f, -0.26842883f, -0.09771873f, 0.17951211f, -0.23878835f, -0.02812157f, -0.31191123f, 
    -0.28378120f, 0.31444934f, 0.00058484f, 0.24642798f, 0.04101411f, -0.07003170f, -0.04965866f, 0.18538406f, 
    0.03861841f, 0.03977272f, -0.05028074f, 0.17755805f, 0.21775723f, -0.02806763f, 0.04051840f, -0.02776521f, 
    -0.15731861f, 0.21252576f, 0.09964778f, 0.17335112f, 0.00106109f, -0.11551041f, -0.01315310f, 0.10250823f, 
    -0.06969291f, -0.00777335f, 0.19025251f, -0.50565451f, 0.04497693f, -0.27602875f, 0.00289831f, 0.26972029f, 
    -0.25332162f, -0.03247508f, 0.02597779f, -0.02314952f, -0.06889164f, -0.06742676f, -0.34754452f, -0.09224641f, 
    0.02409015f, 0.27483454f, -0.04751262f, 0.40068194f, 0.06418392f, -0.34206340f, 0.13929713f, -0.38287830f, 
    -0.51129460f, 0.09851028f, 0.07315357f, -0.27514568f, 0.03979438f, 0.06085914f, -0.03448342f, 0.12971225f, 
    -0.07205226f, 0.06475961f, -0.37994248f, -0.09897637f, -0.08322339f, -0.02930946f, 0.06818470f, 0.16313437f, 
    -0.15655942f, 0.00960837f, -0.08909249f, -0.11100610f, -0.01716687f, -0.46556354f, 0.14711943f, -0.15095943f, 
    -0.11073871f, -0.07426800f, -0.03017125f, -0.03586178f, -0.09049778f, 0.21144699f, 0.07026853f, -0.27568245f, 
    -0.16674729f, -0.43656039f, 0.07476088f, -0.23038343f, -0.53815377f, 0.02366490f, 0.25572726f, 0.04566576f, 
    -0.06645243f, 0.27542830f, -0.07479197f, -0.11499281f, 0.24138668f, 0.19904497f, -0.06534895f, -0.09363463f, 
    -0.00121864f, 0.17972787f, -0.05545228f, 0.23897465f, 0.09343377f, 0.02764975f, 0.00696794f, -0.36704370f, 
    -0.00558108f, 0.02894724f, 0.04172086f, -0.36469498f, 0.22823328f, 0.28762245f, 0.03943702f, -0.47169158f, 
    0.22884887f, 0.06164114f, 0.10259178f, 0.05554043f, -0.24962796f, 0.04212615f, 0.22935718f, -0.00614430f, 
    -0.05973123f, -0.03143746f, 0.21436170f, -0.35194355f, -0.17883825f, 0.04151237f, 0.00323834f, 0.24498713f, 
    -0.16529660f, -0.10808795f, 0.11289126f, 0.18301232f, -0.03404989f, -0.01667752f, 0.02231462f, 0.13384973f, 
    -0.04677278f, 0.09112314f, -0.02646259f, -0.03054324f, -0.40044963f, 0.01291908f, -0.01414461f, 0.17212166f, 
    0.21230710f, -0.00765912f, 0.01918723f, -0.07085118f, 0.04865457f, 0.07343966f, -0.20734964f, -0.21686688f, 
    0.03911479f, -0.03975638f, -0.56720597f, -0.32169205f, -0.05789760f, -0.11745179f, 0.07327795f, 0.17446317f, 
    -0.04911822f, 0.01220255f, 0.24735133f, -0.15124026f, 0.00011249f, 0.02883837f, 0.07467514f, -0.01508377f, 
    -0.02942447f, 0.17814478f, 0.24749760f, 0.21960631f, 0.14652801f, 0.27396366f, 0.08548572f, -0.17972958f, 
    -0.10324687f, -0.46457487f, -0.19197395f, -0.11428984f, 0.06821356f, -0.02111901f, -0.22935534f, -0.01661242f, 
    -0.07930487f, -0.00737128f, -0.13426518f, 0.22818270f, 0.10456920f, 0.01163545f, -0.04422921f, 0.03278698f, 
    -0.18660909f, -0.07639925f, -0.44363135f, 0.12063276f, 0.00303622f, 0.02894962f, 0.10243207f, -0.09335808f, 
    0.26382664f, 0.15887536f, 0.08591932f, -0.49190521f, 0.06548587f, -0.22385506f, -0.06179512f, 0.05512364f, 
    -0.09838664f, -0.32369384f, 0.27264979f, 0.24963266f, 0.16845000f, 0.36060092f, -0.18766478f, -0.00948446f, 
    -0.30360582f, 0.12074652f, 0.06478716f, 0.27013755f, -0.19749805f, -0.13646632f, -0.07765193f, -0.06903265f, 
    0.00053568f, 0.22577636f, -0.16496293f, 0.22636169f, -0.06077958f, -0.09648496f, -0.03019524f, 0.02488659f, 
    0.14181554f, -0.08719454f, -0.08880456f, -0.01407905f, 0.06124010f, -0.36285183f, 0.06846356f, -0.27787822f, 
    -0.10231920f, -0.22112207f, 0.21242154f, -0.00931731f, 0.29081696f, -0.06614631f, -0.08683046f, 0.07201285f, 
    -0.14747339f, -0.05603901f, -0.10433106f, 0.27924851f, -0.14031754f, 0.09988350f, 0.00738452f, 0.17464638f, 
    -0.35511383f, -0.07102350f, -0.15731953f, 0.09661128f, -0.02140589f, -0.01478136f, 0.02701614f, -0.37190589f, 
    -0.05123046f, 0.08801790f, -0.00330168f, 0.16690060f, -0.14321558f, 0.01051144f, 0.03721919f, 0.31156996f, 
    0.07035220f, -0.22234283f, 0.17490546f, 0.08338339f, -0.27539572f, 0.26033622f, 0.27701780f, 0.21533494f, 
    0.00826688f, 0.08489238f, 0.04304117f, 0.30011860f, 0.06956498f, -0.11722218f, 0.05201846f, -0.03685284f, 
    -0.11402950f, -0.04523173f, -0.09329110f, -0.43137640f, -0.18555723f, -0.09268399f, -0.18457447f, -0.04436037f, 
    -0.31815943f, -0.12131491f, -0.35921219f, -0.21589425f, -0.24621786f, -0.20456187f, -0.09317820f, -0.35580179f, 
    -0.08615118f, 0.08853734f, -0.25893390f, 0.11975011f, 0.03002295f, -0.02464630f, -0.26196924f, -0.24138018f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.04377891f, -0.03853656f, 0.00201742f, -0.07459286f, 0.08633207f, -0.03053278f, 0.03566599f, -0.13516510f, 
    0.01411728f, -0.06927904f, 0.06719885f, -0.07249482f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
