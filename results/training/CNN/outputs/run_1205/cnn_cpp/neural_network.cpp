#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.57975376f, 0.74185038f, -0.48989415f, 0.27694091f, -0.00076556f, 0.04031263f, -0.15192477f, 0.29989561f, 
    -0.20917101f, -0.59179437f, 0.32070157f, -0.10376264f, -0.65637434f, -0.57173795f, -0.00644143f, 0.27649075f, 
    0.17398424f, 0.11031926f, 0.02381773f, 0.02462120f, 0.32964754f, -0.27435941f, -0.00472849f, -0.31656820f, 
    0.29862028f, 0.09975069f, 0.54082614f, -0.02846732f, -0.52439868f, -0.18656543f, -0.26071194f, -0.30155817f, 
    -0.29850748f, -0.31742179f, -0.13020895f, -0.29891518f, -0.18171418f, -0.06602367f, -0.32186270f, -0.33245960f, 
    -0.20061782f, -0.57982200f, -0.17805065f, 0.61317122f, -0.21632050f, -0.51738137f, 0.12135846f, 0.78633934f, 
    0.04485371f, -0.41347089f, 0.33375627f, -0.21889164f, -0.01425255f, 0.09944230f, 0.26218846f, 0.22105180f, 
    -0.12526730f, -0.65192515f, -0.14942756f, -0.15702830f, 0.17044429f, -0.28223017f, -0.23819736f, 0.55155993f, 
    0.16928549f, -0.03726881f, 0.06781401f, 0.61558354f, -0.30154377f, -0.03845775f, 0.29091236f, 0.30901688f, 
    0.49198702f, 0.21870092f, 0.25683740f, 0.16092591f, -0.35320666f, -0.47105563f, -0.17667086f, 0.12670478f, 
    -0.10400475f, -0.50945419f, 0.02877345f, -0.48711774f, 0.04776776f, 0.38597628f, 0.24979077f, 0.39883229f, 
    0.42030391f, 0.25960180f, 0.50577992f, 0.60088611f, -0.56506366f, -0.33197206f, -0.18444258f, -0.10744409f, 
    -0.04991703f, 0.29916963f, 0.14786375f, -0.53074735f, -0.38451591f, -0.32011944f, -0.05732300f, 0.76321208f, 
    -0.01388752f, -0.19630159f, -0.25466520f, -0.24164367f, 0.45573089f, 0.28449085f, 0.02278192f, 0.34214565f, 
    0.33068874f, 0.43195146f, -0.27867547f, -0.07259318f, -0.31851006f, 0.83341503f, -0.92701304f, -0.16149653f, 
    -0.11576662f, 0.02580507f, 0.03982596f, 0.06893564f, -0.06429694f, -0.15355332f, -0.40015656f, -0.45467287f, 
    -0.28332916f, 0.48912570f, 0.11393422f, -0.36325121f, 0.09906644f, 0.21106194f, 0.43937579f, 0.39875534f, 
    0.40225530f, 0.48635352f, -0.36249733f, -0.13742100f, 0.40849674f, 0.30624506f, -0.12249580f, -0.10740241f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.09173538f, -0.15426479f, -0.20918204f, -0.28096482f, -0.10316829f, 0.15502593f, 0.02157199f, -0.22474614f, 
    0.16144186f, 0.05801215f, 0.14630120f, -0.22224772f, -0.24972263f, -0.24912320f, -0.05418188f, 0.12597051f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.17542854f, 0.22057208f, 0.27377200f, -0.06955761f, 0.04795233f, 0.10922363f, -0.02030090f, 0.07751887f, 
    0.13807435f, 0.05793984f, 0.05646456f, 0.29668301f, -0.01259611f, 0.05017152f, 0.05363974f, 0.04121170f, 
    0.10469575f, 0.05764113f, -0.15285966f, -0.13402006f, -0.04081231f, 0.00623785f, -0.07559533f, 0.08680397f, 
    -0.03582604f, -0.17749165f, -0.04931478f, -0.06632859f, 0.11764574f, 0.32789031f, 0.03441849f, -0.02294328f, 
    -0.02676504f, 0.04784787f, -0.13334106f, 0.09303271f, -0.00583608f, 0.02898590f, 0.31598234f, 0.09022691f, 
    0.01091260f, -0.08129002f, -0.02192916f, -0.20488182f, 0.08756211f, 0.04065719f, 0.04003415f, 0.05761536f, 
    -0.03577587f, -0.11823843f, -0.13692658f, -0.23340017f, 0.10682653f, -0.06150331f, 0.21741605f, -0.01234086f, 
    0.01005893f, -0.08852684f, 0.09430010f, 0.12531056f, -0.04216924f, -0.09703316f, -0.10280447f, -0.02262088f, 
    -0.05890839f, 0.28083706f, -0.21744789f, -0.04417220f, -0.12028056f, 0.00971427f, 0.16969869f, 0.18134631f, 
    -0.02019634f, 0.09060229f, 0.17038484f, 0.09969878f, 0.01972998f, -0.16853306f, -0.06165702f, -0.03097401f, 
    0.08156530f, -0.07346392f, 0.22962958f, 0.34824580f, -0.13888685f, 0.04373962f, -0.02140458f, 0.05499057f, 
    -0.00062252f, -0.02068913f, 0.24414769f, 0.17517774f, -0.08743375f, -0.02513307f, -0.03378322f, -0.02506530f, 
    0.06900774f, 0.08457479f, -0.18536276f, -0.22395997f, 0.13317214f, 0.00251439f, 0.14894037f, -0.10253900f, 
    0.04970790f, 0.06885516f, 0.06913188f, 0.04849609f, -0.04807752f, -0.23040631f, -0.12521818f, 0.02950267f, 
    -0.06167308f, 0.00758860f, -0.08988219f, 0.10453273f, -0.02992283f, -0.04078440f, 0.17847884f, 0.50837785f, 
    -0.14930394f, -0.00752763f, 0.09548677f, 0.00892852f, -0.11174902f, 0.06807637f, -0.18655968f, -0.27750716f, 
    0.17298052f, 0.10268948f, 0.19379003f, -0.18840049f, 0.01292609f, -0.07739997f, -0.02219016f, -0.04147103f, 
    -0.05893352f, -0.11779442f, -0.03796620f, -0.14939159f, 0.08163113f, -0.00568735f, 0.17953371f, 0.04292571f, 
    0.15632248f, -0.27950361f, -0.45988744f, -0.07157867f, 0.20719832f, 0.04016699f, 0.03131462f, 0.08668766f, 
    -0.08835234f, 0.39889246f, -0.57182670f, 0.13617122f, -0.15303889f, -0.18267269f, -0.08772242f, 0.19332659f, 
    -0.10298754f, 0.13224466f, 0.05572875f, -0.13412634f, -0.04548807f, -0.06237820f, -0.18202354f, -0.03803781f, 
    -0.01268496f, 0.09450461f, -0.11932365f, 0.25074720f, -0.23259956f, -0.13039011f, -0.02503965f, -0.13230395f, 
    0.05060598f, 0.06531741f, 0.08493157f, -0.02603855f, 0.09489544f, -0.07481629f, -0.06480210f, -0.02410712f, 
    -0.11478083f, -0.07537597f, 0.04859710f, -0.10654733f, 0.13944881f, 0.28337678f, 0.02847356f, -0.00616111f, 
    0.07966395f, -0.07098325f, 0.14727831f, 0.09245815f, 0.10002694f, 0.08954315f, -0.17856534f, 0.11890461f, 
    0.20451793f, -0.15771721f, -0.10853625f, 0.14259528f, -0.27764192f, -0.02037053f, 0.10008845f, 0.02936550f, 
    0.21889399f, 0.13800311f, -0.08173194f, 0.05202001f, -0.13625777f, 0.06078133f, 0.02967584f, -0.12742820f, 
    0.06687290f, 0.09745656f, 0.06908979f, 0.05453083f, -0.01432981f, 0.07889170f, 0.06494427f, 0.06174766f, 
    0.16970904f, -0.00261583f, -0.54658478f, -0.32631454f, 0.05185376f, 0.11013482f, 0.05361753f, -0.03293972f, 
    0.02816676f, -0.01825701f, -0.16586772f, -0.00312681f, -0.02809206f, 0.00887095f, 0.05157767f, 0.13453130f, 
    -0.00622791f, 0.10810065f, 0.09408499f, 0.02256939f, -0.47988164f, -0.50627840f, -0.22074457f, 0.05365849f, 
    -0.03536204f, -0.07715631f, -0.05648676f, -0.10922286f, -0.11768661f, -0.06192850f, 0.12360948f, -0.23317903f, 
    -0.02669265f, -0.10117355f, 0.01590265f, -0.14412539f, 0.16512924f, 0.19378401f, -0.42347932f, -0.69021046f, 
    -0.08951161f, 0.20665450f, -0.07275651f, 0.09678011f, -0.01779409f, -0.19963743f, -0.16932438f, -0.18476582f, 
    -0.30054402f, -0.17454503f, 0.01463644f, 0.07606869f, 0.12309710f, -0.02223289f, -0.02845557f, 0.17123562f, 
    0.30843988f, 0.18968086f, -0.05477027f, 0.07955072f, -0.06211594f, 0.00732768f, 0.05944860f, 0.04560101f, 
    -0.00797514f, -0.26646411f, 0.20584877f, -0.05610836f, 0.07130487f, -0.19439617f, 0.07000782f, -0.03996409f, 
    0.19274880f, 0.22289629f, 0.22466812f, -0.22051515f, -0.03339421f, 0.05696784f, -0.15700895f, -0.08605532f, 
    -0.10132998f, -0.11805262f, 0.06639310f, -0.21295802f, 0.17273580f, 0.19747372f, 0.11303148f, -0.05664789f, 
    -0.25864804f, -0.27185291f, 0.04562352f, 0.14732297f, -0.08657552f, 0.02305825f, 0.13354608f, -0.14294812f, 
    -0.01261612f, -0.00370548f, -0.09085549f, -0.20322695f, 0.24106480f, -0.08325067f, 0.08470298f, 0.04858856f, 
    -0.05301654f, -0.01872196f, 0.07642696f, -0.04827321f, 0.05157705f, 0.52753818f, 0.13382095f, -0.40029052f, 
    -0.06026003f, -0.02823457f, 0.00650229f, 0.09969271f, 0.14811467f, 0.00262185f, -0.06085953f, 0.14697610f, 
    0.24563548f, -0.05654614f, 0.01143496f, 0.05825180f, -0.12704164f, 0.15925634f, 0.07137012f, -0.22602145f, 
    -0.17478228f, 0.14477254f, -0.14756103f, -0.01137486f, -0.02520750f, 0.00490056f, -0.00976977f, -0.06357753f, 
    -0.35312459f, 0.07967422f, 0.10153755f, -0.12173470f, 0.05015003f, 0.17196360f, -0.15357752f, -0.07909837f, 
    0.23256283f, -0.12446164f, 0.05781330f, 0.10930865f, 0.15704435f, -0.07010544f, -0.06897301f, 0.07975974f, 
    -0.06799167f, 0.06115391f, -0.12356655f, 0.12680630f, 0.12935536f, -0.16743003f, 0.06902777f, -0.06261525f, 
    -0.00879328f, -0.14594026f, -0.07121774f, 0.21290116f, -0.02222067f, 0.10751916f, 0.13890553f, -0.01619329f, 
    -0.22991352f, 0.17147292f, 0.21776485f, 0.03206016f, 0.05496325f, -0.25323018f, -0.03478537f, 0.05488948f, 
    0.11653606f, 0.05763171f, -0.12704691f, -0.02763138f, -0.05670131f, 0.25996089f, 0.06735448f, -0.00258239f, 
    -0.08150052f, -0.12322148f, -0.08105425f, 0.12496442f, 0.12106094f, -0.06395272f, 0.02632395f, -0.32089496f, 
    0.13652745f, 0.15905616f, 0.14629535f, -0.07531884f, 0.14813383f, 0.08822028f, 0.15623249f, -0.29087195f, 
    -0.11465923f, 0.01137855f, -0.11117139f, -0.12601812f, -0.17566183f, 0.10875273f, 0.04279742f, -0.06122854f, 
    -0.06663157f, 0.05789636f, -0.34537849f, 0.15619168f, 0.17387527f, 0.01814887f, -0.05660680f, 0.05750544f, 
    -0.00824494f, -0.01075713f, -0.03619574f, 0.34891099f, 0.01936583f, 0.09130583f, -0.02611530f, 0.03403509f, 
    -0.00025303f, -0.05125329f, 0.13394241f, -0.01561422f, -0.12383629f, -0.00237437f, -0.04295253f, -0.14728922f, 
    -0.12930696f, 0.05570373f, 0.04835891f, -0.00450578f, 0.09607815f, -0.00567550f, 0.09386471f, -0.10845642f, 
    0.10782412f, 0.14854825f, 0.01734149f, 0.02849631f, -0.18918219f, 0.29248402f, 0.29779634f, 0.14852770f, 
    0.12588044f, 0.07637382f, -0.15069370f, 0.15765682f, -0.03513970f, -0.46772471f, -0.40819034f, 0.07177242f, 
    -0.10047116f, 0.14750732f, -0.01959715f, -0.06412854f, -0.09399114f, -0.07995242f, 0.19268574f, -0.19369090f, 
    0.05538301f, 0.05851705f, 0.10313299f, 0.01876819f, 0.20863876f, -0.00465826f, 0.00198328f, -0.08727619f, 
    0.06538039f, -0.22126700f, -0.08457051f, 0.18152337f, -0.18847431f, 0.01395562f, -0.06313285f, 0.11509504f, 
    0.15619153f, -0.26534459f, 0.09586061f, -0.08670904f, 0.09478636f, -0.03561198f, 0.07158624f, 0.15378830f, 
    -0.01082562f, -0.05876418f, 0.15551780f, 0.03234301f, -0.07810786f, -0.25023824f, 0.20350383f, 0.05370896f, 
    0.03066237f, 0.04944407f, 0.20798120f, -0.12107983f, -0.17201999f, -0.12531359f, 0.16418320f, -0.00290269f, 
    -0.12351225f, 0.09292444f, 0.06902057f, -0.43698645f, 0.04263208f, -0.14926952f, -0.04252441f, -0.19438225f, 
    -0.03670983f, -0.13587832f, 0.01638217f, -0.07769166f, 0.03189698f, 0.07045928f, 0.00041784f, -0.08635634f, 
    -0.00303019f, -0.06974590f, 0.09489045f, -0.27336395f, -0.01736209f, 0.02002252f, -0.36315396f, -0.29553807f, 
    0.06755959f, -0.01309051f, 0.09546403f, 0.06876320f, -0.08631090f, -0.18862653f, -0.02517950f, 0.04638139f, 
    -0.10392345f, 0.04684962f, 0.02900144f, -0.17132679f, 0.23135862f, 0.05938117f, 0.17605118f, -0.25816905f, 
    -0.46086928f, 0.00004112f, 0.17817713f, -0.02956294f, -0.04088390f, 0.01229995f, 0.10752729f, 0.08712158f, 
    -0.42588034f, -0.05371580f, -0.44511130f, -0.11920027f, -0.03279574f, 0.14325096f, 0.04307811f, 0.22429246f, 
    0.02920396f, -0.01343653f, 0.14579171f, 0.19885488f, -0.19240753f, -0.11808398f, -0.17114264f, -0.04660596f, 
    0.05322080f, 0.08264369f, 0.24121068f, 0.17677836f, 0.08158640f, 0.04975856f, -0.11451393f, 0.04346929f, 
    -0.05922723f, -0.13248001f, -0.13162121f, 0.24315666f, 0.19496183f, 0.17104428f, -0.00673861f, 0.08733120f, 
    0.05780240f, 0.06602121f, -0.16664022f, 0.00560029f, 0.14735359f, 0.07153933f, 0.08892215f, 0.01697818f, 
    0.12180819f, -0.15191995f, 0.05195241f, 0.02405174f, 0.03452635f, -0.62510687f, -0.12318381f, 0.00781662f, 
    0.04278509f, 0.08080339f, 0.15339187f, 0.11401654f, 0.02806092f, -0.02984354f, -0.25127903f, 0.15969136f, 
    0.23640375f, -0.02192291f, -0.11447850f, -0.10268184f, -0.03202586f, -0.07205613f, 0.00073426f, -0.19328666f, 
    -0.28600916f, -0.40442324f, -0.00542257f, 0.03441002f, 0.08778931f, 0.02376217f, 0.05476370f, 0.19962139f, 
    -0.02739128f, -0.01445532f, -0.21526340f, -0.00928554f, 0.02006743f, 0.01990015f, 0.09706727f, -0.01942995f, 
    0.06528584f, -0.08381620f, -0.33260754f, -0.29375070f, 0.03426164f, -0.00722462f, 0.12806176f, 0.06530637f, 
    0.06470717f, -0.02313826f, 0.11700880f, 0.00643445f, -0.37631941f, -0.01490680f, -0.04362880f, -0.07978572f, 
    -0.04422234f, 0.04341362f, -0.00115832f, 0.22826339f, -0.34390131f, 0.20478064f, 0.10827403f, -0.01078942f, 
    0.13520353f, 0.09970687f, 0.14761259f, 0.04765460f, 0.31526586f, -0.02359326f, -0.21397246f, 0.00164726f, 
    -0.22813146f, -0.18503423f, -0.00594154f, -0.04432488f, 0.04778939f, 0.47269014f, 0.22951657f, -0.12466262f, 
    0.00578509f, -0.09049175f, -0.15402777f, -0.04304580f, 0.06297857f, -0.08230514f, 0.13232209f, 0.21007505f, 
    0.06782643f, -0.09885444f, 0.09198124f, 0.03805172f, 0.04011883f, -0.12621635f, 0.21406463f, 0.00709084f, 
    -0.23956706f, 0.11714001f, 0.10028471f, 0.00469835f, 0.06723525f, -0.04564672f, 0.06269535f, 0.00997179f, 
    -0.06426652f, 0.02294921f, -0.00401970f, -0.04283570f, 0.01088183f, -0.08640528f, 0.03761450f, -0.07823604f, 
    -0.01554991f, 0.00634368f, -0.08555648f, -0.02421135f, 0.00567243f, -0.08558197f, -0.03421592f, 0.04544723f, 
    -0.07818291f, -0.08619299f, 0.00972630f, -0.04822726f, 0.04300573f, 0.03452122f, -0.04127827f, -0.04076357f, 
    -0.07179480f, -0.01424439f, 0.01599367f, 0.03108973f, 0.04027029f, 0.03577517f, -0.05626254f, 0.05838803f, 
    0.00757453f, -0.05325216f, -0.05226532f, -0.07002294f, 0.02848916f, -0.07491125f, 0.00814264f, -0.06360161f, 
    0.00489633f, 0.01727469f, -0.05637813f, -0.01641952f, 0.03090062f, 0.05152556f, -0.05716877f, 0.06538747f, 
    0.06350216f, 0.02616365f, -0.02226777f, -0.08953330f, -0.01812016f, -0.03092987f, -0.05354363f, 0.06444955f, 
    0.02677644f, 0.02994327f, -0.00433105f, 0.00031070f, -0.01732364f, -0.05693474f, 0.04018132f, -0.05359812f, 
    0.00978007f, -0.05002547f, -0.05481816f, -0.08123048f, -0.08158235f, -0.05502969f, -0.01049802f, -0.01308567f, 
    -0.01374459f, 0.05189484f, -0.07702040f, -0.04248402f, 0.01531789f, 0.00496729f, 0.03185829f, 0.05898454f, 
    -0.05695104f, -0.02702034f, -0.03330057f, -0.01116945f, 0.03908473f, -0.03410301f, 0.01741085f, 0.05945163f, 
    -0.02867123f, -0.02740980f, -0.06506824f, -0.02476199f, -0.05634633f, -0.05224803f, -0.07516537f, 0.06534240f, 
    0.05421979f, -0.05002341f, -0.02985031f, -0.05754354f, -0.08128133f, 0.05974736f, 0.02604855f, 0.06681378f, 
    0.06394108f, -0.06173456f, -0.00577253f, 0.04147411f, 0.00285144f, -0.07959493f, -0.03838553f, -0.04235464f, 
    0.01466418f, -0.02757781f, -0.05692604f, 0.06836861f, 0.06308241f, 0.06415351f, 0.04043769f, 0.02555068f, 
    -0.05070397f, -0.00991782f, -0.04989699f, -0.03583638f, -0.00020325f, 0.02145400f, -0.05862492f, -0.05109456f, 
    -0.00775877f, -0.03757959f, -0.02318343f, -0.08857583f, -0.08253528f, 0.00893547f, -0.06387614f, -0.04765202f, 
    -0.04849042f, 0.00376454f, -0.00322807f, 0.00061730f, -0.05706455f, -0.02220651f, -0.01035567f, 0.02465678f, 
    -0.07444479f, -0.06823045f, -0.06104644f, -0.05112271f, -0.08262092f, -0.00157956f, 0.02671788f, -0.06946042f, 
    -0.08130343f, -0.03903759f, 0.07340746f, 0.02903812f, -0.05982345f, 0.05505670f, -0.08252564f, 0.07313944f, 
    0.04959888f, 0.01128005f, 0.01228180f, 0.04516059f, -0.04764063f, 0.06734583f, 0.01104428f, -0.02342049f, 
    -0.05697738f, -0.02682357f, -0.08517394f, -0.06286135f, -0.00118948f, -0.06170086f, 0.01859610f, 0.02369134f, 
    -0.07421758f, -0.04150904f, 0.05178994f, 0.03651991f, 0.04235444f, 0.01849934f, -0.03499747f, -0.06905001f, 
    -0.01943888f, -0.03341142f, 0.05240062f, 0.05995313f, -0.07146676f, -0.04079944f, 0.04109220f, 0.04565163f, 
    -0.07394432f, 0.03320904f, 0.00559264f, -0.08384509f, -0.08235500f, 0.00647554f, -0.08496184f, -0.05440308f, 
    -0.07887195f, -0.07873150f, -0.05045388f, -0.07813223f, 0.05503969f, -0.05761174f, 0.00944746f, 0.04540414f, 
    0.03618044f, -0.01419760f, 0.03882182f, 0.03526692f, 0.00012577f, 0.06227881f, -0.04099817f, -0.07333660f, 
    0.01318266f, -0.06872638f, -0.07598351f, 0.02020467f, -0.06435036f, -0.06492016f, -0.02167418f, -0.05279323f, 
    -0.05123460f, -0.07373124f, -0.01056076f, 0.01070796f, -0.04648964f, -0.05915381f, -0.02164360f, -0.01013136f, 
    -0.01446353f, 0.02247777f, -0.01700304f, 0.01414898f, -0.04448699f, 0.01737735f, 0.00870457f, -0.00659554f, 
    0.06896401f, -0.04633012f, 0.06423723f, 0.07168931f, -0.01258024f, -0.06867753f, 0.07688040f, -0.00148618f, 
    -0.03131222f, 0.01950462f, -0.06386206f, -0.01617105f, -0.03438373f, -0.07672854f, 0.06177721f, -0.06020126f, 
    0.06575868f, -0.02542292f, -0.04390171f, -0.05324617f, -0.08225515f, 0.01762047f, 0.00724893f, 0.04512540f, 
    0.05131865f, -0.02033272f, 0.05595462f, -0.03271597f, 0.01529475f, 0.06641123f, -0.03246114f, -0.05329767f, 
    -0.01622449f, 0.04370245f, -0.07676090f, -0.00308236f, -0.01207185f, -0.06488873f, 0.04714979f, -0.02005243f, 
    -0.05823484f, -0.04749056f, -0.00651174f, -0.06944431f, 0.04830840f, 0.05358750f, 0.06782136f, 0.03080954f, 
    -0.49356884f, -0.04542378f, -0.27897042f, 0.15721489f, -0.11021600f, -0.19521484f, 0.08566899f, -0.01401684f, 
    -0.00360250f, -0.28432676f, -0.57350820f, -0.40510154f, -0.11094607f, 0.05933382f, -0.27624598f, -0.00305657f, 
    -0.03983217f, 0.11144869f, 0.08370341f, -0.18991324f, 0.11879816f, -0.12189079f, 0.04117627f, 0.08009814f, 
    0.04780718f, 0.02433151f, 0.00676907f, 0.10453879f, 0.33461446f, 0.03536214f, -0.13541725f, -0.17063345f, 
    -0.23289655f, 0.16618487f, -0.02727765f, 0.05253486f, 0.21596837f, 0.15157975f, -0.23958382f, 0.19438979f, 
    0.02214878f, -0.02094505f, 0.08394020f, -0.02592463f, -0.03459836f, -0.14924845f, -0.07760577f, 0.28845489f, 
    0.02967334f, 0.07580009f, 0.17177954f, -0.03048401f, -0.02465382f, -0.05554530f, 0.15508547f, -0.28049612f, 
    -0.27043754f, -0.14121397f, -0.17372327f, 0.07975257f, 0.03586047f, -0.03776151f, 0.12588449f, 0.11297452f, 
    -0.01709199f, 0.13349672f, 0.08004259f, 0.13371399f, 0.02243780f, -0.02123117f, 0.08324247f, 0.03246183f, 
    0.32739869f, 0.10049363f, 0.06251585f, -0.14200765f, 0.09134453f, -0.12823446f, 0.06431816f, -0.03010403f, 
    0.24877983f, -0.34206134f, 0.16371047f, -0.12188616f, 0.04047042f, 0.13221210f, -0.13645762f, -0.02531134f, 
    0.16460046f, -0.04020375f, 0.34253532f, -0.12565704f, -0.00325297f, 0.06534290f, 0.00906050f, 0.07095568f, 
    0.01644278f, 0.04716983f, -0.00598593f, -0.28306082f, -0.09126971f, -0.19991644f, 0.02355135f, 0.19692151f, 
    -0.07698888f, -0.07528549f, -0.05703637f, -0.08499848f, -0.04166220f, -0.02569604f, -0.01310611f, -0.04862858f, 
    -0.01070310f, -0.10015121f, -0.10504678f, -0.05517793f, -0.07726213f, -0.21678157f, -0.12637834f, -0.56202441f, 
    0.02990252f, -0.26532289f, -0.06186600f, 0.02656333f, 0.14352399f, 0.06127533f, -0.04675572f, 0.14988182f, 
    0.20676330f, -0.17361212f, 0.04041762f, 0.13921991f, 0.04976463f, -0.08830717f, 0.01081538f, 0.48252022f, 
    0.23138815f, 0.23841383f, -0.22128634f, -0.12927060f, -0.04534650f, -0.02119315f, 0.14477146f, -0.06711869f, 
    0.40308720f, 0.01039860f, -0.14323744f, -0.04341359f, -0.01280343f, -0.10951677f, 0.17674585f, -0.01203368f, 
    0.08745652f, -0.03232129f, 0.10292818f, -0.10446995f, 0.08543957f, 0.04334008f, -0.05519635f, 0.16096264f, 
    -0.15658133f, 0.04533305f, -0.14311396f, 0.13916540f, 0.11305288f, 0.06055956f, 0.07386597f, -0.00157480f, 
    -0.14522497f, -0.11261366f, -0.13081430f, 0.26894805f, 0.00562872f, 0.06157248f, 0.01510696f, -0.05438355f, 
    0.08106215f, 0.08377720f, -0.20552488f, -0.02733134f, 0.09908149f, -0.06305947f, -0.09833266f, 0.08731768f, 
    0.01361056f, -0.06036439f, -0.04378523f, -0.03196282f, 0.10356110f, -0.03616471f, 0.19677468f, -0.04236620f, 
    -0.12033662f, 0.04549721f, 0.10940976f, 0.00196629f, 0.05411635f, -0.13412482f, -0.03210869f, 0.20280448f, 
    0.03921155f, -0.03256942f, -0.00455760f, 0.06950050f, 0.13983168f, 0.05791719f, 0.14108180f, 0.23568144f, 
    0.37177542f, 0.03121575f, -0.18604651f, 0.05232846f, -0.00117146f, 0.08427112f, 0.05841509f, -0.36136025f, 
    0.33160776f, 0.13361220f, -0.02989304f, 0.04975013f, -0.08528470f, -0.09857059f, 0.06856523f, 0.15501310f, 
    -0.02053941f, 0.38432083f, -0.07192285f, 0.07314003f, -0.06912080f, -0.05432683f, -0.06785002f, -0.10005774f, 
    0.04955214f, -0.02816156f, 0.07658174f, 0.14760925f, 0.09908701f, -0.04627429f, 0.15710495f, 0.02159574f, 
    0.01874398f, -0.01003391f, -0.04158846f, -0.20883277f, -0.32678682f, -0.42765847f, -0.04747279f, -0.02253547f, 
    0.01918823f, -0.00571946f, 0.01045493f, 0.07534523f, 0.14531840f, 0.03823209f, 0.03557198f, 0.02949480f, 
    -0.01665704f, 0.01322759f, 0.14018057f, -0.06498399f, 0.01760138f, 0.12493155f, -0.26034588f, 0.36626825f, 
    -0.05623272f, -0.10572606f, 0.20377332f, 0.01219379f, -0.12605047f, 0.05256903f, -0.29633030f, -0.05480792f, 
    -0.25582814f, -0.05082635f, 0.07561003f, -0.07445176f, 0.05494555f, 0.07517593f, -0.09094761f, 0.06288760f, 
    0.22995982f, 0.17742652f, 0.08448569f, -0.11332902f, -0.03211595f, 0.01465320f, -0.01617235f, -0.10281636f, 
    0.10480944f, 0.14458171f, 0.22513771f, 0.20906462f, 0.09606972f, 0.09900729f, -0.00280907f, 0.14194658f, 
    0.06592888f, -0.37851682f, -0.20089054f, -0.44100484f, -0.06759341f, -0.02150238f, -0.12661543f, -0.02188307f, 
    0.05544604f, -0.06698064f, 0.00681015f, -0.29673955f, -0.10505355f, -0.20632882f, -0.11066435f, -0.08491041f, 
    0.03695045f, -0.00682538f, 0.01053463f, 0.00214185f, -0.28316322f, -0.06525447f, -0.12403595f, 0.00998725f, 
    -0.13194288f, 0.01135602f, -0.06063188f, -0.07608210f, -0.28351599f, -0.16154532f, -0.04064437f, 0.09405043f, 
    -0.04648064f, -0.09276880f, -0.15618664f, -0.07136010f, 0.07679460f, 0.24614392f, -0.08057340f, 0.01968504f, 
    -0.08036608f, 0.10347787f, 0.05623702f, 0.00920431f, -0.11219730f, 0.12548052f, -0.17882574f, -0.07884659f, 
    -0.10373655f, -0.01029703f, 0.17410094f, 0.03619988f, 0.08370633f, 0.15935640f, 0.09775722f, -0.04320803f, 
    -0.07487144f, 0.12929651f, -0.12579992f, 0.03666371f, 0.04925037f, -0.13460705f, 0.04905393f, -0.02265074f, 
    -0.23151110f, -0.02629978f, -0.07167510f, 0.16185549f, 0.08887094f, -0.01457676f, 0.14211531f, -0.13110343f, 
    -0.05999675f, -0.24022011f, 0.20512977f, 0.31882101f, -0.11463387f, 0.12256242f, -0.09309693f, 0.04769765f, 
    0.09304925f, 0.01247785f, 0.35374978f, 0.05481970f, -0.25358537f, 0.00252635f, 0.00155201f, 0.16548879f, 
    -0.00370451f, -0.02323381f, 0.05322766f, -0.20165436f, -0.10297567f, 0.19685671f, -0.25427219f, 0.02381722f, 
    -0.07225719f, -0.00461470f, 0.02303371f, 0.17899522f, -0.28474593f, -0.07590975f, 0.04361995f, -0.00798453f, 
    0.02386429f, -0.07656182f, 0.04603654f, -0.12612632f, 0.12045370f, -0.07545568f, 0.04376484f, -0.08953188f, 
    -0.04842959f, -0.06041511f, -0.05288242f, 0.12359034f, -0.07998018f, 0.00592538f, -0.55445576f, 0.13306378f, 
    0.14686601f, 0.02011112f, 0.06888593f, -0.11842122f, -0.00662516f, -0.15827066f, 0.02925835f, 0.17675932f, 
    0.08007882f, -0.03737951f, 0.08042134f, 0.07249083f, 0.01840079f, 0.07472443f, 0.11795672f, 0.12371913f, 
    -0.07418100f, -0.10755163f, -0.15877268f, -0.21136419f, 0.08257916f, 0.09776358f, 0.05171026f, 0.13900837f, 
    0.08334532f, 0.20591125f, 0.22257975f, 0.11849788f, 0.04234537f, -0.21675138f, -0.08165962f, -0.04822912f, 
    -0.02836362f, -0.03043598f, 0.16569638f, 0.12206661f, 0.09137427f, -0.12180205f, -0.08865649f, 0.07372858f, 
    -0.01420516f, -0.19625172f, -0.11132137f, 0.01883830f, -0.04993297f, 0.06752142f, -0.01732394f, -0.08678861f, 
    -0.08407808f, 0.17280799f, -0.03676134f, 0.00360340f, 0.10828482f, 0.22129415f, 0.35411051f, -0.12178963f, 
    -0.10481133f, -0.01533112f, 0.04375729f, -0.10040587f, 0.03128166f, -0.37631008f, -0.13937771f, -0.22463977f, 
    -0.13557775f, -0.12420286f, -0.04578092f, 0.11068614f, -0.03417299f, 0.12037784f, 0.16926354f, 0.00971324f, 
    -0.05890267f, -0.10788540f, 0.03332547f, 0.07223538f, -0.06712170f, 0.04171435f, 0.06743017f, 0.05152597f, 
    0.04991276f, 0.04695185f, -0.05195811f, -0.01610782f, 0.01699838f, 0.10321099f, 0.05309784f, 0.04750355f, 
    -0.05616176f, -0.10847115f, 0.18195377f, 0.10553498f, -0.01521533f, 0.09538535f, 0.11917587f, -0.06978010f, 
    0.00837054f, 0.02574501f, 0.01003838f, 0.22077106f, -0.11612843f, -0.00796194f, -0.10263398f, 0.08771961f, 
    0.09366598f, 0.15375778f, 0.02814963f, 0.22330180f, -0.11026967f, 0.01582252f, -0.05018087f, -0.03001350f, 
    0.14937168f, 0.08282720f, -0.06594243f, -0.11409884f, -0.06111025f, 0.21418847f, -0.27873617f, -0.32269374f, 
    -0.22706087f, 0.05311336f, -0.00545175f, 0.16526094f, -0.06826290f, -0.02026715f, 0.17217548f, -0.09416620f, 
    -0.14613156f, -0.19240752f, 0.04646053f, 0.04446074f, 0.10155981f, -0.21637166f, -0.18900980f, -0.18232340f, 
    -0.04333116f, -0.12089334f, 0.16370727f, 0.03103769f, 0.06770841f, -0.27723780f, -0.01590662f, -0.09513856f, 
    0.11524748f, -0.00290077f, 0.05707630f, -0.17507845f, 0.02737626f, -0.00854486f, 0.08902656f, -0.24711488f, 
    -0.23422129f, -0.39495608f, -0.00893841f, 0.07034462f, 0.01466752f, 0.00304518f, 0.04036254f, -0.05017589f, 
    0.13845716f, 0.03593918f, 0.07442889f, -0.04639759f, 0.06999692f, 0.02761261f, -0.00158784f, -0.00685422f, 
    -0.13594313f, 0.07934194f, 0.04310273f, 0.20118855f, 0.03416989f, 0.05338785f, 0.09628735f, 0.07436416f, 
    0.07573756f, 0.07178073f, 0.07032295f, 0.15201330f, 0.02611937f, 0.15854168f, -0.02486351f, 0.21143904f, 
    0.14886035f, 0.07819299f, 0.33925146f, 0.15971272f, 0.03090728f, -0.21861725f, -0.01012143f, -0.00636330f, 
    -0.11987767f, -0.00393311f, 0.13733593f, 0.00982959f, 0.07087167f, 0.05124446f, 0.11710220f, 0.01499543f, 
    0.02193756f, 0.09909129f, 0.08004880f, -0.05190699f, 0.09760240f, 0.09444174f, 0.13167337f, -0.00973833f, 
    0.03195074f, 0.07351662f, 0.01183579f, 0.02178536f, 0.03283769f, -0.07721675f, 0.01821062f, 0.10969567f, 
    -0.02993665f, 0.03367243f, 0.01218446f, 0.09951118f, -0.00811384f, 0.04685764f, -0.13457674f, -0.10662371f, 
    0.07061745f, 0.09229830f, -0.10337696f, -0.10004660f, -0.10759448f, 0.16885935f, -0.08663455f, 0.08826954f, 
    -0.27720770f, -0.29147261f, -0.00824397f, -0.18242046f, 0.08046158f, 0.10942727f, -0.00455355f, -0.14348172f, 
    -0.12719050f, 0.21098809f, -0.18460639f, -0.07017941f, -0.06628017f, 0.10140890f, -0.17687172f, -0.00023650f, 
    0.10659260f, -0.03305489f, -0.48684844f, -0.00058729f, -0.12074666f, -0.08856912f, 0.03290615f, 0.13425757f, 
    0.11789599f, -0.05118483f, 0.23182489f, 0.38473165f, 0.17299065f, 0.24377355f, -0.11859805f, -0.09348341f, 
    -0.22850384f, -0.02770340f, -0.05236639f, -0.11023103f, -0.13110812f, -0.06027356f, 0.19134024f, 0.05991890f, 
    0.08974812f, -0.07715783f, -0.14087154f, -0.02415605f, -0.11653725f, 0.13198794f, -0.27487972f, 0.05792983f, 
    0.03636526f, -0.09248056f, -0.01210178f, -0.14403935f, 0.02277138f, -0.25517538f, 0.45747131f, -0.03530719f, 
    0.06341866f, 0.06914435f, 0.10537580f, -0.05385672f, 0.10579671f, -0.00052260f, 0.05283748f, -0.24541248f, 
    0.01539440f, 0.16915065f, 0.05170208f, 0.00159018f, 0.01376618f, -0.18810177f, 0.13106245f, 0.11611845f, 
    -0.07671642f, 0.10946325f, -0.08926599f, -0.10159796f, 0.10353456f, -0.00816172f, 0.03172689f, -0.12906095f, 
    -0.02373372f, -0.06530795f, -0.05264328f, 0.05438773f, -0.08751929f, 0.08033017f, 0.13376668f, 0.20068865f, 
    -0.02030558f, 0.13119334f, -0.06759015f, -0.01155093f, 0.04968493f, 0.23339008f, 0.13746558f, 0.01891112f, 
    -0.02913201f, -0.05309136f, 0.04960305f, 0.01142371f, -0.16073555f, -0.65806043f, -0.01732280f, 0.03705535f, 
    0.05342406f, -0.04319978f, 0.11778201f, 0.02586795f, -0.11604634f, -0.24573809f, -0.40390259f, -0.04558674f, 
    -0.04599597f, -0.20368631f, -0.02963394f, 0.01877706f, 0.11049412f, -0.40888083f, -0.00846225f, 0.21590891f, 
    -0.06424312f, 0.00588972f, -0.06943613f, 0.02408734f, -0.00060180f, 0.05797471f, 0.24599251f, -0.17492025f, 
    -0.25113919f, 0.14405763f, -0.01579919f, 0.01565998f, 0.14919415f, 0.00654567f, 0.08348082f, 0.31583661f, 
    -0.10271212f, 0.16062802f, -0.11945071f, -0.01416038f, 0.18259159f, 0.14850870f, 0.11344840f, -0.11024164f, 
    0.23309857f, -0.02886172f, -0.12964487f, 0.07265755f, -0.12331028f, 0.10501689f, -0.02118436f, -0.02183473f, 
    0.11718389f, -0.02863239f, 0.01578654f, -0.01867083f, -0.02507770f, -0.10634474f, 0.01107605f, 0.03774818f, 
    -0.07346451f, -0.00631453f, 0.04866718f, 0.11592000f, -0.33693299f, 0.11004034f, -0.09511152f, 0.16547477f, 
    0.10039467f, -0.19352025f, 0.10634789f, -0.11701441f, -0.14470480f, -0.24569060f, -0.17432505f, -0.20015602f, 
    -0.22323239f, -0.13261691f, -0.05148180f, -0.15780437f, 0.28645003f, 0.28500664f, 0.29674768f, -0.06620907f, 
    0.07119130f, -0.06782466f, 0.03447896f, -0.03932370f, 0.00937126f, -0.13263261f, -0.19513074f, -0.43667123f, 
    0.15049262f, 0.01839018f, 0.03252828f, 0.14821507f, 0.09323593f, -0.16773379f, -0.00420262f, 0.12092032f, 
    -0.29841307f, -0.02614476f, -0.28108236f, 0.21448331f, 0.15015116f, 0.17861874f, 0.14752503f, 0.12286646f, 
    0.02606313f, -0.05047208f, 0.01086926f, 0.07083208f, 0.15964171f, -0.00522985f, -0.01153741f, 0.01079830f, 
    0.05290473f, -0.09605172f, 0.07945191f, 0.27405202f, 0.00679262f, -0.07761124f, 0.07166173f, 0.13291343f, 
    -0.01169664f, 0.08811126f, -0.12161312f, -0.33746481f, -0.03218598f, -0.06379853f, -0.07849265f, -0.03603570f, 
    0.00099272f, 0.09805221f, -0.19530292f, -0.24838862f, -0.18295531f, -0.23167571f, -0.22926804f, -0.01877538f, 
    0.02292060f, 0.05863516f, 0.21787594f, -0.11742114f, -0.14455643f, 0.06649483f, -0.06859254f, -0.01387398f, 
    0.10301430f, 0.05272259f, 0.16233090f, -0.11262700f, -0.00346049f, -0.27584320f, 0.04733568f, 0.08829422f, 
    0.08861294f, 0.04872509f, -0.04962914f, 0.19346145f, 0.03535644f, 0.28504720f, -0.07901200f, -0.38210875f, 
    0.19902679f, -0.03706378f, -0.04235621f, -0.06484768f, -0.00192427f, 0.09490445f, -0.11629131f, 0.05765255f, 
    0.18032046f, 0.02772615f, 0.10134087f, 0.14910044f, -0.10347910f, 0.09791393f, 0.03809414f, -0.08675221f, 
    -0.31508631f, -0.31874281f, -0.01182639f, -0.08615388f, -0.13142280f, 0.05281517f, 0.07063663f, -0.00068539f, 
    -0.27069786f, 0.16333203f, 0.13321389f, 0.15705314f, -0.04481861f, -0.26148397f, 0.00743561f, -0.02999257f, 
    0.08457925f, 0.11166850f, 0.13564536f, 0.06950298f, 0.06298566f, 0.04349486f, 0.13598679f, 0.21296680f, 
    -0.00314114f, 0.13131775f, 0.13947897f, 0.01180051f, -0.31347543f, 0.05144348f, 0.08228958f, 0.07684676f, 
    0.12644263f, 0.17336023f, 0.02459320f, -0.35207683f, -0.14337710f, -0.05025140f, 0.04101089f, -0.13646056f, 
    0.14974968f, -0.08320595f, -0.15122843f, -0.16239057f, -0.01828198f, -0.25359604f, -0.09086521f, -0.03249597f, 
    -0.30056247f, -0.51417261f, -0.19063708f, 0.13036989f, -0.12390012f, 0.32724148f, 0.03379636f, 0.00974601f, 
    -0.09960240f, -0.11903574f, -0.00374572f, 0.01608715f, 0.03602740f, -0.08110605f, -0.03548295f, -0.13892823f, 
    0.31084499f, -0.05952789f, -0.08122303f, 0.09298833f, 0.12773804f, 0.06837963f, 0.11480202f, -0.17220682f, 
    -0.02549988f, -0.06817406f, 0.03016780f, -0.05883515f, -0.01434331f, 0.09433890f, 0.04703086f, 0.11879079f, 
    -0.16502306f, 0.29372343f, 0.09829058f, 0.10627250f, -0.12508288f, 0.10899482f, -0.28850845f, 0.06889337f, 
    0.06312849f, -0.08301623f, 0.17770012f, -0.04377504f, -0.07607538f, 0.04339348f, 0.00849317f, 0.16559589f, 
    0.11600778f, 0.12286016f, -0.04957477f, 0.01232646f, -0.07422835f, -0.08179314f, 0.11694427f, 0.13366981f, 
    0.05370840f, 0.28492838f, 0.21153699f, -0.20131280f, -0.12420679f, -0.09858405f, 0.09076842f, -0.02433171f, 
    0.10551437f, -0.00695318f, 0.06540494f, -0.18575968f, -0.30577099f, 0.13613097f, -0.11161073f, -0.01406966f, 
    -0.05812788f, 0.00444458f, 0.03629424f, 0.11279372f, 0.02760598f, -0.03937830f, 0.07512719f, 0.31295937f, 
    0.13286434f, -0.02404901f, 0.17414285f, 0.00985885f, -0.06730673f, -0.17815287f, -0.11741769f, -0.13488074f, 
    -0.17174429f, 0.13947430f, 0.14303972f, 0.04478018f, -0.00136650f, -0.04851512f, -0.05963377f, -0.07921190f, 
    -0.21061859f, 0.16596569f, 0.01686204f, 0.12350259f, -0.02437875f, -0.03967803f, -0.09857114f, 0.07700288f, 
    -0.07639035f, -0.05364042f, 0.10936054f, 0.12393522f, 0.06078704f, 0.04132960f, 0.03250119f, -0.00325427f, 
    0.11051116f, 0.01434899f, -0.01846140f, -0.12187632f, 0.13043641f, 0.12531672f, -0.03003323f, 0.08792061f, 
    0.21869224f, 0.06513429f, 0.14981261f, 0.07950820f, 0.10323203f, 0.20834380f, 0.07853346f, 0.05006158f, 
    0.14271030f, -0.00352217f, 0.11199280f, -0.24083234f, -0.28638843f, 0.03549745f, 0.02213788f, -0.01530642f, 
    -0.00589389f, -0.22732289f, -0.23814951f, -0.18714635f, -0.07740685f, -0.23527174f, -0.16309342f, 0.10998419f, 
    -0.07628377f, -0.06400912f, -0.09943189f, -0.08796971f, -0.21338449f, -0.10449126f, -0.06125490f, 0.09460435f, 
    0.08193454f, 0.03212068f, -0.21633635f, -0.18775524f, 0.14432484f, 0.05682602f, -0.01873838f, -0.08820726f, 
    -0.12308681f, 0.06891786f, 0.12417816f, -0.06963338f, 0.20075630f, -0.05904523f, -0.05144130f, -0.04360230f, 
    -0.09879491f, 0.20335175f, 0.02215795f, 0.04484921f, 0.14756764f, -0.13283694f, 0.03672343f, 0.00898336f, 
    -0.05112712f, -0.22388294f, -0.29857075f, 0.10136789f, -0.00511377f, 0.03094722f, 0.16259824f, 0.11492837f, 
    0.06741106f, 0.09156995f, -0.04211383f, -0.16249645f, 0.11504120f, 0.26090536f, -0.00527428f, 0.00733397f, 
    -0.10816439f, -0.11852286f, 0.00232869f, 0.05862652f, 0.22379869f, -0.07207331f, -0.14432414f, 0.02281502f, 
    -0.04632494f, -0.07911128f, -0.51607341f, 0.10960213f, 0.05643343f, 0.21130747f, -0.00070916f, -0.07090326f, 
    -0.14210823f, -0.03787854f, 0.01413525f, 0.33783665f, -0.01577728f, -0.14001752f, 0.13555916f, 0.09765699f, 
    0.22965422f, -0.02059348f, 0.04966044f, -0.12764762f, 0.07200222f, 0.24651001f, 0.13183938f, 0.00191787f, 
    0.01165206f, -0.08368296f, 0.12012462f, 0.00671368f, 0.10123505f, -0.07078962f, 0.03506986f, 0.19547185f, 
    -0.02633129f, 0.02931670f, 0.05626250f, 0.01702731f, -0.02070283f, 0.14754070f, 0.09103458f, 0.06481281f, 
    0.10198092f, 0.02697263f, 0.09311765f, -0.20124233f, 0.13180637f, -0.11732949f, 0.01499407f, -0.10478926f, 
    0.28502622f, 0.15979348f, 0.03985969f, -0.03611588f, -0.02656039f, 0.07983798f, 0.04897558f, 0.04314649f, 
    0.03836608f, 0.01566265f, -0.06658082f, -0.04561114f, 0.02122683f, 0.03138771f, 0.00717429f, -0.11674521f, 
    -0.00184504f, -0.25881732f, -0.01940646f, 0.15864025f, -0.08132456f, -0.04026725f, 0.01938272f, -0.02770869f, 
    -0.11821891f, -0.08765859f, -0.06140078f, -0.10807972f, -0.01838973f, -0.01167123f, -0.04300946f, 0.16361360f, 
    0.09407878f, -0.09671915f, 0.05375295f, 0.38171420f, -0.15181595f, 0.08785737f, -0.06494696f, 0.09235247f, 
    0.05934767f, 0.04840438f, 0.12228149f, 0.01414690f, -0.02652152f, -0.31286958f, 0.09279250f, 0.00770460f, 
    -0.03721937f, -0.16947979f, 0.01957665f, -0.14903960f, 0.21759675f, -0.03713167f, 0.11393382f, -0.13978641f, 
    0.03874834f, 0.09734204f, 0.02181559f, 0.07933759f, 0.01918250f, 0.12279865f, -0.18731491f, 0.18743593f, 
    0.18862219f, -0.30812091f, -0.01394279f, 0.16298953f, -0.16384727f, 0.08775495f, -0.01913465f, 0.13751043f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.05088682f, 0.16850406f, 0.04136484f, 0.10088434f, 0.16953385f, 0.05803121f, 0.06844378f, 0.00559617f, 
    0.01264279f, 0.21184029f, 0.14702144f, -0.01248406f, 0.03621951f, 0.16862290f, 0.04764502f, 0.02589944f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.22248958f, -0.69421953f, 0.07362787f, -0.33358294f, -0.29902104f, 0.15179706f, 0.03654468f, -0.49057594f, 
    -0.05330778f, -0.09831833f, -0.10213342f, 0.31265527f, 0.17020555f, -0.47975403f, -0.04685847f, 0.15091686f, 
    0.07721637f, 0.07111426f, 0.03580634f, 0.17505713f, 0.14709517f, -0.16243058f, 0.03003048f, -0.40825298f, 
    -0.02034709f, -0.18060100f, -0.03366030f, 0.26902166f, 0.26662078f, -0.28528339f, 0.27732012f, -0.07138351f, 
    0.29906750f, 0.08545730f, 0.20363969f, 0.26076853f, 0.09102084f, 0.15598270f, 0.16993442f, 0.17471682f, 
    0.15755215f, -0.40343338f, 0.53898019f, -0.32932228f, -0.12148400f, -0.16887079f, -0.08005282f, 0.18727994f, 
    0.27946055f, -0.24374844f, 0.13137175f, 0.23884277f, -0.08453088f, -0.23093939f, -0.16859722f, 0.33630472f, 
    0.14081991f, 0.39950961f, 0.56986964f, -0.27922735f, -0.22443278f, -0.06012037f, -0.16755362f, 0.31805816f, 
    0.28486884f, -0.40233955f, -0.12370292f, 0.43611827f, -0.32680896f, 0.12319076f, -0.18138924f, -0.09673370f, 
    0.26642162f, -0.15006043f, 0.49754211f, 0.20561787f, 0.12288407f, -0.15304776f, 0.04806510f, -0.10974286f, 
    -0.09190755f, 0.17539626f, 0.37389949f, 0.10438029f, 0.40971473f, 0.06554716f, 0.00431792f, -0.11480180f, 
    0.21418178f, -0.00415615f, 0.09607118f, 0.32403871f, 0.15677118f, -0.34935921f, -0.34163231f, 0.00485310f, 
    -0.20277539f, 0.32988280f, -0.62879515f, 0.11166979f, -0.38189799f, -0.01050740f, 0.01561898f, 0.06046832f, 
    0.10570549f, 0.01752889f, -0.51702797f, 0.34568539f, 0.07556364f, 0.20189106f, 0.07159084f, 0.03949801f, 
    0.14014606f, 0.68784159f, -0.00695688f, 0.31457767f, 0.01464328f, -0.18124405f, 0.22339267f, -0.20515811f, 
    0.15725243f, 0.06465530f, 0.21300738f, -0.05419778f, -0.37242952f, -0.24556486f, 0.23466302f, -0.23821491f, 
    -0.14555813f, 0.35020575f, 0.41949058f, -0.15481572f, 0.19558105f, -0.17261758f, -0.15079287f, -0.58170253f, 
    -0.18814795f, -0.06346590f, -0.07139870f, 0.05967725f, -0.01422163f, -0.39259952f, -0.04006755f, -0.05488119f, 
    -0.33665475f, 0.20685486f, -0.27862993f, -0.30291155f, -0.02637450f, 0.09258500f, 0.09965235f, 0.18114232f, 
    0.12731595f, 0.40103433f, -0.33883372f, -0.41110164f, 0.22455797f, -0.22814821f, -0.35587054f, -0.29486549f, 
    0.27667239f, -0.17238697f, 0.03081429f, -0.21823190f, -0.28012937f, 0.22788016f, -0.00194204f, 0.68939286f, 
    0.17519392f, -0.04339863f, 0.42101285f, -0.10042913f, -0.20595986f, 0.07870179f, -0.01471369f, 0.10367959f, 
    0.07995209f, 0.23662101f, -0.23999022f, 0.39093488f, 0.20000486f, 0.24644066f, -0.23095623f, 0.39941078f, 
    -0.02363462f, -0.24972084f, -0.21882434f, -0.19178069f, 0.07191087f, -0.19902019f, 0.14917924f, -0.05378729f, 
    -0.01577891f, -0.16582848f, 0.26709148f, -0.35253388f, 0.34465519f, 0.04185478f, -0.05504202f, 0.10564749f, 
    -0.60764074f, 0.26172599f, -0.02338343f, 0.19074306f, 0.04096510f, 0.22411248f, -0.01557433f, -0.13692521f, 
    -0.24978125f, -0.00623762f, 0.11943827f, -0.01116247f, -0.04944957f, -0.03651555f, 0.02847449f, 0.16675989f, 
    0.18702891f, -0.11175089f, 0.19304872f, -0.19198653f, -0.11609828f, -0.28655851f, 0.20626417f, 0.40443748f, 
    -0.33954832f, 0.03083040f, 0.12179805f, -0.17513472f, -0.16215499f, 0.18576886f, -0.18193035f, -0.04029373f, 
    0.19698243f, 0.58965319f, -0.46845022f, -0.10394672f, -0.10945660f, 0.26174766f, -0.01094716f, 0.04894994f, 
    -0.16715993f, 0.38579878f, -0.29522434f, 0.41297555f, 0.27708194f, 0.14318305f, -0.18323794f, -0.12139376f, 
    0.17038985f, -0.16355850f, 0.16337165f, 0.04656300f, -0.13718511f, -0.10031351f, -0.02353941f, 0.31825197f, 
    0.00407693f, 0.48502406f, 0.31341833f, -0.39524758f, -0.00509283f, 0.18548870f, 0.15373857f, 0.04395123f, 
    0.10263465f, -0.42752343f, -0.27462715f, 0.31688315f, -0.06390867f, 0.19432199f, 0.05958949f, -0.16091636f, 
    -0.16120698f, 0.19795093f, -0.22692397f, 0.10019843f, 0.40831405f, -0.14702693f, -0.11800870f, -0.40953735f, 
    0.29053202f, -0.08157762f, 0.35359085f, -0.12978114f, 0.12440279f, -0.23966007f, 0.21481816f, 0.00770726f, 
    -0.19098838f, 0.06185305f, -0.71017063f, -0.29361627f, -0.57360864f, -0.01742086f, 0.24994597f, 0.28768411f, 
    0.26899377f, -0.01680814f, -0.45271415f, -0.04191659f, 0.04971080f, -0.17354217f, -0.11295209f, 0.16487181f, 
    -0.26400247f, 0.30384690f, -0.69790745f, -0.25047243f, -0.13075845f, 0.05904938f, 0.21450496f, 0.20210853f, 
    0.12414413f, -0.06891488f, -0.00071435f, -0.22632672f, 0.25910911f, 0.26982486f, -0.12491601f, -0.09305912f, 
    0.06647347f, 0.19152628f, -0.24886620f, 0.11671380f, -0.15317743f, 0.18541020f, 0.08488922f, 0.05336772f, 
    0.18053520f, 0.29913560f, 0.28844178f, -0.33426535f, -0.10521236f, -0.10813984f, 0.10568395f, 0.24489504f, 
    0.07246710f, 0.06261978f, 0.29626164f, -0.26156783f, -0.30207407f, -0.22501822f, -0.15825991f, 0.29886955f, 
    -0.26087123f, 0.50887311f, 0.12187746f, -0.14696747f, -0.43544066f, -0.06344027f, 0.30880743f, 0.11954622f, 
    0.08775405f, -0.15253296f, -0.05605198f, -0.11228412f, -0.18900014f, 0.18689585f, -0.06430328f, 0.01675490f, 
    -0.09376433f, 0.04512374f, 0.14695118f, 0.00801229f, -0.19456401f, 0.19701049f, -0.24914931f, -0.27510777f, 
    0.04889802f, 0.28249234f, 0.27958819f, 0.06464187f, -0.05065132f, -0.12267662f, -0.24633457f, -0.27160034f, 
    0.16490960f, -0.23928948f, -0.18292134f, 0.48518234f, -0.09595955f, 0.36059618f, -0.10209098f, -0.12384587f, 
    0.16871172f, 0.05872210f, 0.25358927f, -0.42897525f, 0.23581645f, -0.17923592f, 0.19998521f, -0.10771626f, 
    -0.25006962f, 0.47181514f, -0.40837058f, -0.15483035f, -0.18789107f, 0.12087440f, -0.30447033f, 0.33781451f, 
    -0.09293455f, -0.27947226f, -0.16617766f, -0.09940151f, 0.37457666f, 0.20538484f, 0.03265933f, 0.18277760f, 
    -0.11920742f, -0.16169174f, 0.04567679f, -0.12066118f, 0.07812759f, 0.41320816f, 0.00150574f, 0.18811958f, 
    0.25144342f, -0.13989052f, -0.04269537f, 0.01024670f, 0.02002632f, -0.07183053f, 0.05309407f, -0.21883546f, 
    0.30697253f, 0.08628293f, 0.67900783f, -0.32002202f, -0.16719528f, -0.01924749f, -0.10952748f, 0.26807579f, 
    0.14255112f, 0.25004211f, -0.09463233f, 0.41841888f, -0.18391825f, 0.15458913f, -0.21744779f, -0.27460018f, 
    0.15484361f, 0.47796857f, -0.30580714f, -0.29168871f, -0.06144170f, 0.12089760f, 0.13952109f, 0.16925350f, 
    0.06206367f, 0.37095362f, 0.05443956f, -0.34630558f, 0.00760054f, 0.24453136f, -0.02661034f, 0.09304550f, 
    -0.05722753f, -0.09116571f, -0.11876395f, -0.17031763f, -0.20120020f, 0.19474818f, 0.00816075f, -0.15064977f, 
    0.09090046f, -0.12441728f, 0.19267288f, -0.39034280f, -0.05912525f, -0.03899622f, -0.15932338f, 0.21760054f, 
    -0.31061447f, 0.06568228f, -0.41967297f, 0.14152531f, 0.08093181f, 0.15906501f, -0.01199949f, 0.13074718f, 
    -0.06730451f, 0.26289955f, 0.23980315f, -0.26889715f, -0.15695199f, -0.22905284f, 0.08793828f, -0.19256802f, 
    0.15056327f, 0.50373834f, -0.36052299f, -0.03286453f, 0.05408207f, 0.30250049f, -0.35283789f, 0.13020992f, 
    0.05423442f, 0.24184100f, -0.39757115f, -0.25898170f, 0.24732132f, -0.01698930f, 0.25093514f, 0.39430249f, 
    0.01724797f, 0.30339682f, -0.06262960f, -0.03586454f, -0.24853873f, 0.21289583f, -0.11441536f, 0.17899199f, 
    0.07908654f, 0.01125429f, -0.00977175f, 0.40662771f, -0.33363000f, 0.04707548f, -0.20907247f, 0.10417582f, 
    -0.26003280f, 0.01811479f, 0.29727855f, 0.25306174f, 0.10428576f, 0.07268770f, -0.00456125f, -0.28820530f, 
    -0.20481320f, -0.06080200f, -0.08848239f, -0.21702901f, 0.37024087f, -0.04024481f, -0.19292748f, -0.18400688f, 
    -0.18605517f, 0.01819041f, 0.09103698f, 0.36579654f, -0.13946556f, -0.06128945f, 0.27270472f, -0.27252707f, 
    -0.23209375f, -0.57308984f, -0.04818320f, 0.03812027f, 0.37385011f, -0.04158301f, 0.23617549f, -0.24114572f, 
    -0.62062150f, 0.08968009f, -0.10742238f, 0.32179305f, 0.09742507f, -0.22489755f, 0.00217665f, -0.08869510f, 
    0.25263214f, -0.00344266f, -0.09403506f, 0.15101849f, -0.38970461f, -0.22724201f, -0.07084516f, 0.12889078f, 
    -0.23613170f, 0.33418807f, -0.24074806f, 0.27369240f, -0.41161186f, -0.34611061f, 0.16364041f, 0.16959378f, 
    -0.16884889f, -0.26755625f, -0.06111456f, -0.27311966f, 0.18698879f, -0.08427452f, -0.10859755f, -0.49736935f, 
    -0.14899994f, 0.00464329f, 0.17713703f, 0.25553140f, -0.20693488f, 0.46108454f, -0.05281481f, 0.29759023f, 
    -0.00092769f, 0.27549845f, 0.19438918f, -0.04042005f, -0.32751012f, -0.22952157f, -0.15379110f, -0.57739115f, 
    -0.23871577f, -0.18118605f, -0.06122431f, 0.31613377f, 0.00459926f, 0.18694437f, 0.21815263f, -0.01200843f, 
    0.09643104f, -0.44468340f, -0.04682088f, 0.33591166f, -0.37686864f, 0.19090074f, 0.15371734f, -0.49422085f, 
    -0.09304781f, 0.25265858f, 0.08194521f, 0.04577552f, -0.03307964f, 0.20418155f, 0.30172840f, 0.19823296f, 
    -0.08033376f, 0.43404427f, 0.38866854f, -0.28485966f, 0.21692473f, -0.07001439f, -0.06351882f, 0.09379317f, 
    -0.21826337f, -0.57405901f, 0.11893436f, -0.04401936f, 0.06413966f, -0.35457242f, 0.05592906f, 0.12465744f, 
    -0.26064509f, 0.08317997f, 0.38720119f, -0.07201749f, 0.12565185f, -0.18443337f, -0.17686234f, 0.20427772f, 
    -0.30010065f, 0.15315300f, -0.19617680f, 0.35875931f, -0.03799950f, -0.30640030f, -0.08486354f, -0.07775801f, 
    -0.65391082f, 0.34795660f, -0.79080147f, 0.04679368f, -0.84307808f, -0.21736374f, 0.24288437f, 0.02963290f, 
    0.31301466f, -0.04302200f, -0.04691412f, -0.03044957f, -0.10211361f, -0.57901692f, -0.09087830f, -0.08642947f, 
    0.14230406f, 0.29543042f, 0.14053264f, -0.06117036f, -0.43521082f, 0.11108094f, -0.00470204f, 0.01143304f, 
    -0.12844224f, -0.00599873f, 0.26170933f, 0.24511789f, -0.28392977f, 0.20833598f, 0.05752691f, 0.18911257f, 
    0.03896362f, -0.25929084f, -0.10208368f, 0.38891903f, 0.45826736f, -0.24988371f, 0.06495961f, -0.42638719f, 
    -0.20652811f, -0.17427455f, -0.31090939f, -0.22222690f, -0.09598781f, 0.53096431f, 0.28837180f, -0.04409487f, 
    0.09625224f, 0.05426614f, 0.02846383f, 0.12945312f, -0.26379964f, -0.16109590f, 0.09296567f, -0.08156040f, 
    0.37118590f, 0.23067208f, -0.07383536f, -0.01419994f, -0.47673535f, 0.19237977f, -0.10456646f, 0.24208724f, 
    0.30990610f, 0.05954090f, 0.21005264f, -0.08301458f, 0.22197878f, 0.08095883f, -0.09588597f, 0.19517483f, 
    0.07390156f, -0.41111284f, -0.25531808f, 0.08337884f, 0.04672520f, -0.27850339f, -0.03237636f, -0.07459842f, 
    -0.07727253f, 0.10441436f, 0.36673164f, 0.07845780f, -0.35513282f, -0.15843657f, 0.25352544f, 0.25524816f, 
    0.04304704f, 0.28957593f, -0.24450518f, -0.27409452f, 0.32410961f, -0.04266787f, -0.10390597f, 0.06997348f, 
    0.15126401f, 0.28643188f, -0.18769106f, 0.00068154f, 0.31003329f, 0.17149693f, -0.10149287f, 0.05414911f, 
    0.04340604f, 0.36174697f, -0.24921805f, -0.08135206f, 0.09325879f, -0.13682245f, -0.15871872f, 0.17647402f, 
    0.33486918f, 0.18700427f, -0.03379674f, -0.24720630f, -0.40218523f, 0.16343287f, 0.05594935f, 0.47233459f, 
    -0.31612864f, -0.37061137f, 0.04285378f, 0.27299243f, -0.67676497f, 0.25835851f, 0.27905965f, -0.01526855f, 
    0.10602618f, -0.08935009f, 0.32204291f, -0.19373433f, -0.11849990f, -0.19348641f, -0.13671492f, -0.10835242f, 
    0.07158998f, 0.38390177f, -0.06443977f, -0.43440869f, 0.16865845f, -0.00762257f, -0.09285511f, 0.33821294f, 
    0.07103608f, -0.24244830f, 0.16537409f, -0.11710805f, -0.23167594f, -0.11149360f, 0.12790424f, 0.57012016f, 
    -0.18939875f, 0.12821789f, -0.09488524f, -0.07931656f, -0.49884030f, 0.15814473f, 0.06040059f, 0.20611513f, 
    0.20040028f, -0.19188088f, 0.34120369f, 0.02560839f, -0.07201087f, -0.14068544f, 0.13805336f, -0.53287160f, 
    -0.12255316f, -0.18765576f, 0.28070763f, -0.19988818f, -0.94011438f, 0.11173328f, -0.01094931f, 0.05071196f, 
    0.05072067f, -0.00107702f, 0.08164212f, -0.02950919f, -0.18516488f, -0.21892405f, -0.06027305f, 0.00663526f, 
    -0.02495606f, -0.23379868f, 0.08914611f, -0.03697097f, 0.09566503f, 0.05129172f, -0.25959200f, -0.29394668f, 
    0.10531911f, 0.09816096f, -0.14736168f, 0.04219764f, 0.22732769f, 0.22752911f, 0.05527380f, 0.10889886f, 
    0.04976933f, 0.37587872f, 0.27388030f, -0.39414173f, -0.45730481f, 0.17390710f, -0.14080958f, 0.37344128f, 
    0.04036957f, -0.09465104f, 0.02868123f, -0.12114809f, 0.04662405f, -0.20328024f, -0.23352244f, -0.39686510f, 
    0.09585895f, 0.30800411f, 0.47688156f, -0.22410060f, -0.14764744f, -0.01566029f, -0.20603505f, 0.41457096f, 
    0.16714920f, -0.38159525f, 0.45420414f, -0.33986533f, 0.19881074f, 0.03202554f, 0.22607455f, -0.31390718f, 
    -0.01229581f, 0.05976127f, 0.14812593f, 0.09256417f, 0.11571357f, 0.15743735f, -0.09185688f, -0.06201202f, 
    -0.02049579f, 0.07776644f, 0.40199685f, 0.18152100f, 0.15481398f, -0.14740312f, -0.17518348f, 0.34021801f, 
    -0.18782689f, -0.36540714f, 0.12335169f, 0.10155619f, 0.11419713f, -0.17701273f, -0.29831004f, 0.11859260f, 
    -0.07202347f, 0.65493411f, 0.12465560f, -0.26930654f, 0.06466320f, 0.01165904f, -0.14799307f, 0.25882888f, 
    0.21893156f, 0.14929962f, -0.32262367f, -0.05665678f, -0.21766479f, 0.15719050f, 0.05941615f, 0.15825024f, 
    0.32751355f, -0.32468176f, -0.05007705f, -0.08763435f, -0.32986739f, 0.04147100f, -0.01334264f, 0.26455975f, 
    -0.25306010f, 0.27073339f, 0.02774437f, -0.10275438f, -0.09768732f, 0.25816193f, 0.01230861f, 0.33557168f, 
    -0.11436639f, -0.34078491f, -0.01703305f, 0.41545120f, 0.28461999f, 0.01716980f, 0.16979909f, -0.10840049f, 
    0.07424269f, 0.15641922f, -0.13952869f, -0.19878614f, 0.32930946f, 0.34089941f, 0.00175966f, 0.01263626f, 
    -0.04381862f, 0.16495134f, -0.21514830f, 0.32446998f, 0.19674936f, -0.02917376f, -0.01054278f, -0.02600775f, 
    0.03098649f, -0.16460800f, 0.32932487f, -0.24878165f, -0.03182782f, 0.23815285f, -0.16224635f, 0.39849779f, 
    0.14610943f, -0.07729481f, 0.48875862f, 0.11596902f, -0.24662986f, 0.09391794f, 0.12856963f, 0.02309582f, 
    0.06005272f, -0.06290885f, 0.36030602f, 0.15939702f, 0.02810533f, -0.33732408f, -0.20345241f, -0.04356711f, 
    0.24951760f, -0.16429663f, 0.14522174f, -0.15592200f, -0.24068730f, -0.04940297f, -0.00523771f, -0.38051888f, 
    0.30691773f, 0.28380609f, 0.26594639f, 0.02250391f, -0.27447888f, 0.10421936f, -0.40705422f, 0.21513803f, 
    -0.12156896f, -0.10404164f, 0.40260872f, 0.18445526f, -0.24947564f, -0.14824951f, 0.23671335f, -0.05057454f, 
    -0.02654711f, -0.05465488f, 0.37056452f, -0.08941408f, 0.13738376f, 0.36864489f, -0.22493795f, 0.23341596f, 
    -0.03777605f, 0.08010942f, 0.16072498f, -0.24519934f, 0.41564590f, -0.16192615f, 0.16352929f, 0.24663609f, 
    -0.23204724f, 0.42213637f, -0.31716606f, -0.07322857f, 0.05474111f, 0.46721315f, 0.12211507f, -0.23942997f, 
    0.19486627f, 0.23929191f, 0.40574029f, -0.35840073f, 0.40687108f, -0.23723941f, 0.08135650f, 0.12314984f, 
    0.13793334f, -0.47242033f, -0.18621948f, 0.03990993f, -0.18789423f, -0.30698943f, 0.31239226f, -0.17255403f, 
    -0.20989618f, -0.08021225f, 0.32225668f, -0.08395000f, 0.09921560f, -0.22393638f, 0.18205866f, 0.03472226f, 
    -0.42634538f, -0.42183408f, 0.19477159f, 0.27189153f, 0.01775285f, 0.00454544f, -0.27184221f, 0.16710505f, 
    0.16210680f, -0.01904784f, -0.14182569f, -0.08805497f, 0.16468281f, 0.21746615f, -0.00657660f, -0.23877764f, 
    -0.15947369f, -0.05168864f, -0.21473195f, -0.13017602f, -0.18361804f, -0.27452907f, -0.20959522f, -0.28283146f, 
    -0.18492982f, 0.44324484f, -0.24114659f, 0.41879568f, 0.03648474f, -0.07689121f, 0.08985242f, -0.41169098f, 
    0.18716598f, -0.23783718f, -0.06646867f, 0.04893559f, -0.31603166f, 0.54810524f, 0.05657287f, 0.08033023f, 
    0.19779207f, 0.25383106f, 0.28782600f, -0.11760057f, -0.35587573f, -0.21714734f, -0.11208575f, -0.13150625f, 
    0.10612305f, 0.14820154f, -0.15603451f, -0.30704686f, 0.10369657f, 0.28216588f, -0.19573122f, 0.28277797f, 
    0.43919384f, -0.24295013f, 0.03449577f, 0.32591882f, 0.07214170f, 0.22299443f, 0.10274664f, -0.21671027f, 
    -0.29378754f, 0.07593419f, -0.29423141f, -0.04566101f, -0.43782607f, 0.21583313f, -0.08410440f, -0.19525020f, 
    0.01040092f, 0.39868760f, 0.15164632f, 0.32128158f, -0.34244987f, -0.13881218f, -0.16615088f, -0.02464201f, 
    -0.18960284f, -0.01425974f, 0.23817609f, 0.29837897f, 0.13341239f, 0.05620947f, 0.07797518f, -0.23096654f, 
    -0.01583458f, 0.42800900f, 0.46276277f, -0.32056522f, -0.22231957f, 0.24090518f, -0.05827016f, -0.14585657f, 
    0.24947447f, 0.03970368f, -0.07295498f, 0.00531620f, -0.41435319f, -0.05308324f, -0.21822622f, 0.47790372f, 
    0.36769536f, -0.51048422f, 0.01790632f, 0.37908962f, -0.32143834f, -0.02138631f, -0.05828515f, -0.39675209f, 
    -0.34899798f, 0.23479810f, 0.25518432f, 0.27414489f, -0.24966478f, 0.06007062f, 0.03819359f, -0.26309448f, 
    0.06936013f, 0.33688626f, -0.46906513f, 0.20752862f, 0.12917805f, 0.21319468f, 0.10029134f, 0.23778453f, 
    -0.09198178f, 0.12371259f, 0.43924922f, 0.25846431f, -0.26087165f, -0.19664875f, 0.30503574f, -0.11448967f, 
    0.25318775f, 0.09506437f, -0.14229624f, 0.20595832f, 0.29132736f, -0.04987789f, 0.20527469f, 0.13946897f, 
    -0.32124978f, -0.06894067f, -0.13485707f, 0.22622141f, -0.29924321f, 0.09953385f, 0.27390644f, -0.07027441f, 
    -0.05458109f, -0.03479040f, -0.06465210f, 0.15324484f, 0.45726663f, -0.13002945f, -0.06845649f, 0.15079199f, 
    -0.02315283f, 0.09524149f, -0.20668221f, -0.30390421f, 0.08726437f, -0.17859825f, 0.24653168f, 0.05933491f, 
    -0.12920435f, 0.46108443f, -0.08351830f, 0.05341611f, 0.06476226f, -0.22562611f, 0.14494988f, -0.29878905f, 
    -0.26022044f, 0.06444189f, 0.09120330f, 0.15171649f, -0.38330612f, 0.39407691f, 0.36635873f, -0.00858565f, 
    0.31013787f, 0.24635980f, 0.12221427f, -0.20864189f, 0.39508933f, 0.09209822f, -0.01224261f, 0.20935106f, 
    -0.00424616f, -0.23932922f, 0.14179154f, 0.01241078f, -0.10817967f, -0.03168051f, 0.26857597f, -0.26083392f, 
    0.25993654f, 0.26321197f, 0.19480927f, 0.00261400f, -0.12036150f, 0.07407047f, -0.21747532f, -0.08815166f, 
    0.12164038f, -0.40220967f, 0.33344492f, 0.17279138f, -0.03693239f, -0.25018674f, -0.01558356f, 0.14571652f, 
    -0.29244241f, -0.01576015f, 0.26818401f, -0.22346945f, -0.29830787f, 0.13269460f, 0.11862307f, -0.18581764f, 
    0.29455513f, 0.51002765f, -0.08708762f, 0.16421741f, -0.40280670f, 0.39991179f, -0.08965503f, 0.19749601f, 
    -0.05215402f, -0.09060017f, -0.33832219f, -0.17605467f, 0.29690033f, -0.05015723f, -0.18283576f, -0.32266510f, 
    0.23368232f, -0.14667222f, 0.33229017f, 0.09429058f, 0.12312160f, -0.13898200f, 0.08928841f, 0.03364062f, 
    0.44395804f, 0.34727919f, 0.01667532f, 0.18771686f, -0.10982356f, -0.07259641f, -0.15070382f, 0.26030952f, 
    -0.13047703f, 0.36997116f, -0.03511999f, -0.35283542f, -0.36644638f, 0.24932609f, 0.09160402f, -0.02881617f, 
    -0.32873115f, 0.69354445f, -0.16371655f, 0.15807877f, 0.51286054f, 0.05613846f, 0.04554554f, -0.01591018f, 
    -0.16320199f, -0.02020508f, -0.23018458f, 0.15779923f, -0.06188219f, -0.00718698f, 0.04892951f, -0.04343916f, 
    -0.05862141f, -0.06650727f, -0.02208656f, -0.12695462f, 0.18939494f, 0.07911429f, 0.02444667f, -0.10201570f, 
    -0.00376007f, 0.05278920f, -0.08695513f, -0.17569159f, 0.04853383f, -0.17126599f, -0.15588771f, -0.11249215f, 
    -0.08069819f, -0.17949912f, -0.17494899f, -0.18047172f, -0.00335634f, -0.12886512f, 0.22413594f, -0.07736415f, 
    -0.19788596f, 0.17419189f, 0.14492974f, -0.21281120f, -0.22679389f, -0.19668096f, -0.15026501f, -0.21176177f, 
    -0.11848356f, 0.34005728f, -0.10358889f, 0.13045685f, 0.32884327f, -0.21943374f, -0.10071138f, -0.32890430f, 
    0.27066511f, 0.08804763f, 0.28516698f, -0.16148297f, -0.56827712f, 0.16970986f, -0.26767442f, 0.40818870f, 
    0.23661326f, 0.33535951f, -0.35723889f, 0.32155663f, 0.34534281f, 0.02733122f, -0.11561812f, 0.10839601f, 
    0.19036874f, -0.38578394f, -0.13669781f, -0.13039909f, -0.47596106f, 0.16136944f, 0.16189246f, 0.00785120f, 
    -0.26685095f, 0.05634627f, 0.09263849f, 0.04007786f, 0.07108826f, 0.15651542f, -0.12621149f, -0.05607817f, 
    -0.09405303f, -0.07434064f, -0.17339611f, -0.08765046f, -0.18045658f, 0.19955981f, -0.13105072f, 0.00042089f, 
    0.16628937f, 0.36727208f, 0.21840891f, 0.19114372f, -0.12737688f, 0.03674208f, -0.00834170f, 0.51360708f, 
    -0.31823346f, -0.23237686f, 0.17472313f, -0.13801908f, -0.09356478f, 0.29234114f, -0.02937615f, -0.23369952f, 
    -0.24641648f, 0.14322302f, 0.00830869f, 0.23057584f, -0.35739225f, 0.00514340f, -0.13226438f, 0.00944037f, 
    -0.39672735f, 0.10108312f, 0.06520895f, 0.52800775f, 0.27340162f, 0.19906512f, -0.03109161f, 0.01273034f, 
    -0.19539323f, -0.10568779f, -0.07372785f, -0.07850667f, 0.22010815f, 0.23399718f, -0.23962022f, -0.12077927f, 
    -0.32921037f, -0.04015323f, -0.18890414f, 0.40259343f, -0.11975476f, -0.28161803f, 0.34332979f, -0.14613980f, 
    -0.11533556f, 0.43661413f, 0.09130713f, 0.24589384f, 0.07269181f, -0.06476912f, 0.24969912f, -0.54661429f, 
    0.29648760f, -0.26250392f, -0.21167265f, -0.03740832f, 0.15372275f, -0.08059195f, 0.10068625f, -0.06164751f, 
    -0.15473172f, -0.21175571f, -0.21311787f, 0.00085946f, 0.02009275f, -0.02151406f, 0.01404650f, 0.12996802f, 
    0.14305763f, -0.33472365f, 0.26109898f, 0.22472265f, 0.24381211f, 0.03987638f, 0.08471116f, -0.27922681f, 
    0.06361675f, -0.11590916f, -0.19210440f, 0.18137750f, -0.19069397f, 0.05735990f, -0.23467848f, -0.19840872f, 
    -0.19268343f, 0.05112860f, -0.19821680f, -0.03615656f, -0.00713417f, -0.18172029f, -0.18030789f, 0.06918108f, 
    0.35257083f, -0.15067561f, 0.09651533f, -0.46027619f, -0.23215362f, 0.16696016f, 0.14241286f, 0.53211337f, 
    0.08816296f, -0.14343446f, -0.28525800f, -0.05967220f, -0.06658744f, -0.25882527f, 0.28461939f, -0.09910973f, 
    -0.07512277f, -0.12478009f, 0.11948862f, 0.23211357f, 0.13315390f, -0.03819148f, 0.04082039f, -0.01594923f, 
    0.15390833f, -0.32668361f, 0.43259904f, 0.20480828f, 0.13961469f, 0.04108787f, -0.36266688f, 0.20440029f, 
    -0.11662343f, -0.24279782f, -0.12880215f, -0.09165245f, -0.12316677f, 0.11127126f, 0.13396147f, 0.14145374f, 
    -0.10320434f, -0.17094526f, 0.21876180f, -0.10688606f, -0.18842682f, 0.14193121f, -0.19501853f, -0.12264761f, 
    0.11046473f, 0.20683415f, 0.23494038f, -0.26376569f, -0.27733478f, 0.00625311f, 0.10094621f, -0.00436147f, 
    0.01891435f, -0.16621377f, -0.11454316f, -0.08015389f, 0.04242066f, 0.32908443f, -0.17766288f, 0.24882503f, 
    0.27748436f, -0.30323431f, 0.22291635f, 0.12362532f, -0.09720541f, -0.20303416f, -0.02914771f, 0.37891406f, 
    -0.17938635f, 0.37873089f, -0.19153804f, -0.36779404f, -0.06223398f, -0.09786063f, 0.23643754f, 0.10901031f, 
    0.19689389f, -0.04472354f, -0.19521675f, 0.34096846f, 0.00433194f, -0.01356472f, 0.05259509f, 0.10385155f, 
    -0.30436611f, 0.20521559f, 0.10821492f, -0.25765771f, 0.12368526f, 0.28147703f, 0.37388662f, -0.10865181f, 
    -0.01326160f, -0.07461031f, 0.31155470f, -0.09177399f, 0.07786833f, -0.24803576f, 0.05229393f, 0.31694934f, 
    -0.09207438f, 0.12714925f, -0.55594522f, -0.55103570f, 0.17970598f, 0.29920056f, 0.19713707f, 0.16542083f, 
    0.29386070f, -0.11788036f, -0.54834139f, 0.09961708f, -0.45691758f, -0.09587577f, -0.22755101f, -0.11082119f, 
    0.25613081f, -0.20849992f, 0.21066369f, -0.12512827f, -0.23163162f, -0.31519625f, 0.44444954f, 0.14875722f, 
    -0.12285859f, 0.39928728f, -0.26667899f, 0.25298414f, 0.04612959f, -0.16568635f, 0.02150708f, -0.00931138f, 
    0.15353529f, 0.03561216f, 0.11984347f, 0.32299715f, 0.00035932f, -0.16113609f, 0.11431375f, -0.25545076f, 
    -0.09882487f, 0.16393378f, -0.20569548f, 0.34041137f, 0.21134019f, 0.20115639f, 0.10754216f, 0.16175753f, 
    -0.31123313f, -0.60392958f, 0.07738717f, -0.21684556f, 0.16516173f, 0.34079626f, 0.20144844f, 0.14960800f, 
    0.08411975f, -0.07437325f, 0.23149006f, 0.16437268f, 0.07394931f, -0.19985425f, 0.15877987f, -0.00561328f, 
    0.39970851f, 0.20614120f, 0.27075878f, 0.21966672f, -0.26725659f, -0.36257020f, -0.28314888f, 0.05127301f, 
    0.16598105f, -0.13113379f, 0.05945577f, -0.00141368f, 0.21322854f, 0.09953498f, -0.06477021f, -0.27203339f, 
    0.01904059f, 0.18743025f, -0.29131290f, 0.08006255f, 0.12827551f, -0.00522970f, 0.29429889f, -0.37538180f, 
    0.28964156f, -0.31252509f, -0.03708506f, 0.34366587f, -0.14609885f, -0.12833613f, 0.21711816f, -0.24293962f, 
    0.06294152f, 0.49411783f, 0.17860852f, -0.24324915f, -0.38744771f, 0.24025105f, 0.14772408f, -0.12118901f, 
    0.03435298f, 0.19299173f, -0.21879216f, 0.28131199f, 0.49414399f, 0.14004356f, -0.22507747f, -0.17377497f, 
    0.18190849f, -0.18430986f, 0.18578856f, -0.04513360f, -0.02433784f, 0.08471633f, 0.14415105f, -0.04944864f, 
    -0.10554554f, 0.40097174f, -0.28409198f, 0.08929978f, 0.46177918f, -0.04299311f, 0.05520506f, -0.20731299f, 
    0.05359096f, -0.21529816f, 0.07920659f, 0.37816894f, -0.05343719f, 0.00804815f, 0.34122589f, -0.22109203f, 
    0.16856301f, 0.50430644f, 0.12351248f, 0.27033252f, -0.17505051f, 0.06025911f, -0.06166425f, -0.30471423f, 
    0.14168040f, -0.18945150f, -0.50051230f, 0.24800064f, -0.08361033f, 0.00254469f, 0.18634209f, -0.24496982f, 
    0.12617742f, 0.05747050f, 0.09239433f, 0.25758693f, -0.11469169f, -0.01144208f, -0.17166467f, -0.54993635f, 
    -0.31628916f, 0.40109184f, -0.19907311f, 0.21223424f, -0.41457927f, 0.12718159f, 0.24246339f, -0.30848932f, 
    -0.21277967f, 0.32586366f, -0.10401487f, 0.28658897f, 0.25852916f, -0.21358621f, -0.14703682f, -0.25333986f, 
    0.21908465f, 0.05712969f, -0.45957717f, 0.31190467f, 0.00804294f, 0.15482695f, 0.01822858f, -0.37178299f, 
    0.42277789f, 0.14636406f, -0.08821226f, -0.03090652f, -0.23014246f, 0.06070017f, 0.16507784f, 0.46176904f, 
    0.26681420f, 0.11839446f, 0.12586099f, 0.07255579f, -0.13042343f, -0.43027109f, 0.07018001f, -0.29392353f, 
    0.08168261f, -0.11498389f, 0.14994536f, 0.28288978f, 0.40422037f, 0.19831342f, 0.11900367f, 0.52513248f, 
    0.12506156f, -0.39492127f, 0.37608737f, -0.13308151f, -0.02055584f, 0.02234856f, -0.11017406f, 0.10741153f, 
    0.11869852f, 0.06984907f, 0.05995548f, 0.07777430f, 0.00165644f, -0.10392988f, 0.05809873f, 0.36562520f, 
    0.22343573f, -0.01292432f, -0.72952288f, -0.35467708f, -0.03309287f, 0.45013192f, -0.02256214f, -0.09546124f, 
    0.28763819f, -0.01294758f, -0.11949918f, 0.19502106f, -0.38201654f, -0.01211698f, -0.07453934f, 0.23951776f, 
    0.05022344f, -0.32983577f, -0.11232246f, 0.12463897f, -0.39515513f, 0.04414109f, 0.26969123f, 0.15836591f, 
    0.28273606f, -0.26288515f, 0.39002258f, 0.22573307f, 0.27270153f, -0.06486340f, -0.11117208f, 0.05313502f, 
    -0.33457282f, -0.27348095f, -0.30059868f, 0.28606525f, 0.16459072f, -0.16959707f, -0.30564165f, 0.11659653f, 
    0.08874403f, -0.57197350f, -0.13159265f, 0.07237517f, -0.26215813f, -0.14405948f, -0.06034293f, -0.27350551f, 
    0.16547558f, 0.12888964f, 0.36497733f, 0.05853617f, 0.36393753f, -0.22153923f, 0.00627546f, 0.21760923f, 
    0.28351080f, -0.18864806f, 0.05762688f, 0.16271316f, -0.05980050f, 0.12398097f, 0.00458694f, 0.19327568f, 
    -0.36426434f, 0.13695425f, 0.34808943f, 0.08116905f, -0.29258922f, -0.29094106f, 0.33692494f, 0.07372744f, 
    0.19008847f, 0.42960203f, -0.08038213f, 0.01426359f, -0.04782517f, -0.12208627f, -0.19816899f, 0.49162912f, 
    0.19233553f, -0.25792658f, -0.10950976f, -0.21526375f, 0.13149947f, -0.05315027f, -0.12611897f, 0.06711952f, 
    0.05566906f, 0.44416109f, -0.00337570f, -0.28510058f, 0.11499912f, -0.10768641f, 0.09261493f, 0.32708436f, 
    0.14620365f, -0.44145593f, -0.12322439f, -0.04776275f, -0.04843849f, -0.13429870f, -0.24994883f, 0.33431149f, 
    -0.05965877f, 0.33290946f, -0.08335477f, 0.15608247f, 0.00731350f, -0.20188360f, -0.15879533f, -0.15847692f, 
    -0.31152025f, 0.58058727f, -0.10191800f, -0.08462218f, -0.39532876f, 0.16422613f, 0.38211641f, -0.10180711f, 
    0.18732928f, -0.33152887f, -0.14383000f, 0.38097402f, -0.30397108f, -0.06070307f, 0.20661336f, 0.02945914f, 
    0.10946466f, 0.27099413f, -0.02912313f, -0.17073454f, -0.22639617f, 0.25517821f, 0.26716289f, 0.21584548f, 
    0.17709474f, -0.63059050f, 0.33537823f, -0.00859631f, -0.31577092f, 0.20777604f, 0.21853247f, -0.47529927f, 
    -0.11844408f, 0.27987385f, -0.01439841f, 0.02775735f, -0.58451414f, 0.38235673f, 0.03118494f, -0.13379461f, 
    0.17462358f, 0.02933421f, -0.00700821f, 0.23938216f, -0.30801308f, 0.08224854f, -0.10864431f, 0.04915359f, 
    -0.07789919f, -0.01910191f, -0.00545324f, -0.14515674f, -0.14383930f, 0.28361681f, 0.19337296f, 0.15940575f, 
    -0.26379025f, -0.41026947f, 0.02765890f, -0.01822993f, 0.39180353f, 0.00699815f, -0.08177692f, -0.13644698f, 
    0.05171029f, 0.20269117f, 0.08721726f, -0.22564770f, 0.19300120f, -0.02695382f, 0.14816278f, 0.27283987f, 
    -0.09904806f, 0.29811612f, -0.11775635f, 0.26116830f, 0.27118114f, -0.20167145f, 0.18953848f, -0.30694643f, 
    0.17894082f, -0.20340312f, -0.23945484f, 0.08852448f, -0.07333758f, -0.15072975f, -0.34766191f, 0.12285271f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.11446238f, -0.30155376f, -0.16401437f, -0.17984636f, -0.35901275f, -0.25401929f, -0.46427023f, -0.05524334f, 
    -0.05629751f, 0.28877899f, 0.20845801f, 0.20786226f, 0.07642970f, 0.00205174f, 0.17205119f, -0.15362406f, 
    0.06325734f, -0.02490754f, -0.46294469f, -0.11929878f, 0.08663459f, 0.11846486f, -0.16432333f, 0.26144910f, 
    0.06146191f, 0.49783704f, 0.34318593f, 0.30400762f, 0.14778928f, 0.17374717f, 0.22040567f, 0.21778609f, 
    0.22041269f, 0.31548741f, 0.17667124f, 0.20825323f, 0.12600268f, 0.13569357f, 0.14683324f, -0.20961799f, 
    -0.10356636f, 0.16440667f, 0.45491904f, 0.34768638f, 0.33589494f, 0.03590873f, -0.17448258f, -0.32593411f, 
    0.36722127f, 0.36259708f, 0.46521282f, -0.36579379f, -0.29450554f, 0.23807921f, 0.31463599f, 0.26393479f, 
    0.07420727f, -0.19792545f, 0.35654393f, 0.03944226f, 0.06000799f, -0.32490084f, 0.18103729f, 0.43276477f, 
    0.25615993f, 0.28590631f, 0.23348457f, -0.24509005f, 0.29870713f, 0.33904546f, 0.31861386f, -0.26180080f, 
    0.20794603f, 0.05485526f, 0.05516074f, -0.19529812f, 0.26942545f, -0.07422187f, -0.10916385f, -0.26118514f, 
    -0.07093594f, -0.09739736f, 0.16592790f, 0.37396997f, -0.09428912f, -0.16271070f, -0.02770447f, -0.01493931f, 
    -0.22971618f, 0.38865334f, -0.31479204f, 0.43511143f, 0.06241336f, -0.18224205f, -0.17428333f, -0.05799617f, 
    0.27119732f, -0.20894158f, 0.29261935f, 0.33623034f, 0.37659261f, -0.20835033f, 0.31047243f, 0.21981889f, 
    0.20870270f, -0.27480420f, -0.18282250f, 0.47609323f, -0.03817810f, -0.06567963f, 0.09827799f, 0.28054783f, 
    0.29944655f, -0.05839077f, -0.14891005f, 0.17721786f, 0.11627516f, -0.17892608f, -0.14281869f, 0.45076442f, 
    0.04903735f, 0.18732536f, 0.40837339f, 0.16756612f, 0.35970473f, 0.41648272f, 0.14121486f, 0.28788173f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.01208151f, 0.00095096f, 0.14632636f, 0.05571807f, -0.05022554f, 0.05950844f, -0.75128770f, -0.29598454f, 
    0.05537230f, -0.00296776f, -0.01636896f, -0.17016046f, 0.18985543f, -0.11095107f, -0.30630714f, 0.22576278f, 
    -0.32443056f, 0.09947103f, -0.48100263f, -0.64802951f, -0.11138366f, -0.13375680f, -0.01895923f, 0.01782835f, 
    0.02716472f, 0.36441663f, 0.20375024f, -0.16560450f, -0.00294114f, 0.08480519f, -0.22034980f, 0.08860569f, 
    -0.06365819f, 0.10710169f, 0.34440926f, -0.13976781f, 0.43473172f, 0.05713144f, 0.09798892f, -0.05853786f, 
    -0.06611515f, -0.07894506f, 0.08705041f, 0.38223428f, 0.07014580f, 0.08965229f, -0.36117789f, -0.20303243f, 
    0.00982562f, -0.14456479f, 0.01223406f, -0.26955059f, 0.03030712f, 0.03189931f, 0.24590831f, 0.22162339f, 
    0.27175012f, -0.30564523f, 0.00215092f, 0.23880136f, 0.27481362f, -0.23459873f, -0.05271417f, 0.21936032f, 
    0.01813287f, 0.04237174f, 0.31652892f, 0.12449616f, 0.08019140f, -0.17030470f, 0.00770191f, -0.14204662f, 
    0.12779783f, -0.04492543f, 0.04310552f, -0.00139153f, 0.13140184f, 0.09802937f, 0.12425586f, 0.07161380f, 
    0.05321790f, 0.18777597f, -0.18051316f, 0.03283194f, -0.00081947f, 0.08118746f, 0.16774607f, 0.04038772f, 
    0.00505891f, 0.02239654f, -0.04274734f, -0.10393770f, -0.02067148f, -0.17688532f, -0.01019418f, -0.30053791f, 
    0.28960598f, 0.07325270f, -0.00611688f, -0.17341393f, -0.08522295f, -0.15584248f, 0.00941852f, -0.27914643f, 
    0.33938649f, -0.06696450f, 0.02905750f, 0.06439950f, 0.24657044f, -0.00010520f, -0.17118880f, -0.21027778f, 
    -0.14794800f, -0.46316481f, 0.28338996f, -0.07194167f, -0.14010127f, 0.14739497f, -0.06213647f, 0.04124615f, 
    -0.16447435f, -0.07826081f, -0.09813142f, -0.00760496f, -0.02548544f, -0.03019488f, 0.29025793f, 0.18618283f, 
    0.09195394f, 0.00248068f, -0.06352105f, 0.11438903f, -0.04336148f, -0.20730039f, 0.08668479f, 0.06990843f, 
    0.03619041f, 0.37819260f, -0.09368131f, -0.00073601f, -0.04733349f, 0.06839143f, 0.10569599f, 0.00613879f, 
    -0.14071979f, 0.04939146f, 0.03474379f, 0.04738984f, 0.14323512f, 0.18277730f, 0.03216086f, -0.06114421f, 
    -0.02400961f, 0.15466827f, 0.00064188f, 0.39619064f, -0.05704337f, -0.03536142f, 0.10570111f, 0.15336412f, 
    0.10739381f, -0.11533184f, 0.11777739f, 0.21881689f, -0.24006061f, 0.01204479f, 0.42705652f, -0.08041116f, 
    -0.39029717f, 0.20128632f, 0.07339845f, 0.26523951f, 0.08094878f, -0.15551330f, 0.10705967f, 0.05736389f, 
    -0.10685208f, 0.13041821f, 0.12223047f, -0.20687383f, -0.05467929f, 0.08088063f, 0.07201395f, -0.04886020f, 
    -0.18473923f, 0.04941799f, 0.26650158f, 0.19593628f, -0.06062890f, -0.14384760f, -0.10292374f, 0.14707449f, 
    0.26889405f, -0.15483049f, -0.23217003f, -0.04478936f, -0.10085531f, 0.10576244f, 0.11709068f, -0.12552570f, 
    -0.13612428f, 0.04992961f, -0.02518876f, 0.07351959f, 0.19464393f, 0.10929068f, -0.11767581f, -0.25074404f, 
    -0.03521073f, -0.01354391f, 0.07868002f, 0.23945695f, -0.01632134f, -0.07225697f, -0.18268712f, 0.05715184f, 
    -0.05277275f, -0.05492796f, -0.00701511f, -0.02487352f, 0.07292362f, -0.02335594f, -0.07911739f, -0.10851370f, 
    -0.10997064f, -0.05086921f, -0.01063962f, 0.22047932f, 0.29820436f, 0.14719844f, 0.07149154f, -0.00905776f, 
    0.15844105f, -0.08003680f, 0.02514431f, 0.40532649f, 0.09868579f, -0.00501280f, 0.07388788f, 0.22768368f, 
    0.18752770f, -0.17073220f, -0.13084471f, 0.19342677f, 0.02136795f, -0.10410769f, -0.05343960f, 0.15631275f, 
    -0.04537335f, -0.24519920f, 0.46506557f, 0.31539136f, 0.07104629f, 0.01928525f, 0.09590045f, -0.13473901f, 
    -0.17892501f, 0.03585356f, 0.21486828f, 0.10701524f, 0.23415637f, 0.26110294f, -0.16096820f, -0.04948081f, 
    -0.21464561f, 0.33954352f, 0.16946387f, -0.03797080f, -0.26707977f, -0.04468342f, -0.14877796f, -0.00182682f, 
    -0.00867698f, 0.21514699f, -0.05565190f, -0.03089099f, 0.03794095f, -0.32109734f, -0.04387240f, 0.13377270f, 
    -0.29449725f, 0.02681424f, 0.26841977f, 0.09423216f, -0.01293169f, -0.14966840f, 0.02092644f, -0.09779723f, 
    -0.05373177f, -0.31885543f, -0.37083128f, -0.19844334f, 0.11619423f, -0.06441663f, 0.07417736f, -0.41744018f, 
    -0.39814356f, 0.14447422f, 0.01178593f, 0.14072467f, 0.07443995f, 0.11084028f, 0.06713879f, -0.06755802f, 
    -0.27114210f, 0.15279074f, -0.20715123f, 0.18373337f, 0.10405181f, -0.08212354f, 0.20441727f, 0.11375411f, 
    0.39752638f, -0.09738367f, -0.07947609f, 0.05593911f, 0.07211760f, 0.32812530f, 0.15655421f, 0.30257550f, 
    -0.48652077f, 0.09689260f, -0.01447140f, 0.05011771f, 0.17718349f, 0.12362318f, 0.17810078f, -0.03628810f, 
    -0.00030765f, 0.03941609f, 0.03606224f, -0.05332045f, -0.08596409f, -0.30001512f, -0.01755477f, 0.29915670f, 
    -0.12060907f, 0.16631676f, -0.09832667f, -0.27694872f, 0.11167049f, 0.00137472f, 0.00836574f, -0.07742766f, 
    -0.03280369f, 0.08467120f, -0.21871629f, -0.42852670f, 0.20491748f, -0.04102378f, 0.02669437f, -0.13247323f, 
    0.26955867f, 0.02249872f, -0.03513159f, -0.10048856f, -0.06089868f, -0.23400912f, 0.30155340f, 0.07453156f, 
    -0.04076665f, 0.22469816f, -0.02159536f, 0.05011974f, 0.11797829f, -0.08655076f, 0.10885315f, -0.04140771f, 
    0.09075240f, 0.08753265f, 0.20594361f, -0.10722491f, 0.01212992f, 0.05431485f, 0.09570017f, -0.02007376f, 
    0.07989503f, 0.17514661f, -0.23344460f, -0.06474914f, 0.16021404f, -0.06514411f, 0.08055845f, 0.21602796f, 
    -0.38579968f, -0.22776948f, 0.15893300f, 0.21273389f, 0.05412321f, -0.00772275f, -0.19846350f, -0.07862847f, 
    -0.53761727f, 0.61281216f, -0.00091752f, -0.17412044f, -0.20764263f, 0.03176210f, 0.28295338f, 0.10494480f, 
    -0.46325633f, 0.07100773f, -0.03625334f, -0.09950678f, 0.20929967f, -0.05157558f, 0.06519389f, -0.02669384f, 
    0.04334116f, 0.03288279f, 0.25185588f, 0.19435404f, -0.00301425f, -0.33262140f, 0.18576923f, 0.03791136f, 
    0.01891076f, -0.14772756f, -0.28624779f, -0.01054721f, 0.14438546f, -0.09511812f, 0.10569324f, -0.46426138f, 
    -0.38140744f, 0.55434501f, 0.06744173f, 0.09923874f, 0.20212798f, -0.21576710f, 0.02418702f, 0.00735028f, 
    -0.32025328f, 0.16274977f, -0.14806092f, -0.06526220f, -0.01918074f, 0.29459468f, 0.26762861f, 0.10246555f, 
    0.11441902f, 0.01174152f, 0.05733086f, 0.13864242f, 0.24169010f, 0.04628026f, 0.29088053f, 0.22444470f, 
    -0.24709256f, -0.18163210f, 0.05560464f, -0.01839260f, 0.11151256f, 0.04325337f, -0.02555584f, -0.11797971f, 
    0.03779758f, 0.05309409f, 0.07362696f, 0.00926628f, -0.13755946f, 0.01892637f, -0.20133418f, -0.02306855f, 
    0.22359453f, -0.09255827f, 0.08584081f, -0.12342276f, -0.01850668f, 0.05951092f, 0.29124835f, 0.00336714f, 
    0.06501061f, -0.16322753f, -0.14456832f, -0.47564113f, -0.06753242f, -0.30870250f, -0.05776841f, -0.34628338f, 
    0.17535043f, -0.00243530f, -0.04219481f, -0.09671962f, -0.02942157f, -0.25107613f, -0.21178092f, -0.00318076f, 
    -0.22391430f, 0.12013733f, -0.09855869f, 0.21611305f, 0.04909973f, -0.14629696f, -0.08132782f, -0.24186204f, 
    -0.04131477f, -0.12933037f, 0.11228046f, -0.29733595f, -0.10235963f, 0.04728796f, 0.09480236f, 0.04886457f, 
    -0.08710373f, -0.12303542f, -0.06068288f, 0.08825969f, 0.03154532f, 0.10134196f, 0.07532623f, 0.12919453f, 
    -0.01557440f, -0.06082346f, -0.07870544f, -0.06441727f, -0.04497705f, -0.11415402f, -0.01438844f, -0.06455651f, 
    0.03446444f, -0.06636904f, 0.02361041f, -0.00117560f, 0.03804309f, -0.08077547f, 0.05513419f, 0.01383961f, 
    -0.03299293f, -0.04872420f, 0.08403211f, -0.05083764f, -0.00508110f, 0.05820910f, -0.07275906f, -0.04709557f, 
    -0.10669514f, -0.06356916f, 0.00788993f, 0.03937653f, 0.07959973f, -0.02455700f, -0.11128328f, 0.04082920f, 
    0.00736141f, 0.07190343f, -0.08802721f, -0.07337619f, 0.00768864f, -0.04161195f, -0.03925788f, 0.06327288f, 
    -0.01370505f, -0.04090870f, 0.04346978f, 0.01038219f, 0.04862656f, -0.07627010f, -0.07484632f, -0.05726562f, 
    -0.09913324f, -0.08252621f, -0.08399315f, 0.07453485f, -0.01977722f, -0.04446885f, 0.04075744f, -0.09781415f, 
    -0.08869539f, 0.00415920f, -0.04063321f, -0.01408679f, -0.04869574f, -0.07663958f, 0.01236001f, 0.05826747f, 
    0.03855050f, -0.07698386f, 0.06185073f, 0.08042101f, 0.01073343f, 0.02187007f, 0.07394049f, -0.09260451f, 
    -0.06617980f, -0.08473585f, 0.01606369f, -0.09753805f, 0.03149708f, -0.02751858f, 0.00452780f, 0.04008026f, 
    -0.11213566f, 0.05846934f, -0.09978081f, -0.07587071f, -0.02742883f, 0.03455361f, -0.02023326f, -0.01826895f, 
    -0.06011239f, -0.01994091f, 0.07627364f, 0.02218800f, 0.06132023f, -0.10349581f, 0.03587988f, -0.01388079f, 
    0.01689404f, 0.02110014f, -0.10387050f, -0.09393638f, 0.01912094f, 0.02705196f, 0.04807495f, -0.06565747f, 
    -0.09331251f, 0.04440418f, -0.04556107f, 0.03162284f, 0.02295426f, -0.02411330f, 0.04466866f, 0.00938893f, 
    -0.04667459f, 0.03635917f, 0.05900218f, -0.04635313f, -0.02327857f, -0.07743172f, 0.04173764f, 0.05012498f, 
    0.06584754f, -0.08619070f, -0.10258067f, 0.01757659f, -0.02721707f, -0.08227824f, -0.09210430f, -0.04095594f, 
    -0.22350702f, -0.26963139f, -0.00966665f, 0.25065252f, -0.00241453f, -0.12135383f, -0.35240984f, -0.22810501f, 
    0.18533495f, 0.37714574f, 0.15433601f, -0.19011195f, 0.11752544f, 0.08378902f, 0.35200936f, -0.41450295f, 
    -0.09207536f, -0.19408464f, -0.17236459f, -0.08986033f, 0.11590429f, 0.15327391f, -0.04047938f, -0.11757907f, 
    0.09138489f, 0.07236844f, 0.14194700f, 0.05556622f, 0.02996230f, 0.16220722f, 0.31534755f, 0.10968149f, 
    0.07003747f, -0.04719490f, 0.01024300f, 0.01389969f, -0.09691571f, 0.01183087f, 0.15835775f, 0.28722399f, 
    0.15373780f, 0.27627507f, 0.13161376f, 0.00208206f, 0.09085593f, -0.07742291f, 0.10198307f, -0.01613715f, 
    -0.02792067f, 0.39848465f, 0.19822600f, 0.25097010f, 0.04411720f, 0.11657827f, 0.18018222f, 0.14140166f, 
    -0.00188630f, 0.03376899f, 0.35858345f, 0.05895960f, -0.11058464f, 0.06564788f, 0.34131914f, 0.26322591f, 
    0.16093621f, -0.07815087f, 0.04399193f, 0.00220965f, -0.30346373f, 0.22597320f, 0.10624512f, -0.14852676f, 
    0.22975421f, 0.14801784f, -0.01991120f, -0.09437282f, -0.00049933f, -0.32274735f, -0.14877181f, -0.07323729f, 
    0.17730559f, -0.02112151f, 0.14795361f, -0.50459659f, -0.00815034f, 0.07968503f, -0.09761535f, -0.08118621f, 
    -0.09397640f, -0.06016588f, -0.30442086f, -0.21273796f, -0.12027065f, -0.08497991f, 0.07652555f, -0.26934773f, 
    -0.01911978f, -0.02502739f, 0.12036856f, 0.28450567f, 0.09049414f, 0.14679530f, -0.05237631f, -0.07052352f, 
    -0.19913542f, -0.05722067f, 0.05898374f, 0.27055240f, -0.25202936f, -0.27306220f, -0.14372529f, 0.11004831f, 
    -0.27133954f, -0.06161951f, -0.02082524f, -0.13608074f, -0.04542492f, -0.00879203f, 0.14073713f, 0.01864425f, 
    -0.12602039f, -0.06534836f, 0.04754137f, 0.16252679f, 0.28857610f, 0.12452099f, 0.17687635f, -0.32209951f, 
    -0.24256180f, -0.05525718f, 0.25427550f, 0.12297247f, 0.06110130f, -0.02504649f, -0.28695756f, 0.22229652f, 
    -0.33053163f, 0.14143510f, 0.16210510f, 0.12934627f, -0.13316110f, 0.03601559f, -0.07195535f, 0.18028569f, 
    -0.26833501f, 0.25963947f, -0.01632255f, 0.02823101f, 0.07170837f, -0.06882191f, 0.01731212f, -0.09442831f, 
    -0.35275128f, -0.01407286f, 0.06320213f, -0.00676963f, -0.10233083f, -0.26774171f, -0.15980187f, 0.09066993f, 
    -0.11725701f, -0.11319160f, -0.11414171f, -0.06060669f, -0.06203759f, -0.28098997f, -0.03301191f, -0.31047052f, 
    -0.27155167f, 0.01742288f, 0.08727217f, 0.15437561f, -0.00629142f, 0.03719031f, -0.04020982f, -0.09617621f, 
    -0.05106364f, -0.02081347f, -0.08059521f, -0.22583365f, -0.00425445f, 0.10209166f, 0.02158464f, -0.02661931f, 
    0.06531123f, 0.00508205f, 0.04125001f, -0.11838312f, 0.13677821f, -0.06447195f, -0.08226051f, 0.03230165f, 
    -0.29650623f, 0.09179406f, -0.00814883f, 0.08061849f, 0.23189358f, -0.01760529f, -0.01986856f, -0.01635202f, 
    -0.00038535f, -0.07593209f, 0.26599506f, -0.09220645f, 0.14563420f, 0.05400089f, 0.01123273f, 0.08960205f, 
    -0.13264994f, 0.06900199f, -0.06704994f, -0.00877187f, -0.07068060f, -0.00301091f, 0.06949922f, 0.00789982f, 
    -0.03390024f, 0.08139507f, -0.24799214f, -0.37378907f, 0.07428164f, 0.03362958f, 0.07312789f, 0.18497962f, 
    0.05755386f, -0.03910847f, -0.03557577f, -0.01803875f, 0.08253735f, -0.16703600f, 0.35003629f, 0.11831782f, 
    0.01604772f, 0.12919466f, -0.10773303f, 0.04787258f, 0.10309496f, -0.08400350f, -0.13117453f, -0.21756499f, 
    -0.15662111f, 0.15644638f, 0.19462058f, -0.10031489f, 0.01142091f, -0.06169514f, 0.03949029f, 0.05187134f, 
    0.09965611f, 0.04967720f, 0.01184311f, -0.00498103f, -0.22497371f, 0.04566814f, 0.05059902f, 0.16813046f, 
    0.08787479f, -0.01082414f, -0.00645115f, 0.03472555f, 0.00899180f, -0.05681413f, 0.01037921f, 0.02302348f, 
    -0.00198561f, 0.00144270f, 0.02200736f, -0.05764622f, -0.03600950f, -0.01994840f, -0.04919029f, -0.01204630f, 
    0.03880717f, 0.05363934f, 0.01376372f, -0.08304183f, -0.00986139f, 0.00366427f, -0.02377057f, -0.00384922f, 
    -0.05279135f, -0.06184586f, 0.05448925f, 0.00482898f, 0.08152093f, -0.09609991f, -0.09195967f, -0.07189401f, 
    -0.09488506f, -0.04429320f, 0.02228224f, 0.06555270f, -0.06443349f, -0.04204177f, 0.02726559f, -0.01479765f, 
    -0.01900902f, -0.08400135f, -0.02975647f, 0.05113691f, -0.06435968f, 0.06486151f, -0.01991555f, -0.05169813f, 
    0.05263788f, 0.07898869f, -0.03036952f, 0.07829679f, -0.04838393f, -0.04602584f, -0.04993163f, -0.10552920f, 
    -0.00450826f, -0.04626208f, -0.01883974f, 0.05887563f, 0.00402163f, -0.06304190f, -0.06708608f, 0.04138591f, 
    -0.01079642f, 0.04348952f, -0.05643446f, -0.07956332f, 0.06894352f, -0.08931449f, -0.01221944f, -0.04736764f, 
    -0.05686844f, -0.02610886f, -0.04952953f, -0.07758369f, -0.03057598f, -0.01923734f, 0.06845276f, -0.07827022f, 
    0.03046397f, -0.08012377f, -0.10141031f, -0.00701632f, 0.03982994f, 0.06978542f, -0.09643163f, 0.06321988f, 
    0.05401617f, 0.00647569f, 0.03339038f, -0.06107659f, 0.02659249f, -0.08077655f, -0.08674373f, -0.07527229f, 
    -0.03679825f, 0.06937902f, -0.07065996f, -0.05772695f, -0.02105576f, -0.00037731f, 0.06802849f, -0.01152748f, 
    0.02419112f, -0.03657922f, -0.00802967f, -0.05193460f, -0.05495591f, -0.00600772f, 0.04399523f, -0.08593126f, 
    -0.10274421f, 0.04283049f, -0.05133926f, 0.00280185f, 0.03646808f, 0.04584947f, -0.05561386f, -0.06945384f, 
    -0.06641364f, -0.08728646f, -0.08373023f, 0.01472012f, -0.10204592f, -0.03675950f, -0.05263950f, -0.08252029f, 
    -0.39369616f, -0.06472789f, -0.06221194f, -0.10328228f, -0.15020873f, -0.03198433f, -0.46580404f, 0.13330217f, 
    0.33032393f, 0.02264895f, -0.07790341f, 0.12090869f, 0.18966642f, -0.18956497f, -0.25476032f, 0.15130571f, 
    -0.03925763f, 0.25746959f, 0.10238187f, 0.01060183f, -0.09281052f, 0.12510104f, -0.05645528f, -0.06273806f, 
    0.03925024f, 0.17322677f, 0.13811375f, -0.05287406f, -0.17442632f, -0.16405880f, -0.19943307f, 0.09393175f, 
    -0.09413899f, 0.17007494f, 0.34914294f, -0.12908007f, 0.21766576f, -0.07927721f, -0.03496868f, 0.16017747f, 
    0.24307595f, 0.07715859f, -0.04862338f, 0.29898930f, 0.01677467f, 0.04593497f, -0.19701645f, -0.09423511f, 
    -0.02805386f, -0.09377579f, 0.03434534f, -0.16989943f, 0.07913937f, 0.09614262f, 0.07612165f, 0.01720471f, 
    -0.06146100f, -0.21503979f, -0.10722277f, -0.00005423f, -0.04983708f, -0.40712607f, -0.16494820f, -0.14802183f, 
    0.31259951f, 0.14306106f, 0.07504989f, -0.02267758f, 0.12221336f, -0.19292480f, 0.12981269f, -0.42905623f, 
    -0.20338617f, 0.06407920f, 0.17768998f, 0.08291181f, 0.23476619f, 0.21676309f, 0.14763418f, -0.07110666f, 
    -0.01599759f, 0.14748801f, -0.08957194f, 0.31450120f, 0.04945501f, 0.02053727f, 0.10635173f, 0.18103684f, 
    0.07273310f, -0.17551289f, -0.68445396f, 0.28205842f, -0.09033930f, -0.08075624f, 0.04300600f, -0.47322491f, 
    -0.07080324f, -0.02655390f, -0.25445214f, -0.04458179f, 0.17287749f, -0.20752989f, 0.21079142f, -0.03830981f, 
    0.10410085f, -0.08947838f, 0.05399932f, 0.22102132f, 0.22063756f, 0.10413159f, -0.09776799f, 0.06736168f, 
    0.05237431f, -0.27261120f, 0.08067997f, -0.06182905f, -0.08346822f, -0.00656667f, -0.21773107f, 0.15138468f, 
    -0.15159138f, -0.12783940f, 0.34677750f, -0.01886835f, 0.04335757f, 0.01581189f, 0.10165711f, 0.15675028f, 
    0.23752421f, 0.04083559f, 0.17706622f, 0.11666367f, 0.17646514f, 0.15175104f, -0.10828134f, 0.27203244f, 
    0.23398915f, -0.09790352f, 0.00625632f, -0.10695720f, -0.08497868f, -0.04309748f, 0.02424155f, 0.23683751f, 
    0.09090700f, 0.12629153f, -0.28412175f, -0.43124393f, 0.02605097f, -0.08649945f, 0.06046538f, 0.49142128f, 
    -0.14152455f, -0.01516467f, 0.23737754f, 0.12473705f, 0.06014378f, -0.13596012f, 0.14398901f, 0.02203559f, 
    -0.01968868f, -0.07847136f, -0.32190472f, 0.01438768f, 0.23003569f, 0.30141082f, 0.03352802f, -0.20473216f, 
    0.10734738f, -0.35533881f, 0.18702786f, 0.13558061f, 0.23821357f, 0.08058330f, -0.26486644f, -0.05522347f, 
    0.07033026f, -0.09366636f, -0.16721523f, 0.47483113f, -0.08394575f, 0.05372099f, 0.07208734f, 0.05791303f, 
    0.05563363f, 0.06105305f, -0.14705741f, -0.14354017f, 0.11684681f, 0.11618693f, 0.19666424f, 0.09584507f, 
    -0.28755450f, 0.14213873f, -0.08109648f, 0.15138520f, 0.52176625f, -0.04646306f, -0.00306634f, 0.03897786f, 
    0.29997644f, -0.07397016f, 0.00447475f, 0.04967253f, -0.19461262f, 0.27483696f, 0.07076848f, 0.21538596f, 
    0.12150732f, 0.04204600f, 0.09256650f, 0.16037196f, -0.03082272f, -0.02642275f, 0.34439659f, 0.20522596f, 
    -0.01413390f, -0.07033046f, 0.13407604f, -0.08812132f, 0.26526099f, -0.08330057f, -0.00160926f, -0.15506364f, 
    0.08330384f, 0.06002691f, -0.02605577f, -0.20364240f, -0.15824185f, -0.39937094f, 0.33979595f, 0.11912905f, 
    -0.17850360f, 0.28049439f, 0.01991797f, -0.09226638f, 0.11960732f, 0.12077349f, 0.25469247f, -0.06281132f, 
    0.19341670f, -0.04344458f, 0.11941440f, -0.04843251f, 0.14471260f, 0.16258818f, -0.03819040f, -0.07614231f, 
    -0.04709350f, 0.10309938f, -0.05666750f, -0.03041170f, 0.09252496f, 0.11196536f, -0.08791533f, 0.51085919f, 
    -0.12602426f, -0.25877851f, 0.14111190f, 0.34765932f, -0.02520682f, -0.03236871f, -0.28612229f, -0.03612313f, 
    0.10699338f, 0.11815149f, -0.01152744f, 0.07142039f, -0.05104790f, 0.07583097f, 0.15603973f, 0.26614329f, 
    -0.48598182f, 0.13834958f, -0.14211489f, 0.01625161f, 0.22873515f, 0.02102431f, 0.04007669f, -0.13887951f, 
    0.14695892f, 0.12225022f, 0.20425318f, 0.15628006f, -0.07334553f, -0.29995650f, 0.17311427f, 0.17752141f, 
    -0.02563335f, -0.11372913f, -0.23491667f, 0.02106161f, 0.10025027f, -0.21174118f, 0.27213192f, -0.14946409f, 
    0.14112386f, 0.33600137f, 0.06206607f, 0.16689560f, 0.21911088f, -0.29974407f, -0.01793060f, 0.03633621f, 
    -0.15484026f, 0.08787925f, 0.00458886f, 0.01979146f, 0.07937854f, 0.32677934f, 0.30622697f, -0.04973375f, 
    -0.00769266f, -0.07498119f, 0.19614424f, 0.16978607f, 0.17957722f, -0.02326539f, 0.21996540f, 0.09330063f, 
    -0.09565096f, -0.31264901f, -0.19750333f, 0.10048039f, 0.10033102f, -0.06030296f, 0.07427333f, -0.15018375f, 
    0.11179406f, 0.03035911f, 0.14092910f, 0.03951937f, 0.18644646f, -0.01621341f, -0.21395414f, -0.11188687f, 
    0.23672272f, -0.02490160f, 0.19702534f, -0.05401012f, 0.01419787f, -0.03988350f, 0.26361954f, 0.13655630f, 
    -0.00325677f, -0.09451683f, -0.32029203f, -0.18455936f, -0.04454589f, -0.23691240f, -0.02005018f, -0.25928041f, 
    0.02783117f, 0.05825743f, -0.12556686f, 0.04861568f, 0.12685704f, -0.08299435f, 0.22983269f, -0.05540395f, 
    -0.04224043f, 0.30914971f, -0.05017770f, 0.30998099f, 0.16966973f, -0.14051607f, -0.12159602f, -0.10928856f, 
    -0.08174703f, -0.08518176f, 0.09735041f, -0.18400952f, -0.06291679f, -0.02029679f, 0.15874763f, 0.14518499f, 
    -0.13601482f, -0.06535190f, 0.15299778f, 0.26154584f, 0.07976617f, 0.03009069f, 0.31600034f, 0.13921073f, 
    -0.01995323f, -0.03160210f, -0.03231050f, -0.04967260f, -0.01073790f, -0.00445637f, 0.01168984f, -0.01603018f, 
    0.03459742f, 0.00176404f, -0.05274380f, 0.01249366f, 0.06702701f, -0.04474651f, 0.07952131f, -0.00951497f, 
    -0.02486127f, 0.09406126f, 0.01309415f, 0.03797921f, -0.02273640f, -0.08190729f, -0.03331260f, -0.02660439f, 
    -0.07591703f, -0.07954488f, 0.02983208f, -0.07646448f, -0.09303033f, 0.06388775f, -0.07827567f, -0.08881186f, 
    -0.00928086f, -0.07976213f, -0.08412859f, -0.04459909f, -0.02926728f, 0.03587355f, 0.07544231f, -0.03942116f, 
    -0.03027837f, 0.05706388f, 0.00691873f, 0.03080401f, 0.04372903f, -0.04173904f, 0.06707159f, 0.00076766f, 
    -0.03802473f, -0.03764119f, -0.03250724f, -0.00232039f, 0.02529246f, -0.08727928f, -0.05623994f, 0.06490880f, 
    -0.09885587f, -0.08391514f, 0.04111151f, -0.08280915f, 0.07551714f, -0.05310347f, -0.03054227f, 0.04342632f, 
    -0.08455241f, 0.01930651f, 0.02073813f, -0.02752554f, -0.00599726f, -0.07253686f, 0.04291408f, 0.07061902f, 
    -0.07278334f, -0.03056148f, -0.02574904f, 0.02511187f, -0.06541800f, 0.01653576f, 0.00532334f, 0.04443787f, 
    0.03885993f, 0.04018359f, -0.04981693f, -0.05674834f, 0.02517564f, -0.05865036f, 0.06473833f, 0.00632114f, 
    0.04755178f, -0.05152971f, 0.00511525f, 0.00988501f, 0.03646607f, -0.04830561f, -0.01800811f, -0.06721603f, 
    0.01062099f, -0.08753656f, -0.06654704f, -0.03221965f, 0.04118088f, -0.05443002f, -0.08485493f, 0.04293566f, 
    0.03262825f, -0.01946874f, -0.04766645f, 0.03580959f, -0.08564056f, -0.09325539f, -0.06993514f, 0.04296767f, 
    -0.09238807f, -0.08961572f, -0.06777275f, 0.02804031f, 0.07632879f, 0.07435519f, -0.02820656f, -0.05869864f, 
    0.07523252f, 0.06877760f, 0.05005299f, -0.01468265f, -0.02638088f, -0.06715813f, -0.01506983f, 0.07053170f, 
    0.03922481f, 0.06344879f, -0.09130263f, 0.07649571f, -0.03715430f, 0.02210266f, -0.06020238f, 0.01896435f, 
    0.06855609f, 0.03582658f, 0.00923494f, -0.06097719f, -0.07320356f, -0.03350160f, -0.08031191f, 0.01661405f, 
    0.00099754f, -0.00369425f, -0.02780665f, -0.01581478f, -0.05462230f, 0.01464149f, 0.02994138f, -0.00183040f, 
    -0.07260808f, -0.07588937f, -0.04387109f, -0.06046505f, 0.00948245f, -0.01815718f, 0.00540592f, 0.00359206f, 
    -0.03413520f, 0.03913084f, 0.02928004f, -0.05020941f, 0.06122078f, -0.02629853f, 0.03985926f, -0.05799345f, 
    0.04457204f, -0.02511883f, -0.08011101f, -0.00311189f, -0.04886105f, -0.07456189f, -0.04545693f, 0.05899898f, 
    0.06372358f, -0.05497409f, -0.00657369f, 0.07058082f, 0.08723602f, -0.05951716f, 0.03698359f, 0.00571952f, 
    -0.01895400f, 0.03792947f, 0.04815200f, 0.01897961f, 0.02824310f, 0.03597911f, -0.03814081f, -0.07182785f, 
    -0.00107830f, 0.00413112f, -0.01991451f, -0.01175138f, -0.06570371f, -0.06552146f, 0.06339952f, -0.00823104f, 
    0.06360382f, 0.01490493f, -0.01411645f, 0.02457105f, -0.03472520f, -0.00897664f, -0.05606817f, 0.06768981f, 
    -0.07098065f, -0.10549994f, 0.01997741f, -0.07103941f, 0.03695628f, 0.05471432f, -0.04116386f, -0.00136384f, 
    -0.03730274f, -0.02048417f, -0.02292839f, -0.06622953f, 0.00723884f, 0.00320233f, -0.01369256f, 0.04944327f, 
    0.05780318f, 0.04678313f, -0.08677322f, -0.03881164f, 0.02338243f, -0.04512036f, -0.04951693f, -0.00073355f, 
    0.01470755f, -0.00597566f, -0.01391826f, 0.03584822f, -0.05505982f, -0.10597900f, 0.01489407f, -0.03754862f, 
    -0.05048502f, -0.00675276f, -0.08746284f, 0.00558489f, 0.05680599f, -0.02879856f, 0.05355212f, -0.07852086f, 
    -0.06174607f, -0.01993832f, -0.06911951f, -0.10041074f, 0.07757801f, -0.09288442f, 0.05454514f, -0.04240793f, 
    -0.02567249f, 0.06155003f, 0.04321541f, -0.07862542f, 0.03030299f, -0.04336662f, -0.09472254f, -0.05672902f, 
    0.06885605f, 0.01130503f, -0.08047737f, -0.08686204f, 0.01379075f, -0.06018143f, 0.00934893f, -0.00994431f, 
    -0.05551058f, 0.01288918f, 0.05781202f, -0.00151903f, -0.02437609f, -0.05762111f, 0.04032644f, -0.02967820f, 
    -0.00882920f, 0.01637335f, 0.00034145f, -0.10364326f, -0.00013651f, -0.10615867f, 0.05085978f, -0.12087294f, 
    -0.07110956f, -0.06827333f, -0.00872969f, -0.03813179f, -0.13172036f, 0.00691983f, -0.09595133f, -0.08631986f, 
    -0.05687086f, -0.09152944f, -0.10298948f, -0.09161865f, -0.09743758f, 0.03782890f, 0.02008243f, 0.01545652f, 
    0.02710972f, -0.08316737f, 0.04997866f, -0.07591231f, 0.05221031f, -0.02839788f, 0.00182486f, -0.05909523f, 
    0.01607947f, 0.00816204f, -0.11480402f, 0.05611319f, 0.06095418f, 0.04674966f, 0.01467158f, -0.06876665f, 
    -0.09473258f, -0.10133928f, -0.00864659f, 0.01111620f, -0.11107445f, -0.10131926f, 0.03684830f, -0.07271986f, 
    -0.11488636f, -0.09306156f, 0.02811085f, -0.10102262f, 0.03822702f, -0.07197980f, -0.00220370f, -0.02515579f, 
    -0.05252963f, 0.03116891f, -0.09379781f, -0.00250396f, 0.03652572f, -0.05519417f, -0.11112504f, -0.00808464f, 
    0.07823871f, -0.02546605f, -0.01808912f, -0.10837658f, -0.00526651f, -0.05697104f, 0.01833794f, -0.07118627f, 
    0.03525900f, -0.03993014f, 0.05369764f, -0.04721703f, -0.11516408f, -0.03332012f, -0.03673094f, -0.04475622f, 
    -0.04347598f, -0.04674594f, 0.07806081f, -0.01022726f, -0.12519924f, -0.04982224f, 0.01760767f, -0.02582994f, 
    0.03136342f, -0.02387100f, -0.12699322f, -0.07090323f, -0.01078388f, 0.01645512f, -0.04211763f, -0.03592543f, 
    -0.01142874f, 0.02614091f, -0.04855571f, -0.04110514f, 0.04453781f, -0.07473537f, -0.01426798f, 0.00812464f, 
    -0.31074813f, 0.04184159f, 0.22069061f, -0.01094315f, 0.39103523f, 0.05203993f, 0.08542497f, 0.58190799f, 
    -0.13915724f, 0.21606283f, 0.09147786f, 0.02258393f, -0.31338003f, -0.18200365f, -0.06972019f, -0.01076476f, 
    -0.04272340f, -0.09922879f, 0.03267358f, -0.08684675f, 0.10181510f, 0.02489060f, -0.04538997f, 0.03807945f, 
    -0.20604602f, -0.58968055f, 0.11061448f, 0.02670821f, 0.17480667f, -0.13423906f, -0.04291857f, -0.05780946f, 
    0.28341132f, -0.06973267f, -0.17604145f, 0.19430159f, -0.31100801f, 0.05902248f, -0.03133477f, -0.21169643f, 
    0.03956529f, -0.58282959f, 0.10910976f, -0.11141516f, 0.12857677f, 0.04923138f, -0.03511678f, -0.04144269f, 
    0.17693435f, -0.17108108f, -0.21203680f, 0.06622984f, -0.03158287f, -0.13984637f, -0.02266560f, -0.21787080f, 
    -0.03200351f, 0.07929612f, -0.07524102f, -0.18576299f, -0.21633732f, 0.25593448f, 0.26914817f, -0.23834594f, 
    -0.10001221f, 0.11254886f, -0.37316501f, 0.00531576f, 0.01099775f, -0.03405847f, 0.15061398f, 0.24282564f, 
    0.22651017f, 0.37645209f, 0.21576612f, 0.10471942f, -0.28294343f, 0.12077142f, 0.25334939f, 0.08808640f, 
    0.05356968f, -0.02845659f, 0.07661577f, -0.17318270f, 0.06480778f, 0.01900480f, 0.03054204f, 0.11212108f, 
    -0.02959930f, 0.09588829f, 0.04929672f, -0.04103316f, 0.00587620f, -0.04737816f, -0.03319719f, 0.13562091f, 
    -0.23322918f, 0.06327601f, -0.24740298f, -0.03103160f, 0.10226376f, -0.25421846f, 0.42799661f, 0.08765730f, 
    -0.45210084f, 0.14502683f, 0.16881974f, 0.09370492f, -0.02877658f, 0.02652900f, 0.17941651f, 0.19631857f, 
    0.12764823f, 0.32134828f, -0.09638067f, -0.29108897f, 0.11802310f, -0.03372505f, 0.00616607f, 0.11858337f, 
    0.01862366f, -0.13882422f, 0.10793930f, -0.00955565f, 0.05960993f, 0.07878089f, -0.38199443f, -0.20082338f, 
    -0.02850734f, -0.03761554f, -0.03101527f, -0.07420336f, -0.04234207f, -0.08322419f, -0.08273774f, 0.04898121f, 
    0.02103463f, -0.06359953f, -0.07779346f, 0.05553630f, 0.02740157f, 0.00076565f, 0.00883278f, 0.05952861f, 
    0.01878557f, 0.02085739f, -0.01349632f, -0.01416997f, -0.06710604f, 0.06869917f, -0.03662421f, 0.02812429f, 
    -0.09611542f, -0.04175197f, -0.05859684f, 0.00149256f, 0.06029757f, -0.05983105f, -0.06316115f, -0.05349568f, 
    0.04115611f, -0.08552378f, -0.05233290f, -0.08856660f, -0.03991204f, 0.02133961f, 0.02278784f, 0.00529793f, 
    -0.02387111f, -0.09729679f, -0.08027579f, 0.04195134f, -0.07163548f, 0.02815679f, -0.05557980f, -0.04716544f, 
    0.04459371f, 0.00159353f, 0.00431208f, 0.03325718f, 0.04739524f, -0.04098615f, 0.00413727f, -0.04803345f, 
    -0.06896996f, 0.05326266f, -0.06158682f, 0.05333130f, -0.04564136f, -0.10444032f, -0.02877457f, 0.08162765f, 
    -0.10184568f, -0.01551388f, 0.03343183f, 0.04187734f, 0.03309871f, 0.05675281f, 0.07978247f, 0.05797093f, 
    0.06915566f, -0.04776719f, 0.00595309f, 0.04247925f, -0.01120953f, -0.03171072f, 0.01724642f, -0.02923217f, 
    0.04848452f, 0.02404555f, -0.06659441f, -0.08408062f, 0.05181098f, -0.03219730f, -0.06205991f, 0.05721675f, 
    0.00955890f, -0.07242911f, 0.00460058f, 0.03189329f, -0.09961611f, -0.10481823f, -0.04437831f, -0.04686362f, 
    0.03578446f, -0.03963555f, -0.06885023f, 0.00459167f, -0.03108147f, -0.08240210f, -0.06134259f, -0.07310397f, 
    0.04706662f, -0.06238279f, -0.08073796f, -0.03193363f, 0.05326888f, 0.02157386f, 0.01687720f, -0.07371150f, 
    -0.05351295f, 0.04249561f, -0.07251299f, 0.04294881f, -0.05632904f, 0.08916252f, 0.03760684f, -0.00800083f, 
    -0.10015211f, -0.08639003f, -0.09298003f, 0.03183146f, 0.06605407f, -0.10144577f, 0.02701652f, 0.08246542f, 
    -0.20373569f, 0.02322470f, 0.13742010f, 0.01785100f, 0.13176419f, -0.02955326f, -0.14344081f, 0.14545247f, 
    -0.29937077f, 0.28452066f, 0.02270668f, -0.03259590f, 0.04020225f, 0.07387055f, 0.00667893f, 0.18160333f, 
    0.09772401f, 0.02943674f, -0.09326233f, -0.18526915f, -0.01761131f, -0.24118836f, 0.08305472f, 0.25413921f, 
    -0.29587743f, -0.02366252f, 0.03081772f, 0.08781456f, 0.02303159f, -0.02115062f, -0.05947782f, -0.04469609f, 
    0.23754887f, 0.08717658f, -0.17033847f, -0.16215578f, 0.19222803f, 0.19232024f, 0.10520379f, -0.36989382f, 
    -0.36221129f, 0.01208425f, 0.13377561f, 0.09876575f, -0.01467475f, 0.12422836f, -0.10279115f, -0.11129692f, 
    0.08324467f, -0.10523770f, -0.33652282f, 0.13302831f, 0.03062944f, -0.18502174f, -0.03697440f, 0.02565706f, 
    0.29621881f, 0.02969747f, 0.04559914f, -0.00642938f, 0.04915285f, 0.07502137f, 0.07564951f, 0.19017664f, 
    -0.30861899f, 0.08821786f, 0.05069877f, -0.01813512f, 0.20798670f, -0.01001673f, -0.02517868f, 0.13273220f, 
    -0.10817163f, 0.09929981f, 0.14593709f, 0.01253677f, -0.07068793f, 0.20561567f, -0.02329783f, 0.29419366f, 
    -0.10599066f, 0.06463368f, -0.11850757f, 0.08295032f, -0.03196913f, -0.02112950f, -0.09879484f, -0.13493262f, 
    0.02142487f, 0.22966571f, -0.04426457f, 0.07163748f, 0.11124111f, 0.05451486f, 0.00077488f, -0.04787610f, 
    0.20524922f, -0.06277355f, -0.05757078f, 0.02571036f, 0.10386642f, -0.17128170f, 0.20068634f, 0.06176669f, 
    0.13893221f, -0.01676790f, -0.00639758f, -0.06161914f, 0.02480557f, 0.04384334f, 0.19529167f, -0.04521231f, 
    0.10991073f, -0.02864509f, 0.10575688f, 0.07776599f, 0.07477992f, 0.16922288f, 0.02685899f, 0.00347114f, 
    0.08317792f, -0.02447454f, -0.14016639f, -0.03637652f, -0.11636650f, 0.14538635f, -0.10157780f, 0.02678352f, 
    -0.00634523f, -0.02486561f, -0.02813440f, 0.01121675f, 0.03870257f, 0.03035835f, 0.02973958f, -0.07634892f, 
    0.08436625f, 0.03089575f, 0.02002899f, -0.02375769f, -0.01219277f, 0.00246776f, 0.04006846f, -0.06106007f, 
    -0.09145048f, -0.14273699f, -0.06169181f, 0.02006857f, -0.05867500f, -0.03576106f, -0.05522380f, 0.02973912f, 
    -0.01727960f, -0.00546118f, -0.08102420f, 0.06311433f, 0.06119254f, -0.02475847f, 0.03124855f, 0.04746374f, 
    -0.06844996f, 0.05464653f, 0.00352827f, 0.00224231f, -0.03491022f, 0.02170116f, -0.07823104f, 0.06519131f, 
    -0.06765714f, 0.03253303f, 0.02633017f, 0.02260706f, -0.03985604f, 0.00130041f, -0.04142294f, -0.10137107f, 
    -0.00416627f, -0.07104260f, 0.01584087f, -0.05627618f, 0.04859659f, -0.01299518f, 0.03855978f, -0.02459974f, 
    0.05324351f, 0.00956322f, -0.03047629f, -0.03733024f, -0.00615121f, 0.03643636f, -0.10187815f, 0.03788562f, 
    0.04482613f, -0.05659322f, -0.05606104f, -0.01034590f, 0.02414066f, -0.02200103f, -0.00352348f, 0.02509155f, 
    -0.02366034f, -0.02006827f, -0.02480866f, -0.02324812f, 0.01253333f, -0.06677624f, -0.07935889f, -0.06824750f, 
    0.02108061f, -0.06108583f, 0.04641484f, -0.07833531f, -0.01264457f, -0.03611505f, -0.01403406f, -0.08085091f, 
    0.07902037f, -0.06322775f, -0.01440354f, -0.02822991f, -0.07937442f, -0.06983485f, -0.05096301f, -0.11835337f, 
    0.00988890f, -0.06457237f, 0.06561495f, 0.04547134f, -0.03672158f, -0.01880109f, -0.08437043f, -0.01212115f, 
    -0.07803622f, 0.01473153f, -0.06870487f, 0.04736621f, -0.07000284f, -0.07803059f, -0.03526130f, -0.06788060f, 
    -0.03347829f, 0.04992124f, 0.00852517f, 0.00080875f, -0.07544947f, -0.03317446f, -0.12177454f, -0.07533806f, 
    -0.10464436f, -0.10156313f, 0.00180823f, -0.08635265f, -0.06631990f, -0.09997055f, 0.01754917f, -0.05773674f, 
    -0.04826259f, -0.07201105f, 0.00013545f, -0.06160034f, -0.04595817f, -0.00402998f, -0.07492036f, -0.07986550f, 
    0.03763395f, 0.06922750f, 0.03809170f, 0.03220719f, 0.02108935f, -0.02664221f, -0.06450657f, -0.02405886f, 
    -0.07497210f, 0.05857494f, -0.05469158f, -0.00128664f, -0.06853735f, 0.03046602f, -0.03989650f, 0.03210824f, 
    -0.07895827f, -0.00548048f, -0.06673322f, 0.04605086f, -0.06541415f, -0.05863932f, -0.01810613f, -0.04089819f, 
    -0.10148137f, -0.06024151f, 0.06317592f, -0.04182589f, -0.02557463f, 0.01227848f, 0.06569964f, 0.06247443f, 
    0.06009750f, 0.01823037f, 0.00414335f, 0.02027238f, -0.10199926f, -0.06903213f, 0.01692763f, -0.04249481f, 
    0.04443702f, -0.07831329f, 0.00501870f, -0.02199773f, 0.05363396f, 0.01464496f, 0.05922248f, -0.06236673f, 
    -0.04826453f, 0.07742570f, 0.03382429f, -0.04837241f, -0.09867555f, 0.06685241f, -0.08599239f, 0.03881913f, 
    -0.06349847f, -0.02263513f, 0.07804726f, 0.08729403f, -0.04942571f, 0.01343748f, -0.02814929f, -0.07183325f, 
    -0.02615028f, 0.04128157f, -0.01889592f, 0.04898177f, -0.00228416f, -0.05933239f, 0.00926535f, -0.06792915f, 
    -0.05313944f, -0.01863133f, 0.06507922f, -0.04598986f, 0.08447239f, 0.06449228f, -0.09382446f, 0.06118678f, 
    -0.00690637f, 0.01230016f, -0.05656786f, -0.07019214f, 0.03507238f, 0.02017000f, 0.06948973f, 0.00183699f, 
    0.01418480f, -0.02941425f, -0.06850342f, 0.01116483f, 0.00289723f, 0.01466299f, -0.00962451f, -0.03483351f, 
    0.00675411f, -0.06026645f, 0.04195954f, -0.03912987f, 0.07158001f, -0.05187492f, -0.08519215f, 0.00825637f, 
    -0.02090897f, -0.00528849f, 0.06904965f, 0.05714516f, 0.02388998f, 0.04610425f, 0.03177846f, -0.04474081f, 
    -0.10393620f, -0.02660944f, 0.04417675f, 0.03895357f, -0.00209016f, 0.02483683f, 0.04886387f, -0.08674960f, 
    -0.00609012f, -0.05865504f, -0.05827142f, 0.08114530f, -0.06827169f, -0.07659438f, -0.00281681f, -0.04958568f, 
    0.02281749f, -0.01317002f, -0.04334113f, 0.05213007f, -0.06161620f, 0.01679327f, -0.04606650f, 0.05309998f, 
    -0.02611433f, -0.01177396f, -0.01262160f, -0.09703933f, -0.04432613f, 0.03232158f, -0.05950070f, 0.01759655f, 
    -0.07510085f, -0.06433893f, 0.07358188f, 0.01298808f, 0.04917128f, -0.08346073f, 0.00750237f, 0.01635016f, 
    -0.06368601f, -0.12371903f, -0.09619318f, -0.06367907f, 0.00999801f, -0.02673517f, -0.03732077f, 0.07679186f, 
    -0.02633519f, -0.09882081f, -0.10131472f, -0.10705723f, -0.06278145f, -0.01702691f, -0.08498529f, -0.06436203f, 
    -0.01250857f, 0.04139972f, 0.03182473f, -0.05347782f, 0.04671705f, -0.07941125f, 0.05946671f, -0.09488545f, 
    0.00760313f, 0.00982796f, 0.05983409f, 0.01790821f, -0.03234472f, -0.05571664f, -0.04777468f, -0.08310957f, 
    -0.07770453f, -0.10222585f, -0.11186620f, 0.01693349f, -0.00814272f, 0.05809692f, -0.04728494f, -0.05103064f, 
    -0.06839429f, 0.05842746f, -0.03801538f, -0.01094186f, -0.10885938f, -0.03785548f, -0.03366174f, -0.01861113f, 
    0.05951481f, -0.10808907f, -0.03434744f, 0.05175995f, -0.00474699f, 0.00860306f, 0.03918497f, 0.02212340f, 
    -0.06053520f, -0.06483992f, -0.10884314f, 0.00597916f, 0.00435655f, -0.08034238f, 0.07818758f, 0.04511011f, 
    0.04723769f, -0.06621000f, -0.09642758f, 0.01166263f, -0.02555438f, -0.00391609f, 0.09633162f, -0.03328334f, 
    0.00045862f, -0.06636519f, 0.03137828f, 0.00773771f, -0.00906662f, 0.03921920f, -0.10266966f, 0.10746299f, 
    -0.01433463f, 0.01691283f, -0.10228778f, -0.03018260f, 0.04013566f, -0.03853031f, -0.06220886f, -0.01894384f, 
    0.06351338f, 0.05948973f, -0.02550079f, 0.04114709f, 0.08085793f, 0.02241689f, -0.04527898f, 0.07415994f, 
    -0.29079878f, -0.11673027f, 0.14979734f, 0.17372359f, 0.08824112f, -0.23604232f, -0.11507737f, 0.07092764f, 
    -0.10945008f, -0.38639489f, 0.33137280f, 0.12049251f, -0.11627562f, 0.10709374f, 0.02765290f, -0.03797573f, 
    -0.18828677f, -0.16022596f, 0.17359740f, 0.12636791f, 0.16073312f, 0.27699113f, 0.08134083f, -0.18850528f, 
    -0.09552575f, 0.09932362f, 0.12844905f, 0.15069902f, -0.03034028f, -0.19353361f, -0.07431909f, -0.04790305f, 
    0.17847915f, -0.14313357f, -0.17682707f, 0.34253681f, -0.14843583f, -0.13135295f, 0.21012282f, 0.05257105f, 
    -0.30822253f, 0.13980857f, 0.11129824f, 0.12968029f, 0.07928229f, 0.00127148f, -0.08348291f, -0.00740575f, 
    0.17529288f, 0.16456679f, 0.47550559f, 0.04165074f, 0.08739642f, 0.20404875f, 0.11731475f, -0.05118348f, 
    -0.03605697f, -0.01478283f, 0.32881057f, -0.06383219f, 0.10648476f, 0.10271669f, 0.09771994f, 0.14696652f, 
    -0.06349521f, 0.06145655f, -0.14213461f, -0.02340777f, -0.20256893f, 0.06707744f, 0.22736424f, -0.04494899f, 
    0.07172447f, 0.20783021f, 0.16128874f, 0.02658916f, 0.01317816f, -0.30478552f, -0.09251966f, -0.07616393f, 
    -0.07794119f, -0.18299365f, 0.18639685f, -0.21130773f, 0.03094699f, 0.01790746f, -0.02534337f, 0.11333391f, 
    -0.03898863f, 0.13520569f, -0.24784704f, 0.11810271f, -0.30960995f, -0.01303124f, -0.08059797f, 0.23991331f, 
    -0.05129471f, 0.08273038f, -0.00509214f, 0.24068013f, 0.27899611f, 0.06527891f, 0.37719727f, -0.07584451f, 
    0.12820978f, 0.01777699f, -0.10246515f, 0.43224603f, -0.06119181f, -0.12567702f, -0.07316543f, 0.16273877f, 
    -0.29876018f, -0.02166479f, 0.04418476f, 0.06818836f, 0.15842247f, -0.01190152f, 0.01680486f, 0.22100548f, 
    -0.00758805f, -0.03449619f, 0.05250243f, 0.19273871f, 0.30168635f, 0.06970825f, 0.00933958f, -0.06043101f, 
    -0.00947631f, -0.06966310f, -0.10546697f, 0.02395244f, -0.01231147f, 0.04704977f, -0.07119119f, 0.07415540f, 
    0.00163257f, 0.02049408f, -0.02577371f, 0.02724623f, 0.05384883f, -0.06987235f, 0.05063152f, -0.06975770f, 
    0.04980974f, -0.00304505f, 0.04246393f, -0.02112176f, -0.08393998f, 0.01973959f, -0.02946776f, -0.08562275f, 
    0.06136555f, -0.01746177f, -0.03396736f, -0.05400924f, -0.06803773f, -0.05996981f, -0.02940795f, -0.03397772f, 
    0.03256359f, -0.04306470f, -0.03640317f, -0.03575291f, -0.07202231f, -0.07142934f, -0.06310652f, -0.08182075f, 
    -0.00535331f, -0.06695172f, -0.04765880f, 0.06056837f, 0.04689007f, -0.08109721f, -0.07543757f, -0.07665595f, 
    -0.04554207f, -0.06768002f, 0.04516366f, -0.04925230f, 0.00675297f, -0.06247362f, -0.09145871f, -0.03267838f, 
    0.05147562f, -0.02986393f, -0.03204877f, 0.02938136f, 0.02254910f, 0.00768666f, 0.05595899f, 0.01072969f, 
    -0.01888994f, 0.06095607f, 0.07772187f, 0.00409902f, 0.05126325f, -0.07330909f, 0.01095385f, -0.06943045f, 
    -0.09490176f, -0.05085604f, -0.03323488f, -0.04612652f, -0.08462929f, -0.06442422f, 0.05493347f, -0.06490815f, 
    -0.02666130f, 0.04027262f, 0.02399166f, -0.06146069f, 0.04723649f, 0.00229597f, 0.07087546f, 0.01225911f, 
    0.03386747f, 0.02267195f, 0.02785781f, 0.07003015f, -0.03594303f, 0.03133899f, 0.04985709f, -0.00800165f, 
    -0.02661912f, 0.06077016f, 0.03195341f, -0.04318302f, 0.03386419f, 0.06510397f, 0.02314348f, 0.00565609f, 
    0.00617272f, -0.04765447f, -0.03586289f, -0.02715076f, 0.05666735f, -0.07333604f, 0.00765978f, -0.00535336f, 
    -0.07393233f, 0.00648153f, 0.00310430f, -0.07074914f, 0.04285393f, -0.06057105f, 0.03434892f, -0.06236563f, 
    -0.01052444f, 0.06324445f, -0.00016130f, -0.05767326f, -0.07769554f, 0.07425386f, 0.00294354f, 0.05480668f, 
    0.14923586f, 0.01722693f, 0.02645119f, 0.04511509f, -0.32645044f, -0.06108479f, -0.19253324f, 0.18095228f, 
    -0.03353655f, -0.13966209f, 0.11480591f, 0.03977085f, 0.28916487f, -0.13098007f, 0.04525195f, -0.24329869f, 
    0.13322122f, -0.22979623f, -0.05355132f, 0.12128393f, -0.06907374f, 0.33829668f, -0.06921712f, 0.07579646f, 
    0.17158484f, -0.10072593f, -0.09957425f, -0.01440717f, -0.13746318f, 0.17418101f, 0.08023913f, 0.12311784f, 
    -0.13569129f, 0.16795573f, 0.27679649f, 0.27995795f, -0.08667620f, 0.01137220f, 0.04333497f, 0.28149974f, 
    -0.19684796f, 0.21342988f, 0.19372663f, 0.03248589f, -0.00997240f, 0.09983087f, -0.01367573f, -0.05335783f, 
    0.37182283f, 0.08708613f, 0.33120969f, 0.02561872f, -0.05648399f, -0.06468052f, -0.14297211f, 0.06098497f, 
    -0.10015301f, 0.01393032f, 0.21278690f, -0.06003356f, -0.35741401f, -0.23294176f, -0.21503337f, -0.09347405f, 
    0.33108705f, 0.36271381f, 0.09616526f, -0.07753299f, -0.31507504f, -0.00783426f, 0.18353017f, -0.16600937f, 
    -0.07233614f, 0.13952215f, -0.03614134f, 0.18035269f, 0.02858776f, 0.00086214f, 0.29906765f, 0.03151860f, 
    0.02459079f, -0.12827334f, 0.19065924f, 0.10305929f, -0.04873529f, 0.02466873f, -0.19903925f, 0.10958986f, 
    0.06041387f, 0.41004378f, -0.44852436f, 0.31290901f, -0.11160249f, -0.06013085f, 0.01979552f, 0.30379677f, 
    -0.21111478f, 0.07536311f, 0.07584440f, 0.18852410f, 0.09910526f, 0.36975682f, 0.05154786f, -0.09840706f, 
    0.08312726f, -0.10107611f, 0.05973079f, 0.12420084f, -0.07823174f, -0.13086531f, 0.01144388f, 0.29550737f, 
    -0.03371450f, 0.16555601f, -0.09875154f, 0.36640704f, 0.19978908f, 0.03171508f, -0.23112641f, 0.17021483f, 
    0.00749231f, 0.07624748f, 0.15863143f, -0.00551738f, 0.18141466f, -0.00989079f, -0.12527347f, -0.29324618f, 
    -0.03542983f, -0.07862625f, 0.02343798f, -0.03856739f, -0.07556673f, 0.17617609f, 0.02399724f, -0.11709770f, 
    -0.08360006f, 0.30634254f, 0.07470944f, -0.00771229f, 0.29527053f, -0.09155277f, 0.06942401f, -0.29825991f, 
    0.04496323f, -0.06884453f, 0.00381867f, 0.03739247f, -0.12063657f, -0.16021140f, 0.05424404f, 0.32199359f, 
    -0.24192019f, 0.01861923f, 0.10249407f, -0.00786807f, -0.05305808f, -0.03165063f, 0.27790996f, -0.01223818f, 
    0.09730540f, 0.15687823f, 0.24486421f, -0.23486397f, 0.19727294f, 0.15889683f, 0.07618301f, -0.00216946f, 
    0.03753253f, 0.27831110f, 0.14903602f, 0.08628152f, 0.08466941f, 0.08716772f, 0.00484664f, -0.00483545f, 
    -0.16417733f, 0.13622545f, -0.18246788f, -0.04059296f, -0.03164931f, -0.17519212f, 0.08465285f, 0.23747873f, 
    0.09271524f, 0.00374525f, -0.05086389f, -0.05097086f, -0.05568882f, 0.07108025f, 0.22402970f, 0.24614112f, 
    0.06300545f, 0.11095858f, 0.23937020f, -0.04577919f, -0.01891867f, 0.10519658f, 0.02058115f, 0.11052824f, 
    0.10167003f, 0.10651219f, 0.07823995f, -0.07905911f, -0.07531594f, -0.21164100f, -0.03831767f, 0.05753778f, 
    -0.01069197f, -0.03970968f, -0.12634774f, 0.09830867f, 0.08170783f, -0.00658924f, -0.18604530f, -0.13876714f, 
    0.00209184f, -0.02658658f, -0.05283136f, 0.21156943f, 0.02347423f, -0.00553263f, 0.06145318f, -0.23325047f, 
    0.18657422f, 0.07873356f, 0.07112609f, -0.08439419f, -0.07672839f, -0.08242285f, -0.07499363f, -0.03018652f, 
    -0.03468747f, 0.09234160f, 0.07670970f, 0.00631068f, 0.03142625f, -0.01524125f, 0.02757067f, -0.01294550f, 
    0.16326183f, 0.00384826f, -0.12537439f, 0.05115651f, -0.02834718f, 0.04639563f, 0.06495682f, -0.06255124f, 
    0.05846686f, 0.13666001f, -0.22754946f, -0.08770718f, -0.04480595f, 0.05251838f, -0.05275585f, -0.00880998f, 
    0.00995413f, -0.20044154f, -0.14326411f, 0.04476512f, -0.13278349f, -0.30963570f, 0.01822974f, -0.19478393f, 
    0.12177172f, 0.01882813f, 0.07261868f, -0.12348405f, -0.25722912f, 0.04750713f, -0.01967382f, -0.03593488f, 
    -0.01234853f, -0.15647154f, -0.13821311f, -0.06075411f, 0.06847949f, 0.19307421f, -0.05482749f, 0.09048215f, 
    0.01879021f, 0.19621219f, 0.19534074f, 0.16973078f, 0.08356690f, -0.10519798f, 0.12400923f, 0.11670031f, 
    -0.17501938f, -0.04874804f, -0.41241106f, 0.20418766f, 0.23608255f, -0.06830254f, 0.29308453f, -0.20677288f, 
    -0.07652049f, -0.12969540f, 0.10716531f, 0.02190344f, 0.23090456f, -0.27333513f, -0.32641625f, -0.15338819f, 
    0.20868471f, -0.06610172f, 0.34585297f, -0.08727784f, -0.03132963f, 0.13226689f, 0.25153396f, -0.06249738f, 
    -0.17426001f, -0.03181689f, 0.21184631f, -0.02580090f, -0.00078060f, -0.18041892f, 0.23921232f, 0.16546686f, 
    -0.07065403f, -0.19940397f, -0.09796707f, 0.02682950f, 0.35655937f, 0.11383238f, -0.02844085f, -0.29938728f, 
    0.19621982f, -0.05210618f, -0.00025297f, -0.05271939f, -0.18132225f, 0.18622938f, -0.21267861f, -0.15609653f, 
    0.42467877f, -0.02319242f, 0.05999185f, -0.06270459f, -0.03111640f, 0.04463515f, -0.01995121f, 0.07738981f, 
    0.02758890f, -0.14167452f, -0.29005605f, -0.05441038f, -0.06120884f, -0.11583715f, -0.06532161f, -0.59334826f, 
    0.01219523f, 0.05688182f, 0.17265706f, -0.02562852f, 0.06729745f, -0.43633589f, 0.52974659f, 0.07738268f, 
    -0.00525468f, -0.03986228f, -0.12410277f, 0.35036555f, -0.16718356f, -0.20630929f, -0.00295698f, 0.15091294f, 
    0.03206030f, -0.24768856f, -0.21998033f, -0.13316333f, 0.23959719f, -0.29806745f, 0.08059788f, -0.03964308f, 
    -0.30636847f, -0.16373995f, 0.41179574f, 0.28428212f, 0.38048863f, 0.15727909f, 0.19546738f, -0.12991083f, 
    -0.01616673f, 0.03832421f, -0.25875410f, -0.77304256f, 0.06658725f, 0.05061905f, 0.11848187f, 0.15763891f, 
    -0.15362799f, 0.25802711f, 0.01039694f, 0.03390180f, -0.35604027f, -0.00565046f, 0.11507440f, -0.18064110f, 
    0.13612871f, 0.07530222f, 0.06009036f, 0.14111055f, 0.09749842f, -0.25240824f, 0.03919080f, 0.00967098f, 
    -0.17370407f, 0.09511153f, -0.18154933f, -0.19075461f, 0.20452639f, -0.06008305f, -0.11163549f, -0.15863846f, 
    0.04500482f, 0.13082047f, -0.24214984f, -0.48582008f, 0.42073119f, -0.02392695f, -0.16168761f, 0.15123753f, 
    0.02954577f, 0.95195198f, -0.08063841f, 0.22147401f, -0.12017024f, -0.04332032f, 0.02596227f, -0.05162473f, 
    -0.26531479f, 0.08443262f, 0.15937546f, -0.25822479f, -0.05837647f, -0.40808231f, -0.45634225f, -0.06234174f, 
    0.01614236f, -0.02668464f, -0.27375442f, 0.11804932f, 0.03162342f, -0.02921307f, -0.03404223f, -0.07527602f, 
    0.03778984f, 0.17902060f, -0.10402007f, -0.00918459f, 0.56750333f, 0.08920034f, 0.21095142f, 0.12347296f, 
    -0.22082698f, -0.07170819f, 0.20089380f, 0.01443995f, 0.01872866f, 0.03966486f, 0.21040621f, -0.14970368f, 
    -0.00316382f, 0.02265699f, 0.00519235f, 0.54636943f, 0.07212305f, -0.05939288f, -0.15835834f, 0.27146599f, 
    -0.04265634f, 0.50488323f, 0.04897735f, 0.10465726f, 0.04063912f, 0.15862568f, 0.07549585f, 0.17936584f, 
    0.06067761f, 0.08505218f, 0.06333844f, -0.08418977f, 0.03878555f, 0.04012650f, -0.25756764f, 0.07917357f, 
    0.06766882f, -0.31589597f, 0.12853839f, 0.26166907f, 0.21051243f, 0.06897594f, 0.14933431f, 0.05460960f, 
    0.05373695f, 0.12040738f, -0.19758381f, -0.14370826f, -0.18115574f, -0.15206155f, -0.02396023f, -0.11304269f, 
    0.07566648f, -0.03327660f, -0.24547662f, -0.13349213f, 0.25534862f, 0.06711531f, 0.11996708f, -0.10344452f, 
    0.21557947f, -0.17598359f, 0.00816585f, -0.05552422f, -0.34142482f, 0.03007557f, -0.31229788f, -0.36056027f, 
    0.27356172f, 0.34313139f, -0.04426229f, -0.01011982f, 0.19589423f, -0.12340189f, -0.01907637f, -0.35643536f, 
    -0.10176157f, -0.05008781f, -0.06307966f, 0.14707483f, -0.00944119f, -0.07057655f, 0.01226959f, 0.07862888f, 
    0.01388293f, 0.15879479f, 0.01342876f, 0.11981226f, -0.17779842f, 0.10592563f, 0.11771286f, 0.13012622f, 
    -0.17124838f, -0.00722352f, 0.21982163f, -0.06574710f, 0.06821056f, 0.04277129f, 0.06171195f, 0.46756193f, 
    0.09219363f, 0.32130834f, 0.05287827f, 0.12623641f, -0.05673140f, 0.05424475f, 0.05545913f, -0.05878220f, 
    0.02784631f, 0.29557368f, 0.10759422f, 0.03149163f, -0.06560501f, -0.10964896f, -0.02115769f, 0.20125452f, 
    0.12571950f, -0.08723148f, 0.15025309f, 0.06218212f, -0.02182805f, -0.08967178f, -0.07933081f, 0.21017323f, 
    0.44026312f, 0.05309452f, 0.15732780f, -0.04413482f, -0.13039844f, 0.19860114f, 0.07508899f, -0.09301075f, 
    0.06687221f, -0.01842766f, -0.12585652f, -0.06425190f, 0.15483473f, -0.03225512f, 0.02233263f, -0.10830487f, 
    -0.15349121f, -0.13386795f, 0.09810624f, 0.23426490f, 0.01976887f, -0.04260951f, -0.26901200f, -0.12952474f, 
    0.03235026f, 0.24136348f, -0.41765872f, 0.16129178f, -0.07372834f, -0.12336154f, 0.00492410f, -0.12173379f, 
    0.07807854f, 0.07582965f, 0.05543170f, 0.22328432f, 0.19338454f, 0.11539201f, -0.04695963f, -0.11157288f, 
    0.07036501f, -0.21494916f, 0.01426634f, 0.05925698f, -0.00490189f, -0.07437284f, 0.04930013f, 0.13364518f, 
    0.06157489f, -0.13117972f, 0.04392686f, 0.26294017f, -0.03047853f, 0.14575987f, -0.03445680f, 0.06698214f, 
    0.00526873f, -0.01556622f, 0.07603506f, -0.02469701f, 0.22407217f, 0.12765025f, 0.14754274f, -0.01877006f, 
    -0.90501189f, -0.04357733f, 0.01834658f, -0.08201279f, -0.15247381f, 0.04230448f, -0.72744155f, -0.16435346f, 
    -0.25441444f, 0.06476233f, -0.02473436f, -0.01039899f, 0.36616880f, -0.80538678f, -0.61463892f, 0.19452296f, 
    -0.28624025f, 0.09621570f, 0.05531985f, -0.03355660f, -0.25124893f, -0.22802897f, -0.07370391f, 0.07791975f, 
    0.07875907f, 0.45026940f, 0.08538174f, -0.25455603f, 0.04742233f, -0.04787663f, -0.39984652f, 0.13253981f, 
    -0.02309706f, 0.23297854f, 0.43655077f, -0.20611759f, 0.34117803f, 0.03527073f, 0.04285089f, -0.32473293f, 
    -0.15521754f, -0.03841842f, 0.07200532f, 0.27175415f, -0.01326507f, -0.02050793f, -0.41181344f, -0.18745551f, 
    0.08405191f, -0.29011106f, 0.00073656f, -0.39275566f, 0.03167082f, -0.03285213f, 0.14853646f, 0.18837702f, 
    0.08611900f, -0.46846730f, -0.08128025f, 0.23412529f, 0.18270022f, -0.42819619f, -0.10520969f, 0.16863246f, 
    0.22841024f, 0.00796704f, 0.19363643f, -0.07099383f, 0.18548597f, -0.37947640f, 0.20198111f, -0.15364973f, 
    -0.23799630f, 0.13876173f, 0.15325718f, 0.12777936f, 0.17931609f, 0.09875026f, 0.07253977f, -0.08981714f, 
    -0.28460065f, 0.22414723f, -0.09363020f, 0.31003085f, 0.03980763f, -0.04531456f, 0.06403094f, 0.16946660f, 
    -0.05328032f, 0.12857769f, -0.19186318f, 0.10892636f, -0.23524848f, -0.16420311f, 0.08674070f, -0.64571214f, 
    0.18981618f, 0.04871866f, -0.29709798f, -0.22336979f, 0.02021675f, -0.08098519f, -0.83402580f, -0.09671182f, 
    0.24542603f, -0.09012732f, -0.05401944f, 0.10898758f, 0.34034517f, 0.16853268f, -0.11788470f, 0.04196435f, 
    -0.04972088f, -0.45284232f, 0.18749827f, -0.21471862f, -0.19117269f, 0.15881883f, -0.37093675f, 0.14089382f, 
    -0.25896323f, -0.09223830f, -0.04675365f, -0.07081641f, 0.05866831f, -0.06540373f, 0.20908859f, 0.24271972f, 
    0.10061721f, -0.10655632f, -0.04921420f, -0.05088038f, -0.09340204f, 0.11610946f, -0.06529736f, -0.02405772f, 
    0.07397904f, 0.53290588f, -0.08731175f, 0.08638750f, -0.02504836f, -0.00145927f, -0.03834013f, 0.45851272f, 
    -0.08359393f, 0.09641185f, -0.08886513f, 0.00624919f, 0.01904926f, -0.14718847f, 0.06186062f, 0.20508178f, 
    -0.14693762f, 0.10551973f, 0.02429255f, 0.09872745f, -0.04808298f, -0.13233727f, -0.03395080f, 0.11818672f, 
    -0.04397766f, 0.07137049f, -0.06362738f, -0.09682465f, 0.07972469f, 0.02183294f, 0.00651986f, -0.20646626f, 
    -0.01517447f, 0.08430793f, -0.02490658f, 0.19787246f, 0.06760035f, -0.08003111f, 0.05765356f, 0.10342879f, 
    -0.11999407f, -0.00693322f, -0.34062427f, -0.29473600f, 0.04255922f, -0.08291738f, -0.06741509f, 0.00927662f, 
    0.01981600f, 0.00944111f, -0.14086820f, 0.00905134f, 0.12859459f, -0.15797168f, -0.19838382f, -0.03276989f, 
    -0.03606948f, -0.03208528f, 0.03932146f, 0.09572680f, 0.21295622f, -0.06152029f, 0.07634936f, -0.07935701f, 
    -0.05388552f, -0.08111684f, 0.07227315f, 0.10141283f, 0.05370551f, 0.30552965f, 0.04794215f, -0.04439275f, 
    -0.08593279f, 0.07754480f, 0.04052383f, 0.49941292f, 0.07049213f, -0.06553248f, -0.01931564f, 0.18476258f, 
    -0.01675102f, 0.08134177f, -0.29417729f, -0.19606450f, 0.05101000f, -0.02892163f, 0.01755819f, -0.07670027f, 
    0.10967794f, 0.04005160f, -0.07356462f, 0.03402526f, -0.06078847f, 0.01222401f, 0.19456790f, 0.11389542f, 
    0.00429405f, 0.05772801f, -0.00505084f, -0.10180168f, 0.23746949f, 0.11567020f, 0.00517809f, -0.04969955f, 
    0.11808078f, 0.00243990f, 0.12641557f, 0.24692896f, -0.02419259f, 0.03099030f, -0.01000810f, 0.00323503f, 
    -0.07288918f, -0.02352143f, 0.25967810f, 0.00415182f, -0.11539800f, 0.01615647f, -0.03097694f, 0.17692913f, 
    0.24980089f, 0.14462900f, 0.02974219f, -0.05310617f, 0.12124705f, 0.30988786f, -0.04714850f, 0.05006526f, 
    0.14466423f, -0.34456673f, -0.16102985f, 0.07928443f, 0.04672680f, -0.00068873f, -0.03007753f, 0.15711829f, 
    0.04159964f, 0.26932040f, 0.01195267f, -0.10980188f, 0.01399129f, -0.49631649f, 0.02244485f, 0.19535576f, 
    -0.11643081f, -0.00794339f, -0.09118529f, 0.17791048f, 0.03476721f, -0.10942458f, 0.07134465f, 0.12879829f, 
    -0.28372630f, 0.04869493f, 0.10133599f, -0.02074236f, -0.10894066f, -0.07008165f, -0.21153566f, -0.11210126f, 
    0.00031142f, -0.20519933f, -0.16854466f, -0.03047568f, 0.09203463f, 0.12603346f, -0.02182977f, 0.16508023f, 
    -0.34395558f, 0.16250095f, -0.48731852f, -0.23372075f, -0.01301367f, -0.09994454f, -0.20305660f, -0.02060192f, 
    -0.07181578f, 0.03855161f, -0.37684470f, 0.09576568f, -0.06458495f, -0.05944251f, -0.02850000f, -0.20735319f, 
    -0.15716912f, 0.27365988f, -0.13897356f, 0.08227943f, 0.02987316f, 0.01293808f, -0.03535994f, -0.04223865f, 
    -0.00515100f, -0.06125509f, -0.00305104f, 0.03332281f, 0.12690322f, -0.51148772f, 0.19264637f, 0.17322043f, 
    -0.02330843f, 0.19265601f, -0.18590456f, 0.17043920f, 0.08769827f, -0.03025523f, 0.10167294f, 0.29817399f, 
    -0.02995006f, -0.23919305f, -0.09995463f, 0.02631842f, 0.22940977f, -0.01333928f, 0.00154699f, -0.26475719f, 
    0.04409669f, 0.00491387f, 0.05167102f, -0.11794041f, -0.23204868f, 0.06266268f, 0.03949500f, -0.04611184f, 
    -0.00191868f, 0.16280320f, 0.10286837f, -0.22041918f, 0.23194036f, 0.08576813f, 0.34224457f, -0.05536767f, 
    0.16630232f, -0.03890253f, 0.00949048f, 0.11784292f, 0.08121639f, 0.05816701f, 0.00542053f, -0.17430368f, 
    -0.03899764f, 0.04435254f, -0.40953839f, -0.01052907f, -0.29870269f, -0.12010519f, 0.07339162f, 0.25377825f, 
    -0.23869987f, -0.12137439f, 0.04307033f, 0.07966916f, -0.23188035f, -0.00257547f, -0.13284466f, 0.03944015f, 
    -0.48039520f, 0.34828833f, 0.18829462f, 0.10637707f, -0.38233238f, 0.10008788f, 0.29064253f, -0.05459503f, 
    0.00421837f, -0.04419933f, -0.04616852f, -0.00967728f, 0.13699721f, 0.18680751f, -0.03111005f, -0.05107982f, 
    -0.08805987f, 0.01734570f, 0.00853075f, 0.19832614f, 0.09953269f, 0.09614877f, 0.34329841f, 0.25814044f, 
    -0.04795677f, -0.36080137f, -0.18521957f, 0.14734362f, -0.79500800f, -0.01097879f, 0.08284828f, -0.13466851f, 
    -0.15315080f, 0.27527779f, 0.09874047f, -0.71385384f, -0.01624545f, 0.06628994f, 0.09492278f, 0.16346590f, 
    0.06382311f, 0.18291911f, 0.16623604f, -0.40567786f, -0.06545959f, -0.07058240f, -0.11573796f, 0.05462281f, 
    -0.13813655f, 0.14496532f, 0.20726630f, -0.09171694f, -0.03136079f, -0.14212167f, -0.14603776f, -0.05009979f, 
    0.20100144f, 0.30216295f, -0.29035121f, 0.04615404f, -0.43564603f, 0.26314881f, -0.74621332f, -0.00616302f, 
    0.14744394f, -0.47763681f, 0.09418178f, -0.12275414f, 0.10492197f, -0.32587880f, -0.04400276f, -0.01566272f, 
    0.03939413f, -0.01808672f, 0.16638017f, 0.24952351f, 0.08526587f, 0.06953863f, -0.09068198f, -0.14664492f, 
    -0.07277562f, 0.33991733f, -0.02363096f, -0.11125390f, -0.03378039f, -0.07546760f, -0.08312459f, -0.03604253f, 
    0.03699594f, 0.05379748f, 0.11729810f, 0.23065594f, -0.01726904f, 0.11237086f, 0.00383977f, -0.05061897f, 
    -0.11384834f, 0.03519126f, -0.00097408f, -0.10667216f, -0.02848418f, -0.12924169f, 0.14454058f, -0.17019939f, 
    0.04403923f, 0.18554573f, -0.16148251f, 0.30572340f, 0.11124489f, -0.11702330f, -0.11822140f, 0.05875909f, 
    0.15659690f, 0.26003557f, 0.06880780f, 0.03527678f, -0.47569016f, 0.09287054f, -0.10356546f, 0.13891669f, 
    -0.26087046f, -0.11458634f, 0.03003494f, -0.10403168f, -0.23796862f, -0.03198067f, -0.14902961f, 0.41090754f, 
    -0.56358027f, 0.59953284f, -0.05223984f, 0.16009653f, 0.13114871f, -0.07366071f, 0.20843033f, -0.16046640f, 
    0.13593355f, 0.03507000f, -0.07762382f, 0.00143968f, 0.03850524f, 0.19204499f, -0.01425138f, 0.07471133f, 
    0.00542610f, -0.00066835f, 0.07782919f, 0.01877414f, 0.02381755f, 0.00366976f, -0.03377524f, 0.11354831f, 
    -0.07319175f, 0.13410798f, 0.19000976f, -0.01221235f, -0.12082429f, 0.00160738f, -0.13269775f, -0.61590028f, 
    -0.44208553f, 0.30228621f, 0.03978899f, 0.01327068f, -0.05698667f, 0.04808022f, -0.02820649f, 0.03843195f, 
    0.27043080f, -0.00410953f, 0.17355317f, -0.49606225f, -0.05378705f, -0.13793112f, -0.15906151f, -0.03088801f, 
    -0.00948192f, 0.08830357f, -0.07502832f, -0.07154329f, -0.32997835f, -0.12591553f, -0.12352420f, -0.12958558f, 
    0.19526283f, 0.36764228f, 0.01729144f, -0.06864962f, 0.02387038f, 0.02580098f, 0.02458036f, -0.13247316f, 
    -0.13784760f, 0.16198283f, 0.07520065f, 0.13549210f, 0.04170714f, 0.11668752f, 0.19336605f, -0.00730721f, 
    -0.16013403f, -0.00728669f, 0.06667300f, 0.33948460f, -0.01375807f, 0.06936275f, -0.18698199f, 0.03323127f, 
    -0.06979001f, 0.27091643f, -0.11456115f, 0.12776367f, -0.00124724f, -0.10096098f, 0.05732261f, 0.23428835f, 
    -0.10296206f, 0.05243799f, -0.09849653f, 0.07752028f, 0.08884563f, -0.03221330f, -0.41851780f, 0.09419867f, 
    -0.00064151f, -0.12758249f, 0.08621784f, 0.15397808f, 0.15226100f, 0.13706836f, 0.14468971f, 0.19722779f, 
    0.05853640f, 0.17658341f, -0.04487950f, 0.11190718f, -0.04492107f, -0.02875448f, -0.14023834f, 0.08888869f, 
    -0.04038282f, 0.05519732f, 0.18308119f, -0.14939244f, -0.01558638f, 0.00165116f, -0.02629881f, -0.03041264f, 
    0.25105438f, 0.11334325f, -0.02948723f, -0.08125957f, 0.19020040f, 0.10488574f, -0.16119935f, -0.12471117f, 
    0.39573559f, -0.13306087f, -0.12543276f, -0.24708486f, 0.19479875f, -0.09352522f, -0.06753577f, -0.08499888f, 
    0.02594474f, -0.00976658f, -0.04865871f, 0.05966862f, -0.03776878f, 0.11209915f, 0.07776835f, 0.12175095f, 
    -0.08306299f, -0.08282155f, 0.11164910f, -0.08650821f, 0.03375758f, -0.00922448f, 0.14180574f, -0.23844780f, 
    0.14015974f, 0.10690088f, 0.14725718f, 0.00637713f, 0.12979136f, 0.19065036f, 0.26736858f, 0.50921446f, 
    0.60104841f, -0.06293802f, 0.07819629f, -0.00191337f, 0.00095094f, -0.09329652f, -0.13153961f, -0.18305936f, 
    0.14236660f, -0.12166435f, -0.01099539f, 0.19870710f, 0.00372389f, -0.17479309f, 0.04018024f, 0.23724760f, 
    -0.09049413f, -0.32567567f, -0.05331563f, -0.02125242f, -0.01144182f, 0.34430686f, 0.17024270f, 0.10478523f, 
    0.01326713f, 0.03326624f, 0.17888696f, -0.10642675f, 0.07706622f, -0.03936412f, -0.03814033f, 0.05719306f, 
    0.10557608f, 0.06249440f, 0.06115929f, -0.08400042f, -0.18814427f, 0.03631358f, -0.01282381f, 0.12778930f, 
    0.18612750f, 0.10107478f, -0.19338199f, -0.22704205f, -0.08631221f, 0.06595112f, -0.11733278f, -0.19584958f, 
    -0.00653060f, -0.05786293f, 0.24016935f, 0.30030620f, 0.05467969f, 0.22249383f, 0.00354178f, -0.45463386f, 
    0.10450386f, -0.07288735f, 0.01536781f, -0.20572092f, 0.00897479f, -0.25796604f, 0.36139807f, -0.02371113f, 
    -0.10298566f, 0.07207200f, 0.13844740f, 0.06075364f, -0.04842525f, -0.01305234f, -0.03765968f, -0.01134666f, 
    0.00081186f, -0.05630716f, -0.13665010f, -0.21623881f, -0.02530005f, -0.00702567f, 0.11343260f, 0.10829646f, 
    -0.29425696f, -0.25558773f, 0.05043539f, 0.06778517f, 0.20224522f, 0.04283021f, 0.10677183f, -0.04319549f, 
    0.19158298f, -0.43884102f, 0.15048404f, 0.30257922f, -0.33761051f, -0.20940273f, -0.15036067f, -0.21947075f, 
    -0.11740154f, -0.10566621f, 0.37231544f, 0.03912093f, -0.05211540f, 0.09294888f, 0.19544387f, -0.15999927f, 
    -0.17879029f, -0.23644564f, 0.04003993f, 0.05722128f, 0.19258703f, 0.30570030f, 0.03541865f, -0.12909254f, 
    0.22664113f, 0.15826178f, 0.19346783f, 0.04901658f, -0.01325471f, 0.10372643f, 0.19304816f, 0.19261047f, 
    0.01485673f, -0.39051655f, -0.19764487f, 0.17097872f, -0.05798618f, -0.24770236f, -0.08577146f, 0.10412391f, 
    -0.16574456f, -0.17338318f, 0.17916714f, -0.11816271f, 0.16963352f, 0.05422276f, -0.11743213f, 0.10814635f, 
    0.10786029f, 0.28211549f, 0.41323027f, 0.38626084f, -0.01356396f, 0.40825874f, 0.22769040f, -0.01372801f, 
    0.12234700f, 0.09884525f, 0.37223363f, -0.23795992f, 0.11147688f, 0.17464338f, 0.31023559f, 0.12700906f, 
    -0.09871630f, 0.06762158f, 0.05094115f, -0.06297614f, -0.15986633f, 0.21718863f, 0.11481158f, -0.28413519f, 
    0.31648040f, -0.00845550f, -0.06773195f, -0.08404186f, 0.01901596f, -0.46480614f, -0.13610294f, 0.01755859f, 
    0.19140099f, -0.14730525f, 0.26493990f, -0.33459795f, 0.06107456f, -0.08014219f, 0.24759571f, 0.09467902f, 
    -0.07583861f, -0.00170045f, -0.33139700f, -0.25562850f, -0.42766610f, -0.18800651f, -0.05490892f, 0.07555715f, 
    0.05561154f, -0.07916208f, 0.17375521f, 0.15588057f, -0.04351597f, 0.26659241f, -0.03333551f, -0.25323197f, 
    -0.09843829f, 0.06057960f, -0.25915062f, 0.24097687f, -0.14915577f, -0.45583376f, -0.07504720f, -0.12566151f, 
    -0.37871510f, 0.01772467f, 0.08956785f, -0.02116998f, 0.09722432f, -0.03101744f, -0.09318954f, 0.15970349f, 
    0.05132341f, 0.12936342f, -0.08126620f, 0.04303557f, 0.17164524f, 0.04515388f, -0.05151608f, -0.01836965f, 
    -0.01672938f, -0.06318010f, 0.13913670f, 0.19946058f, -0.18847531f, 0.19403207f, -0.41284686f, -0.00097605f, 
    -0.23189752f, -0.72568780f, 0.10630406f, 0.00897183f, -0.71137214f, 0.04526518f, -0.05382194f, 0.02243658f, 
    0.03846240f, 0.00594064f, -0.52287889f, -0.38248405f, 0.13114053f, 0.09009928f, -0.01661389f, -0.01876750f, 
    0.22816551f, 0.06430010f, 0.16496137f, 0.08181518f, 0.12752678f, 0.15651533f, 0.30984545f, -0.02660177f, 
    0.18076879f, -0.64070100f, -0.23517519f, -0.13052252f, -0.53080869f, 0.13482958f, -0.03134772f, -0.16110440f, 
    -0.11588801f, -0.97184592f, 0.07704323f, -0.58226919f, 0.17554072f, 0.03006133f, 0.08919765f, 0.14910473f, 
    -0.16809085f, 0.27687469f, -0.09013779f, -0.33231065f, 0.04306928f, 0.13834132f, 0.24835455f, -0.04010719f, 
    0.11821586f, -0.00358301f, 0.09926018f, 0.06147733f, 0.00710995f, -0.01738348f, 0.05714913f, 0.05586256f, 
    -0.08023003f, 0.03870658f, -0.06735533f, -0.00096542f, -0.24464044f, 0.19769737f, -0.55431902f, -0.04125039f, 
    0.25026786f, -0.51145285f, -0.19573283f, -0.28089431f, 0.09892192f, -0.45554224f, -0.17000200f, 0.24036723f, 
    0.01203673f, -0.12882976f, 0.13140507f, 0.02741588f, -0.00327598f, 0.07250137f, 0.05680639f, -0.12981525f, 
    0.04373093f, -0.09227942f, -0.03763426f, -0.21642175f, 0.15747765f, -0.26878077f, -0.05903768f, -0.23612352f, 
    0.12155519f, 0.01343085f, 0.12087220f, 0.12605472f, -0.04552133f, -0.08630634f, -0.06253210f, 0.00977631f, 
    -0.25279346f, 0.07611941f, -0.03388951f, -0.11217191f, -0.00563358f, -0.14852868f, 0.09106325f, -0.53482878f, 
    -0.00809594f, 0.00009187f, -0.04672979f, -0.08949121f, -0.10966273f, -0.23301607f, 0.06959915f, -0.01194156f, 
    0.14224505f, 0.13749561f, -0.16377330f, 0.05787426f, -0.36550429f, 0.06316189f, -0.05390035f, 0.27915025f, 
    0.06586567f, 0.02020212f, 0.08364320f, 0.29435349f, -0.01097786f, 0.12144288f, -0.06334249f, -0.31442240f, 
    0.22876537f, -0.51033366f, 0.27768090f, -0.00710147f, 0.08568833f, 0.13679433f, 0.01356356f, -0.10908831f, 
    -0.14278336f, -0.05649677f, -0.09787252f, 0.00691365f, 0.07589247f, 0.12438783f, 0.00218600f, -0.24249849f, 
    0.13701646f, 0.24166508f, 0.16180323f, -0.11881156f, 0.17292255f, 0.17774874f, -0.05067416f, 0.13852568f, 
    0.03601637f, -0.04117961f, 0.16207518f, -0.04242820f, 0.24624856f, -0.16571979f, 0.02269145f, 0.08997133f, 
    0.21881461f, 0.08336297f, -0.03222743f, -0.07834379f, 0.10038862f, -0.14826815f, 0.07487878f, 0.09352094f, 
    -0.00487265f, 0.12002955f, 0.20100318f, -0.20730795f, 0.02292099f, 0.18779953f, 0.32579681f, 0.13848434f, 
    0.11936586f, -0.00017029f, 0.14941855f, 0.03652387f, 0.16633591f, 0.00114042f, 0.14978048f, 0.02161919f, 
    0.04365528f, -0.06404024f, 0.17594777f, 0.08558740f, -0.13565412f, -0.01396113f, -0.21432558f, -0.06409732f, 
    0.12359855f, -0.24671976f, 0.04747647f, 0.06674749f, 0.03117868f, -0.09835735f, -0.07334158f, 0.01496372f, 
    0.18731424f, 0.05268731f, 0.04359083f, -0.03789144f, 0.06656662f, -0.01921497f, 0.23648363f, -0.06337566f, 
    -0.05088444f, -0.21745118f, 0.07399309f, -0.27293050f, -0.14592786f, -0.07240351f, 0.01665229f, 0.00500709f, 
    0.08735361f, 0.00957483f, 0.12563469f, 0.10275789f, 0.10343927f, 0.14439867f, -0.02198407f, -0.04619803f, 
    -0.05758373f, 0.08228938f, -0.00331495f, 0.09012470f, -0.09760486f, 0.01586862f, -0.25165936f, -0.36850944f, 
    -0.08003948f, -0.08965272f, 0.17724547f, -0.35739434f, -0.25180081f, -0.04590552f, 0.06809930f, 0.13594915f, 
    -0.07801593f, 0.04787578f, -0.05031648f, 0.06701257f, -0.01432934f, -0.08874827f, 0.03207970f, 0.11400905f, 
    -0.18670855f, -0.46140239f, -0.05410653f, 0.07254101f, -0.23288347f, -0.16610621f, 0.28169566f, -0.17256255f, 
    -0.09244787f, 0.04749124f, 0.15768959f, -0.17867008f, -0.13337925f, 0.17073971f, 0.34640694f, 0.05427273f, 
    0.19662857f, -0.23369043f, 0.45502412f, 0.14790702f, 0.14744169f, 0.24865133f, 0.04522680f, -0.02406630f, 
    0.16864029f, -0.02799196f, -0.00745241f, 0.13572133f, 0.08944737f, -0.03057059f, 0.25154766f, 0.30687752f, 
    -0.16616212f, -0.06850577f, -0.37108350f, 0.08023115f, 0.07519305f, 0.04188853f, -0.10337055f, -0.03098503f, 
    0.08942061f, 0.24190928f, 0.12980083f, -0.16521934f, 0.20208092f, -0.27270281f, -0.13642138f, 0.00493883f, 
    0.17723940f, 0.07202589f, 0.36909604f, 0.17169490f, -0.08638423f, 0.25320452f, 0.20592895f, -0.14814095f, 
    -0.21955733f, 0.27873316f, 0.15712962f, -0.29609600f, 0.14376135f, -0.08638944f, 0.22642472f, -0.04659367f, 
    -0.07656123f, -0.08621073f, -0.09334795f, 0.02579476f, 0.27444226f, 0.16414809f, -0.10733490f, -0.30019981f, 
    0.44811642f, -0.05281869f, -0.09730123f, -0.08054806f, -0.23918025f, 0.19170438f, -0.19251075f, 0.01280217f, 
    0.53996927f, 0.00331879f, 0.06936237f, 0.02523319f, 0.05800887f, -0.05855430f, 0.32143307f, 0.00238574f, 
    0.02389113f, -0.17676932f, -0.09783200f, -0.24573582f, -0.15001123f, -0.13062853f, -0.04659031f, 0.21318436f, 
    -0.00407521f, -0.03253816f, 0.20931716f, -0.11808687f, -0.19800247f, -0.07293795f, 0.07126099f, -0.08236279f, 
    -0.20483910f, -0.02180480f, -0.39033648f, 0.05900414f, -0.23394115f, -0.11728118f, -0.11859841f, -0.00319808f, 
    -0.13553910f, 0.06864195f, -0.10155030f, -0.06151054f, 0.12620972f, -0.12453660f, -0.23619765f, -0.09029275f, 
    -0.04345802f, 0.24083565f, 0.16939431f, 0.08866605f, 0.23166442f, 0.07653477f, -0.16404592f, -0.10301148f, 
    -0.20657796f, 0.02224296f, -0.17178416f, -0.28130519f, -0.01252624f, -0.03548335f, 0.08945546f, 0.18279599f, 
    -0.39935946f, 1.09154284f, -0.15405352f, 0.09947367f, 0.04853324f, -0.16550203f, 0.11181252f, -0.11911353f, 
    0.18646885f, -0.06282263f, 0.04912561f, 0.08531513f, -0.03001606f, 0.03067485f, -0.02425972f, 0.12243453f, 
    0.02227464f, -0.06082672f, -0.09820558f, 0.13543957f, 0.06836218f, 0.10558043f, 0.32058215f, 0.06337559f, 
    0.21073955f, 0.19008532f, 0.05770608f, -0.04871580f, -0.05866405f, 0.08801288f, -0.00351028f, -0.49789566f, 
    -0.06960784f, 0.29827571f, 0.15642735f, 0.07868506f, -0.02673145f, 0.05382918f, 0.04701307f, -0.03876893f, 
    0.05105929f, -0.10246646f, -0.29030737f, -0.72809058f, -0.02884236f, -0.19408217f, -0.15485342f, 0.05760903f, 
    0.04179274f, -0.02287597f, -0.13081178f, 0.03733180f, -0.15998055f, -0.16197431f, -0.15587765f, 0.00786883f, 
    0.25835231f, -0.04210071f, -0.05379323f, -0.16261150f, 0.21716774f, 0.01842692f, -0.10064954f, 0.13594657f, 
    0.16545068f, -0.02240078f, 0.18117636f, -0.03581764f, -0.01089394f, 0.27761284f, -0.03454658f, -0.07257542f, 
    0.07128070f, -0.00024550f, 0.05165917f, 0.36754727f, 0.00071575f, -0.03479259f, -0.13233905f, -0.06714128f, 
    -0.04922492f, 0.01240157f, 0.08790526f, 0.29251400f, 0.07873455f, 0.00153744f, 0.03755116f, -0.01918336f, 
    -0.09502921f, -0.02882830f, 0.04761392f, -0.08564261f, 0.18615204f, 0.02715973f, -0.34557682f, 0.15450348f, 
    0.05220715f, -0.15260600f, 0.05746393f, -0.04322927f, -0.00143299f, 0.15858595f, 0.15416998f, 0.17467491f, 
    0.32002801f, -0.00199249f, -0.16706505f, -0.01107490f, 0.00410282f, 0.02366981f, -0.08400886f, -0.12217394f, 
    -0.01588008f, -0.03945645f, 0.14968543f, 0.00575578f, -0.11378580f, 0.00044709f, -0.00677330f, -0.05326622f, 
    -0.41763678f, 0.00556584f, 0.20058618f, 0.02894378f, 0.21720578f, 0.08542684f, -0.61169618f, 0.34269893f, 
    -0.34698090f, 0.06722451f, 0.00065451f, 0.03926952f, 0.03417387f, -0.21063609f, -0.46295038f, 0.23071593f, 
    -0.16225864f, 0.09412590f, -0.20895606f, -0.30819434f, -0.11078831f, -0.11997584f, -0.07926343f, 0.13033104f, 
    -0.20409527f, -0.04358190f, 0.09699614f, 0.00640238f, -0.08281220f, -0.32969084f, -0.18760723f, -0.09178457f, 
    -0.10307119f, 0.25907642f, -0.06491408f, 0.02729772f, 0.04338013f, -0.08795004f, 0.03965249f, -0.47845230f, 
    -0.38559666f, -0.00553235f, 0.03406135f, 0.16446534f, 0.00822673f, 0.15827195f, -0.35046828f, -0.17833026f, 
    0.23760809f, -0.38609743f, -0.23033482f, -0.19185528f, 0.03265204f, -0.19210958f, -0.00386109f, 0.04810317f, 
    0.06916172f, -0.27168447f, -0.17985991f, -0.00085413f, 0.14956327f, -0.10137694f, -0.10695326f, 0.04242535f, 
    -0.04310362f, 0.19469874f, 0.05472132f, 0.01730026f, 0.25680673f, -0.25569874f, 0.24223591f, -0.13294102f, 
    -0.14948368f, 0.13078056f, 0.10446385f, 0.16052656f, -0.08899456f, 0.31122828f, 0.21131724f, 0.14295247f, 
    -0.13580659f, 0.06131819f, 0.09439641f, -0.10776899f, 0.07620542f, 0.01275549f, 0.04757290f, 0.30120161f, 
    0.07142796f, 0.12281828f, -0.66615397f, 0.00998177f, 0.07378700f, -0.15922651f, -0.00225081f, -0.03779738f, 
    0.23111178f, -0.05258888f, -0.33898550f, -0.07890603f, 0.00802124f, -0.24536525f, 0.14275433f, -0.00138905f, 
    0.11438712f, 0.16515878f, 0.04375193f, 0.05904884f, 0.43865561f, 0.19614805f, 0.04618958f, 0.16833819f, 
    -0.02434678f, -0.04351144f, 0.35801992f, 0.03625078f, 0.12462119f, 0.16222258f, -0.18313918f, 0.18235646f, 
    -0.15085348f, -0.18069933f, -0.11502452f, 0.03250634f, 0.06469715f, -0.01204330f, -0.14326204f, 0.37066540f, 
    0.06527880f, 0.02391454f, 0.06393466f, -0.01687557f, -0.04783341f, 0.04100747f, 0.05222266f, -0.07048997f, 
    0.04835300f, 0.05912817f, -0.01774083f, 0.06349513f, -0.01781485f, -0.07828704f, -0.04462039f, -0.08649372f, 
    -0.00553745f, 0.02552434f, -0.04528136f, -0.02824936f, 0.02350181f, 0.01995701f, 0.01417497f, 0.07780674f, 
    -0.09515566f, -0.04886767f, 0.01687107f, -0.06192174f, 0.03594150f, -0.07678311f, 0.02925918f, -0.08460464f, 
    0.03615103f, -0.02632887f, -0.04735654f, -0.03294123f, 0.01548524f, 0.01609323f, -0.06649545f, 0.06061042f, 
    -0.01725121f, -0.00015336f, -0.03201030f, 0.00832919f, -0.03149787f, -0.04772905f, -0.03605328f, 0.02966969f, 
    0.03558451f, 0.00439388f, -0.03762677f, -0.02254093f, 0.06589920f, -0.04917600f, -0.04614613f, 0.02228417f, 
    -0.09247129f, -0.02624431f, 0.01447025f, -0.04152147f, -0.05200860f, 0.01476125f, 0.07409720f, -0.02546289f, 
    0.02452620f, -0.04042281f, 0.02352484f, 0.06471820f, -0.08169193f, -0.06067810f, -0.03239335f, 0.03502632f, 
    -0.04395155f, 0.01344496f, -0.01427321f, -0.04393892f, -0.03027324f, 0.07480943f, -0.07206550f, 0.00822754f, 
    0.01227352f, -0.08631778f, -0.05474070f, -0.06331656f, 0.06553054f, 0.06505653f, 0.06803789f, 0.00711218f, 
    0.01909410f, 0.02051738f, -0.08342818f, -0.00203569f, -0.06583523f, 0.00108004f, -0.07593636f, -0.00100391f, 
    0.07237170f, 0.07038517f, 0.05762713f, 0.06524114f, -0.01118023f, 0.01462683f, -0.08136568f, -0.03596083f, 
    -0.01799393f, -0.09543285f, -0.02040751f, 0.00080548f, -0.03529537f, -0.00360799f, -0.05671079f, -0.01255958f, 
    0.05383217f, 0.01581184f, -0.04004369f, -0.06513667f, 0.06976746f, 0.03554942f, 0.06277197f, -0.03068266f, 
    -0.04382496f, 0.07571072f, -0.05896013f, -0.05921559f, -0.05715882f, -0.01209666f, -0.00565976f, 0.01313389f, 
    -0.01138395f, -0.27427310f, -0.13318390f, 0.09538300f, -0.14651570f, 0.14649652f, -0.01074816f, -0.14145702f, 
    -0.39167601f, 0.74337780f, 0.16060786f, -0.11367898f, -0.25197828f, 0.16358967f, 0.47333750f, -0.16574155f, 
    0.11222833f, -0.07120613f, -0.04755855f, 0.05463454f, 0.13692999f, 0.31455749f, -0.07010052f, 0.09500468f, 
    0.06119844f, 0.00069634f, 0.17867029f, 0.07235051f, 0.15828447f, 0.09692427f, 0.51021296f, 0.17550710f, 
    -0.12917919f, -0.19326548f, -0.36795127f, -0.14131604f, 0.03706457f, -0.09745879f, 0.11698090f, -0.28660434f, 
    -0.46616444f, 0.60766631f, 0.19252811f, -0.20295054f, 0.19205315f, -0.15947007f, 0.19071843f, 0.02661786f, 
    -0.10037149f, 0.28787822f, 0.16328152f, -0.25031364f, 0.07806321f, 0.22963910f, 0.29001868f, 0.11981818f, 
    -0.00533805f, 0.20943452f, 0.01584600f, 0.00752025f, -0.07334708f, -0.01414325f, 0.17726889f, 0.27506274f, 
    0.25039914f, 0.00974551f, -0.15766154f, 0.02706082f, -0.03832125f, 0.26118049f, -0.38426039f, -0.08037598f, 
    0.44414496f, -0.26929799f, -0.15697011f, -0.27421710f, -0.09454583f, -0.03822540f, -0.31110638f, -0.17823745f, 
    0.45207229f, 0.00759667f, 0.12443614f, 0.14111923f, -0.02244937f, -0.07923532f, 0.22956230f, -0.21887302f, 
    -0.04227036f, -0.20273088f, -0.04430764f, -0.28476912f, 0.08418687f, -0.12952089f, 0.07512569f, -0.14797549f, 
    -0.01239729f, -0.07982342f, 0.23297840f, 0.02552968f, -0.11728030f, 0.02831767f, -0.50604177f, 0.06633268f, 
    -0.27532226f, 0.07287584f, -0.07352801f, -0.00222141f, -0.31301644f, -0.22497617f, -0.11363962f, -0.12654985f, 
    0.17156661f, -0.08060596f, -0.26841557f, -0.11979876f, -0.04884825f, -0.38344336f, 0.04553306f, -0.12850723f, 
    0.04517801f, 0.15316314f, 0.05088434f, -0.08127464f, 0.09070412f, 0.06796099f, 0.02236073f, -0.05722591f, 
    -0.00180701f, -0.00613182f, 0.21470690f, 0.08949732f, 0.14675039f, 0.13505311f, -0.10933580f, -0.04857149f, 
    -0.27799204f, -0.59079033f, 0.12746616f, 0.06879101f, 0.05757409f, 0.12100999f, -0.15298514f, 0.02274045f, 
    0.02192184f, 0.10757918f, -0.01258132f, -0.06317681f, 0.03476118f, -0.15835141f, -0.06835733f, 0.13345625f, 
    -0.12732133f, 0.11990803f, 0.14090016f, -0.03662312f, -0.02321208f, 0.05597759f, -0.12444329f, -0.06030224f, 
    0.01763430f, -0.14794143f, -0.27455351f, -0.21934411f, 0.04930899f, 0.12670985f, -0.28932014f, -0.45942158f, 
    -0.20857498f, -0.30520833f, -0.06341633f, 0.13556184f, -0.06730175f, 0.17291656f, -0.02015218f, 0.09847427f, 
    -0.06553422f, 0.07793891f, 0.06465324f, -0.07214348f, -0.00546559f, 0.12941162f, 0.08923189f, 0.06873613f, 
    0.23332007f, 0.09529662f, -0.06889013f, 0.01925116f, 0.17035386f, 0.06056888f, 0.09983271f, 0.09531271f, 
    -0.19249284f, 0.12395023f, 0.12620762f, -0.00444205f, 0.04369370f, 0.10923048f, 0.07399655f, 0.00696607f, 
    -0.04398242f, -0.05560577f, -0.05802779f, -0.05193369f, 0.07313143f, -0.26437959f, 0.18870607f, 0.17436230f, 
    -0.21328217f, 0.10141546f, 0.03411186f, -0.12636626f, 0.00026699f, -0.00159683f, 0.26606369f, 0.08184686f, 
    -0.06328594f, 0.28474286f, 0.07489727f, -0.25210387f, 0.08165479f, -0.08064390f, -0.05332489f, 0.06798196f, 
    0.11464880f, -0.08566304f, 0.04454366f, 0.06594122f, 0.00097525f, -0.00068195f, -0.20932166f, 0.03046295f, 
    0.12885509f, 0.00487202f, -0.03065587f, -0.00564748f, 0.07213449f, 0.04880314f, 0.08547082f, -0.09759153f, 
    -0.14154093f, -0.02152139f, 0.29440647f, -0.03135531f, -0.03441518f, 0.06778044f, -0.06374373f, 0.05159118f, 
    0.10115408f, 0.16071118f, -0.30506006f, -0.18495119f, -0.10238581f, 0.00511658f, -0.15787160f, 0.25240427f, 
    0.05358696f, 0.03713581f, 0.08742047f, 0.05412857f, 0.14941224f, -0.05911376f, -0.02371878f, 0.66716307f, 
    -0.07506672f, -0.13499075f, 0.05574001f, 0.11438364f, -0.21368675f, 0.06482434f, -0.00411588f, 0.30853704f, 
    -0.24105468f, 0.19156995f, 0.03988397f, -0.07876552f, 0.24732488f, 0.06309042f, -0.05843865f, 0.02379376f, 
    -0.25898910f, -0.20316865f, -0.00441460f, 0.17133494f, 0.09605658f, -0.40533066f, -0.12604998f, 0.05664958f, 
    0.08148108f, 0.07739113f, -0.24358124f, 0.14742689f, -0.12676041f, 0.02949829f, 0.05148218f, -0.32684761f, 
    -0.16449861f, -0.13443302f, -0.00241104f, 0.04917908f, 0.10705672f, 0.04296310f, -0.15633854f, 0.04576444f, 
    0.16400252f, -0.08868971f, -0.09352247f, 0.01183674f, 0.06100542f, 0.07589467f, -0.04533798f, -0.18124202f, 
    -0.13314214f, 0.15429154f, -0.10200310f, -0.23236890f, 0.01961473f, 0.01889053f, -0.11029208f, -0.18014187f, 
    -0.29691142f, 0.04387878f, -0.25532383f, -0.09288020f, 0.32152939f, -0.10814013f, 0.06201964f, -0.02392707f, 
    0.03113943f, 0.06311944f, 0.31609237f, 0.14695902f, -0.01314563f, 0.30721530f, 0.00423051f, 0.08781853f, 
    -0.00849671f, -0.03270723f, 0.18912558f, 0.08800513f, -0.06721277f, 0.06388918f, 0.19645546f, 0.12613703f, 
    0.05894953f, 0.13182136f, -0.21658561f, -0.05223726f, 0.00410843f, -0.43445146f, 0.05858104f, 0.10903338f, 
    -0.03177677f, 0.06468655f, -0.19698547f, 0.00963504f, 0.04956902f, -0.29088685f, 0.52206415f, 0.05168176f, 
    -0.03871414f, 0.06099273f, 0.00888916f, 0.15763186f, 0.13673769f, 0.08713070f, 0.09773954f, 0.09738404f, 
    0.07594146f, 0.04293901f, 0.04721025f, -0.18761051f, 0.06596032f, -0.05680990f, -0.09902050f, 0.15624402f, 
    -0.01271766f, 0.05701758f, 0.23522025f, 0.10650803f, 0.00982412f, 0.01391691f, -0.23050870f, -0.06489326f, 
    0.23184247f, -0.36866853f, 0.08402680f, 0.10124736f, -0.32431850f, -0.15669645f, 0.31944114f, -0.05866979f, 
    0.03623929f, -0.04571147f, 0.24331565f, -0.12860417f, -0.01281375f, -0.05314459f, 0.00140780f, 0.00832231f, 
    0.33111036f, -0.36596310f, 0.07569233f, 0.10361893f, -0.00178198f, 0.21619530f, -0.02660738f, 0.10161620f, 
    0.20006190f, 0.01027000f, -0.01936793f, 0.03774525f, 0.12185405f, 0.12249372f, 0.16727717f, 0.11332005f, 
    -0.11964972f, -0.25405872f, -0.37282375f, 0.07912839f, -0.05910905f, -0.09548736f, -0.19723582f, 0.22573741f, 
    0.04420881f, 0.02807734f, 0.04875634f, -0.10093300f, 0.08636665f, 0.10219396f, -0.31042373f, -0.04489362f, 
    0.28743294f, 0.01019853f, 0.46640015f, 0.43663910f, -0.05512567f, 0.11478986f, 0.14721671f, 0.02744100f, 
    0.07650180f, 0.35804734f, 0.00154582f, -0.44408607f, 0.08676725f, 0.12783195f, 0.10677000f, 0.07882090f, 
    -0.06563501f, 0.09970722f, 0.02524106f, -0.03287699f, 0.20360537f, 0.09836572f, 0.04757759f, -0.10187674f, 
    0.44188318f, 0.01433002f, -0.09340531f, -0.11377624f, -0.14711189f, 0.00715157f, -0.00287987f, 0.03300016f, 
    0.17659579f, -0.29911619f, 0.15820195f, -0.16069432f, 0.00038862f, 0.07499439f, 0.23773719f, 0.16350600f, 
    0.02294302f, 0.16015778f, -0.38540098f, -0.21494508f, -0.23618738f, -0.18848270f, 0.07014578f, 0.04782098f, 
    -0.13683672f, -0.02887628f, 0.25955179f, -0.05885960f, -0.27667233f, 0.01526684f, -0.24804005f, -0.23183374f, 
    -0.17965409f, -0.09810850f, -0.34256360f, -0.10731176f, -0.13769096f, -0.26920274f, 0.03254403f, -0.10301806f, 
    -0.24486493f, -0.04220374f, 0.06261883f, 0.10878857f, 0.24466105f, -0.03768423f, -0.50211871f, -0.08075506f, 
    0.05015350f, 0.30800459f, -0.03256191f, -0.02121185f, 0.23236687f, 0.08679403f, -0.51613528f, -0.02633433f, 
    0.04762306f, -0.08533819f, 0.02296664f, -0.01343518f, 0.03127130f, 0.00852925f, -0.11127745f, -0.01730848f, 
    0.09503044f, 0.06686209f, -0.00554778f, -0.04521457f, 0.06376918f, 0.04843433f, -0.03684193f, 0.04085372f, 
    -0.02248388f, -0.05616543f, 0.03897732f, -0.02245764f, 0.03011539f, -0.03527842f, 0.02724396f, -0.02134587f, 
    0.03862035f, 0.00478251f, -0.10886633f, -0.08979131f, 0.01587075f, -0.04603866f, 0.01873158f, 0.00499590f, 
    -0.10193235f, 0.00073417f, -0.04844427f, 0.04372172f, -0.01811745f, -0.04174710f, 0.05610742f, 0.01275578f, 
    0.02977073f, -0.05282167f, -0.09044043f, 0.06797516f, -0.08904593f, -0.00961549f, -0.00892449f, -0.07867894f, 
    -0.07084484f, -0.06503303f, 0.08123993f, -0.01109141f, 0.03264950f, 0.03612245f, -0.10751712f, -0.02001343f, 
    -0.09837689f, -0.02232782f, 0.06073638f, 0.04876319f, -0.07299142f, -0.06930747f, -0.05006196f, -0.00845070f, 
    -0.07677292f, -0.06402218f, 0.07353786f, 0.02249942f, 0.01120880f, -0.01328281f, -0.05581538f, -0.03119204f, 
    -0.08306381f, 0.07097383f, -0.10089947f, 0.04039757f, 0.02845208f, 0.09179839f, 0.04701905f, 0.00511302f, 
    -0.00214401f, -0.04463669f, -0.06867261f, 0.04223040f, 0.04048880f, -0.03898311f, -0.00672434f, 0.01559431f, 
    -0.01326203f, 0.06466433f, -0.12843043f, -0.07826538f, -0.04610197f, -0.06959929f, 0.06453179f, -0.08966411f, 
    0.03456241f, -0.00927768f, 0.01478382f, 0.03180040f, 0.04220140f, -0.05987213f, 0.02354490f, -0.07906448f, 
    0.07419188f, -0.04546714f, -0.02380725f, -0.07702366f, 0.02800409f, 0.06356601f, -0.01295460f, -0.08036018f, 
    -0.11489470f, 0.03412806f, -0.08223493f, -0.08872446f, -0.05487768f, -0.03387817f, -0.13314587f, 0.02112848f, 
    -0.06769854f, -0.11685226f, -0.05393355f, -0.07343316f, -0.08550590f, -0.04192591f, -0.00250298f, -0.11560850f, 
    -0.00892274f, -0.08308810f, -0.03253110f, 0.06006691f, 0.04766786f, 0.08017263f, 0.05387738f, 0.04677644f, 
    0.00205592f, -0.03055837f, 0.01543702f, 0.06258053f, 0.00666285f, -0.09650582f, 0.03381099f, 0.04339367f, 
    0.04131234f, -0.04962723f, 0.01464068f, 0.06175105f, 0.05421326f, -0.08474939f, 0.05558917f, 0.04717725f, 
    0.05631968f, -0.08835625f, 0.04758026f, -0.05171278f, -0.02627934f, 0.07301571f, -0.07325358f, -0.07451372f, 
    -0.03149941f, -0.08673074f, 0.00358305f, -0.03500500f, -0.06929927f, 0.03348961f, -0.04525493f, 0.08015039f, 
    -0.07399958f, -0.04951433f, -0.05557662f, 0.02020510f, -0.06441013f, -0.07327579f, -0.07781610f, -0.04931671f, 
    0.06464490f, 0.05399814f, 0.06085933f, -0.05394154f, -0.00224234f, -0.05041322f, 0.02555363f, 0.01292541f, 
    -0.06334303f, -0.06849387f, 0.05268712f, -0.08645765f, 0.06321485f, -0.08553959f, -0.04102284f, -0.07192030f, 
    0.05463564f, -0.02323626f, 0.00653418f, -0.05041188f, 0.00494530f, -0.02766059f, -0.05878178f, -0.07095433f, 
    0.03969631f, -0.03988934f, -0.08476859f, -0.09023114f, -0.06332921f, 0.06880535f, 0.02293199f, -0.03888302f, 
    -0.02775654f, -0.08056775f, 0.02634572f, -0.04915646f, -0.00248583f, 0.02413356f, 0.06611070f, -0.01118167f, 
    -0.04257344f, 0.06702521f, 0.04342615f, -0.08059433f, -0.06243364f, -0.04007736f, 0.01857309f, -0.00238460f, 
    -0.01611757f, 0.02197861f, 0.00247245f, 0.02852817f, 0.06655987f, -0.01665416f, 0.04018304f, 0.06206965f, 
    -0.03229913f, 0.08292080f, -0.04459194f, -0.07254509f, -0.02497693f, -0.01740737f, -0.06954899f, 0.05140700f, 
    0.02141429f, 0.03519463f, -0.08884529f, -0.06938485f, -0.00858362f, 0.01846557f, -0.00052688f, -0.08988429f, 
    -0.02151297f, 0.02705344f, 0.06410871f, 0.00139594f, 0.05536857f, 0.03384168f, 0.00249706f, -0.01437269f, 
    0.02402735f, -0.10108499f, -0.11871439f, -0.05354430f, -0.08637898f, 0.00817759f, 0.04999457f, 0.03841924f, 
    -0.07835134f, -0.06574431f, 0.03104731f, -0.03593817f, -0.07172536f, 0.03320501f, -0.03287481f, 0.04085670f, 
    0.02361906f, 0.01925635f, 0.04610771f, -0.06651171f, 0.02589695f, -0.02224948f, 0.00120228f, -0.03810157f, 
    0.03820172f, -0.11302043f, -0.10143347f, -0.02568569f, -0.08662868f, 0.05220754f, -0.01595566f, -0.14821118f, 
    -0.04574037f, -0.18854879f, -0.12320162f, -0.05306125f, 0.00605135f, -0.02994731f, -0.08014219f, 0.00230445f, 
    -0.03114145f, -0.02152383f, -0.04282195f, -0.09336063f, 0.05542341f, 0.00870369f, -0.04886061f, 0.04414334f, 
    0.01385522f, -0.09420699f, 0.04138381f, 0.05311226f, -0.02555289f, -0.09015955f, -0.11833183f, -0.09623724f, 
    -0.01376776f, -0.08288469f, -0.04742611f, -0.03235609f, 0.01817038f, 0.02730973f, -0.01094582f, 0.04280645f, 
    -0.12382863f, 0.03870788f, -0.09736580f, -0.08041684f, -0.07095774f, -0.07551495f, -0.11071901f, 0.05908018f, 
    -0.00403459f, -0.00019697f, -0.08831796f, -0.05068497f, -0.03539776f, -0.05303422f, -0.03820914f, -0.08555261f, 
    0.05934110f, -0.06516808f, -0.00790315f, -0.11593794f, -0.04873208f, 0.07550814f, 0.02899682f, -0.03674797f, 
    -0.06795947f, -0.06567946f, -0.02721561f, -0.02497935f, 0.02122264f, -0.04461991f, 0.02642618f, 0.04343190f, 
    0.03031817f, 0.03627813f, -0.09173249f, -0.02319756f, 0.04623088f, 0.04318978f, -0.01310753f, -0.10840055f, 
    0.00302177f, -0.07673712f, 0.02483502f, 0.00548196f, -0.06802710f, -0.00097182f, 0.02265855f, -0.10320999f, 
    -0.08551124f, 0.02163541f, -0.05955623f, -0.01614298f, -0.04851702f, 0.06326494f, 0.00366703f, -0.05419333f, 
    -0.05525162f, 0.02654459f, 0.03637584f, -0.09576658f, -0.06662942f, -0.03868490f, 0.03279512f, -0.03159083f, 
    -0.15122031f, -0.13272151f, -0.04155477f, 0.21871011f, 0.09247061f, -0.19865555f, -0.06362443f, 0.10556085f, 
    0.18661059f, 0.34891108f, 0.24340898f, -0.26804218f, -0.04889019f, -0.11029158f, 0.17778200f, -0.43087354f, 
    -0.13583373f, -0.51469254f, 0.07691883f, 0.38152292f, 0.06221047f, 0.39111984f, 0.00573133f, -0.10506304f, 
    0.02676012f, -0.11855824f, 0.16988400f, 0.11360895f, 0.07193214f, 0.08069195f, 0.05076816f, 0.00627214f, 
    0.16925448f, -0.12287949f, -0.33669820f, 0.34367681f, -0.20457363f, 0.06929086f, 0.20580143f, 0.19551729f, 
    0.23724160f, 0.10631977f, 0.07137251f, -0.23585516f, 0.15893462f, 0.00029094f, -0.16582671f, -0.16211300f, 
    0.31319860f, 0.18197210f, 0.48010206f, 0.47294924f, -0.04210168f, -0.01478631f, 0.09334401f, 0.03837627f, 
    -0.04235738f, -0.15099175f, 0.30908084f, -0.28156492f, -0.11197730f, 0.38740903f, 0.24091692f, 0.05051931f, 
    -0.19744308f, -0.12180808f, 0.06568485f, -0.04230058f, -0.31350201f, 0.11898267f, 0.12394272f, -0.00941912f, 
    0.07101201f, 0.31399035f, 0.10837884f, 0.01526549f, -0.33106506f, -0.07723280f, -0.00619330f, 0.01504376f, 
    0.04443865f, -0.36283961f, 0.15665141f, -0.37807018f, 0.02246698f, -0.08418637f, -0.13836144f, -0.11618964f, 
    -0.06289581f, 0.19158304f, -0.35723016f, -0.13398059f, -0.53354639f, -0.19894788f, 0.00597446f, -0.06438632f, 
    -0.12603115f, -0.00628857f, 0.08015957f, 0.20996429f, 0.04049452f, -0.01713268f, 0.31344038f, -0.18407813f, 
    -0.24349108f, 0.11086869f, -0.09283451f, 0.25657251f, -0.18098098f, -0.33244541f, -0.04047962f, 0.13022128f, 
    -0.25643909f, 0.20126942f, -0.05974544f, -0.23304808f, 0.11810219f, -0.04402887f, -0.04965738f, 0.17177169f, 
    -0.19046444f, -0.12128640f, 0.16728015f, 0.08498885f, 0.32675600f, 0.05201994f, -0.16353905f, -0.20751804f, 
    0.73294139f, -0.03659856f, 0.06581193f, 0.01732875f, -0.12163224f, -0.08886845f, -0.31748882f, 0.12282816f, 
    -0.24772729f, 0.21226126f, 0.17891090f, -0.07987205f, 0.18079993f, 0.00007191f, -0.16715856f, -0.21509744f, 
    0.07755172f, -0.42900917f, -0.01534426f, 0.05989194f, -0.17573868f, 0.15096529f, 0.03360278f, 0.22391179f, 
    0.07775178f, 0.05219479f, -0.02796121f, 0.01773925f, -0.01840225f, 0.24334738f, -0.11725620f, 0.00697110f, 
    0.14691366f, 0.09457506f, -0.13766134f, 0.20595081f, -0.01114521f, 0.25370893f, 0.13152075f, -0.11622320f, 
    -0.30030093f, 0.03432435f, 0.14981462f, 0.18611230f, 0.11549892f, 0.13505866f, -0.36453781f, -0.20667642f, 
    0.36128426f, -0.15784369f, 0.42902461f, 0.23163669f, -0.03626792f, 0.06164360f, -0.07623092f, 0.10416202f, 
    0.15152350f, -0.02408271f, 0.07446612f, -0.25805214f, -0.10227292f, 0.05612971f, -0.02327535f, 0.13435261f, 
    0.08910667f, 0.18389073f, 0.05449397f, 0.01473797f, 0.24713126f, -0.14014332f, 0.28256717f, 0.01297304f, 
    0.15617460f, 0.32691509f, 0.08415867f, 0.13304357f, -0.15758973f, 0.33749825f, 0.09001073f, 0.06880379f, 
    0.05448766f, -0.23460022f, 0.18811120f, 0.10186259f, 0.02864523f, 0.05788461f, -0.14525838f, 0.09075870f, 
    -0.07150630f, 0.58813727f, 0.01606663f, 0.29784176f, -0.18647324f, 0.06443539f, 0.05080145f, 0.22044191f, 
    -0.03179073f, 0.04979146f, -0.02349733f, 0.00526749f, -0.01039308f, -0.06661913f, 0.08634676f, -0.04671955f, 
    0.10558791f, -0.08596791f, -0.02032665f, 0.06939337f, -0.03880716f, 0.10634188f, 0.03966501f, 0.41488010f, 
    -0.02749791f, -0.06370551f, 0.01559907f, 0.06123010f, 0.31583682f, 0.08650041f, -0.36391699f, 0.19231124f, 
    -0.03611099f, 0.12007768f, 0.18446399f, 0.08621226f, 0.16906779f, 0.09273654f, -0.32288983f, -0.08643930f, 
    0.02203019f, -0.22400922f, -0.13264656f, -0.10065039f, -0.48355025f, -0.18869580f, -0.12310403f, 0.03608089f, 
    0.14147088f, 0.48485968f, 0.07653156f, 0.11613207f, 0.30507651f, -0.02261690f, 0.17937304f, -0.06642043f, 
    0.19138068f, -0.14566012f, 0.17090549f, 0.20341851f, -0.00707822f, 0.21556120f, 0.04229385f, 0.03100513f, 
    0.19436611f, 0.21056783f, -0.15939598f, 0.01652383f, -0.05063266f, 0.10422423f, 0.24695556f, 0.16559286f, 
    -0.11687078f, 0.08901094f, 0.24599034f, -0.01677362f, 0.02409375f, -0.05426117f, -0.06771363f, 0.08329925f, 
    -0.08053250f, 0.58735627f, 0.02458254f, 0.20341465f, 0.07356338f, -0.11584243f, 0.03859494f, 0.04427773f, 
    0.16214840f, 0.16217932f, 0.30203184f, 0.02182290f, -0.04281558f, 0.04492079f, -0.17876378f, 0.11803631f, 
    -0.10523322f, 0.26970771f, 0.11553077f, -0.15399213f, -0.05968118f, -0.54702401f, -0.27011821f, -0.10225281f, 
    0.42001539f, 0.09687413f, 0.11424875f, 0.02608478f, 0.04663640f, 0.03191523f, 0.09520308f, -0.08843639f, 
    0.00325339f, 0.11495664f, -0.01980982f, 0.10513549f, 0.15722667f, 0.37805253f, 0.06426080f, -0.12419339f, 
    0.00677752f, -0.08782149f, 0.20473114f, 0.42769587f, 0.00928797f, -0.02284483f, -0.18968101f, 0.10003865f, 
    -0.09552313f, 0.27858824f, -0.26721796f, 0.25187033f, -0.10009678f, -0.07307482f, 0.03017566f, -0.01217554f, 
    -0.02561642f, 0.01213276f, 0.19320159f, 0.08658111f, 0.05048770f, 0.26376474f, -0.42931327f, -0.09378529f, 
    0.16659632f, -0.18632971f, -0.10885250f, 0.04385109f, 0.07203018f, 0.01724437f, 0.01134403f, 0.31674230f, 
    0.09271737f, -0.06395261f, 0.06068467f, 0.49683696f, 0.13088733f, -0.00153325f, -0.24803340f, 0.02802247f, 
    0.06878681f, 0.07612336f, 0.36198789f, 0.03727792f, 0.24417497f, 0.06216460f, 0.04758349f, -0.08687228f, 
    0.04543673f, 0.03219524f, 0.00815548f, -0.06649487f, 0.05124687f, 0.03567460f, 0.00707851f, -0.08027665f, 
    0.07176856f, -0.09413565f, -0.03726672f, 0.06446932f, -0.03251890f, 0.03433041f, -0.05097743f, -0.02797908f, 
    -0.10665324f, -0.02209169f, -0.08328968f, 0.01696264f, 0.00261244f, -0.02411289f, -0.02574581f, -0.09582300f, 
    -0.11383569f, 0.01160039f, 0.05596783f, 0.06858596f, 0.06125437f, -0.09932742f, -0.03361590f, -0.02906271f, 
    -0.04417023f, 0.03198868f, -0.03676887f, -0.02036304f, -0.01456178f, -0.05145356f, 0.04183764f, -0.03633816f, 
    -0.02526428f, -0.04689009f, -0.07737041f, 0.00228625f, -0.09170566f, 0.04216591f, 0.02631384f, -0.09752329f, 
    -0.00409973f, 0.00267157f, -0.04889899f, 0.04829000f, -0.00920987f, 0.00090403f, -0.09920264f, -0.01269130f, 
    -0.07437206f, -0.09763136f, 0.02936182f, -0.00846233f, 0.02939857f, -0.13154095f, -0.02379617f, 0.01947785f, 
    0.04981859f, -0.10066777f, 0.00149437f, 0.02774265f, 0.07028160f, -0.05600145f, -0.07482916f, -0.02352547f, 
    0.00172795f, -0.05459271f, 0.03440687f, 0.05063153f, -0.03962925f, -0.08301948f, -0.01580867f, 0.03264852f, 
    -0.04347948f, 0.04662958f, 0.01462287f, 0.01099656f, -0.00799604f, 0.03863356f, -0.07213476f, -0.03306515f, 
    0.02174190f, -0.02495449f, 0.03959987f, -0.09456394f, -0.03418615f, -0.07598364f, -0.03092617f, 0.04716435f, 
    -0.01759161f, -0.04042865f, -0.03158121f, 0.05582781f, -0.03719872f, -0.11053223f, -0.05821559f, -0.04599695f, 
    -0.01592728f, -0.04731460f, 0.05929317f, -0.00394690f, -0.03711969f, -0.05977541f, 0.01051157f, 0.07333124f, 
    0.04159285f, -0.11045203f, -0.09268662f, -0.03218185f, 0.01111173f, -0.10239366f, -0.09767449f, 0.04285916f, 
    0.04967567f, -0.00180148f, -0.06417406f, -0.04743610f, -0.06712691f, -0.08475426f, -0.10071778f, 0.08064873f, 
    0.04217794f, 0.01376436f, 0.26986858f, 0.14881758f, 0.16696595f, -0.04029911f, -0.34329584f, 0.13334550f, 
    -0.41418043f, -0.57792318f, 0.25172877f, 0.23457758f, -0.09547087f, 0.06739271f, -0.25041747f, 0.19146033f, 
    -0.26991886f, 0.15957895f, -0.07690461f, 0.02879504f, 0.15595777f, 0.01288334f, 0.08421931f, -0.10452337f, 
    -0.26075798f, 0.00293056f, 0.05302342f, 0.06398372f, -0.14250335f, -0.22698604f, -0.33522364f, 0.02641731f, 
    0.07027391f, 0.03515174f, -0.40788913f, 0.00812470f, -0.14091532f, -0.17483087f, 0.08258024f, -0.37593254f, 
    -0.21383829f, -0.29236910f, -0.00513175f, 0.03571935f, -0.04262482f, 0.11674298f, 0.05403214f, -0.07536384f, 
    0.09315123f, -0.14293441f, 0.22537635f, -0.16966569f, -0.08630572f, 0.05794934f, 0.07016130f, 0.06564236f, 
    -0.01423055f, -0.06141528f, 0.08463747f, 0.04523786f, 0.18008114f, 0.10643405f, -0.09003635f, -0.01738169f, 
    -0.17649555f, 0.07419351f, -0.17792201f, -0.01207648f, 0.10184941f, -0.07776774f, 0.02557394f, 0.04978987f, 
    -0.09229210f, -0.03798959f, 0.05825672f, 0.04466347f, 0.21511634f, -0.15957834f, 0.04105331f, 0.06670845f, 
    -0.27948666f, -0.04810641f, 0.15107448f, -0.14895153f, 0.04166665f, -0.04850681f, 0.08792354f, 0.11439545f, 
    -0.02831572f, 0.29587969f, -0.39133483f, -0.23479083f, -0.06209427f, -0.04152039f, -0.01078522f, 0.24055524f, 
    0.17407236f, 0.03762477f, -0.19635788f, 0.16316202f, 0.14960662f, 0.05435588f, 0.28200054f, 0.08540574f, 
    0.09380895f, 0.10359555f, -0.05321571f, 0.16930372f, 0.11716317f, 0.09317375f, -0.07113590f, -0.05495536f, 
    -0.19032905f, 0.15884788f, 0.24523398f, -0.11743216f, 0.15824112f, 0.09660200f, 0.08788892f, 0.10326175f, 
    0.09276965f, -0.02033910f, -0.16712278f, 0.09218500f, -0.04115755f, 0.05686756f, 0.04018028f, 0.08123267f, 
    -0.13269787f, 0.06271554f, 0.18213879f, -0.06159002f, -0.09651055f, 0.22586560f, -0.18741061f, -0.17184651f, 
    -0.08992959f, -0.23229767f, 0.02736589f, 0.07366637f, 0.16481392f, 0.05060300f, -0.16830733f, 0.09609412f, 
    0.09282113f, 0.17751570f, -0.09199303f, -0.18713710f, -0.00021763f, -0.22981437f, 0.01165153f, 0.22042325f, 
    -0.08031439f, 0.05368504f, 0.25737396f, -0.09712135f, -0.04880955f, 0.00137550f, -0.00047182f, -0.04871860f, 
    0.03691384f, 0.10885166f, 0.17214642f, -0.24311173f, 0.42093942f, -0.03491313f, -0.24042493f, -0.29968581f, 
    -0.01174102f, -0.24159828f, 0.08500867f, 0.24432012f, -0.04553376f, 0.14031324f, -0.06052434f, 0.10276422f, 
    -0.12538171f, 0.09802038f, -0.14224589f, -0.08446474f, -0.01282862f, 0.11050503f, 0.16508321f, 0.17175879f, 
    0.38666987f, 0.03565275f, -0.23855016f, -0.00396024f, 0.25036579f, 0.08264325f, 0.17042044f, 0.19425046f, 
    -0.09593478f, 0.19024292f, 0.30760613f, 0.08935889f, 0.27175090f, 0.04429016f, -0.05868553f, -0.03479123f, 
    0.19246387f, -0.17363389f, 0.04697495f, -0.06208749f, -0.00022603f, -0.00181542f, 0.05250925f, 0.16210049f, 
    0.00030157f, 0.05304244f, -0.15873304f, 0.19278507f, 0.03538021f, 0.01780560f, 0.42630851f, 0.06957123f, 
    0.08524930f, 0.01635062f, 0.00324722f, -0.24591893f, 0.03221206f, 0.03110423f, 0.05747422f, -0.00100661f, 
    0.29382059f, -0.07534545f, 0.14286062f, -0.11459883f, -0.06732408f, -0.16404349f, -0.11334452f, 0.01412128f, 
    -0.00221063f, 0.08213301f, -0.09545276f, -0.22186014f, 0.20536125f, 0.10852830f, 0.16132852f, -0.34784409f, 
    0.08916561f, -0.01432163f, 0.20023891f, -0.06416065f, -0.07168019f, 0.02029159f, -0.00100022f, -0.02040797f, 
    0.04930438f, 0.17904814f, -0.27914232f, -0.13312699f, -0.14657791f, -0.03107339f, -0.10720553f, 0.54779375f, 
    0.23335256f, 0.18699871f, 0.02669230f, -0.02439980f, 0.05697591f, 0.13957152f, -0.14872727f, -0.19277281f, 
    -0.18310976f, -0.32138753f, 0.03666276f, -0.08581188f, 0.30951777f, -0.12018583f, -0.37192175f, 0.08615756f, 
    -0.07894011f, 0.15540028f, -0.03426560f, -0.09038777f, -0.32986879f, -0.17370474f, -0.09149406f, 0.07616112f, 
    0.02331547f, 0.16746745f, 0.19360600f, -0.31855735f, -0.08889914f, 0.01623162f, -0.41031289f, -0.02595924f, 
    0.03456809f, 0.35839874f, 0.48139414f, -0.10984965f, 0.34952044f, -0.02021248f, 0.06972202f, -0.20610741f, 
    0.04107752f, -0.30806890f, 0.09349497f, 0.21037467f, -0.05933191f, 0.03726622f, 0.04102940f, -0.15499379f, 
    0.03797307f, -0.19925550f, -0.10880309f, -0.43040758f, -0.02808191f, -0.05253878f, 0.15961480f, 0.25100499f, 
    0.04113237f, -0.58293444f, -0.10690682f, 0.17448188f, 0.10042309f, -0.09383248f, -0.05051665f, 0.02309771f, 
    -0.00080495f, 0.10044368f, 0.33879530f, 0.00700157f, 0.03383552f, -0.30834010f, 0.17581272f, -0.03344039f, 
    -0.15098292f, 0.12324250f, 0.30368972f, 0.16305217f, -0.01166323f, -0.05471665f, 0.28424829f, 0.09072883f, 
    -0.09030689f, 0.17330094f, -0.31485382f, 0.07004896f, 0.02127581f, -0.08271572f, 0.06522008f, 0.07181414f, 
    -0.05491617f, 0.01956716f, -0.20055741f, 0.27991325f, -0.14206956f, 0.11917844f, 0.06531624f, 0.05463219f, 
    0.13997442f, -0.05649213f, -0.29176813f, -0.19749676f, -0.08780603f, -0.17391565f, -0.38611403f, -0.08997931f, 
    0.05836885f, 0.13520305f, -0.00694325f, 0.00506644f, 0.27591598f, 0.24482721f, -0.09501404f, -0.02949330f, 
    -0.06374483f, -0.13999890f, 0.12243115f, -0.35005447f, -0.18588227f, 0.19875146f, 0.08990684f, 0.11562587f, 
    -0.11431681f, -0.18806659f, -0.04362201f, -0.26567438f, -0.03702822f, -0.32325050f, 0.05824460f, 0.22395833f, 
    -0.39235985f, -0.25606227f, 0.27019703f, 0.14131723f, -0.31592146f, -0.15959245f, -0.04216075f, -0.12111361f, 
    -0.15562910f, -0.02791806f, 0.34782240f, 0.07238547f, 0.00533193f, 0.11340748f, 0.19140716f, -0.24704143f, 
    0.08210286f, -0.03912904f, -0.08790173f, 0.04045151f, 0.12386203f, 0.39811337f, 0.04063633f, -0.22778302f, 
    0.11600485f, 0.07025449f, 0.20338129f, 0.01075125f, 0.05204730f, -0.01223346f, 0.08341727f, 0.16968730f, 
    0.17029345f, -0.10657312f, 0.27588466f, 0.11664327f, -0.15753125f, -0.18844490f, -0.12062553f, 0.08455563f, 
    -0.42194623f, 0.39838615f, 0.09157108f, -0.19279118f, -0.11975154f, -0.04507656f, 0.17374629f, 0.04160918f, 
    0.23986509f, 0.13079984f, 0.66039538f, -0.14014986f, 0.10042243f, 0.33634511f, 0.15267316f, 0.05463365f, 
    0.07103225f, 0.10841842f, 0.29027566f, -0.19094138f, 0.09040365f, -0.04533033f, 0.00403763f, 0.04572190f, 
    0.31044298f, 0.14260788f, -0.06972111f, -0.12297573f, -0.46754572f, 0.04510934f, -0.05504143f, -0.03759817f, 
    0.02595324f, -0.13449316f, 0.13079725f, 0.06190608f, 0.10634612f, -0.44822639f, 0.23024431f, -0.02840159f, 
    -0.15284657f, -0.21533540f, 0.18211007f, -0.05324085f, -0.01682140f, 0.03566793f, 0.01170750f, 0.03072689f, 
    -0.03106596f, 0.36757103f, 0.04091134f, 0.03624399f, -0.20413958f, -0.06211094f, 0.07547022f, 0.06131532f, 
    -0.04488098f, -0.07605899f, 0.14077725f, 0.12833820f, 0.06126981f, 0.25540322f, -0.33844507f, -0.03437309f, 
    -0.01912478f, -0.15917428f, -0.17572767f, 0.01894794f, -0.16339298f, -0.27573630f, -0.15698813f, -0.06696034f, 
    -0.27204075f, 0.11469123f, 0.23276263f, 0.13678761f, -0.10114091f, -0.09189641f, -0.14354292f, 0.23930374f, 
    0.15388748f, 0.20619385f, -0.07309877f, -0.02799918f, -0.17394106f, 0.03815996f, -0.19883585f, -0.25400415f, 
    0.21763183f, 0.11213253f, 0.11861650f, 0.05327213f, 0.07304098f, 0.06506942f, -0.30618593f, 0.09010684f, 
    0.05503158f, 0.00381936f, 0.14479275f, 0.09337313f, 0.05791698f, 0.01056175f, -0.06381655f, 0.10930151f, 
    0.17716029f, 0.16870096f, -0.40634954f, -0.21525846f, -0.08966975f, -0.09626442f, 0.00640971f, 0.32530025f, 
    -0.16632861f, 0.16744414f, 0.08070828f, 0.03049555f, -0.07617043f, 0.05157961f, -0.01602393f, 0.04416682f, 
    -0.15355670f, 0.26349971f, 0.07097925f, 0.07394634f, 0.25615001f, -0.02708544f, -0.06344870f, -0.23595540f, 
    -0.17902225f, -0.09491754f, 0.14704396f, 0.38002095f, 0.19181313f, 0.34699464f, -0.20418324f, 0.02139654f, 
    0.18071914f, -0.03812174f, -0.01965473f, -0.21717581f, -0.06664567f, -0.06333853f, -0.10065883f, 0.05455618f, 
    -0.01426191f, 0.00774059f, -0.09305127f, -0.01170916f, -0.01405425f, -0.14391345f, -0.05716700f, 0.04913985f, 
    0.23824385f, 0.35781580f, -0.03941620f, 0.05676636f, 0.27402648f, -0.08446521f, 0.31303659f, -0.18308282f, 
    -0.08122182f, 0.08990161f, 0.06691454f, 0.14220572f, 0.09791488f, 0.28173161f, 0.28105399f, 0.13152461f, 
    0.04297103f, 0.13718016f, 0.00942848f, 0.25331032f, -0.02556308f, 0.06931531f, 0.05319015f, 0.27806017f, 
    0.06309038f, 0.34364784f, -0.50515181f, 0.22507702f, 0.20198007f, -0.11485567f, -0.00610395f, -0.02127465f, 
    0.13569884f, -0.01324222f, -0.02437627f, -0.07375738f, -0.03966211f, -0.05976144f, 0.17286757f, 0.04175296f, 
    0.07664893f, 0.26763341f, 0.27674389f, 0.02710292f, 0.35558155f, 0.31585607f, 0.17185584f, 0.22628511f, 
    0.26028341f, -0.01139531f, 0.32603824f, 0.23618224f, 0.13059793f, 0.16432020f, -0.19093673f, 0.04189679f, 
    -0.00385016f, 0.13579890f, -0.02285174f, -0.03150431f, 0.10691990f, 0.12194660f, 0.01783431f, 0.31126744f, 
    0.17654748f, -0.02987296f, 0.02473262f, -0.00893045f, 0.15061070f, -0.09321368f, -0.32088199f, -0.25094676f, 
    -0.29371053f, 0.04575056f, 0.08813897f, -0.35382152f, 0.14096707f, -0.19309700f, -0.04901956f, -0.21449034f, 
    -0.03881996f, -0.35425836f, 0.03366694f, -0.13185489f, -0.18274817f, 0.09488539f, -0.06928258f, 0.11188039f, 
    0.08952926f, 0.14373136f, 0.04768310f, -0.02502482f, -0.16561396f, 0.10284988f, 0.01277540f, -0.04643362f, 
    0.21057585f, 0.01768869f, 0.00867321f, 0.12658589f, 0.15463936f, 0.17588466f, 0.17133673f, -0.31638542f, 
    -0.27228662f, -0.01142874f, 0.20861921f, 0.20237690f, 0.01508426f, -0.01992321f, -0.60562396f, -0.36299279f, 
    0.10151775f, 0.03045249f, 0.22733472f, 0.15633802f, 0.09829234f, -0.00361640f, 0.09257788f, 0.15107092f, 
    0.12102467f, -0.14717409f, 0.07742679f, -0.04718736f, -0.03895354f, 0.04001106f, 0.11070161f, 0.15049979f, 
    -0.03231723f, -0.10373342f, 0.11822427f, -0.00577394f, 0.00085865f, -0.00968316f, 0.21240698f, 0.07305479f, 
    0.05206186f, 0.12162881f, -0.09796265f, 0.06757253f, -0.32684642f, -0.17151625f, -0.04654597f, 0.09749077f, 
    0.14361520f, -0.16285081f, 0.02078236f, -0.40987504f, -0.03132146f, 0.07593761f, -0.08815204f, -0.12032874f, 
    0.01510509f, 0.22546053f, 0.26912686f, 0.06792010f, -0.19060963f, 0.27018383f, 0.02189768f, -0.27025923f, 
    0.08747691f, 0.03786829f, 0.09094120f, 0.04979300f, 0.00827576f, -0.17441384f, -0.11158286f, -0.15189749f, 
    0.13009158f, -0.05287905f, -0.03966292f, 0.16016836f, -0.08610319f, -0.05453484f, -0.00126877f, 0.06761795f, 
    -0.18187228f, -0.20726083f, -0.07399393f, 0.09179457f, 0.16084652f, 0.09779505f, -0.00937966f, 0.16125067f, 
    -0.37724888f, -0.11855158f, -0.12220795f, 0.03514532f, 0.34875059f, -0.01590083f, -0.26158318f, -0.16587503f, 
    0.42432758f, 0.06393579f, -0.09155172f, -0.22580887f, -0.08259591f, 0.15631743f, 0.10866881f, 0.39296654f, 
    0.40110180f, 0.09615069f, -0.18038763f, -0.06629838f, 0.13162580f, -0.07458082f, 0.07976461f, 0.18230793f, 
    0.19209525f, 0.04213996f, -0.06983574f, -0.41465172f, 0.01146007f, -0.09078851f, 0.06734861f, 0.35972503f, 
    0.26911342f, -0.50054252f, -0.01482670f, 0.17701012f, 0.12845170f, -0.10491642f, 0.20885175f, 0.04590506f, 
    0.03129644f, -0.02500346f, -0.21716195f, 0.11347238f, 0.02692517f, 0.32367599f, 0.00813017f, -0.24847794f, 
    0.16479896f, -0.26851043f, 0.15432106f, -0.05136862f, 0.19361880f, -0.06904308f, -0.14916323f, 0.00838026f, 
    -0.04844170f, 0.06341905f, -0.40632695f, -0.18307105f, -0.01441690f, -0.00359050f, 0.06421927f, 0.02415304f, 
    -0.21216945f, 0.10694911f, -0.15258123f, -0.19757302f, -0.28301245f, -0.01926558f, 0.19138111f, -0.22043470f, 
    -0.04721055f, -0.02867422f, -0.29885975f, -0.10977130f, 0.31729507f, 0.08208341f, -0.06095357f, 0.08562700f, 
    0.42187831f, 0.00808876f, -0.05365265f, 0.07138826f, -0.13094783f, 0.44308200f, -0.13498086f, 0.11513498f, 
    0.39855921f, 0.01731363f, 0.15212978f, 0.31195539f, 0.01803130f, -0.03848496f, 0.13028271f, -0.02373309f, 
    -0.06361333f, -0.15067758f, 0.37291199f, 0.03272217f, 0.21782564f, -0.31948382f, -0.08582518f, -0.28016451f, 
    0.00048411f, 0.00150670f, 0.11722509f, -0.22496703f, -0.29388824f, -0.36849144f, 0.00645900f, 0.09795290f, 
    -0.49507153f, 0.14264397f, 0.02020295f, 0.04330714f, 0.02673861f, 0.04556746f, 0.35083488f, 0.31896934f, 
    0.30010733f, -0.07669858f, -0.35393813f, -0.00219971f, 0.09375285f, -0.15756612f, 0.00435360f, -0.12026728f, 
    0.02456035f, -0.00957662f, 0.19485559f, -0.11014329f, 0.20218307f, 0.09205055f, -0.22993705f, 0.19922146f, 
    -0.30429786f, -0.09180130f, -0.08093273f, 0.06119567f, -0.13362789f, -0.08043827f, -0.17925200f, 0.15423372f, 
    -0.16664578f, 0.66116017f, 0.10054926f, 0.05892766f, 0.07670125f, -0.03623600f, 0.14743812f, -0.14446019f, 
    -0.05002340f, 0.02714898f, 0.12855856f, 0.08860845f, 0.18025149f, 0.28379080f, -0.06350920f, -0.17595685f, 
    -0.10622335f, 0.11927927f, 0.11502019f, 0.06359653f, -0.03623364f, -0.10957746f, 0.21327400f, 0.23441619f, 
    -0.10631202f, 0.11742869f, 0.29183483f, 0.11766175f, 0.01647748f, -0.06273249f, 0.15357311f, -0.29865831f, 
    -0.32107484f, 0.67166752f, 0.04120588f, 0.20506062f, 0.11399218f, -0.01227835f, 0.15510766f, 0.02335820f, 
    0.08683187f, 0.25826219f, 0.13128510f, -0.64480031f, 0.08563387f, -0.02022339f, 0.14519408f, 0.06289245f, 
    -0.11143324f, 0.08656094f, 0.24508323f, -0.05087825f, -0.22323062f, -0.26706064f, -0.01254572f, 0.00878324f, 
    0.22735547f, 0.08964895f, -0.21083491f, -0.01833117f, -0.11273004f, -0.02255108f, 0.04545316f, -0.19050616f, 
    -0.17716329f, 0.10817066f, 0.04936470f, 0.01322510f, 0.15251695f, 0.01029997f, 0.04138534f, -0.22787841f, 
    -0.01998904f, 0.00834161f, 0.02174159f, 0.11429069f, 0.06823900f, 0.02956630f, -0.20855163f, -0.08532207f, 
    -0.03026514f, 0.04538960f, -0.23378660f, 0.12146679f, -0.05615147f, -0.14986442f, 0.02485888f, 0.00665306f, 
    -0.00504191f, -0.05983533f, 0.08789243f, 0.09957912f, 0.15811333f, -0.04561304f, -0.02338840f, 0.05519493f, 
    -0.17037237f, -0.01187332f, -0.00511166f, 0.31136224f, -0.02115791f, -0.04958687f, -0.02912466f, 0.06754703f, 
    0.08931996f, 0.11242025f, -0.08388016f, 0.15538849f, -0.02192256f, -0.13969053f, -0.04365126f, 0.10639541f, 
    0.03738192f, -0.06277397f, 0.37980267f, 0.10530069f, 0.08568615f, 0.12694123f, 0.00381439f, -0.10079852f, 
    -0.00575567f, 0.05157937f, 0.06436413f, -0.07330734f, -0.02630289f, -0.03544965f, 0.02656976f, -0.05545321f, 
    0.08365891f, -0.04398548f, -0.09529042f, 0.05764406f, -0.07782149f, 0.06614812f, 0.01437629f, 0.03387957f, 
    -0.10020938f, 0.06689476f, -0.01842886f, 0.02431479f, 0.02395078f, -0.05015258f, -0.01888049f, 0.04559467f, 
    -0.04857412f, -0.06206359f, -0.04095052f, 0.04596814f, 0.05921112f, -0.05719825f, 0.05825246f, 0.03267776f, 
    -0.07988795f, -0.06482226f, -0.00515403f, -0.02411724f, 0.07871209f, 0.00138653f, 0.05646606f, -0.03817371f, 
    0.00831106f, -0.06929384f, -0.07340252f, 0.07069234f, -0.00718799f, -0.00459696f, -0.05116115f, -0.09385674f, 
    -0.08828552f, -0.08383916f, -0.05132763f, 0.06598050f, 0.08480498f, -0.01800990f, 0.01117057f, -0.09949674f, 
    -0.05896208f, -0.00583703f, 0.05361657f, 0.00683533f, 0.03313476f, 0.05617120f, -0.01207104f, 0.05474165f, 
    0.06036628f, -0.00272662f, -0.07933093f, -0.01334249f, -0.08450899f, 0.03862079f, -0.01617737f, 0.08325806f, 
    0.06899161f, -0.05128946f, -0.05883332f, 0.01636676f, -0.01463258f, 0.03292835f, 0.00326403f, 0.02329258f, 
    -0.09055673f, -0.06951272f, -0.06581663f, -0.07772511f, 0.06827306f, 0.08772754f, -0.08315563f, -0.07489011f, 
    -0.08302456f, 0.02454038f, -0.02521705f, -0.06035257f, -0.03477094f, -0.04331732f, -0.01209873f, 0.05715002f, 
    0.01057022f, -0.05339464f, 0.03860485f, 0.06373052f, -0.03359089f, 0.04496214f, -0.08650294f, -0.07522677f, 
    -0.02186540f, -0.07205475f, -0.08547051f, 0.02876371f, -0.00536193f, -0.06477070f, -0.02371497f, 0.02235807f, 
    -0.09007560f, -0.10207519f, -0.04484639f, 0.08591504f, 0.05727227f, -0.04219710f, 0.07260685f, -0.10055710f, 
    -0.07784116f, 0.07370839f, -0.04293786f, -0.09328908f, -0.08527996f, -0.07626071f, -0.08458980f, 0.04340300f, 
    -0.06554097f, -0.06703370f, 0.05083508f, 0.06997237f, -0.03945369f, -0.07916714f, -0.00469234f, -0.00775478f, 
    -0.05635566f, 0.05657751f, -0.05591327f, -0.05822536f, -0.08477746f, 0.01156787f, -0.05598695f, 0.02967718f, 
    0.01955538f, -0.03341849f, -0.03140075f, 0.05294157f, 0.00251303f, -0.08306015f, -0.00918097f, -0.01639479f, 
    -0.08958022f, -0.04342919f, 0.01464196f, 0.01035512f, 0.07606658f, -0.01689726f, -0.01871703f, 0.07991504f, 
    0.02739910f, 0.04223133f, 0.01727330f, 0.00265643f, 0.03512393f, -0.04675338f, -0.07453036f, 0.05677237f, 
    -0.06179179f, -0.07351556f, 0.03591436f, 0.04095017f, -0.00380064f, -0.02182382f, -0.02084465f, 0.05782869f, 
    0.03652132f, -0.03052006f, 0.03690741f, -0.00408020f, 0.06605842f, -0.03858785f, -0.04471380f, 0.04015843f, 
    -0.09414303f, -0.06355219f, 0.05008615f, 0.04712601f, -0.08669971f, -0.03009006f, 0.02600452f, 0.01618342f, 
    -0.08495893f, -0.08614805f, -0.04260722f, -0.08357724f, 0.01338848f, -0.07977150f, -0.04703374f, 0.00210545f, 
    -0.03908838f, -0.08241234f, 0.05498112f, 0.02403975f, -0.03939467f, -0.04953565f, 0.02253015f, -0.09155762f, 
    0.06964911f, 0.03420969f, 0.00489793f, -0.07836366f, -0.00275398f, -0.02762051f, -0.05628720f, -0.04554478f, 
    -0.07688297f, -0.02838570f, 0.03604021f, -0.08600873f, 0.00805773f, -0.07878538f, -0.08683401f, -0.03521746f, 
    0.06913178f, -0.01707852f, 0.04823280f, 0.05458040f, 0.07083459f, -0.00138251f, 0.05565524f, -0.06567381f, 
    -0.05660675f, 0.00173033f, -0.00802851f, -0.08869576f, -0.00172946f, -0.02520469f, 0.01756933f, 0.02953474f, 
    0.06773336f, -0.07590706f, 0.05666054f, 0.00826534f, -0.08796202f, 0.03858957f, 0.04592790f, -0.09208152f, 
    0.06842777f, 0.06340699f, 0.07450519f, -0.06141292f, 0.00082105f, -0.05983969f, 0.00233192f, 0.00694615f, 
    0.20403564f, 0.20591268f, 0.10462756f, -0.06879713f, -0.00892015f, 0.14370300f, -0.07427435f, -0.36083910f, 
    0.30130154f, -0.36590919f, 0.11206019f, -0.31291226f, 0.16553578f, 0.02884884f, -0.32986391f, -0.02603047f, 
    0.17532653f, -0.13303043f, 0.07351248f, -0.16804031f, -0.24094385f, -0.03683288f, -0.00771396f, 0.12107287f, 
    0.13503410f, 0.11292788f, 0.07080129f, -0.33699176f, 0.03794287f, 0.16968034f, -0.14412351f, -0.05594638f, 
    -0.02972197f, 0.21196552f, 0.33292574f, -0.06977245f, 0.29537040f, 0.23837215f, 0.00927788f, 0.42956194f, 
    0.34484607f, -0.21003361f, 0.07004333f, 0.00343162f, 0.02251386f, 0.09004653f, -0.20492280f, -0.26509193f, 
    0.22091614f, -0.13432367f, 0.03727109f, 0.04242529f, -0.02511238f, -0.01507554f, 0.02831174f, 0.13330279f, 
    0.26031575f, -0.13394326f, 0.05383726f, -0.04943917f, 0.09947456f, 0.24832399f, 0.12511706f, 0.08198531f, 
    -0.02763690f, 0.23771514f, 0.29157990f, 0.04959969f, 0.06380072f, -0.09563622f, -0.07037427f, 0.06951105f, 
    0.21766175f, -0.01410636f, 0.13209604f, 0.15129226f, -0.18085010f, 0.20155486f, 0.09077529f, 0.19850147f, 
    0.01173551f, 0.13433444f, -0.16477349f, 0.13299650f, -0.04431411f, 0.07547377f, 0.04528471f, -0.05580765f, 
    0.01962359f, 0.11286705f, 0.11114333f, 0.39702868f, -0.03300656f, 0.06414914f, -0.00124498f, -0.25328943f, 
    0.20893377f, -0.04042534f, 0.14164072f, -0.22012852f, -0.23807342f, -0.16434921f, -0.31104138f, -0.09196139f, 
    -0.04630651f, -0.02398078f, -0.05174579f, -0.30682433f, 0.01559411f, 0.06299450f, 0.01919359f, -0.15751299f, 
    -0.06469605f, -0.16772862f, 0.16796783f, -0.25091916f, -0.02099439f, 0.27672377f, 0.06381276f, 0.13494636f, 
    -0.14486937f, 0.10092125f, -0.14506672f, -0.29873076f, 0.04517016f, -0.17112260f, 0.16011706f, 0.08440277f, 
    -0.07430036f, 0.02224655f, 0.06081494f, -0.01689834f, -0.00030210f, 0.02836793f, -0.05239663f, -0.02178680f, 
    -0.08305157f, 0.04065410f, -0.10014173f, -0.05368466f, 0.04011029f, -0.06645003f, -0.03252494f, -0.06695152f, 
    -0.07421682f, -0.04795096f, -0.05813409f, 0.00791243f, -0.04369510f, -0.01352621f, -0.07304311f, -0.00051664f, 
    -0.03366994f, -0.04029471f, 0.04222917f, 0.01054770f, -0.08632446f, 0.04324274f, -0.06667840f, -0.04015519f, 
    0.03734206f, -0.04806650f, -0.09537168f, -0.02857645f, -0.09314425f, -0.10914186f, -0.10750810f, 0.05760295f, 
    -0.04667645f, 0.08436738f, 0.03813450f, -0.07096076f, 0.03819136f, 0.04129034f, -0.05786981f, 0.00285032f, 
    -0.02215709f, -0.01506172f, -0.07888234f, -0.08195706f, 0.00386561f, -0.07609485f, -0.02522295f, -0.04888275f, 
    -0.07096528f, 0.06613605f, -0.00507911f, 0.00623888f, -0.10953785f, -0.00407193f, -0.03037801f, -0.09439778f, 
    -0.06068223f, -0.03838974f, 0.05696027f, -0.04503378f, -0.09711424f, -0.08097108f, -0.04310006f, -0.10124153f, 
    -0.10494016f, -0.07826860f, -0.04459995f, -0.06362597f, 0.00817669f, -0.04606440f, -0.02170230f, -0.01138946f, 
    0.04153902f, 0.06456814f, -0.06948579f, 0.01653033f, 0.00334770f, 0.00477421f, 0.02227752f, 0.01673638f, 
    -0.03419205f, -0.04822658f, -0.00111982f, -0.00976276f, 0.06295424f, -0.04315476f, 0.04585899f, -0.01017885f, 
    -0.04210148f, 0.02016631f, 0.03487935f, 0.01886537f, -0.08249289f, 0.02704347f, -0.01194499f, -0.05620612f, 
    -0.03137871f, -0.03497681f, -0.10354060f, 0.05022582f, -0.01934475f, 0.00032064f, -0.10239352f, 0.05459101f, 
    0.00986336f, -0.05708413f, 0.03951816f, 0.02998839f, -0.07967807f, -0.07170419f, -0.05785703f, -0.03587849f, 
    -0.05668870f, -0.00913178f, 0.03525312f, 0.05567348f, 0.01998479f, -0.04412732f, -0.02808345f, 0.03166443f, 
    -0.15205607f, 0.10780818f, 0.00801085f, 0.05295940f, -0.08177070f, 0.27258253f, -0.27543703f, 0.08331086f, 
    0.53626144f, 0.02274828f, -0.16257285f, -0.25076860f, 0.22200336f, -0.02683253f, 0.05432072f, 0.20063941f, 
    -0.12156218f, 0.12298982f, -0.08454776f, 0.07827380f, -0.51633805f, -0.06101782f, -0.07048280f, 0.01774536f, 
    0.06956702f, -0.02708346f, 0.00364472f, -0.36572275f, -0.04167551f, -0.07449910f, 0.08687310f, -0.09025964f, 
    -0.13196112f, 0.05155541f, 0.27265331f, -0.10324251f, 0.06487744f, -0.12950072f, -0.33427131f, 0.53466153f, 
    0.63880223f, 0.08433461f, -0.00175826f, 0.02747066f, 0.02586823f, 0.17954774f, -0.04751946f, 0.24185990f, 
    -0.28310260f, -0.03361592f, -0.53288168f, 0.36136043f, 0.00634460f, -0.13481069f, 0.09483667f, 0.07504155f, 
    0.17774197f, 0.60086250f, -0.73301369f, -0.02357521f, -0.10756468f, 0.24144322f, -0.06429225f, -0.04236010f, 
    0.12414159f, 0.09261881f, 0.12748477f, 0.07521091f, -0.30788895f, -0.64743608f, 0.05075980f, -0.00153328f, 
    0.01494214f, -0.00728855f, 0.00194730f, 0.05673640f, 0.14337645f, -0.00658802f, 0.16874249f, 0.01209765f, 
    0.26973340f, 0.04889638f, -0.34111312f, 0.18946941f, 0.08662150f, 0.05692208f, 0.15232553f, -0.07103328f, 
    -0.05207514f, -0.19669279f, -0.18738298f, 0.12796672f, -0.08644228f, -0.29348153f, -0.00076611f, -0.32376060f, 
    0.05642337f, -0.01093466f, -0.66591698f, -0.26323637f, -0.52302307f, 0.04888938f, -0.84725630f, -0.13480249f, 
    -0.18939526f, 0.28875822f, 0.09928621f, -0.21405320f, 0.06569968f, 0.14810555f, -0.05530672f, -0.08725438f, 
    0.02022034f, -0.13976203f, 0.14128838f, -0.04478339f, -0.50825137f, 0.18784857f, -0.36729494f, 0.07442562f, 
    -0.64393348f, 0.02023468f, -0.16509138f, -0.47552440f, -0.13172108f, -0.52295661f, 0.33311731f, 0.09330080f, 
    0.03526370f, 0.04306831f, 0.05179694f, 0.04651354f, -0.08510868f, -0.02625058f, -0.08370741f, -0.08290154f, 
    0.08216573f, -0.09218467f, -0.04817769f, 0.02843378f, -0.06829592f, 0.06745667f, 0.03581376f, -0.08968271f, 
    0.04545232f, 0.04199965f, -0.03993091f, -0.08414506f, -0.08566872f, 0.02170179f, -0.02490694f, 0.02712133f, 
    0.04234996f, -0.09873299f, 0.04571952f, 0.01491129f, 0.06462681f, 0.00620419f, -0.10457826f, -0.05380528f, 
    -0.09102412f, 0.02648012f, -0.05889214f, -0.06221743f, -0.02155610f, 0.01956064f, -0.01742527f, -0.00137307f, 
    -0.08312074f, -0.05761632f, -0.03265187f, 0.04324634f, -0.07191959f, -0.01021888f, 0.00485150f, -0.08329592f, 
    -0.09288116f, -0.00155679f, -0.09804660f, 0.01199969f, -0.04605871f, -0.07697628f, -0.08609587f, -0.04766141f, 
    -0.07444645f, 0.04918345f, -0.09699462f, 0.03065310f, -0.09134349f, -0.01570060f, -0.03807196f, -0.05184780f, 
    -0.00442641f, -0.03621517f, -0.00511217f, 0.01286093f, -0.06746340f, -0.00523350f, 0.04733209f, 0.00859914f, 
    0.03496194f, -0.12201492f, -0.03424176f, -0.05890516f, -0.08831989f, 0.00372661f, -0.03306906f, 0.06588013f, 
    -0.05604334f, -0.08127290f, 0.04439783f, 0.00493256f, -0.04566288f, 0.04687685f, 0.06027946f, -0.05063253f, 
    0.06301808f, -0.08361293f, 0.03858750f, -0.02693676f, 0.08043745f, 0.03255061f, 0.03379130f, -0.06127877f, 
    0.03520530f, -0.07965612f, 0.03296949f, 0.02780166f, -0.01357430f, -0.07527117f, -0.08572088f, -0.05276525f, 
    0.02501356f, -0.02632546f, 0.00033294f, -0.04503830f, -0.00861483f, -0.02520085f, 0.05511926f, -0.02659228f, 
    0.01365123f, -0.09072100f, 0.07246622f, 0.00245009f, 0.05805829f, -0.08864334f, -0.01359338f, -0.10025825f, 
    -0.00088641f, -0.09562893f, 0.02257538f, -0.08538967f, 0.03867614f, 0.05649099f, -0.00331016f, -0.09599163f, 
    -0.03630650f, -0.00245355f, 0.04747702f, -0.08084197f, -0.06576877f, 0.03479261f, 0.01147116f, 0.02951837f, 
    0.07688515f, -0.03657940f, 0.03069324f, 0.05337245f, -0.02532848f, -0.07472108f, 0.06367947f, 0.00737141f, 
    0.04966845f, -0.10560936f, -0.00504502f, -0.08514512f, 0.01962053f, 0.00254872f, 0.05332433f, 0.03250613f, 
    0.05453661f, -0.01552301f, -0.03126003f, -0.05946720f, -0.03520400f, -0.00780183f, 0.06839855f, -0.03388018f, 
    -0.07922866f, 0.00171144f, -0.06348791f, -0.02381120f, -0.02668369f, -0.08073489f, 0.03406552f, 0.00332964f, 
    0.02785311f, 0.11686908f, -0.02390255f, 0.04438398f, -0.02967425f, -0.04545074f, -0.08616703f, -0.00594718f, 
    0.00757346f, -0.00444917f, -0.08582070f, -0.02187099f, -0.04748940f, -0.07454327f, -0.05500921f, -0.08954416f, 
    -0.02666520f, 0.02264160f, -0.04189400f, -0.08513114f, 0.00342734f, -0.06706995f, 0.12200151f, -0.03156191f, 
    -0.09750956f, -0.02407993f, -0.01026023f, -0.06451263f, 0.00949610f, 0.05180683f, 0.00927179f, -0.06644435f, 
    -0.07192086f, -0.02504019f, -0.02138516f, -0.02634877f, 0.03078120f, -0.04224915f, -0.09507772f, -0.00582748f, 
    0.06967673f, -0.04033332f, -0.04274920f, -0.10312769f, -0.05375911f, -0.06440604f, -0.01444380f, -0.01896478f, 
    -0.04466372f, -0.05867361f, -0.08178250f, 0.04592406f, -0.00041644f, 0.00092284f, -0.05978139f, -0.05495651f, 
    0.02534886f, -0.04530070f, -0.07431936f, 0.04433902f, 0.06587628f, -0.00096733f, -0.03119810f, 0.06684171f, 
    -0.00110742f, 0.03257786f, -0.01517749f, -0.03387498f, 0.03798785f, 0.05311287f, 0.06007045f, -0.04055474f, 
    0.05070763f, -0.00029988f, -0.08908045f, 0.02551622f, -0.02528011f, -0.10841026f, -0.09697036f, -0.10007991f, 
    -0.02362207f, -0.06177905f, -0.10820705f, -0.01439113f, 0.03589154f, -0.07773346f, -0.01478521f, -0.05746755f, 
    0.00700838f, -0.14658222f, -0.05271600f, 0.12116596f, -0.29051957f, -0.20633648f, -0.15976149f, -0.09703104f, 
    0.31512088f, -0.47375581f, 0.14531434f, 0.13696583f, 0.23163317f, 0.07877001f, 0.02603325f, -0.23908404f, 
    -0.02212606f, -0.12568548f, -0.01474333f, 0.10682734f, 0.14345965f, 0.25040236f, -0.00488305f, -0.05909212f, 
    0.13178781f, 0.21851279f, 0.03171618f, 0.16498086f, -0.09429120f, 0.05188821f, 0.06986385f, 0.12979831f, 
    -0.14654681f, -0.04056265f, 0.07430365f, 0.05512439f, -0.07804408f, -0.12076181f, -0.10559075f, 0.44244233f, 
    -0.17140616f, 0.17947206f, -0.02341438f, 0.00329839f, 0.00765199f, 0.09656677f, 0.06931685f, -0.00849878f, 
    0.36595681f, 0.07222054f, 0.40781987f, 0.22313350f, -0.02912173f, 0.13389464f, -0.12087751f, -0.01403287f, 
    -0.14850874f, 0.17688353f, 0.24736612f, 0.09078979f, 0.01510847f, -0.36017394f, -0.22806185f, -0.12089805f, 
    0.37517038f, 0.18833117f, -0.02172885f, 0.04420446f, -0.00307862f, 0.11727867f, 0.04409902f, -0.28688189f, 
    -0.09453876f, 0.00813240f, -0.04862817f, -0.00035738f, 0.13360023f, 0.15140834f, 0.19060409f, -0.02641360f, 
    -0.02507490f, -0.04469791f, 0.28862974f, -0.06227928f, 0.00979772f, -0.03821322f, -0.06996939f, 0.06499838f, 
    -0.00733004f, 0.25550264f, -0.58987850f, 0.13664009f, -0.24686433f, 0.08407167f, -0.01909524f, 0.41897050f, 
    -0.15465991f, -0.07382397f, 0.13195209f, 0.26040018f, 0.23063377f, 0.38241747f, 0.09612644f, -0.01279508f, 
    0.21984534f, -0.23795839f, 0.01501657f, 0.18582858f, 0.05816726f, -0.04425143f, -0.00632289f, 0.29564473f, 
    -0.13035206f, 0.00016692f, -0.07223564f, 0.57338095f, 0.19909838f, -0.16181412f, -0.21177894f, 0.14803642f, 
    0.16731387f, 0.00570812f, 0.30861664f, 0.14086194f, 0.26465142f, 0.16674048f, -0.04250585f, -0.30354926f, 
    -0.13393462f, -0.02727187f, 0.16546308f, -0.10137386f, -0.11100671f, -0.01759732f, -0.12389370f, -0.00327822f, 
    -0.47122461f, 0.23544991f, 0.19259700f, 0.05885721f, -0.54287446f, 0.14050147f, -0.08203619f, 0.35383919f, 
    0.14455952f, -0.03784358f, -0.03215417f, 0.00167043f, 0.10006159f, -0.20246826f, 0.04419645f, 0.22669467f, 
    -0.46990800f, -0.03495327f, 0.14700958f, 0.14498204f, -0.16187420f, -0.12763894f, -0.08832903f, -0.02964917f, 
    -0.20613268f, -0.49974966f, -0.42185694f, -0.19115506f, 0.15931553f, 0.00904838f, -0.07608269f, -0.38786784f, 
    -0.14865081f, -0.06403121f, 0.01964275f, -0.06754434f, 0.06031345f, 0.10582737f, -0.00074644f, -0.10580394f, 
    0.09448486f, 0.02188647f, 0.11528359f, -0.12333352f, 0.01473096f, 0.01739069f, 0.03844912f, -0.17123233f, 
    -0.01229583f, 0.07399980f, -0.01672283f, -0.10137302f, 0.19067194f, 0.01637224f, -0.07906596f, 0.13804856f, 
    -0.28418756f, 0.14213380f, -0.16727349f, 0.05686295f, 0.49125850f, 0.20453528f, -0.31606972f, -0.04649429f, 
    0.22240902f, -0.33203211f, -0.02261359f, -0.21473593f, 0.02783917f, 0.01225970f, -0.03253768f, 0.19985788f, 
    -0.04194321f, -0.09198028f, -0.09490728f, 0.07754246f, -0.07466079f, -0.08713926f, 0.01088298f, 0.04060625f, 
    -0.08606058f, 0.00360684f, -0.16965586f, -0.24633197f, 0.23591362f, -0.16144414f, 0.06095384f, -0.00781754f, 
    0.01494996f, 0.07855503f, 0.19974427f, -0.12103473f, -0.16694778f, -0.15255463f, 0.33485624f, 0.11166430f, 
    0.10374460f, -0.13084897f, -0.19965778f, -0.22832254f, -0.03691679f, -0.11088607f, 0.14828099f, -0.42352208f, 
    0.05763708f, 0.11151904f, -0.06359026f, 0.08671048f, 0.22758335f, -0.23746344f, -0.09120942f, -0.09030361f, 
    0.24413328f, 0.19952238f, -0.10539652f, 0.03514871f, -0.15343596f, 0.05528496f, -0.20921496f, 0.30683136f, 
    -0.06680074f, -0.07329078f, -0.09527744f, 0.02639906f, 0.00898284f, 0.03791662f, -0.01298732f, -0.01972772f, 
    -0.06555570f, -0.01314620f, 0.04905115f, 0.05366752f, 0.07859437f, -0.03947735f, 0.02712357f, 0.02484329f, 
    0.01417521f, -0.09652321f, -0.01299430f, -0.06583919f, 0.04449449f, -0.08994102f, 0.07446216f, 0.02428196f, 
    -0.00111366f, -0.00124892f, 0.01909166f, 0.04746046f, 0.07223417f, -0.02147564f, 0.06355302f, 0.03053415f, 
    -0.05136227f, -0.05303118f, 0.06494159f, 0.07540211f, -0.05723546f, 0.02048289f, -0.04686220f, -0.02426334f, 
    -0.03573624f, 0.08480091f, -0.07706492f, -0.06150525f, -0.01247290f, -0.05743248f, -0.09194515f, 0.00658558f, 
    -0.06457173f, -0.04717890f, 0.04081767f, 0.06685287f, 0.03486611f, -0.04358815f, -0.02256870f, 0.00065118f, 
    0.07940683f, 0.01958084f, -0.04714767f, -0.08000785f, 0.05271325f, 0.02180793f, 0.05218539f, -0.02544103f, 
    -0.00024892f, -0.08264646f, -0.01997806f, 0.05750725f, 0.00127239f, -0.10510784f, -0.05105857f, -0.06155832f, 
    -0.11941755f, 0.01558439f, -0.06473570f, -0.07198294f, -0.07540663f, 0.06283094f, 0.07181289f, -0.03506468f, 
    -0.11103339f, -0.08284710f, 0.02986618f, -0.08177011f, -0.01432565f, -0.01480000f, 0.03682286f, -0.06640650f, 
    -0.00885419f, -0.02849722f, 0.03858613f, -0.01540803f, -0.05454267f, -0.03542804f, 0.03361889f, -0.07415629f, 
    0.05677111f, -0.05650886f, 0.05183976f, -0.10755221f, -0.06784301f, -0.07096818f, -0.01961508f, 0.04736549f, 
    0.05365204f, 0.02414139f, -0.07012209f, -0.05307953f, 0.07719525f, -0.10338299f, 0.00088096f, 0.04986062f, 
    -0.06187270f, -0.10557149f, -0.06460521f, -0.06862617f, -0.02740891f, 0.04514923f, 0.05310354f, -0.04757768f, 
    -0.07899044f, -0.03438708f, -0.08963499f, -0.11398365f, -0.00321919f, -0.04629000f, 0.02683158f, -0.10184772f, 
    -0.13378625f, -0.00577025f, -0.02434268f, 0.11136100f, -0.04294343f, -0.16931756f, 0.02909674f, 0.25945672f, 
    0.59053028f, 0.14512174f, 0.07855057f, -0.03752832f, -0.16488034f, -0.05650599f, 0.05701842f, -0.01955894f, 
    0.06308119f, -0.08550484f, 0.07269921f, -0.03947111f, 0.09441431f, 0.33564913f, 0.05473949f, -0.08235102f, 
    0.37922183f, -0.08524838f, 0.03076097f, -0.00096023f, 0.05543669f, 0.12285437f, -0.03947629f, 0.09323355f, 
    0.15747622f, 0.02505744f, -0.57126033f, 0.37078100f, -0.02636113f, 0.06093346f, 0.01627102f, 0.66736519f, 
    0.27382761f, -0.18107526f, 0.18456675f, -0.32103950f, 0.10185412f, -0.00128085f, 0.01509617f, 0.08571219f, 
    0.19187073f, -0.07201768f, 0.13182740f, 0.23160444f, -0.07448285f, 0.22509600f, 0.11154882f, -0.08442827f, 
    -0.15176715f, 0.07071491f, 0.04981843f, -0.02438283f, -0.13631414f, 0.12278879f, 0.14660275f, -0.17095274f, 
    0.18934363f, -0.13341326f, 0.11328339f, -0.01635632f, 0.05289933f, 0.07940221f, -0.32553011f, 0.03769809f, 
    0.33891830f, 0.06671014f, 0.11940759f, 0.13793641f, 0.00347386f, 0.35168800f, -0.07026843f, 0.03782273f, 
    0.40058056f, -0.08167761f, 0.15835898f, 0.08718318f, 0.03498051f, -0.06634153f, 0.29834688f, -0.00890840f, 
    0.02822447f, -0.31301588f, 0.07098817f, 0.05252868f, -0.08299433f, 0.02954783f, 0.07151886f, 0.12897091f, 
    -0.20466927f, 0.04066597f, -0.03536459f, 0.10843672f, 0.01424387f, 0.07283565f, 0.03962348f, -0.02489482f, 
    -0.06206390f, -0.08175039f, 0.01462383f, 0.11128575f, -0.27089366f, 0.02807616f, 0.06150530f, 0.03878575f, 
    -0.04606320f, 0.03160024f, -0.15630873f, -0.02759107f, 0.16285583f, -0.08516242f, 0.01042366f, -0.01499012f, 
    -0.03935286f, -0.12350336f, 0.25851777f, 0.06205156f, 0.16145794f, 0.12944701f, -0.09713526f, -0.16360952f, 
    0.16510852f, -0.10790692f, 0.03944409f, -0.06363872f, -0.11970074f, 0.01495864f, -0.10994675f, 0.42882901f, 
    -0.37051076f, -0.02900189f, 0.03547284f, -0.09404604f, -0.37397590f, 0.05957339f, -0.13220993f, 0.31892303f, 
    0.15912253f, -0.05865469f, -0.30879566f, -0.22970968f, 0.14349316f, -0.03593529f, -0.08123684f, 0.18210831f, 
    -0.02209074f, -0.22264771f, 0.09794327f, 0.15085945f, 0.20870028f, -0.22919534f, 0.08792003f, 0.12169917f, 
    -0.17318864f, -0.20696282f, -0.25587240f, 0.03309691f, -0.13886753f, 0.05975818f, -0.31163719f, -0.34412012f, 
    -0.41048491f, -0.16647500f, 0.12227172f, -0.26488259f, 0.07292163f, 0.02218771f, -0.10164595f, 0.07839706f, 
    0.13640183f, 0.07809287f, -0.02433416f, 0.32982686f, 0.02191420f, 0.14268762f, 0.08687773f, -0.20720086f, 
    -0.06595095f, 0.07523183f, -0.07261016f, -0.44850385f, 0.17605662f, -0.08011988f, 0.04498807f, -0.02800297f, 
    -0.56380171f, 0.18871464f, -0.09003619f, 0.07453922f, 0.32545143f, 0.12630405f, -0.13540266f, 0.03293217f, 
    0.36296695f, -0.29685581f, 0.02989659f, -0.09725885f, -0.08187626f, 0.31288889f, -0.10065342f, 0.25715318f, 
    0.08754038f, -0.17756058f, 0.06362480f, 0.36438638f, -0.01587442f, -0.05942664f, 0.33098748f, 0.22941735f, 
    -0.06122109f, 0.06845689f, 0.24782844f, -0.10082855f, 0.07053678f, -0.15044516f, 0.04422024f, 0.02511530f, 
    0.00201495f, 0.01908781f, 0.09909038f, -0.16910809f, -0.27496520f, -0.40487310f, 0.19932002f, 0.07024139f, 
    -0.20380259f, -0.00836830f, -0.28673449f, -0.31784332f, -0.03800085f, 0.07457148f, 0.14717947f, -0.27036157f, 
    0.04616027f, 0.07324068f, -0.22354144f, -0.07109812f, 0.09260007f, -0.05691030f, -0.18798897f, -0.17392151f, 
    0.04030120f, 0.26378199f, -0.04295335f, -0.00300242f, -0.17033039f, 0.03873421f, -0.27877170f, 0.28529960f, 
    -0.08181138f, 0.08385205f, 0.11426385f, 0.09994869f, 0.30813640f, -0.05811584f, 0.02377598f, 0.46583205f, 
    -0.20506769f, -0.34191123f, 0.06219278f, -0.07722465f, -0.24510434f, 0.09938978f, -0.01721512f, 0.14352818f, 
    -0.08429077f, 0.02406725f, -0.13692181f, -0.48693004f, 0.13834687f, -0.05209566f, 0.06652766f, 0.18755066f, 
    -0.20820999f, -0.24409495f, 0.03003174f, 0.25813568f, 0.12923183f, -0.16239309f, -0.05255431f, -0.02073023f, 
    0.10814809f, -0.07331584f, -0.32491791f, 0.23348746f, -0.10641072f, 0.19961388f, 0.34536377f, -0.26156956f, 
    -0.23944624f, -0.09598083f, 0.18694687f, 0.00746045f, -0.00932703f, -0.03894476f, -0.18747312f, -0.14563085f, 
    0.12478842f, -0.24675424f, -0.32180375f, 0.08698880f, 0.00696816f, -0.08420554f, 0.04578632f, -0.03511199f, 
    0.11364638f, 0.00076906f, -0.06951661f, -0.01891054f, 0.10406859f, 0.25171921f, 0.03647270f, 0.04605439f, 
    -0.28449616f, -0.13903289f, -0.01210149f, 0.14729299f, 0.21398962f, -0.09158187f, -0.00168187f, 0.15175545f, 
    -0.01408816f, 0.26397437f, 0.19499841f, 0.13313514f, -0.23532878f, 0.36562470f, -0.01812590f, 0.22780654f, 
    0.02316099f, -0.06644230f, 0.19411969f, -0.05935335f, 0.02299908f, -0.05392924f, -0.11000162f, 0.12125171f, 
    0.06280616f, 0.14939880f, -0.11138564f, -0.11544197f, 0.19114257f, -0.11134058f, 0.06708258f, -0.40303022f, 
    -0.02505278f, 0.03467885f, -0.04845693f, -0.06880499f, 0.10330424f, -0.48678520f, 0.44120294f, 0.14018981f, 
    0.02635710f, 0.05819594f, -0.10036445f, 0.21777722f, 0.05473033f, 0.08331804f, 0.20646977f, 0.25013295f, 
    0.07388826f, -0.02017347f, -0.03244451f, -0.31249928f, 0.21384972f, 0.05897425f, 0.02832081f, 0.03248500f, 
    -0.21671197f, -0.12205743f, 0.15648645f, 0.10379008f, 0.07369298f, 0.05487798f, -0.06778707f, -0.07437997f, 
    -0.04084752f, -0.16346754f, 0.21378674f, 0.13211623f, 0.05057632f, -0.10844237f, -0.19020265f, -0.00933955f, 
    0.02859905f, -0.12108617f, 0.05923074f, 0.19497705f, -0.14068040f, 0.14562938f, -0.13926123f, 0.17811067f, 
    -0.35145664f, 0.02341475f, 0.07546563f, 0.04321171f, 0.18488111f, 0.06813096f, 0.06793685f, -0.22892483f, 
    0.04634634f, 0.08144936f, 0.12813433f, 0.20505928f, 0.00264200f, -0.16143669f, -0.09014981f, 0.05268800f, 
    -0.05342453f, -0.18752292f, -0.14000432f, 0.18788682f, -0.06055239f, -0.09095106f, 0.15826768f, 0.03681752f, 
    -0.19470316f, 0.10806950f, 0.01239840f, 0.14866725f, 0.11207693f, -0.09301258f, 0.08348510f, 0.11858147f, 
    0.02208871f, 0.22014396f, 0.17665841f, 0.32014832f, 0.07311617f, 0.15581352f, 0.07331183f, -0.04221874f, 
    -0.08434206f, 0.10333250f, 0.04854397f, 0.10252219f, 0.12622382f, 0.05986047f, 0.08887909f, -0.07490993f, 
    -0.22833951f, -0.02552794f, -0.10748198f, -0.08137979f, 0.05943084f, 0.13352615f, 0.10560150f, -0.22143288f, 
    0.01854447f, -0.10981046f, 0.07896536f, -0.04763347f, 0.10322455f, 0.03662248f, -0.12096993f, 0.06181901f, 
    0.07548853f, -0.04995666f, 0.11190012f, -0.05161382f, -0.02028752f, 0.07904654f, 0.12178836f, 0.02628875f, 
    -0.05819501f, 0.00644063f, -0.46306157f, -0.07128650f, -0.04360865f, -0.23536687f, 0.08830028f, 0.07113531f, 
    0.00383535f, 0.02290452f, 0.07452250f, 0.17468300f, 0.05316946f, -0.00488064f, 0.51638073f, -0.12068351f, 
    0.18698072f, 0.04617445f, -0.09304841f, 0.28371796f, 0.06068375f, -0.06204234f, 0.03295801f, 0.05189715f, 
    -0.08659068f, -0.08355651f, 0.04078181f, -0.11592784f, 0.10485146f, -0.10967622f, -0.04847458f, 0.09077100f, 
    0.09941758f, 0.15905213f, 0.13801779f, 0.19560973f, 0.03780942f, 0.18323696f, 0.09855273f, -0.00002420f, 
    0.15410070f, 0.14300746f, -0.19323541f, -0.13672093f, 0.10171379f, 0.05589100f, 0.00960239f, -0.33237755f, 
    0.22639151f, -0.06030006f, -0.36654910f, -0.12888123f, 0.26096264f, 0.00838117f, 0.13914405f, 0.12727989f, 
    0.00772445f, 0.14919376f, -0.01192458f, 0.00820747f, 0.10742658f, -0.17187424f, -0.06865988f, 0.01815225f, 
    -0.15881850f, -0.09480537f, -0.23063959f, -0.11725026f, 0.00194825f, 0.07967646f, 0.01084796f, -0.27919587f, 
    0.03813937f, 0.26074144f, 0.53762627f, 0.37863192f, 0.29301098f, 0.24750714f, 0.20803224f, 0.11570057f, 
    0.17338403f, -0.00689916f, 0.29694700f, -0.30022418f, -0.15095374f, 0.00087598f, -0.13857651f, -0.01801766f, 
    0.16875531f, 0.04483730f, -0.45970228f, -0.58381373f, 0.09101105f, -0.71071744f, 0.07124738f, 0.08523221f, 
    0.09600190f, 0.10866436f, 0.01277801f, 0.04657482f, -0.16076209f, 0.10592999f, -0.18321975f, -0.01980348f, 
    -0.17269710f, 0.04609026f, 0.41432005f, -0.19690759f, -0.50015217f, 0.03545168f, -0.48429108f, -0.04148849f, 
    -0.36273283f, 0.18833229f, 0.13120328f, 0.10509902f, 0.01621762f, 0.17930655f, -0.00470774f, 0.25407210f, 
    0.07853808f, 0.06266153f, -0.92675281f, 0.09117304f, -0.14573692f, 0.01672363f, -0.64484888f, -0.63078678f, 
    -0.06364878f, -0.11256081f, -0.04432153f, 0.49964437f, 0.09332908f, 0.00660879f, -0.01177202f, -0.17483830f, 
    0.09159183f, -0.02604966f, 0.01791314f, -0.17905006f, -0.12021987f, -0.03167950f, 0.59537512f, 0.01876565f, 
    -0.06977889f, -0.12059443f, 0.08234843f, -0.57139874f, 0.06155059f, 0.10718764f, 0.18137839f, 0.11007817f, 
    -0.06382108f, -0.02733440f, -0.26264405f, -0.26352358f, 0.34858441f, 0.03943948f, 0.05609843f, 0.39241755f, 
    -0.02800194f, 0.01651085f, -0.03498878f, 0.01180882f, -0.34352389f, 0.14423205f, -0.00251365f, -0.16147961f, 
    -0.05582270f, 0.06777225f, -0.05877289f, -0.19109237f, 0.05517443f, -0.09668341f, 0.07310059f, 0.06136161f, 
    -0.04547407f, 0.08549011f, -0.15932310f, 0.05305023f, 0.01221305f, -0.01876692f, 0.09919693f, 0.06645615f, 
    -0.02495278f, 0.06104891f, -0.01219903f, -0.01153376f, 0.07105548f, -0.14069925f, 0.01655833f, 0.11382373f, 
    -0.04785084f, 0.00030636f, -0.33714539f, 0.05916289f, 0.04530998f, -0.03457991f, 0.05331008f, 0.09954464f, 
    0.16218153f, 0.06064802f, -0.01486277f, -0.17612433f, -0.23714897f, 0.00978229f, 0.11374252f, 0.20892636f, 
    0.16146310f, 0.01211830f, -0.27553561f, -0.34552479f, -0.13040571f, -0.20618798f, -0.07011236f, 0.04667973f, 
    -0.00219354f, -0.11467477f, -0.01463510f, 0.03791108f, 0.00213305f, -0.03681404f, -0.03200566f, -0.01295503f, 
    -0.24432506f, -0.05070787f, -0.10928978f, -0.01332257f, -0.29687232f, 0.02379163f, -0.09680448f, 0.00459400f, 
    0.01749853f, 0.01742957f, -0.16298367f, 0.01436023f, -0.26543286f, 0.07235420f, -0.07900058f, 0.14887942f, 
    -0.06781520f, -0.16400594f, 0.29628801f, -0.14818212f, -0.08979230f, 0.01800444f, -0.02777817f, 0.02456376f, 
    -0.13541529f, 0.04424581f, -0.10771288f, 0.26255411f, -0.06563839f, 0.04953391f, 0.00962430f, -0.07050490f, 
    0.02124882f, 0.13115986f, 0.06878302f, 0.21211141f, 0.11127886f, 0.02721028f, 0.01696833f, -0.13941658f, 
    -0.08335624f, -0.07052021f, -0.03299589f, -0.03007798f, 0.09696612f, -0.05437022f, -0.06043882f, 0.09723362f, 
    -0.00473412f, -0.18985996f, -0.01559849f, -0.01909735f, -0.00029775f, 0.05524126f, 0.05534285f, -0.13981901f, 
    0.02996738f, -0.08133611f, -0.16353747f, -0.11946836f, 0.04773217f, -0.07005221f, 0.02770234f, -0.07943261f, 
    0.01415983f, -0.07731630f, -0.16254565f, -0.01775315f, -0.05978664f, -0.11349218f, -0.05592902f, -0.20484036f, 
    0.21077782f, 0.04655309f, 0.12466580f, -0.20316620f, -0.38008025f, -0.07358286f, -0.09402333f, 0.10398363f, 
    -0.30315650f, -0.42944774f, 0.02926764f, 0.13131505f, 0.11953765f, 0.14484794f, -0.25036603f, 0.12715912f, 
    0.25604191f, -0.07635477f, -0.05871855f, -0.05908959f, 0.04899880f, 0.10409231f, -0.05024578f, 0.05307502f, 
    -0.19539863f, 0.07542255f, -0.21891005f, 0.05053056f, -0.02258246f, 0.07757501f, -0.09331259f, 0.11001332f, 
    -0.04276248f, 0.06004769f, 0.18214238f, 0.06358683f, -0.07712784f, 0.19924991f, -0.18304315f, -0.24088971f, 
    -0.27904871f, -0.21461007f, 0.15603660f, -0.05866256f, -0.12059176f, 0.23699574f, -0.09708966f, 0.11329914f, 
    0.36192206f, -0.01276584f, 0.27823621f, -0.10312976f, 0.07948798f, -0.00827542f, -0.23188138f, -0.16895799f, 
    0.02266947f, 0.25908694f, -0.01020835f, -0.14298427f, 0.19125746f, -0.45958397f, -0.33865446f, -0.08174489f, 
    0.18385412f, 0.36464906f, 0.07861774f, -0.05552256f, 0.19935256f, -0.06672251f, -0.15315835f, 0.06447344f, 
    -0.03180719f, -0.17156586f, 0.11369761f, 0.14097840f, 0.03170208f, 0.38719878f, 0.22746848f, 0.07577036f, 
    -0.21235488f, -0.07229288f, 0.09094318f, 0.36262044f, 0.07848930f, 0.07504465f, -0.05409763f, 0.29062083f, 
    0.00703154f, 0.47914144f, -0.00738852f, 0.15843044f, 0.06202521f, -0.16290732f, -0.06868713f, 0.27512485f, 
    -0.11553675f, -0.02190249f, 0.08596174f, -0.06221905f, -0.04662504f, 0.14705311f, 0.12491955f, 0.06499751f, 
    0.33089781f, -0.43827009f, -0.01800559f, -0.37236243f, 0.04129045f, 0.10440248f, 0.16092163f, -0.00728727f, 
    -0.11660082f, -0.07284536f, 0.06155512f, 0.24806848f, 0.19102675f, 0.05580603f, -0.25457820f, -0.00703072f, 
    0.07531097f, 0.29219845f, 0.02677594f, -0.00915478f, -0.18129745f, 0.04600998f, -0.09809066f, 0.12491363f, 
    -0.17469066f, 0.03155340f, 0.04226803f, -0.05904068f, 0.13463277f, -0.24077255f, -0.08692616f, 0.08648994f, 
    -0.05008112f, -0.08628447f, -0.17901681f, -0.02445525f, 0.03459639f, -0.08523428f, 0.00228962f, -0.18394142f, 
    0.04451715f, -0.21246053f, -0.42489633f, -0.38407326f, -0.11833258f, -0.02978330f, 0.07985845f, 0.24103490f, 
    -0.05817236f, 0.03357984f, 0.10456342f, 0.23816775f, 0.11787410f, -0.07602201f, 0.17400745f, -0.15361857f, 
    0.32179832f, 0.00423710f, -0.32589781f, 0.08941442f, -0.01999125f, 0.38285556f, 0.38524181f, 0.23024543f, 
    -0.01799182f, -0.18897207f, 0.12530366f, 0.09744679f, 0.08755282f, -0.07389432f, -0.33403799f, -0.34069008f, 
    -0.13952564f, -0.02564517f, -0.05186342f, 0.48822662f, -0.05004463f, 0.00593274f, 0.13692299f, 0.00284761f, 
    0.01045744f, -0.07648886f, 0.08099445f, 0.11302974f, -0.01325728f, 0.20148739f, 0.01102659f, 0.30196479f, 
    -0.00257751f, -0.11559714f, -0.01330354f, 0.05008911f, 0.24819361f, 0.06323057f, 0.16708612f, 0.20916228f, 
    0.02774755f, 0.26092857f, -0.05462705f, -0.06183412f, -0.26173976f, 0.12382792f, -0.11559926f, 0.01576823f, 
    0.05255857f, -0.08991548f, 0.16639227f, -0.04321939f, 0.04623737f, -0.04949563f, -0.07054879f, -0.08470609f, 
    -0.09487270f, 0.19604124f, 0.14017539f, 0.01008583f, 0.22097732f, 0.02224185f, 0.07496486f, -0.71348947f, 
    0.10013053f, -0.05169806f, 0.18472485f, -0.08007162f, 0.30360103f, -0.20663780f, 0.19459209f, -0.09986234f, 
    0.26927024f, -0.09703772f, 0.07732393f, 0.16679829f, -0.07910649f, -0.00515017f, 0.24792735f, 0.24040802f, 
    0.10974342f, -0.36320385f, -0.06851237f, -0.03856717f, 0.00358918f, 0.02878309f, 0.02328499f, -0.05230359f, 
    -0.23150918f, -0.30649534f, 0.21979694f, 0.19520620f, 0.20137385f, 0.20859592f, -0.01781782f, -0.19204605f, 
    -0.08365984f, 0.13065484f, 0.03223880f, 0.02926852f, -0.02313059f, 0.17846936f, -0.18324672f, 0.01905546f, 
    0.09696174f, -0.52670592f, 0.09666538f, -0.06262230f, 0.10285729f, -0.07045007f, -0.00785531f, -0.14543407f, 
    0.18191318f, -0.08548823f, -0.27180010f, -0.23361297f, -0.07774007f, -0.12380604f, -0.02530928f, 0.20817934f, 
    -0.06654174f, -0.09787715f, 0.12745723f, 0.01402948f, -0.05378213f, 0.16474022f, 0.19589068f, -0.10654792f, 
    0.13077679f, 0.27112857f, 0.45152003f, -0.06647599f, 0.05173174f, 0.03763907f, -0.08696030f, 0.14257258f, 
    0.38253245f, -0.62293202f, 0.12344211f, -0.00494114f, 0.06304306f, 0.22768420f, 0.00922077f, -0.03912099f, 
    0.06094695f, 0.11801536f, -0.14152235f, -0.15781476f, 0.01151609f, -0.10572620f, -0.09970059f, 0.09680060f, 
    0.13823475f, -0.01647449f, 0.03331218f, -0.12540601f, -0.24766901f, -0.07822860f, 0.02866280f, -0.04109246f, 
    0.01234339f, 0.23218797f, 0.15037966f, 0.09889738f, -0.20610826f, -0.01853900f, -0.08871470f, -0.00217668f, 
    0.20694324f, -0.09352841f, 0.11374947f, 0.07765635f, 0.01624181f, -0.18914416f, 0.21469761f, 0.12070887f, 
    -0.07674423f, 0.02062605f, -0.12386780f, 0.08530036f, 0.06552357f, -0.01504684f, -0.07313505f, -0.05088555f, 
    0.02864999f, 0.18313606f, 0.09433465f, 0.36561245f, 0.08990221f, -0.06883996f, 0.05663920f, 0.12512834f, 
    0.04783854f, 0.07487772f, 0.01811231f, 0.12437141f, 0.00145072f, 0.01425438f, -0.04491121f, 0.03346802f, 
    -0.04991722f, 0.18906650f, 0.06783533f, -0.21111274f, 0.04002578f, 0.10268778f, 0.16361900f, -0.17647991f, 
    -0.01199018f, 0.07442990f, 0.06848113f, 0.16483781f, 0.04519535f, 0.18984433f, -0.09191732f, 0.09090340f, 
    0.09513069f, 0.11857062f, -0.29419312f, -0.07569874f, -0.04763889f, -0.00256911f, -0.23994815f, 0.08870172f, 
    0.65367621f, -0.03402435f, -0.03999269f, -0.05453902f, -0.13633266f, 0.00717770f, -0.23946056f, 0.04168530f, 
    0.48804697f, 0.19427834f, 0.21787497f, -0.00490001f, 0.28102773f, -0.04478234f, -0.03079280f, -0.31946355f, 
    0.29095173f, -0.39537248f, -0.01268417f, -0.02927936f, -0.16959119f, 0.21538392f, 0.05795994f, 0.17087531f, 
    0.12826793f, -0.03479445f, -0.06588713f, -0.11789592f, -0.00565835f, 0.11839194f, 0.04038657f, 0.05969875f, 
    0.03491922f, 0.17878899f, 0.13640094f, 0.22229445f, 0.15134360f, 0.22382680f, 0.06498834f, 0.49526891f, 
    0.50609303f, 0.11557352f, 0.06940839f, -0.05343837f, 0.12671682f, 0.17579016f, -0.47064847f, -0.22738755f, 
    0.31919861f, -0.19856276f, 0.36871737f, 0.10400697f, 0.05175928f, -0.03750133f, -0.07438654f, 0.12749517f, 
    -0.00628820f, -0.03841903f, 0.11371897f, -0.25555944f, -0.15766378f, 0.08760959f, 0.06129827f, 0.03071674f, 
    0.20445774f, 0.35058892f, 0.10417566f, 0.00097431f, -0.11749780f, 0.06549127f, 0.12329565f, -0.08983154f, 
    0.11981392f, 0.14405380f, 0.02461407f, 0.05999524f, -0.10225758f, 0.05027669f, 0.23813520f, 0.01625075f, 
    0.16670869f, -0.14253812f, 0.08853661f, 0.05827947f, 0.06411683f, 0.06529050f, -0.00165296f, 0.01894815f, 
    0.08104785f, 0.22851184f, -0.03056285f, 0.37396935f, -0.30297402f, 0.03356273f, -0.04943608f, 0.26331681f, 
    0.04922325f, -0.02513625f, 0.05961842f, 0.04247865f, -0.08608892f, -0.00167057f, 0.16569248f, -0.06141578f, 
    0.01565309f, 0.14190780f, 0.09684871f, 0.08666590f, -0.13702787f, 0.00541838f, 0.02286500f, 0.34457475f, 
    -0.08865304f, 0.06929298f, -0.01395729f, 0.15618646f, 0.11681549f, 0.06870610f, -0.21154994f, 0.19017345f, 
    -0.14427499f, -0.02013293f, 0.21577078f, -0.03446762f, 0.21116571f, 0.10812674f, -0.17845482f, -0.08222881f, 
    0.04022726f, 0.00501215f, -0.02027443f, 0.15390287f, 0.25600120f, -0.10306063f, -0.43055961f, -0.00084612f, 
    -0.04744780f, -0.06152644f, 0.07973056f, -0.11689611f, 0.20479913f, -0.40196738f, -0.13492019f, -0.53775495f, 
    -0.09203251f, -0.38584223f, -0.16724598f, -0.12923820f, -0.20355749f, -0.04751010f, -0.02587688f, 0.14954640f, 
    0.04519857f, -0.09222903f, 0.15158139f, -0.04188249f, -0.19930275f, 0.05220812f, 0.09857474f, -0.08073951f, 
    0.11500692f, 0.11104747f, -0.07591463f, 0.16265713f, 0.19721176f, -0.03030424f, 0.11197031f, -0.14186433f, 
    0.32328895f, 0.05311514f, 0.06554644f, 0.35652444f, 0.02340245f, 0.02250964f, -0.55570614f, -0.21592924f, 
    0.05452631f, -0.13913886f, 0.08893853f, -0.08160501f, 0.03373967f, -0.06308545f, -0.05783006f, 0.23602135f, 
    -0.17306496f, -0.21586829f, 0.00989556f, 0.08793382f, -0.12380107f, 0.23103291f, 0.31364036f, 0.13364333f, 
    0.06592885f, 0.01445384f, -0.31251082f, 0.01539822f, 0.01804890f, 0.01340012f, 0.55158556f, 0.07161100f, 
    0.06593967f, 0.32511535f, -0.13188566f, 0.03578525f, -0.22339837f, -0.18090552f, 0.07454744f, 0.08066161f, 
    0.09169576f, -0.29637405f, 0.11823997f, -0.26656118f, 0.07482366f, -0.06096415f, -0.09129053f, 0.10165351f, 
    0.00342181f, 0.18698807f, 0.00652189f, 0.05302904f, -0.33424544f, -0.03898047f, 0.00072936f, -0.21520257f, 
    0.01886683f, -0.02260439f, -0.07535242f, 0.07972758f, -0.02103680f, -0.19047129f, 0.02280775f, -0.19362517f, 
    -0.17542204f, 0.15037450f, 0.22004049f, 0.20987201f, -0.04333803f, -0.14686710f, 0.12547415f, 0.29891518f, 
    0.07927117f, 0.00576100f, -0.05179068f, 0.29824078f, -0.00159123f, 0.11963242f, -0.18965569f, 0.01498471f, 
    -0.30925933f, -0.22240147f, 0.08401282f, 0.09116921f, 0.40095326f, 0.06248778f, -0.20110312f, -0.20358504f, 
    0.03644670f, -0.04688779f, 0.02389021f, -0.05985400f, -0.04573303f, -0.00389029f, -0.07490636f, -0.08109444f, 
    -0.00440528f, -0.00057188f, 0.04530812f, -0.07534581f, 0.04690561f, 0.05289093f, -0.01466271f, -0.08573627f, 
    0.02604136f, -0.07587195f, 0.02378173f, -0.02832188f, -0.07212280f, 0.01166213f, -0.08096617f, -0.03764598f, 
    0.00883014f, 0.07112328f, 0.07041758f, -0.05260252f, -0.05235493f, -0.06720827f, -0.08256502f, -0.00617118f, 
    -0.06437352f, -0.08106325f, -0.02814545f, 0.01758000f, -0.06125965f, 0.01477169f, -0.05906677f, 0.06337637f, 
    0.06090238f, -0.00046422f, -0.08382571f, 0.08066083f, 0.01749999f, -0.00702690f, -0.06597739f, 0.02961432f, 
    0.02132038f, 0.05798297f, -0.07820503f, -0.02398624f, 0.02643075f, 0.07658436f, 0.00286417f, -0.08090974f, 
    -0.07639615f, 0.02937140f, -0.03011742f, 0.02285495f, 0.07229637f, -0.05769751f, -0.03496584f, -0.01064584f, 
    0.02726438f, -0.06901125f, 0.08334330f, -0.01234520f, -0.06552072f, 0.04804927f, 0.03660007f, 0.08662306f, 
    0.00816476f, -0.05991572f, -0.08523814f, -0.08431965f, -0.02401230f, -0.05229441f, 0.04700787f, 0.05887606f, 
    0.05991790f, 0.03668798f, -0.07265556f, -0.05243360f, 0.08687382f, 0.03256282f, 0.05631892f, -0.02855663f, 
    -0.04458147f, -0.01389729f, -0.02893998f, 0.07773758f, -0.08360628f, -0.08627413f, 0.08234632f, -0.00298945f, 
    -0.07486568f, 0.00457118f, 0.08635774f, -0.05509790f, 0.07499248f, -0.06302444f, 0.03536122f, -0.06461380f, 
    0.03655598f, 0.00583769f, 0.05481936f, 0.00744776f, -0.03221981f, -0.08738055f, -0.04372250f, 0.01482505f, 
    -0.05399190f, 0.02253623f, 0.03193224f, -0.07519504f, -0.02025940f, -0.04598381f, 0.05515247f, 0.00871390f, 
    0.00621177f, -0.05937917f, 0.06506344f, -0.04011240f, -0.07883491f, 0.07928644f, -0.07957148f, 0.08284108f, 
    0.31830671f, 0.11667933f, 0.20080878f, 0.15320159f, 0.31427664f, 0.08037644f, -0.13190135f, 0.44373909f, 
    -0.59662151f, -0.26898238f, 0.13455683f, 0.08311293f, -0.24517600f, 0.03394653f, -0.18300168f, 0.14155297f, 
    0.02665958f, -0.08353750f, -0.23150094f, -0.31401408f, 0.13677070f, 0.01779146f, 0.08327413f, 0.05675291f, 
    -0.24549559f, -0.27202353f, 0.15462041f, -0.06132914f, -0.05708147f, -0.16695358f, -0.19281392f, -0.01692617f, 
    0.20553306f, -0.23657307f, -0.48384905f, 0.06695849f, -0.20490435f, -0.04093134f, -0.06779910f, -0.33713168f, 
    -0.37013927f, -0.58355176f, 0.09991947f, -0.16077304f, 0.16296403f, 0.10919422f, -0.16790448f, 0.00539886f, 
    0.33039609f, -0.16932628f, 0.08930743f, 0.11463507f, 0.06691667f, 0.07117727f, -0.05834439f, -0.13520972f, 
    -0.04915887f, 0.11856173f, -0.09351276f, -0.29999757f, 0.17756434f, 0.33701608f, 0.06194228f, -0.13607424f, 
    -0.33561632f, 0.17352064f, -0.15210044f, 0.07670378f, 0.28648955f, 0.04881277f, 0.03135879f, 0.15139054f, 
    0.24673131f, 0.14149494f, 0.19904135f, 0.13046552f, -0.18106885f, -0.05716501f, 0.25175256f, 0.23969223f, 
    -0.09023573f, 0.05461301f, 0.13511431f, -0.29528773f, 0.04537315f, 0.02334087f, 0.27842653f, 0.26825112f, 
    -0.08824796f, 0.33453834f, 0.01922398f, -0.40743354f, 0.01797919f, -0.05140767f, 0.03849310f, 0.23615739f, 
    -0.00485755f, 0.07447831f, -0.02405833f, 0.00576068f, -0.13847363f, -0.29653376f, 0.43079364f, 0.01519025f, 
    -0.10566426f, 0.05594710f, -0.02317111f, 0.02615742f, 0.02073107f, 0.01251112f, 0.09992252f, -0.13647231f, 
    -0.16611770f, 0.25051740f, 0.00642587f, -0.15525775f, 0.29220024f, 0.12440696f, -0.02605621f, 0.07622536f, 
    0.14186159f, 0.01020582f, -0.34132871f, 0.10104088f, -0.06715388f, 0.13000739f, -0.40148178f, -0.02367964f, 
    -0.08026379f, -0.00923230f, -0.08349646f, 0.03378513f, 0.01976290f, -0.01391044f, 0.00528396f, -0.02836071f, 
    0.05505702f, -0.05417143f, -0.05656161f, -0.05586451f, 0.06215561f, 0.01989866f, 0.07936992f, -0.11606490f, 
    0.02897904f, -0.02336880f, -0.08688164f, -0.03099539f, -0.12320319f, 0.06776967f, -0.00880049f, 0.01863247f, 
    0.04157371f, 0.00063421f, -0.02450995f, -0.00944773f, -0.05689318f, -0.03245262f, -0.09135376f, 0.04880457f, 
    -0.06572861f, 0.06584360f, 0.07760917f, 0.02204963f, 0.00425959f, 0.04249049f, -0.03806364f, -0.04797073f, 
    0.07118410f, 0.04803897f, 0.02670524f, -0.07246406f, -0.01249632f, -0.07399999f, -0.09818122f, 0.01277607f, 
    -0.01117028f, -0.08139040f, 0.02121153f, -0.07664343f, -0.06542095f, -0.01344491f, 0.03814357f, -0.07785846f, 
    0.00047237f, -0.03972012f, -0.08470330f, 0.03847842f, -0.05952526f, 0.05482296f, -0.06746322f, 0.03827851f, 
    0.00079201f, -0.07278617f, -0.02341578f, 0.05645709f, -0.01965592f, 0.00901273f, -0.06879666f, -0.03711963f, 
    -0.08483834f, 0.08216276f, -0.02377107f, -0.06182466f, -0.11776365f, -0.02643383f, 0.00040314f, -0.01436391f, 
    0.00220843f, -0.04553140f, -0.02587421f, 0.05763121f, 0.08225074f, 0.06199691f, -0.01570934f, -0.09282155f, 
    0.02013029f, -0.05518364f, -0.07113784f, -0.06644751f, -0.08441129f, 0.01161362f, 0.01849431f, -0.08283665f, 
    0.00152915f, 0.00870642f, -0.07362112f, 0.03046622f, -0.07666820f, -0.09032057f, -0.08435053f, -0.02442574f, 
    -0.03208039f, -0.11270700f, -0.00897731f, 0.01523550f, -0.03290926f, -0.11797110f, -0.01405432f, 0.01458502f, 
    -0.02903395f, 0.04888847f, -0.04146293f, -0.01205828f, 0.04032854f, 0.04846827f, -0.07886200f, -0.07583568f, 
    0.02809564f, -0.10399185f, 0.03000435f, -0.05229757f, 0.03393518f, -0.02553286f, -0.07648536f, 0.08168157f, 
    0.01910911f, 0.00439412f, 0.08699483f, 0.06551472f, 0.04246424f, -0.07287759f, -0.01318962f, 0.02255118f, 
    -0.29093662f, -0.46216965f, 0.11942334f, 0.26739937f, 0.14599018f, 0.17268610f, -0.22085549f, 0.19154525f, 
    -0.10848942f, 0.11132663f, 0.06507811f, -0.19934504f, 0.17359027f, -0.11447409f, -0.04566084f, -0.22000365f, 
    -0.15987606f, 0.19995195f, 0.11994111f, 0.05195569f, -0.18103726f, -0.06100050f, -0.26902238f, 0.07529608f, 
    -0.08313672f, -0.04026509f, 0.12969296f, -0.05039989f, -0.06015745f, -0.25545099f, -0.03822573f, -0.51123220f, 
    -0.45435202f, -0.05923256f, -0.10489380f, 0.23444781f, 0.01156718f, 0.02724592f, 0.08060762f, -0.00976144f, 
    0.02137464f, 0.08586343f, 0.10273656f, -0.21946554f, -0.05286526f, 0.23226918f, -0.06302028f, -0.00203542f, 
    -0.05510423f, 0.04288450f, 0.03292693f, 0.02113531f, 0.04843051f, -0.16283280f, -0.14321603f, -0.10879127f, 
    -0.07186761f, 0.10909162f, -0.16114101f, -0.07889627f, 0.03700358f, -0.10771608f, 0.14161199f, -0.01760306f, 
    -0.20520329f, -0.06407240f, 0.11084091f, 0.14356478f, 0.31761953f, -0.21746737f, 0.16653793f, 0.02939424f, 
    -0.35682383f, 0.06752534f, 0.14429413f, 0.11719226f, -0.02186804f, 0.05878738f, -0.01341872f, 0.20239860f, 
    -0.02719813f, 0.21971954f, -0.07141285f, -0.05172056f, -0.04116661f, -0.07018410f, -0.08715763f, 0.31136414f, 
    -0.01949444f, 0.03993360f, -0.11975172f, 0.30491021f, 0.23281345f, 0.13409171f, 0.24395825f, -0.05153647f, 
    0.19853766f, -0.02978930f, -0.00203456f, 0.15178382f, 0.14825433f, 0.13349697f, -0.01846498f, -0.00042159f, 
    -0.01762756f, 0.08094960f, 0.19296880f, 0.33260274f, -0.00038480f, 0.02069393f, -0.04684971f, 0.05503116f, 
    0.15416110f, 0.07424646f, 0.05640702f, 0.16357163f, -0.11931140f, 0.11617220f, 0.08032579f, -0.00423683f, 
    0.01312441f, -0.01125007f, -0.04103323f, -0.08716419f, -0.08444965f, 0.02797946f, -0.08467810f, 0.05368335f, 
    0.07269061f, -0.00595589f, -0.07218512f, -0.05139430f, -0.05856425f, 0.06475352f, -0.09599158f, 0.03426225f, 
    -0.03544294f, -0.06751896f, 0.04050957f, 0.01119938f, -0.06747349f, -0.01677890f, -0.08541702f, -0.07209654f, 
    -0.01689287f, -0.06072494f, 0.00459686f, 0.06628963f, -0.04866153f, -0.09277391f, -0.04131784f, -0.10413575f, 
    -0.05920166f, 0.05178623f, -0.07160655f, -0.05281115f, 0.02982458f, -0.02495346f, -0.00239759f, -0.01423432f, 
    -0.06998348f, 0.03496930f, -0.01923159f, 0.00383048f, -0.02105888f, -0.06505878f, 0.06494886f, 0.05481630f, 
    0.05096282f, -0.03211429f, 0.01586976f, -0.04867205f, 0.04437480f, -0.02530008f, -0.06581061f, 0.04252101f, 
    0.08756720f, -0.06965256f, 0.03302253f, -0.07530133f, -0.09855777f, 0.03079781f, 0.06405061f, -0.05970430f, 
    0.01176595f, 0.03076139f, -0.00567745f, 0.06489355f, 0.00559450f, -0.03570923f, 0.04810852f, -0.09312421f, 
    -0.09280904f, 0.05166788f, -0.09456430f, 0.01178125f, -0.01022513f, -0.07202904f, -0.06898896f, -0.02426675f, 
    -0.00356169f, -0.05083219f, -0.04346240f, -0.07881718f, 0.03136870f, 0.07114072f, -0.09952683f, -0.07495066f, 
    -0.04140393f, -0.08323418f, 0.03261609f, -0.08616848f, 0.06227253f, -0.00889412f, 0.00968994f, -0.02712767f, 
    -0.06667330f, -0.02622776f, 0.06542353f, 0.04223542f, -0.08734853f, -0.09795236f, 0.00196920f, -0.02630760f, 
    -0.09437656f, 0.03655681f, 0.03796727f, 0.05558910f, 0.01603190f, -0.00688539f, -0.10653716f, -0.07231069f, 
    -0.01568878f, -0.06788909f, 0.02792377f, 0.03651113f, 0.00398933f, -0.05590883f, 0.00267824f, -0.08123063f, 
    -0.05134506f, -0.05128816f, 0.05639585f, 0.00588426f, 0.04179085f, -0.00004389f, 0.05134857f, -0.04295065f, 
    -0.36653280f, -0.45597720f, -0.02490757f, 0.15123738f, 0.11782853f, -0.42432070f, -0.08066386f, 0.05958400f, 
    -0.52190107f, 0.43452528f, 0.34877542f, -0.23605701f, -0.15356931f, 0.07672731f, 0.22211258f, -0.06804120f, 
    -0.03540456f, -0.05726315f, 0.18096042f, 0.24854706f, 0.23777398f, 0.29458871f, 0.01690445f, -0.06223628f, 
    -0.02868057f, 0.15992466f, 0.28376046f, -0.00357847f, 0.15450351f, -0.13629855f, 0.06255215f, 0.16347750f, 
    0.03467225f, -0.06585050f, -0.50759834f, 0.06300352f, 0.35909554f, -0.02440608f, 0.30865023f, -0.38365805f, 
    -0.17782059f, 0.48163974f, 0.23148070f, 0.02947908f, 0.22777842f, -0.31559935f, -0.12634487f, -0.04568880f, 
    0.32150847f, 0.12840559f, 0.35303631f, -0.14485289f, 0.06359030f, 0.38090470f, 0.31083086f, 0.02937507f, 
    -0.44671234f, 0.20607321f, 0.32927027f, -0.21090931f, 0.01860500f, -0.36094132f, 0.27071843f, -0.00125985f, 
    -0.12806502f, -0.17685030f, -0.27258030f, 0.06778095f, 0.28262800f, 0.09979162f, -0.09954105f, -0.19370407f, 
    0.13914256f, 0.12208791f, 0.13493724f, -0.10656974f, -0.14690237f, 0.28830793f, -0.06753673f, -0.03343346f, 
    0.41409335f, 0.02336921f, 0.09425015f, -0.22324379f, -0.03044198f, -0.07422608f, 0.20551734f, 0.16441742f, 
    -0.02090620f, -0.08348016f, -0.31425315f, -0.24325497f, -0.26290199f, -0.14570388f, -0.04677901f, -0.09212421f, 
    -0.02722092f, 0.02346678f, 0.07729825f, -0.02432014f, -0.00275048f, -0.07118366f, 0.39846975f, -0.11394180f, 
    -0.02151460f, -0.02676271f, -0.27886254f, 0.30905160f, -0.02763330f, -0.03733409f, -0.07479867f, 0.01087960f, 
    -0.14245415f, -0.02491412f, -0.07662662f, -0.03374081f, 0.14890255f, -0.43375245f, 0.02046681f, 0.05025018f, 
    -0.04528010f, 0.14689393f, 0.20977005f, 0.23537014f, 0.36379573f, 0.06462004f, -0.06254449f, -0.50977260f, 
    -0.07093885f, 0.03118050f, -0.04420947f, -0.74065650f, -0.05567001f, 0.05260970f, 0.07401658f, -0.03317396f, 
    -0.12402246f, 0.14639369f, -0.04641742f, -0.06254398f, 0.08862895f, -0.04018737f, 0.09198759f, 0.05329459f, 
    0.09598387f, 0.19014260f, -0.00026217f, 0.13780601f, 0.15630677f, -0.58497155f, 0.05767237f, 0.35422710f, 
    -0.12007034f, -0.12114718f, -0.12383157f, -0.01688957f, -0.00901396f, -0.17115921f, 0.20685981f, 0.02132980f, 
    -0.12096117f, 0.34391588f, 0.09996395f, -0.53807223f, 0.00070521f, -0.15201361f, -0.32329947f, 0.52206516f, 
    0.05884342f, 0.56955391f, -0.06778840f, 0.04396636f, -0.23827220f, 0.05841769f, 0.07092514f, 0.08629291f, 
    -0.25471374f, 0.11267005f, -0.18883674f, -0.02907919f, 0.06668053f, -0.21716624f, -0.18439434f, 0.13648254f, 
    -0.04448084f, 0.17828457f, -0.60806400f, -0.03050740f, -0.02233525f, 0.04214165f, -0.22339013f, -0.04502977f, 
    -0.07861369f, 0.32518324f, -0.14927521f, -0.01843059f, 0.21565841f, 0.02450109f, 0.15604998f, 0.01270188f, 
    -0.24384639f, 0.07687142f, 0.24197188f, 0.01207422f, 0.03759919f, 0.04771488f, 0.11761424f, 0.03162230f, 
    -0.30061248f, 0.12347633f, -0.24645332f, 0.51669741f, -0.05978900f, 0.04169667f, -0.16789208f, -0.00315928f, 
    -0.04703537f, 0.04752130f, -0.01723025f, 0.29025143f, 0.14417490f, 0.03291732f, 0.07508032f, -0.01196833f, 
    -0.03233062f, 0.06429071f, 0.04629611f, -0.28444788f, -0.17772755f, -0.16539110f, -0.15125309f, 0.09021905f, 
    -0.19464141f, -0.05084509f, -0.13092966f, -0.00364002f, 0.13769734f, -0.05623600f, 0.25851122f, -0.08725393f, 
    0.02901146f, 0.09247334f, -0.23376580f, -0.00997775f, -0.17217940f, -0.18912970f, -0.01590681f, 0.08762249f, 
    0.01600037f, 0.15826376f, -0.54173875f, -0.48354667f, 0.04585819f, -0.17541905f, -0.02793624f, 0.47320333f, 
    0.04140108f, -0.01243899f, 0.02107408f, -0.00993224f, -0.05498276f, 0.04020082f, 0.05152006f, -0.03528421f, 
    -0.01750819f, 0.08220281f, -0.01911503f, -0.08553057f, -0.03311918f, -0.06930890f, -0.01498192f, -0.09245286f, 
    -0.09473977f, 0.02593562f, -0.05069675f, 0.00312292f, -0.02145828f, -0.05629890f, 0.08533527f, -0.02407845f, 
    0.01599730f, 0.02054373f, -0.16419157f, -0.02913200f, -0.08758774f, -0.01906776f, -0.05487177f, 0.02847651f, 
    -0.09951478f, -0.06514124f, 0.01796964f, -0.08466911f, -0.06758160f, -0.17642206f, -0.04837987f, -0.02617852f, 
    -0.05310050f, 0.08997504f, -0.01270316f, -0.08651558f, -0.02543999f, -0.12147040f, 0.00363595f, -0.07181828f, 
    0.03335144f, -0.01385856f, -0.06001297f, 0.02812780f, 0.00229943f, 0.01753944f, -0.07617177f, 0.05721266f, 
    0.01408349f, -0.04115682f, -0.14316238f, 0.04250965f, -0.07202028f, 0.02160851f, -0.01982109f, 0.07568219f, 
    -0.14464083f, -0.07460155f, -0.04562071f, 0.08492656f, -0.05360476f, -0.02948929f, -0.07213302f, -0.07274228f, 
    -0.15117030f, -0.07074406f, -0.06737377f, -0.00826792f, 0.03269168f, -0.06208326f, -0.04605687f, -0.17523165f, 
    -0.12918985f, -0.04527479f, -0.04405176f, -0.08202446f, -0.04044235f, -0.00735257f, -0.02458967f, -0.03537994f, 
    0.05046144f, -0.10982579f, -0.05775970f, -0.04475610f, -0.05271190f, 0.04082279f, 0.07624958f, 0.07844941f, 
    -0.04844607f, 0.06308323f, 0.03748826f, -0.12239092f, -0.02638351f, 0.00489456f, -0.10797504f, -0.05432259f, 
    -0.17942852f, -0.03044181f, -0.13994673f, 0.02904953f, -0.07765456f, -0.10297062f, -0.07160696f, -0.06953104f, 
    -0.05549376f, -0.09531102f, 0.07777958f, -0.04652165f, 0.01654826f, -0.00374142f, -0.09764835f, 0.03315861f, 
    0.04272438f, 0.03101807f, -0.06925790f, -0.13629191f, 0.01289280f, 0.01509520f, 0.03299551f, -0.04781178f, 
    0.09055436f, 0.01900728f, -0.00089432f, -0.03763985f, 0.01892894f, -0.05132965f, -0.04521405f, 0.05286157f, 
    -0.00692003f, -0.11077335f, -0.09964135f, -0.03543243f, -0.07383639f, 0.05979258f, -0.13199688f, -0.00675612f, 
    -0.06465984f, 0.03739788f, -0.11760845f, -0.09150415f, 0.00349015f, -0.02260000f, 0.02165372f, 0.00225206f, 
    -0.10654595f, -0.01270507f, 0.02966030f, -0.03883598f, -0.04802271f, -0.07951327f, 0.05249501f, -0.05432943f, 
    -0.00712238f, -0.05445309f, -0.02211368f, 0.02822297f, -0.04672214f, 0.02990054f, -0.01076849f, -0.00565327f, 
    -0.09645975f, -0.02601337f, -0.08014192f, -0.00567181f, -0.01892440f, 0.01655558f, -0.01639452f, 0.01998320f, 
    -0.06127055f, 0.05788508f, -0.07271948f, -0.06971277f, -0.03945225f, -0.13301358f, -0.04489156f, -0.14111608f, 
    -0.03929517f, -0.09137491f, -0.05545208f, -0.08501313f, -0.01738833f, -0.03203821f, -0.02578427f, -0.08157392f, 
    0.02715426f, -0.01094957f, 0.03355480f, 0.03650545f, -0.08341011f, -0.07058195f, -0.04477468f, 0.01674724f, 
    -0.09723289f, -0.07524588f, -0.01958749f, -0.13875285f, 0.01491685f, -0.07152127f, 0.02159679f, 0.00576878f, 
    -0.02155938f, 0.04605851f, 0.03349152f, 0.02596197f, -0.05086170f, 0.05606325f, -0.12367351f, -0.03578709f, 
    -0.00067462f, 0.01095755f, -0.03162187f, 0.01878946f, -0.01166209f, -0.06725313f, 0.02449740f, 0.09297324f, 
    -0.10834750f, 0.06871303f, -0.11813681f, -0.02190345f, 0.00645532f, -0.04120290f, 0.03603448f, -0.12456333f, 
    -0.07558083f, -0.07184943f, -0.05591797f, -0.00068542f, -0.00892366f, -0.11893619f, -0.00976060f, 0.03038906f, 
    -0.09575605f, -0.03143823f, -0.05136287f, -0.08931842f, -0.09435344f, -0.14217815f, 0.02691167f, -0.07699692f, 
    -0.01978593f, 0.05840430f, -0.06994867f, -0.03499579f, 0.00784299f, 0.03891019f, -0.01530528f, -0.10234173f, 
    0.01639465f, -0.05567767f, 0.14410064f, 0.20313673f, -0.15077460f, -0.04710741f, -0.31811860f, -0.25217423f, 
    -0.39979237f, -0.17228977f, 0.15911765f, 0.07970870f, 0.13922743f, -0.08620004f, 0.01473769f, -0.17885339f, 
    -0.19487588f, -0.19260553f, -0.30359799f, -0.17973372f, -0.04756534f, 0.03882857f, 0.03342340f, 0.02853889f, 
    -0.03693326f, 0.30129763f, 0.26010999f, 0.11482061f, -0.09390911f, 0.21143748f, 0.05697194f, 0.01579861f, 
    -0.02900439f, -0.06614646f, 0.04966957f, 0.20434023f, -0.05924493f, -0.04680362f, 0.34224468f, -0.23579441f, 
    -0.46862370f, -0.22906876f, 0.07108964f, 0.05814444f, 0.11998480f, 0.09187872f, 0.04681592f, -0.11328913f, 
    0.01375563f, 0.32727537f, 0.41372281f, -0.17809933f, -0.04326068f, -0.04712017f, -0.01099922f, 0.19562839f, 
    0.18391454f, -0.16084890f, 0.45380124f, 0.15883908f, 0.19767265f, -0.06417236f, -0.10825294f, 0.26539668f, 
    0.18473977f, 0.08375247f, 0.14249381f, 0.05598781f, -0.21043728f, 0.07017304f, 0.21238773f, -0.19915289f, 
    0.00409458f, 0.13806717f, -0.17711712f, 0.06779312f, 0.16545978f, -0.35615766f, 0.07574099f, 0.03430428f, 
    -0.07349190f, -0.08363145f, 0.15271491f, -0.11164932f, 0.03270674f, -0.00838029f, -0.27829131f, -0.08660700f, 
    0.02013429f, 0.23959672f, -0.37282747f, 0.11235173f, 0.01512420f, -0.11927559f, -0.01226307f, 0.06028712f, 
    0.08932581f, 0.08666750f, -0.00261090f, 0.38309887f, 0.22510195f, 0.19169140f, -0.10137300f, -0.12421343f, 
    0.26183504f, -0.05454057f, -0.03960451f, 0.24513388f, -0.09434590f, -0.22929089f, 0.02636733f, 0.01566584f, 
    -0.08836393f, -0.10382347f, 0.17577012f, 0.17401801f, 0.02457616f, 0.13502288f, 0.01334548f, 0.18666537f, 
    -0.03822065f, -0.08333701f, -0.09117858f, 0.13821939f, 0.15702407f, 0.20427459f, 0.24678040f, -0.01685257f, 
    -0.15241453f, -0.08750068f, -0.16192497f, -0.17514554f, -0.35542846f, -0.25550523f, 0.01275418f, 0.27422103f, 
    -0.04963366f, -0.34926555f, -0.06328972f, 0.00648970f, 0.16090080f, -0.20759109f, -0.04665738f, -0.22176252f, 
    0.04080714f, 0.00105920f, -0.30201644f, -0.28504929f, -0.08837995f, 0.15752871f, 0.00149755f, 0.18710254f, 
    0.21720929f, -0.01479572f, -0.16406904f, 0.07092925f, 0.03835857f, -0.07086199f, 0.08091326f, -0.02326793f, 
    -0.00621704f, 0.17150055f, -0.13928834f, -0.00797047f, 0.09825852f, 0.15422054f, 0.14705674f, -0.12076189f, 
    -0.37742472f, 0.11692493f, 0.10687812f, 0.32168078f, 0.10511221f, -0.17016503f, -0.28531653f, -0.04236564f, 
    0.17643070f, -0.19307575f, 0.07213737f, 0.11609697f, -0.05500893f, 0.02662339f, -0.13532291f, 0.07309041f, 
    -0.21009246f, 0.11057177f, 0.02402471f, -0.02013743f, -0.13889828f, -0.62224531f, -0.00588345f, 0.10113910f, 
    0.25453848f, 0.06136714f, -0.21979973f, -0.00532012f, 0.44111997f, -0.13013408f, 0.38349825f, 0.00238006f, 
    -0.09875542f, 0.21326993f, 0.10842633f, 0.10849763f, 0.02331463f, 0.57420421f, 0.18053049f, -0.02364595f, 
    0.15918639f, -0.15085763f, 0.08168194f, 0.26877737f, -0.00279522f, 0.06152880f, -0.04904243f, 0.09143065f, 
    -0.04522308f, 0.31114930f, -0.04893403f, 0.09071916f, 0.03364109f, -0.12481657f, -0.03169701f, -0.20989980f, 
    -0.23820113f, -0.08672521f, -0.10028180f, -0.11293174f, 0.03958743f, -0.08239565f, 0.03076370f, -0.09252653f, 
    0.07656264f, -0.22848850f, 0.10459110f, 0.21169797f, 0.21154632f, 0.14208190f, 0.13692884f, 0.45856637f, 
    0.20796399f, -0.15071052f, -0.06387511f, 0.13647920f, 0.14351510f, -0.00975098f, -0.25267211f, -0.00376391f, 
    -0.28529263f, -0.16160601f, 0.42736712f, 0.08368494f, 0.31178871f, 0.05929551f, -0.24411638f, -0.10989548f, 
    0.02480701f, -0.13853140f, 0.03493989f, 0.00715071f, -0.00138931f, -0.17241040f, 0.17662968f, 0.03674712f, 
    -0.04356768f, 0.00810222f, 0.08500881f, -0.06050878f, 0.07919402f, -0.01697308f, 0.07266369f, -0.22785719f, 
    -0.07885680f, -0.18414760f, -0.09787247f, -0.00433895f, -0.07430035f, 0.28698605f, 0.01407574f, 0.05736089f, 
    0.03993380f, 0.04736946f, 0.08457626f, 0.14763121f, 0.07602264f, 0.00318520f, 0.07166678f, -0.12680425f, 
    0.31510031f, -0.03699448f, -0.06121616f, 0.21264881f, -0.09379489f, 0.15269643f, 0.33409712f, 0.23344573f, 
    -0.11130714f, 0.08662062f, 0.14867051f, 0.06974747f, 0.06469005f, -0.06345110f, -0.18687935f, -0.26139101f, 
    0.23408754f, 0.02450510f, 0.28168753f, 0.20507090f, -0.01676774f, -0.02325479f, 0.06027102f, 0.02374177f, 
    0.11447192f, -0.18674558f, 0.33205232f, -0.03622290f, -0.01527251f, 0.16488563f, 0.14203945f, 0.14093660f, 
    -0.06000943f, -0.14675206f, 0.07168578f, -0.08937737f, -0.01901842f, 0.10578711f, 0.03779968f, 0.15554106f, 
    0.15192270f, 0.17229743f, 0.00330759f, -0.03235654f, -0.10208323f, -0.01392003f, -0.06905022f, -0.03188887f, 
    -0.00078623f, -0.16490664f, 0.09495541f, -0.07323757f, -0.05606437f, 0.02345025f, -0.04489415f, -0.02552805f, 
    0.00144142f, 0.09050351f, 0.25811440f, 0.18130885f, -0.07104790f, -0.08944003f, 0.08713462f, -0.30977020f, 
    -0.03153750f, -0.07015651f, 0.05225786f, 0.10070864f, 0.24919441f, -0.05809981f, 0.01052425f, -0.02464591f, 
    0.27685481f, -0.12185832f, -0.13667168f, 0.19918461f, -0.13165724f, -0.12297412f, 0.12013294f, 0.15214653f, 
    -0.15293266f, -0.13326311f, 0.00480753f, -0.20399536f, 0.10898175f, 0.06480386f, -0.04547860f, 0.17611472f, 
    -0.26169553f, -0.02865811f, 0.06883331f, 0.21306676f, 0.22978012f, 0.16927022f, 0.12344477f, -0.11257414f, 
    -0.11774609f, -0.07270672f, 0.06328248f, -0.02074811f, -0.01314841f, -0.07685677f, -0.06468990f, 0.03131778f, 
    0.04413537f, -0.06875817f, 0.00274735f, -0.12502387f, -0.05601782f, -0.06041856f, -0.00041873f, -0.13139926f, 
    -0.09453581f, -0.00806823f, -0.06890685f, -0.08199160f, -0.13222629f, -0.03287942f, 0.04944113f, -0.08389252f, 
    -0.07832151f, -0.11760905f, -0.00583381f, -0.08053022f, -0.05857361f, -0.08830168f, -0.07109096f, -0.06326994f, 
    -0.07652105f, 0.02770317f, 0.05123801f, 0.06047126f, 0.00940207f, -0.00041446f, -0.11199664f, -0.02165020f, 
    -0.01435038f, -0.00001809f, 0.04057983f, 0.05458372f, -0.06812774f, -0.03097177f, 0.02520974f, 0.02095561f, 
    -0.09178257f, -0.00026625f, -0.09314575f, 0.06395943f, 0.08232322f, -0.08657722f, 0.03775707f, -0.08532497f, 
    0.03182434f, -0.02726844f, -0.07483397f, 0.03953897f, 0.03363608f, 0.00547193f, -0.05395801f, 0.03669709f, 
    0.00320032f, 0.07796030f, 0.06041678f, -0.04112657f, -0.03564311f, -0.06649813f, -0.07523946f, -0.02832594f, 
    0.02464942f, 0.07176788f, -0.08491113f, -0.05021041f, -0.11291067f, 0.02138364f, -0.07460236f, 0.01245606f, 
    -0.08307759f, 0.00472198f, -0.07867098f, -0.02471210f, -0.04920373f, 0.08125778f, 0.03886975f, 0.00995316f, 
    0.06550105f, -0.01170210f, -0.05043229f, 0.01996453f, -0.00685653f, -0.03734536f, 0.04338469f, -0.02569441f, 
    -0.03950839f, -0.05287563f, 0.01302474f, 0.03751065f, 0.00036136f, -0.03126664f, 0.03661339f, -0.04428767f, 
    -0.00712735f, -0.04902314f, -0.07639596f, -0.05868487f, 0.03585895f, -0.02317874f, 0.02833826f, 0.04017798f, 
    0.02740464f, -0.13724525f, 0.03487688f, 0.01340353f, -0.09515574f, -0.01745235f, 0.00858216f, -0.08995287f, 
    -0.02655161f, 0.04941737f, 0.04157115f, -0.07407917f, 0.06976220f, 0.03722892f, -0.04708758f, -0.09732366f, 
    0.10292663f, -0.19863811f, 0.16183892f, 0.17854781f, 0.14563709f, -0.02358296f, 0.42534161f, -0.11420037f, 
    -0.25958678f, 0.01269912f, 0.17735060f, -0.12401075f, -0.14261113f, 0.10628359f, -0.27949464f, 0.13090007f, 
    0.10693265f, -0.50184387f, -0.22891870f, -0.14705765f, -0.09439998f, 0.01473761f, -0.04956779f, 0.03808560f, 
    0.19143547f, 0.03385850f, 0.05217165f, -0.15561783f, 0.13525650f, -0.02936848f, -0.06760146f, 0.05142602f, 
    0.04489448f, -0.28876728f, -0.43679744f, -0.03165802f, 0.13105567f, -0.04435495f, -0.16625279f, -0.10300651f, 
    -0.19252522f, -0.35668385f, 0.10785510f, -0.05741114f, 0.13134091f, 0.10397843f, -0.38597479f, -0.04883831f, 
    0.28161234f, -0.00704344f, 0.29033563f, 0.47591200f, 0.01859979f, 0.10021936f, 0.10312811f, 0.09511136f, 
    0.27657393f, -0.03200457f, 0.07303694f, -0.24116515f, 0.24404170f, 0.30443138f, 0.28447700f, 0.28404248f, 
    -0.41358489f, 0.06220818f, 0.16824891f, 0.04077958f, 0.16363636f, 0.09639068f, 0.02145981f, -0.06093427f, 
    0.32305878f, 0.01479220f, -0.22784463f, -0.01191373f, -0.46409184f, -0.12028091f, -0.08748788f, 0.15940976f, 
    0.06810264f, -0.16489935f, 0.04237030f, -0.39640874f, 0.08523175f, 0.08215345f, 0.11043977f, -0.00909641f, 
    0.01222251f, 0.20982908f, 0.04494276f, -0.52947736f, -0.12905475f, -0.10254755f, 0.04876985f, 0.31410876f, 
    0.17919539f, 0.07327144f, 0.19658658f, -0.07648336f, -0.38667908f, -0.08541930f, 0.00052746f, -0.36567548f, 
    0.13050555f, 0.14305831f, -0.21370669f, -0.07234634f, -0.01348901f, -0.22644679f, -0.06816291f, -0.34483054f, 
    -0.45386052f, -0.01706998f, 0.30258432f, -0.15938818f, 0.14238039f, 0.09231051f, -0.00971069f, 0.00865199f, 
    0.20345838f, 0.30393529f, -0.55130810f, -0.09252926f, 0.18099128f, 0.03383724f, -0.27495778f, 0.18372285f, 
    0.18816890f, -0.06030316f, 0.14114353f, 0.19716065f, 0.20613912f, 0.27593553f, -0.03529575f, 0.15489106f, 
    0.24436954f, 0.11885857f, 0.12458062f, -0.23507193f, -0.04773374f, -0.06948251f, 0.18327150f, 0.11693347f, 
    -0.04350610f, 0.05135216f, 0.00616121f, -0.11331649f, 0.10478405f, -0.05921040f, -0.07269638f, 0.18287458f, 
    0.15241437f, -0.23337825f, 0.28252345f, 0.08087229f, 0.06299540f, -0.07643777f, 0.25457537f, 0.08447409f, 
    0.07329649f, -0.01321346f, -0.03532676f, -0.19884948f, 0.19811586f, 0.08113005f, -0.09179337f, 0.05378539f, 
    0.41735092f, -0.13164693f, 0.08648346f, 0.03145713f, 0.13137642f, 0.02002055f, -0.09703017f, 0.03020624f, 
    -0.28735468f, 0.04569725f, -0.40080056f, 0.16086510f, -0.00349455f, 0.19721302f, 0.34598655f, 0.19791396f, 
    0.09853784f, -0.03466967f, -0.13029261f, -0.21712647f, 0.21805604f, 0.38423803f, 0.33775616f, 0.11249401f, 
    -0.33679426f, 0.01778691f, 0.13680618f, 0.07119152f, 0.05775603f, 0.07634193f, -0.13606201f, 0.03715003f, 
    0.35491589f, -0.17238809f, 0.06318258f, -0.08258744f, -0.16463840f, -0.02132272f, -0.08220905f, 0.11403473f, 
    0.18730848f, -0.01185015f, -0.03753711f, 0.01186190f, -0.04169119f, 0.01485504f, 0.30434781f, -0.15936193f, 
    0.06081963f, -0.31449497f, 0.12307007f, -0.13275898f, 0.07859778f, -0.06595644f, 0.07390810f, -0.13090025f, 
    0.03840218f, -0.01251411f, 0.06479074f, -0.18616244f, -0.24060521f, -0.41532376f, 0.12390316f, -0.00863819f, 
    -0.47625697f, 0.41867772f, -0.09684207f, -0.09975172f, 0.03941125f, -0.07359324f, 0.00027033f, -0.35032329f, 
    -0.04223754f, 0.05640475f, 0.08549730f, -0.27254418f, -0.08972616f, 0.06306594f, 0.07020468f, 0.00853724f, 
    -0.04475752f, 0.00211672f, -0.26097587f, -0.14396940f, -0.04484927f, -0.00847894f, -0.11944921f, 0.25014865f, 
    -0.03031064f, 0.00598751f, -0.09888978f, -0.01639881f, -0.07475865f, 0.03028024f, 0.02801899f, 0.03362566f, 
    0.02251389f, -0.06945995f, -0.06906170f, 0.07028886f, -0.02909298f, -0.07940456f, -0.07275013f, 0.06423621f, 
    -0.03570019f, -0.06647240f, 0.00021833f, -0.11780374f, -0.00547577f, -0.05741745f, 0.06173871f, -0.08411111f, 
    -0.01847231f, 0.03518859f, 0.01627710f, -0.02462695f, -0.03877757f, -0.08041286f, -0.05133585f, -0.01413393f, 
    0.03226399f, 0.02870704f, -0.07682987f, -0.06606776f, -0.00927995f, -0.00230675f, -0.05231279f, 0.00781445f, 
    -0.07523140f, -0.05423698f, -0.08537145f, 0.03265446f, 0.01769259f, 0.04780046f, -0.09519600f, 0.01795493f, 
    0.03698500f, 0.01788931f, 0.05234439f, -0.08233284f, -0.06791689f, 0.06575909f, 0.05292352f, -0.05910970f, 
    -0.00169222f, -0.01027895f, -0.02120680f, -0.02888355f, -0.02309651f, -0.00029080f, -0.05315142f, -0.00780620f, 
    0.03285245f, -0.08218753f, -0.00118370f, -0.04430660f, 0.05605004f, 0.04373396f, 0.00129732f, 0.05397902f, 
    0.02040585f, -0.06576639f, -0.02798536f, 0.07149064f, 0.05487543f, -0.04981019f, -0.02761555f, -0.01953031f, 
    -0.03047703f, -0.10272296f, -0.06102856f, 0.06452441f, 0.07619884f, 0.00993490f, 0.06854355f, -0.09206888f, 
    0.03949344f, -0.08523460f, -0.00598398f, -0.05911640f, 0.02295748f, 0.02715238f, -0.03644511f, -0.03145353f, 
    -0.06776473f, -0.05810576f, 0.05296558f, 0.00155241f, 0.02711666f, -0.05398310f, -0.03193503f, -0.04198637f, 
    -0.03353548f, -0.05899275f, 0.01977790f, 0.01029200f, -0.08519387f, -0.01230473f, 0.02834669f, 0.02451434f, 
    0.05314644f, 0.00201018f, 0.00787671f, 0.02084923f, 0.04813912f, -0.03300405f, 0.03531582f, -0.01270253f, 
    -0.01275819f, -0.07361419f, 0.00556326f, 0.02155513f, -0.02935725f, 0.01591973f, 0.02467935f, -0.00341884f, 
    0.08709313f, -0.03879039f, 0.05798397f, 0.09397727f, -0.25700715f, 0.09211987f, -0.10327055f, -0.24489366f, 
    0.18293181f, -0.61404270f, 0.07532872f, -0.15545128f, 0.29526067f, 0.07278467f, -0.26139653f, 0.26582643f, 
    0.05091218f, -0.01896917f, -0.10602170f, -0.06890032f, -0.19960040f, -0.13278365f, -0.07079532f, 0.19114494f, 
    0.09244019f, 0.20562047f, 0.11967315f, -0.20783122f, 0.12196835f, 0.17270321f, 0.03579379f, 0.29051295f, 
    -0.11454937f, 0.07667171f, 0.43398783f, -0.05413770f, 0.42150185f, -0.00505321f, -0.12696537f, 0.31982261f, 
    0.28132752f, -0.23225921f, 0.08152552f, 0.05020240f, -0.02911005f, 0.09905220f, -0.11007303f, -0.07052211f, 
    0.09168621f, -0.00996952f, 0.14928010f, 0.01836738f, 0.02111601f, 0.26922217f, 0.20071292f, 0.12656581f, 
    0.16712886f, 0.00148848f, 0.02143844f, -0.09814087f, 0.26275301f, -0.19063973f, -0.00344795f, 0.14393425f, 
    0.05372824f, 0.10729610f, 0.42944685f, -0.04133068f, 0.10346804f, 0.10196097f, 0.02984239f, -0.18698253f, 
    0.21738581f, -0.04404345f, -0.01051276f, 0.03093990f, 0.03847420f, 0.13073124f, 0.06694280f, 0.10458428f, 
    -0.02488600f, 0.00269209f, -0.21358195f, 0.35215193f, -0.01852908f, 0.06849346f, 0.30493489f, 0.02186656f, 
    0.01696193f, 0.02561666f, 0.06025110f, 0.18532917f, -0.08517484f, -0.16258894f, 0.08525890f, -0.26525187f, 
    0.21475512f, -0.06418154f, 0.09443950f, -0.11111138f, -0.17797965f, -0.06684021f, -0.15837380f, -0.06812521f, 
    0.13643120f, 0.02458512f, -0.19378670f, -0.23044865f, 0.15838251f, 0.11628420f, -0.17763670f, -0.27907136f, 
    -0.05410262f, -0.35021010f, 0.18245961f, 0.03421174f, -0.01383260f, 0.16681598f, -0.01204788f, 0.08072311f, 
    -0.04917272f, 0.27182236f, -0.09304526f, -0.24926174f, -0.05853789f, 0.03865064f, 0.21351177f, 0.33939791f, 
    -0.05444921f, -0.02255230f, 0.02285516f, -0.06731144f, 0.05191527f, 0.04881550f, -0.06770232f, 0.03893724f, 
    -0.04888006f, -0.05522916f, -0.11372106f, 0.04040499f, 0.04462808f, -0.09663216f, -0.07628680f, -0.08429120f, 
    -0.07123651f, 0.00199356f, 0.02819465f, -0.02222919f, -0.09713838f, 0.03398509f, -0.05855864f, -0.02226348f, 
    -0.02270417f, 0.02254400f, 0.01460348f, -0.03636200f, 0.08582456f, -0.01252092f, -0.08906016f, 0.07552768f, 
    0.00597587f, 0.08679809f, -0.00055433f, -0.02641375f, 0.04278025f, -0.06567820f, 0.04344640f, -0.05948786f, 
    -0.02324411f, -0.02656050f, -0.06863182f, 0.02767564f, -0.03038987f, 0.01213927f, 0.00091761f, 0.05538641f, 
    -0.06174790f, -0.04781005f, -0.07436430f, 0.00530825f, -0.00252532f, 0.00642866f, -0.06395309f, 0.04052244f, 
    -0.02790792f, -0.08885033f, -0.06058732f, 0.03996108f, 0.04021816f, -0.04967886f, -0.05532094f, 0.06519293f, 
    -0.03683771f, 0.04495844f, -0.02114012f, -0.08665653f, -0.00260732f, -0.08911189f, -0.07133097f, -0.08943319f, 
    -0.04966831f, -0.01912781f, 0.00645606f, 0.05791905f, 0.03428445f, 0.05025414f, -0.02124246f, -0.06596407f, 
    0.00117180f, -0.02313453f, 0.04690875f, 0.03327264f, 0.07104987f, 0.05354628f, 0.04585632f, -0.07442681f, 
    0.05168895f, -0.04347407f, -0.07895038f, 0.03761218f, -0.04142995f, -0.09958647f, 0.01968012f, 0.04884847f, 
    -0.07159185f, -0.03156169f, -0.04734009f, -0.05587271f, -0.08754934f, 0.02206125f, -0.07931496f, -0.09126634f, 
    -0.07285181f, -0.07015374f, -0.04203750f, 0.06003363f, -0.04304020f, -0.04990966f, 0.00300189f, -0.07969812f, 
    -0.08733641f, 0.03256843f, -0.00134608f, 0.04266639f, -0.04287159f, 0.08286265f, -0.00708228f, -0.05652272f, 
    -0.08868212f, -0.03071866f, -0.01361591f, 0.01826832f, 0.07981150f, -0.08296591f, -0.03505860f, -0.05269694f, 
    -0.24104586f, -0.02328595f, 0.23279746f, 0.17856662f, 0.03157879f, 0.00385798f, -0.12951531f, -0.14151707f, 
    -0.16722199f, -0.20595443f, 0.21721995f, -0.00420083f, 0.01670199f, -0.08484877f, -0.37617317f, 0.12080619f, 
    -0.04962087f, -0.09343237f, -0.13781200f, -0.01050343f, 0.09844760f, -0.29078546f, -0.06717271f, 0.05170917f, 
    -0.31419086f, -0.05079283f, 0.05198319f, -0.13469173f, -0.12796833f, -0.05736848f, -0.12595163f, 0.03266416f, 
    0.22688872f, -0.16621546f, 0.11060014f, -0.17850164f, -0.01999995f, -0.10778485f, 0.03110568f, -0.02102837f, 
    -0.25328383f, 0.06580025f, 0.07263760f, 0.07441857f, -0.20203616f, -0.05360642f, -0.07906670f, -0.04497529f, 
    -0.25832477f, -0.03820457f, -0.21158683f, -0.41949838f, 0.01137822f, -0.32601020f, -0.20761766f, 0.02787419f, 
    0.24689907f, -0.03204354f, 0.17636949f, -0.11610059f, 0.16095614f, 0.06885014f, -0.14605875f, 0.15200417f, 
    -0.04738415f, -0.12188398f, -0.19454497f, 0.00789750f, 0.05388156f, -0.03141422f, -0.18747751f, 0.17100193f, 
    -0.27243277f, -0.25120777f, 0.26055023f, -0.01666301f, -0.13677490f, 0.02559468f, 0.18653144f, 0.20706406f, 
    -0.24999100f, -0.04719399f, -0.15402794f, 0.08274753f, -0.07026082f, -0.07653427f, -0.30387402f, -0.16402459f, 
    0.05230634f, 0.14415134f, 0.01331952f, 0.07102928f, -0.05492181f, 0.06058487f, -0.05370506f, 0.02763874f, 
    0.15021874f, 0.06067210f, 0.01527438f, 0.01040461f, -0.03509099f, -0.20297813f, -0.03633967f, 0.06555840f, 
    0.03894499f, -0.01413743f, -0.10562345f, -0.03202926f, 0.12113521f, 0.01220941f, -0.12983061f, -0.06711111f, 
    -0.21674715f, 0.04558397f, 0.22818300f, -0.22873327f, 0.08864972f, -0.25488672f, 0.03179954f, 0.03204862f, 
    0.09354815f, 0.08293930f, -0.16995218f, -0.10870811f, -0.20639613f, 0.10123145f, -0.06958842f, -0.08713976f, 
    -0.00910237f, -0.03115477f, 0.15124838f, -0.09072416f, -0.18792154f, -0.00248780f, 0.01095522f, -0.01895746f, 
    -0.01702932f, 0.16287272f, 0.04656592f, 0.07585705f, 0.23049355f, 0.07571876f, 0.02235098f, 0.23460789f, 
    0.11695445f, 0.02774821f, 0.03013011f, -0.02654874f, 0.08722564f, 0.03461361f, -0.06425092f, 0.12737258f, 
    0.11122432f, 0.17981568f, -0.06762160f, 0.01515305f, -0.00648311f, 0.06662872f, -0.05852933f, 0.22938681f, 
    -0.01134982f, 0.06231504f, 0.35410994f, -0.05351789f, 0.22088085f, -0.09790623f, -0.27525640f, -0.01100002f, 
    -0.00377468f, -0.08995491f, 0.04197552f, 0.15021248f, -0.01058499f, 0.02715457f, 0.05612466f, 0.04581679f, 
    -0.01065950f, 0.02222289f, 0.07894236f, -0.37668616f, -0.01793328f, 0.12213948f, -0.04804126f, -0.06522789f, 
    0.08405095f, 0.15799905f, 0.02786695f, -0.14272669f, 0.16682567f, -0.29346773f, -0.18066195f, -0.12059737f, 
    0.27522707f, 0.16141631f, 0.16564924f, -0.13957323f, 0.11593521f, 0.06845044f, -0.02667336f, 0.07585983f, 
    -0.01849713f, -0.16659492f, 0.19681264f, 0.02443207f, 0.19103947f, 0.15014917f, 0.22195490f, 0.08554319f, 
    -0.10210008f, -0.00936492f, 0.01740404f, 0.57819128f, -0.04058070f, -0.06892215f, 0.23454992f, 0.18689252f, 
    -0.02013632f, 0.26321411f, -0.04295935f, 0.05338770f, 0.01516606f, -0.13697378f, -0.03418985f, 0.07463348f, 
    0.00995707f, 0.00942931f, 0.01412490f, -0.00823496f, 0.07073601f, -0.01390610f, -0.13526307f, 0.05034031f, 
    0.16514643f, -0.03832478f, -0.00415463f, -0.18721464f, 0.12423830f, 0.20258707f, 0.10682522f, -0.06629796f, 
    0.00753932f, -0.00702350f, 0.09445534f, 0.22876301f, -0.02638621f, 0.02810419f, -0.21615674f, -0.03229967f, 
    0.16780718f, 0.13517612f, 0.03170376f, -0.11409839f, -0.26690772f, 0.04087501f, -0.07449739f, 0.33546633f, 
    0.50610107f, -0.15045854f, 0.28727660f, 0.10788626f, -0.08306837f, 0.21108758f, 0.21552914f, -0.05847104f, 
    0.66647518f, -0.07837144f, -0.03085077f, -0.40126470f, 0.15690103f, -0.03045106f, -0.16733786f, 0.12500286f, 
    0.01839930f, -0.21373034f, 0.09475720f, -0.04880213f, -0.12107116f, -0.08542694f, -0.04517548f, 0.10652501f, 
    0.39014015f, -0.06421031f, 0.14500684f, -0.09670085f, -0.05301519f, -0.23601934f, 0.14941254f, 0.02140263f, 
    -0.17000748f, -0.04564456f, -0.22950195f, -0.17015027f, 0.22214073f, -0.02335056f, -0.17783469f, 0.75829607f, 
    0.46285278f, 0.11621682f, -0.05622388f, 0.10245612f, 0.13572210f, 0.22818370f, -0.26006344f, 0.01542526f, 
    -0.09686022f, 0.08518016f, -0.09447671f, 0.89635378f, -0.02771935f, 0.22922169f, 0.22141226f, 0.14173585f, 
    0.09453069f, 0.03467415f, -0.04280926f, 0.03656646f, 0.21509252f, 0.28405860f, 0.39153337f, 0.09915079f, 
    -0.06685540f, 0.10010987f, 0.12476738f, -0.01326881f, 0.12698011f, 0.15373601f, 0.21171223f, -0.18796107f, 
    0.41109884f, 0.07724997f, -0.26086938f, 0.03758258f, -0.34674507f, -0.05953141f, 0.02580205f, 0.18518774f, 
    0.22347021f, -0.10920905f, 0.15410149f, -0.03016330f, 0.02498959f, 0.00011028f, 0.41988626f, 0.14802837f, 
    -0.04636474f, 0.00461191f, -0.48912051f, -0.30641758f, 0.03759794f, -0.44239715f, -0.01560380f, -0.16333185f, 
    0.18246193f, 0.05648723f, 0.23401640f, -0.33034399f, -0.37239164f, -0.40719345f, -0.03584073f, -0.38540667f, 
    -0.17370093f, 0.22173840f, -0.09420201f, 0.01169155f, 0.13449256f, -0.04221213f, 0.05390822f, -0.14899693f, 
    -0.24070697f, -0.25100335f, 0.25934350f, -0.07717317f, -0.15341045f, 0.26640207f, -0.31895256f, -0.15119869f, 
    -0.07048713f, 0.26166981f, -0.31291765f, -0.14798810f, 0.23534033f, -0.16256653f, -0.14556719f, 0.29393154f, 
    -0.06243695f, -0.09486392f, -0.01228362f, -0.01714188f, 0.00363790f, 0.01354169f, 0.03376447f, -0.06124758f, 
    0.08580340f, -0.07175694f, 0.03125308f, -0.09542723f, 0.03473628f, 0.03432852f, -0.02984948f, 0.01348024f, 
    -0.02816019f, 0.00431758f, -0.12523104f, 0.01855434f, -0.09770094f, 0.08081926f, 0.08254750f, 0.04354752f, 
    0.01790601f, 0.00372699f, -0.08091938f, -0.04462707f, 0.08745280f, -0.07965024f, -0.11895940f, -0.07851191f, 
    -0.01002091f, -0.02552741f, 0.06088097f, -0.03676906f, 0.03044793f, -0.07705294f, -0.08490659f, -0.08423673f, 
    0.06107065f, -0.06470060f, 0.04017035f, 0.01330368f, -0.07214864f, -0.00373896f, 0.02399009f, -0.04162750f, 
    -0.02269461f, -0.09183247f, -0.01319825f, 0.00344177f, -0.01998774f, -0.09655160f, 0.01996682f, -0.01277293f, 
    0.03066140f, 0.03948561f, 0.02401973f, -0.11029813f, 0.05944420f, -0.04140585f, 0.06143516f, -0.05345600f, 
    -0.01035943f, -0.00924808f, 0.05974390f, -0.02198460f, 0.02241663f, -0.02848237f, -0.07746289f, -0.04116539f, 
    -0.03335153f, 0.01536841f, 0.05592924f, -0.01795480f, -0.10226719f, 0.00511796f, -0.00806643f, -0.00009755f, 
    0.00948639f, -0.02092513f, -0.07473245f, -0.10850214f, -0.00124972f, -0.07445698f, -0.01483254f, -0.06143893f, 
    0.06789043f, -0.05801271f, 0.04914268f, 0.01557393f, -0.06195143f, -0.04760344f, 0.06875400f, 0.02270836f, 
    -0.11628548f, -0.05444832f, -0.00322958f, -0.11395142f, -0.02126561f, -0.02905033f, -0.05230353f, 0.03317339f, 
    0.02501300f, -0.06617385f, -0.08571371f, -0.01835301f, -0.07967321f, -0.10757537f, -0.00149040f, -0.04892816f, 
    -0.04914791f, -0.06411684f, -0.06532446f, -0.10635925f, -0.06049262f, -0.04068947f, -0.06536342f, 0.03885185f, 
    0.02515090f, -0.05682063f, 0.07847952f, -0.04071401f, 0.00217050f, -0.05626108f, -0.07602514f, -0.03947204f, 
    0.06136415f, 0.08054454f, -0.00561511f, -0.11290404f, 0.01079996f, -0.04489664f, -0.08775077f, -0.08937715f, 
    -0.10513608f, -0.00916232f, -0.04571536f, -0.01090073f, 0.00719333f, 0.05497867f, -0.05234220f, 0.01408833f, 
    -0.07935904f, -0.06472239f, -0.08385141f, -0.04858676f, -0.01557509f, -0.01573908f, 0.03902309f, 0.07038153f, 
    -0.02560973f, 0.03424751f, -0.11247822f, -0.05270287f, -0.08683273f, 0.00806359f, -0.03216197f, 0.03911697f, 
    -0.00295344f, -0.10186305f, -0.06777178f, -0.10394970f, -0.09637437f, -0.06265235f, 0.00971969f, -0.05484074f, 
    -0.10295139f, -0.04742264f, -0.09143874f, -0.00881593f, -0.07981500f, 0.04386009f, 0.03560601f, -0.01237616f, 
    -0.11006746f, -0.05353680f, 0.02104365f, -0.10868508f, 0.07070706f, -0.11863291f, -0.00822538f, 0.00204312f, 
    -0.07641933f, 0.02519586f, -0.15099239f, 0.04603433f, 0.05520116f, -0.06140268f, -0.14557303f, -0.06253128f, 
    -0.10257450f, -0.02278693f, -0.07128333f, 0.04705142f, -0.00994684f, 0.00094812f, -0.11446711f, -0.00701326f, 
    -0.03597748f, -0.04374306f, -0.01292637f, -0.12170976f, -0.07970346f, 0.03909954f, 0.02875780f, 0.03383665f, 
    -0.08301539f, 0.01017967f, -0.08570980f, -0.06971757f, -0.02255113f, 0.00029513f, -0.09379583f, -0.05920770f, 
    -0.00241280f, -0.00263406f, 0.09121313f, 0.02665985f, -0.08277494f, -0.00039189f, -0.03289626f, -0.03869808f, 
    0.02516216f, 0.02005245f, -0.04238170f, -0.08522440f, -0.09597328f, -0.10127823f, -0.02954879f, -0.03079362f, 
    -0.05870683f, 0.00385312f, -0.00429888f, -0.13101858f, -0.06674358f, -0.08256314f, -0.02849104f, 0.03301436f, 
    -0.09698226f, -0.08480984f, -0.03349183f, -0.01887747f, 0.02946302f, -0.00428319f, 0.07520761f, -0.13528205f, 
    -0.06540659f, 0.00443877f, 0.02973094f, -0.00780821f, 0.03354933f, -0.04039485f, -0.04522715f, 0.05988731f, 
    0.67015892f, -0.08863938f, 0.03588530f, -0.02875172f, -0.02491538f, -0.18139237f, 0.17957227f, 0.39104456f, 
    -0.18784031f, 0.08109308f, -0.03337041f, 0.05740681f, -0.05736301f, -0.03407544f, 0.00762569f, 0.07421722f, 
    0.05080263f, -0.05057100f, -0.00736065f, -0.18955639f, 0.05306826f, 0.00552862f, -0.04191447f, 0.23264185f, 
    -0.12622003f, -0.10608231f, -0.05752396f, 0.15824859f, 0.06184745f, -0.09922700f, 0.02069700f, 0.09663553f, 
    -0.01651134f, 0.01257817f, -0.23824455f, 0.19513968f, 0.00615017f, 0.09062329f, 0.05266086f, -0.16943245f, 
    -0.28024307f, -0.15220679f, 0.08912411f, 0.10413374f, 0.06420261f, 0.07127278f, -0.22101696f, 0.04122543f, 
    0.25038677f, -0.17189783f, -0.08925500f, 0.17662193f, -0.02330449f, 0.05390386f, -0.09163512f, -0.09575954f, 
    -0.11102334f, 0.15805233f, -0.06949308f, -0.28626803f, -0.00142134f, 0.01576681f, -0.04262285f, 0.02736024f, 
    -0.06179120f, 0.08465867f, -0.10682889f, -0.04809373f, 0.47489080f, 0.04945551f, 0.14666930f, 0.04439606f, 
    -0.02353364f, 0.25044727f, 0.13020672f, -0.01969492f, -0.04057749f, 0.43752444f, 0.08363339f, 0.11032944f, 
    -0.01578276f, -0.14345260f, 0.13971265f, 0.16962406f, 0.06251123f, 0.03604524f, 0.05564367f, 0.09449420f, 
    -0.04471911f, 0.28087768f, -0.07412795f, 0.06164530f, 0.16225249f, -0.19560796f, -0.01165600f, 0.09189736f, 
    -0.07509579f, 0.04288823f, -0.01209158f, -0.06664458f, 0.00593399f, -0.23232749f, 0.26036361f, 0.10432544f, 
    0.00709038f, -0.02576010f, -0.07630849f, 0.08884212f, -0.02255287f, 0.06415926f, 0.21429364f, 0.29255769f, 
    0.15052575f, 0.09887252f, -0.07361729f, 0.08473689f, 0.25751996f, -0.04022201f, -0.15937093f, 0.09419012f, 
    -0.02370900f, 0.04638975f, 0.18630809f, 0.12446809f, 0.17125073f, 0.03279105f, -0.22574146f, -0.06074851f, 
    0.19078988f, -0.00036953f, 0.03832445f, 0.04480928f, -0.11038122f, -0.17976817f, 0.02623765f, 0.08072468f, 
    0.18361874f, 0.20918788f, 0.08697436f, 0.03809533f, 0.06288147f, 0.04779448f, 0.13997190f, 0.22620679f, 
    -0.07212710f, 0.00220941f, -0.02870088f, -0.09587663f, 0.09138913f, 0.24849628f, 0.08584982f, -0.13332383f, 
    -0.09332298f, 0.02554720f, 0.04769641f, 0.15073429f, 0.05337403f, -0.04193952f, 0.01548888f, 0.24422485f, 
    0.03074953f, -0.01440390f, 0.03180723f, 0.21318017f, -0.19003324f, 0.02989827f, 0.34777358f, 0.10024244f, 
    -0.20477509f, -0.06893811f, -0.03297683f, 0.03730206f, 0.06564895f, -0.06406604f, -0.00870897f, 0.04630712f, 
    0.09381614f, 0.01770639f, 0.11540148f, -0.15658545f, -0.02036580f, -0.05340766f, 0.05757939f, 0.02835268f, 
    -0.13783027f, -0.03086598f, 0.20950060f, 0.07028520f, -0.02970552f, -0.21998270f, -0.22519886f, -0.06173943f, 
    0.22894838f, -0.01969284f, -0.08427618f, -0.04045433f, 0.09817810f, 0.04058588f, 0.00825017f, 0.00938300f, 
    -0.02587941f, -0.03125788f, 0.16817315f, 0.05835042f, 0.15896408f, 0.32161030f, -0.10477719f, -0.14562175f, 
    -0.06425032f, -0.04421432f, 0.18892324f, 0.26367235f, 0.02329791f, -0.05227398f, -0.13926953f, 0.00042054f, 
    0.05181404f, 0.12371827f, 0.07012018f, 0.13256119f, 0.02099819f, -0.02326144f, -0.02653535f, 0.03423934f, 
    -0.16533384f, 0.01643728f, 0.04124706f, 0.26569855f, 0.17437199f, 0.08766958f, 0.40756875f, 0.11978800f, 
    0.03811458f, -0.20360556f, 0.10878279f, 0.15395214f, 0.00215677f, 0.04667557f, 0.02137173f, 0.17273775f, 
    0.08042550f, -0.07434770f, -0.17111287f, 0.18603955f, 0.24050722f, -0.03645166f, 0.03627238f, 0.04003707f, 
    -0.03434100f, -0.14284572f, 0.38412172f, 0.30089417f, 0.00173910f, 0.02506172f, 0.00883639f, -0.10988218f, 
    0.08306676f, -0.08490434f, -0.01515099f, -0.10349298f, 0.01340406f, -0.07731252f, -0.08325719f, -0.05161978f, 
    -0.06051827f, 0.05488813f, -0.08756230f, -0.06742976f, -0.02986458f, -0.07283286f, 0.05576440f, 0.02958501f, 
    0.00053504f, -0.08107022f, 0.02841177f, -0.05368932f, -0.00175589f, -0.04896871f, -0.06575573f, -0.07825363f, 
    0.01460948f, -0.08676108f, 0.00020682f, -0.03040039f, 0.07878312f, -0.06905145f, -0.06166515f, -0.02666245f, 
    -0.04791548f, -0.00007518f, -0.04405057f, -0.02709471f, -0.02403287f, 0.00717137f, -0.10090294f, -0.04381739f, 
    0.06548961f, 0.02982008f, -0.07051630f, 0.02121386f, -0.03465329f, -0.02891319f, -0.02716853f, 0.04076765f, 
    -0.02363850f, 0.04408077f, -0.01957965f, 0.01028758f, -0.07452504f, -0.03055116f, 0.05425347f, 0.05537815f, 
    -0.03690745f, -0.02207202f, -0.01812322f, 0.04671592f, -0.02970010f, 0.03811432f, -0.04709299f, 0.01711574f, 
    0.00943007f, -0.03491786f, -0.02344199f, 0.04786687f, 0.00464719f, -0.07781298f, -0.01706212f, 0.05298804f, 
    0.00984818f, 0.06185623f, -0.08393804f, -0.10980471f, -0.03321495f, -0.05939018f, -0.10588042f, 0.05150071f, 
    0.04715062f, -0.06423590f, -0.02665535f, -0.07863753f, -0.07554036f, -0.08166216f, -0.01465142f, 0.00698485f, 
    -0.06098085f, 0.02955034f, 0.04264876f, -0.08272788f, 0.08182601f, 0.06147922f, 0.02346063f, -0.06636991f, 
    -0.07161071f, -0.08254596f, -0.07779359f, 0.00613280f, 0.04541729f, -0.03416665f, -0.00867290f, 0.05234909f, 
    -0.07596524f, 0.04390825f, -0.02030314f, -0.02686165f, 0.01119290f, -0.03356465f, -0.02709767f, -0.04818091f, 
    -0.01614226f, 0.03910844f, 0.04217264f, -0.08932982f, -0.02651493f, -0.07526344f, -0.06169753f, -0.00773825f, 
    -0.04779889f, 0.05850046f, 0.05106578f, 0.02288683f, -0.04418802f, -0.08384267f, -0.08451518f, -0.03837850f, 
    0.00052566f, 0.06943393f, -0.03778068f, -0.06180070f, -0.09377130f, -0.08973044f, -0.00737298f, -0.12683384f, 
    0.03114220f, 0.08277482f, -0.03239105f, -0.05977817f, 0.06051487f, -0.02234905f, -0.10291032f, -0.11741696f, 
    -0.00640988f, -0.07557148f, -0.01283529f, -0.01367687f, 0.01698600f, 0.04652069f, 0.07150894f, -0.11532485f, 
    0.00985764f, -0.07064212f, 0.01937793f, -0.01310830f, -0.02041372f, -0.01617873f, 0.04602121f, 0.03862252f, 
    -0.01933085f, 0.01117541f, 0.07431013f, 0.04470303f, 0.04791846f, 0.04266370f, -0.00233117f, 0.00417065f, 
    -0.04377659f, 0.08394498f, -0.08048762f, -0.01099877f, 0.04106752f, -0.07648085f, 0.10477766f, -0.02992842f, 
    -0.04699716f, -0.04067223f, -0.04252234f, -0.08306885f, -0.05397096f, -0.00167307f, 0.05082193f, 0.02262303f, 
    -0.04083522f, -0.07800544f, -0.04429243f, 0.07016864f, 0.06220182f, -0.03585372f, -0.09336863f, -0.02341414f, 
    -0.04845315f, -0.09903597f, 0.04275167f, -0.07346237f, 0.02292794f, -0.02832627f, -0.00393816f, -0.02615480f, 
    -0.00933957f, -0.08555260f, -0.08045498f, -0.06376398f, 0.05265531f, 0.01911243f, -0.04839553f, 0.01554840f, 
    0.01427160f, -0.09463201f, -0.02982996f, 0.01723532f, 0.04463196f, 0.01986280f, -0.04491828f, -0.06054136f, 
    -0.01078542f, 0.03536334f, 0.07121792f, -0.08647427f, -0.06940549f, -0.04331214f, 0.03350523f, 0.06420754f, 
    -0.04916745f, -0.05206334f, 0.01955175f, -0.10601532f, -0.04935062f, 0.11970179f, -0.09429460f, -0.08825144f, 
    -0.07973091f, -0.07446415f, 0.01666285f, -0.00980098f, -0.02738976f, -0.01914407f, -0.04908394f, -0.06374115f, 
    -0.00737701f, -0.01224715f, 0.03164342f, -0.07632621f, -0.11481947f, -0.08153288f, -0.03493962f, -0.05384825f, 
    -0.03606996f, -0.06704003f, -0.09622312f, 0.03944541f, -0.01577846f, -0.01441130f, 0.05841231f, -0.01965184f, 
    -0.50495350f, -0.20903914f, -0.12441468f, -0.13308971f, -0.52989590f, -0.05226181f, -0.05454431f, 0.01188627f, 
    0.18202280f, 0.63510579f, -0.16732320f, 0.14919700f, 0.16005038f, -0.05873985f, 0.19989368f, -0.14409652f, 
    0.08860836f, 0.02364207f, 0.06785606f, 0.12922844f, 0.02445952f, 0.02900217f, -0.01408746f, 0.09029298f, 
    0.20010082f, 0.14553465f, -0.01646903f, 0.16190366f, 0.05749367f, -0.04409485f, 0.19831106f, 0.09693614f, 
    0.02438348f, 0.17381443f, 0.21253353f, -0.21008040f, 0.07654866f, 0.02533693f, -0.06255914f, -0.13179377f, 
    -0.08181012f, 0.20850976f, -0.03306962f, 0.32788453f, 0.04765365f, -0.12694363f, -0.04216653f, 0.00491358f, 
    0.06672356f, -0.03822162f, 0.10981563f, 0.11196381f, -0.04547375f, -0.03712976f, -0.02101146f, 0.02905887f, 
    -0.11948950f, 0.18389779f, 0.01290859f, 0.13694112f, 0.00548227f, -0.46043289f, -0.17743799f, 0.04830120f, 
    0.51883715f, 0.02246824f, -0.04012922f, -0.08180541f, 0.39031157f, 0.05653400f, 0.19058713f, -0.05796818f, 
    -0.05912435f, -0.01232350f, -0.03896511f, 0.15384211f, 0.27175897f, 0.53578472f, 0.02952965f, -0.20046628f, 
    0.05912682f, -0.18422581f, 0.14616962f, 0.50637287f, 0.07552841f, -0.02277855f, -0.01455418f, 0.10016087f, 
    -0.03894563f, 0.29582092f, -0.18256736f, 0.19028832f, 0.11413193f, -0.20521036f, 0.08526664f, -0.41856912f, 
    -0.03277736f, -0.03525889f, 0.06046385f, -0.05988297f, 0.15761846f, 0.02856182f, -0.58479869f, 0.02556477f, 
    0.21655686f, -0.29329458f, 0.12788895f, 0.11907809f, 0.15007176f, 0.15579839f, 0.10071130f, 0.33955094f, 
    0.30581841f, -0.24738066f, -0.03662181f, 0.28453207f, -0.10790719f, -0.06946550f, -0.54203290f, -0.05457009f, 
    -0.16846693f, -0.13987483f, 0.50270927f, -0.04038052f, 0.21936874f, 0.04141929f, -0.04029724f, -0.00036985f, 
    0.01529359f, 0.03094953f, -0.00443058f, 0.03595693f, 0.01555428f, -0.03909878f, -0.36123398f, -0.14813605f, 
    -0.25671077f, -0.00070899f, 0.09138850f, -0.10224596f, 0.20435734f, -0.23918931f, -0.17981480f, -0.41960111f, 
    0.05393946f, -0.12570436f, -0.10862216f, -0.04087754f, -0.09069081f, 0.08991151f, 0.03600884f, 0.13149258f, 
    -0.11083259f, -0.11173158f, -0.08689714f, -0.14572895f, -0.04362352f, 0.18150729f, -0.17393789f, -0.17711923f, 
    0.04965922f, 0.38794273f, 0.44648880f, 0.17298770f, 0.12667462f, 0.15203273f, 0.17060304f, -0.07589139f, 
    0.05975777f, 0.01526293f, 0.03692848f, 0.15561818f, -0.04290954f, 0.08002948f, -0.30539662f, -0.29434314f, 
    0.28206271f, -0.04680154f, 0.10510826f, -0.01817784f, 0.05443658f, -0.28738305f, -0.05507384f, 0.23692112f, 
    0.15259349f, -0.12102071f, 0.17513764f, -0.17906484f, -0.22065319f, 0.07143422f, -0.07416546f, 0.06021567f, 
    0.11891864f, 0.13602184f, 0.30600232f, -0.10796610f, -0.24683513f, -0.17866465f, 0.07331642f, 0.01195036f, 
    -0.18667173f, 0.18215346f, 0.06103994f, 0.10865195f, -0.07806518f, -0.01328869f, 0.14738983f, 0.06512582f, 
    0.06242837f, 0.07696912f, -0.11417143f, -0.09085453f, -0.04834153f, -0.00260047f, -0.43880048f, -0.04123444f, 
    -0.00911061f, 0.17573601f, -0.11628293f, 0.47282168f, -0.15866886f, -0.04099698f, 0.07770108f, 0.19310950f, 
    0.01823816f, -0.04717701f, -0.04110000f, 0.18417443f, 0.12407476f, -0.00967212f, 0.31460741f, -0.00804698f, 
    -0.10147221f, 0.03770632f, 0.19646876f, 0.00439770f, 0.05920278f, 0.04966057f, 0.09594410f, 0.09898032f, 
    -0.01824000f, 0.16081116f, 0.04384661f, -0.00032436f, 0.12753657f, 0.30923492f, 0.02289046f, 0.31049186f, 
    -0.30216470f, -0.16617276f, 0.05636081f, -0.03471315f, 0.07233568f, 0.05232010f, -0.16661008f, -0.15532202f, 
    -0.05457746f, 0.05763162f, 0.06034964f, -0.06591807f, 0.03128250f, 0.02143786f, 0.01085713f, 0.05816238f, 
    -0.05382327f, -0.07698772f, -0.08815089f, 0.05505083f, -0.02331964f, 0.05032210f, 0.06665758f, 0.00633680f, 
    0.00790318f, -0.06009849f, -0.04757400f, -0.04180057f, 0.06102724f, 0.07114267f, 0.03120296f, -0.02801174f, 
    -0.00189104f, 0.01457222f, 0.02573286f, -0.09186843f, 0.00750999f, 0.00192902f, -0.08387160f, 0.04573901f, 
    0.06049502f, -0.01309712f, -0.01790108f, -0.02019308f, -0.06344913f, -0.08961327f, -0.07067943f, -0.07052178f, 
    -0.02283947f, -0.06750208f, -0.02690375f, -0.00240433f, 0.03323395f, -0.05985515f, -0.05226737f, -0.03092751f, 
    -0.04943942f, 0.04782778f, 0.08251265f, 0.01969777f, -0.08807293f, -0.07393786f, -0.05324091f, -0.03676517f, 
    -0.03543273f, 0.06258614f, -0.02297265f, 0.07058909f, -0.04327781f, -0.00542758f, -0.02545019f, 0.01341000f, 
    0.04380070f, 0.04350733f, 0.04512816f, -0.01757373f, -0.01384898f, 0.00775033f, -0.07413520f, -0.08525506f, 
    -0.03832007f, -0.07289403f, -0.02880036f, 0.04842278f, -0.00892776f, -0.07914844f, -0.05277670f, 0.02470967f, 
    0.03546136f, 0.00452567f, 0.02206712f, -0.06328733f, 0.02940865f, -0.02283536f, 0.07750511f, -0.02199690f, 
    -0.04585510f, -0.00822602f, -0.08774315f, -0.05191645f, -0.10173044f, -0.00440403f, -0.08397768f, 0.00737974f, 
    -0.08018681f, 0.06418991f, -0.03715217f, 0.01588036f, -0.06288538f, -0.03785882f, -0.08201220f, -0.02221440f, 
    -0.09282088f, -0.00232059f, 0.05271499f, -0.02890487f, 0.01302446f, -0.06884461f, -0.07712726f, -0.08587063f, 
    -0.07524244f, 0.03434513f, 0.03055211f, 0.06815101f, -0.07788479f, -0.05647983f, 0.04508874f, -0.05819171f, 
    -0.07757413f, -0.01085716f, -0.01120467f, -0.06884712f, -0.02329440f, -0.08204249f, 0.00524691f, -0.03691034f, 
    0.03340062f, 0.01059684f, 0.06782836f, 0.21532844f, -0.02245996f, 0.09016093f, -0.12690996f, 0.39225000f, 
    -0.13633446f, -0.12041426f, 0.02903583f, -0.00068929f, -0.15604717f, 0.04358396f, -0.12363422f, 0.37921223f, 
    -0.03432629f, 0.08354902f, -0.04209362f, -0.14970973f, 0.16983140f, 0.14957042f, -0.05617249f, -0.07937142f, 
    0.09497129f, -0.15434456f, 0.05668362f, 0.04936332f, 0.10995527f, -0.14337677f, -0.09011856f, 0.26245847f, 
    0.02897383f, 0.07625433f, -0.11197408f, 0.06815305f, -0.01527169f, -0.04138849f, -0.18804787f, -0.17064466f, 
    -0.06726041f, -0.19891718f, -0.00483918f, -0.06684537f, 0.00352443f, 0.03361299f, -0.05378845f, 0.06478328f, 
    0.17285883f, -0.10323852f, -0.06282075f, -0.13236165f, -0.00200410f, 0.14817266f, 0.02766839f, -0.20642285f, 
    0.05977586f, 0.17878994f, -0.06170211f, -0.33114722f, 0.04823748f, -0.18865970f, -0.11963703f, -0.20723513f, 
    0.01684828f, 0.03612510f, 0.08398081f, 0.07951186f, 0.16845065f, -0.08935549f, -0.32414132f, -0.05731995f, 
    0.22403277f, -0.25712079f, 0.31672761f, 0.15066817f, -0.04825555f, 0.53949875f, 0.16652969f, 0.17645513f, 
    0.00422553f, 0.06989425f, 0.18027608f, 0.42454895f, -0.05040469f, -0.06000623f, 0.40705910f, 0.30152175f, 
    0.03101808f, 0.12486282f, -0.03719236f, -0.16078500f, -0.17204577f, -0.21234375f, 0.07798972f, 0.10718107f, 
    -0.14383413f, 0.08630321f, -0.14877157f, -0.03292350f, -0.06446251f, -0.25710392f, 0.07840799f, 0.00257306f, 
    0.03573672f, 0.04739081f, -0.13759232f, -0.20514508f, 0.19444011f, 0.17922199f, 0.09217069f, -0.19312020f, 
    -0.03976082f, 0.03237754f, 0.15266196f, -0.38047150f, 0.00465495f, -0.04055744f, -0.19134322f, 0.04556095f, 
    -0.09568108f, 0.03079167f, 0.07788558f, -0.01642805f, -0.27198595f, 0.04401334f, -0.13413936f, 0.29170388f, 
    0.15120818f, -0.25139526f, 0.07108296f, 0.08408453f, 0.06011518f, -0.06320179f, -0.42694214f, 0.11981729f, 
    -0.00004168f, -0.22120693f, 0.01759339f, -0.11816770f, -0.00243794f, -0.32060075f, -0.11995716f, -0.32711619f, 
    -0.15120801f, -0.52412206f, -0.19656827f, 0.29950121f, -0.18753870f, 0.00629226f, 0.08715933f, 0.11445639f, 
    0.14510874f, -0.06170670f, 0.09156947f, 0.08942743f, -0.13373041f, -0.08020461f, 0.17661285f, -0.09051047f, 
    0.08363065f, -0.17040278f, -0.46098074f, -0.03911661f, 0.02258851f, -0.05288470f, 0.09696514f, -0.10523956f, 
    -0.25142640f, -0.01820603f, 0.13326997f, 0.20357585f, 0.07751308f, -0.01907671f, -0.85969436f, -0.21327759f, 
    0.19516559f, -0.01421515f, 0.17076966f, 0.67657989f, -0.03555001f, 0.07607097f, 0.05839126f, 0.16912852f, 
    -0.04406365f, -0.09463558f, 0.04507492f, 0.05036713f, 0.08492916f, -0.03411074f, 0.25699997f, 0.18440855f, 
    0.14892788f, -0.06388611f, -0.03168398f, 0.06352746f, 0.26077282f, 0.13130200f, 0.49238226f, -0.04227325f, 
    0.11381874f, 0.21991320f, -0.15562035f, 0.13905941f, -0.19881111f, -0.06744025f, 0.02508727f, -0.05610117f, 
    0.12529844f, -0.44217229f, 0.23497488f, -0.28113589f, 0.08553457f, -0.03331838f, 0.09647194f, 0.06548797f, 
    -0.07605078f, 0.29541907f, -0.30138266f, -0.27297020f, -0.36216667f, -0.34209019f, -0.06426297f, -0.19526376f, 
    0.09384865f, 0.07668719f, 0.00309034f, -0.01058491f, 0.06521109f, -0.22931513f, -0.13397254f, -0.35983491f, 
    -0.08182608f, 0.00491367f, 0.01304495f, 0.35984093f, 0.00725638f, -0.23308901f, 0.16174246f, 0.23553725f, 
    0.04010708f, -0.31381625f, 0.03255807f, 0.42264801f, 0.02224854f, 0.06559774f, -0.47380111f, -0.06459574f, 
    -0.45112723f, -0.26759517f, 0.11546275f, 0.08257928f, 0.36505079f, -0.02710076f, -0.43395507f, -0.01220993f, 
    0.03755550f, -0.14890869f, 0.07656376f, 0.24951407f, 0.18394969f, -0.17328732f, -0.33060932f, -0.13175429f, 
    -0.26220062f, -0.32863626f, 0.27257603f, -0.05154525f, -0.15275529f, 0.02075494f, -0.03022050f, -0.15472503f, 
    -0.37538555f, -0.12342729f, -0.18620750f, -0.22110334f, 0.23698130f, -0.01720181f, 0.06505156f, -0.06240217f, 
    -0.00484555f, 0.06493739f, 0.16352890f, 0.30713707f, -0.18674439f, -0.07159723f, 0.07256312f, 0.08819482f, 
    0.14813806f, -0.15171708f, -0.33278611f, 0.12781802f, -0.07367751f, 0.04507376f, 0.39345139f, -0.17824985f, 
    -0.38274899f, -0.20024842f, -0.01533082f, 0.08898641f, 0.22344993f, -0.09980927f, 0.11617917f, 0.03248776f, 
    -0.10500128f, 0.33030254f, 0.19534409f, 0.22980377f, 0.01388937f, 0.08207107f, 0.14001738f, 0.13441294f, 
    0.07215391f, -0.06994124f, 0.42673650f, 0.31818986f, 0.28703198f, 0.11487639f, 0.17567594f, 0.24394093f, 
    -0.12483811f, -0.25626713f, -0.04133378f, 0.03627570f, 0.00628260f, 0.25136948f, 0.24448788f, -0.03162276f, 
    -0.13331491f, 0.06804500f, -0.13164146f, -0.05223813f, 0.03571775f, -0.24672884f, -0.08357986f, 0.05256549f, 
    0.12947525f, -0.17143141f, 0.14632808f, -0.27759558f, 0.04154161f, -0.03797275f, -0.07768516f, 0.00606229f, 
    -0.05380343f, 0.04924930f, -0.23207718f, -0.29435834f, -0.09289095f, -0.11490835f, -0.00076396f, -0.05707366f, 
    0.09627633f, -0.01131668f, 0.08786400f, 0.23470441f, 0.25061601f, 0.21941502f, 0.32965589f, -0.14406979f, 
    0.15302566f, 0.19551396f, -0.00583015f, 0.39323321f, 0.01144758f, -0.20074433f, 0.09855308f, 0.07893497f, 
    -0.12102358f, -0.04750019f, 0.19780123f, 0.19173384f, 0.05328706f, 0.01244876f, 0.13394554f, 0.13994236f, 
    -0.14047392f, -0.06461458f, 0.05242515f, 0.40396479f, 0.24458537f, 0.18347192f, 0.24715933f, 0.00305964f, 
    -0.20968172f, -0.02367323f, -0.00041795f, 0.11352596f, -0.04209826f, -0.09549971f, 0.11237869f, 0.08444473f, 
    -0.08534093f, -0.12885930f, 0.12108524f, 0.16778976f, -0.09100884f, 0.15670118f, -0.00027726f, 0.20669977f, 
    -0.03911423f, -0.02586598f, 0.07780697f, 0.01787054f, 0.17553607f, 0.00765767f, 0.01295986f, -0.26698977f, 
    0.25529441f, 0.12154988f, 0.15436393f, 0.10850156f, -0.00280310f, 0.06276006f, -0.04219534f, 0.17461857f, 
    0.02918668f, -0.14472891f, -0.27425402f, 0.06999283f, -0.01423575f, -0.15754685f, -0.22097103f, -0.25781903f, 
    -0.19978131f, -0.22410384f, -0.06095930f, -0.01559590f, 0.02733215f, 0.02646660f, 0.11449110f, 0.06817651f, 
    -0.07258315f, 0.04851658f, 0.18748300f, 0.15136427f, -0.00732017f, 0.31463507f, 0.07069426f, -0.23558271f, 
    -0.04638221f, 0.09546598f, 0.10713733f, 0.06886470f, 0.33198804f, -0.03853279f, 0.06401829f, -0.01849619f, 
    0.00969810f, -0.18880096f, -0.17785341f, 0.06151692f, 0.28932887f, 0.09844918f, -0.01893744f, -0.06703776f, 
    0.19620030f, -0.04749482f, 0.05564781f, -0.04592476f, 0.20624766f, 0.07469495f, -0.04249384f, -0.07013225f, 
    -0.01699426f, 0.09638862f, 0.16713533f, -0.02573686f, -0.05957842f, -0.00097007f, 0.41032988f, 0.20844664f, 
    0.01805785f, -0.01311465f, 0.00002732f, -0.33778122f, -0.07578785f, 0.01779344f, -0.08716016f, 0.27549443f, 
    0.03732714f, 0.07985191f, 0.01724525f, 0.10764798f, 0.04335392f, 0.13180153f, 0.17599912f, 0.02044811f, 
    0.04348656f, -0.10457715f, -0.04171092f, 0.22449572f, -0.04434937f, -0.02754835f, -0.09368581f, 0.01814099f, 
    -0.10734067f, 0.10645130f, 0.15075831f, -0.01223337f, -0.03005995f, -0.07111946f, 0.00507375f, -0.04404274f, 
    0.09894164f, 0.03237019f, 0.15284848f, 0.04896887f, -0.05411351f, 0.12901203f, -0.05415957f, 0.07808835f, 
    0.34319007f, 0.09490743f, 0.02011558f, -0.14744750f, 0.07194407f, 0.07851622f, 0.12876342f, -0.29938257f, 
    -0.16965356f, 0.04320349f, -0.13552599f, -0.02076947f, -0.46366003f, 0.15780392f, 0.03258419f, 0.17948385f, 
    0.14898643f, 0.22970833f, 0.07507806f, -0.09866146f, 0.02429869f, -0.42507723f, -0.06398108f, -0.00093736f, 
    -0.31938970f, 0.12789068f, -0.29505026f, 0.03727889f, -0.01924011f, -0.01562759f, 0.15394132f, -0.04037464f, 
    -0.17411850f, -0.31925148f, -0.06468866f, -0.11256704f, 0.05117529f, 0.06805000f, 0.17386945f, -0.57203352f, 
    -0.09737149f, 0.25885382f, -0.16151305f, -0.11841905f, -0.11046590f, -0.07472610f, 0.09468650f, 0.07137327f, 
    -0.04539425f, 0.11463549f, 0.22768717f, 0.02170921f, 0.09299520f, -0.13205855f, -0.67726207f, 0.29397357f, 
    -0.23624447f, 0.05067667f, -0.19721885f, 0.10556021f, 0.44464669f, -0.09493494f, -0.71246946f, 0.19491872f, 
    -0.13011372f, 0.03310468f, -0.03778346f, 0.02401917f, 0.23795398f, 0.16816810f, 0.20799582f, 0.02793616f, 
    -0.24516173f, -0.20262092f, -0.19997317f, -0.27174121f, -0.02347773f, -0.40705281f, -0.33811375f, 0.09803608f, 
    0.04929697f, 0.16607720f, -0.05128285f, 0.12890571f, -0.04369286f, 0.03594158f, -0.03072068f, 0.17893502f, 
    0.00727188f, 0.26680151f, -0.03083619f, -0.08347131f, 0.15691055f, 0.09941396f, -0.07733229f, -0.34314132f, 
    0.11935167f, 0.05584434f, 0.15884042f, -0.33369431f, -0.02721581f, 0.04604121f, -0.09275778f, -0.00116066f, 
    0.07134280f, -0.09977420f, 0.03426477f, -0.31928912f, 0.36699614f, 0.08717734f, 0.06994369f, -0.14265354f, 
    0.16001068f, -0.05585398f, -0.05776700f, 0.10139219f, 0.09562884f, -0.19522075f, 0.00771704f, -0.31484413f, 
    -0.01195086f, 0.07194468f, -0.32710290f, -0.04371212f, -0.18744758f, -0.03092655f, 0.14598250f, -0.00427510f, 
    0.05946373f, -0.04866818f, -0.09923032f, 0.04382994f, -0.08837069f, -0.08644105f, -0.05768145f, -0.04802627f, 
    0.05622913f, -0.02124590f, 0.04723364f, -0.10492450f, -0.07763318f, -0.09510013f, 0.00711637f, -0.09193840f, 
    -0.03080708f, -0.02458606f, -0.08270529f, 0.03421361f, -0.06556084f, -0.03565292f, 0.08329191f, -0.09161433f, 
    -0.09515171f, 0.02978301f, -0.02459067f, -0.10698810f, -0.06708303f, -0.08291390f, -0.11082828f, -0.10134619f, 
    -0.08841722f, 0.00420332f, -0.06968146f, -0.07298678f, -0.01108628f, -0.08676828f, -0.01793694f, -0.03428785f, 
    -0.03015309f, 0.07088280f, -0.04976504f, -0.02766494f, -0.05107370f, 0.01573859f, -0.01361633f, -0.05271317f, 
    0.02616404f, 0.04910861f, -0.08256205f, 0.05559883f, 0.04947081f, 0.00947957f, -0.07147708f, -0.03050816f, 
    0.01171229f, 0.05191519f, -0.02966143f, -0.09680150f, -0.02314782f, 0.05500349f, -0.09627055f, 0.03374031f, 
    0.01724790f, 0.05442237f, -0.00028414f, -0.08240760f, -0.00257942f, -0.08526351f, -0.00947942f, -0.08331919f, 
    -0.06827017f, 0.00481325f, -0.02505819f, 0.03298712f, 0.02317918f, 0.06264919f, 0.04572565f, -0.01441143f, 
    0.01469558f, -0.07277253f, -0.01195772f, -0.07444311f, -0.04291547f, -0.05755481f, -0.02408692f, 0.04420753f, 
    0.01466694f, 0.05530117f, -0.05450441f, 0.04778337f, 0.07821398f, 0.06769906f, 0.01443355f, 0.01555882f, 
    -0.04250296f, 0.06667255f, 0.04498259f, -0.07137083f, -0.06840304f, -0.04846187f, -0.02176796f, -0.01716501f, 
    0.05285120f, -0.08308305f, -0.05158408f, -0.06154537f, -0.10698245f, -0.10777309f, -0.10693105f, 0.04420477f, 
    0.01782350f, 0.03433341f, 0.01227165f, -0.09653095f, -0.05006436f, -0.00318166f, -0.03145022f, -0.01223616f, 
    -0.09548838f, -0.05061245f, -0.00787479f, -0.10058600f, -0.06001651f, 0.02491345f, 0.01019107f, -0.02101173f, 
    0.02455395f, 0.01114649f, -0.10054015f, -0.03432756f, -0.11736562f, -0.07190619f, 0.03415522f, 0.00309712f, 
    -0.02695981f, -0.02538798f, 0.01272998f, 0.04784369f, -0.08211191f, -0.01996481f, 0.03129473f, 0.00209313f, 
    -0.01298791f, -0.02795968f, -0.10740868f, -0.01303400f, 0.06719182f, -0.02699965f, 0.01525159f, 0.04794034f, 
    -0.02130121f, -0.06046372f, -0.03017083f, -0.01892037f, -0.01572290f, -0.03330734f, -0.12686244f, 0.03360447f, 
    0.00692716f, 0.05195575f, 0.05466519f, 0.03330476f, 0.04981841f, -0.12119306f, -0.05240377f, -0.02266709f, 
    -0.07288671f, 0.03766924f, -0.07416865f, -0.02451300f, -0.07404386f, -0.11417706f, -0.01263328f, 0.01512234f, 
    -0.08313549f, -0.09646744f, 0.05310920f, -0.05827079f, 0.05348865f, 0.04417040f, -0.00633836f, -0.05709426f, 
    -0.07361337f, -0.09585271f, -0.08425363f, 0.03564855f, 0.02373256f, 0.00863326f, -0.05984406f, -0.04697003f, 
    -0.09456725f, 0.04891917f, -0.05118382f, 0.01758435f, -0.08731367f, -0.00281247f, -0.00204843f, -0.07161082f, 
    -0.03527131f, 0.07792668f, 0.03531677f, -0.04346306f, -0.01322527f, 0.00169159f, -0.02748717f, -0.10118186f, 
    -0.05017136f, -0.04480046f, 0.06800471f, 0.02838275f, -0.02287923f, -0.07887366f, -0.06387167f, 0.06102633f, 
    -0.00790592f, 0.06775299f, 0.03983353f, 0.04761308f, 0.03770313f, -0.07746166f, 0.04619615f, 0.02396427f, 
    -0.10898519f, -0.07015613f, -0.10557238f, 0.00949780f, 0.00052367f, -0.08503406f, -0.00192624f, -0.12890466f, 
    -0.09381115f, -0.07887068f, -0.06442802f, 0.01218126f, -0.08902100f, -0.10631476f, 0.03131288f, 0.07494988f, 
    -0.00257483f, -0.09652676f, 0.03388395f, 0.06340899f, -0.07911548f, -0.10958677f, -0.01470875f, 0.07114542f, 
    -0.03492207f, 0.06046245f, 0.01836353f, 0.00928809f, -0.00764501f, -0.10135318f, -0.07071335f, -0.05927365f, 
    0.24001665f, 0.03459461f, 0.06326798f, -0.04690681f, -0.20612970f, -0.11885326f, -0.04821043f, 0.01388294f, 
    0.37346014f, -0.11866777f, 0.13510883f, -0.12944692f, 0.17093112f, -0.08417092f, -0.08826303f, -0.37484011f, 
    0.29503435f, -0.10802237f, 0.06839410f, 0.11717458f, -0.01468047f, 0.32429084f, -0.07756971f, 0.00770632f, 
    0.14524816f, -0.17015944f, -0.11226122f, -0.12992029f, 0.08201100f, 0.23790020f, -0.01098492f, 0.10050349f, 
    -0.02453927f, 0.10475701f, 0.33199921f, 0.19308665f, 0.10915758f, 0.21489730f, 0.00207627f, 0.55208886f, 
    0.32272631f, 0.09100530f, 0.06178974f, 0.04584268f, 0.02564046f, 0.17703418f, -0.18709226f, -0.15950249f, 
    0.42003235f, -0.06316013f, 0.31180403f, 0.04198696f, 0.06678149f, -0.14453767f, -0.16541359f, 0.13426964f, 
    0.01967075f, 0.14993501f, 0.11237489f, -0.32859874f, -0.25999001f, -0.11488999f, 0.00596980f, -0.08196995f, 
    0.17711188f, 0.34527269f, 0.08378777f, 0.03192153f, -0.24532002f, 0.10268367f, -0.03033313f, 0.01308006f, 
    0.18564925f, 0.13192056f, 0.03611771f, 0.12561993f, 0.00356451f, 0.04663601f, 0.17451857f, 0.00624217f, 
    0.07331223f, -0.10216959f, 0.16990484f, 0.13274726f, 0.07608905f, -0.04028352f, -0.13266379f, -0.03389742f, 
    0.00497739f, 0.26944691f, 0.03045353f, 0.55080622f, 0.01157901f, 0.05131276f, 0.02318006f, 0.17453684f, 
    -0.12682384f, -0.06734852f, 0.09183968f, 0.13325879f, -0.08283067f, 0.07252261f, -0.05576081f, 0.04873056f, 
    -0.14821379f, -0.18135887f, 0.16565599f, 0.04126988f, -0.15718223f, 0.06809022f, 0.11111123f, 0.13888262f, 
    0.05312262f, 0.04913100f, -0.06512632f, 0.24869055f, 0.06209756f, -0.03676042f, -0.24563630f, 0.18875664f, 
    0.04038212f, 0.18464090f, 0.02547388f, -0.06207507f, 0.11017641f, 0.01535980f, -0.07133885f, -0.20984191f, 
    0.00359680f, -0.06803021f, -0.06405409f, 0.04021632f, -0.07281586f, -0.05993329f, -0.07564807f, 0.03096438f, 
    -0.08752280f, -0.05570680f, -0.00229453f, -0.05053869f, -0.05683285f, 0.08702613f, -0.01553139f, -0.06263637f, 
    -0.06795373f, 0.03949859f, 0.05005997f, -0.07274804f, -0.05322196f, -0.00459667f, 0.04077272f, -0.04836135f, 
    0.05997348f, -0.04839385f, -0.04874476f, 0.04901534f, 0.07178405f, 0.05446228f, -0.02403860f, 0.05479581f, 
    -0.08456012f, 0.05390787f, 0.02786869f, -0.01739020f, -0.05913063f, -0.02528590f, -0.02205704f, 0.06704041f, 
    -0.08355154f, 0.02229315f, 0.06290723f, 0.02137282f, -0.00887870f, -0.02251619f, -0.06071403f, 0.04171195f, 
    -0.00320218f, 0.00423829f, -0.02747102f, -0.08698303f, -0.02748260f, 0.04876190f, -0.08647084f, 0.08227463f, 
    0.07079190f, 0.01076933f, -0.00579848f, 0.03957586f, -0.05960425f, -0.05676528f, -0.04452041f, -0.00638078f, 
    -0.02981669f, -0.00840555f, 0.05553113f, -0.02178701f, -0.06134694f, -0.02092297f, 0.04968987f, -0.01168141f, 
    -0.01694842f, -0.05211651f, -0.01062427f, -0.07445680f, -0.01700143f, -0.06638059f, 0.07240838f, -0.05917684f, 
    0.00509387f, -0.03627108f, -0.06436914f, 0.05016429f, 0.08608040f, -0.04773240f, 0.04709478f, 0.02621779f, 
    -0.02794197f, 0.08763557f, -0.04250161f, -0.08037499f, -0.01338248f, -0.04253270f, 0.00820577f, -0.05535770f, 
    -0.08776299f, -0.03882110f, 0.00448353f, -0.03669186f, -0.05994116f, 0.08386778f, 0.01923694f, -0.05451149f, 
    0.04877976f, 0.00492639f, -0.03238998f, 0.02398059f, -0.05155828f, -0.05697720f, -0.03086665f, 0.02089377f, 
    -0.07249960f, -0.02147294f, -0.08815160f, -0.06166703f, -0.05679302f, -0.06971578f, 0.01468409f, -0.02415652f, 
    -0.07123333f, 0.01858710f, 0.01800554f, -0.00806917f, -0.02430868f, -0.03270329f, -0.04084009f, -0.07648659f, 
    0.05021871f, -0.11868048f, -0.11389080f, 0.01171534f, -0.03460386f, -0.03187180f, -0.02657829f, -0.05812414f, 
    -0.03142643f, -0.03011314f, -0.02423577f, 0.01224679f, 0.06282350f, 0.06408560f, 0.04179713f, -0.02439073f, 
    -0.12774988f, -0.00836117f, -0.08671512f, -0.00996534f, 0.02697269f, -0.05769663f, -0.06084798f, -0.04789864f, 
    -0.05180551f, -0.02870369f, -0.05510326f, -0.02039698f, 0.03985315f, -0.11299372f, 0.05280476f, -0.08020885f, 
    -0.09969412f, -0.06188199f, -0.00961327f, 0.00377056f, 0.08575329f, -0.12812290f, -0.06536759f, -0.02063733f, 
    -0.03944418f, -0.08548816f, -0.00129451f, 0.07723226f, -0.04200023f, -0.05821931f, -0.04810911f, -0.02007607f, 
    -0.08259317f, -0.02387874f, -0.01382107f, 0.05613746f, -0.07197706f, -0.03432513f, -0.03359814f, 0.05444887f, 
    0.06634222f, -0.03660112f, -0.12519796f, 0.00829092f, -0.10273220f, -0.02930233f, -0.06047491f, -0.05088026f, 
    0.04355721f, 0.00595439f, -0.01213804f, -0.01357693f, -0.01429956f, 0.00654447f, -0.06363463f, -0.06089399f, 
    0.05535998f, -0.08043718f, 0.02068234f, -0.10982917f, 0.01345372f, 0.04006059f, -0.06014740f, -0.07524106f, 
    -0.10433159f, -0.03980264f, 0.03166644f, -0.03770035f, 0.06115073f, 0.08305235f, -0.09566052f, -0.11748318f, 
    -0.05298098f, -0.04160229f, -0.06255539f, -0.01760392f, 0.00593194f, -0.04203628f, -0.07290632f, 0.03066736f, 
    -0.05344262f, -0.07654923f, -0.05064987f, 0.01347494f, 0.01358918f, -0.00768888f, 0.05016242f, -0.08230053f, 
    -0.04169423f, 0.04734574f, -0.04442880f, -0.07242763f, 0.05581580f, 0.00155737f, -0.00980031f, -0.05603064f, 
    -0.09435154f, -0.10212803f, -0.00632705f, -0.10305316f, 0.03868163f, 0.01232065f, -0.00873885f, -0.04032714f, 
    -0.01528537f, -0.06791230f, -0.10996540f, -0.07019352f, -0.06664354f, -0.00211631f, 0.01599402f, -0.02846905f, 
    -0.16306181f, 0.08226805f, 0.09367722f, 0.16516414f, 0.22342911f, 0.00835800f, -0.10490281f, 0.43505210f, 
    -0.44574031f, -0.30677530f, 0.12409292f, 0.28140014f, -0.09786059f, 0.07513382f, -0.28406149f, 0.15826550f, 
    -0.18109962f, 0.14865221f, 0.14482191f, 0.10947710f, 0.12025541f, 0.05034959f, 0.06106594f, -0.14475745f, 
    -0.11122821f, -0.18888010f, 0.14320646f, 0.10506577f, 0.06817184f, -0.19849467f, -0.28883725f, 0.00704287f, 
    0.12226981f, -0.03775816f, -0.18050200f, 0.15023305f, -0.07443976f, -0.09221514f, -0.14980209f, -0.46158829f, 
    -0.27304450f, -0.24193275f, 0.02661722f, 0.05958334f, 0.06395151f, 0.10669305f, 0.04763937f, 0.12814897f, 
    0.06555519f, -0.14710526f, -0.03156980f, -0.14820255f, 0.02333003f, 0.02904542f, -0.08055932f, -0.04702660f, 
    0.00741284f, -0.03860722f, -0.13291529f, -0.18037134f, -0.00949551f, 0.11977892f, 0.04670883f, -0.06303091f, 
    -0.24467881f, 0.00532872f, -0.21292983f, 0.04214076f, 0.02426581f, -0.16268715f, 0.15021187f, 0.06954267f, 
    -0.12460542f, 0.14338838f, 0.11931175f, 0.03994366f, 0.13964382f, -0.00552235f, 0.16630509f, 0.06083921f, 
    -0.19743192f, 0.03663921f, 0.18530264f, -0.16851528f, -0.02966714f, 0.07680257f, 0.07491596f, 0.25718343f, 
    0.03156626f, 0.14746924f, -0.11029770f, -0.07156710f, -0.06120040f, -0.07925557f, -0.03396361f, 0.56353563f, 
    -0.05446723f, -0.02027659f, -0.12816018f, 0.07830774f, 0.13024949f, 0.02097238f, 0.51107585f, 0.04471979f, 
    -0.11776762f, 0.20117906f, -0.00607837f, 0.32261720f, 0.10222545f, 0.01376586f, 0.10868792f, 0.29589087f, 
    -0.05595645f, 0.30369955f, 0.08305223f, -0.04974076f, 0.20720525f, -0.05171700f, -0.03701240f, 0.07204869f, 
    0.16353284f, -0.02042348f, 0.04754188f, 0.03174475f, 0.05272263f, 0.08807509f, -0.07694761f, -0.08293193f, 
    0.06156487f, -0.09368774f, -0.10270298f, -0.08393677f, -0.05484189f, 0.03264235f, -0.07859726f, 0.03426632f, 
    -0.01443098f, -0.09652942f, -0.00324332f, -0.00784718f, -0.10556874f, -0.06436154f, 0.04598610f, 0.09975551f, 
    -0.00652050f, -0.00205418f, -0.02800411f, 0.02081653f, -0.08290145f, -0.08308870f, 0.04446820f, 0.03146837f, 
    -0.11384115f, -0.06523125f, 0.01882390f, -0.06184079f, 0.02128500f, -0.12652157f, -0.05136957f, -0.07559229f, 
    -0.12611581f, 0.05110784f, 0.04251733f, -0.01305938f, 0.04655813f, -0.11700315f, 0.03214655f, 0.06836957f, 
    0.06167188f, 0.01236203f, 0.01921540f, -0.07223531f, -0.03349628f, -0.06171879f, 0.02333558f, -0.04354860f, 
    -0.06955455f, -0.06927744f, 0.05867461f, -0.09687241f, 0.05533241f, -0.10959736f, 0.00568462f, 0.01830405f, 
    -0.01800091f, 0.00560250f, -0.06390154f, -0.07514394f, -0.12515675f, -0.01866768f, -0.02629765f, -0.09330378f, 
    -0.12347469f, -0.06543075f, -0.00079933f, -0.01146109f, -0.03442273f, 0.01793891f, -0.00934480f, -0.04930688f, 
    0.04545834f, -0.08615500f, -0.04298564f, -0.02817972f, -0.11506745f, 0.04236067f, 0.05242661f, -0.04717109f, 
    0.10079920f, -0.05728206f, 0.01058683f, 0.06463512f, -0.02685918f, -0.08240438f, -0.07366617f, 0.03610147f, 
    0.05701200f, -0.09729728f, 0.06668989f, 0.00686617f, 0.03685403f, 0.02539431f, 0.02782613f, 0.06267954f, 
    -0.12142054f, 0.08088136f, 0.01589754f, 0.01467773f, -0.03948462f, -0.04691737f, 0.04628118f, -0.10953020f, 
    -0.09930439f, 0.00456540f, 0.00700018f, 0.05982289f, -0.03737397f, 0.01645863f, -0.03651916f, 0.05338945f, 
    0.02988888f, -0.02681371f, -0.02861633f, 0.07224859f, 0.06201773f, -0.04868338f, 0.00486297f, -0.03273136f, 
    -0.10747307f, 0.00199136f, 0.07026171f, -0.02345789f, -0.10792855f, -0.03851316f, -0.05702959f, 0.01102009f, 
    -0.23057376f, -0.05276449f, -0.15837072f, 0.09367445f, 0.01661171f, 0.00437809f, -0.03639969f, 0.18781500f, 
    -0.07214037f, 0.29915789f, -0.00212269f, -0.04399972f, 0.03730153f, -0.11295141f, 0.20643492f, -0.21694075f, 
    -0.08044481f, -0.06050932f, -0.01965640f, -0.26430303f, 0.03075479f, 0.23987797f, -0.01908450f, -0.03761054f, 
    0.14069612f, -0.06780118f, -0.01509616f, 0.25375655f, -0.04162654f, 0.12373844f, 0.27077675f, 0.23618081f, 
    -0.22563194f, 0.29519913f, 0.01393499f, 0.26854172f, -0.03236452f, 0.04285899f, 0.21620032f, -0.05138643f, 
    -0.08414997f, 0.33814350f, 0.15546204f, -0.12603174f, 0.06238069f, -0.17320701f, -0.03695467f, 0.08284393f, 
    0.01700793f, 0.04537996f, -0.10646567f, -0.45252252f, -0.00315236f, -0.00934684f, -0.00982997f, 0.11947557f, 
    -0.21459317f, 0.02433954f, 0.09626877f, 0.00405594f, -0.36998504f, -0.28147689f, 0.06610402f, -0.05835267f, 
    0.23007789f, 0.07268210f, -0.22054204f, -0.04734956f, -0.11226040f, 0.14290410f, 0.04042386f, -0.23636320f, 
    0.13117751f, 0.17778476f, 0.05880333f, 0.06449357f, 0.07002665f, 0.12666550f, -0.02786941f, -0.09650037f, 
    0.31332442f, -0.01288781f, 0.09396652f, 0.16351411f, 0.04268178f, 0.02176930f, -0.10605717f, 0.00519810f, 
    0.03533739f, -0.31863835f, -0.13325498f, 0.26578644f, -0.10049459f, -0.39115462f, -0.04630926f, -0.28111747f, 
    -0.08818984f, 0.03221918f, 0.01907199f, 0.13258854f, -0.00261676f, 0.17586315f, -0.12130045f, 0.04850857f, 
    -0.23790051f, 0.20567587f, 0.18597534f, 0.14424819f, 0.03752551f, 0.03078733f, 0.14679298f, 0.26955900f, 
    0.24734090f, -0.02844003f, -0.22349297f, -0.02109608f, 0.13332614f, -0.19927277f, -0.09450987f, 0.08684584f, 
    -0.12341064f, -0.10288758f, 0.29427987f, 0.10790207f, 0.16811645f, 0.12355941f, 0.13489430f, -0.19947799f, 
    -0.21739967f, -0.02592515f, 0.00865039f, -0.11536422f, -0.15024331f, -0.05677213f, -0.07500175f, 0.22574630f, 
    -0.04772849f, 0.08314646f, -0.01194955f, 0.01934605f, 0.07187692f, -0.00764811f, 0.00907145f, -0.07482837f, 
    -0.00767696f, 0.19721869f, -0.11816937f, 0.08550616f, -0.13454528f, -0.00400365f, 0.01715951f, 0.15216286f, 
    -0.13207594f, -0.05709202f, -0.01885135f, -0.14602990f, 0.02791615f, -0.14448434f, -0.16336100f, 0.07704499f, 
    -0.04280666f, 0.38087291f, 0.20160316f, 0.08848308f, 0.13743649f, 0.04013536f, 0.12497219f, -0.10132194f, 
    -0.01096572f, -0.05426767f, -0.04885949f, 0.23467897f, -0.03371705f, -0.02937059f, -0.03817233f, -0.10832859f, 
    0.19014817f, -0.20780668f, -0.13563186f, -0.51091683f, 0.01075986f, -0.21136788f, -0.23031662f, 0.09989600f, 
    -0.04387472f, -0.03888695f, -0.10041580f, -0.14396934f, -0.25502589f, -0.20212169f, -0.23614985f, -0.13651212f, 
    0.13208804f, 0.09339821f, -0.07722320f, -0.10997247f, 0.08540083f, -0.20582880f, 0.07540563f, -0.18632908f, 
    -0.29321080f, 0.12058522f, 0.14352438f, 0.22225706f, 0.00873143f, 0.33934581f, 0.24548003f, -0.09215365f, 
    -0.05468870f, 0.15739898f, -0.00099860f, 0.21246916f, 0.03663077f, 0.08521650f, -0.29466334f, 0.12341733f, 
    -0.07140126f, 0.11332000f, -0.32043871f, 0.29244888f, 0.01467249f, -0.01668139f, -0.07141345f, -0.11041498f, 
    -0.10720957f, 0.08348088f, -0.08403803f, -0.13247804f, 0.06567600f, 0.12621465f, 0.26074880f, 0.03319046f, 
    0.12037178f, 0.07389142f, -0.01255844f, -0.06675756f, 0.23007414f, 0.27032465f, 0.02647897f, 0.22569939f, 
    -0.01575978f, -0.11119719f, 0.02872889f, 0.16739978f, 0.06653303f, 0.07082866f, -0.20840047f, 0.12875481f, 
    -0.16870643f, -0.01380297f, 0.27813295f, -0.04871120f, -0.05206833f, 0.04615181f, 0.13763869f, 0.06477607f, 
    0.20472942f, -0.13102154f, -0.06265248f, -0.12255839f, -0.20049094f, -0.20694329f, -0.08445610f, 0.14782694f, 
    0.47595996f, -0.04079900f, 0.16527025f, 0.05316818f, 0.16438341f, -0.05120627f, -0.06194604f, 0.21805505f, 
    0.19224630f, -0.08647414f, -0.24957560f, -0.17361037f, -0.07065833f, -0.01873991f, 0.03035286f, 0.28036723f, 
    -0.04453855f, 0.26912397f, 0.03068000f, -0.06243261f, 0.08518931f, -0.01433776f, 0.06183554f, 0.25855976f, 
    -0.04907472f, 0.19123271f, 0.08113255f, 0.00862248f, 0.43130228f, 0.12992468f, -0.13602462f, 0.45142436f, 
    0.29663119f, 0.33931279f, 0.20742087f, 0.21549290f, 0.16916569f, -0.03001484f, -0.21887073f, -0.02164165f, 
    0.35843161f, -0.21567507f, 0.11591665f, 0.22064236f, 0.02075667f, 0.04192970f, -0.04292970f, 0.05296041f, 
    0.03751693f, 0.08937494f, -0.00735251f, -0.19549231f, 0.23965719f, -0.33505663f, -0.09333982f, 0.12286782f, 
    0.03804969f, 0.16058028f, 0.06047224f, 0.03859866f, 0.60649586f, 0.06228384f, 0.08325708f, -0.17360637f, 
    0.15539239f, -0.13991234f, 0.17151551f, 0.07027026f, 0.00436083f, 0.62193310f, 0.15379822f, 0.10483598f, 
    0.08089624f, -0.01883897f, 0.00414432f, 0.60026568f, 0.02057716f, 0.03599680f, 0.21425454f, 0.15235187f, 
    0.00568714f, 0.27046260f, -0.14325804f, 0.19894175f, -0.02240062f, -0.14193428f, -0.02223007f, -0.12377728f, 
    0.07405607f, 0.00406109f, 0.06280323f, -0.14609550f, 0.00354210f, -0.07016306f, 0.25728351f, 0.01168857f, 
    0.12470514f, -0.05163191f, -0.27745146f, -0.05107945f, 0.12175816f, 0.21448779f, 0.05537650f, 0.10427824f, 
    0.24745134f, -0.09370639f, 0.21730255f, 0.15979055f, 0.20297001f, 0.16419703f, -0.29607120f, 0.01875884f, 
    0.06838034f, 0.12445550f, 0.23005415f, -0.05823211f, 0.04063049f, 0.01713095f, -0.18363728f, 0.42275918f, 
    -0.05243933f, -0.08694265f, 0.19565453f, 0.13577606f, -0.12946312f, 0.09300675f, -0.11666662f, 0.04345857f, 
    -0.35151935f, -0.46903560f, 0.05378520f, 0.27558333f, 0.10587546f, 0.22020873f, -0.24928887f, 0.09174712f, 
    -0.00957570f, 0.20454752f, -0.14443728f, -0.13754109f, 0.06735015f, -0.08448700f, 0.03729543f, -0.02634108f, 
    -0.16169626f, 0.14717658f, 0.09901380f, -0.02493196f, -0.11622316f, 0.00375779f, -0.21886103f, 0.16097258f, 
    -0.02978138f, 0.04647758f, 0.17784353f, -0.18360020f, -0.02441635f, -0.11473215f, -0.34844917f, -0.35994199f, 
    -0.31526518f, -0.39798602f, -0.08292896f, 0.17424345f, -0.06819770f, 0.12607214f, -0.02700195f, 0.11691667f, 
    -0.06847709f, -0.01591459f, 0.15638530f, -0.18118234f, 0.00893446f, 0.16536659f, 0.05064599f, -0.10663595f, 
    -0.01924617f, 0.00458670f, -0.01478167f, -0.11398523f, 0.18351008f, -0.00943230f, -0.13223094f, 0.01188790f, 
    -0.15540116f, 0.18853751f, -0.12831253f, -0.05222576f, 0.15979776f, 0.02526103f, 0.04789652f, 0.14312817f, 
    -0.07922495f, -0.23663008f, 0.21033920f, -0.01716324f, 0.24725206f, -0.04894612f, 0.14366367f, 0.06949036f, 
    -0.12880281f, 0.10528906f, 0.05937938f, 0.19593094f, -0.02440199f, 0.06253270f, 0.27630547f, 0.10169876f, 
    0.05170551f, 0.24720560f, 0.14207679f, -0.10115535f, 0.02291568f, 0.08313112f, 0.08307949f, 0.26810104f, 
    0.03587104f, -0.03620985f, -0.02194103f, 0.09278822f, 0.01937411f, -0.04963295f, -0.09908557f, 0.10307760f, 
    0.28067064f, -0.11548883f, -0.12442242f, 0.07360803f, 0.03574667f, -0.04222510f, 0.01107674f, -0.25861284f, 
    0.00312224f, 0.09597239f, 0.08698030f, -0.08124766f, 0.00578294f, -0.18592826f, -0.03911025f, 0.01840012f, 
    0.20140284f, 0.27143586f, -0.10448249f, -0.04190847f, -0.11703366f, -0.05266853f, -0.13698789f, 0.11067751f, 
    -0.22610095f, -0.06858286f, 0.19809343f, 0.23133883f, 0.22965255f, 0.17362174f, -0.16226840f, 0.13055079f, 
    0.15934996f, -0.02697680f, 0.07479235f, -0.03435414f, -0.31312931f, 0.08132757f, -0.01949915f, 0.25409359f, 
    -0.04295081f, 0.25423354f, -0.22882380f, -0.26223275f, 0.12591133f, -0.13336705f, 0.05542987f, 0.12024670f, 
    -0.15524058f, 0.05615172f, 0.25903842f, -0.01400119f, 0.02218513f, -0.22652043f, -0.09624785f, 0.00967455f, 
    0.03897584f, -0.03231226f, -0.04748633f, -0.13596648f, 0.18103148f, -0.11104541f, -0.02497408f, -0.08888064f, 
    0.22026470f, -0.32958534f, 0.05386889f, 0.11207685f, 0.03307741f, 0.04903089f, -0.08351226f, -0.08400654f, 
    -0.28537288f, 0.03280690f, -0.30290312f, -0.08766557f, -0.04279966f, 0.10960037f, 0.17932950f, -0.02623373f, 
    0.19292331f, -0.06201575f, -0.05212816f, -0.02357288f, 0.30982164f, 0.15373383f, 0.24312593f, 0.03647729f, 
    -0.48341632f, 0.03499715f, 0.01613477f, 0.09007187f, 0.12932938f, -0.06473988f, -0.10034870f, 0.11351927f, 
    0.19197118f, -0.17788753f, 0.24189156f, 0.00381076f, -0.02744045f, -0.01334802f, -0.03755302f, 0.18015534f, 
    0.07622211f, 0.20752144f, -0.18114725f, -0.11188677f, -0.06111203f, -0.03513324f, 0.29768884f, 0.04176195f, 
    -0.03479224f, -0.21811439f, -0.14676268f, -0.24948688f, 0.11406494f, -0.09264533f, -0.07264923f, -0.06449392f, 
    0.26951471f, -0.01816774f, -0.00607204f, -0.14115673f, -0.10392662f, -0.29222214f, 0.21685573f, 0.04007152f, 
    -0.01014897f, 0.33848506f, -0.15229219f, 0.06303584f, 0.13441363f, 0.05027190f, -0.04996541f, -0.37764600f, 
    -0.11923939f, 0.11285403f, 0.13752396f, -0.31239352f, -0.10127834f, -0.05704769f, 0.00650802f, 0.07276915f, 
    -0.00586295f, 0.02672396f, -0.20949252f, 0.04842446f, -0.07295222f, -0.06197507f, 0.01776685f, 0.25169900f, 
    -0.08850736f, -0.11266384f, 0.21295170f, 0.23510796f, 0.24205974f, -0.04832753f, 0.00283262f, 0.22413278f, 
    -0.14014196f, -0.49102926f, 0.26923636f, 0.14739847f, -0.17218547f, 0.02682286f, -0.00909754f, -0.05769487f, 
    -0.03692708f, -0.04261775f, 0.12690669f, 0.10299786f, 0.05136865f, 0.28114548f, -0.00361390f, -0.27144215f, 
    0.07171500f, -0.01166919f, 0.06306118f, 0.05480909f, 0.02244819f, 0.09393165f, -0.28682306f, -0.01844211f, 
    0.10423865f, -0.14300796f, -0.16380988f, 0.29500318f, -0.13629402f, -0.15803394f, 0.01937209f, 0.01354742f, 
    -0.27257267f, -0.07258575f, 0.05063355f, -0.04191390f, 0.05214433f, 0.07662951f, 0.10031336f, 0.08643570f, 
    0.10179789f, 0.09751397f, 0.24547829f, 0.16225870f, 0.06391017f, 0.18130098f, 0.15559722f, -0.19795114f, 
    0.00359509f, -0.02691878f, 0.26281863f, -0.13114679f, 0.03598781f, 0.07805642f, 0.00474067f, -0.07947398f, 
    -0.18416381f, -0.11402681f, 0.03226826f, 0.05976084f, -0.23689672f, 0.02972973f, 0.13390911f, 0.08293574f, 
    0.05995675f, 0.20199940f, 0.02728531f, 0.14925340f, 0.05312371f, -0.18076633f, 0.00874554f, 0.02321425f, 
    -0.08864713f, -0.00693647f, 0.17364286f, -0.25016040f, -0.07022458f, 0.04431135f, 0.07057147f, 0.02590485f, 
    0.07017507f, 0.02304080f, -0.00980196f, -0.05891882f, -0.26486593f, 0.07707336f, 0.08202507f, 0.46925646f, 
    -0.15017964f, 0.06793939f, -0.02323354f, 0.30679315f, 0.15225661f, 0.16503902f, 0.22388446f, 0.03793775f, 
    0.00543297f, 0.11150281f, -0.06401966f, 0.21818565f, -0.08549139f, -0.11241603f, -0.04359672f, 0.14912115f, 
    -0.23859787f, 0.14618745f, 0.11376365f, -0.19617283f, 0.16059676f, 0.06782959f, -0.00407757f, 0.21507508f, 
    0.03017366f, 0.09948134f, 0.13654314f, 0.22149561f, 0.12455697f, -0.00984758f, -0.08629235f, -0.14943126f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.14811471f, 0.31250560f, 0.18789151f, -0.00939382f, -0.11201409f, 0.17040281f, 0.19584495f, -0.03120700f, 
    0.10762940f, 0.11769754f, 0.10652294f, 0.07191391f, -0.03266655f, -0.01463989f, -0.06612853f, -0.00641295f, 
    0.33310634f, -0.00915249f, -0.02454880f, -0.10723680f, 0.11887345f, -0.09654264f, 0.03308338f, 0.37236491f, 
    0.24406554f, 0.20615356f, 0.41918424f, 0.09065042f, 0.18858249f, -0.05971748f, 0.25981149f, 0.24196419f, 
    0.17098603f, 0.10575085f, 0.17272590f, 0.04472648f, 0.03717181f, 0.30974877f, 0.08732021f, -0.02372615f, 
    0.20796834f, 0.00980619f, -0.03128582f, -0.04388753f, -0.04811665f, -0.09030759f, -0.07465877f, 0.00483600f, 
    0.07602739f, 0.20700911f, -0.06246236f, 0.16033323f, 0.10830033f, -0.02925770f, 0.16606840f, 0.32258055f, 
    0.13922733f, 0.01463274f, 0.34282833f, -0.02034296f, -0.03036571f, 0.04052198f, -0.07763192f, -0.15415658f, 
    -0.02382298f, -0.07840398f, 0.01179355f, 0.27355981f, 0.04921890f, -0.19693580f, 0.01150360f, 0.07539594f, 
    0.13346976f, -0.00818228f, -0.14694281f, 0.02949984f, 0.20072854f, 0.19345695f, 0.08822902f, 0.07861982f, 
    -0.05379022f, -0.15580593f, -0.05031983f, 0.08317893f, -0.09899977f, 0.13919371f, 0.19342087f, -0.10216312f, 
    -0.04922893f, 0.43961182f, -0.00520707f, 0.19671622f, -0.01166523f, -0.02379756f, -0.04535110f, -0.06910994f, 
    0.17885721f, -0.00002976f, 0.04007766f, 0.09742045f, -0.14949682f, -0.09382339f, 0.03902032f, 0.19040397f, 
    0.12920834f, -0.09566830f, 0.07047506f, 0.20033200f, 0.06835584f, -0.01575013f, -0.07867337f, 0.01555513f, 
    0.05915446f, -0.02124314f, -0.02644782f, -0.05927980f, -0.10468264f, 0.08429737f, -0.05354555f, -0.10232995f, 
    0.07635147f, -0.07832675f, 0.14743081f, 0.00500647f, 0.24541967f, 0.15357462f, 0.02334306f, -0.10400227f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.18179308f, -0.20650040f, 0.00410357f, -0.10595465f, 0.05211969f, -0.07194176f, -0.01177200f, -0.07102925f, 
    0.14395829f, 0.13798209f, 0.03431971f, 0.01430305f, 0.05285645f, -0.00507160f, -0.12316220f, -0.01904888f, 
    -0.08095500f, 0.07380864f, -0.06019270f, -0.02879210f, -0.51277214f, 0.07687292f, -0.20708779f, 0.02940331f, 
    0.47796068f, -0.09927768f, 0.00403690f, 0.15534598f, 0.09164335f, 0.19124137f, -0.65872538f, -0.23570614f, 
    0.09157179f, -0.30270767f, -0.65398842f, 0.11544251f, 0.01845105f, -0.22177681f, 0.07740910f, 0.07622949f, 
    -0.09956289f, 0.05565272f, -0.12600642f, -0.25479138f, 0.08514564f, -0.01252449f, 0.00871343f, -0.37124991f, 
    -0.08457210f, -0.13064310f, -0.01726516f, -0.00598299f, 0.08598623f, 0.18966724f, -0.15929352f, 0.12848429f, 
    -0.12198512f, 0.12892261f, 0.16656832f, -0.04075278f, -0.02826053f, 0.17903174f, -0.07432689f, 0.53205407f, 
    0.00911316f, -0.06258689f, -0.19148459f, -0.05339858f, 0.00087358f, -0.05862328f, -0.11791617f, -0.27189398f, 
    -0.36028922f, -0.00867832f, -0.03154494f, -0.21916801f, -0.51965332f, 0.08208511f, 0.05141634f, 0.04390590f, 
    0.05300909f, -0.10134944f, -0.03436201f, -0.18489540f, -0.03250914f, 0.71506047f, 0.00363860f, -0.04919051f, 
    0.03332392f, -0.12866203f, -0.04777117f, -0.45237654f, -0.01723591f, 0.06624090f, 0.18460843f, 0.06510006f, 
    0.16707532f, 0.05046077f, 0.01263324f, 0.09335346f, 0.21529235f, -0.09039425f, 0.04266617f, -0.21783453f, 
    -0.03376577f, 0.03224717f, 0.02746131f, -0.11984573f, -0.02883239f, 0.02279118f, 0.15729053f, -0.17744708f, 
    -0.28773665f, -0.27172518f, -0.01064349f, -0.06604700f, 0.06680627f, -0.12138084f, -0.01519798f, 0.01869439f, 
    -0.16604435f, -0.01797194f, 0.27315700f, 0.04217487f, 0.10930894f, -0.05166905f, 0.17742115f, -0.41470337f, 
    0.12638491f, 0.08632450f, -0.02355338f, -0.43168047f, -0.07165439f, 0.12084939f, -0.08356609f, 0.02152425f, 
    0.23845576f, -0.11058733f, -0.34108257f, 0.06894695f, -0.03185499f, -0.10798825f, -0.39084789f, -0.03335256f, 
    0.04929542f, 0.08230459f, -0.00875934f, -0.00161312f, -0.12345694f, -0.08391850f, 0.16664089f, 0.09598996f, 
    -0.76757848f, 0.02320613f, 0.16286086f, 0.35157105f, 0.07982513f, 0.05742047f, 0.29934874f, 0.21446855f, 
    0.01489994f, -0.13051066f, 0.32456025f, -0.09101922f, -0.37453467f, 0.08243077f, 0.11391385f, -0.07963874f, 
    0.26040733f, -0.02185655f, -0.21156865f, -0.27648711f, -0.02495978f, 0.02450755f, -0.08068400f, -0.11086220f, 
    0.09635563f, 0.21045665f, -0.08411580f, -0.04937664f, 0.00799152f, 0.25757217f, 0.26149791f, 0.12340296f, 
    0.03796124f, -0.17335445f, 0.14830938f, 0.02905016f, -0.04380267f, 0.07370483f, 0.03595859f, -0.58041668f, 
    -0.07012654f, -0.03653416f, 0.07273312f, 0.13893865f, 0.02210382f, -0.25291011f, -0.00163624f, -0.17679648f, 
    -0.19174583f, -0.06818481f, 0.05054319f, 0.24698995f, -0.22394712f, 0.10172482f, 0.00278085f, 0.03063984f, 
    -0.02711903f, -0.41147897f, 0.04565678f, 0.05578868f, 0.01803929f, -0.83249843f, 0.10792468f, 0.00854435f, 
    -0.06756795f, 0.19966727f, 0.07224656f, -0.10023189f, -0.03320062f, -0.19091292f, -0.49079809f, 0.03561831f, 
    0.08388521f, 0.03304957f, 0.03965766f, 0.16221167f, -0.59828490f, -0.00813622f, 0.05120971f, 0.00386546f, 
    0.04303192f, -0.09229249f, 0.07509957f, 0.16289034f, 0.18086377f, 0.00232185f, -0.11781223f, -0.30777586f, 
    -0.18211366f, -0.12886007f, 0.03667575f, -0.05567697f, 0.00953510f, 0.17277670f, -0.05502908f, -0.00583971f, 
    -0.06820889f, 0.00897104f, -0.00975084f, 0.13888890f, 0.09204867f, 0.02893566f, -0.13991621f, -0.17191140f, 
    -0.15748116f, 0.10092202f, -0.08013217f, 0.00310141f, -0.05705000f, 0.24554333f, -0.21024987f, -0.00868122f, 
    -0.20177573f, -0.17557259f, 0.12042307f, -0.10380472f, -0.00398356f, 0.05562829f, -0.08418585f, 0.01012790f, 
    -0.25246853f, -0.01701942f, -0.06389086f, -0.02688404f, 0.06120069f, 0.04116629f, 0.03379072f, 0.06363896f, 
    0.20643705f, 0.04011365f, 0.11259618f, -0.57433933f, -0.06690121f, 0.10408639f, -0.51086557f, -0.20516872f, 
    0.08144157f, 0.22527380f, -0.38466337f, -0.10714380f, 0.22981824f, 0.04982395f, -0.64477128f, -0.04490517f, 
    0.13774234f, -0.12677692f, -0.24294178f, 0.25147018f, 0.04750206f, 0.00454861f, -0.12168703f, 0.16832656f, 
    0.02597519f, 0.14324370f, 0.00090895f, -0.28910151f, -0.13316868f, -0.39771557f, 0.00547765f, -0.06889074f, 
    0.23487215f, 0.03479688f, -0.03897784f, -0.08054227f, -0.06044521f, -0.41884863f, 0.04492057f, -0.05607763f, 
    -0.03325479f, 0.01244600f, 0.12106571f, -0.22150320f, 0.06253707f, -0.03853047f, -0.42832384f, -0.23081256f, 
    -0.04724723f, 0.06958300f, 0.01886332f, -0.30984950f, 0.11589807f, -0.37605509f, 0.03152591f, 0.29178211f, 
    -0.07004090f, -0.64839453f, -0.00875914f, -0.12437839f, 0.03270419f, 0.10144617f, 0.19182996f, 0.00299720f, 
    0.03217811f, 0.09870514f, 0.10504135f, 0.13090740f, -0.00818131f, -0.09578768f, -0.11777189f, 0.05168764f, 
    -0.19114245f, 0.03439831f, -0.17599754f, -0.18548770f, -0.00416448f, -0.00891404f, 0.00248457f, -0.04974704f, 
    -0.06602149f, 0.04453837f, 0.03557187f, 0.22710992f, -0.36304149f, 0.02991210f, -0.50946939f, 0.37080079f, 
    0.11580385f, -0.01477480f, 0.17008565f, 0.00978931f, 0.06959069f, 0.00113243f, -0.03419172f, -0.09686429f, 
    -0.13591793f, -0.12340160f, 0.08760292f, -0.43841329f, -0.05240186f, -0.16767666f, -0.30354378f, -0.18342084f, 
    0.05804475f, -0.35188463f, 0.05020209f, -0.04366484f, 0.07883282f, 0.15194097f, -0.19458960f, -0.02994420f, 
    -0.43051332f, 0.08798937f, -0.14317031f, -0.03667242f, -0.04882041f, 0.05465234f, -0.09173098f, -0.03003595f, 
    0.08093844f, 0.04205401f, -0.06107897f, -0.07078446f, -0.18076771f, -0.03916931f, -0.06935483f, 0.11845719f, 
    0.10773998f, -0.56317490f, 0.09366925f, -0.12126914f, -0.13346678f, -0.12843034f, -0.24276684f, -0.30633655f, 
    0.18701036f, 0.16375944f, -0.26816490f, -0.07376724f, 0.11540086f, -0.03135046f, -0.04814757f, -0.05814448f, 
    -0.22164099f, 0.01900614f, -0.30074424f, 0.40183502f, 0.02693456f, 0.03671824f, -0.08188687f, 0.32666117f, 
    0.13653347f, -0.03130943f, 0.00111169f, -0.15015061f, -0.00619898f, 0.00822942f, -0.14881566f, 0.01000347f, 
    0.20612994f, -0.01958970f, -0.44393414f, -0.00871526f, -0.07404894f, 0.24147610f, 0.01010760f, -0.23477361f, 
    0.05966570f, -0.10171726f, -0.18007472f, 0.19349380f, 0.03594583f, -0.05419197f, 0.13017343f, -0.03238239f, 
    -0.05036679f, 0.60390866f, 0.01014754f, 0.12741861f, 0.13291390f, 0.09458315f, 0.09028520f, 0.07919148f, 
    0.06641982f, 0.06641480f, 0.07752372f, -0.33821377f, -0.03321716f, -0.13331915f, -0.02427961f, -0.31627801f, 
    0.06899747f, 0.05181246f, -0.00135100f, 0.06624595f, -0.00323865f, 0.36002755f, 0.03876502f, 0.01466171f, 
    0.06488378f, 0.07563584f, -0.04666319f, -0.03131483f, 0.22409382f, -0.02231762f, 0.02750112f, -0.04361595f, 
    -0.28335553f, 0.08838120f, -0.01038075f, 0.00820720f, 0.14474891f, 0.01655954f, -0.13366728f, 0.16741425f, 
    0.01037998f, -0.11990938f, -1.04371631f, 0.01610591f, -0.09420197f, 0.13413595f, -0.06939416f, -0.02221568f, 
    -0.29649749f, -0.07398520f, -0.32884750f, -0.11105558f, 0.07597551f, -0.16271253f, -0.01059587f, -0.07696581f, 
    0.15899175f, -0.14483298f, 0.08074183f, 0.24086674f, 0.04294217f, -0.33569440f, 0.09321580f, 0.01018458f, 
    -0.24329317f, 0.14099751f, 0.14431976f, -0.07103338f, -0.07047445f, -0.06910261f, 0.02182852f, -0.02596914f, 
    0.09760318f, 0.02388636f, -0.07375575f, 0.00443856f, -0.07760150f, -0.05981591f, -0.29810405f, -0.01419756f, 
    -0.59157312f, 0.05544899f, -0.02675473f, 0.10143452f, 0.04549019f, -0.01356452f, -0.46869341f, -0.27803963f, 
    -0.08626399f, -0.10359587f, -0.37766346f, 0.06886423f, -0.55581498f, -0.05856363f, 0.12415728f, 0.01201099f, 
    -0.46590814f, 0.11344428f, -0.00365976f, -0.37242836f, -0.00271944f, -0.08166404f, -0.02875077f, -0.22046128f, 
    0.07523339f, -0.60101408f, -0.05691685f, 0.21333395f, 0.06496493f, 0.09859025f, -0.23836066f, 0.09355633f, 
    0.12310243f, -0.48007178f, -0.20681359f, 0.03706978f, -0.02625430f, -0.03696031f, -0.01827486f, -0.25758484f, 
    -0.00568394f, 0.00314282f, -0.57763010f, -0.81220227f, 0.02085489f, -0.24162759f, -0.20949873f, 0.14216699f, 
    -0.06548996f, -0.14763799f, -0.34024417f, -0.24563769f, 0.03069305f, -0.03801708f, -0.11505868f, 0.05640732f, 
    0.04160069f, 0.29981220f, 0.01632874f, 0.06996161f, 0.05835881f, -0.53993434f, -0.03902879f, -0.12659679f, 
    -0.02857665f, 0.12272296f, -0.08487880f, -0.08857612f, -0.07221378f, 0.21186003f, 0.11531507f, 0.01784312f, 
    0.03032849f, -0.03100575f, -0.07230198f, -0.01643806f, 0.10090133f, 0.04279974f, -0.12725006f, -0.03456748f, 
    -0.22417444f, 0.08283430f, -0.03789991f, -0.53445137f, -0.02972662f, -0.00003894f, 0.07453100f, 0.09923458f, 
    0.24556318f, 0.07048090f, 0.00806719f, -0.07992994f, 0.07153725f, -0.43659544f, 0.08522496f, -0.00386212f, 
    0.14370677f, 0.05510877f, -0.36122710f, -0.05987975f, 0.01100923f, 0.07729952f, 0.13957295f, 0.05215853f, 
    0.03704805f, 0.09173587f, 0.08574552f, -0.21118595f, -0.02106325f, -0.47332615f, 0.09554107f, 0.01096681f, 
    0.15018500f, 0.10953239f, 0.06946339f, 0.04371827f, -0.00980308f, 0.00493568f, -0.14661168f, -0.10126662f, 
    0.02396366f, 0.00657676f, -0.06391136f, 0.00744561f, 0.00666972f, 0.05035866f, 0.05157988f, -0.09706994f, 
    0.05647181f, -0.15323071f, 0.06115126f, 0.07196994f, 0.10524386f, 0.13658388f, -0.04149726f, -0.07015476f, 
    -0.03401232f, -0.47946373f, -0.16315928f, -0.10446618f, -0.49418101f, -0.19997673f, 0.12449644f, 0.01003977f, 
    -0.51476800f, 0.03346966f, 0.09112094f, -0.19611721f, 0.02503024f, 0.06990541f, -0.02236258f, -0.57785892f, 
    0.14255761f, 0.01648278f, 0.05242860f, 0.15266506f, -0.01362243f, -0.02999182f, -0.31078202f, 0.12724966f, 
    -0.00726740f, 0.07598221f, 0.01287202f, -0.05333592f, 0.02581891f, -0.15002702f, -0.02772463f, 0.15272200f, 
    0.07388397f, 0.00917252f, 0.18346515f, 0.16820110f, 0.04466252f, -0.05510198f, -0.11078674f, 0.07859693f, 
    0.18017979f, -0.00399849f, -0.11749608f, 0.08715598f, 0.06380277f, -0.10077583f, -0.00032124f, 0.12158336f, 
    0.04950579f, 0.04468367f, -0.08756538f, 0.15441066f, -0.00837103f, -0.33505061f, -0.51594728f, -0.03372166f, 
    0.00219458f, 0.07421877f, 0.12108274f, -0.10120592f, -0.01129360f, -0.38221097f, -0.22565719f, 0.05258094f, 
    -0.08656212f, -0.05015059f, -0.30632219f, -0.01216584f, 0.11528703f, 0.04885853f, -0.10662118f, 0.11488069f, 
    0.04167453f, -0.06676145f, 0.06360335f, 0.17429489f, -0.03990552f, -0.09437436f, -0.03026011f, 0.18158157f, 
    0.13167207f, 0.09332317f, 0.07960805f, -0.02389077f, -0.00562529f, -0.03204607f, 0.06997047f, -0.02188435f, 
    0.14666161f, -0.01024002f, -0.02454291f, 0.01817899f, 0.09813586f, 0.06160726f, 0.02625050f, -0.04225485f, 
    -0.53519201f, 0.19795309f, -0.39487308f, 0.14776869f, -0.01057940f, 0.30909595f, -0.29349229f, 0.01604082f, 
    -0.08690310f, -0.81343269f, 0.27199072f, 0.05856131f, -0.09180512f, -0.03105947f, -0.38585028f, -0.03293025f, 
    -0.41873080f, -0.07936014f, -0.04792832f, -0.01825646f, 0.11435132f, 0.08336914f, -0.01317733f, -0.25750858f, 
    0.11463113f, 0.00331489f, -0.00294647f, -0.09096505f, -0.18491662f, -0.21691714f, 0.07807419f, -0.08873378f, 
    -0.38317218f, 0.24964298f, 0.17854944f, 0.18055373f, 0.11094093f, -0.13431995f, -0.20659050f, -0.06785264f, 
    0.20110326f, -0.20938930f, -0.15443313f, -0.10727616f, -0.07767555f, -0.06610303f, 0.07756948f, 0.27312869f, 
    -0.62248367f, 0.06144829f, -0.02932419f, -0.17265911f, -0.39043310f, -0.18626006f, 0.13541776f, -0.84573764f, 
    -0.47473350f, -0.30877891f, 0.08805285f, -0.03231349f, 0.04090153f, -0.27051851f, -0.05655820f, -0.06892752f, 
    -0.06296889f, -0.04387235f, 0.12190035f, -0.31559744f, -0.06532788f, 0.18780868f, -0.55075717f, -0.26066160f, 
    0.15663390f, 0.07488234f, -0.11803929f, -0.25489902f, -0.04074756f, -0.45725489f, -0.50886667f, -0.34162602f, 
    0.02284733f, -0.63038868f, -0.00127215f, 0.03172300f, -0.08082043f, 0.11794496f, -0.14774671f, -0.08206076f, 
    -0.03034030f, 0.11518421f, -0.57132661f, 0.16567591f, -0.06373440f, -0.66349155f, -0.13053894f, 0.08029837f, 
    -0.47947216f, 0.04715830f, -0.13560772f, -0.19643466f, -0.19612953f, 0.06583225f, 0.01716232f, -0.45494193f, 
    0.11236381f, -0.07885917f, 0.05703326f, -0.05788367f, -0.25500086f, 0.07900469f, -0.18900095f, -0.25169396f, 
    0.20631045f, 0.12597623f, 0.10509378f, -0.05759386f, -0.01589098f, -0.07544012f, -0.03100131f, 0.05577385f, 
    -0.05372683f, 0.03336798f, 0.26727900f, -0.08766437f, -0.95544952f, -0.12523094f, -0.26537189f, 0.18142608f, 
    -0.27301371f, -0.24520826f, 0.03426233f, 0.08333419f, 0.04448950f, -0.19180298f, -0.16611710f, -0.06066373f, 
    -0.06422847f, 0.30988425f, -0.11500910f, -0.03907845f, -0.09445113f, 0.01256938f, 0.33208567f, -0.11389642f, 
    -0.04748415f, 0.06493363f, -0.02404187f, 0.00057018f, -0.42366093f, 0.03054569f, -0.34997678f, 0.07769344f, 
    -0.26307786f, 0.08658245f, -0.72674310f, -0.29473865f, -0.12152801f, 0.17605990f, -0.05323071f, 0.08661512f, 
    -0.65349633f, 0.03449009f, 0.16088949f, -0.01133414f, 0.10074382f, 0.06305198f, -0.60156304f, 0.00450134f, 
    0.11203659f, 0.15807272f, 0.07234187f, 0.21716663f, -0.01415308f, -0.04716991f, 0.04300649f, -0.25717428f, 
    -0.45116875f, -0.41406083f, 0.03896714f, -0.26309863f, 0.16863503f, -0.56508720f, -0.16585940f, -0.08824915f, 
    -0.27829093f, 0.44338870f, -0.32033181f, -0.06576144f, -0.04334615f, -0.51031411f, -0.05411495f, -0.28846145f, 
    0.05092950f, -0.04446515f, -0.30751526f, -0.02464703f, 0.04332857f, 0.07039757f, 0.31122866f, 0.00903322f, 
    -0.13241886f, -0.11524918f, -0.06214128f, 0.05300299f, -0.53929651f, 0.29887307f, -0.47056624f, -0.23125161f, 
    -0.06756775f, 0.27312306f, 0.00651784f, -0.01633096f, 0.08317103f, -0.00814199f, 0.08930424f, -0.03210257f, 
    0.07327089f, -0.79969895f, -0.11365396f, -0.34076431f, 0.04201827f, -0.08737941f, 0.43248346f, 0.03376281f, 
    -0.02467322f, -0.07584667f, -0.08410452f, 0.09642295f, 0.42555094f, 0.05284828f, 0.00065851f, 0.15215315f, 
    -0.19141527f, -0.07902975f, 0.00929538f, -0.02259289f, -0.17490265f, 0.03577683f, 0.17297463f, -0.34899822f, 
    -0.58396238f, 0.04512321f, -0.03422026f, -0.01123706f, 0.00158843f, 0.09985733f, 0.05767283f, 0.06624966f, 
    0.05678957f, 0.09581812f, -0.06109508f, -0.26353595f, -0.05309808f, 0.10622872f, 0.15860058f, -0.05111650f, 
    -0.16706948f, 0.13463576f, -0.37478209f, -0.02047025f, -0.05676720f, -0.39056259f, -0.02339368f, 0.04086162f, 
    -0.49318174f, 0.12626398f, -0.36777353f, 0.04436732f, 0.03234305f, -0.10832227f, 0.16442610f, -0.07484042f, 
    0.00778486f, -0.04045578f, -0.02996602f, 0.03581130f, -0.16132194f, 0.04066471f, -0.01306666f, -0.03423979f, 
    -0.04349857f, 0.00284209f, -0.13265420f, -0.40417862f, 0.14499019f, -0.23946038f, -0.00728578f, 0.17391893f, 
    -0.08331719f, -0.22403753f, -0.22687529f, -0.32466000f, 0.27095076f, 0.31310284f, -0.00116095f, -0.04694072f, 
    0.11612755f, -0.38714477f, 0.23801847f, 0.09830760f, -0.04934551f, 0.03469117f, -0.15317923f, -0.23479761f, 
    0.06742568f, 0.15181035f, 0.01264023f, -0.40338919f, -0.18427716f, -0.30588105f, -0.14795391f, -0.03916904f, 
    -0.61354989f, 0.39991459f, 0.06412413f, -0.06807489f, 0.06296852f, -0.02319588f, 0.06234783f, -0.26168069f, 
    -0.02068449f, -0.08052053f, -0.03811527f, -0.00072171f, -0.05582115f, 0.18074381f, 0.25303298f, 0.30103955f, 
    -0.01025640f, -0.00504256f, -0.09049477f, 0.09689974f, 0.18593788f, -0.25952816f, -0.06232381f, -0.49832812f, 
    -0.03589353f, -0.03746620f, 0.04572754f, -0.11763145f, -0.07868423f, -0.00363336f, -0.35672924f, -0.01376037f, 
    -0.12810883f, -0.57313222f, 0.26973924f, 0.06955425f, 0.01802075f, -0.29764223f, 0.05187443f, 0.04672503f, 
    -0.12983929f, -0.01452714f, -0.13192149f, 0.08676045f, -0.15976253f, 0.06495300f, -0.02061329f, 0.25049481f, 
    0.15073426f, -0.05485861f, 0.02550949f, 0.28398231f, -0.58593565f, 0.05221024f, 0.24027614f, -0.36839947f, 
    -0.69704098f, 0.09611490f, -0.05122378f, -0.03854519f, -0.04829994f, 0.02069551f, 0.04614026f, -0.02520096f, 
    0.13601129f, 0.07508414f, 0.11947723f, 0.09710974f, 0.19584484f, -0.12826163f, -0.22509299f, -0.03093970f, 
    0.23680949f, 0.13060789f, 0.18281616f, 0.27123296f, -0.07008246f, 0.19424839f, 0.19300087f, 0.07299615f, 
    0.30196428f, -0.05717808f, 0.28415295f, -0.07691780f, -0.05287874f, -0.02480132f, -0.08422048f, 0.00766426f, 
    0.03965692f, -0.00942282f, -0.06903908f, -0.08018080f, 0.10726486f, -0.02905084f, -0.46045348f, 0.21991886f, 
    0.17184170f, -0.19752543f, 0.05819384f, -0.21177405f, -0.05772422f, -0.51390034f, -0.14312530f, -0.16350810f, 
    0.06593178f, 0.05423202f, 0.02560268f, 0.12527467f, 0.01668584f, 0.10081113f, 0.09492806f, -0.04685575f, 
    0.14382347f, 0.03883407f, 0.02808853f, -0.32010514f, -0.00169163f, 0.00876473f, -0.03969000f, 0.01954333f, 
    -0.31727678f, -0.28306863f, 0.08820222f, 0.10694830f, -0.01425092f, -0.53464806f, 0.00775596f, -0.21024664f, 
    -0.08468465f, -0.13684584f, 0.07498467f, -0.07381415f, 0.00066652f, -0.64495480f, -0.05982918f, -0.18564925f, 
    -0.02007534f, 0.06711798f, -0.20938657f, 0.18105598f, -0.02137712f, -0.02316333f, -0.15637346f, 0.07137776f, 
    0.13478246f, -0.27855843f, -0.03962369f, -0.54604381f, 0.27542135f, -0.09435538f, -0.45907828f, -0.17958477f, 
    -0.03264375f, -0.02626652f, -0.03463971f, -0.01298430f, 0.04745097f, 0.14814816f, -0.19576530f, -0.13864614f, 
    -0.07052369f, 0.05077877f, -0.22331633f, 0.12296027f, -0.08058410f, -0.14979042f, 0.26292187f, -0.01652028f, 
    -0.21216331f, 0.04799237f, 0.42239916f, -0.15270098f, -0.27038270f, -0.05578064f, 0.00081757f, -0.14119151f, 
    0.04100507f, -0.02479530f, 0.00771097f, -0.08043761f, -0.47131354f, -0.02709034f, -0.08995819f, -0.19221921f, 
    0.13030094f, 0.06768415f, -0.32088995f, -0.05490777f, 0.04627410f, -0.36784801f, 0.00046199f, -0.05446269f, 
    0.03997822f, -0.00391985f, -0.12147290f, -0.16030306f, -0.17080562f, 0.06487352f, 0.33839077f, 0.01454501f, 
    -0.43404922f, -0.00402553f, 0.10652522f, -0.36561632f, -0.01328424f, 0.05671120f, -0.16887185f, -0.06160264f, 
    -0.11574476f, 0.03264873f, -0.20172991f, -0.05605447f, -0.08012244f, 0.03844962f, 0.37712592f, -0.04254603f, 
    0.08141812f, 0.02963708f, -0.08116603f, 0.02825123f, 0.11028982f, -0.05809740f, 0.18588762f, 0.07076456f, 
    0.05724803f, -0.89584506f, -0.07897658f, -0.39108604f, -0.20685467f, -0.01326109f, -0.17278217f, 0.10042096f, 
    0.22053531f, -0.34013200f, 0.02278349f, -0.46968606f, -0.22251950f, 0.01582230f, 0.13731347f, 0.01473157f, 
    -0.22714294f, -0.15377575f, 0.13326725f, -0.37142822f, -0.06649549f, -0.07777169f, 0.03246109f, 0.21219024f, 
    0.15669905f, -0.13931957f, -0.08185507f, 0.10472977f, -0.40944952f, -0.04037154f, -0.35942057f, 0.07640811f, 
    0.03444523f, 0.00146441f, 0.13599347f, 0.07490506f, -0.08391039f, -0.27915844f, -0.08315436f, -0.14498195f, 
    -0.01977225f, -0.06802961f, -0.01972094f, -0.62461406f, 0.04219517f, -0.01744342f, -0.62314945f, 0.31376743f, 
    -0.11544914f, 0.14323260f, -0.20922056f, -0.06771703f, 0.16154356f, 0.08781516f, 0.11324967f, 0.21716709f, 
    -0.08422966f, 0.27164662f, 0.02357050f, -0.19355108f, -0.02216566f, -0.00684848f, -0.51946568f, -0.11307095f, 
    0.04271326f, 0.00891817f, 0.03453699f, 0.06695702f, -0.00171607f, -0.44202429f, -0.06434802f, 0.01068576f, 
    -0.75489670f, -0.09207734f, -0.06582269f, -0.54828978f, -0.55983835f, -0.05793120f, -0.01488026f, 0.15363871f, 
    0.00501708f, 0.01509382f, 0.07752726f, -0.35664421f, 0.19623081f, -0.09017786f, -0.34097263f, -0.00675730f, 
    0.01984520f, -0.31524888f, -0.42425686f, 0.08493568f, 0.06454080f, 0.20803359f, 0.07746079f, 0.03864628f, 
    0.20913613f, 0.09900293f, 0.21817385f, 0.17160530f, -0.07295422f, -0.42315501f, -0.01943130f, 0.14016211f, 
    -0.39989382f, -0.04116124f, -0.44911537f, -0.30570915f, 0.00410380f, -0.20053008f, 0.00291545f, -0.00271204f, 
    0.01946296f, -0.17529972f, -0.11489554f, 0.01671747f, -0.10086386f, -0.11657894f, 0.00789866f, -0.04740803f, 
    -0.26746401f, 0.04312448f, -0.09692263f, 0.06496742f, 0.20248562f, 0.07546690f, 0.25326350f, -0.57119769f, 
    0.01627867f, -0.05857912f, -0.23093790f, -0.17545405f, -0.20623609f, -0.26018018f, 0.10553775f, 0.04604327f, 
    -0.21983768f, 0.20670219f, 0.08166422f, 0.03163863f, 0.10144188f, -0.33433864f, -0.56234497f, -0.06636920f, 
    -0.04038752f, 0.00357450f, 0.11042792f, 0.27183798f, -0.01743414f, -0.03625617f, -0.00990763f, 0.22721426f, 
    0.11973600f, -0.00336667f, 0.04091644f, 0.18352319f, -0.23399362f, -0.33646512f, 0.26252717f, -0.21958303f, 
    -0.16097455f, -0.34062186f, -0.02862139f, -0.07127742f, 0.00157876f, 0.02305772f, 0.01900550f, -0.16562410f, 
    0.05260206f, -0.09107877f, 0.24773127f, 0.02669092f, 0.00522098f, 0.12602827f, -0.00071686f, -0.10932767f, 
    0.08777411f, -0.41287142f, -0.18242057f, 0.22883855f, -0.33825329f, -0.20727155f, 0.02290768f, -0.28983614f, 
    0.08114104f, 0.23237972f, -0.01356598f, 0.16955923f, 0.02445704f, 0.17981996f, -0.26459727f, -0.03565845f, 
    0.00920909f, -0.08474775f, -0.35213119f, 0.06464090f, -0.04038046f, 0.18325953f, -0.43360046f, 0.04250421f, 
    0.14410047f, -0.03148157f, -0.30658397f, 0.09049451f, -0.17822449f, -0.04897736f, -0.02768839f, -0.02699417f, 
    0.04297269f, 0.05591934f, 0.01315364f, -0.39179784f, -0.14577343f, 0.00918528f, 0.15791048f, -0.21376315f, 
    -0.20183645f, 0.15475678f, -0.18183164f, 0.02689842f, -0.07676712f, 0.28464821f, 0.00792844f, -0.01559650f, 
    0.18206863f, 0.07400306f, -0.20465368f, -0.41227734f, -0.02435478f, 0.11628923f, -0.13289715f, 0.20073183f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.17503184f, 0.30668360f, -0.05115481f, 0.00196233f, -0.00528528f, -0.00397981f, -0.07846135f, -0.12366184f, 
    -0.01205633f, 0.24186864f, 0.02048202f, -0.08733246f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
