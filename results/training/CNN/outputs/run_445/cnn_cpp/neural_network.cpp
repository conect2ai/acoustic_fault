#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.50523949f, -0.54330176f, -0.11003456f, -0.51967067f, -0.77714658f, 0.29465792f, 0.18812996f, 0.30325770f, 
    0.13464293f, -0.37733570f, 0.67152059f, -0.41045049f, 0.17962010f, -0.14510563f, -0.48432636f, -0.35180542f, 
    -0.49866146f, -0.35792929f, 0.01770705f, 0.05730407f, 0.16935560f, -0.55612379f, -0.24696195f, 0.50852811f, 
    0.33821148f, -0.07324164f, 0.74092215f, -0.52392793f, -0.38854691f, -0.52454108f, -0.76708049f, 0.07745679f, 
    0.52789694f, -0.08656918f, -0.11311369f, 0.02538070f, -0.57839394f, -0.34228733f, -0.32695347f, 0.59553641f, 
    1.12597275f, 0.40637201f, -0.07522827f, -0.16052952f, -0.12245008f, -0.67188054f, -0.65092403f, -0.80579609f, 
    0.22532500f, -0.29692408f, 0.25485635f, -0.40937147f, 0.08086333f, -0.18097866f, 0.83271605f, 0.53689402f, 
    0.51929253f, -0.01586520f, -0.27384275f, 0.41022173f, 0.13684285f, 0.43643570f, -0.12272692f, -0.34745994f, 
    -0.42592785f, -0.69703746f, -0.47280145f, 0.30937213f, -0.20331165f, 0.25755647f, 0.11766802f, -0.35156149f, 
    0.78607774f, 0.41204372f, 0.80014503f, 0.35789797f, 0.26085362f, -0.19166422f, -0.04286388f, 0.17715441f, 
    0.23685628f, -0.01551862f, 0.51870829f, -0.03222601f, -0.86582071f, 0.63672417f, -0.11190951f, -0.18611188f, 
    0.12004599f, 0.10180974f, -0.76666194f, -0.07482561f, -0.37961063f, 0.42615151f, -0.30155006f, 0.29512382f, 
    0.31030944f, -0.18690753f, 0.42182630f, 0.37047729f, -0.50486225f, 0.47808835f, 0.54607362f, -0.80915672f, 
    0.48770052f, 0.30778208f, -0.36592087f, -0.07416089f, -0.17747895f, 0.86599398f, -0.36656171f, 0.69554001f, 
    -0.12455707f, -0.35457376f, -0.02582089f, 0.13550113f, -0.02530722f, 0.15771745f, 0.32259813f, 0.05760570f, 
    -0.47990534f, -0.77804935f, -0.97488898f, -0.28850406f, 0.36119825f, 0.29044777f, 0.02119202f, 0.33213472f, 
    0.53098404f, 0.27331609f, 0.58348536f, 0.46257183f, -0.30997381f, -0.70677644f, 0.32290447f, 0.48338878f, 
    0.16960701f, 0.34615588f, -1.03391063f, -0.08245115f, -0.53812349f, 0.22690691f, -0.11982297f, -0.13329262f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.14993306f, -0.25370008f, -0.11347039f, 0.16417508f, 0.37033045f, 0.04576483f, 0.31773558f, -0.08363280f, 
    0.39938235f, 0.05591224f, 0.03003688f, -0.16366322f, -0.30771521f, -0.05129266f, -0.68843251f, 0.17487204f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.11366232f, -0.23443414f, -0.21742730f, 0.11957201f, 0.04275906f, 0.00296271f, -0.09611857f, 0.02695179f, 
    -0.00206128f, -0.06446718f, 0.14549129f, -0.03985171f, 0.04772229f, 0.03171532f, -0.08741265f, 0.10037106f, 
    0.08934408f, 0.04765266f, 0.09796623f, -0.15936808f, 0.06979358f, 0.07459833f, -0.07367708f, -0.00472365f, 
    0.04405953f, -0.14561246f, -0.01852346f, -0.24719931f, -0.27757701f, -0.06735746f, 0.17690082f, 0.09781375f, 
    0.06284069f, -0.04262261f, -0.08815640f, -0.12696593f, -0.38255706f, -0.26231295f, -0.33828205f, 0.02973128f, 
    -0.01873211f, 0.08751731f, -0.07496704f, -0.03140974f, -0.06737010f, -0.30210909f, 0.23817275f, -0.15919521f, 
    -0.09062652f, 0.00570394f, -0.05913924f, -0.02060212f, -0.05734545f, 0.05198978f, -0.15495583f, 0.34170568f, 
    0.31754968f, 0.09827328f, 0.09957769f, -0.07666761f, 0.13778487f, 0.05577109f, 0.11195697f, -0.07190846f, 
    0.13672101f, 0.00142900f, 0.26181090f, 0.10336921f, -0.01735445f, -0.04068200f, 0.05447092f, -0.00736297f, 
    -0.06283032f, 0.10697202f, 0.51978904f, -0.07750417f, 0.13064423f, 0.20340706f, -0.07696716f, 0.01511994f, 
    0.13449557f, -0.04290609f, 0.13710000f, 0.17132179f, -0.09016710f, 0.01987574f, 0.00416952f, 0.01281987f, 
    -0.00669664f, 0.18825917f, -0.14595242f, -0.16073248f, -0.08612166f, -0.24465901f, 0.04179612f, -0.03058933f, 
    0.09170440f, 0.05377718f, 0.00111232f, -0.48544973f, -0.26488677f, -0.11301187f, 0.13959001f, -0.09664121f, 
    0.13402387f, -0.07667523f, -0.11296736f, -0.08525092f, -0.20125222f, -0.21986800f, 0.07695101f, 0.00266923f, 
    0.10923646f, -0.04305564f, -0.07645268f, -0.10114395f, -0.08965987f, 0.30473423f, 0.08171979f, 0.09234659f, 
    -0.24223076f, 0.06431675f, -0.04232854f, 0.07337525f, 0.12496920f, 0.17797633f, 0.06162427f, -0.12416045f, 
    0.09644271f, -0.06884877f, 0.03294668f, 0.05500823f, 0.09752059f, -0.14644428f, 0.15468575f, 0.17411958f, 
    0.23605572f, 0.21223614f, -0.00581537f, 0.13452218f, 0.08917964f, 0.07472209f, -0.08541263f, -0.04396230f, 
    0.01377209f, 0.28136981f, -0.12398155f, 0.08884449f, -0.02804498f, 0.07279315f, 0.09827177f, 0.08741006f, 
    0.04007614f, -0.12711446f, -0.09363241f, -0.04145825f, 0.08537690f, 0.06463040f, 0.10763101f, -0.07138018f, 
    -0.09021167f, -0.38856614f, -0.01775221f, -0.04536528f, -0.20071152f, 0.15365399f, 0.02184028f, -0.14749885f, 
    0.30663985f, -0.00443208f, 0.21111074f, -0.22340652f, 0.31012544f, 0.08664777f, 0.10972369f, 0.11437852f, 
    -0.10924096f, -0.15311371f, -0.06080996f, 0.03475650f, -0.02183955f, -0.06971626f, -0.08290845f, -0.15964800f, 
    0.00572201f, -0.11289716f, 0.12944435f, -0.10456469f, -0.04605180f, 0.14616172f, 0.14472154f, 0.00502095f, 
    0.07938311f, -0.17410454f, 0.06894287f, 0.15064234f, -0.02520661f, -0.07553051f, 0.18486601f, -0.13877723f, 
    0.04388332f, 0.26717201f, 0.05464513f, 0.11641375f, 0.03827040f, -0.10351746f, 0.28001717f, 0.08236922f, 
    0.00554520f, -0.33653602f, 0.06315096f, 0.11979483f, 0.16850536f, 0.02495894f, 0.04242351f, 0.02460678f, 
    0.22405802f, 0.00412236f, 0.10809367f, 0.12624228f, 0.02634015f, -0.13714261f, 0.03900938f, 0.04901380f, 
    0.12000052f, -0.02660666f, -0.16597117f, -0.06651324f, -0.07554491f, -0.04436870f, -0.04013041f, 0.10848407f, 
    0.01191075f, -0.01488548f, -0.23009866f, 0.23866466f, -0.02991251f, 0.08696968f, -0.13329172f, 0.03506272f, 
    -0.03035680f, -0.02294797f, -0.15532283f, -0.04970537f, 0.15862754f, 0.29417956f, 0.13059127f, -0.06699772f, 
    0.05943446f, 0.18853804f, -0.05144586f, 0.07516441f, -0.45026612f, -0.26073456f, -0.12102496f, 0.24835692f, 
    -0.04881984f, -0.23798594f, -0.11640139f, -0.16463099f, 0.27077091f, 0.02231717f, -0.11093844f, -0.06582181f, 
    0.02199289f, 0.14044908f, 0.15063186f, 0.06622148f, -0.19996099f, -0.20558432f, 0.03614423f, 0.12072022f, 
    0.04789017f, -0.18387187f, -0.15102826f, -0.37292522f, -0.00531044f, 0.03486343f, 0.07960875f, 0.13151562f, 
    -0.07276048f, -0.12843594f, -0.00953681f, -0.07091854f, 0.17721447f, -0.09956998f, -0.11821515f, 0.11487277f, 
    -0.04066565f, 0.05939523f, -0.19547050f, 0.06704132f, 0.06338561f, -0.02866568f, 0.09134433f, 0.02185548f, 
    -0.13430522f, 0.01470930f, -0.19089074f, -0.18687977f, 0.14584209f, 0.03607931f, -0.28236035f, 0.05186610f, 
    0.09867629f, -0.07668171f, 0.10249763f, -0.11996914f, -0.12278850f, 0.10033724f, 0.10323769f, -0.14241773f, 
    0.10310123f, 0.03913318f, -0.16352974f, -0.22911137f, 0.28720111f, -0.09058667f, -0.11624084f, 0.04442074f, 
    0.00061868f, 0.05752935f, 0.10667971f, 0.15530050f, -0.18031944f, 0.22164322f, 0.07208593f, -0.06294899f, 
    -0.04715005f, 0.17041990f, -0.06675976f, -0.02933133f, 0.31013212f, 0.20709909f, 0.15220630f, 0.02850602f, 
    -0.13022499f, -0.16193144f, 0.09741578f, -0.05896897f, 0.18387385f, 0.20025967f, 0.36110437f, -0.29264253f, 
    -0.04039241f, 0.12015527f, 0.08933011f, 0.06286358f, -0.03691457f, 0.06014228f, -0.25521260f, -0.19032620f, 
    0.19286829f, 0.12529232f, -0.18425305f, 0.11993071f, -0.12985045f, -0.26781273f, 0.10161990f, -0.04945889f, 
    0.13858011f, -0.17936508f, -0.33720270f, 0.14139202f, 0.02118652f, 0.15880777f, 0.08174312f, -0.03677655f, 
    -0.15659901f, -0.06954537f, 0.15328041f, 0.02482429f, -0.05351114f, -0.13041879f, 0.03593403f, -0.01186012f, 
    0.05899271f, 0.37260354f, 0.11918531f, -0.04637572f, 0.13241953f, 0.06530202f, 0.09175208f, -0.00521762f, 
    -0.14607836f, -0.07564655f, -0.04861602f, -0.00248157f, -0.34808701f, -0.30669764f, 0.11988575f, 0.10299674f, 
    0.24803226f, -0.08941762f, -0.10730098f, -0.25230882f, 0.45391372f, 0.04226808f, 0.21099824f, -0.12524994f, 
    0.01491895f, 0.12046880f, -0.02290937f, -0.13657433f, -0.08039448f, 0.24778074f, 0.00015135f, -0.02358497f, 
    0.07596122f, -0.03789165f, -0.32206970f, 0.13805531f, -0.08726663f, 0.09264584f, -0.21301278f, 0.05470088f, 
    -0.17712735f, 0.09730830f, -0.06804052f, 0.02259294f, -0.15151797f, 0.14565535f, -0.05996587f, 0.10450785f, 
    -0.00178990f, -0.12491986f, -0.02220435f, 0.12205054f, -0.07306460f, 0.18417834f, 0.10984802f, 0.11373429f, 
    -0.04250375f, -0.07252793f, -0.06797943f, -0.02021734f, -0.06472213f, -0.02264839f, 0.04626973f, 0.06541557f, 
    0.07354271f, -0.01647637f, 0.05107868f, 0.02750538f, 0.02713380f, -0.01208684f, -0.01254386f, 0.02332400f, 
    0.00812145f, 0.04864310f, 0.02744135f, -0.06080193f, -0.05042411f, -0.03663936f, -0.06142531f, 0.00968875f, 
    0.04359261f, -0.03274345f, -0.08818808f, -0.03869418f, 0.04594965f, -0.08826438f, -0.02772000f, 0.02098755f, 
    -0.03487438f, -0.01403316f, -0.08288922f, -0.05731728f, 0.06586343f, 0.03075545f, -0.04681023f, -0.02464601f, 
    -0.05380618f, 0.02571280f, -0.07139098f, 0.03852964f, 0.05689802f, 0.02001195f, 0.04112041f, -0.09170434f, 
    -0.04521035f, -0.02893055f, 0.04661526f, -0.02123829f, -0.06927861f, -0.03899949f, -0.00625861f, -0.07701178f, 
    0.00228771f, -0.06010734f, 0.06855135f, 0.01642165f, -0.01007405f, 0.05799924f, -0.00636313f, -0.01664846f, 
    -0.06292415f, 0.05595408f, 0.07217988f, -0.01290049f, -0.07922616f, -0.08565160f, -0.06104847f, 0.02792562f, 
    0.05035878f, -0.01107162f, -0.08513886f, -0.07896812f, 0.05085371f, -0.07704420f, -0.04629736f, -0.05334095f, 
    0.03099786f, -0.05965567f, -0.06864421f, -0.00088405f, 0.04622027f, 0.03942807f, 0.00331357f, -0.07448671f, 
    -0.02172184f, -0.07180029f, 0.05950418f, -0.01092004f, -0.08147020f, -0.01395407f, -0.05851159f, 0.01967616f, 
    -0.08481897f, 0.05193101f, 0.06144936f, 0.03948096f, -0.02001481f, -0.05593628f, -0.03615426f, -0.02879390f, 
    -0.02593206f, -0.08024342f, -0.05138989f, 0.01026257f, 0.00184402f, -0.04496339f, -0.04918721f, -0.07047629f, 
    0.01379908f, 0.02065946f, -0.08804636f, 0.05171866f, -0.02539718f, -0.08287946f, 0.02770841f, 0.05386821f, 
    0.02135714f, -0.08192194f, -0.02785705f, 0.07667791f, -0.06132507f, 0.02773159f, 0.03850833f, 0.02515916f, 
    0.00008080f, 0.01351221f, -0.00442254f, 0.04246429f, -0.01705091f, -0.08990940f, 0.01911379f, 0.05256891f, 
    -0.00067738f, -0.08959197f, -0.08270328f, 0.04463300f, 0.05900817f, -0.06814329f, -0.00204231f, 0.03659122f, 
    -0.00703380f, -0.02936011f, -0.08119681f, 0.14188944f, 0.12070180f, 0.02786054f, 0.10827471f, 0.03296298f, 
    0.11336967f, 0.40075907f, 0.14167224f, -0.04918473f, -0.27120391f, -0.18710920f, 0.00883605f, -0.17281990f, 
    0.08496494f, 0.13169189f, 0.03765894f, -0.04699881f, -0.08099640f, -0.03625967f, 0.16223484f, -0.04737597f, 
    -0.01734913f, -0.14468178f, -0.00007756f, -0.07608490f, 0.13695048f, 0.05183465f, -0.14147209f, 0.08279768f, 
    0.00027768f, 0.13967128f, -0.02218831f, 0.06582904f, -0.15785863f, -0.07934981f, 0.04743529f, 0.10275569f, 
    0.21202207f, 0.06582776f, -0.21854009f, 0.01066861f, -0.23754472f, 0.10132077f, -0.19127144f, -0.00516678f, 
    -0.05046599f, 0.02923517f, 0.26550037f, 0.07323455f, -0.13140045f, 0.16092527f, 0.04090129f, -0.04827603f, 
    -0.01948665f, 0.12037320f, 0.31864247f, -0.19974490f, 0.13581914f, -0.05175745f, 0.05689563f, -0.18931697f, 
    0.11810362f, 0.00754500f, -0.08292574f, 0.10729083f, -0.15163900f, 0.03962608f, -0.10774764f, 0.15758668f, 
    -0.08087979f, 0.04109664f, 0.00693128f, 0.05951226f, 0.05328617f, 0.05424922f, 0.27891603f, 0.10302541f, 
    0.04171684f, -0.11715384f, 0.29440799f, 0.16037954f, 0.12755428f, -0.00385765f, 0.02726473f, 0.23849843f, 
    -0.13881028f, -0.07484412f, -0.00241502f, -0.06909447f, -0.04883248f, 0.11804352f, 0.06207993f, 0.04605407f, 
    0.18022349f, -0.10573139f, 0.05017212f, -0.13093024f, -0.10756543f, -0.06152964f, 0.00439730f, -0.03978461f, 
    0.22835641f, -0.06081496f, 0.05031449f, 0.03184059f, 0.15278268f, -0.14622624f, 0.03045563f, -0.31778228f, 
    -0.17969684f, 0.04461791f, 0.15583724f, 0.05301031f, -0.13327731f, 0.15725023f, -0.04448492f, 0.03578928f, 
    -0.02276369f, -0.26228243f, -0.22766303f, 0.18446735f, -0.21710132f, 0.19196022f, -0.26283118f, -0.19291973f, 
    -0.08286693f, 0.21216473f, -0.24715495f, 0.27114058f, -0.03641826f, -0.02348579f, -0.31078100f, 0.06761981f, 
    -0.06456579f, 0.20218226f, -0.09276484f, 0.03627089f, -0.36782011f, 0.02565073f, 0.02156378f, 0.12514113f, 
    0.16690759f, -0.13860971f, -0.29887146f, -0.18600143f, -0.10977755f, 0.05404824f, 0.03843988f, -0.03383827f, 
    -0.11680042f, -0.30626243f, -0.51186728f, -0.14014941f, -0.23386867f, 0.08871757f, -0.20540006f, -0.05340385f, 
    -0.11539077f, -0.17272629f, 0.20946282f, 0.20341209f, -0.04185693f, -0.07613616f, 0.12242603f, -0.06027004f, 
    -0.15140049f, -0.20753212f, 0.01007459f, 0.44070816f, -0.09754603f, 0.04245204f, -0.21379964f, 0.04244796f, 
    0.14434308f, -0.04097476f, 0.07968611f, 0.23634766f, 0.45294783f, 0.05160045f, 0.28498751f, -0.44226706f, 
    -0.10349859f, 0.04011554f, 0.13580750f, -0.04983291f, 0.11090009f, -0.18255685f, -0.08083081f, 0.20706184f, 
    -0.16957508f, -0.00913269f, -0.01854867f, -0.06523649f, -0.05037349f, 0.11289803f, -0.17394073f, 0.24976505f, 
    -0.15654644f, 0.06889576f, 0.13258071f, 0.26810014f, -0.18310633f, -0.01798127f, -0.01739332f, 0.26180965f, 
    -0.06317165f, -0.07255245f, 0.09394412f, 0.21447198f, -0.08395559f, 0.05327987f, -0.04173518f, 0.05744258f, 
    -0.15813676f, 0.19034490f, -0.06230287f, 0.36714953f, 0.27356923f, 0.13351561f, -0.22669986f, -0.15641510f, 
    0.03218687f, 0.30527678f, 0.09087984f, -0.35002044f, 0.10759520f, -0.05971590f, 0.23558022f, -0.12560542f, 
    -0.07087150f, -0.36279976f, -0.13361095f, 0.10803472f, 0.11185879f, -0.10944749f, 0.15244131f, -0.09169067f, 
    0.32110584f, -0.09693594f, -0.11576869f, -0.49432966f, 0.08184633f, 0.00051260f, 0.03058550f, -0.00383374f, 
    -0.02592768f, 0.05605320f, 0.10570496f, -0.02194464f, 0.21407025f, -0.26671940f, -0.06124242f, -0.14249121f, 
    -0.06974556f, -0.00495675f, -0.24660952f, -0.09834107f, -0.00504764f, -0.32353207f, 0.03598568f, -0.11200250f, 
    0.13229662f, 0.24069200f, -0.00363104f, 0.05043947f, 0.06545790f, -0.04658895f, -0.17040826f, 0.17018305f, 
    0.08070689f, 0.10543673f, -0.14233190f, 0.35166585f, 0.31221762f, 0.22706807f, 0.02515913f, 0.50962096f, 
    0.23492426f, -0.36821669f, 0.31182754f, 0.11105113f, 0.00844716f, -0.04687110f, 0.13934392f, 0.03595088f, 
    -0.02285814f, 0.03620544f, 0.00953325f, 0.01574588f, 0.05910208f, 0.01419046f, -0.09162916f, 0.03904699f, 
    -0.04271578f, 0.03338170f, -0.02893995f, -0.00869158f, -0.08371864f, 0.02429825f, 0.05691237f, 0.01262249f, 
    0.06353460f, 0.01504357f, -0.04792804f, 0.03505505f, -0.06463595f, -0.05304462f, -0.06212180f, -0.03239349f, 
    0.01363241f, -0.05053661f, 0.02172872f, -0.04859518f, 0.03465969f, 0.04933382f, -0.00382747f, -0.05506288f, 
    0.01676890f, 0.01631587f, -0.04525989f, 0.04526847f, 0.02934258f, -0.03251798f, 0.03269484f, -0.04475339f, 
    -0.04337572f, -0.01821792f, -0.08947070f, 0.05219590f, -0.09502605f, 0.02466891f, 0.00946406f, -0.00975785f, 
    -0.05288104f, 0.05041342f, -0.05014266f, -0.01597435f, -0.04751370f, -0.02645178f, -0.03121541f, 0.03432235f, 
    -0.03075736f, -0.08965550f, 0.05054205f, 0.00768885f, 0.05694822f, 0.05450182f, 0.03172484f, 0.06005654f, 
    -0.05374560f, -0.03487582f, 0.00178979f, 0.00166559f, -0.08295451f, -0.01000354f, 0.02787788f, -0.09233622f, 
    0.01157844f, -0.06300933f, -0.00059966f, -0.05369109f, 0.06434319f, -0.08547062f, 0.06114060f, 0.01100390f, 
    -0.07654911f, 0.05535169f, -0.04920831f, 0.06210003f, -0.04171600f, 0.01380459f, -0.00678272f, 0.00839967f, 
    -0.00383147f, 0.04802364f, 0.04346316f, 0.01507380f, -0.02454156f, -0.05942556f, -0.02094366f, 0.06057445f, 
    0.03785925f, -0.06985691f, 0.06480622f, -0.05327515f, -0.04527185f, -0.09086037f, -0.08332105f, -0.09094813f, 
    -0.07808825f, -0.01535228f, -0.02217200f, -0.05080649f, 0.03265897f, -0.08412378f, 0.00672100f, -0.06095266f, 
    -0.01712516f, -0.02659045f, -0.07495225f, -0.00703027f, -0.04735086f, -0.03716069f, 0.03838020f, -0.09281220f, 
    -0.02559829f, 0.02542049f, -0.03637016f, 0.01808403f, 0.00961401f, -0.08255461f, -0.00635628f, 0.06745381f, 
    -0.09499827f, 0.01674657f, 0.03463781f, 0.01511940f, 0.07130631f, -0.04552036f, -0.00299468f, -0.07490679f, 
    -0.02501953f, 0.02146165f, -0.05361553f, 0.03333402f, -0.01125509f, -0.01143196f, 0.01613839f, -0.00107943f, 
    0.04363201f, 0.03050367f, -0.07439762f, 0.00679531f, -0.00366678f, 0.04550532f, -0.02387263f, 0.02394007f, 
    -0.06366547f, 0.00054452f, -0.03272288f, -0.09387633f, -0.01441322f, -0.06535455f, -0.02588250f, 0.03543014f, 
    -0.04113268f, -0.00550002f, -0.02211949f, 0.00296347f, 0.07734872f, -0.08512275f, -0.00264074f, -0.02359124f, 
    -0.06259526f, 0.05327594f, -0.04672606f, -0.04938326f, -0.05663693f, 0.06813002f, -0.00672736f, -0.07452155f, 
    -0.05857582f, -0.05409667f, 0.07927682f, -0.00379738f, 0.03568988f, 0.02290530f, -0.02016964f, -0.04236303f, 
    -0.05116329f, -0.08074309f, 0.07210045f, -0.07524978f, -0.01722082f, 0.03900091f, 0.03840438f, -0.05847895f, 
    -0.06999417f, 0.01613230f, -0.02963544f, 0.06947313f, -0.05914245f, 0.00018634f, -0.04274199f, -0.06899800f, 
    -0.06080362f, -0.07342212f, -0.04472190f, 0.00001348f, 0.00895566f, -0.06040713f, 0.01124075f, -0.01248025f, 
    -0.05190429f, 0.01164506f, 0.06215526f, -0.03568687f, -0.00669986f, 0.04984732f, -0.03903461f, -0.01750813f, 
    -0.06581267f, 0.01598071f, -0.03818734f, -0.02845753f, 0.03281201f, 0.05784769f, -0.04079405f, 0.00064153f, 
    -0.04905099f, 0.00861691f, 0.03528619f, -0.09336837f, 0.04750559f, -0.04357700f, -0.00941301f, -0.04392626f, 
    -0.00403704f, -0.06941394f, 0.08217923f, -0.04582106f, -0.07072874f, -0.05947455f, 0.04295180f, -0.01506206f, 
    0.05794402f, 0.03249797f, 0.03877550f, -0.07641056f, 0.06915367f, -0.05496473f, 0.01586197f, -0.07142983f, 
    0.01845776f, -0.02418987f, -0.06731509f, 0.00278024f, 0.06261376f, -0.00895180f, 0.02699928f, 0.02879043f, 
    0.00873001f, -0.00051287f, 0.03870835f, -0.07636847f, -0.02773434f, -0.02555158f, 0.02458799f, 0.01809719f, 
    0.02781438f, 0.03316685f, -0.07638383f, 0.05165649f, -0.02289663f, -0.07702412f, -0.00514064f, 0.04228855f, 
    -0.04148663f, 0.04511004f, 0.05399261f, -0.02610969f, -0.02354880f, 0.00797841f, 0.05167609f, 0.02659045f, 
    0.00532708f, -0.01550602f, -0.02807236f, 0.05571102f, -0.02716833f, -0.08082675f, -0.07340645f, 0.00611032f, 
    -0.55579948f, -0.42472458f, -0.23288611f, 0.03682335f, 0.08044229f, -0.10031097f, 0.02756009f, 0.06782526f, 
    -0.03763565f, 0.18326628f, 0.00918323f, 0.32480252f, -0.14206786f, 0.05617820f, -0.17249261f, 0.17482188f, 
    -0.03446827f, 0.00964491f, 0.11087021f, 0.07652084f, -0.22994165f, -0.03321651f, -0.05549452f, 0.02306580f, 
    -0.19026321f, 0.02145012f, 0.04397944f, -0.11616803f, -0.03369059f, -0.23843063f, 0.08803370f, 0.08787750f, 
    -0.17902909f, 0.18568866f, -0.07998253f, 0.14682001f, 0.36129832f, 0.35625157f, -0.31308708f, 0.23576619f, 
    0.24456923f, 0.03892267f, 0.06978709f, -0.09271980f, -0.00870946f, -0.11889607f, 0.07139910f, -0.01925881f, 
    0.07042693f, 0.17011903f, 0.02568721f, 0.12824537f, -0.03750456f, 0.04732561f, 0.07908729f, -0.03563068f, 
    0.06065685f, -0.18172021f, -0.01476228f, 0.07133036f, -0.09517042f, 0.04292672f, 0.13632141f, -0.28230143f, 
    0.07447265f, -0.01469115f, 0.14246422f, 0.06384511f, -0.03950357f, 0.04765688f, -0.08409417f, -0.17888810f, 
    0.00322392f, 0.14642632f, 0.34328455f, -0.02622593f, 0.10978754f, 0.05416598f, 0.03043671f, -0.05381596f, 
    -0.02214924f, 0.06786228f, -0.16831878f, -0.17308800f, -0.08538236f, -0.09162404f, -0.04427842f, -0.08171352f, 
    0.00801637f, -0.03025630f, -0.21028273f, -0.00934742f, -0.28252646f, 0.29749662f, -0.00020709f, 0.04434523f, 
    -0.10701983f, -0.06607798f, 0.05922682f, 0.20897415f, 0.02048772f, -0.15871532f, -0.14154489f, 0.12059002f, 
    0.17642765f, 0.09782448f, -0.09740887f, 0.00689303f, -0.26735422f, -0.09370239f, 0.04276196f, 0.03715871f, 
    -0.05145285f, -0.06363118f, -0.14089933f, 0.01321161f, -0.10636454f, -0.03863815f, 0.03893215f, 0.18228029f, 
    -0.26859587f, 0.06494916f, -0.05615710f, -0.21369296f, 0.09293837f, 0.23277931f, -0.07107618f, -0.04605060f, 
    0.11328347f, 0.00880556f, -0.12956825f, -0.14444467f, 0.16949278f, 0.25857291f, -0.17920601f, -0.00235615f, 
    -0.00545871f, -0.02663720f, -0.04325747f, 0.07218417f, -0.00698501f, 0.00679558f, 0.03909773f, 0.21207689f, 
    0.06193644f, -0.14079911f, 0.02962802f, -0.15022644f, 0.08360922f, -0.19949257f, -0.00443532f, 0.04331822f, 
    -0.04374798f, 0.28190777f, 0.22684823f, -0.03118534f, -0.16171665f, 0.11641449f, 0.05038303f, 0.08301003f, 
    -0.20682314f, -0.06859584f, 0.14642838f, -0.18471090f, -0.31553957f, -0.02007665f, 0.08659516f, -0.09359192f, 
    0.05432530f, -0.12135353f, -0.04094403f, 0.26353130f, -0.26711631f, 0.23510148f, 0.19500469f, 0.04100594f, 
    0.02508922f, 0.06109029f, 0.02324102f, -0.02357210f, -0.12437670f, 0.07221122f, 0.00452179f, -0.05159234f, 
    -0.13390936f, 0.02142865f, 0.07545850f, 0.02236803f, 0.04582679f, 0.18021381f, -0.34331527f, 0.29885653f, 
    -0.04035150f, -0.05009567f, 0.12683401f, -0.00923416f, -0.03210837f, 0.00122003f, -0.39333531f, 0.00211409f, 
    -0.11048053f, -0.08785783f, 0.09274231f, -0.13049150f, -0.04671944f, 0.00668705f, -0.03236750f, 0.09469435f, 
    0.10183103f, 0.22085552f, 0.03707192f, -0.04965384f, 0.06563522f, -0.02160247f, 0.12838665f, 0.16351734f, 
    -0.20021574f, 0.05766007f, -0.25634363f, -0.03901453f, -0.00166157f, 0.05554779f, 0.11700898f, 0.00493973f, 
    -0.03483933f, -0.03085005f, -0.15154265f, 0.05350253f, 0.11484380f, 0.08862403f, 0.03507606f, -0.12049384f, 
    0.03507806f, -0.01751893f, -0.17488554f, -0.04472968f, 0.06050666f, 0.08135373f, 0.00683013f, 0.13016686f, 
    0.11077070f, -0.02990777f, 0.09076902f, 0.27056560f, 0.03637584f, -0.28865185f, -0.21486320f, 0.15668848f, 
    -0.09413578f, -0.04433293f, 0.10048573f, -0.02802468f, 0.37810928f, 0.36091828f, 0.08652086f, -0.21632704f, 
    -0.08673145f, 0.00592833f, -0.13501211f, 0.03345843f, 0.00536917f, 0.07884850f, 0.03858972f, -0.08877714f, 
    0.07231349f, -0.02665919f, -0.15932304f, 0.02849779f, 0.17073426f, 0.00269639f, 0.13711771f, -0.26927161f, 
    0.16845892f, 0.13325332f, -0.05949574f, 0.22785828f, -0.00546123f, -0.08625221f, -0.05999228f, 0.14229356f, 
    0.00459977f, 0.03740398f, 0.10781508f, 0.08941035f, -0.10344545f, 0.03289854f, -0.16887015f, -0.01809668f, 
    0.06454989f, -0.23835446f, 0.00653314f, 0.01429399f, -0.11775095f, 0.04738347f, -0.02644824f, -0.01098065f, 
    0.01055016f, -0.22523986f, -0.25264290f, 0.13544892f, 0.11387572f, -0.12822866f, -0.17275424f, 0.14396475f, 
    0.08465393f, -0.03684321f, 0.06445786f, 0.38172403f, -0.02463689f, -0.08932994f, -0.10320836f, 0.12302267f, 
    -0.11324514f, -0.07164930f, 0.03124985f, 0.11018647f, 0.05555984f, 0.40135866f, -0.12449958f, 0.08855961f, 
    0.09774666f, 0.16257952f, -0.01321070f, 0.06594950f, 0.32938975f, 0.04280646f, 0.25566173f, -0.06786606f, 
    -0.09265209f, -0.05028601f, 0.04341683f, 0.19263549f, 0.18836752f, 0.46387735f, 0.11365367f, 0.47861668f, 
    0.21067075f, -0.08569289f, 0.03340619f, -0.02604970f, 0.05023905f, 0.04602030f, 0.09005029f, 0.09791328f, 
    0.12033281f, 0.03345508f, 0.02888950f, -0.03045553f, 0.11271401f, 0.03258744f, -0.14585717f, 0.29364291f, 
    0.42141142f, 0.30370387f, -0.00781486f, 0.07263240f, -0.01277951f, -0.01726890f, -0.00159282f, -0.04483267f, 
    0.36830550f, 0.06128490f, -0.11576956f, 0.05579045f, 0.34813282f, 0.02886904f, 0.02619231f, -0.06287444f, 
    0.16660318f, -0.26065922f, 0.00244478f, -0.19433285f, -0.07911836f, -0.02775850f, -0.02731497f, -0.10305489f, 
    -0.02648279f, -0.06477017f, -0.12592457f, 0.06336917f, 0.23218185f, 0.20211959f, 0.07333329f, 0.16708735f, 
    -0.04049489f, -0.04951094f, 0.12502205f, -0.01217858f, -0.18458119f, -0.11979304f, -0.18203795f, 0.23533212f, 
    -0.11921278f, 0.03097703f, -0.06534408f, -0.06562258f, -0.39437243f, -0.06763502f, -0.28514355f, 0.06655096f, 
    -0.14611536f, -0.18509038f, 0.08997408f, -0.08465682f, 0.19058323f, -0.40740621f, -0.34457114f, -0.42352018f, 
    0.13567455f, -0.18183947f, -0.08207679f, -0.01673010f, -0.03009374f, 0.02881967f, 0.19356014f, -0.52958840f, 
    0.01544638f, 0.12598051f, 0.11502032f, 0.12508978f, -0.01633305f, 0.21900021f, 0.08429111f, -0.62968570f, 
    -0.14432368f, -0.62990338f, -0.10423651f, 0.03171943f, -0.06922960f, -0.14031871f, -0.11035687f, -0.06524009f, 
    0.04095680f, 0.22997789f, -0.05230420f, -0.25450265f, -0.24549200f, -0.18092847f, 0.00896362f, 0.17093445f, 
    0.13241714f, 0.12800986f, -0.39678404f, -0.18075866f, 0.05184094f, 0.07807752f, -0.12954232f, -0.15988913f, 
    -0.18097170f, -0.21469106f, 0.07526807f, -0.10254309f, -0.08745241f, -0.23316059f, -0.06057292f, -0.03202628f, 
    -0.01624600f, -0.06215477f, 0.17794302f, -0.11227705f, -0.02989665f, -0.00191022f, 0.06100846f, -0.08842346f, 
    -0.13505538f, 0.07001735f, -0.00096672f, -0.11888816f, 0.28816840f, 0.24209048f, -0.10905667f, 0.15498075f, 
    0.24292099f, -0.03517855f, 0.08027508f, 0.28318414f, 0.11388011f, 0.14835334f, 0.26204500f, 0.14178200f, 
    -0.05695468f, 0.06780444f, -0.05556334f, 0.10429341f, 0.19180658f, 0.00611579f, -0.46307722f, -0.40228766f, 
    -0.05755831f, -0.01440322f, 0.02992005f, -0.08137978f, 0.05947101f, 0.15695500f, -0.00455244f, -0.18569133f, 
    0.01833688f, 0.05341039f, -0.06335228f, 0.04323004f, 0.07522327f, -0.08590778f, -0.01096549f, -0.08776638f, 
    -0.65910268f, -0.42289639f, -0.08318805f, 0.16457057f, 0.18210348f, 0.17312101f, 0.01842711f, 0.04858467f, 
    0.05229343f, -0.42676133f, -0.26799458f, -0.12626429f, -0.07239265f, -0.21343981f, -0.01368600f, -0.02557071f, 
    0.06107902f, 0.08642968f, 0.18158013f, 0.12744965f, -0.14231615f, -0.25079745f, 0.01783374f, 0.22183327f, 
    -0.12058982f, -0.00642455f, 0.07116494f, -0.37900800f, -0.11231016f, 0.11759823f, 0.17118822f, 0.03624255f, 
    0.06746739f, -0.08559946f, 0.15634264f, -0.09012647f, 0.15497260f, -0.34755567f, -0.35446465f, 0.06229562f, 
    0.04065799f, -0.17017628f, 0.21019256f, 0.13352621f, 0.04959012f, 0.26767561f, -0.07124144f, 0.07924957f, 
    0.05752315f, 0.08080200f, 0.13006133f, -0.16955145f, -0.06577002f, 0.06629134f, -0.15571208f, -0.09250064f, 
    -0.07488641f, 0.04439151f, 0.06464588f, 0.09702814f, -0.00471243f, -0.03114513f, -0.13571423f, 0.05730588f, 
    -0.06385672f, 0.30082288f, 0.12103250f, 0.00587624f, 0.16918042f, -0.02116050f, -0.02751439f, -0.04584730f, 
    0.07693140f, 0.00845782f, -0.33108360f, 0.02372279f, 0.10887063f, 0.28732374f, 0.16489208f, -0.07983044f, 
    0.00257165f, -0.11907136f, 0.07252723f, 0.13592279f, -0.22949678f, -0.14598086f, -0.17830156f, 0.05810035f, 
    0.07308123f, 0.29566538f, 0.20970596f, 0.00870594f, 0.01400278f, 0.00489614f, -0.06110942f, 0.18510796f, 
    0.15500288f, 0.05928628f, 0.06895351f, -0.54630554f, -0.13964161f, 0.33266941f, -0.02103377f, -0.02278372f, 
    0.14786744f, -0.01530452f, 0.19333158f, -0.04356062f, -0.20519145f, -0.46593317f, 0.01738296f, 0.00907461f, 
    -0.14937119f, -0.02906920f, 0.03726824f, -0.09267828f, -0.06893475f, -0.28787729f, 0.16046600f, 0.22290733f, 
    -0.07221901f, -0.05436175f, -0.27428979f, 0.02139693f, -0.19287995f, 0.21121481f, 0.19088414f, 0.14211027f, 
    0.10528317f, 0.07808660f, 0.12944642f, -0.03430159f, 0.15300608f, 0.12644322f, -0.01708714f, -0.38561738f, 
    -0.14707586f, 0.02349964f, -0.03873945f, 0.15951261f, 0.07105275f, -0.05809510f, 0.07322614f, -0.18594049f, 
    0.08097850f, 0.33431500f, 0.01095072f, 0.11724541f, 0.03204491f, -0.10999704f, -0.08616947f, -0.01087985f, 
    -0.03442318f, 0.15229928f, -0.07436074f, 0.05410153f, 0.12592444f, -0.03174474f, 0.01997024f, 0.05259033f, 
    0.04657141f, 0.21372333f, -0.21679071f, -0.16415049f, 0.15485543f, -0.11359420f, 0.05730076f, 0.21938817f, 
    -0.08790458f, 0.07996777f, -0.05182084f, 0.40573046f, 0.01787996f, -0.14885315f, -0.22340684f, 0.03788058f, 
    0.07313078f, 0.06453487f, 0.11067762f, 0.21217531f, -0.22670877f, 0.05207020f, 0.16494222f, 0.10556731f, 
    -0.05693477f, 0.27218491f, 0.10544054f, -0.03627068f, -0.19383283f, -0.02145896f, 0.08674737f, -0.53537619f, 
    0.10716308f, 0.04898508f, 0.08546270f, -0.03846590f, -0.03543721f, -0.02779853f, 0.09164383f, 0.05374644f, 
    0.05094368f, -0.17444919f, 0.05844245f, -0.08673026f, 0.06797069f, 0.07593761f, -0.13863640f, 0.00502449f, 
    0.20247000f, -0.48291227f, 0.23916368f, 0.07362856f, 0.08163827f, 0.01698986f, 0.12792283f, 0.01154474f, 
    -0.01879212f, -0.03007797f, 0.06469481f, -0.01632069f, -0.00332788f, -0.06161079f, -0.06877613f, 0.00563906f, 
    -0.06577095f, -0.08724432f, -0.03607405f, 0.03737442f, -0.02233509f, -0.08636776f, 0.03830978f, 0.00850382f, 
    0.01693182f, -0.07005598f, -0.00499743f, 0.05724484f, -0.01558506f, -0.06349177f, -0.07020514f, -0.04751399f, 
    0.05100706f, -0.06792976f, -0.04422993f, -0.04619138f, -0.07554964f, 0.04175889f, 0.05509355f, -0.05611411f, 
    0.03038409f, -0.03846121f, -0.08036136f, 0.04919460f, 0.01595242f, 0.05119829f, 0.03362780f, -0.05215028f, 
    0.00286535f, -0.01111018f, 0.05784071f, -0.00648810f, 0.00496230f, -0.07147848f, -0.04470462f, -0.07629167f, 
    -0.03713957f, 0.05097190f, 0.00660244f, -0.01630160f, 0.01762408f, -0.03222407f, -0.00230861f, 0.01035781f, 
    0.01287417f, 0.00446037f, 0.05512689f, 0.04670306f, -0.07858744f, -0.01212725f, 0.01464250f, -0.00790159f, 
    -0.07321996f, -0.04325574f, 0.02322887f, 0.01525761f, -0.01706262f, -0.06066326f, 0.03331678f, -0.03954754f, 
    -0.01416990f, -0.02841029f, -0.04921999f, -0.07477526f, -0.06678402f, -0.08675133f, 0.05358078f, -0.00909920f, 
    -0.04442266f, -0.09099410f, 0.03111003f, -0.06313757f, 0.02977620f, -0.01920533f, 0.00463906f, -0.04463457f, 
    0.04204730f, -0.07591994f, 0.00307278f, -0.05062357f, -0.03174838f, -0.06718355f, 0.01616286f, -0.07558423f, 
    0.02874096f, 0.03946303f, -0.03740021f, -0.03899135f, -0.02965711f, -0.08769526f, -0.06021130f, -0.08337253f, 
    -0.03364996f, -0.02952126f, 0.03122881f, 0.01213762f, -0.04909544f, -0.05287072f, 0.04564089f, -0.05355719f, 
    -0.05912992f, 0.04808458f, -0.09106015f, -0.02765681f, -0.07819568f, 0.03939256f, 0.01821168f, -0.06044682f, 
    -0.08000419f, -0.00459760f, -0.05921371f, 0.00467354f, -0.03903988f, 0.04358973f, -0.08619697f, 0.01322006f, 
    0.04784676f, -0.02973333f, 0.03320528f, 0.06460603f, 0.01821783f, 0.05486415f, -0.04017461f, 0.07043286f, 
    -0.08866411f, -0.08992264f, 0.01485344f, -0.03775464f, 0.01019601f, -0.08058386f, 0.06287576f, -0.08571140f, 
    -0.35155666f, -0.20103180f, -0.03573791f, 0.05812875f, -0.08186632f, 0.16934195f, 0.06663689f, 0.05067279f, 
    -0.04218642f, -0.08565006f, -0.15199699f, -0.09148441f, 0.03754672f, 0.01824899f, 0.02048695f, -0.01199919f, 
    -0.00173734f, -0.05344903f, -0.10018555f, -0.18961674f, -0.33034450f, -0.02374655f, -0.27731735f, 0.09882475f, 
    0.02926777f, 0.05219742f, 0.20690101f, -0.02287560f, 0.26569802f, -0.21526851f, 0.26746383f, -0.09453081f, 
    -0.10822610f, 0.06112619f, 0.05179610f, 0.04424210f, 0.15075804f, 0.14103630f, -0.19268958f, 0.11635337f, 
    0.03380883f, -0.17162322f, 0.02456046f, 0.07943967f, -0.14654732f, 0.14974751f, 0.01398310f, 0.01295717f, 
    -0.01834958f, 0.04689533f, -0.00800717f, 0.06093683f, 0.10301495f, -0.07715666f, -0.07322215f, 0.18164583f, 
    -0.16038378f, 0.00308180f, -0.07504319f, 0.02278600f, -0.07703662f, 0.12848084f, -0.23501109f, 0.30649179f, 
    0.16874209f, 0.00178094f, -0.00672247f, 0.07954460f, 0.02297268f, -0.00797309f, -0.02500093f, -0.14270507f, 
    0.13994530f, 0.21595857f, 0.29045585f, -0.01398992f, -0.16585456f, 0.11600366f, -0.00037688f, -0.01325062f, 
    0.16085003f, -0.02363384f, -0.17225850f, -0.47447199f, 0.00253341f, 0.14937977f, 0.12522769f, -0.10447628f, 
    0.00161629f, 0.10881130f, 0.02001328f, 0.44243816f, -0.54041183f, 0.23912945f, 0.14306490f, 0.02824056f, 
    -0.00679937f, 0.02966952f, 0.01091125f, -0.42928711f, 0.01527629f, 0.23157142f, -0.04929852f, -0.01020554f, 
    0.11281652f, -0.07820960f, 0.04507672f, -0.06540689f, -0.00239751f, -0.50083536f, -0.08827204f, -0.18598254f, 
    0.07600005f, 0.02849850f, -0.03491015f, 0.05124472f, 0.18545632f, -0.08884824f, -0.07555169f, -0.21624228f, 
    -0.04995526f, -0.07358260f, 0.01151081f, -0.18125594f, -0.01249966f, 0.42547292f, 0.05515206f, 0.37119299f, 
    -0.00304531f, -0.07672472f, 0.28364965f, -0.02474008f, -0.19802156f, 0.06859966f, -0.00259580f, 0.04995987f, 
    -0.13918939f, 0.03453057f, -0.07512619f, -0.02111846f, 0.15954243f, 0.18882465f, 0.15165181f, -0.14848092f, 
    0.00979458f, -0.26017690f, -0.06303327f, -0.14983419f, 0.00673987f, -0.15122451f, -0.02633989f, 0.00643133f, 
    0.02739005f, 0.06156588f, -0.25016159f, 0.05967576f, 0.04755523f, 0.15761600f, -0.14532058f, 0.08399188f, 
    -0.07910103f, 0.20757504f, -0.06607889f, -0.00714306f, 0.02117345f, -0.02409106f, 0.16449486f, 0.17534530f, 
    -0.20938632f, 0.16191122f, 0.20696805f, -0.37024415f, -0.07127698f, -0.12931076f, 0.00002595f, -0.00165150f, 
    -0.17338297f, 0.07324585f, -0.23381473f, 0.20712481f, 0.08697814f, 0.11929689f, 0.27340239f, -0.08628564f, 
    0.10864460f, -0.14574619f, 0.14168975f, 0.07133763f, 0.10347687f, -0.02603839f, -0.20378722f, 0.00117387f, 
    -0.11695336f, 0.00507417f, 0.21722919f, 0.08231603f, -0.10165523f, 0.06310514f, -0.19822030f, -0.02975764f, 
    -0.06357213f, -0.09895941f, 0.08204872f, 0.18846393f, -0.06454551f, 0.05013572f, -0.09797496f, -0.14534661f, 
    -0.17247504f, -0.11255166f, 0.01534093f, 0.00719305f, 0.10564804f, -0.13339537f, -0.22412243f, -0.08361763f, 
    -0.45916492f, 0.13929027f, 0.02416343f, -0.06579133f, 0.04708680f, 0.22388218f, 0.09008009f, 0.15357307f, 
    -0.00401291f, -0.45219749f, 0.17163913f, 0.23546219f, -0.09129503f, -0.16376631f, -0.00449147f, 0.17686528f, 
    0.18959352f, -0.10318213f, 0.27531746f, -0.14598940f, 0.09235762f, -0.23241428f, -0.00132262f, -0.03240311f, 
    0.08546153f, -0.03429357f, 0.01836914f, 0.13698217f, 0.07653674f, 0.09917510f, 0.10372819f, 0.13417293f, 
    0.00374973f, -0.01483439f, 0.03335268f, -0.07230745f, -0.01098243f, -0.18362813f, 0.19652243f, 0.02607627f, 
    -0.01678713f, 0.07893654f, 0.19643901f, 0.03400699f, -0.07321271f, 0.18294704f, -0.16911218f, 0.39805070f, 
    -0.09270181f, -0.05050372f, 0.03842619f, -0.03246412f, -0.00786610f, -0.04035029f, -0.18569736f, 0.17660455f, 
    -0.20370080f, 0.11563933f, -0.17973775f, 0.37677294f, -0.07950909f, -0.22603585f, -0.18496783f, -0.06433770f, 
    -0.05990663f, 0.00606960f, -0.04216217f, 0.01013687f, 0.03011764f, -0.10100668f, -0.11377933f, -0.12799491f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.03199461f, 0.08197598f, 0.18452823f, 0.06731556f, 0.23113792f, 0.17661355f, -0.06362312f, 0.02060128f, 
    0.12784643f, 0.07426277f, -0.07582413f, 0.14974584f, 0.24296442f, 0.00877748f, 0.03493130f, -0.07389878f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00078243f, 0.21833068f, 0.24124192f, -0.16310403f, 0.30303019f, -0.10188863f, -0.01253096f, 0.21505067f, 
    0.50725174f, -0.22235714f, -0.35701230f, -0.22134551f, -0.40155718f, 0.14758214f, 0.54870933f, 0.07717223f, 
    0.08145721f, -0.01896086f, 0.00355560f, -0.24456364f, -0.10034209f, -0.21899189f, -0.11532801f, 0.02641156f, 
    -0.13028447f, -0.19000426f, 0.03779893f, 0.00644024f, 0.06205066f, 0.13140500f, -0.08359920f, -0.10579388f, 
    0.12296814f, -0.38811851f, 0.28771183f, 0.14803913f, 0.31413084f, 0.10942462f, 0.19694920f, 0.11514435f, 
    -0.30705056f, 0.29805747f, 0.25723818f, 0.03547621f, -0.26697496f, 0.23186301f, 0.14914599f, 0.02099182f, 
    -0.27653533f, -0.10425541f, 0.22237466f, 0.18496314f, 0.09351780f, -0.00336116f, 0.18220985f, 0.06241308f, 
    0.52478147f, -0.03002930f, 0.41807306f, -0.31064853f, -0.28918597f, -0.11464447f, 0.32463470f, 0.04491510f, 
    0.01540170f, -0.32761955f, 0.31854987f, -0.15624753f, 0.47905064f, 0.36366838f, -0.06996438f, -0.06961132f, 
    -0.43633240f, 0.03315646f, 0.02245212f, -0.05340655f, 0.05142200f, 0.26780355f, -0.34279215f, -0.66854823f, 
    0.51259160f, -0.19832760f, 0.42196697f, -0.07501149f, 0.54960889f, -0.16540098f, -0.22443682f, -0.23089455f, 
    0.50409144f, 0.00806858f, -0.44315487f, 0.11347981f, 0.04783628f, -0.08155477f, 0.00703095f, 0.19020908f, 
    -0.34753832f, 0.61236817f, -0.17584620f, -0.02759412f, -0.22345832f, 0.32102627f, 0.02056373f, -0.23078133f, 
    0.11376508f, -0.41933912f, 0.21156240f, 0.27784109f, 0.28057575f, -0.08480651f, 0.00846561f, -0.59836411f, 
    0.58961123f, 0.44653261f, 0.27890193f, -0.02717033f, 0.30171651f, -0.34302294f, -0.18903174f, 0.08294383f, 
    -0.06039079f, 0.05484409f, 0.33728370f, 0.07213474f, 0.14789370f, -0.25158617f, -0.06789727f, -0.37756222f, 
    0.23970768f, 0.09847973f, -0.18873809f, -0.14680982f, -0.17103143f, 0.46400127f, 0.16622531f, -0.15011823f, 
    -0.39118758f, 0.42530808f, 0.17978591f, 0.34874135f, -0.13393141f, 0.15509009f, 0.03852798f, 0.16370921f, 
    -0.18668835f, -0.47701046f, -0.06648280f, -0.14283809f, 0.14436421f, -0.07732820f, -0.03609938f, 0.18709409f, 
    0.39129066f, 0.58965313f, 0.31148615f, 0.20647687f, -0.00917885f, -0.18540257f, -0.29062894f, 0.31166792f, 
    -0.01458517f, 0.44203293f, -0.13879308f, -0.02441686f, -0.29255971f, 0.00151004f, -0.23676708f, -0.11974829f, 
    -0.04277646f, -0.12817605f, 0.36718524f, -0.00640955f, 0.18783006f, 0.07968400f, 0.12079528f, -0.27140442f, 
    -0.17620462f, 0.24486731f, -0.22635688f, -0.01589637f, 0.38844532f, -0.14984274f, -0.24706809f, -0.02937493f, 
    0.36528578f, -0.17844963f, -0.14981143f, -0.15660857f, -0.29806903f, -0.20248252f, 0.20088993f, -0.23059660f, 
    -0.29021874f, -0.19126944f, 0.48628351f, -0.09582672f, 0.37592983f, 0.25184458f, 0.05532096f, -0.16619015f, 
    -0.33443034f, 0.02890439f, -0.26936263f, 0.25706872f, 0.23131949f, 0.07904326f, 0.15123157f, 0.49411902f, 
    -0.30847529f, -0.03621421f, 0.02005927f, 0.19140601f, 0.24969110f, 0.47682050f, -0.15406927f, -0.15536496f, 
    0.22971515f, -0.19281262f, -0.15184297f, -0.48166698f, -0.16923609f, -0.17466527f, 0.47572267f, 0.17979431f, 
    -0.18545039f, 0.21964280f, -0.22056676f, 0.06106478f, -0.13400380f, -0.21110751f, -0.22374645f, 0.13424522f, 
    -0.23227727f, 0.13122408f, -0.22034530f, -0.05048340f, 0.01392850f, 0.13941637f, -0.20006692f, -0.14120126f, 
    -0.38841406f, 0.34447941f, 0.51447982f, 0.23038116f, 0.20237984f, 0.15343495f, -0.23407033f, 0.20019180f, 
    -0.46997187f, -0.18460096f, 0.33272544f, -0.11839515f, 0.16295248f, 0.08988083f, 0.01015560f, 0.10881847f, 
    0.36003408f, -0.20108911f, 0.01053666f, 0.00354168f, 0.05185182f, 0.03651057f, 0.23620936f, -0.14993978f, 
    0.03044197f, -0.17394093f, -0.36486852f, -0.03392475f, -0.06778323f, -0.12230226f, -0.08418907f, 0.12973034f, 
    0.01152582f, -0.12617195f, -0.08151115f, -0.12125352f, -0.03017814f, -0.13853672f, 0.18500203f, 0.17918518f, 
    -0.14694370f, 0.04662630f, -0.10237480f, -0.22122173f, 0.10385076f, -0.14303333f, -0.12990274f, 0.22532544f, 
    -0.16681655f, 0.21973914f, -0.15930843f, -0.14867213f, -0.29671478f, 0.11935606f, -0.13361084f, 0.17883213f, 
    -0.01379553f, -0.14595564f, 0.36671463f, 0.25303122f, 0.33300012f, -0.24390571f, 0.18270814f, -0.09993669f, 
    -0.70292389f, 0.45300817f, 0.23890255f, 0.10188985f, 0.15550460f, -0.03525429f, -0.17142691f, 0.03216144f, 
    -0.16365892f, 0.06149567f, -0.21114756f, 0.08875418f, -0.02769271f, -0.09999127f, 0.40422383f, 0.07342799f, 
    -0.13078739f, -0.30673435f, 0.19510129f, -0.22429895f, 0.20986111f, -0.20311272f, 0.07671451f, 0.15523285f, 
    0.42827615f, 0.52892798f, 0.50038290f, 0.35042626f, -0.72861838f, 0.10774540f, 0.05762690f, -0.11953677f, 
    -0.23392962f, -0.23383278f, 0.42237610f, 0.01707692f, 0.01706541f, 0.22923493f, -0.03775432f, -0.18350109f, 
    -0.34487763f, 0.17715906f, 0.05720849f, 0.35372457f, -0.01268427f, -0.04715758f, -0.24538042f, 0.60225350f, 
    -0.27830601f, -0.60158658f, -0.00528615f, 0.12671869f, 0.01283535f, -0.09852203f, 0.23736462f, 0.05564826f, 
    0.37596539f, 0.73776603f, 0.19069029f, 0.29931083f, 0.23908170f, 0.00343766f, -0.27028164f, 0.53683776f, 
    0.43488517f, -0.03760751f, 0.07268639f, 0.10034101f, 0.22030748f, 0.42171460f, -0.01814479f, -0.19537255f, 
    0.51045102f, -0.39372432f, -0.23604825f, -0.00188984f, 0.32094082f, -0.07419447f, 0.23707364f, -0.60767531f, 
    -0.49274248f, -0.05199981f, 0.06509924f, -0.23099241f, 0.00396035f, 0.14498450f, 0.13056043f, 0.10120124f, 
    0.29075804f, -0.04088167f, -0.08096777f, -0.46536192f, 0.63817537f, 0.04970181f, -0.45767593f, 0.07385318f, 
    -0.07215366f, -0.08720054f, -0.26407778f, 0.01320109f, 0.19635798f, 0.29834703f, -0.20243138f, -0.21236137f, 
    -0.06572346f, 0.37858188f, -0.54990023f, -0.62302965f, 0.52458602f, 0.18870679f, 0.62563360f, 0.05698093f, 
    -0.19001772f, -0.03895092f, -0.23635049f, -0.14463866f, -0.07969086f, -0.20903172f, -0.01419084f, 0.22080964f, 
    -0.15282927f, -0.14835593f, 0.11285819f, 0.03646309f, 0.07188479f, 0.05674899f, 0.14714023f, 0.17028302f, 
    0.49680558f, -0.27428350f, 0.11899664f, 0.06675213f, -0.02840937f, 0.24416026f, 0.07344231f, 0.16469775f, 
    -0.07688577f, 0.62074214f, -0.01094895f, 0.36190087f, -0.36070359f, 0.06421660f, -0.27027124f, 0.37433940f, 
    0.21682669f, 0.04446156f, -0.19475277f, 0.12432751f, 0.04833370f, 0.24111442f, 0.13154227f, -0.17508255f, 
    0.29610813f, -0.22890685f, -0.14280230f, 0.27644992f, 0.34527746f, -0.19770414f, 0.25463837f, -0.82584327f, 
    -0.12268661f, 0.31986687f, -0.25194252f, -0.07301506f, -0.08091253f, 0.16441435f, -0.14364141f, 0.20710564f, 
    -0.11591340f, 0.06175921f, -0.72994441f, 0.67752379f, 0.21407191f, -0.18870938f, 0.30627882f, -0.27716109f, 
    0.26146016f, 0.28628445f, -0.22459300f, -0.24135873f, -0.11378734f, 0.12562339f, -0.01283491f, 0.04724898f, 
    0.11452056f, -0.14158946f, 0.27883828f, -0.04674996f, 0.14187035f, 0.02092574f, -0.16707857f, -0.68855572f, 
    -0.51206619f, -0.28559926f, 0.21125101f, -0.19864197f, -0.11789104f, 0.34332782f, -0.12523217f, -0.18285468f, 
    0.25760978f, 0.45528573f, 0.09550951f, -0.01056421f, -0.12256646f, -0.04023157f, 0.14432915f, 0.08551073f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.19574375f, -0.05907121f, 0.02372806f, 0.24186727f, 0.27629086f, 0.28072292f, 0.06006503f, 0.53470093f, 
    -0.35254636f, 0.14901552f, 0.11594228f, 0.33673757f, 0.28252700f, -0.04162695f, 0.18463367f, 0.24538608f, 
    0.16910227f, -0.24741398f, -0.13460945f, 0.05858242f, -0.35445759f, 0.15882918f, 0.02487168f, 0.29655200f, 
    0.14268635f, -0.12907685f, 0.05557562f, 0.30611506f, 0.18071032f, 0.15761849f, 0.16931228f, -0.11119320f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.46287367f, -0.14909489f, 0.13041009f, -0.06124152f, -0.18627113f, -0.17554641f, 0.43983176f, -0.07663438f, 
    0.41421652f, -0.51899797f, 0.05073675f, 0.41467771f, 0.17929681f, 0.05611584f, 0.06385631f, 0.30394596f, 
    0.06029328f, 0.09924843f, 0.34626749f, 0.95189482f, -0.06766972f, 0.24616694f, -0.29753363f, 0.17672743f, 
    -0.65152752f, -0.34747478f, -0.06850436f, 0.03885343f, 0.16336188f, 0.64100248f, 0.05638948f, 0.14832465f, 
    0.44787416f, 0.15204258f, 0.15663068f, 0.07628504f, -0.00039409f, 0.13754600f, 0.02308327f, -0.25243148f, 
    0.06397894f, -0.39868698f, -0.17312253f, 0.05106113f, 0.32714471f, 0.49802700f, -0.00918474f, 0.12575901f, 
    0.13324837f, 0.01594818f, 0.06193579f, 0.68717223f, -0.34723729f, 0.43480256f, -0.11223787f, 0.05237211f, 
    -0.90051097f, 0.25006470f, 0.15947834f, 0.24292594f, 0.14392553f, 0.62935019f, -0.41527712f, 0.45222786f, 
    0.04726259f, -0.02971675f, -0.15873009f, 0.17068991f, -0.05250678f, -0.18318649f, -0.00106372f, 0.11188799f, 
    -0.02568111f, -0.00223202f, 0.11749159f, -0.05344431f, -0.01350520f, -0.01987273f, 0.14344010f, -0.12108431f, 
    -0.04486418f, 0.17111287f, -0.17405698f, -0.07908751f, -0.07356901f, -0.15339646f, 0.03408958f, -0.04497333f, 
    -0.05519187f, -0.08428796f, -0.08605505f, 0.15832599f, -0.07776805f, -0.03396406f, -0.13731277f, 0.04279500f, 
    0.35212305f, 0.10270683f, 0.17207745f, 0.15635529f, -0.41591543f, 0.48202717f, -0.23963700f, 0.12662315f, 
    -0.50779992f, 0.30208138f, -0.26025778f, 0.01515494f, -0.00294983f, 0.10103992f, -0.01823226f, -0.25236693f, 
    0.25800171f, -0.10070092f, -0.19555314f, -0.49081996f, 0.55981910f, -0.40477821f, 0.37383172f, 0.14034837f, 
    -0.00611975f, 0.50849181f, 0.14842971f, 0.01157438f, 0.19682623f, 0.03949745f, -0.01266955f, -0.09573604f, 
    -0.22744794f, -0.14710003f, -0.06184845f, -0.47071663f, 0.10624451f, 0.04542247f, -0.08853205f, -0.26141471f, 
    0.39573979f, 0.08972026f, -0.33892065f, -0.11765229f, 0.22042805f, 0.12089487f, 0.04553577f, -0.36741763f, 
    0.30131480f, -0.03572755f, 0.04316091f, -0.19884963f, -0.49988809f, 0.06352030f, 0.14048222f, 0.29339746f, 
    -0.06714750f, 0.86524040f, -0.11599237f, 0.15957664f, 0.28591740f, 0.62350076f, -0.18866520f, 0.19299312f, 
    -0.10226844f, 0.02293189f, 0.19041622f, 0.45414591f, 0.67887855f, 0.02577793f, -0.23853731f, -0.43122345f, 
    0.32309550f, 0.56187141f, -0.55071038f, 0.28865346f, 0.04124783f, 0.81809336f, 0.06864759f, 0.06994218f, 
    0.00196929f, -0.15936093f, -0.10821000f, -0.29794681f, -0.17188434f, 0.24569973f, 0.45602223f, 0.05125576f, 
    0.19644216f, 0.34876648f, 0.11638599f, 0.18370064f, -0.10779881f, -0.63786227f, -0.04796948f, 0.95892566f, 
    -0.01245774f, -0.05433274f, 0.39203888f, -0.34323925f, 0.66858691f, 0.01996368f, -0.39162695f, 0.28165641f, 
    -0.30098948f, -0.06828220f, -0.07139209f, -0.32918754f, 0.03809563f, -0.39965490f, -0.16967550f, 0.17778522f, 
    0.51898760f, 0.03831047f, -0.41907513f, 0.22208764f, -0.42583713f, -0.17952618f, -0.35662407f, -0.06580932f, 
    -0.26304361f, 0.18319583f, 0.03833420f, -0.13610874f, 0.09554864f, 0.38294381f, 0.01599763f, -1.01614320f, 
    -0.16275796f, -0.08141033f, 0.18003428f, -0.08252145f, 0.20512508f, -0.25303748f, 0.09858987f, 0.18507676f, 
    0.22541912f, -0.01008491f, 0.14971048f, -0.11575065f, 0.12514974f, -0.27051073f, -0.02919115f, 0.59049290f, 
    -0.12241428f, -0.05695964f, 0.12891200f, 0.48685238f, -0.12777497f, 0.60428929f, -0.05308563f, -0.11421277f, 
    0.30077720f, -0.14338577f, 0.02364239f, 0.02350678f, -0.24351585f, -0.53843486f, -0.16502844f, -0.06688390f, 
    -0.08315871f, 0.15070510f, 0.01189296f, 0.19129995f, 0.16648933f, -0.30961481f, 0.27712202f, -0.15355776f, 
    0.53297287f, 0.35519856f, 0.08018258f, 0.27511045f, -0.05675456f, 0.16635650f, 0.02707390f, -0.13649754f, 
    0.11259626f, -0.05933971f, 0.63797963f, 0.38529706f, 0.01087825f, 0.27593929f, 0.34441340f, 0.02226138f, 
    -0.14720850f, -0.05465788f, 0.11205322f, 0.15297262f, 0.02853790f, 0.30117777f, -0.19012737f, 0.50226086f, 
    0.11217362f, 0.00148928f, -0.16137971f, -0.14580213f, -0.07769495f, 0.34599933f, -0.01880463f, 0.28292295f, 
    -0.28715637f, 0.57681841f, -0.12269942f, -0.05704539f, 0.29326147f, -0.50922441f, 0.05710111f, -0.03503660f, 
    -0.22193563f, -0.05811597f, -0.01242474f, 0.21917683f, 0.47508278f, 0.25011155f, 0.55186361f, -0.05858636f, 
    0.21587023f, -0.37034470f, -0.03725328f, 0.29921761f, -0.12683941f, 0.33181217f, -0.13919652f, -0.04355382f, 
    0.15630744f, -0.05834009f, -0.01870040f, 0.05041490f, 0.06627671f, 0.00044714f, -0.01381103f, 0.01586881f, 
    -0.01448423f, -0.02136478f, -0.11017881f, 0.18950182f, -0.06309092f, -0.25514838f, 0.10989936f, 0.09239993f, 
    -0.13418733f, 0.13626687f, 0.09758935f, 0.10915816f, -0.04636849f, -0.10009420f, -0.13144889f, -0.15164506f, 
    -0.16729634f, -0.17338526f, -0.06015101f, 0.06939687f, -0.14883368f, -0.07835651f, -0.10085747f, -0.16063799f, 
    0.12574637f, -0.01625120f, -0.06194433f, 0.25728571f, -0.33643043f, -0.05446176f, 0.44251221f, 0.08428711f, 
    0.04116226f, -0.12928110f, 0.62773067f, 0.85038245f, -0.01263903f, 0.44060472f, 0.06899072f, 0.19186337f, 
    -0.12396847f, 0.00823650f, 0.57053536f, 0.03374671f, 0.11318985f, -0.49182400f, -0.16708355f, 0.19669834f, 
    0.38239184f, 0.42923236f, -0.12993400f, -0.22830412f, 0.41937408f, -0.02186441f, 0.49225068f, -0.10215350f, 
    -0.12779737f, -0.00349277f, 0.17427412f, 0.11412906f, 0.08850927f, -0.26933932f, 0.39853448f, 0.03362179f, 
    0.39547130f, -0.17230925f, 0.33126134f, 0.23890561f, -0.13970754f, 0.78831869f, 0.06935612f, -0.06211627f, 
    0.04228482f, 0.00580586f, 0.33429712f, -0.16473214f, 0.02553548f, -0.38161504f, -0.20001355f, 0.30277181f, 
    -0.19661079f, 0.16753048f, 0.02231381f, 0.10246743f, 0.16127533f, -0.16672730f, 0.57715732f, 0.27319157f, 
    -0.25617278f, 0.09604039f, 0.36330268f, -0.07936486f, 1.13042152f, 0.09420019f, -0.01237452f, -0.00637204f, 
    -0.27556565f, 0.04055405f, -0.36070910f, -0.46155092f, 0.34286290f, 0.09141271f, -0.02397644f, 0.44847447f, 
    -0.16413383f, -0.10174798f, -0.26748613f, -0.22651359f, -0.67162317f, 0.58897293f, 0.23343942f, 0.22575347f, 
    0.02105572f, 0.00829100f, -0.15331283f, 0.12289689f, -0.05937580f, -0.53749686f, 0.03378552f, 0.03440596f, 
    0.16737099f, 0.07471897f, -0.03114977f, 0.39025396f, -0.28437784f, 0.17265153f, -0.03281928f, 0.27505869f, 
    -0.20746304f, 0.26890483f, 0.32229060f, -0.20575354f, -0.17951657f, 0.14348391f, -0.14423892f, -0.00234272f, 
    0.01269592f, 0.17050055f, -0.05666413f, -0.67385936f, 0.53489184f, -0.57606989f, 0.07662366f, 0.28540587f, 
    0.79512173f, 0.19166486f, 0.13278556f, 0.07464477f, 0.23461355f, -0.68447053f, 0.23218952f, -0.13967977f, 
    0.00952624f, -0.06527489f, -0.16911629f, -0.08933697f, -0.00334103f, -0.15496419f, -0.15226036f, -0.17812763f, 
    -0.08749395f, -0.17842732f, 0.00084652f, -0.09014269f, 0.08594777f, 0.09928272f, 0.09025963f, 0.08898367f, 
    -0.16647644f, 0.02382534f, 0.04004200f, -0.16148350f, 0.05414949f, -0.03099905f, -0.01108774f, 0.05139075f, 
    0.13287538f, 0.02633603f, 0.09830413f, -0.09919553f, -0.18848319f, -0.09698708f, -0.07835235f, -0.04240277f, 
    0.45096573f, -0.08544605f, 0.18771827f, 0.46068871f, -0.45545971f, 0.19280298f, -0.05903425f, 0.14895259f, 
    -0.38059619f, 0.24284880f, -0.19374757f, 0.49396360f, 0.04259725f, 0.27398023f, 0.02405652f, 0.00626494f, 
    -0.20170905f, 0.02763304f, 0.03529914f, -0.08314912f, 0.64978582f, 0.02296346f, 0.07636745f, 0.02826979f, 
    0.10040157f, 0.36278209f, -0.06917581f, -0.06772856f, -0.15689383f, -0.14765832f, -0.20897387f, 0.03679347f, 
    0.67213398f, 0.02154677f, 0.12945540f, 0.28020298f, 0.29013643f, 0.19979657f, 0.08548687f, 0.29748380f, 
    -0.17925613f, -0.29906681f, -0.17366578f, -0.77572936f, 0.00475159f, 0.32033321f, -0.18468818f, 0.05997294f, 
    0.03439077f, 0.06462839f, -0.34538001f, -0.26296988f, 0.20535302f, -0.14946431f, -0.34449461f, 0.39223817f, 
    -0.46104908f, 0.33736482f, 0.08162104f, 0.12481479f, 0.20279771f, -0.44762945f, 0.26380086f, -0.38764653f, 
    -0.42914975f, -0.11137207f, 0.23534206f, -0.42749116f, 0.43927813f, -0.01395726f, -0.02256853f, 0.04792918f, 
    0.47444791f, 0.11349674f, -0.22902896f, -0.32512137f, 0.22747377f, -0.19936125f, -0.04286135f, 0.28449520f, 
    -0.24490984f, 0.12476221f, -0.12266459f, -0.00329136f, -0.37956783f, 0.50256109f, 0.10071298f, 0.00096992f, 
    -0.13154495f, -0.14423002f, -0.13563833f, 0.33088496f, -0.10962081f, 0.35743111f, -0.12164482f, 0.08537563f, 
    0.01538933f, 0.01634161f, -0.10541778f, -0.01594000f, 0.01796016f, -0.10650711f, 0.03608140f, 0.11426854f, 
    -0.03835640f, 0.08712582f, -0.08326143f, -0.05808630f, -0.11689065f, 0.15477119f, 0.00371175f, -0.16203040f, 
    0.15212618f, 0.08763238f, -0.06720683f, -0.13513100f, -0.17089072f, -0.06364227f, 0.07677329f, -0.09642918f, 
    -0.11550646f, 0.03772163f, -0.04012801f, -0.02245012f, -0.07106586f, -0.01700281f, 0.12464257f, 0.14895368f, 
    0.12811731f, 0.03025429f, -0.06507587f, -0.01843602f, -0.02257366f, -0.00820511f, 0.10218069f, -0.14392225f, 
    0.01084816f, 0.10907756f, -0.04157051f, 0.10901124f, -0.17493804f, -0.15076877f, 0.02637328f, -0.11624071f, 
    -0.05151264f, 0.00342839f, -0.08518898f, -0.05817926f, -0.00310447f, -0.01943503f, -0.16492046f, -0.10644616f, 
    -0.05519515f, -0.05613745f, -0.11288068f, 0.00274346f, -0.03290198f, 0.04105392f, -0.08186220f, 0.02393288f, 
    0.09613813f, -0.08344948f, 0.02604484f, -0.10165020f, -0.08448181f, -0.11716305f, 0.06847771f, -0.10968015f, 
    -0.12859732f, -0.07944147f, 0.03039013f, 0.13515727f, -0.12318975f, -0.10531941f, -0.03546811f, 0.00912971f, 
    -0.09226025f, 0.16586058f, -0.01431616f, -0.01095199f, 0.07081237f, -0.00249049f, -0.07934714f, -0.14435713f, 
    0.12301572f, 0.04644504f, 0.10249509f, -0.20975523f, -0.17492338f, 0.23453517f, 0.10450210f, -0.03062683f, 
    0.15167972f, 0.00577827f, -0.02435044f, -0.13159189f, 0.67907780f, 0.38221067f, 0.55261862f, 0.35287136f, 
    -0.43048692f, -0.04504721f, -0.12785527f, -0.79107398f, 0.08137608f, -0.40556732f, -0.17616236f, 0.18248166f, 
    0.20195439f, -0.13256297f, -0.17132840f, -0.29134569f, -0.30319840f, -0.09028891f, -0.11335523f, 0.21043310f, 
    -0.10043038f, -0.75984085f, -0.17590301f, 0.07873536f, 0.36075690f, -0.18995237f, 0.17906846f, -0.26544675f, 
    0.44589195f, 0.03884967f, 0.27414685f, 0.41560301f, 0.17163351f, -0.08950388f, -0.06077722f, -0.00531619f, 
    0.27665937f, -0.10290013f, 0.29950792f, 0.24723688f, 0.15391029f, 0.30737200f, -0.09493779f, 0.26074293f, 
    0.07543850f, -0.21770477f, 0.16947120f, 0.42547560f, 0.48697805f, 0.31276783f, -0.10231098f, -0.36121431f, 
    -0.11077657f, -0.71356475f, -0.00369313f, 0.11469251f, -0.48408419f, -0.44562072f, -0.16228154f, 0.35603827f, 
    -0.48463446f, 0.09228343f, 0.48736772f, -0.34378293f, -0.09119827f, -0.04349095f, -0.27553782f, 0.07119780f, 
    0.78615868f, 0.49230060f, -0.00135555f, 0.28360358f, -0.21527775f, -0.46894071f, -0.04303709f, -0.30110008f, 
    0.05948243f, -0.15992616f, -0.00131486f, 0.06688767f, 0.68222266f, 0.27302188f, 0.06656345f, -0.15001373f, 
    -0.32371756f, -0.39830673f, 0.01726959f, 0.68184775f, -0.02514754f, 0.18953396f, 0.30219486f, 0.07678697f, 
    0.38636217f, 0.01118127f, 0.34060481f, -0.27158067f, 0.00634847f, 0.60275620f, -0.29091439f, 0.38697970f, 
    -0.11135249f, -0.22786762f, -0.26077312f, -0.75228029f, 0.30863300f, -0.15477000f, -0.16787443f, 0.03099157f, 
    0.06520963f, 0.04873779f, -0.40574324f, -0.26040936f, -0.14015661f, 0.04494011f, -0.30785564f, 0.19662490f, 
    -0.61087513f, 0.25790247f, -0.15882204f, 0.50637519f, 0.02453595f, 0.09891044f, -0.17574406f, -0.73715448f, 
    -0.14735839f, 0.04818363f, 0.07120921f, -0.02548148f, 0.12811464f, -0.15206918f, 0.12957056f, -0.02934314f, 
    -0.09173064f, -0.03340530f, -0.04110534f, 0.05637879f, -0.10723757f, 0.04611763f, 0.01093725f, -0.12501676f, 
    -0.06881402f, 0.13604718f, -0.08587339f, -0.12754025f, 0.11532363f, 0.01763462f, -0.17986113f, -0.17187162f, 
    -0.15356214f, -0.11853976f, -0.07859367f, -0.03877841f, 0.04000429f, 0.05659167f, 0.13630077f, 0.00127463f, 
    -0.20233607f, -0.13080816f, 0.00497092f, 0.03272670f, -0.14066580f, -0.17738914f, 0.16994296f, -0.12942167f, 
    -0.07727503f, -0.11956705f, -0.12536989f, 0.14462613f, -0.08439890f, 0.17901397f, -0.01243861f, 0.07146168f, 
    -0.04839084f, -0.09148500f, 0.18539242f, 0.16587095f, 0.14441413f, 0.16373941f, -0.12570798f, -0.18097837f, 
    -0.05768706f, -0.14439982f, 0.02255036f, -0.01024539f, 0.06933313f, -0.12855050f, -0.10502424f, -0.00517352f, 
    0.40564314f, -0.11411971f, 0.38632378f, 0.46205467f, 0.27336189f, 0.24146938f, -0.29289854f, -0.03789109f, 
    -0.06533395f, 0.43113068f, -0.40944842f, 0.04322400f, 0.19191873f, 0.24638534f, 0.19243148f, 0.10291288f, 
    0.03099372f, 0.12342219f, -0.49081784f, 0.00474793f, 0.54667944f, 0.38951442f, 0.30573696f, -0.18840070f, 
    0.00306698f, -0.04943926f, -0.02726758f, 0.11332672f, -0.22050689f, -0.69316995f, -0.34066707f, 0.33845368f, 
    0.02108273f, 0.16720153f, -0.04916424f, -0.14064024f, -0.01706841f, 0.10380845f, -0.15880741f, 0.00137757f, 
    0.14536779f, 0.01510638f, -0.11567309f, 0.13097195f, -0.03377149f, 0.11480065f, 0.01747920f, -0.06466235f, 
    -0.04524390f, 0.17533091f, -0.14177917f, 0.03367370f, -0.23159525f, -0.07290073f, 0.00171812f, -0.18125796f, 
    0.08843346f, -0.10199364f, -0.15357995f, -0.12951447f, 0.01126101f, -0.09815427f, 0.10739467f, -0.13112298f, 
    -0.50893748f, -0.12758592f, 0.00356154f, -0.32160142f, -0.33861226f, -0.24073295f, 0.28210604f, 0.06406070f, 
    0.40206301f, 0.30426040f, 0.62902230f, 0.34618545f, 0.14522326f, -0.60183227f, 0.03942083f, 0.12036148f, 
    -0.00945752f, -0.03942805f, 0.84628475f, 0.56199163f, -0.05279408f, 0.34436813f, 0.54705161f, -0.32205689f, 
    -0.03678321f, -0.49100140f, 0.16395196f, 0.15215640f, -0.14905992f, 0.72680223f, 0.24105527f, 0.23965544f, 
    -0.17555256f, -0.09261931f, -0.13476335f, -0.15123850f, -0.04490334f, 0.06459883f, 0.37525865f, 0.25409132f, 
    -0.15740822f, 0.08410374f, 0.04298878f, 0.34681776f, 0.23745865f, 0.07686429f, 0.08003639f, 0.12244387f, 
    -0.65058362f, 0.18527308f, -0.02526724f, -0.36935428f, -0.06477743f, -0.16917816f, 0.06314185f, 0.24231960f, 
    1.13804364f, 1.05987430f, 0.10150441f, -0.07365140f, 0.44561747f, -0.21670559f, 0.23206678f, -0.18569669f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.00561609f, 0.13877565f, -0.16518354f, 0.18866935f, 0.03663798f, 0.02969096f, -0.08529536f, 0.03008854f, 
    -0.08305450f, 0.31766912f, 0.09119659f, 0.32106009f, -0.07845186f, 0.26868129f, 0.01055701f, -0.12840813f, 
    0.03471125f, 0.39711526f, 0.09171630f, 0.01639045f, -0.04789321f, -0.09918839f, 0.61891311f, -0.03374027f, 
    -0.01883088f, 0.55154717f, 0.16543505f, -0.14181486f, 0.29043284f, -0.10417900f, -0.16608472f, 0.47545633f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.03726248f, 0.04070460f, -0.16013809f, 0.33172017f, -0.42811126f, 0.26352161f, 0.66794467f, -0.32065839f, 
    0.21068570f, 0.11733171f, -0.08829153f, 0.08387947f, 0.03238805f, -0.36684844f, 0.19373742f, -0.00141113f, 
    0.27685869f, 0.03250778f, -0.14010774f, -0.01420563f, -0.03954262f, -0.15002003f, -0.02083455f, 0.24562463f, 
    -0.63805038f, -0.21394065f, 0.01171309f, 0.05313834f, 0.38345966f, -0.04275598f, -0.61674571f, -0.23656258f, 
    0.24221626f, 0.13938157f, 0.05358066f, 0.19120774f, 0.36884755f, -0.24986069f, -0.80100530f, -0.17223032f, 
    -0.18707709f, -0.52382696f, -0.19235119f, 0.32443345f, 0.17010140f, -0.53697467f, -0.01900853f, 0.09293882f, 
    0.06600718f, 0.11046430f, -0.27942753f, 0.05969299f, 0.15793429f, 0.02607352f, -0.30121660f, 0.30543518f, 
    0.49029836f, -0.05279830f, 0.05775025f, -0.03570966f, -0.43543234f, -0.13293070f, 0.19136168f, 0.17106211f, 
    -0.00136055f, 0.09859743f, 0.14995550f, -0.38369057f, 0.51326138f, 0.75465763f, -0.01717458f, -0.14915463f, 
    0.30092800f, -0.58214998f, -0.01323715f, -0.04713319f, 0.40023553f, 0.31603163f, -0.20948383f, 0.06891335f, 
    -0.57579297f, 0.02736126f, 0.16634549f, 0.04200549f, 0.14211001f, -0.03820670f, 0.06378974f, -0.92930615f, 
    -0.16675743f, -0.37413356f, 0.00297361f, 0.16458404f, -0.17125879f, -0.06831740f, -0.43583393f, 0.07363977f, 
    -0.08523927f, 0.35440663f, -0.07172602f, 0.01595371f, 0.36708495f, 0.00804491f, 0.04894390f, 0.18870082f, 
    0.07964496f, 0.33154121f, 0.06525287f, -1.15034938f, -1.05201900f, 0.29255831f, -0.75218350f, -0.00719914f, 
    -0.07806040f, -0.43639082f, 0.24724360f, -0.11597461f, -0.01831205f, 0.01407281f, 0.05155853f, -0.05640125f, 
    -0.03126931f, 0.18437293f, 0.09559974f, -0.03051649f, 0.04871539f, 0.01267641f, 0.18224995f, -0.37285927f, 
    -0.48254511f, -0.23804487f, -0.12947679f, 0.03253413f, -0.17609292f, 0.21699856f, -0.30147186f, 0.24643986f, 
    -0.24309269f, 0.04223285f, -0.15148255f, -0.15064187f, -0.10885280f, 0.16849285f, 0.03260923f, -0.09307870f, 
    0.06008721f, 0.12706268f, 0.05724957f, 0.05255044f, 0.11430269f, -0.12800038f, -0.07345475f, -0.22880140f, 
    0.09415743f, 0.34110600f, 0.02062466f, -0.01842207f, 0.29330724f, -0.04016323f, -0.53532141f, 0.21421430f, 
    -0.02654440f, -0.30329314f, -0.16208348f, 0.31452191f, 0.18543443f, -0.37772131f, -1.03106511f, -0.47555628f, 
    -0.47472486f, 0.09364188f, 0.14448822f, 0.04928632f, 0.01686576f, -0.46010518f, 0.40843108f, 0.06566709f, 
    -0.03598548f, 0.28473225f, -0.67589611f, 0.07700443f, 0.09557895f, 0.05239391f, 0.21402693f, 0.41673937f, 
    0.30605608f, 0.24500506f, -0.07940485f, -0.05472050f, -0.23139052f, -0.09386062f, -0.61798960f, 0.17562349f, 
    -0.40420878f, -0.24992286f, 0.10248250f, 0.34709629f, 0.24482076f, -0.13136002f, 0.73458940f, -0.46685228f, 
    -0.29731569f, -0.07704230f, -0.22340643f, -0.11684039f, 0.08131395f, 0.08675011f, 0.29788494f, 0.13834493f, 
    -0.12382337f, 0.30362105f, -0.17485575f, 0.07223409f, -0.15281548f, -0.10203234f, 0.28595418f, -1.04016280f, 
    -0.47034141f, 0.48622644f, -0.04872645f, 0.06454700f, -0.16413218f, 0.07956564f, 0.09108869f, -0.06563550f, 
    -0.30929923f, -0.23974308f, -0.03995464f, -0.12502763f, -0.12538597f, 0.16713701f, -0.52161998f, 0.22559637f, 
    0.25497830f, 0.08693392f, -0.03610729f, -0.09156201f, -0.23530018f, -0.18960389f, 0.11052813f, -0.04913903f, 
    0.13034311f, -0.80785519f, 0.25691396f, 0.14005257f, 0.16995589f, -0.13688934f, -1.07720232f, 0.38876262f, 
    0.42297417f, -0.58103615f, -0.11463474f, -0.00484947f, 0.14036669f, 0.08927944f, 0.35602555f, -0.51663119f, 
    0.32567489f, -0.82758570f, 0.03875171f, -0.82639956f, -0.88420671f, -0.59553039f, -0.54151553f, 0.57308644f, 
    0.05406666f, -0.45651594f, -0.02223616f, 0.33383131f, 0.24056715f, -0.17750211f, 0.03570576f, 0.07439383f, 
    -0.60423476f, -0.00135365f, -0.54488474f, -0.14517044f, 0.14512451f, 0.13130821f, 0.29503411f, -0.46853849f, 
    -0.50386888f, -0.62085414f, -0.14569938f, 0.06291863f, -0.73306930f, -0.07698108f, 0.40450704f, 0.18779789f, 
    -0.51162183f, -0.68259162f, -0.08701006f, 0.17876399f, -0.28065687f, 0.12877089f, -0.10135227f, -0.27120769f, 
    -0.31012613f, 0.26711893f, -0.02660427f, 0.06784791f, -0.13532142f, 0.25225735f, 0.30437002f, 0.06215892f, 
    -0.00305851f, 0.02043865f, -0.15369023f, 0.05793475f, -0.15914606f, -0.12132785f, 0.30681646f, -0.37502503f, 
    -0.25019753f, -0.30280501f, -0.13115077f, 0.03950335f, 0.10254537f, 0.09476642f, -0.03497028f, 0.31284010f, 
    0.47760457f, 0.05010042f, 0.11908849f, -0.60417098f, 0.21429969f, -0.36649829f, -0.11192961f, -0.00088069f, 
    0.25199714f, 0.14817423f, -0.08212347f, -0.14569791f, -0.15444694f, -0.10640994f, -0.87882203f, -0.02595508f, 
    -0.63831699f, -0.34368685f, 0.22919342f, -0.10933010f, 0.09670605f, -0.24196211f, 0.06176861f, -0.01783885f, 
    0.16190386f, 0.02281401f, 0.07697823f, -0.31992087f, -0.25991514f, -0.00627064f, 0.47197217f, -0.14056736f, 
    0.33733317f, 0.34774378f, -0.07600837f, -0.25740394f, -0.28334370f, 0.03778071f, -0.35127795f, 0.25112513f, 
    -0.28173527f, -0.19313587f, -0.12567185f, -0.19259074f, -0.12397282f, 0.38212892f, -0.39695257f, -0.02947092f, 
    -0.01670769f, 0.23592676f, 0.08202353f, -0.00670697f, -0.07495309f, -0.11648463f, 0.24338533f, 0.18931501f, 
    -1.08171272f, 0.21926512f, 0.11596535f, 0.10201289f, 0.19536965f, -0.17323074f, -0.38871369f, -0.21947271f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.12414218f, 0.07926845f, -0.24822932f, -0.00304325f, 0.45492017f, -0.23613909f, -0.06936646f, -0.74920297f, 
    -0.06029429f, 0.25416502f, 0.24316789f, -0.12934898f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
