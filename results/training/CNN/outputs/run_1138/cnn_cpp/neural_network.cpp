#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.18336761f, -0.64017391f, -0.05231021f, -0.29883876f, -0.76648700f, 0.47846124f, -0.08072945f, -0.13490593f, 
    0.41803822f, 0.47811159f, 0.21743712f, 0.19199808f, -0.07607604f, -0.10102035f, -0.70735127f, -0.38383323f, 
    -0.25629473f, -0.23117492f, -0.15458877f, -0.30376461f, -0.58917135f, -0.30475298f, -0.33161253f, -0.22463225f, 
    -0.25594282f, -1.18957877f, 0.61958992f, 0.79507595f, 0.33532432f, 0.30728924f, -0.65850264f, -0.90134531f, 
    -0.36532190f, 0.12835969f, 0.18036348f, 0.01103510f, -0.14355151f, -0.23414724f, 0.69480479f, 0.21590593f, 
    -0.27262929f, -0.25341028f, 0.36344859f, 0.10683621f, 0.22226356f, -0.06386114f, 0.02496677f, -0.04154975f, 
    -0.14345442f, -0.39391014f, -0.95239025f, -0.07146381f, 0.15645781f, -1.14352727f, -0.29590717f, -0.37148514f, 
    0.19299300f, 0.61392295f, 0.82982618f, 0.61490345f, -0.55668527f, -0.58136129f, -0.35859686f, -0.44634035f, 
    0.32581198f, 0.28501666f, 0.33272645f, -0.05108146f, 0.19050284f, 0.09824816f, -0.39159083f, -0.31655997f, 
    0.11647218f, -0.43770510f, -0.55616093f, 0.76308203f, 0.53891015f, 0.25509599f, -0.38229400f, -0.08935846f, 
    -0.01957404f, -0.14372616f, 0.19491872f, -0.21199161f, -0.04086579f, -0.06414731f, -0.22313380f, -0.08217768f, 
    -0.24124174f, -0.03253617f, 0.21752818f, 0.40780637f, -0.02271231f, -0.10802374f, -0.25138277f, -0.20388860f, 
    0.00554179f, -0.16306393f, -0.31992173f, -0.51204467f, -0.24615352f, 0.62663418f, -0.35521692f, -0.26738876f, 
    -0.74631196f, -0.59536242f, 0.94999737f, -0.25138882f, 0.16708528f, -0.21420375f, 0.30377522f, -0.35552117f, 
    -0.19508092f, -0.42116153f, -0.15755288f, -0.01541029f, -0.55052924f, 0.35432047f, 0.46172616f, 0.14726876f, 
    -0.21670122f, -0.07765332f, 0.21895424f, -0.11486153f, 0.40035835f, -0.28647828f, -0.56217861f, -0.68400109f, 
    -0.50621450f, -0.32202032f, 0.32064742f, -0.22362819f, -0.26409966f, -0.46254462f, -0.11314297f, -0.07781475f, 
    0.10274479f, 0.14908893f, -0.02798440f, 0.10832116f, 0.06471718f, 0.12813261f, -0.03715504f, -0.37934902f, 
    0.15713127f, -0.41795880f, -0.22211413f, -0.12973154f, -0.48498005f, -0.42314082f, 0.05874842f, 0.44979906f, 
    0.13687202f, -0.16095914f, 0.13273758f, 0.39150065f, 0.34770414f, -0.00798832f, -0.23989424f, 0.09255058f, 
    0.00111571f, -0.36581945f, -0.18635216f, -0.09831912f, 0.15190567f, 0.09571664f, -0.02020099f, -0.07819706f, 
    0.01325603f, -0.26277441f, -0.01385478f, -0.26681173f, -0.44338134f, -0.32948217f, -0.65969276f, -1.35009956f, 
    -0.02944753f, 0.71540439f, -0.11433799f, -0.29780480f, -0.32617405f, -0.59677958f, 0.42696029f, 1.25469029f, 
    0.31605512f, 0.02479843f, -0.40785685f, -0.25945503f, -0.14688821f, 0.16840474f, -0.12304237f, -0.06902722f, 
    -0.10694299f, -0.20817365f, 0.06461338f, -0.17280483f, 0.23052405f, 0.48397318f, -0.11945517f, 0.19550730f, 
    0.18044995f, 0.25167635f, 0.01358811f, -0.27306214f, -0.55849993f, -0.86285555f, -1.14975524f, -0.75867915f, 
    -0.87268883f, -0.78446537f, 0.02823756f, 0.50694066f, 0.19188282f, 0.69465613f, 0.04360881f, -0.05000445f, 
    -0.15819873f, -0.24820386f, 0.15282759f, -0.23903012f, -0.12479749f, 0.36958960f, -0.01658013f, -0.00998806f, 
    -0.27270555f, -0.72861350f, -0.49378458f, 0.28288448f, 0.21464972f, 0.49175215f, -0.66104531f, -0.34336308f, 
    0.62399310f, -0.11898417f, -0.11961306f, 0.27292204f, 0.10922144f, 0.34787789f, -0.18109778f, -0.17127252f, 
    -0.10538987f, -0.10947915f, -0.06290483f, -0.22595102f, -0.44084415f, 0.36275265f, 0.24791422f, 0.34244555f, 
    -0.06425996f, 0.44634745f, -0.23324886f, -0.20763992f, -0.38102543f, 0.37431365f, 0.38947731f, -0.04176056f, 
    -0.05220767f, -0.45447716f, 0.43167093f, -0.09871826f, 0.07483891f, -0.37933829f, -0.28576785f, -0.26510221f, 
    0.36768848f, -0.30677921f, 0.33879700f, 0.37507460f, -0.44161928f, -0.00936018f, -0.19432053f, 0.20554961f, 
    -0.20350951f, -0.15407835f, 0.18471693f, 0.57267034f, 0.71622169f, -0.52466601f, 0.57975906f, -0.14396916f, 
    -0.79428673f, -0.77231759f, -0.19844390f, 0.26287338f, 0.53569067f, -0.19580565f, -0.36280107f, -0.23612583f, 
    -0.00814565f, -0.47349158f, 0.08190026f, 0.18844536f, 0.22149940f, 0.14699066f, -0.30099422f, -0.23346934f, 
    0.04318178f, 0.05242322f, -0.07800356f, 0.08529007f, -0.51105458f, -0.13985661f, -0.08220786f, 0.02856062f, 
    -0.15082330f, 0.13605808f, 0.13873497f, 0.35895249f, 0.25895372f, 0.29977044f, -0.34254944f, -0.10348041f, 
    0.00531810f, 0.28444579f, -0.28506544f, 0.14235331f, 0.24769282f, -0.01545019f, -0.16933274f, -0.19531234f, 
    0.51990116f, 0.36364773f, 0.24141259f, -0.01720568f, -0.16705260f, 0.88315159f, 1.24067211f, 0.65821141f, 
    -0.86969668f, -1.00199687f, -0.58971953f, 0.23086764f, 0.01349986f, -0.77475822f, -0.80414563f, 0.02228297f, 
    -0.09501412f, 0.26824561f, -0.13497071f, -0.02925154f, 0.16486286f, 0.13795598f, 0.18595739f, 0.22622412f, 
    -0.02405388f, 0.09820871f, -0.10003453f, -0.19877940f, -0.01734226f, 0.04479826f, -0.43892327f, 0.29937303f, 
    -0.10795402f, 0.21203326f, 0.03097276f, 0.00220019f, 0.47668725f, -0.07748270f, 0.59520823f, -0.90617371f, 
    -0.07978620f, -0.10321754f, 0.17386679f, 0.14831656f, -0.20284645f, 0.05730200f, -0.23109528f, -0.17957649f, 
    -0.17674688f, 0.22734554f, 0.00604627f, 0.03129612f, 0.30878672f, -0.28376561f, 0.08447992f, 0.24591634f, 
    -0.62709451f, -0.00188036f, 0.26553413f, -0.92913604f, -0.92815542f, -0.85632521f, -0.38996819f, -0.42561603f, 
    -1.13828337f, 0.64172256f, -0.25042418f, -0.27177632f, 0.29580674f, -0.13503517f, -0.29875165f, 0.05472453f, 
    -0.16020049f, -0.10501342f, -0.41766086f, -0.45085266f, -0.01765016f, 0.11028217f, 0.40290305f, -0.33178884f, 
    -0.50099117f, -0.60648787f, -0.59315211f, 0.11818541f, 0.39287624f, -0.37456095f, -0.44227225f, -0.10312998f, 
    0.36251968f, 0.06635371f, -0.44267142f, 0.13383782f, 0.10717842f, 0.43658736f, -0.66994458f, 0.23482156f, 
    0.19131340f, -0.13590170f, -0.08562766f, 0.22499336f, 0.15002885f, 0.30195796f, -0.17635445f, -0.31113419f, 
    -0.34434938f, -1.25433123f, -0.46711138f, -0.52841806f, -0.58644325f, -0.90271020f, 0.20345031f, 0.74041724f, 
    -0.12183493f, 0.06543355f, -0.05167077f, 0.27642253f, -0.10557554f, -0.08375325f, 0.11175751f, -0.09148797f, 
    -0.41472682f, 0.12269609f, -0.48857987f, -0.61736417f, -0.44533697f, -0.00200850f, -0.08057061f, 0.28511977f, 
    0.20131932f, -0.18094967f, -0.99675399f, -0.61174333f, -0.82965940f, -1.24759018f, -0.58287746f, 0.41946924f, 
    -0.22357485f, -0.36480069f, 0.47018543f, 0.13119797f, -0.49349573f, -0.58924037f, -0.19867457f, -0.08039268f, 
    -0.14542522f, 0.42335761f, -0.06793100f, -0.06888709f, 0.09430557f, 0.04473820f, -0.14326169f, 0.11146670f, 
    -0.08677220f, -0.16909511f, -0.36929515f, -0.41730568f, -0.51408839f, 0.10928342f, 0.29797494f, -0.11164614f, 
    0.54067588f, -0.05718024f, 0.00408735f, -0.28885615f, 0.02395244f, -0.06551892f, 0.35776585f, 0.13424993f, 
    -0.02072414f, -0.15368932f, -0.35721305f, -0.00279957f, 0.26283038f, 0.38847286f, 0.07051273f, 0.55463034f, 
    -0.08020238f, 0.27369878f, -0.10586617f, -0.46349272f, -0.83804488f, -0.82819265f, -0.04241105f, 0.46893328f, 
    0.02764125f, -0.68528908f, -0.60850286f, 0.00723313f, -0.53912514f, -0.76301557f, -0.38172820f, -0.32222813f, 
    -0.41411480f, 0.18406749f, -0.82003874f, -0.27853659f, -0.23112449f, 0.05476784f, -0.29398289f, -0.10539538f, 
    -0.08222982f, -0.01550997f, -0.34434497f, -0.12398927f, 0.29043737f, -0.03035440f, 0.48139000f, 0.18326755f, 
    0.14289229f, 0.26957458f, -0.26779270f, -0.16134414f, 0.43464196f, 0.05276400f, 0.03355645f, 0.08586708f, 
    0.38234195f, 0.12558417f, -0.27726135f, -0.34879708f, 0.07763675f, -0.22316933f, -0.27576005f, 0.12083463f, 
    -0.08148557f, -0.07138674f, -0.36696896f, -0.25054821f, 0.35159567f, 0.09835324f, -1.28874493f, -0.80359942f, 
    -0.58404797f, -0.12227561f, 0.11570200f, 0.93212420f, 0.27166638f, 0.28124914f, 0.12978752f, 0.83158219f, 
    0.16840184f, 0.07291986f, -0.08567360f, -0.01780332f, 0.07126420f, -0.00820832f, -0.05101126f, -0.30022466f, 
    0.08731045f, 0.05865236f, 0.01599519f, -0.08781298f, -0.03791913f, 0.03693625f, -0.05747930f, 0.69526005f, 
    -0.94810718f, -0.87292862f, -0.56259811f, -0.22157019f, -0.57103115f, -0.36530113f, -0.06778372f, -0.52047807f, 
    -0.22769333f, 0.04649712f, 0.17639157f, 0.07939770f, -0.32845801f, -0.20725395f, -0.08059473f, 0.30636120f, 
    0.18140578f, -0.17425765f, 0.15795778f, 0.27342352f, -0.18640941f, 0.29174790f, 0.34717286f, 0.33809271f, 
    0.81501305f, -0.04444487f, -0.54011393f, 0.11270618f, 1.04912043f, -0.41548115f, 0.09134616f, -0.61561137f, 
    -0.71415168f, -0.66598594f, -0.09343740f, 0.13555977f, 0.40810442f, 0.30918139f, -0.11340484f, -0.06040682f, 
    0.15487838f, 0.16507421f, 0.16276360f, -0.13525857f, -0.24172388f, -0.18989576f, 0.20949912f, 0.09920845f, 
    -0.01141772f, -0.03938590f, 0.10176323f, 0.00947810f, 0.00793536f, 0.41406685f, 0.22698322f, -0.01157689f, 
    0.23615167f, 0.26274076f, 0.15010267f, 0.34266585f, 0.05071842f, -0.35160324f, -0.35180214f, 0.43705359f, 
    0.10083139f, -0.17141485f, -0.09588744f, -0.18624805f, -0.16850506f, 0.05351887f, -0.22410683f, -0.09832187f, 
    0.14202020f, 0.21987788f, 0.13482311f, -0.25481263f, 0.06983517f, 0.00742022f, 0.26802024f, 0.14431031f, 
    -0.38587099f, -0.50011730f, 0.00932428f, 0.48820010f, 0.23443271f, -0.11600363f, -0.08601318f, -0.13455452f, 
    0.07024217f, -0.38146964f, -0.06689417f, 0.10090436f, 0.58394748f, -0.40322113f, 0.03647780f, -0.20735563f, 
    0.15301503f, 0.04715205f, 0.19697176f, 0.04010836f, -0.46468621f, 0.23773891f, 0.27541828f, -0.88770181f, 
    0.33343905f, 0.11546504f, 0.49063623f, -0.30976197f, -0.03307562f, -0.29803970f, -0.13402422f, 0.16086793f, 
    0.41000414f, -0.10676564f, 0.25581157f, 0.17571205f, -0.52187186f, -0.23858719f, 0.34697545f, -0.00600016f, 
    -0.28151062f, 0.36772481f, 0.16258681f, -0.35406658f, -1.10608709f, 0.74264818f, 0.23607451f, 0.09576403f, 
    0.11985402f, 0.13687764f, -0.01407462f, -0.09806092f, -0.15305048f, -0.27959883f, -0.36979827f, 0.39560458f, 
    0.41840953f, -0.72709656f, 0.08131469f, 0.28176868f, 0.16791199f, -0.14537370f, 0.32172555f, -0.03835478f, 
    0.00780976f, 0.22208263f, -0.32852995f, -0.23931882f, 0.20122893f, -0.29505232f, -1.14891040f, -0.72324723f, 
    -0.04625405f, 0.01013224f, -0.25771898f, 0.09626637f, 0.06524304f, 0.08579203f, -0.02208589f, 0.53708708f, 
    0.46485150f, 0.53512573f, -0.14739364f, 0.46064869f, -0.04241083f, -0.34545422f, -0.05426368f, -0.17647991f, 
    -0.17171976f, -0.33317846f, -0.05482556f, 0.04780589f, 0.17701666f, -0.15240234f, 0.90718722f, 0.56860709f, 
    -0.36386240f, -0.68665570f, -1.00374198f, 0.03304828f, 0.29734895f, 0.58733708f, 0.50807327f, -0.20211662f, 
    -0.20231071f, -0.21399292f, 0.50540894f, -0.33261782f, -0.40350756f, 0.09417278f, -0.01696108f, -0.25848621f, 
    -0.13797207f, -0.02757458f, -0.06042410f, 0.23944040f, 0.22207452f, 0.10949881f, 0.15926699f, 0.17658882f, 
    0.49297965f, -0.03628794f, 0.03255927f, 0.38664490f, 0.06216746f, 0.06723709f, -0.36221680f, 0.01222385f, 
    0.32078344f, -0.12022001f, 0.52799755f, -0.14418966f, -0.35112900f, -0.00950284f, -0.43911999f, -0.44071838f, 
    0.13659132f, -0.18498640f, 0.07576082f, -0.02654799f, 0.28431267f, 0.30577227f, -0.09920956f, -0.46758324f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.07900887f, 0.06160230f, 0.02164858f, 0.27183029f, 0.29456997f, -0.02544794f, 0.04946140f, 0.25877139f, 
    -0.02637812f, 0.34994563f, 0.33456409f, 0.30719477f, -0.28767774f, 0.30903530f, 0.21058397f, 0.01944478f, 
    0.11297649f, 0.22335920f, -0.33573490f, 0.29330269f, 0.03231923f, 0.06995810f, 0.32596451f, -0.39696819f, 
    0.05671414f, 0.33542377f, 0.52991694f, 0.34969816f, 0.11311704f, 0.51470447f, 0.63535374f, 0.15157416f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.18103734f, 0.15276188f, 0.08933438f, -0.25140145f, 0.04152477f, 0.07645702f, -0.00539898f, -0.06603485f, 
    0.08331750f, 0.07742088f, 0.10465445f, 0.14786151f, -0.15654977f, 0.33849612f, 0.26009688f, -0.28165001f, 
    -0.08591888f, -0.07223447f, -0.06020699f, -0.02599719f, 0.08925834f, -0.05062304f, -0.02181634f, 0.05536902f, 
    -0.46626005f, 0.11188459f, 0.16003852f, 0.00682029f, 0.10582893f, 0.19703861f, 0.02582305f, -0.07104553f, 
    -0.02152309f, 0.12414447f, 0.05349948f, 0.15190808f, -0.54604256f, -0.24633652f, -0.10006058f, 0.19787261f, 
    0.10197797f, 0.06470469f, -0.06483608f, -0.04306772f, -0.01994875f, 0.06718403f, -0.04733241f, 0.06460121f, 
    -0.09689471f, -0.17321506f, 0.03930506f, -0.19475596f, 0.06161682f, -0.26311743f, -0.20911984f, 0.04344966f, 
    0.04654160f, -0.01735196f, -0.04174474f, 0.02879385f, 0.29325840f, 0.09649568f, -0.24546795f, -0.05061803f, 
    -0.07408156f, 0.03837047f, -0.00617114f, -0.13807948f, -0.20159571f, -0.10465919f, 0.00569187f, -0.05460760f, 
    -0.30014354f, -0.14831047f, -0.04952681f, 0.11860307f, 0.04625063f, 0.05106280f, -0.02930709f, 0.00415662f, 
    -0.08055543f, -0.12347864f, 0.04703286f, 0.34266990f, -0.31828088f, -0.15342470f, 0.54047316f, -0.63151813f, 
    -0.04538414f, -0.13813233f, 0.07891542f, 0.05375152f, -0.10444136f, -0.26248938f, -0.14886737f, -0.19273075f, 
    0.32243791f, 0.19492197f, -0.15454884f, -0.23962037f, -0.04888831f, -0.04662568f, -0.01588040f, 0.15548240f, 
    0.08539052f, 0.03583247f, 0.02521130f, 0.02647165f, 0.00325133f, 0.42243534f, 0.34105173f, -0.12484805f, 
    -0.00066419f, -0.03077249f, 0.08910986f, -0.21272127f, -0.04974658f, -0.13989557f, -0.17447962f, -0.27530384f, 
    -0.08987494f, -0.12054576f, 0.08080245f, -0.41790333f, -0.24745798f, -0.02206399f, 0.13076812f, -0.01619171f, 
    0.02384376f, 0.02470547f, -0.05043785f, -0.07291529f, -0.93209666f, 0.51116186f, 0.32520059f, -0.54761362f, 
    0.01967015f, -0.07171955f, -0.08454221f, 0.00000183f, -0.01933172f, -0.04376980f, -0.02264564f, 0.06828538f, 
    0.01402836f, 0.00839451f, 0.12094469f, 0.02378688f, -0.03285348f, -0.23619300f, -0.09070811f, 0.07818218f, 
    -0.01769604f, 0.07981595f, -0.01176096f, -0.11982603f, 0.05068995f, -0.21326467f, 0.01517455f, 0.20120381f, 
    -0.06445270f, 0.06203032f, -0.09117109f, -0.23055403f, 0.01093608f, 0.12977897f, -0.06375736f, 0.02018617f, 
    -0.19858515f, -0.11473913f, -0.21800278f, -0.04318713f, -0.03689652f, -0.10329501f, -0.05287100f, 0.05145003f, 
    -0.11500217f, 0.00031933f, -0.02247055f, -0.28354555f, 0.33883104f, 0.19545349f, -0.00343401f, -0.41037831f, 
    0.18002462f, -0.01248479f, -0.05041822f, 0.11353298f, 0.02031624f, -0.02545619f, -0.13854188f, 0.00812484f, 
    0.39435101f, 0.26064166f, 0.09071074f, -0.07316925f, 0.08625358f, 0.12552042f, 0.15749404f, -0.13810313f, 
    -0.05338334f, 0.00772948f, 0.06122199f, 0.03485353f, 0.22029243f, -0.04701690f, -0.08163477f, -0.12523417f, 
    0.10756843f, 0.20456201f, -0.28884789f, 0.05264077f, -0.31486633f, -0.25101781f, -0.13123968f, -0.05998686f, 
    0.34496111f, 0.21443030f, 0.07777306f, -0.18984015f, 0.10705912f, 0.42279801f, 0.26268002f, 0.01587149f, 
    0.05132627f, 0.10143603f, 0.09666739f, 0.10103587f, 0.01509876f, 0.02697459f, 0.14544009f, -0.03117361f, 
    -0.30023175f, -0.14632878f, -0.19386764f, -0.20830330f, -0.04709992f, -0.07852405f, -0.07525294f, 0.00283924f, 
    0.60877049f, 0.21306394f, 0.07246376f, -0.29613584f, 0.02517043f, -0.02413603f, 0.07501182f, 0.18676858f, 
    -0.10501302f, -0.22143944f, -0.16825768f, -0.31096816f, -0.54920942f, -0.25915337f, -0.17244783f, 0.04522863f, 
    0.06600691f, 0.04701348f, 0.01017419f, 0.09903527f, -0.06416631f, -0.06804538f, 0.04981490f, 0.14952917f, 
    0.30719560f, 0.07104316f, -0.06210032f, -0.08092782f, 0.15624455f, 0.13837236f, 0.11508381f, -0.07382216f, 
    -0.06149571f, 0.05915963f, -0.03416440f, 0.01205717f, 0.45415151f, 0.35378513f, -0.26007035f, -0.15843947f, 
    0.30104768f, 0.08526695f, 0.06722596f, -0.02701451f, 0.01325327f, 0.03073499f, 0.01465973f, 0.06079070f, 
    0.10913170f, 0.03854169f, -0.15175354f, 0.06847166f, 0.04860356f, -0.35975525f, -0.11737503f, -0.00096878f, 
    -0.08785854f, 0.04235325f, 0.02182548f, -0.00228817f, -0.28484356f, -0.11776506f, -0.12183040f, 0.03173237f, 
    -0.02218526f, 0.03437948f, -0.00673718f, -0.01187196f, 0.03623281f, -0.00357304f, -0.08651662f, -0.21207111f, 
    -0.17849348f, 0.07439718f, -0.03676328f, -0.16382864f, -0.25514695f, -0.21345001f, -0.02667233f, -0.14799084f, 
    -0.06841247f, -0.13168609f, -0.05949958f, -0.05072860f, -0.16141000f, -0.80993342f, -0.03639168f, -0.10355690f, 
    0.06971955f, -0.04091342f, -0.09288632f, -0.19079006f, -0.03090227f, -0.07206562f, 0.03328720f, -0.08245652f, 
    -0.07008702f, 0.52837062f, -0.26808566f, 0.19299388f, -0.16776146f, -0.05550929f, -0.13538247f, -0.12971404f, 
    0.04468971f, 0.00649745f, 0.02485294f, -0.06458696f, 0.24924576f, 0.23919702f, -0.13080081f, -0.04730827f, 
    0.07914778f, -0.02933187f, -0.01426130f, -0.20859453f, -0.00293815f, -0.05243509f, -0.07025956f, 0.07115017f, 
    -0.35422575f, -0.76744223f, -0.43116143f, 0.10094365f, 0.05814687f, 0.03662164f, -0.07459296f, -0.04624712f, 
    -0.14673918f, -0.33217892f, -0.30989245f, -0.01552209f, -1.11557519f, -0.15237506f, -0.23400488f, 0.02499766f, 
    0.04430211f, -0.02640189f, 0.15986748f, 0.13737237f, 0.07054487f, -0.04832882f, 0.06130489f, -0.08167197f, 
    0.28185046f, 0.07499824f, -0.42606926f, -0.11453719f, -0.02215275f, 0.07985310f, -0.04113175f, -0.08095331f, 
    -0.17062239f, -0.46584812f, -0.34006560f, -0.31653100f, -0.23954037f, 0.01353371f, -0.08053070f, -0.20391214f, 
    0.10807936f, -0.31657761f, 0.10869912f, 0.31161851f, -0.05680900f, -0.00444579f, 0.09769624f, -0.13186559f, 
    -0.51042175f, 0.15661523f, 0.05910451f, -0.01377143f, 0.08149521f, -0.06417716f, -0.53819251f, -0.32870233f, 
    -0.04025086f, 0.04124175f, -0.25526810f, -0.37124926f, 0.19734961f, 0.06005320f, 0.16592053f, 0.08187089f, 
    0.04416372f, -0.00471028f, -0.02687669f, 0.04862922f, 0.06860701f, 0.27808827f, -0.20292911f, 0.11422615f, 
    -0.08887339f, 0.05672717f, -0.24553375f, -0.63554680f, -0.08135879f, 0.24294175f, -0.11955050f, -0.05732961f, 
    -0.03974045f, 0.08220536f, -0.08581176f, -0.08780609f, 0.04473334f, 0.18796836f, 0.25816086f, 0.19024307f, 
    0.13587734f, 0.22895479f, -0.01831012f, -0.03264186f, 0.09714331f, -0.00719131f, -0.08136993f, -0.14055200f, 
    0.12980834f, 0.10814462f, 0.12039652f, 0.12408128f, 0.02479306f, -0.01956658f, -0.11099631f, -0.05911906f, 
    -0.15516655f, -0.31995454f, -0.06803393f, -0.20391870f, -0.93994737f, 0.36276460f, 0.04728637f, -0.43760154f, 
    -0.05409411f, 0.24655563f, -0.05729694f, 0.03810510f, 0.03303391f, 0.23204957f, -0.04993318f, 0.15933941f, 
    -0.03470341f, -0.08165475f, -0.14016482f, 0.06632141f, -0.15690134f, -0.08805478f, -0.29967001f, 0.15285540f, 
    -0.15182765f, 0.05864122f, 0.02313082f, 0.13446321f, -0.47488606f, 0.10349459f, -0.15150486f, -0.00440588f, 
    -0.01372845f, 0.22202969f, 0.15760894f, 0.23444514f, -0.07619249f, 0.12084606f, -0.07757902f, 0.14228301f, 
    -0.24659304f, 0.10436194f, -0.17986220f, 0.04324248f, 0.16941760f, 0.09379227f, -0.04669784f, -0.09491641f, 
    0.15214884f, 0.05721553f, -0.09025523f, 0.04238112f, -0.43825379f, 0.25198406f, 0.26021367f, -0.16069666f, 
    0.11598335f, -0.06647216f, -0.20955259f, -0.17988472f, -0.01708697f, -0.01393104f, 0.03062136f, 0.01498155f, 
    -0.13105878f, 0.03831363f, 0.07343455f, 0.06643047f, -0.08463167f, 0.13866250f, -0.08125123f, 0.02013090f, 
    -0.23644359f, -0.26926106f, -0.06403723f, -0.01695974f, 0.34026480f, -0.16441058f, -0.02638742f, -0.25007096f, 
    -0.25651154f, -0.14755069f, -0.05181472f, -0.04310192f, -0.03226555f, -0.03090693f, -0.02120375f, 0.08169626f, 
    -0.09419705f, -0.11252273f, 0.10866135f, -0.03898766f, 0.00802046f, -0.22987434f, 0.12282918f, 0.03638867f, 
    -0.08733761f, 0.01139362f, 0.06055330f, 0.06860676f, -0.06167091f, 0.10580218f, -0.00560513f, -0.24818894f, 
    -0.07172063f, -0.17605668f, 0.20232199f, 0.21578568f, -0.05628289f, 0.08563868f, -0.00124679f, 0.06111324f, 
    -0.56803846f, -0.03869603f, -0.23252761f, 0.15441157f, -0.03867859f, -0.04121256f, -0.15813315f, -0.04299886f, 
    -0.13533449f, -0.19817375f, -0.00597873f, -0.02333221f, 0.13638458f, -0.05284339f, 0.07900012f, -0.41916341f, 
    0.06886227f, 0.13353746f, 0.17710188f, 0.15962559f, 0.08112428f, 0.07835294f, 0.11913264f, -0.11325116f, 
    0.20551126f, 0.48630092f, 0.21348576f, 0.20906961f, 0.21059941f, 0.10712370f, -0.28359571f, -0.08686365f, 
    -0.07584634f, -0.07253867f, -0.00956691f, -0.28090927f, -0.00556074f, 0.04470029f, -0.09387276f, -0.09481179f, 
    0.11863656f, -0.00987373f, 0.10971069f, 0.16607615f, -0.15692611f, -0.25970814f, 0.03856195f, 0.08564792f, 
    -0.27402598f, -0.08600701f, 0.09434459f, -0.10495538f, 0.15890719f, 0.12992133f, 0.06333967f, -0.14439088f, 
    0.06937024f, 0.10662536f, -0.01478837f, -0.08206874f, 0.05802798f, 0.12204615f, 0.33193892f, 0.16533704f, 
    0.01667870f, -0.03761624f, 0.05001879f, -0.11001853f, 0.06878331f, -0.05848384f, 0.11729454f, 0.20425132f, 
    0.44244638f, 0.07874728f, -0.33821899f, -0.07347554f, -0.09846005f, -0.04478990f, 0.05909440f, -0.03725969f, 
    0.05336909f, 0.02252707f, 0.01244615f, 0.05963504f, 0.32623610f, 0.13458960f, 0.22894602f, 0.19585788f, 
    0.00889040f, 0.05287978f, 0.15581356f, -0.36724716f, -0.06816784f, -0.02919172f, -0.06349304f, 0.00527692f, 
    -0.04218895f, 0.16800500f, -0.41457456f, 0.01147352f, -0.22905761f, -0.16413809f, 0.29706374f, -0.21658804f, 
    -0.10903137f, -0.02663857f, 0.07397003f, 0.16334333f, 0.10268872f, 0.13706623f, 0.17864795f, 0.17512645f, 
    -0.03756520f, 0.09922667f, 0.06336372f, -0.09226483f, 0.13699514f, 0.13903822f, 0.03436056f, 0.12628564f, 
    0.06705788f, 0.22336170f, 0.01655995f, 0.00274528f, -0.06520993f, 0.32683218f, -0.21003649f, 0.15860538f, 
    0.00971962f, -0.12419650f, 0.02323081f, -0.00613642f, 0.24778070f, 0.11499442f, 0.22911197f, -0.26692510f, 
    0.06126507f, 0.02776347f, 0.15923573f, -0.24501652f, 0.39113149f, -0.03342497f, 0.17474486f, -0.31670928f, 
    -0.11682998f, -0.09317062f, -0.01621715f, 0.12357419f, -0.20240155f, 0.03188827f, -0.02779793f, 0.02099214f, 
    0.06399880f, -0.01963176f, 0.02812077f, 0.00451963f, -0.35442376f, -0.23348065f, -0.22038056f, 0.02929319f, 
    0.01841535f, 0.14364153f, 0.11882416f, 0.09905175f, -0.10842290f, 0.12916501f, 0.09750798f, -0.01075365f, 
    0.64608848f, -0.07468199f, 0.15677792f, -0.06329569f, -0.01536264f, -0.10869613f, 0.02817537f, -0.02281605f, 
    -0.02311639f, 0.16476581f, -0.16616705f, -0.00281552f, 0.63678074f, 0.44673103f, 0.16950530f, 0.13169096f, 
    0.02837170f, 0.02496251f, 0.01939011f, 0.07193034f, -0.02034462f, 0.02811500f, -0.12569980f, -0.03404449f, 
    0.10815407f, 0.46838963f, 0.07151355f, 0.33624199f, -0.04107725f, -0.09345751f, 0.00179384f, -0.06098193f, 
    -0.02361227f, -0.04384704f, 0.14490576f, 0.06952450f, 0.03949539f, 0.07279394f, -0.03824056f, 0.04994381f, 
    0.09945758f, 0.01041282f, -0.22794944f, -0.12744015f, 0.04797506f, -0.02672611f, 0.03490158f, -0.09607561f, 
    0.16816239f, 0.07409550f, 0.06049367f, 0.16493380f, -0.09475198f, -0.01107832f, 0.19581684f, -0.05211572f, 
    0.11552674f, 0.15080929f, -0.02116849f, 0.09568416f, -0.01573023f, -0.18942913f, -0.04326754f, -0.09971847f, 
    0.00166293f, 0.01633488f, -0.01519687f, -0.06675085f, 0.14304034f, -0.11224721f, -0.09821393f, 0.20338851f, 
    0.15028135f, 0.31035325f, 0.19932872f, -0.41132879f, 0.13077325f, 0.17480952f, -0.13076782f, -0.12946834f, 
    -0.11046760f, 0.02296231f, -0.00628352f, -0.14013964f, -0.05322543f, -0.11310235f, 0.24947727f, 0.32909030f, 
    0.02337518f, 0.00166280f, 0.09804258f, -0.21674386f, 0.01289264f, 0.15576328f, 0.07723220f, 0.03437364f, 
    0.03462828f, -0.16157031f, -0.08678406f, -0.16502260f, 0.06490608f, -0.07380900f, -0.06487200f, 0.02172950f, 
    0.06517453f, 0.28930628f, 0.18675825f, 0.11265352f, 0.23904598f, 0.22082524f, -0.54703265f, 0.00731624f, 
    0.14747533f, -0.01824574f, -0.15711886f, 0.13428225f, -0.18860635f, -0.01921163f, -0.14611565f, 0.01359381f, 
    -0.97669750f, -0.78746736f, -0.06995820f, -0.57271874f, 0.14874208f, 0.03803476f, -0.26966986f, -0.28379861f, 
    0.10148311f, -0.13203159f, -0.03833130f, -0.02424232f, 0.09444478f, -0.07684620f, -0.64741892f, 0.05105150f, 
    0.13337801f, 0.19669621f, 0.00676191f, -0.07505665f, 0.02042644f, 0.06686010f, -0.03305939f, -0.09007490f, 
    -0.00948515f, -0.06596609f, -0.06512327f, 0.37272295f, 0.08396081f, 0.13906246f, -0.04875645f, 0.03452276f, 
    0.01769769f, 0.05841962f, -0.09918778f, 0.04176596f, -0.50907415f, -0.24074462f, 0.69850981f, 0.15112595f, 
    0.01858256f, 0.06229483f, -0.08051079f, 0.15688062f, 0.04457726f, -0.04652813f, 0.05795198f, -0.00135745f, 
    0.00673635f, -0.14862604f, 0.05344159f, 0.16038463f, 0.02915525f, 0.28786308f, -0.21525571f, -0.05089570f, 
    0.05533144f, -0.19654305f, -0.01004868f, 0.01772854f, -0.07333338f, -0.12656899f, 0.25982130f, -0.31112891f, 
    0.07448082f, -0.13502240f, -0.18584384f, -0.20853601f, 0.11470391f, -0.02805360f, -0.01206356f, 0.00693617f, 
    -0.01856510f, 0.03313664f, -0.45850620f, -0.07256626f, 0.03704207f, -0.02433180f, 0.15114336f, -0.04120726f, 
    -0.05317464f, 0.03164558f, -0.02767217f, -0.02593991f, -1.48031104f, -0.06282700f, -0.31313801f, -0.12848955f, 
    -0.09291701f, -0.01527926f, 0.16960290f, -0.32532859f, 0.04229022f, -0.06668779f, -0.01681044f, 0.01561500f, 
    -0.18039666f, -0.00674048f, -0.35590598f, 0.33847201f, 0.01574462f, 0.28122205f, 0.05672608f, 0.18891843f, 
    0.04719539f, 0.00419130f, 0.04761989f, -0.03362953f, 0.39563784f, 0.36987200f, 0.68363267f, 0.26279110f, 
    0.04475853f, -0.01878796f, 0.01174790f, -0.21122651f, -0.00990882f, -0.29748034f, -0.06956080f, 0.17004874f, 
    -0.78052086f, 0.42422462f, 0.27721509f, 0.76179922f, 0.04986650f, -0.15955688f, 0.09226622f, 0.17857260f, 
    -0.05378894f, 0.06444339f, -0.00960108f, 0.02540783f, 0.06864217f, 0.04371537f, 0.00662255f, -0.03041212f, 
    0.15490341f, -0.12066458f, 0.06406442f, 0.26071951f, 0.10446424f, 0.02591231f, 0.09806070f, -0.07981250f, 
    -0.72285891f, -0.04737540f, -0.55753720f, -0.27597323f, -0.19145192f, 0.04643001f, -0.03410910f, -0.02520757f, 
    -0.10203977f, -0.00082760f, 0.01869570f, -0.04864658f, -0.21301310f, -0.03672822f, -0.13951534f, 0.00189372f, 
    -0.08219713f, 0.03341774f, 0.01467041f, 0.06858628f, 0.02269504f, -0.12634037f, -0.01280943f, -0.01521925f, 
    -0.14571947f, -0.12905928f, 0.45395881f, 0.35804975f, -0.01247055f, -0.06434517f, 0.15422320f, 0.18527888f, 
    -0.08293610f, -0.07694566f, -0.00506156f, 0.16753431f, -0.32264832f, 0.00245264f, -0.09976495f, -0.22619011f, 
    -0.24243179f, -0.04964507f, 0.16445032f, -0.11941967f, -0.01273538f, 0.00389629f, -0.04247893f, -0.06195027f, 
    -0.31715238f, -0.01890970f, -0.02596175f, 0.01807889f, -0.31652239f, -0.20583764f, -0.06948621f, -0.20085931f, 
    -0.00399519f, -0.02628696f, 0.08508876f, -0.11619646f, 0.03315407f, -0.34301642f, -0.07368822f, -0.01235701f, 
    -0.00313986f, -0.04092068f, 0.00412996f, 0.12781093f, -0.06129484f, 0.14441018f, -0.33496729f, 0.15094712f, 
    -0.16990761f, 0.03374324f, 0.01169210f, -0.02763985f, 0.10650714f, 0.28683534f, 0.06406473f, 0.00060824f, 
    0.02901551f, -0.15942729f, 0.12187891f, -0.13239712f, 0.03852785f, 0.01432830f, 0.04686056f, 0.04681800f, 
    -0.01729249f, 0.00230631f, 0.30162385f, -0.30154219f, 0.07033299f, -0.19615081f, 0.20470658f, 0.07521252f, 
    0.05617527f, 0.06890848f, -0.03799093f, -0.01463272f, -0.10760032f, 0.03601639f, -0.26639029f, 0.06658809f, 
    0.01359546f, 0.06079934f, 0.12536393f, -0.00517492f, 0.05269615f, 0.18335523f, 0.22593178f, 0.15849428f, 
    -0.09145845f, -0.04147849f, 0.02972314f, -0.08929586f, -0.00321623f, 0.14904280f, 0.00272051f, 0.01901866f, 
    -0.19769147f, 0.33864334f, 0.09750064f, -0.23970118f, -0.03765085f, 0.01201554f, -0.01920240f, 0.00944728f, 
    0.07265412f, -0.10517615f, -0.29784516f, -0.12041982f, 0.19895160f, -0.22850290f, 0.15890269f, -0.32428807f, 
    0.01255217f, -0.09644091f, 0.05705152f, 0.07939210f, 0.02731000f, -0.01767499f, -0.07871112f, -0.00505106f, 
    -0.12137452f, -0.20297219f, 0.16792847f, 0.20867589f, 0.15371639f, 0.03823141f, -0.11762656f, -0.00968435f, 
    -0.00589435f, -0.08642923f, 0.08330689f, -0.00848935f, 0.36191621f, 0.42279392f, 0.24061355f, -0.50976640f, 
    -0.17486353f, 0.13496193f, -0.01660386f, -0.21113670f, 0.00302361f, -0.02347708f, 0.02024660f, 0.08952624f, 
    1.25258040f, -0.31883076f, 0.04415364f, 0.00231968f, 0.09111949f, 0.06320276f, -0.01910579f, -0.00213006f, 
    -0.09368104f, -0.00412337f, 0.00420338f, 0.13806880f, -0.21849580f, -0.22717674f, 0.38515797f, 0.07854068f, 
    -0.18156084f, 0.10317548f, -0.10228121f, 0.16949622f, 0.07070641f, 0.27329445f, 0.01143374f, 0.03796945f, 
    0.32558113f, -0.17301460f, -0.07361033f, 0.09830230f, 0.00042313f, -0.02222655f, -0.12925437f, 0.00150170f, 
    -0.11817083f, -0.08158492f, 0.25250259f, -0.25803563f, -0.19756323f, -0.11848274f, -0.14511567f, 0.22733796f, 
    0.01850996f, 0.03555990f, 0.13200660f, 0.09466281f, 0.14990091f, 0.08166227f, -0.10101039f, 0.17438070f, 
    0.04835516f, -0.02445310f, 0.17678203f, 0.20430706f, -0.08265477f, 0.20185731f, 0.05345291f, 0.09334414f, 
    0.06889835f, 0.09409452f, 0.15768322f, -0.01826097f, 1.06189096f, -0.19550182f, 0.13622493f, -0.23165396f, 
    -0.01295592f, 0.07186102f, -0.02530849f, 0.01998997f, -0.14116448f, 0.03216375f, -0.01403582f, -0.08028934f, 
    0.01414159f, -0.17089830f, 0.02986396f, 0.08418407f, -0.00416900f, 0.14048913f, -0.03930095f, 0.09829216f, 
    -0.00140709f, -0.06779673f, 0.03952236f, -0.09524994f, 0.21987292f, 0.04341269f, -0.18075101f, -0.33030009f, 
    -0.03497830f, -0.02322563f, -0.12197310f, -0.00162741f, 0.09645230f, 0.10398480f, 0.03095995f, -0.03812897f, 
    -0.03757347f, 0.09111645f, -0.32400620f, -0.36817393f, -0.30367818f, -0.04152912f, -0.45232964f, 0.08331490f, 
    -0.21113697f, 0.20804530f, -0.06810524f, -0.09546845f, -0.08089774f, -0.24359533f, 0.02984022f, -0.04151370f, 
    -0.48981777f, 0.08125321f, -0.23789793f, 0.04688450f, -0.11079252f, -0.03275578f, -0.01407988f, 0.01400060f, 
    0.23128378f, -0.23717074f, 0.23164186f, -0.27769908f, -0.04067339f, 0.22765173f, 0.14625214f, -0.04083469f, 
    -0.15742548f, 0.24934876f, -0.09565854f, 0.25091791f, -0.17180142f, -0.17032127f, 0.52854246f, 0.31282523f, 
    -0.03806226f, -0.15776569f, -0.11836002f, 0.02755507f, 0.17126817f, 0.10933670f, 0.08574354f, -0.04818408f, 
    0.38108689f, -0.33846849f, -0.13679177f, -0.38704160f, -0.07938457f, 0.00769379f, -0.27229732f, 0.08042256f, 
    -0.11001899f, -0.12097735f, 0.05823990f, -0.39879596f, -0.09447726f, -0.31118149f, -0.00473748f, 0.23498182f, 
    -0.03501232f, 0.01934738f, 0.07486128f, 0.11252024f, -0.02899946f, 0.04102143f, -0.05369085f, -0.16429257f, 
    0.07956006f, -0.12412879f, -0.20278083f, -0.06608503f, -0.08046019f, -0.09376049f, -0.01805947f, 0.09139364f, 
    -0.17925568f, -0.08076109f, -0.06772154f, 0.06643789f, 0.27059025f, -0.14552768f, 0.13493697f, 0.25543848f, 
    0.16310795f, 0.05024277f, 0.02545547f, -0.09684129f, -0.05884977f, -0.01130334f, 0.00059507f, 0.10676535f, 
    0.33997950f, -0.23195753f, -0.09189463f, 0.24356978f, -0.10218409f, -0.07683485f, -0.03557795f, -0.02662404f, 
    0.08992210f, 0.07474011f, 0.10150605f, 0.21033181f, -0.46435991f, 0.23107098f, -0.61061662f, -0.17704125f, 
    0.15915568f, 0.03165399f, 0.02273284f, -0.46587178f, -0.29907596f, 0.05970383f, 0.00374233f, -0.02728798f, 
    -0.21659660f, 0.05828191f, -0.08379082f, 0.15601298f, -0.03337414f, 0.00996845f, 0.03563256f, 0.13480975f, 
    -0.13059741f, -0.01800651f, 0.02941479f, -0.07308633f, -0.47971836f, 0.14556691f, 0.10360330f, -0.05772546f, 
    -0.14740762f, -0.13535939f, -0.23478898f, 0.08796839f, 0.08244118f, 0.20048362f, -0.05845809f, -0.03439942f, 
    -0.30854875f, -0.15483840f, -0.21064925f, -0.24472553f, 0.30678961f, 0.11901571f, 0.10425293f, -0.06201957f, 
    -0.29798406f, -0.02181994f, 0.04639255f, 0.02223150f, -0.22668669f, 0.07599241f, -0.03971521f, 0.31923944f, 
    -0.17297466f, 0.10013778f, 0.18249579f, -0.25951481f, -0.03519516f, 0.12229398f, -0.13378455f, -0.03998264f, 
    0.04282643f, -0.25942019f, 0.14687270f, 0.77160299f, -0.02398555f, -0.07091121f, 0.16250800f, -0.06363740f, 
    0.16498831f, 0.12268328f, -0.04463855f, -0.07713023f, -0.33399212f, -0.15626648f, -0.39002407f, -0.52195221f, 
    0.04553020f, -0.38103670f, -0.01436835f, -0.03638177f, -0.26523742f, 0.31972665f, -0.08268441f, 0.01068364f, 
    -0.33843488f, -0.08421442f, 0.00921128f, -0.05426250f, -0.28120169f, -0.20326094f, -0.09121516f, -0.28750351f, 
    0.06081660f, 0.04687317f, -0.03301477f, -0.00549968f, -0.32520175f, 0.28000149f, 0.18900678f, 0.16933903f, 
    -0.13658097f, -0.16930398f, -0.15940446f, -0.07607666f, -0.22567199f, -0.03000432f, -0.17982231f, 0.08625617f, 
    0.14900304f, -0.10278114f, 0.16159269f, -0.48507777f, -0.00241207f, 0.02924883f, -0.13776930f, -0.29849112f, 
    -0.25709960f, 0.00010363f, -0.07121512f, 0.15426590f, -0.17212759f, 0.01798755f, -0.13276306f, 0.09449049f, 
    0.09782057f, -0.01415005f, 0.23819472f, -0.05036790f, -0.09436397f, 0.09733716f, 0.10594997f, -0.04191049f, 
    0.09208934f, 0.01082230f, -0.05116770f, 0.55186647f, -0.01070970f, 0.04488670f, -0.29570836f, -0.05118853f, 
    -0.00572467f, 0.09318454f, 0.01153170f, 0.10822280f, -0.52951539f, 0.00685831f, 0.40447515f, -0.30671048f, 
    -0.15946457f, -0.12602113f, -0.32883027f, 0.07364214f, -0.02976045f, -0.03263367f, -0.15333635f, 0.17890081f, 
    0.12880360f, 0.17096522f, 0.06129163f, 0.29351431f, -0.05672029f, -0.08828925f, 0.02980828f, -0.01055341f, 
    0.13504198f, 0.08164410f, 0.06762356f, 0.08256595f, -0.12287922f, -0.18640821f, -0.04569545f, 0.51190424f, 
    -0.36333111f, -0.00656100f, -0.36335647f, -0.29466480f, 0.04325796f, 0.01339602f, -0.02348892f, 0.21013576f, 
    -0.75399315f, -0.05493627f, -0.24580243f, -0.05631276f, 0.06098173f, -0.12832561f, 0.10693076f, 0.02032110f, 
    -0.03572074f, -0.09159634f, 0.07670653f, 0.22808011f, 0.33654812f, 0.14204851f, -0.23983794f, 0.00521216f, 
    0.08015280f, 0.00816614f, 0.08260364f, -0.15070082f, 0.11277495f, -0.09866937f, 0.02711474f, 0.12941901f, 
    -0.10235547f, 0.26125500f, -0.06237918f, 0.20215225f, -0.05037404f, -0.03651695f, -0.24807459f, 0.11120933f, 
    0.08113219f, 0.01205612f, 0.01631332f, -0.16780622f, -0.00371933f, -0.02006894f, 0.19397718f, -0.01188577f, 
    0.00968664f, -0.15402120f, -0.01782077f, -0.02439897f, -0.03582555f, -0.01952444f, 0.10123616f, 0.27463162f, 
    0.16098000f, 0.00894300f, -0.14533286f, 0.14372809f, 0.08066089f, -0.03270819f, 0.04206813f, 0.00259246f, 
    0.13303955f, 0.23569012f, -0.00743749f, 0.36704749f, -0.09754594f, 0.04127839f, -0.36259946f, -0.01461551f, 
    -0.00065858f, -0.26084355f, 0.24793974f, -0.12125141f, 0.03994580f, -0.25458574f, 0.10783062f, -0.04055304f, 
    0.20289154f, 0.37568069f, 0.34315106f, 0.28466260f, 0.03860787f, 0.11260505f, 0.15187559f, 0.07730364f, 
    0.08762728f, 0.03811141f, -0.01253535f, -0.07764231f, 0.10386734f, -0.09557630f, 0.24487153f, -0.04933903f, 
    -0.18144481f, -0.03476908f, -0.09958661f, -0.13599481f, -0.00265655f, -0.31816745f, -0.07981168f, -0.12958328f, 
    0.13240384f, -0.11274070f, -0.03069402f, -0.25388771f, 0.12256223f, -0.02176259f, 0.05699960f, -0.08057921f, 
    -0.08706731f, -0.10849032f, 0.04406087f, -0.08830263f, -0.08720826f, -0.48640519f, -0.37902641f, 0.18885213f, 
    -0.08149572f, 0.00331692f, 0.16997649f, 0.06775961f, 0.11682095f, 0.03573947f, 0.02123379f, -0.01538863f, 
    0.24973111f, 0.10454764f, 0.05587559f, 0.03583894f, -0.13286223f, -0.18936540f, 0.24709292f, 0.02092611f, 
    0.29989660f, 0.19282423f, 0.02526325f, -0.22487159f, 0.09089442f, 0.42636356f, -0.28698662f, 0.04230572f, 
    0.04944383f, 0.33639574f, -0.05054560f, -0.06626990f, 0.04872641f, 0.06544016f, -0.03980112f, -0.06093157f, 
    0.09802265f, -0.49600971f, 0.20736799f, 0.05251486f, -0.01315422f, 0.04710525f, -0.23807347f, 0.08658732f, 
    0.02983530f, -0.03103476f, -0.10767031f, -0.01453294f, 0.00540529f, 0.28754053f, 0.23254812f, 0.17029591f, 
    -0.09198058f, 0.06882790f, 0.10677917f, 0.08416422f, -0.00476529f, -0.00492089f, -0.03128720f, -0.05038122f, 
    0.05007287f, -0.05047726f, 0.26085868f, 0.01622370f, -0.24048544f, 0.09447107f, -0.16253959f, -0.13930026f, 
    0.00193449f, 0.01113194f, -0.03764936f, 0.02414643f, 0.03285622f, 0.15766355f, 0.07942888f, 0.19511697f, 
    -0.19173303f, -0.25913924f, 0.02357070f, -0.27046150f, -0.09879496f, -0.13518803f, -0.04591533f, 0.01111155f, 
    -0.32787454f, -0.13766560f, 0.02845778f, 0.14891464f, -0.12916118f, -0.04539332f, -0.25230157f, -0.07664243f, 
    0.02482115f, 0.07994105f, -0.01262035f, 0.08716932f, 0.03266545f, 0.04919762f, 0.04689362f, 0.05068854f, 
    -0.06074743f, -0.20663522f, 0.07358072f, -0.09844311f, 0.08022909f, 0.10464092f, -0.14257887f, 0.01690271f, 
    0.05503340f, -0.05236166f, 0.15690038f, 0.04396436f, -0.11421058f, 0.08267025f, -0.04054638f, -0.17195171f, 
    -0.05475897f, -0.03382132f, 0.00576131f, 0.10864311f, -0.05503352f, -0.15609512f, -0.15556678f, -0.14388600f, 
    0.05974923f, -0.03458402f, 0.05291445f, 0.05226785f, 0.08884490f, 0.06480145f, 0.02277803f, 0.00504927f, 
    0.01764442f, 0.14852017f, 0.00317988f, 0.19020073f, -0.18748350f, 0.03924126f, -0.01491131f, 0.03853874f, 
    0.15393405f, -0.15191011f, -0.20602925f, -0.12872265f, 0.04535135f, -0.06947708f, 0.21684957f, 0.08372471f, 
    -0.02933320f, -0.15253402f, -0.03760764f, 0.02027849f, 0.10880166f, 0.01227251f, 0.02420747f, 0.05131683f, 
    0.19954500f, 0.23553655f, 0.35382006f, -0.15764081f, 0.03114934f, 0.13285328f, -0.20048167f, 0.06021082f, 
    0.01908377f, -0.00378959f, 0.00125427f, -0.05682219f, 0.13195772f, -0.00770649f, -0.07962094f, -0.03049655f, 
    0.12362815f, 0.04160908f, -0.01657139f, 0.04328546f, -0.19081922f, -0.30148539f, -0.12096202f, -0.06613083f, 
    -0.01863131f, 0.01124141f, -0.08310492f, -0.06181693f, -0.11338924f, -0.20469989f, 0.14394508f, 0.02160982f, 
    -0.23189861f, 0.00955741f, -0.19939253f, -0.12318373f, -0.10945572f, 0.07508818f, -0.14507195f, -0.32900423f, 
    -0.09527136f, 0.09334171f, -0.03809897f, -0.17587534f, -0.28441298f, -0.07104505f, -0.15541264f, -0.00837547f, 
    0.44715899f, -0.26484403f, 0.20596750f, 0.05843997f, -0.03718351f, -0.57820064f, 0.10145330f, -0.15889598f, 
    -0.11459031f, 0.01888908f, -0.04345725f, -0.10566733f, 0.24898337f, -0.02548111f, 0.13770321f, 0.17337897f, 
    0.01856131f, -0.06715351f, -0.16611436f, -0.04179988f, -0.02599394f, 0.01047991f, -0.00428083f, 0.05296740f, 
    -0.28196552f, -0.13254640f, -0.05328394f, -0.01770602f, 0.14382100f, -0.17314956f, 0.01036158f, 0.02625579f, 
    -0.01360552f, -0.29792297f, -0.01400607f, -0.40567240f, -0.15863048f, -0.20405412f, -0.65862668f, -0.11356299f, 
    0.11624204f, -0.03926221f, 0.03556639f, -0.09287949f, -0.09043869f, 0.01325279f, 0.05939592f, 0.13077591f, 
    -0.27238002f, -0.17655826f, 0.04344286f, -0.25587600f, -0.04126210f, 0.04459896f, 0.03482586f, 0.13201520f, 
    0.04587160f, -0.23364466f, 0.11544378f, 0.01503862f, -0.23166880f, -0.27775726f, 0.34248516f, 0.28742161f, 
    0.14945090f, -0.08118534f, 0.01710712f, 0.09770033f, 0.08973595f, 0.23010288f, -0.17660461f, -0.14882272f, 
    -0.23122346f, -0.15256342f, -0.08105795f, -0.10167878f, -0.19257160f, -0.11435769f, 0.07177269f, 0.18325293f, 
    -0.09696336f, -0.25660172f, -0.19629185f, -0.20851114f, -0.15232751f, -0.07733671f, -0.15058896f, -0.02217780f, 
    0.02041079f, 0.09534749f, 0.08611730f, 0.00398800f, 0.04740728f, -0.41161183f, 0.23210956f, -0.38468978f, 
    0.19582641f, 0.10648990f, -0.25696447f, 0.12046462f, 0.10936517f, -0.02886758f, 0.25210536f, -0.10547161f, 
    0.05448511f, 0.00507489f, -0.04984106f, 0.28910303f, 0.09031228f, 0.14164068f, -0.01419727f, -0.41539904f, 
    -0.12528113f, -0.01207116f, -0.25628692f, -0.12161025f, -0.05306921f, -0.13922176f, -0.01442993f, -0.03769032f, 
    -0.15946153f, -0.03511899f, -0.00833742f, -0.02304552f, 0.03966381f, 0.02001195f, 0.09879464f, 0.05904424f, 
    0.08045257f, -0.34891468f, -0.48682538f, -0.63359493f, -0.32728118f, -0.59428042f, -0.05912316f, 0.40227905f, 
    -0.18652214f, -0.04196228f, -0.01165282f, -0.03740066f, -0.04584726f, 0.10510509f, -0.17435050f, -0.03636047f, 
    0.01187127f, 0.11258005f, 0.00100687f, -0.22720432f, 0.16918984f, -0.03209019f, 0.10455590f, -0.24073786f, 
    0.00424790f, -0.00973530f, 0.02229931f, -0.05836366f, 0.08146077f, -0.15040261f, 0.28479058f, 0.13696054f, 
    -0.00391306f, -0.16549958f, 0.10049611f, -0.13664761f, 0.08852201f, 0.03450342f, 0.13775621f, 0.03160110f, 
    0.13834217f, -0.20485005f, 0.20426312f, 0.28615576f, -0.22420190f, -0.13344331f, 0.15097421f, 0.17299892f, 
    -0.07654650f, -0.01969336f, 0.17488062f, 0.05421553f, 0.93689317f, 0.00499896f, -0.14439756f, 0.12036549f, 
    0.05243706f, 0.04445427f, 0.05900458f, 0.21827622f, 0.06645494f, 0.10965666f, -0.00192028f, -0.00326750f, 
    0.04881876f, -0.10836361f, -0.16593115f, 0.01791301f, 0.28332907f, -0.28573105f, -0.03167692f, -0.08833442f, 
    -0.07867331f, 0.16375557f, 0.09758494f, 0.07256784f, -0.14175120f, 0.04708064f, -0.68637085f, 0.10910711f, 
    0.23847376f, -0.06456311f, -0.02231069f, 0.19441602f, 0.02636090f, 0.02688864f, 0.12815009f, -0.06403454f, 
    -0.09293311f, 0.36559871f, -0.29829124f, 0.30137241f, 0.01830563f, 0.06100867f, 0.16228792f, -0.09232453f, 
    0.04053894f, -0.04607825f, 0.01533800f, 0.10203338f, 0.27460927f, 0.11991138f, 0.08183584f, 0.04973440f, 
    0.17833975f, 0.23291883f, -0.16628560f, -0.37585065f, 0.02268986f, 0.08846879f, 0.05522152f, -0.00123476f, 
    0.13012545f, 0.08285547f, 0.32072949f, -0.00852973f, 0.29740146f, -0.14434749f, 0.06261440f, 0.02115961f, 
    0.05122896f, 0.10888357f, 0.01779757f, -0.01367067f, -0.35405043f, 0.06712676f, -0.23699231f, -0.10603560f, 
    -0.13576952f, 0.01064608f, -0.09862946f, -0.08823337f, 0.21817064f, 0.10568561f, -0.02980112f, -0.21067135f, 
    -0.13848469f, 0.05039255f, -0.02299822f, -0.41325334f, 0.09683186f, -0.15990281f, 0.06371584f, -0.00363570f, 
    -0.04209897f, -0.03945388f, -0.07474507f, 0.07170037f, 0.17885360f, -0.19550791f, -0.03959601f, 0.00268511f, 
    -0.30688038f, 0.03231384f, -0.06825051f, 0.04912591f, 0.02385526f, 0.19295071f, 0.10902564f, -0.26589954f, 
    0.26950890f, 0.16038454f, 0.27372754f, 0.15052466f, 0.14057182f, -0.04462659f, 0.12047465f, 0.14247617f, 
    0.09418426f, 0.08968592f, 0.06609786f, 0.05931574f, 0.03158678f, -0.10230695f, -0.16704899f, 0.19935133f, 
    -0.01281968f, 0.06424315f, -0.12672919f, -0.05773303f, -0.15546499f, 0.05897254f, 0.06407552f, -0.11726940f, 
    -0.90304714f, -0.21051376f, -0.09322529f, -0.24780411f, 0.01533978f, -0.05875985f, -0.03569022f, 0.05292097f, 
    0.13613753f, -0.00849514f, 0.03743349f, 0.03271395f, 0.08984159f, -0.13669771f, 0.00517277f, -0.23123503f, 
    0.22315064f, 0.33885938f, -0.10798208f, 0.27329707f, 0.08195809f, 0.02847185f, 0.08038118f, 0.11722887f, 
    -0.13081113f, -0.03300475f, -0.08041159f, -0.40003917f, 0.12580115f, -0.09263215f, 0.04353344f, 0.03560027f, 
    -0.02021151f, -0.08498944f, -0.01165558f, 0.05676233f, -0.32283902f, 0.02700957f, -0.00066112f, 0.05031893f, 
    -0.07623741f, -0.05765108f, -0.06816106f, -0.02790972f, 0.10273939f, 0.06644191f, 0.08255382f, 0.27964315f, 
    -0.16296729f, -0.15474786f, 0.07347846f, -0.02735243f, 0.06846419f, -0.26091319f, 0.01907945f, 0.07440609f, 
    0.11979603f, 0.10453716f, 0.10423694f, 0.18872663f, -0.03091191f, -0.41830423f, -0.58919406f, 0.24441974f, 
    0.09668133f, -0.09644395f, -0.19689560f, 0.26651806f, -0.07698752f, 0.25769109f, -0.15896228f, 0.05824601f, 
    -0.30912012f, 0.15475230f, -0.00526457f, 0.22311760f, 0.27138793f, 0.05051620f, 0.10437249f, 0.41861260f, 
    -0.09061769f, 0.02345405f, 0.13929377f, 0.23452803f, 0.28198063f, -0.00772368f, -0.06458420f, -0.12367869f, 
    0.00370050f, 0.04322997f, -0.01025558f, 0.09698448f, 0.12922913f, -0.23048893f, -0.16500056f, -0.13120927f, 
    0.32549325f, -0.04160447f, -0.32111123f, -0.16669086f, 0.12512495f, 0.20263194f, -0.03609207f, -0.04697043f, 
    0.23671262f, -0.21631017f, 0.17522240f, 0.21799986f, -0.44977376f, -0.31316695f, -0.30020413f, 0.09333301f, 
    -0.07233755f, -0.07629262f, 0.00023824f, 0.04631291f, 0.00531110f, -0.00111797f, 0.15554520f, -0.00957709f, 
    -0.27114069f, 0.01506445f, 0.37420899f, -0.02928344f, -0.03203607f, -0.05911474f, -0.03419951f, 0.09886981f, 
    0.03321994f, 0.21964304f, 0.02985112f, 0.10588791f, -0.30134273f, -0.42880732f, -0.40443900f, 0.19601175f, 
    -0.06005342f, 0.40630355f, 0.16719246f, 0.08544825f, 0.02881575f, -0.02120074f, 0.01637880f, 0.18185921f, 
    0.11320100f, 0.00308623f, -0.03846918f, 0.25152883f, -0.16563146f, 0.17792882f, 0.11478389f, 0.44724780f, 
    0.11077141f, -0.04115969f, 0.12928535f, -0.07843522f, 0.13787811f, -0.02428573f, -0.01604105f, -0.11264227f, 
    0.02584262f, 0.05780318f, 0.09310718f, 0.05752228f, -0.04765143f, 0.12551963f, -0.07412609f, -0.09967715f, 
    -0.07142390f, -0.56987810f, 0.38338533f, 0.41159546f, -0.18549979f, -0.09761667f, 0.24859971f, 0.10891936f, 
    -0.01957517f, 0.01764456f, 0.02748411f, 0.04714118f, -0.32082447f, -0.04990747f, -0.11085825f, 0.05147470f, 
    -0.17360090f, -0.00135173f, 0.08550964f, -0.07893530f, 0.05351435f, 0.04366425f, 0.05084073f, 0.08733021f, 
    0.05875708f, 0.00667482f, -0.01888368f, -0.09154550f, 0.04725078f, 0.00064794f, 0.10970776f, 0.01091606f, 
    -0.05383822f, 0.05065010f, 0.20406331f, 0.18560714f, -0.12568995f, 0.08892889f, -0.41180375f, 0.69933057f, 
    -0.08851010f, 0.07262239f, -0.23173086f, -0.01574564f, -0.03043853f, -0.03158608f, 0.30165803f, -0.03621630f, 
    -0.48745817f, -1.07281041f, -0.53976387f, -0.30959886f, 0.08901878f, -0.04442473f, -0.05281678f, -0.34922409f, 
    0.03410704f, -0.01961561f, -0.06197573f, 0.02557410f, -0.18980011f, -0.11535127f, -0.11981183f, -0.09077522f, 
    -0.06628735f, -0.44896698f, -0.27634007f, 0.06307688f, -0.02627275f, 0.09253780f, -0.02403713f, 0.00605167f, 
    -0.22839949f, -0.04193540f, -0.25682059f, 0.23993059f, 0.31045783f, 0.16974644f, -0.01113809f, 0.14405786f, 
    0.01756483f, -0.05916139f, 0.11514745f, 0.10273842f, 0.04267326f, -0.47760910f, -1.01252735f, -0.25059003f, 
    -0.13745856f, 0.08406016f, 0.16592531f, 0.06198305f, -0.11031001f, 0.05350938f, -0.12035783f, 0.01301567f, 
    -0.10780156f, -0.05919239f, -0.05905262f, -0.18061656f, -0.12985304f, -0.16687576f, -0.08007645f, -0.01485890f, 
    -0.02748906f, 0.03443732f, -0.08724154f, -0.10763896f, 0.46498346f, -0.21778302f, -0.08393214f, -0.22636843f, 
    -0.06869649f, -0.00008158f, 0.22568053f, -0.08047687f, 0.06483073f, 0.08119947f, -0.10940175f, 0.05768521f, 
    -0.39089146f, 0.11074823f, 0.28253081f, 0.07818261f, 0.07547871f, 0.05734040f, 0.06052000f, -0.02662466f, 
    0.17711359f, -0.00168716f, 0.08030821f, -0.10706449f, -0.45022476f, -0.88251549f, -0.09852075f, -0.73339963f, 
    -0.06791483f, -0.14767939f, -0.17284183f, -0.45223236f, 0.04966858f, -0.05163358f, -0.06668147f, -0.01216858f, 
    -0.08821497f, -0.22269160f, -0.10362554f, 0.18418546f, -0.09941189f, 0.15004408f, -0.01319366f, -0.04024815f, 
    0.03543878f, 0.08129560f, 0.10835142f, 0.01371796f, -0.82993752f, 0.18438031f, 0.56328315f, -0.06924205f, 
    -0.01887969f, 0.03487279f, -0.21625306f, -0.11603712f, -0.02893761f, 0.07275504f, 0.21827875f, 0.05633868f, 
    -0.63051242f, -0.82794851f, -0.33190644f, 0.10415279f, 0.03785933f, 0.14073320f, -0.07347726f, -0.13070130f, 
    0.08285096f, 0.02984037f, -0.04191282f, 0.04280889f, -0.17857882f, 0.05852004f, 0.02696954f, 0.10214183f, 
    0.07904794f, 0.12203342f, -0.11539614f, -0.44543424f, -0.03274107f, 0.15076324f, -0.17745848f, 0.06711541f, 
    -0.40219489f, -0.66955954f, -0.62757689f, 0.01531868f, -0.16624147f, -0.27924335f, 0.10528273f, -0.48812383f, 
    -0.07772879f, -0.03319000f, 0.05096237f, 0.21738246f, -0.01132532f, 0.05217102f, -0.14846033f, -0.21212764f, 
    0.11502151f, -0.00455914f, 0.06020844f, 0.00869372f, -0.19698708f, -0.03024350f, -0.06686267f, -0.15382636f, 
    -0.54576254f, 0.19989663f, 0.36223179f, 0.11500111f, -0.00142153f, -0.08419444f, 0.03574977f, 0.10090847f, 
    -0.05305408f, 0.03377183f, 0.15239091f, -0.02872468f, -0.72983289f, -0.49344230f, -0.52198857f, -0.34554377f, 
    -0.25937533f, -0.16534530f, -0.28935951f, -0.13405144f, -0.03285161f, -0.04658929f, -0.08714753f, -0.09848260f, 
    -0.54874235f, -0.30849403f, -0.34253749f, 0.33015183f, 0.17558642f, 0.14887592f, -0.07081497f, -0.02271884f, 
    0.05565654f, 0.01245788f, -0.16726038f, 0.08674133f, 0.15126716f, -0.09797080f, -0.06809001f, 0.02050309f, 
    0.05053979f, -0.07629131f, 0.03609966f, 0.09437865f, -0.01679497f, -0.26995841f, 0.14782622f, -0.26262203f, 
    0.02685368f, -0.15019298f, -0.08168704f, 0.30761603f, 0.20913804f, 0.12293463f, 0.13190995f, 0.19906218f, 
    0.06861387f, 0.08420783f, -0.08058891f, -0.00254122f, 0.00894063f, 0.29965189f, 0.17051500f, 0.00903341f, 
    0.15531515f, 0.26267827f, -0.10217579f, -0.15081052f, 0.08084103f, -0.10437129f, 0.07912452f, 0.42125002f, 
    -0.21360642f, -0.19919074f, -0.08755707f, 0.05254099f, 0.16229431f, 0.03191505f, 0.27803251f, -0.31949091f, 
    0.14054708f, 0.01294805f, -0.03995571f, 0.07754555f, -0.45352322f, 0.99650019f, 0.29578644f, -0.07731511f, 
    -0.22936848f, -0.02057535f, -0.20201322f, 0.08670049f, -0.03113896f, 0.01674413f, 0.09682404f, 0.11752797f, 
    0.18557981f, 0.16935351f, -0.11919770f, 0.25990599f, -0.09042343f, -0.05408780f, 0.12124018f, 0.06377409f, 
    0.11854532f, 0.21397650f, 0.13657445f, -0.18118107f, -0.26728663f, -0.13763763f, -0.17192215f, 0.16710581f, 
    0.06604569f, 0.13481592f, -0.07942505f, 0.04677423f, -0.02117486f, -0.11616368f, 0.05544091f, 0.03408565f, 
    0.48905817f, -0.68474108f, 0.12283572f, -0.45270494f, -0.08239756f, -0.11684423f, -0.16468981f, 0.18310685f, 
    0.20920682f, 0.22534803f, 0.02038965f, 0.02175915f, 0.21845511f, -0.11889245f, -0.14144306f, -0.08777630f, 
    -0.12074838f, 0.16799228f, 0.11843082f, -0.06743359f, -0.09692465f, 0.09080039f, 0.10535944f, 0.04289176f, 
    0.20074974f, -0.07590253f, 0.01575793f, 0.07910804f, -0.05971525f, 0.04676902f, -0.04650326f, -0.15167665f, 
    0.13273500f, 0.00477469f, -0.15167733f, 0.13131052f, -0.03679406f, 0.13789006f, 0.06030036f, 0.09385158f, 
    0.05474304f, 0.03960467f, -0.01524597f, -0.02476865f, 0.08379287f, -0.02940031f, 0.16736832f, 0.17675647f, 
    -0.73215711f, 0.02572812f, -0.24449325f, 0.12123413f, -0.17597879f, -0.16917117f, 0.05328186f, -0.17456478f, 
    -0.01491662f, 0.01090876f, 0.04955180f, -0.05011532f, -0.37045220f, -0.23204660f, 0.16430053f, -0.29827029f, 
    0.03937044f, 0.14604141f, 0.20757338f, 0.14903331f, -0.04511910f, -0.19829462f, 0.03212003f, -0.02089835f, 
    0.09205236f, 0.05121173f, 0.05126924f, 0.14227235f, 0.00866502f, -0.03316206f, -0.04239466f, 0.02021830f, 
    0.07570895f, 0.12523542f, -0.12470839f, -0.08961932f, 0.54052943f, -0.09733615f, 0.11532129f, -0.05662952f, 
    0.05414876f, 0.12191256f, -0.13031767f, 0.05849837f, -0.18494597f, 0.11802087f, 0.03370790f, -0.22661968f, 
    -0.72406536f, 0.16484232f, 0.13664110f, 0.71937519f, 0.05419869f, 0.04715349f, 0.04536683f, -0.12060768f, 
    -0.00936016f, -0.06185117f, -0.01434723f, -0.07518199f, 0.39253235f, 0.09096932f, -0.05074095f, 0.32670981f, 
    0.08792032f, -0.13501707f, -0.06229094f, 0.04144830f, 0.00982464f, 0.06137766f, -0.06141530f, -0.02891958f, 
    0.14704050f, -0.42964575f, 0.07944593f, -0.26147905f, 0.04702248f, -0.04284130f, -0.15704359f, 0.01543330f, 
    0.04796939f, -0.00152202f, -0.06197016f, -0.04953779f, 0.02802758f, -0.50025320f, 0.10825752f, -0.28374192f, 
    0.01285132f, 0.08324760f, -0.03958556f, -0.12890320f, 0.09808709f, -0.01585531f, 0.00148371f, 0.09474718f, 
    0.17607583f, -0.01402629f, -0.06245022f, -0.06027529f, -0.14114030f, -0.07652272f, 0.11329179f, 0.07415592f, 
    0.01070810f, 0.07153296f, 0.00000599f, 0.02890963f, -0.28840357f, 0.42883685f, -0.11214374f, 0.08245928f, 
    -0.07987231f, -0.03319323f, -0.07086644f, -0.06639361f, -0.03552759f, 0.08876663f, 0.02528806f, 0.08561765f, 
    0.11488555f, 0.19037475f, -0.10173282f, -0.03583423f, -0.05738728f, 0.00136919f, 0.01258791f, 0.00105096f, 
    -0.05035030f, 0.09226906f, -0.14912343f, -0.11213643f, -0.55308098f, -0.12875809f, -0.12031086f, 0.75247085f, 
    -0.06080442f, 0.00616512f, 0.10157352f, 0.05589295f, 0.00207045f, -0.13171570f, -0.08200651f, -0.03881901f, 
    0.08137839f, -0.27797806f, 0.01377858f, -0.30917710f, 0.06825990f, 0.12147343f, 0.13662769f, 0.03474366f, 
    -0.05986270f, -0.08003003f, -0.12519382f, -0.02221151f, 0.48863319f, -0.89197922f, -0.92252845f, -0.69487923f, 
    -0.15715820f, -0.15332398f, -0.00660952f, 0.08462041f, -0.01260150f, 0.11600495f, 0.06983472f, 0.09851534f, 
    -0.19101091f, -0.29362336f, -0.30269688f, -0.47400793f, -0.12037622f, 0.12133384f, 0.18405095f, 0.14529538f, 
    0.06110243f, -0.06493204f, -0.01056625f, -0.01055004f, 0.03504723f, 0.05334380f, 0.04348560f, -0.11131037f, 
    -0.13611826f, -0.09499868f, -0.19931786f, -0.04124681f, 0.04232001f, -0.15499687f, 0.02753416f, -0.03377323f, 
    -0.59740037f, 0.06681074f, 0.09318695f, 0.27440321f, 0.06790842f, -0.14000367f, -0.15641052f, 0.28575072f, 
    -0.05044582f, -0.07825290f, -0.12903969f, -0.06203741f, 0.08319421f, 0.13807277f, -0.05483387f, -0.07529446f, 
    0.07226489f, -0.01943463f, -0.04925330f, -0.02367134f, 0.07415632f, 0.05958579f, -0.08705614f, -0.13012454f, 
    0.61063844f, -0.23926793f, -0.22652680f, -0.36711836f, -0.09289022f, -0.04725775f, -0.05909344f, -0.01865148f, 
    0.01018028f, 0.15655676f, 0.07814232f, -0.00709672f, -0.72895151f, -0.69587547f, -0.48984092f, 0.07971208f, 
    -0.26544657f, -0.25179929f, 0.14739832f, 0.10491887f, 0.01116968f, 0.06338828f, -0.04540857f, 0.02285820f, 
    -0.31313351f, -0.01274109f, 0.36898595f, -0.32924518f, -0.06717506f, 0.03740665f, -0.10670812f, 0.27169386f, 
    0.07182379f, -0.00779093f, 0.08132987f, -0.05132737f, 0.04862602f, -0.07032142f, -0.00500072f, -0.16766025f, 
    0.06478463f, 0.02870800f, -0.02084657f, -0.03731120f, 0.05357386f, -0.18241377f, -0.36456618f, -0.57383239f, 
    0.10413327f, -0.16556843f, 0.19999214f, -0.22818656f, -0.08455208f, -0.03676917f, -0.15177444f, 0.03176014f, 
    -0.02537120f, -0.05719542f, -0.05494370f, -0.05224567f, 0.16863200f, -0.15573351f, -0.10392313f, 0.21918067f, 
    -0.16638282f, 0.02127025f, -0.13224648f, 0.11960129f, -0.25960630f, 0.10771705f, -0.00490657f, -0.07712693f, 
    0.24451305f, 0.18733755f, -0.16042438f, -0.04638822f, 0.06180124f, -0.12100039f, -0.02535663f, -0.20092405f, 
    -0.14430468f, -0.04026161f, 0.05234892f, 0.03678790f, 0.26129943f, -1.15988088f, -0.44413096f, -0.22603849f, 
    0.08647693f, 0.06307106f, 0.08052856f, -0.07381405f, -0.02596666f, -0.06272627f, 0.14432831f, 0.07126472f, 
    -0.59837359f, 0.30989060f, -0.32299000f, 0.30672750f, -0.06239934f, 0.22149459f, 0.19625291f, 0.03155630f, 
    0.02858528f, -0.18634504f, 0.08555349f, -0.15351050f, 0.00097556f, -0.10651175f, 0.09474321f, -0.14058052f, 
    0.07413622f, -0.00026007f, -0.03793240f, 0.03765578f, 0.13287255f, 0.04246043f, 0.10909516f, -0.19853683f, 
    -0.21783316f, -0.14287455f, -0.20319954f, 0.04517327f, 0.11370871f, 0.13745229f, 0.18352479f, 0.01262326f, 
    -0.20459767f, -0.07195245f, -0.12729180f, -0.44718331f, 0.66948533f, 0.07240233f, -0.11346368f, -0.28186533f, 
    0.16709791f, -0.21803933f, 0.05130907f, -0.10290273f, -0.12242313f, -0.03340437f, -0.14870413f, -0.07624737f, 
    -0.04820322f, -0.16264214f, -0.04393625f, -0.02792641f, 0.02350922f, 0.10653716f, 0.00270678f, 0.14466976f, 
    0.05702299f, 0.03441265f, 0.22594917f, -0.36153620f, -0.55621374f, -0.02022791f, 0.04162617f, -0.04037811f, 
    -0.04653016f, -0.12318580f, -0.18520413f, -0.08996566f, -0.41851133f, -0.22344038f, -0.39914569f, -0.19382519f, 
    0.12412729f, -0.04663651f, 0.22043483f, 0.16198848f, 0.02394615f, 0.21504560f, -0.00028910f, 0.17990942f, 
    0.06664819f, -0.01970942f, 0.15197457f, -0.00659446f, 0.18097626f, -0.06907044f, -0.24618736f, 0.18112876f, 
    0.17816523f, 0.06010116f, 0.13436867f, -0.02937798f, -0.03293383f, -0.18924391f, -0.07891858f, -0.11912508f, 
    -0.43466449f, -0.11035175f, 0.01698690f, -0.13234545f, -0.11448648f, -0.18258208f, -0.11457370f, -0.09184226f, 
    -0.25662446f, -0.01050709f, -0.24069101f, -0.63417548f, 0.38809991f, 0.12635089f, -0.45823658f, -0.14512636f, 
    0.18619522f, -0.15194891f, -0.02964239f, 0.12146828f, 0.15266226f, 0.11652396f, 0.18278632f, 0.24997829f, 
    -0.19118486f, -0.45508224f, -0.23247743f, 0.03451031f, -0.04871288f, 0.12231168f, -0.11925961f, 0.25966066f, 
    -0.00416130f, -0.00013044f, 0.02341944f, -0.00553983f, 0.38847613f, -0.09605729f, -0.52349031f, -0.15776981f, 
    0.15163039f, -0.13044719f, -0.15509619f, 0.02605597f, 0.05139773f, 0.13411272f, 0.07376267f, 0.23784730f, 
    -0.05432685f, 0.24519761f, -0.03668873f, -0.35111794f, 0.20373583f, -0.13086635f, 0.14584254f, -0.11622575f, 
    0.01122484f, 0.06467064f, -0.04168032f, 0.10445081f, -0.43806762f, 0.46044466f, 0.34008008f, 0.05794700f, 
    -0.00300578f, -0.18888709f, -0.06837847f, -0.20213801f, -0.08062003f, -0.05246567f, -0.07565700f, 0.00548492f, 
    -0.17230746f, -0.08123186f, -0.02607812f, -0.01486768f, 0.07912510f, 0.08649340f, 0.01128491f, -0.01093101f, 
    -0.06836849f, 0.02356646f, 0.01072048f, 0.13566090f, -0.52353442f, -0.12988265f, 0.13358685f, 0.25087085f, 
    0.08291862f, 0.17250596f, -0.12987840f, 0.18411070f, -0.05388137f, -0.10230146f, 0.04129002f, 0.02433658f, 
    0.16283502f, -0.11167957f, -0.11410057f, -0.19310257f, -0.12072142f, 0.08964288f, 0.00588415f, -0.06910926f, 
    -0.00033292f, 0.10981176f, 0.08931572f, 0.31349900f, -0.25577933f, -0.15926649f, -0.27956635f, -0.19205797f, 
    -0.01800723f, -0.19440949f, -0.21150288f, -0.00767402f, 0.07978583f, 0.09055085f, 0.06411340f, 0.08183251f, 
    0.64199960f, -0.16451135f, -0.21879826f, 0.01993837f, 0.04289125f, 0.23975249f, 0.21427812f, 0.11647566f, 
    0.01594202f, -0.12572214f, 0.01746385f, -0.09458612f, -0.78766996f, -0.84007120f, -0.54827952f, -0.10458992f, 
    0.11964442f, 0.44079882f, 0.24964440f, 0.20841195f, 0.26071045f, 0.10826878f, 0.05982037f, 0.18250607f, 
    0.03450251f, -0.72460574f, -0.82887888f, -0.18942736f, -0.00802286f, -0.03070852f, 0.32278752f, -0.12081575f, 
    -0.10961295f, -0.03903159f, -0.04445409f, -0.06671229f, 0.05280771f, -0.00742248f, -0.07592110f, 0.00069291f, 
    -0.04053076f, -0.04281878f, 0.06138274f, 0.11102892f, 0.02664034f, -0.14191693f, 0.00299187f, 0.13324261f, 
    0.42968208f, 0.24710806f, -0.76032293f, -0.39340597f, -0.17106207f, -0.13264199f, -0.25865239f, -0.18542583f, 
    0.12583789f, 0.08388015f, 0.07685641f, 0.11524853f, 0.24527627f, 0.03426083f, -0.09827054f, -0.21257436f, 
    -0.06581767f, -0.07944693f, 0.06811158f, -0.06190780f, 0.01471057f, -0.05603306f, 0.00567641f, -0.01712605f, 
    -0.06529943f, -0.37241048f, -0.28650379f, -0.05411296f, -0.12777489f, 0.02151498f, 0.17375176f, 0.09430408f, 
    0.17229055f, 0.15123643f, 0.03786847f, -0.06143115f, -0.17895272f, -0.75017971f, -0.46139124f, 0.28642529f, 
    0.35409606f, 0.03472995f, 0.19329333f, -0.19165783f, 0.03474664f, -0.10607735f, 0.10772166f, 0.08017250f, 
    -0.13459176f, 0.03764521f, -0.00730560f, 0.08408847f, -0.09364459f, 0.05275281f, 0.02968215f, -0.34132981f, 
    0.05802261f, 0.01546144f, -0.04983606f, 0.03376060f, -0.03780273f, -0.10886520f, 0.03744158f, -0.26550406f, 
    -0.01909651f, -0.09785191f, 0.00718286f, -0.02490421f, 0.01011310f, 0.03515982f, 0.18070081f, 0.08787156f, 
    0.41227683f, 0.07358041f, -0.01715533f, -0.09284205f, 0.19328181f, -0.07860225f, -0.00144049f, -0.02097242f, 
    -0.04490022f, 0.08580916f, 0.15954141f, 0.15970100f, -0.15328990f, -0.11320467f, 0.09484492f, 0.32424673f, 
    0.02712497f, 0.06573322f, 0.09724697f, 0.17801163f, -0.05983299f, 0.04156615f, 0.10548384f, -0.33243552f, 
    0.14761728f, 0.02266930f, -0.04032159f, -0.12481298f, 0.09479626f, 0.00118490f, 0.16332996f, 0.13819343f, 
    0.07528272f, 0.05095407f, -0.35086808f, -0.06660518f, 0.12667568f, -0.50010026f, -0.36770543f, -0.20891567f, 
    -0.04200254f, 0.05666995f, 0.10118929f, 0.01448578f, 0.18593492f, -0.36185548f, -0.07801040f, -0.01967890f, 
    -0.99431294f, 0.18547876f, 0.15631594f, 0.45601413f, -0.12115674f, 0.08891046f, -0.06549831f, -0.01597073f, 
    0.02293450f, 0.20191306f, 0.10565389f, 0.32225305f, -0.05657451f, 0.10385413f, 0.25578123f, -0.24587314f, 
    -0.13308516f, -0.01989324f, 0.04396978f, -0.05603192f, -0.07461563f, 0.07510421f, -0.04750101f, 0.14304015f, 
    -0.22133732f, -0.22418392f, 0.20117785f, 0.00814869f, 0.04631700f, 0.03366412f, -0.09551040f, -0.09740483f, 
    -0.09893519f, 0.25742128f, -0.03931086f, 0.14830689f, -0.02515211f, 0.15714225f, -0.32781056f, 0.04041366f, 
    0.10228038f, 0.14258459f, 0.02448452f, -0.10232584f, -0.00437913f, -0.12203439f, -0.17839675f, -0.01209339f, 
    -0.09395724f, 0.26347351f, 0.24517949f, 0.20148751f, -0.01702614f, -0.13577190f, -0.17902829f, -0.27796635f, 
    0.12536256f, 0.07611477f, 0.24695803f, 0.23653772f, -0.02371875f, -0.05554359f, -0.35741082f, -0.01687649f, 
    0.08022804f, 0.03952046f, 0.22496879f, 0.00929033f, 0.06412259f, 0.11440844f, 0.19589169f, 0.16909409f, 
    -0.40583768f, -0.22494124f, -0.30364031f, -1.03607106f, -0.09713227f, -0.19576049f, 0.05967803f, -0.02763801f, 
    0.05923240f, -0.04171602f, 0.06261737f, 0.07411270f, 0.00069391f, 0.03278446f, 0.10252722f, -0.35838318f, 
    -0.07495987f, -0.11029819f, -0.06333119f, 0.17805307f, 0.12272128f, 0.07250214f, 0.13973032f, 0.16153775f, 
    -0.03328783f, -0.11519599f, -0.08288831f, -0.00036060f, 0.02061488f, 0.11699672f, 0.12059388f, 0.04164412f, 
    0.06432705f, 0.18085839f, 0.26410913f, 0.19542007f, -0.64709985f, 0.28869572f, 0.25139421f, 0.23798211f, 
    -0.16264361f, -0.11750925f, -0.08504539f, 0.02963302f, 0.23176880f, -0.11919837f, 0.13939749f, 0.01098978f, 
    0.22826298f, 0.70579958f, -0.53947175f, -0.06783191f, -0.25022501f, -0.02560121f, 0.36823845f, 0.04580253f, 
    0.03277284f, 0.04843564f, 0.01973386f, -0.06178506f, -0.28158832f, -0.09811077f, -0.07437788f, 0.31624460f, 
    0.20674044f, -0.13629025f, -0.19381030f, 0.02072445f, -0.04797115f, -0.09581290f, -0.08215138f, -0.13748538f, 
    0.22398315f, -0.13374467f, 0.14075141f, 0.04949634f, -0.07452309f, -0.05488725f, 0.14323562f, 0.08331513f, 
    -0.13557114f, -0.09832375f, -0.06139336f, -0.17341004f, -0.15023001f, -0.25827140f, -0.74612117f, 0.34794393f, 
    0.17070289f, 0.07529443f, 0.09197228f, -0.11068457f, -0.08891648f, -0.04364699f, -0.05225758f, 0.07784405f, 
    0.18118407f, 0.27612528f, -0.19676621f, 0.30873752f, -0.05529036f, 0.13735442f, 0.10734128f, -0.00704095f, 
    0.29279432f, -0.09808543f, -0.09918558f, -0.19099943f, -0.46817142f, 0.57970446f, -0.42347014f, -0.31541711f, 
    0.01598234f, 0.00845255f, 0.27459675f, 0.13545850f, -0.06727754f, -0.04980711f, -0.21049777f, 0.08664442f, 
    -0.49830732f, -0.02063445f, -0.15420277f, 0.16593532f, 0.17303003f, -0.05859644f, -0.26419753f, 0.01016861f, 
    0.00979143f, -0.12365979f, -0.09915236f, 0.13745995f, 0.22312526f, -0.03732550f, -0.48873958f, 0.12903817f, 
    0.01181654f, -0.00308228f, -0.01065665f, 0.36346209f, -0.02604714f, 0.17503437f, -0.05093675f, -0.14693412f, 
    -0.20604053f, 0.15476996f, 0.07511728f, -0.04392464f, -0.06300067f, -0.22740947f, 0.06248360f, 0.04518661f, 
    0.22592866f, 0.03335251f, -0.05579345f, 0.11174148f, -0.16739920f, 0.25639862f, -0.24883604f, -0.01673558f, 
    -0.04120203f, -0.20267782f, -0.24222480f, 0.06597249f, 0.07402761f, -0.04848390f, 0.08751500f, -0.06030944f, 
    -0.20993887f, -0.32677171f, 0.01239057f, -0.15520653f, -0.41991505f, 0.06163420f, -0.05249555f, 0.10260246f, 
    0.18148896f, -0.01013236f, 0.18031955f, 0.06937976f, 0.07662903f, -0.32695916f, 0.14813952f, -0.17424722f, 
    0.10490945f, 0.21614352f, -0.12933323f, 0.14551474f, 0.24381906f, 0.06527345f, -0.18584144f, 0.12188707f, 
    -0.57545531f, -0.23354654f, -0.51291943f, 0.20568407f, 0.21383476f, -0.03820602f, 0.02037079f, 0.03794812f, 
    0.00278811f, 0.08431051f, 0.16069978f, -0.09867151f, -0.47389510f, -0.17800120f, -0.15370828f, 0.27238724f, 
    0.05244408f, 0.12891816f, 0.05106407f, 0.03115194f, 0.13583128f, 0.09618560f, -0.06394092f, -0.18774691f, 
    0.27619374f, 0.16249447f, 0.47979090f, 0.36092326f, -0.12371983f, 0.02233355f, -0.32150796f, -0.17022525f, 
    0.06467049f, -0.17921193f, 0.01727152f, 0.09470726f, -0.28546771f, 0.25213692f, 0.54947490f, -0.71630841f, 
    0.05378656f, -0.36177692f, -0.10016183f, 0.23383947f, -0.07466063f, 0.01419448f, -0.01459712f, 0.02548952f, 
    0.40197760f, -0.64048165f, 0.00192433f, -0.43652683f, 0.20865351f, -0.13586137f, 0.14402714f, 0.00517038f, 
    -0.01187479f, -0.03277914f, -0.00966729f, -0.01420819f, -0.02827658f, 0.07613615f, 0.24621324f, 0.17864153f, 
    0.07176300f, 0.02478617f, -0.08685604f, -0.24956430f, -0.05123754f, 0.18856023f, 0.14633042f, -0.20673636f, 
    0.34528965f, -0.63758659f, 0.10602033f, -0.09698886f, 0.00768343f, 0.02940774f, 0.12097038f, -0.34424728f, 
    -0.13647205f, -0.03547216f, -0.25721610f, 0.12126519f, 0.23931327f, 0.32397440f, -0.58728647f, -0.21184543f, 
    -0.29168490f, -0.31767890f, -0.04644625f, 0.23623224f, 0.20458202f, 0.03963956f, 0.14285535f, -0.07457731f, 
    -0.49697927f, -0.57294238f, -0.34016329f, 0.01718191f, -0.09393696f, 0.19098814f, -0.03922803f, -0.21712905f, 
    0.33906806f, -0.10532161f, -0.23277530f, 0.01815221f, 0.11546317f, -0.20903274f, 0.58308154f, 0.07222743f, 
    -0.01713561f, -0.33136085f, -0.11460739f, -0.12243130f, -0.05212146f, -0.01739654f, 0.11715420f, 0.08171651f, 
    -0.33170077f, 0.25510979f, -0.01413293f, -0.93683141f, -0.03044859f, -0.24094705f, 0.19884227f, -0.05171407f, 
    -0.19224951f, 0.14039087f, -0.02475234f, -0.14183445f, 0.11995866f, -0.70696336f, 0.15730137f, -0.13913275f, 
    -0.04294766f, 0.22917868f, 0.03067764f, -0.24612106f, 0.16286278f, -0.11357271f, -0.09023333f, -0.00846426f, 
    -0.05368824f, 0.18615225f, -0.12205654f, -0.17804316f, 0.10078958f, -0.11145268f, -0.04962547f, -0.01442183f, 
    -0.02364891f, -0.42133075f, -0.59120870f, -0.57994485f, -0.54550529f, 0.13371295f, -0.24411497f, -0.23385420f, 
    -0.24128738f, -0.08817379f, 0.20946756f, 0.04183115f, 0.05705161f, 0.09864258f, -0.08071599f, -0.02114540f, 
    0.07897170f, 0.04165655f, 0.13395765f, -0.06585237f, 0.01690682f, 0.04896539f, 0.15110666f, 0.10633986f, 
    -0.02419994f, 0.00550315f, -0.26828748f, -0.38370854f, 0.06850881f, 0.14929521f, -0.18881987f, 0.06358556f, 
    -0.19955763f, -0.37810588f, -0.00337471f, 0.09713165f, -0.30074006f, -0.14415354f, -0.20788379f, -0.21451980f, 
    0.05804510f, -0.33006456f, 0.74556267f, 0.35081205f, 0.11561646f, -0.05645506f, 0.20850146f, -0.09015129f, 
    0.03139158f, -0.13285173f, -0.17949428f, 0.26567668f, 0.01320163f, 0.09279205f, -0.24884459f, 0.03601277f, 
    0.04398511f, -0.30859047f, -0.13971692f, 0.18114206f, -0.14039782f, -0.07919005f, -0.06333773f, -0.26697651f, 
    0.14401670f, 0.04304503f, 0.06401600f, -0.12139069f, -0.20206474f, -0.02575959f, -0.02938832f, -0.08891774f, 
    -0.08800806f, -0.30979827f, -0.43603766f, -0.27286637f, 0.40087485f, 0.28511360f, 0.12696548f, -0.41396347f, 
    -0.31599647f, 0.10855681f, 0.23387280f, 0.01175104f, -0.10173270f, -0.17038725f, -0.15749232f, 0.02442046f, 
    -0.22478621f, -0.01906702f, 0.15185055f, 0.11588082f, 0.03219835f, -0.15868962f, 0.17750619f, -0.22551793f, 
    -0.01317981f, 0.12743343f, -0.00807529f, -0.03548743f, -0.13490194f, -0.19332695f, 0.45454636f, 0.02395386f, 
    -0.13639738f, 0.03185279f, 0.09992922f, 0.20147660f, 0.21626039f, -0.14585313f, 0.23500155f, 0.45453236f, 
    -0.23281628f, 0.44689867f, -0.18616287f, 0.00185216f, -0.19414803f, 0.09505741f, 0.14890592f, 0.03245315f, 
    -0.23139679f, -0.02790068f, 0.28110915f, 0.11690306f, -0.26102027f, 0.49611539f, -0.85865140f, 0.02195611f, 
    -0.28691837f, 0.08348251f, 0.28404829f, -0.35740805f, 0.00266223f, 0.16910620f, -0.05530873f, 0.08136504f, 
    -0.12637332f, 0.25331056f, 0.18439859f, -0.28373316f, -0.01104551f, -0.19102991f, -0.19855431f, -0.03255162f, 
    -0.14092079f, 0.03365364f, 0.06233167f, -0.15591249f, 0.13785928f, -0.70868140f, 0.20477316f, 0.12608807f, 
    -0.09007323f, -0.03240586f, 0.09394975f, -0.01792624f, -0.14065737f, -0.01836896f, 0.03921781f, 0.03584413f, 
    0.26478738f, 0.38843688f, 0.43405265f, -0.16094804f, -0.06535999f, 0.11084557f, 0.15776257f, 0.08503501f, 
    0.06767193f, -0.02952108f, 0.03713476f, 0.18074840f, -0.28501880f, -0.05574877f, -0.27671272f, 0.00173265f, 
    -0.03190142f, -0.00909056f, -0.14715564f, 0.04281775f, -0.04464138f, 0.14919086f, 0.05488848f, 0.07220355f, 
    -0.28816569f, 0.42059100f, -0.33314890f, 0.03911525f, -0.20071240f, -0.13912868f, -0.16577752f, -0.03676915f, 
    -0.24835135f, 0.12840389f, -0.19893849f, -0.11504149f, 0.15736304f, 0.15199509f, 0.11394585f, 0.00871766f, 
    -0.00354482f, 0.10858066f, 0.06155140f, 0.20596443f, -0.05499869f, 0.11600424f, -0.01942045f, -0.07805023f, 
    -0.02016510f, -0.20711519f, -0.28284496f, -0.13874373f, -0.00951596f, -0.33038008f, 0.00525703f, -0.06929492f, 
    -0.07693651f, 0.16595793f, -0.08831600f, -0.07950782f, -0.56531477f, -0.03599613f, 0.06503730f, 0.23064461f, 
    0.09507602f, 0.08416058f, -0.03651129f, 0.32197663f, -0.38344255f, 0.13861173f, 0.12638725f, -0.04127801f, 
    -0.26061657f, 0.35184526f, -0.33478352f, 0.15886205f, -0.07619277f, 0.25755292f, -0.13343844f, 0.12183825f, 
    -0.11205203f, 0.20414835f, 0.16305654f, 0.00141290f, -0.36978108f, -0.22160219f, 0.05979530f, -0.43739331f, 
    -0.15691637f, -0.19293287f, -0.17598939f, 0.03230026f, -0.00095352f, -0.19538888f, -0.04706231f, -0.07552415f, 
    -0.08223762f, 0.12453803f, 0.09205825f, 0.01664676f, 0.07214946f, -0.17699097f, -0.18073472f, 0.01094195f, 
    -0.29568827f, 0.31392714f, -0.00017426f, -0.27788916f, -0.50577372f, -0.03396092f, -0.07552128f, 0.23798822f, 
    -0.28837079f, -0.15142812f, -0.01470477f, 0.36692473f, 0.10198431f, 0.15239832f, 0.11466951f, 0.29729182f, 
    -0.40456223f, -0.22864570f, -0.11013332f, 0.13394701f, -0.06336822f, 0.31219855f, -0.36422825f, 0.23441412f, 
    -0.01444506f, 0.01680821f, 0.17055327f, -0.07471920f, -0.34068635f, 0.02575794f, -0.42030111f, -0.02156378f, 
    -0.18473181f, -0.02623254f, 0.01575960f, -0.02536561f, 0.03277227f, -0.20046981f, 0.06561872f, -0.03819413f, 
    -0.55671829f, 0.07540004f, -0.23181352f, 0.14963618f, -0.09079304f, 0.16811123f, 0.06473050f, 0.10695969f, 
    -0.04338173f, 0.22809918f, -0.08930218f, 0.19149119f, 0.06198896f, 0.25686923f, 0.28382134f, 0.22684118f, 
    0.07407405f, 0.30797911f, -0.05872141f, 0.40813071f, 0.02964281f, 0.02501628f, -0.20092705f, -0.05351517f, 
    0.45062047f, -0.71476191f, 0.44221658f, -0.19533689f, 0.00730721f, 0.20222220f, 0.13298804f, 0.26663712f, 
    -0.01821144f, -0.14228359f, 0.02120204f, -0.23260474f, -0.59003538f, 0.24288809f, 0.07496561f, 0.12412012f, 
    0.05509783f, 0.16336203f, -0.23634374f, 0.08682153f, -0.01866536f, 0.10989735f, -0.17702912f, 0.00623490f, 
    0.05458724f, -0.22905414f, 0.31723362f, 0.06272820f, -0.15395507f, 0.03143683f, 0.10910850f, 0.07054710f, 
    0.10024302f, -0.09964256f, 0.07662049f, 0.20960626f, -0.42118159f, 0.04367707f, 0.08515195f, 0.04311524f, 
    -0.44514090f, 0.02420541f, 0.10759468f, -0.01365144f, -0.08074791f, 0.00273887f, 0.16964802f, 0.16974516f, 
    -0.27837160f, -0.20860232f, -0.56075966f, -0.17179444f, 0.13417049f, -0.08274335f, 0.04096467f, -0.12245408f, 
    -0.11416353f, 0.24196631f, 0.08183886f, 0.19710936f, 0.39673010f, -0.13634843f, 0.34324938f, -0.00573272f, 
    0.07339991f, 0.01026590f, 0.03832572f, 0.17745622f, 0.08411004f, -0.06025332f, 0.04652280f, -0.01288947f, 
    0.38563320f, 0.08994988f, -0.05794420f, -0.46824393f, -0.03539945f, 0.02594549f, 0.13778596f, -0.03758010f, 
    -0.05080183f, 0.08871638f, 0.17772217f, 0.13048686f, 0.26317316f, 0.10936213f, 0.17608273f, -0.28956774f, 
    -0.08032712f, 0.11920170f, 0.00724390f, 0.17137621f, -0.11487880f, 0.16077510f, 0.16379149f, -0.20600514f, 
    0.20808260f, 0.17440718f, -0.13059892f, 0.70932424f, 0.00998741f, 0.03108335f, -0.19076510f, 0.08255871f, 
    0.01548438f, 0.01349247f, -0.00149597f, -0.03515279f, -0.30763263f, -0.07109319f, -0.08136921f, -0.05519904f, 
    -0.18763262f, -0.36423129f, -0.00395086f, -0.09752485f, 0.04941013f, 0.15554872f, 0.11560187f, 0.01776665f, 
    0.02118742f, 0.25816649f, -0.16990708f, -0.23461291f, -0.08819643f, 0.03743974f, -0.07995805f, 0.18739881f, 
    0.13554795f, 0.21251495f, 0.26323208f, 0.04737985f, 0.13637827f, -0.84180945f, 0.35217336f, 0.33306754f, 
    0.19867797f, -0.24571225f, 0.15520228f, -0.22851911f, -0.06068625f, -0.02083269f, 0.04432967f, -0.10780113f, 
    -0.05787281f, -0.78932333f, 0.42418700f, -0.24075027f, -0.26209912f, -0.18355633f, -0.34203571f, -0.14565930f, 
    0.00176071f, 0.03281588f, 0.11525207f, 0.11547967f, -0.01404537f, -0.19185674f, -0.06332886f, -0.15676275f, 
    -0.02949302f, 0.14361753f, -0.10633969f, -0.03668899f, -0.11729655f, -0.14784457f, 0.05653759f, -0.56316584f, 
    0.14331096f, 0.17751963f, 0.18153618f, 0.28830779f, -0.11782327f, -0.05507483f, 0.06565408f, -0.05586736f, 
    0.29537991f, -0.08490174f, 0.26080826f, -0.20235714f, 0.90934497f, -0.12993336f, 0.27598089f, 0.09062106f, 
    0.11836171f, -0.13494608f, 0.03601441f, 0.09659562f, -0.30559528f, -0.10945801f, -0.06342705f, -0.32562974f, 
    -0.18015492f, -0.08994952f, -0.03766179f, -0.06377417f, 0.09123159f, 0.08947601f, 0.18129237f, -0.13446786f, 
    -0.02650658f, -0.13612007f, -0.16908413f, -0.17552403f, 0.12559479f, -0.06730773f, 0.80849355f, -0.07455291f, 
    0.01148875f, 0.05147566f, -0.15926920f, -0.03174102f, -0.03305478f, -0.07320905f, 0.11043697f, -0.06171891f, 
    0.04975980f, -0.20677707f, 0.25847074f, -0.17825359f, 0.06117998f, 0.09704860f, -0.20938177f, 0.08606503f, 
    0.18895806f, -0.11840578f, 0.06076520f, -0.18943375f, 0.17934634f, -0.38366127f, 0.08982960f, 0.45247653f, 
    -0.36633068f, -0.11993124f, -0.12614514f, -0.08713500f, -0.00942347f, -0.02561638f, -0.00206049f, 0.12982653f, 
    0.39620072f, -0.39546701f, 0.07047088f, -0.21424705f, 0.26075369f, -0.12307651f, 0.09043545f, -0.00096496f, 
    0.20805122f, 0.19342083f, 0.19071433f, -0.00704245f, -0.80569875f, -0.27070847f, -0.07986068f, -0.10136519f, 
    -0.09845650f, -0.24499534f, 0.01904638f, -0.00669492f, -0.07393390f, 0.05814883f, -0.22417796f, 0.05708122f, 
    0.24639651f, -0.03520007f, 0.52679163f, -0.81912005f, -0.17283233f, -0.00780546f, 0.17039815f, 0.06300573f, 
    0.10631446f, 0.02873318f, 0.15449187f, 0.02255575f, -0.30992752f, 0.05296737f, -0.08538704f, 0.29708344f, 
    0.17854911f, 0.14944263f, 0.21303479f, -0.12132426f, -0.07740133f, 0.01764230f, -0.25998193f, -0.08981503f, 
    -0.08221811f, -1.07368052f, 0.36121339f, 0.08251768f, -0.06681570f, -0.23289762f, -0.17093818f, 0.21002360f, 
    -0.01011805f, 0.05456690f, 0.13207574f, 0.03921580f, 0.41982123f, 0.11225966f, 0.01149082f, -0.08634577f, 
    -0.00175065f, 0.11035619f, -0.16086765f, 0.08705587f, -0.14834711f, 0.29294127f, -0.02310480f, 0.10799740f, 
    -0.85385269f, 0.20819873f, -0.47339344f, 0.11243761f, 0.14393033f, -0.05791168f, 0.09471091f, -0.11969575f, 
    -0.11201070f, -0.21389823f, -0.08212654f, -0.05902644f, -0.23453660f, 0.11446708f, -0.16360551f, -0.11598068f, 
    -0.03042085f, -0.33603746f, -0.41781780f, 0.20693469f, -0.07912731f, -0.01558611f, -0.23372337f, -0.23643795f, 
    0.61020869f, 0.35025951f, 0.09087396f, 0.01198929f, -0.11532957f, 0.30164087f, -0.37877995f, 0.13567944f, 
    -0.08228038f, 0.15465347f, -0.05354306f, -0.22516766f, 0.05326384f, 0.09134766f, -0.35399601f, -0.00617725f, 
    0.00301137f, 0.17793442f, -0.07446431f, 0.12985274f, -0.13643925f, -0.00658078f, 0.02648652f, -0.05434697f, 
    0.11267994f, 0.09363098f, -0.16047662f, 0.29144874f, 0.11285622f, -0.12438700f, 0.07931338f, -0.34521624f, 
    -0.07084192f, 0.06698728f, 0.02426113f, -0.05753759f, -0.27161622f, 0.03279692f, 0.67237025f, 0.13707109f, 
    0.06388596f, -0.14967889f, 0.19588906f, 0.26861244f, 0.05864529f, -0.29082304f, -0.06127581f, 0.27471727f, 
    -0.23180540f, 0.05344439f, 0.21759161f, -0.50412279f, -0.14790590f, 0.15302700f, -0.11071586f, -0.03530010f, 
    -0.17458521f, 0.29364291f, -0.01373864f, 0.22609156f, -0.21548261f, -0.40977028f, -0.17406701f, 0.17057040f, 
    -0.05663497f, -0.15818974f, 0.02208107f, -0.02885920f, -0.08167896f, 0.15183084f, 0.05503893f, -0.08431955f, 
    0.00706688f, -0.37475502f, 0.59504783f, -0.70579422f, 0.05976458f, 0.07618997f, -0.05984578f, 0.16164847f, 
    -0.19153710f, 0.23276292f, 0.05580996f, -0.28170222f, 0.23797296f, 0.41442111f, -0.14811282f, 0.35350141f, 
    -0.07495055f, 0.28998846f, -0.07208422f, 0.19481847f, -0.08457839f, 0.08142955f, -0.05512790f, 0.00199286f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.27204901f, 0.16733922f, 0.09847119f, -0.07847817f, -0.12961319f, 0.05224851f, 0.03147778f, -0.15037858f, 
    0.09576749f, 0.10042657f, -0.00908202f, 0.01715204f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
