#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.09524938f, 0.25879383f, 0.14396746f, 0.44793355f, 0.09415342f, -0.29016000f, -0.29371497f, 0.44279417f, 
    0.28549969f, 1.10893285f, -0.87855190f, 0.06466039f, 0.08887992f, 0.00066026f, -0.22506835f, -0.13671876f, 
    0.10075938f, 0.10039058f, 0.28652212f, 0.65250367f, 0.40252686f, 0.16138865f, -0.28411835f, -0.10174690f, 
    -0.48656088f, -0.47056779f, 0.74810869f, -0.59172589f, -0.69646448f, 0.30763662f, 0.06336218f, -0.27913064f, 
    0.38883972f, -0.29329214f, -0.38594601f, -0.12103450f, 0.16363078f, -0.42513183f, -0.39451846f, 0.11627834f, 
    -0.14150949f, 0.04068971f, 0.34395236f, 0.65980613f, 0.05127676f, -0.76509666f, 0.40121880f, 0.28320026f, 
    0.73130214f, -0.45777982f, -0.38714835f, -0.11216730f, -0.29323635f, -0.23379858f, -0.39744762f, 0.76334232f, 
    0.20068018f, -0.34670624f, 0.00832267f, 0.56649828f, 0.63363713f, -0.03099032f, -0.53743774f, -0.63738406f, 
    0.78796524f, -0.24677460f, -0.52455169f, -0.03904339f, 0.43012294f, -0.29520425f, -0.15066741f, 0.03454624f, 
    -0.78300810f, -0.67870414f, -0.30674589f, 0.29034671f, 0.59101218f, -0.24954438f, 0.10047465f, -0.12055760f, 
    -0.37043080f, -0.27025172f, 0.43290171f, 0.16913396f, 0.72468626f, 0.38286287f, 0.76702011f, -0.25398314f, 
    0.02370012f, 0.20234889f, -0.08243705f, -0.09393503f, -0.44718978f, -0.61031806f, -0.25462225f, -0.51972151f, 
    -0.20318484f, -0.41819316f, 0.23524433f, -0.57518536f, 0.20021175f, 0.43701369f, -0.46915689f, -0.64728200f, 
    -0.12951885f, 0.57374889f, 0.20668620f, 0.13473114f, 0.15451911f, 0.35729179f, 0.53081381f, 0.31503639f, 
    -0.33830798f, 0.42729285f, -0.11721027f, -0.14154515f, -0.55551708f, 0.67607689f, -0.53484178f, -0.20853359f, 
    -0.49515700f, 0.06545956f, -0.15999061f, -0.36626843f, -0.31894007f, -0.26200408f, 0.61890817f, -0.00809968f, 
    0.20190135f, -0.67243803f, 0.25373688f, 0.20182967f, 0.17245054f, 0.22624989f, 0.50822508f, 0.21211892f, 
    0.32204622f, 0.43265909f, 0.58767366f, -0.91641778f, -0.45778254f, 0.02945131f, 0.06957500f, 0.02281798f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.17966472f, -0.15687551f, -0.10243957f, -0.08664621f, 0.35668927f, 0.13440096f, -0.09165183f, 0.33678380f, 
    0.13771571f, 0.07694391f, -0.22636087f, -0.00852916f, -0.10320507f, -0.13052616f, 0.33376813f, -0.13199142f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.18079178f, -0.26815480f, -0.03801637f, -0.04842975f, 0.14819098f, 0.11949691f, 0.15418902f, 0.04078746f, 
    -0.01896893f, -0.07334426f, -0.66985428f, -0.04257428f, -0.10106765f, -0.12893252f, 0.24474452f, 0.07797176f, 
    -0.21674645f, -0.13562828f, -0.09021409f, -0.16869226f, 0.07097901f, 0.01269850f, -0.08541618f, -0.02098901f, 
    -0.03824176f, -0.03072316f, -0.01460328f, -0.38846993f, 0.03659218f, -0.03192028f, -0.02545737f, 0.12379942f, 
    -0.00795315f, 0.06006517f, -0.05306962f, -0.08671123f, 0.20966659f, 0.23207967f, 0.23786435f, 0.20225911f, 
    -0.07856791f, -0.10392445f, 0.01000561f, 0.13915730f, 0.01778308f, -0.60059673f, -0.41496569f, -0.04874188f, 
    -0.16076943f, 0.22092286f, 0.03136249f, 0.01447510f, -0.09534869f, 0.09477489f, -0.53656483f, -0.08029635f, 
    -0.13835876f, -0.11538647f, 0.05353199f, -0.05519753f, 0.00112972f, 0.18345384f, 0.08755208f, -0.40690109f, 
    -0.08144341f, -0.19865930f, 0.10909177f, 0.11850943f, 0.09051733f, -0.05070550f, -0.05632893f, 0.07523423f, 
    -0.18371086f, 0.05064074f, 0.11226383f, -0.02323172f, -0.15665360f, -0.05467750f, 0.12350952f, 0.02056775f, 
    0.08110336f, 0.12676671f, 0.21362546f, 0.30653223f, -0.15101962f, -0.13333419f, -0.06215794f, 0.09140311f, 
    -0.05620797f, 0.08679334f, -0.06948280f, 0.44813308f, 0.52173847f, -0.03885698f, -0.19203848f, -0.05162987f, 
    0.07232665f, 0.03266366f, 0.06555981f, 0.06170220f, 0.10678219f, -0.17173786f, -0.23971903f, -0.01750275f, 
    -0.07731178f, 0.03833184f, 0.00050456f, 0.01189834f, -0.24564373f, 0.04888508f, -0.23354438f, -0.14147308f, 
    -0.09590445f, -0.16675960f, 0.03119214f, 0.01305623f, -0.03524165f, 0.29328445f, -0.27473989f, -0.02553404f, 
    0.19935316f, -0.19834477f, 0.17714900f, 0.12080023f, 0.01254250f, 0.08534544f, -0.03226691f, 0.16134307f, 
    0.22682571f, 0.10406563f, 0.15860881f, 0.15463145f, 0.04718869f, 0.10835301f, -0.04305336f, 0.27604711f, 
    -0.37625697f, 0.10237432f, -0.11844784f, -0.02950465f, -0.14608173f, 0.03166237f, 0.03780095f, -0.06212281f, 
    0.05299773f, 0.21776780f, 0.05377981f, 0.24990301f, 0.03880002f, 0.04889546f, 0.26911262f, -0.09298325f, 
    0.06571079f, 0.38500774f, -0.11525302f, 0.24402170f, -0.05678227f, 0.03298827f, 0.18535061f, -0.08915884f, 
    0.08067057f, 0.27200505f, -0.09653188f, 0.20817873f, 0.05476172f, 0.13745719f, 0.00039410f, 0.12189484f, 
    -0.00945347f, 0.06520517f, 0.13734508f, -0.01062957f, -0.00852007f, 0.18493588f, 0.03876957f, -0.16809019f, 
    -0.00171804f, 0.04254196f, -0.32786104f, -0.11200440f, -0.03307728f, -0.06911949f, -0.07677012f, -0.05059372f, 
    0.14327228f, -0.16388363f, 0.41243643f, 0.14757232f, 0.17377786f, -0.02665306f, 0.05552699f, 0.07000494f, 
    0.13209385f, -0.17468986f, -0.05488287f, -0.13849503f, -0.14323767f, -0.09385222f, -0.05471619f, 0.28861088f, 
    -0.21389087f, -0.02921909f, -0.00208295f, -0.16021678f, -0.12273771f, -0.02231606f, 0.00016886f, 0.21004443f, 
    0.14780284f, 0.10235258f, 0.07697650f, 0.02816663f, 0.22828808f, -0.02057634f, 0.00132061f, -0.01235065f, 
    -0.03482425f, -0.00597166f, 0.18488675f, 0.08088520f, -0.08194605f, -0.05032737f, -0.06659226f, 0.02304779f, 
    -0.18981114f, -0.35796019f, -0.21237330f, -0.25391760f, 0.04051226f, 0.21243609f, 0.08303326f, 0.03782625f, 
    -0.12217747f, -0.10035854f, -0.18499789f, -0.22455852f, -0.22566919f, -0.08815797f, 0.04516129f, 0.05444573f, 
    0.11411403f, 0.15458815f, -0.07016405f, -0.21577816f, -0.32324153f, -0.09733263f, -0.06227332f, 0.05080139f, 
    -0.08934774f, 0.17960455f, 0.17382611f, 0.34020740f, -0.27033821f, -0.04264231f, -0.18216622f, -0.01594171f, 
    -0.10370420f, -0.08742999f, 0.04207636f, -0.05360575f, -0.01509547f, -0.21425104f, -0.01009042f, -0.17411333f, 
    0.02812410f, 0.09376886f, 0.15408735f, -0.10770098f, 0.08523938f, -0.01695222f, 0.11716212f, -0.09232173f, 
    0.10883715f, -0.02549818f, 0.12652257f, 0.02840049f, 0.08913109f, 0.12910591f, 0.27752843f, -0.66532207f, 
    0.08487120f, -0.07322227f, 0.02083324f, 0.13480122f, -0.09126653f, -0.12664521f, 0.25511405f, 0.05023751f, 
    0.01203767f, 0.07851598f, 0.11714391f, 0.04051800f, -0.03821804f, -0.09015566f, 0.09904766f, -0.00796007f, 
    -0.01642882f, 0.20658618f, -0.30191916f, 0.03889663f, -0.23386225f, 0.11494488f, 0.36274505f, 0.04552984f, 
    -0.07706448f, -0.04149394f, -0.06591846f, 0.52558857f, -0.33931205f, -0.03047939f, 0.06195901f, 0.05232378f, 
    0.07642335f, 0.05836086f, 0.00686149f, 0.02966885f, 0.36366266f, -0.14935911f, 0.15223165f, -0.05029058f, 
    0.10643575f, 0.05649816f, 0.05541471f, 0.13337232f, 0.04304413f, -0.16219902f, 0.16134559f, 0.03663663f, 
    -0.02372110f, 0.07948761f, 0.10279693f, 0.09237054f, 0.10792606f, -0.27296674f, -0.22825263f, 0.08327502f, 
    -0.26047644f, 0.07876597f, 0.01955973f, 0.06506915f, 0.09458616f, 0.11854459f, 0.17095529f, 0.36060390f, 
    0.07266551f, -0.14267749f, -0.24821755f, 0.16291548f, -0.13489097f, -0.02557378f, -0.07183901f, 0.03234607f, 
    0.00477578f, -0.46119505f, -0.04952086f, -0.17902479f, 0.11863125f, 0.15882300f, 0.01676191f, 0.02261131f, 
    0.24181505f, -0.09262134f, 0.05678261f, 0.08636458f, -0.02250907f, -0.05398954f, -0.07525636f, -0.05549020f, 
    0.07027171f, -0.19561645f, -0.09815496f, -0.25485304f, 0.11697241f, 0.04627205f, -0.02057771f, -0.02898950f, 
    -0.13625138f, 0.03501607f, 0.38724005f, 0.02703905f, -0.40855521f, -0.43380159f, 0.12468287f, -0.19910561f, 
    0.13501760f, 0.01677494f, -0.00889883f, -0.64696455f, -0.48540866f, 0.01568200f, -0.08137556f, 0.03557811f, 
    -0.17382286f, -0.12299950f, 0.00626254f, 0.00015015f, 0.05153520f, 0.15767644f, 0.06171176f, -0.05616121f, 
    -0.18440299f, -0.16205885f, 0.08160474f, 0.14020069f, 0.05657734f, -0.34925219f, -0.36325893f, -0.20264207f, 
    -0.04714641f, 0.03456394f, 0.22729355f, -0.11889284f, -0.04757437f, 0.18420878f, 0.47937724f, 0.10552735f, 
    -0.29760292f, 0.07508849f, 0.10788961f, 0.24145150f, -0.06177394f, 0.00725498f, 0.04773085f, 0.08999145f, 
    0.22632937f, 0.08846457f, -0.12152341f, -0.22194396f, -0.13201679f, -0.02360861f, 0.09050979f, -0.04114128f, 
    -0.02980715f, 0.20630673f, -0.30153570f, -0.11565179f, 0.03150900f, -0.28360444f, 0.02749761f, 0.03950199f, 
    0.00294251f, 0.08813351f, 0.13416818f, 0.15955044f, -0.12557012f, 0.08298255f, 0.57373196f, -0.09370577f, 
    0.00854734f, -0.12424465f, -0.07268368f, 0.36990577f, 0.18876326f, -0.08479000f, 0.04491613f, -0.21850109f, 
    -0.02273205f, 0.08923645f, 0.02176959f, 0.06607647f, 0.03984587f, -0.02547808f, -0.03056132f, 0.07386099f, 
    0.02986368f, -0.08722951f, -0.11326335f, -0.00918166f, -0.01623945f, 0.15764736f, 0.05864624f, -0.11978123f, 
    -0.06049701f, -0.16056229f, -0.04431848f, 0.07663006f, 0.04477775f, 0.21733429f, -0.03890746f, 0.37171286f, 
    -0.07237685f, 0.06527462f, -0.30489957f, 0.21582983f, 0.09486829f, 0.10555112f, 0.13257261f, 0.41550612f, 
    -0.10100889f, -0.04978630f, 0.10211255f, 0.06466869f, 0.06093578f, 0.21118474f, -0.09028006f, 0.56392545f, 
    0.29955637f, -0.08926748f, -0.02424395f, 0.26630765f, 0.08655085f, 0.15266758f, 0.05001571f, -0.02907760f, 
    -0.14199248f, 0.15293361f, 0.25298285f, 0.01798200f, -0.11765383f, 0.01609772f, 0.01760325f, 0.04338820f, 
    0.01701752f, -0.14350352f, 0.28233543f, -0.16345508f, -0.17038427f, -0.07988799f, 0.03126583f, 0.00260465f, 
    0.08370203f, 0.06390417f, 0.19109671f, 0.24075796f, 0.60096931f, -0.04360950f, 0.04743854f, -0.14174713f, 
    -0.14807811f, -0.10454910f, 0.29881576f, 0.17013884f, -0.06356194f, -0.20620742f, -0.00978962f, 0.06373163f, 
    -0.20816548f, 0.16552968f, 0.08515190f, 0.32770923f, -0.45507601f, 0.27451599f, 0.06836932f, -0.14647132f, 
    -0.26393503f, -0.34094110f, -0.23630999f, 0.09386858f, 0.02484166f, 0.24233349f, 0.05602635f, 0.26560703f, 
    -0.04701508f, -0.07687111f, 0.08222947f, -0.04940896f, 0.10070750f, 0.20754105f, -0.06298575f, 0.16217467f, 
    -0.12919657f, -0.05130701f, 0.00836961f, -0.06653564f, -0.07031657f, 0.14211231f, 0.10230694f, 0.09397244f, 
    0.20236926f, 0.42545417f, -0.24407189f, 0.12580064f, -0.35479784f, 0.23584077f, 0.06082844f, -0.08113731f, 
    -0.15804534f, -0.19061525f, -0.02956103f, 0.14270414f, 0.07139189f, -0.11533122f, 0.15622687f, -0.00933298f, 
    -0.10418565f, -0.54945183f, 0.02652967f, -0.18751234f, 0.07830298f, 0.04442832f, -0.12736616f, 0.01914608f, 
    -0.01374880f, -0.02520055f, -0.45362028f, -0.07953201f, 0.28376839f, -0.01233785f, 0.10533945f, -0.10476950f, 
    0.13447301f, 0.06903967f, -0.23234117f, 0.40101096f, 0.08217838f, -0.12602212f, -0.10100143f, 0.02400738f, 
    -0.03363079f, 0.02429632f, 0.11903798f, -0.04334914f, 0.24050784f, 0.09999242f, -0.00034933f, -0.05227959f, 
    -0.10428324f, 0.05782459f, 0.03066044f, -0.01547600f, -0.02826506f, 0.17966305f, 0.25164697f, -0.12593919f, 
    -0.19831578f, -0.02305909f, 0.06376867f, 0.05808341f, 0.03859622f, 0.09484516f, -0.19141427f, 0.08242373f, 
    0.05717423f, -0.01289136f, -0.02125483f, 0.00920605f, -0.00714721f, 0.01486493f, 0.09113520f, -0.07313894f, 
    -0.16310084f, -0.15746836f, -0.02048106f, -0.08285617f, 0.13831615f, -0.00747460f, 0.11128372f, 0.06250026f, 
    0.25775054f, -0.07201388f, -0.05186937f, -0.00222698f, 0.02060461f, 0.00973296f, -0.03587488f, -0.03752256f, 
    0.04542781f, 0.29907185f, -0.32334280f, -0.42026478f, -0.18545578f, -0.09505318f, -0.20215303f, 0.10718001f, 
    0.20195830f, -0.01168409f, 0.29054183f, 0.14959399f, -0.04301776f, -0.00197981f, -0.10520627f, -0.06138664f, 
    0.08620189f, 0.13138658f, 0.06409703f, 0.21746610f, 0.34458613f, 0.24072623f, -0.25946710f, 0.00394161f, 
    -0.27607033f, 0.08349630f, 0.18824941f, 0.00653712f, -0.36381117f, -0.43561956f, -0.05501021f, -0.16632503f, 
    0.04772475f, -0.07934236f, -0.05954911f, -0.09848884f, 0.00905014f, 0.10150168f, 0.17330150f, 0.00055198f, 
    -0.12128419f, -0.08879635f, 0.11938152f, -0.09931593f, 0.06226120f, -0.08410121f, -0.52808338f, -0.21401773f, 
    -0.06000049f, -0.10296160f, 0.05912245f, -0.01744964f, -0.04499067f, -0.03837944f, -0.04116303f, 0.16158321f, 
    -0.03762944f, 0.19717605f, -0.26152676f, 0.19338374f, 0.09413211f, -0.07767842f, 0.05892209f, -0.02912672f, 
    0.04699395f, -0.42599410f, 0.15790676f, 0.19679311f, -0.08622738f, 0.03146868f, -0.02112309f, 0.15526606f, 
    -0.01262653f, 0.32380819f, -0.14044015f, -0.89529151f, -0.11881540f, 0.01030243f, -0.10567191f, 0.03398287f, 
    -0.03201196f, -0.03428829f, 0.12989363f, -0.08619063f, -0.01504773f, -0.02184160f, 0.05466462f, -0.03832814f, 
    -0.05188107f, 0.04210785f, -0.02099045f, 0.12086481f, -0.04091888f, 0.17581068f, 0.02303818f, 0.05645087f, 
    0.13524385f, 0.13380046f, 0.15569751f, -0.10175023f, 0.08212750f, 0.10920612f, 0.00965701f, 0.02046474f, 
    0.08082409f, 0.09556953f, 0.05862330f, 0.11068137f, 0.02893473f, -0.38876161f, 0.18502927f, -0.00531467f, 
    0.03025127f, 0.03267070f, 0.03937005f, 0.07186914f, 0.16724338f, -0.04544986f, -0.19488080f, -0.41638303f, 
    0.14242579f, 0.02497732f, 0.05994209f, -0.03978580f, -0.06818829f, 0.13581277f, 0.06594774f, -0.62802595f, 
    -0.04803558f, 0.08816984f, 0.00935522f, -0.02203957f, 0.08254189f, 0.13954186f, 0.05911483f, -0.09407651f, 
    0.43940797f, -0.04822681f, 0.18354866f, 0.19145717f, -0.08493751f, 0.10973183f, 0.10207077f, 0.06468177f, 
    -0.03922397f, -0.00770296f, -0.39546540f, -0.53176254f, -0.12815709f, -0.04144053f, -0.03670937f, -0.05991899f, 
    0.04460970f, 0.20928711f, 0.13838659f, 0.07036043f, 0.13083369f, -0.04248226f, -0.00003890f, -0.05722123f, 
    -0.06456788f, -0.04797686f, 0.11722238f, -0.25318143f, 0.03817395f, 0.35877880f, -0.11410251f, 0.09534385f, 
    -0.20692344f, 0.01641903f, 0.01514939f, 0.12980404f, 0.16097657f, 0.03300411f, -0.11947957f, -0.01716802f, 
    -0.03171461f, -0.07314312f, 0.01884041f, -0.11330504f, -0.05580634f, 0.25194770f, 0.22932655f, 0.27729389f, 
    -0.03302586f, 0.05347957f, 0.11351068f, -0.05507227f, -0.00129062f, 0.05747941f, 0.07846993f, 0.13575776f, 
    -0.05875043f, -0.07038997f, 0.09395159f, -0.09858562f, 0.06638486f, -0.00471067f, -0.01473008f, -0.41402772f, 
    -0.48705390f, -0.15774013f, -0.12683572f, -0.11970720f, -0.32929942f, 0.02383217f, -0.04082325f, 0.15313451f, 
    0.35148436f, 0.11128808f, 0.14835402f, -0.07359035f, 0.03499275f, 0.23984589f, 0.03696788f, 0.09089386f, 
    -0.10886491f, -0.19799103f, 0.37691885f, -0.14356232f, 0.07706425f, 0.05372723f, -0.02004175f, 0.30304930f, 
    -0.00287060f, -0.16989423f, 0.30222300f, 0.00419829f, 0.15880129f, -0.28263575f, -0.03858561f, -0.20086354f, 
    -0.08332266f, 0.03646095f, -0.16361178f, -0.06297756f, -0.08823672f, 0.03686652f, -0.01110870f, -0.11187247f, 
    0.10660388f, 0.12836081f, 0.21613090f, 0.05660290f, -0.12475377f, -0.13648023f, 0.29497695f, 0.16447552f, 
    0.05879930f, 0.07236951f, -0.04029866f, -0.00874779f, -0.17167670f, 0.09475734f, 0.13578354f, 0.20641355f, 
    0.32847473f, 0.14812827f, 0.15545139f, 0.19626655f, 0.34415808f, 0.12493116f, 0.07638668f, 0.04833379f, 
    -0.26995340f, -0.07027832f, 0.11371926f, 0.07877353f, 0.04033522f, 0.08996087f, 0.34685865f, 0.23029603f, 
    0.01464076f, 0.00458919f, 0.13872878f, 0.17252092f, -0.02198057f, 0.12496236f, 0.23295555f, 0.36574188f, 
    -0.31999370f, -0.01398911f, 0.05188382f, -0.01926733f, 0.07303101f, -0.03293998f, 0.25067604f, -0.07979818f, 
    0.23838590f, -0.15402590f, -0.39640296f, -0.09934819f, 0.09607616f, 0.12206182f, 0.04030354f, 0.05706943f, 
    0.23369755f, 0.07725926f, -0.02725497f, 0.05019182f, 0.27549979f, 0.14351784f, 0.05557832f, -0.00709067f, 
    -0.14919235f, -0.07652132f, -0.11531876f, -0.05405178f, -0.26674059f, -0.03394550f, -0.08497880f, 0.09807261f, 
    0.20323102f, -0.20629410f, -0.11245110f, -0.39481911f, 0.24272102f, 0.05425457f, 0.09488973f, -0.23052076f, 
    -0.15257272f, 0.13048664f, 0.04188067f, 0.19775110f, 0.06542148f, -0.00482273f, 0.07883725f, 0.16716890f, 
    -0.04489907f, 0.03842129f, -0.05244101f, 0.02186044f, 0.09111805f, 0.16479738f, -0.01401793f, 0.04769745f, 
    0.16542631f, -0.08920769f, -0.08639739f, 0.06230923f, -0.05188717f, -0.00846092f, -0.30946618f, 0.54841346f, 
    0.10760131f, 0.14505050f, -0.09851736f, -0.12615404f, 0.09192159f, -0.03720207f, -0.15673396f, -0.12609452f, 
    -0.00473636f, -0.01139541f, -0.15516239f, -0.00969805f, -0.04236282f, 0.10001310f, -0.02472690f, -0.01527435f, 
    -0.24370064f, -0.40326211f, 0.08958770f, -0.00472721f, 0.17934714f, 0.00078092f, 0.05017135f, 0.12381358f, 
    0.09225817f, -0.26489821f, 0.01471496f, -0.06316181f, -0.04605133f, 0.06939021f, 0.03872440f, 0.00793228f, 
    0.18542728f, 0.06748183f, 0.01935168f, 0.28536093f, -0.04978361f, -0.20050773f, -0.02906641f, -0.01532863f, 
    0.12123373f, 0.05234219f, 0.06856658f, 0.17820871f, 0.09421492f, 0.07633955f, 0.08721761f, 0.12964994f, 
    0.21401250f, -0.00757656f, -0.14222068f, -0.37369129f, -0.17179924f, 0.13111931f, 0.04372616f, -0.02578123f, 
    -0.22540329f, -0.15461144f, -0.10481791f, 0.13965149f, -0.02300382f, 0.09233262f, -0.18704703f, 0.30614170f, 
    0.00627923f, -0.20524426f, 0.13209693f, 0.06229024f, -0.05469715f, 0.08138221f, -0.06118978f, 0.04052548f, 
    0.12301463f, -0.19633606f, -0.09988266f, 0.10030027f, -0.13590632f, -0.06164400f, 0.02111604f, 0.07233990f, 
    0.22839426f, -0.08574618f, -0.11765688f, 0.01966286f, 0.15773794f, 0.20266137f, 0.00092115f, 0.00820710f, 
    0.13947946f, 0.00562998f, 0.18220443f, 0.04137755f, 0.14311205f, 0.10012583f, 0.12729560f, -0.00379990f, 
    0.02122261f, -0.19983485f, 0.15408266f, 0.05364960f, -0.01743229f, 0.18141854f, -0.00951263f, -0.03148638f, 
    -0.13424905f, -0.25100783f, -0.02046795f, 0.19274989f, -0.02136815f, -0.05013318f, 0.39802438f, 0.00115858f, 
    -0.07377248f, -0.08948378f, 0.15456614f, -0.20371392f, -0.03392319f, 0.19435541f, -0.20025627f, -0.09989145f, 
    0.15113144f, 0.02324925f, 0.17636164f, -0.04587243f, -0.11451983f, -0.12306704f, 0.02847397f, -0.05198959f, 
    0.16885218f, -0.13725054f, 0.10950493f, -0.14994015f, 0.18550679f, -0.01034589f, -0.12134445f, 0.06651930f, 
    -0.26087868f, 0.07913577f, 0.03396244f, -0.08420384f, 0.07862264f, -0.17748886f, -0.16612500f, 0.39364991f, 
    0.20933051f, -0.12464944f, 0.00371679f, 0.06267601f, 0.16735803f, 0.00841805f, 0.24562508f, -0.11556110f, 
    -0.01791675f, -0.05798095f, -0.03959282f, 0.21174300f, 0.07690035f, 0.01545914f, -0.03549896f, -0.00702270f, 
    0.04717840f, -0.45618990f, 0.10681640f, -0.02273321f, 0.02592881f, 0.07284607f, -0.07939189f, 0.13667582f, 
    0.03244314f, -0.10611013f, -0.35109499f, -0.14499137f, -0.21001683f, 0.22747657f, 0.13784623f, 0.01811576f, 
    0.15379934f, 0.26336160f, -0.22610885f, 0.42933407f, 0.13148230f, 0.09747503f, 0.15706582f, -0.20180218f, 
    0.08422228f, -0.11689683f, 0.22766177f, -0.30742550f, 0.11100699f, 0.12257725f, -0.08402235f, 0.04014978f, 
    0.16949107f, -0.14606597f, 0.04808929f, -0.06380097f, 0.13112822f, 0.39922404f, 0.18660229f, 0.03286157f, 
    -0.14860161f, 0.07817587f, -0.03198335f, -0.08357105f, 0.04661911f, 0.04963784f, -0.18502663f, -0.08221599f, 
    -0.12800947f, -0.11204427f, -0.13953774f, 0.01498000f, 0.13834216f, -0.00962191f, 0.26918814f, -0.17761184f, 
    -0.05788012f, -0.11140947f, -0.04183898f, -0.01068383f, -0.06904089f, 0.14459483f, -0.01668783f, 0.06283461f, 
    0.29207259f, 0.06508598f, -0.00266696f, 0.00489597f, 0.04783678f, 0.01134210f, 0.02147013f, 0.07655533f, 
    0.00335663f, 0.35860497f, 0.03596041f, 0.17294689f, -0.19158857f, 0.09493649f, -0.06506977f, -0.09193449f, 
    0.06354002f, 0.13279234f, 0.02330316f, -0.07960135f, -0.08155577f, -0.02349885f, -0.35808891f, -0.00990555f, 
    -0.06405090f, 0.07950713f, -0.09562706f, 0.07083631f, 0.14745946f, 0.04654321f, -0.29209721f, -0.12002929f, 
    -0.11521581f, 0.00405539f, -0.10949146f, -0.02018090f, -0.06156484f, -0.27895284f, -0.03501256f, 0.12961777f, 
    0.12414188f, -0.02383747f, 0.12762779f, -0.15233433f, 0.16886272f, -0.11282109f, 0.05472093f, 0.05423652f, 
    -0.05371767f, 0.20373145f, 0.01911639f, -0.11578522f, -0.13313599f, -0.08017895f, -0.19331317f, -0.18362454f, 
    0.05120173f, 0.07104313f, 0.11057124f, 0.14923023f, -0.02954862f, -0.14063448f, -0.13014995f, -0.37709528f, 
    0.07126472f, 0.13643353f, -0.10962170f, 0.10628285f, 0.01685450f, -0.05022642f, -0.14910577f, 0.01640322f, 
    -0.03337848f, 0.08906723f, 0.21490444f, 0.05276625f, -0.06176496f, -0.15699703f, -0.03314629f, 0.19606778f, 
    0.14981692f, 0.18062407f, -0.02162537f, 0.15596533f, 0.04819239f, 0.10190353f, 0.28159949f, 0.22007394f, 
    0.14188923f, -0.07624302f, -0.25607201f, -0.11981736f, -0.15277970f, 0.09466746f, 0.10165028f, 0.23326644f, 
    -0.10294963f, 0.02183685f, 0.13575388f, 0.08432381f, 0.22600140f, -0.24408145f, -0.06654852f, -0.08404518f, 
    0.08203407f, -0.05663350f, -0.08146079f, -0.10065058f, -0.11626692f, -0.16844866f, -0.21869268f, -0.13286319f, 
    -0.05346886f, 0.01776716f, 0.21433531f, 0.14516982f, 0.29016650f, 0.09320790f, -0.33079174f, -0.06243803f, 
    0.04929553f, -0.10714546f, -0.14309211f, -0.09529129f, 0.00151217f, -0.11918253f, 0.34082830f, 0.06731926f, 
    0.33603293f, 0.09748650f, 0.00992983f, -0.32521155f, 0.02930308f, -0.13689713f, 0.16217144f, -0.12112623f, 
    0.05651607f, 0.13449669f, -0.06219707f, 0.18502617f, -0.19509721f, 0.09301190f, -0.23014964f, -0.07452928f, 
    0.27131787f, -0.02484813f, -0.39286920f, -0.07109912f, -0.26836875f, -0.12148408f, 0.07874385f, -0.12045638f, 
    -0.08460972f, -0.01993038f, 0.15918446f, 0.23619296f, -0.22923021f, 0.13693543f, -0.12295949f, -0.16722776f, 
    -0.30957496f, -0.16070597f, 0.21977380f, 0.26058996f, -0.00007921f, -0.11728732f, 0.05612943f, 0.07834227f, 
    0.03360790f, 0.11029705f, -0.02311310f, 0.01513718f, 0.16734229f, 0.10643832f, -0.06805209f, 0.14623378f, 
    -0.05108378f, 0.17449300f, 0.09213280f, 0.22719918f, 0.13273658f, 0.11053126f, 0.10620879f, 0.10934402f, 
    0.00097517f, -0.05955050f, 0.07503299f, 0.05627134f, -0.12578341f, 0.01231587f, 0.02128223f, -0.14015318f, 
    0.13232277f, 0.12212548f, 0.03293158f, 0.03435833f, 0.02639275f, 0.05147303f, -0.30362278f, 0.03294997f, 
    0.17520341f, -0.04243331f, -0.12133407f, 0.23777638f, 0.10819825f, 0.04349985f, -0.04142121f, -0.12410505f, 
    -0.04171078f, 0.30423647f, -0.14362824f, 0.15363349f, -0.15244269f, 0.06562296f, -0.05931301f, 0.05070724f, 
    -0.03222396f, 0.00371330f, 0.08401993f, 0.09906209f, 0.04041331f, 0.12387098f, 0.21064295f, -0.04202743f, 
    0.15341581f, 0.15299466f, -0.12369628f, -0.08738291f, -0.17659616f, 0.05505726f, 0.04825649f, 0.09512004f, 
    -0.04429990f, 0.23463927f, 0.07931526f, -0.17959663f, -0.11081451f, 0.17359163f, 0.14636362f, 0.08242559f, 
    0.22592577f, -0.18208247f, -0.10454652f, -0.08910121f, 0.04429566f, 0.15512559f, 0.26729527f, -0.11465000f, 
    -0.07512519f, 0.01978995f, 0.05011886f, -0.15834357f, 0.12815350f, 0.13877286f, 0.12428104f, 0.02647172f, 
    0.01298467f, 0.05783937f, 0.13811469f, 0.15615232f, 0.10895306f, 0.15500303f, 0.01916558f, 0.18740113f, 
    0.20560010f, -0.10319361f, 0.05655585f, 0.00432936f, -0.16213460f, -0.15057813f, -0.10165851f, -0.31143069f, 
    0.10372342f, -0.04810677f, -0.17371190f, 0.19723293f, -0.11242537f, -0.01391371f, 0.12610534f, 0.08981885f, 
    -0.02054589f, 0.23036252f, 0.00044721f, -0.10845685f, 0.17758188f, 0.03588328f, -0.10675281f, -0.13519996f, 
    0.15482572f, 0.14034787f, -0.09572285f, -0.01156631f, -0.02421848f, 0.14000474f, -0.17254268f, -0.04522232f, 
    0.01416701f, 0.02501709f, -0.04665845f, -0.17739731f, 0.13207991f, 0.06625785f, -0.02004582f, -0.12223849f, 
    0.03043706f, -0.03364176f, -0.20121251f, -0.20525528f, 0.00782390f, 0.18032821f, 0.22039817f, 0.15123539f, 
    0.14923836f, 0.07795795f, -0.13150233f, -0.08549511f, -0.00373369f, -0.07356407f, 0.04752932f, 0.10016006f, 
    0.05540096f, 0.00050100f, 0.19831806f, -0.19763894f, -0.15566473f, -0.54778630f, -0.13603507f, -0.07087822f, 
    -0.00289763f, 0.16612113f, -0.04949554f, -0.18906763f, -0.24727085f, 0.15000315f, 0.00678177f, 0.07407510f, 
    0.03489595f, 0.08847595f, 0.04001842f, -0.02724335f, 0.02013521f, -0.22792885f, 0.03611855f, -0.09167039f, 
    0.20373839f, -0.01075406f, 0.19819705f, 0.02673936f, 0.17998983f, 0.03171768f, 0.45129395f, -0.37617850f, 
    0.09522615f, -0.05946796f, 0.07793768f, 0.00958241f, -0.09969357f, 0.03000576f, -0.05012413f, -0.03979629f, 
    -0.07858501f, 0.01664508f, -0.03094593f, -0.07847387f, 0.04358837f, -0.06304648f, 0.00981360f, 0.02370253f, 
    0.06858260f, -0.00893077f, -0.02455160f, 0.00523324f, 0.00496745f, -0.09074305f, 0.01007845f, -0.07678089f, 
    -0.03895894f, -0.00531389f, -0.02795972f, -0.00294153f, 0.03482947f, -0.04250508f, -0.07032743f, 0.01321127f, 
    -0.04841412f, 0.04425003f, 0.02753622f, 0.06101443f, -0.09535424f, 0.05038476f, 0.05879802f, -0.07245089f, 
    0.05423938f, 0.02345325f, -0.02445019f, -0.05205053f, -0.04699258f, 0.00862801f, -0.03172046f, 0.05639084f, 
    -0.04055906f, -0.08106136f, 0.03414938f, -0.05797664f, -0.03242809f, -0.01328063f, -0.00882515f, 0.02976451f, 
    0.04874894f, 0.04673232f, -0.01081365f, -0.00834045f, 0.01697313f, 0.02347213f, -0.05105785f, -0.08708725f, 
    -0.05536671f, 0.00562542f, -0.07956126f, 0.06371247f, 0.04122565f, -0.06793673f, -0.06143970f, -0.01695644f, 
    0.00810530f, 0.06694914f, -0.00471968f, -0.04674080f, 0.05724393f, -0.04249098f, 0.06716393f, -0.08357362f, 
    0.05716074f, -0.08365185f, 0.03663890f, -0.03413276f, 0.06749669f, -0.03404315f, -0.08177276f, 0.04959287f, 
    -0.01345422f, 0.01016907f, -0.00085379f, -0.02626348f, -0.03164608f, -0.06669403f, -0.07337761f, 0.04467377f, 
    0.03425227f, -0.05108257f, 0.06469408f, -0.00114890f, -0.09003113f, -0.09549087f, 0.03881851f, -0.01939450f, 
    0.05675897f, -0.08418764f, 0.02775601f, 0.05358287f, -0.00219809f, 0.03168679f, -0.06192053f, -0.06329367f, 
    -0.04592782f, -0.02332622f, -0.04939717f, 0.04699238f, -0.07335091f, -0.08943660f, -0.02780167f, -0.03312329f, 
    0.03511928f, -0.04578600f, -0.03059788f, -0.03494657f, 0.03580701f, -0.05701401f, -0.06831091f, -0.04865554f, 
    0.06076274f, 0.04994294f, -0.03961558f, -0.06684077f, -0.08646557f, -0.06758244f, -0.03322327f, 0.04395728f, 
    -0.09093796f, -0.02667779f, 0.00210496f, -0.07315710f, -0.02386350f, -0.08417638f, 0.05486789f, -0.02460706f, 
    0.06174337f, -0.09439087f, -0.06073724f, -0.01748814f, 0.03382248f, 0.05439055f, -0.02637131f, -0.07779132f, 
    0.04364156f, 0.10548301f, 0.11814097f, 0.09795097f, 0.00400133f, -0.05670236f, 0.05228196f, -0.05866006f, 
    -0.05697881f, 0.33611390f, 0.31957522f, 0.00348349f, -0.22123751f, 0.03623890f, 0.15170942f, 0.26799092f, 
    -0.07474489f, -0.01537596f, 0.13405222f, 0.26587796f, 0.31449869f, 0.07844898f, -0.02830459f, -0.12666230f, 
    0.09433822f, 0.01451226f, -0.03877320f, -0.22378932f, 0.09237587f, 0.01579153f, -0.13880090f, 0.00310156f, 
    -0.08252674f, -0.02706631f, -0.03239130f, -0.00856565f, 0.02769437f, -0.15149404f, -0.37473357f, -0.07687524f, 
    -0.00242242f, 0.08072391f, 0.08086900f, -0.01560547f, -0.04290833f, -0.09542273f, -0.14492960f, 0.10423049f, 
    0.12068626f, 0.26319304f, -0.06091619f, -0.11906698f, 0.04306241f, -0.07877670f, 0.11706509f, 0.07044779f, 
    0.17709379f, -0.04834589f, -0.12338810f, -0.01853723f, 0.07304321f, 0.05483324f, -0.13479482f, -0.21301512f, 
    0.03927530f, 0.01876084f, 0.12670507f, 0.04996570f, -0.05351161f, 0.02730412f, -0.20910966f, -0.02773671f, 
    -0.08729515f, -0.06464823f, -0.09314007f, -0.02370510f, -0.19931623f, -0.19538809f, -0.21597885f, 0.08012974f, 
    -0.04775570f, -0.09367713f, 0.10871814f, 0.15528779f, -0.03515423f, -0.00489002f, -0.21447462f, 0.01198842f, 
    0.08098477f, -0.04371266f, -0.04449955f, 0.32841209f, 0.13409159f, -0.15779498f, 0.01872937f, -0.07892071f, 
    0.14288002f, 0.13664950f, -0.06737594f, -0.09553637f, 0.20730913f, 0.27458358f, -0.01577843f, -0.01861635f, 
    0.21213077f, -0.02017649f, 0.09744842f, 0.27027249f, 0.07060855f, 0.12697493f, 0.08952922f, 0.02273730f, 
    -0.00119458f, 0.05737175f, -0.01106112f, -0.00150677f, -0.02242110f, 0.15435494f, 0.17701891f, -0.05652227f, 
    -0.09270214f, -0.09161422f, -0.07441876f, -0.20354417f, -0.15665832f, -0.10791081f, 0.06913649f, 0.35953709f, 
    0.13719893f, -0.00369332f, 0.02504857f, 0.28859508f, 0.01353313f, 0.00181382f, 0.02526465f, 0.22264244f, 
    0.01731163f, 0.08072215f, -0.18043441f, 0.02528270f, -0.12025598f, 0.18178315f, 0.05538916f, -0.09041211f, 
    0.10589307f, 0.10481514f, 0.05777524f, -0.09772722f, 0.11390096f, 0.12911427f, 0.10539221f, 0.14717123f, 
    -0.05782370f, -0.38607877f, 0.22555904f, -0.56950480f, 0.03802990f, 0.00465487f, -0.01193327f, -0.12862386f, 
    -0.03594672f, -0.19630165f, 0.03414521f, 0.10080043f, 0.26175052f, -0.06837939f, 0.08835210f, -0.16362298f, 
    0.06305286f, 0.13219456f, 0.05568764f, 0.10865831f, -0.25745687f, -0.63020563f, -0.00192404f, -0.09934027f, 
    0.01821570f, 0.01467721f, 0.05652687f, 0.05133555f, -0.34691665f, 0.06516867f, -0.18991208f, 0.03498841f, 
    0.15756883f, -0.02552225f, 0.05880101f, 0.03884350f, 0.03553889f, -0.32245621f, -0.01322283f, -0.12644486f, 
    -0.04738959f, 0.01799012f, -0.01293999f, -0.08327770f, 0.05562174f, 0.00374427f, 0.12011467f, 0.08615423f, 
    -0.29609430f, -0.10208175f, -0.01486804f, -0.08583399f, 0.14612648f, -0.09912156f, 0.02888544f, 0.05478182f, 
    -0.19727914f, -0.01333705f, 0.02859938f, 0.20972297f, 0.08285934f, 0.13808244f, 0.17163229f, -0.01516877f, 
    -0.09664198f, -0.87618566f, -0.59687233f, -0.05960943f, 0.17599505f, 0.26602876f, 0.04523486f, -0.03224732f, 
    0.02804407f, 0.06978462f, -0.11887005f, 0.03859177f, -0.10038771f, 0.15282516f, -0.17348443f, -0.03544555f, 
    -0.05689998f, 0.13803023f, -0.01104941f, -0.14484514f, 0.29891247f, -0.05640465f, 0.05297769f, -0.20102580f, 
    -0.02119370f, -0.24387592f, 0.09587540f, -0.55546683f, -0.24152108f, 0.47090745f, 0.11043225f, -0.01065489f, 
    0.06752215f, 0.12418656f, 0.04260647f, 0.03372367f, 0.28874937f, 0.24287036f, 0.10032829f, 0.00033091f, 
    -0.20153625f, -0.21357919f, -0.04088313f, -0.11562618f, 0.16713636f, -0.43788409f, 0.18010305f, -0.16097300f, 
    0.07223045f, 0.13418306f, -0.11594722f, 0.02601582f, -0.05044912f, 0.02458257f, 0.27023518f, 0.01191004f, 
    0.08045039f, 0.04249648f, 0.00594697f, -0.08046157f, 0.03405233f, 0.20287271f, -0.00119283f, -0.16714153f, 
    0.09594923f, -0.16912529f, 0.05063986f, -0.27958602f, -0.08485599f, 0.12335256f, 0.11434767f, 0.09074956f, 
    0.01674872f, -0.08473510f, 0.07835142f, 0.04430478f, 0.13559318f, 0.07260038f, 0.09820560f, 0.04441249f, 
    -0.09573490f, 0.11666517f, 0.35682887f, -0.41340235f, -0.04909560f, -0.04439100f, -0.05398629f, -0.03552478f, 
    -0.19325840f, -0.39093852f, -0.19392191f, -0.14831609f, -0.05679322f, 0.01925729f, 0.07103902f, 0.00622691f, 
    -0.07900883f, 0.08085575f, -0.00131742f, 0.14971083f, -0.21186148f, 0.18440330f, -0.04516046f, -0.07743915f, 
    0.03264107f, -0.18154763f, 0.19139829f, 0.05315732f, 0.04748576f, 0.31373364f, 0.20111389f, 0.06732024f, 
    0.12538826f, -0.20711023f, 0.01263243f, -0.02743817f, 0.06143224f, -0.02365440f, 0.07501060f, -0.08808351f, 
    -0.02247138f, -0.06221060f, -0.07406882f, 0.19707386f, 0.13019446f, 0.07837220f, 0.23811461f, -0.04434382f, 
    -0.17695002f, -0.07727596f, 0.06780896f, 0.03550934f, 0.01543896f, 0.14910510f, 0.11229049f, -0.16651636f, 
    -0.10163476f, -0.18824217f, -0.13835113f, -0.05614648f, 0.11677751f, 0.13256499f, 0.06683566f, 0.13848311f, 
    -0.34460947f, -0.11784217f, 0.39028159f, -0.06427863f, 0.15118238f, 0.05890766f, -0.06992622f, 0.07681621f, 
    0.21849649f, -0.05640157f, 0.18206143f, -0.15927595f, -0.05210593f, -0.14993648f, 0.18699002f, -0.10553000f, 
    0.05827912f, 0.07835985f, -0.14131978f, -0.13214293f, -0.56923234f, 0.13557066f, -0.11084784f, -0.10363322f, 
    -0.08427959f, 0.00910905f, 0.07043640f, -0.44977134f, -0.47493106f, -0.38023743f, -0.08508737f, 0.07391852f, 
    -0.08086783f, 0.05680903f, 0.05507230f, -0.06611256f, 0.00591752f, 0.20384704f, 0.01917737f, 0.11510192f, 
    0.17279558f, -0.05045346f, 0.18548129f, -0.02126076f, 0.02115826f, -0.37497917f, 0.02257194f, -0.21583360f, 
    -0.03631045f, 0.02775939f, -0.16056594f, 0.12757500f, -0.19784783f, 0.01782891f, 0.34305850f, 0.14698426f, 
    -0.32551804f, -0.11903326f, 0.01879890f, 0.04700227f, 0.23259214f, 0.10907634f, -0.09844887f, 0.06930382f, 
    -0.46239984f, 0.04835581f, -0.00726471f, 0.08278590f, -0.23866977f, 0.17559691f, -0.13533150f, -0.01747589f, 
    -0.01604469f, 0.07280105f, 0.03547945f, -0.04693578f, 0.07729951f, 0.01034083f, -0.00425183f, -0.02212700f, 
    0.02911532f, -0.01599574f, 0.01921548f, 0.02461929f, -0.06279032f, 0.07610291f, -0.06622249f, 0.07272886f, 
    0.04953621f, -0.01600392f, -0.07012564f, -0.01826864f, -0.02757927f, 0.05108841f, 0.07381542f, 0.05645866f, 
    0.06175361f, -0.07700513f, -0.04031282f, 0.06870063f, 0.00827906f, -0.02549504f, -0.03081888f, 0.05586066f, 
    0.04168353f, 0.04576846f, -0.03680072f, 0.03055998f, 0.04282479f, -0.04353812f, 0.06706785f, -0.07919884f, 
    -0.03420093f, -0.03766391f, -0.02763108f, -0.01703356f, 0.03744526f, -0.04322602f, -0.07843249f, 0.07683790f, 
    -0.02442987f, -0.08688398f, 0.04269984f, 0.01809012f, -0.06703746f, -0.04814015f, -0.00791191f, -0.00642787f, 
    -0.04413304f, -0.03371808f, 0.04712431f, 0.03713752f, -0.05121643f, 0.06405640f, -0.08783116f, -0.04593587f, 
    0.03917350f, -0.03350485f, 0.04655450f, -0.02351354f, -0.03618382f, 0.00091678f, -0.07283513f, -0.02768797f, 
    0.02376322f, -0.07815025f, 0.03579949f, 0.05710008f, -0.07037473f, -0.03724607f, 0.02216762f, -0.02659227f, 
    -0.08402642f, -0.01204911f, -0.06389117f, -0.06719026f, -0.03878731f, -0.03834983f, 0.02558364f, -0.00101655f, 
    0.04437749f, 0.06119734f, -0.05477076f, -0.02047727f, -0.05506949f, -0.05458811f, -0.03637877f, -0.03727490f, 
    -0.02546207f, -0.06045507f, -0.07195572f, 0.00852584f, -0.00848802f, -0.02988411f, -0.01302697f, -0.04086148f, 
    -0.00149622f, -0.07493988f, -0.07510184f, 0.04511577f, 0.00710965f, -0.01553103f, -0.07238778f, 0.01451860f, 
    -0.01334833f, 0.06374145f, 0.02024947f, -0.00529936f, 0.04079979f, -0.08340489f, 0.01557728f, -0.05511064f, 
    0.04442331f, 0.00665273f, -0.05713751f, -0.01968393f, -0.03682170f, 0.03767812f, -0.03460407f, -0.05849025f, 
    0.00891894f, -0.04323896f, -0.08408909f, -0.05259340f, -0.05636887f, -0.08180777f, -0.01330728f, 0.03461665f, 
    -0.02732185f, -0.02910726f, -0.05268196f, 0.07181465f, 0.03368404f, 0.05217620f, 0.06901810f, -0.05143797f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.14328924f, 0.19620970f, 0.06175380f, 0.06656133f, -0.06057813f, 0.11063249f, 0.33972105f, -0.16581655f, 
    -0.04148091f, -0.11418135f, 0.13911021f, -0.06443173f, 0.10402700f, 0.07350409f, 0.24677244f, -0.04781502f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.11618913f, -0.00436725f, 0.07470037f, -0.14851080f, 0.11709455f, 0.15961340f, -0.22684102f, 0.02406236f, 
    -0.18760578f, -0.19931573f, -0.04646637f, 0.06428122f, 0.00255733f, 0.14456274f, -0.17343013f, 0.04307358f, 
    -0.01727976f, -0.08412798f, -0.38453889f, 0.31178582f, 0.33611560f, -0.36923617f, -0.14947619f, 0.29815912f, 
    0.06342205f, 0.09200378f, 0.17806803f, 0.00996786f, 0.05306853f, -0.22442040f, 0.09601822f, 0.16862226f, 
    -0.23213591f, 0.16680326f, -0.06575435f, 0.30510893f, -0.46856624f, -0.21382478f, 0.27183101f, -0.06116922f, 
    -0.12532401f, -0.02885326f, -0.30342117f, 0.07118568f, -0.07090432f, 0.28801391f, 0.42401534f, 0.03485934f, 
    -0.16842166f, 0.19467594f, -0.51730531f, 0.22912169f, 0.23948054f, -0.24656713f, 0.30648082f, 0.32533455f, 
    -0.12028488f, -0.04530594f, 0.14750069f, -0.15481856f, -0.13869722f, -0.46582794f, 0.45617399f, 0.11587781f, 
    -0.73699123f, 0.19582787f, 0.29320419f, 0.29631844f, 0.23345605f, -0.30700594f, -0.01219240f, 0.15767320f, 
    0.37693566f, -0.12536196f, -0.11972312f, -0.21243434f, -0.19172978f, 0.43515342f, -0.50291860f, -0.05525268f, 
    0.78777748f, -0.20828013f, -0.30542073f, 0.30982468f, 0.05847799f, -0.19722830f, 0.00803702f, -0.19877765f, 
    -0.02326744f, -0.25664061f, -0.07175500f, -0.08042366f, 0.05847361f, -0.10583122f, 0.00768234f, -0.02643631f, 
    -0.26172560f, -0.18384461f, 0.02169787f, 0.04061933f, -0.19055343f, -0.06971251f, 0.32071182f, 0.17608179f, 
    -0.26427329f, -0.05173439f, 0.04296233f, 0.08189379f, -0.20432188f, 0.48939371f, -0.35957226f, 0.06641843f, 
    -0.18189256f, -0.54766721f, 0.14510061f, 0.23057133f, 0.68371218f, -0.07610533f, 0.07840253f, 0.25951877f, 
    0.16946530f, -0.13028590f, -0.07988101f, 0.12753271f, -0.35875788f, -0.27724025f, -0.25648767f, 0.18405290f, 
    -0.08875088f, -0.14919494f, 0.29443002f, -0.01368108f, 0.34127659f, -0.03800293f, 0.28681898f, 0.36427280f, 
    0.32867312f, 0.02530029f, -0.42542768f, -0.25489882f, -0.02669735f, -0.05103423f, 0.24457625f, -0.13952680f, 
    -0.20143077f, 0.48879540f, 0.05024711f, -0.09866238f, -0.17963088f, 0.40533319f, -0.14585650f, -0.13040368f, 
    -0.30998850f, -0.52061552f, 0.31307226f, -0.23907383f, 0.06776755f, 0.16894303f, -0.03631838f, -0.20613708f, 
    0.12259147f, -0.20686445f, 0.24043268f, -0.14304851f, -0.46628082f, -0.26812491f, 0.20309877f, -0.17253299f, 
    -0.09120047f, 0.02934368f, -0.13244279f, 0.02624470f, 0.47994307f, 0.12128828f, 0.24187584f, -0.20110032f, 
    -0.20577028f, -0.26084426f, 0.07783291f, -0.19016419f, 0.19854872f, 0.20683038f, -0.10507598f, -0.20505609f, 
    0.16064450f, -0.07178463f, -0.03726732f, 0.20860942f, 0.16676822f, -0.15130930f, 0.11204689f, 0.00037616f, 
    0.27988914f, 0.13863303f, -0.34205362f, -0.09803627f, -0.32378641f, -0.01482060f, 0.20765604f, -0.16862224f, 
    0.17685999f, -0.06404782f, 0.37428027f, 0.05360856f, 0.20981851f, -0.23028021f, -0.25063816f, 0.15107286f, 
    -0.98574102f, 0.29262814f, -0.13150159f, 0.26160479f, -0.15062988f, 0.21156026f, 0.17159399f, -0.42972869f, 
    -0.12394004f, 0.02472060f, 0.21284540f, 0.03162035f, -0.13492173f, 0.09335591f, -0.27861056f, 0.19173136f, 
    0.06189118f, -0.21116346f, 0.57428598f, 0.12840547f, 0.39895317f, -0.22104193f, 0.14735270f, -0.01355352f, 
    0.46394309f, -0.33105338f, -0.36276767f, 0.08544307f, 0.15258630f, 0.08786120f, -0.05724807f, 0.13118027f, 
    -0.09515928f, 0.01687312f, -0.23145205f, -0.25266621f, -0.14973329f, 0.00033162f, 0.02341460f, -0.16550006f, 
    0.06735133f, -0.17285550f, 0.12211934f, -0.20287809f, 0.00706576f, -0.22352077f, -0.16694498f, -0.10485175f, 
    0.11329462f, -0.09575710f, 0.50910389f, 0.26076055f, 0.27653340f, 0.44752750f, 0.26666367f, 0.01265060f, 
    -0.17312905f, -0.30338004f, -0.32099476f, -0.03204553f, 0.14080963f, 0.15158117f, -0.35565296f, 0.02318580f, 
    0.48465517f, -0.16591689f, -0.39302379f, 0.09772573f, 0.43374887f, -0.27130440f, 0.32057780f, -0.07838333f, 
    0.28243032f, -0.09787115f, 0.09705161f, -0.23583922f, 0.06158147f, -0.43730736f, -0.08699133f, -0.02590125f, 
    0.16295868f, -0.15266557f, -0.39612767f, 0.23645276f, 0.29030991f, 0.44798872f, 0.05924096f, -0.08825772f, 
    0.32048872f, 0.24378781f, -0.00628468f, -0.05187705f, 0.24111009f, -0.12120427f, -0.31866130f, 0.00308994f, 
    0.07786320f, -0.04979871f, 0.27796072f, 0.14841801f, -0.29980162f, -0.16648161f, -0.13499904f, 0.10344700f, 
    0.32530853f, 0.13470897f, 0.23809421f, -0.05645640f, 0.11252294f, -0.06320573f, -0.53099567f, 0.13592720f, 
    -0.32275307f, -0.03310965f, 0.48866010f, -0.27675036f, 0.08720591f, 0.34887335f, 0.29943854f, 0.06967097f, 
    0.19349262f, -0.35222989f, 0.02105100f, -0.01143657f, 0.33948448f, 0.13316946f, -0.33293307f, 0.00638555f, 
    0.32690364f, 0.43935961f, -0.10186107f, 0.15705772f, -0.25876808f, -0.24989912f, 0.23280214f, 0.16106211f, 
    -0.26214877f, -0.57145947f, 0.03107836f, 0.22337723f, -0.47720823f, -0.37977505f, 0.34722769f, 0.01375051f, 
    -0.72442800f, 0.36747470f, 0.13992161f, 0.06741875f, 0.14614376f, -0.26287293f, 0.07274708f, 0.24164292f, 
    0.16969374f, -0.08895263f, 0.07903575f, -0.21470110f, -0.45734769f, 0.37024873f, -0.31461227f, 0.20791876f, 
    -0.36140829f, 0.36899856f, -0.41029477f, 0.10171609f, 0.30265045f, 0.31426001f, 0.01225690f, -0.30499077f, 
    0.61801201f, 0.01748294f, 0.04092399f, -0.15134975f, 0.03364016f, -0.47814643f, -0.11934549f, 0.08923545f, 
    0.38552299f, -0.04274897f, -0.35202864f, 0.04901031f, -0.27330688f, 0.06134825f, 0.25290978f, 0.22970645f, 
    -0.09156268f, -0.06795891f, 0.21783668f, 0.06222652f, 0.07696308f, -0.42119348f, -0.04799442f, -0.04787013f, 
    -0.19199029f, -0.10733234f, -0.23781973f, -0.03376366f, -0.11901928f, 0.02480794f, -0.03112541f, -0.11419684f, 
    0.01081412f, -0.07265888f, -0.02685136f, 0.18010302f, 0.16122738f, -0.19003762f, 0.06661846f, -0.14205617f, 
    -0.09596584f, 0.42236730f, 0.42132211f, 0.36004722f, -0.25648573f, -0.28552338f, 0.12069897f, -0.19131255f, 
    -0.36082017f, -0.15220270f, -0.04404630f, -0.01181137f, -0.21866764f, -0.07853736f, 0.25634477f, 0.24760263f, 
    -0.14833844f, 0.23081338f, -0.17364238f, 0.24836081f, -0.51157784f, 0.13701539f, -0.03525577f, -0.27503723f, 
    -0.48601696f, 0.18494643f, 0.10173465f, 0.01520743f, 0.16854614f, 0.08321873f, -0.02008425f, -0.07514460f, 
    -0.18038668f, -0.16129312f, 0.47809646f, -0.16282833f, 0.08647722f, 0.33478743f, -0.11914033f, -0.15687084f, 
    0.37713903f, 0.31221044f, 0.17254663f, -0.13685130f, 0.37258339f, 0.33292142f, -0.16476041f, 0.15780669f, 
    0.01041489f, 0.11236586f, -0.10380886f, -0.15527456f, 0.16064923f, 0.01260776f, -0.22512217f, -0.10816886f, 
    -0.19348145f, -0.10145522f, 0.18466477f, 0.01162324f, -0.01610372f, -0.21720403f, 0.15674961f, -0.06031962f, 
    -0.47982129f, 0.42690462f, 0.05834873f, 0.00165186f, -0.06050153f, -0.15450177f, 0.23106626f, 0.03253126f, 
    0.20528051f, -0.38163564f, 0.03509086f, 0.06168556f, -0.57686925f, -0.48602286f, 0.57263178f, 0.11249396f, 
    0.49492261f, 0.39673865f, -0.02567223f, 0.35033655f, -0.29314071f, -0.25799048f, -0.16752446f, -0.14952755f, 
    -0.10325710f, 0.17473748f, 0.25240719f, -0.05008071f, 0.03122328f, -0.03819045f, -0.00954653f, 0.22423550f, 
    -0.14092191f, -0.03253907f, 0.19872434f, -0.20188506f, 0.21635252f, 0.01451910f, 0.02181893f, 0.05678516f, 
    -0.19560365f, 0.11716223f, -0.14682697f, -0.10137943f, -0.15512866f, -0.11171506f, -0.10554846f, -0.05279231f, 
    -0.42730778f, 0.31004053f, 0.07096803f, -0.19632153f, -0.37382475f, 0.27820677f, 0.11174624f, -0.06122550f, 
    -0.35757467f, 0.41466299f, 0.18739010f, 0.05891510f, -0.09052242f, 0.28367141f, 0.20109542f, -0.16117559f, 
    0.03046330f, -0.05281435f, 0.04634430f, 0.12930281f, -0.16826868f, -0.17857756f, 0.33046997f, 0.24927293f, 
    -0.17876948f, -0.19109263f, -0.20498061f, -0.20840095f, -0.24266498f, -0.07929070f, 0.57191002f, -0.24165511f, 
    -0.30469185f, 0.29246128f, 0.06048332f, 0.25117409f, 0.01102168f, 0.07942329f, 0.05277502f, -0.49352220f, 
    0.13253631f, -0.28539056f, 0.31592321f, 0.01190204f, -0.03124407f, 0.29294872f, -0.60095078f, -0.23871376f, 
    0.00759200f, -0.06129852f, 0.39716360f, -0.00273259f, -0.43230852f, -0.40056369f, 0.13716894f, -0.17109856f, 
    -0.27323788f, -0.13864559f, -0.10927409f, 0.17557044f, 0.47949231f, 0.12153806f, -0.01677587f, 0.14654893f, 
    0.30004919f, 0.24678048f, 0.06697865f, -0.09662261f, 0.24281447f, 0.56794637f, -0.15442874f, 0.20280933f, 
    -0.29993504f, -0.11300432f, -0.24817310f, 0.08694778f, 0.12467739f, -0.22457303f, -0.06101493f, 0.07657895f, 
    0.23273517f, 0.11123028f, 0.40479150f, 0.27915812f, 0.12159484f, -0.40056118f, 0.33144692f, 0.27671501f, 
    0.23502325f, -0.39957890f, 0.29434183f, -0.15771630f, -0.21569575f, -0.50599396f, -0.35830650f, 0.15081300f, 
    -0.02597177f, 0.29588354f, -0.32957241f, 0.15384400f, 0.01522137f, 0.38827178f, 0.16066013f, -0.04403861f, 
    0.31015766f, -0.20596252f, 0.33353090f, 0.18184435f, 0.00987681f, -0.20359990f, -0.55981493f, -0.00778028f, 
    -0.13255309f, -0.47025898f, -0.01878398f, 0.07463878f, -0.13526149f, -0.30050409f, -0.16182847f, -0.23774928f, 
    -0.31206128f, 0.13397574f, -0.21118101f, 0.24512908f, 0.25263461f, 0.27159560f, 0.20956539f, 0.04448408f, 
    0.06140762f, -0.00796879f, -0.42450362f, -0.28861341f, 0.06845374f, 0.08559488f, 0.22128175f, 0.23617257f, 
    0.33639705f, -0.15208626f, 0.31708986f, -0.04470195f, -0.02273859f, -0.14652379f, 0.17171936f, 0.18613817f, 
    0.40605372f, -0.09923869f, 0.61072761f, -0.17318889f, -0.07310654f, 0.21738867f, 0.05723165f, 0.24105392f, 
    -0.10462864f, -0.43657231f, -0.05607391f, -0.09286006f, 0.19006099f, -0.15815914f, 0.21738192f, 0.24808140f, 
    -0.02042506f, -0.22990292f, -0.09508743f, -0.03714539f, 0.26633230f, 0.62030911f, -0.03704446f, -0.13258347f, 
    -0.24286620f, 0.15011556f, 0.19767742f, 0.18649352f, 0.14899461f, 0.05083019f, 0.05270234f, 0.17313558f, 
    0.06285606f, 0.19762947f, 0.03024589f, -0.06859939f, -0.39728507f, 0.07809106f, 0.06570073f, -0.16749389f, 
    0.04430677f, -0.32119194f, 0.22054918f, -0.08544069f, 0.26996517f, -0.02968038f, 0.51377714f, -0.09880744f, 
    0.04486736f, -0.25647479f, -0.28804082f, -0.21610667f, 0.01271044f, 0.15243547f, -0.09441997f, 0.38888872f, 
    0.44716811f, 0.42336369f, 0.25644195f, 0.19816191f, -0.00888065f, 0.55747354f, -0.11399817f, -0.20309263f, 
    -0.21567605f, 0.27370617f, -0.19270474f, -0.20050089f, -0.16470966f, 0.27083933f, -0.09243694f, -0.07576337f, 
    0.07225358f, 0.57521021f, 0.28906640f, -0.18376385f, -0.15128480f, 0.35785937f, -0.15575084f, 0.00274815f, 
    -0.12913126f, -0.17849725f, 0.00157008f, -0.23795825f, -0.14327371f, 0.08354595f, -0.07012025f, -0.06780496f, 
    0.00564387f, -0.04489186f, -0.06327695f, -0.17273697f, -0.00925347f, -0.03052005f, -0.08071032f, -0.20030490f, 
    -0.23400211f, -0.09290236f, 0.08446431f, -0.14682384f, -0.22264588f, -0.09845629f, -0.16654190f, -0.20790522f, 
    0.00472367f, 0.04585379f, -0.04436035f, 0.22960941f, -0.16129626f, 0.16226965f, -0.16362022f, -0.14582583f, 
    0.04445162f, 0.30809066f, 0.30777475f, 0.36245996f, -0.47514424f, -0.26019055f, 0.08196394f, -0.15007704f, 
    -0.39701137f, 0.02411479f, 0.17871381f, -0.11120780f, -0.01795600f, 0.15785547f, 0.34775281f, 0.20557532f, 
    -0.18246360f, -0.11486375f, 0.45935056f, 0.38967043f, -0.15460145f, -0.15945308f, -0.25973594f, 0.14433128f, 
    -0.50709718f, 0.04914694f, 0.27407685f, 0.11553865f, -0.12540744f, 0.30267102f, 0.08693090f, 0.07117573f, 
    -0.15193224f, 0.11127751f, -0.20183589f, -0.19454665f, -0.01825300f, -0.11452195f, -0.20095101f, 0.15307370f, 
    0.16563749f, 0.01384131f, -0.03123655f, -0.18137726f, 0.12123347f, -0.13063854f, -0.23747759f, 0.09526992f, 
    0.24412882f, -0.09749448f, 0.02653605f, -0.01986640f, 0.48120880f, 0.16469112f, 0.17753765f, 0.44012073f, 
    0.21462920f, 0.04988543f, 0.06648929f, -0.09045083f, -0.19231349f, -0.51595879f, -0.50966662f, 0.00433054f, 
    0.50354022f, -0.32441014f, 0.15802836f, -0.03910166f, -0.05622450f, 0.49435335f, 0.06236262f, -0.13908018f, 
    0.32160059f, 0.17023219f, -0.09709724f, 0.25261131f, 0.25181410f, -0.13041806f, 0.07143112f, 0.08809614f, 
    -0.05228850f, 0.10335825f, 0.10844218f, -0.08642469f, -0.04896839f, 0.44159231f, 0.02906288f, 0.08398200f, 
    -0.35167733f, -0.39047590f, 0.23477527f, -0.06828304f, 0.26987576f, -0.30152097f, 0.26677278f, -0.15264072f, 
    -0.25378451f, -0.13563253f, 0.29899719f, -0.24749328f, 0.18370840f, -0.29324782f, 0.21389121f, -0.12579280f, 
    -0.48523638f, 0.15245616f, 0.04294059f, 0.01589966f, -0.05223358f, -0.38969263f, 0.60417551f, 0.10176957f, 
    -0.20083351f, -0.20647854f, 0.24627583f, -0.14602588f, 0.01759104f, 0.08031249f, -0.08952630f, -0.18522757f, 
    0.12426540f, 0.19376706f, -0.04920816f, -0.23630215f, -0.13620931f, -0.18411946f, 0.17562927f, 0.18661225f, 
    -0.23226191f, -0.10930037f, -0.36327451f, -0.01053629f, 0.37722984f, -0.22527482f, 0.05901329f, 0.45648924f, 
    0.06997091f, 0.31043783f, 0.02162583f, 0.08421929f, 0.06172230f, 0.35244015f, 0.29700360f, 0.19120120f, 
    -0.27864388f, 0.37240747f, 0.27565050f, 0.35890767f, -0.18452382f, 0.06661264f, -0.38824943f, 0.01072325f, 
    0.01963856f, 0.20293218f, 0.11822900f, -0.06750766f, 0.02167517f, 0.10049669f, -0.38838258f, 0.08228424f, 
    -0.39324400f, -0.19955459f, 0.29820046f, 0.11629069f, 0.55997616f, 0.43570563f, -0.15058286f, 0.27253842f, 
    -0.03991380f, 0.15279892f, -0.08823232f, -0.14017349f, 0.16763310f, 0.40517664f, 0.03897892f, 0.22116640f, 
    0.04067668f, -0.01826722f, 0.08427557f, -0.09947077f, 0.51820439f, 0.47275987f, -0.08172104f, -0.13468124f, 
    0.37543067f, 0.28669828f, -0.14605986f, -0.21796863f, 0.00239030f, -0.19115743f, 0.11314534f, -0.23727560f, 
    -0.33053264f, -0.37483266f, 0.23961560f, -0.01828063f, -0.13395630f, 0.27610528f, 0.18816455f, -0.17148945f, 
    -0.05671330f, 0.33340174f, -0.12337050f, 0.01133951f, 0.23047182f, 0.14556624f, -0.22217514f, -0.19401559f, 
    -0.48977154f, 0.19452265f, -0.38372785f, -0.29105753f, 0.20379388f, 0.44147775f, 0.18096170f, -0.07871137f, 
    0.27580157f, -0.31962529f, 0.31050304f, -0.18565583f, -0.19957946f, -0.24714053f, 0.09502707f, -0.03075889f, 
    -0.19296899f, -0.26528779f, 0.08020910f, 0.30674097f, -0.03117074f, -0.04352731f, 0.31977251f, 0.32248744f, 
    -0.02030611f, -0.30111489f, -0.43408117f, -0.08900408f, -0.44266936f, -0.43795407f, 0.32745889f, 0.19254212f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.09533037f, -0.22214594f, -0.05707826f, -0.08632395f, -0.16871203f, 0.26874170f, 0.08124787f, 0.03448753f, 
    -0.38599798f, 0.32209575f, -0.14692742f, -0.11705891f, 0.28982276f, 0.41503939f, 0.24106987f, -0.23631720f, 
    -0.10410025f, 0.20053542f, 0.20641620f, -0.24614140f, -0.24612813f, 0.46046862f, 0.17817605f, 0.14447440f, 
    0.33837295f, -0.03192764f, 0.38611570f, 0.35865071f, -0.09130618f, 0.05077302f, 0.43701902f, 0.15433165f, 
    -0.00920930f, 0.08600693f, 0.37949124f, 0.00821757f, -0.00459938f, 0.01418505f, 0.33300307f, 0.18056259f, 
    -0.06582665f, 0.23686476f, 0.09658364f, 0.17580999f, 0.46765324f, -0.29206920f, -0.05937851f, 0.03239354f, 
    0.16881904f, 0.00733506f, -0.15480237f, -0.16981323f, -0.32570401f, -0.21675706f, 0.55668539f, -0.01826825f, 
    0.07581317f, -0.23253669f, 0.01622955f, -0.30066106f, -0.19705568f, 0.31145203f, -0.12417275f, 0.30370080f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.00152258f, -0.19198349f, 0.05825070f, -0.04758669f, -0.37200215f, 0.47903416f, -0.05353441f, -0.15607384f, 
    0.06571634f, 0.34198621f, 0.02741146f, 0.08106007f, 0.20715988f, -0.19861069f, 0.31082970f, -0.09808394f, 
    0.28754315f, 0.08570542f, 0.16430554f, -0.00471914f, 0.20254399f, 0.24390833f, -0.44615924f, -0.09868793f, 
    0.11598517f, -0.03161568f, 0.13313465f, 0.00785318f, -0.02789535f, 0.06938821f, -0.48509967f, 0.01742129f, 
    0.02990748f, -0.12832753f, -0.10187662f, 0.07849570f, 0.29404506f, 0.20189491f, 0.13863079f, 0.25115606f, 
    0.48185191f, -0.08947441f, 0.50631416f, 0.01308442f, 0.09205018f, -0.56038833f, -0.40359634f, -0.00032821f, 
    0.01074183f, -0.02651148f, 0.07383521f, -0.03998302f, 0.10576949f, 0.17582282f, 0.34823853f, 0.19753598f, 
    -0.09019363f, -0.41516697f, 0.12838270f, -0.19962108f, -0.11864919f, 0.23411164f, -0.41576824f, -0.23430164f, 
    0.00893922f, 0.19786377f, -0.03182692f, 0.20991774f, -0.43152156f, 0.17882071f, 0.08824974f, 0.25652915f, 
    0.24774982f, -0.05536119f, 0.26482350f, 0.10376546f, -0.03017390f, -0.03614577f, 0.17157118f, -0.00480385f, 
    0.09918551f, 0.22866023f, -0.06669312f, -0.36627442f, -0.01227112f, 0.32317799f, -0.16775802f, 0.16972606f, 
    0.06887346f, -0.01083323f, -0.11299355f, -0.00601703f, -0.51736701f, -0.02977115f, -0.02876953f, -0.25688401f, 
    -0.05250505f, -0.31417903f, 0.23581608f, -0.25380731f, 0.26839608f, 0.22751372f, 0.18607412f, 0.13878532f, 
    0.00205515f, 0.06911962f, 0.04088909f, 0.06066797f, 0.01010765f, -0.09963919f, -0.31770200f, 0.11262643f, 
    -0.08069513f, -0.12600179f, -0.40988824f, 0.11312578f, 0.24431852f, 0.00332117f, 0.11907859f, -0.02113700f, 
    0.10598248f, 0.09962180f, -0.49767545f, -0.23302999f, 0.01967839f, -0.11593892f, 0.11553088f, 0.55288827f, 
    -0.11463691f, -0.07083378f, -0.11919010f, 0.03432645f, -0.03647039f, -0.08014712f, -0.06166132f, 0.01735684f, 
    0.01347447f, -0.05243939f, -0.03213948f, -0.01167818f, -0.11742923f, -0.02686422f, -0.09858833f, 0.02689627f, 
    -0.00373523f, -0.02983163f, -0.11956424f, 0.00224031f, -0.09364222f, -0.01868695f, -0.02776452f, -0.06295162f, 
    -0.12498159f, -0.08096111f, -0.03144556f, 0.07472257f, 0.04251759f, 0.00222036f, -0.04811189f, -0.08838841f, 
    0.04970488f, -0.01296107f, 0.03046374f, -0.14974168f, 0.05720565f, -0.04510451f, 0.06671273f, -0.12507345f, 
    -0.01103134f, -0.04269406f, -0.12003866f, -0.04933726f, 0.05187832f, 0.00625123f, 0.07227328f, -0.06458431f, 
    -0.13822091f, -0.10492740f, 0.04024820f, -0.05661898f, 0.01175067f, -0.01991809f, 0.04022316f, -0.06316793f, 
    -0.02982262f, -0.05375815f, 0.06621908f, -0.17766386f, -0.10783428f, -0.08296742f, 0.05023503f, 0.02774999f, 
    -0.08194216f, -0.52667987f, 0.14951117f, -0.07837556f, 0.03037280f, -0.22233403f, -0.07976200f, -0.58583874f, 
    -0.18635762f, 0.54338038f, -0.16935867f, 0.00915173f, -0.05123357f, 0.40297750f, -0.20431392f, 0.09904366f, 
    0.06153290f, -0.04246029f, -0.08039217f, 0.07417755f, -0.14551848f, 0.24166679f, -0.06511975f, 0.27560034f, 
    0.08650563f, -0.11275422f, 0.33644840f, 0.23706603f, -0.16466025f, 0.17547621f, 0.31404698f, 0.22906034f, 
    -0.08392077f, 0.21720248f, -0.05043752f, 0.35488111f, 0.18804631f, -0.04848252f, 0.11328548f, 0.04056803f, 
    -0.16034377f, -0.26801524f, -0.08033106f, 0.08630624f, 0.21600115f, -0.53724074f, -0.03067492f, -0.02665319f, 
    -0.09709883f, 0.21385531f, 0.29244509f, 0.10406444f, -0.15986174f, -0.07578310f, 0.23120947f, 0.48651332f, 
    -0.12741394f, -0.59217477f, 0.30679041f, -0.24803296f, 0.00751799f, 0.00016528f, 0.38508645f, -0.02816403f, 
    -0.10418892f, -0.24757390f, -0.09977342f, 0.04820790f, -0.09397405f, -0.28687203f, -0.03818499f, 0.12080703f, 
    -0.16492188f, 0.15787353f, -0.02218676f, 0.01337764f, 0.31103674f, 0.21068016f, -0.07891833f, -0.04179037f, 
    0.01793366f, 0.18783295f, -0.05057002f, -0.09251861f, 0.17445424f, 0.25867006f, 0.11555120f, 0.27912843f, 
    0.12463868f, 0.06091086f, -0.12602872f, -0.07295506f, -0.15810999f, 0.03304227f, 0.46704286f, -0.18049255f, 
    -0.10180067f, -0.02076078f, -0.13201883f, 0.00941963f, -0.04759675f, 0.03454504f, 0.12811644f, 0.31009179f, 
    0.06839962f, 0.42070547f, 0.10184775f, -0.15121572f, 0.20599045f, -0.10059300f, 0.02830018f, -0.00197220f, 
    0.02009228f, -0.21361186f, -0.71907431f, -0.03209703f, 0.06525539f, 0.05864973f, 0.05207309f, -0.46982250f, 
    -0.05473506f, -0.27162862f, -0.33262035f, -0.42588946f, -0.01118806f, -0.44417822f, 0.63973838f, 0.13812326f, 
    -0.01127729f, 0.06420137f, 0.17564067f, 0.13540609f, -0.46911541f, 0.29117781f, 0.03733099f, 0.07767689f, 
    -0.08479925f, 0.36176917f, 0.16221225f, 0.00215641f, 0.21735696f, 0.12371412f, -0.01248590f, 0.05269961f, 
    0.06322264f, 0.24954458f, -0.02736697f, -0.33738935f, -0.16967663f, 0.40359047f, -0.19324818f, -0.16258484f, 
    0.18099844f, 0.02860045f, 0.24682522f, 0.10480846f, -0.30388951f, -0.04374785f, 0.09544675f, 0.20167567f, 
    0.05305681f, 0.08558511f, 0.32357433f, -0.29795420f, 0.22850807f, 0.16586915f, 0.03002776f, 0.09391656f, 
    -0.30140999f, 0.02992789f, 0.15839654f, -0.01117684f, 0.32778457f, -0.44573265f, -0.25734064f, 0.03898364f, 
    0.00550651f, 0.20196806f, -0.19128382f, -0.08062407f, -0.17676057f, -0.11404309f, 0.32134882f, 0.03109972f, 
    -0.09894998f, -0.04642415f, -0.22245894f, -0.26079080f, -0.12729956f, 0.01451197f, 0.06024325f, 0.09995321f, 
    0.06558856f, 0.22064254f, 0.23949821f, 0.04585873f, 0.10808946f, 0.53488743f, -0.03775293f, -0.05784536f, 
    0.12392778f, -0.17777663f, -0.07596947f, -0.07740308f, -0.22396694f, 0.23864719f, -0.00350288f, -0.05996530f, 
    0.26004353f, -0.24700759f, 0.29906097f, -0.23049250f, -0.20836273f, -0.20352030f, -0.00333004f, 0.09828033f, 
    -0.03048231f, -0.08865838f, -0.03587235f, 0.14695734f, -0.09110224f, 0.05891490f, 0.08068772f, -0.02112971f, 
    -0.00865353f, 0.08655287f, -0.01465971f, 0.07420963f, -0.09157451f, 0.19986218f, -0.23635764f, -0.05169193f, 
    -0.54530329f, -0.33968869f, -0.07298018f, 0.19873472f, -0.09013657f, 0.09468546f, 0.07002126f, -0.00392547f, 
    -0.11364080f, -0.01521858f, 0.21958280f, -0.06261075f, -0.16404121f, 0.19296144f, -0.02496778f, -0.16452987f, 
    0.11367073f, 0.21833903f, 0.11656279f, 0.29113546f, 0.33679765f, 0.21096796f, -0.09241352f, 0.14098333f, 
    0.05764304f, -0.22875449f, 0.16372195f, 0.00328723f, -0.43842342f, 0.12501781f, 0.36253005f, -0.35221371f, 
    -0.04574689f, 0.60561532f, 0.01769327f, 0.02248175f, 0.12938043f, 0.02338363f, 0.26932725f, 0.14297009f, 
    0.25408500f, -0.00600287f, 0.02463811f, 0.01411937f, 0.19128098f, 0.34361431f, -0.33875012f, -0.17943937f, 
    0.06955348f, -0.12365204f, 0.05207271f, 0.21903713f, -0.01867556f, 0.13081762f, -0.18141307f, -0.09808502f, 
    -0.06050994f, 0.10938675f, 0.47917521f, 0.04161439f, 0.23472767f, 0.15875696f, 0.09367039f, -0.06805414f, 
    0.57157290f, -0.02310149f, 0.39412829f, 0.18448018f, 0.26176938f, -0.28074220f, -0.08280981f, -0.02921234f, 
    -0.05756568f, 0.26200020f, 0.04074395f, 0.05641631f, -0.21695869f, 0.02120650f, 0.28175601f, -0.47945535f, 
    -0.04539980f, -0.11134893f, -0.13574378f, 0.13567217f, -0.11957409f, 0.52054334f, 0.14467598f, 0.20295188f, 
    0.07755622f, -0.01937345f, -0.06429996f, -0.06395414f, -0.38041589f, 0.77902222f, -0.16267908f, -0.20220198f, 
    -0.04403101f, 0.09630029f, -0.05776456f, 0.05218504f, 0.04612789f, 0.05666253f, 0.16048601f, -0.04592961f, 
    0.17717592f, 0.22718640f, 0.15643747f, 0.04988855f, -0.23125710f, 0.13938019f, -0.52892292f, 0.01269162f, 
    -0.06244671f, 0.06385025f, 0.16423310f, 0.23710290f, -0.24269444f, 0.03466658f, -0.39807019f, 0.16930258f, 
    0.12145115f, -0.36218393f, -0.14441419f, 0.24968337f, -0.10873403f, 0.06300239f, 0.11954040f, 0.20417625f, 
    0.07287409f, -0.26572683f, 0.13193242f, 0.01119763f, -0.11066794f, -0.65818375f, -0.33609775f, 0.01417725f, 
    -0.01516746f, 0.04213889f, -0.01798145f, 0.07177602f, 0.12062122f, 0.34381709f, -0.01267488f, -0.47233233f, 
    -0.04224834f, -0.64798939f, 0.12746781f, -0.06167747f, 0.14475727f, 0.18158142f, -0.26922783f, 0.06810958f, 
    0.08227635f, 0.16687153f, 0.07552434f, 0.38735542f, 0.07553244f, 0.53275543f, -0.17577869f, 0.38286862f, 
    0.16179687f, -0.23655501f, -0.26623720f, 0.00824792f, -0.04187313f, 0.07233077f, 0.04970808f, -0.12022175f, 
    0.00312030f, 0.22281559f, 0.04606881f, 0.05902751f, -0.52444887f, 0.41703334f, 0.14930311f, 0.04976288f, 
    0.03058119f, -0.08164223f, 0.24212126f, 0.01414971f, -0.49480656f, 0.07189693f, 0.34834036f, 0.28728390f, 
    -0.10585237f, -0.08508842f, 0.41570103f, -0.02496178f, -0.46356449f, -0.16746050f, 0.18762510f, -0.06666727f, 
    -0.03326303f, 0.03047903f, -0.07016709f, -0.14837059f, -0.02009035f, -0.33587831f, -0.23175991f, 0.03378409f, 
    0.06090147f, 0.15371384f, 0.17152718f, -0.00816730f, 0.03444318f, -0.23670377f, 0.00945679f, 0.85113150f, 
    -0.06923454f, 0.06141503f, 0.00322199f, -0.30610067f, -0.13427103f, -0.65572351f, -0.23744038f, 0.28288147f, 
    0.07902863f, 0.29472968f, -0.02999814f, 0.38060787f, 0.10096457f, -0.14378297f, -0.14015986f, 0.13885310f, 
    -0.11153769f, 0.15801692f, -0.40014872f, -0.07845512f, 0.02125696f, 0.19331479f, -0.21704514f, 0.04633046f, 
    -0.19261086f, -0.05469184f, -0.03191975f, -0.17980936f, -0.57235479f, 0.37598753f, 0.34732363f, 0.09664687f, 
    0.07173568f, 0.08408587f, 0.20381404f, 0.11405011f, -0.60815161f, 0.04993926f, 0.44781512f, 0.24481143f, 
    -0.05353955f, -0.06875158f, 0.13384740f, -0.06758020f, -0.31242615f, -0.06095226f, 0.19838697f, 0.06663378f, 
    0.09632809f, -0.04339488f, -0.16338916f, -0.00148409f, -0.03436035f, -0.23262019f, 0.00154527f, 0.03564110f, 
    0.09526803f, 0.12178619f, 0.35480478f, -0.03668077f, -0.02059115f, -0.42497864f, 0.09209493f, 0.92438209f, 
    0.03396699f, 0.09088842f, 0.04693873f, -0.19549295f, -0.16769220f, -0.49037269f, 0.05000687f, 0.25292256f, 
    0.05025738f, 0.03595529f, -0.01129099f, -0.11891334f, 0.01096622f, 0.04882219f, 0.08503490f, -0.05795351f, 
    0.06758089f, 0.02831385f, -0.11729681f, 0.07768585f, -0.14957732f, -0.08265395f, -0.03475916f, -0.10323410f, 
    0.08914848f, 0.02872011f, 0.03206280f, 0.08395047f, -0.11647232f, 0.01226529f, -0.04667872f, -0.01899679f, 
    -0.02572488f, 0.11554378f, -0.02992044f, -0.10615665f, 0.07160886f, -0.03046700f, 0.07905797f, -0.07975636f, 
    -0.05776592f, -0.13529609f, 0.01709293f, -0.15775460f, 0.02147121f, -0.08509250f, -0.08599304f, -0.10075720f, 
    0.08542994f, -0.06176913f, -0.08252608f, -0.06701137f, -0.01339297f, 0.09313397f, 0.05807836f, 0.10755390f, 
    0.03437307f, -0.11697636f, 0.12114736f, 0.01561604f, 0.08020883f, -0.12248566f, -0.00748476f, -0.11241283f, 
    -0.06908752f, -0.04748251f, -0.12049558f, -0.11447696f, -0.10133260f, 0.11001932f, -0.11903158f, 0.00046378f, 
    0.05591933f, 0.38778991f, 0.02561465f, 0.23364894f, 0.23595689f, 0.53252548f, -0.07374531f, 0.15250063f, 
    -0.41412801f, -0.06425987f, -0.72098333f, 0.07281722f, 0.09098149f, 0.27637234f, -0.46934551f, 0.00923934f, 
    -0.08484671f, 0.31262273f, 0.19525297f, 0.31698909f, -0.62024397f, 0.34294066f, 0.26268566f, -0.00132212f, 
    0.19259422f, 0.12491043f, 0.15071173f, 0.06851581f, -0.33700350f, 0.11016731f, -0.03157055f, 0.31590527f, 
    0.02973405f, -0.05788282f, -0.11526816f, 0.23724543f, -0.62524360f, -0.35512000f, 0.07234146f, 0.30921859f, 
    0.12222528f, -0.07614224f, -0.48304433f, -0.15108173f, -0.14477049f, -0.22196496f, 0.21629441f, 0.06597978f, 
    0.01121832f, 0.11967777f, 0.20831220f, 0.04397400f, 0.14984791f, -0.39060202f, -0.18293777f, -0.40404263f, 
    0.10959172f, 0.06538362f, 0.41672081f, -0.37622201f, -0.15199302f, -0.29790249f, -0.17288399f, -0.03234955f, 
    0.01586226f, -0.23483387f, -0.04815254f, 0.23297276f, -0.34733245f, -0.18103908f, 0.06082014f, 0.65876144f, 
    0.10696076f, 0.27225429f, -0.17294942f, 0.06221452f, 0.20170455f, 0.04349465f, -0.30872354f, 0.00681205f, 
    0.11876066f, 0.24800313f, 0.20223142f, -0.28295723f, 0.34081599f, -0.08921200f, -0.02922110f, 0.12893698f, 
    0.22091147f, -0.04419634f, -0.10083693f, -0.16843069f, -0.19990787f, -0.00944471f, 0.00155298f, -0.28975430f, 
    -0.01278875f, -0.07957471f, 0.07086314f, -0.08223755f, -0.15886497f, 0.95705807f, 0.02558695f, 0.14599149f, 
    0.02503201f, 0.40260902f, 0.15962553f, 0.33600590f, -0.21057686f, 0.05482595f, -0.19802998f, -0.11870210f, 
    -0.04388842f, -0.29040381f, -0.20496324f, -0.06538402f, 0.41657135f, 0.07561702f, 0.38129902f, -0.44815162f, 
    0.14055973f, 0.07330304f, -0.24969776f, 0.19751614f, 0.13239589f, -0.04169432f, 0.37479433f, 0.08102842f, 
    -0.00187756f, -0.01499061f, -0.05406765f, 0.02591306f, 0.01438147f, -0.00161817f, 0.09798148f, -0.08916801f, 
    -0.14606078f, -0.08335360f, 0.05282041f, -0.04314154f, 0.03754496f, 0.04930815f, -0.01528260f, 0.00490066f, 
    -0.06743722f, -0.04172778f, -0.00957075f, -0.04220565f, -0.10238085f, 0.03145812f, 0.10910647f, 0.04700451f, 
    -0.10440674f, -0.06602956f, -0.06531683f, -0.11464886f, -0.04615845f, 0.06629580f, -0.00608770f, 0.05683515f, 
    0.00969334f, -0.02033088f, -0.10206106f, -0.06703022f, -0.10051192f, -0.08310284f, 0.05443242f, 0.01916376f, 
    0.05942112f, 0.05371143f, -0.07902588f, -0.14022745f, -0.06818996f, -0.07759707f, -0.02977530f, 0.09874205f, 
    -0.09376678f, -0.01526019f, 0.09843162f, 0.09174874f, 0.07412589f, -0.06846102f, -0.11685462f, 0.06135249f, 
    0.01479910f, -0.07767992f, 0.05469560f, 0.08066643f, -0.10454554f, -0.09741870f, -0.04707884f, -0.01988040f, 
    -0.04337743f, 0.04375565f, -0.11187571f, -0.02485381f, -0.38279262f, -0.07509279f, 0.15650861f, 0.01654543f, 
    0.19330676f, -0.12884891f, 0.16374487f, -0.07524538f, 0.00558432f, 0.11234378f, 0.21424255f, -0.02487328f, 
    0.20512113f, 0.14697310f, 0.39544159f, -0.13232337f, 0.14177071f, 0.05417325f, -0.12586574f, 0.18537897f, 
    0.11697940f, -0.03797646f, -0.33427665f, -0.06774049f, 0.18658227f, 0.10554199f, 0.01775116f, -0.07935048f, 
    0.05924772f, -0.10330492f, 0.13664030f, 0.09836020f, 0.00324697f, 0.58575255f, -0.18074028f, 0.27918556f, 
    0.45928741f, 0.31726673f, 0.05070846f, 0.25836635f, 0.05860351f, 0.04560676f, 0.07204907f, -0.08086810f, 
    0.06498732f, -0.14054200f, -0.32275838f, 0.05618929f, -0.04909211f, 0.09103211f, 0.18109868f, -0.05830077f, 
    -0.04491718f, -0.01071045f, -0.06796682f, 0.07023014f, 0.24277514f, 0.23032713f, 0.66887850f, -0.31560674f, 
    0.02074227f, -0.12867549f, 0.26929736f, 0.17907253f, -0.21731393f, -0.17064054f, 0.25265276f, -0.41539726f, 
    0.00043351f, 0.28472692f, 0.16990870f, -0.11686356f, -0.04528671f, 0.38758084f, 0.04951242f, -0.11934353f, 
    0.13596080f, -0.02801386f, 0.03360919f, -0.22702028f, 0.08183204f, 0.09004398f, -0.00180618f, -0.10297975f, 
    0.04752121f, 0.10301359f, 0.18593588f, 0.15383880f, 0.00560734f, -0.04316064f, 0.12364728f, -0.05457928f, 
    0.03263740f, 0.15321830f, 0.34797519f, -0.02214769f, 0.18866444f, 0.17191948f, -0.19364275f, -0.01200673f, 
    0.22966206f, 0.00608965f, 0.12036775f, 0.39995423f, 0.20000520f, -0.21818295f, 0.00266996f, -0.08002663f, 
    -0.06078012f, 0.15628684f, 0.08791023f, -0.03212630f, -0.30927089f, -0.07979959f, 0.28488067f, 0.25052986f, 
    -0.05440069f, 0.10027564f, -0.09670192f, -0.02345786f, 0.06243566f, 0.33583719f, 0.19626836f, 0.09774575f, 
    0.02522203f, 0.25918794f, 0.14895339f, 0.05279335f, 0.73201603f, 0.22641520f, 0.44093043f, 0.52880841f, 
    0.33797660f, -0.49777585f, -0.18212125f, -0.01927573f, -0.13150783f, 0.14382692f, 0.36418718f, 0.03107791f, 
    0.36704379f, 0.12850028f, 0.21504249f, -0.03385169f, 0.33967528f, -0.41424575f, 0.24167611f, -0.02200343f, 
    -0.08248077f, -0.11333264f, -0.00154091f, -0.18770508f, -0.19455309f, -0.11658359f, -0.34470320f, -0.46131378f, 
    -0.07087201f, -0.22528777f, 0.04243649f, 0.08711279f, -0.29592630f, -0.04305407f, 0.13831517f, 0.13524127f, 
    -0.80138522f, -0.20394619f, -0.25052384f, 0.11288104f, -0.47001377f, 0.21686748f, -0.31120422f, 0.12253533f, 
    -0.02928657f, -0.16960877f, 0.37148607f, -0.04042124f, 0.17618950f, -0.17431267f, -0.10308181f, -0.33360037f, 
    0.04115567f, 0.15394886f, -0.12876177f, 0.26459360f, 0.10038681f, 0.22906385f, -0.06312387f, 0.36480689f, 
    0.06669956f, -0.22226118f, 0.16742431f, 0.19368488f, -0.41045487f, 0.60203528f, 0.08887751f, 0.16252623f, 
    0.10847450f, -0.33238608f, 0.23026493f, 0.06632040f, 0.24604613f, -0.26618719f, 0.18372013f, 0.01335654f, 
    0.02598065f, 0.47596648f, -0.00442809f, 0.13765138f, 0.00762021f, 0.22439055f, -0.36281776f, -0.30988145f, 
    0.25936553f, -0.05297861f, -0.11398610f, -0.05128761f, -0.18895215f, 0.04673954f, -0.41922492f, 0.15017352f, 
    0.04152277f, -0.08663865f, 0.20343792f, -0.20413579f, 0.08237716f, -0.15668061f, 0.24723193f, -0.03133326f, 
    0.34741974f, 0.30441910f, 0.21950106f, -0.02583646f, 0.11999698f, 0.00783660f, -0.19758062f, -0.01537098f, 
    -0.10410263f, 0.05458928f, 0.11513717f, 0.10189155f, 0.22355518f, 0.17767082f, 0.06768586f, -0.05276304f, 
    0.06335171f, 0.05768495f, -0.29994243f, -0.11211587f, -0.23687279f, 0.07768855f, -0.55384248f, 0.14702082f, 
    0.07110527f, -0.03434870f, 0.14793871f, 0.02595194f, -0.17093989f, -0.05288494f, 0.12053876f, 0.07162974f, 
    -0.15732488f, 0.05259487f, -0.05574209f, 0.06639940f, 0.02882170f, -0.09712297f, -0.13192049f, -0.12179695f, 
    0.00584664f, -0.05299603f, -0.05192803f, -0.12759525f, -0.03841259f, 0.00325611f, 0.05205559f, 0.06724109f, 
    -0.02638800f, -0.09402479f, -0.09883679f, -0.08096623f, -0.05595335f, -0.04894890f, -0.10627259f, 0.05215855f, 
    0.06853169f, -0.12513110f, -0.06801478f, -0.07475059f, 0.04481148f, 0.06269258f, -0.13261880f, 0.03079917f, 
    0.07120629f, -0.08635899f, -0.11729294f, 0.08917873f, 0.01925497f, -0.12796645f, -0.03207150f, 0.11941990f, 
    -0.04454030f, 0.00516739f, 0.10980058f, 0.09179522f, 0.01500788f, -0.08048717f, -0.11751066f, 0.10401123f, 
    0.01769231f, 0.01887439f, 0.08169614f, 0.04494274f, 0.06482525f, 0.06155507f, 0.00320230f, -0.15571548f, 
    0.02817620f, -0.01886235f, 0.02700188f, 0.19842392f, -0.20426758f, 0.28423348f, -0.03406250f, 0.14916438f, 
    -0.21770455f, 0.15256301f, -0.61301517f, -0.05634862f, 0.06071522f, 0.17035094f, -0.21968977f, -0.02191856f, 
    -0.07665341f, 0.11471131f, 0.03370323f, -0.22888397f, -0.13881092f, 0.46145955f, 0.01876769f, 0.24905159f, 
    0.08487370f, 0.10343938f, 0.04899574f, -0.15711497f, -0.77811122f, -0.14353316f, 0.38503003f, 0.05583817f, 
    -0.09914996f, -0.11972483f, 0.20552596f, 0.07722146f, -0.41672051f, 0.24874456f, 0.08392979f, 0.26696280f, 
    -0.09578816f, 0.09689414f, -0.12044592f, -0.19950722f, 0.10118992f, -0.33583078f, -0.28855959f, 0.00010657f, 
    0.01361203f, -0.05234230f, -0.35927790f, 0.08709972f, 0.01491771f, -0.29928038f, 0.03739346f, -0.25225487f, 
    0.07008277f, -0.36417750f, -0.17085654f, -0.54455328f, -0.06437103f, -0.68796891f, 0.23261334f, 0.13749263f, 
    -0.01185285f, -0.28491667f, -0.09176286f, -0.15721592f, 0.44604579f, -0.12883627f, -0.02863733f, -0.42083234f, 
    -0.21067813f, 0.14410648f, 0.02621732f, -0.00015322f, -0.11192302f, 0.23834398f, 0.28062832f, -0.05272061f, 
    0.06974839f, -0.06248520f, -0.01973803f, 0.09903935f, 0.10234741f, 0.01015013f, 0.11717878f, 0.01835951f, 
    -0.11933241f, -0.08072706f, 0.22381057f, 0.07238897f, 0.23330382f, -0.03890421f, -0.05210391f, 0.27133065f, 
    -0.09415849f, -0.02489599f, -0.05929652f, 0.33106783f, 0.31689900f, -0.02743083f, 0.09390362f, 0.15479629f, 
    0.40760028f, -0.33493209f, 0.24312630f, 0.00513649f, 0.10954338f, -0.44727820f, -0.02752107f, 0.00071940f, 
    0.04530581f, 0.12937425f, 0.20977682f, 0.05586905f, -0.16067390f, -0.12076388f, -0.00582265f, 0.16176912f, 
    -0.04311744f, -0.33090320f, 0.48449871f, 0.10728779f, 0.14026074f, 0.25318685f, -0.10691293f, -0.27631721f, 
    0.10009211f, 0.24716195f, 0.15616931f, 0.16342379f, -0.31098184f, 0.24936289f, -0.10553247f, 0.06723218f, 
    -0.20460740f, 0.02159101f, -0.30837646f, 0.03612988f, 0.06126403f, -0.00050162f, -0.16394442f, 0.07324237f, 
    0.05862370f, 0.07450255f, -0.01908844f, -0.28563371f, -0.26757497f, 0.61854595f, -0.15251741f, 0.15409875f, 
    0.15005177f, 0.05740781f, 0.10109147f, -0.10583468f, -0.55826634f, -0.09438007f, 0.40291378f, -0.03143888f, 
    -0.04638591f, -0.23864569f, 0.33932120f, 0.02769497f, -0.37533394f, -0.04854931f, 0.18427898f, 0.03624845f, 
    0.09180294f, 0.25833192f, 0.00005834f, -0.01043049f, 0.18103215f, -0.33364555f, -0.22513860f, -0.05710986f, 
    0.10721631f, 0.08907663f, -0.17889801f, 0.11998062f, -0.12874024f, -0.12280715f, 0.20290688f, 0.51342744f, 
    0.09972587f, -0.27397197f, -0.13804099f, -0.26122680f, -0.22720014f, -0.40155104f, -0.00627147f, 0.25390124f, 
    0.05638948f, 0.01766409f, 0.15176530f, -0.04172421f, -0.04834649f, 0.53193396f, 0.07130338f, 0.31098858f, 
    0.17829625f, -0.42734063f, 0.15106814f, -0.01767836f, 0.19475131f, -0.15973216f, 0.25714532f, 0.10086543f, 
    -0.24145283f, 0.20955934f, 0.15219149f, 0.24123655f, -0.01648810f, 0.24397004f, 0.07017023f, 0.02440129f, 
    0.15421996f, 0.10810401f, -0.09094356f, -0.05882281f, 0.02460680f, -0.12170286f, 0.32428631f, 0.20724528f, 
    0.04579544f, -0.09556885f, -0.06519651f, 0.00535708f, 0.05711278f, -0.57514864f, 0.20580782f, -0.08562347f, 
    -0.10274781f, 0.16575401f, -0.04523174f, -0.25675845f, 0.04834535f, 0.24468091f, 0.03762213f, -0.07397664f, 
    0.08881528f, -0.00733548f, -0.21738304f, 0.10200761f, -0.03900656f, 0.12625642f, -0.14281683f, -0.85347021f, 
    -0.01461287f, 0.06561098f, -0.11079979f, -0.15929727f, -0.20331687f, -0.12997815f, -0.14986378f, 0.28794092f, 
    -0.12530352f, -0.14051701f, -0.48360452f, -0.01220201f, -0.04976914f, -0.45936808f, -0.19746357f, 0.03964505f, 
    -0.06808808f, 0.15859739f, -0.23870340f, -0.03364764f, 0.16335399f, 0.22184196f, -0.39690873f, -0.07180900f, 
    -0.00835740f, 0.12368689f, 0.15423666f, -0.18794847f, 0.14641018f, -0.27438328f, 0.06060083f, 0.41429397f, 
    -0.06521627f, 0.07163733f, -0.22339916f, -0.14331846f, 0.20892029f, -0.00660957f, 0.03665625f, -0.26717865f, 
    0.10101632f, -0.09184976f, -0.55072993f, 0.12876019f, -0.28043547f, 0.16778041f, -0.00051198f, 0.13917764f, 
    0.04570062f, 0.30381140f, -0.06786307f, 0.30094051f, -0.05457556f, 0.04775106f, 0.20109245f, -0.01363201f, 
    -0.00257239f, -0.21284735f, -0.29772896f, -0.02451765f, 0.34593281f, -0.01006682f, 0.23696406f, -0.35886210f, 
    0.08887420f, -0.11254265f, 0.07992432f, 0.08213064f, 0.33001915f, -0.21647568f, 0.64065814f, -0.20908616f, 
    0.06182820f, 0.32098770f, 0.05094971f, -0.15505661f, 0.80660790f, 0.00986109f, 0.34472406f, -0.07782501f, 
    -0.12286115f, 0.10426726f, -0.20413846f, 0.08956739f, -0.03788976f, 0.31183818f, 0.03028403f, 0.02169672f, 
    0.25469619f, -0.22626247f, 0.00766506f, 0.07809103f, 0.01240629f, 0.02147597f, 0.55666631f, -0.04989636f, 
    0.01084769f, 0.01332939f, 0.31462234f, 0.22666922f, -0.21494339f, -0.00655328f, 0.09894663f, 0.14011575f, 
    0.04097352f, 0.06816255f, -0.22588368f, 0.36104295f, 0.02791617f, -0.19469585f, 0.23605879f, 0.17199530f, 
    -0.48140159f, -0.42424461f, -0.18088794f, -0.04471474f, -0.27164763f, -0.19546980f, 0.12400870f, -0.01137319f, 
    -0.03869156f, 0.14988378f, 0.42166322f, -0.06368992f, -0.06843796f, -0.38892815f, -0.15699522f, -0.26168728f, 
    0.11280213f, -0.19846918f, 0.60298944f, 0.15066670f, -0.18358146f, -0.00247472f, -0.07508009f, -0.07174373f, 
    0.07839398f, 0.14858158f, -0.06184673f, -0.05943193f, 0.47255328f, -0.07114475f, -0.12358680f, -0.04196182f, 
    -0.03050163f, 0.09016362f, 0.04666438f, -0.02945734f, 0.15712193f, 0.22612399f, 0.15559235f, -0.13009669f, 
    0.13593949f, -0.02750815f, 0.20910808f, 0.19809517f, 0.21820723f, 0.05758438f, 0.23759082f, 0.40753934f, 
    0.04241075f, -0.04845936f, 0.07023156f, -0.01683717f, 0.04751470f, 0.05986942f, 0.12552895f, -0.03258716f, 
    -0.11661319f, -0.11505257f, -0.26141125f, 0.33998767f, -0.07468943f, -0.08839186f, 0.10671133f, 0.16647850f, 
    0.30983585f, 0.07819209f, -0.09451686f, -0.12766369f, -0.05395355f, 0.01623007f, 0.04975215f, -0.11119509f, 
    -0.03166451f, -0.04622331f, -0.20110181f, 0.08555094f, -0.10348281f, 0.08924045f, 0.05220292f, 0.16720586f, 
    -0.10226194f, -0.07805685f, 0.28347933f, -0.04757694f, 0.09827200f, 0.12926012f, 0.36796409f, -0.23153785f, 
    0.08347612f, 0.36030319f, 0.07950746f, 0.13074648f, 0.23408881f, 0.75313854f, 0.06732951f, 0.45213771f, 
    0.13112721f, -0.56968427f, -0.19793542f, 0.12640019f, -0.24507536f, -0.20282167f, 0.01547883f, -0.08367550f, 
    0.00299242f, 0.18369569f, 0.25316879f, 0.04606849f, -0.26400375f, 0.03588133f, 0.10892558f, -0.07878918f, 
    0.09950090f, 0.03244392f, 0.03944946f, 0.00646865f, -0.11477357f, 0.05407849f, -0.19321847f, 0.06999752f, 
    0.10508990f, 0.02554953f, -0.10039931f, -0.09335476f, -0.26758501f, -0.20556569f, 0.15235014f, 0.14898193f, 
    -0.29828119f, -0.01964659f, 0.09990544f, -0.10274334f, -0.14036208f, 0.10894859f, 0.07136764f, 0.04130045f, 
    -0.08693878f, 0.06879869f, 0.20703243f, 0.02362815f, 0.29165581f, 0.15176749f, -0.12178787f, 0.12712969f, 
    -0.09865781f, 0.05309727f, 0.26451027f, 0.22793832f, 0.17612380f, -0.00232771f, -0.46227688f, 0.28987524f, 
    -0.00777607f, 0.05310151f, -0.08793645f, 0.15778053f, 0.22623861f, 0.47890183f, 0.07584816f, 0.24134132f, 
    -0.12318675f, -0.01005262f, -0.52371460f, 0.04745536f, 0.37946764f, 0.22519164f, -0.11804757f, 0.00548301f, 
    0.13234131f, 0.24225336f, 0.35018691f, 0.14612271f, -0.17341432f, 0.02988556f, 0.32146183f, 0.17328763f, 
    0.21336663f, -0.08956274f, 0.00557798f, 0.08941741f, -0.05482715f, -0.02488961f, -0.20476049f, 0.18335851f, 
    -0.01726066f, 0.02315319f, -0.30445769f, 0.53464317f, -0.21370502f, -0.14177479f, 0.26708362f, 0.47372112f, 
    0.13670033f, -0.00263317f, -0.21933958f, 0.08894140f, -0.12866633f, -0.03337708f, 0.31506348f, -0.07683656f, 
    0.02459398f, -0.07295996f, 0.02023809f, 0.14955837f, 0.48906079f, 0.00145560f, -0.03005189f, -0.42327017f, 
    -0.01879902f, -0.15909393f, 0.35996568f, -0.00723984f, 0.15618646f, -0.18950263f, 0.08288029f, -0.19237980f, 
    0.10770984f, -0.22472091f, -0.04696848f, -0.08036921f, -0.44072306f, 0.31636748f, -0.22490114f, 0.14477564f, 
    0.03939178f, 0.04713352f, 0.04421128f, -0.02074553f, 0.06496180f, 0.18737440f, 0.00762187f, -0.10600072f, 
    0.30535644f, 0.27300921f, 0.27806213f, 0.02350138f, -0.13878649f, -0.36100385f, -0.51781529f, 0.34913552f, 
    0.08148928f, -0.07299087f, -0.07749951f, 0.02984527f, 0.16124254f, 0.16404796f, -0.21916860f, 0.17996824f, 
    -0.00124547f, -0.15745921f, -0.28708652f, 0.17551248f, -0.05121948f, 0.56930339f, -0.04839678f, 0.10637015f, 
    0.35784325f, -0.14966519f, 0.07144295f, 0.34460458f, -0.10204420f, -0.12097336f, -0.09545237f, 0.00777109f, 
    -0.07101206f, 0.06077581f, -0.03642599f, -0.03353741f, 0.17013745f, 0.34619579f, 0.13480279f, 0.21572614f, 
    0.05522011f, -0.56314272f, -0.03645925f, -0.10145835f, 0.32264623f, 0.50674582f, 0.11729910f, -0.13414885f, 
    -0.03823769f, 0.25940013f, 0.16935319f, 0.28711078f, -0.12602952f, 0.54110652f, -0.05485015f, 0.03625453f, 
    -0.02280363f, -0.18483245f, 0.02926750f, -0.10506442f, 0.26087067f, -0.16845356f, 0.06510653f, 0.00896213f, 
    -0.11050245f, 0.33291075f, 0.04397596f, 0.09047001f, -0.06138859f, 0.57241315f, -0.03351769f, -0.24451716f, 
    0.18259905f, 0.07813988f, 0.31336290f, 0.12694995f, -0.23040079f, -0.15529232f, 0.13823014f, 0.38675970f, 
    0.11010903f, -0.19378299f, 0.25291526f, -0.05813941f, 0.14377470f, -0.33556727f, 0.30462667f, 0.05651001f, 
    -0.42136979f, 0.13925323f, 0.21786137f, -0.16845335f, 0.32848644f, -0.26025128f, -0.32027471f, -0.04598907f, 
    0.02473947f, 0.06117407f, 0.02436205f, 0.03186702f, 0.02365492f, 0.01651449f, 0.22231221f, -0.13542171f, 
    -0.05085167f, 0.07938997f, -0.00162676f, -0.43134278f, -0.31746718f, -0.27695483f, -0.38636857f, 0.28783026f, 
    0.01801498f, -0.10254217f, 0.23672119f, 0.07570460f, 0.41774043f, -0.53937650f, 0.36103040f, -0.21695729f, 
    -0.06191128f, 0.32582268f, -0.07286105f, -0.02176040f, -0.27716672f, 0.26757565f, 0.11056411f, 0.10289739f, 
    0.28857836f, -0.10653114f, 0.02353319f, 0.06693626f, 0.10393585f, 0.14015672f, 0.36175159f, -0.13569415f, 
    0.00163590f, 0.13032368f, 0.20769385f, 0.12492141f, -0.10126138f, 0.13935302f, 0.29854408f, -0.03275137f, 
    -0.08487865f, -0.00975412f, 0.29268616f, 0.12224539f, 0.33511055f, 0.12787017f, 0.14541449f, -0.07612743f, 
    0.00649688f, -0.09829125f, -0.05138105f, -0.04578847f, -0.03324237f, -0.37344715f, -0.25107640f, 0.05693828f, 
    0.11239862f, 0.11240343f, 0.30279875f, 0.00373150f, -0.19157742f, -0.12981455f, 0.08835270f, 0.50410169f, 
    0.09831485f, -0.19113043f, 0.14839754f, 0.08589297f, -0.12478865f, 0.48605600f, 0.24616262f, 0.14632294f, 
    0.09923066f, 0.11746908f, -0.17888834f, 0.08569888f, -0.00393288f, -0.14430514f, 0.05728977f, 0.07206760f, 
    0.05471929f, -0.02600690f, 0.04415526f, 0.05595852f, 0.02272336f, -0.03834509f, 0.04518372f, 0.05471042f, 
    -0.01770544f, -0.03407785f, 0.03075663f, 0.07589181f, 0.07074557f, -0.09903424f, -0.11877624f, -0.09220134f, 
    -0.05921082f, -0.12299317f, 0.05679263f, 0.07778266f, 0.02469935f, -0.09833974f, -0.04074574f, -0.13589898f, 
    -0.00642179f, -0.11354303f, -0.08098033f, -0.13755825f, 0.05220567f, 0.03249406f, -0.05611262f, -0.04947979f, 
    -0.04879327f, 0.09382521f, -0.15588272f, -0.01971646f, 0.02082923f, -0.02184613f, -0.03530275f, 0.01369521f, 
    -0.13011125f, -0.10780541f, -0.03777746f, -0.11534224f, 0.04670500f, 0.01745364f, 0.05971090f, -0.08459494f, 
    0.10195924f, -0.05264925f, -0.05236409f, -0.07980062f, -0.04318506f, -0.16190892f, 0.01966442f, -0.04069371f, 
    -0.04800050f, 0.22200046f, -0.03786062f, 0.23351452f, 0.25482911f, -0.66125274f, 0.14922611f, -0.03918568f, 
    -0.11996018f, 0.15958042f, 0.00970224f, -0.03592174f, 0.03227197f, 0.36058214f, -0.09714529f, -0.01696463f, 
    -0.03560363f, 0.15652472f, 0.10354237f, 0.06168769f, 0.01459421f, -0.35843271f, 0.42933932f, 0.39019129f, 
    -0.01260563f, -0.05649338f, -0.17262894f, -0.01368034f, 0.01549307f, 0.10307420f, 0.12790157f, -0.17097494f, 
    0.04456909f, 0.22629400f, -0.06831466f, 0.39296722f, 0.09684644f, -0.00362696f, -0.00175704f, 0.28750426f, 
    0.20698728f, 0.19451796f, -0.07565544f, 0.07940596f, -0.08791288f, 0.05842246f, 0.10611426f, 0.04409890f, 
    -0.04186162f, -0.08261181f, -0.02916880f, 0.03069595f, 0.19808966f, -0.11279934f, 0.18960492f, 0.56246263f, 
    0.04567875f, 0.07357863f, 0.08745215f, 0.11949046f, 0.17345142f, 0.12911578f, 0.50663280f, -0.38189778f, 
    0.08896632f, 0.11369979f, -0.03455339f, 0.24585900f, -0.06938510f, 0.71187556f, 0.05663845f, 0.31902581f, 
    -0.17452839f, 0.05597563f, -0.06495519f, 0.02110262f, 0.22026323f, -0.12845542f, -0.19017893f, -0.10228427f, 
    0.01194539f, 0.18972149f, 0.33477136f, 0.06643487f, 0.02916146f, -0.02783304f, -0.06005507f, -0.06930465f, 
    0.23259394f, 0.09230245f, -0.14504835f, 0.11600094f, -0.10665030f, -0.05043800f, -0.40821782f, -0.09022914f, 
    -0.10544202f, -0.15202512f, -0.05039939f, 0.11534992f, -0.08204964f, 0.06492508f, 0.15559268f, 0.28913525f, 
    -0.08364882f, 0.21252234f, 0.04303234f, -0.02504987f, -0.14727436f, -0.18832698f, -0.18830687f, 0.01095025f, 
    -0.12828848f, 0.06291241f, -0.10823251f, -0.11663224f, 0.28065753f, 0.11598574f, 0.08503096f, -0.56786871f, 
    0.12056597f, 0.07085475f, -0.10086919f, -0.10617001f, -0.01587238f, 0.22108902f, -0.40192917f, -0.15914746f, 
    -0.03316362f, -0.07833735f, -0.15542178f, 0.08432494f, -0.08846990f, -0.01302811f, 0.06418165f, -0.06924856f, 
    -0.04278379f, -0.07704149f, 0.03296447f, -0.00936279f, 0.02489817f, -0.11493118f, -0.00716101f, -0.08190133f, 
    0.00665331f, -0.06170316f, 0.03709545f, -0.00922949f, 0.07418496f, -0.10232145f, 0.03390486f, 0.04859388f, 
    0.06539086f, -0.03525250f, -0.13772897f, -0.14506474f, -0.12147006f, -0.02345852f, 0.00285159f, -0.14729862f, 
    -0.10366473f, -0.10916149f, 0.07668700f, -0.02618427f, -0.10813576f, -0.14148954f, -0.08501961f, -0.09008797f, 
    -0.01306668f, 0.00856498f, -0.09105381f, 0.04833330f, -0.09059846f, 0.04425428f, -0.10540268f, -0.08147357f, 
    0.11641930f, -0.03984979f, 0.06747630f, -0.02124007f, -0.14339297f, -0.06354744f, -0.01724472f, 0.11583294f, 
    0.12209073f, -0.12915739f, 0.01894601f, -0.04150385f, -0.14441793f, -0.00100121f, 0.08031875f, -0.05702273f, 
    -0.08437169f, 0.02250823f, 0.05205576f, 0.00399826f, -0.04505280f, 0.02403255f, -0.12203972f, 0.10029851f, 
    0.08207449f, 0.05994226f, -0.07826401f, 0.03532831f, -0.06018524f, 0.06923793f, -0.07636289f, 0.11864682f, 
    -0.11901996f, -0.02541158f, -0.02044694f, 0.02964967f, -0.02002797f, -0.02982388f, -0.05697449f, 0.08818875f, 
    -0.07642239f, -0.03967680f, -0.04150850f, -0.07510528f, 0.07386652f, 0.00493301f, 0.00352517f, -0.05102670f, 
    -0.12137292f, -0.05478764f, 0.12260152f, 0.09963495f, -0.04878981f, 0.03793283f, -0.03517124f, -0.02394207f, 
    -0.06944260f, 0.02518605f, 0.07347675f, 0.09321913f, -0.00787349f, 0.09907269f, -0.11537580f, 0.06794921f, 
    0.03828207f, -0.11302148f, -0.11454497f, -0.07508239f, -0.11512721f, 0.06730433f, -0.10299271f, -0.07491119f, 
    -0.04609960f, -0.11697046f, -0.09861234f, -0.01660870f, 0.03394920f, -0.03837995f, -0.09856993f, 0.04309331f, 
    0.07254297f, -0.19561359f, -0.05985366f, 0.10740835f, -0.47270629f, 0.18775508f, -0.14225525f, -0.20683101f, 
    -0.07602575f, 0.69530004f, 0.19868194f, 0.08321470f, 0.19510102f, 0.06460877f, 0.02624783f, 0.16584353f, 
    0.10086523f, 0.08876462f, -0.01859943f, -0.00979330f, 0.16185202f, 0.42405048f, -0.41133285f, -0.16052511f, 
    0.13517572f, -0.01625820f, 0.30884591f, 0.14315534f, -0.12058638f, 0.13197403f, 0.00590252f, 0.06447124f, 
    0.11652723f, -0.07556201f, 0.24788986f, 0.00188815f, 0.19819885f, 0.21595185f, 0.11751655f, -0.04150150f, 
    -0.13544029f, 0.04494123f, 0.31327924f, 0.06062605f, 0.21154252f, -0.45829588f, -0.19410275f, 0.01106033f, 
    -0.10631853f, 0.15915678f, -0.01846466f, 0.04026504f, -0.06286887f, 0.15386863f, 0.48844340f, 0.37274066f, 
    -0.09786014f, -0.27849650f, -0.05240866f, -0.17378289f, -0.06535726f, 0.12143885f, -0.14893125f, -0.01247745f, 
    -0.08715065f, -0.04642384f, -0.05022365f, 0.00586849f, 0.06622829f, -0.02398226f, 0.09566989f, -0.07428706f, 
    -0.03722753f, -0.12679060f, 0.10457084f, 0.00593044f, 0.09377785f, -0.07425191f, -0.00284932f, -0.12251006f, 
    -0.13900132f, -0.00412673f, -0.06758991f, 0.09142812f, -0.00355747f, -0.09204417f, 0.07447607f, 0.10382082f, 
    -0.06985136f, 0.09553468f, -0.04757548f, 0.08872288f, 0.03032923f, 0.11684643f, 0.09166806f, -0.08624817f, 
    0.12181671f, -0.03772027f, 0.06255440f, 0.04579611f, -0.08958835f, 0.09994698f, -0.05104812f, 0.07753721f, 
    -0.02389753f, -0.09732119f, -0.08585858f, -0.05050593f, -0.02521387f, -0.11344564f, -0.01667174f, -0.08068866f, 
    0.10058527f, -0.08794293f, 0.09786627f, 0.12060660f, -0.09685728f, 0.01735857f, -0.06157624f, 0.09921268f, 
    0.01883695f, -0.00926035f, 0.01749925f, -0.11434591f, 0.10487522f, -0.04257269f, 0.00723132f, -0.05107552f, 
    0.01123044f, -0.01429726f, -0.02793553f, -0.04535028f, 0.06800212f, -0.03906102f, -0.04463352f, -0.02805066f, 
    0.04500957f, -0.10172032f, 0.04144366f, -0.06355092f, -0.07492898f, -0.03333889f, 0.01783037f, -0.06862335f, 
    -0.10000549f, 0.07870200f, 0.10272288f, -0.05884905f, 0.07405727f, -0.05441386f, -0.03451432f, -0.10495524f, 
    -0.03040937f, -0.11576146f, 0.09860535f, -0.10586675f, -0.12490912f, -0.07935159f, 0.05973673f, -0.06613474f, 
    -0.10840552f, 0.02435884f, 0.03076616f, 0.09851372f, -0.11989826f, -0.09844901f, 0.02494946f, -0.01641056f, 
    0.06629306f, -0.06542261f, -0.01298192f, -0.10775000f, -0.03520496f, -0.10868156f, -0.11327957f, 0.08665326f, 
    -0.02749348f, -0.03921053f, 0.03222272f, 0.10176301f, -0.02514260f, 0.04740740f, -0.07641463f, 0.00656429f, 
    0.11666901f, -0.11864306f, -0.01364310f, -0.08935733f, 0.08873084f, 0.08512247f, 0.04726954f, -0.04958928f, 
    -0.10303357f, 0.11247607f, 0.19400388f, 0.33410048f, -0.01114134f, -0.02367400f, 0.06369134f, 0.02882386f, 
    -0.15830941f, 0.08956403f, -0.11021547f, 0.05640731f, 0.22111823f, 0.42319670f, -0.23584589f, -0.11598723f, 
    -0.06495103f, 0.20203055f, 0.03796853f, -0.13340765f, -0.11268885f, 0.02918949f, 0.00501231f, 0.09030096f, 
    0.12381335f, 0.01587957f, 0.09407862f, 0.25201952f, -0.35993826f, 0.04737461f, 0.07893919f, 0.12042651f, 
    0.12244903f, 0.22525465f, 0.16950761f, 0.09459417f, -0.04752483f, -0.19565435f, -0.09005589f, 0.00575263f, 
    -0.17835215f, 0.07272685f, -0.42318177f, 0.19030955f, 0.03993073f, -0.36114910f, -0.01734774f, -0.02570368f, 
    -0.07835452f, 0.17249657f, -0.08817126f, -0.15909620f, -0.06957079f, -0.35200924f, -0.00166917f, 0.61062706f, 
    0.09936215f, 0.10453034f, -0.16727233f, -0.34573838f, -0.31320417f, 0.28055936f, 0.23525414f, 0.04416507f, 
    0.10286851f, 0.06496940f, -0.14045416f, 0.07447543f, 0.09484576f, 0.06995212f, -0.12883443f, 0.01180911f, 
    -0.06085518f, -0.15615818f, -0.00138469f, -0.01727905f, 0.06626131f, -0.04408863f, -0.10878636f, -0.07241763f, 
    -0.01189617f, 0.02580867f, 0.05603912f, -0.10038880f, 0.09304930f, 0.06195451f, 0.05790442f, 0.08031866f, 
    -0.13824336f, 0.05317791f, -0.13791135f, -0.07363542f, 0.08069370f, -0.11633871f, 0.07023511f, -0.11346388f, 
    -0.10033374f, -0.09945998f, 0.02782419f, -0.12618528f, 0.02237134f, -0.00756284f, -0.08580292f, -0.14549978f, 
    -0.05569628f, -0.00368886f, -0.02377937f, 0.06461032f, -0.06067295f, 0.07700974f, -0.06256203f, 0.01545282f, 
    0.04102128f, -0.17190596f, -0.13776569f, 0.10147827f, -0.05310546f, -0.10079464f, 0.02268675f, -0.04489604f, 
    -0.05352075f, -0.01440219f, 0.04881919f, -0.07523275f, 0.03445366f, -0.01490251f, -0.08235595f, -0.10199095f, 
    0.05471809f, -0.11672239f, 0.28068066f, 0.13211562f, -0.11266840f, 0.09905295f, 0.07558139f, -0.48673561f, 
    -0.07144496f, -0.11224519f, 0.12450797f, 0.09510970f, 0.12941307f, 0.30187824f, -0.06170309f, -0.12242829f, 
    -0.13014756f, 0.15147765f, 0.11705621f, -0.22271898f, -0.23634051f, 0.15684037f, -0.03470926f, 0.19430910f, 
    0.09874827f, -0.00339500f, 0.22294144f, 0.28097874f, -0.05422842f, -0.11532811f, 0.31159669f, 0.12707824f, 
    0.06898991f, 0.06149610f, 0.07144443f, -0.37039551f, 0.12657233f, -0.35144487f, -0.20160857f, -0.33729315f, 
    0.66448450f, -0.01636402f, -0.26101068f, 0.05936727f, 0.16145776f, 0.12768094f, 0.02411129f, -0.01641624f, 
    0.00341211f, 0.01166459f, -0.28464019f, -0.03759506f, -0.64408481f, -0.06078597f, -0.19516996f, -0.47698388f, 
    0.10899317f, 0.19806091f, -0.16913238f, -0.01760040f, -0.57045937f, 0.02510211f, 0.23452017f, 0.05992160f, 
    -0.06702079f, -0.04461132f, -0.17029677f, 0.11485298f, -0.23075910f, 0.28786984f, -0.20653516f, 0.25534311f, 
    0.19248533f, -0.36947316f, -0.09976947f, -0.05510973f, 0.20062414f, -0.09316508f, 0.18425535f, 0.12973356f, 
    0.08948994f, 0.38909373f, 0.32394513f, 0.06702934f, -0.23136447f, -0.10704943f, -0.38013649f, 0.16859427f, 
    0.06788573f, -0.08530598f, -0.02930997f, -0.00790250f, 0.07123466f, 0.00481158f, -0.11803804f, 0.02502550f, 
    -0.06944002f, -0.12867895f, -0.08339172f, 0.09366072f, -0.10047252f, 0.06509636f, 0.21191934f, 0.03055586f, 
    0.04695650f, 0.16082808f, 0.09431276f, 0.00119346f, -0.12064821f, -0.13489456f, -0.13134429f, 0.03351188f, 
    0.11501782f, -0.07945137f, -0.09063708f, 0.08818038f, 0.47825930f, 0.51136547f, -0.05762753f, -0.58323753f, 
    0.03927429f, -0.22906537f, -0.11688696f, -0.12191082f, 0.33768016f, 0.10558812f, -0.13429134f, -0.00901201f, 
    0.03503369f, -0.04326837f, -0.07240449f, -0.07951429f, 0.00285980f, 0.08770822f, 0.03170308f, -0.08791640f, 
    -0.09116285f, -0.06676097f, -0.03580882f, 0.11184128f, 0.08568946f, 0.03739782f, -0.05479284f, -0.08494689f, 
    0.02690032f, -0.05659533f, -0.12150072f, -0.05956778f, 0.01969446f, 0.06858827f, -0.08978738f, -0.09650680f, 
    0.09627734f, -0.12037623f, 0.09031735f, -0.00991866f, -0.05138740f, 0.04123956f, 0.07410184f, -0.09798020f, 
    -0.08157769f, -0.11658400f, -0.08708030f, -0.01413165f, -0.10895066f, -0.08203575f, -0.05294302f, 0.03682478f, 
    0.02015868f, -0.03117226f, -0.09124337f, -0.02039963f, -0.05025911f, 0.05958779f, -0.10078138f, -0.03769107f, 
    0.00316660f, -0.11659288f, -0.03953992f, -0.00314398f, 0.03392358f, -0.04668674f, -0.06865272f, 0.05080131f, 
    -0.11880948f, 0.05170354f, -0.09744135f, 0.07785635f, 0.04451905f, 0.05541727f, -0.02989152f, -0.11453189f, 
    -0.02051193f, -0.10319021f, 0.03727178f, -0.03504443f, 0.00403923f, 0.11061236f, -0.12384614f, -0.11995196f, 
    0.02720328f, -0.02600883f, 0.03481357f, -0.00960255f, 0.00888662f, 0.07765226f, -0.09315409f, 0.09567188f, 
    -0.11048350f, 0.02128993f, -0.10045834f, -0.08742429f, -0.01441531f, 0.04749574f, 0.00230080f, 0.05840175f, 
    -0.01140894f, -0.07580154f, 0.04330149f, 0.09054646f, -0.00005741f, 0.04831544f, -0.00137986f, 0.04247771f, 
    -0.00738861f, -0.11315367f, -0.11310957f, -0.12344374f, 0.08044299f, 0.03518760f, 0.09589508f, -0.12334844f, 
    -0.04207945f, -0.07969964f, 0.02300085f, -0.11126910f, -0.04521039f, -0.08467379f, -0.03051385f, 0.00878377f, 
    -0.02529217f, -0.05591030f, -0.07997510f, -0.11844040f, 0.07334512f, 0.08436844f, -0.11840755f, -0.05743138f, 
    0.02302167f, 0.10046482f, 0.00429513f, 0.02118994f, -0.03177117f, -0.05473246f, -0.05607879f, 0.03854409f, 
    -0.03567739f, -0.15054460f, -0.08813287f, -0.04076619f, -0.07833151f, -0.05000009f, 0.29529741f, -0.11613176f, 
    0.35562104f, 0.34973377f, -0.06824338f, -0.05422781f, -0.25578192f, -0.17258084f, 0.48337656f, -0.09337508f, 
    0.42470938f, -0.20496044f, -0.07568989f, 0.07877398f, 0.36457780f, -0.06089283f, 0.16824803f, -0.27245459f, 
    0.04713000f, -0.00585599f, 0.03377653f, -0.08310492f, 0.11288858f, 0.09935794f, -0.47567070f, -0.01696598f, 
    0.05595143f, -0.08247915f, 0.29660797f, -0.05987133f, 0.04848171f, 0.63868582f, 0.11389315f, 0.09453198f, 
    -0.25459853f, -0.11842512f, 0.48539194f, 0.11840464f, 0.05321642f, -0.21923020f, -0.03058495f, 0.02877203f, 
    -0.04195726f, 0.04996324f, 0.33822209f, 0.15391031f, 0.24128973f, 0.18231270f, 0.21476558f, -0.49168998f, 
    -0.12212124f, 0.00851586f, 0.06227067f, 0.44928837f, 0.22527893f, 0.02517606f, -0.26916537f, 0.24042128f, 
    -0.07287639f, -0.16904435f, 0.30393410f, 0.22212973f, 0.08525730f, 0.13029087f, 0.13256198f, 0.03027863f, 
    0.27507195f, -0.53184843f, 0.03620251f, 0.04848043f, -0.14163598f, -0.01406760f, 0.41695252f, -0.03399941f, 
    0.14911121f, 0.04135875f, -0.05243047f, -0.37942502f, -0.04871769f, 0.46273702f, 0.17115821f, -0.10974869f, 
    -0.07862382f, 0.06305110f, 0.36648387f, 0.06951220f, -0.45694473f, -0.02946915f, 0.57039845f, -0.17271277f, 
    -0.04630060f, -0.07495854f, 0.53180498f, -0.09182990f, 0.19324750f, -0.60952258f, 0.00679778f, -0.01897428f, 
    0.36567682f, 0.03280452f, 0.15603752f, -0.43773127f, 0.01537630f, -0.47186154f, -0.33397952f, 0.04774657f, 
    0.03899534f, 0.11358547f, -0.24638443f, 0.06345198f, -0.15128925f, 0.07737194f, 0.03396008f, -0.13711092f, 
    -0.06770514f, 0.01099131f, -0.51704830f, -0.13825330f, -0.10075790f, 0.00193481f, -0.05063353f, 0.68369734f, 
    0.07238555f, -0.04616117f, -0.08559141f, -0.09169067f, -0.07645640f, 0.02264588f, 0.08149217f, -0.03773302f, 
    -0.03587440f, 0.01838887f, -0.10218278f, -0.02755074f, 0.09991186f, 0.08887641f, -0.01040174f, -0.06149353f, 
    0.10902421f, -0.08334342f, -0.00248096f, 0.00589739f, -0.06290928f, -0.00093973f, -0.11436875f, -0.10085076f, 
    0.01127381f, -0.12407075f, -0.08082355f, -0.09939100f, -0.02023999f, 0.04293852f, -0.07750609f, 0.02540947f, 
    0.03638740f, 0.03386891f, -0.11402287f, 0.06811216f, 0.10915598f, -0.09207982f, -0.06311747f, 0.05164839f, 
    0.05776598f, -0.00020703f, -0.08942564f, 0.02486316f, -0.11877278f, 0.01065336f, -0.00183936f, 0.06676541f, 
    0.04579513f, -0.03036792f, 0.01336218f, 0.06843203f, 0.02932199f, -0.06663857f, -0.07789262f, 0.07506156f, 
    -0.11484902f, -0.11231230f, -0.11983681f, -0.05591292f, 0.11793362f, 0.08559112f, -0.10130753f, -0.08642252f, 
    -0.07959021f, 0.10007045f, 0.19977219f, -0.00928523f, 0.27514276f, -0.72762316f, 0.03628101f, -0.17494318f, 
    0.08732177f, 0.35344690f, -0.12972350f, -0.00103929f, -0.08768932f, -0.10220375f, -0.09052924f, 0.02560765f, 
    -0.18099216f, -0.44613549f, -0.27440545f, 0.13171966f, -0.02386755f, 0.18756711f, 0.46143869f, -0.51571041f, 
    0.00983908f, 0.04527285f, 0.30043647f, 0.02520564f, -0.09680929f, 0.09975871f, 0.45161417f, 0.22532281f, 
    0.02245907f, 0.08295111f, 0.06051258f, -0.12998889f, -0.02890732f, 0.15153636f, 0.11311573f, -0.16700149f, 
    -0.39472726f, -0.14464021f, 0.06236375f, -0.08817165f, 0.11035875f, 0.09648120f, 0.16432849f, -0.04273082f, 
    -0.05395103f, 0.13328630f, 0.28961509f, -0.02546754f, 0.09530215f, -0.23255835f, 0.12797843f, -0.07007273f, 
    0.04504369f, 0.21384700f, 0.28145432f, 0.22605914f, -0.09791761f, -0.46596456f, -0.19385439f, 0.25206262f, 
    -0.03162222f, 0.09713049f, 0.19736506f, 0.16922773f, 0.31438327f, -0.15078042f, 0.29203883f, -0.31798893f, 
    0.00907302f, 0.03497610f, -0.11637244f, -0.09808167f, -0.00832263f, 0.17878690f, 0.06517754f, -0.03149223f, 
    0.04865570f, 0.11175933f, -0.07555759f, -0.01985338f, -0.13552701f, 0.26594448f, 0.26690629f, -0.17040871f, 
    0.07975961f, 0.04986751f, 0.12489238f, -0.01898371f, -0.03216321f, -0.02487828f, 0.40206945f, 0.13108322f, 
    0.00601403f, 0.04148301f, 0.19065893f, -0.07606415f, 0.05918695f, -0.46973076f, 0.07672083f, -0.16468474f, 
    -0.10539367f, 0.05334164f, -0.06330629f, -0.10567190f, 0.16632934f, 0.00477930f, -0.04964812f, -0.09915800f, 
    -0.00616897f, 0.19300272f, 0.02185958f, -0.04656654f, -0.27285615f, -0.23051433f, -0.02069277f, 0.05241979f, 
    0.06858004f, 0.13773450f, -0.06177151f, -0.10736549f, -0.21815482f, -0.00448087f, -0.06405719f, 0.36289814f, 
    -0.06649174f, 0.27387661f, -0.02688182f, 0.12032644f, 0.29530999f, 0.54181588f, -0.23666494f, 0.27430171f, 
    0.16979048f, -0.27315962f, -0.01419310f, 0.09240028f, 0.10730460f, 0.20474140f, 0.14747612f, 0.10070430f, 
    0.11207455f, 0.10091226f, 0.04161205f, -0.08338822f, -0.20859961f, 0.48290774f, -0.10632011f, 0.22027305f, 
    0.00075147f, -0.10767883f, 0.19573517f, -0.10763071f, -0.44327998f, 0.01423698f, 0.44619188f, 0.12746368f, 
    -0.12052879f, -0.15976338f, 0.32732484f, 0.12677291f, -0.17026345f, -0.43196136f, 0.25929356f, 0.04636152f, 
    -0.08236772f, -0.05775376f, -0.07454792f, -0.30598325f, -0.03805424f, -0.56836969f, -0.39737186f, 0.09689148f, 
    0.04508992f, 0.12961151f, -0.10755610f, -0.06699559f, 0.00998882f, -0.17926922f, -0.04546801f, 0.60152644f, 
    -0.02412528f, -0.36460015f, -0.03095482f, -0.37674955f, 0.02942741f, -0.39921191f, -0.02780111f, 0.37821946f, 
    -0.13040842f, -0.24938622f, 0.16867311f, -0.11883328f, 0.40169170f, -0.45547110f, 0.07773867f, -0.33013791f, 
    -0.42922914f, 0.77696651f, 0.00809971f, 0.09057400f, 0.04159420f, 0.37704647f, -0.18655820f, -0.03227720f, 
    0.02136330f, -0.21603400f, -0.01698486f, -0.09824899f, 0.04131174f, 0.13967918f, 0.43644249f, 0.25688854f, 
    -0.13832822f, 0.01650000f, 0.26247931f, 0.25109288f, -0.03669622f, -0.09163865f, 0.30881050f, -0.05644880f, 
    0.06468832f, 0.06185377f, -0.09340861f, 0.54102737f, 0.14761087f, -0.07042881f, 0.11172119f, 0.28664789f, 
    -0.06667716f, -0.21548374f, -0.23074275f, -0.01842444f, 0.04490845f, -0.35562161f, 0.02647404f, -0.10868590f, 
    0.11144034f, 0.16866411f, 0.24490312f, 0.12229077f, -0.17403507f, -0.48485479f, 0.22615948f, -0.27734110f, 
    0.08827107f, -0.39610583f, 0.19743127f, -0.09622927f, -0.06160877f, 0.10589787f, 0.49077323f, -0.24728404f, 
    0.04711989f, -0.11272028f, -0.09852059f, 0.06752145f, -0.48045418f, 0.36495975f, 0.17569731f, 0.13643689f, 
    -0.03653010f, 0.08071268f, -0.10656795f, -0.00039074f, 0.24153656f, 0.15194346f, -0.11872857f, 0.05237702f, 
    0.18669842f, 0.20665143f, 0.22785346f, -0.06957695f, 0.12483385f, -0.04308850f, -0.34728101f, 0.16558895f, 
    0.05094316f, -0.08711533f, -0.16038150f, 0.14330001f, 0.07064964f, 0.09011155f, -0.37915167f, -0.20162290f, 
    0.08442352f, 0.11946176f, 0.03443776f, 0.03511885f, -0.07444943f, 0.63828790f, -0.02691539f, 0.29523322f, 
    0.44133028f, 0.21159030f, 0.08489004f, 0.44046310f, 0.14756614f, 0.07708149f, 0.04345773f, -0.10730492f, 
    0.01359742f, -0.12475813f, -0.11039470f, 0.01381332f, 0.05632421f, 0.18186203f, 0.21536426f, -0.09426153f, 
    -0.06909981f, -0.07541461f, -0.20299503f, 0.04965805f, 0.23412658f, 0.24080518f, 0.16667224f, -0.10888315f, 
    0.00828113f, 0.05658330f, -0.05250446f, 0.05904781f, 0.04715399f, -0.08665253f, 0.00629424f, -0.04878763f, 
    0.00791583f, 0.06521497f, 0.03852357f, -0.01685116f, -0.14073306f, -0.06687094f, 0.04272746f, -0.00485229f, 
    -0.06718399f, 0.09965782f, 0.03895821f, -0.00195056f, 0.05722629f, -0.10367619f, -0.00575659f, -0.12429769f, 
    -0.08562840f, 0.11262010f, -0.08166860f, -0.14144450f, -0.01584326f, -0.07440948f, -0.00796006f, 0.09074184f, 
    -0.06145057f, -0.10513707f, 0.03810840f, 0.06396691f, -0.06742568f, 0.03810302f, -0.09335124f, 0.02265486f, 
    -0.08829039f, 0.07400607f, -0.09344397f, -0.11043188f, 0.02966148f, -0.10618873f, 0.11205776f, 0.09844407f, 
    -0.11916804f, 0.03082378f, -0.12113185f, -0.08344002f, 0.02480102f, 0.10476412f, -0.10887214f, -0.02043529f, 
    0.03146312f, -0.12193738f, -0.02347380f, 0.04245659f, -0.05627716f, -0.06165223f, 0.00689442f, 0.04188550f, 
    0.03015043f, 0.32986555f, -0.20817877f, 0.10080061f, 0.39490154f, 0.43896133f, 0.01430463f, 0.57933432f, 
    0.37456077f, -0.77440244f, -0.36787805f, 0.10295954f, -0.08808450f, -0.03930071f, 0.49617958f, -0.01538702f, 
    0.05728451f, 0.36151302f, 0.20423011f, -0.28122666f, 0.04322630f, -0.19737498f, 0.13878837f, 0.20698127f, 
    -0.02254151f, -0.05921892f, -0.32090339f, -0.35330769f, -0.25527659f, 0.01307949f, -0.02345468f, -0.30175841f, 
    -0.04199754f, -0.49795815f, -0.02839658f, -0.13142690f, -0.68599284f, 0.26534131f, 0.14031889f, 0.08744422f, 
    -0.01792908f, 0.17344648f, -0.14723001f, 0.12011293f, -0.51791608f, 0.19619837f, -0.55599904f, -0.07181156f, 
    0.03826563f, -0.15932418f, 0.07940733f, 0.03683264f, 0.37520933f, 0.09704041f, 0.03474771f, -0.27033216f, 
    0.10880134f, 0.30025747f, -0.32830489f, 0.18741153f, 0.23482585f, -0.14151606f, -0.06614757f, 0.23682906f, 
    -0.00003075f, 0.37537238f, -0.08500246f, 0.06294879f, 0.21482076f, 0.57483834f, 0.06053632f, -0.00124306f, 
    -0.28203890f, 0.33532998f, 0.02875657f, -0.06680265f, 0.17496613f, -0.10277090f, -0.10309358f, 0.06824556f, 
    0.13514633f, -0.05617570f, 0.02774166f, 0.38282278f, 0.07414796f, 0.10705929f, 0.13659893f, -0.13171992f, 
    0.07119707f, 0.07303832f, 0.03965883f, 0.09580398f, -0.05168378f, -0.09912915f, -0.04806783f, 0.31265810f, 
    0.07611012f, -0.15407147f, -0.10443562f, 0.21611185f, 0.08156053f, 0.17083566f, 0.21860477f, 0.09796587f, 
    -0.43157375f, 0.04911263f, 0.07394721f, -0.16320278f, -0.04518556f, -0.13970587f, -0.17599438f, 0.04340079f, 
    -0.05334695f, 0.09462038f, 0.11829727f, -0.05053713f, -0.01180907f, 0.00237087f, 0.00840381f, -0.52132279f, 
    -0.11118680f, -0.11420751f, 0.27360579f, -0.16255400f, -0.11352322f, -0.31679252f, -0.20214824f, -0.32170540f, 
    -0.09455092f, 0.12139158f, 0.12005893f, 0.01821494f, 0.52955902f, 0.12686571f, 0.16961385f, 0.28465953f, 
    0.38896242f, -0.44016975f, -0.19290718f, -0.14113466f, -0.09050719f, -0.02688564f, 0.54422051f, 0.02605917f, 
    0.09004597f, 0.16264662f, -0.05611073f, -0.01677866f, 0.29280525f, 0.33180743f, 0.34004223f, -0.12708074f, 
    0.05842433f, 0.04219408f, 0.25312877f, -0.17288840f, -0.29786795f, 0.06652191f, 0.35787535f, -0.34993228f, 
    0.00797154f, -0.06993420f, 0.36462122f, -0.02704515f, 0.05660168f, -0.37792683f, 0.14301953f, -0.14061381f, 
    0.27946198f, -0.02299547f, 0.11771781f, -0.22255760f, -0.02205661f, -0.24442118f, -0.56538522f, -0.10023518f, 
    0.06563751f, -0.12090708f, -0.26849639f, 0.00907589f, 0.17463954f, -0.17499411f, -0.03489178f, -0.01504167f, 
    0.00929992f, -0.03444119f, -0.15882100f, 0.00012644f, -0.07876714f, 0.22842667f, -0.11675814f, 0.71404117f, 
    0.09144048f, 0.20219855f, 0.08957610f, 0.24839438f, 0.38100347f, -0.18330982f, 0.28909227f, -0.17717895f, 
    -0.09047501f, 0.34614235f, 0.02852605f, -0.06373470f, 0.14998905f, 0.15675923f, 0.03639119f, 0.01599760f, 
    0.02990841f, 0.05621418f, -0.16158037f, 0.04993314f, 0.08350052f, 0.41189182f, 0.29555285f, -0.05265044f, 
    0.15701811f, 0.02437790f, 0.13154666f, 0.11824463f, -0.07159913f, -0.08290749f, 0.40005487f, 0.12041175f, 
    0.10339034f, 0.04287817f, 0.20948611f, 0.09279511f, 0.12209573f, -0.28733987f, 0.07064515f, -0.03886659f, 
    -0.08776119f, 0.07449970f, -0.11087051f, -0.02201287f, 0.19458295f, 0.00748667f, 0.16877770f, -0.08726270f, 
    0.06488114f, 0.10591002f, -0.00048039f, -0.05205517f, -0.16743487f, -0.11151458f, -0.06951677f, 0.51282430f, 
    -0.01197125f, 0.05389032f, -0.03509422f, -0.12664267f, -0.29100281f, 0.16115767f, 0.21748798f, 0.12890649f, 
    0.04098316f, -0.01169950f, -0.08758606f, 0.05318586f, 0.24068402f, -0.21919155f, -0.08407383f, 0.12227509f, 
    -0.09808815f, 0.25014323f, -0.30736431f, -0.06487608f, 0.03801502f, 0.00756432f, 0.03574046f, 0.01862472f, 
    0.05017525f, 0.01737459f, -0.05430710f, 0.08330264f, 0.21965782f, 0.11541134f, 0.24067941f, 0.14500427f, 
    0.03933783f, 0.00492351f, 0.08016367f, -0.18244112f, -0.43253875f, -0.13340229f, 0.53916758f, -0.19043717f, 
    0.03067519f, -0.11540923f, -0.01010567f, 0.17977782f, 0.00159692f, 0.03763971f, 0.23702402f, 0.28805068f, 
    0.06431879f, 0.18297957f, 0.11349206f, -0.20093012f, -0.11863374f, -0.12892255f, -0.26176661f, -0.03147030f, 
    0.09713805f, -0.13357280f, -0.26454329f, 0.08496753f, 0.15754420f, -0.31253082f, -0.01339579f, 0.00684541f, 
    -0.03576949f, -0.16851844f, -0.03472365f, -0.39415225f, -0.08230229f, -0.51574117f, 0.46999985f, 0.08153411f, 
    -0.09773923f, -0.01421615f, -0.09449365f, -0.03191542f, 0.03767998f, -0.03419429f, -0.15242009f, -0.05708591f, 
    0.06998746f, -0.02024783f, -0.13979633f, -0.08792670f, 0.06601433f, -0.07649919f, -0.01794959f, -0.05149120f, 
    -0.07142433f, -0.12399326f, -0.13952081f, 0.01832046f, 0.03984924f, -0.11088987f, 0.09610502f, -0.00688346f, 
    -0.09215224f, 0.07416853f, -0.04375312f, -0.02401607f, -0.10210381f, 0.08731620f, 0.00510209f, 0.01293825f, 
    0.03821960f, -0.04796781f, -0.00607434f, -0.06709767f, 0.00689228f, -0.02109949f, 0.03868408f, -0.01462854f, 
    -0.11389543f, 0.00539983f, -0.01449267f, -0.06718283f, 0.04498577f, 0.07513016f, 0.06873695f, -0.04380232f, 
    0.04507264f, -0.08249695f, -0.14985965f, -0.01474549f, 0.10327087f, 0.04094610f, -0.07207101f, -0.08416352f, 
    0.00563771f, -0.13885857f, -0.01722238f, 0.02430003f, 0.00927090f, 0.05910001f, 0.10830421f, 0.03039696f, 
    0.03300905f, -0.01387444f, 0.00017929f, 0.10681361f, -0.31601235f, 0.30016160f, -0.09946242f, 0.03092532f, 
    -0.02952482f, 0.15762956f, -0.07528223f, -0.02091918f, 0.18082920f, 0.09217596f, 0.08863684f, 0.01060020f, 
    0.14484712f, 0.23169482f, 0.25038084f, 0.03194997f, -0.04627544f, -0.21702753f, -0.04750423f, 0.34369278f, 
    0.14169294f, -0.10300093f, -0.22256923f, 0.07969305f, 0.07794245f, 0.12199298f, -0.09648291f, -0.05831543f, 
    -0.08164120f, -0.02460891f, -0.14053059f, 0.18764812f, 0.09745901f, 0.33686233f, 0.07644747f, 0.25902563f, 
    0.47009307f, 0.23404951f, -0.08427750f, 0.25755274f, -0.06044149f, 0.00861766f, 0.13729621f, -0.07805544f, 
    -0.00442626f, -0.14425865f, -0.09353522f, 0.05792267f, 0.06577543f, -0.01090571f, 0.14962715f, 0.12607916f, 
    -0.06362267f, -0.00527972f, -0.00112143f, 0.09756090f, 0.07581334f, 0.16969982f, 0.21121034f, -0.31755883f, 
    0.05485556f, 0.10158409f, 0.01647125f, 0.17132832f, 0.32287881f, 0.07398737f, -0.09271156f, 0.51510882f, 
    0.39683408f, -0.23996340f, 0.27036488f, 0.10235429f, -0.06967724f, -0.13425928f, 0.69744110f, 0.05570954f, 
    0.22155824f, 0.28228584f, -0.11606573f, 0.05618364f, 0.27310249f, 0.25859532f, 0.17115638f, -0.06689437f, 
    0.09960249f, 0.01487520f, 0.06551485f, -0.04586133f, -0.12772284f, -0.08514065f, 0.44674826f, -0.24983226f, 
    0.00959074f, -0.22687645f, 0.21711634f, 0.03781893f, 0.41294232f, -0.27297193f, 0.24269336f, 0.05103665f, 
    -0.01062416f, 0.03023495f, 0.26172450f, -0.34998670f, -0.05391143f, -0.59157676f, -0.59547579f, 0.02268317f, 
    -0.04501538f, -0.14172965f, -0.01843249f, -0.02663435f, 0.09688940f, -0.15170726f, 0.11263477f, 0.10091459f, 
    0.08510801f, -0.17989837f, -0.27123189f, -0.23112476f, -0.18200874f, -0.11079128f, 0.02473702f, 0.46312192f, 
    0.06603218f, -0.04914303f, 0.10726231f, 0.09112456f, 0.42300016f, 0.00106031f, 0.13862911f, 0.23699331f, 
    0.38598728f, -0.84931344f, 0.11740711f, 0.03026571f, -0.06409701f, 0.02383732f, 0.57572919f, 0.09526300f, 
    0.06929237f, 0.09003672f, -0.19904839f, -0.17214900f, -0.03854135f, 0.27618504f, 0.19338700f, -0.03668028f, 
    -0.06069814f, 0.06081885f, 0.10370122f, -0.13658766f, -0.08307965f, -0.15961127f, 0.21986516f, -0.14687702f, 
    -0.05786567f, 0.12892136f, 0.37607551f, -0.03503069f, 0.15205173f, -0.49621335f, 0.24901552f, -0.12259149f, 
    -0.31740788f, -0.07542779f, -0.08812375f, -0.32505751f, -0.15852757f, -0.26005065f, -0.21262674f, -0.01525527f, 
    0.12725726f, 0.03458568f, -0.11631164f, 0.05584542f, 0.17852768f, -0.24130189f, -0.06681550f, -0.36794722f, 
    -0.08897921f, -0.02423583f, -0.16740014f, -0.15283157f, 0.05782589f, 0.21214102f, 0.03936301f, 0.56408495f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.12507401f, 0.14475122f, 0.07388256f, 0.21233690f, 0.10807219f, 0.33831507f, -0.10601339f, 0.55404925f, 
    0.10536835f, 0.12926388f, 0.17949840f, -0.00334730f, 0.05421428f, 0.05100513f, 0.07034814f, 0.11416443f, 
    0.40719944f, -0.27769920f, 0.17089187f, -0.01107150f, 0.19914983f, 0.22055669f, 0.28836581f, -0.18114209f, 
    0.05925391f, -0.10463245f, -0.03675182f, -0.13860731f, 0.33193895f, 0.18572280f, -0.02248186f, 0.15990958f, 
    -0.10978933f, 0.13172725f, 0.00434085f, 0.00641848f, -0.11948897f, 0.20458041f, -0.11103781f, -0.01106249f, 
    0.30067587f, 0.01378794f, 0.24672581f, 0.03641992f, 0.08134679f, -0.08488406f, 0.13217092f, 0.12116895f, 
    0.03398355f, -0.04871477f, 0.03912177f, 0.17143701f, 0.14952169f, 0.37411484f, 0.04901586f, -0.18007351f, 
    -0.02244579f, 0.07175959f, 0.15694116f, 0.17089921f, -0.05402953f, 0.20832129f, -0.11384840f, 0.21268541f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.15938061f, 0.07644603f, 0.04253213f, -0.36943161f, 0.07248346f, -0.42789215f, 0.23619039f, -0.47418576f, 
    -0.11948211f, -0.41446495f, -0.79311043f, 0.09058210f, -0.33815223f, 0.26785371f, 0.07753032f, 0.18471207f, 
    -0.28189605f, 0.32568842f, -0.18555564f, -0.06606206f, -0.16198647f, -0.50919878f, -0.59696788f, -0.08634257f, 
    0.20734356f, -0.35721532f, 0.04992043f, 0.07346703f, 0.04043429f, 0.25079584f, -0.77466238f, -0.27689204f, 
    -0.08730449f, 0.16940050f, 0.02487725f, -0.05148564f, -0.10054086f, -0.50869197f, 0.08808575f, 0.04604305f, 
    -0.44749483f, -0.07971415f, 0.03833722f, 0.17511564f, 0.07280633f, -0.04659365f, 0.10171186f, -0.09171607f, 
    0.01360420f, 0.11749289f, -0.03831462f, -0.36352167f, -0.09376666f, 0.17582296f, -0.09570852f, 0.35069117f, 
    -0.13405441f, -0.27026764f, -0.41898161f, 0.03899310f, 0.09710907f, 0.16297421f, 0.07187696f, -0.22161192f, 
    0.07637919f, -0.21397059f, -0.01668257f, 0.18000077f, 0.17419319f, 0.02444731f, -0.09434786f, 0.22733890f, 
    -0.00604139f, -1.09669006f, -0.33586672f, -0.02807485f, -0.20057331f, 0.18109870f, 0.00661415f, 0.22876333f, 
    0.18452767f, -1.00238383f, -0.15863648f, -0.10772926f, -0.27266130f, 0.21866147f, -0.34985167f, -0.15860584f, 
    0.52527064f, -0.13519551f, 0.02545255f, -0.51208049f, 0.08212972f, 0.25281784f, -0.37502825f, 0.21767217f, 
    -0.07661650f, 0.14857908f, -0.00634302f, -0.01722381f, -0.03005488f, 0.11956935f, -0.02798616f, -0.04945299f, 
    0.03959339f, -0.11063404f, 0.17220587f, 0.11218428f, 0.10858697f, -0.10677750f, 0.01856092f, -0.19986145f, 
    0.11493817f, -0.14094605f, -0.15538865f, -0.78137302f, 0.21081865f, 0.17579089f, -0.01539624f, -0.64494872f, 
    -0.13969502f, -0.67142332f, 0.03859165f, 0.08511596f, 0.06843460f, 0.14400770f, -0.73248786f, 0.10384791f, 
    -0.21048641f, 0.23006959f, -0.08188945f, 0.02062071f, 0.38179201f, 0.13620721f, 0.08489715f, -0.03018406f, 
    -0.09569182f, 0.08673944f, 0.04362670f, -0.00553870f, -0.09548356f, -0.19419472f, 0.06763811f, 0.20887059f, 
    -0.02147359f, -0.68244052f, -0.15701713f, -0.01586340f, 0.62064004f, -0.38476291f, 0.35676575f, 0.24916451f, 
    -0.84974992f, -0.11665253f, 0.08984517f, -0.27874696f, -0.25082859f, -0.62793678f, -0.06343674f, -0.12003393f, 
    -0.16200137f, -0.00838480f, -0.35418794f, 0.05839170f, 0.08786684f, -0.13736784f, -0.04602053f, -0.01611048f, 
    0.15863538f, 0.11262169f, 0.16670959f, -0.71673620f, -0.00271510f, 0.08204693f, -0.32537541f, 0.21062744f, 
    -0.07331255f, -0.10901795f, 0.03498066f, 0.36085895f, 0.22485375f, 0.07394065f, 0.01291970f, -0.91156876f, 
    -0.22990565f, 0.10114112f, 0.15795778f, 0.26408386f, -0.13976741f, 0.10877412f, 0.19781373f, 0.03123509f, 
    -0.35850593f, 0.00327632f, -0.09416235f, -0.33396089f, 0.07426764f, -0.30845201f, -0.20030436f, -0.46941677f, 
    -0.41571125f, 0.12834923f, 0.00200480f, -0.03437423f, 0.27725813f, 0.06636959f, -0.01987558f, -0.03369904f, 
    -0.39512479f, 0.18354073f, -0.07538153f, -0.03747293f, 0.02473959f, -0.23540717f, -0.20722423f, 0.31052962f, 
    0.09236836f, 0.11606665f, 0.05366825f, 0.25762951f, 0.24936070f, -0.14074793f, -0.06230389f, -0.09066157f, 
    0.06827868f, 0.22169727f, 0.12506928f, 0.10338423f, 0.05685024f, -0.54406697f, -0.04699992f, 0.04449390f, 
    -0.03595889f, -0.13113804f, -0.50495160f, 0.07275397f, -0.08173695f, -0.04433692f, -0.39851221f, 0.03358606f, 
    0.06023143f, -0.25807577f, -0.01664983f, 0.25055945f, -0.09996473f, -0.04997155f, 0.03484673f, 0.09907438f, 
    -0.00231410f, 0.19108094f, 0.04414462f, 0.15320936f, -0.12672092f, 0.05628787f, 0.22595048f, 0.40533417f, 
    0.15747894f, 0.20735994f, 0.04681859f, -0.54148817f, -0.12036363f, 0.03991450f, -0.09950170f, 0.05417967f, 
    0.30576649f, 0.09391890f, -0.27123043f, 0.03231337f, -0.05104931f, 0.19706175f, -0.03503677f, 0.02855722f, 
    -0.10889439f, -0.02428675f, 0.09260487f, -0.10457229f, -0.04136537f, -0.00691125f, -0.12174702f, -0.12367070f, 
    -0.17047779f, -0.10833212f, -0.17567389f, 0.16470982f, 0.17744315f, 0.08675987f, 0.06989627f, -0.26177439f, 
    0.05271807f, -0.09016113f, 0.22547011f, -0.07026415f, 0.05405216f, -0.02662018f, 0.04718721f, 0.05198057f, 
    -0.04250586f, -0.02810681f, -0.22316344f, -0.01676522f, -0.10665181f, 0.00186652f, 0.24557546f, -0.54556179f, 
    -0.01984240f, 0.22934940f, -0.50205404f, 0.09674121f, -0.35110307f, 0.14143179f, 0.02852636f, 0.10655583f, 
    0.08923583f, 0.04825809f, -0.14164224f, -0.11426062f, -0.09773440f, 0.10722011f, 0.10510629f, -0.36275989f, 
    0.11356245f, 0.17065287f, -0.00828337f, -0.08579887f, 0.12626937f, 0.06528174f, 0.17110969f, 0.11878860f, 
    0.00046567f, -0.03796241f, 0.13513993f, -0.09278687f, 0.06788255f, 0.12948416f, 0.04358013f, 0.16229793f, 
    0.19949624f, -0.21844843f, -0.01654798f, 0.02150878f, 0.37339190f, -0.27355587f, 0.13964076f, -0.27544537f, 
    -0.10346687f, 0.09735877f, -0.07233755f, -0.06050712f, -0.05070986f, 0.05831078f, -0.00231404f, 0.13900259f, 
    -0.00928241f, 0.18752146f, 0.19369255f, -0.00263760f, 0.00211924f, -0.02237292f, -0.14437611f, -0.05313911f, 
    0.12542161f, -0.01461525f, -0.26190186f, -0.03003090f, -0.01996341f, 0.00623101f, -0.10502813f, -1.01999795f, 
    0.11248700f, -0.31119210f, 0.05635469f, -0.17729230f, 0.17143375f, 0.12442703f, 0.00673712f, -0.17829512f, 
    0.14815122f, -0.80859083f, 0.15193871f, 0.20723659f, -0.08875912f, 0.07921045f, -0.21880868f, -0.87192756f, 
    -0.34470570f, -0.01230173f, 0.04423333f, 0.06772262f, -0.81039786f, 0.16173027f, 0.01701698f, 0.06223003f, 
    -0.43056965f, 0.39950052f, 0.33719805f, 0.03778001f, -0.58455658f, -0.23151410f, 0.08851682f, -0.17791651f, 
    0.15809582f, -0.45304322f, 0.01487700f, -0.01396080f, -0.54237211f, -0.38373050f, 0.19724654f, 0.07715214f, 
    -0.11546678f, -0.17578588f, -0.42499298f, 0.04727126f, -1.40328109f, -0.32591832f, 0.20850411f, 0.09311732f, 
    0.00112982f, -0.39622843f, -0.55848604f, -0.04991348f, 0.11978896f, 0.07929838f, 0.07318984f, 0.11121757f, 
    0.07192145f, -0.01961895f, 0.26735574f, -0.94011396f, -0.10452075f, -0.11956117f, -0.09146972f, 0.36582887f, 
    0.01957604f, 0.29100800f, 0.15129003f, 0.31459954f, -0.66932958f, -0.46891332f, -0.11450832f, -0.38251802f, 
    -0.59303617f, 0.17080088f, 0.20913732f, -0.81341100f, 0.09732677f, -0.37309656f, 0.07882279f, 0.14675339f, 
    -0.58007282f, -0.42031780f, -0.07779477f, -0.08191971f, -0.50460571f, -0.79837650f, 0.30367130f, 0.10894387f, 
    -0.07274643f, -0.26294544f, -0.45849791f, 0.01094698f, 0.07901732f, -0.07949082f, -0.01342814f, -0.24601887f, 
    0.13863099f, 0.64095074f, -0.64650369f, 0.06668022f, -0.26404864f, 0.21576662f, -0.23537037f, -0.27573237f, 
    -0.05646758f, 0.35487723f, -0.07796461f, 0.17889808f, -0.02297490f, -0.32825223f, -0.84082210f, 0.22598794f, 
    0.07677610f, -0.20557125f, -0.13628596f, 0.10161274f, 0.00917527f, -0.50790697f, 0.04175888f, -0.00153500f, 
    -0.66698706f, -0.00455320f, -0.13822800f, -0.19262326f, 0.08153743f, -0.00828484f, 0.10746019f, 0.21878897f, 
    0.05253312f, 0.09387174f, 0.03945198f, -0.14997707f, -0.00370892f, -0.29393962f, 0.07731941f, -0.38646722f, 
    -0.14857621f, 0.42181364f, 0.04501173f, -0.68417513f, -0.06421288f, -0.27692866f, -0.29035729f, 0.19665362f, 
    -0.31963080f, -0.53300774f, 0.00425418f, 0.19283770f, -0.46549651f, 0.07252049f, -0.35760108f, 0.09832951f, 
    -0.37673005f, -0.01816107f, 0.43695596f, 0.07024966f, 0.54463184f, -0.76960570f, -0.01662678f, -0.46250936f, 
    0.18242128f, -0.68211156f, -0.08359372f, 0.08548679f, -0.61479884f, 0.13571894f, -0.08870178f, -0.19145624f, 
    -0.49333802f, 0.21884039f, -0.19087596f, -0.20904484f, -0.05390012f, -1.09342098f, -0.03371153f, 0.10061898f, 
    -0.08281694f, 0.06389402f, -0.19547813f, -0.12139567f, 0.12099254f, 0.16385692f, -0.02260098f, -0.03724442f, 
    0.20654669f, 0.09587084f, 0.10557666f, -0.76141000f, 0.08287948f, 0.10636248f, -0.21280795f, -0.48155648f, 
    0.02360700f, 0.23139879f, 0.24217010f, -0.47362354f, 0.33150697f, -0.17945667f, -0.09695852f, -0.12677191f, 
    0.15018003f, -0.49442852f, 0.17581451f, -0.64992130f, 0.07690547f, -0.14413247f, -0.95385188f, -0.16013427f, 
    0.20409279f, 0.27980286f, 0.01626930f, -0.33844182f, 0.11251508f, 0.18384168f, -0.12460708f, 0.16441581f, 
    -0.16779046f, 0.05390721f, -0.20803981f, 0.04549370f, -0.17941757f, 0.12037635f, 0.08740914f, 0.01265049f, 
    -0.00129125f, -0.23016609f, 0.39243996f, -0.12159173f, 0.11762525f, -0.54185659f, 0.12563309f, 0.33258379f, 
    -0.66126829f, -0.48635972f, -0.53962058f, 0.17016879f, -0.32788238f, -0.09626958f, 0.23394248f, -0.20367289f, 
    0.00787345f, -0.68131441f, 0.20770206f, -0.08290908f, 0.12390950f, 0.11472646f, 0.01022983f, -0.03732798f, 
    -0.12561923f, 0.09413011f, -0.08955666f, 0.26122579f, -0.10422713f, -0.02943867f, 0.04763721f, 0.26149625f, 
    -0.06375821f, -0.29038367f, 0.10467103f, 0.04977936f, -0.78886378f, 0.10041092f, -0.00173016f, -0.38569200f, 
    -0.15334761f, 0.10720333f, -0.07137059f, -0.20975344f, -0.07369711f, -0.18900801f, 0.14014332f, 0.27201965f, 
    0.30997276f, -0.74010825f, 0.00675559f, 0.22901858f, -0.24698421f, 0.03524418f, 0.04453428f, -0.15764354f, 
    0.78771430f, 0.28260851f, 0.11251801f, -0.09832273f, 0.37260956f, -0.87051374f, 0.08238177f, -0.15700699f, 
    -0.24004295f, -0.77450573f, 0.15978152f, 0.08287908f, -0.05655499f, 0.20347810f, 0.09065582f, 0.14483610f, 
    -0.35321695f, 0.03510553f, 0.02031586f, 0.12056543f, 0.08337623f, 0.27057016f, 0.26046732f, -0.24734566f, 
    0.09362032f, -0.22737268f, 0.09412973f, 0.01951395f, -0.11556025f, 0.13378300f, 0.05565111f, -0.02234524f, 
    -0.00474879f, 0.01412313f, 0.01515640f, 0.21061356f, -0.04002829f, -0.04145907f, -0.79656714f, -0.50403649f, 
    -0.03526017f, -0.45768499f, -0.21880522f, 0.31984520f, 0.10849874f, -0.07432464f, -0.00253593f, -0.44838208f, 
    0.25584188f, -0.88642192f, -0.10117290f, -0.30576894f, -0.09616662f, 0.08461778f, -0.92275280f, -0.42552048f, 
    0.37633449f, -0.37826759f, -0.05444856f, 0.24071693f, -0.19822350f, -0.12216366f, -0.41773391f, 0.08067000f, 
    0.07967263f, -0.14675155f, -0.12803237f, -0.08459216f, -0.60718077f, -0.36405951f, 0.04539752f, -0.16466147f, 
    -0.13574605f, -0.16181652f, -0.10348263f, 0.05589844f, -0.28014252f, 0.28411445f, 0.01548206f, 0.03775888f, 
    -0.09979344f, 0.22125266f, 0.09168734f, -0.11904397f, -0.17850658f, -0.26734015f, 0.07358153f, 0.18448858f, 
    -0.00351312f, -0.19364473f, -0.37738746f, -0.05726698f, -0.08845095f, 0.19328500f, -0.14400333f, 0.05768526f, 
    -0.45331386f, 0.04448147f, -0.58355355f, -0.27216825f, -0.04831518f, -0.10960396f, 0.17606711f, 0.09960525f, 
    -0.06876710f, 0.07007024f, 0.13925919f, 0.05480226f, 0.17529669f, -0.41934165f, -0.00151164f, -0.86049479f, 
    0.29068065f, 0.09490751f, 0.11468288f, 0.10407267f, -0.03008675f, -0.25017485f, 0.22514275f, 0.17211807f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.15667927f, 0.38145205f, -0.13382740f, -0.05264706f, -0.05588079f, -0.01818142f, -0.10341811f, -0.11339412f, 
    0.06070960f, 0.03901244f, 0.01413794f, -0.02479903f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
