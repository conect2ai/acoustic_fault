#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.48110649f, -0.18085922f, 0.13856614f, 0.05630112f, -0.01945422f, -0.32147023f, -0.48392874f, -0.49652034f, 
    -0.48911771f, -0.38301268f, -0.11647446f, -0.13428260f, -0.19685976f, -0.43804115f, -0.33207291f, -0.01529567f, 
    -0.06347733f, -0.10502061f, 0.00564600f, -0.20532095f, -0.14069043f, -0.06714127f, -0.06837085f, 0.04296098f, 
    0.04460717f, 0.25046599f, -0.27143180f, -0.43647987f, -0.07002219f, 0.07887132f, 0.18671383f, -0.09517729f, 
    -0.04794476f, -0.00100176f, 0.34790334f, 0.05944870f, -0.11588422f, 0.18784645f, 0.19666788f, 0.24619529f, 
    0.06190969f, -0.30816787f, -0.12785356f, -0.06381290f, -0.38086677f, -0.24540550f, 0.19538651f, 0.38842490f, 
    0.13017510f, 0.34456638f, -0.38911730f, -0.26167369f, -0.18764624f, -0.53802001f, -0.44097820f, -0.25363579f, 
    0.06209609f, -0.04472479f, 0.10260236f, 0.37449968f, -0.20504193f, -0.27497318f, -0.23024464f, -0.20370254f, 
    0.18009782f, 0.03690692f, 0.05492325f, -0.04671644f, -0.06572645f, 0.09768303f, -0.32789913f, -0.58012486f, 
    0.14724998f, -0.29247662f, -0.25119972f, -0.80718786f, -0.66458005f, -0.16461773f, 0.31436312f, 0.31664819f, 
    0.04461784f, 0.25717089f, 0.05261512f, -0.62752223f, -0.32419246f, -0.13506010f, 0.39568207f, -0.25718173f, 
    -0.07448008f, -0.61905771f, -0.04711145f, 0.08986974f, -0.24643053f, -0.12275431f, 0.34154305f, 0.03940462f, 
    -0.23485596f, -0.09194382f, -0.19254383f, 0.08078773f, 1.18383491f, -0.12611507f, -0.52129996f, -0.05077238f, 
    -0.42670289f, -0.47960669f, -0.06050775f, 0.54724932f, 0.09018128f, -0.23011592f, 0.21746828f, 0.24994330f, 
    0.27811462f, -0.32868478f, -0.28247845f, 0.11101078f, 0.21241212f, -0.16668022f, -0.12492693f, -0.04887580f, 
    0.22086482f, 0.11532603f, -0.11763462f, -0.15168531f, 0.25879255f, -0.65439218f, -0.53113282f, -0.68634635f, 
    -0.15357156f, 0.31149191f, 0.41057146f, -0.04412932f, 0.20348121f, 0.32589874f, 0.48012361f, 0.10183334f, 
    0.33155233f, -0.23046331f, -0.18614571f, -0.41861010f, 0.07001080f, 0.01758951f, 0.00954949f, 0.05674117f, 
    -0.07063316f, 0.21545143f, -0.19014834f, 0.19946936f, 0.11925350f, 0.13027266f, -0.52493137f, -0.54125404f, 
    -0.00662111f, 0.20074902f, 0.20640762f, 0.20645921f, 0.11491711f, 0.13647546f, 0.40831921f, -0.12482278f, 
    0.01909990f, -0.12342098f, 0.17905279f, -0.15351863f, -0.33254322f, -0.16649207f, -0.33386600f, 0.25945577f, 
    -0.08243132f, 0.06445716f, -0.04427568f, -0.04566682f, 0.17180227f, 0.21219829f, 0.36271146f, -0.75430787f, 
    -0.06663959f, 0.26723647f, 0.14918090f, 0.50903749f, -0.25533727f, 0.36381662f, 0.30356649f, 0.31017962f, 
    -0.28594697f, 0.16222966f, 0.25714999f, 0.08592298f, 0.11983787f, -0.37253156f, -0.28421313f, 0.10830912f, 
    -0.15032136f, -0.42501342f, 0.22782944f, -0.11533198f, 0.30354992f, 0.00104538f, -0.03688421f, 0.25016868f, 
    0.42134652f, 0.45479026f, -0.17870013f, -0.29983202f, -0.19945717f, -0.29861754f, -0.50180644f, -0.29998058f, 
    0.08088885f, -0.11213248f, 0.27331707f, -0.09467844f, 0.28632233f, 0.21958117f, -0.06220032f, 0.20224358f, 
    -0.11757971f, 0.15891899f, 0.03367024f, -0.35012692f, -0.27699494f, -0.20943746f, -0.29660591f, -0.29968703f, 
    -0.36197820f, -0.73798925f, -0.61818391f, 0.20665613f, 0.41830894f, 0.55322665f, 0.29083091f, 0.22903690f, 
    -0.71064347f, 0.31226286f, 0.43040138f, -0.22817738f, 0.17120636f, 0.26591977f, -0.29199690f, -0.24320370f, 
    -0.25317368f, -0.09313282f, -0.00291302f, -0.21777976f, -0.01428789f, -0.32540435f, -0.10310637f, -0.21467005f, 
    0.11132549f, -0.15376917f, -0.19995850f, -0.28570765f, -0.27203900f, -0.08678754f, 0.04489169f, -0.04524518f, 
    -0.42881009f, -0.76119721f, -0.45834023f, 0.08670563f, 0.01454760f, -0.22287180f, -0.20760857f, -0.17777167f, 
    -0.09384395f, 0.02288222f, 0.04205700f, -0.38066095f, -0.21810588f, -0.61856443f, -0.03085021f, -0.46950653f, 
    0.04533018f, -0.38176751f, -0.01908307f, 0.30270529f, 0.92225784f, 0.62204921f, -0.50484186f, -0.18788300f, 
    -0.66065300f, 0.27705321f, 0.02407597f, -0.15427728f, -0.02406000f, -0.00389351f, 0.13093153f, 0.15848868f, 
    -0.26746193f, -0.39065239f, 0.04668003f, -0.22951123f, -0.01113642f, 0.31344280f, -0.16070209f, -0.00979024f, 
    0.18900238f, 0.13304660f, -0.13441278f, -0.04027525f, -0.76239580f, 0.31958136f, 0.53448313f, -0.64184338f, 
    0.14658687f, -0.49313053f, -0.43388885f, -0.20824467f, 0.29504505f, 0.03796699f, -0.05501359f, -0.19884920f, 
    -0.24936314f, -0.09591061f, -0.02172423f, 0.13120200f, 0.13054268f, -0.26411891f, -0.09517501f, -0.19355860f, 
    0.10351636f, 0.35657701f, 0.27709445f, 0.15532774f, 0.13891646f, 0.50152624f, -0.20419167f, 0.01009694f, 
    -0.16417620f, 0.27501082f, 0.35260594f, 0.17162941f, 0.37681371f, 0.27307466f, 0.07208884f, -0.25606549f, 
    0.13746271f, 0.13210641f, 0.00283378f, 0.40592778f, -0.32562864f, -0.00589309f, -0.09569082f, -0.31355214f, 
    -0.34884965f, 0.27411398f, 0.10271037f, -0.09580210f, 0.14447115f, 0.05623624f, -0.22815362f, -0.21989571f, 
    -0.07267105f, 0.72420990f, -0.31024849f, 0.15395483f, -0.09981703f, -0.34094575f, -0.22628884f, 0.18823838f, 
    -0.20501290f, -0.04231122f, 0.16814055f, -0.42702034f, 0.31325856f, -0.00891270f, 0.14785956f, 0.20757507f, 
    0.17204721f, 0.21127403f, 0.37199464f, -0.34631786f, 0.08938777f, 0.07147668f, -0.19232146f, -0.27668422f, 
    0.39486340f, -0.42064369f, -0.34285820f, -0.41280708f, 0.03639251f, 0.07875726f, 0.18641794f, -0.25031808f, 
    -0.45973343f, -0.01689135f, -0.30540577f, -0.07667814f, -0.16607529f, -0.31989375f, -0.06841956f, 0.41305315f, 
    0.09127306f, -0.40370297f, -0.17576873f, 0.21043836f, 0.16902447f, 0.41850513f, 0.13339218f, 0.08980097f, 
    -0.95362943f, 0.37218460f, -0.23344566f, -0.84210485f, -0.45563117f, -0.07353657f, 0.43534538f, 0.20438701f, 
    0.54717112f, 0.56635940f, 0.16845040f, 0.29473609f, 0.07258775f, -0.16995558f, 0.01481214f, -0.15303244f, 
    -0.13464203f, -0.07371981f, -0.11563339f, -0.16286275f, -0.05088806f, 0.21626526f, 0.36769557f, -0.07629467f, 
    -0.03880387f, -0.21034712f, -0.24713558f, -0.38626677f, -0.22548275f, 0.09488497f, -0.26216283f, -0.50553960f, 
    -0.52287835f, -0.55177504f, -0.36815351f, 0.20050296f, -0.12649269f, 0.42703170f, 0.59182394f, 0.13456817f, 
    0.14555240f, -0.11491337f, -0.20514472f, -0.15949361f, -0.30035004f, -0.20021835f, 0.11529271f, 0.24392012f, 
    -0.04373403f, 0.00155874f, -0.50859791f, -0.41092926f, -0.02244093f, -0.41988316f, -0.49740726f, 0.77131158f, 
    0.18919712f, -0.13904682f, -0.17173901f, 0.55965143f, 0.15025815f, 0.44826594f, -0.21742690f, -0.28528741f, 
    -0.13657160f, -0.44828847f, -0.15428756f, 0.29001170f, -0.27039570f, 0.07106715f, -0.09441543f, 0.03492806f, 
    -0.09056754f, 0.38254160f, 0.34866139f, -0.59151477f, -0.10595939f, -0.39745572f, 0.72435218f, -0.08578975f, 
    -0.37043670f, -0.52947432f, -0.35048968f, 0.99121791f, -0.38198978f, 0.25882941f, -0.09778231f, 0.21609956f, 
    -0.18703566f, 0.16740254f, 0.01565330f, 0.22596611f, 0.02783036f, -0.58250976f, -0.09310023f, -0.02291688f, 
    0.04736647f, -0.23675045f, 0.01939376f, 0.11309639f, -0.10938149f, -0.00554590f, -0.59788257f, 0.50584155f, 
    -0.31087172f, -0.04104150f, -0.12576126f, -0.52765322f, 0.96970654f, -0.27604008f, -0.09534704f, -0.33410782f, 
    0.03320843f, 0.10169040f, 0.14691697f, 0.19176537f, -0.30232796f, 0.15465224f, -0.31029940f, 0.16346517f, 
    -0.31039724f, 0.13867441f, -0.19605272f, 0.16844714f, 0.17840473f, -0.15971763f, 0.35978514f, 0.22190949f, 
    0.32680923f, 0.19605324f, 0.09465457f, 0.24105407f, -0.35948151f, 0.07308804f, -0.51090884f, -0.09566338f, 
    0.13597797f, 0.16280715f, 0.36287978f, -0.31691962f, 0.03369391f, -0.08891343f, 0.19124493f, 0.09519466f, 
    0.14679867f, 0.02735526f, -0.11271125f, 0.13554054f, -0.06066845f, 0.01532812f, 0.02083583f, -0.65267527f, 
    -0.64990354f, -0.62652987f, -0.80997938f, 0.21870838f, 0.31165856f, 0.27706602f, 0.19868392f, 0.06507330f, 
    -0.04272743f, -0.22428411f, -0.04559262f, 0.04057358f, 0.27752367f, -0.03811727f, 0.14289322f, -0.30890128f, 
    -0.23290282f, -0.31311518f, 0.06741083f, -0.40363997f, 0.19439998f, -0.00494519f, -0.17064086f, 0.28337386f, 
    0.16819122f, -0.14683169f, 0.34425309f, 0.27395433f, 0.45600352f, 0.05297657f, -0.12972066f, -0.17342688f, 
    0.29956949f, 0.25884199f, 0.24452800f, -0.38761812f, -0.38941604f, 0.42881027f, -0.26313281f, -0.21077280f, 
    0.14420798f, -0.13333075f, 0.00781088f, 0.23905745f, 0.06899665f, 0.24943843f, -0.16942717f, -0.30918863f, 
    -0.41611689f, -0.50078249f, -0.57961744f, -0.18647754f, 0.07148586f, -0.28377739f, -0.34289730f, -0.54300886f, 
    -0.57828480f, -0.29624236f, 0.45995742f, -0.01586946f, 0.08929475f, -0.08733098f, 0.08449601f, -0.39762560f, 
    -0.28254527f, -0.13448447f, -0.18032314f, 0.03064088f, -0.26290217f, -0.09949070f, 0.19411667f, 0.12654039f, 
    -0.29772496f, -0.49807963f, -0.18526994f, -0.33292729f, -0.63800842f, -0.13428988f, 0.36119920f, -0.26659882f, 
    -0.31603363f, -0.08483531f, -0.57577431f, 0.02532953f, 0.00929083f, 0.06060488f, 0.40038148f, -0.31831273f, 
    0.04893310f, -0.18892500f, 0.11249991f, 0.11351798f, 0.02026713f, -0.01491168f, 0.26251394f, 0.19714688f, 
    -0.05947230f, 0.26032516f, -0.21436150f, 0.00284131f, 0.23155670f, -0.13672896f, 0.27782530f, -0.51523858f, 
    -0.38066405f, 0.28649399f, 0.33937135f, 0.11652236f, -0.28856364f, 0.07696658f, -0.41063070f, 0.71638823f, 
    -0.17840183f, 0.03560800f, 0.00354127f, -0.22827289f, 0.04648463f, 0.02688847f, 0.03939937f, 0.25080219f, 
    0.28612152f, -0.17463146f, -0.16920029f, 0.73173881f, -0.14533858f, -0.27354994f, 0.15016717f, -0.08208536f, 
    -0.12125684f, 0.03779572f, 0.20696075f, -0.14098221f, 0.09734061f, 0.56035894f, -0.21648124f, -0.32885891f, 
    -0.32325980f, 0.45637751f, 0.10553902f, 0.10452916f, -0.10662818f, 0.06028961f, -0.34007326f, -0.28890640f, 
    0.29621014f, 0.20045331f, -0.21087368f, -0.14733064f, 0.57491237f, 0.75002170f, 0.18811910f, -0.07597373f, 
    -0.04376495f, 0.07752741f, 0.11784554f, 0.14430226f, -0.28681678f, -0.12520963f, -0.30845052f, -0.12026718f, 
    -0.12555695f, 0.19139414f, -0.25783366f, 0.17968254f, 0.22413030f, -0.06061012f, -0.20706473f, -0.32528195f, 
    -0.43811956f, -0.00246141f, -0.34394509f, -0.36063388f, -0.44011840f, 0.67850906f, -0.87040144f, -1.11147773f, 
    -0.62051737f, 0.41093788f, -0.17966038f, 0.19810462f, 0.53566390f, 0.47663996f, -0.38545913f, -0.09437675f, 
    0.14871462f, -0.08152612f, -0.09146722f, -0.07738118f, -0.02083881f, -0.06643935f, 0.15976366f, 0.09805360f, 
    0.13995293f, -0.03661202f, -0.12399415f, -0.06159531f, -0.00072009f, -0.07844047f, -0.81547469f, -0.68961728f, 
    -0.13782996f, -0.40849021f, 0.58066219f, -0.14386936f, -0.20929250f, 0.32230639f, 0.62482059f, 0.24892868f, 
    0.14302941f, 0.10792199f, 0.06533928f, 0.17739038f, 0.07183344f, 0.00538798f, -0.08628370f, -0.21996681f, 
    -0.07962850f, -0.29990572f, -0.11645640f, 0.04368615f, -0.16920899f, -0.24224548f, -0.14320205f, -1.02893245f, 
    0.47399378f, 0.09710769f, -0.29304621f, 0.30107602f, 0.32047522f, 0.40816340f, -0.36916703f, -0.13839206f, 
    0.09397306f, -0.23034419f, 0.46027628f, -0.32836995f, 0.04295075f, -0.17782515f, 0.26735830f, 0.12136298f, 
    -0.17301373f, 0.15212315f, -0.39581436f, -0.10311726f, 0.34007257f, -0.30800644f, -0.09543912f, 0.18698278f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.20298740f, -0.09462992f, -0.03185757f, 0.31791121f, 0.20976384f, -0.04166340f, 0.08107448f, 0.19664225f, 
    -0.04787417f, 0.05422555f, 0.19327798f, 0.21181028f, 0.12127001f, 0.18107383f, -0.04313230f, -0.08202055f, 
    -0.00397416f, 0.02930417f, 0.25235206f, 0.20318297f, 0.11312675f, 0.08435073f, 0.11094622f, 0.19349641f, 
    -0.25546640f, 0.02729112f, 0.31605929f, 0.21794017f, 0.14017728f, 0.16222195f, 0.10711614f, 0.17941411f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.09355147f, -0.06783670f, 0.06547663f, 0.13585259f, 0.10298420f, -0.00724598f, -0.01770606f, -0.00508894f, 
    0.03174616f, -0.02097934f, -0.03709422f, -0.03941666f, 0.06790794f, 0.00151873f, 0.11635996f, -0.15208037f, 
    -0.14387724f, -0.13506064f, -0.01401120f, 0.10897514f, 0.01247348f, 0.11068211f, 0.23148306f, -0.04062726f, 
    0.08190534f, -0.20448567f, -0.08548955f, -0.01588999f, -0.00342550f, -0.03882438f, 0.01530389f, 0.08907998f, 
    0.18922006f, 0.06997639f, 0.05566365f, 0.07184877f, -0.24732287f, 0.09607413f, -0.07098076f, 0.00695950f, 
    0.09994929f, 0.07262523f, 0.06781983f, 0.14862628f, 0.05476451f, 0.09098698f, -0.00105484f, 0.04745631f, 
    0.07795426f, -0.05004619f, 0.00255399f, 0.10367841f, 0.01531821f, 0.01166030f, 0.14276983f, 0.04098517f, 
    -0.05088981f, 0.15862802f, -0.00744254f, -0.11046405f, -0.00882477f, -0.04363313f, 0.11350614f, -0.00664342f, 
    0.17602400f, 0.08432751f, 0.10062638f, 0.17922276f, -0.12460548f, 0.02742672f, -0.01384989f, 0.08060716f, 
    -0.16123863f, 0.05840324f, 0.02451141f, -0.02772859f, 0.20841901f, 0.05798049f, -0.11771862f, 0.07428584f, 
    -0.07814381f, 0.10162326f, -0.02976786f, 0.18627214f, -0.08798737f, 0.10720412f, 0.07836420f, 0.08992373f, 
    0.02604283f, -0.06036139f, -0.08198121f, 0.05086484f, 0.00635372f, 0.07546613f, 0.04349245f, 0.01717878f, 
    0.03746178f, -0.10270876f, -0.10085600f, -0.09784081f, -0.08443378f, 0.06146556f, 0.03658019f, 0.17855082f, 
    0.02390603f, 0.12138879f, 0.00508601f, 0.01770512f, -0.21825419f, 0.07243989f, 0.25085363f, 0.02168834f, 
    -0.02412003f, 0.05611366f, -0.11165898f, -0.00287421f, 0.10119192f, 0.10217795f, -0.08911688f, -0.01980233f, 
    -0.07074434f, -0.14824528f, 0.03316250f, 0.15442984f, -0.05847985f, 0.04341554f, 0.04363790f, 0.02314694f, 
    0.06939198f, 0.14157723f, 0.12248234f, 0.02354210f, -0.05180771f, -0.01057682f, 0.00868826f, -0.15987366f, 
    0.00169480f, 0.04049157f, -0.08263122f, -0.01876653f, -0.13421567f, 0.07887597f, -0.04635512f, 0.00928822f, 
    0.07632445f, -0.13209677f, -0.01525828f, -0.03452579f, -0.04938209f, -0.10371895f, -0.05977182f, 0.20339450f, 
    -0.01675417f, 0.00619246f, -0.05562696f, -0.09447389f, 0.17522278f, 0.12071162f, 0.04358894f, -0.09787121f, 
    -0.01023445f, -0.08161737f, 0.00316640f, -0.07846786f, -0.11637945f, -0.12140715f, 0.04038212f, -0.00956638f, 
    -0.08267907f, -0.08225210f, -0.09961588f, -0.02936732f, 0.04427995f, 0.11170290f, 0.04168187f, 0.04627162f, 
    0.00767554f, -0.02255663f, -0.09490139f, -0.01435808f, -0.00875754f, -0.07520279f, 0.04995850f, 0.06254733f, 
    0.00569899f, -0.11236906f, -0.03201125f, 0.05673196f, -0.01824477f, 0.03675037f, -0.09271576f, -0.03221022f, 
    0.06829184f, -0.07963948f, -0.00444486f, 0.06021265f, -0.07673120f, -0.10525186f, -0.04423492f, -0.03219725f, 
    0.00976940f, 0.30230275f, 0.11100907f, 0.03946164f, -0.19362703f, -0.18128462f, -0.06552866f, 0.04395204f, 
    -0.05788346f, 0.00956011f, -0.06673646f, 0.00069530f, 0.00821741f, -0.00278677f, 0.08168963f, -0.01360137f, 
    -0.24705771f, -0.14331988f, 0.14441513f, 0.02225157f, 0.04868853f, -0.13846169f, 0.00595219f, 0.18501520f, 
    0.03274381f, 0.24137287f, 0.01348172f, 0.01859374f, -0.04315582f, -0.31862730f, -0.11800353f, 0.20709537f, 
    0.13452595f, -0.04253052f, 0.04422685f, 0.32155064f, 0.16045868f, 0.15389393f, 0.08000302f, -0.04649378f, 
    0.16777404f, -0.13016073f, -0.08132321f, 0.07666021f, 0.08303789f, -0.02864593f, 0.03973801f, 0.25719970f, 
    0.18900411f, 0.02748943f, 0.10244220f, -0.01509923f, -0.03935919f, -0.09615906f, -0.03688504f, -0.10250083f, 
    0.06913425f, 0.03995182f, 0.04313606f, -0.13928017f, -0.11012441f, -0.05808065f, -0.04607744f, 0.03757439f, 
    0.00814088f, -0.03592001f, -0.03256804f, -0.06097763f, 0.05559861f, -0.07062987f, 0.06184628f, 0.07033937f, 
    0.03037650f, 0.12102138f, 0.11372319f, 0.04200384f, 0.12782545f, 0.02678544f, 0.04767818f, 0.09460986f, 
    -0.03781119f, 0.09269288f, -0.05048296f, -0.03492093f, 0.07124071f, -0.05201574f, 0.02921660f, -0.21095055f, 
    -0.14677119f, -0.21147540f, -0.01778735f, 0.01110963f, 0.02479281f, 0.14729621f, -0.06217462f, -0.01232863f, 
    -0.00265087f, -0.10004905f, 0.04752653f, 0.03437864f, -0.14522621f, -0.22206476f, -0.08603206f, -0.10664351f, 
    0.09185968f, 0.04566583f, 0.03846106f, -0.08146995f, 0.04656843f, -0.07533997f, -0.06447379f, -0.01663836f, 
    0.06339560f, -0.10039729f, 0.01473549f, -0.00476005f, 0.10693717f, 0.09521039f, -0.08041415f, 0.14136156f, 
    0.02268240f, 0.00376654f, 0.03188008f, -0.11811235f, 0.31988090f, 0.02933896f, 0.05444390f, -0.00301230f, 
    -0.13175003f, 0.09607986f, -0.05180173f, 0.13182491f, -0.08307216f, 0.07149862f, 0.36936474f, -0.21195880f, 
    0.24430650f, 0.02239586f, 0.09504320f, -0.03536123f, 0.00690062f, 0.02212765f, 0.04529524f, 0.14714643f, 
    -0.02442364f, 0.03214517f, 0.16616750f, -0.00962769f, 0.06454776f, 0.15901190f, 0.07041435f, -0.04859518f, 
    0.09245021f, -0.05918401f, 0.16797836f, 0.03509116f, -0.08461381f, -0.00441762f, 0.04140143f, 0.05741679f, 
    0.00018072f, -0.03644437f, 0.08097606f, 0.01236687f, 0.05983193f, -0.03918585f, -0.05320296f, -0.05473178f, 
    0.01140367f, 0.09079067f, 0.00612397f, 0.05239969f, -0.20460239f, 0.17049682f, 0.13281889f, -0.02885436f, 
    0.18324955f, 0.05926619f, -0.02609543f, -0.02615042f, 0.03105374f, -0.03299448f, 0.09998532f, 0.23680303f, 
    -0.18567067f, -0.22569123f, -0.04487638f, -0.05449541f, -0.04358916f, 0.00963740f, -0.01990494f, -0.02737170f, 
    -0.03624439f, -0.01824686f, 0.06539099f, 0.06630341f, -0.02580035f, -0.02462825f, -0.00021687f, -0.05357441f, 
    0.04825585f, -0.02387887f, -0.00173838f, 0.09958980f, 0.07643076f, 0.03676133f, 0.09265471f, 0.14746796f, 
    0.05398730f, -0.26216230f, -0.10354403f, -0.04482138f, 0.06090564f, 0.01696544f, 0.10026758f, 0.09412622f, 
    0.05123962f, 0.02747264f, 0.15823516f, -0.03054585f, -0.03548494f, 0.08284593f, -0.16908067f, 0.00778739f, 
    0.11720680f, 0.16677774f, 0.02703683f, 0.01877130f, 0.10830884f, 0.07193416f, 0.05750940f, 0.04811393f, 
    -0.30215877f, 0.09736259f, 0.10032976f, 0.07521684f, -0.01724070f, 0.08101435f, 0.11069625f, 0.16562711f, 
    -0.04749344f, 0.08608139f, 0.00453240f, -0.12470106f, 0.04188975f, -0.12200981f, 0.11121339f, 0.09437193f, 
    0.11386634f, -0.04309167f, -0.00402927f, 0.08315528f, 0.06897597f, 0.19147281f, 0.03035887f, -0.02470056f, 
    -0.02948739f, -0.04446683f, 0.10911329f, 0.06512446f, 0.06741017f, -0.06459253f, -0.11073594f, 0.06076553f, 
    -0.02682923f, 0.05330762f, 0.07834499f, 0.11254010f, -0.03640204f, -0.02519250f, -0.06114114f, -0.16949549f, 
    0.03195503f, 0.04203497f, -0.10459126f, 0.06291934f, 0.07580872f, 0.05662018f, 0.20875625f, 0.12706131f, 
    0.06627861f, -0.01108960f, -0.03547488f, -0.06499605f, 0.11950808f, 0.03471067f, -0.02887542f, 0.09090465f, 
    -0.06507949f, 0.13945505f, 0.09370193f, 0.09621093f, -0.14447640f, 0.03484611f, 0.02035151f, 0.14766376f, 
    0.04724411f, 0.02315236f, -0.05770579f, -0.04471746f, 0.19564953f, 0.20413165f, 0.32859963f, 0.19896014f, 
    -0.12553450f, -0.23302321f, -0.17465062f, -0.07924935f, 0.07537274f, 0.18944244f, 0.03462657f, -0.10874356f, 
    0.12570845f, 0.09364556f, 0.04393730f, -0.07750046f, -0.21334317f, 0.11260477f, 0.13997057f, -0.27917749f, 
    -0.05840131f, 0.11835124f, 0.06883122f, 0.01807671f, -0.13398871f, -0.05670024f, 0.00418525f, 0.05314532f, 
    0.05982960f, -0.18564630f, -0.32041502f, -0.01739731f, -0.00962115f, -0.01178191f, 0.06560858f, 0.10402703f, 
    -0.03107742f, -0.06351849f, 0.00247269f, 0.05376436f, -0.21839595f, -0.01075754f, 0.02807752f, -0.20948780f, 
    0.02941875f, 0.03764086f, 0.02478480f, -0.03275973f, -0.03908405f, 0.05347282f, 0.10694887f, 0.16663781f, 
    -0.00090672f, -0.07448309f, -0.02954147f, 0.07212608f, 0.10053027f, 0.06979397f, 0.18315382f, 0.00964339f, 
    0.05277757f, 0.00519069f, -0.05541308f, 0.04814585f, -0.21333976f, -0.33582142f, -0.01292899f, 0.12158688f, 
    0.01698384f, -0.05979957f, -0.25130612f, 0.06543291f, 0.02866627f, -0.05651280f, -0.02939827f, 0.01525858f, 
    0.08337379f, 0.29956254f, 0.09661561f, 0.34692559f, 0.03324344f, -0.02396191f, -0.05382813f, -0.02542328f, 
    0.01325840f, 0.18120585f, 0.03592436f, 0.20460169f, -0.20147741f, -0.37851182f, -0.22081390f, -0.13901065f, 
    -0.05655898f, 0.07954916f, 0.02063937f, 0.00438623f, -0.07216378f, 0.02865389f, -0.02421538f, 0.05090800f, 
    -0.19843771f, -0.00524882f, 0.21120410f, 0.49985078f, 0.16054063f, -0.20318268f, 0.11165296f, 0.10383496f, 
    0.05635254f, -0.00046862f, -0.00697102f, 0.18997902f, 0.45330280f, -0.34549618f, -0.32293415f, -0.13461244f, 
    0.31582093f, -0.24697950f, 0.10067049f, 0.18079062f, 0.13167405f, 0.11230411f, 0.06940030f, 0.00131351f, 
    0.21336396f, -0.20945005f, 0.03284381f, 0.11183662f, 0.15887876f, 0.01192404f, 0.10080304f, 0.15145648f, 
    0.10078359f, -0.04270238f, 0.03186515f, 0.12851629f, -0.07223844f, -0.06432334f, 0.01559116f, -0.03462335f, 
    0.03418231f, 0.17895153f, 0.12646759f, -0.01542171f, 0.01272616f, -0.03990379f, -0.07239997f, 0.06220564f, 
    -0.10405755f, 0.13065618f, 0.05968447f, 0.13056484f, -0.02443900f, 0.05506746f, 0.03150070f, -0.06323989f, 
    -0.03566098f, 0.07443152f, 0.13242026f, 0.15712309f, -0.05955077f, -0.04753777f, 0.15187874f, -0.03823541f, 
    -0.05756519f, 0.06852186f, -0.02720153f, -0.04436751f, -0.03877963f, 0.04092400f, 0.04579767f, 0.05880198f, 
    -0.15707403f, -0.30667159f, -0.11654865f, -0.11506782f, 0.00925783f, -0.05551242f, 0.03507555f, -0.02732715f, 
    -0.07846015f, -0.11708193f, 0.03811022f, -0.02714029f, -0.14013608f, -0.37869847f, -0.14229341f, -0.06470174f, 
    0.11462121f, 0.07230299f, -0.05655995f, -0.09836368f, -0.02847584f, -0.10919957f, -0.04137495f, 0.00495479f, 
    0.32857573f, -0.03742304f, -0.13419837f, -0.07094172f, 0.31779811f, 0.17240465f, 0.19172981f, 0.00626518f, 
    -0.03217322f, -0.00955119f, 0.12155525f, 0.04502359f, 0.08685611f, -0.06115964f, -0.07496513f, -0.08016332f, 
    -0.10405707f, 0.15142225f, 0.02149439f, 0.11726105f, 0.02881298f, 0.09326136f, 0.15944213f, 0.05007413f, 
    -0.15308669f, 0.02072468f, 0.11940578f, -0.09182382f, -0.04694565f, -0.00802186f, 0.02627115f, 0.10973404f, 
    -0.09812180f, -0.10473232f, 0.07561281f, 0.07815938f, -0.12328374f, -0.12127239f, 0.27979845f, -0.01201374f, 
    0.10868105f, 0.09783503f, 0.04914038f, 0.16468681f, 0.01812842f, 0.05900490f, 0.13917828f, 0.13592114f, 
    0.25846261f, 0.15689716f, 0.18298468f, 0.17866835f, 0.07474798f, -0.07728460f, -0.06301995f, -0.07141535f, 
    0.06882897f, 0.22700077f, 0.09995503f, 0.11343738f, -0.14541484f, -0.06418718f, -0.03181659f, -0.03571334f, 
    -0.02021026f, 0.05935044f, 0.00243964f, -0.02728653f, 0.11312459f, 0.16527377f, 0.08111912f, -0.07459493f, 
    -0.12115972f, -0.11127545f, 0.05357552f, 0.24204634f, 0.06566285f, 0.03416124f, -0.07568786f, 0.03672067f, 
    -0.17142363f, -0.10236769f, -0.05827175f, -0.11369587f, 0.16492732f, 0.04327969f, 0.08322821f, -0.00505585f, 
    -0.04644651f, -0.06424467f, 0.01620849f, 0.06648426f, -0.04501542f, -0.01101661f, 0.14633325f, -0.13040464f, 
    -0.01654005f, -0.10988472f, 0.02175311f, 0.18681905f, 0.06799602f, 0.02535892f, -0.04088745f, -0.06453472f, 
    0.01214652f, -0.02372750f, -0.07869109f, 0.16310601f, -0.27616277f, -0.10480670f, 0.09786079f, 0.02473256f, 
    0.00249670f, 0.01497018f, -0.00015469f, 0.08301963f, -0.05397687f, -0.07045383f, -0.02045563f, 0.09606324f, 
    0.02246284f, 0.15306802f, 0.15502635f, -0.04669358f, -0.02429354f, 0.04220938f, 0.20373140f, -0.10910920f, 
    0.05269795f, -0.02548680f, -0.01139950f, -0.10968478f, 0.06070179f, -0.13147821f, -0.03232146f, 0.07909081f, 
    -0.02379403f, -0.03981904f, -0.07019408f, 0.16795377f, -0.00863781f, 0.03967308f, -0.09958580f, -0.01017058f, 
    -0.07987610f, 0.01774447f, -0.13224520f, -0.06352866f, -0.03733066f, 0.00597499f, 0.00677280f, 0.10185228f, 
    -0.07201411f, 0.13305026f, -0.06896351f, -0.10837647f, 0.11659759f, 0.13861908f, -0.05762447f, 0.11388665f, 
    0.06402998f, 0.00158698f, 0.01370067f, 0.01270228f, 0.05634252f, -0.00389713f, -0.09304404f, -0.00381048f, 
    -0.04964127f, -0.01160681f, 0.03250922f, 0.06754586f, -0.00669749f, 0.02380782f, 0.01883709f, -0.04795966f, 
    0.28470454f, 0.10354086f, 0.11454883f, 0.11665240f, 0.13401528f, -0.10606012f, -0.01858129f, -0.14594577f, 
    -0.00416618f, 0.06270605f, -0.06957862f, 0.00846600f, 0.06260149f, 0.13778609f, -0.02125450f, 0.02412470f, 
    -0.04982559f, -0.06932405f, 0.05171734f, 0.20811552f, 0.08600350f, 0.03187383f, 0.00718788f, 0.05179276f, 
    -0.03779478f, 0.01476371f, 0.05766314f, 0.00931110f, 0.44863424f, 0.06035349f, 0.13685465f, -0.07692149f, 
    -0.00097973f, -0.04959562f, 0.02208420f, -0.05837421f, 0.04238651f, -0.00112588f, 0.11247846f, -0.03633516f, 
    -0.04325388f, -0.11860909f, -0.22107594f, 0.21184354f, 0.02559408f, 0.01916626f, 0.00609539f, 0.04552880f, 
    -0.01266124f, -0.03029961f, 0.00369953f, -0.09010927f, 0.33016145f, 0.19307537f, 0.13767007f, 0.08654700f, 
    -0.01479025f, -0.03534503f, -0.02231906f, 0.05056365f, 0.04562153f, -0.09828001f, -0.01187705f, 0.00096408f, 
    0.02412393f, -0.09448127f, -0.01938163f, -0.07645137f, -0.04233896f, 0.05664170f, -0.08451587f, -0.08726379f, 
    0.04353481f, -0.01444367f, -0.03788177f, -0.03146089f, -0.12907545f, -0.13152570f, 0.07969858f, 0.09931323f, 
    0.09430066f, -0.09117451f, 0.06698354f, 0.13274792f, -0.03385103f, -0.08608478f, -0.06993946f, -0.07166336f, 
    0.28451356f, 0.18071145f, -0.08691846f, 0.01387707f, -0.10018966f, -0.11883916f, -0.10620707f, -0.07835917f, 
    -0.06531076f, -0.08209464f, 0.06372799f, 0.10221513f, -0.16074817f, -0.14272100f, 0.15104023f, 0.34581518f, 
    -0.01178047f, -0.04539299f, -0.06607782f, 0.00925426f, -0.09076398f, -0.02453509f, 0.03476286f, -0.00523168f, 
    -0.03436889f, 0.03337966f, 0.12206603f, -0.00964417f, 0.05240921f, -0.09857771f, -0.10267811f, 0.05308151f, 
    -0.16532616f, 0.17294252f, 0.04075570f, 0.01536100f, -0.14975572f, -0.18837540f, -0.25637618f, 0.20572738f, 
    -0.14511807f, 0.06742761f, -0.19521393f, 0.05330291f, -0.08005086f, -0.05285811f, -0.05851419f, 0.03510386f, 
    -0.17689134f, -0.01143784f, -0.25289401f, 0.09217583f, -0.05706644f, 0.13532265f, -0.10580438f, 0.19915117f, 
    -0.01489005f, 0.11745740f, 0.06764404f, -0.08145410f, -0.01042709f, 0.02209651f, -0.00487213f, 0.06319501f, 
    -0.00329893f, 0.12271070f, 0.01426322f, 0.02264822f, -0.08483103f, -0.05884354f, 0.04789278f, 0.07281565f, 
    -0.03870500f, 0.13839875f, 0.27947432f, 0.20346737f, -0.15129207f, -0.20952877f, 0.07914706f, -0.06866933f, 
    -0.01591198f, 0.10444362f, 0.02422930f, 0.14501578f, 0.30405748f, 0.02621860f, 0.09500713f, 0.05817312f, 
    0.09348534f, 0.04359185f, -0.01061783f, -0.01979311f, 0.03796394f, -0.00532613f, -0.04226679f, -0.05525827f, 
    -0.15202065f, -0.04524580f, 0.18098681f, 0.17772189f, -0.03162139f, 0.02170708f, 0.03255764f, 0.10375000f, 
    -0.11350947f, -0.05489879f, -0.01330604f, 0.06261605f, -0.23779033f, -0.19384740f, 0.08484706f, 0.08185513f, 
    0.05698126f, -0.15209165f, -0.07744890f, 0.02386653f, 0.04082967f, 0.03061932f, -0.02541644f, 0.02240568f, 
    -0.06263793f, -0.00631166f, -0.09712364f, 0.06785127f, -0.04174536f, 0.04058145f, 0.00666728f, 0.09161571f, 
    0.02425255f, -0.04649409f, 0.07639080f, -0.10670983f, 0.28103074f, 0.06694070f, 0.18911612f, -0.09380892f, 
    0.06796525f, 0.00076319f, 0.07339523f, -0.03290044f, 0.10026269f, 0.06482091f, 0.08429337f, 0.00039525f, 
    0.40926263f, 0.13394895f, 0.06198959f, 0.01207718f, 0.05596052f, 0.01590103f, 0.10239985f, -0.06733800f, 
    0.09110297f, 0.05395598f, 0.14843941f, 0.29005334f, -0.25447941f, 0.21087918f, 0.21054989f, 0.08459854f, 
    -0.03221003f, -0.02653420f, 0.08409605f, -0.13270371f, 0.03629332f, 0.04210845f, 0.02303771f, -0.01146777f, 
    0.10313769f, -0.02014437f, -0.09528393f, 0.13870943f, -0.07078448f, -0.09730703f, -0.03129866f, -0.00271970f, 
    0.12555386f, 0.09538805f, -0.00571233f, 0.14082178f, 0.26233026f, -0.40406495f, 0.02329945f, 0.24800009f, 
    0.17307115f, -0.00130005f, -0.03079609f, -0.03261841f, 0.07471917f, -0.01723251f, 0.06193218f, 0.02366201f, 
    -0.01291774f, -0.00520211f, -0.00289922f, -0.04781552f, -0.05401827f, -0.04709081f, -0.03108853f, -0.05079208f, 
    -0.02744319f, -0.02543848f, -0.00543035f, -0.01511622f, -0.01742905f, -0.03552052f, 0.04281525f, -0.03004271f, 
    -0.03719792f, -0.00086084f, -0.01436815f, -0.01744594f, -0.00272051f, -0.02440477f, -0.03548712f, -0.04523018f, 
    0.03516253f, 0.04807305f, -0.03983406f, 0.01988959f, 0.04665046f, 0.03965605f, -0.05800188f, 0.03708228f, 
    -0.05398319f, -0.04303288f, 0.02295279f, 0.02949571f, 0.00629402f, 0.01380619f, 0.04054331f, 0.01896049f, 
    0.03150440f, -0.00253070f, -0.00676759f, -0.01619565f, -0.00800008f, 0.03832174f, -0.01483528f, 0.00830184f, 
    -0.02104368f, -0.02860034f, 0.00886172f, 0.00105984f, -0.01396395f, -0.02171339f, 0.03292509f, 0.02073996f, 
    0.00616413f, -0.02082573f, -0.00403499f, -0.00826864f, 0.00147077f, -0.00444015f, 0.03787385f, -0.03189512f, 
    -0.00586940f, 0.02083776f, 0.01543256f, -0.05600873f, -0.02152976f, -0.05099422f, 0.00308392f, -0.01883846f, 
    0.00291140f, -0.02373251f, -0.00320143f, -0.00511180f, -0.02364802f, -0.00797691f, -0.04895337f, 0.01909038f, 
    -0.03569023f, 0.02784887f, -0.04291140f, 0.02956089f, 0.01170284f, 0.01878758f, -0.02986799f, -0.02234448f, 
    0.00638622f, 0.00042673f, 0.00609495f, 0.04009796f, 0.03110137f, 0.00161259f, -0.01946196f, -0.03448849f, 
    -0.03730160f, 0.01424967f, -0.04343471f, -0.00684546f, 0.03483875f, 0.04122527f, -0.02677306f, 0.00393481f, 
    -0.01687019f, 0.02520636f, 0.03293730f, -0.05674081f, -0.04904897f, 0.02569647f, 0.03308909f, -0.00590292f, 
    0.04471753f, 0.03314726f, -0.03153264f, -0.00164635f, 0.03454633f, -0.00225487f, -0.02521029f, -0.02702281f, 
    -0.00773783f, 0.04178315f, -0.05030986f, -0.02088769f, -0.00300480f, -0.01698634f, -0.04352786f, -0.01723624f, 
    0.00914909f, 0.03440525f, 0.01055287f, -0.00717229f, -0.00940560f, 0.03118112f, -0.00467235f, -0.02298843f, 
    0.02091960f, 0.04097054f, 0.00278473f, 0.02962006f, 0.01023520f, 0.04312654f, 0.00861799f, 0.04934090f, 
    -0.04986092f, -0.03317361f, -0.04817446f, -0.02846043f, 0.03839671f, -0.04311896f, -0.00175190f, 0.03860102f, 
    -0.01241985f, -0.00666393f, 0.03446402f, -0.04360054f, 0.01940801f, -0.00411629f, -0.05078050f, -0.03682328f, 
    0.02815671f, -0.05316749f, 0.00216771f, -0.01833525f, -0.03703227f, -0.05086176f, -0.01813495f, -0.05126562f, 
    0.02308884f, -0.04033548f, -0.04610747f, 0.00719403f, -0.05487958f, 0.02007621f, -0.00115183f, 0.00602715f, 
    0.03688296f, -0.04346794f, 0.03465208f, 0.02554531f, -0.04038374f, -0.06165743f, 0.02660134f, 0.01942103f, 
    -0.03710075f, -0.02003027f, -0.04304684f, -0.03302931f, -0.02316325f, -0.00932426f, -0.04083465f, -0.01911883f, 
    -0.05529086f, -0.00978261f, 0.04557238f, 0.00486276f, -0.05241629f, 0.00322235f, -0.05460527f, 0.03831271f, 
    -0.01914126f, -0.02294882f, 0.04532348f, 0.00165654f, 0.05266224f, 0.02195712f, 0.02723492f, 0.02171236f, 
    -0.00257798f, 0.02910689f, -0.00792482f, 0.03728804f, -0.02088421f, 0.02805097f, 0.04231744f, 0.00209472f, 
    -0.03688231f, 0.03384998f, 0.03627742f, 0.04420497f, 0.04370019f, 0.01298568f, 0.02542430f, -0.03406919f, 
    0.00168328f, -0.02298110f, 0.00990304f, 0.04393062f, 0.00240383f, -0.01422575f, 0.02186078f, -0.00425504f, 
    -0.02252853f, 0.01058427f, -0.01235736f, 0.00093410f, 0.00890946f, -0.01146835f, 0.00468863f, 0.02789207f, 
    0.03571232f, 0.03901989f, 0.02829986f, 0.00502795f, -0.02095625f, 0.01529841f, -0.05501964f, 0.02272554f, 
    -0.02976523f, -0.03189151f, -0.00444243f, -0.05028857f, 0.00124579f, 0.00263892f, -0.05100103f, 0.00738214f, 
    0.00785952f, -0.02453932f, -0.04868173f, 0.01407185f, 0.02117941f, -0.04668064f, 0.02197348f, 0.01695275f, 
    0.02445897f, -0.02017212f, -0.00577865f, 0.02431050f, -0.03463522f, -0.04427936f, -0.03036130f, 0.03303143f, 
    0.02994438f, -0.03713012f, -0.01904053f, -0.03030586f, -0.01808731f, 0.03572761f, 0.00594469f, 0.01976885f, 
    -0.05023280f, 0.02871196f, -0.05384600f, 0.04349246f, -0.03568710f, -0.01387713f, -0.03125983f, 0.01171815f, 
    0.00548095f, 0.01118014f, 0.03634281f, 0.04956966f, 0.04558798f, 0.00126066f, -0.03636821f, -0.01075657f, 
    0.04759869f, -0.02872952f, -0.02483389f, -0.01001140f, 0.05156877f, -0.03093578f, 0.01319500f, 0.00742329f, 
    -0.00514253f, -0.01819185f, -0.02371550f, 0.01173192f, 0.04824596f, -0.04435608f, 0.01264385f, -0.04872708f, 
    0.01842486f, -0.03932973f, 0.00079807f, -0.02119009f, -0.00420547f, -0.00127089f, -0.03261287f, -0.00091203f, 
    0.01373888f, -0.05600136f, -0.02637520f, 0.02075772f, 0.03011526f, -0.03596741f, -0.01911761f, -0.02592343f, 
    -0.00243383f, 0.01581569f, -0.02237985f, -0.05415457f, -0.02179104f, -0.06342284f, 0.03706931f, 0.02043092f, 
    -0.06041397f, 0.03649278f, -0.01905360f, 0.01792750f, -0.02439612f, -0.02892541f, -0.05505340f, -0.03663696f, 
    0.02478834f, -0.01615618f, 0.01396912f, 0.04288315f, -0.04293597f, 0.02603115f, -0.01567050f, 0.03190720f, 
    -0.01016794f, -0.03425524f, 0.00309394f, -0.04874054f, 0.03743913f, 0.04403479f, 0.02136648f, -0.01582153f, 
    0.01357831f, -0.02733337f, 0.03264428f, -0.04386672f, -0.02393344f, 0.01535663f, -0.03415230f, -0.01657395f, 
    0.03142050f, -0.03402987f, -0.02261434f, -0.00207060f, -0.01833744f, -0.04300185f, -0.05538151f, -0.03766077f, 
    -0.02620324f, 0.01222335f, -0.04577258f, 0.03273857f, 0.01640526f, -0.02511219f, -0.03639452f, 0.01701550f, 
    0.24270637f, 0.27520716f, 0.13984399f, -0.03258831f, 0.15131244f, -0.00517190f, -0.00510146f, 0.06182946f, 
    0.08244404f, -0.08709526f, 0.02948842f, 0.07742756f, -0.15497658f, -0.12228593f, -0.03665766f, -0.13043883f, 
    -0.00322324f, 0.04571898f, -0.08739285f, -0.13804486f, 0.17858942f, 0.04867619f, -0.13567531f, 0.12804052f, 
    0.08816031f, -0.01576437f, -0.04632881f, -0.02351396f, 0.08128119f, 0.03836076f, 0.17680211f, 0.21776338f, 
    -0.07619496f, -0.20806783f, -0.14551848f, -0.16015871f, 0.32887390f, 0.16834807f, 0.00288457f, 0.10675720f, 
    0.16929129f, -0.05284048f, -0.00339119f, 0.14506920f, -0.02290454f, -0.18352616f, -0.00326807f, -0.13900435f, 
    -0.02686662f, -0.12473157f, -0.35325065f, 0.22339313f, 0.03315726f, -0.06899980f, 0.00600395f, -0.00706040f, 
    0.04335296f, 0.08197375f, 0.03492960f, 0.10070671f, -0.23467807f, -0.28210658f, -0.04747691f, -0.15167190f, 
    0.06741115f, -0.02084908f, 0.08216174f, -0.16809377f, 0.00313508f, 0.02731244f, 0.13937171f, 0.01256427f, 
    0.24241617f, -0.05906547f, -0.03542424f, 0.04858323f, -0.11035424f, -0.08523361f, 0.00683210f, -0.20735085f, 
    0.23414452f, -0.01447397f, 0.04797943f, 0.17919689f, 0.27669999f, 0.17488550f, 0.01961475f, -0.07247782f, 
    -0.21081962f, 0.01072285f, -0.00984147f, -0.04915165f, -0.04307315f, -0.00408530f, 0.13315153f, 0.02327813f, 
    0.08213623f, -0.12825255f, -0.19503024f, 0.01530726f, -0.11284377f, 0.02086458f, 0.07304370f, 0.09328322f, 
    -0.16097024f, -0.08098182f, -0.09524687f, -0.17502931f, 0.18300621f, 0.24284783f, 0.30888790f, -0.01879862f, 
    -0.08576990f, -0.09404437f, -0.04102987f, 0.02327367f, 0.21539395f, -0.02044792f, 0.22031172f, -0.01624795f, 
    0.08155995f, 0.14120644f, 0.18372844f, -0.10203486f, -0.07868724f, 0.05279174f, 0.06132657f, 0.04745043f, 
    0.00621677f, -0.20466742f, -0.06504131f, -0.09119754f, -0.52439457f, 0.30458438f, -0.28427979f, 0.34217960f, 
    -0.00348994f, 0.03445131f, -0.04386548f, 0.00345765f, -0.05386580f, -0.01954112f, -0.10251191f, 0.09687082f, 
    0.06160162f, 0.01765373f, 0.21199454f, 0.05485627f, 0.07375509f, 0.12013701f, -0.02161673f, 0.09401754f, 
    0.12637840f, 0.11018578f, 0.04077423f, 0.04153938f, -0.09007012f, 0.01648238f, 0.04219992f, -0.17044955f, 
    0.01517808f, -0.12380530f, -0.10844930f, -0.12977572f, 0.08951344f, 0.10228797f, 0.03390002f, 0.09016675f, 
    0.29231927f, 0.04022514f, -0.04510900f, -0.05896126f, -0.07577108f, 0.03605311f, -0.03664086f, 0.05824664f, 
    -0.14262463f, 0.26896885f, 0.12603462f, -0.03437588f, 0.11720896f, 0.16506009f, -0.14292109f, 0.19681305f, 
    0.07686502f, 0.06449300f, -0.00301469f, -0.05519784f, -0.10460898f, 0.02607829f, 0.16426197f, 0.18336131f, 
    0.02004598f, -0.31957385f, -0.01304315f, 0.14693807f, -0.14513248f, -0.11429127f, 0.17227870f, 0.12709692f, 
    0.13278057f, 0.10285442f, 0.14220844f, 0.00443377f, 0.10666706f, 0.09256070f, -0.08915041f, -0.20228580f, 
    0.12380432f, 0.13147752f, 0.10787772f, -0.04889840f, -0.08561253f, -0.00601977f, -0.07877179f, 0.06518205f, 
    -0.15235049f, -0.28540888f, 0.07153536f, 0.06808482f, -0.13993359f, 0.18752782f, -0.04565635f, 0.03235919f, 
    0.29416278f, 0.08225663f, 0.08633550f, -0.00695362f, 0.49249652f, 0.05038307f, 0.17975771f, -0.02974911f, 
    -0.00358675f, 0.21886970f, 0.12258055f, 0.10260172f, 0.13152167f, 0.03363353f, 0.03171730f, -0.00334000f, 
    0.42394066f, 0.03496156f, 0.04928523f, -0.07572103f, -0.11763942f, 0.34161788f, 0.15827075f, 0.04146069f, 
    -0.03034012f, -0.13107088f, -0.04878855f, 0.02682812f, -0.07947803f, 0.07247118f, -0.16608272f, -0.03827630f, 
    -0.01229418f, -0.12229621f, -0.00659539f, -0.07984921f, 0.00922454f, 0.09745398f, 0.08621129f, -0.12535957f, 
    -0.09729664f, -0.19553787f, -0.33239043f, -0.15449452f, 0.04791252f, 0.14777160f, -0.09003947f, 0.17258394f, 
    0.01535675f, -0.03014441f, -0.07984704f, 0.00971361f, -0.06020916f, 0.04006297f, 0.14522366f, -0.27138779f, 
    -0.16618443f, -0.03995837f, -0.00066981f, -0.03044208f, 0.03827742f, 0.00188518f, 0.11322044f, -0.09079957f, 
    0.15145117f, 0.14481297f, -0.10766970f, -0.16462506f, 0.27375853f, 0.11262292f, -0.00033493f, 0.05922285f, 
    -0.10846673f, -0.09622865f, -0.11089926f, -0.07465718f, 0.06281921f, 0.06409852f, -0.21193084f, -0.21248420f, 
    0.08094154f, 0.23142251f, 0.18589756f, 0.11236563f, -0.06265763f, -0.08490369f, -0.10874316f, 0.09652746f, 
    0.01121157f, 0.10337252f, 0.14547490f, 0.03879512f, 0.01992344f, -0.02513252f, 0.07000756f, -0.11188529f, 
    -0.05287850f, 0.15962131f, -0.10027421f, 0.05775513f, 0.09719819f, 0.10536950f, 0.09220248f, -0.09996287f, 
    0.13131861f, 0.08240815f, -0.00073266f, 0.08942623f, -0.00621055f, -0.09791298f, -0.07993215f, -0.11167517f, 
    -0.21793897f, -0.01663559f, -0.07821434f, 0.21916918f, -0.08462200f, 0.10885157f, 0.05997993f, 0.00276800f, 
    -0.03650895f, -0.10083777f, -0.06631804f, -0.31918630f, 0.17053744f, -0.15469836f, -0.39667898f, -0.29109845f, 
    0.09353789f, -0.09317397f, 0.23139314f, 0.13216646f, -0.04843566f, -0.02961166f, -0.01722310f, 0.07960606f, 
    0.20801914f, -0.09387697f, 0.04616065f, -0.22173484f, -0.02766084f, 0.11879172f, 0.03812923f, 0.05617874f, 
    -0.00431748f, -0.00596675f, 0.01571450f, -0.04445770f, -0.02455411f, 0.32968730f, 0.18183345f, -0.48299998f, 
    -0.10393161f, 0.09142081f, 0.09125660f, 0.01739644f, 0.02850630f, 0.01819347f, 0.13203742f, 0.00152492f, 
    0.03036242f, -0.03244136f, -0.05162757f, 0.01546887f, -0.05381322f, -0.05392331f, -0.01790164f, 0.01829067f, 
    -0.01035183f, -0.01239461f, 0.00018225f, -0.05190546f, -0.06126808f, 0.01936603f, -0.04907242f, 0.02845543f, 
    0.00694442f, -0.04917578f, -0.03572485f, -0.03991091f, 0.00817469f, -0.00799691f, -0.01621635f, -0.02350630f, 
    0.03010737f, 0.03821428f, 0.00104939f, 0.03405136f, -0.00131963f, 0.03381503f, -0.00191755f, -0.01488905f, 
    -0.02773949f, -0.00593268f, 0.02721218f, 0.03066712f, 0.02907184f, -0.00532416f, 0.02292618f, -0.03343141f, 
    -0.01621525f, -0.02085111f, 0.00711845f, -0.04013244f, 0.02827822f, -0.03954237f, -0.03788342f, -0.02033111f, 
    0.02127292f, -0.03819523f, -0.02504674f, -0.02229360f, 0.02284251f, -0.01514092f, -0.03121302f, -0.03804523f, 
    -0.05960026f, -0.02830953f, -0.03293721f, -0.05650581f, -0.00721605f, -0.01264371f, -0.04655791f, 0.04486993f, 
    -0.00127167f, -0.03426369f, -0.02134238f, -0.03540462f, 0.00832983f, 0.01778500f, 0.00426767f, 0.04435081f, 
    -0.01247769f, -0.01518231f, -0.03893541f, -0.00492905f, 0.03618991f, -0.05994216f, -0.02427904f, 0.02613055f, 
    -0.01075807f, -0.00962262f, -0.02906918f, 0.00429584f, 0.03657477f, 0.00900277f, 0.01933606f, -0.02617521f, 
    0.03114811f, -0.03089595f, -0.01848231f, 0.01949238f, -0.05729873f, -0.04905956f, 0.02844672f, 0.00027868f, 
    -0.05161554f, 0.04306575f, 0.03868400f, 0.02098662f, -0.00024492f, -0.02974494f, -0.00246024f, -0.05878634f, 
    0.02588885f, 0.01711481f, 0.01885166f, -0.01785105f, -0.01733646f, 0.03622882f, 0.01820110f, -0.03396464f, 
    -0.04979289f, -0.05717582f, -0.03704813f, -0.01829165f, -0.00510361f, 0.00416820f, 0.02653609f, 0.00691805f, 
    -0.02150422f, -0.01154667f, 0.03006557f, 0.02797585f, -0.01977583f, -0.04951626f, -0.01613679f, -0.03398924f, 
    -0.02537549f, -0.00750295f, 0.03909681f, -0.00178756f, -0.05979370f, 0.01299591f, -0.04736720f, 0.01939647f, 
    -0.04662992f, -0.03120898f, 0.00574368f, -0.03751776f, 0.02120072f, 0.03603796f, -0.03928596f, -0.00670728f, 
    0.00637838f, -0.00585667f, -0.02741940f, -0.06513309f, -0.02895585f, 0.00066776f, -0.02401176f, -0.02468966f, 
    0.02105849f, -0.01778126f, 0.02992944f, -0.01270020f, 0.01687312f, -0.01678659f, -0.02653032f, -0.01074411f, 
    0.02571845f, -0.04702095f, 0.03314363f, -0.01560430f, 0.04189005f, -0.03429483f, -0.00461425f, -0.00723946f, 
    -0.03735783f, 0.04163280f, 0.01553160f, -0.02494883f, -0.04646130f, -0.00544185f, -0.02285385f, -0.04880824f, 
    0.04487149f, -0.03975358f, 0.02885526f, 0.01350391f, -0.05113491f, 0.00372869f, 0.03459096f, -0.00580229f, 
    0.02551578f, 0.03436494f, 0.02692848f, 0.00458416f, 0.03593417f, -0.03018832f, 0.00554504f, -0.04895794f, 
    0.02792694f, 0.00115143f, -0.05069281f, 0.03594660f, -0.05059975f, 0.04233303f, 0.02992728f, -0.00570486f, 
    -0.01177804f, 0.03022039f, -0.01572516f, -0.05015180f, -0.05720954f, 0.01936905f, 0.01985706f, -0.06231246f, 
    0.03661930f, 0.03950627f, -0.02226502f, 0.00444889f, -0.03357916f, 0.00689505f, 0.00714576f, -0.01281671f, 
    -0.03075959f, -0.03079017f, -0.02884707f, 0.03335483f, -0.01439510f, -0.03769594f, 0.00872194f, 0.00874496f, 
    0.00852335f, 0.01834754f, -0.05370486f, -0.02520895f, -0.01165198f, -0.00701172f, -0.00534511f, -0.05169439f, 
    0.02251860f, 0.03944634f, -0.01430804f, -0.03013180f, -0.04820105f, 0.03579550f, -0.00741933f, 0.03848433f, 
    -0.02129740f, 0.03872570f, -0.00765085f, -0.04442925f, -0.00260004f, -0.03019086f, -0.04647413f, -0.01565677f, 
    0.02659047f, -0.01432777f, -0.01774815f, 0.00703380f, -0.03379719f, 0.03911312f, -0.02740971f, -0.01820608f, 
    0.02525019f, 0.00698794f, 0.04068751f, 0.03067099f, 0.03166607f, -0.02404981f, -0.03303113f, -0.00058380f, 
    -0.03571808f, -0.05965038f, -0.05514797f, -0.00612363f, -0.01170778f, 0.00329037f, -0.05555783f, 0.01461106f, 
    -0.03469844f, 0.04105129f, -0.02097000f, 0.00732039f, -0.02440945f, -0.03427679f, -0.03868335f, 0.01662497f, 
    0.03965253f, 0.00180511f, 0.04133136f, 0.01424938f, -0.00912490f, -0.00435772f, 0.01121406f, -0.03586451f, 
    0.02503328f, 0.01722796f, -0.03381265f, 0.03057698f, 0.03331161f, 0.02123990f, -0.04317591f, -0.00964736f, 
    -0.03121718f, 0.02891911f, -0.05619580f, -0.00966346f, 0.01613336f, -0.00420683f, -0.03589014f, -0.00257489f, 
    0.02025015f, 0.02472250f, -0.02959743f, -0.01128065f, -0.01258796f, 0.01748272f, 0.02747128f, 0.00897736f, 
    -0.00389226f, 0.02944817f, -0.02745876f, -0.02709964f, 0.03932533f, -0.03793968f, 0.02222514f, -0.02856084f, 
    0.03548177f, 0.04274087f, 0.00819087f, 0.03925554f, -0.04336745f, -0.01111195f, 0.03649737f, 0.00482676f, 
    0.00747007f, -0.01853906f, -0.03142048f, 0.00443530f, -0.01361964f, -0.03925069f, -0.00710400f, -0.00337426f, 
    0.02615089f, -0.02441940f, -0.03836154f, 0.02282667f, 0.01926098f, 0.01122538f, 0.00516810f, -0.01040016f, 
    -0.00650626f, -0.03477484f, 0.02952902f, -0.00146729f, -0.04536875f, -0.00383325f, -0.01190394f, 0.03114569f, 
    -0.05928602f, -0.04954122f, -0.03308402f, -0.02451826f, 0.03446442f, -0.03761473f, -0.02637167f, -0.00894821f, 
    -0.00537210f, -0.02133572f, 0.03139269f, -0.05148601f, 0.02644926f, 0.00103350f, 0.02053689f, -0.03183259f, 
    -0.00080954f, -0.04913891f, -0.06352933f, -0.03906971f, 0.03440623f, -0.03214402f, 0.01263790f, -0.06022488f, 
    -0.05094028f, 0.02170230f, -0.03208088f, -0.03804747f, 0.00006923f, -0.04916255f, -0.03760517f, 0.00656514f, 
    -0.10845461f, -0.05181095f, 0.25150198f, 0.04162266f, -0.00119551f, -0.08707378f, -0.14154722f, 0.04154622f, 
    -0.06168264f, -0.08408511f, 0.03552095f, -0.00413246f, -0.01967847f, -0.09219240f, -0.09099638f, -0.07091378f, 
    -0.04907745f, -0.03629533f, -0.01548621f, 0.14814350f, -0.00747817f, 0.05078752f, -0.08182484f, 0.05360235f, 
    -0.15714176f, -0.03705216f, -0.07442348f, 0.04769379f, -0.05082010f, 0.04726294f, 0.13369659f, 0.12225164f, 
    0.14384331f, -0.06851370f, 0.01890693f, 0.02248464f, -0.05908945f, -0.08810038f, 0.25343770f, 0.17274043f, 
    -0.07336667f, -0.00049040f, 0.08105416f, 0.00384972f, -0.01827079f, 0.05841851f, 0.11384978f, 0.07525495f, 
    0.15070690f, -0.10387362f, 0.05243411f, 0.05020950f, 0.15567216f, 0.07078329f, 0.12534350f, 0.14061472f, 
    0.07767256f, 0.04854403f, 0.03581034f, 0.04663883f, -0.10366393f, -0.15300277f, 0.02689002f, 0.05719611f, 
    -0.08009961f, -0.15157087f, 0.02365286f, 0.22134106f, 0.04355646f, 0.08145236f, 0.03954379f, -0.20514748f, 
    0.20593189f, -0.16479965f, -0.21175238f, 0.03741539f, 0.14280243f, -0.20710573f, -0.10340717f, 0.05283361f, 
    -0.04069877f, 0.01306672f, -0.05854904f, -0.00845034f, 0.27515042f, 0.04289513f, -0.10599220f, -0.07938084f, 
    0.00864129f, 0.04034319f, -0.04399557f, 0.03429938f, -0.02932038f, -0.11759993f, 0.13996454f, 0.05229318f, 
    0.10158713f, -0.09507671f, -0.13992077f, -0.04186337f, 0.07501649f, 0.05715923f, -0.00107253f, -0.00848615f, 
    0.07008830f, -0.10411868f, 0.05835854f, 0.04655190f, 0.16839486f, -0.33525637f, 0.06409765f, 0.11112335f, 
    0.02752629f, -0.08633084f, -0.01609056f, 0.04136366f, 0.24928811f, 0.08075990f, 0.11099415f, -0.00256842f, 
    -0.14296359f, -0.07764206f, 0.24725634f, -0.02835304f, -0.05058301f, -0.00658390f, 0.00720484f, -0.06365092f, 
    0.09599847f, 0.03486212f, 0.07663530f, 0.13343103f, 0.16867357f, 0.21614797f, 0.09756146f, -0.05731511f, 
    0.06577664f, 0.08189253f, -0.00874702f, -0.08234300f, -0.00241011f, 0.04634725f, 0.03042197f, -0.03290015f, 
    -0.31856650f, -0.21275407f, -0.13535841f, 0.20024529f, 0.12051896f, -0.07449467f, 0.01636156f, 0.02738529f, 
    0.05522611f, 0.05130995f, 0.04342904f, -0.10018454f, -0.06247398f, -0.03842711f, 0.08864859f, -0.02097852f, 
    0.02559133f, 0.04958076f, -0.02695887f, 0.01114930f, 0.02799431f, -0.04291203f, 0.19823448f, 0.17201862f, 
    0.03165284f, -0.07568934f, -0.07595210f, 0.04544944f, 0.01559570f, -0.04122671f, 0.23077779f, 0.08048339f, 
    0.02065710f, 0.02682037f, 0.08556920f, 0.00913063f, -0.27321726f, 0.06444955f, 0.06739415f, 0.00769835f, 
    -0.06029818f, -0.02041632f, -0.08571610f, 0.09138246f, 0.09685659f, 0.00249690f, 0.07785928f, -0.02907302f, 
    -0.36397433f, -0.00908680f, -0.23241439f, 0.10233270f, 0.00764615f, 0.00224405f, 0.02979809f, -0.04944927f, 
    0.03080794f, 0.10647868f, 0.14875147f, 0.04119749f, -0.26059470f, -0.06207734f, 0.14699300f, 0.03743017f, 
    -0.00348227f, 0.04493637f, -0.06535560f, -0.20025654f, 0.01773207f, 0.04440438f, -0.03721656f, 0.07295955f, 
    -0.19710642f, 0.09513337f, -0.02526235f, 0.29218861f, -0.06342131f, 0.05126353f, 0.07349385f, 0.12246628f, 
    0.01086699f, 0.02446986f, 0.07974786f, -0.11690588f, 0.25990650f, -0.23967756f, 0.12337882f, 0.27544454f, 
    0.08297601f, -0.07635331f, 0.14867905f, -0.01798376f, 0.12912971f, 0.00078620f, 0.22075112f, 0.08326542f, 
    0.19389097f, -0.23969527f, 0.38243929f, 0.32139143f, 0.13192798f, 0.10487029f, 0.20173116f, 0.20904993f, 
    0.14977081f, -0.07717274f, -0.04714252f, 0.34777844f, 0.06643768f, 0.12488683f, 0.04321187f, -0.00676099f, 
    0.08290839f, 0.06985857f, 0.06530593f, 0.03976868f, 0.00796995f, 0.05466729f, -0.05182485f, 0.04175887f, 
    -0.14526001f, 0.02233762f, -0.06991302f, -0.00693255f, -0.09098763f, -0.03136141f, 0.14115763f, 0.11430027f, 
    0.01727201f, -0.06738773f, 0.01691898f, 0.04812044f, 0.09968752f, 0.19906940f, 0.06505356f, 0.00618206f, 
    -0.00085150f, 0.00710123f, -0.00944521f, -0.05286708f, 0.00471230f, -0.01414549f, 0.01388177f, 0.07064978f, 
    -0.20646316f, -0.14128210f, 0.09275233f, 0.06631775f, -0.02425341f, -0.07762203f, 0.02168527f, -0.09894434f, 
    0.02322998f, 0.14763515f, 0.16190206f, 0.00670514f, -0.17332394f, -0.07904252f, 0.07200396f, -0.09505571f, 
    0.03787249f, -0.08013780f, 0.12269597f, -0.04300865f, -0.00169821f, -0.02238471f, -0.03950543f, 0.02461328f, 
    0.29292983f, -0.20722938f, 0.06866512f, 0.16411056f, 0.20433460f, 0.10647228f, -0.01302016f, -0.16530591f, 
    -0.10949509f, 0.11750232f, 0.14962363f, -0.01282759f, 0.23034133f, 0.23957092f, 0.05754929f, 0.12483115f, 
    0.02875615f, 0.05224140f, 0.06190472f, -0.02442746f, 0.14455904f, -0.20316271f, 0.08498179f, 0.09792419f, 
    0.31767866f, 0.27703819f, 0.02982248f, -0.01519273f, -0.05414034f, 0.00142355f, -0.00979534f, -0.01543124f, 
    0.06272384f, -0.06577847f, 0.08097138f, -0.07866722f, -0.32796040f, -0.09982543f, 0.02249986f, -0.10294391f, 
    -0.12783580f, 0.26977354f, 0.12220605f, 0.07892153f, 0.17722575f, 0.10031141f, -0.06782028f, -0.00335112f, 
    0.04148873f, -0.20795891f, -0.16935091f, -0.01770019f, -0.02102210f, -0.11659185f, -0.00028628f, 0.00426942f, 
    0.20204718f, 0.05755418f, 0.16770713f, -0.01841711f, -0.17735666f, -0.07763860f, 0.04617156f, -0.11390005f, 
    0.25916129f, -0.06182779f, -0.02817842f, 0.15684405f, 0.08012611f, 0.09624419f, 0.20461200f, 0.02725968f, 
    -0.03904121f, -0.03503506f, -0.04492802f, 0.02518530f, 0.03839791f, 0.01030406f, -0.00433065f, 0.03825729f, 
    -0.00382285f, 0.03910727f, 0.02417719f, 0.00273067f, 0.04013894f, -0.05618088f, 0.03047682f, -0.00940178f, 
    0.02570055f, -0.05269523f, -0.00707341f, 0.00014041f, 0.00475943f, -0.02801074f, 0.02986735f, -0.00470788f, 
    0.00315932f, 0.03626749f, -0.00598789f, -0.01258614f, -0.04244923f, -0.03340942f, 0.02755510f, 0.03759483f, 
    -0.01246979f, -0.04737591f, 0.03617602f, -0.04997595f, 0.02261385f, 0.02725058f, 0.03609452f, 0.00532923f, 
    -0.01297217f, 0.01200717f, 0.02473683f, 0.00753114f, -0.02816315f, -0.03025844f, -0.01904806f, -0.04412514f, 
    0.03785625f, 0.03503153f, 0.03516200f, -0.01897709f, -0.00134334f, 0.02347301f, 0.00955076f, -0.01642054f, 
    -0.03934172f, 0.03476315f, -0.03980340f, -0.04067592f, -0.02156717f, 0.02810326f, 0.02898445f, 0.03910992f, 
    0.02422460f, -0.01452815f, 0.00416592f, -0.02186231f, -0.04393120f, -0.00458648f, -0.00478638f, -0.05664415f, 
    -0.03478523f, -0.04509190f, 0.03048839f, 0.03886238f, -0.00452868f, -0.00135194f, -0.04438615f, 0.01470021f, 
    -0.01765304f, -0.05438375f, -0.01274117f, 0.00930730f, -0.03712067f, 0.02805535f, 0.00263952f, -0.03415954f, 
    0.01677073f, -0.00625079f, -0.04396765f, 0.02557063f, 0.03443191f, -0.01104212f, -0.00115378f, -0.04340451f, 
    0.03609681f, -0.03291687f, -0.05739216f, -0.00446886f, 0.03076348f, 0.01659616f, 0.02263280f, -0.00161456f, 
    -0.02446317f, 0.01750499f, -0.00799806f, 0.02033000f, 0.04090150f, 0.00643597f, -0.05380213f, 0.04221071f, 
    -0.02706365f, -0.01684261f, -0.02082602f, 0.02819556f, -0.03744930f, -0.01049598f, -0.02750477f, 0.01735712f, 
    -0.05757439f, 0.03589798f, -0.02532757f, 0.03256090f, -0.05496944f, -0.04468659f, -0.00204243f, -0.03200663f, 
    0.00789029f, 0.00663893f, 0.02080346f, -0.00029634f, 0.03463680f, -0.01992133f, -0.00448905f, -0.03305869f, 
    -0.04087171f, 0.00361597f, -0.02912255f, 0.03074487f, -0.00222313f, -0.00187811f, -0.03953782f, 0.01115497f, 
    0.02678704f, -0.04329411f, -0.02622736f, -0.03273708f, 0.01372629f, 0.00085799f, 0.01964446f, -0.03740161f, 
    0.01895661f, -0.00310625f, 0.04288107f, -0.03161043f, 0.01534820f, -0.00240107f, 0.00913195f, 0.02041236f, 
    -0.05257540f, 0.03640772f, -0.04990736f, -0.04347864f, 0.01020565f, 0.01381791f, 0.00102690f, 0.00319268f, 
    -0.05858735f, 0.01387368f, -0.00233753f, -0.01107324f, -0.00471131f, -0.02782302f, 0.01380025f, -0.03218751f, 
    -0.04079732f, -0.01641768f, -0.01277182f, 0.02789917f, -0.02808981f, 0.03557362f, 0.03445453f, -0.03802348f, 
    0.01958606f, -0.05005490f, -0.00709215f, -0.02621874f, -0.02009164f, 0.02406654f, 0.02525355f, -0.01847125f, 
    -0.03167231f, -0.03617495f, 0.04175026f, 0.01581816f, -0.02557293f, -0.02078479f, -0.00566622f, 0.01417752f, 
    -0.02036195f, -0.01794574f, -0.01421153f, 0.03983117f, 0.03374982f, 0.01817715f, -0.02617633f, 0.01120691f, 
    0.02308811f, 0.03257272f, -0.02936309f, 0.02841956f, 0.00916488f, -0.02846981f, -0.00234404f, 0.01055039f, 
    -0.03034417f, -0.00963577f, 0.02414411f, 0.01620719f, -0.05479942f, -0.01321854f, -0.05511322f, -0.03001541f, 
    -0.02660624f, 0.02364670f, -0.02799084f, -0.01688573f, 0.00492071f, -0.01719166f, -0.03762965f, -0.02760630f, 
    -0.03498068f, -0.04920309f, 0.00319302f, -0.02063193f, 0.03894311f, -0.03626388f, -0.03705585f, -0.02138114f, 
    -0.02685174f, -0.03554925f, -0.00984918f, -0.02877610f, 0.03180728f, -0.03032772f, 0.03941736f, -0.02207949f, 
    -0.02695184f, -0.05569196f, -0.03662546f, 0.01812523f, -0.04020542f, -0.03179061f, 0.02128681f, 0.00661033f, 
    -0.00607120f, 0.01201972f, 0.00315183f, 0.01469801f, 0.03624729f, -0.03782070f, -0.01215942f, -0.02376804f, 
    0.02801976f, 0.04313275f, -0.05638857f, -0.03529537f, -0.04361672f, 0.03359672f, 0.00639528f, -0.05095921f, 
    -0.02538449f, -0.05351969f, -0.04818993f, -0.01203135f, -0.00260929f, -0.00219417f, -0.05641432f, 0.03562040f, 
    0.00465222f, -0.04385862f, 0.03820067f, 0.03498286f, -0.04937351f, -0.04747578f, -0.04065895f, -0.05730039f, 
    -0.04477708f, -0.01793357f, -0.02540468f, -0.01608436f, 0.01072488f, -0.01332499f, -0.02549603f, 0.01895783f, 
    0.04447428f, 0.03057805f, 0.01728532f, 0.02196572f, -0.02077742f, 0.01142177f, 0.01300411f, 0.04123860f, 
    -0.00658633f, -0.00765791f, 0.01605167f, -0.00581474f, -0.01663190f, -0.05437155f, -0.03217776f, 0.00093653f, 
    -0.02447662f, -0.03839294f, 0.03194543f, 0.00654626f, -0.02675163f, 0.02208666f, 0.02226049f, 0.01472664f, 
    0.03508195f, -0.04627016f, -0.02596096f, -0.05913233f, -0.01203764f, 0.03448985f, 0.01941464f, -0.04888696f, 
    -0.04887220f, -0.02863180f, -0.03871238f, -0.03094229f, -0.01137816f, -0.03099287f, 0.00161676f, -0.02569501f, 
    0.00479082f, -0.02679372f, -0.00345698f, -0.02343252f, 0.00941948f, -0.01482406f, -0.02766062f, 0.02972240f, 
    -0.03410347f, -0.00846172f, -0.04567083f, -0.01417492f, -0.01938774f, 0.00848458f, -0.03178776f, -0.00172712f, 
    -0.04128323f, -0.02753680f, -0.01908873f, 0.03987680f, 0.04006069f, 0.02024361f, -0.04821436f, -0.03599307f, 
    -0.00132522f, -0.04093921f, -0.01583437f, -0.00062316f, -0.03971992f, -0.03886861f, -0.00399017f, 0.03743398f, 
    0.04307175f, -0.02291776f, -0.04604457f, 0.02561984f, -0.04137237f, -0.01154624f, -0.01655925f, -0.01240960f, 
    0.03780830f, -0.02090427f, 0.01900261f, -0.05055850f, 0.01081500f, 0.02703997f, 0.02726652f, -0.01743138f, 
    -0.19633514f, 0.12391042f, -0.03751086f, -0.21853754f, 0.03524576f, -0.08520662f, -0.01422752f, 0.01477864f, 
    0.14391407f, 0.13915184f, 0.02507360f, 0.09102975f, 0.04111727f, -0.05942804f, 0.06070599f, -0.09614573f, 
    -0.13290659f, -0.06346704f, -0.05145900f, -0.03847118f, 0.21202542f, 0.13979053f, 0.07158803f, -0.08137313f, 
    0.10618591f, 0.13398919f, 0.21138269f, 0.02119950f, 0.01344241f, -0.02469772f, -0.17199299f, -0.15313445f, 
    -0.04024789f, -0.02284108f, -0.11639799f, -0.21914069f, 0.02380607f, 0.03112571f, 0.04331511f, 0.04822040f, 
    0.10835615f, -0.08851608f, 0.08523084f, 0.07228859f, 0.13770358f, 0.04009776f, -0.09239173f, 0.03719658f, 
    0.06328719f, 0.16725340f, -0.14668877f, -0.01409774f, 0.22047500f, 0.22824259f, -0.00346260f, -0.13470697f, 
    0.17335914f, 0.04370442f, -0.04122156f, 0.13312286f, -0.15725139f, -0.09968095f, -0.00236135f, -0.07235190f, 
    -0.07216241f, -0.03383234f, 0.08542643f, -0.04019071f, 0.10331747f, -0.13579823f, -0.00538928f, 0.18852004f, 
    -0.06924001f, -0.01086932f, 0.08533888f, 0.03801284f, -0.17338425f, 0.08355284f, -0.02016041f, -0.02412683f, 
    0.24768516f, 0.18314086f, 0.20956878f, 0.06283256f, 0.04394277f, -0.02324710f, 0.00164512f, 0.19035156f, 
    -0.03688908f, -0.15606472f, -0.07508925f, 0.00001990f, 0.13433558f, 0.11434771f, 0.02185953f, 0.24884677f, 
    -0.28467804f, -0.06282198f, -0.14299260f, -0.11245712f, 0.02175555f, 0.03354412f, 0.05333981f, 0.02992707f, 
    -0.07494769f, -0.11851510f, -0.11686930f, -0.18122528f, 0.22501503f, -0.20526506f, 0.02882625f, 0.18423660f, 
    -0.10732164f, -0.03272533f, -0.04506593f, -0.04493573f, -0.06335707f, -0.23361988f, -0.00187488f, -0.20371135f, 
    0.04662568f, 0.11694883f, 0.24143225f, -0.19772254f, 0.07847577f, 0.00331879f, -0.03943513f, 0.07376628f, 
    0.15800111f, -0.07793260f, -0.14861438f, -0.05715246f, 0.06291398f, 0.02136563f, -0.11711629f, 0.10749207f, 
    -0.07817390f, -0.09932648f, -0.09235509f, -0.00173691f, 0.04718092f, -0.01630621f, -0.07279404f, -0.05538494f, 
    -0.18731394f, 0.06637848f, 0.05582259f, 0.13803743f, 0.17567010f, -0.02483458f, 0.02404878f, 0.22546865f, 
    -0.01173211f, 0.04345552f, 0.01158630f, 0.07877412f, 0.16880743f, 0.00140585f, 0.11638654f, 0.10659427f, 
    -0.11040010f, -0.05840515f, -0.05251193f, -0.06187982f, 0.14323518f, 0.17227544f, 0.21178100f, 0.13141190f, 
    -0.03744020f, -0.09247694f, -0.01724565f, -0.14373398f, 0.05697157f, 0.10578020f, 0.01762559f, 0.28589705f, 
    0.03553517f, 0.01421861f, 0.06121581f, -0.06758729f, -0.04887368f, 0.21011108f, 0.04490732f, -0.13867919f, 
    0.12767965f, 0.11233521f, 0.14535281f, 0.01714483f, -0.10110003f, 0.04724412f, 0.06310975f, 0.15243259f, 
    -0.34938642f, 0.19283439f, -0.10137618f, -0.10623154f, -0.14388190f, -0.04176502f, -0.13204983f, -0.03482670f, 
    0.17247224f, 0.06438574f, -0.02234191f, 0.08192121f, -0.15389554f, -0.05384127f, 0.02806786f, -0.14571473f, 
    0.17509376f, -0.06524853f, 0.19681448f, -0.10072967f, -0.17049369f, -0.02439739f, -0.02228458f, -0.02060369f, 
    0.09583404f, -0.09943038f, 0.15751551f, -0.20075876f, -0.02343993f, 0.08220964f, -0.03423030f, 0.21619241f, 
    0.12957169f, 0.11643794f, 0.12650079f, 0.14385119f, -0.48540616f, -0.03094950f, -0.53774172f, 0.20279787f, 
    -0.02098139f, 0.10503737f, -0.10885993f, -0.10229676f, 0.05260126f, 0.03963782f, -0.14002332f, 0.19705150f, 
    -0.07708073f, 0.11634614f, -0.59246498f, 0.16866893f, -0.00030766f, 0.10822664f, 0.23314944f, -0.08028958f, 
    0.00298143f, 0.03189298f, 0.06465780f, 0.02591973f, -0.03414261f, -0.03523958f, -0.06925005f, 0.03333611f, 
    -0.03543941f, -0.06982506f, -0.00096686f, 0.01519853f, -0.06743715f, -0.03286101f, 0.06492449f, -0.00569576f, 
    0.29451281f, 0.18823767f, 0.24339193f, -0.10825747f, -0.05388047f, 0.04141814f, -0.03183361f, -0.00982915f, 
    -0.02078176f, 0.01762151f, -0.05168807f, -0.14213224f, 0.17709440f, -0.12031516f, 0.11953548f, 0.05522684f, 
    0.00429288f, -0.11667480f, -0.08917387f, -0.03959721f, -0.00894231f, 0.03842462f, -0.00949445f, -0.02961191f, 
    -0.14287353f, 0.02836894f, 0.22473079f, -0.12363899f, 0.18949859f, -0.03354469f, 0.10292026f, 0.06978120f, 
    0.02174549f, -0.05558808f, -0.08008900f, 0.00189581f, -0.19879942f, 0.16280027f, 0.10899740f, -0.00101909f, 
    0.13301724f, 0.07365679f, 0.28891847f, 0.12824120f, -0.00407191f, -0.02997066f, 0.05919207f, 0.00972461f, 
    -0.12797537f, -0.03905530f, -0.10324247f, 0.17490335f, -0.02053790f, -0.05425047f, 0.14955103f, 0.02910627f, 
    0.14547801f, 0.05083674f, 0.03760812f, 0.02601385f, 0.09472547f, -0.04730967f, 0.19992261f, -0.08856931f, 
    0.08321952f, 0.09736088f, -0.10829169f, -0.06315520f, 0.12125827f, 0.12883340f, -0.14359511f, 0.18553899f, 
    -0.02045453f, 0.00804285f, -0.05518323f, 0.10492107f, 0.08154558f, 0.03872203f, -0.02463887f, -0.08211275f, 
    -0.01783881f, -0.22796689f, -0.23012526f, -0.22709973f, 0.47272357f, 0.25214341f, -0.02395245f, -0.03492542f, 
    -0.18804802f, -0.19721118f, 0.09266267f, -0.04548306f, 0.05907660f, -0.03738505f, 0.01572719f, -0.00315539f, 
    -0.20313661f, -0.00148667f, -0.04183341f, 0.23618533f, -0.07722852f, -0.07444395f, -0.05939389f, 0.03466872f, 
    -0.04789821f, -0.12706387f, -0.13569976f, 0.03614525f, -0.06935316f, -0.10726431f, 0.22851431f, 0.14973663f, 
    0.04831843f, -0.01406339f, -0.12713899f, 0.10186384f, 0.14834635f, -0.01577325f, -0.13949920f, 0.25309849f, 
    -0.03506229f, -0.02028342f, 0.00829306f, 0.03191261f, -0.02703703f, 0.02622885f, -0.00397691f, -0.00614459f, 
    0.03548409f, 0.01618581f, 0.04380363f, 0.02126744f, 0.01077046f, 0.04211280f, 0.03515660f, -0.02394939f, 
    -0.03786135f, -0.03669734f, 0.00343162f, -0.02443712f, -0.01383112f, 0.01182688f, -0.01893790f, -0.00635433f, 
    -0.01942823f, 0.00177823f, -0.03445601f, 0.01594501f, -0.02366075f, -0.01548558f, -0.01500743f, 0.03648613f, 
    0.03944742f, 0.00413341f, -0.02960835f, -0.02673681f, -0.02662401f, 0.04262377f, 0.01181928f, 0.01135870f, 
    0.00136582f, -0.01708016f, 0.01815058f, -0.01660996f, -0.01383325f, 0.04654632f, 0.04015468f, -0.04602562f, 
    -0.00625871f, 0.00079654f, 0.03278601f, -0.01252903f, -0.01610936f, -0.02925953f, 0.02439087f, -0.03644489f, 
    -0.01206140f, -0.04306358f, 0.02740268f, 0.00766132f, 0.00388206f, -0.03965037f, 0.00601831f, -0.02533127f, 
    -0.02447293f, 0.01214734f, 0.04697269f, 0.01587120f, -0.00830396f, -0.02498435f, 0.02177629f, 0.00302890f, 
    -0.05046673f, 0.02220694f, -0.01433368f, -0.02851792f, 0.02233796f, 0.03060777f, 0.03552413f, -0.04167178f, 
    -0.01625584f, 0.03388971f, -0.02895769f, -0.02180582f, -0.03971159f, -0.02285445f, -0.02579501f, 0.02612691f, 
    -0.01644260f, 0.00382419f, 0.04355926f, -0.00499420f, 0.02690476f, -0.00706346f, 0.01880937f, -0.01838022f, 
    0.00692742f, -0.02722605f, -0.00111661f, -0.04335673f, 0.00330344f, 0.03284521f, -0.00879198f, 0.00768185f, 
    0.03666830f, -0.01967829f, -0.01485501f, -0.02005341f, 0.02547478f, 0.01266897f, -0.00626461f, 0.02992387f, 
    -0.01972782f, 0.02617451f, 0.03654677f, 0.02461606f, -0.01606769f, -0.01932107f, 0.01107840f, 0.05865896f, 
    0.00023579f, 0.01024538f, 0.02482882f, -0.04562636f, -0.02283052f, 0.03467834f, -0.03949107f, -0.02553481f, 
    -0.02695356f, -0.04794580f, -0.02160870f, -0.04592441f, 0.03317596f, -0.00221338f, -0.03900021f, 0.00639242f, 
    -0.03733870f, -0.04682782f, 0.00895386f, 0.02994003f, -0.01938615f, -0.04573722f, 0.00196890f, -0.00882848f, 
    -0.05699904f, -0.04626999f, -0.05308568f, -0.03146892f, -0.04034253f, 0.01262480f, -0.03897863f, -0.00753361f, 
    0.00207299f, 0.02165947f, -0.04562494f, 0.00550119f, -0.02317109f, 0.00819473f, 0.02312276f, -0.03443221f, 
    0.00938360f, -0.01504750f, -0.03273581f, 0.05137276f, 0.00433547f, 0.01515315f, 0.05463061f, -0.03506384f, 
    0.00110408f, -0.02268444f, -0.02134169f, 0.03929710f, 0.02786641f, -0.03697081f, -0.00519981f, 0.02372481f, 
    0.00182318f, 0.02021727f, 0.04175500f, 0.03505572f, -0.01079454f, 0.01632639f, 0.04174030f, 0.05423227f, 
    -0.00085907f, 0.00161015f, -0.00577980f, 0.00630248f, -0.02804593f, -0.00220342f, -0.01453512f, -0.04160640f, 
    0.04916887f, -0.02113051f, 0.00357006f, -0.03061854f, 0.01301447f, -0.01966641f, -0.00107894f, -0.05357110f, 
    -0.02568106f, 0.04958554f, -0.00523309f, 0.03464410f, -0.05031872f, -0.05790049f, -0.04924570f, 0.03377297f, 
    0.01557719f, 0.02987205f, -0.02632484f, -0.01001836f, 0.01504329f, -0.03266369f, -0.02200675f, -0.05667362f, 
    0.01479606f, -0.04622687f, 0.02039433f, -0.04500011f, -0.05727178f, -0.03084643f, -0.04362572f, 0.02119520f, 
    0.01125666f, 0.02843641f, 0.02815682f, 0.04845661f, -0.05877910f, 0.02866428f, 0.01584254f, -0.02331046f, 
    -0.00833199f, -0.04601498f, -0.02444204f, -0.02940376f, 0.01995042f, 0.02258475f, 0.00222117f, -0.00070954f, 
    0.02350101f, -0.03072274f, 0.01777751f, -0.03198079f, 0.03890842f, 0.00562851f, -0.00870351f, -0.01482903f, 
    -0.01717552f, 0.03403817f, -0.00102839f, -0.04894505f, -0.03976899f, -0.01330637f, -0.04559578f, -0.00328561f, 
    -0.01733963f, -0.02987281f, 0.04410148f, 0.00233348f, 0.01888064f, -0.02114576f, -0.01869938f, 0.01381675f, 
    -0.00931861f, -0.03601613f, -0.03302401f, 0.01315019f, -0.04408599f, 0.01532918f, -0.00126350f, -0.00648479f, 
    -0.03280874f, -0.01193460f, -0.04143590f, -0.00577031f, -0.03394304f, 0.02860926f, 0.00972834f, -0.02950719f, 
    -0.01327905f, -0.02444447f, -0.03697944f, -0.03949960f, -0.00408680f, 0.00018181f, -0.02837743f, 0.00171932f, 
    -0.00228832f, -0.00760536f, 0.03093556f, -0.02970410f, -0.02941819f, 0.01119875f, -0.05118702f, 0.00064566f, 
    -0.02317224f, -0.01134118f, -0.01500132f, -0.02506867f, 0.02561849f, -0.02486337f, 0.00255764f, 0.03396952f, 
    -0.04979575f, 0.01029612f, -0.04011242f, -0.01562604f, -0.00444568f, -0.01301830f, -0.01875636f, -0.03062989f, 
    0.01954085f, -0.00784474f, -0.03745497f, 0.03829548f, 0.02108629f, 0.01721797f, 0.04918192f, -0.02363348f, 
    -0.02342952f, 0.02798364f, 0.03354345f, 0.03061337f, 0.02371330f, -0.04876640f, -0.02073394f, 0.04386407f, 
    -0.01159134f, -0.01423322f, 0.00477798f, -0.02380957f, -0.02395243f, 0.02034052f, -0.05108170f, 0.00695309f, 
    0.00811828f, 0.01640493f, -0.01698096f, 0.03368418f, 0.03748032f, -0.05122389f, -0.02813819f, 0.04191266f, 
    -0.00465554f, -0.00759920f, 0.01471403f, -0.00066498f, -0.00457332f, -0.01828970f, 0.01590131f, 0.01105266f, 
    0.04161496f, 0.03131335f, -0.02051129f, -0.00496942f, -0.06020813f, 0.03843773f, 0.03571290f, -0.01797665f, 
    0.02044975f, 0.03097831f, 0.03927987f, -0.04069865f, -0.03294878f, 0.02427427f, -0.00116802f, 0.04015646f, 
    0.02110319f, -0.04551231f, -0.04521079f, 0.00171814f, -0.01738148f, 0.03574959f, -0.04214888f, -0.01979568f, 
    0.02136529f, -0.04742951f, -0.03790263f, 0.03308019f, -0.01193078f, 0.02960312f, -0.01228650f, -0.00976742f, 
    -0.04951427f, 0.03398167f, -0.00569244f, -0.01495628f, -0.02653039f, 0.00940573f, -0.01098600f, -0.00149533f, 
    -0.01364512f, 0.00962992f, -0.05668243f, -0.00330364f, -0.03077072f, -0.03059636f, 0.03590598f, 0.02964295f, 
    -0.05431174f, -0.04489541f, 0.02338457f, -0.03201950f, 0.02723052f, 0.02581294f, 0.01171719f, 0.01153272f, 
    -0.04698101f, 0.00083816f, -0.02024096f, 0.01076772f, -0.05538907f, 0.00368646f, -0.01623391f, 0.01782303f, 
    -0.05817674f, -0.04502553f, 0.03695609f, 0.01438207f, -0.01073546f, -0.02832578f, -0.02522320f, 0.03547834f, 
    -0.04675227f, -0.00680069f, 0.03468275f, -0.05171754f, 0.00335315f, -0.03479930f, -0.05164180f, 0.00195412f, 
    -0.02243204f, -0.04773043f, -0.03097294f, 0.03361838f, 0.01082378f, -0.02455352f, -0.05616596f, -0.00604580f, 
    0.01390618f, 0.00148829f, -0.01966133f, -0.00252678f, -0.03571278f, -0.01307827f, 0.02002878f, 0.04209209f, 
    -0.04732721f, 0.00329248f, 0.03097553f, 0.03566134f, -0.04624832f, 0.03201334f, -0.00728177f, 0.03578516f, 
    -0.01187643f, 0.02766561f, 0.01404833f, -0.04284299f, 0.01995745f, -0.02202064f, 0.01248012f, -0.03402525f, 
    0.02633208f, 0.01738547f, -0.02835917f, 0.02778263f, -0.00970807f, -0.01520450f, -0.00902188f, 0.00798591f, 
    -0.03223699f, 0.01584707f, -0.02461253f, -0.05709104f, 0.02507924f, 0.01305367f, 0.01524716f, -0.05403288f, 
    0.00704751f, -0.04032347f, 0.02944904f, -0.05357883f, 0.02689615f, 0.02604931f, -0.04488034f, -0.01336372f, 
    -0.02093632f, 0.03883472f, 0.04326318f, 0.01594748f, 0.01212934f, 0.00364195f, -0.01574093f, 0.02641962f, 
    -0.04017505f, 0.00544321f, -0.04256586f, 0.02160319f, -0.04208506f, 0.04244862f, 0.01396312f, -0.03439938f, 
    0.02075920f, -0.04785517f, -0.02125702f, -0.01373005f, 0.04161922f, -0.04741716f, -0.05268108f, -0.02975253f, 
    -0.05372493f, -0.00575440f, 0.02238345f, -0.01391838f, -0.01432141f, -0.00261738f, -0.00297931f, 0.03424381f, 
    -0.04568223f, -0.05471200f, 0.04335473f, -0.00264966f, -0.03366043f, 0.00074607f, -0.03182271f, 0.03355136f, 
    -0.01327355f, 0.00800563f, -0.02225811f, -0.05805285f, -0.02373432f, 0.01979752f, -0.01475925f, -0.04720213f, 
    -0.03824393f, 0.02067419f, -0.04218956f, 0.03719410f, -0.01807235f, -0.01233828f, -0.03867048f, -0.03656435f, 
    0.02436949f, 0.04203609f, 0.03176369f, 0.02247197f, 0.01497485f, 0.00073196f, -0.03148197f, -0.02304852f, 
    -0.05708253f, -0.01742183f, 0.00637930f, -0.02222963f, 0.04138066f, 0.04304634f, -0.04086734f, -0.01226146f, 
    0.02141141f, -0.02809539f, -0.04117944f, 0.04241633f, -0.04561995f, -0.02439140f, -0.00008102f, 0.01068871f, 
    -0.02942766f, -0.02571270f, -0.04723173f, 0.03206797f, 0.04443582f, -0.00647192f, -0.03409975f, 0.02585189f, 
    -0.05017292f, 0.00660618f, 0.04521281f, 0.01321220f, 0.00225272f, -0.00414640f, 0.00642659f, 0.04087380f, 
    0.02338885f, -0.00599171f, 0.00039647f, -0.00069683f, -0.02003033f, 0.02794076f, -0.04876300f, 0.04355102f, 
    0.04094363f, -0.02423598f, -0.03726953f, 0.01960986f, -0.01822024f, 0.01887138f, -0.03300512f, 0.03016259f, 
    -0.05413266f, -0.01234210f, -0.03645150f, -0.05680871f, 0.04198463f, -0.05204786f, 0.03312387f, 0.03333818f, 
    -0.04009317f, 0.00664540f, -0.02739462f, -0.02731625f, -0.04126830f, 0.04057074f, 0.04191572f, -0.04584167f, 
    0.00236356f, -0.00240200f, 0.00791736f, 0.03681884f, -0.00683468f, -0.05038647f, 0.02110119f, 0.03006688f, 
    0.03108411f, -0.04139965f, 0.01669155f, -0.00557546f, 0.03820436f, 0.03806299f, 0.04266538f, -0.04217929f, 
    -0.04177329f, 0.00412621f, 0.03972691f, -0.05425296f, -0.02557366f, -0.03421337f, 0.01307322f, -0.01547279f, 
    0.00152003f, 0.01718356f, 0.02608834f, -0.01599059f, 0.03510305f, -0.00624739f, 0.01582432f, 0.03110763f, 
    0.02264354f, 0.00246056f, -0.02109425f, 0.00051942f, 0.04357535f, -0.04889801f, -0.05068556f, -0.03646712f, 
    0.04154961f, 0.03480291f, 0.03983672f, -0.02999917f, 0.00722970f, 0.01633927f, -0.04733495f, -0.03713431f, 
    0.04267839f, -0.03210573f, -0.00558028f, -0.03949044f, -0.02154715f, -0.04204086f, -0.03850842f, -0.02969933f, 
    -0.00726312f, 0.00553642f, -0.05349275f, -0.02970787f, -0.05605773f, 0.02807753f, -0.02918035f, 0.03680346f, 
    0.01608644f, -0.01585440f, -0.04525906f, 0.00750046f, -0.03581091f, 0.01560392f, 0.00647489f, 0.01074148f, 
    -0.01711028f, -0.02737481f, -0.03179291f, -0.02179161f, 0.03010888f, -0.03440969f, 0.01671480f, 0.04470203f, 
    0.01842341f, -0.03184954f, 0.01488706f, -0.05160915f, 0.04151750f, -0.02480957f, -0.04711230f, 0.01160148f, 
    -0.04293013f, -0.02909941f, -0.05005525f, -0.01498566f, -0.04692637f, -0.02845020f, -0.05531058f, 0.00920974f, 
    -0.01434171f, 0.03172144f, -0.00105829f, -0.02666282f, -0.05002056f, -0.02471400f, 0.00710919f, -0.02202996f, 
    -0.00770410f, -0.02277906f, 0.00023944f, -0.04440285f, -0.02346946f, -0.01455058f, -0.00223542f, -0.02710099f, 
    -0.03036960f, -0.04453067f, -0.00527987f, -0.01593249f, -0.04259095f, -0.02733315f, -0.05251750f, -0.02489318f, 
    -0.03464309f, 0.02192961f, -0.01366700f, 0.02544124f, -0.04987819f, -0.03122295f, -0.03405507f, -0.03978680f, 
    -0.00662660f, -0.05286251f, 0.02048440f, 0.03524723f, -0.00822730f, 0.01363334f, -0.00819825f, -0.02445809f, 
    0.01005111f, -0.03384174f, -0.02066222f, 0.01887868f, 0.04374380f, 0.00629310f, -0.00270601f, 0.02180005f, 
    0.02501143f, 0.02328159f, 0.00728762f, 0.03918514f, -0.01408997f, 0.03910050f, 0.00287061f, -0.03183832f, 
    0.03182149f, -0.01017948f, -0.01850312f, -0.01441394f, -0.05078302f, 0.00198664f, -0.00812530f, -0.02410314f, 
    0.01972795f, 0.02736793f, -0.04430407f, -0.04491406f, -0.02878330f, -0.04436006f, 0.00248756f, 0.01714174f, 
    0.00863728f, 0.02463548f, 0.01323023f, 0.02718969f, 0.01900968f, -0.04911464f, -0.05337943f, -0.03953864f, 
    -0.05527455f, -0.04471181f, -0.02850533f, -0.01025636f, 0.03967741f, -0.05642325f, -0.01676646f, -0.02792016f, 
    0.02066970f, -0.03356273f, 0.04402307f, -0.01747251f, -0.03682850f, 0.01813006f, -0.02685782f, 0.03751029f, 
    -0.00902630f, 0.02941098f, -0.05313728f, -0.03030373f, 0.03328044f, -0.04637492f, 0.02639043f, 0.03622123f, 
    -0.03910993f, -0.05448386f, -0.02914281f, -0.05930728f, 0.04027638f, -0.00891171f, 0.02662510f, 0.00524731f, 
    0.01714692f, 0.03054888f, 0.01186454f, 0.02940872f, -0.01043554f, -0.00340058f, 0.01525140f, -0.06034200f, 
    -0.02981682f, -0.01081356f, -0.02168154f, 0.00859518f, 0.00713541f, 0.01671965f, 0.03111595f, 0.01840911f, 
    0.04020449f, 0.01421535f, 0.00224593f, -0.00316383f, -0.03028666f, -0.03590808f, -0.03522378f, -0.01140186f, 
    0.03309380f, 0.03729677f, 0.02092327f, 0.02793842f, -0.02366415f, -0.01517635f, 0.03392281f, 0.02701876f, 
    -0.05212452f, -0.01339061f, -0.05510750f, -0.04646039f, 0.01828312f, -0.03584559f, -0.00552830f, -0.02005654f, 
    0.01994447f, -0.04444956f, 0.03304707f, -0.02560129f, -0.03134849f, -0.05575819f, 0.02908615f, 0.02139003f, 
    -0.00630711f, -0.01399480f, 0.03042110f, -0.05245963f, 0.02228111f, 0.01266994f, 0.04469640f, -0.01677862f, 
    -0.04424147f, -0.04800753f, -0.01466164f, 0.00877056f, -0.04909162f, -0.00822787f, 0.02325037f, -0.05746827f, 
    -0.03666171f, -0.03712730f, 0.01044680f, 0.00521117f, 0.03004514f, -0.01799620f, -0.04563474f, -0.04072295f, 
    0.01408885f, 0.01590072f, -0.00397576f, 0.02193708f, -0.02267329f, 0.00141720f, -0.01284044f, -0.03912851f, 
    0.02047628f, 0.01975024f, 0.02343128f, -0.01788534f, 0.00231459f, -0.01850584f, -0.01003128f, -0.02995512f, 
    -0.05419854f, 0.01573899f, -0.01805419f, 0.03051246f, -0.05290234f, -0.03991208f, -0.02325914f, -0.02616854f, 
    0.01512216f, -0.02049591f, -0.04431791f, -0.04849816f, -0.03842200f, 0.00155635f, 0.00511932f, -0.00007168f, 
    -0.04366784f, -0.00768235f, -0.01213764f, -0.03445845f, 0.02702612f, 0.02269132f, -0.05369580f, 0.03888757f, 
    -0.00695478f, 0.02774658f, 0.02723299f, -0.04582083f, -0.04951376f, -0.01175073f, -0.02582172f, -0.01334402f, 
    -0.03727918f, 0.01288483f, 0.03494268f, 0.03117084f, 0.00865712f, 0.01247708f, -0.00849658f, -0.05070998f, 
    0.03579900f, -0.05315613f, 0.01446747f, -0.02580950f, 0.02214852f, -0.03136714f, -0.01660078f, 0.00571264f, 
    0.02453904f, 0.00586986f, 0.00337115f, -0.00597236f, -0.03863353f, -0.03904725f, 0.01588156f, 0.00572208f, 
    -0.03642697f, -0.04998026f, -0.00876959f, 0.04076686f, -0.03272064f, -0.04929120f, -0.03382517f, 0.02935117f, 
    0.02926998f, -0.00641616f, 0.03146864f, -0.02119827f, -0.00610938f, -0.02818591f, -0.00617962f, 0.03457516f, 
    -0.05453815f, -0.01156595f, -0.05268801f, 0.03829151f, 0.03703642f, 0.00216135f, -0.02857143f, 0.00808900f, 
    0.00801770f, 0.03152988f, -0.04261632f, 0.04058629f, -0.04789238f, 0.03842223f, 0.00888981f, 0.00147842f, 
    0.02812857f, -0.05140839f, -0.00188736f, -0.02073927f, -0.02294561f, 0.00226581f, 0.02723610f, -0.04193500f, 
    -0.04980904f, -0.03798739f, 0.00218300f, -0.04974449f, -0.01206258f, 0.01509706f, 0.00148037f, 0.01459462f, 
    -0.02500883f, 0.02262127f, -0.00000230f, 0.00338329f, 0.00448595f, 0.03293847f, -0.05347959f, -0.05493683f, 
    -0.02344072f, -0.05508664f, 0.02516893f, -0.02552968f, -0.03558871f, 0.02207579f, -0.01498162f, 0.04039446f, 
    -0.02143347f, -0.03907702f, 0.00507973f, -0.01858664f, 0.04022442f, -0.01316432f, -0.02691100f, -0.01871297f, 
    0.02457153f, -0.00063388f, 0.01365776f, 0.00525629f, 0.01634271f, 0.01421509f, 0.00825888f, -0.05508920f, 
    0.00282253f, 0.03298140f, -0.03974639f, 0.02291356f, -0.01840402f, -0.03661882f, -0.05193642f, -0.03100001f, 
    0.03016949f, -0.00005864f, 0.01647831f, -0.05048180f, -0.01014439f, -0.04373033f, -0.01056978f, -0.01015806f, 
    0.01894110f, 0.01492644f, 0.00042228f, 0.01296150f, -0.03221208f, 0.00284694f, -0.01726146f, -0.03151878f, 
    -0.05307457f, 0.00463396f, -0.00363113f, -0.01318000f, 0.02776043f, -0.00233876f, -0.02073262f, 0.04195204f, 
    -0.01954974f, -0.03029034f, 0.01206348f, -0.03143828f, -0.03421411f, 0.01328162f, -0.02904613f, -0.03634175f, 
    0.02688416f, -0.04583311f, 0.01760861f, 0.03163571f, -0.05363934f, -0.01792851f, 0.01604800f, -0.00214105f, 
    -0.01954088f, 0.02178157f, -0.00294610f, 0.02525694f, 0.01703195f, -0.03274428f, -0.02335749f, 0.03112524f, 
    -0.01528907f, -0.03615144f, 0.01778143f, -0.01157128f, 0.02958643f, -0.05822734f, -0.00742558f, -0.02957398f, 
    0.03742802f, -0.00457024f, 0.01264974f, -0.02001896f, -0.05749718f, 0.02187135f, 0.02573094f, -0.02529437f, 
    0.01522339f, -0.00161318f, 0.03099173f, -0.03680665f, -0.02904516f, 0.03930180f, -0.00748843f, 0.01234731f, 
    0.00404500f, 0.01171825f, 0.03352595f, 0.00931760f, -0.05437341f, -0.05639665f, -0.02672673f, 0.00845687f, 
    -0.05286354f, 0.00223387f, -0.03813802f, -0.03504977f, -0.00544160f, -0.01620339f, 0.04062218f, -0.04233982f, 
    -0.04171810f, 0.01986645f, 0.02442719f, -0.02407106f, -0.01776886f, 0.00021109f, -0.02341517f, -0.00976444f, 
    0.05012902f, 0.08376817f, 0.24639767f, 0.07755140f, -0.04389782f, -0.02735512f, -0.04672647f, -0.03872678f, 
    0.04891087f, -0.02426056f, -0.00277617f, 0.01818518f, 0.02380767f, -0.08343800f, -0.04676931f, -0.06410231f, 
    -0.02926846f, 0.04135128f, -0.06706809f, 0.06178775f, 0.03204339f, -0.08133142f, -0.11906774f, 0.05556070f, 
    -0.11351403f, -0.01579668f, -0.11714707f, 0.05748213f, -0.04293653f, -0.03473704f, 0.13568404f, 0.11038540f, 
    0.00833057f, -0.09464162f, -0.02018756f, 0.01273043f, 0.10624619f, 0.01300314f, 0.26394755f, 0.18292847f, 
    0.00508014f, -0.03286640f, 0.04666929f, -0.01723549f, -0.07071435f, 0.14625387f, 0.12336475f, 0.01020610f, 
    0.28245264f, -0.32965592f, -0.08240692f, 0.07124074f, 0.09251368f, 0.02294742f, -0.08738955f, 0.11508032f, 
    -0.04999166f, 0.04554359f, -0.00080117f, 0.07302942f, -0.31013596f, -0.02684564f, -0.18699588f, -0.07706018f, 
    -0.20400955f, -0.04680967f, 0.01262521f, -0.00953097f, -0.00562651f, -0.05250025f, 0.07504147f, -0.11457989f, 
    0.12962165f, -0.11347109f, -0.08688177f, 0.08317444f, -0.00199266f, -0.12525390f, 0.02012816f, -0.06243949f, 
    0.12491615f, 0.07107776f, -0.02368897f, 0.05558470f, 0.20982774f, -0.05475821f, 0.01854664f, -0.11179872f, 
    -0.04745010f, -0.05018667f, 0.00135347f, 0.05943526f, -0.03406310f, -0.09188592f, 0.21461660f, -0.03154438f, 
    0.02692344f, -0.08856619f, -0.06415326f, 0.06427187f, -0.00273793f, 0.13256416f, 0.10212239f, 0.09130271f, 
    -0.04588296f, -0.19333412f, 0.00376097f, -0.11826525f, -0.01138643f, -0.22435421f, 0.01409020f, -0.09285490f, 
    -0.02038319f, -0.11239090f, -0.04839570f, 0.09365373f, 0.25704053f, -0.11061722f, 0.02683281f, -0.03352417f, 
    -0.00414449f, 0.13441129f, 0.14863071f, 0.02308318f, -0.14459659f, -0.07262733f, 0.04063669f, 0.03279934f, 
    0.12514344f, -0.03544214f, 0.06502860f, 0.18911831f, 0.21431601f, 0.39208078f, -0.00673605f, 0.29428440f, 
    0.06905614f, -0.04701191f, -0.03218028f, 0.01639478f, 0.01434954f, 0.04521070f, -0.04179452f, -0.03687644f, 
    -0.09685786f, -0.01617183f, 0.15429008f, 0.08890695f, 0.11143382f, 0.01072411f, -0.02111448f, -0.15807511f, 
    0.04681376f, 0.07492211f, 0.03661758f, -0.03409317f, -0.04502263f, -0.00057749f, 0.10277175f, 0.05300928f, 
    -0.00643472f, 0.03096715f, -0.04777037f, 0.04473817f, 0.07732704f, -0.03698140f, 0.19890068f, 0.20696409f, 
    0.02501827f, -0.03520095f, -0.01467596f, 0.01295894f, 0.09112122f, -0.03235269f, 0.13839504f, 0.20673819f, 
    -0.09912871f, -0.01201238f, 0.03176882f, -0.01042788f, 0.00704080f, 0.17890470f, 0.06678236f, 0.04826642f, 
    -0.05150222f, 0.01680317f, -0.10330216f, -0.12705651f, 0.03649241f, 0.00766289f, 0.14538755f, 0.00168641f, 
    -0.45588291f, -0.10174654f, -0.29300743f, 0.09612160f, -0.06218901f, 0.10780122f, 0.13925484f, 0.18429051f, 
    0.25089425f, 0.00346709f, 0.03592593f, -0.26436567f, 0.08339272f, 0.21108055f, 0.17178458f, 0.12549430f, 
    -0.00243292f, 0.10482369f, -0.00260384f, -0.09197822f, 0.12074015f, 0.00322979f, -0.05805492f, 0.01116896f, 
    -0.31437773f, 0.18605630f, -0.20272128f, 0.22330482f, -0.13180920f, 0.01792369f, 0.03339130f, -0.19784084f, 
    0.17429474f, -0.09754971f, 0.15435264f, -0.12870689f, 0.46445420f, -0.09887809f, 0.40208465f, 0.15831731f, 
    -0.01447851f, 0.08736817f, 0.31445301f, -0.02218650f, 0.08298866f, -0.05681865f, 0.18077748f, 0.08314931f, 
    0.23445460f, -0.16413833f, 0.43704525f, 0.29927030f, 0.09816696f, -0.02140125f, 0.17150684f, 0.08042970f, 
    0.10692566f, -0.15816839f, -0.06182804f, 0.22780983f, 0.12910110f, 0.12873498f, 0.02312497f, 0.10708546f, 
    -0.01992271f, -0.06013538f, -0.02832710f, -0.01367669f, 0.05548751f, -0.02076583f, -0.08717017f, 0.03372836f, 
    -0.15547872f, -0.14453398f, -0.15636829f, -0.05350125f, 0.10511199f, 0.01727009f, 0.04022453f, 0.13302931f, 
    0.09936994f, -0.10304202f, -0.18310648f, 0.00457972f, 0.01640198f, 0.36006385f, -0.15750602f, 0.05443355f, 
    -0.01237067f, -0.02640134f, -0.03116151f, 0.00705125f, -0.05486242f, -0.06255759f, 0.05004855f, 0.14477122f, 
    0.03552594f, 0.07685425f, 0.04845239f, 0.05331382f, -0.01988466f, -0.00944275f, 0.05194258f, -0.25050876f, 
    0.23459285f, 0.14322020f, 0.09909765f, -0.04050021f, 0.02000410f, 0.19961341f, 0.10430966f, 0.03194397f, 
    0.07159981f, -0.00695212f, 0.21042630f, -0.04810574f, 0.03989689f, -0.01057510f, -0.01509227f, 0.00661403f, 
    0.02902142f, -0.08252130f, 0.22084303f, 0.05548602f, 0.11988715f, -0.04581569f, -0.02358060f, -0.26687482f, 
    -0.07095132f, 0.11028776f, -0.03514976f, -0.02944436f, 0.04875818f, 0.33662766f, -0.16870332f, 0.12540615f, 
    -0.03339211f, 0.01890866f, -0.05893095f, -0.00277084f, 0.02748409f, -0.15545438f, -0.01260497f, -0.07796299f, 
    0.15731977f, 0.14934464f, 0.00960405f, 0.05526103f, -0.03799543f, 0.07256582f, 0.01980009f, -0.05691062f, 
    0.23101130f, -0.02033971f, -0.07426077f, -0.26442179f, -0.13680364f, -0.15321149f, -0.25152332f, -0.13327755f, 
    -0.08368354f, 0.22300425f, 0.06703126f, 0.05616538f, 0.08781306f, -0.02879534f, -0.12937415f, 0.07614528f, 
    -0.14879109f, -0.35532379f, -0.22265448f, -0.25971735f, -0.01217362f, 0.03544274f, 0.11789045f, 0.13407575f, 
    0.04756658f, -0.10950902f, 0.09135149f, -0.05573559f, -0.24698927f, 0.27679542f, -0.09916859f, -0.19552188f, 
    0.00915698f, -0.15615028f, 0.02697103f, 0.16274163f, 0.05420358f, 0.13190550f, 0.19935545f, -0.07141430f, 
    0.20539668f, 0.20545754f, 0.45500642f, 0.27918783f, 0.01788238f, 0.10296517f, 0.09787868f, 0.16739853f, 
    -0.01449944f, 0.00951519f, -0.00663434f, 0.02379790f, -0.01249604f, -0.07770316f, 0.13735354f, -0.07365927f, 
    0.03019643f, -0.00220235f, -0.14955039f, 0.00321080f, 0.08636348f, -0.02310115f, 0.03953393f, -0.13829739f, 
    0.12238283f, 0.03014713f, -0.02647427f, 0.02371370f, 0.04342265f, 0.05632177f, 0.07552040f, 0.11562289f, 
    0.04098820f, 0.03740571f, -0.00339792f, 0.22094229f, -0.07179683f, 0.07291776f, -0.01926552f, 0.01507835f, 
    0.00399850f, -0.00824462f, -0.05695779f, 0.07972855f, -0.03157632f, -0.05265791f, 0.01102509f, 0.09971097f, 
    0.21765462f, -0.17064416f, 0.18512909f, 0.04752551f, 0.10615515f, -0.07212492f, -0.01708661f, 0.02146121f, 
    0.03799793f, 0.07971172f, -0.10934594f, -0.05707295f, 0.20115094f, -0.00395413f, -0.09772225f, -0.14920697f, 
    0.19811165f, 0.21351585f, 0.12967081f, -0.08594091f, -0.03855913f, 0.08922449f, -0.03949283f, -0.04071076f, 
    -0.03470856f, -0.19930452f, -0.02671206f, 0.06405382f, 0.27133995f, 0.07691082f, -0.02361158f, -0.09104964f, 
    -0.04614751f, 0.11808835f, -0.17633675f, 0.01944919f, -0.33973014f, -0.21118386f, 0.07416075f, 0.08487248f, 
    0.12580393f, -0.03430553f, -0.05177880f, -0.02262735f, 0.00517366f, 0.08224290f, -0.03385029f, -0.01733458f, 
    0.08606802f, 0.06589688f, 0.19821014f, 0.12606752f, -0.10325509f, 0.12386453f, -0.03774023f, 0.04081866f, 
    0.02160389f, 0.12564413f, 0.14640792f, 0.09985480f, -0.31043032f, -0.14609279f, 0.03327785f, -0.13120130f, 
    0.03416812f, 0.04254112f, 0.03931956f, -0.01252553f, -0.00011654f, 0.03997935f, 0.00400509f, 0.07482927f, 
    0.18093453f, 0.19080466f, 0.24336901f, 0.19711956f, -0.17768396f, 0.13181184f, -0.01518005f, 0.17511187f, 
    -0.02457401f, 0.05031065f, 0.21315423f, 0.13633913f, -0.02285245f, 0.03331695f, -0.34945080f, 0.30882153f, 
    0.04276398f, 0.02555010f, -0.04924658f, -0.04347724f, 0.07189238f, 0.08085324f, 0.05461818f, 0.06885320f, 
    0.22530623f, 0.33768678f, 0.27872926f, 0.02288555f, 0.02035970f, -0.04223428f, -0.09826410f, -0.11103246f, 
    -0.02783623f, -0.02776854f, -0.03033541f, -0.12227727f, -0.07692693f, -0.28998122f, -0.15948184f, -0.06147476f, 
    0.12504435f, -0.06044921f, -0.05929627f, -0.09299965f, 0.05529579f, 0.04554752f, 0.03264503f, 0.09199920f, 
    0.18570599f, 0.06907708f, 0.01230622f, -0.08391184f, 0.08178899f, -0.13946547f, 0.11662790f, -0.11738181f, 
    -0.03020017f, 0.06328920f, -0.15075077f, -0.01713981f, 0.35706243f, 0.33471179f, -0.01050709f, 0.20900562f, 
    0.07268059f, -0.00192072f, -0.17558794f, 0.00600952f, -0.04612108f, 0.04281678f, -0.02479935f, -0.05795991f, 
    -0.18428887f, -0.18544196f, -0.12158915f, 0.12832233f, 0.12761049f, -0.05013066f, -0.06293005f, 0.04633836f, 
    0.04915825f, 0.09722760f, 0.07328817f, 0.03833128f, 0.49686486f, 0.37985742f, 0.33308208f, 0.17694262f, 
    -0.10998995f, 0.02412477f, -0.15057008f, 0.16387145f, 0.10682073f, -0.09767196f, 0.02506087f, -0.04681421f, 
    -0.14688216f, -0.13654946f, -0.08850122f, -0.24307737f, 0.07498159f, -0.05290490f, -0.00616586f, -0.23299932f, 
    -0.05688032f, 0.04330294f, 0.03169432f, -0.00014879f, 0.67396533f, -0.27949393f, 0.42262930f, 0.07703976f, 
    0.03540757f, -0.06194053f, 0.13086936f, -0.01069176f, 0.19809869f, -0.00166767f, 0.03400932f, -0.07011863f, 
    0.38558933f, -0.27914003f, 0.20137991f, -0.04875522f, -0.05958268f, -0.11505955f, -0.10504010f, 0.12895776f, 
    -0.06009759f, -0.07886261f, 0.04820494f, -0.09053461f, -0.00313020f, -0.20851071f, -0.09791349f, 0.14531158f, 
    0.16141817f, 0.01331135f, 0.05264636f, 0.00309628f, -0.00274555f, -0.07899466f, -0.03619960f, -0.01970465f, 
    0.14475270f, -0.13778262f, -0.13913630f, 0.06554860f, 0.16708307f, -0.01556836f, -0.07665130f, -0.01578456f, 
    0.00199809f, -0.02329570f, 0.08827221f, 0.13207744f, -0.22232729f, -0.22150482f, -0.26417828f, -0.13374354f, 
    0.07465202f, 0.10988205f, -0.11846945f, -0.08644773f, 0.04640757f, -0.02016622f, 0.14171083f, -0.02276995f, 
    0.35948226f, 0.13185807f, 0.29679283f, 0.05597339f, 0.13612139f, 0.18933116f, -0.02063395f, 0.03544316f, 
    0.08735101f, -0.08843219f, 0.02391522f, 0.06090512f, 0.27245986f, 0.15469491f, 0.04003228f, 0.05290705f, 
    0.12296537f, 0.05377420f, -0.11061689f, -0.05939238f, -0.04012766f, -0.08802742f, -0.06589881f, -0.06851857f, 
    -0.01409600f, -0.05486900f, 0.14498758f, -0.16145627f, 0.08658838f, 0.01937058f, -0.07435538f, -0.04540439f, 
    0.14799659f, -0.08536495f, -0.12538931f, -0.10756721f, -0.06560718f, -0.25361687f, -0.15160285f, -0.37240312f, 
    -0.03472234f, -0.04019339f, -0.06179989f, 0.05484773f, -0.01153397f, -0.10587002f, 0.18765563f, -0.19929861f, 
    -0.06999633f, -0.04103133f, -0.05818308f, 0.10554458f, -0.02059599f, 0.06424669f, 0.03484317f, 0.05150513f, 
    0.16171138f, 0.26850101f, 0.15532888f, -0.06301984f, 0.14597738f, -0.37247998f, 0.03185915f, -0.15157142f, 
    0.25697652f, 0.04581083f, -0.09209019f, 0.10948458f, -0.11862570f, -0.09457820f, 0.07248380f, 0.11612781f, 
    -0.04712109f, -0.21616924f, 0.11929586f, 0.06597467f, 0.08936278f, 0.03406504f, 0.01096299f, -0.09339513f, 
    0.07936602f, 0.00290021f, 0.03122332f, 0.14865293f, -0.30707639f, 0.25385103f, -0.32942984f, -0.22505707f, 
    -0.07368390f, 0.05135793f, -0.04927859f, -0.13981852f, 0.05664575f, -0.05330943f, -0.11726122f, -0.06637893f, 
    0.06979888f, 0.21857627f, 0.03635877f, -0.04206793f, 0.12857997f, 0.03466013f, 0.04792981f, 0.17812374f, 
    -0.00493788f, -0.02035969f, 0.00765479f, -0.08912789f, -0.09323199f, 0.03743664f, 0.05319629f, 0.03925558f, 
    -0.01250560f, 0.10230828f, 0.02917187f, -0.17417279f, 0.15269446f, 0.02345141f, -0.04681343f, -0.10511842f, 
    0.16649793f, 0.05074492f, 0.15751080f, 0.03936371f, 0.16061299f, 0.04726854f, -0.07789225f, -0.01721616f, 
    -0.07654260f, -0.00494136f, -0.11895163f, -0.03282729f, 0.20819572f, 0.19002290f, -0.22081572f, -0.08945247f, 
    0.12047895f, 0.02043268f, 0.14806910f, 0.15040174f, -0.02959291f, 0.00598689f, -0.06211530f, 0.09547754f, 
    -0.09161629f, 0.08148871f, -0.19807160f, 0.26190031f, 0.05887810f, 0.06233593f, -0.15166175f, -0.12899324f, 
    0.00397936f, -0.09832354f, 0.00192246f, 0.23172206f, 0.16386017f, 0.09488866f, 0.03444002f, 0.03990372f, 
    0.16911119f, 0.22635135f, 0.25464988f, -0.14444545f, 0.01896486f, -0.04307746f, 0.05322829f, 0.11947697f, 
    0.12284711f, 0.24205630f, -0.09413034f, -0.10500788f, -0.08221056f, 0.10755316f, 0.08858151f, -0.05638890f, 
    0.08927578f, 0.05615064f, 0.04765166f, 0.00885547f, 0.08868326f, 0.09519258f, -0.11387755f, 0.08136026f, 
    -0.02479263f, 0.05655513f, 0.15665996f, 0.07369529f, -0.03742520f, 0.14806551f, -0.08510278f, 0.15233499f, 
    -0.07626751f, -0.03533122f, -0.00966077f, 0.01758726f, -0.11236486f, -0.03425342f, 0.11943148f, -0.08644290f, 
    0.01938390f, 0.04106408f, -0.00967845f, -0.13676074f, 0.09066255f, 0.13481230f, -0.11799811f, -0.17166457f, 
    0.03072498f, 0.09314027f, 0.08528676f, 0.03713702f, -0.07025795f, -0.11656109f, 0.00485123f, -0.03918349f, 
    0.10251748f, 0.08635823f, 0.10828219f, 0.03030186f, -0.00981888f, -0.04637033f, 0.00166308f, 0.11713833f, 
    -0.02848126f, -0.09930328f, -0.02564440f, 0.04211720f, -0.23721141f, -0.15301219f, -0.05979046f, 0.08810236f, 
    0.04919197f, -0.00252602f, -0.12677664f, 0.08195531f, -0.03384168f, 0.05882723f, 0.12832642f, 0.06295387f, 
    0.26163703f, 0.21596156f, 0.29290074f, 0.03236200f, 0.07180394f, 0.09991420f, -0.10956413f, -0.01171082f, 
    -0.02701679f, 0.03364186f, 0.00645714f, 0.08052819f, -0.10663252f, -0.14061309f, 0.02219622f, 0.12653516f, 
    0.02468145f, 0.03086893f, -0.01516267f, -0.03973598f, -0.03350074f, 0.04749712f, -0.19272436f, -0.09495100f, 
    0.09956910f, 0.10983364f, 0.06690029f, -0.06456907f, -0.14884987f, 0.05194059f, -0.18065073f, 0.03987567f, 
    -0.02099361f, 0.07135782f, 0.12119722f, -0.03187519f, 0.23494495f, 0.07370079f, -0.04803500f, 0.11235923f, 
    0.04598397f, 0.07850021f, 0.25593981f, -0.17744170f, -0.10811394f, -0.01269851f, -0.03833606f, 0.14099222f, 
    0.40047994f, -0.10116399f, 0.19380771f, 0.20150384f, 0.07861677f, 0.05011965f, -0.00585141f, -0.02947194f, 
    -0.08046820f, 0.03140811f, 0.00775172f, 0.05914603f, 0.04437382f, -0.09563968f, -0.11746152f, -0.01618347f, 
    0.16577646f, 0.05378688f, 0.08062161f, 0.01772187f, -0.08008441f, 0.01677822f, 0.00770866f, -0.01976115f, 
    0.12937865f, -0.17550610f, -0.06042681f, -0.10291642f, 0.09177725f, 0.26809138f, -0.13279311f, 0.25032145f, 
    0.20338866f, 0.15075952f, 0.05365867f, 0.00547103f, 0.08776850f, 0.08757179f, -0.10944854f, -0.11377832f, 
    -0.02293967f, 0.13239384f, 0.05805432f, 0.09414771f, -0.11395705f, 0.25419369f, -0.16496833f, 0.11510132f, 
    0.07329164f, 0.16490181f, -0.36930889f, -0.17959274f, -0.09762678f, 0.08292807f, -0.09407210f, -0.05887501f, 
    -0.17856058f, 0.13222668f, 0.01631035f, -0.09605348f, -0.05410040f, 0.09326811f, -0.09399989f, -0.02397236f, 
    -0.07437490f, -0.14881837f, 0.01986306f, 0.07746123f, 0.02838667f, 0.09618274f, 0.15741357f, -0.03279011f, 
    0.06902316f, -0.04772650f, 0.03369071f, 0.12962291f, 0.08055723f, 0.23916869f, 0.03701984f, -0.04406841f, 
    0.10057732f, 0.06651759f, -0.07481021f, -0.00925688f, -0.12710303f, -0.17682624f, 0.21736389f, -0.15092309f, 
    -0.00256173f, -0.06813899f, -0.00354158f, 0.10498691f, 0.07666294f, 0.06576054f, 0.00733912f, 0.06681416f, 
    0.18434438f, 0.17314658f, -0.06019811f, -0.02256840f, 0.21973172f, 0.02548338f, 0.13178732f, 0.12870088f, 
    0.03075368f, -0.06999069f, -0.05945558f, -0.07295380f, 0.10185334f, -0.02115606f, -0.14105383f, 0.12484279f, 
    0.12715328f, 0.17098157f, 0.12578578f, 0.08898332f, 0.01182363f, 0.01215978f, 0.00598046f, 0.04781561f, 
    -0.08863442f, -0.04936055f, 0.10602393f, 0.04704289f, -0.16710104f, 0.00872324f, -0.12908909f, 0.01828992f, 
    0.05506714f, 0.09850430f, -0.02835185f, 0.11082853f, -0.28642640f, -0.03854886f, 0.26947123f, -0.04944946f, 
    0.11490282f, -0.04540369f, -0.05263864f, -0.01368627f, 0.12993518f, 0.07521921f, -0.22999869f, 0.20363732f, 
    -0.20688353f, -0.18535297f, 0.01909850f, 0.00031700f, -0.04999979f, -0.01380828f, -0.07113598f, -0.04169884f, 
    0.01731950f, -0.09183848f, -0.00157467f, 0.04984698f, 0.43729126f, 0.28673232f, -0.26338443f, 0.15222913f, 
    0.06387427f, -0.15115286f, 0.30266613f, -0.08828280f, -0.00262222f, -0.04739857f, -0.10214660f, -0.02883619f, 
    -0.03817870f, -0.01359357f, -0.05276194f, 0.02283140f, 0.01302542f, 0.10740499f, 0.04567318f, 0.05408459f, 
    -0.14346635f, -0.02880311f, -0.07129975f, 0.02732571f, 0.32960853f, 0.03047657f, 0.00226847f, -0.04434564f, 
    0.06624664f, -0.03502955f, 0.08421082f, -0.03747869f, -0.08373021f, -0.13452660f, -0.11558478f, 0.34859371f, 
    -0.05196617f, 0.02356005f, 0.26661310f, 0.16910161f, 0.09149691f, 0.00782483f, 0.04770385f, 0.15316230f, 
    0.05889333f, -0.03459930f, -0.03787421f, -0.04154547f, 0.04926365f, -0.10995839f, 0.12667812f, -0.07792799f, 
    0.04555534f, -0.00239397f, 0.03891063f, -0.12057240f, 0.13293144f, 0.16770233f, 0.11140826f, 0.00648038f, 
    0.05316675f, -0.08808925f, 0.06798285f, 0.12996349f, 0.23974544f, 0.04205449f, -0.12835239f, 0.02153226f, 
    0.00660190f, -0.12964760f, -0.17269880f, -0.01480218f, -0.05826603f, 0.16959728f, -0.17139949f, -0.04876506f, 
    -0.03362407f, -0.01061828f, -0.02073563f, 0.06943282f, -0.01689510f, -0.14232370f, -0.03852045f, 0.14510027f, 
    -0.14132881f, -0.01259865f, 0.15240963f, 0.17892876f, 0.23078991f, -0.00846192f, -0.05828793f, -0.10217998f, 
    0.06264625f, -0.04617330f, -0.04154697f, 0.25053307f, 0.43099740f, -0.23490006f, -0.01364717f, -0.06908827f, 
    0.03631024f, -0.06188148f, 0.18819848f, 0.00600750f, 0.07257314f, -0.02690122f, -0.00264902f, 0.14698744f, 
    0.27539662f, -0.01633035f, -0.08548726f, -0.00947076f, -0.00863141f, 0.03415845f, 0.09657007f, -0.05206714f, 
    0.12515533f, 0.09586070f, 0.02252427f, 0.10507887f, 0.22286882f, 0.14040551f, -0.05456908f, 0.16684273f, 
    0.03497416f, -0.07134481f, -0.03120262f, -0.10082924f, -0.05383178f, 0.03160045f, -0.10947451f, 0.17872691f, 
    -0.08126986f, -0.01401413f, 0.01150863f, -0.00391650f, -0.03929884f, -0.04473219f, 0.15388066f, -0.03647989f, 
    -0.07781737f, -0.09354262f, -0.13347781f, -0.19321667f, 0.27507308f, 0.03011011f, 0.04003398f, -0.14164712f, 
    -0.01215057f, 0.05448138f, -0.04123533f, -0.11993662f, -0.12122495f, 0.04399883f, -0.05172662f, -0.07399376f, 
    0.04086599f, 0.06374476f, 0.22556651f, 0.04494435f, 0.07925078f, 0.09675275f, 0.01997121f, 0.16250362f, 
    -0.00744733f, 0.01501281f, -0.01163958f, -0.02812905f, -0.11419885f, 0.24182209f, -0.16103473f, 0.27520409f, 
    0.00824120f, -0.04457233f, -0.05999509f, -0.08821841f, 0.11789487f, 0.02641382f, 0.01222976f, 0.02477570f, 
    0.03764131f, 0.15080680f, 0.04784942f, 0.22836396f, 0.17175403f, 0.10484090f, 0.04746040f, -0.02427035f, 
    -0.01151428f, 0.07974254f, 0.13482526f, 0.05589252f, 0.18289977f, 0.07081661f, 0.28455868f, 0.02186680f, 
    0.01385436f, -0.04819531f, -0.01782980f, -0.05641182f, 0.04810080f, -0.04830327f, -0.04273522f, -0.00894782f, 
    0.10777157f, -0.08615398f, -0.06167820f, -0.12083554f, -0.10916243f, -0.03399856f, -0.11433323f, 0.01511807f, 
    -0.01089475f, 0.01810004f, 0.06487419f, 0.02905745f, 0.14287190f, 0.11522949f, -0.08854098f, 0.44044009f, 
    0.27972394f, -0.01123294f, 0.17283629f, 0.02211206f, -0.02832151f, 0.03412302f, -0.04960594f, 0.19724715f, 
    0.16314331f, -0.14699227f, -0.22990805f, 0.01982770f, -0.04929189f, -0.11059869f, 0.03585041f, -0.03711768f, 
    -0.01671164f, 0.01511670f, 0.08079718f, -0.02076677f, 0.19022647f, 0.11870050f, 0.28996980f, 0.18498805f, 
    0.10937903f, 0.06358190f, 0.14395948f, 0.17069483f, -0.02363914f, 0.13691580f, -0.02654870f, -0.02368323f, 
    0.15090275f, -0.17805864f, -0.10226686f, -0.18717702f, -0.05267690f, 0.11900737f, -0.00556805f, 0.13723762f, 
    0.22216387f, 0.00418327f, 0.22302580f, 0.11305480f, 0.26521251f, 0.01937788f, -0.20905593f, 0.17205808f, 
    0.13969885f, 0.15561117f, 0.10182126f, -0.15996909f, -0.13391723f, -0.00535212f, -0.06574327f, 0.18105866f, 
    0.06011369f, -0.03879230f, -0.44155699f, -0.08812658f, -0.11027718f, 0.08336567f, 0.01122082f, -0.04493840f, 
    -0.08738606f, -0.04685028f, -0.08340786f, -0.04397152f, 0.02049674f, 0.00420739f, -0.10334729f, 0.05970203f, 
    -0.00871967f, 0.04020124f, 0.01653566f, -0.03182600f, 0.10411876f, -0.00421743f, 0.05724588f, 0.03160604f, 
    0.06910940f, -0.35416320f, -0.10383984f, 0.10630680f, -0.00199104f, -0.00961821f, -0.03056002f, 0.11391593f, 
    0.04233113f, 0.02792076f, -0.00808686f, 0.03656727f, 0.15037653f, -0.18990350f, 0.31302258f, -0.17783403f, 
    0.00887743f, -0.04694022f, -0.10133284f, -0.03587296f, 0.09103744f, 0.07051011f, 0.02404716f, -0.02083579f, 
    0.13053274f, 0.12958579f, 0.18360160f, 0.07156524f, 0.13948159f, 0.08176595f, 0.21097425f, 0.10766476f, 
    0.03189487f, -0.05848537f, -0.01183888f, 0.04580652f, -0.06345785f, -0.00421124f, -0.08639487f, -0.00678384f, 
    0.11202735f, 0.11831599f, 0.02631362f, 0.18537554f, 0.05118417f, 0.05817687f, 0.03694066f, 0.08206216f, 
    -0.02947926f, -0.02871546f, -0.13175645f, 0.01907582f, 0.06399827f, -0.15943812f, 0.07158072f, 0.06659517f, 
    0.00741774f, 0.08928084f, -0.00900754f, -0.02345968f, 0.09707338f, 0.01734789f, 0.34818470f, -0.34281105f, 
    0.12645516f, 0.01535263f, -0.06772727f, -0.02124765f, 0.06574338f, 0.03816380f, -0.12547889f, 0.04620886f, 
    -0.03578190f, 0.06500170f, 0.01589687f, 0.27830160f, -0.03274320f, -0.10426819f, -0.00218666f, -0.11457995f, 
    0.18766618f, -0.07845563f, -0.04328188f, 0.00732794f, 0.23061319f, -0.33099350f, -0.05159229f, -0.20997913f, 
    -0.02439080f, -0.27309740f, 0.19623254f, -0.14678544f, -0.04510482f, -0.12759648f, -0.02655889f, 0.18562235f, 
    0.10027032f, -0.25863400f, -0.12635832f, -0.01048128f, 0.03417582f, -0.03569597f, -0.06914403f, -0.10631184f, 
    -0.01540912f, -0.13300322f, -0.17129004f, -0.04205217f, 0.18732651f, 0.15527277f, -0.07606586f, -0.08206341f, 
    0.06034399f, 0.02085403f, -0.02941380f, -0.09996592f, 0.01422294f, -0.04358398f, -0.08788077f, 0.06113542f, 
    -0.28276038f, -0.08298607f, 0.12659241f, 0.10771709f, 0.03323081f, 0.13158707f, 0.10272992f, 0.05324686f, 
    -0.05371363f, 0.00500453f, 0.06761577f, 0.02829219f, 0.06943396f, 0.05589608f, 0.10214451f, 0.10296625f, 
    -0.05033453f, -0.08195605f, -0.13714017f, 0.05719587f, 0.10080793f, -0.02377072f, -0.10287070f, -0.06737195f, 
    -0.06917212f, -0.03370607f, -0.06022879f, 0.21192668f, -0.08915012f, 0.02170854f, 0.09543292f, 0.07441997f, 
    -0.01656193f, -0.03051037f, 0.04986691f, 0.00128413f, -0.28706434f, 0.04871210f, 0.23741993f, 0.20546301f, 
    0.09511640f, -0.04780208f, 0.00578128f, 0.09001037f, -0.01010242f, 0.08789558f, 0.01406124f, -0.00662834f, 
    0.08830924f, 0.14408794f, -0.16108443f, -0.16898984f, -0.00354656f, 0.01443800f, 0.02156404f, 0.01323732f, 
    0.17559265f, 0.04552398f, 0.03907483f, -0.08986128f, -0.27308533f, -0.16083983f, 0.44348285f, 0.13666657f, 
    0.17605002f, 0.06884496f, 0.00159582f, -0.09360026f, -0.04152794f, 0.10822748f, -0.02873480f, 0.01966932f, 
    -0.13850343f, -0.04752203f, 0.26866594f, 0.27375779f, -0.01698844f, -0.01605121f, -0.15013872f, -0.05207723f, 
    -0.08632509f, -0.01045607f, 0.00091778f, 0.07453778f, -0.06104713f, -0.13903318f, 0.12786968f, 0.22581406f, 
    0.08635314f, 0.02681182f, -0.05897683f, 0.11513127f, 0.02703840f, -0.06544694f, 0.10733823f, -0.01563192f, 
    0.10638586f, 0.21973351f, -0.10384271f, 0.04151390f, -0.12373367f, 0.07873186f, 0.09654967f, -0.02341752f, 
    0.06986003f, 0.06666315f, 0.19540183f, 0.00491222f, -0.23378022f, -0.36675954f, 0.28785303f, 0.18514393f, 
    -0.05218705f, -0.03273556f, -0.02652736f, 0.08279652f, 0.13294969f, -0.01028364f, 0.02167001f, 0.04123057f, 
    -0.12835710f, -0.02224782f, 0.01852535f, 0.04404407f, -0.02579485f, 0.07840260f, 0.08761967f, 0.07811157f, 
    0.06696852f, -0.07121120f, -0.07870045f, 0.11605769f, 0.09145483f, -0.07712045f, -0.44312534f, -0.05899068f, 
    0.01581943f, 0.00559851f, 0.11148718f, -0.01567982f, 0.05508714f, -0.01177944f, -0.06480604f, -0.02651896f, 
    -0.11337440f, -0.22846900f, -0.08249953f, -0.05189196f, -0.08286053f, 0.01195488f, 0.03786092f, 0.07555842f, 
    -0.05501610f, -0.05843245f, -0.03697449f, -0.03334438f, 0.07873875f, 0.04468919f, 0.01266261f, 0.02914013f, 
    -0.03050127f, -0.10051289f, -0.04257684f, 0.03378992f, 0.04481347f, 0.02310505f, 0.18807083f, 0.12930728f, 
    0.15417843f, -0.20923494f, 0.10537722f, 0.02844981f, 0.08999558f, -0.01365076f, -0.03247086f, 0.03424671f, 
    -0.08249738f, 0.15127580f, 0.03547372f, -0.01388323f, -0.04686837f, -0.16479492f, 0.01216742f, -0.15612477f, 
    -0.02559505f, -0.06675613f, -0.02341290f, 0.05920323f, -0.05886708f, -0.05173541f, 0.09962086f, -0.00325487f, 
    0.01128415f, 0.39045167f, 0.20199120f, 0.34051108f, -0.13562165f, -0.15365495f, 0.08461256f, -0.07233773f, 
    0.05917370f, 0.02254715f, 0.00837389f, 0.07078471f, -0.12529573f, 0.01829438f, 0.00302967f, 0.01156168f, 
    0.02736467f, 0.00785204f, -0.11099008f, -0.27168220f, -0.01398372f, -0.12088822f, -0.03055945f, -0.05197155f, 
    -0.34811586f, 0.14113197f, 0.29751870f, 0.23998691f, 0.11370280f, -0.09367660f, -0.11208145f, -0.08578381f, 
    -0.01631732f, 0.20755339f, 0.08169068f, 0.04546333f, 0.05165361f, -0.25125682f, -0.29921320f, 0.22090614f, 
    -0.07309098f, -0.02140484f, -0.11673456f, 0.07645501f, 0.02454144f, -0.04973849f, -0.04880520f, 0.13121611f, 
    0.19560659f, -0.04751414f, -0.20584521f, 0.27177742f, -0.06241547f, 0.07377162f, 0.11042371f, 0.27746001f, 
    -0.03743727f, -0.09704109f, -0.07935324f, 0.18290323f, -0.21106735f, -0.17134114f, -0.00876901f, 0.11386841f, 
    0.11620152f, 0.10683682f, 0.00712034f, 0.08348276f, 0.06623051f, 0.00815590f, -0.05685883f, -0.04579124f, 
    0.05779088f, 0.35978529f, 0.04450234f, 0.13139591f, 0.08112634f, -0.03263339f, -0.00989691f, 0.02390169f, 
    0.12422855f, 0.00044103f, -0.03025168f, 0.04048552f, 0.07616366f, -0.15184739f, 0.01764632f, 0.06092573f, 
    0.08251583f, 0.00916691f, -0.02665816f, 0.03056096f, 0.03992423f, 0.01995360f, -0.10027128f, 0.03338145f, 
    -0.25162420f, 0.02802943f, 0.12533887f, -0.03822546f, 0.14121924f, 0.09985302f, -0.14369906f, -0.14208497f, 
    -0.00026835f, 0.07336998f, 0.10204421f, -0.02019792f, -0.28133309f, 0.04215602f, -0.02424552f, -0.17151548f, 
    0.06157940f, 0.03215032f, 0.07653992f, -0.14027464f, 0.04032832f, 0.06294750f, -0.07310351f, -0.05022709f, 
    -0.00929949f, -0.07146015f, -0.15905257f, 0.14241676f, -0.07698031f, 0.10269111f, 0.10274237f, -0.12618916f, 
    0.02939550f, 0.06826492f, 0.06692909f, -0.01635760f, 0.20313723f, -0.16008447f, -0.03284472f, -0.16789356f, 
    0.14071998f, 0.02699475f, 0.04622911f, 0.02574052f, 0.14676131f, -0.07349790f, 0.01314226f, -0.04879887f, 
    0.12989028f, -0.06667406f, -0.03545162f, -0.06421347f, -0.00218954f, 0.13797633f, 0.11168472f, -0.03720533f, 
    0.10579459f, -0.06199077f, 0.10903132f, -0.05426191f, -0.20616440f, 0.36481482f, 0.16003056f, -0.06644059f, 
    -0.02791219f, 0.01217523f, -0.09187746f, 0.20075156f, 0.03308060f, -0.03245959f, 0.16241656f, 0.00408555f, 
    -0.03171932f, 0.17625719f, 0.27417389f, 0.37326583f, 0.00962546f, -0.10371613f, -0.00999302f, 0.00536869f, 
    0.06806449f, -0.08939289f, 0.00686110f, 0.14746745f, -0.08520083f, -0.04286188f, 0.24583358f, -0.36087427f, 
    0.24171408f, -0.08971006f, -0.00175069f, -0.02059925f, 0.13428344f, 0.00018041f, 0.19901861f, 0.16597123f, 
    -0.29541403f, -0.26634356f, 0.00859164f, 0.16679104f, 0.00411633f, 0.05749813f, -0.08910733f, -0.12243932f, 
    -0.02407711f, -0.00274977f, 0.03834266f, -0.02322483f, 0.10133214f, 0.05298414f, -0.00794714f, -0.03700567f, 
    -0.15317130f, -0.05114156f, -0.03011974f, 0.09409238f, -0.00065396f, 0.07416742f, 0.00680355f, 0.01437045f, 
    -0.15030164f, -0.05103374f, -0.04642978f, 0.09253823f, -0.10970766f, -0.16343430f, 0.20356691f, 0.12962273f, 
    0.07237470f, 0.06722292f, 0.03997532f, 0.02625046f, -0.34035751f, -0.03420294f, 0.37670437f, 0.27042127f, 
    0.01873156f, 0.07600407f, -0.09478153f, 0.07851448f, -0.05739618f, 0.11672366f, 0.06734406f, 0.10185225f, 
    0.04990070f, -0.01585700f, 0.23692657f, 0.01420471f, 0.03227167f, 0.12588993f, 0.09705586f, 0.23797485f, 
    0.02320625f, 0.02514692f, 0.17063263f, -0.14634913f, -0.31168044f, -0.10130332f, 0.28735691f, 0.14913535f, 
    0.07618174f, 0.01523575f, -0.07062110f, 0.10171988f, -0.06655703f, -0.02426425f, 0.03944856f, -0.10281920f, 
    -0.09313155f, -0.04299432f, 0.02759472f, 0.22805384f, -0.05028219f, -0.08038404f, -0.13367386f, -0.05139682f, 
    -0.15575129f, -0.12387987f, 0.12969999f, 0.11137727f, -0.02773472f, 0.07323696f, 0.09820405f, -0.00465735f, 
    -0.03923028f, 0.08366083f, -0.05570352f, -0.03497492f, 0.08391026f, 0.01132636f, 0.14663358f, -0.09567656f, 
    0.12184899f, 0.01608501f, -0.10117412f, 0.00836262f, 0.03492991f, 0.07018509f, 0.07568619f, -0.00487545f, 
    0.04607928f, -0.00870227f, 0.01420394f, 0.01471853f, -0.51922840f, -0.37118837f, 0.23538162f, 0.11469166f, 
    0.00359840f, -0.10349393f, -0.15652613f, -0.06642557f, 0.13968070f, 0.04657765f, 0.01443440f, 0.11452113f, 
    -0.20375140f, -0.11085810f, -0.05891294f, 0.07377863f, -0.01892190f, 0.13762841f, 0.17857435f, -0.02246495f, 
    0.11601902f, 0.09236418f, 0.01641817f, 0.06066998f, 0.20727499f, -0.07267068f, 0.00264688f, -0.18799484f, 
    0.01270799f, 0.09554625f, 0.04673041f, -0.03385255f, -0.02929709f, -0.03841902f, -0.08381078f, 0.03629842f, 
    -0.03162389f, -0.17901701f, -0.17570041f, 0.03025605f, -0.04995650f, -0.13944162f, 0.22103344f, -0.04603720f, 
    -0.01229589f, -0.09176560f, -0.03542662f, -0.02018977f, -0.08682591f, 0.07270601f, -0.08543616f, -0.17079765f, 
    -0.01627937f, -0.08406499f, 0.03629302f, 0.06767937f, 0.03195575f, -0.05163926f, 0.15880889f, 0.17253096f, 
    -0.07347648f, -0.11740000f, 0.02423850f, 0.11200621f, 0.12968326f, 0.01696847f, 0.01362492f, 0.04416727f, 
    -0.18308780f, 0.04460188f, -0.04293328f, -0.07206161f, -0.04730383f, -0.12320906f, 0.21691710f, -0.10103586f, 
    -0.12663579f, -0.04309057f, -0.16865751f, 0.16044654f, 0.01588624f, -0.12415542f, 0.01195689f, -0.05577934f, 
    0.04049168f, 0.38724422f, 0.20099406f, 0.15159632f, -0.08686441f, -0.11839370f, 0.12306856f, -0.00333571f, 
    -0.04386969f, -0.06888052f, 0.06578122f, 0.08238195f, -0.24810860f, -0.10510477f, 0.04714306f, 0.17826608f, 
    -0.06207245f, 0.01279909f, -0.12895858f, -0.16111742f, 0.07202309f, -0.01980363f, -0.04518205f, 0.00492267f, 
    -0.29448226f, 0.28768289f, 0.25014335f, 0.22907594f, -0.01894954f, -0.17571719f, 0.03025438f, -0.15743874f, 
    -0.08634289f, 0.11734021f, 0.13566916f, -0.06059453f, -0.04522197f, 0.04352187f, 0.03850459f, 0.48769477f, 
    0.08122906f, -0.07318677f, 0.08908096f, 0.06280892f, 0.02965120f, 0.02253035f, 0.01514812f, -0.03532385f, 
    0.14882079f, -0.01221815f, 0.31992012f, 0.40249106f, 0.11663878f, 0.16996020f, 0.18069902f, 0.24365632f, 
    -0.07749923f, -0.05514546f, 0.00333213f, 0.13259935f, -0.13175088f, -0.10664412f, 0.08611466f, -0.08234081f, 
    0.12946679f, 0.17319448f, 0.10118886f, 0.01057879f, -0.00428814f, 0.06594351f, -0.10466238f, 0.02122601f, 
    -0.11542003f, 0.33018541f, 0.09113888f, 0.06554493f, -0.03482830f, -0.15474963f, 0.13898206f, 0.14141576f, 
    0.06302471f, 0.03419991f, -0.02947590f, 0.07205550f, -0.23398487f, 0.13000882f, -0.29331300f, -0.06049999f, 
    0.01539135f, 0.03413221f, -0.00460413f, -0.06440043f, -0.03421024f, 0.03115000f, 0.03079192f, 0.10998461f, 
    -0.40094322f, -0.23273921f, 0.03310440f, 0.17533246f, -0.03118436f, 0.04504805f, -0.12596756f, -0.09698713f, 
    0.07479155f, 0.04456329f, 0.02749538f, -0.01083251f, -0.23107381f, 0.17320538f, 0.22573012f, 0.06399083f, 
    0.03594036f, -0.20548317f, 0.05948111f, -0.10442765f, -0.05484922f, -0.00858608f, -0.03894919f, -0.05200718f, 
    0.19131811f, -0.08191554f, 0.00255405f, 0.11098736f, 0.03764203f, 0.07798917f, 0.21561281f, -0.06375137f, 
    -0.04767399f, 0.09113985f, 0.09165303f, -0.08589398f, 0.10871049f, 0.18028861f, -0.20512366f, 0.13932772f, 
    0.05033793f, 0.02287141f, 0.09226871f, 0.08897332f, 0.04231473f, -0.09396829f, 0.22094923f, 0.01993515f, 
    0.14382765f, -0.03641227f, -0.08508011f, -0.28310132f, 0.03400652f, 0.09397352f, 0.10624941f, 0.03686365f, 
    0.07695283f, 0.10522118f, 0.24922454f, -0.11272845f, -0.48409075f, 0.13908918f, 0.40417802f, -0.05701593f, 
    0.02033987f, 0.19951199f, -0.24135169f, 0.27452469f, -0.03278150f, 0.10619609f, 0.12288620f, 0.04927339f, 
    -0.02672016f, 0.10508034f, 0.11905738f, 0.21293633f, 0.02809229f, -0.07599672f, -0.00812429f, -0.03022379f, 
    0.07892837f, -0.15622243f, 0.11528259f, -0.00980653f, -0.07832880f, 0.04178283f, 0.35455415f, -0.10054290f, 
    0.18825370f, 0.10943226f, 0.06340946f, -0.00507493f, 0.08620010f, 0.10647985f, 0.37941828f, 0.07086345f, 
    0.05419648f, 0.11127850f, -0.03118015f, -0.05438118f, -0.08361305f, -0.04627099f, 0.02018940f, 0.06746998f, 
    -0.02757318f, -0.04645465f, 0.00349624f, -0.03806736f, 0.12667528f, -0.05754437f, 0.05243525f, 0.21044423f, 
    0.04453890f, 0.04517892f, 0.05378442f, 0.07477093f, -0.12706806f, -0.10732569f, -0.02675180f, -0.10407309f, 
    0.16274284f, 0.27068534f, 0.25626194f, 0.09811450f, 0.03158198f, 0.10552827f, -0.15056311f, -0.17037620f, 
    0.04476358f, 0.02584007f, 0.10449613f, 0.17386024f, 0.29726329f, -0.00434603f, 0.02070210f, -0.03195548f, 
    -0.08746545f, -0.05819301f, 0.15808322f, -0.06686506f, 0.06402172f, 0.06590656f, 0.00688481f, -0.05327612f, 
    0.11397796f, 0.14183626f, 0.11429084f, -0.24106461f, -0.00605206f, 0.04742470f, 0.06945989f, -0.05445890f, 
    0.01846743f, -0.00753367f, -0.00482397f, -0.04172543f, 0.33254743f, 0.27656063f, -0.11045480f, 0.23749724f, 
    -0.02657923f, -0.00479849f, -0.05976540f, 0.11690318f, 0.05496609f, 0.00611428f, -0.11591601f, -0.08023276f, 
    0.12401218f, 0.06708122f, -0.00240106f, -0.04785043f, 0.12460461f, 0.15482074f, 0.09558282f, 0.09635543f, 
    -0.12788518f, 0.06014772f, -0.00233391f, -0.38417989f, -0.16056272f, -0.23993024f, -0.37159416f, -0.02183557f, 
    0.04764420f, 0.03702234f, 0.05077314f, 0.06204153f, -0.01804388f, 0.03566447f, -0.09523080f, -0.05912410f, 
    -0.06251975f, 0.12508200f, 0.13908316f, 0.09354126f, 0.08427165f, 0.03311096f, -0.06621753f, -0.06911644f, 
    0.05009172f, 0.06274071f, 0.21330070f, 0.27816483f, 0.18822664f, -0.18023147f, -0.46653089f, 0.03877944f, 
    0.08395065f, -0.01266694f, 0.10050125f, -0.00967756f, -0.19097474f, 0.06802726f, 0.08838857f, -0.07892050f, 
    0.14888081f, 0.08978551f, 0.10410632f, -0.08644464f, 0.06178040f, -0.11882122f, -0.12723139f, 0.06840365f, 
    -0.03475631f, 0.04894397f, 0.05083681f, 0.07454339f, 0.00478882f, -0.58641350f, 0.20055231f, -0.09495100f, 
    0.09870812f, 0.07423974f, 0.00171224f, 0.12373500f, 0.07610812f, -0.12610361f, 0.07569541f, -0.09028856f, 
    0.02172282f, 0.07884274f, 0.15551238f, 0.19565699f, 0.11012379f, 0.00608219f, -0.05640619f, -0.00906151f, 
    0.03621148f, -0.06122257f, -0.11500950f, 0.01935334f, -0.05720079f, -0.23408447f, -0.25879237f, 0.06154852f, 
    0.01381980f, 0.13224575f, 0.02519179f, 0.01366909f, -0.09530249f, -0.04068688f, -0.10515527f, -0.13725123f, 
    -0.03924974f, 0.12320641f, 0.02171967f, 0.07033090f, -0.01656246f, -0.08383700f, 0.04219953f, -0.03647176f, 
    0.16499822f, -0.01568480f, -0.12849912f, 0.01931402f, 0.03398350f, 0.13266461f, 0.15253142f, -0.06271537f, 
    0.06842508f, -0.02305282f, 0.12234374f, -0.13450736f, -0.07258992f, -0.00816750f, 0.04223218f, -0.10312973f, 
    0.26118419f, 0.25750834f, 0.08404641f, 0.05549414f, 0.11730681f, 0.14432847f, -0.06775334f, 0.03597776f, 
    0.02640112f, -0.02944810f, -0.05162675f, 0.10288426f, 0.14819255f, 0.13093726f, 0.23052441f, 0.17683141f, 
    -0.05503811f, -0.08992989f, 0.13888989f, 0.23446372f, -0.02720389f, 0.00014174f, 0.01961870f, -0.04876978f, 
    0.51556998f, 0.31204405f, 0.01026018f, -0.06457021f, 0.07933144f, 0.06364046f, -0.04980664f, 0.10982303f, 
    -0.15422781f, -0.10287133f, -0.04381588f, -0.11661465f, -0.17433096f, -0.03105040f, -0.07505471f, -0.08007729f, 
    -0.14134602f, -0.13332781f, -0.14272788f, -0.09939845f, 0.08163887f, -0.04394844f, -0.03461125f, -0.03047081f, 
    -0.22199473f, 0.02505182f, -0.09894214f, -0.03174931f, 0.05213638f, -0.20578735f, -0.14984082f, -0.08214259f, 
    -0.04968412f, 0.14044385f, -0.11058638f, -0.15474559f, -0.06408555f, -0.06514201f, -0.10505697f, -0.04056552f, 
    0.13908918f, -0.04166529f, 0.00252099f, 0.14792602f, 0.02203115f, -0.01635211f, 0.14078082f, -0.03980445f, 
    0.29171750f, 0.24058166f, 0.32674050f, 0.07041121f, -0.04553356f, -0.00215140f, 0.07897815f, -0.22447990f, 
    -0.09162041f, 0.01553355f, 0.05310935f, 0.17528059f, -0.11772654f, -0.22990467f, -0.27994573f, -0.21029170f, 
    -0.00880271f, -0.10910689f, 0.11253008f, 0.09394256f, -0.09360392f, -0.01464353f, 0.02464893f, 0.06388761f, 
    0.14396390f, 0.16097827f, 0.23709518f, -0.02293273f, -0.13309623f, -0.08542344f, 0.03278193f, 0.04860318f, 
    -0.03325110f, -0.07816530f, -0.02617426f, 0.04618734f, 0.16976291f, 0.13240057f, 0.21140525f, 0.13161325f, 
    -0.12234904f, 0.01239055f, -0.08542078f, 0.08498192f, 0.04042731f, -0.09490032f, 0.03495668f, -0.03706470f, 
    -0.17886981f, -0.25194114f, -0.18847835f, 0.03805479f, -0.01174300f, 0.15904440f, 0.06750783f, -0.11188166f, 
    0.05671930f, -0.19572939f, -0.09304383f, 0.04705179f, -0.23300071f, -0.32579377f, -0.07607259f, -0.11009972f, 
    -0.07169149f, 0.05317336f, 0.14147308f, -0.09254254f, 0.08671492f, 0.10208368f, -0.07843132f, 0.20486404f, 
    -0.13942304f, -0.09266277f, -0.22025995f, -0.04869601f, 0.07114256f, -0.05980393f, -0.18505181f, -0.02543932f, 
    -0.08407352f, 0.08529516f, -0.05198228f, 0.38950986f, 0.19300856f, 0.07159090f, 0.18266088f, 0.27546883f, 
    -0.14979006f, 0.07793954f, 0.00594388f, -0.10384604f, 0.12997469f, 0.18675864f, -0.04281579f, -0.14134733f, 
    0.07517712f, 0.09850869f, -0.03493939f, 0.24099223f, -0.02972854f, 0.06418698f, -0.06128435f, 0.05126416f, 
    0.12322222f, 0.26227748f, 0.09332702f, 0.17121124f, 0.04300763f, -0.23169598f, -0.22800516f, 0.41279450f, 
    0.01641609f, -0.04233939f, -0.14302187f, -0.01710073f, -0.05517890f, -0.07534387f, -0.20524956f, -0.12796760f, 
    -0.05337270f, -0.07498918f, 0.00369986f, 0.10981128f, 0.03056359f, 0.04925994f, 0.04295316f, 0.07637295f, 
    0.04435822f, 0.04185243f, 0.06240244f, 0.10158563f, -0.27015910f, -0.35991067f, -0.07512298f, -0.03306290f, 
    -0.10016835f, 0.02166407f, 0.00658513f, -0.04222680f, 0.14714815f, -0.01920469f, 0.09311996f, -0.00407686f, 
    0.14886574f, -0.03305127f, 0.08580723f, 0.15561906f, 0.06274164f, -0.03775332f, -0.12848616f, -0.13967361f, 
    0.04650177f, -0.03554676f, -0.07279810f, -0.03409366f, -0.00443678f, 0.13200137f, -0.10520191f, -0.04409786f, 
    0.00969346f, 0.06453064f, 0.09250785f, -0.03597709f, 0.07572399f, -0.04568825f, -0.08474947f, 0.13850933f, 
    -0.11301845f, 0.13881923f, 0.17342132f, 0.04597720f, 0.13950974f, 0.25624987f, 0.00445165f, -0.15571964f, 
    0.07980417f, -0.04870836f, 0.06772955f, 0.06400476f, 0.08435190f, -0.20758808f, -0.23536973f, -0.04682909f, 
    0.02779889f, -0.06959313f, 0.08619190f, 0.03793548f, 0.04214481f, -0.02829562f, 0.00609230f, 0.14394970f, 
    -0.10443582f, -0.12738307f, -0.21564624f, -0.12122705f, 0.03381612f, 0.06975464f, 0.01441638f, 0.02988324f, 
    0.18191546f, 0.22157587f, 0.14927398f, 0.07935919f, 0.03487661f, -0.23955677f, -0.33790156f, -0.08047476f, 
    -0.07347722f, -0.19832276f, -0.11830211f, -0.01092491f, 0.10548559f, 0.07901387f, 0.01259242f, 0.24640863f, 
    -0.18524982f, -0.02465988f, 0.09001377f, 0.00093452f, -0.00474282f, 0.04740064f, -0.10862696f, 0.06478602f, 
    -0.10144085f, -0.02302281f, 0.04296193f, -0.07386789f, 0.05358182f, -0.13620305f, -0.38344011f, -0.10759365f, 
    -0.07373139f, 0.00098283f, 0.04713715f, 0.00221298f, -0.07362647f, -0.02810668f, -0.04268135f, -0.05879808f, 
    0.08156760f, 0.02470744f, 0.09637277f, 0.06945995f, 0.08148064f, -0.01437045f, 0.03933057f, 0.11161661f, 
    0.03431028f, 0.11663189f, 0.07475256f, 0.10691854f, 0.19749929f, 0.19369411f, 0.23060526f, -0.04089677f, 
    -0.03085437f, -0.11399252f, -0.16027632f, -0.07496987f, -0.02394055f, -0.06973265f, -0.01004629f, -0.06345382f, 
    0.28273964f, 0.14070792f, 0.08075752f, 0.25447762f, 0.17327827f, 0.01352084f, 0.03953202f, 0.10380257f, 
    -0.00966958f, 0.11648188f, 0.11273538f, 0.14550811f, -0.26236522f, -0.08868654f, 0.06719983f, -0.10564801f, 
    -0.11025219f, -0.03377564f, -0.09841377f, -0.06588736f, 0.04755774f, 0.02582106f, 0.05721606f, -0.00174520f, 
    -0.06590877f, -0.02902890f, -0.09286533f, -0.09779838f, 0.03717459f, 0.03549803f, 0.03980513f, -0.00144997f, 
    0.11004497f, -0.02558334f, -0.00358633f, -0.03683622f, 0.08004685f, 0.02809797f, 0.13535593f, 0.26513031f, 
    0.12557374f, -0.01203889f, 0.07822417f, 0.00475871f, -0.05945089f, 0.05649315f, 0.06508066f, 0.11120262f, 
    0.04290643f, 0.22675502f, -0.03666626f, 0.18996941f, 0.04451345f, -0.00219879f, -0.02601048f, 0.02572354f, 
    0.09495988f, 0.07909828f, -0.03050098f, -0.00906846f, 0.07676249f, -0.17824085f, 0.12106807f, 0.20461765f, 
    0.06664965f, -0.02015443f, 0.06966205f, 0.20552464f, 0.02221478f, -0.02282957f, 0.03642990f, 0.00953207f, 
    0.13766098f, -0.00364855f, -0.13784243f, 0.18432279f, 0.21499503f, 0.04199120f, 0.01669484f, 0.12882350f, 
    0.10897845f, 0.02628100f, 0.11361940f, 0.21745171f, 0.09382702f, -0.15507950f, -0.33090046f, -0.03465503f, 
    0.15478373f, -0.08328175f, -0.02316173f, -0.00229518f, -0.07040375f, 0.05046529f, -0.00266305f, 0.14757392f, 
    -0.03978617f, -0.09083378f, -0.38284490f, 0.13701573f, 0.09169388f, -0.17669767f, -0.05024322f, 0.06406533f, 
    -0.01801550f, 0.07850354f, 0.01393656f, 0.02256733f, -0.07983743f, -0.12322186f, -0.16158757f, -0.16666502f, 
    -0.14662804f, -0.13245340f, -0.08296485f, -0.00318650f, -0.04848936f, -0.11863387f, 0.01325224f, 0.02621406f, 
    0.10432809f, 0.05506320f, 0.26999390f, 0.23587708f, 0.00611766f, 0.13037041f, 0.14673628f, -0.07576470f, 
    0.03524864f, 0.09660278f, -0.03254335f, -0.02628540f, -0.14980362f, -0.23202725f, 0.08829578f, -0.20873076f, 
    -0.14295016f, -0.08412610f, -0.12380293f, -0.05294164f, 0.01958808f, -0.03085203f, -0.06481680f, 0.06646161f, 
    -0.04065927f, -0.04723329f, 0.15036051f, 0.04355668f, 0.03826552f, 0.01629595f, 0.24168788f, 0.04911675f, 
    0.04689495f, -0.05594471f, -0.00038045f, 0.15259854f, -0.02807631f, -0.03336280f, 0.09121945f, 0.24029176f, 
    0.12747981f, -0.01434765f, 0.03330583f, 0.06240192f, 0.00192486f, -0.01499930f, 0.00514757f, -0.00976897f, 
    0.10955388f, -0.08109580f, -0.27250439f, -0.08643561f, -0.02065440f, -0.01235800f, 0.03785837f, 0.01425425f, 
    0.16393249f, -0.00325189f, 0.14335562f, 0.07659414f, -0.22045952f, 0.05058670f, 0.09217788f, -0.22623146f, 
    -0.05531549f, 0.05577392f, -0.10564360f, -0.10266053f, 0.04958133f, 0.18669039f, -0.12950970f, 0.21722361f, 
    -0.09118585f, 0.02964402f, 0.06831442f, -0.01445819f, 0.01067999f, -0.06922133f, -0.06673016f, -0.08703624f, 
    -0.14231466f, -0.10099441f, -0.08503012f, -0.03610862f, 0.41139317f, 0.06959736f, 0.08094365f, 0.11169814f, 
    -0.04429333f, 0.06325282f, 0.03238580f, -0.18176581f, 0.08973742f, -0.03675554f, -0.01293438f, 0.01131717f, 
    0.00208647f, -0.07215051f, -0.14338869f, 0.04679151f, 0.01285653f, -0.04657603f, -0.08574326f, -0.02735600f, 
    -0.12193544f, 0.06288926f, -0.09307630f, -0.09171384f, 0.13727118f, -0.17525667f, -0.12431533f, 0.20613953f, 
    0.21204305f, -0.14869717f, -0.08549295f, 0.04221028f, 0.02337550f, -0.03353297f, -0.15768892f, 0.17571153f, 
    -0.06832086f, -0.08247615f, -0.08972124f, 0.24113849f, 0.03834530f, -0.00777413f, -0.01746878f, 0.09253556f, 
    -0.10437962f, -0.05594844f, -0.12665848f, -0.07996882f, -0.06003486f, -0.09539365f, -0.19140451f, -0.01987968f, 
    -0.19250822f, -0.15138021f, -0.12507477f, -0.21200612f, -0.06109754f, -0.19011606f, 0.02319904f, -0.10063745f, 
    0.00824012f, -0.09008610f, -0.00355517f, 0.21125932f, 0.09059812f, 0.15543044f, 0.20274931f, 0.10744277f, 
    0.06749166f, 0.07708377f, 0.12577334f, 0.18384080f, 0.07594895f, 0.07550913f, -0.01940791f, -0.00381053f, 
    0.00121136f, 0.02959192f, 0.16687544f, 0.13897701f, -0.06547376f, 0.06972507f, -0.02110062f, 0.04948191f, 
    -0.43166691f, 0.31261790f, -0.33507863f, 0.08148611f, -0.04228407f, 0.14429751f, 0.08501492f, 0.01519033f, 
    -0.15629983f, 0.13799657f, -0.06783246f, -0.18654047f, -0.03117180f, 0.02444773f, 0.03730948f, 0.07583121f, 
    -0.02386313f, -0.08113941f, -0.02232057f, 0.07744407f, -0.03525159f, -0.00391242f, -0.04151448f, -0.18898199f, 
    -0.02431259f, 0.07336703f, -0.11748213f, -0.21011409f, -0.03393279f, -0.00563250f, 0.01541280f, 0.03729943f, 
    -0.10269275f, 0.11010923f, 0.09605987f, -0.20658575f, 0.18192111f, 0.22517668f, -0.28366622f, -0.38972557f, 
    -0.14782345f, 0.09274774f, -0.00378694f, 0.11941733f, -0.04718712f, 0.01182621f, 0.02101288f, -0.08054700f, 
    0.08409339f, -0.14369635f, -0.01445819f, 0.11882761f, 0.09860625f, 0.19880772f, 0.06857491f, 0.01547951f, 
    0.20612508f, 0.07781240f, 0.34260514f, 0.16298947f, 0.03855241f, 0.23773125f, -0.08555672f, -0.22442186f, 
    0.08778605f, 0.05316834f, -0.02638106f, 0.11286563f, 0.19957015f, 0.20893817f, 0.16583949f, 0.10077582f, 
    -0.14121795f, -0.13722728f, 0.00987534f, 0.19399123f, 0.08515617f, -0.07350530f, -0.04601248f, -0.08479249f, 
    0.08472594f, 0.07534403f, -0.00822929f, 0.10056934f, 0.09341440f, 0.02388398f, 0.24688931f, -0.08888453f, 
    -0.01449722f, 0.02589030f, -0.07460120f, 0.03496974f, -0.08991387f, -0.07540309f, 0.04547929f, -0.07907729f, 
    0.12846573f, -0.17419522f, -0.00927110f, 0.07808832f, 0.00969065f, 0.23188549f, -0.07819150f, -0.04304532f, 
    -0.12751187f, -0.21174352f, -0.25623131f, -0.05886283f, 0.02752788f, 0.00026627f, -0.22150485f, -0.07993004f, 
    -0.03177930f, -0.11297745f, 0.02415805f, -0.16142878f, -0.19162342f, 0.02427020f, -0.10753563f, 0.05797556f, 
    -0.18349457f, 0.05942105f, 0.04238876f, 0.08395501f, 0.10277508f, 0.18434456f, 0.02047406f, -0.04295552f, 
    -0.28552011f, -0.14517628f, -0.19492947f, -0.09281313f, -0.09565776f, -0.23592350f, -0.04176133f, 0.10252205f, 
    -0.04129377f, 0.05727951f, 0.01697955f, 0.02882791f, -0.01234318f, -0.12433796f, -0.04979753f, -0.03682568f, 
    0.72628897f, 0.11846739f, 0.14080982f, 0.47180799f, -0.06730930f, 0.02005250f, -0.07465394f, -0.01768494f, 
    -0.01521047f, 0.00220134f, 0.05622901f, 0.06077364f, -0.09465113f, -0.15695675f, -0.07482211f, 0.24741726f, 
    -0.06117478f, -0.00860266f, -0.12212905f, 0.03518677f, 0.12614907f, -0.00967612f, -0.06926823f, -0.08229959f, 
    0.02398320f, -0.01713487f, 0.16255102f, 0.35651493f, 0.09343679f, -0.03108879f, -0.10387176f, 0.00891733f, 
    -0.14438312f, -0.02200755f, -0.03105415f, -0.08680627f, 0.18910342f, -0.01619926f, 0.06150564f, -0.10156902f, 
    -0.24007303f, 0.07295944f, -0.03125365f, 0.19667751f, -0.06504421f, 0.16674162f, -0.08648797f, -0.08095349f, 
    -0.05978489f, 0.08024629f, 0.08056616f, -0.12957279f, 0.00107084f, 0.09906512f, 0.15306728f, 0.09879959f, 
    0.01321288f, 0.13550608f, 0.01581696f, 0.01860508f, -0.14178751f, 0.21901183f, -0.00671239f, 0.01082704f, 
    -0.09639272f, -0.01941553f, 0.04329930f, -0.14520721f, -0.25960407f, -0.12816273f, -0.15577365f, -0.21761273f, 
    -0.21338445f, 0.24151030f, 0.33753884f, 0.43418553f, -0.13265808f, 0.08728366f, 0.21457227f, -0.07406409f, 
    0.13450351f, 0.09605435f, -0.05252054f, 0.21110022f, 0.14862905f, 0.03810390f, 0.12958181f, 0.00602687f, 
    0.00993394f, -0.11661135f, -0.00954180f, -0.08206435f, -0.07037143f, -0.03869325f, -0.12968580f, 0.13555428f, 
    -0.10995492f, -0.10749118f, -0.14072284f, 0.08746222f, -0.03144747f, -0.07334501f, 0.01312786f, 0.01276373f, 
    0.07260092f, 0.12681828f, 0.01999515f, -0.05868696f, -0.06811017f, -0.15065221f, -0.02512177f, 0.10209440f, 
    -0.07141076f, -0.07716440f, -0.12221394f, 0.06350280f, -0.03041700f, -0.02405875f, -0.09710506f, -0.05988766f, 
    0.01167146f, -0.05833628f, 0.05861825f, -0.04421441f, -0.05049599f, 0.12703118f, -0.15469670f, -0.12283602f, 
    -0.10365324f, -0.16306463f, -0.00635511f, -0.05378184f, -0.08638254f, 0.15553656f, 0.00620431f, 0.15208031f, 
    -0.05278070f, 0.01524310f, 0.03599199f, -0.06341682f, 0.08834723f, 0.18012655f, -0.00677474f, 0.17006554f, 
    0.15641089f, 0.02119753f, 0.09732368f, 0.05797496f, -0.10959066f, -0.03584789f, -0.00380143f, -0.06670032f, 
    0.03035431f, 0.15967353f, 0.17854458f, 0.31134865f, -0.21249011f, 0.47980618f, 0.05998319f, 0.32897288f, 
    0.05435479f, 0.00974398f, 0.18133448f, 0.07376385f, 0.02568326f, 0.13142030f, 0.07067771f, 0.03470096f, 
    0.26417449f, 0.09520245f, -0.05021033f, -0.02500171f, -0.11627076f, 0.01765360f, 0.02286389f, 0.13755934f, 
    0.19911011f, 0.11620494f, 0.06709987f, 0.14120379f, 0.64135599f, -0.17807522f, 0.00969498f, 0.12304284f, 
    0.06398939f, -0.13238807f, 0.07017598f, 0.07095284f, -0.12514481f, 0.06440184f, 0.12806945f, -0.03779171f, 
    0.02084088f, 0.03850393f, -0.02413709f, 0.03305195f, -0.02146750f, 0.02248673f, -0.00098377f, -0.01780357f, 
    -0.01763468f, -0.02250560f, 0.00904704f, 0.00094656f, 0.01206030f, 0.03313043f, 0.04016972f, 0.03475150f, 
    0.02298382f, 0.02948634f, 0.00650030f, 0.02477946f, -0.04785080f, 0.04198723f, 0.00288776f, -0.01846473f, 
    -0.02554645f, -0.03895479f, 0.01290179f, -0.01478374f, 0.00305970f, 0.01731557f, 0.00874804f, -0.01721355f, 
    0.02765372f, 0.00519251f, -0.01801840f, 0.04223546f, -0.03389279f, 0.00567642f, -0.04981010f, -0.01935025f, 
    0.02319161f, -0.01981999f, -0.05623436f, 0.02376691f, 0.01029282f, -0.01356259f, 0.02538381f, 0.04293615f, 
    -0.00093984f, -0.04918924f, -0.00012883f, -0.03350545f, -0.00149265f, -0.02027160f, -0.00171800f, 0.03621922f, 
    -0.03165625f, -0.04899233f, 0.03324522f, -0.05916939f, 0.00114861f, -0.00449015f, -0.03282600f, -0.03533605f, 
    0.00059177f, 0.02341206f, -0.05939079f, 0.00619776f, -0.03801514f, 0.03146988f, 0.01757454f, -0.03117989f, 
    -0.00540232f, -0.05510687f, 0.00588648f, -0.04462813f, 0.02370858f, -0.05707418f, 0.01394761f, 0.02522178f, 
    0.01954769f, -0.04228733f, -0.03978981f, 0.01948309f, 0.02390513f, 0.02761361f, -0.04843285f, -0.02750575f, 
    -0.00704996f, -0.02711297f, 0.02889891f, 0.00295628f, -0.01288379f, 0.01275424f, 0.04608793f, 0.00668345f, 
    -0.03971205f, 0.02312129f, -0.02312163f, 0.00973457f, 0.02352840f, 0.04058119f, 0.01056571f, -0.03575499f, 
    -0.02120783f, 0.02745884f, -0.00927170f, 0.02130760f, 0.03393302f, -0.00014254f, -0.01373621f, -0.03046812f, 
    -0.05302565f, 0.01875897f, -0.00859338f, -0.04951355f, 0.04464157f, -0.04919359f, -0.02789839f, -0.01790698f, 
    0.02964948f, 0.01613513f, 0.03319101f, -0.00801620f, 0.03752224f, -0.03352203f, -0.01712005f, 0.00241296f, 
    -0.01812304f, 0.01330333f, -0.01194925f, -0.03997196f, -0.03114596f, 0.02156960f, -0.04903392f, 0.02943558f, 
    0.03761093f, -0.00620212f, 0.01997115f, 0.03461085f, 0.04253484f, 0.03809633f, 0.03338509f, -0.04840522f, 
    0.03721517f, 0.02760157f, -0.05384835f, 0.00727915f, 0.02343677f, 0.01617721f, -0.02962933f, 0.01914186f, 
    0.04218692f, 0.01779724f, -0.04085562f, 0.00562797f, -0.02431044f, -0.03073901f, 0.04099141f, 0.03827538f, 
    -0.01613476f, -0.01027606f, 0.01435935f, -0.02432158f, 0.02260675f, -0.04519308f, -0.00818848f, 0.01729331f, 
    -0.02637629f, -0.05244014f, -0.04595688f, 0.02603004f, -0.02713790f, 0.03849941f, -0.02682882f, 0.04086459f, 
    -0.04993261f, -0.01356965f, 0.01484374f, -0.00109889f, 0.03740657f, -0.02235793f, -0.03543760f, -0.02520782f, 
    -0.03768020f, -0.00695052f, -0.03378571f, -0.04366289f, 0.01023159f, -0.00597498f, -0.04809663f, 0.01925101f, 
    -0.03677062f, -0.04233494f, 0.02370491f, -0.02148474f, -0.03137388f, 0.01598499f, 0.03203870f, -0.00282106f, 
    0.00576357f, -0.04558226f, -0.04322815f, 0.04071993f, 0.03329556f, -0.03531127f, 0.01126395f, 0.03747744f, 
    -0.04631235f, -0.05608458f, -0.00048206f, -0.00805485f, 0.00028263f, -0.04362998f, 0.02700007f, 0.01892561f, 
    -0.02909908f, 0.03797030f, -0.03186562f, -0.02489046f, -0.05524563f, 0.01224779f, 0.00011721f, -0.00967169f, 
    -0.05134929f, 0.03537384f, -0.00884779f, -0.00371443f, -0.01738305f, -0.05692826f, -0.03043966f, -0.05534252f, 
    0.01902093f, 0.03687391f, 0.00752124f, -0.05369698f, -0.02370126f, -0.05673651f, 0.04262494f, -0.05077512f, 
    -0.03047090f, -0.02784352f, 0.01183375f, -0.04005042f, -0.04199344f, 0.02656382f, 0.00710175f, -0.05054284f, 
    -0.02377239f, 0.00015827f, -0.00454533f, 0.01771843f, 0.03352337f, -0.04187425f, -0.02118655f, 0.04675860f, 
    0.02593600f, 0.00416200f, 0.01870600f, 0.03779872f, -0.03126113f, 0.03543514f, 0.02196725f, -0.04026273f, 
    -0.01945134f, 0.00616945f, -0.04737969f, -0.05070794f, 0.01020752f, -0.04337312f, 0.02026718f, -0.04583353f, 
    0.02091472f, -0.05144509f, -0.04624513f, 0.04025209f, -0.05194248f, -0.02838617f, -0.01524032f, -0.01450595f, 
    0.02788183f, -0.04148379f, 0.02158751f, -0.03659926f, -0.00965381f, 0.01318877f, -0.05035416f, -0.05224271f, 
    -0.03343014f, 0.02273325f, -0.04938744f, 0.03844052f, -0.04719817f, 0.01559267f, -0.02378809f, -0.05046463f, 
    0.00793702f, -0.02245663f, 0.03904494f, -0.03861542f, -0.00464596f, 0.00290063f, 0.01206789f, -0.05374509f, 
    -0.00446077f, 0.00033882f, 0.00981874f, 0.03557224f, -0.00352115f, -0.00210226f, 0.04098231f, -0.00405324f, 
    -0.01017866f, -0.04419044f, 0.02053184f, -0.01632616f, 0.03903825f, -0.02592178f, -0.03463535f, -0.00096693f, 
    -0.04226501f, -0.01308760f, 0.01375190f, -0.05146175f, 0.00166900f, 0.00603261f, 0.02190116f, 0.02459936f, 
    0.04022705f, 0.01112261f, -0.03486481f, -0.02745216f, -0.01381728f, 0.02476191f, 0.00670501f, -0.02482234f, 
    -0.05927998f, -0.05806063f, 0.03760675f, 0.02240504f, -0.04635447f, -0.00247925f, -0.02065499f, 0.01515259f, 
    0.01153492f, -0.03872914f, 0.03021012f, -0.01272739f, -0.04502605f, -0.01996861f, -0.00721399f, -0.03176508f, 
    -0.01990775f, -0.00573845f, -0.05626546f, 0.02365350f, -0.03285284f, 0.01207900f, -0.01776227f, 0.02381236f, 
    0.02801261f, -0.01600918f, 0.01024322f, -0.04281579f, 0.02360983f, -0.02920293f, 0.03909260f, -0.03059491f, 
    0.03522700f, -0.00347940f, -0.04478158f, 0.01271804f, 0.03453026f, -0.00621120f, -0.00416722f, -0.00323672f, 
    -0.05753238f, -0.04242294f, 0.02606873f, 0.04073751f, -0.05532216f, -0.01998368f, -0.04723608f, -0.05265279f, 
    -0.32377681f, -0.73321742f, -0.27955246f, -0.24936660f, 0.20775035f, -0.02164619f, 0.00185901f, 0.07465084f, 
    0.00401166f, -0.00688100f, 0.01961389f, -0.02537589f, 0.04983584f, -0.00607116f, 0.00984724f, 0.04010583f, 
    -0.10349292f, -0.02373947f, -0.00864932f, -0.02293045f, -0.01951742f, -0.03306570f, -0.03046480f, -0.19521712f, 
    -0.21553151f, -0.17164399f, -0.24977116f, -0.12614681f, 0.06437613f, 0.08762382f, 0.00221136f, -0.07823358f, 
    0.01502663f, 0.03330803f, 0.02521944f, 0.20596702f, -0.22510649f, -0.28640416f, -0.33853891f, -0.37459254f, 
    -0.05949513f, 0.06063250f, -0.03541780f, 0.03725927f, 0.04253376f, 0.06808301f, -0.03552699f, 0.11303899f, 
    0.19764866f, -0.02240300f, -0.00798007f, -0.07246782f, 0.18393813f, 0.05075677f, 0.12134857f, 0.05373685f, 
    -0.02537324f, 0.04587699f, -0.06970910f, -0.01420784f, -0.10894561f, -0.00920389f, -0.16531928f, 0.02119879f, 
    0.00398186f, 0.19085021f, -0.05689913f, -0.05725524f, -0.13232699f, -0.11642525f, 0.01293035f, 0.01186677f, 
    -0.04841708f, 0.05666600f, -0.02003095f, 0.03667530f, 0.00976962f, 0.04875427f, -0.05803938f, -0.07265272f, 
    -0.05548595f, 0.06824247f, 0.06288610f, 0.08715530f, 0.07871211f, 0.11486224f, 0.11786710f, 0.14616096f, 
    0.00118134f, -0.00619421f, -0.05100144f, -0.02437998f, 0.09775661f, -0.02895543f, -0.08201032f, 0.09850936f, 
    -0.10999373f, -0.18742178f, 0.00319165f, 0.01283278f, 0.05770824f, 0.04837547f, 0.04691419f, 0.11048184f, 
    0.10548217f, 0.03997213f, -0.02750263f, 0.09728800f, 0.46028769f, 0.12519602f, 0.14814372f, 0.01078527f, 
    -0.09099093f, 0.07385271f, -0.00627344f, -0.06760583f, 0.06555265f, 0.05281521f, -0.11058275f, -0.09454714f, 
    0.04977100f, 0.01300300f, -0.28817302f, 0.19366792f, 0.18089087f, 0.02126217f, -0.04221218f, 0.09672213f, 
    0.04157931f, 0.02570222f, 0.13520530f, 0.17416221f, 0.50942010f, 0.21697904f, 0.31082404f, 0.35724452f, 
    -0.01799664f, -0.01581328f, -0.01767210f, -0.08340031f, 0.03685242f, -0.06748293f, 0.07910985f, 0.03780549f, 
    -0.09911929f, 0.13758978f, 0.09603474f, -0.01927664f, 0.22719397f, 0.06219053f, 0.03840221f, 0.04021177f, 
    -0.06852338f, -0.09676849f, -0.04785317f, -0.11784267f, 0.31396410f, 0.08448195f, 0.13640469f, 0.15545286f, 
    -0.03534664f, -0.06178807f, -0.08187088f, -0.03155567f, 0.04096518f, 0.01435852f, -0.05486400f, -0.01331931f, 
    -0.08306933f, -0.00582264f, -0.02397416f, -0.00733341f, 0.01003182f, 0.01453339f, 0.02866244f, 0.03359875f, 
    -0.11766776f, -0.07875942f, -0.12486438f, -0.08617587f, 0.10316000f, -0.16831616f, -0.52765542f, -0.09980541f, 
    0.15607409f, 0.03449397f, 0.13788769f, 0.00824784f, -0.11657986f, -0.10720040f, -0.01132031f, -0.01627900f, 
    -0.51233935f, -0.45079663f, -0.29897633f, -0.48496112f, -0.14389047f, -0.11181537f, -0.02558052f, -0.06852564f, 
    0.11429448f, 0.02979480f, 0.16187672f, 0.04537949f, 0.07204339f, 0.00727318f, 0.09696836f, -0.05088959f, 
    0.16592659f, -0.07363093f, -0.03198750f, 0.14586188f, -0.00421636f, -0.03339576f, -0.01157717f, -0.05479679f, 
    -0.07302812f, 0.03349166f, -0.15441249f, -0.39886272f, -0.11137754f, -0.11539485f, 0.02425621f, 0.12470919f, 
    -0.02612364f, 0.25757003f, -0.00622768f, -0.04705772f, -0.52817351f, 0.20845166f, 0.10340778f, 0.03106504f, 
    -0.03018768f, 0.21692760f, -0.13955079f, 0.01414770f, -0.03773994f, -0.00087529f, 0.03940834f, -0.06517800f, 
    -0.38841522f, 0.17835471f, -0.39712337f, -0.00969725f, -0.00684918f, 0.24985167f, -0.19690174f, 0.00330524f, 
    -0.02027605f, 0.07953426f, 0.00171919f, 0.00464127f, 0.12453960f, 0.03836884f, 0.04250980f, 0.01853444f, 
    -0.00750701f, -0.03965896f, -0.01135642f, 0.00612543f, -0.04141420f, -0.07090794f, -0.00065328f, -0.07579260f, 
    -0.35617542f, -0.73143274f, -0.56549531f, -0.34911388f, -0.09606344f, 0.01345136f, 0.08316357f, 0.14684720f, 
    0.12413247f, 0.03516024f, 0.01574381f, 0.01855642f, 0.23941803f, 0.18993235f, 0.07219209f, 0.17051660f, 
    0.00038955f, 0.04696617f, -0.02888097f, 0.01760289f, 0.05419907f, 0.05511545f, -0.04226821f, 0.01321731f, 
    -0.11162808f, -0.19571599f, -0.28083441f, -0.10162517f, -0.08909532f, 0.04066255f, -0.02732383f, 0.19454643f, 
    0.11768122f, 0.10495286f, -0.03856889f, 0.04946887f, -0.22346279f, -0.46006554f, -0.53886044f, -0.47701561f, 
    0.02738364f, -0.08723760f, 0.00234996f, 0.04374992f, -0.08223204f, -0.11170287f, -0.05716714f, -0.04146333f, 
    -0.03140792f, 0.11238480f, 0.22267255f, 0.06998792f, 0.00664558f, 0.16335268f, -0.00925108f, 0.14718047f, 
    -0.05650526f, -0.05263041f, 0.03805170f, -0.02601017f, 0.26633215f, 0.18172050f, 0.29896691f, 0.10681456f, 
    0.04988589f, 0.02597724f, 0.03558930f, -0.02731303f, -0.01117590f, 0.18040007f, 0.13005061f, 0.11706423f, 
    0.32858938f, 0.09348702f, 0.13463879f, 0.17604057f, -0.03287477f, -0.09271299f, 0.12779452f, 0.06303261f, 
    0.25008932f, 0.28840664f, 0.29961401f, 0.26337257f, 0.32118514f, -0.17521033f, -0.33579928f, -0.12474099f, 
    0.00600915f, 0.05071593f, 0.23731785f, -0.11627795f, -0.00095543f, 0.07286651f, -0.08408864f, 0.01400698f, 
    0.00852962f, -0.23303339f, -0.12619889f, -0.20501271f, -0.06974156f, 0.02792212f, -0.01558962f, 0.00672785f, 
    0.06634765f, -0.13210233f, -0.05780721f, 0.03751123f, 0.04235908f, -0.07107349f, -0.08840220f, 0.24305327f, 
    0.00475767f, 0.12860496f, 0.15154196f, -0.03165532f, 0.10250992f, 0.15734939f, 0.26237997f, 0.19405337f, 
    -0.07839300f, -0.17187980f, -0.27385795f, -0.00337005f, -0.05925263f, 0.02945868f, -0.02607929f, -0.07695425f, 
    -0.05492246f, 0.06040061f, -0.07441933f, 0.02293336f, -0.02202924f, 0.05361569f, -0.09832548f, -0.10996952f, 
    0.00285995f, -0.07679532f, 0.10328194f, -0.07338215f, -0.00138492f, 0.20415750f, 0.17008944f, 0.10715392f, 
    0.10872751f, -0.13429852f, -0.00817095f, 0.05917057f, 0.16465734f, 0.09131361f, 0.01959901f, 0.00387371f, 
    -0.02170948f, 0.03519841f, -0.10687155f, -0.00309735f, 0.04438248f, 0.08497833f, -0.23910443f, -0.07678625f, 
    0.04723539f, 0.11570200f, 0.16621000f, -0.04087560f, 0.00361223f, -0.01553040f, -0.02018784f, 0.04624901f, 
    -0.37429184f, 0.13845940f, -0.00726812f, 0.29883558f, -0.07830676f, 0.20458399f, 0.02708024f, -0.02107020f, 
    -0.03925470f, 0.00261322f, 0.04391469f, 0.05123407f, 0.09660718f, 0.05783518f, -0.08298889f, -0.03550198f, 
    0.01588941f, -0.07522982f, -0.04620164f, 0.08700031f, -0.01793510f, -0.08003549f, 0.11188848f, 0.02092788f, 
    -0.05886220f, 0.26747599f, -0.09292349f, -0.12836120f, 0.00681707f, 0.06050935f, 0.01250020f, 0.03249466f, 
    0.22989005f, 0.19343241f, 0.21178773f, 0.04811408f, 0.05119243f, 0.16833079f, -0.05374660f, -0.40606558f, 
    -0.15679328f, 0.05293247f, 0.07666428f, -0.02267819f, 0.19469595f, 0.19161184f, 0.08096182f, 0.11744064f, 
    -0.18717439f, -0.09691188f, -0.06055392f, -0.03700967f, 0.14188318f, 0.06004310f, 0.12024540f, 0.12066749f, 
    0.03613987f, 0.02205883f, -0.08431827f, -0.04827764f, -0.17347646f, 0.39468259f, -0.30911845f, -0.18868911f, 
    0.07720868f, 0.09506504f, -0.01397644f, -0.03513377f, 0.04405183f, 0.11494622f, 0.01412770f, 0.08468069f, 
    -0.05036806f, -0.12278119f, -0.25521976f, 0.10382257f, 0.08361148f, 0.04878932f, 0.16270310f, -0.02426057f, 
    -0.01280932f, 0.07352931f, 0.02215757f, -0.01030091f, 0.11236079f, 0.12209673f, 0.50547743f, -0.29566142f, 
    -0.21526141f, -0.12622005f, -0.14559771f, 0.06292389f, -0.17020103f, 0.07790580f, 0.01172282f, 0.07037684f, 
    0.33611611f, -0.11049563f, -0.11818805f, -0.03486774f, -0.00343392f, -0.06025407f, -0.01294335f, 0.03926094f, 
    -0.04032630f, 0.04085367f, -0.01453202f, 0.11982874f, -0.16499728f, 0.22102369f, 0.02931238f, -0.17857064f, 
    0.01097027f, 0.01934118f, 0.02967492f, 0.00773931f, -0.02603247f, 0.07551494f, 0.07939773f, 0.12372996f, 
    -0.16675080f, -0.00011830f, -0.10548146f, -0.04277579f, 0.11709737f, 0.22216308f, -0.00870372f, -0.01367407f, 
    -0.04193643f, -0.05005377f, 0.06972067f, -0.02329536f, -0.04781153f, -0.23981264f, 0.07024930f, 0.21776602f, 
    -0.00648642f, -0.07119516f, 0.10415196f, 0.01547404f, -0.00275574f, 0.07365372f, -0.14318821f, 0.24545473f, 
    0.58295834f, 0.14765696f, 0.08643433f, 0.03931324f, -0.02447632f, 0.10047882f, -0.06103658f, -0.00684168f, 
    -0.00591548f, 0.16761664f, -0.08178697f, -0.01572469f, -0.20243619f, -0.29451942f, -0.27271184f, 0.08558316f, 
    0.08877026f, -0.02344201f, 0.04427897f, 0.06166287f, -0.11811001f, 0.05018669f, 0.07590527f, -0.01364229f, 
    0.13365562f, -0.11802370f, 0.06990518f, 0.36704040f, 0.17386851f, -0.14706869f, 0.03071188f, 0.15568262f, 
    0.04657318f, 0.03009515f, 0.05822554f, 0.08464860f, -0.14941193f, 0.13141614f, -0.32892153f, -0.21378395f, 
    0.18677399f, 0.09256782f, 0.02622602f, 0.16737549f, -0.20265058f, 0.22459234f, -0.12270866f, 0.04925981f, 
    -0.12552567f, 0.11102131f, -0.10104975f, -0.08672405f, 0.19869305f, 0.06508062f, 0.13534041f, -0.00680556f, 
    0.07723238f, 0.11368879f, 0.05989833f, -0.06691179f, 0.00689828f, 0.15110150f, 0.03910296f, -0.17241609f, 
    -0.16287908f, 0.05164624f, -0.01043475f, -0.16555867f, 0.02234498f, 0.04571519f, 0.05030272f, 0.04561488f, 
    -0.06469670f, 0.07693885f, 0.26806939f, 0.26545301f, -0.03464952f, 0.16401652f, 0.19236009f, 0.03764123f, 
    0.08936854f, 0.10418080f, -0.00055245f, 0.02163203f, -0.00819505f, 0.05099654f, 0.22500299f, -0.03482258f, 
    -0.13430607f, -0.03425817f, -0.04412518f, -0.04888229f, 0.04731489f, 0.08139639f, 0.03064146f, 0.05089596f, 
    -0.10123084f, -0.14148772f, -0.24416029f, 0.12775257f, 0.00386276f, 0.00966083f, 0.17564209f, 0.08712304f, 
    -0.06737126f, -0.02448471f, -0.04025272f, -0.02668184f, -0.08993123f, -0.16307637f, -0.09276931f, 0.21556668f, 
    0.12159626f, -0.05015153f, -0.03144018f, 0.04272778f, -0.10147460f, 0.01897410f, 0.02482581f, 0.07844272f, 
    0.15782520f, 0.17255907f, -0.10957155f, -0.19015110f, 0.02093881f, 0.02907143f, -0.11846508f, 0.20661731f, 
    -0.00281511f, -0.02485931f, 0.17479125f, 0.02991731f, -0.22609861f, 0.20298184f, 0.13376249f, 0.26910627f, 
    -0.05109015f, -0.01080247f, -0.10097617f, 0.00162475f, -0.07403254f, 0.26828036f, 0.06942767f, 0.21403645f, 
    -0.19022563f, 0.07288387f, 0.30837992f, -0.09790780f, -0.13345166f, -0.18070498f, -0.20140032f, -0.02382588f, 
    -0.17164283f, 0.02199523f, 0.00627982f, 0.11228842f, 0.05796475f, 0.37921855f, -0.07391688f, 0.24641640f, 
    0.09214518f, 0.06592192f, 0.19271882f, 0.02790773f, 0.08496744f, 0.08581930f, -0.03686857f, -0.08575471f, 
    0.07183515f, 0.11740638f, -0.23974778f, -0.28794542f, -0.02435338f, 0.03911326f, 0.00335311f, 0.03656028f, 
    -0.18762846f, 0.11186105f, -0.07777024f, -0.09604648f, 0.53088337f, -0.00642631f, 0.17941935f, 0.26022893f, 
    0.06430621f, -0.02272978f, 0.08725846f, -0.01748795f, -0.06486218f, 0.08706965f, -0.05837992f, 0.15390204f, 
    0.04414387f, 0.03824799f, 0.03168232f, 0.01371635f, -0.04945178f, -0.03494459f, -0.05318610f, -0.01165987f, 
    -0.00624003f, -0.01596112f, -0.00274529f, -0.05236106f, -0.04477907f, -0.02433836f, -0.03634958f, 0.01575053f, 
    -0.03592982f, 0.01631099f, -0.03693378f, -0.00488969f, -0.05024801f, -0.02299552f, 0.01279474f, 0.01146348f, 
    0.00102448f, 0.02036423f, -0.01454426f, -0.00875644f, -0.04271442f, 0.01770143f, -0.05497307f, -0.04537030f, 
    -0.00689451f, -0.02797915f, -0.01355814f, -0.02094641f, 0.03692855f, 0.01789592f, 0.04328379f, -0.01892689f, 
    -0.05475819f, 0.01920779f, -0.01525023f, -0.05641437f, 0.01823748f, 0.03400371f, 0.03041130f, -0.01446694f, 
    0.03864298f, 0.00478349f, -0.00147328f, -0.02119716f, -0.01127270f, 0.01304025f, -0.03992520f, -0.05726942f, 
    -0.00788201f, 0.03559257f, -0.02095711f, -0.04501470f, 0.04044108f, 0.02845752f, 0.00989203f, -0.03258472f, 
    -0.02023829f, -0.00191204f, 0.02999851f, -0.02508367f, -0.02561419f, -0.02728358f, -0.02441933f, -0.04271394f, 
    0.01677624f, 0.00087127f, 0.03255996f, 0.00550929f, -0.04020223f, 0.03609719f, -0.02820656f, 0.03971936f, 
    -0.02660692f, 0.03626053f, -0.01137292f, 0.02986901f, 0.00287944f, 0.02058499f, 0.01143509f, 0.01895343f, 
    -0.01598489f, -0.04281852f, 0.01355773f, 0.04075273f, 0.00975151f, 0.01091188f, 0.01163756f, 0.03302558f, 
    -0.01747139f, 0.00585630f, -0.03367707f, -0.00161216f, 0.02392823f, -0.02507864f, -0.03590561f, -0.02655360f, 
    0.02816415f, 0.04329506f, 0.01288983f, -0.02990802f, 0.01663747f, -0.03483073f, 0.03485435f, 0.01416294f, 
    -0.05468713f, 0.04112947f, -0.02398290f, 0.04188390f, 0.02599532f, 0.02389121f, 0.02935494f, 0.03842564f, 
    0.02591873f, 0.00478034f, -0.03645116f, -0.04886334f, 0.03024121f, 0.03800669f, 0.04130750f, 0.02095277f, 
    -0.05033359f, -0.03394210f, -0.02791034f, 0.00275146f, 0.03998369f, 0.02161122f, -0.00159006f, -0.03342567f, 
    -0.03735601f, -0.02996956f, -0.02599370f, -0.01243804f, -0.04126599f, -0.02700218f, 0.04248051f, -0.03951987f, 
    0.00504865f, -0.02192778f, -0.03700195f, -0.00711707f, -0.05384949f, -0.01343893f, -0.00105604f, -0.01197819f, 
    -0.00322703f, 0.02919245f, 0.03487023f, 0.01974105f, -0.00159943f, 0.01634558f, 0.03595515f, -0.05363565f, 
    -0.01028147f, 0.00904078f, -0.03118894f, 0.00482144f, 0.03576645f, -0.04688732f, -0.04236731f, -0.04219618f, 
    0.01538139f, 0.01149301f, 0.02997063f, -0.03398666f, -0.01633238f, -0.03742379f, -0.03114320f, 0.02180121f, 
    -0.03450773f, 0.01777913f, -0.01969998f, -0.03581099f, -0.01016066f, 0.02745851f, -0.01592208f, -0.02802132f, 
    0.02369682f, 0.00547346f, -0.01808686f, 0.03303739f, -0.01711839f, 0.01764661f, 0.04120631f, 0.02754653f, 
    -0.04602576f, 0.01891074f, 0.02852610f, -0.02370469f, 0.03334739f, 0.02404519f, -0.02991541f, 0.01895717f, 
    0.01840131f, 0.00596241f, -0.01634356f, -0.00110903f, -0.05013900f, 0.04397098f, 0.04203258f, 0.00517554f, 
    0.04158382f, 0.01229124f, -0.01444139f, -0.05033085f, -0.00207687f, -0.00354225f, 0.01517332f, 0.00640473f, 
    -0.05324763f, -0.04590883f, -0.04757157f, 0.03057007f, 0.03487828f, -0.00982900f, -0.04490184f, -0.03608137f, 
    -0.02988743f, -0.03128923f, 0.01737018f, -0.03918605f, 0.00534047f, -0.00416475f, 0.02419796f, -0.03995930f, 
    -0.04999975f, 0.02746770f, -0.01307826f, 0.03690175f, 0.01840730f, -0.01537962f, -0.04648296f, -0.05409039f, 
    -0.03737393f, 0.03475329f, -0.02624897f, -0.04550879f, -0.04815457f, 0.00815369f, 0.02968877f, 0.02854478f, 
    0.01537385f, -0.04289199f, -0.00898811f, -0.04887171f, 0.04244760f, 0.02119357f, -0.05641840f, 0.01785325f, 
    -0.03777369f, 0.03774328f, -0.02307892f, -0.05356629f, -0.03389076f, -0.03212741f, -0.01468467f, -0.00930596f, 
    -0.03497182f, -0.02536567f, 0.02213378f, -0.00012742f, -0.01009642f, -0.04473781f, -0.05060221f, 0.02978597f, 
    0.03580366f, -0.01631976f, -0.05100387f, -0.00942281f, 0.01888864f, -0.02201907f, -0.02653618f, -0.02476791f, 
    -0.00405406f, 0.04050775f, -0.03993853f, 0.00059239f, -0.00872850f, 0.01586769f, 0.01171912f, -0.05456930f, 
    0.02721034f, 0.02577368f, -0.00504553f, 0.00373554f, -0.01550018f, 0.03096445f, -0.04802145f, -0.01909857f, 
    0.01631900f, 0.01109683f, -0.05569173f, -0.03414884f, -0.02921049f, -0.01702656f, 0.03320565f, 0.01284960f, 
    0.04476513f, 0.04340855f, -0.01000973f, -0.02566344f, 0.03538398f, -0.01857299f, -0.00017910f, -0.05711592f, 
    0.00485348f, 0.02722274f, -0.05427612f, 0.00268652f, 0.01111603f, -0.01367992f, -0.02243208f, 0.00885869f, 
    -0.01585484f, -0.02865141f, -0.01698221f, -0.05528891f, -0.01883523f, -0.01610452f, 0.01747424f, -0.02632941f, 
    -0.03801234f, -0.04196819f, 0.00713117f, -0.01113453f, -0.00971499f, -0.02394143f, -0.02760271f, -0.01801872f, 
    -0.03084592f, -0.00813628f, -0.03973192f, 0.01470776f, 0.03446920f, 0.04180562f, -0.03166955f, -0.01958958f, 
    -0.02578925f, -0.05101627f, 0.02814467f, -0.02678079f, -0.03706102f, 0.00869624f, 0.03411562f, 0.02404396f, 
    -0.04076222f, -0.02685527f, 0.03035337f, -0.04529198f, -0.04525308f, -0.04389961f, 0.01088105f, -0.00226144f, 
    -0.05679943f, -0.01155935f, -0.00642124f, -0.00493031f, 0.00316278f, -0.05320222f, 0.01080609f, -0.05183284f, 
    0.01987855f, 0.04345873f, 0.01359577f, -0.00529838f, -0.01396551f, -0.00319084f, -0.03278496f, 0.01304792f, 
    0.03827268f, 0.03829961f, 0.00043390f, 0.02839789f, -0.00788677f, -0.04594493f, -0.04886748f, -0.05176978f, 
    0.11919323f, 0.22259064f, 0.14393702f, 0.06639804f, 0.05627040f, 0.10738715f, 0.06157609f, 0.06702131f, 
    -0.03728277f, -0.03399908f, 0.02137986f, -0.05893267f, -0.09431092f, 0.10617453f, -0.14954607f, 0.11869698f, 
    -0.04992191f, 0.02517104f, 0.03747025f, -0.15343499f, 0.10840207f, -0.03509826f, -0.08080253f, 0.18282135f, 
    -0.00548010f, 0.18291458f, -0.03712931f, 0.02789081f, 0.15127176f, 0.01444898f, 0.06904799f, 0.07979547f, 
    -0.07933715f, 0.04853855f, -0.14002858f, -0.01670282f, 0.15067121f, 0.14405715f, 0.13867199f, 0.15768901f, 
    0.09304626f, -0.03361303f, -0.05228950f, 0.02275027f, -0.11811151f, -0.02579722f, -0.06936546f, -0.09763630f, 
    0.10088936f, -0.06524103f, -0.00011100f, -0.00890009f, -0.03878682f, 0.08676685f, -0.07719158f, 0.03795072f, 
    0.02764863f, -0.09941946f, 0.01728885f, 0.12183359f, -0.20406599f, -0.03136871f, 0.01588553f, -0.06268343f, 
    0.04738910f, 0.02874259f, 0.04997591f, -0.01648410f, -0.00295719f, 0.02007354f, 0.07240247f, 0.05977514f, 
    0.06065175f, 0.12325339f, 0.07790107f, 0.04437012f, -0.15479931f, -0.02108000f, 0.03212003f, -0.05095196f, 
    0.06788380f, 0.02978532f, -0.00524178f, 0.16306601f, 0.06309264f, 0.04845743f, 0.11628087f, 0.04184356f, 
    -0.06454871f, 0.00588268f, 0.08580032f, -0.04737639f, 0.00313062f, -0.05302497f, -0.04986129f, 0.00269108f, 
    0.06105107f, 0.06817237f, -0.12180690f, 0.02047464f, -0.06397981f, -0.05269992f, 0.00771789f, -0.05355053f, 
    -0.06943637f, -0.18965368f, -0.10440084f, -0.20760356f, -0.05103276f, 0.14487606f, 0.27479649f, -0.05524397f, 
    0.02738924f, -0.05228277f, -0.02132793f, -0.03938454f, -0.07236025f, 0.01383577f, -0.14159095f, 0.04379863f, 
    0.04221171f, 0.20846313f, 0.02476406f, 0.01550369f, 0.05951277f, -0.04132385f, 0.10783578f, 0.06039855f, 
    -0.05486112f, -0.13579080f, -0.14652050f, -0.05835195f, -0.32825777f, -0.06748687f, -0.43580255f, 0.12921824f, 
    -0.03078572f, -0.03573490f, 0.02514963f, 0.00831188f, -0.00058638f, 0.00586308f, -0.08780593f, -0.05792497f, 
    0.02999711f, 0.13614476f, 0.24039105f, 0.09528538f, 0.13364498f, 0.04449144f, 0.10535835f, 0.03896086f, 
    0.01981265f, 0.08805522f, 0.06862254f, -0.01468490f, -0.00193137f, -0.06662404f, -0.21365593f, 0.00782550f, 
    -0.06095522f, 0.02307185f, -0.04681183f, 0.01672244f, 0.06377373f, 0.00074411f, 0.12193687f, -0.01503065f, 
    0.02284223f, -0.03826106f, 0.06980253f, -0.07190126f, 0.02361539f, -0.03339320f, -0.12945689f, 0.11465801f, 
    -0.08635154f, 0.12048459f, 0.10322536f, 0.02996121f, 0.23859765f, 0.21782775f, 0.03917561f, 0.14725593f, 
    0.02463555f, 0.05556958f, 0.08065570f, 0.04110174f, -0.00830307f, -0.06008094f, 0.03034098f, 0.00191926f, 
    0.30688381f, -0.04424171f, 0.18145028f, -0.00202389f, -0.05114801f, -0.06025890f, 0.12542376f, 0.01587865f, 
    0.02725457f, -0.11265867f, -0.02470638f, 0.03129886f, 0.24296330f, 0.41927612f, 0.09333269f, 0.16306897f, 
    0.12976143f, 0.11383301f, 0.09858796f, 0.07916621f, -0.03721254f, 0.01298169f, -0.05156988f, 0.04491628f, 
    0.21010436f, 0.12681781f, 0.01188101f, 0.02483500f, -0.13122441f, 0.03698765f, 0.11191937f, -0.15497050f, 
    0.01477354f, -0.05273413f, 0.03703317f, -0.01603870f, 0.01007218f, 0.36146817f, 0.21906269f, 0.15843126f, 
    -0.08982529f, 0.20051691f, 0.00987045f, 0.01481907f, -0.04106914f, -0.09569755f, 0.02694758f, 0.09353691f, 
    0.11184613f, 0.21482213f, 0.09328081f, 0.05806516f, -0.08253719f, 0.16102415f, 0.22450721f, -0.00710479f, 
    0.02662963f, -0.01926437f, -0.07177922f, 0.01732955f, -0.10613707f, -0.08183973f, -0.08870271f, -0.02596249f, 
    -0.07418710f, -0.05940229f, 0.00099685f, 0.04376921f, 0.10928768f, 0.05063853f, 0.00778743f, -0.00500160f, 
    0.24641702f, 0.06430385f, -0.08142246f, 0.08285168f, 0.10001405f, -0.00073481f, -0.06337308f, 0.09642766f, 
    0.10209095f, -0.08151037f, -0.05899511f, -0.02709137f, -0.13530660f, -0.12063973f, -0.20699848f, -0.12861668f, 
    -0.02772039f, -0.15990368f, -0.03583784f, -0.03490339f, -0.03297396f, -0.06257812f, -0.02312306f, 0.01027452f, 
    0.11616169f, 0.26778367f, 0.00664053f, 0.06952823f, 0.14977434f, 0.06499157f, -0.09512603f, 0.05254641f, 
    0.03488561f, 0.05346783f, -0.07089835f, -0.01947583f, 0.15663899f, 0.35245189f, -0.01598481f, 0.11685862f, 
    -0.08175371f, 0.15394835f, 0.22642168f, 0.05344223f, 0.00243438f, 0.10389663f, -0.02231108f, -0.00147052f, 
    -0.17799512f, 0.06220756f, 0.19735357f, 0.05580554f, -0.13819498f, -0.09216826f, -0.02392102f, 0.08433184f, 
    0.00993958f, 0.18314001f, -0.02128542f, -0.00788359f, -0.25332612f, 0.03072328f, -0.07855172f, 0.04884060f, 
    0.08252781f, -0.19001004f, 0.01143867f, -0.12277446f, -0.07856169f, -0.12711962f, -0.16974802f, -0.02394191f, 
    -0.12608746f, -0.09298436f, -0.22899365f, 0.14001437f, -0.07920976f, 0.01630596f, 0.03656809f, -0.10973001f, 
    -0.12289169f, -0.10153762f, -0.09384878f, -0.19264923f, 0.05028979f, 0.14811151f, -0.12110063f, -0.05910983f, 
    0.01056590f, -0.01001689f, -0.15712558f, 0.07769132f, 0.06970078f, 0.08266989f, -0.04841639f, -0.01421401f, 
    0.03815195f, 0.13630632f, 0.03811010f, -0.06010407f, 0.01867250f, 0.08842628f, 0.09447905f, 0.02850487f, 
    -0.05258865f, -0.14751582f, -0.09520551f, -0.02287662f, 0.13078916f, 0.12290801f, 0.27107453f, -0.14393933f, 
    0.05004673f, -0.11624916f, 0.05600052f, 0.00053265f, -0.01360802f, 0.04699003f, 0.11666408f, -0.01590096f, 
    0.00840600f, -0.00679176f, -0.22415806f, -0.17711566f, 0.00858763f, -0.00530422f, 0.06525300f, -0.03478988f, 
    0.02355577f, 0.05323376f, -0.01048958f, -0.08600309f, -0.09603853f, -0.11829896f, -0.23096398f, -0.09794267f, 
    0.00259598f, 0.04764299f, -0.04815670f, -0.29903698f, 0.02388607f, 0.17165257f, -0.01036801f, 0.21587738f, 
    0.15813151f, 0.13751744f, 0.27527866f, -0.07895370f, 0.14483087f, 0.06277478f, -0.00694414f, -0.03378575f, 
    -0.07891349f, 0.04146570f, -0.10979453f, -0.13227279f, 0.16996367f, 0.20060284f, -0.17289551f, -0.07623290f, 
    0.18056400f, 0.02949680f, 0.04079467f, 0.10270724f, -0.01474124f, 0.00775297f, -0.03882660f, 0.01152478f, 
    -0.30234730f, 0.21418293f, -0.06268367f, 0.37017894f, 0.02207446f, 0.14799382f, -0.09325313f, -0.01277278f, 
    0.00663531f, 0.00947471f, 0.02398464f, 0.19784266f, -0.08973881f, 0.00902719f, -0.03469199f, -0.10256714f, 
    0.04592276f, 0.01480438f, -0.06814009f, -0.10496038f, 0.07029976f, -0.09712838f, 0.08980302f, 0.19333789f, 
    -0.20092003f, 0.07929907f, -0.01571691f, -0.08380976f, 0.09854400f, 0.12720712f, 0.01092440f, -0.07972609f, 
    0.19839415f, -0.00540046f, 0.11597437f, -0.01725709f, 0.01369944f, -0.00422105f, -0.13650814f, 0.00108272f, 
    -0.06993192f, 0.02206384f, -0.00255527f, -0.03371796f, 0.17412558f, 0.08356263f, -0.00280007f, 0.02202117f, 
    -0.26516446f, -0.09735318f, 0.00828350f, -0.06072798f, -0.03444155f, -0.07773606f, -0.11429588f, 0.03733060f, 
    -0.07694250f, -0.02391776f, -0.03621386f, -0.02178879f, -0.19895591f, 0.19559099f, -0.10898998f, 0.11240112f, 
    -0.01453050f, -0.02154263f, -0.04545512f, -0.00815712f, -0.06355247f, -0.16392232f, -0.04535343f, -0.12289201f, 
    0.01418148f, 0.12152560f, -0.01444575f, -0.05792612f, 0.08759580f, 0.03461762f, 0.00365430f, 0.00243579f, 
    0.01007768f, -0.00588753f, -0.04710310f, -0.05689050f, -0.04579320f, -0.05338762f, 0.58479935f, -0.06414081f, 
    -0.04620785f, -0.16147585f, -0.12812789f, 0.13781399f, -0.09507523f, 0.03029953f, -0.00779515f, -0.02026866f, 
    0.26222807f, 0.04954758f, 0.03388051f, -0.02036787f, -0.00618348f, 0.00363640f, -0.01606506f, 0.05227651f, 
    0.00393813f, -0.01970964f, -0.04318605f, 0.11566249f, -0.13314891f, 0.09713941f, 0.00181805f, 0.16416530f, 
    -0.11933067f, 0.01367759f, -0.10126392f, -0.13951291f, 0.05519501f, 0.05447550f, -0.05789443f, -0.13186784f, 
    -0.13368100f, 0.12199017f, -0.01559961f, -0.21907227f, 0.04073841f, 0.07279046f, -0.07052035f, 0.19919932f, 
    -0.00810964f, -0.05697383f, 0.17428693f, -0.01381451f, 0.18767713f, 0.06595048f, -0.00738047f, 0.00614650f, 
    -0.05525724f, 0.12012102f, 0.23686458f, -0.08849825f, -0.01091250f, 0.03058323f, -0.07433394f, 0.16635936f, 
    0.19102663f, 0.11312827f, 0.16623142f, -0.10434166f, -0.05226312f, 0.00670294f, -0.09497281f, -0.11987461f, 
    -0.01853304f, -0.07041718f, -0.12122191f, 0.05290810f, 0.02838182f, -0.09115306f, -0.12088796f, 0.01040637f, 
    0.20239069f, 0.00409178f, 0.15144250f, 0.02778597f, -0.04461043f, 0.00854255f, 0.02056695f, 0.01672352f, 
    0.23050833f, -0.17008066f, -0.06962527f, -0.02897158f, 0.07002316f, 0.07093647f, -0.13353051f, 0.12891825f, 
    0.06605782f, -0.06607831f, 0.07617789f, 0.07117718f, -0.21858656f, 0.27418944f, -0.04616218f, 0.06701232f, 
    0.20789130f, 0.18664375f, -0.08361732f, 0.05281018f, 0.02327776f, -0.04441446f, -0.02031864f, 0.21975747f, 
    -0.02625748f, 0.19920352f, -0.11332631f, 0.01348324f, 0.04889519f, -0.00613564f, -0.02337585f, -0.14050902f, 
    0.01941242f, 0.06904904f, 0.11757741f, 0.08208177f, 0.04880901f, 0.07709498f, -0.05495404f, -0.22730497f, 
    -0.19893077f, -0.18402880f, -0.02715872f, 0.01037922f, -0.01381221f, -0.03786018f, 0.03430169f, -0.08261748f, 
    0.08052795f, 0.07422595f, 0.23078839f, 0.11619924f, -0.02408351f, 0.13277777f, 0.02036283f, -0.02591092f, 
    -0.01767204f, 0.03894077f, -0.16180637f, -0.00908984f, 0.02841695f, 0.08396721f, 0.17244431f, 0.03008014f, 
    -0.13133337f, -0.01502474f, 0.00614334f, 0.06446633f, 0.00337107f, 0.13483180f, -0.13431966f, -0.07633491f, 
    0.03163396f, 0.00294915f, -0.15437938f, -0.04485073f, 0.01832598f, 0.06804943f, 0.23234968f, 0.03249109f, 
    0.00289749f, 0.03510695f, -0.07700469f, -0.05665747f, 0.08957234f, 0.05716704f, -0.09141863f, 0.07776585f, 
    0.10476562f, 0.06443688f, 0.13795279f, 0.18666629f, -0.08018197f, 0.03396020f, 0.04164468f, 0.01335412f, 
    0.03260722f, 0.08887251f, 0.06002707f, 0.09344435f, -0.00558154f, -0.04060436f, 0.13094084f, 0.13612166f, 
    0.10648648f, -0.02417463f, 0.03609734f, 0.11307292f, -0.24232571f, 0.03833285f, 0.15963078f, 0.40129706f, 
    -0.10200877f, 0.00071718f, -0.15519379f, -0.00853832f, -0.05747217f, 0.28014979f, -0.12000953f, 0.23436487f, 
    -0.18964763f, -0.06072741f, 0.08642879f, 0.00333679f, -0.06292169f, -0.06038677f, -0.09550066f, -0.01487127f, 
    -0.08874963f, -0.01950253f, -0.12615280f, -0.14705460f, 0.45795810f, 0.32032794f, -0.05861910f, 0.18274762f, 
    0.12669195f, -0.07781576f, 0.12270936f, 0.02403898f, -0.03579077f, 0.10002250f, -0.02481047f, 0.03810842f, 
    -0.00183137f, 0.09204333f, -0.04314825f, 0.08153793f, 0.01018240f, 0.02920813f, -0.07470692f, -0.11742186f, 
    -0.16772144f, -0.00901665f, -0.00613476f, -0.03656879f, 0.19036801f, 0.03530444f, 0.07064101f, 0.17514892f, 
    0.05460948f, 0.03479289f, 0.01634322f, -0.01181769f, -0.13244283f, -0.06526011f, -0.06838366f, 0.21779481f, 
    0.17686148f, -0.06416181f, 0.06410587f, 0.28183660f, 0.00508147f, 0.07178088f, 0.05825314f, 0.06379870f, 
    -0.00826026f, -0.02122304f, -0.12611869f, -0.00033979f, 0.16368251f, 0.22115934f, -0.00754589f, 0.10543372f, 
    0.03257643f, -0.01956533f, 0.11553365f, 0.09107458f, -0.03265439f, 0.00048886f, 0.11218505f, -0.05721378f, 
    0.01163093f, -0.02406634f, -0.04698049f, -0.02168420f, 0.00883311f, -0.03385097f, 0.01187724f, -0.01498304f, 
    -0.01542146f, -0.01507812f, -0.05444571f, 0.22852264f, -0.01753601f, -0.09476066f, 0.02646553f, -0.06280140f, 
    0.00284223f, 0.00222129f, 0.01878548f, -0.14263602f, -0.14250168f, -0.03818981f, -0.05518330f, 0.02441333f, 
    0.21868500f, -0.11105572f, 0.09175507f, -0.01838010f, -0.08926575f, -0.07222941f, 0.17749760f, -0.07796203f, 
    -0.06661850f, 0.03176416f, 0.08930486f, -0.03724444f, 0.06260099f, 0.10550769f, -0.29238710f, -0.17291600f, 
    -0.03766324f, 0.12165421f, 0.01880922f, 0.10777610f, -0.01746174f, -0.04764562f, 0.04576983f, 0.02072148f, 
    -0.00123103f, 0.02241539f, 0.01787862f, -0.10414403f, 0.11124071f, 0.08097205f, 0.17015240f, 0.02806218f, 
    0.05282447f, 0.07717023f, -0.03024991f, -0.02400788f, -0.00027531f, 0.05016442f, 0.14760117f, -0.13197625f, 
    -0.03176277f, -0.01473617f, -0.01055268f, -0.02287362f, 0.09468444f, 0.05944794f, -0.08846561f, -0.10833424f, 
    0.05962653f, -0.04331531f, 0.03456395f, 0.05044110f, 0.03416189f, 0.03576899f, -0.16250786f, 0.08669063f, 
    0.16006510f, 0.01339814f, -0.01280425f, 0.21599676f, 0.00630574f, 0.42991978f, -0.06303449f, -0.28865397f, 
    -0.00961273f, 0.01727850f, 0.03768105f, 0.02136599f, -0.16736303f, 0.08594549f, -0.13342395f, 0.05583206f, 
    0.13168131f, 0.03592574f, -0.20734130f, 0.28483802f, -0.00957980f, -0.14178449f, 0.08849806f, 0.03823175f, 
    -0.09883931f, 0.00348585f, 0.15329415f, 0.02951831f, 0.45614475f, 0.04997686f, 0.18203643f, 0.18250330f, 
    0.00765804f, 0.00605702f, -0.00537131f, -0.01477701f, 0.05059455f, 0.07697274f, 0.04715573f, -0.04374711f, 
    0.17721759f, 0.16791959f, 0.13058220f, 0.02327262f, -0.02463609f, 0.09252567f, -0.06905813f, -0.01287011f, 
    0.04118313f, 0.03634753f, -0.05960686f, -0.13251397f, 0.29167107f, 0.17124218f, 0.00323900f, 0.03290837f, 
    -0.02215044f, 0.01607586f, -0.03111996f, 0.07760656f, 0.07286172f, 0.01423033f, -0.09102204f, -0.11919620f, 
    -0.11828953f, 0.08855685f, -0.00924427f, 0.05217323f, 0.00218497f, 0.02000546f, 0.00424801f, -0.04723170f, 
    -0.02318694f, -0.04789094f, -0.03113779f, -0.03777571f, 0.29712942f, 0.06611411f, 0.12823664f, 0.02580510f, 
    -0.00381387f, -0.01591881f, 0.00916345f, 0.00665951f, -0.03310781f, 0.06794247f, 0.05129740f, -0.08098452f, 
    0.24662618f, -0.22773212f, -0.16761294f, -0.21642205f, 0.06631374f, 0.03930290f, -0.04424965f, 0.10721977f, 
    0.01992391f, -0.04443744f, 0.08146343f, -0.11066765f, 0.23767340f, 0.24117872f, 0.11018211f, 0.33035687f, 
    -0.04447537f, 0.10530848f, -0.04621668f, 0.13192677f, 0.05636254f, 0.04609609f, 0.02516560f, 0.00940062f, 
    0.14093593f, 0.13764310f, -0.12867294f, -0.06488762f, -0.04636382f, -0.10317157f, 0.13120146f, -0.12602596f, 
    -0.22402088f, -0.03457464f, 0.02581227f, -0.07015515f, -0.21350804f, 0.16853222f, 0.34913319f, -0.13897508f, 
    -0.15207601f, 0.03714661f, -0.12372616f, 0.01377310f, -0.00875469f, -0.05182264f, 0.01121124f, -0.23344965f, 
    -0.19358873f, 0.10357655f, 0.30664659f, -0.07850607f, -0.00956077f, 0.07534298f, -0.12660463f, 0.06721451f, 
    0.01695326f, -0.03383648f, 0.11854270f, -0.20652902f, 0.13006245f, 0.04360983f, 0.05497476f, 0.08602704f, 
    -0.00937266f, 0.00701211f, -0.02977083f, -0.09111298f, -0.04425062f, 0.01504127f, 0.03831267f, 0.01974043f, 
    0.10814448f, -0.03320521f, -0.00396182f, 0.07997119f, 0.05300431f, -0.15252419f, -0.07418187f, 0.04558108f, 
    -0.05468397f, 0.05963973f, 0.00498992f, 0.06430807f, 0.02959137f, 0.24881478f, -0.22388384f, 0.25241220f, 
    0.06752379f, 0.01682364f, 0.02060208f, 0.03344457f, 0.06349549f, 0.02528705f, 0.10427406f, -0.10165288f, 
    0.17324843f, 0.14753301f, -0.02767014f, 0.25225109f, -0.07713619f, 0.16631344f, -0.09413509f, 0.01213353f, 
    0.00676001f, -0.10099309f, -0.06127409f, 0.06586984f, 0.27347341f, 0.09775612f, 0.09247943f, 0.16088687f, 
    -0.05254093f, -0.04711021f, -0.13726024f, -0.00862222f, -0.02393658f, 0.03422127f, 0.00471610f, -0.02668674f, 
    -0.08205243f, 0.16357125f, 0.22135098f, -0.13175569f, -0.12717053f, -0.03186604f, -0.19435295f, 0.10766004f, 
    -0.00213480f, -0.03007889f, -0.10709412f, -0.09761330f, -0.03536768f, 0.18209048f, -0.13611694f, 0.10164707f, 
    -0.10312173f, -0.09138115f, 0.00062597f, 0.05156954f, -0.02832226f, 0.11783949f, 0.05714098f, -0.17770593f, 
    0.22673264f, 0.02504753f, 0.11663005f, 0.03945068f, -0.03279587f, 0.03162728f, 0.01349503f, 0.05361397f, 
    0.02550151f, 0.27512112f, 0.07368568f, 0.14554812f, -0.06984501f, 0.10774230f, -0.03432989f, 0.07152412f, 
    0.06980962f, 0.08323064f, -0.24592388f, -0.07512137f, -0.12047287f, -0.03766792f, -0.06548483f, -0.01405013f, 
    -0.18137804f, -0.07256529f, -0.10892744f, -0.29344678f, -0.06012174f, 0.06822482f, 0.05107732f, -0.04173036f, 
    0.06772880f, 0.03815579f, -0.06061542f, -0.00747425f, 0.21907556f, 0.03949770f, -0.11885387f, 0.23258980f, 
    -0.05483262f, 0.08889516f, 0.11761201f, -0.04752862f, -0.10752405f, -0.00442621f, -0.00580942f, -0.06417071f, 
    0.01139989f, -0.03571261f, -0.04440244f, -0.04571712f, 0.00468139f, -0.01903494f, -0.04318565f, -0.01904148f, 
    -0.01306675f, -0.02743545f, 0.03372150f, 0.02934259f, 0.03922273f, -0.03141507f, 0.02623269f, 0.00108018f, 
    0.01720425f, -0.03247810f, -0.03728602f, 0.01516576f, -0.02098646f, 0.00316679f, -0.01295446f, -0.02006757f, 
    0.04074058f, -0.02547563f, -0.03041634f, -0.00882230f, -0.04814940f, -0.03971886f, -0.01919594f, -0.02268418f, 
    0.01908815f, 0.00890274f, -0.02164748f, -0.02826661f, -0.00575535f, -0.04805380f, 0.01819309f, 0.02115310f, 
    -0.04728995f, -0.03009565f, 0.01747554f, 0.00642525f, 0.01894508f, 0.03476213f, -0.01486403f, -0.05137203f, 
    -0.03959604f, -0.03643418f, -0.03902676f, 0.01042796f, 0.01993666f, -0.00402965f, -0.00887759f, -0.05526754f, 
    0.00500306f, -0.05148938f, -0.02429886f, -0.02880427f, 0.00067218f, -0.00018420f, -0.01661995f, -0.03971623f, 
    0.01022566f, 0.02207538f, 0.01280691f, -0.04240077f, -0.04118925f, -0.04045272f, -0.02713309f, 0.02632314f, 
    -0.05630311f, 0.01531285f, -0.04998110f, -0.03747021f, -0.02662657f, -0.04523894f, -0.05348402f, -0.03612243f, 
    -0.05174046f, -0.00779755f, 0.01988453f, 0.01507262f, -0.00829231f, 0.04203024f, -0.02877553f, -0.02923454f, 
    0.00426748f, 0.00556718f, -0.03819089f, -0.05449466f, 0.02651086f, -0.02016238f, 0.01273581f, -0.01025935f, 
    0.02380734f, -0.04852910f, 0.01717175f, -0.02852812f, -0.02613843f, 0.00767371f, 0.03840949f, -0.00722098f, 
    0.02728422f, 0.02122732f, -0.01827966f, -0.05038806f, -0.03462189f, -0.03739633f, -0.00455195f, -0.00812621f, 
    0.01791882f, 0.03706151f, 0.04229826f, 0.02870966f, -0.05172606f, 0.04051927f, -0.01971087f, -0.01866170f, 
    0.04082960f, 0.04375602f, -0.01377616f, 0.01548404f, -0.02814448f, -0.03412204f, 0.00348244f, 0.02677421f, 
    0.01708223f, 0.00106718f, 0.03218868f, -0.05406178f, 0.00605075f, 0.00702439f, -0.04728917f, -0.05665200f, 
    0.04365319f, -0.04105311f, -0.00439785f, -0.03555055f, -0.04020144f, -0.03791536f, -0.03488881f, 0.00853300f, 
    0.02494229f, -0.01075452f, -0.01088817f, -0.04404638f, -0.04881803f, 0.03591995f, -0.00671503f, 0.02009263f, 
    -0.02084467f, -0.00027051f, -0.00740923f, -0.00508636f, -0.01301160f, -0.00582920f, 0.01148887f, -0.00475630f, 
    -0.05173965f, -0.04555134f, -0.00141578f, 0.02684337f, -0.01829863f, -0.04469288f, -0.01313565f, -0.02962189f, 
    -0.02780465f, -0.02542972f, -0.04095564f, -0.00616081f, -0.04598713f, -0.00086009f, -0.04037695f, 0.01230990f, 
    -0.04379693f, -0.05139978f, -0.01146737f, -0.02439903f, 0.02321166f, 0.02647747f, -0.02107061f, -0.02179652f, 
    0.04042804f, -0.04707727f, -0.01369788f, 0.00289658f, 0.00492714f, -0.02712767f, 0.00205185f, -0.03479652f, 
    0.02400924f, 0.00646760f, -0.04983330f, 0.01620136f, 0.00152307f, 0.03322355f, 0.01901753f, 0.04045292f, 
    0.04311329f, -0.05113256f, 0.04428496f, -0.02799760f, 0.00881963f, -0.03941499f, -0.04602448f, -0.02987755f, 
    0.04376315f, -0.00015753f, 0.03252052f, -0.04264494f, -0.04819684f, -0.04129347f, -0.02880041f, 0.00837270f, 
    0.00037640f, 0.02900979f, 0.00149621f, 0.01198651f, 0.00289261f, -0.00528187f, -0.02170298f, 0.01479877f, 
    0.02314478f, 0.00275654f, -0.05620386f, -0.03805738f, 0.00413972f, -0.01416632f, -0.04655047f, 0.04064122f, 
    -0.03175050f, 0.04111874f, -0.02823533f, -0.04929931f, -0.03691470f, 0.02692720f, -0.02988075f, -0.01738374f, 
    0.02822380f, -0.02140931f, 0.03847095f, -0.03056692f, 0.01857702f, -0.01696378f, -0.03016799f, 0.02523244f, 
    0.03385267f, -0.01559430f, -0.02291431f, -0.00792963f, 0.04926098f, -0.04961473f, -0.00881211f, -0.02696561f, 
    0.03152919f, 0.00690292f, 0.01185844f, -0.03906309f, 0.03676970f, -0.01220582f, -0.04637877f, -0.03795303f, 
    -0.05648812f, -0.01851523f, 0.03946948f, -0.02191964f, 0.04124408f, -0.04569226f, -0.02277650f, -0.05433501f, 
    -0.01970541f, 0.00723456f, 0.01950233f, -0.04495863f, -0.04327634f, 0.04250225f, 0.01604735f, 0.01138676f, 
    0.03174180f, -0.03966500f, 0.03349475f, 0.02199372f, 0.04418935f, -0.04322428f, 0.02061732f, 0.02342482f, 
    0.01166847f, 0.01822598f, 0.02232851f, 0.01919557f, -0.03927127f, -0.04132163f, 0.03679948f, -0.00045868f, 
    0.02253607f, -0.03443031f, 0.00783253f, -0.05538870f, -0.01074615f, -0.00837766f, 0.01103975f, 0.00250705f, 
    -0.01704087f, -0.04560257f, -0.03850308f, 0.03840771f, -0.04670624f, -0.02703641f, 0.01060542f, -0.00730998f, 
    -0.03877681f, -0.02596761f, 0.02795370f, 0.02859640f, -0.01023750f, -0.04670140f, -0.05626479f, 0.04455015f, 
    -0.04570651f, -0.05578469f, 0.03099168f, 0.01375502f, -0.01629225f, -0.04723679f, 0.01798137f, 0.02806316f, 
    0.03259493f, 0.02212455f, -0.01091387f, 0.01810543f, 0.01846276f, -0.03774256f, -0.04079426f, -0.05415898f, 
    -0.04859936f, -0.05600695f, -0.00194461f, 0.00641050f, 0.01000004f, -0.00514014f, 0.01472262f, -0.03762446f, 
    -0.02171441f, 0.00961544f, -0.03310436f, 0.01420557f, -0.04780856f, 0.00263357f, 0.00913276f, -0.02230576f, 
    0.02105935f, 0.01610607f, 0.00662408f, -0.03071450f, -0.05221029f, 0.01310940f, 0.00046181f, 0.01256376f, 
    0.02011558f, 0.02782653f, 0.02202657f, -0.03986995f, 0.04409882f, -0.04611761f, -0.00040832f, -0.02078142f, 
    -0.00912711f, -0.01418787f, 0.02740526f, 0.02931091f, -0.01272233f, 0.01019823f, 0.01286870f, 0.03774446f, 
    -0.03589167f, -0.03794549f, 0.03259833f, -0.05533779f, -0.03368256f, -0.01953294f, 0.03745045f, -0.01957387f, 
    -0.11692170f, -0.12110986f, -0.00965249f, 0.04530511f, 0.07142577f, 0.08624637f, -0.01581481f, 0.00266670f, 
    0.10787010f, 0.06367363f, 0.05718232f, 0.03586224f, 0.37819049f, 0.11098924f, 0.23331487f, -0.07449356f, 
    -0.03247864f, -0.13691010f, -0.03978859f, 0.01257332f, -0.01865992f, 0.06823432f, 0.06940392f, -0.06262226f, 
    -0.14652647f, 0.08882470f, -0.05387849f, 0.06713375f, -0.10343738f, -0.01984705f, 0.02217647f, 0.17048109f, 
    0.05737076f, -0.05588720f, 0.06439665f, -0.03500596f, -0.20272397f, -0.18612477f, 0.30315462f, 0.12750508f, 
    -0.06632292f, 0.02814999f, -0.13260992f, 0.10864813f, 0.00304831f, -0.03092907f, 0.08939936f, -0.04279891f, 
    0.18633346f, 0.08821909f, 0.11343400f, -0.42656231f, 0.03064753f, -0.04984049f, 0.14336056f, 0.07066429f, 
    0.01697965f, -0.06398912f, -0.00571397f, -0.02632150f, 0.05527338f, -0.05365495f, 0.25134453f, 0.15019929f, 
    -0.10741297f, -0.14247669f, -0.09078604f, 0.11392231f, 0.03457394f, 0.03591326f, -0.02914038f, -0.14651082f, 
    0.11171576f, -0.00778157f, 0.14649314f, 0.19227362f, -0.29585549f, -0.20542206f, -0.08772793f, 0.05822815f, 
    -0.10289995f, 0.05199211f, 0.03333853f, 0.15707406f, -0.23046657f, 0.02154820f, 0.22157867f, 0.20975374f, 
    0.08183312f, 0.00842748f, 0.01924453f, -0.13734074f, 0.03135790f, -0.05805957f, 0.03044295f, 0.01420557f, 
    0.14451168f, 0.19923200f, -0.20941386f, 0.02882527f, 0.04983741f, -0.02955789f, 0.22852655f, -0.06565121f, 
    0.05969200f, 0.06786149f, -0.07565584f, -0.00943870f, 0.19909117f, -0.28862137f, 0.38669983f, 0.11782920f, 
    -0.15478531f, -0.11281866f, -0.11244990f, 0.00966402f, 0.10193314f, 0.14667368f, 0.08113295f, 0.14144526f, 
    -0.02086534f, -0.04328974f, -0.05158134f, -0.04288455f, 0.09327343f, 0.01697171f, 0.05319968f, 0.15995680f, 
    0.08035725f, 0.04796807f, -0.02987946f, -0.01293188f, -0.05429306f, -0.14895387f, -0.60969949f, -0.08490024f, 
    -0.06204649f, -0.02852498f, 0.19926886f, -0.12256071f, 0.07686948f, -0.02135296f, -0.08889361f, 0.00995070f, 
    -0.37321311f, -0.02244023f, -0.26797101f, 0.08344924f, 0.05805612f, -0.02738551f, 0.21687026f, 0.09923601f, 
    -0.01735942f, -0.06034307f, 0.05086044f, 0.01719156f, 0.19017339f, 0.03035581f, 0.09494843f, -0.16668049f, 
    -0.05603891f, -0.08467913f, -0.03513704f, -0.00341531f, 0.09814534f, 0.11312332f, 0.13955139f, 0.11067431f, 
    0.05676077f, -0.38474867f, -0.04012880f, -0.03494369f, -0.01480463f, 0.00578409f, -0.06505078f, -0.04912712f, 
    -0.05730389f, -0.13901657f, 0.01286650f, -0.12314753f, -0.16760276f, 0.05846081f, 0.06695472f, -0.01084422f, 
    0.06786147f, 0.00455043f, 0.01977677f, 0.25788763f, -0.02133362f, -0.02641534f, 0.05463438f, -0.08007511f, 
    -0.20544520f, 0.22778746f, 0.06012111f, -0.13039707f, -0.23441316f, -0.17376973f, -0.02813381f, 0.10275511f, 
    0.06177238f, -0.00630652f, 0.15313430f, 0.02673266f, -0.06454042f, 0.16771902f, 0.12301135f, 0.00565713f, 
    0.00704744f, 0.09661566f, -0.01015163f, -0.02564289f, -0.00748189f, 0.05780667f, -0.16117032f, -0.01635253f, 
    0.11850038f, 0.21973053f, 0.31092736f, -0.03109841f, -0.08678409f, -0.06312212f, -0.00410778f, -0.09577925f, 
    0.02926598f, 0.07971249f, 0.03988854f, 0.02778269f, -0.28661269f, 0.25908613f, -0.09077555f, 0.26007009f, 
    -0.06921630f, -0.00158301f, 0.11865215f, -0.23988760f, 0.05904008f, -0.04718875f, -0.02533501f, 0.02115997f, 
    -0.07330210f, 0.21162409f, -0.05458704f, 0.13824098f, 0.05450330f, 0.04113019f, 0.24587831f, 0.03462385f, 
    0.01058463f, -0.05606000f, -0.10212122f, -0.01086725f, -0.27761728f, -0.27312380f, 0.03279020f, 0.05179353f, 
    0.22755873f, 0.19931841f, 0.10181101f, 0.04540676f, 0.04772415f, 0.05895673f, -0.09731594f, 0.11083711f, 
    0.05221344f, 0.18776749f, -0.04270658f, -0.13749662f, -0.04324685f, -0.14766935f, -0.06463458f, 0.10914840f, 
    0.11671057f, -0.02331930f, 0.14379556f, -0.06993226f, 0.08742128f, -0.26567569f, -0.06847095f, -0.07964342f, 
    0.01713073f, 0.05833039f, -0.01312155f, -0.12152517f, -0.06814389f, -0.07715888f, 0.05845625f, 0.07284648f, 
    -0.15290572f, 0.05601150f, 0.21235365f, 0.07765860f, -0.00575214f, -0.05049165f, -0.16090971f, 0.06871784f, 
    0.03203217f, 0.00524438f, 0.04365968f, -0.00464112f, -0.11406415f, 0.21500252f, 0.19487108f, 0.00268424f, 
    -0.08354961f, -0.10347193f, 0.04329377f, 0.06897012f, 0.03359357f, 0.01402725f, -0.02316693f, -0.03887225f, 
    -0.14629988f, 0.11131985f, -0.16898541f, 0.15823419f, 0.07549909f, 0.06553113f, 0.17858380f, 0.01257284f, 
    0.02644200f, 0.06308821f, -0.01970355f, 0.00711929f, 0.42825338f, -0.12873693f, -0.08528583f, -0.24895874f, 
    0.17612480f, 0.02605728f, 0.11495809f, 0.07780833f, 0.07941774f, -0.15817638f, 0.10947575f, -0.08078136f, 
    0.03542493f, 0.02086411f, -0.28847101f, -0.05239575f, 0.05918203f, 0.02870509f, 0.18816614f, -0.02345361f, 
    0.07603723f, 0.06524173f, 0.01858833f, 0.03274684f, -0.38411933f, -0.08669310f, 0.27834460f, -0.20139904f, 
    -0.03334173f, -0.02230309f, -0.13577682f, 0.15280756f, 0.05348469f, 0.04331221f, 0.06181585f, -0.00582355f, 
    -0.06698947f, 0.23126641f, 0.20250283f, 0.22982509f, -0.07398092f, -0.15313621f, -0.02051963f, -0.04046465f, 
    0.16686948f, -0.11494134f, 0.01566727f, 0.05359917f, 0.02006139f, -0.07747845f, 0.38974515f, -0.01088799f, 
    -0.09444728f, -0.01323520f, 0.02147088f, 0.06878546f, 0.22377911f, 0.18046218f, 0.05274459f, -0.05679950f, 
    0.19363397f, 0.26258853f, 0.20921676f, 0.19797416f, 0.10092261f, 0.07440155f, 0.11876901f, 0.17627861f, 
    -0.03927098f, -0.13217090f, -0.05167609f, -0.11677939f, 0.04108704f, -0.09534869f, 0.06135710f, -0.04014247f, 
    -0.09473985f, -0.02581032f, -0.01756432f, -0.31017783f, -0.09880871f, -0.10990313f, -0.22673889f, -0.16140963f, 
    0.08626013f, 0.02249122f, -0.03670103f, -0.01849768f, 0.11892191f, 0.13985546f, 0.16083731f, 0.14257748f, 
    0.03503959f, 0.16337687f, 0.08792026f, 0.20892932f, 0.18222097f, 0.21723916f, -0.09397183f, -0.08587941f, 
    0.15625615f, 0.05153223f, -0.09565753f, 0.20460109f, 0.01306937f, -0.04241760f, 0.04343279f, 0.01935552f, 
    -0.35817575f, 0.16857424f, 0.09061532f, -0.18116893f, 0.20921296f, -0.04578974f, 0.10786060f, 0.13315633f, 
    -0.23300454f, 0.04586336f, -0.11777455f, -0.20852797f, 0.33403179f, 0.16756071f, 0.29614195f, -0.01430059f, 
    0.23574331f, -0.08569430f, -0.10673223f, -0.05580689f, -0.05321100f, 0.03313207f, -0.09229731f, -0.12314576f, 
    0.06819512f, 0.09231620f, 0.03365345f, -0.03482170f, 0.07832274f, -0.02121763f, -0.13449581f, 0.05210260f, 
    -0.13207981f, -0.06730630f, -0.16229276f, -0.20076062f, 0.04667124f, 0.15104209f, -0.16365828f, 0.11993700f, 
    0.04503839f, 0.01534145f, -0.17267823f, 0.04437388f, -0.09360363f, -0.12906757f, -0.06106264f, -0.22552803f, 
    0.05238007f, 0.07621802f, 0.23998980f, 0.20076366f, -0.07699842f, 0.06048260f, 0.03382315f, -0.02861419f, 
    0.13055664f, 0.15686786f, 0.35852602f, 0.21804519f, -0.03296980f, 0.17375243f, 0.18611698f, 0.04034575f, 
    -0.06989954f, -0.00932399f, -0.12285011f, -0.13175926f, 0.03669873f, 0.15009212f, 0.11344736f, 0.11420413f, 
    0.12239540f, 0.17637293f, 0.16516531f, 0.15887152f, -0.03236948f, 0.12176275f, -0.04954475f, 0.06647914f, 
    0.02685454f, 0.06314850f, 0.04272411f, 0.04115291f, -0.42833337f, 0.04362558f, -0.13251337f, 0.36035982f, 
    0.09180873f, 0.18204483f, 0.10591631f, -0.11430148f, 0.18938541f, -0.21459979f, 0.03126829f, 0.14289980f, 
    -0.03090465f, 0.09269727f, 0.04552083f, 0.09342683f, -0.05223461f, 0.21337719f, 0.03136541f, -0.08787104f, 
    -0.14956880f, -0.34541526f, -0.14988437f, -0.27643457f, 0.20896755f, -0.06813002f, -0.10332112f, 0.12137556f, 
    0.06862742f, -0.17118385f, -0.20009674f, -0.38367319f, -0.20976569f, -0.06367469f, -0.10278378f, -0.08460440f, 
    0.30930948f, 0.11016266f, 0.03425354f, -0.36474398f, -0.04694235f, -0.00530596f, 0.07758491f, -0.03712402f, 
    -0.12643178f, 0.00003099f, -0.28052208f, 0.01820209f, 0.09598428f, 0.03846217f, -0.16868360f, 0.13720453f, 
    0.10741004f, 0.12998709f, 0.14572284f, 0.06117813f, -0.01749068f, -0.15646866f, 0.10100084f, -0.17049231f, 
    0.34517020f, -0.02196870f, 0.11584777f, 0.15274951f, -0.05451372f, -0.20708527f, 0.05660115f, -0.23765200f, 
    0.03784309f, 0.06198403f, -0.02271174f, 0.10137841f, 0.28340295f, 0.21796390f, 0.03581880f, -0.10712981f, 
    -0.07808750f, 0.06645139f, 0.08830609f, 0.11460350f, 0.06125328f, -0.05656618f, 0.03629890f, -0.05724141f, 
    0.06416693f, -0.13806944f, 0.09428148f, -0.26402009f, -0.06822574f, 0.03092154f, -0.18671806f, 0.09041556f, 
    0.00965662f, 0.05666401f, -0.12003186f, -0.14522396f, 0.54482955f, 0.00626030f, 0.27362391f, 0.00300476f, 
    0.01427351f, -0.03546796f, -0.01644364f, 0.07837815f, 0.15010497f, -0.06860857f, 0.01337903f, -0.03716400f, 
    0.20300218f, 0.05235267f, 0.00340093f, -0.23832610f, -0.10313491f, 0.08948421f, -0.10191152f, 0.09024622f, 
    -0.11665032f, 0.02809954f, -0.05511198f, -0.11301922f, 0.07420994f, 0.07496643f, -0.02805730f, -0.06829526f, 
    0.10195055f, 0.04251177f, 0.05920752f, 0.01583286f, -0.15358339f, -0.12137121f, -0.10580377f, -0.37595308f, 
    0.09375662f, -0.10958117f, -0.08982933f, 0.08270466f, 0.00931196f, 0.01307239f, 0.02972534f, -0.01274761f, 
    0.01314600f, 0.08844892f, -0.01693426f, 0.15334971f, 0.18196778f, -0.19379647f, 0.20777260f, -0.17579958f, 
    -0.03505545f, 0.03273016f, -0.16165090f, -0.15090036f, 0.00935276f, -0.03236392f, 0.01658362f, 0.00323062f, 
    0.24580821f, 0.14343233f, 0.09429635f, -0.11771969f, 0.18772596f, 0.01352267f, 0.09194291f, 0.26376837f, 
    0.10706390f, 0.04469968f, 0.08235309f, -0.08175492f, 0.17346707f, -0.04391718f, -0.28201652f, -0.16780485f, 
    -0.01221949f, 0.14168078f, -0.07145508f, 0.17988861f, 0.06952696f, -0.12839702f, -0.12925802f, -0.18079898f, 
    -0.18161073f, -0.09507040f, -0.02264895f, 0.03339677f, 0.07773437f, 0.04071166f, 0.05385964f, -0.27982765f, 
    0.02027842f, -0.03712044f, -0.19535197f, -0.06995066f, 0.05992875f, -0.41876259f, 0.14515655f, -0.24178170f, 
    -0.00375563f, -0.08143241f, 0.06464916f, -0.09598541f, -0.08721988f, -0.05737589f, 0.12154607f, 0.09826098f, 
    -0.15988341f, 0.01549968f, -0.01090293f, 0.29570287f, 0.14798696f, 0.00747535f, 0.19151616f, 0.01779838f, 
    0.23563765f, 0.11734216f, 0.33557129f, 0.13818936f, 0.09266166f, -0.31358394f, -0.02614767f, -0.13116342f, 
    0.16802758f, -0.10587695f, 0.12979583f, 0.06964344f, -0.13381727f, 0.09693855f, 0.21076953f, -0.01536539f, 
    0.31121314f, 0.02165869f, 0.21319766f, 0.34639257f, 0.03698701f, -0.05843219f, -0.14251408f, -0.28885210f, 
    0.22578411f, 0.08252928f, 0.01366043f, 0.18146549f, 0.15261869f, 0.28018123f, -0.12832077f, -0.07226633f, 
    -0.05630239f, 0.12164187f, -0.09386801f, -0.12630533f, 0.04052244f, -0.13188353f, 0.07812107f, -0.16222507f, 
    0.01887081f, -0.01057251f, 0.00970236f, -0.04529238f, 0.01891341f, -0.03222622f, -0.01571934f, 0.01446315f, 
    0.04055955f, 0.00480955f, -0.02355663f, -0.02574939f, -0.01903653f, 0.00084222f, -0.05609420f, 0.02300476f, 
    0.00351135f, -0.01872092f, -0.05887523f, -0.01966755f, 0.01800428f, -0.02647750f, 0.00008241f, -0.03833663f, 
    0.01255139f, -0.01941133f, 0.02580527f, -0.00955548f, -0.02506256f, 0.02394135f, 0.02565286f, -0.01169028f, 
    -0.00463306f, 0.00857139f, -0.05454299f, -0.03598150f, -0.04535057f, -0.01718539f, -0.02868347f, 0.01309261f, 
    -0.05010011f, -0.04610563f, -0.02235588f, 0.01162062f, -0.05918248f, 0.04133119f, -0.03409634f, 0.02264963f, 
    -0.00447899f, 0.04918786f, -0.04527495f, -0.01484149f, 0.03976861f, -0.00836238f, -0.00880773f, 0.04271157f, 
    -0.01528391f, -0.00739031f, 0.01014602f, 0.02258520f, 0.00171216f, 0.01959431f, -0.00585690f, -0.03551116f, 
    -0.04198920f, 0.00838686f, -0.04537559f, -0.03293582f, -0.02111189f, -0.04865522f, 0.01291839f, -0.02008140f, 
    -0.02823859f, 0.04206204f, 0.01870240f, -0.02204753f, 0.04732363f, 0.03186924f, -0.01210806f, 0.05061172f, 
    -0.03396892f, 0.01496523f, -0.03956754f, -0.02644152f, 0.00525728f, 0.02957541f, -0.04048133f, 0.01798217f, 
    0.02504258f, -0.03102029f, 0.02682289f, 0.02794606f, -0.04929611f, 0.00192764f, 0.01760448f, 0.02887106f, 
    0.01654401f, -0.05430117f, -0.01705342f, -0.01120690f, 0.00724939f, -0.04108158f, 0.01012177f, 0.00525417f, 
    0.03282268f, 0.00599651f, 0.03472994f, -0.04216409f, -0.00410130f, 0.03576776f, -0.02241504f, -0.03120358f, 
    0.02139223f, -0.05940662f, 0.00577913f, -0.03569095f, -0.01835977f, -0.01653589f, -0.03120395f, 0.01254292f, 
    -0.02871068f, -0.01266505f, 0.00874265f, -0.02187669f, 0.00213926f, 0.01567896f, -0.01442175f, -0.01499774f, 
    0.02884041f, 0.00126327f, -0.00769247f, 0.01378195f, 0.01473790f, -0.03077220f, -0.03404316f, 0.04290427f, 
    -0.01562217f, -0.00106438f, -0.01905679f, 0.03729242f, 0.01358268f, 0.02160715f, -0.05733071f, 0.03271302f, 
    -0.05448241f, -0.00506143f, 0.01559782f, -0.01251517f, 0.00879191f, -0.03458691f, 0.00491074f, -0.05117381f, 
    -0.00448391f, 0.01200572f, 0.02930686f, 0.00760137f, 0.01046502f, -0.00524648f, -0.04984270f, -0.03877157f, 
    0.02501666f, 0.01026948f, -0.03130913f, -0.04637016f, 0.02128713f, 0.01965650f, 0.00994145f, -0.01999757f, 
    -0.04481564f, 0.01476097f, -0.02848620f, 0.01860254f, -0.03276820f, 0.00141584f, -0.04123879f, -0.00362701f, 
    0.00343349f, -0.05221943f, 0.05278605f, -0.05532388f, 0.00588337f, 0.03088195f, 0.00916016f, -0.05828217f, 
    0.02762992f, 0.01623368f, 0.03569956f, -0.03265383f, 0.02862253f, 0.04618498f, -0.01790812f, 0.01949726f, 
    -0.03245805f, -0.03508781f, -0.02144097f, -0.05433066f, 0.01842485f, 0.02375016f, -0.03181360f, 0.01202082f, 
    -0.04418998f, -0.01528683f, 0.03230830f, -0.00222112f, -0.03670416f, 0.03187711f, 0.02095616f, 0.01874354f, 
    0.01988629f, -0.03682674f, -0.04600872f, 0.03187167f, -0.04876295f, 0.03456855f, 0.02858173f, 0.02645401f, 
    -0.02167548f, -0.05523328f, -0.05415913f, 0.00536146f, 0.00277691f, -0.04661153f, -0.00257220f, 0.00625207f, 
    -0.04885200f, 0.02039321f, -0.01064602f, -0.01647822f, 0.01432993f, -0.00805848f, -0.04062739f, -0.01574145f, 
    -0.04100955f, -0.01857545f, -0.04606514f, 0.01114351f, 0.02908047f, -0.01208552f, -0.04016550f, 0.03605831f, 
    0.03178393f, -0.03042218f, 0.03840561f, -0.00626445f, -0.04142609f, 0.01118482f, -0.02745618f, 0.02829330f, 
    0.03852601f, -0.03768118f, 0.04080517f, -0.01034547f, -0.04345722f, 0.01209084f, -0.05054485f, -0.00223398f, 
    0.00025508f, 0.02038156f, -0.01162725f, -0.02536000f, 0.00296845f, 0.01663898f, -0.02329866f, 0.01070352f, 
    0.02621683f, 0.03229028f, -0.04578616f, -0.04042601f, 0.02227109f, -0.02492464f, -0.04384164f, -0.00895778f, 
    0.00509666f, -0.02281358f, -0.02757854f, 0.02095786f, 0.00643835f, 0.04096980f, 0.02631716f, 0.01847667f, 
    -0.02014243f, 0.02912867f, 0.00718458f, 0.02972124f, -0.02772404f, 0.01308487f, -0.02852444f, -0.04650983f, 
    -0.04705602f, 0.01910383f, -0.02804986f, 0.03349552f, 0.01739945f, -0.01623083f, -0.02184988f, 0.03833967f, 
    0.00155570f, -0.05581314f, 0.03041673f, -0.00666751f, 0.03732106f, -0.00140115f, -0.00256472f, 0.04219668f, 
    -0.00031195f, -0.03538367f, -0.03780881f, 0.00098581f, -0.05756530f, -0.05729016f, -0.02154899f, -0.00361012f, 
    -0.02025709f, -0.04842615f, 0.02911364f, -0.04415337f, -0.00893133f, -0.02268981f, -0.05127452f, 0.00312090f, 
    0.02730452f, 0.01494648f, 0.00120555f, -0.05460484f, 0.03667443f, 0.02109022f, -0.00313397f, -0.02110439f, 
    -0.01565726f, -0.02911275f, 0.03108951f, -0.00891882f, -0.04215964f, -0.05369138f, 0.01242274f, -0.04577382f, 
    -0.01663982f, -0.01074873f, -0.02345514f, -0.01951580f, 0.02516212f, -0.00168304f, -0.04407374f, -0.05219352f, 
    0.03192013f, -0.03596699f, -0.04679961f, -0.00013101f, -0.02949490f, -0.00397901f, 0.03117721f, 0.00660647f, 
    -0.01819368f, 0.01780626f, 0.00618605f, 0.02267529f, -0.03250294f, -0.05106600f, 0.00051071f, -0.00584816f, 
    0.02783427f, -0.03954216f, -0.04392363f, -0.02147310f, -0.05124430f, 0.01863211f, 0.03879688f, -0.05150086f, 
    -0.04437246f, -0.02714715f, 0.00017474f, -0.00374291f, -0.00698396f, 0.03541325f, -0.04535173f, 0.04646478f, 
    0.00437676f, -0.05612278f, 0.03893350f, 0.04225114f, -0.04257064f, -0.01200625f, 0.00109906f, -0.03840949f, 
    0.09759482f, 0.12952036f, 0.15936530f, 0.11831177f, 0.11516134f, 0.02331349f, 0.05145206f, 0.15196544f, 
    0.12827644f, -0.04438021f, 0.03978391f, -0.07435060f, 0.11270848f, -0.02959678f, -0.01415435f, -0.13490817f, 
    -0.16052587f, 0.03208934f, 0.10784434f, -0.31094402f, 0.14067879f, -0.08964771f, -0.16861510f, -0.03771508f, 
    0.02605535f, 0.22176975f, 0.06365221f, -0.06725156f, 0.03682916f, 0.05108940f, 0.03389759f, 0.12985167f, 
    0.02800322f, 0.12195341f, -0.05015494f, -0.00610331f, 0.08341173f, 0.10159019f, 0.11726347f, 0.10824293f, 
    0.14092889f, -0.03172721f, -0.19288117f, 0.24396478f, 0.05008170f, -0.03027418f, 0.01213848f, 0.02692335f, 
    -0.08421911f, -0.07543752f, 0.20318045f, -0.10436130f, 0.04825835f, -0.06391340f, -0.04269525f, 0.18214628f, 
    -0.10188124f, 0.02189151f, 0.00166449f, -0.01997084f, -0.03539241f, -0.01977815f, 0.24355926f, -0.12222194f, 
    0.05046175f, -0.06279177f, -0.03409714f, -0.07712720f, 0.04678724f, -0.06458743f, 0.00182634f, 0.03002336f, 
    0.17207833f, -0.08180446f, -0.06674516f, 0.08708684f, -0.04997470f, 0.07321769f, 0.04191415f, -0.09727630f, 
    0.02215878f, -0.08813135f, -0.15773201f, -0.06636186f, 0.11592499f, 0.04235979f, -0.03992482f, 0.43182391f, 
    0.12801437f, 0.03541404f, -0.07604422f, -0.07592031f, 0.04184174f, -0.04144075f, -0.03692171f, -0.04994039f, 
    0.05180253f, 0.09840697f, 0.03996075f, 0.13058501f, -0.04821417f, -0.10360730f, -0.05374797f, -0.08116298f, 
    0.02451728f, -0.01875179f, -0.04270095f, -0.01711825f, 0.05434830f, -0.03034588f, 0.34887820f, 0.18825096f, 
    -0.12652689f, -0.03429645f, -0.06665728f, -0.07888415f, 0.02375379f, 0.00584712f, -0.01826233f, -0.09501751f, 
    0.02936335f, 0.27870369f, 0.29501846f, 0.10846422f, 0.02614374f, 0.07203092f, -0.05813944f, 0.10495658f, 
    0.04019793f, -0.11080544f, -0.08030810f, -0.03780192f, -0.29594317f, -0.07875220f, -0.26606837f, 0.24423678f, 
    0.13895357f, 0.00868301f, 0.13665210f, -0.01232014f, 0.21836583f, -0.10071553f, -0.08770718f, 0.12547892f, 
    -0.29791361f, 0.12076551f, 0.15893668f, 0.14051969f, 0.10468052f, 0.16704921f, 0.12519690f, 0.03176745f, 
    -0.08268674f, 0.02387762f, -0.02088255f, -0.05642611f, 0.18022045f, -0.16478118f, -0.13366537f, 0.17843346f, 
    -0.06811932f, -0.14964125f, -0.18269128f, -0.09999999f, 0.00939382f, 0.02479365f, 0.16795038f, -0.09734478f, 
    0.16765985f, -0.11256988f, 0.15322527f, -0.42136434f, -0.01832046f, -0.00033014f, -0.13296737f, 0.16653258f, 
    -0.03501563f, 0.23313501f, 0.16944259f, -0.05766478f, 0.15877457f, 0.18660006f, -0.11488315f, 0.04894782f, 
    0.08072652f, 0.17703985f, 0.16556963f, 0.13739249f, -0.04944022f, -0.07051022f, 0.17449754f, -0.09810790f, 
    -0.07685147f, -0.18154503f, -0.02180406f, -0.26434657f, -0.20869584f, -0.21720275f, 0.18060011f, -0.08792374f, 
    0.09246362f, -0.13467333f, -0.00024067f, 0.05885423f, 0.17390582f, 0.37512809f, 0.27760169f, -0.09348106f, 
    0.01788910f, 0.12203578f, 0.10731281f, -0.00486816f, 0.01528591f, -0.09809805f, -0.00661638f, -0.04563978f, 
    0.08073313f, 0.03306447f, 0.02463710f, -0.48990968f, -0.28701115f, 0.16323812f, -0.15003958f, -0.00618477f, 
    0.13854668f, 0.02911219f, -0.06975551f, -0.16927689f, 0.04770979f, 0.24356581f, 0.42813402f, 0.47257611f, 
    0.04163728f, 0.15650876f, -0.05687902f, -0.06707135f, 0.10451956f, -0.23699956f, 0.06893274f, 0.11339746f, 
    0.24094586f, 0.15042883f, 0.07077235f, 0.02989763f, -0.05566494f, 0.18026038f, -0.07268454f, -0.09000801f, 
    -0.10789403f, -0.13249390f, -0.01468866f, -0.04241236f, 0.08750096f, -0.09122132f, -0.18903813f, -0.07697426f, 
    0.14651088f, 0.09296498f, 0.04075737f, 0.18379487f, 0.01569272f, 0.08081981f, 0.08759212f, -0.17836273f, 
    0.07378031f, -0.11077933f, -0.20020817f, -0.28871018f, 0.00676326f, -0.13243160f, -0.06951056f, 0.08562177f, 
    0.09028017f, -0.06265046f, -0.11670849f, 0.04096652f, 0.10484311f, -0.01407690f, -0.07652646f, -0.11541298f, 
    -0.09655534f, 0.09221729f, -0.05970267f, 0.09818199f, 0.05082877f, 0.06183080f, -0.00962185f, 0.01487467f, 
    0.16063789f, 0.20524049f, 0.19804363f, 0.05639527f, 0.13706046f, 0.05650396f, -0.09268902f, 0.13349719f, 
    0.15562816f, 0.08110325f, -0.01332454f, 0.00136489f, 0.10605980f, 0.38346514f, 0.00322508f, -0.12693520f, 
    -0.06405710f, 0.19765420f, 0.11283508f, 0.21738845f, 0.01770486f, 0.01771725f, 0.04090789f, -0.13137040f, 
    -0.25338382f, -0.00092912f, 0.04780340f, 0.23498075f, 0.02996512f, -0.05497481f, 0.25881609f, -0.28130227f, 
    0.03032421f, 0.14445484f, -0.23062025f, -0.05615539f, 0.03945722f, -0.17143777f, 0.09276444f, 0.05395660f, 
    0.00795119f, -0.07687563f, 0.10286107f, -0.06737743f, -0.06028924f, -0.14088054f, 0.01005161f, 0.01330207f, 
    0.11807233f, -0.06314363f, -0.20725696f, 0.25547463f, 0.12064604f, 0.09024806f, 0.17881751f, 0.06307387f, 
    0.06814913f, -0.05018051f, 0.02486507f, -0.14216599f, -0.03426433f, -0.33583894f, 0.11545490f, -0.22946116f, 
    0.03908795f, -0.07358235f, 0.04172835f, 0.08578751f, -0.00135277f, 0.06836262f, 0.02831970f, 0.00348231f, 
    0.15088320f, -0.06103763f, 0.13769613f, 0.34565151f, 0.03177694f, -0.10281707f, -0.12429010f, -0.30201536f, 
    0.18637668f, -0.13784193f, -0.04424341f, 0.02818977f, -0.24370639f, 0.26411033f, 0.05860423f, -0.15165712f, 
    -0.02360859f, 0.16595961f, -0.08029969f, -0.04903091f, 0.10564455f, -0.09293687f, 0.19815257f, -0.00571586f, 
    -0.11288497f, -0.01898456f, 0.11307918f, -0.05203455f, 0.00207402f, -0.03195304f, -0.01438431f, -0.02106370f, 
    0.09974504f, 0.11877558f, 0.09064835f, 0.06060873f, -0.08951697f, -0.18727778f, 0.06038368f, -0.15656705f, 
    -0.12745227f, -0.04021922f, -0.10034198f, 0.01938337f, 0.17897317f, 0.08283125f, -0.04091148f, 0.01751008f, 
    0.05032073f, -0.07850403f, -0.03485728f, -0.05304384f, 0.00178478f, -0.12930414f, 0.01387079f, 0.07679291f, 
    0.17961177f, 0.00605406f, 0.04131774f, -0.23026054f, -0.09981415f, 0.16405475f, 0.04428709f, 0.11000381f, 
    0.09977636f, 0.00020705f, 0.05854113f, 0.12930419f, 0.14017841f, 0.14558353f, -0.00595595f, 0.06544604f, 
    0.03898163f, -0.04784765f, -0.01055266f, 0.20719220f, 0.17880554f, 0.03494841f, 0.02081277f, 0.05951348f, 
    -0.00245174f, -0.00631213f, -0.01100781f, 0.16881073f, -0.11642774f, -0.08027700f, 0.21740884f, 0.03280887f, 
    0.05587124f, -0.00837215f, 0.08128504f, 0.05214454f, -0.01453163f, 0.09155949f, 0.09286562f, 0.01287444f, 
    -0.04704851f, -0.07272234f, 0.00171163f, 0.23071575f, 0.00959860f, -0.05341222f, -0.10688405f, -0.06512193f, 
    0.13321583f, 0.06844874f, 0.00528179f, 0.22658813f, -0.04544012f, -0.01762279f, -0.07964642f, 0.11768742f, 
    0.03084280f, -0.11056273f, -0.07070090f, 0.01482488f, 0.04577673f, 0.06761011f, 0.17699079f, 0.10038993f, 
    0.01007485f, -0.11257144f, -0.06017679f, -0.14304173f, -0.07651053f, 0.05658746f, 0.09044277f, 0.11060631f, 
    -0.12402616f, -0.00711356f, -0.13940792f, -0.16854697f, -0.10572262f, -0.39666769f, 0.23567258f, 0.25932440f, 
    0.00668741f, -0.01796064f, -0.06677891f, 0.00972314f, 0.25654778f, -0.10825427f, 0.01894723f, -0.02456564f, 
    -0.03865547f, -0.02694730f, 0.22220574f, -0.05560810f, -0.09796442f, 0.00861580f, -0.04397834f, 0.10482962f, 
    0.18480437f, 0.03005761f, 0.03492324f, 0.03373608f, -0.19665471f, 0.15259831f, 0.02642144f, 0.08388781f, 
    0.02500701f, 0.01753789f, -0.14490582f, -0.03103203f, -0.14593272f, 0.05738066f, -0.00057241f, 0.03917737f, 
    -0.18623374f, -0.01103842f, 0.10864195f, -0.07375850f, 0.07348146f, -0.09794218f, 0.02911397f, 0.10208162f, 
    -0.05544874f, 0.02843754f, 0.05725300f, 0.07775817f, -0.10803157f, -0.03592345f, 0.16701926f, -0.02850581f, 
    -0.07365897f, -0.10923173f, -0.04705899f, -0.10885788f, 0.05265845f, 0.08629604f, 0.13854572f, 0.15453945f, 
    -0.00196023f, -0.11182935f, -0.04368221f, -0.02830921f, 0.05952156f, 0.05342126f, 0.06124430f, 0.23346098f, 
    -0.03085244f, 0.02350190f, 0.02396324f, 0.04284366f, -0.04747316f, 0.12517303f, -0.01951893f, -0.04044326f, 
    0.03398919f, 0.02624256f, -0.03346476f, -0.09233575f, -0.01383351f, 0.00582093f, 0.03690518f, 0.10418013f, 
    -0.49184036f, -0.05487983f, -0.03458391f, 0.05244947f, -0.07930845f, -0.09011617f, -0.02474560f, 0.05505997f, 
    0.07124843f, 0.28747311f, 0.08813336f, -0.05805108f, -0.16771941f, -0.10908260f, 0.02516430f, -0.21713653f, 
    0.07165814f, 0.00383544f, 0.05882242f, -0.17559621f, 0.05683606f, 0.00032894f, -0.01442360f, 0.02288590f, 
    -0.19151902f, -0.20514534f, 0.07897784f, 0.06978813f, -0.00104915f, 0.07261320f, 0.00785903f, 0.16688952f, 
    0.30410221f, 0.08695634f, 0.01397141f, 0.06551129f, 0.18226899f, -0.32808635f, -0.04916960f, 0.28019962f, 
    0.21722144f, -0.08561981f, 0.28775367f, 0.05134277f, 0.26593471f, 0.22873823f, 0.10034344f, 0.11944906f, 
    0.36102512f, -0.13332520f, 0.00661911f, 0.13085388f, 0.10115736f, 0.00499716f, 0.17230406f, 0.08610856f, 
    0.16715938f, -0.12149444f, 0.01091548f, 0.21187147f, 0.00158242f, -0.01311500f, -0.01464862f, -0.06879835f, 
    0.09273398f, -0.07835141f, 0.02420731f, -0.02372965f, -0.00500635f, 0.01982054f, -0.03125946f, -0.04631565f, 
    -0.00229240f, -0.06199158f, -0.15531398f, -0.12894449f, 0.09603676f, 0.12771121f, 0.01463761f, 0.04531644f, 
    0.12738609f, -0.01127762f, -0.02092067f, -0.11343909f, -0.03764952f, 0.07828893f, 0.16473272f, -0.04536576f, 
    -0.03917574f, 0.05136986f, -0.07619959f, 0.00599016f, 0.04997209f, -0.04077134f, 0.05634693f, 0.00269669f, 
    -0.06705526f, -0.16601951f, 0.06921899f, -0.12820266f, 0.13062225f, 0.06802291f, 0.06926353f, -0.06428071f, 
    0.15809181f, 0.04804096f, 0.00670549f, 0.01328536f, -0.15226212f, -0.01335809f, -0.05086454f, -0.09700374f, 
    0.14254633f, 0.14714274f, 0.22576845f, -0.04521789f, -0.00019812f, -0.09159775f, 0.00167129f, 0.02398805f, 
    0.07675385f, -0.17498991f, 0.05529928f, 0.14206478f, 0.22666001f, 0.01096137f, 0.04181337f, 0.01646678f, 
    0.10612243f, 0.13823113f, 0.11281519f, 0.03770440f, 0.11552926f, 0.15182707f, 0.08654510f, -0.09907229f, 
    0.00449675f, 0.11886752f, -0.13528742f, 0.10997383f, 0.02003523f, -0.20764388f, 0.08827720f, -0.00399714f, 
    -0.02853024f, 0.03825521f, 0.04195057f, 0.01603158f, 0.00904313f, 0.08823406f, -0.01024798f, -0.02668103f, 
    0.02413098f, -0.19900163f, -0.06245042f, -0.41539299f, 0.23644570f, 0.01907189f, -0.03824883f, -0.07263723f, 
    0.11450794f, -0.04803874f, 0.30433780f, 0.13801454f, 0.09146389f, -0.03263921f, -0.05249835f, 0.20522991f, 
    -0.07582042f, -0.22027272f, -0.02324832f, 0.10268617f, 0.07076278f, -0.08165609f, -0.06585173f, 0.02499112f, 
    0.00770235f, -0.03802372f, 0.03488809f, -0.04576885f, -0.48821160f, 0.19255610f, 0.15119679f, -0.28917986f, 
    0.12346604f, -0.00854888f, -0.11441499f, 0.19463088f, 0.17758204f, 0.06077074f, 0.08195125f, 0.18759137f, 
    -0.00115667f, -0.02518995f, -0.04834924f, 0.03139365f, -0.01734682f, -0.05579277f, -0.01360076f, 0.03688622f, 
    -0.01022236f, 0.02610628f, 0.01798499f, -0.04883988f, -0.01155477f, 0.03992162f, 0.01284004f, 0.00716953f, 
    0.00106467f, -0.05725289f, -0.02940531f, -0.03761581f, -0.04243716f, -0.03074026f, 0.02234195f, -0.02268973f, 
    -0.03309090f, -0.02018621f, -0.02067685f, -0.01408276f, -0.05222147f, -0.05468194f, 0.01372170f, 0.01849764f, 
    0.01063466f, -0.01966477f, -0.04814243f, -0.00274366f, -0.02340065f, -0.03153023f, -0.02338674f, 0.00044157f, 
    -0.01603441f, -0.03471172f, -0.05067746f, -0.03913225f, -0.01353811f, 0.01722688f, -0.05281206f, -0.03637901f, 
    -0.03997408f, 0.00231428f, 0.03122863f, 0.02197402f, -0.01309397f, 0.00247250f, -0.04615798f, -0.00348551f, 
    0.01249785f, 0.00162767f, 0.03390811f, 0.00131219f, -0.05372650f, -0.05715251f, 0.01414530f, 0.00826392f, 
    0.02510580f, 0.02702346f, 0.02115754f, -0.01941657f, -0.02100471f, -0.03244813f, -0.03462582f, -0.05040308f, 
    0.02416532f, 0.02237203f, -0.03429786f, -0.02634208f, 0.04330350f, -0.01768507f, -0.03324595f, 0.02082349f, 
    0.04380729f, 0.00084277f, 0.03090944f, -0.01178614f, -0.00696516f, -0.03437743f, -0.00890292f, -0.05440598f, 
    -0.01234193f, 0.03836975f, -0.03456990f, -0.04101387f, 0.03310331f, 0.03052899f, 0.03937902f, -0.03872110f, 
    0.04715018f, -0.05144908f, -0.01398241f, -0.01748028f, 0.01053895f, -0.03166730f, -0.05454320f, 0.00274243f, 
    -0.01548990f, 0.02260810f, -0.04457214f, 0.00168955f, -0.01079243f, -0.05169841f, -0.05659499f, 0.02452133f, 
    -0.03526919f, 0.00435894f, 0.04002536f, 0.03375383f, 0.02737159f, 0.02730793f, -0.00952682f, -0.04935296f, 
    -0.05621603f, 0.03780956f, 0.02510219f, 0.03130110f, -0.03145846f, -0.01799306f, -0.04649283f, -0.00979189f, 
    0.00052310f, 0.04206373f, -0.03496555f, 0.01573423f, -0.04516648f, -0.04795647f, -0.02149300f, -0.02963952f, 
    0.03078253f, 0.04203205f, -0.04121954f, 0.02432823f, -0.00371857f, 0.01287737f, -0.01169405f, 0.03513441f, 
    -0.01541818f, -0.00970132f, -0.00789547f, 0.00748070f, -0.05407199f, -0.03233646f, -0.05014953f, 0.00068419f, 
    -0.04267634f, 0.00503885f, -0.04794283f, 0.03419947f, -0.04773029f, 0.00776936f, -0.00012642f, 0.03833295f, 
    0.02781833f, 0.00645776f, 0.00913437f, 0.01938909f, 0.03718332f, -0.03537444f, -0.01622148f, -0.03989420f, 
    -0.04786761f, 0.01760937f, -0.03061966f, -0.03627598f, 0.03071242f, -0.01195306f, -0.02876758f, 0.01899462f, 
    -0.05690670f, 0.00847029f, 0.00201277f, -0.04923854f, -0.01892274f, 0.03670803f, 0.01878740f, -0.02888674f, 
    -0.00921531f, -0.05433251f, -0.05283643f, 0.02795568f, -0.02630870f, 0.01670211f, 0.02765013f, 0.01785143f, 
    -0.04195717f, -0.03537849f, -0.00025285f, 0.00129825f, 0.00062422f, -0.02291486f, 0.04249833f, -0.02951709f, 
    0.04210481f, -0.02383706f, -0.05352081f, -0.00853881f, 0.04228038f, 0.02831541f, -0.00226368f, 0.03868327f, 
    -0.02887777f, -0.03524378f, 0.02049012f, -0.04588417f, -0.03451502f, 0.00267308f, -0.03076985f, -0.03691459f, 
    0.03704257f, -0.00284544f, -0.04442000f, 0.00303032f, -0.05314828f, -0.04570747f, -0.01840700f, 0.01422730f, 
    -0.02849462f, -0.03512761f, 0.00010774f, -0.01760375f, -0.03509733f, -0.03144699f, 0.01547571f, -0.03797780f, 
    -0.04465120f, 0.03668409f, -0.03064194f, -0.03296008f, 0.01411646f, 0.02674596f, -0.05488239f, 0.00004122f, 
    -0.04978552f, -0.03836083f, -0.04052130f, -0.02455174f, 0.00983022f, -0.04581937f, -0.01286406f, 0.03457531f, 
    0.01484988f, 0.00940100f, 0.03674690f, -0.01500421f, -0.04124907f, -0.00972620f, -0.02496863f, -0.05022150f, 
    -0.03183695f, -0.00559064f, 0.00908178f, -0.05449160f, 0.00204788f, 0.03145218f, 0.00981055f, 0.03232463f, 
    -0.03640935f, 0.04152484f, -0.04248555f, -0.00817878f, -0.05750227f, -0.03986032f, 0.00941017f, 0.01748725f, 
    -0.01914197f, -0.05218931f, 0.00878801f, -0.01521019f, 0.02582646f, -0.05010206f, 0.03273296f, -0.01036336f, 
    -0.05701622f, 0.01438538f, -0.02289146f, 0.01504730f, 0.00899991f, 0.04251515f, 0.03679146f, 0.04349849f, 
    -0.04693074f, 0.03969198f, 0.02158808f, -0.02974551f, -0.00380191f, -0.01943950f, -0.04339727f, -0.04841648f, 
    -0.04840051f, 0.00296907f, -0.04390082f, -0.02132233f, -0.01640998f, 0.01971104f, -0.01302131f, -0.02210308f, 
    0.00706246f, -0.03444031f, 0.01530678f, 0.01506272f, 0.00768080f, -0.05341988f, -0.01666863f, -0.02710719f, 
    0.00001463f, -0.04436923f, 0.03284672f, -0.03884128f, -0.03847269f, -0.05716462f, -0.01195175f, -0.00073739f, 
    -0.04419066f, 0.00039636f, -0.05091301f, -0.03895159f, 0.01186404f, -0.02081189f, -0.03118055f, 0.03493050f, 
    0.01604000f, -0.01407271f, -0.02828309f, 0.03120620f, -0.02574281f, -0.05165736f, -0.03942867f, 0.01851273f, 
    0.01477067f, 0.02613918f, 0.03198644f, 0.00745470f, 0.00589797f, -0.04210220f, -0.01678626f, 0.02031287f, 
    -0.03164018f, 0.02695856f, 0.02670335f, 0.02192649f, 0.03607210f, -0.05931243f, -0.02245081f, -0.02193813f, 
    0.03362131f, -0.05069811f, 0.03974275f, -0.00826712f, 0.04244467f, -0.01391634f, -0.01475408f, -0.03398819f, 
    -0.02279341f, -0.02734808f, -0.04051287f, 0.02210357f, 0.03627161f, -0.02400695f, -0.04202912f, 0.01675564f, 
    -0.02985548f, -0.01567242f, 0.04266870f, 0.00467230f, -0.04471093f, -0.03602379f, -0.05490273f, 0.01680763f, 
    0.02260957f, -0.00842269f, -0.01394790f, 0.03888681f, 0.00751915f, 0.03420755f, 0.04323280f, 0.03732105f, 
    0.16026175f, 0.18544468f, -0.11136531f, -0.33662212f, -0.01493718f, -0.05604236f, 0.05085406f, -0.07569450f, 
    -0.00140602f, 0.03182463f, 0.03183570f, -0.05935327f, 0.04407268f, 0.00392534f, 0.01108565f, -0.03528201f, 
    0.04961323f, 0.07086539f, 0.03486075f, -0.03124633f, -0.11122656f, 0.09323964f, -0.05298981f, -0.06379681f, 
    0.20141245f, 0.22602560f, 0.16262248f, -0.27949244f, 0.13653077f, 0.09853049f, -0.07385728f, -0.10180651f, 
    0.01251353f, 0.03473740f, 0.05392558f, -0.14198019f, 0.28014973f, 0.13198285f, -0.17492837f, -0.06226426f, 
    0.17028692f, 0.02122868f, 0.10005116f, -0.01667922f, 0.16626580f, 0.03220025f, 0.02732391f, 0.02204071f, 
    0.15331095f, 0.03774360f, -0.09893360f, 0.01121412f, 0.12260689f, 0.11233127f, 0.04353140f, 0.08464453f, 
    -0.01345032f, 0.07162540f, -0.05903694f, 0.08664805f, -0.06922319f, 0.20871182f, 0.01891353f, -0.03608798f, 
    0.06295267f, 0.15933666f, -0.05270892f, -0.12746117f, -0.28331661f, -0.18843679f, 0.11787945f, 0.07474776f, 
    -0.07028659f, 0.13588017f, 0.03572759f, 0.03281044f, 0.13728984f, 0.07479012f, -0.01754509f, -0.02679911f, 
    0.07431738f, -0.06641089f, -0.00085811f, 0.05357969f, -0.06900274f, 0.02247404f, 0.08798729f, 0.11401383f, 
    -0.05837180f, 0.00707293f, -0.04099506f, 0.03991587f, 0.14258409f, 0.11519674f, 0.04676884f, 0.17191787f, 
    -0.16325292f, -0.08997046f, 0.05458227f, -0.19237910f, 0.06144278f, -0.00192415f, 0.03385676f, 0.07141811f, 
    -0.11990017f, -0.01873869f, -0.09444983f, 0.07033560f, 0.11486588f, 0.14426084f, 0.09531562f, 0.35016721f, 
    -0.00278531f, 0.05613463f, 0.11164211f, -0.04697645f, -0.06383970f, -0.10379688f, -0.05455742f, -0.10308378f, 
    0.09993972f, 0.10041497f, 0.01150183f, -0.15661114f, 0.08511337f, 0.03858647f, 0.03208753f, 0.02667565f, 
    -0.09951878f, 0.04516840f, 0.14771818f, -0.05364063f, -0.06413440f, -0.01276236f, 0.34759676f, 0.18694949f, 
    -0.04685543f, -0.06637884f, -0.08152134f, 0.02533983f, -0.11661234f, 0.01219159f, -0.01602343f, 0.02127378f, 
    -0.13713561f, 0.14785703f, 0.20501681f, -0.24268942f, 0.08489183f, -0.08125243f, -0.00404007f, 0.08152467f, 
    -0.02761962f, -0.04316391f, 0.00630308f, -0.02909773f, 0.04596733f, 0.01416543f, 0.07837581f, 0.13309619f, 
    -0.05582792f, 0.02230266f, 0.02352160f, -0.03146298f, 0.06296973f, 0.09627878f, 0.05123724f, 0.06960909f, 
    -0.08353473f, 0.12247054f, -0.00367676f, -0.07125048f, 0.05406465f, -0.00020516f, 0.00953632f, 0.12642513f, 
    -0.02818514f, -0.03201921f, -0.04806838f, 0.00858486f, 0.02038241f, 0.13074975f, -0.00044703f, -0.21881424f, 
    0.02564686f, 0.10554176f, 0.05993034f, -0.11844628f, -0.08878523f, 0.00041471f, -0.07341122f, -0.03890914f, 
    -0.41760156f, -0.17090499f, 0.01062275f, -0.25861409f, -0.01625117f, 0.06031962f, 0.00900284f, 0.06369063f, 
    0.06501117f, 0.16829662f, -0.11597157f, -0.09418475f, 0.07026999f, 0.03221012f, -0.02271629f, -0.35982847f, 
    0.04040791f, -0.03507079f, 0.12184837f, -0.06140660f, -0.03729411f, 0.01517910f, 0.06972466f, -0.00413524f, 
    0.22502682f, -0.01450943f, -0.10712844f, -0.32913288f, -0.04350402f, 0.05274824f, -0.02294243f, 0.16858590f, 
    0.07163287f, 0.12918600f, -0.12385293f, -0.06634346f, -0.14887804f, 0.15001987f, 0.11048453f, -0.02971764f, 
    0.24258561f, 0.03202455f, 0.03290270f, 0.03647992f, 0.15859227f, -0.01493844f, 0.14612788f, 0.03836682f, 
    0.01076524f, 0.04060588f, 0.05815809f, -0.05046567f, 0.12718104f, -0.15664656f, -0.12454996f, -0.21839075f, 
    0.16847196f, -0.10167710f, 0.08489829f, -0.01549718f, 0.10788728f, 0.05106841f, -0.00189499f, 0.00234257f, 
    0.08761983f, -0.11370358f, -0.07168812f, 0.05398225f, 0.01041193f, -0.00594989f, 0.06004512f, -0.01321437f, 
    0.10717252f, -0.03663478f, -0.15205181f, -0.22484460f, 0.04074918f, 0.11500067f, -0.08533076f, -0.00625472f, 
    -0.04358357f, -0.02419174f, 0.01010493f, -0.07621375f, 0.10524461f, 0.10652332f, 0.08781882f, 0.17171347f, 
    -0.05698244f, 0.08152419f, 0.08779428f, 0.09111276f, 0.00270973f, 0.04234432f, 0.09634405f, -0.02372369f, 
    0.21472695f, 0.11224195f, -0.06822247f, -0.16730404f, 0.00790286f, 0.06734259f, 0.06177888f, 0.02408765f, 
    -0.01493031f, -0.06369612f, -0.04476422f, -0.06191491f, 0.09861227f, 0.07143014f, -0.13876003f, -0.18194014f, 
    0.06372507f, 0.16224016f, 0.14321920f, 0.01832180f, -0.19210340f, -0.11319655f, 0.03000229f, -0.09859086f, 
    -0.01019602f, 0.05478893f, 0.18011425f, 0.11104441f, 0.16419180f, 0.16029204f, 0.11812641f, 0.07869740f, 
    0.01201045f, -0.06654484f, -0.05275918f, 0.17917749f, 0.12077975f, -0.06894588f, 0.04367052f, 0.23574162f, 
    -0.01799309f, 0.16976255f, -0.01885006f, -0.00134099f, -0.12416624f, 0.11803700f, 0.15975463f, 0.11545783f, 
    -0.21983357f, -0.02324190f, -0.06424634f, 0.00491360f, -0.05891708f, -0.08362690f, 0.00050929f, 0.09829728f, 
    0.02859136f, 0.17081881f, -0.02415707f, -0.00174262f, 0.46453926f, -0.15871045f, -0.24711929f, 0.03845898f, 
    0.16108528f, 0.05129486f, 0.26663691f, 0.01902039f, -0.02191337f, 0.01788547f, -0.07341563f, -0.11926059f, 
    -0.14880151f, 0.02136609f, 0.01510498f, 0.03971864f, -0.05426363f, 0.03649353f, -0.04655335f, -0.02831141f, 
    -0.07069229f, 0.08836181f, 0.08535398f, 0.01253889f, -0.43944153f, 0.21629147f, -0.04925527f, 0.17792322f, 
    -0.11420463f, 0.29518726f, -0.09233589f, 0.02224044f, 0.09991969f, -0.05627402f, -0.05826704f, 0.21528144f, 
    -0.02550761f, -0.02673055f, 0.02976923f, 0.01278903f, -0.03311833f, -0.00671403f, -0.04447320f, -0.01270306f, 
    -0.05472374f, 0.03169758f, 0.03356310f, -0.03986663f, 0.02345225f, -0.00093501f, -0.03431470f, 0.01541524f, 
    -0.01035877f, 0.03821738f, 0.01701819f, -0.05422516f, -0.00049342f, -0.00615710f, -0.04254119f, -0.01476085f, 
    0.02927024f, 0.04316772f, -0.02295047f, -0.03285028f, -0.02873346f, 0.04059913f, 0.01364280f, -0.02871427f, 
    0.00007841f, -0.05670167f, -0.02671165f, 0.02209113f, -0.01790029f, -0.00575342f, 0.03008013f, 0.04191799f, 
    -0.00472329f, 0.02681045f, 0.01364193f, -0.04758692f, 0.01776354f, 0.02268476f, -0.03493747f, 0.01408502f, 
    -0.04401610f, 0.00861698f, 0.03294115f, 0.03475899f, 0.04638448f, -0.02299959f, -0.01982156f, 0.02746169f, 
    -0.04371987f, -0.05249364f, -0.04813718f, -0.02887345f, 0.01253202f, -0.03706732f, -0.04513004f, 0.01740494f, 
    0.03824420f, 0.03184719f, 0.04603451f, -0.03894451f, -0.02137561f, -0.01363287f, -0.04546054f, -0.02825374f, 
    -0.05345267f, 0.03945581f, -0.03339554f, 0.01645304f, 0.00332230f, 0.02814418f, -0.02555333f, -0.02800588f, 
    -0.00558869f, -0.02548977f, -0.01791292f, -0.03514848f, 0.01726994f, -0.01819478f, 0.00354802f, 0.00698291f, 
    -0.03454699f, 0.03716705f, -0.01782208f, -0.04941186f, 0.03852436f, -0.04743153f, -0.04933368f, -0.03962508f, 
    -0.01783138f, -0.01543494f, -0.04210125f, 0.01072991f, 0.02917487f, -0.04366599f, -0.03916344f, 0.03401639f, 
    -0.02702423f, -0.04390431f, -0.03672986f, -0.00163798f, -0.00519953f, -0.00259397f, -0.02983815f, 0.03803719f, 
    0.03340045f, 0.00045078f, -0.03019755f, -0.00614747f, 0.03732656f, -0.05418769f, 0.00093093f, -0.04670942f, 
    -0.02372573f, 0.03602714f, -0.04592290f, 0.02406580f, 0.01921011f, -0.00713015f, 0.00229136f, -0.02667943f, 
    -0.03105468f, -0.05772254f, -0.03928484f, 0.02673239f, 0.03171133f, -0.01241563f, -0.04656269f, -0.01283471f, 
    0.02988312f, -0.02667083f, -0.00375551f, -0.03116871f, -0.02880293f, 0.01600035f, -0.00089910f, 0.00320234f, 
    -0.02171466f, 0.03865533f, -0.00204652f, 0.02752512f, 0.01537439f, 0.02817322f, -0.03223215f, 0.02234432f, 
    -0.04612540f, 0.02322846f, 0.00175016f, 0.01147710f, 0.00198151f, -0.00125240f, -0.03875843f, -0.05321063f, 
    -0.03759705f, 0.00233631f, -0.00635818f, 0.00288978f, 0.02974025f, 0.02939984f, -0.03841601f, 0.03328221f, 
    0.00149851f, -0.03967965f, -0.02818781f, 0.01877322f, -0.03366134f, -0.01476682f, 0.02927488f, 0.02864539f, 
    0.02044836f, 0.01682157f, -0.03641302f, -0.02699902f, 0.03030491f, -0.01970055f, 0.04181981f, -0.03084238f, 
    0.04110501f, -0.03643432f, -0.04675715f, -0.04170849f, -0.02041865f, -0.05107222f, -0.03917423f, -0.01138069f, 
    0.01653059f, 0.00099731f, 0.03400381f, 0.00418434f, -0.04784006f, -0.04824784f, -0.00698424f, -0.03360075f, 
    -0.02108161f, 0.00095667f, 0.00552879f, 0.00183971f, -0.02981621f, -0.03441293f, -0.03374775f, -0.00978611f, 
    -0.01521362f, -0.03491791f, 0.04085909f, 0.02502324f, 0.02095990f, 0.00712082f, -0.05593933f, 0.00098029f, 
    -0.01672998f, 0.04490945f, -0.00972320f, 0.01859215f, 0.01684873f, -0.01907722f, 0.01140462f, -0.00613000f, 
    0.00699768f, 0.02458165f, 0.00634743f, -0.00180523f, -0.01323616f, 0.04224517f, 0.03478223f, -0.03538642f, 
    -0.00820060f, 0.03682021f, 0.01357728f, -0.03363731f, -0.05263226f, 0.02371813f, 0.02584208f, -0.03594063f, 
    0.01343272f, -0.00110845f, -0.02511218f, 0.02397610f, 0.00995968f, -0.00062509f, -0.00970717f, -0.05398007f, 
    0.02708222f, 0.00921617f, 0.03151900f, 0.01975244f, -0.03532529f, 0.01502637f, -0.04309790f, 0.00438707f, 
    -0.03371381f, 0.01429541f, -0.01148681f, 0.00542866f, -0.03357473f, -0.02482880f, 0.02304226f, 0.03408163f, 
    0.03541747f, -0.00305403f, 0.02785319f, 0.01670262f, -0.00148364f, 0.02649865f, 0.03047758f, 0.04409100f, 
    0.02241459f, -0.05074463f, 0.02964407f, -0.02238292f, 0.00801454f, -0.06136597f, -0.01294361f, 0.00594434f, 
    -0.00686205f, -0.03265722f, -0.04521045f, -0.02984839f, -0.04830640f, -0.05604070f, 0.04372952f, -0.02042326f, 
    0.02002822f, -0.00846987f, -0.04324114f, 0.01745055f, -0.02750012f, -0.01816324f, -0.01491127f, 0.02611971f, 
    -0.05611429f, 0.04133973f, -0.00505683f, -0.03973312f, 0.03283158f, -0.01892771f, -0.03742816f, 0.03581508f, 
    0.00623319f, 0.02222345f, -0.03306855f, -0.01167553f, -0.00976741f, -0.03921666f, 0.00162795f, 0.03653119f, 
    -0.02927834f, 0.00314701f, -0.03596115f, 0.00128059f, 0.03839534f, 0.00940811f, 0.03856335f, -0.03372611f, 
    0.03698643f, -0.04610427f, -0.03907434f, -0.00140583f, -0.03041068f, -0.01949520f, 0.03751568f, 0.00968535f, 
    -0.01771452f, 0.02753341f, 0.01819107f, -0.01231389f, -0.04604954f, -0.00848907f, -0.00855391f, -0.02140498f, 
    0.00392524f, -0.01556667f, -0.04263324f, -0.04652672f, -0.04823048f, -0.05025102f, -0.02307355f, 0.02150758f, 
    -0.01453358f, -0.05291611f, -0.01470684f, -0.04484497f, 0.03312293f, 0.00135468f, -0.03132099f, 0.02792911f, 
    -0.01952644f, -0.02234142f, -0.04615818f, 0.01545550f, -0.04308395f, -0.00576235f, -0.00484004f, -0.03243175f, 
    -0.01692645f, -0.00662523f, -0.01302817f, 0.00381391f, -0.05580508f, 0.01658045f, -0.01571235f, -0.02913174f, 
    0.03764383f, -0.02319624f, 0.03588853f, 0.03210333f, -0.04393436f, 0.03449526f, -0.02645645f, 0.00727654f, 
    0.03357502f, -0.03495032f, -0.03343527f, 0.00461193f, -0.02928527f, 0.01305452f, -0.03725472f, 0.02698186f, 
    -0.11983487f, -0.07426215f, 0.12566215f, 0.06092855f, -0.03222145f, -0.05266426f, -0.04414500f, 0.02323005f, 
    0.01229803f, -0.02661694f, 0.01035844f, -0.01078743f, 0.04089699f, -0.15702324f, 0.11336066f, -0.17078941f, 
    0.05038010f, 0.01423982f, -0.03031150f, 0.08641534f, 0.06357659f, -0.02231768f, -0.06496554f, 0.06372564f, 
    -0.12921616f, 0.07584444f, -0.00069705f, -0.02784031f, -0.04961006f, -0.13606338f, 0.09669500f, 0.07650275f, 
    0.07285844f, -0.00761253f, 0.11830288f, 0.06712030f, 0.02101707f, -0.08972138f, 0.10315327f, 0.04929253f, 
    -0.08878649f, 0.01383457f, -0.10325815f, 0.07273184f, 0.13734056f, 0.00821296f, 0.11526532f, 0.06304555f, 
    -0.04004049f, 0.02294296f, 0.35184470f, -0.26233071f, 0.19840656f, 0.02274702f, -0.02167261f, 0.12576932f, 
    -0.01968743f, 0.06460328f, 0.12195673f, -0.03144804f, 0.21269304f, -0.04814641f, 0.17006961f, 0.21270727f, 
    0.02139192f, -0.03913712f, 0.00496613f, 0.18281427f, 0.10442962f, 0.07660093f, -0.04498681f, -0.02814832f, 
    0.33619031f, -0.09595620f, -0.02634652f, 0.11900800f, 0.03939080f, -0.13403094f, 0.01437352f, 0.06686488f, 
    -0.05289463f, 0.09504244f, 0.01288797f, -0.04241660f, 0.01657400f, 0.01459922f, -0.13533561f, 0.18102303f, 
    0.02573273f, -0.01805514f, 0.00899230f, -0.07710497f, 0.04052517f, 0.05942725f, 0.03177271f, 0.03725805f, 
    0.04146795f, 0.10424133f, 0.13012484f, 0.06522540f, 0.03156377f, -0.08082777f, -0.01226600f, -0.10829993f, 
    0.01892180f, 0.01775993f, 0.05608591f, 0.11534391f, 0.13385306f, -0.41706246f, 0.02339448f, 0.17990489f, 
    -0.06653059f, -0.04194773f, -0.02433279f, -0.16027093f, 0.07629889f, 0.05808976f, 0.09905667f, -0.00444135f, 
    -0.01491802f, -0.01175169f, 0.12515239f, -0.01733185f, 0.04559285f, 0.04835169f, -0.01489705f, 0.05888386f, 
    0.07199728f, 0.07178186f, 0.10670000f, 0.11853860f, -0.17650639f, 0.11641051f, -0.07275330f, 0.07242916f, 
    0.09525282f, 0.05439804f, 0.09438102f, -0.09664150f, 0.08604352f, -0.06577446f, -0.04018993f, 0.05951567f, 
    -0.29774821f, 0.00532031f, -0.11120612f, 0.20180710f, 0.16811934f, -0.03754962f, 0.12743188f, -0.10934207f, 
    0.02750961f, -0.03326791f, 0.06535634f, -0.00452592f, -0.03448847f, -0.12032772f, 0.03034285f, -0.00129750f, 
    -0.00311670f, -0.03018561f, -0.00904632f, -0.08478639f, -0.07220327f, 0.08953090f, 0.06816730f, 0.11956111f, 
    0.10335691f, -0.07382822f, -0.00114319f, 0.04932073f, 0.00977136f, -0.10360229f, 0.10192770f, 0.02371308f, 
    0.06077524f, -0.07635574f, -0.06381341f, 0.05969549f, -0.21013939f, 0.17131680f, 0.02455233f, -0.03883633f, 
    0.05357107f, 0.04636372f, -0.07071542f, 0.10172562f, 0.06785714f, -0.12420820f, -0.00190204f, -0.09557515f, 
    -0.32505676f, 0.17372012f, -0.04343402f, -0.01883733f, 0.03815508f, -0.03400114f, 0.08124139f, -0.00116562f, 
    0.02812446f, -0.09945202f, 0.01109048f, 0.02848700f, 0.06992660f, 0.04771618f, 0.21763395f, 0.02749950f, 
    -0.14461315f, 0.03856951f, 0.03627591f, 0.03740324f, 0.05943434f, -0.01121312f, -0.05618954f, -0.07481640f, 
    0.10994698f, 0.18249707f, 0.03874020f, -0.05592866f, -0.02132867f, 0.05824521f, -0.00274453f, 0.09676022f, 
    0.05748009f, -0.03762942f, -0.02993274f, 0.02402328f, 0.23196565f, -0.13297936f, 0.10967223f, 0.36447772f, 
    0.14571512f, -0.07918911f, 0.08844394f, -0.18697831f, 0.16087016f, -0.07450518f, 0.05458729f, 0.00997317f, 
    0.24982971f, -0.18494281f, 0.27953732f, 0.12581965f, 0.04314660f, -0.00349942f, -0.04061921f, 0.00728449f, 
    0.00281264f, -0.01629973f, -0.04773894f, 0.01522904f, 0.04345856f, -0.09736783f, 0.01075037f, -0.08352043f, 
    0.15350489f, 0.11081101f, 0.09988233f, 0.16182366f, 0.02865846f, 0.08042463f, -0.06311391f, 0.00617910f, 
    -0.03132457f, -0.04181663f, -0.07236452f, -0.18532054f, -0.04322072f, -0.04098019f, 0.07824115f, 0.10893109f, 
    -0.07460681f, -0.00156672f, 0.03146861f, 0.03941628f, -0.09358790f, -0.10561318f, 0.04725718f, -0.36594719f, 
    -0.01486677f, 0.08584493f, 0.02634662f, 0.00309973f, -0.05992569f, 0.01294766f, 0.06252849f, 0.13455580f, 
    -0.02633217f, -0.14653610f, 0.24508914f, -0.08940745f, -0.02834656f, -0.13401009f, 0.02598942f, 0.04922694f, 
    0.03027232f, 0.05480104f, 0.01944437f, -0.03970754f, 0.01858780f, 0.08391250f, 0.19972177f, -0.09979708f, 
    -0.10294979f, -0.06517054f, -0.01597534f, 0.02965701f, 0.04005468f, -0.12457508f, -0.05157936f, -0.06792544f, 
    0.12807857f, -0.14794494f, -0.15833925f, 0.24679106f, 0.33968458f, 0.11341815f, 0.28903970f, -0.21905668f, 
    0.04144396f, -0.05586273f, 0.02418005f, 0.00685035f, 0.12748741f, -0.18282874f, 0.07003243f, -0.26379967f, 
    0.02492447f, 0.10225391f, 0.11420580f, 0.04282669f, 0.08301400f, -0.10003655f, 0.05920838f, 0.12439863f, 
    -0.15087695f, 0.04274506f, -0.13617042f, -0.01828432f, 0.08936094f, -0.08749499f, 0.02214380f, -0.00439662f, 
    0.08456086f, -0.03578768f, 0.13491903f, 0.03517345f, -0.19995503f, -0.57185698f, 0.35241619f, -0.12738092f, 
    0.13483690f, 0.10360257f, 0.04638167f, 0.13821389f, -0.00539051f, 0.03021085f, 0.13194981f, 0.01675894f, 
    0.18768513f, -0.17436874f, 0.03228288f, 0.39278191f, 0.05873513f, -0.12834923f, -0.10798528f, -0.18938309f, 
    0.28271484f, -0.00026550f, 0.12903959f, 0.03826085f, -0.27174854f, -0.04704889f, -0.13619417f, -0.00900002f, 
    -0.10219657f, 0.18800904f, -0.04857178f, 0.03247661f, 0.07283194f, 0.05305966f, 0.04417693f, -0.12649126f, 
    -0.02870117f, -0.00239080f, -0.02314368f, 0.03267664f, -0.01965553f, -0.04973394f, 0.00306989f, 0.02817616f, 
    -0.01219826f, 0.02185224f, -0.05067962f, -0.04309476f, -0.02429108f, -0.05187426f, -0.00713415f, -0.02268714f, 
    -0.01431355f, 0.00587309f, -0.02410608f, 0.04398322f, -0.03241891f, 0.03406380f, -0.03418753f, -0.01842378f, 
    -0.04419277f, -0.01220574f, 0.03090512f, -0.00309440f, 0.01202767f, -0.02768791f, -0.01194931f, -0.00579862f, 
    -0.00564150f, -0.01769937f, -0.03333799f, -0.01357803f, -0.00042989f, -0.05186134f, -0.05206258f, 0.04128315f, 
    0.03366374f, 0.02222241f, -0.04155786f, -0.00950102f, 0.01217220f, -0.01298395f, 0.00280000f, -0.04578960f, 
    0.01176693f, -0.03032086f, -0.05199036f, 0.03614157f, -0.01910834f, 0.01157293f, -0.05017767f, 0.03972305f, 
    -0.00335466f, -0.03767454f, 0.01585386f, -0.03695921f, 0.04915779f, 0.01604548f, -0.01120074f, -0.03408017f, 
    -0.02409705f, 0.02288913f, -0.03563965f, 0.01929472f, -0.02261219f, -0.04576023f, 0.02619625f, -0.02620206f, 
    -0.01307225f, 0.02346305f, 0.03934726f, -0.05736445f, -0.05288008f, 0.00323976f, -0.03603356f, 0.00476955f, 
    0.04280173f, 0.03557871f, 0.01030455f, -0.01376038f, -0.04389696f, 0.00023029f, -0.00964678f, -0.00838631f, 
    0.00301838f, 0.02046112f, 0.04214019f, 0.00168350f, 0.00512863f, -0.00984076f, -0.05821738f, 0.03998619f, 
    -0.01652651f, 0.04048839f, -0.02243613f, -0.05838279f, 0.03366099f, -0.01513393f, -0.00458557f, 0.03941037f, 
    0.00282997f, -0.03473246f, 0.02302890f, -0.02048092f, 0.00608077f, 0.03889536f, 0.00796252f, 0.02322295f, 
    -0.03092478f, 0.02399944f, -0.04227468f, -0.00489748f, 0.03210152f, 0.01269495f, 0.03904768f, -0.03595486f, 
    0.01901200f, 0.02412799f, -0.04279108f, -0.03176665f, 0.02397503f, -0.00520967f, 0.00098679f, -0.00985505f, 
    0.01362773f, -0.00913373f, 0.03095195f, 0.01739928f, 0.01211863f, 0.03018846f, 0.01019502f, -0.03751587f, 
    -0.04241074f, -0.00305624f, 0.00787346f, 0.02066100f, 0.01438095f, -0.01154625f, 0.01958939f, 0.03228941f, 
    -0.01799800f, -0.02078430f, -0.04231328f, -0.00127823f, -0.00369328f, -0.05118880f, 0.02563755f, 0.03839726f, 
    -0.00347100f, -0.03675842f, -0.01625743f, 0.01102521f, -0.04576174f, 0.03881616f, -0.03113453f, -0.05237124f, 
    0.00770347f, -0.00615822f, -0.01320195f, 0.01760671f, 0.01139513f, 0.04421930f, -0.05090682f, -0.02732578f, 
    0.04760373f, 0.01396240f, 0.04446083f, 0.02217240f, -0.01272941f, -0.02454384f, -0.04923223f, 0.00816125f, 
    -0.04031337f, 0.01095022f, 0.01257835f, -0.05118260f, -0.00954234f, -0.04180892f, -0.02408584f, 0.01614709f, 
    -0.03861620f, 0.02184346f, -0.00259675f, -0.01520224f, 0.01166349f, 0.00796561f, 0.00583497f, -0.00989845f, 
    -0.01415697f, -0.03775579f, 0.02857626f, -0.05416649f, -0.02858441f, -0.01012688f, 0.03443581f, -0.01818857f, 
    0.02171456f, 0.02862946f, 0.03869031f, 0.03386791f, 0.03586566f, -0.03357339f, -0.05582905f, 0.01981351f, 
    -0.03678748f, -0.01060845f, -0.04358817f, 0.00381097f, 0.03219065f, 0.02563372f, -0.03845901f, -0.03198698f, 
    0.03703594f, 0.01755511f, -0.04219478f, -0.00119615f, 0.03351114f, 0.01802731f, -0.05960654f, -0.02345169f, 
    0.00687122f, 0.04448058f, 0.03420833f, -0.00430673f, 0.00037875f, 0.03637706f, -0.05049349f, -0.02067697f, 
    -0.04681476f, -0.03965307f, 0.04080999f, -0.05373371f, 0.04546645f, 0.01792298f, 0.02255022f, -0.03121949f, 
    0.00127602f, 0.00273045f, 0.02115086f, -0.02740294f, -0.02598135f, -0.01373947f, 0.02428056f, 0.03639220f, 
    0.00895053f, 0.03035812f, -0.03528286f, -0.02051649f, -0.04265134f, 0.04749571f, 0.04400136f, 0.01952951f, 
    0.02117157f, -0.01768574f, -0.03967504f, 0.02134509f, 0.04258490f, 0.00508045f, -0.03480826f, -0.05384735f, 
    -0.04295141f, -0.05501301f, 0.03280095f, -0.00622082f, -0.00261250f, -0.03774254f, 0.04204149f, 0.02320723f, 
    0.00627739f, 0.01439118f, -0.03907949f, -0.02929361f, -0.01469734f, -0.03882236f, 0.01058207f, -0.03657514f, 
    -0.04307305f, 0.02721528f, -0.03563637f, -0.05385898f, -0.02566523f, 0.03669567f, 0.01120143f, -0.04849538f, 
    -0.00382120f, 0.00545102f, -0.01791623f, 0.02276638f, -0.04534897f, 0.01295180f, -0.05190077f, 0.02964067f, 
    -0.04216653f, -0.04516210f, 0.02578223f, -0.00841690f, -0.00763552f, -0.03646209f, 0.00100253f, -0.00460399f, 
    0.04258715f, 0.03493666f, 0.03887185f, 0.00788511f, 0.02820641f, 0.03752587f, -0.04086792f, 0.03864757f, 
    -0.00654708f, -0.03608528f, 0.01586559f, -0.02906643f, 0.01140636f, -0.02516680f, 0.02230132f, 0.01662416f, 
    -0.03185229f, -0.00618366f, 0.03840216f, -0.02731050f, -0.04611704f, -0.05043498f, 0.01769947f, -0.04332075f, 
    -0.05131598f, 0.00658803f, -0.04132983f, 0.01706548f, 0.02806176f, 0.01484618f, -0.01385000f, 0.03222841f, 
    0.02755643f, -0.04108209f, -0.04003060f, 0.00064853f, 0.02858653f, -0.03289410f, 0.01009309f, -0.00952195f, 
    -0.02594199f, -0.01233803f, 0.02883809f, -0.04360114f, 0.03869927f, -0.04887453f, -0.03764958f, -0.02512627f, 
    0.02426452f, -0.01910168f, 0.02434674f, -0.01338106f, -0.04658492f, -0.03929706f, -0.03471612f, 0.01458936f, 
    0.03830058f, 0.02392936f, 0.02991653f, 0.01329070f, 0.02303072f, 0.01552686f, -0.04682807f, 0.01477358f, 
    -0.00913306f, -0.05669978f, 0.02757411f, 0.00706235f, -0.03065188f, 0.03969068f, -0.03839716f, -0.03846838f, 
    -0.03336896f, -0.00055879f, 0.02344344f, 0.03151034f, -0.05107070f, -0.00504302f, 0.00356584f, 0.02641808f, 
    0.12978739f, 0.04097196f, -0.07153116f, -0.01371999f, 0.00698560f, 0.18621762f, 0.15506408f, 0.03720576f, 
    0.03859423f, 0.07534571f, 0.07097449f, 0.04566417f, 0.15623771f, 0.17819087f, 0.13910829f, 0.01877870f, 
    0.02955632f, -0.15390642f, -0.08753277f, 0.00081019f, 0.01844252f, -0.02471732f, -0.01822020f, -0.02420898f, 
    -0.10296630f, 0.04784442f, -0.03992051f, 0.01289703f, 0.01469919f, 0.03856822f, -0.04119950f, -0.00716094f, 
    0.01889038f, -0.04279469f, 0.09038866f, 0.07407417f, -0.08860628f, -0.08621482f, -0.08461042f, -0.08186691f, 
    -0.08056740f, -0.07010356f, -0.01813099f, -0.08798804f, -0.06266817f, 0.01184685f, 0.03059945f, 0.04095269f, 
    0.01931009f, -0.05559444f, -0.00609315f, -0.33693025f, 0.12764458f, -0.08125078f, 0.02881232f, 0.03707506f, 
    0.05217367f, -0.02548540f, -0.08336788f, -0.08559565f, 0.22061625f, -0.05152867f, 0.06212087f, 0.13735726f, 
    -0.00230825f, -0.09855159f, 0.00304277f, -0.06869169f, -0.01722283f, 0.05428219f, 0.10083000f, -0.03574132f, 
    0.01357820f, 0.07064985f, 0.21425176f, 0.12585816f, -0.17373031f, -0.11926433f, 0.00743303f, -0.04027365f, 
    -0.07343129f, -0.00821141f, -0.01869005f, 0.15982538f, -0.19542876f, 0.06614415f, 0.33032584f, 0.02653381f, 
    0.00549806f, -0.08575531f, 0.00718217f, -0.14127363f, -0.14787704f, -0.09394270f, -0.05618993f, 0.03024042f, 
    0.05786035f, 0.10571630f, -0.01271334f, -0.00095690f, 0.05048046f, -0.03486161f, 0.10846760f, 0.01073151f, 
    0.05830866f, 0.05980803f, -0.02864208f, 0.07044546f, 0.25044626f, 0.10905523f, 0.26450580f, 0.07205426f, 
    -0.01912109f, 0.04162856f, -0.00093406f, -0.03976174f, 0.04096185f, 0.16085462f, 0.15879220f, 0.17380859f, 
    0.12362251f, -0.02736484f, -0.19473980f, -0.06821139f, 0.03312404f, 0.06073772f, 0.07540490f, 0.11605302f, 
    0.03558645f, 0.00402383f, -0.01702760f, 0.00499452f, -0.07276591f, 0.13303408f, -0.44001335f, 0.16490921f, 
    -0.00679680f, -0.01177384f, 0.15059434f, -0.05784466f, 0.09437687f, -0.02559796f, -0.08615560f, -0.02509432f, 
    -0.22104773f, 0.09485612f, -0.17618194f, -0.00690151f, 0.02497084f, 0.08800226f, 0.13442808f, 0.07762226f, 
    -0.00572368f, -0.00063163f, 0.11677673f, 0.00293799f, 0.08760682f, 0.19477697f, 0.25385278f, -0.01569129f, 
    -0.00821261f, -0.04628503f, -0.05516212f, -0.01902257f, 0.07167394f, 0.03395314f, 0.00160965f, 0.05387653f, 
    0.01216747f, -0.12529305f, -0.06900850f, -0.00041716f, 0.06782833f, -0.02794381f, -0.03523001f, -0.23547754f, 
    0.00856751f, -0.11892050f, -0.01331997f, 0.04862078f, -0.05152838f, -0.12497319f, -0.06098466f, 0.11225653f, 
    0.08907054f, 0.00178058f, -0.09612904f, 0.24324493f, -0.02783891f, -0.03110153f, 0.02974252f, 0.07097962f, 
    -0.13159922f, 0.17946236f, 0.16335718f, 0.01619758f, 0.00116250f, -0.13444099f, -0.08421811f, 0.05984612f, 
    0.08763985f, -0.06351870f, 0.05392899f, -0.02409610f, 0.36763036f, 0.32676083f, -0.01061791f, -0.03367219f, 
    -0.13662770f, 0.09863079f, 0.08375772f, 0.27258691f, 0.03018417f, 0.13981766f, -0.04315091f, 0.03283285f, 
    0.01947201f, 0.16835062f, 0.11452471f, 0.03012115f, -0.05132160f, -0.12620112f, 0.12628250f, -0.08073610f, 
    -0.06769165f, -0.08812131f, 0.15765022f, 0.05630371f, 0.16655813f, 0.34223071f, 0.01386144f, -0.28256744f, 
    -0.00781062f, 0.05388307f, 0.13913402f, -0.10406918f, 0.01411450f, 0.00577063f, 0.04825775f, 0.05547412f, 
    -0.00802381f, 0.07732683f, -0.14007895f, -0.19449042f, 0.02245641f, -0.10473008f, 0.10489785f, 0.03540241f, 
    0.03557319f, -0.06770452f, -0.01531547f, -0.01270086f, -0.12957998f, -0.21107559f, 0.01049436f, 0.07759466f, 
    0.12355114f, 0.13371487f, 0.00483231f, -0.13958646f, -0.01259058f, -0.11531954f, -0.11433806f, 0.04345530f, 
    0.14614893f, -0.06233642f, -0.15123424f, 0.04889837f, 0.06088466f, -0.08043256f, -0.18537901f, 0.09324015f, 
    0.13373360f, -0.00080930f, 0.15207243f, 0.01153144f, -0.01257681f, -0.24578483f, 0.14341882f, -0.01103276f, 
    0.02865692f, -0.00178503f, -0.00608507f, -0.05569433f, -0.12346296f, -0.12691016f, -0.01848820f, 0.15222077f, 
    0.13091825f, 0.09625933f, 0.10474650f, -0.04145117f, 0.01326903f, -0.03460414f, -0.05319925f, 0.10822598f, 
    -0.02030675f, 0.02405898f, 0.06276421f, 0.04739275f, 0.03736809f, -0.04064753f, -0.06494272f, -0.10845225f, 
    -0.19928528f, -0.04107670f, -0.15718769f, 0.01262863f, 0.03625211f, 0.01499913f, 0.06982739f, 0.07024430f, 
    -0.12097761f, 0.18720719f, -0.17668605f, -0.20869476f, 0.05157782f, 0.10051493f, 0.11734760f, 0.05360241f, 
    -0.01222940f, -0.08921393f, -0.05036660f, -0.07160143f, 0.13059343f, -0.05595580f, -0.12294208f, -0.35727465f, 
    0.09194219f, -0.04063260f, 0.02942568f, 0.03504812f, -0.06454271f, -0.01214663f, 0.02617528f, -0.03274717f, 
    -0.09667784f, 0.08435519f, -0.06284945f, 0.12118916f, 0.01224042f, -0.00400312f, 0.02370645f, -0.03273385f, 
    -0.00691325f, 0.09494580f, -0.05225734f, 0.08756977f, -0.06548662f, -0.24190281f, 0.09645426f, -0.21673580f, 
    0.01669363f, -0.03543282f, -0.14399864f, 0.00889634f, -0.01098508f, -0.11503761f, 0.06981797f, 0.16839027f, 
    0.15986839f, 0.22025479f, 0.26977721f, 0.03166915f, -0.00166425f, 0.01803459f, 0.04141356f, -0.08508725f, 
    0.11795048f, 0.07010443f, 0.02773186f, 0.00703670f, 0.07004988f, 0.15395413f, 0.11784610f, 0.03219635f, 
    -0.13689099f, 0.02372279f, 0.02475043f, -0.01226958f, 0.04486040f, 0.18899001f, -0.02619017f, -0.23398142f, 
    -0.21466276f, -0.11476640f, 0.03519173f, 0.03441175f, -0.24577391f, -0.14669579f, -0.00649735f, -0.06243062f, 
    -0.04306909f, -0.07002053f, -0.00451028f, 0.08297414f, 0.04905981f, 0.00887177f, 0.07871569f, -0.04057698f, 
    0.08091968f, -0.08448263f, -0.03451891f, -0.08405485f, 0.05124770f, -0.00149705f, -0.01874654f, 0.28880826f, 
    -0.14661174f, -0.07307454f, 0.00093606f, -0.03669995f, 0.00850705f, 0.02402337f, 0.05239978f, 0.21222170f, 
    -0.23110017f, -0.02862059f, 0.01409566f, -0.00269289f, -0.23372513f, -0.12113187f, 0.14097904f, 0.01976322f, 
    -0.11711185f, 0.03204355f, -0.22117656f, 0.05268031f, -0.06230502f, -0.12657019f, 0.08034104f, 0.10243315f, 
    -0.20384498f, 0.29707047f, 0.12364621f, -0.03261172f, -0.08052471f, -0.00450392f, -0.02834417f, -0.13011198f, 
    0.14101137f, 0.17265552f, 0.17590314f, -0.01418131f, 0.06375832f, -0.18923314f, 0.19101050f, 0.01002488f, 
    0.14682451f, 0.07720351f, 0.04643476f, -0.01609830f, 0.14018057f, 0.13115367f, 0.01345596f, 0.32087272f, 
    0.14852160f, -0.23282820f, 0.06723619f, 0.07653128f, 0.04358270f, -0.08744314f, 0.04081246f, 0.04740506f, 
    -0.02024803f, -0.11511961f, -0.18061717f, 0.13959384f, -0.02757118f, 0.04514817f, -0.02324912f, 0.10993677f, 
    0.06470115f, -0.04891781f, -0.01175527f, 0.02671923f, -0.06834806f, -0.11589220f, 0.02544460f, -0.16585432f, 
    0.08779079f, 0.05833787f, 0.04384159f, 0.02789280f, 0.01469763f, -0.03231599f, 0.06271134f, -0.22126071f, 
    -0.01593430f, 0.21942590f, 0.13386540f, -0.10920084f, -0.08678189f, -0.27637088f, 0.20330992f, 0.16374269f, 
    -0.02628779f, -0.05754261f, -0.02985517f, 0.04443078f, 0.00861995f, 0.22960255f, 0.10691682f, 0.14228354f, 
    -0.21892838f, -0.12527351f, 0.01980629f, -0.11569743f, -0.00419432f, 0.04389926f, -0.12123983f, -0.07689296f, 
    -0.07648620f, -0.08328260f, -0.31728432f, -0.25433624f, -0.13156959f, 0.08856983f, -0.30593932f, -0.08829423f, 
    0.12139005f, 0.01586989f, 0.05070330f, -0.01026252f, 0.13754420f, -0.00652210f, -0.05634533f, -0.05643832f, 
    -0.07839109f, -0.04864017f, -0.25859874f, 0.01447579f, -0.30208868f, -0.08683762f, 0.15498856f, -0.01521055f, 
    0.02312945f, -0.03309751f, 0.02719748f, 0.00733274f, 0.14411117f, 0.07428632f, -0.04413450f, 0.02069814f, 
    0.07458350f, -0.00831725f, 0.00576557f, -0.05381881f, -0.02987422f, 0.00876720f, 0.14677605f, -0.10035373f, 
    0.05305167f, -0.09754838f, 0.03296386f, -0.06116828f, 0.03754595f, -0.15691786f, -0.07290357f, -0.16588776f, 
    0.06406514f, -0.00059711f, -0.00326818f, 0.04791589f, -0.06625117f, 0.01410680f, -0.03798904f, -0.12036899f, 
    -0.21653821f, -0.11684408f, -0.10923506f, 0.21848688f, 0.02961236f, -0.03666981f, 0.03076443f, -0.08242176f, 
    0.30264455f, 0.22992760f, 0.14205524f, 0.08181267f, -0.03481839f, -0.07787275f, 0.06804345f, 0.00090733f, 
    0.02683396f, -0.09851540f, 0.04693301f, 0.34228617f, 0.18689671f, 0.11463956f, 0.04160877f, 0.00520012f, 
    -0.02302258f, -0.13194522f, -0.05290161f, -0.02268456f, -0.00532435f, 0.01281907f, -0.03387383f, 0.00497273f, 
    0.07018317f, -0.23329696f, 0.34818938f, -0.14529653f, -0.04971679f, 0.10622071f, -0.01429227f, -0.16260873f, 
    0.14684772f, -0.11047578f, 0.31585267f, 0.30821049f, -0.08731765f, 0.14018977f, -0.10397788f, 0.21573395f, 
    -0.00139259f, 0.08647331f, -0.13488398f, 0.06602497f, -0.09169837f, -0.20893812f, 0.01858548f, 0.06314596f, 
    0.15947895f, 0.03211906f, -0.06655465f, 0.06827569f, -0.12993386f, -0.16054344f, -0.05571533f, 0.25403658f, 
    -0.13478027f, 0.00859859f, 0.02792715f, 0.34387758f, -0.05248199f, -0.03618032f, -0.04587639f, 0.00445820f, 
    0.11601045f, 0.09764445f, -0.07033358f, -0.04206873f, 0.05549286f, -0.00444434f, -0.04558794f, -0.00058684f, 
    0.02891497f, 0.11199988f, -0.03771235f, -0.05836695f, -0.01322683f, -0.09952946f, -0.04049576f, -0.01964494f, 
    -0.11806791f, 0.08582880f, 0.17923613f, 0.08124895f, 0.05355196f, -0.10264713f, 0.09149058f, -0.02446810f, 
    0.05945193f, 0.03510379f, 0.01903605f, -0.05107544f, 0.05553488f, -0.04647901f, -0.00992593f, -0.02931372f, 
    -0.15199363f, -0.06315989f, 0.16419230f, -0.13199900f, -0.03520981f, -0.18856858f, -0.04920374f, -0.05348072f, 
    -0.17328668f, 0.00895559f, 0.08612437f, 0.06486566f, -0.13909142f, -0.02365275f, -0.03578699f, -0.06598853f, 
    -0.32537839f, -0.03155028f, -0.16353516f, 0.01585645f, 0.08795568f, 0.07970435f, 0.00376931f, -0.00117394f, 
    -0.00160890f, 0.19733599f, -0.22416706f, 0.11527797f, -0.02787054f, -0.25051165f, 0.16147590f, 0.04713369f, 
    0.00934032f, 0.04283611f, -0.11101434f, -0.03085492f, 0.06700563f, -0.04256216f, 0.10958799f, -0.06458575f, 
    0.00361890f, -0.02655661f, 0.08996315f, 0.02734373f, 0.10800889f, 0.07426778f, -0.16508906f, -0.10946342f, 
    -0.00449343f, 0.07773871f, 0.04572231f, 0.08464857f, 0.06625586f, 0.05085569f, 0.11640228f, 0.00684198f, 
    -0.00361602f, 0.10367654f, 0.19668444f, 0.10012323f, -0.35168597f, -0.06143443f, 0.26412937f, 0.00783561f, 
    0.05958460f, -0.13542546f, -0.06819764f, 0.22825222f, -0.05752863f, 0.01305470f, 0.29672509f, 0.26802921f, 
    0.04825553f, 0.19149618f, 0.18507053f, 0.21329364f, 0.02331622f, -0.11849469f, -0.04849924f, -0.07365033f, 
    0.05038133f, -0.18131582f, -0.08003787f, 0.05814605f, 0.09696155f, -0.06092063f, 0.21460491f, -0.24904405f, 
    0.00990511f, 0.00166225f, -0.11518305f, -0.08622993f, 0.10340603f, -0.11125118f, -0.04662146f, -0.06180489f, 
    -0.03157989f, 0.01890829f, -0.05410913f, -0.13025369f, -0.07010448f, 0.02119648f, 0.08321945f, -0.05515704f, 
    -0.07965263f, -0.06600878f, -0.05098112f, 0.00094032f, -0.06958959f, 0.04532908f, -0.10423274f, 0.12761886f, 
    -0.04166745f, -0.01186497f, -0.03961342f, 0.15320553f, -0.07373632f, -0.10156702f, -0.04317012f, -0.09531870f, 
    0.09612082f, 0.07924901f, 0.12860155f, 0.13885726f, 0.05151822f, 0.16812482f, 0.00298373f, -0.14388253f, 
    0.01152782f, 0.05549067f, 0.07074816f, 0.12418327f, 0.03837016f, -0.10823626f, 0.20106025f, 0.10992800f, 
    0.06557690f, 0.21041861f, 0.23564687f, -0.01812361f, 0.04333653f, 0.12754069f, 0.04415922f, 0.08991296f, 
    0.34445417f, -0.02234094f, -0.10123176f, -0.15744486f, -0.03418761f, 0.13903391f, 0.04744249f, 0.02154253f, 
    0.09482111f, -0.10952186f, -0.01548590f, -0.04507760f, -0.14468881f, 0.03477197f, -0.18445039f, 0.02454772f, 
    -0.22876297f, -0.01231933f, -0.04387642f, 0.04842520f, -0.00686520f, -0.05843638f, -0.11914627f, 0.06852216f, 
    -0.19066013f, -0.07602820f, -0.02621409f, 0.01681702f, 0.02662944f, 0.09092482f, 0.10522369f, -0.02596433f, 
    -0.14254180f, -0.03098396f, 0.02804813f, -0.28273389f, 0.00170092f, -0.27975395f, 0.03362485f, 0.07526913f, 
    -0.01797064f, -0.03354111f, -0.03618031f, 0.04721681f, 0.00033325f, -0.01616367f, 0.00365554f, 0.06939970f, 
    -0.07221777f, -0.04893636f, 0.02328688f, -0.11570582f, 0.16160639f, 0.14640297f, -0.06894996f, 0.00667059f, 
    0.14955062f, 0.04818245f, 0.15527575f, 0.27281833f, 0.08154716f, -0.17550677f, -0.19672437f, 0.16184399f, 
    0.04890865f, -0.04882807f, -0.02206565f, -0.04665325f, 0.05560592f, -0.03231860f, -0.04559997f, 0.04040281f, 
    0.03112989f, -0.01142984f, -0.03771337f, 0.00447611f, 0.17930403f, -0.02478279f, -0.00031063f, -0.00069277f, 
    0.01739372f, -0.01390320f, -0.00048204f, 0.12108598f, 0.64287949f, -0.15444054f, 0.32853132f, -0.09170794f, 
    -0.05814211f, -0.07414430f, -0.03722011f, -0.01768799f, -0.03719778f, -0.06315354f, 0.03422836f, -0.21737397f, 
    -0.03525215f, -0.07075152f, 0.10739249f, -0.07556088f, 0.14440714f, 0.01041367f, 0.09052446f, 0.14354149f, 
    -0.05404052f, 0.08215511f, -0.13154967f, -0.10486595f, 0.04426597f, -0.04501829f, -0.16696645f, 0.10109156f, 
    -0.19536749f, 0.04367205f, 0.00862251f, 0.07064685f, 0.01239229f, 0.01072397f, -0.03118654f, -0.04818863f, 
    -0.22443040f, -0.14233513f, -0.00997066f, -0.00341739f, 0.19941275f, -0.00532106f, 0.14297509f, 0.03214433f, 
    0.08188944f, -0.06979962f, -0.03922160f, -0.08078668f, -0.12313828f, -0.07351398f, 0.23712897f, -0.27211517f, 
    0.02504329f, 0.06033070f, -0.03015698f, -0.02019970f, 0.00764403f, -0.05504588f, -0.11512656f, -0.22697829f, 
    -0.06878167f, 0.24719468f, 0.04087923f, 0.17785969f, -0.11003301f, 0.08759204f, -0.12303153f, 0.03444655f, 
    -0.01794804f, -0.01928672f, -0.02461545f, -0.04153595f, -0.16427925f, -0.18196225f, 0.11984432f, 0.12001419f, 
    0.08743475f, -0.12349843f, 0.02806700f, -0.04624889f, -0.02414674f, -0.07350288f, 0.11088710f, -0.02172451f, 
    0.08678353f, 0.29043594f, -0.12331521f, 0.15647264f, 0.07960320f, 0.02959494f, -0.00973545f, 0.05501015f, 
    -0.16318411f, -0.18560344f, -0.04969505f, -0.08322373f, -0.41965273f, -0.30846855f, -0.22296359f, -0.05650903f, 
    -0.09806296f, 0.03045451f, -0.03222379f, 0.00538470f, 0.07699826f, -0.01579753f, 0.08388904f, -0.00834891f, 
    -0.28008604f, -0.15140627f, 0.02415615f, 0.29950842f, 0.23142171f, -0.00779997f, 0.05665795f, 0.07481991f, 
    0.10483580f, 0.17079508f, 0.11089470f, 0.09891856f, -0.10719804f, -0.03266023f, 0.02891449f, 0.13858505f, 
    0.04528537f, -0.08153489f, 0.00596227f, 0.04574945f, -0.10571538f, -0.08745021f, 0.03518208f, -0.04132837f, 
    0.08231154f, 0.37494239f, 0.37317285f, 0.23672475f, 0.00792804f, 0.02378471f, 0.11380196f, -0.11149579f, 
    -0.03043462f, 0.04036621f, -0.04933447f, 0.16094153f, -0.01065364f, 0.11405904f, -0.22336210f, 0.26361120f, 
    0.08361109f, -0.20798182f, -0.03865451f, 0.09742730f, -0.02548738f, -0.00305138f, -0.09398956f, 0.08241899f, 
    -0.12517916f, 0.02098262f, 0.12978633f, 0.04723888f, -0.03211501f, 0.05805157f, 0.03790922f, -0.11306396f, 
    -0.06137597f, -0.03480502f, -0.13358712f, 0.01126844f, -0.12262659f, -0.02676121f, 0.25682762f, 0.20183641f, 
    0.06287911f, -0.08169086f, 0.04351708f, -0.11331732f, -0.05547016f, -0.05289850f, -0.02218416f, -0.17329390f, 
    0.10391604f, -0.22769929f, -0.00761836f, -0.02511575f, -0.00128360f, 0.08750144f, 0.00954937f, 0.12343103f, 
    0.00882000f, -0.05008127f, 0.10429887f, 0.03692687f, -0.02380197f, 0.18978311f, -0.22646233f, 0.13385904f, 
    -0.04051249f, 0.02591009f, 0.05474756f, -0.02573100f, 0.27765155f, -0.01582294f, -0.00851290f, 0.14828867f, 
    0.34146270f, -0.07380386f, 0.04780520f, -0.09209715f, -0.04472705f, 0.04045417f, -0.12980905f, -0.07084750f, 
    -0.03594919f, 0.01354945f, 0.05727407f, 0.29018429f, 0.11869297f, 0.55996037f, -0.00731682f, 0.36461228f, 
    -0.15184096f, 0.26940632f, -0.20851927f, -0.02268826f, 0.18352130f, 0.08209787f, -0.11628897f, 0.05678022f, 
    -0.16869016f, 0.16202809f, -0.01841279f, -0.01692917f, -0.02828284f, -0.02426183f, -0.02896016f, 0.09890547f, 
    0.07012607f, 0.16917656f, 0.17393197f, 0.14061764f, -0.02314633f, -0.29493964f, -0.15399656f, 0.40579426f, 
    0.21083550f, -0.15811174f, -0.02491096f, 0.05212398f, 0.13204800f, 0.02958625f, -0.09866654f, 0.27354166f, 
    0.04768196f, 0.04192661f, -0.03391167f, -0.00434552f, -0.00894254f, -0.01417642f, 0.02688043f, 0.01855139f, 
    0.02052373f, 0.01542468f, -0.00914216f, -0.02618613f, -0.01637380f, -0.05424863f, -0.02473406f, 0.01155292f, 
    -0.02348611f, -0.04956591f, 0.00334293f, 0.00984884f, 0.01110942f, -0.04678330f, -0.00944609f, 0.00419919f, 
    -0.05037500f, 0.02893065f, -0.01414785f, -0.04724964f, -0.02685366f, -0.00349063f, 0.02230883f, -0.05317581f, 
    -0.03518362f, -0.05549962f, -0.03209045f, -0.00121552f, -0.04510353f, -0.04017190f, 0.02558018f, -0.01225411f, 
    0.00830973f, 0.00084533f, 0.00158755f, 0.03463303f, 0.00196360f, 0.01271427f, 0.04180175f, -0.00853319f, 
    -0.02933083f, -0.02053716f, -0.03537847f, -0.03784306f, 0.04020515f, -0.01528896f, -0.04813284f, 0.02200347f, 
    -0.02554943f, -0.04802103f, -0.01406793f, -0.04627644f, 0.00313523f, 0.03088874f, -0.04624955f, -0.04739779f, 
    -0.00841914f, -0.02364625f, 0.02853079f, -0.02566426f, 0.00893637f, -0.02554176f, -0.02244571f, -0.02350892f, 
    0.03493709f, -0.00152977f, -0.02468964f, -0.05593328f, -0.00797576f, -0.04658860f, -0.00938405f, -0.05719185f, 
    -0.00227182f, 0.00685346f, -0.02115953f, -0.03386237f, -0.02721752f, -0.04029333f, -0.01336613f, -0.04241639f, 
    0.02621456f, 0.01910896f, 0.02353761f, 0.03737147f, 0.01113600f, 0.00490329f, -0.01235413f, 0.01146414f, 
    0.00072948f, 0.02729452f, 0.01138238f, -0.03768696f, -0.00046830f, 0.01662172f, -0.01825812f, -0.05433854f, 
    -0.01039456f, -0.03223281f, -0.00845747f, 0.00281142f, -0.01299854f, -0.04948466f, 0.02834870f, -0.00442862f, 
    -0.04955573f, 0.00490360f, 0.00508463f, -0.04985597f, -0.00265210f, 0.02975359f, 0.02438466f, 0.04132700f, 
    -0.01379695f, 0.03263468f, -0.02669528f, -0.00758784f, -0.02023444f, -0.02566128f, -0.05856718f, -0.05820496f, 
    -0.02299330f, -0.04763528f, -0.04005966f, 0.03771249f, -0.00818330f, 0.02869004f, -0.01255414f, -0.01223621f, 
    0.01300088f, 0.01979591f, 0.04325023f, 0.01679137f, -0.05271905f, -0.03271388f, 0.02603562f, 0.00384092f, 
    -0.00808521f, -0.03016668f, -0.01806195f, 0.01988569f, 0.02370292f, -0.05743174f, 0.03229964f, -0.04034615f, 
    -0.01511404f, 0.01631351f, -0.02721958f, 0.00237260f, 0.03057769f, -0.04990668f, -0.05391136f, -0.01485731f, 
    -0.02547374f, -0.03524502f, -0.05794487f, -0.00114492f, -0.05268412f, -0.02756036f, 0.03211714f, -0.04230986f, 
    0.03155239f, 0.03091061f, -0.01978035f, -0.04877630f, 0.01074914f, -0.04208364f, -0.03634869f, 0.04326865f, 
    0.00189627f, 0.03791917f, -0.05600191f, 0.00346731f, -0.00710048f, 0.01783926f, -0.02180995f, -0.00368865f, 
    -0.03767351f, 0.03806081f, -0.00785052f, -0.01889332f, -0.01599088f, -0.05008069f, 0.03987585f, -0.00362296f, 
    0.00163990f, -0.05792075f, -0.03341849f, -0.03309565f, 0.03753071f, 0.02007613f, 0.00013099f, 0.01422602f, 
    0.01204008f, 0.03456311f, -0.00806831f, 0.00968109f, -0.03769498f, -0.04995766f, -0.01919857f, -0.04912833f, 
    -0.05136168f, 0.02309125f, -0.03120762f, -0.01330414f, -0.03550732f, 0.03222803f, -0.03950273f, -0.00638190f, 
    -0.02241619f, -0.00014705f, -0.01538642f, -0.02842389f, -0.05451399f, -0.05144572f, 0.01847910f, 0.03589125f, 
    0.03017094f, -0.02612382f, -0.05524369f, -0.02507708f, -0.03166683f, 0.01202701f, -0.04472487f, 0.04101637f, 
    -0.03831475f, -0.01199649f, -0.05107110f, 0.00290738f, 0.01562226f, 0.03652734f, -0.03529100f, 0.01490323f, 
    0.00460508f, -0.00431098f, 0.03469817f, 0.03054434f, 0.03442525f, -0.02943257f, -0.02603917f, 0.01807952f, 
    0.04233709f, -0.03384596f, -0.05018962f, -0.00159987f, 0.00851495f, 0.03563322f, -0.03309835f, -0.02024566f, 
    -0.03587513f, 0.00678233f, -0.03785586f, -0.02018829f, 0.03935640f, -0.04975523f, -0.03408312f, -0.03264539f, 
    0.03190441f, -0.02283863f, 0.01653378f, 0.00404590f, -0.02864446f, 0.01457286f, -0.03011984f, 0.01098614f, 
    -0.03848740f, -0.02417106f, -0.00615944f, -0.04604575f, -0.01811950f, -0.03041004f, 0.01557401f, 0.03890944f, 
    0.01595032f, 0.00908630f, -0.02012178f, 0.00341188f, -0.02545435f, -0.01160009f, -0.01965911f, -0.04421251f, 
    -0.03475293f, 0.03421742f, -0.00090444f, -0.00425675f, -0.04017816f, 0.01069808f, 0.00089377f, -0.05176824f, 
    -0.04586658f, 0.03410958f, 0.03625380f, 0.02172855f, 0.01745302f, -0.01639549f, -0.04696444f, 0.03902633f, 
    0.00173021f, 0.01777567f, -0.00835064f, -0.03441823f, -0.02283332f, -0.03143969f, 0.04057254f, -0.03025458f, 
    -0.05566480f, 0.02340695f, 0.01537352f, -0.01426497f, 0.03323387f, 0.03575336f, -0.03851599f, 0.02813804f, 
    -0.03157895f, 0.01650145f, 0.00915487f, -0.02415860f, -0.02935770f, -0.02541569f, 0.04019777f, 0.04260117f, 
    0.02666571f, -0.05641235f, -0.01982977f, -0.04210078f, 0.01586663f, 0.03764006f, -0.01875673f, 0.00147082f, 
    -0.00720922f, -0.04816355f, -0.01551899f, -0.03935674f, -0.00379083f, -0.04985907f, -0.02628750f, -0.02873670f, 
    -0.04859431f, 0.00609301f, -0.04219636f, -0.00183242f, 0.01526534f, 0.04274072f, 0.02369773f, 0.01691581f, 
    0.02429587f, -0.02711105f, -0.05469572f, -0.00689302f, -0.03938057f, 0.02780168f, -0.02201989f, -0.05416444f, 
    0.03103104f, 0.01593763f, -0.05165176f, 0.04112925f, -0.01703058f, -0.02077369f, -0.01400114f, -0.03679953f, 
    -0.05487569f, 0.02312221f, 0.01569838f, -0.04557436f, 0.00130210f, 0.01541539f, -0.05146670f, -0.05450352f, 
    -0.05754052f, 0.01928389f, 0.03412349f, 0.01336025f, -0.01655014f, 0.03065095f, -0.04506589f, -0.05848466f, 
    0.03635509f, 0.01337084f, -0.06750381f, -0.23011722f, -0.08236951f, -0.11306023f, -0.00976162f, -0.09605885f, 
    0.06064360f, 0.06046120f, -0.04563931f, 0.02034010f, -0.07228805f, -0.12129456f, -0.15817103f, -0.13480256f, 
    -0.12037375f, 0.02717397f, 0.03243576f, 0.04516159f, 0.02607570f, 0.08942463f, -0.08789726f, 0.01150039f, 
    0.07633577f, 0.21364295f, 0.17638469f, -0.02110699f, -0.03909601f, -0.05293235f, -0.03977029f, -0.09179900f, 
    -0.05374279f, -0.03805452f, -0.15194800f, -0.23466930f, 0.27646807f, 0.02438970f, 0.16377671f, 0.12227625f, 
    0.04463675f, 0.12222910f, 0.16086042f, -0.04141836f, 0.18533064f, 0.11991502f, -0.00599660f, 0.03366180f, 
    0.21761462f, -0.08590526f, 0.03600950f, -0.00695078f, 0.07359523f, 0.17656377f, 0.08609752f, 0.12181529f, 
    0.09003644f, -0.01215469f, 0.07374549f, 0.17169103f, -0.21428847f, 0.05650867f, -0.27495354f, -0.07743157f, 
    -0.11125133f, 0.05348429f, -0.10183639f, -0.01720128f, 0.00338733f, -0.09912965f, 0.07963535f, 0.05756942f, 
    -0.07181593f, -0.07047167f, -0.12307581f, 0.05131251f, -0.07925680f, -0.04524108f, 0.04497973f, -0.06564703f, 
    0.14978333f, 0.04207258f, 0.11322231f, 0.01674586f, 0.04985825f, -0.06172714f, -0.01522223f, -0.00125558f, 
    -0.06375911f, -0.04848117f, -0.03335328f, -0.02381114f, 0.12568878f, 0.05807047f, 0.07658520f, 0.07590617f, 
    -0.18818001f, -0.17949456f, 0.05233538f, -0.13437755f, 0.11935646f, -0.07104178f, -0.04897486f, 0.01381025f, 
    -0.18074268f, -0.18193959f, -0.18016985f, -0.17778669f, 0.19850603f, -0.09846649f, -0.22548902f, 0.18207563f, 
    -0.09399095f, -0.09337275f, 0.04782704f, -0.02966256f, -0.01587621f, -0.16393548f, -0.12233596f, -0.10560746f, 
    0.07090098f, 0.08310250f, 0.12020589f, -0.10898894f, 0.04412403f, -0.01385787f, -0.00329235f, 0.00490677f, 
    0.07006010f, -0.07864039f, 0.03245841f, 0.02707529f, 0.39450210f, 0.20135243f, 0.54509771f, 0.07389148f, 
    0.02673036f, -0.12673005f, -0.22436985f, 0.00555894f, -0.11701541f, -0.07305905f, 0.00006262f, -0.09209593f, 
    -0.11149310f, 0.01157003f, 0.12395979f, 0.05052584f, 0.17896628f, -0.16280557f, 0.06725717f, 0.15686104f, 
    -0.02337088f, 0.08571777f, 0.02520751f, 0.13212985f, -0.03587093f, 0.08268152f, 0.08941939f, 0.14888191f, 
    -0.09648690f, 0.04755915f, -0.08465125f, 0.01804960f, 0.13330488f, 0.00085901f, -0.01750734f, 0.05406008f, 
    -0.17036894f, -0.06714467f, -0.13117486f, -0.15032704f, 0.05969390f, -0.03966166f, 0.18054873f, 0.26325235f, 
    0.03186287f, -0.06912430f, 0.04238496f, -0.05702909f, -0.06800221f, 0.14060365f, 0.12957308f, -0.09520400f, 
    0.04284754f, 0.10217174f, 0.05082193f, 0.00474534f, -0.04888536f, 0.03985973f, 0.00638690f, 0.04362830f, 
    -0.46922693f, -0.03159261f, -0.20006944f, -0.29927480f, -0.03540489f, 0.08571902f, -0.09670193f, 0.05648958f, 
    0.17359439f, 0.03535808f, 0.03870924f, -0.04946037f, -0.20925425f, -0.10632305f, 0.10838997f, -0.07916063f, 
    0.13248897f, -0.02595684f, 0.15460855f, -0.08978921f, -0.06290732f, -0.01521597f, 0.01012493f, 0.04583174f, 
    0.10738656f, 0.17637445f, -0.17220853f, 0.08365387f, -0.06272725f, 0.10110398f, 0.06912883f, 0.05620318f, 
    0.07788404f, 0.00260160f, 0.03642007f, 0.00564319f, -0.22822312f, 0.02416618f, 0.01233444f, 0.17039330f, 
    0.03114943f, 0.06749949f, 0.11280887f, -0.06674118f, 0.03029750f, 0.03425197f, 0.14714614f, 0.15081038f, 
    -0.09770637f, -0.05445207f, 0.21670660f, 0.29728371f, 0.25485095f, 0.02360240f, 0.10713343f, -0.14644818f, 
    0.14537282f, 0.02521002f, 0.10868375f, 0.12293889f, 0.12711711f, 0.04548350f, 0.02886664f, -0.11416858f, 
    -0.06448067f, -0.18933162f, -0.10801887f, -0.08175454f, 0.03920080f, 0.05111271f, -0.00296575f, 0.04362360f, 
    0.02202427f, 0.01973809f, 0.09226538f, -0.08701537f, -0.03254366f, 0.13760847f, 0.09699664f, 0.14673811f, 
    0.02170717f, -0.02419515f, -0.06019277f, -0.10103786f, 0.09073862f, 0.35485592f, 0.00619087f, 0.15800472f, 
    -0.02843197f, -0.14901084f, -0.01792262f, 0.03192746f, -0.09482710f, -0.04077131f, -0.03534242f, 0.00734413f, 
    -0.02916197f, -0.00834371f, -0.04650142f, 0.01193297f, -0.07516525f, -0.03582789f, 0.20654212f, -0.11268441f, 
    0.01100270f, 0.00350389f, -0.04555000f, 0.08212361f, -0.01021216f, 0.14704694f, 0.23325242f, 0.13667028f, 
    0.11871539f, -0.01341071f, 0.26956365f, -0.01277411f, -0.07197893f, -0.11584355f, -0.01076206f, 0.02481299f, 
    0.05657218f, -0.09016121f, 0.14477488f, 0.05885577f, 0.14076564f, -0.04074417f, 0.07386464f, 0.02270003f, 
    -0.00556081f, 0.01845724f, 0.08243664f, 0.08101074f, -0.01966986f, 0.43001685f, 0.08114653f, 0.34222680f, 
    -0.00987785f, 0.08016801f, -0.03461562f, -0.10417156f, 0.04473063f, -0.04835715f, -0.07080411f, 0.25015980f, 
    0.13136357f, 0.12591237f, 0.20609996f, 0.01817965f, 0.02388587f, 0.01010889f, -0.16498049f, -0.08250564f, 
    -0.16816525f, -0.08793781f, -0.17226523f, -0.10735935f, 0.24305455f, 0.03311957f, -0.12353442f, 0.23641792f, 
    -0.04692306f, 0.21858957f, 0.01194916f, -0.01520461f, 0.21979764f, 0.11034402f, -0.08791717f, 0.02203772f, 
    -0.12470666f, -0.17191277f, -0.31282371f, -0.32407561f, -0.15880737f, -0.00878780f, -0.07971711f, 0.04992135f, 
    -0.08507812f, -0.05585876f, 0.05486507f, -0.09140360f, -0.18735228f, -0.00560672f, 0.01595497f, 0.28625810f, 
    0.10427819f, -0.00654651f, 0.00536339f, 0.12646233f, 0.12962437f, 0.03675793f, 0.02367011f, 0.31847358f, 
    -0.02839293f, 0.01775197f, 0.00380035f, -0.01751001f, 0.01875619f, -0.04357822f, 0.02009537f, 0.00935846f, 
    0.01310618f, -0.01167537f, 0.01951714f, 0.02981628f, 0.00521460f, 0.01951985f, -0.00592642f, 0.02337552f, 
    -0.02505299f, 0.00738504f, 0.02739358f, 0.03397466f, 0.00613806f, -0.02093393f, -0.00736487f, -0.03621071f, 
    0.00567048f, -0.04953803f, -0.04570158f, -0.03572032f, -0.02812125f, -0.02923137f, 0.03434496f, -0.05217711f, 
    -0.00426378f, -0.05050124f, 0.02611156f, 0.03162426f, 0.02955073f, -0.02617076f, 0.00907598f, -0.05491067f, 
    0.03969070f, -0.01183920f, -0.05064001f, 0.00377989f, -0.05488209f, -0.04407422f, 0.02064783f, -0.03933920f, 
    0.01061038f, -0.03518095f, -0.02449994f, 0.02401966f, 0.01363581f, -0.00022898f, 0.03883219f, -0.05310737f, 
    0.00528029f, -0.05348594f, -0.01320763f, 0.01663412f, 0.04442424f, -0.04698561f, 0.01645411f, 0.03804654f, 
    -0.00409592f, -0.00636911f, -0.04374449f, -0.01436075f, -0.00776671f, 0.02812789f, 0.05229436f, -0.04068183f, 
    -0.00330939f, -0.01232808f, 0.03886396f, 0.02413601f, -0.03112586f, 0.02476376f, 0.03643033f, 0.01416910f, 
    -0.04336770f, -0.03725021f, 0.04303787f, 0.04025035f, 0.04338129f, 0.02397777f, 0.01901023f, 0.04257484f, 
    -0.01684233f, -0.05366790f, -0.04039447f, -0.03634611f, -0.04721063f, 0.04715137f, -0.01985481f, -0.03397654f, 
    0.02817866f, -0.03154887f, 0.00571758f, 0.02831151f, 0.00783056f, 0.04031523f, -0.03804049f, -0.02300208f, 
    0.04251885f, 0.02769881f, -0.04269884f, -0.01247761f, -0.03842052f, 0.01411789f, -0.00388666f, -0.03655795f, 
    -0.02767830f, 0.04231454f, -0.04687246f, 0.00874645f, 0.00720082f, -0.01826503f, 0.03342100f, -0.03171121f, 
    0.00036490f, -0.04822904f, 0.01647647f, -0.00725462f, 0.00899860f, -0.01588187f, -0.04768303f, -0.03099176f, 
    -0.02671289f, 0.01713560f, -0.05496178f, -0.01097326f, -0.02549655f, 0.01388031f, 0.00343938f, 0.02075439f, 
    -0.03372553f, -0.04067365f, 0.04088785f, -0.00998463f, 0.02015432f, -0.05129777f, -0.03288387f, -0.05869750f, 
    0.02244424f, 0.00680878f, -0.01603212f, 0.04077591f, -0.01041958f, 0.03770746f, 0.02639448f, -0.03336009f, 
    0.02464812f, 0.02311175f, -0.00974934f, 0.02101789f, -0.01380088f, -0.01158553f, 0.04461326f, -0.02974713f, 
    -0.01473470f, -0.00690425f, -0.00915880f, -0.03362311f, -0.04656790f, 0.00474488f, 0.05599409f, 0.02073826f, 
    -0.00630218f, 0.02437167f, 0.04658913f, 0.03630052f, -0.04008795f, -0.04095918f, -0.00741144f, 0.01086119f, 
    0.02853128f, -0.00333545f, -0.04609746f, -0.03193254f, -0.00471284f, -0.03633485f, 0.03401734f, 0.00017592f, 
    -0.00656050f, -0.03972797f, 0.03735048f, 0.02274952f, 0.02320572f, -0.00497862f, 0.02842691f, -0.02879925f, 
    -0.05649200f, -0.01480928f, 0.02972092f, -0.02492751f, 0.03942626f, 0.02772048f, -0.03277666f, -0.03463307f, 
    -0.02806129f, 0.01210764f, -0.02988080f, 0.00840467f, 0.00201014f, 0.00079453f, -0.01812271f, -0.00920353f, 
    -0.03666678f, -0.01240729f, -0.00746337f, -0.03656568f, 0.02571699f, -0.02491574f, -0.00467617f, 0.03981312f, 
    -0.00652739f, -0.05678062f, -0.03569938f, -0.02705278f, -0.00120185f, -0.01554179f, -0.04730412f, 0.01902238f, 
    0.01944340f, 0.01377189f, -0.04728409f, -0.03275833f, -0.04895437f, 0.02165253f, -0.00971820f, -0.00964822f, 
    -0.00408815f, 0.01283186f, -0.04030354f, -0.00620914f, -0.05242412f, -0.02203923f, -0.05422000f, -0.00944704f, 
    0.03756754f, 0.04115618f, -0.01848759f, 0.00802700f, -0.04636014f, 0.00322445f, -0.05327747f, -0.04190359f, 
    -0.05193941f, -0.01663116f, -0.03881754f, 0.02143759f, -0.05129040f, -0.05046317f, -0.01957493f, -0.02679910f, 
    -0.01733135f, -0.00655583f, -0.01228667f, -0.01393346f, -0.04309888f, 0.01552019f, 0.03308845f, 0.01622324f, 
    -0.03003474f, 0.00975821f, 0.00268218f, -0.02957210f, 0.04119473f, 0.02471818f, -0.04281074f, -0.05159274f, 
    -0.03998715f, -0.03736126f, -0.03311995f, 0.01589017f, 0.00402872f, -0.04235010f, -0.01971238f, 0.03500582f, 
    0.02602903f, 0.03325333f, -0.01954291f, -0.02613915f, -0.02578926f, -0.01509329f, -0.01467753f, -0.01552242f, 
    -0.00786930f, -0.05053190f, 0.02729801f, -0.02117605f, -0.04775601f, 0.03201262f, 0.03899479f, -0.00371723f, 
    0.00172032f, -0.01348480f, -0.03552207f, -0.03587031f, -0.05159356f, 0.02948609f, 0.03069053f, 0.00990503f, 
    -0.01045489f, -0.04421874f, 0.00954284f, -0.00988273f, 0.00527638f, -0.04745821f, 0.02495749f, 0.03860174f, 
    0.02604434f, 0.02453058f, -0.02441372f, -0.01244291f, 0.03751701f, 0.00101896f, -0.04573364f, -0.03043262f, 
    0.02815603f, -0.02589235f, 0.01908323f, -0.04708415f, 0.02730033f, -0.00956891f, -0.04409805f, -0.00842876f, 
    0.01832747f, 0.01738133f, 0.01781782f, -0.05223793f, 0.00813935f, 0.04241782f, -0.04952946f, -0.03129001f, 
    0.03185661f, 0.00684861f, 0.03223480f, -0.00600431f, -0.03535476f, -0.01780109f, 0.00559097f, -0.01481618f, 
    -0.03792297f, -0.01367496f, -0.04639686f, -0.03236388f, 0.04007909f, -0.00552753f, -0.03410155f, -0.01609124f, 
    -0.05238314f, -0.02293803f, -0.01932928f, 0.00067162f, -0.01665522f, -0.03021462f, -0.03922411f, 0.00062336f, 
    0.03811195f, 0.02698347f, -0.05020595f, -0.00497504f, -0.00429431f, -0.02065461f, -0.00495746f, -0.03137565f, 
    0.02130872f, -0.03306097f, -0.00102774f, 0.01048117f, 0.01173224f, -0.05018833f, 0.00956986f, -0.01188411f, 
    -0.02468044f, -0.01243593f, 0.01407188f, -0.03163524f, -0.01610326f, -0.05878204f, -0.02478806f, 0.00465788f, 
    0.09467150f, 0.01173429f, -0.11880638f, 0.14703400f, 0.05014685f, 0.07019442f, -0.02071662f, 0.05943748f, 
    0.00387941f, -0.04362969f, -0.02009220f, 0.02784549f, -0.07812528f, -0.06282136f, -0.19517143f, 0.08178496f, 
    0.06980418f, -0.01737997f, -0.01676334f, -0.36898741f, 0.00950424f, 0.01765789f, 0.07717061f, 0.05371120f, 
    -0.05903137f, -0.08228075f, -0.04866822f, 0.23849313f, 0.12639612f, 0.20116331f, 0.18064618f, 0.09683229f, 
    -0.06780581f, -0.01326970f, 0.00056679f, -0.00113814f, 0.15473333f, 0.09444575f, -0.09498676f, -0.03880472f, 
    -0.00081907f, -0.04271821f, -0.01234491f, 0.13748862f, -0.10457164f, -0.00612241f, 0.03798443f, -0.02509936f, 
    -0.39759514f, 0.16255714f, -0.35977942f, 0.15021829f, -0.03428026f, 0.07494635f, 0.00354294f, -0.03949622f, 
    -0.10375647f, 0.09091193f, -0.03487271f, 0.04754264f, 0.00291645f, -0.04413217f, -0.03850985f, 0.03518670f, 
    0.06082271f, -0.02622177f, 0.13740927f, 0.02361399f, 0.02735403f, 0.07610942f, 0.13621320f, -0.07838170f, 
    0.10616839f, 0.12961718f, -0.02111120f, -0.20623307f, -0.11202016f, 0.01970402f, 0.02070594f, -0.04828853f, 
    0.04710263f, 0.06949078f, 0.25115156f, 0.02525993f, 0.17912920f, 0.22225805f, -0.16492459f, -0.45078859f, 
    -0.16155742f, 0.09979363f, 0.14213325f, 0.04531671f, -0.06842396f, -0.04433281f, 0.01983207f, -0.06301425f, 
    -0.02205828f, -0.15795371f, -0.19965076f, 0.18632761f, 0.06078279f, 0.15943828f, 0.07926150f, 0.02394230f, 
    0.10302301f, 0.10937505f, 0.14740302f, 0.02973416f, 0.11227843f, 0.39199871f, 0.01881026f, -0.27742016f, 
    0.01257681f, 0.08949620f, 0.04509621f, 0.04371737f, 0.05054339f, 0.10032549f, 0.18220508f, 0.15564953f, 
    -0.04456528f, -0.04134589f, -0.03752352f, 0.08933651f, -0.01305547f, -0.05083573f, 0.01710562f, -0.09544881f, 
    0.03815905f, 0.03677383f, -0.03800162f, 0.01541772f, -0.10246138f, 0.11816349f, -0.05293461f, 0.08516408f, 
    -0.15904430f, -0.09406067f, -0.10188682f, -0.00389060f, -0.00363625f, -0.05076104f, -0.04916824f, 0.08555851f, 
    0.33850858f, 0.02075583f, 0.01078239f, 0.11886182f, -0.03012139f, 0.18002151f, -0.08377036f, -0.07847168f, 
    0.07153246f, -0.11511321f, -0.10885662f, 0.03945907f, -0.04477053f, 0.09291469f, -0.13912106f, -0.17427514f, 
    0.09354950f, 0.06121815f, 0.00913811f, -0.07466763f, -0.05690450f, 0.09651423f, -0.03437721f, 0.17978142f, 
    0.11729141f, 0.13476177f, 0.11551775f, 0.07396089f, -0.00610207f, 0.16754587f, -0.05988731f, -0.11271927f, 
    -0.25707039f, -0.02243936f, -0.08403599f, 0.00133053f, 0.07111081f, -0.14751886f, -0.11178973f, 0.31210235f, 
    -0.01743655f, 0.01162188f, 0.07640588f, 0.02728083f, -0.07414257f, -0.05798949f, -0.04391767f, 0.14523093f, 
    0.68020558f, -0.09842332f, 0.13058446f, 0.38129458f, 0.00709477f, 0.03364448f, 0.00339107f, 0.04847569f, 
    0.01631810f, -0.03779598f, -0.01243149f, 0.07853519f, 0.06001988f, -0.07862168f, -0.18780723f, 0.16642119f, 
    0.10775453f, 0.10037801f, -0.00940451f, 0.02235324f, 0.12536937f, 0.11369748f, -0.06812894f, -0.00233825f, 
    0.04612114f, -0.12104397f, 0.17892441f, 0.41516304f, 0.06806275f, 0.03640824f, -0.03733027f, -0.03088600f, 
    -0.07861239f, 0.06611378f, 0.11400000f, 0.04714061f, 0.32993481f, 0.24754025f, 0.06186636f, -0.30420285f, 
    -0.18401490f, 0.18110391f, 0.01152353f, 0.11133425f, -0.10512351f, 0.09024494f, -0.12764925f, -0.01369153f, 
    -0.05225716f, 0.17052412f, 0.02018709f, -0.24918112f, -0.19511904f, 0.11752877f, 0.26103926f, 0.05532012f, 
    -0.04937958f, 0.08468761f, -0.03687528f, -0.03024259f, -0.18689494f, 0.18667671f, -0.01131883f, -0.01612594f, 
    -0.11051839f, -0.14728940f, 0.00229394f, -0.06219175f, -0.04031868f, 0.00900473f, -0.09723273f, -0.09897012f, 
    -0.19459040f, 0.03224007f, 0.06589854f, 0.39536139f, 0.02942207f, 0.13292649f, 0.08640397f, 0.07708640f, 
    0.10299354f, 0.08295459f, -0.05048951f, 0.06258621f, 0.02388031f, -0.05028056f, 0.16751459f, -0.13051215f, 
    -0.04407629f, -0.08821924f, 0.10416085f, -0.17355140f, -0.06268310f, -0.03382841f, -0.05584326f, 0.12887098f, 
    0.03102353f, 0.11074345f, -0.30338123f, 0.09265829f, 0.09804831f, -0.05634962f, 0.01149926f, 0.10032200f, 
    0.07164058f, 0.11061795f, -0.00249245f, -0.12479749f, 0.10078942f, -0.12623477f, -0.14998657f, 0.13091365f, 
    -0.04690398f, -0.02102359f, -0.09883133f, 0.09936547f, -0.02288510f, 0.01683865f, -0.02602449f, 0.02356352f, 
    -0.06245111f, 0.23108818f, 0.08692399f, -0.14621830f, -0.14823024f, 0.07287679f, -0.05725516f, -0.06721233f, 
    -0.10251549f, -0.12361073f, -0.01098841f, 0.01536105f, -0.17272985f, 0.14205019f, 0.00892137f, 0.05812118f, 
    0.01911530f, -0.08632831f, -0.06932993f, -0.10849997f, -0.04403839f, 0.17452677f, -0.12949674f, 0.05364537f, 
    -0.11013655f, -0.00152198f, 0.07169403f, 0.12708731f, -0.21056840f, -0.17028810f, -0.09120985f, -0.01098235f, 
    0.04271978f, -0.01746746f, -0.06935787f, 0.11920238f, -0.14470644f, 0.30778697f, -0.19961677f, 0.07457740f, 
    -0.03394175f, -0.03004414f, 0.13206816f, 0.02881945f, -0.02308879f, 0.04343940f, 0.05379097f, 0.06530818f, 
    0.17273684f, 0.10671303f, -0.06128720f, -0.23168442f, -0.09106471f, 0.21030317f, 0.16101694f, 0.08946921f, 
    0.01481057f, 0.02694953f, -0.03042893f, 0.00674546f, 0.68212569f, -0.01679991f, 0.12773199f, -0.07573856f, 
    -0.06320865f, -0.17054464f, 0.14412963f, 0.08574704f, -0.16108948f, 0.12652196f, -0.00388478f, -0.10417362f, 
    -0.03021357f, 0.00733574f, -0.02512300f, 0.01930179f, -0.00796439f, -0.01934521f, 0.01676930f, -0.05139345f, 
    -0.02253656f, -0.00999695f, 0.01099413f, 0.03995370f, 0.00437236f, 0.00234116f, -0.00933962f, -0.04339541f, 
    0.04652079f, 0.02956887f, -0.01810066f, -0.03500363f, 0.00533006f, -0.00240854f, -0.04115905f, -0.01869893f, 
    0.03766910f, 0.03750393f, -0.01741615f, -0.04614866f, 0.02753930f, 0.01693815f, -0.02693080f, -0.00451467f, 
    0.01457744f, 0.00449500f, -0.00924054f, 0.01936650f, 0.03254697f, 0.00998543f, -0.00600907f, -0.03331614f, 
    -0.02230211f, -0.04525754f, -0.05700378f, 0.02455590f, -0.02611451f, 0.03396042f, 0.00987868f, -0.01735363f, 
    -0.02981305f, -0.01443762f, -0.02019108f, -0.01544031f, 0.04695039f, -0.03197978f, -0.02672409f, 0.00020614f, 
    -0.02836275f, 0.03462756f, -0.05935437f, -0.02677507f, -0.02354771f, 0.03723561f, 0.01486675f, 0.02728663f, 
    0.04605854f, 0.04678957f, -0.01722495f, 0.03295216f, -0.03201769f, 0.04926362f, 0.01050264f, 0.01596832f, 
    0.01603159f, 0.02217977f, 0.03125976f, -0.02234143f, -0.03461877f, -0.05651522f, -0.01083844f, 0.03461757f, 
    0.00803576f, 0.02992804f, -0.01100613f, -0.02332306f, 0.01504977f, -0.03878900f, -0.02956614f, -0.00627597f, 
    -0.03394898f, -0.00354039f, -0.03321696f, 0.03440762f, -0.05399450f, 0.00011971f, -0.02873336f, 0.01663198f, 
    0.00286691f, -0.01513131f, -0.05731126f, 0.03845982f, -0.00806786f, -0.01255819f, 0.01920539f, 0.02446968f, 
    -0.01713867f, 0.02092520f, -0.05616915f, 0.00363502f, -0.04790161f, -0.00074099f, -0.03703426f, -0.00640071f, 
    0.03492153f, 0.02870994f, 0.00286904f, -0.02919882f, -0.01174126f, 0.03350985f, -0.03598061f, -0.01107085f, 
    -0.03706051f, 0.00962736f, -0.04072282f, -0.04740104f, -0.01764167f, 0.03407310f, 0.00575049f, 0.02854733f, 
    -0.05242836f, 0.00695295f, -0.00101008f, 0.01412394f, -0.05695009f, 0.03997264f, 0.03536396f, 0.04048945f, 
    -0.03206933f, -0.05382193f, 0.03024278f, -0.04626449f, 0.00974278f, -0.04127419f, -0.01232234f, 0.00285021f, 
    0.01044542f, 0.00626410f, -0.05071352f, 0.00879659f, -0.03457520f, 0.02277740f, 0.03841531f, -0.05353141f, 
    0.00420309f, -0.03486557f, 0.04286351f, -0.04928679f, -0.04750541f, -0.01626865f, -0.01548899f, -0.01832511f, 
    -0.00034154f, -0.02157726f, -0.02962385f, -0.03345184f, -0.01883834f, 0.00826853f, 0.01766182f, 0.03503044f, 
    -0.02393813f, 0.01409450f, -0.00015507f, 0.00604908f, 0.00882998f, -0.01708575f, -0.01324077f, -0.00433907f, 
    0.03755062f, -0.01405346f, -0.02640997f, 0.01511016f, -0.01638635f, 0.02623345f, -0.04051884f, -0.04626745f, 
    -0.01424559f, 0.03356780f, -0.03053709f, 0.02743724f, 0.03003884f, -0.03728199f, -0.05092509f, -0.02850909f, 
    -0.01490662f, -0.02801028f, -0.02602446f, -0.00560355f, -0.00683766f, -0.04268133f, -0.01918089f, -0.04355394f, 
    -0.03870995f, 0.00883325f, -0.05064344f, -0.00160150f, 0.01175744f, 0.02108043f, -0.00179544f, -0.02214603f, 
    0.04037305f, 0.01659255f, 0.04503538f, -0.02116293f, -0.01548659f, 0.03785173f, -0.05358921f, -0.00598866f, 
    -0.04400101f, -0.00284643f, -0.04620449f, 0.00372840f, -0.02369441f, -0.04793259f, 0.03119446f, -0.02564802f, 
    -0.02169818f, -0.01276863f, -0.00241209f, -0.03988288f, -0.04196975f, 0.00192963f, 0.03053198f, -0.01071609f, 
    -0.04259837f, -0.02046628f, 0.02032953f, 0.04378385f, -0.04325585f, -0.04353371f, -0.02540198f, -0.05628151f, 
    0.01057005f, -0.04079833f, -0.02528976f, 0.00080340f, -0.01974742f, -0.00823696f, -0.04511712f, -0.01012271f, 
    -0.00015097f, -0.04018370f, -0.05472821f, 0.02283761f, 0.01997601f, 0.03466577f, 0.01871096f, 0.03522713f, 
    -0.04610963f, 0.01429754f, 0.02068684f, -0.00154883f, -0.05024164f, -0.03895306f, -0.05065862f, 0.03557971f, 
    0.03105421f, 0.03416442f, -0.04771424f, -0.05189949f, -0.00229388f, 0.00526275f, -0.03003473f, -0.01037459f, 
    -0.01820288f, -0.04125887f, -0.00890645f, 0.01644279f, -0.00657783f, 0.03110982f, -0.03081443f, 0.03587615f, 
    0.00628384f, -0.05007328f, -0.04640586f, 0.01154473f, -0.04409879f, 0.04012078f, -0.04744746f, -0.03881354f, 
    -0.01185018f, -0.04551750f, -0.01182766f, -0.05271694f, -0.05114090f, -0.02594743f, 0.02968021f, 0.01276067f, 
    -0.00808661f, 0.00438724f, -0.00106016f, 0.03394530f, 0.02855422f, -0.03181643f, -0.01701971f, -0.02385346f, 
    0.02130818f, 0.03121901f, 0.01606826f, -0.02032686f, 0.00429058f, 0.04362585f, 0.01151037f, 0.01247629f, 
    -0.01665444f, 0.03259646f, -0.05643551f, -0.03688388f, 0.03433077f, -0.00325206f, -0.04671736f, 0.02168905f, 
    -0.05568605f, -0.05810754f, -0.02596213f, -0.01443597f, -0.04891047f, 0.01180642f, -0.05851823f, -0.01480330f, 
    -0.00725663f, -0.03822345f, -0.00679419f, 0.03926891f, -0.04252433f, -0.03837306f, -0.01020958f, -0.04029871f, 
    0.03802363f, 0.03152878f, 0.01012911f, 0.01307499f, 0.02294858f, -0.05590164f, 0.02023663f, -0.01873474f, 
    0.00307777f, 0.01176420f, -0.00856639f, 0.03343946f, -0.03926088f, 0.01219995f, -0.04226072f, -0.04350499f, 
    0.00612756f, 0.01456540f, 0.01359772f, 0.01296880f, -0.01128201f, -0.01536920f, 0.00648149f, -0.04965322f, 
    -0.03710062f, -0.00629932f, 0.00905173f, -0.00081733f, -0.03602559f, 0.01703633f, -0.00605738f, 0.02964438f, 
    0.03342406f, 0.02674548f, -0.01605600f, 0.02096314f, -0.00571344f, 0.00727220f, 0.00877924f, -0.02441707f, 
    -0.00145325f, 0.02055527f, 0.00164705f, -0.04588253f, -0.05396656f, -0.01871998f, -0.01757043f, 0.02160444f, 
    0.00983501f, -0.04579891f, -0.03647615f, 0.02304286f, 0.03695123f, 0.00465132f, 0.03664537f, 0.00473885f, 
    0.03361243f, -0.04679744f, 0.02695721f, 0.02626693f, 0.03087499f, 0.00767620f, 0.03605457f, -0.04865929f, 
    -0.05106029f, 0.02246368f, 0.03105368f, -0.00124991f, 0.00429556f, 0.04156277f, 0.00830423f, -0.00751686f, 
    -0.03905982f, -0.02286795f, 0.00785499f, -0.00984358f, 0.04506569f, 0.02885279f, -0.02537152f, -0.02117880f, 
    0.02261078f, -0.02549119f, 0.00419218f, -0.01387584f, -0.02214140f, 0.01948400f, -0.04750319f, -0.04758181f, 
    0.00369439f, 0.04598702f, 0.03217851f, -0.05024397f, -0.03690143f, 0.02451553f, 0.03677202f, -0.01046430f, 
    -0.04129690f, -0.02892655f, 0.00737631f, -0.05273809f, -0.00935917f, 0.00460772f, -0.01027114f, 0.01272340f, 
    -0.03099722f, -0.03862049f, -0.03289710f, 0.03595935f, 0.04289594f, -0.05082758f, 0.01408878f, 0.02297707f, 
    -0.01327882f, 0.03430516f, -0.02574260f, -0.00432328f, -0.01981352f, 0.02715431f, 0.03556930f, 0.02561980f, 
    0.02910159f, -0.01212065f, 0.03779516f, -0.01734116f, -0.04771901f, -0.02775406f, -0.00907355f, -0.01848597f, 
    0.02137988f, 0.01303912f, -0.00966974f, 0.02304216f, 0.03880284f, -0.03279369f, 0.01863470f, -0.04326153f, 
    -0.05196277f, -0.00444035f, 0.04092715f, 0.03948613f, 0.02461102f, 0.01880647f, -0.00883525f, -0.01911859f, 
    0.02687964f, -0.01049358f, -0.02570898f, -0.02005219f, 0.01519772f, -0.00917673f, -0.04276699f, -0.02479143f, 
    0.02006899f, 0.01735643f, -0.01495736f, -0.05458213f, 0.01632313f, -0.04923931f, 0.03397050f, 0.01876469f, 
    0.03082952f, -0.02701874f, -0.00702946f, -0.04648068f, 0.02402755f, -0.01908941f, 0.00877647f, -0.02262697f, 
    -0.05387140f, -0.02590672f, -0.03750628f, -0.02233123f, 0.01633339f, 0.02392424f, -0.02231765f, 0.01788208f, 
    0.01319040f, -0.04387598f, -0.04680176f, -0.04284970f, 0.00189994f, 0.01053094f, 0.03664582f, 0.01971473f, 
    -0.01189403f, 0.03340419f, 0.02306765f, 0.00533738f, 0.00680354f, 0.03975426f, -0.04995004f, 0.01300909f, 
    0.00332873f, 0.01932397f, -0.02846995f, -0.04132662f, 0.01054859f, 0.03329267f, -0.04398528f, -0.00046674f, 
    -0.00330770f, 0.00505221f, -0.01865571f, -0.02806698f, -0.01286039f, 0.02499099f, -0.02062391f, 0.01183004f, 
    -0.01064565f, -0.01778443f, 0.00270286f, -0.05349084f, -0.01419496f, 0.00296851f, 0.02882562f, -0.00384307f, 
    -0.01251214f, -0.01715933f, 0.02018516f, -0.02751970f, 0.04201641f, -0.03401270f, -0.03507742f, -0.02318545f, 
    -0.01835543f, -0.01465238f, 0.01793038f, 0.00602325f, -0.00051775f, 0.03979794f, 0.03757001f, -0.02150089f, 
    -0.02083365f, 0.03487973f, -0.02661967f, -0.01157150f, -0.02718637f, -0.03765764f, -0.03442648f, -0.01959990f, 
    -0.01516163f, 0.02172801f, -0.00393804f, -0.02153776f, -0.05316029f, -0.00985026f, -0.04774723f, 0.03717174f, 
    -0.04611376f, -0.01960413f, 0.01918511f, 0.02955748f, 0.00663713f, -0.05066698f, -0.02748092f, 0.01627224f, 
    0.02286386f, 0.00295319f, -0.03248935f, -0.05227509f, -0.01115230f, 0.02823884f, 0.02711293f, -0.02067046f, 
    -0.00903870f, -0.02916460f, -0.03746156f, -0.04150313f, -0.00610030f, -0.02665780f, -0.02231296f, 0.01455219f, 
    0.04307732f, -0.05062883f, 0.02568649f, -0.05381538f, -0.04121903f, -0.03924312f, 0.03250130f, 0.04149327f, 
    0.03404398f, 0.05110340f, -0.02362908f, -0.03721191f, 0.03618424f, 0.03788123f, 0.04660864f, -0.01047593f, 
    0.03562364f, 0.02059170f, -0.05172619f, -0.02302682f, -0.04981580f, -0.00915174f, -0.00749010f, -0.00708704f, 
    -0.01959099f, -0.04830997f, -0.01562904f, 0.00655217f, -0.00526550f, 0.00091171f, 0.03105689f, -0.05022046f, 
    0.01375626f, 0.03546101f, 0.02186045f, 0.02330590f, -0.02001970f, -0.05270189f, 0.00102178f, 0.02688309f, 
    -0.01006242f, 0.04689638f, -0.01430266f, -0.01561789f, -0.01869524f, -0.02666600f, 0.00769832f, 0.01077590f, 
    0.01110511f, -0.05155253f, -0.04060875f, 0.01329328f, 0.02906290f, -0.02278033f, -0.02457151f, -0.03594764f, 
    -0.05249606f, -0.03774490f, 0.01135575f, 0.00059328f, 0.02170420f, -0.00829890f, -0.01304796f, 0.01416760f, 
    -0.04484550f, -0.00910034f, -0.02661306f, 0.02697298f, 0.03551813f, 0.03788759f, -0.03389113f, 0.01058480f, 
    -0.01220502f, -0.01547249f, -0.00081688f, 0.04382061f, 0.03309965f, 0.02875711f, 0.04458286f, -0.05302234f, 
    0.00872896f, 0.00267636f, -0.03381900f, -0.02338806f, 0.00704051f, -0.03788892f, 0.03187769f, -0.06024482f, 
    -0.05862663f, -0.04759063f, -0.01730565f, -0.00581167f, -0.03067262f, 0.03277632f, -0.02688270f, -0.02157548f, 
    -0.05660942f, -0.01493126f, 0.00322067f, -0.00502090f, 0.03312655f, -0.01915571f, -0.05219943f, 0.02256902f, 
    0.00624911f, -0.02693631f, 0.03554136f, -0.03545091f, -0.04787045f, 0.01182132f, -0.02819954f, 0.04010458f, 
    -0.03763094f, -0.04018160f, -0.06307302f, 0.03498259f, -0.01565767f, -0.04501243f, -0.04719686f, 0.00392601f, 
    0.04683961f, -0.02786193f, 0.01199080f, 0.05059844f, -0.04108654f, 0.01932759f, -0.04595601f, -0.02473474f, 
    -0.04637049f, 0.01156461f, 0.00267047f, 0.03859145f, 0.00800410f, -0.00507202f, 0.04357838f, -0.04970266f, 
    0.02791787f, 0.00080921f, -0.01370883f, 0.04055437f, -0.01449212f, 0.00106867f, -0.01309663f, -0.01678774f, 
    -0.03405242f, 0.04852733f, 0.01410265f, 0.04225233f, -0.05919797f, 0.03012698f, -0.03757022f, -0.00820974f, 
    0.04630344f, -0.04999240f, -0.03514657f, 0.00757001f, -0.03597228f, 0.02656447f, -0.04975944f, 0.04428867f, 
    0.05776276f, 0.04942947f, 0.13154227f, 0.18388897f, -0.02635821f, 0.07188980f, 0.14166209f, 0.01068332f, 
    -0.02389987f, 0.06665730f, -0.05261713f, -0.00206482f, -0.07768653f, 0.02377693f, -0.05073239f, 0.11951794f, 
    0.04164469f, 0.01113865f, -0.07696961f, -0.13013673f, -0.05722279f, -0.18312848f, -0.24904856f, -0.03747657f, 
    0.01226989f, 0.10216537f, 0.01727952f, -0.00333319f, 0.00218431f, -0.00761569f, 0.14371501f, -0.06136053f, 
    0.03854681f, 0.12324452f, 0.05906051f, 0.32340163f, 0.01608685f, 0.03545833f, 0.00570790f, 0.01327494f, 
    0.05673958f, 0.04189119f, -0.20316948f, 0.04834495f, 0.05482839f, 0.02674116f, 0.08550032f, 0.09724238f, 
    -0.17529048f, 0.00336185f, 0.45597693f, -0.14292188f, 0.14800739f, -0.07071455f, -0.06648492f, 0.30368242f, 
    -0.10438152f, -0.03380210f, 0.01970025f, -0.17449072f, 0.03076195f, 0.16386375f, 0.09216713f, 0.11200697f, 
    0.24477097f, 0.09280395f, -0.01444109f, -0.05008408f, -0.09519764f, -0.06602648f, -0.10563805f, -0.01794258f, 
    -0.02583680f, -0.05310713f, 0.05646991f, 0.08909928f, 0.25777707f, 0.07033486f, -0.03222694f, 0.01041546f, 
    -0.30470923f, -0.06599453f, -0.04912890f, -0.24376018f, -0.01017299f, -0.15994467f, -0.05605393f, 0.14506465f, 
    0.02972136f, -0.00434239f, -0.00526588f, 0.06337338f, 0.03698777f, -0.00967721f, 0.02191973f, -0.07663764f, 
    0.02460378f, 0.18584661f, 0.21685942f, 0.12731855f, 0.02486482f, 0.01755021f, -0.11602065f, -0.11944414f, 
    0.13185357f, 0.13748676f, 0.34669480f, 0.19323607f, -0.30034333f, -0.07964772f, -0.10029201f, 0.10745974f, 
    0.06185419f, 0.02615697f, 0.03794183f, -0.10777143f, -0.05389747f, 0.02760121f, 0.02287975f, 0.11369389f, 
    0.03889956f, 0.08688986f, 0.00056395f, 0.10938177f, -0.01313834f, 0.06486607f, -0.08585021f, -0.07246590f, 
    0.01117508f, 0.03024442f, 0.08843647f, 0.14674920f, 0.17670006f, -0.04949869f, 0.19687238f, 0.10744647f, 
    0.02423678f, 0.08584365f, 0.01378559f, 0.01733524f, 0.12196736f, -0.13147171f, -0.02777903f, -0.02789730f, 
    0.13925208f, 0.05505306f, 0.03661019f, 0.05858911f, 0.09800405f, 0.11576197f, 0.14347842f, -0.22531132f, 
    0.01363885f, -0.14517526f, -0.13442264f, -0.12062683f, 0.00969747f, -0.12178790f, -0.13308372f, 0.16419248f, 
    0.00746630f, 0.00413404f, -0.03311574f, -0.03478514f, -0.10084420f, -0.03198657f, -0.08143947f, -0.01828320f, 
    0.07507122f, 0.08051044f, 0.03050100f, 0.00834535f, 0.19500895f, -0.06552812f, 0.16111572f, 0.03438282f, 
    -0.08202676f, 0.03107606f, -0.11230490f, -0.05324437f, 0.14969824f, -0.02644632f, -0.02268524f, -0.00522939f, 
    0.05089891f, 0.07522649f, -0.15390448f, 0.02039372f, 0.03465347f, -0.07055636f, -0.08123147f, -0.13946445f, 
    0.02370706f, 0.24365897f, 0.07343905f, 0.09590160f, 0.14058603f, -0.06845943f, 0.07614598f, -0.15197846f, 
    -0.01978704f, -0.16725974f, -0.00900716f, 0.09273677f, 0.32384548f, 0.25053090f, 0.20847331f, 0.22265406f, 
    -0.10133404f, 0.10164455f, -0.04292723f, 0.18026979f, 0.11929798f, -0.03573152f, 0.06248183f, -0.01294462f, 
    -0.08390392f, 0.33153051f, -0.11426160f, -0.15668395f, 0.15125537f, -0.12724181f, -0.06380739f, -0.18016906f, 
    -0.23291884f, -0.03940094f, 0.01323632f, -0.04081259f, 0.41302028f, -0.20004065f, 0.23703577f, 0.08995627f, 
    0.16355348f, -0.10619494f, -0.15966283f, -0.01274806f, 0.01940355f, -0.21595009f, 0.01511038f, -0.04040885f, 
    0.11276430f, -0.13552339f, 0.17575714f, -0.02361111f, -0.02595427f, -0.12954402f, -0.26887980f, -0.03632987f, 
    -0.21312122f, -0.00419179f, -0.02157690f, -0.10195981f, 0.17075899f, -0.01830148f, 0.07086296f, 0.02048468f, 
    0.19350880f, 0.09584378f, 0.06342903f, 0.14745253f, -0.05331549f, 0.02334696f, -0.08143681f, -0.19984914f, 
    -0.01777466f, -0.04832303f, 0.10802326f, 0.08469414f, -0.00978604f, -0.07073934f, 0.04370997f, -0.06029637f, 
    0.01244882f, -0.00320743f, -0.03915603f, 0.27388880f, -0.08333870f, -0.01392318f, -0.12005364f, -0.07006411f, 
    0.06759930f, 0.08529238f, 0.00434158f, -0.02235663f, -0.03226444f, -0.00057537f, -0.00694851f, 0.21781506f, 
    0.17704730f, 0.08358505f, 0.12933268f, -0.00638717f, -0.04939750f, -0.00286626f, -0.02241495f, 0.04307168f, 
    0.04219129f, 0.10828028f, 0.00755503f, 0.06627508f, 0.19931689f, 0.06167076f, 0.04859829f, 0.10432833f, 
    -0.03539603f, 0.05158591f, -0.17933118f, 0.00005133f, 0.04911417f, -0.02359732f, 0.00428752f, -0.08191159f, 
    0.06017121f, -0.19416709f, 0.02311427f, -0.02890986f, 0.13384964f, 0.10524323f, 0.17675619f, -0.18220012f, 
    -0.00065275f, -0.10864389f, -0.04419648f, -0.14514607f, -0.21105486f, -0.15902229f, -0.12592618f, -0.08956711f, 
    -0.06890592f, -0.04653613f, 0.05320805f, -0.01449303f, -0.00886464f, 0.05986218f, -0.03102318f, 0.15267609f, 
    0.07509177f, 0.03606543f, -0.00379314f, 0.12512249f, 0.06382886f, -0.03699009f, -0.01957336f, -0.01160719f, 
    0.27557749f, 0.21001257f, 0.29321566f, 0.21770458f, -0.09928297f, -0.43102011f, 0.29809791f, -0.05370324f, 
    0.17380895f, 0.13846132f, -0.17685132f, 0.02870045f, -0.12665208f, 0.07261365f, 0.17450541f, -0.02725082f, 
    0.16532180f, -0.14035206f, 0.07068238f, 0.28555736f, 0.11984402f, -0.07475334f, -0.00404866f, -0.14428873f, 
    0.18450968f, 0.10564312f, 0.16077222f, 0.10707932f, -0.19274722f, 0.04990564f, -0.37839890f, -0.02046327f, 
    0.05156870f, 0.07543971f, -0.02656385f, -0.22595033f, -0.04049632f, -0.08861519f, 0.06190088f, -0.10195779f, 
    0.24726284f, 0.01461338f, -0.18068537f, -0.07004189f, -0.03553709f, 0.01524156f, 0.08873866f, 0.04599873f, 
    -0.06116693f, 0.09043767f, 0.00503192f, -0.01518280f, 0.13427506f, 0.05263998f, -0.10723005f, -0.03952507f, 
    0.07281662f, 0.03240413f, 0.12106265f, -0.08916944f, -0.13681425f, 0.05206399f, 0.15058266f, 0.01583828f, 
    0.27878812f, 0.25632438f, 0.20100854f, 0.00250763f, 0.07197564f, 0.01475297f, -0.19184220f, -0.12677380f, 
    0.10353156f, 0.00999206f, -0.05124274f, -0.01037210f, 0.08960979f, 0.07984108f, 0.03631619f, -0.08445586f, 
    0.03272896f, 0.03839555f, 0.15516011f, -0.10274234f, -0.00338762f, 0.04139281f, -0.06149790f, 0.00126925f, 
    0.13530461f, -0.01785247f, -0.00099569f, 0.11777096f, -0.04664272f, -0.08812375f, 0.09990139f, -0.00979124f, 
    -0.05642183f, -0.03459319f, 0.05841817f, 0.03577608f, 0.20074077f, 0.14929719f, -0.25401381f, -0.00506436f, 
    -0.01096645f, 0.03242025f, -0.00545887f, 0.01666177f, -0.05254135f, 0.12708141f, -0.02306633f, -0.00453347f, 
    -0.11925747f, 0.12990355f, -0.15420498f, -0.13216342f, 0.08858867f, 0.08307555f, 0.01909306f, 0.02630447f, 
    0.17173071f, 0.12535216f, -0.01590960f, 0.01497605f, -0.61237699f, -0.13151632f, -0.14074343f, -0.15919527f, 
    -0.08667216f, -0.05929714f, 0.05545411f, -0.02424897f, -0.07887302f, 0.01267943f, 0.01091007f, 0.11791993f, 
    0.00419649f, -0.00749014f, 0.00700422f, -0.09718656f, 0.00971736f, -0.15536200f, -0.00159341f, 0.09974886f, 
    -0.03443605f, 0.04147042f, -0.12886043f, 0.08812153f, 0.01529995f, 0.37821504f, -0.33121765f, 0.06586650f, 
    -0.03252337f, 0.07258462f, 0.03792074f, -0.07661108f, -0.05230207f, 0.05274114f, -0.06311499f, -0.11690649f, 
    0.19453008f, 0.14360861f, -0.10801961f, -0.03968532f, 0.02629537f, -0.15287605f, 0.10070435f, 0.13313685f, 
    -0.02552360f, 0.06365505f, 0.14049158f, -0.04630233f, -0.24333464f, -0.41183755f, 0.27662885f, -0.19450723f, 
    -0.03900070f, -0.00860390f, -0.07940637f, 0.07554290f, -0.07554995f, 0.09874160f, -0.03783141f, -0.01407611f, 
    0.01514645f, 0.20108953f, 0.06260297f, 0.04965630f, 0.03814986f, -0.06528548f, -0.07095920f, 0.00637095f, 
    -0.00107601f, -0.00358314f, -0.03311284f, -0.00787657f, -0.27533963f, -0.07220490f, -0.46610638f, -0.09172352f, 
    -0.01468174f, 0.03519312f, 0.05810423f, 0.00830310f, -0.15837611f, -0.05924873f, -0.00034424f, -0.21589744f, 
    -0.27079397f, 0.09858587f, -0.10469545f, -0.20663996f, -0.01075220f, 0.04656248f, 0.05458036f, -0.05013269f, 
    0.15230656f, -0.16088073f, 0.00173963f, -0.01528833f, 0.01503202f, 0.15923910f, 0.17140125f, 0.00340581f, 
    0.04126289f, 0.11252189f, 0.22218312f, -0.01901383f, -0.01084257f, 0.06952593f, -0.00029037f, -0.00616887f, 
    0.13179050f, -0.09562244f, 0.11700279f, -0.26074341f, 0.03508403f, 0.14092250f, -0.08373230f, -0.06740984f, 
    0.00803550f, 0.12357388f, -0.06432571f, -0.03698542f, 0.15925476f, 0.22158279f, 0.11738506f, 0.19672842f, 
    -0.00709943f, -0.02126086f, 0.11251053f, 0.09840152f, -0.04781073f, 0.14437070f, 0.02782112f, -0.00125171f, 
    0.44523269f, 0.02181467f, -0.03977584f, -0.19625144f, 0.01482602f, 0.18318066f, -0.01733679f, 0.05723831f, 
    0.02385115f, -0.08929644f, -0.02841687f, -0.00922783f, -0.66372305f, 0.38962233f, 0.13827898f, 0.03630729f, 
    0.05647721f, 0.03510517f, 0.00394033f, 0.03766898f, 0.03178402f, -0.00391725f, 0.02910914f, 0.03548901f, 
    -0.26513946f, 0.24020265f, 0.04425421f, -0.05145585f, 0.18171936f, -0.12896639f, -0.01448030f, -0.13526052f, 
    0.18562394f, 0.09260284f, -0.02372488f, -0.11170866f, -0.05840907f, -0.11631235f, -0.21858980f, -0.21608436f, 
    -0.04099417f, -0.02650657f, -0.12979800f, -0.13742355f, -0.00211723f, -0.04348427f, -0.03722963f, 0.09264172f, 
    0.26823863f, 0.05920526f, 0.13738324f, 0.07794085f, 0.06362872f, 0.05582250f, 0.09156656f, -0.05476693f, 
    0.02046187f, 0.10709618f, 0.08501754f, -0.01428017f, -0.04144370f, -0.38851416f, -0.16364148f, 0.02435999f, 
    -0.11015009f, -0.04283333f, -0.03993122f, -0.01660240f, -0.20179389f, -0.11623832f, -0.11392251f, -0.15373679f, 
    0.17795989f, 0.20149322f, 0.05216047f, 0.21716918f, -0.10538913f, 0.05435194f, 0.09771393f, 0.07806026f, 
    0.01461049f, -0.00005441f, 0.00420120f, 0.03935397f, 0.20234701f, 0.09425192f, 0.22514197f, 0.22227913f, 
    -0.10523284f, 0.05158797f, 0.03389975f, 0.13806900f, -0.05406124f, 0.03737534f, 0.03162984f, -0.06683499f, 
    -0.29754111f, 0.05536440f, -0.06539635f, -0.06170250f, -0.00966197f, -0.03252558f, -0.09075767f, 0.12513494f, 
    -0.04206523f, -0.08628973f, -0.09260998f, -0.01018725f, -0.24852176f, -0.09374734f, -0.17471300f, 0.16712387f, 
    -0.16531341f, -0.10358089f, 0.06414261f, -0.04583882f, -0.14255427f, 0.11901078f, -0.00112110f, 0.04180443f, 
    -0.16115977f, 0.02487028f, -0.07232597f, -0.08551752f, 0.01709673f, -0.05182191f, -0.19204165f, 0.00964770f, 
    -0.44023895f, 0.04420168f, -0.39736241f, 0.04799200f, 0.22131737f, 0.19628547f, -0.08565236f, 0.31044084f, 
    0.00872492f, 0.05049221f, 0.03508403f, -0.15802008f, 0.15369461f, 0.08650713f, -0.15277350f, -0.06294731f, 
    -0.15154466f, 0.17817438f, -0.06628785f, -0.10255767f, -0.04920650f, 0.07237425f, -0.05515305f, -0.00094498f, 
    -0.10556225f, 0.22619234f, 0.10428566f, 0.03507132f, -0.02808600f, 0.08663417f, 0.11668278f, 0.48562425f, 
    -0.04484239f, -0.11559259f, 0.01797104f, 0.01709224f, -0.01905580f, 0.01974988f, -0.26878566f, 0.02943979f, 
    -0.02004973f, -0.01722939f, -0.04996577f, 0.02839818f, 0.03232169f, -0.01409374f, -0.03685400f, 0.04670073f, 
    0.02475256f, -0.02327861f, -0.01625400f, 0.02638822f, 0.04061453f, -0.03752684f, 0.02751115f, 0.00206467f, 
    0.01210705f, -0.04749821f, -0.00121841f, -0.03967252f, -0.00973883f, 0.00800819f, -0.03518371f, 0.01425715f, 
    -0.00810680f, -0.02820087f, -0.01923069f, -0.04242326f, 0.03753914f, -0.01222981f, -0.04480507f, -0.00623159f, 
    -0.01039296f, 0.00481647f, 0.03632315f, 0.03093945f, 0.01543884f, -0.00728410f, -0.04870882f, -0.04758685f, 
    0.02121201f, 0.04333519f, 0.00361068f, -0.04075510f, -0.03037255f, -0.03971556f, -0.04291404f, 0.02129086f, 
    -0.02621847f, 0.00130578f, 0.03556652f, 0.03033199f, -0.04987172f, -0.03771985f, -0.01914141f, -0.00096259f, 
    0.02196500f, 0.00258146f, 0.02614120f, -0.00100120f, 0.02794119f, 0.04007351f, -0.04584706f, 0.01072739f, 
    -0.04585909f, 0.02589296f, -0.02543813f, 0.01390404f, 0.01758638f, 0.02403520f, -0.02519594f, -0.04682747f, 
    0.01342736f, -0.00674852f, -0.04650037f, -0.04500354f, -0.00905914f, -0.03535642f, -0.01538246f, -0.04074375f, 
    -0.01542866f, 0.02558604f, 0.03911688f, -0.04249384f, -0.02545565f, 0.02216942f, -0.00998222f, 0.00965806f, 
    -0.04459418f, -0.04382144f, -0.01150316f, -0.05479243f, 0.00152945f, -0.03154178f, 0.04132241f, 0.02759121f, 
    -0.05624967f, -0.01260267f, -0.01549869f, -0.02668481f, 0.01005095f, -0.01324632f, -0.02352784f, -0.03510550f, 
    0.04116485f, 0.04068251f, 0.00889581f, -0.05427398f, -0.03943055f, -0.02233918f, 0.01094176f, -0.02763461f, 
    0.02348104f, -0.01281525f, 0.00926181f, 0.04543609f, -0.01222372f, -0.05370301f, 0.01675518f, -0.03260775f, 
    -0.02739150f, 0.00884496f, 0.00663212f, 0.04220662f, -0.05002705f, -0.00994938f, -0.00014710f, -0.03758220f, 
    -0.02318481f, 0.04508964f, 0.03303171f, 0.03020966f, 0.03859071f, 0.04471483f, -0.01712414f, -0.03563316f, 
    -0.04494170f, 0.02458243f, 0.03323383f, -0.01871747f, 0.00443524f, 0.00038476f, 0.02884543f, -0.03944964f, 
    -0.01876623f, -0.00858998f, 0.02874863f, -0.04340522f, -0.03708627f, 0.03140856f, -0.05336994f, 0.00333214f, 
    -0.01146131f, 0.04206969f, -0.03469054f, 0.04751976f, 0.02170124f, -0.02038393f, -0.04387673f, -0.05360071f, 
    -0.02115295f, 0.01902996f, -0.01608604f, -0.03386596f, 0.03364025f, -0.00250158f, 0.03316165f, -0.01111253f, 
    -0.02419745f, 0.03752654f, -0.00981747f, -0.04909578f, -0.00140621f, 0.02730405f, 0.04180304f, -0.00666286f, 
    -0.04509953f, -0.02862512f, 0.02899973f, 0.02810133f, -0.04208041f, 0.02559635f, 0.04052313f, 0.01453826f, 
    -0.03796949f, 0.00531456f, 0.02755968f, 0.03563249f, 0.01195545f, -0.02216217f, -0.00050425f, -0.01442385f, 
    -0.04308249f, -0.00737540f, 0.00142182f, 0.03822802f, -0.05028968f, 0.01835143f, 0.01745754f, -0.01773930f, 
    -0.02882783f, 0.00592263f, -0.01920096f, -0.05167620f, -0.02864728f, 0.04134189f, -0.03588794f, 0.00415118f, 
    0.00830859f, -0.02335688f, -0.01488593f, 0.01780888f, -0.01992772f, -0.04974052f, 0.03698889f, 0.03439436f, 
    -0.04687557f, -0.05252472f, -0.03691399f, -0.01270656f, 0.04218253f, -0.03829589f, 0.04751703f, 0.00097578f, 
    -0.02380269f, 0.04453690f, -0.03199286f, 0.01494034f, -0.03344198f, 0.02687345f, -0.04787363f, -0.01761036f, 
    -0.00349123f, -0.02969887f, 0.01416259f, 0.04214819f, 0.03763918f, 0.05039100f, -0.04169279f, -0.01274351f, 
    -0.00738144f, 0.03686424f, 0.04402202f, -0.03798356f, -0.00743986f, -0.00139911f, 0.02326357f, -0.04665542f, 
    0.04476655f, -0.03644557f, 0.01099406f, -0.05038469f, 0.02514895f, -0.05065506f, -0.04746971f, -0.03892532f, 
    0.00384446f, -0.03883443f, 0.01481794f, 0.00676953f, -0.02702099f, 0.04377871f, -0.05165430f, 0.00800409f, 
    0.00051883f, 0.02756249f, 0.03993138f, -0.01995936f, 0.01960723f, -0.03875785f, -0.03399900f, 0.00340041f, 
    -0.04762295f, 0.03594887f, -0.04403087f, -0.03140871f, -0.03842997f, -0.04530280f, -0.04100284f, 0.03434961f, 
    -0.03502275f, -0.04556011f, 0.00383860f, 0.01788509f, 0.03105664f, -0.00548028f, -0.05333496f, 0.01778268f, 
    -0.00472667f, 0.00192861f, -0.03175476f, -0.05334716f, -0.04587592f, -0.01953156f, -0.04710993f, -0.03664200f, 
    -0.02392323f, 0.02017595f, -0.02234604f, 0.02305547f, 0.02203911f, -0.04358457f, 0.02086328f, -0.02516039f, 
    -0.05478223f, 0.00628639f, -0.01912611f, -0.03474225f, 0.00588578f, -0.05350899f, -0.00187283f, 0.00051087f, 
    -0.00285462f, 0.01482461f, -0.05533263f, 0.01225410f, 0.02979385f, 0.00765543f, -0.05179847f, -0.02322303f, 
    0.01527845f, 0.03448059f, -0.03405977f, -0.03860835f, -0.02800876f, 0.00824154f, 0.01834637f, -0.00091614f, 
    0.02254760f, 0.01176920f, -0.04877885f, 0.03689987f, 0.01428456f, -0.02155193f, -0.00276832f, -0.04128742f, 
    0.04076836f, -0.04977208f, 0.01511806f, 0.01165764f, 0.02985005f, 0.00571852f, -0.01249379f, -0.01301987f, 
    -0.02706488f, 0.02692426f, 0.04521373f, -0.04803387f, -0.02317725f, 0.01779062f, 0.01468056f, -0.00505151f, 
    0.04522759f, -0.01017915f, -0.03064586f, -0.02483543f, 0.02496182f, 0.03984443f, -0.02573360f, -0.05319035f, 
    -0.02147048f, -0.03820882f, 0.02241559f, -0.02362521f, -0.02241898f, -0.03443904f, -0.03574222f, -0.01185223f, 
    -0.03340578f, 0.02508745f, -0.00617013f, 0.01994549f, -0.02770570f, 0.03493701f, 0.00898026f, -0.00099272f, 
    0.03879638f, -0.03069897f, 0.01053354f, 0.04079013f, -0.01497071f, 0.02283688f, 0.03563409f, -0.05149289f, 
    0.21295039f, 0.17690398f, 0.09627356f, -0.07857244f, 0.02666977f, 0.03080030f, 0.02450323f, -0.10943954f, 
    0.06991155f, -0.01488420f, -0.02811558f, 0.01230433f, -0.09403790f, 0.10524200f, -0.14572412f, -0.06269225f, 
    -0.16756035f, 0.02487753f, -0.09261400f, 0.03097450f, 0.08323894f, 0.10287818f, -0.08150537f, 0.00945273f, 
    0.02496354f, -0.02105759f, -0.06052399f, -0.07635867f, -0.01200836f, 0.03367606f, 0.19282646f, 0.12122520f, 
    0.02405776f, -0.00328419f, -0.05045075f, -0.04420630f, 0.13801743f, 0.12985276f, 0.21906255f, 0.14322546f, 
    0.16564015f, 0.01384966f, 0.13004039f, -0.03762640f, -0.04651705f, 0.05930531f, 0.11454870f, 0.03406312f, 
    0.25139010f, -0.22014654f, -0.10723042f, 0.11702078f, -0.09378231f, 0.03831121f, 0.10277802f, 0.13961293f, 
    -0.01662981f, -0.01758008f, 0.04408598f, 0.01642825f, -0.47600439f, 0.01336760f, -0.03256201f, -0.16095826f, 
    0.05909285f, 0.13916469f, -0.02683241f, -0.07537815f, -0.11536929f, -0.04789121f, 0.18418634f, 0.00295595f, 
    -0.06130547f, 0.05737694f, 0.12936133f, 0.13783239f, -0.00459590f, -0.04880564f, -0.09882811f, -0.21360347f, 
    0.14828256f, -0.12271171f, -0.01406637f, 0.23327087f, 0.02499369f, -0.00877272f, 0.33746275f, -0.01761497f, 
    -0.08910400f, -0.00087214f, -0.10446659f, -0.01942290f, 0.02375892f, -0.01745466f, 0.20360929f, 0.01852776f, 
    0.09569534f, -0.13750763f, -0.13241366f, -0.09230044f, -0.06573315f, -0.00478730f, -0.01049301f, 0.15868428f, 
    -0.06718265f, -0.05234261f, -0.13685803f, -0.08775498f, -0.18411890f, 0.09506088f, 0.15106310f, 0.07000222f, 
    -0.04582328f, -0.07556442f, -0.06474326f, 0.02472295f, 0.15520413f, -0.13800707f, -0.07144307f, -0.01732257f, 
    -0.02458329f, 0.19978374f, -0.00477789f, -0.03863792f, -0.01931295f, 0.07988534f, 0.18685804f, 0.00222091f, 
    0.00814697f, -0.05164885f, 0.09583284f, 0.15393296f, 0.12305130f, 0.03881472f, 0.17525040f, 0.14980268f, 
    -0.01398366f, -0.01860732f, -0.11171359f, 0.00285565f, -0.14295430f, 0.00791726f, -0.05260976f, -0.01406231f, 
    -0.01527118f, -0.09105947f, 0.13951440f, -0.18988046f, -0.05365322f, -0.06007736f, -0.00424591f, 0.11737153f, 
    -0.00017248f, 0.03682382f, 0.02986344f, -0.06134286f, -0.05096649f, 0.11038194f, -0.02118093f, 0.06684866f, 
    -0.06615274f, -0.07548774f, -0.00087115f, 0.01625922f, 0.02469922f, -0.06146584f, 0.06422618f, 0.11714333f, 
    -0.11544368f, -0.07830895f, -0.10649990f, 0.00281296f, 0.14250055f, -0.00927745f, 0.14050965f, 0.14685684f, 
    -0.18945868f, 0.03092109f, 0.03783783f, -0.10907537f, 0.16832295f, 0.08398137f, 0.11381442f, -0.11220586f, 
    -0.09771693f, 0.06183136f, -0.04872066f, -0.05496141f, -0.01354678f, 0.05197561f, -0.00363085f, -0.02118994f, 
    -0.19103837f, -0.20610131f, 0.02930283f, -0.02821481f, -0.07845284f, 0.01794234f, 0.08151343f, 0.17792277f, 
    0.08305102f, 0.18253359f, 0.07688469f, 0.00883708f, -0.10557533f, 0.08886921f, -0.12551430f, -0.17915881f, 
    0.08454673f, 0.08872424f, -0.01875697f, -0.20255491f, 0.03730151f, -0.00238997f, -0.04514510f, 0.11220805f, 
    -0.25470826f, 0.03539483f, 0.00621284f, 0.27016988f, -0.06072859f, -0.04545492f, 0.07687467f, -0.03452737f, 
    0.20706169f, 0.02746298f, 0.02227093f, 0.01620271f, 0.03451288f, 0.02093266f, 0.35378909f, -0.01573497f, 
    0.07214411f, 0.10703768f, 0.11385581f, 0.19759890f, 0.10659762f, 0.02837217f, 0.17056882f, 0.01127520f, 
    0.29388472f, 0.05297532f, 0.44645900f, 0.24885657f, 0.10395987f, 0.18737143f, 0.21688068f, 0.13742325f, 
    0.13707912f, -0.13550791f, 0.16168758f, 0.09765330f, -0.01997050f, -0.03395309f, 0.00127018f, -0.01655458f, 
    0.04917607f, -0.08482353f, -0.10136810f, -0.14124314f, 0.06731003f, 0.00248078f, 0.00681449f, -0.01758828f, 
    0.01809731f, -0.01682442f, -0.24369296f, -0.17692886f, 0.09135118f, 0.08615643f, 0.03747761f, 0.17283018f, 
    0.12437636f, 0.04695482f, 0.01484706f, -0.03696284f, -0.05580297f, 0.33756959f, -0.19292250f, 0.34665516f, 
    -0.03622427f, -0.11793248f, 0.00553241f, -0.03908255f, -0.09023197f, -0.10932060f, 0.02648770f, -0.06711640f, 
    0.06776796f, 0.15422364f, -0.16221629f, 0.00246320f, 0.08694813f, 0.19122434f, -0.05491757f, -0.15391897f, 
    0.07613388f, 0.04363157f, 0.01930621f, 0.02973995f, 0.05617414f, 0.11142219f, -0.03828287f, -0.01284387f, 
    0.14178996f, 0.10498840f, 0.27459019f, -0.09680274f, -0.11262271f, 0.02610729f, -0.08588929f, -0.04904313f, 
    0.11025954f, 0.01355500f, 0.31121334f, -0.01135739f, -0.01156422f, 0.01282104f, 0.03105626f, 0.02015200f, 
    -0.05177327f, 0.13085638f, -0.00148392f, -0.05073158f, 0.09132203f, 0.36017847f, -0.16081597f, 0.36116612f, 
    0.01904297f, -0.04574687f, 0.01524826f, 0.15029339f, -0.02220948f, -0.08345462f, 0.06873122f, -0.10631757f, 
    0.17987306f, -0.00926255f, 0.15068485f, -0.11425991f, -0.06862139f, 0.10172424f, -0.00410514f, 0.05748945f, 
    -0.12154012f, 0.01927340f, 0.00428475f, -0.16215889f, 0.06564982f, 0.19726923f, -0.28242016f, -0.11558548f, 
    -0.00325452f, 0.14828086f, -0.08944231f, 0.18082829f, 0.10415051f, 0.08023742f, 0.02200247f, 0.02804925f, 
    -0.17007597f, -0.06217527f, 0.00439359f, -0.36242050f, -0.06314833f, 0.00946048f, 0.03680642f, 0.09718044f, 
    -0.15721026f, -0.09434451f, 0.05570370f, -0.13812575f, -0.26241469f, 0.25670192f, 0.19266401f, -0.19700745f, 
    0.08547012f, 0.01024115f, 0.10831626f, 0.09887937f, 0.08146760f, 0.15354067f, 0.20060447f, 0.31046763f, 
    0.01082567f, -0.03875972f, -0.18739238f, -0.05969426f, 0.00247530f, -0.05734764f, -0.02293469f, 0.01649369f, 
    -0.03116864f, 0.07218175f, 0.03869457f, -0.02879463f, 0.21655704f, 0.05562849f, 0.03118462f, 0.08469690f, 
    0.01486602f, -0.06347470f, 0.07295267f, -0.03988799f, -0.05088864f, 0.08602146f, 0.04375187f, -0.06738596f, 
    -0.00779510f, 0.23226872f, 0.06564849f, -0.03526433f, -0.00604716f, 0.06738514f, -0.13817847f, 0.04338114f, 
    0.00954629f, 0.09667355f, 0.08191445f, -0.00363614f, 0.07492992f, -0.19062485f, 0.05494600f, -0.06571818f, 
    -0.08596285f, 0.02845053f, 0.06517291f, -0.03440815f, 0.09565647f, 0.02797589f, 0.00247437f, -0.03922837f, 
    0.15840742f, 0.09966054f, 0.03761464f, -0.27327073f, 0.00137352f, 0.00284544f, 0.19040427f, -0.05918577f, 
    0.02269050f, 0.01520744f, 0.03964515f, 0.06128999f, 0.23886788f, 0.14551361f, 0.00282808f, 0.13103330f, 
    -0.21355247f, -0.09611131f, -0.09575474f, 0.07321262f, 0.03295843f, -0.10769001f, -0.00172790f, -0.06762843f, 
    -0.01055470f, 0.13280906f, 0.00483908f, -0.03928095f, -0.13767929f, -0.04764052f, 0.06632597f, 0.05132507f, 
    0.06813402f, 0.08586156f, 0.00600526f, 0.01245678f, -0.18040878f, 0.05489915f, 0.16939443f, 0.13069974f, 
    0.10181180f, -0.00218514f, 0.08716397f, -0.17288716f, 0.03533961f, -0.06908350f, -0.11661069f, 0.05253191f, 
    -0.05758211f, 0.05419758f, -0.09025810f, -0.12402426f, 0.04837887f, -0.12317897f, 0.09249649f, -0.02555939f, 
    0.06553998f, -0.02175903f, -0.11755590f, 0.09086932f, 0.60392010f, 0.08670961f, 0.02390682f, 0.14011465f, 
    -0.11517964f, -0.01510797f, 0.04477537f, -0.08315238f, -0.05841441f, 0.01301061f, 0.03343157f, 0.05596500f, 
    0.10925685f, -0.02401779f, -0.13433960f, -0.01927381f, 0.18146560f, -0.02065555f, 0.07054634f, 0.09552595f, 
    -0.05458024f, 0.10884350f, -0.00831075f, -0.05139229f, 0.19660252f, -0.20699334f, -0.05978502f, -0.05444684f, 
    -0.06005673f, -0.10109312f, 0.14672825f, 0.00185422f, 0.00702629f, 0.04571505f, -0.00748345f, -0.02681428f, 
    -0.30295449f, 0.02920243f, -0.18470947f, 0.09228025f, 0.07328743f, 0.02844797f, 0.06260063f, -0.01840263f, 
    -0.03119868f, -0.02395457f, 0.04932941f, 0.01982959f, 0.30645531f, 0.12233840f, 0.05919600f, 0.12902816f, 
    -0.06359422f, 0.04394963f, -0.03747666f, -0.00271253f, 0.03449906f, 0.02795954f, -0.00699509f, -0.10317595f, 
    -0.14714348f, -0.06246344f, -0.11434645f, -0.15514679f, -0.08204707f, 0.05557302f, -0.09713067f, 0.01411059f, 
    0.11837190f, -0.19328091f, -0.09574796f, -0.05448744f, -0.11247212f, 0.07327178f, 0.10688245f, -0.16307448f, 
    0.12654532f, 0.03879064f, 0.17501701f, 0.11570528f, 0.04725156f, 0.00701408f, -0.10436918f, -0.12194206f, 
    -0.14163683f, 0.02625060f, 0.18469563f, -0.33542359f, 0.01385322f, 0.02910327f, -0.17708318f, -0.10533129f, 
    0.00105921f, -0.10447827f, -0.05945230f, 0.02376266f, 0.04381105f, 0.18094695f, 0.05303611f, 0.08961130f, 
    0.03988244f, -0.02027825f, 0.05666605f, 0.10486152f, -0.02399527f, 0.04705622f, -0.00767323f, -0.04721165f, 
    0.50336760f, 0.12084626f, 0.15946949f, -0.21254113f, -0.09646979f, 0.10641576f, 0.11160633f, 0.06708968f, 
    -0.05261102f, -0.15400016f, -0.04679996f, 0.10307251f, -0.59419960f, 0.50196898f, 0.02917192f, 0.06835119f, 
    -0.09381952f, 0.04684333f, -0.03883604f, -0.22213459f, -0.12157989f, -0.04175063f, 0.09482951f, 0.00872070f, 
    -0.44959125f, 0.30184129f, -0.09535964f, -0.06476302f, 0.10927721f, -0.07307191f, 0.09887734f, -0.20649128f, 
    0.13444848f, 0.11071637f, -0.05287284f, -0.08969252f, 0.00261376f, -0.04036530f, -0.00583289f, -0.04502174f, 
    0.02683906f, 0.12168477f, -0.00315334f, -0.00635076f, -0.03018468f, -0.05088073f, 0.00266496f, 0.09500923f, 
    0.14274107f, 0.09766250f, -0.00208999f, -0.04077148f, -0.05950569f, -0.02942578f, -0.01155046f, -0.03927763f, 
    0.01550760f, 0.00676725f, 0.12562647f, -0.06761931f, 0.23169136f, -0.09485567f, 0.15504849f, 0.08768039f, 
    -0.05859094f, 0.02842387f, 0.11946623f, -0.02173309f, -0.08506722f, -0.00771410f, 0.01744382f, -0.01188065f, 
    0.09740753f, 0.08910694f, 0.09708975f, 0.07672590f, -0.15740076f, -0.10610367f, -0.07337726f, 0.11971652f, 
    0.04017860f, 0.05228563f, -0.03946158f, 0.03611260f, 0.05833332f, 0.17227605f, 0.13673751f, 0.01321172f, 
    -0.11348187f, -0.04706263f, -0.00153243f, 0.20791782f, -0.09427016f, 0.00990131f, 0.10006263f, -0.09481446f, 
    -0.30754396f, 0.24068384f, -0.08984683f, 0.07211451f, 0.00754424f, 0.00340472f, 0.00411522f, 0.14544997f, 
    0.00612860f, -0.17724600f, -0.03316621f, 0.02614704f, 0.23086886f, -0.05311851f, 0.19396353f, 0.11722162f, 
    -0.04470614f, -0.03317261f, 0.06783499f, -0.06146660f, 0.10790654f, 0.09879773f, 0.01271109f, 0.10423592f, 
    0.06516074f, 0.16923098f, -0.19423653f, 0.03820355f, 0.01859149f, -0.13546331f, 0.00588332f, -0.03587232f, 
    -0.12375467f, 0.01502777f, -0.21659663f, 0.29301512f, -0.03801703f, -0.01114815f, 0.08695356f, 0.14070648f, 
    -0.02883235f, 0.02261009f, 0.05616911f, -0.01936657f, 0.06999352f, 0.13733979f, -0.06780087f, -0.10895360f, 
    -0.03278430f, 0.32433042f, 0.01636718f, 0.06715585f, -0.11021935f, -0.02261752f, -0.02503187f, -0.07516176f, 
    0.08328109f, 0.04564650f, 0.01362705f, 0.05217663f, 0.21115300f, -0.07455646f, 0.19637196f, 0.44212911f, 
    -0.13879721f, 0.06094513f, -0.04627768f, -0.03695223f, 0.12754789f, 0.09512970f, -0.16632713f, -0.02824879f, 
    0.08030878f, 0.03557391f, 0.10752729f, 0.26015347f, -0.04686286f, 0.15088746f, 0.12298629f, 0.11306553f, 
    -0.04582253f, 0.03700509f, -0.04345912f, -0.04822901f, 0.01885034f, 0.16145156f, 0.02469476f, 0.06420084f, 
    -0.02638452f, 0.02431211f, 0.04008783f, -0.01849394f, 0.09024619f, -0.01785126f, 0.12008334f, 0.09954454f, 
    0.05392422f, 0.24209267f, 0.18982762f, 0.10159317f, 0.10498903f, -0.01823589f, 0.11113226f, -0.01055535f, 
    -0.04923183f, 0.10511457f, -0.10512815f, 0.14728352f, -0.12567960f, 0.19531171f, 0.08027421f, 0.11820246f, 
    -0.03423310f, 0.05318044f, -0.18487307f, 0.01997365f, -0.08045784f, 0.06476299f, -0.03206368f, 0.06254025f, 
    0.04094145f, -0.05888289f, 0.24279064f, 0.00460888f, 0.08676273f, 0.02264023f, -0.03114286f, 0.06063400f, 
    -0.08798857f, 0.00375831f, -0.01590539f, 0.02898725f, -0.00739529f, 0.22774829f, 0.07696740f, -0.04859478f, 
    0.25789335f, 0.24114768f, 0.19440541f, 0.06243761f, 0.01898594f, 0.05122653f, 0.13903062f, 0.17492235f, 
    -0.15371621f, 0.07437319f, 0.04102786f, -0.02837821f, 0.12872359f, 0.18420491f, 0.09858875f, -0.01868046f, 
    0.03026184f, 0.05539416f, 0.11848743f, 0.01110249f, -0.16784438f, -0.07706410f, 0.01247830f, 0.08083553f, 
    0.01516020f, -0.07779291f, -0.01896587f, -0.01536441f, 0.15195292f, -0.00018014f, 0.04136404f, 0.05995081f, 
    -0.02037690f, 0.14904007f, 0.16482514f, 0.05550339f, -0.04057526f, -0.00268699f, -0.09075560f, -0.09635059f, 
    0.04636694f, -0.04560623f, 0.04878156f, 0.04906896f, -0.38624594f, 0.04900692f, -0.11960581f, -0.17757329f, 
    -0.08425111f, 0.01515022f, 0.01491362f, -0.13912061f, -0.11941875f, -0.11330887f, -0.22773029f, 0.07147071f, 
    0.09041257f, 0.26903960f, 0.04269202f, 0.33263740f, 0.00606092f, 0.08167564f, 0.07399511f, 0.06981464f, 
    -0.03472839f, 0.03640652f, -0.00098275f, 0.01924728f, 0.05908886f, -0.22922142f, -0.09670103f, 0.12538788f, 
    0.02445167f, -0.05130320f, -0.03518520f, -0.03711462f, 0.04634387f, -0.07913464f, -0.09583268f, -0.04368192f, 
    0.29788977f, 0.32595620f, 0.29489347f, 0.15537930f, 0.09395114f, 0.02018910f, 0.12724127f, -0.09266788f, 
    -0.02207698f, -0.05820426f, 0.00078636f, -0.03626498f, -0.09199572f, -0.10367965f, -0.23370180f, 0.06149811f, 
    -0.07504493f, -0.07827249f, -0.06674337f, -0.07514645f, 0.02051160f, 0.01714508f, 0.03878105f, -0.04970966f, 
    -0.08263659f, 0.10524104f, 0.14256768f, -0.03335927f, 0.01884999f, 0.00139101f, 0.05913091f, 0.01565247f, 
    0.05080834f, 0.02016457f, -0.03713226f, -0.00506842f, 0.55686289f, 0.20343301f, 0.02756352f, 0.19175048f, 
    0.05018597f, -0.00256730f, 0.10222153f, -0.05063610f, -0.03594767f, 0.00129314f, -0.00901333f, -0.07532633f, 
    0.37602729f, 0.08551362f, 0.18234323f, -0.00667223f, 0.01893179f, -0.03635016f, 0.02206278f, 0.01052816f, 
    0.00472094f, -0.04232835f, -0.04136667f, 0.00679766f, 0.47969285f, 0.47746262f, 0.28846896f, 0.39022461f, 
    0.05018577f, 0.10260085f, -0.00646664f, 0.29432398f, 0.05435765f, -0.04896144f, 0.03460708f, -0.09678806f, 
    0.22124380f, 0.21391372f, -0.10403688f, -0.19177553f, 0.04247088f, 0.08703356f, 0.04309180f, -0.08320800f, 
    -0.04877673f, -0.02394754f, 0.12392652f, -0.09034305f, 0.03615309f, 0.31035927f, 0.43681809f, 0.29083091f, 
    -0.02791417f, 0.13636018f, -0.11014043f, -0.03216128f, -0.08920598f, -0.07113519f, -0.10720138f, 0.07630426f, 
    0.01064881f, 0.12732415f, 0.23316669f, 0.02635139f, -0.11651349f, 0.03880078f, -0.13243748f, -0.00280811f, 
    -0.15912063f, -0.01317460f, 0.04538422f, -0.11946481f, -0.06785024f, -0.15455677f, -0.10195366f, -0.13824600f, 
    0.08231576f, 0.03176905f, 0.07062452f, -0.02426617f, 0.11002862f, 0.07670145f, 0.08897130f, -0.05575807f, 
    0.21574196f, -0.03114586f, 0.09909546f, 0.11192227f, 0.08229510f, -0.11023219f, 0.05172356f, 0.04743644f, 
    0.01064951f, -0.00747120f, -0.11603430f, 0.07801331f, -0.18579933f, -0.21518545f, -0.31265005f, -0.21136351f, 
    0.00159616f, -0.05345714f, -0.03382398f, -0.01674603f, -0.01449080f, 0.06045520f, -0.04593394f, 0.05562722f, 
    0.20042370f, 0.31120279f, 0.02915564f, 0.23390849f, -0.08067948f, 0.06963632f, -0.03025365f, 0.09910879f, 
    0.12043967f, 0.06587017f, -0.07710279f, -0.02397376f, 0.37411118f, 0.40210086f, 0.08313138f, 0.30019051f, 
    -0.10566566f, -0.01310011f, -0.15842912f, 0.17743190f, 0.02994339f, 0.04421582f, 0.04421186f, -0.04131704f, 
    -0.25515690f, -0.00141572f, 0.09543756f, -0.09049255f, -0.08558696f, -0.03461654f, 0.11654153f, 0.00478962f, 
    0.10854538f, 0.02234941f, -0.02651456f, -0.00539439f, -0.35757262f, -0.15651092f, -0.20484072f, 0.01097207f, 
    -0.07368592f, -0.13916333f, -0.00991851f, -0.07635667f, -0.12708810f, 0.15711045f, -0.02266620f, 0.13123761f, 
    -0.06700201f, -0.17244835f, -0.16608301f, 0.08589198f, 0.00582755f, -0.04271956f, -0.07082526f, -0.10964063f, 
    0.05973887f, 0.00212573f, 0.06032874f, 0.00162144f, 0.15509169f, 0.07990994f, 0.13907821f, 0.01413744f, 
    0.02354154f, 0.00183527f, -0.17563386f, 0.07845385f, -0.04357953f, 0.03101047f, -0.00804027f, 0.02071317f, 
    -0.03453962f, -0.06053650f, 0.09607689f, 0.05388716f, -0.04684934f, -0.05419236f, -0.07282472f, -0.09045403f, 
    -0.03702715f, -0.11127376f, -0.08254154f, -0.01427661f, 0.00369314f, 0.15202574f, -0.03495006f, 0.14272238f, 
    -0.00124117f, -0.00005251f, 0.04264209f, -0.11447259f, -0.11641767f, -0.15440725f, 0.10591378f, 0.03090400f, 
    -0.07828552f, -0.29461002f, -0.01959961f, 0.25853303f, -0.02041876f, 0.01361488f, -0.04265532f, -0.01478539f, 
    0.00436876f, -0.05670493f, -0.14884952f, -0.01568680f, 0.05700474f, 0.03692696f, -0.14181900f, -0.09083058f, 
    0.04305230f, -0.00924023f, 0.08592939f, 0.07668640f, -0.01816949f, 0.21838300f, 0.12482011f, 0.11617854f, 
    -0.08408194f, -0.07956064f, -0.01496683f, 0.12804298f, 0.05047193f, -0.02592499f, 0.19373001f, 0.08143217f, 
    0.03748044f, 0.03600225f, -0.03622415f, 0.10580166f, -0.18314627f, -0.11001473f, 0.09362067f, 0.16136423f, 
    -0.09028795f, 0.07236900f, -0.04916308f, -0.03437503f, -0.03948169f, -0.09743932f, 0.16079816f, 0.05989087f, 
    -0.18222131f, -0.16347487f, 0.36931100f, 0.10931230f, -0.05433651f, 0.00436609f, 0.08325709f, 0.17000316f, 
    -0.02348902f, -0.08991437f, 0.17412531f, -0.01272999f, 0.11462419f, -0.00866392f, -0.07772513f, 0.10236013f, 
    -0.03571727f, -0.06997416f, -0.06021707f, 0.28899193f, 0.01107284f, -0.04728016f, 0.04923391f, -0.04152015f, 
    0.15221155f, -0.02157849f, -0.15966596f, -0.09161560f, 0.00171163f, -0.05955399f, 0.04662313f, -0.01105818f, 
    0.05459540f, -0.01980680f, 0.04543816f, 0.00001523f, 0.18738315f, 0.15812521f, 0.03078219f, -0.16444360f, 
    -0.08849800f, 0.11619850f, 0.03750768f, -0.03747225f, 0.13525429f, 0.01016400f, 0.03477730f, -0.00493754f, 
    -0.05478272f, -0.04579862f, -0.08019681f, -0.03720367f, 0.09366237f, -0.02188996f, -0.00262516f, -0.00243028f, 
    -0.00404555f, -0.15146856f, -0.12297762f, 0.04352721f, -0.13360660f, 0.09075928f, -0.22320575f, -0.24483310f, 
    0.06559259f, -0.04088766f, -0.11136217f, -0.06393848f, 0.13786802f, 0.06918235f, -0.05560956f, 0.04955851f, 
    -0.04589176f, -0.09616832f, -0.04156067f, 0.18315414f, 0.11377229f, 0.05867720f, 0.16710418f, 0.00043749f, 
    -0.00890533f, 0.06179248f, 0.00348258f, 0.02137184f, 0.16168371f, 0.24893673f, 0.23720339f, -0.02742589f, 
    -0.02126113f, 0.01104497f, -0.03241818f, -0.08776181f, -0.04361536f, 0.10329774f, 0.00720767f, 0.06812639f, 
    0.01502861f, -0.17546220f, -0.24034370f, 0.14970572f, 0.03215122f, -0.01247724f, 0.13342206f, -0.10100298f, 
    -0.03113930f, -0.01141815f, 0.00415577f, -0.03045126f, 0.01083505f, 0.16151315f, -0.02170256f, -0.13011675f, 
    0.03304261f, 0.04356812f, -0.01870897f, 0.07149675f, 0.00047382f, -0.03895267f, 0.12690841f, 0.03555978f, 
    -0.15086825f, 0.00176266f, -0.01888444f, 0.03306411f, 0.04811043f, 0.10722357f, 0.04945121f, -0.05081546f, 
    0.02767082f, -0.04667091f, 0.01798778f, -0.04278196f, -0.01937492f, -0.05534450f, 0.15350173f, 0.17113252f, 
    -0.00129512f, -0.10349466f, 0.03021078f, 0.18273571f, 0.05654819f, -0.03278754f, -0.08613902f, 0.01610292f, 
    0.29297772f, 0.07290423f, -0.08605009f, -0.07689585f, -0.04892834f, 0.03976647f, 0.04900654f, -0.04284962f, 
    0.06818137f, -0.18421385f, 0.15222965f, 0.00196823f, -0.05510658f, -0.01888865f, 0.20598784f, 0.34213409f, 
    -0.07622299f, 0.10562444f, -0.04714217f, 0.05608097f, 0.00271197f, 0.15239298f, -0.01380369f, 0.08171179f, 
    -0.00925199f, 0.19393998f, -0.02459506f, 0.28299296f, 0.01734590f, -0.04216427f, 0.11002933f, -0.09361488f, 
    -0.07979129f, -0.11002482f, 0.02875948f, 0.07430445f, 0.08865010f, 0.24044572f, 0.25157669f, 0.19947074f, 
    0.05498801f, 0.09652368f, 0.04618076f, -0.02973416f, -0.12436816f, -0.08009806f, 0.05711360f, 0.04221295f, 
    -0.03298691f, 0.06123780f, 0.46273005f, 0.17565401f, 0.16250759f, 0.15777689f, 0.10394593f, 0.00286714f, 
    0.02648867f, -0.00898302f, -0.03537121f, -0.02739138f, 0.08997661f, 0.10557614f, 0.11633177f, -0.15559454f, 
    0.06120649f, 0.18741046f, 0.10881274f, 0.00288287f, 0.02813013f, 0.02438323f, -0.01359930f, 0.10354059f, 
    -0.25235614f, -0.06566303f, 0.07558970f, 0.10770901f, -0.11086246f, -0.22134373f, 0.10160600f, 0.20075563f, 
    0.03234742f, 0.00424864f, -0.02380550f, 0.03809657f, 0.00111028f, 0.21632190f, -0.03583595f, -0.00546831f, 
    -0.01372919f, 0.01484287f, 0.05622215f, -0.10326564f, -0.02927172f, -0.00734325f, 0.00803422f, 0.02443125f, 
    -0.15492411f, -0.12077376f, -0.08025283f, 0.30658689f, -0.15159383f, 0.04101237f, 0.03933277f, -0.01064383f, 
    -0.02125043f, 0.12393851f, 0.06126745f, 0.07059730f, 0.04696987f, 0.09497185f, 0.21436325f, 0.21960285f, 
    -0.07772193f, -0.21705835f, -0.08724978f, 0.04177952f, -0.03740646f, 0.10467002f, -0.00135268f, 0.01327765f, 
    0.15716542f, 0.09515205f, 0.01801252f, -0.08256894f, 0.07653625f, -0.01403838f, 0.14629371f, 0.06809043f, 
    -0.11712729f, 0.05335984f, 0.03872965f, -0.08128774f, 0.02226513f, 0.32715267f, -0.04748618f, 0.24516118f, 
    -0.08916561f, -0.03575061f, 0.14860044f, 0.03166564f, 0.04641986f, -0.03630185f, 0.06145356f, 0.07824092f, 
    0.19183172f, 0.26919565f, 0.05772107f, -0.02914468f, -0.01761122f, -0.06817571f, 0.00400672f, -0.06098189f, 
    0.03269979f, -0.03241364f, 0.06001057f, 0.13647111f, -0.45199797f, -0.20370945f, 0.27764642f, -0.01082889f, 
    -0.05826711f, 0.20340057f, -0.06920163f, -0.00234096f, -0.01708291f, 0.03199789f, 0.03446640f, -0.01303384f, 
    0.20532364f, -0.07460194f, -0.21748328f, -0.27894938f, -0.01615327f, -0.07317943f, -0.02977367f, -0.10804512f, 
    0.06687950f, -0.08099114f, -0.03687013f, -0.08893790f, 0.23500390f, -0.00178791f, 0.10379584f, 0.21252912f, 
    0.05903517f, -0.01839860f, 0.11708988f, 0.02988355f, -0.06253269f, 0.08188582f, 0.16227256f, -0.08601970f, 
    -0.06752881f, -0.19911359f, -0.03138720f, 0.12025830f, -0.04306962f, 0.04602223f, 0.05734174f, -0.04507035f, 
    -0.09470750f, 0.02625610f, -0.06705579f, -0.10740794f, 0.03992829f, 0.02678960f, 0.01621605f, -0.07615054f, 
    -0.05451934f, -0.04310599f, 0.03522952f, -0.11985388f, -0.05468605f, 0.17056720f, 0.14466824f, 0.01717111f, 
    0.10641234f, -0.07162172f, 0.05423034f, 0.01443685f, 0.06408265f, -0.10684795f, -0.02173672f, -0.12767714f, 
    0.00238088f, -0.00131827f, -0.03687751f, 0.05039892f, -0.23744547f, 0.12102381f, -0.17035486f, -0.01575773f, 
    0.10683230f, 0.05546421f, -0.08288834f, -0.02257669f, -0.01189364f, 0.03426544f, 0.00837142f, 0.10349765f, 
    -0.16417274f, 0.07343005f, 0.19627889f, 0.24810256f, 0.06129316f, 0.04499419f, 0.11514525f, 0.07756972f, 
    -0.08902169f, 0.04967385f, 0.03252590f, -0.02940325f, -0.04271913f, 0.05833650f, 0.05073115f, -0.07839952f, 
    0.19636245f, 0.11198646f, -0.03304748f, -0.00444831f, -0.15864658f, -0.09411573f, 0.11594846f, 0.11040875f, 
    -0.35913557f, 0.17381154f, 0.01119860f, -0.01520537f, 0.25173375f, 0.05389638f, -0.17489576f, 0.05563345f, 
    0.06874561f, 0.17399113f, 0.10647970f, 0.11507226f, -0.14951788f, 0.14573961f, 0.00916569f, -0.04926549f, 
    0.01365660f, -0.05380929f, -0.03467257f, 0.03254883f, 0.20268193f, 0.13061260f, 0.05761445f, 0.13044521f, 
    -0.08642736f, -0.11458215f, 0.04716908f, -0.06996954f, 0.02484391f, -0.08821458f, -0.01478327f, 0.12501778f, 
    -0.05132109f, 0.03704425f, -0.13778569f, -0.02907998f, -0.51390135f, 0.17009452f, -0.18845131f, -0.04855793f, 
    -0.03991548f, 0.04509315f, -0.06469674f, -0.10969326f, -0.09627292f, -0.03851331f, -0.23126544f, -0.05985691f, 
    -0.00482209f, -0.07080157f, -0.11609963f, 0.16930105f, 0.03255450f, 0.01194274f, 0.02406178f, -0.00689331f, 
    -0.01494781f, 0.11673538f, 0.02325865f, 0.00853903f, 0.24323685f, 0.09032466f, 0.49657020f, 0.00710271f, 
    -0.07767896f, 0.02879160f, -0.13642558f, -0.02257886f, -0.15619102f, 0.07078186f, 0.02303028f, 0.16988716f, 
    0.26481867f, 0.03397018f, 0.01334845f, 0.04778713f, -0.06853780f, -0.19264995f, 0.00126345f, -0.07011984f, 
    -0.06421074f, 0.01445711f, 0.00258886f, 0.09990274f, 0.11667543f, 0.19151467f, 0.16812009f, -0.03101393f, 
    0.01796606f, -0.04215055f, -0.00118739f, -0.12390547f, -0.10180619f, -0.04708997f, 0.00075643f, 0.00540925f, 
    -0.26105297f, 0.07040459f, -0.04719955f, -0.13052560f, 0.04543868f, 0.13249570f, -0.02441264f, 0.00012719f, 
    -0.00683282f, -0.14396961f, -0.05879325f, -0.02593688f, 0.05454881f, -0.04232260f, 0.11048993f, 0.22851481f, 
    -0.07779279f, -0.11257153f, -0.00247981f, 0.00541438f, -0.02645511f, -0.00162097f, -0.08430329f, 0.20075570f, 
    0.15096582f, 0.07701025f, 0.04601342f, -0.08090889f, 0.04909471f, -0.11300732f, -0.10889611f, -0.08480205f, 
    -0.11699156f, 0.17587395f, -0.12545702f, -0.03853934f, -0.06026103f, -0.12977968f, 0.02234100f, 0.09261081f, 
    -0.01479394f, -0.01249136f, 0.07883830f, 0.15473393f, -0.00083085f, -0.00194369f, 0.00645850f, 0.02738845f, 
    -0.05894914f, -0.09158903f, 0.03725664f, -0.02685144f, 0.10237289f, -0.13971511f, -0.03939800f, 0.07664418f, 
    0.10206159f, 0.18572871f, 0.01388746f, 0.10866340f, -0.09307882f, -0.08335944f, -0.02048079f, 0.11216652f, 
    0.31703138f, -0.04906379f, -0.02240185f, 0.18021676f, -0.01135863f, 0.05894732f, -0.01936750f, -0.01401022f, 
    0.07144323f, -0.01075303f, -0.01817895f, 0.05345327f, 0.09990369f, -0.18769647f, -0.10921924f, 0.01582193f, 
    -0.00358570f, -0.05835743f, 0.13726200f, -0.06329457f, 0.06761651f, 0.00840634f, 0.05948602f, -0.17725235f, 
    -0.00520969f, 0.07127099f, 0.01899379f, -0.19689067f, 0.03250765f, -0.07636932f, 0.01286827f, 0.11389057f, 
    0.02196481f, -0.00954529f, 0.15066922f, 0.05780526f, 0.03933563f, -0.00898017f, 0.10789998f, 0.11537325f, 
    -0.02073918f, 0.12969263f, 0.00627807f, 0.01345261f, 0.11215758f, 0.16944970f, 0.15646750f, 0.22983533f, 
    -0.18744180f, 0.07276983f, -0.15049149f, -0.02212559f, 0.00323514f, 0.05189617f, 0.03250430f, 0.00033853f, 
    -0.06500814f, -0.15491238f, -0.07597728f, 0.14907268f, -0.00220472f, 0.03124299f, 0.09619227f, 0.02915745f, 
    0.04519028f, -0.07820352f, -0.04310391f, -0.00595244f, -0.00120429f, -0.06155342f, 0.06829545f, 0.13210255f, 
    0.07743777f, -0.03044608f, -0.06101440f, 0.07172022f, -0.06834295f, -0.04035741f, 0.00885963f, 0.01188487f, 
    0.11332967f, 0.06537823f, -0.07425230f, -0.10649116f, 0.14908682f, 0.01458568f, 0.07693176f, 0.13484469f, 
    0.04986069f, -0.00164451f, 0.14365676f, -0.00090857f, 0.03890873f, 0.10425476f, 0.08577976f, 0.21776365f, 
    -0.17387308f, 0.00520963f, -0.06473918f, 0.08493049f, -0.20930569f, 0.27361828f, 0.16350602f, 0.04058969f, 
    0.10405169f, 0.05566729f, 0.30207729f, -0.05724119f, -0.07665507f, -0.04612395f, 0.07176093f, 0.07206934f, 
    -0.02553157f, 0.06372599f, -0.00273075f, 0.04577423f, 0.16170426f, 0.00848127f, 0.03734256f, 0.17191803f, 
    0.15644071f, -0.01200147f, -0.01256884f, -0.09294622f, -0.02014611f, 0.02131684f, 0.02795921f, -0.02957585f, 
    -0.04072499f, -0.06450076f, -0.11676417f, -0.02687288f, 0.06618219f, -0.11138828f, -0.03565286f, -0.10435854f, 
    -0.12879845f, 0.03324107f, -0.08350637f, -0.06285478f, -0.04506765f, 0.17840359f, 0.07708708f, 0.30015579f, 
    0.11772354f, 0.05144014f, -0.02301548f, -0.06183485f, 0.01235971f, -0.06142848f, 0.00435819f, 0.26643345f, 
    -0.20182979f, -0.19967037f, -0.04071723f, 0.06367644f, -0.02444122f, -0.02163732f, 0.01104030f, 0.05628944f, 
    -0.11959291f, -0.01328110f, -0.02862099f, -0.08997947f, -0.05779386f, -0.20561662f, 0.07416800f, -0.12384777f, 
    -0.09095605f, -0.06220885f, -0.02954004f, -0.08255779f, -0.09665614f, -0.10043658f, 0.15352902f, -0.02857952f, 
    0.07465036f, -0.04808171f, 0.10265145f, 0.03124842f, 0.09518248f, 0.04455931f, 0.00760023f, -0.12501431f, 
    0.07345955f, 0.13994083f, -0.00492065f, 0.13259937f, -0.16690747f, 0.07510968f, -0.11997394f, -0.08258078f, 
    0.05930972f, 0.13901535f, 0.02890758f, 0.12954767f, 0.09437194f, 0.00112541f, -0.01364021f, 0.06963859f, 
    -0.26175824f, 0.29109201f, 0.13909344f, 0.20804791f, 0.07058144f, 0.15896817f, 0.06717812f, -0.00117071f, 
    -0.07785136f, 0.09303264f, 0.04214736f, -0.13237330f, 0.17962702f, 0.05405447f, -0.01638786f, 0.04114592f, 
    0.00839045f, 0.03739306f, -0.04121760f, 0.09697797f, -0.01303509f, -0.03561894f, -0.00081628f, 0.03229690f, 
    -0.33535168f, 0.00232539f, -0.18165721f, -0.11514153f, 0.25848833f, 0.12047558f, -0.03961483f, 0.17372814f, 
    -0.00978793f, 0.18946674f, 0.01152753f, -0.22111608f, 0.00295491f, -0.07020729f, -0.42224011f, 0.00893694f, 
    0.07197262f, -0.04085265f, -0.10776798f, 0.08703604f, 0.14103583f, 0.01914063f, -0.01957162f, 0.08084874f, 
    -0.20494175f, -0.04008183f, 0.15678182f, 0.03739035f, 0.08737858f, 0.06962216f, -0.05283377f, 0.02579739f, 
    0.06800498f, 0.20864385f, 0.11306839f, 0.16010365f, -0.09736904f, 0.09082332f, -0.34881243f, -0.10097304f, 
    0.02543786f, 0.16285652f, 0.00514307f, -0.06190051f, 0.00117137f, 0.10313353f, 0.03007436f, -0.02581499f, 
    -0.02096807f, -0.09621815f, 0.07550195f, 0.10589261f, 0.08516290f, 0.06491309f, -0.01301907f, -0.03344008f, 
    0.07844858f, 0.15567115f, 0.07350128f, 0.03692273f, 0.33046356f, -0.00214846f, 0.64372414f, -0.13233271f, 
    -0.04502256f, 0.00455870f, -0.18781972f, 0.13248648f, -0.07231820f, -0.02017327f, 0.06870200f, -0.03469235f, 
    0.18686135f, -0.09339516f, -0.04412953f, 0.07336200f, 0.07644351f, 0.03143322f, -0.08417518f, -0.08021178f, 
    -0.01072940f, -0.09815415f, -0.03600532f, 0.03914072f, 0.09815960f, 0.00478017f, -0.08398269f, 0.01108676f, 
    -0.09270274f, -0.03597863f, 0.01199398f, -0.11996134f, -0.10710688f, -0.06773733f, -0.06668966f, -0.11235890f, 
    -0.25004300f, 0.05253364f, -0.01589639f, -0.16119267f, -0.00257914f, 0.13643202f, 0.03842376f, -0.02547810f, 
    0.12535565f, -0.15564457f, -0.07211110f, -0.04686942f, -0.01556963f, -0.10071342f, 0.00746389f, 0.03925674f, 
    -0.01978375f, 0.01415969f, 0.03250482f, -0.04055799f, 0.05814504f, -0.01445864f, -0.05414883f, 0.00697310f, 
    0.33706471f, 0.11164638f, 0.06079588f, 0.00420928f, 0.07502103f, 0.02535901f, -0.04669558f, -0.13318491f, 
    -0.01970025f, -0.00335284f, -0.10252692f, 0.07022499f, -0.12958445f, -0.27990606f, 0.06148460f, 0.17893600f, 
    -0.01916557f, -0.04968630f, 0.00881097f, 0.18351290f, 0.03608136f, -0.02095020f, 0.10857441f, -0.05582702f, 
    0.04134537f, -0.05533876f, -0.04398099f, -0.03845504f, 0.06823196f, -0.08624454f, -0.14923404f, 0.13489749f, 
    -0.12157777f, 0.11792606f, -0.03725597f, -0.00434301f, -0.16352527f, -0.23018558f, -0.22059342f, 0.09644680f, 
    0.16828611f, -0.17897989f, -0.08095350f, 0.13005431f, -0.04239985f, 0.05690228f, 0.01197729f, -0.04721674f, 
    -0.10387235f, -0.08801033f, -0.10272300f, 0.08460506f, 0.06476132f, -0.12420440f, -0.14863305f, 0.06803457f, 
    0.04769409f, 0.09526077f, 0.06812481f, 0.12922294f, 0.05453768f, 0.13661115f, 0.02835535f, -0.16171597f, 
    -0.00762379f, -0.01691685f, 0.09836306f, 0.04951312f, -0.13546774f, -0.13968274f, 0.02550381f, 0.00374348f, 
    -0.02082828f, 0.14274271f, 0.32242158f, 0.22723496f, -0.06454197f, -0.03736832f, 0.24333668f, -0.08585259f, 
    -0.07399052f, 0.04467111f, -0.03760466f, 0.04971912f, 0.15933406f, 0.03634938f, 0.09940995f, -0.07166312f, 
    -0.09072793f, 0.02217089f, -0.11295241f, -0.00359169f, 0.04156493f, 0.02343987f, -0.07832273f, -0.05889420f, 
    -0.06091651f, -0.12961167f, 0.02697886f, 0.05908229f, -0.10785712f, -0.03006862f, 0.07451067f, 0.15777832f, 
    -0.00013321f, -0.05669852f, -0.05814404f, 0.01730385f, -0.06622947f, -0.22517671f, 0.08038512f, 0.15350784f, 
    0.10919976f, -0.00453642f, -0.08898048f, 0.11983550f, -0.03230951f, -0.00248807f, -0.00058575f, -0.02550679f, 
    0.06884645f, -0.13400173f, -0.19545650f, 0.00886630f, 0.04010280f, 0.09338818f, 0.07887979f, 0.03612289f, 
    0.01342354f, -0.16722791f, 0.08918543f, 0.07639708f, -0.09619830f, -0.09080293f, 0.17877322f, 0.04239409f, 
    -0.22658643f, 0.08623538f, -0.00313515f, -0.12554158f, -0.01965965f, 0.20347036f, 0.08657634f, 0.13480785f, 
    0.14128768f, 0.01742926f, 0.22721648f, -0.07855997f, 0.01959247f, -0.11914466f, 0.02574957f, 0.10638134f, 
    0.08215168f, 0.04603197f, 0.11115500f, 0.22666794f, 0.13963242f, 0.11912118f, 0.21298638f, 0.41070342f, 
    0.14584231f, -0.05300115f, 0.14133765f, -0.11242657f, -0.00040855f, 0.07405502f, 0.05891922f, 0.02562716f, 
    0.10100490f, 0.01069201f, -0.18370663f, 0.22829972f, -0.00664848f, -0.07879377f, -0.07955754f, -0.07938089f, 
    -0.03229258f, 0.18846138f, -0.03600666f, 0.07774781f, 0.22481020f, -0.16807850f, -0.18958509f, 0.34883401f, 
    0.11089456f, 0.01165036f, -0.04190153f, -0.04515434f, -0.06701416f, -0.13351047f, -0.06976898f, 0.08351024f, 
    0.09310066f, 0.17301184f, 0.06100025f, -0.11377780f, -0.05119450f, -0.01080226f, -0.00252710f, 0.05652292f, 
    0.04015846f, 0.02578933f, 0.04787162f, 0.01808041f, -0.13119400f, -0.12426353f, -0.15933673f, -0.03412446f, 
    -0.08962816f, 0.08441877f, -0.10042081f, -0.08953098f, 0.10845686f, -0.12958655f, -0.28145325f, -0.02171354f, 
    -0.03368561f, 0.24810693f, 0.10672184f, 0.00143061f, -0.02176469f, 0.05747450f, 0.03647452f, 0.04848222f, 
    -0.03117536f, -0.05456985f, -0.11589800f, -0.06796444f, 0.32470727f, 0.04843581f, 0.12727626f, 0.14648829f, 
    -0.03449488f, -0.01702434f, 0.00243683f, 0.01679580f, -0.00277204f, -0.00936133f, 0.00111745f, 0.10763072f, 
    0.09036612f, 0.00035421f, 0.05111608f, -0.07336640f, 0.04858566f, 0.12961008f, -0.11106068f, -0.04977760f, 
    0.05261098f, -0.06103905f, -0.03406337f, 0.18100388f, -0.12371843f, -0.02206684f, 0.04005660f, 0.05761877f, 
    -0.16637319f, 0.02432992f, 0.10309865f, -0.13288713f, 0.11004180f, -0.04348769f, 0.02249201f, 0.00542505f, 
    0.10230739f, -0.01970048f, -0.12473849f, 0.00499393f, -0.15222183f, -0.01424779f, -0.04312491f, -0.13214615f, 
    0.09934349f, -0.06222237f, 0.04828104f, 0.01336605f, 0.11317671f, -0.18242711f, -0.19459863f, 0.08019380f, 
    -0.05881257f, -0.06901965f, 0.00308197f, -0.00348645f, -0.03797964f, 0.08070905f, 0.05235965f, 0.11341246f, 
    -0.02036143f, 0.02835399f, -0.06798277f, 0.05861660f, -0.00388487f, 0.02328662f, 0.09293687f, -0.10182907f, 
    -0.07389437f, -0.06200203f, 0.08872157f, -0.00489625f, 0.07124922f, -0.34755191f, -0.02079628f, 0.05112953f, 
    0.01267379f, -0.05600071f, 0.01164834f, 0.07998495f, 0.15958236f, -0.08247949f, 0.04396684f, 0.03175680f, 
    0.10690524f, 0.23215961f, 0.25202188f, -0.14497226f, -0.06070904f, -0.02884563f, 0.04144740f, 0.12990618f, 
    -0.01342052f, -0.11977816f, -0.01663158f, 0.10498521f, -0.19166727f, 0.03764774f, -0.01903256f, 0.05569575f, 
    0.03157601f, -0.05370937f, -0.04602119f, 0.02581470f, -0.02495417f, -0.02585554f, 0.04685750f, -0.00201951f, 
    -0.13717300f, 0.13130793f, 0.24558465f, 0.11777064f, 0.10213494f, 0.05833288f, 0.01739898f, -0.03756711f, 
    0.02094679f, -0.00595649f, 0.00774161f, 0.01061738f, -0.27711293f, -0.22538568f, -0.02484000f, 0.07159881f, 
    -0.06922086f, 0.03671368f, -0.02440985f, -0.02637106f, 0.05170715f, 0.11399671f, 0.16082701f, 0.06340626f, 
    0.00936051f, 0.00266958f, 0.02712412f, -0.06456915f, 0.08507024f, -0.04698764f, 0.03889403f, 0.23266093f, 
    -0.06891698f, -0.01099695f, 0.01599949f, -0.09120966f, -0.02313700f, 0.24069586f, 0.01020391f, -0.10738719f, 
    0.06152655f, 0.16488901f, 0.13681701f, -0.12119542f, -0.02023510f, -0.00312530f, 0.02507528f, -0.01273276f, 
    -0.26874751f, 0.03082621f, -0.01977115f, 0.03299428f, -0.02870460f, 0.01151440f, 0.14441366f, -0.00719792f, 
    0.08975716f, -0.00619567f, 0.01848989f, -0.08216598f, 0.06774328f, 0.18736807f, 0.05253557f, -0.21778528f, 
    0.09265266f, 0.04984443f, 0.13364081f, -0.09816462f, 0.02961299f, -0.02825841f, -0.02903263f, -0.01343125f, 
    0.13467605f, 0.13039452f, 0.00610996f, -0.05108703f, -0.05169744f, 0.12213906f, -0.09101003f, -0.02809972f, 
    0.14488728f, -0.04287936f, 0.10414568f, -0.04487419f, 0.20522742f, 0.12450142f, 0.18340571f, 0.17007555f, 
    -0.12669075f, 0.18326110f, 0.17155902f, -0.13043883f, 0.05650577f, -0.06860887f, -0.03253827f, 0.18533787f, 
    0.17132746f, 0.04418774f, 0.16006763f, 0.16550191f, -0.07880685f, 0.10645373f, 0.05519588f, -0.10706399f, 
    -0.04468237f, -0.09143630f, -0.06789038f, 0.15581329f, -0.00879109f, -0.02415163f, -0.09710620f, -0.03956634f, 
    -0.12063272f, -0.20125398f, -0.04395980f, 0.09528545f, 0.01089971f, 0.03727755f, -0.06127614f, -0.10965272f, 
    0.06035960f, 0.07313701f, 0.05866078f, -0.02479143f, -0.05374001f, 0.07654854f, 0.00488985f, 0.10719734f, 
    0.03127324f, -0.12774803f, -0.19245924f, -0.03975994f, -0.15693931f, 0.02275480f, -0.11316778f, -0.15901919f, 
    -0.03379263f, -0.14102496f, -0.00860187f, 0.01321241f, -0.02736558f, 0.00861394f, 0.02542374f, 0.08739875f, 
    0.08954036f, 0.20736971f, 0.08127785f, -0.03292064f, 0.04996797f, -0.02252068f, -0.00564182f, 0.03876741f, 
    0.03373038f, 0.07743838f, -0.04795324f, -0.05168791f, 0.06010741f, 0.25791469f, 0.01659289f, 0.01644079f, 
    -0.05544834f, 0.06645045f, 0.26885360f, 0.06099049f, -0.03950275f, 0.02270061f, 0.07534989f, -0.05665236f, 
    -0.06052644f, 0.04830346f, 0.06793761f, 0.20597608f, 0.00635391f, 0.00964343f, 0.07278220f, -0.11322158f, 
    -0.00339826f, 0.05564006f, -0.09639623f, 0.13212936f, -0.22066566f, 0.05537061f, 0.00826633f, 0.09295420f, 
    0.02168509f, -0.04964665f, 0.10440249f, -0.08439031f, 0.18260802f, -0.10005047f, -0.14836167f, 0.19355467f, 
    -0.25335202f, -0.08371591f, -0.14185643f, -0.11387274f, -0.01333234f, 0.01421091f, 0.00945233f, -0.10467183f, 
    0.14527617f, -0.02080555f, 0.04343305f, -0.12362084f, 0.10538444f, 0.01565535f, -0.10302541f, -0.09236404f, 
    -0.01988076f, 0.07490171f, 0.09306404f, 0.11535776f, 0.02842551f, 0.03271723f, 0.00372437f, -0.01460205f, 
    -0.08198412f, -0.10478677f, -0.04602685f, 0.09194034f, -0.06772023f, 0.01694395f, 0.02627160f, 0.09156404f, 
    0.10491476f, -0.09311234f, 0.08527936f, 0.01052603f, -0.10830650f, -0.01127146f, 0.08658771f, -0.19640583f, 
    -0.02704412f, -0.03501223f, 0.00064286f, 0.16597530f, 0.05594822f, 0.02864770f, 0.15442315f, 0.11683629f, 
    0.04293838f, -0.00779879f, 0.03849394f, -0.00233454f, 0.03558757f, -0.00712535f, -0.00084671f, -0.01753850f, 
    -0.02924537f, -0.01998898f, -0.04436846f, -0.03570553f, -0.02104678f, -0.00069717f, -0.00063830f, -0.04132416f, 
    0.04546477f, 0.00863223f, 0.01874848f, -0.04231989f, -0.01729570f, 0.00436130f, 0.02021841f, -0.01044420f, 
    0.02200898f, -0.00999866f, -0.02504368f, -0.05606986f, 0.03738214f, -0.05050103f, -0.00788761f, 0.00140433f, 
    -0.00079300f, -0.01213812f, -0.04511975f, -0.02133936f, -0.05253801f, -0.05436803f, 0.02934460f, -0.02473253f, 
    0.04052959f, 0.01994267f, -0.04465484f, -0.02168761f, -0.02226515f, -0.04954037f, -0.02804388f, -0.00036261f, 
    0.01877480f, -0.02403452f, -0.02323609f, 0.04336306f, -0.04708599f, -0.01801994f, -0.00447953f, -0.04784599f, 
    -0.05093114f, -0.04087722f, 0.00614285f, -0.00890790f, -0.05359732f, -0.00096252f, -0.05361426f, -0.00342548f, 
    -0.02585242f, -0.04329027f, 0.01384814f, -0.02378125f, 0.04560182f, 0.02577815f, -0.04171410f, 0.01982885f, 
    0.01861588f, -0.04382554f, -0.03863856f, -0.01664060f, 0.04103334f, 0.00480444f, 0.01842837f, 0.01281189f, 
    -0.00873354f, -0.00697092f, 0.03489838f, 0.00777832f, -0.01992214f, 0.03212024f, 0.00454587f, 0.03648185f, 
    0.04229084f, -0.00174647f, 0.02083956f, -0.01330032f, -0.04829792f, 0.02541873f, 0.01328901f, 0.03557851f, 
    0.02220355f, -0.01161464f, -0.03490384f, 0.00476304f, -0.00956220f, 0.02018526f, 0.00457094f, -0.01465599f, 
    -0.00183882f, -0.04693823f, 0.03181654f, -0.02022455f, 0.01142425f, -0.02835444f, -0.04039478f, -0.02799374f, 
    0.03049822f, 0.01738801f, 0.01147980f, -0.04170151f, 0.02415964f, -0.03351936f, 0.01652135f, -0.00442279f, 
    -0.01327230f, -0.01498467f, -0.04006865f, 0.01236008f, -0.03649338f, 0.00648148f, -0.03518564f, 0.01617855f, 
    0.01958103f, -0.00328325f, -0.02534150f, 0.00735334f, 0.02370432f, 0.02280653f, -0.01382319f, -0.03952427f, 
    -0.04804007f, -0.00282103f, 0.02009819f, -0.01916790f, -0.03947114f, -0.03791173f, -0.01545330f, 0.04472651f, 
    0.01545757f, 0.02888972f, -0.04400536f, 0.00081776f, -0.05050863f, -0.03305643f, 0.04002550f, 0.01461205f, 
    -0.03224883f, 0.01150554f, 0.00546535f, -0.03438224f, -0.01421102f, -0.02556290f, -0.04785773f, -0.05377458f, 
    -0.03032154f, -0.03575440f, 0.03541365f, 0.02468399f, 0.02301410f, -0.02352004f, 0.01410768f, 0.00583210f, 
    -0.05441532f, -0.04204858f, -0.04618686f, -0.03797126f, -0.04859182f, -0.04910070f, -0.03200297f, 0.00721605f, 
    -0.00882496f, -0.01812078f, -0.02503092f, 0.00751662f, -0.01459342f, -0.03559671f, 0.01456595f, 0.02151514f, 
    -0.03366201f, 0.02377141f, -0.04887575f, 0.04008233f, 0.03187579f, 0.00903331f, -0.03176728f, 0.00882749f, 
    0.03759409f, 0.02962507f, -0.00499924f, 0.02043787f, 0.04572535f, 0.01705383f, -0.04228435f, -0.03088927f, 
    -0.00436971f, 0.02927981f, -0.04758234f, -0.00914841f, 0.03771225f, 0.01965029f, -0.00377032f, -0.03051787f, 
    0.04556063f, 0.01746265f, 0.04163574f, -0.01081607f, 0.00159711f, 0.02392600f, -0.01028955f, -0.02203554f, 
    0.00146496f, -0.02259998f, 0.03101127f, 0.04064136f, -0.05500096f, -0.00339607f, 0.02114991f, 0.00837683f, 
    0.01189242f, 0.03332926f, 0.00155305f, -0.00081637f, 0.01399285f, 0.02855154f, -0.03742812f, 0.04545865f, 
    0.01998149f, 0.03962830f, -0.04163030f, -0.01658132f, 0.03198115f, 0.00973000f, 0.03489346f, 0.00000291f, 
    -0.03686633f, 0.04991945f, 0.03527170f, 0.00615390f, -0.02313288f, 0.02680119f, -0.00985766f, 0.00286284f, 
    -0.02135523f, 0.00105301f, 0.01147909f, -0.05436000f, -0.03640325f, 0.00825600f, -0.04162858f, -0.01203508f, 
    -0.03744969f, 0.01528010f, -0.04308843f, -0.03820734f, 0.02396519f, -0.02829438f, 0.03080552f, -0.02453469f, 
    0.01449566f, -0.01439427f, 0.01202038f, 0.00524389f, 0.00094091f, 0.00474806f, -0.00888985f, 0.00271543f, 
    -0.04480852f, -0.04063342f, 0.02969198f, 0.00103586f, -0.00173784f, 0.03994177f, -0.01899335f, 0.01489840f, 
    0.04578357f, -0.03106089f, -0.02977410f, -0.03091811f, -0.04912130f, -0.05356869f, -0.02804541f, -0.02377172f, 
    0.03040232f, 0.02657633f, -0.01762172f, -0.03703951f, -0.04437323f, -0.03803456f, -0.00471930f, -0.04110555f, 
    0.00804333f, -0.02096153f, -0.01529166f, -0.03028040f, -0.01836522f, -0.04297815f, 0.04447318f, -0.03699234f, 
    0.02016256f, -0.04198032f, 0.02803431f, 0.02997864f, 0.02569572f, 0.00886114f, 0.03461968f, -0.03357660f, 
    0.00562390f, 0.03585009f, -0.05174492f, 0.02868467f, -0.04516611f, 0.02872863f, -0.01038018f, -0.05396454f, 
    -0.01138063f, -0.02859894f, -0.00282857f, 0.03418759f, -0.05471350f, -0.01502304f, -0.03288386f, 0.00053906f, 
    -0.02716186f, -0.03856150f, -0.00183037f, -0.03417591f, 0.04187352f, -0.01732183f, 0.03887516f, -0.02818164f, 
    -0.00408059f, 0.01911579f, 0.02451764f, -0.02886777f, 0.01639181f, -0.04893605f, -0.01550710f, -0.01569454f, 
    0.03092404f, -0.01346802f, -0.05053063f, -0.02753362f, -0.03629485f, -0.05043056f, 0.04053762f, -0.02006503f, 
    -0.02327912f, -0.00370221f, 0.03399234f, -0.01813125f, -0.02344825f, 0.02014917f, 0.04132819f, 0.00765689f, 
    0.01232597f, 0.04390924f, -0.02911459f, -0.04938695f, 0.03276328f, -0.04071673f, 0.02139779f, -0.03715853f, 
    0.03800845f, -0.04119205f, -0.04716900f, -0.05548749f, -0.04359033f, 0.03150431f, -0.02264741f, 0.00625872f, 
    0.00475654f, -0.02142306f, -0.03077448f, 0.02844664f, -0.04865710f, -0.05588759f, 0.03262290f, -0.02131021f, 
    -0.00423126f, -0.03364496f, -0.16821225f, -0.10231721f, -0.01107914f, -0.02550688f, -0.05110813f, -0.00362452f, 
    0.02857049f, 0.08138497f, 0.05115899f, 0.02583983f, 0.09433220f, 0.00359866f, 0.13442293f, 0.14027500f, 
    0.03582165f, 0.02248340f, 0.06503204f, 0.16912830f, -0.04521789f, 0.01673374f, 0.05561424f, -0.09577327f, 
    -0.02718375f, 0.18056095f, 0.13186796f, -0.01274319f, -0.06000045f, 0.03117886f, -0.12962052f, -0.04256248f, 
    -0.01748652f, 0.03558899f, 0.11659666f, 0.01820455f, 0.02140883f, -0.19552058f, 0.13244779f, -0.06776726f, 
    -0.13699464f, -0.03855756f, 0.03556107f, -0.07408260f, 0.11994330f, 0.05336042f, -0.07569044f, -0.08260285f, 
    0.31249121f, 0.10857397f, -0.13257261f, -0.36091682f, 0.14097427f, 0.06957689f, 0.10901501f, -0.05872188f, 
    0.09164642f, 0.05655864f, -0.00339234f, -0.08476778f, -0.04629587f, 0.03593928f, -0.08746590f, 0.10385972f, 
    -0.08057515f, -0.09366127f, -0.12582311f, 0.07774289f, -0.04052041f, 0.01632322f, -0.13170733f, -0.03006289f, 
    -0.07500340f, 0.06212449f, 0.09867788f, 0.03394449f, -0.20727055f, 0.03445504f, 0.07110218f, 0.12715329f, 
    0.11197241f, 0.18599200f, 0.05466812f, -0.07902172f, -0.10751157f, -0.10384270f, 0.10216226f, 0.13730030f, 
    0.02578181f, 0.02765066f, 0.02414575f, -0.02125594f, 0.06904826f, 0.03706639f, -0.06875977f, 0.07145800f, 
    -0.01649849f, 0.15520117f, -0.01548124f, -0.05954990f, 0.04247645f, -0.03209252f, -0.01485731f, 0.05311902f, 
    0.05814979f, 0.01819242f, -0.00849400f, 0.19273935f, 0.51099026f, -0.09578884f, 0.16368477f, 0.25289512f, 
    -0.12361058f, 0.06196934f, 0.02501897f, 0.05285226f, -0.17503735f, 0.07319069f, 0.05611616f, 0.01292482f, 
    0.05623728f, -0.00676259f, -0.01503260f, -0.10552616f, 0.04402763f, -0.07635193f, -0.05973625f, 0.15352252f, 
    -0.00438827f, 0.01909493f, 0.12363536f, -0.00823799f, 0.35792539f, -0.13646312f, -0.19259186f, -0.06357116f, 
    0.00071396f, -0.06950909f, 0.16148096f, 0.00604896f, 0.07114660f, -0.09312680f, 0.02391396f, -0.00511552f, 
    -0.24927601f, 0.06539096f, -0.06062162f, 0.01220726f, 0.10323770f, -0.00492650f, 0.02267676f, 0.18528138f, 
    0.06410109f, -0.06041726f, -0.00002727f, -0.03497259f, 0.21631461f, 0.06754609f, 0.06660046f, 0.08706604f, 
    -0.01670394f, 0.02035823f, 0.02937895f, 0.11266934f, 0.14304380f, 0.13705778f, 0.08372331f, -0.01912278f, 
    -0.07529559f, 0.03986587f, -0.00590377f, 0.01100485f, -0.04722167f, 0.05382780f, -0.00574092f, -0.06103627f, 
    0.07297308f, -0.05039020f, -0.09002315f, 0.01649421f, -0.15495370f, 0.03629375f, 0.11501746f, -0.19536307f, 
    0.05494159f, 0.03227207f, 0.01277938f, 0.16041449f, -0.02880825f, -0.03169583f, 0.03605517f, -0.07288831f, 
    -0.51379025f, 0.16575372f, 0.05897286f, -0.20231305f, -0.01690769f, 0.05142877f, -0.14964285f, 0.11673897f, 
    0.08195590f, 0.03516375f, -0.04615042f, -0.03533455f, 0.04069337f, 0.16516532f, 0.08452244f, -0.06567729f, 
    -0.02654920f, -0.03005332f, 0.02383587f, 0.08935582f, -0.08415980f, -0.04441689f, 0.06548601f, 0.04692236f, 
    0.33240542f, 0.20165484f, 0.15005901f, -0.21223980f, -0.01852529f, -0.06317561f, 0.11513615f, -0.00235438f, 
    -0.09893433f, 0.06070989f, -0.14585918f, 0.04829384f, -0.52193582f, 0.23408411f, -0.29081807f, -0.07604709f, 
    -0.21346228f, 0.02413712f, -0.13118595f, -0.14492461f, -0.00721329f, -0.14978929f, 0.01472013f, -0.11087576f, 
    -0.33941522f, 0.14326069f, -0.19578972f, -0.04959923f, 0.06204273f, -0.01931652f, 0.13670598f, -0.02147847f, 
    0.14044967f, 0.06034065f, 0.02914932f, -0.16242984f, -0.08529195f, -0.08928134f, 0.05517076f, 0.13249600f, 
    -0.01965413f, 0.02884492f, 0.00602425f, 0.05410165f, -0.03280040f, 0.03336639f, -0.00765450f, 0.07928176f, 
    0.23870037f, 0.23583910f, 0.08611430f, -0.14824423f, -0.06098183f, -0.03875937f, -0.06660991f, -0.04830522f, 
    -0.08857425f, 0.02218541f, 0.10410188f, 0.01631964f, 0.29179773f, -0.04306177f, 0.01074059f, 0.16321781f, 
    0.00681211f, 0.05803454f, -0.00220747f, 0.03995370f, -0.02748973f, -0.01520215f, -0.01086329f, -0.07137275f, 
    0.07981006f, 0.11176527f, 0.19741963f, -0.08730424f, -0.05128638f, -0.02143525f, -0.07090461f, 0.06762446f, 
    -0.13613975f, -0.04504843f, -0.01861907f, 0.03107375f, 0.04616020f, 0.15824565f, 0.12927808f, -0.12051345f, 
    -0.15535162f, -0.03671394f, -0.02753323f, 0.04548975f, -0.01156067f, -0.05503102f, 0.03622876f, 0.05710634f, 
    -0.13356155f, 0.14564817f, -0.10074662f, 0.15502304f, 0.04166751f, 0.16274241f, 0.05740182f, 0.14203383f, 
    0.09660419f, -0.15809402f, 0.02784286f, 0.00116067f, 0.43783990f, -0.18007228f, 0.01033145f, -0.07819776f, 
    0.09749930f, 0.03310559f, 0.05103601f, 0.00543376f, -0.06712116f, 0.13526054f, 0.04084270f, -0.00215369f, 
    -0.00017362f, -0.07292365f, -0.23539041f, -0.02975447f, 0.11078673f, -0.05492509f, 0.02301927f, 0.04413239f, 
    -0.10664644f, 0.11408506f, -0.13609014f, 0.10176905f, -0.02597922f, 0.02239384f, 0.12035115f, 0.07923906f, 
    -0.04597182f, -0.00956300f, -0.06482756f, 0.03228025f, 0.09610995f, 0.07699577f, 0.07781296f, -0.16585697f, 
    -0.17027315f, 0.31143364f, 0.17053588f, 0.22113843f, -0.06465339f, 0.10952947f, -0.01169652f, 0.04506842f, 
    0.07313700f, 0.02937173f, 0.09470704f, 0.10249981f, -0.13826825f, -0.26279247f, 0.17473668f, 0.35898626f, 
    -0.12562643f, 0.08560082f, -0.03892880f, 0.11039007f, 0.12516902f, 0.11261646f, -0.21013455f, -0.06597397f, 
    -0.00956861f, -0.02036878f, -0.04437801f, 0.03760136f, -0.01210103f, 0.01714033f, 0.03198034f, 0.02967665f, 
    -0.03163106f, 0.01499988f, -0.00951422f, -0.00879982f, 0.00378554f, -0.02420846f, 0.02018919f, -0.00597199f, 
    -0.04882489f, 0.02339391f, 0.00976606f, -0.01641788f, 0.00843021f, -0.05510438f, 0.00827029f, 0.02197653f, 
    0.03092226f, -0.03490838f, -0.03300261f, 0.00658224f, -0.04069208f, -0.04520691f, 0.04165291f, -0.03166667f, 
    -0.01226235f, 0.03707136f, -0.04666026f, -0.02418486f, 0.02314500f, 0.03033024f, 0.02439679f, -0.05230957f, 
    -0.04992490f, 0.01191903f, -0.05478789f, 0.03184189f, 0.00802964f, -0.04713362f, -0.05814572f, 0.01314299f, 
    -0.00489172f, 0.02976282f, -0.05133532f, 0.01725083f, -0.05517891f, 0.03329910f, -0.03922073f, -0.03649878f, 
    -0.04003004f, -0.00316999f, -0.05522913f, -0.03680129f, 0.00265444f, 0.00306748f, 0.00127481f, -0.01456794f, 
    0.02605042f, 0.03367186f, 0.03483769f, -0.01074249f, 0.01687549f, 0.03508272f, 0.01447366f, 0.03606907f, 
    0.04356334f, 0.03851986f, -0.05266139f, -0.02497162f, -0.05387983f, 0.01156424f, -0.00272246f, -0.02088013f, 
    -0.00293247f, -0.02016572f, 0.04538406f, 0.03337288f, -0.05018338f, -0.05505615f, 0.02138572f, -0.00495484f, 
    0.03805809f, -0.01489593f, -0.02704527f, -0.06061738f, -0.03824830f, -0.02251795f, 0.01340327f, 0.02332488f, 
    -0.03991929f, -0.00638648f, 0.02355801f, -0.05826782f, -0.03696345f, 0.03205332f, -0.02986650f, 0.02001264f, 
    -0.05250974f, -0.04544080f, -0.00731137f, -0.01961495f, -0.05290282f, -0.00825761f, 0.02850377f, -0.02934452f, 
    -0.05503782f, -0.03505595f, -0.06240673f, -0.00218347f, -0.03615044f, -0.00227925f, -0.02741672f, -0.01824542f, 
    0.03696810f, 0.03952024f, 0.01145489f, -0.03959071f, -0.02525540f, 0.02780251f, -0.03984752f, -0.03973811f, 
    0.01579667f, 0.03773656f, 0.00586191f, 0.00577079f, -0.05326056f, 0.01872286f, -0.01037637f, 0.03880471f, 
    0.02047815f, -0.04813584f, 0.00914040f, 0.01454648f, -0.03587651f, 0.03330948f, 0.03248286f, -0.04552464f, 
    0.01869378f, -0.05392695f, -0.00057757f, -0.01144505f, 0.02885836f, 0.00915772f, 0.01040867f, 0.00308996f, 
    -0.01551608f, -0.04399077f, -0.00988203f, 0.03143224f, -0.05424209f, -0.01828502f, -0.03184243f, -0.00710255f, 
    0.02730718f, -0.02068643f, 0.02731587f, -0.04726718f, 0.02674028f, -0.01473764f, -0.05218826f, -0.05017878f, 
    -0.03526644f, 0.02034246f, 0.01579911f, 0.01155596f, 0.01594942f, 0.03041350f, -0.01961735f, -0.04285437f, 
    -0.05340883f, -0.05902176f, 0.03119648f, -0.00575915f, -0.02508119f, -0.02183366f, -0.05496796f, 0.00447986f, 
    -0.01460857f, -0.01292651f, 0.00109393f, 0.03830449f, 0.00094220f, -0.02108601f, 0.02018140f, 0.01975493f, 
    -0.02167344f, 0.01171839f, 0.03761003f, -0.05260576f, 0.02475253f, 0.04062735f, -0.04741791f, -0.01101361f, 
    0.02735150f, -0.04053399f, 0.02503676f, 0.00982913f, 0.03726293f, -0.01275472f, 0.02589618f, -0.00945245f, 
    0.03449370f, -0.02378056f, -0.05456162f, 0.01000431f, -0.04892177f, -0.03151393f, -0.03717866f, -0.01690496f, 
    -0.00309549f, -0.04389342f, -0.02194671f, -0.02145052f, -0.01802502f, 0.01928739f, 0.00329902f, 0.00989074f, 
    -0.05058094f, -0.05144453f, 0.01810308f, -0.01295205f, -0.05748075f, 0.01194162f, -0.01984679f, -0.03551174f, 
    -0.04827291f, 0.01585329f, 0.02865557f, 0.02507319f, -0.02217283f, -0.05455444f, 0.01819529f, 0.04370302f, 
    0.01376438f, 0.02482392f, -0.01574829f, 0.02677860f, -0.04143199f, 0.03264920f, -0.02056325f, -0.05808554f, 
    0.01615034f, 0.02484118f, 0.03172068f, -0.01605802f, -0.01508816f, 0.03429813f, 0.02990865f, 0.00679404f, 
    0.00400897f, -0.01947648f, 0.03775454f, 0.03579400f, 0.02461100f, 0.02517838f, 0.03536026f, -0.04162158f, 
    -0.01772942f, 0.03173925f, -0.02132972f, 0.01271348f, -0.05935335f, -0.03348910f, -0.05208253f, 0.03265872f, 
    -0.05234139f, 0.01144246f, -0.00421695f, -0.01728551f, -0.01363690f, -0.05773396f, -0.00279043f, -0.01507684f, 
    0.01320598f, 0.02825764f, 0.02343768f, 0.01882046f, -0.03635125f, 0.02343852f, 0.02174305f, -0.02523521f, 
    0.03112488f, 0.00515767f, -0.00019941f, 0.00267281f, -0.03675735f, -0.04346550f, -0.05254839f, -0.04405198f, 
    -0.03264892f, 0.02527574f, 0.01026196f, -0.05894918f, -0.04934734f, 0.02872759f, -0.01708197f, -0.03703044f, 
    0.01600774f, -0.05887113f, -0.05483313f, -0.00362726f, -0.03195574f, -0.04529729f, 0.00011796f, 0.02126167f, 
    -0.03210112f, -0.00955216f, 0.00884540f, 0.03362216f, -0.04992441f, -0.02533387f, -0.02198294f, -0.02508738f, 
    0.00163351f, -0.04012242f, -0.05079919f, 0.01222711f, 0.03879624f, 0.00807224f, -0.01248279f, 0.02177607f, 
    0.03228904f, 0.00967714f, 0.03857797f, -0.02300725f, 0.01792656f, 0.01811146f, 0.02537264f, 0.02289054f, 
    -0.03195065f, 0.02392500f, 0.02496716f, -0.04496483f, -0.05955886f, 0.02669836f, 0.03016831f, -0.05963222f, 
    0.01843234f, 0.02449062f, -0.03124842f, -0.04546209f, 0.03741825f, 0.02265440f, 0.01761830f, -0.00881368f, 
    -0.03808746f, -0.00806860f, -0.04598343f, 0.00432603f, 0.00579687f, 0.03650057f, 0.00522282f, -0.04261720f, 
    -0.05027682f, -0.04913811f, -0.03736511f, 0.02103762f, 0.03428021f, 0.02086717f, 0.02956311f, -0.03172409f, 
    0.04152472f, 0.01830535f, -0.05317122f, 0.01445286f, 0.00546368f, 0.03701421f, -0.03026298f, -0.05371939f, 
    -0.04899920f, 0.00288435f, 0.00561368f, -0.01897013f, -0.00182512f, -0.02882552f, -0.02106615f, -0.05502457f, 
    -0.01823666f, -0.04463611f, -0.04331794f, -0.05613206f, 0.00856088f, 0.00038165f, -0.01983193f, -0.01456414f, 
    -0.03747284f, 0.03607360f, -0.05795159f, 0.00981228f, -0.03442939f, 0.00023549f, 0.01963598f, -0.05637227f, 
    0.01228488f, -0.00005876f, 0.00796585f, -0.05049500f, -0.03921682f, 0.01533761f, -0.04739315f, -0.02668700f, 
    0.04052851f, -0.02015718f, 0.01787962f, 0.02859470f, -0.00353144f, -0.00697845f, 0.01426979f, 0.03041870f, 
    -0.04963263f, -0.02303738f, 0.01548438f, 0.02718159f, -0.02442639f, 0.04052121f, 0.00213760f, -0.02369050f, 
    -0.05002299f, 0.02942821f, -0.03748521f, 0.03477184f, -0.02951396f, -0.00873597f, 0.01303999f, -0.03344623f, 
    0.03464403f, 0.00031225f, 0.03820546f, 0.01876813f, 0.03796786f, -0.00882275f, -0.05569976f, 0.02737321f, 
    -0.04238496f, 0.03816610f, -0.04372410f, -0.01669056f, -0.04620370f, 0.03536719f, 0.02932488f, -0.02273135f, 
    -0.02022829f, -0.02138553f, 0.03692632f, 0.00435942f, -0.02952680f, 0.01389054f, -0.02805169f, 0.01257456f, 
    -0.04311151f, -0.02594871f, 0.03595175f, 0.02603878f, 0.04048968f, -0.04212449f, 0.02007776f, 0.01880611f, 
    -0.04700996f, -0.02287125f, 0.03445208f, 0.00961744f, 0.02399236f, -0.02531470f, -0.01243699f, -0.01072302f, 
    -0.02211640f, -0.02451731f, 0.01406633f, -0.02515279f, -0.05797512f, 0.00062709f, 0.01187642f, 0.03709948f, 
    -0.00111489f, -0.04405855f, 0.03099781f, -0.02187463f, -0.01421446f, 0.01520106f, -0.03058240f, -0.04648087f, 
    -0.01373318f, -0.00298854f, -0.02413556f, -0.01606032f, -0.02560894f, 0.03589120f, -0.00481583f, -0.01599012f, 
    -0.04545087f, 0.02483124f, 0.01097288f, -0.03700818f, 0.00823538f, -0.01487417f, -0.00380682f, -0.05440851f, 
    0.02228538f, 0.01675265f, -0.00344508f, 0.03657842f, 0.00146920f, -0.04543180f, -0.01149495f, -0.00154621f, 
    0.02420442f, -0.00111245f, -0.05644087f, -0.02054665f, 0.03380061f, -0.01549578f, -0.00763385f, -0.00187336f, 
    -0.04023017f, 0.01942570f, -0.03194198f, 0.01725644f, -0.02359137f, 0.01991980f, 0.03504037f, 0.02490959f, 
    0.02579587f, 0.00537776f, -0.00903976f, 0.01865890f, 0.04010898f, 0.04336526f, 0.01309146f, -0.05674392f, 
    -0.00342125f, 0.00935788f, -0.02318080f, 0.01258680f, -0.04167065f, -0.00806260f, -0.03896442f, 0.00404934f, 
    0.03345137f, -0.02515029f, 0.03419732f, 0.01457439f, -0.01642635f, -0.03407829f, 0.01603192f, 0.00925007f, 
    -0.01191179f, -0.00223024f, 0.03372142f, -0.04269316f, 0.01793083f, -0.05751518f, 0.03083981f, 0.01938540f, 
    -0.02878166f, 0.03166849f, -0.02653917f, -0.00858070f, 0.03877434f, 0.03347528f, 0.01082316f, 0.04069898f, 
    -0.00887238f, -0.02346662f, 0.00315963f, 0.01094860f, -0.00242593f, -0.03380019f, -0.02687723f, -0.04748860f, 
    -0.00085334f, -0.02951639f, -0.00050058f, -0.02320356f, 0.00666875f, -0.01243393f, -0.00193554f, -0.04501191f, 
    -0.03509091f, -0.00181307f, -0.00569706f, 0.00437414f, 0.01169251f, -0.02435888f, -0.01102531f, -0.05498381f, 
    -0.00807392f, 0.00993445f, -0.02250965f, -0.05825756f, -0.03917017f, 0.01139077f, -0.00480050f, -0.05469000f, 
    0.02936132f, 0.04098797f, -0.01764243f, -0.04364248f, 0.01243054f, -0.05291166f, -0.05663447f, -0.04567697f, 
    -0.01251255f, -0.03534677f, -0.01135946f, 0.01984400f, 0.00907050f, -0.00760876f, -0.00468573f, -0.04514129f, 
    0.03702864f, -0.00578562f, -0.01617939f, 0.02977625f, 0.00477097f, 0.01191433f, -0.01075074f, 0.02550131f, 
    -0.03272993f, 0.01234240f, -0.02477837f, -0.03457561f, -0.01151663f, -0.00167461f, 0.03332788f, -0.02834438f, 
    -0.01198262f, -0.02412286f, 0.03605536f, -0.01945699f, -0.00738487f, -0.00273247f, -0.00517863f, 0.00605343f, 
    -0.01478797f, -0.03657608f, 0.03984592f, -0.02985560f, -0.05327214f, 0.03383642f, -0.05930618f, -0.05916144f, 
    0.00969868f, 0.02998665f, -0.05486808f, -0.01214751f, -0.01464128f, -0.02380803f, -0.01515041f, 0.01946357f, 
    0.00331492f, 0.00779334f, 0.00625959f, -0.02467958f, -0.00483364f, 0.01251453f, -0.01344656f, -0.01043731f, 
    0.01674384f, -0.03583700f, 0.00211828f, 0.03327517f, -0.00280314f, -0.05186101f, -0.03292968f, -0.00365146f, 
    0.00287195f, -0.00482840f, 0.00806602f, 0.04169971f, 0.00111194f, -0.01142766f, 0.03822938f, -0.04169544f, 
    0.00301390f, -0.01283374f, 0.01461857f, -0.04280112f, -0.01783571f, -0.02826227f, 0.02575996f, -0.02667139f, 
    -0.05166014f, 0.02389779f, 0.00575397f, -0.03550247f, -0.02903022f, 0.02981198f, 0.00018184f, -0.01946532f, 
    0.00584577f, 0.02822172f, -0.01378469f, 0.02698188f, 0.01941164f, -0.02509768f, 0.02839208f, -0.03681603f, 
    -0.02126686f, -0.01040589f, 0.00543108f, 0.02617695f, -0.02299383f, -0.01393231f, -0.05768686f, 0.03595418f, 
    -0.04698243f, -0.03265821f, 0.01743793f, -0.00148452f, -0.01472198f, -0.04901831f, -0.04746677f, -0.00616843f, 
    0.02968224f, -0.00290940f, 0.01051765f, 0.00608528f, 0.01297149f, -0.02423482f, -0.03950782f, -0.04506843f, 
    0.01183981f, -0.02947570f, -0.03679507f, 0.02333842f, 0.00524831f, -0.05602768f, 0.01239386f, -0.00514948f, 
    -0.01958723f, -0.05403221f, 0.01617923f, -0.02282484f, 0.03881733f, 0.00573873f, 0.02088828f, 0.02028170f, 
    -0.00958037f, -0.01796674f, -0.01279381f, -0.04511576f, -0.04914921f, -0.04296689f, -0.01775660f, -0.04371800f, 
    -0.00013916f, -0.03761042f, 0.01091009f, -0.05676440f, -0.03649293f, -0.03817509f, 0.01159632f, -0.05243025f, 
    -0.01118553f, -0.05114272f, -0.02285089f, 0.03841406f, -0.02418548f, -0.00160746f, -0.05472254f, 0.03562973f, 
    -0.27430180f, -0.19022262f, -0.15027428f, -0.04312621f, 0.06936504f, 0.12394428f, -0.00923498f, -0.03854609f, 
    0.00872855f, 0.03296684f, 0.08585116f, 0.02842698f, 0.12604778f, 0.14721511f, -0.04987308f, 0.04377879f, 
    0.00434125f, 0.01210492f, -0.04263651f, -0.05983939f, 0.03682690f, 0.01005818f, -0.04398451f, -0.01143778f, 
    -0.10864341f, 0.12208779f, 0.06118153f, 0.17427029f, 0.00480477f, 0.00681624f, 0.00910711f, 0.02101030f, 
    0.02394337f, 0.09666804f, -0.05908856f, 0.02942924f, -0.26389563f, -0.08374112f, 0.25963354f, 0.18674354f, 
    -0.00317670f, -0.03847149f, -0.02192978f, 0.01432126f, -0.06576492f, 0.10046068f, 0.10394304f, 0.06424747f, 
    0.03415666f, 0.30054009f, -0.06994653f, -0.10098977f, -0.01379995f, 0.14169092f, -0.01028900f, 0.01970761f, 
    0.13308801f, -0.09769737f, 0.13645805f, 0.08952343f, -0.29317224f, -0.06624595f, 0.32396919f, 0.02033509f, 
    -0.14394407f, -0.20485398f, -0.01306220f, -0.01200240f, -0.00564800f, -0.04375244f, 0.00920090f, -0.09092135f, 
    -0.05077297f, 0.16788906f, 0.17195296f, 0.11031017f, -0.30763933f, -0.01842608f, -0.01017332f, -0.07875798f, 
    -0.01843965f, -0.05230237f, 0.06717741f, 0.04921582f, -0.00534030f, -0.07024729f, 0.20285472f, 0.14368621f, 
    -0.01050218f, -0.02593060f, 0.02691239f, -0.11717908f, 0.01410085f, -0.06244965f, 0.00908615f, -0.02952555f, 
    -0.14140536f, 0.14916125f, -0.15155751f, 0.03307231f, 0.07907781f, -0.03552001f, 0.06123740f, -0.10128650f, 
    0.14682518f, -0.04201070f, -0.02136911f, 0.00495487f, 0.04981924f, -0.20435469f, 0.23096694f, 0.14709000f, 
    -0.11750484f, -0.11394458f, -0.06730591f, -0.01116714f, -0.00770645f, -0.09674968f, -0.10657125f, 0.08400527f, 
    -0.00694862f, -0.06676006f, -0.14926204f, -0.04208300f, 0.18505879f, 0.04478227f, 0.16391376f, 0.13261649f, 
    0.05257982f, 0.04512321f, 0.04484452f, 0.10007831f, 0.20210348f, -0.13763902f, -0.26977330f, 0.00711646f, 
    -0.07566326f, -0.12839991f, 0.04648147f, -0.06587616f, 0.02400979f, -0.05873585f, -0.15958431f, -0.11722618f, 
    -0.20811659f, -0.09939346f, -0.10877500f, 0.03175002f, 0.01710909f, -0.04902928f, 0.13752721f, 0.15758231f, 
    -0.08382501f, 0.03289407f, -0.02030896f, -0.02832717f, 0.02113470f, 0.09564121f, 0.03740636f, -0.02042898f, 
    -0.15751171f, -0.03701149f, -0.09709948f, 0.09905958f, 0.08366806f, -0.02546551f, 0.20030932f, 0.09143385f, 
    -0.10485657f, -0.34657565f, 0.03487041f, -0.12932722f, 0.08673252f, 0.04515230f, -0.11262123f, 0.09880777f, 
    -0.06985765f, 0.03904504f, 0.12746589f, -0.16775499f, -0.05739943f, -0.03209815f, 0.14204353f, -0.15923506f, 
    0.03758656f, 0.11465932f, 0.10831781f, 0.19605382f, -0.06872534f, -0.06551734f, 0.02902264f, 0.10532154f, 
    0.11150799f, 0.35282257f, 0.21154401f, -0.02857941f, -0.22884104f, -0.04974383f, -0.00221455f, -0.02440846f, 
    -0.02691985f, -0.15578324f, -0.11098159f, -0.01200339f, -0.15732536f, 0.12533291f, -0.02079426f, 0.07512669f, 
    0.15873611f, 0.02035021f, 0.02943817f, -0.10577269f, 0.01948720f, 0.10543691f, 0.01497220f, 0.06066357f, 
    0.12999997f, 0.19062847f, 0.33066902f, 0.08873906f, -0.02650756f, 0.00836266f, -0.00364957f, -0.07082050f, 
    -0.06960735f, -0.03081733f, 0.05166236f, 0.06840618f, -0.62736821f, 0.37039429f, -0.29066816f, 0.12094108f, 
    -0.04719657f, 0.09194864f, -0.02665721f, -0.15460390f, -0.10107981f, -0.04506465f, 0.04867492f, 0.20110478f, 
    -0.14393508f, 0.24975811f, -0.25386748f, 0.24950288f, 0.14320183f, 0.14717036f, 0.30009404f, -0.05621815f, 
    0.10110985f, 0.01315512f, -0.04033826f, 0.13605584f, -0.27661574f, -0.15548161f, -0.07792715f, 0.10608105f, 
    0.04689151f, 0.02193009f, -0.05948491f, -0.02965674f, 0.05429493f, 0.04948451f, 0.02761933f, -0.09393162f, 
    0.17189294f, 0.34010491f, 0.17460978f, 0.03662086f, 0.02336477f, -0.00462674f, 0.00953905f, 0.04656461f, 
    0.15751874f, -0.00923112f, -0.06892496f, -0.07153894f, 0.01578952f, -0.13589615f, -0.01923534f, 0.11349312f, 
    0.01561615f, -0.11833427f, -0.03370553f, -0.07119422f, 0.00992342f, 0.04258106f, -0.01101578f, 0.04780872f, 
    -0.33050075f, 0.13418368f, 0.07893073f, 0.04932300f, 0.08457582f, 0.00806241f, -0.05402300f, -0.02400249f, 
    0.00235098f, 0.07524395f, 0.03545071f, 0.01124840f, -0.21234997f, 0.28962195f, 0.21131581f, 0.03166610f, 
    -0.03256797f, -0.09032004f, 0.23267502f, 0.03623679f, -0.02400141f, 0.05979788f, -0.01704536f, -0.03642325f, 
    -0.16629925f, 0.12638070f, -0.07011945f, 0.22684208f, -0.06356152f, 0.03108942f, 0.06413376f, 0.03893059f, 
    -0.03745143f, 0.12284158f, 0.04360491f, -0.05520268f, 0.01605695f, -0.03879952f, -0.08085024f, 0.02910020f, 
    0.13035816f, -0.09242366f, -0.00156381f, -0.01414993f, 0.11047939f, 0.00184262f, -0.06335814f, 0.04447903f, 
    0.00239008f, 0.01300962f, -0.15889591f, -0.06612707f, -0.05903780f, 0.02137078f, -0.03306649f, -0.03917949f, 
    -0.00432159f, -0.04701624f, -0.07464617f, 0.03000365f, -0.23030424f, 0.39115977f, 0.24081972f, -0.03728581f, 
    -0.19539316f, 0.03006748f, -0.27366018f, 0.08363256f, 0.14911671f, 0.04708868f, -0.00361340f, -0.04287675f, 
    -0.14579903f, 0.33664644f, 0.15016696f, 0.24671158f, -0.11807682f, -0.01804362f, 0.03404668f, 0.06528424f, 
    0.02501237f, -0.15807304f, 0.00646118f, -0.03328579f, 0.12924673f, -0.09394889f, 0.40325046f, 0.06367442f, 
    0.15928723f, -0.06012102f, 0.01997150f, 0.02960500f, 0.07778744f, 0.07131991f, 0.07310884f, 0.12488694f, 
    0.04166575f, 0.03433803f, -0.01783685f, -0.02968720f, 0.02141348f, -0.01269764f, -0.05402734f, -0.00947671f, 
    0.03305304f, 0.01540179f, -0.04805379f, 0.02309594f, 0.01163299f, 0.01894179f, -0.00969485f, -0.01080660f, 
    -0.03121031f, 0.00767159f, 0.02097825f, -0.04591355f, 0.01240061f, 0.00693927f, 0.03797781f, -0.00537322f, 
    0.01946349f, -0.01405851f, -0.04778207f, -0.00609391f, 0.02193809f, -0.03249467f, 0.00918003f, -0.02295030f, 
    0.01000906f, -0.04619706f, -0.02626614f, 0.00221608f, -0.04618742f, -0.04920177f, -0.03534591f, -0.02736459f, 
    -0.04888770f, 0.01723517f, 0.02829335f, 0.03034177f, -0.03668461f, -0.04041081f, -0.04545365f, -0.02176606f, 
    -0.04062995f, -0.02779461f, 0.03659280f, 0.01802870f, 0.04004612f, -0.01288732f, 0.00533259f, -0.02009126f, 
    -0.02818104f, -0.00659017f, -0.00464838f, 0.01643002f, -0.04016107f, -0.00094970f, 0.02116917f, 0.03270129f, 
    -0.04378489f, 0.00977326f, -0.00317236f, -0.01042467f, -0.03974085f, -0.02487546f, -0.04238448f, 0.00627562f, 
    -0.01523111f, -0.02071950f, -0.02886868f, -0.02793657f, -0.05462246f, -0.04096202f, -0.01410067f, -0.04887949f, 
    -0.05068906f, -0.03985227f, 0.02306861f, 0.00376073f, -0.01581564f, 0.01420045f, 0.03223446f, -0.03886902f, 
    -0.04407789f, 0.03956368f, 0.02496895f, 0.03291551f, -0.02594080f, 0.02057968f, -0.02392027f, -0.04596315f, 
    0.01896176f, -0.04413719f, 0.02277662f, -0.00852537f, 0.01557553f, -0.05535498f, -0.01146109f, -0.03449448f, 
    0.03332245f, 0.02344766f, -0.00164512f, -0.04680893f, 0.00239574f, -0.05398426f, 0.00884466f, -0.03609208f, 
    -0.03411989f, -0.05826382f, -0.05662380f, 0.02816350f, -0.03982503f, 0.01690129f, -0.04363214f, -0.01388222f, 
    0.03998924f, -0.01696161f, 0.02160387f, 0.02397141f, -0.00816226f, -0.00373847f, 0.02445873f, -0.02773732f, 
    -0.04425119f, -0.01460548f, 0.01924685f, -0.04794016f, -0.05083434f, -0.00247041f, 0.02315049f, 0.00730600f, 
    -0.02714688f, 0.00813458f, -0.03560283f, -0.04422304f, -0.04238873f, -0.04382468f, 0.02489497f, -0.02252540f, 
    -0.04653379f, -0.00575090f, 0.03052829f, 0.00724885f, 0.04124933f, 0.03872250f, -0.01646810f, -0.00673217f, 
    0.04204155f, 0.02030439f, 0.05147416f, 0.02886926f, -0.01812732f, -0.01583799f, 0.00899458f, -0.01159976f, 
    -0.05094034f, -0.01706382f, -0.03074369f, -0.04336116f, 0.02633448f, -0.03077263f, -0.02003846f, 0.00131276f, 
    -0.00955529f, 0.01153928f, -0.01898229f, -0.04138830f, -0.03244287f, 0.02658047f, -0.01610448f, -0.01063655f, 
    -0.04324507f, -0.00765043f, -0.02959318f, -0.00267017f, 0.01185810f, -0.05457360f, 0.00176048f, -0.03064655f, 
    -0.02518825f, -0.02533517f, 0.02833869f, 0.00833008f, 0.04060363f, 0.03538087f, 0.03005868f, 0.00217563f, 
    0.00122299f, -0.03394742f, -0.01789356f, -0.03082045f, -0.00731747f, 0.04071075f, -0.02159468f, -0.04689186f, 
    -0.03758097f, -0.03814565f, -0.00236465f, -0.03512772f, 0.01649223f, 0.00006801f, -0.03233217f, 0.00619857f, 
    0.02032317f, 0.02385822f, 0.03049497f, 0.01714355f, -0.02611791f, -0.03451161f, 0.03484307f, -0.02902132f, 
    -0.00255916f, 0.02495364f, -0.01013026f, 0.03726494f, 0.00802650f, -0.04597201f, -0.01668417f, -0.00020613f, 
    -0.02706168f, -0.01694705f, -0.02190342f, -0.05634382f, -0.04213571f, -0.00208508f, 0.03570289f, 0.03911391f, 
    0.01085680f, 0.00852486f, -0.02705250f, -0.05868576f, -0.05346603f, -0.04848680f, 0.00924277f, 0.02368015f, 
    -0.03323894f, 0.03509824f, -0.05602805f, 0.03216290f, 0.01663537f, -0.00745184f, 0.03211877f, 0.04272852f, 
    -0.00705602f, -0.00518321f, 0.01622818f, -0.03257279f, 0.01089748f, -0.04566979f, 0.02874806f, 0.04981224f, 
    -0.02260327f, 0.02001252f, -0.03768839f, 0.00407832f, 0.03143466f, -0.03290689f, -0.01977034f, -0.05489979f, 
    0.03639135f, -0.00810875f, -0.03584137f, -0.00787126f, 0.02644116f, 0.01760542f, 0.01557998f, -0.02927213f, 
    -0.02180418f, -0.05346334f, -0.05465339f, 0.03428569f, 0.03239774f, -0.01011994f, -0.02878823f, 0.03498287f, 
    0.04038050f, -0.03373069f, 0.01826883f, -0.03131749f, -0.04309643f, -0.03229922f, 0.00100504f, -0.04068452f, 
    0.02289349f, -0.00858612f, 0.02890095f, 0.04234989f, 0.01725700f, -0.03684224f, -0.02553964f, 0.04175536f, 
    -0.03576338f, 0.01172660f, 0.03796704f, 0.00987384f, -0.03135608f, -0.02024246f, 0.02322021f, -0.03549502f, 
    0.03372783f, -0.04577298f, -0.04829441f, -0.05078202f, -0.02638616f, -0.03077718f, -0.00071776f, 0.04294658f, 
    0.04686128f, 0.03628069f, -0.02594822f, 0.01897746f, 0.00713399f, -0.03995125f, -0.03682179f, 0.01468514f, 
    -0.01828117f, 0.04336191f, -0.02766287f, -0.03931041f, -0.03226752f, -0.03649808f, -0.03506887f, -0.01392760f, 
    -0.00910739f, 0.00140973f, 0.03482101f, -0.04123287f, -0.03374540f, 0.01215155f, -0.04384762f, 0.02501658f, 
    -0.00037404f, -0.05497125f, 0.03399644f, -0.04136413f, 0.00787244f, 0.04365855f, -0.04166619f, -0.05562282f, 
    -0.01888582f, -0.02076093f, 0.00941974f, 0.01134516f, -0.05311881f, 0.00848600f, -0.03956005f, -0.02501527f, 
    0.00227341f, -0.02842268f, 0.04468941f, 0.00919078f, -0.03747593f, -0.05021236f, -0.01395591f, 0.03534867f, 
    -0.02134693f, -0.00535106f, 0.00288123f, -0.04159051f, -0.01314869f, 0.03363758f, 0.02254869f, 0.04320085f, 
    -0.03911651f, -0.05331906f, 0.01409542f, -0.03647973f, 0.00419234f, 0.04408906f, -0.01751138f, -0.02554789f, 
    -0.00451354f, 0.01321373f, 0.03288336f, 0.02609501f, -0.02358013f, 0.01932183f, 0.01815163f, -0.05244593f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03162494f, 0.10052665f, 0.10277893f, 0.04041376f, 0.03192915f, 0.00581589f, 0.10295854f, -0.01045231f, 
    0.16907108f, -0.01293537f, -0.05615785f, -0.05588258f, 0.04818006f, -0.07056975f, 0.01721940f, -0.00982621f, 
    0.12438910f, 0.16605863f, 0.02233795f, 0.06503972f, -0.02895303f, 0.04283981f, 0.15200956f, 0.03935349f, 
    -0.05139393f, -0.03353129f, 0.10066842f, -0.07633784f, 0.02526510f, 0.08811510f, -0.05138774f, -0.00999694f, 
    -0.06211772f, 0.19879380f, 0.00189513f, 0.11117163f, -0.02778268f, 0.03574885f, -0.05289109f, 0.00072329f, 
    -0.05236951f, 0.12280269f, 0.02790119f, 0.14140409f, 0.02547195f, -0.04791871f, -0.00198593f, 0.02873712f, 
    -0.03488608f, -0.08171817f, -0.04455769f, 0.05530468f, 0.07615876f, -0.05335158f, -0.02840537f, 0.00517680f, 
    0.02455937f, 0.08373615f, -0.02513663f, 0.15093766f, 0.02500156f, 0.01221390f, 0.13121037f, 0.03470997f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.31633046f, -0.25645089f, -0.53154856f, 0.03149342f, 0.32590091f, 0.06016696f, -0.34626743f, -0.06706685f, 
    -0.14188451f, -0.02694333f, 0.02382996f, -0.01023109f, -0.08212272f, 0.12241279f, 0.21937370f, -0.08442259f, 
    -0.15395920f, -0.54331017f, 0.14291084f, -0.22464527f, -0.01942941f, -0.09966294f, -0.12141008f, -0.25892612f, 
    -0.02937095f, 0.14454570f, 0.09171993f, 0.15763490f, -0.10031230f, -0.36166528f, 0.29599392f, -0.03958753f, 
    0.23153588f, -0.32085672f, -0.00573362f, 0.30393696f, 0.13043605f, -0.32324925f, -0.06343378f, 0.13098340f, 
    0.04257579f, -0.05244071f, -0.01275421f, -0.15707071f, -0.04468893f, 0.13623142f, -0.08801722f, 0.00327042f, 
    0.06667674f, 0.08305751f, -0.11102279f, 0.06308531f, 0.14810087f, 0.10802258f, -0.46827450f, -0.30340517f, 
    -0.42664355f, 0.11257374f, -0.00624086f, 0.05678658f, 0.00601605f, -0.06258720f, -0.13828915f, -0.07184749f, 
    -0.01872366f, -0.24573755f, 0.08365418f, -0.03532235f, -0.28533077f, -0.04540279f, -0.02376657f, -0.02911210f, 
    0.28025803f, 0.02341659f, -0.04971022f, 0.09208265f, 0.02867401f, -0.02729629f, 0.07389482f, 0.08418623f, 
    -0.18800803f, -0.30052063f, 0.26105243f, 0.20919895f, -0.40221664f, -0.08229052f, 0.34893295f, 0.04699620f, 
    0.10612608f, -0.01952339f, 0.14904170f, 0.11021707f, 0.04217795f, -0.14777125f, -0.56711537f, -0.05146227f, 
    -0.08539965f, -0.00897686f, 0.07691504f, 0.25608972f, 0.06583241f, -0.23324358f, 0.08808744f, -0.10576986f, 
    -0.21671309f, 0.27272034f, -0.08970678f, 0.23102832f, -0.00917548f, -0.36064512f, -0.09716493f, -0.06037098f, 
    -0.19082494f, 0.38564357f, -0.03584814f, 0.02935342f, 0.34051830f, 0.07411871f, -0.14139098f, 0.11337989f, 
    0.10447203f, 0.06623064f, 0.07520135f, 0.17423454f, -0.01778132f, -0.10106967f, -0.00510083f, 0.02705341f, 
    -0.14502145f, 0.01117194f, 0.11533425f, 0.00233358f, -0.38597256f, 0.04749782f, -0.00396237f, 0.07484944f, 
    0.30898574f, 0.05608398f, 0.10260465f, 0.00666729f, -0.21265854f, -0.41685343f, 0.12732300f, -0.22093213f, 
    0.20331556f, 0.05097211f, 0.18296033f, 0.19046314f, 0.38030380f, -0.08293820f, -0.54697526f, 0.11086626f, 
    0.05961404f, -0.16815637f, 0.32954314f, -0.27138036f, -0.07262370f, -0.19896080f, -0.12032100f, 0.12210482f, 
    -0.10482091f, -0.03810550f, 0.07960767f, -0.02903980f, 0.09290983f, -0.02230585f, -0.00304042f, -0.35826352f, 
    0.05764584f, 0.37572461f, 0.09720655f, 0.04944549f, -0.02401849f, 0.10178746f, -0.09939997f, -0.04511460f, 
    0.06440707f, -0.50565583f, 0.03258240f, -0.25716326f, -0.05411508f, -0.11569957f, -0.20355001f, -0.13610408f, 
    0.34595528f, 0.13253525f, -0.03749909f, 0.08952585f, 0.06991978f, 0.01135972f, 0.15087520f, 0.10310316f, 
    0.11361131f, 0.05868186f, 0.13307451f, -0.03159836f, -0.10961290f, -0.10519256f, -0.27349496f, 0.08822598f, 
    -0.11189765f, -0.03504383f, -0.06296081f, -0.01744360f, -0.15362185f, 0.16629329f, 0.17402917f, 0.17179574f, 
    0.01934970f, -0.14652731f, -0.03499489f, 0.24666327f, 0.17920466f, -0.05569157f, -0.25459355f, 0.32844216f, 
    0.02659087f, 0.00061716f, 0.11741690f, 0.14804152f, -0.01088645f, -0.63070577f, 0.08679343f, 0.05490608f, 
    -0.15148646f, -0.20298696f, -0.06399683f, -0.23057579f, -0.07361783f, -0.49507827f, -0.02514873f, -0.04330377f, 
    -0.21419285f, 0.03050395f, -0.00783015f, -0.24454981f, -0.04345864f, 0.19217877f, 0.10801417f, -0.00886805f, 
    0.10459472f, -0.04841764f, -0.11152968f, -0.07754729f, -0.49397412f, 0.17190097f, -0.06172954f, 0.32534561f, 
    0.31032363f, -0.12942016f, -0.06620599f, -0.55987060f, -0.07740548f, 0.07699778f, -0.15416165f, 0.00487851f, 
    -0.30186495f, -0.25372428f, 0.15513881f, 0.04972703f, -0.30393550f, -0.05351099f, 0.07430160f, 0.08691127f, 
    -0.13882814f, -0.01059689f, 0.10166544f, 0.00134845f, 0.22180216f, 0.14124958f, -0.17409045f, 0.12628961f, 
    0.00407585f, -0.01064630f, 0.16706093f, 0.04218325f, 0.00276690f, -0.05749437f, 0.05224021f, -0.37295115f, 
    -0.10014421f, 0.06484227f, -0.26306382f, 0.16467920f, -0.05340209f, 0.11802363f, 0.03476503f, 0.12110586f, 
    0.07873841f, -0.39478475f, 0.09689577f, -0.35162845f, -0.10236297f, 0.13113667f, 0.08104686f, 0.19443381f, 
    0.05009763f, 0.16583554f, 0.03553908f, -0.08522719f, -0.08198996f, -0.03286873f, -0.13258353f, 0.10278063f, 
    0.20161913f, -0.10735316f, -0.03853838f, -0.18310244f, 0.07408615f, 0.16260554f, 0.09231133f, -0.28682053f, 
    -0.18815827f, 0.06184727f, -0.07259545f, 0.04121746f, 0.08437963f, 0.03810548f, 0.01446082f, -0.04279402f, 
    0.02786520f, -0.16238189f, -0.22440189f, -0.00179419f, 0.45699480f, -0.07629127f, 0.13976476f, -0.03338365f, 
    0.21040054f, 0.08683716f, -0.07280489f, 0.06954494f, 0.29825151f, 0.14104122f, 0.07660902f, 0.14694294f, 
    0.21024348f, 0.03472711f, -0.25515005f, -0.03847187f, -0.52780217f, -0.09192933f, -0.09345698f, -0.43525901f, 
    0.02776504f, 0.13758010f, -0.04747803f, -0.12157306f, 0.07982255f, 0.05721418f, -0.12041678f, 0.09139898f, 
    0.32928026f, 0.25852329f, -0.01162976f, 0.07232401f, 0.06534573f, 0.02754363f, 0.01103901f, -0.08612913f, 
    0.00487040f, -0.12169140f, 0.06422033f, 0.05032200f, 0.03999964f, -0.31910139f, -0.02686308f, -0.10419325f, 
    -0.07136165f, -0.24535792f, 0.05134100f, 0.23365454f, -0.37630478f, 0.03403721f, -0.24625961f, -0.14135407f, 
    -0.59483957f, 0.18395239f, 0.06093392f, -0.17987530f, 0.03005030f, -0.10978886f, 0.00995197f, 0.11347001f, 
    0.17102656f, 0.18733713f, 0.16183160f, 0.05438703f, -0.14396507f, 0.00985570f, 0.15601978f, 0.09587070f, 
    -0.16629741f, -0.00969803f, -0.07619552f, -0.05182328f, -0.10668579f, -0.25581735f, -0.31086066f, -0.41051301f, 
    0.30164286f, 0.25469187f, -0.37424755f, -0.36867279f, 0.15585135f, -0.03281264f, -0.21881637f, 0.11546500f, 
    -0.00022834f, -0.29727167f, -0.43038002f, 0.03414629f, 0.09756323f, 0.35213482f, -0.36977392f, -0.06318191f, 
    -0.74720806f, -0.02926458f, 0.10409248f, -0.21617599f, -0.10293250f, -0.13882227f, -0.08648653f, 0.09500390f, 
    0.08064814f, 0.25685036f, -0.09461533f, -0.23733376f, 0.11192437f, 0.05786046f, -0.01249189f, 0.07699786f, 
    -0.36970627f, -0.05749729f, -0.10180838f, 0.13272317f, 0.11939996f, -0.62789232f, -0.01850119f, -0.04664903f, 
    -0.13347505f, -0.30706453f, -0.12222809f, 0.21836945f, 0.04544232f, 0.07103167f, 0.14920445f, 0.08743173f, 
    0.05775916f, -0.10747081f, 0.21157525f, -0.12137360f, 0.32748482f, -0.03370671f, 0.06981129f, 0.04828934f, 
    -0.05282003f, -0.04552532f, 0.06504543f, 0.01999512f, -0.16933562f, -0.07529823f, 0.13646646f, 0.31788746f, 
    -0.36370784f, -0.28704512f, -0.39342996f, -0.21614419f, 0.26486287f, -0.07070661f, 0.11917939f, 0.03926284f, 
    0.09931620f, -0.40898767f, -0.16341123f, 0.07000893f, -0.03176548f, -0.02812325f, 0.27964997f, 0.01034704f, 
    0.29007626f, -0.09891597f, -0.09435344f, -0.27473131f, -0.13043870f, 0.08118181f, 0.10941479f, -0.16558623f, 
    0.03581801f, -0.58431304f, 0.09036510f, -0.14049457f, 0.02295965f, 0.31129861f, -0.02517256f, -0.05729299f, 
    -0.38071597f, -0.32362661f, -0.10738840f, -0.28269750f, 0.16871512f, -0.35658672f, 0.12514523f, -0.12926950f, 
    0.15680905f, -0.15112944f, -0.01648987f, -0.18594243f, 0.05778440f, 0.09131971f, -0.37992480f, -0.02014697f, 
    -0.11500000f, 0.30814442f, -0.32000566f, 0.00018094f, 0.43684399f, 0.04404766f, 0.10773370f, 0.09245907f, 
    0.01976781f, 0.11259475f, 0.01160577f, -0.10128893f, 0.12746599f, -0.18196233f, 0.04602051f, 0.19792832f, 
    -0.49209830f, -0.23331976f, -0.21414292f, 0.35927394f, -0.19822784f, -0.07762149f, -0.18595266f, 0.32268792f, 
    0.02099941f, -0.20048261f, 0.19536221f, -0.28341818f, 0.08720545f, -0.36536682f, -0.29563639f, 0.10657693f, 
    -0.74181437f, 0.18815158f, -0.03304312f, 0.18720829f, 0.00352953f, 0.15842886f, 0.09230632f, 0.06287258f, 
    -0.28584710f, -0.45313624f, -0.06029195f, 0.20638302f, 0.06021453f, 0.18762504f, 0.00509559f, -0.02405296f, 
    -0.28523859f, -0.32114542f, 0.09405778f, 0.01438544f, -0.11659893f, -0.54377371f, 0.06322089f, 0.03405584f, 
    -0.08939826f, 0.13652946f, -0.04896525f, -0.28717160f, -0.00323022f, -0.03995816f, -0.39944708f, -0.10781047f, 
    0.06455220f, 0.14651646f, 0.08406952f, 0.06159294f, -0.55521417f, -0.11407782f, -0.14462517f, 0.03916283f, 
    0.14562884f, 0.06283361f, 0.05031234f, -0.09308660f, -0.48690882f, 0.18127172f, -0.26627955f, 0.10563154f, 
    0.09686181f, 0.04717150f, -0.07993311f, -0.01994997f, -0.23492473f, 0.06529652f, -0.11277096f, -0.23043850f, 
    0.10475880f, -0.23327395f, -0.15103176f, -0.26177660f, 0.01773432f, 0.31257653f, 0.34825969f, 0.02904001f, 
    0.30422312f, 0.06768946f, -0.04838095f, 0.14642197f, -0.07543971f, 0.38007990f, 0.05575282f, 0.26840806f, 
    0.21078385f, -0.33450553f, 0.01040908f, -0.40046322f, -0.12868059f, -0.40282464f, 0.00829633f, 0.07632360f, 
    0.16752616f, -0.13401461f, 0.10092500f, -0.45075497f, 0.23627096f, -0.00756972f, -0.16467439f, 0.14089409f, 
    0.17801757f, -0.09154961f, -0.00565375f, 0.19926815f, 0.03722867f, 0.06913978f, 0.04559085f, 0.01412152f, 
    -0.17865631f, -0.25039551f, -0.20844387f, 0.04215135f, -0.00200340f, 0.01891097f, -0.15847667f, -0.10669833f, 
    -0.01893374f, -0.00958125f, 0.03849723f, 0.09529191f, -0.00440807f, -0.60088867f, 0.01407946f, -0.11892421f, 
    -0.10118077f, 0.28739280f, -0.46984011f, -0.15022855f, -0.01826109f, -0.08902735f, -0.37908530f, 0.31833303f, 
    0.10090972f, 0.29739061f, 0.27510017f, 0.10400116f, -0.08934248f, 0.18710631f, -0.60284847f, 0.08041289f, 
    0.10839691f, -0.20707910f, -0.10444894f, -0.15345143f, -0.09991706f, -0.52091038f, -0.02635308f, -0.00794939f, 
    -0.18563795f, -0.29480261f, 0.03557635f, 0.09523020f, -0.11341855f, 0.27059829f, 0.03757678f, -0.03690131f, 
    -0.30217308f, 0.20234698f, 0.01459748f, 0.23914203f, 0.29733354f, 0.17313112f, 0.36480668f, 0.17227991f, 
    -0.30597857f, 0.04928976f, -0.03220192f, -0.24203257f, 0.07427117f, -0.02878065f, 0.32546893f, -0.02046557f, 
    0.12312613f, 0.16707581f, -0.08311255f, -0.03804668f, -0.30670863f, -0.04271471f, 0.22035556f, 0.11211005f, 
    -0.53542131f, 0.06784580f, 0.02281455f, 0.12051027f, 0.21868649f, 0.10350570f, -0.48941958f, -0.52493393f, 
    -0.28046814f, 0.27263510f, -0.11331522f, -0.35116494f, -0.07848343f, -0.08954496f, -0.04101695f, -0.02406155f, 
    -0.11166265f, -0.47594646f, -0.00997622f, 0.19477403f, 0.01191147f, -0.36068529f, -0.12945017f, 0.00749679f, 
    -0.11107530f, 0.06878852f, 0.02631333f, 0.21256331f, -0.02369777f, 0.22392732f, -0.04252728f, -0.43309110f, 
    -0.20328645f, 0.22099824f, -0.09142910f, 0.24565510f, -0.06264509f, -0.44661468f, -0.06217147f, -0.05542601f, 
    0.28182131f, -0.10742163f, 0.03992942f, 0.24101245f, -0.23303874f, 0.05792177f, 0.28460819f, 0.21344940f, 
    0.22472391f, -0.08109509f, 0.11900400f, -0.30779251f, -0.00655738f, -0.05483166f, -0.41092625f, 0.08950911f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.01931705f, 0.01334399f, 0.09018624f, -0.14418454f, -0.13436599f, -0.06697606f, 0.14912158f, -0.07105463f, 
    0.09822967f, -0.08903532f, 0.09260515f, 0.11572616f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
