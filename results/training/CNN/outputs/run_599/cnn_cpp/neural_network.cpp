#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.77261347f, 0.86709821f, 0.48688856f, 0.98436606f, 0.81688184f, -0.58262450f, 0.28511396f, -0.08172578f, 
    0.07586161f, 0.22570387f, -0.46122831f, 0.00655653f, 0.19236989f, -0.03900058f, -0.08135830f, 0.06922314f, 
    0.34322381f, 0.42756712f, 0.22532576f, 0.50956327f, -0.03917798f, -0.05244382f, -0.03574876f, -0.12347109f, 
    0.16640553f, 0.65035492f, 0.61246246f, -0.69571114f, 0.57503802f, 0.78793639f, -0.55074692f, -0.66274250f, 
    0.12231223f, -0.12216687f, -0.22124995f, 0.33705056f, 0.34311619f, 0.07437404f, 0.12837169f, 0.22564319f, 
    0.39184633f, -0.21716985f, -0.41821706f, 0.41611183f, -0.52513635f, 0.02895375f, 0.03546942f, -0.07888608f, 
    0.28294528f, -0.40290299f, -0.75281036f, -0.58773696f, -0.16104828f, -0.32824320f, -0.57410640f, -0.37522769f, 
    -0.09833682f, 0.49982983f, 0.30553991f, -0.66607547f, -0.26203543f, -0.32159397f, -0.40862852f, -0.33556780f, 
    0.19454247f, 0.31214482f, -0.08195020f, -0.67109823f, -0.36347038f, 0.28078976f, 0.02798838f, 0.60187250f, 
    0.62451059f, -0.17307797f, 0.00140659f, -0.11611661f, 0.10200032f, -0.37858024f, 0.79057884f, 0.74176973f, 
    -0.28792170f, 1.04624832f, 1.02819180f, -0.15196010f, 0.44847402f, -0.20122191f, -0.23723166f, -0.06930574f, 
    0.01130957f, 0.27388740f, -0.07029606f, 0.10625467f, 0.13622849f, -0.00739330f, 0.14435914f, 0.79917526f, 
    0.08634397f, 0.05820473f, -0.20165123f, -0.16259599f, -0.67601341f, 0.99682128f, -0.38576594f, -0.57003933f, 
    -0.18964751f, -1.02289176f, -0.64668155f, -0.38562855f, -0.81046593f, -0.31711265f, 0.38302231f, 0.18877250f, 
    -0.38475043f, 0.22504318f, -0.51605749f, -0.48814833f, -0.12371652f, -0.17748488f, -0.20285998f, -0.36741033f, 
    0.05986582f, -0.06219704f, 0.20748660f, 0.15826827f, 0.39925331f, -0.79797703f, -0.60727251f, -0.63149989f, 
    -0.44800720f, 0.43024248f, 0.28664520f, 0.25434044f, 0.68424726f, 0.55690569f, 0.37605900f, 0.25087884f, 
    -0.19691174f, 0.28400341f, -0.18210171f, -0.01699925f, 0.29663184f, 0.12872237f, 0.44093743f, 0.10614413f, 
    -0.19863394f, -0.19061148f, -0.15432456f, -0.23921241f, 0.26505104f, 0.32862452f, -1.33317518f, 0.91877776f, 
    0.64634192f, 0.32383013f, 0.45391425f, 0.42902789f, 1.27238667f, 0.30844995f, -0.46536571f, 0.39136046f, 
    -0.00638991f, -0.03826019f, 0.46985799f, -0.38671464f, 0.04942999f, -0.06389546f, 0.20713522f, 0.15890160f, 
    -0.02678647f, -0.08729217f, 0.15618849f, 0.06123578f, 0.07440507f, 0.02757844f, -0.14705263f, -0.04852336f, 
    -0.70984632f, -0.77795017f, -0.46480927f, -0.10384620f, -0.26226115f, 0.90098286f, 0.49300134f, 0.02979408f, 
    0.58007503f, -0.18010007f, -0.46375278f, -0.07841449f, -0.19827767f, -0.50563192f, -0.49249953f, -0.09720807f, 
    -0.39008868f, 0.12551098f, -0.34336922f, -0.09252312f, 0.43212953f, -0.35179183f, -0.21540502f, 0.11566715f, 
    0.93560541f, 0.64117640f, -0.22814272f, 1.05629909f, 0.90246046f, 0.83622056f, 0.15032963f, 0.33258939f, 
    -0.40567642f, -0.68889719f, 0.01245866f, -0.16931054f, -0.36705744f, -0.19767062f, 0.04631578f, -0.01742169f, 
    -0.13901590f, 0.04653250f, -0.04388532f, 0.11142250f, -0.16301064f, 0.06310358f, 0.04677775f, 0.08757740f, 
    0.03347877f, 0.21035315f, -0.87888950f, -0.87698960f, -0.77373046f, 0.26464137f, 0.16240308f, -0.22744451f, 
    -0.60786545f, -0.59603000f, 0.22832890f, 0.12370742f, -0.04902883f, 0.61493981f, 0.00450078f, 0.24919586f, 
    -0.18524641f, 0.22676183f, 0.08658402f, 0.10889746f, -0.18937676f, 0.17556435f, -0.19499739f, 0.27369216f, 
    0.12931180f, -0.31091192f, 1.28962004f, -0.90121007f, 0.74312246f, -0.01282176f, 0.05175303f, -0.32522741f, 
    -0.25912291f, 0.22714767f, 0.61321902f, -0.02842343f, -0.17146735f, -0.06971496f, -0.22971511f, -0.07582912f, 
    -0.46948734f, 0.16415730f, 0.12976611f, 0.03897490f, 0.11862251f, 0.13240470f, -0.42511341f, 0.12647443f, 
    -0.10556298f, -0.20107566f, -0.24415119f, 0.65204310f, 0.82951593f, 0.35308447f, -0.56085104f, 0.57664651f, 
    -0.08894753f, -0.14648092f, 0.58858067f, -0.51720262f, -0.59145838f, -0.18500394f, 0.10717440f, 0.23053990f, 
    0.43914384f, -0.44577122f, 0.23727508f, -0.11795906f, -0.07507668f, -0.39436418f, -0.24835637f, -0.45169091f, 
    -0.02782024f, 0.29417166f, -0.34752101f, -0.25952289f, -0.10544307f, 0.55055827f, 0.62035352f, 0.94679153f, 
    -0.09619695f, 0.38234279f, -0.55184978f, -0.09198123f, -0.03980255f, -0.13835570f, 0.15718995f, 0.37526637f, 
    -0.49167442f, 0.21141180f, -0.14372453f, 0.36269835f, -0.10799584f, -0.33216420f, -0.17597359f, 0.12159061f, 
    0.00069231f, -0.67339212f, -0.03013764f, -0.65493166f, -0.44861069f, 0.54538643f, 0.93387616f, 0.21559487f, 
    -0.79882044f, 0.19778657f, -0.62743843f, -0.19451344f, -0.11158336f, -0.11907721f, 0.72724932f, 0.00070655f, 
    0.26559636f, 0.41835797f, -0.32553199f, -0.22890913f, 0.33853522f, 0.28589243f, -0.70889610f, 0.27445373f, 
    0.74919301f, -0.45093304f, -0.16747114f, -0.25192174f, 0.10295351f, 0.03162660f, 1.42448997f, 0.82295394f, 
    0.88747209f, -0.22615285f, 0.37494770f, 0.14495237f, -0.89260322f, -0.29138929f, 0.22914273f, 0.24414298f, 
    -0.06065916f, 0.04160249f, -0.06154437f, 0.25254986f, 0.26073527f, -0.10674873f, -0.10959989f, -0.19295067f, 
    -0.03655888f, -0.45529884f, 0.24151327f, 0.40507698f, 0.08510897f, -0.21229233f, 0.36152130f, -0.80318761f, 
    0.84424442f, -0.63422471f, -0.70929009f, -0.76024079f, 0.79957741f, 0.47744611f, 0.14470385f, 0.26549891f, 
    -0.07494123f, -0.38505435f, 0.13502535f, -0.48504490f, -0.07220164f, -0.27029252f, 0.46316063f, -0.04935803f, 
    0.13583000f, 0.08108930f, -0.04148307f, 0.39825141f, -0.10888715f, -0.21498592f, 0.24720606f, 0.51530308f, 
    0.83680236f, 1.08175874f, -0.26164252f, 0.13741714f, -0.00902945f, -0.39678887f, 0.47550333f, 0.12076945f, 
    -0.04365581f, 0.47279546f, 0.36046180f, 0.25881070f, 0.01870604f, -0.20251352f, -0.33519801f, 0.10217724f, 
    -0.13388385f, 0.21624453f, 0.16034694f, -0.17317435f, 0.38884041f, 0.25540814f, -0.31756002f, 0.18075797f, 
    0.48507339f, 0.38943174f, 0.37734565f, 0.63409179f, 0.71944910f, 0.84401554f, -0.66848028f, -0.49782136f, 
    -0.60429418f, -0.63891101f, -0.03127324f, 0.33027729f, 0.10205000f, 0.21453907f, 0.20013189f, 0.33164942f, 
    0.12011117f, 0.44834283f, 0.39661634f, -0.19607280f, 0.48664254f, 0.13193317f, -0.06341946f, -0.10275183f, 
    0.32928365f, 0.22696829f, -0.58030844f, -0.99575943f, -0.58523494f, -0.35147548f, -0.32085809f, -0.70467269f, 
    0.68218470f, 0.80005348f, -0.47399420f, 0.33626667f, -0.24349681f, -0.13962185f, 0.02764875f, -0.42064080f, 
    -0.14856121f, -0.25457135f, 0.16027001f, -0.01054654f, 0.09197574f, -0.20217748f, -0.08351529f, -0.03084346f, 
    0.12347257f, 0.14900865f, 0.23682687f, -0.31676251f, -0.68297583f, 0.47771841f, 0.88273162f, -0.28400546f, 
    -1.14045429f, -0.35028768f, 0.22884993f, -0.53201938f, -0.31910279f, -0.07834005f, 0.37126514f, 0.32463673f, 
    -0.09992084f, 0.01612121f, -0.07548926f, 0.04226430f, 0.10916945f, 0.39637691f, 0.04901436f, -0.35202929f, 
    -0.19398300f, -0.07000009f, -0.04995505f, 0.11050227f, 0.94200712f, 0.92690974f, -1.02973855f, -0.36632428f, 
    -0.64834005f, 0.52159119f, -0.08093011f, -0.73100913f, -0.34653398f, 0.10800190f, -0.01612620f, 0.49153709f, 
    0.65714693f, 0.40033802f, -0.10145245f, 0.19698951f, -0.04891423f, 0.02300070f, 0.32064649f, 0.30176267f, 
    0.20639324f, 0.31008422f, 0.36243430f, -0.27320164f, 0.03386977f, 0.72566360f, -0.01955296f, -0.33583882f, 
    -0.47046590f, 0.15551175f, 0.72089553f, 0.32357463f, 0.82893813f, 0.34862849f, 0.75930125f, 0.35962754f, 
    -0.35501760f, -0.30442324f, -0.05625624f, -0.04693615f, 0.27008149f, 0.28027311f, -0.46339834f, 0.06571740f, 
    0.31508708f, 0.33684051f, -0.30492276f, -0.47665647f, 0.02492669f, -0.22425270f, -0.78329271f, -0.78107148f, 
    -0.39594990f, -0.05535552f, 0.68041295f, 0.84596908f, 0.73137730f, 0.34427604f, -0.13498802f, -0.12161181f, 
    0.36681834f, 0.21790676f, 0.36972767f, 0.05127662f, 0.14690313f, -0.39654517f, -0.17010623f, -0.56186926f, 
    -0.28857708f, -0.23902984f, 0.23785059f, -0.33153439f, -0.02817503f, 0.10342111f, -0.03767546f, 0.93808842f, 
    0.55952549f, -0.80643022f, -1.12168121f, -1.14735830f, -0.31047571f, -0.18867834f, -0.30373293f, 0.08937150f, 
    -0.50626695f, 0.25815910f, 0.00783397f, -0.24508935f, 0.03293853f, -0.26098311f, 0.16234151f, 0.19651759f, 
    -0.01364742f, -0.03861428f, -0.05334909f, -0.16380072f, -0.14795811f, 0.12658255f, 0.19503038f, 0.12131370f, 
    0.25933754f, 0.58588719f, -0.10962317f, 0.79220641f, 1.12101579f, 1.12104023f, -0.19307415f, -0.98672462f, 
    0.41701415f, -0.26358172f, -0.53973603f, 0.32266739f, -0.26642954f, 0.54277635f, -0.57426155f, -0.13143733f, 
    0.13525468f, 0.28552431f, -0.21439259f, -0.12930001f, 0.09883676f, -0.19204125f, -0.25093338f, -0.01023743f, 
    0.09710209f, -0.87756729f, 1.09969676f, 0.17434166f, -1.46531045f, 0.50499481f, 0.16288567f, -0.13382030f, 
    0.44069114f, 0.77467448f, 0.30289081f, -0.02585121f, -0.34206438f, -0.38486382f, 0.57240540f, -0.00729579f, 
    -0.25480288f, 0.07652859f, -0.00721954f, 0.24044029f, 0.08858795f, -0.02544608f, 0.17009830f, 0.05903876f, 
    0.30386856f, 0.19750080f, 0.67605013f, 0.54514426f, 1.06309342f, 0.63720548f, -0.46431401f, -1.14120579f, 
    0.54998720f, -1.06700480f, -0.24904616f, -0.07391563f, 0.36672151f, 0.31609032f, -0.22381854f, -0.05284433f, 
    -0.16770488f, -0.29802093f, -0.03340653f, 0.15618916f, 0.22721316f, 0.07117777f, 0.17661425f, 0.44171157f, 
    0.37120360f, 0.19657917f, 0.18676972f, -0.37590793f, -0.96909016f, -0.47964317f, -0.26576596f, -0.09601304f, 
    0.34509477f, 1.07808805f, -0.49714771f, 0.28239512f, 0.49971336f, 0.09325425f, 0.26195008f, -0.15603846f, 
    -0.19879645f, 0.30425793f, -0.00132238f, 0.25585735f, 0.06104155f, 0.09753520f, -0.07936248f, -0.29565561f, 
    -0.29145244f, -0.18913999f, 0.00005036f, -0.14832866f, 1.13763487f, 0.37837389f, 0.18082915f, 0.80058002f, 
    0.84887695f, 0.62794411f, 0.40732023f, -0.07786840f, 0.27844414f, 0.37662521f, -0.27327681f, -0.21761531f, 
    -0.13512887f, -0.10118142f, -0.19673622f, -0.30791506f, -0.48983690f, -0.11331475f, -0.15987566f, 0.04425447f, 
    0.43695086f, 0.14682896f, 0.46326706f, 0.11153172f, 0.45525625f, 0.94483483f, -0.66558415f, 0.36330318f, 
    0.17681478f, -0.06899855f, 0.28202787f, 0.78994197f, 0.48598900f, 0.42928341f, 0.36562270f, -0.28493389f, 
    -0.47356236f, -0.59838957f, -0.34540415f, -0.24327643f, -0.46271273f, -0.35548913f, -0.52971959f, 0.19769979f, 
    -0.18385661f, -0.17824678f, -0.21929260f, 0.09606246f, -0.25268012f, -0.31877416f, -0.05565876f, 0.53108096f, 
    0.55694753f, 0.59605020f, -0.35580283f, -0.68839163f, 0.64472640f, -0.18955940f, -0.01469071f, 0.47452593f, 
    -0.17787685f, 0.13865165f, -0.00168882f, 0.14941671f, 0.41842616f, -0.32133910f, -0.54420972f, 0.14217645f, 
    -0.35966784f, -0.59359014f, 0.23735011f, -0.25846267f, -0.21942249f, 0.13355282f, -0.69171089f, -0.06295329f, 
    -0.61017495f, -0.78326887f, -0.64615810f, -0.80312926f, 0.24183439f, 0.61274922f, 0.04453615f, -0.10647150f, 
    0.42330116f, 0.22845353f, -0.23544143f, -0.43787915f, -0.12980756f, -0.11866335f, 0.06763439f, -0.01401480f, 
    -0.04490829f, -0.10699682f, 0.09433175f, 0.10678458f, -0.27010468f, -0.01003847f, -0.40104002f, 0.05145771f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.03489809f, 0.02234369f, 0.03535634f, 0.04886365f, 0.23415834f, -0.02565003f, 0.04997012f, 0.06523556f, 
    -0.09591782f, 0.53393793f, -0.14190100f, 0.17593148f, -0.08198182f, 0.03278649f, 0.14316413f, 0.01785431f, 
    0.15672924f, 0.04011113f, 0.07034538f, 0.29480532f, 0.17953897f, 0.07081942f, 0.21382102f, 0.09340364f, 
    -0.09617720f, 0.15377508f, 0.10608315f, 0.15021153f, 0.30352277f, 0.14936650f, 0.20651944f, -0.07668084f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.08683780f, -0.03821274f, -0.09089725f, 0.19616798f, -0.26490325f, 0.00030495f, -0.05107814f, 0.09019317f, 
    0.01462024f, 0.01447766f, -0.04883389f, -0.03536022f, 0.33994848f, -0.03038331f, 0.20488924f, -0.02655765f, 
    -0.09535705f, 0.02221643f, -0.07179293f, -0.02644801f, -0.03502219f, 0.00396806f, 0.13932323f, -0.04440200f, 
    -0.16692708f, -0.05359121f, -0.12533665f, -0.09797089f, -0.06353649f, 0.04520236f, 0.14382774f, -0.02623842f, 
    0.05586512f, -0.02725201f, 0.07487407f, -0.09490335f, -0.44431618f, 0.20579289f, 0.09329971f, 0.11895334f, 
    -0.13679437f, 0.13764441f, -0.19147855f, -0.04639297f, 0.03890895f, -0.12531330f, -0.03031401f, 0.12927508f, 
    -0.41336784f, -0.14692304f, 0.15035512f, -0.01102815f, -0.15960652f, -0.04101616f, 0.02184894f, 0.05649639f, 
    -0.04013400f, 0.01594507f, -0.00962766f, -0.14849322f, 0.09140322f, 0.30667695f, -0.06587692f, -0.12745598f, 
    0.20997599f, 0.08506507f, -0.04352269f, 0.09467313f, 0.04214508f, -0.03052241f, -0.10950483f, -0.05813045f, 
    0.02881243f, 0.12872934f, 0.25974342f, -0.04275667f, -0.07327940f, -0.15770163f, 0.04500976f, -0.16756614f, 
    0.07584924f, -0.10722838f, 0.06047935f, 0.09447596f, -0.07754033f, 0.33387396f, -0.04668172f, -0.31106439f, 
    0.11177207f, 0.09331634f, 0.12426979f, -0.13146427f, -0.29491976f, 0.02188936f, -0.07839396f, 0.00382917f, 
    0.29424873f, -0.11981498f, -0.05385255f, 0.07243879f, -0.35373685f, 0.04679541f, -0.01131493f, 0.19702534f, 
    -0.07095393f, -0.11570238f, 0.12248337f, -0.09329201f, -0.30644956f, -0.33889627f, 0.32276118f, -0.14682963f, 
    0.06074619f, -0.04045596f, 0.07473517f, 0.06910799f, -0.29410917f, 0.03170681f, -0.03023174f, -0.09390643f, 
    0.52104312f, -0.19012593f, -0.06031791f, 0.17408431f, 0.04322371f, -0.08022103f, 0.04948035f, 0.11467833f, 
    -0.08615571f, -0.02790333f, -0.08105221f, -0.06373243f, 0.12738195f, 0.14787447f, 0.05394828f, -0.58940232f, 
    -0.21365061f, -0.15990932f, -0.16913769f, 0.10355403f, 0.11976606f, 0.02640801f, -0.06857880f, -0.07560708f, 
    -0.15105805f, 0.22690552f, -0.31115198f, 0.17928576f, -0.17182715f, 0.02627152f, 0.08735768f, 0.19136214f, 
    0.07994814f, 0.05677597f, 0.02513209f, -0.22415732f, -0.00943965f, 0.00389191f, 0.06193613f, -0.33721107f, 
    -0.01431643f, 0.01823584f, 0.03262014f, 0.13531314f, 0.09715471f, -0.16609880f, -0.02650246f, -0.04373348f, 
    0.28775501f, -0.21199456f, 0.02434661f, -0.43604863f, -0.11476279f, -0.06806983f, -0.04763955f, 0.03075223f, 
    -0.03798483f, -0.04895055f, 0.08646891f, -0.03552831f, 0.51487410f, 0.11778815f, 0.18731973f, -0.31125593f, 
    0.15185697f, -0.10478443f, 0.05353292f, 0.03181031f, -0.01324835f, 0.05492568f, 0.00164955f, 0.01502998f, 
    0.04907676f, 0.12942977f, 0.13698104f, -0.13335487f, -0.04479108f, -0.07074169f, 0.03553445f, -0.00366427f, 
    -0.10522307f, -0.05103580f, -0.08545158f, -0.03436519f, 0.21530151f, -0.03136571f, -0.19948599f, 0.07027216f, 
    -0.16762124f, -0.15432861f, 0.06710615f, 0.01679468f, -0.03781008f, -0.03234789f, -0.08445057f, -0.05610438f, 
    -0.55224741f, 0.32135442f, -0.11757510f, -0.24015626f, 0.05230496f, -0.00165433f, -0.11292400f, 0.03230932f, 
    0.12316784f, -0.08391843f, -0.08496921f, 0.20829889f, -0.05463582f, -0.03953579f, -0.21896984f, 0.33313754f, 
    0.00847819f, 0.04100415f, 0.01302901f, 0.06547257f, 0.15295477f, 0.04061835f, -0.16444467f, 0.06933807f, 
    -0.24750830f, 0.00146391f, 0.21015462f, -0.37938127f, -0.13444045f, 0.06869549f, -0.05174802f, -0.01165379f, 
    -0.06486292f, -0.08963671f, -0.06024275f, 0.12270276f, 0.14135091f, 0.04179954f, -0.03722051f, -0.20676894f, 
    0.12733613f, 0.16061182f, -0.07041602f, 0.03950374f, -0.10887308f, 0.02237005f, 0.00069377f, -0.11746748f, 
    -0.04733513f, 0.09965740f, 0.13776666f, -0.14639775f, 0.05200096f, 0.03009837f, -0.11243080f, 0.03856096f, 
    0.13062564f, 0.05498135f, 0.08068404f, 0.04394072f, -0.59171343f, 0.09322061f, 0.10313269f, -0.27158472f, 
    -0.17253204f, -0.12322262f, 0.06789082f, -0.07043307f, -0.05940302f, 0.01582020f, 0.05662366f, -0.07608024f, 
    -0.08654223f, -0.09370173f, 0.20557307f, 0.37347203f, 0.00144698f, -0.09295598f, 0.04837734f, -0.09017066f, 
    -0.02551565f, 0.09596393f, -0.08494548f, -0.00289894f, 0.00959782f, 0.01470858f, 0.19383009f, -0.35944363f, 
    -0.04197116f, 0.14222619f, 0.07939726f, -0.13567051f, 0.16760148f, 0.05227002f, -0.06561136f, -0.00896589f, 
    0.11404223f, -0.02190719f, -0.01675955f, 0.34882301f, -0.01165429f, -0.05753852f, -0.24147321f, 0.01604976f, 
    -0.04013450f, 0.05377940f, -0.12183481f, -0.02443019f, 0.15665908f, 0.08887434f, 0.16352479f, -0.27475309f, 
    -0.00343949f, 0.09034327f, -0.09696907f, 0.09214821f, 0.18391843f, 0.13455792f, -0.01944768f, 0.05636004f, 
    0.21431234f, -0.04342062f, 0.07938926f, 0.28503230f, -0.09571493f, -0.08553976f, -0.05809480f, 0.05909722f, 
    -0.16324300f, 0.13496278f, -0.04935576f, -0.05915160f, -0.02054125f, -0.08199593f, 0.07884717f, 0.22254939f, 
    -0.06073329f, -0.07549315f, 0.04490035f, -0.04971421f, -0.12383677f, -0.02527726f, 0.13730729f, 0.06162211f, 
    -0.02383020f, -0.19336437f, -0.17347524f, 0.29541329f, -0.10653023f, -0.06438367f, 0.09922303f, -0.32397225f, 
    -0.09169218f, 0.04346379f, 0.09683968f, -0.20990737f, 0.13157527f, -0.11550961f, 0.09034788f, -0.51622277f, 
    0.04139588f, 0.06664850f, 0.13858303f, 0.03277787f, -0.01233572f, -0.00338025f, -0.04239386f, 0.07518151f, 
    0.57263601f, -0.05054478f, 0.04373061f, 0.30914536f, -0.03382003f, 0.05376524f, 0.07546397f, 0.02745845f, 
    -0.02341685f, -0.22969587f, -0.01191667f, -0.06786802f, -0.17498919f, -0.10286405f, 0.05861406f, 0.21060553f, 
    -0.03778804f, -0.07761090f, 0.03876239f, 0.13060421f, 0.18832296f, 0.18361825f, -0.31997550f, 0.13086766f, 
    -0.27766323f, 0.06243560f, -0.04177437f, -0.11781188f, -0.06927114f, -0.29454443f, 0.02637491f, 0.06458900f, 
    0.06514788f, 0.09263673f, -0.24709268f, 0.04663461f, 0.17604406f, 0.01355178f, -0.05202734f, 0.11525284f, 
    0.06491908f, 0.02884015f, -0.19504876f, 0.03563752f, 0.21031700f, 0.25215846f, 0.19659452f, 0.08899596f, 
    -0.25414160f, 0.05141850f, -0.54439199f, -0.40559226f, -0.07641408f, 0.14402173f, -0.03694502f, 0.13875099f, 
    0.07300852f, 0.13378444f, 0.07621922f, -0.10617615f, 0.16019377f, -0.00217648f, -0.07369305f, -0.14553049f, 
    -0.00010704f, 0.10572980f, -0.02443228f, 0.18986134f, 0.05893623f, -0.00082135f, -0.02354356f, 0.09734398f, 
    -0.01398355f, 0.32427043f, -0.08165989f, -0.02122713f, -0.09739621f, 0.12289274f, -0.07860196f, -0.04855245f, 
    -0.10068962f, 0.01297879f, 0.13110761f, -0.12086993f, 0.23727298f, -0.27427128f, 0.00467773f, -0.15376100f, 
    0.07550228f, -0.19182260f, -0.14193432f, -0.01864484f, 0.16473256f, 0.00650474f, -0.03593533f, -0.13537429f, 
    -0.05125166f, -0.14695986f, 0.29597747f, 0.25306547f, 0.00297913f, 0.05758682f, -0.06500610f, 0.05238885f, 
    -0.05903280f, 0.09858502f, -0.11009212f, 0.13479349f, 0.37178940f, 0.02119932f, 0.08822975f, -0.12466329f, 
    -0.01658182f, -0.08825342f, 0.08577781f, -0.02347184f, 0.07141257f, -0.00847154f, 0.03125064f, 0.01129268f, 
    0.38882980f, -0.28770852f, -0.14953244f, 0.18975160f, 0.13276972f, -0.16192211f, -0.17974879f, -0.12317402f, 
    0.04192215f, -0.02356905f, -0.04187738f, -0.13181028f, 0.12591346f, 0.23945954f, -0.14050570f, -0.26365891f, 
    0.14875722f, -0.13477191f, 0.11302564f, -0.01047205f, -0.18854365f, -0.08157708f, -0.00007532f, 0.10597028f, 
    0.01605595f, -0.11331062f, -0.11039738f, 0.08813646f, -0.11472741f, -0.12805769f, -0.07372713f, -0.13006663f, 
    0.03908215f, -0.11926217f, -0.26467633f, 0.20633200f, 0.21667162f, -0.02674155f, 0.08939484f, -0.20261014f, 
    -0.00227474f, -0.08580146f, 0.11277719f, -0.16902061f, -0.25744006f, -0.00959497f, 0.19239476f, 0.09112028f, 
    -0.02808993f, 0.00721769f, 0.18592958f, 0.15746327f, -0.05689417f, -0.19876273f, 0.13958931f, 0.10847613f, 
    -0.05726875f, -0.13074245f, -0.07354370f, -0.02818027f, -0.55983025f, -0.19147724f, -0.09480341f, -0.23798546f, 
    0.01064500f, -0.07852704f, -0.05700551f, 0.00606011f, 0.19767120f, 0.12168879f, -0.04286312f, -0.06834568f, 
    0.28956968f, 0.06891314f, 0.02708406f, -0.05974910f, -0.13378355f, -0.00208110f, -0.00349085f, 0.00792697f, 
    0.24159089f, -0.08816127f, -0.01630571f, 0.03191030f, 0.07427762f, -0.05333316f, 0.23929316f, 0.05646936f, 
    -0.05199273f, 0.15505280f, -0.01660529f, -0.00816212f, 0.04602615f, 0.02052145f, 0.18001522f, 0.10352947f, 
    0.39893967f, -0.17151023f, -0.05387245f, -0.09115317f, -0.06676451f, 0.01145151f, -0.10049985f, -0.00763127f, 
    0.00176665f, -0.15301345f, -0.03341879f, -0.20179173f, -0.58538282f, -0.13218470f, -0.24845050f, 0.00406324f, 
    -0.02786701f, 0.00939589f, -0.17951064f, -0.22794785f, -0.21262674f, -0.00585278f, 0.13798314f, 0.01180850f, 
    0.20158909f, -0.24263082f, 0.11972757f, -0.31214330f, 0.01018351f, -0.20607135f, 0.09861225f, 0.04996524f, 
    -0.14030834f, 0.14378385f, 0.02104800f, -0.05502231f, 0.15251189f, -0.22002648f, 0.18952000f, -0.05832279f, 
    -0.02921996f, -0.09247414f, -0.17103566f, 0.01197734f, 0.13002087f, 0.07839882f, 0.03560503f, 0.12262330f, 
    0.21309817f, -0.00386321f, -0.10245268f, 0.01143075f, -0.03772268f, 0.00204931f, 0.01392782f, -0.08704936f, 
    -0.20402206f, -0.17752045f, -0.18999729f, -0.09875261f, 0.24073073f, -0.25719452f, -0.03762419f, -0.30807570f, 
    -0.08299794f, -0.00325353f, 0.12136810f, 0.11065596f, -0.19103387f, 0.14141114f, 0.10787992f, 0.06626364f, 
    0.19123992f, -0.17417465f, -0.04909330f, 0.07016073f, -0.09605437f, 0.03539891f, -0.12289910f, 0.10544495f, 
    -0.01020177f, -0.07469460f, 0.01262400f, -0.21121787f, -0.60022378f, 0.03404625f, -0.12754591f, -0.27232274f, 
    -0.02074347f, -0.00552300f, 0.06966536f, 0.09426273f, -0.02451125f, -0.04890813f, -0.06931786f, -0.10149797f, 
    0.05683303f, -0.10651440f, -0.23705053f, 0.12065427f, -0.12834015f, -0.03094857f, 0.11164411f, 0.05400473f, 
    0.16344027f, -0.00429837f, 0.13281952f, -0.04461594f, 0.21543111f, -0.24228337f, -0.08776534f, -0.08200432f, 
    0.03831050f, -0.13161637f, -0.04075965f, -0.09122408f, -0.05879179f, -0.03864311f, -0.01272017f, 0.04499801f, 
    0.25881550f, -0.01321159f, 0.10494208f, 0.18397334f, -0.26389587f, 0.06872723f, 0.02629244f, 0.02760138f, 
    -0.00607886f, 0.04549398f, -0.02577703f, 0.14067285f, 0.42817521f, -0.02327214f, 0.14368382f, 0.09432469f, 
    0.03899688f, 0.04168807f, 0.00665629f, 0.00528635f, 0.01111064f, 0.01441802f, -0.29028988f, -0.22476278f, 
    0.13620588f, 0.26124683f, -0.05406370f, 0.05796348f, -0.19225460f, 0.11518797f, 0.01851030f, 0.07185656f, 
    0.08015608f, -0.17348284f, 0.02500105f, 0.25804043f, 0.08537104f, 0.04567307f, -0.13749999f, -0.15984626f, 
    -0.13046020f, -0.00619539f, 0.05478715f, 0.03746439f, -0.10742670f, 0.07918787f, -0.02608283f, -0.01079865f, 
    0.06973521f, -0.05019374f, -0.02079023f, 0.15980232f, -0.03956012f, 0.03652707f, 0.08522718f, -0.05857216f, 
    -0.09176929f, -0.01644817f, -0.03278802f, 0.08793020f, 0.18763293f, -0.06045263f, -0.11881321f, -0.19998781f, 
    0.10413377f, 0.06532794f, 0.06249027f, -0.04448349f, -0.02809413f, -0.02236761f, 0.12852274f, -0.24628465f, 
    0.07919803f, 0.00331911f, -0.15474521f, 0.23243234f, -0.20033941f, 0.09328444f, -0.06068333f, -0.07501111f, 
    0.05749688f, -0.04355924f, 0.13266012f, -0.08045432f, 0.31556791f, -0.09203158f, -0.05331770f, 0.04799563f, 
    0.06664752f, 0.05254867f, 0.00925191f, -0.02458410f, -0.03810351f, -0.07682346f, 0.01950651f, 0.13319002f, 
    -0.29181179f, -0.33071977f, -0.19168510f, -0.60497499f, 0.12384463f, 0.10917093f, -0.04164762f, -0.23701192f, 
    -0.09516024f, -0.03499789f, 0.06250434f, -0.05552305f, 0.05326837f, -0.08408660f, 0.13405381f, 0.32357290f, 
    -0.31966981f, -0.08341373f, -0.03574974f, 0.03056795f, -0.00646374f, -0.05089753f, 0.00762479f, 0.01303166f, 
    0.38237968f, -0.08733227f, -0.06216842f, 0.02175591f, -0.02521037f, -0.00013406f, 0.07281012f, 0.02069913f, 
    0.00785446f, 0.04872607f, -0.00684295f, -0.03987328f, 0.21094517f, 0.15912206f, 0.17158580f, 0.34421611f, 
    0.04604658f, -0.15262987f, 0.19180873f, 0.09749016f, 0.06166586f, 0.07667165f, 0.11093008f, 0.00509584f, 
    -0.01252416f, -0.08193862f, -0.01129811f, -0.06460267f, 0.13272217f, -0.17614716f, 0.01891740f, 0.03396686f, 
    0.14132825f, -0.06922995f, 0.04751828f, 0.10420236f, -0.20611604f, -0.29820952f, 0.09230257f, -0.17099313f, 
    -0.16490681f, 0.01604008f, -0.15441380f, -0.13345601f, -0.12895273f, -0.16972761f, -0.14691775f, -0.10322472f, 
    -0.75016189f, 0.33119559f, -0.19194561f, -0.12644571f, -0.02751729f, -0.08375902f, 0.02761263f, 0.22341241f, 
    -0.12567019f, 0.03150825f, -0.25150982f, -0.08630681f, -0.37431264f, 0.08854701f, -0.24288815f, 0.02056712f, 
    0.21998498f, -0.01159860f, 0.07246906f, -0.11245623f, -0.14288247f, 0.21733670f, -0.06494552f, 0.05582964f, 
    0.20760648f, -0.00133193f, -0.22362967f, 0.05437754f, -0.04862601f, 0.19448157f, -0.05449014f, -0.08383007f, 
    -0.08300283f, 0.06031403f, -0.02305152f, -0.12278517f, -0.16596514f, 0.07465410f, -0.02398037f, -0.03120185f, 
    0.03816465f, 0.12622206f, 0.13854764f, -0.03171504f, -0.05974605f, -0.08739040f, 0.04134621f, -0.22122392f, 
    -0.18769234f, 0.09486169f, -0.09870587f, -0.27226433f, 0.03979556f, 0.04723673f, 0.11326242f, -0.10138460f, 
    -0.07491876f, 0.11564715f, -0.00839685f, -0.05597143f, 0.19366373f, 0.14697711f, -0.08985208f, 0.15118141f, 
    -0.05799502f, -0.12206175f, -0.08279411f, 0.12780041f, -0.14446619f, -0.08036352f, 0.06957110f, 0.12287427f, 
    0.24129322f, 0.10011379f, 0.12238126f, -0.20680498f, 0.06069512f, -0.00870843f, 0.14127085f, -0.08184640f, 
    -0.09175740f, -0.07082868f, 0.03266926f, 0.01858170f, 0.16077133f, 0.04208884f, -0.15561117f, 0.19805925f, 
    0.12997694f, 0.00686527f, 0.07205509f, -0.07481059f, -0.10884377f, -0.08717265f, -0.06054588f, -0.12249438f, 
    0.48163345f, 0.02421250f, -0.11857524f, 0.41607589f, -0.16052009f, -0.09261148f, -0.02055568f, -0.02109328f, 
    0.12036821f, 0.13489823f, 0.04563887f, 0.03257081f, 0.54501468f, -0.12705727f, -0.14426814f, -0.10362279f, 
    -0.16716772f, 0.06827565f, 0.04674862f, -0.02408737f, -0.04504640f, 0.03580441f, -0.15139349f, -0.13337809f, 
    -0.23237467f, -0.04248323f, 0.07483031f, -0.45744327f, 0.02593947f, -0.06991845f, 0.12770993f, -0.05810908f, 
    -0.08022404f, -0.02814987f, -0.03174390f, -0.06081807f, -0.03071561f, 0.26423401f, 0.10855784f, 0.15608606f, 
    -0.04281279f, -0.15298782f, 0.18912303f, 0.16040312f, -0.08325648f, -0.14068915f, 0.03835069f, -0.05344060f, 
    0.32391098f, -0.19852862f, 0.20012437f, 0.00783410f, 0.03347966f, -0.16104418f, -0.23450886f, 0.05103430f, 
    -0.04585451f, 0.04851643f, -0.02501434f, -0.12323253f, -0.39915782f, -0.25639626f, -0.17629910f, -0.10124134f, 
    -0.04580401f, -0.03691770f, 0.10971379f, -0.04191777f, -0.10697047f, -0.00508533f, 0.13589324f, -0.17034119f, 
    0.01823921f, -0.58363646f, 0.17071679f, 0.05876470f, 0.16520891f, -0.04114566f, 0.10491555f, -0.20444021f, 
    -0.14289035f, 0.11099800f, -0.15279922f, -0.06074595f, 0.18861586f, 0.19935961f, -0.14069724f, 0.19002633f, 
    -0.01185036f, 0.06388120f, 0.12856290f, -0.19569041f, -0.19977686f, -0.07745024f, -0.01595698f, 0.08343568f, 
    -0.13122132f, 0.38672590f, -0.12799345f, -0.24710338f, -0.03937472f, -0.01341812f, -0.07176731f, 0.00480381f, 
    0.04727360f, -0.16238403f, -0.09453259f, 0.00525393f, 0.35811409f, -0.18203658f, 0.29312366f, 0.00261004f, 
    -0.14762177f, -0.01929141f, 0.01189272f, 0.18725623f, -0.05374950f, -0.02081094f, 0.02122636f, -0.11427525f, 
    0.12580572f, 0.02086263f, -0.05837145f, -0.18013227f, 0.10941303f, -0.09175028f, -0.00909486f, 0.04446837f, 
    -0.01768769f, 0.03654810f, 0.01956588f, -0.03636946f, -0.14325944f, 0.11643690f, -0.08026391f, -0.05072651f, 
    0.03264245f, -0.08713999f, 0.00823830f, 0.13923460f, -0.12640168f, -0.00138808f, 0.09265815f, -0.00563775f, 
    0.13276325f, 0.07194321f, -0.20794410f, -0.22086765f, 0.10826935f, -0.01086218f, 0.03521958f, -0.17118672f, 
    -0.03844545f, 0.09439053f, 0.07901306f, -0.20902427f, 0.07690979f, -0.19322686f, 0.27650324f, 0.07192323f, 
    -0.07460086f, -0.17021677f, -0.04073382f, 0.03464872f, 0.05155523f, -0.11704139f, 0.06530348f, -0.13575391f, 
    -0.41226980f, -0.21106623f, -0.19802919f, 0.04217647f, -0.17927782f, -0.10156476f, 0.08528365f, -0.14567547f, 
    -0.02649892f, -0.05778413f, 0.02008172f, 0.15184399f, 0.38360128f, -0.05891896f, 0.04508965f, 0.00419849f, 
    0.18325171f, -0.01082202f, 0.16721874f, 0.04032066f, 0.16496354f, -0.07143872f, 0.06927879f, -0.16169813f, 
    0.14998057f, 0.01981308f, 0.05235462f, 0.02603461f, -0.16544451f, -0.00162958f, 0.01087682f, 0.11468292f, 
    0.08211154f, -0.01785621f, 0.09804186f, -0.07937343f, -0.64041835f, -0.16431171f, 0.07716987f, -0.09178231f, 
    -0.01440724f, 0.05546044f, 0.22996423f, -0.20591822f, -0.08804661f, 0.05579518f, -0.18120416f, -0.06219855f, 
    0.20702174f, 0.32421780f, 0.21627691f, 0.15532666f, 0.13659242f, 0.08909055f, 0.00385339f, 0.03121187f, 
    -0.04036434f, 0.19731671f, 0.02169099f, -0.02112241f, 0.08792888f, -0.02144149f, 0.08059525f, -0.07123492f, 
    -0.20341764f, -0.25751513f, -0.03247212f, -0.09991295f, -0.07673210f, 0.04913088f, -0.00737132f, -0.13121751f, 
    -0.61063039f, 0.05961056f, 0.21529318f, -0.09463567f, 0.02621561f, -0.03586033f, -0.03177187f, 0.14261799f, 
    0.05795850f, -0.09260994f, -0.23636709f, 0.07985959f, -0.06217897f, -0.15414894f, -0.11019926f, -0.09923062f, 
    -0.04942643f, 0.08263852f, 0.01886518f, 0.07304371f, -0.13656728f, 0.07588431f, 0.00209570f, -0.00185390f, 
    -0.23107821f, -0.32153991f, 0.04446399f, 0.24225198f, -0.14151663f, -0.10491730f, 0.16647266f, -0.04806665f, 
    -0.00873094f, -0.14259617f, 0.15519319f, 0.02597102f, 0.18282326f, 0.08183730f, 0.09047951f, 0.04960021f, 
    -0.21531770f, 0.06349419f, -0.02209970f, -0.05064145f, 0.00432652f, 0.10734672f, 0.03587291f, 0.02270171f, 
    0.07465385f, 0.27366799f, 0.26767442f, -0.05340933f, -0.10594484f, 0.09319155f, 0.08498479f, 0.30445382f, 
    0.01375146f, 0.09826134f, 0.00292378f, -0.03495713f, -0.11901128f, -0.27446392f, -0.09719667f, -0.01422637f, 
    0.04999415f, -0.04537496f, 0.02024590f, 0.04445157f, 0.14706148f, -0.00698775f, -0.10664883f, -0.02922783f, 
    0.14241114f, -0.28473410f, -0.31691772f, 0.40456870f, 0.05706495f, -0.00014306f, 0.16931167f, 0.11583179f, 
    0.11916971f, 0.14852384f, -0.01821295f, 0.02267815f, -0.16671306f, 0.09713485f, -0.17744674f, 0.11826245f, 
    -0.01712816f, 0.10172675f, 0.00747378f, 0.18407728f, 0.11590126f, 0.03436657f, -0.14086589f, 0.17030598f, 
    0.05341173f, -0.56679577f, -0.52925211f, 0.10414552f, -0.06179916f, 0.06506930f, 0.13878666f, -0.10298652f, 
    0.01343356f, -0.01237676f, -0.02365059f, -0.04445817f, -0.05107527f, 0.32986569f, 0.05163541f, -0.17782763f, 
    0.01737834f, -0.01502070f, 0.16745237f, 0.01903340f, -0.18028378f, -0.01838764f, -0.10783844f, 0.11784727f, 
    -0.19258535f, -0.52008367f, -0.33413249f, 0.15187278f, -0.06587406f, 0.05504920f, -0.08492325f, -0.05151259f, 
    -0.15198323f, 0.12438244f, 0.08658732f, -0.14564753f, -0.41330668f, -0.17831941f, 0.13339923f, 0.34586957f, 
    0.14350384f, 0.00716365f, -0.01400226f, -0.15521394f, -0.11806341f, -0.11916991f, -0.03729705f, -0.27984169f, 
    0.10785772f, -0.11218367f, 0.15604937f, -0.06851403f, 0.00630393f, -0.03115907f, 0.03154163f, -0.02111050f, 
    -0.14683557f, 0.02290109f, -0.05297156f, 0.07108397f, 0.01029339f, 0.24523285f, 0.25335491f, 0.01746464f, 
    0.03304677f, -0.09970093f, 0.01619792f, 0.00351463f, -0.13740101f, -0.07415174f, -0.13390793f, 0.10307480f, 
    0.34542397f, -0.16234308f, -0.13821828f, 0.17781389f, -0.12471391f, 0.11791006f, -0.01705154f, 0.13305902f, 
    0.07169483f, -0.06037009f, -0.14256415f, 0.09068156f, -0.48745868f, 0.03373104f, -0.33898118f, -0.26669949f, 
    -0.11981586f, 0.01042676f, -0.08012476f, 0.05500215f, -0.06962015f, 0.03568583f, 0.02691210f, -0.01558703f, 
    0.13845089f, 0.25274003f, -0.11437790f, 0.09620845f, 0.04996077f, 0.00205378f, 0.07511257f, -0.09555437f, 
    -0.06251572f, 0.06364537f, -0.01103839f, 0.03953208f, 0.07561565f, -0.14569569f, 0.02610241f, -0.05245985f, 
    -0.22664128f, 0.08623981f, 0.00298927f, 0.20635723f, 0.07199456f, 0.06037964f, -0.15019315f, -0.04383973f, 
    0.81940508f, -0.24225236f, -0.25708771f, 0.32819691f, 0.00079006f, -0.08315890f, 0.05326286f, -0.08356290f, 
    0.03297383f, -0.06007956f, -0.10605031f, 0.15736172f, 0.23447749f, 0.07580844f, 0.22729366f, -0.32536846f, 
    0.09885181f, -0.08521039f, -0.03988120f, -0.09506705f, -0.01605382f, -0.06312937f, 0.06119934f, 0.07518049f, 
    -0.63139379f, 0.30503550f, -0.31942105f, 0.18078975f, 0.09370472f, 0.08113091f, -0.00853727f, 0.02698484f, 
    -0.09629904f, 0.00400606f, 0.03185861f, -0.07177991f, -0.12557462f, 0.03922013f, -0.15428963f, 0.09895052f, 
    0.02762194f, -0.09681766f, -0.04573541f, 0.03339321f, 0.06254692f, -0.17891259f, 0.08422896f, 0.01605955f, 
    -0.39739364f, -0.39067140f, -0.42488554f, -0.10060157f, -0.10912998f, 0.00324666f, -0.02163764f, -0.10699146f, 
    0.09550746f, 0.05839631f, 0.06148717f, 0.06687561f, -0.25569361f, -0.28005588f, -0.14079794f, -0.08849843f, 
    0.01410218f, 0.06995007f, -0.14114882f, -0.03969237f, 0.04425511f, 0.07870454f, 0.21500935f, 0.00101342f, 
    -0.57062125f, 0.18332756f, -0.06332268f, 0.09993163f, -0.13231739f, 0.06090065f, -0.00515737f, -0.07971510f, 
    -0.07373796f, 0.00429923f, 0.11609286f, 0.10515423f, 0.04436898f, -0.15219939f, -0.08470621f, -0.10464542f, 
    -0.14632052f, -0.03596682f, 0.03118241f, 0.06318837f, -0.00407672f, 0.04131855f, 0.05802922f, 0.00570513f, 
    -0.00208321f, 0.14666322f, -0.00354444f, 0.06985372f, -0.03917325f, 0.00906586f, 0.17606810f, 0.13312463f, 
    0.09455053f, 0.07033243f, -0.14241539f, -0.08330458f, -0.00276202f, -0.22457577f, -0.15482995f, 0.34028834f, 
    -0.20597525f, -0.05095093f, -0.14122720f, -0.11274268f, -0.05861922f, -0.03107761f, 0.04691265f, -0.02731250f, 
    0.03661692f, -0.01375640f, -0.07529154f, -0.11763635f, -0.02179570f, 0.03878506f, -0.09652427f, 0.07949872f, 
    -0.06602795f, -0.09305777f, -0.06696009f, 0.00355744f, 0.07944980f, -0.10208566f, -0.11082577f, 0.05532864f, 
    -0.16338971f, -0.05172053f, 0.36721849f, -0.06192720f, -0.00870697f, -0.13171786f, 0.11268632f, -0.03827917f, 
    0.10853156f, -0.15604544f, 0.13639940f, -0.10098455f, 0.07186774f, 0.00047615f, 0.16727749f, 0.03645861f, 
    0.04276667f, -0.11072940f, -0.04159935f, 0.01808832f, -0.06372481f, 0.07339448f, -0.21043812f, 0.17474440f, 
    0.04359378f, -0.18614094f, 0.12727123f, -0.13001326f, -0.09371302f, 0.04446139f, 0.06572320f, -0.00662421f, 
    -0.41341341f, 0.25529936f, -0.15997605f, -0.03617280f, -0.10473023f, -0.00167408f, 0.21452022f, 0.10907215f, 
    -0.07565518f, 0.10586970f, -0.08580001f, -0.00203008f, -0.61440051f, 0.05137612f, 0.12793793f, 0.12614723f, 
    -0.03937044f, 0.08143865f, 0.09487432f, -0.01198774f, -0.06469944f, 0.00479827f, 0.08916491f, 0.11981381f, 
    0.50902206f, 0.20555452f, -0.14365372f, -0.08664001f, 0.15511951f, -0.17571247f, 0.05871894f, 0.00242186f, 
    -0.00884801f, -0.02560992f, 0.17077115f, -0.02911642f, 0.04484117f, -0.00672760f, -0.00885558f, 0.18851978f, 
    -0.01193014f, -0.10308595f, 0.03531999f, 0.09226113f, 0.05137435f, 0.02406315f, -0.12427737f, -0.04983568f, 
    -0.19819626f, -0.07742552f, -0.06032003f, -0.10231948f, 0.00057973f, 0.05002668f, 0.05062283f, 0.01225063f, 
    0.04747595f, 0.05784329f, -0.08881066f, -0.01720888f, 0.29345086f, -0.03484762f, 0.09584274f, 0.07854789f, 
    -0.17739871f, 0.06934180f, 0.06064741f, -0.05746435f, -0.01527378f, 0.14653376f, 0.10155951f, 0.04309209f, 
    -0.17039339f, -0.02699844f, -0.04371399f, -0.25235790f, -0.18243709f, 0.29904494f, 0.08546428f, 0.13100478f, 
    -0.09226048f, -0.10647690f, 0.03173626f, -0.00162413f, -0.10867018f, -0.33381119f, -0.16273442f, -0.12947610f, 
    -0.23183529f, -0.04368566f, 0.00912277f, -0.03493090f, 0.01603803f, 0.09977595f, 0.03634334f, -0.16885723f, 
    -0.11349578f, -0.33152527f, 0.03382699f, 0.15195107f, -0.09591908f, -0.03954629f, -0.08470755f, -0.03946721f, 
    0.16665214f, 0.07187500f, 0.02111888f, 0.08005521f, 0.17874005f, -0.21115533f, -0.00819567f, 0.01398327f, 
    0.07033224f, -0.22714965f, 0.12003078f, 0.11273994f, 0.08057482f, 0.06743561f, 0.02269774f, -0.03567350f, 
    -0.10549755f, -0.36632359f, 0.05595883f, -0.12849988f, -0.17252083f, -0.06425373f, -0.04239798f, 0.01986829f, 
    0.02648845f, -0.02254927f, -0.23951425f, -0.12530071f, -0.38876402f, -0.13259241f, 0.23992674f, 0.22557208f, 
    -0.07627036f, -0.04380638f, -0.16104537f, -0.14852339f, 0.08040705f, 0.02312329f, -0.18184900f, -0.10553422f, 
    -0.69334292f, -0.01583842f, 0.12407505f, 0.15086162f, 0.09442611f, -0.03350967f, -0.03312413f, 0.12761353f, 
    -0.03731563f, -0.03278382f, 0.07811689f, 0.09558925f, -0.12995291f, -0.34692371f, 0.09874654f, 0.09179661f, 
    0.02649271f, 0.10219575f, 0.05584935f, 0.14790621f, 0.12654616f, 0.02513035f, -0.07883417f, -0.03070430f, 
    -0.10257179f, -0.29076570f, -0.10040258f, 0.10665734f, -0.00268019f, 0.03838833f, -0.03501297f, -0.09722516f, 
    -0.01136572f, -0.09337045f, -0.00332634f, 0.00284054f, -0.29540831f, -0.22655968f, 0.00487835f, 0.14472343f, 
    0.05050115f, -0.06049406f, -0.01154274f, -0.11479611f, 0.21128385f, -0.06957319f, 0.06013845f, -0.07281378f, 
    -0.49396685f, 0.11558775f, -0.35506803f, -0.27626175f, 0.02809827f, -0.03419763f, 0.12438721f, 0.05763590f, 
    0.00179803f, 0.00377301f, 0.13555567f, -0.06162271f, 0.06722865f, -0.01970444f, 0.03252147f, 0.05023322f, 
    -0.11059628f, 0.08411865f, 0.27246055f, 0.04920734f, 0.04604702f, 0.02499750f, 0.04610520f, 0.04639184f, 
    0.23773955f, 0.14126755f, -0.29367441f, -0.18965670f, -0.18420662f, 0.12402802f, -0.00470453f, 0.07613950f, 
    -0.10517430f, -0.05844003f, 0.00199998f, 0.08391926f, 0.87782651f, 0.10752725f, -0.41243598f, 0.06292080f, 
    -0.11611182f, -0.12690122f, 0.08883961f, -0.11671311f, 0.09225106f, -0.12435512f, -0.00725077f, 0.08447079f, 
    -0.44145498f, -0.06912580f, 0.35151309f, -0.00860066f, 0.00368761f, 0.12297871f, 0.01094471f, -0.08814117f, 
    0.10556101f, -0.02349221f, -0.02857070f, -0.17403911f, -0.62762851f, 0.20694411f, 0.17702107f, 0.24499077f, 
    -0.03511523f, 0.00483186f, 0.03391135f, 0.07426782f, -0.02582509f, 0.10934767f, -0.00516570f, -0.03947921f, 
    0.16986190f, 0.06537528f, -0.09380437f, 0.13964880f, 0.03013734f, -0.06551319f, 0.09372114f, 0.02115618f, 
    -0.11390468f, -0.11063697f, 0.04013971f, 0.04016821f, -0.39452606f, 0.28473589f, 0.06107710f, -0.12563224f, 
    0.02435838f, 0.16541573f, 0.10386598f, 0.17224993f, -0.05999146f, -0.05123540f, 0.19864886f, 0.15803595f, 
    -0.33745551f, -0.12377483f, 0.13085902f, 0.08045229f, -0.05383582f, 0.07930812f, 0.02320645f, -0.01562671f, 
    0.05159008f, 0.00704904f, 0.00042346f, 0.05311049f, -0.47230533f, -0.10961310f, 0.26114830f, 0.38389519f, 
    0.02230066f, 0.06391568f, 0.02650889f, 0.13651001f, -0.02020424f, 0.04691085f, 0.00967530f, 0.06277934f, 
    -0.05046529f, -0.09800688f, 0.16625524f, -0.25616220f, -0.01815110f, -0.04308200f, 0.02009306f, -0.03709494f, 
    -0.04565651f, 0.15498972f, 0.18231109f, 0.24940614f, -0.13290919f, 0.07715403f, 0.21711615f, -0.22326754f, 
    0.03975011f, -0.06680800f, 0.10097235f, -0.16214195f, -0.14883970f, -0.16651882f, 0.02122779f, 0.10868932f, 
    -0.14592649f, -0.09477284f, -0.30309868f, 0.07585087f, 0.22232985f, 0.18430458f, 0.27464405f, 0.03304033f, 
    0.06730758f, 0.20041054f, -0.34910810f, -0.01898202f, -0.29120743f, 0.21656097f, 0.18941049f, -0.46570018f, 
    0.00256260f, -0.10236348f, -0.00956540f, 0.15475485f, 0.15473576f, -0.01243585f, -0.02204588f, -0.17347069f, 
    -0.01374259f, -0.00086434f, -0.06916492f, 0.59851277f, -0.06792958f, -0.13487056f, 0.17802477f, 0.05815414f, 
    0.12499862f, -0.20383726f, 0.03690819f, 0.19627753f, -0.27355829f, -0.04776656f, -0.11010511f, 0.04693627f, 
    0.07090134f, 0.20626758f, -0.06544887f, -0.27478734f, 0.20110531f, -0.24869762f, -0.01161860f, 0.09378384f, 
    -0.60620832f, -0.09946187f, 0.27092129f, -0.03291912f, 0.02890463f, -0.02437116f, 0.07918490f, -0.09024543f, 
    0.07769444f, -0.00269513f, 0.04328024f, -0.04026856f, -0.02788052f, -0.13078313f, -0.27097172f, -0.06480308f, 
    0.01558149f, -0.04678935f, -0.18908134f, -0.00275962f, -0.01685395f, -0.12890629f, -0.01602651f, -0.18793669f, 
    -0.06981403f, 0.20617279f, 0.20778990f, -0.12991552f, -0.02896388f, -0.01147199f, 0.08805883f, -0.09692555f, 
    0.02721114f, 0.00607196f, -0.06597331f, 0.07859921f, -0.28552467f, -0.29119223f, -0.06876592f, 0.00695746f, 
    0.04712361f, -0.07578303f, 0.02402294f, 0.15923953f, 0.17026329f, 0.00873586f, 0.17475095f, 0.04581857f, 
    -0.37962738f, 0.11237682f, 0.02907797f, 0.12678343f, -0.25553173f, -0.07010996f, -0.07132145f, -0.14261489f, 
    0.13529086f, -0.05833052f, 0.10033885f, 0.05169092f, 0.02040756f, 0.03426221f, 0.33782932f, 0.41739920f, 
    -0.02348950f, -0.02404385f, 0.07568853f, -0.06058844f, 0.02527109f, -0.17377964f, 0.02801176f, 0.01385478f, 
    0.07496518f, -0.06224682f, 0.11900769f, 0.13953020f, 0.16456981f, -0.00140988f, 0.00858358f, -0.13452163f, 
    0.03115123f, 0.08957285f, -0.02855692f, 0.09973404f, 0.16591601f, 0.09579585f, -0.14602228f, -0.15813027f, 
    0.05311330f, -0.28217220f, -0.05387590f, -0.20666209f, -0.09981574f, 0.00900467f, 0.01911086f, 0.10311171f, 
    0.07282386f, 0.04668520f, 0.08798853f, 0.18781963f, 0.04249886f, -0.11656293f, 0.06525259f, 0.03124737f, 
    -0.04443152f, -0.13746901f, -0.00442383f, 0.02750908f, 0.22090630f, -0.00860417f, -0.10660671f, 0.00116758f, 
    0.18275365f, 0.34216172f, -0.22099862f, -0.13564742f, 0.19537479f, 0.06478906f, 0.05258775f, 0.02701962f, 
    0.01083752f, -0.05920878f, 0.11506952f, 0.04506008f, -0.13855454f, 0.18598326f, -0.04825666f, -0.01628945f, 
    -0.01976243f, -0.01742948f, 0.22357732f, 0.09525933f, 0.11307930f, 0.09115162f, -0.02754956f, -0.08057619f, 
    -0.06697511f, 0.01717277f, 0.09284861f, 0.11558717f, -0.16563685f, 0.05426759f, 0.16423942f, 0.32660916f, 
    -0.40668979f, -0.06400259f, -0.43918544f, -0.19511442f, 0.13656797f, 0.13057327f, 0.09204357f, 0.11603573f, 
    0.03857998f, 0.07482702f, -0.10418691f, -0.09142861f, 0.19413073f, -0.08048629f, -0.16193509f, -0.05488391f, 
    -0.06314563f, -0.16110490f, 0.08043852f, 0.11388526f, -0.05983062f, -0.08902222f, 0.24168310f, 0.09236495f, 
    -0.01259489f, 0.23081273f, 0.08843052f, 0.18995072f, -0.17396080f, -0.19792669f, 0.08963215f, -0.01873556f, 
    0.00609965f, 0.03215414f, 0.14777675f, -0.02723962f, 0.31337550f, 0.27764529f, -0.12481152f, -0.07755169f, 
    0.00627175f, -0.08127348f, -0.20446725f, -0.10663478f, 0.03187680f, 0.19613348f, -0.24161601f, 0.07855526f, 
    -0.72785223f, -0.10543638f, 0.00129647f, -0.08602996f, -0.10206216f, 0.15452774f, 0.00891975f, 0.05743119f, 
    -0.00636017f, 0.06833238f, -0.02403755f, -0.06513332f, 0.03466905f, 0.04694093f, -0.24351978f, 0.08186975f, 
    0.03926158f, 0.02842441f, 0.00601311f, 0.02321283f, 0.03484545f, -0.07330714f, -0.18847299f, 0.02854213f, 
    -0.07519149f, -0.14360040f, 0.15830691f, -0.15937871f, 0.08791539f, -0.05577008f, 0.02411785f, -0.07959346f, 
    0.01700333f, -0.09518748f, 0.08054162f, 0.11825291f, 0.06127360f, -0.11468945f, 0.11346614f, 0.04743876f, 
    -0.01210661f, -0.17972521f, -0.06573249f, -0.09905545f, -0.03384255f, 0.03851075f, 0.04421364f, -0.08252694f, 
    -0.14906637f, -0.07452343f, 0.09270982f, 0.11449528f, -0.03684380f, -0.01800644f, 0.06755860f, 0.07836852f, 
    -0.06300377f, 0.07591187f, 0.04981371f, 0.05414663f, -0.55090094f, 0.03065596f, -0.27916628f, -0.09801932f, 
    0.07812487f, -0.04128913f, -0.07606132f, -0.16615961f, -0.00508169f, -0.10739353f, -0.00725443f, -0.03889731f, 
    0.05967158f, -0.08394893f, 0.05870866f, -0.17564060f, 0.02525061f, 0.00487900f, 0.00855639f, 0.14113863f, 
    0.29047456f, -0.03790607f, -0.13420911f, -0.08569016f, 0.10206155f, 0.19708788f, 0.01603792f, -0.02333981f, 
    -0.05582223f, -0.02950302f, -0.00932028f, -0.10499521f, -0.12650695f, -0.05609979f, -0.25865471f, -0.17837265f, 
    -0.00438298f, -0.09500811f, 0.05134902f, -0.21787834f, 0.26870731f, -0.10802498f, -0.06456475f, 0.24724154f, 
    -0.02389626f, -0.06003630f, -0.08089302f, -0.14457519f, -0.07017203f, -0.22183637f, -0.51985842f, 0.23241460f, 
    0.10033771f, 0.00458017f, -0.18239595f, -0.11705924f, 0.16888265f, 0.06103551f, -0.12564865f, -0.04880358f, 
    -0.14133132f, 0.39923587f, 0.15986064f, -0.45336372f, -0.10353523f, 0.02242910f, -0.02473398f, -0.03708598f, 
    -0.08171169f, -0.06146568f, -0.11267795f, -0.16029580f, 0.15409876f, 0.15409271f, -0.00143642f, -0.13418968f, 
    0.01347062f, 0.10114750f, -0.04012923f, 0.01928736f, 0.13014725f, 0.02853535f, 0.23284313f, -0.15840757f, 
    0.01380763f, -0.16365229f, -0.02252058f, -0.20297720f, -0.13746402f, -0.09513707f, -0.19585346f, -0.20414495f, 
    -0.10174119f, -0.10305074f, 0.28493848f, 0.10746576f, -0.04819417f, -0.27525908f, 0.11455159f, -0.09936775f, 
    0.14837064f, 0.00471907f, -0.10364125f, 0.12252180f, -0.11326765f, -0.09294343f, -0.01687479f, 0.01947935f, 
    -0.22387686f, -0.25820303f, -0.12059070f, 0.00505346f, -0.00135132f, 0.01230576f, -0.09852594f, 0.04357484f, 
    -0.11149481f, 0.04897531f, -0.13588399f, -0.01586669f, -0.28994426f, -0.50288022f, 0.00388221f, -0.42914197f, 
    0.00941977f, 0.03991212f, -0.13966346f, -0.01211704f, -0.09405540f, 0.16039719f, -0.10064059f, 0.04644879f, 
    0.46174568f, -0.40644726f, -0.15654951f, 0.14900762f, -0.00373914f, -0.07427683f, 0.02967952f, 0.12400238f, 
    -0.00470198f, -0.02982648f, -0.09246947f, 0.04402120f, -0.10052965f, -0.20317736f, 0.05108146f, -0.04974705f, 
    -0.02903197f, 0.11817118f, 0.05543589f, -0.04955902f, 0.14900327f, -0.06294957f, 0.17179179f, 0.28462443f, 
    -0.11962750f, -0.06581646f, -0.12589958f, -0.06244448f, -0.09024020f, -0.00346644f, 0.02142497f, 0.05045968f, 
    0.11587561f, -0.03205490f, 0.02574657f, -0.18137145f, -0.18609667f, 0.16316336f, -0.27283993f, -0.26906523f, 
    0.01949564f, 0.02594335f, 0.03492435f, -0.06222536f, -0.08620239f, 0.04717210f, -0.11384096f, 0.07339589f, 
    0.12324085f, 0.15148295f, 0.16674346f, 0.09613617f, 0.04575611f, 0.00862119f, 0.20730114f, 0.05878818f, 
    -0.16631079f, 0.01154707f, 0.12104877f, 0.19546854f, -0.10493470f, 0.13165109f, -0.13347746f, 0.01116658f, 
    -0.07141479f, -0.00372336f, -0.06886311f, 0.05606617f, -0.07994885f, 0.08964586f, -0.00429290f, 0.06997321f, 
    0.24599092f, 0.24577940f, 0.23310030f, -0.35181719f, -0.18313266f, 0.03171251f, 0.09942077f, -0.04638441f, 
    0.11136697f, -0.02783832f, 0.26641297f, 0.03059615f, -0.53904921f, 0.30790216f, 0.21716999f, 0.10499306f, 
    0.09931176f, 0.22579660f, 0.08993327f, 0.12551402f, 0.11707681f, -0.23783520f, -0.06895693f, -0.16666488f, 
    -0.28615886f, 0.44993857f, 0.06665087f, 0.12272251f, -0.14765300f, 0.19775340f, -0.12660991f, 0.15210456f, 
    0.03585013f, 0.11127377f, 0.13594584f, -0.05534348f, 0.08798613f, -0.03399935f, -0.19783495f, 0.26669773f, 
    -0.17407325f, -0.08651775f, 0.19047377f, -0.06708951f, -0.11500265f, -0.08012342f, -0.13640955f, 0.01262706f, 
    -0.31505367f, 0.32628441f, -0.12415460f, 0.10111957f, 0.00125244f, -0.04688121f, -0.02179768f, 0.12482625f, 
    0.00553324f, 0.18334417f, -0.02266729f, -0.15108883f, 0.14057267f, 0.29256153f, 0.17515981f, -0.34262305f, 
    -0.09338415f, 0.03097827f, -0.09725998f, 0.05513348f, 0.15388615f, -0.00169836f, -0.20820123f, -0.25530240f, 
    -0.08769573f, -0.32449210f, -0.08382098f, -0.29261857f, -0.02300166f, 0.05894879f, -0.06426988f, -0.24771228f, 
    0.05406205f, -0.10573161f, 0.11281147f, 0.15497556f, 0.10491318f, -0.02134363f, 0.03078261f, -0.14441819f, 
    0.00417658f, 0.18621567f, -0.01243572f, 0.03260209f, 0.19615035f, -0.02754763f, -0.07424161f, -0.10896410f, 
    0.23905110f, -0.20479344f, -0.04095948f, 0.39226329f, 0.02822631f, 0.23236103f, -0.16013882f, 0.07150073f, 
    0.12592302f, -0.02258544f, -0.10095970f, -0.02507071f, -0.58882034f, -0.16403832f, 0.07589623f, 0.05888094f, 
    0.01449052f, 0.00410814f, 0.06426215f, 0.09711713f, -0.14746144f, -0.08732262f, 0.19874035f, -0.07352472f, 
    0.26925993f, -0.46950698f, -0.11940972f, 0.11224677f, -0.11418013f, -0.11646367f, 0.06396580f, -0.05594424f, 
    0.03371531f, 0.03073509f, -0.06071219f, 0.04845613f, -0.04065201f, -0.35131261f, -0.28780264f, 0.38929266f, 
    0.17793064f, 0.06439143f, -0.15555713f, -0.03889231f, 0.03743391f, -0.05788381f, -0.01035215f, -0.09982584f, 
    -0.15587847f, -0.02289885f, 0.05007561f, -0.24173880f, -0.13773356f, 0.15417643f, 0.21618299f, 0.11750306f, 
    0.08558943f, 0.07144538f, -0.07931152f, 0.00448598f, -0.48630524f, 0.10491629f, 0.18054980f, 0.19925846f, 
    -0.06961780f, 0.04420979f, -0.07801210f, -0.08400185f, -0.03098595f, 0.00632610f, -0.08052753f, -0.11930085f, 
    0.05070678f, 0.04016732f, 0.17147401f, -0.31985179f, 0.17539804f, -0.01806227f, 0.03446688f, -0.04556071f, 
    -0.14509459f, -0.03157989f, 0.06694181f, 0.02987070f, 0.15816154f, -0.24592876f, -0.16133800f, -0.05785582f, 
    -0.02905297f, 0.13009144f, -0.04948518f, 0.08567420f, -0.04545260f, 0.24541366f, -0.02502629f, 0.18114649f, 
    -0.22190072f, 0.09891451f, 0.22280569f, -0.08570354f, -0.03941790f, -0.11804558f, -0.06246628f, 0.06239348f, 
    -0.05305618f, -0.10821514f, 0.14710785f, 0.11007489f, 0.09274871f, -0.28325298f, 0.00520380f, -0.03763964f, 
    0.07604767f, -0.10750813f, -0.21312878f, 0.04539670f, 0.08587075f, -0.04068333f, 0.09652317f, 0.20714007f, 
    0.09833658f, 0.20141889f, 0.18231112f, -0.08656207f, 0.02339597f, -0.18523513f, -0.10455377f, 0.02930155f, 
    -0.03025640f, 0.05464675f, -0.09139833f, 0.14941175f, -0.13117363f, 0.15781003f, -0.28752410f, -0.18727386f, 
    0.06596886f, -0.02522618f, -0.07409395f, -0.08654997f, -0.02603267f, -0.06824323f, 0.16614583f, -0.00333463f, 
    -0.28992501f, 0.08559550f, -0.00235331f, -0.13462380f, 0.05307361f, -0.00440602f, -0.08701609f, -0.00681078f, 
    -0.02849896f, -0.02123993f, -0.08045298f, -0.04253910f, -0.35085303f, 0.22434627f, -0.06048586f, -0.09130410f, 
    0.06816118f, -0.11236690f, -0.15948674f, 0.01843638f, -0.03113692f, -0.10708687f, 0.07629648f, -0.14549822f, 
    0.12188730f, 0.12916224f, 0.20996527f, 0.22992046f, 0.28748104f, 0.16270618f, -0.04425390f, 0.04456156f, 
    -0.11048504f, -0.05592456f, 0.06898599f, -0.02013127f, 0.23652101f, -0.20479850f, 0.08018465f, -0.19811206f, 
    -0.12704147f, 0.09517340f, -0.01673435f, -0.03152242f, -0.03899971f, -0.01511095f, -0.07303828f, 0.00462638f, 
    0.13881789f, 0.07307813f, 0.22803311f, 0.24211340f, 0.03600384f, -0.25498885f, -0.05451557f, -0.10934459f, 
    -0.01841815f, -0.13648137f, -0.04298561f, -0.03837691f, -0.19020095f, 0.12904082f, 0.13211027f, 0.01173442f, 
    0.10456822f, -0.00483271f, 0.01182000f, -0.10769706f, -0.03420524f, -0.02725405f, 0.05323072f, -0.06881534f, 
    0.15688258f, -0.19197264f, 0.09398101f, -0.02246653f, 0.08277714f, 0.03089233f, -0.07121901f, -0.05147079f, 
    -0.05756912f, -0.06164184f, -0.00532146f, -0.12930496f, 0.14015253f, 0.18750694f, 0.15835361f, 0.09174833f, 
    -0.08665709f, 0.02207530f, 0.05561763f, 0.01661183f, -0.00133716f, 0.02288133f, -0.00125643f, -0.01517367f, 
    -0.31910452f, 0.26768059f, -0.01888465f, -0.02617128f, -0.18756914f, -0.06331143f, 0.02597432f, -0.02000365f, 
    0.12652150f, 0.05516469f, 0.04033822f, -0.08339290f, -0.15840738f, 0.17719392f, 0.07430708f, 0.23231308f, 
    -0.15593007f, 0.02492202f, -0.12809207f, -0.07158334f, -0.12043080f, -0.00150564f, -0.13297814f, -0.14726275f, 
    0.19003251f, 0.08227304f, -0.20861371f, 0.06400322f, -0.10413361f, -0.05858135f, 0.02903385f, 0.01082200f, 
    -0.21874782f, -0.06692799f, -0.06816643f, -0.11437418f, -0.03429033f, -0.39729384f, -0.14186765f, 0.25513551f, 
    0.03691109f, -0.02801256f, -0.11065294f, 0.02135411f, -0.04842945f, -0.05425911f, 0.06534885f, -0.06291614f, 
    -0.23193879f, -0.01573209f, -0.06947321f, 0.11586983f, -0.03293733f, 0.00851641f, 0.10818522f, -0.06627589f, 
    -0.08094636f, 0.06085085f, -0.00940447f, -0.24238449f, -0.13977624f, -0.19039388f, -0.04105151f, 0.16846423f, 
    0.03534062f, 0.02728925f, -0.17938450f, 0.13324417f, -0.00275533f, 0.10500266f, -0.11210972f, -0.11038803f, 
    -0.26687333f, -0.04671805f, -0.56803578f, -0.16406849f, 0.11904944f, 0.02785655f, -0.00401006f, 0.02156072f, 
    -0.26231080f, 0.04338500f, 0.15911862f, 0.04132197f, 0.10321142f, 0.15021034f, 0.08170142f, 0.12749973f, 
    0.10666081f, -0.07588492f, 0.10951055f, -0.07220102f, -0.05992708f, -0.01830513f, 0.06555713f, -0.03735877f, 
    -0.35984373f, 0.06446163f, 0.00028159f, -0.11794798f, 0.11293299f, -0.05553982f, -0.02954303f, -0.06100939f, 
    -0.03534805f, 0.01273384f, -0.10576919f, -0.03033243f, -0.35285583f, -0.34264955f, -0.19890222f, -0.17129232f, 
    -0.02868059f, -0.04963733f, -0.01535162f, -0.03742742f, 0.05490449f, 0.08830523f, 0.05267371f, -0.09000702f, 
    0.41484806f, 0.19599824f, 0.33983535f, 0.07860309f, 0.16059275f, 0.08217998f, 0.03239622f, -0.00401339f, 
    -0.05639534f, 0.22420445f, -0.05161918f, -0.07799839f, 0.43735889f, -0.03119285f, 0.05096367f, -0.05751826f, 
    0.02861716f, -0.01850786f, 0.00083452f, -0.15614583f, -0.08136922f, 0.03658175f, -0.08686389f, -0.07901979f, 
    -0.42653289f, 0.26033106f, 0.01175078f, 0.01752376f, -0.10275461f, 0.04138045f, -0.00830084f, 0.01414956f, 
    0.03779266f, -0.02038285f, -0.05725472f, -0.02470399f, -0.28495988f, 0.04455761f, -0.02605001f, -0.06002383f, 
    -0.14601034f, 0.08350090f, -0.04410540f, -0.06257180f, 0.05955530f, 0.00390795f, -0.02234552f, -0.00050439f, 
    -0.10998466f, -0.15228808f, 0.09817569f, 0.03797871f, -0.03157302f, -0.01305058f, 0.11148316f, 0.04957911f, 
    -0.00581628f, 0.04783257f, -0.09586558f, 0.01176208f, -0.03783780f, 0.21982737f, -0.18404762f, 0.18076444f, 
    0.04171102f, 0.00025694f, -0.14935918f, -0.01125301f, 0.06383038f, -0.03045112f, -0.03196394f, -0.23419978f, 
    -0.02737361f, 0.49684453f, -0.07975957f, -0.23910613f, -0.02396361f, -0.02844080f, 0.07395553f, -0.14016673f, 
    -0.12471562f, 0.02113150f, 0.07614564f, -0.00944201f, -0.11072353f, 0.13309182f, -0.03524764f, 0.15080051f, 
    0.15536536f, -0.00401597f, -0.09584304f, -0.05071765f, -0.03798547f, -0.07456106f, -0.03389755f, -0.05095969f, 
    0.32233351f, -0.45652261f, -0.18434936f, -0.09163547f, -0.02193701f, -0.01465941f, -0.04868070f, 0.01380196f, 
    -0.07177451f, 0.01745211f, -0.06958456f, -0.00341321f, -0.11405995f, 0.34856680f, 0.19741820f, 0.00507290f, 
    0.02125902f, 0.09082681f, 0.10360970f, 0.00994109f, -0.02527708f, 0.03142275f, -0.10249083f, -0.05017808f, 
    -0.34872895f, 0.13322493f, -0.10520828f, -0.16056074f, -0.00853284f, 0.03868500f, 0.00953896f, -0.08028683f, 
    0.01698739f, -0.06114502f, -0.10086719f, -0.12122490f, -0.09291219f, 0.06317577f, -0.20389776f, -0.14211333f, 
    -0.14183412f, -0.01992302f, -0.04383304f, -0.05860584f, 0.02801662f, 0.01334349f, -0.02622445f, -0.00895233f, 
    0.03937054f, -0.22554426f, -0.04222936f, -0.29054564f, 0.12198186f, -0.02359606f, 0.04158514f, 0.00308661f, 
    -0.05923767f, -0.07314592f, -0.04766808f, -0.02656163f, 0.14116916f, 0.28499746f, 0.20795836f, 0.25252470f, 
    0.05838506f, 0.10094987f, 0.02991539f, 0.03509464f, 0.02648214f, 0.04919565f, -0.03334771f, -0.08127658f, 
    0.06608923f, 0.03395693f, -0.01088346f, 0.34944963f, 0.22340217f, -0.09329495f, -0.13935551f, -0.10809387f, 
    0.00273212f, 0.08637328f, 0.14256005f, 0.10685547f, -0.20143926f, 0.05725359f, -0.29230243f, -0.10819881f, 
    -0.04893969f, -0.04195887f, 0.02479540f, 0.05553960f, -0.10257285f, -0.09154095f, 0.00263523f, 0.12755348f, 
    -0.35567397f, -0.23057280f, 0.11862638f, -0.44288000f, -0.04691471f, -0.13706183f, 0.09030275f, 0.10425314f, 
    0.11988069f, 0.11370727f, -0.31464237f, -0.00703143f, 0.37979549f, 0.20491236f, -0.13957098f, 0.12430657f, 
    -0.14472076f, -0.10036646f, -0.07604343f, -0.09494955f, 0.00366484f, 0.16269201f, -0.09236431f, -0.01307023f, 
    -0.17637488f, 0.18761906f, -0.16266704f, -0.40855035f, 0.09762268f, -0.11265650f, -0.14075477f, -0.12016681f, 
    0.03605775f, -0.10316756f, -0.03231110f, 0.17462684f, -0.22827022f, -0.07247213f, 0.25098911f, 0.07130142f, 
    -0.23606694f, 0.00408028f, -0.23577654f, -0.18524544f, -0.03887963f, -0.02469067f, 0.12328569f, -0.00110303f, 
    0.22586192f, 0.06210206f, 0.00894497f, 0.17095080f, -0.06380343f, -0.12764549f, -0.09946178f, -0.12764893f, 
    -0.02730296f, -0.05434813f, -0.08758669f, 0.03587103f, -0.09856584f, 0.16122569f, 0.00953196f, 0.07130080f, 
    0.02667789f, -0.06175919f, -0.09141363f, 0.18668109f, 0.10151011f, -0.15582812f, -0.13897757f, -0.24807996f, 
    0.05015950f, -0.02077333f, -0.08345848f, 0.22631787f, -0.07600150f, 0.05038393f, -0.01850860f, -0.08623657f, 
    0.07927071f, -0.04495696f, 0.11842088f, 0.14470136f, -0.36447531f, 0.28040671f, -0.08505353f, -0.17045999f, 
    -0.18936418f, -0.00815683f, 0.07852314f, -0.13086216f, -0.01600404f, 0.09667993f, 0.06239476f, -0.05399106f, 
    -0.26219344f, 0.02635188f, 0.07350877f, -0.06054662f, 0.08301041f, 0.03637190f, -0.22256203f, -0.15697181f, 
    0.17275712f, -0.04957655f, 0.11628259f, 0.01772322f, 0.05699040f, 0.07717910f, -0.13268077f, 0.04016987f, 
    0.23848328f, 0.10459623f, -0.16406283f, 0.02975659f, 0.04106330f, -0.01729751f, -0.03039813f, -0.14764622f, 
    -0.11063852f, -0.43014961f, 0.02937253f, 0.06526887f, 0.11368316f, -0.26456079f, -0.13756695f, -0.03204947f, 
    -0.02958488f, 0.09481109f, -0.23697868f, -0.00519085f, 0.11323700f, 0.11344311f, -0.40406230f, -0.09409487f, 
    0.01771497f, -0.24419242f, -0.12203991f, -0.02978071f, -0.02470145f, 0.13968123f, -0.06075924f, 0.25505248f, 
    -0.17081437f, 0.02554017f, -0.09383116f, 0.01112948f, 0.11496548f, 0.08757087f, -0.06778559f, 0.01037802f, 
    0.06281794f, -0.02894909f, -0.05254028f, -0.11074736f, 0.03956684f, 0.13507614f, -0.07581566f, 0.00263416f, 
    -0.23822600f, -0.01889262f, -0.09219126f, 0.09694768f, -0.08421338f, -0.19757554f, 0.10765053f, 0.13224168f, 
    0.09455725f, 0.09136730f, -0.32469070f, 0.12266588f, 0.07150391f, -0.04953316f, -0.06594691f, 0.00933446f, 
    -0.06024716f, 0.01744801f, 0.16008759f, 0.04786411f, -0.16581900f, -0.30800456f, -0.11015073f, 0.05434115f, 
    0.08530109f, 0.01029338f, 0.07699135f, -0.03563328f, 0.12515905f, 0.17541173f, 0.09216888f, 0.09864506f, 
    -0.29282582f, -0.16786282f, 0.16923974f, -0.07796533f, -0.16232049f, 0.12913713f, 0.14555836f, -0.18888658f, 
    0.06443930f, -0.12284047f, -0.03376839f, -0.05881275f, -0.00202257f, -0.37136400f, 0.12226743f, -0.30403686f, 
    -0.01677514f, -0.01106195f, 0.05109555f, -0.11380015f, -0.01077512f, -0.01553174f, 0.05120157f, 0.19390325f, 
    0.11430651f, 0.25549859f, -0.36956051f, -0.02584921f, -0.01960693f, -0.05285449f, -0.18496493f, 0.03338089f, 
    0.07908811f, 0.12190782f, 0.16771093f, -0.02561536f, 0.20190965f, 0.26432168f, 0.00588753f, 0.18491518f, 
    -0.15460362f, -0.10764990f, 0.01004205f, -0.01529109f, -0.03524503f, 0.05015080f, -0.10978508f, 0.04823146f, 
    -0.05600749f, -0.04679501f, 0.14481866f, 0.17351270f, 0.02273361f, 0.06842840f, -0.08598652f, -0.14568412f, 
    -0.04373494f, -0.10953639f, -0.13733108f, 0.07974354f, 0.02067730f, 0.40702468f, -0.45001021f, -0.27284619f, 
    0.07388514f, -0.17060851f, -0.05333610f, -0.01155125f, 0.08560777f, -0.12142141f, -0.01082650f, 0.11888386f, 
    0.02246285f, -0.31088158f, 0.24146520f, 0.09829003f, 0.01576626f, 0.00512120f, -0.16260906f, 0.00597368f, 
    0.14533320f, -0.17463133f, 0.26586309f, -0.16116028f, 0.15105365f, 0.05861827f, -0.06121872f, 0.06869157f, 
    0.09601735f, -0.06775615f, -0.12473460f, -0.00163911f, -0.08093522f, 0.05020003f, 0.10482132f, -0.08461224f, 
    0.16991386f, -0.30306548f, -0.50850290f, 0.03408114f, 0.08942150f, -0.01275114f, 0.18747379f, -0.02549761f, 
    0.17089899f, 0.02281341f, 0.04537128f, 0.13893726f, -0.14039101f, 0.22602764f, 0.04367192f, 0.07997172f, 
    -0.27690533f, -0.05979817f, -0.15928113f, -0.19875111f, -0.01747539f, -0.00572300f, 0.06937607f, 0.11429407f, 
    0.26513004f, -0.06369467f, 0.00493214f, 0.19169164f, 0.17751461f, 0.03803786f, -0.06106302f, -0.08211737f, 
    -0.07651702f, 0.02816361f, -0.02830996f, -0.18334056f, 0.26137534f, 0.12729822f, -0.08242968f, 0.11334867f, 
    0.00073020f, -0.03731717f, -0.01571687f, -0.16055802f, 0.02518802f, -0.01568586f, 0.04990155f, -0.20549190f, 
    0.04802569f, 0.05901318f, -0.24312639f, -0.04846043f, -0.04446272f, 0.01708046f, 0.01614140f, -0.01895151f, 
    0.09812240f, -0.01295441f, 0.09521235f, -0.33024725f, -0.11159531f, 0.25280431f, 0.16186494f, -0.10931607f, 
    -0.05543399f, -0.00824234f, -0.21417287f, -0.03463269f, -0.01203398f, 0.00801209f, -0.18400697f, -0.01230426f, 
    -0.08851407f, -0.27442402f, 0.03269780f, -0.12830448f, 0.16011450f, -0.09175721f, -0.01474505f, -0.06589656f, 
    0.21966787f, -0.06190963f, -0.09791664f, -0.09392190f, -0.25462228f, -0.06966970f, 0.00056853f, -0.27557653f, 
    0.00585970f, -0.08081058f, 0.08413310f, 0.06947133f, -0.01066897f, 0.10071330f, 0.04611631f, -0.05352695f, 
    0.11615911f, 0.21529116f, -0.05894874f, 0.40296757f, -0.04928534f, -0.02625957f, -0.05690558f, -0.05308029f, 
    -0.09859339f, -0.02949748f, 0.11223113f, 0.00907278f, 0.10739474f, -0.13147032f, -0.20710696f, 0.13367479f, 
    0.20163462f, -0.01008037f, 0.15695620f, -0.10994875f, -0.22938997f, -0.01712988f, -0.06639376f, 0.02452200f, 
    0.11569476f, -0.49710649f, 0.06010736f, -0.33295035f, -0.01187520f, -0.12371548f, -0.09800588f, -0.04135083f, 
    -0.11814863f, 0.06604920f, 0.04759874f, 0.03830586f, 0.23768811f, -0.42715681f, -0.09756359f, 0.20623030f, 
    0.05211722f, -0.02335417f, 0.06724048f, 0.14073476f, -0.01973191f, -0.03027897f, 0.05923067f, 0.03813585f, 
    0.64633220f, -0.16169222f, -0.00338173f, -0.10919763f, 0.05634242f, 0.11251870f, -0.03796768f, -0.08980374f, 
    0.00803480f, 0.01272122f, 0.04620078f, 0.16539028f, -0.05396564f, -0.05209119f, 0.04575387f, -0.01493956f, 
    -0.00584761f, -0.04278348f, -0.10650383f, 0.11062003f, -0.11867367f, 0.20297654f, -0.03269778f, 0.10271305f, 
    -0.44487265f, 0.31228614f, -0.64399123f, -0.16128525f, 0.20863704f, -0.03669428f, -0.05498716f, 0.01177035f, 
    -0.16624430f, -0.09606824f, -0.19140773f, -0.03136357f, -0.26403978f, 0.04941036f, 0.03082631f, 0.19496763f, 
    0.02418565f, 0.18582498f, -0.16407964f, 0.02381157f, 0.03091004f, -0.03859632f, -0.06862469f, -0.00924459f, 
    0.50407690f, -0.11050303f, 0.05120806f, -0.08975044f, -0.13333721f, 0.05132961f, 0.13439561f, 0.21695559f, 
    0.04404518f, 0.03398428f, 0.05018412f, 0.21130191f, 0.12158451f, -0.48557162f, -0.10726631f, -0.08694854f, 
    -0.02681646f, 0.15243691f, 0.08387789f, 0.02628698f, 0.10438609f, 0.07844149f, 0.04822500f, -0.04285374f, 
    -0.09828322f, 0.09331541f, 0.06982237f, -0.18769275f, 0.06198511f, -0.09733144f, -0.13546184f, 0.12443203f, 
    0.06213961f, 0.04973643f, 0.07623669f, -0.14067222f, 0.03744588f, -0.33962053f, 0.12216900f, 0.29605305f, 
    -0.01862630f, 0.00135658f, -0.08451480f, 0.03394675f, 0.01566336f, 0.03845691f, -0.15525526f, -0.01271102f, 
    0.18267235f, 0.26461574f, 0.23412342f, -0.24911398f, 0.00867530f, 0.14833048f, -0.03985409f, -0.08229033f, 
    -0.23283713f, -0.04887120f, -0.20321509f, 0.00337899f, -0.32270786f, -0.12704071f, 0.36232024f, 0.12178345f, 
    0.04965473f, -0.02548764f, -0.03620680f, -0.06844980f, -0.04104193f, -0.04215514f, 0.08072755f, 0.07900916f, 
    -0.08301641f, -0.01767772f, 0.22805406f, 0.06764740f, 0.21830015f, -0.09971031f, 0.09046695f, -0.31727552f, 
    -0.12259589f, -0.09801065f, 0.02924544f, 0.01583975f, -0.08346494f, 0.14668183f, -0.03310537f, -0.60471117f, 
    0.02203308f, -0.11744543f, -0.04759005f, -0.00937413f, -0.02909909f, -0.04483705f, 0.01279928f, -0.25393453f, 
    0.13526250f, -0.29686856f, -0.10111151f, -0.02350511f, -0.04317262f, -0.08723523f, 0.02907805f, 0.07840940f, 
    -0.16304456f, 0.13300630f, -0.00010133f, -0.06426612f, -0.15659378f, 0.20426540f, 0.09779352f, -0.05108014f, 
    0.01530877f, -0.19803801f, 0.07742516f, -0.00975437f, 0.01864733f, -0.09280343f, -0.05405127f, -0.10735548f, 
    -0.47590399f, 0.35536391f, 0.28872779f, -0.04153097f, 0.18275471f, 0.04083135f, 0.14223081f, -0.02796960f, 
    -0.07689039f, -0.06174269f, -0.12522067f, -0.02300229f, 0.31965744f, 0.20406264f, -0.07687519f, 0.15289512f, 
    -0.00176470f, 0.14082095f, 0.14438914f, 0.05119042f, -0.09268502f, -0.15358904f, 0.10878690f, -0.16991037f, 
    0.07430985f, 0.11130802f, -0.13996300f, 0.33778745f, 0.06914270f, -0.07780358f, -0.08154373f, 0.02916914f, 
    0.16976157f, 0.13446198f, 0.17816645f, -0.04072242f, 0.03955614f, 0.09395948f, 0.32295045f, -0.05830550f, 
    0.11972766f, -0.07591611f, -0.14443587f, 0.09694196f, -0.08864276f, -0.11526220f, 0.03846227f, -0.04304321f, 
    -0.65312582f, 0.62710190f, -0.28474101f, -0.25090274f, 0.14829686f, -0.13814391f, -0.14625283f, -0.06114623f, 
    -0.08635490f, 0.03691730f, 0.05552111f, 0.09605784f, -0.14281763f, -0.44642070f, 0.11034083f, -0.17311044f, 
    0.00190317f, 0.08696026f, -0.10071012f, 0.17735873f, 0.03798566f, -0.09268308f, 0.15823336f, 0.08212650f, 
    -0.13383040f, 0.03658007f, 0.11364497f, -0.20572780f, -0.01433548f, 0.02223026f, -0.02952661f, -0.01132565f, 
    -0.14435059f, -0.00596014f, -0.13188015f, 0.02245063f, -0.40706265f, -0.57962763f, -0.14511748f, -0.04422313f, 
    0.18396737f, -0.01237712f, 0.03373638f, -0.11936727f, -0.00184367f, -0.01030108f, 0.00749211f, -0.11644386f, 
    -0.41294375f, 0.34277889f, -0.14691371f, -0.22046334f, 0.10862815f, 0.06556942f, 0.08926957f, -0.24693424f, 
    -0.01505915f, -0.06190848f, -0.00822160f, -0.10591254f, 0.12991561f, 0.16044991f, -0.09326923f, 0.15658008f, 
    0.16353691f, 0.06804597f, -0.01752391f, -0.08224322f, 0.01526025f, 0.11191800f, 0.04277809f, 0.14528479f, 
    0.18471751f, -0.25007498f, 0.28308851f, 0.00866900f, 0.02590334f, 0.14935447f, -0.02752739f, 0.11523125f, 
    0.05092357f, 0.05707608f, 0.00845297f, 0.06609715f, -0.32708058f, -0.22251178f, -0.03634089f, -0.08525442f, 
    0.00216708f, 0.08107007f, 0.00641973f, 0.07143380f, 0.05534953f, -0.04206531f, 0.05109759f, 0.01650805f, 
    -0.78745830f, -0.33695042f, -0.15436015f, -0.18590228f, 0.03912191f, 0.01937412f, -0.11365443f, 0.06455478f, 
    0.00545240f, 0.16098754f, 0.13105105f, 0.00152662f, 0.14195780f, -0.29784611f, -0.04655724f, 0.12484047f, 
    -0.02850031f, 0.03706101f, -0.01847862f, 0.00107970f, -0.00760071f, -0.03113974f, -0.04208069f, 0.24673447f, 
    0.19911806f, -0.23128517f, 0.03173820f, -0.19297200f, -0.07845908f, 0.04261550f, 0.14609739f, -0.15310764f, 
    -0.02326704f, 0.07789253f, -0.04231228f, 0.13988161f, 0.17495783f, -0.11571010f, -0.32188407f, 0.03935523f, 
    -0.02917415f, -0.16609010f, -0.25607362f, 0.21945268f, 0.00894344f, 0.11599171f, 0.14017834f, 0.13273305f, 
    0.30399323f, 0.41805089f, -0.07068167f, -0.10344476f, 0.10772200f, 0.13272819f, 0.02144295f, -0.00043107f, 
    -0.03063032f, -0.03936615f, -0.01025796f, -0.02883141f, 0.22629216f, 0.05420851f, 0.06597742f, -0.07389254f, 
    -0.00510126f, 0.09773451f, 0.01724743f, 0.03462775f, 0.03989546f, 0.07274044f, 0.04167168f, 0.07726932f, 
    -0.31360674f, 0.10625995f, -0.48099935f, -0.03418214f, 0.18477580f, 0.01947428f, -0.15088837f, -0.04111184f, 
    0.04344971f, -0.00813789f, 0.11875715f, -0.08527867f, 0.38652694f, -0.01865972f, -0.09391124f, 0.05250011f, 
    -0.17931724f, -0.00727737f, 0.02643792f, 0.00587283f, 0.13184018f, 0.00393615f, -0.07357553f, -0.14284758f, 
    -0.28502634f, -0.46476328f, -0.05960140f, -0.42945632f, -0.03199181f, 0.05349487f, -0.15822117f, 0.00113490f, 
    0.00665891f, 0.10518152f, -0.09470551f, -0.01738493f, 0.24098402f, 0.01330836f, -0.16140877f, 0.06680396f, 
    0.08078158f, 0.14540134f, 0.18347572f, 0.09023735f, 0.00339963f, 0.17675355f, 0.05214572f, -0.06322338f, 
    -0.92534262f, -0.30434257f, 0.14065188f, -0.10573331f, 0.14617525f, -0.00203926f, -0.07002486f, -0.16276868f, 
    0.04430626f, -0.01953956f, -0.07536995f, 0.03006097f, -0.30277616f, -0.12024546f, 0.25104970f, -0.22210689f, 
    0.09249035f, 0.01276353f, -0.04865917f, -0.01835430f, -0.03351754f, -0.08976629f, 0.03888090f, -0.04467379f, 
    -0.45223299f, 0.12168638f, 0.15484808f, -0.20587872f, 0.17555788f, -0.15642834f, -0.19575669f, -0.09501532f, 
    -0.04292303f, -0.10476945f, -0.05469748f, -0.10452342f, -0.06431907f, -0.04732770f, 0.02353269f, -0.00847435f, 
    0.09527371f, 0.06940123f, -0.01673824f, -0.03403341f, 0.06416523f, -0.09710401f, 0.01220822f, 0.10080152f, 
    -0.73880619f, -0.23995046f, 0.21485159f, -0.07502411f, 0.06668457f, -0.09629322f, 0.00660091f, 0.06960906f, 
    0.09304290f, 0.11478827f, -0.14095172f, 0.13272880f, -0.04337896f, -0.07502433f, -0.00201973f, -0.01192242f, 
    -0.19487159f, 0.10556941f, -0.09032947f, 0.03349955f, -0.02243884f, 0.07364883f, 0.09686365f, -0.05364051f, 
    -0.44820443f, -0.19181454f, -0.10971967f, 0.00401477f, 0.06114109f, 0.10842900f, -0.02746988f, 0.11286449f, 
    0.20143190f, 0.00226412f, 0.05702340f, 0.18655473f, -0.08703494f, 0.02138492f, -0.13396350f, -0.13592257f, 
    -0.07445130f, 0.04161563f, -0.00316551f, 0.07658950f, 0.07832029f, 0.22862563f, 0.14390458f, 0.25636977f, 
    0.13946888f, 0.05980486f, -0.02617681f, -0.04552794f, -0.11650444f, 0.10355359f, -0.09019207f, 0.03939425f, 
    0.12951981f, 0.03198736f, -0.01049224f, -0.14560677f, 0.17563562f, 0.25675741f, -0.03002815f, 0.00175865f, 
    0.02191345f, 0.04049017f, 0.02299992f, 0.06112418f, 0.03081390f, 0.12420446f, 0.02329629f, 0.15559158f, 
    -0.29968503f, -0.30796883f, -0.24523175f, 0.00442297f, 0.21023628f, -0.08580265f, -0.04715945f, -0.00626764f, 
    0.17261447f, 0.20172520f, 0.15026785f, -0.00474155f, 0.07168641f, -0.20301706f, 0.05014147f, -0.08999586f, 
    0.11278679f, -0.04814633f, -0.02385211f, -0.00176653f, -0.17532088f, 0.07110920f, -0.19876535f, 0.14985062f, 
    0.36282969f, 0.21305862f, 0.00970435f, 0.12453545f, -0.13732606f, -0.15644372f, 0.08706256f, 0.01472964f, 
    0.05241094f, -0.12008981f, -0.11452440f, -0.07912393f, -0.37553495f, -0.01999543f, 0.44805005f, -0.08482548f, 
    0.07430737f, -0.04099821f, 0.04548266f, -0.07402395f, 0.03013428f, -0.08844194f, -0.11547409f, 0.05453341f, 
    -0.45050392f, -0.21015236f, 0.03011825f, -0.21164827f, 0.00546853f, -0.05752515f, -0.03958862f, 0.09902152f, 
    0.06454830f, -0.16498561f, 0.16835722f, -0.01931249f, -0.35550055f, 0.11137097f, -0.12047042f, 0.03315261f, 
    0.17715448f, 0.11078059f, 0.13155539f, 0.07126508f, 0.11453956f, 0.23052132f, -0.13115601f, 0.03637378f, 
    -0.42674273f, 0.01004021f, 0.35068282f, -0.14675777f, 0.04711097f, 0.06352112f, 0.08167693f, 0.04862631f, 
    0.04180725f, 0.16390955f, 0.12706317f, -0.00977827f, 0.26574802f, 0.08118723f, -0.14829458f, 0.02445816f, 
    -0.18882886f, -0.11728553f, 0.18125647f, -0.08950016f, 0.05120608f, -0.05964607f, -0.16724020f, 0.03675058f, 
    -0.33169341f, -0.18984899f, -0.08693846f, -0.23741944f, -0.02673365f, 0.08938967f, 0.04775219f, 0.01258173f, 
    0.21871720f, 0.07507825f, 0.04557127f, 0.17037377f, -0.06354693f, -0.25025073f, 0.03015933f, 0.03791168f, 
    -0.06159892f, 0.14228521f, 0.19244567f, -0.19212225f, 0.04494531f, -0.18395105f, -0.28354257f, -0.16041709f, 
    -0.40243447f, 0.09931246f, -0.09583879f, 0.28660828f, 0.02785535f, 0.16177054f, -0.05374177f, -0.06092034f, 
    0.03258433f, -0.02595875f, -0.09673696f, -0.03708171f, 0.12677886f, 0.02792699f, 0.01881309f, -0.08586816f, 
    -0.16178474f, -0.10085211f, 0.05295662f, -0.11721302f, 0.01173648f, -0.16538663f, -0.14528523f, 0.02279969f, 
    -0.25026801f, 0.18105142f, -0.42136455f, -0.13099182f, -0.04077404f, 0.06146968f, -0.00512452f, 0.10965635f, 
    -0.04050890f, -0.08752102f, -0.11552473f, -0.04019393f, -0.05018451f, 0.17679538f, -0.24957235f, 0.02422581f, 
    0.16702454f, 0.12515962f, 0.03349687f, 0.06815898f, -0.05289904f, 0.01139991f, -0.14684391f, -0.08958136f, 
    -0.20673940f, 0.23111364f, 0.06053576f, -0.04772803f, 0.04327811f, -0.14667509f, -0.30217913f, 0.15349235f, 
    0.01751641f, -0.08660860f, 0.27316588f, -0.02988502f, -0.44991046f, -0.00380384f, 0.00416274f, -0.01999259f, 
    0.05377398f, -0.04668685f, 0.06366635f, -0.07440314f, 0.00324502f, -0.30975154f, -0.00148481f, -0.02694415f, 
    0.08841384f, -0.11740094f, -0.16317526f, -0.01430137f, -0.16632833f, 0.03214893f, 0.06447551f, -0.04278148f, 
    0.16182603f, -0.04540478f, 0.02138640f, -0.00404422f, -0.09392463f, 0.05500789f, 0.13094266f, -0.14937557f, 
    -0.06580544f, -0.13547719f, 0.04861529f, 0.13473892f, -0.09866309f, 0.10530388f, 0.04914147f, -0.27910772f, 
    -0.44365489f, -0.20309409f, -0.03814665f, -0.13828425f, -0.15715535f, 0.04980510f, 0.03326349f, 0.08007906f, 
    -0.12905803f, 0.06111136f, 0.05845438f, 0.02446319f, -0.14204137f, 0.02202788f, -0.20335224f, 0.12122787f, 
    0.09549884f, -0.09437704f, -0.01251701f, 0.06025590f, 0.14749044f, -0.13214722f, 0.06049792f, -0.01042573f, 
    -0.06663869f, -0.39868209f, 0.04380166f, -0.09423154f, 0.17750269f, 0.03830068f, -0.01306205f, -0.15499322f, 
    -0.05277834f, -0.00918168f, -0.00693236f, -0.01095568f, 0.34784546f, -0.02963908f, -0.18220206f, 0.08224829f, 
    0.03672213f, -0.06642653f, 0.02608714f, -0.02248535f, -0.05765130f, -0.09056858f, -0.07534344f, 0.04756185f, 
    -0.34506342f, 0.15307011f, -0.11795819f, -0.44014797f, 0.16222948f, -0.03855685f, -0.13791208f, 0.11003151f, 
    0.01833546f, -0.04189526f, 0.05986876f, -0.10266753f, -0.15791255f, -0.01542977f, -0.07555292f, 0.21543705f, 
    0.06050269f, -0.06161844f, 0.13446179f, 0.01728985f, 0.19954816f, -0.05534798f, 0.08666548f, -0.08651163f, 
    0.34038979f, -0.23825929f, 0.15585953f, -0.22384770f, 0.06146556f, -0.11242577f, -0.02561232f, -0.02525435f, 
    -0.08756375f, -0.16649115f, 0.16391949f, 0.12096331f, 0.25207493f, 0.14377895f, -0.10425821f, 0.21718234f, 
    0.06812138f, 0.09337273f, -0.12831426f, 0.02926961f, 0.06988554f, 0.06862345f, -0.13626596f, -0.05334801f, 
    0.66711169f, 0.15030487f, -0.25019521f, 0.06997290f, -0.07421077f, -0.12019144f, -0.05998180f, -0.01610877f, 
    0.13580395f, 0.20533432f, 0.03031817f, 0.08128168f, -0.32580170f, -0.12526524f, -0.04473807f, 0.07404710f, 
    -0.33421472f, 0.07239109f, 0.05846975f, -0.10880423f, -0.07653328f, -0.07438461f, 0.03306165f, -0.11123394f, 
    0.40565619f, 0.09026906f, -0.19113441f, 0.04916404f, 0.06492710f, 0.08509156f, 0.22097163f, -0.00080102f, 
    0.00486017f, 0.03351078f, -0.10209693f, 0.08289792f, 0.05122390f, 0.09861676f, -0.24289748f, 0.04055355f, 
    0.06496321f, 0.02388640f, 0.08611490f, 0.01656781f, -0.07771101f, -0.11105096f, -0.04353532f, -0.12087890f, 
    -0.46412882f, 0.31787381f, -0.18780740f, 0.12192109f, -0.08217152f, -0.16842772f, -0.07581265f, -0.08771051f, 
    0.02884033f, 0.07202513f, 0.04404348f, -0.04793072f, -0.41471502f, 0.26896077f, -0.00787002f, 0.01355006f, 
    0.07990879f, -0.07421440f, 0.04552704f, 0.02699279f, 0.09635758f, 0.00122584f, 0.00833005f, -0.05050397f, 
    0.29402143f, -0.13162291f, -0.16477910f, 0.03749074f, 0.22107400f, -0.07726695f, -0.24129514f, -0.10877676f, 
    0.00371131f, -0.14974929f, -0.10167311f, 0.05828029f, -0.24084702f, -0.23283672f, -0.01032436f, 0.17019860f, 
    -0.07260574f, -0.06052792f, 0.19851512f, 0.09914343f, -0.12245971f, -0.16080761f, -0.03733270f, -0.08513130f, 
    -0.11524472f, -0.26983586f, 0.20930493f, -0.00949191f, 0.13801064f, 0.12146623f, 0.11890971f, -0.10509991f, 
    0.08390266f, -0.07895981f, 0.17577541f, 0.24202859f, 0.22642596f, 0.06536105f, -0.13661839f, -0.04155780f, 
    0.04814711f, -0.06170062f, -0.27763945f, -0.27369115f, -0.03394041f, 0.14868534f, -0.05260844f, -0.01526210f, 
    0.15208173f, -0.17067513f, 0.00058439f, 0.21100008f, -0.02725884f, 0.11207911f, 0.04312333f, -0.00944154f, 
    0.02366200f, 0.14099906f, -0.04900084f, -0.04733528f, -0.13822927f, -0.12338393f, 0.12034269f, 0.36283502f, 
    -0.00551088f, 0.17478877f, -0.08139770f, 0.19978254f, 0.10162453f, 0.01498370f, -0.06417733f, 0.21176001f, 
    0.76923126f, 0.12637807f, -0.20301963f, 0.00843906f, 0.07092997f, -0.18509458f, -0.16442651f, 0.01017973f, 
    0.02378320f, 0.06760872f, -0.06282838f, 0.03680397f, 0.25738779f, -0.15003906f, 0.03270817f, 0.06006797f, 
    0.09947687f, 0.04531934f, 0.05499829f, 0.11204784f, -0.10748514f, -0.10683961f, -0.05609573f, -0.15996878f, 
    0.12753840f, -0.20673366f, -0.18831317f, -0.20197390f, 0.05687209f, 0.04053009f, -0.04741685f, -0.08691865f, 
    0.05606851f, -0.04130975f, -0.05671958f, -0.17294155f, -0.62772465f, -0.21463452f, -0.03500621f, -0.30835077f, 
    0.11164600f, -0.06515759f, 0.12974843f, 0.16047326f, 0.07327548f, -0.02185962f, 0.03266989f, 0.22337048f, 
    0.28538132f, 0.18151541f, -0.09623590f, -0.05883785f, -0.11028203f, -0.10405850f, -0.13687418f, 0.04183753f, 
    -0.04664727f, 0.11311732f, 0.10137379f, 0.19598573f, 0.23903765f, -0.25183228f, -0.21167608f, 0.15258630f, 
    0.09004595f, -0.05502398f, -0.05091297f, -0.05433063f, 0.06040829f, -0.06162686f, 0.01129668f, -0.08359991f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.11159272f, -0.00141331f, -0.06705479f, 0.01859565f, -0.02037399f, 0.00087745f, -0.02192573f, -0.12450166f, 
    -0.01408910f, 0.03139622f, 0.07324057f, 0.03189579f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
