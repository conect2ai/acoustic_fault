#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.27044535f, 0.83170730f, 0.39120302f, 0.33863109f, 1.53975105f, 0.63440359f, -0.09331155f, 0.61053509f, 
    0.53392178f, 0.35460749f, -0.18653266f, 0.12891445f, 0.28204244f, 0.11982929f, 0.05120480f, -0.09927888f, 
    0.08915436f, -0.00011983f, -0.07026000f, -0.22657317f, 0.06914174f, 0.13983002f, 0.10471412f, 0.23559727f, 
    0.16168572f, 1.29995334f, -1.17170465f, 0.32901904f, 0.34664977f, -0.24340688f, 0.89807314f, -0.98042160f, 
    0.38152578f, 0.26603886f, 0.03388130f, 0.23524071f, -0.22285971f, -0.57682389f, 0.09534498f, -0.13313611f, 
    0.27736518f, -0.38480994f, -0.18944417f, -0.20652872f, 0.11947140f, 0.27791941f, -0.11174592f, 0.26060653f, 
    0.02910031f, 0.00531419f, 0.08225189f, -0.10080355f, 0.80436814f, -0.58340961f, 1.05859339f, -1.07465756f, 
    -0.19248019f, -0.36805090f, -0.44982558f, -0.63728881f, 0.25353625f, 0.10018025f, -0.08624171f, -0.06009420f, 
    0.08741001f, 0.37418222f, -0.16116033f, -0.18335071f, 0.01739223f, 0.14368407f, 0.11898039f, -0.20256567f, 
    0.11115363f, -0.30656093f, -0.02893879f, 0.67986083f, 1.50723982f, 1.05938613f, -0.23289861f, -0.12120255f, 
    -1.22058928f, 0.40540582f, -0.17788878f, -0.47847277f, 0.88966167f, 0.19936776f, 0.18717755f, -0.53718156f, 
    0.07935579f, -0.17927468f, 0.00089734f, -0.29331359f, -0.13938160f, 0.01332629f, -0.11961433f, -0.24446279f, 
    0.02818788f, 0.10021368f, 0.00034990f, 0.07035982f, 0.30850369f, -0.27625257f, -0.40640703f, -1.21123660f, 
    -0.70773572f, 0.30111799f, 0.81828058f, 0.54941934f, -0.17467415f, 0.09415819f, -0.41253242f, -0.34503245f, 
    -0.29886565f, -0.11975310f, -0.56277192f, -0.12362172f, -0.30951527f, 0.04157474f, -0.32476038f, 0.04717732f, 
    -0.01011716f, -0.28808665f, 0.26949397f, 0.15222318f, -0.08417914f, -0.41216633f, -0.50587666f, 0.66731912f, 
    0.25754815f, 0.86020362f, -0.39562291f, 0.84155768f, 0.07086807f, -0.53346473f, 0.67327118f, -0.15362792f, 
    0.10788847f, 0.35665286f, -0.10266027f, 0.09151574f, -0.24845292f, 0.28889462f, -0.50656867f, 0.15977767f, 
    -0.18396978f, 0.02868047f, -0.30093744f, 0.23355134f, -0.00177536f, 0.42574674f, 0.92158020f, 0.42335528f, 
    0.44757381f, 0.88519907f, -0.03207342f, 0.05678397f, 0.53959793f, 0.50418395f, 0.64478749f, 0.75672859f, 
    -0.72145700f, -0.01166916f, -0.00615304f, -0.39288962f, -0.49777269f, -0.29035175f, -0.30121171f, -0.37019151f, 
    -0.03772878f, -0.08844025f, -0.08213033f, -0.00405674f, -0.43871173f, -0.08684040f, -0.13668579f, 0.05977683f, 
    -0.68283254f, -0.66980559f, -0.09361001f, -0.00604416f, 0.60088563f, 0.52787000f, 0.21518099f, 0.65527356f, 
    0.14647700f, 0.17525549f, 0.32296470f, 0.02527648f, 0.58342838f, 0.69531047f, 0.05290298f, -0.42294452f, 
    -0.31774640f, -0.02698143f, 0.50220418f, 0.28996986f, -0.23200199f, -0.20901532f, -0.04330194f, -0.08693267f, 
    0.69930100f, 0.74625623f, -0.72356886f, -0.01693631f, 0.31954196f, -0.40432334f, -0.10197101f, -0.65344620f, 
    0.13810338f, 0.39615533f, 0.40174797f, 0.19375135f, -0.05437169f, 0.09032188f, 0.04331193f, 0.14302242f, 
    0.30481330f, 0.62210166f, 0.12772875f, 0.43617088f, 0.46648258f, -0.47579217f, -0.06413234f, -0.13366815f, 
    0.23221973f, -0.83378756f, -1.06770754f, -0.71530074f, 0.12907453f, -0.19836238f, 0.94468760f, 0.68305618f, 
    0.35125679f, 0.47610778f, 0.48703298f, -0.19180825f, -0.22598404f, -0.13265884f, -0.11277182f, 0.14950110f, 
    -0.17129233f, 0.41188774f, 0.41523406f, -0.40446353f, -0.07684077f, -0.35224536f, -0.13357638f, 0.08182044f, 
    -0.17567426f, 0.02741244f, 0.29125494f, -1.64166832f, -0.74080503f, 0.72103423f, 0.47279361f, -0.82644910f, 
    1.11358559f, 0.15787262f, -0.65252781f, 0.35613373f, 0.46688893f, 0.34775564f, -0.13598742f, 0.00570053f, 
    0.28835616f, -0.23687688f, 0.01749084f, 0.19838183f, -0.18832633f, -0.05433179f, 0.15508677f, 0.19385189f, 
    -0.18647365f, 0.17471573f, -0.11444569f, -1.12680531f, 0.45046231f, 1.12431014f, 0.62931925f, -0.67768973f, 
    0.09355491f, 0.32478157f, 0.52054048f, -0.46240065f, 0.30766135f, -0.06315454f, 0.12470698f, 0.16171648f, 
    0.38830757f, -0.20332335f, 0.32114816f, 0.08648199f, -0.42861089f, 0.15936360f, -0.28823209f, 0.18247142f, 
    0.02131717f, -0.08797316f, 0.02345980f, 0.02701866f, -1.33624339f, 0.49284583f, -0.44967121f, 0.59478563f, 
    0.54086846f, -0.69342875f, 0.41134614f, -0.41904908f, -0.48632166f, -0.77913457f, 0.54387283f, 0.07876267f, 
    0.08088982f, 0.07501081f, 0.53812146f, 0.29360005f, 0.15883513f, -0.18607226f, 0.06442420f, 0.37369701f, 
    0.06502178f, 0.07470367f, -0.19798815f, 0.05314236f, 0.12064505f, -0.61038268f, -1.11110449f, 0.00255254f, 
    0.76037651f, -0.00123334f, -0.30060998f, 1.06560981f, 0.69231898f, 0.21655706f, 0.52295107f, -0.15234642f, 
    -0.14289126f, -0.83953637f, 0.09411382f, -0.23244368f, -0.26829955f, 0.29487118f, -0.62075323f, 0.29720062f, 
    -0.20827724f, -0.06578750f, 0.28461334f, 0.18855231f, 0.40713444f, -0.20262267f, -0.28297025f, 0.26796466f, 
    0.07307397f, 1.29525244f, -0.17263579f, -0.87963367f, -0.01041118f, -1.01170063f, 0.20230955f, -0.14337862f, 
    0.56521416f, -0.28711706f, -0.37102196f, -0.13817075f, 0.21417795f, -0.48320705f, 0.14543900f, -0.36963943f, 
    -0.13370337f, -0.37483525f, -0.01173458f, -0.14407249f, 0.24762222f, 0.28095311f, -0.06435908f, 1.02632225f, 
    0.85325509f, -0.19733052f, -0.80548900f, -0.32416636f, -0.18440619f, 0.39950198f, 0.14912623f, 0.61012018f, 
    0.75696570f, 0.28089973f, 0.20774665f, -0.26246473f, -0.52051812f, 0.31406999f, 0.33987626f, -0.03680890f, 
    -0.51686114f, 0.08495437f, 0.32102546f, 0.06855391f, -0.03773762f, 0.15590073f, -0.14103436f, -0.50257868f, 
    0.72979259f, -0.42278683f, -0.79173791f, -1.10970283f, -0.22198881f, 0.80034024f, 0.76808947f, -0.06576010f, 
    -0.04646912f, 0.32664761f, -0.22203660f, -0.02391555f, -0.22012237f, -0.25777143f, -0.08514009f, -0.24536642f, 
    0.26335827f, 0.31913814f, -0.06503768f, -0.18499969f, -0.28715256f, -0.33126494f, 0.04606888f, 0.21179964f, 
    0.34415838f, 0.29590517f, -0.42839673f, -0.66797870f, 0.05692308f, 0.38799390f, -0.27898988f, 0.76351464f, 
    0.38966355f, 0.37031004f, -0.73768932f, -0.31577304f, -0.58070350f, -0.77176446f, -0.52096134f, -0.65452129f, 
    -0.30799684f, -0.01472265f, -0.56179786f, -0.44455075f, -0.49625406f, 0.33262518f, 0.10698972f, 0.01501992f, 
    0.02080696f, -0.42805839f, 0.22191738f, 0.41582420f, 0.24802652f, -0.03557626f, -0.62738019f, -0.72588176f, 
    0.25214788f, -0.96904141f, -0.78605366f, -0.24464121f, 0.46946797f, 0.55194825f, 0.42240849f, 0.20275401f, 
    -0.09712035f, -0.11553829f, 0.16146252f, -0.05135082f, 0.43671224f, 0.21501410f, 0.30474910f, 0.32967600f, 
    -0.34000784f, 0.37672848f, 0.64806032f, 0.74815834f, 0.71913767f, 1.40426731f, 0.58997500f, 0.61844075f, 
    0.98916519f, -0.06270492f, -0.29802033f, -0.13990100f, -0.00878966f, 0.25681794f, 0.61805016f, -0.01799986f, 
    0.11410110f, -0.54737449f, 0.09436594f, 0.07015080f, 0.28950399f, -0.01135971f, -0.14701824f, 0.13532512f, 
    -0.06327431f, 0.13555729f, -0.15143444f, 0.09384699f, -0.84047490f, 0.60716397f, -1.17114592f, -0.85590369f, 
    0.33785197f, 0.05456122f, 0.38623825f, 0.99129105f, 0.23904189f, 0.54276872f, 0.52316409f, -0.56307930f, 
    0.18862037f, -0.48808745f, 0.19286120f, 0.25418204f, 0.35198462f, -0.05663636f, 0.41153693f, -0.05047480f, 
    -0.33655423f, -0.13785808f, -0.16955808f, 0.21290766f, -0.00929311f, -0.69267708f, -0.13868599f, -0.59488815f, 
    -0.61471575f, -0.68503332f, 0.00159072f, 0.75433993f, -0.53525269f, -0.21980834f, 0.51152194f, -0.26854032f, 
    0.02776284f, -0.22502179f, 0.31251350f, 0.39718491f, -0.27212751f, 0.01183932f, 0.17409864f, 0.39418706f, 
    -0.07801383f, 0.42065972f, 0.23418254f, 0.21312754f, -0.24924634f, 0.20354916f, -0.62463284f, 0.28637192f, 
    -0.03864496f, 0.70309329f, 1.00443590f, -0.20867977f, 0.71550798f, 0.95788914f, 0.45504710f, 0.13556555f, 
    -0.32765633f, -0.34607103f, 0.14768495f, 0.28856206f, -0.00853847f, -0.11785671f, -0.32904756f, 0.60240936f, 
    -0.07768071f, 0.10082658f, 0.39239779f, 0.29821485f, -0.20624605f, 0.15610866f, -0.42095062f, -0.71366405f, 
    0.25426558f, 0.70467007f, -0.09537671f, -0.76775962f, -0.62920904f, 0.51352215f, -0.23214622f, -0.61731619f, 
    -0.77316165f, 0.14791109f, 0.58707047f, -0.50243175f, 0.30765072f, -0.33275452f, -0.33545569f, -0.26509774f, 
    0.13049184f, -0.63494796f, 0.06980420f, -0.03881312f, 0.39773235f, 0.29399019f, 0.21240941f, -0.21164899f, 
    0.74355465f, -0.85829055f, -0.83406126f, -0.60539013f, -0.27015588f, -1.04801548f, 0.75511426f, 0.23225276f, 
    -0.36732507f, 0.49408737f, 0.10373877f, 0.42785051f, 0.31498599f, -0.29434392f, -0.18556900f, -0.34415570f, 
    0.21365148f, -0.31209153f, -0.32263529f, -0.32760265f, 0.02127305f, -0.12191986f, 0.26077357f, -0.28274456f, 
    0.10990532f, -1.50977933f, 0.21215633f, 0.46944293f, -0.31763816f, -0.32853138f, 0.44174606f, 0.98667008f, 
    -0.64957136f, 0.05972017f, 0.27560332f, -0.07705301f, 0.10354070f, 0.29906085f, -0.60824639f, 0.01611575f, 
    0.07455587f, -0.20427945f, 0.22512802f, -0.06418934f, -0.34636328f, 0.15573540f, -0.07306067f, 0.38494930f, 
    0.43933859f, 0.16505361f, 0.68079215f, 0.78717571f, -0.94605613f, 0.36101624f, 0.41754782f, 0.04102341f, 
    0.48925263f, 0.66699022f, 0.56817430f, -0.62177086f, -0.41518164f, -0.25076008f, 0.43044141f, -0.10449018f, 
    -0.19995931f, 0.28326657f, -0.28798172f, 0.35522160f, -0.42561755f, 0.33592942f, 0.21258479f, -0.29797772f, 
    0.30541629f, 0.07159795f, 0.30361807f, -0.16513643f, 0.37495187f, -0.45406890f, -0.45233849f, -0.40764254f, 
    -0.40821236f, -0.18143637f, -0.54846174f, -0.46352789f, 0.72949719f, -0.05977377f, -0.17430790f, -0.59556127f, 
    -0.42064881f, 0.22452787f, -0.02592165f, -0.32716113f, 0.40971246f, -0.43102896f, 0.32272550f, -0.71043921f, 
    0.22928230f, -0.07111537f, -0.02722473f, 0.15923369f, -1.38162303f, 0.32241538f, 0.62514907f, -0.91073376f, 
    0.15003440f, 0.90530455f, 0.63923156f, 0.78224391f, 0.34127042f, -0.51330400f, -0.10064925f, -0.19387284f, 
    -0.23455049f, -0.20210451f, -0.29649225f, 0.30339783f, -0.23349576f, 0.18757388f, -0.37459064f, -0.13801533f, 
    -0.35579762f, 0.07334414f, -0.02861329f, -0.14123367f, 0.20259370f, -0.74010229f, -1.16590059f, -1.01230776f, 
    -0.70900017f, 0.19803905f, -0.66999555f, -0.65514362f, -0.22256146f, -0.40477604f, 0.36120555f, -0.28302369f, 
    0.35471863f, 0.38597223f, -0.01588828f, -0.15187958f, 0.30389005f, 0.11573929f, 0.27041402f, 0.32258549f, 
    0.15803662f, -0.11606769f, -0.36506572f, -0.01687120f, 0.06938899f, -0.01203569f, 1.15957963f, -0.04065268f, 
    0.00231936f, 0.20921145f, 0.29583356f, 0.97857648f, 0.36015657f, -0.31267518f, 0.60310918f, 0.00828576f, 
    -0.06793814f, -0.20461637f, -0.43729866f, 0.35161784f, -0.22659126f, 0.48270851f, 0.50863981f, -0.01085403f, 
    0.31286409f, 0.25471672f, -0.27317783f, 0.59860277f, -0.10948793f, -0.19693631f, 0.43771553f, 0.72317660f, 
    0.81997514f, 1.24704766f, 1.15058231f, 0.73060715f, -0.34591898f, -0.06446472f, -1.00150049f, -0.60224789f, 
    -0.25900933f, 0.33400828f, -0.33695945f, -0.03796548f, 0.32497579f, -0.10911677f, 0.07436783f, 0.09200206f, 
    0.11759026f, -0.08905288f, 0.10808584f, -0.06410658f, 0.32647255f, 0.22371960f, 0.28556576f, 0.21853705f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.16933858f, 0.36778453f, 0.35427725f, 0.28620294f, 0.05558322f, 0.24905053f, 0.37723061f, 0.09494442f, 
    0.35061488f, 0.24092647f, 0.13586825f, 0.08051635f, 0.23507056f, 0.16589800f, 0.29670355f, 0.45726925f, 
    0.12100447f, 0.04127259f, 0.26118472f, 0.37351918f, 0.10012630f, 0.19556659f, 0.23032205f, 0.12223700f, 
    0.10423658f, 0.00139314f, 0.10170909f, 0.32675883f, 0.18681672f, 0.40648755f, 0.03885652f, 0.24979292f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.35886258f, -0.12283679f, 0.27543250f, 0.04692776f, -0.22631142f, 0.05356008f, 0.00813417f, 0.06269770f, 
    -0.02375804f, 0.09160405f, 0.01560364f, -0.13187329f, 0.46981156f, -0.47590247f, -0.03197304f, 0.27878696f, 
    -0.07872919f, 0.06809360f, -0.15569484f, -0.03641498f, -0.19588208f, -0.03566183f, -0.11854588f, -0.17027657f, 
    0.15742598f, -0.11194599f, -0.13687964f, -0.20681445f, -0.14712210f, 0.18652013f, -0.15663537f, 0.14772159f, 
    0.07516512f, -0.24354783f, -0.00896599f, -0.12455477f, 0.09129895f, 0.10330789f, 0.02350052f, -0.11995129f, 
    0.00452714f, -0.11963332f, 0.00959429f, 0.08292037f, -0.07514922f, -0.10390694f, 0.04780656f, -0.15295903f, 
    -0.13144393f, 0.19261855f, 0.13375290f, -0.54803735f, -0.04177957f, 0.07237453f, -0.01958344f, -0.01203039f, 
    -0.02599060f, 0.08303540f, 0.07726153f, 0.07593539f, -0.19445021f, 0.03144559f, 0.01508140f, -0.17630611f, 
    -0.08925672f, 0.06309152f, -0.06361850f, -0.17065760f, -0.14638236f, -0.01572694f, -0.07987673f, 0.17229563f, 
    0.19513620f, -0.01972385f, -0.19198996f, 0.36968938f, -0.01211409f, -0.03808129f, -0.07399283f, -0.01023961f, 
    0.02215950f, -0.01801466f, -0.02823510f, -0.05868958f, 0.04384612f, -0.06147060f, -0.16228037f, -0.15471067f, 
    -0.14876148f, -0.10269586f, 0.07940537f, -0.12668976f, 0.16615599f, 0.03151875f, 0.11557009f, 0.09948885f, 
    -0.17134841f, -0.07013413f, 0.19268329f, -0.04977025f, -0.19319524f, -0.10289066f, 0.07024785f, 0.08861080f, 
    -0.02258765f, 0.07314932f, 0.06636294f, -0.15302540f, 0.20805445f, 0.10160886f, -0.12031356f, -0.05596546f, 
    0.19785982f, 0.16043858f, -0.02234454f, 0.07928563f, 0.07532100f, -0.03468394f, -0.04009044f, 0.10479427f, 
    -0.31886405f, 0.06610129f, -0.04224096f, 0.27917102f, -0.12426262f, -0.15908575f, -0.11055060f, -0.05260345f, 
    -0.08084537f, 0.00772849f, -0.07738128f, 0.04982981f, -0.42719617f, 0.37944227f, 0.03618419f, 0.33850288f, 
    0.06247825f, 0.07516560f, 0.02675662f, -0.06024899f, 0.01186841f, -0.14800303f, 0.07504018f, -0.13216534f, 
    -0.34193790f, 0.16581562f, 0.00014438f, 0.10114803f, 0.03511401f, -0.08218343f, 0.07904715f, 0.05857774f, 
    0.06868814f, 0.01573125f, 0.00699302f, -0.02583588f, -0.21575777f, 0.21291937f, 0.01432357f, 0.00992814f, 
    -0.00407447f, 0.19311035f, -0.16972806f, 0.02964338f, 0.01097912f, -0.07597297f, -0.16627090f, 0.01920443f, 
    0.01150681f, -0.17229791f, -0.24113078f, 0.28064874f, 0.12381417f, -0.12496848f, 0.02477625f, -0.27356005f, 
    -0.02323284f, -0.05693227f, -0.02858573f, 0.13081205f, -0.08053356f, 0.02390661f, 0.03470363f, -0.40002474f, 
    -0.00989889f, -0.06619170f, 0.12752043f, -0.09041101f, 0.01918794f, -0.00380698f, 0.13093181f, 0.10013012f, 
    0.07288944f, 0.02861263f, 0.14660735f, -0.36765972f, 0.02315936f, 0.08212876f, -0.09970073f, -0.02881422f, 
    -0.04094890f, 0.04992779f, 0.00331877f, 0.10213497f, -0.33236626f, 0.32461739f, -0.06209466f, -0.00209069f, 
    -0.01964604f, 0.02053504f, -0.00323645f, -0.01365418f, -0.02759842f, 0.17329404f, 0.22889467f, -0.02906283f, 
    -0.19941959f, 0.18044990f, 0.21648924f, 0.17483735f, -0.13742977f, 0.17107160f, -0.03466716f, 0.02467516f, 
    -0.00852432f, -0.17391355f, -0.12066295f, 0.06557675f, -0.22242129f, -0.10638048f, -0.11510114f, 0.03370619f, 
    -0.31535733f, -0.25419682f, 0.01986948f, -0.03360163f, -0.04566052f, 0.13465513f, -0.12796989f, -0.00366768f, 
    0.28397164f, 0.25684083f, 0.13859406f, -0.31247571f, 0.13403669f, 0.05385244f, -0.06549721f, -0.11627964f, 
    -0.00807967f, 0.10832106f, -0.15375781f, -0.10256248f, 0.30086949f, -0.23502582f, 0.05665313f, -0.46317786f, 
    0.14158793f, 0.10595078f, 0.07717050f, 0.10692925f, 0.03594002f, -0.00273887f, -0.05011936f, 0.09931578f, 
    -0.41664124f, 0.33445105f, 0.05106720f, 0.02114513f, -0.23843187f, 0.02291753f, 0.00692986f, 0.04461498f, 
    0.04886789f, -0.08188796f, -0.08566770f, 0.10433495f, -0.41818884f, 0.06687123f, -0.02066632f, 0.15024050f, 
    0.06595155f, 0.13460201f, -0.14884521f, 0.08752123f, 0.11192705f, 0.00686914f, 0.04195343f, -0.06807171f, 
    -0.55762833f, -0.33919609f, 0.14405996f, -0.19928005f, -0.09853335f, -0.05733484f, -0.01178433f, -0.06908121f, 
    -0.06742929f, 0.05765380f, 0.03453216f, -0.04157675f, 0.56848228f, 0.11656311f, 0.42638254f, -0.19730274f, 
    0.00451483f, -0.01515318f, -0.03145846f, 0.02955248f, -0.00444670f, 0.05099586f, 0.07117269f, 0.07356089f, 
    0.05898600f, 0.18617666f, -0.19226028f, -0.10211581f, -0.27054715f, 0.06085378f, -0.10663864f, -0.01401423f, 
    -0.00653689f, 0.20309938f, 0.00383430f, -0.10859234f, -0.15194103f, -0.07451293f, 0.05556588f, -0.05437987f, 
    -0.01711717f, -0.12685496f, -0.07284973f, -0.05919341f, -0.00649212f, 0.06138077f, 0.08414616f, -0.09671816f, 
    0.14894541f, 0.08581465f, 0.28103217f, -0.27715623f, 0.02425547f, 0.04655678f, 0.00639988f, 0.01590718f, 
    -0.03396095f, -0.10689940f, 0.07109911f, -0.08935316f, -0.09278867f, -0.55920374f, 0.09833895f, -0.10092013f, 
    -0.01489533f, -0.05673186f, 0.15279226f, 0.17435551f, -0.15478992f, -0.04165520f, -0.05129781f, 0.02414927f, 
    0.24866557f, -0.33994153f, 0.06337037f, 0.16988462f, 0.01433342f, -0.12775789f, 0.09437192f, 0.06268753f, 
    0.01553657f, 0.12908165f, 0.05224857f, 0.01071809f, 0.24624872f, 0.11791845f, -0.09011857f, 0.18182017f, 
    -0.26744309f, -0.18079849f, 0.04620578f, 0.08248693f, -0.10459441f, -0.02488559f, -0.04328866f, -0.03891309f, 
    0.22649787f, -0.02770256f, -0.00835560f, 0.29672992f, -0.06077769f, -0.10588886f, 0.05283250f, 0.04955908f, 
    0.07709031f, -0.11927999f, -0.09137361f, 0.05912384f, 0.12766583f, 0.21637075f, 0.19029580f, -0.12822090f, 
    -0.04763978f, 0.00206288f, -0.00276390f, 0.08842263f, 0.04748560f, 0.01574862f, 0.02475410f, 0.11869760f, 
    -0.32590011f, 0.06656036f, 0.11306491f, -0.00464504f, 0.12129430f, -0.07628792f, 0.00550028f, -0.01194926f, 
    -0.02680351f, 0.07764748f, -0.16298622f, 0.06676836f, 0.13697860f, 0.09217684f, -0.19831374f, -0.00423864f, 
    -0.14478980f, -0.01867645f, 0.06968191f, 0.00649968f, 0.06245953f, -0.10705683f, -0.04278554f, -0.00226000f, 
    0.04703937f, -0.22864659f, 0.17260338f, -0.13399148f, 0.01694434f, -0.06475016f, -0.03098464f, -0.02892653f, 
    -0.02596659f, -0.17512934f, 0.00052072f, 0.04414532f, 0.10200386f, -0.00115569f, 0.13937967f, 0.19606972f, 
    -0.00215732f, 0.09270621f, -0.06429499f, 0.14480951f, 0.09730757f, 0.23571314f, 0.02988457f, -0.22325367f, 
    0.36112696f, 0.09154568f, 0.15048721f, 0.31531918f, 0.04749835f, 0.14254257f, -0.04916118f, -0.01732420f, 
    0.10569359f, -0.09550660f, -0.02058129f, -0.14185633f, 0.21809858f, -0.19102128f, -0.03833394f, 0.03881468f, 
    -0.02937999f, 0.09919354f, -0.05736095f, 0.09674438f, -0.23040195f, 0.20089468f, -0.16438361f, -0.13234720f, 
    0.23463783f, -0.18428744f, -0.08334499f, -0.01155114f, -0.08081243f, 0.05801061f, -0.08304076f, -0.02125030f, 
    0.09264054f, 0.06559400f, 0.04288051f, 0.11747530f, 0.14484079f, 0.14068650f, -0.23394734f, 0.04819661f, 
    0.17105544f, -0.05246979f, -0.07194595f, -0.01819227f, 0.07743732f, 0.11565904f, 0.09316913f, 0.02916816f, 
    0.30799034f, -0.41280183f, -0.00180644f, 0.17765644f, -0.18667421f, 0.11471148f, 0.00735354f, 0.12897559f, 
    0.12277344f, -0.09558006f, 0.05902294f, 0.14275713f, -0.20751996f, -0.05978565f, -0.12264432f, 0.08673920f, 
    -0.02752076f, 0.04399953f, -0.06339484f, -0.06633202f, -0.09038530f, 0.04477688f, -0.05488117f, -0.02410478f, 
    -0.12488666f, 0.00703167f, -0.45589256f, -0.22682764f, 0.03091806f, 0.08419275f, -0.24902104f, -0.04063972f, 
    -0.12267872f, -0.01155762f, 0.04777973f, -0.00769033f, 0.00348246f, -0.07398343f, -0.14954112f, 0.18287165f, 
    -0.20443474f, 0.06292223f, 0.00091683f, -0.10344830f, 0.14607090f, -0.00977187f, -0.26110691f, 0.05758889f, 
    0.00022123f, -0.26463690f, -0.44190517f, 0.03178791f, -0.03371193f, 0.12893228f, 0.03345943f, 0.11124019f, 
    -0.01398663f, -0.02115042f, 0.00507049f, -0.07670417f, 0.35898334f, -0.04286058f, 0.05258589f, -0.21320847f, 
    -0.19878457f, -0.02815808f, -0.08495315f, -0.07959077f, -0.26493949f, 0.03835566f, -0.20784268f, 0.09190989f, 
    0.27406403f, -0.46106544f, 0.11261547f, -0.29715335f, 0.08345033f, 0.03589343f, -0.07421014f, 0.06632614f, 
    -0.03010168f, -0.15821074f, 0.06339961f, 0.02414949f, 0.02561343f, -0.39566827f, -0.02728478f, 0.01736116f, 
    -0.03482291f, 0.12088335f, -0.01101113f, 0.06385661f, 0.26423168f, -0.04761735f, -0.51964688f, -0.22643603f, 
    -0.06982119f, -0.06256941f, -0.21184678f, -0.24410355f, -0.04201354f, -0.02356908f, -0.07612587f, 0.04396598f, 
    0.29246077f, 0.26006064f, 0.11817918f, -0.09706287f, 0.20281021f, 0.07966601f, 0.34771457f, 0.15898624f, 
    -0.26106510f, -0.02075906f, -0.03495883f, -0.04897647f, -0.00217539f, -0.11053001f, 0.12817852f, -0.02228503f, 
    0.41642663f, -0.03918378f, -0.05771342f, -0.41427159f, 0.03203034f, 0.10850305f, 0.02640253f, 0.16660814f, 
    0.08988340f, -0.03204806f, 0.15619507f, 0.02233745f, -0.24196775f, 0.04709721f, -0.27652395f, -0.13476856f, 
    -0.05988369f, -0.06024193f, 0.07723614f, 0.07698926f, 0.01613084f, 0.13388182f, -0.10280944f, -0.19749564f, 
    0.08492734f, 0.05593992f, -0.09725749f, 0.21127672f, 0.12176500f, 0.10242927f, -0.13160209f, 0.02950371f, 
    -0.09502576f, 0.15372521f, 0.17778721f, 0.01356457f, -0.31117842f, -0.12132942f, -0.54059297f, -0.13688403f, 
    -0.17750083f, -0.04587621f, 0.03772876f, -0.06208158f, -0.10509683f, -0.19045429f, -0.14190899f, -0.09952728f, 
    0.49578592f, -0.31945536f, -0.01833943f, -0.14072894f, 0.02611033f, 0.02546307f, -0.05697619f, 0.06409635f, 
    -0.14952849f, -0.10720325f, -0.00785935f, -0.23495708f, -0.66700369f, -0.27919418f, -0.35107186f, -0.07727046f, 
    -0.15635833f, -0.14021230f, -0.11806845f, -0.06499224f, 0.08635876f, -0.03453454f, 0.05305176f, 0.07351296f, 
    -0.00028587f, -0.12417977f, 0.14017239f, 0.25651193f, -0.08032774f, -0.08022843f, -0.07852019f, 0.17228703f, 
    0.02152330f, -0.09411056f, -0.04218293f, 0.21070366f, 0.00775239f, -0.10405749f, -0.38241914f, -0.28048781f, 
    -0.05042795f, -0.07700804f, 0.13536032f, -0.13340268f, -0.02692736f, -0.08811282f, 0.02063225f, 0.13811235f, 
    -0.56747591f, 0.03196182f, -0.18425195f, -0.18512760f, -0.06385279f, 0.20266621f, 0.02254780f, -0.09705744f, 
    -0.00741584f, 0.10477123f, -0.09091702f, 0.11814553f, 0.13741781f, -0.04162844f, 0.27480668f, -0.15652323f, 
    -0.01368410f, 0.05022438f, 0.28702444f, 0.09838408f, -0.10463662f, -0.05915918f, 0.12889378f, 0.10187117f, 
    0.57000029f, -0.30750942f, 0.05021524f, -0.03543932f, -0.17769587f, 0.10793632f, -0.30999446f, 0.03399761f, 
    -0.13355047f, 0.22221546f, 0.09995838f, -0.18416919f, 0.17470163f, -0.06962878f, 0.22576141f, 0.15374246f, 
    -0.15986027f, 0.02325584f, 0.15697700f, 0.00284317f, 0.05601906f, 0.00680169f, 0.06770057f, 0.03539405f, 
    -0.10906471f, 0.01801596f, 0.02251312f, -0.01122323f, 0.33532348f, 0.10277725f, 0.12772591f, -0.09490287f, 
    -0.08325814f, 0.03112290f, 0.03022467f, 0.02789761f, -0.53482634f, -0.02752064f, -0.14079313f, -0.02193861f, 
    -0.01952343f, 0.03497490f, -0.07682135f, 0.12787180f, -0.03319436f, -0.03775001f, 0.01380679f, -0.20509259f, 
    0.17151479f, -0.02084525f, -0.40034649f, -0.19429952f, 0.15311675f, 0.00947225f, -0.03948710f, -0.14287595f, 
    -0.04255429f, -0.18218336f, -0.11311343f, -0.14383966f, 0.01833003f, 0.13102840f, -0.15118922f, -0.18545848f, 
    0.02411884f, 0.07547712f, 0.03004489f, -0.09027444f, -0.10734960f, -0.08069935f, -0.04808722f, -0.00249849f, 
    -0.04245416f, 0.15788031f, 0.10298447f, 0.13377328f, 0.00830125f, -0.12347858f, 0.06115360f, 0.00120404f, 
    -0.01062146f, 0.05407297f, -0.01876680f, -0.05149437f, 0.36981577f, -0.30839089f, -0.05155791f, 0.11449235f, 
    -0.04187099f, -0.10024613f, 0.02163787f, -0.00158190f, 0.08383755f, -0.08042135f, -0.07676088f, 0.14069213f, 
    0.05657556f, 0.11553419f, -0.10079467f, -0.00251602f, -0.04333426f, 0.00734880f, 0.15837272f, 0.15058634f, 
    -0.15055633f, 0.12467160f, 0.05410527f, -0.05740746f, 0.19559132f, 0.21381792f, 0.16876042f, 0.13326083f, 
    -0.20956717f, -0.13133298f, 0.06560013f, 0.06783108f, -0.00299825f, -0.08168833f, -0.03822224f, 0.00596173f, 
    0.16614270f, -0.35167202f, 0.08889619f, -0.07565384f, 0.05954115f, 0.00090245f, 0.04425670f, -0.15919431f, 
    -0.13790900f, -0.10523012f, -0.00346769f, -0.07861589f, 0.20323102f, 0.07853196f, 0.14486066f, 0.24730508f, 
    -0.18185723f, -0.16633353f, 0.00739202f, 0.13616729f, 0.10127414f, 0.00015178f, -0.07675864f, 0.04833660f, 
    0.78259408f, -0.32092422f, 0.19406815f, -0.06902438f, 0.03434356f, 0.17688680f, -0.08444354f, 0.03170810f, 
    0.01464154f, -0.10313556f, 0.04800749f, -0.04800784f, 0.42308930f, 0.06319986f, -0.35820326f, -0.14673895f, 
    -0.26866549f, 0.08138540f, 0.01591013f, 0.02063088f, -0.08585261f, 0.01804440f, 0.03471716f, -0.10491516f, 
    0.26992849f, -0.10909389f, -0.40714785f, 0.01368037f, 0.08672825f, 0.06647750f, -0.32024589f, -0.06597427f, 
    -0.12871802f, -0.01629976f, -0.08765541f, 0.01221406f, 0.14793251f, -0.12136472f, 0.02994449f, 0.17631145f, 
    -0.24596417f, -0.02326388f, 0.03116311f, -0.09248867f, 0.07598784f, -0.03131744f, 0.15792996f, 0.04738266f, 
    0.24506991f, -0.19188058f, -0.28896594f, -0.02578579f, 0.04444185f, 0.04462713f, -0.33856440f, -0.08298327f, 
    0.00088447f, 0.07286557f, 0.15200618f, 0.01472142f, 0.10743779f, -0.15502580f, 0.13276529f, 0.05481089f, 
    -0.11926734f, -0.17593224f, 0.01472945f, 0.23419107f, 0.04409741f, -0.07998662f, 0.02074244f, -0.20173016f, 
    -0.07189185f, 0.06828223f, 0.27528861f, -0.00515180f, 0.05982226f, -0.29945001f, 0.02631872f, 0.00469939f, 
    -0.16780917f, -0.08378396f, 0.05309717f, 0.02115753f, -0.24887992f, -0.04654983f, -0.22958629f, -0.07269944f, 
    -0.01130490f, -0.12056651f, 0.09280204f, 0.10210083f, 0.11697414f, 0.13416280f, 0.01580385f, 0.02501718f, 
    0.05568541f, 0.16461058f, -0.10755180f, -0.26698595f, -0.08045476f, 0.10391983f, 0.15390404f, -0.01757371f, 
    -0.11955804f, -0.07127739f, -0.03938896f, -0.03729110f, 0.16756502f, -0.06070454f, -0.04224315f, 0.19031543f, 
    -0.01045769f, 0.03828343f, 0.02162932f, -0.11086052f, -0.07041769f, 0.00316089f, -0.12258363f, 0.00524999f, 
    0.00189710f, 0.08179520f, 0.10601649f, 0.21403679f, -0.19646157f, 0.02935412f, -0.12553433f, 0.07048588f, 
    -0.07584023f, -0.02312740f, -0.17682254f, -0.03911763f, 0.27931666f, -0.00888885f, 0.05199892f, 0.10359685f, 
    -0.11409799f, -0.13029407f, -0.04018392f, -0.07055422f, -0.09678067f, -0.13600099f, 0.09790231f, -0.02687027f, 
    -0.10463994f, -0.12492492f, -0.00343197f, 0.05125160f, -0.08637794f, 0.04365021f, -0.05153633f, -0.18455447f, 
    0.09271683f, -0.14151779f, 0.13275172f, 0.05691345f, 0.18126389f, 0.25207084f, -0.40940264f, -0.32102215f, 
    -0.08236717f, 0.15489072f, 0.01929371f, -0.15095890f, 0.08089450f, 0.02885415f, -0.00003963f, -0.01793393f, 
    0.43350250f, 0.03068762f, -0.02868708f, 0.08690599f, -0.11608701f, -0.06950350f, 0.13197961f, -0.09339111f, 
    -0.04944681f, 0.06108420f, -0.13354351f, -0.20681112f, 0.62985826f, -0.33254603f, -0.14015539f, -0.40092692f, 
    0.00169880f, -0.09786142f, 0.05279728f, 0.06194226f, 0.03893257f, 0.02489031f, 0.12656869f, -0.15474626f, 
    0.02132972f, -0.01637252f, -0.13570240f, -0.05643060f, 0.01835681f, -0.06499839f, 0.13952760f, 0.04543480f, 
    -0.14270662f, 0.09891482f, 0.03259605f, 0.03575180f, -0.34814304f, -0.33772939f, 0.06675513f, -0.11534727f, 
    0.01991486f, -0.00908908f, -0.10109543f, 0.17566338f, 0.11734576f, 0.00777507f, -0.11570050f, -0.14187871f, 
    0.27536732f, -0.04618057f, -0.11307108f, 0.10941672f, -0.06833915f, -0.12623103f, -0.01321645f, 0.14262933f, 
    -0.07245947f, 0.00795615f, -0.11464582f, -0.09401332f, 0.06343582f, -0.47735813f, -0.12833436f, -0.09941166f, 
    -0.09758995f, -0.14590052f, -0.10889003f, -0.00521902f, 0.04250662f, -0.00763873f, -0.08818445f, -0.06413791f, 
    -0.22938831f, -0.08284424f, 0.10958053f, -0.09081258f, 0.09232336f, -0.11831305f, 0.16184318f, 0.11450171f, 
    -0.00962891f, -0.11970596f, 0.00546906f, 0.06613388f, -0.04350422f, 0.03888499f, -0.23629513f, 0.25535354f, 
    0.15669437f, 0.05376054f, -0.09390484f, -0.10317448f, 0.05656927f, 0.08188204f, -0.08902619f, -0.01505369f, 
    -0.84137523f, -0.59530294f, -0.49618372f, -0.12984730f, -0.07791970f, 0.00067504f, -0.00467435f, -0.17370215f, 
    -0.01196670f, -0.05621136f, -0.09370941f, 0.11599287f, 0.29917046f, 0.01052898f, -0.21327837f, 0.04075445f, 
    -0.01615904f, 0.22941160f, 0.03128050f, 0.09018569f, 0.02866495f, 0.05132398f, 0.04798626f, -0.10286789f, 
    -0.01203725f, 0.29677814f, 0.17974734f, 0.38982812f, 0.13657412f, 0.16058177f, 0.04478608f, 0.02217595f, 
    -0.02318401f, -0.11491221f, 0.08909674f, -0.20461830f, -0.65716881f, 0.13507120f, -0.09271439f, 0.22155306f, 
    -0.03773702f, 0.13716535f, 0.00823053f, 0.02781916f, 0.04962659f, 0.04256515f, 0.03179026f, 0.00321760f, 
    -0.21783687f, -0.17113237f, -0.06825241f, 0.02719317f, 0.01592392f, 0.10306582f, 0.12259710f, 0.16798979f, 
    -0.15794860f, 0.02135386f, 0.04142786f, -0.10137182f, -0.40293360f, 0.12177350f, 0.21646650f, 0.06590337f, 
    0.06444327f, 0.12388396f, 0.04297132f, 0.06135376f, -0.01719601f, 0.00834069f, -0.09835357f, 0.03709664f, 
    -0.20651340f, -0.41816723f, -0.28944084f, -0.12436952f, -0.11006403f, -0.10919149f, 0.03284021f, -0.03051993f, 
    -0.05274658f, 0.18522987f, 0.15051800f, 0.08062468f, 0.07925683f, 0.09132089f, -0.29079685f, -0.15879180f, 
    0.08080903f, -0.07756728f, -0.07696667f, -0.16940995f, -0.00190249f, -0.09765466f, 0.31538653f, -0.08184360f, 
    0.25508958f, 0.16773362f, -0.01880838f, 0.01604992f, -0.04220673f, -0.00232198f, 0.09331446f, -0.12888207f, 
    0.04980706f, 0.07411411f, -0.12150632f, -0.07243928f, 0.22338457f, -0.06841707f, -0.17191085f, -0.18035173f, 
    -0.03630872f, -0.15370816f, -0.01436011f, 0.09807815f, 0.02547907f, 0.05103254f, 0.03962500f, -0.15916087f, 
    -0.00137228f, 0.06898724f, 0.11683504f, 0.15504795f, 0.04326959f, 0.17121686f, 0.10877109f, -0.08791620f, 
    0.01885089f, 0.20645040f, -0.09452820f, -0.03847203f, -0.49134353f, 0.25617826f, 0.28951856f, -0.18283065f, 
    0.04876290f, 0.05411775f, 0.13548088f, 0.16193569f, 0.00780453f, 0.06276571f, 0.02626446f, 0.17687301f, 
    -0.29620907f, 0.42178214f, 0.32182807f, -0.20371719f, 0.21518348f, 0.12576377f, 0.08283964f, 0.12855472f, 
    -0.08036263f, -0.02105731f, -0.28939804f, -0.13315117f, -0.09462069f, 0.14358681f, 0.10827845f, -0.22372326f, 
    -0.06602684f, -0.08350731f, 0.00032776f, 0.02614963f, 0.01196224f, -0.12885711f, 0.08784216f, -0.04958734f, 
    -0.26275012f, 0.25114506f, -0.12954409f, 0.07216144f, 0.13826720f, -0.12382802f, 0.07903354f, 0.05950189f, 
    -0.00478491f, -0.04133919f, 0.07040893f, -0.08029973f, -0.37963933f, -0.16442668f, -0.25833043f, -0.12765758f, 
    -0.06848545f, 0.14030771f, -0.02463479f, 0.12859491f, 0.00162980f, -0.08132555f, -0.02713918f, 0.03340459f, 
    -0.17229247f, -0.17539373f, -0.04724536f, 0.09274057f, -0.13551261f, 0.01089039f, 0.00931347f, -0.00144051f, 
    -0.02887390f, -0.00831513f, 0.01878729f, 0.08487681f, -0.07148467f, -0.07048559f, 0.13216956f, 0.15051661f, 
    -0.01620897f, -0.03308157f, 0.04559341f, -0.10943449f, -0.11571769f, 0.25439268f, 0.06264278f, 0.08292742f, 
    -0.36240378f, 0.07585178f, 0.01647106f, 0.05758610f, -0.02420194f, 0.09520711f, 0.07150622f, 0.01520708f, 
    -0.07993649f, 0.01455742f, -0.11771239f, -0.14786378f, -0.02486440f, -0.62759697f, -0.28707254f, 0.28008893f, 
    0.00841845f, -0.06066627f, 0.02532239f, 0.02755273f, 0.12258742f, 0.01641673f, -0.07780275f, 0.04112692f, 
    -0.32747671f, 0.27127734f, -0.11097655f, -0.30216005f, -0.14166303f, -0.13921785f, 0.06835759f, -0.03582643f, 
    0.03120440f, -0.14458610f, -0.10168272f, -0.01991617f, -0.15215513f, 0.10710109f, 0.00529810f, -0.23450908f, 
    -0.20223159f, -0.13719961f, 0.04500578f, 0.02602757f, -0.05713372f, -0.09057485f, -0.00616764f, 0.17980275f, 
    -0.42265597f, 0.17904817f, -0.02180378f, -0.05164475f, -0.22777677f, -0.05005538f, 0.10739379f, -0.00681541f, 
    -0.01817120f, -0.04835013f, -0.16336814f, -0.08766153f, -0.11481819f, 0.50500733f, 0.27863705f, -0.06386784f, 
    0.09073327f, 0.18108590f, -0.06612577f, 0.07878843f, 0.01399325f, 0.10950869f, -0.10236512f, 0.19915602f, 
    0.12720867f, 0.10054651f, 0.03790184f, 0.06289782f, 0.08198808f, -0.08970668f, -0.00096457f, 0.00863231f, 
    0.01775294f, 0.14109083f, -0.03169348f, 0.13368107f, -0.11713541f, 0.35828525f, 0.18671058f, -0.10056403f, 
    0.04939596f, -0.01650527f, 0.01235194f, 0.22502111f, -0.14721847f, -0.14551859f, 0.01408836f, -0.04313774f, 
    0.15451007f, -0.03261711f, -0.11477447f, -0.16828918f, -0.14402986f, -0.00780761f, 0.02657369f, 0.12712486f, 
    -0.03311893f, -0.00077656f, 0.01496984f, 0.01259985f, 0.00431989f, 0.17581147f, 0.19091225f, -0.06613908f, 
    -0.03087735f, 0.13002840f, -0.14817998f, 0.09929188f, 0.11506812f, -0.00663200f, -0.00037198f, 0.06843211f, 
    -0.31135166f, 0.01192692f, 0.19177306f, -0.08682375f, 0.01325367f, -0.21575381f, -0.01901449f, -0.05212667f, 
    0.10237913f, -0.10404487f, -0.03742555f, -0.14573246f, 0.07990661f, 0.18819648f, 0.04782506f, 0.12893383f, 
    -0.04289200f, -0.12854049f, -0.04620603f, 0.00973506f, 0.01722841f, 0.07387625f, -0.00727484f, 0.00468132f, 
    -0.14797153f, -0.09554429f, -0.35437503f, -0.09251001f, -0.12272823f, -0.11868192f, 0.11389735f, 0.05542875f, 
    -0.06368589f, -0.12817122f, 0.03398240f, 0.00740418f, -0.27965170f, -0.44131300f, -0.09520657f, 0.31326404f, 
    0.03824770f, 0.06662475f, 0.10962073f, -0.07213090f, -0.03101609f, -0.18671452f, -0.05154521f, -0.04299010f, 
    0.36638746f, -0.32179958f, -0.18086356f, 0.10954393f, -0.10535844f, -0.10539635f, 0.00625750f, 0.03614484f, 
    0.00383803f, 0.20791201f, -0.05856774f, 0.00731491f, -0.43731830f, 0.27684334f, 0.14069122f, -0.13347033f, 
    -0.01430027f, -0.06295080f, 0.05507457f, -0.12912910f, -0.10806708f, -0.10288083f, -0.06596069f, -0.04042661f, 
    -0.06665575f, -0.03205179f, 0.12240185f, 0.09927183f, -0.07742315f, -0.02110928f, -0.01508629f, -0.10852408f, 
    0.15064947f, -0.14974292f, 0.09737407f, -0.08483321f, -0.57703555f, -0.13798600f, 0.12656909f, 0.01844893f, 
    -0.17018348f, -0.01016734f, 0.09781419f, 0.01987027f, 0.10667576f, 0.15112154f, 0.00911910f, -0.13044383f, 
    -0.44287840f, -0.28884628f, 0.20243202f, 0.20457041f, -0.01963692f, 0.02761291f, 0.01735679f, 0.14304009f, 
    -0.00025888f, 0.05170476f, -0.01836707f, 0.07127269f, -0.46347234f, 0.27791557f, -0.05662888f, -0.18609099f, 
    -0.05956497f, -0.31520301f, -0.07213900f, 0.15114324f, 0.00057167f, -0.06512082f, 0.08689118f, 0.01368906f, 
    -0.24078831f, 0.17157651f, 0.25109318f, 0.07610724f, -0.04356642f, 0.00166373f, 0.16214919f, 0.06643006f, 
    0.00407247f, 0.01917174f, 0.18589601f, 0.09145815f, -0.15226911f, 0.35536328f, -0.11332815f, 0.04417410f, 
    0.17800094f, 0.00813957f, 0.01248575f, 0.10755768f, 0.00353577f, -0.21121760f, 0.07474641f, -0.00479210f, 
    0.04723410f, -0.09811972f, 0.01012923f, 0.01100038f, -0.06820534f, -0.02320764f, 0.01244045f, -0.12218270f, 
    0.02884317f, -0.02740052f, -0.03990488f, -0.14273737f, -0.81580544f, -0.13316904f, 0.01448901f, 0.17908341f, 
    -0.06736786f, 0.01193911f, 0.01124561f, 0.00871558f, 0.07833686f, 0.03626875f, 0.01201116f, 0.13097377f, 
    -0.64436549f, 0.29916325f, -0.00070128f, -0.09859018f, 0.10862967f, -0.07104390f, -0.10189852f, -0.11063653f, 
    -0.00342448f, -0.11137291f, -0.16134998f, 0.04783443f, 0.15363750f, -0.26089558f, -0.26016656f, -0.22634713f, 
    0.05414631f, -0.03405596f, -0.07083610f, 0.12687624f, -0.14266230f, -0.04893301f, -0.14899176f, -0.09740750f, 
    -0.39529851f, 0.07005049f, 0.07502878f, -0.02968484f, 0.04346234f, 0.01490619f, 0.04959174f, -0.13849033f, 
    0.00856072f, -0.08849806f, 0.03935676f, -0.08755918f, -0.50384581f, 0.25675458f, -0.00000855f, 0.11097743f, 
    0.01958705f, 0.16283481f, 0.00067428f, 0.07037078f, -0.17480817f, 0.10425260f, 0.14136426f, -0.07642838f, 
    -0.20046809f, -0.07234546f, 0.27573133f, 0.05508153f, 0.01093672f, 0.19648327f, -0.14576341f, -0.16969967f, 
    0.09429602f, 0.13706784f, -0.09485010f, -0.02288043f, -0.08249439f, -0.09125577f, 0.08624154f, -0.02478464f, 
    -0.04209488f, 0.05905750f, -0.01098280f, -0.07763994f, 0.02365206f, 0.12064300f, 0.11595441f, -0.08069275f, 
    -0.51921672f, -0.20599011f, 0.09066218f, 0.21039714f, 0.21964662f, -0.21599345f, 0.04681017f, -0.03109719f, 
    -0.08373334f, -0.03022829f, 0.00412000f, 0.01449009f, 0.26530486f, -0.10197072f, 0.14512052f, -0.12491957f, 
    -0.10405426f, -0.02750799f, 0.01207012f, -0.00907152f, -0.08993620f, -0.07799529f, 0.25885665f, 0.21822917f, 
    -0.25976512f, -0.35556462f, 0.14290771f, 0.01617170f, 0.00580360f, 0.02779129f, 0.00091066f, -0.00953430f, 
    0.12827088f, -0.15924689f, -0.12597601f, -0.08536700f, -0.17016487f, 0.13519637f, -0.14118248f, -0.12828518f, 
    0.02752251f, 0.09277316f, -0.01655000f, 0.18566880f, 0.03513646f, -0.10158853f, -0.05973873f, 0.08287206f, 
    -0.01712125f, -0.04420615f, -0.23017682f, 0.24234268f, 0.09878904f, 0.03121323f, 0.03405230f, -0.02183271f, 
    -0.03775879f, -0.06696619f, 0.12224459f, 0.06609380f, -0.12727292f, 0.06271490f, 0.20760374f, 0.10801344f, 
    0.16873579f, -0.12214273f, -0.12615357f, 0.13591190f, 0.00683367f, 0.01088040f, -0.16182299f, 0.09990866f, 
    0.14809625f, 0.05325866f, -0.20647566f, 0.09285502f, -0.06444842f, 0.22025138f, 0.22917227f, -0.16071746f, 
    -0.03481213f, 0.01306580f, -0.05273198f, -0.13705470f, 0.04425081f, -0.21467459f, 0.20940030f, -0.31799605f, 
    -0.00295025f, 0.05335982f, 0.05074469f, -0.03348361f, -0.14859314f, -0.00076752f, -0.00686537f, 0.13288224f, 
    -0.30865499f, 0.07492877f, 0.05979327f, -0.07836625f, 0.02977979f, 0.06800742f, 0.06013801f, 0.11107061f, 
    0.05165998f, 0.14773063f, 0.08264459f, 0.01703889f, -0.25552344f, 0.15102005f, -0.05627648f, -0.27540338f, 
    -0.03459571f, 0.02320812f, -0.11802292f, -0.01526114f, 0.03110218f, 0.02127022f, -0.21742451f, 0.01717988f, 
    0.60267806f, -0.12096943f, -0.44228348f, -0.02002304f, 0.19098200f, -0.11732710f, -0.03900189f, -0.08910661f, 
    -0.06390624f, 0.06609401f, 0.03782925f, -0.06461211f, 0.13027763f, -0.12473541f, 0.10491958f, 0.18564108f, 
    -0.04391385f, -0.07553612f, 0.01324543f, 0.14148964f, 0.00132377f, -0.10309497f, 0.09671123f, 0.08884413f, 
    0.50079250f, 0.34093449f, -0.29457918f, -0.06496854f, -0.02465642f, -0.09316197f, 0.21021838f, 0.01721937f, 
    -0.19864507f, -0.01079046f, 0.01564686f, 0.11424197f, 0.07197910f, 0.08614645f, 0.04453006f, 0.31182426f, 
    0.12798928f, -0.02709001f, 0.03124321f, 0.12820850f, 0.19893238f, -0.01925474f, 0.09557125f, -0.08708040f, 
    -0.18268567f, 0.18476874f, 0.13585366f, 0.06727777f, -0.10090517f, -0.06981630f, -0.00393832f, 0.00790952f, 
    0.07859107f, -0.12367558f, -0.11778567f, 0.00215838f, -0.29306099f, 0.21012437f, 0.34053731f, 0.18717061f, 
    -0.01845068f, 0.06957237f, -0.10484973f, -0.00346213f, 0.03467475f, -0.06421394f, -0.04660483f, -0.05395196f, 
    0.13784063f, 0.10107499f, 0.34602621f, -0.09492976f, 0.07531696f, 0.03810241f, 0.00800829f, -0.08907824f, 
    0.05652093f, -0.17825460f, 0.07466364f, 0.06725652f, -0.36193100f, -0.18740252f, -0.20113854f, 0.14287409f, 
    0.03768943f, -0.12416562f, -0.01006926f, -0.14839220f, 0.25566378f, 0.10424120f, -0.09466232f, 0.11508601f, 
    0.16593508f, 0.03209776f, -0.02006608f, -0.11297599f, -0.10225074f, 0.07472855f, 0.10542774f, -0.05144914f, 
    -0.15123869f, 0.07114714f, 0.11617968f, 0.25647449f, 0.18523915f, -0.11958744f, -0.09394019f, -0.07972312f, 
    -0.11547509f, -0.02491053f, -0.09989379f, 0.11641597f, -0.09323435f, -0.01353991f, -0.01771793f, -0.03320634f, 
    0.36397350f, -0.24905679f, -0.37132797f, -0.05522808f, -0.01248060f, -0.10946044f, 0.06875885f, 0.04554611f, 
    0.08118717f, -0.02088864f, -0.08419976f, -0.18379663f, -0.04159951f, 0.15567754f, 0.00419795f, -0.32358390f, 
    -0.09602417f, 0.09551984f, 0.06422744f, -0.04566948f, 0.01683959f, -0.07783576f, 0.08303801f, -0.03473696f, 
    0.23472591f, -0.00440989f, 0.09129065f, -0.20151618f, -0.09281265f, -0.09133080f, -0.24659146f, 0.03973769f, 
    -0.10831963f, 0.06331696f, 0.06491686f, -0.13354768f, -0.48966756f, -0.10361066f, -0.20571904f, -0.16979344f, 
    0.09197261f, 0.00134557f, -0.12282671f, -0.03349629f, 0.05860990f, 0.08113578f, -0.00218877f, 0.24876185f, 
    -0.00320552f, -0.07483886f, 0.04797895f, -0.31491509f, -0.17532979f, 0.08888368f, -0.01158444f, 0.11131203f, 
    -0.05076982f, -0.02257637f, 0.09433054f, 0.25817788f, -0.35935199f, 0.12834306f, -0.24182269f, -0.26046667f, 
    0.04021338f, 0.10739145f, 0.00429299f, -0.31108299f, -0.07694725f, -0.09037874f, -0.11486714f, -0.06049911f, 
    -0.82661653f, -0.00541331f, 0.03613811f, -0.25191823f, 0.15279745f, -0.12810838f, 0.01362570f, 0.04883645f, 
    -0.07851664f, -0.03578847f, 0.09112153f, 0.02109823f, -0.26435024f, 0.05833267f, -0.11628236f, -0.05485595f, 
    -0.01611858f, -0.22425458f, -0.02529506f, 0.01130371f, 0.02746044f, -0.04148675f, -0.02940610f, 0.05330992f, 
    0.13839191f, -0.20692953f, 0.15272355f, -0.11605753f, -0.01456720f, -0.07229273f, 0.01010193f, 0.00540142f, 
    0.02966474f, -0.02134869f, 0.05752147f, 0.18932298f, -0.15053709f, 0.15990686f, -0.23819895f, -0.25212416f, 
    0.25073934f, -0.04827129f, 0.19110249f, -0.01830177f, -0.13959843f, -0.05631826f, -0.15114224f, -0.10983475f, 
    0.17609878f, 0.16326360f, 0.41857961f, -0.05785860f, -0.05811259f, 0.00455165f, 0.10297085f, 0.27671856f, 
    -0.01316481f, -0.06520215f, -0.05592072f, -0.12939008f, 0.22690745f, -0.07364123f, -0.08959029f, -0.12269747f, 
    0.12757312f, -0.16702917f, -0.01271499f, -0.15952328f, 0.04619977f, 0.09767415f, -0.15382193f, 0.03896172f, 
    0.24475500f, 0.02070191f, -0.05155379f, -0.03890377f, -0.19766058f, 0.18243311f, 0.07655317f, -0.02118241f, 
    0.04657624f, -0.10078193f, -0.02044984f, -0.01790266f, -0.06661487f, 0.16844662f, -0.01709484f, -0.01931974f, 
    -0.00252218f, 0.18738867f, 0.10018203f, 0.01393586f, 0.10167301f, -0.02782698f, -0.26575345f, -0.07784472f, 
    0.03940391f, 0.17674220f, 0.14046617f, 0.23660229f, -0.20555654f, -0.15011249f, 0.11467637f, 0.04664685f, 
    -0.21497330f, -0.03343747f, 0.18939036f, 0.26108316f, 0.02349011f, -0.12162735f, 0.26810199f, 0.19120580f, 
    0.23315358f, 0.10054271f, 0.02822079f, 0.05608129f, 0.04941032f, 0.04679099f, 0.07134563f, 0.14238341f, 
    -0.42458060f, 0.09717673f, 0.07346724f, -0.04863448f, 0.09450626f, -0.00418086f, -0.11434740f, -0.35595790f, 
    -0.01983168f, -0.06749044f, -0.13388994f, 0.11495154f, -0.44526723f, -0.32681596f, -0.25655439f, 0.00604395f, 
    0.05835030f, 0.17488205f, 0.09338477f, -0.00328967f, 0.12877977f, -0.02242552f, 0.23059666f, -0.09990000f, 
    0.00139339f, 0.20138437f, 0.29058424f, -0.25509319f, 0.05749913f, -0.16562136f, 0.05196859f, 0.17943458f, 
    0.08779406f, 0.05531383f, 0.07213769f, -0.20900151f, -0.26251173f, -0.00306863f, -0.01161187f, 0.35791653f, 
    -0.00789268f, -0.11970502f, -0.04121102f, 0.16161381f, 0.07983822f, 0.21588379f, -0.20943272f, -0.10093226f, 
    -0.31733841f, -0.23901638f, -0.09216642f, 0.00952148f, -0.08946623f, -0.04892514f, -0.12154786f, -0.01669258f, 
    0.18462563f, -0.20156009f, -0.12258225f, 0.07235863f, -0.61801612f, -0.14846979f, 0.01097792f, 0.23655663f, 
    0.09794776f, 0.02463152f, 0.09015083f, -0.07093269f, 0.10697685f, -0.06176473f, 0.09411349f, -0.12647770f, 
    0.12224914f, 0.27161881f, 0.23272195f, -0.13825177f, 0.13384753f, 0.16467749f, 0.04774851f, -0.31386799f, 
    0.07557722f, 0.09266566f, -0.05918662f, -0.00273052f, -0.13957433f, -0.00394379f, -0.07266181f, 0.09115673f, 
    0.11548448f, -0.04901802f, 0.08081080f, 0.09548739f, -0.17501147f, 0.09031405f, -0.04908632f, -0.13841204f, 
    0.02083804f, -0.16988446f, 0.26967052f, 0.16901977f, 0.12012228f, -0.14554693f, 0.00171834f, -0.19320245f, 
    0.23211703f, -0.14971855f, -0.10614167f, 0.01148574f, -0.31777120f, -0.11260470f, -0.23426741f, 0.04359944f, 
    0.13998263f, 0.25351873f, -0.10654941f, -0.04185835f, 0.08697990f, 0.00097336f, 0.16264781f, 0.09850603f, 
    -0.05966819f, 0.13865694f, -0.05964216f, 0.00871032f, -0.06727060f, 0.03689098f, 0.21863142f, -0.03273898f, 
    0.13434005f, -0.14827958f, -0.04029259f, 0.16601706f, 0.12801005f, -0.05578154f, 0.12730826f, 0.13411751f, 
    0.03927808f, -0.03092923f, 0.05636652f, -0.04938231f, -0.07134473f, 0.09952248f, 0.01535950f, 0.29734695f, 
    -0.52881444f, 0.25218624f, 0.37028211f, -0.13829754f, -0.22871676f, 0.02213684f, 0.13824251f, 0.10297488f, 
    0.01074335f, 0.21314254f, 0.08773538f, -0.00841847f, -0.00260258f, 0.06023578f, -0.11103571f, -0.12544815f, 
    -0.00439463f, 0.15615658f, 0.08017042f, 0.00008990f, -0.04911559f, -0.05682699f, 0.07685173f, 0.08452286f, 
    0.18460101f, 0.16142449f, 0.03742757f, -0.08195326f, -0.14602074f, 0.04255921f, -0.06410047f, 0.08349727f, 
    -0.07955219f, -0.07696448f, -0.10632540f, 0.06869737f, -0.31563279f, 0.31952384f, 0.02837369f, 0.14460148f, 
    0.14812836f, 0.22950359f, 0.07731388f, -0.11173306f, 0.03169344f, -0.01684053f, -0.09115098f, 0.15715638f, 
    0.07755349f, 0.02894508f, -0.17279918f, 0.16119952f, -0.00806948f, 0.01304897f, -0.03484050f, -0.15863454f, 
    0.00788763f, 0.09741099f, 0.10909018f, 0.11557093f, 0.27118826f, -0.17660773f, -0.01890078f, 0.17610818f, 
    0.05327800f, 0.01351508f, 0.17440647f, -0.02014784f, 0.20387265f, -0.08312016f, -0.00696806f, 0.07120197f, 
    -0.19791786f, 0.16198857f, 0.13872203f, -0.08658559f, 0.00331439f, 0.07507787f, 0.00041541f, 0.08152469f, 
    -0.13410161f, -0.04301404f, 0.02941355f, 0.18683654f, -0.14693049f, -0.27853742f, 0.15395959f, -0.13592005f, 
    -0.11295094f, -0.01960761f, 0.15271938f, -0.11182417f, 0.09891211f, -0.21126612f, 0.03558157f, -0.13220707f, 
    -0.05818548f, 0.24241123f, 0.03055602f, 0.21576194f, 0.26592878f, -0.09779170f, 0.04224286f, -0.02136468f, 
    -0.02746303f, -0.03377473f, -0.09411743f, -0.08511151f, 0.00195133f, -0.39641398f, -0.01958529f, -0.42829686f, 
    -0.16276056f, 0.02553901f, 0.08143024f, 0.11229541f, -0.00122940f, 0.11395600f, 0.13201831f, 0.14714824f, 
    0.56424642f, 0.06128123f, -0.00701964f, -0.21580760f, -0.14844196f, 0.10787449f, 0.10788793f, 0.10210406f, 
    -0.07450661f, -0.04506211f, 0.04239025f, -0.11359669f, 0.18510649f, -0.32647213f, 0.21302462f, 0.06147611f, 
    0.02708982f, -0.01807431f, 0.19589424f, 0.10329948f, -0.08403282f, 0.06383475f, -0.00671603f, -0.25864738f, 
    0.12991765f, 0.14929467f, 0.07997771f, 0.41186535f, -0.05776143f, -0.04446013f, 0.09108094f, 0.03386506f, 
    0.04089117f, 0.06133075f, 0.02137972f, -0.20272636f, 0.29317141f, -0.47037831f, 0.21631356f, -0.16138493f, 
    -0.00207340f, -0.04253178f, 0.02169469f, -0.04356087f, -0.07717688f, -0.04576096f, 0.36224222f, 0.08435455f, 
    0.11021024f, 0.09063256f, -0.08222070f, -0.06847359f, 0.00071933f, 0.03153989f, 0.09159254f, -0.05299992f, 
    0.07984183f, 0.06789381f, 0.02932782f, 0.03040755f, -0.76264286f, -0.00244413f, -0.06086294f, 0.30574739f, 
    0.03909955f, 0.06806091f, 0.00888158f, 0.22656997f, 0.09937409f, -0.02832772f, 0.13914846f, -0.10159135f, 
    0.00825258f, -0.06858586f, -0.39165881f, -0.06581248f, 0.11130041f, 0.00877450f, -0.12441951f, -0.04711075f, 
    0.01197500f, 0.16370584f, -0.01638470f, 0.02384146f, 0.04804651f, -0.17092499f, 0.06348537f, 0.05202817f, 
    0.21055356f, -0.21784949f, -0.07948115f, -0.05309714f, -0.15441296f, -0.12816980f, 0.15549073f, 0.12010581f, 
    -0.05450726f, -0.17395292f, -0.00761133f, 0.04182377f, 0.12577948f, -0.07276452f, -0.01050694f, 0.03493948f, 
    -0.13946532f, -0.25270724f, -0.10744110f, -0.23524721f, 0.01927205f, 0.25733307f, 0.00624403f, -0.06431288f, 
    -0.17657581f, 0.04773941f, 0.07963326f, 0.03705763f, 0.02494127f, -0.00329758f, 0.00998506f, -0.03511786f, 
    -0.72210968f, -0.30656695f, -0.09591658f, 0.05191348f, 0.09279609f, 0.01439913f, -0.02394335f, -0.01675423f, 
    0.14148577f, -0.02881281f, -0.08693474f, -0.03192833f, 0.00939623f, -0.00279109f, -0.13851318f, 0.08814342f, 
    -0.18633103f, 0.06722832f, -0.04559404f, -0.16533841f, -0.11023776f, -0.03880887f, -0.00567735f, -0.07795707f, 
    0.00298193f, -0.20698905f, 0.30336857f, -0.13707474f, 0.09695275f, 0.07815589f, -0.26600540f, 0.04885193f, 
    -0.02173848f, -0.07325618f, -0.25247070f, 0.18610902f, 0.10449874f, -0.34372178f, -0.12066635f, -0.15929742f, 
    0.16319083f, 0.09691534f, 0.08990622f, -0.11699577f, -0.08265079f, -0.09293272f, 0.12778792f, 0.04092572f, 
    -0.05202764f, -0.18043996f, 0.02355021f, -0.00316343f, 0.07927529f, -0.07066784f, -0.15397210f, -0.11908499f, 
    0.14667501f, -0.29037100f, 0.10170134f, 0.05214492f, 0.41326442f, -0.23550047f, -0.31247908f, 0.01270084f, 
    -0.11931277f, 0.14942509f, 0.03615183f, 0.06439261f, 0.01050405f, 0.09450624f, -0.07766510f, 0.20540045f, 
    -0.33488613f, 0.15085833f, 0.09333397f, 0.11982466f, -0.09345087f, -0.06915952f, 0.04103538f, -0.02557353f, 
    -0.02229065f, -0.19363019f, -0.11171088f, -0.00231043f, -0.13743883f, 0.03945241f, -0.12248717f, 0.02421964f, 
    -0.21760306f, 0.06905835f, 0.02483347f, -0.00387100f, -0.02686365f, 0.19077496f, -0.07397947f, 0.03630436f, 
    0.11331056f, -0.43151754f, -0.33974898f, 0.23613484f, -0.03224158f, 0.08134662f, 0.01358548f, 0.01078143f, 
    0.07109518f, -0.04718971f, -0.10463665f, 0.06678743f, -0.50938529f, 0.03064808f, -0.36584455f, -0.45984983f, 
    -0.05671199f, -0.15091634f, -0.05477776f, -0.02665371f, -0.03423268f, -0.05686509f, -0.04603534f, 0.06486132f, 
    -0.25368297f, 0.10831942f, -0.17297028f, -0.08446737f, -0.11517257f, 0.02406430f, -0.06401061f, -0.09969544f, 
    -0.00338132f, -0.10087676f, -0.10123219f, -0.07737395f, 0.22691081f, 0.28484434f, 0.11323283f, -0.61190933f, 
    0.12937412f, 0.06927039f, 0.01991277f, 0.07826860f, 0.03532416f, 0.01459548f, -0.01060968f, -0.23384292f, 
    0.04283035f, 0.25270975f, -0.12890497f, -0.07963580f, -0.00457615f, 0.09302962f, -0.02701700f, -0.02758863f, 
    -0.24667893f, 0.02792875f, 0.01456620f, -0.11934464f, -0.16148362f, 0.23950973f, -0.24846691f, -0.00147925f, 
    -0.15154597f, 0.01966837f, -0.11954029f, -0.07414589f, -0.06002900f, -0.18325013f, -0.12270076f, -0.18383749f, 
    0.11351363f, -0.46044701f, 0.00820218f, 0.22998783f, -0.22754715f, -0.17689444f, -0.06353413f, -0.02876622f, 
    -0.02054277f, -0.13137695f, 0.05501105f, -0.08106910f, -0.01176139f, -0.40728965f, 0.23877656f, -0.13297766f, 
    0.03308676f, 0.06147599f, -0.02912885f, -0.05947558f, -0.09508964f, -0.12818977f, -0.01450901f, -0.06758207f, 
    0.16557468f, 0.15337732f, 0.06097979f, 0.14669804f, 0.03720496f, 0.06287947f, 0.04779428f, 0.02903907f, 
    0.02835389f, 0.11710238f, -0.01991979f, -0.14510477f, 0.01185716f, -0.33502731f, -0.08123197f, -0.11359813f, 
    -0.07642609f, -0.01593533f, -0.01251533f, -0.05991351f, -0.07386300f, 0.02087330f, -0.01920776f, -0.00447340f, 
    -0.12658711f, 0.03574900f, -0.10906612f, -0.23777871f, -0.07934387f, -0.08953642f, -0.08628343f, -0.16386248f, 
    0.00246019f, -0.03440220f, -0.09136961f, -0.08463446f, -0.14572394f, 0.08419999f, -0.00889422f, -0.03588536f, 
    -0.20029935f, 0.01679647f, -0.02860668f, -0.02451059f, 0.11742590f, -0.07990813f, -0.05876563f, 0.03173492f, 
    -0.55171287f, 0.11157892f, -0.20211539f, -0.09619878f, 0.04239856f, -0.07475884f, 0.01505323f, 0.10271949f, 
    -0.02272081f, -0.02345777f, -0.02176274f, -0.05768270f, -0.13588065f, 0.10314254f, 0.14418827f, 0.13996698f, 
    0.11310203f, 0.14209123f, 0.01947425f, -0.05257789f, -0.19824369f, 0.00328530f, 0.04906682f, 0.03576927f, 
    0.43738076f, -0.00101819f, 0.20331353f, -0.17489490f, -0.20871064f, -0.14413954f, -0.12004855f, 0.00444341f, 
    0.07189541f, 0.14819233f, -0.11365224f, 0.07277992f, 0.32152593f, -0.30800954f, 0.11948444f, -0.00083454f, 
    0.22523659f, -0.17745794f, 0.10336285f, -0.19422013f, 0.06858661f, -0.09187680f, -0.09669036f, -0.06404310f, 
    0.22119324f, -0.51637375f, 0.16608547f, 0.02326831f, -0.04062467f, -0.18010496f, -0.06794149f, -0.07717837f, 
    0.08956891f, 0.03954981f, -0.01934439f, -0.01886998f, 0.14478132f, 0.09288674f, 0.14899440f, -0.20178977f, 
    0.14871942f, -0.02070505f, 0.00328061f, 0.11942735f, -0.05988519f, 0.11543912f, 0.08670274f, -0.02130233f, 
    -0.00983633f, -0.14673306f, -0.03537162f, -0.04757603f, -0.09056850f, -0.14258911f, -0.18942688f, -0.14143822f, 
    -0.05339287f, 0.06447629f, 0.11327721f, -0.02653209f, -0.45979244f, -0.04722342f, -0.00660946f, -0.00727036f, 
    0.03564692f, 0.08761466f, -0.13451871f, -0.07235736f, 0.15601514f, -0.05293171f, 0.03595119f, -0.13359061f, 
    -0.01959978f, 0.17665613f, -0.03585765f, 0.03211885f, -0.11497416f, 0.10458431f, 0.05020228f, -0.03870476f, 
    -0.11408678f, 0.09281471f, -0.10888512f, -0.06270870f, 0.27750799f, 0.01026588f, 0.12952840f, -0.07635944f, 
    0.03932590f, 0.06755196f, -0.06276929f, -0.03301968f, -0.17084588f, -0.05017484f, 0.10871136f, -0.06031883f, 
    0.13812184f, -0.13517509f, 0.02484279f, 0.18793832f, -0.05233108f, -0.12693162f, -0.09873053f, -0.04621730f, 
    0.02499291f, -0.02867573f, -0.10328634f, -0.01444054f, -0.33861509f, 0.15764454f, -0.08303439f, -0.28176612f, 
    0.05935099f, 0.02670372f, 0.07606956f, -0.12095689f, -0.14168721f, -0.00019478f, 0.00906781f, -0.07545687f, 
    -0.21332106f, 0.02876230f, 0.10617195f, 0.06064602f, 0.07888623f, 0.04906506f, 0.06247353f, 0.03687095f, 
    0.02550452f, -0.01968065f, 0.02922733f, -0.04528533f, 0.15572692f, 0.29923674f, 0.20293099f, 0.32622436f, 
    0.21605183f, 0.06613076f, 0.11964016f, 0.07732412f, -0.00837701f, -0.08329646f, 0.05152586f, -0.00328704f, 
    -0.18524116f, -0.06324470f, -0.00582591f, -0.11006755f, 0.01240603f, 0.09108376f, -0.07350510f, -0.20388059f, 
    -0.06621602f, 0.09695619f, -0.10554276f, -0.09214187f, 0.31585580f, -0.18062797f, 0.25744766f, 0.27167860f, 
    -0.01878374f, -0.12422464f, -0.06184003f, -0.03440046f, -0.11041121f, -0.10113445f, 0.07256466f, -0.16505085f, 
    0.18983175f, 0.13775253f, 0.25457954f, 0.05753514f, -0.25647619f, 0.02329843f, -0.05219227f, -0.08846926f, 
    -0.07801447f, 0.02078228f, -0.14784400f, 0.08774069f, 0.36767673f, 0.35475203f, 0.16672975f, 0.21216252f, 
    0.23372538f, 0.05377202f, 0.12323128f, 0.05736585f, -0.12101350f, 0.07547026f, 0.13058038f, 0.01241319f, 
    0.05910573f, -0.14207183f, 0.04375222f, -0.08620976f, -0.05920032f, -0.02407169f, -0.07773580f, 0.01039685f, 
    -0.06237522f, 0.03081961f, -0.11164933f, -0.07703122f, 0.07915158f, 0.14176568f, 0.11045957f, 0.18800019f, 
    0.04107922f, -0.03846978f, -0.11869234f, 0.00060687f, -0.21747820f, -0.03421911f, 0.00947081f, -0.15224685f, 
    0.01112223f, 0.13658854f, -0.00221520f, 0.13049045f, 0.11813004f, 0.08601464f, -0.01603912f, 0.06604365f, 
    -0.07061806f, -0.16159940f, 0.07380960f, -0.07638362f, 0.22060932f, 0.15447217f, 0.27493802f, 0.19735919f, 
    0.07953606f, 0.06257553f, -0.07732374f, -0.12355056f, -0.00617059f, -0.01599393f, -0.10805314f, -0.12847440f, 
    -0.18514064f, 0.10819723f, -0.25375006f, -0.03417497f, -0.07899158f, 0.03883849f, -0.00915285f, -0.03598996f, 
    -0.04286028f, 0.00241352f, -0.00814824f, 0.02282269f, -0.20663109f, -0.48071131f, -0.10758147f, 0.07037284f, 
    -0.11974081f, -0.05993946f, -0.00533827f, -0.03786425f, -0.02334165f, -0.00148163f, 0.00724324f, -0.02718994f, 
    0.21437159f, -0.06729428f, 0.08537412f, 0.21668434f, 0.07044017f, -0.06505188f, -0.17950742f, -0.04529479f, 
    -0.04807261f, 0.10145182f, 0.02727770f, -0.00726898f, -0.09107120f, 0.20525633f, 0.22549716f, 0.02678851f, 
    -0.03107216f, 0.05325680f, -0.11144341f, -0.15401690f, 0.08789472f, 0.01044091f, -0.08625460f, -0.02387795f, 
    -0.10852429f, -0.17377819f, -0.13142227f, -0.13265516f, -0.08809431f, -0.00195070f, -0.04558778f, 0.01952640f, 
    0.02712733f, 0.20786111f, -0.09275026f, 0.02947283f, 0.02378730f, -0.07250173f, -0.50139850f, 0.12531243f, 
    0.19762014f, -0.09249986f, 0.00685203f, -0.05405414f, 0.12945648f, 0.10799950f, 0.02533968f, 0.13402693f, 
    0.04388270f, 0.22070123f, -0.12563513f, -0.10961121f, -0.20213436f, -0.05842634f, 0.11462253f, -0.03391594f, 
    0.06036953f, 0.03132356f, -0.08607116f, -0.02984689f, 0.03858906f, -0.10050824f, -0.00794021f, 0.11985525f, 
    0.03620214f, -0.05428699f, -0.00119640f, -0.11710337f, -0.03261305f, -0.11768423f, -0.08901968f, 0.01624915f, 
    0.25777459f, -0.09198235f, -0.04547726f, 0.07294948f, 0.16235150f, -0.12516938f, -0.13145977f, -0.12712853f, 
    -0.09292307f, 0.04579899f, -0.07295976f, 0.01685844f, 0.01259500f, 0.12744153f, 0.20693327f, 0.13922583f, 
    -0.11836101f, 0.08383334f, -0.09948596f, 0.11969837f, -0.11468369f, 0.12833959f, 0.05066992f, -0.04882141f, 
    -0.22221386f, 0.24813905f, -0.35793763f, -0.01712395f, 0.03609960f, 0.03630433f, -0.24791853f, -0.05115717f, 
    0.00678100f, 0.01529370f, 0.05217513f, 0.01747735f, -0.21359730f, -0.25207952f, 0.33626911f, 0.11009532f, 
    -0.20941685f, -0.10556909f, -0.11387124f, -0.17021957f, -0.00312714f, 0.07569531f, -0.10099280f, -0.05780802f, 
    -0.10850510f, 0.22029912f, -0.22418430f, -0.08538360f, -0.04303221f, -0.02720878f, -0.06284665f, 0.04142852f, 
    0.02560372f, 0.00185638f, -0.03658750f, 0.07825329f, 0.11532111f, -0.17670731f, 0.09121305f, 0.02621252f, 
    0.01046525f, -0.00772540f, -0.05380282f, -0.09570837f, -0.05811075f, -0.06075059f, 0.05040614f, 0.00803531f, 
    -0.18201280f, -0.18342766f, -0.07297686f, -0.13014023f, -0.09822193f, -0.09261368f, 0.01622150f, -0.20515651f, 
    0.07045953f, 0.20433424f, -0.10651010f, 0.24083327f, 0.03982137f, -0.28185332f, 0.05258635f, 0.21061598f, 
    -0.01485843f, -0.11512523f, 0.04722306f, -0.11728460f, 0.20814799f, -0.18679202f, -0.21339658f, -0.06608181f, 
    -0.21131264f, -0.15492089f, -0.04490913f, -0.09084524f, 0.06467699f, -0.14404340f, 0.07183274f, -0.06974544f, 
    0.09268036f, -0.02299658f, -0.21237758f, -0.02072886f, 0.12842934f, 0.34380728f, -0.33942476f, 0.23927963f, 
    -0.01541614f, -0.02396248f, 0.03198754f, -0.03504772f, -0.04595178f, 0.02556500f, -0.16434468f, 0.07023972f, 
    0.00326271f, 0.33599326f, -0.16824365f, -0.03091099f, -0.24185540f, 0.03866504f, 0.02526768f, -0.19246054f, 
    -0.01805911f, -0.12040264f, 0.03566791f, 0.07838228f, 0.12461563f, -0.06523369f, -0.06780621f, -0.24073921f, 
    -0.03089949f, -0.20708768f, -0.11512420f, 0.09687600f, 0.04324708f, -0.02951975f, -0.38465032f, -0.24932113f, 
    0.40428057f, 0.01610736f, -0.41730478f, -0.21959639f, 0.03856536f, -0.10850742f, 0.09790918f, -0.13828450f, 
    0.12010910f, 0.09103508f, 0.11640491f, 0.15586480f, 0.17110021f, 0.11633089f, 0.04209628f, 0.30440772f, 
    0.03470746f, -0.06078222f, -0.10680488f, -0.05725834f, 0.00356467f, -0.06410270f, 0.08137119f, -0.05800664f, 
    -0.04347965f, 0.22745822f, 0.07029109f, 0.23857912f, -0.11330058f, 0.03193899f, -0.04400660f, -0.20503102f, 
    -0.06468971f, -0.01806518f, 0.14862004f, -0.05523425f, -0.11636606f, 0.07185549f, 0.16849671f, -0.04410774f, 
    0.00756987f, 0.08149683f, 0.06320114f, -0.03278210f, -0.09527692f, -0.00717166f, 0.11785033f, -0.10390686f, 
    0.29257604f, -0.09338333f, 0.07098381f, 0.14155287f, -0.14720514f, -0.12629363f, -0.04668423f, -0.02781465f, 
    0.07467397f, -0.09716855f, -0.03410308f, -0.16516680f, 0.31603768f, -0.57811022f, -0.20292334f, -0.29368320f, 
    0.01784825f, -0.25448984f, 0.04960720f, 0.08144721f, -0.02899191f, 0.04267501f, 0.04613400f, 0.03378060f, 
    -0.20878880f, 0.32430303f, -0.18789653f, -0.11418607f, -0.01646363f, 0.08417476f, -0.10281415f, 0.13964993f, 
    0.18313454f, 0.08275674f, -0.01486822f, 0.20218851f, -0.06380105f, -0.39706624f, -0.08414060f, 0.01859027f, 
    0.00245799f, 0.10669453f, 0.24298428f, -0.18009900f, 0.07789611f, -0.10069524f, 0.02495987f, -0.04722567f, 
    0.08201720f, -0.20156100f, -0.04419791f, -0.14330114f, 0.02604187f, 0.01859267f, -0.01193750f, -0.04870517f, 
    -0.00744205f, 0.08499946f, 0.10865473f, 0.02420974f, -0.12328534f, 0.09240758f, -0.44019699f, -0.23015527f, 
    0.11259717f, -0.02845756f, -0.12941255f, 0.03533140f, -0.04846773f, 0.07119460f, -0.08073884f, 0.06375692f, 
    0.05251614f, 0.05269936f, 0.05243488f, 0.03400293f, -0.01241598f, -0.21459955f, -0.18393467f, -0.12767059f, 
    -0.17515501f, -0.02577097f, 0.00567552f, -0.15898454f, -0.53986228f, 0.10221678f, 0.13552561f, -0.23610204f, 
    -0.08361509f, -0.04637850f, -0.03107245f, -0.13257714f, 0.08162273f, -0.09382802f, 0.08509867f, 0.04562309f, 
    0.06659981f, 0.23182330f, 0.31637096f, 0.19615738f, -0.24001865f, 0.06506706f, 0.06382708f, -0.06186522f, 
    0.21992970f, -0.13292803f, 0.10880896f, 0.06558038f, -0.20195179f, -0.30413970f, -0.16457410f, 0.42489243f, 
    0.14427970f, 0.04755295f, -0.01529521f, -0.06235150f, -0.00107473f, 0.20886192f, 0.09467145f, 0.14468485f, 
    -0.28587747f, 0.41374943f, -0.44545293f, -0.12417790f, 0.00846642f, 0.12872231f, -0.13503247f, -0.02514006f, 
    -0.07424067f, -0.14610504f, 0.02157874f, 0.01371213f, 0.74556023f, 0.13090530f, -0.07172611f, -0.05440680f, 
    -0.10412381f, -0.13193995f, 0.22690739f, 0.10835905f, -0.07747751f, -0.01490250f, 0.16220559f, -0.07887768f, 
    -0.04854106f, -0.21795405f, -0.08849095f, -0.27699298f, 0.18221726f, -0.07110205f, 0.10119845f, -0.13471363f, 
    -0.01429770f, 0.08755548f, 0.24353510f, -0.02384035f, 0.29363367f, -0.61980891f, 0.38065499f, -0.06870043f, 
    -0.01360274f, -0.14768496f, -0.13682784f, -0.13848071f, -0.10139420f, -0.00948416f, 0.08248749f, -0.13717930f, 
    -0.00475775f, 0.18896005f, 0.02679462f, 0.22502872f, 0.14972650f, 0.10718983f, -0.19368310f, 0.04724451f, 
    0.03034333f, -0.02078859f, 0.07066958f, -0.00095923f, 0.14299797f, -0.04661408f, -0.09801470f, -0.33802298f, 
    0.27285582f, 0.07430304f, 0.06054478f, -0.04457895f, -0.04253611f, 0.02079299f, 0.04737071f, -0.19332369f, 
    -0.17605938f, -0.05007098f, -0.01056380f, -0.00533585f, 0.00293437f, 0.04601944f, 0.18303923f, -0.14725088f, 
    0.17058904f, 0.01934023f, -0.09282279f, 0.16829470f, 0.00797206f, 0.13890669f, -0.03403638f, 0.07813283f, 
    0.15013742f, 0.04709683f, -0.00037344f, 0.06553160f, 0.02714552f, -0.05209377f, -0.14511688f, -0.06164657f, 
    -0.30971208f, 0.05288902f, 0.26624960f, -0.02723891f, -0.06718716f, -0.11455704f, -0.00916930f, -0.00869940f, 
    -0.02351930f, -0.14274785f, -0.10948037f, -0.09366164f, 0.02150358f, -0.02304065f, 0.00951818f, 0.06964585f, 
    0.13062964f, -0.04316393f, -0.06109736f, -0.09644658f, 0.02456740f, -0.10577323f, 0.06212917f, -0.03963064f, 
    -0.42211655f, -0.12789690f, -0.15902923f, 0.10700575f, 0.06392052f, -0.05829193f, 0.07409634f, -0.08630633f, 
    0.02978563f, 0.13843924f, 0.04904349f, -0.10010490f, 0.32287773f, 0.04853593f, 0.21430342f, -0.06384391f, 
    0.05815438f, -0.03312159f, -0.05552722f, -0.20581219f, 0.16073392f, 0.01312951f, -0.01368629f, 0.14280578f, 
    0.45166773f, -0.18681221f, -0.19763470f, 0.04362278f, -0.14622557f, -0.01227265f, 0.12612797f, 0.01247399f, 
    0.16718808f, -0.17329186f, -0.08019099f, -0.20417105f, 0.16211246f, -0.39228833f, 0.13289155f, -0.00432550f, 
    0.02929199f, -0.04703523f, -0.09488478f, -0.08088217f, 0.11074566f, 0.09337944f, 0.12304162f, 0.05633279f, 
    -0.51416492f, -0.00418007f, -0.01316597f, -0.20948759f, -0.18629058f, 0.00122339f, -0.04241991f, -0.09414408f, 
    0.05333776f, -0.03621837f, 0.00838120f, 0.00704488f, 0.24111974f, 0.20931484f, 0.14823934f, 0.12877902f, 
    0.04918571f, 0.11879002f, -0.04300246f, 0.05374390f, 0.09005614f, -0.05017630f, 0.01618760f, -0.18751580f, 
    -0.29882473f, 0.31137753f, 0.05370469f, 0.24330796f, -0.01018691f, 0.09873743f, -0.16275096f, 0.19405913f, 
    0.15619063f, 0.02387572f, -0.08828179f, 0.00018341f, -0.15948878f, 0.15345034f, -0.22627130f, 0.19795606f, 
    0.01523108f, 0.13236845f, -0.11109338f, 0.07374346f, -0.17487957f, 0.12392598f, 0.07524507f, -0.00252976f, 
    -0.08668553f, 0.17275614f, 0.02834088f, -0.28793973f, 0.18262202f, 0.08160446f, -0.18292382f, -0.16056925f, 
    -0.07125273f, 0.05127131f, -0.02226938f, -0.14862432f, -0.06127133f, 0.29463679f, -0.00105708f, -0.59460497f, 
    0.19912027f, -0.06483675f, -0.04278541f, -0.03053605f, -0.17217532f, 0.00549821f, 0.06039620f, -0.18445545f, 
    0.23868833f, -0.76539898f, -0.13547218f, -0.11061159f, -0.07757051f, -0.04538370f, 0.09525514f, 0.48810175f, 
    -0.08019268f, -0.01399753f, 0.23820083f, -0.07505731f, -0.34530514f, -0.38236973f, 0.09595534f, -0.05168571f, 
    0.07237165f, 0.01789777f, -0.14254364f, -0.03922284f, -0.07190976f, -0.03398448f, -0.00166817f, 0.15384613f, 
    0.31684878f, -0.31722465f, -0.18973550f, 0.18123353f, 0.13360178f, -0.08823685f, 0.04496717f, -0.05649555f, 
    -0.19135401f, -0.05582437f, 0.11565083f, 0.06213866f, 0.13749693f, -0.02351694f, 0.08088158f, -0.02372109f, 
    0.01407746f, -0.11165258f, -0.00379686f, 0.04846604f, -0.04798381f, 0.07828554f, 0.03899098f, 0.17700957f, 
    -0.41767049f, -0.08733293f, -0.19657099f, 0.39148560f, 0.01860940f, 0.09746178f, 0.14400691f, 0.04847261f, 
    -0.20533194f, 0.07921600f, 0.02594595f, 0.07350791f, 0.13121021f, -0.43528050f, 0.17297050f, 0.11071683f, 
    0.26025584f, 0.02274281f, 0.01667320f, -0.08615188f, -0.08109972f, -0.06451359f, 0.05371853f, -0.02050919f, 
    -0.18897803f, -0.07779217f, 0.02228568f, 0.08987925f, 0.02646399f, 0.08948961f, -0.03506324f, 0.29491574f, 
    -0.04291226f, -0.09308790f, 0.12365854f, -0.02088322f, -0.01106493f, -0.17593826f, 0.11759429f, -0.11568175f, 
    0.13452455f, 0.10695171f, 0.01447751f, -0.08386678f, 0.12690386f, -0.17224385f, 0.15082358f, -0.00056518f, 
    -0.02246388f, -0.35204276f, 0.05124134f, 0.19257319f, 0.12903859f, 0.11663166f, -0.00311406f, 0.08051452f, 
    0.09858349f, 0.01192791f, 0.17131107f, -0.01438326f, -0.01176919f, -0.39877304f, -0.18243614f, 0.05958609f, 
    -0.00505828f, 0.10119713f, -0.06256398f, 0.01985717f, -0.01501553f, -0.07950576f, -0.26614061f, 0.07435639f, 
    -0.07963561f, 0.28547069f, -0.00826292f, -0.07963026f, 0.29875743f, -0.00019569f, -0.05388183f, 0.15935627f, 
    -0.12320288f, -0.14707267f, 0.05778077f, 0.06120040f, -0.32479206f, 0.00846311f, -0.12479256f, -0.60055155f, 
    0.05938652f, -0.00827388f, -0.19693410f, 0.12026981f, -0.03496323f, -0.20402007f, -0.17691101f, -0.12483931f, 
    -0.67960113f, -0.44349825f, -0.22607115f, -0.19591108f, 0.05095327f, -0.07622565f, -0.11364359f, -0.05829936f, 
    0.02093223f, -0.01521036f, -0.05348417f, 0.01066812f, -0.61345696f, -0.26179978f, 0.21251442f, 0.15614972f, 
    0.26950419f, 0.03107328f, -0.04914001f, -0.03951622f, 0.15098424f, 0.22917640f, -0.17515582f, 0.13905749f, 
    0.12921865f, 0.13627973f, 0.03958958f, -0.30884743f, 0.05676212f, -0.11511179f, -0.02726311f, 0.21788958f, 
    0.04195087f, 0.08138040f, -0.08854611f, 0.35052708f, -0.53549755f, 0.05978343f, -0.09624760f, -0.00514403f, 
    0.21711272f, -0.05286785f, -0.05361655f, -0.00602261f, 0.07162078f, -0.03709797f, -0.10331523f, 0.15751278f, 
    0.14975064f, 0.01752243f, 0.06271170f, -0.07614563f, -0.20824581f, -0.11767597f, 0.08855119f, -0.18373188f, 
    0.14229095f, -0.11872557f, -0.04057053f, -0.07851024f, 0.10197771f, 0.10565915f, -0.03644617f, 0.05197362f, 
    -0.15367541f, 0.00614817f, -0.08272674f, 0.11022200f, 0.01786186f, 0.12153537f, 0.08076190f, 0.01527776f, 
    -0.47075891f, -0.30974528f, -0.21167283f, -0.21379957f, 0.04679598f, 0.17812313f, -0.00174184f, -0.06175491f, 
    0.12382706f, -0.26184452f, -0.23947358f, -0.03379992f, 0.29369313f, -0.12507762f, 0.10741652f, 0.03963115f, 
    -0.17871700f, -0.01946260f, 0.17064045f, 0.05171288f, 0.01594651f, 0.07130302f, -0.17098323f, 0.14707597f, 
    -0.22196865f, -0.22205612f, -0.16069937f, 0.08175233f, 0.16285487f, 0.02130738f, -0.11683130f, 0.14832196f, 
    0.05649843f, 0.27057534f, 0.21446556f, 0.17067091f, 0.39293897f, 0.17888662f, 0.01048735f, 0.00342659f, 
    -0.15586591f, -0.08468132f, 0.03433038f, -0.08998021f, -0.05876428f, -0.00402980f, -0.02890303f, -0.05811001f, 
    0.07514326f, -0.18087064f, -0.18335004f, 0.13666733f, 0.00536569f, 0.04105985f, -0.05790507f, 0.08068597f, 
    -0.05143764f, 0.06630775f, -0.00989559f, 0.00737043f, -0.60764831f, -0.03197423f, -0.22308029f, 0.07569808f, 
    -0.04324781f, 0.10547972f, -0.00805856f, 0.06388648f, -0.05449556f, -0.01453790f, 0.06918903f, -0.08806162f, 
    0.16505150f, 0.13210136f, -0.05351768f, 0.09669621f, -0.19775695f, 0.12429873f, -0.00609108f, 0.10105185f, 
    0.04967188f, 0.12507509f, 0.18387108f, 0.25496736f, 0.37182108f, -0.13258104f, -0.21470861f, -0.01814040f, 
    -0.05575180f, -0.11386780f, -0.01242665f, 0.15294948f, 0.06260536f, 0.01011404f, -0.27914679f, -0.01130505f, 
    0.28273496f, 0.25855511f, 0.23185803f, 0.22530903f, -0.04209312f, 0.18326734f, 0.12964128f, 0.11616838f, 
    -0.02494883f, -0.06724890f, 0.04854407f, 0.10256975f, -0.12175410f, -0.19607882f, 0.08962733f, -0.08828247f, 
    0.14432979f, -0.04790280f, 0.00594614f, 0.02128706f, 0.01300178f, -0.00906752f, -0.06447323f, 0.22215132f, 
    -0.15497102f, 0.05967189f, -0.20828356f, 0.00518255f, -0.08448586f, 0.01061024f, -0.01074446f, -0.11113924f, 
    0.01300158f, -0.17744663f, 0.05259177f, -0.19569570f, 0.12764525f, -0.10765182f, 0.03936639f, 0.10319736f, 
    -0.17052567f, -0.03858907f, 0.12006082f, 0.00830356f, 0.02123143f, -0.31744677f, -0.22939335f, -0.17363828f, 
    -0.10498817f, 0.04403850f, 0.15018407f, 0.04134538f, 0.18508331f, 0.03844751f, -0.00746560f, 0.07657345f, 
    0.07495024f, 0.07852230f, -0.00083630f, 0.11833396f, -1.01331449f, -0.30922446f, -0.32184163f, -0.43267909f, 
    0.15811704f, -0.04606416f, -0.14618285f, -0.03978233f, -0.03305717f, -0.03238413f, 0.19991834f, 0.04737453f, 
    0.33184201f, -0.04769902f, 0.10922030f, 0.00217361f, -0.08815563f, -0.02282028f, 0.11129092f, -0.11338199f, 
    -0.10548862f, 0.08525149f, -0.06859174f, -0.02522572f, 0.26349616f, -0.02759942f, -0.16558640f, 0.10603933f, 
    -0.15272745f, -0.04970139f, -0.01084275f, -0.01663986f, 0.14010856f, 0.30086803f, 0.03599137f, -0.00500709f, 
    0.29453453f, -0.22289115f, -0.34179977f, -0.13827585f, 0.10628424f, -0.10582244f, -0.09738840f, 0.18353292f, 
    0.04909990f, 0.17506926f, 0.13341929f, 0.10664912f, -0.21078464f, 0.16390149f, -0.03439845f, -0.12539619f, 
    0.09824073f, -0.19264777f, 0.21705747f, 0.03324499f, 0.02445028f, -0.02544158f, -0.10293797f, -0.05211310f, 
    -0.03248320f, -0.18271613f, -0.06467892f, -0.12940767f, -0.07334301f, 0.08844361f, 0.03442498f, -0.00571620f, 
    0.00389876f, -0.14989437f, -0.04077430f, -0.10278470f, -0.06931940f, 0.22046573f, -0.31539115f, 0.21428187f, 
    -0.17402400f, -0.20716295f, -0.00984338f, -0.14379022f, 0.00751535f, 0.04575538f, 0.09066455f, -0.09480851f, 
    -0.31209409f, -0.48320657f, 0.01471597f, -0.11372292f, -0.00015976f, 0.06782501f, 0.02136914f, 0.06536186f, 
    0.09026603f, 0.06135305f, -0.00077765f, 0.06982755f, -0.07744475f, 0.10321979f, -0.07769927f, 0.18287057f, 
    0.07746728f, -0.01968869f, 0.15984622f, -0.18541482f, 0.05898092f, -0.04353265f, -0.22826852f, -0.02429707f, 
    0.16641873f, 0.14262667f, -0.02119730f, -0.24681346f, -0.09527738f, 0.09408075f, -0.02849057f, -0.05830527f, 
    -0.02038812f, 0.04246885f, -0.11708978f, -0.03978067f, 0.23602036f, 0.09261080f, -0.08554869f, -0.28717291f, 
    -0.03579313f, 0.12792979f, 0.07415834f, -0.09930562f, -0.18432280f, -0.04032581f, 0.05890872f, -0.12053037f, 
    -0.43882465f, -0.31833467f, 0.03228207f, 0.08546084f, 0.16041814f, 0.07436189f, 0.18332231f, -0.01280420f, 
    0.23757617f, 0.21553595f, 0.16487157f, 0.06940157f, -0.49128920f, 0.05793530f, -0.10261191f, -0.42763075f, 
    0.04356080f, 0.05998641f, -0.03501956f, 0.06365994f, 0.06955713f, 0.16449049f, 0.09757496f, 0.04752021f, 
    0.01190341f, -0.17318669f, -0.39994311f, -0.10425606f, 0.07718801f, -0.01379225f, -0.01763738f, 0.08638651f, 
    0.13240020f, 0.00225425f, -0.01726633f, -0.05825651f, -0.05305314f, -0.47379243f, 0.05969566f, -0.06747048f, 
    0.22648357f, -0.15950733f, -0.05692555f, 0.27569509f, -0.04853661f, -0.02032276f, -0.05331749f, 0.05277135f, 
    -0.00227357f, -0.12240731f, -0.16068301f, 0.39368090f, -0.05456147f, -0.12246312f, -0.00404923f, 0.04627778f, 
    0.03358844f, 0.05473699f, -0.08988896f, -0.23708865f, 0.83631057f, 0.11317901f, -0.22657432f, 0.00112194f, 
    0.02316990f, 0.06054718f, -0.00771081f, 0.07731660f, 0.01980440f, 0.18232249f, 0.12318977f, 0.04156489f, 
    -0.17588052f, 0.05830901f, -0.06624636f, -0.01920696f, 0.10393244f, -0.05301799f, -0.03027128f, -0.17130978f, 
    -0.03059183f, -0.06904770f, -0.04261439f, -0.04290535f, -0.26136777f, -0.12080888f, -0.26392162f, -0.08459523f, 
    -0.12159429f, -0.06225710f, 0.13736568f, 0.03791635f, -0.15225472f, 0.05727404f, -0.01302164f, 0.10931343f, 
    -0.42872152f, 0.03116801f, -0.10259341f, -0.38676888f, 0.06561038f, 0.02655189f, -0.03956816f, 0.17740448f, 
    0.14565621f, 0.08177887f, -0.00524798f, -0.03217294f, -0.16855232f, -0.24676977f, 0.12608680f, 0.06019114f, 
    0.09188575f, 0.08237285f, -0.00948511f, 0.02152717f, -0.17593876f, 0.08579838f, -0.06343909f, -0.05501619f, 
    0.22077513f, 0.15791835f, -0.10425636f, 0.29620031f, 0.12361155f, 0.02841731f, 0.10099555f, 0.03334830f, 
    0.05320479f, 0.02404547f, -0.11902235f, -0.07864366f, 0.15710485f, -0.18342705f, 0.08732079f, -0.05798434f, 
    -0.10891453f, -0.01018155f, 0.07019851f, 0.07831109f, -0.11118946f, -0.10045962f, 0.11105329f, -0.05703564f, 
    -0.22012039f, 0.18638495f, -0.06433546f, 0.02229755f, 0.39212707f, 0.05434241f, 0.22879019f, -0.20958753f, 
    -0.07703547f, -0.19093560f, 0.13409489f, -0.02460179f, -0.30814421f, 0.21199091f, 0.12070024f, -0.11135376f, 
    -0.11736300f, 0.07322498f, -0.19377264f, 0.01462827f, 0.03440231f, 0.13465431f, 0.10096434f, 0.08998932f, 
    -0.27561840f, -0.00837245f, 0.08484083f, -0.01402284f, 0.00241539f, 0.04467759f, 0.14690751f, 0.06739794f, 
    -0.29405147f, -0.04927596f, 0.08040995f, -0.05379238f, -0.56880391f, 0.22451341f, -0.03780188f, -0.17734784f, 
    0.04253871f, -0.15785696f, -0.00163772f, 0.07720416f, -0.01426764f, 0.08082639f, -0.10593035f, -0.10235313f, 
    0.26911259f, -0.07466892f, -0.14459322f, -0.23810343f, 0.13673727f, -0.14642863f, -0.01219142f, -0.03709907f, 
    -0.02099207f, -0.00627340f, 0.00377965f, 0.15422811f, 0.10276521f, 0.14575891f, 0.13227676f, 0.01882991f, 
    0.04178620f, 0.12340376f, -0.05798614f, 0.01686864f, 0.03096816f, 0.01981336f, 0.03817230f, -0.02598111f, 
    0.09539413f, -0.05795997f, -0.17349225f, 0.10427733f, -0.01562589f, -0.09109352f, 0.21655789f, 0.03643076f, 
    -0.12031361f, 0.16221981f, -0.09145331f, -0.04537192f, -0.32144159f, 0.03180615f, 0.12529182f, -0.05520382f, 
    0.11405798f, -0.06147900f, 0.07022829f, -0.15186618f, 0.14708592f, -0.06481908f, 0.21973395f, 0.10629420f, 
    0.34493157f, -0.13933811f, -0.33763063f, 0.16032107f, 0.03538889f, -0.16012992f, 0.03783685f, 0.12447029f, 
    -0.01032215f, 0.02268616f, -0.06091253f, -0.02444877f, 0.55295181f, -0.42134735f, -0.38806099f, -0.03672818f, 
    -0.02316760f, 0.00028569f, -0.09189941f, -0.01713567f, -0.04412033f, 0.02337483f, -0.07727576f, -0.01933140f, 
    0.03865122f, -0.06270123f, 0.07380040f, 0.11957263f, -0.09282215f, 0.01617580f, 0.00846568f, -0.02653280f, 
    -0.07804838f, 0.26837593f, -0.04721726f, -0.22893889f, 0.14749216f, -0.02184155f, 0.02790562f, 0.18777519f, 
    0.03926897f, -0.00294487f, -0.06376188f, -0.03874235f, -0.08770196f, 0.04161367f, 0.05327182f, -0.14172854f, 
    -0.38568401f, -0.02522407f, 0.00145187f, -0.17023659f, -0.01232836f, -0.01047997f, 0.11122914f, -0.01069050f, 
    0.01538652f, -0.17691317f, -0.01355478f, 0.10005017f, 0.35354468f, -0.09958820f, 0.06396253f, 0.19377376f, 
    -0.02084714f, 0.07315553f, -0.18922779f, -0.10973357f, 0.17156668f, 0.00728086f, 0.17321685f, -0.23206611f, 
    -0.16737074f, 0.44667923f, -0.10186758f, -0.06099136f, 0.18134411f, -0.12387358f, -0.03870843f, -0.12484042f, 
    -0.10540844f, 0.17718771f, 0.20108719f, -0.03154973f, -0.07552731f, -0.07203376f, -0.04201552f, 0.02391991f, 
    -0.26690927f, 0.08407416f, -0.11442289f, 0.06693583f, -0.12487809f, 0.09197451f, -0.03802100f, -0.05273924f, 
    -0.59624547f, -0.18306819f, 0.28000343f, 0.11248542f, 0.20502710f, 0.02281373f, 0.03221245f, -0.01051022f, 
    0.00477970f, -0.04400892f, -0.10167685f, -0.08813279f, 0.30973160f, 0.11856007f, 0.02005979f, 0.05197569f, 
    -0.16157587f, -0.00142628f, -0.02643361f, -0.04732295f, 0.13094337f, 0.19213431f, 0.09501801f, -0.02593651f, 
    -0.51759726f, -0.04806959f, 0.09624813f, -0.00066349f, -0.11493398f, 0.01740341f, -0.13856646f, 0.20663668f, 
    -0.09179728f, 0.18287490f, 0.24842180f, 0.02256217f, 0.03758211f, 0.19815275f, -0.38430673f, -0.11606258f, 
    -0.19250652f, -0.23871250f, -0.07076618f, -0.21610537f, -0.00158661f, 0.07046245f, -0.09726411f, -0.08844081f, 
    -0.07121010f, -0.30182520f, 0.13140410f, -0.16587287f, 0.05274248f, 0.05015325f, 0.02622973f, 0.10689557f, 
    -0.10039979f, 0.10068721f, -0.12174922f, -0.22383244f, 0.42184052f, -0.12070041f, -0.39666817f, 0.05665750f, 
    0.01066531f, -0.15141055f, -0.06698208f, -0.07412707f, -0.04458845f, 0.00714927f, 0.06902426f, -0.01705310f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15327527f, 0.04031263f, -0.10788538f, -0.00897528f, -0.04168566f, -0.00513697f, -0.04120000f, -0.14675668f, 
    -0.02469921f, 0.05822983f, 0.09293518f, -0.00723924f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
