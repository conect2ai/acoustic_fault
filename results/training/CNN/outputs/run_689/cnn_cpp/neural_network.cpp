#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.95716709f, -1.52488256f, 1.31755376f, 0.88033754f, -0.44306436f, 0.16961092f, -0.36700687f, -0.07530945f, 
    -0.86943692f, 0.95550907f, -0.79811180f, -1.17913282f, -0.71530122f, -1.00243771f, -0.88531548f, 0.11193781f, 
    -0.17568839f, -0.10576241f, -0.31487158f, 1.09016478f, -0.05754171f, -1.16635406f, 0.58833861f, 0.62482071f, 
    0.52859926f, 0.63304299f, -0.18010074f, 1.03904498f, -1.49711001f, -0.12503468f, -0.89391381f, 0.30607301f, 
    0.39520472f, -0.20282663f, 0.37853387f, -0.28370348f, 1.42010796f, 0.59301049f, 0.94561565f, 0.07481126f, 
    -1.14402628f, -0.63432699f, -0.28359255f, 0.28185800f, 0.37361938f, 1.36887443f, 0.84085661f, -0.96208513f, 
    1.07911181f, 0.36945444f, -0.54108989f, -0.44449297f, -0.40727589f, 0.08650655f, -0.85691184f, -0.17579842f, 
    -0.92710358f, 0.79550773f, 0.63868785f, -0.57365978f, 0.73262852f, -0.24311928f, 0.16091830f, 0.55510670f, 
    1.42033696f, 0.79573697f, -1.16704845f, 0.21071810f, -0.19727501f, -0.24479896f, -0.55407822f, -0.46764180f, 
    -0.03149470f, -1.04998422f, -0.66114581f, -0.38739774f, 0.05710280f, -1.05419874f, -0.88408387f, 0.31252113f, 
    0.14726083f, 0.03804322f, 0.80165130f, -0.83384347f, 0.78956175f, 0.96535057f, 0.58742964f, 0.25380626f, 
    -0.35926735f, -0.63808483f, -0.46068838f, -0.38403052f, 0.73403150f, -0.59892881f, 1.25501072f, 0.69686174f, 
    -0.58851409f, 0.55871427f, 0.59341043f, 0.40255126f, 0.40277770f, 0.81530285f, -1.26736140f, -0.40342236f, 
    -0.91084945f, 0.74930811f, 0.73455673f, -0.39095977f, 0.26707658f, 0.90468794f, 1.02986479f, 0.80458504f, 
    -0.08669411f, 0.63687479f, -0.59041154f, 0.55401558f, -0.45543495f, -1.02245796f, 1.20460558f, -0.90710855f, 
    0.64375192f, 0.06367056f, -1.19362509f, 0.00965495f, 0.19558793f, -0.18680279f, -0.04821334f, -0.53004318f, 
    -0.61737680f, -0.72599870f, 0.60035026f, -0.56726116f, -0.29805160f, 0.72043759f, -0.59019506f, -1.39150107f, 
    -0.70056343f, 0.05792443f, 0.69720632f, 1.25140595f, -0.03614989f, -0.20366395f, -0.02813759f, -0.19313340f, 
    -0.14234194f, 1.12497091f, 0.71806097f, 0.07699592f, 0.02610266f, -1.20999122f, -0.19159968f, 0.76501197f, 
    0.44960037f, 1.18151617f, -0.72941470f, 1.13195193f, 0.99737942f, -0.27153572f, 0.30034178f, 0.23478791f, 
    -0.18763393f, 0.10206570f, 0.04947395f, -0.36040026f, -0.98693597f, -0.35633263f, 1.10360444f, 1.11358237f, 
    -0.27506846f, -0.39156133f, -0.32016784f, -0.96639007f, -1.29535735f, -0.60237664f, -0.61280650f, 0.42802721f, 
    1.13808751f, 0.45737892f, -0.08177430f, 0.04043685f, -0.43938953f, -1.39177370f, -0.85978806f, -0.06003465f, 
    0.78329700f, 0.04667252f, -0.11994645f, -0.19938955f, -0.31079024f, -0.78212398f, -1.08383656f, -0.61646873f, 
    -0.20641577f, -1.21341348f, -0.34921145f, -0.01941294f, -0.05597739f, -0.13925007f, 0.42309234f, 0.52735025f, 
    1.26718748f, -0.88846928f, 1.08341229f, -0.35079691f, 0.42034578f, 0.44548553f, -0.34597319f, 0.94313347f, 
    0.72673261f, 0.89030278f, 0.50594985f, 0.53519714f, 0.51939344f, 0.00997941f, 0.18579185f, -0.58050203f, 
    1.38199544f, -0.18484384f, -0.89399904f, -0.66901511f, -0.03795635f, 0.06194908f, -0.05749284f, 0.36221138f, 
    0.90275198f, 1.26418602f, -0.46248010f, -1.01353836f, 0.98332888f, 0.10213291f, 0.28551415f, 0.29436097f, 
    0.42567778f, -0.31072479f, 0.11334498f, 1.52373552f, 0.70677078f, 0.74495399f, 0.47038704f, -0.73945624f, 
    -0.26819327f, -0.42911768f, 0.39907679f, -0.74193096f, -1.11773288f, -0.87171203f, 0.81509757f, -0.16125749f, 
    0.55628908f, -0.21583030f, 0.21612893f, 0.30908296f, 1.42248261f, 0.56905502f, -0.29934457f, -0.48080596f, 
    -0.20344317f, -0.80427641f, -0.16452144f, -0.42663279f, -0.36223871f, 0.08844814f, -1.00072336f, 1.07709742f, 
    -0.66661215f, -0.92446429f, -0.34067824f, 0.85947877f, 0.18844125f, 0.34665838f, 0.33234912f, -0.49181324f, 
    -0.60500795f, 0.70079666f, -0.04528129f, -1.11851275f, 0.02492048f, -0.52538270f, -0.62343478f, 0.37085971f, 
    1.30680811f, -1.21020293f, -0.78991777f, -0.64069074f, 0.92501992f, -0.29885480f, -0.34061736f, 0.09397307f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.00489142f, 0.62815183f, 0.20662509f, 0.05675982f, -0.06798987f, 0.04846890f, 0.11052073f, 0.14718024f, 
    0.30027542f, 0.28984749f, 0.30787981f, -0.04699837f, 0.21747215f, 0.21329992f, 0.33686677f, 0.17166193f, 
    -0.04072035f, 0.25786981f, -0.07080878f, 0.27748802f, 0.36661133f, 0.37716657f, 0.11620619f, 0.46024173f, 
    0.23338896f, 0.21323247f, 0.17673825f, 0.36962247f, -0.12774259f, 0.35592791f, 0.24729030f, 0.05207643f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.26551548f, -0.10972328f, 0.09933436f, 0.17054296f, -0.62003303f, 0.00868668f, -0.06478705f, 0.03799078f, 
    -0.00429596f, -0.01558557f, -0.16910386f, 0.14023040f, -0.09606902f, 0.10722597f, 0.03348054f, 0.05012896f, 
    -0.04784225f, 0.06376489f, -0.03065565f, 0.08148482f, -0.04809962f, -0.47068611f, 0.27124545f, 0.23356265f, 
    -0.03709600f, -0.03750782f, 0.00958769f, 0.07546248f, 0.01196036f, -0.01986348f, -0.03517265f, -0.15571408f, 
    0.00140056f, -0.02875127f, 0.04419813f, -0.00727164f, -0.08554411f, -0.02885000f, 0.07853524f, -0.05473468f, 
    -0.30166978f, 0.00454859f, 0.03265722f, -0.02835459f, 0.32066727f, 0.01988787f, -0.08079459f, -0.01309287f, 
    -0.14782111f, -0.00535820f, -0.02639877f, -0.17895892f, 0.11275090f, 0.02780844f, 0.13123381f, -0.15065011f, 
    -0.01263632f, -0.09570215f, -0.09647667f, -0.12023934f, 0.13242446f, -0.17270923f, 0.07864397f, 0.12078431f, 
    -0.38658312f, -0.12190542f, 0.03583922f, -0.06765757f, -0.06215310f, 0.03787068f, 0.05499315f, 0.11126906f, 
    0.09449751f, -0.16903920f, 0.01498132f, 0.01605293f, -0.08218592f, -0.10804722f, -0.04903397f, -0.01311676f, 
    0.36522108f, -0.05246583f, 0.15313326f, -0.31184515f, -0.07710946f, -0.00375200f, -0.13701281f, -0.06861896f, 
    0.06256822f, 0.07509685f, -0.07271095f, -0.12922229f, -0.12537855f, 0.16041735f, -0.06533563f, 0.06936024f, 
    0.01259906f, 0.00740370f, 0.09472938f, 0.08063894f, 0.12983380f, -0.19294639f, 0.06353284f, 0.03100031f, 
    0.48753867f, -0.25768200f, -0.05294095f, 0.00669193f, 0.12509947f, -0.05452986f, 0.09997188f, 0.12536369f, 
    -0.06419171f, -0.02494971f, -0.18575990f, 0.12864941f, 0.00583905f, 0.11819357f, -0.15305345f, 0.03892246f, 
    0.47971332f, -0.15541042f, -0.03041085f, -0.14520237f, -0.18017805f, -0.06501057f, 0.03684939f, -0.07793351f, 
    0.08666226f, -0.08070482f, 0.13254745f, 0.05666113f, 0.00903993f, 0.06253509f, 0.18267269f, 0.14368851f, 
    0.18413660f, -0.03345218f, 0.09895455f, -0.16302198f, 0.11080561f, 0.09688575f, -0.02771390f, -0.14374743f, 
    0.28932771f, -0.19797249f, -0.11548581f, -0.10149033f, -0.00907595f, 0.07911143f, -0.01652021f, -0.01581684f, 
    -0.00866253f, -0.18880604f, 0.02274711f, 0.05160116f, 0.07288128f, -0.03470911f, 0.02210415f, 0.02381310f, 
    -0.06963195f, -0.65873027f, 0.16266108f, 0.13222277f, -0.26999113f, 0.07196514f, -0.09606554f, 0.10729279f, 
    -0.04488770f, 0.00337697f, 0.01460441f, -0.04471720f, -0.03298815f, 0.02432168f, 0.00428711f, -0.13638631f, 
    -0.10192907f, -0.02579501f, -0.14355302f, -0.08554643f, 0.15407707f, 0.17795989f, 0.13519126f, -0.24062930f, 
    0.15497942f, -0.04390213f, 0.06324278f, 0.12225577f, -0.00073551f, -0.14258537f, -0.04883912f, 0.03959744f, 
    -0.11257502f, -0.13038796f, 0.12760350f, 0.03577580f, 0.11283110f, -0.01783241f, -0.01324739f, -0.01881657f, 
    -0.09063870f, -0.03831355f, -0.02245438f, 0.05607342f, -0.11408646f, 0.03820091f, 0.09280781f, 0.07502486f, 
    0.06080140f, -0.07926288f, 0.04816142f, -0.03234792f, 0.04992209f, 0.01567677f, 0.08280131f, -0.02492071f, 
    -0.05695645f, -0.00559586f, 0.01696554f, 0.03435738f, 0.10186058f, -0.05469695f, -0.08845565f, 0.19185692f, 
    -0.03685394f, -0.12430779f, -0.10054912f, -0.16388270f, -0.06191487f, -0.06107246f, 0.04144688f, 0.11761822f, 
    -0.00533507f, -0.04529491f, 0.05194547f, 0.05016314f, -0.01957073f, -0.07750279f, 0.08405680f, -0.14800456f, 
    -0.14016749f, 0.06988750f, 0.05699110f, 0.11858094f, 0.14333682f, -0.08870139f, -0.19120203f, 0.03806611f, 
    -0.04977158f, 0.04411501f, 0.01465447f, -0.05734961f, 0.08228650f, -0.01269772f, -0.11239740f, 0.04332807f, 
    -0.03592091f, -0.13875599f, -0.13219805f, 0.04580255f, 0.51818061f, -0.04311792f, 0.05448373f, -0.16329633f, 
    0.14249839f, -0.03566517f, -0.07559261f, 0.04888295f, -0.17157964f, 0.09198474f, 0.09827844f, 0.04743925f, 
    -0.08945437f, 0.10651471f, 0.02706918f, -0.01103059f, -0.07865991f, 0.09575015f, -0.10896829f, -0.06445304f, 
    -0.22832154f, -0.17125252f, 0.06167564f, -0.06201315f, -0.07071823f, 0.00687496f, 0.03027724f, 0.06514589f, 
    -0.08437972f, 0.08073251f, 0.09639245f, -0.05214950f, 0.02348084f, -0.07940730f, 0.11340119f, -0.07488785f, 
    -0.01990233f, 0.02732649f, -0.07594469f, -0.07389678f, 0.20973589f, 0.21676777f, 0.43249163f, -0.16300747f, 
    -0.34193209f, 0.07894193f, 0.06832520f, 0.02387587f, 0.13120401f, -0.06985128f, -0.01236952f, -0.02961203f, 
    -0.02644388f, 0.05148065f, -0.00653297f, 0.08123293f, 0.08618002f, 0.09145187f, 0.06126168f, -0.03625120f, 
    -0.27337015f, -0.03644609f, 0.28146043f, -0.22821429f, 0.14188963f, -0.00524195f, -0.08784734f, 0.01943426f, 
    -0.11104690f, 0.10290480f, -0.12012656f, 0.09590520f, -0.06934366f, 0.05716396f, -0.01578722f, -0.15122259f, 
    0.09940606f, 0.14318997f, 0.00471175f, -0.02850069f, 0.29075262f, -0.16089292f, 0.07664802f, 0.00646710f, 
    -0.21109974f, -0.07115819f, -0.07624997f, 0.03933984f, 0.02085430f, 0.00625964f, -0.14589833f, 0.11378178f, 
    -0.11393138f, 0.02833595f, 0.10360209f, -0.04786872f, -0.00592095f, 0.04904771f, 0.00889195f, 0.10247380f, 
    -0.42042130f, 0.47968146f, -0.04938549f, -0.29720688f, -0.03011421f, 0.04372671f, 0.05258092f, -0.02212726f, 
    0.06001433f, -0.02479407f, -0.06166581f, -0.04533337f, -0.01898044f, 0.01157046f, -0.05987278f, 0.04145512f, 
    0.08575197f, -0.04247740f, 0.00616626f, -0.01195409f, -0.48015943f, 0.29916745f, -0.17193399f, -0.01791742f, 
    -0.47968879f, 0.00828379f, 0.03713563f, -0.11239708f, 0.07597762f, -0.01633364f, 0.11257240f, -0.02186319f, 
    -0.06193207f, 0.03020784f, 0.01296724f, 0.02060504f, -0.20530599f, -0.01154016f, 0.14327148f, -0.03470059f, 
    -0.17341851f, 0.15182483f, -0.15388823f, -0.14892918f, -0.45191815f, 0.05160286f, -0.00185783f, 0.08087510f, 
    -0.06421064f, 0.00321115f, 0.00831044f, 0.00949860f, -0.03378857f, -0.04852796f, 0.00826667f, -0.08786731f, 
    -0.02652437f, 0.08683277f, -0.02556295f, 0.08608656f, -0.23839200f, -0.47279218f, -0.14367948f, 0.09584540f, 
    -0.21045440f, 0.01962971f, -0.06163535f, -0.05262579f, 0.04375578f, 0.06088315f, -0.09951006f, -0.08497852f, 
    -0.11314047f, -0.04926557f, 0.00423499f, 0.11595827f, -0.00901296f, 0.08660588f, -0.04514471f, -0.01972771f, 
    0.15003611f, 0.05227532f, -0.02672091f, 0.06241544f, -0.08454062f, -0.04992026f, -0.03847128f, -0.06085930f, 
    0.02373118f, 0.01652242f, -0.03797311f, 0.04183851f, 0.02923728f, 0.00340716f, 0.01934959f, -0.04382960f, 
    -0.10912707f, -0.00473881f, -0.08437864f, -0.07098525f, 0.08092660f, -0.01340348f, -0.02909666f, -0.04519466f, 
    0.11570074f, -0.16818322f, -0.10726194f, -0.00988859f, -0.01973122f, -0.04619743f, 0.00591447f, 0.03538325f, 
    -0.00288277f, 0.00708048f, 0.02843831f, 0.05025910f, -0.03834471f, -0.02959435f, -0.01275602f, 0.02462010f, 
    -0.24106742f, -0.16084519f, 0.07186920f, 0.00881374f, 0.03325149f, -0.01718540f, 0.00973781f, 0.05218771f, 
    0.15759529f, 0.07433376f, -0.03591568f, 0.03013974f, -0.02174358f, 0.04195515f, 0.00499866f, 0.00923960f, 
    -0.11066332f, -0.15739311f, 0.08580267f, -0.07157036f, 0.24717112f, -0.13251773f, -0.00311921f, -0.04441463f, 
    0.21540380f, -0.07674537f, 0.00848542f, -0.02526283f, 0.01551720f, -0.09696815f, -0.11522596f, -0.02537398f, 
    0.06547902f, -0.02949781f, 0.03261766f, 0.04101980f, -0.03811977f, 0.01531171f, -0.01357321f, 0.06801933f, 
    0.14338234f, 0.05963876f, 0.11364842f, -0.08805958f, 0.23859695f, -0.21913654f, -0.19002917f, 0.03208645f, 
    -0.09971543f, 0.01545758f, 0.02692184f, -0.03160692f, -0.12142046f, 0.08584137f, 0.00262075f, -0.02242292f, 
    0.00395532f, 0.04062239f, -0.21984914f, 0.04898700f, 0.16295613f, -0.04740196f, -0.21434470f, -0.13834369f, 
    -0.40237841f, -0.01203959f, 0.02418114f, 0.00188368f, 0.03470405f, -0.07632351f, 0.02735851f, -0.00820316f, 
    -0.06640062f, 0.04823598f, -0.01947385f, 0.11675572f, -0.11038912f, 0.09537324f, 0.01039436f, 0.05591407f, 
    0.07771155f, 0.15112627f, 0.14495742f, 0.07380879f, 0.30221820f, -0.09682159f, -0.01218605f, -0.07731503f, 
    0.11354990f, 0.04394621f, 0.01175085f, -0.00195725f, 0.07434323f, -0.12237128f, -0.03484276f, -0.01552676f, 
    0.08873834f, 0.00277572f, 0.13987392f, -0.10675001f, 0.11765145f, -0.29530105f, -0.09642494f, 0.09187175f, 
    -0.28898337f, -0.05080717f, 0.04127157f, -0.00319509f, -0.03177080f, -0.02486491f, -0.15138663f, 0.01662889f, 
    -0.13257772f, -0.04658790f, -0.01211859f, -0.03866462f, 0.09431085f, 0.08764986f, 0.09832338f, -0.00572159f, 
    -0.03875951f, -0.20835297f, 0.22923405f, 0.08535555f, 0.08045628f, 0.06478706f, -0.07118985f, 0.08278564f, 
    -0.03683903f, -0.11448853f, 0.07554681f, 0.01936311f, 0.01351027f, 0.00570317f, 0.03666925f, -0.06384934f, 
    0.01640106f, -0.01068688f, -0.13833991f, -0.07065746f, 0.11345482f, 0.00136471f, 0.25853977f, -0.18309678f, 
    0.22132066f, -0.16162863f, -0.11424450f, -0.08628295f, 0.02663765f, -0.02210710f, -0.05456409f, 0.06766911f, 
    0.07792888f, -0.06080325f, 0.04577027f, -0.00339502f, 0.07037409f, -0.11478627f, -0.12184999f, -0.04463932f, 
    0.37922102f, 0.08675569f, 0.13996689f, -0.09679200f, -0.30942154f, -0.06720971f, 0.12849888f, 0.06271557f, 
    0.01503019f, 0.14005172f, 0.15279189f, -0.10496214f, 0.15831718f, -0.18869133f, 0.04425720f, -0.02653205f, 
    0.03238441f, -0.06347927f, 0.06597064f, 0.11192866f, 0.08375798f, -0.16772398f, -0.10440759f, -0.18090738f, 
    -0.00719801f, -0.03142403f, 0.03196330f, 0.04437263f, 0.03007597f, 0.01989642f, -0.01865527f, 0.10849747f, 
    0.04252534f, 0.12483507f, 0.03840602f, -0.08971067f, -0.12988278f, -0.19253305f, -0.09524906f, -0.04149443f, 
    0.02730156f, 0.18604858f, -0.21663451f, -0.09376333f, 0.03198363f, -0.11972272f, 0.03476389f, -0.05346365f, 
    0.12735508f, -0.02462985f, 0.10995010f, 0.08875748f, -0.04883402f, 0.03804374f, -0.05218911f, 0.05396335f, 
    -0.04401362f, 0.12925656f, -0.02555759f, 0.07075328f, 0.14534004f, -0.46743992f, 0.04560621f, -0.00478181f, 
    0.22132137f, -0.11254282f, 0.04674593f, 0.04038216f, 0.01851499f, -0.06267583f, -0.09720774f, -0.01616223f, 
    -0.08570651f, 0.03198188f, -0.18250598f, 0.09078968f, -0.03886184f, 0.04979584f, 0.00983118f, -0.00497424f, 
    0.10694938f, 0.00196224f, 0.10670519f, 0.13119894f, 0.18747757f, 0.00047788f, -0.04745138f, 0.08919746f, 
    -0.03940368f, -0.07432169f, 0.07576007f, -0.01764883f, 0.13318694f, 0.04028194f, 0.10667089f, 0.13292266f, 
    -0.05370837f, -0.22595029f, -0.07058781f, -0.03475124f, 0.12164965f, -0.44941518f, 0.20103897f, -0.11050328f, 
    0.02443393f, -0.05553790f, -0.02806577f, -0.03746260f, 0.02800881f, -0.08970778f, -0.21537374f, -0.09987798f, 
    -0.00896406f, -0.05818386f, -0.01590204f, -0.25984690f, 0.04403159f, -0.23994045f, 0.16642277f, -0.11882189f, 
    -0.24257576f, 0.12105722f, -0.34111723f, 0.01508052f, -0.05740389f, 0.16540073f, -0.03212231f, 0.00888831f, 
    -0.05037723f, 0.06611364f, -0.03905991f, -0.07178880f, -0.04353483f, -0.09237741f, -0.09592640f, 0.19250669f, 
    0.09966338f, -0.14607736f, 0.10600115f, -0.04781536f, 0.16315559f, 0.28613722f, -0.30465561f, 0.01696314f, 
    0.12080032f, 0.13080819f, 0.00572721f, 0.08544654f, 0.04852072f, -0.01342105f, -0.08405232f, -0.07626251f, 
    -0.01584341f, 0.15811774f, -0.10347594f, 0.03932214f, 0.02772825f, 0.03316074f, -0.11330315f, -0.04585345f, 
    0.02222068f, -0.28555945f, -0.01348991f, -0.23351707f, -0.09338217f, -0.18570282f, 0.10924368f, 0.09222164f, 
    0.04618769f, 0.06064128f, -0.12009802f, -0.19903840f, 0.12561077f, 0.14698446f, -0.05302602f, -0.04525755f, 
    0.08029746f, -0.06063513f, -0.11960161f, 0.01317832f, 0.03965126f, -0.09191695f, -0.01449379f, 0.03906270f, 
    0.08505534f, -0.02260942f, 0.01237559f, -0.08583688f, -0.07857873f, 0.01216978f, 0.15239532f, 0.00657997f, 
    -0.13178766f, 0.08596499f, 0.04436900f, -0.05160404f, -0.03314947f, 0.05942040f, 0.00683863f, 0.09260099f, 
    -0.28678688f, 0.26404276f, -0.03998705f, -0.11620478f, -0.01565160f, -0.10237698f, -0.03810623f, -0.03867705f, 
    -0.05694217f, -0.02205678f, -0.00489906f, -0.04707277f, -0.02242411f, -0.13200560f, -0.06619606f, -0.03802452f, 
    0.00623236f, 0.07746293f, -0.10001529f, 0.09680805f, -0.22434731f, -0.11927576f, -0.16509451f, 0.06518184f, 
    -0.24263069f, 0.05782827f, -0.01825129f, 0.04284049f, 0.05493632f, -0.03626588f, 0.00218368f, 0.03624842f, 
    0.14295678f, 0.04518494f, -0.10448007f, -0.05970387f, 0.06244501f, -0.10130440f, -0.12210269f, 0.03477268f, 
    0.35812929f, 0.20740244f, 0.01772894f, 0.06095182f, 0.19265826f, -0.02453909f, -0.03112053f, 0.00309114f, 
    -0.09531242f, 0.12221422f, -0.01262820f, 0.05651945f, -0.00945402f, -0.03314730f, -0.01984353f, 0.06239501f, 
    0.00797764f, 0.12425455f, 0.08774947f, 0.09707824f, -0.56836867f, -0.30768889f, -0.20739010f, -0.12906751f, 
    0.21487385f, 0.06070009f, -0.11960335f, 0.03262703f, -0.10255844f, 0.01089639f, 0.07139811f, 0.02064922f, 
    -0.02662317f, -0.07942962f, 0.09157394f, -0.01987384f, -0.03348166f, -0.18838039f, -0.11909877f, -0.10652214f, 
    0.11526492f, -0.17730583f, -0.27483097f, 0.03982808f, 0.02534400f, -0.03952817f, 0.00183683f, -0.04545946f, 
    0.08688284f, 0.15182143f, -0.02761396f, -0.03099615f, 0.05231204f, 0.04891679f, -0.01006465f, 0.07476113f, 
    0.11858450f, 0.02647763f, 0.01668922f, 0.19175005f, -0.18581830f, -0.07740512f, -0.29433572f, -0.01843725f, 
    -0.08908153f, -0.03961897f, -0.01666592f, -0.04033278f, -0.05394799f, 0.05265492f, 0.05973945f, 0.10568559f, 
    -0.07861179f, -0.02993287f, 0.00629839f, 0.09683059f, 0.00498762f, 0.00681945f, -0.08260188f, 0.07152945f, 
    0.00359920f, 0.19960433f, -0.03001661f, -0.16983019f, 0.20034879f, -0.12548624f, 0.01561569f, 0.05340327f, 
    -0.15918624f, 0.15467003f, 0.21607280f, -0.07294819f, 0.11346455f, -0.02038335f, 0.09139950f, -0.11913932f, 
    0.04007909f, -0.05127530f, -0.12285207f, 0.06592511f, -0.02899455f, 0.14995077f, 0.17987351f, -0.01075239f, 
    -0.03323182f, -0.04596838f, -0.02731667f, 0.02318875f, 0.03747979f, 0.12078425f, 0.21429007f, 0.00503979f, 
    0.14160475f, -0.09476724f, 0.04057472f, 0.00798771f, -0.01518468f, 0.01001281f, 0.09449509f, 0.11087775f, 
    0.36389950f, -0.37969270f, 0.08670695f, -0.16421275f, -0.14253724f, -0.15254182f, -0.08038180f, -0.15782332f, 
    0.05320369f, -0.11539827f, 0.11265265f, -0.01998598f, -0.07494971f, 0.11569253f, 0.13858736f, 0.01157201f, 
    -0.12059440f, 0.04457803f, 0.00628097f, 0.13195604f, 0.37999597f, 0.04152919f, -0.09215506f, 0.08174860f, 
    -0.26508799f, -0.07660552f, -0.04677225f, -0.00577085f, 0.08903781f, 0.08564711f, 0.01782143f, -0.08431424f, 
    0.00070897f, 0.01057595f, -0.05380670f, 0.03105805f, 0.03739544f, 0.01150977f, -0.06145772f, 0.03633618f, 
    0.35319462f, -0.21574119f, -0.26464954f, 0.10966400f, -0.26274675f, 0.05308459f, 0.01040687f, -0.02839613f, 
    0.03401969f, 0.15096900f, 0.09187978f, 0.02864609f, -0.09079231f, 0.01133295f, -0.03320532f, 0.05169923f, 
    0.11416736f, -0.09897389f, -0.08964185f, -0.10624512f, 0.02350841f, 0.18053664f, 0.01489808f, -0.20075670f, 
    -0.11705154f, 0.01255417f, -0.01697493f, 0.07077587f, 0.09507572f, 0.04274558f, -0.01309378f, -0.00302705f, 
    0.10251273f, 0.18354371f, -0.11284249f, -0.04104802f, 0.09068028f, -0.31023929f, -0.21002880f, -0.23515332f, 
    -0.07787754f, 0.17009847f, 0.06914004f, 0.11518373f, 0.43875867f, -0.09288010f, -0.05916246f, 0.01078893f, 
    0.02849132f, -0.03299884f, 0.12136569f, -0.06860928f, -0.02889274f, -0.04148779f, -0.15087311f, -0.16482735f, 
    0.06642616f, 0.08464951f, -0.09028724f, 0.02728186f, 0.23650321f, 0.24988684f, 0.12018225f, 0.09260752f, 
    0.18667381f, 0.03080940f, -0.00538596f, 0.04113752f, -0.00048921f, 0.12908939f, -0.06500767f, -0.01485051f, 
    0.02667821f, -0.01535313f, -0.09146362f, -0.08485213f, 0.08790779f, 0.07820584f, 0.07285762f, 0.08322555f, 
    0.24408020f, -0.41210321f, 0.11464616f, -0.05426756f, -0.10136609f, 0.01701966f, -0.09754620f, -0.00139161f, 
    0.10490420f, -0.03372321f, -0.03255026f, 0.01646579f, -0.03318311f, -0.10083842f, 0.07072067f, 0.00958133f, 
    -0.12684846f, 0.11755296f, -0.10300688f, -0.12842654f, 0.20790468f, -0.67841911f, 0.17328955f, -0.14343493f, 
    -0.10054743f, 0.04308617f, -0.04152675f, -0.03398853f, -0.03664069f, 0.03367769f, 0.00721326f, -0.12506990f, 
    -0.04632652f, 0.14862657f, -0.08068769f, 0.02922129f, 0.15870549f, -0.13778523f, 0.02873309f, 0.02504773f, 
    0.07228992f, 0.03182911f, 0.20755666f, 0.00206757f, 0.33988091f, -0.00768865f, -0.01423684f, 0.01060524f, 
    -0.02956478f, -0.06250789f, -0.07481162f, 0.04965452f, 0.18158342f, 0.00707629f, 0.07116093f, 0.08966424f, 
    -0.00895679f, -0.00262943f, 0.02965636f, -0.03033607f, 0.12234477f, 0.11036821f, -0.03566873f, 0.09157817f, 
    -0.17583346f, -0.05320756f, 0.03736187f, 0.01598289f, 0.02206188f, 0.17153710f, 0.12266148f, -0.09658691f, 
    0.10515986f, 0.07495267f, -0.02351400f, -0.00017477f, 0.15626897f, -0.08153410f, 0.00623144f, -0.00688580f, 
    0.42387143f, -0.33231729f, -0.07929438f, -0.21494414f, -0.11862110f, -0.04904967f, -0.16322586f, 0.10733619f, 
    0.02630158f, -0.11476826f, -0.05324236f, -0.00038650f, -0.06361578f, 0.05404690f, -0.15568052f, -0.15904386f, 
    -0.04041560f, -0.16951033f, -0.05669120f, -0.04667611f, -0.65868652f, 0.02728103f, 0.02054256f, -0.08998574f, 
    -0.31776398f, 0.03747975f, 0.08307955f, -0.05268243f, 0.16852491f, -0.03532053f, 0.06832367f, 0.12482366f, 
    0.10875046f, 0.00879961f, 0.03672969f, 0.03261469f, -0.05246082f, -0.15371579f, 0.06841969f, -0.11882956f, 
    0.06043633f, -0.20545778f, -0.22669174f, -0.37037417f, -0.10841827f, 0.17529988f, -0.10076234f, -0.04282577f, 
    -0.00797245f, -0.03004228f, -0.09547366f, -0.00020474f, -0.10958506f, -0.13499562f, 0.01533743f, -0.09157728f, 
    0.00112426f, -0.11832092f, 0.12619852f, 0.05448323f, 0.09181292f, -0.26316369f, -0.04226894f, -0.33595347f, 
    0.11175752f, -0.07725562f, -0.08531041f, -0.02605444f, 0.08091264f, -0.21531658f, 0.05263660f, -0.13604456f, 
    -0.12138893f, 0.06654213f, -0.08157876f, -0.11627318f, -0.04206024f, 0.06681889f, 0.08792745f, -0.19228430f, 
    -0.67238432f, 0.22794244f, 0.04618671f, -0.11302158f, 0.03104818f, 0.03006603f, 0.04060512f, -0.09053669f, 
    0.03788729f, -0.05389153f, 0.06766336f, -0.06370541f, 0.03880458f, -0.15198347f, 0.11317235f, -0.05707181f, 
    0.05745719f, -0.04435552f, -0.02614692f, -0.03471523f, -0.25295576f, -0.36574835f, -0.13505498f, -0.23526275f, 
    -0.44135472f, 0.03502407f, -0.02378256f, 0.01816591f, -0.02279918f, -0.01106556f, 0.04835480f, 0.00035794f, 
    -0.01915490f, -0.07011700f, -0.01997780f, 0.04875662f, 0.00471721f, 0.13278283f, 0.08384819f, -0.01054931f, 
    0.18286616f, 0.10174774f, 0.00120774f, -0.09890166f, -0.08733849f, 0.01075404f, 0.08676536f, 0.11749824f, 
    -0.13850848f, -0.02884404f, -0.06418618f, -0.06393880f, 0.10668943f, 0.02614085f, -0.07585704f, -0.00015403f, 
    -0.07667986f, -0.06495585f, 0.01583409f, -0.04675194f, 0.43473804f, 0.07412495f, -0.12094603f, -0.12706928f, 
    -0.13408829f, -0.10078651f, -0.05582529f, 0.05400566f, 0.02709383f, 0.01477662f, 0.00835552f, 0.00627652f, 
    -0.04186454f, 0.00617896f, -0.06514925f, 0.03275332f, -0.02558516f, -0.04770198f, 0.01126081f, 0.08022844f, 
    -0.54592419f, 0.26457664f, 0.05683146f, -0.21997589f, 0.10228956f, 0.08001414f, 0.12975751f, 0.03643076f, 
    0.00865976f, -0.02276286f, -0.05855170f, 0.16975148f, -0.06443131f, -0.10417335f, -0.01835071f, 0.02865669f, 
    0.07168586f, 0.03639570f, -0.10950889f, 0.03702864f, 0.36950159f, -0.49754411f, 0.04600811f, -0.24345325f, 
    -0.13573010f, 0.13662836f, -0.17301926f, 0.07631014f, 0.04818850f, 0.11259042f, -0.05139999f, 0.01161704f, 
    0.10896327f, 0.02684757f, -0.06965843f, -0.04923990f, -0.07115787f, 0.08346296f, -0.08677667f, 0.00465023f, 
    0.29313001f, -0.14974491f, 0.22156440f, -0.02606770f, 0.11121069f, 0.02633169f, -0.13853033f, -0.11487591f, 
    0.14087936f, 0.09023999f, -0.01779344f, -0.04962808f, -0.03780084f, 0.02870915f, 0.02146862f, 0.10775971f, 
    -0.15092136f, 0.00999553f, 0.01767319f, 0.00216347f, -0.05042098f, 0.05035288f, -0.24966329f, -0.09209228f, 
    0.05040395f, 0.06832346f, 0.00937327f, 0.02675953f, -0.07955232f, -0.01135829f, -0.15094770f, 0.04350022f, 
    -0.08840553f, -0.02118795f, -0.02100706f, -0.04599921f, 0.04293796f, -0.03231980f, -0.13662836f, 0.04684916f, 
    0.10277613f, -0.36176232f, -0.12513153f, -0.32200080f, -0.24455178f, -0.16219428f, 0.05886219f, -0.09449515f, 
    0.05516813f, -0.05110416f, 0.06800524f, -0.03011755f, -0.07300998f, -0.01086901f, 0.00467663f, -0.06852639f, 
    0.06709275f, 0.14812101f, -0.04909012f, -0.09600233f, 0.12500419f, 0.07593746f, 0.11494354f, 0.01084667f, 
    0.05902594f, -0.03197052f, -0.09790067f, 0.03844787f, 0.01956182f, 0.08292682f, -0.00436456f, -0.16473341f, 
    0.03855558f, 0.01980956f, -0.09174664f, -0.06771095f, -0.11295457f, 0.00785469f, -0.12328599f, -0.06800015f, 
    0.30494145f, 0.06886495f, 0.05106408f, -0.02831117f, 0.02918860f, -0.11844063f, 0.01831023f, 0.01346631f, 
    0.02508425f, 0.01679894f, 0.04128888f, -0.02129923f, -0.02785838f, 0.01220529f, -0.00886265f, -0.04367922f, 
    0.08432712f, -0.07244398f, 0.01625663f, -0.09751206f, 0.13593237f, 0.23999552f, 0.04632230f, 0.01371505f, 
    -0.03687933f, -0.02595151f, 0.18291745f, 0.00083330f, -0.06642808f, -0.00023097f, -0.00897780f, -0.08457979f, 
    0.00920780f, -0.02096266f, -0.08548842f, 0.11377549f, 0.14448951f, -0.12482763f, 0.04270112f, -0.07337388f, 
    0.06455880f, 0.01541087f, -0.01796442f, -0.07691155f, 0.03555180f, -0.05780765f, -0.01966156f, -0.00183786f, 
    -0.00147882f, 0.02719915f, -0.02101796f, 0.05971419f, 0.03631772f, -0.01765861f, -0.03151075f, -0.03552492f, 
    -0.01764623f, -0.09785549f, -0.00017371f, 0.11398034f, 0.16923314f, -0.14768381f, -0.10951273f, -0.25439647f, 
    -0.07170162f, 0.04854727f, -0.05376361f, 0.05539268f, -0.05465550f, 0.01736536f, -0.02960289f, -0.02635019f, 
    -0.07020730f, -0.00109641f, 0.01929260f, -0.01026088f, -0.02168038f, 0.05978911f, 0.04962166f, -0.06756081f, 
    0.29224724f, -0.13615224f, 0.01140604f, -0.20512950f, -0.10065836f, -0.10104270f, -0.04671630f, 0.01596362f, 
    -0.04081282f, -0.00916278f, 0.03068777f, -0.05260707f, 0.09208491f, 0.00683098f, -0.08514860f, -0.00713004f, 
    -0.00227554f, -0.02827967f, -0.13741499f, -0.00308919f, 0.48397189f, -0.20648101f, 0.17428949f, -0.05683122f, 
    0.26992589f, -0.17483206f, -0.09340288f, -0.06018904f, 0.04100691f, 0.13045906f, 0.05619518f, -0.02324379f, 
    -0.06972162f, -0.09222289f, -0.06429482f, 0.02085160f, -0.09512818f, -0.02756716f, -0.02846719f, -0.02984551f, 
    0.21988589f, 0.16085054f, -0.10595942f, -0.11715788f, -0.19446322f, 0.08999368f, 0.12789853f, 0.02977383f, 
    -0.17175478f, -0.09484688f, 0.12247033f, 0.06373087f, -0.04516468f, -0.09392837f, 0.08870962f, -0.13158631f, 
    -0.09297992f, -0.07569809f, -0.04309896f, 0.00137590f, -0.51903260f, 0.16851367f, 0.13584378f, -0.02000434f, 
    0.12604694f, 0.08530533f, 0.09557029f, -0.01104386f, 0.09674370f, -0.06109089f, -0.08293497f, -0.04264751f, 
    0.01159419f, -0.00041895f, 0.08194836f, -0.04432363f, 0.03233390f, -0.03268683f, -0.05864023f, 0.03989634f, 
    0.39860722f, 0.23581851f, -0.10068452f, 0.49876738f, -0.03326140f, -0.01564491f, -0.14048526f, -0.00245314f, 
    0.12588094f, 0.15189503f, 0.03163726f, 0.03327563f, 0.11994510f, 0.07370161f, -0.07513918f, -0.07115554f, 
    -0.14773500f, -0.16748141f, -0.04470820f, -0.04769240f, 0.50340551f, -0.11540189f, 0.05536748f, 0.33052608f, 
    0.10936636f, -0.21505968f, 0.09501999f, -0.08010851f, 0.04049002f, 0.13626926f, 0.03173175f, -0.00926994f, 
    0.03983460f, -0.04301824f, -0.01770630f, 0.05079266f, -0.16514440f, -0.07552345f, 0.08064257f, 0.02925487f, 
    0.19220686f, -0.38776097f, 0.07066216f, 0.09178009f, 0.17160426f, -0.22436447f, 0.03110889f, -0.16818215f, 
    0.02755830f, 0.01333737f, 0.11084763f, -0.09188633f, 0.01046647f, 0.05903897f, -0.01326154f, -0.03406397f, 
    -0.11651971f, 0.07588470f, -0.02651312f, 0.04081156f, -0.26757553f, -0.43607402f, -0.20657288f, -0.13299181f, 
    -0.43829095f, -0.01608153f, -0.02594195f, -0.16821890f, -0.05311435f, -0.07729948f, -0.01046076f, 0.04684255f, 
    0.02486242f, -0.01333942f, -0.00038252f, -0.01929323f, -0.06486312f, 0.09280090f, 0.05453687f, -0.03294129f, 
    0.19303636f, 0.26451573f, -0.10653409f, -0.07610157f, 0.08676574f, -0.00673763f, 0.11906883f, 0.08836851f, 
    -0.04115986f, -0.10626084f, -0.08293028f, -0.03680391f, 0.00285833f, -0.01466607f, -0.00638208f, 0.04092915f, 
    0.01021424f, -0.14702323f, 0.02615199f, -0.07385820f, -0.09665549f, 0.00393621f, 0.04257499f, -0.15997304f, 
    0.12509808f, 0.07900928f, -0.06777825f, 0.07871304f, 0.03915908f, 0.02964204f, 0.00691452f, 0.06254195f, 
    0.01390570f, -0.03016779f, 0.04566914f, -0.01313096f, -0.11761950f, -0.05388261f, -0.06229862f, -0.02377857f, 
    0.11190335f, 0.12919898f, -0.05532736f, -0.13307317f, -0.23886271f, 0.00366559f, 0.02521255f, 0.10911804f, 
    -0.04148228f, 0.04478374f, -0.00795676f, 0.00251695f, -0.02982565f, -0.09806482f, -0.08213498f, -0.03268614f, 
    -0.02603645f, -0.01780233f, 0.05513840f, -0.01323889f, -0.11611214f, 0.01172353f, 0.10669785f, 0.00074395f, 
    -0.08348524f, -0.02070842f, -0.12498386f, 0.04882026f, 0.04413126f, 0.04124346f, 0.02372450f, 0.00675924f, 
    0.04951853f, 0.03414062f, -0.02906970f, 0.06846540f, 0.01164323f, -0.02722494f, -0.02280488f, -0.06530880f, 
    0.21198727f, -0.09423678f, 0.12370221f, -0.03150976f, -0.09679124f, 0.03893359f, 0.09556524f, 0.13404855f, 
    -0.00347146f, 0.05698542f, 0.03317498f, 0.05225580f, -0.01494317f, 0.01987979f, -0.05986622f, -0.02664562f, 
    -0.12936080f, 0.01539719f, -0.15252115f, -0.02123580f, 0.01852785f, -0.02659590f, 0.14393242f, 0.10454981f, 
    0.20153736f, -0.12143489f, -0.05895309f, -0.16918065f, 0.07446380f, 0.01510615f, -0.06852983f, -0.07510370f, 
    -0.12133923f, -0.04607352f, 0.01146436f, -0.02460991f, -0.00822867f, 0.00114081f, 0.06384098f, 0.00436164f, 
    0.05683637f, 0.07450060f, -0.11673768f, -0.23406352f, 0.05787536f, 0.04939434f, -0.08638923f, 0.09973440f, 
    0.05813759f, 0.07107875f, -0.11215758f, 0.10616495f, 0.00237696f, -0.13903032f, -0.03062942f, 0.06496645f, 
    0.07472766f, 0.15781769f, 0.02453246f, -0.03430047f, 0.09668192f, -0.08377632f, -0.11705421f, 0.09098914f, 
    -0.14620212f, -0.14478673f, 0.11998095f, -0.06450193f, -0.06238839f, -0.02062742f, -0.04017827f, -0.10006336f, 
    0.02505176f, -0.09806702f, -0.05411000f, 0.04049852f, 0.04845703f, 0.05086216f, 0.03517408f, -0.08735026f, 
    -0.07745927f, -0.45781943f, -0.02335125f, -0.14344339f, -0.15721437f, 0.06042314f, 0.00223392f, 0.03686762f, 
    -0.02225354f, 0.04569490f, 0.02200378f, 0.01167506f, 0.01900027f, -0.00565397f, -0.08104334f, 0.07026511f, 
    -0.09537766f, -0.10915737f, -0.13843662f, -0.08867954f, -0.32580444f, -0.17796144f, -0.23869643f, -0.00648215f, 
    -0.25070953f, 0.00058356f, 0.05130397f, 0.13848422f, 0.05967313f, 0.10611062f, -0.01131707f, -0.01735708f, 
    0.04661929f, -0.09026862f, 0.01497941f, 0.02782719f, -0.00665016f, 0.09648649f, -0.02829527f, -0.05913387f, 
    0.06258067f, -0.15739581f, -0.30905065f, 0.08086287f, -0.06233180f, -0.05210755f, 0.07387724f, -0.05246103f, 
    -0.07874244f, -0.00324404f, 0.06671751f, 0.01110485f, -0.08523848f, 0.03339445f, 0.00329883f, -0.02514734f, 
    -0.01471986f, -0.03742914f, 0.14715499f, -0.00288440f, 0.18580703f, 0.23602554f, 0.25089094f, 0.08894467f, 
    0.03161234f, -0.01753734f, 0.00100132f, -0.03257416f, -0.06489868f, 0.06723813f, 0.03402949f, -0.00902865f, 
    -0.01560447f, -0.11359575f, -0.11465090f, -0.02017208f, 0.01033426f, 0.04545692f, 0.01938131f, 0.12104385f, 
    -0.41652510f, 0.03079234f, 0.10880183f, -0.07066748f, 0.05987420f, 0.03523447f, 0.09101719f, 0.00378988f, 
    0.03979139f, -0.02092040f, -0.01597032f, -0.00933924f, -0.07609327f, -0.01794471f, 0.02373489f, -0.00491522f, 
    0.10090564f, -0.22635029f, 0.12097526f, -0.06868101f, -0.11690718f, 0.15984552f, 0.19639258f, 0.18784225f, 
    0.07479445f, 0.12697107f, 0.06595828f, -0.04540676f, 0.01564173f, 0.00935907f, 0.00071198f, 0.05529073f, 
    -0.05615605f, 0.04677647f, -0.00553235f, -0.06552664f, -0.05704184f, -0.05277971f, -0.03216700f, 0.02946572f, 
    -0.08458336f, -0.60284072f, -0.30546665f, 0.22539207f, 0.12251607f, 0.16271813f, 0.08771344f, 0.11061735f, 
    -0.05188666f, -0.08512122f, -0.03274659f, -0.03736489f, -0.19402985f, -0.11068953f, -0.08263593f, 0.02587346f, 
    0.09833556f, 0.18984002f, -0.01592853f, 0.01118446f, -0.10295995f, 0.01193109f, -0.30051842f, 0.17447899f, 
    -0.04347426f, -0.00288227f, -0.07808501f, -0.03091219f, 0.02916458f, 0.01515268f, -0.08203167f, -0.06694589f, 
    0.01004257f, 0.03604846f, -0.03642093f, 0.01447409f, 0.01320104f, -0.00930966f, -0.07389872f, 0.09922276f, 
    0.15097296f, 0.16011883f, -0.21129888f, -0.12735389f, -0.04178261f, 0.01963072f, -0.16209261f, 0.05948154f, 
    0.02459948f, -0.11200941f, 0.03702390f, -0.08237048f, -0.06262591f, 0.08922119f, 0.00955603f, -0.14520527f, 
    -0.06848145f, 0.09952246f, -0.00007539f, -0.04771196f, -0.26967150f, -0.08311194f, -0.25304297f, 0.04919589f, 
    0.29921192f, 0.02354475f, 0.02661710f, -0.00392979f, -0.01542585f, 0.05948604f, -0.01483037f, 0.03449403f, 
    0.13909814f, 0.02789557f, -0.02040973f, 0.00568093f, 0.06223522f, -0.00477489f, 0.10298986f, 0.11496012f, 
    0.14054546f, 0.18436959f, 0.09341083f, 0.12315228f, -0.02993787f, -0.02606520f, 0.01901185f, -0.04438395f, 
    -0.10581492f, -0.05195430f, 0.04629277f, 0.05611207f, 0.02392628f, -0.00443467f, -0.04373838f, 0.07347919f, 
    -0.15573724f, 0.15304585f, -0.02758711f, 0.01499472f, -0.23508172f, 0.05964319f, -0.10484070f, -0.19483387f, 
    -0.24838665f, -0.12359104f, -0.13650663f, 0.07731919f, -0.04628917f, 0.00738360f, -0.10742068f, -0.03616777f, 
    0.06204160f, 0.00920212f, -0.06069781f, -0.03813624f, -0.06056508f, -0.08209340f, 0.05551397f, -0.00936107f, 
    -0.16557226f, 0.21638282f, 0.02521225f, 0.04109565f, -0.10410805f, 0.01817519f, -0.05838170f, -0.05097949f, 
    0.01682585f, -0.09660874f, -0.09414662f, -0.01987990f, -0.08158235f, 0.10303093f, 0.05127993f, 0.06783273f, 
    0.00841338f, -0.06277220f, 0.06355627f, -0.04804596f, -0.40844616f, 0.22241381f, -0.09449818f, 0.27141201f, 
    0.22393440f, 0.06452927f, 0.15314907f, 0.05898428f, -0.00433566f, 0.10922979f, -0.03936507f, -0.04202968f, 
    0.04967955f, -0.23778595f, -0.03402137f, -0.02286296f, 0.04646540f, -0.07064245f, 0.06689313f, -0.08072475f, 
    -0.40438312f, -0.60905242f, -0.23329894f, 0.01502641f, -0.13137588f, -0.14113912f, -0.11603432f, 0.01717058f, 
    -0.00767928f, -0.10286108f, -0.08738460f, -0.01893269f, -0.02383618f, -0.04633128f, 0.04265863f, 0.07462018f, 
    -0.07462451f, 0.03377074f, -0.00588594f, -0.02515297f, 0.62141556f, 0.30703098f, -0.00822547f, 0.12474956f, 
    0.04945526f, 0.05040987f, -0.00764032f, -0.02090516f, 0.09229822f, 0.04777464f, -0.09663945f, -0.12414058f, 
    -0.07602151f, 0.07934667f, 0.03620378f, -0.07440917f, -0.00051356f, 0.01259406f, 0.07934812f, 0.06025474f, 
    0.00296970f, 0.22622219f, 0.10259532f, 0.06205733f, 0.10754749f, -0.06840886f, -0.02321590f, 0.02919409f, 
    -0.02776556f, 0.05409349f, -0.06301158f, 0.01543510f, 0.05980715f, 0.02936000f, 0.07232337f, 0.05090834f, 
    0.06955244f, -0.00469966f, 0.02242400f, 0.05749906f, -0.33141011f, 0.07266092f, 0.04764299f, -0.03494385f, 
    -0.07722844f, -0.05088349f, -0.22311138f, -0.09294826f, 0.03736461f, -0.06551792f, 0.04930520f, -0.08312121f, 
    0.10068602f, -0.04363147f, 0.01521928f, -0.11246159f, -0.03485784f, -0.06390183f, 0.12527534f, 0.05861156f, 
    0.32591796f, -0.17999265f, 0.02709861f, 0.19423009f, 0.15165645f, 0.03052928f, 0.00159677f, 0.08384778f, 
    0.01678761f, -0.11299138f, -0.06222871f, 0.04659579f, -0.36309621f, 0.02241931f, -0.16722186f, 0.04669966f, 
    -0.00213124f, -0.05556147f, 0.03021901f, -0.07791740f, -0.20875038f, -0.25852874f, -0.42920014f, 0.00366207f, 
    -0.03571364f, -0.06828047f, 0.04522800f, -0.00531638f, 0.05680410f, -0.13708806f, 0.00431620f, 0.01333926f, 
    -0.02058856f, -0.02340815f, -0.02232838f, 0.04074966f, 0.02421559f, -0.01478874f, -0.02744471f, -0.02095387f, 
    -0.19738021f, -0.36828512f, -0.02023642f, -0.14935653f, -0.24315776f, -0.11632135f, -0.10467770f, 0.16035442f, 
    -0.14231789f, -0.01588899f, -0.22007793f, 0.14121476f, -0.02294451f, 0.04455326f, 0.05947889f, 0.10256550f, 
    0.00624361f, 0.00004753f, 0.00602043f, 0.07071235f, 0.19777583f, -0.22529230f, 0.09514939f, -0.07235064f, 
    -0.11567756f, -0.08233117f, -0.05661284f, -0.01056742f, -0.10220656f, -0.04860077f, -0.13944875f, -0.01454223f, 
    -0.01246314f, -0.06561264f, 0.13340610f, -0.00785363f, 0.09527254f, 0.12540986f, 0.06519692f, -0.03193922f, 
    -0.00061058f, 0.00478711f, -0.04975488f, 0.01981246f, -0.05562897f, -0.11448314f, -0.21504660f, 0.05390629f, 
    -0.05328528f, 0.05508715f, -0.02831029f, 0.04849983f, 0.06038702f, -0.05544745f, 0.04479297f, -0.03448812f, 
    0.00347205f, 0.10996883f, 0.11107003f, -0.00796698f, 0.14154570f, 0.11231590f, -0.01013230f, 0.07705498f, 
    0.01316876f, -0.14132498f, 0.01268189f, -0.02736782f, -0.01280653f, 0.01474129f, -0.10821422f, -0.07420531f, 
    -0.01240283f, -0.08634323f, -0.04198123f, -0.08584516f, 0.00944687f, 0.14266708f, 0.02599120f, 0.03263672f, 
    -0.60402226f, 0.39436796f, -0.20624626f, 0.14805290f, 0.16783966f, -0.07757737f, 0.06232844f, 0.05175789f, 
    0.02140031f, -0.04047453f, -0.09693944f, -0.05856093f, 0.11380774f, -0.06662287f, 0.07933895f, -0.12645419f, 
    -0.03920215f, -0.17563510f, 0.04833982f, 0.06729902f, -0.47310024f, -0.47992504f, -0.25918338f, -0.09992819f, 
    -0.12543750f, -0.12263083f, -0.14296719f, -0.06947500f, 0.03338604f, -0.05689282f, -0.06386733f, -0.06650419f, 
    0.08774224f, -0.05067372f, -0.02296603f, 0.02080041f, -0.13734810f, 0.01771373f, -0.01250336f, 0.02250169f, 
    0.12996289f, 0.05456306f, 0.05897900f, 0.01423244f, -0.02628529f, 0.02754014f, -0.03344562f, -0.01501293f, 
    0.00663526f, 0.05829278f, 0.01585325f, -0.05251770f, 0.05459682f, -0.05756897f, 0.00735801f, -0.04066322f, 
    -0.04056689f, -0.01100812f, -0.00284777f, 0.05106456f, 0.01518732f, 0.16585107f, -0.16839555f, 0.15531050f, 
    -0.12370630f, -0.07822059f, 0.00744970f, 0.03145568f, 0.11386465f, -0.08695812f, -0.05711074f, -0.00203754f, 
    0.03989708f, 0.00347491f, 0.04921196f, 0.04848079f, -0.05768155f, -0.05140739f, -0.10268822f, -0.02584018f, 
    0.34222475f, -0.23738058f, -0.06523723f, 0.16602461f, -0.02684511f, -0.06620707f, -0.10848040f, -0.08318595f, 
    0.07568195f, -0.03418829f, -0.05473259f, -0.03355584f, -0.02196421f, 0.14555812f, -0.06633982f, 0.00381573f, 
    0.15052406f, -0.06945270f, 0.05318172f, -0.06930398f, 0.14931417f, 0.05701393f, -0.23008144f, -0.10016569f, 
    -0.09735846f, -0.08109357f, 0.00045380f, 0.01324826f, -0.04512776f, 0.00764975f, -0.07407332f, -0.07893731f, 
    0.07328327f, -0.07606366f, 0.03728739f, -0.05616457f, -0.07453088f, -0.02218160f, -0.00691615f, -0.00015085f, 
    -0.02017035f, -0.29133630f, 0.09147240f, -0.15531625f, 0.21516515f, -0.01063100f, 0.09190033f, 0.02082671f, 
    -0.07782072f, 0.16483597f, 0.00005069f, 0.03627227f, -0.02363792f, 0.05793794f, -0.01437498f, 0.01469768f, 
    0.03883948f, 0.04225487f, -0.00730393f, 0.04287095f, 0.03739154f, 0.06622559f, 0.09345011f, 0.15837288f, 
    0.06399170f, -0.03414982f, 0.13145286f, -0.00472874f, 0.01814930f, -0.06336164f, -0.07503290f, 0.04794372f, 
    0.00202662f, -0.17577562f, -0.06067099f, 0.04094355f, 0.03872187f, 0.00701187f, -0.08605963f, -0.04127653f, 
    0.15261307f, 0.02271169f, 0.07404463f, 0.17094091f, 0.07001492f, -0.07144200f, -0.02775383f, 0.02411333f, 
    -0.06806966f, 0.00578876f, -0.01902115f, -0.00574309f, -0.00726982f, -0.01412109f, 0.06269528f, 0.02072970f, 
    0.07302938f, 0.04276134f, 0.00343561f, -0.15865240f, 0.24577664f, -0.26435155f, -0.08032398f, 0.15795684f, 
    0.14153966f, -0.11285052f, 0.06576282f, 0.07412332f, 0.03426520f, 0.08333372f, 0.06390281f, 0.09025075f, 
    -0.04998065f, -0.00866331f, -0.04008302f, -0.02727167f, -0.00101245f, 0.07002290f, 0.02251883f, 0.05706662f, 
    -0.35056323f, 0.22908714f, 0.08221223f, -0.12912929f, -0.06067206f, 0.23021372f, -0.02469392f, -0.00097308f, 
    -0.08219327f, -0.21370606f, 0.10704084f, -0.01874225f, -0.14131318f, -0.00966606f, -0.19746847f, 0.04007048f, 
    -0.04808669f, -0.00179023f, -0.01436326f, -0.00991478f, -0.05829230f, 0.16451812f, -0.22899754f, 0.18819639f, 
    -0.18122107f, -0.00960615f, -0.00443099f, 0.04945655f, 0.01645296f, -0.10715859f, 0.01824370f, 0.03966254f, 
    0.03298588f, -0.09777807f, 0.03101034f, -0.01567289f, 0.05100170f, 0.16611172f, 0.02358348f, 0.13205779f, 
    -0.01351298f, -0.18907389f, -0.04330730f, 0.08495173f, -0.03427105f, -0.00764043f, -0.03144631f, 0.23463693f, 
    -0.09927097f, -0.10498838f, -0.01874971f, -0.07567610f, -0.21238406f, 0.00048584f, 0.09482776f, 0.11360540f, 
    -0.08568577f, -0.04423313f, -0.11267243f, -0.11075181f, -0.41439733f, 0.26823062f, 0.02437192f, -0.12269768f, 
    -0.27009216f, 0.13995321f, -0.02098819f, -0.02096323f, -0.00847400f, 0.02498643f, -0.09356027f, -0.02576962f, 
    0.08504443f, -0.05647257f, 0.03408841f, 0.09470581f, -0.09260514f, 0.00597377f, 0.01016508f, -0.07671373f, 
    -0.26845223f, -0.24207903f, 0.21069281f, 0.28752768f, -0.07047258f, -0.12567711f, 0.15755519f, -0.04851463f, 
    -0.01354008f, -0.00468754f, 0.12842762f, 0.03152408f, -0.04515894f, 0.09500530f, -0.06791054f, -0.26306704f, 
    0.06535327f, 0.02029151f, 0.07657728f, 0.04822237f, 0.22000790f, 0.07960419f, -0.12371565f, 0.21799861f, 
    -0.30356631f, 0.21054256f, -0.16082077f, -0.00708423f, 0.03833127f, 0.14198884f, -0.09602758f, -0.08011815f, 
    0.08769646f, 0.06106412f, 0.04677580f, -0.05146649f, -0.03310657f, 0.08631361f, -0.19353305f, 0.03116436f, 
    -0.39443943f, 0.02937202f, -0.05803929f, 0.00560571f, 0.02193238f, 0.02735927f, 0.01102398f, 0.09609748f, 
    -0.07509191f, -0.00627656f, 0.02827846f, -0.03812679f, 0.09258956f, 0.00771998f, -0.06691785f, -0.08880349f, 
    -0.07649831f, -0.00109568f, -0.00396869f, 0.01068949f, -0.17217897f, 0.11241101f, 0.20301069f, 0.18888040f, 
    -0.04868764f, 0.00560333f, -0.07880446f, 0.07822610f, -0.07146499f, 0.03701209f, 0.16119997f, 0.01586764f, 
    0.04772751f, 0.05535578f, 0.01639205f, 0.10136899f, 0.15329269f, -0.03962022f, 0.00699731f, 0.04553729f, 
    -0.06259829f, 0.20068362f, 0.02686387f, 0.21601680f, -0.06868571f, 0.09871390f, -0.06549394f, -0.16460066f, 
    0.05963150f, -0.19981711f, 0.02849663f, 0.08674033f, -0.09874234f, 0.01424029f, 0.12803388f, 0.03551508f, 
    -0.09144087f, -0.02564852f, 0.05825457f, 0.14248259f, -0.16691555f, -0.44434685f, -0.09501176f, 0.21339674f, 
    0.01553645f, 0.04306459f, 0.04897269f, 0.16119787f, -0.04597247f, -0.07418824f, 0.02294153f, -0.11465103f, 
    0.09764753f, 0.10205025f, -0.06477442f, 0.08056014f, 0.03098612f, -0.03611538f, 0.04398003f, -0.01410957f, 
    -0.58255756f, 0.18464035f, 0.09737593f, 0.03793735f, 0.05733205f, 0.00780787f, -0.05812078f, 0.00345417f, 
    0.13309531f, 0.03202535f, -0.10276917f, -0.00875622f, -0.03807522f, 0.02343787f, 0.03910789f, -0.01391290f, 
    0.07815962f, -0.01943363f, -0.11592744f, -0.13658334f, -0.51819849f, -0.38539597f, 0.22788468f, 0.22300710f, 
    0.07732514f, -0.14545536f, -0.05726243f, 0.06739188f, -0.19525102f, 0.04555070f, -0.00990831f, 0.07565657f, 
    -0.05297597f, -0.11143803f, 0.09108366f, -0.04148541f, -0.17447647f, 0.07713490f, 0.03782461f, 0.00513180f, 
    0.17915660f, 0.07863604f, -0.08023155f, -0.12171955f, 0.06580415f, 0.00309614f, -0.05109657f, 0.04681443f, 
    0.05080594f, 0.00078358f, 0.07585541f, -0.00279725f, 0.16816851f, 0.11950728f, -0.07902004f, 0.07279418f, 
    -0.01734194f, 0.02097099f, -0.00407890f, 0.06968041f, 0.13265134f, -0.01630919f, 0.08034501f, -0.24935760f, 
    -0.32589000f, 0.00866889f, 0.01296220f, 0.02936837f, 0.01361018f, -0.00512368f, -0.05897154f, -0.05882335f, 
    0.02057225f, 0.04156630f, 0.03800334f, -0.07189424f, 0.14122240f, 0.06201111f, 0.01109954f, 0.05625721f, 
    -0.00681393f, 0.17504855f, 0.10088602f, -0.04111788f, 0.03119252f, 0.17129043f, -0.09516532f, 0.03375199f, 
    0.01777232f, -0.01795582f, -0.07928938f, 0.09607524f, -0.06367877f, 0.03871493f, 0.03673581f, -0.02171284f, 
    0.08806644f, -0.00492344f, -0.02166473f, -0.10845615f, -0.36019304f, 0.09522293f, -0.20864019f, -0.17596333f, 
    0.14131922f, -0.01265986f, -0.00184156f, -0.00496475f, 0.03486676f, -0.02617985f, -0.01682046f, 0.06281116f, 
    -0.12303963f, 0.07635298f, 0.00717097f, -0.05580696f, 0.07506119f, 0.09211215f, 0.06027653f, -0.11905318f, 
    -0.53303355f, 0.02293385f, 0.12039314f, 0.08442386f, -0.11637592f, -0.08324206f, 0.09749331f, -0.11483418f, 
    0.09283561f, -0.18117926f, 0.07371886f, -0.06000652f, 0.03551491f, -0.04460477f, 0.05033999f, -0.04596240f, 
    -0.06434409f, -0.01568492f, -0.03964923f, 0.00304907f, -0.17215531f, 0.29656717f, -0.00983228f, -0.30185527f, 
    -0.02531646f, 0.13521300f, -0.05977559f, -0.11758374f, 0.01749040f, 0.04560641f, -0.01620981f, -0.17635691f, 
    0.01412536f, 0.03395350f, 0.04074089f, -0.00963902f, 0.08761877f, -0.10446607f, -0.09639771f, -0.06998035f, 
    -0.13745245f, -0.20944928f, 0.16728291f, 0.08722939f, 0.17044939f, 0.06682190f, 0.02013654f, 0.06790917f, 
    -0.18184048f, 0.22359514f, -0.00600652f, -0.08405565f, 0.11932264f, 0.09262583f, 0.06840528f, -0.05351832f, 
    0.02439019f, 0.09995505f, 0.07815123f, -0.20415601f, -0.58771318f, -0.02200951f, -0.14013059f, 0.07955414f, 
    0.27162701f, 0.07755524f, 0.03222244f, -0.03011155f, 0.00111314f, 0.15484942f, -0.06104771f, -0.06549063f, 
    0.02316270f, 0.02483448f, -0.09304395f, -0.06316859f, 0.10468327f, -0.00158032f, 0.08580041f, -0.15574361f, 
    -0.69823456f, 0.14301017f, 0.04121951f, 0.19268268f, 0.18268146f, 0.06440020f, -0.06337339f, 0.01770814f, 
    0.19433866f, 0.14727490f, -0.11250465f, -0.01129091f, 0.06048188f, 0.07415695f, 0.03886656f, 0.01756724f, 
    0.12341160f, 0.07569487f, 0.08556788f, 0.00212940f, 0.06744158f, -0.18451901f, 0.03739439f, 0.09502516f, 
    0.21501374f, 0.04052199f, 0.10161354f, -0.07547921f, 0.12682070f, 0.01641716f, 0.17643633f, 0.10025878f, 
    -0.05304673f, -0.00811100f, 0.06739945f, -0.06270964f, 0.03121546f, -0.02816117f, 0.12024455f, 0.10167869f, 
    -0.63386506f, -0.00962891f, 0.14315704f, -0.02948321f, 0.04207744f, -0.05048074f, -0.01593797f, -0.00284543f, 
    -0.01241479f, 0.00510695f, 0.12308706f, -0.03529599f, -0.03443763f, -0.20567146f, -0.01289757f, 0.07713591f, 
    -0.03539038f, -0.16634643f, 0.04718748f, 0.01781579f, -0.02405394f, 0.06642836f, 0.12066305f, -0.11613890f, 
    -0.00590557f, 0.09246243f, -0.00108393f, -0.08243006f, 0.06354988f, 0.09793487f, 0.06512770f, -0.02724448f, 
    -0.02832120f, 0.01500030f, -0.00305490f, 0.11525328f, 0.05713631f, -0.09842919f, -0.03472357f, 0.02945772f, 
    0.32230988f, -0.00798172f, -0.17095776f, -0.02377965f, -0.19181494f, -0.09669010f, -0.03094283f, -0.04500179f, 
    -0.16115463f, -0.13747221f, 0.01749513f, 0.04013510f, 0.03515695f, -0.04854349f, -0.03681993f, -0.13890398f, 
    0.09677327f, 0.03064310f, 0.09328177f, -0.12940611f, -0.11461305f, 0.17271675f, -0.17931534f, 0.06403160f, 
    -0.33142117f, -0.08451880f, -0.04197362f, 0.00213368f, -0.29061177f, 0.04235321f, -0.11904920f, -0.08824265f, 
    -0.04757073f, -0.00312722f, -0.01114103f, 0.06762573f, -0.04684001f, -0.03027664f, -0.24126206f, -0.00011681f, 
    -0.32563663f, 0.39591566f, -0.20909548f, -0.07197628f, 0.07476570f, 0.08005592f, -0.02849080f, 0.01174366f, 
    0.13224079f, 0.06356860f, -0.09596242f, 0.08990239f, -0.10809576f, -0.06830188f, 0.03258625f, -0.18283318f, 
    0.15304536f, 0.02683302f, 0.02092784f, 0.04882997f, -0.46314722f, -0.07263844f, -0.12507521f, 0.09552486f, 
    0.18999805f, 0.12358561f, 0.02965644f, 0.03399818f, 0.02046363f, 0.11726779f, 0.07371851f, 0.07238251f, 
    -0.06480660f, -0.11840679f, 0.03333230f, 0.09784160f, -0.12369852f, -0.01370542f, 0.07261809f, 0.12514625f, 
    0.23632921f, -0.02716638f, 0.20788224f, 0.09640972f, -0.08824082f, -0.02118940f, -0.01598753f, 0.03267926f, 
    -0.01978415f, 0.07569281f, 0.07884633f, 0.05284723f, -0.05521649f, -0.12516220f, 0.11336265f, 0.12304804f, 
    0.14870515f, 0.01696691f, -0.00184038f, 0.17541546f, -0.13032515f, -0.19184929f, 0.10170686f, 0.00021810f, 
    0.14325987f, 0.04552852f, -0.13089821f, -0.12208597f, -0.07182088f, 0.07522872f, 0.00726441f, -0.05698419f, 
    -0.10284491f, -0.01560898f, 0.05014935f, -0.18492433f, -0.09747218f, -0.03368758f, -0.05019447f, -0.00313642f, 
    -0.10737039f, 0.20245992f, 0.24914289f, 0.09135344f, -0.23848379f, -0.13824090f, 0.03487602f, -0.00669461f, 
    0.07437647f, -0.02355631f, -0.08231222f, -0.06554569f, 0.03284844f, 0.17148483f, 0.02350303f, -0.04827525f, 
    -0.03285999f, 0.10278692f, -0.07603835f, 0.09891265f, 0.36127049f, -0.34149492f, -0.08567695f, 0.04473232f, 
    -0.43892977f, 0.06191977f, -0.05060079f, 0.23679693f, -0.24827939f, 0.02383913f, -0.07628908f, 0.11096884f, 
    -0.00617904f, -0.04857197f, 0.11919869f, 0.09805515f, -0.03657940f, 0.08120468f, 0.00571068f, 0.00718652f, 
    -0.47508419f, 0.17003696f, 0.01644860f, 0.30789253f, 0.01372729f, -0.06018778f, -0.19589391f, -0.03323980f, 
    -0.05129836f, 0.04169638f, 0.02162952f, 0.07426906f, 0.04437219f, 0.02457034f, 0.04254648f, -0.13104896f, 
    -0.03229861f, -0.11752846f, -0.01871981f, -0.23315372f, -0.11151870f, -0.20330238f, 0.09179620f, 0.12586096f, 
    0.09792756f, 0.05740509f, -0.04405496f, -0.03542495f, 0.03641619f, 0.13974261f, 0.03178179f, -0.02938315f, 
    0.10379445f, 0.08237195f, 0.00825801f, -0.01430818f, -0.04726475f, -0.16461350f, -0.13635537f, -0.09961650f, 
    0.12899247f, 0.05032058f, 0.05536559f, 0.12195715f, -0.09642011f, -0.08211987f, -0.13636337f, -0.13904941f, 
    0.09404156f, 0.04108411f, 0.07868653f, 0.08590310f, -0.04270388f, 0.10136436f, -0.03917265f, -0.00818350f, 
    -0.04994102f, 0.04773328f, -0.01437386f, 0.01890459f, -0.33609492f, -0.13604328f, -0.03325137f, 0.03796180f, 
    -0.04797802f, 0.01193173f, -0.03792159f, -0.03080765f, -0.04583563f, 0.00549617f, 0.08560000f, -0.07441287f, 
    -0.01546472f, -0.07502414f, -0.01231652f, -0.09572462f, 0.00186995f, 0.01098725f, -0.13616104f, -0.11537076f, 
    0.20106529f, 0.08234822f, -0.00044690f, 0.24511972f, 0.26273999f, -0.05772565f, -0.21174952f, 0.12182264f, 
    -0.03870632f, -0.03225589f, -0.07231069f, -0.13267697f, -0.02446827f, 0.06734210f, 0.01193241f, -0.02333170f, 
    -0.09439261f, 0.12275138f, -0.04769383f, -0.14867441f, 0.12539808f, 0.03030825f, 0.02622532f, -0.21014065f, 
    0.03750613f, -0.10633092f, -0.07154653f, 0.00769096f, -0.09774034f, 0.05859341f, 0.12426693f, -0.00020922f, 
    0.01687746f, -0.01993565f, -0.10804264f, -0.01594222f, 0.02639782f, -0.12099728f, 0.17827094f, 0.03433730f, 
    -0.46514115f, -0.03116166f, 0.05105793f, -0.14680611f, 0.06171440f, 0.03475355f, -0.01931597f, 0.06027839f, 
    0.02175367f, -0.07195958f, 0.06485028f, -0.03446923f, 0.02380750f, -0.20192249f, 0.06485248f, 0.03857882f, 
    0.05523404f, -0.03964682f, -0.14290488f, 0.10686544f, 0.09071514f, -0.09308155f, 0.04928407f, 0.14497891f, 
    -0.18483579f, -0.26526928f, 0.03282258f, -0.07337660f, -0.03068786f, 0.01897412f, -0.04023357f, 0.01358651f, 
    0.16967438f, 0.08569191f, 0.19413276f, -0.14204940f, -0.15888469f, 0.05613151f, 0.07468501f, -0.07684620f, 
    -0.07254405f, 0.07390844f, -0.22401486f, 0.10530057f, 0.11107218f, 0.15137735f, 0.04692229f, -0.03075463f, 
    0.04258413f, 0.21842062f, -0.02299054f, 0.15405308f, 0.20780671f, -0.00282785f, 0.00049124f, -0.16967909f, 
    0.09233774f, -0.20061488f, 0.03287848f, -0.23049350f, 0.16307180f, 0.47841245f, 0.04298820f, -0.04157881f, 
    -0.01278378f, 0.06431306f, -0.05614505f, -0.06472441f, -0.12816210f, 0.00781735f, 0.14242293f, 0.10342093f, 
    -0.08925282f, 0.00082586f, 0.01758120f, 0.06856657f, 0.00934686f, 0.05690518f, 0.10441156f, 0.10534700f, 
    0.07932160f, -0.04557315f, -0.05977128f, -0.00464430f, -0.15770017f, 0.08028901f, 0.06690518f, -0.01065412f, 
    -0.00512782f, -0.08895254f, 0.01589105f, 0.07775085f, 0.05809895f, -0.06028972f, -0.12282075f, 0.08274775f, 
    -0.13264671f, -0.02293384f, 0.21215416f, 0.07018812f, 0.12959312f, 0.12498128f, -0.06871054f, -0.10610960f, 
    0.15692337f, -0.25670090f, -0.13776915f, 0.08193554f, 0.09950040f, 0.02196777f, -0.05862559f, -0.19127256f, 
    -0.14676487f, 0.10288039f, 0.25027007f, -0.02028925f, 0.10377261f, 0.03241234f, -0.18306574f, 0.06902549f, 
    -0.09276663f, -0.03455975f, 0.27766249f, 0.14849219f, -0.13942461f, 0.09180162f, 0.05480525f, -0.00670170f, 
    0.03065229f, -0.08596399f, -0.05659290f, 0.00636107f, -0.13303851f, 0.05021513f, 0.03950002f, -0.00546198f, 
    0.01270212f, 0.16968295f, 0.05486411f, -0.09570322f, -0.17947587f, 0.02095772f, 0.11008374f, -0.03607503f, 
    -0.24570888f, -0.08894192f, 0.07061297f, 0.03136924f, 0.00725207f, 0.03150725f, -0.04281556f, 0.03308706f, 
    0.02030862f, -0.05969991f, -0.13718992f, -0.12843205f, -0.11109268f, -0.18565610f, 0.12569925f, 0.03394850f, 
    -0.04233505f, -0.07595737f, -0.01146669f, -0.01044969f, 0.06035030f, 0.13602264f, 0.02149441f, -0.01892177f, 
    0.05137921f, -0.08332817f, 0.02457775f, -0.05430653f, -0.12237147f, -0.08889736f, 0.02931466f, -0.03736790f, 
    -0.09352896f, -0.05744272f, -0.15798113f, -0.02085931f, -0.56398988f, 0.14903323f, -0.17713082f, -0.15800290f, 
    -0.09805153f, 0.14824888f, 0.05351069f, 0.09180053f, -0.12529504f, -0.11991299f, 0.10247257f, -0.09680825f, 
    0.04772428f, -0.10061190f, -0.00483370f, 0.05916834f, 0.03895632f, -0.12075756f, 0.10692968f, 0.02574219f, 
    0.08387035f, -0.08968167f, 0.02166679f, 0.16245000f, -0.24416901f, 0.03672540f, -0.07639708f, 0.02997196f, 
    0.03497471f, -0.00008621f, -0.17968376f, 0.02712180f, 0.07570031f, 0.06415670f, 0.01216906f, 0.08323415f, 
    0.00743047f, -0.14089778f, 0.12057486f, -0.07947735f, -0.02530899f, -0.07851022f, 0.16335841f, 0.33130163f, 
    0.03781815f, -0.06636187f, 0.09053160f, -0.00988934f, -0.01859308f, 0.00373280f, 0.09573329f, -0.05654798f, 
    -0.05261991f, -0.02856988f, 0.01736501f, 0.11190160f, -0.06289280f, 0.00330934f, 0.06021344f, 0.05425299f, 
    -0.12788005f, 0.35620591f, -0.10336306f, -0.10081065f, 0.07013140f, -0.01620366f, 0.13454625f, -0.03085119f, 
    -0.15406625f, -0.14414498f, 0.14484377f, 0.04483005f, -0.16766332f, -0.06948808f, -0.12363513f, -0.04184809f, 
    0.05099237f, 0.17377739f, -0.01486873f, -0.10530607f, -0.73491907f, -0.14024453f, -0.31836095f, -0.36349118f, 
    -0.16726401f, 0.19563696f, 0.02598937f, 0.10466839f, 0.05978163f, -0.16352679f, 0.02539870f, 0.10716335f, 
    -0.17965838f, 0.04428089f, -0.05033187f, 0.06983447f, -0.03950110f, 0.00480780f, -0.25211936f, 0.05247353f, 
    -0.45432341f, 0.11545248f, -0.47400516f, -0.24068993f, 0.06701213f, 0.13339300f, 0.14372721f, -0.04266804f, 
    -0.09663181f, -0.12525004f, -0.00370172f, -0.01381124f, -0.10103437f, -0.06306760f, 0.03628409f, 0.01210583f, 
    0.03891141f, 0.00209147f, -0.04043435f, -0.03309470f, -0.10341007f, -0.04994746f, -0.25411808f, 0.05239410f, 
    0.07469670f, 0.10399159f, 0.07867905f, 0.04391532f, -0.10492051f, 0.15545486f, 0.10007159f, 0.14486676f, 
    0.20217663f, 0.07177591f, 0.12349330f, -0.05836092f, -0.00329182f, 0.08829820f, -0.08261792f, -0.04324646f, 
    -0.05621546f, -0.08380278f, -0.06276187f, -0.04093707f, -0.22574039f, -0.06021376f, 0.04394345f, 0.06118153f, 
    0.03210074f, 0.02309525f, -0.07619992f, 0.03377349f, 0.02387104f, 0.01932654f, 0.07120708f, -0.11389972f, 
    -0.03144941f, 0.11887223f, 0.00761904f, -0.01860584f, 0.07388771f, -0.02858024f, 0.05084555f, 0.13242072f, 
    -0.05062214f, -0.05644541f, 0.14171053f, 0.01712855f, 0.02117493f, 0.00915308f, -0.00014058f, 0.02709953f, 
    -0.00896015f, -0.02076117f, 0.07694448f, 0.03561135f, 0.02501677f, 0.15592873f, 0.06996750f, 0.00531730f, 
    -0.11065237f, 0.03771595f, 0.12758361f, 0.05105211f, 0.03930977f, -0.14578012f, -0.15973999f, 0.06162865f, 
    -0.03876030f, 0.04201015f, 0.02064393f, -0.07739473f, -0.05160126f, -0.01921261f, -0.01808398f, 0.11038921f, 
    0.01759741f, -0.16123383f, -0.04705936f, 0.14557265f, -0.09488076f, 0.04170679f, -0.05820172f, -0.12900300f, 
    0.02587131f, 0.07292990f, -0.10678024f, -0.14714976f, -0.05848211f, 0.00395845f, 0.09212323f, 0.12584791f, 
    0.03477346f, -0.07066412f, -0.00920615f, -0.08225648f, 0.02301029f, -0.02632473f, 0.15866917f, -0.03689123f, 
    -0.14511272f, -0.18073802f, 0.16998607f, 0.19593136f, -0.31951120f, -0.01826714f, -0.05100412f, 0.05614184f, 
    -0.03325888f, 0.09798939f, 0.01275642f, -0.00988933f, 0.00663778f, -0.07859959f, 0.03930996f, 0.08679333f, 
    -0.02461240f, -0.01347823f, 0.15865128f, 0.09341989f, -0.51773751f, -0.09972649f, -0.19774590f, -0.12462266f, 
    -0.00923875f, 0.07177492f, 0.17424949f, 0.07753582f, -0.01508960f, -0.06915372f, -0.02140116f, 0.10290306f, 
    0.09041469f, -0.09678389f, -0.09158805f, 0.14685203f, 0.09791507f, -0.07006150f, -0.00549812f, -0.00863378f, 
    -0.04770333f, -0.25721732f, -0.13885039f, 0.07964075f, 0.38094270f, -0.02112276f, -0.00865824f, -0.02531257f, 
    -0.01707949f, -0.01172906f, -0.06244677f, -0.17831816f, 0.20777759f, 0.10043102f, 0.11530074f, -0.02623342f, 
    -0.13865171f, -0.03067252f, -0.00759377f, -0.09567418f, 0.05759853f, -0.03241163f, 0.07962100f, 0.16650333f, 
    0.04528340f, -0.01973990f, -0.06562233f, 0.06210353f, 0.13556470f, 0.04768382f, 0.03404796f, -0.05160233f, 
    0.12731403f, 0.14029276f, 0.09872274f, 0.09657233f, 0.07895415f, 0.04771049f, -0.24789892f, -0.04269743f, 
    0.13320565f, 0.08347390f, -0.29069009f, 0.13326941f, 0.08770471f, 0.06223862f, 0.11698592f, -0.00839034f, 
    0.16186459f, 0.00998624f, 0.03860487f, 0.07789818f, 0.02672745f, -0.03230165f, -0.04519697f, -0.01592310f, 
    0.06080542f, -0.09002406f, 0.10333130f, -0.07385024f, -0.13669592f, 0.15326732f, 0.18231976f, 0.07316556f, 
    -0.03236715f, 0.03437612f, 0.05458016f, -0.12289177f, -0.16306485f, 0.18283387f, -0.07330009f, -0.15202266f, 
    -0.05314835f, 0.13987979f, -0.08891077f, 0.08832218f, 0.01980637f, 0.00170317f, 0.05789467f, 0.03071100f, 
    0.05504904f, -0.10885227f, -0.14131731f, -0.03662722f, 0.58098406f, -0.04306755f, -0.00292324f, 0.05813849f, 
    0.01322314f, -0.02724381f, -0.11297900f, -0.04542229f, -0.00425172f, 0.03012620f, 0.12454882f, -0.01363975f, 
    -0.04781503f, 0.05579554f, 0.10328741f, 0.17931688f, 0.06638791f, 0.03033825f, -0.48170000f, -0.16922474f, 
    0.12893820f, 0.00299492f, 0.05156418f, -0.04514376f, -0.05638444f, 0.07581831f, -0.06537353f, -0.14323957f, 
    -0.10189959f, 0.04702930f, -0.13827823f, 0.05005841f, 0.08669499f, 0.18023880f, 0.13409559f, 0.14961813f, 
    -0.30410782f, 0.08642460f, 0.09624600f, 0.03681263f, -0.02917550f, 0.12783647f, -0.03504157f, 0.02887809f, 
    -0.02558443f, -0.06608901f, -0.06556929f, -0.07962792f, 0.13587175f, -0.07922996f, -0.08552093f, -0.06978509f, 
    0.05238594f, 0.00235216f, 0.06987841f, -0.05804535f, 0.58960658f, 0.04531185f, 0.18423447f, -0.09902341f, 
    0.29609433f, 0.05662079f, -0.14343882f, -0.07241549f, -0.03606929f, -0.08820885f, 0.00653155f, 0.03282796f, 
    0.05382067f, 0.02578755f, -0.02272147f, -0.05653721f, 0.09396769f, 0.03271983f, 0.07513963f, 0.03205772f, 
    -0.25308606f, 0.37698290f, 0.06712869f, -0.01364184f, -0.34168884f, -0.04700710f, 0.06023327f, 0.03124294f, 
    0.02910721f, 0.05429949f, -0.01073022f, 0.09707826f, 0.10021352f, -0.15708143f, 0.05693825f, 0.05666592f, 
    -0.11213195f, 0.12450436f, 0.01930987f, 0.03314485f, -0.19179875f, 0.14364983f, -0.20065969f, 0.20121688f, 
    -0.17370473f, -0.20154545f, 0.12343860f, -0.08110243f, -0.03989035f, 0.03810101f, -0.05489215f, -0.03346473f, 
    0.00276487f, 0.01023383f, -0.03097317f, 0.02381773f, -0.02125424f, 0.10958021f, -0.17197509f, -0.09867394f, 
    0.12011607f, -0.00305184f, -0.14513481f, 0.04706021f, 0.05860627f, -0.12330936f, 0.09160853f, -0.08073844f, 
    -0.07302924f, -0.05230053f, -0.01901956f, 0.06426455f, -0.02683257f, 0.04148799f, 0.19603094f, -0.20629232f, 
    -0.07433338f, 0.09410532f, -0.00875564f, 0.11533165f, -0.11298168f, 0.31348753f, 0.25120440f, -0.05045031f, 
    -0.32499567f, 0.20963222f, 0.01577793f, 0.13727823f, -0.01255779f, -0.06073770f, -0.02048897f, 0.08505453f, 
    -0.16365966f, 0.00726060f, -0.14597331f, 0.07076258f, -0.07450794f, -0.08744498f, 0.08445882f, 0.00271998f, 
    -0.13076162f, 0.04984294f, -0.11117382f, -0.44604379f, 0.16262485f, -0.03628287f, -0.03400075f, -0.00496100f, 
    -0.24197172f, -0.23024274f, -0.00142597f, -0.13152911f, -0.12961373f, -0.02358109f, -0.09180393f, 0.11362786f, 
    0.07101116f, 0.13063738f, 0.22374089f, 0.17215911f, -0.18660316f, -0.23988387f, -0.16542013f, 0.14291351f, 
    -0.13231550f, -0.01046736f, 0.01427197f, -0.12072551f, 0.17678335f, 0.05745666f, -0.07314295f, 0.05445139f, 
    0.09537664f, -0.05618574f, 0.00491844f, 0.04711527f, -0.01546277f, -0.06767336f, -0.08646772f, -0.16432819f, 
    0.20733887f, -0.50470531f, -0.00976678f, 0.07863027f, 0.03829223f, -0.02728191f, 0.03870467f, 0.01078212f, 
    -0.14141923f, 0.04484403f, 0.05340423f, -0.02691263f, 0.04218967f, 0.10817073f, 0.11785495f, -0.01882933f, 
    -0.00993772f, 0.03775904f, -0.08197169f, -0.11965928f, -0.00017293f, 0.16188534f, 0.18773519f, -0.10154951f, 
    -0.12018767f, 0.13204961f, 0.10729720f, -0.01992817f, 0.05010296f, -0.01862942f, -0.10995206f, 0.00087536f, 
    -0.09453587f, 0.06297963f, -0.24171820f, -0.02956256f, -0.03790161f, 0.04264676f, -0.04276421f, -0.05672665f, 
    -0.31518722f, 0.27628940f, -0.22361286f, 0.18978636f, -0.17018104f, -0.12905350f, -0.06981649f, 0.04772185f, 
    0.09312516f, 0.05833032f, 0.01442461f, -0.04855351f, -0.01481276f, -0.00801577f, 0.10834907f, -0.08915284f, 
    0.00019710f, -0.17690825f, -0.09139414f, -0.04999091f, 0.02683508f, -0.14930971f, 0.07098275f, 0.25135601f, 
    0.27597937f, 0.06199176f, 0.11582834f, -0.10387111f, 0.07981411f, -0.10588025f, 0.05651047f, 0.09077068f, 
    -0.01444354f, 0.00672967f, 0.06662931f, 0.09324689f, 0.01890007f, 0.15877891f, 0.02616380f, -0.04023828f, 
    -0.04460037f, -0.09938779f, -0.06797521f, -0.19629191f, 0.00338436f, 0.02091564f, 0.17239341f, 0.02676121f, 
    -0.03774092f, -0.00013254f, -0.02998679f, -0.11723019f, 0.05183443f, -0.05597658f, -0.08257168f, -0.08263553f, 
    0.03254572f, 0.16305684f, 0.11446218f, 0.04950128f, 0.33169484f, -0.74639982f, -0.17878532f, -0.00849895f, 
    -0.14052974f, -0.07426766f, 0.13829221f, -0.01730911f, 0.04281339f, 0.01524604f, -0.04648958f, 0.03857882f, 
    -0.04136030f, 0.13633795f, 0.06666208f, 0.01708433f, -0.04484488f, 0.07748122f, -0.20974845f, 0.07998783f, 
    0.07524740f, 0.05665935f, 0.08293910f, -0.00625398f, 0.04006635f, 0.08194578f, 0.11260479f, 0.02905039f, 
    -0.00294802f, -0.10816438f, -0.04515130f, -0.01040401f, -0.13291641f, 0.00998735f, -0.22311449f, 0.08039457f, 
    -0.09845135f, 0.15783972f, -0.03516724f, 0.01102161f, -0.03180734f, 0.04412708f, -0.03295513f, 0.08422785f, 
    0.32924607f, -0.00766279f, -0.05055194f, -0.05914809f, 0.07275095f, 0.03244783f, -0.08150139f, 0.09422415f, 
    0.02476147f, -0.01155794f, 0.06042650f, -0.11507128f, -0.02692996f, 0.04672221f, 0.03387285f, -0.06417339f, 
    -0.41416427f, -0.51662290f, -0.12513143f, -0.13411069f, 0.20006688f, 0.09003317f, -0.11226837f, 0.02624050f, 
    0.09397622f, -0.12926628f, -0.11396804f, -0.03093196f, 0.10966146f, 0.10051923f, -0.04076241f, 0.12980475f, 
    -0.02101986f, -0.28542477f, -0.06993614f, 0.15909593f, -0.10687331f, -0.33382443f, 0.11149220f, -0.26861584f, 
    0.14198048f, -0.05577905f, -0.00836460f, 0.07560645f, -0.17763521f, 0.12182917f, 0.03522581f, -0.07393368f, 
    0.08158554f, 0.03689735f, 0.14569998f, -0.07241911f, 0.00586265f, -0.08430988f, 0.07073171f, 0.02672708f, 
    0.24646120f, -0.22143383f, -0.00132664f, -0.40936419f, 0.24756426f, -0.06612539f, 0.00672524f, -0.01027422f, 
    0.01117892f, -0.17689890f, 0.06585967f, 0.01074508f, 0.06016131f, 0.02026921f, -0.10022175f, 0.03547620f, 
    0.00220197f, -0.05176109f, -0.06863482f, 0.21330649f, -0.35097480f, 0.05232391f, -0.09563135f, -0.37508047f, 
    0.10605524f, 0.05234549f, -0.08551414f, 0.03799392f, -0.07238245f, -0.11109586f, -0.06978748f, -0.06527968f, 
    -0.15395235f, -0.03232542f, 0.03315431f, -0.03477296f, -0.12844031f, 0.10216941f, 0.08808690f, 0.08195693f, 
    0.20709695f, 0.07734848f, 0.22453833f, 0.07657728f, -0.16244116f, 0.11938262f, -0.05669549f, -0.03149957f, 
    -0.03243102f, 0.04188768f, -0.11854450f, 0.02380339f, 0.07503726f, 0.04725348f, -0.00918022f, 0.13377219f, 
    -0.03987092f, -0.02604329f, -0.11913799f, -0.07813405f, -0.34053779f, 0.21151730f, -0.05078435f, 0.19679683f, 
    -0.03996023f, 0.01331021f, -0.14872898f, -0.04220446f, 0.09879737f, -0.03556915f, -0.01906183f, -0.03506840f, 
    0.01700242f, 0.10096578f, 0.00324635f, -0.06585663f, 0.01613118f, -0.18770623f, -0.09990814f, -0.15042424f, 
    -0.03324683f, -0.21146253f, 0.10462582f, -0.00688341f, 0.13398969f, 0.04431792f, 0.04912150f, -0.11277615f, 
    0.01687530f, 0.05675719f, -0.02553494f, 0.02356230f, 0.08931398f, 0.03194801f, -0.15907694f, -0.03533078f, 
    0.08634509f, 0.08833607f, -0.01060019f, -0.00624384f, -0.06264815f, -0.26782480f, -0.17833202f, -0.08907047f, 
    0.33067340f, 0.07252380f, 0.09527620f, 0.01915616f, 0.18205617f, 0.04437527f, -0.01553162f, -0.04383323f, 
    -0.03435459f, -0.06295304f, -0.03806121f, -0.13234322f, -0.07374971f, 0.14746498f, -0.05268040f, 0.02808803f, 
    0.16651452f, 0.24802114f, -0.00299881f, 0.13743363f, -0.26612613f, -0.02055180f, 0.04164980f, 0.03736533f, 
    0.13216512f, 0.05080587f, -0.07668391f, 0.06993810f, -0.04529005f, 0.08388111f, -0.01610651f, 0.00265177f, 
    -0.02271122f, 0.00086029f, -0.09089950f, -0.00235661f, -0.18386710f, -0.26761299f, -0.05397375f, -0.38459402f, 
    0.10123039f, -0.10927016f, -0.04838243f, 0.02504894f, -0.06381963f, -0.11298264f, -0.06868616f, -0.00933547f, 
    -0.05656518f, 0.07284515f, -0.02283133f, -0.12266596f, 0.00140932f, -0.05588673f, 0.03582044f, -0.00515909f, 
    -0.34131226f, 0.28409019f, -0.14324018f, 0.12273023f, -0.60186082f, 0.04217969f, 0.07729489f, 0.02014457f, 
    0.11512433f, 0.04383641f, 0.00851634f, -0.00033794f, -0.00777982f, 0.12233686f, -0.12032917f, 0.01361505f, 
    -0.02492164f, 0.00996652f, 0.03775194f, 0.12745771f, 0.06193458f, -0.02697881f, -0.06461115f, -0.09815180f, 
    -0.04908394f, -0.02288527f, 0.00665533f, 0.06705471f, -0.17487042f, 0.02112005f, 0.07704735f, 0.01853774f, 
    -0.16039109f, -0.03471905f, -0.07105894f, 0.04090156f, -0.19419084f, 0.08400059f, 0.11432957f, 0.05102400f, 
    0.02183284f, -0.01287662f, -0.10890270f, -0.17287564f, 0.18665424f, -0.08723255f, 0.01336459f, 0.07068831f, 
    0.05281018f, -0.01514663f, 0.02446990f, 0.02344328f, -0.02042436f, -0.01689331f, 0.07953613f, 0.00497166f, 
    -0.04656994f, 0.24095018f, -0.13968126f, 0.16105212f, -0.19894482f, 0.28864256f, 0.04231482f, 0.09368784f, 
    -0.20692690f, -0.05889593f, -0.10950597f, 0.01010357f, -0.06499703f, 0.04580317f, 0.11009897f, 0.06374695f, 
    0.01291441f, -0.06001569f, -0.09404119f, 0.03293316f, -0.11815958f, -0.08290365f, -0.04998175f, 0.03967131f, 
    -0.03743636f, -0.02605714f, -0.13901329f, 0.10191011f, 0.18890317f, -0.06875772f, 0.05623478f, -0.08369499f, 
    0.07723562f, -0.09723461f, -0.14541431f, 0.07126734f, -0.09408053f, 0.04102024f, -0.05289239f, -0.02390973f, 
    -0.14079507f, -0.04016586f, -0.07507248f, -0.05531857f, 0.09012297f, 0.21688502f, -0.01623680f, -0.03796535f, 
    0.14041698f, -0.10630202f, 0.06844453f, -0.15220538f, 0.02968202f, -0.01735214f, -0.03278799f, 0.02399060f, 
    -0.05343817f, -0.09666020f, -0.08163895f, -0.02276587f, -0.02845903f, 0.05395349f, -0.02530815f, -0.03056851f, 
    0.13570167f, -0.14634034f, 0.09099356f, -0.04561013f, -0.20386122f, 0.01820709f, -0.08553484f, -0.05726417f, 
    -0.03113537f, -0.00563971f, -0.06499773f, 0.04555283f, -0.00137507f, -0.00821990f, -0.09465295f, -0.05338513f, 
    0.07543825f, -0.00265565f, -0.02717006f, -0.01583804f, 0.14768478f, 0.14444028f, 0.11295510f, 0.02863213f, 
    0.11436820f, -0.15852706f, 0.09138802f, -0.01485172f, 0.04696663f, 0.06041516f, -0.04812613f, -0.02173886f, 
    -0.07891624f, -0.02390822f, 0.05111620f, 0.04772101f, 0.01050820f, -0.00366915f, -0.11926860f, -0.07723396f, 
    -0.22182326f, -0.00596479f, -0.38146362f, 0.05067582f, 0.02748812f, -0.06126610f, -0.08198214f, -0.08243924f, 
    0.03420301f, -0.05842558f, -0.20127565f, 0.08589818f, 0.02974692f, -0.03788872f, -0.11740713f, -0.03120442f, 
    -0.03393950f, -0.08717517f, 0.02340430f, 0.08434160f, -0.10456384f, 0.31339458f, 0.03366309f, -0.11469772f, 
    -0.12780921f, -0.12625121f, 0.08152770f, -0.00615112f, -0.04736120f, -0.00449934f, -0.01450814f, 0.08307557f, 
    -0.07144506f, 0.05489134f, -0.05664212f, 0.00493215f, 0.04733996f, -0.03968539f, 0.00314694f, -0.00267929f, 
    -0.31506261f, 0.11049744f, 0.16180275f, 0.03010256f, 0.05836606f, 0.03455164f, 0.04349402f, -0.02387533f, 
    0.08939423f, 0.05661015f, 0.01626192f, 0.01989639f, 0.05233254f, -0.12553842f, -0.01558067f, 0.09310421f, 
    -0.03465087f, 0.04350710f, 0.04546791f, -0.02851067f, -0.08223714f, -0.43588689f, 0.02523878f, -0.12189749f, 
    -0.10508709f, -0.02555841f, -0.06541944f, -0.06422572f, -0.01030112f, -0.06616100f, -0.09510539f, -0.02547347f, 
    -0.07503609f, 0.01905990f, -0.04661488f, -0.02704296f, -0.00437284f, -0.06958793f, -0.02492801f, -0.03878622f, 
    0.20078088f, 0.09937331f, 0.19091621f, -0.04572875f, 0.30486366f, 0.00288441f, 0.11155948f, 0.02247858f, 
    0.01437241f, -0.01814513f, 0.00406211f, 0.04111977f, -0.14390050f, 0.04208075f, 0.02121359f, -0.15180679f, 
    0.01993538f, 0.01915129f, 0.09155224f, -0.11562674f, -0.34392816f, -0.04816379f, 0.02047246f, -0.06878322f, 
    -0.14746906f, -0.09008007f, -0.03780615f, -0.06280141f, -0.07586030f, -0.03271512f, 0.00063410f, -0.04577642f, 
    -0.01473344f, -0.04187312f, -0.12539248f, 0.06342372f, -0.05703372f, 0.03093002f, 0.03631220f, -0.05273597f, 
    0.20872848f, -0.31030008f, 0.05525150f, -0.12381731f, -0.02700791f, -0.04055968f, 0.06928060f, -0.05513640f, 
    -0.05226283f, -0.00379989f, -0.01701780f, -0.02357286f, -0.00142744f, 0.05728153f, -0.04224633f, -0.09533578f, 
    0.07449295f, 0.00972458f, -0.00920734f, -0.09843534f, 0.02889149f, -0.31934285f, -0.10232755f, 0.03731352f, 
    0.10284729f, -0.06372411f, -0.10250507f, -0.08060452f, 0.01832872f, -0.01766536f, -0.08357844f, -0.01907772f, 
    0.00414897f, 0.00285063f, 0.04255923f, -0.02681596f, 0.07571328f, 0.02383054f, 0.00347834f, 0.10178593f, 
    0.08555955f, -0.07346235f, -0.11386651f, -0.25327367f, -0.10931827f, -0.02818986f, -0.04658259f, -0.04184099f, 
    -0.02514559f, -0.10015121f, -0.04013681f, 0.00006040f, -0.16230500f, 0.01238121f, -0.10760716f, 0.06423990f, 
    -0.01048768f, -0.04954058f, -0.05358236f, -0.05818177f, -0.38480970f, 0.15933757f, -0.01801775f, 0.08035538f, 
    0.09079836f, 0.01238229f, -0.11791347f, -0.03897508f, 0.08318501f, -0.02098727f, -0.01995302f, 0.01939531f, 
    0.03824929f, -0.04065031f, -0.10757688f, 0.04506467f, 0.05230820f, 0.07216068f, 0.00807820f, -0.02983065f, 
    0.19714490f, -0.09384802f, 0.21720068f, -0.00277334f, 0.18649383f, -0.01378161f, 0.08231235f, -0.03868730f, 
    0.05470654f, -0.01180666f, 0.01745839f, -0.01167489f, -0.10963818f, 0.00730923f, -0.08618232f, -0.04842951f, 
    -0.12173847f, -0.03607079f, -0.07400725f, -0.05835726f, -0.00301269f, 0.15614973f, 0.27406737f, 0.04530559f, 
    0.06286573f, 0.13831118f, 0.11094841f, -0.02961316f, 0.03712166f, -0.08681518f, -0.03904684f, -0.00738196f, 
    0.05308944f, 0.00331479f, -0.08333770f, -0.12753719f, 0.01913898f, 0.04672921f, -0.00325791f, -0.07148984f, 
    -0.11889737f, -0.17891572f, -0.06342084f, 0.12259177f, -0.02321634f, 0.07213107f, -0.09977613f, -0.03775905f, 
    0.06533681f, -0.09263530f, -0.10207124f, 0.00471235f, -0.00320081f, -0.03971869f, -0.11132953f, 0.04031196f, 
    0.09576402f, 0.04277895f, 0.10194740f, -0.02144010f, -0.17840685f, -0.02001422f, -0.20800029f, -0.07831600f, 
    0.06487177f, -0.02836316f, -0.01531635f, -0.04725724f, -0.03052601f, -0.04390868f, -0.07041924f, 0.01599434f, 
    -0.07111798f, -0.04860549f, -0.05498608f, 0.00543884f, -0.05162970f, -0.04917192f, -0.04772440f, -0.03846928f, 
    0.35648021f, -0.15352115f, 0.26661164f, -0.03416105f, 0.05949081f, -0.04073453f, 0.15378997f, 0.04684588f, 
    0.08105045f, 0.05835740f, 0.02838704f, 0.11677281f, -0.03620946f, -0.04200931f, -0.05036801f, 0.04468799f, 
    0.04059400f, -0.00616156f, -0.01278936f, -0.03277459f, 0.19578695f, -0.05618110f, 0.24813206f, 0.13402492f, 
    0.12900849f, 0.06087013f, 0.00535608f, -0.13420756f, -0.03967288f, -0.00635797f, -0.03072347f, 0.16779768f, 
    0.01183231f, -0.04925856f, -0.05693495f, -0.01710266f, -0.03223375f, -0.04096007f, 0.06199003f, -0.12924649f, 
    0.09793300f, 0.15215603f, 0.29781398f, 0.02292635f, 0.16763075f, 0.03232569f, 0.11984077f, -0.00372502f, 
    0.04074258f, -0.02344392f, -0.00981020f, 0.01114355f, -0.03398797f, -0.00483406f, -0.10263489f, 0.00119481f, 
    -0.03590266f, -0.04018758f, 0.06689101f, -0.02941136f, 0.09179277f, 0.16346398f, 0.22779302f, 0.18085504f, 
    0.16586863f, 0.07426533f, 0.07905458f, -0.04671685f, -0.06448334f, -0.03787904f, -0.02347146f, 0.00069238f, 
    -0.09495495f, -0.10721795f, -0.07781899f, -0.00655258f, 0.02660480f, 0.05003376f, 0.09451110f, 0.03952498f, 
    0.14706954f, -0.47967744f, 0.01269676f, -0.07022233f, -0.14813837f, 0.04389402f, 0.01161908f, 0.06415582f, 
    -0.00126449f, -0.10074621f, -0.05168779f, -0.08201723f, -0.09454715f, 0.03896160f, 0.06784964f, -0.04910561f, 
    0.04220868f, 0.01310637f, -0.00386595f, -0.05158167f, -0.13489388f, -0.22509193f, -0.08137865f, -0.11300239f, 
    -0.15046844f, -0.04986591f, -0.05158184f, -0.00420916f, -0.04545438f, -0.14377239f, 0.01551678f, -0.07077506f, 
    -0.08381015f, -0.01875214f, -0.03772247f, 0.00142493f, 0.02771523f, -0.01639901f, -0.04818254f, -0.01078649f, 
    0.06232118f, 0.21027263f, 0.02508429f, -0.09336719f, 0.01127173f, -0.12358391f, 0.13508438f, -0.11062691f, 
    -0.02685046f, -0.03845504f, -0.02014361f, -0.00253167f, -0.03221261f, -0.02051882f, 0.04354508f, -0.00935903f, 
    0.02076639f, 0.08700464f, -0.12495232f, 0.10161809f, -0.20864674f, 0.08425630f, -0.17716402f, 0.00971995f, 
    0.05710425f, -0.09447965f, 0.05223370f, -0.12338077f, 0.00250933f, -0.08955794f, -0.02794261f, 0.05656049f, 
    -0.11059754f, 0.00007676f, -0.04326522f, 0.02082881f, -0.07735357f, 0.04715960f, -0.07505456f, -0.00939594f, 
    -0.21402177f, 0.13835390f, -0.11190192f, -0.08168305f, -0.18750122f, -0.02817478f, -0.05516890f, -0.05801104f, 
    0.02005215f, -0.05566126f, 0.00881734f, 0.01559909f, -0.07997318f, -0.03510980f, -0.14512549f, 0.08743764f, 
    -0.00747431f, -0.01689640f, -0.01434915f, -0.01309415f, -0.01570386f, 0.10615293f, 0.23808241f, 0.18885788f, 
    0.13385399f, -0.00184704f, 0.07630412f, 0.01238207f, 0.05683120f, -0.10634110f, -0.09038011f, 0.04727438f, 
    -0.06917859f, -0.02321282f, -0.06182844f, -0.02919453f, -0.04269768f, 0.05794456f, -0.00921685f, -0.06605182f, 
    -0.21522051f, 0.05250338f, -0.14609873f, 0.08856676f, 0.06555535f, -0.09073639f, 0.03506237f, -0.11697637f, 
    -0.01546706f, 0.00017515f, -0.02336017f, 0.05318366f, -0.00022713f, -0.03205078f, 0.01831118f, 0.00948729f, 
    -0.09881287f, -0.06770886f, -0.02046483f, 0.00334678f, 0.11298098f, 0.04142619f, -0.08250470f, 0.00784704f, 
    0.23615845f, -0.19634055f, -0.08117185f, -0.03345000f, -0.01545606f, -0.00210844f, -0.04950523f, 0.02568522f, 
    -0.07924432f, -0.01609435f, -0.02786789f, -0.15223132f, -0.05786934f, -0.00716309f, -0.01133029f, -0.00454296f, 
    -0.18420541f, 0.17240316f, 0.06618268f, 0.12084504f, 0.14628369f, -0.14646670f, 0.05085785f, -0.03937185f, 
    0.03062308f, 0.00449754f, 0.04175317f, -0.00967607f, -0.04629543f, 0.03545646f, -0.12526681f, -0.01743566f, 
    -0.05434774f, 0.04316827f, -0.06418014f, -0.05307595f, 0.04200402f, 0.21609108f, -0.02112032f, 0.03133904f, 
    0.11219344f, 0.03118162f, 0.12087727f, -0.14342666f, 0.03432031f, 0.09126792f, -0.03807203f, -0.02714115f, 
    0.01583617f, -0.02868959f, -0.00327649f, 0.01621867f, -0.04216184f, -0.00543016f, -0.03962732f, 0.08220351f, 
    -0.10471161f, 0.16752708f, 0.14033613f, -0.04992437f, -0.01190619f, -0.07106082f, -0.02177553f, -0.11792852f, 
    -0.11340262f, -0.07215536f, 0.08269021f, 0.01129853f, 0.00145605f, 0.04601994f, -0.16765566f, -0.06994268f, 
    -0.00388013f, -0.01894755f, -0.04947744f, -0.09690907f, -0.20373705f, 0.16351530f, -0.02201861f, -0.22570896f, 
    -0.28930491f, -0.11637699f, -0.00286149f, -0.05569558f, 0.05151606f, -0.06851021f, 0.08086663f, 0.03188988f, 
    0.00513290f, 0.01533488f, -0.01860130f, 0.00965574f, 0.03296440f, -0.19338961f, -0.11637408f, 0.03957757f, 
    0.07158704f, 0.18703745f, -0.13907404f, 0.07108198f, 0.03261527f, 0.07247358f, -0.05429795f, -0.04853561f, 
    -0.06792133f, 0.01577169f, -0.00486029f, 0.08020438f, 0.03325931f, 0.10975708f, -0.02675229f, 0.07477557f, 
    -0.04876978f, -0.01275528f, 0.03433302f, 0.03306887f, -0.09298982f, 0.10455225f, -0.09706781f, -0.20809947f, 
    -0.12493798f, 0.06313579f, 0.04457468f, -0.00655123f, 0.07347048f, -0.07662971f, 0.12528546f, -0.02668618f, 
    -0.01929053f, 0.02830442f, 0.07739526f, -0.06297865f, 0.07211098f, -0.05115923f, 0.08644057f, 0.01187453f, 
    -0.08617372f, -0.11139277f, -0.07485071f, -0.09311314f, 0.11359381f, 0.10107209f, -0.02104746f, -0.02520772f, 
    -0.08343829f, -0.02169234f, 0.03531445f, 0.00881193f, 0.03066711f, 0.01678006f, 0.09821330f, -0.01024063f, 
    0.16243306f, 0.08532543f, 0.00345230f, -0.04804560f, 0.23050858f, 0.09621851f, -0.04364630f, 0.14267799f, 
    -0.03596159f, -0.06461459f, 0.08020446f, -0.09928149f, -0.07533512f, -0.07099543f, 0.11075652f, 0.03010742f, 
    0.07672911f, -0.17912729f, 0.05726197f, -0.11289781f, -0.05648541f, -0.07243967f, 0.23212592f, -0.12921184f, 
    -0.09740877f, -0.08817575f, 0.13352090f, 0.05768108f, -0.04145409f, -0.03964309f, -0.00481314f, 0.03587484f, 
    -0.05173618f, 0.09615669f, -0.03487399f, 0.03661952f, -0.13932681f, 0.09463407f, -0.00712904f, 0.00301781f, 
    0.05965984f, -0.12506928f, 0.06867854f, -0.03065128f, -0.14561144f, -0.24890110f, -0.05300437f, 0.15632172f, 
    0.19338559f, 0.15668216f, 0.02285399f, -0.04649998f, -0.05564956f, -0.07721175f, 0.08560928f, 0.01361175f, 
    0.09923090f, -0.02561621f, 0.10532445f, -0.06474897f, 0.08541782f, 0.01994911f, 0.03938577f, -0.11258395f, 
    -0.22072779f, 0.11956695f, -0.04272900f, -0.40267554f, -0.42681414f, -0.10522389f, -0.01524639f, 0.04173611f, 
    -0.05440133f, -0.06769270f, 0.01038234f, -0.04416553f, 0.01067176f, 0.03003953f, 0.04806415f, -0.06176389f, 
    -0.07624903f, -0.16571264f, -0.11192520f, -0.01963075f, 0.15983009f, 0.17224194f, -0.10881928f, 0.13542937f, 
    0.12793958f, -0.02681103f, -0.07150501f, -0.14408982f, -0.10680572f, -0.03403799f, -0.10544091f, -0.07425818f, 
    -0.01369013f, -0.02486661f, 0.05515349f, 0.03604900f, 0.01375159f, 0.06229397f, 0.08341174f, 0.02129028f, 
    0.14353798f, -0.07585866f, 0.13881011f, 0.07480476f, 0.08153337f, -0.03595613f, 0.06369343f, 0.07801767f, 
    -0.08797576f, -0.07781421f, -0.03945493f, 0.00631783f, -0.01475560f, -0.02736144f, 0.00452957f, 0.04955930f, 
    -0.11577763f, -0.00447728f, 0.07416989f, 0.01465859f, 0.02391221f, -0.11806995f, -0.37872642f, -0.16755401f, 
    -0.06067017f, 0.10832199f, 0.01182402f, 0.04228924f, 0.02520943f, -0.02084566f, 0.02345156f, -0.02623657f, 
    -0.02249598f, 0.08180188f, -0.03089511f, 0.10720114f, 0.04357735f, -0.03491595f, -0.08751453f, -0.08752377f, 
    0.19807662f, 0.16844200f, -0.03070830f, 0.06522657f, 0.16248851f, 0.05991832f, 0.04587346f, -0.07437580f, 
    -0.05289857f, -0.03272816f, -0.03544330f, 0.03801088f, -0.09747598f, -0.01325833f, 0.05127143f, -0.05923787f, 
    -0.00682508f, 0.07429074f, -0.01199645f, 0.03841496f, -0.08626558f, 0.09054958f, -0.27280414f, 0.03999754f, 
    -0.19811033f, -0.04798654f, -0.07071860f, -0.19778459f, -0.02466819f, -0.07584815f, 0.09105211f, -0.03859450f, 
    0.00785164f, 0.02787288f, 0.02444856f, 0.02308282f, 0.04680226f, -0.13992418f, 0.11096931f, 0.03655427f, 
    -0.11992083f, 0.13173677f, -0.23579833f, -0.12930933f, -0.18972573f, -0.07277391f, 0.01885510f, -0.07230513f, 
    -0.07738344f, -0.00839833f, 0.02885056f, 0.01550015f, -0.02975911f, 0.01735210f, 0.03252056f, -0.08530176f, 
    0.00554611f, -0.14216636f, -0.06908552f, -0.04593997f, -0.00456886f, -0.20997284f, 0.12847924f, 0.11741681f, 
    0.07699335f, -0.15914997f, -0.06286503f, -0.01499236f, -0.09409998f, 0.05549171f, -0.00487215f, -0.06673305f, 
    -0.04796854f, -0.03289551f, 0.02817395f, 0.01398680f, -0.00879558f, -0.06924975f, 0.09341867f, -0.03662998f, 
    0.11303883f, -0.05613253f, -0.33414221f, -0.01609782f, 0.05620330f, 0.04883909f, -0.04010905f, -0.00143016f, 
    0.00593291f, -0.01550400f, 0.09164926f, -0.04603553f, 0.02493639f, 0.00765803f, 0.12039569f, 0.01043227f, 
    -0.01256871f, 0.03732747f, 0.06251504f, 0.03634207f, 0.09091967f, 0.20933965f, 0.08452941f, 0.10102578f, 
    -0.00225265f, 0.05840671f, -0.03972808f, -0.09605593f, -0.11905330f, -0.06134554f, 0.12308433f, 0.02393375f, 
    -0.00851609f, -0.02871514f, -0.16716678f, -0.05471893f, 0.04304955f, 0.05950474f, 0.06258527f, -0.06850625f, 
    0.00315873f, 0.27300993f, -0.07485647f, 0.01460313f, 0.24296021f, -0.06510645f, -0.08914448f, 0.02286248f, 
    0.00836717f, 0.08677191f, 0.00879362f, -0.03853457f, -0.25543332f, -0.08630075f, 0.04494587f, 0.03818416f, 
    -0.09166558f, 0.15385245f, 0.09988883f, 0.05541432f, -0.17848779f, -0.18053024f, 0.32614911f, 0.01977681f, 
    0.30044505f, -0.09100465f, -0.02202318f, 0.11894727f, -0.11384185f, -0.03520865f, 0.04534072f, -0.03554462f, 
    0.03396476f, 0.07703605f, 0.09597405f, -0.04144250f, -0.02457066f, 0.07717329f, -0.13014263f, 0.09720886f, 
    -0.23223551f, 0.08984382f, 0.32264096f, -0.04773627f, 0.01950515f, -0.01738034f, -0.06576666f, -0.03341364f, 
    -0.03166898f, 0.00205268f, 0.03280972f, -0.08097494f, -0.07940861f, -0.00499174f, 0.02594474f, -0.02605933f, 
    0.02932011f, -0.05269318f, 0.02014600f, -0.05189414f, -0.28510010f, -0.10034924f, 0.28845438f, -0.23436140f, 
    -0.20466621f, 0.00490605f, 0.02858596f, -0.02571605f, -0.07256471f, -0.10006312f, 0.05557760f, 0.06315926f, 
    -0.00227617f, -0.05698468f, -0.07762042f, -0.08064901f, 0.06560113f, -0.06462635f, -0.28284517f, -0.02846576f, 
    0.13523339f, -0.16269958f, -0.34389913f, 0.09423316f, 0.04559615f, 0.12993634f, 0.01618235f, -0.00062988f, 
    -0.03570938f, -0.05830179f, -0.00110522f, 0.01799993f, -0.00956292f, 0.03594449f, -0.03552058f, 0.00349455f, 
    0.05146093f, -0.02041790f, 0.08838540f, 0.00017804f, 0.20731792f, 0.20583020f, -0.04415549f, 0.13965274f, 
    0.13729063f, 0.01300154f, 0.01198435f, -0.04198702f, -0.07773762f, -0.02349409f, -0.02501862f, -0.01552175f, 
    -0.06815685f, -0.05410794f, -0.00922855f, -0.08469497f, -0.04437030f, 0.08267990f, 0.06154424f, -0.04628582f, 
    -0.15086502f, 0.11428629f, -0.17069671f, -0.08910761f, -0.16525981f, -0.05085804f, 0.00196906f, -0.04454644f, 
    -0.00154242f, -0.04338244f, 0.08455390f, 0.03373215f, -0.00592606f, 0.05499060f, -0.00406149f, 0.01386502f, 
    0.02941843f, -0.07381441f, 0.01422852f, 0.08903076f, -0.03879993f, 0.16827057f, -0.00977639f, 0.10398923f, 
    -0.09069572f, -0.14969413f, 0.00444018f, -0.09119909f, -0.02260753f, 0.02148737f, 0.08209223f, -0.00557055f, 
    -0.03324835f, 0.03006343f, -0.02054293f, -0.08501556f, 0.04700768f, -0.02462479f, 0.16724773f, 0.02591406f, 
    0.13415274f, 0.03322567f, -0.22761945f, 0.15317845f, 0.16921312f, 0.10973252f, 0.03483013f, -0.12378087f, 
    -0.01081550f, -0.01381344f, 0.13026184f, 0.00523314f, 0.04223488f, -0.09254792f, 0.11539250f, -0.00760326f, 
    0.04640026f, -0.00042593f, 0.12190675f, 0.01425832f, -0.21162817f, 0.01471324f, 0.21489955f, 0.06340778f, 
    0.05488661f, -0.11957987f, -0.05009459f, 0.01644026f, -0.07952031f, -0.05366213f, 0.03983282f, 0.03455982f, 
    -0.02378449f, -0.02605473f, 0.03036550f, -0.00534808f, 0.03160383f, 0.00748183f, -0.00578909f, 0.06398573f, 
    -0.05493466f, -0.07536892f, -0.22712670f, 0.15595219f, -0.03033636f, -0.02426261f, 0.08570439f, -0.12600842f, 
    -0.11676013f, -0.10431809f, 0.14551759f, -0.00102484f, 0.05932989f, -0.03465265f, 0.11574312f, -0.03853740f, 
    -0.01670448f, -0.05429525f, 0.06564030f, -0.14652532f, -0.05258762f, -0.12356009f, 0.03534494f, -0.21334727f, 
    -0.09378072f, 0.07251489f, -0.12183844f, -0.05000605f, -0.08259510f, -0.11781432f, -0.09167777f, 0.04611287f, 
    -0.00039473f, -0.00770856f, -0.02900789f, 0.02550784f, 0.00546594f, -0.00584709f, -0.28061828f, 0.03878073f, 
    -0.09325334f, -0.06845710f, 0.02898811f, 0.05941682f, -0.19871281f, -0.02984500f, 0.02188715f, -0.04942818f, 
    -0.02783852f, 0.09232581f, 0.06546399f, 0.00322266f, -0.00182489f, 0.09143040f, 0.01674179f, -0.00980067f, 
    0.00268652f, -0.08739988f, 0.04001053f, -0.17989251f, -0.30716071f, 0.02395320f, -0.32981339f, -0.19066831f, 
    -0.26054782f, 0.07807393f, 0.04851231f, -0.15172340f, 0.07660893f, -0.06601068f, 0.00471187f, 0.05165514f, 
    0.03285535f, -0.05564523f, 0.03098308f, -0.09530564f, -0.01692246f, -0.04554417f, 0.09123736f, -0.08043661f, 
    0.68373728f, -0.12950356f, -0.18766232f, -0.30011693f, -0.13439333f, -0.01258168f, 0.05212767f, 0.09032137f, 
    0.12600267f, -0.05590506f, -0.04771757f, -0.09302407f, 0.06105968f, 0.15727691f, -0.15150955f, 0.13214953f, 
    0.13596605f, 0.13782626f, -0.03828529f, 0.02679599f, -0.18706772f, 0.03430133f, 0.13037586f, 0.00576920f, 
    -0.12510078f, 0.10807182f, 0.04031889f, -0.03624200f, -0.05276033f, -0.05364271f, -0.08058225f, 0.06882159f, 
    -0.05078749f, -0.07836526f, 0.16745596f, 0.06493096f, 0.11236352f, 0.01356419f, -0.01808057f, -0.06521367f, 
    0.27756846f, -0.43189773f, 0.15654291f, -0.00226241f, -0.14428365f, 0.01323000f, -0.02159572f, -0.13541022f, 
    0.06239549f, 0.14560555f, 0.01873419f, 0.05180315f, 0.04990861f, -0.28128082f, 0.05158098f, 0.02797120f, 
    0.03207358f, -0.12055084f, 0.04150475f, 0.06477697f, -0.00456307f, -0.08357852f, -0.39870745f, 0.18359786f, 
    -0.28032482f, -0.06701799f, 0.09325136f, 0.03755631f, 0.02980400f, -0.04854364f, -0.12047885f, -0.12473854f, 
    0.02379279f, 0.18985167f, 0.09116153f, -0.04795516f, 0.02575436f, 0.04697433f, 0.06103269f, 0.08172811f, 
    0.07244314f, 0.00611139f, -0.00442332f, -0.39893720f, -0.35222122f, 0.04206680f, 0.17627302f, -0.09086970f, 
    -0.09013277f, 0.08612401f, -0.04775205f, -0.10934946f, -0.15240009f, -0.16287893f, 0.02721721f, -0.05403077f, 
    0.09248745f, -0.09915877f, -0.01746543f, 0.05570266f, -0.84333503f, 0.40331271f, 0.23926270f, 0.03130087f, 
    0.21884537f, 0.11954496f, 0.11219954f, -0.00688394f, 0.05174032f, -0.08965351f, 0.02533291f, 0.08482639f, 
    -0.06550088f, -0.01027793f, 0.12188072f, 0.14823560f, 0.02363802f, 0.13797310f, -0.16850598f, 0.14457408f, 
    -0.24358687f, -0.31751463f, 0.08396031f, 0.06854694f, 0.07132255f, -0.03163097f, 0.02000805f, -0.08857841f, 
    0.05328266f, 0.15807265f, -0.08159677f, 0.15904182f, 0.00835052f, 0.06785537f, -0.23133998f, -0.06107166f, 
    -0.07194016f, 0.03631188f, 0.02815390f, 0.07000659f, 0.16038916f, -0.41754597f, 0.10408100f, -0.13349952f, 
    -0.09501316f, -0.11159449f, 0.06434342f, -0.17021200f, -0.02317267f, 0.05076624f, -0.10037818f, -0.06201425f, 
    0.08391280f, -0.16799448f, -0.11472315f, -0.00411238f, 0.05762709f, -0.04676922f, -0.08663630f, -0.00202584f, 
    -0.22805130f, -0.06033954f, -0.04143485f, 0.01092848f, 0.11594298f, -0.00942880f, 0.00482076f, -0.02837863f, 
    0.03100514f, 0.13243803f, -0.06258394f, -0.01593308f, -0.11047076f, 0.00142084f, 0.02668012f, 0.20550808f, 
    -0.12756288f, 0.09687731f, 0.06173176f, 0.12239174f, -0.24239708f, 0.03103134f, 0.14620209f, -0.09164929f, 
    0.06354881f, 0.10541804f, 0.06347812f, 0.03738667f, 0.04908036f, 0.04026029f, -0.04488609f, -0.00858372f, 
    0.00350150f, -0.00479085f, -0.01488949f, 0.00069156f, -0.08890378f, -0.05936374f, -0.20503606f, 0.04542994f, 
    0.31527796f, -0.24474005f, 0.09373105f, 0.00238935f, -0.04535060f, 0.10772048f, -0.05980935f, 0.00555476f, 
    0.02731829f, 0.03468462f, -0.10475566f, 0.04938709f, -0.10817989f, 0.03621433f, 0.04395492f, -0.00794994f, 
    0.01279838f, -0.05739994f, -0.12337346f, 0.03306274f, -0.10041825f, -0.01677681f, 0.12383403f, -0.43199912f, 
    -0.25261158f, -0.01874859f, 0.06206597f, -0.03603079f, -0.02141767f, 0.04806872f, 0.01957121f, 0.01672228f, 
    0.05070990f, -0.11651838f, -0.11628183f, -0.09932680f, -0.00097974f, 0.05814309f, 0.20154324f, 0.04899025f, 
    0.05249264f, -0.10321623f, 0.13269334f, -0.06563095f, -0.04968308f, 0.03152419f, 0.16465594f, -0.10424088f, 
    0.07511628f, -0.19560599f, -0.08340089f, 0.15885109f, 0.03912614f, -0.00865247f, 0.00646302f, 0.00760385f, 
    0.03705497f, -0.25753394f, 0.03525713f, -0.18430074f, -0.47909763f, -0.18807499f, 0.19471031f, 0.06529506f, 
    0.20574313f, -0.02862793f, -0.00221227f, 0.00562830f, 0.04994335f, -0.01716060f, -0.15511525f, 0.00772564f, 
    -0.09856380f, 0.00036707f, -0.10790106f, 0.14708261f, -0.04370181f, 0.03476598f, -0.05554926f, 0.07537729f, 
    -0.38597372f, -0.00349547f, 0.06819773f, 0.12297370f, -0.06757397f, -0.09619862f, 0.01665150f, -0.00332699f, 
    0.01195529f, -0.07763615f, 0.16904822f, 0.02528665f, 0.08522056f, 0.08887509f, 0.13938901f, 0.13683319f, 
    -0.04913342f, 0.01094596f, 0.13440689f, 0.07129829f, -0.02317481f, -0.22684515f, -0.12368158f, 0.15158744f, 
    0.24453890f, 0.11985271f, -0.08840372f, 0.00305005f, -0.06384303f, 0.17940733f, -0.15667085f, -0.03538653f, 
    0.10816403f, 0.08621428f, 0.00784931f, -0.09561423f, -0.05648216f, -0.08308294f, -0.02236296f, -0.04746342f, 
    -0.01735459f, 0.00749836f, 0.18947065f, -0.40254971f, 0.11722777f, -0.17657939f, 0.01312953f, 0.05228433f, 
    0.11434606f, 0.05733483f, 0.01764872f, 0.00541293f, -0.05599227f, -0.06449187f, 0.03087940f, -0.04006758f, 
    0.02709474f, -0.04366602f, -0.12279009f, -0.05094309f, 0.54962689f, -0.08362342f, -0.22566193f, -0.09870233f, 
    -0.33537331f, 0.05240930f, 0.03042284f, 0.11844587f, -0.02413392f, -0.15388262f, -0.08150522f, 0.02679398f, 
    0.01408610f, 0.14145385f, -0.08205055f, 0.00281626f, 0.02530361f, -0.08320319f, -0.20528747f, 0.01807701f, 
    -0.20467412f, 0.11447284f, -0.17609316f, 0.16533677f, -0.27120426f, 0.02166632f, 0.05637701f, -0.11707251f, 
    0.12141557f, 0.04596047f, -0.13236451f, 0.05865738f, 0.09024941f, -0.03970156f, 0.08551386f, 0.01839357f, 
    -0.07035438f, -0.01083253f, -0.10138065f, 0.04488260f, 0.34909731f, -0.11094550f, -0.23818663f, 0.15585050f, 
    0.03879872f, -0.05226734f, 0.01300324f, -0.07472711f, 0.08075719f, -0.07701968f, -0.08825435f, 0.05400792f, 
    0.07296827f, -0.15631899f, -0.01162461f, -0.07695384f, 0.04462554f, 0.05976022f, 0.03938789f, 0.00469246f, 
    -0.04759806f, -0.29003611f, -0.06059969f, 0.12974912f, -0.01480193f, -0.03385092f, 0.04295466f, -0.05667740f, 
    -0.05948932f, 0.13770169f, -0.10633562f, -0.01757428f, 0.04120104f, 0.03754568f, 0.09457725f, -0.03256708f, 
    -0.14306304f, -0.08816971f, 0.01859335f, -0.13721332f, 0.05951126f, -0.18176234f, 0.00650677f, 0.18484604f, 
    -0.03660753f, -0.05197675f, 0.05316974f, 0.03763355f, -0.03373544f, -0.07021253f, -0.05779091f, -0.09975481f, 
    0.01533954f, -0.09223558f, 0.06282555f, 0.14660017f, -0.01427301f, 0.03963676f, 0.02746543f, 0.03387908f, 
    -0.11279662f, -0.33949074f, 0.28417024f, -0.12175049f, -0.30552885f, 0.06457676f, -0.09748149f, -0.01847885f, 
    0.01153103f, -0.00926148f, -0.00825526f, 0.00040621f, -0.07505112f, 0.08878830f, 0.08690451f, -0.06697609f, 
    0.00981268f, 0.03367912f, 0.10813192f, 0.07235400f, 0.06242477f, -0.06247937f, 0.12558092f, 0.05522995f, 
    -0.11384923f, 0.04281864f, 0.09180189f, 0.01847310f, 0.00616834f, -0.15674575f, 0.01845053f, 0.05801481f, 
    -0.11767154f, -0.05956599f, 0.12136835f, 0.04637054f, -0.02068016f, -0.05605636f, 0.09358232f, -0.00935775f, 
    -0.54716265f, 0.16664778f, -0.19811830f, 0.13483089f, -0.00003064f, 0.07720060f, 0.11580248f, -0.04004177f, 
    -0.04488469f, -0.04181235f, -0.05856774f, -0.11884351f, -0.08439758f, 0.03444089f, 0.01671997f, 0.02285008f, 
    -0.01721603f, -0.00824765f, 0.02049024f, 0.07093310f, -0.10660228f, 0.40003625f, 0.10841341f, 0.25900447f, 
    -0.06161471f, 0.05604164f, 0.12765010f, 0.16480240f, 0.03655158f, -0.18475665f, 0.08911189f, 0.06730237f, 
    0.17310995f, 0.01059898f, 0.12339547f, 0.01731187f, -0.03473269f, 0.10278319f, -0.13191789f, -0.07050683f, 
    0.04180479f, -0.22750479f, 0.20213325f, -0.36542046f, 0.07272481f, 0.00065491f, 0.13007577f, -0.12091079f, 
    0.03340822f, -0.14800622f, 0.12537679f, -0.09173906f, 0.00383364f, 0.03698796f, -0.06666257f, -0.02045268f, 
    0.01528877f, 0.00257913f, -0.24059716f, -0.05648231f, 0.07745983f, -0.14892600f, 0.03309122f, 0.11179724f, 
    0.07052584f, 0.09549639f, -0.04821658f, -0.12670401f, -0.04374734f, 0.05758986f, -0.07671808f, -0.03029581f, 
    0.02830419f, 0.04474862f, 0.15412146f, -0.08203017f, -0.16534434f, 0.13106123f, -0.08311012f, 0.02059896f, 
    -0.48330492f, 0.08346510f, 0.07011918f, -0.02028060f, -0.30532250f, -0.00562276f, 0.03312540f, -0.12872054f, 
    -0.08398694f, -0.00875083f, -0.11089976f, 0.06805022f, -0.08710082f, -0.00373761f, 0.03352850f, 0.08145911f, 
    0.05007522f, 0.09720643f, -0.03345263f, -0.02658911f, 0.15710339f, 0.21157749f, -0.16664053f, -0.17885070f, 
    -0.07217170f, -0.01248150f, 0.01069268f, 0.03062800f, -0.10502157f, -0.02876247f, -0.05667764f, 0.08009155f, 
    -0.07905445f, 0.00227719f, -0.12301350f, 0.05585527f, -0.02778586f, -0.12455343f, 0.11928514f, 0.04272609f, 
    -0.19714035f, 0.15279271f, -0.06176298f, -0.10753519f, 0.05745066f, 0.08748933f, -0.00042066f, -0.06491371f, 
    -0.06651656f, 0.17358333f, -0.06421231f, -0.06049816f, 0.05339279f, -0.07986911f, 0.10596965f, 0.20593685f, 
    0.03228153f, 0.04046799f, 0.09868203f, 0.02490061f, 0.05726798f, -0.39896867f, 0.12302423f, 0.06116241f, 
    0.00093808f, -0.02855567f, 0.00097074f, 0.11582398f, 0.19867232f, 0.01668545f, 0.07384074f, 0.04260126f, 
    0.15197767f, 0.06979457f, 0.05464558f, 0.10249946f, 0.06358296f, 0.03961824f, -0.05665367f, 0.05153699f, 
    -0.41071269f, -0.03413124f, 0.29688346f, 0.08600485f, -0.06314518f, 0.02296767f, 0.00435018f, -0.00634313f, 
    -0.04816249f, 0.09384619f, -0.00139057f, 0.07004763f, 0.05778689f, -0.20581263f, 0.07485022f, -0.11157186f, 
    -0.06021951f, 0.00683705f, -0.02205342f, -0.00242762f, 0.08142145f, -0.03365876f, 0.05279688f, 0.08278857f, 
    0.07676618f, 0.09212915f, 0.11166891f, 0.07018999f, -0.02121678f, 0.03246198f, 0.04967761f, 0.04354917f, 
    -0.00474110f, 0.02796841f, 0.00380527f, -0.03115327f, -0.01020468f, -0.23797214f, -0.09053297f, -0.00218135f, 
    -0.15135011f, 0.12778378f, -0.09430324f, 0.02747259f, 0.08849915f, 0.02808493f, 0.02872104f, -0.02291184f, 
    0.04984425f, 0.06641651f, -0.06835730f, -0.02679115f, -0.01694069f, 0.03749789f, 0.08292889f, 0.09390488f, 
    0.08420411f, 0.19462450f, 0.05342802f, 0.11783568f, -0.06114187f, -0.15139432f, 0.02059508f, 0.00933326f, 
    0.09753121f, 0.02236909f, -0.00437471f, 0.01009137f, -0.06500956f, -0.00440782f, 0.03004978f, -0.04668827f, 
    0.02377195f, -0.04919114f, 0.03385961f, -0.05237958f, 0.01728668f, 0.01773402f, -0.01739554f, 0.09026386f, 
    -0.49722663f, -0.35822880f, 0.09989206f, -0.18088327f, -0.30419806f, -0.01590475f, -0.02117696f, -0.04532221f, 
    -0.13075440f, 0.08394594f, -0.01092883f, -0.00509400f, 0.00810259f, 0.15227343f, -0.07058401f, 0.05528002f, 
    -0.07171115f, -0.05761794f, -0.05447810f, -0.12623526f, -0.62157065f, -0.38405931f, -0.14453919f, -0.18731014f, 
    -0.07576296f, -0.00216128f, 0.01231026f, 0.05183570f, -0.14531164f, -0.12357768f, 0.20187272f, -0.11917163f, 
    -0.01774853f, -0.15694951f, 0.01293738f, -0.02160319f, -0.16322620f, -0.00094315f, 0.14231132f, -0.05428576f, 
    0.24800356f, 0.13466381f, -0.07468537f, 0.20825915f, -0.08562506f, -0.07584432f, -0.04342480f, 0.05288774f, 
    0.05400607f, 0.07770148f, 0.07531576f, 0.02356974f, -0.03050672f, -0.05427650f, 0.00749891f, 0.05607086f, 
    -0.04378583f, 0.02183636f, 0.02244147f, -0.02524907f, -0.45532730f, -0.06122674f, 0.02971158f, -0.01857328f, 
    -0.10477908f, 0.07230590f, 0.02697089f, -0.00503542f, 0.00625582f, 0.01691176f, -0.03967753f, -0.02730895f, 
    -0.10855650f, 0.09329576f, 0.05022610f, -0.01059898f, -0.07812992f, -0.07243378f, -0.11524848f, -0.08191118f, 
    0.22105068f, 0.02849988f, -0.11626809f, 0.07557770f, -0.11547442f, 0.06575661f, 0.14286044f, 0.06092981f, 
    0.08603333f, 0.12061436f, -0.06834186f, -0.01645912f, 0.11904805f, -0.10295383f, -0.00755872f, -0.03614453f, 
    0.07346416f, -0.31174153f, -0.09218220f, 0.04122126f, 0.16210267f, -0.03649192f, -0.12641233f, 0.03279830f, 
    -0.03623557f, -0.07404525f, 0.03500656f, -0.02948518f, -0.01982428f, -0.01959278f, -0.00677014f, 0.03588813f, 
    -0.13340701f, 0.00314367f, 0.10848413f, 0.00594169f, 0.09383541f, 0.07969009f, 0.00029205f, 0.04217437f, 
    0.02570225f, -0.07692231f, -0.14655469f, 0.02888781f, 0.01398197f, 0.00601109f, 0.02170542f, 0.04706265f, 
    0.02190345f, 0.03671658f, 0.07562192f, 0.05597095f, 0.10339581f, -0.10232873f, 0.03615455f, 0.09000678f, 
    0.06670675f, 0.12273950f, 0.02410619f, 0.13039921f, 0.13593957f, 0.17950502f, 0.08085936f, -0.07442443f, 
    -0.13729294f, 0.07745268f, -0.05729674f, -0.01650108f, 0.08169228f, 0.03808055f, -0.00910264f, 0.06130760f, 
    0.04472427f, 0.11036550f, -0.00661216f, 0.06438218f, 0.07891220f, 0.00105240f, -0.02344324f, -0.00020026f, 
    -0.51695955f, -0.16430424f, -0.15684928f, -0.16868998f, -0.17196652f, 0.07029182f, 0.06502753f, -0.09014666f, 
    -0.03707656f, 0.10441621f, 0.03281930f, 0.00382052f, -0.05668407f, 0.03110800f, 0.01626376f, -0.04399516f, 
    0.07565393f, 0.14246055f, 0.09200812f, 0.12963174f, -0.12616046f, -0.02454217f, -0.14800335f, 0.19450097f, 
    0.05259486f, 0.02266569f, 0.04450026f, -0.05026510f, 0.03087987f, 0.02675461f, 0.03568916f, 0.07642365f, 
    0.04091545f, -0.10615841f, 0.14233141f, 0.00416193f, -0.06126276f, -0.16386688f, -0.03030155f, -0.08060647f, 
    0.11854213f, -0.02441613f, -0.07031381f, 0.13729085f, 0.00230599f, 0.01705408f, 0.00996929f, -0.00224566f, 
    0.05359489f, 0.03649933f, -0.01457893f, 0.03768045f, -0.08237198f, -0.00355149f, -0.10144767f, -0.00408486f, 
    0.00791013f, -0.03232019f, -0.02414571f, -0.02744300f, 0.24868794f, 0.17590076f, -0.25095680f, 0.10553228f, 
    -0.07870871f, -0.11781963f, -0.16385028f, -0.05186662f, -0.02118057f, 0.01010459f, 0.03952479f, 0.05272307f, 
    -0.11319797f, -0.09887139f, -0.09861338f, -0.04433320f, -0.04953520f, 0.03543863f, -0.11252866f, -0.01589223f, 
    -0.18186435f, -0.17185034f, -0.25051138f, 0.00853039f, 0.05591517f, 0.03565676f, -0.02216190f, -0.08088645f, 
    -0.06317610f, 0.15587111f, 0.02743417f, -0.00733202f, 0.11368105f, -0.13383862f, 0.03469378f, 0.09415492f, 
    0.00803490f, 0.03121331f, -0.02722291f, 0.06312376f, -0.50023210f, -0.32655641f, 0.06997116f, -0.00641275f, 
    -0.19081488f, 0.04000982f, 0.00124285f, -0.05133015f, -0.04939647f, 0.09161110f, 0.03226663f, 0.07422110f, 
    0.01393983f, -0.01177954f, 0.06524134f, -0.06779697f, -0.01058707f, 0.09007964f, 0.06857215f, 0.10853256f, 
    0.38775432f, -0.21342713f, -0.06780065f, 0.01326966f, 0.14772867f, -0.18700877f, 0.00868234f, -0.11164239f, 
    -0.02379498f, -0.14699276f, -0.02854989f, 0.02617278f, -0.08753486f, -0.18974933f, -0.03204475f, -0.31103048f, 
    0.12868890f, 0.04548827f, -0.08550984f, 0.03509797f, 0.23201868f, 0.10682631f, -0.05944577f, -0.04970260f, 
    0.05706783f, 0.00570073f, 0.02210790f, -0.01142338f, 0.02155425f, -0.05293467f, 0.00220014f, 0.01435638f, 
    -0.06245316f, 0.08829501f, -0.07081229f, -0.07291711f, 0.12432299f, 0.02329673f, -0.13893957f, 0.11993733f, 
    0.31495291f, 0.05298217f, -0.03294927f, 0.12726113f, -0.12317022f, -0.06292623f, -0.05086044f, 0.01405160f, 
    0.00761033f, -0.00949613f, -0.04135448f, 0.04926535f, -0.06536477f, -0.05181515f, -0.09832700f, -0.07563977f, 
    0.01955032f, -0.12177410f, -0.12766655f, -0.08255818f, 0.26450533f, 0.13191406f, 0.05421964f, -0.11512626f, 
    0.00008882f, 0.06793270f, -0.08948966f, 0.14230584f, -0.07536683f, 0.08369211f, -0.01678493f, -0.02020141f, 
    -0.04323252f, 0.03081404f, -0.07102104f, 0.03376669f, -0.00597975f, -0.25201389f, -0.17012237f, -0.02787268f, 
    -0.50838190f, -0.21554679f, -0.21204351f, -0.14304787f, -0.16304283f, 0.02852922f, 0.08338238f, -0.07706816f, 
    -0.02349320f, 0.12080178f, 0.04238175f, 0.09409773f, -0.03298724f, -0.00313674f, 0.01955629f, 0.17107163f, 
    0.01549404f, 0.16473766f, -0.01548625f, 0.04037721f, -0.39074567f, -0.36945015f, -0.23216400f, -0.08742069f, 
    -0.21176980f, 0.03334624f, 0.12330621f, -0.08159995f, -0.08053501f, -0.01717737f, 0.01134226f, 0.01796053f, 
    0.00065509f, 0.05313944f, 0.06083259f, -0.04311804f, 0.09207670f, 0.08878856f, 0.07376944f, 0.09975976f, 
    -0.22837242f, -0.26587328f, 0.03522444f, 0.03612503f, 0.27198249f, 0.06740375f, 0.09951717f, 0.01049943f, 
    0.01356402f, 0.00297928f, 0.03885182f, -0.01708273f, 0.06349257f, 0.05978684f, -0.00269713f, 0.12736480f, 
    0.06412800f, 0.03776423f, 0.01127235f, 0.02328331f, -0.12930886f, -0.20864764f, -0.10041703f, 0.04188019f, 
    0.08973697f, -0.02775501f, -0.01076578f, -0.05605755f, 0.04499923f, 0.06097986f, 0.07311524f, -0.07735107f, 
    -0.00221438f, 0.00242304f, -0.00353888f, 0.00139714f, 0.02395844f, 0.01819785f, 0.21951027f, 0.05628525f, 
    -0.67010480f, -0.31128693f, -0.40484458f, -0.23703514f, -0.06040193f, 0.14806508f, -0.00993577f, -0.18882038f, 
    -0.02751363f, -0.00526840f, 0.11070874f, -0.03881979f, 0.01948429f, -0.13823293f, 0.08872477f, -0.00197207f, 
    -0.10567591f, 0.06453369f, 0.03200883f, -0.03332058f, 0.22713637f, 0.07991996f, 0.09334788f, 0.00793987f, 
    -0.10045747f, -0.05887413f, -0.19830817f, 0.17528786f, 0.01354984f, 0.04794477f, -0.01108108f, 0.00548105f, 
    -0.01040978f, 0.03830077f, -0.00480112f, -0.00659649f, 0.02957888f, 0.07093047f, 0.02326855f, -0.04678200f, 
    -0.61503267f, -0.26458481f, 0.18475263f, 0.03098047f, -0.19806418f, 0.01786846f, -0.01914802f, 0.00455941f, 
    -0.08294760f, -0.06387693f, 0.05907613f, 0.01886488f, -0.00961208f, 0.06336772f, -0.06691058f, -0.03020961f, 
    -0.04448099f, -0.14299601f, -0.13492334f, -0.09769682f, 0.10623541f, 0.32559618f, 0.10945942f, -0.09203035f, 
    -0.12933564f, 0.02515430f, -0.00862108f, 0.00058854f, 0.12188349f, 0.01378522f, -0.02886484f, 0.02814092f, 
    0.16102873f, -0.03550186f, 0.00926564f, 0.04949934f, 0.17492950f, 0.02877503f, -0.00401430f, 0.12853782f, 
    0.01457579f, -0.01050847f, -0.00539553f, 0.03443440f, -0.13045757f, 0.00455140f, 0.02999334f, 0.05968046f, 
    -0.00602544f, 0.03427758f, 0.11119599f, 0.01134195f, 0.02379819f, -0.00136023f, 0.03058281f, -0.02053742f, 
    -0.05692673f, -0.08817799f, 0.13106234f, 0.05393320f, -0.30339298f, -0.04730181f, -0.00243640f, 0.06357684f, 
    0.32059589f, 0.05608534f, 0.09013775f, -0.06109446f, -0.03530995f, -0.10294435f, -0.02882222f, -0.02553483f, 
    -0.00529143f, 0.13950479f, 0.11701625f, -0.04696656f, 0.12503484f, -0.07158528f, 0.03240812f, -0.03707002f, 
    -0.21610391f, -0.45545846f, 0.00103905f, -0.10230314f, 0.26893926f, -0.06145353f, -0.17013231f, -0.01405129f, 
    0.04189530f, 0.10523269f, -0.03575195f, -0.05524957f, -0.00761361f, 0.05112484f, -0.02278162f, 0.07638370f, 
    0.11684389f, -0.00934467f, 0.02425906f, -0.08350483f, 0.05540133f, 0.11540180f, -0.20370491f, -0.07120532f, 
    0.30315587f, -0.02214247f, -0.17651321f, -0.00717408f, -0.02365265f, -0.06974656f, 0.01270214f, 0.08020326f, 
    -0.03516348f, -0.00770056f, 0.03189921f, 0.01040780f, 0.03545408f, 0.06700599f, 0.14387228f, 0.05269796f, 
    0.05212042f, 0.02261542f, -0.09526199f, -0.05543729f, -0.09555052f, -0.03769807f, 0.18714924f, 0.09233462f, 
    0.05154458f, 0.00453664f, -0.02461849f, -0.03130049f, -0.01245472f, -0.15167943f, 0.16357958f, 0.04483312f, 
    -0.01501272f, 0.03716809f, 0.00832090f, 0.01266266f, -0.50732952f, 0.17878966f, -0.07194099f, -0.11071327f, 
    0.23856178f, 0.05997042f, -0.07138181f, 0.15626211f, -0.04457657f, 0.15574010f, 0.03376054f, 0.14328833f, 
    0.02283212f, 0.09560503f, 0.05767472f, 0.05163994f, 0.09596412f, -0.11270129f, -0.07920933f, 0.01232664f, 
    0.35128778f, 0.15490939f, -0.35922751f, -0.15588772f, 0.09632576f, 0.04906983f, -0.14289869f, -0.07194017f, 
    0.08111499f, -0.02032799f, 0.06689391f, 0.08477063f, 0.04074086f, 0.00353110f, 0.04545246f, 0.11835306f, 
    -0.08723582f, 0.13619064f, 0.00609634f, 0.09636358f, 0.04832308f, -0.27767077f, -0.14187285f, 0.10668477f, 
    -0.23792087f, 0.13033791f, 0.08089332f, 0.02374962f, 0.00953712f, 0.03845772f, -0.05879630f, -0.01859339f, 
    0.02168068f, 0.12282718f, 0.06027913f, -0.01048167f, 0.08665164f, -0.08395229f, -0.08992320f, -0.03182273f, 
    0.38538712f, -0.36201209f, 0.08144067f, 0.08828521f, -0.00665349f, -0.04964073f, 0.04080437f, 0.07668902f, 
    -0.10216487f, -0.01487238f, -0.07741520f, -0.12253536f, 0.04746495f, 0.02047517f, -0.21440852f, 0.02634883f, 
    -0.14005189f, 0.00969120f, -0.12171469f, -0.08993629f, 0.36305445f, 0.11892445f, -0.23484746f, -0.17051491f, 
    -0.19261609f, -0.10684698f, -0.04283689f, -0.05148359f, 0.05297465f, -0.05112336f, 0.09343258f, 0.03902887f, 
    -0.10835365f, 0.00399948f, 0.02767895f, -0.05012532f, -0.00768372f, -0.01605370f, -0.00583934f, 0.04076207f, 
    -0.02307836f, 0.00767063f, -0.18114829f, 0.10877941f, 0.11840205f, -0.03847525f, -0.14246155f, 0.03279785f, 
    -0.04220756f, 0.00307702f, 0.14783005f, -0.04643325f, -0.00428710f, 0.00683824f, -0.03176484f, 0.13678409f, 
    0.02411338f, 0.08458461f, 0.01436221f, -0.04390464f, -0.19465286f, -0.31196362f, -0.09158897f, -0.02240284f, 
    -0.23278666f, 0.04066332f, 0.10063721f, 0.10751572f, 0.05699673f, 0.08161359f, -0.08361410f, 0.04049124f, 
    0.02992314f, -0.03667426f, -0.14257698f, -0.14015250f, -0.04611342f, -0.06783184f, -0.10017193f, -0.14517525f, 
    -0.39367074f, 0.16537262f, -0.04516736f, -0.04563827f, 0.10308386f, -0.08184175f, -0.10198470f, -0.03822363f, 
    0.13817756f, 0.19136952f, -0.08370557f, 0.00666955f, 0.03504488f, -0.06655051f, 0.03537752f, -0.01888001f, 
    -0.06696096f, -0.01432712f, -0.06917264f, -0.07498545f, 0.43289948f, -0.06052104f, -0.30622616f, 0.01264204f, 
    0.19045709f, 0.02023452f, 0.01174429f, -0.04814558f, 0.14516881f, -0.01339787f, 0.13177878f, -0.00543938f, 
    0.06239412f, -0.02826342f, 0.03259822f, 0.05853354f, -0.10529593f, 0.00278970f, 0.09520872f, 0.09586684f, 
    -0.05480716f, -0.35688820f, 0.05242193f, -0.20260674f, -0.23030315f, 0.07435681f, 0.04821306f, 0.01078751f, 
    -0.00966897f, 0.01022840f, 0.07706100f, -0.05469586f, 0.03357011f, -0.08883525f, -0.05380828f, -0.03700074f, 
    -0.03201163f, -0.00949853f, 0.03618443f, -0.00913417f, -0.02687807f, 0.02983067f, -0.14485508f, 0.16982035f, 
    -0.07138297f, 0.01530183f, 0.05663315f, -0.00123901f, -0.05761240f, -0.11742558f, 0.06421322f, -0.06212490f, 
    0.11867858f, 0.05226227f, -0.06813435f, 0.01905346f, 0.02330669f, 0.06463833f, -0.00454667f, -0.13656925f, 
    -0.03016329f, 0.12622833f, -0.15239628f, -0.03201072f, -0.03029365f, -0.09404925f, -0.10092733f, 0.07728827f, 
    -0.10999858f, -0.08184856f, 0.01961205f, 0.08638253f, 0.04388131f, -0.12049191f, -0.01726066f, 0.08086516f, 
    0.00212259f, -0.03799777f, 0.08328847f, -0.15522499f, -0.13097285f, -0.04839396f, 0.04967057f, -0.01391053f, 
    -0.02791735f, -0.01492190f, 0.09799100f, 0.06354548f, 0.02822193f, -0.12986407f, -0.20074511f, -0.03991996f, 
    0.11567527f, 0.15572074f, 0.01742407f, -0.05428950f, -0.05299849f, 0.09040920f, -0.26542866f, 0.03256388f, 
    0.24859568f, -0.09362720f, -0.25299919f, 0.18958028f, -0.21908458f, -0.00786655f, -0.12289620f, 0.09724651f, 
    0.00782872f, -0.06844505f, 0.11751465f, -0.08672166f, 0.02152543f, 0.04484345f, -0.02272456f, 0.10424670f, 
    0.03088379f, -0.10662681f, 0.08026841f, -0.01035931f, 0.03151784f, -0.33673403f, -0.06017609f, -0.07799486f, 
    0.03448826f, 0.05399347f, -0.14763707f, 0.08855307f, 0.07299285f, 0.14457227f, -0.00637027f, 0.00138499f, 
    0.00268767f, 0.01748461f, -0.05637770f, 0.06603102f, 0.06035256f, -0.08302586f, -0.05420872f, -0.22818664f, 
    -0.52175689f, 0.09326617f, 0.08616672f, 0.07771674f, -0.25634435f, 0.13035351f, -0.01326117f, 0.03148410f, 
    0.00374668f, 0.06236784f, 0.00449010f, -0.09101284f, 0.03860515f, -0.08824874f, -0.05677128f, -0.03344261f, 
    0.07239236f, -0.21094345f, -0.04274273f, -0.04021286f, -0.37368920f, 0.34761792f, 0.07706366f, -0.09731349f, 
    0.03301650f, -0.07830425f, -0.09792828f, 0.02060541f, -0.18909898f, -0.09860572f, -0.03121620f, -0.03965898f, 
    0.02566904f, -0.15439799f, -0.01706687f, 0.01296093f, -0.07011207f, -0.07608271f, -0.03652762f, -0.11482972f, 
    0.08619729f, 0.04557473f, 0.02332391f, -0.06513765f, -0.02355806f, -0.07940517f, -0.11593561f, 0.09524724f, 
    -0.16728078f, -0.20371571f, -0.03358726f, -0.03267188f, 0.05416209f, -0.09745248f, -0.05455801f, -0.06718534f, 
    0.00498099f, 0.01689941f, 0.05463295f, 0.08837138f, 0.29019487f, 0.15170364f, -0.21799919f, -0.17134811f, 
    0.06348629f, -0.34195825f, -0.12423787f, 0.07487171f, -0.03792261f, -0.10770524f, 0.01925390f, 0.02500540f, 
    -0.06862439f, 0.02443374f, -0.02637643f, 0.10996721f, -0.06566422f, 0.09014881f, 0.17151578f, 0.06925602f, 
    0.60368365f, 0.09944557f, -0.21300948f, 0.05376090f, 0.11541829f, -0.06444211f, -0.02935378f, 0.01553562f, 
    0.03686692f, 0.08743312f, 0.01456186f, 0.04376509f, 0.05138973f, -0.00366694f, -0.04507195f, 0.09707326f, 
    0.05435231f, -0.03072193f, -0.03931228f, -0.03817004f, 0.14174742f, -0.26545796f, -0.18686989f, -0.17267038f, 
    -0.25056276f, 0.00038343f, -0.01457682f, 0.05737903f, 0.02322806f, 0.11651401f, 0.02303036f, 0.04465767f, 
    -0.00979483f, 0.01601422f, -0.02290660f, -0.05530958f, -0.05674144f, 0.02702899f, -0.14615017f, -0.06922314f, 
    -0.24466765f, 0.22686829f, -0.14016514f, 0.11238698f, 0.07556468f, 0.19364572f, 0.02156158f, 0.00665221f, 
    -0.02244269f, -0.06347604f, 0.03574233f, 0.09958489f, -0.03434756f, 0.06990519f, 0.10894784f, -0.05254963f, 
    0.13286598f, 0.06607531f, -0.13675809f, 0.05843152f, -0.14414354f, -0.15912783f, 0.08995242f, 0.05367351f, 
    -0.00062668f, 0.13448954f, -0.06874027f, -0.01910089f, -0.04196469f, 0.08902124f, -0.07360255f, 0.06622877f, 
    -0.03252107f, -0.07483713f, -0.04287069f, -0.18755955f, 0.03251956f, -0.00557131f, -0.04995177f, 0.00323328f, 
    0.12743963f, -0.20482290f, -0.32753924f, -0.00772855f, -0.22154200f, 0.01937022f, 0.05178572f, -0.03997916f, 
    0.00101228f, 0.00957667f, 0.00805128f, -0.04936672f, -0.04485534f, 0.06933068f, -0.00866307f, 0.01746495f, 
    0.08644342f, -0.16671024f, 0.03043166f, -0.05123383f, 0.23163228f, 0.01434373f, 0.03593781f, -0.05445912f, 
    0.00885613f, 0.02457414f, 0.04294199f, 0.00787996f, -0.04490162f, -0.16990711f, -0.01421209f, -0.09436149f, 
    0.04197950f, 0.06294277f, -0.13059658f, -0.08089650f, -0.04983305f, 0.05809385f, -0.07960264f, -0.14139317f, 
    0.33184427f, 0.27492920f, -0.15418081f, -0.05883323f, -0.02609919f, -0.03469645f, 0.05930462f, 0.07947622f, 
    -0.07783850f, -0.03750013f, -0.05301261f, 0.06449404f, -0.10799325f, -0.09638726f, -0.01471515f, -0.05810205f, 
    0.05046281f, 0.05944734f, 0.00959239f, 0.08021820f, -0.13080133f, 0.05152742f, -0.06241306f, 0.02437965f, 
    0.35629761f, 0.07868411f, -0.10107253f, 0.12370205f, 0.09360693f, 0.03661319f, -0.01059750f, -0.18532965f, 
    0.03222855f, -0.00306173f, 0.15166958f, -0.05393598f, 0.07584177f, 0.00134367f, 0.12986642f, 0.00987184f, 
    0.17621553f, -0.23980628f, -0.01359019f, 0.13180384f, 0.02812637f, -0.14490822f, -0.10918554f, 0.09331182f, 
    -0.12059121f, 0.01108994f, -0.01583974f, -0.08126765f, 0.00156250f, -0.02655277f, -0.19008209f, -0.07704789f, 
    -0.06878736f, -0.03491123f, 0.11639378f, 0.03311792f, -0.23272732f, 0.42433122f, -0.13945137f, 0.11614375f, 
    0.11708102f, 0.15520580f, 0.15694419f, -0.03208466f, -0.00792687f, 0.03146534f, 0.01041846f, 0.03332181f, 
    0.02116421f, -0.02359363f, 0.03143254f, 0.01195620f, 0.16724278f, -0.06600070f, -0.07009663f, 0.15544967f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.07865722f, 0.07085010f, -0.02565637f, 0.00532965f, -0.00926734f, 0.04418272f, -0.02348268f, -0.02065707f, 
    -0.02018026f, 0.01726775f, 0.03769166f, 0.00798753f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
