#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.04502082f, -0.97335374f, 0.03321993f, -0.21887882f, 0.18165848f, -0.65666759f, -0.44462821f, 0.32906857f, 
    0.57566994f, 1.15553546f, -0.99886370f, -0.73523790f, -0.47893903f, -0.02216722f, -0.82708174f, -0.39626303f, 
    -0.18503511f, -0.65554434f, 0.80211800f, -0.27059132f, -0.09764209f, 0.76644868f, -0.51196873f, 0.35577676f, 
    -0.02390743f, 0.46273962f, -0.55723876f, 0.53128546f, 0.45163822f, -0.67473310f, 0.22450912f, 0.15076311f, 
    0.03949134f, -0.07518762f, -0.45253384f, 0.11099819f, -0.93502873f, 0.69273883f, 0.44194567f, -1.06061065f, 
    0.14563470f, 0.77820414f, 0.03192567f, -0.19603026f, 0.35507751f, -0.39509457f, 0.39051872f, 0.28601429f, 
    0.63183892f, 0.91610569f, -0.42485949f, -0.21797693f, 0.60417581f, -0.49192944f, 0.60735458f, -0.76686144f, 
    0.28253779f, -0.07641714f, 0.18893307f, -0.07468322f, 0.24635214f, 0.38813129f, -0.54991978f, -0.82965332f, 
    -1.04420650f, -0.65131605f, 1.15680087f, 0.79942131f, 0.05983606f, -0.14452159f, -0.27011064f, -0.01163875f, 
    0.98248810f, 1.08470988f, -0.49818012f, -0.42930099f, -0.75915498f, 0.36806017f, 0.01837518f, -0.23704366f, 
    0.01212465f, -0.70109773f, -0.45531374f, -0.30330706f, -0.10280202f, -0.97704971f, -0.36972293f, 0.58147269f, 
    0.40831968f, -0.12013222f, -1.08951521f, 0.22471488f, 0.67424583f, -1.09352446f, -1.08434129f, -0.13591632f, 
    0.15764496f, 0.63813937f, -0.25600678f, 0.40998486f, 0.49053028f, 0.25112423f, -1.01773548f, -0.66868389f, 
    0.70453429f, 0.30730069f, 0.11736647f, -0.38755438f, 0.72819608f, 0.62964016f, 0.68273342f, -0.22615430f, 
    0.14206330f, 0.06334481f, 0.17279620f, -0.08480223f, -0.25496879f, -0.50511861f, -0.02778716f, 0.20988002f, 
    0.45173487f, 0.26448485f, 0.07063491f, -0.15780504f, 0.05887813f, 0.33073521f, -0.03249698f, 0.41194502f, 
    0.84097964f, -0.73942465f, 0.13166364f, -0.76319593f, 0.09211808f, 0.41372636f, 0.46349847f, -0.11876564f, 
    -0.23170969f, 0.53342438f, 0.05836656f, -0.39315516f, 0.42822993f, 0.21236822f, 0.32646549f, 0.00015367f, 
    0.82238650f, -0.43898758f, -0.62822890f, -0.27824530f, -0.30825424f, -0.26252601f, 0.58905107f, 0.41824701f, 
    0.44680294f, -0.06622918f, -1.29868507f, 1.22770131f, -0.79183429f, -0.84900147f, 0.62228656f, 0.40464175f, 
    -0.61812192f, -0.26805967f, 0.55771643f, 0.66112858f, 0.50271279f, 0.01065097f, -0.61444521f, -0.62955964f, 
    0.31045884f, -0.47246528f, 0.29717022f, -1.36530840f, 0.72396058f, -0.15439714f, 0.41534233f, 0.12835215f, 
    -0.55900115f, 0.03379172f, 0.64368367f, -0.05462153f, -0.49480692f, -0.53418100f, -0.19985650f, -0.59748375f, 
    -0.46464372f, -0.16771233f, -0.63207686f, 0.45682338f, 0.07439597f, -1.34146440f, -0.49583143f, 0.31659064f, 
    -0.26078871f, -0.01959141f, 0.83232963f, 0.49468458f, 0.15647602f, -0.06881649f, -0.78888303f, -0.29614913f, 
    -0.40414968f, -0.81419981f, -0.73397309f, -0.38284928f, -0.67093760f, -0.60934156f, -0.95737362f, -0.32012025f, 
    0.45135817f, -0.33758298f, 0.31722918f, -0.12470678f, 0.09294802f, -0.10299955f, 0.26663628f, 0.32625285f, 
    0.69381094f, -1.37215054f, -0.76122171f, 0.20067564f, 0.82035238f, 0.44275182f, -0.20279190f, 0.23718178f, 
    -0.02534008f, -0.33953977f, -0.93369651f, -0.33979595f, -0.77625185f, -0.54257601f, -0.55174166f, 0.27543688f, 
    0.09809479f, 0.27332589f, -0.46507043f, 0.75538015f, -0.11819024f, 0.51672804f, -0.06633695f, 0.58359957f, 
    0.00838755f, -0.75568241f, -0.69778728f, 0.17887011f, -0.82405168f, -0.43667510f, -1.07728863f, -0.97017866f, 
    -0.95294225f, 0.01951259f, -0.34499499f, 0.60801882f, -0.93340683f, -0.74251944f, 0.33511066f, 0.33996931f, 
    0.16192797f, -0.47233418f, -0.57667142f, 0.30448362f, 0.01145563f, -0.00315458f, -0.01029207f, -0.09385145f, 
    0.28732374f, 0.52229309f, -0.99133706f, 0.32103357f, 0.02734098f, 0.21518843f, -1.36272597f, -1.19320226f, 
    -0.20121317f, 1.06196189f, -0.39188629f, -1.07490301f, -0.13943185f, -0.43137673f, -0.42203003f, -0.97365481f, 
    0.24948250f, -1.33180940f, 0.24348196f, 0.02917376f, 0.12534375f, -0.36694533f, -0.37559208f, 0.18518934f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.21373545f, 0.26834458f, 0.33536243f, 0.43766212f, 0.29270345f, 0.20918763f, 0.32869151f, 0.16909586f, 
    0.32478786f, 0.21357650f, 0.03269523f, 0.20605545f, -0.21178110f, -0.00033108f, 0.11693776f, -0.13564046f, 
    0.16814442f, 0.32913619f, 0.23818351f, -0.11801524f, -0.41930816f, 0.10029755f, -0.23503125f, 0.07896579f, 
    0.27959654f, -0.02016169f, 0.11105279f, -0.10299726f, 0.32070747f, 0.39363271f, -0.25418672f, -0.00843424f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02971255f, 0.13639542f, 0.02870341f, -0.08259877f, -0.06588896f, -0.06011891f, -0.20222798f, -0.13356678f, 
    -0.30023617f, -0.19551450f, -0.08296998f, 0.04544096f, -0.01184573f, -0.08605412f, -0.02330151f, -0.11640608f, 
    0.02124782f, -0.11506107f, -0.26633337f, -0.08250710f, 0.18773203f, 0.03924233f, 0.16621003f, -0.18384950f, 
    -0.13083781f, 0.12661697f, -0.09104053f, 0.14691849f, -0.13078256f, 0.09615871f, -0.02470884f, -0.01327465f, 
    -0.08477671f, -0.11780024f, -0.15774450f, -0.07186323f, -0.12384735f, 0.11053980f, 0.11233868f, 0.27179521f, 
    -0.27593589f, -0.18661606f, -0.13738813f, 0.01023001f, 0.00354614f, -0.01981174f, -0.02459026f, -0.05581744f, 
    0.03766980f, 0.06289329f, -0.10835395f, 0.13796537f, -0.04231035f, -0.12443548f, 0.00364212f, -0.11441825f, 
    -0.23819880f, -0.01474225f, -0.05727234f, -0.01828572f, -0.56847322f, -0.41852778f, -0.16972819f, 0.08784262f, 
    -0.41408342f, 0.00841450f, 0.00141791f, -0.02974384f, 0.07470117f, -0.02517722f, 0.02399191f, -0.05322627f, 
    -0.07032502f, 0.00859921f, -0.04225010f, 0.01140385f, -0.05761635f, -0.11718797f, 0.05522759f, -0.13777846f, 
    -0.40730050f, -0.08362449f, 0.38406289f, 0.03410468f, 0.07107054f, -0.18831381f, -0.26892731f, 0.22262874f, 
    0.05914484f, -0.05977342f, -0.04997608f, -0.14527103f, -0.08427112f, -0.12572184f, -0.04698955f, -0.10027511f, 
    -0.05380491f, -0.03986054f, -0.19537520f, -0.10850567f, -0.05179936f, -0.10180644f, -0.22071210f, -0.00099873f, 
    -0.00630051f, -0.01088778f, 0.01304318f, 0.02901166f, 0.09105465f, 0.05261717f, -0.18365565f, 0.00025087f, 
    -0.10753960f, -0.18589018f, -0.16703491f, -0.02451284f, 0.07805128f, -0.03516411f, 0.02226986f, 0.09723364f, 
    -0.12683237f, -0.06067255f, -0.14112015f, 0.00650483f, 0.07387612f, -0.06107980f, -0.06206630f, -0.00189344f, 
    -0.05861682f, 0.01378542f, -0.19810520f, -0.13294435f, -0.01337725f, -0.14833647f, -0.19049837f, -0.06044146f, 
    -0.11512171f, -0.01874367f, -0.21294872f, 0.06688030f, 0.38234302f, -0.04403373f, -0.66197497f, -0.08793322f, 
    -0.02311782f, 0.14707828f, 0.12474131f, 0.09845031f, -0.23609810f, 0.02684594f, -0.08098738f, 0.02728554f, 
    -0.05903394f, -0.01794373f, 0.03120205f, -0.02229852f, 0.13968512f, 0.08184844f, 0.01690517f, 0.06870619f, 
    -0.62442517f, -0.08088370f, -0.12181471f, 0.00014982f, -0.40079203f, -0.02104964f, -0.03028493f, -0.09322673f, 
    0.05600307f, 0.02250347f, 0.05606407f, 0.04707398f, -0.05450082f, 0.00927956f, 0.06973723f, -0.01874113f, 
    0.08341516f, -0.17024292f, 0.10892302f, -0.16698062f, 0.34219563f, 0.38683188f, 0.06813501f, -0.43667963f, 
    -0.14083856f, 0.07518454f, 0.06057046f, -0.19982547f, 0.01051402f, 0.03312962f, 0.05168723f, -0.06415465f, 
    -0.01715124f, -0.01992171f, 0.02007562f, -0.00899798f, -0.05108035f, -0.00618362f, -0.09674211f, -0.02874518f, 
    0.09574984f, 0.36485580f, 0.20345080f, -0.34573904f, -0.13602847f, -0.23056334f, 0.04248907f, -0.08153743f, 
    0.14133053f, -0.08976161f, 0.11911249f, -0.02165953f, -0.05414176f, 0.01346473f, 0.04027242f, -0.03737941f, 
    -0.00622107f, 0.02293322f, -0.16493744f, 0.12181027f, -0.52840239f, 0.08701216f, 0.08818236f, -0.14132556f, 
    -0.12349212f, -0.14260720f, -0.11924601f, -0.38018483f, -0.07320629f, -0.04839621f, 0.00212240f, 0.09141693f, 
    -0.04682219f, 0.03343416f, 0.11106794f, 0.05250769f, 0.09063317f, 0.03403686f, -0.00690799f, -0.04553399f, 
    -0.12964085f, -0.05989875f, -0.10684722f, 0.07671761f, 0.00668013f, 0.00765463f, 0.06822871f, -0.00298394f, 
    0.02109155f, 0.02284615f, 0.00744605f, 0.07492736f, 0.06198739f, 0.05876086f, 0.08560828f, 0.09555451f, 
    -0.11005956f, -0.06209108f, -0.02891457f, 0.02849753f, 0.11285260f, -0.01270850f, 0.01969316f, 0.05334796f, 
    0.10700802f, -0.01556675f, 0.02099432f, 0.02307485f, 0.09207381f, 0.05638042f, -0.09442333f, -0.12342435f, 
    -0.12885581f, -0.06376472f, -0.01904374f, -0.02989352f, 0.02974802f, 0.01134215f, -0.00299339f, 0.01274493f, 
    0.10174774f, -0.02303184f, -0.01687834f, 0.01178225f, -0.09129015f, -0.21761453f, -0.25958529f, 0.07242534f, 
    0.01401616f, -0.02978847f, 0.04293729f, 0.07712200f, 0.01497368f, -0.02493208f, -0.14672452f, -0.08800605f, 
    0.00760986f, -0.16325948f, -0.10381983f, -0.21850576f, 0.02952972f, 0.00317432f, 0.11631870f, 0.00381132f, 
    0.07121858f, -0.00143156f, 0.06906773f, 0.06451575f, 0.05750307f, 0.06580039f, 0.03789439f, -0.17106014f, 
    -0.05149053f, -0.00132931f, -0.04280414f, 0.03582958f, -0.04786711f, -0.01160189f, -0.06418509f, 0.00605862f, 
    0.23754980f, 0.20084846f, -0.07266591f, -0.04493978f, -0.00270892f, -0.04491871f, 0.03622936f, 0.04883029f, 
    0.04268528f, -0.14325052f, -0.03815775f, 0.11199389f, -0.03350682f, 0.03910137f, 0.02446309f, -0.02761737f, 
    -0.06357246f, 0.02388053f, -0.02515848f, 0.06044253f, 0.18193127f, 0.09027212f, 0.34880039f, -0.68600315f, 
    0.12038400f, -0.08573160f, 0.02814275f, 0.04954445f, -0.15174776f, -0.08584462f, -0.04141132f, -0.02892689f, 
    -0.08646436f, -0.05052568f, -0.11359160f, 0.00068338f, 0.01072203f, -0.10651944f, -0.03666689f, -0.17879099f, 
    -0.14582466f, -0.12271583f, -0.07740764f, -0.02719868f, -0.16167890f, 0.02505971f, -0.08173714f, -0.07787114f, 
    -0.01743814f, -0.07360301f, 0.00202799f, 0.01735000f, 0.00780166f, 0.05328925f, 0.00702885f, 0.00368145f, 
    0.03518584f, -0.17381273f, -0.07292868f, -0.11801088f, 0.29709581f, 0.19813740f, -0.16506167f, -0.02758464f, 
    0.03178562f, -0.11005829f, 0.13655724f, 0.17165679f, 0.05853989f, -0.21562286f, -0.05664597f, -0.17027575f, 
    0.05194465f, 0.01648171f, -0.02109422f, -0.08384510f, 0.05637191f, 0.03013116f, -0.04760719f, -0.03160001f, 
    0.32774395f, 0.34486672f, 0.04153743f, -0.27389190f, -0.03061515f, 0.23419276f, 0.21475019f, 0.33538601f, 
    -0.17078170f, -0.00383398f, -0.05590623f, -0.04605797f, -0.00161834f, 0.01574790f, -0.01830254f, -0.01276451f, 
    -0.09793434f, -0.06205450f, 0.11196849f, -0.20404375f, 0.04761767f, 0.11166307f, 0.21541928f, -0.16520263f, 
    0.06779156f, 0.05149824f, 0.07824926f, 0.12384108f, 0.08942443f, -0.18485174f, -0.07543331f, -0.26769641f, 
    -0.21457423f, 0.04380371f, 0.06646454f, 0.02273407f, -0.03661511f, -0.01534257f, 0.00621900f, -0.05137941f, 
    0.25534913f, 0.27982289f, 0.30605677f, -0.27827692f, -0.08954440f, 0.11248223f, 0.21370791f, 0.12845045f, 
    0.02844410f, 0.10546554f, 0.00034768f, -0.01484619f, -0.04892641f, -0.17336287f, -0.23193203f, -0.08415246f, 
    -0.17480175f, -0.01611800f, 0.03056132f, 0.15665066f, 0.03836913f, -0.01808159f, -0.01053483f, 0.06844036f, 
    0.07985730f, 0.04254076f, -0.01010994f, 0.02192031f, -0.02212014f, 0.06493371f, -0.19922389f, -0.06708707f, 
    -0.04785085f, -0.04310226f, -0.04645424f, -0.04343086f, -0.02841950f, -0.03890273f, -0.10131600f, -0.06271359f, 
    0.06487031f, -0.13219081f, -0.43323258f, 0.11086863f, 0.01136531f, 0.11453846f, -0.01490643f, 0.11735950f, 
    -0.06850606f, 0.04874451f, -0.00792865f, 0.03653139f, -0.20902510f, -0.07222200f, -0.11061441f, 0.09620918f, 
    0.07783484f, 0.01496395f, -0.05579264f, 0.02814559f, 0.29889569f, 0.37051851f, 0.07923218f, -0.48137176f, 
    -0.18482520f, 0.06933556f, 0.10657566f, 0.13013239f, -0.02428021f, -0.03313654f, 0.01615627f, -0.02390527f, 
    -0.00524051f, 0.06597493f, 0.04761651f, 0.00890122f, -0.03868465f, 0.01565131f, -0.02922118f, 0.00551191f, 
    -0.29569486f, -0.00169439f, 0.31543070f, -0.15902564f, 0.02400168f, -0.04073155f, -0.01573493f, -0.01207504f, 
    0.04387485f, 0.04310157f, 0.06265368f, 0.09205742f, 0.01306203f, 0.00241111f, 0.06810230f, 0.09947536f, 
    0.12752062f, -0.12190326f, -0.14978604f, 0.20720150f, 0.29242894f, 0.43812484f, 0.14878529f, -0.42782703f, 
    -0.15474500f, 0.13312902f, 0.06082432f, 0.01096710f, 0.04375178f, 0.03452443f, -0.02000889f, -0.05958259f, 
    -0.02468946f, 0.04281448f, -0.01695204f, 0.00462059f, -0.00488155f, 0.09014403f, 0.17764163f, -0.06890461f, 
    0.39487076f, 0.20222694f, -0.07442500f, -0.22951531f, -0.02697844f, -0.03440864f, -0.00439975f, 0.11967038f, 
    -0.05060364f, 0.03123835f, -0.08927607f, -0.07907266f, -0.02328493f, -0.07012124f, 0.00136728f, 0.02024288f, 
    0.05412134f, -0.02526039f, -0.03550220f, -0.08010840f, 0.01440986f, 0.03436571f, -0.10608629f, 0.07015495f, 
    -0.01259723f, -0.05169708f, -0.03368168f, 0.00909923f, -0.05242517f, 0.05316292f, -0.07097840f, -0.10659437f, 
    -0.21147102f, -0.05202074f, -0.09225095f, -0.10151802f, -0.11980946f, -0.16312580f, -0.10169271f, -0.08047016f, 
    0.58844227f, 0.31493700f, -0.01639568f, -0.44089857f, -0.02661058f, 0.04888844f, 0.19340780f, 0.14424953f, 
    0.06291219f, 0.10180496f, 0.03267365f, 0.00131248f, -0.00606525f, -0.09304029f, 0.08130863f, -0.06884122f, 
    -0.05787232f, -0.02669836f, -0.13532501f, 0.11031720f, 0.21247134f, 0.19527508f, -0.01993507f, -0.15637927f, 
    -0.01242731f, 0.05866039f, 0.18095344f, 0.21980503f, -0.05708485f, -0.15658329f, -0.06214776f, -0.00991167f, 
    0.01015919f, 0.04770521f, 0.04207778f, -0.02140076f, 0.00067302f, -0.05170231f, -0.17361391f, -0.02644833f, 
    0.17758189f, 0.17513430f, -0.24164304f, -0.14019968f, -0.18282281f, 0.02796836f, 0.09608168f, -0.07951900f, 
    -0.12994958f, 0.14341436f, -0.15027562f, 0.05636790f, 0.17286088f, 0.14617543f, 0.04022173f, -0.08199489f, 
    0.13972527f, -0.07651859f, 0.25639004f, 0.00976000f, 0.19118194f, 0.18151207f, -0.32571813f, -0.16737983f, 
    -0.28968650f, 0.04043140f, 0.00438617f, -0.18155134f, -0.05570560f, 0.08708749f, 0.04230438f, -0.00710339f, 
    0.07995358f, 0.07880954f, 0.02967951f, -0.09574313f, -0.09906720f, -0.10277593f, -0.29231933f, -0.02043870f, 
    0.65577179f, 0.15813279f, -0.12644815f, 0.06357247f, 0.05692227f, -0.01980278f, -0.02873107f, -0.04309288f, 
    0.10200450f, -0.04620054f, -0.00763052f, 0.04606022f, -0.05908978f, 0.03982459f, 0.00075056f, -0.11249366f, 
    -0.00451475f, 0.14305590f, 0.01597405f, -0.12126380f, 0.33331087f, 0.06060284f, 0.08838040f, 0.11035918f, 
    0.11200978f, 0.01165091f, -0.07591723f, 0.02844558f, -0.02567711f, -0.06345717f, -0.07544854f, 0.09454136f, 
    0.09274930f, -0.01106986f, -0.05120277f, 0.21706474f, -0.07505260f, 0.16531813f, 0.10925139f, 0.14226922f, 
    -0.21793042f, -0.35349429f, 0.03229703f, -0.10283577f, 0.05191495f, -0.05821510f, 0.08419584f, 0.11535471f, 
    -0.04716460f, 0.11884365f, 0.14682977f, 0.02429307f, 0.00786131f, 0.01519193f, -0.03099038f, 0.12883362f, 
    0.07565331f, 0.05023748f, 0.11944021f, 0.21710370f, 0.11914289f, -0.00798777f, -0.02023734f, 0.12452380f, 
    0.20413408f, -0.05522940f, 0.04027681f, -0.05239713f, 0.01675090f, -0.07052308f, 0.07905710f, -0.01042739f, 
    -0.16350725f, -0.03861256f, 0.13494124f, -0.01322704f, -0.15837377f, -0.10768211f, -0.00391108f, -0.04160102f, 
    0.18753922f, 0.05731974f, -0.11008754f, 0.06678856f, 0.15300205f, -0.13939947f, 0.07626225f, -0.04475712f, 
    0.02923810f, 0.00746784f, -0.07815063f, 0.12933971f, 0.09979689f, 0.21241859f, 0.03350404f, -0.07884531f, 
    0.03727510f, 0.04721348f, -0.05057004f, 0.04878613f, 0.43773761f, -0.26840505f, 0.07453002f, 0.01443122f, 
    -0.12791100f, 0.08152546f, 0.01266763f, 0.15859753f, 0.13239294f, -0.24671201f, 0.14141586f, -0.17092896f, 
    -0.05425397f, -0.15938735f, -0.11100788f, 0.08948975f, -0.05094020f, -0.14331245f, -0.01345984f, -0.04133482f, 
    0.10735188f, 0.00449808f, 0.21958934f, -0.01295092f, -0.17443691f, -0.03463798f, -0.12065725f, -0.00276075f, 
    -0.08430283f, 0.05494867f, -0.05679241f, -0.01173986f, -0.02299164f, 0.07875707f, -0.03726051f, -0.08290748f, 
    0.07514942f, 0.00140461f, 0.05783877f, 0.04900470f, -0.24160632f, 0.07911423f, -0.14793852f, 0.23692960f, 
    0.14244929f, -0.05420778f, 0.08937033f, 0.03953904f, 0.06470998f, 0.00620011f, -0.07973205f, -0.00102823f, 
    0.03953928f, 0.01450580f, 0.05831684f, 0.03837823f, -0.01117003f, 0.07462529f, -0.09841806f, 0.04171734f, 
    -0.51965046f, -0.07961679f, -0.29619130f, -0.08955651f, 0.12472114f, 0.06327858f, 0.05831371f, -0.22018972f, 
    0.25890392f, 0.02145384f, -0.05633762f, 0.10676862f, -0.01328453f, 0.02074632f, 0.05125857f, -0.03186482f, 
    0.00379371f, -0.02923306f, -0.09894133f, -0.15260248f, 0.00698552f, -0.08175437f, 0.30996960f, -0.03679976f, 
    -0.11377873f, 0.15723261f, 0.16531654f, 0.06452703f, -0.02269321f, 0.01142897f, 0.00789389f, -0.07288381f, 
    -0.01370098f, 0.03186053f, -0.04381019f, 0.08856104f, 0.04739966f, -0.07509045f, 0.04674260f, -0.09504864f, 
    0.34171414f, 0.10303937f, 0.05436497f, 0.13991216f, 0.19775909f, -0.00925515f, -0.06507808f, -0.05432775f, 
    -0.05102510f, -0.04372526f, -0.00458699f, -0.02929490f, -0.02886529f, 0.05237946f, -0.01886073f, -0.07213560f, 
    0.09080733f, -0.11113804f, 0.02770689f, -0.12006249f, 0.03201866f, 0.00089318f, 0.05512623f, 0.06222189f, 
    0.02067442f, -0.00210439f, -0.06871690f, 0.00610000f, -0.06369636f, -0.09194773f, -0.10597385f, 0.10929000f, 
    -0.03221435f, 0.03237199f, 0.01899134f, -0.01480974f, 0.00975352f, -0.06931332f, -0.08153465f, -0.05923145f, 
    0.11606609f, -0.00636383f, 0.01600455f, -0.20392689f, 0.03591625f, -0.02407920f, 0.00345288f, -0.22183703f, 
    0.01333318f, 0.10201588f, -0.06931739f, -0.06768724f, 0.09696077f, 0.04778669f, 0.04329309f, -0.13832419f, 
    0.03566148f, -0.05948352f, 0.06094082f, -0.11362302f, 0.01074003f, -0.09096776f, 0.06888866f, -0.05767529f, 
    -0.01296752f, -0.00455161f, -0.03395621f, -0.01522620f, 0.03009203f, -0.02205405f, 0.12515832f, 0.07109845f, 
    -0.08456506f, 0.19664778f, -0.13784830f, -0.25435895f, 0.06773572f, -0.01773267f, 0.00135013f, -0.03299049f, 
    -0.09822308f, -0.08785184f, -0.22232196f, -0.09165736f, -0.17006771f, 0.02775329f, 0.07652899f, 0.07057452f, 
    -0.01222610f, 0.05468660f, 0.24512739f, -0.00161710f, -0.00985036f, 0.09449548f, 0.01713139f, -0.00553160f, 
    0.00138999f, -0.04891137f, 0.10109837f, 0.06017273f, -0.92609358f, 0.29810500f, -0.38236386f, -0.19834003f, 
    0.32824475f, -0.14864670f, 0.14234684f, -0.12875195f, 0.02265021f, 0.00438745f, 0.02713414f, 0.01840287f, 
    0.09961835f, -0.07809559f, 0.12987417f, 0.06388786f, -0.02953975f, 0.01081553f, -0.24463512f, -0.16860688f, 
    0.13697344f, 0.13419743f, -0.09648920f, -0.23465614f, -0.06713808f, -0.08708782f, -0.23392041f, -0.22506775f, 
    -0.04833575f, 0.00365341f, -0.07249662f, 0.02420838f, 0.03949655f, 0.07638492f, 0.02222290f, 0.04801096f, 
    0.01779232f, -0.01404775f, 0.13246499f, 0.06947211f, -0.41660309f, -0.17161460f, -0.11460297f, 0.13575085f, 
    0.15968114f, 0.04355347f, 0.01467152f, -0.11978850f, 0.21406190f, -0.04555972f, -0.19212921f, -0.05176267f, 
    -0.14389201f, 0.06292908f, -0.02486366f, -0.11188109f, 0.07525940f, -0.07502766f, 0.09369591f, -0.08621120f, 
    -0.18252984f, 0.24503325f, -0.09014615f, 0.23540124f, 0.08011360f, -0.20710190f, 0.01028256f, -0.32126957f, 
    0.08073182f, 0.05843357f, 0.03156377f, -0.00407967f, -0.00066352f, 0.02730113f, 0.04623132f, 0.02821282f, 
    0.06462091f, -0.00593229f, -0.16098014f, 0.09195186f, -0.40931550f, -0.26111013f, -0.28937519f, -0.09125797f, 
    -0.00842687f, 0.01400596f, 0.01638839f, 0.14690956f, 0.05229865f, -0.04416024f, -0.12310133f, 0.11433508f, 
    -0.09002539f, -0.01312673f, -0.08044239f, -0.06235353f, 0.03786355f, 0.00476323f, -0.04076827f, 0.03574831f, 
    -0.06525681f, 0.23519085f, 0.12933023f, 0.14346375f, 0.05806685f, 0.20139073f, -0.04999406f, -0.15024681f, 
    -0.07628704f, 0.04959328f, -0.01819986f, 0.03887585f, 0.03908913f, -0.04930100f, 0.09970815f, -0.18627776f, 
    -0.11077446f, 0.12311710f, -0.07472282f, -0.09578618f, -0.06247799f, -0.08908386f, -0.03545602f, 0.00315072f, 
    0.01009645f, 0.03693781f, -0.01421715f, 0.04075338f, -0.01960065f, 0.03988856f, -0.17052197f, 0.21005861f, 
    -0.05274217f, 0.01601656f, -0.02596503f, -0.07575837f, 0.02686325f, -0.04887504f, 0.01610176f, -0.01177490f, 
    0.69698232f, -0.34371844f, -0.17375475f, 0.02566815f, -0.17267942f, -0.03618829f, 0.06456827f, 0.02562662f, 
    -0.16983804f, 0.19873744f, 0.09698490f, -0.06965946f, -0.01611376f, -0.10357988f, 0.02001596f, 0.01024573f, 
    0.04835487f, -0.09989245f, -0.02525993f, 0.04496690f, -0.25156626f, 0.13370393f, -0.13071832f, 0.15811095f, 
    0.13702376f, -0.12743630f, 0.08027982f, -0.02146218f, -0.07839783f, -0.05575764f, 0.04262353f, 0.00504743f, 
    0.05740676f, 0.00476653f, 0.02437531f, 0.01665431f, -0.00561739f, 0.01080625f, -0.11944553f, 0.00421598f, 
    -0.45958018f, 0.06509282f, 0.15702562f, 0.26912466f, 0.18628462f, -0.00564437f, -0.06857750f, 0.03200516f, 
    -0.04779696f, 0.00393332f, 0.07409208f, -0.05291672f, -0.00528622f, -0.14625442f, 0.12744994f, 0.29079193f, 
    -0.19798806f, -0.05318511f, 0.12723139f, -0.27326360f, -0.24100609f, 0.12354060f, -0.17021282f, 0.09346901f, 
    -0.33520555f, -0.20885868f, -0.10241708f, -0.09785121f, -0.33781707f, -0.10281582f, -0.00570608f, -0.06562595f, 
    0.00124117f, -0.00401879f, 0.07699385f, -0.01486302f, 0.02950599f, 0.05297306f, -0.18754151f, -0.03863044f, 
    -0.15226276f, -0.02255532f, 0.13980003f, -0.07507759f, 0.03244545f, -0.03710349f, 0.09121674f, 0.02616086f, 
    0.34009638f, 0.01678788f, 0.10935809f, 0.00172323f, 0.04462525f, -0.01415420f, -0.09986276f, 0.00016537f, 
    0.07363854f, -0.05784192f, 0.00668560f, -0.10062686f, 0.03813900f, 0.01232241f, -0.14904906f, 0.02017210f, 
    0.03997562f, -0.01401303f, 0.08558597f, -0.01114729f, 0.15465924f, -0.03199667f, -0.04767575f, 0.06438462f, 
    0.12247109f, 0.02108428f, -0.00715859f, -0.00819398f, 0.10363933f, 0.16750263f, 0.10667899f, -0.13893330f, 
    0.36845511f, 0.28418201f, 0.15342949f, 0.09448608f, 0.11458771f, 0.20113100f, -0.26424098f, -0.00435874f, 
    0.26977405f, -0.28756338f, 0.09542533f, -0.07137034f, 0.04830777f, -0.13670467f, -0.02005862f, 0.00480113f, 
    0.00814196f, -0.01530359f, -0.18065500f, -0.05122463f, -0.51012391f, 0.13318352f, 0.34225395f, 0.12375797f, 
    -0.18123554f, 0.14237905f, 0.02165131f, -0.12103489f, -0.30146784f, -0.13902017f, -0.03153524f, 0.06391010f, 
    -0.04159889f, -0.14025868f, -0.10272948f, 0.12204339f, 0.14534675f, -0.13208187f, -0.08132242f, 0.08988725f, 
    -0.23032492f, 0.23264569f, -0.08845772f, -0.06524028f, 0.01690348f, -0.12782741f, 0.07750127f, 0.01481594f, 
    -0.18650575f, -0.04856709f, 0.11814006f, 0.00154213f, 0.01371014f, 0.03723093f, -0.01502566f, 0.04201447f, 
    -0.01752774f, -0.14719270f, 0.11985983f, 0.06289329f, -0.27621043f, 0.45673043f, 0.10852161f, 0.22478908f, 
    -0.38296789f, -0.04227328f, 0.04587129f, -0.09948529f, -0.16840053f, 0.09517426f, 0.00100613f, -0.02731201f, 
    0.00135233f, -0.03111335f, -0.01956420f, 0.09701501f, 0.16412997f, 0.24737941f, 0.16537924f, 0.20465373f, 
    -0.13478692f, 0.13388859f, -0.06951768f, -0.11105002f, -0.01588050f, -0.03523742f, -0.08464624f, 0.01539102f, 
    0.01173033f, 0.05960894f, -0.02290799f, 0.12910968f, -0.13700439f, 0.15384051f, 0.10755411f, 0.18289453f, 
    0.03631242f, 0.08886676f, 0.09200838f, -0.03392010f, -0.06676342f, 0.07068996f, 0.07752452f, -0.18676600f, 
    -0.01137066f, 0.00208561f, 0.00593442f, 0.00497606f, 0.00630042f, 0.05785467f, -0.00910099f, -0.01998575f, 
    -0.07699036f, 0.00820852f, 0.03533600f, 0.15579545f, 0.03008698f, -0.01894916f, 0.14675616f, -0.04345245f, 
    0.10891496f, 0.07415600f, -0.24546337f, -0.05294878f, 0.14684184f, -0.14818469f, 0.04977974f, -0.12738626f, 
    -0.13336582f, 0.04063028f, -0.03041407f, 0.02319832f, 0.11889772f, 0.00618137f, -0.07614447f, 0.11685582f, 
    -0.05710896f, 0.04911464f, 0.04727205f, -0.02480772f, 0.11591322f, -0.06701174f, -0.27354160f, -0.29101503f, 
    0.11435329f, 0.01685833f, -0.03563838f, -0.04849483f, 0.05621549f, 0.07677678f, -0.11826246f, -0.12884071f, 
    0.07512441f, -0.01781271f, 0.06064468f, 0.13903898f, -0.03993581f, -0.04273324f, 0.14075680f, 0.07966194f, 
    -0.03008090f, 0.05070204f, -0.07033169f, -0.02186772f, 0.11766358f, -0.01930148f, -0.02471320f, -0.03925748f, 
    0.01038687f, 0.03756468f, 0.19408320f, 0.08540384f, -0.12523675f, 0.04981801f, 0.03791155f, 0.09443099f, 
    -0.03269035f, 0.03730610f, 0.04874386f, -0.00862133f, -0.18093470f, -0.19869779f, 0.98816580f, 0.34351900f, 
    0.27470487f, -0.04965028f, -0.09580001f, 0.10727952f, 0.25465447f, -0.13036786f, 0.12936343f, 0.07873628f, 
    0.05992617f, -0.13409366f, 0.08118656f, 0.03177106f, 0.01486587f, 0.06092578f, 0.05435982f, -0.03960939f, 
    -0.57170737f, -0.04309031f, 0.23768458f, -0.12125969f, -0.15101123f, -0.04647866f, 0.08566029f, -0.02288419f, 
    -0.01208861f, 0.12729461f, 0.00013812f, 0.00627258f, -0.00349533f, 0.04028122f, -0.02187613f, 0.05819276f, 
    -0.08307789f, -0.06309471f, 0.03622376f, -0.07360943f, -0.11894206f, -0.10763896f, -0.27661303f, 0.08150784f, 
    -0.15918694f, 0.11710670f, 0.03007246f, -0.02125981f, 0.12887336f, -0.11744499f, 0.01204974f, 0.09774633f, 
    -0.03695107f, 0.02671459f, -0.03248280f, 0.02738509f, -0.00012455f, 0.02580283f, -0.00024611f, 0.08281679f, 
    -0.00148258f, -0.36799598f, -0.73258352f, -0.05067584f, -0.39195991f, 0.11943310f, 0.10026231f, 0.05170519f, 
    -0.03475527f, 0.00960610f, -0.07532977f, -0.06154134f, -0.13742466f, 0.01708278f, -0.05426382f, 0.00410043f, 
    -0.03923326f, 0.01759706f, -0.10683225f, 0.08008924f, -0.54197323f, -0.19224124f, -0.06626278f, -0.01850871f, 
    -0.23370525f, -0.03168954f, 0.10733175f, 0.06312314f, -0.24023673f, 0.15077119f, 0.04074753f, 0.02002555f, 
    -0.03004604f, 0.04158566f, -0.04402212f, -0.06697427f, -0.01439796f, 0.09903062f, -0.09258722f, -0.17281091f, 
    -0.36798319f, -0.34276325f, 0.04612488f, -0.31975895f, -0.06199951f, -0.02874569f, -0.08722577f, -0.01030457f, 
    -0.00600654f, 0.08219264f, -0.01336111f, -0.01484543f, -0.05786954f, 0.01471596f, -0.06063293f, -0.14021243f, 
    -0.18501808f, 0.09082182f, 0.01280098f, 0.00532237f, -0.00481273f, -0.05868970f, -0.00204078f, 0.07739337f, 
    0.11900590f, 0.03309834f, -0.04991494f, 0.07671395f, 0.03894700f, 0.03876643f, -0.26977661f, -0.02999127f, 
    0.16474551f, -0.03291687f, 0.04608675f, 0.02724210f, -0.05288010f, 0.00312310f, 0.01420587f, -0.10569087f, 
    0.03257915f, -0.06267944f, 0.17733791f, -0.08501553f, 0.08862428f, 0.01377839f, -0.14507297f, -0.39435065f, 
    -0.03976901f, 0.16125052f, 0.03531318f, -0.09349430f, 0.01999713f, -0.08637317f, 0.00162915f, 0.09571648f, 
    -0.01310544f, -0.16592826f, -0.08288202f, 0.06455488f, 0.01294705f, -0.02206969f, -0.09962303f, -0.00005506f, 
    0.06406987f, 0.00120812f, -0.00205558f, -0.04973739f, 0.02495239f, 0.01711618f, -0.15578152f, -0.09319150f, 
    0.04812174f, 0.01175973f, -0.09078763f, -0.02066992f, -0.02465703f, -0.01331790f, -0.04440043f, -0.04834401f, 
    -0.23411970f, 0.13402680f, -0.06319196f, -0.00329248f, -0.01180470f, -0.01576325f, -0.04564992f, -0.39250159f, 
    -0.25940958f, -0.30589890f, 0.07545929f, -0.13667467f, -0.02719011f, 0.04729858f, -0.00396214f, 0.00557583f, 
    -0.03255100f, -0.09712894f, -0.02357093f, -0.07052712f, 0.23092921f, 0.36749873f, -0.63189495f, 0.13443433f, 
    0.21669923f, -0.03160718f, 0.04673842f, -0.12471988f, 0.03813848f, 0.17656425f, 0.01237311f, 0.00139133f, 
    0.10223673f, 0.01187395f, -0.09292808f, -0.14028081f, 0.01778901f, 0.04681563f, -0.27714983f, 0.09088142f, 
    -0.40233532f, -0.03352855f, 0.27430210f, -0.37268648f, 0.07123321f, -0.01852443f, 0.03839124f, -0.05082409f, 
    -0.02709740f, 0.14375307f, 0.05440269f, -0.01384355f, 0.04062812f, 0.01009661f, -0.04240709f, -0.07978816f, 
    -0.18152146f, -0.22537872f, -0.03560381f, 0.01367506f, 0.48525324f, -0.15074971f, -0.04621842f, 0.17987004f, 
    0.02558467f, 0.15451166f, -0.31145406f, -0.17881699f, 0.08665951f, -0.07779977f, -0.06141700f, 0.19305386f, 
    -0.01537809f, 0.01782446f, -0.05016269f, 0.03132861f, -0.09022762f, -0.13435762f, 0.16156523f, -0.06938681f, 
    -0.05566561f, -0.53312004f, -0.49597582f, 0.02008226f, -0.35295177f, -0.20270658f, 0.04069725f, 0.24082915f, 
    -0.14326441f, 0.04893599f, -0.01823628f, 0.00886539f, 0.01736891f, -0.00528473f, 0.00324810f, -0.01069376f, 
    -0.00965258f, -0.05776598f, -0.39515612f, -0.03986627f, 0.33694786f, 0.22496571f, 0.00151796f, 0.03389074f, 
    0.27459568f, -0.06537482f, 0.02525248f, -0.03833540f, 0.04359520f, 0.09771497f, -0.04551138f, 0.03217033f, 
    0.02467085f, 0.04099754f, 0.00304553f, 0.00325250f, 0.00244070f, -0.00444483f, -0.10029639f, 0.07233296f, 
    -0.50214583f, -0.43584445f, -0.36226293f, 0.12591349f, -0.15640728f, -0.12592581f, -0.06272575f, 0.00250877f, 
    0.03511312f, -0.11656137f, -0.08926097f, 0.00459710f, -0.01881973f, -0.00733995f, 0.03764207f, -0.02119042f, 
    -0.01036191f, -0.00953974f, -0.06043496f, 0.14532842f, 0.09922160f, -0.06932347f, -0.01714122f, 0.06904130f, 
    0.02913178f, 0.08567572f, -0.04809411f, 0.02661039f, 0.05853289f, -0.05098229f, -0.17656097f, -0.04570575f, 
    0.05461510f, 0.03504706f, 0.04976709f, -0.00082244f, -0.10315482f, -0.06251603f, 0.04753695f, -0.09527077f, 
    0.06714399f, 0.13318162f, 0.45956171f, 0.03782550f, 0.25885782f, -0.09700578f, 0.03805063f, 0.07392953f, 
    0.04935464f, -0.06249615f, 0.10785506f, -0.02640130f, -0.02123888f, 0.00095393f, 0.17793265f, 0.02214190f, 
    -0.03595234f, -0.02252175f, 0.04154649f, -0.08543207f, -0.29585683f, -0.34958309f, -0.36155996f, 0.15791306f, 
    -0.30704558f, 0.06438644f, -0.04272432f, 0.11130445f, 0.01690699f, -0.12048306f, 0.02150531f, 0.05799163f, 
    0.04350346f, -0.03504789f, -0.02927244f, 0.01434886f, -0.02174872f, 0.00633935f, 0.00359553f, -0.07820503f, 
    0.14023492f, -0.34409344f, -0.06360676f, -0.38284534f, -0.02792840f, 0.02593670f, 0.02394771f, -0.01771732f, 
    -0.03452508f, 0.00586460f, -0.04666840f, 0.04531083f, -0.10045833f, 0.00550752f, -0.07834203f, 0.11874134f, 
    0.09336260f, 0.13368684f, 0.17497379f, 0.02413286f, -0.85976756f, -0.77794492f, -0.58516943f, -0.05606373f, 
    -0.53434157f, 0.04125109f, -0.00263217f, 0.10277318f, -0.14885086f, -0.17546001f, 0.00312365f, 0.00085180f, 
    0.00749132f, -0.06080073f, -0.10235921f, -0.06522292f, 0.01280141f, -0.00890343f, -0.14031453f, 0.02352756f, 
    0.37581345f, -0.00656772f, 0.28984398f, 0.44503602f, 0.12002582f, -0.05175387f, 0.12627253f, -0.07344658f, 
    0.07132658f, 0.10180170f, 0.03333670f, 0.04002454f, 0.03294579f, -0.01070364f, -0.00311727f, -0.00177334f, 
    0.04673506f, -0.03851400f, 0.06544837f, 0.03186676f, 0.08632634f, -0.05986992f, 0.04050779f, -0.07453088f, 
    0.05565844f, 0.09242802f, -0.14057955f, 0.01360857f, 0.03490584f, 0.08302979f, -0.05666818f, 0.00591430f, 
    0.19000380f, 0.01667296f, -0.00333941f, 0.02904884f, -0.05541132f, -0.11624736f, 0.06948654f, -0.04212372f, 
    -0.20407048f, -0.55596310f, 0.67683345f, 0.74834108f, -0.10169907f, 0.03123435f, -0.04334801f, -0.22542651f, 
    0.30771744f, -0.00024185f, -0.03329396f, 0.02368206f, -0.03936624f, 0.03983508f, -0.13679308f, -0.02212827f, 
    0.01163767f, 0.03486644f, 0.03276081f, -0.11754772f, 0.15918586f, -0.03541091f, 0.51580548f, 0.68240678f, 
    0.24007776f, 0.12192239f, 0.00116401f, 0.10122240f, 0.02677136f, -0.15257080f, -0.00407559f, 0.00241128f, 
    0.03332556f, -0.02680447f, 0.08415028f, -0.02794515f, 0.02694218f, -0.05067322f, 0.09891405f, -0.04632134f, 
    -0.51242983f, 0.18907632f, -0.24493507f, 0.38098094f, -0.05936957f, 0.12246162f, -0.23661198f, 0.22173852f, 
    0.08046047f, -0.05308989f, 0.04537511f, 0.05563730f, -0.15270402f, -0.01902992f, -0.08131883f, -0.02544968f, 
    -0.08835934f, 0.01597593f, -0.13851939f, -0.24806672f, -0.33053002f, 0.16164635f, -0.31741986f, 0.32561579f, 
    0.16470981f, -0.17292812f, -0.05862826f, 0.10103416f, -0.04324758f, 0.04195464f, -0.02002174f, 0.05355737f, 
    0.05061127f, -0.12438834f, -0.12658113f, 0.05571888f, 0.12949826f, -0.01378229f, -0.00224130f, -0.00493474f, 
    -0.78925258f, -0.08552064f, 0.03274861f, -0.12343135f, -0.23580095f, 0.06817836f, 0.02323225f, 0.07303945f, 
    -0.13038561f, -0.23196401f, -0.06848286f, -0.01106620f, -0.00481580f, 0.11106826f, -0.17870232f, -0.03979212f, 
    -0.01734076f, 0.12112667f, -0.13009405f, -0.02978915f, -0.03699933f, -0.08952508f, -0.13597558f, 0.33870065f, 
    -0.08663597f, -0.00258631f, 0.00245823f, -0.13147217f, 0.04710576f, 0.07582715f, 0.00478181f, -0.11877394f, 
    0.05293244f, -0.15770563f, -0.08729587f, -0.00435873f, -0.02972906f, -0.01241289f, 0.01062221f, -0.00465248f, 
    0.91990334f, 0.46198320f, -0.06345960f, -0.48186192f, -0.39276120f, -0.18980880f, -0.19253802f, 0.07058603f, 
    -0.13760063f, -0.26349381f, -0.04401622f, 0.00670843f, 0.05880580f, -0.12002227f, -0.05592737f, 0.01301845f, 
    0.04188056f, -0.19624321f, 0.10249744f, -0.13084246f, 0.05195934f, 0.79012185f, -0.42631060f, 0.06503373f, 
    -0.81539094f, 0.06564450f, 0.00884909f, 0.09713700f, -0.01541475f, 0.14898534f, -0.13488039f, -0.28893292f, 
    -0.01067168f, -0.10771501f, 0.01577857f, -0.16017684f, -0.09043875f, -0.15972067f, 0.22594567f, 0.05065667f, 
    -0.84042704f, 0.15541352f, -0.28391570f, 0.05434496f, -0.43058383f, -0.04304965f, -0.06689087f, -0.06481485f, 
    -0.26484233f, -0.05069342f, -0.07799745f, 0.20718089f, -0.01433572f, -0.05171164f, -0.10860108f, 0.06921139f, 
    -0.08994290f, 0.17462498f, 0.00952269f, -0.10055981f, -0.11617909f, 0.59466612f, -0.13784315f, -0.12173481f, 
    0.33376387f, 0.29633546f, 0.15436999f, -0.00364761f, -0.00373814f, 0.01423319f, -0.24490629f, -0.05754123f, 
    0.10437386f, 0.06132080f, 0.18761234f, -0.05165818f, 0.05992232f, -0.06679235f, 0.15281457f, 0.07104672f, 
    -0.63595825f, -0.41170028f, 0.51283264f, 0.20822112f, 0.59103328f, -0.13148721f, -0.02306952f, -0.19046350f, 
    0.05392474f, -0.08379973f, 0.13731448f, 0.05339690f, -0.03909982f, -0.07807476f, 0.06636935f, 0.09207302f, 
    -0.02616706f, 0.16785963f, 0.00523626f, -0.01597433f, 0.01210820f, -0.18973623f, -0.24573757f, -0.07374784f, 
    0.19407871f, 0.10842135f, 0.07629663f, 0.04359757f, 0.11211883f, 0.00095024f, 0.11550947f, -0.04749755f, 
    0.01393533f, 0.04541807f, -0.01862464f, -0.03872734f, -0.10034730f, 0.14607376f, -0.07585625f, 0.19860165f, 
    0.41362372f, 0.17361592f, -0.17398146f, -0.41913056f, 0.34593770f, 0.09106048f, 0.03120571f, 0.03095600f, 
    0.03926313f, 0.03769534f, 0.11429014f, -0.13689086f, -0.12568229f, -0.09725964f, -0.02661391f, -0.01640965f, 
    -0.07400808f, 0.01362003f, -0.10586484f, 0.15549836f, -0.18342017f, -0.08784716f, 0.44565177f, -0.01120795f, 
    0.12373317f, -0.11841133f, 0.03993077f, -0.14532642f, -0.04516828f, -0.11527203f, 0.04000018f, 0.01159035f, 
    -0.08987597f, -0.14500614f, 0.07142042f, -0.16229573f, -0.08746166f, 0.12375046f, -0.14256535f, -0.11074989f, 
    -0.61041862f, -0.58965862f, -0.24286570f, 0.02925025f, -0.62040895f, 0.11349910f, -0.29165232f, -0.04254242f, 
    0.12673913f, -0.02106458f, 0.00373774f, 0.09318241f, 0.11753740f, -0.00907777f, -0.08490684f, -0.07872830f, 
    0.02395164f, -0.05750679f, -0.08854389f, -0.03787361f, -0.09981088f, 0.47021827f, -0.16611673f, -0.10744034f, 
    -0.22035304f, 0.40626973f, 0.17949900f, -0.00391042f, 0.14280108f, -0.09483095f, -0.18529962f, -0.12003759f, 
    0.02476452f, -0.10474940f, 0.11096325f, -0.09386642f, 0.15641485f, -0.25193647f, 0.03881517f, -0.32632336f, 
    0.31268725f, 0.16681077f, 0.22180219f, -0.14256017f, 0.23348503f, -0.03334454f, -0.08656405f, 0.17092790f, 
    0.05419904f, -0.05400726f, 0.05493727f, 0.00107698f, -0.11936372f, 0.12225817f, 0.07386635f, -0.00493731f, 
    -0.01388827f, 0.02735586f, -0.09540761f, 0.01781902f, -0.22470310f, -0.49961257f, -0.26693130f, -0.10492593f, 
    -0.10742339f, -0.11208209f, 0.00059019f, 0.04642592f, -0.08513648f, -0.13086148f, -0.01163127f, 0.01051772f, 
    -0.29490820f, -0.17420483f, -0.04059473f, 0.25738901f, 0.05910467f, 0.06380828f, -0.11517859f, -0.20045751f, 
    -0.29481909f, 0.05151964f, -0.04761931f, 0.29846320f, 0.21770878f, 0.07656903f, 0.13229096f, 0.16183633f, 
    -0.03407332f, 0.09709073f, 0.06139088f, 0.10497507f, 0.02596062f, -0.10284314f, -0.12157784f, 0.18471713f, 
    0.05568019f, 0.03766046f, -0.05675973f, -0.15626293f, -0.20484307f, 0.10091020f, -0.05378266f, -0.13777524f, 
    0.01807654f, 0.02686299f, 0.19807102f, -0.16455562f, 0.00473477f, -0.10170942f, -0.01678716f, -0.00162230f, 
    -0.01409481f, -0.09031887f, -0.01171166f, 0.00678131f, 0.04921510f, 0.13488616f, -0.29030690f, -0.11476985f, 
    -0.37885436f, -0.29075718f, 0.82797426f, -0.21587446f, 0.42243209f, -0.22525951f, 0.07325472f, -0.07066675f, 
    -0.09863827f, -0.00393487f, 0.12016201f, 0.08451558f, 0.08349814f, -0.11019058f, 0.11756631f, -0.05670150f, 
    0.17131674f, 0.19256598f, -0.00479539f, -0.05754558f, 0.17965180f, 0.36521655f, -0.50802988f, -0.05841243f, 
    0.19994968f, 0.18795608f, 0.16494790f, 0.02861773f, -0.24110065f, 0.03680541f, -0.36825609f, -0.16606559f, 
    -0.10643082f, 0.08680378f, -0.04305413f, 0.05148245f, -0.01534226f, -0.10673197f, 0.13241687f, 0.14283907f, 
    -0.11678232f, -0.11490075f, -0.19708693f, -0.05252555f, 0.19709024f, 0.01832406f, -0.02483470f, 0.11786722f, 
    0.04400416f, 0.01092717f, -0.05493727f, 0.09104937f, -0.04840397f, 0.04369186f, 0.11244601f, -0.02539946f, 
    0.07768192f, 0.15670376f, -0.22342148f, 0.11480861f, 0.27463213f, 0.02481270f, -0.11541317f, -0.29108801f, 
    0.15429144f, 0.17429473f, 0.02298144f, -0.08690754f, -0.04879408f, -0.39273250f, -0.16229106f, 0.04913477f, 
    0.08490144f, -0.01860549f, 0.03449079f, 0.04541766f, 0.00832807f, -0.07024804f, 0.11557329f, 0.10080042f, 
    0.15712629f, -0.05221706f, -0.17082368f, -0.10311700f, 0.20416723f, 0.04830212f, 0.11288217f, 0.06503285f, 
    0.08486205f, 0.10628871f, -0.08902285f, -0.02146796f, 0.06357485f, -0.09515156f, 0.03429831f, -0.06375033f, 
    0.02429760f, 0.00259096f, -0.00215112f, 0.01330825f, -0.41936433f, -0.25512460f, 0.14387207f, 0.01609041f, 
    -0.05473547f, 0.10415800f, 0.04931443f, -0.03305091f, -0.16186692f, -0.04335064f, 0.11934547f, -0.01692786f, 
    -0.04634028f, -0.01966143f, -0.16631144f, 0.04084773f, -0.07570309f, 0.15875100f, -0.05569381f, -0.18531905f, 
    -0.55830973f, 0.92601591f, 0.00457588f, -0.03828191f, 0.38296530f, 0.14755806f, -0.07575466f, 0.10141069f, 
    -0.17059137f, -0.03851978f, -0.23492330f, -0.08980209f, 0.05899262f, -0.02362906f, -0.03310961f, 0.00712566f, 
    -0.14066920f, -0.00395146f, -0.05134146f, -0.00770410f, -0.04067011f, -0.03106346f, -0.20654608f, 0.05329705f, 
    0.20815323f, 0.07976805f, 0.03892379f, 0.02417355f, 0.05893105f, 0.13182628f, 0.03655798f, 0.05134485f, 
    -0.01285819f, -0.07417931f, -0.00784482f, -0.02467888f, -0.05924000f, 0.13690880f, -0.11499520f, 0.01971775f, 
    0.71090800f, -0.16903576f, 0.05981797f, -0.34807050f, -0.50167835f, 0.13494590f, 0.17224246f, 0.21216726f, 
    0.11951620f, 0.21183987f, -0.02254517f, -0.09442466f, 0.22902219f, -0.16148703f, -0.11091424f, -0.04129288f, 
    -0.05748065f, 0.02484806f, -0.09981799f, 0.05163823f, -0.02545152f, -0.04544301f, -0.35797086f, 0.17339054f, 
    0.28763384f, 0.07631804f, -0.05118412f, 0.11789232f, 0.07844249f, 0.22341587f, 0.02171095f, 0.00057654f, 
    -0.04728522f, -0.14522205f, -0.05693955f, -0.13505098f, -0.10939258f, 0.01542540f, -0.09533956f, -0.08587500f, 
    -0.34953535f, 0.24471968f, -0.20403121f, -0.15397708f, 0.21203564f, 0.00796986f, -0.05430628f, -0.04837343f, 
    0.03850430f, -0.09289740f, -0.21063539f, 0.06547969f, -0.15235546f, 0.12425222f, 0.10289764f, -0.09707283f, 
    -0.09097175f, 0.08294298f, -0.09857235f, -0.06155995f, -0.18172763f, -0.12460991f, -0.25173575f, -0.18081051f, 
    -0.12074366f, 0.13939819f, 0.09110971f, 0.07080414f, -0.01218653f, 0.01594012f, -0.06380294f, -0.14253694f, 
    -0.13231349f, -0.07981003f, -0.23843852f, -0.03685921f, -0.22450714f, 0.11911099f, 0.09724379f, -0.07366543f, 
    -0.34435052f, 0.38007471f, -0.23025522f, -0.09306739f, 0.44852975f, 0.12050515f, 0.09959039f, -0.00655263f, 
    0.05863166f, 0.03150201f, -0.23566641f, 0.18618752f, -0.06952401f, 0.14684322f, 0.09241221f, -0.14927933f, 
    -0.06648253f, 0.26876810f, 0.15614480f, -0.01069873f, 0.31602889f, -0.32291970f, -0.39821219f, 0.11012299f, 
    0.30860060f, 0.09086072f, 0.18498762f, -0.11023564f, -0.13082743f, -0.03595506f, 0.01641526f, 0.22565630f, 
    0.10476777f, 0.14869358f, 0.06395259f, -0.08923167f, 0.01200662f, 0.13328958f, 0.11004298f, -0.04088807f, 
    0.27750063f, -0.30039397f, 0.23597784f, -0.39616832f, 0.24475294f, 0.06091730f, -0.01780767f, 0.16333514f, 
    0.01744138f, -0.05444057f, -0.02006612f, -0.00963232f, -0.04127675f, -0.04880003f, 0.03122327f, 0.07287613f, 
    -0.18155323f, -0.04116467f, -0.32858914f, -0.49194118f, -0.03673412f, -0.01912018f, 0.17811656f, -0.18562095f, 
    0.06602889f, -0.01179944f, 0.20622991f, -0.01048136f, -0.06767085f, -0.17646331f, -0.03784474f, -0.04853015f, 
    -0.19047618f, 0.13999826f, -0.08273057f, 0.02174060f, 0.22920023f, -0.25548866f, 0.01099944f, 0.03742443f, 
    0.05072356f, -0.09979992f, -0.12739727f, -0.01968689f, -0.21423505f, 0.05665635f, -0.02450556f, 0.08451060f, 
    -0.05012858f, -0.02346119f, 0.06893047f, 0.07640272f, -0.06635608f, -0.18533956f, -0.05642707f, 0.11579905f, 
    -0.01868839f, -0.17792413f, -0.11760846f, 0.06533238f, -0.44778466f, 0.03399448f, -0.11588094f, -0.28143710f, 
    -0.21609282f, 0.03088543f, 0.07191130f, -0.08995621f, -0.02483470f, 0.09446561f, 0.03696968f, -0.08752015f, 
    0.01064268f, 0.10744338f, -0.08106904f, -0.24612209f, -0.03620779f, 0.03938783f, -0.06092350f, -0.02400362f, 
    -0.19055854f, 0.03971752f, 0.00802848f, 0.06231662f, -0.15957302f, 0.12078903f, 0.14379835f, -0.25902060f, 
    0.00541094f, -0.07573076f, 0.03638953f, -0.26395336f, -0.05229257f, 0.05561571f, -0.02173272f, -0.10087173f, 
    -0.19050473f, -0.05279075f, -0.27126691f, -0.15938511f, 0.21023178f, -0.05608575f, -0.00397519f, -0.09995066f, 
    -0.14237742f, 0.09426074f, 0.05019797f, 0.05764053f, -0.04711416f, 0.07062652f, -0.03950996f, -0.23632805f, 
    0.10608299f, -0.12231801f, -0.15154819f, -0.03038543f, -0.02500059f, 0.01664659f, -0.24550176f, 0.00597900f, 
    0.01928648f, -0.13678485f, -0.03621279f, -0.18989664f, 0.00035876f, -0.00188154f, -0.05686712f, -0.02267310f, 
    -0.01897362f, -0.12854588f, 0.07419717f, 0.02402906f, -0.13051707f, 0.01400743f, -0.04514048f, 0.03893926f, 
    0.01507153f, -0.07043908f, -0.09039114f, 0.03260340f, -0.08440194f, -0.43268549f, 0.27284539f, 0.09364128f, 
    -0.06349660f, -0.32789534f, -0.09594213f, -0.16813603f, -0.06075521f, 0.15026721f, 0.05889789f, 0.01098335f, 
    -0.01819286f, -0.04834256f, 0.01103534f, -0.06093279f, 0.06590250f, 0.06502438f, -0.03876996f, -0.07234392f, 
    -0.05511488f, 0.14077204f, -0.37590089f, -0.01720650f, 0.28171498f, -0.03300439f, 0.01701061f, 0.02037832f, 
    0.02069671f, 0.01333294f, 0.03017502f, -0.01586138f, -0.00381646f, -0.00555097f, -0.00747858f, -0.01898218f, 
    0.06188499f, 0.14734848f, 0.04751680f, 0.02179955f, 0.07141016f, 0.16671130f, 0.21065651f, 0.18740964f, 
    0.08953452f, -0.09171468f, -0.16568051f, -0.04046641f, -0.09843932f, 0.12990569f, 0.03322338f, 0.05414490f, 
    -0.02476917f, 0.03087811f, -0.00629916f, 0.06055465f, -0.02209848f, -0.07746229f, -0.00657701f, -0.15492772f, 
    0.04314760f, 0.17188515f, 0.15698984f, 0.52936351f, 0.15965955f, -0.04212282f, 0.05901193f, 0.16248512f, 
    -0.05250499f, 0.23866966f, 0.02975078f, -0.10613379f, 0.11501389f, -0.05552291f, -0.02874572f, -0.04708279f, 
    -0.02310955f, 0.01030576f, -0.13407861f, -0.25181001f, 0.03663752f, -0.05042418f, -0.16753778f, -0.19788277f, 
    0.13803516f, -0.13280441f, -0.20250076f, 0.13640700f, 0.21247056f, -0.08247726f, 0.04202648f, -0.02092622f, 
    0.07481125f, -0.06907264f, 0.00033858f, -0.11780128f, -0.02367723f, -0.00867757f, -0.14848010f, 0.08951523f, 
    0.01863029f, 0.05056059f, 0.00606758f, 0.04481268f, 0.16952057f, 0.06375757f, 0.10204193f, 0.03733262f, 
    0.07220874f, 0.08377098f, 0.11063349f, 0.05970146f, 0.03677306f, 0.06736743f, 0.13204618f, 0.08558398f, 
    0.04680264f, -0.10498212f, 0.01727526f, 0.10086724f, 0.11709061f, 0.12120418f, 0.02390577f, -0.02458160f, 
    0.01547664f, -0.00570860f, -0.02674295f, 0.02764891f, 0.06400081f, 0.11353751f, 0.11146865f, -0.02538705f, 
    -0.11033840f, -0.04554446f, -0.02920584f, 0.04963791f, -0.02174623f, 0.03789298f, -0.03857295f, -0.04964840f, 
    -0.16899450f, 0.03361260f, -0.03520396f, 0.12962529f, 0.09409267f, 0.09194336f, 0.20114923f, -0.11578812f, 
    -0.09203297f, 0.18564104f, 0.09446210f, -0.06768995f, -0.06010385f, -0.11668374f, -0.00371002f, 0.07880688f, 
    -0.08033162f, -0.16532083f, -0.07830063f, -0.04297749f, 0.03642849f, 0.01209872f, 0.00713840f, -0.01894750f, 
    0.01539107f, 0.06993219f, 0.08769738f, 0.02997489f, -0.02357643f, 0.01910699f, -0.05405142f, 0.20579910f, 
    0.17868380f, -0.01584361f, 0.01623224f, 0.14100088f, -0.07758676f, -0.03118017f, 0.01491976f, 0.15532716f, 
    0.15993902f, -0.04050634f, 0.25138202f, -0.07747925f, 0.07808765f, 0.11108553f, 0.00798189f, 0.04885881f, 
    -0.14782998f, 0.03566432f, 0.12889417f, -0.01981324f, 0.17735614f, -0.01678716f, -0.02489428f, -0.01463519f, 
    -0.07196146f, -0.08385541f, -0.08297937f, -0.33473676f, -0.18312687f, -0.16785622f, 0.10088320f, 0.07725550f, 
    -0.21584478f, -0.16046688f, -0.26163757f, -0.01638675f, -0.07496865f, -0.05302069f, -0.04175565f, -0.03733652f, 
    -0.05766051f, -0.00178841f, -0.08679571f, 0.01770488f, -0.02532088f, -0.08078808f, 0.32277483f, 0.16347058f, 
    0.10766840f, -0.05707692f, -0.19662800f, 0.40981734f, 0.21752378f, 0.01995077f, 0.14255662f, 0.00783413f, 
    0.05407999f, 0.10340019f, 0.04455717f, 0.01899543f, -0.05231211f, -0.00763373f, 0.03335370f, -0.12943593f, 
    -0.06442848f, -0.14025497f, 0.04625829f, -0.11167555f, 0.14276113f, 0.00369018f, -0.08886997f, 0.13444704f, 
    -0.16043541f, 0.03818314f, -0.30203035f, -0.08636844f, -0.18514833f, 0.08748951f, 0.20698322f, -0.14758992f, 
    0.03775661f, 0.04204717f, 0.07646181f, 0.08967151f, -0.11054347f, 0.09747603f, -0.32605276f, -0.05609219f, 
    0.13904333f, 0.02125991f, 0.34096652f, 0.14448801f, 0.07167566f, -0.16338181f, -0.05607955f, -0.00630961f, 
    0.16120434f, 0.26216996f, -0.01854807f, -0.01526602f, 0.09243757f, -0.01167146f, 0.09850807f, -0.04602583f, 
    -0.08268502f, -0.02158835f, -0.13047825f, -0.11498884f, 0.10725861f, -0.08032570f, 0.06925304f, -0.05336594f, 
    0.03893464f, -0.17169368f, -0.10396413f, -0.01557547f, -0.08908471f, -0.04927683f, 0.07452694f, 0.08268886f, 
    -0.03075090f, -0.00181548f, -0.03134138f, 0.05603166f, -0.02427502f, -0.09551784f, -0.04444656f, -0.04901671f, 
    -0.19653183f, -0.11484887f, 0.03084263f, 0.15860917f, 0.06431372f, -0.06530583f, 0.09134629f, -0.05315413f, 
    -0.05830348f, 0.09727000f, -0.01609645f, 0.05733935f, -0.01968833f, 0.11989097f, 0.05606702f, 0.12238000f, 
    0.25460166f, 0.00739007f, 0.13366279f, 0.35181504f, 0.09999353f, 0.10039639f, -0.00885548f, 0.00213146f, 
    -0.03197389f, -0.00141907f, -0.04973668f, -0.04813650f, 0.00415401f, 0.00375607f, 0.12952866f, -0.06420464f, 
    0.07747874f, -0.04297026f, 0.07805032f, 0.13375662f, -0.03451928f, -0.00392593f, -0.06323272f, -0.06346905f, 
    -0.27709571f, -0.51683849f, 0.12035456f, -0.06785596f, 0.01242140f, -0.10947974f, -0.02670476f, -0.09908511f, 
    0.07955599f, -0.05254163f, 0.11585822f, -0.19692560f, -0.20954965f, 0.08053529f, -0.03480182f, 0.03690187f, 
    0.03043662f, 0.09059270f, -0.05169442f, -0.13170397f, 0.17054500f, 0.12539358f, 0.24620798f, 0.22838826f, 
    0.19534424f, -0.15773667f, -0.06972022f, -0.04742987f, -0.05758993f, 0.13855894f, 0.05416763f, 0.04711620f, 
    -0.00001651f, 0.05485016f, 0.02108814f, -0.00306606f, 0.01777039f, -0.08779863f, -0.07579786f, -0.00654584f, 
    0.33706716f, -0.43527621f, -0.31758088f, -0.12878188f, -0.57972062f, 0.12996882f, 0.01945684f, 0.02533808f, 
    0.10731578f, 0.01607690f, 0.09441195f, -0.04338112f, -0.03575579f, 0.03989749f, -0.20525658f, 0.01779761f, 
    0.09075733f, 0.11978129f, 0.09701528f, 0.47548568f, 0.18768020f, 0.12478033f, 0.43076819f, 0.20007564f, 
    0.29350421f, -0.13853925f, 0.21450576f, 0.09379017f, 0.17930879f, 0.22848263f, 0.01445362f, 0.00277072f, 
    -0.03695389f, 0.01473791f, 0.05757828f, 0.02929914f, -0.04183219f, -0.14864933f, 0.09040342f, -0.10733223f, 
    0.11950582f, -0.24528973f, 0.10033856f, 0.08247641f, -0.03517143f, -0.15734509f, -0.03721185f, 0.04597682f, 
    -0.30962875f, -0.08356545f, -0.10778832f, -0.03238558f, 0.02413900f, 0.00660324f, 0.03252144f, -0.08944080f, 
    -0.17844246f, 0.10116085f, -0.06535985f, -0.05312759f, 0.01052490f, 0.05919545f, -0.10777033f, 0.05145639f, 
    -0.08544680f, 0.04791200f, -0.05361235f, -0.01816892f, -0.03463716f, 0.12772523f, -0.08279446f, -0.02733842f, 
    0.04145693f, 0.03225458f, 0.05194006f, 0.00219666f, -0.12344049f, -0.12711059f, -0.21741955f, -0.10221160f, 
    -0.02759445f, -0.35849997f, 0.08893334f, 0.13486721f, 0.03611857f, -0.17665835f, -0.06681908f, 0.02559153f, 
    -0.28466779f, -0.17508067f, -0.02725566f, 0.02332732f, 0.00654097f, 0.07858825f, -0.06497992f, 0.04252331f, 
    0.08492944f, -0.07745842f, 0.05979218f, 0.12800880f, -0.05991606f, -0.27326360f, 0.28900313f, 0.08613596f, 
    0.04380548f, -0.25513428f, -0.18025504f, -0.11984891f, 0.23673120f, -0.00639729f, 0.03870837f, -0.04839460f, 
    0.09756154f, -0.04679161f, 0.16350038f, 0.00120238f, -0.02227256f, -0.06718738f, 0.01550048f, -0.00189440f, 
    0.12866019f, -0.31534320f, 0.16792791f, 0.14296769f, 0.13517201f, -0.05753927f, -0.01597394f, -0.09285334f, 
    0.12295171f, 0.14424299f, 0.17537437f, -0.13944381f, -0.04635718f, -0.15189642f, -0.11596137f, 0.08746810f, 
    -0.03791792f, 0.11428255f, -0.08036932f, 0.33393547f, 0.14870369f, -0.00317030f, 0.33508679f, 0.05318103f, 
    0.10046370f, -0.00135612f, -0.03319003f, -0.01666345f, 0.13971585f, 0.06813177f, 0.09469917f, -0.00676556f, 
    0.10200391f, -0.05856722f, 0.01188595f, -0.09944891f, -0.14234485f, -0.03610293f, 0.04672306f, -0.27272078f, 
    -0.56059778f, -0.17542481f, -0.05429634f, -0.20007986f, 0.25636271f, 0.06325782f, 0.06629498f, -0.18546219f, 
    -0.11142986f, 0.01221309f, 0.18795192f, -0.18607625f, 0.21736749f, 0.02578628f, 0.05689591f, -0.10187473f, 
    -0.08767579f, -0.15317754f, 0.16041473f, -0.00034545f, 0.51788527f, 0.14113374f, -0.25726286f, -0.14216766f, 
    0.23771833f, 0.02127766f, 0.12883326f, -0.09802748f, -0.09234895f, 0.04558670f, 0.10158028f, -0.08384281f, 
    -0.06140426f, -0.09585488f, 0.12613864f, -0.13771315f, 0.08324278f, -0.14011860f, 0.00113224f, -0.00860822f, 
    -0.32813248f, 0.00356029f, -0.12650727f, 0.32264552f, -0.10167050f, 0.13778953f, -0.37640604f, -0.31810069f, 
    0.14821734f, 0.25944939f, -0.09473643f, 0.11254274f, -0.08198477f, 0.08417451f, 0.01773032f, 0.02626621f, 
    0.03850399f, 0.10657347f, -0.01059361f, 0.07200258f, -0.05852498f, -0.04942244f, -0.27051517f, -0.14993882f, 
    0.02038006f, 0.06938256f, -0.12303632f, -0.03223033f, -0.06080922f, -0.10109875f, 0.25981459f, 0.12180019f, 
    0.02884373f, 0.16595705f, -0.04268101f, -0.05740321f, 0.00451428f, 0.15336460f, 0.14588246f, -0.01896903f, 
    0.22545987f, -0.10373199f, 0.08230192f, -0.06762069f, -0.08117161f, 0.19969174f, -0.02283780f, 0.11903500f, 
    -0.05986888f, -0.03316664f, 0.11337760f, -0.15356675f, -0.01855006f, -0.12542176f, 0.07520995f, -0.18634577f, 
    0.03046950f, 0.01527404f, 0.19995423f, -0.10928838f, -0.58151829f, 0.25978056f, -0.38801095f, -0.42631358f, 
    -0.27948821f, -0.05330896f, -0.00590774f, -0.02873143f, -0.24976854f, 0.04161809f, -0.06021293f, 0.10488676f, 
    -0.15060692f, 0.06508949f, -0.01655743f, -0.10135366f, -0.13073947f, 0.05730709f, -0.04342733f, -0.02415814f, 
    0.61737561f, -0.13543230f, -0.29847515f, -0.11076507f, 0.10044306f, 0.07163431f, 0.16101931f, -0.06554386f, 
    0.00305250f, 0.11220067f, 0.05985725f, 0.05223313f, -0.01051013f, -0.05267832f, -0.01219360f, 0.07413231f, 
    -0.17986239f, -0.04818037f, -0.10417459f, -0.00778660f, 0.06417812f, -0.01154085f, 0.24650954f, -0.08764160f, 
    -0.14460078f, 0.03454247f, 0.05887112f, 0.15027495f, -0.14214288f, -0.13667448f, 0.05763787f, -0.01836356f, 
    -0.02364803f, -0.08479510f, 0.03525184f, -0.03666420f, 0.05661432f, -0.01867276f, 0.16894044f, 0.16166279f, 
    -0.08185421f, -0.13748996f, 0.50297314f, 0.20347026f, -0.43627784f, -0.08004714f, -0.03653219f, -0.03449181f, 
    -0.18642417f, 0.01353267f, 0.02690073f, -0.02971995f, -0.06811807f, 0.01512444f, 0.04389691f, 0.01996915f, 
    -0.00588954f, 0.04396020f, -0.01911387f, 0.19389658f, -0.02865087f, -0.21984045f, -0.19670971f, 0.32455522f, 
    -0.01240368f, 0.04908087f, -0.39379123f, -0.26143080f, -0.09203051f, 0.26913992f, -0.03953941f, 0.12684262f, 
    -0.05987057f, -0.05242518f, 0.03400662f, -0.07578492f, -0.27942920f, 0.05590395f, 0.07758214f, 0.02767856f, 
    -0.41635421f, -0.24663384f, -0.15377727f, 0.14620113f, 0.04641905f, 0.14898652f, 0.02141733f, -0.00078162f, 
    0.02834087f, 0.05021469f, -0.00146521f, -0.04221607f, -0.07214742f, -0.04875647f, -0.00757412f, 0.02771922f, 
    -0.02071643f, 0.22147192f, -0.07956894f, 0.02397356f, -0.11163324f, -0.11251806f, -0.11148747f, -0.05019571f, 
    -0.01257924f, 0.00646281f, -0.01388384f, -0.15673845f, -0.01997519f, 0.06770650f, 0.26715702f, 0.05079386f, 
    0.00168221f, 0.01085606f, -0.10473061f, -0.09206225f, -0.04607327f, 0.13043173f, 0.04187114f, 0.14350168f, 
    -0.21083772f, -0.13326137f, -0.07794499f, 0.21274306f, 0.08062571f, 0.01115502f, -0.11932236f, 0.10461559f, 
    0.18162589f, -0.23515852f, -0.05268094f, -0.02911080f, -0.00522573f, 0.00350880f, 0.14176312f, 0.05288600f, 
    -0.00046070f, 0.28437930f, -0.09753387f, 0.12312280f, 0.11977145f, 0.11777098f, 0.00835704f, 0.10967629f, 
    -0.00894597f, 0.02975772f, -0.01322775f, -0.10774431f, -0.12287137f, 0.03970305f, 0.06220974f, -0.23553392f, 
    0.14851449f, -0.16043806f, 0.19784208f, 0.04443096f, -0.00078047f, 0.03982989f, 0.03005744f, -0.02822979f, 
    0.14786211f, 0.01979191f, 0.09028886f, -0.17117178f, -0.07648612f, -0.04341523f, 0.01583216f, -0.00964212f, 
    -0.09618495f, 0.11820170f, -0.20271632f, -0.00080006f, -0.08373515f, -0.07779700f, -0.06576826f, 0.01599733f, 
    0.12792553f, 0.03319493f, -0.00765822f, 0.15786457f, 0.62052333f, -0.19664368f, 0.18953744f, 0.15031253f, 
    -0.38661829f, 0.18541797f, -0.03593857f, 0.15295675f, -0.03133520f, 0.12678541f, 0.04117868f, 0.00365405f, 
    -0.11026461f, 0.02892553f, 0.06375604f, -0.14539787f, -0.09532402f, 0.03750684f, 0.01216933f, 0.06694175f, 
    -0.21380506f, -0.00999295f, -0.30474493f, 0.11984808f, 0.11758952f, 0.18017907f, 0.16639024f, 0.03656577f, 
    -0.09847875f, 0.01491430f, 0.09445849f, -0.06290226f, -0.01320262f, -0.04440716f, 0.01051962f, 0.07034822f, 
    0.10090170f, 0.11783677f, -0.20922080f, -0.06358773f, -0.47442091f, 0.18862611f, 0.23892237f, -0.43890750f, 
    -0.26930097f, -0.17468823f, 0.04839480f, 0.05910249f, 0.12758546f, -0.22806856f, 0.23734196f, 0.06127206f, 
    0.07149480f, -0.13099681f, -0.04023435f, 0.05725569f, -0.07980347f, 0.05756960f, 0.06168096f, 0.15188609f, 
    0.03840413f, -0.09312663f, 0.23392245f, 0.09945621f, -0.12231939f, 0.26662639f, 0.06704874f, -0.01436148f, 
    -0.00158602f, -0.28626752f, 0.09036670f, 0.04564292f, -0.00737766f, 0.12407025f, -0.04412773f, 0.04874864f, 
    0.09200254f, -0.04059372f, 0.17399666f, 0.10238537f, -0.21972477f, 0.04404957f, -0.07750802f, 0.06433922f, 
    -0.24988218f, 0.00893732f, -0.08811222f, -0.01788872f, 0.04854044f, 0.11680850f, 0.17635694f, -0.11249816f, 
    -0.00107642f, -0.06707688f, 0.06102592f, -0.06508043f, 0.09773773f, 0.08167259f, -0.08353610f, -0.00223367f, 
    -0.09545644f, 0.01525161f, 0.18651310f, 0.09483114f, -0.14031217f, -0.06794023f, -0.13502288f, 0.16947694f, 
    0.14602168f, -0.05676893f, 0.06352632f, 0.04522656f, 0.05257981f, 0.05084780f, -0.06406973f, 0.06005540f, 
    0.00293482f, -0.22210851f, -0.32879972f, -0.45221704f, 0.04551994f, -0.00574031f, -0.08980266f, -0.06727768f, 
    0.00468071f, -0.04942176f, 0.05841890f, -0.02170555f, -0.00429600f, 0.05561047f, 0.18555103f, -0.10552413f, 
    -0.08154839f, -0.10872625f, -0.10464518f, 0.09145153f, 0.02170129f, 0.08393256f, 0.02261763f, 0.17474318f, 
    -0.02009653f, -0.22152388f, -0.31099281f, -0.25543344f, -0.05741192f, 0.15535675f, 0.00069816f, -0.07770991f, 
    0.00188353f, -0.18231426f, -0.12808301f, 0.20095994f, 0.09811246f, -0.02778955f, -0.06902163f, -0.05313130f, 
    -0.03531034f, 0.13527136f, -0.06482123f, 0.13537766f, 0.13580501f, -0.11459193f, 0.28357673f, -0.04225886f, 
    -0.23526143f, 0.26201320f, 0.16042022f, 0.05788443f, 0.06161758f, -0.16661862f, -0.00585614f, -0.07986145f, 
    0.00629819f, 0.02271100f, -0.01925871f, -0.06740603f, 0.06092168f, -0.03136474f, 0.13609838f, 0.13000493f, 
    0.11141463f, 0.42772239f, -0.35979643f, -0.27832067f, 0.19792050f, 0.01019464f, -0.02153685f, -0.15197209f, 
    -0.01585048f, -0.03020599f, -0.08477181f, -0.08005605f, -0.02873212f, 0.17362468f, 0.00873973f, -0.26080024f, 
    -0.00684890f, 0.12913020f, 0.05473724f, -0.39899933f, 0.17764395f, -0.07507956f, 0.32845065f, -0.00763823f, 
    -0.19747497f, 0.20561433f, 0.12150095f, -0.08538746f, 0.09800154f, -0.15796556f, 0.07824905f, 0.01295626f, 
    0.00778800f, 0.07600198f, 0.02048511f, -0.00847667f, 0.02288351f, -0.09121078f, -0.16098894f, 0.26562098f, 
    -0.22373460f, -0.03775930f, 0.11154263f, -0.00087878f, -0.26111317f, 0.13653623f, -0.14175981f, -0.06400430f, 
    -0.09678376f, -0.01351252f, -0.01798509f, 0.09813637f, -0.02147477f, -0.09502178f, 0.03891418f, 0.05964428f, 
    -0.01827271f, -0.09671955f, -0.01665909f, 0.20929682f, -0.07495897f, 0.04028107f, 0.15404819f, -0.22456114f, 
    0.10844948f, -0.00192637f, -0.05227696f, -0.04056164f, -0.13156328f, -0.05621932f, 0.22627904f, 0.01872911f, 
    -0.08884655f, -0.03906722f, 0.03270243f, 0.05069527f, 0.09844630f, -0.12059372f, 0.07698039f, 0.24213251f, 
    -0.48805073f, -0.14819689f, 0.21111423f, -0.32274622f, -0.30616561f, -0.01822590f, 0.10507665f, 0.05937195f, 
    -0.21762337f, 0.09077696f, 0.04031745f, 0.00676067f, -0.11820734f, 0.10391670f, 0.02708100f, 0.05997229f, 
    -0.05296730f, -0.12557994f, 0.03306453f, -0.04275380f, -0.11515667f, 0.39845195f, -0.13700418f, -0.30320606f, 
    -0.18217701f, 0.02029555f, -0.14663118f, 0.18220223f, 0.08394334f, 0.26095760f, -0.05212159f, -0.06643885f, 
    -0.07458559f, 0.03532783f, -0.09024990f, -0.07185809f, -0.21983552f, 0.09363100f, -0.07521900f, -0.00730453f, 
    -0.00129760f, 0.07206119f, -0.38827875f, 0.17290078f, -0.00681104f, 0.03931794f, 0.02016584f, 0.03222875f, 
    0.19008006f, -0.12709193f, -0.00311841f, 0.04958107f, -0.16846395f, 0.02318630f, 0.08106200f, 0.04005328f, 
    -0.05642355f, 0.15925340f, -0.09507340f, -0.04670750f, -0.27153525f, -0.28757879f, -0.58349812f, 0.45978886f, 
    -0.46882987f, -0.06162424f, 0.20773071f, 0.08248116f, -0.11299502f, -0.36106932f, 0.12942313f, 0.02106130f, 
    0.02738879f, 0.14038849f, 0.11214339f, 0.02794133f, 0.00469844f, 0.24740946f, 0.15800160f, 0.10468917f, 
    0.01487919f, 0.12003560f, 0.03203163f, -0.00862072f, -0.10308286f, 0.03174384f, 0.11507742f, 0.06677420f, 
    -0.08081489f, 0.05299320f, 0.04820395f, -0.13729237f, 0.05496991f, -0.08852125f, 0.12739530f, 0.09641280f, 
    0.09927490f, -0.10060737f, -0.13450870f, 0.03110128f, -0.02705442f, 0.07584164f, -0.00015269f, -0.04808503f, 
    0.07426763f, 0.00097931f, -0.00157785f, 0.02458118f, 0.03222259f, -0.10692472f, 0.05050998f, 0.03994092f, 
    0.03614864f, -0.00754394f, -0.02783251f, 0.07263565f, 0.08334915f, -0.08264235f, -0.12672882f, 0.05889953f, 
    -0.11074347f, 0.01306418f, -0.09946619f, 0.01999669f, 0.26601192f, -0.17901745f, 0.15984061f, 0.02239877f, 
    -0.04879489f, 0.16448502f, -0.01253062f, 0.14227241f, 0.02723131f, -0.00482782f, 0.10104447f, -0.08761125f, 
    -0.02445820f, -0.10885091f, 0.08798551f, -0.28115928f, 0.06238395f, -0.05179790f, 0.26715317f, 0.08069655f, 
    -0.17682859f, 0.00854411f, 0.01437551f, -0.03209338f, -0.08456599f, 0.04015507f, -0.07262089f, 0.05080232f, 
    0.17376882f, 0.02577033f, -0.18233523f, 0.08067098f, -0.06159947f, 0.08117844f, -0.03034663f, -0.03759532f, 
    0.00297744f, 0.08445349f, 0.06066264f, 0.03590868f, -0.11472677f, 0.03972501f, 0.09160063f, 0.08794191f, 
    -0.04736243f, 0.11913013f, -0.01193355f, -0.11748005f, 0.09245465f, -0.02018919f, -0.00304258f, 0.05723473f, 
    -0.02163090f, -0.13209786f, -0.02769987f, -0.01735904f, -0.43610957f, 0.32224393f, 0.61235422f, -0.06635752f, 
    0.42860928f, -0.11398312f, -0.16358513f, -0.12035966f, -0.19747642f, 0.19557409f, -0.00511356f, 0.15943079f, 
    0.12647206f, 0.14743692f, -0.06502002f, 0.05612734f, 0.04966922f, 0.07633038f, 0.03456656f, 0.04081346f, 
    0.18994769f, -0.08885007f, -0.11214118f, -0.24056838f, 0.13221037f, -0.03263146f, 0.06031166f, 0.15348792f, 
    0.09768958f, -0.11972307f, 0.08141813f, -0.03405470f, -0.03788471f, -0.02750435f, 0.03740511f, -0.01403191f, 
    -0.05001919f, -0.05224616f, 0.08369559f, 0.13494048f, -0.83743304f, -0.51256382f, 0.10227755f, 0.10225014f, 
    -0.30163896f, -0.19280726f, -0.04615939f, -0.06783611f, -0.11998559f, -0.19615620f, -0.03173382f, -0.01520065f, 
    0.07169329f, -0.06564935f, 0.03609924f, 0.00409611f, 0.00597435f, 0.07824909f, 0.09060828f, -0.26165715f, 
    -1.38071728f, -1.04795408f, -0.99996454f, -0.21965149f, 0.26156974f, -0.12139087f, 0.06505634f, -0.07845702f, 
    -0.27965492f, -0.14411809f, -0.01137874f, -0.04718748f, 0.00183331f, -0.08917882f, 0.06322326f, 0.00339174f, 
    0.01284507f, -0.01373606f, 0.29131037f, -0.02540039f, 0.39953905f, -0.10373349f, -0.55850887f, -0.29886171f, 
    -0.03751148f, 0.00737289f, 0.02115204f, 0.26270777f, 0.13059799f, 0.07527009f, 0.00418199f, 0.02602878f, 
    0.06848059f, -0.10870308f, 0.00943572f, 0.02313214f, 0.09430501f, -0.23645161f, 0.23908752f, 0.16362797f, 
    0.10201856f, -0.15998243f, -0.20613886f, -0.19807607f, -0.02426431f, 0.03300406f, 0.04417365f, 0.05667577f, 
    -0.12881525f, 0.02930196f, -0.09500150f, -0.09165343f, -0.12425081f, -0.11530438f, -0.04808877f, -0.19795698f, 
    -0.13540934f, -0.28260237f, -0.00411991f, 0.05078152f, -0.19800884f, 0.01228751f, 0.15849163f, -0.13837536f, 
    -0.01852877f, -0.00480957f, -0.05887992f, -0.07523400f, -0.02701355f, 0.02644191f, 0.07521409f, 0.01555749f, 
    -0.09766267f, 0.14025761f, -0.18623143f, 0.05879207f, -0.04617860f, -0.02965834f, -0.11685063f, 0.06544875f, 
    0.05892065f, -0.46393487f, -0.22915363f, 0.04842079f, 0.20587017f, -0.02661751f, 0.22615540f, 0.15601982f, 
    0.05506413f, -0.10347447f, 0.06089138f, -0.00480133f, -0.11323661f, 0.00115771f, 0.03302952f, -0.02081116f, 
    0.08773801f, 0.07182170f, 0.20896545f, -0.05796260f, -0.01345447f, -0.07609820f, -0.04932741f, -0.05138721f, 
    -0.05221793f, -0.06372733f, 0.02389365f, -0.05307467f, -0.03666032f, 0.04100188f, 0.04901612f, -0.05756300f, 
    -0.00914378f, 0.01711555f, 0.06548762f, -0.00707646f, -0.02489695f, -0.15629773f, 0.00317293f, -0.04253468f, 
    0.11665931f, 0.28304780f, -0.08899637f, -0.17043591f, -0.00508232f, -0.09586958f, -0.07785460f, -0.27702737f, 
    -0.03391942f, -0.07177018f, 0.01373672f, -0.11851737f, -0.20210613f, -0.02758189f, 0.09173489f, -0.03576405f, 
    -0.07773276f, 0.05451130f, -0.10081119f, -0.25860596f, -0.01883576f, 0.31985599f, -0.57633638f, 0.13271323f, 
    0.27197215f, -0.00453560f, 0.06156182f, -0.01946885f, -0.11835803f, 0.16880578f, -0.02086617f, -0.00893351f, 
    0.02557445f, 0.12503934f, 0.08444332f, 0.07681391f, 0.03408617f, -0.13290133f, 0.32515708f, -0.01648727f, 
    0.09900125f, -0.37692788f, -0.27320439f, -0.08903012f, 0.16287193f, -0.06474555f, 0.17820723f, 0.28638318f, 
    0.09662465f, -0.08018552f, 0.01368947f, 0.00412468f, -0.08099898f, -0.00296312f, 0.09042219f, 0.04608522f, 
    0.04445988f, 0.06521643f, -0.01028328f, 0.07357453f, -0.65132356f, -0.10760740f, 0.53140634f, 0.27096567f, 
    -0.25083145f, 0.03170120f, -0.27240589f, -0.06818029f, -0.04084045f, 0.14411488f, 0.30904162f, 0.05400391f, 
    0.01914840f, 0.04238290f, 0.07187514f, -0.03076738f, 0.06546152f, 0.00474440f, -0.15696363f, 0.02080532f, 
    -0.37317368f, -0.29827848f, -0.39385363f, -0.25893795f, 0.13043274f, 0.02248492f, 0.06210975f, 0.16535057f, 
    -0.11407774f, -0.02325895f, 0.02115500f, -0.04255383f, -0.06139274f, 0.04925282f, 0.02962679f, -0.03034415f, 
    -0.03054930f, 0.03642021f, 0.06957442f, -0.00377335f, -0.48425290f, 0.09788549f, 0.27075887f, 0.06984895f, 
    0.01626522f, -0.15917851f, -0.07319643f, -0.11685741f, -0.12560056f, 0.45718327f, -0.20539208f, 0.05504993f, 
    0.25972241f, -0.01115003f, 0.10004926f, -0.01616449f, 0.06048027f, -0.13636616f, 0.09516644f, -0.11048380f, 
    -0.11663115f, -0.48567611f, -0.67012489f, -0.27695587f, 0.27541265f, -0.30475548f, -0.12428631f, -0.03803722f, 
    -0.15194875f, -0.24323358f, -0.02451091f, -0.01703535f, -0.03522807f, -0.02138545f, -0.00910391f, -0.13434397f, 
    -0.07128497f, 0.02723025f, 0.20374851f, 0.04592634f, -0.09573517f, 0.10255760f, 0.11160624f, -0.07651369f, 
    0.00397575f, -0.06310184f, -0.04359427f, -0.05519816f, -0.00782403f, 0.00456491f, 0.19786119f, 0.00047509f, 
    -0.06541404f, 0.05119403f, 0.02368502f, -0.00080264f, -0.05851533f, -0.07943022f, -0.16219234f, 0.04236764f, 
    -0.41016412f, 0.68039477f, 0.37630931f, 0.03660697f, 0.27683827f, -0.08127178f, -0.04599256f, -0.03665214f, 
    0.01616019f, 0.14261617f, 0.12587821f, 0.06696484f, 0.13952456f, 0.04962826f, 0.07896423f, 0.06534296f, 
    -0.04910929f, 0.00439236f, 0.00599709f, 0.00738404f, -0.55331689f, -0.45283240f, -0.26277387f, -0.35547507f, 
    -0.04411821f, -0.28072119f, -0.06544299f, -0.17019221f, -0.05791759f, -0.26833326f, 0.04742727f, -0.04066937f, 
    -0.04877895f, -0.02671302f, 0.02376085f, 0.01405267f, -0.01498201f, 0.10728242f, 0.05127495f, -0.06176141f, 
    -0.07700224f, 0.23506853f, 0.12341882f, 0.01667317f, -0.10602251f, 0.01726330f, -0.02601109f, -0.06962969f, 
    0.01273253f, 0.05393636f, -0.04474094f, -0.00544679f, 0.14332910f, -0.08190633f, -0.06783834f, 0.05559545f, 
    0.11799198f, -0.11832508f, -0.15937494f, 0.01483029f, -0.72427666f, -0.68171978f, -0.66755998f, -0.44450012f, 
    0.31246755f, -0.20099916f, -0.07772453f, -0.29040605f, -0.04683292f, -0.67238802f, 0.04623225f, -0.05704393f, 
    -0.10963976f, -0.02471719f, -0.01912855f, -0.01968433f, -0.00120403f, 0.15306439f, 0.12743127f, 0.22138636f, 
    0.02845140f, -0.21449740f, 0.39134246f, 0.26108211f, 0.06283311f, 0.05075451f, -0.07413986f, 0.06517456f, 
    -0.10739291f, -0.01142133f, 0.00937137f, 0.06139089f, 0.01349103f, 0.04158791f, -0.10342093f, 0.00231273f, 
    0.04157304f, 0.00108557f, 0.08581568f, 0.06399430f, -0.03635644f, -0.09167881f, 0.09981070f, 0.10540958f, 
    -0.04861211f, 0.00555061f, -0.05807595f, -0.00918983f, -0.03948154f, -0.06582450f, 0.04244842f, 0.05174361f, 
    -0.11719287f, 0.00705239f, 0.08754699f, 0.02707588f, -0.01814285f, 0.02243804f, -0.11343711f, -0.14016108f, 
    -0.30668634f, -0.74685234f, -0.36887449f, -0.15390660f, -0.34087145f, -0.09255091f, -0.28279862f, -0.18822934f, 
    -0.14167514f, 0.02790568f, -0.07481793f, 0.06605311f, 0.04535804f, -0.04522616f, -0.12652642f, -0.02480728f, 
    0.00834805f, 0.11850941f, 0.01801617f, -0.00939274f, -0.37897629f, 0.17231488f, 0.19852860f, -0.39007470f, 
    0.79549372f, 0.02629821f, 0.02239461f, -0.08187388f, 0.10569642f, 0.06840491f, 0.03971431f, 0.04996501f, 
    0.00755533f, 0.16436094f, 0.00794285f, -0.04833051f, 0.04322283f, 0.07165258f, 0.00022275f, 0.06432612f, 
    -0.53188378f, -0.16680902f, 0.35603279f, -0.15270929f, 0.17704207f, -0.07582973f, 0.00759914f, 0.02438785f, 
    -0.21673661f, 0.04618311f, 0.01647786f, -0.07733231f, -0.04218249f, -0.07274242f, -0.13372485f, 0.00545856f, 
    -0.00737685f, 0.00193382f, -0.07559593f, 0.10897740f, -0.58362299f, -0.66123223f, 0.67520577f, -0.35588455f, 
    0.44531071f, 0.08720540f, -0.23342383f, 0.24815039f, -0.09934377f, 0.01504541f, -0.03326914f, 0.04452614f, 
    -0.05833753f, 0.04526362f, -0.10883609f, 0.10532970f, 0.05792556f, 0.02442220f, 0.00453000f, -0.24068601f, 
    -0.02029749f, 0.04458496f, 0.10361937f, -0.11874127f, -0.02610712f, 0.03860098f, 0.01922207f, 0.02057848f, 
    -0.02209368f, 0.02257522f, -0.04413826f, -0.11002720f, -0.00570605f, -0.12046655f, 0.00280658f, -0.04541907f, 
    -0.09826440f, -0.13224174f, 0.00688104f, -0.01348993f, -0.11412171f, 0.06493285f, -0.02560985f, 0.09382465f, 
    -0.04422759f, 0.04060742f, 0.07086001f, 0.04728855f, -0.04131124f, -0.03730840f, 0.06187125f, -0.00309637f, 
    0.07415968f, 0.02207975f, -0.01768460f, -0.09043049f, -0.06773416f, -0.17861708f, -0.00406529f, -0.02538892f, 
    0.42181107f, 0.22613110f, -0.35160267f, 0.12084006f, -0.37131074f, 0.16710624f, 0.09892167f, 0.26161250f, 
    -0.13182232f, -0.12750307f, -0.23620439f, -0.01677106f, 0.08557409f, 0.09772317f, -0.11099461f, -0.06401331f, 
    -0.14716150f, 0.00918650f, -0.17012088f, -0.20326672f, 0.07124773f, 0.12461087f, 0.06394258f, 0.05304949f, 
    -0.05984746f, 0.05994983f, 0.03103898f, 0.05851478f, 0.00017600f, -0.06496127f, -0.07959691f, -0.11258060f, 
    -0.08894428f, -0.39310181f, -0.33562368f, -0.08660345f, 0.03056128f, 0.02169292f, -0.10019555f, -0.02271411f, 
    -0.04432601f, 0.04049123f, 0.05585812f, -0.06468023f, -0.02477076f, 0.04982816f, -0.05264771f, -0.03988903f, 
    -0.01128848f, -0.02317270f, 0.02738038f, -0.07221411f, -0.11216086f, -0.06274066f, -0.01006158f, 0.02713491f, 
    -0.02998463f, -0.08092648f, 0.07450289f, -0.01403312f, 0.58925408f, -0.72406161f, -0.59623563f, -0.22169065f, 
    -0.14867117f, -0.01288687f, 0.04370475f, -0.07005422f, 0.32349330f, -0.09839004f, -0.02250876f, 0.01151002f, 
    0.03693537f, 0.00019264f, 0.04267539f, -0.09362736f, 0.05205713f, -0.08427791f, 0.06376670f, 0.08433621f, 
    -0.14406298f, 0.11786538f, 0.02133310f, 0.00399951f, -0.05172368f, -0.05773967f, -0.01041872f, -0.01357391f, 
    -0.08886873f, -0.01440138f, 0.09380783f, 0.01911282f, 0.04483658f, 0.04438423f, 0.02087567f, 0.05962011f, 
    0.04495278f, -0.08180737f, 0.01808120f, 0.03172151f, 0.28847393f, -0.59431326f, -0.05750388f, 0.07389135f, 
    -0.08585867f, -0.05378495f, 0.14094701f, -0.07667274f, 0.15194012f, 0.06759755f, 0.00564893f, 0.03928033f, 
    0.08415955f, -0.00644780f, 0.02425542f, -0.05201893f, 0.02976590f, -0.03440698f, -0.04628000f, -0.12551388f, 
    0.09450132f, -0.95808911f, -0.58644032f, 0.79039246f, -0.05031710f, 0.07754146f, 0.01653851f, 0.05718328f, 
    -0.04495640f, 0.04260865f, 0.10817096f, 0.00795653f, 0.13758822f, -0.07537451f, 0.04035240f, 0.01798948f, 
    0.07858662f, -0.00243773f, 0.06263797f, -0.07770420f, 0.01800498f, 0.15506196f, -0.10424124f, 0.02638311f, 
    -0.13825285f, 0.00971482f, 0.13536978f, -0.19917832f, -0.25228035f, 0.08244709f, 0.07850862f, 0.00048502f, 
    0.08619113f, 0.00120880f, 0.06036564f, -0.11449117f, 0.17293279f, 0.04375608f, -0.06903434f, 0.12510376f, 
    -0.01401398f, 0.11871767f, 0.05218204f, 0.01601588f, -0.14956772f, -0.02787494f, 0.08110252f, -0.04536381f, 
    -0.02574142f, -0.04136281f, 0.06174129f, 0.01153797f, 0.01657845f, -0.00331191f, 0.00644158f, -0.03543846f, 
    -0.20814067f, 0.14229305f, 0.08114742f, 0.02456902f, 0.09369791f, 0.12665707f, -0.01623054f, -0.08970818f, 
    -0.06914441f, -0.01538598f, 0.10940749f, 0.04321763f, -0.00295962f, -0.08608739f, 0.02633498f, -0.04032853f, 
    0.09351503f, -0.04975453f, -0.02645016f, -0.00924714f, 0.00956016f, 0.00413247f, -0.00306092f, 0.01276965f, 
    -0.17143761f, 0.06236774f, -0.04816132f, 0.05492224f, -0.21234921f, -0.00797860f, 0.04365623f, 0.21339068f, 
    -0.00431691f, -0.03373848f, 0.03689507f, 0.01927305f, -0.00590793f, -0.02318104f, -0.09731175f, 0.04979901f, 
    -0.03801247f, 0.01223348f, -0.02793406f, 0.09158465f, 0.07134591f, 0.07664223f, -0.01907039f, -0.05841302f, 
    -0.11370228f, 0.03322351f, 0.02100218f, 0.01727675f, 0.04540693f, -0.00231173f, -0.20343253f, -0.15205340f, 
    -0.17939004f, -0.09466382f, -0.06689242f, 0.05446717f, -0.01553181f, 0.08751570f, -0.01917764f, 0.00486037f, 
    -0.22036730f, -0.25430328f, 0.00302624f, 0.13432319f, 0.14097880f, 0.08545420f, -0.03966133f, 0.12698352f, 
    0.03166092f, 0.05528818f, -0.06233758f, 0.06949607f, 0.10734524f, 0.08127420f, 0.02308949f, 0.04527675f, 
    -0.04719920f, -0.01606637f, -0.11209552f, -0.05579777f, -0.14177835f, -0.60951805f, 0.10221954f, 0.43274230f, 
    0.10213909f, 0.00409368f, 0.10288556f, -0.05870123f, -0.02342163f, -0.07157639f, 0.03771614f, 0.07369808f, 
    -0.15650699f, -0.04010147f, 0.03947700f, -0.04717697f, 0.02982580f, 0.04593967f, 0.03375480f, 0.02415383f, 
    -0.09650595f, 0.10702564f, 0.10064885f, 0.01460503f, -0.10307025f, 0.00487166f, -0.01479136f, -0.21078186f, 
    0.07925100f, -0.00856737f, 0.02266505f, -0.03440131f, 0.02329243f, 0.01193714f, -0.03177910f, -0.01942793f, 
    -0.09088920f, -0.25513828f, 0.09909619f, 0.00714876f, 0.79596120f, -0.10866918f, -0.21893293f, -0.17699075f, 
    -0.21505120f, -0.02369116f, 0.15061216f, 0.04559371f, -0.02256633f, -0.04593746f, 0.05804670f, -0.08840469f, 
    0.27502409f, -0.04607052f, 0.03414289f, -0.00319831f, -0.01536691f, 0.02696699f, -0.06643204f, -0.03919741f, 
    0.23274200f, -0.28898987f, -0.26494846f, -0.05199325f, 0.03277519f, 0.01690892f, 0.05663234f, 0.07782663f, 
    0.11133301f, 0.13804846f, 0.04044499f, -0.00331213f, 0.03092163f, -0.04789776f, -0.05774359f, 0.05796738f, 
    -0.08924859f, -0.01171653f, 0.16336007f, 0.02084992f, 0.58088237f, 0.16865803f, -0.20682956f, -0.02120207f, 
    -0.36598644f, 0.14392889f, -0.01435473f, -0.09494503f, -0.02456848f, 0.04270431f, 0.10150103f, 0.09614057f, 
    0.10670231f, -0.00917030f, -0.00422732f, -0.00326669f, -0.03933233f, -0.02245116f, -0.00335320f, -0.08900229f, 
    0.00157174f, -0.36554843f, -0.33121341f, 0.18519028f, -0.26298073f, 0.12653993f, -0.00070767f, -0.16641542f, 
    0.03103040f, 0.15955588f, 0.03039270f, -0.02615824f, -0.17833935f, -0.06403053f, 0.01199613f, 0.08304143f, 
    0.09490494f, -0.01352855f, 0.04838744f, -0.07578786f, 0.11767599f, 0.05215780f, -0.01633675f, -0.01926201f, 
    -0.05156096f, -0.06291568f, 0.00418907f, 0.01049145f, 0.00699174f, -0.05802449f, -0.07441057f, -0.23745833f, 
    0.06951103f, -0.01499467f, -0.03815861f, -0.05195148f, -0.07113601f, 0.07805210f, -0.01178500f, -0.05419592f, 
    -0.03539149f, -0.00678445f, -0.10651514f, -0.05995835f, -0.12278775f, -0.07981925f, -0.04406860f, 0.07195809f, 
    0.05783888f, 0.00278696f, -0.12170499f, 0.00736709f, 0.12812690f, 0.02660669f, 0.06488413f, -0.00291228f, 
    -0.04332996f, 0.03865411f, 0.05990927f, 0.00205189f, 0.03453915f, -0.42036605f, -0.28210455f, 0.04812688f, 
    0.06156257f, -0.01353021f, -0.05266206f, -0.02690932f, 0.04130914f, 0.01403050f, 0.02164547f, -0.01790737f, 
    -0.01295311f, 0.00119970f, 0.03026215f, 0.01311865f, 0.01406097f, -0.00854177f, 0.06006675f, -0.00030191f, 
    -0.02788099f, 0.07541698f, 0.14169154f, -0.02644339f, -0.04877490f, 0.00381786f, 0.08604671f, 0.04635854f, 
    0.01758819f, 0.00327742f, -0.00766629f, 0.00737339f, 0.08081174f, -0.06611989f, -0.00260536f, -0.18429734f, 
    -0.08173698f, -0.40432054f, -0.06439131f, 0.11497096f, -0.82620507f, -0.56197304f, 0.17444792f, 0.47013605f, 
    0.26306367f, 0.00330397f, 0.09256911f, 0.04607230f, 0.04584283f, 0.13605753f, 0.07052520f, 0.00102936f, 
    -0.03669369f, -0.04314415f, -0.02398308f, 0.03505715f, -0.05717060f, -0.08081867f, 0.10022874f, -0.12851292f, 
    0.35852429f, -0.50388426f, -0.03131568f, -0.75513268f, -0.01545447f, -0.02468894f, 0.08186031f, -0.12278787f, 
    0.15963833f, -0.10207248f, 0.03175796f, -0.00670939f, 0.02672245f, -0.09171721f, -0.00479956f, 0.00415653f, 
    -0.04331370f, -0.07532124f, -0.05695581f, 0.03466968f, -0.07306632f, 0.11014569f, 0.11104351f, -0.10595585f, 
    0.04684091f, 0.00303008f, 0.04227000f, 0.02561238f, 0.03665117f, -0.06759446f, -0.15484250f, -0.16356012f, 
    -0.00463300f, 0.02195591f, 0.01843315f, -0.03353840f, -0.07379034f, -0.10485742f, -0.01309083f, 0.04816183f, 
    0.46631733f, -0.75574923f, 0.58089238f, -0.86203098f, -0.15647160f, -0.20786111f, 0.27727020f, -0.29666635f, 
    0.42936334f, 0.08309641f, 0.00228235f, 0.02096893f, -0.05190571f, -0.06905897f, 0.13783866f, -0.08520830f, 
    -0.03406970f, -0.20040412f, 0.11764469f, 0.01545781f, 0.61372173f, -0.70262831f, -0.59002286f, -0.81600624f, 
    -0.49841368f, -0.03656926f, 0.12976094f, 0.06118793f, 0.07931843f, -0.13569359f, 0.01016344f, -0.04880194f, 
    -0.00107704f, 0.05272913f, -0.04556406f, -0.14476356f, -0.07903676f, 0.02212377f, -0.09865213f, 0.00157855f, 
    0.49365979f, -0.32109556f, -0.00027720f, 0.37405849f, -0.09041838f, 0.13168812f, 0.07861347f, -0.12403407f, 
    -0.19195434f, 0.16224569f, 0.17946236f, 0.14470458f, -0.01109127f, 0.08649216f, -0.03340055f, -0.03283153f, 
    0.15858093f, -0.03797946f, 0.04472255f, 0.20624280f, 0.32241657f, -0.61001068f, -0.10530180f, 0.09123635f, 
    0.25157645f, 0.13263829f, 0.15422557f, 0.01645918f, -0.09168343f, 0.08659721f, -0.01578373f, 0.01714063f, 
    0.09249812f, 0.04471055f, 0.09522306f, 0.03397961f, -0.14453121f, -0.08161379f, -0.25270993f, -0.26282266f, 
    -0.37123838f, 0.00755233f, 0.03494785f, 0.06326333f, -0.00108710f, 0.01808612f, -0.06870325f, 0.05196937f, 
    0.02586264f, 0.04816573f, 0.02097623f, 0.01434060f, -0.02448818f, 0.16148320f, 0.04676675f, -0.06922852f, 
    0.07864688f, -0.06273928f, -0.12287626f, 0.08464616f, -0.62023616f, -0.01853551f, 0.24097528f, 0.21186110f, 
    0.12531845f, -0.00700432f, -0.01651321f, -0.06424043f, -0.01254030f, 0.02047189f, -0.07203907f, -0.07760664f, 
    -0.00726003f, 0.04101782f, 0.01798554f, -0.09123350f, -0.13412027f, -0.08123954f, -0.05063099f, -0.03135964f, 
    0.59755313f, -0.00889504f, -0.25061893f, -0.13698404f, -0.01643733f, -0.08846904f, 0.22124787f, 0.05019961f, 
    0.02435646f, -0.20311135f, 0.04317791f, 0.00929586f, 0.09724546f, -0.05667220f, -0.02755672f, 0.02953833f, 
    0.05649264f, -0.01123753f, 0.19618900f, -0.01583042f, -0.28562742f, -0.03326416f, -0.01068793f, 0.02821313f, 
    -0.30657786f, -0.11698792f, -0.01716134f, -0.02529172f, 0.10569043f, -0.11440365f, -0.04964101f, 0.13368045f, 
    0.01640249f, 0.16776264f, 0.15225032f, -0.06776611f, 0.02861790f, 0.02571537f, -0.01823054f, -0.02927290f, 
    0.11153483f, 0.02720049f, 0.00602410f, 0.00489638f, -0.08897755f, -0.01769845f, -0.00487293f, -0.03673894f, 
    0.02684306f, 0.11482935f, 0.15605631f, -0.08695481f, 0.04874988f, 0.13311222f, 0.13978674f, -0.11920375f, 
    0.14250992f, -0.00750293f, -0.02393802f, 0.08432120f, 0.03496431f, -0.41779900f, -0.71176916f, 0.07755432f, 
    0.30853242f, -0.12958422f, 0.05273438f, 0.31840125f, 0.13329762f, 0.03253032f, 0.07434834f, -0.15785947f, 
    -0.04234024f, -0.01468283f, -0.03975525f, -0.04524612f, -0.04319514f, -0.05772696f, -0.08580776f, -0.11085153f, 
    -0.60844886f, 0.18389955f, 0.26542360f, 0.26930481f, 0.08232556f, 0.08835302f, -0.04110263f, -0.04632718f, 
    -0.02345748f, -0.10787877f, -0.04944476f, -0.07171860f, 0.08121630f, -0.02386646f, -0.01847291f, -0.07018651f, 
    -0.10490157f, -0.07153319f, -0.13208608f, -0.15277871f, -0.04806028f, -0.28098005f, -0.47468641f, -0.15916590f, 
    0.14288299f, 0.04349504f, -0.19380870f, 0.10986126f, 0.12696685f, 0.09459824f, -0.09292062f, -0.02976429f, 
    -0.02841847f, -0.00675747f, 0.06696258f, 0.00066906f, 0.04174079f, 0.10100316f, 0.00263702f, 0.10370637f, 
    0.80345792f, -0.17092811f, -0.31523827f, -0.31635317f, -0.16412051f, 0.09339894f, -0.02179241f, -0.17833866f, 
    0.12420993f, -0.22309563f, 0.03594121f, 0.00265372f, 0.03831950f, -0.02765876f, 0.02033298f, 0.03111383f, 
    0.04899082f, 0.05729685f, 0.13037625f, -0.02795676f, 0.01671613f, 0.47400561f, 0.06696252f, 0.13277097f, 
    -0.05131108f, 0.03830224f, -0.00943162f, 0.02036566f, 0.08466461f, -0.17161429f, -0.05451497f, -0.05540970f, 
    0.09171138f, -0.01934248f, -0.06717434f, -0.13458368f, 0.08962340f, 0.03866734f, 0.05352921f, -0.04382917f, 
    -0.42961130f, 0.28023809f, 0.18243605f, 0.00394631f, -0.18513224f, -0.04610341f, -0.04886012f, -0.08399124f, 
    -0.03680751f, -0.09852970f, -0.13059197f, -0.07418582f, -0.05437810f, -0.07259193f, 0.00143962f, 0.00434731f, 
    0.07771663f, 0.05260104f, -0.01615236f, -0.00446100f, -0.15976286f, -0.19349658f, -0.18786657f, -0.07386104f, 
    -0.19610263f, -0.17943503f, -0.02776003f, 0.08858720f, 0.05546066f, 0.03911309f, 0.14884956f, 0.04545474f, 
    0.04428859f, 0.08045171f, 0.08653378f, 0.01562820f, 0.12914348f, 0.02076639f, 0.03938460f, 0.09793143f, 
    0.17685506f, 0.16253306f, 0.07109743f, 0.07687571f, -0.32314762f, -0.12037961f, -0.09024373f, -0.15387475f, 
    -0.02925595f, -0.18637064f, -0.02431775f, 0.08580935f, 0.00089177f, -0.04093949f, 0.08557742f, -0.05414866f, 
    0.18691596f, 0.13780510f, 0.21597783f, 0.07857945f, -0.03031116f, -0.07132866f, -0.14944093f, -0.08253156f, 
    -0.07509302f, -0.02161068f, -0.08807502f, -0.08273485f, -0.00566713f, -0.05858963f, 0.00404297f, 0.05302056f, 
    0.21866681f, 0.06599700f, 0.04325821f, -0.11674840f, 0.14865839f, -0.03933806f, 0.17826778f, 0.05831543f, 
    0.11437030f, -0.18158679f, -0.15760146f, 0.05460284f, 0.08110658f, -0.04207285f, -0.10073911f, -0.17143396f, 
    -0.04204222f, 0.06527562f, 0.00744506f, 0.09282661f, -0.02849193f, 0.00229710f, -0.01990963f, -0.03672248f, 
    0.07110124f, 0.18011168f, 0.12495744f, 0.12333366f, 0.66627651f, 0.25924847f, -0.14284407f, -0.04031577f, 
    0.09473473f, 0.16314708f, -0.08272359f, 0.06350422f, 0.04088904f, -0.04187228f, 0.10754299f, 0.03323690f, 
    0.12751727f, 0.12138749f, -0.03537229f, 0.02390902f, -0.02696794f, -0.02820229f, 0.01649671f, -0.03484745f, 
    -0.25755778f, 0.12050074f, 0.18502240f, 0.19225506f, -0.14182755f, 0.11613338f, -0.15695213f, 0.09222786f, 
    -0.00527489f, -0.16009299f, -0.06758283f, 0.08831269f, 0.05405213f, -0.07548904f, -0.00927890f, -0.02715548f, 
    -0.04292997f, 0.05691156f, -0.04068648f, 0.09364680f, 0.01214295f, -0.16305092f, -0.29492050f, -0.08103280f, 
    -0.21470612f, -0.12666512f, -0.05571933f, 0.25670269f, 0.05419463f, 0.07427574f, 0.01514388f, 0.08904304f, 
    -0.20673697f, -0.03545601f, 0.00609976f, -0.09791586f, 0.13668658f, 0.03207133f, 0.02306419f, 0.04703495f, 
    0.00779679f, -0.27378491f, -0.41257054f, -0.25234276f, -0.01944323f, 0.02449871f, -0.12377041f, -0.05274986f, 
    0.08677053f, -0.34211621f, -0.02988355f, -0.02699216f, -0.06458268f, -0.04177214f, -0.00383920f, 0.04762336f, 
    0.01131880f, 0.00431485f, 0.17265722f, -0.03486437f, 0.01062626f, -0.38748401f, -0.39406088f, -0.26025158f, 
    0.01050781f, -0.02388517f, 0.09023622f, 0.12670155f, 0.12408607f, 0.08271760f, -0.03097459f, -0.05903585f, 
    0.02973098f, -0.05979663f, -0.10547917f, 0.02248089f, -0.05646548f, -0.00162157f, 0.08247770f, -0.01194532f, 
    0.20286185f, -0.06832127f, -0.33280769f, -0.36465901f, -0.20152827f, -0.14263754f, -0.17128284f, -0.04244228f, 
    -0.18763174f, -0.39425108f, 0.01417597f, -0.03694463f, -0.02855481f, 0.12418739f, 0.08999020f, 0.09636722f, 
    0.05979044f, 0.06877251f, -0.19736817f, -0.30434695f, -0.05125846f, -0.17465107f, -0.02343807f, -0.04470064f, 
    -0.09704347f, -0.07991404f, 0.01307356f, 0.07023210f, 0.04163964f, 0.07001821f, 0.04271472f, 0.11020557f, 
    -0.03447393f, 0.01601482f, 0.03417993f, -0.03888706f, 0.20702368f, 0.04083602f, 0.05689089f, 0.12705678f, 
    -0.13469151f, -0.39237875f, -0.20354596f, -0.06368143f, 0.10396026f, -0.15260780f, 0.11291158f, 0.13209371f, 
    -0.00982543f, 0.08773632f, 0.14089455f, 0.03602022f, 0.03755348f, 0.00121914f, 0.01164028f, -0.02748780f, 
    0.08031756f, -0.04163574f, 0.08726847f, -0.06647452f, -0.04344075f, -0.61928421f, -0.47942325f, -0.03492172f, 
    -0.02508662f, -0.11848434f, -0.05699287f, -0.01031091f, -0.02479417f, -0.09114506f, -0.02374166f, -0.02959250f, 
    -0.03729074f, -0.01208006f, 0.01907451f, -0.02125307f, 0.01223307f, 0.03454542f, 0.01651522f, 0.13537608f, 
    -0.00508403f, 0.19195594f, 0.23072314f, -0.00615678f, -0.05445041f, -0.05536024f, -0.12421800f, -0.04813104f, 
    -0.05614156f, -0.13326928f, -0.08711661f, 0.06424812f, -0.08278172f, -0.06688852f, 0.00773218f, -0.32546887f, 
    -0.11579921f, -0.41184285f, -0.49013633f, -0.24433318f, 0.32246250f, -0.58658379f, -0.44427073f, 0.03508027f, 
    -0.10562834f, 0.04945700f, -0.11935056f, -0.00114303f, -0.06171478f, -0.34408486f, -0.04047963f, -0.01238275f, 
    -0.00864169f, 0.00647368f, -0.00692133f, 0.00581254f, 0.02340843f, 0.13117248f, -0.07768057f, 0.12053195f, 
    0.14655550f, 0.09635361f, -0.55911249f, -0.06475171f, 0.07661568f, 0.18974797f, 0.13192433f, 0.20858337f, 
    0.09617355f, 0.03867105f, 0.05847692f, -0.05834650f, -0.07330254f, 0.03063464f, -0.01877587f, 0.04394257f, 
    0.01848688f, 0.05082018f, 0.06147249f, -0.06212592f, -0.07069476f, -0.07104986f, -0.05660999f, 0.06791604f, 
    -0.06512534f, -0.06275012f, -0.03394290f, 0.02766066f, -0.00873530f, 0.00547653f, 0.03643830f, 0.01164172f, 
    0.08252934f, -0.03026385f, 0.08355381f, -0.01312939f, 0.14267172f, 0.16438144f, 0.11537886f, 0.20135447f, 
    -0.02698459f, -0.16831145f, -0.89565742f, -0.56906623f, -0.08879169f, 0.10597529f, -0.28825977f, 0.37357262f, 
    -0.01215136f, -0.20786324f, 0.00448135f, -0.03406272f, 0.01323631f, 0.06757752f, 0.06103627f, 0.04965211f, 
    -0.01767327f, 0.03630982f, -0.01245534f, 0.02195159f, -0.07273606f, -0.58507645f, -0.93774790f, -0.24678187f, 
    0.10385740f, 0.10244925f, 0.11519534f, 0.17197873f, -0.02791863f, -0.17128150f, -0.04534834f, -0.02900047f, 
    -0.03587016f, -0.05179495f, 0.02174210f, 0.08557485f, 0.00433454f, -0.10196335f, -0.06611526f, -0.01230166f, 
    -0.05486491f, -0.16092826f, 0.13031004f, -0.29055157f, -0.02804206f, 0.05331321f, 0.06069993f, 0.10540254f, 
    -0.26081795f, -0.08775511f, 0.12584384f, -0.13445565f, -0.05505277f, -0.03811636f, -0.03539727f, -0.10062396f, 
    -0.03559266f, -0.07490818f, -0.18898706f, 0.05586820f, 0.43768024f, -0.73855162f, 0.11511225f, -0.28601936f, 
    0.09591302f, -0.04160967f, -0.30832943f, -0.04651987f, 0.13684033f, 0.17386955f, -0.11360149f, 0.03023204f, 
    0.04169949f, -0.08003680f, 0.06896924f, 0.01364013f, 0.16425644f, 0.03171213f, 0.02835232f, 0.14941709f, 
    0.05509044f, -0.13047394f, -0.05029083f, -0.15942022f, 0.18726493f, 0.03508371f, 0.02209120f, 0.01412990f, 
    0.04123272f, -0.04819031f, 0.05090897f, 0.11792327f, 0.07461637f, -0.13342609f, -0.04472389f, 0.19716798f, 
    0.02788228f, -0.07837669f, -0.04658375f, 0.03790341f, -0.05357127f, -0.02651195f, -0.18153022f, -0.21855198f, 
    0.00199113f, 0.04014061f, -0.11022718f, 0.14150026f, 0.01253954f, 0.06918408f, -0.03278373f, 0.08113515f, 
    -0.04401332f, -0.01636679f, 0.07320318f, -0.04004516f, 0.11222188f, 0.15285309f, 0.00008581f, 0.16652372f, 
    -0.78742170f, 0.38299239f, -0.45388272f, 0.15891533f, -0.09948934f, 0.01804195f, -0.17871946f, 0.02641195f, 
    -0.06963087f, -0.24195392f, 0.08637875f, -0.00008416f, -0.02090612f, -0.15471262f, 0.01028067f, -0.08736750f, 
    0.04831126f, -0.16046154f, 0.02775405f, -0.00308969f, -0.24165352f, -0.11974975f, 0.12138172f, -0.15254337f, 
    0.30470791f, -0.16574013f, 0.13767891f, -0.15737002f, -0.04357322f, -0.05093623f, 0.12308633f, 0.00151207f, 
    -0.00590757f, 0.02367731f, 0.03811999f, 0.25463498f, 0.13990457f, -0.03056876f, -0.05954793f, 0.04987597f, 
    -0.09905016f, -0.19794470f, 0.18059917f, -0.09543278f, 0.07032377f, 0.06401665f, -0.04755656f, -0.24117328f, 
    -0.02584430f, -0.04203411f, -0.03242306f, 0.11963138f, 0.05871950f, -0.07923568f, -0.01441522f, 0.11435208f, 
    -0.11413787f, -0.17670761f, -0.20383914f, -0.00857929f, 0.20519473f, 0.17816797f, 0.18619712f, 0.48164305f, 
    -0.39345714f, -0.16232026f, -0.04873364f, -0.49497023f, 0.12074060f, -0.17819096f, 0.07503357f, -0.06953716f, 
    0.12784360f, 0.17355451f, 0.01423373f, 0.10790436f, 0.08968144f, 0.02727760f, 0.05327802f, 0.11721709f, 
    -0.24098380f, 0.12295590f, -0.83689404f, 0.08373651f, 0.01888294f, 0.04873912f, 0.03189769f, 0.26740330f, 
    -0.03135918f, 0.02137854f, -0.03494680f, -0.01386357f, -0.00789067f, 0.00969379f, 0.01243889f, -0.04780893f, 
    0.12855062f, -0.04131199f, -0.07194076f, 0.07913652f, -0.04481766f, -0.26992533f, 0.26571012f, 0.16720328f, 
    -0.31752238f, -0.01534315f, -0.12437502f, 0.08838186f, 0.14946036f, 0.13214737f, 0.02572523f, -0.03614093f, 
    -0.00046226f, 0.02294511f, -0.02619974f, 0.03589413f, -0.01232572f, 0.01685113f, -0.02834084f, -0.17827609f, 
    -0.17287317f, 0.11321401f, -0.59906435f, 0.01147771f, -0.36964998f, 0.00481508f, -0.35041401f, 0.21472298f, 
    -0.18266101f, 0.13630615f, -0.00162502f, -0.03109775f, -0.04227189f, -0.12575610f, -0.11788789f, 0.11494369f, 
    -0.00823250f, -0.05416887f, 0.24536344f, -0.02100327f, -0.49756372f, 0.03173129f, -0.86022109f, 0.18601273f, 
    0.19131313f, -0.12973012f, 0.20943519f, 0.36568287f, -0.07032871f, -0.18123925f, -0.04995577f, 0.01677513f, 
    -0.06495827f, -0.11343325f, -0.10996374f, 0.13682236f, 0.18159124f, -0.18727581f, -0.06034445f, 0.02583500f, 
    -0.24432074f, -0.08988019f, -0.43313861f, -0.16955456f, 0.07885560f, -0.04449945f, 0.17531262f, 0.25357834f, 
    0.04014439f, 0.04241238f, 0.04792814f, 0.06121693f, -0.00079857f, 0.04938873f, -0.07058385f, 0.08377469f, 
    0.13314342f, 0.09266527f, 0.07075983f, 0.00995338f, -0.17095008f, 0.20722122f, 0.08311238f, 0.28988299f, 
    0.27308568f, -0.09935933f, 0.04348167f, -0.18691571f, -0.03972458f, -0.14119552f, -0.00085556f, -0.07221907f, 
    0.05569990f, -0.02336629f, -0.07449786f, 0.00117829f, -0.07602677f, -0.08770246f, -0.13799247f, -0.06730986f, 
    0.04614509f, 0.31470439f, -0.44307494f, -0.00823990f, -0.03333659f, 0.14812973f, 0.16127650f, 0.08497126f, 
    0.01191800f, -0.03768962f, 0.07353958f, -0.13251698f, -0.10955842f, -0.03210968f, -0.08144774f, 0.03673382f, 
    -0.10438602f, -0.06295151f, -0.10048643f, -0.05663685f, -0.01941055f, 0.04730629f, -0.08108104f, 0.18436517f, 
    0.09740068f, -0.00926797f, 0.01907944f, -0.01908124f, -0.04370151f, -0.17241941f, -0.08584002f, 0.00010165f, 
    -0.09630457f, -0.02171233f, -0.09153359f, 0.07939827f, -0.05945489f, -0.15238015f, 0.02909799f, -0.00163704f, 
    0.08975138f, 0.19373198f, 0.57393432f, -0.12695129f, -0.26890850f, 0.08867857f, -0.13737407f, 0.06729339f, 
    0.09343924f, 0.07149173f, -0.06152099f, -0.05408806f, 0.06898621f, -0.10194710f, -0.04395454f, 0.03076003f, 
    -0.06872353f, -0.04887814f, -0.15293202f, -0.23571821f, -0.21182410f, -0.16371799f, -0.38655436f, 0.06280734f, 
    -0.24571688f, 0.08930267f, -0.04882589f, 0.02034213f, 0.05244501f, -0.09898327f, -0.02395367f, 0.05459621f, 
    0.06417718f, -0.05949807f, 0.02533979f, -0.04595504f, 0.18398030f, -0.07552842f, 0.03846987f, 0.21338795f, 
    0.27620870f, 0.09952181f, -0.54307419f, 0.11573512f, -0.14015238f, 0.14395669f, 0.12500295f, 0.25992841f, 
    0.01602054f, 0.16668127f, 0.01370218f, 0.00547098f, -0.11673080f, -0.07617235f, -0.01864128f, -0.07643467f, 
    -0.01645265f, 0.04142279f, -0.01374760f, -0.01997104f, -0.49768257f, -0.46284968f, -0.02704465f, -0.28524747f, 
    0.16471681f, -0.13653891f, 0.14232147f, -0.34189540f, -0.37961233f, 0.05426770f, 0.04312294f, -0.00364147f, 
    -0.00138510f, -0.00722668f, 0.07336980f, 0.20166376f, -0.07318893f, -0.03286783f, -0.06809670f, -0.10940032f, 
    -0.24138018f, -0.23427291f, 0.08172158f, -0.08774662f, -0.02752228f, -0.05723239f, -0.44633323f, -0.04608333f, 
    -0.09377822f, 0.19360377f, 0.04419040f, -0.01839039f, 0.08242343f, -0.02733825f, -0.14395265f, -0.02578306f, 
    0.02832682f, 0.12910131f, 0.01652150f, 0.02219999f, -0.31414059f, 0.28820330f, 0.35922441f, 0.59312141f, 
    -0.35696706f, 0.08962453f, -0.14489146f, -0.26987383f, -0.27490473f, -0.33620855f, 0.16059813f, -0.06048867f, 
    0.10597890f, 0.01248090f, 0.07440491f, 0.05827309f, -0.08664373f, -0.10456863f, 0.05448280f, 0.03252101f, 
    -0.05750936f, 0.01535872f, 0.00451307f, 0.46257079f, -0.24199784f, 0.07735798f, -0.20102899f, -0.03495995f, 
    -0.02649713f, 0.21313863f, 0.05686562f, 0.02998064f, 0.12064315f, 0.06495324f, 0.08198957f, -0.07367293f, 
    0.02354000f, 0.21100391f, 0.23269302f, 0.34310859f, -0.11981691f, 0.12565276f, 0.14096726f, 0.00257072f, 
    0.13105229f, 0.05391499f, -0.08137485f, -0.15865515f, -0.09154217f, -0.04891888f, 0.00207557f, 0.05917412f, 
    0.11399291f, 0.06624761f, 0.00991283f, -0.02037298f, -0.06288646f, -0.12098556f, -0.09806433f, -0.12874644f, 
    0.07052043f, 0.00671969f, 0.41334596f, 0.23431779f, -0.25517786f, 0.04269727f, -0.21248609f, -0.26833212f, 
    -0.04625998f, -0.33457157f, 0.00089666f, 0.13911974f, -0.03476023f, 0.20876838f, -0.02087079f, 0.04535701f, 
    -0.02250143f, -0.07237568f, 0.02257411f, 0.11351835f, -0.14480443f, -0.01672853f, 0.37353125f, 0.26200661f, 
    -0.34221482f, -0.02315414f, -0.27169594f, 0.08629778f, 0.10967366f, 0.20087035f, -0.00948915f, 0.06138083f, 
    0.03061805f, -0.04897717f, -0.02174014f, 0.02037072f, -0.01476565f, 0.01651189f, -0.07199890f, -0.18737146f, 
    -0.07263608f, -0.17495807f, -0.22577080f, 0.11935420f, 0.30571327f, -0.07259361f, 0.11565269f, 0.10445057f, 
    -0.07357218f, 0.02837485f, -0.05851102f, -0.10912973f, 0.03349449f, -0.03259271f, -0.01384482f, -0.02838210f, 
    0.21938600f, 0.09916908f, -0.08399229f, 0.33584726f, 0.04177633f, -0.05460706f, -0.13452125f, 0.13042666f, 
    -0.25458404f, -0.13733141f, -0.23597400f, 0.18366766f, 0.08914961f, 0.32841945f, -0.10832586f, 0.09720987f, 
    0.02878833f, -0.05018318f, -0.01108428f, -0.01282828f, -0.02722251f, 0.04151897f, 0.03957016f, -0.26238030f, 
    -0.37159103f, 0.10986675f, -0.37134540f, 0.09315715f, 0.02511491f, -0.11917028f, 0.12909409f, -0.23787193f, 
    0.08196308f, 0.11302499f, 0.07988173f, -0.02573480f, 0.03689865f, 0.01679943f, 0.04448567f, 0.05260598f, 
    0.03049803f, 0.13456596f, -0.04159024f, -0.03142432f, 0.25325760f, -0.05110390f, 0.05881245f, 0.02027081f, 
    0.09037975f, -0.08991698f, 0.11105677f, -0.13319127f, -0.03213245f, 0.00197473f, -0.06569522f, 0.04999831f, 
    0.08874635f, 0.00286006f, -0.02063823f, -0.04775290f, -0.06171393f, -0.05681295f, -0.19715545f, 0.08331528f, 
    -0.23140900f, -0.52341372f, -0.13679582f, 0.24536037f, -0.62576783f, -0.29013467f, 0.18776841f, -0.11870681f, 
    -0.00392646f, 0.18245807f, 0.14237243f, -0.02672859f, 0.09895498f, 0.04201219f, 0.06914631f, -0.01480079f, 
    0.07664277f, -0.01861595f, 0.03982960f, -0.06174897f, 0.23695074f, -0.00044428f, -0.00924879f, 0.28224424f, 
    -0.79643077f, -0.08328995f, -0.03284266f, -0.33037111f, -0.08478691f, 0.08571326f, 0.11877394f, -0.04461745f, 
    0.02278908f, 0.02864332f, -0.01723800f, 0.02513624f, -0.00772399f, 0.16027160f, -0.03859776f, -0.00806516f, 
    -0.53418291f, 0.23117909f, 0.01893433f, 0.15781300f, -0.07526715f, 0.10790368f, 0.07009795f, -0.15725440f, 
    0.34121963f, 0.09114283f, -0.23255475f, -0.10517732f, 0.07537520f, -0.00067490f, 0.05941554f, -0.13602488f, 
    0.17308658f, -0.06199396f, 0.26304469f, 0.19652426f, -0.32550678f, 0.26640534f, -0.08991684f, 0.18292655f, 
    -0.05560807f, 0.07206193f, 0.01123417f, -0.10746751f, 0.09173494f, -0.02672228f, -0.01021463f, 0.06704922f, 
    -0.03428243f, -0.02265331f, 0.09714233f, -0.12931447f, -0.03240461f, -0.19741476f, -0.35476097f, -0.16476600f, 
    -0.15793975f, -0.00609216f, 0.16031812f, 0.33400044f, 0.08310822f, -0.07351151f, -0.10226253f, -0.13831244f, 
    0.04691690f, 0.18055247f, -0.22790504f, 0.06613719f, 0.12199340f, -0.08962669f, 0.05027489f, -0.06385962f, 
    0.05307765f, -0.04577207f, 0.04833360f, 0.27357376f, 0.01592666f, 0.00207718f, -0.22757685f, 0.25194010f, 
    -0.23858477f, -0.02154177f, -0.02741888f, 0.17202237f, -0.11086717f, -0.02111630f, 0.03995922f, -0.00970034f, 
    -0.06433503f, 0.08967526f, -0.02550351f, -0.03645503f, 0.04509997f, -0.02606373f, -0.14360912f, -0.02468558f, 
    0.14305308f, -0.55966431f, 0.33998540f, 0.05501585f, 0.02619703f, -0.19977400f, 0.13496736f, 0.18108788f, 
    0.12189108f, -0.03489899f, -0.11523037f, -0.02895537f, -0.06307654f, 0.17991182f, 0.13399550f, -0.00777741f, 
    0.14198296f, 0.10974629f, 0.05063396f, 0.00916536f, 0.35603359f, -0.40836826f, 0.53659642f, 0.09152897f, 
    -0.50704962f, 0.04564442f, -0.15778935f, -0.08957571f, -0.02832255f, -0.12202919f, -0.09088856f, 0.03108446f, 
    0.06919402f, 0.04705944f, 0.02328045f, 0.03185112f, 0.07373390f, 0.01755486f, -0.07123265f, -0.08413221f, 
    -0.33561832f, 0.04426156f, 0.19525404f, 0.09278605f, -0.14792062f, 0.10993581f, -0.01671533f, 0.13372891f, 
    0.11417525f, 0.10368934f, -0.20716895f, -0.00758206f, 0.14264035f, -0.12489723f, 0.00497709f, -0.07735944f, 
    -0.02850295f, 0.01700330f, 0.07753086f, 0.15675844f, 0.00912216f, 0.16525188f, -0.10347426f, 0.05913347f, 
    0.04235461f, 0.14604615f, -0.00825895f, -0.05636624f, -0.06647041f, 0.04408599f, -0.21727477f, 0.16337799f, 
    -0.01733063f, -0.22494124f, -0.14916375f, -0.01072642f, -0.01697473f, -0.13513193f, -0.03857113f, -0.15341575f, 
    -0.14597778f, -0.12905683f, -0.19778889f, 0.15719885f, -0.07106482f, -0.06799986f, -0.15295009f, 0.17775393f, 
    -0.13649480f, -0.14361043f, -0.10965861f, 0.03203804f, -0.07861601f, 0.06470827f, 0.03265632f, 0.04847037f, 
    -0.23471303f, 0.06512335f, -0.16250712f, -0.04611175f, -0.35642651f, 0.08915310f, -0.15102792f, -0.07317351f, 
    0.11180914f, -0.02487827f, -0.05915889f, 0.02633758f, -0.00525612f, -0.05295807f, -0.10518500f, -0.02273538f, 
    0.00037794f, 0.06805651f, 0.05611347f, 0.09912652f, 0.00246579f, -0.06052196f, -0.01509061f, 0.12679116f, 
    -0.43625230f, -0.03080918f, 0.26568314f, -0.18508737f, 0.09991446f, -0.09539185f, -0.13876250f, 0.14174393f, 
    0.12018020f, -0.11094211f, -0.19868171f, 0.16929328f, 0.06910618f, 0.02171559f, 0.02968859f, 0.14546801f, 
    0.03882628f, 0.08843974f, 0.05194094f, -0.16180748f, -0.29914665f, -0.44413197f, 0.10739337f, -0.23041347f, 
    0.06175480f, 0.09105229f, -0.26127490f, 0.14959547f, 0.09547648f, -0.22790572f, -0.16373862f, -0.07786925f, 
    0.09811512f, 0.13307542f, 0.18799549f, 0.17659777f, -0.09221300f, 0.13167697f, -0.05719944f, -0.04074880f, 
    -0.03647469f, -0.60308623f, -0.61637425f, -0.61150128f, -0.40006623f, -0.14473224f, -0.26622000f, -0.00927475f, 
    0.05148012f, -0.07219886f, -0.16773686f, 0.05206820f, -0.14736338f, -0.10685953f, -0.00113452f, 0.19633263f, 
    -0.13483937f, -0.07938491f, -0.05761100f, -0.17292029f, 0.34427860f, -0.37419966f, 0.17527115f, 0.10445115f, 
    -0.23907277f, 0.18191241f, -0.13100630f, -0.12967677f, -0.07577788f, 0.08030815f, -0.15590277f, 0.09407565f, 
    -0.10187615f, -0.05766873f, -0.03082080f, -0.05699787f, -0.06255570f, 0.03659906f, 0.11537541f, -0.03595226f, 
    -0.40516695f, -0.50843340f, 0.15023085f, -0.05378637f, -0.10244887f, 0.00167949f, -0.02926997f, 0.21562596f, 
    0.03064033f, -0.00283300f, 0.01601260f, 0.03210754f, 0.02102658f, -0.00992388f, -0.09799457f, 0.04120492f, 
    0.17803317f, 0.07796331f, 0.04435853f, 0.13074462f, -0.33447248f, -0.31176594f, 0.09844104f, -0.02558443f, 
    -0.13647202f, -0.11553617f, 0.04455826f, 0.17611286f, 0.07560549f, -0.07481062f, 0.01821084f, -0.07760082f, 
    -0.01948967f, 0.06323125f, 0.07220523f, 0.02722199f, 0.01727868f, 0.26454899f, 0.10235074f, 0.19289534f, 
    -0.39230359f, -0.04742579f, -0.14499523f, 0.28875148f, -0.08049091f, -0.11214618f, 0.10503794f, -0.14692637f, 
    0.22181292f, 0.06035187f, -0.08843318f, -0.23332483f, 0.05360391f, 0.06577343f, 0.03504756f, 0.13916476f, 
    0.05380093f, -0.09400683f, 0.20688091f, 0.34189609f, -0.31201714f, -0.04166039f, 0.21221849f, 0.02495548f, 
    -0.01453874f, 0.00709434f, -0.06465047f, 0.11670550f, 0.27914172f, 0.17756307f, -0.16355151f, -0.08401326f, 
    -0.12142224f, 0.15837063f, -0.04837814f, 0.12516667f, -0.19816472f, 0.05075012f, -0.14862320f, -0.08918973f, 
    0.01225344f, -0.37245888f, -0.16958754f, 0.22880875f, -0.06134991f, -0.08355875f, -0.24394454f, 0.16324577f, 
    -0.10300283f, -0.01989343f, -0.11934131f, 0.17901914f, -0.04664634f, -0.01546029f, -0.00141869f, 0.02802661f, 
    -0.08923459f, -0.01189123f, 0.00614429f, 0.11246581f, 0.59761900f, -0.02268350f, 0.35803288f, -0.17401110f, 
    0.17544629f, -0.03813057f, 0.05903170f, 0.29701936f, 0.24160345f, 0.11488134f, -0.02016129f, 0.13664620f, 
    0.13684577f, -0.10836478f, -0.06423399f, -0.04921686f, 0.05506774f, 0.08484864f, 0.18060243f, 0.13941634f, 
    -0.35563913f, 0.04008887f, -0.15377916f, 0.08543509f, 0.04825044f, -0.06905935f, -0.00959870f, -0.45246667f, 
    -0.13042034f, -0.03324802f, -0.04128247f, 0.15245806f, -0.01856290f, -0.02873882f, -0.01891698f, -0.02905585f, 
    0.07195494f, -0.13645183f, 0.05054020f, -0.09127144f, 0.21376069f, 0.02344039f, 0.27454072f, -0.16424450f, 
    0.07560521f, -0.18673730f, 0.00021117f, 0.06326462f, 0.13050874f, 0.01813378f, 0.04468729f, 0.03426576f, 
    -0.17559943f, 0.07762279f, 0.00487303f, 0.01410707f, -0.01401613f, 0.07138694f, 0.14224589f, 0.10156073f, 
    -0.25767133f, 0.04558176f, -0.34381711f, -0.00403443f, 0.01100237f, -0.18305601f, 0.08043180f, -0.16554031f, 
    -0.02063581f, -0.01186461f, -0.02484801f, 0.07728489f, 0.01870692f, 0.04452275f, -0.01151738f, 0.11938117f, 
    -0.09379379f, -0.07278637f, -0.12209261f, -0.16555728f, 0.10200863f, -0.25949314f, 0.12842011f, 0.21115682f, 
    -0.18003865f, 0.03863990f, 0.06548884f, 0.15605637f, 0.08521299f, 0.09657839f, -0.02744346f, 0.02940795f, 
    0.06613771f, -0.07070641f, -0.11178452f, -0.00772424f, 0.07424732f, 0.22465457f, 0.25148124f, 0.19565322f, 
    -0.47682819f, 0.32271066f, 0.12080359f, -0.08270093f, -0.04887393f, 0.04146922f, -0.08194513f, -0.11964150f, 
    0.11775793f, 0.02435150f, 0.03583099f, -0.04826748f, -0.06122693f, 0.02763813f, -0.03920029f, -0.20056278f, 
    -0.08370173f, -0.04366837f, 0.08568161f, -0.02236279f, -0.45187092f, 0.01931584f, -0.24973562f, 0.03511862f, 
    0.08875683f, -0.05222569f, -0.00746740f, -0.18928556f, -0.11420754f, -0.10318793f, -0.03736363f, 0.01851897f, 
    -0.01411229f, 0.05129388f, 0.00904782f, 0.00967881f, 0.01970280f, -0.15167753f, 0.05416439f, 0.07692254f, 
    0.23990034f, -0.34749031f, 0.26301444f, 0.29512939f, -0.06800057f, -0.08660559f, -0.00365502f, 0.07044683f, 
    -0.13008288f, -0.04924544f, -0.02218349f, 0.06069760f, -0.23445471f, 0.01767986f, 0.00154144f, -0.05343184f, 
    -0.16731259f, -0.02360717f, -0.07709725f, -0.23505910f, -0.41601372f, -0.10977293f, -0.07747904f, -0.02331298f, 
    0.10283011f, 0.04096376f, -0.11477534f, -0.31638819f, 0.10707442f, -0.11741658f, 0.00478402f, 0.14791657f, 
    0.00699454f, 0.08494682f, -0.00321403f, 0.06938218f, -0.08525875f, -0.22078310f, 0.03035063f, -0.01691541f, 
    0.01332876f, 0.11073634f, -0.10046415f, 0.11115445f, 0.17957908f, -0.02540681f, 0.01058227f, -0.07600240f, 
    -0.07233676f, 0.04141431f, -0.09000052f, 0.06619444f, 0.05075170f, -0.04959203f, 0.04221945f, 0.00048738f, 
    0.08617222f, -0.13430046f, -0.07038985f, -0.07371309f, -0.05702298f, 0.00706749f, 0.24382488f, 0.11267865f, 
    -0.12370180f, -0.04571965f, 0.08175874f, -0.03186458f, -0.03482696f, -0.01819167f, -0.01722785f, 0.10495488f, 
    -0.02536868f, 0.05505805f, -0.01423167f, 0.10111249f, 0.09934662f, 0.09639393f, 0.08065547f, 0.32270300f, 
    -0.27882949f, 0.11289112f, -0.91888088f, 0.10556334f, 0.22673620f, 0.00914424f, -0.03207675f, -0.06843875f, 
    -0.38841096f, 0.07676634f, -0.07204195f, 0.10515401f, 0.00098143f, -0.05458972f, 0.04075016f, -0.00099322f, 
    0.00307648f, -0.25605708f, 0.01731692f, 0.02817904f, 0.27267686f, -0.11946869f, -0.13451952f, 0.01897207f, 
    0.10620166f, -0.02365974f, -0.07536958f, 0.23055069f, 0.10470314f, 0.08269890f, -0.05512515f, 0.12929101f, 
    -0.01780758f, -0.23717859f, -0.22835097f, -0.02456921f, 0.01992190f, 0.08681037f, 0.07256659f, -0.08458693f, 
    -0.08846387f, 0.21153903f, -0.03077265f, 0.29121837f, -0.13800187f, -0.28470486f, 0.05358240f, -0.06415882f, 
    0.34626275f, -0.13928494f, -0.22364594f, 0.04730324f, -0.00522454f, 0.02127754f, 0.19820814f, 0.16352151f, 
    -0.16926011f, 0.17101946f, 0.08618106f, -0.25443059f, -0.61394322f, -0.41694835f, -0.33587784f, 0.18962267f, 
    0.24255931f, -0.01674183f, -0.00745024f, -0.07416616f, 0.08397750f, -0.16715997f, -0.05730497f, 0.06672101f, 
    0.01154039f, -0.02834191f, 0.15898730f, 0.12264528f, -0.06304533f, 0.18452860f, 0.20477493f, 0.16761675f, 
    -0.14651667f, -0.01151502f, -0.06838027f, 0.29304346f, -0.14499673f, -0.04824926f, 0.03416108f, 0.02961530f, 
    0.12881701f, 0.08485452f, -0.20713738f, -0.16304241f, -0.11234966f, 0.06057714f, -0.12549852f, -0.00007411f, 
    0.08707894f, 0.25862226f, -0.07973180f, -0.11617373f, 0.18897767f, -0.20764945f, 0.16208418f, -0.04240727f, 
    -0.00854858f, -0.01847714f, 0.11699582f, -0.11872250f, 0.18503456f, -0.06304663f, -0.23447660f, 0.09767768f, 
    -0.01534900f, -0.10992465f, 0.02015373f, 0.14435807f, -0.02547319f, 0.00749694f, 0.00561448f, -0.05212272f, 
    0.20637722f, -0.20543957f, 0.39648315f, -0.26346904f, 0.44623721f, 0.34399426f, 0.18273586f, -0.04359182f, 
    0.23028103f, 0.01996046f, -0.11679354f, 0.07845723f, 0.02896312f, 0.07313954f, 0.04358802f, -0.01848935f, 
    0.27691093f, -0.15242097f, -0.12304100f, 0.05597821f, -0.43316492f, 0.04902060f, -0.43090171f, 0.02060306f, 
    0.31432024f, -0.04027093f, 0.25083488f, 0.00942637f, -0.11807359f, 0.13902856f, -0.06743424f, 0.11264550f, 
    -0.02667841f, 0.15169337f, 0.19685473f, 0.09325025f, 0.11157032f, 0.06975578f, -0.03261849f, -0.09444457f, 
    -0.27460745f, 0.18233851f, -0.15194498f, 0.33079684f, -0.20983803f, -0.02377633f, 0.15348352f, 0.12152397f, 
    0.19255681f, 0.02607554f, -0.04399113f, 0.06313848f, -0.08995334f, 0.01957736f, -0.02948475f, 0.09338901f, 
    -0.02526456f, -0.00397979f, -0.16116044f, -0.02419488f, -0.92123425f, 0.17619300f, -0.59842110f, 0.17361200f, 
    -0.63618577f, 0.11541048f, 0.08636155f, 0.07915723f, -0.06385770f, 0.15863308f, -0.08646735f, -0.24621665f, 
    0.06298315f, 0.11387919f, -0.02149644f, -0.01327389f, -0.00154756f, 0.04284335f, -0.01542028f, 0.05302167f, 
    0.61036801f, -0.25399253f, 0.39185828f, 0.05753648f, -0.17815091f, -0.05318594f, -0.08963838f, -0.26942658f, 
    0.22904697f, -0.12313143f, -0.12612069f, 0.03060768f, 0.04125984f, -0.04124802f, -0.07404298f, 0.07849687f, 
    0.10979665f, 0.11152389f, 0.09959095f, 0.08739589f, 0.14163165f, -0.23234108f, -0.22954127f, 0.19833185f, 
    0.07269774f, -0.10571386f, -0.23657255f, -0.02940995f, -0.29437843f, 0.01473649f, 0.01511059f, 0.00611102f, 
    -0.07664105f, -0.04964905f, -0.16268626f, 0.00260892f, -0.04094986f, 0.03274223f, -0.03770333f, -0.24672896f, 
    0.13456503f, -0.75476891f, 0.01528255f, -0.49233368f, 0.45529273f, 0.04120168f, -0.14241265f, -0.21866918f, 
    0.02785764f, -0.29592562f, -0.00180571f, 0.05516846f, 0.00482801f, 0.15077373f, -0.10099179f, 0.08855325f, 
    -0.07513500f, 0.08799384f, -0.03930668f, 0.13798185f, 0.71021503f, 0.00649826f, 0.46900383f, 0.16385812f, 
    0.12794152f, -0.03416473f, 0.15730429f, -0.12021609f, 0.12628774f, -0.28977165f, -0.12933895f, -0.14006808f, 
    -0.01890759f, -0.01382322f, -0.02676740f, 0.11910030f, -0.03369377f, 0.09118871f, -0.02978166f, 0.07960788f, 
    0.26781735f, 0.05400881f, 0.27919111f, 0.00639203f, -0.26563948f, -0.06665230f, -0.03159979f, -0.08424032f, 
    0.06867652f, 0.00994044f, -0.15725353f, -0.04736177f, 0.02367766f, -0.11177240f, -0.16637382f, -0.03602619f, 
    0.04330753f, -0.02032634f, -0.11269096f, 0.08098662f, -0.37750730f, -0.12663518f, -0.16814822f, 0.05295327f, 
    0.07366614f, -0.00156741f, 0.10808895f, 0.02474244f, -0.02214588f, 0.10506935f, 0.00591696f, -0.05941455f, 
    -0.13262105f, -0.02245476f, 0.01063137f, -0.02027510f, -0.21927820f, -0.19576386f, 0.06021796f, -0.14148375f, 
    0.28226414f, 0.37640595f, 0.08931223f, 0.08730349f, -0.14799690f, 0.14500202f, 0.07931464f, 0.00201663f, 
    -0.24565405f, -0.03547290f, -0.18896514f, 0.13642466f, 0.07513089f, 0.13691731f, -0.01285169f, -0.09779510f, 
    -0.13317710f, -0.00630264f, -0.02350883f, 0.08599604f, -0.12503469f, 0.08986603f, 0.09783795f, 0.00110421f, 
    -0.03221761f, 0.13587600f, -0.02378770f, 0.12062136f, 0.02630377f, -0.06216469f, -0.03145613f, 0.08517848f, 
    -0.03255659f, -0.04794559f, 0.06214957f, 0.03048943f, -0.11909897f, -0.01360895f, -0.41037029f, -0.12022030f, 
    -0.11779841f, -0.25478068f, -0.15794446f, 0.28852144f, 0.07598263f, -0.30072150f, -0.00167824f, 0.10912295f, 
    0.12674089f, -0.15825407f, -0.00534266f, 0.06088451f, -0.02784035f, -0.14674781f, 0.09813040f, -0.08131428f, 
    -0.05034416f, 0.08718412f, -0.12110665f, -0.29901859f, 0.34168380f, -0.62565434f, 0.42777365f, 0.43448862f, 
    0.22355996f, 0.00756885f, 0.00150350f, 0.20042963f, -0.04156910f, -0.12750542f, 0.15750964f, -0.05828395f, 
    0.17920725f, 0.05293625f, 0.05287810f, 0.08351435f, 0.04497895f, 0.09211161f, 0.05382888f, -0.12300956f, 
    0.40234870f, 0.09601995f, 0.57595539f, 0.03534967f, -0.38808101f, -0.10249946f, -0.06041915f, -0.14870076f, 
    0.06668334f, -0.02215149f, -0.07537153f, -0.01580835f, 0.02898771f, 0.07937694f, -0.00152689f, -0.10829421f, 
    0.08521545f, 0.08900234f, 0.11312151f, 0.04371178f, -0.53485745f, -0.08825236f, -0.42105857f, 0.28474286f, 
    0.47588688f, -0.07158541f, 0.08333012f, -0.10161980f, -0.15283209f, 0.23162350f, -0.06096158f, 0.05736929f, 
    -0.11392201f, 0.00998668f, -0.12336794f, 0.10193685f, -0.26804349f, -0.07088326f, -0.08020964f, -0.00237171f, 
    0.13141352f, 0.02150336f, 0.04558023f, -0.31154436f, -0.21245027f, -0.09987499f, -0.15630411f, -0.04379348f, 
    0.04441884f, -0.08935636f, -0.03856479f, 0.07729495f, -0.04381555f, -0.01962537f, -0.05146988f, 0.08684798f, 
    -0.05413138f, 0.04778631f, -0.02079998f, -0.06813298f, 0.00674275f, -0.31773943f, 0.19508019f, 0.05258504f, 
    0.03084204f, 0.15699002f, 0.07515827f, 0.05154792f, -0.15302677f, 0.06247661f, 0.00370206f, 0.10988564f, 
    0.09441692f, -0.13504983f, -0.10885436f, -0.05172879f, -0.01422760f, 0.08998223f, -0.05997043f, -0.03326625f, 
    0.21870357f, -0.41225535f, 0.02002587f, -0.56976199f, 0.10779097f, 0.01591260f, -0.15655096f, 0.08084666f, 
    -0.07820391f, -0.10200932f, -0.02941401f, -0.00578958f, 0.06415243f, -0.11196768f, -0.11652515f, 0.05794333f, 
    0.08144138f, -0.05490806f, 0.11175149f, -0.02685024f, -0.16206215f, -0.13602555f, 0.04281356f, -0.02460954f, 
    0.11687825f, -0.01184991f, 0.13928437f, -0.12589531f, 0.13981627f, 0.06441802f, 0.02440923f, 0.05315752f, 
    -0.17909181f, -0.06709418f, 0.08568756f, -0.09782674f, -0.11508592f, -0.06100294f, -0.17397292f, -0.32128084f, 
    -0.67590928f, 0.11437969f, -0.55132842f, 0.40153760f, -0.34546047f, 0.02048501f, 0.12499636f, -0.03653288f, 
    0.27939242f, 0.06959917f, -0.13536151f, -0.12330327f, 0.02825538f, 0.02826220f, -0.00183269f, 0.06654097f, 
    -0.05662474f, 0.09581700f, -0.14293110f, 0.11988584f, 0.04392564f, -0.32834804f, -0.27586648f, -0.03105011f, 
    -0.18441088f, -0.00658928f, -0.29897907f, -0.02451207f, -0.18484581f, -0.02939181f, -0.01018386f, 0.07238829f, 
    -0.03743742f, -0.07928739f, -0.02953038f, -0.03005489f, -0.01428475f, 0.00346089f, 0.07283520f, -0.06000946f, 
    -0.18434680f, -0.34317157f, -0.11172821f, 0.08209247f, -0.08353522f, -0.03931077f, 0.10438620f, -0.01041761f, 
    0.02193352f, 0.00709619f, -0.10356292f, 0.13683721f, -0.00074733f, 0.08673388f, -0.06130595f, 0.06451944f, 
    -0.09345543f, 0.08733679f, 0.09225228f, -0.01738992f, -0.19164144f, -0.40132281f, -0.12134821f, -0.26034257f, 
    0.05158819f, -0.05176703f, -0.46280438f, 0.00639437f, -0.09160589f, -0.09435492f, -0.05642000f, 0.03558967f, 
    0.06572666f, -0.02549651f, -0.04303643f, 0.00355222f, -0.09874325f, 0.06074005f, 0.13233817f, -0.09523963f, 
    -0.16543865f, -0.00713489f, -0.08795018f, 0.06948592f, -0.12922542f, 0.12398978f, -0.04858208f, 0.07729317f, 
    -0.19642678f, 0.04488726f, -0.04861850f, -0.04826312f, -0.07535738f, 0.06214657f, 0.09379219f, 0.06863272f, 
    -0.09581532f, 0.01690003f, 0.06669445f, 0.06434676f, -0.23075563f, 0.12507486f, -0.19602476f, 0.22255710f, 
    -0.06534879f, -0.01814713f, 0.05170818f, 0.01081335f, -0.00998298f, 0.00695445f, -0.04352325f, -0.02021598f, 
    -0.13502513f, 0.03053341f, 0.02499535f, 0.00899369f, -0.07106331f, 0.08073482f, -0.08322721f, -0.18365118f, 
    -0.22253549f, -0.21850884f, -0.11700233f, 0.53549653f, -0.17528717f, 0.01637059f, -0.01508649f, 0.21809697f, 
    -0.19786406f, 0.13380854f, -0.05532039f, -0.05043810f, 0.20879360f, 0.04386303f, -0.00985102f, 0.02931223f, 
    0.09471616f, 0.19482760f, 0.03148427f, 0.00747595f, -0.08369383f, 0.07060245f, 0.01908506f, -0.12892108f, 
    -0.04196482f, -0.04407847f, -0.09682354f, -0.07566071f, 0.05498332f, 0.04763997f, 0.06671824f, 0.03152862f, 
    -0.06777094f, -0.09752782f, -0.04947527f, -0.02644875f, 0.00116116f, -0.03758717f, 0.17415655f, 0.07948536f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.19914784f, 0.16195056f, 0.03456072f, -0.09740241f, -0.07629783f, -0.02721948f, 0.01807495f, -0.15277220f, 
    0.00652622f, 0.02174110f, -0.00359829f, 0.00070252f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
