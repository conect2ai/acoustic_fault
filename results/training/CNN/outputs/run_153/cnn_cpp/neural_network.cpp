#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.59190363f, -0.85562623f, -0.65721089f, 0.16536011f, -0.01615836f, -0.01934520f, 0.08351783f, -0.01473858f, 
    -0.07537437f, -0.52353346f, 0.36196142f, 0.25099954f, -0.66840124f, 0.21236631f, 0.26160488f, 0.20145215f, 
    0.40599099f, -0.60894960f, -0.72875202f, -0.55233359f, -0.82261842f, 0.17278962f, 0.11753499f, 0.25550005f, 
    -0.20508714f, 0.35590476f, 0.25920191f, 0.47494057f, -0.17700256f, 0.43323892f, 0.42843431f, 0.12318600f, 
    0.62104845f, -0.25325590f, -0.31067902f, 0.21718688f, -0.38554376f, -0.61884964f, -0.41713691f, -0.15572311f, 
    0.66011530f, -0.04390497f, -0.28417554f, -0.29427972f, -0.61886579f, 0.79418516f, -0.24613084f, 0.49848583f, 
    0.23701924f, 0.30056581f, 0.37956971f, -0.31714377f, -0.49498659f, -0.54121256f, 0.37885320f, 0.50151443f, 
    -0.08791105f, -0.45780262f, -0.57832199f, -0.91835701f, 0.48038229f, -0.13069205f, 0.13181663f, -0.46514082f, 
    -0.73995948f, 0.30115646f, -0.66076714f, -0.52207327f, -0.42369533f, 0.14850940f, 0.34576067f, 0.19973519f, 
    -0.61665249f, 0.32544306f, 0.73952502f, -0.57812512f, 0.14828479f, -0.42005086f, -0.13991579f, -0.50986886f, 
    -0.33151752f, 0.18733145f, -0.43818468f, -0.07952709f, 0.81580424f, 0.73670763f, -0.70940590f, 0.29637551f, 
    -0.04446128f, 0.04502163f, -1.00785136f, 0.14673981f, 0.60033911f, 0.44692007f, 0.38694474f, 0.00893251f, 
    -0.27994478f, -0.42833716f, -0.26529175f, -0.04187475f, -0.13219169f, -0.49949962f, -0.13772596f, -0.00796690f, 
    -0.61485785f, 0.00046336f, 0.72454470f, -0.26391515f, 0.47164938f, 0.38337013f, -0.06233143f, 0.57207590f, 
    0.76925582f, 0.19836649f, -0.35838842f, 0.39425528f, 0.14406630f, 0.48928812f, 0.52118862f, -0.24045339f, 
    -0.59419882f, -0.29688203f, -0.67457813f, -0.43720910f, -0.16921806f, -0.35935819f, -0.77826798f, 0.00521766f, 
    0.16280472f, 0.69257003f, 0.72935116f, 0.40684816f, 0.13704246f, 0.25562692f, 0.21651658f, -0.25272289f, 
    -1.02110147f, -0.22434735f, 0.64042825f, -0.66732919f, 0.32518297f, 0.17217369f, -0.16191910f, -0.01090532f, 
    0.69505608f, 0.31364053f, 0.41466033f, 0.16626433f, 0.17939264f, -0.10146050f, -0.06186466f, 0.41344428f, 
    0.01420227f, -0.55002397f, 0.18736973f, 0.35660714f, 0.44744554f, -0.58579946f, -0.94570577f, -0.33531544f, 
    0.02516909f, 0.33903033f, -0.39253652f, -0.15516341f, -0.46814868f, -0.46376404f, 0.61951256f, -0.18194297f, 
    0.52913439f, -0.03226910f, -0.25072554f, -0.33811820f, 0.50287747f, -0.66685325f, -0.38150260f, -0.56820399f, 
    -0.13784094f, -0.46812314f, -0.41638982f, 0.27823144f, -0.76337719f, 0.90760064f, -0.72113740f, 0.11634655f, 
    0.18014477f, -0.56645644f, 0.06112044f, 0.07042672f, 0.24180353f, -0.44220749f, 0.81838626f, -0.20543572f, 
    0.39713484f, 0.03629565f, -0.35966867f, 0.06135136f, 0.47478583f, -0.37904260f, 0.44820595f, 0.55358803f, 
    0.68817723f, -0.61768311f, 0.57670939f, -0.30457124f, -0.16304795f, -0.11640468f, 0.44145581f, -0.13277958f, 
    -0.49955019f, -0.75171733f, -0.54413867f, -0.48829451f, -0.01536001f, 0.05455271f, 0.38200200f, 0.25430006f, 
    0.16491923f, 0.93290758f, 0.42472190f, 0.49758768f, 0.44542110f, -0.57403457f, 0.25877687f, -0.22632958f, 
    -0.23872833f, -0.33491319f, -0.58533758f, -0.65002638f, -0.51905662f, 0.32629430f, 0.54464251f, -0.28607357f, 
    -0.13880445f, -0.06391024f, 0.68277681f, 0.57013297f, 0.61060065f, -0.46640965f, -0.43783987f, 0.04117828f, 
    0.41604558f, -0.06245049f, -0.34716249f, 0.78571749f, 0.40594584f, -0.56997013f, -0.02558027f, 0.03720501f, 
    0.30808732f, 0.64111769f, 0.09853505f, -0.11604389f, 0.67544472f, 0.57731098f, 0.27691242f, -0.24065925f, 
    -0.54052824f, 0.48666519f, 0.04546757f, 0.44981501f, -0.09786804f, -0.59543633f, 0.51268077f, -0.70758712f, 
    0.27866817f, 0.42343780f, 0.70832682f, 0.56367248f, -0.64845359f, 0.31757215f, 0.26063368f, -0.41165000f, 
    -0.09483015f, -0.67724627f, 0.80964673f, -0.61640465f, -0.04074989f, 0.24266709f, 0.29011273f, -0.43560207f, 
    -0.74353677f, 0.38058251f, 0.30089960f, 0.37828025f, 0.81968373f, -0.03866654f, -0.38728473f, 0.13462868f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.09476114f, 0.12080002f, -0.02822480f, 0.19025470f, 0.16019294f, -0.04078252f, 0.14202465f, 0.31853217f, 
    -0.03640036f, -0.16313435f, -0.14303604f, 0.06328273f, -0.19365720f, -0.14016770f, -0.15952906f, -0.10456095f, 
    0.39530355f, 0.15902239f, 0.01974325f, -0.06889575f, -0.01217637f, -0.09986246f, -0.03289896f, -0.10160516f, 
    0.13661668f, -0.26520905f, -0.11358073f, -0.15480667f, -0.03951360f, -0.15670003f, -0.06951632f, -0.14485580f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.10337734f, -0.05788703f, -0.02158768f, 0.05401288f, 0.09936126f, 0.06878013f, 0.09510322f, -0.09122067f, 
    -0.07029927f, -0.03637261f, -0.07621945f, -0.11316821f, -0.03806686f, 0.01673766f, 0.05405287f, 0.06546646f, 
    0.08693993f, -0.00087223f, -0.00163934f, -0.10058608f, -0.11969818f, 0.09163036f, -0.04980117f, -0.03475338f, 
    0.07551284f, -0.23579989f, 0.05811055f, 0.01316572f, 0.02266892f, -0.03252678f, 0.00973688f, -0.11318950f, 
    -0.09287114f, 0.02222229f, 0.01987315f, 0.04955073f, 0.04467673f, 0.03179573f, -0.14523195f, 0.04133532f, 
    0.03356708f, 0.01808143f, 0.02633719f, -0.03707306f, -0.10744540f, 0.05338770f, 0.01459828f, 0.07346451f, 
    -0.06549811f, -0.12489398f, -0.22548293f, 0.05806907f, 0.06526835f, 0.02144159f, -0.14787386f, 0.08096274f, 
    0.13033150f, -0.01786809f, 0.04649501f, 0.06846054f, 0.07840414f, -0.01607460f, 0.02149626f, -0.14873424f, 
    -0.16297819f, 0.13670890f, 0.08797374f, 0.12459221f, -0.02292956f, -0.08237629f, -0.09171778f, -0.02098153f, 
    -0.02767256f, -0.15944299f, 0.16699563f, 0.12936896f, -0.01289224f, 0.02757482f, 0.01574747f, 0.09987679f, 
    -0.03668802f, -0.34380096f, -0.01010222f, -0.25250930f, 0.06124464f, 0.13441956f, 0.12883346f, 0.09140979f, 
    0.05578950f, 0.20812385f, 0.16205508f, 0.19633242f, 0.33103800f, 0.08497080f, -0.04072955f, -0.14886840f, 
    0.07796673f, 0.01561335f, -0.01746690f, -0.29313898f, 0.02535461f, 0.16839074f, -0.00402998f, -0.02546930f, 
    0.10069954f, -0.07834973f, -0.08525021f, -0.03824859f, 0.27146289f, -0.07425523f, -0.35433808f, -0.08956617f, 
    -0.12165322f, -0.05197044f, -0.18803127f, 0.21163943f, 0.21104147f, -0.03380594f, -0.10750150f, 0.18778014f, 
    0.09911793f, -0.05367216f, -0.00892922f, -0.09846359f, -0.03816736f, -0.00715909f, 0.15274310f, 0.28927827f, 
    0.07384026f, 0.09827665f, -0.08794884f, -0.09107568f, 0.04721699f, 0.04961677f, 0.11230310f, -0.05961374f, 
    0.07675856f, 0.16721119f, 0.21928167f, 0.00200709f, 0.12337470f, 0.03218093f, -0.21705954f, -0.02429631f, 
    0.15027903f, 0.07266194f, 0.07392450f, -0.04290550f, -0.06091812f, 0.11196750f, 0.01850753f, 0.05438345f, 
    0.00596215f, -0.32297298f, 0.02411635f, 0.02068036f, 0.01676811f, 0.10199574f, -0.13657118f, -0.00173231f, 
    0.15062273f, 0.16274829f, 0.08889125f, -0.12155450f, -0.00402846f, -0.01889663f, 0.08592462f, 0.19780800f, 
    -0.02887651f, -0.02671594f, 0.00503235f, -0.06398727f, 0.02839057f, 0.10466743f, 0.10970960f, 0.00256760f, 
    0.00734281f, -0.06058494f, 0.10708573f, -0.07786351f, 0.11016624f, -0.29350683f, -0.26059160f, 0.16201250f, 
    0.15518133f, 0.11305162f, 0.04371686f, -0.10825482f, -0.02287401f, -0.12309337f, 0.00212559f, -0.14683568f, 
    0.10304896f, 0.12934086f, 0.06367442f, 0.07432521f, 0.10236637f, 0.07205402f, 0.07794315f, -0.13674276f, 
    0.06323130f, -0.09358642f, -0.17068844f, -0.05906463f, 0.02651523f, 0.17019860f, 0.15878744f, -0.24126326f, 
    -0.13581035f, -0.05100311f, 0.05386932f, 0.02075939f, -0.00372540f, -0.06840641f, 0.06216170f, -0.20642757f, 
    -0.04032189f, 0.22869283f, 0.07107138f, 0.01176909f, 0.01907071f, -0.10312854f, 0.19276421f, -0.07482773f, 
    0.05722956f, 0.02334591f, 0.01530909f, -0.29351971f, -0.05531679f, 0.04109498f, -0.07525474f, -0.15058944f, 
    -0.20805262f, 0.07825651f, 0.15534222f, 0.12509818f, -0.03097822f, -0.17277652f, -0.24934699f, -0.17823087f, 
    0.05325560f, -0.01221165f, 0.13096377f, -0.20210281f, -0.00607549f, -0.10186494f, -0.03794822f, -0.13157015f, 
    -0.03131437f, -0.03284938f, 0.02410763f, 0.09370700f, 0.22611170f, 0.11761615f, 0.04829148f, -0.19079064f, 
    -0.09977064f, -0.19378342f, -0.05332704f, 0.04870118f, 0.15791199f, 0.28096530f, 0.11783034f, -0.34853187f, 
    -0.12253138f, 0.05185505f, -0.06041264f, 0.10619807f, 0.04844153f, 0.11180264f, -0.14518096f, -0.22986384f, 
    0.00181768f, 0.02527943f, 0.04827922f, 0.20032670f, -0.05250783f, -0.05233570f, 0.00051376f, 0.02177297f, 
    0.00001747f, 0.11224575f, -0.06325232f, -0.03098905f, -0.16704229f, 0.13772172f, -0.03909528f, -0.10041291f, 
    0.16247241f, -0.02681600f, 0.08150814f, -0.11364939f, 0.07152272f, -0.03459414f, -0.08084905f, 0.12145036f, 
    0.02061194f, -0.02686386f, -0.12488668f, 0.17326283f, 0.07873449f, -0.02138785f, -0.18971808f, -0.01751942f, 
    -0.03630544f, -0.08588123f, 0.05808867f, 0.00609604f, 0.24042504f, 0.11449422f, 0.09884767f, 0.23021241f, 
    -0.02833523f, 0.06705319f, 0.08112446f, 0.42174995f, -0.24698041f, -0.24335931f, 0.03132936f, -0.16641858f, 
    -0.04647963f, 0.02638366f, -0.10494231f, -0.07701836f, 0.08813294f, 0.22271466f, 0.29323521f, 0.11366034f, 
    0.08345521f, 0.08269233f, -0.15043320f, 0.05956381f, -0.01015693f, 0.35097501f, 0.00549892f, -0.00189996f, 
    -0.00434968f, -0.14367549f, 0.05324019f, 0.11212459f, 0.03481586f, -0.04306614f, -0.22062139f, 0.01067100f, 
    -0.07558421f, -0.11276940f, -0.10474278f, -0.08876568f, -0.00893053f, -0.03592432f, 0.08540095f, 0.08916663f, 
    -0.08156317f, -0.01964811f, -0.06947161f, -0.13503392f, 0.05410785f, -0.11500688f, 0.04977125f, -0.05016975f, 
    0.27455926f, -0.18150042f, 0.06932005f, 0.02720297f, -0.08070317f, 0.00414862f, 0.06216902f, 0.15903109f, 
    0.01352923f, -0.08146822f, 0.18463668f, -0.08653700f, -0.06700726f, -0.03954986f, 0.05103006f, 0.13058048f, 
    0.04767070f, 0.02497880f, 0.12245265f, 0.13588229f, -0.11264320f, 0.12919013f, 0.10286155f, -0.00314510f, 
    -0.04724502f, 0.07730158f, 0.13575512f, -0.32985875f, -0.02608386f, 0.10021351f, -0.09340443f, -0.14783594f, 
    0.08227801f, -0.11036385f, 0.01613241f, -0.08680843f, -0.07905137f, 0.01111426f, 0.17588842f, 0.11007312f, 
    -0.02653017f, -0.09259423f, 0.06349298f, 0.01932016f, -0.01197406f, -0.14731845f, -0.12570015f, -0.07308130f, 
    -0.07303537f, -0.10408128f, -0.04171618f, -0.03561290f, 0.06111116f, -0.04230207f, 0.14897306f, 0.08012156f, 
    0.05094514f, 0.02752935f, -0.01867671f, 0.03801816f, -0.03471022f, 0.08691063f, 0.08032417f, 0.01812857f, 
    0.12289378f, -0.03058696f, 0.03835655f, 0.08759755f, -0.04731366f, 0.11715149f, -0.16957037f, 0.04369188f, 
    -0.02059850f, 0.05256350f, -0.05372284f, -0.00266599f, -0.03935685f, 0.05107829f, -0.06932263f, -0.06622347f, 
    -0.07367503f, -0.02005628f, 0.00801072f, -0.31126186f, 0.01695531f, -0.00914014f, -0.06438663f, -0.06963769f, 
    0.13761240f, 0.01119316f, 0.04143734f, 0.23508979f, 0.22971956f, -0.08091332f, 0.01313363f, -0.02299241f, 
    -0.12684627f, -0.06536388f, 0.05074938f, -0.01383187f, 0.05349831f, 0.12339348f, 0.05504991f, 0.07529119f, 
    -0.09312072f, -0.00871675f, 0.00389511f, -0.07953146f, -0.23766336f, 0.04979778f, 0.03728725f, -0.05384208f, 
    -0.09355331f, 0.03379819f, 0.09535011f, 0.04773942f, -0.11869555f, -0.08404646f, -0.04072749f, -0.18779612f, 
    -0.08493172f, -0.02994679f, 0.09521107f, 0.17270681f, 0.01096870f, -0.21533200f, 0.11295012f, -0.03701265f, 
    -0.11482941f, -0.01964717f, 0.05405391f, 0.03958224f, -0.05266554f, -0.12926967f, -0.03588602f, 0.18916714f, 
    0.04893800f, 0.22973397f, 0.07940815f, 0.20947018f, -0.03263042f, 0.09159745f, 0.10140266f, 0.10720556f, 
    0.00442956f, 0.07125570f, -0.04400674f, 0.11181446f, -0.03554586f, 0.11628576f, 0.00748415f, 0.04499697f, 
    0.04623504f, 0.44237375f, 0.09434761f, 0.37028879f, 0.17782789f, 0.18604223f, -0.02278591f, -0.05922123f, 
    0.12359012f, 0.12090857f, -0.04356312f, 0.11906511f, 0.02196918f, -0.04795237f, -0.07495871f, -0.03504137f, 
    -0.01689815f, 0.08841368f, 0.06443750f, -0.23299539f, 0.07304425f, 0.04496194f, -0.06909737f, 0.11616234f, 
    -0.02355947f, 0.01270135f, 0.10206998f, 0.05428512f, -0.15800077f, 0.22163182f, -0.03433969f, 0.03662556f, 
    0.05984662f, -0.11138142f, -0.15278471f, -0.03562762f, 0.02252645f, -0.31097859f, -0.14310513f, 0.02800343f, 
    0.08046364f, 0.00066645f, -0.04949511f, 0.00323516f, -0.06045752f, -0.08290238f, 0.08689328f, -0.15395540f, 
    0.14602077f, -0.15964776f, 0.05411680f, -0.04405789f, -0.09304990f, -0.08734199f, -0.18646489f, -0.01692617f, 
    -0.18429279f, -0.10042588f, 0.06423970f, 0.01633960f, -0.12802544f, 0.06676082f, -0.10721918f, -0.07406328f, 
    0.05641484f, -0.34738359f, -0.07450484f, 0.02652512f, 0.00727944f, -0.05778391f, -0.23138326f, 0.23244692f, 
    -0.09404079f, -0.11720739f, -0.10646115f, -0.14626150f, 0.02292867f, 0.02827399f, -0.00783895f, 0.07597967f, 
    0.07671054f, 0.12023956f, -0.03646483f, -0.02994544f, 0.07114220f, 0.05331353f, 0.01484085f, -0.07566174f, 
    0.10409818f, -0.10755424f, -0.16513158f, 0.09066968f, 0.24129756f, 0.25449809f, -0.07239140f, 0.05025649f, 
    0.07771450f, -0.03081955f, -0.07806230f, -0.12659225f, 0.35525766f, -0.24392134f, -0.34434789f, 0.06052127f, 
    0.01866398f, 0.06188621f, 0.02616978f, 0.03447270f, -0.05536066f, 0.30960336f, -0.01538140f, -0.00418577f, 
    -0.13732561f, -0.08381207f, 0.12639679f, 0.07445984f, 0.06521003f, 0.00114257f, 0.27341187f, 0.14731392f, 
    -0.08087739f, 0.05371462f, 0.05465039f, 0.02269594f, -0.00597125f, 0.04314242f, -0.06149369f, -0.02306377f, 
    0.11889849f, -0.15988855f, 0.17327568f, 0.10626594f, 0.06816113f, -0.05715130f, -0.01856090f, 0.03401674f, 
    0.11567590f, 0.04698762f, -0.00778079f, -0.06441510f, 0.05114897f, -0.12834582f, 0.24714082f, 0.12616044f, 
    0.17908257f, -0.10709864f, -0.30348176f, -0.12694801f, 0.10281755f, 0.02023770f, 0.00679541f, -0.07258400f, 
    -0.17573042f, -0.08386411f, -0.13472956f, -0.01455308f, -0.06488095f, 0.10808042f, 0.15900055f, -0.03879871f, 
    0.14511716f, -0.02762512f, -0.13012607f, -0.12553534f, 0.04995031f, -0.11080062f, 0.05582576f, 0.03514251f, 
    0.06739340f, -0.19296145f, -0.07947642f, -0.05037105f, -0.02220294f, 0.02232862f, 0.11780757f, 0.08589150f, 
    0.19135168f, 0.14726231f, -0.05204285f, -0.29510579f, -0.20115775f, 0.26929635f, 0.08480235f, 0.04383833f, 
    -0.05257234f, 0.00764268f, -0.00460172f, 0.12112503f, 0.04793280f, 0.13710387f, -0.03434943f, -0.22470386f, 
    0.01226811f, 0.14891514f, 0.15700218f, 0.01653530f, -0.05848742f, -0.20789589f, -0.17092025f, -0.04633022f, 
    0.14345412f, -0.41479409f, -0.03931251f, 0.02545489f, 0.08243180f, -0.01614712f, 0.07461835f, -0.11941107f, 
    0.23012340f, 0.12628986f, 0.10814241f, -0.04369576f, -0.08704136f, 0.08494080f, 0.11270268f, 0.11999539f, 
    0.03592515f, -0.07072912f, -0.00260438f, -0.09483241f, 0.10543368f, 0.27786094f, -0.02116172f, 0.14264655f, 
    0.23267296f, 0.09990779f, -0.07505785f, -0.16116801f, 0.02084904f, -0.11505613f, 0.09476893f, 0.06262826f, 
    -0.18557799f, 0.15652236f, -0.07738922f, 0.19228773f, 0.08380964f, -0.03503111f, -0.15067405f, -0.08267474f, 
    -0.02537018f, 0.02997708f, 0.24914801f, 0.17552266f, 0.02644009f, 0.02384782f, 0.07365023f, 0.09641203f, 
    -0.09876508f, -0.10185256f, -0.03178483f, -0.06502812f, 0.07763891f, -0.32220495f, -0.05813418f, 0.09477444f, 
    0.03316348f, 0.04630447f, -0.11186586f, -0.09307429f, 0.04890154f, 0.00814395f, 0.19953051f, 0.26761094f, 
    0.15209910f, -0.17283122f, -0.16020396f, 0.12385020f, 0.00804850f, -0.10627781f, 0.00654939f, -0.21464868f, 
    0.13469529f, -0.09761493f, 0.15583797f, 0.16252469f, 0.06442919f, -0.05770679f, 0.01689620f, -0.00139764f, 
    -0.04291626f, 0.01706350f, 0.00205354f, 0.03796351f, 0.02349940f, -0.06932122f, -0.02892975f, -0.00795668f, 
    0.02478359f, 0.32683843f, -0.18208942f, -0.17356151f, 0.17790928f, 0.00075609f, 0.19690134f, -0.00021770f, 
    -0.14178553f, -0.07952432f, 0.10448398f, 0.14970514f, 0.16252497f, -0.06196781f, -0.03549175f, 0.00667681f, 
    0.19641399f, -0.00443375f, -0.04775004f, -0.10133397f, -0.06170113f, 0.23614371f, -0.13255335f, -0.09142620f, 
    -0.06520058f, 0.15955350f, -0.11345366f, -0.13448359f, 0.18362716f, 0.30206123f, 0.26315537f, -0.07873302f, 
    0.04967243f, 0.09314413f, -0.10683590f, 0.12439371f, 0.06949992f, -0.17734373f, -0.25936800f, 0.02952903f, 
    0.06110482f, 0.01585861f, 0.10148165f, -0.11402719f, -0.17337129f, -0.19721651f, 0.07094025f, -0.00074008f, 
    -0.07650995f, -0.02586174f, 0.10764369f, 0.02685411f, 0.03738961f, 0.02385769f, 0.08143440f, 0.28127983f, 
    -0.17678593f, -0.08341400f, 0.11132468f, 0.07091124f, 0.18482131f, 0.06217473f, -0.11883408f, -0.11734667f, 
    0.04378346f, 0.04892055f, 0.00586747f, -0.02838121f, 0.01567749f, 0.04426965f, 0.00038392f, 0.00678027f, 
    -0.05121767f, -0.00212630f, 0.03550556f, -0.03568180f, -0.01708103f, 0.01915058f, -0.05823402f, 0.00488232f, 
    -0.04341076f, -0.02914109f, 0.00894793f, -0.05315352f, 0.00293108f, -0.03579826f, -0.03920659f, 0.01588825f, 
    0.00305473f, -0.00603148f, -0.00456744f, 0.01979507f, -0.00612150f, -0.04849812f, 0.05188733f, -0.06110388f, 
    -0.06069530f, -0.04746063f, 0.05364573f, -0.00638346f, 0.00657567f, 0.04341610f, -0.05530602f, 0.00274747f, 
    0.02424705f, 0.03268899f, -0.03379088f, -0.01588925f, -0.04618409f, 0.03148429f, 0.00320101f, 0.04815836f, 
    -0.05242974f, 0.04297633f, 0.00172863f, 0.01059202f, 0.04718949f, -0.04243925f, 0.05058987f, -0.05388675f, 
    -0.05259216f, -0.02475265f, 0.04818775f, -0.02965524f, -0.04453433f, 0.01050890f, 0.04665825f, -0.03723310f, 
    0.01609342f, -0.05961027f, -0.03269948f, -0.04832363f, -0.04622948f, 0.05379215f, 0.02307019f, 0.01435571f, 
    0.00757342f, -0.05977805f, -0.05817022f, -0.02881321f, -0.02080412f, -0.00722052f, 0.00586144f, 0.01616168f, 
    -0.03757348f, 0.03718670f, 0.04244841f, 0.00151641f, 0.04648410f, -0.04565800f, -0.05357812f, 0.05583853f, 
    -0.00745809f, -0.04340338f, -0.03058514f, -0.04788849f, -0.00469267f, 0.03720489f, -0.05213920f, 0.00659437f, 
    -0.03250153f, -0.04947737f, 0.01039495f, 0.05366554f, -0.05139895f, 0.02039780f, -0.04032401f, -0.01344581f, 
    0.03439593f, 0.02687382f, 0.02506873f, -0.03453236f, 0.02229267f, 0.01277330f, -0.05412690f, -0.03042480f, 
    0.02700072f, -0.00855807f, -0.02259884f, -0.03266181f, -0.01865132f, -0.05579213f, -0.01074720f, -0.00658220f, 
    -0.00971792f, -0.05713679f, -0.05330584f, -0.04532836f, 0.01410239f, 0.02046261f, -0.04574601f, 0.03479959f, 
    -0.03427558f, 0.03693311f, 0.02135579f, 0.00179872f, -0.04613910f, -0.05277328f, 0.04598770f, 0.00433481f, 
    -0.04484577f, -0.00772188f, 0.04010048f, 0.00311303f, -0.04461834f, 0.00170431f, -0.04844283f, 0.00433605f, 
    0.03706457f, -0.05532556f, -0.05429486f, -0.01391293f, -0.05296147f, -0.04211060f, 0.02818935f, -0.05503419f, 
    -0.03188113f, -0.02406823f, 0.00544147f, -0.02022463f, -0.04518960f, -0.02330426f, -0.04836058f, 0.04599697f, 
    -0.03098967f, -0.00178069f, -0.05025261f, -0.03925490f, -0.05756608f, -0.06122527f, -0.00747834f, 0.02866663f, 
    0.02030754f, 0.03739239f, 0.03398735f, -0.05359088f, -0.02061071f, 0.02544163f, 0.02906535f, 0.01712516f, 
    -0.00555554f, 0.03538711f, 0.03378832f, 0.03253904f, -0.05581132f, 0.01580272f, -0.04204146f, 0.04016267f, 
    -0.05642967f, 0.00337478f, -0.04244707f, -0.05665860f, 0.05011464f, -0.05230820f, 0.02050391f, -0.05844824f, 
    0.02487168f, -0.03538993f, -0.01648809f, -0.02173321f, -0.01857797f, -0.02506358f, -0.04789509f, 0.02773883f, 
    -0.01595811f, -0.04570869f, 0.03705906f, -0.04744366f, 0.04877248f, 0.05397085f, 0.00121374f, -0.06190666f, 
    -0.02071681f, 0.01270780f, 0.02004995f, -0.03707134f, 0.00932748f, -0.06116972f, -0.04211217f, -0.02805961f, 
    0.00305592f, 0.01723183f, -0.05515351f, 0.01442874f, 0.04645004f, -0.01496124f, 0.03349005f, 0.03609778f, 
    0.02483899f, 0.02076992f, -0.02275903f, 0.01630741f, 0.05356378f, -0.01613531f, -0.03664654f, 0.00222561f, 
    -0.01367436f, 0.01937925f, 0.01091143f, -0.01545964f, -0.01476807f, -0.01926526f, 0.04445278f, -0.00152057f, 
    0.01531862f, -0.02499076f, 0.01058530f, 0.01086583f, -0.00586656f, -0.00940731f, 0.00358641f, 0.00626976f, 
    0.00388044f, -0.05452619f, 0.01610073f, -0.02012176f, 0.01398589f, -0.04828173f, 0.05635425f, -0.02101399f, 
    -0.02524697f, -0.05755736f, -0.01280274f, -0.01271382f, -0.04112610f, -0.01766687f, -0.01964365f, 0.00175950f, 
    0.03140504f, 0.04306860f, -0.00074008f, -0.05347879f, -0.03483053f, 0.04725414f, 0.01370245f, 0.03521902f, 
    -0.03380040f, 0.03970847f, -0.02206949f, 0.00040762f, -0.00795368f, -0.01911463f, -0.02854178f, 0.04609100f, 
    0.00412546f, -0.02730898f, 0.04725612f, 0.00275674f, 0.04340034f, -0.04170256f, 0.02399381f, 0.03155880f, 
    -0.01141712f, -0.03823947f, 0.03368908f, -0.02922048f, -0.03657053f, -0.03538455f, -0.02583201f, -0.05321626f, 
    -0.03463230f, -0.00431261f, 0.00971586f, -0.05398763f, -0.03416996f, 0.02437674f, 0.00221447f, -0.02994777f, 
    -0.00987936f, 0.04250434f, 0.00282643f, 0.01052378f, -0.05877933f, -0.00084658f, 0.04548122f, -0.03470643f, 
    0.02517249f, -0.04657837f, -0.02729892f, 0.02808697f, -0.02494735f, -0.02072618f, -0.03292876f, 0.04356460f, 
    -0.01105111f, -0.04189854f, -0.03480946f, -0.03658127f, -0.03709278f, -0.05748210f, -0.02328483f, 0.01998149f, 
    -0.01155483f, -0.00303981f, -0.00023372f, -0.05280444f, -0.05227912f, -0.03629634f, -0.03702543f, 0.02630275f, 
    0.02942838f, -0.00383827f, -0.04974060f, 0.05217367f, 0.04586293f, -0.02521334f, 0.01662763f, -0.02261995f, 
    -0.05148418f, -0.03759861f, 0.02082996f, -0.01693763f, -0.00552154f, -0.02003030f, -0.00736767f, 0.03895081f, 
    -0.05395814f, 0.02551408f, -0.01840431f, -0.00192901f, -0.04050857f, 0.01272928f, 0.00435664f, 0.04734360f, 
    -0.02748222f, -0.03228531f, 0.00814817f, -0.05399729f, 0.02119883f, 0.05114819f, -0.03721816f, 0.05504395f, 
    -0.00697441f, 0.05263001f, -0.00634753f, 0.00079993f, 0.00263658f, -0.00147156f, 0.02910651f, -0.00625483f, 
    0.04481441f, -0.00133976f, -0.05365958f, 0.02251168f, 0.01250803f, 0.00207949f, -0.04263805f, -0.02639722f, 
    -0.05731342f, 0.00513779f, -0.02089855f, -0.00878745f, 0.04311048f, -0.00770143f, -0.04170784f, -0.02960370f, 
    -0.05667112f, 0.02454328f, -0.03783227f, -0.05208991f, 0.02977107f, -0.03860255f, 0.02801027f, 0.04410211f, 
    0.01762541f, 0.01013568f, 0.00072741f, 0.02343213f, 0.03484097f, -0.01386594f, -0.00425690f, -0.01109243f, 
    -0.02211884f, 0.02331448f, -0.04369108f, -0.02946455f, 0.01683972f, -0.03054839f, 0.02441766f, 0.00559320f, 
    0.03987048f, -0.02170451f, -0.00653174f, 0.00973285f, -0.02257011f, 0.04268112f, -0.03519337f, -0.05628191f, 
    -0.05671193f, 0.02961206f, -0.00904940f, 0.02029905f, -0.00134477f, -0.01917426f, 0.04665492f, -0.02029275f, 
    -0.04988814f, -0.05001385f, 0.04329863f, 0.04817809f, -0.04863422f, 0.00460430f, 0.03143502f, 0.02295907f, 
    -0.05184898f, 0.04657489f, 0.02972821f, -0.04151888f, 0.02485584f, 0.03210509f, 0.00070498f, 0.01535357f, 
    -0.00466657f, 0.02507003f, -0.02334397f, 0.00190891f, -0.01609197f, -0.02151234f, 0.01131884f, -0.03709724f, 
    -0.03088109f, -0.04383364f, 0.04463789f, -0.00788659f, -0.02595707f, -0.01829010f, 0.02358248f, -0.01272817f, 
    -0.00196178f, -0.02893359f, 0.05226843f, 0.01508154f, -0.05856589f, -0.03514091f, -0.04597882f, 0.03719361f, 
    0.03592780f, 0.01173365f, 0.03360542f, 0.02684164f, -0.01915559f, 0.02618777f, 0.02634248f, -0.01935966f, 
    -0.02500424f, 0.03492250f, 0.05037480f, -0.04956058f, -0.01689610f, -0.03877781f, 0.05439791f, 0.00294512f, 
    -0.05588549f, -0.04344103f, -0.00952023f, 0.01809200f, 0.00105380f, -0.05129773f, -0.02807694f, 0.04112629f, 
    0.00029019f, -0.03417359f, -0.02670546f, -0.04541572f, 0.01640175f, 0.05730077f, -0.00161328f, 0.02735574f, 
    0.01689708f, -0.01332325f, -0.04308433f, -0.02828745f, 0.01013902f, 0.04278658f, 0.01069132f, -0.03100489f, 
    0.00843840f, -0.02531623f, 0.05178767f, 0.04331220f, -0.02493321f, -0.03252666f, -0.00014116f, -0.04041073f, 
    0.00133039f, 0.02579784f, 0.01690167f, -0.04795404f, 0.02636955f, -0.03573593f, 0.02949568f, 0.05485517f, 
    0.05273139f, -0.04156613f, 0.03943693f, 0.05231268f, 0.05023672f, -0.00671452f, -0.01799629f, 0.00009332f, 
    0.01031055f, 0.00913719f, -0.03241861f, -0.00923388f, 0.03937545f, -0.02297220f, 0.01879036f, -0.04260790f, 
    0.04602657f, -0.00550559f, 0.05641788f, -0.01677921f, -0.02104791f, -0.05197671f, -0.04777825f, -0.05497187f, 
    -0.05619422f, -0.03000971f, -0.04916768f, 0.01500433f, -0.00312175f, 0.04288155f, -0.01907508f, 0.01780855f, 
    0.00091995f, -0.02481824f, 0.02732006f, -0.03221083f, -0.05314836f, -0.05737287f, -0.00595668f, 0.00330344f, 
    0.00276754f, -0.04461689f, 0.05190459f, -0.04844126f, 0.01520047f, -0.03340480f, 0.00067592f, -0.03024728f, 
    0.30772865f, 0.01439918f, 0.33603394f, 0.19969659f, 0.03469121f, -0.05880267f, -0.05186814f, 0.04345673f, 
    0.17534024f, -0.41258895f, 0.25462613f, 0.01877417f, 0.10501918f, -0.09708299f, -0.09552783f, 0.08140694f, 
    -0.01843844f, -0.14251399f, -0.39370808f, -0.15832376f, 0.37142429f, 0.00377064f, 0.06283919f, 0.09192082f, 
    -0.04141463f, -0.10638892f, 0.11444352f, 0.01174688f, -0.11510748f, -0.01881780f, 0.06674423f, 0.10591008f, 
    0.10886519f, -0.00211376f, 0.00982857f, -0.03456206f, -0.13663466f, -0.05327332f, 0.10969050f, 0.02394283f, 
    0.08272001f, 0.00696796f, -0.02211004f, -0.00370435f, 0.13285337f, 0.17723103f, -0.14308278f, 0.14373527f, 
    -0.07702385f, 0.09652837f, 0.01758960f, -0.02877106f, -0.00094943f, 0.05013274f, 0.20513795f, 0.26763290f, 
    -0.29527673f, 0.03855979f, 0.02656423f, 0.04005371f, 0.02163158f, -0.05460730f, -0.04977719f, -0.12386388f, 
    -0.06771243f, -0.01211967f, 0.07017709f, 0.12169789f, -0.03050044f, 0.01395061f, -0.05931880f, 0.10669358f, 
    -0.41297850f, 0.14088917f, -0.26068494f, 0.05133647f, 0.03305246f, -0.01752581f, -0.11236033f, 0.01849042f, 
    0.02709067f, 0.17252836f, -0.37346914f, 0.08623102f, -0.09859435f, -0.14811568f, -0.06587398f, 0.06223705f, 
    -0.00822187f, 0.11634551f, -0.24407123f, 0.07312440f, -0.06659053f, -0.10302569f, 0.05167428f, 0.00817729f, 
    -0.04995098f, -0.05143571f, 0.10568395f, 0.11021160f, 0.05460368f, 0.01052720f, 0.11040814f, 0.09813918f, 
    -0.01403381f, 0.00724547f, 0.06845549f, 0.00985286f, 0.27154443f, -0.01245994f, -0.09320161f, -0.06661081f, 
    -0.15208966f, 0.07537244f, 0.08466795f, -0.01779487f, 0.01926735f, -0.05271844f, 0.05778439f, -0.08033031f, 
    -0.07313956f, 0.02176502f, -0.08059981f, -0.04190509f, 0.02792007f, 0.01358032f, -0.05532453f, -0.25709483f, 
    0.16076577f, 0.07099736f, -0.03992763f, -0.00740337f, -0.15891026f, -0.03540323f, 0.04499700f, 0.07723221f, 
    -0.15145037f, 0.10647094f, -0.08039888f, -0.02096637f, -0.02357719f, -0.08078007f, 0.12876205f, 0.02335245f, 
    0.19580373f, 0.18203217f, -0.01327356f, 0.00472209f, 0.11262166f, -0.04628171f, 0.09295316f, 0.10672377f, 
    0.04612208f, -0.12602825f, -0.15058622f, -0.28971824f, -0.03943063f, 0.05943560f, 0.11484969f, 0.03348006f, 
    0.06432834f, 0.12954339f, -0.60940444f, -0.01427437f, 0.17365830f, 0.07354742f, -0.08183500f, -0.06200533f, 
    0.03936114f, -0.01773532f, 0.03223098f, -0.36515796f, 0.04818571f, 0.12333261f, 0.03344286f, -0.01497364f, 
    -0.00846514f, 0.10212872f, -0.12162727f, 0.01319622f, -0.67466253f, 0.07158059f, 0.04449018f, 0.04208294f, 
    0.11124752f, 0.06130703f, -0.07391554f, -0.12275474f, 0.00780847f, -0.16589780f, -0.04412388f, -0.05035543f, 
    0.01248129f, -0.05366312f, -0.11969020f, -0.04349862f, 0.06256348f, -0.16419663f, -0.30703461f, 0.09705251f, 
    -0.34798786f, 0.17970994f, 0.01085466f, 0.02728099f, -0.07519908f, -0.04325040f, 0.03924752f, -0.23243736f, 
    -0.13883503f, 0.11072049f, 0.18118179f, -0.12506139f, 0.01131665f, -0.07369120f, -0.04018636f, 0.07056899f, 
    -0.12122230f, 0.16813223f, -0.18641230f, 0.08024763f, 0.05282657f, -0.03664461f, -0.07771987f, 0.04913738f, 
    0.11033513f, -0.05159926f, -0.38504305f, 0.10561416f, 0.03446483f, -0.10864210f, 0.06441168f, 0.08127444f, 
    -0.04225434f, 0.01897855f, -0.18367684f, 0.20694330f, -0.14690475f, -0.00114708f, 0.05677262f, 0.02219920f, 
    -0.07430562f, 0.12909012f, -0.07263252f, -0.03197355f, 0.23230574f, 0.26355767f, 0.02151471f, -0.08760814f, 
    -0.02079237f, -0.05830396f, -0.05902322f, -0.05191540f, -0.17827101f, 0.15014274f, -0.01747235f, -0.01844569f, 
    0.02928431f, -0.06075682f, 0.17769863f, 0.09194628f, -0.09044385f, -0.19472025f, 0.00527151f, -0.14697281f, 
    0.06286904f, 0.12571201f, 0.14515212f, -0.11409077f, 0.17915663f, 0.02682726f, -0.02251462f, -0.08623209f, 
    -0.11113188f, 0.04064691f, 0.11578816f, 0.13299811f, -0.03628580f, -0.24030749f, 0.17023034f, 0.25402874f, 
    -0.15360723f, -0.25684673f, -0.05262645f, -0.07953700f, -0.19229138f, 0.04499197f, 0.13294442f, 0.07820643f, 
    -0.08564131f, 0.09392405f, -0.07490154f, -0.10383117f, -0.07566983f, -0.07980242f, -0.05140912f, 0.17985439f, 
    -0.04361121f, -0.02828410f, 0.04377870f, -0.00190182f, -0.06651017f, 0.00777342f, -0.11073672f, 0.12615943f, 
    0.00286458f, 0.01618810f, 0.08889358f, 0.06592233f, 0.04202353f, 0.00678304f, 0.07944980f, -0.07496691f, 
    0.04889469f, -0.07671287f, -0.00916858f, -0.14479154f, -0.11324751f, 0.02229193f, -0.05510827f, 0.11304593f, 
    -0.04929883f, -0.00824784f, 0.13562360f, -0.09545878f, 0.09712300f, 0.00336393f, -0.05215750f, 0.05353735f, 
    0.14557007f, 0.01332573f, -0.10577963f, 0.00116915f, 0.05183779f, -0.25441170f, -0.14068739f, 0.20676745f, 
    0.03036332f, 0.16829674f, -0.04571258f, -0.13008898f, 0.00263508f, 0.00801313f, 0.11460045f, 0.14995861f, 
    0.11207447f, 0.20757119f, 0.04815554f, -0.06866946f, -0.20208812f, 0.01171517f, 0.18804775f, 0.32790279f, 
    0.07886963f, 0.07758052f, 0.01831320f, -0.17229135f, -0.07688852f, 0.07815917f, 0.02610900f, 0.06156717f, 
    0.10477382f, -0.00291281f, 0.28122467f, -0.02986852f, -0.09697529f, -0.12964141f, 0.16242927f, -0.05663412f, 
    -0.07682605f, -0.05508083f, 0.08768778f, -0.28163284f, -0.03011861f, -0.08448631f, 0.02739834f, 0.12790957f, 
    0.14977668f, 0.25840774f, -0.01422956f, 0.00186926f, -0.16787095f, -0.02260639f, 0.02348203f, -0.02327419f, 
    -0.00064691f, -0.07426123f, -0.03121211f, 0.14912432f, -0.01699835f, -0.02393811f, -0.23992895f, -0.06000615f, 
    -0.15569688f, -0.04351552f, -0.01206544f, -0.00254861f, -0.32370737f, -0.22036889f, -0.09437604f, 0.13731527f, 
    0.01968875f, -0.00687950f, 0.21527033f, -0.08410018f, -0.06398278f, -0.16936271f, 0.13042860f, 0.21611385f, 
    0.09575941f, 0.02079426f, 0.04909148f, 0.07674880f, -0.03146368f, 0.06272601f, 0.21438414f, 0.04071641f, 
    -0.11890001f, -0.02777370f, 0.00329990f, -0.05479915f, 0.15011536f, 0.13578817f, -0.00288899f, 0.18053049f, 
    0.01256955f, 0.05447244f, 0.11579664f, -0.11377753f, -0.07658824f, -0.14602919f, 0.26506135f, -0.03356181f, 
    -0.55579066f, -0.15844703f, -0.11467303f, 0.21361402f, 0.05473858f, 0.17431086f, 0.09213211f, 0.00532216f, 
    0.03722867f, 0.19469987f, -0.06146546f, -0.08218201f, 0.08872659f, -0.09276713f, -0.03495698f, 0.04965258f, 
    0.02578051f, 0.02275707f, 0.05736387f, 0.09174652f, -0.02989597f, 0.03723450f, -0.01770928f, 0.07123020f, 
    -0.01544866f, 0.13596772f, 0.11182503f, 0.25708991f, -0.06828237f, 0.06922544f, 0.12900010f, -0.09680789f, 
    0.07274578f, 0.06830966f, -0.04613269f, -0.10342447f, 0.00145050f, 0.02254567f, -0.01672279f, 0.02814108f, 
    0.01696815f, 0.02720067f, 0.03001237f, 0.01806975f, 0.06243614f, 0.10175120f, -0.00388972f, -0.00159580f, 
    0.01778085f, -0.07826959f, 0.03985378f, 0.09813389f, 0.01911197f, 0.11310952f, -0.45577690f, -0.13880481f, 
    0.04322803f, 0.12898532f, 0.09111223f, 0.00573141f, -0.01155562f, 0.14798853f, 0.00710529f, 0.12800822f, 
    0.01515018f, -0.06471806f, 0.13462599f, 0.02039071f, 0.08430162f, -0.10423406f, 0.13606989f, -0.10808891f, 
    -0.21930306f, -0.02838151f, -0.09321181f, 0.10640592f, 0.09672528f, -0.04885599f, -0.01045462f, 0.01628617f, 
    -0.02170205f, 0.00737796f, -0.02897857f, 0.02898568f, 0.19067931f, -0.01987820f, 0.03117801f, 0.01742548f, 
    0.03077593f, -0.15339726f, -0.30967382f, 0.02183901f, -0.07515147f, 0.12359140f, 0.04846362f, -0.03856861f, 
    -0.01570371f, 0.02820656f, 0.02552813f, -0.24800949f, -0.24742591f, -0.27346978f, 0.09955576f, -0.02236623f, 
    0.01814379f, -0.18992192f, 0.17033374f, -0.02788899f, -0.33094120f, -0.20103854f, -0.07299981f, 0.07020817f, 
    0.12487728f, 0.05424354f, -0.00675241f, -0.00956185f, -0.04574176f, 0.04679514f, -0.04621780f, -0.05789807f, 
    0.19926327f, 0.04406504f, 0.08927978f, -0.03029759f, 0.11110146f, -0.02139604f, -0.14245531f, -0.01543586f, 
    0.05525021f, -0.04333770f, 0.06354557f, 0.02785381f, 0.16994795f, -0.20884639f, 0.06878591f, 0.18167186f, 
    -0.05636564f, -0.10527527f, -0.08453294f, -0.01049239f, -0.07318489f, 0.02533435f, 0.07618599f, -0.03725152f, 
    0.11767924f, -0.13244985f, -0.02182921f, -0.21584786f, -0.02416247f, 0.12275595f, -0.01808308f, -0.06742694f, 
    -0.02474237f, 0.11883824f, -0.10718501f, -0.22715491f, 0.05273024f, 0.06655294f, 0.01666512f, -0.09414383f, 
    -0.03644115f, 0.12188055f, 0.22748469f, 0.02634150f, 0.18032311f, -0.25851491f, -0.15057069f, 0.14876285f, 
    0.13582787f, -0.05721355f, -0.05707545f, -0.37799004f, 0.04901766f, -0.02240702f, 0.12276854f, -0.04773592f, 
    0.04816002f, 0.00506826f, -0.03088514f, 0.10384002f, 0.07318999f, -0.10172279f, -0.10177486f, 0.00806713f, 
    0.00047835f, -0.01753404f, -0.10126402f, 0.03571265f, 0.10052609f, -0.39506760f, 0.23253243f, -0.13937351f, 
    0.02075421f, -0.15387887f, 0.09105703f, 0.00003492f, 0.04765433f, 0.13891466f, 0.07475555f, 0.24468718f, 
    0.14011879f, 0.06107364f, 0.06603745f, -0.06829889f, -0.15837952f, -0.03922321f, 0.04286676f, 0.25888664f, 
    -0.02797409f, -0.16134238f, -0.17517133f, -0.04005408f, -0.08000742f, -0.05852045f, -0.07969733f, 0.01434147f, 
    0.22658934f, -0.00787252f, -0.46571863f, -0.11241916f, -0.06262782f, 0.07039187f, -0.26097476f, -0.10327540f, 
    0.01776366f, 0.17433242f, -0.23201008f, 0.06904385f, 0.00407592f, 0.03869425f, 0.02737069f, 0.02449581f, 
    -0.11473954f, 0.06113679f, 0.50779194f, -0.10627480f, -0.19109702f, -0.16117457f, 0.04828281f, 0.10286526f, 
    -0.12707780f, 0.07659113f, -0.04229977f, -0.16759169f, -0.02898534f, -0.01949280f, 0.09085660f, -0.00350634f, 
    -0.04453957f, 0.02049047f, 0.01846513f, 0.06975033f, 0.03991943f, -0.06170645f, 0.23208806f, -0.04427760f, 
    -0.21121220f, -0.10945220f, -0.01878827f, 0.04754110f, 0.07244395f, -0.03154851f, 0.20674932f, 0.11395929f, 
    0.16026042f, 0.11480039f, 0.01576537f, -0.04288263f, 0.06328005f, 0.02050420f, 0.59819758f, 0.15041192f, 
    0.08357535f, -0.00521666f, -0.14393438f, -0.01303580f, 0.00934832f, 0.04166859f, -0.05286831f, -0.36812255f, 
    0.10317779f, 0.08659920f, -0.10952501f, 0.06682787f, -0.03493028f, 0.00463963f, -0.07193790f, 0.06665940f, 
    -0.28791136f, 0.09780129f, -0.07634445f, 0.13560076f, 0.04078708f, 0.15336576f, -0.17438403f, 0.09862652f, 
    -0.08831850f, 0.14897077f, 0.15786430f, 0.02244463f, -0.06156211f, -0.07731345f, -0.03095509f, -0.01263730f, 
    0.06347021f, -0.07377794f, 0.07810199f, 0.00702098f, 0.14471541f, -0.01510541f, 0.05464515f, 0.04699449f, 
    -0.16565268f, -0.04205807f, 0.10957823f, -0.34386075f, -0.12389942f, -0.13531898f, 0.05765529f, 0.03853964f, 
    0.03819960f, 0.03393905f, 0.06388697f, -0.14861622f, 0.00437333f, -0.05379671f, -0.11132371f, 0.08210501f, 
    0.05480321f, -0.11414376f, -0.07553703f, -0.10184184f, -0.04235888f, 0.17706542f, -0.20502603f, 0.06131280f, 
    -0.24900597f, 0.06034827f, -0.00556630f, -0.05429253f, 0.09721223f, -0.09363472f, -0.04664652f, 0.32156524f, 
    -0.08032867f, 0.04967235f, 0.19988154f, 0.05100438f, -0.00999345f, 0.00001902f, -0.06835888f, 0.36874220f, 
    -0.31753090f, -0.01028839f, -0.00648728f, 0.10144331f, 0.10657680f, -0.01552355f, 0.06876649f, -0.00224381f, 
    -0.00458388f, -0.13708474f, -0.03791950f, -0.05329570f, 0.16813785f, -0.00344941f, -0.01702124f, -0.04195835f, 
    0.04829015f, 0.46893075f, -0.15436059f, -0.28003499f, -0.07734692f, 0.03245267f, 0.13825548f, -0.13180044f, 
    0.05344315f, 0.05981253f, -0.15814216f, 0.20694114f, -0.07196025f, 0.03245909f, 0.01203426f, 0.07825480f, 
    0.04987424f, 0.05274762f, 0.01338757f, 0.20567131f, -0.01993559f, 0.02869416f, -0.28405648f, -0.20489293f, 
    0.20771866f, -0.06910234f, -0.00608103f, 0.04134586f, -0.32486090f, 0.17959452f, -0.08049583f, 0.08274522f, 
    0.18526351f, 0.16166735f, -0.08834091f, 0.08147669f, -0.00931095f, 0.09294745f, 0.11275693f, 0.02269330f, 
    0.02077370f, -0.08520742f, -0.15301777f, 0.09403317f, -0.05183614f, -0.08400393f, 0.21721484f, 0.16838425f, 
    -0.10431584f, 0.04151244f, 0.05533683f, 0.11722322f, -0.15828213f, -0.12510234f, -0.06042980f, 0.11061863f, 
    0.06174218f, 0.03827870f, -0.15632105f, -0.11293165f, 0.09231432f, 0.03861459f, -0.01680954f, 0.08278660f, 
    0.15493609f, 0.16899402f, -0.16241796f, -0.01081662f, 0.04947667f, -0.15147012f, -0.01149823f, -0.08375201f, 
    0.02911139f, -0.18171294f, 0.11022232f, 0.19523132f, -0.02393013f, -0.06374694f, -0.13583750f, -0.09192292f, 
    -0.07713282f, 0.01009198f, 0.00999036f, 0.07721163f, -0.00445256f, 0.10670865f, -0.08825149f, -0.01654344f, 
    0.26733875f, 0.08805821f, 0.03093294f, -0.03141987f, -0.28235975f, -0.08815683f, -0.03181593f, 0.06348190f, 
    0.00129475f, -0.00020850f, 0.08538734f, 0.11991466f, 0.07923198f, 0.17629775f, 0.10846506f, 0.01517137f, 
    0.20747474f, -0.07760938f, 0.03475039f, -0.01539891f, -0.07734983f, -0.16794428f, -0.22484656f, -0.03719011f, 
    0.07703490f, -0.01039012f, 0.08173987f, 0.03876181f, 0.08389580f, 0.04503630f, -0.10038836f, -0.00554848f, 
    0.05277298f, 0.07742807f, 0.16116337f, 0.05976877f, -0.16149791f, 0.03335623f, 0.00593149f, -0.00349161f, 
    0.11152464f, -0.04331749f, 0.03764639f, -0.17463082f, -0.19381548f, -0.06946235f, -0.15600291f, 0.06388486f, 
    0.21326864f, 0.02963615f, 0.29848009f, 0.01655840f, -0.09610176f, 0.08907927f, -0.06272539f, -0.15690129f, 
    0.14811720f, 0.11234219f, -0.19661978f, 0.14228697f, -0.01392748f, 0.12941617f, -0.19739732f, -0.25798115f, 
    0.06586646f, 0.09715982f, -0.02237639f, -0.05687368f, 0.16319109f, -0.00455662f, -0.12095875f, 0.04944186f, 
    -0.09833789f, -0.05129841f, 0.20447081f, 0.12689871f, 0.08725571f, -0.11109453f, -0.00532378f, 0.06887694f, 
    0.04876749f, -0.09713863f, -0.08365054f, 0.15312475f, 0.02171325f, -0.06247077f, 0.04336113f, -0.12981828f, 
    -0.00160111f, -0.06889378f, 0.09751559f, 0.11895818f, -0.08274382f, -0.01699620f, 0.04597710f, -0.19403093f, 
    0.15642676f, 0.07934767f, -0.03408849f, 0.02407428f, 0.02341290f, 0.06304342f, 0.03866367f, 0.16121686f, 
    0.11940090f, 0.02289215f, -0.21280691f, -0.22788450f, -0.00664757f, 0.04476850f, -0.00772398f, 0.21397886f, 
    0.11930253f, -0.21240972f, 0.14708987f, 0.10926807f, -0.04088953f, -0.10693085f, -0.01624841f, -0.05540000f, 
    -0.31119275f, -0.48372337f, -0.22678471f, -0.14809300f, -0.12612920f, 0.01462870f, -0.04671338f, -0.12145407f, 
    -0.07795217f, 0.22657061f, -0.12786664f, 0.15708853f, 0.01162140f, -0.15024517f, -0.09377153f, -0.03039662f, 
    0.00734126f, 0.04185438f, 0.02807035f, -0.01378850f, -0.09762882f, -0.20736916f, 0.05470941f, -0.06505869f, 
    0.14288141f, -0.14046840f, 0.07598038f, 0.00938147f, -0.05566341f, -0.11355358f, -0.10067556f, -0.04580213f, 
    0.00580621f, -0.12155899f, 0.06291527f, 0.10171995f, 0.26618493f, -0.01479940f, 0.01962600f, -0.00889102f, 
    -0.03456362f, 0.05911934f, -0.19710386f, 0.03190113f, 0.00658991f, 0.37793636f, -0.16927843f, -0.16788614f, 
    -0.02591106f, -0.06470097f, 0.00016461f, 0.04770315f, -0.08429518f, 0.10508355f, -0.10718871f, -0.27040586f, 
    -0.04289439f, -0.04383640f, 0.08238272f, 0.06160652f, -0.12161171f, -0.00852189f, 0.11044534f, 0.09437246f, 
    0.08446705f, 0.04227889f, -0.01693532f, 0.03235108f, -0.24855006f, 0.05218592f, 0.01821497f, 0.11996073f, 
    0.39899746f, -0.54710144f, 0.02137948f, -0.10689804f, -0.18210830f, 0.08754406f, -0.09207428f, 0.10352445f, 
    -0.03875355f, -0.02754486f, 0.21326183f, 0.11182734f, 0.07553551f, 0.14589055f, 0.21769910f, 0.13059972f, 
    0.00339040f, -0.06073118f, -0.36114237f, -0.36518279f, 0.00826181f, 0.03656238f, 0.29725301f, 0.01096341f, 
    0.03170018f, -0.09703065f, -0.15190732f, 0.32155481f, -0.16525877f, 0.06748331f, -0.20331237f, 0.03574845f, 
    0.01887527f, -0.18161020f, 0.07092866f, 0.07898912f, -0.47075796f, -0.58216470f, 0.17723058f, -0.02982131f, 
    0.24458057f, 0.09906557f, -0.01281612f, -0.02112307f, -0.04428710f, -0.04908130f, 0.14981762f, 0.04922400f, 
    0.05845403f, -0.01546109f, 0.18970148f, 0.01987987f, -0.04064844f, 0.03085104f, 0.15159933f, 0.09463508f, 
    0.05395785f, -0.08695725f, 0.02080296f, -0.05323982f, -0.03927311f, -0.05879921f, -0.00506603f, 0.12914045f, 
    -0.13352568f, 0.08418195f, -0.04585110f, -0.01340174f, -0.01932534f, 0.00055700f, 0.10475303f, 0.05017003f, 
    -0.01946622f, -0.00995359f, -0.02353600f, -0.05941432f, 0.01483994f, -0.00505036f, 0.03036853f, 0.03633266f, 
    0.03090050f, 0.04186084f, -0.01016624f, 0.03105978f, 0.05107251f, 0.00237872f, 0.05238816f, 0.01809200f, 
    -0.01805088f, -0.06114938f, -0.02010702f, 0.00903939f, 0.01092535f, -0.00636199f, -0.00479592f, -0.06309035f, 
    0.01868193f, -0.02738446f, 0.02279318f, -0.00056521f, 0.05206983f, 0.03528794f, -0.06198604f, 0.03225689f, 
    -0.06166574f, 0.02425997f, -0.02478781f, -0.05535248f, 0.00332118f, -0.04728236f, 0.02468737f, -0.03905564f, 
    0.04713568f, -0.01804089f, -0.03558828f, 0.00846498f, -0.05529896f, -0.06243417f, 0.04267167f, -0.06427547f, 
    0.00024515f, -0.00332820f, 0.02685197f, -0.01864095f, 0.04508736f, 0.05031576f, 0.00624159f, -0.02052398f, 
    0.02732916f, -0.00414530f, -0.03002118f, -0.04641068f, 0.01628192f, -0.02749584f, -0.03926516f, 0.01526072f, 
    0.00827392f, -0.00449976f, 0.03088977f, 0.03183503f, -0.03015429f, -0.03818491f, -0.05801551f, 0.01788292f, 
    -0.02255419f, 0.00319634f, -0.04921031f, 0.00883373f, -0.05200244f, -0.05335774f, 0.03174794f, -0.03193365f, 
    -0.03936218f, -0.05016210f, 0.00640326f, -0.00482461f, -0.03011581f, -0.02680362f, -0.01317173f, 0.01840304f, 
    -0.00182831f, 0.02673463f, 0.03558813f, -0.05133116f, -0.03334161f, 0.03516397f, -0.03289359f, -0.03297804f, 
    -0.06163970f, -0.03966517f, -0.00137135f, -0.00083189f, -0.05021236f, -0.03481783f, -0.02702339f, -0.03196316f, 
    0.04733458f, 0.02276537f, 0.02457028f, -0.05631993f, -0.03890603f, -0.04798441f, 0.03163956f, 0.02996538f, 
    -0.01887844f, -0.06343242f, -0.05313334f, -0.01135681f, 0.00948523f, -0.03019964f, -0.02919716f, -0.02859862f, 
    0.00944395f, -0.06420338f, 0.04951546f, -0.05632746f, -0.03487782f, -0.04095906f, -0.04402835f, 0.01956075f, 
    0.01220817f, -0.03811220f, -0.05518561f, 0.01188078f, -0.02684354f, -0.04728569f, -0.02423271f, 0.01657370f, 
    -0.02043758f, -0.01586946f, 0.03321696f, 0.01671054f, -0.00173685f, 0.02453366f, 0.01136772f, 0.02242236f, 
    0.01051859f, 0.01570436f, -0.00504692f, -0.03894249f, -0.00196812f, 0.05023196f, -0.00417680f, -0.04410641f, 
    0.01118943f, -0.06041941f, -0.03249300f, 0.01560359f, -0.06416546f, -0.01757657f, -0.02989425f, -0.02354527f, 
    0.01333858f, -0.03504505f, 0.00858808f, -0.04137443f, -0.00356043f, -0.01636310f, 0.04397083f, 0.00368500f, 
    0.05166936f, -0.04701469f, -0.00677000f, -0.00359211f, -0.04979142f, 0.04806012f, 0.01945726f, 0.01883008f, 
    0.00003480f, 0.02184315f, -0.04914603f, 0.03086696f, -0.03649874f, -0.04040492f, 0.02022361f, -0.04047874f, 
    0.00757752f, 0.05162888f, -0.05276104f, -0.01508586f, 0.00771954f, 0.02304061f, 0.01286387f, -0.02287092f, 
    0.04996202f, 0.01247930f, -0.02571005f, 0.05193904f, -0.02127586f, -0.05559773f, -0.04209922f, -0.02044180f, 
    0.03632696f, 0.02510634f, -0.02024420f, -0.06033843f, -0.03314975f, 0.04418557f, -0.04954415f, 0.02061182f, 
    0.02123846f, 0.00732977f, -0.06129428f, -0.05279977f, -0.01047832f, -0.00756664f, 0.03826023f, 0.04405957f, 
    0.03925002f, -0.04500256f, 0.02784633f, -0.01449054f, -0.04733592f, 0.04685686f, 0.01078083f, -0.02712178f, 
    0.04472132f, -0.02280646f, -0.02670655f, -0.04765552f, -0.02135306f, 0.04085094f, -0.03840209f, -0.05090844f, 
    -0.01729888f, 0.00282648f, 0.04559949f, -0.06020031f, -0.03754475f, 0.04247979f, 0.01052818f, -0.01747750f, 
    0.00803509f, 0.02973743f, -0.04296688f, -0.05915521f, -0.01353287f, 0.01360336f, 0.00957698f, 0.01359067f, 
    0.01052125f, 0.02828199f, 0.00020764f, 0.01872830f, 0.00542571f, 0.00122075f, 0.03987737f, 0.01604506f, 
    -0.05697227f, -0.01786708f, -0.02781749f, -0.05740739f, -0.06265507f, -0.00126142f, -0.04171837f, 0.00253345f, 
    -0.02939545f, -0.01416084f, 0.02978667f, 0.00188836f, -0.02488421f, 0.04263388f, 0.03419942f, -0.05952448f, 
    0.01634715f, -0.01361525f, -0.05294783f, -0.03493698f, -0.01332185f, -0.02871468f, -0.02684580f, -0.06250962f, 
    -0.01585742f, -0.04908951f, -0.06431489f, -0.00533006f, 0.00681362f, -0.03813294f, -0.06317021f, 0.01596323f, 
    0.01873845f, -0.04124270f, -0.03741946f, 0.02422311f, -0.03967814f, -0.05812388f, -0.04513380f, -0.00986447f, 
    -0.02211093f, -0.03601327f, 0.03740646f, 0.04249037f, -0.06384594f, 0.04412936f, 0.00142874f, 0.04831731f, 
    0.03852411f, 0.03932042f, -0.02705685f, -0.02826233f, -0.04995957f, -0.04840566f, -0.04504171f, -0.04941973f, 
    0.04215111f, -0.01120173f, -0.01073700f, -0.04408069f, 0.04871663f, -0.03472586f, 0.00752546f, -0.04071958f, 
    -0.04434531f, -0.02725380f, 0.02971154f, 0.02515902f, 0.01307128f, 0.04220004f, 0.00038838f, 0.02834261f, 
    0.01185238f, 0.00620760f, -0.00907961f, -0.03516819f, -0.06468599f, 0.03298313f, 0.03633095f, -0.03961682f, 
    -0.02550198f, -0.06424623f, -0.01877230f, -0.04360149f, -0.02217541f, 0.05120766f, 0.01895270f, 0.01986950f, 
    -0.00519995f, -0.05377770f, -0.04295710f, -0.04010756f, 0.04812641f, 0.00423279f, 0.02848512f, -0.02824977f, 
    -0.02557606f, -0.00690799f, -0.06178805f, 0.04484796f, -0.03907411f, -0.02781902f, -0.01091295f, -0.04029997f, 
    -0.05208229f, 0.01631520f, 0.06023763f, 0.04388352f, -0.00137885f, -0.01430373f, 0.04283921f, 0.00087948f, 
    -0.00193247f, -0.02741307f, -0.03898423f, -0.00320876f, 0.01726621f, -0.00805355f, 0.02236780f, -0.04313047f, 
    0.04159524f, 0.02918896f, -0.05865628f, 0.05970348f, -0.00445781f, 0.01495041f, 0.05177526f, 0.00823392f, 
    -0.03983392f, -0.00501197f, -0.04015187f, 0.05882660f, 0.02142843f, -0.06457974f, -0.00554692f, -0.05480089f, 
    0.00213017f, 0.02076864f, -0.05106278f, 0.02268084f, -0.02418539f, -0.04303063f, -0.05495811f, -0.04091149f, 
    0.00534947f, 0.02826358f, 0.01793007f, -0.02953413f, 0.05152561f, -0.01408950f, 0.03870649f, -0.01003560f, 
    -0.04215330f, -0.02450084f, -0.04636137f, -0.03616751f, -0.02187545f, 0.01352630f, -0.04767542f, 0.00558619f, 
    -0.03035760f, 0.01896005f, -0.04278180f, -0.02372309f, 0.01238751f, -0.02173757f, 0.03300478f, 0.01696661f, 
    -0.05798967f, 0.04536845f, 0.04614506f, 0.03674839f, -0.00748739f, -0.01537102f, 0.01966451f, 0.05126153f, 
    -0.05611477f, 0.00965503f, 0.01742779f, -0.06651709f, -0.03450650f, 0.01784167f, -0.02019681f, 0.03287708f, 
    0.04079686f, -0.05122729f, -0.05549073f, -0.00206586f, -0.00092082f, -0.05730047f, -0.03157316f, -0.03419633f, 
    0.04264192f, -0.00518662f, -0.03151563f, -0.06375836f, 0.01274657f, -0.01572817f, -0.00817846f, 0.03513993f, 
    -0.03740446f, 0.05445847f, -0.05775766f, 0.02497890f, 0.01656666f, 0.03511012f, -0.00045891f, 0.02556948f, 
    0.01439987f, -0.02069317f, 0.00745795f, -0.00451750f, 0.01663083f, 0.02211007f, 0.01939650f, -0.01868886f, 
    -0.02585799f, -0.01640572f, -0.05127342f, 0.04912164f, -0.01058811f, -0.06412537f, -0.02717631f, 0.02563779f, 
    -0.01195600f, -0.00134051f, 0.02650329f, -0.06279515f, -0.04206681f, -0.03484209f, 0.04093039f, 0.03221976f, 
    0.01099140f, -0.03411925f, 0.01444581f, 0.00824326f, 0.01316537f, -0.00474953f, 0.00749455f, -0.00888475f, 
    -0.01970212f, 0.03313841f, 0.00386761f, -0.02258063f, 0.05028639f, -0.06408162f, 0.01621580f, -0.04004123f, 
    -0.01888358f, -0.03957000f, -0.02023920f, 0.00920359f, 0.04732837f, -0.00348512f, -0.02300261f, 0.02092739f, 
    0.04288151f, -0.01829200f, 0.00279694f, 0.00144379f, -0.01513427f, -0.05900523f, -0.04572314f, -0.02959483f, 
    -0.02572516f, -0.06416257f, 0.03619215f, 0.00381159f, -0.04868589f, -0.04928207f, -0.05461186f, 0.01430372f, 
    -0.00208572f, -0.04501175f, -0.04394666f, 0.03569632f, -0.02189879f, -0.01786168f, -0.01947507f, 0.03650364f, 
    0.02038894f, 0.02158519f, -0.01487525f, 0.00547267f, 0.03373463f, 0.06140333f, 0.01582719f, 0.00865433f, 
    -0.02185310f, -0.01903468f, 0.00432590f, 0.03287432f, 0.00621014f, 0.04871840f, 0.00662302f, -0.03601110f, 
    -0.00912500f, 0.05668007f, 0.00587661f, -0.03009195f, -0.05864588f, -0.02476750f, -0.03299389f, 0.01945433f, 
    -0.04945096f, -0.00182788f, -0.01442780f, -0.01101746f, 0.03292557f, -0.05579378f, 0.03633269f, 0.02785397f, 
    0.04472369f, -0.02730529f, -0.03734320f, -0.04144390f, -0.03813498f, 0.03333471f, -0.05911743f, -0.00822528f, 
    -0.09534395f, 0.34535912f, 0.13489962f, -0.02927793f, -0.08257969f, -0.01395060f, 0.03082584f, -0.03930645f, 
    -0.03213596f, 0.05891647f, 0.08671902f, -0.21414848f, -0.12132087f, 0.03687520f, 0.04369073f, 0.12641472f, 
    -0.04427077f, -0.11126880f, -0.08653702f, 0.08314665f, 0.20961796f, 0.05122999f, -0.06703515f, -0.05075861f, 
    -0.02755542f, 0.00161958f, 0.03200059f, -0.03725396f, 0.11222631f, -0.00452166f, 0.03039544f, 0.09069268f, 
    0.04818225f, 0.04543395f, 0.01546684f, 0.02412788f, -0.14774425f, 0.14612021f, 0.13980451f, 0.05725165f, 
    -0.04482558f, 0.13861801f, -0.01773876f, 0.03364147f, -0.04979147f, 0.00983113f, 0.23359798f, -0.03746501f, 
    0.03143951f, -0.01791348f, 0.05064328f, 0.15296651f, 0.02619287f, 0.04482202f, -0.02690991f, -0.13282517f, 
    -0.10519426f, 0.10292297f, 0.20890400f, 0.02240510f, 0.19757071f, 0.13141742f, 0.06234120f, -0.19711608f, 
    -0.21567892f, -0.05196239f, -0.06120754f, -0.05312011f, -0.16208978f, -0.02414238f, -0.03026932f, 0.18611288f, 
    -0.19577190f, -0.09156132f, -0.08344460f, 0.17240719f, 0.01785430f, 0.13777182f, 0.15815894f, 0.00915019f, 
    -0.01316801f, 0.03536018f, -0.02862506f, 0.11569327f, -0.18331936f, -0.02014957f, -0.00286950f, -0.10131695f, 
    -0.13610956f, 0.11808998f, 0.28939945f, -0.07449359f, 0.08669126f, -0.20969589f, 0.01755973f, 0.19718413f, 
    0.06156285f, 0.08778562f, 0.02992091f, -0.07194656f, 0.01477742f, -0.06268595f, -0.20799194f, -0.07816849f, 
    -0.05821445f, 0.11960118f, 0.06173353f, -0.06078935f, 0.27585089f, 0.02854681f, -0.01425915f, 0.11925802f, 
    -0.15725829f, 0.08636042f, -0.12673935f, 0.02518107f, 0.13133079f, -0.14495641f, -0.19757581f, -0.15830205f, 
    0.10062707f, 0.13136394f, -0.12313478f, -0.08769499f, -0.01208524f, -0.15943964f, 0.36181813f, 0.07923496f, 
    0.18881738f, -0.04649204f, -0.08586676f, 0.09236813f, -0.02362719f, 0.13107514f, 0.08522397f, -0.31917742f, 
    0.09566910f, 0.26931337f, -0.06531052f, 0.03309509f, -0.12946358f, 0.04835451f, 0.02400426f, -0.10486679f, 
    0.08694448f, 0.00939639f, 0.05620127f, 0.11444776f, 0.08781469f, 0.04148953f, 0.03889677f, -0.02727399f, 
    -0.03505757f, -0.10107219f, -0.26091266f, -0.20965940f, 0.05487416f, 0.07844630f, -0.11393127f, -0.00757466f, 
    -0.06500816f, 0.06716625f, -0.15425998f, 0.09416394f, -0.03511522f, 0.08407719f, 0.04121464f, -0.01085624f, 
    0.10901405f, -0.17638321f, -0.01294941f, -0.24740154f, -0.03878281f, -0.40626508f, 0.12419164f, -0.08859761f, 
    0.13669686f, 0.01809929f, -0.04425300f, 0.11553199f, -0.13070783f, 0.00683565f, -0.55285776f, 0.02632135f, 
    -0.08687313f, 0.03741890f, 0.15157266f, 0.05807997f, -0.00552376f, 0.24379399f, -0.06415559f, -0.17580572f, 
    -0.18086000f, -0.07072151f, -0.15115929f, 0.05901756f, 0.08811913f, -0.05166262f, -0.07717876f, -0.16252394f, 
    -0.25135893f, 0.07651745f, 0.13944876f, 0.03442797f, 0.01723580f, -0.04653550f, 0.15211862f, -0.34485552f, 
    0.01375429f, -0.06693407f, -0.02616745f, -0.10012300f, -0.06155818f, 0.04143767f, 0.04860894f, 0.01791109f, 
    -0.07658142f, -0.06613768f, -0.13370021f, 0.05027854f, -0.10057341f, 0.01288429f, 0.11093379f, 0.10235403f, 
    0.11580215f, -0.07842176f, 0.15069462f, 0.28730538f, -0.11317577f, -0.05002698f, -0.05184018f, -0.04531200f, 
    0.17422490f, -0.07404741f, -0.18838404f, -0.07011741f, 0.07155187f, 0.07868304f, 0.03558043f, 0.01423001f, 
    0.04020325f, -0.06022900f, -0.04384162f, -0.11303464f, 0.26215371f, -0.04730044f, 0.02275030f, -0.07523077f, 
    0.06847008f, -0.01882917f, -0.20421118f, 0.03734877f, -0.12897666f, -0.03002836f, -0.05767053f, 0.22557010f, 
    0.00977001f, 0.02750394f, 0.14751306f, -0.03861653f, -0.16961417f, 0.28583589f, 0.14160600f, 0.06866032f, 
    -0.22633336f, -0.05985440f, 0.01737364f, -0.06849764f, -0.07383631f, 0.25519857f, -0.10037612f, 0.08082558f, 
    -0.28490177f, -0.02175851f, 0.06832190f, 0.07499621f, -0.01284626f, -0.14041176f, -0.12291931f, 0.22571652f, 
    0.18363068f, 0.32491088f, -0.13242689f, -0.13044868f, 0.01900391f, -0.10736360f, 0.09887362f, 0.00929332f, 
    -0.08971895f, -0.06923970f, -0.36415437f, 0.03700063f, -0.07001536f, 0.03719944f, 0.05243783f, 0.12408564f, 
    0.04501767f, -0.13587847f, -0.09068645f, -0.15929690f, -0.01018188f, 0.06116006f, 0.01533276f, 0.01412638f, 
    0.22906496f, 0.02113240f, -0.26159665f, 0.00799545f, -0.34037286f, 0.03654204f, 0.15789717f, 0.10957544f, 
    0.00215761f, 0.25690341f, 0.01987523f, 0.12102132f, 0.07079846f, 0.11753449f, 0.15331677f, 0.18709667f, 
    0.10807014f, 0.08326840f, -0.04486559f, 0.13401212f, 0.16189219f, 0.06007301f, -0.26648960f, 0.08686055f, 
    0.00451691f, 0.14418091f, -0.00911960f, -0.02130681f, -0.01402524f, -0.02111093f, 0.15543512f, 0.01091396f, 
    0.16787183f, 0.07727896f, 0.04793589f, 0.13868502f, 0.08077642f, 0.12070462f, 0.05468333f, 0.16499229f, 
    0.00574775f, -0.16756943f, 0.04052083f, 0.09211191f, 0.08806328f, 0.03788792f, 0.03459699f, 0.05597705f, 
    0.04795946f, -0.13360159f, 0.10981998f, 0.05626784f, 0.16926306f, 0.20840880f, -0.07756289f, 0.06660321f, 
    -0.00456388f, -0.05842061f, -0.01188861f, -0.22097367f, 0.23019858f, -0.11510573f, 0.01342138f, 0.06173274f, 
    -0.00854753f, -0.32718652f, -0.40173274f, -0.14550829f, 0.05599275f, -0.05441702f, 0.01472277f, 0.06963558f, 
    -0.00255322f, 0.06636357f, 0.16700125f, -0.10294501f, -0.02487867f, 0.11051673f, -0.04992868f, -0.04511328f, 
    -0.13860932f, -0.13106909f, 0.08289180f, 0.18245941f, 0.01128866f, 0.06327134f, -0.03327577f, -0.13414939f, 
    0.01223674f, 0.03336630f, 0.11824253f, 0.05617196f, -0.23272033f, -0.10607785f, 0.21453089f, 0.09996126f, 
    0.10981718f, -0.09132274f, -0.10480431f, 0.09178137f, 0.10880624f, -0.00511725f, 0.12767613f, 0.11183088f, 
    -0.00878080f, -0.02908587f, 0.17787723f, -0.10824636f, 0.01414405f, 0.36359054f, -0.14105423f, -0.18795767f, 
    -0.02930095f, 0.11558919f, -0.05355831f, 0.11308488f, 0.00268832f, -0.01440346f, 0.04388007f, -0.40506744f, 
    -0.13665637f, -0.32016847f, 0.05742647f, 0.11788268f, 0.04258819f, 0.02657801f, 0.08610225f, -0.11239982f, 
    0.07238717f, 0.26363507f, 0.29686058f, 0.00096074f, 0.14993079f, 0.10994270f, 0.07863852f, 0.10334306f, 
    0.06196875f, 0.00618005f, -0.02310137f, -0.06779307f, 0.11269020f, 0.15999782f, 0.06584236f, 0.18832998f, 
    0.11350837f, 0.22340305f, -0.29860762f, -0.12400175f, 0.09861288f, 0.12264683f, 0.13883162f, -0.06126972f, 
    0.22554375f, -0.02548390f, -0.03436167f, -0.15623240f, -0.06436484f, 0.21113741f, -0.07693146f, -0.14938442f, 
    -0.03790894f, 0.06531499f, 0.00254527f, 0.10186218f, -0.36827847f, -0.01480459f, 0.27633762f, 0.00719609f, 
    0.08199736f, -0.06963574f, 0.01078213f, 0.06679212f, -0.10944494f, -0.09661409f, -0.11192256f, 0.01891127f, 
    0.18851279f, 0.08292115f, -0.12045973f, -0.19093485f, -0.03766964f, -0.06330410f, 0.04069969f, 0.20753878f, 
    0.27209938f, -0.01024391f, 0.08463374f, 0.03904898f, -0.06536404f, 0.05822808f, 0.16069670f, -0.24695159f, 
    0.12699214f, -0.05130543f, 0.09479707f, 0.10652764f, 0.01279908f, 0.23549075f, -0.09109284f, -0.02128833f, 
    0.09948995f, 0.05409761f, 0.13919024f, 0.20303066f, 0.06526487f, -0.04415274f, 0.07547668f, 0.12588204f, 
    0.04430548f, -0.25619665f, -0.26327667f, -0.41011381f, 0.10567831f, 0.10243614f, 0.18408503f, -0.24882053f, 
    -0.19418043f, -0.03146089f, -0.05622052f, 0.18944123f, 0.32243043f, -0.00719811f, 0.11854527f, 0.09694044f, 
    0.11307167f, 0.05843403f, 0.03040060f, -0.04121095f, -0.02810515f, 0.04116553f, -0.11672688f, -0.23466656f, 
    -0.13929202f, 0.06184115f, 0.02519990f, -0.25555405f, -0.02112340f, 0.25181824f, 0.27142060f, -0.09497683f, 
    -0.07272342f, 0.03768692f, 0.04618954f, 0.01101432f, 0.07904608f, -0.55356646f, -0.08521536f, -0.12702012f, 
    -0.03786696f, -0.10125493f, 0.00887060f, 0.34016109f, -0.02500980f, -0.19693238f, -0.00282016f, -0.07940671f, 
    -0.03704094f, 0.05884940f, 0.10572329f, 0.05868292f, -0.08525715f, -0.23205136f, -0.17816226f, -0.18356380f, 
    -0.17634200f, -0.11044891f, 0.03243232f, 0.01226415f, 0.02129408f, -0.07982396f, -0.09768785f, 0.28164992f, 
    -0.11627898f, 0.02759941f, -0.22669652f, 0.24100535f, 0.07214025f, -0.08727115f, 0.16616774f, -0.00620775f, 
    0.10450224f, 0.02163893f, -0.02831333f, 0.03224815f, 0.04354577f, 0.11123975f, -0.05337622f, 0.15021411f, 
    -0.03394023f, 0.06341009f, -0.06540556f, -0.01407849f, -0.27879784f, -0.10204411f, -0.00100481f, 0.06907819f, 
    -0.09629215f, -0.15024596f, 0.10840493f, 0.01726322f, 0.17855464f, 0.07707947f, 0.00210648f, 0.06203574f, 
    -0.02111072f, 0.09401885f, 0.05904788f, 0.12343858f, -0.05541462f, -0.05248543f, -0.20682558f, 0.03289609f, 
    -0.06196788f, -0.06215801f, 0.06543011f, -0.12543359f, -0.31142220f, -0.10891128f, 0.03002350f, 0.03886169f, 
    0.02305848f, -0.14611986f, -0.17309207f, -0.01025257f, 0.13792346f, -0.08649425f, 0.17334241f, -0.01250145f, 
    -0.23521720f, 0.19019645f, -0.03921194f, 0.14127801f, -0.01445182f, -0.05920620f, -0.08360898f, -0.00986233f, 
    0.03583535f, -0.14293119f, -0.06663822f, -0.03179334f, 0.19624321f, 0.01784458f, 0.16174544f, -0.18356715f, 
    0.03543754f, -0.03202963f, 0.00888242f, 0.06410295f, 0.05573974f, -0.01521655f, -0.01088269f, -0.02593455f, 
    -0.13564588f, 0.05899653f, 0.00740238f, 0.03338390f, -0.07682730f, 0.04708460f, 0.04396930f, 0.02337886f, 
    -0.26147372f, 0.14821941f, -0.32654873f, -0.13385500f, -0.12232090f, 0.13852628f, -0.10485380f, -0.09153122f, 
    0.01744084f, 0.05308767f, -0.10794074f, 0.12766600f, -0.01184050f, -0.35136965f, 0.19218847f, 0.02839837f, 
    0.20661873f, 0.03264726f, -0.04958648f, -0.11111787f, 0.19486615f, 0.02310736f, -0.02432063f, -0.00409805f, 
    0.01788911f, -0.27067143f, -0.07989779f, 0.09902343f, 0.17747141f, 0.06647800f, 0.11928174f, -0.21385269f, 
    -0.01290238f, -0.01499758f, 0.19849074f, -0.04837161f, -0.29938483f, -0.22216725f, -0.26786265f, -0.14606906f, 
    -0.03747893f, -0.22962022f, -0.06352085f, -0.12334266f, 0.02402001f, -0.01979453f, -0.04170756f, -0.30896360f, 
    0.26484817f, 0.05108919f, -0.06107860f, -0.00494585f, 0.02504648f, 0.19381712f, -0.01695535f, 0.02109397f, 
    0.09444515f, 0.11247124f, 0.05723710f, 0.07164469f, 0.14885442f, 0.10107177f, 0.05315252f, 0.15444817f, 
    -0.02941294f, -0.14066386f, -0.05921084f, 0.01941787f, 0.04290459f, 0.17796749f, -0.04684157f, -0.00066609f, 
    0.13352264f, 0.11505365f, 0.11002044f, -0.15926899f, -0.25157961f, -0.08370791f, 0.18636765f, -0.01670633f, 
    0.00151911f, -0.14019367f, -0.13914587f, 0.11913890f, 0.00146499f, -0.09807670f, 0.03815630f, 0.05095511f, 
    0.07873196f, -0.20637052f, -0.23550357f, -0.15195620f, -0.21656349f, -0.15782399f, -0.04475047f, -0.13214210f, 
    0.09417778f, 0.12018757f, -0.04784778f, -0.00171320f, 0.05503837f, -0.03675446f, -0.20307755f, -0.10817981f, 
    0.08143102f, -0.01469461f, 0.08358985f, 0.11701451f, -0.14699669f, 0.09858994f, 0.03858241f, 0.09749160f, 
    0.04171187f, 0.06480067f, 0.03409873f, 0.05031640f, -0.03053281f, -0.06318748f, 0.15164517f, -0.02450004f, 
    0.25029939f, -0.16638988f, 0.06009726f, -0.07025941f, 0.18840356f, -0.13458245f, -0.04757635f, -0.15305039f, 
    0.23898089f, -0.06804357f, 0.03477076f, 0.04628595f, 0.00235960f, 0.03636610f, -0.06546655f, -0.01274383f, 
    0.03240591f, -0.22212474f, -0.04874912f, -0.08621768f, 0.17211531f, -0.03789013f, -0.07949617f, -0.06249642f, 
    0.01727626f, 0.01443148f, 0.18615110f, 0.05767225f, 0.16423565f, 0.09267601f, -0.02844158f, 0.06520440f, 
    0.03426562f, -0.12929155f, -0.04149696f, 0.18390726f, -0.12181540f, 0.07287470f, 0.15589887f, -0.01778997f, 
    -0.12226247f, 0.05305370f, 0.09805148f, -0.09224837f, 0.17027266f, 0.14735959f, 0.09900562f, 0.07168543f, 
    -0.08565459f, 0.02022384f, 0.11763604f, -0.09823695f, 0.14100580f, 0.09738016f, 0.08024140f, 0.02113066f, 
    -0.09354568f, -0.01884689f, 0.04572055f, 0.11962738f, 0.06922019f, 0.08265460f, 0.14609121f, 0.12526213f, 
    -0.00094651f, -0.06093363f, 0.01588873f, 0.11131561f, 0.01744130f, 0.00422130f, 0.07594887f, 0.02925866f, 
    0.04882916f, -0.08328263f, -0.09074965f, 0.03557340f, -0.10094244f, 0.11721620f, -0.01306483f, -0.01543265f, 
    0.13245498f, 0.00502461f, 0.19920434f, -0.02547929f, -0.04931373f, -0.02418026f, 0.01716509f, 0.21113557f, 
    0.06778728f, 0.01606540f, 0.24640685f, -0.05283321f, -0.00689090f, -0.09991502f, 0.04391885f, 0.01798994f, 
    0.15968989f, 0.01943569f, 0.06217713f, -0.04872922f, 0.31765896f, 0.01691032f, 0.04547934f, -0.06144094f, 
    0.01836186f, -0.09978436f, 0.13463573f, 0.00707259f, -0.09183663f, -0.24337421f, 0.08151908f, 0.13353027f, 
    0.13290761f, -0.06571720f, -0.09879034f, -0.19911884f, -0.16911723f, -0.13871725f, 0.26044646f, 0.00272061f, 
    -0.10266372f, 0.04145379f, -0.01206742f, -0.05648390f, 0.27133295f, 0.06364608f, 0.06800164f, -0.33275506f, 
    0.00835348f, 0.06175720f, 0.15369536f, 0.00084557f, -0.07193721f, 0.02672913f, 0.13679194f, 0.00725035f, 
    0.00919581f, 0.05826380f, 0.14402054f, -0.17589349f, 0.06287304f, -0.02933308f, 0.12893513f, 0.15632276f, 
    -0.11317922f, -0.03426795f, 0.02004874f, -0.01607655f, -0.00955937f, 0.15278539f, -0.09349276f, 0.10024597f, 
    0.16573054f, 0.18985523f, -0.05231488f, 0.10268086f, -0.04995760f, 0.05714809f, -0.07358766f, -0.10099310f, 
    0.16939706f, -0.00297965f, -0.12867923f, 0.07639900f, -0.06199595f, -0.14019692f, -0.08552507f, -0.14769919f, 
    0.22904152f, -0.00099009f, 0.16495264f, -0.18155245f, -0.21889164f, 0.18384378f, -0.00975476f, 0.17101239f, 
    0.03140187f, -0.02225368f, -0.18736200f, 0.12582356f, 0.00836201f, 0.26278082f, 0.03431188f, 0.02768511f, 
    -0.15727918f, 0.00811465f, 0.11371798f, 0.08117518f, -0.25526792f, -0.14992255f, 0.00611935f, 0.14037339f, 
    0.05405406f, 0.09632605f, -0.10174935f, 0.12274881f, -0.40330115f, 0.15770015f, 0.07068814f, -0.15468697f, 
    0.10720006f, 0.08350880f, -0.01138094f, 0.11746386f, -0.00352160f, 0.01496758f, 0.01234048f, -0.02192573f, 
    0.08448593f, 0.26167366f, 0.07687544f, 0.00167237f, -0.06549462f, 0.00039339f, -0.26527807f, 0.02834274f, 
    0.00092782f, 0.08518641f, 0.00406649f, 0.11228931f, -0.17677829f, 0.01770047f, 0.03897118f, 0.03792877f, 
    -0.04360513f, 0.02443274f, -0.07648057f, 0.03964596f, 0.08209302f, 0.11832930f, 0.04978129f, -0.08046324f, 
    -0.01236398f, 0.09069435f, 0.04133084f, -0.00480491f, 0.05925418f, -0.00948543f, -0.07949237f, 0.00415110f, 
    0.00165915f, -0.04181224f, 0.05980489f, 0.12666082f, 0.18514378f, 0.01612850f, -0.01884464f, -0.09348375f, 
    -0.09661034f, 0.14908743f, 0.15508775f, 0.12984338f, 0.05968992f, 0.08136547f, 0.12820642f, 0.08454401f, 
    0.13486247f, 0.04173264f, -0.01654663f, 0.01015825f, 0.18032713f, 0.03006549f, 0.02325417f, 0.07675609f, 
    -0.12952997f, -0.00878192f, -0.08731109f, 0.08806929f, 0.04884704f, 0.09431466f, 0.01408498f, 0.01790771f, 
    -0.08650615f, -0.10713034f, 0.18438616f, 0.06248093f, 0.09086040f, 0.03640489f, -0.05466147f, 0.00873412f, 
    0.01596640f, 0.02975264f, -0.08006326f, 0.08127256f, -0.06376985f, -0.12641898f, -0.05929596f, 0.27821970f, 
    -0.07025886f, 0.10515949f, 0.10592029f, 0.00955945f, -0.10564837f, 0.03249600f, -0.04527578f, -0.02369613f, 
    0.17100504f, -0.01837338f, 0.02577916f, 0.17057113f, -0.02176493f, 0.15459420f, -0.02614850f, 0.09245047f, 
    -0.10374264f, -0.13670819f, 0.01651604f, 0.27640226f, -0.05359089f, 0.04950679f, -0.01385777f, -0.01376982f, 
    -0.09441363f, 0.04798651f, 0.07005412f, 0.01334763f, -0.08627288f, 0.01397191f, 0.08954097f, -0.00963118f, 
    -0.02622265f, 0.01696258f, -0.14979568f, -0.10665546f, -0.08104165f, 0.03323202f, 0.07395923f, 0.14666271f, 
    -0.23546280f, 0.01158021f, 0.15360244f, -0.03437929f, -0.03991523f, -0.14519392f, -0.17525893f, 0.06080379f, 
    0.15802421f, 0.01131802f, -0.03117231f, -0.08140700f, -0.15494029f, -0.20841949f, 0.00714693f, 0.09488986f, 
    0.15619208f, 0.17565322f, 0.04246493f, -0.11432865f, -0.08317726f, -0.04103727f, -0.07205495f, -0.06158158f, 
    0.13783112f, -0.08371354f, -0.04380094f, 0.01371730f, 0.03259198f, 0.06996515f, 0.09265820f, 0.22103943f, 
    -0.31044179f, -0.11531152f, -0.09636373f, 0.02105719f, -0.02825961f, 0.12824820f, -0.18150164f, -0.29364818f, 
    0.00075919f, 0.01012763f, 0.00045927f, 0.02015676f, -0.05633885f, 0.02465631f, -0.04993489f, 0.03805217f, 
    0.01585405f, -0.04947210f, -0.01883293f, -0.00842597f, -0.02575253f, 0.05240311f, -0.01529936f, -0.04939164f, 
    0.04908239f, 0.01158094f, -0.03058466f, 0.04311795f, 0.01479219f, -0.04081099f, 0.00550556f, -0.00422526f, 
    -0.05653631f, -0.02800003f, 0.03678370f, -0.04817060f, 0.03118643f, -0.04809353f, -0.06090945f, -0.02124632f, 
    0.00695946f, -0.05000703f, -0.02992671f, -0.02849623f, 0.00840514f, -0.00872364f, 0.00148958f, 0.02655494f, 
    -0.05536202f, 0.04060521f, -0.01507133f, -0.00372059f, 0.00452121f, 0.01157716f, -0.06271899f, 0.01025643f, 
    0.00866888f, -0.05126821f, 0.00974233f, 0.01242836f, -0.02527597f, 0.01905265f, 0.00313091f, 0.00527731f, 
    0.04562923f, 0.01752025f, -0.02111091f, 0.02970169f, 0.04886506f, -0.05640724f, 0.01097178f, -0.04103373f, 
    -0.02220771f, -0.03312112f, -0.00693254f, 0.02730459f, 0.00050116f, 0.01416581f, 0.01957368f, -0.03699501f, 
    0.03388363f, 0.04185731f, -0.00404835f, -0.05997206f, -0.06002013f, -0.02508657f, -0.04015931f, -0.05023751f, 
    0.01553525f, -0.00220716f, 0.03161751f, 0.02423632f, -0.04623059f, -0.00110514f, 0.03786273f, -0.02837908f, 
    -0.03110562f, 0.01508102f, -0.02548772f, -0.02532948f, -0.01315436f, 0.01537682f, 0.04489801f, -0.05180567f, 
    -0.03522809f, -0.04165190f, 0.03039080f, 0.01838371f, 0.00065407f, -0.04348711f, -0.05918784f, 0.00954867f, 
    0.01185472f, -0.03846409f, 0.01810895f, -0.00785520f, -0.03547762f, -0.02502155f, 0.04602855f, 0.03051439f, 
    -0.02402986f, 0.01158473f, -0.00257408f, 0.03628468f, 0.01401181f, 0.03450029f, -0.05007052f, 0.04843047f, 
    -0.00499572f, -0.05738970f, -0.03809403f, -0.01976466f, -0.04466109f, 0.02777245f, -0.03252985f, -0.05736830f, 
    -0.04478095f, 0.04888377f, -0.05633233f, -0.02971057f, -0.04244995f, 0.02081480f, -0.00777305f, -0.03532971f, 
    -0.04841119f, 0.00514439f, -0.02858120f, 0.03143305f, 0.04301952f, 0.02678104f, 0.02205478f, -0.03051361f, 
    -0.02186538f, -0.00528619f, -0.04047382f, 0.01807370f, 0.02242022f, -0.04046022f, -0.00249945f, 0.02951084f, 
    -0.04416474f, 0.05488421f, 0.04010944f, 0.03525217f, 0.00955910f, -0.05983840f, 0.02656846f, 0.01478665f, 
    0.03936422f, -0.06177622f, 0.02024702f, 0.03477076f, 0.02708859f, -0.00955566f, -0.01455710f, -0.06048847f, 
    -0.02303484f, 0.05391332f, 0.02396615f, -0.00478134f, -0.02425762f, 0.00772361f, 0.04399610f, -0.00527637f, 
    -0.02071718f, -0.06241733f, -0.02988121f, -0.01202097f, -0.00905257f, 0.04442054f, -0.03266453f, -0.05763843f, 
    0.01346577f, 0.02409170f, -0.03408451f, -0.01455322f, 0.02225913f, -0.02910459f, 0.03825610f, -0.00316332f, 
    -0.03100155f, 0.04467821f, -0.01600200f, -0.00517838f, -0.03081590f, 0.03794454f, -0.00828070f, -0.06104783f, 
    0.02048548f, -0.05449570f, 0.03180455f, -0.01403005f, -0.04575332f, -0.02491155f, 0.02388113f, -0.01245026f, 
    -0.03060425f, -0.03895576f, 0.01729508f, 0.01786192f, 0.00055928f, 0.02837576f, 0.03779100f, -0.04635216f, 
    -0.00380202f, -0.04932123f, -0.02914726f, -0.00469054f, -0.00013438f, 0.04434465f, -0.03708871f, -0.05662734f, 
    0.00099562f, -0.04168955f, -0.05344049f, -0.02796508f, -0.03572201f, -0.04020166f, -0.04015047f, 0.02286184f, 
    -0.02612348f, 0.04289790f, 0.05193521f, -0.04989867f, -0.00552345f, -0.01759150f, -0.06737277f, -0.00572149f, 
    -0.05436398f, -0.00665183f, 0.02476363f, -0.04633082f, 0.01607460f, 0.02894770f, 0.03336400f, -0.00464844f, 
    0.00751061f, 0.05328525f, -0.01401668f, 0.04925715f, 0.02379021f, 0.03789161f, -0.05545530f, -0.00533163f, 
    0.03983879f, 0.04047554f, -0.03510603f, -0.00362227f, -0.02508971f, -0.00016391f, -0.01607773f, 0.00547093f, 
    -0.00393522f, -0.06183047f, 0.03013566f, -0.04843805f, -0.04441112f, -0.03064812f, -0.00237196f, 0.02970020f, 
    -0.04693265f, 0.00057072f, -0.04699732f, -0.01952736f, 0.00078812f, -0.04757054f, 0.00876081f, -0.05522194f, 
    0.01383633f, 0.01284986f, 0.02551465f, -0.05802946f, 0.01011121f, 0.00488819f, 0.04086822f, -0.03563464f, 
    0.08340327f, -0.19542299f, 0.05840727f, 0.05615607f, -0.09323540f, -0.11512865f, 0.03577853f, 0.14893641f, 
    -0.06061137f, 0.08770576f, -0.05573502f, -0.20434575f, -0.10039913f, -0.06883097f, 0.01391636f, 0.12772289f, 
    0.01634785f, -0.00736022f, 0.12687966f, 0.00026084f, -0.06914510f, 0.06678596f, 0.01037835f, -0.06432167f, 
    0.12397425f, 0.06616920f, 0.00071485f, -0.21321443f, -0.16789617f, -0.09188841f, 0.07734045f, 0.16540030f, 
    0.10858544f, 0.02714762f, 0.04421911f, -0.11671684f, -0.00699520f, 0.15370786f, 0.02142241f, -0.07044929f, 
    -0.08779103f, 0.08656069f, -0.15887602f, 0.00887716f, -0.07205760f, -0.50394619f, -0.05657721f, -0.14458139f, 
    0.14878632f, 0.05028402f, 0.08756182f, 0.05259586f, 0.01904419f, -0.09285771f, 0.41972390f, -0.01601898f, 
    -0.27686024f, 0.00084924f, -0.15300538f, 0.03910525f, 0.06644699f, 0.04442155f, -0.06835616f, -0.22276726f, 
    0.04116528f, -0.16048291f, -0.06273063f, 0.02252867f, 0.06012173f, -0.02521027f, -0.11879614f, -0.00193835f, 
    -0.13953646f, 0.12095179f, 0.03565525f, -0.08163194f, 0.08108961f, 0.05284421f, 0.06315046f, -0.08699815f, 
    -0.02507032f, 0.00647643f, -0.13030192f, -0.11727950f, 0.04374767f, 0.08064051f, 0.02214306f, -0.16426866f, 
    -0.08175964f, -0.09827247f, -0.41698611f, 0.20349483f, 0.04029725f, -0.00929072f, 0.06952289f, 0.03382386f, 
    -0.23570184f, 0.08378361f, 0.06969874f, -0.16294824f, 0.09439709f, -0.09336729f, -0.17449683f, -0.07537568f, 
    -0.05443447f, -0.03224299f, 0.04664525f, -0.06145157f, -0.23972043f, -0.23494986f, -0.06253959f, 0.06030641f, 
    0.04329426f, 0.05640760f, 0.10749710f, 0.02509458f, 0.00894285f, 0.09837338f, 0.09999652f, -0.03636537f, 
    0.07097579f, 0.10303839f, -0.02746870f, -0.10924959f, -0.06587351f, 0.05057829f, -0.38542998f, -0.02879333f, 
    -0.03389568f, 0.15036735f, 0.17142522f, 0.08120842f, 0.09575457f, 0.12751962f, 0.11278272f, 0.19740243f, 
    -0.11731888f, -0.10339824f, 0.04140190f, 0.05320854f, -0.00146275f, 0.00504191f, -0.02968343f, 0.04539251f, 
    0.25733224f, -0.03198693f, -0.04792978f, -0.02829436f, 0.00034624f, 0.02396534f, 0.00540683f, -0.04060213f, 
    0.03520061f, -0.11071637f, -0.02372731f, 0.05291137f, -0.15008233f, 0.09892850f, -0.02025433f, 0.12548588f, 
    -0.11230125f, 0.08082862f, -0.01148544f, 0.01443054f, 0.00102872f, 0.01776597f, 0.00158481f, 0.01837488f, 
    -0.23029140f, 0.04791068f, 0.08360823f, -0.11750571f, 0.13165124f, 0.00594217f, -0.02087734f, 0.10733186f, 
    0.12757128f, 0.06344808f, -0.14238673f, 0.06410044f, -0.05018391f, 0.05016290f, -0.01742879f, -0.20946322f, 
    -0.07994568f, -0.18363583f, 0.15341681f, -0.11407921f, 0.02425148f, 0.11386766f, 0.05849580f, 0.06713008f, 
    -0.01055387f, -0.00593815f, 0.11280031f, -0.04396679f, -0.11601664f, 0.19936959f, 0.25788721f, 0.16796808f, 
    -0.03690969f, 0.01814468f, 0.05569493f, 0.05064296f, 0.02390637f, -0.10608617f, 0.01885594f, -0.12035173f, 
    0.22845420f, -0.02136731f, -0.02062251f, -0.21109237f, 0.01387273f, 0.01391281f, 0.20077312f, 0.04469075f, 
    0.35889840f, -0.19329460f, -0.09155539f, -0.02353304f, 0.03456445f, -0.03131176f, 0.01818306f, 0.04554215f, 
    0.11206411f, -0.08406552f, 0.14640465f, 0.06004018f, 0.14924733f, -0.12532215f, -0.10096327f, 0.06661627f, 
    -0.02343803f, 0.03051160f, 0.46534097f, -0.00871197f, -0.20213275f, 0.10321871f, -0.04751741f, -0.05773318f, 
    0.05119666f, 0.11508801f, 0.08020396f, 0.07539548f, 0.08676251f, 0.19270407f, 0.20744427f, -0.04677268f, 
    -0.05261505f, 0.11774285f, 0.10075885f, -0.10532271f, 0.26407763f, 0.02144089f, 0.00004399f, 0.07908367f, 
    0.02144189f, -0.04053728f, 0.03001819f, 0.06392138f, 0.08218900f, -0.19516565f, -0.09550779f, 0.25843564f, 
    0.05649981f, 0.11335681f, -0.16163327f, -0.09584446f, 0.16676156f, -0.09425920f, -0.18565296f, 0.02251758f, 
    -0.26631901f, 0.08375085f, -0.04104044f, -0.04810135f, -0.04421370f, -0.03855137f, -0.07198418f, -0.55857444f, 
    -0.04876732f, -0.06343845f, 0.01729351f, 0.15529366f, -0.09295525f, -0.02053585f, 0.05644576f, 0.11735775f, 
    0.00477810f, 0.03446244f, -0.01765579f, -0.04790172f, -0.02826725f, 0.00811012f, -0.01043754f, -0.00618600f, 
    -0.03374897f, 0.00738269f, -0.01047305f, -0.01931907f, -0.05245557f, -0.04592936f, 0.04345871f, 0.00522597f, 
    -0.03359541f, -0.01742782f, -0.01763800f, -0.05576994f, 0.04872987f, 0.04403945f, 0.04109156f, -0.02487285f, 
    0.00392350f, 0.04495040f, -0.05176207f, -0.01684452f, 0.02870810f, -0.04464642f, -0.06161306f, 0.04805961f, 
    0.00635887f, -0.00148818f, 0.04568193f, 0.00162229f, 0.01846648f, -0.00665571f, 0.03031895f, 0.04821366f, 
    -0.02705432f, -0.03186474f, -0.04846376f, -0.02661969f, -0.00879411f, 0.00404893f, -0.06008777f, -0.04315140f, 
    -0.02846612f, -0.06558445f, -0.00460200f, 0.02327325f, -0.03506253f, 0.03426268f, -0.03981235f, -0.02034812f, 
    0.04797145f, -0.02301680f, -0.01117236f, -0.02268147f, 0.00051950f, 0.02422548f, -0.03293690f, -0.00496314f, 
    0.05459165f, -0.05185746f, 0.00401316f, 0.02420722f, 0.02474694f, 0.03219776f, 0.02693438f, 0.05411035f, 
    -0.04662836f, 0.02605766f, 0.00433879f, -0.05003048f, 0.02907181f, 0.02901353f, 0.01874427f, -0.01252468f, 
    0.01546130f, -0.01368534f, 0.03876872f, -0.03560889f, -0.00092915f, -0.05592777f, -0.04213013f, 0.02945187f, 
    0.01614436f, 0.01686374f, -0.03529003f, -0.03742613f, -0.02220602f, 0.05227248f, -0.06395012f, -0.00849189f, 
    0.01478733f, -0.02953334f, 0.04606194f, 0.03850302f, 0.01449032f, -0.01816903f, -0.06007145f, -0.03445419f, 
    0.01656874f, 0.05310343f, -0.01123235f, -0.04119276f, 0.01703326f, 0.04605936f, -0.02737480f, -0.03188290f, 
    -0.03006332f, -0.03832826f, -0.03320681f, -0.00340697f, -0.04038617f, 0.04115994f, 0.01066972f, 0.01609837f, 
    -0.04301817f, 0.01682431f, -0.02685495f, 0.00467655f, -0.05799061f, -0.04832686f, -0.05044369f, -0.06606600f, 
    -0.02428104f, -0.03385814f, 0.01148248f, -0.02025294f, 0.01462948f, -0.05477440f, 0.04193830f, -0.05391215f, 
    0.03094717f, -0.01725384f, -0.06357957f, -0.00384025f, 0.02519472f, -0.04151811f, -0.00670673f, 0.00264238f, 
    0.03851205f, 0.04358166f, 0.01096417f, 0.00193470f, -0.06171913f, 0.05058604f, -0.02448244f, 0.00997672f, 
    0.03810485f, 0.03191357f, 0.03738797f, 0.03559908f, -0.04008649f, -0.06512106f, -0.06181451f, 0.03737393f, 
    -0.03239459f, -0.02660213f, 0.00597461f, 0.00880875f, -0.01795008f, -0.01994173f, -0.04998262f, -0.04246876f, 
    0.02364654f, -0.02779419f, -0.05333044f, -0.03393146f, -0.04550377f, 0.01112099f, 0.05208118f, -0.05950547f, 
    -0.02217681f, 0.02722712f, 0.02967310f, -0.05416775f, -0.03800367f, -0.00005663f, 0.04023939f, -0.05165889f, 
    -0.02208191f, 0.01119811f, -0.01934088f, -0.05810878f, 0.02945854f, -0.05723152f, 0.00508533f, -0.04773892f, 
    0.05178891f, 0.04868955f, -0.00626686f, 0.01050552f, 0.03355012f, -0.05524884f, 0.01612064f, 0.02433591f, 
    0.04028051f, 0.00490669f, -0.05456541f, -0.01877087f, -0.04681540f, 0.01660122f, 0.01837229f, 0.03987765f, 
    -0.04138887f, 0.01644878f, 0.05170124f, 0.01540540f, -0.02696734f, 0.05066243f, -0.04481341f, -0.04116714f, 
    -0.02491122f, -0.03660578f, -0.03431607f, 0.05604535f, 0.04032262f, -0.05645588f, -0.01178078f, 0.00870942f, 
    -0.05287733f, -0.06164835f, 0.01832686f, -0.01280887f, -0.04444920f, 0.00672930f, -0.00200659f, 0.03867595f, 
    -0.05189776f, -0.00585300f, 0.02809929f, -0.03455236f, -0.01196348f, 0.02142654f, 0.02300495f, -0.00544397f, 
    -0.03410232f, -0.02017979f, 0.01553629f, 0.03084408f, -0.01115409f, -0.02667606f, -0.04204963f, -0.03610762f, 
    -0.06074199f, 0.01001252f, -0.02743510f, -0.04731584f, 0.01124730f, -0.03007313f, 0.05539893f, -0.06089151f, 
    -0.04956388f, 0.04189352f, 0.01534256f, 0.03531755f, 0.03710742f, -0.00408670f, 0.03887465f, 0.00644266f, 
    -0.03143710f, 0.01600740f, -0.04537645f, -0.04122414f, -0.05894759f, -0.05757475f, -0.03497837f, -0.03879683f, 
    -0.02045907f, 0.03161594f, -0.03046834f, 0.03501204f, 0.03073025f, -0.04294026f, 0.02552237f, -0.05172867f, 
    0.04508070f, -0.04441676f, -0.04991864f, 0.02837037f, -0.06534138f, -0.03913572f, -0.01853906f, -0.06463947f, 
    0.23625781f, 0.14104751f, 0.01517315f, 0.04884119f, -0.02723913f, -0.01872217f, 0.03442676f, -0.07374940f, 
    -0.11703632f, -0.02503826f, -0.33905935f, 0.00852676f, 0.05663935f, 0.06489304f, 0.04174187f, 0.00535152f, 
    0.07430968f, -0.10211214f, -0.06241214f, 0.18882777f, 0.07808296f, -0.08169098f, -0.13789922f, -0.09341779f, 
    -0.11696804f, -0.06444132f, -0.07208841f, 0.12487449f, 0.14132158f, 0.01758428f, 0.02244047f, -0.00916615f, 
    0.01078257f, 0.07763123f, 0.02539085f, 0.00891188f, -0.20123075f, -0.10315923f, -0.11719469f, 0.10307411f, 
    -0.03513695f, -0.06823832f, 0.11088949f, 0.01096440f, 0.00653963f, 0.18696061f, -0.09699281f, 0.05112864f, 
    -0.01177387f, -0.11016580f, 0.04270350f, -0.06045369f, -0.06569484f, 0.07737219f, 0.04033059f, 0.04592277f, 
    -0.24165802f, 0.03519809f, -0.03369323f, 0.12246685f, 0.09075212f, 0.11302180f, 0.02067114f, -0.04446404f, 
    0.13225082f, 0.05725231f, 0.22239152f, -0.06759932f, -0.01685571f, -0.00439157f, -0.04081218f, 0.07966672f, 
    -0.24479897f, -0.06502359f, -0.08739157f, -0.13088872f, 0.00755434f, -0.11791693f, -0.00966258f, 0.05870007f, 
    -0.01681511f, -0.22478308f, -0.05259389f, -0.10566679f, 0.02314147f, -0.07742663f, -0.07791699f, 0.03946123f, 
    -0.05837579f, 0.16828233f, -0.06895244f, -0.26067698f, -0.13878353f, -0.07262436f, -0.04939974f, -0.03500202f, 
    0.01411882f, 0.02831145f, -0.05273596f, 0.23986374f, 0.07025903f, -0.28299204f, 0.01802744f, -0.04417124f, 
    -0.05635329f, 0.09666991f, 0.10899768f, 0.07909365f, 0.20351160f, 0.05430947f, -0.09365478f, 0.00740228f, 
    -0.00286478f, -0.17941464f, -0.15577830f, 0.04838564f, -0.08987820f, 0.19706355f, 0.02692129f, -0.36183769f, 
    0.11122655f, -0.02942372f, -0.01189782f, 0.02291445f, 0.06386067f, 0.13780455f, -0.13621463f, -0.34497917f, 
    0.01533342f, -0.08760715f, 0.00781476f, -0.12907352f, -0.02204318f, -0.03882059f, -0.12538710f, 0.42116314f, 
    0.21745570f, 0.04932260f, -0.15781665f, -0.09215885f, 0.07580493f, -0.01641363f, 0.17920887f, 0.03933188f, 
    0.26673096f, 0.19786620f, -0.01925025f, -0.06916115f, 0.10615546f, -0.11183824f, 0.09355024f, 0.00717618f, 
    -0.09352766f, -0.12497415f, -0.26235455f, 0.01952574f, 0.01185921f, 0.05595687f, -0.02680542f, -0.02517324f, 
    0.01385286f, 0.17219178f, 0.00502277f, -0.26171696f, -0.09634899f, -0.08456535f, 0.01018150f, -0.06422597f, 
    0.09932557f, 0.00728809f, 0.03354592f, -0.21577868f, 0.00516075f, -0.04266614f, 0.13440922f, 0.01127140f, 
    0.07447608f, 0.17279422f, 0.05941775f, -0.08275754f, -0.24572049f, -0.15248738f, -0.23303546f, -0.05035782f, 
    0.01603647f, 0.04367008f, 0.00627686f, 0.00653909f, 0.14624494f, -0.23841448f, -0.23336536f, -0.00382023f, 
    -0.01215310f, 0.04776800f, -0.06153367f, 0.01625108f, -0.07880089f, -0.00915436f, 0.15951295f, 0.00398735f, 
    -0.03113077f, 0.00547665f, -0.12442100f, -0.11032290f, 0.02253513f, -0.10304904f, -0.06527784f, 0.01920379f, 
    0.34770656f, 0.00812817f, 0.12481774f, -0.06651635f, 0.03048799f, -0.12873140f, -0.17726707f, 0.04191511f, 
    -0.05652585f, 0.17778271f, -0.11129913f, -0.12228343f, -0.06224858f, -0.05651595f, -0.02818908f, -0.05984383f, 
    0.01678422f, -0.30731177f, 0.11785826f, 0.08457685f, -0.12045176f, -0.08751813f, 0.10179626f, -0.10200471f, 
    0.16122253f, 0.02557342f, 0.21676359f, 0.14721180f, 0.16781978f, 0.12980658f, 0.08157607f, -0.04951204f, 
    0.15386516f, 0.02675422f, 0.08207113f, 0.26243719f, 0.16983385f, 0.19881161f, -0.15541175f, 0.10157719f, 
    0.05545219f, -0.03883971f, 0.05804726f, -0.03802214f, 0.15545945f, 0.07072996f, 0.20916888f, 0.08216894f, 
    0.11969510f, 0.00052262f, 0.07605144f, 0.01843922f, -0.07076848f, 0.09348891f, -0.10600626f, 0.14384709f, 
    0.08832622f, -0.01565704f, 0.01904036f, 0.01107660f, 0.22097582f, -0.04418347f, 0.07989287f, -0.04414812f, 
    -0.08313259f, 0.14731850f, 0.00808331f, 0.10406393f, 0.02845338f, 0.05810943f, 0.06335930f, 0.25487587f, 
    -0.24091263f, 0.09612601f, -0.22656302f, -0.06810094f, -0.13085596f, -0.00832623f, 0.03413013f, -0.13900287f, 
    -0.04163046f, -0.05339264f, -0.02820592f, -0.00390491f, 0.03911897f, -0.03946146f, -0.02027578f, -0.06017612f, 
    0.01426211f, -0.01880115f, 0.00396268f, -0.03988489f, 0.00983752f, -0.04967741f, -0.04589563f, 0.01678577f, 
    -0.01546310f, -0.02604845f, -0.06468894f, 0.02706312f, -0.04168870f, -0.05995519f, -0.03628712f, -0.00007536f, 
    0.04919083f, -0.05227173f, -0.04605137f, 0.00569805f, -0.04143765f, -0.06473040f, -0.03809646f, 0.02827876f, 
    -0.01386867f, 0.02638029f, -0.01206679f, -0.04304267f, 0.02675990f, -0.01928636f, -0.02011121f, 0.02092000f, 
    0.02645724f, -0.04636455f, 0.00808429f, -0.04488420f, 0.00412839f, 0.05452207f, 0.04030931f, -0.06093328f, 
    -0.01644079f, -0.05627862f, -0.02576114f, -0.04444807f, 0.04233060f, 0.04509205f, 0.04185281f, -0.00891547f, 
    0.01539604f, -0.03610923f, -0.04676096f, -0.00249035f, 0.00025035f, -0.06332476f, 0.03678799f, -0.02852316f, 
    -0.05644998f, -0.01995529f, -0.00586502f, -0.05916895f, -0.04252579f, -0.06332189f, 0.03592858f, 0.03283182f, 
    -0.05233503f, 0.03499009f, -0.03257714f, -0.01556371f, 0.01070511f, -0.00225945f, -0.01704821f, -0.04949653f, 
    -0.01327076f, 0.04150652f, 0.03646090f, -0.05857089f, -0.02060667f, 0.03556141f, -0.01419146f, 0.05008304f, 
    0.02003676f, 0.00945118f, 0.03067428f, -0.02079749f, -0.03678092f, -0.02387461f, -0.04172414f, 0.03267754f, 
    0.00727273f, -0.05284188f, -0.06473144f, -0.00729084f, 0.03863194f, -0.04836709f, -0.05368242f, 0.02951222f, 
    -0.04269800f, -0.00340526f, 0.00767062f, 0.05666090f, 0.03538737f, -0.04468299f, 0.03344265f, -0.05752450f, 
    0.01432386f, -0.00042635f, 0.01759486f, -0.04252863f, 0.01226193f, -0.02386252f, -0.05719264f, 0.05366186f, 
    0.04843368f, -0.00311121f, 0.00046206f, -0.00749566f, -0.02355411f, 0.05609503f, 0.02694143f, 0.02375098f, 
    0.03465412f, 0.02792259f, 0.03009298f, -0.03444859f, 0.02121524f, 0.02213379f, -0.06723981f, -0.05688445f, 
    0.00100567f, -0.03366353f, -0.02234243f, 0.01237408f, -0.00241862f, 0.02864222f, 0.02920118f, -0.04254999f, 
    0.00632805f, 0.01273062f, 0.01857945f, 0.05013455f, 0.02203641f, -0.05124132f, -0.00591519f, -0.04578496f, 
    0.04884124f, 0.02349414f, -0.05879842f, 0.00906714f, 0.00258384f, -0.04290231f, -0.06377454f, -0.03191513f, 
    -0.05067078f, -0.04611788f, 0.04810288f, -0.02362731f, -0.03235684f, -0.03034663f, -0.05739037f, 0.01067817f, 
    -0.00457183f, 0.03581093f, -0.04444829f, -0.03006118f, 0.00751337f, -0.01985874f, -0.02461824f, -0.00000667f, 
    0.02165939f, -0.05538794f, -0.02795908f, 0.04238683f, 0.00914057f, 0.00499135f, 0.05090167f, 0.01776419f, 
    -0.01887005f, -0.02084780f, -0.04219339f, -0.06386690f, -0.05982808f, 0.01485338f, 0.01431896f, 0.03275209f, 
    -0.02163165f, -0.03359757f, -0.00015577f, -0.04552047f, 0.04542150f, -0.02187712f, 0.02668705f, -0.07653306f, 
    -0.05596361f, 0.02745934f, 0.00232447f, 0.02870911f, 0.03991506f, 0.02019614f, 0.04042875f, 0.01542941f, 
    -0.05686835f, 0.00190848f, -0.00460410f, 0.00884071f, -0.00763340f, 0.03744398f, -0.03568471f, -0.04507802f, 
    -0.04003591f, 0.00659792f, -0.03189943f, -0.00338413f, 0.03116233f, -0.05006274f, -0.01680535f, -0.00069731f, 
    0.01014596f, 0.04791008f, -0.00831871f, 0.02393997f, -0.03861894f, 0.02824344f, -0.00695884f, 0.05635887f, 
    0.03818173f, -0.00742202f, -0.05045943f, -0.03695702f, -0.03270736f, 0.03510541f, 0.04048622f, -0.02136576f, 
    0.02927704f, -0.01373001f, -0.00181162f, -0.06409296f, 0.01908370f, -0.01764821f, -0.04252785f, 0.04517373f, 
    -0.05222414f, 0.02462422f, -0.05465811f, 0.00848430f, 0.02236304f, -0.06577357f, 0.00725549f, 0.04433923f, 
    -0.01627442f, -0.03494303f, -0.03071466f, -0.03850038f, -0.03371802f, 0.02957518f, -0.01511674f, -0.04342739f, 
    -0.01462904f, 0.02913568f, 0.01475607f, 0.02292930f, -0.06002029f, -0.00812556f, 0.03849655f, -0.05100857f, 
    -0.04990577f, -0.04835830f, -0.01251949f, 0.01310388f, -0.05529001f, 0.04673246f, -0.00235431f, -0.06371110f, 
    0.01492643f, 0.04444878f, -0.02502847f, 0.02098508f, -0.03795850f, -0.02587857f, 0.02419678f, 0.01442344f, 
    0.29441053f, 0.02525157f, 0.10256683f, -0.00528051f, -0.04406692f, 0.06052005f, 0.04555408f, 0.02297146f, 
    0.00617018f, -0.14896624f, 0.03109958f, -0.03058957f, -0.05436507f, 0.01679174f, 0.01927165f, -0.00188327f, 
    0.07135367f, 0.19161884f, 0.15681155f, 0.19557208f, 0.09928437f, -0.03136548f, -0.06640040f, 0.06145129f, 
    -0.02528587f, -0.09961230f, 0.11214390f, -0.05874412f, 0.00429202f, 0.06505920f, 0.12106129f, 0.02598657f, 
    -0.02070374f, 0.08127621f, 0.00272245f, -0.03858207f, 0.24703233f, -0.12111856f, -0.07289769f, 0.04437672f, 
    -0.02820569f, -0.02996778f, 0.12726654f, 0.11146035f, -0.14502193f, 0.04626161f, 0.01258293f, -0.07496085f, 
    -0.06529923f, 0.08126372f, -0.14166869f, -0.05975479f, -0.12399828f, -0.12868355f, 0.18936747f, 0.04103512f, 
    0.24081849f, 0.15834203f, 0.13246715f, -0.02276766f, -0.04298777f, 0.11510760f, 0.04159489f, 0.10872231f, 
    0.28979689f, -0.00503536f, -0.02675667f, -0.11598921f, 0.09241201f, -0.13988712f, 0.12348690f, 0.17516407f, 
    -0.16727588f, 0.07991128f, -0.11024097f, 0.00878370f, 0.06541390f, 0.10477194f, -0.06655440f, 0.00106075f, 
    -0.11984374f, 0.05075152f, 0.05461922f, -0.15194051f, -0.14499263f, -0.09088016f, -0.04578608f, 0.05859143f, 
    0.03951901f, 0.14419200f, -0.09720316f, 0.02803310f, -0.23210859f, -0.09679976f, 0.06997876f, -0.06189722f, 
    0.03476131f, -0.01168012f, -0.12299745f, 0.19011809f, -0.09499686f, -0.02822898f, -0.03312396f, -0.07758242f, 
    0.11449093f, 0.01237153f, 0.02437136f, -0.10805467f, -0.05192829f, -0.19091612f, -0.09130155f, -0.10626511f, 
    -0.04257492f, -0.05714361f, -0.04695875f, -0.07414541f, 0.15978962f, -0.29852188f, 0.00154910f, 0.49147701f, 
    -0.05874166f, -0.01862202f, 0.09486364f, -0.05186191f, -0.16778581f, -0.17552806f, 0.01452758f, 0.10020178f, 
    0.08996917f, -0.03510932f, 0.08759748f, -0.04860244f, 0.18791987f, -0.02509082f, -0.09485473f, -0.18074143f, 
    0.23269559f, 0.13201997f, -0.08116847f, -0.18125406f, 0.10912778f, -0.05785086f, 0.10063948f, 0.09320693f, 
    -0.37961850f, 0.03815558f, 0.03134450f, 0.10249509f, 0.13940983f, 0.00468708f, 0.07871936f, 0.04319705f, 
    0.09914463f, -0.10838024f, 0.15285510f, -0.25312096f, 0.11441139f, 0.01871059f, 0.11801339f, 0.05000989f, 
    -0.00138227f, 0.13741541f, 0.00063084f, -0.09762563f, 0.06804270f, 0.13524120f, 0.14720742f, -0.08936020f, 
    0.06419295f, 0.04947020f, 0.04635847f, -0.00480846f, -0.18176273f, -0.02500656f, 0.15226121f, 0.13408332f, 
    0.11801758f, -0.07595231f, 0.03631136f, -0.04084915f, -0.08629673f, -0.08260803f, -0.27081975f, -0.07305361f, 
    0.13355269f, 0.04389489f, -0.07115751f, 0.06077563f, 0.16853334f, -0.23198587f, -0.04101256f, -0.27439135f, 
    0.04784896f, -0.03256639f, 0.08655041f, 0.05750849f, 0.06983322f, 0.08458179f, -0.53958195f, -0.55419081f, 
    -0.00003468f, 0.12746002f, 0.07767541f, -0.03933063f, -0.05743187f, 0.07482510f, -0.19457133f, 0.22549661f, 
    -0.07252265f, 0.08057743f, 0.09087284f, 0.02265581f, 0.09469178f, -0.01393724f, 0.05567541f, 0.01136798f, 
    -0.43389004f, 0.02213435f, -0.10201450f, 0.15069315f, 0.00444992f, -0.07595637f, -0.00471315f, 0.03537039f, 
    0.03800457f, 0.08509433f, -0.14149079f, 0.00699334f, -0.00024396f, 0.02910861f, -0.23666482f, -0.04446339f, 
    0.11318611f, -0.01722926f, -0.35158202f, 0.03627110f, -0.01731966f, 0.16588400f, -0.12415944f, -0.01338447f, 
    -0.12852333f, -0.07070440f, 0.08286691f, 0.01384109f, -0.59244782f, -0.18670037f, 0.06034748f, -0.07339050f, 
    -0.00575950f, 0.08447183f, 0.01891845f, 0.08895979f, -0.22048600f, -0.08711170f, -0.08380155f, 0.13519543f, 
    -0.06759029f, -0.09834655f, -0.03117831f, -0.11258122f, 0.09809225f, 0.21017656f, 0.09797158f, 0.05161332f, 
    -0.04924722f, 0.03974340f, 0.06038078f, -0.10972250f, 0.01733575f, 0.12203573f, -0.13228671f, -0.15085573f, 
    -0.20547818f, 0.01925316f, 0.01771758f, 0.21915874f, -0.04636766f, -0.01184247f, -0.12391804f, 0.12637852f, 
    0.18266012f, 0.13915947f, 0.01043590f, 0.00879530f, -0.06294964f, 0.04157413f, -0.04292497f, 0.01815706f, 
    0.02096057f, -0.04234781f, -0.00395763f, -0.01780908f, 0.01432965f, 0.02905207f, -0.04399716f, 0.04556788f, 
    0.02583968f, -0.00336987f, -0.00734441f, 0.04935599f, -0.05258399f, -0.01129284f, -0.05923529f, 0.04472950f, 
    -0.00453947f, 0.04177512f, -0.06675056f, 0.02326818f, -0.04620954f, 0.02746269f, 0.04183467f, -0.03931572f, 
    0.01831930f, 0.03051849f, 0.03995244f, -0.03646500f, 0.04235253f, 0.03377229f, -0.03348318f, 0.04627547f, 
    -0.01856554f, -0.01797388f, -0.06092856f, -0.04032380f, 0.03091009f, -0.06283992f, -0.02769383f, -0.03424791f, 
    -0.04188175f, 0.00299299f, -0.02492226f, -0.02372792f, -0.02421309f, 0.04874923f, 0.02454315f, -0.00716993f, 
    -0.01800078f, 0.04847104f, -0.05048477f, 0.04261480f, -0.04494458f, 0.00521389f, -0.00970924f, -0.05920196f, 
    0.02001656f, 0.04378207f, -0.00286878f, 0.02736135f, -0.01440022f, 0.02158788f, -0.01922641f, 0.04807959f, 
    0.00650798f, -0.00080566f, 0.04966358f, -0.02877505f, -0.04757003f, 0.02564666f, -0.06411379f, -0.04173226f, 
    0.00060006f, 0.04710669f, 0.03700120f, -0.01515945f, 0.00804777f, -0.03336091f, -0.07021239f, 0.01384995f, 
    0.00202628f, -0.00100959f, 0.02043180f, -0.04185477f, -0.05835425f, -0.05685506f, -0.05730450f, -0.02583629f, 
    0.02650893f, -0.01898678f, 0.01955066f, 0.02667679f, -0.06179212f, 0.00723541f, 0.02755225f, -0.02764663f, 
    -0.03525982f, -0.02254491f, -0.01406493f, -0.00495616f, -0.02393362f, -0.03360503f, -0.04934536f, -0.02591453f, 
    -0.00862682f, 0.00168829f, 0.04711797f, -0.00943662f, 0.00257332f, -0.03232296f, 0.03560028f, 0.03441873f, 
    0.02438155f, 0.00669139f, -0.01536239f, -0.04369900f, -0.02207468f, -0.02099205f, -0.05304758f, 0.02697134f, 
    0.02078741f, -0.00707109f, 0.01815367f, -0.04800038f, 0.00526086f, -0.02836289f, 0.00383262f, -0.05227675f, 
    -0.03563235f, -0.05690712f, 0.03684312f, 0.00361424f, 0.03542230f, 0.00840902f, -0.06530943f, -0.02504887f, 
    -0.04481998f, -0.04526037f, 0.03120720f, -0.03969885f, 0.00462486f, -0.06715420f, -0.01619737f, -0.01325286f, 
    -0.06264286f, -0.01824591f, -0.00079883f, -0.00279880f, -0.01329074f, -0.03938981f, 0.00637434f, -0.04716365f, 
    -0.00021294f, 0.04706741f, 0.04007120f, -0.03855349f, -0.02678612f, 0.03655864f, 0.04155788f, 0.04701167f, 
    -0.02934893f, 0.01319042f, 0.01172563f, -0.06290863f, 0.04692635f, 0.05221958f, -0.01818240f, -0.03293953f, 
    -0.02795610f, -0.04372691f, -0.01025388f, 0.05092160f, 0.03634097f, 0.00255835f, 0.04233908f, -0.00208194f, 
    -0.03997282f, 0.03452517f, -0.06540618f, -0.02427586f, -0.00858037f, -0.00973990f, -0.05953447f, -0.05519356f, 
    0.05190542f, -0.05161859f, 0.00879580f, 0.02594960f, -0.02677215f, -0.04603159f, -0.00836855f, -0.03799560f, 
    0.05038628f, -0.02557310f, -0.04552864f, 0.04679679f, -0.01575990f, 0.00144713f, 0.03127960f, 0.00847189f, 
    0.04096349f, -0.06003153f, -0.05906604f, 0.05452330f, 0.00507954f, -0.04490424f, 0.03836831f, -0.01168171f, 
    0.04623410f, -0.02780557f, -0.05378248f, -0.04212508f, -0.03711895f, -0.04136000f, 0.00321754f, -0.00056039f, 
    -0.01010823f, 0.02080772f, -0.04599773f, -0.04409559f, -0.03641475f, -0.02663147f, 0.04703882f, -0.04503378f, 
    -0.02904435f, -0.07427819f, 0.03946440f, -0.05613263f, -0.00878420f, -0.02249205f, 0.04786504f, -0.01646506f, 
    -0.05932685f, -0.05008120f, 0.02266066f, -0.04297900f, -0.02926417f, 0.04177293f, -0.00403571f, -0.02333422f, 
    -0.04223026f, 0.04631430f, 0.00239919f, -0.02363792f, -0.00994382f, -0.05982989f, 0.01156795f, 0.05763902f, 
    0.02871497f, -0.02309194f, -0.02628358f, 0.00994739f, 0.03242386f, 0.03567288f, 0.02146745f, -0.02440066f, 
    -0.02413174f, 0.01125896f, -0.04585970f, 0.02824885f, 0.02102506f, -0.05054327f, -0.02289144f, 0.03588975f, 
    0.03471333f, 0.02502921f, -0.00682663f, -0.00051700f, -0.00075851f, 0.02112931f, 0.02265053f, -0.02338802f, 
    0.05010871f, -0.01726624f, -0.03180374f, -0.05754916f, -0.02694353f, 0.02086210f, -0.05057672f, 0.00940134f, 
    -0.03407743f, 0.03979921f, 0.04252442f, 0.00228877f, -0.00935857f, 0.05004490f, 0.03271842f, -0.04484779f, 
    0.14367163f, -0.06738937f, -0.18547641f, 0.03536280f, -0.04803891f, -0.06985081f, -0.03891671f, -0.00038716f, 
    0.12328222f, -0.12755430f, 0.09607877f, -0.05658433f, -0.02441793f, 0.11951675f, -0.02147575f, -0.11596620f, 
    0.00757369f, 0.04101012f, 0.20941815f, 0.18145491f, -0.28290403f, -0.10915000f, -0.08337594f, 0.06631254f, 
    0.17167859f, 0.05124434f, 0.10001613f, -0.09642069f, -0.15344565f, -0.01318376f, -0.02342476f, -0.01961348f, 
    -0.13535550f, 0.00844316f, 0.02341284f, 0.20189336f, 0.20919302f, 0.06285333f, 0.06181538f, 0.11936326f, 
    -0.04535625f, -0.04703785f, -0.03392259f, -0.08523572f, -0.09389760f, -0.34181687f, -0.13139236f, -0.08490766f, 
    0.16967194f, 0.01172560f, 0.01923571f, -0.10716476f, 0.05750082f, -0.01260797f, 0.26105049f, -0.05995934f, 
    0.07878444f, 0.03550423f, 0.04342165f, 0.16592140f, -0.00944767f, 0.07363559f, -0.05771003f, 0.10241557f, 
    0.10259605f, 0.06327398f, -0.02014140f, 0.12261873f, 0.11889722f, -0.03645556f, 0.19673584f, -0.05828453f, 
    -0.13127083f, 0.01376456f, 0.12682553f, 0.14648826f, 0.13213409f, 0.11543606f, -0.25037211f, 0.06446695f, 
    0.03331787f, -0.15422785f, 0.03284556f, -0.06317019f, -0.08668417f, 0.20028447f, -0.01985511f, 0.07353120f, 
    0.11673929f, -0.06878147f, -0.25466821f, -0.02600851f, 0.18673149f, 0.02011383f, -0.02103670f, 0.05278879f, 
    -0.04589228f, 0.11078601f, 0.10287650f, -0.01869806f, -0.02045905f, -0.00416442f, -0.03310327f, 0.04370295f, 
    0.09667209f, 0.20481689f, -0.11445466f, -0.11714800f, -0.04129443f, -0.09347375f, -0.20343170f, -0.07715489f, 
    -0.08859874f, 0.01562538f, 0.02199545f, -0.03577472f, 0.29211509f, 0.03668500f, 0.06567145f, -0.05218454f, 
    -0.09035452f, 0.03557158f, 0.08247126f, -0.13519996f, -0.00236883f, -0.09431797f, 0.10668301f, 0.16942996f, 
    0.09348984f, 0.00081200f, -0.04373073f, -0.12642202f, 0.11772530f, -0.03422551f, 0.06375566f, 0.13918705f, 
    0.01933362f, -0.12336546f, 0.06560724f, 0.06961332f, 0.08915175f, -0.03967525f, 0.07037760f, -0.14947301f, 
    0.05787762f, -0.14475200f, 0.01942021f, 0.06127216f, -0.00258690f, -0.09952909f, -0.01267430f, 0.00120152f, 
    0.14518724f, -0.03058493f, -0.11550103f, 0.00921221f, -0.05342864f, 0.13328417f, 0.12672378f, -0.07931647f, 
    -0.01064122f, -0.04463917f, 0.04576763f, -0.07306396f, -0.08075431f, 0.07883499f, 0.01227611f, -0.10642762f, 
    -0.02797221f, -0.06959356f, -0.17200030f, 0.05679460f, -0.08830351f, 0.03906408f, 0.09162588f, 0.23528577f, 
    -0.02392215f, -0.04543745f, 0.08763953f, 0.00408637f, 0.17261972f, -0.15108523f, -0.16941440f, 0.13499169f, 
    0.08121436f, 0.16394342f, -0.02263377f, -0.07471066f, -0.13120697f, 0.18377186f, -0.10972013f, 0.00336986f, 
    0.01177694f, -0.07316747f, 0.01152194f, 0.10761055f, 0.13616812f, 0.03692774f, -0.07170793f, -0.21967845f, 
    -0.19907671f, 0.05179909f, 0.01795150f, 0.07449339f, -0.04646734f, -0.02511304f, 0.25040346f, 0.07296636f, 
    0.04299099f, -0.23889802f, -0.06677052f, -0.07526097f, 0.01038222f, -0.00722863f, -0.00650856f, -0.12735474f, 
    0.07924110f, -0.25491479f, -0.05271972f, -0.02246716f, 0.04293427f, 0.01768149f, -0.05016367f, 0.04573854f, 
    0.09294505f, 0.08102287f, 0.20612217f, -0.07265180f, 0.17524453f, -0.26682773f, -0.07509127f, 0.08205992f, 
    -0.02482766f, 0.20023091f, 0.23122117f, -0.12024259f, 0.05788011f, -0.05883482f, 0.01266886f, 0.24886805f, 
    -0.15296291f, 0.23675488f, -0.03024988f, 0.06204761f, -0.29889598f, -0.15366457f, 0.02306533f, -0.18398456f, 
    0.10543475f, -0.00484224f, 0.05091809f, 0.08397789f, -0.00796182f, -0.03030986f, -0.18681706f, -0.00884136f, 
    -0.18881349f, -0.06248014f, -0.02237394f, -0.05032862f, -0.01676176f, 0.13652799f, 0.00947715f, -0.16631646f, 
    -0.00202165f, 0.20451145f, -0.22566800f, -0.06076386f, 0.13303925f, 0.09702325f, 0.07960840f, -0.17170660f, 
    0.09047972f, 0.15402573f, -0.05055934f, 0.00554538f, -0.00043633f, -0.04214422f, -0.10631279f, 0.01860782f, 
    0.13069007f, -0.17130794f, 0.07002475f, 0.08183534f, -0.17320865f, -0.01971409f, -0.05920610f, 0.13491499f, 
    0.01721463f, 0.16501915f, -0.25217846f, -0.13538948f, 0.05100416f, -0.01795177f, 0.04472904f, 0.14633228f, 
    -0.02823535f, -0.03252334f, 0.01641665f, 0.08721984f, -0.01570318f, 0.11872984f, -0.02281475f, -0.03426725f, 
    0.06207670f, -0.03776834f, -0.02843112f, 0.07051247f, 0.00439448f, -0.07767414f, -0.02085866f, -0.08681613f, 
    -0.07363696f, 0.01703284f, 0.10240474f, -0.01669037f, -0.00559129f, 0.06948400f, -0.01917611f, 0.24383074f, 
    0.11974900f, -0.01793455f, 0.09308742f, -0.23342426f, -0.20119944f, 0.11819862f, 0.06935755f, -0.18255042f, 
    0.01067148f, 0.24144037f, 0.04966718f, 0.03665931f, 0.12489276f, -0.04859931f, -0.01611329f, -0.04029670f, 
    -0.04560126f, 0.14489047f, 0.04921485f, 0.15715146f, 0.02121237f, -0.08765871f, 0.31650010f, 0.14031507f, 
    0.17650822f, 0.17590709f, -0.02775889f, -0.08169875f, 0.06223302f, -0.03191528f, 0.17309488f, 0.04707376f, 
    0.15768658f, 0.08310422f, -0.02717642f, -0.07601862f, -0.09164583f, 0.08241163f, 0.08724876f, 0.14548084f, 
    -0.10190179f, -0.03173085f, 0.20366853f, 0.05885660f, -0.04208019f, -0.06679919f, -0.01158265f, -0.02868181f, 
    -0.01673214f, -0.10545366f, -0.04589308f, -0.04707335f, -0.03482608f, -0.03982616f, -0.00022455f, -0.08679435f, 
    -0.03263405f, 0.20930366f, -0.17436028f, 0.16010016f, 0.00779236f, -0.05541873f, -0.12141033f, 0.09013354f, 
    0.02877096f, 0.02373957f, -0.14524849f, 0.08947769f, 0.05540049f, 0.13817541f, -0.18795988f, 0.03367733f, 
    -0.19394866f, -0.06680577f, -0.01392283f, 0.04794687f, -0.32746214f, -0.01530822f, -0.00876925f, 0.08866050f, 
    0.01359649f, -0.15367374f, -0.03118665f, 0.13694426f, -0.01602148f, 0.12278837f, 0.09130559f, -0.12608123f, 
    0.06428748f, 0.08877861f, 0.10869886f, 0.16486394f, 0.02929354f, -0.05189198f, 0.11622754f, 0.18920106f, 
    -0.04709669f, -0.04142206f, 0.03895242f, -0.10658582f, -0.08183574f, 0.07287984f, 0.09361351f, 0.22918206f, 
    0.02241925f, -0.23662005f, -0.16690925f, 0.05588206f, 0.07204030f, 0.04075470f, 0.02908048f, 0.01733933f, 
    -0.05623029f, -0.37890667f, -0.11291671f, 0.13804704f, 0.12004743f, 0.08758777f, 0.06511187f, -0.10488506f, 
    -0.02204707f, 0.31346378f, 0.00635110f, 0.00329679f, -0.01069475f, -0.18918456f, -0.00087274f, 0.07808084f, 
    0.08079935f, -0.12634633f, -0.14239082f, 0.02516497f, -0.13899678f, -0.05835722f, 0.05534599f, -0.01860129f, 
    -0.00757175f, 0.04497392f, 0.00606944f, 0.11551830f, -0.05352517f, -0.07335660f, -0.02292625f, -0.08972556f, 
    -0.02996058f, 0.13129701f, 0.09428268f, -0.16600251f, 0.36907706f, -0.02656828f, 0.07630998f, -0.05882643f, 
    -0.06808697f, -0.05049507f, 0.09256282f, -0.11693830f, 0.00434781f, 0.41964123f, 0.02132342f, 0.05906429f, 
    -0.03078508f, -0.04366626f, -0.00436914f, 0.00924807f, -0.04679319f, -0.08668131f, -0.14923994f, -0.21099408f, 
    0.06946945f, 0.01197428f, 0.11321674f, 0.06359944f, -0.05008839f, 0.04100302f, -0.06122996f, -0.11861576f, 
    0.02842440f, -0.07732517f, -0.10997829f, -0.23355970f, -0.26086944f, 0.04620942f, 0.12889431f, 0.06445337f, 
    0.19087748f, -0.03023717f, 0.06769074f, 0.07119368f, 0.02642755f, 0.04767055f, 0.13364394f, 0.05625070f, 
    0.04855358f, -0.07579399f, 0.01932772f, 0.04398389f, -0.12725538f, -0.06728034f, 0.11753511f, -0.06534947f, 
    0.15931112f, 0.04639273f, -0.11810376f, -0.40300491f, 0.13629816f, 0.10224944f, 0.21575736f, 0.04243421f, 
    0.11693075f, 0.00024367f, 0.00113422f, 0.05734185f, -0.12686974f, 0.05970613f, 0.09909410f, 0.01583121f, 
    0.01249750f, -0.00363356f, -0.05284179f, -0.03440171f, 0.03122986f, -0.51749927f, 0.13990381f, 0.08495630f, 
    0.08405851f, 0.00987907f, 0.07080156f, -0.11780320f, -0.02714798f, 0.03949042f, -0.01118027f, -0.04362090f, 
    0.07818226f, 0.09290419f, -0.09041795f, -0.05014521f, -0.00476650f, 0.07470340f, -0.18148050f, 0.06662328f, 
    -0.00309403f, -0.15912105f, -0.12398884f, 0.09263628f, 0.10765621f, 0.03679515f, 0.03840316f, 0.37557784f, 
    0.15803002f, -0.05154746f, -0.20598580f, -0.04784372f, -0.02378666f, 0.02454992f, 0.09476576f, -0.03930717f, 
    0.02816979f, -0.03455997f, -0.06017715f, -0.04732203f, -0.01419921f, 0.03466593f, 0.02500369f, 0.02928633f, 
    -0.04497331f, -0.00311066f, -0.06040095f, -0.01755763f, 0.02548439f, -0.02598225f, -0.01791552f, 0.03481357f, 
    0.04775525f, -0.04248685f, -0.03409709f, -0.06047154f, -0.01214169f, -0.02506248f, 0.01372163f, -0.01700607f, 
    0.02590965f, -0.05196711f, -0.03402394f, 0.02466498f, -0.04209180f, -0.06477481f, 0.02162771f, 0.04805678f, 
    -0.05529102f, -0.03426137f, -0.01643256f, 0.04359652f, 0.02769963f, 0.02022609f, -0.04810722f, 0.04363642f, 
    0.04732264f, -0.05285229f, -0.01437700f, -0.03114670f, 0.04088730f, -0.04440916f, 0.00362166f, 0.02342158f, 
    0.05449799f, -0.04951620f, 0.03813882f, 0.05080798f, 0.04374314f, -0.02419496f, 0.01908610f, -0.02320278f, 
    -0.02356794f, 0.02056177f, -0.06276961f, 0.01767331f, 0.03051270f, 0.03916045f, -0.03990848f, 0.00400173f, 
    0.06098057f, -0.04981223f, -0.05714150f, -0.06233174f, -0.06187294f, -0.01217807f, -0.03331422f, 0.04734412f, 
    -0.01042463f, -0.06240911f, 0.02033335f, -0.02553134f, -0.04503241f, 0.04344661f, 0.01634444f, 0.01554380f, 
    -0.04405622f, -0.04647004f, -0.04302254f, 0.01766787f, 0.03017861f, 0.00126052f, -0.01345335f, -0.04356387f, 
    -0.01791029f, -0.06472220f, -0.03046270f, -0.05298153f, -0.01218593f, 0.00402896f, -0.05190606f, -0.01155287f, 
    0.01117046f, -0.00918883f, 0.00664047f, -0.05442504f, -0.05399169f, 0.04317383f, -0.06196503f, -0.06265195f, 
    0.00713264f, 0.04989047f, 0.04310736f, -0.01910256f, -0.03191276f, 0.04147354f, -0.00266156f, 0.03467632f, 
    -0.04777432f, 0.04836088f, 0.00896226f, -0.01125748f, -0.04409890f, 0.01905792f, 0.00864865f, -0.03185387f, 
    -0.02194015f, -0.00486654f, 0.03587977f, 0.01677811f, -0.03466159f, -0.06419698f, 0.01724339f, 0.02570273f, 
    0.01436847f, -0.00371462f, -0.05784904f, 0.04727959f, -0.06082850f, 0.01993905f, 0.01450030f, -0.03645502f, 
    0.00670286f, 0.04959274f, -0.00026190f, 0.01185000f, 0.02222491f, -0.00707750f, -0.04221917f, 0.03690506f, 
    0.02868090f, -0.02177776f, 0.01670667f, 0.04070315f, 0.00317891f, 0.00027852f, -0.01783997f, -0.04137841f, 
    0.00656884f, -0.01759688f, 0.01384305f, -0.01845043f, 0.01983621f, 0.04491711f, 0.02867953f, 0.03957708f, 
    0.00616343f, 0.00016574f, -0.00083976f, -0.01923750f, 0.02567866f, -0.04154833f, 0.00654386f, -0.04979193f, 
    0.00930756f, -0.00597458f, -0.05646685f, 0.04158793f, 0.01634737f, -0.02351855f, -0.00247556f, 0.04061259f, 
    -0.02887440f, 0.03211844f, 0.05793913f, -0.02500080f, 0.04307642f, 0.03416905f, -0.01217425f, 0.04430960f, 
    0.05140916f, -0.05871697f, -0.05978764f, -0.05188730f, 0.01252859f, -0.03181310f, 0.01751446f, -0.01875498f, 
    -0.02063184f, -0.01741580f, 0.01010542f, -0.03942245f, 0.04286047f, -0.00830187f, 0.01470790f, -0.01549419f, 
    0.04666305f, -0.03226675f, -0.01952263f, 0.00310497f, -0.00074109f, -0.00191288f, 0.00727327f, -0.01065514f, 
    0.04620002f, -0.06257434f, -0.03611274f, -0.05736056f, -0.02291822f, -0.00618618f, -0.02038393f, -0.03612386f, 
    0.06455489f, -0.01145772f, 0.01919550f, -0.04655436f, -0.04006625f, 0.01834472f, 0.04992341f, -0.05471876f, 
    -0.04053188f, -0.01612961f, -0.03503938f, 0.00343115f, 0.03918722f, -0.04880438f, -0.06196570f, -0.03819269f, 
    -0.02885349f, -0.02955255f, 0.00425843f, -0.01744055f, 0.03626524f, 0.00630578f, 0.03601740f, 0.02601342f, 
    -0.01756558f, 0.00525602f, 0.00932485f, -0.02134770f, 0.00077002f, 0.01649110f, -0.00813657f, -0.04610479f, 
    -0.04839128f, 0.00119798f, 0.04542403f, 0.00119061f, -0.04872759f, -0.05470847f, 0.04292922f, 0.00815363f, 
    -0.01774029f, 0.02368119f, -0.05196273f, -0.06043928f, -0.05275190f, -0.01566772f, 0.03785146f, -0.03519061f, 
    -0.02104733f, 0.04863533f, 0.00583894f, -0.01733723f, -0.04592344f, 0.00273712f, -0.04853979f, -0.04472036f, 
    0.03408262f, -0.06056222f, -0.04772082f, 0.04713004f, -0.04438908f, -0.01019868f, 0.01482488f, -0.00515529f, 
    -0.04783934f, 0.02743887f, -0.03438986f, 0.00758780f, -0.02893826f, 0.00652589f, -0.03287984f, -0.01299986f, 
    -0.00747441f, 0.00496670f, 0.01795549f, 0.03493835f, -0.02069293f, -0.04576840f, -0.03891041f, -0.00435600f, 
    -0.05852583f, -0.00633685f, -0.05129540f, 0.05222031f, 0.04568385f, -0.02427813f, 0.01269368f, -0.00985753f, 
    0.00059944f, 0.03798790f, -0.03902787f, 0.04633372f, -0.04394932f, 0.04338188f, 0.01744796f, 0.01447092f, 
    -0.00028039f, 0.03399359f, -0.04241979f, -0.05202395f, -0.06114804f, -0.05623040f, -0.00069145f, -0.05137027f, 
    0.03734213f, -0.04464410f, -0.02729215f, -0.02069019f, -0.03793709f, -0.05944862f, 0.04152187f, -0.04946523f, 
    -0.02639663f, -0.02821707f, 0.02586126f, -0.02925564f, -0.00515596f, 0.03308043f, 0.01718808f, -0.02559624f, 
    0.04837551f, 0.01207472f, -0.00769170f, 0.01696505f, 0.04736941f, -0.00715712f, 0.00709280f, -0.05921750f, 
    0.04560489f, 0.03034360f, 0.02383044f, -0.03971834f, -0.03892434f, 0.00682169f, 0.05203191f, 0.03192251f, 
    -0.04491341f, 0.00025381f, -0.03354086f, -0.05302979f, -0.03155103f, -0.05142575f, -0.05400781f, 0.02372825f, 
    0.04957530f, 0.00644668f, 0.03566153f, -0.02907442f, 0.03664886f, -0.05551647f, -0.06073424f, -0.02070914f, 
    -0.00894310f, -0.00610519f, 0.03567265f, -0.04322205f, 0.03622253f, 0.00440948f, 0.00004759f, -0.04180811f, 
    0.03044090f, -0.06200030f, 0.05643282f, -0.00074826f, -0.05179294f, 0.02511659f, 0.02533164f, 0.05302499f, 
    0.03956504f, 0.04854443f, -0.03149619f, 0.01248556f, 0.03032840f, 0.00891323f, -0.03932617f, 0.00093621f, 
    0.00092665f, 0.04082366f, 0.01138161f, 0.01646551f, 0.01227995f, -0.04959932f, 0.02042335f, -0.03764927f, 
    -0.06065141f, -0.04387325f, 0.00371561f, -0.06280445f, -0.04748349f, 0.04409618f, 0.02889402f, 0.03948707f, 
    0.01941323f, -0.04258886f, 0.02663857f, 0.00783058f, 0.00609500f, 0.03516959f, -0.03150281f, -0.02366538f, 
    -0.02215779f, 0.04359858f, -0.04064341f, 0.00949075f, 0.01213989f, -0.02750060f, -0.02440224f, -0.02838114f, 
    -0.03727962f, 0.04786897f, -0.05373088f, -0.05631332f, -0.04325303f, -0.02601702f, -0.03963934f, -0.00689846f, 
    -0.05871127f, 0.05284696f, 0.05222685f, -0.04946392f, -0.00941188f, -0.05165306f, -0.00227512f, -0.03477065f, 
    -0.04589375f, 0.04810379f, -0.00949618f, -0.03075989f, 0.00695895f, -0.06016441f, 0.00730946f, 0.01611412f, 
    0.04564794f, -0.03726300f, -0.00646814f, 0.03329609f, -0.01998706f, -0.03228645f, -0.05315721f, -0.01614378f, 
    0.03165762f, -0.01790668f, -0.01136021f, -0.03588443f, -0.05515064f, 0.01693654f, -0.00350153f, 0.02049933f, 
    0.02731288f, 0.00282422f, -0.03254766f, -0.02235986f, -0.00545729f, -0.04789304f, -0.04475413f, -0.00635518f, 
    0.02754313f, 0.01916410f, -0.03847081f, 0.01034217f, -0.04131605f, -0.05964385f, 0.01184520f, 0.05208812f, 
    -0.05962374f, -0.05029266f, 0.04288092f, 0.00367507f, -0.03752195f, -0.00357892f, 0.00966981f, 0.03964077f, 
    -0.04594447f, -0.01045121f, -0.03016430f, 0.00063168f, -0.03780686f, 0.04917700f, -0.05538548f, 0.04532771f, 
    0.01058597f, 0.01619389f, -0.06167915f, 0.00974157f, -0.01572838f, -0.05199756f, -0.04776999f, 0.00162801f, 
    0.03377332f, -0.02937887f, 0.01363816f, 0.01532104f, -0.01945426f, 0.04558294f, 0.03352320f, 0.00742276f, 
    0.03409879f, -0.05542350f, -0.01696560f, -0.02019110f, 0.03480202f, 0.01222639f, -0.03904005f, -0.03987639f, 
    0.02892852f, -0.00848393f, 0.01660232f, 0.02920435f, -0.04745391f, 0.03556084f, 0.00678032f, 0.04386418f, 
    -0.04150077f, 0.04315583f, -0.02900198f, -0.02569673f, -0.05330447f, -0.04180409f, -0.01932449f, -0.03683355f, 
    -0.00863723f, -0.01334117f, 0.05097665f, -0.02730455f, -0.02739432f, -0.04711048f, 0.02405710f, -0.05670831f, 
    -0.04155803f, 0.00621751f, 0.02756141f, 0.01279425f, -0.03800599f, -0.06631395f, 0.02963929f, 0.03267946f, 
    -0.04238310f, 0.03649277f, 0.01513980f, -0.02381691f, 0.02303116f, -0.00096743f, -0.03854293f, -0.03457787f, 
    -0.04226820f, -0.01803592f, -0.00454835f, 0.04169761f, -0.00008539f, 0.05102275f, 0.03907778f, -0.03537939f, 
    -0.06064820f, -0.03142184f, -0.03050957f, -0.06054093f, -0.00544462f, -0.00490999f, -0.06022952f, -0.01264882f, 
    0.17308213f, -0.26059076f, 0.05357098f, 0.02488193f, -0.05037008f, -0.08625713f, 0.11500886f, 0.11979452f, 
    -0.05000765f, -0.09014455f, 0.02020855f, -0.13576083f, -0.06241788f, -0.22717772f, 0.03755939f, 0.20363469f, 
    -0.03927122f, 0.02354404f, 0.00537485f, -0.04102246f, -0.06233625f, 0.08663197f, 0.02796473f, 0.02812635f, 
    0.06129197f, 0.03101526f, -0.03123903f, 0.18316700f, 0.02657828f, 0.05954152f, -0.13211693f, 0.05493459f, 
    -0.00862612f, 0.02845889f, 0.04076122f, -0.08224165f, 0.03313763f, 0.06206721f, -0.16626894f, 0.11221281f, 
    0.05830839f, 0.01880494f, -0.00393955f, 0.00100560f, -0.07850834f, 0.20221402f, -0.09808064f, -0.01610942f, 
    -0.30428901f, 0.05373422f, -0.02456239f, 0.15373196f, 0.10230508f, 0.01388716f, 0.08857156f, 0.22185428f, 
    0.09920929f, -0.09669559f, 0.00178989f, 0.05533992f, -0.09980926f, -0.08065218f, 0.08632989f, -0.02642754f, 
    -0.05119739f, 0.25763234f, -0.02825334f, 0.11268117f, -0.04237537f, -0.11778773f, 0.21210672f, 0.04238805f, 
    -0.33049366f, -0.19731601f, 0.15648629f, 0.07582537f, 0.09586945f, 0.01666677f, 0.16026264f, 0.15550561f, 
    -0.03292850f, -0.15874431f, -0.31906918f, -0.03750949f, -0.05220710f, 0.10529988f, 0.13081305f, 0.05622911f, 
    0.14737646f, -0.02353611f, 0.10444654f, 0.19711995f, 0.48829260f, -0.00409940f, 0.12150461f, 0.01679521f, 
    0.01812879f, 0.08040074f, 0.11300484f, -0.23988301f, -0.08292700f, 0.12059102f, -0.19281107f, 0.12905492f, 
    0.02667098f, 0.19582267f, 0.09212154f, -0.02429092f, 0.29607388f, 0.08233812f, -0.22220203f, -0.03544063f, 
    -0.02553646f, -0.01183039f, 0.23873986f, -0.01796073f, -0.02956987f, 0.09193185f, 0.02495400f, 0.05729997f, 
    -0.22989018f, 0.03537031f, 0.20490497f, -0.04819587f, -0.17773366f, 0.05873922f, 0.36693993f, 0.21583652f, 
    0.09075800f, 0.08609383f, -0.00155494f, 0.00268882f, -0.03006628f, -0.19666956f, 0.02629522f, 0.15095797f, 
    -0.02531798f, -0.01305767f, 0.22504306f, -0.04462841f, 0.10634243f, -0.03016119f, 0.06515078f, -0.10360022f, 
    0.08278678f, 0.17351952f, 0.09062719f, -0.02690534f, 0.08313899f, 0.01811063f, 0.06948067f, 0.01761885f, 
    -0.05596514f, -0.20783144f, -0.11544849f, 0.07780568f, 0.04261805f, -0.01478432f, -0.09119384f, 0.00317816f, 
    0.01045114f, 0.25292274f, -0.00316195f, 0.01509878f, -0.00674059f, 0.15195277f, -0.05584287f, 0.17760742f, 
    -0.03840670f, -0.06701937f, -0.00035798f, -0.21367370f, -0.11613426f, 0.03006144f, -0.20256294f, -0.03707160f, 
    -0.08446109f, 0.07964694f, 0.00962785f, 0.20253575f, 0.31698012f, -0.23858072f, -0.13346002f, 0.05171334f, 
    0.10521305f, -0.15234089f, 0.03363234f, -0.31276858f, 0.08215662f, -0.15721492f, 0.08570251f, 0.00302665f, 
    0.05872208f, -0.03667864f, -0.01606643f, -0.03518220f, 0.00746705f, 0.03236994f, 0.12254552f, -0.05983540f, 
    -0.04909560f, 0.00247676f, 0.03559367f, -0.12679210f, 0.11397916f, 0.04717363f, 0.06885885f, -0.42551690f, 
    -0.15164988f, 0.05090456f, -0.17255898f, -0.12877448f, -0.11228896f, 0.18108270f, 0.05113376f, 0.16298307f, 
    -0.13030468f, 0.17388004f, 0.00606281f, -0.08225789f, 0.03168362f, 0.07036688f, 0.13187358f, 0.19058976f, 
    -0.02045071f, -0.29815337f, 0.24559899f, -0.71478760f, 0.05000663f, 0.05212921f, -0.07234113f, -0.24469408f, 
    0.05975004f, -0.07923792f, 0.18986434f, 0.21806057f, 0.02207522f, -0.31773022f, 0.02943772f, 0.18700576f, 
    -0.00688633f, 0.07903000f, -0.02072345f, -0.14670321f, 0.07105380f, 0.06118094f, -0.20790069f, -0.01702025f, 
    -0.00487047f, -0.08078979f, -0.08205179f, 0.09461275f, 0.13405424f, 0.20769508f, -0.02962701f, -0.20829216f, 
    -0.14595777f, 0.05392422f, -0.19521362f, 0.10430293f, 0.04348140f, 0.22751287f, 0.22359192f, -0.40974700f, 
    -0.00693181f, 0.04363809f, -0.06001355f, 0.04941330f, -0.13750462f, -0.01249432f, -0.26734194f, -0.26076642f, 
    0.06361671f, -0.01677038f, 0.13389122f, 0.06763795f, 0.04431188f, 0.09633489f, -0.07571301f, 0.14007396f, 
    0.29421717f, -0.17425422f, 0.01015806f, -0.03241901f, 0.07053148f, 0.09841368f, -0.06872518f, -0.05200728f, 
    0.11779257f, 0.10373315f, -0.05105903f, 0.02335501f, 0.03761870f, -0.21839826f, -0.03902810f, 0.05746058f, 
    -0.05188601f, -0.19376230f, 0.05808062f, 0.09828177f, -0.04354276f, -0.05170446f, -0.14899322f, -0.01516669f, 
    -0.04250966f, -0.04586544f, 0.26379940f, 0.24204941f, 0.16426925f, 0.21073173f, -0.12340542f, -0.00928590f, 
    0.00588841f, 0.20510425f, -0.00161506f, -0.15795711f, -0.16675393f, -0.09123538f, -0.06260572f, 0.07946757f, 
    -0.02127332f, -0.02740693f, 0.03135566f, 0.09451790f, 0.33381811f, 0.11746779f, 0.16898420f, 0.05673002f, 
    -0.04767805f, 0.03729045f, 0.04237628f, -0.09643361f, -0.08124985f, -0.20576113f, -0.08244333f, -0.10268141f, 
    0.06035813f, 0.15736882f, -0.19240373f, -0.10266412f, -0.00338850f, 0.13008676f, -0.02283210f, -0.24560280f, 
    -0.00075592f, 0.03445096f, -0.11007308f, 0.07756674f, -0.03146612f, -0.05230007f, -0.13378559f, 0.13076515f, 
    0.07804387f, 0.07904276f, -0.15408593f, -0.05403339f, -0.09254693f, -0.07325403f, -0.10372270f, 0.06964154f, 
    0.00897429f, 0.27856010f, 0.04741662f, 0.04805997f, -0.05341163f, 0.17582865f, -0.19240616f, -0.11365315f, 
    -0.20613423f, 0.22569907f, 0.12871602f, -0.21349007f, -0.04519685f, 0.13506435f, -0.12864529f, 0.12025229f, 
    0.04381192f, -0.00779924f, 0.14018850f, 0.05527170f, 0.18609801f, 0.02041403f, 0.00549387f, -0.06279622f, 
    -0.07752384f, 0.07543720f, 0.03646197f, -0.01232284f, 0.02573007f, 0.06907127f, -0.14417519f, 0.13816206f, 
    0.09112053f, 0.07833081f, -0.08784080f, -0.14944306f, -0.12773320f, -0.03370161f, -0.13667113f, -0.00037772f, 
    -0.03130714f, 0.05810592f, 0.09411527f, 0.03489911f, 0.06304111f, -0.11485279f, -0.23484285f, 0.04304620f, 
    0.02738814f, 0.10197989f, -0.01511982f, -0.21673910f, -0.18375385f, -0.17892654f, 0.02344155f, 0.02742873f, 
    0.16713086f, 0.09028161f, 0.07774659f, -0.09184199f, 0.04946609f, 0.19562469f, -0.04703865f, 0.26505640f, 
    0.10940854f, 0.04291784f, 0.06749173f, 0.01054905f, 0.01940104f, 0.07394631f, 0.04053808f, 0.03654916f, 
    -0.13241926f, -0.05356001f, -0.01323678f, 0.00935306f, -0.09608261f, -0.03303633f, 0.01158822f, -0.06123561f, 
    -0.05911968f, 0.03889916f, -0.14316612f, 0.10683832f, -0.09155509f, 0.04047025f, -0.02128186f, 0.01037870f, 
    -0.00118351f, -0.08545575f, 0.12582515f, 0.13347457f, 0.03790480f, 0.10152785f, -0.03998389f, -0.07557303f, 
    0.02079041f, -0.10170980f, -0.06034038f, 0.28328612f, 0.06618965f, 0.02614029f, -0.01361783f, -0.01475306f, 
    0.04381825f, -0.00869572f, 0.04566898f, -0.01559634f, 0.11902205f, 0.04720113f, 0.17518881f, -0.07653335f, 
    -0.03490154f, 0.07915933f, -0.10983440f, -0.03183632f, -0.07799322f, 0.04187561f, 0.07005935f, -0.09059099f, 
    0.00829501f, 0.01478897f, -0.18068662f, 0.07202704f, -0.03931177f, -0.03944568f, -0.34736872f, -0.19668527f, 
    -0.03177943f, -0.06166906f, 0.08389714f, 0.08898997f, -0.01269984f, -0.05916809f, 0.00625372f, 0.20018290f, 
    0.12329176f, 0.13877171f, -0.04232375f, -0.17917101f, -0.09161694f, 0.11124634f, -0.02013040f, -0.05565777f, 
    -0.05960264f, 0.15701358f, -0.23964426f, 0.04710565f, -0.20831990f, -0.04500266f, 0.05596477f, 0.02587482f, 
    0.08485732f, 0.22857274f, 0.21427044f, 0.21224444f, 0.32226843f, -0.03135067f, -0.02180188f, 0.06120834f, 
    0.04216319f, -0.09654080f, -0.03427574f, -0.23380436f, 0.00524658f, 0.05383344f, -0.07643443f, 0.10031762f, 
    -0.00551463f, 0.02970193f, -0.08081896f, -0.05721525f, -0.17898397f, 0.10034458f, -0.02224494f, -0.11920478f, 
    -0.16100571f, 0.13325559f, -0.03510549f, 0.02758741f, 0.04686501f, -0.29924843f, -0.00678553f, -0.00276403f, 
    -0.21705751f, -0.07443776f, 0.07953345f, -0.05167112f, 0.02166945f, -0.07273828f, 0.00532267f, 0.08165014f, 
    -0.02072022f, 0.15043865f, -0.09535338f, -0.03018398f, 0.07276815f, -0.04645734f, -0.12673785f, 0.01038454f, 
    0.05075561f, 0.04010159f, 0.00179712f, -0.01256115f, 0.06148303f, -0.10251082f, -0.12521257f, 0.16890846f, 
    -0.06720102f, -0.05052564f, -0.03040535f, 0.06662242f, -0.18222332f, -0.08018293f, 0.05315335f, 0.14195356f, 
    0.03171103f, -0.05210797f, -0.03848414f, -0.03609255f, 0.01639900f, -0.01268342f, 0.00392692f, -0.02693891f, 
    -0.03073464f, -0.02110319f, 0.03512494f, -0.05741375f, -0.07947067f, 0.00388114f, -0.04501582f, -0.02612996f, 
    0.04173486f, 0.04471208f, 0.00999602f, 0.01806683f, -0.00024417f, 0.01159077f, -0.01393722f, -0.02285242f, 
    -0.07015791f, -0.07657307f, -0.06532903f, 0.01901975f, -0.01973115f, 0.04857073f, -0.01003267f, 0.03449964f, 
    0.04180890f, -0.02495673f, 0.00438911f, 0.02226824f, -0.05443893f, 0.02594086f, -0.03119003f, -0.00055938f, 
    -0.07937685f, -0.06611858f, 0.01363625f, -0.04842388f, -0.05194215f, -0.07792284f, -0.06594365f, -0.03290027f, 
    -0.01965482f, -0.00119070f, -0.03995078f, -0.00734033f, -0.05000272f, 0.03115081f, -0.01936360f, -0.05241061f, 
    -0.04769109f, -0.05251036f, 0.03624254f, -0.05490466f, -0.02609617f, 0.04157237f, -0.05508317f, 0.06924817f, 
    -0.05237317f, -0.00351644f, 0.00918973f, -0.05894804f, 0.04116033f, 0.00267677f, -0.05262576f, 0.05169465f, 
    -0.05537788f, 0.03838252f, -0.05058155f, -0.02077652f, -0.06217268f, 0.00814000f, 0.01524862f, -0.00241553f, 
    0.06288487f, 0.02639098f, 0.02645803f, -0.03125561f, 0.00830427f, 0.03445803f, 0.01837165f, -0.02058310f, 
    -0.06886781f, 0.03162983f, 0.02359778f, 0.05282537f, 0.01925022f, -0.05668028f, 0.01145637f, -0.05851358f, 
    -0.06517598f, -0.04306355f, -0.04263680f, -0.00399637f, -0.06735579f, 0.00104354f, 0.02609730f, 0.02510881f, 
    0.00183991f, -0.01265418f, -0.02807266f, -0.02286679f, 0.04218701f, -0.01823278f, -0.05367408f, -0.02923964f, 
    -0.02210808f, 0.00021399f, -0.05392929f, -0.03339047f, -0.02177946f, -0.03774236f, -0.00484903f, 0.04511313f, 
    -0.05342945f, -0.02289917f, -0.00030704f, -0.04544620f, 0.02319389f, 0.00168309f, 0.00512115f, 0.02104909f, 
    -0.06734733f, -0.04286393f, -0.05547851f, -0.00881993f, 0.00615335f, -0.04358701f, -0.01205890f, 0.02325209f, 
    0.02808720f, -0.00662008f, -0.00891079f, -0.06998511f, -0.03377000f, -0.01814023f, 0.03239728f, 0.00223626f, 
    -0.02125466f, -0.00046934f, -0.02934952f, 0.01994334f, -0.05020935f, -0.07534641f, -0.00509378f, -0.02876464f, 
    -0.03498597f, -0.04529375f, 0.04603848f, -0.03525657f, -0.04295772f, -0.02571751f, 0.02195440f, -0.06941397f, 
    0.00458262f, -0.02491814f, 0.02558256f, -0.02606666f, 0.03977151f, -0.07189494f, -0.04143767f, -0.00485726f, 
    0.01966322f, -0.03129562f, 0.03074688f, -0.03475022f, 0.01607517f, -0.05197456f, -0.01344837f, -0.06469736f, 
    -0.04972688f, -0.01670806f, -0.05356628f, 0.05204162f, -0.02895256f, -0.05289898f, 0.01645243f, -0.01232836f, 
    -0.03373737f, 0.00575708f, -0.05951698f, 0.03101961f, 0.01642126f, 0.01169859f, 0.01618111f, -0.00692383f, 
    -0.06982380f, -0.02407673f, 0.00041360f, -0.01525208f, -0.05759576f, -0.02409286f, -0.00320576f, -0.06813423f, 
    0.00055647f, 0.01182470f, 0.02778260f, 0.01896960f, 0.02630643f, -0.00243059f, -0.03878587f, 0.06075137f, 
    0.01330514f, -0.00071898f, -0.04171406f, 0.00268353f, -0.02163467f, -0.05148235f, -0.02763533f, -0.04588033f, 
    -0.05002449f, 0.02124230f, 0.03404642f, 0.00663276f, -0.00245983f, 0.02496740f, 0.02911268f, -0.01812436f, 
    0.00577172f, 0.03597264f, 0.01776258f, -0.00940316f, -0.04771028f, -0.08027334f, -0.01545501f, 0.04003505f, 
    0.02612993f, -0.05462161f, -0.02105470f, -0.05772208f, -0.03297849f, -0.01050244f, 0.06016150f, -0.07858694f, 
    0.03329440f, 0.03811055f, 0.01721647f, 0.04901770f, -0.07271618f, -0.02308656f, -0.03718160f, -0.00122724f, 
    -0.04777044f, -0.06266166f, -0.02198335f, 0.02891310f, -0.00352605f, -0.01405847f, -0.04829977f, 0.01578831f, 
    0.01091930f, -0.00296170f, -0.07939404f, -0.00603897f, 0.04981494f, 0.00087446f, -0.00555800f, 0.01308327f, 
    -0.04476951f, 0.00962812f, 0.01349520f, -0.03378279f, -0.01589618f, -0.07079120f, 0.05356121f, -0.06807648f, 
    0.02480480f, 0.03061030f, -0.04626615f, -0.05155142f, -0.05966523f, -0.06806933f, -0.04148860f, -0.01811934f, 
    0.01105586f, 0.03313448f, -0.07804044f, 0.00470544f, 0.00717322f, -0.05408014f, -0.02234820f, -0.00930801f, 
    0.03769322f, -0.10079107f, -0.09242363f, -0.11271324f, 0.12870362f, -0.01092427f, 0.11260202f, -0.06292658f, 
    0.05609064f, -0.23071666f, 0.16384558f, -0.02709310f, 0.11017115f, 0.35084257f, 0.07830820f, -0.03888652f, 
    0.13254601f, 0.07425889f, 0.26687491f, -0.15256901f, -0.02770961f, -0.10404111f, 0.08424113f, 0.14564258f, 
    0.05020478f, -0.10867546f, 0.08166624f, -0.23910092f, -0.12600908f, 0.10852449f, 0.12281892f, -0.22811505f, 
    0.15142339f, -0.03544160f, -0.04557672f, -0.06865880f, 0.20688234f, -0.15968907f, 0.25105640f, 0.09282766f, 
    0.01191137f, 0.14140514f, 0.01147576f, -0.00030598f, 0.17994125f, -0.21040973f, 0.06382996f, 0.08009581f, 
    0.11534832f, -0.06993294f, 0.04908092f, 0.07297937f, -0.04905559f, 0.09607282f, -0.06668652f, -0.07076131f, 
    0.18737194f, -0.01824944f, 0.06094275f, -0.29203483f, 0.11720426f, 0.05152648f, 0.03264044f, -0.21004611f, 
    -0.09768892f, 0.14931415f, -0.10495550f, -0.04969670f, 0.06448374f, -0.00571044f, 0.05869390f, -0.01149836f, 
    -0.07742383f, 0.10202993f, 0.02775015f, 0.06353259f, 0.15274097f, -0.17047231f, 0.02968452f, -0.09958880f, 
    -0.08246640f, -0.04990058f, -0.32960954f, -0.08722876f, -0.03808732f, -0.07049283f, 0.03539714f, -0.01488246f, 
    -0.15137133f, -0.04110354f, 0.21769501f, -0.06602000f, -0.22011840f, -0.01269520f, 0.10339030f, 0.10322185f, 
    0.11753815f, -0.06239458f, 0.00711877f, 0.07595037f, -0.05514501f, 0.01294236f, 0.01007457f, -0.19618583f, 
    0.07215147f, 0.05083399f, 0.03743509f, -0.15190531f, -0.29772770f, 0.02617818f, 0.07556921f, 0.08531682f, 
    -0.00284878f, -0.01835788f, -0.03493736f, -0.02337306f, 0.02797955f, 0.31991178f, 0.12961961f, 0.19012731f, 
    -0.03690862f, -0.09465329f, -0.12975429f, -0.10002949f, 0.02917022f, 0.03578677f, 0.24031557f, 0.09156542f, 
    -0.21229661f, -0.08630038f, 0.01682449f, 0.06273321f, 0.01067323f, 0.06598389f, -0.12739597f, -0.02814411f, 
    -0.27277464f, -0.04783694f, -0.10593639f, 0.06449213f, 0.06962281f, -0.03851804f, -0.22153568f, -0.23066533f, 
    0.11787375f, -0.02921207f, 0.23337051f, 0.02420140f, 0.00570391f, -0.07939183f, -0.02774050f, 0.09345131f, 
    -0.11809526f, 0.14253405f, 0.06851253f, -0.04356081f, 0.00048789f, 0.06003101f, 0.12521857f, -0.05736221f, 
    -0.02886738f, 0.00667319f, 0.20102918f, -0.01521557f, -0.03599060f, 0.19000275f, 0.03665201f, 0.10209372f, 
    -0.09818301f, -0.25203896f, 0.14227457f, -0.23430733f, -0.08955441f, -0.03787483f, -0.00689746f, -0.09171698f, 
    -0.11177444f, 0.05075654f, 0.02726337f, -0.04346120f, 0.17273125f, -0.01416443f, -0.26847219f, 0.19695120f, 
    0.02451237f, -0.02467144f, -0.07064352f, 0.04263048f, -0.11535253f, 0.23714218f, 0.00444245f, 0.04674834f, 
    0.07033361f, -0.08361369f, 0.19005358f, 0.10909383f, -0.05690076f, 0.07601387f, -0.10193954f, 0.06663075f, 
    0.15825638f, -0.04590566f, 0.00979648f, 0.03767119f, 0.14633165f, 0.01720152f, 0.05873259f, -0.05962377f, 
    -0.18651333f, 0.04211885f, -0.09171224f, -0.07354154f, 0.09072923f, 0.08512682f, 0.02721090f, -0.06150180f, 
    0.08843429f, 0.07579666f, 0.13956258f, -0.18467671f, 0.07374771f, 0.03281743f, -0.03226964f, -0.08392154f, 
    0.06030007f, 0.18240774f, -0.36641374f, 0.18123765f, 0.03000655f, -0.09385999f, 0.31179419f, -0.00713648f, 
    -0.09520374f, 0.05588032f, -0.13323088f, 0.00092909f, 0.26286370f, -0.21691151f, -0.21744367f, -0.29103434f, 
    0.14920476f, -0.04958167f, 0.10272574f, -0.28849643f, -0.33356673f, -0.13831994f, -0.05344617f, 0.11190707f, 
    -0.05945359f, 0.11508100f, -0.16260593f, -0.07031059f, -0.18273932f, -0.04726515f, 0.32441908f, -0.20078708f, 
    0.04581114f, 0.05430425f, 0.06320488f, -0.00739617f, -0.11972577f, 0.31582257f, -0.09743706f, -0.35446918f, 
    0.07831279f, 0.23860814f, 0.00181967f, -0.14962707f, -0.07486467f, -0.03231325f, -0.05991850f, -0.01670071f, 
    -0.14406887f, 0.22369565f, 0.17703025f, 0.06858069f, 0.04169144f, -0.08963908f, -0.11627482f, -0.10244686f, 
    0.05235047f, -0.02640097f, 0.10187673f, -0.07839815f, -0.03696305f, -0.07466932f, -0.20226783f, 0.07046568f, 
    -0.03540347f, -0.01811782f, -0.01834797f, -0.01259196f, 0.02559930f, -0.05903141f, -0.00628251f, -0.05283213f, 
    -0.05577413f, -0.06560399f, -0.05068962f, -0.05774268f, 0.02692524f, 0.00302647f, -0.05716700f, -0.03519867f, 
    -0.03201010f, 0.03523438f, -0.05588292f, -0.03559170f, 0.00087849f, 0.00508204f, -0.00362348f, 0.02204273f, 
    0.00961975f, -0.01175085f, -0.03723637f, -0.06287277f, -0.02102155f, -0.03744293f, -0.00815808f, -0.05725795f, 
    0.04358810f, 0.02868748f, 0.01817115f, -0.05960679f, 0.00045492f, -0.04589256f, 0.01062490f, -0.00931673f, 
    -0.01768123f, 0.04953888f, -0.00516852f, 0.03857411f, 0.03777361f, 0.05068109f, 0.02709499f, 0.05021594f, 
    -0.05858789f, 0.04770118f, 0.03120562f, 0.02942698f, -0.05992296f, -0.01224771f, -0.03049963f, 0.04499007f, 
    -0.05789515f, -0.00330414f, -0.05208011f, -0.03267539f, -0.01980028f, 0.00121388f, 0.02466519f, 0.00341225f, 
    -0.02927276f, 0.01706310f, -0.03348188f, -0.04416605f, 0.02460817f, -0.05496974f, 0.03672558f, -0.00531581f, 
    -0.04802443f, -0.02374130f, -0.00244522f, 0.04058386f, 0.05140793f, 0.04824906f, 0.01905542f, -0.00639408f, 
    -0.00600014f, -0.05015834f, 0.04178204f, 0.03720478f, -0.04920705f, -0.00917067f, 0.04875680f, -0.05164339f, 
    -0.05779903f, -0.05939456f, 0.01579521f, -0.05143251f, 0.02841810f, 0.03429501f, 0.03694418f, -0.06171519f, 
    -0.03461378f, 0.02965990f, -0.00149447f, -0.00353582f, -0.00283958f, 0.01162906f, -0.02148628f, -0.00221263f, 
    -0.00084875f, -0.01454204f, 0.00512034f, -0.05276279f, -0.02492108f, -0.03032065f, -0.03833963f, 0.03576021f, 
    -0.02106737f, -0.05573111f, -0.00388676f, -0.01185094f, 0.03164052f, -0.01322358f, -0.05988793f, 0.02260685f, 
    -0.01219678f, 0.04524589f, 0.04777623f, -0.04458490f, 0.02829094f, -0.03045737f, -0.01802908f, -0.06656577f, 
    -0.05126399f, -0.00029882f, 0.00134302f, -0.04615826f, 0.02449687f, -0.01762582f, -0.04115268f, -0.05135805f, 
    0.02958954f, 0.03785125f, 0.04991263f, -0.04690854f, 0.03410454f, 0.03571138f, 0.04818239f, -0.02176104f, 
    -0.06264284f, 0.04316948f, -0.03368245f, 0.05115102f, 0.02539652f, -0.05000308f, 0.00816664f, -0.05169782f, 
    -0.02988791f, 0.03337710f, 0.01678153f, -0.03464011f, -0.06336989f, -0.05085834f, -0.00646226f, -0.06138277f, 
    0.01573859f, 0.03685055f, -0.00055033f, 0.00086000f, -0.02605221f, -0.06173078f, -0.04161866f, 0.00688426f, 
    -0.00617052f, -0.05006063f, -0.00327996f, -0.00940722f, 0.01162755f, 0.01831915f, 0.01684391f, -0.05700512f, 
    -0.05926877f, 0.00358111f, -0.00282169f, -0.06539362f, 0.04000061f, 0.00736440f, -0.06167780f, 0.00905664f, 
    -0.04402690f, 0.04928283f, -0.00817828f, 0.02820303f, -0.00011069f, 0.00494242f, -0.05331627f, -0.03252585f, 
    0.00821578f, 0.04383769f, 0.01193319f, 0.04334468f, 0.02759734f, 0.04506374f, 0.00265579f, -0.06103097f, 
    -0.04322495f, -0.03746353f, -0.05655070f, 0.01343197f, -0.02982889f, -0.06201348f, -0.03175103f, -0.02004158f, 
    0.02973566f, -0.05185300f, -0.00113228f, 0.01230193f, -0.06424111f, -0.01625986f, -0.05482273f, -0.02178541f, 
    -0.01824154f, 0.03983105f, 0.04873251f, 0.01604891f, 0.05075731f, -0.05439004f, 0.03365520f, 0.00180231f, 
    -0.02809311f, -0.03290484f, -0.03691764f, 0.01852259f, -0.02627149f, 0.04190816f, 0.03941095f, -0.03360875f, 
    -0.04551596f, -0.01976954f, -0.05804729f, -0.01230746f, -0.00401318f, -0.00155652f, -0.06305131f, -0.02144013f, 
    -0.00705287f, 0.04269419f, 0.02777010f, 0.04762541f, 0.00126780f, 0.00628242f, 0.01286763f, -0.01489783f, 
    -0.01397940f, -0.02672417f, 0.02218050f, -0.05700791f, -0.00105975f, -0.00265176f, -0.04042622f, 0.02579974f, 
    -0.00489424f, 0.01581503f, -0.03273462f, 0.04282219f, 0.03988237f, 0.00518064f, 0.01208768f, -0.06058462f, 
    0.02991965f, -0.04354255f, 0.04660891f, 0.02355504f, -0.03025876f, 0.03888155f, -0.06201856f, 0.03726004f, 
    0.02251389f, 0.01169864f, 0.00229226f, 0.03797064f, -0.03690461f, 0.04529737f, -0.01879127f, -0.04275398f, 
    -0.01007359f, -0.05838343f, -0.05721567f, 0.02264992f, -0.05152216f, 0.01285572f, -0.02166503f, -0.00835096f, 
    -0.05010112f, -0.24481429f, 0.17053941f, 0.16951650f, 0.02922272f, -0.12150057f, -0.03765614f, -0.00454400f, 
    0.05433351f, -0.10661890f, 0.31020933f, -0.45767286f, 0.01588644f, -0.03785038f, -0.00225688f, -0.04067896f, 
    0.06981363f, 0.00673035f, 0.32153395f, 0.11133149f, -0.02342996f, 0.02332916f, -0.02103015f, -0.08290284f, 
    0.12522139f, 0.23366819f, 0.13554686f, -0.09339672f, 0.02385766f, -0.05047687f, -0.00482073f, -0.06762495f, 
    -0.04313099f, 0.04120010f, 0.02450009f, 0.13039926f, 0.15093008f, -0.04461606f, -0.17618680f, 0.11683401f, 
    0.12876514f, 0.06055537f, 0.08187611f, 0.03349363f, -0.02601384f, -0.14702864f, 0.00161331f, 0.11130513f, 
    0.11237592f, 0.16175815f, -0.00889734f, -0.04723448f, -0.01590048f, -0.02817319f, -0.06221015f, -0.31076595f, 
    -0.15197097f, -0.14405456f, 0.13771479f, 0.09978116f, 0.05472026f, 0.05897024f, 0.03756022f, -0.31917167f, 
    -0.10777439f, 0.00422156f, 0.03625829f, -0.01849989f, 0.06058355f, -0.20445864f, -0.06485825f, 0.13293940f, 
    -0.01594375f, -0.08398599f, -0.26674053f, -0.02067439f, 0.24000481f, 0.04751820f, -0.09633028f, -0.09727340f, 
    -0.01542498f, 0.01663978f, -0.40372020f, -0.00278354f, -0.07335921f, -0.01845445f, -0.11914851f, -0.07946347f, 
    0.09678283f, -0.02353421f, -0.18225770f, 0.07076865f, 0.13250345f, -0.08610011f, 0.27424431f, 0.04012708f, 
    0.03861438f, 0.07124923f, -0.00789891f, -0.13602726f, -0.16767357f, -0.07526883f, -0.07916457f, 0.10914864f, 
    -0.08109988f, -0.05249019f, 0.02286602f, 0.13039434f, 0.06641537f, 0.17124440f, 0.11434801f, 0.02679522f, 
    -0.02203296f, -0.05249958f, -0.04070762f, -0.03402341f, 0.12475108f, 0.06984771f, -0.17393325f, -0.11683558f, 
    0.03879870f, 0.00928681f, 0.19380188f, -0.07056995f, -0.02060186f, -0.11355951f, -0.23482323f, 0.16775391f, 
    0.04299878f, -0.00487705f, 0.05620568f, -0.12512989f, 0.06842396f, -0.04386596f, -0.02068661f, 0.05817591f, 
    0.19274956f, 0.00866403f, 0.09477945f, 0.13301674f, 0.05934232f, 0.04515138f, 0.08580158f, -0.03183759f, 
    -0.10640305f, -0.04335198f, 0.10278725f, -0.01281970f, 0.00697444f, 0.11569530f, -0.04643876f, -0.04427019f, 
    0.08506698f, -0.24807109f, -0.03454324f, -0.20352745f, 0.10535258f, 0.01461087f, 0.10255767f, 0.02935709f, 
    -0.06926151f, 0.00034377f, 0.33942714f, -0.03419779f, -0.06188865f, -0.01018554f, -0.06114269f, 0.13326772f, 
    -0.05559680f, -0.03921682f, -0.00173311f, -0.15108271f, -0.08299806f, 0.03433728f, 0.00603494f, 0.06430548f, 
    0.07178926f, -0.06785654f, -0.16016820f, 0.06401147f, -0.01987624f, -0.05067606f, -0.19182339f, -0.08135299f, 
    -0.06622716f, 0.25142005f, 0.09009871f, -0.04796200f, -0.09454432f, -0.04249055f, -0.13036424f, -0.07980606f, 
    -0.01602807f, -0.00709460f, -0.17734198f, 0.10761280f, 0.06666525f, 0.03673032f, 0.05921262f, 0.07592862f, 
    -0.05412560f, -0.05284869f, -0.01065047f, 0.17342810f, -0.02024408f, 0.05589213f, 0.10411566f, -0.07104152f, 
    -0.10411514f, 0.29157463f, 0.05402800f, -0.01998010f, -0.01150053f, -0.12505741f, 0.02333213f, 0.05635793f, 
    -0.07065753f, -0.20137762f, 0.22749867f, -0.17613064f, -0.03142777f, -0.04642936f, -0.01002197f, 0.15661009f, 
    -0.07920995f, 0.31655151f, -0.10741419f, 0.08227075f, 0.05307441f, -0.09758499f, 0.04847230f, 0.15410516f, 
    0.10229558f, 0.22976196f, -0.01683966f, -0.11366473f, 0.07657310f, 0.08999260f, 0.02945400f, -0.02319431f, 
    -0.04603229f, 0.10655712f, 0.01313329f, -0.07923209f, -0.37026086f, -0.04868214f, 0.11654420f, -0.07686307f, 
    -0.06603827f, 0.01978051f, -0.06957100f, 0.10843023f, -0.19479175f, -0.04677342f, -0.00332851f, 0.12153094f, 
    -0.07320215f, 0.01539727f, 0.04902819f, -0.11767811f, 0.07274995f, 0.42163879f, 0.19540271f, -0.12376107f, 
    -0.01988002f, 0.04748924f, 0.02955736f, -0.06867321f, 0.00235662f, -0.17018984f, -0.00100810f, -0.22379990f, 
    -0.16162354f, -0.14571026f, 0.15985723f, 0.16033740f, 0.09611320f, 0.04941919f, -0.19129403f, -0.02572674f, 
    0.25231549f, -0.07468701f, 0.00808371f, 0.11221077f, -0.14097850f, 0.18711695f, 0.01074153f, -0.00904780f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.12880935f, -0.18538436f, 0.12775667f, 0.02203256f, 0.03967402f, 0.06601848f, 0.07634246f, -0.03432437f, 
    -0.15510273f, -0.04215186f, -0.00248568f, 0.01930676f, 0.11771465f, 0.05784802f, 0.05008474f, -0.04593312f, 
    0.03867084f, 0.03112546f, 0.07471494f, 0.00964758f, 0.19798423f, 0.04363314f, 0.08741596f, -0.03832837f, 
    -0.01090660f, -0.00967390f, 0.03675345f, -0.08058766f, -0.05531921f, 0.06832983f, -0.06021179f, 0.05646222f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05197123f, 0.33614215f, -0.17169645f, -0.11603624f, 0.16254783f, 0.37299180f, 0.07256351f, -0.50369120f, 
    0.30571544f, -0.09123147f, -0.16976430f, 0.36738953f, -0.26441696f, -0.35077748f, 0.39503980f, -0.09292941f, 
    0.21963672f, 0.00210757f, 0.14607127f, -0.16518919f, -0.29297510f, -0.02126314f, 0.06531926f, 0.34116381f, 
    0.02639261f, 0.02389833f, 0.17152123f, 0.35649484f, -0.09432817f, 0.14679980f, 0.01842990f, -0.04617942f, 
    -0.00983146f, 0.07912946f, 0.02376329f, -0.12472740f, -0.11130299f, 0.03886482f, -0.11730120f, 0.03369860f, 
    -0.15149444f, -0.01634042f, 0.09807344f, 0.01254461f, -0.13651048f, -0.13231108f, 0.02792977f, -0.14939974f, 
    -0.03935245f, -0.10349175f, 0.05964584f, -0.01952318f, -0.18048242f, -0.11490777f, 0.03898701f, 0.06231726f, 
    -0.17518516f, -0.13601977f, -0.11826332f, -0.07795951f, 0.10273581f, -0.04014215f, 0.03586933f, -0.10636336f, 
    0.04840537f, 0.16801926f, 0.07448500f, -0.05818497f, 0.10649967f, -0.16138735f, 0.23897010f, -0.00834834f, 
    0.25766367f, -0.06137614f, -0.10623240f, 0.04559035f, -0.12044075f, -0.47653276f, 0.33964580f, -0.06232382f, 
    0.29612961f, -0.10092597f, -0.10061412f, -0.08140426f, -0.44982281f, 0.08214574f, -0.07191042f, 0.22774602f, 
    0.12922189f, 0.08610785f, -0.03074090f, -0.07098700f, -0.00621548f, -0.03315099f, -0.06394370f, 0.07446241f, 
    0.16356447f, 0.12177759f, -0.00551423f, -0.15700309f, -0.08473337f, -0.16852951f, 0.12934911f, 0.31809559f, 
    -0.47436330f, 0.01713066f, -0.14398375f, 0.07778794f, 0.10182378f, -0.34642249f, 0.17111796f, 0.15652578f, 
    0.21954198f, -0.04063972f, -0.68728298f, 0.03190476f, 0.06453689f, 0.13090457f, 0.14130905f, 0.19178681f, 
    0.06365459f, -0.16855711f, 0.23178674f, -0.04914088f, -0.07121686f, -0.21803902f, 0.16823807f, -0.19886452f, 
    0.21923155f, 0.13786769f, 0.37020719f, 0.17237280f, -0.05578820f, -0.09203039f, -0.00871208f, 0.07307711f, 
    0.05934835f, 0.00055181f, 0.08870157f, -0.16444455f, 0.21808499f, 0.20779656f, -0.08472839f, 0.05791002f, 
    0.01908002f, 0.03646383f, 0.60799319f, 0.10271870f, -0.04488670f, -0.14592856f, -0.33256280f, -0.08767129f, 
    -0.10521796f, -0.00101316f, -0.14775957f, -0.33188528f, 0.17728168f, 0.29684260f, -0.14441691f, 0.19913080f, 
    -0.37458512f, -0.45142186f, 0.03933281f, 0.10335777f, -0.15020964f, 0.24159393f, 0.35092005f, 0.17250487f, 
    0.42044374f, 0.05669937f, 0.00125462f, -0.26725984f, -0.00872125f, 0.50289881f, 0.16637564f, 0.15594728f, 
    0.01033712f, 0.14296383f, 0.19115503f, -0.01370151f, 0.36834988f, -0.00218911f, 0.29924360f, 0.33941734f, 
    -0.06360328f, -0.15712126f, -0.24497740f, -0.11896422f, 0.08622482f, 0.06901287f, -0.06433254f, -0.29073447f, 
    0.08802953f, 0.55694389f, 0.04692726f, 0.02534701f, -0.06573755f, 0.23721351f, 0.36804810f, -0.11199097f, 
    -0.11546156f, -0.16459003f, 0.14596443f, -0.03841831f, 0.37507737f, -0.03747143f, 0.09869496f, -0.17742428f, 
    -0.36627764f, 0.07464750f, -0.34533951f, -0.07070343f, -0.08809841f, 0.03206020f, -0.39234284f, 0.11147676f, 
    -0.14379451f, 0.07657076f, -0.10197615f, -0.00214742f, 0.05764223f, -0.01155584f, -0.08259563f, -0.14007314f, 
    0.10076635f, 0.60358596f, -0.04018704f, 0.12655568f, 0.07038795f, 0.23339070f, 0.12407107f, -0.06369904f, 
    0.08316323f, -0.06446005f, -0.13559568f, 0.55520546f, 0.11592533f, -0.10395592f, 0.25439325f, -0.03905666f, 
    -0.15754884f, 0.08139110f, 0.06217754f, -0.04437392f, -0.03614554f, -0.10065316f, -0.34353626f, -0.22919443f, 
    0.16864057f, 0.07704550f, -0.20826526f, 0.21116610f, -0.02482881f, -0.06955905f, -0.10870696f, 0.17363995f, 
    -0.00202772f, -0.25614932f, -0.06274161f, 0.05946789f, -0.06381090f, -0.48901376f, 0.19975218f, -0.29584169f, 
    -0.47230011f, -0.13908096f, -0.05844194f, -0.10922207f, -0.30983239f, 0.05140956f, 0.12255578f, -0.12079025f, 
    0.17167416f, 0.06716414f, 0.28179908f, 0.11514218f, 0.00478705f, 0.09167330f, 0.24352716f, 0.27847257f, 
    -0.15330908f, -0.02081866f, 0.24060874f, 0.09583009f, 0.09008957f, 0.32419965f, 0.01274314f, 0.45613009f, 
    0.14996915f, -0.05370287f, -0.01319897f, -0.07370105f, 0.01766905f, 0.66256964f, -0.32165653f, -0.30049312f, 
    -0.67248207f, -0.02879344f, -0.12495013f, 0.47785836f, -0.09429721f, 0.29119787f, 0.18038145f, -0.12565269f, 
    -0.18850251f, -0.11207835f, 0.36736944f, -0.06864804f, 0.03879088f, -0.14556271f, -0.00183804f, 0.14514585f, 
    0.07113326f, 0.14738818f, -0.02264937f, -0.02281978f, 0.01070928f, 0.08792374f, -0.12320331f, 0.03793999f, 
    0.42336565f, -0.02149007f, 0.45664793f, -0.05736039f, -0.06121899f, 0.44327578f, 0.22052506f, -0.00665558f, 
    -0.14418547f, -0.01870094f, 0.00768534f, -0.22987197f, 0.36247748f, 0.34619617f, -0.16634764f, 0.07484033f, 
    -0.31201199f, -0.06381530f, 0.36754090f, -0.09857225f, 0.31222504f, -0.15107654f, -0.26474410f, -0.44461158f, 
    -0.01343912f, 0.00302174f, 0.13567212f, -0.29296368f, -0.12608348f, 0.18048078f, -0.11583935f, 0.17372920f, 
    -0.02387295f, 0.31046987f, -0.04175835f, -0.02975654f, 0.14051557f, -0.09260526f, -0.20548142f, -0.02984876f, 
    0.50696599f, -0.05814760f, 0.03335575f, 0.18517065f, -0.01523226f, -0.40048042f, 0.28717148f, -0.16513486f, 
    -0.32516494f, 0.11404511f, -0.10702914f, -0.08553641f, -0.49209255f, 0.05817540f, 0.21783841f, 0.07599106f, 
    0.08439177f, 0.11513627f, 0.17838001f, 0.06907035f, -0.13737522f, 0.34663489f, -0.01118442f, 0.53709459f, 
    0.20380460f, -0.08642153f, 0.14744969f, 0.11884689f, -0.15183823f, 0.04942189f, -0.06509676f, 0.45073894f, 
    0.04509738f, -0.08252768f, -0.03850976f, -0.07202673f, -0.13969973f, 0.35792127f, -0.00807028f, -0.07294812f, 
    -0.31004670f, -0.14557445f, 0.36782739f, 0.16090176f, -0.09900022f, 0.01413129f, -0.19831651f, -0.24347392f, 
    -0.16025811f, -0.15783826f, 0.10173527f, -0.45828044f, -0.09355679f, 0.33985269f, -0.11881087f, 0.27713525f, 
    -0.39370558f, -0.59292430f, 0.01428181f, -0.16998397f, -0.00507564f, 0.41746801f, 0.12716979f, 0.17940524f, 
    0.00456786f, -0.11876015f, -0.16727245f, -0.26333579f, -0.21840441f, 0.26550034f, 0.18351328f, -0.11559307f, 
    0.32051793f, -0.16734593f, 0.12349813f, -0.01694698f, 0.36724010f, 0.01832775f, 0.14996673f, 0.28998297f, 
    0.02105053f, -0.10349142f, 0.01324285f, 0.22349963f, -0.14364077f, 0.09421572f, 0.16380109f, 0.17876054f, 
    -0.19204554f, -0.06040720f, -0.12753806f, -0.09722871f, 0.01089431f, -0.13628419f, -0.02906868f, 0.05008936f, 
    -0.01915262f, 0.01864421f, -0.11240707f, -0.18419856f, 0.08738060f, -0.13580273f, -0.14528872f, -0.00612800f, 
    0.02476524f, -0.05680027f, -0.03209905f, -0.08231427f, 0.00876237f, -0.07482448f, 0.05575626f, -0.01682761f, 
    0.12241318f, 0.05910434f, -0.02079329f, -0.03559228f, 0.01038755f, 0.02635021f, -0.03985037f, 0.09224459f, 
    -0.29461750f, 0.08375120f, 0.33299109f, -0.01699715f, -0.13928606f, 0.37306431f, -0.01317130f, 0.18610351f, 
    -0.36819458f, 0.08673279f, -0.14358355f, -0.31090161f, 0.38156852f, 0.11921376f, 0.27869928f, -0.11429867f, 
    0.43664443f, -0.11750405f, -0.25614107f, -0.15948403f, -0.22217184f, 0.03080322f, -0.39494544f, 0.11314736f, 
    0.02059904f, 0.00539427f, -0.05889913f, 0.06185786f, -0.14304732f, -0.22320677f, 0.08753521f, -0.19622566f, 
    -0.02853528f, 0.05568916f, -0.21730487f, -0.05360841f, -0.16168347f, -0.37916049f, 0.36019772f, 0.20069832f, 
    -0.39709708f, 0.08662349f, 0.15871702f, 0.11419962f, -0.00550727f, -0.28880420f, 0.26918876f, 0.18140189f, 
    0.05087597f, -0.17614119f, -0.43491665f, 0.07867848f, -0.13285396f, -0.00597221f, 0.09039544f, 0.30747804f, 
    -0.11744086f, 0.13294110f, -0.11411446f, -0.27701053f, -0.16338317f, 0.35510227f, 0.06860249f, 0.27733773f, 
    -0.02826736f, 0.12173838f, -0.18492526f, -0.17226209f, 0.09696466f, -0.01005297f, -0.14336324f, 0.07925822f, 
    0.14542638f, -0.16817290f, 0.05210926f, -0.10380293f, 0.07001535f, -0.07180132f, -0.18298486f, -0.00697969f, 
    -0.02722854f, 0.09418543f, -0.02342496f, 0.09235374f, 0.15364780f, -0.02116895f, -0.12390377f, -0.05203694f, 
    0.04873537f, -0.04997552f, 0.13874856f, -0.17078619f, -0.00849729f, -0.08545941f, 0.01983528f, -0.17429133f, 
    0.00867904f, -0.06313445f, -0.01676517f, -0.06731243f, 0.11841816f, -0.16687642f, -0.05254760f, -0.16258325f, 
    -0.04345093f, 0.11116002f, 0.12160291f, -0.15486631f, -0.06352817f, 0.09353190f, 0.08571043f, -0.03723204f, 
    -0.11968108f, 0.04291004f, -0.00773738f, -0.04157576f, 0.12239561f, 0.08817536f, -0.13803615f, -0.15465596f, 
    0.06717712f, 0.04271724f, -0.04487344f, 0.05621405f, -0.02467173f, -0.10792159f, 0.01094946f, 0.16049473f, 
    -0.00256721f, -0.03316344f, -0.03646336f, -0.03478681f, 0.13984603f, -0.07039192f, -0.01914559f, -0.14979397f, 
    0.24678202f, -0.02485145f, 0.10257342f, 0.10628267f, -0.29816452f, 0.01010694f, 0.18388689f, 0.01859315f, 
    0.08213487f, -0.11467171f, -0.08267017f, 0.14620923f, 0.11104310f, 0.15360747f, 0.21747565f, -0.08865566f, 
    -0.09351557f, -0.01095314f, -0.13609733f, 0.01722773f, -0.10209481f, 0.08304933f, -0.05029010f, -0.06295203f, 
    0.43284377f, -0.10556213f, -0.07618917f, -0.09224346f, -0.01135183f, -0.12031944f, 0.12504779f, -0.41074321f, 
    -0.57585496f, 0.01382971f, -0.10643551f, 0.09072577f, 0.17602497f, 0.06102491f, -0.05928395f, -0.10554286f, 
    0.09169570f, 0.01060061f, -0.05172558f, 0.06855547f, 0.49261603f, 0.05184332f, 0.02459845f, 0.14174725f, 
    0.05069964f, -0.17825629f, 0.18561557f, -0.19772311f, 0.11189464f, 0.12075349f, 0.16279244f, -0.13546556f, 
    -0.11033255f, -0.11152525f, 0.23237945f, -0.09284097f, 0.15094355f, -0.41026178f, -0.00738121f, -0.25005445f, 
    0.33980674f, -0.14866817f, 0.04957797f, -0.35685039f, 0.11685056f, 0.27473745f, -0.19766703f, -0.12214985f, 
    0.44134185f, -0.17024346f, 0.35328180f, 0.09229916f, -0.29271749f, -0.15436246f, -0.02249988f, 0.10059816f, 
    -0.10397851f, -0.13758563f, 0.17266712f, 0.01695841f, -0.02712400f, 0.31291854f, 0.01152064f, 0.39997515f, 
    -0.26045015f, 0.15138409f, -0.09260769f, -0.03192838f, -0.10728882f, 0.54770577f, 0.33882818f, -0.20995679f, 
    -0.03906345f, 0.03814620f, 0.07526983f, -0.16015813f, 0.27987534f, -0.20047316f, 0.29197720f, -0.05283458f, 
    -0.39342955f, 0.15165308f, -0.11784624f, -0.13017599f, 0.23555839f, 0.16575494f, -0.14570656f, 0.37837136f, 
    0.11343220f, 0.04014961f, -0.20391688f, 0.13382432f, -0.17158081f, 0.10165419f, -0.16717410f, -0.28168210f, 
    -0.13312161f, -0.08076668f, -0.01526976f, -0.01411502f, 0.10820069f, -0.33104357f, 0.01930568f, 0.09970600f, 
    0.15812327f, 0.10175905f, 0.14546445f, 0.33288676f, 0.17253967f, -0.12759958f, 0.07399603f, -0.16809793f, 
    -0.12589954f, -0.05296468f, -0.22196409f, 0.03553888f, 0.12216839f, -0.18506120f, -0.13954821f, 0.22938664f, 
    -0.13699055f, 0.17239511f, -0.27295890f, -0.42083365f, -0.11518427f, 0.44244155f, -0.15708163f, 0.14911455f, 
    0.08685148f, 0.11335864f, -0.32613137f, 0.05952412f, 0.13836952f, 0.12688938f, 0.24497209f, -0.03374732f, 
    0.07882936f, 0.11357715f, -0.11028206f, 0.54647326f, -0.36250633f, -0.11397333f, 0.20578963f, 0.08270083f, 
    -0.14087449f, 0.07759964f, -0.01271976f, -0.02115183f, -0.01421426f, -0.13855846f, 0.37755176f, 0.12477648f, 
    -0.15795176f, 0.12886946f, 0.25295499f, 0.25156316f, -0.10836544f, 0.15529884f, -0.00102950f, 0.29434019f, 
    0.31007478f, -0.07704519f, -0.10643964f, 0.01534760f, -0.03216019f, -0.44814247f, 0.20429593f, 0.12280786f, 
    0.27064386f, -0.04433062f, 0.06383121f, -0.20503469f, 0.03343022f, 0.19119394f, -0.23231155f, 0.14781639f, 
    -0.47950813f, 0.14742674f, 0.03277446f, -0.03189344f, -0.16759180f, -0.16287887f, 0.24268077f, 0.12631880f, 
    -0.11385293f, 0.08734788f, 0.25186941f, -0.02128847f, -0.14809613f, 0.36381197f, 0.02895709f, 0.53031236f, 
    -0.29023993f, -0.07154264f, 0.04500508f, 0.12213112f, 0.01150091f, 0.38831359f, -0.26727489f, 0.06660108f, 
    0.15391782f, -0.12154256f, 0.08872638f, 0.30701467f, 0.21070121f, 0.50432825f, -0.11618373f, 0.12417722f, 
    0.26411188f, -0.13247308f, 0.04403691f, 0.09099450f, 0.28074759f, 0.00470933f, 0.41937274f, 0.09155151f, 
    -0.02380679f, 0.04695199f, 0.04656708f, 0.38465482f, -0.13138141f, -0.36904737f, 0.15296790f, -0.20515859f, 
    -0.26666981f, 0.33015108f, -0.20367648f, -0.00444213f, 0.17396332f, 0.15940551f, -0.12501405f, 0.24451482f, 
    0.35069740f, 0.00788856f, -0.00977813f, 0.27100191f, -0.20675202f, 0.29040784f, 0.25529796f, -0.03104282f, 
    0.41058272f, -0.02090029f, 0.34378809f, 0.16460685f, 0.14374042f, -0.08798284f, 0.06365313f, 0.16026245f, 
    -0.00992211f, -0.08175967f, -0.18333213f, 0.37484270f, 0.12890184f, -0.01932379f, 0.08293640f, 0.25967816f, 
    -0.05398875f, -0.52464265f, 0.32832888f, -0.02317973f, -0.08021681f, 0.16191021f, 0.00687216f, 0.19376978f, 
    -0.11325463f, 0.12059921f, -0.03690135f, -0.35179946f, 0.08187154f, 0.36892420f, -0.01144162f, 0.15086843f, 
    0.36069769f, 0.12416080f, 0.21333131f, -0.08149593f, 0.19984473f, -0.08246070f, 0.39327642f, 0.03903842f, 
    -0.08043619f, -0.17832927f, 0.22214462f, -0.08942612f, -0.14382400f, -0.24054568f, -0.11328845f, -0.01284603f, 
    0.16481818f, 0.09826703f, -0.01551684f, 0.06119420f, -0.16566503f, -0.10093483f, 0.03221808f, 0.03527829f, 
    0.32429358f, -0.13611394f, 0.03905024f, 0.12810001f, -0.21334583f, -0.26910225f, -0.01940291f, -0.07123011f, 
    -0.20822170f, -0.09530358f, -0.22531471f, -0.13548903f, 0.07029555f, 0.11797249f, 0.30542138f, 0.14638340f, 
    0.06747760f, 0.12866274f, 0.36242619f, -0.25248083f, 0.08799401f, -0.12501431f, 0.06745472f, -0.17664415f, 
    0.16984862f, 0.03006022f, -0.31656173f, 0.04715527f, 0.00199382f, 0.33836219f, -0.06084770f, -0.14087191f, 
    -0.15167110f, 0.13254167f, -0.12812033f, 0.16704641f, 0.01746283f, 0.26160428f, 0.02103678f, -0.02749242f, 
    -0.24747856f, -0.01030488f, -0.23337367f, -0.10819125f, 0.43994051f, -0.07432638f, 0.42878622f, -0.09184162f, 
    -0.05040408f, -0.02421479f, 0.25456247f, 0.66915876f, -0.03110653f, -0.02629057f, 0.13986592f, 0.38627568f, 
    -0.14148542f, 0.00309156f, 0.07875738f, 0.15629171f, -0.05128393f, 0.47223088f, -0.01855303f, 0.37427875f, 
    0.13960412f, 0.01137906f, -0.14252385f, 0.53102267f, -0.10539225f, 0.32113048f, 0.10806291f, -0.09268278f, 
    0.06934997f, 0.11582371f, 0.10258669f, -0.15520957f, 0.26130849f, -0.14563121f, 0.24308699f, 0.20000847f, 
    -0.00588628f, -0.14665082f, 0.00800913f, -0.13043922f, 0.12499955f, -0.55387205f, 0.16384597f, -0.55308288f, 
    0.05868831f, -0.14872654f, 0.03699072f, 0.13441199f, -0.02239783f, -0.14328162f, -0.12217495f, 0.02918625f, 
    -0.19866550f, 0.03686311f, -0.10897645f, 0.09081499f, 0.13219729f, 0.43169674f, 0.09096909f, 0.13869925f, 
    0.58560115f, 0.15642269f, 0.59108472f, 0.13358583f, 0.40057704f, -0.15320913f, -0.14912717f, -0.11618046f, 
    -0.00352587f, -0.00425385f, -0.27078819f, -0.03687446f, 0.14234875f, 0.27699497f, -0.09839001f, 0.28276074f, 
    0.04133675f, -0.26906642f, 0.13256390f, 0.07172315f, -0.07544256f, 0.54815990f, 0.11972243f, 0.12002818f, 
    -0.06196922f, -0.03824864f, 0.11399205f, -0.40622914f, 0.31528324f, -0.20444022f, 0.24576721f, -0.05535718f, 
    -0.24244292f, 0.13628747f, -0.30184913f, -0.11202397f, -0.06557196f, -0.07356539f, 0.15891753f, -0.04741618f, 
    0.14655161f, 0.01371345f, 0.06392547f, -0.14410286f, -0.12726937f, -0.04362253f, 0.06762106f, -0.29494280f, 
    -0.05020823f, -0.04770348f, 0.29114863f, 0.08642000f, 0.08257037f, 0.14052621f, -0.27756798f, -0.24173707f, 
    0.40065342f, 0.04507680f, 0.00690074f, 0.18885346f, -0.20405439f, -0.35253114f, 0.06494942f, -0.01964693f, 
    0.28437644f, -0.08782227f, 0.05547247f, 0.16105966f, -0.36248916f, -0.11309243f, 0.47634178f, 0.10316493f, 
    0.16209130f, -0.00139420f, 0.43705893f, 0.22607271f, 0.09745849f, -0.09417783f, -0.03767084f, 0.17354596f, 
    0.03606378f, -0.01188173f, 0.03719589f, 0.07969502f, -0.15694930f, 0.01064748f, -0.01514461f, 0.10385323f, 
    0.02322630f, -0.04450246f, -0.16387783f, -0.01604873f, -0.17996009f, 0.00668147f, -0.10852266f, -0.05775556f, 
    0.05759268f, -0.04262874f, 0.12131536f, 0.01182552f, -0.19249380f, 0.12073167f, -0.11134515f, -0.01747874f, 
    -0.10771095f, 0.16713324f, -0.12949415f, 0.11112726f, -0.15466285f, -0.03153668f, 0.09961835f, 0.04871557f, 
    -0.11445481f, -0.22577719f, -0.07446644f, -0.01002943f, -0.01488047f, 0.08348903f, 0.28385931f, 0.34396860f, 
    0.03031801f, 0.08925775f, 0.12862924f, 0.15083598f, 0.00184621f, -0.22147225f, 0.33058307f, -0.02168588f, 
    -0.03353234f, 0.00444961f, 0.31409788f, -0.06283998f, 0.03565717f, 0.14566141f, -0.36262545f, 0.11584223f, 
    0.11383736f, -0.13011073f, -0.13830908f, -0.31107116f, 0.03370166f, 0.51576543f, 0.03189187f, 0.06726037f, 
    0.05159197f, 0.18098243f, 0.51154107f, 0.14201142f, -0.08782027f, 0.01300159f, -0.14742398f, 0.17026865f, 
    -0.24969918f, -0.03173262f, 0.14370874f, -0.49729341f, 0.30756414f, -0.05719721f, 0.01637933f, -0.04638006f, 
    0.20013839f, 0.16150104f, 0.13134123f, 0.17778842f, -0.31910118f, -0.04956908f, -0.07923945f, -0.04070074f, 
    0.15824412f, -0.15207495f, 0.23044604f, -0.24951473f, -0.04971728f, -0.03665413f, 0.06399078f, -0.21115336f, 
    -0.03226945f, 0.10435522f, 0.07948082f, 0.07515078f, 0.16258764f, -0.15512796f, 0.05335304f, -0.21107736f, 
    0.08135156f, -0.13440825f, -0.16295406f, 0.05482665f, 0.04127060f, -0.09028082f, -0.16362233f, -0.14485283f, 
    -0.13742581f, -0.01791829f, -0.12354904f, -0.05031088f, -0.18889673f, 0.01419413f, -0.08057503f, -0.06890205f, 
    0.13463666f, -0.11047180f, -0.17284393f, -0.07267497f, -0.03703191f, 0.00725181f, 0.08481518f, -0.10175715f, 
    0.40808845f, 0.07512680f, -0.00850068f, 0.08958988f, 0.06619550f, 0.37148073f, 0.16345908f, -0.30303532f, 
    -0.11842809f, 0.03179299f, 0.03685888f, 0.03056378f, 0.21513917f, 0.11522999f, -0.19171512f, -0.11466172f, 
    -0.46914062f, 0.15433086f, 0.33044973f, -0.03140413f, 0.36348459f, 0.08925951f, -0.06931094f, -0.23435682f, 
    0.17948176f, 0.03076808f, 0.12551270f, 0.16932969f, 0.11212363f, 0.13878427f, 0.05904146f, 0.39885634f, 
    -0.05919724f, 0.48130193f, 0.03824506f, -0.03626465f, 0.16323484f, -0.41288489f, 0.28820628f, 0.25060210f, 
    -0.22107427f, -0.00321154f, -0.07402956f, 0.03746630f, 0.14050946f, -0.29944003f, 0.17842749f, 0.00116884f, 
    -0.18337761f, 0.08114994f, -0.61368310f, 0.04018935f, 0.15985233f, -0.08777238f, -0.09331217f, 0.02675363f, 
    0.05476096f, 0.09041510f, 0.01700971f, 0.14526464f, 0.11744541f, -0.16136712f, 0.01605266f, -0.00133334f, 
    0.24499461f, -0.31881917f, 0.07982525f, 0.02375734f, 0.10225605f, -0.13908927f, 0.24947003f, 0.36824811f, 
    -0.35609555f, -0.00977630f, -0.00221879f, 0.29015070f, -0.27351671f, -0.10672331f, 0.15781717f, -0.16472393f, 
    -0.04858038f, -0.06419899f, 0.25991815f, 0.06668796f, 0.38971430f, -0.16282485f, -0.01003080f, -0.06776465f, 
    -0.13184439f, 0.06776484f, -0.09182235f, -0.28017631f, -0.09740678f, 0.41247928f, -0.15589713f, 0.18730758f, 
    0.07726268f, -0.29034126f, 0.02335919f, 0.15127055f, -0.16298892f, 0.09166325f, -0.08029035f, -0.13187212f, 
    0.43707818f, 0.05161845f, -0.03170229f, -0.51747221f, 0.16786067f, -0.10665118f, 0.22088271f, -0.08316317f, 
    0.18392721f, -0.04577388f, 0.31280303f, 0.07347119f, -0.40943679f, 0.09313467f, -0.16855484f, 0.25279310f, 
    0.05709111f, -0.09271283f, 0.10193352f, -0.20741437f, 0.15594962f, 0.49661022f, -0.11448102f, 0.12514000f, 
    0.17137100f, 0.08883329f, 0.31815770f, -0.15045057f, -0.13964720f, 0.47981679f, -0.36975819f, -0.51626939f, 
    -0.08466978f, -0.01895441f, -0.09033224f, 0.08061766f, 0.16009231f, 0.02682464f, -0.19256562f, -0.02937947f, 
    -0.00500413f, -0.13460863f, 0.32490826f, -0.19821322f, -0.09651570f, 0.09259084f, 0.06406149f, -0.00212556f, 
    0.07846590f, 0.08937506f, 0.31971321f, 0.50603616f, -0.01396990f, -0.06615485f, 0.08320161f, -0.04378020f, 
    0.18785159f, -0.37604594f, -0.27731496f, 0.00230636f, -0.02741922f, -0.23221292f, -0.15412319f, 0.13210744f, 
    -0.03296222f, 0.07781996f, -0.18139446f, 0.48073465f, 0.19338864f, 0.21768644f, -0.07837187f, 0.08643520f, 
    0.17468925f, 0.12795554f, -0.04475432f, -0.03222493f, 0.43700793f, 0.03556623f, 0.19890957f, 0.10195620f, 
    -0.07365078f, -0.01645336f, -0.06142069f, 0.09478199f, 0.04278460f, 0.25917146f, 0.10716874f, 0.14422970f, 
    -0.23854110f, -0.45790583f, 0.20295365f, -0.06739149f, -0.05133703f, 0.06657481f, 0.05712824f, 0.42423382f, 
    -0.07078226f, 0.07314231f, -0.05317685f, -0.17542380f, -0.23113333f, 0.28199956f, 0.19523142f, -0.11147274f, 
    0.70746672f, 0.11442392f, 0.50726026f, 0.15843338f, 0.00532830f, -0.04718566f, -0.03574594f, 0.21541288f, 
    0.03943076f, 0.15194836f, -0.10035990f, -0.10149333f, -0.05715789f, 0.11771789f, 0.03888632f, 0.03994490f, 
    -0.13817538f, 0.03711936f, -0.06301144f, 0.04301154f, 0.10972755f, -0.10294389f, 0.38971269f, 0.36391479f, 
    -0.07729226f, 0.00867689f, 0.12861976f, -0.07822471f, -0.04223048f, -0.33399710f, 0.32472861f, 0.15944569f, 
    0.01264623f, 0.02369333f, -0.22579235f, 0.03707663f, -0.10805295f, 0.09954783f, -0.04315766f, 0.47544459f, 
    0.16978614f, 0.14985426f, 0.01225809f, -0.20050585f, 0.05558560f, 0.17705648f, -0.09834624f, -0.12510972f, 
    0.48915139f, -0.03374995f, 0.46819371f, 0.05864851f, 0.00545117f, 0.36119160f, -0.10092968f, -0.08345509f, 
    -0.11389209f, 0.17333300f, -0.09393744f, 0.03794492f, 0.07634459f, -0.02742525f, -0.13760574f, -0.12927124f, 
    -0.29683694f, 0.12677288f, 0.18819384f, -0.11629389f, 0.09126087f, 0.15435559f, 0.19366175f, -0.34846821f, 
    0.05616798f, 0.01071885f, 0.44996074f, -0.06672072f, -0.07405932f, -0.29359144f, 0.11810767f, 0.07819631f, 
    -0.16289698f, -0.11318933f, 0.01833348f, 0.01190767f, 0.14391163f, 0.09700973f, 0.04545522f, -0.07097302f, 
    -0.14276035f, 0.03092342f, 0.10926662f, -0.13747939f, 0.00127959f, -0.03978322f, -0.09732254f, -0.14332144f, 
    -0.07406973f, 0.12792912f, 0.06320374f, 0.06761497f, 0.05186429f, 0.15822585f, 0.13686763f, 0.04751184f, 
    -0.15712166f, 0.05816706f, -0.13889652f, 0.00798400f, 0.03788771f, -0.17146257f, -0.06830381f, -0.10543257f, 
    -0.01313101f, -0.39693636f, 0.24355710f, 0.00514303f, 0.01349717f, -0.47147503f, -0.01226144f, 0.20747402f, 
    -0.18503800f, -0.00108138f, -0.13632040f, 0.06540731f, 0.25435963f, 0.11776151f, -0.03369286f, 0.06032097f, 
    0.42051259f, 0.01628479f, -0.02741961f, -0.15016957f, 0.14862935f, 0.00910708f, 0.31476223f, -0.06100782f, 
    -0.15739983f, 0.09743205f, 0.17958105f, -0.26667222f, 0.17667073f, 0.30592361f, -0.03621323f, -0.05502146f, 
    0.13499084f, 0.05137470f, -0.08980070f, -0.18209103f, 0.15060036f, 0.29724136f, 0.36936632f, -0.19328149f, 
    0.24214914f, -0.09177992f, -0.13445275f, -0.29432318f, 0.20122759f, 0.01645330f, 0.13599025f, -0.06704404f, 
    -0.57648742f, 0.06483875f, -0.53807735f, 0.00115844f, 0.07047395f, 0.12387053f, -0.01234751f, 0.29871073f, 
    0.16933197f, -0.11641148f, 0.17614307f, 0.20546651f, 0.00338656f, 0.16806914f, 0.11045936f, -0.07182191f, 
    0.17679676f, 0.43760684f, 0.05265622f, 0.05565408f, 0.11375578f, -0.37460780f, 0.02834299f, -0.26454318f, 
    -0.09219150f, -0.07357805f, 0.11866933f, -0.12641835f, 0.40429285f, -0.18253517f, 0.01188509f, 0.15100269f, 
    -0.02653943f, 0.13778949f, -0.59068710f, 0.16365792f, -0.15655145f, -0.16904645f, 0.12836082f, -0.03516462f, 
    0.17424566f, -0.10609149f, 0.13103271f, 0.06431478f, -0.14493023f, 0.05718268f, -0.12960298f, -0.06192686f, 
    0.17154099f, -0.28277579f, 0.27263057f, -0.10121721f, -0.06993264f, 0.20397438f, 0.10614401f, 0.05189024f, 
    0.41837007f, 0.01473161f, 0.05651274f, -0.20903032f, -0.12571807f, -0.11319562f, 0.06507249f, 0.01458623f, 
    -0.31084731f, -0.03634188f, 0.34916785f, -0.08698208f, -0.24489866f, 0.04943014f, -0.10424152f, 0.22140752f, 
    -0.13827682f, 0.16699806f, 0.15247497f, -0.31033003f, 0.04186561f, 0.25024801f, 0.08507448f, -0.20747182f, 
    0.22795838f, 0.39191690f, -0.11566810f, -0.06521562f, -0.11211226f, -0.09662170f, 0.24715306f, 0.08866662f, 
    0.02108120f, 0.16810863f, 0.05593909f, -0.26629671f, -0.06726480f, -0.27378470f, -0.05524559f, -0.09626540f, 
    -0.07685262f, -0.00372817f, -0.28067586f, 0.11086893f, 0.39399636f, 0.07455388f, 0.11373997f, -0.23339598f, 
    0.02842869f, -0.01235472f, -0.03479346f, 0.59536409f, 0.00529046f, 0.11771064f, 0.16445568f, 0.40019628f, 
    0.17903282f, -0.24549389f, -0.22503890f, 0.10502731f, 0.10929133f, -0.13860922f, 0.08370280f, -0.20647091f, 
    -0.52939725f, -0.12645121f, 0.11355387f, -0.03593740f, 0.18764226f, 0.17709769f, -0.01968245f, -0.15095364f, 
    0.08017276f, -0.13122799f, -0.38152838f, 0.15177363f, 0.40038726f, -0.15632372f, 0.37442788f, 0.14199288f, 
    0.01062716f, -0.02246094f, 0.26111314f, 0.57495147f, -0.09873909f, 0.06799275f, -0.09270246f, 0.11954657f, 
    0.15329064f, 0.19474682f, 0.22724356f, 0.07193862f, -0.10473455f, 0.19566192f, -0.00893333f, 0.13760383f, 
    0.16970740f, 0.04889150f, -0.14360210f, -0.22894324f, 0.09526111f, -0.48606434f, 0.29759571f, 0.14704712f, 
    -0.29069838f, -0.03044616f, -0.04342888f, 0.07569542f, -0.35851172f, 0.10165934f, -0.25341889f, 0.25939369f, 
    -0.10305066f, 0.11090116f, 0.15829849f, -0.30392176f, -0.07067711f, 0.26795810f, 0.03031479f, -0.31933129f, 
    0.16883777f, -0.01792788f, 0.21165478f, 0.16712229f, 0.10821945f, -0.06038386f, 0.09152218f, 0.03221225f, 
    0.14586093f, -0.10637248f, -0.11604255f, 0.10573911f, 0.12463877f, 0.46837273f, -0.36686099f, -0.15197548f, 
    -0.06032206f, 0.01625863f, -0.04305601f, 0.08166943f, 0.22929472f, 0.14673524f, 0.18385859f, 0.02937854f, 
    -0.02160128f, -0.12938634f, 0.20574538f, 0.28239635f, -0.02930127f, -0.45991448f, -0.03403686f, -0.03791688f, 
    -0.40835774f, 0.02625247f, 0.05530655f, -0.10556664f, 0.14091454f, -0.01512418f, 0.23736572f, -0.10868346f, 
    -0.02873181f, 0.13883209f, 0.00741502f, -0.21080117f, 0.11849773f, -0.01624762f, 0.25714201f, 0.07684197f, 
    0.22419702f, -0.10718850f, -0.13954851f, 0.12839334f, 0.22173834f, -0.00677992f, -0.13855147f, 0.23674083f, 
    0.08921818f, -0.13912794f, -0.30416048f, 0.14724837f, 0.13622595f, 0.39254746f, -0.16925423f, -0.08835748f, 
    0.36767843f, 0.21199678f, -0.03475493f, -0.16752405f, -0.01739247f, -0.30380970f, -0.02539516f, 0.45262840f, 
    0.12772842f, -0.03791269f, 0.00685447f, -0.01421622f, -0.13048676f, -0.21853493f, -0.11784457f, -0.10288021f, 
    -0.36121956f, -0.13489047f, -0.05604816f, -0.13321382f, -0.29939485f, 0.16921993f, 0.32182273f, -0.11963990f, 
    0.09406786f, 0.13541193f, 0.36634031f, 0.14895669f, 0.03544004f, 0.13159038f, 0.01630749f, 0.48450541f, 
    0.05607090f, 0.53867817f, 0.08215720f, 0.08712253f, 0.00526852f, 0.72048241f, 0.01503696f, 0.22487314f, 
    -0.20663130f, 0.05660349f, -0.13165611f, 0.22104742f, -0.22117189f, -0.52742183f, 0.33086807f, 0.09250182f, 
    -0.30906835f, -0.00464902f, 0.03598018f, 0.16192643f, 0.16021986f, 0.13338469f, -0.27813098f, 0.03775159f, 
    0.02570993f, -0.08188483f, 0.14433111f, -0.06671239f, 0.13271806f, -0.05516740f, 0.04930778f, -0.30342701f, 
    -0.21836397f, -0.36369628f, 0.29133031f, -0.05244891f, 0.11679098f, 0.07060269f, -0.13083221f, -0.18430108f, 
    -0.02223866f, 0.15262058f, -0.04081330f, -0.64120167f, 0.34994826f, 0.13114361f, 0.17063297f, 0.04952866f, 
    0.29361847f, 0.16079073f, 0.19519229f, -0.03536703f, -0.09746756f, -0.02963269f, 0.04262939f, 0.12231971f, 
    0.15583612f, -0.04124613f, 0.07320806f, -0.05065887f, -0.07736504f, 0.11788385f, 0.13123736f, -0.18773578f, 
    -0.05699738f, 0.21969993f, 0.00644415f, 0.00206028f, -0.04002737f, -0.42911378f, 0.00948809f, 0.39071742f, 
    -0.08116943f, -0.16761279f, -0.05752691f, 0.37523878f, 0.04913964f, 0.41218072f, 0.17343386f, -0.12964961f, 
    0.26173040f, 0.15607026f, 0.25121048f, -0.08688851f, 0.12636805f, 0.06748188f, 0.10751527f, -0.10853267f, 
    -0.03174384f, 0.04302699f, -0.39943403f, -0.17463918f, 0.18446676f, 0.33992690f, 0.00839821f, 0.08797278f, 
    0.40031582f, 0.09204274f, 0.22760557f, -0.02634297f, 0.07980289f, -0.60542649f, 0.11669990f, 0.15811566f, 
    -0.11691140f, -0.06498938f, 0.16764461f, 0.07867086f, -0.13240719f, 0.20248920f, -0.15428929f, 0.03761015f, 
    0.19171846f, -0.07942027f, 0.22069959f, -0.09446359f, 0.20778367f, 0.04074793f, 0.21714315f, -0.30790135f, 
    -0.16297410f, -0.03495535f, 0.07936321f, -0.11913319f, -0.14741252f, 0.01762532f, 0.09795056f, 0.39375681f, 
    -0.20400399f, 0.11316142f, 0.16404110f, 0.00770836f, -0.05001440f, -0.30650958f, 0.05972390f, -0.00808517f, 
    0.04844109f, 0.02195821f, 0.16521998f, -0.17035228f, 0.09842873f, 0.07674551f, 0.21876329f, 0.12760155f, 
    0.60609150f, -0.05753887f, -0.25618738f, -0.16406685f, -0.14395113f, 0.01546509f, 0.01753492f, 0.09906702f, 
    0.03675550f, 0.02655913f, -0.19161172f, 0.26086354f, 0.08458400f, 0.18261006f, 0.12341993f, -0.15599561f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.07035708f, -0.18017437f, 0.10322107f, 0.17633541f, -0.00796708f, 0.12927431f, 0.17641521f, -0.09615373f, 
    -0.08038542f, 0.12068137f, 0.07784553f, -0.12708044f, -0.10652748f, 0.08853661f, -0.08394992f, 0.18417947f, 
    -0.05285357f, 0.06601683f, -0.17569342f, -0.08180396f, 0.32054612f, -0.13664767f, 0.19268031f, 0.07520870f, 
    0.03358423f, -0.12339029f, -0.11307873f, -0.05785328f, 0.10656267f, 0.12459310f, 0.10930967f, 0.18322451f, 
    -0.00742612f, 0.29188952f, 0.12591787f, 0.04121430f, 0.20464750f, 0.05021248f, -0.15470512f, 0.12129788f, 
    0.06071813f, 0.29246768f, -0.06490842f, -0.06049341f, 0.07285622f, 0.19540168f, 0.08753586f, 0.14971034f, 
    0.10049567f, 0.22929284f, -0.06920780f, 0.09825835f, 0.18137038f, -0.10686851f, 0.29719493f, 0.13651088f, 
    0.00860649f, 0.20906417f, 0.13341027f, 0.21732385f, 0.03985110f, -0.13565238f, 0.07422817f, 0.05979124f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.17580511f, 0.10097282f, 0.15982424f, 0.21002303f, -0.14623103f, -0.66652787f, -0.01914930f, -0.18400744f, 
    0.23433405f, -0.43508679f, 0.00254930f, 0.14510377f, -0.21921982f, -0.45845848f, 0.10007256f, -0.42230511f, 
    0.13594964f, -0.12909128f, -0.01846068f, -0.16147286f, 0.20880635f, -0.04807048f, -0.20570025f, -0.00482083f, 
    0.27134481f, 0.22669014f, -0.37237597f, -0.43320942f, -0.08734990f, 0.49766654f, 0.08965281f, -0.33748299f, 
    -0.57744801f, 0.04960498f, 0.39209473f, -0.03791174f, -0.20772846f, -0.07001554f, -0.00222218f, 0.12660927f, 
    -0.02192227f, 0.04179494f, 0.00782993f, 0.06538294f, -0.10221604f, -0.57870889f, 0.05423789f, 0.22106162f, 
    -0.08984061f, 0.00453503f, 0.14568146f, 0.20409375f, 0.14733565f, 0.05373056f, 0.11298981f, 0.23029338f, 
    -0.03904130f, -0.41162884f, 0.38884151f, 0.08142176f, -0.29305464f, -0.47030628f, 0.17839266f, -0.37589455f, 
    -0.13464448f, 0.05626984f, -0.30329290f, -0.39041030f, 0.24507609f, -0.43086284f, -0.33550620f, -0.04027023f, 
    0.35833317f, 0.12822358f, 0.19337924f, 0.15110713f, 0.37853175f, 0.01536721f, 0.09718645f, -0.35011181f, 
    -0.11474685f, -0.07434002f, 0.12498318f, -0.25094631f, -0.06955460f, 0.40177086f, -0.42548522f, -0.17124403f, 
    0.01356127f, 0.31954160f, -0.19683252f, 0.05715406f, 0.01403877f, -0.55153477f, 0.17898722f, -0.68454444f, 
    0.24048740f, -0.29542601f, -0.01619201f, -0.09430054f, -0.01884161f, -0.02372798f, 0.03843628f, 0.35451233f, 
    -0.35266316f, 0.12066476f, 0.07380366f, 0.20239830f, 0.00277368f, 0.00160242f, -0.42923111f, 0.08785876f, 
    -0.02528390f, 0.02106054f, -0.16178703f, -0.17547408f, -0.01790793f, 0.30974051f, 0.04366708f, -0.29791570f, 
    -0.09880769f, -0.19971998f, 0.29007038f, -0.34966129f, -0.01980843f, 0.08717553f, 0.23628791f, -0.30242777f, 
    -0.62350482f, -0.09710436f, 0.07465308f, 0.12760174f, 0.21983267f, 0.09223929f, -0.26644862f, 0.04059992f, 
    -0.45535892f, -0.35938713f, 0.09338503f, 0.08590502f, 0.57938689f, -0.14184235f, 0.05904044f, -0.01423111f, 
    0.01200042f, -0.10762741f, 0.12213710f, 0.01280825f, -0.48540860f, -0.36543530f, -0.55998844f, -0.08096743f, 
    -0.08591438f, -0.17066444f, -0.03878095f, 0.15378004f, 0.03354651f, 0.24145786f, -0.40653238f, 0.39819658f, 
    -0.00509158f, 0.06885213f, -0.07099492f, -0.08842486f, 0.35495284f, 0.20856588f, -0.11340921f, -0.35770249f, 
    0.10756097f, 0.29224491f, -0.18479873f, -0.62104714f, -0.05110501f, 0.27941462f, 0.13555871f, 0.04654627f, 
    0.02949692f, 0.14208308f, -0.48218811f, -0.41497740f, 0.15555228f, -0.49959582f, -0.68952781f, 0.16951632f, 
    -0.07919493f, -0.48462120f, 0.39374134f, 0.36942390f, -0.41588986f, 0.31979921f, 0.24733302f, -0.24932598f, 
    0.20942737f, 0.01060512f, 0.05423217f, -0.10467117f, -0.63131028f, 0.42697266f, -0.26151296f, -0.37618160f, 
    0.07517710f, -1.01324272f, -0.61689562f, 0.23068777f, -0.09627239f, 0.34057653f, 0.01619612f, -0.24184196f, 
    0.06024900f, 0.02354467f, -0.09467547f, 0.15819961f, -0.45951620f, 0.08696612f, 0.15995255f, 0.07001407f, 
    0.22140482f, 0.23556033f, 0.10728461f, 0.18295372f, -0.02356768f, 0.16410790f, 0.11475925f, 0.08128779f, 
    -0.42501503f, 0.04508238f, 0.23992755f, 0.06842324f, 0.12993751f, -0.58474857f, -0.02982778f, -0.47686312f, 
    -0.14231807f, -0.27564698f, 0.24543385f, -0.33350831f, 0.08076730f, 0.08360616f, 0.19122639f, -0.62076044f, 
    0.04767654f, -0.10788255f, 0.21491462f, -0.11011131f, 0.11431240f, -0.25310630f, 0.08411498f, 0.04686977f, 
    -0.13780187f, 0.19448687f, 0.07485011f, -0.26285025f, 0.09967284f, -0.02533526f, -0.46559331f, 0.08878177f, 
    0.03854625f, -0.02952459f, -0.03046773f, 0.14166836f, -0.05565921f, -0.20599826f, 0.31346321f, 0.22142211f, 
    -0.12593141f, 0.29707721f, 0.02546909f, 0.12047432f, 0.00556458f, -0.24899325f, 0.04606333f, 0.09544881f, 
    0.34029433f, 0.02090983f, -0.07137123f, -0.52655482f, 0.05696734f, -0.33443552f, 0.35750511f, 0.26265520f, 
    -0.07539632f, -0.20226860f, -0.23337628f, -0.06826062f, -0.26874354f, -0.34323135f, 0.00704307f, -0.19993927f, 
    0.06451558f, 0.17574352f, -0.40052921f, 0.10054056f, 0.38997549f, -0.15982583f, -0.08809181f, -0.01163215f, 
    0.20607851f, 0.16735063f, -0.01957720f, -0.27794784f, 0.05556697f, -0.31869635f, 0.12786426f, -0.29066366f, 
    0.10912255f, -0.02516726f, 0.09643153f, 0.19125938f, -0.10508697f, -0.00757051f, 0.01326310f, 0.23348756f, 
    -0.33377415f, 0.28360939f, -0.20650083f, 0.22460388f, -0.08725730f, 0.13140415f, -0.32174557f, -0.01028562f, 
    -0.52813160f, 0.05659059f, -0.37260821f, 0.21662384f, -0.04858533f, -0.35530350f, 0.05468719f, -0.16743068f, 
    -0.33554623f, 0.10248702f, 0.15416349f, -0.10759698f, -0.22554962f, -0.32837605f, -0.04356435f, 0.17362736f, 
    -0.26756841f, 0.02612100f, -0.01373253f, -0.20034745f, 0.05012234f, 0.07963646f, -0.13180621f, -0.43962440f, 
    -0.45285615f, -0.03853760f, 0.23977613f, -0.26128027f, 0.18134710f, -0.23559058f, 0.20486750f, 0.04794613f, 
    -0.13979279f, 0.29310480f, 0.07309043f, -0.07986755f, -0.69439518f, 0.33774602f, -0.08428245f, 0.06500243f, 
    0.16068684f, -0.41088367f, -0.17265208f, 0.30771738f, 0.01557250f, -0.40267155f, -0.35419679f, 0.18580987f, 
    -0.02534287f, 0.12776060f, 0.05395525f, 0.34927362f, -0.25304434f, 0.34968719f, 0.27670342f, -0.15719695f, 
    0.28696200f, -0.16693014f, 0.04649053f, -0.46934310f, 0.28679839f, -0.13957796f, 0.03258549f, 0.07087156f, 
    -0.39704138f, -0.10368710f, -0.08361572f, -0.13571472f, 0.36457857f, 0.22183725f, 0.20862509f, -0.24984996f, 
    -0.20750345f, -0.68354160f, 0.22703391f, -0.28490338f, 0.00287307f, -0.12033997f, 0.00293784f, 0.18921232f, 
    -0.17634171f, 0.00987050f, -0.04595098f, -0.03824051f, 0.04913093f, 0.42182228f, 0.03674787f, 0.17389357f, 
    -0.81619358f, -0.03145430f, -0.16772087f, -0.29300499f, 0.02916559f, -0.59036398f, -0.50531691f, -0.23262265f, 
    0.21567546f, 0.20314853f, -0.36730433f, 0.03839958f, 0.17654172f, 0.25120747f, 0.00825151f, -0.07331988f, 
    -0.14068204f, -0.09734438f, 0.30677229f, -0.10647602f, -0.12813331f, 0.15969063f, -0.00709929f, -0.06735487f, 
    -0.11311733f, 0.17792359f, 0.04828930f, 0.10453817f, 0.28436241f, -0.77607000f, -0.22602460f, 0.17469314f, 
    -0.01880225f, 0.25978595f, -0.42266551f, -0.36954737f, 0.42073542f, 0.04598474f, -0.01015674f, 0.17965333f, 
    0.28493613f, 0.10350280f, 0.32025668f, -0.03712428f, -0.08788458f, -0.26693341f, 0.33790278f, 0.41288280f, 
    -0.06040301f, 0.13569540f, -0.33423918f, 0.22260150f, -0.17693721f, -0.36511123f, 0.02056257f, -0.11544487f, 
    0.10609517f, -0.09143604f, -0.01703056f, 0.01050143f, -0.46264678f, -0.04272388f, 0.08169281f, 0.04954308f, 
    0.18580869f, -0.08728826f, -0.02593450f, 0.31559080f, -0.70239341f, -0.15190928f, 0.10362499f, -0.03378793f, 
    -0.15874727f, -0.58217067f, 0.01139925f, -0.09931225f, -0.29856077f, -0.33166531f, -0.00773179f, -0.19084902f, 
    0.31897518f, -0.46247482f, -0.33971736f, 0.20088227f, -0.28943926f, -0.60525292f, 0.06525226f, -0.33792117f, 
    -0.00549843f, -0.54743135f, 0.06603659f, 0.27636686f, -0.59266222f, 0.23215166f, -0.03327441f, -0.19645409f, 
    -0.03482281f, 0.19681136f, 0.18654752f, 0.17965427f, -0.78136933f, 0.19084899f, -0.03994839f, 0.25782987f, 
    0.17040527f, 0.00171458f, -0.42397115f, -0.22877531f, 0.03832960f, -0.11868240f, -0.42603046f, 0.19530019f, 
    -0.24025384f, 0.38243768f, 0.06435066f, -0.12606555f, -0.37160298f, -0.21027249f, 0.04037270f, -0.39803812f, 
    -0.40544564f, 0.14067434f, -0.09568509f, -0.08366108f, 0.16807918f, -0.13660991f, -0.39323157f, 0.16261140f, 
    0.20454796f, -0.30299670f, 0.34228262f, 0.27764213f, 0.02343783f, 0.29012647f, 0.21751572f, 0.40076813f, 
    0.26669011f, -0.51173621f, 0.16887546f, -0.07423973f, -0.17853323f, -0.50564742f, 0.09609873f, 0.15487231f, 
    -0.44016305f, 0.01559404f, -0.50058085f, 0.30927920f, 0.33611825f, -0.14729340f, -0.60857314f, 0.10373171f, 
    -0.00942506f, 0.11475876f, -0.31066006f, -0.22419433f, -0.07266598f, -0.06765465f, -0.03661876f, -0.60415488f, 
    0.19790646f, -0.32294127f, -0.34872091f, -0.03465875f, -0.46141660f, 0.26581103f, 0.10170758f, -0.26562408f, 
    0.23593099f, 0.01855256f, -0.03751804f, -0.10656352f, -0.00242949f, -0.15661864f, 0.16302498f, 0.09250627f, 
    -0.38558012f, 0.40267345f, 0.15571344f, -0.07308640f, -0.27104300f, 0.07727152f, 0.04715860f, 0.21941878f, 
    -0.50840735f, 0.07937558f, 0.10990596f, -0.63629711f, -0.14353582f, -0.22636543f, 0.23406596f, -0.87884140f, 
    -0.06619488f, -0.63109547f, 0.08316708f, 0.03280015f, 0.08029499f, -0.25464240f, 0.07113478f, 0.20012274f, 
    -0.24969411f, 0.28107041f, 0.27258638f, 0.03455620f, -0.07549495f, 0.13524865f, -0.00572688f, 0.07991285f, 
    -0.17442873f, -0.18312714f, 0.10621848f, 0.50784242f, -0.40727067f, 0.04413465f, -0.13170309f, 0.19327359f, 
    -0.04501008f, -0.26351872f, 0.05435721f, -0.19895449f, 0.22802445f, -0.07759681f, -0.14757159f, 0.25756270f, 
    -0.08539234f, -0.03426134f, -0.32132888f, 0.51460987f, 0.22253154f, -0.51482552f, -0.50960857f, -0.11021104f, 
    -0.28205252f, -0.13977052f, -0.30065814f, 0.15406233f, -0.34896529f, 0.34687158f, -0.04346826f, -0.19379525f, 
    0.12970440f, -0.17827938f, -0.00376695f, -0.75216699f, -0.11338456f, 0.40070406f, 0.05316959f, -0.17763788f, 
    0.16688542f, 0.07396781f, 0.03794564f, -0.08238625f, 0.31656009f, -0.57497972f, 0.18433213f, -0.12401835f, 
    0.16953969f, -0.07277512f, 0.07235236f, 0.07076757f, 0.08123707f, 0.01067229f, 0.31790087f, 0.29615664f, 
    0.07641665f, -0.06221558f, -0.71405506f, -0.11843646f, 0.00804965f, -0.80633962f, -0.08776464f, 0.16583139f, 
    0.12787186f, 0.28077966f, -0.67038625f, -0.61105043f, 0.10183696f, 0.10000455f, 0.10071177f, -0.15872508f, 
    0.08495355f, -0.07965281f, 0.10453023f, -0.27438080f, -0.23311567f, 0.16699503f, 0.36740077f, -0.62383646f, 
    0.19193579f, 0.17484771f, -0.21015853f, 0.03371997f, -0.34444806f, 0.01266518f, 0.05499978f, -0.16473101f, 
    0.14102529f, -0.08017246f, 0.20075704f, 0.14500143f, -0.18019143f, -0.12910852f, -0.52451158f, -0.30322850f, 
    0.32764629f, -0.21621345f, -0.33062372f, -0.11341796f, -1.04968047f, 0.31966674f, -0.04937744f, 0.19111340f, 
    0.10818046f, -0.03752329f, 0.05057023f, 0.06477830f, -0.00419678f, 0.23906732f, -0.34576142f, -0.09994014f, 
    0.02215928f, -0.53767675f, -0.00180298f, 0.23024236f, 0.21287665f, -0.21877731f, -0.16550790f, -0.02658862f, 
    0.23229101f, -0.13199368f, 0.34861103f, -0.09853162f, -0.01084235f, 0.04968017f, 0.08871927f, -0.70259368f, 
    -0.11063026f, 0.10010491f, 0.04916734f, -0.13535336f, -0.00415910f, 0.54975522f, 0.07990548f, -0.27606633f, 
    -0.09689168f, 0.17880610f, -0.40610209f, -0.09868556f, -0.19881423f, -0.32973713f, 0.11544666f, -0.18520483f, 
    -0.19483912f, 0.18021008f, -0.28380615f, -0.19691475f, 0.35969195f, 0.14857765f, 0.04932639f, 0.34401596f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.00169414f, -0.18143235f, 0.02875755f, -0.01455802f, 0.14831616f, 0.03605281f, -0.07974184f, -0.12041640f, 
    -0.09433535f, 0.08472419f, -0.00994125f, 0.08049983f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
