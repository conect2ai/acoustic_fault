#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.39607203f, 0.71213347f, 0.40560997f, -0.35205978f, 0.10989513f, -0.06811727f, -1.10878694f, -0.00002851f, 
    -0.14872432f, 0.21638954f, 0.01488538f, 0.61548740f, 0.03788724f, 0.17586209f, 0.24077885f, 0.17016582f, 
    -0.04355711f, 0.12642385f, 0.02411993f, 0.18379696f, 0.29532796f, 0.26334435f, -0.06256280f, -0.03788104f, 
    0.35419801f, -0.81570506f, -1.04043806f, 1.20232785f, 0.57161182f, -0.72848225f, 0.25435960f, 0.40042758f, 
    0.65394968f, 0.14948907f, -0.75326794f, -0.06397296f, -0.29366633f, -0.24109152f, 0.28275934f, -0.42969403f, 
    0.12810233f, 0.34349191f, -0.13865520f, -0.31126830f, -0.08427994f, -0.16628399f, -0.07043871f, 0.23791380f, 
    -0.02427663f, -0.06127036f, -0.94298011f, 0.50170767f, -0.25362173f, -1.12510848f, -0.73676395f, 0.61880070f, 
    0.65072745f, -0.01344174f, 0.46401247f, 0.63683885f, -0.08528836f, 0.13503073f, -0.30881876f, -0.25683391f, 
    -0.59147197f, 0.31856659f, 0.26169777f, 0.09633671f, 0.15538092f, -0.04267131f, -0.03887168f, -0.18177308f, 
    -0.11210999f, -0.41299403f, 0.16356093f, 0.12666851f, -0.72550839f, -0.57423967f, -0.75841713f, -0.38511026f, 
    -0.40917233f, -0.01989953f, -0.45153511f, 0.42357028f, 0.33624721f, 0.44995901f, 0.02471389f, -0.08899698f, 
    -0.21524020f, -0.39332294f, 0.17476824f, 0.36345664f, -0.20381786f, -0.00755462f, 0.05086802f, 0.08186414f, 
    -0.24203315f, -0.25455797f, -0.14732832f, 0.00368962f, -0.34297416f, 0.06488320f, 1.16255426f, -0.81996775f, 
    -0.62783515f, 0.05080966f, 0.04965276f, -0.27805591f, -0.71380770f, -0.16781192f, 0.07923506f, 0.47407877f, 
    -0.33292586f, 0.09455543f, 0.22417673f, -0.50692523f, -0.24017240f, -0.01988196f, -0.36157697f, -0.27782378f, 
    0.08894184f, 0.30294940f, 0.22754249f, 0.22267616f, 0.37846866f, -0.69409418f, 0.57270449f, 0.22177069f, 
    0.81227261f, 0.69381338f, 0.59482378f, 0.50734234f, 0.85909724f, 0.06428919f, 0.64917612f, -0.24153930f, 
    -0.56182170f, -0.50500137f, -0.55630201f, -0.14781636f, -0.30065259f, -0.20662445f, -0.11266192f, 0.03557034f, 
    -0.19940093f, -0.06578287f, -0.09517845f, -0.22743623f, -0.27426431f, -0.20367874f, -0.36006394f, -0.43374795f, 
    0.23508930f, -0.14818045f, -0.44709340f, 0.11129550f, 0.69513327f, -0.79927391f, 0.26954237f, 0.32383725f, 
    0.30933252f, -0.17982958f, -0.59441042f, -0.29706439f, -0.12443859f, -0.17894958f, 0.17879745f, 0.06807477f, 
    0.26115984f, 0.03313549f, 0.22048561f, 0.46218511f, 0.60790926f, 0.56791866f, -0.08031891f, -0.54015535f, 
    -0.77465504f, 0.48194370f, 0.89746028f, 0.42094249f, -0.56251162f, -0.11489231f, -0.70937109f, -0.59374142f, 
    -0.38788533f, 0.50996107f, 0.48208693f, 0.49022084f, 0.08485132f, -0.10498386f, -0.11715756f, 0.32161200f, 
    -0.07036199f, 0.19801965f, 0.10448822f, -0.28724876f, 0.25261658f, -0.40359622f, 0.09754753f, -0.04584883f, 
    0.01368822f, 0.58255219f, -0.63098156f, -1.27183771f, -0.22980590f, -0.08798171f, -0.08891478f, -0.46445471f, 
    -1.00000441f, -0.60638064f, 0.18718633f, 0.54278672f, 0.40943536f, 0.31615782f, -0.14789277f, 0.13694625f, 
    0.15389939f, 0.17152670f, 0.12644613f, 0.42535368f, 0.19323088f, 0.04349037f, -0.04368009f, 0.06468719f, 
    0.28735375f, -0.31880197f, 0.46407178f, 0.46187589f, -0.23250546f, 0.69534701f, 1.07604146f, -0.57232088f, 
    -1.11536610f, -0.52745312f, -0.76383543f, 0.10688585f, 0.03383275f, 0.03248710f, 0.13242264f, -0.66212302f, 
    -0.07722032f, 0.10027663f, 0.29638758f, 0.05005109f, -0.02143608f, -0.00807512f, 0.24638735f, -0.03480020f, 
    -0.24231012f, 0.19262771f, -0.59883368f, -1.19959080f, -0.95578218f, 0.10834634f, -0.20975076f, 0.15658925f, 
    0.17797062f, 0.22318977f, 0.77566326f, 0.37085980f, 0.03246686f, 0.26398194f, 0.15340051f, 0.47082531f, 
    -0.05214730f, -0.05433291f, 0.22839044f, 0.34960818f, -0.15637124f, 0.06606575f, 0.10527480f, 0.04050306f, 
    0.02058829f, 0.11052451f, 0.17370011f, -0.64723456f, -0.23209189f, -0.64615798f, -0.81257015f, -0.47196683f, 
    -0.74652022f, -0.58975214f, 0.41300112f, 0.04147165f, 0.08947238f, -0.24984848f, 0.04844575f, -0.10891408f, 
    -0.08334783f, 0.43031338f, -0.12391058f, -0.05120840f, 0.04594280f, 0.06891162f, 0.02764960f, 0.59480804f, 
    0.01554754f, 0.18540534f, -0.25478512f, 0.19051555f, -1.31337440f, 0.23036331f, 0.01110997f, -0.00490570f, 
    0.21063599f, 0.49217930f, 0.92459095f, -0.67023450f, 0.12136489f, 0.41891679f, -0.03968388f, 0.04792977f, 
    0.49908215f, -0.29391211f, 0.27015108f, -0.06654728f, -0.22455201f, -0.17309552f, -0.42463267f, -0.26616508f, 
    0.21662503f, -0.07101112f, -0.05393844f, -0.03954350f, -0.15843648f, 0.83765715f, 0.66282398f, 0.56928301f, 
    0.94927526f, -0.08607542f, 0.53238904f, 0.57679945f, -0.09202266f, -0.10178308f, 0.78356832f, -0.23001209f, 
    0.47494939f, 0.18192992f, -0.25008970f, 0.02556033f, -0.40975854f, -0.20642895f, 0.06982715f, -0.29834962f, 
    0.00284120f, 0.29848373f, -0.06742664f, 0.24059460f, 0.02083545f, 0.29730991f, 0.71127152f, 1.08344293f, 
    1.14374053f, 0.99899805f, -0.18745099f, -0.64068145f, -0.24341485f, -0.16762105f, 0.22212845f, 0.23435561f, 
    0.29362169f, 0.00890045f, -0.42355105f, 0.32851651f, -0.41672271f, 0.13750075f, -0.06266150f, 0.56224334f, 
    -0.21440440f, -0.21827304f, -0.08745574f, 0.08832072f, 0.19926046f, -0.03194909f, -0.03970148f, -0.45445478f, 
    -1.15628207f, -0.90790069f, 0.09981533f, 0.44488755f, -0.30007502f, 1.21368933f, 0.55810821f, -0.51714271f, 
    0.16549525f, 0.23405445f, -0.11350337f, 0.01048475f, -0.29292852f, 0.11899086f, -0.24645656f, -0.13077271f, 
    -0.26014239f, -0.09552491f, -0.10207184f, 0.03330720f, -0.09652318f, 0.13694495f, -0.02514097f, 0.06200339f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.19680414f, 0.26050028f, 0.02580882f, 0.04889962f, 0.29581043f, 0.03424896f, -0.04068421f, 0.21939451f, 
    0.59495312f, 0.44047061f, 0.25049537f, 0.43624625f, 0.08840217f, 0.29281488f, 0.34073254f, 0.27374664f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.44183666f, 0.44425404f, -0.09865244f, -0.38344011f, 0.39144722f, 0.19059597f, 0.09898941f, -0.09071949f, 
    -0.13968074f, -0.07093291f, -0.08400036f, 0.00543283f, 0.58124441f, 0.18569176f, 0.22753052f, 0.21860002f, 
    0.05041882f, -0.21623644f, 0.02877913f, -0.12254582f, 0.10241567f, 0.15355991f, -0.03891009f, 0.05265033f, 
    -0.34573081f, -0.11425070f, 0.02035482f, -0.20131563f, -0.04630170f, 0.10703883f, 0.06937987f, 0.14287403f, 
    0.20208000f, 0.00947969f, 0.06926845f, -0.04023217f, 0.11533733f, -0.08325360f, -0.03300845f, -0.15187441f, 
    0.00053628f, 0.37878978f, -0.09257399f, 0.06306643f, -0.11116459f, 0.20899232f, 0.00967491f, 0.19306071f, 
    0.05565875f, -0.04874443f, -0.15620142f, 0.04353734f, 0.08706248f, 0.05694522f, 0.09740739f, -0.10893112f, 
    -0.02466061f, 0.08036171f, -0.04097572f, 0.10866565f, 0.08610845f, -0.17208739f, -0.12064910f, 0.15741560f, 
    -0.03639681f, -0.01531943f, -0.21521020f, -0.13847494f, 0.00740711f, 0.18542191f, -0.08894314f, 0.16890743f, 
    -0.09499696f, -0.61973041f, 0.13657777f, 0.01765390f, 0.02401070f, -0.00386988f, 0.03060826f, -0.15156226f, 
    0.18335603f, -0.20674948f, 0.02237247f, 0.05756777f, -0.00038762f, 0.16398075f, -0.24494117f, -0.03445157f, 
    -0.02288517f, 0.06301389f, 0.03254424f, 0.08497866f, -0.19440621f, -0.02902862f, 0.06108619f, -0.03931487f, 
    0.01384237f, 0.32241207f, -0.08187237f, -0.36496866f, 0.07121298f, 0.11264399f, -0.10174213f, 0.05194875f, 
    0.02288653f, 0.09025294f, 0.01060133f, -0.06124167f, 0.03162170f, -0.07488425f, -0.36384389f, -0.06220344f, 
    -0.02612715f, -0.11763714f, -0.03472483f, -0.18331599f, -0.09745070f, 0.09339324f, -0.15516347f, -0.18616246f, 
    0.39707273f, -0.22649187f, 0.18395115f, -0.01731562f, -0.06357712f, -0.01914954f, 0.03487654f, 0.01489106f, 
    -0.10493988f, 0.08207247f, -0.04204527f, 0.17053363f, -0.20707768f, -0.09376603f, 0.35919702f, -0.10208660f, 
    -0.06393207f, 0.01091013f, -0.04850945f, -0.09556391f, 0.11965790f, -0.13780893f, 0.11559774f, 0.04499200f, 
    0.62114054f, -0.24406062f, -0.02519693f, 0.11122826f, -0.04473941f, 0.19021893f, -0.04155078f, 0.02062142f, 
    -0.03713192f, -0.07146522f, -0.08207444f, 0.11421234f, 0.37227279f, 0.14160715f, -0.25964695f, 0.07337216f, 
    0.03217147f, 0.09861328f, 0.02464885f, -0.17631155f, 0.08531460f, 0.19709647f, 0.07168577f, -0.02839809f, 
    0.24645215f, -0.25500533f, 0.16428103f, -0.09617011f, 0.20077008f, -0.01560112f, -0.05252549f, -0.06209747f, 
    -0.09843520f, -0.08182041f, 0.14580192f, -0.02569842f, 0.50254899f, -0.07557296f, 0.20623170f, 0.27710497f, 
    -0.07018244f, 0.10049076f, -0.16946289f, 0.01268651f, 0.01863147f, 0.07897174f, 0.10942281f, -0.04961439f, 
    0.03482922f, -0.05724635f, 0.01488216f, -0.05904099f, -0.02029340f, 0.00976268f, 0.05945726f, 0.05636453f, 
    0.03987899f, 0.03484482f, 0.03617284f, -0.06076706f, 0.05091746f, -0.03054170f, -0.03979945f, 0.02381939f, 
    -0.02796674f, 0.05751585f, -0.01879883f, -0.04360266f, -0.02686814f, -0.02347213f, -0.01832094f, -0.02075711f, 
    0.05101939f, 0.04712645f, -0.07788659f, -0.02098629f, 0.03825948f, 0.02657524f, 0.03701196f, -0.07552131f, 
    -0.03638393f, -0.03509600f, 0.03286683f, -0.05109141f, -0.04667620f, 0.05318787f, -0.00196553f, 0.00627085f, 
    -0.00766577f, 0.00330098f, -0.07123026f, -0.06162206f, 0.02475909f, 0.04645829f, 0.04009174f, 0.00424164f, 
    -0.04867015f, 0.05972631f, 0.03305743f, -0.02844804f, 0.03692624f, -0.02862717f, 0.02472463f, -0.00517951f, 
    -0.05368344f, 0.02959250f, 0.01945402f, 0.01113472f, -0.01037355f, -0.03949879f, -0.05200246f, -0.01960098f, 
    0.02800598f, 0.02695840f, -0.05216987f, -0.00008337f, -0.00904130f, 0.01439240f, -0.05105374f, 0.02551253f, 
    -0.06540631f, 0.01953192f, 0.05148834f, 0.03376461f, -0.07571116f, -0.06019299f, 0.05211987f, 0.00266588f, 
    -0.00095479f, 0.04839683f, 0.01902424f, 0.01139270f, 0.01522490f, 0.02771733f, -0.05938708f, 0.02310906f, 
    -0.01295492f, -0.05996852f, 0.05983578f, -0.06109777f, -0.01991036f, 0.01600277f, -0.06617498f, -0.00049157f, 
    -0.02090817f, -0.07537713f, 0.03714907f, -0.06900379f, -0.01709693f, -0.06572609f, -0.04659024f, -0.05515528f, 
    0.00553407f, -0.01354501f, 0.01983789f, -0.02280293f, 0.04728451f, -0.05370429f, 0.03310297f, -0.04447896f, 
    -0.03887523f, 0.02202334f, 0.05611471f, 0.02044319f, -0.01558699f, -0.05276640f, -0.05113436f, -0.04953588f, 
    -0.01000841f, -0.04939776f, 0.00209510f, -0.07031910f, -0.01262473f, 0.01926403f, 0.02228763f, -0.03645357f, 
    -0.06853257f, -0.00062635f, 0.01592978f, -0.00079542f, 0.03773107f, 0.01530305f, -0.00467222f, -0.01427001f, 
    -0.00012946f, -0.06349214f, 0.05282788f, -0.01863999f, -0.00840370f, -0.05651179f, -0.00094654f, 0.01509768f, 
    -0.06758277f, -0.08115883f, 0.05965520f, -0.04174052f, -0.01164360f, -0.07666703f, 0.00714980f, -0.07824514f, 
    0.05921180f, -0.02545547f, 0.02013535f, 0.01407340f, 0.03586280f, 0.04815800f, 0.03087708f, -0.04081305f, 
    0.01391723f, -0.06570674f, 0.00577571f, -0.06077294f, -0.02192844f, 0.03356780f, -0.02660906f, -0.08034353f, 
    -0.07154115f, -0.04103435f, 0.02324138f, -0.03217081f, -0.05492795f, 0.01828644f, 0.02539926f, 0.04756061f, 
    0.04417951f, -0.06613658f, 0.04321396f, 0.05568143f, 0.03426471f, 0.02548630f, -0.06232210f, 0.01717964f, 
    -0.04783322f, 0.03889198f, -0.00721122f, 0.01985194f, -0.03214295f, -0.04233349f, 0.03316696f, -0.00203034f, 
    -0.23117259f, -0.35749269f, -0.04293993f, 0.38898575f, -0.21253526f, -0.02430916f, -0.20887071f, 0.06801290f, 
    0.25498545f, 0.03449966f, 0.03622759f, 0.14365323f, -0.32773432f, -0.18451723f, 0.02456125f, -0.06069768f, 
    0.07815994f, 0.03952485f, 0.16673224f, -0.02414455f, -0.08306839f, -0.11548105f, -0.00093863f, 0.11615559f, 
    -0.03220000f, 0.33267820f, 0.06157332f, 0.03132201f, 0.01779998f, -0.10113115f, -0.08656334f, -0.00428240f, 
    -0.01337322f, -0.09612131f, 0.04631446f, 0.20277368f, -0.21694851f, 0.33915716f, -0.04002745f, 0.22468700f, 
    0.02500043f, -0.13932264f, -0.10190070f, -0.02376018f, 0.13263083f, -0.02185845f, 0.02124891f, 0.16246009f, 
    0.04645403f, 0.33714426f, 0.20397048f, -0.10099545f, 0.17180289f, 0.03638573f, 0.06732879f, -0.00129983f, 
    -0.07525940f, 0.04054137f, -0.01482609f, -0.13071525f, 0.08502001f, 0.39828715f, 0.17235218f, 0.12845351f, 
    -0.09512663f, -0.09878409f, -0.05190929f, -0.02788445f, 0.14788871f, -0.08218637f, 0.17571546f, -0.14236394f, 
    0.11951613f, 0.49421790f, -0.05639719f, 0.15236300f, 0.04516494f, 0.00056114f, 0.17996937f, 0.23439789f, 
    0.11081833f, 0.01253856f, 0.02135512f, -0.05073010f, -0.19661829f, -0.30269137f, 0.17741321f, 0.04523849f, 
    0.08151066f, 0.02548779f, -0.00450227f, -0.05665829f, 0.09858077f, 0.11977014f, -0.04597874f, 0.06163846f, 
    0.26904583f, 0.21756327f, 0.04517139f, 0.18035932f, -0.09422171f, 0.05171215f, 0.07204144f, 0.14670424f, 
    0.07615066f, 0.00137467f, 0.04266460f, 0.12006013f, 0.22863746f, 0.25958899f, 0.20827180f, 0.08894556f, 
    0.00105997f, 0.22665192f, 0.04809024f, 0.30026880f, 0.16168010f, 0.07870953f, 0.06963785f, 0.22546169f, 
    -0.37653276f, 0.17273635f, 0.13259184f, -0.09829894f, 0.07770177f, -0.04168258f, 0.06300280f, 0.05866908f, 
    0.00734597f, -0.08261912f, 0.07302932f, -0.01698032f, 0.02083092f, -0.17288229f, -0.06085473f, -0.06109421f, 
    0.28223613f, -0.03114418f, 0.05154084f, 0.25486746f, -0.10879525f, 0.15419015f, -0.10298366f, 0.09259856f, 
    -0.54114854f, 0.35911337f, -0.01549340f, 0.01773441f, -0.07654136f, -0.14372644f, 0.04768449f, -0.12132175f, 
    0.16559128f, -0.00052177f, -0.05137249f, -0.04409515f, -0.24095210f, -0.15041776f, 0.05026100f, 0.23649415f, 
    -0.08133502f, -0.12782668f, -0.06373641f, 0.04370090f, -0.02806172f, -0.13835682f, 0.03678742f, 0.02139398f, 
    -0.30761141f, -0.03236831f, -0.19060235f, 0.41421905f, 0.04878597f, -0.07498062f, 0.05636793f, 0.06414707f, 
    0.12560202f, -0.04319035f, 0.04516785f, 0.09110889f, -0.34905982f, 0.17093280f, -0.24842374f, -0.24972863f, 
    -0.00000203f, -0.06484985f, 0.10606635f, -0.01101725f, -0.00831121f, -0.01600277f, -0.12336987f, 0.18086986f, 
    -0.30457780f, 0.09018908f, -0.37105396f, -0.24144073f, 0.06415426f, -0.11036913f, 0.20048265f, -0.23399316f, 
    0.00694049f, -0.02008839f, 0.09713769f, -0.10143530f, 0.60846955f, 0.15222006f, 0.14671445f, -0.16483124f, 
    0.03159380f, -0.03401358f, -0.14614242f, 0.15532847f, 0.07389449f, -0.01069872f, 0.01212027f, -0.01051919f, 
    0.20890246f, 0.21532407f, 0.30197677f, 0.30049026f, 0.01045522f, 0.15714911f, 0.09279805f, -0.08215821f, 
    -0.19537430f, -0.12134636f, 0.01069134f, -0.17110488f, -0.06775228f, 0.07365936f, 0.23810042f, 0.00692934f, 
    0.07558329f, 0.01169995f, 0.30878878f, 0.04083059f, 0.19837005f, 0.06371552f, -0.02655571f, -0.11790231f, 
    0.55847716f, -0.35352078f, 0.15686747f, -0.09152938f, -0.02663027f, 0.06755631f, 0.01352972f, -0.09443852f, 
    0.08061922f, 0.00494528f, 0.11864117f, -0.00496457f, -0.14176181f, 0.00063386f, -0.21509548f, -0.25157186f, 
    0.01265485f, -0.17139941f, 0.00589875f, 0.01641699f, 0.06011821f, -0.07388148f, 0.14878312f, 0.01104997f, 
    -0.00581742f, 0.07100524f, 0.24741749f, 0.13631599f, -0.00845430f, 0.15120888f, 0.13064182f, 0.07639709f, 
    -0.09015616f, -0.00872619f, 0.02739008f, 0.11324720f, -0.01439106f, 0.08513843f, 0.10340052f, 0.17650503f, 
    0.00205749f, -0.00654347f, -0.00235926f, 0.08708173f, -0.03622659f, 0.10625982f, 0.00099351f, 0.22492634f, 
    -0.07347827f, 0.12798880f, -0.01750824f, 0.21013695f, 0.05851395f, -0.09273263f, -0.02045267f, -0.09814569f, 
    0.15537466f, -0.09603682f, -0.17745179f, 0.02975292f, -0.32867345f, 0.12202062f, 0.06230583f, 0.28629640f, 
    0.12063733f, -0.11595212f, 0.12914357f, 0.02505895f, 0.07346725f, -0.08527713f, 0.09583616f, -0.08246367f, 
    -0.17860532f, -0.02799271f, 0.29860958f, 0.24902445f, 0.01561364f, -0.05537562f, -0.01828060f, -0.03384743f, 
    0.01290528f, 0.21410985f, 0.04847506f, -0.04093773f, 0.26970199f, 0.09479349f, -0.16383038f, 0.23733211f, 
    -0.10939513f, -0.00706014f, -0.02267470f, -0.06454949f, 0.04289006f, 0.05566843f, -0.11963715f, 0.16575162f, 
    0.45044243f, 0.09449849f, 0.13353677f, 0.07949141f, 0.17851517f, 0.13154158f, -0.00107550f, 0.20366687f, 
    0.24506721f, 0.10218897f, -0.13322924f, 0.08247364f, -0.08054614f, -0.30850533f, -0.22915423f, -0.36145043f, 
    0.39526212f, 0.24368224f, 0.01630853f, 0.01005450f, 0.05437675f, 0.11041818f, -0.09425578f, 0.00041544f, 
    -0.00603304f, -0.28368515f, -0.02011379f, -0.20491664f, 0.06363763f, 0.15937153f, -0.00953702f, -0.08188093f, 
    -0.01973975f, 0.05404387f, 0.09435854f, 0.09589355f, -0.42147490f, 0.20185913f, 0.18533617f, 0.20516726f, 
    -0.03751537f, -0.08002750f, -0.01595321f, 0.10056107f, 0.00660126f, 0.17374480f, -0.01878802f, -0.05394135f, 
    0.05452627f, -0.04958497f, 0.03794071f, 0.02435383f, -0.04838946f, 0.01714087f, -0.03547684f, 0.06497312f, 
    -0.03281942f, 0.00689440f, -0.02088718f, 0.00661375f, -0.06018240f, -0.04142395f, 0.01507161f, 0.05433357f, 
    -0.02231537f, -0.04064621f, -0.03286739f, -0.05703646f, -0.02302159f, -0.02720258f, -0.00125639f, -0.00070449f, 
    -0.05304609f, -0.05248332f, -0.06591026f, -0.00371683f, 0.04166169f, 0.06280080f, -0.06929383f, -0.03140695f, 
    -0.06902998f, -0.06834582f, 0.00150617f, 0.00185458f, 0.06205799f, -0.05278023f, 0.04242251f, -0.07288101f, 
    0.04770471f, -0.05581321f, -0.01291816f, -0.06365265f, -0.05534609f, -0.02636456f, -0.05181357f, -0.03384357f, 
    0.04773064f, 0.01401200f, -0.06682817f, -0.04295546f, 0.03758929f, 0.01579992f, -0.06240980f, 0.02605438f, 
    -0.01989572f, -0.00745547f, 0.04699670f, 0.05505121f, -0.04028853f, -0.06168932f, 0.06122852f, -0.07126256f, 
    0.02867476f, -0.05821784f, -0.02842208f, 0.01382356f, -0.05947997f, -0.02851153f, -0.04934671f, -0.01942658f, 
    0.03797235f, -0.06945901f, -0.05945284f, -0.00473793f, -0.05413872f, 0.01124024f, -0.01580667f, -0.05636233f, 
    -0.06535728f, 0.03866849f, -0.06736919f, -0.03921472f, 0.02832644f, -0.06386145f, -0.00297414f, 0.05500302f, 
    -0.01255181f, -0.01657789f, -0.06286657f, -0.02470815f, 0.01008953f, -0.06608844f, 0.06508609f, 0.01616203f, 
    -0.00333908f, 0.05226754f, 0.02483983f, 0.01229278f, 0.06123240f, 0.06182671f, 0.03790473f, -0.03686471f, 
    0.05031038f, -0.05449788f, -0.07354047f, -0.03626345f, 0.06446796f, -0.06525009f, 0.06271877f, -0.03106086f, 
    -0.00334584f, 0.02972964f, -0.04468858f, 0.04824662f, 0.01123292f, 0.00285254f, -0.01246815f, 0.05769039f, 
    0.04438460f, -0.07729068f, -0.05121559f, 0.00942409f, -0.00919720f, -0.00514228f, -0.03658337f, -0.03497424f, 
    -0.01841478f, 0.04295204f, -0.04831322f, -0.02931557f, -0.03634874f, -0.06861755f, 0.05517414f, -0.04406901f, 
    -0.07214774f, 0.03065182f, -0.01738720f, -0.04747974f, 0.02628741f, 0.06271055f, 0.01791127f, 0.03003647f, 
    0.04744694f, 0.02181926f, -0.06813724f, -0.01783797f, 0.00029567f, 0.04306017f, -0.04890305f, -0.01327017f, 
    -0.00070145f, -0.07752986f, 0.06182354f, -0.05453615f, -0.00048562f, 0.03619763f, 0.05836347f, 0.01029720f, 
    0.06608623f, 0.00671946f, -0.06950710f, -0.06512798f, -0.04889731f, 0.05442280f, -0.01351872f, -0.04352718f, 
    0.02498928f, -0.04337773f, -0.06310723f, 0.02664313f, 0.06348395f, 0.06576162f, -0.07167876f, -0.01388846f, 
    -0.04214700f, -0.01325567f, -0.02422682f, 0.01957762f, -0.02025815f, -0.07360774f, 0.04195587f, -0.01996787f, 
    0.01411583f, 0.06539820f, 0.04514416f, 0.05321455f, -0.04422210f, 0.04625364f, 0.03382164f, -0.00721540f, 
    -0.04998437f, -0.05086185f, -0.04640093f, 0.05849327f, 0.00869949f, 0.01679051f, -0.02134421f, -0.06814998f, 
    -0.01312395f, 0.03318598f, 0.06648295f, -0.04478759f, -0.04353638f, -0.01091975f, -0.01704144f, -0.07286022f, 
    0.00518586f, -0.02962704f, -0.05361464f, 0.00311661f, -0.00436010f, 0.04690138f, -0.05123654f, -0.02057565f, 
    -0.04226944f, -0.01073566f, -0.05029959f, 0.02203013f, -0.04053435f, 0.06251919f, -0.03427492f, -0.02428619f, 
    -0.06545208f, 0.02010009f, 0.05056427f, 0.05911710f, -0.02438872f, 0.05113752f, -0.06528443f, -0.05114866f, 
    -0.01510168f, -0.04016318f, 0.01739901f, -0.05765495f, 0.02359307f, -0.03740294f, -0.06542020f, -0.01521510f, 
    0.01692611f, -0.04916655f, 0.06380687f, 0.03768119f, 0.03661380f, 0.03969507f, -0.02367966f, -0.06270591f, 
    0.03799691f, 0.01943636f, -0.05075607f, -0.05451319f, -0.02653097f, 0.05736694f, -0.00687875f, -0.03529174f, 
    0.02556643f, -0.04031771f, -0.00257006f, -0.02080639f, -0.01222278f, -0.02268246f, -0.06057195f, 0.02851788f, 
    -0.03455085f, 0.01786632f, -0.05505306f, 0.01040090f, 0.02167721f, -0.05300254f, -0.03272462f, -0.00507550f, 
    0.00947049f, -0.04394446f, -0.03383947f, 0.04698343f, 0.06086729f, 0.01943916f, -0.00734032f, -0.06207141f, 
    -0.00993426f, 0.03451089f, 0.02592175f, 0.00891701f, -0.04566963f, 0.06087637f, -0.04551408f, -0.03176386f, 
    0.05784842f, -0.00818972f, -0.06427522f, -0.00956815f, 0.06668869f, 0.02430699f, -0.07471301f, -0.07200714f, 
    -0.05940924f, -0.01189977f, -0.07161447f, -0.04889790f, -0.07397237f, -0.05505786f, 0.01361558f, -0.04365125f, 
    0.04990548f, -0.06024467f, 0.05091880f, -0.01692717f, 0.00730925f, 0.05372024f, -0.03308665f, -0.04247100f, 
    -0.07700706f, 0.03439845f, -0.01311275f, 0.01653757f, -0.03866381f, -0.05924909f, -0.07465222f, -0.03075171f, 
    -0.00906060f, 0.00663598f, -0.05940212f, 0.03352731f, -0.03872064f, 0.04188273f, -0.01423770f, 0.03532413f, 
    0.02159159f, -0.00245687f, -0.01368772f, 0.01450715f, 0.04193452f, -0.01236479f, -0.06368949f, -0.05711712f, 
    -0.02262202f, -0.05261474f, -0.04120807f, -0.06171580f, 0.06239592f, -0.01690835f, -0.06884699f, 0.01743462f, 
    -0.05843377f, -0.02798424f, -0.00803004f, 0.02696521f, 0.05320366f, -0.05555117f, -0.00048370f, -0.01118869f, 
    0.04503173f, -0.04828297f, 0.04330640f, 0.03744043f, -0.06919670f, -0.03264043f, 0.04412444f, 0.04083972f, 
    -0.00442863f, 0.03716963f, 0.03075318f, 0.03135217f, -0.06460594f, 0.02257582f, -0.06824711f, -0.04903801f, 
    -0.01425072f, 0.06523583f, -0.00541040f, 0.00650002f, -0.03841050f, 0.02863171f, 0.06541568f, 0.05706446f, 
    0.02041761f, -0.04640829f, -0.03448288f, 0.00648764f, -0.01307964f, -0.04123141f, -0.04711761f, -0.04063154f, 
    0.67359322f, -0.02386738f, 0.05390701f, 0.33000350f, -0.26849690f, -0.19051041f, -0.16168119f, -0.17872865f, 
    0.06425895f, -0.05491411f, -0.08290856f, -0.15874892f, -0.18659987f, 0.22121641f, -0.11904376f, -0.07765565f, 
    0.14931156f, 0.07974640f, -0.15976630f, 0.10856640f, -0.03220366f, -0.05720395f, 0.16020758f, 0.09892879f, 
    0.05021525f, -0.33397427f, 0.12845549f, 0.01311130f, -0.00408757f, -0.06302471f, 0.00048609f, 0.02466682f, 
    0.09913457f, 0.21065296f, 0.11700166f, -0.03226001f, 0.30249649f, 0.00917362f, -0.06094071f, 0.17305185f, 
    0.02490968f, 0.13330935f, 0.18797994f, 0.25472608f, 0.08926970f, 0.37405825f, 0.15001327f, 0.12707667f, 
    0.03048272f, -0.28886375f, 0.09802739f, -0.11959851f, -0.21853691f, -0.10435960f, -0.01167979f, 0.03408650f, 
    -0.00435459f, -0.05122693f, 0.14956725f, 0.17311920f, -0.16107418f, 0.02022024f, 0.09040731f, -0.03102701f, 
    -0.02310067f, 0.10898118f, 0.26312456f, 0.18348514f, 0.06645493f, 0.18571740f, 0.24797040f, 0.01311913f, 
    -0.34958276f, 0.15650731f, -0.30632597f, 0.11665746f, -0.16154414f, 0.01297991f, -0.29374966f, 0.10951515f, 
    -0.22978191f, 0.02466685f, -0.10760276f, -0.06713027f, -0.78747267f, 0.08037313f, 0.00567875f, 0.02290072f, 
    0.21461162f, -0.01384714f, 0.04655973f, 0.15307850f, 0.15522073f, 0.13600588f, -0.00098814f, 0.09777799f, 
    -0.09997442f, -0.35887519f, 0.19291787f, 0.42243278f, 0.11061636f, -0.06051549f, 0.15079483f, 0.15156342f, 
    -0.00022590f, -0.09849278f, -0.04563025f, -0.08606178f, 0.11313210f, 0.18476517f, 0.13036810f, 0.23444715f, 
    -0.06650427f, 0.01994323f, 0.07428323f, 0.02017171f, -0.15333030f, -0.00318812f, -0.01267635f, 0.18573265f, 
    -0.25808176f, 0.06938303f, -0.22062293f, 0.18426198f, 0.27784517f, 0.14548178f, -0.02627365f, -0.01428581f, 
    0.10138570f, 0.00236832f, -0.04747255f, -0.02999126f, -0.06999973f, 0.14954408f, -0.19022048f, 0.06798076f, 
    -0.10756284f, -0.15450814f, 0.05154225f, 0.18756250f, 0.05246347f, -0.10785900f, 0.03656609f, 0.02473336f, 
    -0.69609332f, 0.01027258f, 0.25896856f, -0.17075521f, 0.00284628f, 0.23086524f, 0.01166729f, 0.11028621f, 
    0.04320804f, 0.03539617f, -0.05126515f, 0.12546441f, 0.26243728f, 0.06164215f, 0.13320303f, -0.06534842f, 
    0.16500647f, 0.06697314f, 0.05409543f, 0.20160018f, 0.01228249f, -0.21726798f, -0.14359896f, 0.14222336f, 
    0.69933033f, 0.18781139f, 0.13984837f, 0.00856179f, -0.19316350f, 0.08331946f, 0.08338447f, 0.12631406f, 
    0.20350043f, 0.02819679f, -0.02401013f, 0.11409620f, -0.96167457f, 0.21278393f, -0.21260470f, -0.04938740f, 
    0.27474427f, 0.03464004f, 0.14428224f, 0.04309603f, -0.04209504f, 0.04017081f, 0.15641245f, -0.03122137f, 
    -0.06168881f, 0.05318557f, 0.56806266f, 0.03457852f, -0.14365529f, 0.22675800f, 0.12840615f, 0.02973867f, 
    -0.12333529f, -0.21765731f, -0.04603777f, -0.08467229f, 0.58452439f, -0.03767437f, -0.15962628f, 0.43834710f, 
    0.23669291f, 0.08982842f, 0.28352815f, 0.08441354f, 0.14663461f, -0.01054095f, -0.02290115f, 0.06091843f, 
    0.17122957f, -0.55171734f, 0.05968006f, -0.10748562f, 0.19952679f, 0.02916089f, -0.11019666f, 0.18639758f, 
    0.07709610f, 0.06966420f, 0.08253204f, 0.24875040f, -0.18765691f, -0.32280362f, -0.15516809f, 0.20980605f, 
    0.20283544f, 0.15588303f, -0.14490482f, 0.05747069f, -0.03812936f, 0.03230314f, 0.00351143f, -0.14427280f, 
    -0.50516123f, -0.05137026f, 0.07757711f, -0.15997802f, 0.21317373f, -0.15030415f, 0.00374515f, 0.06370972f, 
    -0.09322409f, 0.06856059f, 0.02587136f, 0.15526460f, 0.55257905f, 0.05665398f, 0.19102925f, 0.33664444f, 
    0.21194515f, 0.15765120f, 0.13882190f, -0.08720360f, 0.03959885f, -0.18947814f, -0.06439643f, 0.07132205f, 
    -0.27564111f, -0.22590840f, 0.06539804f, -0.10392175f, 0.15447670f, 0.11858685f, 0.02955856f, -0.01793061f, 
    0.06116191f, -0.01947471f, 0.09165875f, 0.16444956f, 0.36341146f, 0.12114222f, -0.18722081f, -0.10268026f, 
    -0.14010692f, 0.07557747f, 0.04359087f, -0.02037409f, -0.01060760f, -0.03429581f, 0.03497166f, -0.06244043f, 
    -0.31405234f, -0.08563341f, 0.23326592f, -0.13818805f, 0.07491371f, 0.10192946f, 0.05352029f, 0.20191883f, 
    0.00908691f, 0.13243230f, 0.14052922f, -0.10444193f, -0.14287718f, 0.20046178f, 0.05221281f, -0.58705473f, 
    0.06938395f, 0.15384263f, 0.20851603f, 0.13659458f, 0.06790181f, 0.11111441f, -0.00784654f, 0.10702419f, 
    -0.17693505f, -0.26628935f, -0.17226796f, -0.00363756f, 0.01322077f, 0.09271492f, -0.06775437f, 0.04703909f, 
    0.00704160f, -0.12091594f, -0.10305186f, 0.17957596f, -0.05654134f, -0.45806283f, 0.10936309f, 0.04508819f, 
    0.20748624f, 0.04958670f, 0.12697755f, 0.19019486f, 0.00300211f, 0.04195272f, 0.14699611f, 0.08830404f, 
    -0.04315840f, -0.11331045f, 0.12137198f, -0.05946676f, -0.08479302f, -0.09497038f, 0.06021490f, -0.03432440f, 
    0.18451406f, -0.01806388f, -0.00395745f, -0.10220895f, -0.16299438f, 0.39256218f, 0.12180524f, 0.08082369f, 
    -0.14039922f, 0.16585174f, 0.04355769f, 0.06873060f, 0.03886586f, 0.12178314f, 0.22530477f, 0.06137350f, 
    -0.36679795f, 0.29894876f, 0.33349177f, 0.20935020f, 0.06337506f, 0.06018456f, -0.04989157f, -0.12278143f, 
    -0.00428945f, 0.03610145f, 0.02913527f, -0.02875100f, 0.08002366f, -0.10824593f, -0.15114562f, -0.06036590f, 
    -0.04958204f, 0.01673751f, -0.05431507f, 0.04827334f, 0.04617194f, -0.00423210f, 0.09083053f, 0.08242988f, 
    -0.25747278f, -0.43936059f, -0.17055252f, 0.03898120f, -0.16092183f, 0.00085817f, -0.12038050f, -0.20224483f, 
    -0.07832895f, 0.06217526f, 0.05597726f, -0.16095826f, 0.66134077f, 0.20305052f, -0.00226631f, 0.22146434f, 
    0.17357816f, -0.01236125f, -0.19003524f, 0.19648398f, -0.10760137f, -0.02145544f, 0.15264159f, 0.12066370f, 
    -0.16195767f, -0.09309003f, 0.28544202f, 0.13615751f, 0.22789104f, 0.00440397f, 0.18454988f, 0.08427040f, 
    -0.06078592f, 0.27657843f, 0.23573479f, 0.09590887f, 0.20401540f, 0.26400471f, 0.05172104f, 0.22899608f, 
    0.18638282f, 0.09122432f, 0.20351000f, 0.24384396f, -0.14888974f, 0.12334175f, 0.14402975f, -0.21093871f, 
    0.30040762f, -0.25018063f, 0.15364295f, 0.05417497f, 0.31667024f, 0.05093739f, 0.03476324f, -0.00665372f, 
    -0.13816734f, -0.19565646f, 0.06931798f, 0.27071187f, 0.13588662f, -0.21533996f, -0.34709305f, -0.25053895f, 
    0.08916872f, 0.10582490f, 0.09588696f, -0.00329001f, 0.09286976f, -0.05682115f, 0.09031262f, 0.04969146f, 
    -0.20335442f, 0.45905146f, -0.00932057f, 0.12814611f, -0.00817098f, -0.09158905f, -0.06736600f, -0.10906285f, 
    -0.03244262f, 0.20102303f, 0.08475138f, 0.18677436f, -0.18567982f, 0.37180775f, -0.07009308f, -0.21332668f, 
    0.05139998f, -0.10963496f, -0.06135351f, 0.07199246f, 0.17865582f, 0.09741709f, -0.02337398f, 0.00502729f, 
    0.20674969f, -0.17316295f, 0.32840785f, 0.30822951f, 0.14285435f, -0.00062805f, 0.03470884f, 0.05454807f, 
    0.03664939f, -0.02326984f, -0.04269332f, -0.28392118f, -0.34140426f, 0.57474095f, -0.11649055f, -0.56844538f, 
    0.09008680f, -0.01130351f, 0.04355062f, 0.21121494f, -0.09996532f, -0.05812656f, 0.17497630f, -0.03682740f, 
    -0.14200674f, 0.05111267f, 0.02656925f, 0.15415692f, 0.22719081f, 0.09398774f, -0.07341847f, -0.06918397f, 
    -0.05440883f, 0.05586054f, -0.00729926f, -0.08626909f, 0.47143105f, 0.09709313f, 0.06947669f, 0.14310336f, 
    0.01999084f, 0.08623276f, 0.26080579f, 0.16792205f, -0.06692864f, -0.04754430f, -0.02705798f, 0.00446539f, 
    -0.25357842f, 0.14716084f, 0.01639797f, -0.03457577f, 0.17607728f, -0.01308575f, 0.05777417f, 0.01568646f, 
    0.03986412f, 0.12923625f, -0.04929777f, 0.00785320f, -0.48957956f, 0.06009239f, -0.11418539f, -0.33967671f, 
    0.18814072f, 0.06217441f, -0.05903001f, -0.05864198f, 0.15219532f, -0.15843655f, -0.07091104f, -0.08916501f, 
    -0.11883487f, -0.06504738f, 0.43621841f, -0.47443783f, -0.07469271f, 0.09519710f, 0.07866044f, -0.14587019f, 
    -0.05567598f, -0.01220608f, -0.09416050f, -0.07295205f, -0.12053603f, -0.07922101f, -0.10369743f, 0.14493383f, 
    -0.05767084f, 0.12734844f, -0.03471287f, 0.03653059f, 0.03540115f, 0.13845965f, -0.00574975f, 0.06723803f, 
    -0.65440935f, -0.08358339f, 0.16506305f, 0.05166025f, 0.14317723f, 0.21781828f, 0.20853777f, -0.06465992f, 
    0.28310797f, 0.00921519f, 0.06612415f, 0.15820989f, -0.13436927f, -0.13386914f, -0.28433728f, -0.33074084f, 
    -0.09470247f, 0.05041877f, -0.01364920f, -0.01240755f, 0.01455503f, -0.03483047f, 0.01826819f, 0.19155465f, 
    0.25731030f, -0.24407095f, -0.12481639f, 0.50930411f, -0.15633549f, -0.01732422f, 0.14652316f, 0.13282925f, 
    -0.01587484f, 0.12280521f, -0.00605612f, 0.02618208f, -0.00401744f, -0.05932120f, 0.25506163f, 0.21290803f, 
    -0.03924753f, -0.04837675f, 0.01147153f, 0.08434924f, -0.06960002f, -0.06062125f, 0.07524677f, -0.28218448f, 
    -0.17004655f, -0.16661733f, -0.29790768f, -0.36325109f, 0.16732457f, 0.22121574f, 0.03547122f, 0.07806190f, 
    0.17261256f, -0.14796929f, 0.05446505f, -0.00842243f, 0.59546638f, -0.16677527f, -0.13306807f, 0.17562057f, 
    0.25969592f, 0.03951429f, -0.09061113f, 0.11789339f, -0.08407958f, 0.05060291f, -0.13709041f, 0.28485715f, 
    0.15894637f, -0.08574716f, 0.06659526f, -0.19945680f, -0.10233368f, -0.32627389f, -0.04899536f, -0.20816764f, 
    0.12641980f, 0.26147231f, -0.02559015f, 0.08822480f, 0.67192131f, 0.03944127f, -0.07455707f, -0.18702868f, 
    -0.11477425f, -0.04794208f, -0.13246661f, 0.06891872f, 0.08477131f, -0.10337313f, 0.10740360f, -0.09343438f, 
    0.03211156f, -0.04947270f, -0.33727327f, -0.17177860f, 0.14858758f, -0.02476090f, 0.07156031f, 0.08732008f, 
    -0.04943020f, 0.20305750f, 0.26021087f, 0.05592743f, -0.41335571f, 0.04778336f, -0.14191960f, -0.37622720f, 
    0.06181489f, 0.09700328f, -0.03171223f, -0.09450023f, 0.11377988f, -0.01519113f, 0.17209591f, 0.17427814f, 
    0.16812508f, -0.05365617f, 0.21138613f, 0.32481489f, -0.13569796f, 0.02567229f, -0.11410250f, 0.32782179f, 
    0.05926980f, -0.06874949f, 0.06813196f, -0.01679919f, 0.00773551f, 0.04292002f, 0.19672261f, 0.10856039f, 
    -0.07934533f, 0.18518513f, 0.02028330f, 0.07754387f, 0.02078395f, 0.05386566f, 0.05136632f, -0.07430154f, 
    0.06923871f, -0.08961014f, -0.13814950f, -0.22304258f, 0.15001795f, -0.11979770f, -0.05035672f, 0.07480238f, 
    -0.07122084f, 0.03846617f, 0.05678955f, -0.03842408f, 0.25547886f, 0.23790731f, 0.22059354f, -0.04377012f, 
    0.01271044f, 0.26480559f, -0.06935946f, 0.12130353f, 0.09867989f, 0.09632027f, 0.19246078f, 0.09793369f, 
    -0.11262006f, 0.13673654f, 0.39796397f, -0.19035010f, 0.29740968f, 0.12314571f, -0.00595278f, 0.02628432f, 
    0.01076381f, -0.00764930f, -0.01446718f, 0.20567909f, 0.66469663f, -0.16704778f, 0.04680606f, 0.01288668f, 
    -0.19093877f, 0.07188040f, -0.05340634f, 0.18836871f, 0.04558177f, -0.12536015f, 0.03260520f, -0.00624130f, 
    -0.05289454f, -0.05705916f, -0.07211175f, 0.03744846f, 0.01024417f, -0.04514770f, -0.08039150f, -0.02331987f, 
    -0.02537504f, 0.05640933f, -0.03705670f, 0.02661168f, 0.02416182f, -0.07654586f, -0.02334800f, -0.04506414f, 
    -0.04669189f, -0.04162224f, -0.06475510f, 0.02456644f, -0.01039249f, -0.00059149f, 0.05433225f, -0.07235043f, 
    -0.00391196f, 0.04683558f, -0.01506303f, 0.00926345f, 0.00128468f, -0.06122423f, 0.01736186f, -0.03640999f, 
    0.06916590f, -0.01055179f, 0.05795621f, 0.01422014f, 0.03031830f, -0.03064017f, -0.07382724f, -0.03459388f, 
    -0.07141083f, 0.04493958f, 0.03740870f, -0.02310933f, 0.01284966f, -0.03476860f, -0.02294618f, -0.01017596f, 
    -0.01199807f, -0.04495863f, -0.02060618f, -0.01640674f, 0.02270974f, 0.05418495f, -0.01669158f, 0.05006786f, 
    -0.06234536f, -0.03710669f, 0.05486406f, -0.05845693f, 0.01078535f, -0.06765028f, -0.02733995f, 0.00698545f, 
    -0.01268640f, -0.06795595f, -0.07701030f, -0.00478239f, -0.03968174f, 0.03498416f, 0.01563028f, 0.03857698f, 
    -0.06238271f, 0.01445444f, 0.01519768f, -0.01250680f, -0.02806698f, -0.04498722f, -0.01476397f, -0.02719471f, 
    -0.01384294f, 0.04107075f, -0.04287602f, 0.05960375f, -0.05757149f, 0.04824351f, 0.01536321f, -0.03827726f, 
    -0.00186217f, -0.04118316f, -0.02610551f, 0.04665400f, 0.06580097f, -0.04952833f, 0.02350737f, -0.02500782f, 
    -0.03553177f, -0.02903319f, -0.02202766f, 0.02094789f, 0.00849047f, 0.00518546f, 0.00840877f, 0.05593538f, 
    -0.00439023f, -0.02122714f, -0.02888959f, 0.05256413f, -0.07052373f, 0.03723782f, -0.00905330f, -0.03609763f, 
    0.02713514f, 0.02244726f, -0.01977423f, -0.02373281f, 0.00006810f, -0.07820700f, -0.03355257f, -0.01820159f, 
    -0.06829756f, 0.04713375f, -0.03044815f, 0.04933302f, -0.02990720f, 0.00835473f, -0.02643842f, 0.01681801f, 
    -0.07257473f, 0.01823937f, 0.04322987f, -0.05031624f, 0.00482533f, -0.07226221f, 0.06478366f, 0.00829581f, 
    -0.00081281f, 0.00436454f, 0.02396800f, 0.00338354f, 0.05462253f, 0.02748036f, -0.04649902f, 0.03578165f, 
    -0.07167549f, -0.04896847f, -0.03425628f, 0.04117015f, -0.07889479f, -0.03526671f, 0.00495456f, -0.05113174f, 
    -0.00849375f, -0.02654469f, 0.04284485f, 0.00983593f, -0.06077851f, -0.06672332f, 0.01714080f, -0.00470028f, 
    -0.02410449f, -0.01826496f, 0.00695033f, -0.07048258f, -0.01162673f, -0.00750419f, -0.04139761f, 0.05526569f, 
    -0.02413973f, -0.04374896f, 0.01929874f, 0.04735512f, -0.03088110f, 0.05308335f, -0.00493215f, 0.05957497f, 
    -0.07199784f, -0.07143407f, 0.06390622f, 0.04925608f, -0.04921517f, 0.01749318f, 0.03838650f, -0.06981716f, 
    0.00888029f, 0.00437037f, -0.04290469f, -0.00801739f, -0.05811026f, 0.06042590f, 0.02421651f, -0.03667940f, 
    0.00492117f, 0.00628996f, -0.07316478f, 0.05033978f, 0.02635219f, -0.08140721f, -0.04751333f, -0.06184888f, 
    -0.03687397f, -0.01896258f, -0.04362257f, 0.03858050f, -0.02615485f, 0.06454068f, 0.01911090f, -0.03876256f, 
    0.01595774f, -0.05697206f, 0.02513603f, 0.02343286f, 0.05408521f, -0.05582830f, -0.05492976f, 0.02702644f, 
    -0.05228016f, 0.05442617f, -0.01856047f, 0.03490248f, -0.04822523f, 0.00688488f, -0.06572742f, 0.05864647f, 
    -0.04688904f, -0.05701403f, -0.02098790f, 0.05527645f, 0.01573692f, -0.02069403f, 0.03353451f, 0.01861263f, 
    -0.07771654f, 0.05404467f, 0.05491025f, -0.07176901f, -0.03650417f, 0.02274412f, 0.06679413f, 0.00377640f, 
    -0.00568159f, -0.07060351f, -0.05644961f, -0.07321426f, -0.02135052f, 0.05473994f, 0.03688412f, -0.00306903f, 
    0.01471713f, 0.04990240f, -0.03858611f, 0.02793468f, 0.00292441f, -0.05923697f, 0.05170348f, 0.01970991f, 
    0.04852333f, -0.06688774f, -0.03772473f, -0.01010143f, 0.03840562f, 0.05314605f, 0.05714442f, 0.03978072f, 
    -0.05732050f, 0.06376585f, -0.06171056f, -0.02718098f, 0.01119041f, 0.05127212f, 0.05008480f, -0.04222696f, 
    -0.07704619f, -0.04960763f, 0.04180068f, -0.03396986f, -0.06672114f, -0.00958725f, 0.03542019f, 0.05814683f, 
    -0.07185917f, 0.00252874f, -0.05791260f, 0.00119596f, -0.03510987f, -0.05155129f, -0.04252558f, -0.04982840f, 
    0.03548987f, 0.00900336f, -0.02745822f, -0.04483135f, -0.01650760f, 0.03152997f, -0.02402308f, -0.05302058f, 
    0.01655413f, -0.00841248f, -0.00544346f, -0.07674056f, -0.00568542f, 0.04995541f, 0.02450977f, 0.01825728f, 
    0.04631035f, -0.03087831f, -0.02552067f, -0.01340540f, 0.00140227f, -0.06903555f, 0.00360998f, -0.01361420f, 
    0.06403818f, -0.00566667f, -0.03074982f, -0.00712887f, -0.03141567f, -0.05827677f, -0.02791313f, 0.04590630f, 
    -0.02883361f, 0.02935257f, -0.03538972f, 0.05852361f, 0.02570103f, 0.02533265f, 0.00630469f, -0.04112449f, 
    0.05650030f, 0.01445015f, 0.00529986f, -0.00345256f, 0.01970152f, 0.03275983f, 0.00979489f, -0.01609712f, 
    0.05236179f, -0.03419764f, -0.02408874f, -0.00295970f, -0.05204351f, -0.08556035f, -0.03248113f, 0.05222176f, 
    -0.01414863f, -0.00301638f, -0.01547970f, 0.05246286f, -0.04737525f, -0.01125718f, 0.00537342f, 0.05171886f, 
    0.05683106f, 0.02663398f, -0.07046755f, -0.07968757f, 0.03013122f, 0.01870491f, -0.02504672f, 0.05288534f, 
    0.03855432f, -0.03660231f, -0.05813603f, -0.04580665f, 0.02177479f, -0.04892172f, -0.01704262f, 0.02154467f, 
    -0.07829498f, -0.01616046f, -0.00176945f, -0.05113769f, -0.08027316f, -0.06084745f, -0.07098108f, 0.05213086f, 
    0.06163852f, -0.06821764f, -0.01536484f, -0.00347192f, 0.03445831f, -0.02652829f, -0.05939553f, 0.03893145f, 
    -0.19477116f, -0.36747476f, -0.04107770f, -0.36099967f, 0.14390646f, 0.00288878f, 0.01175016f, 0.04257399f, 
    0.13247713f, 0.17860277f, 0.09579818f, 0.04769350f, -0.07976201f, 0.12590513f, -0.06520855f, 0.07211228f, 
    -0.18993853f, -0.05257437f, 0.04772890f, -0.11455941f, -0.04141043f, 0.05251713f, 0.04611328f, 0.00909082f, 
    0.13776457f, 0.51217365f, 0.28913829f, 0.09035722f, 0.17711954f, -0.04268241f, 0.14996460f, 0.20991822f, 
    0.00081489f, 0.12847656f, 0.09403994f, -0.01658200f, -0.07593795f, 0.32786119f, 0.07540168f, 0.13150090f, 
    -0.23338054f, -0.04475344f, 0.21511860f, 0.11276028f, -0.06478459f, 0.10122371f, -0.01397688f, -0.01751781f, 
    0.08510556f, 0.06904422f, -0.09640849f, -0.39685881f, 0.27390158f, 0.24260311f, -0.01439603f, -0.00272158f, 
    0.13036217f, -0.28657928f, 0.00837247f, 0.02248873f, 0.40001577f, 0.16197772f, -0.10154584f, 0.37475279f, 
    -0.05486748f, 0.11187100f, -0.04915957f, -0.01012350f, -0.06760427f, 0.17855918f, -0.00548037f, 0.00119875f, 
    0.04059140f, 0.15837109f, 0.15742603f, -0.20020305f, -0.05545673f, 0.01488865f, -0.09595900f, 0.04611046f, 
    0.14585762f, 0.02963270f, 0.12623730f, 0.14862525f, -0.22281851f, -0.40388811f, -0.12374006f, 0.16939965f, 
    -0.11394934f, -0.10992549f, 0.03284930f, -0.11981350f, 0.00743472f, -0.00756439f, -0.26521561f, -0.10426113f, 
    -0.16823673f, 0.41475365f, -0.02857656f, -0.39808157f, 0.13410561f, 0.04786522f, -0.06003848f, 0.03809594f, 
    0.02208575f, 0.08189140f, 0.10527480f, -0.11379860f, -0.13833088f, 0.20334023f, 0.07705568f, -0.13736892f, 
    -0.14556898f, -0.15457478f, -0.08420769f, -0.05442730f, -0.07742395f, 0.06848759f, 0.04530968f, -0.00968699f, 
    0.42306566f, 0.29315233f, 0.20599797f, 0.36381599f, 0.09139516f, 0.03622434f, -0.07589375f, 0.23055664f, 
    -0.13128105f, 0.00573984f, 0.05236538f, -0.02316426f, 0.39907539f, 0.08471809f, 0.12648794f, 0.01485770f, 
    -0.04621454f, -0.08163696f, 0.02297421f, 0.07407295f, 0.10122520f, -0.34808192f, -0.11783450f, -0.03753636f, 
    0.43735895f, 0.20767201f, -0.00581167f, -0.29607645f, 0.19341737f, 0.00463049f, -0.01058384f, -0.08410825f, 
    -0.02631155f, 0.04829048f, -0.05768169f, -0.07387295f, 0.19378430f, 0.23476915f, -0.02824669f, 0.20087318f, 
    -0.18167821f, 0.03829051f, 0.01723666f, -0.07393436f, -0.10323007f, 0.16303898f, -0.06325247f, 0.03932513f, 
    -0.04352746f, -0.24855062f, -0.07945409f, 0.09095459f, 0.03345733f, -0.07551447f, 0.05637592f, 0.08478764f, 
    0.09539387f, 0.02918431f, 0.03724247f, -0.16687889f, 0.55790639f, 0.07712330f, 0.20145950f, 0.10736527f, 
    -0.05282458f, 0.04881004f, -0.02566002f, -0.10393430f, -0.04680812f, 0.08062889f, 0.02710710f, 0.12096000f, 
    0.44678336f, 0.55031657f, 0.35982808f, -0.23602420f, 0.17810191f, 0.00296982f, 0.03205946f, 0.12099348f, 
    -0.15343463f, -0.07968369f, 0.12195425f, 0.13664174f, -0.16681650f, 0.24785696f, -0.00367150f, 0.26864237f, 
    0.06369977f, -0.05841318f, 0.06667200f, -0.09392488f, 0.25494695f, 0.06664116f, -0.14389384f, -0.04127246f, 
    0.30983973f, -0.32169440f, -0.10864813f, 0.03206059f, 0.11575309f, 0.09812915f, -0.20520630f, -0.09929332f, 
    0.02068394f, -0.21729998f, -0.18023810f, -0.13799559f, -0.05367384f, -0.24529113f, -0.06539932f, -0.13595919f, 
    0.09346801f, 0.17232931f, 0.02012942f, 0.01625175f, 0.16339773f, -0.14883569f, -0.22601604f, 0.08013522f, 
    -0.44253972f, 0.00608605f, 0.03246107f, 0.14893626f, -0.20962556f, 0.10371592f, 0.13687424f, -0.00584998f, 
    -0.03473669f, 0.12858164f, 0.03229829f, -0.03646945f, -0.09619685f, 0.09040515f, 0.30455408f, -0.01205580f, 
    0.20263161f, -0.03611099f, -0.09388515f, -0.19205807f, -0.01438080f, 0.03609626f, -0.25503734f, -0.03161842f, 
    -0.21046762f, -0.31972411f, 0.10984573f, 0.03763618f, 0.15383431f, 0.01816263f, 0.27598032f, -0.05807601f, 
    0.11867264f, -0.02793432f, -0.04335593f, 0.00982888f, 0.15863594f, 0.19156994f, -0.06532571f, 0.00053946f, 
    -0.02550034f, 0.15415990f, -0.05979899f, 0.14008665f, -0.14293273f, -0.03098985f, 0.28783667f, 0.20842521f, 
    -0.16473269f, -0.10707435f, -0.08921257f, -0.03293977f, 0.00183528f, 0.07312155f, -0.05852095f, 0.02735948f, 
    -0.06573508f, 0.20989986f, 0.21095338f, 0.24562737f, -0.32092154f, -0.37865379f, 0.04417740f, 0.11878333f, 
    0.02576111f, 0.02990704f, 0.17346290f, -0.22549002f, 0.06518221f, -0.03525229f, 0.10080948f, -0.01604775f, 
    -0.06532259f, -0.25581279f, -0.02922454f, 0.11655422f, 0.02190174f, -0.00925329f, 0.16549882f, 0.13645461f, 
    -0.00380852f, 0.01667554f, -0.01428190f, 0.12322751f, -0.24302526f, -0.03881104f, -0.03427512f, 0.10068116f, 
    0.10113303f, 0.11075282f, -0.20254098f, -0.13635075f, 0.16182239f, 0.14653394f, 0.00110359f, -0.15582782f, 
    0.09724581f, -0.49259350f, 0.18437405f, -0.05457223f, 0.00117626f, 0.07701774f, 0.00230653f, 0.16908403f, 
    0.00093494f, -0.07133808f, 0.16213287f, -0.02639281f, 0.61746937f, -0.02634632f, 0.03071833f, -0.00581630f, 
    0.11948696f, 0.28021815f, 0.15101653f, 0.01584356f, 0.05734963f, 0.25519356f, 0.19759572f, 0.03023327f, 
    0.47831544f, 0.02217148f, -0.08551776f, 0.03520103f, 0.02465602f, -0.13550979f, -0.16771805f, -0.07213086f, 
    0.02154618f, -0.03264250f, 0.21297260f, 0.07289878f, 0.00277474f, 0.12557201f, 0.06619067f, -0.07126214f, 
    0.03739440f, -0.03719516f, -0.07715852f, 0.05274312f, -0.00250147f, 0.00473454f, 0.08902663f, -0.29356703f, 
    -0.04260155f, -0.18226376f, 0.14124486f, 0.18488386f, 0.07672197f, 0.02203714f, 0.05921109f, 0.07591625f, 
    0.03290740f, 0.08365012f, 0.04323806f, 0.35233518f, -0.18475869f, 0.29449469f, -0.02690245f, 0.11116178f, 
    0.01036543f, -0.13794811f, 0.06585327f, -0.00080803f, -0.02786439f, -0.05867212f, -0.01706531f, 0.12488341f, 
    -0.25930646f, -0.10628528f, 0.01884873f, -0.26032895f, -0.01043032f, -0.08763672f, -0.17219989f, -0.09005582f, 
    -0.06384411f, -0.23068593f, 0.02622468f, 0.01675658f, -0.00551591f, -0.11934372f, -0.07953546f, -0.25334892f, 
    0.22407487f, 0.18431196f, -0.02862248f, 0.08650399f, 0.10868423f, -0.13221531f, -0.28676698f, 0.18728231f, 
    -0.16237831f, 0.27911520f, 0.14202940f, 0.09103569f, 0.02703170f, 0.14804292f, 0.14048280f, 0.07793179f, 
    0.01211257f, 0.09445857f, -0.02200921f, -0.04963058f, -0.05316722f, 0.25707117f, -0.13411829f, -0.11532129f, 
    -0.00965857f, -0.11936791f, -0.23792541f, -0.07384481f, 0.15763424f, 0.04620448f, -0.19929449f, -0.20819744f, 
    -0.24200085f, -0.11057729f, -0.35404146f, 0.30148944f, 0.10282446f, -0.28386268f, 0.18464452f, 0.02995724f, 
    0.35816315f, 0.03279839f, -0.11229531f, -0.00182146f, -0.29368174f, 0.32298371f, 0.08245502f, -0.20644149f, 
    0.10242839f, 0.12984614f, -0.15100084f, 0.15428674f, -0.09019355f, 0.24623586f, 0.21855219f, 0.28119802f, 
    0.29500845f, 0.07816079f, 0.00983525f, -0.07979763f, -0.16427004f, 0.09822822f, 0.08592670f, 0.07702544f, 
    0.02387941f, 0.28971905f, 0.26747438f, 0.25756368f, 0.03675053f, 0.03676072f, -0.05530937f, 0.05605929f, 
    0.22894864f, 0.01512576f, 0.06807263f, 0.08252051f, 0.01542134f, -0.00474546f, 0.14624155f, 0.18580979f, 
    0.08750110f, -0.03854093f, -0.12437098f, 0.03363307f, 0.13656433f, 0.01004525f, 0.16947250f, 0.03713530f, 
    0.06495094f, -0.01974949f, 0.12213556f, 0.27184540f, 0.05143789f, -0.21076524f, 0.18471670f, -0.30358195f, 
    0.16817360f, 0.14024562f, -0.06836011f, -0.01240903f, 0.11010550f, 0.31186765f, -0.20062289f, 0.04134112f, 
    -0.58250296f, 0.01163956f, -0.06622411f, 0.00573664f, 0.00096321f, 0.00490986f, 0.00243336f, -0.07767660f, 
    -0.02734571f, -0.09371044f, 0.04309485f, -0.14712757f, -0.20477031f, -0.28198028f, -0.10536909f, -0.02901378f, 
    0.19573955f, 0.06658901f, 0.02644674f, 0.07311282f, 0.17391387f, -0.06203229f, 0.24148089f, 0.06181408f, 
    -0.13650754f, -0.07960068f, -0.12422626f, 0.27472657f, 0.17696442f, -0.20339261f, -0.07205968f, -0.11977957f, 
    -0.02066809f, -0.19994222f, 0.13811012f, 0.14559869f, 0.07007852f, 0.05224947f, -0.17185381f, -0.12868467f, 
    0.07573591f, -0.00933167f, 0.05448853f, 0.11320850f, -0.01917498f, 0.00915068f, -0.06004136f, -0.17163362f, 
    0.04390458f, -0.03850787f, -0.11587813f, 0.38760206f, 0.06656178f, 0.08791211f, -0.04981690f, 0.05503258f, 
    0.07427541f, 0.04450514f, -0.02646622f, -0.04495143f, -0.38652277f, 0.00370076f, -0.03235742f, -0.02049334f, 
    -0.16520463f, 0.04349848f, -0.13727769f, 0.02670252f, -0.00174782f, 0.06838053f, 0.08537981f, 0.01007644f, 
    -0.70137882f, -0.17390217f, -0.11583278f, -0.02583050f, -0.05786257f, -0.04570391f, 0.27653706f, 0.13355115f, 
    0.08891658f, 0.24176867f, 0.03810455f, -0.04087752f, 0.37009755f, -0.01400700f, 0.14198817f, -0.11418667f, 
    0.03724936f, 0.04137922f, 0.00948835f, 0.06454526f, -0.00131491f, 0.04692874f, 0.16443704f, 0.05301654f, 
    0.21223581f, 0.17992462f, -0.33869562f, 0.24504113f, 0.00423136f, 0.03073625f, -0.01568140f, 0.08777004f, 
    0.03936583f, -0.07147300f, -0.03953561f, -0.03401721f, -0.01211819f, -0.14027993f, -0.10261044f, 0.12994398f, 
    -0.06582052f, 0.18989293f, -0.01218391f, 0.18747723f, -0.06958321f, 0.18688202f, -0.11538603f, 0.15908547f, 
    -0.07205865f, -0.02217271f, -0.11895417f, 0.03311522f, 0.04689044f, -0.23869826f, -0.25725612f, -0.12218824f, 
    0.04073700f, 0.04521305f, 0.00648494f, -0.03424300f, -0.03746828f, 0.22886868f, -0.05045705f, 0.05143774f, 
    0.14611334f, 0.05585982f, -0.05949243f, 0.07524455f, -0.02226519f, -0.06064506f, -0.04472641f, -0.22704373f, 
    0.30303302f, -0.28037331f, 0.03861813f, -0.06198980f, 0.07659908f, 0.02265158f, 0.12876023f, 0.04108518f, 
    -0.06561408f, 0.16676092f, -0.01271032f, -0.10036553f, 0.53340352f, -0.20748691f, -0.23201144f, 0.10925253f, 
    0.06961662f, -0.06246130f, -0.08259282f, -0.09242099f, -0.06506206f, -0.02519985f, -0.07437664f, -0.01108599f, 
    0.71454602f, 0.02781981f, -0.12308232f, -0.04702158f, -0.05098899f, 0.01262041f, 0.13271023f, 0.05164497f, 
    -0.05312758f, -0.01269532f, 0.06252604f, -0.07650147f, 0.02923410f, 0.29658169f, 0.38817909f, -0.13377167f, 
    0.00377468f, 0.18551753f, 0.20874137f, -0.05613653f, -0.02160592f, 0.01032962f, 0.15849538f, -0.06817164f, 
    -0.16188449f, -0.03669943f, -0.34496319f, -0.04178371f, 0.10187143f, 0.01595534f, 0.01140182f, -0.01963285f, 
    -0.18087877f, -0.01296011f, 0.06824978f, 0.13122700f, 0.12825808f, 0.04707616f, 0.01468238f, -0.01882046f, 
    -0.21384822f, -0.04899083f, -0.00275764f, -0.02736848f, 0.02335963f, -0.01785163f, -0.04041395f, 0.01455326f, 
    0.29410121f, 0.19985560f, 0.07973336f, -0.22250621f, 0.01396039f, 0.08701038f, 0.11473373f, 0.05548993f, 
    -0.09184100f, -0.04906166f, -0.08659796f, 0.03620354f, 0.90758294f, -0.23176773f, -0.03246835f, 0.04942373f, 
    -0.11400429f, 0.06349225f, 0.19329132f, 0.10345574f, 0.15169668f, -0.15008712f, 0.06777247f, 0.06684152f, 
    0.20349848f, -0.19849893f, 0.29534230f, -0.15196648f, 0.13102998f, -0.09057532f, 0.20892783f, -0.00925709f, 
    0.13896739f, 0.12875003f, 0.00223994f, 0.14348704f, -0.32763159f, 0.33032808f, 0.04108572f, 0.09446952f, 
    -0.21422108f, 0.17253458f, 0.06454310f, 0.08270050f, 0.17251177f, 0.13123359f, 0.20037481f, -0.22123387f, 
    -0.08696374f, 0.04925916f, -0.10616908f, -0.44533652f, -0.43255541f, -0.03448570f, -0.03232704f, -0.00950576f, 
    -0.14131482f, 0.00291532f, -0.01333799f, -0.05706429f, 0.26901013f, -0.14309314f, 0.06668029f, -0.41645133f, 
    -0.01537456f, -0.19819157f, 0.12510803f, -0.10062445f, -0.05797918f, -0.15702897f, -0.00987083f, 0.00366150f, 
    -0.18692540f, 0.24958308f, 0.01411852f, -0.03709994f, -0.11870429f, 0.08948316f, -0.01413860f, 0.05974655f, 
    0.20735541f, 0.14669321f, 0.19907328f, 0.01361694f, -0.41022843f, -0.20508356f, -0.31304064f, -0.11275318f, 
    0.13107686f, -0.07933089f, -0.13313898f, 0.37643328f, -0.02659621f, 0.25036943f, -0.31349730f, 0.10148139f, 
    0.25175613f, -0.36433035f, 0.00798603f, -0.08734620f, -0.01538062f, -0.08768034f, -0.15294817f, -0.09336859f, 
    -0.08542873f, 0.13989311f, -0.05156120f, -0.03572181f, -0.07628243f, 0.63571137f, 0.00628182f, 0.26739809f, 
    0.09182411f, -0.02621569f, 0.10797966f, 0.21196653f, 0.17606373f, 0.01489903f, -0.02337607f, -0.06000084f, 
    0.22619590f, -0.03010449f, -0.00724543f, -0.27752641f, 0.12959078f, 0.38904303f, 0.14095093f, -0.04637484f, 
    -0.01625355f, 0.03283218f, -0.13753544f, 0.14380632f, 0.34909838f, -0.05013772f, 0.04853936f, 0.00188912f, 
    0.09012745f, 0.13924722f, 0.03578413f, -0.00220252f, 0.09526818f, -0.05107908f, 0.04577198f, -0.08737167f, 
    0.72316563f, 0.14444250f, -0.34847352f, -0.15287811f, -0.02284998f, -0.17497589f, 0.13776299f, 0.33763751f, 
    0.03871060f, 0.00123891f, 0.04609829f, 0.15297462f, -0.05185566f, 0.28872287f, -0.03342988f, -0.41089198f, 
    -0.26476166f, 0.21046366f, 0.02813033f, -0.08816287f, 0.13355927f, 0.03311573f, 0.18097483f, -0.00373519f, 
    0.59723639f, 0.13274972f, -0.28171453f, 0.19932146f, -0.03301034f, 0.03154159f, 0.01530544f, -0.14575759f, 
    -0.05516244f, -0.11419828f, 0.24447453f, 0.17250766f, -0.39205754f, -0.22602691f, -0.34069610f, 0.05123722f, 
    0.04291483f, -0.06661795f, 0.04219617f, 0.03200064f, 0.11227927f, 0.08605719f, 0.11908688f, 0.33381078f, 
    0.07497301f, -0.04790064f, -0.24728712f, -0.04385956f, -0.10057399f, -0.11069458f, -0.02886562f, 0.08273089f, 
    0.13048846f, 0.14182478f, -0.02684670f, 0.05673750f, 0.13631995f, -0.08793329f, -0.11049902f, 0.24725972f, 
    0.05341041f, -0.05675101f, -0.04051443f, 0.07307026f, -0.05609041f, -0.01782363f, 0.06364122f, 0.10773700f, 
    -0.07633025f, 0.28446695f, -0.34452224f, 0.43104067f, -0.00161609f, 0.20219013f, -0.07573079f, -0.10933091f, 
    0.23001979f, -0.05156229f, -0.14422189f, -0.08299473f, 0.06704044f, -0.40314040f, 0.24140716f, -0.58414811f, 
    0.07814251f, 0.05802290f, -0.16852225f, 0.10473067f, -0.03523178f, 0.04457925f, 0.04233275f, 0.12693448f, 
    -0.19278972f, 0.04708729f, -0.34403089f, 0.31843624f, -0.27631804f, 0.04919241f, 0.31890485f, -0.04018831f, 
    -0.12300646f, 0.14585495f, 0.00763783f, 0.16461919f, 0.01517912f, 0.26027039f, -0.05323687f, 0.02834534f, 
    0.06143215f, -0.15037142f, -0.02666830f, -0.16281109f, 0.03333795f, 0.06872474f, 0.25652161f, 0.06167433f, 
    0.61524582f, -0.01602726f, -0.14130855f, 0.17097558f, -0.06949578f, -0.10911493f, -0.03150307f, -0.07962298f, 
    0.02573948f, 0.26753899f, 0.05605876f, 0.01076757f, -0.10610852f, -0.17873050f, -0.02469787f, -0.21607663f, 
    0.01892396f, -0.25221419f, 0.04195730f, 0.10913543f, -0.11922212f, 0.01355514f, 0.18835358f, 0.20731460f, 
    0.40987700f, 0.22338687f, -0.08181611f, -0.16739561f, 0.01495902f, -0.04385539f, 0.11581596f, 0.02422552f, 
    -0.14868128f, -0.07618183f, -0.07674311f, -0.16469121f, 0.08010856f, -0.07538307f, 0.15733089f, -0.20368415f, 
    0.21429713f, -0.03922310f, 0.06030036f, 0.12682588f, 0.06663965f, -0.04081742f, 0.08311830f, -0.02907357f, 
    0.49147284f, 0.09755331f, -0.43602997f, 0.37503153f, 0.02032101f, -0.02194086f, -0.01018761f, -0.14065479f, 
    0.16256021f, -0.17346883f, -0.08299135f, 0.04421213f, 0.27799493f, 0.01232176f, -0.03045585f, 0.27308688f, 
    0.04067496f, 0.14333484f, -0.07870124f, 0.12937228f, 0.15189566f, -0.04687629f, 0.01323043f, 0.07898003f, 
    -0.32134682f, -0.02667916f, 0.50269252f, -0.22653905f, -0.15459324f, -0.01978971f, 0.09133764f, -0.20266673f, 
    0.21776994f, 0.10277902f, 0.08406888f, -0.08847331f, -0.23032045f, 0.16570246f, 0.01007590f, 0.01462386f, 
    -0.05804508f, 0.01533277f, 0.12936974f, -0.05075987f, -0.04546020f, 0.27248290f, 0.19706161f, 0.19079584f, 
    0.04817758f, 0.09186945f, -0.16826692f, 0.22895484f, 0.02411497f, 0.07177501f, 0.07377484f, 0.09583929f, 
    0.04439367f, 0.16540940f, 0.01123643f, 0.26771617f, 0.13627720f, -0.23797998f, 0.08165032f, 0.05516940f, 
    0.21939240f, 0.01461387f, -0.20007910f, -0.11200468f, 0.06870978f, -0.07156274f, -0.07782435f, 0.00676935f, 
    0.09109843f, 0.11951776f, 0.14018619f, -0.08146858f, 0.26905641f, 0.06814083f, -0.01699270f, 0.08413449f, 
    0.03689940f, 0.12926771f, 0.02538077f, 0.12676668f, -0.36834854f, -0.07233135f, 0.06051821f, -0.03369039f, 
    0.02855922f, -0.00953603f, 0.30935159f, -0.00248823f, 0.03166527f, -0.03817095f, 0.18849349f, 0.11835083f, 
    -0.05265659f, -0.04241630f, -0.02831712f, 0.01738304f, 0.02969957f, 0.02957108f, -0.05486220f, 0.01497491f, 
    0.04248374f, 0.02877328f, 0.01199933f, -0.07619562f, 0.03784190f, 0.02114534f, 0.01849402f, -0.00023189f, 
    -0.05848934f, -0.07643510f, -0.01751582f, 0.03372469f, -0.07432924f, 0.05081899f, 0.05671916f, -0.03117402f, 
    0.00856485f, 0.05576716f, -0.02523344f, -0.00911021f, -0.02600059f, -0.06658337f, -0.03497151f, -0.06805129f, 
    -0.01019345f, -0.01894733f, 0.02138522f, 0.00289747f, -0.06938887f, 0.02443830f, 0.03037795f, -0.04827071f, 
    -0.07532638f, 0.02521215f, -0.06014475f, -0.07598316f, 0.05896457f, 0.05227640f, 0.03502539f, -0.05914721f, 
    0.04276795f, -0.07763880f, 0.03968219f, -0.02802288f, -0.03297656f, -0.06489652f, -0.07468244f, -0.04873588f, 
    -0.06819593f, 0.02819252f, -0.02347270f, 0.06305517f, 0.04896465f, -0.02203522f, 0.00001519f, -0.05626738f, 
    -0.00744589f, -0.01969148f, 0.05482096f, 0.03621119f, -0.00262667f, 0.02688902f, -0.01395946f, -0.06361392f, 
    0.04247634f, 0.03049122f, -0.07231651f, 0.00677956f, -0.07767680f, -0.07569163f, 0.02175028f, 0.02265661f, 
    -0.02281826f, 0.05012476f, 0.05395158f, -0.03561259f, 0.04166720f, -0.02546761f, -0.03418140f, -0.04021449f, 
    0.01533627f, -0.04369560f, -0.03132130f, -0.05067509f, -0.05869888f, 0.06170936f, -0.04743548f, -0.03488053f, 
    -0.02889388f, 0.04033780f, -0.04199000f, -0.04026723f, 0.00590534f, -0.07974608f, -0.04029115f, -0.02782664f, 
    0.03382532f, -0.06401549f, 0.02187140f, 0.05067637f, 0.01192941f, 0.00895407f, 0.04917011f, -0.04775985f, 
    -0.03066337f, -0.01448392f, 0.02491189f, 0.02914841f, 0.00288952f, -0.03773632f, -0.01773766f, 0.03259946f, 
    -0.03966909f, -0.03266256f, 0.04294704f, -0.02105825f, 0.01678794f, 0.05329800f, 0.03756749f, 0.02104707f, 
    -0.01167502f, 0.05223826f, -0.04218646f, -0.00121588f, 0.00587302f, 0.03054855f, 0.01966750f, -0.01156038f, 
    -0.01354454f, -0.00603713f, -0.02742242f, 0.03268378f, -0.02283319f, -0.01387340f, -0.07534938f, 0.00103944f, 
    -0.05614980f, 0.03900902f, -0.01240732f, 0.00770838f, -0.01085305f, 0.01984866f, -0.04894143f, -0.07823860f, 
    -0.06733775f, 0.00983071f, -0.02791950f, 0.04555481f, 0.03626394f, -0.02586403f, 0.01754051f, -0.03744985f, 
    0.01345588f, 0.00996579f, -0.07600575f, -0.05260712f, 0.05653984f, 0.03468287f, 0.06115635f, -0.06779920f, 
    0.00995244f, -0.02619144f, -0.00740760f, 0.02595710f, 0.02016933f, -0.02852336f, -0.00494998f, 0.02875221f, 
    -0.03055355f, -0.00906514f, 0.05632478f, 0.03192138f, 0.01404338f, -0.04353423f, -0.03032956f, 0.00836495f, 
    -0.00837944f, -0.00702586f, 0.06334335f, 0.01749610f, -0.02780058f, -0.04475037f, -0.07564316f, -0.03135038f, 
    -0.29876909f, -0.47659406f, -0.06472475f, -0.03357695f, 0.16244400f, 0.10941986f, 0.12066387f, 0.04876548f, 
    0.15397429f, 0.05422443f, -0.05402287f, 0.17854828f, -0.27223575f, 0.22136620f, -0.06657184f, -0.06327012f, 
    -0.15667453f, -0.12784466f, 0.06254356f, -0.01958761f, 0.12255327f, 0.04267038f, -0.00699551f, 0.13674033f, 
    -0.14577614f, 0.29868913f, 0.18045498f, -0.19560571f, -0.10745648f, -0.06011671f, 0.10191302f, 0.09266841f, 
    0.01844860f, -0.09700713f, 0.04503226f, -0.01880366f, -0.19962238f, -0.05617949f, 0.15631197f, -0.13222116f, 
    -0.23203103f, -0.05720099f, -0.05671266f, 0.21994919f, 0.17359482f, 0.00337170f, -0.08356078f, 0.20192890f, 
    0.06847131f, 0.14296281f, -0.05851612f, -0.37870723f, 0.18866944f, 0.00893849f, 0.02178608f, -0.04249058f, 
    0.05232104f, -0.10514563f, -0.00097832f, -0.00089987f, 0.32639334f, 0.27765170f, -0.13796467f, 0.25270844f, 
    0.05943238f, 0.05053602f, -0.08614268f, 0.02200445f, 0.03409863f, 0.21162014f, -0.01256640f, -0.05668599f, 
    0.08987354f, -0.38317418f, -0.05618225f, -0.03887215f, -0.08002101f, -0.00396799f, -0.03928474f, -0.05040956f, 
    0.31774464f, -0.01572657f, 0.09527050f, -0.01526446f, -0.10304788f, -0.25530577f, 0.02827301f, 0.13633363f, 
    -0.10683554f, 0.10485232f, 0.06231811f, -0.06901181f, -0.22094315f, 0.05242138f, -0.02998902f, -0.02538283f, 
    0.03410612f, 0.39220342f, -0.13327873f, -0.50990778f, -0.06076777f, 0.05701260f, -0.05613058f, 0.02267665f, 
    -0.02594515f, 0.17507777f, 0.23796514f, 0.10051816f, 0.44459832f, -0.03090232f, 0.05860034f, 0.24400951f, 
    0.01620730f, -0.11014865f, -0.15152456f, -0.04136117f, -0.02098103f, 0.02201491f, -0.07318406f, 0.09907345f, 
    0.49590707f, 0.20313834f, 0.06453884f, 0.15199834f, -0.07603298f, -0.10851697f, -0.01717490f, 0.21953209f, 
    -0.06383108f, -0.06907719f, 0.08200510f, -0.04257376f, 0.15328999f, -0.22062790f, 0.00862450f, -0.23517722f, 
    -0.10753893f, -0.07410672f, -0.01019209f, 0.00622212f, 0.17883134f, -0.04687848f, -0.15202981f, 0.01524513f, 
    0.32095772f, 0.37207383f, -0.22876330f, -0.09108599f, -0.00970625f, 0.03041107f, -0.08322743f, -0.14632709f, 
    0.07206443f, -0.04318717f, 0.06350596f, -0.10965536f, -0.01976974f, -0.19993213f, -0.03629014f, 0.26599711f, 
    -0.09332580f, 0.02667582f, 0.11624315f, 0.06321813f, -0.09031092f, 0.01235346f, -0.07263699f, 0.09166396f, 
    -0.32720909f, -0.33587360f, -0.20868464f, 0.51241076f, 0.11503418f, 0.02757987f, 0.06899368f, 0.15237603f, 
    -0.00832134f, -0.19162422f, -0.04256149f, -0.00305758f, 0.56658661f, 0.01845462f, 0.13395160f, 0.04818168f, 
    -0.07899101f, 0.05411514f, 0.08545558f, -0.01493870f, -0.09260508f, 0.04248554f, -0.01017573f, 0.11662887f, 
    -0.00604381f, -0.05424819f, -0.06190813f, -0.01087100f, 0.00908095f, -0.00352676f, 0.05842393f, 0.05046974f, 
    -0.00459839f, -0.06693707f, 0.05224086f, 0.02922142f, 0.04993666f, 0.02995384f, -0.02233012f, 0.02679806f, 
    0.04381301f, 0.01235207f, -0.03963098f, -0.02424656f, -0.04126486f, -0.07082573f, 0.02066155f, 0.03795495f, 
    0.02344951f, -0.01690268f, 0.05409636f, 0.02021946f, -0.07849192f, -0.01626726f, 0.06114994f, 0.04532294f, 
    -0.01377251f, 0.05347863f, -0.02210847f, -0.07041483f, -0.00889384f, 0.02287267f, 0.02981471f, 0.04166427f, 
    -0.08200675f, -0.03574378f, -0.06751408f, -0.02824784f, 0.05988325f, -0.05886859f, -0.00469381f, -0.03161473f, 
    -0.05713757f, -0.01278868f, -0.06365569f, 0.05762914f, 0.00419993f, -0.02195152f, -0.06153248f, -0.07352170f, 
    -0.06183427f, 0.01285638f, 0.02055802f, -0.00545623f, -0.00485887f, -0.00065022f, 0.01570559f, -0.02855610f, 
    0.01998104f, 0.04086622f, -0.06304842f, -0.01350227f, -0.00313836f, -0.00752562f, 0.05677513f, 0.03394048f, 
    -0.02147068f, 0.05011986f, -0.02471818f, -0.02325410f, -0.05845866f, 0.03236460f, -0.02657090f, 0.00623310f, 
    -0.06038738f, 0.05580147f, 0.05703549f, -0.03960503f, 0.00117061f, 0.01420033f, 0.06623206f, 0.02175742f, 
    0.03664748f, 0.01009990f, 0.05303402f, -0.06355196f, -0.00613005f, 0.02657007f, -0.07297229f, 0.02366626f, 
    -0.04337403f, -0.04316845f, -0.04150277f, -0.02722041f, 0.04342080f, 0.06002606f, 0.05093839f, -0.02633873f, 
    -0.00149161f, 0.03968263f, 0.00300771f, -0.03274145f, -0.03784414f, 0.03569455f, 0.03328262f, -0.04035692f, 
    -0.02616156f, -0.06922483f, -0.04330430f, 0.04930285f, -0.06705732f, -0.02817830f, -0.02683394f, -0.00687376f, 
    -0.05189323f, 0.06381451f, -0.02878391f, 0.03016079f, -0.06026417f, 0.03305120f, -0.04116393f, -0.00345957f, 
    0.01731010f, 0.04471816f, -0.04969974f, 0.05927654f, 0.02033591f, -0.02605421f, 0.00246475f, 0.03312120f, 
    -0.05546495f, -0.03155900f, -0.01870114f, -0.07392826f, 0.00399256f, -0.04347119f, -0.04523851f, -0.00821492f, 
    -0.04960405f, 0.02823890f, 0.00427074f, 0.01355388f, 0.06595063f, -0.03100335f, -0.04096280f, 0.06058406f, 
    -0.01862970f, -0.00111097f, 0.00041166f, -0.01129265f, -0.02505333f, 0.03696584f, -0.07696899f, 0.00715489f, 
    -0.02691429f, -0.06609947f, 0.06611486f, -0.06127391f, 0.03132799f, -0.01377721f, 0.04977955f, -0.05260130f, 
    -0.01380703f, -0.06947967f, -0.06361279f, -0.01993522f, -0.00562596f, 0.06015264f, -0.02119539f, -0.03290243f, 
    -0.05218067f, 0.06112408f, 0.02408228f, -0.06823143f, -0.06184199f, -0.06317814f, 0.06353151f, -0.00926927f, 
    0.00124604f, 0.02550980f, -0.06766344f, -0.00153227f, -0.03601916f, -0.01348676f, -0.03117983f, -0.04978500f, 
    -0.10869657f, 0.14167738f, -0.37706703f, 0.36477247f, 0.18908583f, -0.04062137f, 0.05199265f, 0.07268234f, 
    -0.18857229f, -0.06987719f, -0.05483869f, -0.04698399f, -0.17295350f, -0.00732570f, 0.23479076f, 0.17253366f, 
    -0.03235046f, 0.01298553f, -0.07472368f, 0.02334270f, 0.02015217f, -0.10714786f, 0.09290287f, 0.09338084f, 
    -0.26860288f, 0.27346727f, -0.09407651f, -0.15528412f, 0.04248779f, 0.02496153f, 0.05738097f, -0.10531344f, 
    0.12532358f, -0.13231145f, -0.14261562f, -0.19526848f, 0.15205170f, 0.00494153f, 0.08456696f, -0.22257921f, 
    0.00941392f, 0.03643167f, 0.02582164f, -0.03659028f, 0.13826649f, 0.02949070f, -0.01442711f, 0.07033095f, 
    0.37654382f, 0.32325342f, 0.23095533f, 0.67095149f, -0.01293677f, -0.17981505f, -0.04645388f, 0.06574911f, 
    -0.08657423f, 0.22103988f, -0.08809761f, -0.13842970f, -0.59379548f, 0.17124590f, 0.02639945f, -0.36865231f, 
    -0.14424737f, 0.02263471f, -0.03963282f, -0.03014220f, 0.10710135f, -0.07674581f, -0.01696968f, -0.00562127f, 
    0.14070554f, 0.32757255f, 0.10071619f, 0.37784046f, 0.05486277f, 0.04665235f, -0.02440040f, 0.13757220f, 
    0.02682266f, 0.06608052f, 0.00422875f, -0.02715856f, 0.21781589f, 0.10820216f, 0.36555323f, 0.17630756f, 
    0.21137725f, 0.27287403f, -0.00174109f, -0.02813901f, -0.14441526f, 0.11584476f, 0.14004503f, -0.01236994f, 
    0.30291808f, -0.08153664f, 0.21687610f, 0.29288003f, 0.01716152f, -0.12311032f, -0.04503535f, 0.01478879f, 
    0.03059647f, 0.07459795f, -0.03806502f, 0.10942211f, 0.48354355f, -0.23480484f, 0.17094372f, 0.63973880f, 
    0.13733397f, -0.00841179f, 0.01251736f, 0.12965702f, -0.11415617f, -0.05300315f, -0.10019650f, 0.06573335f, 
    0.34635159f, 0.04960213f, -0.14132521f, -0.33438280f, -0.09552523f, -0.06605726f, 0.10833695f, -0.23651493f, 
    0.09408049f, 0.02010293f, 0.08586715f, 0.00232833f, 0.21300834f, 0.13941208f, 0.06758700f, 0.14057404f, 
    0.21590713f, 0.07806017f, 0.00916390f, -0.27418920f, -0.07382280f, 0.31471825f, 0.08919428f, 0.00604786f, 
    -0.09213566f, 0.12963237f, 0.08120290f, 0.12224177f, -0.03886962f, -0.15256579f, -0.12828363f, 0.01216537f, 
    -0.05838723f, -0.08772247f, 0.02398216f, -0.09081092f, -0.44195193f, -0.37280849f, 0.03314882f, -0.22021714f, 
    -0.09342276f, -0.05301480f, 0.05584328f, 0.03039615f, 0.05921426f, -0.12510321f, -0.10047086f, -0.05001967f, 
    -0.14677379f, -0.00017929f, -0.52868348f, 0.04280822f, 0.04167368f, 0.11289159f, 0.12905115f, -0.05324841f, 
    -0.07872944f, -0.08722959f, 0.04471072f, 0.06014787f, 0.55334860f, -0.18069325f, 0.09534892f, -0.07619940f, 
    0.06606924f, -0.00700712f, 0.12137970f, -0.04876073f, 0.14343670f, 0.06354625f, -0.08305874f, -0.13307481f, 
    -0.07134129f, -0.05058047f, -0.01866928f, -0.05456544f, 0.01741520f, 0.06014550f, 0.06113714f, -0.02916070f, 
    0.00504119f, 0.01945981f, 0.00517330f, -0.04877221f, 0.05472376f, 0.00886610f, -0.06987786f, 0.04323430f, 
    0.00739636f, -0.04619583f, -0.00424901f, 0.00512235f, -0.02346415f, -0.02992692f, 0.02188438f, 0.01273891f, 
    -0.00806113f, 0.01100760f, 0.00779003f, -0.05392184f, 0.06090276f, -0.02459693f, -0.00366508f, -0.01567199f, 
    -0.02691518f, 0.02584433f, 0.03196319f, -0.06994380f, -0.02861774f, -0.02371775f, -0.04324330f, -0.05119035f, 
    -0.03697159f, -0.07850730f, 0.05492342f, 0.03348731f, -0.03087883f, 0.00936657f, -0.03438865f, -0.00353572f, 
    0.02858515f, -0.03214643f, 0.00368979f, -0.01283212f, -0.06803142f, -0.03226949f, -0.07100967f, -0.03836366f, 
    -0.02476555f, 0.02207187f, -0.03653127f, -0.00397168f, -0.05443621f, -0.03917834f, -0.05113307f, -0.01435073f, 
    -0.00785187f, -0.00994258f, 0.07012085f, 0.00483364f, 0.01679976f, -0.03898762f, 0.00594626f, -0.06861150f, 
    -0.02424982f, -0.00007747f, -0.03724964f, 0.02145301f, -0.07705837f, -0.02071114f, -0.00153322f, 0.02805150f, 
    0.05050198f, 0.00897630f, 0.04642505f, -0.03218451f, 0.04688152f, 0.03829261f, 0.03082930f, -0.04024488f, 
    0.04271692f, -0.02869635f, 0.00542499f, -0.06097780f, -0.08126538f, -0.06382109f, 0.00797763f, 0.05029850f, 
    -0.06866185f, -0.00146710f, -0.05197785f, -0.06536394f, 0.00487912f, 0.04595398f, -0.00007115f, -0.02060049f, 
    -0.04013913f, 0.02892610f, -0.00091718f, -0.03251017f, -0.07468238f, -0.05531809f, -0.04166747f, 0.02411347f, 
    -0.06741035f, -0.01550276f, 0.05710534f, -0.02389802f, 0.02508971f, -0.01684936f, 0.05629654f, -0.05444650f, 
    0.06828026f, -0.05286257f, 0.04957065f, -0.03366031f, -0.06951630f, -0.05066248f, -0.02516198f, -0.04725190f, 
    0.03975878f, -0.07041606f, -0.01798781f, -0.02283970f, 0.06143805f, -0.00191377f, -0.05884421f, 0.00864647f, 
    -0.00322900f, 0.06282933f, 0.03962909f, 0.04169471f, 0.02567376f, 0.06149158f, -0.03057773f, -0.04833447f, 
    -0.07430580f, 0.03715762f, 0.00271398f, 0.06664839f, -0.04891475f, 0.03501769f, -0.02962963f, -0.07291913f, 
    0.00763688f, -0.03014741f, 0.06094506f, -0.06818314f, -0.04453372f, -0.05126577f, 0.03472920f, -0.02674138f, 
    -0.02813191f, -0.00063698f, -0.05861850f, -0.00446811f, 0.01661542f, 0.03214968f, 0.01291652f, 0.03492097f, 
    -0.03979352f, -0.02670447f, -0.07588183f, -0.03839780f, -0.06037975f, -0.06814938f, 0.01382699f, -0.04050579f, 
    -0.01246065f, 0.05609980f, -0.04708643f, -0.05366277f, 0.01169648f, -0.07670360f, 0.04954099f, -0.01642072f, 
    -0.02167344f, 0.01035916f, -0.06396532f, -0.01895275f, 0.02640789f, -0.02360272f, 0.03572595f, -0.07424496f, 
    0.17725079f, 0.00314493f, 0.20227991f, -0.27760997f, 0.04029343f, -0.27337742f, -0.16804940f, 0.04313866f, 
    -0.02350578f, -0.14764801f, 0.05044516f, 0.13071923f, -0.80521965f, 0.18464763f, -0.13354863f, 0.23037775f, 
    0.08348146f, 0.11087033f, -0.04089552f, -0.05327939f, 0.13886662f, -0.00732911f, -0.09741806f, -0.08239977f, 
    0.68449783f, 0.48966184f, 0.03624377f, -0.27629146f, 0.21745197f, 0.14612533f, -0.07451390f, -0.02763985f, 
    0.10391420f, 0.01215569f, -0.08642828f, -0.17187163f, -0.02371501f, -0.02500344f, 0.29357299f, -0.17836767f, 
    -0.09818522f, 0.04422509f, 0.14801870f, -0.06179094f, -0.08265992f, -0.02482490f, 0.01164189f, 0.03924999f, 
    -0.37761456f, 0.35909331f, 0.41868955f, -0.05765055f, 0.04405901f, 0.08355082f, -0.06470314f, 0.02905925f, 
    0.04383383f, 0.09030873f, -0.08217596f, -0.07355693f, -0.10657395f, 0.29040653f, 0.20783712f, -0.13761434f, 
    -0.05607546f, -0.13969590f, -0.09111591f, -0.10548511f, -0.04922149f, 0.08153208f, 0.04749941f, -0.11426356f, 
    0.14111629f, 0.39495990f, -0.01321341f, 0.04028928f, 0.09306606f, 0.23100705f, 0.12824945f, 0.02178674f, 
    0.12623623f, 0.16533613f, -0.09681575f, 0.05505897f, 0.01480682f, -0.02823303f, 0.01903709f, 0.17912990f, 
    -0.04158442f, 0.05293948f, -0.08334325f, -0.17153606f, -0.14105450f, 0.05909245f, 0.03767955f, -0.08913539f, 
    -0.29314154f, 0.25383124f, 0.21261597f, -0.00502939f, -0.10969014f, -0.09464950f, 0.02494538f, 0.00168986f, 
    0.04899241f, 0.11922324f, 0.02123345f, 0.03534639f, -0.31130204f, -0.09004921f, 0.42755225f, 0.29375368f, 
    -0.07059883f, 0.08341230f, 0.14000155f, -0.07960775f, -0.11331916f, -0.03450545f, 0.03862092f, 0.01566731f, 
    -0.18450861f, 0.21120493f, -0.28461689f, 0.05716002f, 0.35968754f, 0.16151763f, -0.00854257f, 0.06560308f, 
    0.15262471f, 0.00502886f, 0.15666713f, 0.14963426f, 0.21652973f, 0.28185409f, -0.12830408f, 0.28856209f, 
    0.25277889f, 0.09969139f, -0.09439205f, 0.08764572f, -0.05937147f, -0.03997562f, 0.08338200f, -0.01230545f, 
    0.04445429f, 0.05828354f, 0.20878379f, -0.30138823f, 0.01740323f, 0.02648611f, 0.03536564f, -0.02131918f, 
    -0.08277389f, -0.02218549f, -0.01842259f, -0.03230083f, 0.25699180f, -0.20242812f, -0.06473751f, -0.01423954f, 
    -0.14421047f, 0.03051196f, -0.05767365f, -0.13595188f, -0.15590486f, 0.00164162f, -0.11501788f, 0.09809962f, 
    0.11382042f, 0.00926791f, -0.35057628f, 0.24906930f, -0.19099547f, -0.30417737f, -0.35696009f, -0.07105178f, 
    0.04408530f, -0.09001631f, 0.12284792f, 0.07954748f, -0.20154250f, 0.44430465f, -0.17978725f, -0.32062152f, 
    0.16466081f, 0.01755370f, -0.05927036f, 0.02834519f, 0.01081125f, -0.05247644f, -0.01720246f, 0.13030541f, 
    0.08162854f, 0.53856122f, -0.09954497f, -0.12191511f, 0.17121531f, -0.00824684f, -0.19347383f, 0.26646322f, 
    0.03568520f, 0.02683440f, 0.05853356f, 0.33934629f, -0.39013162f, -0.30689198f, 0.22522977f, 0.14594284f, 
    0.01533109f, -0.02339814f, 0.04138753f, -0.16775551f, -0.05327053f, 0.04044446f, -0.05911715f, -0.05653273f, 
    0.25407869f, 0.11586101f, -0.34597272f, 0.15026295f, -0.03857940f, 0.01794811f, 0.05527496f, -0.15483980f, 
    0.06462210f, -0.08633103f, -0.04871102f, -0.05146757f, 0.12849405f, 0.26485547f, -0.11396576f, -0.25301251f, 
    0.13768712f, -0.10063041f, -0.20145561f, -0.27347669f, 0.01747695f, -0.26674396f, 0.08104173f, -0.01915652f, 
    -0.10350490f, 0.12633091f, -0.18586034f, 0.61242342f, -0.18290722f, 0.08327820f, 0.10157879f, -0.01338935f, 
    0.02286701f, 0.14326870f, 0.00678896f, -0.09164243f, -0.05809364f, -0.09546517f, 0.25644499f, -0.10775289f, 
    -0.08602897f, 0.03888645f, -0.13209082f, 0.02506124f, -0.20937394f, -0.14406495f, -0.08691112f, -0.01118878f, 
    0.35488713f, -0.04239316f, 0.09412548f, 0.05758875f, 0.17008460f, 0.03775753f, 0.19601989f, -0.04110791f, 
    -0.18329999f, 0.13348542f, 0.12364559f, 0.07684775f, 0.46136478f, -0.14424551f, -0.03496767f, -0.07156355f, 
    0.18741564f, -0.08050340f, -0.00182542f, -0.14982703f, 0.10143277f, -0.13979417f, 0.06653310f, 0.00495613f, 
    0.19972228f, -0.01728195f, -0.26437297f, 0.17197004f, -0.13401078f, 0.00682717f, -0.12960885f, -0.15666507f, 
    0.08247884f, -0.04090508f, 0.05574179f, 0.21856938f, -0.29213172f, -0.36484408f, -0.00862639f, 0.13046491f, 
    -0.03512836f, 0.01833045f, 0.01613383f, -0.09291773f, 0.02289461f, -0.07475954f, -0.01623846f, -0.00846193f, 
    0.10018639f, 0.03085888f, 0.22511972f, -0.34152183f, 0.20007630f, -0.02199530f, 0.21634132f, 0.11845164f, 
    0.10606583f, 0.03368498f, -0.01099448f, -0.01684675f, -0.16181493f, 0.27751303f, 0.10737558f, 0.08540957f, 
    0.26093763f, 0.10829469f, -0.01046105f, -0.19953936f, -0.02465614f, 0.07752037f, 0.11810347f, -0.20454134f, 
    0.20606159f, -0.22280249f, -0.04916557f, 0.15364815f, -0.11061698f, -0.02304495f, -0.01519954f, -0.05964107f, 
    -0.16508752f, 0.03981316f, 0.19458567f, -0.04838753f, 0.57409978f, 0.32155132f, 0.26953954f, 0.07028186f, 
    -0.19754520f, -0.07397943f, -0.06193467f, 0.01048508f, -0.07307870f, -0.11614338f, 0.08363735f, -0.11818837f, 
    0.23801143f, 0.28915620f, 0.00290139f, -0.29053989f, 0.22081476f, -0.15070133f, -0.03937311f, -0.05581447f, 
    -0.08561603f, -0.03834654f, 0.04606501f, 0.13459438f, 0.56269073f, 0.00639810f, 0.20966868f, -0.11320952f, 
    0.03475836f, -0.01282483f, -0.01820192f, -0.09567720f, 0.11065506f, -0.03097641f, 0.05733938f, 0.02660820f, 
    -0.04058650f, -0.00554206f, -0.05242457f, -0.06063501f, 0.01752638f, 0.06311578f, 0.04132301f, -0.05334809f, 
    0.00338825f, -0.03871462f, 0.02570099f, -0.03486697f, -0.02173847f, 0.01434509f, -0.07152013f, -0.03964376f, 
    0.02971579f, -0.02633638f, -0.05084898f, 0.02060570f, 0.00636621f, -0.06402866f, 0.02688791f, -0.07064755f, 
    -0.02165374f, 0.01057370f, 0.03646358f, 0.02418847f, -0.03359227f, -0.06888490f, 0.02183728f, -0.07503357f, 
    -0.03783512f, -0.05529645f, 0.04446794f, 0.04528912f, -0.00786314f, -0.06900579f, 0.05612177f, -0.06967334f, 
    0.02400590f, -0.06146262f, 0.02267104f, -0.06734264f, -0.01256789f, 0.06025476f, -0.07515513f, -0.00466028f, 
    -0.01924729f, 0.05575164f, -0.07794384f, 0.02617249f, 0.01963812f, -0.02551188f, 0.04510936f, -0.01535729f, 
    0.00981469f, 0.00462403f, -0.03882346f, 0.01536672f, -0.01952766f, 0.03776174f, 0.02964276f, -0.06638831f, 
    -0.05475643f, -0.01711571f, 0.05409771f, -0.06672071f, -0.05588113f, 0.01424939f, -0.04300827f, -0.06620986f, 
    0.00829807f, 0.00601486f, -0.02168648f, 0.04884235f, -0.05266221f, -0.01355165f, 0.04526187f, -0.03007058f, 
    0.01100155f, 0.03508493f, 0.00192607f, -0.01775168f, -0.06487164f, -0.05282875f, 0.01618841f, 0.02178660f, 
    -0.01446492f, 0.06568448f, 0.01826932f, 0.06238403f, 0.04778181f, -0.05556552f, 0.02610923f, -0.02832881f, 
    0.01962286f, 0.00090497f, -0.02763143f, -0.05027130f, 0.05524506f, -0.01347929f, 0.01010078f, 0.00230944f, 
    0.00662974f, 0.06070068f, 0.01084357f, 0.01087959f, 0.00620243f, 0.02960813f, 0.00226410f, 0.05246244f, 
    0.03850170f, 0.03147562f, 0.01163309f, -0.04133936f, -0.07102223f, -0.03803635f, -0.00933925f, -0.05646560f, 
    0.05259256f, 0.05223981f, -0.01921393f, -0.02082693f, -0.02942835f, -0.06327734f, -0.03747804f, -0.05369913f, 
    -0.03461466f, -0.03804539f, 0.03070189f, 0.00055256f, 0.01653908f, -0.03623135f, -0.07640033f, -0.01338409f, 
    -0.04296901f, 0.02805600f, 0.06463227f, 0.06132265f, -0.03847572f, 0.01340446f, 0.05979802f, 0.01583486f, 
    -0.01608622f, -0.05047088f, -0.01412186f, -0.05884196f, 0.05468274f, 0.00372905f, 0.03569179f, -0.06042719f, 
    0.06558302f, -0.01472366f, -0.02247409f, 0.00918401f, -0.05033959f, -0.04461822f, 0.01494526f, 0.00099128f, 
    0.01087056f, 0.03605372f, 0.02559574f, -0.06402206f, -0.04779075f, -0.07297659f, 0.05665378f, -0.06820357f, 
    -0.07734745f, 0.04087448f, -0.06912326f, 0.00073534f, -0.00723956f, 0.03166173f, -0.00322579f, -0.02676296f, 
    -0.01973477f, -0.03134823f, -0.03499967f, -0.02215506f, -0.01162430f, 0.06579778f, -0.04934872f, 0.01229449f, 
    -0.03220240f, -0.02415317f, -0.03209994f, -0.01104888f, -0.03981973f, -0.05459161f, 0.05293595f, -0.06715893f, 
    0.03047082f, 0.05878498f, 0.05439215f, 0.04851871f, -0.07220718f, -0.01127376f, -0.07181221f, -0.04114753f, 
    -0.03759127f, 0.05220146f, -0.04717772f, 0.00540273f, 0.03947380f, 0.03765317f, -0.05957038f, -0.03979718f, 
    0.00219455f, 0.04540030f, 0.03486453f, -0.03363938f, 0.05870565f, -0.02813093f, -0.03996672f, -0.03200951f, 
    -0.05299949f, 0.02307015f, 0.00385767f, -0.05356210f, -0.05614080f, 0.05740306f, 0.01390184f, -0.04938159f, 
    -0.07537236f, 0.02196054f, -0.00178457f, -0.04140323f, -0.04699819f, -0.04906673f, 0.04408542f, -0.03111695f, 
    0.04917946f, -0.03645426f, 0.03000755f, 0.02992065f, -0.04545825f, 0.06200998f, -0.05812379f, -0.03625176f, 
    -0.01716804f, 0.02994160f, -0.07616021f, 0.01045137f, -0.05911265f, -0.05661806f, -0.05428861f, -0.04032293f, 
    0.01051556f, -0.03988282f, 0.00349408f, 0.01861945f, 0.01257955f, -0.05275031f, 0.01067469f, 0.01508208f, 
    -0.06535491f, 0.04627529f, -0.06583536f, -0.01532539f, 0.01777633f, -0.02914511f, -0.03194340f, -0.02070441f, 
    -0.07370169f, -0.05527923f, 0.03225672f, -0.03705695f, -0.03593471f, -0.07464377f, -0.02638230f, 0.02878379f, 
    -0.06327750f, -0.01101753f, 0.03914832f, -0.03770624f, 0.02671632f, 0.05548565f, 0.04832250f, -0.01521462f, 
    -0.05889026f, 0.06399770f, -0.02640750f, -0.06361973f, 0.02664909f, -0.04081934f, -0.01911001f, -0.06310375f, 
    -0.03794939f, -0.04540857f, 0.06493429f, -0.05560438f, -0.06857708f, -0.03103216f, 0.00727557f, -0.03896789f, 
    -0.00514459f, -0.01921057f, 0.06298293f, 0.04110744f, -0.04403205f, 0.00714407f, -0.03539086f, 0.01249410f, 
    -0.01105139f, -0.02642672f, -0.03840871f, -0.01785004f, -0.04064202f, -0.03606254f, 0.02710048f, 0.05017929f, 
    0.02583688f, 0.05200303f, -0.06490526f, -0.06807305f, -0.05523787f, -0.01623472f, 0.04637155f, 0.02692483f, 
    0.01523583f, -0.03607472f, 0.06045306f, 0.02590959f, -0.05093231f, -0.06291750f, 0.05186711f, 0.01264864f, 
    0.04944680f, -0.04121422f, 0.02879898f, 0.02571443f, -0.03438321f, -0.05263405f, -0.07398984f, -0.04367228f, 
    -0.00676194f, 0.06234494f, -0.06527009f, 0.04384468f, 0.05371588f, 0.05986667f, -0.01968683f, 0.05036243f, 
    0.01366646f, 0.06340398f, -0.06797897f, -0.00024524f, 0.03744276f, 0.02130107f, -0.04985643f, -0.07643620f, 
    -0.04431624f, -0.06272024f, 0.05462776f, -0.06599379f, 0.02792254f, -0.03102960f, 0.03523038f, -0.02521806f, 
    -0.03119494f, -0.03206414f, -0.05312912f, -0.04649332f, -0.06314445f, -0.05934442f, -0.01122879f, -0.00649755f, 
    -0.02150927f, -0.04042821f, 0.03123122f, 0.03715616f, -0.02641668f, -0.05101114f, -0.02266229f, 0.01609043f, 
    0.05028651f, 0.02324160f, -0.00295003f, -0.05197186f, 0.04419925f, 0.04054966f, 0.00170766f, 0.02774334f, 
    0.80360615f, 0.35926998f, 0.23316395f, 0.11267328f, -0.12255127f, -0.01142944f, -0.13298589f, 0.07823192f, 
    0.09271213f, -0.12122807f, 0.03380704f, 0.01228285f, -0.65564501f, 0.08447208f, -0.11609497f, -0.00700702f, 
    0.11227179f, -0.04271212f, 0.13222755f, 0.02073188f, 0.04601240f, 0.07584196f, 0.02498626f, 0.06554310f, 
    0.07423674f, -0.04608875f, -0.18493697f, -0.22044602f, 0.14884216f, 0.06541657f, -0.16118836f, -0.03223715f, 
    0.34334630f, 0.03833085f, -0.02319896f, 0.07589347f, 0.08132745f, -0.03786137f, -0.17035572f, 0.00530937f, 
    -0.16917688f, 0.22035217f, -0.14264089f, 0.04147639f, 0.07235647f, 0.24247676f, 0.04811898f, 0.41641086f, 
    -0.26793766f, 0.11310512f, -0.09350561f, 0.02403270f, -0.20911950f, 0.04073543f, 0.01903448f, 0.07678799f, 
    -0.15442172f, 0.02429659f, -0.14079380f, -0.00567262f, 0.02315802f, 0.11232755f, 0.43942824f, 0.44652301f, 
    0.02281759f, 0.10460077f, 0.08386364f, -0.04022496f, -0.03039200f, 0.26840037f, 0.06185691f, -0.08351982f, 
    -0.15672743f, -0.13257019f, -0.20375185f, 0.08956533f, -0.00939318f, 0.04930597f, -0.11693472f, 0.09026288f, 
    0.08647524f, -0.21679674f, -0.13467857f, -0.10920450f, -0.64370668f, -0.40054971f, -0.03031359f, -0.02566637f, 
    0.16016024f, 0.04354982f, -0.03557240f, -0.04999252f, -0.02115509f, -0.02576352f, 0.09097284f, 0.01255717f, 
    -0.07714187f, 0.10972344f, -0.03112990f, -0.12721345f, -0.05883342f, 0.01009977f, 0.10957477f, 0.16547635f, 
    -0.09504722f, 0.05931701f, 0.21483673f, 0.14286166f, 0.29213440f, -0.28003907f, 0.16239639f, 0.37313348f, 
    -0.08545469f, 0.05450371f, -0.00135128f, -0.10465135f, -0.08780689f, 0.09036788f, -0.11310761f, 0.16049050f, 
    -0.13316537f, 0.08536298f, -0.11582535f, -0.01964392f, 0.12394369f, 0.20679227f, 0.04659447f, 0.10408661f, 
    0.01935434f, -0.06751098f, 0.08348967f, 0.11366516f, -0.23550190f, 0.00465411f, 0.10244451f, 0.00395426f, 
    -0.00745064f, -0.01826230f, -0.06250761f, -0.01116536f, 0.17127270f, -0.01432908f, 0.04789311f, -0.06946427f, 
    -0.38941732f, -0.13361704f, 0.09351546f, -0.15409200f, -0.10691813f, 0.19347346f, 0.02530390f, -0.04537504f, 
    -0.04021930f, 0.01344601f, 0.10132720f, 0.01113110f, 0.94387257f, 0.17598309f, 0.12669432f, 0.37005547f, 
    -0.05202024f, 0.02811745f, 0.15897755f, 0.08930755f, -0.08263447f, 0.00282920f, -0.03474968f, 0.02681562f, 
    0.71823674f, 0.15233560f, -0.08086332f, 0.43578678f, -0.03943260f, -0.07102486f, 0.07237906f, 0.16458780f, 
    0.13520873f, -0.05443551f, 0.07593812f, -0.00379238f, -0.43243146f, 0.29593644f, -0.01119303f, -0.19844243f, 
    0.22781390f, 0.09507384f, 0.12513500f, -0.01624977f, 0.11372652f, -0.07212445f, 0.05579359f, -0.04075095f, 
    0.05158615f, 0.02876696f, -0.01313843f, 0.02583447f, 0.03966562f, -0.03577328f, 0.04762893f, 0.00501392f, 
    -0.06851099f, -0.02973823f, 0.03459897f, -0.03231779f, -0.05463964f, -0.03511271f, -0.02694376f, 0.00917647f, 
    0.04279274f, 0.05133856f, 0.04990022f, -0.01059354f, -0.05026174f, 0.04455649f, -0.00928971f, -0.07182804f, 
    -0.04474679f, 0.01068562f, -0.03742613f, 0.06602490f, -0.03620824f, 0.00021569f, -0.07699344f, -0.01963154f, 
    -0.04055500f, -0.01149295f, -0.04320690f, -0.06986567f, -0.03049023f, 0.05544051f, -0.01282291f, 0.05135183f, 
    -0.07728360f, 0.00885245f, -0.02914459f, -0.00252973f, -0.01040978f, -0.00181981f, -0.02053671f, 0.02516878f, 
    -0.06713816f, -0.00214617f, 0.01425968f, -0.07499749f, -0.04148535f, 0.03808033f, -0.02601906f, 0.05927799f, 
    -0.01052269f, -0.04655934f, -0.03531823f, 0.02587432f, 0.06358358f, -0.03996776f, -0.04512157f, -0.05053727f, 
    -0.03691179f, -0.05234849f, 0.00553900f, -0.02284033f, 0.05153666f, 0.05718899f, -0.03168784f, 0.06036006f, 
    0.04997629f, -0.03126007f, -0.05947180f, 0.01733906f, 0.06574766f, 0.02286539f, -0.06348733f, 0.03419417f, 
    -0.01069341f, -0.06110013f, -0.06307341f, 0.02680295f, -0.07445702f, 0.03166503f, -0.05702040f, 0.05523500f, 
    0.00805202f, 0.05499635f, -0.07405729f, -0.02712182f, 0.00285649f, 0.02378089f, -0.04423950f, 0.03949411f, 
    0.04028662f, 0.05669802f, 0.06125764f, 0.01075507f, 0.03266142f, -0.01293947f, -0.02203899f, 0.04473373f, 
    0.00473138f, 0.03143099f, -0.02434485f, -0.04101632f, 0.00994507f, -0.00271560f, -0.02207691f, 0.04768071f, 
    0.03865522f, 0.02164580f, -0.02576390f, 0.01905464f, -0.06181272f, -0.02876838f, -0.06239585f, -0.05398206f, 
    -0.01361139f, 0.06262009f, -0.03605197f, 0.05278385f, 0.03499402f, 0.02258875f, -0.07066701f, 0.07262547f, 
    -0.02716843f, 0.06184016f, 0.00500186f, -0.00273466f, 0.02281784f, -0.05072106f, -0.00187049f, 0.00444013f, 
    -0.04668059f, -0.06715976f, -0.05747478f, 0.05220999f, -0.03197204f, -0.03192304f, -0.04454346f, -0.01498404f, 
    -0.06472387f, -0.03308147f, -0.03118985f, -0.04914500f, -0.07775383f, -0.03083435f, 0.02304392f, -0.02251132f, 
    -0.04032180f, -0.05064526f, 0.05167150f, -0.01132354f, -0.06479220f, 0.05195500f, 0.04769736f, 0.05447256f, 
    0.05175769f, -0.04657407f, -0.03551665f, 0.05220669f, 0.04094532f, 0.01310662f, -0.01549180f, 0.02575945f, 
    0.04531533f, -0.02815532f, -0.04056456f, -0.04691400f, -0.00952504f, -0.07383508f, -0.01622152f, 0.01659868f, 
    0.04262030f, -0.05053567f, 0.01678293f, -0.03979423f, -0.06295653f, -0.02625553f, -0.01647019f, -0.00087592f, 
    -0.05005533f, -0.06335489f, -0.01729986f, 0.00403953f, -0.07481969f, -0.01496477f, -0.01271007f, -0.01563637f, 
    -0.02728688f, -0.06366710f, -0.07110927f, -0.07697799f, -0.04533454f, -0.07049189f, -0.01091808f, -0.04637325f, 
    0.02731003f, 0.00215173f, 0.01360319f, -0.02970644f, -0.07416540f, -0.01814757f, 0.02293051f, -0.05816744f, 
    -0.00136643f, -0.02886795f, -0.02217348f, -0.02790481f, -0.07088900f, 0.03101112f, -0.07835221f, -0.02232138f, 
    0.05704461f, -0.03146950f, -0.07260472f, -0.07557309f, -0.07482722f, -0.01881400f, 0.00994838f, -0.08076052f, 
    -0.00111961f, 0.04500115f, 0.02055005f, -0.05498644f, 0.01115325f, -0.05341098f, 0.01163451f, -0.03596510f, 
    0.03810197f, -0.05267283f, 0.05550493f, 0.04180216f, -0.00420607f, 0.00423388f, -0.03250226f, -0.03338378f, 
    0.02345226f, 0.04201923f, -0.01159978f, -0.02897818f, 0.02290925f, -0.06994071f, 0.04014999f, 0.02220822f, 
    0.01085203f, 0.04604675f, -0.07668501f, 0.02384552f, -0.07431383f, -0.02844274f, 0.03230796f, 0.01717266f, 
    -0.07405374f, -0.00568792f, 0.03867164f, 0.02410322f, -0.07951361f, -0.03342068f, 0.01461693f, 0.06074985f, 
    0.04402819f, 0.02433978f, 0.02270506f, -0.02181565f, -0.02471895f, -0.05057088f, 0.05234021f, 0.05313740f, 
    0.05622498f, -0.07314877f, -0.03699224f, -0.00933905f, -0.05941250f, -0.05348523f, -0.03788840f, -0.04525280f, 
    0.01532512f, 0.02170347f, -0.00896254f, -0.06954478f, -0.00131521f, -0.04578325f, -0.02520449f, -0.06040996f, 
    0.01748603f, 0.03062175f, -0.02688003f, -0.02598788f, -0.05026393f, 0.00639126f, -0.03818672f, 0.02674550f, 
    0.01331920f, 0.02222707f, -0.01985418f, -0.01497259f, -0.07456618f, -0.00101062f, 0.00482089f, 0.00047287f, 
    0.00600829f, -0.02592533f, 0.04065375f, 0.05856314f, -0.03332938f, 0.03889559f, 0.01078285f, 0.03504498f, 
    -0.07047470f, 0.00531382f, -0.05817114f, -0.04347919f, -0.02768945f, -0.02508918f, 0.04235775f, 0.06227354f, 
    0.03988581f, 0.04635750f, 0.00814303f, -0.00455050f, -0.02419447f, 0.02333436f, 0.03215863f, -0.05546833f, 
    -0.01258932f, -0.03436437f, -0.07314137f, 0.04580101f, -0.03693110f, -0.06636946f, -0.00520465f, -0.04441570f, 
    0.00592297f, 0.01448043f, 0.02634481f, -0.06100977f, -0.06322148f, -0.04302547f, 0.00711079f, -0.07904892f, 
    -0.07711149f, -0.03826128f, -0.02436911f, 0.05658140f, 0.02709717f, -0.04706610f, -0.01193510f, 0.03668829f, 
    0.04506824f, -0.00345068f, -0.00937715f, 0.02388476f, 0.03410102f, -0.03905578f, -0.00382457f, 0.06404430f, 
    0.00230907f, -0.07439715f, -0.07802531f, -0.06352415f, 0.02657292f, -0.01874691f, 0.04043872f, 0.04991321f, 
    -0.03838073f, -0.06957891f, 0.00976910f, -0.05486051f, 0.04757548f, -0.00255161f, 0.03822489f, -0.06851035f, 
    -0.06379540f, 0.00160933f, 0.03625936f, 0.05966185f, 0.03386633f, -0.03205413f, -0.01804554f, -0.05523206f, 
    0.16627598f, -0.13851178f, 0.12723750f, -0.09436382f, -0.21825349f, 0.01720318f, 0.11996099f, -0.35563841f, 
    0.02142922f, -0.18274815f, 0.02224064f, -0.23090504f, 0.45580772f, -0.07048029f, 0.06972499f, 0.06887170f, 
    -0.00851004f, 0.18209881f, -0.01758442f, 0.16067959f, -0.01480734f, 0.15070841f, 0.06828243f, 0.03092432f, 
    0.50787604f, 0.09506661f, -0.00259893f, -0.13523173f, -0.03444470f, 0.13744642f, 0.18684635f, 0.17070803f, 
    -0.02683555f, 0.06429213f, 0.05063176f, 0.18158132f, -0.31798545f, -0.32328415f, 0.14448062f, -0.06381621f, 
    0.03878440f, -0.14704029f, 0.08431034f, 0.05750038f, -0.27467427f, 0.19083539f, 0.06016111f, -0.20830052f, 
    -0.18140456f, 0.03804784f, 0.11168341f, -0.15158463f, 0.09653027f, -0.25676933f, -0.23813994f, -0.20101698f, 
    0.03811644f, 0.07690826f, 0.05588983f, 0.23118238f, 0.20226444f, -0.22060895f, 0.11342323f, 0.04838576f, 
    0.05842278f, -0.00668689f, 0.30268618f, 0.07541472f, -0.03602423f, -0.04108132f, 0.38767654f, 0.24927455f, 
    0.25708979f, -0.17670205f, 0.20925303f, -0.24789563f, -0.04506861f, 0.31924963f, -0.21169946f, 0.08528145f, 
    -0.06864770f, -0.08576325f, 0.01436322f, 0.07886215f, 0.33301327f, -0.03605563f, 0.01557333f, 0.30748069f, 
    -0.09862720f, 0.05137289f, 0.08760711f, -0.12624413f, 0.04750993f, 0.02332132f, -0.01545825f, -0.22667019f, 
    -0.49504304f, 0.12364542f, 0.23062646f, -0.08400392f, 0.19677413f, -0.00434709f, -0.01347347f, 0.11710738f, 
    0.16645917f, -0.31353140f, -0.31370220f, -0.10235951f, 0.35834125f, 0.19369066f, 0.18391687f, -0.28192908f, 
    -0.05492336f, -0.02645813f, -0.13540755f, 0.11106835f, 0.03509526f, 0.06638642f, -0.18245870f, 0.11100195f, 
    -0.00750893f, 0.02959894f, -0.01245790f, -0.29258779f, -0.07044981f, -0.05836106f, -0.06353574f, -0.02530372f, 
    0.16393295f, -0.00047419f, -0.30322888f, -0.08324020f, 0.07723869f, -0.21436396f, -0.23691177f, 0.19592175f, 
    -0.17854954f, -0.22210731f, 0.10971205f, 0.00230603f, -0.03708126f, -0.16359822f, 0.03346439f, 0.14314565f, 
    0.86102927f, -0.03058625f, 0.15887162f, -0.30778232f, 0.06716928f, -0.03863823f, 0.13745651f, 0.23804909f, 
    -0.01770039f, 0.08274571f, -0.07751632f, 0.07447648f, -0.12050675f, 0.00863975f, -0.06851789f, 0.00891329f, 
    -0.17428620f, -0.19379115f, -0.15918681f, -0.24392712f, 0.09064562f, 0.03427085f, -0.21106108f, 0.14014977f, 
    -0.23697302f, -0.01608499f, 0.05391604f, 0.25794142f, -0.23934405f, 0.09868716f, -0.01488027f, 0.05158482f, 
    -0.05582909f, 0.21353753f, 0.02464931f, 0.05369931f, -0.20489725f, 0.09161583f, -0.11660398f, -0.05936804f, 
    0.15543027f, 0.06057284f, 0.08600374f, 0.00783074f, 0.09911405f, 0.16230066f, 0.07498614f, 0.24963315f, 
    0.09067471f, 0.23521560f, 0.02622542f, -0.15430389f, 0.01267477f, 0.13312092f, 0.12072730f, 0.02344724f, 
    -0.30991086f, -0.09520341f, -0.04495495f, -0.20054543f, 0.92598116f, 0.02614010f, 0.27643046f, 0.36043629f, 
    0.29710165f, 0.02162755f, 0.14583318f, 0.17835613f, 0.03426868f, 0.02358739f, 0.14757015f, -0.10849294f, 
    0.14956571f, -0.35939428f, 0.06984011f, -0.16016333f, -0.11564666f, 0.10878068f, -0.05407377f, -0.03141785f, 
    -0.11227497f, 0.03971852f, 0.02598984f, 0.05649193f, 0.06527076f, -0.13732137f, -0.18723553f, -0.07337711f, 
    0.20422323f, -0.08066982f, 0.09998260f, 0.01324754f, -0.15860777f, -0.02830110f, 0.09579006f, -0.24882863f, 
    0.00546158f, -0.16746138f, 0.14202957f, 0.15251015f, 0.06865655f, -0.08707070f, -0.03612979f, -0.01248907f, 
    -0.08314627f, 0.13558105f, 0.17853124f, 0.16873777f, -0.22551346f, -0.22381310f, 0.00142892f, -0.17132576f, 
    0.06676406f, -0.00548288f, 0.14929242f, -0.00708245f, 0.04859183f, -0.31164166f, 0.01368192f, 0.25950873f, 
    -0.06212100f, 0.01327991f, 0.16592444f, -0.09929796f, 0.07904705f, 0.18837471f, 0.06579463f, 0.02522169f, 
    -0.17643064f, 0.07203821f, 0.22648469f, 0.21705905f, 0.39820293f, 0.53027809f, -0.04556755f, 0.14068562f, 
    0.07453373f, -0.01436673f, 0.10317914f, 0.00146443f, 0.12415063f, 0.07515828f, 0.06197004f, 0.05926829f, 
    -0.15396123f, -0.45162567f, 0.15386607f, 0.18269959f, 0.08432297f, 0.21888939f, -0.09836414f, 0.00541201f, 
    0.05885611f, -0.22461076f, -0.24348335f, -0.06174071f, -0.14401796f, 0.21198986f, -0.09564418f, -0.34184298f, 
    0.03541972f, 0.08566485f, 0.17791240f, 0.08103373f, 0.06212468f, -0.02652043f, -0.06403818f, -0.08129273f, 
    -0.13150139f, -0.01604927f, -0.06726912f, -0.31694695f, -0.11589190f, -0.17499603f, 0.06328660f, -0.19886976f, 
    -0.06165824f, 0.00837812f, -0.08542900f, 0.03240063f, -0.05596440f, 0.01878694f, -0.16202512f, -0.07988044f, 
    -0.02657482f, -0.07640411f, 0.20906280f, 0.04681715f, -0.12368996f, -0.04465916f, 0.32719630f, 0.10412732f, 
    0.64751840f, -0.06614759f, 0.13375141f, 0.41129267f, -0.15019722f, 0.02551828f, 0.08491332f, 0.05782468f, 
    0.15463327f, 0.01680882f, 0.00740551f, 0.19527939f, -0.44379327f, 0.04436342f, -0.17125772f, -0.17902893f, 
    -0.05199270f, -0.10829756f, 0.05021333f, 0.02803358f, 0.20186134f, 0.05089086f, -0.00622733f, 0.07984097f, 
    -0.06266540f, 0.12585250f, 0.20858236f, -0.41501290f, -0.15912063f, 0.07846125f, 0.01118240f, -0.02041097f, 
    -0.04323021f, 0.12269729f, -0.05184872f, -0.05090578f, -0.08929287f, -0.08178717f, 0.13795780f, 0.22982122f, 
    0.02993713f, 0.03795644f, -0.16448350f, 0.04295821f, 0.00413230f, 0.25003126f, 0.00893127f, 0.15897392f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02244499f, -0.05941733f, 0.08022844f, -0.08490551f, -0.05832732f, -0.00906339f, 0.06794849f, 0.13440421f, 
    0.02517184f, 0.06390106f, 0.01310808f, -0.02040726f, -0.03908781f, 0.09716564f, 0.25616300f, 0.11653725f, 
    0.25193802f, 0.01681833f, -0.03717416f, 0.02185170f, 0.03171943f, 0.03312378f, -0.02788573f, 0.01223249f, 
    0.00223684f, 0.01703846f, 0.06208596f, -0.07112672f, -0.02482929f, -0.03847278f, -0.08150877f, -0.04046368f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.14231057f, 0.15128353f, 0.12371629f, -0.18181820f, -0.02264580f, 0.01587071f, -0.07607894f, 0.15695737f, 
    -0.45561144f, -0.37087303f, 0.17165320f, 0.16794074f, 0.21250424f, 0.21174467f, -0.29473692f, -0.77055532f, 
    0.18451393f, -0.66173208f, 0.09916288f, -0.07360534f, 0.12133060f, -0.36543968f, -0.00147008f, 0.77870864f, 
    0.17647207f, 0.01034336f, 0.00563564f, 0.22657159f, -0.03501899f, -0.06098099f, 0.48843980f, 0.12985541f, 
    0.16198578f, -0.03081496f, -0.09421673f, -0.63710660f, -0.02861076f, -0.09007359f, -0.01524555f, 0.08364097f, 
    -0.18220176f, 0.14084066f, -0.02088833f, -0.17127864f, 0.20795533f, 0.09791615f, 0.27883306f, 0.65077269f, 
    0.06884779f, -0.50958741f, 0.07319748f, 0.29143283f, 0.10151179f, -0.14917150f, -0.00359801f, -0.07234845f, 
    0.10131238f, -0.11058307f, -0.06975551f, 0.34954888f, 0.02529759f, -0.18473674f, -0.59690291f, -0.57090175f, 
    0.14851883f, 0.14107513f, -0.61180580f, 0.25863868f, 0.13922936f, 0.01935256f, -0.58396447f, 0.16850993f, 
    -0.45658040f, 0.55378592f, -0.10066696f, 0.15007433f, 0.37021083f, 0.28862804f, -0.78391582f, -0.00618181f, 
    -0.11592257f, -0.36807096f, 0.14051206f, 0.33557335f, 0.10966519f, -0.21941330f, -0.03808558f, -0.01002659f, 
    -0.02257676f, 0.10184918f, -0.11473092f, -0.19883479f, -0.05534019f, 0.09546564f, 0.34689498f, -0.11608613f, 
    -0.05758924f, 0.16899668f, 0.33801311f, 0.09805801f, 0.08358099f, -0.00390054f, -0.17821333f, -0.29080534f, 
    -0.17145766f, -0.76003635f, -0.04281491f, -0.00891698f, 0.00842734f, -0.75744277f, 0.26553574f, 0.22903499f, 
    0.19336271f, 0.05273003f, 0.14240046f, 0.56928647f, 0.03655340f, 0.47737151f, -0.11717589f, -0.22648740f, 
    -0.58832991f, -0.12963411f, -0.16981620f, -0.16237047f, 0.02816033f, 0.14385208f, 0.30925113f, -0.10117041f, 
    -1.00051224f, -0.15129136f, 0.38860017f, 0.11004642f, -0.08486844f, 0.12263488f, 0.47794387f, 0.08807109f, 
    0.35261771f, 0.17484491f, -0.01542198f, 0.03431068f, 0.15978420f, -0.57474381f, -0.14627936f, -0.19140807f, 
    -0.29375944f, 0.07362751f, 0.13391148f, -0.04953929f, 0.07793295f, -0.50404572f, -0.01273607f, -0.03055912f, 
    -0.68877316f, 0.15248951f, 0.04396771f, 0.02220544f, -0.09524358f, 0.07210980f, 0.13893777f, -0.18392566f, 
    -0.39295271f, 0.07231589f, 0.20964147f, -0.06930066f, 0.09533868f, 0.10819916f, 0.22074276f, 0.18887736f, 
    -0.32062668f, -0.14796500f, -0.13044496f, -0.11946505f, -0.61433136f, 0.45797038f, 0.41624653f, -0.36335433f, 
    -0.51504093f, -0.06948350f, -0.04948477f, -0.57879728f, -0.02897897f, 0.10934805f, -0.05359929f, 0.30137715f, 
    0.07010904f, -0.05841362f, -0.10161791f, 0.34251043f, -0.02103867f, -0.12632997f, -0.48806939f, -0.16971399f, 
    -0.13714439f, -0.11805493f, 0.01521025f, -0.40463930f, -0.06281945f, 0.06630077f, -0.14303523f, 0.25810173f, 
    -0.08423398f, 0.12671745f, -0.10887339f, 0.12698397f, -0.40610266f, -0.22942348f, -0.54660410f, 0.39755851f, 
    -0.06332521f, 0.42258629f, -0.18057695f, -0.62600172f, -0.15064137f, 0.01559954f, -0.07132005f, -1.05839670f, 
    0.47889462f, -0.06339472f, -0.08753277f, -0.02254684f, 0.02442272f, 0.09282140f, 0.36522210f, 0.30204484f, 
    -0.24855952f, 0.17889160f, 0.13580550f, 0.34090048f, -0.09190748f, 0.16410045f, -0.27811486f, -0.35809970f, 
    0.44951856f, -0.11926374f, 0.14415923f, -0.02690068f, 0.28689066f, -0.39368874f, -0.39845997f, 0.04827894f, 
    -0.94212556f, -0.01933219f, -0.00584512f, -0.22528796f, -0.06040296f, 0.34854802f, -0.10762545f, 0.24513339f, 
    0.29706591f, 0.02420668f, 0.08338406f, -0.45113131f, -0.02708611f, 0.12069155f, -0.26019594f, 0.02180502f, 
    0.37916526f, -0.03068040f, 0.18922475f, 0.11055825f, -0.14958225f, -0.04543607f, -0.52418864f, -0.23752204f, 
    -0.44567427f, 0.16991369f, 0.04740447f, -0.08906011f, 0.30983722f, 0.06604230f, 0.12399137f, -0.42508993f, 
    -0.36834973f, 0.42442715f, 0.01307510f, 0.35729751f, 0.16827673f, -0.49562162f, -0.13899300f, -0.44439742f, 
    0.24610910f, 0.09981064f, 0.08259968f, 0.14953844f, 0.14087330f, -0.13953991f, -0.41940260f, -0.67408901f, 
    0.59355164f, -0.15120003f, -0.46022084f, 0.22453050f, -0.14543745f, -0.02866844f, 0.07115830f, 0.41579762f, 
    0.44909683f, -0.11327422f, -0.00614908f, -0.11904394f, -0.13543062f, 0.11128370f, 0.07104883f, -0.23920189f, 
    -0.09160091f, -0.31025442f, 0.10439787f, -0.57276499f, -0.06454852f, -0.47324082f, -0.14900075f, -1.02790046f, 
    -0.63171959f, 0.15797931f, -0.12575759f, -0.21397355f, -0.05008931f, 0.12276978f, 0.14263700f, 0.62315714f, 
    -0.26282400f, 0.11147849f, 0.07319994f, -0.02700292f, -0.14830282f, -0.00433448f, -0.76168942f, 0.02127088f, 
    0.10178932f, 0.38091081f, 0.10990842f, 0.00746616f, -0.08570101f, -0.08105624f, 0.57937992f, 0.22331539f, 
    0.49236473f, -0.16250998f, -0.05392712f, 0.09136283f, 0.08152774f, 0.11692391f, -0.05539024f, 0.03388299f, 
    0.20831777f, -0.10951159f, 0.12255630f, -0.85818321f, 0.03240604f, -0.12305163f, -0.82041204f, 0.07864034f, 
    0.00855633f, -0.13295229f, -0.44718117f, 0.28036368f, -0.12380581f, -0.16778807f, 0.37194788f, -0.78085560f, 
    -0.16862915f, -0.27095765f, 0.02635988f, 0.08238218f, -0.33246714f, 0.16375569f, -0.21976516f, 0.38192639f, 
    0.41112289f, 0.33566555f, -0.13816735f, -0.46802649f, 0.09037239f, 0.06861449f, 0.03952026f, -0.18028103f, 
    0.29378563f, -0.08727098f, -0.13368486f, 0.13841110f, 0.02105681f, 0.09798671f, -0.46172068f, 0.01383006f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.04396751f, -0.03778734f, -0.17947578f, 0.10765766f, 0.01433126f, 0.09183234f, -0.06772179f, -0.18656670f, 
    -0.19054298f, 0.02223877f, 0.14991760f, 0.02883181f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
